#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.31395301f, 0.73630381f, -0.47509906f, 0.59252053f, -0.30870569f, 0.05641031f, 0.51271117f, -0.41306466f, 
    0.29916903f, -0.05122981f, 0.26552951f, -0.07883734f, -0.02754556f, -0.12378764f, -0.17864910f, -0.04219807f, 
    -0.03253991f, 0.11578616f, 0.11852068f, -0.27451751f, 0.10928360f, -0.25658509f, -0.32767618f, -0.06921154f, 
    0.08537862f, 0.77397692f, 0.33061513f, 0.12369841f, 0.82062358f, 0.57982296f, 0.55175900f, 0.41476616f, 
    -0.11644839f, 0.50808823f, 0.21234313f, -0.45227185f, 0.06342801f, -0.08430640f, 0.08290160f, -0.30953902f, 
    -0.08201914f, -0.08204129f, -0.03915247f, -0.05895500f, -0.16903020f, -0.18129031f, 0.00695083f, -0.01040495f, 
    0.02393030f, 0.13881831f, -0.61988598f, -0.18900494f, 0.34576118f, -0.34221143f, -0.39248842f, 0.10120023f, 
    -0.35749200f, -0.04020445f, -0.21848173f, -0.61832714f, 0.14194599f, -0.05224261f, -0.09040828f, 0.30729795f, 
    0.03635313f, 0.22351687f, -0.04777337f, -0.12178443f, 0.00978751f, -0.04480946f, 0.04135164f, 0.29093409f, 
    0.32268566f, 0.13518140f, 0.21087408f, -0.88367319f, -0.23647133f, -0.29969013f, -0.24663386f, 0.25368610f, 
    -0.02590799f, 0.51629531f, -0.22497000f, 0.05331643f, 0.29076961f, -0.19411707f, 0.11188267f, 0.37501538f, 
    0.08525804f, 0.29596332f, 0.07197321f, 0.16689461f, 0.32310763f, 0.39338312f, 0.05080104f, 0.18152478f, 
    -0.14754950f, 0.08335108f, -0.17684402f, -0.18166345f, 0.51098305f, 0.11166636f, 0.67086577f, -0.02800174f, 
    0.11512166f, 0.19124793f, -0.47100011f, 0.14427374f, -0.24558088f, -0.32632816f, 0.13720542f, -0.08718850f, 
    -0.12376606f, 0.00373095f, 0.17750134f, 0.03337648f, 0.02538293f, 0.26486862f, 0.00854190f, 0.04043680f, 
    0.12235068f, 0.30721679f, -0.10596063f, 0.22227600f, 0.50519252f, 0.43851471f, 0.57559335f, 0.53319412f, 
    0.22539847f, -0.29352671f, -0.39508057f, -0.76076603f, 0.14679843f, 0.35298085f, 0.24629119f, -0.27916291f, 
    0.04687296f, 0.11909441f, 0.14978005f, -0.24701931f, 0.02322239f, 0.26977101f, 0.27289656f, 0.05418373f, 
    -0.17441587f, -0.10609252f, -0.21758999f, 0.14365391f, -0.25781763f, 0.04271479f, 0.79612321f, 0.67496258f, 
    -0.35119000f, -0.77621555f, -0.53073692f, 0.11715312f, 0.17122887f, -0.04053377f, -0.33196262f, 0.09019589f, 
    0.29431307f, 0.37342578f, 0.04026426f, 0.04694173f, -0.16857432f, 0.04282016f, -0.04075455f, 0.01434889f, 
    0.13466364f, -0.10611461f, 0.07271798f, 0.07750164f, 0.18957527f, 0.00389334f, 0.13454327f, -0.55345720f, 
    -0.56807053f, -0.47807744f, -0.26733965f, -0.27880207f, -0.29477689f, -0.12977399f, 0.02098740f, -0.11774164f, 
    0.38700685f, 0.29877001f, 0.24738164f, 0.03989237f, 0.08669269f, -0.10634355f, -0.06680433f, 0.17979936f, 
    0.36746344f, 0.10041137f, -0.15012325f, -0.01871727f, -0.09552465f, 0.04192132f, -0.06016284f, 0.06652226f, 
    -0.93824273f, 0.15952572f, 0.01612879f, -0.17936105f, -0.25073326f, 0.71057355f, 0.59204519f, 0.12643629f, 
    0.49795982f, 0.52619946f, 0.22534782f, -0.42554247f, 0.10653663f, -0.22556593f, 0.21431278f, -0.02337591f, 
    -0.19231918f, -0.19662622f, -0.12978059f, 0.00798374f, -0.13558802f, -0.04963288f, 0.05774398f, 0.06802977f, 
    -0.10114793f, 0.27832410f, -0.04545956f, -0.76504713f, -0.34934893f, -0.18768412f, 0.23509927f, -0.37785798f, 
    0.16846359f, -0.00289479f, -0.43293768f, -0.48716369f, -0.15259345f, 0.28835508f, 0.15730210f, -0.45985082f, 
    -0.06273625f, -0.16756199f, 0.05726567f, -0.01695078f, -0.12678631f, -0.11278895f, -0.11489896f, -0.11825188f, 
    -0.07949975f, 0.05711551f, -0.55649877f, 0.81218147f, 0.04610523f, -0.26389858f, -0.09836283f, 0.45512566f, 
    -0.25456727f, -0.67224789f, -0.27446011f, -0.26699153f, 0.02602722f, -0.06803823f, 0.16122304f, 0.15867592f, 
    -0.20887223f, -0.27340072f, -0.03711868f, 0.07983167f, -0.02721553f, -0.05122061f, -0.13811278f, -0.02675327f, 
    -0.03581765f, -0.16105662f, 0.06688652f, 1.06502724f, -0.01866035f, 0.22914848f, 0.60757929f, 0.80202150f, 
    -0.04726886f, -0.11277968f, 0.02880668f, 0.00299816f, -0.38134068f, -0.00449411f, 0.13352130f, -0.23036247f, 
    0.05288765f, -0.06755773f, 0.15247308f, 0.12478933f, 0.02500471f, 0.22672234f, -0.07705274f, 0.17643356f, 
    0.32209721f, -0.02040807f, 0.01999322f, 0.06170940f, 0.45393491f, 0.47314987f, -0.16486706f, -0.12265017f, 
    0.32897288f, -0.31617677f, -0.51868141f, 0.08690210f, -0.20623165f, 0.50605506f, -0.33328977f, -0.04013688f, 
    -0.06316938f, -0.27884057f, -0.04088302f, -0.14617179f, -0.21296749f, -0.18072826f, -0.41012451f, -0.08637290f, 
    0.40809214f, 0.02659616f, 0.21731988f, 0.02022416f, -0.07880534f, -0.10923024f, 0.36605269f, 0.80052942f, 
    0.50563985f, -0.19391222f, -0.28633362f, -0.00641595f, -0.31083164f, -0.34304968f, -0.17334968f, -0.07902225f, 
    -0.01592860f, -0.06477102f, 0.33116633f, 0.29396772f, 0.15176038f, -0.25451437f, -0.05986406f, -0.09912767f, 
    0.07555361f, -0.06273295f, -0.10712830f, -0.25606543f, -0.09234375f, 0.00778332f, -0.27031076f, -0.02134367f, 
    0.04043228f, -0.40425882f, -0.12611404f, -0.01414100f, -0.56985003f, -0.49575689f, -0.47403696f, 0.15402998f, 
    -0.12118534f, -0.06601548f, -0.21467550f, 0.12580046f, -0.07484391f, -0.35400182f, 0.00835294f, -0.46176752f, 
    -0.08298354f, 0.30974960f, -0.13623150f, 0.45021892f, 0.07126558f, 0.00006881f, -0.33501214f, -0.02073112f, 
    -0.72684675f, -0.76299918f, -0.22975115f, 0.06548450f, -0.36438221f, -0.00347406f, 0.03281187f, 0.44985163f, 
    0.00475305f, -0.23564436f, -0.16290064f, -0.13631670f, -0.07034781f, 0.02616655f, -0.03784765f, 0.14695412f, 
    -0.33604261f, -0.13653675f, -0.02157107f, 0.06807408f, 0.01507717f, 0.17885132f, 0.22237058f, -0.13814799f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02140742f, 0.11025059f, 0.20787060f, 0.40086761f, 0.13037573f, 0.21790524f, -0.01698053f, 0.18522035f, 
    -0.20427592f, 0.19711283f, 0.03132918f, 0.16503853f, 0.42043665f, 0.14953375f, 0.11557828f, 0.10299499f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03084940f, -0.06967301f, -0.01496909f, 0.03781842f, -0.05324271f, 0.05013633f, 0.02798820f, -0.02411487f, 
    0.04548847f, -0.05248461f, -0.02042353f, 0.02712247f, 0.03661637f, 0.05498264f, -0.03339562f, -0.06592874f, 
    0.02063714f, 0.05340635f, -0.05656625f, -0.03996084f, -0.04369000f, -0.02022657f, 0.00939188f, -0.01192422f, 
    0.00214159f, -0.07165623f, -0.03277662f, 0.05268088f, -0.03466979f, -0.03667670f, 0.02540981f, -0.06596317f, 
    -0.06931201f, -0.03255483f, -0.05589670f, -0.03833651f, -0.03861475f, 0.04580398f, 0.05198032f, 0.02655577f, 
    -0.05639423f, -0.02909610f, -0.07253333f, -0.05057009f, 0.05834430f, -0.03944139f, -0.00162914f, 0.06540404f, 
    0.02669607f, -0.01654142f, -0.00265769f, 0.00322342f, 0.05723368f, 0.04831511f, -0.04366482f, 0.00308439f, 
    0.01319027f, -0.05152894f, -0.03953439f, 0.05932842f, -0.02795848f, 0.01576556f, -0.00237428f, 0.03310869f, 
    0.02726946f, 0.03991837f, -0.06093315f, -0.05154142f, -0.00228793f, -0.03099413f, -0.00803519f, -0.03143390f, 
    0.01650370f, -0.01125130f, 0.05038453f, 0.02137484f, -0.07308947f, -0.04308325f, 0.06123107f, -0.05494194f, 
    -0.04268133f, 0.05358850f, 0.03073292f, 0.00622035f, 0.03556263f, 0.06059899f, -0.05547739f, 0.02031393f, 
    0.06490402f, -0.06992539f, -0.03837608f, -0.07134568f, -0.00212438f, -0.04749131f, -0.06126767f, 0.03784711f, 
    -0.00658849f, -0.03766143f, 0.04160925f, 0.01857295f, -0.05222484f, -0.03307600f, 0.05542973f, 0.03758587f, 
    -0.06900595f, -0.03055136f, -0.02813767f, 0.00308833f, -0.03877458f, -0.06109779f, -0.01340224f, -0.02642523f, 
    -0.06954384f, -0.01009105f, -0.03930541f, -0.04077932f, -0.05858438f, 0.01905791f, 0.00538573f, 0.01309829f, 
    0.00175843f, 0.03020408f, 0.03899130f, -0.06027509f, 0.06214253f, -0.04780303f, -0.03015299f, 0.06441251f, 
    -0.04339203f, -0.04846269f, 0.00486980f, 0.06237688f, 0.04469974f, 0.03733640f, -0.04440483f, -0.02246385f, 
    -0.07706241f, -0.06018742f, -0.04166212f, -0.06850175f, -0.07622074f, 0.02876592f, -0.04049181f, -0.00338877f, 
    0.00528426f, -0.02621032f, 0.06015533f, -0.04061848f, -0.06851793f, 0.01377134f, -0.01322083f, -0.03374105f, 
    -0.03530594f, -0.02232659f, -0.05102934f, 0.05970063f, 0.04539408f, -0.05217261f, -0.02818532f, -0.01986787f, 
    0.04966735f, 0.03303502f, 0.01974025f, -0.07452410f, -0.00116628f, -0.03961482f, 0.06209701f, -0.02704308f, 
    0.01260270f, 0.01760820f, 0.05328301f, -0.02805695f, 0.04490980f, 0.03557285f, -0.03736737f, 0.03318192f, 
    -0.06585953f, -0.03193120f, -0.07627353f, -0.05649883f, -0.01323743f, -0.00271760f, 0.01266209f, 0.02224515f, 
    0.03719909f, -0.07350843f, 0.03239692f, -0.00259687f, 0.01159227f, 0.04655344f, 0.00907873f, -0.01147609f, 
    0.14427437f, 0.07815491f, -0.01625013f, -0.18427885f, 0.09889528f, 0.03676565f, 0.07464249f, -0.01387223f, 
    -0.03361688f, 0.28884771f, 0.13619667f, -0.05698358f, 0.08488909f, 0.07878627f, -0.19920780f, -0.12044349f, 
    -0.00374125f, -0.10318916f, 0.02982877f, 0.01515359f, 0.04647822f, 0.00535261f, -0.00476581f, 0.13067810f, 
    0.36417377f, 0.08693770f, 0.09652854f, 0.00871442f, 0.02746688f, -0.19490138f, -0.29982036f, -0.10792727f, 
    0.07103359f, -0.04173030f, -0.02686068f, -0.04340795f, 0.10881113f, 0.07336817f, 0.11648576f, 0.11574353f, 
    -0.08485480f, -0.04621278f, 0.03340936f, -0.11706677f, -0.00762890f, -0.11090960f, -0.18648806f, -0.00224805f, 
    -0.05995590f, 0.02532078f, 0.04177259f, 0.05400484f, 0.09491502f, -0.19468661f, -0.12823762f, -0.15647610f, 
    -0.05887247f, -0.13037430f, -0.04734419f, -0.18117046f, -0.05457569f, -0.24563423f, -0.11757300f, 0.20937844f, 
    -0.15112847f, 0.22916898f, 0.08012304f, 0.00066912f, 0.03044988f, 0.22529526f, -0.00431581f, -0.09262959f, 
    -0.37946373f, -0.10557032f, 0.04635027f, 0.02297843f, -0.10541363f, -0.06970581f, 0.21404295f, -0.01665968f, 
    -0.04624189f, 0.04060199f, -0.05229246f, -0.05596003f, 0.08327124f, -0.19041339f, 0.17550875f, -0.05340559f, 
    -0.00012564f, -0.08243936f, -0.00232444f, 0.00449374f, -0.07601614f, 0.03986716f, -0.04485961f, -0.09623684f, 
    0.32106954f, 0.22782673f, -0.18283023f, -0.01773474f, 0.11192803f, 0.03976005f, 0.00435470f, 0.22843461f, 
    0.00181293f, -0.01292654f, 0.06272921f, 0.08972313f, 0.06391064f, 0.03544277f, 0.01815996f, 0.28137502f, 
    -0.13708392f, -0.03433020f, 0.07971963f, 0.17286137f, 0.00598344f, 0.09018485f, -0.08380003f, 0.17720105f, 
    0.30400762f, 0.19799331f, -0.01868625f, -0.05111673f, -0.01039475f, 0.03759586f, 0.08564508f, -0.04245228f, 
    -0.06902277f, 0.08607993f, -0.04733627f, 0.18405494f, 0.00313733f, 0.14532875f, -0.01772250f, 0.01647479f, 
    -0.07962137f, -0.06919757f, -0.02711960f, -0.18161787f, -0.01791849f, -0.03463390f, -0.00165619f, -0.09208524f, 
    -0.00805760f, -0.22356430f, -0.12553816f, 0.19762769f, -0.03515908f, 0.05532675f, -0.03722683f, -0.23393838f, 
    -0.02084412f, 0.09641141f, 0.04788126f, 0.03502739f, -0.04020967f, -0.02377434f, 0.03881242f, 0.12526739f, 
    0.02800548f, 0.08522061f, 0.09201607f, 0.01276382f, -0.02485225f, 0.00299096f, -0.08430748f, 0.01432533f, 
    0.00596492f, -0.07604196f, -0.10758305f, 0.10678796f, 0.00657911f, 0.12434275f, -0.26697677f, 0.07309161f, 
    -0.05967604f, 0.00063570f, 0.06604052f, 0.18615447f, 0.11817824f, 0.08405977f, -0.01298586f, 0.33620515f, 
    -0.01679151f, 0.07649373f, 0.06202253f, 0.16173291f, -0.11078836f, 0.00269417f, 0.25583881f, 0.04655096f, 
    0.04020023f, -0.03290414f, -0.05330306f, -0.00062299f, -0.06758094f, -0.02166249f, 0.00448493f, 0.00821760f, 
    -0.01552942f, -0.01519436f, 0.03070863f, 0.03504934f, 0.00291993f, -0.00558479f, 0.01391445f, -0.00557287f, 
    -0.06115536f, -0.01291112f, -0.03724643f, -0.06007092f, -0.01791959f, 0.01103448f, 0.03906748f, 0.00847664f, 
    -0.00765670f, -0.03645685f, 0.02719485f, -0.06847063f, -0.01171129f, -0.03871819f, 0.04946469f, -0.04871426f, 
    0.01948586f, 0.04889756f, -0.05926475f, -0.00674238f, 0.04303716f, 0.02462950f, -0.05385306f, 0.06675308f, 
    -0.03021410f, 0.00861623f, 0.01942571f, -0.07460739f, -0.02087524f, 0.03281247f, -0.04588666f, 0.03823652f, 
    -0.02427276f, 0.01371327f, 0.00356704f, 0.04106404f, -0.02798388f, -0.02697771f, 0.06417920f, -0.02685492f, 
    -0.00181570f, -0.06138129f, -0.00470533f, 0.05440894f, -0.00442042f, 0.02337200f, 0.04122635f, 0.03423025f, 
    -0.03847111f, -0.00779952f, 0.02980765f, -0.05111167f, -0.03155314f, 0.02186522f, -0.05222991f, 0.00927601f, 
    -0.02431329f, -0.04006323f, -0.03321363f, -0.07699390f, -0.02622245f, -0.06633037f, -0.00738240f, -0.05945268f, 
    -0.02909348f, -0.03547650f, -0.05612802f, -0.02555945f, -0.03733660f, -0.00731471f, 0.01012185f, -0.01571702f, 
    -0.04100324f, 0.05678665f, -0.05798588f, -0.02127279f, -0.04826435f, -0.05968240f, -0.01892337f, -0.02884242f, 
    0.04030484f, -0.00762773f, 0.02614741f, -0.05532208f, 0.05728855f, -0.02382095f, -0.04598927f, -0.07600823f, 
    0.06303001f, 0.06506952f, 0.05847819f, -0.02066062f, -0.02542539f, 0.03003217f, 0.04535511f, 0.04387226f, 
    -0.02964814f, 0.04579042f, -0.05233140f, 0.03142498f, -0.04759237f, 0.00825457f, 0.01845290f, -0.05405853f, 
    -0.07290730f, 0.01574944f, -0.02878046f, -0.00480605f, -0.07038080f, 0.03477934f, -0.00192015f, -0.03670051f, 
    -0.02771249f, 0.01068803f, 0.06049300f, 0.00375837f, -0.03570438f, 0.04991053f, 0.01386475f, 0.04184365f, 
    -0.06487365f, -0.07838301f, 0.04623362f, -0.06918164f, -0.03383467f, 0.04609209f, 0.05278452f, -0.00435340f, 
    -0.07203295f, -0.05711490f, 0.00332585f, -0.01548170f, 0.01310899f, -0.06878918f, 0.01187867f, -0.06076746f, 
    0.02293970f, -0.02191867f, -0.01034718f, -0.00300484f, 0.05195121f, 0.06051375f, -0.07386465f, 0.01655473f, 
    0.00771972f, 0.03060144f, -0.01150398f, -0.02823527f, -0.01790053f, -0.00549968f, 0.00570663f, 0.00394888f, 
    -0.06369811f, -0.04750575f, 0.02957695f, -0.03657702f, 0.04407765f, 0.00978359f, 0.04543356f, 0.04110833f, 
    -0.02190493f, 0.04188355f, 0.01162516f, -0.00546006f, 0.05926473f, -0.04321722f, 0.03535238f, -0.01757940f, 
    -0.07466523f, -0.03197631f, -0.07711945f, -0.02356995f, -0.05341392f, 0.04234149f, 0.02059995f, 0.01317396f, 
    0.30895206f, 0.10638893f, -0.22794671f, 0.00420225f, 0.13077165f, 0.20669430f, 0.11953484f, -0.00732145f, 
    -0.00097536f, -0.04606077f, -0.00067103f, -0.05233043f, 0.32057315f, -0.16600530f, -0.02188797f, 0.46411002f, 
    -0.21918367f, 0.01929572f, 0.12001498f, 0.22933014f, 0.06750997f, 0.09767704f, 0.06474921f, -0.00554496f, 
    -0.00801226f, 0.19837533f, 0.15731166f, -0.17154917f, -0.09489227f, -0.00453933f, 0.01083983f, -0.01985902f, 
    -0.03115882f, -0.01270435f, -0.03603267f, 0.02378107f, -0.29731241f, 0.24465773f, -0.01209762f, -0.03315730f, 
    -0.00884162f, -0.01692260f, -0.19365358f, 0.06559216f, 0.01227272f, 0.13694130f, -0.03546456f, 0.02173847f, 
    0.09390593f, 0.09223465f, 0.05867319f, 0.17956130f, -0.02277881f, 0.00235029f, 0.12586601f, -0.00535933f, 
    0.07736668f, 0.00494824f, -0.24675536f, -0.11630429f, 0.10362209f, -0.05536185f, -0.21184041f, 0.20029302f, 
    -0.18362175f, -0.11154330f, 0.05656759f, 0.11024074f, 0.07983000f, -0.09163454f, 0.03610514f, 0.05529243f, 
    0.28104040f, -0.06647623f, -0.05635787f, -0.09306584f, -0.07071523f, 0.05216429f, -0.04759168f, 0.12264228f, 
    -0.16795938f, -0.01211523f, -0.06102550f, 0.10091704f, -0.03645092f, -0.05662565f, -0.04359089f, -0.04033919f, 
    0.03710748f, -0.13578449f, -0.08255309f, 0.13947758f, 0.08662216f, -0.04415995f, 0.05059898f, 0.05526146f, 
    -0.17805606f, 0.04165662f, 0.00069778f, -0.07045349f, -0.01571919f, 0.13093154f, -0.11747523f, -0.06905244f, 
    0.12062101f, -0.01619177f, 0.07632306f, 0.02213373f, 0.00298644f, -0.18623203f, 0.01594082f, -0.03861838f, 
    -0.05638102f, -0.20036364f, 0.07835601f, 0.09968895f, -0.05285943f, -0.03885288f, -0.07902419f, 0.05114904f, 
    0.39815250f, 0.13296588f, 0.17247552f, -0.18019792f, -0.04373427f, 0.05708320f, 0.14362463f, 0.14321797f, 
    0.05516934f, 0.01178541f, -0.05717566f, 0.13626173f, 0.41131705f, -0.17005223f, 0.19521910f, 0.27518529f, 
    -0.05799870f, 0.03532611f, -0.07396053f, 0.10645970f, -0.00038971f, 0.08223571f, -0.02964479f, -0.11932874f, 
    0.03216764f, -0.18694259f, -0.00965356f, -0.11245321f, -0.10572986f, 0.07541070f, 0.00062083f, 0.02565528f, 
    0.07758020f, 0.01623216f, -0.11938942f, -0.06587203f, -0.32642657f, 0.12200459f, -0.11050762f, 0.05832644f, 
    -0.01121383f, -0.00011650f, 0.20557629f, -0.04055066f, -0.06121583f, -0.09764191f, 0.06024945f, -0.02669650f, 
    0.03102039f, -0.00005603f, 0.16376638f, -0.21370652f, -0.04760966f, -0.05983029f, -0.04087616f, 0.12598552f, 
    -0.15242937f, -0.02236453f, 0.15993936f, -0.00023260f, -0.09090604f, 0.04416387f, 0.00373588f, 0.01798422f, 
    0.03640148f, -0.11123263f, -0.00731764f, -0.02905983f, 0.03011434f, 0.03627682f, 0.03753034f, 0.03652529f, 
    0.04469230f, 0.20103738f, 0.24812105f, -0.18932772f, -0.11834308f, 0.05778965f, 0.09783048f, -0.06658927f, 
    0.06101720f, -0.14878802f, -0.01560017f, -0.13335717f, -0.04575775f, 0.03210877f, 0.12181230f, 0.04664564f, 
    -0.00087796f, -0.07399660f, 0.07342964f, 0.04625491f, -0.05204815f, 0.02729873f, -0.06819554f, -0.12834525f, 
    -0.36152065f, -0.12640102f, 0.24403106f, 0.13640490f, -0.12868826f, -0.01564272f, -0.07897159f, 0.13919255f, 
    0.02666705f, -0.02987067f, 0.13596860f, -0.04269245f, -0.41531441f, 0.01150180f, -0.01303825f, -0.20007974f, 
    0.02551058f, 0.15982781f, -0.01667551f, 0.06400314f, 0.10426654f, -0.02157593f, 0.05318901f, 0.07076584f, 
    0.30015066f, -0.18774848f, 0.06438200f, 0.43407780f, -0.07558428f, 0.02817175f, -0.05212220f, 0.11899105f, 
    0.18831824f, 0.00290957f, 0.00645112f, 0.00875652f, 0.24093458f, 0.16485129f, 0.00659705f, 0.11445046f, 
    0.03514772f, -0.09211812f, -0.00239461f, 0.02470948f, -0.02185448f, 0.04791468f, 0.01991345f, 0.21526679f, 
    -0.02391788f, -0.31302917f, 0.00937803f, 0.04553140f, -0.04018838f, 0.02330929f, -0.00979366f, 0.09276047f, 
    0.02964962f, -0.08247504f, -0.13563231f, 0.02285701f, -0.38551781f, -0.03115697f, -0.32137236f, 0.03291447f, 
    0.12679233f, 0.06506886f, -0.03390674f, 0.06292187f, 0.12652695f, 0.11256695f, -0.03852208f, 0.13892892f, 
    -0.25709224f, -0.18835008f, -0.14482167f, -0.18622163f, -0.05099201f, 0.08900427f, 0.09391910f, -0.00155160f, 
    0.02475679f, -0.08337512f, -0.04294027f, -0.00844737f, 0.32945892f, -0.18272315f, -0.22674279f, 0.14677423f, 
    0.17319182f, 0.05799331f, -0.03271778f, -0.06044423f, 0.05657601f, -0.00799925f, 0.19838235f, 0.10959876f, 
    0.16889276f, 0.01524420f, 0.38132828f, 0.36647591f, -0.12132300f, -0.01847436f, 0.10370209f, 0.03457202f, 
    -0.09112287f, -0.06295822f, 0.07301054f, 0.01999374f, 0.40150318f, -0.04108405f, 0.12792049f, -0.03105096f, 
    0.05496036f, 0.06728907f, -0.01686039f, -0.12754728f, 0.08458605f, -0.06384463f, -0.02708936f, 0.03422293f, 
    0.13283525f, -0.12480535f, -0.02792942f, 0.14103891f, -0.09099437f, -0.03957443f, 0.00178480f, 0.09937364f, 
    0.04975601f, 0.00554252f, -0.03149093f, -0.18168373f, 0.07861886f, 0.13236889f, 0.16242108f, 0.08840165f, 
    0.00967308f, 0.10280321f, -0.01186493f, 0.08514591f, -0.09373472f, 0.09699892f, 0.17616197f, -0.03163575f, 
    0.05718722f, 0.08987983f, 0.14146143f, 0.24263242f, 0.05215488f, -0.02579974f, -0.06796881f, 0.06795102f, 
    -0.08967131f, -0.06820691f, 0.00949694f, -0.04005124f, 0.01376797f, -0.00567781f, -0.36670271f, -0.13918819f, 
    0.07393511f, 0.06314800f, 0.08824690f, -0.07266992f, -0.01328075f, -0.02259595f, -0.02706754f, -0.01456476f, 
    -0.05630095f, -0.03068005f, -0.03900505f, 0.00913929f, -0.02020138f, 0.02821164f, -0.07419193f, -0.03826318f, 
    -0.02957509f, 0.04123211f, -0.04389459f, 0.04315965f, 0.00835131f, -0.06617080f, 0.00486427f, 0.00103282f, 
    0.04784741f, -0.03121557f, 0.03199627f, -0.07144769f, 0.04225178f, 0.02360946f, -0.03378453f, -0.01722256f, 
    0.01680331f, -0.02000521f, 0.04467611f, 0.01181084f, 0.06211796f, 0.05847358f, 0.01884495f, -0.05716569f, 
    -0.04274582f, -0.06031216f, -0.04677190f, -0.04037854f, 0.05645718f, 0.05209672f, -0.05156610f, -0.02670667f, 
    -0.03989537f, -0.03080739f, 0.01436475f, 0.04209262f, -0.06407586f, 0.04277682f, -0.06995215f, 0.05859925f, 
    -0.07021011f, -0.05933078f, 0.02838731f, -0.07622780f, 0.04777123f, 0.05707419f, 0.02399076f, 0.02555055f, 
    -0.05328101f, 0.04430549f, -0.04831353f, 0.03464585f, -0.00137015f, 0.01065897f, 0.04590347f, -0.03103221f, 
    0.00306393f, -0.04575140f, -0.05168253f, -0.06033901f, -0.05259227f, 0.01623356f, 0.05972987f, 0.01560689f, 
    0.01238404f, -0.04920291f, -0.06128376f, 0.02615156f, -0.03708674f, -0.06362565f, -0.03831526f, 0.04275827f, 
    0.02048190f, -0.02066473f, -0.03255285f, 0.02105221f, 0.00571792f, 0.05687745f, -0.03416330f, -0.05530668f, 
    -0.06413267f, -0.05625425f, 0.04997403f, -0.02400829f, 0.00629310f, 0.05010916f, 0.01774859f, -0.05341015f, 
    -0.06065077f, -0.05225591f, -0.05740272f, -0.05514544f, -0.01159737f, 0.02644066f, -0.00131760f, 0.00865831f, 
    0.06019311f, -0.07199570f, -0.02090354f, -0.03415313f, -0.03883491f, -0.06553310f, -0.05344381f, -0.01235371f, 
    -0.01029325f, 0.04476453f, -0.02489602f, 0.04569469f, -0.01698667f, -0.01187224f, 0.01570666f, 0.02024519f, 
    -0.06914810f, 0.00621949f, -0.06294201f, -0.01265299f, 0.00098689f, -0.03130889f, -0.03260858f, -0.04798676f, 
    0.02275452f, -0.07402661f, 0.04659268f, -0.03533545f, 0.06649999f, -0.03312925f, 0.00414735f, -0.07557027f, 
    0.03505512f, -0.00326863f, -0.04213519f, 0.00732293f, 0.02454386f, -0.05866330f, -0.05957594f, 0.01409225f, 
    0.04649900f, -0.06878560f, 0.05146702f, 0.04917320f, 0.03516812f, -0.03425323f, -0.01369669f, 0.03959266f, 
    0.06344965f, 0.05159746f, 0.03405019f, -0.02989662f, 0.00200598f, 0.00992277f, -0.05924897f, -0.01953156f, 
    -0.01938032f, -0.03514481f, 0.06173618f, -0.03273638f, -0.06693754f, 0.00794093f, 0.00116214f, 0.06255163f, 
    0.02579291f, 0.03040725f, -0.02725564f, -0.05899343f, 0.06488448f, -0.00724440f, -0.01190031f, -0.01673365f, 
    -0.06376872f, -0.00433166f, 0.00168436f, 0.05773188f, 0.01886625f, 0.04422324f, -0.01613493f, 0.00107043f, 
    -0.04472395f, -0.02470875f, 0.02281422f, -0.04935445f, -0.07473631f, -0.03288313f, -0.04341698f, 0.06112335f, 
    -0.05263136f, 0.23840922f, 0.02260919f, 0.01185946f, -0.04408342f, -0.01146970f, -0.05851896f, 0.08085650f, 
    0.06095523f, 0.06698814f, 0.08453801f, -0.00350103f, -0.25597477f, -0.14488800f, -0.01500343f, -0.30404148f, 
    0.01700007f, -0.02822939f, 0.02567982f, -0.12598234f, 0.11284439f, 0.09424210f, -0.07417510f, -0.14839107f, 
    -0.10293298f, -0.03589124f, 0.14261001f, 0.28506953f, -0.13395098f, 0.02419538f, 0.07028374f, -0.04974564f, 
    0.02570241f, -0.04790556f, 0.14716019f, -0.00608749f, 0.06290665f, 0.04785980f, 0.05056070f, 0.03924279f, 
    0.03172674f, 0.10846198f, 0.02513910f, 0.10775869f, -0.09597609f, -0.06184567f, 0.07599784f, 0.01823840f, 
    -0.05545181f, -0.09927591f, -0.13885947f, 0.05447175f, 0.08612320f, -0.10273228f, -0.04785470f, 0.08276621f, 
    0.09971170f, -0.00077602f, 0.07328340f, 0.06576561f, 0.10505611f, 0.28094542f, -0.01213363f, -0.12091551f, 
    0.17526272f, 0.15678835f, 0.02575877f, -0.10838154f, 0.05779744f, -0.04345201f, 0.02112715f, 0.10319617f, 
    -0.15581913f, -0.08368105f, -0.21435428f, 0.27615312f, 0.09265053f, -0.02801239f, -0.06512733f, 0.00908516f, 
    0.13900620f, 0.01981650f, -0.02973728f, 0.01134219f, 0.07291228f, 0.30906662f, -0.08881707f, -0.04789219f, 
    -0.04537016f, -0.06103099f, -0.06537545f, -0.10675903f, -0.04894294f, -0.08708206f, 0.01422946f, -0.09652927f, 
    -0.18090692f, 0.01600131f, -0.07094647f, -0.04103854f, -0.03961902f, 0.16449107f, 0.07503767f, -0.01545830f, 
    -0.03794350f, 0.04451857f, -0.03179654f, -0.07201634f, 0.25551698f, 0.12582016f, 0.00092490f, 0.01875916f, 
    0.06366041f, 0.06612466f, -0.01592648f, -0.16990170f, 0.00804772f, -0.02851563f, 0.13090858f, 0.00128762f, 
    0.13248645f, -0.05261327f, 0.03735357f, 0.40805179f, 0.12307718f, -0.11417289f, -0.05490108f, 0.05679925f, 
    0.03902103f, 0.01691937f, 0.03778461f, 0.00627171f, -0.16821125f, -0.20997746f, -0.04051922f, -0.06782128f, 
    0.10524625f, 0.10236245f, 0.01102695f, -0.07348238f, 0.02439940f, -0.01389017f, 0.04504842f, 0.10906619f, 
    -0.05023024f, 0.12666717f, -0.09457071f, 0.06474456f, 0.10696953f, -0.03724895f, -0.11285149f, 0.02593940f, 
    0.07418394f, -0.04030883f, 0.13868435f, 0.00481468f, 0.27152309f, -0.05893489f, 0.02699777f, 0.19484136f, 
    0.03121544f, -0.09071141f, 0.03688220f, -0.03452901f, 0.01355730f, 0.06609157f, 0.05626766f, -0.01753885f, 
    0.25435460f, 0.14960569f, 0.03218967f, 0.27947158f, -0.03468700f, 0.01087910f, -0.08538268f, -0.13486320f, 
    0.09709390f, -0.03835559f, -0.00590906f, -0.01858356f, 0.18065962f, 0.18497169f, 0.12972565f, -0.26524827f, 
    0.07854147f, 0.05188438f, 0.15299578f, -0.12158323f, 0.03065309f, 0.04018841f, 0.02808937f, -0.02976235f, 
    -0.13598895f, -0.09153513f, -0.15312694f, -0.01885816f, -0.04932799f, -0.05944911f, -0.11539488f, 0.10543702f, 
    -0.01014433f, 0.16413420f, 0.11208323f, 0.08181374f, 0.16641033f, 0.00246943f, -0.13041879f, -0.13323484f, 
    -0.02306045f, -0.08170376f, -0.05530399f, -0.07058515f, 0.06893282f, -0.08075862f, 0.03289226f, 0.06689642f, 
    0.20127240f, 0.08373682f, 0.16405873f, 0.01357876f, 0.14938457f, -0.05377972f, 0.09740857f, 0.06216945f, 
    -0.12153449f, -0.06664640f, 0.03821573f, 0.16002570f, -0.00357432f, 0.09308767f, 0.07194986f, 0.25782397f, 
    -0.17552908f, -0.05051459f, 0.14590208f, 0.03451202f, -0.01789763f, 0.13686751f, 0.08374744f, -0.02151802f, 
    0.06458504f, -0.02692347f, -0.04097401f, 0.06816850f, 0.13993756f, -0.01762048f, -0.09668511f, -0.05466043f, 
    -0.01445443f, 0.02538033f, -0.00814846f, -0.09468549f, 0.20724097f, -0.18184178f, 0.01182262f, -0.18830320f, 
    -0.00865229f, 0.06473041f, -0.08892390f, 0.01268612f, 0.02044448f, -0.10386906f, 0.04249359f, 0.02346576f, 
    0.01712643f, -0.20116712f, -0.14278869f, 0.09572090f, 0.05225784f, -0.00483090f, -0.08443263f, -0.14227812f, 
    0.06666914f, 0.10944142f, -0.04232942f, -0.12582617f, 0.25546715f, 0.26129505f, 0.14402898f, 0.05834487f, 
    -0.05319311f, -0.01751433f, 0.01546211f, -0.08734612f, -0.01349360f, 0.01294568f, 0.12158031f, -0.10014863f, 
    -0.49006456f, 0.06458975f, -0.09476928f, 0.15940796f, 0.09171291f, -0.01941725f, 0.03098555f, 0.03155560f, 
    -0.04045832f, 0.10260437f, 0.04672377f, -0.07426803f, 0.14114428f, 0.30655175f, -0.12019378f, 0.11399216f, 
    -0.09458341f, 0.12591356f, 0.03887806f, 0.08484981f, 0.03107449f, -0.06002988f, 0.11905815f, -0.01256057f, 
    0.16064808f, 0.04828370f, -0.15515079f, 0.24876280f, 0.05309755f, 0.11526940f, -0.11943268f, 0.08841638f, 
    0.07100269f, 0.09139147f, 0.10500914f, 0.02034837f, -0.20782934f, -0.15673144f, 0.06627807f, 0.17141967f, 
    0.03708483f, 0.13432562f, -0.02500173f, -0.01101356f, 0.04075733f, 0.02938240f, -0.09527450f, 0.08958745f, 
    0.05936092f, 0.10989789f, -0.14663775f, 0.20162480f, 0.13171743f, 0.01949601f, -0.00767107f, -0.03949606f, 
    0.03249628f, -0.00160383f, 0.01554722f, 0.10418779f, 0.06501062f, -0.21706572f, 0.16079235f, 0.16519031f, 
    -0.06962380f, -0.06994031f, -0.04417190f, 0.01218843f, 0.08448812f, -0.08917163f, 0.02493973f, 0.06310368f, 
    0.35917354f, -0.00176682f, 0.04768947f, 0.33185184f, -0.03823594f, -0.08132666f, -0.07815654f, -0.08635070f, 
    0.08090519f, 0.11499400f, -0.01417461f, -0.12375552f, 0.01414813f, 0.10066793f, 0.14221901f, -0.00260285f, 
    0.00429843f, -0.10156055f, 0.00089895f, 0.13363770f, 0.03609500f, 0.01488690f, 0.05799614f, 0.06378847f, 
    -0.06430718f, 0.03599908f, -0.04402879f, 0.01603314f, -0.02906519f, -0.09376336f, -0.01204104f, 0.03919821f, 
    -0.04648815f, -0.03464361f, -0.02474745f, -0.08527842f, 0.02844567f, -0.05253784f, -0.07730208f, -0.06406169f, 
    -0.03464178f, -0.02770453f, -0.04621058f, 0.02820243f, -0.00061452f, -0.05151756f, -0.00911905f, -0.05166695f, 
    -0.08829779f, -0.02429204f, 0.00884704f, -0.00925360f, 0.02704780f, -0.08586563f, -0.08778785f, 0.01087309f, 
    -0.08375889f, -0.02575074f, -0.00786481f, -0.04574733f, -0.07063250f, 0.04107411f, -0.08551020f, -0.07410517f, 
    -0.03203130f, -0.01164400f, -0.06972365f, -0.02136720f, -0.03983839f, -0.00445845f, -0.07526249f, -0.02911182f, 
    -0.04929733f, -0.00534507f, -0.06311408f, 0.04173125f, -0.07665864f, -0.07523707f, -0.04130008f, 0.02873010f, 
    -0.08118241f, -0.06580070f, -0.00701049f, -0.04185034f, -0.03820048f, 0.00429382f, -0.04803436f, -0.03583085f, 
    0.01617574f, 0.01956360f, -0.00047908f, 0.00105015f, -0.01849011f, 0.03549535f, 0.04492614f, -0.08687463f, 
    0.02604133f, -0.06335037f, -0.05995160f, -0.04373523f, 0.02574709f, 0.02842275f, -0.04098549f, 0.03678905f, 
    0.03495739f, 0.01777624f, 0.03367427f, -0.07564099f, 0.00313631f, 0.02555279f, -0.04092807f, -0.05103410f, 
    -0.07072068f, 0.00289997f, -0.06743788f, -0.09155504f, -0.06777515f, -0.08303965f, -0.09297111f, 0.01694263f, 
    -0.08617790f, -0.05643049f, 0.00897615f, 0.01391952f, -0.04397953f, -0.03053854f, -0.01523761f, 0.04252258f, 
    0.04033831f, -0.00954972f, 0.01899002f, -0.09311452f, -0.03206314f, -0.04554549f, -0.01082136f, 0.00784153f, 
    -0.03531887f, -0.05861836f, 0.01786621f, 0.04421074f, -0.05298431f, 0.03796719f, 0.02090482f, 0.02379126f, 
    -0.03851892f, 0.03061097f, -0.02175070f, -0.01117154f, -0.07962352f, 0.03274769f, 0.00277216f, -0.09855579f, 
    -0.06757589f, -0.05069241f, -0.00612662f, 0.04328198f, -0.02644298f, -0.01761908f, -0.09742287f, -0.06602672f, 
    -0.03568295f, 0.01072726f, -0.01078956f, 0.01740172f, 0.03386648f, 0.00208015f, -0.04911701f, -0.03169020f, 
    -0.00880996f, -0.08413430f, -0.04721430f, -0.01661850f, -0.08079081f, -0.09946082f, -0.03006887f, -0.06907974f, 
    -0.00803315f, -0.05701547f, -0.02496923f, -0.05925003f, 0.04619507f, 0.00101091f, 0.00325953f, -0.07636945f, 
    -0.03624421f, -0.08651944f, -0.05245875f, -0.09401762f, -0.06844798f, 0.01480940f, -0.02512728f, 0.04167960f, 
    -0.04646567f, 0.01966234f, -0.04575514f, 0.03079990f, 0.00759980f, 0.06371908f, -0.07855348f, -0.00398896f, 
    -0.09048294f, -0.00462229f, 0.04364352f, -0.06164331f, -0.03484698f, -0.06811759f, -0.01246295f, -0.03391980f, 
    -0.04544966f, 0.02880701f, 0.02958652f, -0.07591046f, 0.04442986f, 0.00760455f, -0.02293487f, -0.04185882f, 
    -0.00025155f, 0.03024440f, -0.04160362f, -0.09002572f, -0.07470962f, -0.06080857f, -0.00490872f, -0.07389085f, 
    0.03312101f, -0.01410129f, 0.00876238f, -0.09110562f, 0.03993173f, -0.06454847f, -0.04838775f, -0.05249118f, 
    0.03990450f, -0.08176771f, -0.05819786f, -0.07162294f, -0.06142011f, 0.00050349f, -0.01200922f, 0.04732905f, 
    0.05030359f, -0.03687971f, -0.05152994f, -0.01677182f, -0.04782199f, -0.08694959f, 0.01094904f, -0.04888888f, 
    -0.04245557f, -0.00125686f, -0.06452020f, 0.01191832f, 0.00762210f, -0.05167543f, 0.02476498f, -0.06773866f, 
    -0.07927021f, -0.01515919f, -0.02076085f, 0.04946874f, -0.02792048f, -0.00229925f, -0.05855948f, -0.05575999f, 
    -0.05943175f, -0.06744809f, -0.01975727f, -0.06208745f, -0.04150590f, 0.04894720f, 0.02256775f, 0.03664890f, 
    -0.00290036f, -0.06473672f, -0.08816210f, 0.01406931f, -0.07456519f, -0.06566866f, -0.00700802f, -0.06870545f, 
    -0.05238056f, -0.05665768f, -0.07201254f, 0.04692684f, -0.03446405f, -0.03442312f, 0.02843423f, -0.01717019f, 
    0.00837349f, 0.03672035f, -0.01033903f, -0.01688485f, 0.04699010f, -0.01899246f, -0.02897626f, -0.06801964f, 
    0.06220539f, 0.01097445f, -0.01639400f, -0.00293753f, -0.01913343f, -0.01575204f, -0.07208044f, -0.01884908f, 
    -0.08205117f, -0.04373230f, -0.01435131f, -0.00330103f, -0.02982940f, -0.05911428f, -0.03097110f, -0.01576339f, 
    -0.06200649f, 0.03454001f, -0.02829645f, -0.07009625f, -0.04127810f, -0.04216297f, 0.03467062f, -0.00675802f, 
    -0.09371585f, -0.06581467f, 0.04836005f, 0.03019490f, 0.06207197f, 0.05521049f, -0.01739470f, 0.04532460f, 
    -0.02116125f, -0.03995070f, -0.06427853f, -0.07767572f, -0.03205678f, -0.02011694f, 0.02172999f, 0.04208438f, 
    -0.05034501f, -0.07132199f, -0.05175683f, -0.06331030f, -0.07385948f, -0.01923924f, -0.08658355f, 0.04211086f, 
    -0.00448337f, -0.05795954f, -0.03530701f, 0.04091755f, -0.02599927f, 0.00893223f, -0.08404743f, -0.00222130f, 
    0.03046945f, -0.09077667f, -0.00454091f, -0.00950955f, -0.06407185f, -0.06941521f, -0.02613401f, -0.09357899f, 
    -0.01803243f, -0.05258948f, -0.05776488f, -0.04784476f, 0.01433793f, -0.02336085f, -0.01948579f, 0.00474810f, 
    -0.05538037f, -0.08022378f, -0.00949998f, -0.02009316f, -0.05335674f, -0.08488336f, 0.02466301f, -0.04171979f, 
    0.00576827f, -0.07831923f, -0.02380026f, 0.01799002f, 0.00144609f, -0.05495210f, -0.03696838f, -0.05253130f, 
    -0.01190614f, -0.06595317f, -0.06178601f, -0.04357389f, -0.06568705f, -0.00233602f, -0.01585868f, -0.01775052f, 
    -0.08299458f, 0.03726613f, -0.05715862f, -0.06222018f, 0.04736261f, -0.07458831f, -0.06430405f, -0.03955788f, 
    0.02041628f, -0.05772317f, -0.05087886f, 0.01120698f, -0.01360253f, -0.06287835f, 0.01748584f, 0.03480889f, 
    -0.08828246f, -0.27206382f, -0.07184149f, 0.04571097f, 0.03354280f, -0.05173398f, -0.17156096f, -0.04867009f, 
    0.11188237f, -0.02359582f, -0.00243175f, 0.04700706f, 0.11783411f, 0.02770914f, 0.11887269f, 0.02942906f, 
    0.13408910f, 0.12030922f, -0.06257351f, -0.07952855f, 0.05040858f, -0.12232093f, 0.04631123f, 0.07625201f, 
    -0.11663745f, 0.04343322f, 0.03019750f, -0.16575637f, 0.05790446f, -0.05039484f, 0.12484149f, 0.05024061f, 
    -0.01430041f, 0.11755740f, 0.07214355f, 0.09388749f, 0.12770249f, -0.08429961f, -0.13363011f, 0.06929951f, 
    0.08457422f, -0.00678979f, -0.08265425f, -0.06677105f, -0.00455913f, 0.05399368f, -0.01838425f, -0.10662410f, 
    0.26580027f, 0.08530709f, 0.14025033f, 0.08231692f, -0.01199730f, 0.03904326f, -0.03739080f, 0.07446378f, 
    0.09166594f, 0.10350797f, -0.02175037f, 0.08038168f, -0.04026953f, 0.10986322f, 0.22140828f, -0.04617359f, 
    0.09709080f, 0.00392371f, -0.20006733f, 0.01405261f, -0.02224491f, 0.09743598f, 0.06747504f, -0.00170985f, 
    0.35438806f, 0.14720583f, -0.09022257f, -0.02426268f, -0.01170569f, 0.11782183f, -0.17162344f, -0.04657355f, 
    0.07854407f, -0.04060711f, -0.01123725f, 0.01284501f, 0.00481180f, 0.07076789f, -0.11041571f, -0.00892420f, 
    0.07024653f, 0.13343537f, -0.02512756f, 0.03202546f, -0.02345959f, 0.04736029f, 0.07401949f, 0.10774641f, 
    -0.15406591f, -0.32665133f, -0.03431780f, 0.06953108f, 0.04304184f, -0.16413291f, 0.05405040f, -0.03983950f, 
    -0.04654855f, 0.14532977f, -0.10040652f, -0.04131626f, -0.07032390f, 0.01954211f, -0.02671188f, -0.17644516f, 
    0.07269839f, 0.01218512f, 0.04674560f, 0.04306715f, 0.20251508f, -0.03724221f, 0.21142411f, -0.05577362f, 
    -0.22409178f, -0.29894602f, -0.04835399f, -0.16799639f, -0.16959314f, 0.15187444f, -0.08124433f, 0.01706976f, 
    0.12221564f, 0.01987898f, 0.21803014f, 0.01044631f, 0.01254755f, 0.04305067f, -0.05513658f, -0.00647935f, 
    -0.05179311f, 0.03046754f, -0.01446288f, 0.09407306f, 0.02303108f, 0.05975084f, 0.00620658f, 0.14172307f, 
    0.07271835f, 0.11413612f, 0.10256931f, 0.15244089f, 0.03103485f, 0.09835220f, 0.06755987f, 0.19194829f, 
    0.10542619f, 0.08281995f, -0.02100026f, 0.09998752f, 0.00861828f, -0.05236351f, 0.11900577f, -0.13769126f, 
    0.00845767f, 0.03393377f, -0.11455198f, 0.01810058f, 0.02542587f, -0.03136289f, 0.13740711f, 0.05589880f, 
    0.00751881f, -0.02609350f, 0.03341561f, 0.01135819f, 0.00254474f, 0.05012574f, 0.16489394f, 0.04139911f, 
    0.08874101f, 0.09491262f, 0.01543566f, 0.02677270f, -0.03671154f, -0.16308619f, 0.03061070f, -0.05711805f, 
    0.17962512f, -0.02403326f, 0.03422316f, 0.07994756f, 0.10295802f, 0.06623461f, -0.13110091f, 0.02788180f, 
    0.20601782f, -0.04835407f, -0.06698138f, 0.17355838f, 0.12789515f, -0.06951179f, 0.13645934f, -0.02766269f, 
    -0.00417400f, 0.08909852f, -0.08824224f, 0.04808471f, 0.13450944f, 0.18097188f, 0.19783388f, 0.11147036f, 
    -0.01688072f, 0.02505687f, 0.08972258f, -0.02147644f, 0.03152020f, 0.12752585f, 0.11286914f, 0.16541654f, 
    -0.04832212f, -0.03213170f, -0.23180695f, 0.00651318f, 0.06575062f, 0.01407478f, -0.09757277f, 0.03549827f, 
    0.05308278f, 0.10092064f, -0.06123617f, 0.03335265f, 0.25100821f, -0.10851447f, 0.04510277f, -0.02708422f, 
    0.10449778f, 0.09620302f, -0.02638788f, 0.08560359f, -0.03213311f, -0.07022230f, -0.11675364f, -0.01832603f, 
    -0.01795937f, 0.13673581f, -0.00631916f, -0.11661235f, 0.12856200f, -0.01965970f, 0.02932017f, -0.15545841f, 
    -0.14971171f, -0.05362180f, -0.00355123f, -0.07210477f, -0.01078344f, 0.10097762f, -0.01775108f, 0.24516717f, 
    -0.05474348f, 0.14739850f, 0.05284609f, 0.10047608f, -0.01877226f, 0.09403316f, 0.01403627f, -0.14141981f, 
    0.37343308f, 0.22536787f, 0.32231537f, -0.06201291f, -0.06722329f, -0.07194007f, 0.08401029f, 0.00590776f, 
    -0.17723446f, 0.03016726f, 0.07472758f, -0.02131313f, -0.01626797f, -0.37485665f, 0.01879369f, -0.06223918f, 
    -0.03732486f, -0.03289665f, 0.08105909f, 0.03688763f, -0.08712521f, 0.04798454f, -0.16718009f, -0.09120083f, 
    0.29121774f, -0.01079722f, 0.17170788f, 0.02058673f, -0.03070541f, 0.09470518f, -0.12055145f, 0.07555606f, 
    0.07364740f, -0.00927968f, 0.15387064f, 0.07679190f, -0.35575321f, -0.09380455f, 0.18492903f, -0.03840633f, 
    -0.00901108f, 0.01749823f, 0.05954350f, 0.11904135f, 0.13967986f, 0.12617664f, -0.08500058f, 0.14792015f, 
    -0.03351530f, -0.07225963f, 0.00090965f, -0.30340323f, 0.02267768f, 0.01276410f, 0.03780806f, 0.04734546f, 
    -0.04291422f, 0.02222256f, -0.03113826f, 0.13775612f, 0.17849679f, 0.40572271f, -0.09676357f, 0.04739419f, 
    0.12941447f, 0.04472598f, 0.03505081f, 0.01403110f, -0.12821805f, -0.02279508f, -0.05522616f, -0.05603640f, 
    0.14063603f, 0.16630606f, 0.24751702f, -0.14420108f, 0.06420284f, 0.12176628f, 0.08198659f, -0.12320646f, 
    0.03651990f, -0.06054470f, 0.10323270f, 0.16149826f, 0.17346711f, 0.08396381f, -0.09762824f, -0.11893336f, 
    0.01074029f, 0.06569592f, 0.11261391f, 0.03431918f, 0.12360170f, 0.00362917f, -0.04978564f, -0.00309285f, 
    -0.24359451f, -0.10749524f, -0.10878579f, -0.23878272f, 0.02983768f, 0.10512434f, 0.04856378f, 0.02414799f, 
    0.06202211f, -0.02835828f, 0.09526511f, 0.10200443f, 0.06033410f, -0.07086708f, -0.04629346f, 0.16210197f, 
    0.03663003f, 0.03476145f, -0.08467349f, -0.01938738f, 0.07131262f, 0.03469505f, 0.12132049f, 0.09751297f, 
    -0.24139825f, -0.15592411f, 0.09806323f, -0.19451797f, -0.04323505f, 0.17652588f, -0.14498639f, -0.05800465f, 
    0.14850031f, -0.02592497f, 0.01512202f, -0.02683106f, 0.15376467f, -0.10340960f, -0.03969105f, -0.08360416f, 
    0.05027197f, 0.05978881f, 0.05313961f, 0.01952699f, 0.01079190f, -0.09729957f, -0.05230828f, -0.05485240f, 
    -0.10391277f, 0.04926385f, 0.01670385f, -0.15757823f, -0.05027179f, -0.00034164f, -0.06830822f, -0.02283009f, 
    -0.00091098f, 0.04868808f, 0.12202387f, -0.00143140f, -0.16975063f, 0.11497323f, -0.09362038f, -0.01940862f, 
    0.08809243f, -0.01433722f, -0.01969955f, 0.05029802f, 0.29359442f, 0.10092384f, -0.05129934f, 0.06330595f, 
    -0.11747133f, 0.11668278f, 0.32513162f, 0.23241958f, -0.12818158f, -0.00896529f, -0.03348523f, -0.00714344f, 
    0.15947345f, 0.11275665f, 0.04845108f, 0.24138822f, -0.25870284f, 0.15021397f, 0.21598364f, 0.16305162f, 
    0.02244449f, -0.07736072f, -0.06824230f, -0.05768408f, -0.07302408f, 0.13475622f, 0.03329189f, 0.06802232f, 
    -0.58561319f, -0.26803458f, -0.07327444f, -0.14496721f, -0.12057866f, 0.13022646f, 0.15149184f, -0.08231521f, 
    0.03673500f, -0.18412508f, 0.08681726f, -0.02504941f, 0.05992245f, 0.07387039f, -0.17255427f, 0.16639172f, 
    0.21097711f, 0.08165371f, 0.07393627f, 0.09275714f, 0.17931932f, 0.04169861f, -0.03742877f, 0.19208778f, 
    0.31106272f, 0.06167823f, -0.21415634f, -0.04112119f, 0.02850858f, 0.02706456f, 0.10274025f, -0.01808908f, 
    -0.03350592f, 0.00316541f, -0.07564443f, 0.00828725f, -0.10323256f, -0.18236859f, -0.26099837f, -0.11831973f, 
    -0.02272166f, -0.12564144f, -0.04522667f, -0.10503905f, 0.02361189f, -0.05973119f, 0.21534565f, -0.07048819f, 
    -0.17315102f, 0.30165797f, 0.22501898f, -0.00086358f, -0.06414717f, -0.01108922f, 0.14111188f, -0.07715946f, 
    -0.00423707f, -0.03067193f, 0.10472549f, -0.00966272f, 0.27875429f, -0.05522948f, 0.22452837f, -0.12116513f, 
    -0.05673783f, -0.12399290f, 0.03376007f, 0.02005560f, 0.21952325f, 0.15945114f, 0.04575478f, 0.09786993f, 
    0.03940927f, -0.41014621f, 0.18955702f, 0.29775450f, -0.21006791f, -0.04037191f, 0.06174271f, 0.01032995f, 
    0.08885911f, 0.06003957f, -0.03249892f, 0.03046896f, -0.20027399f, 0.31693661f, 0.16765733f, 0.09153640f, 
    0.12842254f, 0.07283572f, -0.16700205f, 0.03305089f, -0.11450242f, 0.18137443f, -0.01238054f, 0.04571189f, 
    -0.02857798f, -0.09531121f, 0.09974771f, 0.30663356f, 0.13573648f, 0.07703926f, 0.03219325f, 0.00932576f, 
    0.00803669f, 0.10210055f, -0.09344424f, 0.06715202f, 0.10336182f, -0.21423520f, -0.19058323f, 0.18446848f, 
    0.12634218f, 0.23930466f, 0.05397494f, 0.03433993f, 0.09643137f, -0.02991671f, -0.11626534f, 0.05445841f, 
    0.03319526f, 0.31147808f, 0.13125883f, 0.12735479f, -0.04670151f, 0.03165421f, -0.06840026f, -0.03331547f, 
    0.02754718f, -0.21903330f, 0.03128053f, 0.03446531f, -0.21878466f, 0.01834452f, 0.16111596f, -0.03522690f, 
    -0.04126287f, -0.05427454f, -0.16026145f, -0.17899992f, -0.00083887f, -0.03042388f, -0.04888892f, -0.10396637f, 
    -0.22675388f, -0.02789365f, -0.06200700f, 0.10401224f, 0.02783685f, 0.14147091f, 0.04324968f, -0.03886380f, 
    0.16405615f, 0.07986984f, 0.00490812f, 0.02198845f, -0.03433570f, -0.20930104f, -0.12566791f, -0.22686578f, 
    0.16277085f, -0.03287489f, 0.04585221f, -0.06215215f, 0.00558593f, 0.02672537f, 0.21179390f, -0.06280320f, 
    -0.07540926f, 0.01875465f, -0.06840500f, 0.29040408f, 0.01797077f, 0.06456754f, -0.03650599f, -0.01406561f, 
    0.12874417f, -0.03354743f, 0.11531862f, 0.05908455f, -0.00742231f, 0.16012435f, 0.05090721f, 0.12673736f, 
    0.18683580f, -0.08523576f, -0.04292256f, -0.03291180f, -0.07059975f, -0.03362357f, 0.08394685f, 0.02319461f, 
    -0.15367751f, 0.20940092f, -0.20543498f, 0.14837708f, 0.01562145f, 0.07089885f, -0.08046568f, 0.10879217f, 
    0.10797343f, -0.05370484f, 0.00448869f, 0.14012067f, -0.41913298f, 0.04879444f, -0.17744030f, -0.09934459f, 
    0.18629016f, 0.04043998f, -0.05215908f, 0.00575175f, 0.04664835f, -0.06409904f, -0.07856379f, 0.16905367f, 
    0.12948789f, -0.32326040f, -0.15465325f, -0.19644491f, -0.05782147f, -0.07499303f, 0.10382269f, -0.18614049f, 
    0.01582885f, -0.03309570f, -0.09675122f, -0.03189033f, 0.02432388f, -0.01612752f, 0.11553421f, -0.16703103f, 
    0.19162510f, 0.14162797f, -0.02449154f, 0.00870368f, 0.03445865f, 0.08079527f, 0.08395620f, 0.02800117f, 
    0.02731373f, -0.11608239f, 0.19199976f, 0.33908996f, 0.09513953f, -0.12096045f, -0.01598001f, 0.02852662f, 
    -0.15259778f, -0.10520359f, 0.10038539f, 0.09779543f, -0.09321713f, 0.12246926f, 0.08616626f, -0.14670235f, 
    0.00948831f, -0.00777151f, 0.09063120f, 0.02963966f, 0.05328715f, -0.02342679f, 0.10241234f, 0.16086648f, 
    -0.13106841f, 0.05921426f, 0.06422234f, -0.00041359f, -0.08420421f, 0.11053622f, -0.01406368f, 0.17744571f, 
    -0.03756762f, -0.06984283f, 0.00409935f, -0.07102925f, 0.17499761f, 0.07367654f, 0.06944545f, 0.04806409f, 
    0.14689969f, 0.07233480f, -0.00147162f, 0.04065600f, -0.06330299f, 0.12070639f, 0.06992679f, -0.15870568f, 
    -0.13583390f, 0.26665896f, 0.06238016f, 0.16458617f, 0.11489660f, 0.02348349f, 0.14940131f, -0.05810893f, 
    -0.02769799f, 0.02245803f, 0.01845746f, -0.01005217f, -0.11682805f, -0.09466709f, 0.01123439f, -0.13960668f, 
    0.06021819f, 0.08091027f, 0.09776309f, -0.16712148f, 0.07199052f, -0.04559729f, -0.14564942f, -0.15580726f, 
    0.17410946f, 0.04102467f, -0.28074905f, -0.00114850f, 0.03584340f, 0.04063932f, -0.02875153f, 0.04687531f, 
    0.02970853f, -0.02913513f, -0.01433024f, -0.12949006f, 0.27432778f, -0.09675976f, 0.03369884f, 0.27970919f, 
    -0.10207887f, 0.01939656f, -0.08988719f, 0.07830151f, -0.03305743f, -0.09293556f, 0.09450965f, 0.09619951f, 
    -0.01059939f, 0.09905408f, 0.08101162f, -0.19873008f, 0.07220314f, 0.04975834f, 0.07214674f, 0.02880241f, 
    0.09451415f, 0.08420498f, 0.06355590f, 0.00442436f, -0.05732051f, 0.21159567f, -0.05243968f, 0.00715223f, 
    -0.02035603f, -0.04757867f, -0.12717131f, 0.06908873f, 0.08729165f, 0.15353329f, 0.05639915f, 0.05145122f, 
    -0.01102856f, 0.16005726f, 0.11420485f, 0.17688259f, -0.06015056f, 0.09180465f, 0.03282881f, 0.00148334f, 
    0.11389317f, 0.04737734f, 0.02110047f, 0.05480343f, -0.09844421f, -0.10875040f, -0.14511351f, 0.13134272f, 
    -0.01940811f, -0.15773490f, -0.02504254f, -0.08518948f, -0.01157363f, -0.10320706f, 0.04105627f, 0.06662166f, 
    0.20779009f, 0.08495397f, 0.00471357f, -0.32022914f, -0.05217971f, 0.01041691f, -0.05236526f, 0.01966472f, 
    -0.06846918f, -0.04103193f, 0.00782402f, 0.07897177f, 0.00184903f, -0.03918881f, -0.05977299f, -0.07871865f, 
    0.05434008f, 0.02202429f, 0.03176312f, 0.23990752f, 0.02844315f, -0.02866625f, 0.04540043f, 0.15994993f, 
    -0.06097628f, 0.14180577f, -0.06395696f, -0.17268601f, -0.04650555f, -0.03286508f, -0.13643874f, -0.23088573f, 
    0.09053843f, -0.05596293f, -0.01487372f, -0.00611571f, -0.03078071f, -0.20627137f, -0.07617750f, -0.18893799f, 
    -0.04295354f, -0.09386755f, -0.04100131f, 0.11937366f, 0.08089625f, -0.04945336f, 0.08354200f, 0.03950109f, 
    0.05624598f, 0.06818338f, 0.02868268f, -0.25338632f, 0.01143434f, 0.12804282f, -0.04412045f, 0.04440411f, 
    0.00409693f, 0.08256658f, 0.03896308f, 0.08678231f, 0.14688389f, -0.10778989f, 0.13806443f, 0.15349457f, 
    -0.10284305f, -0.03539519f, -0.09012159f, 0.07736102f, 0.09768427f, 0.13690408f, 0.03732404f, 0.11096101f, 
    0.10602864f, -0.21725762f, 0.09912661f, 0.06856815f, 0.01825037f, 0.00590257f, 0.13901055f, 0.11888846f, 
    0.17076795f, -0.00990517f, -0.15813512f, -0.03998900f, -0.37631691f, 0.01453899f, 0.02857254f, 0.14905669f, 
    0.05107646f, -0.01939419f, -0.03170222f, -0.02667510f, 0.02157901f, 0.01569470f, 0.03696709f, -0.01849038f, 
    0.01059538f, 0.02749771f, 0.11647760f, -0.10379232f, 0.07353427f, -0.11284482f, 0.17277612f, 0.08047288f, 
    -0.05007660f, 0.04585901f, 0.09563878f, -0.03396059f, 0.00763818f, -0.15986538f, 0.07051696f, 0.15308799f, 
    0.17884642f, 0.09130684f, 0.00009051f, 0.07785691f, 0.03961177f, 0.02586148f, -0.05975737f, 0.08189616f, 
    0.21943513f, 0.04616735f, 0.07965121f, 0.11345810f, 0.01396959f, -0.00734159f, 0.23927176f, -0.03759858f, 
    0.03384611f, 0.08089128f, -0.09346184f, 0.04622097f, -0.14110190f, 0.11465519f, -0.08276613f, -0.03927803f, 
    -0.04138480f, 0.06660994f, 0.06436590f, 0.18308002f, 0.00883490f, 0.09378958f, -0.03362777f, 0.12418444f, 
    0.05739720f, -0.03779505f, -0.00736256f, -0.09861758f, -0.08289362f, 0.00742956f, -0.07295076f, -0.11352302f, 
    0.06035800f, -0.19567695f, -0.03855185f, -0.03847159f, -0.03741905f, 0.06263271f, -0.02740773f, 0.14741246f, 
    0.05137368f, 0.13616273f, 0.05194477f, 0.06603048f, 0.00699269f, 0.02823968f, -0.09635903f, -0.02384538f, 
    0.18856783f, -0.02929947f, 0.03782476f, -0.01966380f, 0.03508706f, 0.01874903f, 0.03947352f, -0.05838988f, 
    0.01050694f, -0.07459901f, -0.00745618f, -0.09659286f, 0.16775441f, 0.13963899f, 0.09006530f, 0.11582485f, 
    -0.07254761f, 0.06258763f, 0.09777055f, 0.07299571f, 0.11084392f, 0.08931904f, -0.04407109f, -0.08665622f, 
    0.09892333f, -0.27866352f, 0.05316689f, 0.09865451f, 0.13935801f, 0.03955682f, -0.00093144f, 0.08150963f, 
    0.00887817f, -0.02741724f, -0.05742459f, -0.03660630f, -0.12143420f, -0.09052617f, -0.17000777f, -0.05019094f, 
    -0.07313661f, -0.09480114f, 0.04695726f, 0.01571036f, 0.00911793f, 0.12520574f, -0.13536288f, -0.04596441f, 
    0.04069763f, -0.23244071f, -0.03422804f, -0.01476640f, -0.02687602f, 0.14727561f, -0.05439218f, 0.08976920f, 
    -0.01696560f, 0.04810689f, 0.12043728f, 0.13248302f, 0.16051091f, -0.10545683f, -0.03971272f, 0.00330880f, 
    -0.04568538f, -0.09860729f, 0.07253113f, 0.00280415f, 0.02954276f, 0.05028571f, -0.00776566f, 0.05626326f, 
    0.24108484f, 0.01185590f, 0.04590197f, -0.10067846f, -0.14162405f, 0.01458495f, -0.04465368f, -0.00376822f, 
    0.02156139f, 0.00202943f, -0.20597304f, 0.07682990f, 0.29440153f, 0.18651411f, 0.03390967f, -0.09273461f, 
    -0.00966863f, 0.07066059f, 0.09121569f, 0.04745841f, -0.07588342f, -0.08206680f, -0.02706965f, -0.14647560f, 
    -0.04114377f, 0.15225577f, 0.07837011f, 0.02055616f, -0.05473179f, 0.00290366f, 0.02135444f, -0.03022436f, 
    -0.06235201f, -0.01646371f, 0.14944687f, 0.02643735f, 0.00747689f, 0.17359173f, 0.06628424f, -0.04858771f, 
    -0.02961442f, -0.03380110f, 0.05486272f, 0.00358840f, 0.08159732f, -0.06275145f, 0.05120580f, -0.04062967f, 
    0.03343325f, -0.10167539f, -0.10053940f, -0.06641821f, -0.17087920f, 0.08481970f, -0.01581880f, 0.04146437f, 
    0.00948852f, -0.14547813f, 0.07651824f, 0.18581311f, -0.12288009f, 0.06304660f, -0.06802310f, 0.12029738f, 
    -0.09530310f, -0.22913931f, -0.02990941f, -0.03534744f, 0.04401289f, 0.03689993f, 0.18657777f, 0.05124319f, 
    0.02824961f, 0.02768686f, 0.02893327f, 0.01469750f, -0.05629394f, 0.04948292f, 0.00763111f, 0.04523197f, 
    0.05021232f, -0.03614274f, 0.00612987f, -0.05788118f, -0.02619431f, 0.02553998f, -0.06173192f, 0.00231481f, 
    -0.07074320f, -0.05148195f, 0.00517308f, -0.06630781f, -0.04752195f, 0.05353628f, -0.03528224f, 0.00374522f, 
    -0.00099722f, -0.02361496f, -0.02406291f, 0.02476788f, -0.04151703f, -0.04272743f, 0.02027555f, 0.05364354f, 
    -0.07436833f, 0.00753805f, -0.01245420f, -0.01626098f, 0.00076744f, -0.01653269f, 0.01317513f, -0.00231412f, 
    -0.04510660f, -0.03680416f, 0.00560144f, -0.07657391f, 0.01191078f, 0.00986855f, -0.02693198f, -0.05967240f, 
    -0.04484859f, -0.01230842f, 0.03226312f, -0.03513477f, -0.03702194f, 0.00403217f, -0.03959278f, 0.06428853f, 
    -0.02419783f, -0.04618552f, -0.00110261f, -0.00773318f, -0.02333792f, 0.02597237f, -0.05757322f, 0.02649106f, 
    -0.07645080f, 0.05357971f, 0.05278468f, 0.03986216f, 0.00017147f, -0.03115671f, -0.04753698f, -0.02265125f, 
    0.06429981f, -0.04664429f, -0.05970870f, -0.00408375f, -0.00519992f, -0.01033746f, -0.00756286f, -0.02969850f, 
    -0.03045353f, 0.03800353f, -0.00586606f, 0.04727139f, 0.00719964f, 0.01478992f, -0.01603633f, -0.06365429f, 
    -0.02117098f, -0.05793085f, -0.04937946f, -0.02208083f, -0.03380277f, -0.02012626f, -0.02181620f, 0.03243410f, 
    -0.00387273f, -0.07468618f, -0.02586858f, -0.05932332f, -0.05914658f, 0.02375227f, -0.07752580f, 0.01407321f, 
    -0.01140302f, 0.06196745f, -0.04311309f, -0.04479448f, -0.06550546f, -0.02562439f, 0.05189424f, -0.01242678f, 
    -0.03793703f, -0.03136931f, -0.01721117f, 0.05166004f, 0.04749353f, 0.00028839f, -0.02810296f, -0.01314116f, 
    -0.04231615f, -0.00141605f, -0.01344273f, -0.01746105f, 0.01109333f, -0.04085741f, 0.01843188f, -0.02566472f, 
    -0.06150839f, 0.01405052f, -0.04505871f, 0.01332207f, -0.05824547f, -0.02433627f, 0.03620261f, -0.03489803f, 
    0.00346938f, -0.07461120f, -0.07693614f, -0.04919169f, -0.06212200f, 0.06428453f, -0.04634648f, -0.04901065f, 
    0.00597732f, 0.01474272f, 0.00644650f, -0.06203901f, 0.02395935f, -0.06781773f, -0.03325672f, -0.07485705f, 
    0.00796870f, -0.02083469f, -0.02757997f, -0.00434343f, 0.01332240f, 0.06432030f, -0.03825121f, -0.04048026f, 
    0.03884386f, 0.04245106f, -0.04848148f, 0.04933406f, -0.04143376f, 0.00134684f, 0.05749424f, 0.05098121f, 
    0.05378823f, -0.00121945f, -0.01947968f, -0.06547324f, -0.02677689f, 0.02086702f, -0.05596614f, -0.03478454f, 
    0.05886912f, -0.05629504f, 0.01158331f, 0.06067989f, 0.01265728f, 0.06523832f, 0.01264903f, -0.00344846f, 
    0.05942362f, -0.07645257f, 0.03103020f, 0.04522906f, -0.01623050f, 0.02409017f, -0.00465194f, -0.02745109f, 
    -0.05242189f, 0.02430568f, -0.00572433f, -0.00043326f, -0.04839803f, -0.06981185f, -0.06112142f, 0.02634043f, 
    0.06879232f, -0.02122617f, 0.02936386f, 0.03383522f, -0.05195903f, 0.02093852f, -0.06608494f, -0.02178338f, 
    0.02253108f, -0.02642632f, -0.06760637f, 0.06404231f, 0.01902644f, -0.04014134f, -0.01205543f, -0.04129500f, 
    0.02016482f, -0.04015047f, -0.04791331f, -0.02224172f, -0.05216208f, 0.04282408f, -0.06972774f, -0.05044194f, 
    0.02756195f, 0.03703471f, -0.04998006f, -0.06291883f, 0.00150354f, -0.06900235f, -0.05128074f, -0.01711801f, 
    -0.04592141f, -0.01690974f, -0.01305766f, -0.00316401f, 0.05232481f, 0.01470387f, -0.03321914f, -0.03200225f, 
    0.01990953f, -0.07182909f, 0.06035629f, 0.00210278f, -0.00845487f, -0.07947805f, 0.00942559f, -0.00580929f, 
    -0.00073094f, -0.06724699f, 0.01323132f, -0.03726199f, 0.05617575f, -0.07710196f, 0.04787186f, 0.05943980f, 
    -0.02077036f, 0.05501486f, 0.01303461f, -0.05335801f, 0.01109334f, -0.05975628f, -0.05449787f, -0.07282256f, 
    -0.06929580f, -0.00158634f, -0.01500826f, 0.00842177f, -0.07400567f, -0.01678343f, 0.01416551f, 0.04351750f, 
    -0.00549012f, 0.02214142f, 0.02121599f, 0.04450316f, 0.01508438f, 0.04430810f, 0.00178151f, -0.05016985f, 
    -0.00121746f, 0.02687415f, -0.01262298f, -0.05383589f, -0.03376431f, 0.02010272f, 0.05181490f, -0.05014806f, 
    0.05893215f, 0.00392296f, -0.03787493f, -0.00265191f, -0.07850439f, -0.00803125f, -0.03188417f, -0.04868960f, 
    0.00918695f, -0.00434612f, 0.04559746f, -0.00125794f, -0.04127385f, 0.02623581f, 0.05309319f, 0.02154181f, 
    0.01419703f, -0.01828304f, 0.03281521f, 0.05382356f, 0.00318190f, 0.02470251f, 0.04746952f, 0.04844166f, 
    0.03961063f, 0.03324983f, 0.01730068f, -0.08390205f, -0.05426959f, -0.01466978f, -0.01733615f, 0.03213743f, 
    0.04889355f, -0.06353469f, -0.02603295f, -0.00303812f, 0.03275080f, -0.05560799f, -0.01934736f, 0.03364728f, 
    -0.05836242f, -0.01933614f, -0.01440551f, -0.07990533f, 0.00887809f, 0.05158390f, -0.00762784f, -0.06965966f, 
    -0.01512031f, 0.00077792f, -0.04180202f, -0.05520457f, -0.06580092f, 0.01587260f, -0.05309718f, 0.05287240f, 
    0.01469505f, -0.02458712f, -0.04075363f, 0.02828006f, 0.00578768f, 0.05925429f, 0.03036368f, -0.06881907f, 
    -0.03888832f, -0.07110664f, 0.01260424f, 0.04931261f, 0.04823448f, 0.04316181f, -0.06882896f, -0.06073102f, 
    0.04790798f, 0.00790150f, 0.04626609f, 0.04532275f, -0.06520683f, -0.06754366f, 0.02629755f, -0.02400063f, 
    -0.05763416f, -0.01738624f, 0.03926463f, 0.02143035f, 0.05840455f, -0.04499260f, -0.07672386f, 0.03431816f, 
    0.02597766f, -0.04670787f, -0.00947074f, -0.05397914f, 0.01114205f, -0.08391248f, 0.01562886f, -0.05847886f, 
    0.21250889f, -0.11631253f, -0.29700699f, 0.13244309f, 0.09378015f, 0.02732857f, -0.02305028f, 0.04315894f, 
    0.00584266f, 0.00648079f, 0.01332135f, 0.06445394f, 0.31394169f, -0.27408347f, 0.08000462f, 0.15243271f, 
    0.01189408f, 0.09569041f, 0.05055575f, 0.02989643f, -0.01307052f, 0.05582336f, 0.09467452f, -0.00786969f, 
    -0.08948629f, 0.12721570f, -0.00886086f, -0.06055686f, 0.02544069f, 0.03880612f, 0.05554638f, -0.06894042f, 
    -0.06895121f, 0.05380292f, 0.00674582f, -0.03010743f, 0.20344180f, 0.07819650f, -0.12543927f, -0.00136423f, 
    -0.04067018f, -0.09622899f, -0.07135454f, 0.14172947f, -0.06182732f, 0.14808509f, 0.04372517f, -0.07834531f, 
    -0.21570005f, 0.18791249f, 0.10893662f, -0.00692663f, 0.02808025f, 0.06656446f, 0.08427107f, -0.02804306f, 
    0.04738072f, 0.06517863f, -0.04532694f, 0.03787402f, -0.05623366f, 0.12797314f, -0.11771727f, 0.07535812f, 
    0.02296397f, 0.06123215f, -0.03671386f, -0.07694633f, -0.02337665f, -0.15189514f, -0.03838504f, -0.01431206f, 
    0.18158148f, -0.01868160f, 0.00876823f, -0.07881192f, 0.10858905f, -0.08349289f, 0.09811155f, -0.03229233f, 
    -0.08126235f, 0.07230470f, 0.16377841f, -0.06171149f, 0.19904095f, 0.04927978f, 0.01268789f, 0.00073844f, 
    -0.08540250f, -0.11028208f, 0.00248335f, 0.07004379f, -0.12679376f, -0.06988032f, 0.01512122f, -0.06672353f, 
    0.23933975f, 0.07117631f, -0.08918526f, -0.01157726f, -0.06221347f, 0.04173182f, -0.02981228f, -0.08640093f, 
    -0.05487866f, 0.13938397f, -0.09360839f, 0.05949818f, -0.04096239f, -0.18635865f, -0.08494359f, -0.17998168f, 
    0.00569571f, -0.05317491f, 0.11563797f, 0.10423303f, 0.09626330f, -0.04300505f, -0.00549697f, 0.00362265f, 
    -0.00500561f, -0.08975415f, -0.11152661f, -0.05699074f, -0.02150461f, 0.09132665f, -0.02638394f, 0.00176942f, 
    -0.00933012f, 0.03633337f, -0.02812746f, -0.01700821f, -0.10187914f, -0.14910279f, 0.09983449f, 0.20145008f, 
    0.09955726f, 0.04618426f, 0.01294597f, 0.03654290f, 0.05750572f, 0.08949491f, 0.02330355f, -0.00102136f, 
    0.15692374f, 0.23629050f, 0.08149678f, -0.07611675f, 0.10368937f, 0.01149028f, 0.15704988f, 0.08413883f, 
    0.05600509f, 0.00120978f, 0.01105422f, 0.09254760f, 0.04674679f, 0.08198253f, -0.12755577f, 0.05553197f, 
    0.00827923f, -0.01851088f, 0.02738655f, 0.03376759f, 0.04650948f, -0.03908705f, -0.00567719f, 0.10348808f, 
    0.14337572f, 0.01109794f, -0.05993685f, -0.09558272f, 0.02996067f, 0.02224340f, 0.16872430f, -0.05005870f, 
    -0.07070520f, 0.09503458f, 0.18553416f, -0.07437061f, 0.26342884f, -0.06034029f, 0.07540776f, -0.03611998f, 
    0.01691860f, -0.14653085f, -0.01185701f, 0.10050236f, 0.09707303f, 0.01486979f, -0.01631851f, 0.11458981f, 
    -0.07613748f, 0.01362462f, 0.05139209f, 0.02027177f, -0.00513280f, 0.02537101f, 0.03538483f, -0.01013493f, 
    -0.00188618f, 0.04513934f, -0.03742798f, 0.02072424f, -0.06851958f, -0.05645785f, 0.01106793f, -0.02782335f, 
    0.01747979f, 0.05551719f, -0.02864005f, -0.01857793f, 0.01703466f, 0.00317981f, -0.02647454f, 0.03937244f, 
    0.03777960f, 0.03092687f, 0.00323615f, -0.00261427f, -0.06827562f, 0.05348036f, -0.04944295f, -0.05350673f, 
    -0.07214158f, -0.06421201f, 0.02885934f, 0.02739512f, 0.00530736f, -0.04439180f, 0.00884577f, -0.01807481f, 
    -0.02179427f, -0.00292322f, -0.03973728f, 0.03182714f, 0.02904938f, 0.00619710f, -0.05661072f, 0.06692562f, 
    0.02428855f, -0.00534437f, 0.02175813f, 0.06069865f, -0.04502467f, 0.02751021f, -0.02908889f, -0.04110432f, 
    -0.07654961f, 0.02895712f, -0.06554791f, 0.04209717f, -0.01765973f, 0.04919391f, -0.05508109f, 0.03764549f, 
    0.04053517f, -0.04307542f, 0.00333377f, 0.01913248f, 0.03677126f, -0.05060182f, 0.02189900f, -0.01249627f, 
    -0.02368409f, -0.00670902f, -0.07602653f, 0.01244904f, 0.00902490f, -0.00739595f, -0.04453569f, 0.06575293f, 
    -0.00653371f, 0.01268139f, -0.06564153f, -0.03496850f, -0.00411360f, 0.02969292f, 0.00105676f, -0.00405221f, 
    -0.04931859f, 0.00142306f, 0.03285089f, -0.02986665f, -0.07767268f, 0.01684903f, 0.05666237f, -0.03038815f, 
    0.03810529f, -0.05743036f, -0.04694119f, 0.03865858f, -0.04423396f, -0.04440333f, -0.05806708f, -0.03063843f, 
    0.04635677f, 0.02792062f, -0.04739272f, -0.00068888f, -0.04635479f, 0.04165474f, -0.04073770f, -0.00008995f, 
    -0.06594881f, 0.01955769f, -0.02326915f, -0.06324770f, -0.05913896f, 0.02829255f, -0.07167370f, -0.03062817f, 
    0.05546561f, 0.04075674f, 0.05042665f, -0.06923615f, -0.03632037f, 0.04135472f, -0.00028755f, -0.05279161f, 
    0.00520710f, 0.01317763f, 0.00019633f, -0.01288959f, 0.06509773f, -0.07122285f, -0.07376805f, 0.05747377f, 
    0.02947256f, -0.05891071f, -0.07947006f, -0.04702008f, 0.07257879f, -0.06379171f, 0.04950661f, -0.05927098f, 
    0.00086281f, -0.07033989f, -0.05124308f, -0.05913312f, 0.02964474f, -0.06853037f, -0.01244271f, -0.06499415f, 
    -0.07950377f, 0.01736950f, 0.04488981f, 0.01376797f, 0.01665675f, -0.03575028f, -0.03582618f, 0.04501348f, 
    -0.04490581f, -0.07229743f, -0.04613552f, -0.05992928f, 0.01908511f, 0.00306032f, 0.01439294f, -0.06746252f, 
    -0.02720336f, -0.07129143f, -0.00312965f, 0.00356651f, 0.05479824f, 0.03540630f, 0.02323972f, -0.06295412f, 
    0.04122530f, 0.00827119f, 0.01003299f, -0.07955365f, 0.01283363f, 0.04636721f, 0.04760586f, 0.04926344f, 
    0.03060381f, -0.05786613f, 0.01356874f, -0.05161419f, -0.05656223f, -0.00539699f, -0.05986145f, -0.05306089f, 
    0.06590930f, 0.01345728f, -0.15676728f, -0.08053347f, -0.07462705f, 0.06870606f, 0.04843596f, 0.07260250f, 
    0.01060842f, 0.00664698f, -0.00873428f, 0.02565778f, -0.01963534f, -0.25132990f, -0.16624290f, -0.21598421f, 
    0.08598003f, 0.06324645f, 0.05091133f, 0.09322011f, 0.07539582f, 0.06094708f, -0.01105965f, -0.03640728f, 
    -0.08614960f, 0.01920870f, 0.07958001f, 0.08753821f, 0.00357812f, 0.06136330f, 0.02281202f, 0.17075244f, 
    0.04403942f, -0.08646125f, 0.09589951f, 0.12658580f, 0.29023284f, 0.28863928f, -0.22670434f, 0.08484112f, 
    0.06105043f, 0.03038682f, -0.02186490f, 0.17555217f, 0.11990135f, 0.12850748f, 0.02345422f, 0.03868250f, 
    0.10535443f, -0.21691178f, 0.08510028f, 0.21008520f, -0.04190945f, 0.08193588f, 0.11065155f, 0.16245106f, 
    -0.03840436f, 0.02962503f, 0.16759570f, 0.15163405f, 0.04020164f, 0.20951971f, -0.01331524f, 0.01286238f, 
    0.09726629f, 0.12078412f, 0.10097118f, -0.16096984f, -0.07040145f, -0.17300476f, -0.07415104f, 0.17371805f, 
    -0.06868058f, -0.58327174f, 0.22516128f, -0.06314290f, 0.09815519f, -0.03526637f, 0.08910719f, -0.03837457f, 
    0.03903324f, 0.07151533f, 0.10397521f, -0.03348256f, 0.13636680f, 0.26527241f, -0.27303275f, -0.07102647f, 
    -0.08626828f, 0.02981332f, 0.10292720f, 0.00974700f, 0.10977721f, 0.02852779f, -0.01141094f, -0.06519205f, 
    -0.17081502f, -0.07819624f, -0.23245910f, -0.25481609f, -0.14291136f, 0.12437562f, -0.12579063f, -0.06630559f, 
    -0.08315536f, 0.01081753f, -0.16816016f, -0.09027666f, 0.20311369f, -0.10708628f, -0.25797057f, -0.07638100f, 
    -0.04754559f, -0.10130472f, 0.10981718f, -0.12899803f, -0.06851608f, 0.00918383f, 0.07082501f, 0.03455682f, 
    0.08815259f, -0.09782799f, -0.00852175f, 0.09640463f, -0.13392615f, 0.13354284f, 0.07601275f, 0.00268092f, 
    -0.05338020f, -0.12054051f, -0.04791126f, 0.04303043f, -0.02288902f, -0.28254175f, 0.14652146f, -0.04981069f, 
    0.12988435f, 0.09854930f, 0.05626331f, 0.07311136f, 0.16885445f, 0.08905535f, 0.04762970f, 0.02406023f, 
    0.27935261f, 0.19400473f, 0.12474411f, 0.14850792f, 0.05058249f, 0.05890154f, 0.05176839f, 0.10446914f, 
    0.10345069f, -0.08280152f, -0.05942881f, 0.03412486f, 0.01843752f, 0.22459057f, 0.01294241f, 0.14100270f, 
    0.03067727f, 0.08533691f, 0.02333236f, 0.02473027f, 0.05267336f, -0.13456880f, 0.05751605f, 0.20342845f, 
    0.37989157f, -0.02048726f, 0.07444129f, 0.23487851f, -0.10622194f, 0.05467656f, -0.12012003f, -0.03611087f, 
    0.09501479f, 0.06096061f, 0.05839166f, 0.01584815f, 0.29924798f, -0.25383997f, 0.00034298f, 0.10731166f, 
    0.11393763f, -0.25006208f, 0.18546365f, -0.03882793f, 0.20176953f, 0.01131517f, 0.03763507f, 0.01454781f, 
    -0.42230320f, -0.38733876f, 0.19508825f, 0.01546851f, -0.15046617f, -0.02771908f, -0.09397561f, -0.00900260f, 
    -0.00248631f, -0.00583789f, -0.11050583f, 0.08343551f, 0.06799603f, 0.28481519f, 0.12512015f, -0.06778070f, 
    0.10167197f, 0.10137776f, -0.00318334f, -0.04407846f, 0.01208491f, 0.02587338f, 0.04974957f, -0.01421167f, 
    -0.11945131f, 0.04988420f, -0.03537964f, 0.16055827f, 0.06178418f, 0.09379683f, 0.07831226f, 0.13110280f, 
    0.07934571f, -0.00727702f, -0.03863683f, 0.14794780f, 0.17109990f, -0.10848666f, 0.05747872f, -0.00779350f, 
    0.15479903f, 0.05991070f, 0.06423956f, -0.04901018f, 0.01140482f, 0.14207347f, 0.01216989f, -0.05378849f, 
    0.36429632f, 0.03585121f, 0.11890132f, 0.01482415f, -0.01719974f, 0.11877229f, -0.03035958f, -0.04061535f, 
    0.04178927f, 0.04183231f, 0.09754056f, 0.11793734f, 0.08059343f, 0.11519741f, 0.17021711f, -0.09033819f, 
    0.10582351f, -0.10971985f, -0.11631240f, -0.00965001f, 0.00074741f, -0.02117147f, -0.02375923f, 0.10980064f, 
    0.17588055f, -0.00420131f, 0.23035659f, -0.29045844f, 0.00277889f, 0.03700570f, -0.08852810f, 0.02406351f, 
    0.01419116f, 0.02203736f, 0.09237476f, -0.08598753f, 0.07671945f, 0.02317526f, -0.15934104f, 0.05939541f, 
    0.18766440f, 0.19120589f, 0.08707107f, 0.10855481f, 0.04467527f, 0.05075295f, -0.00466902f, -0.02582221f, 
    0.01017855f, -0.31650990f, -0.08155750f, 0.02331807f, -0.01328752f, -0.05303650f, 0.14157680f, -0.04422258f, 
    -0.03772573f, 0.19751388f, -0.06286292f, -0.04205108f, -0.03302291f, 0.20812923f, 0.10451952f, -0.16617343f, 
    0.07008018f, 0.09932133f, -0.06753941f, -0.04549674f, 0.12959152f, -0.04778741f, 0.09423199f, -0.11340107f, 
    -0.46907109f, -0.25554067f, 0.10836110f, -0.18444839f, -0.15220669f, -0.00878335f, 0.01276660f, -0.10031708f, 
    0.07115655f, -0.06420383f, 0.20283455f, 0.01983243f, 0.14279780f, 0.15633199f, -0.08533878f, -0.00258579f, 
    -0.04371111f, -0.09138943f, -0.06391535f, -0.00089294f, 0.01164811f, 0.09366374f, -0.04803892f, 0.07824545f, 
    0.16998044f, 0.10402181f, 0.20725647f, 0.01315026f, -0.05033004f, 0.03177017f, 0.11298019f, 0.01044270f, 
    -0.02528074f, -0.10873990f, -0.03745693f, -0.00660282f, 0.10953663f, -0.08860874f, 0.15389836f, -0.09062661f, 
    -0.04256061f, 0.00877791f, -0.17916265f, 0.02846898f, -0.01554893f, 0.01476927f, 0.04250928f, 0.17263423f, 
    -0.02194542f, -0.15418574f, 0.01080760f, 0.21767496f, 0.12149560f, 0.08472853f, 0.09820654f, -0.01241784f, 
    -0.02114188f, 0.07140558f, -0.01828993f, 0.00060158f, -0.06909136f, 0.00347039f, -0.04033584f, 0.04722280f, 
    0.20577088f, 0.12708633f, -0.03952492f, 0.03061746f, 0.05904208f, 0.03703547f, -0.11830685f, 0.10042218f, 
    0.02298896f, -0.05066102f, 0.16378281f, -0.06896605f, -0.00278667f, 0.07400841f, 0.16911216f, 0.02167879f, 
    -0.05510982f, 0.08337708f, -0.07478280f, -0.01651966f, 0.14525719f, 0.15523320f, 0.00872965f, -0.12762429f, 
    -0.12114789f, 0.01699764f, 0.12334520f, 0.16826561f, -0.04441667f, 0.10139161f, -0.03314365f, 0.07090675f, 
    0.20808902f, -0.05020116f, 0.00032879f, -0.03138676f, -0.02924628f, -0.08171225f, -0.04026331f, 0.04620607f, 
    -0.06353437f, -0.15675797f, -0.01378543f, -0.00714382f, -0.11604641f, -0.02562699f, 0.12985767f, 0.20869130f, 
    -0.10595598f, 0.03330882f, 0.09866416f, -0.06522708f, -0.01817292f, -0.03540171f, -0.02947182f, 0.07183620f, 
    0.07353761f, -0.11622117f, -0.03200319f, 0.04612391f, 0.02127971f, -0.05827983f, -0.00516427f, -0.07057910f, 
    -0.05171309f, 0.05215366f, 0.03246205f, -0.15879188f, 0.23979613f, -0.04204660f, 0.02517344f, -0.01371765f, 
    -0.14476506f, 0.15645689f, 0.12271170f, 0.10441807f, 0.11698363f, 0.04409420f, -0.00931922f, -0.07157400f, 
    -0.06259812f, -0.32612157f, -0.06534500f, 0.07455462f, 0.13583592f, -0.01331823f, -0.00892490f, -0.09154234f, 
    -0.03245234f, 0.01309250f, -0.05564981f, -0.05277466f, -0.03201943f, -0.00016651f, 0.04324204f, 0.04861243f, 
    -0.12696411f, 0.05970330f, 0.02789010f, -0.11342881f, 0.00276869f, 0.06385382f, 0.02762373f, -0.09748501f, 
    -0.20492673f, 0.08552358f, 0.01438442f, 0.21582337f, -0.05984161f, 0.06113991f, -0.06235046f, 0.26796043f, 
    -0.02107562f, 0.07454254f, 0.14329568f, 0.10271675f, 0.10620730f, 0.06507539f, -0.16104670f, 0.18854150f, 
    -0.09462023f, -0.17026541f, -0.07468557f, 0.00877629f, -0.06932227f, -0.01447263f, -0.08627058f, 0.04342391f, 
    0.16134706f, 0.15467267f, -0.00000103f, 0.01717784f, 0.03039386f, 0.14979057f, 0.05420459f, 0.02051186f, 
    0.02079316f, 0.01807665f, -0.07335193f, 0.08957801f, 0.03919263f, 0.19275403f, 0.05716516f, 0.00725779f, 
    0.09606621f, 0.09914698f, 0.05360348f, 0.07983070f, 0.00516874f, -0.13460855f, -0.13766223f, -0.16575177f, 
    -0.00698511f, -0.04973730f, -0.17576943f, 0.09406637f, -0.05188108f, -0.05292809f, 0.00944120f, -0.04290655f, 
    -0.06950445f, 0.00601075f, -0.01360865f, 0.10407663f, 0.08003443f, -0.04637899f, 0.01685251f, 0.04790776f, 
    -0.10958618f, -0.02236035f, 0.12022307f, -0.08961003f, -0.03737841f, 0.12026171f, -0.04813431f, 0.03937079f, 
    0.03372080f, -0.02844560f, -0.12662248f, 0.04791913f, -0.13030864f, 0.05498464f, -0.14636239f, 0.15879142f, 
    0.05465692f, -0.02441892f, -0.06244551f, 0.02262787f, -0.10546838f, 0.16894609f, -0.04733035f, 0.12034317f, 
    -0.09573737f, -0.13097852f, -0.07420793f, 0.08916981f, 0.00858955f, 0.16118701f, 0.19178009f, 0.03527891f, 
    -0.09940474f, 0.07658367f, 0.17850107f, 0.25649786f, 0.14927670f, -0.04798681f, 0.04291113f, 0.03401468f, 
    0.02780747f, 0.07218687f, 0.07488235f, 0.09905026f, -0.25236022f, 0.22413398f, 0.07730155f, -0.20573947f, 
    -0.10840681f, -0.09532629f, 0.00506461f, -0.00318099f, 0.10790932f, 0.04054023f, 0.08471414f, 0.01966888f, 
    0.05541355f, -0.12491547f, -0.08257947f, -0.00547054f, 0.06017135f, -0.07779893f, 0.12576087f, -0.15836637f, 
    -0.14848232f, -0.12395993f, 0.04156495f, -0.07972090f, -0.04714304f, -0.12709503f, 0.02670921f, 0.00048799f, 
    0.00653038f, 0.11224234f, -0.07100572f, 0.01083423f, 0.02801550f, 0.03301762f, -0.07188067f, 0.02702368f, 
    -0.30549908f, -0.02699919f, -0.10316632f, -0.02774113f, 0.15618925f, -0.15059617f, -0.05071780f, 0.00143140f, 
    -0.04830178f, 0.01246302f, 0.07717911f, -0.03970573f, -0.08660595f, 0.15546958f, 0.15006891f, -0.03049994f, 
    0.15806811f, 0.06934907f, 0.07878066f, -0.11777553f, 0.04972634f, 0.04981842f, -0.06203419f, -0.07160071f, 
    -0.11203634f, -0.15640552f, -0.17660201f, 0.45259702f, 0.10973128f, 0.05439941f, 0.07835789f, 0.04049573f, 
    0.10769939f, -0.03313569f, 0.00447522f, -0.10663097f, -0.08753821f, 0.03002903f, -0.11852421f, -0.11987983f, 
    -0.15588868f, -0.10453683f, -0.03969220f, -0.09336073f, -0.06837764f, -0.03464781f, -0.12812825f, 0.05224287f, 
    0.05432906f, -0.12349727f, -0.13981390f, 0.14186567f, -0.06684339f, -0.12053565f, -0.06927151f, -0.01446159f, 
    0.01515955f, 0.01020928f, 0.04302597f, 0.12889180f, 0.24218062f, -0.01969179f, 0.07766977f, 0.03598189f, 
    -0.02738349f, -0.01499404f, 0.16966005f, 0.06547348f, 0.10298489f, 0.09938873f, -0.02895787f, 0.14107120f, 
    0.30141249f, 0.05988722f, 0.01477766f, 0.06465300f, 0.10016487f, -0.02871428f, -0.01226745f, -0.03926551f, 
    -0.02830240f, -0.02650894f, -0.12868117f, 0.05716301f, -0.06198332f, 0.12956046f, 0.20063713f, -0.35933053f, 
    -0.01760711f, 0.19206460f, 0.01231212f, 0.08525531f, -0.12458006f, -0.02808505f, 0.02558197f, -0.06414612f, 
    -0.40825078f, 0.18596780f, 0.11423620f, 0.04273145f, 0.05075842f, 0.10606444f, -0.07324828f, 0.03270484f, 
    -0.04026560f, 0.02803675f, 0.19685395f, 0.11095829f, 0.03037049f, 0.19104384f, 0.05385530f, -0.15356588f, 
    0.13794033f, -0.00284958f, 0.14324933f, -0.10585202f, 0.03127191f, 0.17497112f, -0.04872211f, 0.01127963f, 
    -0.05042240f, 0.07633465f, -0.15336819f, -0.12282563f, -0.16568677f, -0.05226668f, 0.20818037f, 0.17773192f, 
    0.05037287f, 0.06057491f, 0.06699301f, 0.17746289f, -0.02082951f, -0.15912510f, 0.04557106f, -0.23811594f, 
    -0.18999767f, -0.16670437f, 0.07752476f, -0.09296105f, 0.04228521f, -0.01956366f, 0.26338300f, -0.06927211f, 
    0.03375585f, 0.02780385f, -0.06515867f, -0.05877691f, -0.04495685f, 0.00230373f, -0.01136162f, -0.05289263f, 
    0.05723536f, 0.02131691f, 0.03074589f, 0.03618778f, -0.06477655f, -0.04152219f, -0.02219184f, -0.04116819f, 
    -0.04373198f, 0.04164299f, -0.04534636f, -0.01441030f, 0.04050581f, -0.02170624f, -0.03512363f, 0.03607204f, 
    -0.04668977f, -0.06487836f, -0.07575180f, 0.00316839f, -0.02188219f, 0.01805951f, -0.06421196f, -0.04661245f, 
    -0.03452645f, 0.04029933f, -0.01333678f, -0.07191242f, -0.04407344f, 0.06332697f, -0.06696627f, -0.03971956f, 
    -0.01414814f, -0.03292094f, -0.04164170f, -0.01711593f, -0.04315630f, 0.01764993f, -0.02906987f, -0.06047366f, 
    -0.06423283f, -0.03966396f, 0.04491831f, 0.02226371f, -0.02137313f, 0.02553617f, 0.04985637f, 0.00739516f, 
    0.02870169f, -0.07518205f, 0.01059944f, 0.01451866f, 0.01050981f, 0.02305087f, 0.02705335f, 0.05778870f, 
    -0.04157509f, 0.02269723f, 0.02566131f, -0.02688854f, 0.03222831f, 0.00858534f, 0.02129915f, -0.01220771f, 
    -0.03378964f, -0.02130579f, 0.06421927f, 0.06171896f, -0.06711186f, -0.07099193f, 0.05157951f, -0.04479766f, 
    -0.05491413f, -0.02233111f, -0.02685754f, 0.03363816f, -0.04008715f, 0.03836213f, -0.07088700f, -0.05190561f, 
    -0.06584552f, -0.00180840f, -0.03921539f, 0.02440990f, -0.07542631f, 0.00652838f, 0.00404436f, 0.02820437f, 
    -0.06796612f, -0.06468955f, 0.00790608f, 0.01686190f, 0.04171847f, -0.05554867f, -0.06035570f, -0.00810787f, 
    0.05479112f, -0.05584043f, -0.05692270f, 0.04384235f, 0.00285467f, 0.06556654f, 0.03856119f, -0.06722075f, 
    -0.01884837f, -0.02043264f, -0.02011772f, 0.06281725f, 0.06722224f, -0.01065311f, -0.06152534f, -0.00017852f, 
    0.06007718f, -0.00840052f, -0.06101930f, -0.02172487f, -0.01964551f, -0.00861688f, -0.01712658f, 0.03810583f, 
    0.02367576f, -0.01541312f, 0.03654859f, -0.06009819f, -0.05077137f, -0.07601947f, -0.00032389f, 0.02206397f, 
    -0.04380973f, 0.01268721f, 0.03845408f, 0.03312213f, 0.05897307f, 0.01752988f, -0.06238486f, 0.03559682f, 
    -0.00175531f, -0.03201262f, -0.07695908f, -0.03582830f, 0.02164006f, -0.01259778f, -0.05355227f, -0.07062948f, 
    -0.03898394f, -0.04868039f, -0.01342491f, 0.03043415f, 0.06411465f, 0.01418842f, -0.05767901f, -0.02289602f, 
    -0.01452240f, 0.01769755f, 0.05203833f, 0.04114501f, -0.07467884f, 0.06329602f, 0.06554130f, -0.01404627f, 
    -0.06689966f, -0.04039500f, 0.00778636f, -0.05487502f, -0.02268754f, 0.04777036f, -0.02234516f, -0.06687583f, 
    0.06758255f, -0.01596062f, -0.03832333f, 0.04961631f, -0.01799995f, 0.00057501f, -0.07043809f, 0.01340015f, 
    0.05968180f, -0.01162465f, 0.03040016f, 0.01694157f, -0.01138471f, -0.02055391f, -0.00142328f, -0.03098427f, 
    -0.24690193f, -0.03703936f, 0.15980448f, 0.00329583f, -0.06914390f, -0.01461890f, 0.06715899f, 0.16381960f, 
    0.05872719f, 0.10785846f, 0.05617695f, 0.06975383f, -0.03992987f, 0.10092974f, -0.00355965f, -0.11856589f, 
    -0.09291594f, 0.03921814f, 0.04681271f, 0.05436810f, 0.03342751f, 0.10701264f, -0.04826466f, -0.00856696f, 
    -0.01047325f, 0.03730913f, 0.05692925f, 0.17162266f, -0.11064696f, -0.05298136f, 0.00035262f, -0.04379096f, 
    -0.05517626f, -0.20122607f, 0.15650444f, -0.00104378f, -0.21706419f, 0.11974563f, -0.03552011f, 0.01059779f, 
    0.01177931f, 0.06539475f, 0.14533696f, 0.08018917f, -0.01624840f, -0.01647976f, -0.03269226f, -0.01465743f, 
    0.19012104f, -0.05258236f, 0.05632721f, 0.13969830f, -0.04379741f, -0.01445961f, 0.02429811f, 0.00782740f, 
    0.04231942f, 0.07478091f, 0.01404223f, -0.03040407f, 0.10145984f, 0.07908984f, 0.01994312f, -0.08120724f, 
    0.05035910f, 0.06583292f, 0.08199392f, -0.11038523f, -0.02959364f, -0.06116760f, -0.02116093f, 0.04155404f, 
    -0.18148673f, -0.37803003f, -0.10617516f, 0.15183721f, 0.14137831f, 0.04013206f, 0.04089693f, 0.02007413f, 
    0.00873595f, -0.03636051f, -0.05310818f, -0.08316533f, 0.10905953f, 0.33108979f, -0.13102403f, 0.11071782f, 
    0.03587539f, 0.04204816f, 0.04533289f, -0.06717722f, 0.05980488f, 0.12805109f, -0.03077736f, -0.05378339f, 
    -0.33520332f, -0.01735519f, -0.19296497f, 0.04908059f, -0.13221386f, 0.09335797f, -0.01116566f, 0.01317877f, 
    -0.05418619f, 0.00087099f, 0.07381590f, -0.01097598f, 0.39821693f, 0.06096943f, -0.17702083f, 0.01394639f, 
    -0.10995883f, -0.00691280f, -0.00794135f, -0.06225988f, 0.04043377f, -0.04796022f, 0.10792556f, 0.03677259f, 
    0.08826748f, 0.03065841f, 0.18008333f, 0.29593462f, 0.00536043f, -0.01686515f, 0.04654425f, 0.11111276f, 
    0.00621284f, 0.02642926f, -0.10926902f, -0.00140251f, 0.28412920f, 0.02395758f, 0.19053142f, -0.11554305f, 
    0.06172209f, 0.10611943f, 0.04226944f, -0.11157522f, 0.04082957f, -0.03410443f, 0.01930409f, -0.04656119f, 
    -0.00534814f, 0.03203486f, -0.09239236f, 0.24940045f, -0.08630850f, 0.04410384f, -0.08735970f, 0.07703870f, 
    -0.01229337f, 0.00642519f, 0.04766068f, 0.11304487f, 0.07425307f, 0.11636835f, 0.17964138f, 0.06060604f, 
    0.06712023f, -0.08514883f, -0.02655245f, 0.01011580f, 0.03211527f, 0.04587443f, 0.05145051f, -0.00330331f, 
    0.28544405f, 0.03503850f, -0.00381845f, 0.27959967f, -0.04164204f, 0.04303914f, -0.05801111f, 0.07608854f, 
    0.04353136f, 0.08588581f, 0.03715637f, 0.08438463f, 0.06907175f, -0.00007003f, -0.01563769f, -0.10325743f, 
    0.00426989f, -0.01629064f, 0.08030982f, 0.01384927f, 0.09098010f, 0.04879375f, 0.15355210f, -0.02116993f, 
    0.01703715f, 0.32234550f, 0.16944224f, -0.10085908f, -0.06236149f, 0.11187766f, -0.01022439f, -0.06439275f, 
    0.12048485f, -0.03537939f, 0.02823474f, 0.05120597f, -0.28167021f, -0.15229826f, -0.10590622f, -0.12374922f, 
    -0.00517951f, -0.03029119f, -0.00136214f, -0.02795862f, 0.05975226f, -0.02648366f, -0.04436641f, -0.13060103f, 
    0.05185958f, -0.03619603f, 0.18099774f, 0.12391522f, -0.10573520f, 0.07395744f, 0.02705674f, 0.09248846f, 
    0.09832837f, -0.04610625f, 0.10931554f, -0.02318158f, -0.26438940f, 0.16467594f, 0.07735701f, 0.04272619f, 
    0.01842034f, 0.05281490f, 0.17247824f, 0.02107399f, 0.05673538f, -0.04656532f, 0.05030588f, 0.03710580f, 
    -0.05090458f, -0.11196848f, -0.01741506f, 0.21732531f, 0.02492180f, -0.07109427f, 0.01664684f, 0.14498261f, 
    0.01393430f, 0.01937059f, 0.06199173f, 0.02041167f, -0.02501311f, 0.04348839f, 0.01351316f, -0.06356536f, 
    0.04606016f, -0.12845714f, 0.06490356f, 0.05183047f, 0.06284401f, 0.04408156f, 0.06163216f, 0.19680171f, 
    -0.36023802f, -0.20037131f, -0.14532119f, 0.24390855f, 0.03191924f, 0.10401504f, 0.01364896f, 0.03966236f, 
    0.12181480f, 0.01929473f, -0.09435571f, 0.05251870f, -0.01156468f, 0.29383028f, 0.01799911f, -0.03558911f, 
    0.11099544f, 0.10199212f, 0.03467442f, -0.00837444f, 0.14555527f, 0.04017510f, 0.02569568f, 0.07314488f, 
    0.02054194f, 0.02863055f, -0.02596757f, -0.02922306f, 0.06997623f, 0.03570534f, 0.06511038f, 0.11649297f, 
    -0.01111880f, -0.04959865f, -0.03015623f, 0.00024953f, 0.19986975f, 0.00113007f, -0.11036564f, 0.10616703f, 
    0.01827657f, 0.12592086f, -0.00454296f, -0.15861227f, -0.14249636f, -0.07827649f, 0.02623078f, 0.01212147f, 
    0.22747146f, 0.28714594f, 0.10182664f, 0.40432930f, 0.13029924f, -0.09203600f, 0.08157390f, 0.10509250f, 
    0.00742112f, 0.04805312f, 0.03263723f, -0.06926276f, -0.04567939f, -0.20022421f, 0.02712887f, -0.14733990f, 
    -0.06102699f, -0.01634440f, 0.09281521f, -0.03366175f, 0.13267037f, 0.03296186f, 0.13840698f, 0.08140368f, 
    -0.13058783f, -0.16184792f, -0.04546087f, 0.04565505f, -0.06140308f, -0.01907124f, -0.12089808f, -0.01797169f, 
    0.01898163f, 0.06597209f, -0.04683184f, -0.14967084f, -0.13545418f, 0.02823539f, 0.06644399f, 0.06243955f, 
    0.03987864f, 0.01071417f, 0.06671909f, 0.08415689f, -0.06957393f, 0.14048709f, -0.04024306f, -0.06802277f, 
    0.13471349f, 0.14582385f, 0.08238003f, 0.38854134f, -0.02437071f, 0.04087164f, -0.03763189f, -0.01487446f, 
    -0.04050475f, -0.01427398f, -0.11391360f, 0.01877298f, 0.06268697f, 0.17832750f, -0.00094207f, 0.00952898f, 
    -0.01847076f, 0.22952557f, 0.16327569f, -0.04964274f, -0.09417145f, -0.03625759f, 0.04739417f, -0.09568059f, 
    0.13983172f, -0.12253439f, -0.15227570f, 0.10097706f, 0.05850636f, 0.07813741f, -0.13247788f, 0.08753947f, 
    0.07668856f, 0.01916461f, 0.03358859f, 0.10301088f, 0.27557471f, 0.00678111f, 0.09882915f, 0.19856553f, 
    0.01050084f, -0.06029475f, -0.04510306f, -0.07430732f, -0.02725158f, -0.10062893f, 0.08720363f, -0.06178663f, 
    0.12104616f, 0.12998483f, -0.20493867f, -0.35115919f, 0.04496235f, -0.09087267f, 0.00932470f, -0.00396181f, 
    0.01961037f, 0.03292004f, -0.03334065f, 0.08422463f, 0.10961404f, 0.09501758f, 0.00233322f, 0.04752934f, 
    -0.11854085f, -0.16001390f, 0.03336119f, -0.07455180f, 0.19533293f, 0.13703707f, 0.09349207f, -0.08537884f, 
    -0.27242202f, 0.23576160f, 0.10327143f, 0.02660944f, 0.16908638f, 0.12563178f, -0.03355608f, -0.07223388f, 
    0.07359748f, 0.17558645f, -0.01521172f, 0.10754460f, -0.35448813f, -0.19433673f, -0.00482210f, -0.01431959f, 
    0.12767282f, -0.00727133f, 0.01140333f, 0.06042432f, 0.00934965f, 0.12452278f, 0.05175706f, -0.01584160f, 
    -0.17391680f, 0.19412868f, -0.05921014f, -0.18887846f, 0.02688128f, 0.07948354f, 0.00126643f, 0.02099873f, 
    0.02001585f, 0.03644034f, -0.00436399f, 0.03396567f, 0.08495364f, 0.07508377f, 0.04640179f, -0.03314766f, 
    -0.09527303f, 0.01000699f, 0.02130393f, -0.06213858f, 0.07364259f, 0.07464676f, 0.10523299f, 0.00254838f, 
    0.20152143f, 0.16925424f, 0.15561327f, 0.24773639f, -0.05656862f, -0.22396351f, -0.02768621f, 0.12135150f, 
    -0.06650868f, 0.01767757f, -0.05299880f, -0.10518759f, -0.34135395f, -0.02198321f, -0.08118918f, -0.26346186f, 
    0.02964247f, 0.07462022f, -0.07142564f, 0.09645911f, 0.06888893f, -0.05247318f, 0.18691808f, -0.19900995f, 
    -0.08978977f, 0.01198175f, -0.19120711f, -0.23473042f, -0.01566096f, 0.09444107f, 0.08194333f, 0.07682600f, 
    0.03663521f, 0.03885731f, 0.21061963f, -0.03467815f, -0.36328217f, -0.09658505f, 0.12389258f, 0.27584565f, 
    0.06521025f, -0.12420758f, 0.04381948f, 0.05705362f, 0.11331623f, 0.15639330f, 0.06885351f, -0.01268395f, 
    -0.15714744f, -0.19178660f, -0.07078800f, 0.14970401f, -0.03186588f, -0.00595607f, 0.07096948f, 0.06038568f, 
    0.01202280f, 0.06318109f, -0.15000682f, 0.07492231f, -0.21014126f, -0.16398942f, 0.07994995f, 0.08936224f, 
    0.14335436f, -0.09836677f, -0.11348468f, 0.03342311f, -0.00120394f, 0.10987613f, -0.01146935f, 0.08594228f, 
    -0.01960555f, -0.15098402f, -0.17155600f, -0.00645708f, 0.10307013f, -0.08185483f, 0.02530961f, -0.04595236f, 
    0.07270764f, 0.08396368f, -0.01633828f, -0.02799567f, -0.09939326f, -0.09466969f, 0.13431251f, 0.08851146f, 
    0.01273982f, 0.04702470f, -0.02065127f, 0.25463352f, -0.00076859f, 0.00029524f, -0.22402826f, 0.01155601f, 
    0.01397783f, -0.02726723f, -0.01745500f, 0.00469160f, -0.09607738f, -0.07644825f, 0.03483685f, 0.05072957f, 
    -0.02346000f, -0.07207315f, -0.05851227f, -0.03791001f, 0.01416282f, -0.05132797f, -0.01130316f, -0.04450684f, 
    -0.00138437f, -0.02024145f, -0.05892944f, 0.00540489f, 0.03680790f, 0.04199540f, 0.00145251f, -0.04814612f, 
    -0.03691488f, -0.06354486f, 0.06100309f, -0.08113758f, -0.01134628f, 0.02600335f, -0.02971872f, 0.05476572f, 
    -0.01556892f, -0.06885329f, -0.01718073f, -0.03531190f, 0.05975443f, -0.06495284f, -0.02708881f, -0.07089175f, 
    -0.05526610f, 0.02459731f, -0.00134997f, 0.02505455f, -0.02272444f, 0.04906838f, -0.00899240f, -0.08927710f, 
    -0.00837343f, 0.04791358f, 0.05511311f, -0.08417755f, -0.01480704f, 0.04177019f, -0.02841914f, -0.01242425f, 
    0.03755607f, -0.06230036f, -0.06164080f, 0.04360902f, 0.00911532f, -0.07760752f, -0.01424971f, -0.06983165f, 
    0.00246640f, 0.00850431f, -0.01783852f, -0.00748809f, -0.04608482f, 0.00355069f, -0.06110271f, -0.00687458f, 
    0.06102128f, 0.03419184f, -0.00375685f, -0.09223404f, 0.01886963f, -0.07625248f, -0.02517140f, -0.01940976f, 
    0.03529101f, 0.03739481f, 0.04173845f, -0.02022516f, 0.04286997f, 0.03016283f, -0.02668457f, -0.05859317f, 
    0.05548493f, -0.08015757f, -0.00717003f, -0.08596389f, 0.03777167f, -0.06343381f, 0.00051499f, -0.01671344f, 
    0.04074855f, -0.02757558f, -0.01559430f, 0.02649142f, -0.07829078f, -0.00826144f, -0.07873688f, 0.03236021f, 
    0.05307036f, 0.04737255f, 0.00373551f, 0.05553184f, 0.05316400f, 0.01190195f, -0.06067263f, 0.01997022f, 
    -0.08859740f, -0.04717728f, -0.00892815f, -0.06148187f, 0.00278904f, -0.04462340f, 0.01040729f, 0.04932321f, 
    -0.08326177f, -0.03688102f, 0.04587264f, -0.06426413f, -0.05736572f, 0.01628398f, -0.04893940f, 0.03680787f, 
    -0.03336276f, -0.04393673f, -0.05407740f, 0.09025845f, 0.01877983f, -0.04606385f, 0.02689167f, 0.02875661f, 
    -0.03199828f, 0.05410830f, 0.04450504f, -0.08019270f, 0.02396404f, 0.04144265f, 0.05763178f, 0.00129624f, 
    0.02473330f, -0.03427020f, 0.03040934f, -0.06803688f, -0.01610105f, 0.07764709f, -0.05750380f, -0.03372946f, 
    -0.01455106f, 0.03124901f, -0.02971918f, 0.00021516f, -0.06778061f, -0.08168500f, 0.01985339f, -0.03579714f, 
    0.00853669f, 0.04998394f, -0.01707703f, -0.04072512f, -0.09074430f, -0.03634796f, 0.02237246f, 0.08078104f, 
    -0.05574515f, -0.02745221f, 0.00323599f, -0.00584675f, -0.04408664f, -0.06390781f, 0.03701445f, -0.02009133f, 
    -0.02327465f, 0.00614093f, -0.02993224f, -0.01448687f, -0.03834212f, -0.05600395f, -0.05777408f, -0.01130772f, 
    0.03728567f, 0.03442414f, -0.02034966f, -0.04635746f, -0.05539918f, -0.08025189f, 0.01970969f, -0.02787282f, 
    -0.05183068f, 0.01047352f, -0.06403205f, 0.03106499f, 0.05648259f, -0.03700082f, -0.00589906f, 0.00080130f, 
    -0.03229144f, -0.07441090f, -0.01288722f, 0.00610738f, 0.04784380f, 0.05614289f, 0.03329246f, 0.04058398f, 
    0.00691861f, -0.07232506f, -0.00251969f, -0.02936092f, -0.03509888f, -0.03724740f, 0.05240515f, -0.07586155f, 
    0.00936572f, -0.02934187f, -0.00806383f, 0.05288073f, -0.05023288f, 0.03999825f, 0.01564096f, 0.06001282f, 
    -0.07092603f, -0.01378903f, 0.03762225f, -0.07378399f, 0.01858686f, 0.05951500f, -0.04556542f, 0.02593579f, 
    -0.07242995f, -0.05165099f, -0.04678835f, -0.02022751f, -0.04822410f, 0.05281309f, 0.05436958f, 0.05151273f, 
    0.01186371f, 0.01792854f, -0.03885536f, 0.07170743f, -0.02777673f, -0.05617394f, -0.07150058f, -0.03091924f, 
    0.00282659f, -0.01368266f, -0.02699340f, 0.01445557f, 0.05669194f, -0.06845051f, 0.05627166f, 0.05177962f, 
    0.05386913f, 0.00395485f, -0.01259072f, 0.05928355f, -0.05290156f, 0.03186246f, -0.02992998f, -0.07531727f, 
    -0.07941581f, -0.04915904f, 0.01517753f, 0.02727361f, 0.01753170f, 0.04552217f, -0.00982247f, 0.00334652f, 
    -0.08482916f, -0.08173552f, 0.01174636f, -0.01434928f, -0.06377489f, -0.06313404f, -0.06730532f, -0.05258264f, 
    -0.05613782f, -0.03317069f, 0.02669081f, -0.03114687f, -0.07914605f, 0.03654161f, -0.01886643f, 0.01666364f, 
    -0.07338560f, 0.01306414f, 0.02863169f, 0.03910156f, 0.03665484f, -0.02432708f, -0.00229809f, -0.06559643f, 
    -0.02205846f, -0.05804486f, 0.00992347f, -0.04647285f, 0.03531138f, 0.04332501f, 0.00681407f, 0.03702587f, 
    -0.05298946f, -0.00537721f, -0.02911913f, 0.05783762f, -0.06936659f, -0.07500219f, -0.04461120f, 0.05189363f, 
    -0.06674737f, 0.02425664f, -0.03072855f, -0.04224507f, 0.03957818f, 0.03874445f, -0.02150905f, 0.03518696f, 
    -0.01602732f, 0.04638459f, 0.05078911f, -0.07603373f, -0.01102199f, -0.04593633f, -0.05184262f, 0.03410980f, 
    0.01945792f, -0.02866861f, 0.01450245f, 0.00402526f, -0.01781021f, 0.05215089f, -0.05851571f, -0.04226846f, 
    -0.04589995f, -0.01036020f, 0.04528316f, -0.07457317f, 0.06283300f, -0.05827340f, -0.08002689f, -0.05238489f, 
    -0.03102338f, -0.07099338f, 0.01816277f, -0.01181286f, 0.01303693f, -0.03800889f, -0.00827088f, -0.02564979f, 
    0.00022184f, -0.00531384f, 0.01382404f, 0.00408186f, -0.00284906f, -0.03325509f, 0.04346465f, 0.00486588f, 
    -0.05078848f, -0.03133183f, 0.01428626f, -0.05659628f, -0.06473032f, 0.00104497f, -0.02664964f, 0.03898511f, 
    0.05244044f, 0.00502205f, 0.04865135f, 0.03516225f, -0.05328278f, 0.04915788f, -0.06224189f, -0.07704107f, 
    -0.03756770f, 0.00523112f, -0.01366225f, 0.01450779f, 0.03638998f, 0.01226309f, 0.00395437f, -0.02285120f, 
    0.11448638f, 0.07412143f, -0.27356589f, 0.08505009f, 0.07410280f, -0.12202474f, -0.08372200f, 0.04482050f, 
    0.16357648f, 0.00015920f, 0.10740957f, -0.07093251f, -0.05338049f, -0.35704431f, -0.13661125f, 0.32384720f, 
    0.01762860f, -0.01399549f, -0.04618001f, -0.04532496f, 0.05218589f, -0.08398896f, 0.10730717f, 0.07177033f, 
    -0.02436988f, 0.21115042f, 0.11840910f, -0.17944239f, 0.01925061f, 0.01244113f, 0.08778740f, 0.01085343f, 
    -0.07602610f, 0.17646737f, -0.01551216f, 0.04467604f, -0.07261559f, 0.22232683f, -0.11716224f, 0.06640919f, 
    -0.12448113f, -0.17778064f, 0.01536411f, 0.09900910f, -0.15377855f, 0.05339114f, 0.06145406f, 0.00970541f, 
    -0.32541543f, -0.04516963f, -0.10481537f, 0.02645886f, 0.11288431f, 0.05056767f, 0.04979762f, 0.10286465f, 
    0.04140876f, 0.04289774f, 0.09774441f, 0.04480676f, -0.20559356f, -0.09487295f, -0.23368186f, 0.17244337f, 
    0.07063114f, -0.03847733f, 0.01813909f, -0.10370795f, -0.08069488f, -0.03298723f, 0.01245250f, 0.01114450f, 
    -0.03718020f, -0.14192909f, -0.11264629f, -0.09057487f, 0.04994273f, 0.04828041f, 0.02649468f, 0.13567609f, 
    0.10857979f, 0.09573931f, 0.03259616f, 0.06620842f, 0.28035814f, 0.38570249f, -0.00777241f, -0.15020171f, 
    -0.12000951f, -0.18061167f, 0.02508329f, 0.10398242f, -0.12005033f, -0.03955348f, 0.14862157f, 0.12823628f, 
    -0.06026034f, 0.10010702f, 0.00899324f, -0.12019115f, -0.16037978f, -0.02819791f, -0.20332327f, -0.13594683f, 
    0.15701213f, -0.05549386f, -0.08750505f, 0.10970913f, 0.19526456f, -0.10838193f, 0.03752762f, -0.17839979f, 
    -0.05519509f, 0.09474616f, 0.11557633f, 0.12039756f, -0.10334825f, -0.02943820f, -0.00342529f, -0.04421328f, 
    0.20415208f, 0.18706745f, 0.02283594f, -0.06785302f, 0.15136510f, -0.02055231f, 0.02232971f, 0.17795992f, 
    0.04111714f, 0.02182057f, 0.05019366f, -0.03092858f, -0.21810733f, -0.45387554f, 0.14758067f, 0.12965941f, 
    -0.03864343f, 0.05492765f, -0.00177143f, 0.03995502f, 0.02668789f, 0.04827542f, 0.08784711f, 0.15848352f, 
    -0.08766044f, 0.01866192f, 0.05734449f, 0.04029907f, 0.13369422f, 0.16050313f, 0.00759751f, 0.02312768f, 
    0.12766582f, -0.08369762f, -0.04168445f, 0.11947846f, -0.33215210f, 0.08459819f, -0.02313757f, 0.02667446f, 
    0.07012556f, -0.06321760f, 0.10322910f, -0.01577369f, 0.09611633f, -0.15327127f, 0.09547216f, 0.13723995f, 
    0.18508139f, 0.21519883f, 0.09479734f, -0.11010550f, -0.00905153f, 0.06945205f, 0.07827163f, -0.01194717f, 
    0.01302543f, 0.15681450f, 0.11203970f, -0.02593004f, 0.20746031f, -0.05925924f, 0.30170843f, -0.00365283f, 
    -0.15485904f, -0.05902840f, 0.12173628f, 0.02467562f, -0.08032621f, 0.07280724f, 0.02449471f, -0.07752612f, 
    0.04927214f, -0.01509326f, -0.01498929f, -0.11220137f, 0.02322746f, -0.05073376f, -0.06304301f, 0.00889177f, 
    -0.06017194f, 0.01784672f, -0.01346413f, -0.04564342f, -0.00259754f, 0.01753368f, -0.00617460f, -0.05772852f, 
    -0.01208267f, -0.03182282f, 0.00510429f, -0.00090058f, -0.03063548f, -0.02828889f, -0.08611644f, -0.06839412f, 
    -0.03062673f, -0.00795293f, 0.02956846f, -0.04423729f, -0.06873246f, -0.01511438f, -0.08233390f, 0.00489425f, 
    -0.03863761f, -0.08425860f, 0.00768836f, 0.00435846f, -0.02845536f, -0.03140721f, -0.09240086f, -0.01170561f, 
    -0.08386520f, -0.08414214f, -0.05394246f, 0.00948234f, -0.06797206f, 0.06517282f, -0.00711231f, -0.03111509f, 
    -0.00643770f, -0.07975474f, -0.08596376f, 0.02132887f, -0.01177266f, 0.01986554f, -0.00953089f, -0.08941004f, 
    0.03951748f, 0.06411304f, -0.09072150f, -0.07367168f, -0.02268761f, -0.00879168f, 0.01259591f, 0.02077145f, 
    -0.02724225f, -0.01765983f, -0.00470629f, -0.05603632f, 0.04799215f, 0.04062736f, 0.03496076f, -0.11456586f, 
    0.04666900f, -0.06928221f, 0.04713068f, -0.08771568f, -0.04334191f, 0.05493548f, 0.05936481f, -0.06563935f, 
    0.02404377f, 0.02187650f, -0.07507548f, -0.00146681f, 0.05810583f, 0.04745055f, 0.03273534f, 0.06386902f, 
    -0.06571554f, 0.03169741f, -0.06621192f, 0.03830181f, -0.07288633f, 0.04362445f, 0.00274543f, 0.03078744f, 
    0.01711087f, 0.01238120f, -0.01776661f, -0.01567196f, -0.04417720f, -0.07139475f, -0.06320991f, 0.04207740f, 
    0.03054620f, 0.00786631f, -0.07212606f, 0.01595109f, 0.03348882f, 0.04297802f, -0.02544482f, -0.00715529f, 
    -0.06202460f, -0.06569663f, 0.02037882f, -0.04530795f, 0.02400795f, 0.01173448f, -0.01250902f, -0.00367770f, 
    0.03606177f, -0.03597840f, 0.06297069f, -0.04683158f, -0.02712691f, -0.05653556f, -0.02041582f, -0.07355992f, 
    0.04761618f, 0.02641062f, 0.03689121f, -0.03933726f, -0.04446946f, -0.00871142f, 0.01101948f, 0.00581840f, 
    -0.02450623f, 0.01656790f, -0.07546885f, -0.05194445f, -0.03873817f, 0.00149556f, 0.05096700f, -0.05180007f, 
    0.02480781f, 0.00678536f, -0.05566664f, -0.02072532f, 0.04891764f, -0.02263895f, -0.00405193f, -0.01681614f, 
    0.00674131f, 0.05546890f, -0.03820503f, -0.05429983f, -0.08600709f, -0.04681576f, 0.03424324f, 0.02656430f, 
    0.02467654f, -0.04993025f, -0.08330261f, 0.00589820f, 0.06036825f, 0.02375759f, -0.03548722f, -0.07714697f, 
    -0.01286397f, -0.04299761f, 0.02351422f, -0.02655098f, 0.00572776f, -0.04658319f, -0.05406435f, -0.01577181f, 
    -0.00914965f, -0.02095071f, 0.01424458f, -0.03881907f, 0.04315139f, 0.01677998f, -0.07067887f, -0.04920002f, 
    0.03519323f, -0.08063590f, 0.05944346f, -0.07633233f, 0.02227626f, -0.02547958f, 0.04051534f, 0.03844179f, 
    -0.17666954f, 0.06344225f, 0.20689063f, -0.07640260f, -0.11334180f, -0.05714557f, 0.01698313f, -0.01916266f, 
    0.04068469f, -0.02458359f, 0.02918355f, 0.03737875f, -0.41084492f, 0.32020044f, -0.13341978f, -0.16795237f, 
    0.16766430f, -0.04417761f, 0.02206730f, -0.07573856f, 0.03627888f, -0.03363486f, 0.04329916f, 0.06623869f, 
    0.14477237f, -0.10756119f, 0.08583863f, 0.33074591f, 0.00116664f, -0.05290475f, 0.03128982f, 0.09787047f, 
    0.10374580f, -0.07294101f, 0.01327438f, 0.12520808f, 0.09759389f, -0.15315835f, 0.14120069f, -0.05463559f, 
    0.00248724f, 0.16647241f, 0.18358177f, -0.08130063f, -0.12181287f, -0.13901964f, -0.01185366f, 0.05380486f, 
    0.44337124f, -0.17692652f, -0.17130286f, -0.01528109f, 0.05789029f, -0.04788453f, -0.01286843f, 0.01325001f, 
    -0.08998114f, -0.01032826f, -0.00408900f, -0.00116455f, 0.34311071f, -0.06128991f, 0.05541653f, -0.11092057f, 
    0.05830639f, 0.12297421f, -0.10383652f, -0.00249600f, 0.04118862f, 0.01862497f, 0.03501493f, 0.14686446f, 
    0.05769930f, -0.03286060f, 0.03331697f, 0.16544230f, 0.01049278f, 0.03290256f, -0.12876937f, 0.02952049f, 
    -0.01018625f, -0.00542713f, -0.02186097f, -0.03172076f, -0.08594973f, 0.06011835f, -0.14369692f, 0.00426605f, 
    -0.00813633f, 0.10561664f, 0.06761276f, -0.00638407f, 0.14084394f, 0.17901987f, -0.12756468f, -0.10932963f, 
    -0.35979933f, -0.19196109f, 0.00310335f, 0.01095461f, 0.07333922f, 0.07608538f, 0.08342393f, 0.03528827f, 
    0.05655579f, 0.02088207f, 0.05949197f, -0.05448721f, 0.22912131f, 0.28768283f, 0.08194321f, 0.18201634f, 
    0.05363967f, 0.06542278f, 0.03722419f, -0.00341871f, 0.00278497f, 0.10859854f, 0.02703113f, 0.00071345f, 
    -0.04786445f, -0.13498087f, 0.06860209f, 0.20602426f, -0.05097128f, 0.01648709f, -0.08358724f, 0.05201476f, 
    0.09635722f, -0.07082296f, 0.05426905f, 0.06704690f, -0.03207530f, 0.12351449f, -0.18057331f, -0.01751640f, 
    0.00975650f, 0.00677821f, 0.08871347f, -0.06150029f, -0.09852576f, -0.03294064f, 0.07095922f, 0.09102112f, 
    0.07155616f, 0.07959455f, -0.10013135f, 0.03983540f, -0.01475460f, 0.00870690f, -0.08936478f, -0.07698349f, 
    -0.11467882f, 0.00887237f, 0.11585471f, 0.04838406f, 0.15294611f, -0.04850303f, 0.12681785f, 0.07064097f, 
    -0.07653925f, 0.01568951f, 0.00266778f, 0.07428981f, 0.00583742f, 0.02989742f, 0.06908306f, 0.11833289f, 
    0.13107598f, 0.02259292f, 0.02436882f, 0.28144854f, -0.01298808f, -0.00932278f, -0.05170791f, -0.03943125f, 
    0.09272147f, -0.12893724f, -0.14160523f, 0.08343975f, -0.15761203f, 0.13753454f, 0.03654849f, -0.04709843f, 
    0.06282751f, 0.08371398f, 0.08925173f, 0.01208540f, -0.16717649f, 0.12265240f, 0.11427517f, 0.02292308f, 
    0.34932464f, 0.23623081f, -0.18390404f, 0.07343119f, -0.02973719f, 0.05693656f, -0.15389602f, 0.00412293f, 
    0.19409703f, -0.05237337f, 0.18540020f, 0.01773444f, 0.07061967f, -0.17317766f, 0.04512868f, 0.11934848f, 
    0.07792614f, 0.03335929f, -0.03975040f, 0.05913807f, -0.05823255f, 0.04586231f, 0.00990973f, -0.05615977f, 
    0.11553559f, 0.11303928f, 0.03178018f, -0.17384878f, -0.27827841f, -0.20799933f, 0.03385462f, -0.04527135f, 
    -0.05161694f, -0.04252399f, 0.06751185f, 0.01209720f, -0.45653418f, -0.02607873f, 0.18329239f, 0.13767728f, 
    -0.20297703f, 0.16112970f, 0.00383474f, -0.12307900f, 0.15774217f, -0.09658607f, 0.08003485f, -0.01340053f, 
    0.08981691f, 0.21193661f, -0.03902823f, 0.35512796f, 0.05784421f, 0.06561366f, 0.04333705f, 0.04152238f, 
    -0.04367176f, -0.00768583f, 0.13541691f, 0.08280887f, -0.05592845f, 0.01456343f, 0.07381560f, -0.01447457f, 
    0.09770869f, 0.04780297f, -0.08414911f, 0.04774961f, 0.07029878f, 0.09068011f, 0.19439836f, -0.00653985f, 
    0.34849465f, 0.55811524f, -0.45609006f, 0.03185023f, 0.03204148f, 0.05454098f, 0.00713510f, -0.25463998f, 
    -0.01246463f, -0.19391698f, -0.04462804f, 0.04673651f, -0.30445182f, 0.09325135f, 0.14778996f, -0.16270106f, 
    0.00948786f, 0.06831130f, -0.38112056f, -0.16608743f, 0.24964449f, -0.02693290f, 0.14402761f, 0.13820435f, 
    -0.13670193f, -0.07699681f, 0.02286300f, 0.26826903f, -0.18659270f, 0.04859845f, 0.07342375f, 0.01117235f, 
    -0.01830520f, -0.05169871f, 0.00725019f, -0.23101889f, -0.21708108f, 0.27935484f, 0.03687014f, -0.05521711f, 
    0.04781483f, -0.02173038f, 0.08077174f, -0.00891205f, 0.13672489f, -0.08234359f, 0.25179437f, -0.01968551f, 
    0.27070877f, 0.03564321f, 0.24008730f, -0.00773118f, 0.03879111f, 0.16909520f, -0.04323495f, -0.27806804f, 
    0.08436572f, -0.13718508f, -0.09890763f, 0.23846276f, -0.13868155f, 0.06127906f, 0.04453954f, 0.06583853f, 
    -0.07157145f, 0.02932635f, -0.10410824f, 0.06405389f, -0.19669047f, 0.08461376f, 0.11546692f, 0.11249022f, 
    -0.17671613f, -0.22086039f, 0.00678341f, 0.01945395f, 0.01724115f, -0.06263793f, -0.00276746f, -0.06486955f, 
    -0.04663676f, 0.13215776f, -0.19300468f, -0.22937620f, 0.31596580f, -0.22470652f, -0.06403060f, 0.02399635f, 
    0.25507343f, -0.01676168f, -0.06203591f, -0.01789433f, 0.03200997f, 0.04759752f, 0.13258035f, -0.14073646f, 
    -0.16181812f, 0.07758375f, 0.11026365f, -0.26278672f, 0.04638464f, -0.24169810f, 0.07261558f, 0.17227341f, 
    -0.02577731f, -0.21589422f, -0.14066070f, -0.09190503f, -0.44321975f, 0.14095761f, 0.02730030f, -0.04154380f, 
    0.05493473f, 0.02844622f, -0.01378138f, 0.00365603f, -0.15170498f, -0.01421978f, -0.05690236f, -0.20080908f, 
    -0.21435358f, -0.04476799f, 0.17388290f, -0.02739868f, 0.04569088f, -0.02325421f, -0.00790920f, 0.04183372f, 
    -0.03020714f, 0.19786359f, 0.04651836f, 0.09136696f, -0.36073565f, -0.03456498f, -0.22661079f, -0.36124000f, 
    0.13917381f, -0.05845587f, 0.02827770f, -0.01267762f, 0.09669927f, -0.06030880f, -0.02122151f, 0.09991429f, 
    0.35741201f, 0.00788629f, -0.01417454f, 0.00880603f, 0.11743358f, -0.02965582f, -0.00623269f, 0.02535777f, 
    -0.01528320f, -0.00310887f, 0.06261658f, 0.03931423f, 0.26601392f, 0.03341951f, 0.02880312f, 0.25612158f, 
    -0.09655716f, 0.06207757f, 0.14676930f, 0.04462687f, -0.04560471f, -0.05736440f, 0.03384702f, -0.00205261f, 
    -0.12277409f, -0.18970776f, -0.04276519f, -0.08333106f, 0.18425694f, -0.08707941f, 0.04593938f, 0.02424580f, 
    -0.06436035f, 0.07550658f, 0.10467665f, -0.00139235f, 0.00257026f, -0.12641877f, 0.08245102f, -0.04706252f, 
    0.06018106f, 0.14849301f, 0.05414072f, 0.02432122f, 0.04071112f, 0.06260817f, -0.03277553f, 0.04672338f, 
    -0.29071945f, -0.21868041f, 0.08752327f, 0.08096968f, -0.02927863f, 0.03058092f, 0.03665876f, 0.00651454f, 
    -0.01737148f, 0.09095965f, -0.12699020f, 0.00138227f, 0.29603350f, 0.12004730f, 0.12904803f, 0.04615343f, 
    -0.07193756f, 0.09883451f, 0.10077614f, -0.03744360f, 0.04400905f, 0.14521430f, 0.06937397f, -0.10101013f, 
    -0.06250665f, 0.18201341f, 0.01957994f, -0.04940921f, -0.00525148f, 0.00437671f, -0.06638622f, 0.27435786f, 
    0.01546370f, 0.13189100f, -0.02583974f, -0.07471997f, 0.04594694f, 0.18868835f, -0.07540444f, 0.28617465f, 
    -0.09502722f, 0.04071472f, 0.01634086f, -0.04321254f, -0.06601378f, 0.00871840f, -0.01807629f, 0.03048659f, 
    0.24794018f, 0.25110313f, -0.09683239f, 0.07516839f, 0.12449803f, 0.01358704f, -0.06232858f, 0.09203330f, 
    -0.02532607f, -0.01567607f, 0.00524990f, -0.08428787f, -0.36687455f, -0.10205169f, -0.14327423f, -0.15021639f, 
    0.06646577f, 0.08073350f, 0.08070184f, 0.03247367f, 0.03273556f, 0.01743488f, 0.05046556f, -0.01601015f, 
    -0.01125633f, 0.01379193f, 0.01491593f, 0.19223815f, 0.06789751f, 0.09109770f, -0.02952844f, -0.04992739f, 
    0.03658746f, -0.02421587f, 0.11557799f, 0.20478086f, 0.00737467f, 0.00700857f, -0.01580441f, -0.02370047f, 
    0.08696585f, 0.01534113f, 0.01588186f, 0.00399933f, -0.02210552f, -0.03465971f, -0.00232947f, 0.12378197f, 
    0.27892110f, 0.15350763f, -0.04566783f, 0.20936567f, -0.04265413f, 0.11321008f, -0.10663972f, -0.06858758f, 
    0.15200275f, -0.06316671f, -0.03432721f, 0.04029604f, 0.12132904f, -0.02867541f, -0.02731814f, 0.18842553f, 
    -0.17149428f, -0.13780074f, -0.02728876f, 0.08148126f, 0.01808414f, -0.01545264f, 0.14251305f, 0.02961103f, 
    -0.14318171f, 0.03175541f, 0.12746975f, -0.07704657f, 0.00579546f, 0.03198440f, 0.10970392f, -0.00217297f, 
    -0.05256981f, -0.15990384f, 0.10997808f, 0.00216286f, 0.27739933f, 0.14291483f, 0.28849864f, -0.00353924f, 
    -0.00338390f, 0.04738883f, 0.03780286f, -0.06659123f, -0.04315822f, -0.01630862f, 0.09454819f, 0.09318145f, 
    -0.35202506f, -0.02020304f, -0.20766281f, 0.07298826f, -0.05252378f, -0.04435899f, 0.04769237f, 0.01429601f, 
    -0.11065615f, -0.00934523f, -0.00487997f, -0.06621218f, -0.25231752f, -0.18084122f, -0.30999053f, -0.22160746f, 
    -0.01668672f, 0.05563348f, -0.01521364f, 0.10541835f, 0.01280131f, 0.03604396f, 0.07910357f, -0.15540338f, 
    0.02425786f, 0.08065545f, 0.09166835f, 0.43816888f, 0.02914788f, 0.21399768f, 0.07390603f, 0.15537460f, 
    0.20434242f, 0.10762835f, -0.03064601f, 0.14341229f, 0.05731915f, 0.21564813f, -0.04046153f, 0.06589867f, 
    0.06574874f, -0.13297512f, 0.08287204f, -0.06765527f, -0.13096517f, -0.15270738f, 0.03970940f, 0.05637158f, 
    -0.14145358f, -0.13424881f, -0.05900479f, 0.06372380f, -0.01135877f, 0.00997093f, 0.02161630f, -0.08724418f, 
    0.11433050f, -0.07504889f, -0.02742706f, -0.06850098f, -0.27088663f, -0.15296721f, -0.43167517f, 0.14985272f, 
    0.04359445f, -0.04134006f, 0.01645759f, -0.12604770f, 0.01911666f, -0.00220884f, 0.12222542f, 0.16060126f, 
    -0.49473941f, 0.22150674f, -0.14878139f, -0.31540290f, 0.03197984f, -0.16901252f, 0.04402181f, -0.00781040f, 
    -0.04619852f, -0.10076395f, -0.00736600f, 0.00427526f, -0.20607401f, -0.38545230f, -0.24174762f, -0.11851419f, 
    0.04357101f, -0.05457480f, -0.08626199f, -0.03732950f, 0.07452829f, 0.01760089f, 0.19133875f, -0.07850533f, 
    -0.09792724f, -0.17749290f, 0.15020762f, 0.29605696f, 0.02021394f, -0.02912774f, 0.15254481f, 0.01576436f, 
    0.04154841f, 0.09594754f, 0.07562657f, 0.06183046f, 0.06509722f, 0.10509904f, 0.32173204f, 0.09819185f, 
    0.09025201f, 0.03585957f, -0.12002339f, -0.06869454f, 0.01590629f, -0.01710377f, 0.04632122f, 0.17792965f, 
    0.09413402f, -0.05241620f, 0.01001026f, -0.01044340f, -0.09807277f, -0.02460158f, 0.12815566f, 0.10215924f, 
    -0.01083130f, -0.05973114f, -0.02674849f, -0.01304704f, 0.05155456f, 0.09485154f, 0.05585270f, 0.07457666f, 
    0.08733822f, 0.03301650f, 0.01511268f, 0.05068512f, -0.01957232f, 0.11931667f, 0.25332564f, 0.02557136f, 
    -0.05240928f, 0.04059605f, -0.04242761f, 0.08658129f, 0.02362131f, -0.04815026f, 0.03377530f, -0.08259434f, 
    0.03243043f, 0.13078533f, 0.06417568f, -0.10458192f, -0.21540892f, -0.47187352f, -0.29158601f, -0.16075878f, 
    0.08312324f, 0.03052275f, 0.05936807f, -0.05953453f, 0.13145217f, -0.04286061f, -0.16182788f, 0.07041375f, 
    0.04260154f, 0.09631499f, 0.15566531f, 0.03410450f, 0.12912340f, -0.02110229f, 0.15586568f, 0.01697834f, 
    0.06285399f, 0.11550068f, 0.01558417f, 0.10876480f, -0.34296218f, 0.11779486f, -0.14817847f, -0.22615474f, 
    0.14437591f, -0.09068456f, -0.05292495f, 0.03336683f, 0.05131959f, 0.12944885f, 0.11608060f, 0.19820791f, 
    0.23392856f, -0.11476924f, -0.04758022f, 0.08178403f, 0.02368425f, -0.06563038f, -0.03115911f, -0.11227659f, 
    -0.02231057f, -0.04920180f, -0.01426665f, -0.06411542f, 0.22154874f, -0.10223696f, 0.01420140f, 0.12950642f, 
    0.02092498f, 0.10730799f, 0.07589366f, 0.02059593f, -0.05913541f, 0.05022514f, -0.01721910f, 0.04982226f, 
    0.04443977f, -0.03393702f, -0.00891519f, -0.15732142f, 0.23083577f, -0.07660028f, 0.07338865f, -0.09065281f, 
    -0.12097189f, -0.12705144f, 0.01417710f, -0.06941243f, 0.03814205f, -0.01584107f, 0.23700351f, 0.08176663f, 
    0.09870394f, 0.21905157f, 0.00185229f, -0.01688795f, 0.17428310f, 0.21364446f, -0.05992068f, -0.03271902f, 
    0.05469251f, 0.04154525f, 0.02657185f, 0.31184691f, 0.05766639f, 0.08022787f, 0.04905131f, 0.01393304f, 
    0.03194468f, 0.02690626f, 0.06767641f, -0.09892011f, -0.07222738f, -0.13706765f, -0.01353934f, -0.16728678f, 
    -0.11448643f, -0.07450078f, -0.00422231f, -0.12957428f, -0.09234248f, 0.08439511f, -0.19639897f, -0.07347117f, 
    0.13096842f, -0.32473880f, -0.07839722f, 0.03712145f, -0.01100849f, 0.01289436f, -0.07351384f, 0.08882339f, 
    -0.03716773f, 0.04217756f, 0.19999860f, 0.11781241f, -0.04985459f, 0.05361129f, 0.16641372f, 0.12105342f, 
    -0.05070618f, 0.10530134f, 0.15449513f, 0.00354787f, 0.14765802f, 0.07394490f, -0.11327729f, 0.10242023f, 
    0.27637491f, 0.10191525f, -0.18268959f, 0.02737465f, 0.03269213f, -0.02253971f, -0.21931964f, 0.04579784f, 
    0.09556202f, -0.03861177f, -0.05488357f, 0.03778167f, -0.04767074f, 0.18108618f, -0.18995540f, -0.21669313f, 
    0.14043821f, 0.01678567f, -0.03227932f, -0.07343219f, -0.07951987f, -0.05052896f, 0.09068228f, -0.07162432f, 
    -0.18283574f, 0.29844782f, 0.07135601f, -0.05487312f, 0.10249316f, 0.14242664f, -0.02728179f, -0.08183996f, 
    -0.07322871f, 0.09898211f, 0.24905060f, 0.18131356f, 0.14293912f, 0.06730186f, 0.00067463f, 0.01036441f, 
    0.05326748f, -0.02295865f, 0.11031843f, 0.03179003f, 0.05082295f, -0.04826814f, 0.04886218f, -0.03485954f, 
    0.10385821f, 0.04688944f, -0.05248039f, -0.03874591f, -0.08700518f, 0.09503815f, -0.05468827f, 0.07824460f, 
    0.11487725f, -0.06962045f, 0.03625231f, 0.15335712f, -0.11962942f, 0.16151518f, 0.08527076f, -0.02047441f, 
    -0.12800737f, -0.04762454f, 0.05702531f, 0.06734420f, -0.12908798f, 0.00837089f, 0.23304750f, -0.00626297f, 
    0.13475090f, 0.13956867f, 0.01910412f, -0.03414387f, 0.00941006f, -0.09798379f, 0.09285617f, -0.05790592f, 
    -0.02838354f, 0.04856402f, -0.18795173f, 0.07479756f, 0.08323678f, -0.17988737f, -0.05112659f, 0.34664553f, 
    0.06177559f, -0.03939028f, -0.04275853f, 0.07569435f, -0.10234917f, 0.07822391f, -0.11020633f, 0.00340031f, 
    -0.09837525f, -0.00801625f, -0.08691910f, 0.15749699f, -0.22297302f, 0.11209387f, -0.26498002f, -0.01850881f, 
    0.13253148f, 0.00147279f, 0.01310378f, -0.04976477f, 0.18769991f, 0.20679554f, 0.20237425f, -0.17242815f, 
    0.13832882f, 0.03890620f, -0.12397970f, 0.01040250f, 0.03843715f, -0.04065014f, 0.00643326f, 0.15302594f, 
    0.01718749f, -0.00920611f, 0.10489145f, -0.12625691f, -0.08405144f, -0.07371782f, 0.02554493f, -0.13479261f, 
    -0.03859483f, -0.08604848f, -0.14329861f, 0.01734225f, -0.03596160f, 0.21893391f, -0.19996712f, 0.04448548f, 
    -0.12397692f, -0.15893964f, -0.03114100f, 0.11659916f, 0.03012656f, 0.04530313f, -0.03481245f, -0.11063787f, 
    -0.22693434f, 0.14854969f, 0.07403247f, -0.30906096f, 0.04995032f, 0.01385071f, 0.12204640f, 0.08893648f, 
    -0.04880714f, -0.04775621f, 0.14739150f, 0.09063070f, 0.14864044f, 0.18531373f, 0.12558185f, 0.16098404f, 
    -0.03376196f, -0.00270353f, 0.06426794f, 0.14865394f, 0.07072559f, 0.04390126f, -0.16420251f, -0.10334081f, 
    0.54553801f, 0.21536790f, 0.21831447f, 0.01199977f, -0.04976994f, 0.14022075f, -0.00795052f, -0.05518787f, 
    0.06226178f, 0.00472691f, 0.10293430f, 0.11273994f, 0.15773334f, -0.02964047f, 0.10370427f, -0.03624909f, 
    0.02791944f, -0.03155417f, 0.00557003f, -0.11645760f, -0.15275915f, 0.03155525f, -0.12819031f, -0.01586638f, 
    -0.42332238f, 0.01704822f, 0.11838050f, 0.01996027f, 0.00819690f, -0.11364554f, 0.12238406f, -0.04749698f, 
    -0.08576664f, 0.01673971f, 0.02636780f, 0.01595030f, 0.30235571f, 0.08697001f, -0.04100448f, 0.08757263f, 
    -0.05106049f, 0.00668259f, 0.00892567f, -0.00925252f, -0.03954083f, -0.07822246f, 0.02723247f, -0.12654793f, 
    0.02836225f, 0.09110877f, 0.06212690f, -0.28441823f, 0.07551349f, -0.04555710f, -0.02843653f, 0.04665373f, 
    -0.08368933f, -0.16205995f, 0.08482249f, -0.03913815f, 0.14973739f, 0.19685011f, -0.20060770f, 0.12376499f, 
    -0.08225769f, -0.04273120f, 0.09533434f, -0.03721758f, 0.05168090f, 0.04975362f, -0.11562400f, -0.07229050f, 
    -0.14716482f, -0.07104352f, -0.00784620f, -0.05338967f, 0.06943631f, 0.10306974f, 0.05712593f, -0.06465835f, 
    -0.22162007f, -0.09254682f, 0.06892556f, 0.04861787f, 0.15471634f, 0.38008282f, 0.08625785f, 0.00246094f, 
    0.09074499f, 0.20604423f, 0.03463139f, -0.04434475f, -0.04207279f, -0.03972451f, 0.07993739f, 0.02407448f, 
    -0.61997128f, -0.00177509f, 0.27631015f, -0.28767118f, 0.09267900f, 0.08398462f, 0.01062905f, -0.05306983f, 
    -0.06702246f, 0.09797460f, -0.04915263f, 0.06520136f, -0.16371119f, 0.27206197f, -0.26009125f, -0.19454163f, 
    0.09726735f, 0.05713038f, -0.22048634f, -0.11894969f, 0.00496987f, -0.07557522f, -0.07224849f, 0.13516249f, 
    0.18847503f, -0.03671808f, 0.00394016f, 0.10313138f, 0.06448286f, 0.00552207f, -0.02808820f, 0.08527923f, 
    0.04099974f, 0.00088918f, 0.04104219f, 0.07484983f, -0.11249421f, 0.06219830f, 0.17929800f, 0.06682503f, 
    0.02053691f, -0.05712179f, 0.02066067f, -0.03622325f, -0.02648677f, 0.03727281f, 0.11190915f, 0.05310735f, 
    0.10116662f, -0.05879078f, 0.05104521f, -0.04028365f, 0.08577990f, -0.08099432f, 0.00205349f, -0.10920338f, 
    -0.06998318f, -0.01175055f, 0.01314230f, 0.01690619f, 0.08423799f, -0.30445355f, -0.05390949f, -0.18617809f, 
    0.08096173f, -0.07741717f, 0.03664239f, -0.04061290f, -0.01051106f, 0.16119255f, 0.03826049f, 0.03850717f, 
    -0.33749950f, -0.18965605f, 0.18823376f, -0.21904975f, -0.00626016f, 0.02376857f, -0.04916619f, -0.10514712f, 
    0.09983049f, 0.15626815f, -0.01876600f, -0.02776985f, 0.12087620f, 0.03952542f, 0.07734476f, 0.06989203f, 
    0.13019437f, 0.13247633f, 0.05535661f, 0.02581659f, 0.07880460f, 0.13541375f, 0.06684268f, 0.00068677f, 
    -0.17512234f, 0.12959222f, -0.06354215f, -0.02957809f, 0.09573309f, 0.06380595f, 0.16210875f, 0.17530961f, 
    0.01067561f, -0.00550433f, -0.04266930f, 0.01581602f, 0.11071240f, 0.16216107f, 0.01081609f, 0.21614514f, 
    0.03435644f, -0.02044452f, 0.02812195f, 0.08786606f, 0.01501121f, -0.00636792f, -0.00255427f, -0.02506806f, 
    -0.15375118f, 0.21763842f, 0.04576756f, -0.04901405f, 0.03801900f, 0.07259479f, 0.10166632f, -0.00081002f, 
    0.05692252f, 0.03260927f, 0.00220247f, -0.05487265f, 0.04940587f, -0.07564536f, -0.14877081f, 0.04113552f, 
    0.02802554f, -0.06485073f, -0.09602027f, -0.09684952f, 0.11255711f, -0.08796824f, 0.00907353f, 0.08295593f, 
    0.00470469f, -0.33665946f, -0.08947936f, 0.19016103f, -0.01589911f, 0.04840445f, 0.09016953f, -0.15113659f, 
    -0.05491013f, 0.09452841f, 0.07631999f, 0.03872517f, -0.14236690f, -0.05052242f, -0.00310548f, 0.05145545f, 
    0.00965171f, 0.03202613f, -0.14283927f, -0.06225955f, 0.13033043f, -0.02535090f, -0.10344312f, 0.07157281f, 
    -0.01313113f, -0.08876389f, -0.02011062f, 0.26881695f, 0.03038589f, 0.04637826f, -0.07006403f, 0.06975122f, 
    0.06696059f, 0.03966478f, -0.03499140f, 0.03679925f, -0.09341697f, 0.05165422f, -0.16583446f, 0.20025916f, 
    0.01605739f, 0.12265829f, 0.04417489f, 0.10588580f, 0.03169164f, 0.09641646f, 0.15231806f, -0.07148723f, 
    0.03011283f, -0.02104313f, 0.01269656f, 0.03887317f, -0.06355093f, -0.02343047f, -0.00296219f, 0.01192119f, 
    -0.02100440f, -0.00062544f, -0.02397635f, 0.04314194f, 0.02559766f, -0.03773993f, -0.01966153f, -0.02942531f, 
    -0.00672466f, -0.00522934f, -0.02481181f, -0.06812260f, 0.02584282f, -0.05002371f, 0.01170666f, -0.06278106f, 
    -0.04189502f, -0.03078273f, 0.06157935f, 0.03956748f, 0.01236813f, 0.05549683f, -0.04158545f, -0.00860537f, 
    -0.04826665f, -0.03755769f, -0.07592233f, -0.00172981f, -0.02075769f, -0.07057577f, -0.04550192f, -0.04140906f, 
    -0.02107537f, 0.02285718f, -0.04699793f, -0.02062204f, -0.06574321f, -0.07434103f, 0.03929893f, 0.05997201f, 
    -0.02389380f, 0.06091464f, -0.04064044f, -0.01437606f, -0.02303634f, 0.00037277f, -0.04399237f, 0.03795720f, 
    0.00188364f, -0.02483468f, -0.05798090f, 0.05850269f, 0.03826047f, -0.07950012f, -0.03898437f, 0.05146179f, 
    0.01908712f, 0.04400927f, 0.03054717f, 0.05631453f, 0.03181528f, -0.01908609f, -0.05537440f, -0.01947547f, 
    0.04690533f, 0.04234069f, -0.07298244f, -0.00788268f, -0.08216976f, -0.04904614f, 0.01935025f, -0.07727396f, 
    0.00521628f, 0.05454380f, 0.03747218f, 0.02782098f, -0.05024810f, -0.04797003f, -0.06562670f, -0.02488694f, 
    -0.02016859f, -0.03741473f, -0.00024661f, -0.08073407f, 0.04678401f, 0.00885157f, 0.00964450f, -0.00654300f, 
    -0.04754294f, 0.03035231f, 0.02503953f, -0.02498436f, 0.01887582f, -0.01484479f, -0.06339280f, 0.02975141f, 
    -0.01110787f, 0.02468202f, -0.04326404f, -0.01172811f, -0.02708095f, -0.05316580f, 0.03502148f, -0.07196515f, 
    0.01976319f, -0.02161411f, 0.05583539f, 0.04506410f, 0.00683402f, 0.01828200f, 0.06097733f, 0.02644284f, 
    0.02467428f, 0.06491102f, -0.06902142f, 0.02161163f, -0.04556675f, -0.06204972f, -0.04904989f, 0.04225492f, 
    0.01428976f, -0.02408085f, -0.06341880f, -0.02429841f, -0.07391326f, 0.05403200f, 0.04921196f, -0.05374306f, 
    -0.02270255f, 0.01393043f, 0.06202418f, -0.04943372f, 0.00932526f, -0.02080943f, -0.07144269f, 0.05685719f, 
    -0.08060075f, -0.00726826f, -0.05677283f, 0.02388772f, -0.02556184f, -0.08148586f, -0.00092248f, -0.06412382f, 
    0.02028855f, 0.05688206f, 0.01985181f, -0.03698295f, -0.03547481f, -0.02463445f, 0.06433664f, -0.06236891f, 
    -0.02961615f, 0.05259842f, -0.03560752f, 0.03554631f, -0.04986617f, -0.06226996f, 0.02583247f, 0.01881777f, 
    -0.06962360f, -0.05091140f, -0.01818522f, -0.05592933f, -0.02000524f, 0.04171854f, 0.02522455f, 0.01968120f, 
    0.05804861f, -0.00280580f, -0.07984674f, -0.03069886f, -0.04129169f, -0.00012201f, -0.01526232f, -0.01395091f, 
    -0.00370580f, 0.02538403f, 0.05299961f, -0.04481406f, -0.05042520f, 0.05494562f, -0.08327271f, -0.02178780f, 
    -0.19199009f, -0.17413506f, 0.13228944f, 0.03190719f, 0.03778623f, 0.01732846f, 0.12792234f, 0.09803364f, 
    0.09847835f, -0.00000476f, -0.08063147f, -0.02494519f, 0.23315668f, 0.44345093f, 0.22028942f, 0.11690455f, 
    0.01870396f, 0.00544696f, 0.06635363f, 0.14203899f, -0.04777499f, -0.00554186f, -0.12351185f, 0.11275586f, 
    0.04880111f, -0.01879920f, -0.06821816f, -0.00689094f, 0.09507293f, -0.06517701f, 0.04861014f, 0.07166106f, 
    -0.06227062f, -0.10555180f, -0.04544653f, 0.05268330f, -0.17016599f, -0.08235025f, 0.08739058f, -0.02086291f, 
    0.09354842f, 0.00331130f, 0.00728888f, -0.00418308f, 0.02119159f, 0.03927908f, 0.05606559f, -0.06144549f, 
    0.43899611f, 0.06031871f, 0.00868122f, 0.12082454f, -0.08502058f, 0.02640692f, -0.01851496f, -0.01365371f, 
    0.02881696f, 0.03875022f, -0.12639868f, -0.07359071f, 0.32782590f, -0.11066386f, 0.14454858f, -0.09206024f, 
    -0.02056434f, -0.06970192f, -0.09730847f, 0.06070063f, 0.04402058f, 0.04386600f, 0.16266434f, 0.01378211f, 
    0.46035331f, 0.14709100f, 0.01161288f, 0.02218912f, -0.02255916f, 0.10087074f, -0.22293183f, -0.05390946f, 
    0.07046235f, -0.02654893f, -0.02414801f, -0.08915284f, -0.24103437f, -0.17603812f, -0.01712528f, 0.14874633f, 
    0.17337359f, 0.13863926f, 0.02668483f, 0.11246815f, 0.08143193f, 0.09321837f, 0.14233848f, -0.02757750f, 
    -0.44472298f, -0.14403082f, -0.03969450f, 0.26847589f, 0.08882338f, -0.00587936f, 0.05907435f, 0.07120419f, 
    0.02632729f, 0.04772197f, -0.00147168f, -0.03002523f, -0.05578804f, 0.19071883f, -0.05537023f, -0.04160250f, 
    0.06890130f, 0.00272389f, 0.01516114f, 0.18816258f, 0.10187365f, -0.01783714f, 0.16036698f, -0.04346749f, 
    -0.17101957f, -0.18950686f, 0.13086088f, -0.16746210f, -0.16147873f, 0.10037614f, 0.02905169f, 0.02068717f, 
    0.06468454f, 0.01664531f, 0.14907594f, 0.10174349f, 0.32768071f, 0.30923140f, 0.15426175f, 0.08832861f, 
    -0.03201506f, 0.01387114f, -0.06230721f, 0.03338651f, -0.05666130f, 0.03812243f, -0.07311260f, 0.05007917f, 
    0.13201374f, -0.17989004f, 0.02226738f, 0.15158105f, -0.09138830f, 0.01082326f, 0.09487492f, -0.03055433f, 
    -0.10114288f, 0.06367754f, -0.02563155f, -0.02809737f, 0.07279062f, -0.05604165f, 0.14269271f, -0.11254045f, 
    0.04390807f, 0.03188818f, -0.08211941f, -0.02275364f, 0.03060280f, 0.03919829f, 0.11485941f, 0.00268234f, 
    -0.11463279f, -0.23416984f, 0.05379801f, 0.06610756f, 0.01042431f, 0.00267942f, 0.05102831f, 0.16606900f, 
    0.00870567f, 0.10947153f, -0.01315213f, -0.01487333f, -0.28553918f, -0.00484735f, -0.09210948f, 0.00546521f, 
    0.17773175f, 0.00842383f, -0.10029446f, 0.11870062f, -0.03025709f, 0.08940191f, -0.00157686f, 0.12859513f, 
    0.24709073f, 0.10220451f, 0.04619667f, 0.06848600f, 0.08093277f, 0.17938437f, 0.16536359f, 0.00580554f, 
    0.11459010f, 0.18239482f, -0.01660080f, -0.00072603f, 0.04229467f, 0.07040645f, -0.10289117f, 0.00775000f, 
    0.03021826f, 0.06042062f, 0.10097023f, 0.15754779f, 0.01633655f, 0.20610608f, 0.02593364f, 0.14034615f, 
    0.11762067f, -0.11318763f, -0.10824429f, -0.25396216f, 0.04651330f, -0.02992114f, -0.13804922f, -0.13845420f, 
    -0.03951450f, -0.09246139f, 0.04568670f, -0.01289261f, 0.06789801f, -0.01224280f, 0.01048228f, 0.11784928f, 
    0.05067119f, 0.15110317f, 0.03863361f, 0.14676054f, 0.03334866f, -0.02648304f, -0.13179387f, 0.01248391f, 
    0.01702058f, -0.06385893f, 0.02837535f, -0.03475976f, 0.10215164f, -0.10320288f, 0.06743413f, -0.07712509f, 
    0.03352075f, -0.01300874f, -0.08575183f, -0.03982546f, -0.04832235f, 0.05681305f, 0.04619621f, 0.21958187f, 
    -0.07988019f, 0.18020970f, 0.27810028f, 0.00818166f, 0.03175082f, 0.10427272f, -0.07388084f, -0.04115252f, 
    -0.18490072f, -0.32982326f, 0.07059132f, 0.08553163f, 0.05718764f, 0.05651831f, 0.16383980f, -0.00729866f, 
    -0.04313567f, 0.09912129f, -0.02666037f, -0.07131465f, -0.04863191f, -0.13502347f, -0.08854613f, -0.11312607f, 
    -0.11193678f, -0.02282637f, 0.01630084f, 0.07821757f, -0.02696905f, 0.09888525f, -0.02540266f, 0.00054849f, 
    0.17143734f, -0.09330215f, -0.04721845f, 0.00156993f, -0.02926252f, 0.03562124f, -0.07693058f, 0.24794947f, 
    -0.03172269f, 0.08869535f, 0.06387595f, 0.07371357f, 0.01558783f, -0.14113285f, -0.05639936f, 0.10072421f, 
    0.04588488f, -0.06917843f, 0.17941053f, 0.10597464f, 0.03916545f, 0.06750938f, -0.08233271f, 0.16678220f, 
    0.42592254f, 0.30877259f, 0.08871394f, 0.00741992f, 0.02830553f, 0.06148454f, -0.00824087f, 0.04884752f, 
    0.09071752f, 0.04939704f, -0.15433635f, 0.09608311f, 0.14038098f, 0.14324148f, 0.12789397f, -0.08656019f, 
    0.04392358f, 0.10318024f, -0.00201596f, -0.09954099f, -0.02917398f, -0.01040227f, 0.03684083f, -0.08548491f, 
    0.04344145f, 0.03597989f, 0.09504806f, 0.20351805f, -0.00544150f, 0.12890333f, -0.00441921f, -0.08862156f, 
    0.03353589f, 0.11083758f, 0.18251817f, 0.13719271f, -0.00832165f, 0.20142618f, 0.04465256f, 0.04106645f, 
    0.10196232f, 0.12039474f, 0.15683083f, 0.02276419f, 0.07291678f, -0.01851599f, 0.00668776f, 0.08305497f, 
    0.02501854f, -0.05260814f, -0.10074934f, -0.09562545f, -0.09496304f, 0.18547344f, 0.00696646f, 0.20024668f, 
    0.13659598f, 0.00510808f, 0.10426880f, 0.23577973f, -0.02321305f, 0.00493901f, -0.13493742f, 0.23701003f, 
    -0.04179363f, -0.15039004f, 0.01601891f, 0.08600672f, -0.03293181f, 0.05272134f, 0.18934305f, 0.08427752f, 
    -0.08839028f, 0.06350576f, 0.48993936f, 0.14293723f, 0.07393294f, 0.09117024f, 0.06775558f, -0.12775394f, 
    0.11715326f, -0.01531835f, 0.05508554f, 0.01244030f, -0.48071635f, 0.18259478f, 0.07604606f, -0.28133595f, 
    0.19861940f, 0.06351119f, 0.01527048f, -0.06717333f, 0.12880813f, 0.13314670f, -0.01765013f, 0.03698726f, 
    0.14690259f, -0.19066423f, -0.14030865f, 0.06371307f, 0.08302049f, -0.02229725f, 0.09314559f, 0.09268612f, 
    0.00462636f, 0.09663758f, 0.04292246f, 0.01868375f, 0.19416709f, -0.37718779f, -0.13432385f, -0.06057801f, 
    0.11808542f, -0.00699764f, 0.15965432f, -0.05404492f, 0.05016994f, -0.12060802f, 0.04548406f, 0.03768836f, 
    -0.01803366f, 0.06016617f, 0.04816671f, -0.04293105f, 0.08180843f, 0.11783914f, -0.02284964f, 0.06806812f, 
    0.07728896f, -0.04265052f, 0.13651055f, 0.07979377f, -0.17026439f, -0.03306762f, 0.32262433f, 0.10666049f, 
    0.22243160f, 0.21618327f, 0.15704933f, 0.05545034f, 0.03476970f, 0.19361542f, -0.06439967f, 0.03846344f, 
    -0.27648547f, -0.12863524f, 0.21332191f, 0.21602732f, -0.04834666f, 0.12607582f, 0.12386578f, -0.03955091f, 
    0.00823392f, 0.03626395f, -0.01771017f, 0.03825046f, -0.13489181f, -0.41934368f, -0.16284345f, 0.02465083f, 
    0.11561987f, 0.04878744f, 0.03911577f, 0.04118597f, 0.01704821f, 0.00762251f, -0.06105121f, 0.02352360f, 
    0.24144430f, -0.04724010f, 0.04887250f, -0.12721372f, 0.03841226f, -0.17457983f, 0.06196619f, 0.10665285f, 
    0.07641598f, -0.01772540f, -0.00995423f, 0.04907562f, -0.22949781f, 0.01713436f, 0.14485472f, 0.26162583f, 
    0.19366200f, 0.12896484f, -0.03897866f, -0.02707271f, 0.13968474f, 0.11396767f, 0.13395557f, 0.10049678f, 
    0.09341833f, 0.09157331f, 0.13062397f, 0.01881491f, 0.09097008f, 0.01314150f, -0.05160921f, 0.08417974f, 
    0.03183469f, -0.02453990f, 0.03110014f, 0.10092242f, -0.14034650f, 0.28018525f, -0.14399973f, -0.29905495f, 
    0.18578561f, -0.08897968f, 0.13999617f, 0.02586737f, -0.02823757f, 0.05066612f, 0.18168901f, 0.06209606f, 
    -0.23589614f, -0.00684124f, 0.24536160f, 0.04872806f, -0.01464477f, 0.03386251f, 0.12554285f, 0.00013383f, 
    0.01250492f, 0.04052753f, 0.19322923f, 0.13644898f, 0.02156905f, 0.21263818f, 0.10599121f, -0.16399901f, 
    0.18508498f, 0.24054109f, 0.03408675f, 0.11359112f, 0.00184823f, 0.14999963f, 0.01112634f, 0.04421012f, 
    -0.23187038f, 0.12756699f, 0.09539042f, 0.01680306f, 0.10967922f, 0.20514648f, 0.03379335f, 0.11003691f, 
    0.07398576f, -0.07107036f, 0.03140197f, 0.10981158f, -0.02946906f, -0.26855713f, -0.31630120f, 0.19445816f, 
    -0.17568485f, 0.10903294f, -0.03316467f, 0.00336648f, 0.04259464f, -0.10628649f, 0.12965789f, -0.00299489f, 
    -0.06799699f, -0.07532657f, 0.05226272f, -0.06840800f, -0.04237253f, 0.01828628f, 0.05050569f, -0.05053962f, 
    0.03665958f, -0.01278013f, -0.00262091f, 0.01956335f, 0.01954113f, 0.04907456f, -0.03530959f, -0.02192756f, 
    0.03137156f, -0.07746602f, -0.03765997f, 0.00482608f, -0.07725268f, -0.00859037f, -0.07033184f, 0.02258407f, 
    0.00987219f, -0.02276505f, -0.04847640f, 0.02545495f, -0.06820082f, -0.01178946f, 0.03162584f, -0.00786508f, 
    -0.04316966f, -0.07355326f, -0.05030815f, -0.03159028f, -0.00493104f, 0.04641327f, 0.04229575f, -0.00702333f, 
    0.00256907f, -0.01810223f, 0.04186515f, 0.02544430f, 0.05131296f, -0.03614550f, -0.04279968f, 0.05640032f, 
    0.05198685f, -0.01587626f, -0.01300837f, -0.01655475f, -0.08054572f, 0.02755441f, -0.04183974f, -0.00081916f, 
    0.04177308f, -0.00474470f, 0.01059846f, 0.05390059f, 0.05949863f, 0.02427242f, -0.03555389f, -0.07877925f, 
    0.04891649f, 0.00063872f, 0.05914068f, -0.08242460f, -0.06714298f, 0.01003428f, 0.00214906f, -0.01450348f, 
    0.02627895f, -0.06838078f, -0.03213634f, 0.02254786f, 0.02964845f, 0.01590080f, -0.02619617f, 0.04058667f, 
    -0.01980075f, -0.00848495f, 0.00286097f, -0.05990072f, 0.04504002f, -0.06785428f, 0.06230124f, 0.01808664f, 
    0.05466207f, 0.04003782f, 0.03211797f, 0.01310098f, 0.01432194f, 0.04408933f, 0.04109230f, 0.04109827f, 
    0.01048068f, -0.06796730f, -0.02039626f, -0.07107862f, -0.07356152f, 0.05248760f, 0.02510306f, 0.00827783f, 
    -0.03924943f, -0.05286020f, 0.01455557f, 0.03763443f, 0.00386595f, -0.05638728f, 0.04331186f, -0.06908432f, 
    0.02982494f, -0.02561051f, -0.05490617f, 0.06210100f, 0.00456538f, -0.08500589f, 0.00312818f, -0.07999652f, 
    0.05527415f, 0.00152553f, 0.00700830f, 0.05968208f, -0.00201404f, 0.01739842f, -0.00985715f, 0.04398106f, 
    -0.07054710f, 0.01091918f, -0.02752135f, -0.07432888f, 0.05873568f, 0.00413768f, -0.06668878f, 0.03436596f, 
    0.00190669f, -0.01477348f, -0.07898779f, -0.02732589f, 0.05747233f, -0.07617931f, -0.01240020f, 0.00326914f, 
    -0.07128841f, -0.03547353f, -0.06472645f, -0.03669500f, 0.03550669f, -0.06682362f, 0.05413410f, 0.02371006f, 
    -0.01097660f, -0.04275339f, 0.03851360f, -0.03208886f, -0.07649573f, -0.01576094f, -0.07708719f, -0.02014489f, 
    0.05473794f, 0.04688006f, -0.02579923f, -0.03890593f, 0.00652267f, -0.06502657f, -0.03418036f, 0.04150280f, 
    -0.03334952f, 0.03527635f, -0.06730241f, 0.02412029f, -0.06582104f, 0.00227653f, 0.00046800f, 0.05266673f, 
    -0.04574295f, -0.05894033f, -0.00112335f, -0.01339523f, -0.04948725f, -0.07626127f, -0.01008729f, 0.04515070f, 
    0.00981790f, -0.01967724f, 0.03441251f, -0.01263506f, 0.04344003f, 0.03093773f, -0.03454508f, -0.07560755f, 
    0.01133750f, -0.01115550f, -0.08538675f, 0.00631180f, 0.04198162f, -0.05593462f, -0.03014705f, -0.02288486f, 
    0.02568681f, 0.02591874f, -0.03463848f, -0.01061783f, -0.03872976f, 0.04517419f, -0.03445053f, 0.00908721f, 
    -0.03264947f, -0.05777417f, -0.07773496f, -0.05607922f, 0.03250588f, -0.03205708f, -0.03353423f, -0.03310618f, 
    -0.01733965f, -0.05944974f, 0.01845668f, -0.06421266f, -0.06605656f, -0.07391823f, -0.00236599f, 0.02447318f, 
    -0.04712113f, -0.00437322f, 0.00162035f, -0.08128028f, -0.05930311f, 0.02076929f, -0.03817021f, 0.04621568f, 
    -0.02693880f, -0.02853158f, 0.00040853f, 0.05304641f, 0.02449117f, -0.01232353f, -0.06649148f, -0.03183702f, 
    -0.02322594f, -0.08832260f, -0.03251852f, 0.03298877f, 0.01258562f, -0.05856382f, 0.01457500f, 0.03082154f, 
    0.00263533f, 0.00054354f, -0.02922111f, -0.04889701f, 0.01696453f, 0.03935986f, -0.05091272f, -0.00617108f, 
    0.00912511f, 0.05047135f, -0.01893471f, -0.07068062f, 0.01117352f, -0.03133631f, 0.04362417f, -0.06417694f, 
    0.04556991f, 0.01012319f, -0.00063592f, -0.03974563f, -0.08245512f, -0.04488857f, 0.02224414f, -0.07081030f, 
    -0.08040264f, 0.00970022f, -0.05634056f, 0.01593312f, -0.04680184f, -0.02751437f, 0.00164431f, -0.04212023f, 
    -0.03348169f, 0.04325243f, -0.02188919f, -0.08171193f, -0.00181590f, -0.04748562f, 0.02550304f, 0.02185534f, 
    0.04847676f, 0.03385941f, 0.05084093f, 0.01063939f, 0.02264610f, -0.05298373f, 0.02365049f, -0.08772300f, 
    0.00189822f, -0.03957592f, -0.04378283f, 0.02116710f, 0.06276067f, -0.04086446f, -0.08861192f, 0.03232071f, 
    -0.06606798f, -0.04187853f, 0.00169585f, -0.03192332f, -0.04208752f, -0.07974806f, 0.00735219f, -0.07829345f, 
    -0.00704909f, -0.02852229f, 0.01631517f, 0.00167392f, -0.03324269f, -0.05297032f, -0.05210349f, 0.05037582f, 
    0.04524532f, -0.07219429f, -0.06882660f, 0.00698155f, -0.06885079f, 0.02004345f, 0.00143825f, -0.02332357f, 
    0.02195896f, 0.03719869f, 0.00104148f, -0.05795528f, -0.06898851f, -0.00151675f, -0.02725610f, -0.01355518f, 
    0.04415724f, -0.00446263f, -0.02833346f, -0.01309422f, -0.08650054f, -0.01308714f, -0.07837591f, 0.01225584f, 
    -0.01234330f, 0.05191788f, -0.02066563f, -0.00662391f, -0.07661293f, -0.00002888f, 0.05044147f, 0.03087518f, 
    -0.02398112f, -0.01625061f, -0.05668630f, 0.00983880f, 0.02756491f, -0.05646048f, -0.00829819f, -0.06019526f, 
    0.02391736f, -0.05860304f, -0.04618927f, -0.06410819f, -0.06280687f, -0.03705554f, 0.01483460f, -0.07748563f, 
    0.05511100f, 0.03818604f, -0.03283093f, 0.01357056f, -0.06844062f, 0.03010434f, 0.02614941f, -0.01905922f, 
    0.05328194f, -0.03782378f, -0.02989843f, 0.04230155f, -0.06273510f, -0.00417819f, -0.02434508f, -0.06772240f, 
    0.21262638f, 0.11437852f, -0.27206495f, 0.08532616f, 0.03290068f, 0.05206833f, -0.09731027f, 0.09755475f, 
    0.09094832f, 0.04644917f, -0.01664027f, 0.00018032f, 0.18726723f, -0.40433648f, -0.14687140f, 0.03276776f, 
    -0.20707290f, -0.02254385f, 0.04487873f, 0.05550059f, 0.12316046f, -0.01598048f, 0.20034480f, 0.09473617f, 
    -0.18054962f, 0.12992533f, 0.22096418f, -0.10218249f, -0.05414855f, 0.13979355f, 0.02166724f, -0.03778217f, 
    -0.01298024f, 0.05148892f, 0.10244274f, 0.00387159f, 0.06806601f, 0.08055313f, -0.17079090f, -0.04160464f, 
    0.02365847f, -0.04430551f, -0.08863549f, 0.09198567f, 0.23034286f, 0.23781018f, -0.06919136f, 0.01834782f, 
    -0.23283115f, 0.14926885f, 0.09878843f, 0.12838554f, -0.05433340f, -0.06256600f, 0.00354622f, -0.06162882f, 
    0.01631049f, -0.03529462f, 0.03823396f, 0.08336961f, -0.22600925f, 0.20775306f, -0.04331613f, 0.08206680f, 
    -0.12602602f, -0.11701808f, -0.03021427f, -0.09742031f, 0.02458029f, -0.07892370f, -0.00275465f, -0.01701589f, 
    -0.15776448f, -0.15847993f, -0.14175288f, -0.11443105f, 0.00436453f, 0.01011046f, 0.08739452f, -0.03026507f, 
    -0.05161483f, -0.00926188f, 0.06198505f, 0.05698644f, 0.15087643f, 0.16437635f, -0.12739384f, -0.08443362f, 
    -0.03024620f, -0.07568248f, 0.04339775f, 0.14679450f, 0.12053693f, -0.11114436f, -0.10298591f, 0.10024284f, 
    0.30381075f, -0.24939454f, -0.19504772f, -0.36767256f, -0.02545446f, 0.08656126f, -0.02098409f, -0.09199704f, 
    -0.11431118f, 0.06849370f, -0.01508724f, 0.04070293f, 0.17725874f, -0.23040442f, 0.00076917f, -0.13169838f, 
    -0.09568864f, 0.00430466f, 0.03451482f, 0.02864960f, 0.06147468f, -0.10645554f, -0.02533370f, -0.02759716f, 
    0.20384596f, 0.19185844f, -0.05844085f, 0.03474765f, 0.05467528f, 0.12219215f, 0.04370295f, 0.10550629f, 
    0.02124315f, 0.03239194f, -0.12620521f, -0.05938545f, 0.23364173f, -0.10682347f, 0.14117856f, 0.00421553f, 
    -0.21447733f, -0.00037325f, -0.05897227f, -0.00609091f, 0.01874211f, 0.09946360f, 0.06859556f, 0.02283682f, 
    0.04493601f, 0.10663143f, 0.25066891f, 0.03667090f, 0.02785051f, 0.02883847f, 0.01643088f, 0.09754796f, 
    0.19486600f, 0.05436760f, 0.01292003f, 0.06670777f, -0.15149726f, 0.20960398f, -0.02488982f, 0.11097690f, 
    0.01901585f, 0.01528309f, 0.00309396f, -0.03353934f, 0.09447590f, -0.02753148f, 0.04654836f, -0.05221489f, 
    0.17935683f, 0.08010141f, 0.14957905f, -0.03631448f, -0.01683927f, 0.04318635f, 0.19100966f, -0.02578542f, 
    -0.05504598f, 0.03472818f, 0.10446205f, 0.03439823f, 0.12293215f, -0.15646209f, 0.08307169f, -0.08309206f, 
    -0.00998709f, -0.01193961f, 0.17842640f, -0.06535751f, 0.13463521f, 0.01148215f, 0.02870598f, 0.00710139f, 
    0.05222381f, 0.04254752f, -0.08015883f, -0.03974177f, -0.07521978f, 0.01184533f, -0.00764224f, -0.02321176f, 
    0.01486015f, -0.07300133f, -0.02878419f, 0.03029275f, -0.05400226f, 0.06516637f, -0.03377026f, -0.00329684f, 
    0.03273752f, -0.07146392f, -0.01723971f, 0.00130147f, 0.04560529f, 0.04979789f, 0.05088847f, -0.03965853f, 
    0.06247346f, -0.01632910f, -0.02408394f, -0.06748523f, -0.00836939f, -0.02833423f, -0.00134011f, -0.03791753f, 
    -0.08072723f, -0.01401534f, -0.02499337f, -0.06959975f, -0.05555517f, 0.05891198f, -0.04718937f, -0.01484663f, 
    -0.01481449f, -0.04440289f, -0.04037932f, -0.02980517f, 0.04816320f, -0.06454635f, 0.04495440f, 0.02361234f, 
    0.03292814f, 0.04690988f, -0.00171147f, -0.01827475f, 0.01557184f, -0.00808040f, 0.00433765f, -0.06591548f, 
    -0.06182761f, -0.02161671f, -0.06144568f, -0.07023665f, 0.00653301f, 0.03577347f, -0.05834875f, 0.00653028f, 
    -0.03138785f, 0.04950666f, -0.04861812f, -0.07252991f, -0.03780255f, 0.05902269f, -0.05863579f, -0.00818647f, 
    -0.02268042f, -0.04411466f, -0.06499315f, 0.00482611f, -0.05438316f, -0.03017096f, -0.02500032f, 0.04198361f, 
    -0.01744299f, -0.04209433f, -0.01247902f, 0.03373187f, -0.08051412f, 0.03375961f, 0.00826784f, -0.06207365f, 
    -0.01077971f, -0.07163236f, -0.01982605f, -0.03131263f, 0.01612317f, -0.05771313f, 0.06095667f, -0.02448348f, 
    -0.03209435f, 0.02294937f, -0.01156700f, -0.07850310f, 0.05899942f, 0.03127475f, 0.05689331f, 0.04396927f, 
    -0.01962332f, -0.05255164f, -0.03155908f, 0.01316428f, -0.05590485f, 0.03054267f, 0.02477868f, -0.03691069f, 
    -0.02548851f, 0.05309247f, -0.01707695f, 0.03796913f, 0.03903684f, -0.01414644f, 0.01993506f, -0.08071749f, 
    -0.06557293f, 0.00421425f, 0.02376934f, 0.05382423f, -0.02592502f, 0.01984962f, 0.02183046f, -0.06631251f, 
    -0.04131044f, 0.04353243f, 0.05773880f, -0.04719919f, -0.04037908f, -0.05094458f, -0.04991227f, 0.01182454f, 
    -0.05724300f, 0.04043895f, 0.01422668f, 0.05807063f, -0.04676630f, -0.05393334f, -0.03071664f, -0.05313401f, 
    -0.04828160f, -0.02589617f, -0.07886582f, 0.03940022f, -0.03591566f, -0.05135683f, 0.01869585f, -0.04011343f, 
    -0.06378457f, 0.05434505f, -0.05771684f, -0.00147570f, -0.07819464f, 0.00125476f, 0.02447326f, 0.02952890f, 
    -0.00821577f, -0.02992246f, -0.04083795f, -0.03720508f, 0.05771500f, -0.06679919f, -0.07863654f, -0.04330753f, 
    -0.02486933f, 0.05867336f, 0.03559308f, -0.05689496f, -0.02868237f, -0.02801202f, 0.01622508f, 0.03882934f, 
    0.01740216f, 0.02973530f, 0.02820350f, 0.02805664f, 0.06044261f, 0.05722113f, 0.05500075f, -0.01860769f, 
    0.02786043f, -0.01324180f, -0.02456318f, -0.03828854f, -0.04020401f, -0.02536859f, 0.05505950f, -0.06954224f, 
    0.10557805f, 0.13104807f, -0.16900854f, -0.21722548f, 0.00861928f, 0.10556893f, -0.00942547f, -0.06219425f, 
    -0.04496718f, 0.22530800f, -0.00385728f, 0.00588563f, 0.28885096f, -0.15272991f, -0.22647603f, -0.18956593f, 
    -0.07564551f, -0.16511127f, -0.02756794f, 0.02549994f, 0.12456386f, 0.02980822f, 0.12701762f, 0.07823372f, 
    0.01210544f, -0.00731852f, 0.29192466f, -0.03149820f, -0.06252031f, -0.06732734f, -0.13707733f, -0.08689086f, 
    -0.06079511f, -0.09661587f, -0.00731950f, -0.10524555f, -0.13503832f, 0.11378937f, 0.05434441f, 0.05596495f, 
    0.00672397f, 0.07653023f, -0.01123118f, 0.14734395f, 0.00113191f, -0.07391340f, -0.23159014f, -0.03896151f, 
    0.28478795f, -0.15665260f, 0.07413646f, 0.07041782f, -0.14138274f, -0.21155429f, -0.01232125f, -0.18291026f, 
    -0.04665583f, -0.01881175f, -0.12552795f, -0.11515833f, 0.35156885f, 0.04162731f, -0.20030206f, -0.03472444f, 
    -0.03830644f, 0.08833575f, -0.03415332f, 0.02513708f, 0.06707013f, 0.19296415f, -0.09136689f, -0.05865059f, 
    -0.05528433f, -0.07708619f, -0.25205538f, 0.02244507f, -0.04959056f, -0.06894364f, 0.11014136f, -0.08078922f, 
    -0.03850857f, -0.02340399f, 0.07578262f, -0.14189246f, 0.00202661f, 0.15175189f, -0.01881420f, -0.01926764f, 
    0.01575821f, 0.03621376f, 0.04735972f, -0.01854766f, -0.00755694f, 0.09455817f, 0.06104977f, -0.11097404f, 
    0.00161311f, -0.31910524f, -0.15224658f, -0.08220039f, -0.05134591f, 0.16431718f, 0.03522277f, 0.25036097f, 
    -0.04857476f, 0.07773653f, 0.11424468f, 0.04579521f, 0.15950060f, 0.19283773f, -0.19526877f, 0.15277432f, 
    -0.11555143f, -0.10358240f, 0.11575841f, 0.04980845f, -0.00922757f, 0.05650458f, 0.02684998f, 0.09301484f, 
    0.28760484f, 0.12532365f, 0.06200970f, 0.27201763f, -0.12298836f, 0.07922314f, -0.08266066f, -0.06101284f, 
    0.13145797f, 0.08956416f, -0.09312313f, 0.02329650f, 0.43840346f, -0.09879432f, -0.01102917f, 0.04137345f, 
    0.05555128f, -0.03582884f, -0.03688985f, -0.18637599f, 0.11049963f, -0.15440646f, 0.03993403f, -0.10540799f, 
    0.09430432f, -0.00421290f, -0.18996599f, 0.20093703f, -0.08386984f, -0.07134010f, -0.01233267f, -0.13177553f, 
    0.03509061f, -0.03317942f, 0.01999413f, 0.05849792f, 0.10370746f, -0.16942848f, 0.12908621f, 0.05393831f, 
    -0.10659452f, 0.02275602f, 0.01326576f, -0.04906235f, -0.06509006f, -0.04584209f, -0.03928529f, 0.09605305f, 
    0.12223031f, -0.12518570f, -0.04026912f, 0.19447255f, 0.01020267f, 0.05155871f, -0.06781220f, 0.10567614f, 
    0.05439076f, 0.06661828f, 0.04678331f, 0.10541938f, 0.04758321f, 0.25928110f, -0.06995131f, 0.03597538f, 
    -0.01047654f, -0.14568201f, 0.00543296f, 0.13428617f, -0.07357334f, 0.16293849f, 0.20893347f, 0.08549847f, 
    -0.06784591f, -0.03737228f, 0.03983926f, 0.04028396f, -0.05247766f, 0.01029093f, 0.05192773f, -0.05000391f, 
    -0.07654411f, -0.00764864f, 0.04833222f, 0.01513522f, -0.00047827f, -0.03109952f, -0.04541055f, 0.05567127f, 
    -0.05019170f, 0.00665048f, 0.01157092f, -0.05127232f, -0.00768347f, 0.03745009f, -0.08503393f, -0.02336325f, 
    -0.03794807f, 0.01085816f, -0.03922799f, -0.05678794f, 0.04925648f, 0.03625771f, -0.04070310f, -0.05313618f, 
    -0.03323268f, 0.00821603f, 0.01004716f, 0.04376692f, -0.03804548f, -0.01976103f, 0.05608452f, -0.04226083f, 
    0.00190830f, 0.02387751f, 0.05086630f, -0.02695814f, -0.06770411f, 0.01178100f, -0.05563428f, -0.02327065f, 
    -0.03525880f, -0.05565475f, -0.01281221f, 0.05049429f, -0.08109995f, -0.05455263f, -0.01590460f, -0.08146323f, 
    -0.05105130f, -0.03167966f, 0.01010030f, -0.01219706f, -0.06057800f, -0.01091372f, -0.07025564f, 0.02428246f, 
    -0.06590565f, -0.01116230f, 0.03705662f, -0.07663231f, -0.02464388f, 0.03361401f, -0.01720580f, 0.02830484f, 
    -0.00354952f, -0.04625803f, -0.02942022f, -0.00508361f, -0.04250874f, 0.02007683f, -0.02141965f, 0.01496615f, 
    0.00500467f, -0.02850200f, -0.03035485f, 0.00908167f, 0.00815450f, 0.02855253f, -0.07493420f, 0.02781772f, 
    0.03212976f, -0.03656910f, 0.02227964f, 0.00649832f, -0.04801398f, 0.04757567f, -0.07247950f, -0.04267090f, 
    0.02940363f, -0.00417655f, 0.02178712f, -0.04438324f, 0.04215195f, 0.00036803f, -0.02312889f, 0.06816427f, 
    -0.05400577f, 0.00482396f, 0.00166891f, 0.04803432f, -0.02965050f, -0.02986360f, -0.07010885f, 0.03534950f, 
    0.01780221f, 0.04402265f, -0.02936701f, 0.00799740f, 0.02436626f, 0.02443275f, 0.02816922f, -0.03164966f, 
    -0.00115845f, -0.08555723f, 0.04547037f, 0.00256518f, -0.07382195f, -0.07046596f, -0.02261589f, 0.04077296f, 
    -0.05880935f, 0.05931007f, -0.04906455f, -0.03871140f, -0.06135008f, -0.09471440f, -0.03261214f, -0.03702675f, 
    -0.06856240f, -0.05325049f, 0.04186360f, -0.03265065f, -0.08456120f, -0.00546546f, -0.08530036f, 0.03360792f, 
    0.03944090f, -0.05333279f, -0.06242883f, -0.01884861f, -0.05288674f, 0.04874679f, 0.03540083f, 0.04942187f, 
    0.06298856f, 0.06223901f, 0.04032454f, -0.00775557f, -0.09386010f, 0.00365583f, -0.02868323f, -0.01875513f, 
    -0.04321596f, -0.04323885f, -0.03419141f, 0.06115642f, 0.03263241f, -0.02145099f, -0.05014422f, -0.06819613f, 
    0.05691291f, -0.08205907f, 0.02877065f, 0.03415643f, 0.05510999f, -0.01502134f, -0.07713149f, 0.03713847f, 
    -0.00411652f, 0.02078203f, -0.02693041f, -0.05951158f, -0.04409597f, -0.01602590f, 0.03103147f, 0.01641690f, 
    -0.08018278f, -0.04456193f, 0.06159750f, 0.06242504f, 0.05381427f, -0.00022307f, -0.03983075f, -0.05842251f, 
    0.20094088f, -0.09375929f, -0.20626488f, 0.05047259f, -0.02516660f, -0.04758821f, -0.03661937f, 0.04493782f, 
    -0.03688319f, -0.10009751f, 0.04445734f, 0.05502761f, 0.35520142f, -0.05950633f, 0.17490134f, 0.08069497f, 
    0.11532346f, -0.04916713f, 0.01264256f, -0.04655931f, -0.01446422f, -0.00959051f, 0.05705425f, -0.04319045f, 
    -0.25601649f, -0.12923941f, 0.05406623f, 0.04882557f, -0.04322245f, -0.02409210f, -0.09794924f, 0.11624968f, 
    0.04395436f, -0.00654289f, -0.00961600f, 0.06043551f, 0.29669574f, 0.09822363f, -0.02555587f, -0.07024311f, 
    0.08711704f, -0.05228217f, -0.09114409f, -0.01830362f, -0.11512862f, -0.06645172f, 0.06572205f, -0.01334472f, 
    0.37054673f, 0.15229040f, -0.06551453f, 0.18130861f, 0.01931095f, 0.03739511f, -0.00419629f, -0.02223550f, 
    0.06924484f, 0.00149458f, -0.04754486f, 0.00338250f, 0.22523865f, 0.22687073f, -0.11897690f, 0.01069365f, 
    -0.04029910f, 0.02900119f, -0.15371192f, -0.00248728f, 0.03014891f, -0.14010602f, 0.09186434f, 0.00576187f, 
    0.37075171f, 0.17847045f, 0.01165034f, -0.25795719f, 0.01979834f, -0.07039126f, -0.05652157f, 0.08303778f, 
    0.05347325f, 0.04621261f, 0.12549677f, 0.02862793f, 0.03550004f, -0.05731664f, -0.08571157f, 0.01525296f, 
    0.05005816f, 0.02146513f, 0.02263284f, 0.02868950f, 0.01183292f, 0.01788587f, 0.00597623f, -0.03026231f, 
    0.13314591f, -0.05790128f, -0.04772507f, -0.02295904f, -0.01688143f, 0.10193365f, -0.05668940f, -0.17370111f, 
    -0.02838836f, 0.08643538f, -0.04068359f, 0.05452473f, -0.05005082f, 0.01378182f, -0.00550668f, -0.18846759f, 
    -0.00914477f, 0.02486393f, 0.04441269f, 0.04571800f, 0.10640837f, 0.06075494f, 0.20811749f, 0.04181417f, 
    -0.28063190f, -0.44093373f, 0.06621217f, -0.02881639f, -0.15226874f, 0.01850573f, 0.01088682f, -0.00660618f, 
    -0.06649423f, 0.04806247f, 0.13368398f, 0.12445418f, 0.21550417f, 0.07252881f, 0.00974882f, 0.26462981f, 
    0.11538275f, 0.03081522f, 0.00703970f, -0.05628038f, 0.07950195f, -0.07010221f, -0.03723645f, 0.12645353f, 
    0.27583340f, 0.16836318f, 0.02329823f, -0.08526650f, 0.11926309f, 0.11444382f, 0.08057762f, 0.10006389f, 
    -0.00456586f, -0.03331209f, 0.02478199f, -0.06878572f, 0.30831024f, -0.14216967f, 0.02277284f, 0.23864233f, 
    -0.06476946f, 0.05978982f, -0.09043968f, 0.01848927f, -0.01202661f, -0.09353973f, 0.07834502f, 0.14990473f, 
    -0.00363832f, -0.14217483f, 0.08173755f, -0.13492030f, 0.10163424f, -0.02357663f, 0.04774228f, -0.01838580f, 
    0.04849063f, 0.04035877f, 0.09306362f, -0.05630147f, 0.12104223f, 0.02318460f, 0.06709132f, -0.02214231f, 
    0.17034575f, 0.03698551f, 0.07909101f, -0.02464307f, 0.02200217f, 0.06120133f, -0.00646139f, 0.09089674f, 
    -0.04492000f, 0.04172465f, -0.07612500f, -0.06626435f, -0.03454821f, -0.02524115f, 0.06285546f, 0.06343237f, 
    0.02037815f, -0.05035599f, 0.01719799f, -0.02401508f, 0.03904330f, -0.02684950f, -0.03796486f, 0.05935748f, 
    -0.00418710f, -0.07082271f, 0.01755880f, -0.07191267f, 0.01433310f, -0.07281041f, -0.03105906f, 0.00293223f, 
    -0.00408622f, -0.05015512f, -0.06441072f, -0.04639984f, 0.02024976f, 0.05631777f, 0.03696474f, -0.02050353f, 
    -0.00566105f, -0.07490493f, 0.04673623f, 0.02259923f, 0.00256739f, 0.01068830f, -0.08938870f, -0.07672176f, 
    0.02769670f, 0.00396298f, 0.06479103f, 0.01329079f, -0.06309350f, -0.06290446f, -0.04906688f, -0.05332495f, 
    0.06604245f, 0.00432615f, 0.03297940f, -0.03654383f, 0.03480473f, -0.06501415f, -0.03114574f, -0.03017806f, 
    -0.00130698f, -0.06113287f, 0.01675072f, 0.02931098f, 0.01417835f, 0.04861498f, -0.07134228f, -0.02051755f, 
    0.04853783f, -0.02788322f, -0.02478055f, -0.02583782f, -0.00600143f, -0.01814700f, -0.02428951f, 0.02195587f, 
    0.02688810f, -0.08682726f, 0.02957135f, -0.07151742f, 0.05294159f, 0.04912926f, 0.00818809f, -0.07857565f, 
    -0.01632232f, -0.07276957f, 0.01350277f, 0.03954848f, -0.06163660f, -0.05853789f, 0.01131161f, -0.04455410f, 
    0.01047604f, -0.00696091f, -0.06745726f, -0.03955344f, 0.05294460f, -0.06203415f, 0.02677680f, -0.01246815f, 
    0.06348720f, -0.06395371f, -0.06347402f, -0.03118564f, -0.03909018f, -0.04503008f, -0.00775346f, -0.05394559f, 
    0.00333450f, 0.06644090f, -0.03444223f, -0.03683817f, 0.02169263f, -0.03601325f, 0.02784354f, 0.05417750f, 
    0.06022295f, 0.04897105f, 0.05668486f, -0.07080996f, -0.01267746f, -0.07633190f, 0.01968764f, -0.03766084f, 
    0.05473932f, -0.02070067f, -0.06589247f, -0.03045636f, 0.00574430f, -0.03406749f, 0.05826649f, 0.03339295f, 
    -0.01930047f, -0.06657713f, -0.08657819f, -0.02603170f, -0.05071047f, -0.01583425f, 0.02790795f, -0.05788242f, 
    -0.00370177f, 0.02103225f, 0.01401740f, 0.04599432f, -0.02408889f, -0.08478316f, 0.05780442f, -0.00598151f, 
    0.05097174f, 0.03553724f, 0.00254750f, -0.02110883f, -0.00616154f, -0.08982040f, 0.04629973f, -0.06113152f, 
    -0.07242871f, 0.03723133f, -0.03030448f, -0.07646620f, -0.06728856f, -0.02492590f, 0.05830710f, 0.05512369f, 
    -0.03279927f, -0.04588278f, 0.01811563f, 0.03643312f, 0.01983512f, 0.02729664f, -0.06676725f, 0.03165368f, 
    0.01915843f, 0.02850150f, 0.04022507f, 0.05505580f, 0.04933867f, 0.00084472f, -0.00350803f, 0.03507745f, 
    -0.01901737f, 0.06139673f, -0.03481859f, -0.03512752f, -0.05245109f, 0.04523648f, -0.01932091f, 0.04534301f, 
    -0.05211252f, -0.07610576f, 0.05704089f, 0.05829217f, -0.07132326f, 0.01468176f, -0.06429602f, 0.06424109f, 
    0.24675150f, -0.06712218f, -0.04166636f, 0.11845101f, 0.10057383f, -0.06257188f, -0.06106550f, 0.00664791f, 
    0.01268935f, -0.13632849f, 0.04683116f, 0.05220880f, 0.22590585f, -0.07355352f, 0.29062676f, 0.01221823f, 
    0.18110263f, 0.17370363f, 0.07329086f, -0.03582826f, 0.15466543f, 0.13476536f, 0.13187943f, 0.02861851f, 
    -0.11025721f, -0.06010886f, -0.19796605f, -0.10083228f, 0.03745041f, 0.06012819f, 0.02405403f, 0.04443943f, 
    -0.01508130f, 0.15699030f, -0.06061343f, 0.10272378f, 0.26970926f, -0.06733745f, -0.06120039f, -0.07850235f, 
    0.01922230f, 0.02611219f, -0.08159599f, 0.11705203f, 0.04526206f, -0.04226573f, 0.08177164f, -0.05235901f, 
    -0.23759262f, 0.22324066f, 0.01142249f, 0.01417034f, 0.10505837f, 0.11666953f, 0.02067577f, 0.07565542f, 
    0.10196047f, -0.05949399f, 0.10077694f, 0.08327121f, -0.11904851f, 0.13840529f, 0.04136824f, 0.20716359f, 
    0.08129630f, 0.10160772f, 0.04277742f, 0.00373131f, -0.08187320f, 0.03738848f, 0.06149517f, 0.04593883f, 
    0.16051199f, 0.10243631f, 0.20206571f, 0.02488992f, -0.01531853f, 0.00182055f, 0.19188830f, 0.05960432f, 
    0.03925803f, 0.12100667f, 0.08261533f, 0.06774696f, 0.00211323f, -0.18924819f, 0.05835672f, -0.03217316f, 
    -0.03675259f, -0.05204440f, -0.06690947f, 0.04030040f, -0.07662764f, -0.12121642f, 0.06159491f, 0.07378067f, 
    0.26596045f, 0.06597307f, 0.00088328f, -0.03206990f, -0.11068133f, -0.10904546f, -0.02355363f, -0.02032594f, 
    0.04543778f, 0.06774396f, -0.00753688f, -0.07166846f, -0.37227061f, -0.11707158f, 0.02605324f, -0.02412703f, 
    0.06069804f, -0.02749409f, -0.01398976f, 0.00079377f, 0.02598033f, 0.09495547f, 0.00133647f, 0.07922269f, 
    -0.00286606f, -0.05203878f, -0.04410351f, 0.02743181f, 0.08003954f, 0.04041322f, 0.06648479f, -0.01226398f, 
    0.02208290f, 0.07661538f, 0.00638432f, 0.04735938f, -0.33073789f, 0.18962878f, 0.05775130f, 0.01643245f, 
    0.17405888f, -0.06248765f, -0.06197838f, 0.05076015f, -0.00705416f, 0.06880458f, 0.10453322f, 0.17401712f, 
    0.06595109f, 0.18232781f, 0.12314144f, -0.06223540f, 0.16476862f, 0.04171528f, 0.19454180f, -0.00703163f, 
    0.05411144f, 0.08861791f, 0.14010508f, 0.15665837f, 0.21752636f, -0.01162531f, -0.06152213f, 0.02294250f, 
    0.07924621f, 0.19991814f, 0.04206045f, 0.03739950f, -0.04109222f, 0.07871733f, 0.00549690f, -0.01845234f, 
    -0.13935123f, 0.11205244f, 0.01169531f, -0.15095058f, 0.15406871f, 0.07149062f, 0.13966802f, -0.06853996f, 
    0.14923860f, 0.04652959f, 0.06904594f, -0.09445716f, 0.22581349f, -0.24096195f, -0.06674086f, 0.01722844f, 
    -0.02501777f, -0.01987491f, 0.00812500f, 0.10793591f, 0.10007824f, 0.01796474f, -0.09072110f, -0.00530846f, 
    0.11686268f, -0.02435453f, -0.08886504f, -0.03231613f, 0.01428089f, 0.11118340f, -0.14586286f, 0.16168992f, 
    -0.00439067f, 0.13691585f, 0.07650712f, 0.02574604f, 0.04135857f, -0.05105092f, -0.21379435f, 0.13524239f, 
    0.11836863f, -0.13633455f, -0.03499431f, -0.07527104f, 0.03872890f, -0.12501101f, 0.12024747f, -0.00050914f, 
    0.37959990f, 0.16945301f, 0.11137121f, -0.05164152f, 0.10714664f, -0.03060900f, 0.05282040f, 0.10057827f, 
    0.19702668f, 0.18697129f, 0.02940127f, 0.23417409f, 0.07108098f, 0.16950706f, -0.00231556f, -0.00665951f, 
    0.03201802f, -0.17133611f, 0.06395303f, -0.03024570f, 0.00421796f, 0.05729235f, 0.12030965f, 0.02977120f, 
    -0.02904760f, 0.02341302f, 0.06924242f, 0.11493169f, -0.01251829f, 0.12454829f, 0.07104377f, 0.07850870f, 
    -0.01753134f, 0.02935910f, -0.00563903f, -0.00191850f, 0.07319643f, -0.37631658f, -0.03630135f, 0.11248216f, 
    -0.06753964f, 0.09645258f, -0.03676280f, 0.06364473f, 0.07356253f, -0.02464145f, 0.08325633f, 0.15615174f, 
    -0.06377850f, 0.01794693f, 0.30196372f, -0.18368433f, -0.06363696f, -0.05617244f, -0.09640753f, 0.11929568f, 
    -0.11762903f, 0.01652142f, -0.10197338f, 0.07733680f, 0.10542009f, -0.11917969f, 0.04526216f, -0.08694188f, 
    0.06002388f, 0.07991340f, -0.00756002f, 0.10847115f, 0.00501648f, 0.00564237f, 0.21689115f, 0.16025618f, 
    -0.24655983f, 0.42375326f, 0.01216338f, -0.22219600f, 0.17918846f, -0.12155376f, -0.02266826f, 0.05340312f, 
    0.08706552f, -0.07508784f, 0.02486275f, 0.02333925f, -0.22790146f, 0.00511364f, 0.04371079f, 0.15121548f, 
    -0.06100531f, 0.03117169f, -0.09911397f, 0.14602281f, 0.00947149f, 0.00587028f, -0.06221550f, 0.01931037f, 
    0.33505440f, 0.27777600f, -0.06197599f, -0.16320151f, 0.06133244f, 0.15760688f, -0.15313679f, 0.09511233f, 
    0.04722682f, 0.10899608f, 0.10367855f, -0.03283875f, -0.25147218f, -0.13535677f, -0.04547777f, 0.37634379f, 
    -0.09318502f, -0.08165212f, 0.09409775f, -0.01556306f, 0.10337149f, 0.01699926f, 0.07950449f, 0.06923687f, 
    0.22438134f, -0.35974634f, 0.00555223f, 0.05178407f, 0.11498143f, 0.12155227f, 0.08540004f, -0.18898812f, 
    0.07419051f, 0.07065364f, -0.13129856f, 0.02073981f, -0.41159561f, -0.01750875f, 0.08035256f, 0.14591798f, 
    0.04466376f, 0.03988739f, -0.02743572f, 0.14290798f, -0.02008806f, -0.04623085f, -0.01813681f, 0.10431830f, 
    0.04767145f, -0.01351640f, 0.13587976f, 0.18860859f, 0.05990509f, -0.00447428f, -0.10486171f, -0.06948201f, 
    0.07051226f, -0.04327171f, 0.05055860f, 0.01109744f, 0.01748330f, -0.12665758f, -0.05099185f, 0.31588271f, 
    -0.04557063f, 0.00080233f, -0.07698996f, 0.13332565f, -0.09201297f, -0.00693756f, -0.09164669f, 0.16131233f, 
    0.23699197f, 0.09031765f, 0.15202646f, 0.09232493f, 0.09275179f, -0.03355281f, 0.04681371f, 0.00470822f, 
    -0.08831858f, -0.01040668f, 0.01617532f, -0.06400760f, -0.08711809f, 0.02580601f, 0.11943484f, 0.00551272f, 
    0.00041240f, -0.09676673f, -0.05982160f, -0.06822117f, -0.11366317f, 0.04610894f, -0.01655763f, 0.08695339f, 
    -0.16188465f, -0.20581949f, -0.02631431f, 0.18760100f, 0.01158855f, 0.01511625f, -0.13314135f, -0.16885924f, 
    0.08625110f, 0.12424770f, -0.07271612f, -0.08566158f, 0.27448896f, -0.25292155f, -0.04930813f, -0.10856726f, 
    0.13037090f, 0.02838040f, 0.02677494f, 0.13915381f, -0.00261314f, 0.07831371f, 0.03297422f, -0.19668019f, 
    -0.10541562f, 0.22734787f, 0.05599645f, 0.07544632f, 0.04639978f, -0.06552297f, 0.07282268f, -0.15586677f, 
    -0.05936633f, -0.11630992f, -0.09719393f, 0.11950514f, -0.00804203f, 0.24409892f, 0.22603330f, 0.20975676f, 
    -0.04254600f, -0.01835362f, 0.02221341f, -0.03993951f, -0.02443866f, 0.10035557f, -0.03778388f, -0.04742944f, 
    -0.21491770f, 0.14045560f, 0.09096301f, 0.09027620f, 0.06431928f, 0.03757222f, 0.04351106f, 0.09435596f, 
    -0.09175607f, 0.04791781f, 0.09105375f, 0.08147776f, -0.22800615f, -0.36227304f, -0.12161314f, -0.09095418f, 
    -0.03063942f, 0.04436007f, 0.07779772f, 0.05756219f, 0.04901947f, 0.16947243f, -0.28732979f, -0.21279977f, 
    0.60842174f, -0.25908673f, -0.08082786f, -0.33574095f, 0.01695652f, 0.10563008f, 0.07712412f, 0.19254506f, 
    -0.05825143f, 0.05577437f, 0.05629125f, 0.08226173f, -0.24795684f, -0.15824425f, 0.20654868f, -0.19862679f, 
    0.00462070f, -0.02639861f, -0.00431124f, 0.08097915f, 0.28834727f, 0.16960871f, -0.14690793f, 0.07258951f, 
    0.03497355f, -0.06828515f, 0.13000946f, -0.00420548f, -0.03943243f, -0.15777606f, -0.13832209f, 0.06348112f, 
    -0.02526492f, -0.00818215f, 0.00101572f, 0.10887119f, 0.38734266f, 0.29475299f, 0.00760619f, -0.06560731f, 
    -0.00938634f, -0.15661615f, -0.12389962f, -0.30469882f, -0.02162498f, -0.02261536f, 0.11951382f, -0.01703393f, 
    -0.12733245f, 0.03477530f, 0.22104789f, -0.12152700f, 0.04127397f, 0.12379014f, -0.06471393f, -0.09602457f, 
    -0.04893005f, -0.08078985f, 0.14649275f, 0.06234977f, 0.32069159f, 0.20847495f, -0.06518354f, 0.08219431f, 
    0.03519692f, -0.01599546f, 0.09292987f, 0.01285074f, 0.10744122f, -0.00041377f, 0.03818704f, -0.07396021f, 
    -0.08625501f, -0.10911572f, -0.10113479f, -0.00288693f, 0.11643785f, 0.07855806f, -0.01429805f, -0.05101896f, 
    -0.01694951f, 0.02764397f, -0.00691008f, 0.08179870f, -0.07472425f, -0.04580402f, -0.03729111f, -0.04571041f, 
    -0.07689223f, 0.04441744f, 0.10328966f, -0.03225397f, 0.02191017f, -0.01245332f, 0.10347215f, -0.01740244f, 
    -0.41631091f, 0.21905760f, 0.18103895f, 0.06088159f, -0.03555197f, 0.12890640f, 0.02946750f, 0.04848148f, 
    0.02935364f, -0.07744481f, -0.06527959f, -0.16272525f, -0.25011140f, 0.31213316f, -0.01713421f, 0.18223348f, 
    0.01617402f, 0.04253623f, -0.04887548f, -0.01212787f, -0.00925286f, 0.00131720f, -0.09087603f, 0.01344855f, 
    0.18526222f, 0.17443208f, 0.10404624f, 0.22621197f, 0.10050187f, 0.07646184f, 0.08684327f, 0.08441914f, 
    0.12364235f, 0.12571783f, 0.00098002f, -0.03284208f, -0.11092468f, 0.02642018f, 0.02824075f, -0.32432142f, 
    0.00987344f, 0.01476877f, -0.05799024f, 0.02614894f, -0.01129431f, -0.02107232f, 0.09793978f, 0.09381080f, 
    -0.00043758f, -0.09059054f, -0.22647516f, 0.03373175f, -0.06309634f, 0.08751493f, -0.02037269f, 0.05532648f, 
    -0.07784721f, 0.01836440f, -0.04736554f, 0.02174660f, 0.15351281f, -0.21004578f, -0.06844526f, -0.03173253f, 
    0.01945278f, -0.17550337f, -0.00308052f, 0.03947942f, -0.00482606f, 0.10852017f, -0.04934710f, 0.08573364f, 
    -0.02117439f, -0.07499559f, 0.18738714f, 0.00333466f, -0.21960938f, -0.01361219f, -0.05095688f, 0.13916773f, 
    -0.08602118f, 0.06091261f, -0.08585806f, -0.00899643f, 0.12814566f, 0.06978785f, 0.08079380f, 0.01213422f, 
    0.21356268f, 0.03381652f, -0.03892011f, 0.14064626f, 0.09628547f, 0.05245127f, -0.03326852f, 0.18908033f, 
    -0.34462497f, 0.35302013f, 0.02097128f, -0.11344867f, 0.18000957f, 0.03563777f, -0.01740625f, -0.09039547f, 
    0.22371133f, -0.13970032f, 0.05071391f, 0.04433890f, 0.36531794f, 0.04293785f, 0.19321752f, 0.09479767f, 
    0.02038354f, 0.11874785f, -0.12327244f, 0.15197307f, -0.12272163f, 0.01112975f, -0.05170833f, 0.17226632f, 
    0.12397824f, 0.13452113f, 0.29572991f, 0.00196387f, 0.04130459f, -0.10732445f, 0.10201025f, 0.25749800f, 
    -0.09014860f, 0.00240260f, -0.06626447f, 0.00445159f, 0.04411076f, -0.11439161f, -0.08021818f, 0.02945601f, 
    -0.10719858f, 0.02046204f, 0.06299536f, -0.03641772f, -0.04503071f, 0.09203131f, 0.06164093f, 0.00509109f, 
    0.00899951f, -0.31107825f, 0.00522326f, 0.00007400f, -0.15150423f, -0.01234486f, -0.01394278f, -0.05914969f, 
    -0.10098003f, -0.03779254f, -0.21786766f, -0.08943506f, -0.20845403f, 0.11633410f, 0.00960132f, -0.04881831f, 
    0.02370615f, -0.01228668f, 0.14689651f, 0.05027876f, -0.04624432f, -0.03592575f, 0.04671133f, 0.05097099f, 
    0.14946234f, 0.17463294f, 0.21550761f, 0.17720513f, -0.03418176f, -0.02598367f, -0.13917187f, -0.02362760f, 
    -0.04000642f, -0.01111140f, 0.03154162f, 0.02760257f, 0.08235882f, 0.02800804f, -0.05218875f, -0.01477147f, 
    -0.01814600f, 0.30147049f, -0.00780336f, -0.07316245f, -0.11548048f, -0.02897486f, -0.04661527f, 0.10173932f, 
    0.00121095f, 0.05644773f, -0.00146955f, -0.02996389f, -0.10047803f, -0.10790032f, -0.01328654f, 0.00249669f, 
    -0.14464746f, -0.10851493f, 0.14826241f, 0.20831954f, 0.05012653f, -0.10776899f, -0.09476446f, -0.40413669f, 
    0.22923045f, 0.13170946f, 0.00823622f, -0.11238045f, 0.06523567f, 0.12289437f, -0.04596185f, -0.06944163f, 
    -0.14714786f, -0.01125748f, -0.08403934f, 0.21548447f, -0.02890195f, -0.14393809f, -0.01291362f, -0.01514956f, 
    -0.00323315f, 0.00510789f, 0.03431061f, -0.05481068f, 0.46214104f, 0.00376659f, 0.01021190f, 0.18144694f, 
    -0.05183789f, 0.01206259f, -0.02973417f, -0.05165390f, -0.11987572f, 0.00365879f, 0.01401529f, -0.06332687f, 
    -0.02622671f, -0.04100426f, -0.07547275f, -0.10439539f, 0.18920922f, -0.00564473f, -0.01218458f, 0.00751241f, 
    -0.01398396f, 0.09886621f, 0.06017171f, 0.08401553f, -0.05573761f, 0.03782913f, -0.05431785f, -0.20212831f, 
    0.26572511f, 0.15366755f, 0.01663857f, -0.02732209f, 0.00048361f, 0.08652060f, 0.05348989f, -0.10369238f, 
    0.15444347f, 0.31711289f, 0.01671336f, -0.04129860f, 0.19396538f, -0.09272813f, 0.00411596f, -0.08698948f, 
    0.16079234f, 0.06211969f, 0.14884792f, -0.00217215f, 0.19427523f, 0.10795606f, 0.16685680f, -0.02987600f, 
    -0.17253336f, -0.13621923f, 0.00217053f, -0.20395263f, -0.05525431f, -0.03056650f, -0.02693029f, -0.09450419f, 
    0.10243984f, 0.03436200f, 0.12712605f, 0.15226421f, -0.14828411f, -0.00407223f, 0.05196013f, 0.16782418f, 
    -0.08226893f, 0.00422768f, -0.05113244f, -0.07815462f, -0.22136258f, 0.18625955f, 0.00994958f, -0.00514008f, 
    0.04282810f, 0.11397621f, 0.06302989f, -0.15902026f, 0.20443910f, 0.07139989f, 0.08258066f, -0.00349188f, 
    -0.18426089f, -0.15844059f, -0.23814991f, 0.23407000f, 0.14438674f, -0.00131926f, -0.13205597f, -0.20092143f, 
    0.03696088f, 0.03481789f, 0.09575618f, -0.02939387f, -0.39060143f, -0.06865798f, -0.25040361f, -0.04309789f, 
    0.19954243f, 0.05017797f, 0.08656427f, -0.06803090f, 0.02324002f, 0.05361548f, 0.04856532f, 0.11594681f, 
    0.02489601f, 0.25381210f, -0.21502660f, -0.01240915f, 0.30122223f, -0.01612841f, -0.01229393f, 0.07706815f, 
    0.09787765f, 0.11259874f, 0.15806690f, -0.02889533f, 0.37611586f, -0.29486412f, -0.14471783f, 0.01246208f, 
    0.10613108f, 0.06139709f, -0.07491408f, 0.03302523f, 0.03176308f, 0.03750609f, -0.01029907f, 0.04130469f, 
    0.02218257f, -0.08360244f, -0.02584122f, 0.10181203f, -0.06203033f, 0.03029648f, -0.05373044f, -0.06161905f, 
    0.14646047f, 0.10472204f, 0.01419022f, -0.07482506f, 0.09880882f, -0.00082918f, 0.03264366f, -0.06117442f, 
    -0.11835570f, -0.12931031f, -0.10799526f, 0.13756295f, 0.02164990f, 0.05276686f, 0.00670984f, -0.01604791f, 
    -0.07386271f, 0.01910535f, 0.03965231f, -0.05297290f, -0.03145831f, -0.04554106f, 0.06463820f, 0.03056977f, 
    0.04425848f, -0.03698584f, -0.07479660f, -0.07541292f, -0.06056711f, 0.05175412f, -0.04908676f, 0.01181820f, 
    -0.03027830f, -0.03024779f, -0.05702246f, -0.05716207f, -0.02915003f, 0.01420877f, 0.04425440f, 0.06635986f, 
    -0.06161994f, 0.03369497f, -0.01722196f, -0.05694278f, -0.02715920f, 0.01928413f, -0.00610869f, 0.01204540f, 
    0.00946190f, 0.04086025f, -0.02089113f, -0.07144071f, 0.02101735f, 0.01102594f, -0.02132095f, 0.00127830f, 
    0.05000410f, 0.00765987f, -0.03448979f, -0.06467747f, -0.05848438f, 0.04708110f, -0.01740901f, -0.04121185f, 
    -0.07059956f, 0.04566892f, 0.00396022f, 0.01420068f, 0.02278997f, 0.04802161f, -0.06602365f, 0.01613036f, 
    -0.00801064f, -0.01997109f, -0.05777381f, -0.06794683f, 0.05290139f, 0.04711482f, -0.01167087f, 0.00017526f, 
    -0.06918883f, -0.00449473f, 0.00814317f, -0.05215497f, -0.01059638f, 0.01894015f, 0.04889189f, 0.05214586f, 
    0.05759197f, -0.01896336f, -0.04826041f, -0.02494003f, 0.01517177f, -0.04060660f, 0.06349730f, 0.00220619f, 
    0.02580200f, -0.01001479f, 0.00905667f, 0.06437057f, -0.03167196f, 0.00802706f, -0.01482891f, 0.03424015f, 
    0.02685587f, -0.00541190f, 0.06112303f, -0.06867521f, 0.05964051f, 0.05508982f, -0.06173541f, -0.06980504f, 
    -0.01575497f, 0.00736387f, -0.03095087f, -0.05509675f, 0.01113403f, 0.01975843f, -0.02783144f, 0.05815442f, 
    0.02151543f, -0.06595302f, 0.03274513f, -0.01506243f, 0.02529502f, -0.00408028f, -0.05777390f, 0.02226046f, 
    -0.01847598f, 0.03206533f, 0.03138857f, -0.02450237f, 0.01482613f, -0.03316591f, 0.03528803f, -0.00903152f, 
    -0.05713220f, -0.05671183f, -0.02010716f, 0.04150016f, -0.02252296f, -0.01306360f, -0.05679312f, -0.02933876f, 
    -0.06404427f, -0.05578962f, 0.02861583f, 0.01357013f, 0.05801226f, 0.01996959f, 0.02778250f, -0.02272604f, 
    0.00672483f, 0.01101393f, 0.01315298f, -0.05316845f, -0.04571332f, 0.00416891f, 0.03068746f, 0.02133122f, 
    0.03308931f, -0.03844535f, -0.04149421f, -0.02221864f, 0.02151681f, 0.02490340f, -0.01637024f, -0.00317220f, 
    0.03670879f, 0.00475454f, -0.07941362f, -0.06382584f, -0.00766131f, -0.05933543f, 0.05068062f, -0.05638539f, 
    -0.02330666f, -0.01944641f, -0.01170668f, -0.07659438f, 0.06094035f, 0.01365635f, -0.04340094f, -0.06658146f, 
    -0.03642214f, 0.02995392f, -0.06199893f, -0.04984155f, -0.02895479f, 0.03324173f, 0.04441465f, 0.04448084f, 
    -0.06451056f, -0.06678469f, -0.05564780f, -0.06834611f, 0.04263655f, 0.02084495f, 0.04001639f, -0.00076946f, 
    -0.03332047f, 0.03042914f, -0.04554703f, 0.01976988f, -0.02112324f, -0.01706116f, -0.02588527f, -0.03694546f, 
    0.02543108f, 0.03822810f, -0.05531318f, -0.01412317f, -0.05800399f, 0.04705193f, 0.00140548f, -0.02829943f, 
    -0.04521622f, -0.00746304f, 0.01860562f, -0.06371319f, 0.02569162f, -0.00015743f, -0.04785708f, -0.07039513f, 
    -0.02020167f, -0.02926807f, 0.02709593f, -0.01015994f, -0.04690728f, -0.06993322f, 0.06154532f, -0.05615044f, 
    -0.01437806f, -0.07568943f, -0.07347789f, -0.05003935f, -0.00981474f, -0.05909071f, 0.05373139f, -0.02157216f, 
    0.05364748f, 0.05002356f, -0.06820155f, 0.00117471f, 0.02724385f, -0.03650826f, 0.02341483f, -0.01547292f, 
    -0.06551503f, -0.02059019f, -0.03107902f, -0.06592213f, 0.00257824f, 0.04871453f, -0.01882943f, -0.03327432f, 
    -0.01951038f, 0.04583689f, 0.05980056f, 0.00902391f, 0.05161878f, 0.00047976f, 0.03313640f, 0.04456396f, 
    0.00469835f, 0.01124311f, 0.03477614f, -0.02895502f, -0.02238478f, -0.02492834f, -0.01660765f, -0.01361880f, 
    0.02922107f, 0.06778216f, 0.02492862f, -0.04220958f, -0.02822759f, 0.01805420f, 0.02029696f, -0.05093354f, 
    -0.04930817f, -0.03770270f, -0.05358626f, -0.03208143f, -0.00434352f, -0.05352385f, -0.07460191f, 0.05909146f, 
    -0.06908134f, 0.01543672f, -0.06827980f, 0.05340675f, -0.04481119f, 0.02872223f, -0.02039893f, 0.04209053f, 
    0.03530402f, 0.05129821f, -0.04825945f, -0.03317631f, -0.01936492f, -0.01530985f, 0.05485274f, 0.02838001f, 
    0.05892298f, -0.06743927f, -0.06420695f, 0.03868004f, -0.02820838f, 0.04924510f, -0.07213561f, 0.04717512f, 
    -0.01544278f, 0.04295450f, 0.05193779f, -0.06964839f, 0.06003374f, -0.02287569f, -0.05490897f, -0.00893932f, 
    -0.01598024f, -0.05357454f, -0.01218081f, 0.04426770f, -0.07153549f, -0.05096607f, 0.01935713f, -0.00241113f, 
    0.04014643f, -0.06719707f, -0.02509114f, -0.06082170f, 0.04946847f, -0.02085710f, 0.02446704f, -0.03816624f, 
    -0.07040586f, 0.04241228f, -0.05539201f, -0.00843128f, -0.03244451f, 0.04643282f, -0.02430394f, 0.03922712f, 
    0.04628270f, -0.05053974f, 0.01672369f, -0.05656151f, -0.00270981f, -0.00437329f, 0.02186940f, -0.05059872f, 
    -0.02962198f, 0.01883902f, -0.00424396f, -0.04159161f, -0.02594475f, -0.02414012f, 0.03111154f, -0.06781495f, 
    -0.02410116f, 0.06303689f, 0.05738015f, -0.02017000f, -0.05508211f, 0.06621807f, -0.04098022f, 0.01756347f, 
    -0.03391276f, 0.05211869f, -0.06959746f, -0.03912718f, 0.04982452f, 0.04029867f, 0.04056125f, -0.04316660f, 
    0.01987793f, 0.02388855f, -0.06465834f, 0.00721596f, -0.07472862f, 0.05324215f, -0.04485309f, -0.06208118f, 
    -0.05449583f, 0.04632952f, -0.07263952f, -0.05208769f, 0.01821518f, -0.02175671f, -0.05435954f, -0.03386350f, 
    -0.02353443f, -0.00515109f, 0.00319816f, 0.01347454f, -0.06371693f, -0.01789318f, 0.05809216f, -0.03835320f, 
    -0.16266865f, 0.09700190f, 0.09504800f, -0.05898543f, 0.06276671f, 0.03593251f, -0.02717783f, 0.00904987f, 
    -0.12235544f, 0.16417256f, -0.01568756f, 0.05205891f, -0.15691701f, 0.31388131f, -0.10998945f, 0.02040341f, 
    0.15740938f, -0.09283279f, 0.03035824f, -0.07504354f, -0.02536311f, -0.09956926f, 0.02606578f, 0.07528553f, 
    0.11374906f, -0.06045303f, 0.08714475f, 0.15003362f, 0.10851491f, -0.11259174f, -0.10118493f, -0.03286661f, 
    0.01826963f, 0.02716262f, 0.09059200f, -0.00138464f, -0.00012555f, -0.04464214f, 0.05123408f, -0.02517834f, 
    0.03792104f, -0.03099069f, 0.03462393f, -0.03961568f, 0.01874735f, -0.03612442f, -0.22813189f, 0.01556578f, 
    0.21307118f, -0.06112761f, -0.03141245f, -0.06847709f, 0.00460696f, -0.07934397f, -0.05820578f, -0.11279074f, 
    -0.19855575f, -0.04863650f, -0.08649706f, -0.05805085f, 0.20607121f, -0.29854366f, 0.08015250f, 0.07922714f, 
    0.01293787f, 0.07060731f, -0.00780594f, 0.15451612f, 0.02380671f, 0.16121264f, 0.00987325f, -0.04471801f, 
    -0.16927390f, 0.10817042f, 0.15303944f, -0.05173195f, -0.20879884f, -0.00627145f, -0.02511008f, -0.15577592f, 
    -0.09222129f, 0.10164218f, -0.09393352f, 0.01022514f, -0.13790755f, -0.20122451f, 0.04917721f, -0.07344007f, 
    0.00767396f, 0.04495508f, 0.02689496f, 0.04755207f, 0.15904687f, 0.19404252f, -0.08846277f, 0.06029102f, 
    0.01240751f, -0.04326243f, -0.06314579f, -0.27407372f, 0.16040023f, 0.09955545f, -0.04846164f, 0.06536826f, 
    0.08455512f, 0.02191831f, 0.09216544f, 0.11931060f, 0.18363297f, 0.22812855f, 0.14409040f, 0.18459302f, 
    -0.08318537f, 0.01242187f, 0.10629542f, 0.17678784f, 0.05282414f, 0.01284138f, 0.01970144f, 0.08846764f, 
    0.02738194f, 0.12025297f, 0.12723653f, -0.09466349f, -0.09000926f, -0.02249369f, -0.02941935f, 0.04062158f, 
    0.03584560f, -0.05220480f, 0.02498786f, 0.13066480f, 0.21635263f, -0.02419914f, -0.12227683f, -0.00604377f, 
    -0.02609183f, -0.01683849f, -0.09613594f, -0.19500302f, -0.09537663f, -0.06177846f, 0.04529590f, -0.13439025f, 
    0.04181126f, -0.35596913f, -0.04317516f, 0.11138184f, -0.00190713f, 0.03792913f, 0.06377552f, -0.15269986f, 
    0.02751017f, 0.03274962f, 0.09038182f, 0.06163282f, -0.11226138f, -0.08991461f, 0.07057925f, -0.04463368f, 
    -0.06755191f, 0.08085962f, 0.04738831f, -0.04731244f, -0.03814536f, -0.11201019f, -0.00567547f, 0.08540689f, 
    -0.06179155f, -0.09860146f, 0.12917762f, 0.17043294f, 0.05206238f, 0.05347633f, -0.07248961f, 0.01125341f, 
    0.04498345f, -0.08488261f, -0.02527993f, 0.26997688f, -0.08294135f, 0.05661676f, -0.02240911f, 0.09611719f, 
    0.03144321f, 0.09906062f, -0.03608483f, 0.08866183f, 0.03491712f, 0.04099387f, 0.11569672f, 0.12360678f, 
    -0.25438005f, 0.04730204f, 0.08091649f, -0.05626315f, 0.06830837f, -0.12312859f, -0.11899704f, -0.04743642f, 
    -0.09142502f, -0.01533654f, 0.14099257f, 0.05311063f, 0.30970046f, 0.11180171f, 0.03012157f, 0.15804541f, 
    0.01276218f, -0.05682455f, -0.15026318f, -0.14844218f, -0.06166612f, -0.13477661f, 0.02346242f, 0.05701868f, 
    0.11770544f, 0.20979021f, 0.05240561f, 0.10698084f, 0.03638121f, 0.01559888f, -0.04121875f, 0.03650390f, 
    0.14536017f, 0.08281604f, 0.04349227f, 0.04963044f, 0.01772639f, 0.09522475f, 0.04594991f, -0.16760254f, 
    0.10052556f, -0.11689577f, -0.06630625f, -0.00794785f, -0.04902228f, -0.00569118f, 0.14004830f, -0.02021647f, 
    -0.27467090f, 0.05604287f, -0.01964923f, 0.03133121f, 0.04849935f, -0.04051611f, -0.03551470f, -0.12422723f, 
    -0.07249951f, -0.03491465f, 0.05706786f, 0.00480809f, -0.13172086f, -0.24720757f, -0.16269024f, -0.08213960f, 
    -0.04793282f, -0.02454109f, 0.05294368f, -0.01221662f, -0.06092681f, -0.14646800f, 0.06875379f, -0.04445313f, 
    -0.27810425f, 0.29193553f, 0.23139621f, -0.31241411f, -0.12094459f, -0.16744214f, 0.01550832f, 0.04819729f, 
    -0.08835485f, 0.01384226f, -0.04818063f, 0.09027378f, 0.26084346f, 0.07264759f, 0.26937759f, 0.15864104f, 
    0.11570767f, 0.03369134f, 0.02182288f, 0.16694616f, -0.02364909f, 0.00220971f, 0.07935661f, -0.08545274f, 
    0.08138747f, 0.58972549f, 0.13664976f, -0.05529546f, 0.12745632f, -0.00647990f, 0.08794760f, -0.09145865f, 
    0.15091741f, 0.03437461f, -0.07552632f, -0.09108476f, -0.09965448f, 0.17446040f, 0.12412793f, -0.02661853f, 
    0.05190721f, 0.10150106f, -0.02167706f, 0.17389852f, 0.03842371f, 0.03827286f, 0.06257043f, -0.06995244f, 
    -0.26724738f, 0.27070194f, 0.03113759f, -0.01568433f, 0.19276233f, -0.12888640f, 0.05710125f, 0.02118061f, 
    -0.10588790f, 0.18774389f, 0.19436708f, -0.07160555f, -0.01214314f, -0.06873707f, -0.06242967f, 0.37791806f, 
    -0.03981576f, -0.01825416f, 0.02244974f, -0.06947468f, 0.06629135f, -0.01358257f, -0.03377949f, 0.05301285f, 
    -0.00868825f, -0.25639704f, -0.03388549f, 0.03972506f, 0.13477820f, 0.04871829f, -0.08796386f, -0.11165229f, 
    0.03259634f, 0.00042398f, -0.03403324f, -0.07044204f, 0.01670092f, -0.02548192f, -0.02884448f, 0.05394389f, 
    -0.09655689f, 0.02014483f, -0.13416153f, -0.11106100f, -0.04320657f, 0.04947365f, 0.02131678f, -0.00476653f, 
    0.02530301f, 0.04952455f, 0.12369669f, 0.14521006f, 0.18763213f, -0.06364193f, 0.00274570f, -0.10256011f, 
    -0.02310776f, 0.08677790f, -0.07396529f, -0.07163426f, 0.10449263f, 0.04750535f, 0.07799353f, 0.18474209f, 
    0.12955111f, 0.28269491f, -0.01439308f, 0.09839135f, 0.06293192f, -0.01846872f, -0.09531504f, 0.04552254f, 
    0.30285990f, -0.05418265f, -0.32185015f, 0.02634722f, 0.10592616f, -0.08991346f, 0.04729500f, -0.00549577f, 
    -0.06516350f, -0.01021985f, -0.02264210f, -0.01276601f, 0.13314115f, -0.09320875f, -0.04449869f, 0.22033280f, 
    0.16263834f, 0.00229664f, -0.01253459f, -0.05712510f, 0.05037229f, -0.06066395f, 0.05423860f, 0.09661967f, 
    -0.07544676f, 0.09168044f, 0.00676837f, -0.03336102f, 0.11236247f, 0.10943121f, -0.05174708f, 0.03143464f, 
    0.11247673f, 0.16545326f, -0.09274881f, 0.06488243f, 0.31241944f, -0.06459071f, -0.02570874f, 0.04735316f, 
    -0.02635768f, -0.01984984f, -0.05131883f, 0.04853086f, 0.05396324f, 0.10778254f, 0.00035694f, -0.01216954f, 
    0.08632021f, 0.07198532f, 0.10004827f, -0.18938239f, 0.10261945f, 0.15209743f, 0.03344176f, -0.11659521f, 
    -0.12467527f, -0.00771881f, -0.05697418f, 0.08610816f, 0.02227066f, -0.00350495f, -0.04717383f, 0.09680430f, 
    0.00967795f, 0.00817523f, -0.13522305f, -0.00559432f, 0.07537936f, -0.00438583f, 0.05418148f, -0.05753230f, 
    0.29068545f, 0.28134695f, 0.25612679f, -0.21832322f, -0.03043460f, -0.08786921f, 0.02147787f, -0.02906459f, 
    -0.00152889f, 0.05287860f, 0.12069424f, 0.18426485f, -0.01819041f, -0.15563092f, 0.05360663f, -0.00020334f, 
    -0.01234870f, -0.05319058f, 0.08697198f, 0.08767530f, -0.07996265f, -0.09365336f, -0.00064886f, 0.01032120f, 
    0.28323501f, -0.01121386f, 0.07497272f, -0.07565910f, -0.07682768f, -0.00438010f, -0.05191583f, -0.07065370f, 
    0.04621974f, 0.00664031f, 0.07969820f, 0.06682023f, -0.32490104f, -0.04049093f, 0.18158525f, -0.03588674f, 
    0.00881123f, -0.01199177f, 0.01712831f, 0.14412425f, 0.00739192f, 0.01173226f, -0.01448638f, 0.00656743f, 
    -0.09116908f, -0.07824264f, -0.23526166f, -0.28235137f, -0.04328823f, 0.07507966f, -0.06287175f, -0.01707194f, 
    0.08101501f, 0.07272132f, 0.03609211f, -0.01760933f, -0.08637512f, -0.05203889f, -0.18956786f, 0.24422999f, 
    0.00490223f, -0.07585783f, -0.06980205f, 0.04243972f, 0.00004902f, -0.03731559f, 0.05992411f, -0.06510338f, 
    0.29327199f, 0.11874121f, 0.21010050f, -0.14953034f, 0.17695306f, -0.01732029f, 0.13438353f, 0.07617024f, 
    0.17754175f, -0.12410351f, -0.00234141f, 0.00301888f, -0.02642328f, -0.10073259f, -0.14014572f, 0.06926034f, 
    -0.10960633f, 0.06228748f, -0.09406779f, 0.00736288f, 0.05780108f, -0.13874668f, -0.11052322f, 0.10726594f, 
    -0.05060042f, -0.05481191f, 0.06001502f, -0.25917512f, 0.03240077f, 0.08156540f, 0.07545524f, -0.12133622f, 
    0.00681284f, -0.01428894f, 0.07245465f, 0.04722530f, 0.04821071f, 0.02090822f, 0.07686736f, 0.13729694f, 
    0.09178019f, 0.01515904f, -0.09430049f, 0.13200141f, 0.03334802f, 0.06144916f, -0.07330080f, 0.15991592f, 
    0.13826405f, -0.00818996f, 0.04765686f, 0.09734295f, 0.04101591f, 0.12157025f, -0.03219779f, -0.11980582f, 
    0.09803336f, 0.02128937f, -0.15407768f, -0.13273445f, -0.04054783f, 0.05274696f, -0.09235122f, 0.26384026f, 
    -0.09290702f, 0.08660430f, -0.08502622f, 0.12553045f, -0.02872675f, -0.09406265f, 0.07954887f, 0.11262449f, 
    0.10613033f, 0.00130249f, 0.03167000f, -0.14891507f, 0.05468860f, 0.10135205f, -0.06776655f, -0.00867729f, 
    0.02798900f, 0.09047003f, 0.00542895f, -0.02076646f, -0.09479686f, 0.13454379f, 0.03253638f, -0.01806447f, 
    0.08120774f, -0.06246195f, 0.03881573f, 0.03606522f, 0.23630892f, 0.14330871f, -0.09163299f, 0.03953973f, 
    -0.06135282f, 0.12599024f, 0.22685681f, -0.10954543f, -0.06270424f, -0.09746025f, -0.07787497f, -0.02911464f, 
    0.05739361f, 0.08071179f, -0.10887545f, -0.02819075f, -0.12815058f, 0.00263213f, 0.17488132f, 0.19334424f, 
    -0.13261800f, -0.11371591f, 0.01842299f, 0.01104465f, 0.05231347f, 0.24162455f, -0.06101627f, 0.03473078f, 
    -0.26413390f, -0.12356911f, 0.02902008f, -0.13850674f, -0.04305298f, 0.15023004f, 0.06541628f, -0.08805418f, 
    -0.04915095f, 0.00704243f, 0.02547072f, -0.07478722f, -0.06572106f, -0.11862195f, -0.18449292f, -0.15069941f, 
    0.01564011f, 0.09386410f, 0.14646628f, 0.21120451f, 0.13572933f, 0.17728472f, -0.08755653f, 0.06583545f, 
    0.44845736f, -0.06651792f, -0.21078493f, -0.11691995f, 0.08478869f, 0.09102301f, 0.08544383f, -0.09452863f, 
    0.01068613f, -0.01279197f, 0.00987513f, 0.14303347f, 0.05449888f, -0.07666174f, 0.12161251f, -0.20950468f, 
    -0.08500315f, 0.04627268f, -0.04860076f, 0.08856408f, 0.02970639f, 0.02686168f, -0.10359205f, -0.02802614f, 
    -0.00938371f, 0.26121613f, 0.13291013f, -0.26244354f, -0.10690826f, -0.05582766f, 0.01963374f, -0.01980709f, 
    0.03478389f, 0.03727541f, -0.09907369f, 0.07324769f, 0.26957452f, 0.09072158f, -0.04308198f, -0.01194591f, 
    -0.20100918f, -0.05782782f, 0.05176187f, 0.01187511f, 0.02668251f, 0.03001040f, -0.00874921f, -0.01097011f, 
    -0.01830176f, -0.22848243f, 0.26428860f, 0.04805994f, -0.13755465f, 0.03231258f, 0.03061281f, 0.00799253f, 
    0.00311925f, -0.00481852f, 0.04307776f, 0.03504527f, -0.33437490f, 0.31785926f, 0.05689089f, -0.03193604f, 
    0.01460893f, -0.04342734f, 0.11927061f, 0.04884934f, -0.01590132f, 0.09179003f, -0.04130039f, -0.08417339f, 
    -0.13441671f, -0.01563851f, -0.01409490f, -0.04300697f, -0.01535146f, 0.05403117f, 0.04620441f, -0.06450557f, 
    -0.15356055f, 0.03198503f, -0.01250911f, 0.15093079f, -0.21914387f, -0.04511493f, -0.05745816f, 0.09355817f, 
    0.04311181f, 0.15955374f, 0.03755581f, 0.04028742f, -0.02659224f, 0.02021772f, 0.10648809f, 0.04521516f, 
    -0.12841587f, -0.10366128f, -0.05006315f, 0.04813892f, 0.09518509f, -0.10057008f, -0.06147927f, 0.09490639f, 
    -0.10270087f, -0.09988379f, 0.02661216f, -0.05935048f, 0.25594133f, 0.16545142f, 0.31427446f, 0.07985483f, 
    -0.04954821f, 0.14836530f, -0.02687801f, -0.04940094f, 0.00520257f, 0.00032233f, -0.04745236f, -0.11255158f, 
    -0.27720177f, 0.08929892f, 0.00832137f, 0.26253688f, -0.03887723f, -0.06146632f, 0.04989215f, 0.13479075f, 
    -0.00590668f, 0.06625322f, -0.05948796f, 0.03602453f, -0.03841492f, -0.04766119f, -0.05082530f, -0.13619542f, 
    -0.04780951f, 0.02674953f, -0.11406198f, -0.05388009f, -0.06894398f, 0.00702830f, 0.08202416f, -0.01366170f, 
    0.14018728f, 0.02445547f, -0.11669230f, 0.15196067f, -0.01006075f, 0.10629992f, 0.02857509f, 0.10179867f, 
    -0.01238678f, 0.09256014f, 0.12658499f, 0.06960980f, 0.22366907f, 0.11800336f, -0.13345830f, -0.13952525f, 
    0.00600902f, 0.00040790f, -0.04429919f, -0.08852881f, -0.06089797f, -0.10397494f, 0.02396753f, 0.00944817f, 
    0.40674958f, 0.18695335f, 0.00889410f, -0.01484825f, -0.11121363f, -0.04874124f, -0.06784239f, -0.01894018f, 
    0.01721111f, 0.03226537f, 0.00196445f, -0.02735869f, 0.09071513f, 0.04464907f, -0.01064681f, 0.15980943f, 
    0.05173328f, 0.02335534f, -0.07823460f, -0.06632130f, 0.04537135f, -0.09547654f, 0.07637186f, 0.05628732f, 
    -0.44410226f, -0.00561113f, -0.06213237f, 0.04901327f, -0.00252152f, 0.01651604f, 0.06686477f, -0.21310475f, 
    0.08801556f, -0.00610893f, -0.03858985f, -0.09239560f, 0.06800476f, 0.08516067f, 0.01042007f, -0.09287869f, 
    0.02487899f, 0.01191331f, -0.05003337f, 0.13405013f, 0.08440308f, 0.06544359f, 0.06586654f, 0.08917702f, 
    -0.11811747f, -0.38917351f, 0.03891547f, 0.10148842f, -0.08427975f, 0.06002011f, 0.02996319f, 0.05440620f, 
    -0.02934281f, 0.08558334f, 0.15025961f, 0.00335546f, 0.04106651f, 0.01232280f, 0.15667583f, 0.12394740f, 
    -0.02854731f, 0.06150543f, 0.02271110f, -0.06279066f, -0.01190802f, 0.00373739f, 0.04771329f, 0.15243299f, 
    0.13986059f, 0.11630331f, -0.00829609f, -0.08258153f, -0.07611469f, -0.01426469f, 0.07331263f, 0.01191488f, 
    0.02113259f, -0.05979224f, -0.10020299f, -0.01892270f, 0.22223063f, -0.12543185f, 0.05658179f, -0.03033944f, 
    -0.02304781f, -0.00680985f, 0.00351943f, -0.05505620f, -0.07356165f, -0.04567226f, 0.14219511f, 0.08546560f, 
    -0.00801551f, -0.01338257f, 0.12056556f, 0.04526785f, -0.01460668f, -0.15995310f, 0.11397031f, 0.03140430f, 
    -0.03428007f, 0.07013793f, 0.03254190f, -0.16940074f, 0.05039074f, -0.06803647f, 0.09550906f, -0.24747233f, 
    0.14126849f, 0.03058652f, 0.05287909f, -0.05709020f, 0.11327645f, -0.01352092f, -0.13798620f, 0.01572814f, 
    -0.05242800f, 0.02986338f, -0.01940976f, -0.06625529f, -0.05958464f, 0.03735379f, 0.05667679f, 0.05083259f, 
    -0.07145912f, -0.03055352f, -0.03736128f, 0.02106991f, -0.03731273f, -0.03837879f, -0.06705045f, -0.06764898f, 
    0.05192795f, -0.07454491f, 0.04663606f, -0.03893890f, 0.04893296f, 0.06507195f, -0.02335905f, 0.01355214f, 
    -0.01326632f, -0.02543080f, -0.02058483f, -0.03498015f, -0.02351238f, -0.04978684f, -0.07548247f, 0.00574610f, 
    0.02876157f, -0.05288355f, -0.04454752f, -0.05576913f, -0.03882930f, 0.04950384f, -0.07907268f, -0.07578924f, 
    -0.06372681f, -0.03048809f, -0.03381727f, 0.03885461f, 0.03197665f, -0.06898089f, -0.05739601f, -0.03481485f, 
    -0.00054305f, -0.06787027f, 0.03616210f, -0.03118177f, 0.02699040f, 0.03820087f, -0.07168841f, -0.02521826f, 
    -0.01746165f, 0.05413606f, 0.02048585f, -0.00129768f, 0.02793249f, 0.06102955f, -0.02132530f, -0.04145927f, 
    0.02812905f, 0.06520323f, -0.06808566f, -0.02972385f, -0.00306323f, -0.06452437f, 0.04853518f, 0.04219738f, 
    -0.03922884f, -0.06973406f, 0.03919385f, -0.02371903f, -0.06488753f, -0.01807910f, 0.04209148f, 0.02045642f, 
    0.04781617f, 0.02927314f, -0.03735802f, -0.02107335f, 0.01691541f, 0.04086109f, -0.07155921f, -0.01887358f, 
    0.00801515f, 0.05138620f, 0.05694330f, -0.03719105f, -0.04835340f, -0.04891409f, -0.01252869f, -0.03741182f, 
    -0.06028767f, -0.04313748f, 0.01219442f, -0.01314268f, 0.00966527f, 0.00744642f, 0.05621174f, -0.06734096f, 
    -0.02129079f, -0.00571174f, -0.04240022f, 0.03448273f, -0.06766786f, -0.04806313f, -0.00369836f, -0.04863906f, 
    -0.01325145f, -0.04275704f, 0.05683169f, 0.05815410f, -0.00070303f, 0.02676587f, 0.06284146f, -0.00808378f, 
    -0.05745698f, 0.04793997f, 0.06067933f, -0.07547856f, -0.04187463f, 0.03131225f, -0.05225894f, 0.03544987f, 
    -0.06562828f, 0.05466465f, 0.00410258f, -0.06695918f, 0.05132100f, -0.07226437f, 0.01357226f, 0.01139761f, 
    0.03961640f, -0.02465663f, 0.04600618f, -0.07618111f, -0.06051910f, -0.04627270f, -0.00659195f, 0.04865240f, 
    -0.03942771f, -0.02362901f, -0.03049346f, 0.00760224f, -0.04699096f, -0.06305714f, 0.04830583f, 0.03413424f, 
    0.01353319f, 0.01990025f, 0.05929111f, -0.05376249f, -0.03696312f, -0.06908035f, -0.00930548f, -0.02904978f, 
    0.02319616f, 0.03165839f, 0.04321982f, -0.03275849f, -0.03350913f, -0.04096618f, -0.07276611f, -0.04574270f, 
    0.05760168f, 0.04817448f, -0.00095857f, -0.05768608f, -0.00337277f, -0.03094871f, 0.04764351f, 0.06367613f, 
    0.03914031f, 0.02605120f, -0.04635198f, 0.00645241f, 0.00402667f, 0.00135714f, -0.02100033f, 0.00547671f, 
    0.05919500f, 0.03134377f, -0.05750662f, -0.01210889f, -0.05859876f, 0.00533547f, 0.00315882f, -0.06511847f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00778728f, 0.01473260f, -0.06133937f, 0.00985971f, -0.06761108f, -0.03087477f, 0.02695236f, 0.05284204f, 
    -0.09751771f, 0.00259563f, 0.07113619f, 0.05897251f, 0.09284469f, 0.08679037f, 0.05098737f, 0.05927110f, 
    0.03617250f, 0.02522031f, 0.02327356f, -0.03500222f, 0.13070707f, 0.10720488f, -0.02088350f, -0.03222743f, 
    -0.06571079f, 0.02029316f, 0.06323110f, 0.03366890f, -0.02502788f, 0.05045956f, 0.05956255f, -0.07481833f, 
    -0.05422974f, -0.00204831f, 0.14788418f, 0.04343361f, 0.11238150f, -0.17421100f, 0.07846722f, -0.04289889f, 
    -0.02414296f, 0.00772599f, 0.10494589f, -0.05270714f, 0.01171771f, 0.11267629f, 0.05871709f, 0.06413851f, 
    -0.03436405f, 0.09667449f, -0.06901065f, 0.08216020f, 0.04877090f, 0.00477212f, -0.02801443f, -0.00829145f, 
    -0.03885202f, -0.02346156f, -0.00059154f, 0.02586596f, 0.07395247f, 0.01407492f, 0.01593945f, -0.03382540f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.00340882f, 0.36769149f, -0.07514360f, -0.07144265f, 0.09428777f, -0.02366053f, -0.12775980f, -0.20645380f, 
    -0.01270188f, -0.12981893f, -0.07907226f, 0.22008424f, 0.14542642f, -0.18251321f, -0.00125393f, 0.09162964f, 
    0.04783598f, 0.00150854f, -0.01192171f, -0.02728737f, -0.16969374f, 0.03335585f, 0.08571950f, -0.29316822f, 
    -0.05725764f, -0.13474765f, -0.04087302f, -0.04322195f, 0.06150099f, 0.09344681f, -0.34311873f, 0.10865271f, 
    0.13842124f, -0.38563612f, 0.01080735f, -0.67284209f, 0.18304394f, 0.33072120f, 0.20681383f, -0.11383525f, 
    -0.06754705f, 0.20898743f, -0.00893800f, 0.06003424f, -0.11659892f, -0.02694317f, 0.10969509f, 0.14883216f, 
    -0.02267859f, 0.08825837f, -0.08305625f, -0.07570417f, 0.17159779f, 0.33749261f, -0.16881096f, 0.03206539f, 
    -0.11978223f, -0.04759103f, 0.38070792f, 0.08731927f, 0.18562020f, 0.27502218f, -0.48263320f, 0.06852610f, 
    -0.10556996f, -0.11762337f, -0.05447943f, -0.10938729f, 0.13992390f, 0.04635284f, -0.12420290f, -0.35371438f, 
    -0.11102235f, 0.08630207f, 0.13856386f, 0.25458220f, 0.29122043f, 0.36165312f, 0.08701918f, 0.13112387f, 
    -0.08057095f, 0.01288696f, -0.02589465f, 0.01180275f, -0.05893278f, 0.32901898f, -0.16192918f, 0.14421338f, 
    -0.09646652f, 0.09862593f, -0.09004239f, -0.44320443f, -0.13041683f, 0.05026589f, -0.27355865f, -0.09391061f, 
    -0.06359547f, -0.09047852f, -0.22190942f, 0.40399069f, 0.05366540f, 0.03421389f, -0.22615780f, 0.07378160f, 
    0.33207995f, 0.09475820f, 0.23223700f, -0.09575517f, -0.03396054f, 0.04966890f, -0.04779118f, -0.12457532f, 
    -0.10400504f, 0.12181164f, -0.00672371f, 0.17104870f, -0.07521237f, 0.61959392f, 0.12086333f, -0.23674284f, 
    -0.07257869f, -0.02599038f, 0.05740196f, -0.17136386f, -0.06337120f, 0.12219689f, 0.16860823f, 0.12453625f, 
    0.02733153f, -0.22250804f, -0.11566313f, 0.01522128f, -0.03517643f, 0.05046040f, -0.24648798f, 0.01484104f, 
    0.05821026f, -0.08806296f, 0.22054410f, 0.23457360f, 0.02017622f, 0.08610892f, 0.17688484f, 0.28940427f, 
    0.06661369f, -0.07052369f, 0.04292476f, 0.02898535f, 0.26627946f, 0.17871736f, -0.23294020f, 0.01245513f, 
    -0.11268963f, -0.18532005f, -0.16685849f, -0.02222209f, -0.04825216f, -0.03210282f, 0.11335930f, 0.02866941f, 
    0.11543268f, -0.15705644f, 0.03386101f, -0.44547522f, 0.15115403f, -0.06553891f, 0.02464364f, 0.05897314f, 
    0.02974053f, 0.13184842f, 0.15715280f, 0.01367950f, 0.05033425f, 0.27663678f, 0.11046376f, -0.23173773f, 
    0.05099191f, 0.10986064f, 0.06779359f, 0.13871337f, 0.07741188f, 0.18201280f, -0.03045638f, -0.11492585f, 
    0.11156054f, -0.08636878f, -0.05961189f, -0.20900851f, 0.43518180f, 0.28689033f, -0.22766094f, -0.02431618f, 
    0.02231102f, -0.03626671f, -0.02927421f, 0.03210534f, -0.02064787f, 0.03350348f, -0.09909732f, -0.03452738f, 
    -0.10988803f, -0.02392416f, -0.07257438f, 0.06925202f, -0.07313772f, 0.06189207f, 0.03500047f, -0.09725124f, 
    -0.00732248f, 0.00657706f, -0.07012343f, -0.01366571f, -0.04629707f, -0.07502925f, 0.06646406f, -0.11470111f, 
    -0.02272232f, -0.12382732f, -0.01017338f, 0.03610655f, 0.04854332f, 0.06979191f, 0.04706879f, -0.06872760f, 
    -0.03125274f, -0.00691359f, -0.02005935f, 0.08929108f, -0.04023223f, -0.06538051f, 0.04299733f, 0.05076665f, 
    -0.11801392f, -0.00390172f, -0.00985994f, 0.01920652f, -0.05442202f, -0.12526187f, -0.09579077f, -0.11800577f, 
    -0.11312588f, 0.00938013f, -0.06165488f, -0.07237859f, -0.10249518f, 0.06619796f, -0.04662986f, -0.10075704f, 
    0.03686655f, 0.09017090f, -0.11165450f, 0.07322265f, -0.09074993f, 0.03305234f, 0.07867115f, 0.09485865f, 
    0.06120893f, 0.06899175f, -0.12818763f, 0.02190857f, 0.01350689f, 0.08261621f, -0.08581186f, -0.03035446f, 
    0.10200122f, 0.05173382f, 0.09245510f, -0.05953387f, -0.06039347f, 0.05285833f, 0.01833697f, -0.04032338f, 
    0.06208877f, -0.05337618f, 0.01606507f, 0.11982749f, 0.07651163f, -0.09883310f, -0.08293217f, 0.01129231f, 
    0.02852842f, 0.01422941f, -0.12888640f, -0.07192522f, 0.02870926f, 0.00833233f, -0.01506266f, -0.11938331f, 
    0.08802939f, -0.08970580f, -0.04779884f, -0.07032797f, -0.01899476f, -0.03872259f, 0.02373564f, 0.09874298f, 
    0.02031054f, -0.09301603f, 0.00697098f, -0.10831933f, -0.08896922f, 0.06400573f, 0.04122181f, -0.05005707f, 
    0.06842747f, -0.09741105f, 0.10579364f, 0.06867600f, -0.01158519f, -0.02208412f, -0.06498413f, -0.00370696f, 
    -0.03700891f, -0.12482579f, -0.08105078f, 0.00607748f, 0.02423511f, -0.06440344f, -0.02983326f, -0.09792304f, 
    0.01539885f, -0.20013164f, -0.01737838f, 0.08217442f, 0.01439640f, -0.01530522f, -0.02173320f, 0.18556596f, 
    0.06556468f, -0.04948787f, 0.23202659f, -0.10502423f, 0.10798073f, -0.16721486f, 0.11382304f, -0.03009148f, 
    0.12161493f, -0.08086940f, 0.01756952f, 0.03400485f, 0.26151013f, 0.34928349f, -0.05556257f, -0.59510952f, 
    0.07339685f, 0.09930362f, -0.10734579f, 0.05394516f, 0.07847872f, -0.12127430f, -0.02644038f, 0.09950170f, 
    0.19166602f, -0.35674357f, 0.08565270f, 0.01487030f, -0.10620967f, 0.23779501f, 0.31592932f, 0.04354869f, 
    0.12279986f, -0.10299681f, -0.16986334f, -0.06668360f, -0.00826041f, 0.19819464f, 0.03406457f, 0.21980001f, 
    0.00408780f, 0.05153500f, -0.08310049f, -0.15778869f, 0.15232028f, -0.00591952f, 0.26453868f, -0.18327633f, 
    0.01816732f, -0.01793832f, 0.30209050f, 0.26169193f, 0.19842656f, 0.11497881f, 0.14372535f, -0.11675671f, 
    0.02510696f, -0.06036244f, -0.11210048f, -0.24686770f, 0.32719919f, 0.08210610f, 0.32009986f, 0.00382757f, 
    -0.01451018f, 0.01338463f, -0.10064668f, 0.04699284f, 0.15072905f, 0.26984397f, -0.30783224f, 0.06810085f, 
    0.05507716f, 0.03364772f, 0.04903152f, -0.05514963f, 0.24229705f, 0.15546808f, 0.09293082f, -0.07492936f, 
    0.02063460f, 0.25652811f, 0.14885570f, -0.20437035f, -0.05688362f, 0.01125830f, -0.30375454f, 0.07721413f, 
    0.24098904f, -0.13486356f, -0.16568625f, 0.28856704f, -0.11783615f, 0.56513876f, -0.00138579f, -0.03237421f, 
    0.05684109f, -0.03977858f, 0.01564028f, -0.10177616f, -0.00077657f, -0.21949466f, 0.11985811f, 0.09265052f, 
    -0.07683958f, 0.16834632f, 0.12086792f, 0.04738253f, -0.38023064f, 0.25892508f, 0.08076731f, 0.33513278f, 
    0.00482728f, 0.03503593f, -0.19362271f, 0.11804213f, -0.09220234f, -0.29038599f, 0.30078322f, -0.09782080f, 
    -0.06227930f, 0.09797307f, -0.10769977f, -0.06072503f, -0.06103259f, -0.03803413f, -0.09149018f, -0.12434863f, 
    -0.01087579f, -0.01198180f, -0.02921182f, 0.06194818f, -0.05000306f, -0.04391331f, -0.00149409f, 0.03093439f, 
    -0.07724732f, 0.04712140f, -0.02344764f, -0.09328758f, -0.07358291f, -0.01290985f, -0.06234866f, -0.02238635f, 
    0.09586495f, 0.06397476f, 0.08225153f, -0.00756647f, 0.11990836f, 0.00049963f, -0.12338735f, -0.07117227f, 
    0.07620562f, 0.02168154f, 0.00867610f, -0.03230561f, 0.00925787f, -0.06582787f, -0.07655472f, 0.05053535f, 
    -0.04405196f, -0.14137341f, -0.06424830f, 0.09940824f, 0.09971312f, 0.07845632f, -0.00432688f, 0.02408103f, 
    0.07440807f, 0.11569162f, -0.12724680f, -0.10972039f, -0.10947299f, 0.11253285f, -0.05107449f, -0.12128955f, 
    0.07968081f, -0.11067177f, -0.10390312f, 0.01257316f, -0.08755215f, 0.03886029f, 0.10522097f, -0.00294906f, 
    0.06919536f, -0.12140883f, -0.08200006f, -0.03213115f, -0.13977860f, 0.06516889f, -0.11319387f, -0.05375173f, 
    0.10707194f, -0.05130523f, -0.10324681f, -0.09570281f, -0.07228966f, -0.10170395f, 0.09377211f, -0.08593465f, 
    0.09666230f, -0.11711967f, -0.05983062f, 0.08184561f, 0.05192099f, -0.01788505f, -0.10215100f, -0.13474990f, 
    -0.00439034f, -0.02382478f, -0.02138834f, -0.00226841f, 0.09607833f, 0.02703913f, -0.10414537f, -0.02954608f, 
    0.05494753f, -0.10315183f, -0.06445187f, -0.03739085f, 0.00800547f, -0.11478303f, -0.00055609f, -0.06935301f, 
    0.01867721f, -0.10470183f, 0.06822952f, 0.05673516f, 0.01243071f, 0.08801555f, 0.10470314f, 0.09955688f, 
    -0.11858758f, -0.13671540f, 0.10205126f, 0.04419542f, -0.13225369f, 0.08863090f, 0.01830246f, 0.04425015f, 
    -0.11685209f, 0.06687531f, 0.07844421f, -0.07711540f, -0.00274246f, -0.09652766f, 0.06941052f, -0.01784369f, 
    0.09274530f, 0.32844800f, 0.03922747f, -0.13235997f, 0.04464454f, -0.06835217f, 0.30913273f, 0.14978719f, 
    -0.06673040f, -0.04354171f, -0.14152779f, -0.21653305f, 0.07208714f, 0.06333508f, 0.00228679f, -0.09843526f, 
    -0.07890189f, -0.03692933f, 0.05975961f, -0.03408581f, 0.00650563f, -0.23575318f, 0.19274683f, 0.61999029f, 
    0.06890018f, 0.30392757f, 0.34143543f, 0.37707788f, 0.12472914f, -0.05954123f, 0.33206984f, 0.12977067f, 
    -0.04962857f, 0.38890088f, 0.22234175f, 0.04118443f, 0.08819608f, -0.19714913f, 0.02695505f, 0.04388847f, 
    -0.07991380f, 0.15158051f, -0.08413357f, 0.11868166f, 0.03615387f, 0.22196837f, 0.11416712f, 0.24623185f, 
    0.01273492f, -0.10745075f, -0.02148937f, 0.06679265f, -0.03882233f, -0.01236165f, -0.10990983f, 0.03005256f, 
    0.11825414f, 0.04464018f, -0.11845446f, 0.12826590f, -0.34645069f, -0.03605703f, -0.10348085f, 0.11845861f, 
    0.09011053f, 0.08823599f, -0.07391094f, 0.10725404f, 0.45006910f, -0.08438185f, 0.00013962f, 0.11449957f, 
    -0.00344050f, -0.09750768f, -0.00952023f, -0.29123393f, 0.41888270f, 0.16907072f, 0.15116672f, 0.11019941f, 
    -0.02967307f, 0.01146351f, 0.08753987f, -0.03443662f, 0.40199175f, -0.03455382f, 0.13449977f, -0.16963477f, 
    -0.03345683f, 0.29025626f, 0.28097704f, -0.03191851f, -0.03179558f, 0.07698930f, 0.01911865f, 0.06132684f, 
    -0.05772339f, 0.11441679f, 0.06420825f, 0.23060383f, -0.13045618f, -0.26343036f, 0.17461017f, 0.11120150f, 
    -0.08867276f, 0.18239754f, -0.11383016f, 0.04711202f, -0.07452299f, 0.33123559f, -0.06631136f, 0.43895736f, 
    -0.07587898f, 0.07958101f, 0.11700280f, -0.00350065f, 0.18133689f, -0.16714282f, -0.16679586f, -0.13767990f, 
    0.10455529f, -0.06631066f, -0.05730918f, -0.21931788f, -0.22893895f, 0.11818754f, -0.19454883f, 0.10996634f, 
    -0.09272730f, -0.36334655f, -0.12588778f, 0.19578138f, 0.27262568f, 0.00970743f, 0.05384799f, 0.02296915f, 
    0.08357286f, -0.05813519f, 0.23603870f, -0.18100260f, 0.32512465f, 0.33089703f, 0.25496972f, -0.13938704f, 
    -0.07624268f, 0.04719153f, 0.06527423f, 0.06052504f, 0.07266637f, -0.06791654f, -0.19772844f, -0.17669213f, 
    0.04354307f, 0.10951136f, 0.08572791f, 0.34800434f, -0.08139542f, 0.04167610f, 0.11138741f, 0.09959540f, 
    -0.11496064f, 0.48433203f, -0.05175852f, 0.48528436f, -0.09125773f, -0.02927439f, -0.08876047f, 0.04731260f, 
    0.08554445f, -0.08264254f, 0.09833998f, 0.11440075f, -0.05763185f, 0.19364695f, -0.04705985f, -0.02416662f, 
    -0.07045756f, 0.12650734f, 0.12046032f, 0.03645237f, 0.03101960f, -0.15604171f, 0.04178592f, -0.20374683f, 
    -0.06155303f, -0.07539369f, -0.25415275f, -0.00985138f, -0.13590066f, 0.01894647f, 0.15443952f, 0.01728742f, 
    0.02396995f, 0.03862325f, 0.10850268f, -0.01484717f, -0.10006221f, 0.05960657f, -0.04507146f, -0.05589378f, 
    -0.02795854f, 0.03166206f, -0.01557308f, -0.10359272f, -0.05248162f, 0.02450844f, 0.02195207f, 0.07636257f, 
    -0.10264465f, -0.05430733f, -0.02126458f, -0.03196201f, 0.04538405f, -0.05209975f, -0.07881762f, -0.09859483f, 
    0.12460442f, -0.08326302f, -0.09911571f, 0.02665376f, -0.12432152f, -0.10479647f, 0.02060570f, -0.00168657f, 
    -0.08583812f, -0.03479725f, -0.05563611f, 0.07364345f, -0.02773262f, -0.10105839f, 0.08159760f, 0.01318879f, 
    0.04238516f, -0.10129669f, -0.11965535f, 0.06782515f, 0.02278583f, -0.06950112f, 0.06987812f, 0.03291982f, 
    -0.11147729f, -0.01556828f, -0.10017645f, -0.06287591f, 0.06457751f, 0.01879963f, -0.03063444f, -0.00150721f, 
    0.04947348f, -0.09907041f, -0.10937732f, -0.04382396f, -0.08143599f, 0.01428962f, -0.10796800f, 0.02878776f, 
    -0.06211882f, -0.36436078f, 0.00878166f, -0.24882586f, -0.10476142f, -0.06326671f, -0.01066399f, 0.06734215f, 
    0.11543380f, -0.08926554f, 0.19655463f, 0.14360057f, -0.05151613f, 0.47204378f, 0.00848090f, -0.14895958f, 
    0.12413704f, -0.01548594f, 0.03753505f, 0.07795577f, -0.12544656f, 0.13818252f, -0.17457613f, 0.11148227f, 
    0.03170099f, -0.04546618f, -0.04175970f, -0.01159316f, 0.07452161f, -0.02911989f, 0.02770580f, 0.10256211f, 
    0.18274961f, 0.19795924f, -0.04924522f, 0.25018895f, 0.17473026f, -0.16163605f, -0.19624665f, -0.05226512f, 
    0.07076693f, -0.03449218f, 0.23359790f, 0.08487476f, -0.08705719f, -0.22379366f, 0.09658158f, -0.49728024f, 
    -0.15870243f, 0.08479253f, 0.04008289f, 0.12671353f, 0.13976887f, 0.25097495f, -0.04306655f, 0.37938195f, 
    -0.01408077f, -0.10248383f, -0.14635640f, 0.05400397f, 0.09139986f, -0.15048179f, 0.30347320f, -0.08140458f, 
    -0.02714287f, 0.09324566f, -0.04511987f, -0.07733397f, -0.12723377f, 0.06649319f, -0.10776280f, 0.04074973f, 
    -0.07635231f, 0.12044775f, 0.00100882f, -0.02854816f, 0.09701373f, -0.06844702f, -0.01355038f, -0.12199134f, 
    -0.11963160f, 0.04699344f, 0.02539826f, 0.00810564f, -0.13738063f, -0.08863997f, 0.04447546f, 0.05134603f, 
    -0.06301701f, 0.02658596f, -0.10415609f, 0.07190552f, 0.02752903f, 0.11302836f, -0.13751161f, -0.10453391f, 
    -0.02046562f, 0.06867974f, 0.06815052f, 0.09751941f, -0.00250307f, -0.11395182f, -0.00605507f, 0.06898944f, 
    0.04124494f, -0.03746697f, 0.06809995f, 0.09105285f, 0.08533417f, 0.10182307f, 0.05913090f, -0.09797028f, 
    0.11140490f, -0.05443705f, -0.03522930f, -0.13781095f, -0.08116172f, -0.02909311f, 0.04095468f, 0.07428774f, 
    0.05146356f, 0.09759288f, -0.09225474f, 0.02059986f, -0.05225773f, -0.08176364f, -0.07126722f, 0.09146246f, 
    0.04152923f, -0.24239951f, 0.01831374f, 0.36764443f, -0.22034293f, 0.02380599f, -0.33584678f, 0.17027016f, 
    -0.07868502f, -0.03432124f, 0.18408625f, 0.11965150f, -0.07922257f, -0.07980678f, 0.36606655f, -0.02812991f, 
    0.04129202f, 0.05513636f, 0.29203749f, 0.04629554f, -0.29517880f, 0.06930014f, -0.02089741f, -0.13968003f, 
    -0.06434091f, -0.02280047f, -0.28322136f, 0.32251939f, 0.09028319f, 0.03885462f, 0.23572747f, -0.02264246f, 
    -0.27415311f, 0.19659957f, -0.31268427f, 0.06479812f, -0.03599649f, 0.09450427f, -0.14449874f, 0.08077280f, 
    0.24459177f, -0.04616942f, -0.25949818f, -0.04782233f, 0.05753506f, 0.15163662f, 0.01911992f, -0.13249087f, 
    -0.09540358f, 0.20233929f, 0.10226747f, 0.01407891f, 0.04203372f, 0.13936624f, -0.05996901f, -0.28213456f, 
    0.02288835f, -0.03568263f, -0.25603613f, 0.24072438f, 0.26917917f, 0.14099488f, 0.11210412f, -0.03819435f, 
    0.04193257f, 0.36002240f, 0.09766497f, -0.00955650f, 0.25270453f, -0.02735901f, -0.05935412f, -0.11093455f, 
    0.07189764f, -0.04946673f, -0.15896560f, 0.01886927f, 0.21333542f, 0.06323218f, -0.05476337f, 0.13262084f, 
    -0.10339130f, 0.09567590f, -0.25813085f, 0.06265308f, 0.02357323f, -0.08702455f, 0.18340443f, 0.42258859f, 
    0.07370971f, 0.04841369f, 0.23734556f, -0.07990945f, -0.09431718f, 0.02481799f, 0.07747616f, -0.00308528f, 
    -0.02725362f, 0.03561611f, 0.13075203f, -0.09436880f, 0.03183006f, -0.22563566f, 0.01338447f, 0.12943193f, 
    0.10947432f, 0.10419066f, 0.25726232f, -0.00895924f, -0.06136159f, 0.05226436f, -0.08913001f, -0.12499049f, 
    -0.03835693f, -0.34584936f, -0.02337805f, -0.09435060f, 0.00333587f, 0.25543609f, 0.22666889f, -0.52817053f, 
    0.01516641f, 0.00550883f, 0.10328126f, -0.26785418f, -0.23869857f, 0.10397360f, -0.00245036f, -0.04284331f, 
    0.09480728f, 0.08853986f, -0.06455259f, 0.12853147f, -0.21114603f, 0.04336810f, -0.29244152f, -0.04894365f, 
    0.09624711f, 0.00854945f, 0.00005741f, 0.04473553f, 0.39076206f, -0.21451999f, 0.30727816f, -0.17176425f, 
    0.10537621f, -0.12091820f, 0.27035964f, 0.07691529f, 0.16860928f, 0.08345123f, -0.15658896f, -0.41378146f, 
    -0.02690335f, -0.06783532f, -0.03428023f, 0.57474351f, -0.02910145f, 0.09956032f, 0.17544484f, 0.04444557f, 
    -0.35356721f, -0.40717569f, 0.06469840f, 0.24163106f, -0.25065726f, 0.35563123f, 0.15797260f, -0.03256885f, 
    -0.08130045f, 0.06051843f, 0.00732241f, 0.06817579f, 0.06284964f, 0.19234014f, -0.05181041f, -0.18381281f, 
    -0.08788159f, 0.14020513f, -0.08047760f, -0.00091684f, 0.00911293f, -0.05639648f, 0.10128242f, -0.11019945f, 
    0.09785301f, -0.06121645f, -0.14425905f, 0.25400662f, 0.18271008f, 0.17214523f, -0.06877173f, -0.02290982f, 
    -0.07608800f, -0.15994287f, 0.01576936f, -0.40836069f, 0.04682774f, 0.10198888f, 0.14430818f, 0.24507143f, 
    0.12546241f, 0.06299880f, 0.20202543f, -0.11724970f, -0.09911712f, 0.16828768f, -0.13566142f, -0.23536061f, 
    -0.08596531f, 0.09364149f, -0.20600402f, -0.08726119f, -0.24762499f, 0.25335130f, -0.07350057f, -0.16826209f, 
    -0.03278799f, 0.10455833f, 0.10274751f, 0.36144781f, 0.03663740f, -0.05649969f, -0.40864798f, 0.04997963f, 
    0.31970853f, 0.19175816f, 0.12490423f, 0.22662361f, 0.12804875f, -0.19088295f, 0.30924430f, 0.01705414f, 
    0.31749389f, 0.00432170f, 0.04222122f, 0.01520312f, 0.04914719f, -0.43501294f, -0.06870895f, -0.00366802f, 
    -0.12752593f, 0.17742753f, -0.01819099f, 0.13468926f, 0.04911333f, -0.22873634f, 0.00002176f, 0.48166156f, 
    -0.07894456f, -0.11266540f, 0.15940554f, 0.21826369f, 0.10143122f, -0.12071297f, 0.13798593f, 0.01825409f, 
    -0.11221936f, -0.05598088f, -0.05944366f, 0.03014182f, -0.11268536f, -0.10212228f, 0.27893278f, 0.25497594f, 
    -0.10835613f, 0.10846736f, -0.01761112f, -0.09681199f, 0.04090749f, 0.00568875f, 0.14687872f, 0.14894699f, 
    0.06576541f, 0.05695727f, 0.12299116f, 0.04718486f, 0.35906526f, -0.12212604f, -0.02465193f, 0.51499921f, 
    0.08378065f, 0.23962548f, 0.14737585f, -0.05394319f, -0.10632967f, -0.01719630f, 0.39966267f, 0.02460852f, 
    -0.00663809f, -0.42608422f, 0.19648218f, 0.35801706f, 0.18290783f, -0.16600749f, 0.10195215f, -0.07579755f, 
    -0.23447892f, 0.25175199f, 0.16341287f, -0.06117936f, -0.09529047f, 0.22811899f, -0.00039108f, -0.03786475f, 
    0.03234046f, -0.18084577f, -0.03907160f, -0.04622671f, 0.18151724f, -0.18827073f, 0.18766305f, 0.01112270f, 
    0.06343105f, -0.02529266f, -0.01689174f, -0.14793120f, -0.20306897f, 0.12597546f, 0.01146928f, -0.05921762f, 
    -0.10511065f, -0.16543706f, 0.00247294f, 0.05837673f, 0.26411888f, 0.02586887f, -0.09019428f, -0.32850426f, 
    -0.04608219f, 0.02096038f, -0.04844624f, 0.18587153f, 0.14155775f, 0.16307661f, 0.21373549f, -0.12076088f, 
    0.07158291f, -0.09327547f, -0.09146855f, 0.04774772f, -0.01574397f, 0.23872778f, -0.20516378f, -0.37735561f, 
    0.00028738f, -0.03436722f, -0.12605070f, -0.08573385f, 0.09085694f, -0.12967905f, -0.24907005f, -0.09383067f, 
    -0.07883754f, -0.02475910f, -0.15672541f, 0.27180704f, -0.25623348f, 0.20677643f, 0.10667349f, -0.06128530f, 
    0.06778029f, 0.07685853f, 0.14636338f, -0.01097942f, 0.04608602f, 0.08835591f, -0.12071200f, -0.27531698f, 
    0.07762620f, 0.01854424f, 0.10725034f, 0.13701206f, 0.16493213f, 0.01805896f, -0.01691369f, 0.10250099f, 
    0.01534432f, -0.06019859f, 0.07860113f, 0.34092155f, 0.15755357f, 0.06282241f, 0.24315351f, -0.00187764f, 
    -0.08421960f, 0.35680935f, 0.03842372f, 0.09934378f, 0.23423237f, 0.06232090f, -0.10935999f, 0.14659594f, 
    0.03827028f, 0.11694816f, -0.12992553f, 0.07872230f, -0.04020075f, -0.35967034f, 0.00891428f, 0.18491694f, 
    -0.04082999f, -0.10328119f, -0.12745209f, 0.08716667f, -0.06794916f, -0.12992184f, 0.40039739f, -0.18667509f, 
    -0.06230966f, 0.10194381f, -0.02338854f, 0.09379334f, -0.08439215f, -0.06946669f, -0.28594780f, 0.11745384f, 
    0.18662038f, 0.08001345f, 0.12918831f, -0.14402969f, -0.03345586f, -0.29879159f, 0.19987833f, 0.02420454f, 
    0.31845438f, 0.17215163f, 0.07264062f, 0.00575667f, -0.03967093f, -0.28996852f, 0.04347850f, 0.43496370f, 
    -0.08737957f, 0.08394402f, 0.12055132f, -0.14433882f, 0.22622214f, -0.15352848f, 0.20752305f, -0.04870678f, 
    -0.04952108f, -0.10801180f, 0.44156557f, 0.02325171f, 0.01472345f, -0.09167075f, 0.12437033f, -0.04968095f, 
    -0.01075655f, -0.12866144f, 0.04853714f, -0.06686393f, 0.07520066f, -0.09110717f, -0.02521478f, 0.00488320f, 
    -0.10490111f, 0.08380248f, -0.13249649f, -0.07051058f, -0.09216841f, -0.12421383f, 0.06497734f, -0.04228096f, 
    -0.09145191f, -0.10207194f, -0.08158382f, -0.10233761f, 0.04707004f, -0.05017811f, -0.06147848f, -0.04391827f, 
    0.03980187f, -0.13433965f, 0.07765213f, 0.00356235f, 0.03290179f, 0.06951480f, -0.03427418f, 0.10664018f, 
    -0.13533393f, 0.08378368f, 0.09750182f, -0.08836253f, -0.03001007f, 0.04987833f, -0.01971085f, 0.04782083f, 
    0.08718168f, 0.01946246f, -0.08648288f, -0.12187306f, 0.09332461f, -0.02226509f, 0.08982193f, -0.13279715f, 
    0.10632636f, 0.03700946f, 0.08534419f, -0.10513178f, 0.01286444f, 0.09809379f, -0.10908861f, -0.00418147f, 
    0.09667051f, -0.00562982f, 0.02471199f, -0.08438662f, -0.04907738f, 0.10782230f, -0.15523873f, 0.00943848f, 
    0.00696175f, 0.29013082f, 0.01868777f, 0.06346337f, 0.10710686f, -0.01387444f, -0.37072963f, -0.32471138f, 
    -0.01247750f, 0.06368303f, 0.09006621f, 0.22939441f, 0.24104899f, -0.05753158f, -0.10229956f, 0.22065420f, 
    0.12436634f, -0.02977107f, -0.13666266f, -0.05563953f, -0.17312372f, 0.15913081f, 0.07692509f, 0.31859046f, 
    0.07728314f, 0.04525744f, 0.00350617f, 0.01316508f, -0.02661047f, 0.06042704f, -0.36819640f, 0.06041694f, 
    -0.09130505f, 0.11270681f, -0.08538674f, -0.02641933f, 0.13454844f, 0.02630961f, 0.21783255f, -0.00366201f, 
    0.15521164f, 0.17314607f, 0.20949848f, 0.00602361f, 0.00629708f, -0.08522081f, 0.02275467f, -0.18861105f, 
    0.05711376f, -0.13559692f, 0.00938039f, 0.13808624f, -0.13406265f, 0.51867831f, 0.05358762f, -0.36689597f, 
    -0.00863873f, -0.05246026f, 0.31600338f, -0.04390144f, -0.07896853f, 0.41850394f, -0.11122107f, -0.07810219f, 
    0.11635937f, -0.11916780f, -0.11019194f, 0.03182240f, 0.10678508f, 0.08645770f, -0.01609014f, -0.03944557f, 
    -0.08031265f, 0.00952566f, 0.01331579f, -0.02018047f, -0.11043642f, 0.07415342f, 0.05832192f, -0.08721136f, 
    -0.08908015f, -0.03780010f, 0.00865649f, -0.09770301f, 0.02758594f, -0.13746604f, -0.03817965f, -0.00066335f, 
    -0.06903328f, -0.12095217f, 0.08355066f, 0.04310000f, -0.02877517f, 0.04154345f, 0.03474024f, 0.09008582f, 
    0.11449271f, -0.06984034f, -0.06607759f, -0.03941174f, 0.04537729f, -0.00960915f, -0.11067050f, -0.03439204f, 
    -0.09465216f, 0.02593681f, -0.00919040f, 0.00670925f, -0.03996339f, -0.12717082f, 0.12373130f, -0.07270916f, 
    0.10335906f, -0.01347409f, -0.04166928f, 0.00310155f, -0.09343069f, 0.03903726f, -0.06882066f, -0.07976112f, 
    -0.08078137f, 0.05037126f, -0.03782582f, -0.04947133f, -0.10371973f, 0.08240966f, 0.11424804f, 0.10406420f, 
    -0.05464460f, 0.35811830f, -0.00539245f, 0.14780179f, 0.02795622f, 0.07516219f, -0.01392609f, 0.12268303f, 
    -0.04959448f, -0.07037056f, -0.01261071f, -0.03258196f, 0.01684826f, -0.34191069f, -0.00026697f, 0.23356554f, 
    -0.00262308f, 0.12736720f, -0.14180346f, -0.10851692f, 0.11761135f, 0.01940146f, 0.36243710f, -0.06552901f, 
    0.00231219f, 0.20050259f, -0.00811941f, -0.08606595f, 0.00373562f, 0.01277434f, -0.07035793f, -0.00976538f, 
    0.25378105f, -0.36260098f, 0.27618298f, -0.03540557f, 0.09582826f, -0.00825184f, 0.27297884f, 0.02655195f, 
    0.08221555f, 0.14859545f, 0.20561826f, -0.03920692f, -0.03386576f, -0.30436745f, -0.09746824f, 0.35778496f, 
    -0.00860680f, -0.02548874f, 0.06364069f, -0.06983592f, 0.12480497f, -0.17736782f, 0.22358415f, -0.07286476f, 
    -0.10625653f, 0.02597191f, 0.27015018f, 0.03942637f, -0.06557465f, -0.01926379f, -0.05283650f, 0.12351558f, 
    -0.07959317f, 0.07031534f, -0.11641955f, -0.10369051f, 0.10361497f, -0.08376917f, -0.03868587f, -0.04624927f, 
    0.09701896f, 0.11401924f, -0.02685743f, 0.06335428f, 0.06560147f, -0.00754415f, 0.03115547f, -0.07048556f, 
    0.09818438f, -0.11716069f, 0.09073541f, 0.03249837f, -0.12082303f, -0.12576804f, -0.13117070f, 0.04935541f, 
    -0.11507499f, 0.07981180f, -0.00754543f, -0.03375354f, 0.00888757f, 0.05753472f, -0.05955354f, 0.05538160f, 
    -0.07418562f, 0.04751201f, 0.02732278f, 0.17437373f, -0.07816362f, 0.00648932f, -0.14275607f, -0.06261076f, 
    0.00688664f, -0.11369705f, -0.14286266f, -0.08072475f, -0.02895138f, 0.11395600f, 0.08349112f, 0.01744296f, 
    0.00124617f, -0.06393648f, -0.02024846f, -0.13722758f, -0.06249472f, 0.05086796f, -0.08892679f, -0.09908402f, 
    0.07488503f, -0.00927013f, 0.03781238f, -0.00729842f, 0.00296766f, -0.06216783f, -0.02614531f, -0.08176319f, 
    0.09668256f, -0.35961044f, 0.10441598f, -0.22435631f, -0.00762667f, 0.12231047f, -0.00440897f, 0.12023172f, 
    0.11077085f, -0.08612143f, 0.38147113f, 0.15877904f, -0.00729020f, 0.05054917f, -0.00183598f, 0.34126762f, 
    -0.08439071f, -0.05433347f, 0.08441361f, -0.01972348f, 0.22635496f, 0.36221719f, 0.08365866f, 0.09148818f, 
    0.07201820f, 0.08013903f, -0.21759582f, -0.02249946f, -0.03347063f, -0.02329742f, -0.18619244f, -0.03959559f, 
    0.26519105f, 0.04988969f, 0.03424151f, 0.09323874f, 0.18245481f, -0.34554031f, 0.13036728f, 0.04050706f, 
    0.35416788f, 0.09202959f, -0.04034498f, -0.10068190f, -0.01256136f, -0.11242668f, -0.00348453f, 0.01686365f, 
    0.04136717f, 0.16641697f, -0.04433714f, -0.04852875f, -0.06463479f, -0.08204740f, -0.22727762f, 0.19912651f, 
    -0.06560224f, 0.11361301f, -0.12752451f, -0.40713462f, 0.10325051f, 0.02331584f, 0.17829981f, 0.01417347f, 
    0.11257890f, 0.08546130f, 0.08817922f, 0.03281124f, -0.08226344f, 0.10239941f, 0.05674588f, 0.01428707f, 
    -0.00577687f, 0.07037038f, -0.03875190f, 0.10449447f, 0.06445230f, -0.10339850f, 0.06698074f, -0.11820293f, 
    0.10342254f, -0.02692978f, -0.13155447f, 0.06926788f, 0.03816062f, 0.04808664f, -0.07424168f, 0.13212045f, 
    -0.05098721f, -0.12357212f, -0.02853903f, -0.11995924f, 0.00924552f, 0.01048109f, 0.01201876f, -0.00731501f, 
    -0.09938949f, 0.02080381f, -0.14939837f, -0.06292950f, 0.06714316f, 0.06228809f, 0.08903076f, -0.01669411f, 
    -0.00719621f, -0.11203071f, -0.08293647f, -0.10087814f, 0.05780383f, -0.07958946f, 0.02031557f, 0.08789370f, 
    0.07904354f, -0.10770199f, -0.08103507f, 0.04741699f, 0.03559536f, 0.00421963f, -0.06954553f, -0.12981099f, 
    -0.07977378f, -0.11493129f, 0.05384053f, -0.01696755f, 0.08657800f, -0.11375322f, -0.01717367f, 0.03262600f, 
    -0.02198912f, 0.07877406f, -0.09701718f, -0.06713545f, -0.00218363f, -0.04139256f, 0.09631687f, -0.02285762f, 
    0.02769309f, -0.06962104f, -0.10517025f, 0.08216967f, -0.07274605f, -0.11056095f, 0.12272395f, 0.07670979f, 
    0.03189734f, 0.04710753f, -0.04934388f, 0.05122322f, -0.11404785f, 0.07144050f, -0.00837643f, -0.01113626f, 
    -0.01268679f, 0.01255534f, -0.12097171f, -0.06629258f, -0.00344510f, 0.08684534f, -0.07302751f, -0.11452097f, 
    0.08081146f, -0.12592250f, 0.06911775f, 0.03214562f, -0.07385080f, 0.10896920f, -0.12585193f, -0.05032614f, 
    -0.06674987f, -0.07954215f, -0.08248423f, -0.02219526f, 0.09998368f, -0.11149845f, -0.05900778f, -0.04453894f, 
    0.11970171f, -0.11945800f, -0.12391250f, -0.12100136f, -0.05337562f, -0.12359317f, 0.09047247f, -0.08532836f, 
    -0.06346293f, 0.10464765f, -0.12884429f, -0.02783789f, -0.01369362f, -0.12378538f, -0.12298407f, 0.01983309f, 
    0.09966759f, -0.05481663f, -0.12613894f, -0.30047351f, -0.30813897f, -0.07112539f, -0.15197301f, 0.08603788f, 
    0.07905520f, 0.13412493f, 0.25469932f, 0.08139621f, 0.33844605f, -0.06399882f, 0.11206323f, -0.13171354f, 
    -0.06501420f, 0.02163924f, 0.21434925f, -0.00731443f, 0.11472379f, 0.25101501f, -0.17285378f, 0.09304178f, 
    0.11025275f, -0.15131478f, -0.07033513f, 0.50079167f, -0.03115370f, 0.04817759f, 0.02068074f, -0.04044361f, 
    -0.03147862f, -0.49924102f, 0.24174021f, -0.12277538f, 0.07945002f, -0.33522534f, 0.13058679f, -0.02940251f, 
    -0.15504166f, -0.04580624f, 0.19895153f, -0.08857445f, -0.05864511f, 0.00983611f, -0.06637587f, -0.31853706f, 
    -0.09631648f, -0.13932171f, -0.07576207f, 0.21779865f, 0.21487448f, -0.31452611f, -0.09651073f, 0.00462368f, 
    -0.06447387f, 0.10215430f, -0.04083819f, 0.07250532f, 0.20590316f, 0.16504614f, -0.24292128f, 0.02321391f, 
    -0.06557705f, 0.06302361f, -0.10508782f, 0.28353944f, 0.08620527f, -0.10753921f, 0.01770217f, -0.10657994f, 
    0.05738335f, 0.12759206f, -0.11083847f, 0.29903436f, -0.28691787f, 0.15377407f, 0.21063556f, 0.05708892f, 
    -0.07108423f, -0.04842271f, 0.19101050f, 0.06711646f, 0.10978251f, -0.30579415f, -0.11329419f, 0.20223111f, 
    0.10930032f, -0.03556026f, -0.19110839f, -0.57285088f, 0.11251793f, -0.09732255f, 0.28678736f, -0.12332461f, 
    -0.11427216f, -0.00203639f, 0.00889515f, 0.21289147f, 0.13611901f, -0.01837755f, -0.38843694f, 0.03387946f, 
    -0.13044715f, 0.18225721f, 0.02377892f, 0.09073858f, -0.10146436f, 0.12150441f, 0.02981951f, -0.13693489f, 
    0.03609415f, 0.10390010f, -0.09841142f, 0.14185695f, 0.20202389f, 0.37527090f, 0.22136369f, -0.13658156f, 
    -0.01486407f, 0.04408675f, -0.03793366f, -0.10318672f, 0.26449278f, -0.03838365f, 0.15561053f, -0.04577798f, 
    -0.09628695f, -0.05511244f, 0.02253426f, 0.23103696f, 0.26422960f, -0.05349647f, -0.01841742f, -0.11747214f, 
    0.13325907f, 0.08597827f, -0.08655806f, -0.08880334f, 0.08741169f, 0.36270541f, 0.18170404f, 0.07100568f, 
    -0.04537870f, -0.09320740f, -0.12327636f, 0.03059113f, -0.07484749f, 0.00397218f, -0.19225754f, 0.10491285f, 
    -0.02230220f, 0.16642934f, 0.27128589f, -0.14159894f, 0.09389491f, 0.05106764f, 0.23594312f, 0.05991680f, 
    0.13746728f, 0.12110134f, -0.05510421f, 0.13504432f, -0.00444443f, 0.29061848f, 0.11361042f, 0.11205394f, 
    -0.00390382f, -0.02345349f, -0.08700189f, 0.09753446f, 0.00074655f, 0.23833442f, 0.07533288f, 0.06676783f, 
    0.01568444f, 0.05489232f, 0.05958859f, -0.06759303f, 0.00176220f, 0.16933355f, 0.47023365f, -0.26792440f, 
    -0.00329638f, -0.00548009f, 0.26338413f, 0.10835576f, -0.09753695f, 0.33336583f, -0.01453101f, 0.08377433f, 
    0.02523927f, -0.01841867f, -0.10480607f, -0.04742534f, -0.02877857f, 0.00734537f, 0.09027769f, 0.04117034f, 
    -0.00839501f, 0.04513921f, -0.09125026f, 0.04185051f, -0.13731562f, -0.12451747f, -0.12951100f, -0.07451038f, 
    0.09564625f, -0.04828667f, 0.06956778f, -0.05394953f, -0.07183973f, -0.10919301f, -0.13927977f, -0.00211225f, 
    0.06604573f, -0.12075586f, -0.06778970f, -0.03690641f, -0.03927625f, 0.10706846f, 0.04413373f, -0.02842504f, 
    -0.10657515f, 0.03556034f, -0.12401150f, 0.03870096f, 0.00221046f, -0.11717357f, -0.06651231f, -0.02398678f, 
    -0.06202453f, 0.02787044f, -0.01792329f, 0.09370968f, -0.04716506f, 0.11644492f, 0.09602223f, 0.05084815f, 
    0.07768098f, 0.00704962f, -0.04386311f, -0.10023952f, 0.10558741f, -0.00113264f, 0.10246758f, -0.08409324f, 
    0.10657310f, 0.07992037f, 0.09989856f, -0.02163806f, 0.02473220f, 0.03844268f, 0.01206323f, 0.09450185f, 
    0.03730842f, -0.05760702f, 0.03720760f, -0.07962123f, -0.02439615f, -0.04727582f, 0.04739687f, 0.01401671f, 
    -0.11680646f, 0.07632059f, 0.02754000f, -0.05091334f, 0.06752226f, 0.02482362f, -0.08319797f, -0.04592340f, 
    -0.01853383f, 0.02651808f, 0.02465502f, 0.07787219f, -0.06981599f, -0.10555308f, -0.11559036f, -0.05669477f, 
    0.08387628f, -0.02368024f, -0.08277544f, 0.07320715f, 0.07089221f, -0.11928025f, 0.11358368f, -0.05397286f, 
    0.07958183f, -0.01797313f, -0.11140738f, -0.05787060f, -0.02195382f, -0.01399318f, -0.03731908f, -0.01358388f, 
    -0.08794852f, 0.04898639f, 0.02571924f, 0.10804700f, 0.04575564f, 0.07743890f, -0.09724997f, -0.04046798f, 
    -0.00161153f, -0.02003545f, -0.04216453f, -0.05121059f, -0.01882810f, 0.03717194f, -0.06330226f, -0.03371453f, 
    0.01766470f, -0.09634642f, -0.05805006f, 0.09962904f, -0.03828178f, 0.06936882f, 0.08331380f, 0.00440331f, 
    -0.09556207f, 0.07509086f, 0.13178787f, 0.05193792f, 0.06813291f, -0.08555511f, 0.07450027f, 0.01403235f, 
    -0.02733408f, 0.09357409f, 0.07277914f, 0.05406500f, -0.08615509f, 0.10602418f, 0.16228469f, -0.20056555f, 
    -0.05218321f, 0.09865180f, 0.04459528f, -0.03923637f, -0.27810675f, -0.18076050f, -0.15299864f, -0.08026387f, 
    0.02224389f, -0.19913949f, 0.09199438f, 0.06180896f, 0.10948983f, 0.09661378f, -0.06656512f, 0.08297821f, 
    -0.04918933f, 0.45097935f, -0.09791327f, -0.59987283f, 0.11526635f, 0.13607509f, -0.18314731f, -0.07712980f, 
    0.01079426f, 0.01963971f, -0.07978389f, -0.03333021f, -0.10642254f, -0.02766627f, 0.03758705f, -0.05134003f, 
    -0.11821499f, -0.03872896f, -0.03175129f, 0.16975649f, 0.04605725f, 0.21159941f, -0.00147303f, 0.12862054f, 
    -0.09341396f, -0.03604572f, 0.14821155f, 0.14971204f, 0.11797486f, 0.12369226f, -0.12862189f, -0.02161534f, 
    -0.08778678f, -0.24068174f, -0.00674667f, -0.07903361f, 0.09321880f, -0.07461469f, 0.36206284f, 0.34577754f, 
    -0.07599675f, -0.04776763f, 0.14461486f, -0.00974528f, -0.21499187f, -0.05856758f, -0.11507925f, 0.01826154f, 
    -0.11406922f, -0.07717351f, 0.14546548f, 0.11900090f, 0.30564964f, 0.16919394f, 0.08792811f, 0.07839554f, 
    -0.07932888f, 0.30703732f, 0.08092252f, -0.18771450f, 0.08203174f, 0.04709478f, 0.13409038f, 0.02535229f, 
    0.26011017f, -0.20612577f, 0.21895440f, 0.65408260f, 0.12009607f, -0.17592037f, 0.00159946f, -0.06395170f, 
    -0.04020533f, 0.05726628f, -0.07118258f, 0.11431727f, 0.08094745f, 0.07721375f, 0.07599989f, 0.14218098f, 
    -0.06339351f, 0.22594306f, -0.07875425f, 0.02051166f, -0.03486434f, -0.10258673f, -0.11532932f, 0.42092061f, 
    0.10123846f, 0.02069881f, -0.23320903f, -0.10207819f, -0.11767844f, -0.34267801f, 0.36075303f, -0.02136051f, 
    0.06911493f, 0.43120840f, 0.01454309f, -0.14204274f, -0.21875332f, 0.04763854f, -0.11141909f, -0.01520066f, 
    0.00622152f, -0.09221234f, -0.10375720f, 0.08486584f, 0.25878114f, -0.30532601f, -0.04928004f, 0.21772499f, 
    -0.11707504f, -0.05270691f, 0.10777581f, 0.04794177f, 0.20971818f, -0.09872598f, 0.20706895f, 0.37276572f, 
    0.06106825f, 0.17693134f, 0.05740758f, 0.13883260f, 0.02086775f, 0.03054966f, 0.09566956f, -0.04622360f, 
    -0.22496465f, -0.46028987f, 0.35125962f, -0.35648575f, 0.15348288f, -0.08499742f, -0.00952105f, 0.00479668f, 
    -0.14032389f, 0.21821415f, 0.16920486f, -0.06724805f, 0.05566395f, 0.34929511f, 0.03536116f, 0.06317173f, 
    -0.06104939f, -0.18942539f, 0.06824732f, 0.20755900f, 0.13520524f, 0.10804415f, -0.13878272f, -0.06818151f, 
    0.01822315f, 0.05183048f, -0.13306153f, -0.06002691f, 0.02387743f, 0.27617201f, -0.40475428f, -0.03763173f, 
    0.08772063f, 0.08386646f, 0.00293694f, -0.11350213f, -0.05689594f, 0.03581399f, 0.08471698f, -0.03763042f, 
    -0.00904252f, 0.01046279f, 0.00366253f, 0.10788512f, -0.10050339f, -0.06154026f, -0.04222512f, -0.06432103f, 
    0.06394124f, -0.03232422f, -0.05465233f, 0.06837323f, -0.11639346f, -0.02780671f, 0.11404882f, -0.04400530f, 
    0.10176012f, -0.06619696f, 0.00235757f, -0.03958236f, 0.10811143f, -0.06110302f, -0.12360500f, -0.08790344f, 
    -0.11807270f, -0.05686514f, -0.02128357f, 0.10424446f, -0.09550136f, 0.08546689f, -0.03423379f, -0.01709615f, 
    -0.08452454f, 0.11911221f, -0.02739078f, -0.01235020f, 0.00635616f, 0.02383110f, 0.05315159f, -0.01498993f, 
    -0.05380279f, -0.09661664f, 0.10304900f, -0.00577031f, -0.01265568f, -0.02819803f, 0.04482377f, 0.05609794f, 
    -0.06628506f, -0.02607608f, -0.00638327f, -0.03697589f, -0.03759319f, -0.12012501f, 0.01397140f, -0.03161672f, 
    0.04070352f, -0.24053638f, -0.10873909f, -0.23502307f, 0.21382485f, -0.00698176f, 0.10643444f, 0.17329642f, 
    0.09077805f, -0.00545614f, 0.10608426f, -0.15382203f, 0.39795491f, 0.14501663f, -0.00793003f, -0.21919169f, 
    -0.05908918f, -0.10611399f, -0.02417151f, 0.05015320f, 0.11333743f, 0.19700837f, -0.12664084f, 0.05393716f, 
    -0.11579147f, 0.21692531f, -0.02024612f, 0.20526858f, -0.11074606f, -0.00425434f, 0.21618022f, -0.08129840f, 
    -0.02568585f, -0.09574791f, 0.08576416f, 0.70181268f, -0.12489317f, -0.20429319f, 0.26136860f, -0.05337483f, 
    0.08241731f, -0.04591674f, -0.00410678f, 0.09410641f, -0.10929076f, 0.08536967f, -0.02556538f, -0.08956766f, 
    -0.07321643f, -0.01347917f, -0.10292120f, -0.08336903f, -0.04673213f, -0.13466051f, 0.20524824f, -0.05647034f, 
    -0.10824477f, 0.12265186f, -0.11793400f, 0.27353850f, -0.24103518f, -0.00403425f, 0.24618372f, 0.11855894f, 
    -0.06943771f, -0.09916219f, -0.00379434f, -0.06657674f, -0.00163419f, 0.01103085f, 0.05115023f, -0.12738891f, 
    0.02150998f, -0.06901473f, -0.14207692f, -0.12004697f, -0.00616970f, -0.08137157f, 0.03430810f, -0.11977130f, 
    -0.04097661f, 0.11431460f, 0.02072563f, 0.09361269f, 0.09847450f, 0.02753697f, 0.01790374f, 0.07650425f, 
    -0.08480932f, -0.01416557f, -0.08102312f, 0.02725269f, -0.03411300f, -0.08055492f, -0.09871700f, -0.12204859f, 
    0.01782188f, 0.07087808f, 0.05758703f, -0.00730308f, -0.06479900f, 0.09373707f, 0.10037971f, -0.03799425f, 
    0.00959274f, -0.00897927f, -0.05620901f, -0.11350330f, -0.02978903f, -0.06004196f, 0.10132720f, 0.04087683f, 
    0.08619186f, -0.05405711f, -0.01526858f, 0.05914058f, -0.10824502f, -0.01302248f, -0.04318064f, -0.04629375f, 
    -0.07194851f, -0.06406893f, 0.09415286f, 0.02198234f, -0.04397170f, -0.05578174f, 0.01542853f, 0.10062844f, 
    -0.05908614f, -0.07321693f, 0.01969871f, -0.05520652f, 0.01308826f, 0.10078160f, -0.10293409f, -0.09166010f, 
    0.11908700f, -0.04512045f, -0.02367035f, -0.08432326f, 0.08414380f, -0.06059293f, 0.09555013f, -0.09442103f, 
    -0.07935217f, 0.06261018f, -0.05835912f, 0.04392961f, -0.06718683f, -0.01316832f, 0.06585446f, 0.02996059f, 
    0.08896470f, -0.03150868f, -0.01179317f, -0.00872733f, 0.09756258f, 0.00009082f, -0.09362562f, -0.01590763f, 
    0.09156567f, 0.03185014f, -0.00967431f, 0.03765965f, -0.05295075f, 0.00053270f, -0.05678898f, -0.04429878f, 
    -0.10622087f, -0.03708676f, 0.11830759f, -0.07173134f, -0.10751753f, -0.02556506f, -0.03953791f, 0.11549161f, 
    0.00122914f, -0.02646241f, 0.03331418f, -0.07801303f, 0.03371435f, 0.06889537f, -0.10679954f, 0.06729633f, 
    0.06144029f, 0.00669713f, -0.04235421f, 0.07380471f, -0.01381373f, -0.00916943f, -0.08555724f, 0.07485190f, 
    0.10737547f, -0.08963072f, -0.00908136f, 0.16449857f, 0.02912852f, -0.08840235f, -0.10997848f, -0.08710045f, 
    0.05025005f, 0.13591702f, 0.20112215f, 0.19055681f, 0.09905487f, 0.36827755f, 0.15713683f, -0.00454828f, 
    -0.11144888f, -0.06588054f, 0.18564065f, -0.01911633f, -0.30780631f, -0.01123982f, 0.09035207f, 0.10798103f, 
    0.08187643f, -0.00374799f, -0.14576507f, 0.09402350f, 0.04896333f, 0.08102147f, -0.03456892f, -0.10304236f, 
    -0.14037634f, 0.37407067f, -0.00725007f, 0.61808413f, -0.07949729f, 0.18401423f, -0.30529591f, -0.01799649f, 
    0.22665824f, 0.08394603f, 0.11778884f, 0.09953180f, -0.09122380f, -0.12176624f, 0.01446480f, -0.35024571f, 
    -0.07582360f, 0.06160233f, -0.02092452f, 0.16294236f, -0.12395489f, 0.44297040f, 0.03320049f, 0.17154169f, 
    -0.00902806f, 0.01269029f, -0.09539698f, 0.13853219f, -0.03180305f, -0.07946679f, 0.31502119f, -0.05310838f, 
    -0.00968853f, -0.10734861f, 0.06070768f, 0.06893186f, 0.01462048f, -0.07096305f, 0.00455281f, 0.05651139f, 
    0.09711939f, -0.02702059f, 0.08549453f, -0.03838406f, -0.04698418f, -0.06178350f, -0.11553910f, -0.09955921f, 
    -0.01146694f, -0.00814689f, -0.07657542f, 0.01226845f, -0.11840059f, -0.11415064f, -0.06906580f, 0.04301126f, 
    0.09189703f, 0.02682489f, -0.10847808f, -0.05577978f, 0.05963017f, -0.02964588f, 0.06799314f, -0.11410786f, 
    -0.07819024f, -0.11086376f, -0.08829038f, 0.08337701f, 0.07301514f, 0.00145269f, -0.01001223f, 0.10227265f, 
    -0.12158378f, 0.10309767f, -0.06134926f, 0.07240904f, -0.08049654f, -0.00319357f, -0.08204720f, -0.04231034f, 
    0.08203257f, 0.06398369f, 0.05977506f, -0.11109040f, 0.09449182f, -0.08249398f, -0.06293821f, 0.04940943f, 
    -0.12459588f, -0.00311269f, -0.04264821f, -0.12256972f, -0.01701971f, -0.07069275f, 0.02788963f, 0.05292167f, 
    -0.11531793f, 0.53690833f, -0.05439272f, -0.19489510f, -0.26614672f, -0.08336478f, 0.22435498f, 0.33594570f, 
    0.00229166f, 0.12031919f, -0.07174655f, 0.06306134f, -0.26538351f, -0.19356608f, -0.12738366f, -0.14943577f, 
    0.05145492f, 0.05218748f, 0.17177299f, -0.06642849f, -0.01334490f, -0.13767838f, 0.02468086f, 0.03549449f, 
    -0.07408129f, -0.04591038f, 0.17296222f, 0.18841971f, -0.09337165f, -0.11847492f, 0.12579064f, -0.01969630f, 
    -0.00486263f, -0.09923094f, 0.39176366f, -0.44051790f, 0.23324510f, 0.08297122f, 0.28733128f, -0.09900295f, 
    -0.25491512f, 0.10314415f, 0.04958045f, 0.08803298f, 0.12295866f, 0.02766288f, -0.02546327f, 0.11031868f, 
    0.03069670f, -0.04973413f, 0.02229642f, 0.21048822f, 0.25092149f, -0.22682555f, 0.02077111f, 0.41423389f, 
    0.04443853f, -0.03420140f, 0.08361003f, 0.42672348f, 0.12179854f, -0.25756037f, -0.09742016f, -0.01615113f, 
    -0.07929403f, -0.26753443f, -0.06654204f, -0.07366054f, -0.20895070f, -0.08383214f, 0.02628800f, -0.06754696f, 
    -0.11303405f, 0.03427307f, 0.10573649f, 0.03288172f, 0.20538040f, 0.07668120f, 0.07795472f, -0.15285139f, 
    0.12041938f, -0.07830162f, 0.18628156f, 0.01448200f, 0.11823501f, 0.10020738f, -0.07374856f, -0.20774272f, 
    0.09700859f, 0.03017289f, -0.00735129f, 0.40735421f, 0.04946620f, -0.10790923f, 0.17303210f, 0.04093156f, 
    -0.30555585f, -0.31146911f, -0.05126705f, 0.37650755f, -0.20215932f, 0.00052927f, -0.11285899f, -0.00560017f, 
    -0.11086599f, 0.11979064f, 0.05690293f, -0.02541029f, -0.09583659f, 0.04279871f, -0.04569117f, -0.36084121f, 
    -0.04179157f, 0.07106362f, 0.02936386f, 0.17499700f, -0.05402908f, -0.12609103f, -0.08291434f, 0.15054238f, 
    -0.05190834f, 0.05760967f, -0.36588654f, 0.27848199f, 0.20591997f, 0.14911193f, 0.16885750f, 0.03693983f, 
    0.01656078f, 0.21461737f, -0.05854105f, 0.19072737f, 0.17865241f, 0.07870390f, 0.00377539f, -0.02943685f, 
    0.02737834f, 0.06065887f, -0.16226164f, -0.05231146f, -0.12981090f, 0.01350870f, 0.05511347f, 0.07169466f, 
    0.06592766f, 0.10140324f, -0.09006551f, 0.00131120f, 0.14338088f, -0.12182200f, 0.11511631f, 0.11099880f, 
    0.02351095f, 0.06168367f, 0.23118575f, -0.19099608f, 0.00590595f, 0.03857368f, -0.02503649f, -0.07827967f, 
    0.30858082f, 0.03242302f, 0.16522554f, -0.07051046f, 0.05133913f, -0.21654342f, 0.22931181f, 0.04632568f, 
    0.05597499f, 0.08705359f, 0.20320839f, -0.06608077f, 0.03200554f, -0.33726075f, 0.02775885f, -0.10252522f, 
    -0.02319842f, 0.02402571f, 0.04348566f, -0.06912250f, 0.20203464f, -0.13145402f, 0.37187031f, -0.10999976f, 
    0.10937409f, -0.05204966f, 0.52617705f, 0.06325294f, -0.18747875f, 0.11068447f, -0.10073853f, 0.00971814f, 
    -0.05164996f, -0.09545831f, -0.08413309f, -0.30066723f, 0.19632527f, -0.06448340f, 0.00171953f, -0.06032404f, 
    0.01571457f, -0.09429418f, 0.11303535f, -0.03307318f, 0.14162470f, 0.18561496f, 0.05702212f, -0.19225861f, 
    0.01162336f, -0.00069769f, -0.20961404f, 0.04407443f, 0.07572395f, 0.16730174f, -0.21625294f, -0.31988224f, 
    0.09679280f, -0.08950138f, 0.20654871f, 0.06384270f, -0.01549150f, -0.06324504f, -0.32236156f, 0.00772363f, 
    0.21850942f, 0.18959899f, 0.16771516f, 0.22055741f, 0.07118723f, -0.19703618f, 0.41659123f, 0.09662424f, 
    0.09493612f, -0.12774096f, 0.23806912f, -0.04807686f, -0.04945851f, -0.33889982f, 0.11312275f, -0.45064142f, 
    0.09262336f, -0.07926179f, 0.06073383f, 0.10369641f, 0.30279866f, -0.23834053f, 0.39427605f, 0.19257283f, 
    -0.01288364f, 0.11598384f, 0.18763849f, 0.31435266f, -0.04516591f, -0.07733602f, -0.04906458f, 0.07351617f, 
    0.01049420f, -0.11648354f, -0.08781957f, 0.20311996f, 0.15633780f, -0.05703517f, -0.15842716f, -0.15814513f, 
    0.02582128f, -0.03006177f, 0.10855013f, 0.27147979f, 0.13118204f, 0.10025307f, 0.25703558f, 0.12468703f, 
    -0.02102385f, 0.03370244f, 0.13775761f, -0.04244297f, 0.21817370f, 0.11513713f, -0.07989234f, -0.39101928f, 
    -0.10312486f, -0.13524806f, -0.05805272f, -0.19293657f, -0.00616982f, -0.11486583f, 0.12017967f, -0.11538506f, 
    -0.16549976f, 0.01053283f, -0.05214439f, -0.35615084f, 0.14499505f, 0.20875640f, -0.29794160f, 0.11452756f, 
    -0.01210126f, 0.18055955f, 0.06293845f, 0.07870042f, 0.09679497f, 0.34317151f, 0.11970636f, 0.29633749f, 
    0.02933486f, 0.23730427f, 0.04380657f, 0.24750784f, 0.06168566f, 0.32168165f, -0.25974864f, 0.15090007f, 
    0.09776752f, 0.07657315f, -0.15961309f, -0.11886821f, 0.41821420f, -0.05022150f, -0.04524472f, -0.07699016f, 
    0.07848059f, -0.10587786f, 0.02971518f, 0.09875245f, -0.04757138f, -0.03451324f, -0.04352311f, 0.03647807f, 
    0.01575036f, 0.07809943f, 0.00035654f, -0.04264386f, -0.10249087f, 0.01757554f, 0.05952751f, 0.02949487f, 
    0.08683354f, 0.10828447f, -0.09373750f, -0.03983633f, 0.05171464f, -0.00678545f, -0.06981689f, 0.08432657f, 
    0.01374856f, 0.00840327f, -0.10242376f, 0.01497125f, 0.04391296f, -0.10405789f, -0.11022533f, -0.12002024f, 
    0.11495145f, -0.16147287f, -0.06975570f, -0.04920012f, -0.10063611f, -0.11700239f, -0.05064090f, 0.11495048f, 
    0.07920274f, 0.08600214f, -0.05044902f, 0.11305776f, -0.05268830f, -0.06243094f, 0.00475524f, 0.00335707f, 
    -0.00356837f, 0.04968962f, -0.00953808f, -0.02910871f, -0.01813900f, -0.06985842f, -0.12419804f, 0.02519283f, 
    -0.12388004f, -0.05212188f, -0.01886570f, 0.04069842f, 0.00964335f, -0.01194991f, -0.07449713f, 0.00172479f, 
    -0.06890746f, 0.24836762f, 0.01579924f, -0.52458870f, -0.20246041f, 0.09622216f, 0.25540236f, -0.16140550f, 
    0.04894675f, -0.13051848f, -0.13824674f, 0.16603690f, 0.14776684f, 0.29583901f, -0.14743122f, -0.05024867f, 
    -0.05110281f, -0.01784623f, 0.08071422f, -0.08869359f, -0.02367410f, 0.07595091f, -0.32427505f, 0.15298919f, 
    -0.03029919f, -0.07063616f, 0.16370621f, -0.05528376f, 0.09999298f, 0.06184594f, -0.04021525f, -0.02315123f, 
    0.15205473f, -0.61783004f, 0.23038830f, -0.53147346f, 0.24610013f, 0.53725839f, 0.16523252f, 0.10907807f, 
    -0.39515793f, 0.03336986f, 0.22232607f, 0.01650742f, 0.02396636f, 0.12488770f, -0.00314667f, -0.16232595f, 
    0.03592776f, 0.15315139f, 0.00829149f, 0.04100087f, -0.04192645f, 0.33904859f, -0.07391779f, 0.32263771f, 
    -0.05596388f, -0.03584493f, 0.09489746f, 0.18313888f, 0.04142783f, 0.31929231f, -0.42707887f, 0.09792690f, 
    0.03532560f, 0.03607928f, -0.09587113f, 0.20608515f, -0.01918617f, -0.11370706f, 0.12915671f, 0.07343362f, 
    0.07802916f, 0.01160713f, 0.09361791f, -0.03420956f, -0.13503143f, 0.01796431f, 0.20964980f, -0.11434569f, 
    0.07859178f, -0.01827322f, 0.26972905f, -0.00307445f, 0.17894553f, -0.01899883f, -0.14499837f, -0.49134803f, 
    0.03269382f, 0.00525916f, 0.14049201f, 0.19661331f, -0.10463934f, -0.02862390f, 0.13585109f, -0.08078607f, 
    0.06380452f, -0.28503758f, -0.01478682f, 0.01334654f, -0.11242352f, -0.02342804f, -0.07531644f, -0.01387419f, 
    -0.15990332f, -0.08368596f, -0.04214147f, -0.10871442f, -0.09443244f, 0.11509261f, -0.07361858f, 0.04107513f, 
    0.01510455f, 0.20624512f, -0.01373651f, 0.20124747f, 0.34648219f, -0.12933452f, 0.01503170f, 0.12067056f, 
    -0.07412394f, -0.06775748f, 0.13466641f, 0.36300620f, 0.36189964f, -0.02092711f, 0.10515103f, 0.11119717f, 
    -0.02792777f, -0.10528764f, 0.05950773f, -0.05069786f, -0.10447797f, -0.10691419f, -0.07127312f, -0.01381990f, 
    0.00087947f, 0.00636245f, -0.11793138f, -0.08165668f, -0.06818636f, -0.01844022f, 0.07517546f, 0.06524664f, 
    -0.09207271f, 0.07145654f, -0.04067697f, -0.03478070f, 0.04089056f, -0.05975316f, 0.01771170f, 0.07097462f, 
    -0.07060008f, -0.11429963f, 0.12256862f, -0.10510743f, -0.11854151f, -0.01737532f, 0.00710984f, 0.09349318f, 
    0.01985520f, -0.07730946f, -0.08934601f, 0.01589012f, -0.01355055f, -0.09071186f, -0.06297025f, -0.05517560f, 
    -0.10234644f, -0.05433133f, -0.07498713f, 0.07472137f, 0.09649219f, -0.04370128f, 0.03606856f, -0.04996952f, 
    -0.03856139f, 0.07984103f, 0.06266570f, -0.03106833f, 0.06116371f, -0.06964366f, -0.12032598f, 0.12084636f, 
    0.11384375f, 0.10842134f, 0.08275078f, 0.00535558f, -0.07563850f, -0.02951294f, 0.08460292f, 0.03050569f, 
    0.07340931f, -0.07123289f, 0.10592382f, -0.02133890f, 0.33018595f, -0.11488973f, 0.27764663f, -0.16240644f, 
    0.10918352f, -0.07658524f, 0.16676816f, -0.09916532f, 0.01502521f, 0.36719951f, -0.10190569f, 0.19833715f, 
    -0.05972563f, 0.07803348f, 0.12170396f, 0.11264871f, 0.24466434f, -0.03278324f, -0.05093351f, 0.33494934f, 
    0.08577782f, 0.10591495f, 0.13709605f, -0.28388712f, 0.06933115f, -0.11910785f, 0.12166722f, -0.04333692f, 
    -0.03156543f, 0.23379962f, -0.02434263f, 0.04720667f, 0.14776224f, 0.12013857f, -0.30403277f, -0.04189576f, 
    -0.12207904f, 0.06810617f, 0.13324121f, -0.06886517f, 0.04783071f, 0.13838209f, -0.00269251f, 0.05826990f, 
    -0.09487951f, 0.11020949f, 0.03240094f, 0.19481391f, -0.30162087f, 0.22573130f, -0.29129145f, 0.29894218f, 
    -0.09503550f, -0.06793935f, -0.27872509f, -0.37547049f, -0.00966960f, -0.10263841f, -0.10755412f, 0.04081107f, 
    0.10060579f, 0.21671622f, -0.03978351f, 0.21470031f, 0.01364845f, 0.08080181f, -0.31999347f, 0.04516210f, 
    -0.09086008f, -0.08485314f, 0.04218769f, 0.15280372f, 0.08118544f, -0.27412567f, 0.21158543f, -0.10481359f, 
    -0.06095141f, -0.04806983f, 0.05532604f, 0.07233698f, -0.12761873f, 0.08925974f, 0.12406444f, -0.53339106f, 
    -0.07341985f, -0.09154331f, 0.05414124f, 0.46278027f, -0.08046632f, 0.09648520f, -0.10324458f, 0.06495839f, 
    -0.10478804f, -0.03874976f, -0.13758893f, -0.02424013f, -0.13270453f, 0.25783014f, 0.23736271f, -0.04635885f, 
    0.26673484f, -0.01742580f, -0.09926356f, -0.11420327f, 0.06869046f, -0.10351009f, -0.05184059f, -0.07314388f, 
    0.15950452f, 0.06454689f, 0.07535995f, 0.11742433f, 0.29354262f, -0.03224799f, 0.11631220f, -0.18318821f, 
    -0.04457138f, 0.10980789f, 0.16192625f, 0.55062962f, -0.00832339f, 0.16628854f, 0.05689824f, -0.10485066f, 
    -0.05516140f, 0.10377462f, 0.01889486f, 0.28273600f, 0.13714464f, 0.05206360f, 0.11769897f, -0.01002720f, 
    -0.08473161f, 0.03523452f, -0.15312858f, 0.06758352f, 0.13110523f, -0.02194502f, 0.20032287f, 0.09786924f, 
    0.00469167f, 0.04417330f, 0.26188561f, 0.03653706f, 0.21010560f, -0.05375225f, -0.00167633f, -0.63121241f, 
    -0.04845649f, 0.09246632f, 0.00463991f, -0.12115933f, 0.00321532f, 0.03422368f, 0.18979992f, 0.11118320f, 
    -0.06453960f, -0.22587556f, -0.24391522f, 0.02009365f, -0.10577215f, 0.38472375f, -0.13760945f, 0.12334147f, 
    0.05306767f, 0.04842326f, -0.26837003f, 0.05517005f, -0.03813170f, 0.25091287f, 0.01763023f, 0.50526762f, 
    0.01218692f, 0.20090345f, -0.00942185f, 0.03747931f, 0.01052048f, -0.01054677f, -0.07787421f, -0.26696828f, 
    0.08621389f, 0.04201764f, 0.01956692f, 0.25099123f, 0.11908042f, 0.01959752f, 0.22410522f, 0.09548069f, 
    -0.10998377f, 0.21376532f, 0.10591824f, -0.05062281f, -0.08091782f, -0.09426768f, -0.04329383f, -0.01109240f, 
    0.04684852f, 0.11924481f, 0.08982507f, 0.28549352f, -0.08237274f, -0.03568999f, -0.22256745f, 0.29285628f, 
    -0.07980299f, -0.10291275f, -0.04351365f, 0.06995308f, -0.16231577f, 0.15226156f, 0.18693599f, 0.36091557f, 
    -0.07646912f, 0.18549679f, -0.10401708f, -0.23752795f, -0.06051987f, -0.11484513f, -0.25921544f, 0.13190819f, 
    0.13808453f, 0.11054412f, -0.00641355f, -0.33263385f, 0.27013844f, 0.19408678f, 0.09804560f, -0.00848906f, 
    0.28437138f, 0.19056314f, 0.16307911f, -0.10237038f, 0.03207092f, -0.19561663f, -0.01091729f, 0.15918420f, 
    0.07144086f, 0.04632880f, 0.10806099f, -0.03860876f, -0.23492913f, 0.38399646f, -0.17143443f, 0.06191281f, 
    0.06793533f, -0.05285973f, 0.12665579f, -0.20682445f, -0.02610025f, 0.03845153f, -0.05306429f, 0.05492401f, 
    -0.10274574f, -0.35076672f, 0.06970076f, 0.02578234f, -0.02753615f, 0.07047552f, -0.11854634f, 0.05691886f, 
    -0.03527212f, 0.14505272f, 0.21440063f, 0.30410188f, -0.08546957f, -0.09356360f, 0.01817859f, 0.18786591f, 
    -0.07346331f, -0.03769516f, 0.23139855f, 0.07798874f, 0.10028476f, 0.18869151f, 0.04769179f, 0.25571468f, 
    -0.07681003f, 0.12069182f, -0.26640660f, -0.33231363f, 0.07987411f, 0.00134600f, -0.15849094f, 0.05165010f, 
    0.11352177f, -0.13453805f, -0.05713694f, 0.31375900f, 0.13213070f, -0.10250983f, -0.28851283f, 0.06790936f, 
    0.27160203f, 0.03717789f, 0.07433509f, 0.10435267f, 0.06894183f, 0.16965251f, -0.04436502f, 0.09597795f, 
    -0.00362884f, 0.24241391f, -0.05977702f, 0.20280784f, -0.18051797f, 0.23880947f, -0.17376123f, 0.16904004f, 
    -0.10183413f, 0.06000420f, -0.15344210f, -0.32362133f, 0.05666558f, -0.04478932f, 0.21953604f, 0.10236005f, 
    0.02703467f, 0.31871799f, 0.06323975f, 0.08827187f, -0.20329250f, 0.08807334f, -0.25131974f, 0.11030268f, 
    -0.01005229f, -0.03097031f, -0.03945652f, 0.23109004f, 0.21733269f, -0.05332784f, 0.12518869f, -0.13602129f, 
    0.07455206f, -0.10596211f, 0.07917924f, -0.07407632f, -0.06283747f, -0.12135196f, 0.07419708f, -0.10970047f, 
    -0.10404068f, -0.15227397f, -0.32034254f, 0.35889226f, 0.04718257f, -0.04700124f, -0.06961725f, 0.00820661f, 
    -0.21884093f, 0.18347624f, -0.08518356f, 0.24104652f, -0.07996023f, -0.20773025f, -0.03125756f, 0.04772594f, 
    0.10501724f, 0.00858056f, 0.09954975f, -0.06878556f, 0.00030754f, -0.19485959f, -0.08396854f, -0.25423974f, 
    -0.02997046f, 0.09668095f, 0.03238310f, 0.24166782f, 0.19114614f, 0.07648547f, -0.38092747f, 0.10700581f, 
    -0.00860697f, -0.03035642f, -0.15797673f, 0.23386857f, -0.02365607f, -0.12557095f, -0.04469717f, 0.03153604f, 
    0.00409378f, 0.03707921f, 0.06249976f, -0.07833511f, -0.11425187f, 0.01637067f, 0.06112185f, 0.06972858f, 
    -0.04543569f, 0.10461196f, -0.11133411f, -0.08124257f, 0.01477787f, 0.04934762f, -0.11586865f, 0.02747877f, 
    -0.10433133f, -0.07252551f, 0.02659134f, -0.11221287f, 0.01610801f, -0.08139262f, 0.05431255f, -0.05380281f, 
    0.03801687f, -0.07379217f, -0.11407116f, -0.10649359f, -0.04160843f, -0.09331622f, 0.03202816f, 0.05570826f, 
    -0.04455308f, 0.02241917f, -0.13297497f, -0.02968593f, 0.07630251f, -0.04938247f, -0.09767371f, 0.02942059f, 
    -0.06169047f, -0.07586364f, 0.06607687f, 0.08724792f, -0.00772427f, 0.02330075f, 0.04619780f, 0.11129618f, 
    -0.08384883f, -0.03294865f, -0.07478977f, 0.03646892f, 0.00801075f, -0.05816219f, -0.10904539f, 0.10886434f, 
    0.04538469f, -0.04089820f, -0.04804866f, 0.10135116f, -0.12039556f, 0.11212726f, -0.11624987f, 0.05762382f, 
    -0.04267183f, 0.36614600f, -0.08207942f, 0.11440721f, 0.19326347f, -0.10018987f, 0.19851340f, 0.23930973f, 
    -0.00552989f, -0.10097179f, 0.05404608f, -0.17483944f, 0.28478006f, -0.23712003f, 0.11121831f, 0.09050070f, 
    0.07856047f, 0.01784250f, -0.20671649f, 0.00957807f, -0.04508657f, 0.10484519f, 0.29706612f, 0.14768174f, 
    0.04174916f, 0.23406763f, 0.30445081f, 0.07339592f, 0.00479538f, 0.01801707f, 0.00464273f, -0.00846164f, 
    0.15423803f, 0.03240167f, 0.02339060f, -0.36867082f, 0.14432943f, 0.05511638f, 0.34024990f, -0.03579645f, 
    0.07115988f, 0.09616663f, 0.10983093f, 0.01837774f, 0.09439679f, -0.02192855f, -0.05554546f, 0.56363487f, 
    0.07902445f, -0.15472427f, 0.11111918f, -0.22981541f, 0.06534612f, -0.14138052f, -0.02972292f, -0.35085434f, 
    -0.07489538f, 0.06810354f, 0.33372673f, -0.11937748f, -0.18159360f, 0.24011616f, -0.23697016f, -0.04304037f, 
    0.09211451f, -0.16392794f, -0.00337777f, 0.24257287f, 0.14055799f, 0.03956864f, 0.09695691f, 0.03414423f, 
    0.09030806f, 0.08197897f, 0.23331667f, -0.05730929f, 0.09796281f, 0.57274711f, 0.23498321f, -0.00633513f, 
    0.09144770f, 0.10958770f, -0.01155626f, -0.07550483f, -0.16231316f, -0.13146771f, -0.36680004f, -0.09857235f, 
    -0.06192785f, -0.00982000f, 0.23252302f, 0.27857342f, -0.10412924f, 0.12259113f, 0.34844109f, 0.00923080f, 
    -0.10269467f, 0.54763091f, -0.15137598f, -0.03615947f, -0.01185541f, -0.15606368f, -0.18131374f, -0.07658253f, 
    0.06669929f, 0.13342147f, 0.08790378f, 0.11044767f, 0.11967044f, 0.40175796f, 0.09770443f, -0.09211481f, 
    0.14076193f, -0.06722185f, -0.01616791f, -0.04310599f, 0.11595269f, 0.03527742f, 0.03488760f, -0.11201935f, 
    0.07988475f, -0.05732318f, -0.12257781f, -0.12776273f, 0.07981145f, 0.18300191f, -0.00847826f, -0.10254506f, 
    -0.06354392f, -0.07284298f, -0.07062200f, -0.03245744f, 0.09725805f, -0.03723566f, 0.10350436f, -0.07015943f, 
    -0.05117555f, 0.01770221f, -0.11635339f, -0.02988989f, -0.08482055f, 0.01113831f, 0.03619069f, 0.09404717f, 
    -0.09082212f, -0.00674871f, -0.09962327f, -0.07933524f, 0.08683319f, -0.06170862f, -0.06246255f, 0.04687177f, 
    0.09013692f, -0.07361828f, 0.00628413f, 0.05807175f, 0.06725501f, -0.09634736f, -0.05804991f, 0.09505536f, 
    -0.06937363f, 0.01015514f, -0.11966761f, 0.09551590f, 0.08603030f, -0.05629311f, -0.03289740f, -0.01566014f, 
    -0.10574764f, -0.00959735f, 0.07892661f, -0.11579903f, 0.09468544f, 0.02075996f, 0.11444524f, 0.01371336f, 
    -0.04879617f, -0.03204707f, 0.07458111f, -0.11932045f, -0.07528196f, 0.04684241f, -0.03330629f, 0.02346685f, 
    0.05510037f, 0.04562462f, -0.11365246f, 0.00130032f, 0.08061705f, -0.06248096f, -0.11189821f, 0.00101567f, 
    -0.03142659f, -0.10188796f, -0.00727346f, 0.02994340f, 0.05115671f, -0.04679739f, 0.04486864f, 0.02120714f, 
    0.06249709f, 0.07116687f, -0.11475626f, -0.00347201f, 0.05056201f, -0.00070380f, 0.04613023f, -0.14317818f, 
    0.11262539f, -0.09569515f, -0.12253438f, 0.02083853f, 0.03567448f, 0.04810787f, 0.03956017f, -0.07657772f, 
    -0.02673495f, 0.09595784f, -0.04241107f, -0.04292662f, 0.04775906f, -0.07146500f, 0.02945961f, 0.03186863f, 
    -0.03401705f, 0.09689584f, -0.07848844f, -0.01592089f, -0.09479235f, -0.10239629f, 0.02444180f, 0.06619763f, 
    -0.04521466f, 0.09126100f, -0.08309618f, 0.06616724f, 0.07598496f, -0.04197006f, -0.00139674f, -0.12936863f, 
    0.11012596f, 0.05686652f, 0.10130676f, -0.00993656f, -0.12603176f, -0.06483773f, 0.02794864f, 0.04236123f, 
    0.03955051f, -0.02867135f, -0.09253438f, 0.01386891f, 0.07455362f, -0.00205344f, -0.12661721f, -0.00851816f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.12504993f, 0.04923457f, 0.25150922f, 0.10525300f, -0.08785228f, 0.17315377f, 0.01927160f, 0.09351916f, 
    -0.07685836f, 0.14696284f, -0.03302466f, 0.15361832f, 0.02879067f, 0.17513230f, 0.01071709f, 0.06368313f, 
    -0.14498465f, 0.01115997f, 0.00814565f, 0.09625604f, 0.04005174f, -0.05938971f, -0.06905235f, 0.02376890f, 
    -0.11481225f, -0.07179548f, -0.04464912f, 0.28575873f, -0.08025268f, -0.07600982f, 0.05172023f, -0.13021044f, 
    -0.08939401f, 0.11094466f, -0.09473513f, 0.03656675f, -0.01961212f, 0.21793228f, 0.00131059f, 0.17723881f, 
    -0.13362969f, -0.00134860f, -0.03411829f, -0.02876996f, 0.11226439f, 0.07978263f, -0.00113580f, 0.14719176f, 
    0.12171247f, -0.09902485f, 0.02078595f, 0.18005387f, -0.11162011f, 0.07595365f, -0.10950246f, -0.03194416f, 
    0.02532923f, 0.18141121f, 0.13875717f, -0.06264738f, 0.11774361f, 0.16553712f, 0.02650427f, -0.06470864f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.35766366f, 0.05872028f, 0.14525923f, -0.06717344f, -0.05295945f, 0.21368578f, 0.03330211f, -0.07729535f, 
    0.00442027f, -0.25648242f, 0.01022375f, 0.03030057f, 0.04531721f, -0.28834283f, -0.00361056f, 0.18462145f, 
    0.07435467f, 0.16810645f, -0.54494643f, -0.26098299f, 0.08808633f, -0.16609956f, 0.10726590f, 0.13840429f, 
    0.03037162f, -0.19508107f, 0.06163282f, -0.29705417f, -0.11189345f, -0.08117996f, -0.18135472f, 0.05239794f, 
    0.28596523f, -0.00227982f, -0.12277123f, 0.27327442f, -0.56841207f, -0.04462489f, -0.02943093f, -0.46430141f, 
    -0.07636803f, 0.09496444f, -0.07614786f, 0.10070092f, -0.30640072f, -0.13459933f, -0.06117555f, -0.22447637f, 
    0.20019656f, 0.10532331f, 0.42595175f, 0.03339907f, -0.05186939f, 0.02603611f, 0.12420516f, 0.31222403f, 
    0.02414716f, -0.13733819f, -0.38122374f, 0.01693813f, 0.05225920f, 0.18495208f, -0.01864692f, -0.07071976f, 
    -0.39803371f, 0.10784682f, 0.14023113f, 0.02374495f, 0.06897234f, 0.33860734f, -0.06050153f, -0.12793259f, 
    0.03259323f, -0.40798256f, -0.03585896f, 0.10259863f, 0.00272530f, -0.03348261f, -0.06428038f, 0.23192738f, 
    -0.85469055f, 0.24257195f, -0.21170805f, -0.00643756f, 0.17590837f, -0.13276622f, 0.01949245f, -0.13833714f, 
    0.05898960f, -0.15360048f, -0.02068795f, 0.07537273f, 0.10287222f, -0.07560180f, 0.02666082f, 0.21076639f, 
    0.00601222f, -0.03861325f, -0.06998851f, -0.35470107f, 0.08098578f, -0.20842002f, 0.01998776f, 0.19674598f, 
    -0.00348076f, 0.01232219f, 0.05921892f, -0.07116447f, -0.23293532f, 0.13048276f, -0.22709461f, -0.20710719f, 
    0.11233120f, 0.01355712f, -0.61942339f, 0.13726963f, 0.01404491f, -0.22403862f, 0.04631013f, 0.24286072f, 
    -0.21447793f, 0.17797853f, 0.05375150f, 0.08151917f, -0.30803525f, -0.05925638f, -0.06477373f, 0.00585563f, 
    0.16055815f, -0.00105281f, 0.02657212f, -0.13222378f, -0.04942894f, -0.48396596f, 0.06348244f, -0.05386395f, 
    0.06397498f, 0.00241926f, -0.36763513f, -0.20402811f, -0.01034805f, -0.00857190f, 0.00968719f, -0.16618529f, 
    0.08528943f, 0.22672503f, -0.25741646f, -0.20071383f, 0.04696548f, -0.09207038f, 0.06089245f, 0.12494477f, 
    0.04811801f, -0.09965155f, 0.00908170f, -0.37319037f, 0.05053670f, -0.00414827f, 0.09832565f, 0.11263472f, 
    -0.41564846f, -0.01541812f, -0.05953025f, 0.09656743f, -0.22814222f, 0.33375335f, -0.08340862f, -0.29619855f, 
    0.06286369f, 0.08635592f, 0.20034751f, 0.03252355f, 0.34166259f, 0.11955248f, -0.21515562f, -0.13195780f, 
    0.15491979f, 0.04854372f, 0.34365767f, -0.03659765f, 0.01904133f, 0.00171159f, 0.03645261f, -0.04581920f, 
    0.10305395f, -0.00625654f, 0.31339669f, -0.05107363f, -0.36059788f, -0.26857102f, 0.09409329f, -0.09290694f, 
    0.03662265f, -0.57545769f, 0.00938088f, -0.02178398f, -0.01654367f, -0.15346383f, -0.36587730f, -0.12446526f, 
    0.12108665f, 0.08105086f, 0.20591292f, -0.16080181f, 0.09345300f, -0.38528109f, 0.11422786f, -0.14789030f, 
    0.15903908f, -0.19614334f, -0.34112048f, 0.21859980f, -0.73437858f, 0.25502303f, -0.01347649f, -0.25247148f, 
    0.02706605f, 0.18165652f, 0.05016314f, -0.56023407f, -0.03401767f, 0.09936307f, -0.18850207f, 0.49464130f, 
    0.13029076f, 0.01258993f, -0.04408180f, 0.11285132f, -0.02698527f, 0.18263745f, -0.07383086f, -0.23254429f, 
    -0.07331730f, 0.09304239f, -0.54697108f, 0.01826721f, 0.24257514f, -0.46720642f, 0.29775095f, -0.06667462f, 
    -0.04695383f, -0.06228970f, -0.25043643f, 0.16744241f, -0.01994093f, -0.05017662f, -0.04858359f, 0.18410380f, 
    -0.34200242f, -0.43948793f, -0.15736189f, 0.01835177f, 0.07955346f, 0.11463402f, -0.03022017f, -0.03033095f, 
    0.14305389f, -0.06724815f, 0.00407101f, 0.10127337f, 0.09271168f, 0.12038538f, -0.19807187f, -0.12435415f, 
    0.02739142f, 0.05294674f, 0.24493672f, 0.06535112f, 0.10028712f, -0.45700094f, 0.06500985f, 0.17732571f, 
    0.15253651f, 0.19098945f, -0.04796119f, -0.04829899f, -0.17053531f, 0.33578795f, 0.00679546f, 0.20930372f, 
    -0.13531296f, 0.19942068f, -0.08641675f, 0.05432511f, 0.05974585f, -0.01773960f, 0.06372091f, -0.36128429f, 
    0.00410477f, -0.03017903f, -0.05067579f, -0.21792755f, -0.23041867f, 0.15335816f, 0.11425734f, 0.16086465f, 
    -0.03384027f, -0.12172382f, -0.13128386f, 0.01188041f, -0.16488902f, -0.05354159f, 0.07873406f, 0.01753582f, 
    -0.12166434f, 0.02031957f, -0.40666303f, -0.22956271f, -0.06710064f, -0.30173996f, 0.21973960f, -0.03676854f, 
    0.12553436f, -0.08590432f, 0.28264096f, -0.10392056f, 0.30512130f, -0.05910602f, 0.04879016f, 0.04551685f, 
    -0.25496203f, 0.13232067f, 0.00523662f, -0.01213869f, 0.01340356f, -0.09133341f, 0.22764485f, 0.07710756f, 
    -0.13006511f, -0.13691550f, 0.22948363f, 0.33109179f, -0.12758495f, 0.18247373f, 0.04008249f, -0.56903875f, 
    -0.22630857f, -0.20519631f, 0.17279685f, -0.08592284f, 0.22665773f, -0.01263226f, -0.09096288f, 0.01765862f, 
    0.04581457f, -0.13751590f, -0.06777249f, 0.00044446f, -0.08646313f, 0.10162537f, -0.16674165f, -0.06552418f, 
    0.13749717f, -0.06310648f, -0.02162212f, 0.02754566f, 0.02399163f, -0.51515549f, -0.01826741f, 0.30864200f, 
    -0.04641277f, -0.05282328f, 0.12143137f, 0.04785112f, -0.46147636f, -0.02400039f, 0.13301370f, 0.33273727f, 
    -0.04370587f, -0.08716211f, -0.10322879f, -0.11401023f, 0.03354965f, 0.19137460f, -0.17957202f, -0.11037613f, 
    -0.14899170f, -0.03459005f, -0.20232061f, -0.00997943f, -0.08748957f, 0.16062468f, 0.02554474f, -0.05784195f, 
    -0.19180508f, 0.22280635f, 0.15102099f, -0.10895689f, -0.00531017f, -0.64653361f, -0.01643020f, 0.03206078f, 
    -0.15173538f, 0.12982088f, -0.02931103f, -0.01131247f, -0.11596718f, 0.05171430f, -0.06967693f, 0.03772143f, 
    0.23831050f, -0.57980216f, -0.36926457f, 0.14200830f, -0.33635381f, -0.19953588f, -0.01994864f, 0.24322274f, 
    -0.08688030f, -0.15294012f, -0.13887241f, 0.16462950f, -0.01242240f, -0.12265490f, -0.17871895f, 0.27288774f, 
    0.13574374f, -0.09886151f, -0.00785195f, 0.23338716f, -0.04387873f, 0.15006217f, -0.02952607f, -0.08308576f, 
    0.05738005f, -0.08083810f, 0.12166568f, 0.01273577f, -0.32212430f, -0.25112841f, -0.06999026f, -0.41162562f, 
    0.04373302f, 0.07273987f, 0.03481332f, -0.49135807f, 0.01644523f, 0.26240322f, -0.68103904f, -0.29744753f, 
    0.30481350f, 0.21965092f, -0.43629003f, 0.01554790f, -0.00079171f, 0.15690699f, -0.07234557f, -0.11438450f, 
    -0.22445509f, -0.29270414f, -0.59547430f, 0.05114748f, -0.06479754f, 0.13723806f, 0.28567845f, 0.00632383f, 
    -0.05717357f, 0.20369880f, -0.13681696f, -0.23974173f, 0.11711867f, -0.07007044f, -0.07932999f, 0.11560038f, 
    -0.10280015f, 0.07102572f, 0.30154464f, 0.11267244f, 0.06155244f, 0.15041375f, 0.09372069f, -0.29617521f, 
    0.04596583f, 0.14667018f, 0.06429452f, -0.44904149f, 0.00483139f, 0.05130751f, -0.43468508f, -0.29149047f, 
    0.25888470f, 0.04446431f, 0.01557394f, -0.21085116f, 0.14572313f, -0.30225381f, 0.06198044f, 0.27757844f, 
    0.07179809f, -0.05919091f, 0.06378692f, -0.00943068f, 0.21383505f, 0.05312326f, 0.12016510f, 0.02790506f, 
    -0.60197759f, -0.00778412f, 0.21993506f, -0.09649983f, -0.05829790f, -0.30609319f, 0.08845405f, 0.10858199f, 
    0.08118133f, -0.37694025f, -0.04790201f, 0.03731515f, 0.19118474f, -0.36403126f, 0.03544876f, 0.07275140f, 
    -0.25559464f, -0.12621734f, 0.10138659f, -0.12103101f, 0.06148641f, -0.09154732f, -0.41324428f, -0.04049562f, 
    -0.01247019f, -0.01613987f, -0.39055872f, 0.21908858f, -0.03173865f, 0.31823015f, 0.00864294f, 0.39511475f, 
    -0.61396521f, 0.04593535f, 0.37232098f, -0.34469789f, -0.09748272f, -0.07674947f, -0.11619976f, -0.27140680f, 
    -0.02879455f, -0.53458267f, 0.05201977f, 0.03175044f, -0.11515166f, 0.08827808f, 0.04596581f, -0.07804482f, 
    -0.27458626f, 0.04069825f, -0.06528167f, 0.44977811f, -0.11975757f, -0.69629622f, 0.02191138f, -0.01897525f, 
    -0.04965826f, -0.04032493f, 0.22327681f, 0.10339575f, 0.22537646f, 0.06671869f, -0.37388486f, -0.03220030f, 
    0.11312655f, -0.01624316f, -0.34160134f, 0.21083456f, 0.01526754f, -0.23047933f, 0.14498942f, -0.15094419f, 
    -0.20290987f, -0.01851801f, 0.29504931f, -0.12780340f, -0.32266060f, 0.37054938f, -0.03158490f, -0.02570799f, 
    0.23223765f, 0.15903249f, 0.22362942f, -0.04007940f, -0.06923973f, 0.01042227f, -0.08681332f, 0.00201393f, 
    -0.11742256f, -0.53797150f, -0.37833697f, -0.46830517f, -0.11026692f, 0.21725738f, 0.08375259f, -0.26409915f, 
    -0.07494777f, -0.59626687f, 0.27644920f, -0.10087367f, -0.01283914f, 0.18197066f, 0.08871409f, 0.21554334f, 
    0.01029829f, 0.13734925f, 0.01406937f, 0.24122414f, -0.09985758f, 0.05061032f, 0.15537569f, 0.04119832f, 
    -0.13466510f, 0.05190115f, 0.09487510f, -0.01150739f, -0.18073364f, 0.00051470f, -0.08247696f, -0.28448361f, 
    -0.03285120f, 0.09376617f, -0.03161718f, -0.00009786f, -0.00302110f, -0.38506338f, 0.17796890f, 0.26912215f, 
    -0.06064651f, 0.03854212f, 0.21359216f, -0.14951114f, -0.05785190f, -0.18474528f, -0.11720253f, -0.60036099f, 
    0.26959053f, 0.09190794f, -0.20751916f, -0.09998785f, -0.09153131f, -0.29053977f, 0.09280636f, -0.02719330f, 
    -0.41406152f, -0.41087312f, 0.13206980f, -0.01659468f, -0.05330245f, -0.00722959f, -0.16147539f, 0.03249606f, 
    -0.03208845f, 0.13369545f, 0.13693149f, 0.10325493f, -0.03199949f, -0.00105041f, -0.06315261f, -0.36532214f, 
    -0.10276893f, 0.38066933f, 0.01925587f, 0.26188168f, -0.34861830f, -0.46776855f, 0.02506359f, -0.38837147f, 
    0.08131837f, -0.14845984f, 0.04686831f, -0.03262708f, -0.07571875f, -0.07922380f, 0.40594453f, -0.34858358f, 
    -0.08112280f, -0.10701931f, 0.07233540f, -0.23003359f, -0.00732459f, 0.34713456f, 0.01004148f, 0.31641272f, 
    0.07201367f, -0.05831070f, -0.40363222f, 0.08942746f, 0.15629302f, 0.21220052f, -0.10194852f, 0.15134893f, 
    -0.12033810f, 0.07296689f, 0.39804476f, 0.04558056f, -0.06922057f, 0.07760797f, -0.37108284f, -0.41601625f, 
    -0.47072607f, -0.29497141f, -0.29097956f, 0.01199986f, 0.00217960f, 0.12786809f, -0.06049653f, -0.08870541f, 
    -0.06805188f, -0.17870687f, 0.05635528f, 0.06361500f, 0.06112076f, 0.01765117f, 0.22348356f, 0.07073658f, 
    -0.01465990f, -0.01859198f, 0.15974393f, -0.18440941f, 0.10492444f, -0.14266033f, 0.05196118f, -0.41638094f, 
    -0.66507638f, -0.41386008f, 0.13999674f, -0.02437516f, -0.57470095f, 0.14064780f, 0.04049833f, -0.39603999f, 
    -0.14736098f, 0.04809112f, -0.15819716f, 0.42264286f, -0.03179542f, 0.06747037f, -0.12878576f, -0.16336858f, 
    -0.34606975f, 0.07320973f, 0.01642952f, -0.26474988f, 0.32324579f, -0.03964074f, -0.04736540f, -0.18613738f, 
    0.00054902f, -0.07521744f, -0.30389380f, 0.01868150f, 0.08923905f, -0.13156743f, -0.10904358f, -0.25788134f, 
    0.16813198f, -0.05290662f, -0.12074764f, -0.02143091f, 0.06745139f, 0.26658949f, -0.50098121f, 0.22809267f, 
    0.20511188f, 0.22173442f, -0.57772058f, -0.11731779f, 0.06526606f, -0.22627044f, 0.05592679f, 0.02919117f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.02112811f, 0.02684363f, 0.03040795f, -0.09453997f, 0.00199959f, 0.02913387f, 0.07468210f, -0.00575176f, 
    -0.03891004f, -0.05195575f, -0.04438300f, 0.00163195f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
