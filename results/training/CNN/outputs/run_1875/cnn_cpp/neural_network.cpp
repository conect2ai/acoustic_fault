#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.53677607f, -0.32540870f, 0.47552580f, -0.07697976f, 0.48694119f, 0.10957604f, 0.21697864f, -0.59700167f, 
    0.45175713f, -0.22478399f, -0.30807936f, 0.95277631f, -0.20174371f, -0.82734603f, 1.08753777f, 0.38642618f, 
    -0.39115384f, -0.04808860f, -0.48872972f, 0.48410144f, 0.58100837f, 0.23421939f, 0.58804137f, 0.18658996f, 
    -0.32374692f, -0.81856251f, -0.73427278f, -1.04206908f, -0.38330424f, -0.68122065f, -0.64565754f, -0.22465281f, 
    -0.28657654f, -0.47843623f, -0.70692337f, -0.61731714f, 0.73868454f, 0.65272081f, 0.28408995f, 0.44780093f, 
    0.60996538f, 0.55693364f, 0.04806634f, 0.28802672f, 0.11979098f, -0.65026164f, -0.05072356f, 0.57415617f, 
    -0.00576794f, -0.15647294f, -0.06947900f, 0.27145329f, 0.69809854f, 0.84245032f, -1.46484709f, -1.09313333f, 
    -1.10979223f, 0.65637136f, 0.36039683f, 0.42430478f, 0.63912213f, 0.37700692f, -0.26951462f, -0.12561472f, 
    0.81162119f, 0.47730082f, 0.29786220f, -0.22657581f, -0.14895517f, 0.04597980f, 0.44874331f, -0.56214714f, 
    -0.10479593f, -0.13278329f, -0.43466234f, 0.62270355f, 1.08270609f, -0.03779744f, -0.48801789f, -0.66219997f, 
    -0.27121121f, -0.86786783f, -0.01033292f, -0.05826901f, 0.33237055f, 0.88589716f, 0.82809114f, 0.41544911f, 
    0.56309497f, 0.30226922f, 0.38417998f, 1.18442619f, 0.27202067f, -0.62130404f, -0.54266715f, -0.56151348f, 
    -0.02423784f, -0.36697647f, -0.10708583f, -0.10267314f, -1.03992856f, 0.97579503f, -0.76128751f, -0.52258134f, 
    -0.06871322f, 0.26237950f, 0.21436520f, -0.62748617f, 0.13535218f, 0.53647077f, -0.79232776f, -0.70441717f, 
    -0.38262966f, 0.76610136f, -0.78323126f, -0.11032400f, -0.71678060f, -0.59716821f, -0.33327278f, -0.72867543f, 
    -0.55980146f, -0.78124112f, -0.52545166f, -0.30941620f, -0.70610380f, 1.05641568f, 1.02305532f, 0.62524199f, 
    0.54852045f, -1.02435684f, -0.62309802f, 0.20693399f, -0.04237596f, 0.29013038f, 0.09800903f, -0.19995528f, 
    -0.03689428f, 0.28175738f, 0.37914661f, 0.64456844f, -0.22632384f, -0.60455018f, -0.57998520f, 0.97345412f, 
    -0.41053635f, 1.06465411f, -0.74808562f, -0.50558269f, -0.06850654f, -0.20908545f, 0.64740497f, 0.30151939f, 
    0.23629050f, 0.34860668f, -0.02603503f, -0.00383716f, -0.30925733f, 0.79550165f, 0.72723138f, 0.24166657f, 
    0.36595201f, 0.57807797f, -1.04449677f, -0.82996738f, -0.20050661f, -0.51285142f, -0.27480987f, -0.78845280f, 
    -0.14675376f, 0.32424068f, 0.00511278f, 0.18242446f, -1.45366585f, -0.84457767f, 1.41187024f, 0.37028798f, 
    0.08000995f, 0.19048192f, -0.54979056f, 0.16437650f, 0.49909964f, 0.16298535f, -0.60611689f, -0.75065589f, 
    -0.10373165f, 0.27744469f, -0.17418985f, 0.55076325f, 0.85280395f, 0.67265582f, 0.37849918f, 0.60269380f, 
    0.59778434f, -0.81548005f, -0.45158601f, 0.16268571f, -0.19550550f, 0.11823179f, 1.16577172f, 0.47427136f, 
    -1.02686048f, 0.19318266f, -0.26853329f, 0.38801354f, 0.12815519f, -0.05902671f, -0.44860706f, -1.15791249f, 
    0.51556009f, 0.66670245f, 0.11771266f, -0.67450756f, -1.16856444f, 0.28446054f, 0.38657653f, -0.47308087f, 
    0.35921326f, 0.93823254f, 0.17352767f, -1.00870347f, -0.35393167f, -0.55134463f, 0.75885391f, 0.27649042f, 
    -0.68509758f, 0.18045689f, -0.57909715f, 0.10743687f, 0.25164965f, -0.37962621f, -0.92466944f, 0.12802309f, 
    0.71215510f, 0.67053449f, 0.60574758f, 0.55802190f, 0.40881085f, -0.14527628f, 0.45867389f, 0.07000813f, 
    0.56716263f, -0.30042624f, -0.65869433f, -1.01066947f, 1.61365247f, -0.99905330f, -0.69882840f, -0.05181946f, 
    0.61804700f, 0.00472478f, -0.04894571f, 0.06456269f, 0.63188440f, -0.23716658f, 0.16910625f, -1.14807665f, 
    -0.76134849f, -1.27242279f, 0.27211231f, -0.19317573f, 0.63729852f, 0.24801160f, 0.27703249f, -0.57139140f, 
    0.03349132f, 1.18126905f, -0.85926843f, -0.02671910f, 0.23006031f, 0.09326292f, -0.96152490f, -1.13862932f, 
    -0.17825717f, 0.74966741f, 0.43947265f, -0.25598317f, -0.61706108f, -0.33528513f, -0.86199343f, 0.75066620f, 
    -0.77805448f, 0.65662140f, -0.33295807f, 0.28026584f, 0.36119324f, 0.00313503f, 0.15690970f, 0.23409410f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.69700605f, 0.36248791f, -0.21449803f, 0.43495694f, -0.03458761f, 0.23667631f, -0.17963332f, -0.30514365f, 
    0.13018887f, 0.50692749f, 0.03266695f, 0.54680777f, -0.18457857f, -0.05993965f, -0.09034632f, 0.38137028f, 
    -0.12475590f, -0.28363669f, -0.60987741f, 0.10655954f, 0.42683622f, 0.48741806f, 0.20350686f, 0.25719813f, 
    -0.14686659f, -0.15620662f, 0.24909155f, -0.02527347f, 0.24178945f, -0.17147942f, 0.33776116f, 0.65518439f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03724870f, -0.02938554f, 0.11374199f, 0.25019783f, -0.01753892f, 0.00889376f, 0.12660651f, 0.15280223f, 
    0.14939708f, -0.10575272f, -0.43179128f, 0.13103326f, 0.03516312f, 0.00799730f, 0.03403378f, 0.06816813f, 
    0.26203579f, -0.08649813f, -0.00866151f, -0.01577450f, -0.15553348f, 0.13864732f, 0.03098310f, 0.01226085f, 
    -0.09981986f, 0.14009304f, 0.11804532f, -0.48309183f, 0.12832165f, 0.11097841f, -0.07182452f, 0.31927112f, 
    -0.05177739f, -0.04491521f, 0.08413436f, 0.11894944f, -0.07894299f, -0.11119672f, -0.07927827f, 0.07379609f, 
    0.12929763f, 0.02462948f, 0.02990107f, -0.01155928f, 0.04719275f, 0.08007028f, 0.02643951f, 0.07216302f, 
    0.08170414f, 0.00942134f, -0.05721273f, -0.05945764f, -0.53972930f, -0.22222036f, -0.12877062f, 0.09007846f, 
    0.62694097f, 0.09548953f, -0.08116040f, -0.16346945f, 0.23006436f, 0.09117013f, 0.01041904f, -0.40415743f, 
    -0.18676710f, -0.04738954f, 0.11144890f, -0.00013474f, 0.11774582f, 0.06844671f, 0.00029763f, 0.09578170f, 
    -0.01339116f, 0.14287713f, 0.14461935f, 0.02509094f, 0.00091700f, -0.05135617f, 0.05005887f, 0.32798889f, 
    0.12918757f, 0.21174616f, 0.13762650f, 0.29263628f, 0.09878018f, 0.03606372f, 0.05993874f, 0.03596240f, 
    0.16527133f, 0.08557349f, -0.21111028f, -0.20345731f, -0.04843123f, 0.04705054f, 0.18077166f, 0.03898919f, 
    0.11336457f, 0.08004167f, 0.00556512f, -0.06941245f, -0.06852209f, 0.15331572f, 0.03056815f, 0.18190163f, 
    0.02358958f, -0.18364483f, 0.10672129f, -0.04918332f, -0.28194293f, -0.24687138f, -0.39078340f, 0.06711542f, 
    -0.02012452f, -0.05206497f, 0.04193531f, 0.16572531f, 0.06405021f, -0.36650315f, -0.06386288f, -0.01688273f, 
    0.09263667f, 0.01849668f, 0.01859709f, -0.11877163f, -0.00896154f, 0.06796917f, -0.39207748f, -0.31761986f, 
    -0.11526138f, -0.16434611f, 0.00148572f, -0.01037332f, -0.05650987f, -0.03753402f, -0.10460074f, 0.02297143f, 
    -0.16707277f, 0.06813501f, 0.03033305f, 0.10855342f, -0.11398043f, 0.08423495f, 0.17276618f, 0.36122423f, 
    0.30890742f, 0.09895068f, 0.08783418f, -0.00322822f, -0.34309489f, 0.01430858f, 0.02787207f, -0.45200932f, 
    -0.42776150f, -0.01728308f, -0.03222243f, 0.13448168f, 0.00674196f, 0.04005328f, 0.04992913f, -0.15189685f, 
    0.11615972f, -0.27735198f, -0.66196603f, -0.42716607f, -0.45920295f, 0.14124303f, 0.01462685f, -0.33394092f, 
    -0.20840977f, 0.08631294f, -0.02676396f, -0.16072673f, 0.25914603f, 0.13277052f, -0.13099772f, 0.07111746f, 
    -0.14942427f, -0.04139404f, 0.15457360f, 0.19255228f, 0.06218352f, 0.19652508f, 0.07486298f, -0.08376113f, 
    -0.05095264f, -0.17484158f, -0.13516766f, -0.20605953f, -0.22019310f, -0.19125286f, -0.12835541f, 0.07061608f, 
    0.13244489f, 0.16891938f, 0.26835370f, 0.04252204f, 0.03736261f, -0.01720380f, 0.10362370f, -0.18343745f, 
    -0.22101721f, 0.17707714f, -0.01740527f, -0.02892579f, 0.19225548f, 0.11659897f, -0.12246593f, -0.10191195f, 
    -0.41995075f, -0.13067773f, 0.21451016f, -0.24675861f, -0.16372880f, -0.01544256f, -0.02190538f, -0.01903322f, 
    0.00769571f, -0.42691180f, -0.16301507f, -0.15887037f, -0.12650935f, 0.12985496f, 0.18675871f, -0.03485874f, 
    -0.03003702f, 0.03575154f, 0.03657740f, -0.14866632f, 0.11541738f, -0.22875994f, -0.07291777f, -0.22873218f, 
    -0.33956581f, -0.15324952f, -0.05705862f, -0.28111202f, -0.09091514f, 0.20903073f, 0.00263717f, 0.05449312f, 
    0.24763907f, 0.08400509f, 0.01464417f, -0.12662521f, 0.01402991f, -0.31365663f, 0.11975894f, -0.42108104f, 
    0.07772361f, 0.13647397f, 0.16166690f, -0.15816730f, -0.07994258f, -0.04035338f, -0.10107429f, -0.14532945f, 
    -0.05956389f, -0.02350963f, 0.03166385f, 0.08350582f, 0.00142024f, -0.01373859f, -0.11308652f, 0.18285428f, 
    0.12032327f, -0.16740836f, 0.22325376f, -0.01070955f, -0.24648273f, 0.06068120f, -0.13467494f, 0.38789779f, 
    0.35257193f, -0.13528645f, 0.09477831f, -0.06225161f, 0.11559157f, 0.11959684f, 0.18542783f, -0.03747159f, 
    -0.05036662f, 0.07020803f, 0.23920426f, 0.10219585f, 0.14637753f, 0.06097031f, 0.01452224f, -0.20311175f, 
    -0.07391527f, -0.20084208f, 0.00857990f, 0.26292446f, -0.12790927f, 0.14016132f, 0.08588246f, 0.17843077f, 
    0.03927775f, 0.15719286f, -0.00314254f, -0.37478533f, 0.04584881f, -0.11048373f, -0.00511354f, 0.02206670f, 
    0.04364711f, -0.26954710f, 0.16703445f, -0.05846287f, -0.09795809f, 0.02956792f, -0.28114453f, 0.02928767f, 
    -0.04893965f, 0.42276311f, 0.38523838f, -0.16537499f, -0.39187849f, 0.05668761f, 0.01774066f, -0.17069529f, 
    0.11565899f, 0.04343697f, -0.20126782f, -0.36043093f, -0.03597860f, -0.11968690f, -0.01544040f, 0.08237346f, 
    -0.13137798f, -0.06699283f, 0.16962788f, 0.15711206f, 0.13065647f, 0.20277648f, -0.09401622f, -0.07896729f, 
    -0.19061524f, -0.10114320f, -0.20895584f, 0.10380497f, 0.02851587f, 0.01167325f, -0.40214318f, -0.12794928f, 
    0.27709094f, 0.12706041f, 0.02047956f, -0.07565951f, -0.05773402f, -0.15684666f, 0.10146134f, -0.08633120f, 
    0.14935200f, -0.18657874f, 0.10067889f, 0.06961797f, -0.05632420f, -0.21345289f, 0.10917703f, 0.11742581f, 
    0.22534092f, -0.19362490f, -0.09895595f, -0.32472497f, -0.65670294f, 0.02895481f, 0.09090803f, 0.00472276f, 
    0.06474362f, 0.15398400f, 0.09770700f, 0.05164881f, -0.07472077f, -0.11670837f, -0.17920606f, 0.10757665f, 
    0.17482443f, 0.13113244f, 0.11693247f, 0.47527915f, 0.30071089f, 0.08258737f, -0.00430381f, 0.00005620f, 
    -0.11551275f, 0.13882580f, 0.00061378f, -0.14876994f, 0.11201858f, 0.24158522f, 0.09718996f, -0.13005462f, 
    0.12521620f, 0.16279115f, 0.09364290f, 0.15451851f, -0.04581897f, -0.22347680f, -0.05139299f, -0.09620846f, 
    -0.22090220f, 0.22450306f, 0.24641398f, 0.16515025f, 0.25321782f, 0.22353792f, -0.22033638f, 0.30111212f, 
    0.07863006f, -0.10094661f, -0.03655405f, 0.02437995f, -0.19083667f, -0.07328139f, -0.32367316f, 0.34095481f, 
    0.17341323f, -0.00950506f, 0.06472445f, 0.03014708f, -0.00039600f, -0.15334919f, -0.09309005f, -0.00578030f, 
    -0.18295440f, -0.25541267f, -0.04439072f, -0.14962459f, 0.03538057f, -0.02159204f, 0.05685290f, 0.05755052f, 
    0.15264364f, 0.41400325f, 0.08854805f, -0.21360722f, -0.15081507f, -0.14687359f, 0.16846035f, 0.13570566f, 
    -0.11185168f, 0.04535471f, -0.02963030f, 0.07440250f, -0.30520487f, -0.18233640f, 0.10582451f, 0.16198604f, 
    0.23958559f, 0.05537820f, -0.12682402f, -0.29453114f, 0.18345514f, 0.03021415f, -0.01659770f, -0.14504886f, 
    -0.12298167f, -0.21753447f, -0.03523834f, 0.02527291f, 0.16727921f, 0.39204672f, 0.10626643f, -0.19629778f, 
    -0.07014325f, -0.01228699f, -0.05902290f, 0.01286215f, 0.14981526f, -0.00949411f, 0.15522081f, -0.04058061f, 
    0.05496427f, -0.03576595f, 0.17960988f, 0.02819210f, -0.07672273f, -0.31175172f, 0.26965973f, 0.10020748f, 
    0.03763170f, 0.07267965f, 0.05368622f, 0.26464289f, -0.14011493f, -0.13785520f, -0.06352107f, -0.02989232f, 
    -0.12803400f, 0.00693423f, 0.06301302f, -0.09203928f, 0.08426500f, 0.05511343f, -0.05876827f, 0.33824039f, 
    0.33057085f, 0.35267514f, 0.08419623f, -0.07804191f, -0.19978708f, 0.16895555f, -0.04205934f, -0.09762235f, 
    -0.07584416f, 0.51762271f, 0.18415272f, 0.00969061f, 0.01900870f, 0.11648186f, 0.16495435f, 0.04016422f, 
    0.11280663f, 0.14555450f, -0.28564876f, 0.17697534f, -0.24126126f, -0.09815875f, -0.07363603f, 0.13553822f, 
    -0.07181928f, 0.36561289f, -0.12684274f, -0.04610045f, -0.02382040f, 0.12277159f, -0.05708220f, 0.02659589f, 
    0.03568362f, 0.12598850f, -0.03769022f, 0.44266126f, -0.02919334f, -0.03820870f, -0.11092764f, 0.16861261f, 
    0.29326323f, 0.09668177f, 0.04476557f, -0.30336648f, 0.16889495f, 0.05606371f, 0.66537786f, 0.00329688f, 
    -0.02356248f, 0.08660954f, 0.02214533f, -0.27004433f, -0.06502274f, 0.13564193f, -0.00498034f, 0.19819060f, 
    -0.09655701f, -0.43215063f, -0.48161253f, -0.13721791f, 0.28875107f, 0.13116053f, 0.09493999f, -0.12830289f, 
    0.02144917f, -0.03791555f, -0.11966332f, -0.11250427f, 0.00218543f, -0.07522437f, 0.25345433f, -0.00258805f, 
    -0.13589458f, 0.01471118f, 0.04601788f, -0.04090659f, 0.07624406f, 0.09875898f, 0.01334214f, 0.04328020f, 
    0.05078805f, -0.03534744f, -0.05778655f, 0.02527927f, -0.00089136f, 0.02283068f, 0.02264296f, 0.04660691f, 
    -0.03248484f, -0.01589908f, -0.04359270f, 0.01149711f, 0.02404331f, 0.02415318f, -0.03543036f, 0.03836029f, 
    0.04135619f, 0.00210546f, -0.06379312f, 0.02699142f, 0.05313376f, 0.04734808f, -0.05683675f, 0.00876881f, 
    -0.04665497f, 0.00631452f, 0.03388914f, -0.04448101f, -0.03064435f, -0.01430929f, 0.02862939f, 0.02014438f, 
    -0.00335799f, 0.04015691f, -0.05215839f, 0.00861940f, 0.00094587f, 0.04386477f, -0.03353096f, -0.02765452f, 
    0.01577239f, 0.03627983f, -0.00154592f, -0.03021693f, 0.02081851f, 0.03783503f, 0.00563191f, 0.02495996f, 
    0.01375859f, -0.04421430f, 0.03656380f, -0.02574042f, 0.03549989f, -0.05124561f, 0.01225590f, -0.02009868f, 
    0.04651845f, -0.03642089f, -0.02553358f, 0.02203212f, 0.04066713f, -0.03400599f, 0.01128805f, 0.03699590f, 
    -0.01171546f, -0.00860193f, 0.03680502f, -0.02708897f, -0.03180864f, 0.02395564f, 0.04502834f, -0.02363363f, 
    0.02839234f, -0.05840975f, 0.03279636f, -0.01383010f, 0.03773339f, 0.04034818f, -0.01198097f, -0.00358384f, 
    -0.05621719f, -0.01797637f, -0.05801262f, -0.01707926f, 0.01474673f, -0.03211856f, 0.01826745f, -0.03033784f, 
    -0.03610720f, -0.02392597f, 0.00413310f, 0.04008980f, -0.06029963f, 0.02078803f, 0.04038679f, 0.02613883f, 
    -0.05998514f, 0.01305030f, 0.01609348f, -0.01508832f, 0.03525012f, -0.04069409f, 0.04630043f, 0.03609654f, 
    -0.01947877f, -0.03405938f, 0.02956426f, 0.03467311f, -0.07263330f, -0.02015886f, -0.05911512f, -0.02076607f, 
    -0.04411769f, 0.03696468f, -0.02891625f, -0.06691375f, -0.01304484f, -0.01230382f, 0.04163264f, 0.00849468f, 
    0.00329649f, -0.01680508f, 0.03031742f, 0.01508211f, -0.05502420f, -0.06118503f, -0.06025092f, 0.04237414f, 
    -0.00198562f, 0.03667061f, -0.00131174f, -0.02413972f, 0.04435434f, 0.00855363f, 0.00966168f, -0.06055845f, 
    0.01701771f, 0.02733688f, -0.04652406f, 0.01331072f, -0.04130260f, -0.06869807f, 0.01985012f, -0.00133581f, 
    -0.06444234f, 0.03997269f, 0.01248405f, -0.04745067f, -0.01982314f, -0.04529709f, 0.01541328f, 0.03013121f, 
    -0.05495913f, -0.02974966f, -0.03532643f, 0.00950613f, 0.00212532f, 0.00431203f, -0.00977145f, -0.01917180f, 
    0.00827874f, 0.01405422f, 0.03007638f, -0.00731958f, 0.04282947f, -0.04592831f, 0.02401223f, -0.02007637f, 
    0.03960860f, 0.03504544f, -0.02548292f, 0.01203252f, -0.02847842f, -0.01136100f, -0.05478267f, 0.01380616f, 
    -0.00933000f, 0.01330609f, -0.06118947f, -0.05160613f, 0.04013104f, -0.03074459f, 0.03161750f, -0.07258503f, 
    0.01918686f, -0.01854286f, 0.00706312f, 0.02627839f, -0.05179902f, -0.05377319f, 0.00821410f, -0.01738524f, 
    -0.04798257f, 0.03533521f, -0.03162597f, 0.01036704f, 0.02589988f, -0.04800715f, -0.07008275f, -0.07101963f, 
    -0.02676279f, -0.03182080f, 0.03799203f, -0.06086204f, -0.05558890f, 0.00258640f, -0.00621958f, -0.03227623f, 
    -0.02921733f, 0.03506043f, -0.00154587f, 0.02102003f, -0.01340650f, -0.02051568f, 0.01653426f, 0.02917133f, 
    -0.01785488f, -0.01769053f, 0.02129759f, -0.02142577f, 0.04782555f, 0.01517679f, -0.04965276f, -0.06529716f, 
    -0.01367761f, -0.01637363f, 0.01399078f, -0.03860000f, 0.03594003f, 0.02832885f, -0.03937101f, -0.00713167f, 
    -0.03964071f, 0.00898999f, -0.06762849f, -0.05070345f, 0.02425212f, -0.05185292f, -0.03041152f, 0.01315007f, 
    -0.03525040f, -0.05851081f, -0.02773404f, 0.00441756f, 0.02877240f, 0.03205381f, -0.02860650f, -0.02463578f, 
    0.02936920f, -0.00988672f, -0.01321607f, 0.01487065f, -0.01446602f, 0.01009354f, -0.00777984f, 0.03776608f, 
    0.01968128f, 0.02703181f, -0.03487231f, -0.01603561f, 0.03258103f, 0.03196157f, -0.04459925f, 0.00249056f, 
    0.00738642f, 0.02267489f, 0.04487301f, -0.01186248f, 0.02354280f, 0.00474796f, 0.04233470f, -0.03020195f, 
    -0.03327548f, 0.03074014f, -0.04326357f, -0.01793106f, -0.03616250f, 0.01019015f, -0.05328607f, -0.00188876f, 
    -0.04928622f, -0.02162680f, 0.04124958f, -0.01930246f, 0.01500244f, -0.05820903f, 0.02671108f, -0.00839714f, 
    -0.02350796f, 0.03566193f, 0.00654750f, -0.03842602f, 0.05182031f, -0.02372031f, -0.03989083f, 0.02635538f, 
    0.01737165f, -0.03850012f, -0.01796824f, 0.05323465f, 0.03358880f, -0.03202914f, -0.04270233f, 0.02885596f, 
    0.00633258f, -0.06453586f, -0.01442290f, 0.05165438f, 0.00785298f, 0.00570412f, -0.06122824f, -0.00639609f, 
    -0.01166947f, 0.00229960f, 0.01352526f, 0.00962789f, 0.03812847f, -0.00545926f, 0.03433878f, -0.01200911f, 
    0.02238870f, 0.01639373f, -0.02717389f, -0.04501827f, 0.00930951f, -0.02189041f, -0.00491816f, -0.04526096f, 
    -0.01528674f, 0.02452378f, -0.04809533f, 0.04730172f, -0.05400915f, 0.05163421f, 0.00861060f, -0.05568290f, 
    0.01488476f, 0.03421398f, -0.04349799f, -0.04813112f, -0.03517278f, 0.00976193f, 0.00234428f, 0.03590671f, 
    -0.00516411f, -0.03459178f, -0.01201270f, -0.06658302f, 0.01963705f, 0.03152239f, -0.00521095f, -0.00129398f, 
    0.00047746f, 0.04538870f, 0.00970411f, -0.02470447f, -0.03320549f, -0.01676694f, 0.02265190f, -0.05845167f, 
    -0.06173196f, -0.04660159f, -0.05900833f, -0.03984001f, -0.05023888f, -0.00178664f, 0.02989321f, 0.00661909f, 
    -0.03197131f, -0.01794787f, 0.02270239f, 0.04829093f, 0.03027228f, -0.04567944f, -0.02290067f, 0.00124991f, 
    0.04439066f, 0.02997208f, 0.04806162f, 0.01010594f, 0.02922371f, 0.04143219f, 0.01894436f, -0.04556224f, 
    0.05486425f, -0.04515897f, 0.00778861f, -0.03724427f, 0.00677730f, -0.05006121f, -0.02852174f, 0.01303579f, 
    0.02491696f, 0.00880466f, -0.00573444f, 0.04621274f, -0.05426578f, -0.05689847f, -0.05797637f, 0.03734070f, 
    -0.00294569f, 0.02754724f, -0.04456448f, 0.03950080f, -0.05095842f, 0.01846365f, -0.07347777f, -0.07416973f, 
    0.02852619f, -0.00590726f, -0.04407071f, 0.00529873f, -0.05123049f, 0.01138291f, 0.00312540f, 0.03909830f, 
    0.03426277f, -0.06252734f, -0.05048843f, 0.01692721f, 0.03739412f, 0.03448214f, -0.03828018f, 0.00520735f, 
    0.04254717f, -0.03033587f, -0.04060288f, -0.06587206f, -0.05563339f, 0.04957031f, -0.06614459f, -0.05333355f, 
    -0.04705825f, 0.02241594f, -0.06692466f, 0.02105675f, -0.05151395f, 0.03980752f, 0.04424500f, -0.05701444f, 
    -0.06264482f, -0.05337261f, 0.04247212f, -0.04620235f, 0.02443670f, 0.01933465f, -0.01577456f, 0.02187174f, 
    0.04395484f, -0.05010385f, 0.04188183f, -0.02426481f, 0.01812211f, -0.00070928f, 0.01516620f, -0.04975882f, 
    -0.01123743f, 0.03934126f, -0.03259965f, -0.06613711f, 0.01161268f, 0.02808448f, -0.03818525f, -0.04445339f, 
    0.01381583f, -0.04528698f, -0.00574070f, -0.02558800f, 0.00172283f, 0.04039429f, -0.05885585f, 0.03434309f, 
    0.04594742f, 0.00398430f, 0.00823937f, -0.06321158f, 0.01473569f, -0.02171119f, 0.03567447f, -0.01172135f, 
    0.03050160f, 0.00530408f, 0.00673507f, 0.05531377f, -0.01319972f, -0.04236770f, 0.01216373f, -0.01398177f, 
    0.04788522f, -0.03870699f, 0.05980496f, -0.03504128f, 0.02105191f, -0.05128917f, -0.00761254f, 0.00680587f, 
    0.02140232f, 0.01571017f, -0.03650087f, 0.04331079f, -0.01381984f, -0.03331669f, 0.03885801f, 0.01129345f, 
    -0.00697602f, 0.01567317f, -0.00372356f, 0.02455285f, 0.00674291f, -0.02133053f, -0.02889865f, -0.01396018f, 
    0.05918245f, -0.02482986f, 0.01401899f, 0.04192193f, 0.00389255f, 0.01483443f, -0.02844600f, 0.03649524f, 
    -0.00389062f, 0.00375686f, 0.02185003f, -0.00816646f, -0.03241036f, -0.03750650f, -0.03489047f, -0.02129264f, 
    0.05147942f, -0.03905528f, -0.06251921f, -0.06047301f, -0.00873228f, 0.00804100f, 0.00834244f, 0.00045513f, 
    -0.05458410f, -0.04739185f, -0.03047964f, 0.01026681f, -0.00154260f, -0.02538103f, -0.03890868f, -0.00612904f, 
    -0.02560899f, -0.06249750f, 0.04905377f, -0.01001007f, 0.03731077f, 0.01282636f, -0.02559100f, -0.04809299f, 
    0.00735656f, 0.04162751f, -0.03617371f, -0.00291476f, -0.03514780f, 0.00386807f, 0.01690718f, 0.01489891f, 
    -0.07079986f, 0.03973140f, -0.06538289f, 0.01898234f, -0.00997533f, -0.02145817f, -0.05282265f, -0.00154570f, 
    0.02902823f, 0.04074450f, -0.04609393f, -0.00485815f, -0.02693313f, -0.05726091f, -0.03966281f, 0.01579987f, 
    0.13766651f, 0.00650519f, 0.17882119f, 0.09888902f, 0.01655938f, 0.08059289f, 0.19277652f, 0.14436349f, 
    0.05483500f, -0.11741210f, -0.45548233f, 0.35568821f, -0.00498791f, 0.09332239f, 0.16507208f, 0.14445370f, 
    -0.21884474f, 0.21918213f, -0.07220878f, -0.10087071f, -0.05437121f, 0.12533624f, -0.00678459f, -0.03749268f, 
    -0.20257981f, -0.23075636f, 0.13386336f, -0.11202160f, 0.17163745f, 0.22462779f, -0.03905085f, -0.03447522f, 
    -0.03282966f, 0.10945596f, 0.02080764f, -0.11202037f, -0.07396329f, -0.13913335f, 0.10743780f, -0.03908540f, 
    -0.02915506f, 0.07697079f, -0.13832878f, -0.02506247f, -0.01790449f, -0.07657780f, -0.10507651f, 0.11371998f, 
    -0.08109123f, -0.10878754f, -0.03517032f, 0.16921702f, 0.00274680f, 0.09061836f, -0.63104808f, 0.38948062f, 
    0.36443031f, 0.20282359f, 0.21702789f, -0.13117132f, -0.10499681f, 0.09456517f, -0.02841732f, -0.16859008f, 
    -0.10973402f, -0.08086754f, -0.13319340f, -0.12930883f, -0.06798100f, 0.04829027f, -0.04002733f, 0.02819808f, 
    -0.11172051f, 0.23066658f, 0.16348451f, 0.00854232f, -0.13899663f, 0.08448174f, 0.10803758f, -0.27297050f, 
    -0.08021846f, -0.05131653f, 0.07347204f, 0.20747687f, 0.13175134f, 0.06122942f, 0.11911774f, -0.09507997f, 
    0.12059464f, 0.11851139f, -0.18994306f, 0.06061320f, -0.14947702f, 0.10211217f, 0.11902569f, 0.15953043f, 
    -0.01958280f, 0.00987236f, 0.02012431f, 0.10761686f, -0.06027499f, -0.05518856f, 0.03296162f, 0.12065390f, 
    0.25767466f, 0.07036158f, 0.03174631f, -0.00249827f, -0.07057516f, -0.24409385f, -0.03161053f, -0.11244418f, 
    -0.05898001f, 0.12649326f, 0.02878271f, -0.08617562f, -0.12125257f, -0.34837374f, -0.34379479f, 0.17954126f, 
    0.04879120f, -0.11931131f, -0.06879680f, 0.14657922f, -0.05505088f, 0.11535506f, -0.39450082f, 0.00969627f, 
    0.10002540f, -0.10064262f, 0.05270617f, -0.09812313f, 0.06520353f, -0.18358631f, 0.03723889f, -0.10743276f, 
    -0.13031825f, 0.23025388f, 0.03858280f, -0.23084112f, 0.03360893f, 0.38055012f, -0.03192221f, 0.31272238f, 
    -0.22638702f, 0.14871393f, -0.07618114f, 0.07213521f, -0.43181753f, 0.00115099f, -0.07031627f, 0.30440181f, 
    -0.00664664f, -0.03618488f, -0.08490856f, 0.13936591f, -0.04176884f, 0.00939701f, 0.03948213f, -0.08821879f, 
    0.01007032f, -0.03386333f, -0.77087647f, -0.16253643f, -0.43656585f, -0.11948722f, -0.28668731f, -0.17799181f, 
    0.12274630f, -0.10448790f, -0.02481047f, 0.21290344f, 0.49565440f, 0.03289662f, 0.03568515f, -0.00219663f, 
    -0.09618062f, 0.09621890f, -0.10215285f, 0.01622044f, 0.04803425f, -0.07604325f, -0.03545738f, -0.04077240f, 
    0.09452315f, -0.22945255f, 0.13310079f, 0.01976906f, 0.02695446f, -0.13857353f, 0.05776913f, 0.04561424f, 
    0.15303901f, 0.09027982f, 0.01136842f, -0.02184970f, -0.05026343f, 0.01160658f, 0.25809968f, 0.07408443f, 
    -0.26382008f, 0.06154358f, -0.08035527f, -0.01151268f, 0.08888792f, 0.00703755f, -0.15129584f, -0.24929845f, 
    -0.26262215f, -0.21920265f, 0.11337589f, -0.14836252f, 0.02806606f, 0.01577215f, 0.13717364f, 0.01010668f, 
    -0.49352846f, -0.03019029f, -0.35739464f, -0.00769526f, -0.08328457f, -0.01963162f, 0.03464604f, 0.11838388f, 
    0.06271090f, 0.00647145f, -0.13304359f, -0.19331779f, -0.12272666f, -0.10256054f, -0.23982577f, 0.00395199f, 
    -0.01851103f, 0.16553649f, 0.05467092f, -0.15059039f, 0.04340593f, 0.04051936f, 0.05477536f, 0.01740585f, 
    -0.08750250f, 0.13853942f, 0.09847012f, -0.54319578f, 0.27958250f, -0.17679831f, -0.01878987f, -0.28800270f, 
    0.33205923f, 0.02648062f, 0.19905946f, -0.22807653f, 0.13543019f, -0.07302857f, -0.51745194f, 0.17171599f, 
    0.12046776f, -0.10995126f, 0.10520738f, -0.09980604f, -0.01143976f, -0.15248941f, -0.14873770f, 0.37275884f, 
    -0.21095787f, -0.06224173f, 0.14186543f, -0.03646235f, 0.01040920f, -0.03793602f, -0.01657415f, 0.47031081f, 
    0.58270258f, -0.20093536f, 0.03763615f, -0.17924441f, 0.04698898f, -0.05727845f, -0.17403425f, 0.07045676f, 
    -0.06604800f, 0.22075903f, 0.17544389f, 0.10948992f, 0.08223361f, 0.03870352f, -0.02140613f, -0.06167659f, 
    0.10112795f, 0.12668478f, 0.22492772f, 0.16693474f, 0.06068708f, 0.10352112f, 0.01685259f, 0.03123187f, 
    0.15861715f, 0.16302997f, 0.57733613f, 0.25608617f, 0.12423483f, 0.00993900f, 0.03926162f, -0.00171330f, 
    0.00426443f, 0.19398011f, -0.25268790f, -0.01970827f, -0.03629828f, -0.03343821f, -0.13819742f, -0.15437011f, 
    0.12768482f, 0.11938454f, 0.02890981f, -0.14383747f, -0.15043083f, -0.17017706f, -0.15048754f, 0.02043928f, 
    -0.04885161f, 0.01313555f, 0.17052220f, 0.11636259f, 0.10039711f, -0.06585543f, 0.06273564f, 0.06301431f, 
    -0.04760478f, -0.15530038f, -0.17995013f, -0.13406821f, -0.16503461f, -0.08597673f, 0.08562730f, -0.04939496f, 
    -0.02635482f, -0.05272242f, -0.01698137f, -0.02009961f, -0.02520836f, -0.20614280f, -0.55733931f, 0.26724422f, 
    0.30007234f, -0.23115541f, 0.23909998f, 0.02827184f, -0.18483998f, -0.00559912f, -0.03386934f, -0.10149407f, 
    -0.14973052f, 0.09314142f, 0.01363287f, -0.05940774f, -0.12251996f, 0.13939814f, -0.06226814f, -0.08438303f, 
    -0.19236739f, 0.01810937f, 0.05773345f, 0.05544984f, -0.02165754f, -0.09477196f, 0.13156618f, 0.08370733f, 
    0.32873082f, -0.26116171f, -0.03590293f, 0.04713134f, 0.02615530f, 0.00727891f, 0.02325871f, 0.07180629f, 
    -0.08073187f, 0.04716255f, -0.02633449f, -0.82378465f, 0.04581428f, 0.06752827f, 0.11398993f, 0.16000533f, 
    0.00107714f, 0.06744805f, -0.11981119f, -0.03245943f, 0.16451496f, -0.04811217f, -0.20014428f, 0.19452126f, 
    0.14554773f, 0.07841396f, 0.03808092f, 0.19944493f, 0.04267204f, 0.16039008f, -0.26702178f, -0.23291001f, 
    0.17264408f, 0.02759589f, -0.03498974f, 0.19911271f, 0.12258454f, -0.21138488f, -0.20606591f, -0.26635167f, 
    -0.25597981f, 0.03034963f, -0.11397993f, 0.05459141f, 0.03155879f, -0.00665420f, 0.43522143f, -0.01277677f, 
    -0.01285793f, 0.03378352f, 0.05363157f, 0.08608077f, -0.07328216f, 0.04542682f, -0.05551546f, -0.01697659f, 
    0.25550550f, 0.36078659f, 0.25232330f, -0.15269478f, 0.04718973f, 0.40198323f, 0.06468913f, 0.06887307f, 
    -0.21876973f, -0.07098325f, -0.18540797f, -0.04909732f, -0.19938880f, -0.03534589f, 0.08719768f, -0.12968981f, 
    -0.07855322f, 0.03588695f, -0.04683010f, 0.02847724f, 0.05386748f, -0.02730222f, -0.04567242f, -0.16966566f, 
    -0.04498332f, -0.04226380f, -0.08187468f, -0.21066318f, 0.18655650f, -0.26994312f, -0.04219080f, -0.23946390f, 
    -0.07054042f, 0.00015805f, -0.09485689f, -0.32144877f, 0.44328684f, 0.33325630f, 0.09446211f, 0.17418832f, 
    -0.08818541f, 0.05029392f, 0.13957439f, 0.18662003f, 0.36029872f, 0.20034888f, -0.00218865f, 0.19492783f, 
    0.22483298f, 0.21205632f, 0.00245078f, 0.04692997f, 0.05052394f, 0.08817952f, -0.07483894f, 0.21186823f, 
    0.06874278f, 0.23842326f, -0.02079968f, 0.17736587f, 0.17018059f, 0.06368055f, 0.23873560f, 0.09822126f, 
    0.06101300f, 0.07067298f, 0.05390157f, 0.11113799f, -0.03696699f, -0.21797994f, 0.43076944f, -0.92767876f, 
    -0.31236356f, -0.18027018f, 0.05270788f, 0.13812084f, 0.17591944f, 0.14697492f, 0.14201325f, -0.07650275f, 
    0.20129958f, -0.07579488f, -0.19865340f, 0.16191640f, -0.10845242f, 0.09978720f, 0.10086188f, 0.07203114f, 
    -0.02925136f, 0.01377696f, 0.02394975f, -0.41298550f, -0.17244369f, -0.17049816f, -0.05917508f, -0.07483771f, 
    -0.11238224f, -0.17214261f, -0.01528659f, 0.07312810f, 0.24044812f, 0.04601201f, -0.05341874f, -0.11504932f, 
    -0.07130016f, -0.05827535f, 0.04561748f, -0.91351378f, -0.23565261f, -0.29119271f, 0.35086319f, -0.37490097f, 
    0.47789305f, 0.19295183f, 0.12556306f, 0.47961259f, -0.01080660f, -0.24604289f, -0.66056573f, 0.03680984f, 
    0.11005006f, 0.13670500f, -0.00897218f, 0.14985353f, 0.14147332f, 0.02901001f, -0.44928607f, -0.05010977f, 
    0.20491840f, -0.10794874f, -0.01954275f, 0.23124783f, -0.22611029f, 0.11712664f, -0.18715790f, 0.17298532f, 
    0.25261137f, -0.10613406f, -0.11311860f, 0.00121271f, -0.13621326f, 0.01102877f, 0.28023687f, 0.18982409f, 
    0.23686661f, 0.13628516f, 0.09625732f, 0.10116547f, 0.17692031f, -0.06396195f, 0.09973013f, 0.19840518f, 
    0.01567093f, 0.04339699f, -0.00329783f, 0.00277504f, -0.03656103f, -0.01017086f, 0.03060704f, -0.01354028f, 
    -0.02076810f, 0.02091510f, 0.03631940f, 0.04538929f, 0.03255978f, 0.03724503f, -0.05425444f, 0.03171230f, 
    -0.05313597f, 0.04237006f, 0.02744010f, 0.01172836f, 0.03724463f, -0.04971008f, -0.02562765f, 0.00724318f, 
    -0.04411594f, 0.04479855f, -0.05250890f, -0.00125776f, -0.04433145f, -0.04305831f, -0.02179066f, -0.03044126f, 
    -0.05296189f, 0.05305016f, -0.02846935f, -0.00672465f, -0.01244930f, -0.01057585f, 0.00182419f, -0.02264334f, 
    -0.04629502f, -0.06052889f, 0.00345609f, -0.03982891f, -0.04040458f, -0.02545623f, -0.02599992f, 0.01984400f, 
    -0.00066198f, -0.01923221f, 0.00395784f, -0.03225910f, -0.02249055f, -0.00594268f, 0.01179887f, 0.00746786f, 
    -0.06371011f, 0.01558488f, -0.02502826f, -0.05051664f, 0.01603249f, -0.03439788f, 0.02487894f, -0.05828443f, 
    -0.03388312f, -0.02064538f, -0.01732656f, -0.04263719f, -0.05323693f, -0.05673437f, 0.02658303f, 0.04702524f, 
    -0.05887325f, -0.00803744f, 0.01459303f, -0.00720473f, -0.06069534f, -0.03217610f, -0.05754188f, 0.03563347f, 
    0.02764361f, 0.01184270f, -0.05383217f, -0.00222919f, 0.03389833f, 0.04958057f, 0.04687888f, -0.00491528f, 
    0.01052815f, -0.02862908f, -0.03690229f, -0.01184715f, -0.00845829f, 0.02184095f, 0.04540604f, -0.01533931f, 
    -0.00939315f, -0.01589157f, -0.01615393f, -0.02517794f, -0.04801593f, -0.01106864f, 0.00640819f, 0.04191154f, 
    -0.00535276f, -0.04828675f, 0.04788094f, -0.00574735f, -0.05740856f, 0.00117272f, 0.00137743f, -0.00209659f, 
    -0.03097272f, -0.04690343f, -0.03609787f, -0.01129243f, -0.00405813f, 0.00492795f, 0.04054130f, -0.00505463f, 
    0.00523804f, 0.02794009f, 0.04058434f, -0.03918490f, 0.02682566f, 0.05236049f, -0.03534763f, 0.01670370f, 
    0.02755194f, 0.00678505f, 0.01084965f, -0.00881001f, 0.04373907f, 0.02339601f, -0.04930446f, -0.06507265f, 
    -0.06385421f, 0.01354458f, -0.06409041f, 0.04718088f, 0.04891296f, -0.04574236f, 0.02826615f, -0.04989553f, 
    -0.02589701f, 0.04272395f, 0.00450503f, 0.04445171f, -0.05515328f, -0.02013138f, -0.03738908f, 0.02117340f, 
    -0.01201170f, -0.00514812f, -0.00425488f, -0.04630396f, -0.01529092f, -0.00924830f, 0.01200349f, -0.06172236f, 
    0.04142473f, -0.05615136f, 0.02119892f, 0.01671729f, 0.03321213f, 0.02903396f, 0.00885756f, 0.00089121f, 
    -0.04328808f, -0.06152412f, 0.04839063f, -0.03314357f, 0.03813185f, 0.02854105f, 0.04401454f, -0.01546391f, 
    -0.02546824f, 0.04363647f, -0.06452459f, -0.04302784f, 0.02262435f, -0.04843666f, -0.02063746f, -0.03682232f, 
    0.02059290f, 0.04816395f, 0.02986526f, -0.00115119f, -0.00692094f, -0.00538767f, 0.03177691f, -0.01851176f, 
    -0.05852325f, 0.00347013f, -0.04403535f, 0.01885223f, -0.06171316f, -0.00250284f, -0.05832822f, 0.02032982f, 
    -0.00392007f, -0.00966572f, 0.05537302f, -0.04445229f, 0.03042972f, -0.00443933f, -0.03224558f, -0.06246710f, 
    -0.06429163f, -0.01912989f, -0.02917281f, -0.03656809f, -0.02883266f, -0.05282106f, -0.05661406f, 0.01061529f, 
    -0.02347295f, -0.02009116f, -0.02177350f, 0.02845220f, 0.00017707f, -0.05758294f, -0.03222534f, 0.02083174f, 
    -0.00721414f, -0.00894552f, -0.02573597f, 0.02738313f, 0.00790964f, 0.02100550f, 0.00079532f, -0.00777817f, 
    -0.02760931f, 0.00974130f, -0.00456388f, 0.00525921f, 0.01556743f, 0.02865326f, -0.00245530f, -0.01815459f, 
    -0.04222215f, -0.04265408f, 0.04761526f, -0.02714135f, -0.05342570f, -0.02672613f, -0.02271220f, -0.05282869f, 
    0.01939719f, -0.02931040f, 0.04525721f, -0.00875263f, 0.01141261f, -0.01581226f, -0.06419053f, -0.00136697f, 
    -0.00053064f, -0.01150939f, -0.03580265f, -0.02819693f, -0.03532690f, 0.00411423f, -0.00970348f, -0.05022864f, 
    -0.03291438f, -0.00573563f, -0.00717875f, -0.02828948f, 0.00140146f, -0.03580588f, -0.05614762f, -0.03909573f, 
    0.00385545f, -0.05313168f, -0.00927105f, -0.01414863f, -0.04156061f, 0.03249755f, -0.02917771f, -0.01059540f, 
    -0.02618420f, 0.02718132f, -0.02299372f, 0.00294982f, -0.04733848f, -0.05363280f, -0.00949144f, 0.01235409f, 
    -0.04269704f, -0.03675167f, -0.10939841f, 0.10408246f, 0.09101836f, -0.05539879f, 0.09661599f, 0.13442510f, 
    0.00809507f, 0.56324196f, 0.11129697f, -0.23866743f, -0.04886465f, 0.26626751f, -0.06574742f, 0.25615451f, 
    0.35090345f, 0.00174577f, 0.22589850f, 0.09506468f, -0.32752016f, 0.10139787f, 0.18970324f, 0.02268023f, 
    0.10209474f, 0.06044908f, -0.17683502f, 0.21679911f, -0.02194350f, 0.20877983f, 0.02287103f, -0.04913662f, 
    0.15197372f, 0.01250669f, 0.13953629f, 0.22129963f, -0.05505375f, 0.06209455f, -0.06182792f, 0.00092913f, 
    0.05015029f, 0.08401677f, -0.02422250f, -0.02064502f, 0.00245810f, -0.07308071f, -0.00171262f, -0.05594280f, 
    0.03798500f, 0.05682294f, -0.13002498f, -0.09528869f, -0.53032291f, -0.36403167f, 0.10502570f, -0.93783194f, 
    -0.02760552f, 0.00429656f, 0.11507257f, 0.02019558f, 0.21491563f, 0.03833799f, 0.15466303f, -0.12959324f, 
    0.15476513f, -0.28585890f, -0.02784166f, -0.06050865f, 0.15016523f, 0.00723217f, 0.09749707f, -0.03560089f, 
    -0.28630993f, -0.22345388f, -0.09590659f, 0.16411684f, 0.24290290f, 0.09189193f, -0.05697278f, 0.11099990f, 
    0.13268721f, -0.02503982f, -0.06918292f, -0.06383945f, 0.02787669f, 0.14501224f, 0.03111066f, -0.19421026f, 
    -0.65789109f, -0.54818559f, 0.08280119f, 0.48664373f, 0.15296191f, -0.01655493f, -0.01316347f, 0.09224792f, 
    0.02046711f, 0.06083383f, -0.12993051f, 0.18357830f, -0.07917122f, 0.02650640f, 0.08202217f, -0.00108468f, 
    0.02596969f, -0.00459950f, -0.04620421f, -0.00367817f, -0.05284335f, -0.00861540f, 0.22695023f, 0.07808997f, 
    0.06752352f, 0.24313217f, 0.06060165f, 0.13081630f, 0.13790967f, 0.11394609f, 0.09370416f, -0.05452581f, 
    0.26979551f, 0.04126546f, 0.17211118f, -0.06483524f, -0.02873093f, -0.12696269f, 0.10912347f, 0.29186603f, 
    -0.26967621f, -0.16920784f, 0.03023917f, -0.14525731f, 0.13364930f, 0.04186154f, -0.15014046f, 0.04764092f, 
    -0.23377466f, -0.20283526f, 0.16515976f, 0.09264411f, -0.06398800f, 0.00882171f, 0.04845855f, -0.08385574f, 
    -0.01444557f, 0.17937003f, 0.05150159f, 0.27799478f, -0.05231453f, -0.31547818f, -0.16624200f, -0.14951766f, 
    -0.14163819f, -0.15051252f, -0.03439820f, -0.04947927f, 0.09126762f, 0.05701103f, 0.06004529f, -0.48170710f, 
    -0.26335484f, -0.03145953f, 0.02160507f, -0.16973689f, -0.17506167f, 0.36624926f, 0.12777005f, 0.16061972f, 
    -0.03165988f, -0.07025060f, 0.01822602f, -0.14643948f, -0.44140816f, 0.03659316f, 0.14591168f, 0.08392134f, 
    0.21880648f, -0.11262873f, 0.51894110f, 0.15408337f, -0.22759360f, 0.04424858f, 0.04815490f, 0.11384258f, 
    -0.01532938f, -0.29103523f, -0.09542542f, -0.36512670f, -0.23823366f, 0.05393562f, 0.25706512f, 0.11517697f, 
    -0.11602221f, -0.06378199f, 0.04173722f, -0.06582082f, 0.14854610f, -0.09835146f, -0.64326292f, 0.18385345f, 
    0.04462369f, -0.10109660f, 0.01295125f, 0.09505288f, -0.00564418f, 0.13013621f, -0.06846840f, 0.44967815f, 
    0.18160176f, -0.29223019f, 0.21618406f, 0.14761196f, -0.03380074f, -0.13525294f, 0.02919045f, 0.05414821f, 
    0.07957616f, 0.26144749f, -0.16898644f, -0.01480656f, -0.05455951f, 0.02200224f, -0.00047374f, 0.04468134f, 
    -0.07855289f, -0.04412515f, 0.00937194f, 0.00318077f, 0.05698689f, 0.03623370f, -0.11967253f, -0.33674839f, 
    -0.28281307f, -0.26900905f, 0.12905848f, 0.28934005f, -0.13348798f, 0.01778618f, 0.07291865f, 0.00400379f, 
    0.12341358f, 0.03250593f, -0.03952269f, 0.35760152f, 0.38804933f, -0.17112394f, -0.02126289f, 0.09638002f, 
    -0.14867271f, 0.39513966f, 0.07317553f, 0.00620391f, -0.03361902f, 0.28132465f, -0.00626476f, 0.26785180f, 
    0.04063978f, 0.11856306f, -0.01718574f, -0.01528312f, -0.09552601f, -0.17007701f, 0.03352942f, 0.04328351f, 
    -0.12869272f, 0.11229935f, 0.19040076f, -0.20643303f, 0.14172095f, -0.07580540f, 0.13277106f, -0.13956167f, 
    -0.05599349f, 0.06957803f, 0.21176159f, 0.29674205f, 0.07297057f, 0.08947910f, 0.22722603f, -0.00313883f, 
    0.04730061f, -0.04895427f, -0.00708142f, 0.06396508f, -0.13669312f, 0.06829873f, -0.05505003f, -0.18789977f, 
    -0.02820772f, -0.34078178f, -0.31592381f, 0.10496031f, -0.15604451f, 0.14041978f, 0.22908777f, 0.18868116f, 
    0.22498475f, 0.72352844f, -0.13719770f, -0.26202226f, 0.18752548f, 0.29417875f, 0.20874934f, -0.04696638f, 
    0.10656891f, 0.11376746f, -0.12889555f, 0.16284576f, -0.20884271f, -0.10371085f, -0.20739590f, -0.01795490f, 
    -0.28616434f, -0.04710072f, -0.01160101f, -0.25320333f, -0.02152689f, 0.04704691f, -0.06283686f, 0.02628204f, 
    0.12747560f, -0.01412204f, 0.24438065f, 0.13360152f, -0.00412701f, 0.02237111f, -0.08384337f, -0.32139167f, 
    -0.15870953f, -0.25629282f, -0.10255827f, 0.02422267f, -0.04100157f, 0.24539930f, -0.29574668f, -0.30268288f, 
    -0.05545246f, 0.02752679f, -0.03932608f, 0.29288888f, -0.09155212f, 0.08631103f, -0.66454637f, 0.09886490f, 
    0.37838033f, -0.02963944f, 0.17456183f, -0.13337921f, -0.01589676f, -0.00769536f, 0.17356537f, -0.09089483f, 
    -0.12118875f, -0.26523396f, 0.15879235f, -0.39644051f, -0.43580678f, -0.23390090f, 0.18082798f, 0.09724307f, 
    -0.32757801f, -0.09273432f, 0.01855158f, -0.07211878f, 0.08335248f, 0.01033094f, 0.03588583f, -0.01303942f, 
    0.01057502f, 0.22081468f, 0.26066458f, 0.01294147f, -0.09409552f, -0.10911264f, -0.02960348f, 0.12777096f, 
    0.13161732f, 0.17682382f, 0.18521813f, -0.46329027f, -0.18112354f, -0.19801664f, 0.10665613f, -0.23521410f, 
    -0.01621508f, -0.04932938f, -0.14813092f, 0.22582093f, -0.21976723f, 0.11551283f, -0.09040169f, 0.12468773f, 
    0.17858261f, 0.11479177f, 0.13097921f, 0.22233585f, 0.43007433f, -0.33211255f, 0.01773223f, -0.03964446f, 
    -0.13732925f, 0.10990867f, 0.08976286f, 0.02626306f, -0.05171863f, -0.11041080f, -0.11853746f, 0.17618950f, 
    -0.13393763f, -0.15620904f, -0.10319304f, 0.00798487f, -0.04584464f, 0.19130406f, -0.24081995f, -0.74568313f, 
    -0.42790478f, -0.32289970f, -0.14747876f, -0.14878957f, 0.04888406f, -0.06688734f, -0.02682967f, 0.24002638f, 
    -0.18247992f, 0.08202589f, -0.13922663f, -0.04717405f, -0.08789694f, 0.17222139f, 0.04955087f, 0.31691518f, 
    0.31256214f, -0.10527482f, -0.51187557f, -0.15949874f, -0.18154606f, -0.07752401f, 0.09865790f, -0.13669482f, 
    -0.13030590f, 0.13438275f, -0.28965607f, -0.36105737f, -0.36734655f, -0.38487652f, -0.06038177f, 0.18845777f, 
    0.26011959f, 0.10111392f, -0.25954276f, -0.21338587f, 0.06274682f, -0.09915435f, -0.16402665f, -0.30662087f, 
    -0.28579971f, -0.07971700f, 0.10124057f, -0.39881214f, 0.37621316f, 0.66211009f, -0.15761696f, -0.00116215f, 
    0.05574571f, 0.11315855f, 0.04932264f, 0.14112456f, 0.00799825f, -0.05070088f, -0.02552452f, -0.08842160f, 
    -0.02207419f, 0.02369236f, 0.05747296f, 0.09219217f, -0.07189219f, -0.21436447f, -0.00801895f, 0.00332075f, 
    -0.22389662f, 0.11929569f, -0.01027264f, 0.25644165f, 0.00520995f, 0.02781413f, 0.44077021f, 0.29282609f, 
    -0.10088479f, 0.20689255f, -0.14006551f, -0.15778032f, 0.09902069f, 0.08361512f, 0.25003153f, -0.03067542f, 
    -0.11976821f, 0.34891143f, 0.11084244f, 0.08368732f, -0.33504638f, 0.19584765f, 0.17061281f, 0.14247662f, 
    -0.04007182f, -0.43272883f, -0.04188068f, -0.32221082f, -0.01295760f, -0.36001101f, 0.12259427f, -0.00224310f, 
    0.43800190f, -0.30493963f, -0.18181913f, 0.00046861f, -0.32010585f, -0.11844954f, -0.30436754f, -0.04766994f, 
    -0.11354768f, 0.16191076f, -0.04909587f, -0.14108124f, 0.04474649f, -0.08354669f, -0.28205958f, -0.18022515f, 
    0.06479004f, -0.11815406f, 0.24805377f, 1.29787886f, 0.06115551f, -0.57860625f, -0.23204459f, 0.08442444f, 
    0.30817097f, 0.11035463f, -0.02874015f, 0.07748924f, -0.19446947f, -0.00628060f, 0.26006830f, -0.12573901f, 
    0.14273679f, -0.25920033f, -0.01134123f, 0.15930963f, -0.06781986f, -0.20319352f, -0.68731904f, 0.86420107f, 
    0.09805362f, 0.07590853f, -0.46407443f, -0.08850623f, -0.18107089f, 0.28318718f, -0.40018421f, 0.10624281f, 
    0.26005939f, -0.03173026f, 0.08037896f, 0.03014609f, -0.08831317f, 0.07412232f, 0.23599890f, 0.35175556f, 
    0.00348234f, -0.41906160f, 0.18595554f, -0.08800981f, 0.46650389f, 0.36637065f, 0.12824756f, 0.15188417f, 
    0.04677204f, -0.00200750f, 0.04968283f, 0.03304635f, -0.02524269f, 0.01486367f, -0.01974985f, 0.02530928f, 
    -0.00518710f, 0.00730430f, -0.03470831f, -0.03202531f, -0.00981091f, -0.02117042f, -0.00597504f, -0.02967546f, 
    0.02939939f, -0.06044214f, -0.05690565f, 0.03278720f, -0.00827399f, 0.00831488f, -0.03374023f, 0.02661987f, 
    0.03693300f, 0.02450581f, 0.00294888f, -0.02678809f, -0.02362839f, -0.01857058f, -0.01730171f, 0.04039954f, 
    -0.05675691f, -0.03635857f, -0.04320537f, 0.01123813f, -0.05337777f, 0.04273880f, -0.01387646f, 0.03336576f, 
    -0.02938909f, -0.04716172f, -0.03177320f, -0.05681003f, 0.00058239f, 0.03962814f, -0.02284992f, 0.00627959f, 
    0.00689089f, -0.01766870f, 0.04156069f, 0.03928092f, 0.03431241f, 0.03283325f, -0.06356817f, 0.00159421f, 
    -0.03203863f, 0.00564464f, 0.03839247f, -0.04568367f, 0.02058844f, 0.00765639f, -0.01532685f, -0.03777700f, 
    -0.02396970f, 0.01017030f, 0.02830534f, -0.06416647f, -0.03932132f, -0.03883594f, -0.05170403f, -0.03877789f, 
    -0.02590802f, -0.04185757f, -0.05428435f, 0.02841842f, -0.03287335f, 0.04170459f, 0.04832806f, -0.06311598f, 
    -0.04765983f, -0.01388104f, 0.04596934f, -0.05379042f, -0.04670148f, -0.01938666f, -0.03954772f, -0.00318342f, 
    -0.02152961f, -0.05597243f, -0.01231117f, -0.02166582f, -0.04599944f, 0.03775359f, -0.06423965f, -0.02648619f, 
    0.01330271f, 0.03510254f, -0.04969694f, -0.01255194f, 0.01138753f, 0.02318619f, 0.03947473f, -0.00054860f, 
    -0.06090232f, -0.00979476f, -0.03421262f, 0.00780943f, 0.03899810f, 0.04904924f, -0.01723461f, 0.01007940f, 
    -0.02881678f, -0.01128144f, 0.00895458f, -0.03909027f, 0.03983978f, 0.00964102f, -0.05666082f, 0.03135038f, 
    -0.01118735f, -0.02672139f, 0.00536005f, -0.02659299f, 0.01413878f, -0.04167672f, 0.00964664f, -0.02631691f, 
    -0.01220050f, 0.00366006f, -0.04911096f, -0.03020498f, -0.04982363f, -0.03441755f, -0.05860623f, -0.02423287f, 
    0.03083146f, 0.05110357f, 0.04237571f, -0.02394217f, 0.02191468f, -0.00416888f, -0.04428386f, 0.05124352f, 
    -0.02466625f, 0.02428179f, -0.02096408f, 0.01281004f, 0.00900658f, -0.04869240f, 0.03277539f, 0.03880763f, 
    0.00611412f, 0.04130696f, 0.04253097f, -0.01477336f, 0.01832132f, -0.03033065f, -0.05501428f, 0.00407589f, 
    0.03106700f, -0.04472758f, 0.01553569f, -0.02960396f, 0.04810944f, -0.04088674f, 0.04387026f, 0.00698726f, 
    0.03905919f, 0.04748420f, -0.05407918f, 0.03622022f, -0.01223888f, 0.00350364f, 0.02394392f, 0.01057223f, 
    -0.03202900f, 0.00090923f, -0.00012438f, -0.02751037f, 0.01155618f, -0.04686777f, 0.02032186f, 0.00726198f, 
    -0.06035351f, -0.03041438f, 0.04063250f, -0.04086369f, 0.02899829f, 0.05053390f, -0.05696341f, -0.01598428f, 
    0.04483040f, -0.01119974f, 0.03591763f, -0.05041395f, 0.05269809f, -0.04814585f, 0.04677500f, 0.02063332f, 
    0.01081591f, -0.05316007f, -0.02826113f, -0.05793040f, -0.04876572f, -0.04380753f, 0.02726241f, -0.04812566f, 
    -0.01402927f, -0.05891494f, 0.05558179f, -0.01210481f, -0.04877783f, -0.05929045f, -0.01964538f, -0.02188080f, 
    -0.00205857f, 0.00304055f, 0.02643469f, 0.03542038f, 0.04531935f, 0.03017694f, -0.04440556f, 0.04515275f, 
    -0.00308153f, 0.02578028f, -0.00382948f, 0.04150912f, -0.03410097f, 0.00428408f, 0.03558979f, 0.04905631f, 
    -0.04592443f, -0.02530442f, -0.04742740f, -0.05104950f, 0.00590325f, 0.01826815f, -0.03383159f, 0.03304272f, 
    0.02680891f, -0.02070954f, -0.04616268f, 0.04511226f, -0.00987755f, 0.00266774f, 0.04534685f, 0.01311906f, 
    0.02482533f, -0.01897435f, -0.02631553f, -0.04139660f, -0.06269454f, -0.00782329f, -0.01481937f, -0.01130471f, 
    -0.00293103f, 0.03352353f, -0.05643357f, 0.00885400f, -0.06104077f, 0.04201869f, 0.01622151f, 0.01643014f, 
    -0.05519355f, -0.01374082f, -0.03842762f, -0.05669147f, -0.00934156f, -0.05498248f, -0.00643743f, 0.04678449f, 
    0.03488332f, -0.00847535f, -0.05055456f, -0.02790543f, -0.01239030f, -0.03419701f, 0.02563111f, -0.04470763f, 
    -0.00025023f, -0.02024915f, -0.06401207f, 0.00487004f, -0.02014350f, 0.04181532f, -0.01249022f, -0.06146957f, 
    0.21997041f, 0.01982485f, -0.03696498f, -0.00959887f, 0.06367143f, -0.02715563f, -0.19364707f, -0.00209628f, 
    -0.01916146f, 0.18463007f, 0.09398805f, -0.08888453f, -0.00005116f, 0.05661840f, -0.15674342f, -0.18155700f, 
    0.16617185f, 0.05867566f, -0.01659775f, 0.07787821f, 0.05533789f, 0.14008203f, 0.04780991f, -0.15683003f, 
    -0.16540141f, -0.05413660f, -0.06997595f, -0.14979059f, -0.08815275f, -0.23545931f, -0.04303557f, -0.12777753f, 
    -0.10960863f, 0.05699610f, 0.17118442f, -0.04050324f, 0.13442925f, 0.08877692f, 0.10450803f, -0.09475002f, 
    -0.21296267f, -0.11325725f, -0.06379786f, -0.26811129f, -0.15613399f, -0.07722238f, -0.05229836f, 0.16948712f, 
    -0.13504282f, -0.02431057f, 0.04984408f, 0.12655346f, 0.27983075f, 0.22994602f, 0.39734030f, 0.34140918f, 
    -0.10488183f, -0.15767375f, -0.09543838f, -0.19744113f, -0.00353263f, 0.05581708f, -0.04104711f, 0.25056773f, 
    -0.05366474f, 0.26367158f, -0.08514459f, -0.17890413f, -0.10203769f, -0.09800838f, -0.09057944f, 0.06100862f, 
    -0.27498680f, 0.21760204f, 0.03283380f, 0.02370319f, -0.01542571f, -0.08544682f, -0.14008366f, -0.34162152f, 
    0.06921693f, 0.15163186f, 0.15314485f, -0.05323565f, -0.05317392f, 0.12399040f, 0.14529814f, 0.07794512f, 
    -0.01460919f, -0.00373877f, -0.06293058f, 0.01814052f, 0.25206187f, -0.07327798f, 0.15225917f, -0.03716674f, 
    0.13894996f, 0.04951775f, 0.10597742f, 0.00839709f, -0.04950102f, -0.12071262f, 0.13766862f, -0.05290187f, 
    -0.03917408f, -0.02365628f, 0.00252380f, -0.09417627f, 0.28108579f, -0.02743201f, -0.60206854f, 0.13007842f, 
    -0.04237742f, 0.24642241f, -0.17520088f, -0.00139335f, -0.23175721f, -0.24222490f, 0.29310530f, -0.45519620f, 
    0.14540273f, 0.03514707f, 0.17023884f, 0.05607792f, -0.05957925f, 0.06116336f, -0.11612232f, -0.18377918f, 
    0.06486336f, -0.05440366f, 0.04193708f, -0.10848467f, 0.30305755f, -0.12167408f, 0.12117644f, 0.02032939f, 
    -0.05011904f, -0.03178874f, -0.06599381f, -0.05101975f, 0.11243311f, 0.35735434f, 0.05126632f, 0.12401631f, 
    -0.17741555f, -0.09034669f, 0.17565709f, 0.05667031f, -0.02695068f, 0.08643264f, 0.04031677f, 0.06460225f, 
    0.25823966f, 0.06103656f, -0.10480850f, -0.05532366f, -0.00808265f, 0.00526175f, -0.07378472f, -0.01579062f, 
    -0.10406464f, -0.04535126f, -0.03761243f, 0.40115872f, 0.20171723f, 0.03765547f, 0.06114373f, -0.02486677f, 
    0.10008810f, -0.11753495f, -0.06281120f, 0.42228675f, -0.10069010f, -0.36761576f, -0.28917968f, 0.14082144f, 
    -0.19991659f, -0.05911246f, -0.09009805f, -0.12722643f, -0.13464539f, -0.38298663f, -0.19978362f, 0.08667304f, 
    0.02367306f, 0.04546201f, 0.32414731f, -0.18305793f, 0.24653003f, 0.05460595f, 0.04042195f, -0.02009506f, 
    -0.04836829f, -0.07429033f, -0.08509201f, -0.03999276f, 0.24765982f, 0.13036503f, 0.42882150f, 0.23059535f, 
    -0.02736684f, 0.14529262f, -0.14413154f, 0.13981064f, -0.05757254f, 0.07251652f, -0.08544701f, -0.27103642f, 
    -0.43804982f, 0.41948199f, 0.10731243f, 0.14908157f, 0.14566761f, -0.04177160f, -0.00729162f, 0.19468796f, 
    -0.24092278f, -0.22582841f, 0.39596084f, -0.04965144f, -0.06881847f, -0.02678625f, 0.08314156f, 0.03213843f, 
    0.29045352f, -0.14010882f, 0.10912053f, -0.09314821f, 0.06271558f, 0.04684253f, 0.07787152f, -0.08158014f, 
    -0.06156705f, 0.23108515f, 0.23512648f, 0.06733533f, 0.16731794f, -0.06075896f, -0.01872839f, 0.01557136f, 
    -0.07014696f, -0.14730108f, 0.00975812f, 0.27545097f, -0.31529844f, 0.08261161f, -0.03420178f, 0.16103336f, 
    0.29470706f, 0.20878460f, -0.08936438f, -0.07238176f, -0.70443517f, 0.05114865f, -0.02681868f, 0.18382181f, 
    0.05985323f, 0.01028716f, 0.06332326f, -0.12463655f, 0.15644981f, -0.07769463f, 0.08731154f, 0.20002250f, 
    -0.03412773f, 0.01873293f, -0.03654977f, 0.10721152f, -0.09962118f, 0.05220500f, -0.27784234f, 0.09374256f, 
    -0.04187405f, -0.29412445f, -0.11817021f, -0.33857977f, 0.00927077f, -0.34741649f, -0.26937768f, 0.32671413f, 
    -0.00899377f, -0.00034702f, 0.08118436f, 0.07947046f, 0.02853929f, 0.02935811f, 0.06141556f, 0.20574094f, 
    -0.01437564f, 0.15693542f, 0.21920677f, -0.05119145f, 0.15729252f, 0.04826030f, -0.02752754f, 0.02554490f, 
    0.09412339f, -0.03585006f, -0.02364685f, -0.32065001f, 0.04678632f, 0.06689564f, -0.06297916f, 0.01432212f, 
    0.20308971f, 0.09362821f, -0.18432255f, 0.00087945f, 0.06426372f, 0.00040727f, 0.11937159f, -0.03323864f, 
    0.00456453f, -0.34057802f, -0.38671130f, 0.13754410f, -0.04770216f, 0.04428460f, -0.09151424f, -0.08031344f, 
    -0.10637372f, -0.10820497f, 0.03453282f, 0.09819513f, -0.14753173f, 0.17502205f, 0.17896365f, -0.04591563f, 
    -0.05801225f, 0.05922404f, -0.04123059f, -0.08490010f, 0.11507597f, 0.15226850f, -0.03985424f, -0.01831464f, 
    0.05973756f, -0.00128784f, 0.07706235f, 0.10832974f, 0.10289025f, 0.20523338f, 0.06164687f, -0.20731992f, 
    0.40418214f, -0.00979623f, -0.12993997f, -0.03612281f, -0.02595168f, -0.05321152f, 0.01676129f, 0.00611613f, 
    0.00256487f, 0.15642881f, -0.14195411f, -0.12618661f, -0.02452300f, 0.04889318f, -0.08486229f, -0.19798017f, 
    -0.03960684f, -0.20238701f, 0.14244516f, -0.08890174f, 0.20154168f, -0.15245636f, 0.01802893f, -0.17572829f, 
    -0.19002019f, 0.22452882f, 0.11951644f, 0.11733492f, 0.22311245f, -0.06667366f, -0.26977950f, -0.00927565f, 
    -0.10716990f, 0.06953347f, -0.36236683f, 0.15707085f, 0.12418585f, 0.05509422f, 0.04609493f, -0.04255602f, 
    0.01410439f, -0.03417460f, -0.02993211f, 0.39577156f, 0.05607208f, -0.58767444f, 0.09888327f, -0.02872719f, 
    0.25434715f, -0.09143204f, 0.08783296f, -0.14709762f, -0.06890655f, -0.13536842f, -0.12829277f, 0.01935425f, 
    -0.03530655f, 0.03960866f, -0.15066886f, -0.20755479f, -0.12595138f, -0.07197187f, 0.00617825f, -0.33388850f, 
    -0.15499064f, 0.03697187f, -0.09275365f, 0.05063347f, -0.05940494f, -0.06138980f, -0.09706945f, 0.01283171f, 
    -0.05791727f, 0.10464945f, -0.02800774f, 0.09238935f, 0.11859158f, -0.12954284f, 0.32851756f, -0.01536543f, 
    -0.06218975f, 0.07669163f, -0.01839802f, -0.04485905f, -0.09717290f, 0.18873724f, 0.12591293f, 0.06244901f, 
    0.07174116f, 0.19675139f, -0.00255606f, 0.33056217f, -0.04854999f, 0.10657483f, 0.03225502f, 0.09661774f, 
    0.06321551f, -0.12751044f, 0.14318369f, 0.21267779f, 0.17251948f, -0.15853636f, -0.16327029f, -0.20763661f, 
    -0.17142080f, 0.14044406f, -0.02615089f, 0.17715994f, -0.03187025f, -0.19217087f, -0.15010123f, 0.02772311f, 
    0.04972520f, 0.01425509f, -0.24569868f, 0.08692330f, -0.33095992f, 0.13182890f, -0.12724595f, -0.05500703f, 
    -0.10217654f, -0.01747143f, -0.01722469f, -0.10143538f, -0.10253213f, 0.07825359f, -0.08100791f, 0.19695334f, 
    0.14431652f, 0.05686859f, -0.04823814f, -0.07710014f, 0.34727284f, -0.16169326f, -0.17715229f, 0.02408262f, 
    0.01929252f, 0.04841674f, 0.17327432f, 0.07353870f, 0.09991182f, 0.00938722f, -0.17629226f, 0.05766780f, 
    0.29686570f, -0.21482213f, -0.14169087f, 0.01164949f, -0.23486461f, 0.12112489f, 0.10424408f, 0.57512265f, 
    -0.08842442f, 0.13826151f, 0.08198648f, 0.18977565f, 0.08839019f, 0.10464872f, 0.15330409f, 0.06733576f, 
    -0.19619152f, -0.00281270f, -0.20473282f, 0.00159074f, -0.17446847f, 0.16828078f, -0.02177227f, 0.25175196f, 
    0.02299925f, 0.30167738f, -0.08759221f, -0.03342167f, -0.14954630f, 0.05354768f, 0.08048831f, -0.02309111f, 
    0.06069987f, 0.17571564f, -0.15261340f, -0.02204585f, 0.13715957f, -0.10619673f, 0.08040271f, -0.06847514f, 
    0.05766704f, 0.12376329f, 0.16491926f, 0.47629163f, 0.62307364f, -0.30361998f, 0.19253498f, -0.17836224f, 
    -0.33099833f, 0.09007066f, 0.06685339f, -0.05667047f, -0.02699802f, -0.19571248f, -0.37404478f, 0.14728922f, 
    0.16423981f, 0.26534459f, 0.02908643f, 0.00095150f, 0.21942839f, -0.07618220f, -0.20232823f, 0.04448377f, 
    0.13271327f, -0.02949431f, -0.07606352f, -0.01464779f, -0.16448915f, 0.10416777f, 0.10833421f, -0.10422718f, 
    0.13711312f, -0.09925524f, 0.04724091f, -0.30586696f, 0.06782786f, -0.16295177f, -0.16640450f, 0.13995303f, 
    0.11052481f, 0.13908298f, 0.08678859f, 0.01757598f, -0.09661432f, 0.01231004f, -0.06510274f, 0.12867537f, 
    0.15439044f, 0.10665155f, -0.07930401f, 0.10250419f, 0.05417623f, 0.04063845f, 0.28904042f, 0.09265169f, 
    0.28041011f, 0.05526259f, -0.15118857f, 0.03350200f, 0.26601198f, -0.05129128f, 0.09627222f, -0.12911329f, 
    0.27064437f, -0.15146098f, -0.30398229f, 0.07341529f, -0.08131099f, -0.02206059f, -0.30034995f, -0.24001220f, 
    0.05028264f, -0.14495499f, 0.23545298f, 0.32690382f, 0.11416341f, -0.04819039f, 0.07716821f, 0.05644276f, 
    0.19090745f, 0.10673545f, -0.06570186f, -0.14030986f, -0.59412181f, -0.05844389f, 0.13504188f, -0.22809194f, 
    -0.08141647f, -0.21154332f, -0.09768997f, 0.00455407f, -0.03054838f, 0.35332403f, -0.08867431f, 0.15237753f, 
    -0.18140917f, -0.01951046f, -0.11667683f, 0.19211467f, 0.14308669f, 0.22292753f, 0.05798695f, -0.31006265f, 
    -0.35251701f, -0.04816486f, 0.05298877f, 0.30610064f, -0.03819885f, 0.05494829f, 0.06036467f, -0.18161194f, 
    -0.36720657f, 0.04340610f, -0.01763062f, -0.19246197f, -0.15098198f, -0.09320045f, -0.06938481f, -0.02613833f, 
    0.34392977f, -0.11951554f, 0.14732884f, -0.06914664f, -0.02880560f, -0.32221055f, 0.10178597f, -0.22392419f, 
    -0.14640088f, 0.16011302f, -0.25429797f, -0.13463724f, 0.20911431f, -0.01761598f, -0.02348077f, 0.07405568f, 
    0.13306376f, 0.13985308f, -0.72959268f, -0.34934759f, 0.02925379f, -0.16256756f, -0.37046328f, -0.03730666f, 
    -0.12219555f, 0.06470326f, 0.14196838f, 0.43316594f, 0.02300532f, -0.28272003f, 0.19623074f, 0.04471530f, 
    0.15661854f, -0.03706775f, 0.04539310f, 0.00180475f, 0.25863430f, 0.05081471f, 0.41447997f, -0.08641321f, 
    -0.00552420f, -0.26358411f, -0.03504924f, -0.10218102f, -0.11345810f, 0.21166416f, -0.07490510f, -0.25426292f, 
    0.08859640f, 0.07874830f, -0.07158163f, 0.07254496f, 0.00358600f, 0.05265947f, -0.42143825f, -0.24174605f, 
    0.06218801f, -0.11287672f, -0.17112112f, -0.17398451f, 0.06201155f, 0.04308525f, 0.07868788f, -0.09201842f, 
    -0.22254686f, 0.01503966f, 0.04918491f, 0.01992845f, -0.21701933f, 0.28327513f, -0.00016616f, 0.17850904f, 
    0.09875820f, -0.56821138f, -0.52421516f, -0.10175604f, -0.22181651f, -0.05686881f, 0.05687118f, -0.05409575f, 
    0.02264665f, -0.31791285f, -0.44449466f, 0.00124586f, -0.30197352f, -0.04418968f, -0.14405563f, -0.00839593f, 
    0.04283802f, 0.05194137f, 0.52425814f, 0.05389636f, -0.19765644f, 0.14031130f, -0.13545664f, 0.20363715f, 
    0.01867319f, -0.05710248f, 0.04580688f, 0.34399462f, -0.00942894f, 0.01144392f, 0.00452695f, 0.10642199f, 
    -0.08838961f, 0.20281234f, -0.10024087f, 0.05631169f, 0.00322557f, 0.13917062f, 0.10895295f, -0.01395860f, 
    0.12721789f, 0.01777522f, 0.14833589f, 0.19642889f, 0.30003861f, -0.77673697f, -0.17891172f, 0.05550395f, 
    -0.10667763f, -0.01875678f, 0.22621009f, 0.12389752f, 0.14048217f, 0.08921994f, -0.18847375f, 0.07050829f, 
    0.14053240f, -0.00027788f, -0.11903278f, -0.23261048f, 0.25094301f, -0.13046966f, 0.13710807f, 0.48307034f, 
    0.42205596f, -0.23404089f, -0.10761260f, -0.06650673f, 0.13624938f, 0.01978644f, 0.20212662f, 0.26325732f, 
    -0.36222473f, -0.04000746f, -0.09647053f, -0.16401629f, -0.04878877f, -0.08564427f, -0.06549189f, 0.04460896f, 
    0.28945005f, 0.23228034f, 0.07145716f, -0.37828231f, -0.08990503f, -0.22992061f, -0.27566653f, 0.21412270f, 
    0.06011713f, 0.07841405f, -0.48192593f, -0.09983097f, 0.02043451f, -0.04748828f, -0.07447387f, -0.19391130f, 
    0.12117025f, -0.14557895f, 0.32672352f, 0.48864770f, -0.41039544f, -0.41231608f, -0.05509400f, -0.24777368f, 
    -0.30964041f, 0.06433667f, -0.03161782f, 0.00438412f, 0.08113809f, 0.08839098f, -0.20776980f, -0.20636162f, 
    -0.12706234f, 0.04623254f, 0.02432429f, 0.12381732f, 0.32385528f, 0.08775072f, -1.17750084f, -0.74912393f, 
    -0.20616552f, -0.07446137f, 0.22236516f, -0.04284179f, -0.10940729f, -0.01987015f, 0.33162519f, 0.31985754f, 
    -0.14929138f, 0.09476057f, -0.06131448f, 0.04149976f, -0.01982700f, 0.02080591f, -0.13097276f, 0.51260978f, 
    -0.04481531f, -0.35137337f, 0.15623055f, 0.06984495f, -0.03203953f, 0.02559907f, 0.13238086f, 0.17424420f, 
    -0.05249522f, 0.06293686f, 0.00336161f, -0.12175678f, -0.03430674f, -0.01184095f, 0.00909803f, -0.08441723f, 
    0.07047476f, 0.07521383f, 0.32721058f, 0.11295792f, 0.12782979f, -0.04496892f, 0.08404464f, -0.12204427f, 
    0.10469244f, -0.11549512f, 0.08627963f, 0.11197607f, -0.08629620f, -0.04863144f, -0.03452533f, -0.09489653f, 
    -0.09676181f, 0.14701973f, -0.02185883f, 0.01830075f, -0.26767930f, -0.34275383f, -0.10151209f, -0.10382953f, 
    -0.19069408f, -0.14295192f, -0.14448288f, 0.35248548f, -0.07332312f, -0.02883834f, 0.04475484f, -0.21601322f, 
    0.01174551f, -0.13070402f, 0.04856946f, 0.16072714f, 0.05091351f, -0.00360517f, 0.11751211f, 0.00041743f, 
    -0.03584170f, 0.28343239f, 0.05159941f, -0.07194871f, -0.08692189f, -0.08062052f, 0.45597062f, -0.22102374f, 
    0.08410211f, 0.00668418f, 0.19886373f, 0.06652667f, 0.11493436f, -0.04141267f, -0.07092760f, -0.11152726f, 
    0.16843553f, -0.01121242f, -0.13978773f, 0.01320885f, -0.04028452f, -0.19461966f, 0.37850070f, 0.03297349f, 
    0.00687970f, -0.04344954f, -0.04393729f, 0.19378826f, 0.08190952f, 0.16533904f, 0.14574157f, -0.00696906f, 
    0.15305746f, 0.06248668f, 0.01874419f, -0.04348471f, -0.16275476f, -0.07495300f, 0.19741346f, 0.02316321f, 
    0.03806040f, -0.00484465f, -0.02381861f, -0.15009749f, -0.13543925f, -0.07729085f, 0.04659138f, 0.06687934f, 
    -0.00102540f, -0.33009839f, 0.06007330f, -0.37694907f, -0.06470245f, 0.05709075f, 0.07599056f, 0.08435909f, 
    0.00034431f, 0.04733292f, -0.29734701f, 0.32656938f, 0.12569121f, -0.37157908f, -0.10846932f, 0.06809327f, 
    -0.16782926f, -0.06936987f, 0.28763667f, 0.17469528f, 0.43140793f, -0.03192104f, -0.28202772f, 0.08543760f, 
    0.00600790f, -0.01965544f, -0.14330375f, -0.05601670f, -0.20821780f, -0.19612777f, 0.03112883f, -0.28235567f, 
    0.10965897f, -0.01428649f, 0.08217401f, 0.04815093f, 0.12677474f, -0.01879954f, 0.18620345f, 0.22223496f, 
    0.04852030f, 0.03085854f, 0.15719816f, 0.25108668f, -0.03542009f, 0.12932715f, -0.06472780f, 0.03303131f, 
    -0.15729405f, -0.03791834f, 0.13000835f, 0.15706459f, 0.29513684f, 0.00368473f, 0.05408350f, 0.04617036f, 
    -0.22688428f, -0.02170615f, 0.02079199f, 0.08092671f, -0.37490818f, -0.04521690f, 0.09442470f, 0.05824087f, 
    0.11380867f, 0.05694135f, 0.61851811f, -0.30069640f, -0.16004512f, -0.03204613f, -0.03444597f, -0.05698994f, 
    -0.09742693f, -0.22214843f, -0.12720539f, 0.05603311f, -0.08696309f, 0.37927780f, 0.05616612f, 0.23616199f, 
    0.21008341f, 0.22062570f, -0.12813522f, 0.04504376f, -0.07149694f, -0.08438579f, 0.07081710f, -0.02991145f, 
    0.16274253f, 0.02584678f, -0.06541806f, 0.07515492f, -0.23282409f, -0.14735101f, 0.02416511f, -0.05204098f, 
    -0.00231038f, 0.05869984f, -0.00205260f, -0.22056250f, -0.23580110f, 0.18192768f, 0.03713854f, -0.07842870f, 
    0.08931878f, -0.19149505f, 0.01247158f, -0.08008613f, -0.35901546f, 0.33842543f, 0.17132242f, -0.23101389f, 
    0.12275434f, -0.10707655f, 0.10700200f, -0.10463662f, 0.03597271f, 0.00960797f, -0.07250978f, -0.01858106f, 
    -0.32670343f, -0.40927663f, 0.12552942f, -0.12045237f, 0.14689475f, 0.03793698f, 0.09146870f, -0.06560574f, 
    -0.28952849f, -0.15298949f, 0.09735375f, 0.06634811f, 0.12828840f, 0.11911304f, 0.09491671f, -0.00634870f, 
    0.03440328f, -0.08716367f, -0.03232740f, 0.04077454f, 0.05567056f, -0.05445772f, -0.00560371f, 0.07785948f, 
    -0.15518723f, 0.09191263f, 0.06051520f, 0.42054525f, 0.35805902f, 0.42470932f, 0.24597409f, 0.02569719f, 
    0.08014239f, -0.07508397f, 0.07437298f, -0.04315964f, -0.47263914f, -0.08275004f, -0.02356814f, -0.03281842f, 
    0.05525423f, -0.02783613f, -0.09131462f, -0.24876010f, -0.20691368f, -0.03843289f, 0.20171447f, 0.16939801f, 
    -0.12273622f, -0.31454197f, 0.29517484f, -0.16384758f, 0.22518520f, -0.00924680f, 0.32560524f, -0.13730852f, 
    -0.17776100f, 0.11865058f, -0.06123642f, 0.13168797f, 0.13802922f, 0.22024211f, 0.05260161f, -0.15297802f, 
    0.03719123f, 0.15920530f, -0.24110025f, -0.01537175f, -0.01226987f, -0.00027247f, 0.07740079f, -0.03693205f, 
    -0.06662561f, 0.04761847f, 0.21774471f, -0.05183620f, 0.07958188f, -0.05844649f, -0.17204998f, -0.13057028f, 
    -0.06622614f, -0.32184851f, 0.22617690f, 0.13043371f, -0.14622919f, -0.12891681f, -0.00938310f, -0.12732159f, 
    -0.08931313f, -0.45550284f, -0.05525683f, 0.11339901f, 0.02187894f, 0.06239804f, -0.16894235f, 0.07222253f, 
    0.06267131f, 0.04772230f, -0.13945572f, 0.13664237f, 0.13208672f, 0.10945441f, 0.08021260f, 0.07926998f, 
    -0.04070434f, 0.04614784f, -0.27356234f, 0.03102549f, 0.07419290f, 0.05792366f, 0.17647164f, 0.14221178f, 
    -0.08571064f, -0.14934276f, -0.00887088f, 0.12166083f, -0.13713558f, 0.16567379f, 0.21769382f, -0.02576889f, 
    -0.02554492f, -0.18343787f, -0.10098868f, -0.14792415f, -0.08008112f, -0.10792759f, 0.39387164f, -0.00612322f, 
    -0.10382753f, -0.17949004f, 0.06120633f, -0.12737097f, -0.00348318f, 0.00490725f, 0.02598033f, -0.08477792f, 
    0.26574013f, 0.06893459f, 0.10695460f, 0.12833942f, 0.05674341f, -0.09839038f, 0.08992349f, -0.12595300f, 
    0.24374273f, -0.08051451f, -0.12357718f, 0.02580459f, 0.01761071f, -0.06317411f, 0.02163003f, 0.03484100f, 
    -0.23528193f, 0.09320133f, 0.00056707f, 0.05736027f, -0.24105845f, -0.16277859f, 0.02660100f, -0.12339221f, 
    0.06098224f, -0.04007008f, -0.56371266f, -0.19414151f, 0.12469585f, 0.06875917f, 0.01652650f, 0.03752871f, 
    0.01971794f, -0.03787388f, 0.11898174f, -0.13681005f, 0.53163719f, 0.16520491f, -0.04970205f, -0.08269677f, 
    0.09284967f, -0.05550965f, -0.06907452f, 0.04701823f, 0.03120644f, -0.11297038f, 0.15753187f, 0.16972513f, 
    0.02036462f, 0.12773496f, 0.05195267f, -0.03562902f, -0.06621739f, 0.07391227f, 0.01320320f, 0.15655613f, 
    -0.04171993f, 0.05562863f, 0.07929486f, 0.11166560f, -0.21646474f, 0.03804004f, -0.24140412f, -0.14734279f, 
    0.14095780f, 0.03639501f, 0.13658035f, 0.05947138f, 0.08920189f, 0.11044868f, 0.02405595f, 0.12104554f, 
    -0.11886375f, -0.06644835f, 0.03040123f, 0.18413307f, -0.29292336f, -0.05315772f, -0.08661605f, -0.14571129f, 
    0.16435081f, 0.24650492f, 0.17604943f, 0.07932058f, 0.08520116f, -0.15335536f, -0.00082252f, 0.15252532f, 
    -0.00428457f, 0.15074970f, 0.12787065f, 0.17221217f, -0.20705917f, -0.13315280f, 0.06403092f, -0.08761068f, 
    0.09540705f, -0.23439719f, 0.27663729f, 0.25784418f, -0.00245900f, 0.13187899f, -0.00079670f, 0.09962720f, 
    0.05489523f, -0.11546843f, 0.01876641f, 0.44770083f, -0.11298955f, -0.33634126f, -0.06857631f, 0.11676548f, 
    -0.15741250f, 0.06800760f, -0.02482320f, 0.04302803f, 0.03705388f, 0.01916092f, 0.21333256f, -0.01480582f, 
    0.06566695f, -0.10076535f, -0.13069600f, -0.03908924f, -0.10499908f, -0.24353249f, -0.02300362f, -0.03334153f, 
    0.12436911f, 0.02807230f, 0.08574075f, 0.15464585f, 0.00323279f, 0.02462360f, -0.04826499f, -0.08372842f, 
    0.25706798f, 0.26748466f, -0.00533113f, 0.08430000f, 0.06582396f, 0.02966839f, 0.00114623f, -0.11882974f, 
    0.36862028f, -0.28992245f, -0.04484317f, -0.18959521f, 0.06491204f, -0.12462717f, -0.11516532f, -0.12464816f, 
    0.04992941f, 0.12123925f, -0.03022832f, -0.01815978f, 0.20746818f, 0.07573669f, 0.04733563f, -0.11559170f, 
    -0.03085193f, 0.16295324f, 0.37067702f, -0.18927631f, 0.12172227f, -0.00643934f, 0.06811313f, -0.07585438f, 
    -0.00651256f, 0.04490816f, -0.07448890f, -0.00870042f, 0.14414422f, 0.03331205f, 0.00579071f, 0.09093028f, 
    0.00620128f, 0.01235106f, -0.14261197f, -0.07777978f, 0.71138960f, 0.76075852f, -0.11316867f, -0.06772827f, 
    0.17136355f, -0.01198660f, 0.22022663f, 0.00697000f, -0.26709053f, 0.17723210f, 0.20819740f, -0.13839374f, 
    -0.00623904f, -0.05849105f, -0.14739667f, -0.16612993f, 0.04071621f, 0.24915107f, 0.04715240f, 0.13530348f, 
    0.06102083f, -0.16781139f, -0.15424661f, -0.28912827f, 0.53235638f, -0.03911135f, 0.39886761f, 0.29461208f, 
    -0.29299277f, 0.03160649f, 0.09740017f, 0.11762504f, 0.02609593f, -0.05826734f, -0.19940987f, -0.08295554f, 
    0.15943597f, 0.26312310f, -0.11734358f, 0.01564731f, -0.02119939f, -0.10846115f, 0.06710840f, -0.13113947f, 
    -0.21990846f, 0.06277669f, 0.03954941f, 0.00427429f, 0.07253300f, 0.16524678f, -0.27569818f, -0.07186208f, 
    -0.05817974f, -0.04529327f, 0.17302018f, 0.03850494f, -0.26607749f, -0.11421291f, 0.07777000f, -0.03602515f, 
    -0.28320733f, 0.02656980f, -0.07364947f, 0.09315365f, -0.00155165f, 0.05574971f, 0.01996275f, 0.17569445f, 
    -0.67565614f, -0.16173649f, -0.06840792f, 0.08983740f, -0.13540682f, 0.08549204f, 0.01912632f, -0.10149141f, 
    0.14475252f, 0.22598465f, 0.09276950f, -0.30010343f, -0.19081154f, 0.02105264f, 0.02934895f, 0.05918433f, 
    -0.01729179f, 0.02297706f, 0.04282201f, -0.08432574f, -0.02581333f, 0.07042465f, 0.28115267f, -0.04703943f, 
    -0.10363380f, 0.00929643f, -0.31432492f, 0.15071012f, 0.07775609f, 0.09801786f, 0.55429459f, -0.36334831f, 
    -0.10727732f, 0.03518679f, -0.07451129f, -0.11011308f, -0.00159200f, 0.00442055f, 0.04607673f, -0.04896479f, 
    0.09695910f, 0.08258779f, 0.06938300f, 0.21302895f, -0.07296875f, 0.15139027f, -0.00858193f, -0.25129172f, 
    -0.04044759f, -0.08485758f, -0.18246578f, 0.00153221f, -0.06031868f, -0.10191949f, -0.29671076f, -0.10894100f, 
    -0.15775001f, -0.01600632f, 0.12613486f, -0.13006872f, 0.11295044f, -0.12318002f, -0.05755303f, -0.03598313f, 
    0.08614927f, 0.12490600f, -0.26803404f, -0.01985692f, -0.26616004f, 0.16216642f, 0.19288644f, 0.01322096f, 
    -0.00783434f, 0.05245546f, -0.07816985f, 0.15974106f, 0.32259494f, 0.21885219f, -0.00650162f, 0.12832186f, 
    0.04057541f, 0.04211524f, 0.21084721f, -0.00415468f, -0.11076166f, 0.15400326f, -0.18142718f, 0.07189114f, 
    0.09012222f, 0.18679510f, -0.07318031f, 0.15340522f, -0.17406729f, 0.35047919f, 0.31267726f, 0.11570326f, 
    -0.08071695f, -0.00061896f, 0.07545808f, 0.07268443f, 0.01066261f, 0.14069347f, -0.34943902f, 0.11347952f, 
    -0.09306185f, 0.11340542f, 0.11772683f, 0.09635710f, -0.06169394f, 0.07399292f, 0.08869792f, -0.06843780f, 
    -0.13500504f, -0.11155912f, -0.05961423f, -0.09727918f, -0.03385737f, -0.10067004f, -0.12344939f, -0.09988472f, 
    -0.00122432f, 0.28918868f, 0.30664626f, -0.12551616f, 0.36598322f, 0.15631673f, 0.02346773f, 0.20901366f, 
    0.11291131f, 0.00040280f, 0.02123234f, -0.03867282f, 0.08164714f, -0.22543178f, -0.10200942f, -0.03357476f, 
    0.04705360f, 0.03365030f, 0.45504516f, -0.09068503f, -0.03735737f, -0.03079771f, -0.09237486f, 0.00718636f, 
    0.17383955f, 0.15588665f, 0.09429576f, 0.24755877f, -0.17509136f, -0.26940402f, -0.02918487f, -0.03321626f, 
    -0.05433048f, -0.06210695f, -0.14870059f, 0.09084547f, -0.14862013f, 0.09471503f, 0.19336054f, 0.10916825f, 
    -0.01230972f, -0.09627066f, 0.16667303f, -0.04633634f, 0.06672816f, -0.35814714f, -0.17746820f, 0.02128042f, 
    0.06287810f, 0.04045017f, 0.01259965f, -0.15803204f, -0.28690931f, -0.19618043f, -0.33771366f, 0.00397523f, 
    0.10744614f, 0.17628996f, -0.05497878f, -0.00145452f, -0.18498214f, 0.07150336f, -0.05519925f, 0.22461323f, 
    0.43768707f, 0.04998950f, 0.02385734f, 0.07010705f, 0.05998757f, -0.00641165f, 0.09982482f, -0.57253331f, 
    -0.52662700f, 0.48263121f, 0.17337947f, 0.02900304f, 0.19120832f, 0.16002344f, -0.05354517f, 0.41338390f, 
    -0.09698300f, 0.06673331f, 0.31356353f, 0.03567554f, 0.04685060f, 0.08673804f, 0.04517951f, 0.20732920f, 
    0.08291075f, 0.17324792f, -0.25690904f, -0.01513850f, 0.07073879f, -0.09464470f, 0.06314468f, -0.00839334f, 
    0.04653205f, 0.01282858f, -0.16459022f, 0.46781528f, 0.59626365f, 0.39871907f, 0.15611312f, 0.53903055f, 
    0.07376152f, -0.14304535f, 0.09068041f, 0.03482570f, 0.06038274f, 0.11348617f, 0.23288822f, 0.10888771f, 
    0.05361775f, 0.11643260f, -0.01468099f, -0.09543356f, -0.11219733f, -0.18446882f, 0.54965407f, -0.08932447f, 
    0.05770484f, 0.05865523f, -0.24495783f, -0.00748165f, 0.33464828f, 0.22700571f, 0.26407316f, -0.29530358f, 
    -0.27473032f, 0.04479535f, -0.05941043f, 0.06533883f, -0.23035844f, -0.09659521f, -0.24092598f, -0.17201358f, 
    0.04355912f, -0.06354868f, -0.03759551f, -0.01489221f, -0.00934966f, -0.11559799f, 0.00967468f, 0.10628198f, 
    -0.15314014f, 0.06978561f, 0.10756809f, -0.02349538f, -0.02611344f, -0.03794990f, -0.11735073f, -0.21604510f, 
    0.08112439f, -0.35833633f, 0.31222141f, 0.12199796f, -0.07530950f, -0.11455773f, -0.07468519f, -0.02268114f, 
    0.08540163f, 0.00477665f, -0.14690477f, 0.15732399f, 0.04750620f, 0.04138499f, -0.13953255f, -0.08191920f, 
    -0.05215919f, 0.03516025f, 0.04432991f, 0.07765819f, -0.02696090f, 0.05358067f, -0.02629080f, -0.13354297f, 
    0.05039507f, 0.17765991f, -0.11240410f, 0.04567117f, 0.03465287f, 0.13328850f, 0.10031948f, -0.09119388f, 
    -0.06383248f, -0.03277390f, 0.07080230f, 0.01902214f, 0.01269925f, 0.21377195f, -0.00136650f, -0.06770277f, 
    0.00752037f, 0.24911205f, -0.07021963f, 0.16335322f, -0.01708176f, 0.11792860f, 0.79951406f, 0.06258103f, 
    0.09548361f, -0.17461190f, -0.30699894f, -0.06644205f, 0.09610810f, -0.03080915f, 0.03167420f, -0.14776473f, 
    0.27397895f, 0.12802638f, -0.05225145f, 0.08543494f, -0.01032126f, -0.02601168f, -0.05625930f, -0.04159560f, 
    -0.14663208f, 0.27316272f, 0.14036083f, -0.02944683f, -0.08787296f, -0.08027598f, -0.12387037f, 0.05175178f, 
    0.08140305f, 0.18065239f, 0.24165396f, -0.14551063f, -0.22816795f, -0.07085450f, -0.07103578f, 0.01790800f, 
    -0.04249066f, -0.00445499f, 0.15312517f, -0.27707493f, 0.13841943f, -0.00733766f, 0.02582215f, -0.21478565f, 
    0.16789886f, 0.04009677f, 0.08246960f, 0.06377584f, -0.09141588f, -0.00826685f, -0.05489575f, 0.04448207f, 
    -0.04406904f, 0.04038039f, 0.00454152f, -0.02484933f, 0.10299348f, -0.06765121f, -0.04467991f, 0.03872910f, 
    0.03528670f, -0.20845996f, -0.07239397f, -0.06116605f, 0.17726198f, 0.13047916f, 0.55324215f, 0.34897578f, 
    -0.06586839f, -0.08938665f, -0.05676935f, 0.01525063f, -0.06691737f, -0.13014622f, -0.22364363f, -0.43110085f, 
    -0.19061978f, 0.00713391f, 0.01455047f, 0.00928861f, 0.10106944f, 0.13305293f, 0.06935970f, 0.15429339f, 
    0.33257687f, 0.03095913f, -0.10921465f, 0.09364259f, -0.04064934f, -0.21462375f, -0.00004627f, -0.07155998f, 
    0.05488693f, -0.40312338f, 0.31784484f, 0.15505905f, 0.40603006f, 0.18258072f, 0.01190887f, 0.07296483f, 
    -0.03132242f, -0.03928679f, 0.17703933f, -0.03260828f, -0.05191333f, -0.17770116f, -0.02657472f, -0.00131919f, 
    -0.01715823f, 0.03554425f, 0.35504508f, 0.43772057f, 0.45080400f, -0.07727388f, -0.17476125f, 0.01298136f, 
    0.17482454f, 0.07445699f, 0.02708713f, -0.15979931f, -0.44381663f, 0.21878843f, -0.25591961f, -0.02618132f, 
    -0.19978358f, -0.00486635f, -0.03194905f, -0.02828110f, -0.50310600f, 0.01334553f, -0.22078045f, 0.29381952f, 
    -0.12863146f, -0.02040978f, -0.15818705f, 0.10217235f, 0.03224272f, -0.14573294f, -0.22656865f, -0.12775798f, 
    -0.07241163f, -0.17605610f, -0.01072863f, 0.03076253f, 0.06420646f, -0.00000597f, -0.20799789f, 0.07489229f, 
    0.03574934f, -0.01133935f, -0.09659554f, -0.15254812f, -0.10714899f, -0.13716349f, 0.04399275f, 0.00494355f, 
    0.01488757f, 0.32470644f, -0.17391276f, 0.07891063f, -0.19506559f, 0.00775243f, -0.06578811f, 0.26122898f, 
    -0.01312369f, -0.16197041f, 0.32776076f, -0.05497502f, 0.19571058f, -0.07785608f, -0.17725693f, 0.08766202f, 
    0.00790145f, -0.05282781f, 0.08852410f, -0.11402869f, 0.15769917f, -0.08467024f, 0.07411870f, 0.22087727f, 
    0.21675776f, 0.14722195f, -0.04340585f, 0.18682528f, 0.12071128f, -0.11280839f, -0.03614134f, -0.04681075f, 
    0.19843502f, -0.06738652f, 0.06522050f, -0.41229227f, 0.45282078f, -0.07542288f, -0.03351730f, 0.53193325f, 
    0.05249360f, -0.04645160f, -0.20352156f, -0.35960358f, -0.25357506f, 0.07854857f, 0.44128147f, -0.06572541f, 
    -0.10978757f, 0.05484173f, -0.01605255f, 0.03212980f, 0.06455535f, -0.17834963f, 0.60785550f, 0.29622552f, 
    -0.47641861f, -0.41932511f, -0.40578026f, 0.08049958f, 0.03482076f, 0.03773898f, 0.10610697f, -0.08894134f, 
    0.05589483f, -0.09751914f, -0.05304686f, -0.11419837f, 0.09615511f, -0.01152382f, -0.08940192f, -0.25464863f, 
    0.08581564f, -0.06370414f, -0.09296133f, 0.02523611f, 0.18257383f, -0.05765282f, -0.13392887f, 0.05474226f, 
    -0.35223427f, -0.16471937f, -0.14568473f, -0.01434218f, 0.14080638f, 0.02490195f, 0.02702556f, 0.00632838f, 
    0.08106631f, -0.22284237f, -0.09882971f, -0.44674733f, 0.09957426f, 0.00859625f, 0.23247033f, -0.09974576f, 
    0.30253899f, 0.08792901f, -0.27634016f, -0.40866527f, -0.53915453f, 0.10901071f, 0.09799623f, -0.07098939f, 
    -0.05300535f, -0.03257767f, -0.19779877f, 0.00725455f, -0.14392455f, 0.00149625f, 0.05570662f, 0.11204372f, 
    0.05481374f, 0.00359876f, 0.03474479f, 0.30284843f, -0.11899599f, -0.16957913f, -0.09299666f, -0.11058282f, 
    -0.01887320f, -0.02175247f, 0.08051155f, -0.08917095f, -0.01988164f, 0.06335378f, -0.04793514f, -0.08274973f, 
    0.04556305f, 0.01133116f, -0.10924532f, 0.12189947f, 0.14799108f, 0.07980902f, -0.44626847f, 0.11807048f, 
    0.46260193f, -0.01077066f, -0.03080121f, 0.01184775f, 0.07210368f, -0.10584469f, -0.07727253f, -0.03013490f, 
    -0.20652749f, -0.31229222f, 0.04788404f, -0.02127433f, 0.03782010f, -0.08022486f, 0.04526394f, -0.16579568f, 
    -0.23432274f, 0.03722861f, 0.20327011f, 0.21014555f, 0.00034503f, -0.02927599f, 0.08464430f, -0.39704290f, 
    -0.24634673f, -0.10143472f, 0.12794888f, -0.07668409f, 0.02055131f, 0.12795806f, 0.13046393f, 0.21223049f, 
    0.06419786f, -0.07228544f, -0.17199107f, -0.28184855f, 0.16313995f, 0.10482012f, 0.13411698f, -0.14389999f, 
    -0.01702598f, 0.08071262f, -0.15256202f, 0.23609625f, -0.09224760f, 0.04916850f, -0.17529564f, 0.06849431f, 
    0.00207970f, 0.11644522f, 0.27795225f, 0.12151682f, 0.13286048f, -0.08009109f, 0.01914165f, -0.11217942f, 
    -0.10263386f, 0.23838763f, -0.07486649f, 0.13442452f, 0.16979471f, 0.00891242f, 0.08952925f, 0.18200637f, 
    0.11765608f, 0.00421884f, 0.28044236f, 0.10562272f, 0.04328161f, -0.00895550f, -0.26859984f, 0.09995894f, 
    -0.06099862f, -0.18970481f, 0.05049128f, -0.12949415f, -0.06382188f, 0.14145283f, 0.08359558f, -0.24922442f, 
    -0.00615147f, -0.22052063f, 0.05733336f, -0.04091161f, -0.04455995f, 0.08964846f, -0.08030447f, -0.01924926f, 
    -0.06619529f, -0.15480672f, 0.24956706f, 0.30166331f, 0.07029151f, -0.14721037f, 0.03096786f, 0.04436398f, 
    0.04389409f, -0.01842496f, -0.07638850f, -0.06775151f, -0.06168485f, 0.06581550f, 0.03790749f, -0.12844718f, 
    0.10561267f, 0.05211587f, 0.08235500f, 0.27638257f, 0.22840953f, -0.01575022f, -0.03797512f, 0.01262510f, 
    0.16928396f, 0.18744749f, 0.14329830f, 0.03300273f, -0.00831013f, 0.64930451f, 0.19677393f, -0.20956598f, 
    0.05219279f, -0.00577397f, -0.05986397f, -0.02072688f, 0.06868919f, 0.05918998f, -0.05521541f, 0.01766022f, 
    -0.02649847f, -0.00513504f, 0.06211616f, -0.04408419f, 0.18255971f, -0.33864808f, -0.02304602f, -0.20923358f, 
    0.06748213f, 0.08679403f, -0.06937266f, -0.04884086f, 0.13812046f, -0.07856708f, -0.34923065f, -0.16863164f, 
    0.19610173f, -0.22901526f, -0.23019935f, 0.09988218f, -0.05406831f, 0.12810129f, 0.12005118f, 0.23483779f, 
    0.25648683f, 0.38461810f, 0.27636102f, 0.10118306f, -0.21960792f, -0.21391006f, 0.11386959f, 0.15859887f, 
    -0.28762728f, -0.15468445f, 0.40995827f, 0.20985344f, 0.18756241f, -0.06786893f, -0.12696987f, 0.14967574f, 
    0.04857181f, -0.06436259f, 0.05029487f, 0.02142684f, -0.02666757f, -0.27111012f, -0.05899966f, 0.07930389f, 
    0.19599491f, 0.16713773f, -0.32680041f, -0.19989187f, -0.29692972f, -0.07550806f, -0.06391759f, 0.06891667f, 
    0.03774101f, 0.14753717f, 0.01306945f, 0.26845983f, -0.17813727f, 0.23593688f, 0.06011014f, 0.01288713f, 
    0.11662564f, -0.14518669f, -0.11148843f, 0.12694728f, -0.07071996f, 0.20758002f, 0.71213019f, -0.01062827f, 
    0.12751056f, 0.18650469f, 0.06593813f, 0.10838827f, 0.21604961f, 0.22126856f, 0.03082930f, 0.03990635f, 
    -0.22459869f, 0.09657046f, 0.03948246f, -0.27388236f, 0.04197684f, 0.23608840f, -0.27505821f, 0.03637415f, 
    0.27876329f, 0.11539996f, 0.09490569f, -0.26975584f, 0.04813645f, 0.05349679f, -0.09870669f, -0.18845914f, 
    -0.01367080f, -0.15893166f, -0.09333449f, 0.03473402f, 0.14098200f, 0.02054843f, 0.19329113f, -0.11670221f, 
    0.22455785f, 0.12182743f, 0.03044331f, 0.03443945f, 0.01114345f, -0.07027129f, 0.17095922f, -0.04467610f, 
    -0.06692572f, 0.33828032f, 0.19734289f, -0.09911443f, 0.31347859f, 0.08737481f, 0.11602657f, -0.03359654f, 
    0.37133977f, 0.14443912f, 0.04043284f, 0.32335395f, 0.09926163f, 0.04372590f, -0.20024808f, -0.26537985f, 
    0.23844986f, 0.14489999f, 0.19071150f, -0.68571150f, -0.54640454f, -0.73234963f, -0.02805682f, -0.05321291f, 
    0.05256868f, 0.22877158f, 0.13676697f, 0.18162164f, 0.34285298f, 0.19349478f, 0.04235391f, -0.15433787f, 
    -0.15713695f, -0.02157309f, 0.01165677f, -0.14801076f, -0.06924744f, -0.08843954f, -0.03305840f, 0.07390453f, 
    -0.03419959f, -0.13427806f, 0.01277228f, 0.01725637f, 0.08007450f, 0.08164056f, -0.29995206f, -0.03234950f, 
    -0.25831196f, -0.35340890f, 0.06788760f, 0.03659097f, 0.04714882f, 0.02935868f, -0.08617480f, 0.08966813f, 
    0.12904890f, -0.11278140f, 0.00029540f, -0.13734852f, -0.15189819f, -0.02662675f, 0.12521249f, -0.03306630f, 
    -0.12993608f, 0.31048170f, 0.19977701f, -0.00309804f, -0.03069592f, -0.01271772f, -0.10907574f, 0.18227585f, 
    0.31797960f, 0.18001759f, 0.02245414f, -0.13787417f, -0.28377894f, -0.09701233f, 0.09352656f, 0.10202152f, 
    0.04560948f, 0.03273608f, -0.02964740f, -0.18033259f, -0.23342749f, 0.07911035f, 0.16045067f, 0.05913323f, 
    -0.02388188f, 0.16021533f, 0.06903323f, -0.48635006f, -0.30396333f, 0.28850546f, 0.03497252f, 0.12700777f, 
    -0.02460807f, 0.05279746f, 0.11552964f, -0.14733952f, -0.03595858f, -0.51901281f, -0.20322482f, -0.03327352f, 
    0.07821820f, -0.09649885f, -0.01959702f, 0.37348005f, -0.00825320f, -0.64121312f, -0.39791727f, -0.22772554f, 
    0.12736119f, 0.05024713f, 0.05359003f, -0.08090373f, -0.04568257f, 0.06092655f, 0.18284781f, -0.53253043f, 
    -0.16454440f, -0.05888250f, -0.00117439f, -0.07593837f, 0.06057208f, -0.07702827f, -0.02054769f, 0.10819563f, 
    0.01479911f, 0.16847853f, 0.13859765f, 0.16602665f, -0.06445953f, 0.15887433f, -0.03691652f, 0.21679735f, 
    -0.34326035f, 0.12300111f, 0.10435296f, -0.07244411f, 0.28918976f, -0.06997292f, -0.20536232f, -0.05016746f, 
    -0.09782446f, 0.13278891f, -0.07307748f, -0.14253524f, -0.21410550f, -0.34824106f, -0.16803019f, 0.06331352f, 
    -0.09710135f, 0.02867902f, -0.49246109f, -0.50313187f, -0.13972111f, -0.22767255f, -0.10645318f, -0.00312564f, 
    -0.07050568f, -0.20262665f, -0.05852006f, -0.41275370f, -0.15064970f, -0.55728209f, -0.30586246f, 0.30376437f, 
    -0.15509938f, 0.08013585f, 0.07765969f, -0.00646335f, 0.09068166f, -0.18817677f, -0.09701884f, -0.00015389f, 
    -0.07395857f, 0.03887485f, 0.15864863f, -0.19739598f, 0.18038426f, 0.04492248f, 0.07668595f, -0.24692470f, 
    0.07626913f, -0.02734089f, -0.08462056f, 0.08615391f, 0.22626124f, 0.18466596f, 0.40840119f, 0.39286581f, 
    -0.24728352f, -0.12334703f, -0.01454171f, -0.25439975f, 0.37812695f, 0.23446757f, -0.17686573f, -0.65396887f, 
    0.29748324f, 0.04024525f, 0.13982716f, -0.01245382f, 0.05198139f, 0.14413653f, 0.03061245f, 0.13229369f, 
    -0.14981604f, -0.13611615f, 0.02130820f, 0.02310679f, 0.02305159f, -0.04850508f, -0.05653328f, 0.19183786f, 
    -0.21658546f, 0.12381847f, 0.62780750f, 0.13612108f, 0.15203582f, -0.25129589f, -0.00593386f, 0.01713327f, 
    -0.12772287f, -0.04398147f, 0.27719241f, 0.21363860f, -0.05000225f, 0.06090728f, -0.14846829f, -0.04557987f, 
    0.11080102f, 0.11300108f, -0.10588052f, -0.67406303f, -0.36470169f, -0.50573438f, 0.21410984f, 0.57796532f, 
    0.17521009f, 0.11419923f, 0.12612729f, -0.24109238f, -0.39075476f, 0.19528627f, 0.28449142f, 0.03699826f, 
    0.01078735f, -0.04056337f, 0.02113524f, -0.09420003f, -0.32853103f, 0.00927160f, 0.68168300f, 0.24461782f, 
    -0.21240276f, -0.05848487f, 0.15261734f, 0.13783796f, 0.10773861f, 0.04820523f, -0.45987064f, -0.27935168f, 
    -0.40268525f, -0.13985290f, -0.02718462f, 0.11175155f, 0.15795909f, 0.05630898f, -0.04044240f, 0.24267741f, 
    -0.06411082f, -0.05093907f, 0.02910941f, 0.11951338f, -0.04927345f, 0.14044715f, -0.08407436f, 0.13082299f, 
    0.02224413f, 0.02818851f, 0.02283215f, -0.05624031f, -0.03718070f, 0.01646384f, 0.01855827f, -0.00745558f, 
    0.00684190f, 0.02889288f, -0.02267271f, -0.05726381f, -0.01990703f, 0.00755106f, -0.03504325f, 0.03611013f, 
    -0.02655983f, 0.04464935f, -0.01382979f, -0.03728149f, 0.02722181f, -0.02073067f, 0.02391006f, -0.03829404f, 
    -0.00855742f, -0.03969571f, -0.06274115f, 0.04441012f, 0.00657515f, -0.05470255f, -0.04396148f, 0.04838599f, 
    -0.04870094f, -0.03690882f, -0.05467546f, 0.01941391f, 0.01536917f, -0.04472619f, 0.01772481f, -0.00500385f, 
    0.01391176f, 0.04883963f, 0.04759771f, -0.03149205f, -0.04422226f, -0.01197623f, -0.06022552f, 0.00130708f, 
    0.00703064f, 0.04192353f, -0.03677122f, 0.02854323f, -0.02789757f, -0.00386883f, -0.04093992f, 0.01484739f, 
    0.03952996f, -0.03760904f, -0.04159031f, 0.04594011f, -0.02006547f, -0.03742574f, 0.04625226f, 0.04222806f, 
    -0.03688047f, 0.03002542f, -0.03742442f, 0.02498534f, 0.05414955f, 0.03737973f, 0.02889161f, 0.04792183f, 
    0.00069081f, 0.03878955f, -0.00026215f, -0.03646322f, 0.04347652f, 0.01507193f, -0.01844037f, -0.05257514f, 
    -0.05858387f, -0.05870584f, -0.00480979f, -0.04240506f, 0.00367118f, -0.00101937f, 0.01491383f, -0.03702242f, 
    -0.01188575f, -0.02490915f, -0.04342369f, 0.01028573f, 0.03945411f, 0.04418052f, 0.02364062f, -0.01690930f, 
    -0.06086821f, -0.00218486f, -0.04883601f, -0.04262186f, 0.01548914f, 0.01158289f, 0.01179145f, 0.02713605f, 
    0.03112255f, -0.03909051f, 0.04170159f, 0.04396113f, -0.02585641f, -0.04993208f, 0.03538051f, 0.02192701f, 
    0.02642081f, 0.01266315f, -0.00034418f, -0.04299617f, -0.02624590f, 0.00343398f, -0.05297580f, -0.01139652f, 
    0.00815941f, -0.06192512f, 0.03072684f, 0.04884173f, 0.00849559f, 0.00486139f, -0.05221374f, -0.02353860f, 
    0.03868824f, -0.02633404f, -0.00524298f, 0.03123963f, 0.04904968f, 0.05279955f, 0.00607775f, -0.06039030f, 
    -0.03099657f, -0.02068721f, 0.03569660f, 0.01053186f, 0.03780632f, 0.00382216f, -0.05273857f, -0.00873880f, 
    -0.03981671f, -0.02865784f, 0.00474679f, -0.03667617f, -0.00842595f, -0.02879345f, -0.04082480f, 0.02851880f, 
    -0.06394751f, -0.05419212f, -0.04232354f, -0.01283723f, 0.00571802f, 0.00044657f, 0.02934279f, -0.05038286f, 
    -0.03661044f, 0.02840572f, -0.03515359f, -0.00715351f, -0.05332118f, -0.01090225f, -0.04022029f, 0.01675300f, 
    0.03781186f, -0.02600398f, -0.05618349f, -0.00407715f, 0.01597943f, -0.03693460f, 0.02151814f, -0.03486754f, 
    0.04002673f, -0.04978768f, -0.00668353f, 0.02623527f, -0.05904549f, -0.00004785f, -0.03529137f, -0.00914259f, 
    0.03113320f, 0.03240228f, 0.01007367f, 0.00232004f, -0.05113416f, -0.02369646f, 0.02415985f, -0.00683757f, 
    -0.05126902f, -0.02870022f, 0.01547365f, -0.01292856f, -0.05341648f, 0.02385981f, -0.00982655f, 0.02095667f, 
    0.02725686f, -0.05740454f, -0.01957530f, -0.04309570f, -0.03339638f, -0.03021131f, 0.01360144f, -0.03183704f, 
    -0.03587107f, 0.02236138f, 0.03889423f, -0.02295743f, -0.03651334f, -0.06296540f, -0.01686935f, -0.05209737f, 
    -0.02151323f, -0.04158307f, 0.01524709f, -0.04735574f, 0.03519867f, -0.03920186f, 0.01808917f, -0.03173763f, 
    0.00824903f, -0.01790914f, 0.03440751f, -0.05087900f, -0.05305656f, 0.02810502f, 0.00331175f, -0.01264025f, 
    -0.03494040f, -0.00241644f, -0.00478458f, -0.04514487f, -0.01757262f, -0.02838269f, -0.01539270f, -0.04872339f, 
    -0.00809579f, 0.04887303f, -0.02086783f, -0.03102209f, -0.06605119f, -0.02940384f, 0.04774198f, -0.03286650f, 
    -0.02613707f, -0.04779985f, 0.00886461f, 0.02197764f, 0.01938208f, -0.03626695f, 0.01034139f, -0.00457936f, 
    0.04891276f, 0.00188422f, -0.02744059f, 0.03160537f, 0.02148196f, 0.00416647f, -0.00075623f, 0.00145209f, 
    -0.02567076f, -0.04255904f, -0.01267750f, -0.01283610f, 0.05584089f, -0.01753951f, -0.00984297f, 0.00592007f, 
    -0.00807300f, -0.00692895f, 0.01712121f, -0.04958882f, -0.06610572f, 0.00434745f, -0.01329765f, -0.01491180f, 
    -0.00326260f, 0.01176963f, -0.01892516f, 0.04090229f, -0.01771074f, 0.00798633f, -0.04589050f, -0.00483955f, 
    -0.10125473f, -0.16713853f, -0.09153058f, -0.20145296f, 0.22173271f, -0.12571786f, 0.03661281f, -0.03599186f, 
    0.35635510f, -0.58278292f, -0.41239348f, -0.34244406f, 0.02828604f, -0.06390906f, -0.21032283f, -0.00499842f, 
    0.17082708f, 0.28734112f, -0.32996565f, -0.30429253f, -0.11106044f, 0.01605671f, 0.05258810f, 0.03550842f, 
    0.08274980f, -0.10588058f, -0.13435185f, -0.19778258f, 0.23904429f, 0.29611418f, 0.16130944f, -0.03454614f, 
    -0.03115345f, 0.15525511f, 0.08159358f, -0.09916796f, -0.54211712f, -0.71335799f, -0.07118444f, -0.14524357f, 
    -0.00054572f, -0.04600814f, 0.01224094f, 0.04234217f, 0.19004275f, 0.21959732f, 0.23615427f, 0.02564753f, 
    -0.06610539f, -0.03045192f, 0.00626811f, -0.12944826f, 0.02737586f, 0.21076919f, -0.06904948f, -0.07544751f, 
    0.33357069f, 0.07002312f, 0.07996374f, 0.14964667f, 0.10658064f, 0.12407089f, 0.14884245f, -0.88527369f, 
    0.06084185f, 0.49484724f, 0.32633820f, 0.07165994f, 0.03172354f, -0.03167884f, -0.07443656f, 0.00396807f, 
    0.22715048f, 0.16426986f, 0.41254753f, 0.17309897f, 0.08156127f, -0.00722495f, 0.33300188f, 0.24327111f, 
    0.00590638f, -0.47925010f, -0.57920599f, -0.10548826f, -0.00324537f, 0.05842749f, 0.12323637f, 0.05375282f, 
    0.27763945f, 0.13012384f, 0.09332948f, -0.54233617f, -0.25652614f, -0.02040110f, -0.14116348f, -0.09727629f, 
    -0.22697003f, 0.06827217f, -0.02415498f, -0.15618031f, 0.03352598f, 0.14828822f, -0.05352048f, 0.18044524f, 
    0.01227286f, 0.01559830f, 0.02398444f, 0.09843912f, -0.01970489f, 0.22514084f, 0.12169349f, 0.15769696f, 
    -0.05589204f, -0.00052574f, 0.26336595f, 0.09309352f, -0.17561251f, -0.28489739f, 0.16120414f, 0.19429277f, 
    -0.06381258f, 0.19261774f, 0.02337591f, 0.06387889f, 0.06586264f, -0.08666717f, -0.27512136f, -0.69131118f, 
    -0.13436005f, -0.21660060f, -0.06920791f, -0.34764138f, -0.17197914f, -0.07261762f, 0.05034499f, -0.15787072f, 
    -0.16953126f, 0.30168411f, 0.18012682f, 0.37924269f, 0.33227873f, 0.05396349f, 0.17113556f, 0.30785570f, 
    0.04955223f, -0.16795565f, 0.02153066f, 0.10501731f, 0.10399175f, 0.33481690f, -0.06112226f, -0.24748380f, 
    -0.04782816f, -0.39453289f, -0.30838063f, 0.05698993f, -0.08575288f, -0.11991603f, -0.28999954f, 0.11978353f, 
    0.05129337f, 0.00482037f, -0.57902759f, -0.04210671f, 0.37801602f, -0.20364839f, -0.12985672f, -0.11215068f, 
    0.09756890f, -0.02712436f, -0.00025722f, 0.15915035f, 0.03794659f, 0.35823008f, -0.11649632f, 0.26448491f, 
    -0.06634776f, 0.33916235f, 0.09874421f, 0.16035832f, 0.23517352f, -0.17179269f, 0.00400166f, -0.11475036f, 
    0.25237566f, 0.03148738f, -0.12320974f, -0.09552170f, 0.05034193f, -0.11969138f, -0.36796162f, -0.54420751f, 
    -0.11319505f, 0.09048063f, 0.05822215f, 0.11185539f, 0.18355961f, -0.05834781f, 0.56572402f, -0.12002195f, 
    0.10754151f, 0.00243633f, 0.20944130f, -0.03832525f, -0.00572840f, 0.10565358f, 0.08695500f, -0.06676181f, 
    -0.16846763f, 0.28605261f, -0.14728102f, -0.10086081f, -0.00452574f, -0.02149275f, 0.11784709f, 0.09206296f, 
    -0.12863630f, -0.28221118f, 0.37039965f, -0.14025392f, 0.02136756f, -0.20121869f, -0.23306777f, -0.14919709f, 
    -0.21906915f, -0.20521998f, -0.13998556f, 0.24889515f, -0.10182610f, 0.20658886f, -0.02944923f, -0.24052595f, 
    -0.26206103f, -0.00593569f, -0.32211408f, -0.67608225f, 0.06365060f, 0.06291121f, 0.09140056f, -0.06055952f, 
    -0.01829813f, -0.02968838f, 0.10363801f, -0.49460953f, -0.07693233f, -0.30302611f, 0.25297073f, 0.17473426f, 
    0.20324121f, -0.10666253f, 0.24581388f, -0.34203359f, 0.05392120f, 0.11916654f, -0.12206887f, -0.24224021f, 
    -0.03921186f, -0.14252228f, -0.15464693f, -0.04017596f, -0.09666468f, -0.64374787f, -0.43927497f, -0.35435805f, 
    -0.35178921f, -0.01637526f, -0.08456734f, 0.04293122f, 0.04649627f, -0.08475798f, 0.02802038f, 0.28679284f, 
    0.37564737f, 0.10799337f, 0.00498453f, -0.14858519f, 0.51440012f, 0.09067794f, 0.15054180f, 0.01691217f, 
    -0.22478928f, -0.24673183f, -0.05472855f, 0.21567714f, -0.17870519f, -0.08168491f, 0.12969755f, 0.17532134f, 
    0.04770770f, -0.10974996f, -0.13461587f, 0.05327680f, -0.18608250f, -0.02971690f, 0.06789936f, -0.07792688f, 
    -0.01438800f, -0.10525785f, -0.55629808f, 0.28103465f, -0.12292308f, -0.09011089f, 0.01968876f, -0.02710227f, 
    0.15747911f, 0.01658539f, -0.30270538f, -0.10708597f, -0.20760524f, -0.02374778f, -0.49773690f, -0.07917654f, 
    -0.02228549f, -0.10067536f, -0.08554101f, -0.03980012f, 0.26260319f, 0.44337156f, -0.00472175f, 0.08983491f, 
    0.19950061f, 0.09832712f, -0.02417298f, 0.05735623f, 0.31794196f, 0.31014711f, -0.50504851f, 0.09949331f, 
    0.12134293f, 0.22876841f, 0.16406994f, -0.10456895f, -0.03340750f, -0.05209102f, -0.17496260f, 0.34841833f, 
    -0.08675676f, -0.10440543f, -0.16210222f, -0.05866885f, 0.01642397f, -0.19124475f, 0.10245181f, -0.31031376f, 
    0.22194311f, -0.01575395f, 0.06079897f, -0.04936927f, 0.11399315f, -0.13875890f, 0.01795582f, 0.17305836f, 
    0.33621958f, -0.03007244f, -0.08156577f, -0.20717077f, 0.09852514f, -0.40822440f, -0.11905021f, 0.16087143f, 
    -0.39415354f, -0.45698878f, -0.26576179f, 0.11660424f, -0.07646620f, -0.00021600f, 0.19955848f, 0.03426422f, 
    0.02868547f, -0.11349764f, -0.10263043f, -0.00305235f, -0.15744148f, -0.23877271f, 0.00917804f, 0.00458164f, 
    -0.01100063f, 0.15300654f, 0.28164417f, 0.26343197f, -0.13587254f, 0.23478951f, -0.03832294f, 0.07855149f, 
    -0.04512141f, 0.15184602f, -0.01252049f, 0.19535156f, 0.24777563f, 0.57335025f, 0.04484549f, 0.07767622f, 
    0.00206049f, 0.05912373f, -0.06674420f, 0.05410445f, -0.30045462f, 0.41592962f, -0.14615807f, 0.27891585f, 
    0.07552749f, 0.02000935f, -0.02425697f, -0.01026050f, -0.09543692f, 0.29299241f, 0.39441672f, 0.42168829f, 
    0.09221742f, 0.02294500f, -0.16326033f, 0.02587466f, -0.06561600f, -0.00765456f, -0.04244759f, -0.59414363f, 
    -0.66285485f, -0.14012475f, -0.09849561f, -0.25467169f, 0.00960473f, 0.07772029f, 0.04556910f, 0.10291018f, 
    -0.51164037f, -0.13184565f, 0.28566682f, 0.01991607f, -0.02089034f, 0.19997615f, 0.13597895f, -0.13936979f, 
    0.18734257f, 0.23152150f, -0.72330600f, 0.22934617f, 0.02052995f, 0.15186761f, 0.30898887f, -0.10783081f, 
    -0.37597600f, 0.01350406f, -0.06474845f, -0.77225006f, -0.09990764f, -0.11035506f, 0.13082685f, -0.25393462f, 
    0.18772767f, -0.29941562f, 0.12797497f, 0.18848780f, 0.66132843f, 0.03220407f, 0.11812084f, -0.04762948f, 
    0.13531503f, -0.17745854f, 0.03493790f, 0.24158111f, -0.59761190f, -0.31927803f, -0.12637672f, 0.15627234f, 
    0.06780442f, -0.12993884f, 0.15483564f, 0.02370577f, 0.08198252f, 0.10967483f, -0.13025941f, 0.02927654f, 
    0.12710696f, -0.07837342f, 0.04027706f, 0.01076101f, -0.22804850f, 0.38903809f, -0.30804569f, -0.33995044f, 
    -0.04243182f, 0.04463363f, 0.06382371f, -0.02924456f, 0.06914236f, -0.03371913f, 0.27609318f, 0.15408045f, 
    -0.79320937f, 0.17562440f, -0.09337824f, -0.04608789f, 0.23851842f, 0.13020594f, 0.09265821f, -0.06858332f, 
    -0.01475588f, 0.26790193f, -0.09841519f, 0.01060262f, -0.03433840f, 0.00039773f, 0.16205092f, -0.02640128f, 
    0.05267261f, -0.01264072f, -0.53353834f, 0.07468025f, 0.10562111f, 0.11469019f, -0.05983110f, 0.00698451f, 
    -0.16252273f, 0.56045359f, 0.20124169f, 0.63929641f, 0.03874162f, 0.13342191f, -0.16216606f, -0.28211173f, 
    0.17349122f, 0.16474466f, 0.45365539f, -0.03336044f, -0.13544276f, 0.33106974f, -0.09593875f, 0.06348910f, 
    0.04493075f, -0.31984499f, 0.02318419f, -0.72461045f, 0.17136182f, -0.95805955f, -0.38957474f, -0.10659254f, 
    -0.02259364f, 0.16697265f, 0.04759772f, -0.05439172f, 0.03676356f, 0.10909725f, 0.15791993f, -0.04562124f, 
    0.25453705f, -0.11663882f, -0.05773592f, -0.05725437f, -0.05816933f, -0.74864852f, -0.07560849f, -0.01939675f, 
    0.13590488f, -0.16448274f, 0.06008853f, -0.12665896f, -0.18847688f, -0.15485336f, -0.04838962f, -0.14249119f, 
    0.15391372f, 0.02806854f, 0.02774650f, 0.03279885f, 0.09973313f, -0.05355484f, -0.03578053f, 0.11939397f, 
    -0.28318378f, -0.40252465f, -0.15353788f, -0.02045384f, 0.01018810f, 0.05401451f, -0.02812388f, 0.00130987f, 
    -0.04746561f, -0.03365082f, 0.01309744f, -0.02111201f, -0.06250355f, -0.02235108f, -0.01254237f, 0.03260805f, 
    0.04502630f, 0.04096914f, -0.03384531f, -0.01394044f, -0.01573002f, 0.01496259f, -0.02584759f, -0.01197460f, 
    0.00258389f, -0.01831623f, -0.02358191f, -0.01828058f, 0.03082688f, 0.04319450f, -0.05639172f, -0.04715756f, 
    -0.05319675f, -0.00644689f, -0.04717623f, -0.01808229f, 0.01371756f, 0.00445787f, 0.04488990f, -0.06227489f, 
    0.00611389f, -0.00768915f, 0.04009493f, -0.05771976f, 0.01415964f, 0.02980807f, 0.04848392f, -0.04787480f, 
    -0.04486877f, 0.01619925f, -0.04014457f, 0.02873712f, -0.02125208f, 0.05212485f, 0.05594285f, -0.01680467f, 
    -0.01408512f, -0.05625168f, -0.06053613f, -0.04362043f, 0.04546389f, 0.04595712f, 0.00015472f, -0.03416669f, 
    -0.05686703f, 0.04902955f, 0.02150517f, 0.03899572f, -0.02543098f, -0.00456427f, 0.03056586f, -0.02608201f, 
    0.01260696f, -0.05583258f, 0.00302397f, -0.03915257f, 0.01248084f, -0.01546277f, 0.01432122f, 0.02704937f, 
    0.00202195f, -0.03245051f, -0.06210502f, 0.01179236f, -0.03702261f, -0.05733157f, -0.00374182f, -0.00783828f, 
    -0.03158187f, -0.03279545f, 0.01411140f, 0.03221742f, -0.01533401f, -0.05758324f, 0.03787978f, -0.02039456f, 
    -0.01451409f, 0.04370102f, -0.03916213f, 0.02583101f, -0.02066737f, -0.05004171f, -0.01786798f, 0.01167395f, 
    -0.06176101f, -0.03909533f, -0.02784038f, -0.01034195f, -0.05045744f, 0.02433165f, -0.06205916f, 0.01501984f, 
    0.01657170f, -0.05039906f, -0.05395309f, -0.02053742f, -0.02280395f, 0.02486612f, -0.04375486f, -0.05605176f, 
    -0.06471328f, 0.04071293f, 0.01335174f, 0.02252532f, -0.03752108f, 0.02496554f, 0.01612838f, -0.04400133f, 
    0.01147076f, 0.04561209f, 0.03937586f, -0.06153306f, 0.01555503f, -0.03183227f, 0.02043609f, -0.02765912f, 
    -0.05296351f, 0.00377546f, -0.05324103f, 0.01873694f, -0.05185216f, -0.01215062f, -0.00504208f, -0.04645851f, 
    -0.04824488f, 0.04242286f, -0.05912246f, -0.03970772f, -0.02752411f, 0.00319324f, 0.00158828f, 0.00035721f, 
    -0.04562052f, -0.00510223f, 0.03501045f, 0.02301332f, 0.03485604f, 0.03095437f, -0.02498842f, -0.05439827f, 
    -0.00487336f, 0.05520167f, 0.01254538f, 0.02894370f, -0.02482180f, -0.01083314f, 0.03412419f, 0.02958998f, 
    -0.00530647f, -0.04629313f, 0.03039399f, -0.03181328f, 0.02141128f, -0.01129086f, -0.01729565f, -0.04470557f, 
    0.01202532f, 0.03725135f, -0.05237933f, 0.02213608f, -0.02237637f, -0.04031362f, 0.03261135f, 0.00285546f, 
    0.01699355f, -0.03926622f, -0.03478400f, -0.06218075f, 0.00666032f, -0.04835998f, -0.05268278f, 0.02326683f, 
    -0.05967839f, -0.04114082f, 0.03835092f, -0.00180877f, 0.03720087f, -0.04094978f, -0.00271647f, -0.05228160f, 
    0.03651223f, -0.06504917f, -0.03307241f, 0.02514938f, -0.04608166f, -0.05078880f, -0.02877263f, 0.04372739f, 
    -0.03681567f, 0.00146784f, -0.02061759f, -0.01416888f, -0.02205249f, 0.00751468f, -0.03198913f, 0.00806304f, 
    -0.00906932f, -0.03468936f, 0.00098950f, 0.01708395f, 0.02507990f, -0.00865751f, 0.04941055f, -0.01033296f, 
    0.01373123f, 0.02271312f, -0.03908585f, -0.01291846f, -0.04299255f, -0.02412350f, -0.05801736f, -0.01877976f, 
    -0.02447571f, -0.02962996f, -0.00119000f, 0.05167770f, -0.01984710f, -0.06185946f, -0.00355098f, 0.04616628f, 
    -0.05251801f, -0.05925955f, -0.00876905f, 0.01824830f, -0.02792222f, -0.02544558f, 0.05303694f, 0.01654516f, 
    0.00658713f, -0.06506940f, 0.02572065f, 0.02673912f, -0.04343363f, -0.06470876f, -0.02823332f, 0.05755580f, 
    0.01964659f, -0.04302158f, -0.00676616f, 0.04260818f, -0.05269662f, -0.01749559f, -0.05594916f, 0.00839492f, 
    0.02834566f, -0.05040604f, 0.02107065f, -0.06233449f, -0.00019577f, -0.00777515f, 0.02845700f, -0.05730615f, 
    -0.04827933f, -0.03348654f, 0.04795210f, -0.05897457f, 0.02947805f, -0.01351998f, -0.05753291f, 0.00082772f, 
    0.00481401f, -0.01999711f, -0.00628801f, 0.02269164f, -0.00245084f, 0.01355647f, -0.05405807f, -0.01374529f, 
    0.01097703f, -0.02143126f, 0.04354004f, -0.04989187f, -0.04925524f, -0.02047732f, 0.01104893f, 0.01480577f, 
    0.16830327f, -0.08653690f, -0.07420462f, 0.07567729f, -0.03145344f, -0.08296794f, 0.00168908f, -0.07232857f, 
    -0.13503036f, -0.05745045f, -0.11073931f, -0.10754976f, -0.00433914f, -0.00302268f, 0.02732025f, -0.06653770f, 
    -0.26443675f, -0.14547260f, 0.05030669f, -0.07803742f, 0.05225937f, -0.01166929f, -0.00743929f, 0.13071160f, 
    -0.25819695f, -0.04843254f, -0.10130996f, -0.20038617f, 0.11849990f, 0.01028566f, -0.10020577f, -0.13186306f, 
    -0.09710838f, -0.03369439f, 0.08462042f, -0.18608958f, 0.11993093f, 0.00396419f, -0.05345958f, 0.30913690f, 
    0.04253871f, 0.07115896f, 0.02834548f, -0.03054454f, -0.07360178f, -0.00130727f, -0.01512509f, 0.04526296f, 
    0.02253766f, -0.00575172f, -0.09545915f, 0.22013548f, 0.07776699f, 0.17160738f, -0.25476903f, 0.36547658f, 
    -0.08315445f, 0.07380164f, 0.00497992f, 0.02718372f, -0.00464759f, 0.05368973f, -0.05350285f, 0.04992558f, 
    -0.04012069f, 0.11145163f, 0.22235291f, -0.02258828f, 0.00012781f, 0.08963981f, 0.03267910f, -0.34077516f, 
    0.01886487f, 0.04044823f, -0.06422104f, -0.08937337f, 0.03974888f, 0.21612942f, -0.36510476f, -0.37873846f, 
    -0.22157475f, 0.07688976f, 0.09118669f, 0.03849262f, 0.11914106f, -0.03637610f, 0.13103147f, 0.11968062f, 
    0.08907346f, 0.11759715f, 0.05532083f, -0.29536080f, 0.00260134f, 0.06483743f, 0.22933592f, 0.08463885f, 
    0.14007050f, 0.06999501f, 0.03115615f, -0.18047681f, 0.12616289f, 0.01705278f, 0.12639374f, -0.17103295f, 
    0.11134820f, -0.11015742f, -0.07582770f, -0.20869523f, 0.14922763f, -0.10044689f, -0.21619344f, -0.00403184f, 
    -0.01880268f, 0.11505470f, -0.22112668f, -0.03357931f, -0.22312768f, 0.04190350f, 0.30662182f, 0.25315085f, 
    -0.02296034f, -0.11719400f, -0.05826156f, 0.17268096f, -0.12315341f, 0.08943967f, 0.01966645f, -0.13039218f, 
    0.25363204f, 0.14778487f, 0.18539935f, 0.12393630f, 0.12506583f, -0.05953425f, -0.06084374f, -0.19095854f, 
    -0.05024452f, 0.09489418f, -0.00623572f, -0.30310282f, -0.14298941f, 0.01903796f, -0.32257587f, 0.20323978f, 
    0.01355806f, 0.11580010f, 0.09994968f, 0.10861315f, 0.09143765f, -0.04923775f, 0.09201358f, 0.21722965f, 
    -0.01023722f, 0.10701512f, -0.05406381f, -0.06933348f, 0.20693678f, 0.01349724f, 0.14467888f, 0.05756729f, 
    -0.01987590f, 0.02550673f, -0.47890186f, 0.07724636f, 0.14613190f, 0.01348344f, -0.10208717f, -0.05845088f, 
    0.15081984f, 0.06424577f, 0.11157097f, 0.17539987f, 0.29520398f, -0.14941449f, 0.04132982f, 0.04129440f, 
    -0.06859004f, -0.04867738f, -0.07136566f, -0.13796809f, 0.15008934f, -0.13741493f, -0.00723825f, -0.07135917f, 
    0.14844128f, -0.01818054f, 0.24965715f, -0.05273348f, 0.05690366f, 0.15307680f, -0.04861740f, -0.08205462f, 
    0.17838030f, 0.08189001f, 0.02697811f, 0.04157583f, -0.02607594f, -0.28503463f, 0.22443114f, -0.04465500f, 
    -0.05401755f, 0.14549993f, 0.15189102f, -0.05760859f, 0.04367083f, 0.07444333f, -0.09949400f, -0.39084825f, 
    0.14825174f, 0.31495050f, -0.04092297f, -0.14093028f, -0.13157691f, 0.04571436f, 0.06962126f, -0.19589719f, 
    0.05823046f, -0.07365445f, 0.27607355f, 0.23479728f, 0.08110552f, 0.10156648f, 0.15592369f, 0.11364611f, 
    0.14717118f, 0.05709127f, 0.07645049f, -0.08808259f, 0.24812885f, 0.16604948f, 0.01015640f, 0.13058017f, 
    0.22611828f, 0.11016732f, 0.09646671f, 0.02058173f, 0.02459045f, 0.14795004f, 0.04148423f, 0.07506114f, 
    0.06952179f, -0.00917814f, -0.08521120f, -0.09132974f, -0.14829098f, -0.13522314f, 0.29596853f, 0.09682314f, 
    0.16874176f, 0.09347305f, -0.07509338f, -0.32421407f, 0.23771511f, 0.21013159f, 0.15196551f, -0.03256181f, 
    0.14258380f, 0.02931422f, 0.16276529f, 0.12449951f, -0.07887978f, 0.27564299f, 0.05829739f, 0.12266646f, 
    0.34274516f, 0.10186046f, 0.39992002f, 0.14033805f, -0.17853965f, 0.16386686f, -0.25539991f, -0.04584384f, 
    0.18983300f, -0.20636651f, -0.21838745f, 0.00079026f, -0.16445178f, -0.30908763f, -0.33740553f, 0.18056934f, 
    -0.17085849f, -0.09545138f, 0.25003341f, 0.04118118f, 0.03624709f, -0.05036116f, 0.00383868f, -0.02007462f, 
    0.19701229f, 0.05319291f, 0.09155083f, -0.06628846f, -0.03784260f, -0.00195675f, -0.08043163f, -0.03000918f, 
    0.28511828f, 0.18640223f, 0.00093827f, 0.46790633f, 0.08248947f, -0.00531006f, 0.02152810f, 0.01157327f, 
    0.07281277f, -0.00160281f, -0.39080980f, 0.16645589f, 0.02775157f, -0.10181246f, -0.20326483f, -0.09657847f, 
    -0.11769640f, 0.03743490f, 0.31474671f, -0.00219391f, -0.07187346f, -0.06255154f, -0.02554997f, 0.14096542f, 
    0.12211024f, 0.14401667f, 0.08555451f, -0.01116978f, 0.27121335f, 0.21567863f, 0.03702473f, -0.11305980f, 
    0.07474773f, -0.09018127f, 0.03549463f, 0.07753470f, -0.00112691f, 0.00397294f, -0.21287438f, -0.05686915f, 
    0.02364267f, 0.05696016f, -0.11808116f, 0.21352583f, 0.11761766f, 0.02425862f, -0.25672719f, -0.47448519f, 
    -0.50978351f, -0.11405418f, 0.05978844f, 0.11204983f, -0.07577025f, -0.08472783f, -0.05011484f, 0.09587827f, 
    0.31531119f, 0.23954359f, -0.03559724f, -0.07252540f, -0.06567279f, -0.06390753f, -0.08080380f, -0.11205797f, 
    -0.27677163f, -0.03805826f, -0.36617798f, -0.11083021f, -0.06112466f, -0.09633689f, -0.04838559f, -0.09718914f, 
    0.18883310f, 0.07258642f, -0.08641561f, -0.26024398f, -0.00601128f, 0.07550026f, 0.02635596f, 0.25243700f, 
    0.07164624f, 0.06043349f, 0.87937099f, 0.24168703f, 0.18378867f, 0.11093513f, -0.24433658f, -0.18434845f, 
    -0.01395103f, 0.01522497f, 0.05455438f, 0.27598217f, -0.18116540f, 0.28903523f, 0.09630659f, 0.15227357f, 
    0.24746628f, 0.08383286f, -0.07711689f, 0.19985950f, 0.12251058f, -0.58918571f, 0.29978040f, 0.06736823f, 
    -0.04680343f, -0.02749233f, 0.16357280f, -0.12471922f, -0.13135524f, 0.10904457f, -0.06313111f, -0.12365366f, 
    -0.03772789f, -0.01375633f, -0.05595313f, -0.00715522f, 0.10563873f, 0.08560098f, 0.59685320f, 0.05611616f, 
    0.29137707f, -0.04086926f, -0.04824449f, -0.24622039f, -0.03134266f, 0.08989617f, 0.10937740f, -0.06992175f, 
    0.11025263f, 0.17550933f, 0.03451025f, -0.10017274f, 0.02165642f, -0.00308066f, 0.05380983f, -0.20097220f, 
    -0.17691261f, -0.20302649f, -0.18624561f, -0.16365610f, -0.10977057f, -0.04715346f, -0.03763942f, 0.23993389f, 
    -0.03805476f, 0.14976069f, -0.02309411f, -0.09323072f, -0.08151912f, 0.06668903f, -0.00680231f, 0.21683635f, 
    0.13500054f, 0.10978189f, -0.02479046f, -0.25540450f, 0.02643311f, -0.18476085f, -0.13813388f, -0.21062744f, 
    0.07117555f, 0.07780579f, 0.07600124f, -0.60639703f, -0.30532581f, -0.48562041f, -0.50162321f, 0.18135448f, 
    0.26211753f, -0.06650642f, -0.29434139f, -0.01770888f, 0.31961876f, -0.21510498f, 0.15723455f, 0.12684663f, 
    0.04226005f, 0.03229988f, 0.05047021f, 0.27484953f, 0.06497303f, 0.39416352f, 0.20712589f, 0.14694028f, 
    -0.14671710f, -0.13593465f, -0.04080638f, 0.15828170f, -0.01847112f, 0.10985978f, 0.03582831f, -0.18516657f, 
    0.03569784f, -0.13879709f, 0.02088853f, 0.05195875f, -0.04419371f, 0.05538854f, 0.11295819f, -0.56225878f, 
    -0.14253208f, 0.46037725f, -0.19887590f, -0.00585333f, -0.31352985f, 0.25090000f, -0.08650870f, 0.06414737f, 
    0.17348540f, 0.35691231f, 0.30878636f, -0.25934637f, -0.16179021f, -0.18728743f, -0.07373127f, 0.18484071f, 
    0.02150496f, -0.15913573f, -0.10463781f, 0.16221371f, -0.40356767f, -0.03586845f, -0.23744480f, 0.05235608f, 
    0.11333422f, -0.01510218f, -0.04078351f, 0.24706498f, 0.10610878f, -0.11138716f, 0.00476750f, -0.11383518f, 
    -0.10367218f, 0.03397800f, 0.07767326f, -0.10629364f, -0.19302027f, -0.41707933f, 0.16945136f, -0.25332269f, 
    -0.18020821f, 0.17389597f, 0.00571255f, -0.42255786f, 0.02697791f, 0.12462284f, 0.26930302f, 0.00526186f, 
    -0.03329186f, -0.03480704f, 0.05101620f, -0.05268817f, 0.19377397f, -0.24545620f, -0.08156870f, 0.08063588f, 
    -0.01576661f, 0.11644323f, -0.23152836f, 0.25402588f, 0.19827189f, -0.22228496f, 0.02308997f, -0.20108244f, 
    -0.35145032f, 0.08601219f, 0.00544758f, 0.17875625f, 0.01761173f, -0.07368083f, 0.21224014f, 0.28895727f, 
    0.02288980f, -0.15790105f, -0.00640149f, 0.14913404f, 0.09167761f, -0.04185112f, 0.04668967f, 0.01610443f, 
    -0.35709709f, -0.08543216f, 0.17853671f, -0.14456400f, -0.19933574f, -0.15958753f, 0.03293204f, -0.17024755f, 
    -0.02429788f, -0.33419666f, -0.29043710f, 0.39948970f, -0.08900550f, 0.07305156f, -0.09364054f, -0.16965072f, 
    -0.02700966f, 0.12711869f, -0.48876977f, -0.22866853f, 0.35640392f, -0.01931629f, -0.23387940f, -0.05152662f, 
    0.01538358f, -0.16401047f, 0.17430073f, 0.16639681f, 0.25605100f, 0.20643526f, 0.00444702f, 0.07250694f, 
    0.24029197f, 0.06530970f, 0.07912534f, 0.15208556f, -0.15966202f, 0.01468034f, -0.27766797f, 0.21753787f, 
    -0.05453388f, -0.06962522f, 0.14267881f, 0.03648891f, 0.27394849f, -0.10065027f, 0.02303051f, 0.07701932f, 
    0.00804410f, -0.19361280f, -0.10365736f, 0.10754894f, 0.06706971f, 0.34030294f, 0.34875384f, 0.21860357f, 
    0.11185346f, -0.00313928f, 0.04521264f, 0.06217832f, -0.04019681f, 0.01100166f, -0.05813390f, -0.73357862f, 
    -0.78372902f, 0.24433072f, 0.19939731f, -0.10785852f, 0.07568387f, -0.20380154f, 0.22002092f, 0.08148967f, 
    0.16889809f, -0.04664222f, -0.04588810f, -0.29707325f, -0.20298529f, -0.07812565f, 0.15838140f, 0.07576417f, 
    0.18864915f, 0.23718250f, -0.13337301f, -0.01713533f, -0.12964164f, -0.10640733f, -0.09242319f, 0.15234330f, 
    -0.01145266f, 0.24173121f, -0.00866910f, -0.32668534f, 0.15931442f, 0.14107740f, 0.25622940f, 0.01232697f, 
    -0.00423706f, -0.02898576f, 0.01841105f, 0.17082284f, 0.22482423f, 0.34797564f, -0.05541515f, 0.14697395f, 
    -0.00820881f, 0.01703797f, 0.14703612f, -0.08035748f, -0.18865569f, 0.09539444f, -0.12066996f, -0.08913928f, 
    0.10473161f, 0.00972110f, 0.03889551f, -0.09530535f, 0.06402976f, 0.34552193f, 0.69590861f, 0.32327494f, 
    -0.13836204f, -0.03774981f, 0.03427129f, 0.10504999f, -0.02555253f, 0.22846249f, -0.23323920f, -1.09688997f, 
    -0.37725061f, -0.24151008f, 0.15382752f, -0.08202639f, 0.15642484f, 0.06280989f, 0.10975348f, -0.04877480f, 
    -0.06053349f, 0.13108626f, -0.14533560f, -0.20809703f, -0.19436538f, 0.20954113f, 0.11961179f, 0.11486183f, 
    0.71128106f, -0.06331014f, -0.25591320f, -0.14991760f, 0.15000305f, 0.01412398f, 0.19102529f, 0.40352601f, 
    0.16130798f, 0.27016962f, -0.11903079f, -0.34700716f, 0.08210333f, -0.12480555f, 0.00109343f, 0.20497940f, 
    -0.02551451f, 0.23032169f, 0.35344276f, 0.59136128f, 0.41011807f, -0.09900229f, 0.24828811f, -0.15241240f, 
    0.00951285f, 0.06277942f, 0.09361379f, 0.23360227f, -0.64283276f, -0.75942087f, -0.18523039f, -0.09877200f, 
    -0.04204474f, 0.07432846f, 0.01822233f, 0.00516757f, 0.25259778f, 0.11038528f, -0.35827208f, -0.10485921f, 
    0.02452369f, 0.01726532f, 0.28134829f, -0.06539971f, 0.09421638f, -0.48606536f, -0.54905903f, 0.01056155f, 
    0.05734496f, 0.23968333f, -0.16074961f, -0.03823262f, -0.00919187f, -0.10063504f, -0.35517105f, -0.43944308f, 
    -0.95160419f, -0.16122063f, 0.03550610f, -0.13647771f, 0.16004221f, 0.10774399f, -0.10284306f, -0.15708491f, 
    0.05218185f, 0.43424603f, -0.19045201f, -0.15409142f, -0.29775426f, -0.09579883f, 0.14608942f, 0.01975543f, 
    0.00040583f, -0.49938372f, 0.03291940f, 0.11461990f, -0.17984022f, -0.10780084f, -0.04758425f, 0.25572252f, 
    -0.11511197f, 0.13952449f, 0.60757512f, 0.25151506f, -0.06577190f, 0.03155134f, -0.09911355f, 0.07386424f, 
    0.03761159f, 0.37939820f, -0.79134357f, -0.12307167f, -0.09679315f, 0.23204164f, -0.14807394f, -0.42037225f, 
    -0.09989751f, 0.07707493f, 0.08656805f, -0.56788677f, -0.87880164f, -0.55743670f, -0.31774577f, -0.14954230f, 
    -0.04609945f, -0.01106393f, 0.30737361f, 0.18570688f, 0.04372455f, -0.01791889f, 0.33299986f, -0.23903023f, 
    -0.03164073f, -0.27799749f, -0.01026495f, -0.12137068f, 0.07721924f, -0.74604142f, 0.35998902f, -0.28599930f, 
    -0.21506003f, -0.02201960f, 0.01918586f, 0.15703095f, 0.17765529f, 0.40460864f, 0.40418974f, -0.11606145f, 
    0.00302006f, 0.10255288f, -0.11645078f, 0.15123732f, 0.19676465f, -0.02407224f, 0.00926431f, -0.49351037f, 
    -0.45085418f, -0.44260705f, -0.00265419f, -0.00948931f, 0.00620997f, 0.14098547f, -0.01400564f, 0.10551048f, 
    0.11677191f, 0.13275073f, 0.13608886f, -0.06816606f, 0.16105036f, 0.00598140f, 0.01081974f, 0.21152598f, 
    -0.05692560f, -0.38152280f, 0.36842892f, 0.26099205f, -0.03448683f, -0.11400542f, -0.14554459f, 0.03495865f, 
    0.18220721f, -0.00860459f, -0.06576297f, 0.00356413f, -0.05058191f, 0.04713918f, 0.02425213f, -0.23541954f, 
    0.01205875f, -0.08093424f, 0.02065180f, 0.06504087f, 0.02827839f, 0.12659007f, 0.00015500f, -0.00717406f, 
    -0.15582931f, 0.02233753f, 0.27260283f, -0.00541016f, 0.16951370f, 0.14509758f, 0.04340120f, 0.18112656f, 
    -0.05542288f, 0.05132853f, 0.10335875f, -0.04623592f, -0.02531253f, 0.13049383f, 0.10703366f, 0.00293955f, 
    0.11959523f, 0.09026350f, 0.08339967f, -0.00137698f, 0.05006518f, 0.11145002f, 0.13934843f, -0.13864435f, 
    -0.34410581f, -0.17444552f, -0.11099170f, -0.01119427f, 0.04269563f, 0.01332692f, -0.09766071f, 0.07482739f, 
    0.28920734f, 0.04924965f, -0.02415581f, -0.17544812f, -0.05924556f, 0.01995685f, -0.06454284f, 0.13887639f, 
    0.04382911f, -0.21758753f, 0.03749246f, -0.08749910f, -0.26371467f, -0.33449283f, -0.22218893f, -0.10104368f, 
    -0.16128190f, 0.03829654f, 0.00605066f, -0.12655021f, 0.06667555f, -0.12964658f, 0.04701929f, 0.00441343f, 
    -0.15639567f, 0.00327439f, -0.26016626f, 0.32192245f, -0.09845838f, 0.03544435f, -0.08975215f, 0.00575955f, 
    0.07136279f, -0.17132524f, -0.06161394f, -0.51261479f, -0.11114744f, -0.06441454f, 0.06933047f, 0.12270155f, 
    0.00561333f, -0.07296118f, 0.01483340f, -0.08031875f, -0.11516044f, 0.22931789f, -0.26044819f, -0.03408692f, 
    -0.12551351f, 0.23560013f, -0.13372609f, 0.07474866f, 0.18981299f, -0.04722515f, 0.20026174f, -0.24406241f, 
    -0.02699426f, 0.21328847f, -0.13111639f, -0.02176969f, 0.03704939f, -0.32146704f, -0.04341876f, 0.28126606f, 
    0.02076780f, 0.01630717f, -0.06935768f, 0.03050431f, 0.11172915f, -0.03226909f, 0.21155980f, 0.10876866f, 
    0.37169015f, 0.05063076f, -0.10925163f, -0.00096933f, -0.33768958f, 0.17670988f, 0.22475839f, -0.34407389f, 
    -0.03192216f, -0.14506835f, 0.07819570f, 0.33638093f, -0.00802774f, 0.31799641f, 0.12710600f, -0.02622449f, 
    0.00560155f, 0.09832712f, 0.09593575f, 0.05944056f, 0.18352342f, -0.13168228f, 0.02596400f, 0.05486029f, 
    -0.10213626f, 0.02991519f, 0.27183986f, 0.13829164f, 0.13344590f, -0.03940379f, 0.13480671f, 0.06975941f, 
    0.16198702f, 0.06272838f, -0.11079808f, 0.06914707f, -0.33649865f, -0.13992490f, -0.37715349f, -0.18326606f, 
    -0.16024117f, -0.09687501f, 0.12729974f, -0.22602111f, 0.00937948f, 0.20006812f, 0.10491043f, 0.17859928f, 
    0.13489942f, 0.19228002f, 0.07992656f, 0.03766720f, 0.18458878f, 0.06636252f, 0.17402837f, -0.01397763f, 
    0.02458727f, 0.03056630f, 0.00682025f, 0.02520713f, 0.05393821f, 0.11269297f, -0.10111819f, -0.03461465f, 
    0.38557833f, -0.04244650f, -0.00103947f, 0.05030168f, -0.06681447f, 0.11317757f, 0.39013967f, -0.13620494f, 
    -0.06022679f, 0.40295145f, -0.05745284f, 0.11271282f, -0.04554153f, -0.07672038f, 0.00235724f, 0.09660169f, 
    0.06797563f, 0.39119121f, 0.38990358f, -0.10852120f, -0.15215452f, 0.01444603f, 0.06715506f, -0.04786051f, 
    -0.00404717f, 0.12320014f, -0.09009319f, 0.47731647f, -0.13796966f, 0.08027992f, 0.09809773f, 0.05239667f, 
    0.00755280f, 0.25472417f, 0.11109250f, 0.12691909f, 0.26600769f, 0.02798948f, -0.09362432f, -0.10646098f, 
    -0.03829708f, -0.05636489f, 0.13274311f, -0.63075328f, 0.48075208f, -0.46315846f, -0.09625536f, -0.02982530f, 
    0.66692758f, -0.03691305f, 0.07542279f, 0.04977189f, -0.35318995f, 0.01974184f, 0.11075684f, -0.06243595f, 
    0.15850839f, 0.02378752f, -0.07320135f, 0.00047047f, 0.09366356f, 0.12377139f, -0.23709700f, 0.28032854f, 
    0.16890660f, -0.41684219f, -0.14393957f, 0.25885883f, -0.03514812f, -0.08209473f, -0.15129562f, -0.08874398f, 
    -0.20419735f, 0.03421459f, -0.12951049f, -0.25922614f, -0.16438389f, 0.09633797f, 0.07732188f, 0.18230538f, 
    0.16459830f, 0.01620978f, -0.11898539f, 0.07631548f, 0.14669967f, 0.04563583f, 0.12867787f, -0.01322259f, 
    0.12365870f, 0.12374600f, 0.20646860f, 0.06742375f, 0.11122847f, -0.00589979f, 0.16012362f, 0.25760633f, 
    0.08541430f, 0.09719668f, -0.01392367f, 0.11080243f, 0.06475254f, 0.12320991f, 0.03645638f, 0.03797438f, 
    0.10223074f, 0.27788800f, -0.25544068f, -0.00800864f, -0.02310844f, -0.05783901f, 0.05083652f, -0.16186170f, 
    -0.25611964f, -0.11493026f, 0.13803028f, -0.14120945f, -0.07744043f, 0.06663235f, -0.07929015f, -0.02056217f, 
    0.01060895f, 0.04567293f, 0.09438872f, 0.06348159f, -0.20870847f, 0.00990418f, -0.03047354f, -0.14986871f, 
    -0.14416547f, -0.11605681f, -0.00198142f, 0.14227229f, 0.08105909f, -0.25008139f, -0.08821308f, -0.18462025f, 
    -0.13889275f, -0.00351037f, -0.05459288f, 0.11356102f, 0.16934502f, 0.20970614f, -0.26193681f, -0.10972463f, 
    0.24186927f, -0.09257019f, -0.03938814f, -0.16974276f, -0.18157318f, 0.05889669f, 0.06793744f, -0.30598888f, 
    -0.20922591f, -0.19167647f, -0.22268160f, 0.01817007f, -0.31155604f, 0.06738783f, 0.05263035f, -0.19575086f, 
    -0.01069122f, 0.00225559f, -0.03889802f, 0.07014697f, -0.11689358f, -0.01124870f, -0.00085894f, -0.05326881f, 
    -0.07621965f, -0.11069553f, -0.05368280f, -0.04260203f, 0.15143390f, -0.01638059f, -0.05872647f, -0.02193007f, 
    0.10269243f, 0.24399745f, -0.01618301f, -0.32762083f, -0.71251971f, 0.04179929f, -0.00391518f, -0.05394987f, 
    -0.03407413f, 0.02025042f, -0.05594014f, 0.17154472f, -0.04094815f, 0.33211437f, 0.10323987f, 0.05505088f, 
    0.18611470f, 0.02294487f, 0.17405342f, 0.24593081f, -0.15797220f, -0.44397908f, -0.46412992f, 0.04658648f, 
    0.00603042f, 0.37210178f, 0.05520160f, 0.01605907f, 0.07458862f, -0.34665611f, 0.05610129f, -0.26205200f, 
    -0.13762452f, 0.06763033f, -0.12268022f, 0.22160657f, 0.00528013f, 0.06786513f, 0.00397666f, -0.15467840f, 
    -0.66838503f, -0.04521375f, -0.04399801f, 0.02429437f, -0.07609143f, -0.06697226f, 0.11603174f, -0.22375284f, 
    -0.09095545f, 0.36717236f, 0.11276510f, 0.05704067f, -0.21542439f, 0.37826827f, 0.22268605f, -0.04425921f, 
    -0.41129267f, 0.27856332f, -0.17037269f, -0.15896593f, -0.04822493f, 0.24414867f, 0.04386435f, 0.26150101f, 
    0.14691985f, -0.21146221f, -0.04749001f, -0.10673068f, 0.05874714f, -0.19825330f, -0.13288333f, 0.01212109f, 
    0.10210419f, 0.27543110f, -0.66687381f, -0.30502820f, -0.16195944f, -0.26695201f, -0.20298396f, -0.08029207f, 
    0.10097568f, 0.02138110f, -0.00552893f, 0.14412692f, -0.17177711f, -0.00892134f, -0.09386397f, -0.39022392f, 
    0.00694401f, -0.08368275f, -0.09909149f, 0.09090253f, 0.07792573f, 0.23433125f, 0.04935642f, 0.25802046f, 
    0.06272107f, 0.28568083f, 0.17068835f, 0.21090758f, 0.09351236f, 0.19076163f, -0.30780044f, 0.17058499f, 
    0.07514349f, 0.02614988f, 0.10096391f, 0.14779332f, -0.06250984f, 0.08568909f, 0.10494750f, -0.22599936f, 
    -0.12396698f, 0.00161289f, -0.14738317f, 0.08043141f, 0.00224131f, 0.02377925f, -0.16117185f, -0.31818709f, 
    -0.20346080f, -0.04971405f, 0.10428987f, 0.14519246f, -0.08585131f, 0.26791811f, -0.01156371f, 0.07782797f, 
    -0.26701456f, -0.01314940f, -0.56554407f, -0.19983073f, 0.02230310f, -0.18167748f, 0.00710538f, 0.14535893f, 
    0.14004856f, -0.06758896f, -0.41688460f, 0.00983808f, 0.04725823f, 0.30326971f, -0.14257763f, 0.15206553f, 
    -0.01479666f, 0.07866473f, -0.06890058f, -0.04515089f, -0.01788165f, -0.19070673f, 0.04328142f, -0.17899279f, 
    -0.13926362f, 0.11247155f, -0.00646884f, -0.92931277f, 0.34697056f, -0.32629180f, 0.51824343f, -0.10888067f, 
    0.11975719f, 0.11062937f, 0.32256174f, 0.07269013f, 0.54361951f, 0.12865701f, -0.53955364f, 0.06113911f, 
    0.10062659f, 0.17698959f, 0.19632885f, 0.20198634f, 0.19826803f, -0.20711219f, 0.04329029f, 0.12585764f, 
    0.24226815f, 0.06807560f, 0.06016210f, 0.24459697f, 0.33025423f, 0.01112075f, 0.21557553f, 0.13024285f, 
    -0.04901737f, 0.01572564f, -0.14138693f, 0.19207627f, -0.02721803f, -0.09094996f, 0.00502878f, 0.16778840f, 
    0.06488185f, 0.11907197f, 0.22668870f, 0.11500877f, 0.03030231f, -0.01745285f, 0.10721928f, 0.10869172f, 
    -0.28797978f, -0.08934283f, -0.29449373f, 0.14330634f, -0.08624955f, -0.02811846f, -0.04282388f, 0.10704663f, 
    0.15760078f, -0.18489371f, -0.49213007f, -0.01863064f, 0.10083848f, -0.05833086f, -0.18065429f, 0.19539194f, 
    0.09867159f, -0.17482160f, 0.33292112f, -0.06288665f, -0.12447449f, 0.13802411f, 0.10642666f, 0.13878702f, 
    -0.07535552f, 0.00251466f, 0.11500423f, 0.34349677f, 0.13360219f, 0.00562786f, 0.05433161f, 0.05164165f, 
    0.00504781f, -0.00559532f, -0.01393920f, -0.02497818f, -0.05561715f, -0.15854684f, -0.04412087f, 0.00555961f, 
    -0.10177214f, 0.01949334f, -0.05024073f, -0.01338857f, 0.10567183f, 0.03871492f, -0.07287195f, 0.03126914f, 
    0.03046704f, 0.08650088f, 0.11151470f, -0.05165815f, -0.20410383f, 0.10593864f, -0.23498309f, -0.25192514f, 
    -0.06596743f, 0.37490669f, 0.35871866f, 0.08924172f, 0.10784760f, 0.03145146f, 0.10947946f, 0.07227235f, 
    -0.66480678f, -0.11611535f, 0.01228880f, 0.00057110f, 0.04427401f, 0.03908460f, -0.15616944f, 0.17336677f, 
    0.32398528f, 0.12077364f, -0.00922723f, 0.08001558f, 0.15189828f, 0.25723836f, -0.04614821f, -0.00476662f, 
    -0.10077239f, -0.18406142f, -0.26503932f, -0.13387498f, 0.03232063f, 0.05049197f, 0.06510548f, 0.00351451f, 
    0.15775700f, -0.17781071f, -0.28614712f, -0.33170897f, 0.13786082f, -0.22047579f, -0.31497988f, -0.15608403f, 
    -0.04974654f, 0.12448153f, 0.05335015f, 0.14929183f, 0.04317479f, -0.19552778f, -0.11864904f, 0.03448354f, 
    -0.18721554f, -0.07350231f, 0.05322548f, -0.14635809f, 0.41406575f, 0.11243019f, 0.26604009f, -0.10256508f, 
    0.14319582f, -0.04184494f, -0.12917785f, -0.19011822f, 0.03778075f, 0.37080333f, 0.28416777f, 0.01514365f, 
    0.23101833f, 0.02575608f, -0.12200815f, 0.07406580f, 0.09311493f, -0.10917234f, -0.20582914f, -0.09200344f, 
    0.18970130f, 0.07252049f, -0.43471327f, -0.45329237f, 0.04645503f, 0.17910916f, 0.12697883f, -0.32689989f, 
    -0.23248850f, 0.12631357f, 0.34711814f, 0.20838368f, 0.02827518f, -0.02381187f, 0.00865375f, -0.03351252f, 
    0.17266622f, 0.17112023f, -0.10365260f, 0.06656313f, 0.13649110f, -0.03648145f, -0.23072131f, -0.26892799f, 
    -0.01506822f, -0.02440583f, -0.09927141f, 0.06490320f, 0.03466072f, -0.09212774f, 0.11346273f, 0.01918491f, 
    -0.02905554f, -0.49240297f, 0.48895058f, 0.36492380f, 0.16173066f, 0.29248336f, -0.00263164f, 0.25841218f, 
    0.09939765f, -0.00514517f, -0.09769762f, -0.29948854f, 0.57566923f, -0.40301487f, 0.18145220f, 0.24977730f, 
    -0.06523551f, 0.05558256f, 0.07981504f, 0.03375687f, -0.02993619f, -0.04490072f, 0.03222932f, 0.03174979f, 
    -0.17921403f, 0.26829523f, -0.03540163f, 0.06253177f, -0.06610238f, -0.34297863f, -0.40300429f, -0.18838514f, 
    -0.28169128f, -0.09270960f, -0.20589966f, 0.10872631f, 0.05456518f, 0.24626508f, 0.34635559f, 0.07417187f, 
    -0.26241383f, 0.06747634f, -0.06278038f, 0.02166672f, -0.06371217f, 0.02482362f, -0.01501729f, 0.20626767f, 
    0.45119375f, -0.14133669f, -0.07672227f, 0.11780372f, 0.11376248f, -0.14127390f, -0.17637773f, 0.03688140f, 
    0.02970323f, 0.02199433f, 0.00077992f, -0.10553733f, -0.20475708f, -0.48376414f, -0.03900357f, -0.03790733f, 
    0.12839417f, -0.02408265f, 0.10676789f, -0.14684746f, 0.02921495f, -0.02811387f, 0.32238817f, -0.27204174f, 
    0.06288478f, 0.11355671f, -0.10958447f, -0.44717622f, -0.18296804f, 0.02593547f, 0.03713457f, 0.01102517f, 
    -0.04065396f, 0.05619807f, 0.00792066f, 0.11663545f, 0.38740897f, -0.18133868f, -0.00447028f, -0.19528314f, 
    0.00142399f, -0.12247801f, -0.18758343f, 0.09721576f, 0.09354592f, 0.19328949f, -0.17325349f, -0.29182380f, 
    -0.33249059f, 0.07292499f, -0.07732641f, 0.03870102f, 0.07753748f, 0.07314999f, -0.20891365f, -0.61932808f, 
    -0.05117592f, 0.08182961f, 0.07173307f, -0.15929177f, -0.12840118f, -0.12252820f, 0.19107814f, 0.21021098f, 
    -0.08621885f, 0.26131141f, 0.09527266f, 0.23204486f, -0.00541183f, 0.12138744f, -0.11873801f, -0.18960737f, 
    -0.20980619f, -0.27959576f, -0.05792470f, -0.03204808f, 0.09580740f, -0.28574550f, 0.24425699f, -0.15679596f, 
    0.20831457f, 0.14648797f, 0.05275228f, 0.06951538f, 0.01526546f, 0.00422812f, 0.08521754f, -0.09812444f, 
    0.09212604f, 0.08179993f, -0.06602897f, -0.00831340f, 0.04683227f, 0.32769641f, 0.09621016f, 0.18086194f, 
    0.10406876f, -0.00989100f, -0.15505996f, 0.17842606f, 0.12751105f, -0.02334392f, 0.06223750f, 0.06872651f, 
    0.05656166f, 0.14038110f, 0.15906578f, -0.00335461f, 0.22393930f, -0.00672098f, 0.08995478f, -0.13751908f, 
    -0.08318038f, 0.04317951f, 0.10742518f, 0.18475305f, 0.07723122f, 0.07503766f, 0.19359486f, 0.12177315f, 
    -0.05238249f, 0.10696932f, 0.12853101f, -0.03578266f, -0.04274619f, 0.05428663f, 0.00206881f, 0.03757011f, 
    0.05095024f, -0.07396179f, 0.18650331f, -0.27022919f, -0.23536548f, 0.05109957f, 0.05440623f, 0.24935050f, 
    0.44678918f, -0.39250809f, -0.00935116f, -0.03873796f, 0.25497508f, -0.05522807f, 0.03507069f, 0.13448276f, 
    -0.12033966f, -0.10347667f, -0.12757970f, -0.05088701f, -0.03908623f, 0.11666106f, -0.01979461f, 0.01082242f, 
    -0.16442083f, -0.00787477f, 0.27492586f, 0.09703399f, 0.12094229f, 0.07880400f, 0.21530502f, -0.02147117f, 
    0.03392387f, -0.01407475f, -0.02340545f, 0.11303567f, -0.04650460f, -0.17093760f, -0.05288185f, 0.10659941f, 
    -0.45198694f, -0.20274812f, 0.02647061f, 0.25486282f, 0.16850497f, -0.02681231f, -0.05185244f, 0.20494945f, 
    0.01765084f, -0.01932590f, 0.00483727f, -0.30108470f, -0.15938567f, -0.19438905f, 0.01584025f, 0.15849724f, 
    -0.00575257f, -0.00976352f, 0.01155468f, -0.10341800f, -0.34221196f, -0.47631231f, -0.31433743f, 0.08386299f, 
    -0.14106466f, -0.01949656f, -0.08565473f, 0.15145013f, 0.23077095f, -0.06242368f, 0.01812210f, -0.29494438f, 
    -0.20859024f, 0.09633429f, -0.04905513f, -0.09084085f, -0.03925939f, -0.03016223f, 0.04878313f, 0.19597547f, 
    0.14820620f, 0.20319925f, -0.13740000f, 0.17545566f, 0.04202660f, -0.20721890f, 0.00394685f, 0.20503412f, 
    0.17894551f, 0.43579683f, -0.15390915f, 0.00272020f, 0.02159831f, 0.12141479f, -0.13608195f, -0.03861050f, 
    0.13153987f, -0.08044347f, -0.15658049f, 0.31258100f, 0.11172753f, -0.26507962f, -0.21976119f, -0.25703904f, 
    -0.14516915f, 0.05330044f, 0.01863749f, 0.10729552f, 0.07253774f, -0.09915249f, -0.02233228f, 0.04938281f, 
    -0.41216198f, -0.00659685f, 0.20671321f, 0.19427422f, 0.10825361f, -0.30405828f, -0.07749384f, -0.02462842f, 
    0.06786708f, -0.03748282f, -0.04096389f, -0.08227446f, 0.37146109f, 0.25575534f, -0.08032718f, -0.01180061f, 
    -0.06594992f, 0.04396011f, 0.19277428f, -0.28200454f, -0.09786230f, 0.06324065f, -0.03959913f, 0.04031974f, 
    0.14840369f, 0.13881677f, 0.01430745f, -0.30521265f, 0.08829278f, 0.25559625f, 0.36797041f, -0.07855409f, 
    0.00245791f, 0.05846210f, -0.00997386f, -0.00319625f, 0.03737694f, 0.04473494f, -0.28479436f, -0.01901349f, 
    0.07632515f, -0.03929578f, 0.00651007f, 0.00710776f, -0.12126682f, 0.19585185f, -0.05142116f, -0.00877230f, 
    -0.04538856f, -0.02968201f, -0.03788329f, 0.10298888f, 0.08489444f, -0.17062625f, -0.12666219f, -0.02114983f, 
    0.03196745f, -0.12430131f, 0.01696686f, 0.07718247f, -0.13586064f, -0.01794032f, -0.11089184f, -0.03935260f, 
    -0.14386876f, 0.04818820f, 0.04562708f, 0.01015578f, 0.16090468f, 0.16597691f, 0.02385846f, -0.29791322f, 
    -0.07901370f, -0.16266510f, 0.03141321f, 0.18085614f, 0.00242583f, 0.06114754f, 0.12878062f, 0.06238748f, 
    0.06540461f, 0.08606056f, 0.04465809f, -0.55675173f, -0.52685833f, -0.58752412f, 0.21567483f, -0.06597814f, 
    -0.36859834f, -0.06862304f, 0.18403167f, 0.08573902f, 0.00697485f, -0.00014090f, -0.21671198f, 0.12054227f, 
    0.10511737f, 0.28726915f, -0.15475579f, -0.11098212f, -0.03019722f, -0.18514578f, -0.24085663f, -0.42500004f, 
    0.16991757f, -0.08764869f, -0.05963083f, -0.04114214f, -0.07994665f, -0.23936221f, -0.11250085f, 0.14718285f, 
    0.03720361f, 0.09610911f, -0.01249375f, 0.10308367f, 0.19304155f, 0.04967981f, 0.14231282f, 0.12472955f, 
    0.03428885f, -0.11377139f, -0.03813659f, 0.01529570f, 0.07077074f, 0.18596250f, 0.09746188f, 0.02276125f, 
    -0.04422941f, -0.01493523f, 0.01396382f, 0.01408819f, -0.03710551f, 0.00216422f, 0.05119193f, -0.04296474f, 
    0.03821154f, -0.01334900f, -0.03907885f, 0.00491305f, -0.00769404f, -0.06200816f, -0.01299068f, 0.03660959f, 
    0.01712862f, 0.00653985f, -0.05069705f, 0.01218942f, -0.05758930f, -0.00552709f, -0.06258421f, 0.02341352f, 
    0.02335185f, -0.02487819f, -0.01231938f, 0.03798034f, 0.01594630f, 0.03811897f, -0.04357560f, -0.00142768f, 
    -0.02867882f, -0.05407257f, -0.02153677f, 0.00367347f, 0.02393818f, -0.00597702f, -0.06314951f, -0.02458996f, 
    -0.04173435f, -0.00093204f, 0.02343665f, -0.02854542f, -0.02430192f, -0.01139691f, 0.00728522f, 0.01306084f, 
    -0.03263947f, -0.00620849f, 0.04673388f, -0.04055298f, 0.00664968f, -0.03541897f, -0.03052215f, 0.03495972f, 
    -0.06415449f, -0.06681824f, -0.04077645f, -0.06371077f, -0.04823294f, -0.00395431f, -0.06589027f, 0.01306347f, 
    -0.01119195f, 0.03493835f, -0.05420051f, -0.05043303f, 0.03043873f, 0.00223796f, -0.05019084f, 0.00877697f, 
    -0.02045701f, 0.02593252f, -0.05754111f, 0.02485451f, 0.01315050f, 0.04293766f, 0.03216749f, 0.02077376f, 
    -0.05979888f, -0.01612231f, -0.02340915f, 0.03680041f, 0.03721696f, 0.04287938f, -0.02271749f, 0.02356614f, 
    0.01550920f, -0.05718332f, -0.05105317f, -0.01053750f, 0.00822272f, -0.00091214f, 0.02990051f, -0.04484544f, 
    0.00724925f, 0.00640381f, -0.05724924f, 0.00185145f, -0.03175142f, -0.04829149f, -0.05544772f, -0.05527929f, 
    -0.01521952f, -0.00539117f, 0.00802353f, -0.04430707f, 0.02923767f, 0.02514720f, 0.04534022f, -0.01556911f, 
    0.02329932f, -0.05999054f, 0.01992001f, 0.03150332f, 0.02131754f, -0.02233483f, 0.05233493f, 0.00920368f, 
    -0.02119368f, -0.02293164f, 0.05858707f, -0.02285601f, 0.03108178f, 0.03007273f, -0.02100453f, -0.01497444f, 
    0.04712906f, 0.01094125f, 0.03221527f, -0.00457234f, -0.05833650f, 0.04832736f, -0.03715527f, -0.05833404f, 
    -0.05749603f, -0.06529489f, 0.01565506f, 0.02694985f, -0.01356216f, -0.01487052f, -0.03122058f, -0.06865641f, 
    -0.00271327f, -0.02511275f, -0.01268613f, -0.04091648f, -0.05894575f, -0.00376330f, 0.03048020f, -0.05827560f, 
    0.02852785f, -0.04098438f, -0.02643202f, 0.03953953f, -0.06825841f, 0.03519998f, -0.02929817f, -0.02189908f, 
    0.05875622f, -0.03434573f, -0.04813419f, -0.02876443f, 0.04993365f, 0.02277423f, 0.00145374f, -0.05711339f, 
    0.00253406f, 0.03353762f, -0.01987488f, -0.01368893f, -0.00975838f, -0.05164950f, -0.04953006f, -0.00103077f, 
    -0.03991059f, 0.01747330f, -0.03355869f, 0.03487530f, -0.05120604f, -0.03946603f, -0.05011589f, -0.06887724f, 
    -0.05312770f, -0.06668501f, 0.03321238f, -0.03853967f, 0.03389005f, 0.03950915f, 0.03083372f, -0.00815604f, 
    -0.00462557f, -0.00944280f, -0.02362730f, -0.03989278f, -0.05220733f, -0.01346086f, -0.02771370f, 0.03680242f, 
    0.01783413f, 0.02715896f, -0.00611244f, -0.06148706f, -0.05006384f, -0.05570278f, 0.01143195f, -0.03286867f, 
    0.03886275f, 0.02645038f, 0.00558829f, 0.01457206f, -0.04989784f, 0.01916978f, 0.01233670f, -0.00724237f, 
    0.02920428f, -0.00461200f, 0.04229991f, -0.05294093f, 0.01466500f, -0.01368047f, -0.06404070f, -0.04690111f, 
    0.04588240f, -0.03297753f, 0.03570263f, -0.03309223f, -0.03069783f, 0.01770573f, -0.00557132f, -0.05857126f, 
    -0.02430598f, 0.04376941f, -0.02421762f, -0.01226599f, -0.06319353f, -0.02633273f, -0.02488945f, -0.05440490f, 
    0.01520745f, -0.04120081f, -0.02939057f, 0.02057701f, 0.02031063f, -0.00821163f, 0.01184292f, 0.00611728f, 
    -0.01230971f, -0.05744699f, -0.04177816f, -0.05854687f, 0.02031423f, -0.03822285f, 0.02205613f, -0.01290377f, 
    -0.02479426f, -0.04824363f, -0.02696193f, -0.05832846f, -0.02089676f, 0.00256672f, -0.03508007f, -0.03896908f, 
    -0.01279173f, -0.06623736f, 0.00146109f, 0.01932533f, 0.01131525f, 0.03476243f, 0.04191643f, -0.04185800f, 
    -0.00945699f, -0.01957950f, -0.06509794f, -0.04871156f, 0.00008911f, -0.02289836f, -0.03913273f, 0.04611116f, 
    -0.01361584f, 0.02865484f, 0.00917668f, -0.05203635f, 0.03605815f, -0.05168738f, -0.02207450f, 0.05637038f, 
    -0.04285518f, 0.11209127f, -0.11739962f, 0.03899004f, -0.00236030f, -0.03655891f, 0.06030926f, -0.11858032f, 
    -0.13803010f, 0.13315170f, 0.16520533f, 0.18601893f, 0.23610209f, 0.00530605f, 0.22088134f, 0.01409908f, 
    -0.02973314f, -0.00693439f, -0.49288106f, 0.05509694f, -0.11383867f, -0.03670370f, 0.11633325f, 0.08282721f, 
    0.08442038f, 0.04878169f, -0.01006670f, 0.07247177f, 0.00363379f, -0.23741975f, 0.06461783f, 0.09705327f, 
    0.12773080f, -0.11931155f, 0.03923003f, 0.21753246f, 0.17962487f, 0.00872077f, 0.05388305f, 0.13456970f, 
    0.05977219f, 0.04789420f, -0.00275270f, 0.10770022f, -0.19108605f, -0.18784171f, -0.00575478f, -0.05031599f, 
    0.11443103f, 0.22260073f, 0.01469828f, -0.24572583f, -0.26559776f, -0.32308936f, -0.03290689f, 0.34343028f, 
    0.30444583f, -0.05473339f, -0.25708845f, -0.18316089f, -0.07410064f, 0.03812359f, 0.30612203f, 0.10621502f, 
    0.04898559f, 0.03717892f, -0.16455090f, 0.07990570f, -0.06403485f, 0.07200251f, 0.28184342f, -0.06909093f, 
    -0.06924340f, -0.05959179f, 0.06088880f, 0.14967035f, 0.23078945f, 0.16088746f, 0.09005044f, -0.10231518f, 
    0.03999061f, -0.17682163f, 0.11106950f, 0.10627993f, -0.01796273f, 0.05362521f, -0.08899681f, -0.03378576f, 
    -0.13155621f, 0.00581173f, 0.32086542f, -0.26037100f, -0.05667326f, -0.17545465f, -0.22854812f, -0.00029643f, 
    -0.00473711f, 0.09732918f, -0.04042190f, -0.28866079f, -0.02663393f, -0.14405443f, 0.05170674f, 0.24788113f, 
    0.13107921f, 0.06919047f, -0.00200159f, 0.14318085f, 0.10948856f, -0.32113427f, -0.13574933f, 0.08053137f, 
    -0.02269219f, 0.15054508f, -0.11272481f, 0.02728064f, 0.05052502f, -0.11225375f, -0.12321576f, -0.01957955f, 
    0.31900185f, 0.07266088f, -0.05980628f, -0.03902669f, -0.08579875f, -0.06126184f, 0.35033515f, -0.01720833f, 
    0.14173572f, -0.00275515f, -0.18181407f, 0.06636568f, -0.03685236f, 0.06924859f, -0.08807199f, 0.06375792f, 
    0.17528903f, -0.05528612f, 0.15267810f, 0.01592092f, 0.24166471f, 0.25898698f, -0.33620200f, -0.02596802f, 
    0.05494134f, -0.29441816f, -0.14934111f, 0.05547532f, 0.19969188f, -0.20995510f, -0.23400779f, -0.25118572f, 
    -0.50113595f, 0.04557879f, 0.03001322f, 0.02281752f, -0.00564790f, 0.13331562f, 0.00989047f, -0.13234891f, 
    -0.18857081f, -0.14388867f, -0.02683025f, 0.06857125f, -0.30441195f, 0.00325529f, 0.21490748f, -0.08695845f, 
    -0.15048447f, -0.03236901f, 0.01119170f, -0.19242840f, 0.24440028f, 0.55388093f, 0.04584374f, -0.19586578f, 
    0.03068286f, -0.21177679f, 0.00680279f, 0.21104060f, 0.13135770f, 0.08791684f, 0.10404225f, 0.14184660f, 
    0.20946249f, -0.13413857f, 0.08546999f, -0.07328289f, -0.07620687f, 0.38612419f, 0.10962545f, 0.04661854f, 
    0.10963812f, 0.02122623f, -0.04553773f, -0.03486341f, 0.13417499f, 0.08973791f, 0.10032073f, -0.26433474f, 
    0.32059106f, 0.05044287f, 0.06013754f, 0.22789212f, -0.02484204f, 0.22196680f, 0.09913591f, -0.18861020f, 
    -0.11518908f, -0.29511991f, -0.21765871f, 0.00177226f, 0.25413904f, -0.02690035f, 0.14316039f, -0.10187442f, 
    0.20781873f, -0.36972567f, 0.04696030f, 0.05486864f, -0.27944559f, 0.00400289f, -0.11001931f, 0.09209874f, 
    -0.08091912f, -0.20883006f, -0.20926912f, -0.11811684f, 0.11017202f, -0.00938302f, -0.17646618f, -0.27222070f, 
    -0.42323753f, -0.38446704f, 0.02321074f, -0.01585437f, 0.05810266f, 0.07325997f, 0.00770289f, 0.04447875f, 
    0.07646865f, 0.16167441f, 0.01330448f, -0.04043390f, -0.64617199f, -0.12448060f, -0.05213937f, -0.07557621f, 
    -0.60408062f, -0.03577021f, 0.13399541f, -0.09609503f, 0.07067969f, -0.16955435f, -0.11215632f, 0.15713872f, 
    -0.21763907f, -0.14938124f, -0.16134346f, 0.12112984f, -0.15102705f, 0.13906270f, -0.34450105f, -0.22807853f, 
    0.00513836f, 0.12554587f, 0.11802530f, 0.27600679f, -0.13069807f, -0.19352257f, -0.03092846f, 0.27247512f, 
    0.05643740f, 0.05865267f, 0.18146294f, 0.08246073f, 0.05460797f, 0.00248256f, 0.27153289f, -0.07016122f, 
    0.10226498f, -0.07905354f, 0.07070991f, 0.06875638f, 0.01975786f, 0.14053681f, 0.16529302f, -0.10144424f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.22937919f, -0.03577438f, -0.00266328f, -0.03971724f, 0.40450799f, 0.31733391f, 0.03123481f, -0.05745678f, 
    0.29687855f, -0.03825724f, 0.19111155f, 0.20605941f, 0.14610936f, -0.23260912f, -0.24154340f, -0.10139454f, 
    0.03125557f, 0.09616011f, 0.31787938f, -0.02015822f, 0.19803062f, 0.08261205f, 0.01597864f, 0.12600829f, 
    0.23706727f, 0.08846585f, 0.00980514f, 0.37285516f, -0.23605101f, 0.06484110f, -0.01882710f, 0.10985444f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03085252f, -0.28327191f, -0.14027420f, -0.16922243f, 0.05744615f, 0.01529447f, -0.11107070f, -0.09529412f, 
    -1.35219610f, -0.12144962f, 0.01732406f, 0.15860595f, 0.43705878f, 0.20411658f, 0.39234498f, 0.06850804f, 
    0.14261927f, -0.30318442f, 0.08663084f, 0.11382421f, -0.46105179f, 0.34505183f, -0.10248026f, -0.13426152f, 
    -0.53088939f, 0.58628035f, 0.02511689f, -0.49829829f, 0.21165836f, 0.08675086f, -0.16137767f, -0.14321867f, 
    -0.33735284f, -0.42412776f, -0.04129239f, -0.07619131f, -0.08472826f, 0.18761100f, -0.15442166f, -0.50552130f, 
    -0.62465000f, 0.12986751f, 0.30685928f, 0.25427034f, 0.21568125f, -0.23461118f, -0.06160728f, -0.17954686f, 
    0.00588399f, -0.03269454f, 0.26533344f, -0.03197694f, 0.77224576f, -0.27549118f, -0.08316316f, 0.03981747f, 
    0.06756916f, 0.08401597f, 0.23350027f, 0.01559868f, 0.23380741f, 0.17841719f, -0.12268867f, 0.01128749f, 
    0.35559931f, 0.06487405f, -0.07583596f, -0.16900657f, 0.36919382f, 0.07318480f, 0.16634858f, 0.05494208f, 
    0.67554969f, 0.09614199f, 0.06659156f, 0.22720613f, 0.39320162f, 0.00969608f, -0.31533140f, -0.38514027f, 
    -0.18842962f, 0.07342655f, -0.22456135f, 0.02200573f, 0.24510023f, -0.09139287f, 0.15811284f, -0.18986739f, 
    -0.70551270f, -1.34080398f, -0.07385999f, -0.28598571f, -0.09593951f, 0.16023923f, 0.10421651f, 0.13429950f, 
    -0.27136537f, 0.72828674f, -0.07795575f, -0.16742894f, -0.50453424f, -0.04682919f, 0.14733130f, 0.36672714f, 
    -0.16796696f, 0.03265134f, -0.49277821f, 0.05734246f, 0.37391770f, 0.02322003f, 0.19484657f, 0.12678201f, 
    -0.56113464f, 0.17795007f, -0.91269982f, -0.04325126f, -0.18091899f, -0.51453018f, 0.12561969f, -0.20587327f, 
    -0.58055723f, -0.23049366f, 0.30234060f, -0.47241819f, 0.53935015f, 0.30849332f, 0.01492930f, -0.36701685f, 
    0.14474577f, 0.11598768f, 0.15552850f, 0.01908667f, -0.21361165f, -0.18159305f, 0.04056090f, -0.02641727f, 
    -0.19459501f, 0.11683200f, -0.00048366f, -0.33043948f, -0.58202213f, 0.02952999f, 0.06419118f, -0.10078378f, 
    0.42390409f, 0.27820116f, -0.04517583f, 0.13145156f, 0.17809319f, 0.26666451f, 0.04350163f, 0.12460257f, 
    -0.01561400f, 0.39635590f, 0.06649876f, -0.62083089f, -0.27469480f, 0.06957892f, 0.06576466f, 0.32715976f, 
    0.08018962f, 0.19392376f, -0.00379895f, -0.12452977f, 0.17834795f, 0.04229913f, 0.08546360f, -0.23229523f, 
    0.12942278f, 0.07250210f, 0.18365517f, -0.26073968f, 0.07029895f, -0.37884167f, 0.15209056f, 0.28891453f, 
    -0.38272849f, -0.30310473f, 0.05863754f, -0.16135187f, 0.20160526f, 0.35055703f, 0.00506176f, 0.27075046f, 
    0.36865723f, 0.19832480f, -0.23476644f, 0.06324998f, -0.07342930f, -0.31393644f, -0.06887621f, -0.36464089f, 
    0.12537555f, 0.16760020f, -0.03326560f, -0.06531045f, 0.24220729f, 0.36041251f, 0.08329841f, 0.32816198f, 
    0.56811404f, -0.12669593f, 0.12600704f, -0.32586697f, -0.81301844f, 0.10654314f, -0.30517572f, -0.48848835f, 
    -0.65253896f, -0.08463282f, 0.28868547f, 0.03735798f, -0.98762983f, -0.59680367f, 0.07839584f, -0.12141674f, 
    -0.47937983f, -0.61593544f, -0.38007051f, 0.07165636f, -0.32942429f, 0.17906117f, 0.10321802f, 0.32579759f, 
    -0.13986436f, 0.02183888f, -0.04849789f, 0.09407273f, -0.41217080f, -0.32440242f, -0.15119883f, -0.05119535f, 
    0.16803068f, -0.07726768f, 0.14709952f, 0.05346242f, -0.53556228f, 0.32963064f, -0.01684648f, 0.13616379f, 
    0.48456889f, -0.12937516f, 0.43414384f, 0.04497833f, 0.22336309f, 0.19704621f, 0.03914011f, -0.20087415f, 
    0.29828754f, -0.84145314f, 0.07241621f, -0.23528180f, -0.02040232f, 0.00903337f, 0.14899446f, 0.06350445f, 
    -0.51358807f, -0.14580722f, 0.08240508f, 0.08422083f, 0.16001333f, -0.06224164f, 0.14176862f, -0.17360386f, 
    -0.00222898f, -0.05436861f, -0.02010433f, 0.30668321f, 0.67744035f, -0.37076730f, -0.39231843f, 0.23902293f, 
    -0.47649220f, 0.48578495f, 0.23211657f, 0.14791061f, -0.66414338f, -1.14268911f, -0.05272221f, 0.38404939f, 
    0.31550971f, -0.24514140f, -0.15561648f, 0.21538287f, -0.57433003f, -0.07666529f, -0.03466043f, -0.21661443f, 
    0.35735747f, 0.02755326f, 0.10353556f, 0.07525232f, 0.29897547f, -0.11500830f, 0.14042282f, 0.59138256f, 
    -0.39250612f, 0.01133706f, -0.51671976f, 0.30303609f, -0.79975271f, -0.06630655f, -0.31833994f, -0.45275223f, 
    -0.24360451f, -0.41471702f, -0.28934842f, -0.11190425f, -0.07738426f, 0.32488680f, -0.18313919f, -0.10741260f, 
    0.06763837f, 0.49116701f, -0.04325108f, 0.57489729f, -0.64028567f, 0.40017134f, 0.13756502f, -0.14051270f, 
    0.09707540f, 0.28302735f, -0.01965591f, -0.03216201f, 0.11161199f, -0.10280637f, 0.15438703f, -0.43654108f, 
    0.11050007f, -0.18085599f, -0.19927500f, 0.27977949f, -0.37303254f, 0.05289571f, 0.34106025f, 0.42792085f, 
    0.72415346f, 0.20526250f, -0.04470030f, -0.01303863f, 0.18890740f, -1.05251706f, -0.11899664f, -0.21218367f, 
    -0.20484182f, -0.30235139f, -0.06963080f, 0.29137629f, -0.39411652f, -0.67724758f, 0.06679332f, -0.60279834f, 
    -0.14261372f, 0.08246017f, -0.03907310f, -0.02194422f, -0.47612900f, 0.43445909f, -0.05437324f, -0.26750356f, 
    0.11618451f, 0.12163802f, -0.46961734f, -0.33424237f, -0.10226803f, 0.33084452f, 0.34207565f, -0.35674801f, 
    -0.42227271f, 0.24342431f, -0.52602893f, -0.00633221f, -0.39090312f, -0.17395727f, -0.13219430f, -0.35097200f, 
    0.60437536f, -0.83429950f, 0.36170337f, 0.05264964f, -0.24459830f, 0.02967846f, 0.14649606f, 0.48529720f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11567350f, 0.35092470f, 0.04937571f, 0.02702336f, -0.08010056f, -0.10320037f, -0.04904336f, -0.21828851f, 
    -0.00829545f, 0.17448036f, 0.05201823f, 0.01186525f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
