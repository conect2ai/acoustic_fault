#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.05524552f, -0.75096571f, -0.70680207f, -0.48687899f, -0.28399244f, -0.08102523f, -0.16406322f, 0.02652571f, 
    0.42927516f, 0.17262326f, -0.00633011f, 0.18456934f, 0.16889881f, -0.15125167f, 0.08070802f, 0.29102093f, 
    -0.11367952f, -0.06730355f, -0.18645640f, 0.02279443f, -0.16436885f, -0.17297089f, -0.23870857f, 0.04395824f, 
    0.24311985f, -0.86164087f, -0.41278368f, 0.21059003f, -0.11572941f, 0.18182302f, 0.27711049f, 0.50637352f, 
    0.31144956f, 0.23413615f, -0.06884318f, 0.04010646f, 0.05014469f, 0.14962275f, 0.38726917f, -0.40367529f, 
    -0.06132592f, -0.07773615f, -0.17102426f, -0.27290821f, -0.13294145f, 0.17226055f, 0.19927087f, 0.36844715f, 
    -0.00616785f, -0.15266159f, 0.20494841f, 0.74475503f, -0.19570103f, -0.75369751f, 0.17306072f, 0.38707593f, 
    -0.63844484f, -0.10493429f, -0.33078691f, -1.06817901f, 0.13216522f, 0.41734946f, -0.12298108f, 0.22479364f, 
    -0.26799253f, 0.13473897f, -0.11265703f, -0.17019103f, -0.20574827f, -0.35711172f, -0.33178654f, -0.06213691f, 
    0.00647184f, 0.00410916f, 0.09375710f, -0.29330572f, -0.04593811f, -0.37415594f, -0.03839803f, 0.06729444f, 
    0.08335611f, 0.39823425f, -0.28939316f, 0.05251610f, -0.03486719f, 0.17487462f, -0.07509477f, -0.03763305f, 
    0.15818021f, -0.28941515f, -0.37795824f, -0.08926170f, 0.18788934f, 0.14530584f, -0.11693924f, 0.14383955f, 
    0.11061235f, -0.04701069f, 0.14317854f, 0.25389010f, 0.49197140f, -0.20964307f, -0.66805345f, -0.12050997f, 
    -0.38782781f, 0.33193734f, 0.09298871f, 0.68485552f, -0.57052928f, -0.22569293f, -0.68678504f, -0.41930124f, 
    -0.28944963f, 0.35702798f, -0.22024798f, -0.30164850f, -0.18874718f, 0.35587773f, -0.15310493f, -0.27227765f, 
    0.17374994f, -0.04342323f, -0.13869338f, 0.03445000f, -0.00277370f, -0.02921556f, 0.05785342f, -0.37292698f, 
    -0.44593233f, -0.45766670f, -0.35748479f, -0.40578300f, -0.38278961f, -0.09598009f, 0.08307923f, 0.28915438f, 
    0.34801838f, 0.34858415f, 0.02512173f, -0.06222663f, 0.09562624f, -0.04943437f, 0.01495248f, -0.09246622f, 
    0.01143605f, -0.17973629f, -0.15196720f, -0.09078594f, -0.18580133f, -0.14087750f, -0.02830161f, -0.21593335f, 
    0.06914379f, -0.01615831f, -0.08052152f, -0.19208093f, -0.07926757f, 0.12429086f, 0.26699173f, -0.09208713f, 
    -0.08597675f, 0.00974700f, 0.14332855f, -0.00827169f, -0.17775507f, -0.16131392f, 0.05725625f, 0.29435870f, 
    -0.25373387f, -0.22023644f, -0.05938958f, 0.27617022f, 0.44375956f, 0.20386957f, 0.02074303f, -1.02233791f, 
    -0.79768676f, -0.40712854f, -0.61282587f, -0.90510011f, 0.88778055f, 0.39855966f, -0.29763642f, 0.14223036f, 
    0.49212211f, -0.23771587f, -0.22157748f, 0.01861820f, 0.06842557f, 0.01989319f, -0.14153114f, -0.05386168f, 
    -0.22393386f, -0.20930542f, -0.02864689f, -0.14718680f, 0.02584156f, 0.27224267f, -0.01766090f, 0.01550141f, 
    0.17468010f, -0.02915372f, -0.14282981f, 0.06391150f, -0.02096374f, -0.16180441f, 0.03182928f, 0.17672889f, 
    -0.02987737f, -0.00230397f, 0.19905141f, 0.07423939f, -0.27912593f, -0.03942641f, 0.00122048f, 0.10080394f, 
    -0.07079122f, -0.41211826f, 0.07382192f, 0.24192835f, 0.03829750f, -0.25898847f, 0.03797124f, 0.24103115f, 
    -0.02500858f, 0.84431118f, 0.12958147f, -0.00269405f, -0.19527586f, -0.33683589f, 0.24597651f, 0.00884058f, 
    0.33106697f, -0.09275349f, -0.35674414f, -0.30804744f, 0.11357082f, -0.30720904f, -0.30780992f, 0.41405725f, 
    -0.00861684f, 0.23304944f, -0.05198730f, -0.17452630f, -0.20442097f, -0.02552662f, -0.19712304f, -0.28579807f, 
    0.13440214f, 0.17072287f, 0.21649919f, -0.16779763f, -0.12467364f, 0.29064545f, 0.14517915f, -0.34382179f, 
    -0.45149019f, -0.02680331f, 0.33043075f, 0.34694779f, -0.22177467f, 0.01917195f, -0.06313115f, -0.01777824f, 
    -0.13148692f, -0.02594761f, -0.09843354f, -0.18388541f, 0.06017444f, -0.27672195f, -0.56455672f, -0.11102265f, 
    -0.31486553f, -0.54966950f, -0.47191164f, -0.45676059f, 0.18868564f, -0.29756728f, -0.09865104f, 0.38035348f, 
    0.15105468f, -0.20249918f, -0.22112294f, 0.47899288f, -0.22998051f, 0.25105831f, 0.32474524f, -0.10157919f, 
    -0.58177871f, 0.35401669f, -0.11946354f, 0.09617915f, -0.17186682f, -0.30738056f, -0.43161580f, 0.10953187f, 
    -0.13540645f, -0.30771977f, -0.20298716f, -0.26763183f, -0.69485074f, 0.43605968f, 0.22643358f, -0.64414191f, 
    -0.34298331f, -0.07452608f, -0.11379517f, -0.14469212f, -0.32591298f, -0.16045891f, -0.00157676f, -0.14311236f, 
    0.05511982f, -0.14431225f, 0.06633738f, 0.10099775f, -0.36821285f, -0.40147957f, -0.09399883f, -0.23909703f, 
    0.31095812f, -0.17366712f, 0.20370142f, 0.04360669f, -0.17161383f, -0.58475429f, -0.05872757f, 0.04259049f, 
    -0.19684727f, -0.31380635f, -0.13139679f, 0.02099609f, 0.52918667f, 0.43509382f, 0.13689713f, -0.34578410f, 
    -0.06193324f, 0.21764958f, 0.47699654f, -0.40357986f, -0.16365817f, 0.14489956f, -0.30483845f, 0.01201666f, 
    0.16840705f, 0.06919286f, -0.15872306f, 0.16882502f, 0.12288922f, -0.20384599f, 0.34221631f, -0.03394670f, 
    -0.27312383f, -0.17177179f, -0.34580877f, 0.06924602f, 0.32314679f, 0.12797002f, 0.05823648f, -0.19377050f, 
    -0.08862196f, 0.31660581f, -0.04311973f, 0.01864574f, 0.10321873f, 0.25435331f, -0.14929627f, -0.09322876f, 
    0.13151877f, -0.21347278f, 0.36596927f, -0.25965515f, 0.14157568f, -0.15687530f, 0.23821972f, -0.82329035f, 
    0.17724806f, 0.21003975f, 0.04268513f, -0.54008132f, -0.67506522f, -0.63927341f, 0.23732883f, 0.03687975f, 
    0.31521451f, 0.64309925f, 0.16717739f, 0.46407783f, 0.13996132f, 0.01193532f, -0.30804533f, -0.05984151f, 
    -0.02915080f, -0.48553756f, -0.53442836f, -0.02574919f, 0.19004165f, 0.25276607f, -0.04047473f, 0.08907638f, 
    0.04633035f, 0.16952583f, 0.17927875f, 0.11454424f, 0.14613914f, -0.08211962f, 0.25141805f, -0.04703927f, 
    0.10223261f, 0.17444308f, -0.08805212f, 0.24539387f, 0.31419235f, -0.14628969f, -0.22800936f, -0.13439618f, 
    -0.34373426f, -0.16360047f, -0.14896987f, -0.01693571f, -0.20490266f, 0.11852086f, -0.00182885f, 0.11604978f, 
    0.16231413f, 0.62090999f, -0.08159521f, -0.44289878f, -0.94631821f, -0.68887651f, 0.31620082f, 0.38145766f, 
    -0.14371231f, -0.38409337f, 0.26494992f, -0.03645407f, 0.49358696f, 0.09436213f, -0.02463031f, -0.07810297f, 
    -0.08312241f, 0.11426790f, 0.16256745f, -0.22811027f, -0.02978995f, 0.20427147f, -0.18554510f, -0.25299892f, 
    0.30451152f, 0.09035634f, 0.65042114f, -1.04846513f, -0.58571768f, 0.25907913f, 0.06548790f, 0.16571712f, 
    0.72955132f, 0.09417839f, -0.08639839f, -0.24245737f, 0.10429164f, -0.23682378f, -0.02015053f, -0.02276184f, 
    -0.05656059f, -0.08453092f, -0.22113146f, -0.05938049f, -0.13424017f, 0.04325503f, 0.03645399f, -0.16571848f, 
    -0.22474326f, -0.42387980f, -0.41693833f, 0.11358479f, -0.74040729f, -0.55641109f, -0.53031659f, -0.09248324f, 
    0.03859440f, -0.00532113f, 0.23276116f, 0.07298004f, 0.27131662f, -0.15282857f, 0.33725265f, 0.18606295f, 
    -0.24822740f, -0.01343058f, 0.13673440f, 0.04375685f, -0.13356134f, -0.14915131f, 0.03064862f, -0.29092082f, 
    0.08820853f, -0.31754959f, -0.23630349f, -0.32028520f, -0.87302989f, 0.51483959f, 0.21283054f, -0.34841540f, 
    0.37184367f, 0.28284451f, 0.27198827f, 0.02842803f, 0.01875581f, -0.30490071f, -0.05986058f, -0.19624022f, 
    0.01939191f, -0.12996970f, 0.15504535f, -0.14934447f, -0.09879287f, -0.21718684f, 0.12993376f, 0.04334476f, 
    0.07587889f, 0.14552711f, -0.08291528f, 0.02639250f, -0.15589449f, -0.80997974f, -0.61298567f, -0.22269410f, 
    0.63474727f, 0.40668592f, -0.43076059f, 0.08181901f, 0.07952391f, 0.41681445f, 0.24195050f, 0.26785201f, 
    0.01923260f, -0.17400543f, 0.25337994f, 0.03549121f, 0.00851286f, -0.06948931f, 0.14689998f, -0.04986355f, 
    -0.18101479f, -0.07798350f, -0.02511150f, 0.02651560f, 0.16768312f, -0.03843775f, -0.55229259f, -0.34797403f, 
    -0.50277364f, -0.27469465f, 0.56808549f, -0.12937014f, 0.33449703f, -0.78076565f, -0.43252760f, -0.35719118f, 
    -0.06434414f, 0.31099820f, -0.28143135f, -0.43797123f, -0.40269968f, -0.05571530f, -0.15829639f, -0.04415012f, 
    0.27137327f, -0.14350352f, 0.08037493f, -0.10881298f, 0.16719121f, 0.02287230f, -0.17629595f, -0.06526025f, 
    -0.15557314f, -0.38119718f, -0.11283211f, -0.58846539f, -0.54576194f, -0.72451967f, -0.57958996f, -0.59658772f, 
    -0.72972137f, 0.08398626f, 0.20497943f, 0.08674677f, 0.57158762f, -0.06144265f, 0.10629054f, 0.07733097f, 
    0.11803631f, 0.08421179f, -0.23829614f, -0.05180001f, 0.01668294f, 0.14317670f, -0.10235690f, 0.13800091f, 
    0.53599137f, 0.11901858f, -0.02008005f, -0.39383149f, 0.09554785f, 0.02750377f, -0.40170670f, 0.09083365f, 
    -0.21213260f, 0.25819063f, -0.20156486f, -0.25578845f, 0.17735167f, 0.09609390f, 0.23936422f, 0.02727986f, 
    0.06282692f, -0.14129896f, 0.02591124f, -0.14890064f, 0.04263697f, -0.11588566f, 0.19140013f, -0.03149845f, 
    -0.05171211f, 0.10918298f, -0.14286600f, -0.58270383f, -0.51664311f, -0.04377430f, -0.27765635f, -0.26185715f, 
    -0.33345065f, -0.45014727f, -0.73598802f, 0.59063178f, -0.23678927f, -0.00956566f, -0.14673680f, 0.18845862f, 
    -0.40062737f, -0.07151981f, -0.18250264f, -0.32119057f, -0.34217232f, 0.00734778f, 0.00516736f, 0.18522756f, 
    -0.15857729f, 0.17397869f, 0.18765128f, 0.23880391f, -0.17791042f, -0.00661746f, -0.03423266f, 0.47743362f, 
    -0.37039435f, 0.01508891f, 0.20497243f, -0.00801238f, 0.29483026f, -0.15050958f, -0.21133313f, 0.36035088f, 
    -0.28752875f, 0.04517504f, -0.04613561f, 0.03235931f, 0.04892944f, -0.28520828f, -0.16101891f, 0.13461907f, 
    0.30200699f, -0.06760170f, -0.22552952f, 0.31392202f, 0.46783826f, 0.38556084f, -0.07027180f, -0.60872817f, 
    -0.07377659f, -0.09661949f, 0.11756811f, 0.26914212f, -0.21020095f, -0.26067814f, -0.03348911f, -0.07092563f, 
    0.30024701f, -0.29129440f, 0.08328564f, -0.02257662f, -0.03482242f, -0.22003499f, 0.02438245f, -0.09157872f, 
    -0.08801729f, -0.38015777f, -0.22929110f, -0.11341729f, -0.23531285f, -0.71674597f, -0.31110555f, 0.19682673f, 
    -0.05177879f, -0.12036199f, 0.28502586f, 0.34637150f, 0.10790412f, 0.42113292f, -0.20592055f, -0.40172011f, 
    -0.34427845f, 0.00004658f, 0.44358298f, 0.04149162f, 0.03354992f, -0.07844249f, 0.19648293f, -0.20584795f, 
    0.02201138f, -0.44837490f, 0.55057353f, -0.02587336f, -0.16370101f, 0.33734876f, 0.53900808f, 0.18359476f, 
    0.04685930f, -0.01758252f, -0.48229992f, -0.05266665f, 0.05362183f, -0.35882372f, 0.05228410f, -0.11783576f, 
    0.28997928f, -0.36720327f, -0.51100230f, 0.11640378f, 0.05288171f, 0.20883453f, 0.28105235f, 0.10571504f, 
    -0.03067801f, 0.10373758f, -0.15003814f, -0.18816994f, -0.24830256f, -0.23865360f, 0.25647184f, 0.35998422f, 
    0.38389024f, -0.06268090f, 0.43119562f, -0.44009081f, -0.32827762f, -0.65790021f, -0.50576264f, -0.10357591f, 
    -0.04926885f, 0.08731464f, 0.25467372f, 0.17314006f, 0.04101905f, 0.08459426f, -0.34278134f, -0.17172095f, 
    0.30741355f, 0.11047011f, -0.17643061f, 0.00679644f, 0.11878818f, 0.26894829f, -0.05347864f, 0.72627908f, 
    0.10817055f, -0.06868396f, -0.53988451f, -0.53094113f, 0.80596834f, 0.11358938f, -0.25702807f, -0.46845549f, 
    0.10377856f, -0.01298991f, -0.17003079f, -0.06313689f, 0.12356304f, 0.13086024f, 0.11279356f, 0.07923049f, 
    -0.12234647f, -0.17982706f, 0.02619282f, 0.09288948f, -0.21905692f, -0.16893883f, -0.17112121f, -0.11068501f, 
    -0.16042092f, -0.43117851f, -0.57806998f, -0.56956804f, -0.28994331f, -0.29957089f, -0.52857119f, -0.07572991f, 
    -0.29736906f, -0.61566550f, -0.11639875f, 0.26219332f, 0.21479994f, -0.23738290f, 0.04310260f, 0.07004454f, 
    -0.04668327f, -0.16651814f, 0.23372382f, 0.08955343f, 0.02938280f, 0.50825006f, -0.03582198f, 0.04539199f, 
    0.38633013f, -0.96418852f, -0.41169056f, 0.57042408f, 0.49291041f, 0.42580238f, -0.46470687f, -0.36880362f, 
    -0.45904860f, 0.33688828f, -0.24329115f, 0.03463101f, -0.42642117f, 0.14383771f, -0.07908719f, -0.08344369f, 
    -0.27771994f, -0.24321610f, -0.11764986f, -0.07240507f, 0.15567297f, -0.06224512f, -0.03410526f, -0.20477380f, 
    -0.06435490f, -0.07744979f, -0.07498243f, -0.22162539f, 0.09600177f, 0.20829898f, 0.14203474f, -0.26923648f, 
    -0.25056934f, 0.16875887f, -0.07926153f, -0.41081786f, 0.57278198f, -0.12654579f, -0.34470409f, 0.05274150f, 
    0.15530691f, 0.23613727f, 0.10075582f, -0.27562186f, 0.01572936f, -0.17043848f, -0.41918901f, 0.09592069f, 
    0.26906538f, 0.14854120f, 0.17631319f, 0.51863879f, 0.57582343f, -0.31206548f, -0.16607507f, -0.74949682f, 
    -0.39666781f, -0.38704753f, 0.27312192f, 0.28949791f, 0.15812740f, 0.18073186f, -0.28162143f, 0.29451114f, 
    0.15878054f, -0.20356871f, 0.27019918f, -0.24446873f, 0.16128576f, -0.21851349f, -0.04914741f, -0.07116981f, 
    0.11544714f, 0.01165709f, -0.30129424f, 0.12456351f, -0.10121112f, -0.73205507f, -0.04574435f, 0.46200716f, 
    0.40996262f, 0.09823586f, 0.69555700f, -0.31278801f, -0.38881066f, -0.11622054f, -0.18215136f, -0.18063620f, 
    0.09324323f, -0.14421754f, 0.08018067f, 0.03687773f, 0.01241760f, 0.21532740f, 0.05866796f, -0.20116164f, 
    -0.09244708f, -0.06042241f, -0.15307419f, 0.14035289f, 0.18922596f, 0.21050745f, 0.33971259f, 0.14498602f, 
    0.31853083f, 0.13537192f, 0.06925025f, 0.26297694f, 0.25931355f, 0.02404792f, -0.03799269f, 0.24860331f, 
    -0.06874837f, 0.10877128f, 0.23565520f, -0.32742596f, -0.10872277f, 0.00298909f, 0.19344889f, -0.17152078f, 
    -0.21086849f, 0.15154402f, -0.06517009f, -0.01228756f, 0.08584864f, 0.11451429f, -0.07769151f, 0.18143953f, 
    -0.30701199f, -0.51692247f, -0.91235518f, 0.03919882f, -0.04230292f, -0.04265051f, 0.15323654f, 0.57175702f, 
    -0.03453367f, 0.29211622f, -0.08175193f, 0.08834884f, 0.05353689f, -0.24970180f, 0.09373409f, -0.18138967f, 
    0.13305616f, 0.19290619f, 0.02588049f, -0.07706319f, 0.07281973f, -0.19451460f, -0.06587181f, 0.30914712f, 
    0.58707273f, 0.10771240f, -0.33828160f, -0.35998672f, -0.09612938f, 0.07479281f, -0.23498136f, -0.22326019f, 
    -0.02719427f, -0.08141581f, -0.26731139f, -0.08030403f, -0.07396243f, 0.29111770f, -0.28059849f, 0.11944114f, 
    -0.04953637f, -0.01143987f, -0.17744273f, -0.29702902f, -0.34040189f, -0.38927722f, -0.52752751f, -0.71241593f, 
    0.90555203f, -0.62582356f, -0.24572448f, 0.07733891f, 0.17036995f, 0.45993462f, 0.31920087f, 0.40349361f, 
    -0.09964263f, 0.00191672f, -0.26534438f, 0.10932178f, -0.15657723f, -0.26652023f, -0.04879702f, 0.08364960f, 
    -0.17957157f, 0.13718109f, -0.12535518f, -0.31101912f, 0.16158234f, -0.08218633f, -0.16603741f, 0.17084679f, 
    -0.06755976f, 0.75787193f, -0.47665346f, -0.04478140f, 0.17143868f, -0.75049967f, 0.09696770f, 0.05985484f, 
    0.28800544f, -0.09090924f, -0.25733045f, 0.45243478f, -0.37703887f, 0.08003569f, -0.21043612f, 0.16868700f, 
    -0.25913638f, 0.21157868f, -0.05381253f, -0.18131970f, 0.07306117f, -0.28832158f, -0.27403054f, -0.00980462f, 
    0.14005011f, 0.12637593f, 0.23820777f, -0.29830861f, -0.45171759f, 0.60596263f, 0.08641206f, 0.07193901f, 
    -0.20907103f, -0.67479157f, -0.47048455f, -0.23265265f, -0.14230095f, 0.02878600f, -0.16506310f, -0.08854574f, 
    0.21329242f, 0.02357137f, -0.21889363f, 0.37354743f, 0.37607899f, 0.09295900f, -0.40765944f, 0.06368002f, 
    0.13533372f, -0.14047568f, -0.06027050f, -0.48254710f, -0.40013340f, -0.05675554f, -0.15012375f, -0.28273353f, 
    -0.27103806f, -0.05675863f, 0.04946011f, -0.20374869f, -0.43716425f, -0.02499054f, -0.30519754f, -0.24050207f, 
    0.45687491f, -0.42817926f, -0.14376499f, 0.02733750f, -0.14513953f, 0.13969029f, 0.14596622f, 0.07716525f, 
    -0.16418919f, -0.37555441f, -0.25453746f, -0.29184827f, -0.72261661f, -0.68646187f, 0.09980690f, 0.06395403f, 
    0.38169858f, -0.40196949f, -0.25435555f, -0.58736932f, -0.55495673f, -0.18959740f, 0.06035052f, -0.40472281f, 
    -0.24139352f, -0.10065522f, -0.50012451f, -0.15878718f, -0.10323986f, -0.19157664f, -0.11858743f, -0.17670481f, 
    0.06451490f, -0.27115735f, 0.06092052f, -0.04443608f, 0.12838744f, -0.34374541f, -0.92420828f, 0.13405253f, 
    0.36269289f, 0.60704798f, -0.36532873f, -0.44669691f, -0.48215464f, -0.40305090f, -0.12307787f, 0.30398816f, 
    0.00684073f, 0.54316866f, -0.42685089f, 0.17378557f, -0.04990136f, 0.07642851f, 0.07847717f, -0.02366539f, 
    -0.10367855f, 0.01315800f, -0.09272259f, -0.19272332f, -0.02609027f, 0.33204767f, -0.58593971f, -0.51632845f, 
    -0.12464595f, 0.29685214f, 0.44282630f, 0.30637595f, 0.30118850f, -0.45425251f, 0.23924305f, -0.20452067f, 
    0.26472181f, 0.19562469f, -0.28650570f, 0.16630283f, -0.32623473f, 0.12871291f, -0.21402073f, -0.23209625f, 
    0.03095921f, 0.13077320f, -0.01904718f, 0.13623773f, 0.22267017f, 0.05754091f, -0.09902692f, -0.46688792f, 
    -0.36855033f, -0.00286002f, 0.57763571f, -0.20033464f, 0.64464629f, -0.08311499f, 0.07473042f, -0.20663567f, 
    0.10569594f, -0.13626131f, -0.06633282f, -0.05854378f, -0.06093096f, -0.17516539f, -0.23078039f, -0.07891943f, 
    0.19267887f, 0.19062936f, -0.07765479f, -0.28694871f, -0.12211025f, 0.04327951f, 0.28817064f, 0.33128852f, 
    0.54214799f, 0.78597784f, 0.02338857f, -0.52556890f, -0.01646418f, 0.05786267f, 0.19925244f, 0.27828312f, 
    -0.24820058f, -0.67575175f, -0.34455949f, -0.09254832f, -0.09815563f, -0.20005012f, -0.12539698f, 0.28572777f, 
    0.03156193f, -0.04618297f, 0.07375862f, -0.01960944f, -0.31784451f, 0.08606344f, 0.10850310f, 0.01488748f, 
    0.00329205f, -0.28789401f, -0.60423273f, -0.63607162f, -0.52946466f, -0.45161575f, 0.19872884f, -0.00727382f, 
    -0.33416596f, -0.23806325f, 0.39004853f, 0.08940116f, 0.38003322f, -0.35347176f, 0.01971472f, 0.02382879f, 
    -0.12876669f, -0.18018346f, -0.04068210f, -0.06653018f, 0.02190346f, -0.24043012f, -0.08258619f, 0.08784113f, 
    -0.08578004f, -0.39540839f, 0.03586115f, -0.80168188f, 0.13896941f, 0.36105990f, 0.15679617f, 0.35402960f, 
    -0.01110126f, 0.02040009f, 0.30277741f, -0.26323384f, -0.12836817f, 0.05304177f, 0.10152523f, -0.02945641f, 
    -0.25416654f, -0.18722287f, 0.06891061f, 0.06059808f, -0.08306406f, -0.10541166f, -0.00564803f, -0.21490428f, 
    0.10052090f, -0.17053407f, -0.35864434f, -0.60219747f, -0.58758450f, -0.35171625f, -0.20944728f, -0.16567770f, 
    0.20740664f, 0.23310734f, 0.03779262f, 0.00961069f, 0.24568959f, 0.32246453f, 0.33168340f, 0.23927513f, 
    0.01038754f, -0.01031647f, -0.16481860f, -0.02408861f, 0.14711000f, -0.21282642f, -0.07870544f, -0.11539211f, 
    -0.02682251f, -0.16498296f, 0.25877944f, 0.00032702f, -0.73510391f, -0.64828718f, -0.18087204f, -0.14646947f, 
    -0.09869679f, 0.34120321f, -0.54075468f, -0.98147565f, -0.48153007f, 0.11225083f, -0.21050958f, -0.37564632f, 
    -0.30877274f, -0.06676418f, -0.32760781f, -0.25350282f, -0.40446180f, -0.17041828f, -0.25535676f, -0.50847954f, 
    -0.29511496f, 0.06869484f, -0.50028181f, 0.11371326f, -0.22780600f, -0.21782744f, 0.27220583f, 0.50452381f, 
    0.68778503f, 0.34615085f, 0.17978419f, 0.02085028f, -0.37204584f, -0.38108736f, -0.29017931f, -0.37711528f, 
    -0.18450426f, 0.15227944f, 0.13461491f, 0.09486316f, -0.07253238f, 0.24837683f, -0.04545054f, -0.18120264f, 
    0.24923159f, -0.18435210f, -0.01830428f, -0.16658324f, 0.10938170f, -0.24268693f, -0.21951930f, 0.31763551f, 
    -0.04948423f, 0.38527700f, -0.53663659f, -0.17428891f, -0.05647337f, -0.05297216f, 0.07959213f, -0.08957783f, 
    0.21743391f, -0.26594168f, 0.03144750f, -0.17478496f, 0.16193591f, -0.05779417f, 0.10758668f, -0.11127746f, 
    -0.18865769f, 0.25653318f, -0.02767748f, 0.17201833f, -0.18556762f, -0.22703020f, 0.31887606f, -0.42425385f, 
    0.28967339f, 0.28397280f, -0.60640144f, -0.83565444f, 0.52866590f, 0.21376733f, 0.12340334f, -0.13951491f, 
    0.12977657f, -0.14992511f, 0.30493072f, -0.06171126f, -0.30768380f, 0.13105407f, -0.07422747f, 0.08047313f, 
    -0.02178275f, 0.03354791f, -0.22851774f, -0.18973601f, 0.38178912f, 0.04093322f, -0.20928721f, 0.31945145f, 
    -0.17103404f, -0.39608884f, 0.47727653f, -0.06316247f, -0.60938716f, 0.42284992f, -0.16837057f, -0.19665426f, 
    0.09398443f, 0.25092703f, 0.31454971f, -0.27292496f, -0.25091675f, 0.32372019f, 0.16645123f, -0.24505624f, 
    0.09209318f, -0.05865324f, -0.23982774f, 0.01831242f, 0.19194666f, 0.10677224f, 0.22457767f, 0.01085434f, 
    -0.17735626f, 0.09670635f, 0.29250380f, -0.06142971f, 0.07457414f, -0.23447679f, -0.04079991f, -0.00568822f, 
    0.19551814f, 0.06849326f, -0.12700477f, 0.13995500f, -0.38575205f, 0.14980023f, -0.08521358f, -0.01919476f, 
    0.15226483f, -0.33790126f, -0.20034795f, 0.04100684f, 0.29965347f, -0.34586707f, -0.27297169f, -0.00172095f, 
    0.21857351f, 0.25276378f, 0.20776157f, 0.16220064f, -0.55771136f, -0.54297221f, -0.05624472f, 0.25888634f, 
    0.19893113f, 0.25098109f, 0.14231570f, 0.03037169f, -0.33999217f, 0.22269924f, -0.23657539f, 0.20336123f, 
    -0.35447490f, -0.38720068f, -0.07914018f, 0.16281767f, 0.14655057f, 0.24657790f, 0.25523570f, 0.15453906f, 
    -0.26598990f, 0.05049964f, -0.21509616f, -0.51851958f, 0.00138340f, 0.24269979f, -0.62910038f, -0.05661992f, 
    -0.15215518f, 0.37142062f, 0.31533131f, 0.26993203f, -0.03476380f, -0.25371730f, -0.11851888f, -0.35748842f, 
    -0.05641501f, 0.32833967f, 0.12395418f, -0.02847338f, -0.10808928f, -0.00180550f, 0.14140762f, -0.12942915f, 
    -0.06774192f, 0.00159166f, -0.25464603f, -0.19958790f, -0.88693541f, -0.68503976f, -0.22430299f, 0.22243193f, 
    0.32676789f, 0.55439055f, 0.45728597f, -0.06841301f, 0.08776409f, 0.08508542f, 0.13202782f, -0.07675669f, 
    0.18800484f, -0.20345613f, -0.31291506f, -0.19006908f, -0.02202863f, -0.33245766f, -0.03879975f, 0.07547615f, 
    0.31704912f, 0.16453463f, -0.24106942f, 0.09669887f, 0.26896933f, 0.65136886f, 0.47314611f, -0.14088395f, 
    -0.25457540f, -0.53700089f, 0.17610838f, 0.00621060f, -0.32840097f, -0.18485233f, 0.21544985f, 0.14037991f, 
    0.00586462f, 0.01008353f, 0.10720498f, -0.07522129f, 0.20343962f, 0.06431076f, -0.04045623f, 0.21594185f, 
    -0.25581387f, -0.07531624f, 0.29373381f, 0.07002364f, -0.19390392f, 0.16270179f, -0.40176231f, -0.18022226f, 
    -0.20389158f, -0.15978311f, -0.20090637f, -0.39334923f, -0.15532579f, -0.34681204f, -0.33109298f, -0.44685367f, 
    0.31784046f, 0.16850632f, 0.14865066f, 0.02464504f, 0.34992629f, -0.15199181f, -0.36317647f, -0.13989642f, 
    -0.34334952f, -0.29037336f, -0.19924968f, 0.02516055f, 0.18487446f, -0.26921600f, -0.12728094f, -1.01137650f, 
    -0.28531504f, -0.02069457f, 0.37551254f, 0.41156581f, 0.18993334f, -0.09585661f, -0.30508402f, 0.49596289f, 
    0.37049687f, -0.31852227f, -0.19752234f, -0.17977898f, 0.06170624f, -0.28103366f, 0.08936432f, -0.10976055f, 
    0.17654613f, 0.30202687f, 0.31905979f, 0.04369024f, -0.17055297f, -0.19514526f, -0.13106917f, -0.34234425f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24337265f, 0.10223226f, 0.16977797f, 0.07920158f, -0.10259081f, -0.03799399f, 0.20580304f, -0.09173008f, 
    0.34754056f, 0.32143018f, -0.09607104f, -0.19720118f, 0.10468873f, 0.25936607f, -0.08237430f, 0.36215213f, 
    -0.14071624f, 0.56712031f, -0.08063369f, -0.09682091f, 0.14266391f, 0.11992461f, -0.22100201f, -0.13592756f, 
    0.09102237f, -0.31259286f, 0.25679609f, 0.06603181f, -0.07731416f, 0.04133876f, 0.02174384f, 0.13113056f, 
    -0.24354841f, 0.09659310f, 0.17232901f, 0.19115657f, 0.29111010f, -0.23498349f, 0.21402475f, -0.05210662f, 
    0.55164474f, 0.30285224f, 0.28091785f, -0.07340204f, 0.24750991f, 0.30114704f, 0.25078273f, 0.06484878f, 
    0.27616036f, -0.03575324f, -0.13723435f, 0.04183849f, -0.09409277f, 0.05921212f, 0.20348057f, 0.21009283f, 
    0.12261771f, 0.43217543f, 0.02802093f, -0.11181233f, 0.05280252f, 0.07122059f, 0.08855776f, 0.03673118f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02007580f, 0.05530927f, -0.07003319f, -0.03232853f, 0.00119156f, -0.03950606f, 0.02033575f, -0.10080636f, 
    -0.15299116f, 0.02781210f, 0.03888056f, 0.11122041f, -0.14786863f, -0.04842246f, -0.12654305f, -0.05280946f, 
    0.00546320f, 0.05571884f, 0.00289686f, 0.05571501f, -0.16300954f, -0.04928721f, -0.21913920f, -0.06007082f, 
    0.29459688f, -0.04357132f, -0.58883572f, -0.00391673f, -0.01292532f, 0.00777620f, -0.10587680f, 0.12516530f, 
    -0.08487176f, 0.06110293f, -0.09792329f, -0.13367407f, -0.01312539f, 0.03468170f, -0.00476647f, -0.00227117f, 
    -0.08198811f, -0.11484131f, -0.09472638f, -0.10281952f, 0.02078338f, -0.03064403f, -0.05896762f, -0.04434406f, 
    0.20380479f, 0.02659888f, 0.05992888f, 0.07939653f, 0.00291035f, 0.02949819f, -0.16047499f, -0.14326854f, 
    -0.01729422f, -0.04010269f, -0.08910169f, 0.15848061f, 0.30337083f, 0.12400980f, -0.02668465f, -0.17141880f, 
    -0.00025616f, -0.07450870f, -0.10887757f, 0.05227744f, -0.05605512f, -0.04063265f, 0.06398375f, 0.09732161f, 
    -0.02661607f, -0.02811491f, 0.07648987f, 0.01630829f, -0.12052779f, 0.03204748f, -0.00761785f, -0.00496398f, 
    -0.09146380f, -0.08138063f, -0.08390356f, -0.05522817f, 0.23738810f, 0.02308320f, -0.11642768f, -0.06337813f, 
    0.12385002f, 0.19702215f, -0.06812724f, -0.05363201f, -0.02312266f, -0.00366378f, 0.00204929f, 0.04494776f, 
    -0.21566816f, 0.00514911f, -0.00317903f, -0.03288510f, -0.09169427f, -0.02467180f, 0.01310718f, -0.05119929f, 
    -0.04755891f, -0.02265587f, -0.04073548f, -0.00360330f, -0.27512291f, -0.28521210f, -0.09308037f, -0.00528729f, 
    -0.03940708f, 0.00463644f, -0.04574926f, 0.00033625f, -0.00240343f, 0.00948728f, 0.03686557f, -0.10360730f, 
    -0.25675285f, 0.10870534f, 0.06456859f, 0.03160071f, 0.01271441f, 0.02524860f, -0.00028032f, -0.02390959f, 
    -0.37039307f, -0.06182024f, 0.05710633f, 0.12772642f, -0.21676572f, 0.19913255f, -0.09341459f, -0.09936244f, 
    -0.01640024f, 0.09531274f, 0.05289487f, 0.01865971f, -0.01360976f, -0.00035262f, 0.28521210f, 0.12562776f, 
    0.16106808f, 0.12526245f, -0.13660122f, -0.08531140f, -0.01772170f, 0.12543811f, 0.13323840f, 0.17328277f, 
    -0.05652414f, -0.07873584f, -0.01435579f, -0.04423853f, -0.35976103f, -0.30410206f, 0.14794977f, -0.00894972f, 
    -0.03683961f, 0.03292893f, 0.00315313f, -0.00499752f, 0.03842609f, -0.07195106f, -0.06525275f, -0.15559790f, 
    -0.00987160f, -0.03446071f, -0.00827650f, 0.03283815f, -0.01753577f, -0.06293314f, -0.31858876f, -0.26176217f, 
    -0.16022603f, -0.04374299f, -0.08384646f, -0.05654629f, 0.03372844f, 0.00663385f, 0.23150499f, -0.33787623f, 
    0.01625943f, 0.00560274f, 0.05936315f, 0.03817726f, -0.04413680f, -0.04007922f, -0.23557968f, -0.07898365f, 
    -0.14432076f, -0.12010271f, -0.12642024f, 0.02408514f, 0.04460946f, 0.02276069f, 0.03826396f, 0.06086395f, 
    -0.05225206f, 0.04000835f, 0.05226433f, -0.00033597f, 0.16466910f, -0.07124294f, -0.33985868f, 0.06807257f, 
    0.03477520f, 0.04001808f, -0.32458726f, -0.09816770f, -0.07776389f, -0.09095259f, -0.01519149f, -0.00786799f, 
    0.22196518f, -0.27130705f, -0.29372996f, 0.00477896f, -0.00916538f, -0.00700681f, 0.08133457f, -0.03757692f, 
    0.05517487f, 0.11177540f, 0.02508040f, 0.19340897f, 0.21666828f, 0.09547029f, 0.03695836f, 0.03323882f, 
    0.09849816f, 0.13704829f, 0.05320561f, -0.11410049f, -0.04567256f, 0.23721227f, 0.01821371f, 0.05577176f, 
    -0.27894410f, -0.00696673f, -0.22542278f, -0.17368695f, -0.01026804f, 0.07020871f, 0.02184189f, -0.00389231f, 
    -0.12820020f, 0.04021135f, -0.05288599f, 0.03962928f, 0.00792242f, 0.18579578f, 0.11627194f, -0.03943254f, 
    0.01303462f, 0.01214201f, 0.00775168f, 0.02076113f, 0.08530650f, -0.13823387f, -0.14530404f, 0.01718602f, 
    0.34100676f, 0.25175831f, -0.14668453f, 0.00453786f, 0.13547631f, 0.07897031f, 0.13289955f, -0.08753865f, 
    -0.01474041f, -0.05626655f, -0.07249885f, -0.00132765f, 0.35312030f, 0.16921648f, -0.19409779f, -0.27106756f, 
    -0.02924679f, -0.00136451f, 0.08922128f, 0.10794833f, 0.01857948f, 0.04191220f, -0.01118580f, 0.04735679f, 
    -0.05486583f, 0.05996627f, -0.03203269f, -0.06531337f, 0.01231444f, -0.00059110f, 0.00248187f, -0.07977018f, 
    0.00077276f, -0.04093656f, -0.08348437f, 0.02677895f, 0.32615912f, 0.14564228f, -0.27268228f, -0.14435782f, 
    0.15899816f, 0.20900624f, 0.05725994f, -0.07097397f, -0.01293259f, 0.04565160f, -0.07004434f, -0.06388244f, 
    -0.26013634f, -0.37333757f, -0.30432492f, 0.03108561f, -0.00446112f, 0.03641288f, 0.02277096f, 0.07637888f, 
    -0.07557502f, -0.05494078f, -0.12695967f, -0.10497291f, -0.40357196f, -0.35496160f, 0.03791030f, 0.00431447f, 
    0.00711197f, 0.00342702f, -0.08492395f, 0.06057828f, -0.04764882f, -0.11961771f, -0.16347209f, -0.03926134f, 
    0.10409489f, 0.06588377f, -0.04299610f, 0.02015537f, 0.09304900f, 0.08341536f, -0.06962138f, -0.05982219f, 
    0.12105132f, 0.01427121f, 0.03966289f, 0.00797121f, -0.13405816f, 0.00033619f, -0.01931655f, 0.02787447f, 
    0.03759007f, 0.01142788f, -0.06812669f, -0.15088312f, -0.06380302f, 0.03873970f, 0.04798959f, 0.04176442f, 
    0.05557457f, 0.16889068f, -0.29358292f, -0.04972005f, 0.13759711f, 0.02505085f, -0.06413153f, -0.03798534f, 
    -0.03618041f, 0.02397302f, 0.01924303f, -0.00495759f, -0.00444262f, -0.11878322f, -0.28774661f, 0.07824425f, 
    -0.07669719f, -0.01394788f, -0.04071093f, 0.01025016f, -0.05581734f, -0.09795643f, 0.08769660f, -0.05732470f, 
    0.31100115f, 0.14420609f, -0.10974330f, -0.09116328f, 0.12351562f, -0.00671931f, -0.07222203f, -0.09732068f, 
    0.02195160f, 0.01067238f, 0.00689409f, -0.01905155f, 0.45275605f, 0.37049776f, 0.15939251f, -0.26565289f, 
    -0.16840130f, 0.00746039f, 0.00414837f, 0.03611540f, -0.03264219f, -0.01811269f, -0.00355573f, -0.08745241f, 
    0.00681131f, 0.00746427f, 0.07134797f, -0.12206856f, 0.06853427f, 0.06212548f, -0.08088029f, -0.23033954f, 
    -0.00381733f, 0.06708257f, -0.07875878f, 0.01352637f, -0.18382572f, -0.17660667f, 0.04270970f, -0.01620308f, 
    0.01244376f, -0.09430664f, 0.12560530f, -0.13569638f, -0.09400956f, -0.13310362f, -0.01964724f, -0.10781991f, 
    0.16849694f, -0.10238496f, -0.02234659f, -0.10880030f, -0.15141661f, -0.13335684f, 0.12879089f, -0.14856008f, 
    -0.08243108f, -0.06645688f, -0.07609449f, 0.01316612f, -0.06736638f, -0.05715581f, -0.09194978f, 0.00880846f, 
    0.01884951f, 0.05581353f, 0.00285901f, 0.03036829f, -0.01745187f, -0.01567619f, -0.05169274f, -0.00958527f, 
    0.14474085f, -0.09181722f, 0.02644289f, 0.03413749f, 0.01768906f, 0.04716181f, -0.09204020f, -0.11512478f, 
    -0.00914101f, 0.01492091f, -0.02873518f, -0.05382344f, -0.11142209f, -0.01188048f, -0.04001411f, 0.00985034f, 
    0.00541180f, -0.04698353f, -0.11659245f, 0.01365252f, -0.02147833f, -0.02502864f, 0.13739519f, 0.16171953f, 
    -0.30314654f, -0.56809127f, -0.74085063f, 0.15286495f, -0.03071624f, 0.05260333f, 0.04674662f, -0.00217362f, 
    -0.01621907f, -0.06894020f, -0.09703964f, -0.06817868f, -0.06038687f, -0.48004386f, -0.13373479f, -0.19560526f, 
    -0.04755838f, 0.00490671f, 0.03009190f, -0.04990434f, -0.11092007f, 0.01312490f, -0.07998136f, -0.04443657f, 
    0.22201189f, 0.12151799f, -0.03337296f, -0.10860110f, 0.05537087f, 0.01174583f, 0.08469619f, -0.05322095f, 
    -0.03736049f, -0.00068969f, -0.02819163f, 0.02181961f, 0.28665578f, 0.16607799f, 0.05836533f, -0.04399144f, 
    0.11167180f, 0.18904699f, 0.07540161f, 0.24368994f, -0.03935490f, -0.08220385f, -0.03413867f, -0.05358272f, 
    0.40585357f, 0.15641302f, -0.02792688f, -0.22129029f, 0.07076468f, 0.11921573f, 0.07497321f, 0.01168942f, 
    -0.04055598f, -0.06935730f, -0.09605496f, -0.18273927f, 0.24939539f, 0.25021175f, -0.09219465f, -0.25649989f, 
    0.04400618f, 0.01523974f, 0.07044968f, 0.00102895f, 0.05275869f, -0.02644587f, -0.00855456f, -0.05004229f, 
    0.12162219f, 0.17789218f, -0.12504661f, -0.11203773f, -0.10100751f, 0.00936681f, 0.03933463f, -0.09059917f, 
    -0.08956975f, -0.07322135f, -0.01310858f, -0.06062352f, 0.23573600f, -0.11106780f, 0.06910940f, -0.14215389f, 
    -0.15206651f, 0.03249407f, 0.09405072f, -0.07365937f, 0.08173424f, -0.07785355f, -0.13634939f, -0.08058930f, 
    -0.25284031f, -0.33392936f, -0.42441827f, 0.29703352f, -0.01651087f, 0.00670669f, -0.03709409f, 0.06313394f, 
    -0.03154877f, 0.05173373f, 0.01813470f, -0.00034187f, 0.29418051f, 0.09504533f, -0.04646144f, -0.02741205f, 
    0.06470793f, 0.02383033f, -0.04250129f, -0.02136884f, -0.09230471f, -0.03531836f, -0.09085014f, 0.03978677f, 
    0.10331591f, -0.08177848f, -0.05729372f, 0.04831301f, 0.00325943f, -0.01173127f, 0.05584640f, -0.02812679f, 
    -0.00200451f, 0.13501705f, 0.08335344f, 0.07555072f, 0.11591338f, 0.11412173f, 0.03814268f, 0.01648045f, 
    0.07703065f, 0.07509337f, 0.06907146f, 0.01251323f, -0.02524809f, -0.08323614f, -0.04392335f, 0.03717583f, 
    0.31888944f, 0.22680554f, -0.04241173f, -0.15353206f, 0.01682035f, 0.05157920f, 0.00029746f, -0.06131734f, 
    -0.17020990f, -0.18945412f, -0.06093010f, 0.03568399f, -0.15195696f, -0.51277155f, -0.22986560f, -0.03888728f, 
    -0.01996027f, -0.02368236f, 0.01050148f, 0.02820158f, 0.00469172f, 0.03273788f, 0.02606614f, 0.03344652f, 
    -0.03388350f, -0.06646816f, 0.08695855f, -0.12996772f, -0.09434496f, 0.10061602f, -0.07591985f, -0.17125052f, 
    0.02396539f, -0.05520090f, -0.02725372f, -0.08177179f, 0.06334731f, -0.25025976f, -0.14434293f, -0.01867961f, 
    -0.03961017f, 0.10820446f, -0.15092519f, -0.14339364f, -0.01989657f, -0.00041670f, -0.06597663f, -0.03365504f, 
    -0.03397216f, -0.19694491f, 0.03458415f, -0.19762821f, -0.00289582f, 0.03472707f, -0.14340167f, 0.03202200f, 
    -0.00404871f, -0.06487567f, -0.06379157f, -0.04492940f, -0.42636052f, -0.40810302f, -0.04360894f, -0.04899818f, 
    -0.02906393f, 0.00010446f, 0.04024379f, 0.02381452f, -0.15939118f, -0.04468040f, -0.07840493f, -0.10583407f, 
    -0.12624249f, -0.14978687f, -0.41359785f, 0.11799848f, 0.04919046f, 0.05440431f, -0.01103627f, -0.02022011f, 
    -0.01660215f, -0.05164479f, -0.00082484f, -0.23974603f, -0.25779569f, -0.08673682f, 0.13226448f, 0.06163257f, 
    0.00681416f, 0.06362569f, -0.00815516f, 0.03478079f, 0.01487386f, -0.00910440f, 0.17605670f, 0.15824553f, 
    0.30098906f, 0.22656848f, -0.30317548f, -0.19784258f, -0.02564864f, -0.01379110f, 0.14731231f, -0.06155059f, 
    -0.07360565f, -0.05363135f, -0.12007581f, -0.32225746f, -0.00227763f, -0.04611412f, -0.04060352f, 0.08120729f, 
    -0.12987727f, -0.01881547f, -0.02838121f, -0.12370895f, -0.18659295f, -0.13346383f, -0.00616834f, -0.00701136f, 
    0.27753428f, 0.19215876f, -0.10107320f, -0.11636080f, -0.10544218f, -0.01297821f, -0.03511209f, -0.06597265f, 
    -0.00962464f, -0.09645789f, -0.12679857f, -0.06993638f, 0.26747441f, 0.29467446f, 0.13982870f, -0.09323400f, 
    -0.02979602f, 0.04942991f, 0.04355490f, -0.15421961f, 0.15048192f, 0.07689255f, -0.03934973f, -0.11566714f, 
    0.34446564f, -0.12954147f, -0.10420055f, -0.09280575f, 0.05674435f, 0.08309966f, 0.01383884f, -0.29323864f, 
    0.23252785f, 0.03566212f, -0.08379257f, -0.08459210f, -0.07258464f, -0.15443392f, 0.13977793f, -0.02333114f, 
    -0.12658572f, -0.03484935f, 0.06205426f, 0.02880955f, -0.10705633f, -0.03224539f, 0.05819676f, 0.07920387f, 
    0.13337681f, -0.36176473f, -0.37489292f, -0.01336354f, -0.11457904f, -0.13675773f, 0.17955501f, 0.15438315f, 
    -0.07660842f, 0.04497429f, -0.15067227f, 0.19737224f, -0.00773918f, -0.01614588f, 0.02922903f, -0.08108047f, 
    0.05810868f, 0.00557239f, -0.04014935f, 0.04860742f, -0.06601796f, -0.03485998f, 0.02612933f, -0.02773565f, 
    0.63024670f, -0.00627598f, 0.21928450f, -0.17341843f, 0.01824247f, 0.02281918f, 0.01499539f, -0.05555679f, 
    0.09556910f, -0.06114505f, 0.00715052f, -0.17386881f, -0.05857702f, 0.03036451f, 0.06030450f, 0.04041798f, 
    0.01134460f, -0.01348964f, -0.18048151f, 0.03575553f, 0.06723344f, -0.04493084f, 0.03494498f, 0.01333902f, 
    -0.03319260f, 0.04670878f, 0.06988519f, -0.01131751f, 0.09732737f, 0.07148984f, 0.01789687f, 0.04747852f, 
    -0.12007677f, -0.04795159f, 0.00447956f, -0.00985685f, 0.40828976f, 0.40810454f, 0.22673358f, -0.09150273f, 
    -0.00732412f, -0.00015011f, -0.02386006f, 0.06400204f, -0.04516217f, -0.03382329f, 0.07171708f, -0.22978707f, 
    0.08727023f, -0.01932039f, 0.09474850f, 0.03423112f, 0.00229068f, 0.04784409f, 0.13796306f, -0.08205347f, 
    0.03160666f, -0.06066930f, 0.03713290f, 0.14923902f, 0.75049353f, 0.10787508f, 0.13738617f, 0.09262047f, 
    0.01500996f, 0.01151153f, 0.05315580f, -0.13410582f, 0.06253831f, 0.11991348f, -0.15986422f, 0.04780963f, 
    -0.04544447f, 0.08125926f, -0.02226344f, -0.02396876f, 0.04153867f, -0.00550581f, -0.02810969f, 0.04619762f, 
    -0.28671029f, -0.04942556f, -0.14947626f, -0.11290645f, -0.23418887f, -0.28676996f, -0.17506272f, 0.05453946f, 
    -0.03256091f, -0.02306311f, -0.03206253f, 0.06507461f, -0.38369808f, -0.13325793f, -0.30723938f, -0.26355353f, 
    -0.13533051f, -0.11718848f, 0.14241090f, 0.07005721f, 0.14228892f, -0.00509164f, -0.09706412f, 0.10902525f, 
    -0.01079998f, 0.01123677f, 0.02296868f, 0.05149897f, -0.33496335f, -0.01299986f, 0.01480673f, -0.11565328f, 
    -0.04478430f, -0.04354322f, 0.11516658f, -0.04366615f, 0.10005780f, -0.09906568f, 0.07665945f, 0.02421683f, 
    0.15548731f, -0.09084489f, -0.05550500f, 0.04147120f, -0.13885699f, 0.07428132f, 0.04119286f, 0.00508405f, 
    -0.03771596f, -0.11186662f, -0.04997373f, -0.08085899f, -0.97453284f, -0.38272932f, -0.29865175f, -0.32273000f, 
    -0.07290635f, 0.04992096f, -0.02043289f, 0.07881174f, 0.09232923f, -0.01766670f, 0.04549839f, 0.06684238f, 
    0.22128476f, 0.12106288f, 0.26891348f, 0.17230557f, 0.00103411f, 0.00969250f, 0.02451707f, 0.04504609f, 
    0.01521489f, 0.01286585f, -0.01705576f, -0.07007152f, 0.36005086f, -0.43145984f, -0.15621544f, -0.26925001f, 
    0.09945927f, 0.03253461f, 0.06838474f, 0.09575035f, 0.15905531f, -0.05746454f, -0.02648764f, 0.03914808f, 
    0.30855045f, -0.14493573f, -0.15520291f, -0.00304786f, -0.02969201f, 0.01632886f, -0.00538371f, -0.05365054f, 
    -0.16861598f, -0.37033966f, 0.02109754f, -0.19228956f, 0.04497933f, -0.05407546f, -0.12355321f, -0.01605182f, 
    -0.01479380f, -0.01076835f, -0.07386208f, -0.15624607f, -0.02572060f, -0.07185271f, 0.08253960f, -0.05237552f, 
    -0.06378662f, -0.26543751f, -0.02535408f, 0.19408926f, 0.05603253f, -0.03773940f, -0.00271408f, 0.00241180f, 
    0.01483044f, 0.02207654f, 0.12944520f, 0.03083896f, -0.11657260f, -0.05795962f, -0.02647952f, -0.01072572f, 
    -0.04980260f, -0.00631299f, 0.02512913f, 0.03796639f, -0.15173863f, -0.01424463f, -0.07801312f, 0.02247885f, 
    0.17115438f, -0.11293112f, 0.00735009f, 0.18775545f, -0.27949524f, 0.05653477f, 0.03086575f, 0.05116895f, 
    0.00305337f, -0.00419065f, -0.12847477f, 0.04219053f, -0.07768651f, 0.01889689f, 0.05037440f, 0.03339936f, 
    -0.15887624f, -0.13785654f, 0.11265662f, -0.02028860f, -0.02389551f, -0.01752329f, 0.01055945f, 0.05067340f, 
    0.15278837f, 0.00705023f, -0.04682265f, 0.04178193f, -0.03741718f, 0.04163302f, 0.05297770f, -0.00110925f, 
    -0.03993686f, 0.01063944f, 0.08919204f, -0.01693640f, -0.03333734f, 0.12222262f, 0.20095080f, -0.11875416f, 
    0.01736467f, 0.03819631f, 0.11223907f, 0.17167059f, -0.02885190f, 0.02570128f, -0.02333112f, 0.10632762f, 
    0.03461636f, 0.09932818f, -0.04171778f, 0.15732187f, -0.01849427f, -0.11292364f, 0.09090155f, -0.00588396f, 
    0.01127400f, 0.18586825f, -0.07536894f, 0.07597052f, 0.13688052f, -0.01205004f, 0.11298194f, -0.09959020f, 
    -0.00034100f, -0.02350618f, -0.00626442f, 0.01639673f, 0.07336821f, -0.12205626f, -0.17037459f, 0.09833229f, 
    -0.21572040f, 0.04841280f, 0.15648986f, 0.04752956f, 0.05216771f, -0.02907956f, 0.08064589f, -0.17544052f, 
    -0.02065287f, 0.00120905f, -0.02248498f, -0.17389199f, 0.02325531f, 0.01548288f, 0.10373957f, -0.04467042f, 
    -0.03990281f, -0.05675906f, 0.00024074f, -0.04900451f, 0.09169452f, -0.08631655f, -0.01126576f, 0.03378120f, 
    0.27382934f, -0.05557745f, -0.20009942f, 0.01822698f, -0.16291855f, -0.02569288f, -0.10748637f, 0.02140701f, 
    -0.02525952f, -0.01227928f, 0.02935368f, 0.02664653f, 0.25644761f, -0.08154302f, -0.09101974f, -0.03215042f, 
    0.10629411f, -0.02891297f, -0.19217859f, 0.01252882f, 0.04364701f, -0.01425518f, 0.06960633f, -0.12240479f, 
    0.14311640f, 0.33237332f, 0.11508343f, 0.20745456f, -0.17727657f, 0.10962125f, -0.29305565f, -0.25192371f, 
    -0.07001506f, 0.01244201f, -0.05528629f, -0.02937946f, -0.49565056f, 0.01232931f, -0.67793286f, -0.38881946f, 
    0.01346511f, -0.15099031f, 0.11119592f, -0.01761814f, 0.07674552f, 0.05609685f, 0.01405913f, -0.09310134f, 
    -0.11475284f, -0.02117246f, 0.00956546f, 0.00693262f, -0.01050943f, 0.25690824f, 0.11778297f, 0.06946415f, 
    -0.13384582f, 0.07390633f, -0.00025314f, 0.07529171f, -0.06799196f, -0.16905279f, 0.16206042f, -0.14463577f, 
    0.05221749f, 0.09538282f, -0.00657481f, -0.17409728f, 0.02581220f, 0.08882170f, -0.04323236f, 0.02766531f, 
    0.02695527f, -0.07683582f, 0.04272936f, 0.08848417f, 0.05468494f, -0.01217575f, 0.12677978f, 0.00096717f, 
    0.23726271f, -0.08325352f, 0.07621057f, 0.00247160f, 0.11603169f, 0.08938720f, 0.12896210f, 0.08762937f, 
    -0.03724235f, -0.01321423f, -0.00445865f, -0.06571577f, 0.02178469f, 0.02067380f, 0.05534974f, 0.04897174f, 
    -0.18349971f, -0.00652363f, -0.02346681f, -0.13784489f, 0.01853510f, 0.05889468f, -0.26972562f, -0.20548654f, 
    0.06923871f, -0.02484790f, -0.11124813f, -0.06460290f, -0.01634030f, -0.07763252f, 0.10694816f, -0.22504896f, 
    0.03479958f, 0.03942211f, -0.09391002f, 0.01779699f, -0.24697192f, -0.06929500f, -0.16933149f, -0.17788897f, 
    0.95173091f, 0.22146685f, 0.28749070f, 0.24559395f, -0.04290655f, -0.04466124f, 0.03085773f, 0.00651523f, 
    -0.00596855f, 0.14713997f, -0.02413695f, 0.12811926f, 0.27404398f, -0.11249801f, -0.11105482f, -0.12016027f, 
    -0.13925415f, 0.00111878f, 0.14204256f, -0.20162810f, 0.18504919f, -0.10723884f, -0.01276882f, -0.01606449f, 
    -0.00090339f, 0.07785553f, -0.18512182f, -0.23908252f, -0.10586210f, 0.11714993f, -0.01476822f, 0.04689030f, 
    0.03211318f, -0.00924534f, 0.01250678f, -0.02163301f, 0.02881914f, -0.08365144f, 0.11304110f, -0.07179823f, 
    0.05211236f, -0.14614499f, -0.03880760f, -0.30884454f, -0.04157057f, -0.05845701f, 0.02763209f, 0.00528815f, 
    0.03030582f, -0.17205369f, -0.01827383f, -0.15303111f, 0.16477591f, -0.11006368f, 0.03801945f, -0.09386475f, 
    0.03972435f, 0.04447174f, -0.05117344f, -0.06415073f, -0.33844468f, 0.04239207f, -0.27520359f, 0.06342275f, 
    -0.02998282f, 0.03071216f, 0.16952451f, -0.04226206f, -0.01641868f, -0.01897736f, 0.03861717f, 0.04904195f, 
    0.01086200f, -0.16783145f, -0.18130963f, 0.07678784f, -0.02672825f, -0.02203807f, 0.16159579f, 0.10955950f, 
    -0.00712933f, 0.15350682f, -0.01063320f, -0.00781209f, -0.02401631f, 0.04960115f, -0.16435921f, -0.01713207f, 
    -0.09855237f, 0.02455430f, -0.01710638f, 0.05769334f, 0.20297146f, 0.05436246f, 0.05359394f, 0.05888877f, 
    0.42903161f, -0.17203896f, 0.15367472f, 0.13103622f, -0.07763995f, -0.16584928f, 0.04536529f, -0.08392023f, 
    -0.04223018f, 0.05025757f, -0.05311035f, 0.03149370f, 0.05121257f, 0.11612675f, -0.06078722f, 0.08091579f, 
    -0.02244436f, 0.09318049f, -0.10242335f, -0.11535134f, 0.03655271f, 0.00860468f, -0.10025272f, -0.04127007f, 
    0.05738582f, 0.00176302f, 0.00808369f, -0.01670624f, -0.09008678f, -0.00995589f, 0.04400369f, -0.02365133f, 
    -0.25359711f, -0.13888843f, -0.01208031f, -0.19696569f, 0.00931758f, -0.15718672f, -0.13620870f, -0.03870711f, 
    -0.01622562f, 0.02075928f, 0.00439940f, 0.04386328f, 0.02918321f, 0.03554827f, 0.04161242f, -0.00510197f, 
    0.26158667f, 0.12070796f, -0.08627771f, 0.31958216f, -0.02541833f, -0.13144445f, 0.06676059f, 0.16297723f, 
    0.07406128f, -0.00262088f, 0.05545676f, -0.03878152f, 0.11915003f, 0.12426897f, -0.03714004f, -0.01124387f, 
    -0.02267306f, -0.08370421f, 0.00358912f, -0.04031716f, 0.03889178f, 0.01736499f, -0.04987641f, 0.01173163f, 
    -0.13265578f, 0.05077663f, -0.00576888f, -0.12496029f, 0.06425043f, -0.01927433f, -0.05234049f, -0.05911174f, 
    -0.04296142f, 0.06768454f, -0.04137476f, -0.04996850f, -0.02417202f, 0.15361023f, 0.15284064f, -0.10647549f, 
    0.07464503f, 0.06509925f, -0.04868014f, -0.07926698f, -0.08359466f, 0.13579719f, -0.14954297f, 0.00420410f, 
    -0.03854087f, 0.04515358f, -0.03686599f, -0.31477937f, -0.10928272f, -0.02644406f, 0.03650628f, 0.20512713f, 
    -0.10892095f, -0.08431333f, 0.19647765f, -0.15889223f, 0.05256252f, 0.10054521f, 0.17369986f, 0.06708409f, 
    -0.08862891f, -0.02533842f, 0.09910435f, -0.03140568f, 0.05112854f, 0.05618274f, 0.03447237f, 0.03854097f, 
    0.25361243f, -0.05818368f, -0.03276772f, -0.10915551f, -0.01379258f, -0.06572902f, 0.01388691f, 0.02265224f, 
    -0.11468857f, -0.03351505f, 0.06120044f, -0.01091849f, -0.09701345f, -0.00247153f, 0.03299267f, -0.00811399f, 
    -0.01861781f, 0.02243646f, -0.12354881f, -0.04503464f, -0.06856371f, 0.13235219f, -0.02591692f, -0.38715217f, 
    -0.00425791f, -0.03745040f, -0.14568675f, 0.06846493f, -0.06275420f, -0.02038939f, 0.00685865f, 0.08028959f, 
    0.07058558f, -0.07640101f, 0.04672276f, 0.10575292f, 0.12273476f, -0.02298073f, -0.00786648f, -0.09334811f, 
    0.06149282f, 0.07607391f, -0.03010046f, -0.09838141f, -0.05707191f, 0.03249041f, -0.01071625f, 0.01470149f, 
    -0.13782768f, -0.07471211f, 0.09905422f, -0.11641490f, 0.02627059f, 0.15774776f, -0.04364810f, 0.17389344f, 
    -0.06319113f, 0.05119612f, 0.01474190f, 0.03998143f, -0.12996511f, 0.12912560f, -0.09997769f, -0.02405628f, 
    -0.07506369f, 0.07513011f, -0.05046833f, 0.05738876f, 0.03974954f, -0.18930723f, -0.02685237f, -0.00629853f, 
    -0.09385528f, 0.38567421f, 0.01124829f, 0.14936969f, -0.07951654f, 0.07526010f, 0.00594504f, -0.08782941f, 
    0.02695591f, 0.16826947f, -0.02116362f, 0.11550673f, 0.03952671f, -0.20047586f, -0.06819340f, 0.15247913f, 
    0.00718892f, 0.01368437f, 0.05664314f, 0.01410333f, -0.12107956f, -0.10402570f, -0.05017148f, -0.06596631f, 
    -0.17690122f, -0.16036563f, 0.15184416f, -0.36536935f, 0.00821621f, -0.10390845f, -0.03524042f, -0.26891226f, 
    0.02405288f, 0.03412364f, -0.11278093f, 0.01843402f, -0.03941368f, -0.04190091f, 0.03614381f, -0.01961421f, 
    0.07033134f, 0.15857792f, -0.03215981f, 0.03204170f, -0.00097014f, -0.06508423f, 0.10144760f, -0.06309202f, 
    -0.30753741f, -0.12741356f, 0.41965964f, 0.05153513f, 0.02289545f, 0.08478154f, -0.02219740f, -0.07397565f, 
    0.04713554f, -0.09138250f, 0.12914535f, -0.13088308f, 0.05362812f, 0.03563267f, -0.08674009f, 0.19717321f, 
    -0.05388024f, 0.05443466f, -0.02949260f, -0.17001790f, 0.02278396f, 0.13372114f, 0.02968592f, 0.00851345f, 
    0.00739724f, -0.04005531f, -0.00797536f, 0.03560242f, -0.15840621f, 0.05574105f, 0.04052532f, -0.02292768f, 
    -0.01335061f, -0.05350466f, 0.04543506f, -0.02566756f, 0.12283229f, 0.29756325f, 0.83448583f, 0.70557356f, 
    -0.01564489f, -0.02593068f, 0.11194443f, 0.13561107f, 0.03161974f, -0.03201028f, 0.01338369f, -0.01541769f, 
    -0.01057102f, -0.00439337f, -0.01433139f, 0.08167072f, 0.02705319f, -0.08804407f, -0.00446353f, 0.00419020f, 
    0.05615776f, 0.01502128f, -0.14132622f, 0.15390043f, -0.31014168f, 0.04811076f, 0.00916344f, -0.04235245f, 
    -0.01755334f, -0.00299822f, 0.02848758f, -0.05846278f, 0.04205648f, 0.01545059f, -0.12364636f, 0.03766952f, 
    -0.16284604f, 0.02865911f, -0.04040406f, 0.10947773f, -0.04566994f, -0.01114670f, -0.03900352f, -0.00585860f, 
    0.10779843f, 0.07089228f, 0.06478730f, 0.18106848f, -0.07123258f, -0.20220871f, -0.08846513f, 0.07829726f, 
    -0.02251240f, -0.01111383f, -0.01013643f, 0.04493375f, -0.05801438f, 0.02471833f, -0.13840875f, 0.22608164f, 
    0.29531527f, -0.15173405f, 0.17904605f, -0.01594235f, 0.13577597f, -0.02708701f, -0.02547332f, -0.09581568f, 
    0.00275383f, -0.00812703f, -0.03550317f, -0.01131211f, 0.14928344f, 0.16160248f, -0.14733696f, 0.24054551f, 
    -0.10114022f, 0.01911990f, 0.12546255f, -0.02967384f, 0.01635921f, -0.14096461f, 0.07004484f, -0.02509217f, 
    -0.04446550f, 0.08009282f, 0.01542512f, -0.03639153f, -0.12706846f, 0.04617157f, 0.05631313f, -0.05452463f, 
    -0.00168334f, -0.04431906f, -0.04083955f, 0.02069216f, 0.22233276f, -0.00666096f, -0.44879365f, -0.01241370f, 
    0.05604449f, 0.07438638f, -0.08945462f, -0.17467158f, 0.13035679f, -0.11488877f, -0.11132543f, 0.08603653f, 
    -0.17552841f, -0.23111039f, -0.22651377f, -0.19055222f, -0.02946662f, -0.00402282f, -0.00243011f, -0.00317405f, 
    0.00450450f, -0.06122239f, -0.02664254f, -0.06869560f, 0.10585871f, 0.15843768f, 0.03002354f, -0.03499216f, 
    0.00889942f, -0.05872576f, 0.02237600f, -0.10532895f, 0.03361195f, 0.03111131f, 0.04111418f, 0.00631416f, 
    0.05898558f, 0.01718710f, 0.23010069f, -0.02614529f, -0.06469654f, -0.01755937f, 0.02001690f, 0.03858403f, 
    0.01991522f, 0.07777315f, 0.21234789f, 0.04119685f, 0.06650999f, 0.06803367f, 0.07661702f, 0.22872567f, 
    -0.07959034f, -0.01868334f, 0.04121159f, 0.09590875f, -0.16205035f, -0.00962341f, -0.05381354f, 0.04548895f, 
    0.09378603f, -0.05029621f, -0.30167729f, -0.03051758f, -0.00360302f, -0.06461228f, 0.07007722f, 0.03714485f, 
    -0.06996758f, 0.09530931f, -0.07793817f, -0.09353479f, 0.02133022f, -0.05385285f, 0.04865102f, 0.10263253f, 
    -0.05224372f, 0.00226524f, 0.01416604f, 0.04830674f, -0.08431602f, 0.01104143f, -0.05377816f, 0.09357312f, 
    -0.52708071f, -0.31200835f, 0.01442166f, -0.27559975f, 0.05297690f, -0.17809680f, 0.08541647f, 0.14455816f, 
    0.00970972f, -0.02054786f, 0.02528550f, -0.03699993f, -0.78176934f, -0.69112730f, -0.29328918f, -0.33923844f, 
    0.00452716f, -0.10080567f, 0.01314816f, -0.27851808f, 0.00967422f, -0.04149344f, 0.00065803f, -0.02303353f, 
    -0.16109754f, -0.06026075f, 0.05188331f, 0.06649631f, -0.00532316f, -0.01433912f, -0.01225629f, -0.06742936f, 
    -0.00459460f, 0.02884858f, -0.01848756f, 0.00508539f, -0.89895093f, -0.23627941f, -0.15139578f, -0.37835586f, 
    -0.03770117f, 0.01103657f, -0.15259171f, -0.04050360f, -0.00888920f, 0.01586498f, -0.04727453f, -0.01149406f, 
    -0.04608534f, 0.01456444f, -0.03648308f, -0.06627540f, 0.00143337f, -0.00704753f, 0.04276896f, 0.01322825f, 
    -0.05074653f, -0.19618289f, 0.12942478f, 0.05873929f, -0.14391151f, 0.05433695f, -0.06428322f, -0.07082871f, 
    -0.02372652f, -0.00980792f, -0.09187441f, -0.02845999f, -0.00206318f, -0.07165071f, 0.20154451f, 0.00339799f, 
    -0.04109562f, -0.15229605f, 0.28994977f, 0.02180495f, -0.04926386f, 0.18426123f, 0.06561567f, -0.15086360f, 
    -0.02816849f, -0.00814784f, 0.06045033f, 0.02785050f, -0.05276672f, -0.17961557f, 0.11650599f, -0.26382229f, 
    0.05939526f, -0.01872022f, -0.05231244f, -0.07323322f, 0.05986937f, -0.07803953f, -0.04806389f, 0.07580669f, 
    -0.28562191f, -0.12626383f, 0.12925829f, -0.05683519f, 0.03131686f, -0.12665240f, -0.22652251f, -0.00603216f, 
    -0.01302099f, -0.01321637f, 0.05644820f, -0.10111627f, -0.04408104f, 0.07963349f, 0.12176630f, -0.17764983f, 
    0.02572919f, -0.01238098f, -0.00828298f, -0.21761581f, 0.06505539f, 0.17278010f, -0.04264768f, -0.05118496f, 
    -0.47086528f, -0.04782580f, -0.17167422f, -0.18911569f, -0.05855614f, -0.03623941f, 0.10804103f, 0.02597225f, 
    0.02835426f, -0.04950985f, -0.06322549f, -0.00152710f, 0.11992279f, 0.39295143f, -0.32863727f, -0.02056441f, 
    0.04495475f, 0.04074591f, -0.05443487f, 0.09644429f, -0.08567068f, -0.00098258f, 0.03923425f, 0.02669108f, 
    -0.01308337f, 0.02586231f, -0.09939131f, 0.05261045f, -0.07890771f, -0.04667919f, 0.20288353f, -0.13542372f, 
    -0.00212250f, 0.03386412f, -0.00509265f, 0.08312660f, -0.27438006f, 0.23729731f, -0.04662083f, -0.03691559f, 
    -0.00153402f, 0.04657770f, -0.15474704f, -0.06025521f, -0.03450656f, -0.02948346f, 0.05006109f, 0.13606854f, 
    -0.01174877f, 0.08353744f, 0.10235077f, 0.16538487f, 0.08803153f, 0.05737835f, -0.11545277f, 0.09897484f, 
    0.04374539f, -0.03918489f, 0.08061179f, -0.12343020f, -0.33391774f, -0.22011855f, -0.26584765f, -0.03890967f, 
    0.00467823f, 0.01382703f, 0.04554273f, 0.03823403f, -0.03909133f, -0.04675686f, 0.09808668f, -0.04959419f, 
    0.24839616f, 0.26052344f, 0.05162902f, 0.18225552f, -0.08017513f, 0.06120637f, -0.04814499f, 0.09560575f, 
    0.13132352f, 0.07182841f, -0.07587089f, 0.09388533f, -0.01691495f, 0.01544812f, 0.09672582f, -0.09716885f, 
    0.03007142f, -0.06845623f, -0.03870967f, -0.09821744f, 0.15451476f, 0.21548726f, -0.03514517f, 0.01965427f, 
    -0.18973605f, 0.00107039f, 0.06754773f, 0.02698995f, -0.01885554f, -0.00016995f, 0.00071403f, -0.02762008f, 
    0.01508325f, 0.01049226f, 0.07981114f, 0.07009116f, -0.20930560f, 0.24064755f, 0.00122402f, -0.17852835f, 
    -0.03079991f, -0.00372188f, -0.01077547f, -0.24327800f, 0.11958385f, 0.05386236f, -0.06838350f, 0.08762386f, 
    -0.36671895f, -0.01219088f, 0.01533163f, -0.06756561f, 0.00866276f, -0.05629509f, 0.00664924f, -0.05710517f, 
    0.00507650f, 0.03395354f, 0.02043644f, -0.04818914f, -0.19976114f, -0.03285435f, 0.07591769f, -0.08509693f, 
    -0.04043901f, 0.02129075f, -0.03819991f, 0.08671881f, 0.02079378f, -0.01486160f, 0.07609235f, -0.08812809f, 
    -0.19428237f, 0.14239582f, 0.00954768f, 0.02454840f, 0.00978858f, -0.01721306f, -0.05937890f, 0.11724133f, 
    -0.04890226f, -0.01281085f, -0.00043150f, 0.03814405f, -0.04605336f, -0.15716471f, -0.32964638f, 0.02182384f, 
    -0.06807142f, 0.11167830f, -0.21769430f, 0.01308506f, -0.02401054f, -0.01088405f, 0.03817568f, -0.03042401f, 
    0.02738184f, -0.12046044f, -0.00062611f, -0.11211917f, 0.07630366f, -0.10032091f, 0.10307521f, 0.10209035f, 
    0.05603572f, 0.06412975f, -0.03327384f, -0.06162236f, -0.28787470f, 0.12993738f, 0.06272201f, -0.10626792f, 
    -0.08223370f, -0.01817553f, -0.04880437f, -0.00172530f, -0.14439960f, 0.06463701f, 0.07349542f, -0.27392000f, 
    0.04722348f, -0.27990702f, 0.06515174f, -0.29980636f, 0.05330376f, 0.01934136f, 0.05669193f, 0.00069164f, 
    -0.02327220f, 0.03409803f, -0.04187158f, 0.03416692f, 0.09542464f, -0.00238192f, 0.28097373f, 0.07501688f, 
    -0.08327420f, -0.08660478f, 0.13321906f, -0.01045505f, -0.02691810f, 0.02618273f, 0.01171804f, 0.00349057f, 
    0.03100169f, 0.04902896f, -0.11312709f, 0.05533648f, -0.02393721f, 0.03038744f, 0.00327334f, 0.04700850f, 
    0.10078482f, 0.05324674f, 0.09566801f, -0.00053255f, 0.13703808f, 0.03647703f, 0.14314565f, 0.07579124f, 
    -0.01803151f, -0.01931317f, -0.02344611f, 0.01968245f, -0.17765050f, -0.18895565f, 0.13512686f, 0.03589741f, 
    -0.26792386f, -0.22322513f, 0.15838821f, 0.14014827f, 0.04389303f, -0.05564364f, -0.19038826f, 0.04678874f, 
    -0.05045774f, -0.07999200f, -0.05685702f, -0.20230788f, -0.19030128f, 0.36166930f, -0.39475644f, -0.26107490f, 
    0.03802938f, -0.05651782f, 0.03967516f, 0.07349025f, -0.00919464f, 0.06315657f, 0.00739333f, -0.06153795f, 
    -0.01157111f, 0.08238348f, -0.05412910f, -0.06842081f, 0.04029305f, -0.01365954f, -0.22163986f, 0.01265457f, 
    -0.01177334f, 0.00150600f, -0.06911687f, -0.00207045f, 0.09549288f, 0.12176137f, 0.18040821f, 0.08106432f, 
    0.02346570f, 0.00646700f, -0.20670728f, 0.15121542f, -0.01503808f, 0.05400805f, -0.06387908f, 0.06625123f, 
    0.16976424f, 0.13470419f, 0.11310318f, 0.05002544f, 0.09638578f, -0.04671031f, 0.00883706f, 0.00341751f, 
    -0.00309708f, -0.03869637f, -0.09162669f, 0.09925534f, -0.04068945f, 0.08997712f, -0.09573391f, -0.06038933f, 
    0.02280027f, 0.03109103f, -0.01129400f, 0.04131587f, -0.12738159f, 0.04354430f, -0.08858988f, 0.00155025f, 
    -0.05310873f, 0.15752189f, 0.09118339f, 0.15429845f, -0.10681017f, -0.03686095f, 0.02604363f, 0.14275384f, 
    0.15874361f, -0.08203497f, -0.02545589f, -0.06307478f, 0.16676076f, 0.02594835f, 0.03560979f, 0.00542210f, 
    -0.01605428f, -0.00095211f, 0.05555627f, -0.00690839f, -0.01174705f, 0.18979129f, -0.09500500f, 0.03932644f, 
    -0.17997663f, -0.16445683f, 0.21166001f, 0.25991076f, 0.09276030f, -0.07344682f, 0.08446112f, 0.02301764f, 
    0.15306363f, -0.01248716f, -0.17669590f, -0.16423486f, -0.06147869f, -0.02304807f, 0.13286585f, -0.08432429f, 
    0.03564845f, -0.05250575f, -0.13174775f, 0.05496180f, 0.07775531f, -0.11776696f, 0.01176464f, 0.07680678f, 
    -0.25852251f, -0.14203513f, -0.02115691f, -0.13862474f, 0.06233196f, -0.01269551f, 0.05994698f, -0.09037809f, 
    -0.00508819f, 0.07424673f, -0.03279641f, -0.01557351f, -0.09493145f, -0.06109465f, -0.16310094f, 0.23559456f, 
    0.03508826f, -0.00762135f, -0.00737736f, 0.20141271f, 0.10254247f, 0.07922529f, 0.03344801f, -0.09950519f, 
    -0.41454899f, 0.06659637f, 0.00086336f, 0.14651076f, -0.05708028f, 0.03487041f, 0.03728504f, -0.07808155f, 
    -0.11018444f, -0.00492940f, 0.10753335f, -0.04609007f, 0.09484550f, 0.16137658f, -0.03971059f, -0.10993251f, 
    0.16986947f, 0.09555746f, -0.06013778f, 0.09440500f, -0.01028086f, 0.04922926f, -0.09484223f, -0.00160374f, 
    -0.06839921f, -0.16925092f, 0.37411886f, 0.12370906f, 0.04223838f, -0.03490948f, -0.00470213f, -0.02042356f, 
    0.04194557f, -0.02279796f, -0.01003816f, -0.04729870f, 0.08884335f, 0.06296129f, -0.26575631f, 0.10837879f, 
    0.12809674f, -0.00298541f, -0.03292292f, -0.07158055f, 0.00655849f, -0.10297153f, 0.00337632f, 0.08861449f, 
    0.14782023f, -0.11545172f, -0.08619236f, 0.16301930f, -0.08606225f, -0.09812453f, 0.03093593f, 0.05615736f, 
    0.00405563f, 0.07279518f, 0.04919223f, -0.00586739f, -0.04449812f, -0.06476891f, -0.06835295f, 0.12146530f, 
    0.01896675f, 0.06095289f, 0.08393927f, 0.08009654f, 0.00210686f, -0.05237864f, 0.01962292f, 0.01814177f, 
    0.14005350f, -0.10417210f, 0.04448990f, 0.04073897f, -0.02295522f, -0.17385918f, -0.07960207f, -0.07059547f, 
    -0.03492062f, 0.10615803f, -0.14624019f, 0.01894702f, 0.12041876f, -0.07876362f, 0.07485056f, 0.13061029f, 
    0.09572323f, 0.06082983f, -0.02654010f, -0.01389903f, -0.00714479f, 0.12512618f, 0.03865925f, 0.04195511f, 
    -0.37808400f, -0.08812158f, -0.18194102f, -0.11005639f, -0.00919976f, -0.26175901f, -0.04297601f, -0.13404857f, 
    -0.06294847f, -0.05494566f, -0.05626157f, 0.07718400f, -0.42277682f, -0.20909317f, 0.06021422f, -0.02622389f, 
    -0.03185950f, -0.16897954f, 0.01711111f, 0.03849673f, -0.05426355f, 0.05390887f, -0.24248359f, -0.02546056f, 
    -0.14233918f, -0.03147876f, -0.14620137f, -0.00777356f, -0.18207154f, -0.08366956f, -0.10946266f, 0.04695225f, 
    0.04255355f, 0.00494982f, -0.02046959f, 0.04166170f, 0.17850667f, -0.10756690f, -0.16969903f, -0.12734161f, 
    0.15126762f, 0.05733260f, 0.03837306f, -0.02372557f, -0.05724882f, 0.30124694f, -0.38245076f, 0.01954808f, 
    0.16514878f, -0.00483055f, 0.08646120f, 0.14171559f, -0.00080945f, -0.06230076f, 0.05775744f, 0.01369432f, 
    -0.10966407f, 0.07101434f, 0.13245860f, 0.06014078f, 0.41765028f, -0.21236992f, 0.06131051f, -0.10413077f, 
    0.00402734f, 0.08221997f, -0.01891416f, 0.05300479f, -0.11219015f, 0.09158318f, 0.00298925f, 0.03215747f, 
    -0.29348969f, 0.16503111f, 0.09782396f, 0.27563551f, 0.18483675f, -0.04575864f, 0.00858362f, 0.15281890f, 
    -0.01767814f, -0.04737968f, 0.31516710f, -0.19955097f, 0.24611908f, 0.08533508f, 0.05055206f, 0.13549146f, 
    0.06601151f, -0.02192720f, -0.03557856f, -0.05732359f, -0.02220398f, 0.11138834f, -0.05336273f, -0.04783906f, 
    -0.20325090f, 0.08137400f, 0.11473778f, -0.15399158f, 0.06081019f, -0.02326358f, -0.11133616f, 0.05284027f, 
    -0.12360986f, -0.04033020f, -0.09445602f, 0.02811352f, -0.38827831f, -0.07651541f, -0.03327121f, 0.37614745f, 
    -0.05356258f, -0.10796458f, 0.04719839f, -0.08962689f, -0.09419173f, 0.01543013f, 0.01957764f, 0.07382245f, 
    -0.14859733f, 0.51479173f, -0.18873857f, 0.06417394f, 0.08352039f, -0.00334386f, -0.08835639f, -0.04741476f, 
    -0.11616517f, -0.05169486f, 0.03894250f, -0.14616369f, -0.19006741f, -0.05744600f, -0.13183418f, 0.09205672f, 
    0.01711195f, 0.02793645f, 0.09020317f, -0.05300403f, 0.06774610f, 0.04955666f, -0.13006987f, 0.19551212f, 
    0.73119557f, 0.13463059f, 0.10395788f, -0.14329457f, -0.05450455f, 0.00342951f, -0.10085698f, -0.00737896f, 
    -0.12237081f, -0.19424014f, 0.15856269f, -0.16793382f, 0.23766451f, 0.07086646f, -0.09585582f, -0.56225270f, 
    0.03900511f, -0.06718785f, -0.05447459f, -0.14968605f, -0.17515537f, -0.00749358f, -0.05228747f, -0.12274146f, 
    -0.03430444f, 0.11379616f, -0.18125841f, 0.04406749f, 0.07046174f, -0.09189066f, 0.01590795f, 0.04228854f, 
    0.05247562f, -0.08421139f, -0.04876245f, 0.13582687f, 0.02417554f, -0.28318202f, -0.01944010f, 0.19347213f, 
    0.01682350f, 0.21989004f, -0.03238273f, 0.17937523f, 0.06738442f, 0.00028619f, 0.04292258f, -0.12438859f, 
    -0.47312897f, -0.06450183f, -0.17419665f, -0.16820756f, 0.02037050f, -0.19784404f, -0.03845791f, 0.01989029f, 
    -0.01554112f, 0.03444056f, -0.01244013f, -0.01164185f, 0.03830083f, -0.03338717f, 0.05461621f, 0.16768295f, 
    -0.01696217f, 0.10352093f, 0.06971138f, 0.09065951f, 0.00013337f, -0.06599844f, -0.05294244f, -0.07036773f, 
    -0.37057409f, -0.31379339f, -0.04047588f, -0.40430492f, -0.12673697f, 0.07431579f, -0.19944908f, -0.16165709f, 
    -0.03201275f, 0.00259443f, 0.03837496f, 0.09924155f, 0.02888750f, -0.15518740f, 0.29209140f, -0.15975572f, 
    -0.25024238f, 0.00447400f, 0.09855860f, -0.00167159f, 0.07126462f, 0.09034477f, 0.22920378f, 0.06678637f, 
    0.02686436f, 0.21058092f, -0.06899081f, -0.10920181f, 0.11931625f, 0.01978778f, 0.04704379f, -0.20617819f, 
    -0.04290101f, 0.13684849f, 0.06817617f, 0.09597594f, -0.14824800f, -0.14342429f, 0.31521440f, -0.06458933f, 
    -0.39636618f, -0.05053397f, -0.04875093f, 0.07763694f, 0.19784831f, 0.11312353f, -0.17200279f, 0.11030257f, 
    -0.09653600f, 0.03323928f, 0.12979934f, 0.24895620f, -0.01174267f, 0.03573726f, 0.05596783f, -0.01332571f, 
    0.01674802f, -0.11337507f, 0.12417435f, 0.07665282f, -0.44452924f, -0.10407826f, 0.21261889f, 0.22427911f, 
    -0.01737008f, 0.07714428f, 0.18581402f, 0.06051996f, -0.00533910f, 0.01894976f, 0.01326540f, 0.04910197f, 
    -0.08636259f, -0.13038813f, -0.07610871f, 0.18694636f, 0.01913560f, 0.00482642f, -0.03792342f, 0.03539035f, 
    0.09958591f, -0.00321943f, 0.04629549f, -0.03776775f, -0.13356395f, 0.15206479f, -0.06650478f, -0.09298409f, 
    -0.06830515f, 0.02721805f, -0.02773665f, 0.04827550f, -0.15130593f, -0.02254751f, 0.03743020f, -0.06326611f, 
    0.13276233f, -0.17152880f, -0.12183481f, -0.07027157f, -0.06410415f, 0.02090177f, -0.13124800f, -0.00919797f, 
    -0.10112741f, -0.17523417f, 0.08341486f, -0.06098754f, -0.36020473f, 0.17761439f, -0.02273439f, 0.07325568f, 
    -0.15004520f, 0.13785805f, -0.46162274f, -0.02259955f, -0.13246487f, 0.01638669f, 0.14138366f, -0.10351195f, 
    -0.33937582f, 0.68902308f, -0.53250498f, 0.06088204f, 0.09117655f, -0.08546704f, -0.04419133f, -0.21459021f, 
    -0.10352223f, -0.03943827f, -0.03775083f, -0.06820108f, -0.42922610f, -0.39036062f, -0.25791103f, -0.12609054f, 
    -0.00567018f, -0.15947874f, -0.10599783f, 0.07364827f, -0.04788028f, 0.14311886f, 0.06060134f, -0.08164484f, 
    0.01545407f, -0.15803188f, 0.01893115f, 0.25536478f, 0.01336603f, -0.07121273f, -0.13735311f, -0.17445616f, 
    -0.02688947f, -0.10581903f, -0.04597747f, 0.16501319f, -0.03364934f, -0.08526576f, 0.21098641f, 0.17275377f, 
    -0.13298486f, 0.10553694f, 0.01430294f, 0.10644284f, 0.05826689f, 0.00049356f, -0.08638458f, 0.01452285f, 
    -0.45628217f, 0.71758902f, -0.10581687f, -0.20018548f, 0.25342879f, 0.03404677f, 0.16807102f, -0.09034050f, 
    -0.11255201f, 0.02594419f, 0.06166487f, -0.05486368f, -0.46986547f, 0.11482789f, 0.10977737f, 0.17940351f, 
    -0.01944709f, -0.23113370f, 0.02309070f, -0.17754699f, -0.19445582f, 0.06783930f, -0.10224877f, -0.01416142f, 
    -0.10499167f, 0.03165828f, -0.11089554f, 0.32908764f, -0.00680650f, -0.05576550f, -0.13402265f, 0.03600477f, 
    0.08679204f, -0.03074321f, 0.03909893f, 0.01228105f, -0.06158845f, -0.02339829f, 0.00898951f, 0.04450779f, 
    0.03284911f, 0.03731391f, 0.08407395f, 0.04694666f, 0.02282951f, 0.00690157f, 0.05922795f, -0.01025937f, 
    -0.17914343f, 0.07015263f, -0.10281381f, 0.07475489f, -0.03416876f, 0.06971955f, -0.04426824f, 0.00291437f, 
    -0.08223183f, -0.01896495f, -0.13447781f, -0.01690266f, -0.02217015f, 0.17855686f, -0.27880347f, 0.11669788f, 
    -0.00810168f, -0.05540598f, 0.00266900f, 0.04496459f, 0.00376609f, -0.05967714f, -0.10873497f, -0.00154100f, 
    -0.14992483f, 0.25550038f, -0.49730590f, -0.31095076f, -0.02457758f, 0.11540327f, -0.07817919f, 0.03477010f, 
    -0.11780652f, -0.08073242f, -0.01536942f, 0.03444811f, -0.58744907f, 0.35747319f, 0.19819780f, -0.19700591f, 
    0.27419797f, 0.07311599f, -0.13824403f, 0.14736134f, -0.41442767f, -0.10676310f, -0.03984260f, -0.30323830f, 
    0.01624139f, -0.11255762f, 0.46996135f, 0.23540789f, -0.09068432f, 0.00792027f, -0.26933056f, -0.00045101f, 
    -0.01274061f, 0.04875521f, 0.12305113f, 0.00567447f, -0.14126362f, -0.19523379f, -0.06349105f, 0.16348909f, 
    0.01748655f, -0.02368040f, 0.11623581f, -0.02263727f, 0.08987401f, -0.02595369f, 0.14919122f, 0.05321358f, 
    -0.63517451f, 0.38213661f, -0.08755485f, -0.15794322f, 0.13659097f, 0.23247258f, 0.20023805f, -0.04354226f, 
    -0.21841714f, -0.05432952f, -0.05437297f, 0.05946126f, -0.11980762f, -0.12548649f, -0.03311441f, 0.12652570f, 
    0.20793377f, 0.06195362f, 0.10027555f, 0.08006027f, 0.05648114f, 0.02872587f, -0.07683259f, -0.07240079f, 
    -0.19893441f, -0.00923819f, -0.09630453f, 0.14834371f, 0.10134696f, 0.03461368f, 0.02245888f, -0.01680189f, 
    -0.06008087f, 0.04711797f, -0.07051872f, 0.04318693f, -0.12744780f, 0.52891517f, 0.07243129f, 0.19942708f, 
    -0.15068509f, -0.07204388f, 0.05602809f, -0.05085887f, -0.06609677f, 0.19093101f, 0.07128217f, 0.27616990f, 
    0.09478229f, -0.19514281f, 0.23150404f, -0.14196143f, 0.04231588f, -0.15533306f, -0.03238966f, -0.11096848f, 
    -0.00915345f, 0.00706354f, -0.03664142f, -0.22281356f, 0.21847251f, -0.07109867f, 0.07240482f, 0.29664508f, 
    0.12418707f, -0.13085860f, -0.19185475f, 0.00474656f, -0.06645323f, -0.14863740f, -0.00974410f, 0.03174865f, 
    -0.09676091f, -0.19079155f, 0.28035158f, 0.06023614f, 0.08318678f, -0.02494133f, 0.00512399f, -0.09890813f, 
    0.03499483f, 0.21044774f, -0.13342804f, -0.00147812f, -0.16835444f, -0.29522717f, -0.07650756f, -0.13368171f, 
    -0.09608556f, -0.04500569f, -0.07796951f, -0.02700433f, -0.00518447f, -0.05809912f, 0.04381752f, -0.18257552f, 
    0.33597124f, -0.13244210f, 0.04423644f, 0.17082395f, -0.03998692f, 0.14388508f, -0.04598584f, 0.03516348f, 
    0.00774293f, -0.00076398f, 0.08909128f, 0.08178733f, 0.88836360f, 0.03010107f, -0.03204637f, 0.01695448f, 
    0.13195911f, 0.09342587f, -0.04335681f, -0.03662523f, -0.13995369f, -0.02815911f, -0.04964046f, 0.02982536f, 
    -0.19536039f, 0.26805344f, -0.09132919f, -0.19098210f, 0.34043550f, 0.09315284f, -0.06851661f, 0.04253406f, 
    -0.24497661f, 0.05595620f, 0.04355855f, -0.02090711f, -0.65219182f, 0.15436646f, -0.31041801f, 0.13874716f, 
    -0.04037791f, -0.04238473f, -0.30854386f, -0.04772710f, -0.10848108f, -0.11077204f, -0.07035685f, -0.12262740f, 
    0.03042299f, -0.06871481f, -0.06504447f, 0.05403212f, 0.09148706f, -0.01179677f, 0.08115881f, 0.09693641f, 
    -0.12468874f, -0.03909345f, 0.02393493f, -0.13868311f, 0.23852700f, 0.33354160f, -0.19058539f, -0.42924875f, 
    0.12756991f, 0.13278760f, -0.00915921f, 0.00855293f, -0.15451695f, 0.00405143f, 0.00088423f, -0.08948898f, 
    -0.01928698f, -0.22711079f, 0.00873754f, -0.03438269f, 0.01821683f, -0.01264277f, -0.09443844f, 0.05177701f, 
    -0.13393001f, -0.16044109f, -0.00233478f, 0.00113754f, 0.21688561f, -0.06642733f, 0.10068875f, -0.01593684f, 
    -0.05679486f, 0.00967054f, 0.01582657f, -0.01571187f, 0.08235275f, -0.18725909f, -0.05016148f, -0.15779456f, 
    -0.01356603f, 0.30010596f, 0.03086730f, 0.25035319f, 0.05265380f, -0.07501405f, -0.04361532f, -0.10496268f, 
    -0.07738690f, -0.07509766f, 0.15409546f, -0.13124782f, 0.04933054f, -0.07998099f, -0.04493252f, 0.05665682f, 
    0.01640162f, 0.07193952f, -0.06878629f, -0.16017787f, 0.01251392f, 0.00787439f, -0.11972459f, -0.07700132f, 
    -0.37692410f, -0.01984830f, -0.05891182f, -0.06305318f, -0.03013620f, 0.04049352f, 0.06697010f, -0.03163104f, 
    -0.01061200f, 0.00319239f, 0.04856147f, -0.00399445f, 0.06894493f, 0.10607445f, 0.09493568f, 0.17138501f, 
    -0.01945729f, 0.05139455f, -0.01631548f, -0.07097331f, 0.15906639f, 0.11420009f, 0.03392419f, 0.03462184f, 
    0.03549014f, -0.04017201f, 0.02843197f, 0.01433809f, 0.09895150f, 0.01440394f, 0.06497414f, 0.05424332f, 
    0.05065683f, -0.12850642f, -0.07573729f, -0.10599393f, 0.06939263f, 0.17803149f, 0.04079229f, 0.17851228f, 
    -0.13327193f, -0.18729727f, 0.01177741f, -0.13057052f, 0.03011124f, -0.09231256f, 0.04245525f, 0.06076251f, 
    -0.08732430f, -0.09000102f, -0.03773502f, -0.11810304f, -0.03621997f, -0.00286695f, -0.08743576f, 0.05439634f, 
    -0.16336182f, 0.00343997f, -0.12860848f, -0.10892364f, 0.08334531f, 0.09412045f, -0.29987776f, -0.23723926f, 
    0.06112823f, 0.05210148f, -0.01800097f, 0.00904798f, -0.08458240f, 0.08173773f, 0.03886526f, -0.09113791f, 
    0.12079307f, -0.12745978f, -0.01126207f, -0.01302848f, 0.00192539f, -0.00379660f, -0.00210898f, -0.08879939f, 
    0.10909621f, 0.24055405f, 0.29166418f, 0.32913432f, 0.23656239f, -0.07566939f, -0.06535801f, 0.13455211f, 
    0.01621884f, 0.00690323f, 0.01538897f, -0.02822821f, -0.01893084f, -0.15529253f, 0.32235384f, 0.16813523f, 
    0.06331189f, 0.03051175f, -0.07260786f, 0.15457240f, -0.01111179f, -0.01428200f, -0.13354775f, -0.10376484f, 
    0.02322111f, 0.02731857f, -0.04972484f, 0.02361299f, -0.16611540f, 0.14356159f, -0.08849455f, -0.13863334f, 
    -0.00797638f, -0.05416286f, -0.01373663f, 0.03957517f, -0.12935737f, -0.04156426f, -0.13362242f, 0.01593130f, 
    0.09386333f, 0.03074725f, -0.00113267f, 0.01708093f, 0.03051464f, -0.04540722f, 0.01241144f, -0.03565751f, 
    0.08650407f, 0.10468455f, 0.00454834f, 0.00734165f, -0.14096178f, 0.20398590f, 0.13091379f, 0.18054435f, 
    0.01297994f, 0.02547379f, 0.01831457f, -0.12698729f, -0.11083382f, -0.16861142f, -0.00657846f, -0.11956295f, 
    -0.07862502f, -0.01473092f, -0.19490887f, 0.10251367f, 0.07045840f, 0.01734764f, 0.00904363f, 0.00676422f, 
    -0.01757868f, -0.05234777f, 0.00584905f, -0.01363532f, -0.02205988f, 0.02687319f, -0.06162225f, 0.09478418f, 
    0.05311957f, -0.17010996f, -0.16797571f, -0.26762444f, -0.06756917f, 0.06026514f, 0.04615773f, -0.07388321f, 
    -0.11973815f, -0.31192353f, 0.11316536f, -0.11677131f, -0.04840611f, -0.05631331f, -0.00522679f, 0.01563901f, 
    0.26090777f, 0.02713038f, -0.06614150f, 0.33949143f, -0.04669584f, -0.09671520f, 0.11878655f, 0.00175102f, 
    -0.06245242f, -0.05234553f, -0.10279970f, 0.02312406f, -0.00909864f, -0.16885261f, -0.01027201f, 0.11001815f, 
    0.11944658f, -0.45702675f, -0.20384006f, 0.12083980f, 0.16115409f, -0.09122471f, -0.02781374f, -0.04980170f, 
    0.00548574f, -0.04484227f, -0.16278899f, -0.07656465f, -0.09566795f, -0.09157117f, -0.05006725f, 0.00124700f, 
    -0.05652584f, -0.01014117f, -0.00156477f, 0.02271053f, -0.07225144f, 0.20533611f, -0.09679048f, 0.03334222f, 
    -0.13079546f, -0.12492788f, 0.05096686f, 0.04247963f, -0.03140058f, -0.04287657f, -0.18130353f, -0.09074689f, 
    -0.04094941f, 0.05874258f, 0.04814789f, -0.06636170f, 0.13261634f, 0.25746658f, 0.31991649f, 0.18520398f, 
    -0.07780449f, -0.02317611f, 0.11464359f, 0.15178187f, 0.06533192f, 0.03696897f, 0.00515551f, -0.01528296f, 
    0.10880180f, -0.12213244f, -0.03234214f, 0.08835706f, -0.10354463f, 0.05549311f, -0.02570842f, -0.01151511f, 
    0.04989542f, 0.03059524f, -0.05096668f, -0.04259720f, 0.08204233f, 0.09172118f, 0.27150798f, 0.09790910f, 
    0.07692567f, -0.07725761f, 0.05646096f, 0.19181582f, -0.01754286f, -0.03313381f, 0.08775507f, -0.04923710f, 
    -0.01816596f, 0.05948442f, 0.03332754f, 0.06809368f, 0.08287177f, 0.00173302f, 0.04335525f, -0.04525187f, 
    0.10708654f, -0.21486470f, -0.27396160f, -0.06917770f, 0.08161099f, 0.00808883f, -0.20670161f, -0.00896098f, 
    0.06596104f, 0.01073898f, -0.05258495f, -0.03673742f, 0.00578769f, 0.05077157f, 0.03260643f, 0.04527256f, 
    -0.20506464f, -0.04178675f, -0.18297260f, -0.17500429f, -0.21726674f, -0.13252006f, 0.06484573f, 0.05358244f, 
    -0.10242935f, -0.06275707f, -0.17297433f, 0.11943763f, 0.18760061f, 0.17594995f, -0.11505886f, 0.29656801f, 
    0.09184599f, 0.00590360f, 0.02433361f, -0.06216311f, 0.13078339f, -0.02480988f, 0.04740956f, -0.00691096f, 
    -0.16089736f, 0.14542606f, 0.29158050f, 0.20826247f, -0.01314515f, 0.13258384f, 0.01870620f, 0.14366591f, 
    -0.00755712f, 0.04052062f, -0.07108988f, -0.01109236f, 0.05154678f, 0.08654591f, 0.01123493f, 0.00787292f, 
    0.02467306f, -0.05675575f, -0.10378668f, -0.07750495f, -0.02195661f, 0.02236915f, -0.09127185f, 0.15576929f, 
    0.08041428f, 0.09453622f, 0.25361735f, 0.04934808f, -0.09526416f, -0.16475311f, 0.00269117f, 0.08772512f, 
    0.11697821f, -0.01839040f, 0.00655948f, -0.00652656f, -0.15333796f, -0.16128403f, 0.05042613f, 0.11312123f, 
    0.01492180f, 0.02898951f, -0.02476132f, -0.16362357f, -0.01447778f, -0.10566179f, -0.01462273f, 0.15693793f, 
    -0.00217758f, 0.06862426f, 0.11178023f, 0.07147480f, -0.06258038f, -0.13948321f, -0.04541125f, 0.20611331f, 
    0.10538908f, -0.03738952f, -0.10083934f, -0.13489816f, -0.20309173f, -0.23686494f, 0.05241504f, -0.00063259f, 
    -0.08973873f, -0.00874579f, -0.22729759f, -0.00777382f, 0.06029668f, -0.10552622f, -0.03903144f, -0.17781185f, 
    0.01991433f, -0.34168869f, -0.00199483f, -0.07054138f, 0.00546968f, 0.22166729f, -0.09511963f, -0.02347100f, 
    -0.26137432f, 0.08412880f, -0.10928726f, -0.13507165f, 0.06549474f, 0.04911646f, 0.08537920f, 0.05505628f, 
    0.11006256f, 0.05075590f, 0.06464864f, 0.07942268f, 0.11700132f, -0.00790081f, -0.01758800f, -0.01091734f, 
    -0.07788453f, 0.14669828f, -0.07865918f, 0.06497457f, 0.01272332f, -0.02593730f, -0.00001056f, 0.08332752f, 
    -0.01208192f, -0.03978709f, 0.02748861f, -0.07179238f, 0.11173174f, 0.15387802f, -0.12362641f, 0.16389465f, 
    0.02331314f, -0.15457600f, 0.05699956f, -0.13486248f, 0.01892842f, -0.01386218f, 0.16611907f, 0.30506888f, 
    -0.09602685f, -0.52888232f, -0.27620354f, -0.30990288f, 0.04416935f, 0.05613209f, 0.02794470f, 0.10444024f, 
    -0.02927028f, -0.05833011f, -0.14143758f, -0.07369234f, -0.09028149f, -0.02643714f, 0.15642525f, -0.18941207f, 
    -0.00538902f, -0.07444663f, -0.15252538f, 0.12833288f, -0.21349241f, -0.07278761f, -0.04924888f, -0.04351977f, 
    0.04448535f, -0.02645010f, 0.28049830f, 0.11821402f, -0.07868043f, 0.03105542f, -0.00682456f, -0.14486019f, 
    -0.11548115f, -0.04211951f, -0.09584751f, -0.03804577f, -0.06589125f, -0.00420865f, 0.00340824f, 0.04725523f, 
    -0.03229794f, -0.00072959f, -0.08298064f, -0.02532717f, 0.02409890f, 0.04861220f, -0.04845242f, 0.18970440f, 
    -0.14470525f, -0.02172679f, 0.11088946f, 0.03740231f, -0.00699560f, -0.02116061f, -0.10127275f, -0.08980918f, 
    -0.10142492f, -0.05721462f, -0.01899230f, 0.09433641f, 0.06022781f, -0.00795875f, 0.29243413f, 0.06475276f, 
    0.00729701f, -0.13307746f, -0.17102030f, 0.04558505f, -0.11767779f, 0.04242287f, -0.04148771f, -0.03854104f, 
    0.16844188f, -0.27119833f, 0.13956888f, 0.17224191f, -0.06388958f, -0.10963258f, -0.13508348f, -0.13760369f, 
    -0.03442820f, -0.09531430f, -0.22734250f, -0.02316562f, 0.14426962f, -0.22127804f, -0.18669401f, 0.04439346f, 
    -0.12203274f, -0.01013025f, 0.16681987f, -0.03334138f, -0.23061042f, 0.08909866f, -0.04481037f, -0.19454007f, 
    0.02623273f, 0.41161463f, -0.39979726f, -0.03608550f, 0.10456523f, 0.06224323f, 0.01583908f, -0.00405705f, 
    0.03056023f, 0.00865324f, -0.05129183f, -0.07865252f, 0.06063780f, 0.14680088f, 0.14362431f, 0.14841017f, 
    -0.04618048f, -0.13210772f, -0.00703871f, -0.07157782f, 0.01721320f, 0.02536591f, 0.01636097f, 0.10148518f, 
    0.00324212f, -0.13126162f, 0.09054258f, -0.08536837f, 0.05255371f, -0.07445275f, 0.04144242f, 0.05412788f, 
    0.16750535f, 0.14141947f, -0.01940553f, 0.14981993f, 0.08657488f, 0.19063659f, 0.00111582f, 0.13291240f, 
    -0.03078157f, -0.08347675f, 0.01855722f, -0.00259201f, 0.02070338f, 0.03535371f, 0.03364968f, -0.02792892f, 
    -0.04678970f, -0.05924236f, 0.04477221f, 0.02095064f, 0.06581732f, 0.06320641f, -0.04230965f, -0.09811681f, 
    -0.00919462f, 0.07159053f, 0.07814573f, 0.00763565f, 0.14453933f, -0.22096248f, 0.14560333f, 0.22001196f, 
    0.09432542f, 0.11970124f, 0.03203127f, 0.01165082f, 0.06377249f, 0.00811537f, -0.00215488f, 0.06107765f, 
    0.02129512f, 0.05857201f, -0.03661568f, 0.08005204f, -0.03698035f, -0.09106867f, -0.11909860f, 0.13756955f, 
    -0.00850706f, -0.05242066f, -0.03998132f, -0.02146398f, 0.09801264f, -0.07151047f, -0.03993357f, 0.00141883f, 
    -0.07816271f, -0.18488136f, -0.04964264f, -0.33473915f, -0.03856492f, -0.04302604f, 0.07861228f, -0.16379882f, 
    0.03574938f, 0.17390279f, -0.20001598f, 0.11223911f, -0.05331065f, -0.00000521f, 0.06939740f, -0.19002412f, 
    -0.01408414f, 0.02977084f, -0.18205854f, 0.00520233f, -0.25614959f, -0.02191411f, -0.05015583f, -0.12231277f, 
    -0.01677245f, 0.00653197f, -0.04954195f, 0.06690686f, -0.13104282f, -0.02111521f, -0.06751385f, -0.08122022f, 
    -0.17466524f, 0.10353451f, 0.11533696f, -0.09468079f, 0.15790378f, -0.04549381f, -0.28480008f, 0.07620857f, 
    -0.00282574f, -0.05284663f, -0.23313171f, -0.03171229f, -0.30773935f, -0.16121379f, -0.16767770f, -0.04620558f, 
    -0.02329955f, -0.04220600f, 0.10896222f, -0.00215582f, 0.00360759f, -0.00722889f, 0.12241047f, 0.16164201f, 
    0.27463892f, -0.11505395f, 0.13377598f, 0.13853152f, -0.30771190f, 0.01005731f, -0.11028300f, -0.06670362f, 
    -0.10495806f, -0.01230721f, -0.18627168f, -0.12712266f, 0.03372821f, 0.00441321f, 0.00313576f, 0.04966123f, 
    0.13831858f, 0.16804786f, -0.07162966f, -0.14929534f, 0.05635108f, 0.06705261f, -0.04669507f, -0.03742767f, 
    0.06698342f, 0.09226049f, 0.18323541f, 0.10862048f, -0.04047526f, -0.09608106f, -0.03628654f, 0.06546648f, 
    0.09783694f, 0.08050196f, 0.03742628f, 0.03683488f, -0.13393532f, -0.38531619f, 0.08372213f, 0.15914573f, 
    -0.02200905f, -0.09037820f, -0.05901906f, -0.03472307f, -0.14551480f, 0.00497424f, -0.05683075f, 0.20946667f, 
    0.12832743f, -0.22752972f, 0.01181300f, -0.06499542f, 0.00427690f, 0.02023124f, -0.03813111f, 0.16742869f, 
    0.05775969f, -0.16042791f, -0.10324112f, 0.04939864f, -0.15581931f, -0.08931800f, -0.12566835f, 0.24588557f, 
    0.06844307f, -0.01878472f, -0.04248480f, -0.09995360f, 0.19360834f, 0.09956966f, 0.20208763f, 0.01111341f, 
    -0.06718252f, 0.37144065f, -0.11800769f, -0.32121339f, 0.00838683f, 0.32076591f, 0.00075730f, -0.19933829f, 
    0.06507620f, -0.10560393f, 0.01482168f, -0.02454124f, -0.05270596f, 0.08038153f, -0.05513088f, -0.10279353f, 
    -0.20744665f, 0.07442235f, 0.10945122f, -0.04575083f, 0.01343544f, 0.05419854f, 0.05352110f, 0.08492158f, 
    -0.09461365f, 0.23582572f, -0.10799271f, -0.16532649f, 0.06158571f, -0.00549643f, -0.08838740f, 0.11731498f, 
    -0.05353605f, 0.04106006f, -0.05619483f, -0.15040614f, 0.05175122f, 0.04860235f, 0.02564624f, -0.09931900f, 
    -0.00473920f, 0.00604162f, -0.09644695f, 0.02369432f, -0.17353816f, -0.11570517f, -0.08624198f, -0.05007770f, 
    0.06037140f, -0.07697625f, -0.09524735f, 0.06352317f, -0.01529039f, -0.04064183f, -0.11367974f, -0.12087918f, 
    0.18743111f, 0.03092661f, 0.01598990f, 0.01729044f, -0.56103748f, -0.37818280f, -0.42055371f, -0.38537255f, 
    0.05070051f, 0.05867463f, -0.02181012f, -0.08511731f, 0.09413736f, -0.01976725f, -0.12275825f, -0.05500328f, 
    0.01719931f, 0.03291648f, -0.14461347f, 0.07259212f, 0.08949041f, -0.04616158f, -0.05562370f, 0.01135169f, 
    0.11075469f, 0.04681648f, -0.07064751f, -0.02762312f, -0.27148542f, -0.27718461f, -0.06610916f, -0.03574093f, 
    -0.00796171f, 0.04342992f, -0.04654956f, 0.11180210f, 0.08503962f, -0.16227725f, 0.20785387f, 0.18370618f, 
    0.11667889f, -0.23419157f, 0.08761773f, 0.01898138f, 0.00720887f, -0.04191042f, 0.05158766f, 0.00684054f, 
    0.10947574f, -0.41901958f, -0.34005550f, -0.42788753f, -0.17211951f, 0.14419289f, 0.05610580f, 0.00919430f, 
    0.01530541f, -0.04528657f, -0.01455061f, -0.01783829f, 0.32989222f, -0.02638689f, 0.08610599f, 0.14768228f, 
    -0.05524812f, 0.29145235f, 0.08792053f, -0.14824867f, 0.00550728f, -0.03622262f, 0.09970710f, 0.05187352f, 
    -0.00134971f, 0.06865873f, 0.03204967f, -0.08517753f, -0.06897405f, -0.22631800f, -0.24569198f, 0.15355428f, 
    0.14098847f, -0.00373214f, -0.14016266f, -0.02211721f, -0.05457573f, 0.16305806f, -0.04928618f, 0.00850074f, 
    -0.06652503f, -0.04872889f, -0.07074486f, -0.09690439f, 0.15815143f, 0.01011836f, -0.00836607f, -0.04203193f, 
    0.09091049f, 0.06339946f, -0.01329280f, 0.13114181f, 0.23320860f, 0.08274711f, 0.09215581f, 0.12628652f, 
    -0.05662603f, -0.03873167f, 0.04537972f, 0.05786159f, -0.03313163f, 0.00541516f, -0.00964158f, -0.17978501f, 
    -0.28141898f, -0.22541919f, -0.14161068f, 0.22343907f, -0.02376980f, -0.03621867f, 0.00453352f, 0.02357767f, 
    0.01230316f, -0.03483681f, 0.07120453f, 0.30550840f, -0.19753791f, 0.12363957f, -0.06649078f, -0.23970473f, 
    -0.07480048f, 0.07996129f, -0.21108542f, 0.11487531f, -0.02546027f, -0.04897000f, 0.01441973f, -0.08211051f, 
    0.03405323f, 0.00859962f, -0.09291065f, -0.12972552f, 0.08841081f, 0.07294214f, -0.02034580f, 0.00488798f, 
    -0.16507609f, 0.11767954f, -0.12077056f, -0.26194888f, 0.08752529f, -0.17188433f, -0.02444023f, -0.11324610f, 
    0.02314038f, 0.01862920f, 0.00966438f, 0.00698894f, -0.06796295f, -0.16482277f, 0.10741243f, -0.14672776f, 
    -0.43458846f, 0.44737038f, 0.27300563f, 0.09323055f, -0.05604164f, 0.02446105f, 0.01566873f, 0.07682977f, 
    0.14621270f, -0.00623438f, -0.15533908f, -0.05418112f, -0.06570173f, -0.25005579f, 0.09135474f, 0.14138985f, 
    0.04077835f, -0.02993187f, 0.01885746f, 0.02259975f, 0.11590963f, -0.12802841f, 0.12361810f, -0.01297381f, 
    -0.04815851f, 0.27567336f, 0.17975457f, -0.18315618f, 0.15363792f, 0.01377142f, 0.26282263f, 0.02660976f, 
    0.05224857f, 0.04962911f, 0.08500640f, 0.01447334f, -0.01085349f, 0.16413710f, 0.02432582f, -0.08767674f, 
    0.25076288f, 0.13997142f, -0.11903680f, -0.16173145f, 0.00870150f, 0.03146431f, 0.00619659f, 0.02696726f, 
    -0.12860967f, 0.03661375f, 0.06134883f, -0.05993523f, 0.10259897f, 0.05015513f, -0.08925552f, 0.04851805f, 
    -0.00959803f, 0.00713197f, -0.05401106f, 0.09663681f, 0.10538670f, 0.07878029f, -0.04341237f, -0.08871900f, 
    -0.06561652f, -0.04685687f, -0.00094042f, -0.24518962f, 0.04769912f, 0.00009917f, 0.08687361f, 0.03068205f, 
    0.06763151f, -0.09626075f, -0.05187694f, -0.26714212f, 0.04516944f, -0.00797175f, -0.11372351f, -0.05892625f, 
    0.00368892f, -0.01402519f, 0.28474778f, -0.06452965f, 0.06069428f, -0.11106994f, -0.29140776f, 0.19172280f, 
    -0.01004786f, 0.06314896f, 0.05932007f, -0.05904460f, -0.13726795f, -0.13025838f, -0.20687877f, -0.24435161f, 
    0.11593007f, -0.35413843f, -0.00790804f, -0.08495435f, -0.02674372f, -0.14434451f, -0.13471654f, 0.15369345f, 
    0.03473961f, -0.15737215f, -0.12139394f, -0.05862073f, 0.01642017f, -0.05289508f, -0.12711109f, 0.08116887f, 
    0.08524203f, -0.07920375f, -0.07535409f, 0.23540795f, -0.12501767f, 0.14275427f, 0.07699911f, -0.12785882f, 
    -0.30049884f, 0.01464688f, -0.08794985f, -0.23328884f, 0.01746053f, -0.08126171f, 0.21368054f, -0.00544336f, 
    0.03267857f, 0.01836687f, -0.04277470f, 0.04350914f, -0.17836912f, 0.07121945f, -0.13708085f, -0.19417699f, 
    -0.04221245f, 0.13891688f, 0.10208425f, 0.01765507f, 0.17891593f, -0.04501721f, -0.08548012f, -0.11188280f, 
    0.00864863f, -0.02578170f, 0.01829059f, -0.04529621f, 0.27588806f, 0.28011465f, 0.33919436f, 0.10088725f, 
    0.07746678f, 0.00005577f, 0.07678492f, 0.04065321f, 0.06104529f, -0.17681895f, 0.45902780f, 0.17106044f, 
    0.03607118f, 0.01954228f, -0.08036074f, 0.06001186f, 0.00711058f, -0.06669805f, -0.02549994f, -0.00088088f, 
    0.02637480f, -0.00723889f, 0.08646400f, -0.13707484f, 0.13704321f, 0.00067571f, 0.05293364f, -0.22040865f, 
    0.09191502f, -0.13289782f, 0.06823148f, 0.05245429f, 0.51154506f, 0.02669524f, -0.29238963f, 0.12789454f, 
    0.05525860f, -0.04587978f, 0.11228112f, 0.23414642f, 0.05024727f, -0.12629180f, -0.15348133f, 0.14681205f, 
    0.14971252f, -0.04021706f, 0.05709279f, -0.17332821f, -0.21383266f, -0.13720064f, -0.07641214f, -0.02942852f, 
    -0.03529748f, 0.01303373f, -0.05309758f, 0.02561440f, -0.00796165f, -0.05883668f, -0.01065454f, 0.07387351f, 
    0.02074739f, -0.07674666f, -0.06814026f, -0.00814405f, -0.08628448f, -0.00058824f, -0.00599433f, 0.00197189f, 
    0.01410325f, -0.27619135f, -0.14456442f, 0.02737113f, -0.01045986f, 0.02872761f, 0.10892653f, 0.23657471f, 
    -0.01191733f, 0.02266008f, 0.12308259f, -0.05173282f, -0.05372069f, -0.00136673f, -0.05391907f, -0.03440361f, 
    0.01792974f, 0.05046839f, 0.04102815f, 0.07982392f, -0.01142151f, -0.15223023f, -0.17260160f, -0.57938123f, 
    -0.31379834f, -0.17390987f, -0.04075537f, -0.20278636f, -0.03152342f, -0.00992416f, -0.00255312f, 0.02373979f, 
    0.05105042f, -0.15843685f, 0.03628692f, -0.09668943f, 0.18782142f, -0.16136071f, -0.40994206f, 0.02792352f, 
    0.20059243f, 0.13046673f, -0.09005125f, 0.04800121f, 0.11143898f, -0.05986098f, 0.06587012f, 0.01757544f, 
    0.11641642f, 0.13832785f, 0.12910336f, -0.20629582f, 0.09871598f, -0.09610159f, 0.13470525f, 0.12968948f, 
    0.05048268f, 0.04716681f, 0.05158098f, -0.01291627f, 0.03285229f, 0.08373562f, -0.00326368f, 0.12711181f, 
    0.02679487f, -0.04008907f, -0.04755495f, 0.03241740f, -0.03235897f, 0.06645196f, -0.04881914f, -0.06162226f, 
    0.08673119f, 0.17501654f, 0.28295627f, 0.00314173f, 0.00609067f, 0.03792824f, 0.18426956f, 0.19107735f, 
    0.10232157f, -0.02395507f, -0.01352700f, 0.04031285f, 0.30201772f, -0.04313225f, 0.21905583f, -0.05697101f, 
    0.15606759f, 0.14686269f, -0.03669534f, -0.05381684f, 0.03765762f, -0.00251217f, 0.08607157f, 0.09644126f, 
    -0.22806285f, 0.07415216f, 0.20064057f, 0.03566593f, -0.00622846f, -0.04658749f, 0.03145746f, -0.13297765f, 
    0.07588098f, -0.05419676f, -0.03329490f, 0.03683254f, 0.10316654f, -0.12795168f, -0.11510438f, -0.07226003f, 
    0.03813044f, -0.06247707f, -0.08921868f, 0.05520525f, 0.05870584f, -0.09356593f, -0.08769513f, 0.22504163f, 
    0.12714407f, 0.18858810f, -0.49607879f, -0.12780140f, 0.12623242f, 0.14509457f, -0.06984271f, 0.05931281f, 
    0.16221440f, -0.07147159f, 0.05409782f, 0.00268613f, 0.00068195f, -0.08772067f, 0.05020369f, -0.21232046f, 
    0.02753494f, 0.02653373f, -0.07602961f, 0.01284098f, 0.01267098f, -0.01920661f, 0.00958412f, -0.14986791f, 
    0.19294147f, -0.15431881f, -0.04244699f, 0.02287738f, 0.07276931f, 0.04337642f, -0.00452639f, -0.06470301f, 
    0.01739775f, -0.17741302f, 0.05659208f, -0.15841807f, -0.06699409f, -0.05378883f, -0.04552715f, -0.07682176f, 
    -0.09309271f, 0.09398007f, -0.01011529f, 0.03864074f, 0.11909682f, -0.00428475f, -0.02549284f, -0.06459095f, 
    -0.04823926f, 0.09003650f, 0.26976195f, -0.39307967f, -0.15497309f, -0.01500518f, 0.01791673f, 0.00145442f, 
    0.05864877f, -0.05932168f, -0.11901402f, 0.02155011f, -0.17523053f, -0.38090670f, 0.14615545f, 0.18401806f, 
    -0.03722328f, 0.01064161f, -0.04544318f, 0.02061604f, -0.05366682f, -0.03414454f, 0.03691408f, -0.07391037f, 
    0.13129914f, -0.13793507f, -0.10900852f, 0.21507315f, 0.04432364f, 0.02215705f, 0.13566831f, 0.19172479f, 
    -0.00670391f, 0.04556151f, 0.08095032f, 0.21733552f, -0.27133316f, 0.01016566f, -0.37698457f, -0.26706061f, 
    0.00887909f, 0.00989452f, 0.19208597f, 0.21373175f, 0.25139025f, -0.11282898f, 0.13161197f, 0.10761242f, 
    0.09749481f, -0.06409679f, 0.01532089f, 0.05783278f, 0.02420787f, 0.06017645f, -0.11894576f, 0.03469476f, 
    0.11978885f, 0.11179671f, -0.01935115f, -0.05912214f, 0.25556549f, 0.03541140f, -0.22402968f, 0.13414246f, 
    0.08520065f, -0.01573497f, -0.07291654f, 0.02549167f, 0.18348970f, 0.00483429f, 0.03022564f, 0.29060197f, 
    -0.19984546f, 0.00973094f, -0.26911405f, -0.33074996f, -0.07329718f, 0.03671535f, -0.00918678f, -0.04631743f, 
    0.07249247f, 0.07924382f, 0.14858058f, 0.03232784f, -0.09938672f, 0.04975225f, -0.10774691f, 0.03518899f, 
    -0.02723968f, -0.11909197f, 0.04204632f, 0.07500809f, 0.13376881f, -0.21966620f, -0.35413232f, 0.00391693f, 
    -0.46277615f, -0.04992117f, 0.03872710f, 0.00897030f, -0.01524596f, 0.05827052f, -0.00854550f, -0.06490820f, 
    0.03869966f, 0.08043675f, 0.01298493f, 0.21539237f, 0.05149495f, -0.03720390f, -0.20245133f, -0.02121854f, 
    0.01496764f, -0.11560763f, 0.06419858f, 0.17761502f, 0.18695991f, -0.08459632f, 0.05339092f, -0.05996018f, 
    0.04839353f, 0.14472657f, -0.01129408f, 0.05624930f, 0.03458617f, 0.01995431f, 0.06909570f, -0.16228777f, 
    -0.00994019f, 0.01087792f, -0.10432589f, -0.05137122f, -0.44600916f, -0.29527467f, 0.19163837f, 0.03973594f, 
    -0.10434045f, -0.17617144f, 0.03624426f, 0.07325769f, -0.19889286f, 0.01858567f, -0.02780086f, -0.14720358f, 
    0.16500321f, 0.37197018f, -0.06478383f, 0.12049884f, 0.00669946f, -0.01386883f, 0.06551884f, 0.09146031f, 
    0.05060073f, 0.10041507f, 0.04796055f, 0.00286398f, -0.10663727f, -0.01123945f, 0.31352678f, -0.24402204f, 
    0.00962142f, 0.02007334f, -0.09566905f, -0.01863990f, -0.05394071f, 0.02587510f, 0.03557294f, 0.07727447f, 
    -0.25229216f, -0.19278528f, 0.22412252f, -0.61725062f, 0.04605956f, -0.05138632f, 0.07168386f, -0.08870672f, 
    0.09225748f, 0.07715984f, -0.07901843f, -0.05164652f, -0.17978160f, -0.02730377f, 0.14873382f, -0.04034233f, 
    -0.05683175f, -0.25319391f, 0.09843817f, 0.09986575f, -0.07903776f, 0.01072766f, -0.13351393f, -0.01720444f, 
    -0.52473933f, -0.37405121f, 0.28585726f, -0.37694588f, -0.09865738f, -0.07519565f, 0.14732794f, 0.00106492f, 
    0.00945046f, 0.04270108f, -0.04664009f, 0.13666029f, -0.15480863f, -0.15843140f, -0.18634263f, -0.23764257f, 
    -0.11930668f, 0.14168818f, -0.06990980f, -0.03526100f, 0.03733556f, -0.00008327f, -0.06521847f, 0.03969756f, 
    -0.00441679f, 0.03189570f, -0.05297814f, -0.04053269f, -0.14974585f, -0.11058750f, -0.03060313f, 0.08591595f, 
    0.00073479f, 0.00442341f, -0.10652151f, -0.02675715f, -0.50430757f, -0.08160129f, 0.22808096f, -0.01341552f, 
    0.07172972f, -0.13803960f, -0.03003606f, 0.02709068f, -0.03853199f, 0.05286149f, 0.07579859f, 0.10426027f, 
    0.00601157f, 0.08797599f, -0.01604977f, -0.02241372f, 0.05230445f, 0.04457455f, 0.02588720f, 0.03698350f, 
    0.02076979f, -0.06799036f, 0.10668322f, -0.27505788f, 0.06007502f, 0.01869075f, 0.10208366f, -0.27932847f, 
    -0.01808139f, 0.03121127f, 0.11788169f, -0.00109279f, -0.00347762f, -0.03224620f, 0.02444850f, 0.07786701f, 
    0.09145010f, 0.08893695f, -0.11216374f, -0.04171655f, -0.00059824f, 0.00620905f, 0.02155249f, 0.07395420f, 
    0.06583750f, 0.13165754f, 0.01299207f, 0.12348415f, 0.08354798f, 0.07336832f, 0.03059241f, -0.20077939f, 
    0.03745911f, 0.02917625f, -0.01523995f, -0.00926901f, 0.09252589f, 0.09159487f, 0.25906760f, -0.18901773f, 
    -0.48514739f, -0.49695134f, -0.31575477f, -0.19152409f, 0.01081656f, 0.03139016f, -0.04560840f, -0.20466712f, 
    0.02472842f, -0.03972203f, 0.05142774f, -0.01831644f, -0.02228061f, 0.10096230f, 0.14620858f, 0.03879278f, 
    0.03894841f, 0.03211322f, -0.21044801f, 0.04894799f, -0.04032679f, 0.07214612f, 0.04347191f, 0.08825003f, 
    0.11706563f, 0.16793981f, 0.08081407f, -0.05981583f, 0.06612045f, -0.09080964f, -0.03061325f, -0.02387330f, 
    -0.00900143f, 0.03558514f, -0.06358782f, -0.05640831f, 0.01748446f, -0.00328254f, 0.19656265f, -0.06846520f, 
    -0.05712838f, -0.03853279f, -0.03791309f, 0.05754552f, -0.02466815f, 0.06212621f, -0.02671134f, -0.08913757f, 
    0.04126389f, -0.04328905f, -0.08076258f, -0.04235953f, 0.01052467f, -0.01512020f, -0.02279810f, -0.00890628f, 
    -0.06873281f, -0.01659055f, -0.14014885f, -0.00135362f, 0.33233029f, 0.21406995f, 0.01950606f, 0.12686424f, 
    0.06602979f, -0.18451945f, 0.10401247f, 0.09016500f, 0.00764957f, 0.09301545f, -0.11834651f, -0.03570263f, 
    -0.24446952f, 0.30065179f, 0.07899515f, 0.01319416f, -0.02945557f, 0.06600796f, 0.03192934f, -0.09782556f, 
    0.13414483f, -0.04975270f, 0.12343863f, 0.08261404f, -0.02688791f, 0.35180405f, 0.01395141f, -0.06416383f, 
    -0.02699016f, 0.03241501f, 0.03114070f, 0.11397818f, -0.02445364f, 0.04066623f, 0.07499611f, 0.01025586f, 
    -0.13814333f, -0.03416503f, 0.06600620f, -0.11256582f, 0.00090123f, 0.06616339f, 0.03465831f, -0.07515299f, 
    0.08723954f, -0.03325170f, 0.13801947f, 0.11852857f, -0.28954303f, 0.00439039f, 0.10770416f, -0.02707044f, 
    -0.09344044f, 0.00279639f, -0.07204933f, 0.09156381f, 0.11414374f, -0.00762334f, 0.07596304f, -0.12776068f, 
    -0.34825200f, -0.39171302f, -0.18057397f, 0.60464358f, -0.14227758f, -0.02021528f, -0.19177732f, -0.26326874f, 
    -0.03697328f, 0.04282685f, -0.00862574f, -0.05566069f, -0.53805792f, -0.71355146f, -0.77869987f, -0.33314931f, 
    -0.06893303f, -0.23134184f, -0.13078052f, -0.39688975f, -0.00860335f, -0.05655449f, -0.03688515f, 0.00573606f, 
    0.26851431f, 0.01226011f, 0.01885572f, 0.04484485f, -0.00377414f, -0.04113095f, 0.09951731f, 0.22876546f, 
    -0.09840298f, -0.05515044f, -0.07584713f, 0.05247659f, -0.33506542f, -0.38492811f, -0.02303952f, -0.16963188f, 
    0.02992317f, -0.07409500f, -0.13484013f, -0.24653642f, 0.00751795f, -0.06153714f, -0.04467376f, -0.08569423f, 
    0.05480211f, 0.15740477f, 0.10033279f, -0.10754593f, 0.00662333f, 0.05090142f, -0.09659520f, 0.04357245f, 
    0.01523425f, 0.04101847f, -0.05538662f, -0.03683073f, 0.21396099f, 0.09424284f, -0.00268205f, -0.11753788f, 
    -0.00035266f, 0.00129026f, 0.06101892f, 0.04664939f, 0.04442863f, 0.10100774f, 0.09942025f, -0.00033907f, 
    0.00232803f, 0.06494398f, -0.45020384f, 0.15934220f, -0.08923190f, 0.05251066f, -0.05882329f, 0.16626590f, 
    0.12004768f, 0.02720783f, 0.13455014f, 0.00495723f, 0.09657765f, -0.11211134f, -0.21718894f, -0.02566519f, 
    -0.00389050f, 0.10027691f, 0.20031974f, -0.03765189f, -0.01833181f, 0.05539092f, -0.01829520f, 0.03571036f, 
    -0.44318214f, -0.41527930f, -0.50560606f, 0.23856248f, 0.10199885f, 0.14631362f, 0.11860225f, -0.15086064f, 
    -0.02901363f, -0.02765246f, -0.02040071f, 0.03308212f, 0.27603248f, 0.02212103f, 0.08988345f, -0.03787114f, 
    0.04565322f, 0.01008566f, 0.06027253f, -0.00937723f, -0.05511596f, -0.08133282f, 0.05868534f, 0.16919495f, 
    -0.47703466f, -0.53292036f, -0.45372799f, -0.43614534f, -0.10821030f, -0.21502811f, -0.20886174f, -0.37326473f, 
    -0.01216286f, 0.00382217f, -0.00242006f, 0.01260752f, -0.10511711f, -0.46640077f, -0.25713062f, 0.04103452f, 
    -0.02195779f, 0.09895901f, -0.00777154f, -0.05290823f, 0.03123755f, 0.04173647f, 0.11366531f, 0.10889991f, 
    -0.02238767f, -0.10301844f, -0.00787273f, -0.10526345f, -0.10475081f, -0.01860534f, -0.12304115f, 0.04412889f, 
    -0.02153447f, -0.05648785f, 0.03022738f, -0.20839776f, 0.47888115f, 0.17678115f, -0.28528509f, 0.12595388f, 
    -0.03238512f, -0.02094812f, 0.25705546f, 0.24778596f, 0.21801282f, 0.06908189f, 0.01180038f, -0.22818506f, 
    -0.17893316f, -0.07586734f, 0.06530074f, 0.05278138f, 0.06884749f, 0.02246074f, 0.02124804f, 0.06765806f, 
    -0.08367690f, 0.08989178f, -0.01880480f, 0.06904034f, 0.03285794f, -0.04475145f, -0.09281411f, -0.22311102f, 
    0.08505004f, 0.02355159f, -0.02312537f, -0.00427185f, -0.07897580f, -0.05479989f, -0.30789223f, -0.05515805f, 
    0.33923730f, 0.19591001f, 0.09931564f, 0.30940858f, 0.06521214f, 0.06262369f, -0.08952489f, 0.13150382f, 
    0.02887640f, -0.02495029f, -0.00783386f, 0.07964753f, 0.13465169f, -0.14853704f, -0.03634399f, 0.12014242f, 
    -0.04166386f, 0.03538497f, 0.16748871f, 0.02699205f, -0.04166541f, 0.02967787f, 0.13941632f, 0.11194960f, 
    -0.12614135f, -0.00161905f, -0.09905998f, -0.06654072f, 0.05775873f, 0.02716345f, -0.00726664f, 0.02590850f, 
    0.05746878f, 0.10675548f, 0.07731236f, 0.03063431f, 0.16129132f, 0.11704140f, 0.05231079f, -0.07411227f, 
    0.07054395f, -0.04579674f, 0.07040449f, -0.05619599f, 0.12028260f, -0.00552751f, 0.15285707f, 0.01977463f, 
    -0.46097675f, -0.55860180f, -0.39775485f, 0.55197418f, 0.11174030f, 0.04152019f, 0.03757705f, -0.12454633f, 
    0.01124006f, -0.00580919f, -0.02681798f, 0.06756046f, -0.34950274f, -0.57001948f, -0.23053764f, -0.14816146f, 
    -0.04180669f, 0.05539165f, 0.00464037f, -0.26905110f, -0.00586477f, 0.04287858f, 0.00124537f, 0.00254747f, 
    -0.20797874f, -0.64708686f, -0.40556630f, 0.03818790f, -0.05165224f, -0.10930639f, 0.03601935f, -0.10705492f, 
    -0.03010452f, -0.03992757f, 0.09624141f, 0.00679325f, -0.73405528f, -0.40218654f, 0.20127393f, 0.16197737f, 
    -0.21840346f, -0.18744026f, -0.13114645f, -0.00108954f, -0.02901517f, -0.08239605f, -0.00990470f, 0.02442248f, 
    -0.12705328f, -0.13412055f, 0.15788609f, 0.03043241f, 0.02308396f, 0.06724826f, -0.18835020f, 0.02188004f, 
    -0.02111657f, -0.07683975f, 0.05157949f, -0.12426472f, 0.05314202f, -0.05617342f, 0.25461432f, 0.10970959f, 
    0.01777769f, -0.11369570f, -0.01272448f, 0.04501160f, -0.34852704f, 0.17632221f, -0.19004811f, 0.08217231f, 
    -0.24666323f, -0.28922918f, 0.19461730f, -0.23430616f, 0.03712667f, 0.09581476f, 0.08104745f, -0.01003478f, 
    -0.00876844f, 0.00160279f, -0.02101830f, 0.04007423f, -0.42934197f, -0.17635143f, 0.08672045f, 0.27897319f, 
    -0.02997339f, 0.18210654f, -0.04142544f, 0.04152602f, -0.00762673f, 0.02772931f, 0.06799542f, 0.06415034f, 
    -0.19109558f, 0.13646613f, 0.13731070f, -0.04295243f, 0.02362104f, 0.01725477f, -0.00424307f, 0.03481061f, 
    0.12008759f, 0.08019602f, -0.02734275f, 0.04252685f, -0.36827549f, 0.28497028f, 0.33368972f, -0.00983985f, 
    -0.09648243f, -0.09489423f, -0.08535194f, -0.06651897f, -0.18570349f, -0.00211609f, -0.04684694f, 0.03986612f, 
    -0.30597690f, -0.74511182f, -0.39341587f, -0.07388204f, -0.07668021f, -0.06917831f, 0.01847586f, -0.14284897f, 
    -0.00880168f, 0.06749017f, -0.01457937f, 0.03337734f, -0.37635937f, -0.22645237f, -0.02998232f, 0.25109252f, 
    0.05161351f, 0.16898271f, -0.03015088f, 0.02566118f, -0.03948645f, -0.04433838f, 0.02075566f, 0.06328104f, 
    0.01851889f, -0.13408251f, -0.04243174f, 0.11624055f, 0.01441234f, -0.08271017f, 0.25494546f, 0.01498499f, 
    -0.03060839f, -0.07251034f, 0.04622010f, -0.06221793f, -0.01575800f, -0.10538252f, 0.26138926f, 0.12466919f, 
    0.03662976f, -0.23165831f, 0.04614517f, -0.07048246f, -0.03987751f, 0.02053726f, 0.01452699f, 0.06468021f, 
    -0.00467054f, -0.08623933f, -0.10947580f, 0.13568768f, 0.05014420f, 0.05943199f, -0.06602553f, -0.09572877f, 
    0.04577057f, -0.07968339f, 0.04898789f, 0.02035498f, -0.05591550f, 0.10833052f, 0.08531666f, 0.06688260f, 
    0.01831005f, 0.01378606f, 0.07236563f, 0.05542836f, -0.11385929f, -0.05699678f, 0.03847955f, -0.12726897f, 
    -0.11062670f, 0.18554291f, 0.13674214f, 0.14302894f, 0.12590931f, 0.08795317f, -0.08376761f, -0.14122182f, 
    0.06823348f, 0.11669327f, -0.17603916f, -0.03028697f, 0.02545720f, -0.00669741f, 0.03059415f, 0.05234031f, 
    -0.07683732f, 0.05162948f, 0.03981277f, 0.03298165f, 0.04878005f, 0.00304230f, 0.13517191f, -0.11864822f, 
    -0.17482245f, -0.01543985f, 0.41095045f, -0.06364127f, -0.07940145f, -0.16303492f, -0.04393301f, -0.06048599f, 
    -0.05946797f, 0.02212547f, 0.01479295f, 0.01018911f, 0.41064012f, 0.11087203f, -0.21792717f, -0.10415107f, 
    0.02534455f, -0.12970093f, 0.24222606f, 0.07997807f, 0.04293128f, 0.01464865f, -0.07241902f, -0.15049346f, 
    -0.46533820f, -0.20099570f, 0.11394525f, -0.20052359f, -0.09644433f, -0.06226486f, -0.14529186f, -0.08080797f, 
    -0.04982007f, -0.13833213f, 0.07425478f, 0.04470247f, 0.01456821f, 0.00835978f, 0.02693193f, 0.08305447f, 
    -0.03630664f, 0.08864578f, 0.06948327f, 0.03383992f, 0.08465507f, 0.14183477f, 0.02665027f, 0.07440137f, 
    -0.25471711f, -0.22505106f, -0.02147956f, -0.09362139f, -0.13020453f, -0.10811681f, 0.11025493f, -0.12407833f, 
    -0.10131940f, 0.10696172f, 0.00989470f, -0.00800569f, 0.24328713f, 0.20637311f, -0.24580854f, -0.17503618f, 
    0.02361923f, 0.03887152f, -0.10846059f, -0.00530853f, -0.04681011f, -0.03011426f, 0.01131742f, -0.04317097f, 
    -0.42176744f, 0.37341765f, 0.08498518f, 0.22121458f, -0.07297467f, -0.16216895f, 0.03024973f, 0.07010100f, 
    -0.00335523f, -0.13211296f, 0.04385900f, -0.09855746f, 0.06573736f, -0.06703973f, 0.00621041f, -0.06393038f, 
    -0.20999810f, -0.08457820f, -0.02764557f, 0.11448199f, 0.05157855f, 0.02275601f, -0.01096360f, 0.03770750f, 
    -0.22249646f, 0.58977824f, -0.12187415f, 0.08480872f, 0.09841497f, -0.06238262f, 0.11525708f, -0.06499090f, 
    -0.06847791f, -0.00155972f, -0.01679349f, 0.14041148f, -0.30190048f, -0.27350923f, -0.16537918f, 0.13827834f, 
    0.06218106f, 0.12864774f, 0.09320528f, 0.00042844f, 0.02731457f, 0.00116018f, 0.04510976f, -0.01787523f, 
    0.06310253f, 0.01028480f, -0.03248370f, 0.00829681f, -0.13493770f, 0.00177455f, 0.08510724f, 0.01485643f, 
    0.02703610f, -0.01702938f, 0.04869753f, -0.04307256f, 0.58178282f, -0.62562466f, -0.58445984f, -0.55524778f, 
    -0.19391058f, 0.01711268f, -0.12681684f, 0.18425456f, 0.09439664f, 0.06717936f, 0.05339141f, 0.08453587f, 
    -0.03157208f, 0.00933776f, -0.03553547f, -0.07370674f, -0.00703208f, 0.00527502f, -0.03591478f, -0.03532172f, 
    -0.03404719f, -0.00113741f, -0.11712963f, -0.05467749f, 0.00559753f, 0.16374674f, 0.00935742f, 0.07786544f, 
    0.03654645f, 0.00946082f, 0.00758660f, 0.00866977f, -0.02795412f, -0.06875212f, -0.03145643f, -0.13349864f, 
    0.09761014f, -0.09192265f, 0.09495956f, -0.07625090f, -0.03426000f, -0.03457977f, 0.01562952f, -0.05082044f, 
    0.10225959f, -0.02075109f, 0.01502345f, 0.08769590f, 0.38225815f, -0.07693365f, 0.03943630f, -0.15054148f, 
    0.09339490f, 0.00541996f, 0.01115737f, -0.02180459f, 0.08282144f, -0.07073217f, -0.03127220f, -0.20343769f, 
    -0.37675169f, -0.03853963f, -0.34499806f, 0.29186964f, 0.04025400f, 0.10873009f, -0.00724945f, 0.02793942f, 
    -0.00449896f, -0.03758577f, 0.02201278f, -0.00246896f, 0.18599622f, 0.07768181f, -0.12005536f, -0.03667450f, 
    -0.06201104f, -0.01316594f, -0.10443108f, -0.06898854f, -0.11866715f, -0.03940329f, -0.03396053f, 0.01373615f, 
    -0.05895938f, 0.00965736f, -0.01892170f, 0.00425935f, -0.04985671f, -0.13289011f, 0.01566174f, -0.02737575f, 
    -0.00957537f, 0.01874503f, 0.02260004f, 0.07400922f, 0.20992634f, -0.45472041f, -0.34832340f, 0.48160619f, 
    0.03631672f, 0.02275194f, -0.00040657f, -0.05222876f, -0.03592595f, -0.15978120f, 0.13833930f, -0.00622635f, 
    0.03666143f, 0.06944941f, 0.01931144f, -0.04540315f, 0.06275631f, 0.02921680f, 0.01150585f, -0.01602708f, 
    -0.00962136f, 0.01996104f, -0.02765657f, -0.10666943f, -0.43579215f, -0.05979354f, 0.14649916f, 0.07848518f, 
    -0.13378374f, 0.00349227f, 0.07190791f, -0.04035281f, -0.03469064f, 0.02792445f, 0.06008677f, 0.02055820f, 
    -0.04633575f, -0.03997321f, 0.05480148f, -0.03439982f, 0.09287380f, -0.05283448f, 0.07843378f, -0.04627794f, 
    0.00486483f, 0.12207651f, 0.04838567f, -0.01154559f, -0.29441884f, -0.30952927f, -0.03746482f, -0.14814685f, 
    -0.14167118f, -0.03084978f, 0.05151116f, -0.01813308f, 0.18647756f, 0.01782357f, 0.09355041f, -0.10676400f, 
    0.18168290f, 0.17313319f, -0.05431586f, -0.08144063f, -0.01607007f, 0.06861997f, -0.00557315f, 0.02687884f, 
    -0.06172270f, 0.07123399f, -0.10244925f, -0.17786363f, 0.33782983f, 0.04705457f, -0.06435331f, -0.16943061f, 
    0.02377111f, 0.05716446f, -0.03723643f, -0.09411521f, 0.01652115f, 0.13621081f, -0.01045893f, -0.08563290f, 
    0.05357938f, -0.36840948f, 0.25327131f, -0.18458317f, 0.02773267f, -0.02603221f, -0.03019903f, 0.23987553f, 
    0.03559666f, -0.05691358f, -0.04614462f, -0.01891689f, -0.43923309f, -0.30752286f, -0.01677118f, 0.30735537f, 
    0.11561377f, 0.03086960f, -0.03569526f, 0.01639419f, 0.04164401f, 0.01501308f, -0.00742587f, -0.04150901f, 
    -0.10255248f, 0.01548045f, 0.03811133f, -0.01524918f, 0.00755554f, -0.03141301f, 0.01645416f, 0.02242453f, 
    0.03677604f, 0.01667663f, 0.00344069f, -0.01746210f, -0.22518289f, 0.07917180f, 0.13865636f, 0.32672781f, 
    0.05851838f, 0.05547444f, 0.03507958f, -0.00580542f, 0.01818836f, -0.02780701f, -0.03446186f, -0.00722009f, 
    0.08447174f, -0.02999144f, 0.11304349f, -0.16352777f, -0.05358260f, -0.03214462f, -0.03389289f, -0.00613496f, 
    0.01153901f, -0.14919795f, -0.09456107f, -0.13408026f, 0.06545351f, 0.14615510f, -0.01223304f, 0.14642115f, 
    0.01172400f, 0.02670370f, -0.02552712f, -0.00109897f, 0.08656953f, 0.04097002f, -0.04785872f, -0.07780340f, 
    0.39529660f, -0.39446050f, -0.14006384f, -0.24852465f, 0.12898292f, -0.00408906f, 0.01621485f, -0.05743828f, 
    -0.05742666f, 0.11332021f, 0.10191842f, 0.10114594f, -0.02464092f, 0.10921469f, 0.07915174f, -0.04699479f, 
    0.07340757f, -0.03820526f, -0.07701163f, -0.08638075f, -0.04564271f, 0.04522921f, 0.07323361f, 0.06114306f, 
    -0.34846959f, -0.09624709f, 0.06548736f, 0.02076426f, -0.07007720f, -0.17032014f, -0.06970404f, 0.15875134f, 
    0.03928560f, 0.07627361f, 0.00366902f, -0.01399763f, -0.01681698f, -0.02701185f, 0.15145646f, 0.15190768f, 
    -0.04595282f, 0.05697976f, 0.04706170f, 0.16203278f, -0.09470959f, 0.03040875f, 0.00359134f, -0.09506272f, 
    -0.42313033f, -0.30616876f, -0.31234837f, -0.01364352f, 0.05272448f, -0.19046880f, 0.04838665f, -0.04030346f, 
    -0.00043660f, -0.01720131f, 0.01868764f, 0.00504319f, 0.19196461f, -0.03925486f, 0.01106147f, 0.10892275f, 
    -0.10705350f, -0.03443458f, 0.01465428f, -0.01191946f, 0.02072064f, 0.09751607f, -0.05612271f, 0.01435449f, 
    -0.06385093f, 0.05456199f, -0.03254737f, 0.10216499f, -0.10249025f, -0.02050116f, -0.00643762f, -0.07357746f, 
    -0.00115293f, 0.01386385f, -0.03015795f, -0.04083807f, -0.09656821f, 0.03192568f, 0.01963077f, 0.03297433f, 
    -0.05921158f, 0.02047975f, -0.06119129f, 0.02524550f, -0.13172284f, -0.05475263f, 0.07931921f, -0.02633015f, 
    0.16571225f, -0.11113150f, 0.05873044f, -0.20409408f, 0.03556348f, -0.08477104f, 0.04647573f, -0.11242593f, 
    -0.08585404f, 0.05191135f, -0.00230795f, -0.04706906f, 0.09126267f, 0.07513379f, 0.01954020f, -0.05916870f, 
    -0.00404218f, 0.01733804f, -0.02487814f, -0.00234722f, 0.00762141f, -0.05756830f, -0.01178306f, -0.08314294f, 
    -0.12597483f, -0.09570181f, -0.12350751f, -0.20607388f, -0.09982605f, 0.01081910f, 0.02790598f, 0.02552019f, 
    0.02149116f, -0.02758770f, 0.03716122f, -0.07225260f, -0.09128775f, -0.03873564f, -0.09606413f, 0.07744192f, 
    -0.03874627f, 0.01996485f, 0.08628260f, -0.01053639f, 0.05269727f, -0.04696973f, 0.08301335f, 0.06295740f, 
    -0.07720769f, -0.12801115f, 0.04068637f, 0.00191910f, 0.05661014f, 0.02107893f, 0.07793310f, -0.08070884f, 
    -0.00855310f, -0.18534258f, -0.03437980f, -0.21359144f, 0.12585454f, 0.02708728f, 0.10114413f, -0.10264507f, 
    -0.01536310f, 0.05581890f, 0.07905563f, -0.00454697f, -0.26113078f, 0.00316883f, -0.10597426f, -0.07045697f, 
    -0.32985497f, -0.30222988f, 0.25780556f, -0.40847448f, 0.10471187f, -0.07615336f, -0.12421295f, -0.08119075f, 
    -0.10405114f, -0.08072948f, 0.04275697f, 0.01465943f, -0.23908231f, -0.05585638f, -0.31129190f, -0.00610817f, 
    0.05123523f, -0.01041420f, 0.09701146f, 0.13892427f, -0.01654584f, -0.07236171f, -0.16858584f, 0.10049319f, 
    -0.04111007f, -0.40625155f, 0.21371157f, 0.22335121f, -0.06690239f, -0.12066425f, -0.09975523f, 0.11442842f, 
    -0.03798207f, -0.06441855f, -0.12243984f, -0.11141901f, -0.29076687f, -0.54774803f, 0.21664667f, -0.07064503f, 
    -0.01068251f, 0.01418916f, 0.02617263f, 0.02076651f, -0.01743734f, -0.01001980f, -0.02227611f, -0.04444920f, 
    0.25833863f, -0.06315696f, -0.06536691f, -0.31909382f, -0.00061705f, 0.08088191f, -0.01069559f, 0.03994342f, 
    0.01319481f, -0.04715886f, -0.13754466f, -0.00918229f, 0.26359537f, -0.01823460f, 0.06496232f, -0.47460547f, 
    -0.01431614f, 0.07898893f, 0.00529603f, 0.07506480f, -0.01860277f, -0.02211295f, -0.01362611f, -0.15870233f, 
    -0.30548030f, 0.28758678f, -0.15266420f, 0.13190211f, 0.09487980f, 0.01571786f, 0.07953457f, -0.01384733f, 
    0.01211637f, 0.01484669f, 0.05738301f, -0.01506417f, -0.08741070f, -0.26142454f, -0.19704702f, -0.32893565f, 
    0.00939075f, 0.03986331f, 0.01484494f, 0.03223074f, -0.00075587f, -0.03610813f, 0.05087203f, 0.02220769f, 
    0.09504856f, 0.06454831f, 0.04533428f, -0.16524291f, 0.02893666f, -0.00295760f, -0.02278221f, -0.01814318f, 
    0.02343535f, 0.15409082f, -0.05135957f, -0.12302291f, 0.23618193f, -0.13441265f, -0.07798697f, -0.10529188f, 
    0.08075875f, -0.01244436f, -0.03116543f, -0.04126520f, 0.00160784f, 0.05043887f, 0.11322492f, 0.03999151f, 
    -0.07823300f, -0.54653186f, 0.47467768f, -0.02905424f, -0.10830589f, -0.07612371f, -0.18695688f, 0.14825444f, 
    -0.05947864f, 0.00244494f, -0.01624403f, 0.02677027f, 0.15536430f, -0.04955388f, -0.07200576f, -0.11968458f, 
    0.01088784f, -0.09551186f, -0.01376690f, -0.01601971f, -0.02050455f, 0.00889131f, 0.02401243f, -0.01458955f, 
    0.03116331f, 0.04678193f, -0.03789972f, -0.00017321f, -0.19556411f, -0.05455710f, 0.01190422f, -0.06251325f, 
    0.00005801f, 0.07306145f, -0.03368928f, -0.03686734f, -0.09999755f, -0.01610033f, 0.02129933f, 0.04643252f, 
    -0.18368459f, 0.12404702f, 0.12796445f, 0.03911306f, 0.07836808f, -0.06816678f, 0.12299421f, -0.02653132f, 
    0.16243441f, -0.15538611f, 0.17491330f, -0.26215324f, -0.10048256f, -0.00879530f, -0.07818298f, 0.12606490f, 
    0.03637504f, 0.05933990f, -0.10630423f, -0.03743334f, 0.01239080f, 0.09437417f, -0.04464315f, -0.05183866f, 
    -0.01502673f, 0.05323420f, -0.00097360f, -0.08986075f, -0.17589313f, 0.04698132f, -0.04585041f, -0.11532451f, 
    -0.21204679f, -0.05321376f, -0.16461648f, 0.07305893f, -0.06839039f, -0.07498355f, 0.17169939f, -0.04591171f, 
    0.00614116f, -0.12220263f, 0.00319173f, 0.02621883f, 0.05484939f, 0.02742477f, -0.00430088f, 0.09581845f, 
    0.05834706f, -0.01140516f, -0.00165384f, -0.07597812f, 0.06365367f, -0.03536229f, -0.00381757f, 0.11256214f, 
    0.50539082f, 0.11524231f, -0.02219993f, -0.54497594f, 0.04787086f, 0.15086699f, -0.01219438f, 0.11941399f, 
    -0.00067841f, 0.03470317f, -0.07642144f, -0.01476476f, -0.09622357f, -0.04512044f, 0.13209584f, -0.02250243f, 
    -0.09478413f, -0.00004730f, 0.01967486f, 0.03895891f, -0.00315182f, -0.04327997f, 0.02420594f, 0.06245090f, 
    -0.17036465f, -0.08980657f, -0.00426101f, 0.25424767f, 0.12460654f, -0.01358400f, 0.10481500f, 0.01609681f, 
    -0.02582907f, -0.03998793f, -0.00669198f, -0.05073203f, 0.40900853f, -0.00851606f, 0.02059201f, -0.16444850f, 
    0.01827884f, -0.11390708f, -0.30024052f, 0.02030857f, -0.07589886f, -0.05596778f, 0.00011107f, -0.02634629f, 
    0.22982518f, -0.26404300f, -0.08551766f, -0.00563001f, 0.09851123f, -0.00203056f, 0.13213198f, -0.03471659f, 
    0.09418719f, 0.03695147f, 0.02826882f, 0.08684091f, -0.05772337f, -0.14079697f, -0.24108779f, -0.16851538f, 
    -0.09145555f, 0.08811129f, 0.06585152f, 0.03582243f, 0.12641706f, 0.13407539f, 0.03805688f, 0.07971440f, 
    -0.53096521f, 0.06080629f, 0.01296322f, -0.01291524f, 0.16991660f, -0.02634001f, 0.09244102f, 0.22280180f, 
    0.08198918f, 0.04645598f, -0.03685277f, 0.10565780f, -0.02197330f, -0.03922108f, -0.09593453f, -0.07056633f, 
    0.06319999f, -0.04392272f, 0.08840727f, 0.12094060f, 0.03427288f, 0.04095226f, 0.10888913f, 0.09092723f, 
    -0.23983277f, -0.33417839f, -0.13106899f, 0.14945568f, -0.00157958f, 0.01012636f, -0.02706925f, 0.00718365f, 
    0.04734565f, 0.01272587f, -0.02873559f, 0.06107376f, -0.14049688f, -0.18451862f, -0.10807446f, 0.04820396f, 
    0.08038246f, 0.01564780f, -0.02147911f, 0.15008442f, -0.21445225f, -0.06150279f, -0.11498937f, -0.09437370f, 
    -0.05933698f, 0.01153198f, -0.03005524f, -0.01064081f, 0.09290896f, -0.06366537f, -0.08222523f, -0.03526724f, 
    0.06081046f, 0.20582801f, 0.06963734f, 0.24603929f, -0.57673007f, -0.63052666f, -0.49027669f, 0.18917251f, 
    0.09563694f, 0.20588726f, 0.24498242f, 0.05653378f, -0.04789523f, 0.01892127f, 0.01511691f, 0.11421826f, 
    0.05955426f, 0.04844381f, 0.11885238f, -0.08014096f, -0.01623770f, 0.02210569f, 0.03786525f, 0.00977921f, 
    0.07556790f, -0.05610952f, 0.13047083f, -0.01359635f, -0.44286475f, 0.00355945f, 0.20092425f, 0.14221902f, 
    -0.08345730f, -0.08160933f, -0.09729805f, 0.01637365f, 0.01652279f, -0.20006585f, 0.06874547f, -0.04987660f, 
    -0.00597067f, 0.02877080f, -0.07558554f, -0.08895528f, 0.03851303f, -0.05855237f, -0.03417628f, -0.10906772f, 
    -0.11327831f, -0.09469141f, -0.13202830f, -0.13732821f, 0.00276502f, -0.15912673f, 0.11473891f, -0.24047388f, 
    -0.00881609f, -0.01687306f, -0.01200625f, -0.02358441f, -0.10852751f, 0.04315853f, -0.21768819f, -0.29342431f, 
    -0.13818789f, -0.49934116f, -0.44464496f, 0.01232382f, 0.00482379f, 0.12209071f, 0.12085157f, -0.05007869f, 
    0.03478579f, 0.05029222f, 0.03521509f, -0.07569444f, -0.01228484f, -0.03402163f, -0.00516343f, -0.03882946f, 
    0.04124057f, 0.10623376f, 0.08127631f, 0.12382168f, 0.09705541f, -0.02458178f, 0.12613377f, -0.04497212f, 
    -0.21656640f, -0.14908154f, 0.02178281f, 0.01540784f, 0.02768774f, 0.10802361f, -0.03908667f, 0.10078495f, 
    -0.00724624f, 0.05035282f, 0.02007519f, 0.07079883f, 0.34251827f, -0.01759579f, -0.43645135f, -0.07261220f, 
    0.16638863f, 0.04161681f, -0.02487689f, 0.01868600f, 0.03172844f, 0.15923917f, 0.16014230f, 0.12498717f, 
    0.07840005f, -0.00713346f, -0.09249078f, -0.04353408f, -0.06103894f, -0.05916959f, 0.00907010f, -0.03086962f, 
    0.06835032f, 0.07787357f, 0.02217318f, 0.09390069f, -0.51212001f, -0.27125522f, -0.01564590f, 0.36431697f, 
    -0.02714978f, 0.21268807f, 0.13132098f, 0.03360743f, 0.01966389f, -0.05316482f, -0.02497985f, 0.04055509f, 
    0.04805919f, -0.02930180f, 0.15016417f, 0.01340876f, -0.02923834f, 0.10488249f, -0.04479826f, -0.02719251f, 
    -0.11762368f, -0.05131920f, -0.22470403f, -0.36819103f, -0.06016275f, -0.19385710f, -0.12198450f, -0.00426851f, 
    0.10267442f, 0.15458439f, 0.07466731f, 0.10393617f, -0.16111130f, -0.17120352f, -0.29451889f, -0.17244381f, 
    0.01856995f, -0.07787979f, 0.03532239f, -0.16672483f, -0.06952752f, -0.07750937f, 0.02236778f, 0.01092292f, 
    0.05188537f, 0.07531381f, 0.13099010f, 0.16060862f, 0.07580359f, -0.10107607f, -0.31004432f, -0.31699461f, 
    0.02330448f, -0.00978276f, -0.00646465f, 0.04131668f, 0.12179460f, -0.08170240f, 0.09458795f, -0.00121784f, 
    0.26173484f, 0.11909259f, -0.35571611f, -0.19200559f, -0.05808799f, -0.11737086f, 0.03284917f, -0.26441196f, 
    0.00068018f, -0.02842453f, 0.00370620f, 0.02769190f, -0.38688624f, -0.32042399f, -0.13360915f, -0.06974578f, 
    0.02051633f, 0.00543695f, -0.09901528f, 0.03059068f, -0.04486709f, 0.02551809f, -0.00076957f, 0.06114696f, 
    -0.20157304f, -0.11029474f, 0.05500372f, 0.02404209f, 0.08496511f, 0.04847159f, -0.03849703f, 0.05431931f, 
    0.03543763f, 0.03290680f, 0.06393617f, 0.07116743f, -0.20379028f, -0.24865593f, -0.39056671f, -0.27045089f, 
    -0.12222344f, 0.03878992f, 0.01199603f, -0.13125180f, 0.00824390f, 0.08426796f, 0.07306288f, 0.06720643f, 
    -0.13245629f, 0.16439272f, -0.02420727f, -0.11740551f, 0.01204537f, -0.00571062f, 0.06176534f, 0.05417957f, 
    -0.06577095f, 0.15918562f, -0.04474895f, 0.04677388f, -0.39320639f, 0.05080799f, 0.07237624f, 0.08353689f, 
    -0.03289593f, -0.02112312f, -0.18334943f, 0.01289515f, -0.19994903f, 0.02958093f, -0.08097275f, -0.20393096f, 
    0.17293297f, -0.19132729f, -0.04733654f, -0.18867156f, -0.04958070f, 0.13849467f, -0.21984340f, 0.07853524f, 
    0.02204897f, 0.00349987f, 0.11899034f, -0.22976848f, -0.29056945f, 0.02942682f, 0.11407738f, 0.00315964f, 
    -0.08992299f, 0.09731594f, -0.17725208f, -0.15162319f, -0.16213398f, -0.04321962f, -0.23803401f, -0.16338827f, 
    0.18622112f, -0.10533367f, 0.06408328f, 0.00786625f, -0.18752433f, -0.06308093f, -0.06984239f, -0.07729466f, 
    0.07098694f, 0.04148332f, -0.00173917f, 0.01442356f, -0.30880299f, -0.10413837f, -0.01075834f, 0.14823116f, 
    -0.06051901f, -0.01849084f, -0.06680047f, 0.08293857f, -0.02880914f, -0.06954274f, 0.02640858f, -0.13632770f, 
    -0.15791519f, -0.65825725f, -0.49686393f, 0.11219239f, -0.16462901f, -0.03937284f, -0.05873023f, -0.01256184f, 
    -0.12887260f, 0.05413966f, 0.04135908f, 0.02828253f, 0.56907880f, 0.27883866f, 0.06771293f, -0.29484621f, 
    0.10011332f, -0.02700030f, -0.02908214f, -0.06488819f, -0.02898716f, 0.01030809f, 0.00363427f, 0.10072573f, 
    0.06740531f, 0.00837483f, -0.09827045f, -0.05833043f, -0.06851230f, -0.08593891f, -0.05567429f, 0.05185584f, 
    0.21239713f, 0.11441328f, 0.09791355f, 0.10137945f, -0.51607352f, 0.15470771f, -0.04527708f, 0.13157366f, 
    0.04374039f, 0.07208458f, -0.09562325f, 0.05048830f, -0.22662982f, 0.03293267f, -0.02261414f, 0.00877849f, 
    0.25647521f, 0.09933031f, 0.05311200f, -0.03952918f, -0.06316841f, 0.01738643f, 0.03753896f, 0.00013561f, 
    0.08397957f, 0.07666771f, 0.08049638f, 0.10567653f, -0.10531038f, 0.01308180f, -0.02099117f, -0.16393366f, 
    -0.08966530f, -0.07184713f, 0.00985500f, -0.02775373f, 0.01027539f, -0.01473220f, 0.03455378f, 0.02335828f, 
    -0.35683402f, -0.25667062f, -0.04835160f, 0.26078382f, 0.05994526f, 0.14048485f, 0.12716827f, 0.03971885f, 
    -0.30407110f, -0.08117954f, -0.03023598f, -0.05899548f, -0.17894299f, -0.03505265f, 0.01777475f, 0.04597320f, 
    0.04239591f, 0.00566064f, -0.03159790f, 0.01607920f, -0.25751635f, 0.00945013f, -0.21233431f, -0.31057194f, 
    -0.08172374f, -0.05059063f, 0.17936845f, -0.08551002f, -0.11193354f, -0.04368099f, -0.07124654f, -0.09997483f, 
    0.03465863f, 0.08238220f, 0.04149141f, 0.12877947f, 0.01819702f, 0.18492950f, 0.12532485f, 0.20659518f, 
    0.07273189f, 0.06382830f, 0.00358463f, 0.13537708f, 0.14305171f, 0.00946368f, 0.10214891f, 0.14970331f, 
    0.23608522f, -0.05749593f, 0.04174690f, 0.11444694f, 0.04865479f, 0.12623434f, 0.11699798f, -0.05981592f, 
    0.02397534f, 0.03905876f, -0.05721514f, 0.02033744f, 0.20862111f, 0.01200182f, -0.17252456f, 0.09661139f, 
    -0.01348670f, 0.02201347f, -0.17801084f, -0.03860958f, -0.00932891f, -0.07996903f, 0.00894602f, -0.10149649f, 
    0.25280422f, 0.13590255f, -0.22696042f, -0.28982610f, -0.18595007f, -0.21444479f, -0.05871170f, -0.10732096f, 
    0.08178601f, 0.06073578f, 0.07974935f, 0.08935421f, 0.50281549f, 0.04903523f, -0.21659175f, -0.10767772f, 
    -0.03670330f, -0.09122471f, 0.04891607f, -0.13168366f, 0.10256251f, 0.08807018f, -0.08102685f, 0.03899157f, 
    0.10150260f, -0.17331317f, -0.05624639f, -0.24535149f, -0.13427654f, -0.05655998f, 0.09943374f, -0.01208500f, 
    0.03965458f, 0.09247341f, 0.16127682f, 0.02183568f, 0.21232758f, -0.01365512f, -0.02803742f, 0.12604076f, 
    -0.07591148f, -0.20704706f, 0.00440813f, -0.08507359f, 0.22461289f, 0.12854481f, 0.16539735f, 0.27488968f, 
    -0.67905152f, 0.03248192f, 0.13267376f, 0.20586428f, -0.09755067f, -0.08519278f, -0.15378664f, -0.02191352f, 
    -0.04441563f, -0.04408676f, -0.05659404f, -0.02345042f, -0.08130115f, -0.37041295f, -0.20712653f, -0.01150445f, 
    0.17179178f, 0.23831826f, 0.10829449f, 0.01180129f, -0.04054285f, -0.06697914f, -0.05917986f, -0.05962420f, 
    -0.12707059f, -0.03966212f, -0.23111670f, -0.14877185f, -0.06634440f, -0.09929266f, -0.06759860f, -0.09384307f, 
    0.03578056f, -0.16739418f, -0.17004764f, -0.04360338f, -0.12862118f, -0.21533354f, -0.26797119f, -0.14468412f, 
    -0.01612984f, 0.04345616f, 0.06505359f, 0.05865004f, 0.14721695f, -0.15171956f, -0.09160782f, -0.00820683f, 
    0.00092073f, -0.34210536f, -0.23170398f, -0.51368099f, 0.17033345f, -0.02680304f, 0.04814803f, -0.06141371f, 
    0.05466400f, 0.03508168f, 0.04777487f, -0.16671503f, 0.04788481f, 0.19703518f, 0.11635569f, -0.03408358f, 
    -0.02362716f, -0.04123306f, -0.02471754f, -0.05719380f, -0.04724597f, -0.08521713f, -0.10369676f, -0.04889179f, 
    -0.01537648f, 0.10085394f, 0.00518683f, 0.01787090f, 0.13700229f, -0.04788732f, -0.12410530f, -0.04334252f, 
    -0.01667115f, 0.08986736f, 0.09523696f, 0.07580411f, -0.15042596f, -0.14327677f, -0.00692369f, 0.41982782f, 
    -0.06344876f, 0.05285624f, 0.00807551f, 0.12355278f, -0.05675527f, 0.02092139f, -0.07743252f, 0.02333455f, 
    -0.20820729f, -0.10634339f, -0.14966317f, -0.06491014f, 0.05889148f, 0.11588215f, 0.05129787f, 0.02747368f, 
    -0.00760408f, -0.07056440f, 0.08853234f, 0.10080279f, 0.07513690f, 0.10245077f, 0.09445262f, 0.03342858f, 
    -0.00556641f, 0.00572745f, -0.01205725f, -0.05924800f, 0.08610930f, -0.06299649f, 0.10472640f, 0.04202811f, 
    -0.02527054f, -0.09929205f, 0.20445995f, 0.24403316f, -0.05406351f, -0.09840023f, 0.07782882f, 0.09682210f, 
    -0.02782117f, 0.00004983f, -0.04168679f, 0.02638991f, -0.11394884f, -0.17732014f, 0.06476873f, -0.06907806f, 
    0.01119325f, 0.01391408f, 0.04059723f, 0.09655306f, -0.17740993f, -0.00608380f, 0.04551297f, -0.26424095f, 
    0.00213437f, -0.28663307f, -0.42364147f, -0.26469198f, -0.17729545f, -0.09014984f, 0.16486895f, -0.10164840f, 
    0.07380913f, 0.10303584f, 0.24057153f, 0.03121570f, -0.32784808f, -0.06969421f, 0.07249131f, 0.11408184f, 
    0.04523216f, 0.01788333f, -0.02798631f, 0.05857088f, 0.00245885f, 0.16018492f, 0.08095253f, 0.01007499f, 
    -0.02516922f, -0.46987855f, -0.38359475f, -0.29480156f, 0.01100516f, 0.02725554f, 0.09818339f, 0.08042298f, 
    0.08867359f, 0.10106481f, 0.01108745f, 0.03350190f, 0.18921158f, 0.05891112f, -0.23585427f, -0.23469397f, 
    0.13797188f, -0.09248722f, 0.04868162f, -0.10538765f, 0.09418808f, 0.03803145f, -0.02719141f, -0.04612624f, 
    0.04213738f, -0.10533796f, 0.50447613f, -0.29004332f, 0.01978378f, -0.26999667f, -0.07661610f, -0.12097639f, 
    -0.21397857f, 0.00735696f, 0.03439005f, -0.01296115f, -0.09129709f, 0.26086098f, -0.03114785f, 0.44873232f, 
    0.11600676f, 0.02074179f, -0.23132060f, -0.03796162f, -0.05662590f, -0.13163999f, -0.04269659f, -0.03525448f, 
    0.02004723f, 0.01665725f, -0.18993942f, 0.05847555f, -0.11482375f, -0.08920310f, 0.04398012f, 0.06157258f, 
    0.05097936f, -0.01436086f, -0.02072353f, -0.24031015f, 0.24331930f, -0.07919741f, 0.10127269f, -0.00431689f, 
    0.10376509f, 0.08876287f, -0.17988859f, -0.03486768f, 0.02384886f, -0.10195982f, -0.10830540f, -0.01280270f, 
    0.33383793f, -0.21702890f, -0.62377965f, 0.09831586f, 0.08380304f, -0.03447557f, 0.01499365f, 0.04276479f, 
    0.00720969f, 0.00571677f, -0.00534011f, -0.03581291f, -0.03607373f, 0.29074934f, 0.32402360f, -0.31841791f, 
    -0.09491213f, -0.11163754f, 0.18054427f, 0.12997231f, -0.05414432f, 0.05459745f, 0.07620041f, 0.00336550f, 
    -0.02389489f, 0.02011891f, 0.01397900f, 0.08002035f, 0.15135142f, 0.00909766f, 0.04994232f, 0.08114263f, 
    0.08256548f, -0.07619161f, -0.10278309f, -0.07581110f, -0.00249271f, -0.05246694f, -0.40709814f, -0.37676007f, 
    -0.30992460f, -0.03234581f, -0.24158323f, -0.06318271f, 0.01219508f, -0.07749882f, 0.03204671f, 0.04530302f, 
    -0.00621231f, -0.11944124f, -0.00723369f, -0.07522631f, 0.00744924f, 0.06548222f, -0.08993923f, -0.01832342f, 
    -0.08890425f, 0.00041795f, 0.07083021f, -0.14793901f, -0.04375936f, -0.08281477f, -0.10744135f, -0.11762048f, 
    0.09101275f, -0.02795226f, 0.07721429f, 0.06456396f, -0.07336439f, -0.13200293f, -0.05623917f, -0.10273964f, 
    0.11631262f, -0.09618842f, 0.15272118f, 0.12670919f, 0.05762813f, 0.04196575f, 0.05747194f, -0.06263608f, 
    0.13141242f, 0.10882927f, 0.20391183f, 0.03964525f, -0.09194156f, -0.08421083f, 0.32030931f, 0.28157583f, 
    0.05918449f, 0.00889537f, -0.04390220f, -0.14360039f, 0.06501821f, 0.08353521f, 0.03407661f, -0.03016760f, 
    -0.32739195f, 0.39891559f, -0.12475455f, -0.17851907f, -0.32700735f, -0.04243912f, 0.06521560f, 0.04956782f, 
    0.09688080f, -0.00477381f, -0.00347082f, -0.08446706f, -0.05383098f, 0.24254712f, -0.13867764f, 0.16351593f, 
    -0.07097722f, -0.23393650f, -0.01727956f, -0.14922078f, 0.10334685f, -0.18498842f, 0.04944339f, 0.04662912f, 
    0.05692231f, 0.13503139f, -0.00272922f, -0.15961108f, 0.19622386f, -0.24630177f, -0.06166922f, -0.09235629f, 
    0.11920644f, 0.17380626f, 0.03843674f, 0.01180161f, 0.12108780f, 0.26086614f, -0.04301609f, 0.02528514f, 
    -0.08952255f, -0.10659768f, -0.06124502f, -0.05398927f, 0.17125469f, 0.03328377f, -0.05500864f, 0.06247369f, 
    -0.24995703f, -0.21203898f, 0.00417176f, 0.06494986f, 0.13424711f, 0.03289120f, -0.02810680f, -0.04202547f, 
    0.03643583f, 0.07288538f, -0.06277737f, -0.07591652f, -0.00985304f, 0.33586952f, 0.53888941f, -0.63947260f, 
    -0.04536157f, -0.04974496f, 0.05281602f, -0.10672655f, -0.07794655f, 0.08163436f, 0.04743810f, 0.10864178f, 
    -0.04993591f, -0.05790569f, 0.18967257f, 0.09127937f, 0.05736723f, -0.02550706f, -0.06414270f, 0.03591518f, 
    0.05907965f, 0.14074373f, 0.00436940f, 0.16973805f, 0.03844977f, -0.00205322f, 0.37996423f, -0.11705191f, 
    -0.00487816f, -0.10943162f, -0.12561855f, -0.25902024f, 0.09236443f, 0.09648931f, -0.01380698f, 0.08963916f, 
    -0.40482479f, 0.07593746f, 0.24360804f, 0.25740379f, -0.09263652f, 0.07215437f, -0.05995312f, -0.11765701f, 
    -0.04350894f, -0.15784207f, 0.07746630f, 0.06537808f, 0.09967948f, 0.21317904f, 0.28340858f, 0.43840542f, 
    0.12629840f, -0.05535369f, -0.08958947f, -0.12837067f, 0.00655858f, -0.05106608f, 0.04462145f, 0.05308822f, 
    -0.33685330f, -0.38402495f, 0.30998424f, -0.29738116f, 0.02241894f, -0.12930012f, -0.26697013f, 0.10597903f, 
    0.07063336f, 0.03833684f, 0.02216197f, 0.05454604f, 0.01272521f, 0.45057991f, -0.25821403f, -0.04120327f, 
    -0.02884386f, -0.01767714f, 0.13804978f, 0.29745525f, -0.07053474f, 0.07542139f, -0.00166056f, -0.02257337f, 
    -0.05108209f, -0.05084074f, -0.24615958f, -0.17517290f, 0.09037513f, -0.18788250f, 0.09109176f, -0.12735587f, 
    0.09897088f, -0.02927374f, -0.02363615f, -0.01039817f, 0.02662075f, -0.03242870f, 0.11881649f, -0.38843900f, 
    -0.01727971f, -0.22304982f, 0.13927060f, 0.12958768f, 0.08061530f, 0.04223321f, -0.03094205f, -0.06837009f, 
    0.02804371f, -0.18526037f, -0.17950913f, 0.01237932f, -0.03060366f, 0.02461332f, 0.04350514f, -0.08317449f, 
    0.11530790f, -0.02769103f, 0.00098288f, -0.14343032f, -0.18580832f, 0.06891803f, -0.21012524f, 0.04428555f, 
    0.04391564f, 0.01448908f, 0.18302727f, 0.05694170f, 0.03437628f, 0.04925583f, 0.00451686f, 0.17471416f, 
    0.07429764f, 0.17810228f, 0.27274951f, 0.27109158f, 0.13862103f, -0.08301628f, -0.23276348f, -0.03057412f, 
    -0.02047514f, -0.01373199f, 0.14530341f, -0.14216195f, -0.12582889f, -0.20308991f, -0.29473275f, -0.20302597f, 
    0.04013868f, 0.21638146f, 0.13102251f, 0.03019195f, 0.03272999f, -0.08997473f, -0.01827052f, 0.04575540f, 
    0.34458810f, -0.06657819f, 0.04238378f, -0.15981580f, 0.14358777f, 0.07100131f, 0.07778916f, -0.02211846f, 
    0.03603984f, -0.04996610f, -0.03744081f, -0.07351554f, 0.03771564f, 0.05452324f, -0.02398210f, -0.21549037f, 
    -0.07016858f, -0.00292472f, 0.13000502f, 0.08691581f, 0.08316014f, 0.11142345f, -0.00681279f, 0.06116237f, 
    -0.38854796f, 0.14266558f, 0.13905786f, -0.40131769f, 0.01511828f, -0.26295376f, 0.05026864f, 0.17146306f, 
    -0.03447253f, -0.03242933f, 0.00017002f, -0.00103555f, -0.66648918f, -0.36581105f, -0.30725035f, 0.18697791f, 
    0.02414937f, 0.08221737f, 0.04381535f, 0.04277551f, 0.05338001f, 0.02632908f, 0.04832415f, -0.03139262f, 
    -0.08016239f, -0.11602842f, -0.12231676f, -0.01398891f, 0.16341686f, -0.04553170f, -0.05358447f, 0.19601054f, 
    -0.17608815f, -0.10161638f, -0.10031346f, -0.18072022f, -0.28204831f, 0.35114318f, -0.19268306f, -0.38371354f, 
    -0.09406962f, -0.36758190f, 0.14076526f, -0.10494480f, 0.02235701f, 0.13801654f, -0.09198996f, -0.15742795f, 
    -0.05696891f, -0.47545943f, 0.01939349f, -0.10813500f, 0.03478307f, 0.14095384f, -0.11584702f, 0.09470200f, 
    -0.03221736f, -0.00768042f, -0.05124108f, -0.17949146f, -0.03857538f, -0.18031301f, 0.09980410f, 0.16605186f, 
    0.05047544f, 0.19034277f, 0.05482395f, 0.03611415f, 0.18095742f, 0.05487787f, 0.03252839f, -0.16686720f, 
    -0.15938704f, 0.20264979f, 0.23125841f, -0.64801455f, -0.04944618f, -0.20609929f, 0.02863089f, -0.10251708f, 
    -0.04505191f, 0.02567808f, 0.04052102f, 0.08861466f, 0.07470009f, 0.01346550f, -0.01091786f, -0.10939115f, 
    0.01314821f, 0.08165053f, 0.11955743f, 0.03347312f, 0.05938561f, 0.03302222f, 0.14162202f, 0.29073271f, 
    0.06962853f, -0.16769366f, 0.12215838f, -0.15389089f, 0.08602421f, -0.06552496f, -0.01874345f, 0.02491622f, 
    -0.18139236f, 0.05561817f, 0.03470940f, -0.09939264f, 0.08920752f, -0.03726110f, -0.01355619f, -0.31036001f, 
    0.08260509f, -0.00270361f, -0.15576535f, 0.12110925f, -0.08122732f, -0.00041568f, -0.03218433f, -0.12145343f, 
    0.37839022f, -0.52760655f, 0.14739159f, -0.46452758f, -0.04725694f, -0.06004094f, -0.28237540f, 0.18014413f, 
    -0.07005787f, -0.03381668f, -0.02469787f, -0.03105982f, -0.32488245f, 0.17079554f, -0.21034209f, 0.06837121f, 
    -0.03795274f, 0.00790347f, 0.16519392f, 0.11189821f, 0.07147899f, 0.03384008f, 0.06589600f, -0.00790342f, 
    -0.38445479f, -0.28334084f, -0.01234041f, 0.13753064f, 0.00870696f, 0.07338405f, -0.06233918f, 0.08876180f, 
    -0.01114563f, 0.00338232f, 0.04774444f, -0.04044829f, -0.31909654f, -0.44044185f, -0.29275128f, -0.04684414f, 
    0.05952105f, -0.03463399f, 0.25497058f, 0.08319138f, -0.00400591f, -0.00795146f, -0.07136075f, -0.03668387f, 
    -0.05311868f, 0.05868501f, 0.11927166f, 0.28274402f, 0.01000630f, 0.03836381f, -0.19516805f, 0.00734932f, 
    -0.03017552f, -0.09348845f, -0.01934002f, 0.00628798f, -0.08791818f, -0.33911687f, -0.00817576f, -0.16100284f, 
    -0.01662807f, 0.13434802f, -0.11187610f, 0.07764611f, 0.03999883f, -0.08985770f, 0.08223609f, -0.04761299f, 
    -0.54929727f, 0.05984618f, -0.07084822f, -0.05104975f, 0.13146013f, -0.04521845f, 0.15737900f, 0.07027971f, 
    -0.04606353f, -0.02518211f, 0.03744825f, 0.02227877f, 0.00819081f, -0.10439175f, 0.19494237f, -0.32045335f, 
    -0.07943738f, -0.03523668f, -0.01191281f, 0.01970528f, 0.06125445f, 0.00004350f, -0.03041157f, 0.05649270f, 
    -0.00737004f, -0.15971963f, 0.13267590f, 0.19698817f, 0.00334551f, 0.01732840f, -0.09972419f, -0.01163919f, 
    0.03299862f, 0.10726838f, 0.04455819f, 0.22525211f, 0.23122978f, 0.12966023f, 0.21019484f, 0.13366000f, 
    0.04611966f, -0.08727739f, -0.14370073f, -0.11111069f, -0.05780682f, 0.13661218f, 0.01020675f, 0.11817747f, 
    -0.03794426f, -0.21262704f, 0.20589378f, 0.09932256f, -0.13564375f, 0.22876985f, -0.01324310f, 0.01736823f, 
    -0.01818831f, 0.13338153f, 0.01384723f, 0.01069568f, -0.04310076f, -0.33566964f, 0.09610748f, -0.10650880f, 
    0.19820228f, 0.09586830f, 0.03161226f, 0.05496675f, -0.04729928f, -0.05921221f, 0.03557852f, 0.05195092f, 
    -0.04025230f, 0.06094588f, -0.24407288f, -0.17614228f, -0.06877487f, -0.00820589f, -0.09683484f, -0.07112644f, 
    0.09459779f, -0.10618422f, -0.08685358f, -0.01648573f, -0.06641047f, 0.13402314f, -0.16292953f, -0.47680879f, 
    -0.04282568f, -0.08605453f, -0.10912775f, 0.02521645f, 0.11347698f, -0.02409440f, -0.03079513f, -0.06549273f, 
    0.20189303f, 0.10857470f, -0.16337232f, -0.12346905f, -0.21290049f, 0.04558135f, -0.08182630f, -0.11790401f, 
    -0.06134019f, -0.10357674f, 0.05116899f, 0.03322205f, -0.11341320f, 0.00442519f, -0.07609839f, -0.10991188f, 
    0.09501377f, -0.00541187f, 0.04774630f, 0.01050374f, -0.19235998f, 0.08754089f, 0.07116265f, -0.03306033f, 
    0.20805122f, -0.03026508f, 0.18554626f, -0.52929556f, 0.09204953f, -0.20633112f, 0.13708614f, -0.05974071f, 
    -0.04608349f, -0.15724713f, -0.00828682f, 0.26195231f, -0.15045407f, 0.17949699f, 0.03389622f, 0.17985028f, 
    0.02530714f, -0.04475105f, -0.05519598f, -0.09517974f, 0.11052769f, -0.05476020f, 0.21378556f, 0.10209943f, 
    -0.08478705f, 0.02835268f, 0.15155755f, 0.27771327f, -0.02829811f, 0.06986734f, -0.37604550f, -0.00830875f, 
    -0.02829695f, -0.11569134f, -0.01785297f, -0.00836990f, -0.09817170f, 0.11750799f, -0.04758517f, -0.13552533f, 
    0.02749078f, -0.08085360f, 0.10994262f, 0.12796342f, 0.08646129f, 0.14063035f, -0.23641464f, -0.14272301f, 
    0.17987503f, 0.13093263f, 0.08047179f, -0.06473269f, -0.00447903f, -0.13585314f, -0.04216937f, 0.00574318f, 
    0.10180119f, -0.02031836f, -0.02761493f, -0.02526307f, -0.27181640f, -0.04652027f, 0.15792485f, 0.22432001f, 
    0.00085363f, -0.01801469f, -0.13615178f, -0.18895653f, 0.15744586f, -0.06373528f, -0.03465870f, 0.11700329f, 
    -0.38838512f, 0.15484907f, -0.20197032f, 0.02216023f, 0.00781867f, -0.02892864f, -0.11329809f, 0.19010572f, 
    -0.03809357f, -0.11532274f, -0.07663903f, -0.11323518f, 0.28526354f, 0.32665733f, 0.07158647f, -0.15922999f, 
    0.03119261f, -0.02783711f, 0.00723732f, -0.03997295f, -0.00725102f, 0.11320847f, -0.03072383f, 0.12477207f, 
    0.12239205f, -0.19595687f, 0.29694915f, 0.15507814f, 0.02672771f, -0.13584512f, 0.07509790f, 0.05746075f, 
    0.04317448f, 0.11300971f, 0.05177325f, -0.03518515f, 0.06761444f, 0.10100456f, 0.18197374f, 0.06594601f, 
    -0.08167175f, -0.08497625f, 0.19303071f, 0.05801988f, 0.08741707f, 0.09256867f, 0.06937397f, 0.08584353f, 
    -0.31375161f, -0.01511840f, -0.14239587f, 0.45740035f, 0.02373719f, 0.16399471f, 0.02960309f, 0.02904035f, 
    0.18353561f, 0.09039770f, -0.13018410f, 0.09641028f, -0.12379193f, -0.26930445f, -0.13429840f, -0.03869583f, 
    0.02183152f, -0.06638535f, 0.07109115f, -0.02179381f, -0.03476094f, -0.14723890f, -0.12957667f, -0.01037831f, 
    -0.05219996f, 0.12396872f, -0.01436016f, -0.03846595f, -0.12769003f, -0.01046148f, -0.03550803f, 0.06005953f, 
    -0.01039325f, 0.02127386f, 0.14834933f, 0.23476177f, 0.05070829f, 0.09813597f, -0.02723662f, -0.07464068f, 
    0.07677169f, -0.13028203f, 0.04828222f, 0.08012643f, -0.12586141f, 0.18453014f, -0.04413925f, -0.08204216f, 
    -0.07784481f, -0.09145976f, 0.12845525f, -0.10557944f, -0.04445224f, 0.09619545f, -0.12409414f, 0.05026064f, 
    0.01810660f, 0.00877235f, 0.09206060f, -0.05671173f, -0.09144092f, 0.20779768f, -0.01947502f, 0.07979874f, 
    0.08774022f, 0.02356157f, -0.14638285f, 0.03545260f, -0.02203234f, -0.00347000f, 0.11817728f, -0.05841070f, 
    -0.26474756f, 0.17020458f, -0.08828388f, -0.15660790f, -0.09686260f, 0.00448425f, 0.03537493f, -0.02388943f, 
    -0.01857186f, 0.00760660f, -0.17300914f, -0.24584791f, -0.07898764f, 0.28265625f, -0.02034459f, -0.18328512f, 
    0.00533733f, 0.01183803f, 0.03211619f, 0.04589973f, -0.05692337f, -0.25312439f, -0.36701083f, -0.22178940f, 
    0.10317085f, -0.50460058f, 0.09420489f, 0.05406167f, -0.05292750f, 0.01390086f, -0.04399688f, -0.00754490f, 
    -0.00395351f, -0.03520647f, 0.08124882f, 0.04434049f, 0.04336606f, 0.22536786f, 0.22853595f, -0.14544669f, 
    0.00045641f, -0.06681710f, -0.03520293f, 0.02793826f, 0.02679751f, 0.05656017f, -0.01178252f, -0.11507271f, 
    -0.07726642f, -0.05070940f, 0.24035043f, 0.05724604f, -0.18319382f, -0.05775383f, -0.04982124f, 0.09640545f, 
    0.02354801f, 0.05403941f, -0.00794042f, -0.10662896f, 0.04231606f, 0.02563943f, 0.19249161f, -0.04692292f, 
    -0.06460862f, 0.00188597f, 0.09790691f, -0.07349665f, -0.19545181f, -0.09611703f, -0.03948027f, 0.14479338f, 
    -0.30105191f, -0.06722086f, 0.05245890f, -0.31570625f, -0.24029472f, -0.01736851f, 0.02573939f, 0.01595197f, 
    0.03247586f, -0.08938139f, 0.10081615f, 0.12467424f, 0.04188767f, 0.01864406f, 0.21138416f, 0.17584944f, 
    0.00024259f, 0.07386220f, -0.09288561f, 0.02057711f, -0.09543384f, -0.10780393f, 0.11111327f, -0.12089840f, 
    -0.14908718f, 0.12644506f, 0.01988702f, 0.11086587f, 0.04593205f, 0.02146906f, -0.07120001f, 0.04739104f, 
    -0.06310473f, -0.18053280f, -0.34169802f, -0.24843194f, -0.31687608f, 0.10814968f, -0.03970963f, -0.08251611f, 
    0.02003789f, -0.17161436f, 0.01376401f, 0.09011301f, -0.09260134f, -0.04954544f, -0.41278106f, -0.20254309f, 
    0.49551320f, -0.16273607f, 0.12568325f, -0.10868014f, -0.18643332f, 0.06837136f, 0.17155385f, 0.05176253f, 
    0.05748358f, 0.11894532f, 0.06340070f, -0.00769895f, -0.34762764f, 0.22735485f, -0.08852761f, -0.03428965f, 
    -0.01836281f, 0.07912185f, -0.10196275f, 0.02486741f, 0.02622457f, -0.01792756f, 0.06477445f, 0.01441645f, 
    -0.21777381f, -0.27157316f, 0.17540425f, 0.13561237f, -0.07422644f, 0.22157663f, -0.18295608f, 0.06317250f, 
    -0.02371699f, 0.00124251f, 0.06143004f, -0.09155448f, -0.26216185f, 0.03064501f, -0.14165172f, -0.08177016f, 
    0.11118902f, 0.11249619f, -0.01177617f, -0.14584558f, -0.02186030f, 0.07815371f, -0.00653449f, 0.00674645f, 
    -0.12843239f, 0.17834714f, -0.05672866f, 0.22297649f, -0.10438282f, -0.07079675f, -0.02961663f, 0.04281446f, 
    -0.18667886f, -0.01288832f, -0.06849675f, 0.00754370f, -0.11808152f, -0.07455322f, -0.39002323f, 0.36536241f, 
    -0.06083472f, 0.01733500f, -0.14079368f, -0.01017868f, 0.10546328f, 0.00462750f, 0.10537195f, 0.07329480f, 
    0.02944320f, 0.28787926f, -0.25039747f, 0.27053231f, -0.13104877f, -0.07598032f, 0.13007502f, -0.07441950f, 
    -0.04890941f, 0.16450875f, -0.16394767f, 0.11090095f, 0.02096980f, 0.20528430f, -0.05003133f, -0.03932784f, 
    -0.05985926f, -0.06934659f, 0.00946047f, -0.08629345f, -0.07302041f, -0.03201938f, -0.21342030f, -0.13001761f, 
    -0.39273614f, 0.27616560f, 0.08994020f, 0.02648387f, -0.00951939f, -0.00828685f, 0.08504818f, 0.12797561f, 
    0.03342637f, 0.03505867f, -0.17735633f, -0.09232282f, -0.11465184f, 0.01958728f, 0.12824509f, -0.01903330f, 
    -0.04808293f, -0.17624505f, -0.12652671f, -0.11134516f, -0.22185265f, -0.10389154f, -0.09461480f, -0.11561912f, 
    -0.26820418f, -0.34947422f, -0.11953453f, -0.13930783f, -0.15760659f, 0.09721564f, 0.04819328f, 0.09996174f, 
    0.10600147f, 0.08390486f, 0.02183731f, -0.04179268f, 0.06348604f, 0.00232560f, -0.09602645f, 0.26460722f, 
    0.07042754f, -0.19289924f, -0.00655317f, -0.02129789f, -0.21009183f, -0.18844794f, -0.14729549f, -0.15807264f, 
    -0.23433350f, -0.25325507f, 0.07909164f, 0.09391872f, -0.10064368f, -0.00858520f, 0.04065296f, 0.09192824f, 
    0.01059674f, 0.07478110f, 0.07826421f, 0.08418079f, -0.18089630f, 0.13918391f, 0.17915301f, -0.06124472f, 
    -0.08015615f, -0.01943497f, 0.10065661f, -0.05351946f, -0.02542481f, -0.00004998f, -0.13251692f, -0.08318606f, 
    -0.07182456f, -0.02356633f, -0.13993219f, 0.03915688f, -0.03033347f, -0.04285846f, 0.01880682f, 0.12303898f, 
    -0.06770324f, 0.15383402f, -0.02146613f, 0.17330815f, -0.09422369f, -0.11928447f, 0.02308021f, 0.21766275f, 
    0.00152322f, -0.23137012f, 0.19091678f, -0.04074711f, -0.07864121f, -0.03853996f, -0.02799365f, 0.15105835f, 
    -0.23643023f, 0.12029858f, 0.14776894f, 0.12414582f, -0.03786664f, 0.09577094f, 0.01486179f, 0.08879767f, 
    0.02322234f, 0.03802849f, 0.20741369f, 0.11851881f, -0.11453869f, -0.29915553f, -0.34012190f, -0.21334909f, 
    -0.24262634f, -0.09537210f, -0.00506142f, -0.00009514f, 0.14328012f, 0.10859113f, 0.07294378f, 0.11849053f, 
    -0.01596914f, 0.05406145f, 0.15606824f, -0.08984500f, 0.03955197f, 0.00546600f, 0.20839104f, -0.07655195f, 
    0.08906289f, 0.04987257f, 0.04196908f, -0.06671588f, 0.08222054f, 0.10771810f, -0.06023774f, -0.10160211f, 
    -0.05513105f, -0.03777568f, -0.03497097f, -0.03550366f, -0.12704970f, -0.18217176f, -0.21390350f, -0.31695026f, 
    -0.28194904f, 0.20995021f, -0.12119413f, 0.11208758f, -0.06684151f, 0.05014015f, -0.10330814f, 0.07860409f, 
    0.04553659f, -0.06958073f, 0.00698007f, 0.01924008f, -0.10578589f, 0.22360936f, 0.08115561f, 0.34674656f, 
    0.00970455f, 0.06755649f, -0.15147226f, 0.20427766f, -0.03433487f, 0.01660092f, 0.09042685f, 0.06426333f, 
    -0.39529848f, 0.16278373f, -0.11485177f, 0.02239595f, 0.09174212f, 0.18035290f, -0.01988600f, -0.16524227f, 
    0.13619459f, -0.07270748f, -0.04151388f, 0.02366425f, 0.03309578f, 0.09064636f, -0.02008784f, -0.12656027f, 
    -0.03065174f, -0.04666927f, -0.11758413f, -0.09619635f, -0.02789188f, 0.04610780f, -0.05414415f, -0.11718268f, 
    -0.22249584f, 0.04461084f, -0.34469879f, 0.05114476f, -0.07463399f, 0.06600360f, 0.06260224f, -0.03887941f, 
    0.02838854f, 0.09386320f, -0.00191066f, -0.03370881f, -0.52612442f, 0.00247451f, 0.26416519f, 0.19726649f, 
    -0.13998720f, 0.18562800f, 0.09449529f, 0.10730552f, -0.02477361f, -0.00536695f, 0.09848786f, 0.04910195f, 
    -0.14328137f, 0.39177182f, 0.20607032f, 0.02836143f, -0.04054082f, -0.01902474f, -0.02422293f, -0.05559002f, 
    -0.03908397f, 0.06540474f, -0.02062756f, 0.09406305f, -0.07322200f, 0.14610693f, 0.10682155f, 0.35809484f, 
    0.12655924f, 0.10066011f, -0.01932417f, -0.11351274f, 0.07338043f, -0.00187849f, 0.07444252f, 0.16981904f, 
    0.07909197f, -0.30976632f, 0.00177562f, -0.08015644f, -0.14813440f, -0.04695194f, -0.01521360f, -0.05253889f, 
    -0.02579902f, -0.01343194f, -0.15410918f, 0.05124636f, -0.18930376f, 0.02189144f, 0.04210537f, 0.00118448f, 
    0.00573284f, -0.10148326f, -0.04524851f, 0.05335224f, -0.08468277f, -0.01214399f, -0.05517152f, -0.14483868f, 
    -0.36376762f, 0.24024537f, -0.20042680f, -0.15594712f, -0.06968844f, -0.00488393f, -0.08176404f, 0.05766291f, 
    -0.06053682f, -0.19797955f, -0.04802879f, -0.11715084f, -0.12257277f, -0.06593660f, -0.02765284f, -0.06924660f, 
    -0.02807178f, 0.05442218f, -0.11090355f, -0.03971969f, -0.06661637f, -0.02601097f, 0.03930353f, -0.05348760f, 
    -0.20993792f, 0.04072973f, -0.65827376f, -0.04232023f, 0.06589469f, 0.11275437f, 0.09821874f, -0.05038652f, 
    0.02863906f, 0.13441156f, -0.13393894f, -0.07351892f, -0.12577100f, -0.29862878f, -0.11878601f, -0.15199982f, 
    -0.27123496f, -0.03085752f, -0.02201276f, -0.17018279f, 0.09951863f, -0.06046174f, -0.04867221f, -0.09536673f, 
    0.00711105f, -0.08447504f, 0.27672815f, -0.00811996f, -0.11972040f, 0.24417259f, 0.22093034f, 0.04312606f, 
    0.08616539f, 0.01078963f, 0.10446742f, 0.10269383f, 0.40013674f, -0.33957416f, 0.21832177f, 0.16388047f, 
    -0.09074319f, 0.11655761f, 0.08247068f, 0.09125390f, -0.10718174f, 0.08984348f, -0.00581404f, 0.11642800f, 
    0.00775512f, 0.24102628f, -0.13359353f, 0.09801283f, 0.09518378f, -0.16187508f, 0.08722422f, -0.00772293f, 
    -0.17080353f, 0.08609451f, -0.14234953f, -0.00021377f, 0.00731213f, -0.07815336f, 0.07991511f, 0.04761302f, 
    -0.10536309f, -0.04254710f, -0.02187650f, -0.12614663f, 0.16630886f, 0.01273282f, 0.01766843f, 0.11633340f, 
    0.06046287f, 0.10373070f, 0.24757609f, 0.21611957f, 0.05949768f, -0.06568305f, 0.18730462f, -0.15312372f, 
    -0.07617314f, 0.18415982f, 0.00923503f, -0.10622955f, 0.24223836f, -0.05155391f, 0.11802984f, -0.14270969f, 
    0.00372665f, -0.00723019f, 0.06529774f, -0.02160528f, -0.10168827f, 0.05970542f, -0.06132764f, -0.29654795f, 
    0.03565229f, -0.09297463f, 0.01502326f, -0.15175223f, -0.07663319f, -0.04976930f, 0.02612062f, 0.04828167f, 
    0.00390955f, 0.03830172f, 0.04414199f, 0.01581485f, -0.08749560f, -0.01633339f, -0.03683982f, 0.13889322f, 
    -0.16459687f, -0.12648489f, 0.02132743f, -0.06406305f, -0.15542643f, 0.05827613f, -0.05284801f, 0.09261071f, 
    -0.08002824f, -0.06898344f, 0.02471552f, 0.06148197f, 0.04239211f, 0.08712103f, -0.01131117f, 0.11278875f, 
    -0.00387970f, 0.07701378f, 0.02310189f, -0.02172688f, -0.16347884f, 0.18907721f, -0.13823646f, -0.32011190f, 
    0.00201240f, 0.03805161f, -0.04186308f, -0.15106565f, -0.19481346f, -0.06017233f, -0.05848401f, -0.23175892f, 
    -0.38064674f, -0.28752452f, 0.09546941f, 0.10419071f, 0.05905885f, 0.05814718f, -0.07158212f, 0.20998439f, 
    -0.04705510f, 0.02472080f, 0.11330613f, -0.07048349f, -0.25429770f, -0.30889890f, -0.10233210f, -0.06341197f, 
    0.04301548f, 0.00178742f, 0.03585938f, -0.08363340f, -0.02629464f, -0.01463731f, -0.09819335f, -0.10114112f, 
    0.14746456f, -0.28627914f, 0.30501544f, 0.08860043f, -0.00072050f, 0.38873005f, -0.28378403f, 0.12523973f, 
    -0.00039452f, 0.14017713f, 0.16330948f, 0.16716917f, -0.11572795f, 0.02130804f, -0.10506980f, 0.22815220f, 
    0.14917457f, 0.00454175f, -0.06634179f, 0.03133915f, -0.06090852f, -0.00534169f, -0.16010688f, -0.11613674f, 
    -0.23750050f, 0.11738253f, 0.16953471f, -0.15536256f, -0.12621456f, -0.08748180f, 0.03113070f, -0.03869363f, 
    -0.10105190f, -0.01151513f, 0.14439860f, 0.01461307f, -0.15521272f, -0.36879504f, -0.03240878f, -0.27742392f, 
    0.06922365f, -0.09644614f, 0.12089410f, -0.18084720f, 0.04309032f, 0.14138019f, -0.02198065f, -0.04512522f, 
    0.08323919f, -0.00420509f, 0.05873363f, -0.07398023f, 0.02403607f, 0.02316579f, 0.03037986f, 0.01760789f, 
    -0.10110223f, -0.01057360f, -0.06525708f, -0.21602650f, -0.13084131f, 0.28336164f, -0.12960097f, -0.17549279f, 
    0.01991756f, -0.10890323f, 0.07151145f, -0.07068814f, -0.03183125f, -0.03697444f, -0.07217040f, -0.07581516f, 
    0.13740896f, 0.04509871f, 0.00464377f, 0.12779565f, -0.05684570f, 0.00961284f, 0.05633014f, 0.11698868f, 
    0.06766095f, 0.07571165f, -0.00698976f, 0.14733902f, 0.13674188f, 0.05182204f, -0.02727582f, 0.17162549f, 
    -0.06594226f, -0.00952541f, -0.00158494f, 0.04679926f, -0.18679570f, 0.04884323f, -0.10746396f, 0.00339786f, 
    0.14659700f, 0.05926318f, -0.03974084f, -0.02199561f, 0.00798649f, 0.03731624f, -0.15418959f, 0.16347475f, 
    0.00269258f, 0.11398184f, 0.05026764f, 0.01642263f, -0.13063782f, 0.22212191f, 0.01581078f, 0.08064789f, 
    0.01654921f, 0.07090579f, -0.06247328f, 0.01832286f, -0.07387032f, 0.07147778f, 0.04460265f, -0.12597694f, 
    -0.45409414f, -0.29230776f, 0.18838271f, -0.34376580f, -0.13776179f, -0.17620392f, -0.05824165f, -0.01377507f, 
    0.03100038f, -0.03757323f, -0.05712206f, -0.05812480f, 0.18759061f, -0.37460312f, 0.10385114f, -0.25428075f, 
    0.10968964f, 0.06230662f, 0.08209983f, 0.03422859f, -0.02392317f, 0.12562400f, 0.04864373f, 0.04970499f, 
    -0.23561697f, -0.06528118f, -0.07181583f, 0.18871330f, -0.09252410f, 0.09327103f, 0.09925421f, 0.14623147f, 
    -0.11530264f, -0.10810152f, -0.04686924f, 0.02012362f, -0.13402231f, -0.33787075f, -0.07747284f, 0.00960155f, 
    0.04978401f, -0.04425355f, 0.17065234f, 0.11589265f, -0.16481154f, 0.04374230f, 0.00690917f, -0.02185553f, 
    0.20256343f, 0.14445826f, 0.04749491f, -0.17243074f, -0.06011095f, 0.01128625f, -0.09676168f, 0.02637615f, 
    -0.08755806f, 0.09177949f, -0.07674105f, -0.19713977f, -0.46400893f, 0.24492639f, -0.05069841f, 0.12122752f, 
    -0.01171608f, -0.03894621f, 0.09949997f, 0.02609183f, -0.13235793f, 0.05598623f, -0.15710703f, -0.09788685f, 
    -0.32054335f, -0.03108037f, -0.16905831f, 0.25597414f, 0.00210315f, 0.14842401f, 0.00219001f, 0.12031467f, 
    -0.09431060f, 0.10159568f, 0.10537905f, 0.12008449f, -0.05185477f, 0.04004617f, -0.19272813f, -0.15795048f, 
    -0.03415014f, -0.00827729f, -0.02742870f, 0.14318430f, -0.00007256f, 0.14985645f, 0.16161518f, -0.12911962f, 
    -0.17108336f, 0.04902291f, -0.03055310f, -0.18324232f, -0.00916430f, 0.18868431f, 0.02772890f, -0.08773975f, 
    -0.06074276f, -0.00617532f, -0.13068753f, 0.08726656f, -0.12009455f, -0.13769600f, -0.17230664f, 0.19977845f, 
    0.18561023f, 0.04938380f, 0.00587864f, -0.03911727f, 0.09488339f, 0.18338430f, 0.04646302f, 0.03137711f, 
    -0.11849205f, -0.14669733f, -0.17898943f, 0.21655555f, -0.10613322f, 0.23448810f, -0.12734134f, -0.17899492f, 
    -0.01932769f, 0.04008738f, -0.05315556f, -0.09211828f, 0.11897044f, -0.20656976f, 0.25541535f, -0.03821236f, 
    -0.23256150f, -0.13264495f, -0.17342687f, -0.23100759f, 0.02356552f, -0.06126548f, 0.01430942f, -0.02037003f, 
    0.32441950f, 0.04131407f, 0.19159038f, -0.11877657f, -0.06035004f, 0.04913700f, -0.02777573f, -0.00585659f, 
    0.07104252f, 0.01567104f, 0.10260690f, -0.01405888f, -0.28917393f, -0.15835863f, -0.00795151f, -0.07231227f, 
    -0.40860546f, 0.04212328f, -0.23979233f, -0.12007400f, 0.04541874f, 0.00509845f, 0.05226890f, -0.06588650f, 
    0.05513781f, -0.17733781f, 0.16614337f, 0.31381792f, -0.02328487f, 0.12735577f, -0.06116130f, 0.11130245f, 
    -0.11540297f, -0.07526898f, 0.19717292f, 0.10234960f, 0.20728409f, -0.20378290f, 0.33553112f, -0.02837927f, 
    0.03088115f, -0.00407203f, -0.00297881f, 0.03809094f, 0.09386051f, 0.05465804f, 0.18157749f, 0.05454973f, 
    -0.11073657f, 0.11293483f, -0.09778527f, 0.13313051f, 0.08230940f, -0.03058584f, 0.12206560f, -0.03351795f, 
    -0.02278348f, -0.01611733f, 0.04223454f, 0.19702511f, 0.26640585f, 0.13575631f, -0.08476509f, 0.19429396f, 
    -0.11311954f, -0.08767488f, 0.00817080f, 0.07804993f, -0.02439905f, 0.07988735f, -0.06384280f, -0.08350986f, 
    0.69124001f, 0.33069465f, 0.47472659f, -0.14036074f, 0.03534589f, -0.01263160f, -0.08345511f, -0.04624344f, 
    -0.13833773f, 0.04198599f, -0.02079074f, 0.10537621f, -0.25639254f, 0.12223138f, 0.11920055f, -0.00994630f, 
    -0.04601495f, 0.10288870f, 0.07658394f, -0.09749727f, -0.10285088f, 0.01546812f, 0.17420004f, 0.14501494f, 
    0.14386052f, -0.19040923f, 0.15085986f, -0.29691449f, -0.12171961f, -0.16384193f, -0.19182989f, 0.03209481f, 
    0.00344536f, -0.01763496f, -0.12642713f, -0.11639579f, 0.04953394f, -0.50043744f, 0.21247759f, 0.14412954f, 
    0.05337546f, -0.06352188f, 0.00558789f, 0.04582249f, 0.04308004f, -0.01709414f, 0.03794328f, 0.01363668f, 
    0.12618981f, 0.10056715f, 0.13799775f, 0.18775912f, -0.05155110f, -0.00345682f, -0.13638774f, -0.03270319f, 
    0.05273198f, -0.14476208f, -0.03370919f, -0.12818167f, 0.21339755f, -0.43881074f, 0.34828669f, -0.07578961f, 
    0.09180842f, 0.07764146f, -0.03157675f, 0.00351205f, -0.06036697f, -0.02439251f, 0.08948839f, -0.06024001f, 
    -0.40564397f, 0.27790636f, -0.32976478f, 0.26859924f, 0.08639932f, -0.05277386f, 0.10767208f, 0.02056444f, 
    -0.07858852f, 0.03293169f, -0.02536994f, -0.04448702f, 0.14746431f, 0.00619484f, 0.16903242f, -0.05796112f, 
    -0.01333598f, -0.08003114f, -0.03101340f, 0.06120647f, -0.09799886f, 0.02433584f, 0.00720330f, -0.18076381f, 
    0.10221782f, -0.08707077f, -0.08542506f, -0.21784070f, 0.11031578f, -0.03745215f, 0.17507274f, -0.06230092f, 
    0.03631060f, 0.08279595f, -0.04521099f, 0.06428701f, 0.02132139f, 0.15537527f, -0.04589133f, -0.07335428f, 
    0.01477603f, -0.02321477f, -0.04646953f, -0.06281066f, 0.20201772f, 0.12782849f, 0.13127258f, 0.12879473f, 
    -0.36127540f, -0.04076193f, -0.19746506f, 0.26629180f, -0.08446455f, 0.01649159f, -0.02010637f, 0.10951603f, 
    -0.19357955f, -0.08140762f, 0.12770410f, 0.01440571f, -0.25775942f, 0.02620255f, 0.18148808f, 0.39426789f, 
    -0.04313510f, -0.09466039f, 0.26273566f, 0.13273317f, -0.04103457f, 0.03856166f, 0.02522453f, 0.08063813f, 
    -0.09052760f, 0.20998427f, -0.06610800f, 0.20398444f, -0.27889502f, -0.09111279f, 0.09381405f, -0.06692077f, 
    -0.02053031f, 0.07044912f, -0.00360914f, -0.07283818f, 0.13506033f, -0.16119139f, 0.14981760f, -0.17072536f, 
    -0.02705704f, -0.00541777f, 0.08435777f, 0.11331657f, -0.00277356f, -0.03856666f, 0.04304556f, 0.14771204f, 
    -0.11012552f, -0.42401204f, 0.03922657f, 0.14463589f, -0.17594038f, 0.01048485f, -0.04404331f, -0.16530791f, 
    0.03535041f, -0.01838699f, 0.07105695f, 0.02382340f, -0.03390345f, -0.09160900f, 0.04235427f, 0.06821758f, 
    -0.10093187f, -0.12569059f, -0.05975980f, -0.18372287f, -0.05300038f, 0.02353097f, -0.05935180f, -0.17596838f, 
    -0.29799443f, -0.03250401f, -0.03667531f, 0.19802734f, 0.26625040f, 0.10473856f, -0.09156922f, 0.02910459f, 
    -0.04418141f, -0.08888112f, 0.10792951f, -0.05845329f, -0.53684253f, 0.17554109f, -0.12662628f, 0.26776981f, 
    0.23116291f, -0.08704863f, 0.09874424f, -0.07264113f, -0.10677236f, -0.16723655f, -0.09544071f, 0.01011183f, 
    0.38121161f, 0.03749075f, 0.18075058f, -0.17769720f, -0.11393487f, -0.02462819f, -0.28269452f, 0.00479066f, 
    -0.04928721f, 0.07612146f, 0.06064891f, 0.01920541f, 0.08703203f, 0.10424396f, -0.48083776f, -0.04363367f, 
    -0.11275840f, -0.18175262f, 0.10847896f, 0.00111458f, 0.10440066f, 0.12511173f, -0.01819409f, 0.06187184f, 
    -0.17246722f, -0.09858079f, 0.00669989f, 0.33712783f, 0.05252198f, -0.06309910f, -0.02275039f, 0.00951947f, 
    -0.01156227f, 0.10127306f, -0.02928876f, 0.16876407f, -0.26067871f, -0.10426298f, -0.29848137f, 0.13626824f, 
    0.00760896f, -0.14743973f, 0.07022243f, -0.06538700f, -0.02665344f, 0.11939392f, -0.05931368f, -0.14203559f, 
    -0.31927836f, -0.35200098f, -0.50539136f, 0.24500145f, -0.02625964f, -0.15431672f, 0.00950163f, -0.14850871f, 
    -0.01993047f, 0.04484172f, 0.08190753f, 0.05800919f, 0.24514003f, 0.22076230f, -0.02720125f, -0.35342628f, 
    0.03965825f, -0.06839580f, 0.03051847f, 0.02592225f, -0.04978529f, 0.04924398f, -0.00956418f, -0.07166929f, 
    0.13671683f, 0.06386609f, 0.11504103f, 0.09965394f, 0.05655441f, 0.00080345f, 0.06012559f, 0.06267312f, 
    0.05509800f, -0.17835777f, -0.03312852f, -0.22278418f, -0.18788213f, 0.20271248f, -0.03205029f, -0.15382412f, 
    -0.07646213f, 0.15248027f, 0.13981280f, -0.00312989f, -0.17357804f, -0.08049788f, -0.06965638f, -0.11798659f, 
    -0.45992371f, 0.05512498f, 0.23547386f, 0.49901348f, 0.11147977f, -0.04409744f, 0.17109825f, -0.26672506f, 
    0.08435650f, -0.00724301f, -0.18902133f, 0.13426758f, 0.10329148f, -0.14977644f, 0.07137192f, -0.09865573f, 
    0.06669342f, 0.00824580f, -0.03131443f, 0.02791920f, 0.15628988f, 0.09904049f, 0.01261627f, 0.09025058f, 
    -0.00272450f, -0.18567759f, -0.02478699f, 0.00110854f, -0.04774281f, 0.16162318f, -0.00085791f, 0.06939918f, 
    0.03201832f, 0.02682356f, 0.12757701f, 0.00884831f, 0.06830341f, 0.02168720f, -0.01813130f, -0.17474754f, 
    0.05664925f, -0.00393213f, 0.11086394f, -0.07640921f, 0.00836363f, 0.01090137f, 0.06505780f, 0.14433220f, 
    -0.43885258f, -0.21825962f, -0.40289876f, 0.18807343f, 0.21847978f, 0.01902148f, 0.01639552f, -0.03831912f, 
    -0.07061926f, -0.20827551f, -0.04505301f, -0.13264827f, -0.11729112f, 0.06050809f, 0.25900742f, 0.16743401f, 
    -0.00430521f, 0.10240176f, 0.08529914f, -0.05668976f, -0.12978855f, -0.05658991f, 0.17387748f, -0.01756403f, 
    -0.45021364f, -0.27965248f, -0.26619044f, 0.04669842f, -0.12122721f, 0.01578133f, -0.03438306f, -0.08815429f, 
    -0.00400395f, 0.02925972f, 0.01716791f, -0.01750098f, -0.17062521f, -0.22767740f, -0.14914341f, 0.06718860f, 
    0.19412339f, -0.01076704f, 0.24603465f, -0.05599058f, -0.00861568f, 0.07760140f, 0.16583546f, 0.11357729f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15600395f, 0.08898873f, 0.09719847f, -0.09796564f, -0.05001234f, 0.06296456f, 0.01016010f, -0.12043732f, 
    0.07502806f, 0.01946173f, 0.03307531f, 0.02402961f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
