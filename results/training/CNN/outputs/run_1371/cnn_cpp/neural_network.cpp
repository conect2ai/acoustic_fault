#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.35585234f, -0.90804976f, 0.57877374f, -0.09599160f, -0.41076088f, -0.16838343f, -0.45421976f, -0.31645593f, 
    -0.43760866f, -0.74660635f, 0.53642482f, 0.33917031f, -0.44097304f, 0.30974665f, 0.38341901f, -0.24021088f, 
    0.20506223f, -0.24919970f, -0.01498538f, 0.52007312f, 0.65689391f, -0.75996381f, -0.33844805f, -0.32038486f, 
    0.39003453f, 0.24664152f, 0.12774372f, 0.02571557f, -0.68835312f, -0.69153827f, -0.09141787f, 0.87354845f, 
    0.09820067f, 0.13312224f, 0.25030297f, 0.22943883f, -0.98357707f, -1.04267728f, 0.01511681f, 0.52995664f, 
    0.31943020f, -0.39139390f, 0.38385978f, -0.48962593f, 0.10873877f, 0.56782442f, -0.46503186f, -0.64989233f, 
    0.33757174f, 0.44340801f, 0.48318574f, -0.31017688f, -0.32470089f, -0.03397213f, 0.27567473f, 0.41113606f, 
    0.24181069f, 0.22599965f, -0.07784344f, -0.21852717f, 0.10335168f, -0.17569530f, 0.06150710f, -1.24469101f, 
    0.75521952f, 0.72992420f, -0.01674835f, -0.12554258f, 0.13301536f, 0.04513692f, -0.29727474f, -0.43132758f, 
    0.87546295f, -0.13808954f, 0.00609999f, -0.35742354f, 0.11790803f, 0.13261653f, -0.18090063f, -0.12472615f, 
    0.13834658f, 0.23107989f, 0.02123565f, 0.18904312f, -0.49314058f, 0.54528844f, -0.44767708f, -0.26774013f, 
    -0.13749625f, 0.06784627f, -0.67246515f, -0.57349187f, -0.69598907f, -0.07956976f, -0.42170671f, -0.53995812f, 
    -0.43219355f, -0.64102286f, -0.45074442f, -0.82518226f, 0.70794779f, 0.04143622f, -0.14934140f, -0.16054167f, 
    0.48105958f, -0.40397277f, 0.29578274f, 0.05740331f, 0.68812329f, -0.86647034f, -0.46116778f, -0.22961231f, 
    0.77832198f, 0.06570006f, 0.30640358f, -0.56933671f, -0.63493901f, 0.11249923f, 0.25229993f, -0.20417421f, 
    -0.12621559f, -0.14345704f, 0.48350513f, 0.15355478f, -0.31926146f, 0.13748050f, 0.19204009f, 0.19419152f, 
    -0.20957744f, -0.36102933f, -0.47675058f, 0.39643463f, 0.25202563f, 0.21177602f, 0.12239722f, -0.31331399f, 
    -0.02881249f, 0.49289048f, -0.26302111f, -0.09789854f, 0.27798384f, -0.52820307f, -0.10391437f, 0.55971766f, 
    0.70930719f, -0.60698426f, -0.82410789f, 0.49983099f, 0.31215018f, -0.13636380f, -0.06577636f, 0.50191015f, 
    -0.27713767f, 0.64791948f, -0.29587758f, -0.66323489f, -0.07154302f, 0.40780777f, 0.71887815f, -0.49790704f, 
    -0.25428692f, 0.03051501f, -1.00987089f, 0.27560356f, -0.54814935f, -0.38655272f, -0.47820690f, -0.66150755f, 
    0.16176523f, -0.09846263f, 0.38946250f, 0.00365640f, 0.23484540f, -0.32500824f, 0.33799273f, 0.20017782f, 
    0.06061367f, -0.37724784f, -0.26972580f, 0.40656579f, 0.59014797f, 0.06084129f, -0.39185303f, 0.25520054f, 
    0.36368603f, 0.27385387f, 0.17188878f, 0.26609790f, 0.06959813f, 0.87066448f, -0.40188619f, 0.06413072f, 
    -0.58849138f, -0.59720427f, -0.63107628f, -0.32677034f, 0.21890609f, 0.38853413f, 0.27018678f, -0.68960094f, 
    0.58849472f, 0.08577434f, 0.05306042f, -0.51737678f, 0.15205260f, 0.23368706f, 0.12752941f, 0.41996777f, 
    -0.14812192f, -0.48882544f, -0.27690136f, 0.02864199f, 0.05855339f, 0.47056407f, 0.12001823f, -0.05193634f, 
    -0.85624844f, -0.65980428f, 0.17504446f, 0.16988297f, -0.23752941f, 0.49355453f, 0.14543259f, -0.00995939f, 
    0.29818410f, 0.69607639f, -0.57024640f, 0.05067254f, -0.06207141f, 0.39432997f, -0.45834908f, 0.15811770f, 
    -0.04426280f, -0.13373198f, 0.32152143f, 0.32286015f, -0.03215251f, 0.02912334f, 0.14585361f, -0.10588186f, 
    -0.36295602f, 0.26369745f, 0.13713969f, -0.48780891f, -0.91606069f, 0.12674133f, -1.07983959f, -0.93248510f, 
    -0.28724018f, 0.04086623f, -0.30369985f, 0.31586072f, 0.50119084f, -0.74854124f, 0.29368559f, -0.18903986f, 
    -0.54353946f, -0.48236442f, 0.05659143f, 0.06402733f, 0.50090051f, 0.36277926f, 0.69776189f, 0.46372348f, 
    -0.69568765f, -0.67527628f, -0.40162334f, 0.17453657f, 0.03720612f, 0.24915338f, 0.45695475f, 0.12486379f, 
    0.12364533f, -0.37237626f, -0.63270116f, -0.34744465f, -0.48062122f, -0.42506519f, -0.27873415f, -0.67093325f, 
    0.56169432f, 0.12249576f, 0.16429126f, 0.48771599f, 0.03327542f, -0.11546338f, -0.26268619f, -0.20579454f, 
    -0.10269945f, -0.58543944f, -0.07382261f, -0.12034026f, 0.07518268f, -0.04384486f, 0.21128690f, 0.36512572f, 
    0.17219584f, -0.70841599f, -0.73826391f, -0.54472911f, -0.39071679f, -0.30741194f, 0.07218614f, 0.18210429f, 
    -0.25782675f, -0.34774458f, 0.56347597f, -0.49860612f, -0.30082399f, 0.81129545f, -0.24736495f, -0.04975178f, 
    -0.46834153f, 0.07633486f, 0.11943862f, 0.75940794f, 0.42827672f, -0.42890313f, 0.28032988f, -0.47530812f, 
    -0.14009885f, 0.07484841f, -0.05380030f, -0.14060374f, -0.70197457f, 0.09913973f, -0.52507383f, 0.21984226f, 
    0.18777660f, -0.37351862f, 0.39318168f, 0.48034459f, 0.11441016f, 0.42573562f, 0.63190645f, 0.37357682f, 
    -0.18421949f, -0.16996840f, -0.29328346f, -0.18454061f, -0.48229662f, 0.02900157f, -0.48788321f, -1.18587470f, 
    0.04742609f, 0.59050387f, 0.74941009f, 0.15326954f, 0.04077331f, -0.08500346f, -0.33332458f, 0.72779274f, 
    -0.24300918f, -0.54494077f, 0.22805995f, 0.11873601f, -0.17661655f, 0.11033212f, 0.22713475f, -0.16884597f, 
    1.04270864f, -0.78962243f, 0.06428778f, 0.60268664f, 0.37107062f, -0.49279365f, -0.33362040f, -0.00257601f, 
    -0.23010823f, 0.27589458f, 0.43743142f, 0.44674262f, 0.05245798f, -0.22026671f, 0.37977087f, -0.24346556f, 
    0.02595822f, -0.24629757f, -0.71776664f, -0.91375965f, 0.61305994f, 0.69748074f, -0.05978442f, -0.45490935f, 
    0.08904868f, -0.21229932f, -0.69535959f, -0.11932661f, 0.76789719f, -0.12701395f, -0.37312311f, -0.01837617f, 
    0.29338554f, 0.13501245f, 0.24101566f, -0.24070928f, 0.25626382f, 0.44593197f, 0.08852648f, -0.41345301f, 
    -0.85232383f, -0.81239271f, -0.31117314f, -0.33654389f, -0.40890080f, -0.32201320f, -0.02194985f, -0.33922502f, 
    0.45321792f, 0.16007152f, -0.08488069f, 0.22916187f, -0.07287461f, 0.01603675f, -0.74538213f, -0.27934188f, 
    0.01524366f, -0.59430552f, -0.50834167f, 0.63731122f, -0.29996958f, 0.20744002f, 0.32531968f, 0.88574898f, 
    -0.16321407f, -0.52177995f, 0.55116868f, 0.15186056f, 0.11920258f, -0.41077298f, 0.49217010f, -0.46073097f, 
    -0.65023983f, -0.58650148f, 0.56347418f, 0.31216684f, 0.42401478f, 0.14103943f, -0.38534310f, -0.22543545f, 
    0.44762117f, -1.08850646f, 0.75882041f, -0.42252842f, 0.67527342f, 0.65692365f, -0.66013008f, -0.00821447f, 
    -0.01521923f, -0.03879463f, -0.94781822f, -0.89110231f, -0.72389877f, 0.26459226f, 0.26722646f, 0.34798884f, 
    -0.41302535f, -0.12310675f, -0.11909430f, -0.60764384f, -0.14796729f, 0.55027932f, 0.44244215f, -0.18105376f, 
    -0.35691774f, 0.15899184f, 0.01757076f, 0.21170704f, -0.60189909f, 0.08762479f, -0.19403745f, -0.24152085f, 
    -0.48275864f, 0.12997092f, 0.52038008f, 0.26927683f, 0.38365692f, 0.58849108f, 0.48847586f, -0.57340866f, 
    0.27712458f, -0.56240273f, 0.46437344f, -0.28588000f, -0.24681339f, -0.10984606f, 0.65680569f, 0.67572576f, 
    -0.53015625f, 0.07254704f, -0.32848710f, -0.05797805f, -0.12278901f, -0.24042180f, 0.47239321f, -0.06549459f, 
    0.44526216f, -0.35814646f, -0.35493883f, 0.49286658f, 0.50673085f, -0.46642640f, 0.25123093f, -0.38108870f, 
    -1.35781610f, 0.47059137f, -0.34006003f, -0.36819902f, 0.48594594f, 0.76431787f, 0.10907935f, 0.21726304f, 
    -0.16703954f, -0.73226148f, -0.12703572f, -0.46605799f, -0.54856515f, -0.55976129f, -0.64101857f, -0.02061369f, 
    -0.55647296f, -0.68227208f, 0.13328525f, -0.32733983f, 0.58854586f, 0.21860398f, -0.26752692f, -0.64205009f, 
    0.60137123f, -0.54561669f, 0.15432201f, -0.57646662f, 0.24445003f, -0.41139886f, -0.15722238f, -0.28036827f, 
    -0.85083425f, -0.28059372f, 0.59208280f, 0.07730757f, -0.09197081f, 0.47655761f, -0.18339141f, 0.21693783f, 
    0.32276988f, -0.06004896f, 0.23134126f, 0.52223426f, -0.50131536f, 0.17426851f, 0.23650749f, 0.15153638f, 
    -0.52537733f, 0.45553532f, 0.16657497f, 0.02043187f, 0.20899248f, 0.22613561f, 0.47166327f, -0.08120141f, 
    -0.00080739f, 0.11855951f, -0.38123173f, 0.22237696f, 0.13431783f, 0.34968612f, -0.45870101f, 0.80961615f, 
    -0.54815561f, -0.24000192f, -0.50052303f, -0.19566122f, 0.65805203f, 0.03273464f, -0.23750037f, 0.07471482f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.05607271f, 0.39460278f, 0.10181728f, 0.14546457f, 0.27425539f, 0.14663006f, -0.04783821f, 0.07566173f, 
    0.08564608f, 0.00792511f, -0.33599544f, 0.20256704f, -0.03409724f, 0.31391290f, 0.03922197f, 0.22924604f, 
    0.20015156f, 0.14093538f, 0.02196309f, 0.19034834f, 0.31921291f, 0.11012881f, -0.07487962f, -0.05272248f, 
    0.05547779f, 0.17519157f, 0.27647284f, -0.00706531f, 0.10532461f, 0.11064579f, -0.16058683f, 0.22021133f, 
    0.20124559f, 0.04553512f, 0.05065715f, 0.24527091f, 0.12794045f, 0.04400602f, 0.02577553f, 0.21219662f, 
    0.13114442f, -0.25199348f, 0.20136437f, 0.23868683f, -0.04117985f, 0.18663032f, 0.22232537f, 0.02413349f, 
    0.04439632f, 0.15081945f, -0.03386788f, -0.02023892f, 0.09652076f, 0.21286163f, 0.15781517f, 0.18315099f, 
    0.20420653f, -0.12153451f, 0.10274180f, 0.15206462f, 0.09752095f, 0.20864102f, 0.04410471f, 0.13030402f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.20910788f, 0.14493136f, 0.20309770f, -0.54183269f, 0.26117694f, -0.03560406f, -0.16686712f, 0.10005134f, 
    -0.12545995f, 0.06977475f, -0.01508251f, -0.02803707f, -0.00278838f, 0.04542870f, -0.00822595f, 0.01676222f, 
    -0.03546171f, 0.13541353f, 0.02264244f, -0.00793057f, -0.46873346f, -0.27352035f, 0.21921244f, -0.02207433f, 
    -0.07184982f, -0.04650078f, -0.01704857f, 0.00345584f, 0.04071769f, -0.02610229f, -0.05843171f, 0.01046595f, 
    0.01017569f, -0.02790452f, -0.06305934f, -0.06509270f, -0.00696646f, -0.02318979f, -0.08070806f, 0.06431037f, 
    0.01536369f, 0.06473942f, 0.12518726f, -0.11125285f, -0.01836937f, -0.13800909f, 0.06491707f, -0.14181630f, 
    0.00295380f, -0.01257340f, -0.00440298f, 0.02333825f, 0.01017257f, 0.01865554f, 0.03248503f, 0.01055198f, 
    0.02952918f, 0.02433261f, -0.10801580f, -0.12490622f, 0.19976160f, 0.22386843f, -0.18434444f, 0.05880687f, 
    0.05339251f, 0.11347744f, 0.06069762f, 0.08507113f, -0.02869789f, -0.03290208f, -0.04948486f, 0.05264542f, 
    -0.04454171f, -0.00080747f, 0.04407301f, 0.03077676f, 0.04275827f, -0.02432893f, -0.05577715f, -0.02675808f, 
    0.34432438f, 0.13716611f, -0.09927952f, -0.29070574f, -0.05222583f, -0.00001884f, 0.12363697f, 0.06096788f, 
    0.07350646f, -0.05116407f, 0.02517868f, -0.02330736f, -0.05374532f, 0.00428759f, 0.04441768f, -0.01846272f, 
    0.04300455f, 0.01167633f, 0.01268406f, -0.03417147f, 0.13775675f, -0.28359848f, -0.38265425f, 0.09755904f, 
    -0.07400727f, 0.01385440f, 0.03593168f, 0.02295990f, 0.01529534f, 0.04956789f, 0.02668402f, 0.02606892f, 
    -0.10715912f, 0.01929372f, -0.03430483f, 0.00709435f, 0.05449606f, -0.01936367f, 0.02893844f, -0.03953981f, 
    -0.12931444f, -0.07606916f, -0.09339026f, -0.00501921f, 0.01986904f, 0.06606540f, -0.01424181f, -0.01090566f, 
    0.02746477f, -0.00266945f, -0.00671628f, 0.01407963f, 0.02303846f, 0.07798112f, 0.05766607f, -0.04649657f, 
    0.07394192f, -0.03071103f, 0.02125948f, -0.00273345f, -0.47259247f, 0.18922178f, 0.36189434f, 0.02533313f, 
    0.32522982f, -0.03514523f, -0.04017874f, 0.01356039f, 0.11082826f, -0.02587685f, 0.02435732f, 0.03700914f, 
    -0.00160599f, 0.00960295f, 0.05759731f, 0.12486120f, 0.10143890f, 0.06766744f, -0.11991136f, 0.19171822f, 
    -0.55813712f, -0.22497648f, 0.19311100f, -0.12463021f, -0.13826513f, 0.03504107f, -0.00619176f, -0.02611465f, 
    0.01687011f, 0.00186660f, 0.02152318f, 0.00817125f, -0.01034419f, -0.01054739f, 0.05344358f, -0.00402235f, 
    0.11570149f, -0.03637808f, -0.03715895f, -0.02579304f, -0.05991476f, -0.03917659f, 0.17613804f, 0.09862198f, 
    -0.09909633f, -0.04196758f, -0.11786310f, -0.05186658f, -0.09031643f, 0.04301329f, -0.02396243f, 0.03240921f, 
    -0.00963188f, 0.02482309f, 0.02612852f, -0.07924299f, -0.06327271f, -0.05083448f, -0.04203069f, 0.07467803f, 
    0.32005823f, 0.19116609f, 0.09756786f, -0.13183051f, -0.07469814f, 0.12953611f, 0.20796113f, 0.20634572f, 
    -0.00288879f, 0.09790557f, -0.03022203f, 0.00977011f, 0.01107339f, -0.10060032f, -0.01990749f, -0.01998414f, 
    -0.17611337f, -0.04463071f, -0.00418563f, 0.08101656f, -0.51450425f, -0.17578417f, 0.15857092f, 0.05381011f, 
    0.02769835f, -0.13881440f, -0.10655743f, 0.07959773f, 0.00106477f, -0.07279149f, -0.11531933f, 0.01040816f, 
    0.06033240f, -0.09170131f, -0.07868481f, -0.12681498f, -0.05235675f, -0.03120303f, -0.17698510f, -0.04385450f, 
    0.30542272f, -0.15919015f, -0.16307817f, 0.01119212f, -0.11944778f, -0.00316888f, -0.10374983f, 0.03049844f, 
    -0.12740996f, 0.06301603f, 0.02156082f, 0.07560191f, -0.18540393f, 0.17392966f, 0.12603748f, -0.07682598f, 
    0.02340177f, -0.05315138f, 0.02118754f, 0.14111170f, -0.22789359f, -0.22912370f, -0.07494550f, -0.01525352f, 
    0.01811798f, 0.03057764f, -0.03892604f, 0.02440838f, 0.00429318f, -0.01994332f, -0.05982144f, -0.08645569f, 
    -0.10923335f, -0.09211058f, -0.03873191f, -0.04088659f, -0.06366825f, -0.03967986f, 0.05239940f, -0.10582376f, 
    0.04330324f, 0.03274189f, 0.04256621f, -0.01678557f, -0.04053748f, -0.06025185f, -0.00517992f, 0.00555099f, 
    0.02375349f, -0.00372622f, -0.05616860f, 0.09074315f, -0.08371104f, -0.01401922f, 0.00335527f, -0.02230972f, 
    -0.08279224f, 0.00804687f, -0.04490509f, -0.07060216f, -0.48850337f, -0.14193417f, 0.18034278f, 0.00805841f, 
    -0.02667003f, 0.02074623f, -0.10079093f, -0.11792896f, 0.03791810f, -0.08031385f, 0.08163354f, -0.01817458f, 
    -0.01020360f, -0.01070285f, -0.06333491f, -0.22921328f, -0.00613911f, -0.10549971f, 0.02750724f, -0.24168944f, 
    -0.01392346f, -0.06409494f, -0.44743848f, 0.09099499f, 0.05999343f, 0.06668836f, -0.03816184f, 0.02365118f, 
    -0.06294437f, 0.05353169f, -0.05150011f, 0.01987577f, -0.05240306f, -0.06348170f, -0.08751550f, -0.00475579f, 
    0.01808987f, -0.03527791f, -0.02502466f, 0.05460001f, 0.01804622f, -0.01713530f, -0.06816416f, 0.11487035f, 
    -0.05458035f, 0.04581929f, 0.07290399f, -0.00612078f, 0.03348411f, 0.00988826f, 0.05990968f, 0.01383579f, 
    -0.09626726f, 0.04127264f, -0.02154173f, 0.04057761f, 0.04106481f, 0.01018883f, -0.00219229f, -0.05666338f, 
    0.27306682f, 0.25012732f, -0.02378969f, -0.25766778f, -0.12506005f, 0.07827535f, 0.10475757f, 0.04681465f, 
    0.08124442f, 0.06326844f, 0.01165414f, -0.04023563f, 0.00329271f, 0.02131199f, -0.00203249f, -0.03979605f, 
    -0.02600830f, -0.03222668f, -0.09885196f, -0.00080836f, -0.22218503f, -0.16314150f, -0.04182504f, 0.06750160f, 
    0.04537304f, 0.04622398f, -0.00188571f, -0.03389792f, -0.01148144f, 0.00804069f, -0.02057936f, -0.00000559f, 
    -0.02176864f, 0.10052752f, 0.00476283f, 0.02322519f, -0.02206379f, -0.05675391f, 0.00727526f, -0.06571625f, 
    -0.03284092f, -0.02024080f, -0.00342090f, 0.06729612f, 0.01259996f, 0.02349664f, -0.02827984f, -0.00291959f, 
    0.01910968f, 0.02161959f, -0.15880209f, -0.17185174f, -0.22984043f, -0.22521190f, -0.17832872f, -0.01647904f, 
    0.02343098f, -0.01351755f, 0.00193151f, -0.00785844f, -0.02859031f, 0.14712754f, -0.05154728f, -0.21835445f, 
    -0.14825422f, -0.08498403f, 0.04177894f, -0.07542449f, -0.11682634f, -0.03600512f, -0.00911321f, 0.03443856f, 
    -0.00699849f, -0.00254730f, -0.01623426f, -0.03516478f, -0.02437355f, -0.01029134f, -0.06720351f, 0.06247861f, 
    0.08830757f, 0.02816107f, -0.01245833f, -0.04954395f, 0.02988073f, -0.09269932f, 0.04371284f, 0.05916138f, 
    -0.05533021f, 0.03994799f, 0.04407819f, 0.02845284f, 0.01339788f, 0.00717630f, -0.04501999f, -0.05668807f, 
    0.02580726f, -0.09028243f, -0.07811379f, -0.03757785f, 0.11607382f, 0.10306852f, -0.06106870f, -0.02292133f, 
    -0.03306260f, 0.02863494f, -0.04257684f, -0.00397520f, 0.07493516f, 0.00676483f, -0.03884082f, 0.09730555f, 
    0.00374030f, 0.00198529f, 0.02335092f, -0.00557532f, -0.05746050f, 0.00652454f, 0.03291193f, 0.00189382f, 
    0.24337597f, 0.19714460f, 0.21471494f, -0.10413077f, 0.09741917f, 0.02749700f, 0.08223012f, 0.14513972f, 
    0.05015559f, -0.15715262f, -0.03776855f, -0.10803391f, -0.05600899f, -0.03168938f, 0.02026426f, 0.01352666f, 
    -0.01044385f, 0.01711525f, 0.00738352f, -0.01919450f, -0.04135786f, -0.13223037f, -0.18995070f, -0.12569144f, 
    -0.02962186f, -0.18595897f, -0.10711277f, -0.00599370f, -0.18875928f, -0.00487310f, -0.12063251f, 0.05328604f, 
    0.03466556f, -0.01790854f, -0.09407592f, -0.13047801f, -0.07410947f, -0.09958118f, -0.22240952f, 0.12118603f, 
    -0.18001387f, -0.15390730f, -0.05895913f, 0.03888142f, -0.05555245f, 0.01585277f, -0.00690036f, -0.01587064f, 
    0.00484055f, 0.02540310f, -0.03846570f, -0.01069435f, 0.00015500f, 0.01766445f, 0.03553409f, -0.11218794f, 
    -0.00913355f, -0.11635732f, 0.02123180f, -0.00982662f, 0.31637281f, 0.30871263f, 0.18409732f, -0.41082844f, 
    -0.04799592f, 0.09854478f, 0.10060499f, 0.11886756f, -0.04208124f, -0.03555203f, 0.00200777f, -0.05936226f, 
    0.00726544f, -0.05029285f, -0.07955959f, 0.00443124f, -0.05777433f, -0.01676958f, 0.11909632f, -0.14130488f, 
    0.19316921f, 0.21613452f, -0.00465558f, -0.20312898f, 0.01172585f, -0.08159506f, -0.00339449f, -0.08650931f, 
    -0.12492441f, -0.06121682f, 0.12723848f, 0.09872792f, -0.01562317f, 0.04180463f, -0.05627610f, -0.06134369f, 
    0.01066903f, -0.03594175f, -0.08488427f, -0.13345000f, 0.03495562f, 0.12493233f, 0.00923522f, -0.14761017f, 
    -0.08486773f, 0.05948053f, -0.03933186f, -0.15133055f, -0.00665402f, -0.09772725f, 0.04844407f, -0.01575049f, 
    -0.00036542f, 0.01381232f, 0.02717511f, 0.00270649f, 0.02756445f, 0.05917126f, -0.06715787f, -0.02703706f, 
    -0.06062653f, 0.32101583f, 0.18650509f, -0.11726681f, -0.12663166f, -0.09724564f, -0.18450390f, -0.18837573f, 
    -0.05933448f, -0.01606724f, 0.01552979f, -0.02524845f, -0.01538942f, 0.03234722f, 0.02481615f, 0.10284501f, 
    0.03176522f, 0.09748992f, 0.10800003f, 0.08771466f, -0.15673172f, -0.11637197f, 0.00869773f, -0.13925698f, 
    -0.01064820f, -0.00933018f, -0.04054713f, 0.04827454f, 0.07400505f, -0.00510066f, -0.02407552f, 0.08252419f, 
    -0.01265405f, 0.02948509f, 0.00261544f, -0.01267425f, -0.09536862f, 0.01881161f, -0.01626616f, 0.06498478f, 
    0.11998107f, 0.12977716f, 0.00671004f, -0.05425404f, 0.03018574f, 0.00441015f, 0.01775301f, 0.07836847f, 
    -0.05298171f, -0.04855368f, -0.05318380f, -0.03197616f, -0.04246235f, 0.02554281f, 0.02532382f, -0.03120974f, 
    -0.04913209f, -0.07076377f, -0.03205749f, 0.00004803f, 0.29657584f, 0.16947253f, 0.08691426f, -0.23206574f, 
    -0.07945962f, 0.17335609f, 0.15681732f, 0.12449124f, 0.01602610f, -0.01049786f, 0.00975801f, -0.04439792f, 
    -0.00218733f, -0.02313862f, 0.02662463f, 0.04583254f, -0.06824747f, -0.01394142f, -0.05085783f, -0.06939576f, 
    0.05221850f, -0.03645669f, -0.34822670f, 0.01029194f, -0.02430513f, -0.09322903f, -0.02434555f, 0.00717076f, 
    -0.09271520f, -0.00124540f, -0.06766029f, -0.02561907f, 0.10411946f, -0.02108125f, 0.05225079f, -0.10024185f, 
    0.08304066f, -0.10751183f, -0.06412860f, -0.02291476f, -0.56327981f, -0.19452707f, -0.44227710f, 0.36298233f, 
    -0.23975632f, -0.01169770f, 0.03554443f, -0.00138562f, 0.00575849f, 0.03552923f, -0.04013678f, 0.03974257f, 
    -0.03724365f, -0.00781142f, 0.02857838f, -0.05509588f, -0.01117333f, 0.00052220f, 0.03662726f, -0.09621197f, 
    0.15864615f, 0.14549549f, -0.03030107f, -0.02512361f, 0.04438728f, 0.03897599f, 0.05397094f, 0.08381978f, 
    -0.04795940f, -0.09256534f, -0.03453749f, -0.13594885f, -0.02491620f, -0.02095895f, 0.02835295f, -0.07374971f, 
    -0.01228774f, -0.06198968f, -0.00752726f, -0.01612834f, -0.45800322f, 0.00262847f, 0.07538702f, 0.23820081f, 
    0.09555966f, 0.06071093f, -0.00768592f, -0.02676294f, 0.02189264f, 0.00534070f, 0.01885391f, 0.00075169f, 
    0.00404413f, 0.07034781f, 0.02081012f, 0.11691742f, 0.09968495f, -0.05796314f, 0.07561168f, -0.03658295f, 
    0.36666676f, -0.16786601f, -0.52938068f, -0.02673558f, -0.00936156f, 0.10124920f, 0.00344260f, 0.14611536f, 
    -0.06095554f, -0.00132300f, -0.02278399f, 0.03172643f, -0.06017355f, 0.01770387f, -0.04669883f, -0.00186090f, 
    0.07234513f, 0.03844691f, 0.00661974f, 0.04391177f, -0.06200390f, -0.04486042f, -0.13852935f, 0.08979691f, 
    0.00561075f, 0.01254455f, -0.00492286f, -0.00026239f, 0.07486288f, 0.01603254f, -0.13882448f, -0.01681577f, 
    -0.19174543f, -0.10337562f, -0.07764349f, -0.05938532f, -0.03200343f, 0.01649329f, -0.05022577f, 0.02597234f, 
    0.02998963f, -0.51534015f, -0.05191417f, 0.10077630f, -0.05194711f, -0.02665676f, -0.03708959f, 0.05985616f, 
    -0.01850209f, 0.04573951f, 0.02689262f, 0.02118297f, 0.07113210f, 0.03310237f, 0.03424488f, -0.22421098f, 
    0.08722594f, 0.03863185f, -0.20490305f, 0.13260020f, -0.06117673f, -0.07055004f, -0.06645902f, -0.07799536f, 
    -0.01086932f, 0.02419214f, -0.01485645f, -0.00133696f, 0.01866006f, 0.06154230f, 0.02646502f, 0.04842193f, 
    0.04483113f, 0.02856380f, 0.03051195f, -0.03325669f, -0.11323582f, -0.02723559f, 0.01843441f, 0.02622965f, 
    0.42459300f, 0.12647313f, -0.04732243f, -0.38028014f, -0.01434511f, 0.00541004f, -0.02079091f, 0.07303479f, 
    -0.02288380f, 0.12064455f, 0.04332056f, 0.04643917f, -0.14461294f, -0.06579341f, -0.04084273f, -0.00885202f, 
    0.00723605f, 0.07494210f, -0.13469128f, 0.02566478f, -0.16567703f, -0.03645155f, 0.03775130f, 0.06197447f, 
    -0.13513760f, -0.02391313f, -0.01735524f, -0.04826461f, 0.00814975f, 0.05466618f, 0.03596497f, -0.00002460f, 
    -0.02523355f, 0.00107239f, 0.03220278f, -0.11956142f, -0.04250240f, -0.06466372f, -0.06034758f, 0.00993551f, 
    -0.08838149f, 0.23793352f, 0.03804930f, -0.14089544f, -0.06317192f, -0.11965126f, -0.04502825f, -0.09359273f, 
    -0.02154578f, 0.00834582f, 0.03065124f, -0.07350284f, 0.01394643f, 0.03189914f, 0.01911935f, -0.04806711f, 
    -0.03070282f, 0.12908025f, 0.04211970f, 0.13503960f, 0.01291151f, -0.05375945f, -0.23295803f, 0.03266437f, 
    0.02885724f, 0.00967176f, 0.06152656f, 0.00976791f, -0.01449918f, -0.01093234f, -0.08690443f, -0.08783127f, 
    -0.05548707f, -0.02165288f, 0.01726750f, -0.02586245f, 0.04633052f, -0.02834640f, -0.00171182f, -0.02382230f, 
    0.07825328f, 0.18486239f, 0.17815661f, -0.21041478f, -0.11468475f, -0.04043503f, 0.07900894f, 0.06281587f, 
    -0.08936254f, -0.22827940f, -0.07137989f, -0.08094276f, 0.00938187f, 0.00773328f, 0.04103698f, -0.01278142f, 
    -0.04511517f, 0.00195013f, -0.02348790f, -0.11827330f, -0.43220848f, -0.28650331f, -0.36570823f, 0.16083741f, 
    -0.01183817f, 0.05999630f, -0.00105751f, 0.01574990f, 0.03502243f, 0.07500680f, 0.02641348f, 0.10932048f, 
    -0.15683228f, -0.20189482f, 0.05149548f, -0.03726594f, -0.05307589f, 0.04443081f, 0.01509420f, 0.03589415f, 
    0.06234214f, -0.06724513f, -0.04296260f, -0.06168707f, 0.06264006f, 0.01122216f, 0.00197399f, 0.04408769f, 
    0.04894185f, -0.01663583f, -0.07181997f, 0.01484320f, -0.05928871f, -0.02773114f, -0.07229692f, -0.01829798f, 
    0.06698675f, 0.04936620f, 0.02292318f, 0.02337904f, 0.12187961f, 0.19103388f, -0.30849576f, -0.09721176f, 
    -0.00456022f, -0.08685282f, 0.05579060f, 0.01508478f, -0.06815047f, -0.15265158f, -0.06487332f, -0.12292466f, 
    0.05389688f, 0.02342727f, 0.00142868f, -0.10416065f, 0.03163800f, 0.06815312f, -0.04708298f, -0.09262917f, 
    0.25655708f, 0.11933918f, -0.10658914f, -0.16779664f, -0.06274765f, 0.12938043f, 0.09668091f, 0.18905985f, 
    -0.02990709f, 0.03580698f, -0.06601637f, -0.01306437f, 0.00753856f, -0.00656667f, 0.01747307f, 0.03374464f, 
    0.03266612f, 0.02195965f, 0.05163327f, -0.00108668f, 0.17055397f, 0.11486764f, 0.04877142f, -0.10100498f, 
    0.01865664f, -0.03738409f, 0.03053883f, 0.01614892f, 0.02286674f, 0.00712064f, 0.08207902f, -0.16388068f, 
    -0.13672058f, -0.01676898f, -0.00732646f, -0.01009531f, -0.00505060f, 0.01844929f, -0.01488192f, 0.03118275f, 
    0.17410643f, 0.18945739f, 0.11930797f, -0.10678798f, 0.00633273f, -0.00319813f, 0.01188451f, 0.06021623f, 
    0.03460115f, -0.04429520f, 0.13568166f, 0.06332399f, -0.00370818f, 0.01629036f, 0.01385542f, -0.03124913f, 
    -0.03622195f, -0.00518051f, -0.03615392f, -0.04622089f, -0.36528784f, 0.01541319f, -0.07040235f, 0.17600155f, 
    -0.23068660f, -0.02798743f, -0.02331039f, 0.00484149f, 0.00784673f, 0.00822885f, 0.01085320f, -0.01264988f, 
    -0.02885222f, -0.00402038f, -0.00462398f, 0.05907810f, -0.08698739f, -0.00963234f, 0.08847667f, -0.16502701f, 
    -0.38807485f, -0.24967986f, -0.04400063f, 0.03475211f, -0.21570809f, 0.06589707f, -0.01811367f, 0.00961642f, 
    -0.02944115f, -0.02964264f, 0.03771361f, 0.00037467f, -0.03463270f, 0.10400283f, 0.03371947f, -0.05235258f, 
    0.01601945f, -0.13331828f, 0.02652314f, -0.18904106f, -0.15498316f, -0.24818659f, -0.02846093f, 0.12315302f, 
    -0.17947645f, 0.01615137f, 0.04204943f, -0.00435221f, 0.00206858f, 0.02920210f, 0.10668842f, 0.09103917f, 
    -0.05903012f, -0.02215265f, -0.08973964f, -0.14817967f, 0.08201531f, -0.01191709f, -0.06471111f, 0.04250503f, 
    -0.15702981f, -0.09014850f, 0.11286923f, 0.03608506f, 0.07084339f, 0.06742816f, 0.05214606f, 0.09636937f, 
    0.06240762f, -0.25496739f, -0.05421526f, -0.02945989f, 0.03923171f, 0.04493964f, 0.07713175f, 0.01458387f, 
    0.01928319f, 0.01141150f, -0.02161600f, -0.00627018f, 0.22683400f, 0.19199395f, 0.13799255f, -0.23250566f, 
    -0.09342912f, 0.08232373f, 0.21275507f, 0.05861236f, -0.00444919f, 0.07772402f, 0.01548646f, -0.00122843f, 
    -0.03399822f, -0.10087699f, -0.08843312f, -0.07391236f, -0.07775676f, -0.06089252f, -0.06924962f, 0.14441378f, 
    -0.02913595f, 0.02116816f, -0.20043986f, -0.33760545f, 0.09658554f, -0.16135976f, 0.06271549f, -0.13557123f, 
    -0.11475753f, -0.02585084f, -0.00416468f, 0.04074257f, 0.04105433f, 0.01542287f, -0.02941015f, -0.01650062f, 
    -0.04821906f, -0.11877094f, -0.04381546f, -0.07903466f, 0.15627678f, 0.16293781f, -0.06260572f, -0.17719688f, 
    -0.20883110f, 0.12475994f, 0.03098528f, 0.01459746f, 0.03382443f, 0.03070590f, -0.02403422f, -0.00015263f, 
    -0.00276899f, -0.03060237f, -0.00463980f, -0.01282230f, -0.02284567f, -0.06656076f, 0.01975979f, -0.00531926f, 
    -0.03389971f, -0.01913787f, -0.06103017f, 0.03808060f, 0.02816520f, 0.01104771f, -0.01617656f, -0.02212826f, 
    0.04070550f, 0.04224854f, -0.09669793f, -0.07528083f, -0.14213449f, -0.11102274f, -0.13082792f, -0.01263427f, 
    -0.01721493f, 0.00358029f, -0.04726615f, 0.00881599f, -0.07198039f, -0.03592531f, 0.10625311f, 0.05996281f, 
    0.02151172f, -0.01999767f, -0.01021627f, 0.03191510f, 0.03666725f, 0.03934358f, -0.06490713f, 0.05428574f, 
    -0.04033324f, -0.01993035f, -0.03649811f, -0.00758901f, -0.09479717f, -0.04306820f, -0.09093073f, -0.05846871f, 
    -0.09429692f, -0.02329147f, -0.04859198f, -0.09658562f, 0.08496149f, -0.04960050f, 0.02695289f, -0.07599983f, 
    0.01657740f, 0.03344680f, -0.07459793f, 0.06043223f, -0.00418668f, 0.02359722f, -0.02177394f, -0.06504210f, 
    -0.17423154f, 0.00329494f, -0.08898167f, 0.01471796f, -0.04678079f, 0.13192466f, -0.14728674f, -0.13468015f, 
    -0.13171707f, -0.03814026f, -0.08772787f, -0.09084736f, 0.03252678f, -0.11082106f, -0.03539815f, -0.02884460f, 
    -0.12125929f, 0.00133631f, -0.01482344f, 0.03262400f, -0.02260545f, 0.02469360f, -0.03300093f, -0.09970658f, 
    -0.39584470f, -0.01201405f, -0.30976272f, -0.27617702f, -0.18046620f, 0.03919084f, 0.00693216f, -0.14196701f, 
    0.03397560f, -0.06985200f, 0.05704858f, 0.00166142f, -0.00841377f, -0.00253500f, -0.00318164f, -0.11110078f, 
    -0.28227818f, -0.31438124f, -0.24777199f, -0.20958677f, -0.11260868f, -0.22443682f, 0.07769855f, 0.03492686f, 
    0.12595934f, -0.03165210f, 0.00131821f, 0.00050954f, -0.03760920f, 0.01711022f, 0.15400225f, -0.00144199f, 
    0.05196133f, 0.00052487f, 0.04707846f, 0.02158164f, -0.02148857f, -0.01002649f, 0.09499969f, 0.02191639f, 
    -0.01204274f, -0.08127121f, 0.05834951f, -0.13575415f, 0.04058537f, -0.01435937f, 0.05813572f, -0.29322720f, 
    0.07081229f, -0.00664663f, -0.02583278f, -0.01900862f, 0.01120939f, 0.04463511f, 0.00935413f, -0.02802574f, 
    -0.03262686f, -0.05975371f, 0.08264592f, -0.03788659f, 0.08324320f, -0.22072312f, -0.25334871f, -0.05815483f, 
    -0.10540973f, -0.07803363f, 0.09651975f, 0.02894282f, -0.01524205f, 0.02130566f, 0.09807219f, -0.04351561f, 
    0.05323301f, -0.05380915f, -0.02876143f, -0.04651005f, 0.01036938f, -0.06905713f, 0.02544257f, 0.00415120f, 
    0.13277756f, -0.02178118f, -0.08932625f, -0.18053792f, 0.03014075f, -0.01887043f, 0.00483889f, 0.08565426f, 
    0.08777109f, -0.13075210f, 0.09844720f, -0.02638043f, 0.05279805f, -0.09431819f, -0.02978794f, 0.02755259f, 
    0.00668645f, 0.05230192f, -0.05739281f, -0.01719675f, 0.71005082f, -0.01222374f, 0.28245199f, 0.14076211f, 
    -0.18543155f, 0.00632773f, -0.02373621f, 0.03849372f, -0.00032064f, -0.01477524f, 0.16379152f, -0.26043823f, 
    -0.06779659f, -0.07141645f, -0.05821311f, 0.07259838f, 0.02166078f, -0.14838135f, -0.05073619f, -0.02418155f, 
    0.17059143f, 0.14402942f, -0.03097428f, 0.11254271f, 0.09159423f, -0.01862105f, -0.04427552f, 0.00427411f, 
    -0.03612358f, -0.01404189f, -0.04034919f, 0.04071351f, -0.00569018f, -0.00749507f, -0.00394303f, 0.07181172f, 
    0.06361447f, -0.07902842f, 0.06639417f, -0.00558573f, -0.24051602f, -0.43410423f, -0.14548960f, -0.09223411f, 
    0.31507441f, 0.01559023f, -0.05713903f, -0.02039132f, -0.07300334f, 0.00659477f, 0.02684378f, 0.02627203f, 
    -0.02521638f, -0.03080686f, 0.10372270f, 0.01280579f, -0.09817945f, 0.04053940f, 0.09018039f, -0.18101653f, 
    0.41708365f, 0.07089181f, 0.02213797f, 0.04895682f, -0.04202461f, -0.04283658f, -0.01327684f, -0.01135843f, 
    -0.08948528f, 0.01015142f, -0.01773046f, -0.00912774f, 0.00179052f, 0.03889605f, -0.01788582f, -0.10751336f, 
    -0.02692506f, -0.01568229f, 0.03008576f, 0.01183793f, 0.34594035f, 0.00612869f, -0.19235447f, -0.23384087f, 
    0.00431258f, -0.06333785f, 0.02100288f, -0.04460727f, -0.01930973f, -0.02686990f, -0.06296481f, 0.03550086f, 
    0.01751943f, -0.03124660f, 0.03674188f, -0.09002148f, -0.19234835f, -0.20345859f, -0.04371370f, -0.07318725f, 
    0.29042405f, 0.29081300f, 0.23700713f, 0.25276119f, -0.03780444f, 0.09245375f, -0.14303011f, 0.04567896f, 
    0.00933282f, 0.02844613f, 0.02076675f, -0.00038232f, 0.02361971f, -0.09595993f, 0.08298215f, -0.08121561f, 
    -0.00803063f, 0.02780264f, -0.00623969f, 0.10231844f, -0.26552072f, -0.23425288f, 0.12468647f, 0.00024602f, 
    0.06838538f, 0.01982844f, -0.04921483f, 0.07235727f, -0.01758534f, -0.01491969f, 0.03617956f, 0.01945683f, 
    -0.05253512f, 0.05705864f, 0.06689506f, -0.11818729f, 0.07102849f, -0.01566124f, 0.03708329f, -0.07030746f, 
    0.13132451f, 0.17927980f, 0.14651053f, -0.03532066f, -0.20787998f, 0.04176196f, -0.05005145f, 0.04840922f, 
    -0.03734125f, 0.04156215f, -0.00245936f, -0.12438279f, 0.06303684f, -0.05557984f, -0.09743820f, 0.10272760f, 
    -0.11963203f, -0.08564494f, -0.16739993f, -0.08222345f, -0.07415733f, 0.01171887f, 0.09865202f, 0.08543266f, 
    0.04247404f, -0.01707347f, -0.01491203f, 0.04649097f, 0.00878934f, 0.00872360f, 0.03632934f, 0.05838416f, 
    -0.03915708f, 0.07787988f, -0.01653222f, 0.00672106f, -0.08934022f, 0.02356018f, 0.01813802f, 0.00736308f, 
    -0.08191444f, -0.05562379f, 0.10825213f, -0.06106648f, -0.04284217f, 0.07834104f, 0.07019367f, 0.01761315f, 
    0.02751653f, -0.01184688f, 0.11746927f, -0.03206343f, -0.05730368f, 0.11769085f, 0.00392260f, -0.03084228f, 
    -0.03389320f, 0.00657608f, -0.00016532f, 0.00545691f, -0.11033303f, 0.11407378f, -0.01017630f, 0.06074432f, 
    0.11137431f, -0.00992817f, 0.02845649f, 0.07923105f, -0.05013417f, 0.00328812f, -0.00607763f, 0.07415935f, 
    0.05017291f, -0.13000631f, -0.11153443f, 0.02249167f, 0.18089648f, 0.07533246f, -0.10277207f, 0.04328625f, 
    0.57152182f, -0.05415101f, -0.17675570f, -0.04685110f, -0.11315986f, -0.07120313f, 0.00352302f, -0.01490752f, 
    -0.01507954f, 0.01016419f, 0.11894804f, 0.09178020f, -0.01748993f, 0.01923287f, 0.05682902f, -0.04594512f, 
    -0.01062838f, -0.08130941f, 0.05518447f, 0.07818271f, 0.66596562f, 0.16297698f, 0.26907301f, 0.21352966f, 
    -0.25382680f, 0.00195607f, -0.00030223f, 0.04081218f, -0.03048106f, -0.00851583f, -0.02050376f, -0.09031370f, 
    -0.05491168f, -0.09380152f, -0.09111814f, 0.05181559f, 0.03709729f, 0.04529160f, -0.06779362f, -0.05270555f, 
    -0.27900541f, 0.04247620f, -0.03396602f, 0.29342437f, 0.05490039f, 0.03262956f, 0.05042736f, -0.21629301f, 
    -0.30883312f, 0.04594101f, -0.02691342f, 0.02770278f, -0.00850973f, 0.01240700f, 0.00775762f, -0.01422715f, 
    0.05407839f, 0.01258564f, -0.20268218f, -0.08157744f, 0.03949181f, -0.06467474f, 0.15262602f, 0.04455004f, 
    0.11825222f, 0.00387639f, 0.00124285f, 0.02748823f, 0.05089830f, -0.08848244f, 0.02659912f, 0.05499216f, 
    0.02248129f, -0.04802214f, -0.09687505f, 0.13845628f, 0.07401262f, -0.14755352f, -0.00119408f, -0.01717865f, 
    0.14843032f, 0.00601501f, 0.04461845f, 0.04118036f, 0.02629677f, -0.01252990f, -0.02047081f, -0.00354893f, 
    -0.01803541f, -0.04070028f, 0.08379996f, 0.04725493f, -0.03333530f, -0.03365226f, -0.01267549f, -0.06902035f, 
    -0.04839636f, -0.11413146f, 0.01443110f, 0.02650930f, 0.03480440f, 0.09934752f, -0.47239894f, -0.01870537f, 
    -0.15893020f, -0.11063616f, -0.04568865f, -0.12589592f, -0.21533625f, 0.18089758f, -0.03558195f, 0.01159828f, 
    0.06533632f, 0.05567671f, -0.03875428f, 0.04598729f, 0.07558648f, -0.04858334f, 0.06724924f, -0.01084374f, 
    -0.05939148f, 0.01371867f, -0.01296752f, -0.10858519f, -0.00375027f, 0.01727326f, -0.03870250f, 0.05222754f, 
    0.02434497f, -0.00233953f, -0.12250681f, 0.08994697f, 0.07660026f, 0.07038064f, -0.05645642f, -0.05818046f, 
    -0.04124834f, 0.04488741f, -0.03242436f, -0.17258161f, -0.10933009f, -0.05775176f, -0.03165918f, -0.00555326f, 
    -0.15935622f, -0.00822423f, 0.07358229f, 0.04268818f, -0.02724046f, 0.02515650f, 0.19088145f, -0.06720389f, 
    0.11322293f, 0.08364622f, 0.01153293f, 0.00577980f, -0.03556008f, 0.00564431f, -0.05070533f, 0.06702911f, 
    -0.23552737f, -0.01710938f, -0.20066716f, -0.09072690f, -0.07287552f, -0.04595157f, 0.04060084f, 0.16106263f, 
    -0.00146556f, 0.00066448f, -0.07379482f, 0.02425515f, 0.02778066f, 0.00730814f, -0.03871587f, -0.02677188f, 
    0.01094831f, -0.00511514f, -0.05555128f, 0.01485578f, 0.17710832f, 0.19572173f, -0.22951968f, 0.03793123f, 
    -0.12403532f, -0.07013164f, 0.05110342f, -0.10742669f, -0.07528909f, 0.06770185f, -0.08635674f, 0.05652585f, 
    0.07831537f, 0.05939048f, -0.05803038f, 0.05990095f, -0.09904129f, 0.09065136f, 0.09249203f, -0.05001783f, 
    0.11747308f, 0.04933016f, 0.04051554f, 0.01335907f, 0.02489021f, 0.02044379f, 0.00709638f, -0.00731599f, 
    -0.02411989f, -0.03715190f, -0.00732564f, 0.01117635f, 0.01781065f, -0.01641026f, -0.01571462f, 0.03194022f, 
    0.09526834f, -0.12270126f, 0.05497366f, 0.00824366f, -0.30694404f, 0.23458049f, -0.15900812f, 0.10951187f, 
    0.12364750f, -0.19759977f, -0.04666477f, 0.12414679f, 0.05012991f, 0.01631930f, -0.02159947f, 0.03568871f, 
    0.01122316f, -0.02205314f, 0.04921773f, 0.01672885f, 0.04236133f, 0.08546276f, -0.32574752f, -0.02148044f, 
    -0.37389466f, 0.10112569f, -0.26393807f, -0.05610535f, -0.03806829f, -0.13045098f, 0.05306465f, -0.07980236f, 
    -0.25178969f, 0.05750001f, -0.04927024f, -0.08800117f, 0.09654876f, 0.04980996f, 0.02337405f, -0.00625371f, 
    0.06644855f, 0.05366452f, 0.03097801f, -0.01077070f, 0.04270139f, -0.05612638f, 0.05853051f, -0.17746255f, 
    -0.07942162f, -0.05347992f, -0.15468277f, -0.14854391f, -0.02033339f, -0.09293776f, -0.02551756f, -0.03387146f, 
    0.01956919f, 0.06683095f, 0.05240886f, 0.01797825f, 0.00653992f, -0.06015195f, 0.06120078f, 0.09936734f, 
    0.02726888f, -0.01665070f, -0.38991368f, -0.22384170f, -0.53645605f, 0.03680897f, -0.01734743f, -0.08366540f, 
    -0.08469218f, -0.08181343f, 0.00055870f, -0.01733019f, 0.00558221f, 0.02455662f, 0.01774977f, -0.05976179f, 
    -0.18564036f, -0.22740798f, -0.21827133f, -0.20009430f, -0.03035473f, -0.15071304f, 0.06208951f, 0.04352678f, 
    0.16854215f, -0.01746279f, 0.01093760f, 0.01509036f, -0.03207202f, 0.00775043f, 0.06938543f, -0.02513915f, 
    -0.02484147f, 0.05984981f, 0.16214374f, 0.16536111f, -0.01091737f, -0.05788574f, -0.01575907f, -0.03709643f, 
    -0.05463712f, -0.03461049f, -0.11219719f, -0.04426222f, -0.00597985f, -0.04929185f, 0.07871553f, 0.05849623f, 
    0.06783052f, 0.07335007f, -0.09755612f, 0.05798647f, 0.02070368f, 0.05978670f, -0.01441650f, -0.02785613f, 
    0.05727487f, 0.04335965f, 0.01476507f, 0.04767338f, 0.02633633f, 0.27093250f, 0.14248104f, 0.09247414f, 
    0.10691597f, 0.00726170f, -0.06968881f, 0.10683621f, -0.05583300f, 0.00358557f, -0.03729334f, 0.02235190f, 
    0.00521396f, -0.02095933f, 0.05978207f, 0.10453169f, 0.04107330f, 0.02738605f, -0.15406413f, 0.07340991f, 
    0.98227483f, -0.02748861f, -0.24751626f, 0.08284769f, -0.04416844f, 0.03728303f, 0.04155127f, -0.03152432f, 
    0.09659938f, -0.08496441f, 0.06677459f, -0.06805044f, 0.09139457f, 0.02596093f, -0.09912300f, 0.14286119f, 
    0.18639939f, -0.14053534f, 0.05844219f, 0.20538826f, 0.16667344f, 0.10573614f, 0.05487592f, 0.04485486f, 
    -0.11129101f, -0.01425626f, -0.07162432f, -0.00772413f, -0.02694705f, -0.05562139f, -0.03039397f, -0.01904990f, 
    0.00571191f, 0.00270344f, 0.04717771f, 0.02529189f, 0.04974194f, 0.02867672f, 0.10113893f, 0.09895818f, 
    -0.11232071f, -0.09684792f, -0.10711428f, 0.00030215f, -0.05468494f, -0.00694501f, 0.05761017f, 0.02160140f, 
    0.09467369f, -0.05101931f, -0.15652792f, 0.06762289f, 0.00225124f, 0.03538778f, 0.01346959f, -0.00929456f, 
    0.04065733f, 0.03042186f, 0.03013068f, 0.03808597f, 0.30965140f, 0.14604001f, -0.00353873f, -0.02081616f, 
    0.02443790f, -0.01764072f, -0.06351601f, -0.05549983f, -0.04323100f, -0.02846415f, 0.00243038f, 0.01614903f, 
    0.03757187f, 0.00273717f, -0.00765627f, 0.07661157f, -0.01813139f, -0.07352173f, 0.01414946f, 0.07046635f, 
    0.23283370f, -0.31869167f, 0.05253402f, 0.03553123f, -0.09360757f, -0.06536244f, 0.01571377f, 0.00656697f, 
    0.04367010f, -0.01515878f, 0.10882645f, -0.07141723f, 0.02763953f, -0.00919526f, -0.06289655f, 0.01038681f, 
    -0.03367244f, -0.06355890f, -0.02150075f, -0.07460298f, 0.25510618f, 0.03029632f, -0.06601389f, 0.00634811f, 
    -0.09755141f, -0.04539260f, -0.02100311f, 0.00839208f, -0.00122011f, 0.01332757f, 0.10916115f, 0.12028683f, 
    0.04423114f, 0.02225999f, 0.11098927f, -0.05921333f, -0.01211707f, 0.00051055f, 0.04216288f, 0.09223473f, 
    0.79458904f, -0.09154580f, -0.17525965f, 0.12684411f, 0.03532122f, -0.01558497f, 0.03141249f, -0.04483288f, 
    -0.04539239f, -0.05572104f, -0.07075095f, 0.08762272f, -0.03763152f, 0.10850991f, 0.02809126f, 0.19915424f, 
    0.05203939f, -0.01955780f, 0.03776806f, -0.03126070f, 0.23454978f, 0.14369984f, 0.05347708f, 0.09014150f, 
    0.15150566f, -0.00583188f, -0.03286529f, -0.01459714f, -0.00384175f, -0.03319157f, 0.04253880f, 0.01779553f, 
    0.01105861f, -0.01320721f, 0.00584869f, 0.03653729f, 0.04646883f, 0.02056326f, 0.00807355f, -0.08618384f, 
    0.16873379f, -0.04346135f, -0.19324289f, -0.22836745f, 0.10937100f, 0.06421398f, -0.18987283f, -0.05631545f, 
    0.25662881f, 0.08103431f, 0.14357461f, 0.00738302f, 0.06757168f, 0.00885405f, 0.01772890f, 0.02158383f, 
    -0.08544759f, -0.11307341f, -0.06792208f, -0.15573016f, -0.08592483f, -0.15518354f, 0.17915191f, -0.00444230f, 
    0.02623362f, 0.02347344f, 0.05427256f, -0.00722710f, -0.05143206f, 0.01179207f, 0.07988922f, -0.08293792f, 
    0.02588655f, 0.07018299f, -0.06208587f, -0.04907857f, 0.14584270f, -0.07102631f, 0.02346921f, -0.02461435f, 
    -0.20027919f, -0.12294552f, -0.32473665f, -0.21244329f, -0.42901680f, 0.05948280f, -0.17897168f, -0.08339139f, 
    -0.02550826f, -0.05216788f, -0.07201382f, 0.01428006f, -0.01044184f, 0.01158237f, 0.02746053f, -0.08808349f, 
    -0.07955874f, -0.27293533f, -0.08823625f, -0.13050708f, 0.08757883f, -0.03309054f, -0.08597763f, -0.00573765f, 
    -0.06760963f, 0.02379550f, -0.02057036f, 0.01500400f, 0.04969382f, -0.13451196f, 0.01186033f, 0.04312300f, 
    0.09221720f, -0.03424770f, -0.03773153f, 0.04685415f, -0.01503948f, -0.04428327f, -0.00113867f, -0.00714145f, 
    -0.51942468f, 0.00483001f, -0.11367375f, -0.02812858f, 0.08714295f, -0.03243130f, 0.05619072f, 0.01407204f, 
    -0.00954446f, -0.09142239f, -0.00409090f, 0.04546194f, 0.00763254f, 0.02143713f, -0.00773577f, 0.00570080f, 
    0.03912281f, -0.01394075f, -0.02682139f, 0.04262165f, 0.93289173f, 0.12252509f, -0.05542783f, -0.01833888f, 
    -0.12940405f, -0.04480748f, -0.03121998f, -0.02134752f, -0.04963118f, -0.07363588f, -0.08261009f, 0.11954913f, 
    -0.13441955f, 0.03690242f, 0.05380621f, -0.15916005f, -0.08989357f, 0.07824162f, 0.16646589f, 0.01112281f, 
    -0.03325985f, -0.16698989f, 0.14999007f, 0.04823438f, 0.07235803f, -0.05159815f, 0.01869778f, 0.06922023f, 
    -0.00072388f, -0.04201274f, 0.06056359f, -0.05962958f, 0.07814211f, -0.03746548f, 0.02606264f, 0.09463812f, 
    0.01979121f, -0.01159094f, -0.03408182f, -0.07607538f, -0.09980849f, -0.03914012f, -0.03449721f, -0.04043070f, 
    0.04296954f, 0.07620641f, 0.07182243f, -0.11766122f, 0.01240648f, -0.16690169f, -0.00750493f, -0.07215972f, 
    -0.03085264f, -0.00288084f, -0.00509692f, 0.05417994f, 0.00176680f, -0.07270619f, -0.01332125f, -0.00209813f, 
    0.04090196f, 0.15143418f, 0.19822644f, 0.02619054f, -0.22172880f, -0.12460387f, -0.05596656f, -0.05867374f, 
    0.08369332f, -0.12328053f, 0.04842230f, -0.02522340f, -0.03257629f, -0.07798652f, -0.05101788f, 0.06819544f, 
    0.02656626f, -0.06300727f, 0.01171716f, 0.04948720f, -0.03842943f, 0.04433707f, -0.07967642f, -0.01262383f, 
    0.15765870f, 0.05814639f, -0.03353032f, 0.07267310f, 0.03961534f, -0.02113971f, -0.13832465f, 0.01225407f, 
    0.16118886f, 0.06232705f, -0.05177969f, -0.08998688f, -0.01572525f, 0.05363174f, -0.02650394f, -0.06109971f, 
    -0.23939307f, -0.14975730f, -0.05945522f, -0.01312135f, 0.03295818f, 0.03396167f, 0.18003491f, 0.10764644f, 
    0.10824719f, 0.04072843f, -0.15623677f, 0.08860956f, 0.05078509f, 0.06862202f, 0.01902677f, 0.00398504f, 
    -0.03079452f, -0.01311253f, -0.03063679f, 0.09583081f, 0.24258988f, 0.20017295f, 0.10134808f, 0.19026028f, 
    0.12098612f, -0.00123678f, -0.04785279f, 0.00660784f, -0.03201079f, 0.01069098f, -0.05300371f, 0.01735947f, 
    -0.01662328f, 0.03746377f, -0.00787541f, -0.09066482f, -0.02959960f, 0.10420084f, 0.06542408f, 0.01310968f, 
    0.01400600f, 0.06391551f, -0.00519138f, 0.00605049f, -0.01913609f, 0.02388823f, -0.08927470f, -0.08702412f, 
    -0.05160906f, -0.04087507f, -0.05596795f, -0.00801619f, 0.05953165f, 0.05789387f, -0.06834432f, 0.05771199f, 
    0.11382763f, -0.05481172f, 0.04242577f, 0.05257941f, -0.06317361f, -0.11247686f, 0.26868862f, 0.07369958f, 
    -0.09448436f, -0.00084855f, 0.05221111f, -0.01644347f, -0.07226621f, 0.01667950f, 0.04786480f, 0.13064216f, 
    0.01323083f, 0.00005265f, -0.05471818f, -0.01532582f, -0.07449824f, -0.05660198f, 0.10524338f, 0.06708199f, 
    -0.59522569f, -0.74158543f, 0.04158298f, -0.01628113f, -0.04693229f, 0.06097491f, 0.03653559f, 0.02712989f, 
    -0.02202280f, -0.15244441f, -0.02992265f, 0.08059406f, -0.09889194f, 0.03420136f, -0.11630528f, -0.01944568f, 
    0.01084906f, -0.05571407f, 0.05203975f, 0.05428889f, 0.11128771f, 0.17245029f, 0.06292073f, 0.06313350f, 
    0.12895082f, 0.17240192f, -0.14760809f, -0.00319910f, -0.00308649f, 0.07229941f, 0.01225483f, 0.05493277f, 
    0.00716309f, -0.02892796f, 0.06466667f, -0.06634602f, 0.00962617f, 0.16562507f, -0.19874309f, -0.03504027f, 
    -0.17144610f, 0.28151160f, -0.17987469f, -0.17061439f, 0.15811910f, -0.19586600f, -0.13357045f, -0.06850502f, 
    0.11157031f, -0.14014018f, -0.02813425f, -0.02110313f, 0.00886014f, 0.04007721f, 0.02356441f, 0.00347115f, 
    -0.03939326f, 0.00452188f, 0.10853285f, -0.12089457f, -0.11734840f, 0.06048800f, -0.13011180f, 0.13323346f, 
    -0.05004843f, -0.06187264f, 0.10590492f, -0.22334476f, 0.05377687f, 0.10012630f, 0.01964324f, 0.00440687f, 
    -0.04637535f, 0.00579643f, -0.01626305f, -0.08306357f, 0.03526324f, -0.00593520f, -0.00144729f, -0.04361788f, 
    0.03211806f, 0.00827341f, 0.01985221f, 0.08511184f, 0.00995103f, -0.00686036f, -0.00125517f, -0.03088423f, 
    0.02230359f, -0.04546766f, -0.04275721f, -0.04013473f, -0.05566718f, -0.02872298f, -0.04132938f, -0.12199021f, 
    -0.01948540f, -0.08801932f, 0.02703078f, 0.01357386f, 0.09971771f, 0.00768485f, 0.09330637f, -0.01350845f, 
    0.04414736f, -0.02602828f, -0.02249308f, -0.07105821f, -0.00121718f, 0.01588000f, -0.00635105f, -0.00371261f, 
    0.05597883f, 0.06264829f, 0.00107898f, -0.15371546f, 0.06918975f, -0.03819067f, -0.00569530f, 0.04464244f, 
    0.15588968f, 0.01264526f, 0.05186976f, -0.06275972f, 0.03345823f, 0.01521658f, -0.05383118f, 0.01795372f, 
    0.10466483f, -0.12649935f, -0.02978078f, -0.08384146f, 0.01888919f, 0.06245551f, -0.04591461f, 0.00938936f, 
    0.02350886f, 0.05830771f, 0.01364880f, -0.08500630f, 0.29715097f, 0.33137751f, 0.01262667f, 0.27124709f, 
    -0.16032076f, -0.11803461f, 0.11503326f, 0.07304969f, -0.19332655f, 0.11775508f, 0.01678074f, 0.02775044f, 
    -0.01423157f, 0.14024845f, -0.09759232f, -0.07869569f, -0.03328493f, -0.01192718f, -0.12391082f, 0.04232257f, 
    -0.15457469f, 0.23569584f, -0.32047242f, 0.19160898f, -0.15773280f, -0.04063845f, -0.00282132f, -0.06690314f, 
    -0.05641442f, 0.03212565f, -0.02039719f, 0.02764495f, 0.00969492f, -0.05480887f, -0.00956323f, 0.11387642f, 
    0.16667907f, 0.21361010f, 0.09094168f, 0.06750040f, 0.15149628f, 0.00527227f, -0.10285571f, -0.09970172f, 
    0.09175762f, 0.01438389f, 0.03551266f, 0.00655649f, -0.01991998f, 0.01082218f, 0.01205098f, 0.00814382f, 
    -0.02673908f, 0.05807215f, -0.03478821f, 0.09564224f, 0.06063033f, 0.04039728f, 0.06244739f, 0.05830717f, 
    -0.17400026f, -0.09727583f, 0.08313563f, -0.11512326f, -0.01436138f, 0.00902692f, -0.13981034f, -0.35193503f, 
    -0.05268266f, 0.09483132f, -0.00097142f, -0.00503095f, 0.02356132f, 0.01322283f, -0.08560877f, 0.02247170f, 
    -0.04922870f, -0.00950739f, -0.11527573f, -0.01713595f, 0.04535308f, 0.10459901f, 0.30730268f, 0.00559352f, 
    0.14656685f, -0.04602358f, -0.03859694f, 0.04282682f, 0.09067019f, -0.23554388f, -0.10395837f, -0.04397239f, 
    0.05492926f, -0.01850566f, 0.06554466f, 0.00656138f, -0.05976316f, -0.09106299f, 0.04710209f, -0.06314446f, 
    0.05189619f, -0.07265305f, 0.36851391f, 0.25840095f, 0.26653484f, -0.00506132f, -0.00454367f, -0.08205913f, 
    0.22015841f, -0.00479381f, 0.00122804f, 0.06761973f, 0.05383708f, -0.01484989f, -0.00453122f, 0.03023312f, 
    -0.01045622f, 0.03114762f, -0.02961006f, -0.00930517f, -0.15740898f, 0.09740168f, 0.27230689f, 0.03597115f, 
    0.05006145f, 0.02510948f, -0.03290511f, -0.00817416f, -0.06558128f, 0.05416812f, 0.07391240f, -0.00954065f, 
    0.03294815f, -0.05502618f, 0.02664111f, -0.01421649f, 0.05558715f, 0.10471781f, 0.01937711f, -0.10857149f, 
    -0.18301094f, -0.11357363f, 0.11833148f, -0.42267093f, -0.01836575f, -0.01317119f, -0.04788980f, -0.06152437f, 
    0.02541582f, 0.01379268f, -0.02592039f, -0.02497278f, 0.01241504f, 0.00146457f, -0.01071574f, -0.03437260f, 
    -0.12619343f, -0.05665564f, 0.02180029f, 0.03549490f, 0.33115408f, 0.17111300f, -0.03644985f, -0.03990678f, 
    0.20186876f, 0.05649866f, 0.04050427f, -0.03207411f, -0.01936769f, 0.02692197f, -0.04366125f, 0.02060693f, 
    -0.01800919f, 0.02966032f, -0.07493369f, 0.02446713f, 0.09663890f, -0.00133068f, 0.02663018f, 0.01611707f, 
    -0.45625645f, 0.12306392f, 0.01468514f, 0.00809979f, -0.12285873f, -0.05294559f, 0.01043644f, -0.03197217f, 
    -0.00945301f, 0.08455002f, -0.04277815f, -0.02546646f, 0.00557027f, 0.03320268f, 0.00443927f, 0.04492542f, 
    -0.01694910f, -0.03097108f, -0.00957298f, 0.00645025f, -0.11019915f, -0.04631139f, 0.11643761f, -0.00707840f, 
    -0.01605429f, 0.03278559f, -0.00177762f, -0.01429460f, -0.03175893f, 0.04475284f, -0.01483011f, -0.00521507f, 
    0.02007963f, -0.01181214f, 0.01553486f, 0.11568836f, -0.00594399f, -0.09981765f, 0.15525036f, 0.02799870f, 
    -0.48284817f, -0.53906590f, -0.00157183f, 0.25619695f, -0.24265133f, -0.12378957f, -0.09166399f, 0.02870429f, 
    0.02142291f, -0.13141832f, -0.03039351f, 0.00818371f, 0.03091066f, 0.00500902f, -0.08445211f, -0.04460072f, 
    0.00832131f, -0.04355589f, -0.06461214f, 0.01272523f, 0.12829958f, 0.04248698f, -0.08286814f, 0.00888866f, 
    0.02820230f, 0.03573406f, 0.04468993f, -0.02126007f, -0.04035058f, 0.00040550f, -0.05620395f, 0.01341517f, 
    -0.06002592f, 0.08259817f, 0.05568224f, 0.05079696f, 0.08633746f, -0.02845829f, 0.11663503f, 0.02571341f, 
    -0.06795408f, -0.02209607f, 0.31507456f, -0.01763782f, -0.04835885f, 0.04396902f, -0.04332088f, -0.10771260f, 
    -0.11155593f, 0.12416284f, -0.00456146f, 0.00845927f, 0.12297431f, -0.00051413f, 0.04330266f, 0.09109195f, 
    0.01103902f, -0.20541522f, 0.18325089f, 0.01857699f, 0.01314085f, -0.01647295f, -0.07904536f, 0.03685362f, 
    0.00807504f, -0.00338386f, -0.00927971f, 0.02379521f, -0.02466242f, 0.05265027f, 0.00793961f, 0.04126804f, 
    -0.02233861f, 0.01963946f, -0.03527172f, -0.01978101f, 0.07221437f, 0.06250376f, 0.07895189f, -0.05381621f, 
    -0.14603940f, 0.02389421f, -0.04909038f, -0.00039076f, 0.04769061f, 0.04691215f, 0.01483309f, -0.03862010f, 
    -0.01872726f, -0.03463484f, 0.00532511f, -0.03023434f, -0.08631612f, 0.04739672f, 0.02063296f, -0.00044377f, 
    0.03129777f, -0.03566558f, -0.08047832f, -0.10844959f, 0.23357852f, 0.20088983f, -0.15793841f, -0.01757442f, 
    0.13760586f, -0.11244292f, 0.08101027f, 0.00213103f, -0.02588029f, 0.02237004f, -0.04298424f, 0.07414693f, 
    -0.00404228f, -0.03083333f, 0.00042172f, 0.00744822f, -0.01086233f, 0.04236277f, -0.04271741f, 0.05246629f, 
    -0.05169868f, 0.05831041f, 0.16642019f, -0.04212095f, 0.08877245f, -0.03300123f, -0.07732901f, 0.03171682f, 
    0.04830229f, -0.04992107f, 0.03593824f, -0.00407831f, -0.10962486f, 0.01812080f, 0.02928090f, 0.03945135f, 
    -0.05208551f, 0.03305000f, 0.06556726f, -0.03263289f, -0.12712041f, 0.14344700f, 0.16377534f, 0.12823403f, 
    0.01015681f, 0.01613680f, -0.01994597f, 0.00107452f, -0.05279546f, 0.08844752f, 0.03988373f, -0.02226670f, 
    0.03572057f, -0.07116075f, 0.03566360f, -0.04514316f, 0.09433478f, -0.01502974f, 0.08235659f, -0.08911929f, 
    0.19184834f, -0.55082250f, -0.37673056f, 0.15918781f, -0.34134114f, 0.12827270f, -0.01940398f, -0.07518168f, 
    -0.00347666f, -0.07048768f, -0.02172514f, 0.06475873f, 0.00260283f, -0.03421133f, -0.02259906f, 0.02554665f, 
    0.01562077f, -0.03038759f, 0.06169406f, -0.03994925f, -0.03653547f, -0.00381621f, -0.04998117f, -0.03569475f, 
    -0.00790580f, 0.00846925f, -0.01619461f, 0.01572834f, -0.02479638f, -0.03074261f, 0.00764624f, 0.04808546f, 
    0.03718242f, -0.07363534f, 0.05007949f, -0.00216242f, 0.08892449f, 0.02184700f, 0.06338562f, 0.00125147f, 
    -0.03369724f, 0.04125485f, 0.04426115f, -0.03727094f, 0.01610372f, -0.03904333f, -0.00025617f, 0.01421644f, 
    0.01800718f, 0.02764440f, -0.07650992f, -0.06332006f, -0.06678651f, 0.01522515f, 0.02541241f, 0.03801776f, 
    -0.03786577f, 0.00801157f, 0.06129596f, -0.03354787f, -0.84977406f, -0.03808501f, 0.00876719f, -0.11427434f, 
    -0.15400723f, -0.07939909f, 0.14284220f, -0.14791596f, -0.11114438f, -0.09604164f, 0.03689047f, 0.02834153f, 
    -0.00929740f, -0.01786770f, -0.02530709f, 0.01387638f, 0.00888859f, -0.03723373f, -0.03686817f, 0.04464209f, 
    0.00376247f, 0.01973179f, -0.00731614f, -0.02443593f, 0.03867711f, -0.01089017f, -0.18631668f, -0.08507141f, 
    0.04544760f, 0.05353497f, -0.05759113f, -0.21157658f, 0.07755198f, -0.05338286f, -0.06081097f, 0.00336900f, 
    -0.01990486f, -0.05719811f, -0.06346653f, -0.03125357f, -0.11104308f, 0.08322386f, 0.06174109f, 0.00381264f, 
    0.09936081f, -0.01808457f, 0.01189460f, -0.14677076f, 0.03790844f, -0.20071998f, 0.01827611f, -0.01365472f, 
    -0.01070322f, 0.03156551f, 0.02777113f, 0.03977794f, 0.04189131f, -0.02272524f, -0.01700836f, -0.01299441f, 
    0.18775006f, 0.04979613f, 0.00335527f, 0.22403330f, 0.14066873f, -0.05132509f, -0.00235685f, 0.01389082f, 
    0.01244798f, 0.04988393f, -0.03648354f, 0.00952335f, 0.02665350f, 0.00952924f, 0.02278970f, -0.00879571f, 
    -0.04299332f, 0.01501950f, -0.03977316f, -0.02639573f, -0.19767065f, 0.11587611f, -0.07352826f, 0.04949459f, 
    -0.21609578f, 0.06051885f, -0.03902292f, -0.11963076f, 0.00182219f, 0.05357044f, 0.08036216f, -0.03649503f, 
    -0.01789756f, -0.01470183f, 0.03443414f, 0.03517437f, 0.11870832f, -0.04015814f, 0.06730355f, 0.03896604f, 
    -0.04732523f, -0.00557499f, 0.04684789f, -0.15485047f, 0.04450290f, -0.03602757f, 0.00350603f, -0.03506514f, 
    -0.00922007f, 0.04822793f, 0.01995286f, -0.04923957f, 0.04984309f, 0.03029253f, 0.03120537f, 0.00227658f, 
    -0.06538598f, -0.03369134f, 0.03070796f, 0.02446403f, -0.35342982f, -0.56992251f, -0.77465755f, -0.00675939f, 
    -0.41209459f, -0.06831357f, 0.02094770f, -0.03429495f, -0.01629846f, 0.09225963f, 0.00224369f, -0.02202116f, 
    -0.00669505f, -0.03734284f, -0.06639362f, -0.01483625f, 0.01881140f, 0.01805809f, -0.17006914f, 0.06126249f, 
    -0.18805088f, 0.08306845f, -0.17985187f, 0.06919909f, -0.06369347f, -0.02482715f, 0.10278449f, -0.10423982f, 
    -0.17858581f, -0.06778709f, 0.02424326f, -0.00274891f, 0.06112000f, -0.03513374f, -0.06308492f, -0.00809875f, 
    -0.03102513f, 0.04696125f, -0.02623400f, -0.14457971f, -0.40211484f, -0.19727910f, 0.19927047f, -0.14982317f, 
    0.00237912f, 0.00717616f, -0.03500905f, -0.27531675f, -0.18401140f, 0.13181013f, -0.00112987f, 0.00566481f, 
    0.02971163f, 0.00363295f, -0.03701200f, 0.00184303f, -0.06603288f, -0.05210799f, -0.09161438f, -0.08196804f, 
    -0.24577445f, -0.13331872f, 0.18051198f, -0.01855392f, -0.17952271f, -0.04584099f, -0.00996927f, -0.00249936f, 
    -0.01108064f, 0.00014397f, 0.01257501f, 0.00613863f, 0.00684164f, -0.04276004f, 0.00748130f, 0.04348933f, 
    0.08991560f, 0.19766526f, 0.09113892f, 0.09865402f, 0.04667739f, -0.00988565f, -0.14141317f, -0.07008908f, 
    0.15078023f, 0.02618052f, -0.01388989f, -0.03706142f, -0.00111692f, 0.00281806f, -0.01959767f, -0.04120804f, 
    -0.00454565f, -0.01400444f, -0.04489759f, 0.07130431f, 0.11044316f, 0.00377507f, 0.06436612f, 0.02689749f, 
    0.06616331f, -0.01580071f, 0.01979456f, 0.06747235f, 0.08516990f, -0.03079110f, -0.01594942f, 0.01138329f, 
    0.05042936f, -0.11172073f, -0.05648993f, 0.03588971f, 0.03126095f, 0.02393761f, 0.02851021f, 0.00482105f, 
    -0.05364671f, -0.02301973f, -0.01470544f, -0.05040571f, -0.19104590f, 0.11818612f, 0.14151260f, 0.16787575f, 
    0.15301229f, 0.04952266f, -0.01027694f, 0.03337415f, 0.11302227f, 0.03919483f, -0.01189892f, -0.00351726f, 
    0.02850141f, -0.00758026f, -0.02207941f, -0.04689305f, 0.02155260f, -0.00059178f, -0.04968688f, 0.01514264f, 
    -0.34522200f, 0.31685883f, -0.16426355f, -0.04325879f, -0.18499503f, 0.05812261f, -0.04722974f, -0.04306890f, 
    -0.00674369f, -0.08262773f, 0.05153329f, 0.11062966f, 0.01874993f, -0.06963352f, -0.00378092f, -0.02572280f, 
    -0.01269430f, 0.15539090f, 0.22507496f, -0.11331219f, -0.42154288f, 0.16002932f, 0.27441657f, -0.29389569f, 
    -0.16924755f, -0.04717641f, -0.01420830f, -0.05424062f, 0.02495742f, 0.04958566f, 0.01542887f, 0.03850628f, 
    -0.02907801f, 0.03985692f, 0.01050220f, 0.05524252f, -0.09516069f, -0.05112191f, 0.05122096f, 0.01366388f, 
    0.13040446f, -0.05450848f, 0.07868819f, 0.04556346f, 0.07303212f, 0.03981172f, -0.10338841f, -0.07348810f, 
    0.08001770f, -0.19582233f, -0.01658020f, 0.02022902f, 0.00309067f, 0.04145460f, 0.01229536f, 0.00858898f, 
    -0.05842047f, -0.05465858f, 0.07468457f, -0.04190434f, -0.40380439f, -0.13225962f, 0.21664913f, -0.39094135f, 
    0.10582455f, 0.00431862f, -0.01043485f, -0.02840722f, 0.02115008f, 0.03884128f, 0.01925589f, 0.00284389f, 
    0.00094148f, -0.02364181f, 0.02311392f, 0.04581463f, 0.04499143f, 0.03746242f, -0.07747588f, -0.10738166f, 
    -0.05554308f, -0.20944901f, 0.45061809f, 0.05753517f, 0.24156636f, -0.05006983f, -0.02136731f, 0.03692585f, 
    0.10734376f, -0.12008246f, 0.04321659f, 0.02010796f, -0.02655976f, -0.13666956f, 0.04392726f, 0.00909039f, 
    -0.01544660f, 0.03243097f, 0.00517451f, 0.00845948f, -0.11082447f, 0.07820123f, 0.06584784f, -0.01044398f, 
    -0.01320673f, -0.01444103f, -0.05122130f, -0.03385156f, -0.00054129f, 0.00240500f, -0.03351738f, -0.03262803f, 
    -0.01026888f, 0.03804376f, 0.01203107f, 0.02644928f, 0.00023720f, -0.05696332f, 0.03240578f, -0.01558268f, 
    -0.46586356f, 0.30209744f, -0.30085713f, -0.15277201f, -0.35586184f, 0.04563140f, -0.02839406f, -0.05025963f, 
    -0.00603552f, -0.00192452f, -0.01700092f, -0.00671811f, 0.09614280f, -0.06641942f, 0.06586871f, 0.18157406f, 
    0.08526036f, 0.10155437f, 0.22823183f, -0.02233006f, -0.15088844f, -0.23591109f, -0.19490525f, -0.36668205f, 
    -0.08578163f, -0.04987676f, -0.00867538f, -0.01269350f, 0.04215953f, 0.03073162f, 0.01682764f, 0.00753210f, 
    -0.03037999f, 0.07098845f, -0.01394711f, -0.02630240f, -0.03092789f, 0.06668112f, 0.01572425f, -0.02718171f, 
    0.05517410f, 0.10879564f, 0.34715280f, 0.24651471f, 0.13186771f, 0.02965483f, -0.04748648f, -0.15568921f, 
    0.15573427f, -0.09993708f, 0.01321750f, 0.01874398f, -0.01619523f, -0.08186521f, -0.04080294f, -0.06344597f, 
    0.03198468f, -0.00078531f, -0.10053936f, -0.05630904f, 0.09288285f, -0.10486855f, 0.00279530f, -0.06721646f, 
    0.00501944f, -0.00050238f, -0.03097793f, -0.04482597f, -0.01755994f, 0.01990530f, 0.07059508f, -0.05017963f, 
    -0.03706546f, 0.03846322f, -0.02797336f, 0.01658238f, -0.07305249f, 0.04416378f, 0.07193856f, -0.02657214f, 
    -0.33945248f, -0.20286685f, 0.23025875f, -0.14545701f, -0.04688877f, -0.00590134f, -0.02181530f, -0.13272959f, 
    -0.02257049f, -0.05364681f, 0.00565055f, 0.02372386f, 0.00755410f, -0.02835599f, 0.01938551f, -0.06053670f, 
    -0.07162997f, 0.13960925f, 0.08828583f, 0.07239296f, 0.01580943f, -0.12784643f, 0.18357675f, 0.05849478f, 
    0.07284548f, 0.04827465f, -0.03355189f, 0.01607985f, 0.06459561f, -0.13268259f, -0.02013207f, -0.01474848f, 
    -0.05590617f, 0.00834162f, -0.00793954f, 0.04502535f, -0.02833937f, 0.01406781f, 0.04164553f, -0.00797177f, 
    0.09973742f, 0.16311237f, -0.29101449f, 0.14221556f, 0.11021356f, -0.02000493f, 0.04902095f, 0.12888041f, 
    -0.07935624f, 0.06701798f, -0.03742759f, 0.01168768f, 0.03523567f, 0.03813933f, 0.00577732f, 0.03293336f, 
    -0.00723746f, 0.04268939f, -0.08110032f, 0.01933021f, -0.32935929f, 0.05035537f, -0.01718208f, -0.22022209f, 
    -0.14893061f, -0.01279987f, -0.08827908f, -0.00911161f, -0.01018686f, 0.07414810f, 0.06999166f, -0.01095923f, 
    -0.22998601f, 0.11344381f, 0.12847833f, 0.13705255f, -0.00338125f, -0.03032967f, 0.16938516f, -0.03533997f, 
    0.18855105f, -0.00646688f, 0.05630625f, 0.10961894f, 0.13074775f, -0.03776369f, -0.01400064f, -0.01235702f, 
    0.00048135f, -0.09122726f, -0.09521692f, -0.01378335f, 0.12293740f, -0.03293926f, 0.08718453f, -0.00871083f, 
    -0.00075361f, 0.01481795f, -0.02188070f, -0.01170240f, 0.31020355f, -0.45934105f, 0.01655059f, 0.08325960f, 
    0.15511391f, 0.12156715f, -0.14802063f, -0.05277749f, 0.05599312f, -0.08822756f, -0.05892191f, 0.06174342f, 
    0.06795926f, -0.05816330f, -0.07502855f, 0.07140368f, 0.01076989f, -0.07326508f, 0.05911040f, -0.04573936f, 
    -0.07958636f, -0.00457017f, 0.41633120f, 0.27471027f, 0.24103916f, -0.05040671f, -0.13934804f, 0.01309713f, 
    0.09927026f, 0.01776701f, 0.03424504f, 0.01164716f, 0.01052480f, 0.02651321f, 0.07965596f, 0.01909290f, 
    -0.01200105f, 0.04193854f, -0.01444733f, -0.01152167f, 0.22760932f, -0.02628251f, -0.03777725f, 0.04559472f, 
    0.02857003f, 0.08301154f, -0.09338565f, -0.06534043f, 0.06136574f, 0.09344281f, -0.13879713f, -0.01728794f, 
    0.10150039f, -0.08996052f, -0.02660847f, -0.01081321f, -0.00740030f, 0.00138035f, 0.04764818f, -0.04017047f, 
    0.01349786f, 0.06878204f, -0.11599804f, 0.06822791f, 0.07477162f, 0.00733635f, -0.03833145f, -0.09464724f, 
    -0.13080363f, -0.12424314f, -0.02038985f, 0.01341212f, 0.01215924f, 0.04529321f, -0.01990078f, 0.00185308f, 
    -0.00062154f, -0.00887443f, -0.01832470f, -0.00149667f, -0.15148614f, -0.07501176f, 0.11049201f, -0.06246550f, 
    -0.16906260f, -0.00654096f, -0.00958477f, -0.00255386f, -0.00784997f, 0.02294064f, 0.00519272f, 0.02464346f, 
    -0.04462044f, 0.03125661f, 0.03440113f, 0.03376411f, 0.03522616f, 0.03192088f, 0.03249896f, -0.07017964f, 
    -0.22929804f, -0.03063343f, 0.13287227f, -0.12837341f, 0.02761498f, -0.01390279f, -0.01651394f, -0.02734558f, 
    0.00844550f, 0.01439372f, -0.03576558f, 0.03223007f, 0.01157540f, -0.03860393f, 0.01123835f, 0.00460665f, 
    -0.10699517f, -0.20414765f, 0.02806878f, -0.02171410f, 0.22327647f, -0.09534930f, 0.08161572f, -0.08332692f, 
    0.05056949f, -0.02881481f, -0.00266308f, 0.03022727f, -0.02305040f, 0.04921780f, 0.03129322f, -0.04928564f, 
    -0.11671926f, 0.11733329f, 0.06170505f, 0.11612906f, 0.05989476f, -0.03915562f, 0.10726979f, -0.06178702f, 
    0.03722382f, 0.21375038f, 0.20021051f, 0.01875669f, 0.18362661f, -0.02591647f, 0.03740600f, 0.01221509f, 
    -0.02678849f, 0.00490594f, -0.03221782f, -0.01731788f, -0.09865315f, 0.09786858f, 0.08702956f, 0.02826219f, 
    0.00997520f, 0.00277334f, -0.00562297f, 0.05590359f, -0.36422527f, -0.41307318f, -0.23139511f, 0.04125012f, 
    -0.41244030f, -0.00226720f, 0.08051157f, -0.00725249f, 0.06478484f, -0.06580903f, -0.04142070f, -0.03018026f, 
    -0.01964399f, 0.01201522f, -0.03567465f, -0.05401408f, 0.00632496f, 0.01209675f, 0.03229715f, 0.13059460f, 
    -0.13361670f, 0.15599293f, -0.12827623f, -0.26249546f, -0.10468304f, 0.06097714f, -0.15855661f, -0.18937822f, 
    0.03128115f, 0.19078526f, -0.01148223f, 0.04505629f, 0.05804025f, 0.03199056f, -0.05976316f, -0.08600135f, 
    0.00959237f, -0.10353366f, -0.04454571f, 0.04882248f, 0.20349009f, -0.45673639f, -0.20254812f, 0.03673359f, 
    -0.10430406f, 0.13319191f, -0.01098894f, -0.02310808f, 0.06267807f, -0.09933528f, -0.00878903f, 0.06813553f, 
    0.00900924f, 0.01366724f, 0.00219909f, 0.03315658f, 0.01642799f, 0.00847741f, 0.06318708f, 0.02871566f, 
    0.09817638f, -0.15069099f, 0.00820800f, -0.07304383f, 0.04682997f, -0.03553421f, -0.04587633f, 0.00742661f, 
    0.01158837f, 0.01024489f, -0.01807149f, -0.04797779f, -0.06498361f, 0.09447966f, -0.03214024f, 0.10862189f, 
    -0.00433216f, -0.05542503f, 0.03573399f, 0.03078545f, -0.02200149f, -0.02866148f, -0.02323296f, 0.00526534f, 
    0.06338982f, -0.06361625f, -0.01509480f, -0.01924018f, -0.01270197f, 0.06495833f, -0.04474136f, -0.05178843f, 
    -0.06299467f, -0.00148071f, -0.06809296f, 0.03582209f, -0.12433036f, -0.04281697f, 0.00100105f, -0.00667046f, 
    -0.15982845f, 0.05217733f, -0.00406457f, 0.00900653f, -0.08157057f, -0.06523137f, -0.03869069f, -0.03538923f, 
    0.01398853f, 0.03372153f, 0.02746373f, 0.04858588f, -0.05735510f, 0.07758407f, -0.02299634f, 0.03420540f, 
    -0.05495546f, 0.03375482f, 0.00486476f, -0.02179251f, -0.25402528f, 0.36929891f, -0.15556805f, 0.24769068f, 
    -0.08097894f, -0.00177836f, 0.03625210f, -0.01569876f, -0.11196698f, 0.19895478f, 0.01796417f, 0.05585894f, 
    0.08280843f, 0.04166582f, -0.09536862f, 0.01190409f, -0.04342961f, -0.01012676f, 0.00134604f, -0.01653734f, 
    -0.55810654f, 0.13430713f, 0.08165988f, 0.14044115f, -0.07458182f, -0.06428652f, 0.02686284f, 0.00558317f, 
    -0.06308496f, 0.09898752f, -0.08549719f, 0.02581525f, -0.06650411f, -0.05428280f, 0.02628647f, 0.12297975f, 
    0.08429446f, 0.22049512f, -0.19846652f, -0.03049376f, 0.61482078f, 0.39123505f, -0.14681946f, -0.39798701f, 
    -0.33656812f, -0.01117167f, 0.00981637f, 0.00752858f, -0.10665170f, 0.01969956f, -0.16164245f, -0.17095013f, 
    0.01681708f, -0.00969233f, -0.04758263f, 0.00512457f, 0.02957122f, -0.09482637f, 0.02667861f, 0.08083484f, 
    0.28490207f, -0.00610852f, 0.41480687f, -0.13098499f, 0.23978199f, -0.08754776f, 0.08358515f, -0.01467818f, 
    0.13998541f, 0.04659973f, 0.12951323f, 0.00526219f, -0.01573699f, 0.01653007f, 0.11416275f, -0.07802262f, 
    -0.07404447f, -0.05223788f, -0.05593562f, 0.04064219f, -0.08409893f, 0.36313558f, -0.08859746f, -0.00556189f, 
    0.28006366f, 0.12655966f, -0.12746169f, 0.08183415f, -0.12080686f, 0.10142864f, -0.07827149f, 0.03942100f, 
    0.02451889f, -0.07567680f, -0.01159366f, 0.05801817f, -0.05004531f, -0.01918570f, 0.08001081f, 0.07992448f, 
    -0.21507676f, 0.10857157f, -0.05609450f, -0.15909098f, 0.24395292f, 0.13149698f, 0.06331170f, -0.07006000f, 
    -0.05614513f, -0.09219485f, -0.07897715f, 0.04273116f, -0.02602670f, 0.02377337f, 0.08720525f, -0.05909868f, 
    0.04496632f, 0.03729603f, 0.08139035f, 0.03432938f, 0.17318588f, 0.47211251f, -0.08600338f, 0.06209392f, 
    -0.01724647f, 0.14670859f, 0.01979030f, -0.01045642f, 0.05589336f, 0.05387526f, -0.04874085f, -0.11198175f, 
    -0.05983939f, 0.00739819f, 0.07853888f, -0.01535666f, -0.06579459f, -0.11984582f, 0.01389346f, -0.02998855f, 
    -0.51371258f, -0.42763287f, -0.14251700f, -0.22195089f, -0.19551007f, -0.06598478f, -0.04651903f, -0.05959748f, 
    0.03658493f, 0.02728233f, 0.06357947f, 0.02198882f, 0.04887606f, -0.06230083f, 0.04144292f, -0.02225024f, 
    0.02559697f, 0.10230960f, -0.07984511f, -0.02779355f, 0.77776879f, 0.61112893f, 0.33483821f, -0.56449550f, 
    0.26040897f, -0.03770861f, 0.08670156f, 0.01972255f, -0.11979184f, 0.03760601f, 0.02134865f, 0.00787649f, 
    0.15423951f, -0.00714223f, -0.01390839f, -0.01362089f, -0.15247008f, -0.02602790f, 0.13374163f, 0.07937787f, 
    -0.61471444f, -0.08384854f, -0.04295383f, 0.19985983f, -0.04680758f, 0.08108552f, -0.09005700f, -0.05609746f, 
    0.05529646f, -0.24174617f, 0.04754446f, 0.07632101f, 0.03890031f, -0.00236871f, 0.00096745f, -0.12462188f, 
    -0.02926493f, -0.15494221f, 0.04632380f, -0.02763895f, -0.03009265f, -0.00038591f, -0.08508079f, 0.06223558f, 
    -0.10187085f, -0.05007011f, -0.08138193f, 0.11129797f, 0.10214971f, -0.02949253f, 0.06123677f, -0.04390708f, 
    0.07594377f, -0.03416714f, -0.01029561f, 0.00100651f, 0.04699313f, -0.01854036f, 0.12556398f, -0.04739040f, 
    0.03466096f, -0.05225195f, -0.26033297f, 0.03120841f, 0.27420944f, 0.01105155f, 0.04255648f, -0.03604516f, 
    0.03214235f, 0.04143538f, -0.08110321f, 0.02967256f, -0.06907963f, -0.03129777f, -0.01000551f, 0.03360324f, 
    -0.00135831f, 0.03953457f, -0.00906935f, 0.01970711f, 0.36044103f, 0.41787186f, -0.13016813f, -0.16834967f, 
    -0.17147459f, -0.02330132f, -0.00197492f, 0.03323090f, -0.11965290f, -0.16249628f, -0.08356432f, -0.08681297f, 
    -0.08435700f, 0.07262142f, -0.07438974f, 0.07542309f, 0.02332759f, 0.11640824f, -0.02554359f, 0.03452174f, 
    -0.40500405f, 0.50039148f, -0.13051802f, 0.03340306f, 0.06716950f, 0.02219213f, -0.01708917f, 0.03793532f, 
    -0.02426002f, 0.00920389f, -0.02539894f, -0.00258622f, 0.06930502f, -0.02695249f, -0.09669473f, -0.01402661f, 
    0.02761780f, 0.03677678f, 0.01956453f, -0.00541612f, -0.03771627f, -0.06643121f, -0.11580215f, -0.13780715f, 
    -0.32702255f, -0.07138151f, -0.06233364f, -0.08614822f, -0.07589835f, -0.08560497f, -0.01946834f, 0.00924784f, 
    -0.01529413f, -0.04749706f, -0.02038993f, 0.00597211f, -0.10494325f, 0.06143428f, -0.16541569f, -0.08748230f, 
    -0.05115516f, 0.02874183f, -0.07558117f, -0.04109760f, 0.03049465f, -0.02973137f, 0.01491969f, 0.09295106f, 
    0.00036786f, 0.03044436f, -0.00465942f, 0.00535134f, -0.13058636f, -0.06136203f, 0.05050579f, 0.07828400f, 
    -0.03525227f, 0.10724466f, -0.12799112f, -0.06182016f, 0.14200920f, 0.22895645f, -0.06382740f, -0.36944753f, 
    -0.15476419f, -0.05113477f, -0.07821621f, -0.07521179f, -0.12658234f, -0.08670110f, 0.00332525f, 0.04161056f, 
    -0.00502101f, -0.03669622f, 0.10719766f, 0.11473492f, -0.00382498f, -0.12124138f, -0.14751951f, -0.07798131f, 
    -0.25250050f, 0.09623040f, -0.11799995f, 0.12142607f, 0.27450383f, 0.05454296f, -0.09695141f, 0.09895937f, 
    -0.14676857f, 0.01738595f, -0.06865860f, 0.03730460f, 0.09041651f, 0.03134924f, -0.04830607f, 0.06149218f, 
    0.00678285f, 0.01364505f, 0.03367523f, -0.04372061f, 0.21869452f, 0.18848993f, -0.11526023f, 0.08715210f, 
    -0.06473997f, 0.08496490f, -0.05757560f, -0.04582693f, -0.00183531f, -0.00737445f, -0.06151525f, -0.06565283f, 
    -0.06543184f, -0.03085461f, 0.00558501f, -0.07522327f, -0.06762163f, -0.02551072f, -0.04824309f, 0.03543200f, 
    0.13640775f, -0.11894623f, -0.21916571f, -0.04764050f, 0.22562990f, 0.08200192f, 0.07372422f, 0.02221918f, 
    -0.05207011f, 0.06440988f, -0.07486250f, 0.04308369f, -0.02687182f, 0.01574132f, -0.13289265f, -0.08534367f, 
    -0.10745679f, 0.03311525f, 0.06190905f, -0.07549044f, 0.04893907f, -0.05527867f, -0.18020745f, 0.00779375f, 
    -0.35136855f, 0.14890420f, 0.18104886f, -0.04463372f, 0.00405759f, 0.16097142f, 0.00042695f, -0.11052707f, 
    0.01693242f, -0.08638362f, -0.09315542f, -0.09886292f, -0.05974471f, 0.04030571f, -0.05516294f, -0.14567438f, 
    -0.21103485f, -0.17495809f, -0.27287164f, 0.06713179f, -0.13333791f, 0.00756319f, -0.09250143f, -0.05074421f, 
    -0.12092321f, -0.07927325f, -0.03192755f, -0.02457662f, -0.00649409f, -0.03846796f, -0.05987131f, 0.04480872f, 
    0.02394482f, -0.01184543f, -0.09939767f, -0.07963306f, -0.09487510f, -0.05902174f, 0.01657900f, 0.20282881f, 
    0.19543104f, 0.02305365f, -0.03903012f, 0.26118630f, -0.01544531f, -0.00742148f, 0.08362207f, 0.06928324f, 
    -0.02252397f, -0.00724172f, 0.04776395f, -0.11229174f, -0.08959341f, 0.06091383f, -0.03452522f, -0.10598843f, 
    -0.20813990f, -0.17199580f, -0.39446479f, 0.55033541f, -0.08975916f, 0.11443313f, -0.01432014f, 0.06932422f, 
    0.05242079f, -0.08121832f, -0.04846616f, -0.02709321f, -0.13583557f, 0.09325594f, -0.15990078f, 0.12794618f, 
    -0.08123877f, 0.23773639f, -0.23656079f, -0.08522965f, -0.02614216f, 0.15223455f, 0.04266590f, 0.20967960f, 
    0.10994030f, -0.08470194f, -0.00642019f, 0.00867153f, -0.01160390f, 0.11671791f, -0.05419495f, 0.17514013f, 
    0.07619590f, -0.09206399f, -0.00746104f, 0.08843877f, 0.03650354f, -0.03738958f, 0.00948886f, 0.09857219f, 
    -0.14735818f, 0.14469302f, -0.19397430f, -0.26082358f, 0.28882077f, 0.22453536f, 0.07315003f, -0.18048984f, 
    0.00975266f, -0.31367657f, -0.04091628f, 0.07454020f, -0.09337714f, 0.07398327f, 0.03698539f, 0.03609529f, 
    0.11875482f, 0.01785915f, -0.02509602f, -0.12419048f, -0.57258904f, 0.12324232f, -0.20702200f, 0.24061337f, 
    -0.10607287f, 0.05438191f, -0.20171994f, 0.05071186f, -0.13151143f, -0.12638870f, 0.03269279f, 0.00675345f, 
    0.01859618f, -0.04994647f, -0.08485597f, 0.08452438f, 0.09941860f, 0.00191137f, 0.02127620f, -0.11564623f, 
    -0.31978458f, -0.12523162f, 0.20661585f, -0.12336397f, -0.23722760f, -0.06719154f, -0.09889756f, -0.06193077f, 
    -0.03560887f, -0.05539799f, -0.02716305f, -0.02744567f, -0.04031628f, 0.04948628f, 0.05655561f, -0.05450425f, 
    -0.00768336f, -0.04345174f, -0.10243151f, -0.06659224f, 0.03050322f, 0.01236967f, -0.22876295f, -0.05501795f, 
    0.19664979f, 0.02061553f, -0.00938745f, -0.05838802f, 0.11768411f, 0.04953060f, -0.11737958f, 0.04383257f, 
    -0.07695221f, -0.10693991f, -0.05852805f, -0.06039860f, -0.03781866f, 0.09112023f, -0.18719530f, -0.00500193f, 
    -0.14354753f, -0.01339360f, -0.20203204f, 0.20401610f, 0.10164557f, 0.20083562f, -0.02100127f, 0.12242943f, 
    0.03777684f, 0.04153814f, -0.05548117f, -0.01226389f, -0.12070669f, -0.08743432f, 0.05831246f, 0.04831383f, 
    -0.08006651f, 0.20965661f, -0.15073653f, -0.17972928f, 0.07117177f, -0.10366306f, 0.37291050f, 0.00109426f, 
    0.25306901f, -0.21045335f, 0.07479794f, -0.00947528f, 0.07594674f, 0.00688952f, 0.15077376f, 0.02510602f, 
    -0.01158831f, 0.05866234f, 0.12110371f, -0.01672390f, -0.02475580f, -0.02335672f, -0.05596101f, -0.00383250f, 
    -0.05346906f, -0.22944129f, 0.08724223f, 0.06607341f, 0.26349556f, -0.13869132f, 0.02824422f, 0.03650949f, 
    0.08936504f, 0.05727233f, 0.07134100f, 0.02052001f, 0.01740946f, -0.01708189f, 0.08901846f, 0.04247070f, 
    0.04907139f, 0.06778512f, 0.04391536f, -0.01039442f, 0.56300956f, 0.34432587f, -0.11766858f, -0.07560540f, 
    -0.47526053f, 0.11077100f, 0.14628087f, 0.02632668f, -0.00435221f, 0.08883741f, -0.09333538f, -0.12162026f, 
    0.15995041f, -0.02953915f, 0.02751236f, -0.03871194f, -0.07537980f, -0.17895032f, 0.04201342f, 0.00793090f, 
    -0.25844350f, -0.03454125f, -0.10265605f, -0.08177171f, 0.26379389f, 0.06353140f, -0.01922939f, 0.03325026f, 
    0.06553472f, 0.05876581f, -0.02205278f, 0.00590756f, -0.02273613f, -0.05399985f, -0.03050654f, 0.10390761f, 
    -0.03567527f, 0.10830506f, -0.01844865f, 0.04198794f, 0.06865060f, -0.09523298f, -0.13616157f, -0.07369205f, 
    0.27519968f, 0.04399474f, 0.00903174f, -0.08444043f, 0.01650345f, -0.15334035f, 0.02922855f, 0.02116352f, 
    0.09311652f, 0.00469351f, 0.06999977f, -0.10885005f, -0.02407826f, 0.10487036f, -0.03937741f, 0.06626622f, 
    -0.44551906f, 0.33736145f, 0.00759572f, -0.19844106f, 0.13485691f, 0.10769767f, 0.17643537f, 0.05275766f, 
    0.04141483f, 0.15904114f, -0.11865690f, -0.05035724f, -0.14106926f, -0.04701332f, 0.06590590f, -0.11854841f, 
    -0.02080160f, 0.07055310f, -0.05063989f, -0.06669282f, -0.59278876f, -0.51103789f, 0.14758179f, 0.11831551f, 
    0.30557233f, -0.08770687f, -0.02332555f, -0.06752259f, 0.00247748f, -0.06621465f, 0.01899278f, 0.05904084f, 
    -0.10204301f, 0.05155435f, 0.03572652f, 0.05341011f, 0.08205253f, 0.05237506f, -0.06246274f, -0.00593629f, 
    -0.08556179f, -0.09338674f, -0.23386061f, 0.01274304f, 0.26293218f, 0.12978993f, 0.05798735f, 0.05951165f, 
    -0.02737623f, 0.03545795f, -0.05882024f, 0.01051373f, 0.05897989f, 0.05459283f, -0.06070016f, 0.09102423f, 
    0.04476057f, -0.02951823f, 0.04418402f, 0.03529920f, -0.18355675f, -0.43953860f, 0.39607319f, -0.07640198f, 
    0.09878764f, -0.19804375f, -0.12563944f, -0.09185311f, 0.05792227f, -0.00769864f, 0.07445329f, 0.01403461f, 
    0.10437176f, -0.05260245f, 0.08002012f, 0.00157719f, 0.02285695f, -0.01102670f, 0.05012569f, -0.01300588f, 
    -0.60459089f, 0.65980726f, -0.13201280f, -0.17239845f, 0.19436722f, 0.23928428f, 0.08567918f, 0.03657408f, 
    -0.10614461f, 0.06693857f, -0.20262632f, -0.02684804f, -0.03199165f, -0.01267095f, 0.06712651f, -0.05160576f, 
    0.06818498f, -0.01844156f, 0.09485800f, 0.08909216f, -0.30766630f, 0.11306139f, -0.02228347f, 0.23568860f, 
    0.24416383f, -0.07426959f, -0.21449408f, -0.00704986f, -0.11534911f, -0.01971792f, -0.03565760f, 0.00425222f, 
    0.10383523f, 0.00569405f, -0.08331435f, 0.07353981f, 0.01484234f, 0.03173608f, -0.06611061f, -0.05538734f, 
    -1.16053367f, 0.56495768f, -0.22477980f, 0.34231308f, -0.25956053f, 0.08537132f, -0.04737462f, 0.22959274f, 
    -0.07041250f, 0.02060571f, -0.03256978f, 0.04801184f, -0.03245183f, 0.04365861f, -0.02916056f, 0.03430969f, 
    -0.05163217f, -0.00127573f, -0.04397531f, -0.01584995f, -0.59704494f, -0.27968207f, -0.11921865f, -0.20840320f, 
    -0.40101406f, -0.02358343f, 0.01889873f, 0.04928073f, 0.18595554f, 0.07621883f, 0.05870892f, -0.01394932f, 
    0.11003261f, 0.06270381f, -0.03215548f, 0.00823866f, 0.00242655f, 0.12652609f, -0.09794643f, -0.15904178f, 
    -0.38061732f, 0.36178213f, -0.10939494f, -0.06212754f, 0.18627270f, 0.08109291f, -0.01789456f, -0.04892356f, 
    -0.04392919f, -0.05097328f, -0.15747188f, 0.07057511f, -0.05111689f, 0.05767348f, 0.08115521f, -0.04362400f, 
    -0.02795592f, 0.10981619f, 0.05981316f, -0.00731661f, -0.24612430f, -0.03557155f, 0.07947726f, -0.27553552f, 
    -0.22161618f, -0.00790959f, -0.17388216f, -0.11577397f, -0.08799577f, -0.21133836f, -0.09907330f, -0.14104447f, 
    -0.06146774f, -0.05646447f, 0.07493395f, -0.01862124f, -0.12469183f, -0.04701492f, -0.03446174f, -0.03244768f, 
    0.01393379f, -0.12111867f, 0.13664316f, 0.06735061f, 0.25358987f, -0.08209886f, 0.07875657f, 0.07197506f, 
    0.04855448f, 0.04317206f, 0.04386703f, -0.01696279f, -0.00703820f, -0.06796099f, 0.05221773f, -0.01119587f, 
    0.00041996f, 0.06255044f, 0.02871568f, 0.01790966f, -0.04574724f, -0.14098039f, -0.13753924f, -0.05324910f, 
    0.08747500f, 0.18272698f, 0.06052320f, -0.02710794f, -0.09247844f, -0.08202899f, -0.05154422f, -0.04894843f, 
    0.03298081f, -0.04141124f, -0.02038146f, -0.05103508f, -0.01906093f, -0.07828181f, 0.11333723f, 0.00899839f, 
    0.10664050f, 0.01967277f, -0.23424807f, -0.16268937f, 0.17114545f, 0.04818661f, -0.02245382f, -0.01929204f, 
    0.00834479f, -0.09269741f, 0.07089214f, 0.04004133f, -0.06680142f, -0.01265032f, 0.04395660f, 0.02895829f, 
    -0.02003818f, -0.00158642f, -0.13498884f, -0.00037447f, 0.07363771f, -0.11756300f, 0.25365672f, 0.25138843f, 
    -0.08558042f, 0.07634366f, 0.09033276f, 0.05910977f, 0.09648781f, -0.18169788f, 0.01565488f, -0.04293509f, 
    0.15479037f, 0.12575683f, -0.20065203f, -0.04504374f, -0.00658156f, 0.15458737f, 0.00376573f, -0.05832011f, 
    -0.36380595f, 0.48574257f, 0.00041752f, -0.20880844f, -0.09636421f, 0.29469338f, 0.09071010f, -0.07679395f, 
    0.00487512f, -0.02171717f, -0.10201649f, -0.08671834f, 0.03897042f, -0.06535870f, 0.07693960f, -0.08434172f, 
    0.15895830f, -0.22401902f, 0.00208481f, -0.11285735f, 0.38727707f, 0.19244163f, -0.24925622f, 0.07409704f, 
    -0.04563431f, 0.20623671f, 0.18075293f, -0.03367348f, -0.24177381f, 0.10659140f, -0.21573456f, -0.15421192f, 
    0.01239027f, -0.16155088f, 0.01787281f, -0.18568289f, -0.09190179f, -0.08277580f, 0.13037483f, -0.05519082f, 
    0.00460841f, 0.07684813f, -0.13465786f, 0.01707167f, 0.23722678f, 0.12250761f, 0.03271548f, -0.07365155f, 
    -0.01333399f, -0.07155833f, -0.00168668f, 0.09343189f, 0.06393535f, 0.12381168f, 0.08623897f, -0.06502738f, 
    0.03523235f, 0.03585558f, -0.03624886f, 0.06834724f, -0.38968024f, 0.58369774f, 0.27708018f, -0.42875439f, 
    0.36261022f, 0.06431514f, 0.13636297f, -0.02750716f, 0.06039523f, -0.21442312f, -0.03367182f, 0.02239102f, 
    -0.15235735f, -0.01843653f, -0.00290066f, -0.06663325f, 0.04273544f, -0.04423561f, 0.06546166f, -0.08273530f, 
    0.10202544f, -0.08955109f, -0.13272275f, -0.20437200f, 0.15545365f, 0.07519649f, 0.07550655f, 0.07319342f, 
    0.04677450f, 0.02344581f, 0.07900974f, -0.01184801f, 0.04883308f, -0.05326221f, -0.09875953f, 0.11089457f, 
    -0.04715737f, 0.06895258f, 0.04318137f, -0.02332524f, 0.07225133f, -0.41971156f, 0.07606514f, -0.04141421f, 
    0.04757091f, -0.04124670f, 0.07939362f, -0.03707209f, 0.03874289f, -0.04038319f, 0.05745310f, 0.03059544f, 
    0.04713912f, 0.00278499f, -0.00741220f, 0.00604456f, 0.00139139f, 0.09454942f, -0.03270107f, 0.01593500f, 
    -0.63333142f, -0.19126089f, 0.20411441f, 0.00398377f, 0.30593613f, -0.05374362f, -0.06947666f, -0.08965632f, 
    -0.12900145f, 0.12128998f, 0.08100108f, 0.04145784f, 0.01190900f, -0.00162904f, -0.00151014f, 0.02361188f, 
    0.06897529f, 0.06987377f, -0.04795310f, -0.02700236f, 0.42245319f, -0.02874847f, -0.07311726f, -0.11322570f, 
    -0.22979161f, 0.04525899f, -0.10893375f, 0.03054355f, 0.03228314f, -0.01412711f, -0.18592584f, -0.11028686f, 
    0.02083408f, 0.08002116f, -0.07496037f, -0.05478222f, 0.04398338f, 0.01262438f, -0.00939090f, 0.08744754f, 
    0.86591470f, -0.00945753f, -0.19311197f, -0.08214823f, 0.14154659f, 0.19025090f, -0.03316659f, 0.11794226f, 
    -0.18175000f, -0.21843606f, -0.22534674f, -0.03869410f, -0.00510913f, 0.07722232f, 0.02528594f, 0.01500149f, 
    0.06630630f, 0.01227393f, 0.05141229f, 0.14455196f, 0.09859048f, -0.07724301f, -0.15642738f, -0.03704368f, 
    0.24974275f, 0.01316267f, 0.09264061f, 0.00922582f, 0.03723868f, 0.02672385f, -0.03012875f, -0.01819213f, 
    -0.01201661f, -0.09880995f, 0.01634120f, -0.01323662f, -0.03909102f, -0.01673898f, 0.03129741f, -0.02904810f, 
    -0.06276626f, -0.20650445f, 0.51414686f, 0.06776854f, 0.18402167f, 0.02799971f, 0.19728674f, 0.02307231f, 
    -0.10178468f, -0.18701559f, 0.07884067f, -0.06861819f, 0.05778660f, -0.01717164f, -0.06754689f, -0.05212258f, 
    0.09367497f, 0.12957618f, -0.08029902f, -0.14134376f, 0.04351018f, -0.05107665f, -0.12418944f, -0.09119851f, 
    0.18876754f, 0.09199658f, 0.01770526f, -0.03377974f, -0.02072621f, 0.04271474f, -0.06413481f, -0.01330670f, 
    -0.13400254f, 0.06266322f, -0.02147695f, -0.04840091f, 0.00370502f, 0.04059255f, -0.03774368f, 0.02896465f, 
    -0.25690326f, 0.03569198f, -0.20990498f, 0.03132929f, -0.27554938f, -0.01665428f, -0.20718074f, -0.07048769f, 
    -0.08793992f, -0.09604050f, -0.03731400f, -0.08509113f, 0.08483888f, -0.03576742f, -0.04248950f, 0.03647079f, 
    -0.00872053f, -0.18931741f, -0.03639990f, 0.00590500f, -0.21020366f, -0.09860200f, -0.06258223f, -0.19106112f, 
    -0.37298086f, -0.01503005f, -0.16895661f, -0.00080658f, -0.08542989f, -0.16258617f, -0.02167460f, -0.01306177f, 
    0.06637275f, -0.06666384f, 0.02125069f, -0.00605143f, 0.03256991f, -0.09022288f, 0.09245045f, -0.04337395f, 
    -0.30432981f, -0.13777067f, 0.06161387f, 0.02769772f, -0.18630369f, -0.03989621f, -0.01961913f, 0.01547428f, 
    -0.11608393f, -0.10981542f, 0.01772396f, 0.09641305f, -0.08794210f, 0.15182218f, -0.09394564f, -0.00503421f, 
    -0.01780419f, 0.20171115f, -0.11803558f, 0.02030265f, -0.37024015f, 0.05453489f, 0.00930764f, 0.05140367f, 
    0.12190759f, -0.05086471f, -0.16933553f, -0.17887126f, -0.06816847f, -0.12305519f, -0.05875809f, 0.05366861f, 
    -0.15104215f, -0.10429907f, 0.03542591f, -0.01527033f, 0.00497188f, -0.00595743f, -0.10679097f, -0.03102818f, 
    0.05928437f, -0.07715561f, -0.00243879f, -0.24116264f, 0.09397938f, -0.14706959f, 0.04137309f, 0.02935843f, 
    0.06770344f, -0.01235175f, 0.02488911f, -0.01775432f, 0.01889534f, 0.00360441f, -0.00774295f, -0.04813986f, 
    0.17638329f, 0.00636544f, 0.17122796f, 0.39208394f, 0.13647383f, -0.28627113f, -0.17267837f, -0.03179142f, 
    -0.09333985f, 0.07769952f, -0.06694403f, 0.02718073f, 0.00100636f, -0.02127361f, 0.07540219f, -0.10224239f, 
    -0.02683566f, 0.02005419f, 0.03674217f, -0.12839252f, -0.18580364f, -0.01269468f, -0.09380198f, 0.02646195f, 
    -0.09553626f, 0.04084033f, -0.02745316f, 0.30017063f, 0.16613513f, 0.03090675f, 0.06640005f, -0.01654177f, 
    -0.03573291f, 0.10552295f, 0.06725981f, -0.04709167f, -0.00394930f, -0.00088233f, 0.02385158f, -0.02164254f, 
    -0.01799070f, -0.15654907f, -0.03216824f, -0.02964989f, 0.13201906f, -0.13985424f, 0.12191674f, 0.11245638f, 
    0.07115742f, -0.05625524f, -0.04172637f, -0.07518481f, 0.04853927f, -0.06121299f, 0.10017570f, -0.10877749f, 
    0.00978180f, -0.02900663f, 0.01596121f, 0.01017723f, 0.04894621f, 0.05996563f, -0.05868103f, -0.11985943f, 
    0.07793356f, -0.03512835f, 0.03322672f, 0.22841376f, 0.12752166f, -0.12885575f, -0.02600311f, 0.04813711f, 
    -0.23735307f, -0.00229709f, -0.11736560f, 0.00409901f, 0.00099344f, -0.01898048f, -0.05614724f, -0.00890387f, 
    0.01589162f, 0.01463193f, -0.05328634f, -0.01979479f, -0.52667320f, -0.14984123f, -0.02055959f, -0.32020733f, 
    -0.09330961f, 0.02786349f, 0.07238871f, -0.03342237f, -0.00682006f, 0.03169835f, -0.03570708f, -0.03664428f, 
    -0.03999019f, 0.15260406f, -0.04480010f, -0.05661056f, 0.00063062f, 0.06023839f, -0.02701395f, 0.04681524f, 
    0.09724897f, 0.06140533f, -0.01458628f, 0.14346683f, 0.11429119f, 0.06898052f, 0.04543816f, 0.05674944f, 
    0.03958469f, 0.00901676f, 0.01085455f, 0.02717002f, 0.01528623f, 0.02003814f, 0.03599287f, 0.01137268f, 
    -0.10912086f, -0.00554744f, 0.02243899f, 0.00040351f, 0.28386903f, -0.89791131f, -0.73029792f, 0.32996267f, 
    -0.56450081f, 0.08472983f, -0.03929564f, 0.02602333f, -0.03628414f, -0.01874543f, 0.10095917f, -0.04664199f, 
    0.01578162f, 0.06755784f, -0.01774304f, -0.01239538f, 0.08219058f, 0.03489843f, -0.13568115f, 0.12538679f, 
    0.09198565f, -0.00456530f, -0.14918056f, -0.10721523f, 0.21895531f, 0.01773470f, 0.03680998f, 0.00928406f, 
    0.07824587f, -0.03519651f, 0.00990900f, -0.01247698f, 0.02368554f, 0.03627656f, 0.03157814f, -0.04808789f, 
    -0.00942278f, 0.11395428f, -0.07489217f, -0.04853165f, -0.01727048f, 0.16034511f, 0.00424692f, -0.05702873f, 
    -0.00850350f, -0.03765422f, 0.08651005f, -0.03542223f, 0.10110741f, -0.03023156f, 0.08110575f, -0.00216515f, 
    -0.04156087f, -0.04001540f, 0.01671160f, 0.00901451f, 0.08149663f, 0.14119510f, -0.08113801f, -0.03090663f, 
    -0.16131097f, -0.06995071f, 0.13282166f, 0.07183518f, 0.08847890f, -0.11464462f, 0.06765719f, -0.04119049f, 
    0.00419594f, 0.00911532f, -0.02592846f, -0.01049528f, 0.01962859f, 0.07882948f, 0.05204706f, 0.07938491f, 
    0.12222341f, -0.06238241f, 0.04542557f, 0.07625213f, 0.30690694f, -0.35053864f, -0.12354419f, -0.05192322f, 
    -0.07333975f, 0.04048751f, -0.14909174f, -0.04760955f, 0.06313311f, -0.08954611f, -0.01667068f, -0.08533894f, 
    0.06985332f, -0.19600946f, 0.13206676f, -0.07219718f, -0.14900765f, -0.02967376f, -0.14810473f, -0.05117493f, 
    -0.24761665f, -0.03597380f, -0.06536484f, -0.29216903f, -0.01559003f, -0.09595451f, -0.01354200f, -0.09135060f, 
    0.15791227f, -0.08560921f, -0.01662006f, -0.05923314f, -0.11681382f, 0.10970710f, -0.03458434f, -0.10823162f, 
    0.00008800f, 0.08179528f, 0.09248210f, -0.07684048f, -0.04845335f, -0.03272408f, 0.00961858f, -0.11097939f, 
    -0.08270407f, 0.01407357f, 0.00964796f, -0.03631899f, 0.01918875f, -0.00584141f, 0.03276918f, -0.05824956f, 
    0.01378236f, -0.11489267f, 0.00034868f, 0.01307154f, -0.03779167f, -0.05557730f, -0.01067968f, 0.05227624f, 
    0.01354277f, 0.00583462f, 0.06299217f, -0.00365575f, 0.06989932f, -0.00221076f, 0.02010351f, 0.00059508f, 
    0.02826132f, 0.02925915f, 0.05684718f, -0.02132179f, 0.11506853f, -0.03792106f, 0.03635469f, -0.03403380f, 
    -0.07968976f, -0.06700759f, -0.01699316f, 0.01161670f, -0.17696205f, -0.09026305f, -0.06794505f, -0.13643219f, 
    -0.03578309f, -0.08522207f, -0.03838331f, -0.03013432f, 0.03422481f, -0.03185707f, -0.00978557f, -0.10882846f, 
    -0.03446045f, 0.01145341f, 0.03843337f, -0.20608464f, -0.21102065f, -0.01031787f, 0.01815934f, -0.15573820f, 
    0.03928795f, -0.08533256f, 0.14028765f, 0.03639216f, -0.07342081f, -0.04560709f, 0.00886750f, -0.00805480f, 
    -0.07540909f, -0.06737485f, 0.01859578f, -0.16431583f, -0.02223323f, 0.03344950f, -0.03548457f, 0.01887069f, 
    -0.00154598f, -0.02473946f, -0.04151819f, -0.06539163f, -0.50198197f, -0.05989406f, -0.09835432f, -0.43567628f, 
    -0.05677047f, 0.03740206f, 0.04166651f, -0.02982139f, -0.00123014f, 0.02243895f, -0.11403736f, -0.04488214f, 
    0.00764107f, 0.07275238f, -0.01575034f, -0.05863401f, 0.05466052f, 0.01461881f, -0.08041306f, 0.06923401f, 
    0.06981014f, 0.20972937f, 0.19691923f, 0.27685615f, 0.15204498f, -0.14566693f, -0.07665961f, -0.06664010f, 
    0.06273184f, 0.08733910f, 0.06698149f, 0.00092025f, -0.00046530f, 0.00546385f, 0.03272867f, -0.00680993f, 
    -0.00809317f, -0.10062099f, -0.06728664f, -0.09237663f, -0.00594598f, -0.02904131f, 0.01780249f, -0.15455364f, 
    -0.17088346f, 0.01020572f, 0.02845118f, 0.00170503f, 0.04440967f, 0.01881886f, 0.00748154f, -0.08169336f, 
    0.14297888f, -0.07937316f, 0.04816998f, -0.11265809f, 0.05143190f, -0.06159869f, -0.03522348f, -0.00228014f, 
    0.04842610f, -0.01340494f, -0.01083608f, -0.02156116f, -0.01393364f, 0.02798068f, 0.01273869f, 0.06927656f, 
    0.00189158f, 0.05017989f, 0.02867384f, -0.03461349f, -0.00121009f, 0.02133630f, 0.03736017f, 0.08063982f, 
    0.01709429f, 0.02084069f, -0.03024810f, -0.01025255f, 0.18800804f, 0.03801148f, 0.24647184f, -0.01863027f, 
    0.24172784f, 0.07317929f, 0.08751363f, 0.09594608f, 0.11933360f, 0.09924543f, -0.04557499f, 0.01462245f, 
    -0.04294781f, -0.07878105f, -0.02168181f, 0.04505491f, -0.04143281f, -0.07826192f, -0.03393590f, -0.03288954f, 
    0.05925858f, 0.03012384f, 0.05636083f, -0.04090132f, 0.08650126f, 0.09602947f, 0.07216395f, -0.05813264f, 
    -0.02274165f, 0.01422341f, -0.07057218f, 0.03519086f, 0.03016231f, 0.08370472f, 0.03138570f, 0.07081797f, 
    -0.07547997f, -0.03169401f, -0.12144882f, -0.04637859f, 0.13466738f, -0.07250440f, 0.13514313f, -0.09396257f, 
    -0.00659369f, 0.04836725f, 0.03060404f, 0.11389041f, -0.07013136f, -0.06761572f, 0.04391777f, -0.14501749f, 
    -0.10345044f, -0.09645628f, 0.01581665f, 0.01345283f, 0.00267578f, -0.04069672f, -0.06396757f, -0.14682503f, 
    0.11887623f, -0.08831646f, 0.04800623f, 0.11735743f, 0.05697312f, -0.14784716f, -0.09134567f, 0.05846054f, 
    -0.04369281f, 0.03921643f, 0.02660730f, -0.03406657f, -0.05997184f, 0.01299765f, 0.01287279f, -0.02227502f, 
    -0.04084166f, -0.02087901f, 0.01226869f, -0.03769795f, 0.12544368f, -0.16701603f, 0.00453280f, -0.16974041f, 
    0.00600302f, -0.01049964f, 0.00270249f, 0.03867584f, 0.07699080f, -0.14293945f, -0.00379892f, -0.03167190f, 
    -0.12932950f, 0.02006743f, 0.05360554f, -0.07042777f, -0.09081147f, -0.12264261f, -0.09738393f, -0.17733534f, 
    0.02937857f, -0.05813870f, -0.15572493f, -0.02581595f, 0.01563552f, 0.04037297f, 0.05957655f, 0.02544882f, 
    -0.00100067f, 0.02055555f, 0.01604453f, 0.07684004f, -0.01004083f, -0.02191836f, 0.01109049f, 0.03786875f, 
    -0.07440833f, 0.08120026f, -0.03562078f, -0.01846973f, -0.02097983f, 0.04268289f, 0.19008426f, 0.25123638f, 
    0.17199746f, -0.19873241f, 0.07044411f, 0.01692013f, 0.02751934f, 0.07103531f, -0.00337075f, -0.01077749f, 
    -0.02263084f, 0.06442647f, 0.06491289f, -0.06740763f, 0.00492982f, -0.08657015f, -0.04720615f, -0.00107795f, 
    0.07589498f, -0.03291214f, 0.23761623f, -0.03933771f, 0.20266373f, -0.01606226f, 0.01618002f, 0.04355361f, 
    0.10767297f, 0.08083066f, -0.07022478f, 0.01028035f, -0.07598259f, -0.00216345f, -0.02645789f, 0.01209528f, 
    -0.10046308f, -0.10085555f, -0.12202875f, -0.22737816f, -0.04214922f, 0.02004784f, 0.02185875f, 0.27796307f, 
    0.27791023f, 0.07899950f, 0.17185558f, 0.04803039f, 0.01431990f, 0.10476449f, 0.02557262f, -0.00510977f, 
    0.01520527f, -0.02172034f, 0.03989265f, -0.07714542f, -0.01074783f, -0.07218088f, 0.04983804f, -0.08658903f, 
    0.20724644f, 0.12778573f, 0.04046202f, -0.05969694f, 0.18318057f, -0.03075497f, 0.06346939f, 0.06008871f, 
    0.15405719f, 0.05703568f, 0.00368075f, 0.00940447f, 0.01267405f, -0.00043388f, -0.01395653f, 0.13094462f, 
    0.10073846f, 0.06941960f, 0.10819346f, 0.22358553f, 0.19366497f, -0.26495588f, -0.04076051f, -0.03414922f, 
    -0.22504415f, 0.07174975f, -0.04594459f, 0.00796222f, 0.02959117f, 0.04404885f, 0.04412333f, 0.02192972f, 
    -0.01863647f, -0.01663219f, -0.07352848f, -0.09206971f, 0.03126718f, 0.04587166f, -0.06078095f, 0.06928544f, 
    0.14999267f, 0.00671967f, 0.11383888f, 0.08476733f, 0.00181817f, 0.01960526f, -0.03171850f, -0.06284712f, 
    0.00471837f, -0.02440575f, 0.10099363f, 0.02596374f, 0.01486071f, 0.03506405f, 0.03402442f, 0.03846455f, 
    -0.04951385f, -0.00134334f, -0.03505358f, -0.07758937f, -0.03340790f, -0.02058271f, 0.10486085f, 0.13141945f, 
    0.11780217f, -0.12312697f, -0.01030654f, -0.04775594f, -0.09872722f, 0.00085474f, 0.01059147f, 0.04344389f, 
    -0.03019726f, 0.03199068f, -0.02673660f, 0.05218913f, 0.00723253f, -0.03635473f, -0.00731915f, 0.07650126f, 
    -0.03129455f, -0.48374075f, 0.33817387f, 0.02071390f, -0.29653671f, -0.01636735f, 0.06204564f, 0.04816191f, 
    -0.01674267f, 0.01237081f, 0.09615223f, -0.02322305f, -0.05327568f, 0.06858312f, -0.01543286f, -0.12504725f, 
    -0.10313939f, -0.06066799f, -0.23958297f, -0.05394911f, -0.04727609f, 0.03016126f, -0.13228996f, -0.09604190f, 
    0.09660456f, 0.07797733f, 0.03412394f, 0.05481201f, -0.01291938f, 0.02274147f, 0.05631648f, 0.00299311f, 
    0.05397270f, -0.03401013f, -0.01791719f, -0.01461856f, -0.03931859f, -0.01893523f, -0.07574128f, 0.01594516f, 
    0.09872811f, 0.12437317f, 0.04698495f, 0.13850383f, 0.02082101f, -0.01123386f, -0.04414076f, -0.03609226f, 
    -0.03707432f, 0.11517253f, 0.13518494f, -0.05345566f, 0.01302557f, 0.01559262f, 0.03427513f, 0.01822491f, 
    0.01502640f, -0.00332884f, -0.12633286f, -0.05059407f, 0.32164761f, 0.21430601f, -0.23501611f, 0.26824516f, 
    0.12028372f, 0.02292920f, 0.06192644f, 0.04321464f, 0.07899346f, 0.09862091f, 0.06810736f, 0.04533934f, 
    0.00660766f, -0.03412473f, 0.01739323f, 0.00677895f, 0.08334398f, 0.10807765f, -0.10494812f, 0.00767660f, 
    -0.05719940f, -0.21723104f, 0.23709217f, 0.09092458f, 0.02249677f, -0.21227267f, -0.09003807f, -0.03021504f, 
    -0.09923468f, 0.09176803f, 0.02730177f, 0.00315772f, -0.05590252f, -0.03103286f, -0.06358648f, 0.01804525f, 
    0.04172409f, 0.04575843f, -0.02517633f, 0.01956664f, 0.07374168f, -0.11282635f, 0.00286516f, -0.06247214f, 
    -0.00924112f, 0.04630282f, 0.04704094f, 0.05229026f, -0.06903220f, -0.02615062f, 0.04486806f, -0.12956002f, 
    0.00443217f, 0.05900049f, -0.04612616f, 0.05050362f, -0.01875326f, -0.12140323f, -0.09166881f, -0.05492303f, 
    0.13512009f, -0.19907181f, 0.03855148f, -0.48258746f, 0.03418422f, 0.08067593f, 0.09020431f, 0.01698522f, 
    0.08769635f, -0.01827801f, 0.02388971f, 0.04677433f, -0.01059745f, 0.02584263f, -0.07823133f, -0.11693476f, 
    -0.08046401f, -0.14889522f, -0.07266775f, -0.04388269f, 0.05585456f, 0.05666830f, 0.00631469f, 0.16102189f, 
    0.08694769f, 0.02504897f, 0.05032168f, 0.03743196f, 0.06751949f, 0.01575938f, 0.07411031f, 0.04003305f, 
    -0.00860957f, 0.02793640f, 0.08316361f, 0.00699410f, 0.05384037f, -0.06755311f, -0.00572473f, 0.10524616f, 
    -0.07873300f, -0.22041009f, 0.01300528f, 0.11850169f, 0.02991079f, -0.06453820f, -0.04863232f, 0.01147802f, 
    -0.29708463f, -0.10773027f, -0.07004000f, -0.00002061f, -0.05350609f, -0.13337086f, -0.30241394f, -0.05433325f, 
    -0.01466955f, -0.01023530f, 0.08589873f, 0.18359958f, 0.09645725f, -0.03801786f, -0.13190675f, -0.06341960f, 
    0.01209096f, 0.02555705f, -0.01951337f, 0.06616508f, 0.06648231f, 0.00013007f, 0.03409562f, -0.03090804f, 
    0.10291919f, -0.03322601f, 0.04218070f, -0.03997777f, -0.09171841f, -0.01032246f, -0.11791559f, -0.02351496f, 
    0.20340268f, 0.07386652f, 0.04406210f, 0.12337988f, 0.12161605f, 0.14127497f, 0.17512487f, 0.07194961f, 
    0.10983913f, 0.13300224f, 0.00506124f, 0.00113027f, -0.02954355f, -0.00489677f, -0.01210018f, 0.04488347f, 
    0.09269621f, -0.03814775f, 0.16490622f, 0.13362575f, 0.12361474f, 0.02094811f, 0.05230584f, 0.02057706f, 
    -0.01173633f, -0.02067581f, -0.06302286f, -0.07550950f, -0.04323671f, 0.11406561f, 0.09093729f, -0.07308628f, 
    -0.05568822f, -0.04742991f, -0.05053013f, 0.01713445f, 0.02639937f, 0.00853239f, -0.04922108f, -0.00706650f, 
    0.07750335f, -0.00051001f, 0.11093698f, 0.15500653f, 0.05696840f, -0.11844628f, -0.11357984f, -0.05297019f, 
    0.09969497f, -0.02027264f, 0.04033826f, -0.04143036f, 0.03521480f, -0.02216797f, 0.03053929f, -0.07893372f, 
    -0.09294418f, -0.00601573f, -0.04824911f, -0.06260093f, -0.18657431f, 0.13541946f, -0.04772546f, -0.33534947f, 
    -0.22946873f, 0.07542365f, 0.05224432f, 0.03239446f, -0.00374037f, 0.08028238f, 0.07985432f, 0.03151399f, 
    -0.01110966f, -0.03424001f, -0.00314778f, -0.00147804f, 0.11246698f, -0.10315248f, -0.19445843f, 0.08202567f, 
    0.09778983f, -0.17556894f, -0.05606697f, -0.08689154f, -0.02257044f, -0.07471786f, -0.08193818f, 0.04444496f, 
    0.00479669f, 0.04567999f, 0.04416567f, 0.03823122f, -0.04122659f, 0.01474534f, -0.10055216f, -0.05984380f, 
    -0.04400142f, 0.01700052f, 0.00277919f, -0.01591334f, 0.29034793f, -0.62724364f, 0.00375978f, 0.06102335f, 
    -0.09365853f, -0.02349487f, -0.26668915f, -0.08426102f, -0.00244149f, 0.05595775f, 0.02045982f, -0.06130056f, 
    0.01272948f, -0.03049177f, -0.00450371f, 0.04082662f, 0.05317094f, 0.00304251f, -0.20060539f, 0.05586392f, 
    -0.01893984f, -0.09699551f, 0.15207620f, 0.16805102f, 0.15421009f, -0.22211730f, 0.04375404f, 0.01083573f, 
    -0.06349944f, -0.05781069f, 0.01964613f, 0.00827412f, -0.03566688f, -0.04587825f, 0.03617356f, -0.04066035f, 
    0.01549116f, -0.00338032f, 0.02162908f, -0.03830875f, -0.03386107f, 0.06596161f, -0.07181957f, 0.03289229f, 
    -0.02292118f, 0.06048623f, 0.01063940f, 0.04355939f, -0.07706355f, 0.01690226f, -0.06525614f, 0.08952215f, 
    -0.06660899f, 0.05753952f, 0.02521342f, 0.03708274f, -0.07340441f, 0.01859604f, -0.01582813f, -0.06276593f, 
    0.08771902f, 0.14024670f, 0.07896891f, 0.14004865f, 0.01451101f, 0.00274841f, 0.00268360f, -0.10332613f, 
    -0.04493225f, 0.05479822f, 0.10233288f, 0.05941046f, 0.03594337f, 0.02913947f, 0.04483814f, 0.03574985f, 
    -0.02014240f, -0.02121683f, -0.05294186f, -0.09971160f, -0.36263549f, 0.05128716f, -0.17449354f, -0.13637911f, 
    -0.24643062f, 0.00506251f, -0.00251137f, 0.02766124f, 0.00392484f, 0.05096403f, 0.03292803f, -0.00777490f, 
    -0.02788777f, 0.01432532f, 0.03948829f, -0.08765434f, 0.10282977f, 0.09674817f, -0.09330381f, 0.14185725f, 
    0.00886827f, -0.04098868f, -0.03929362f, 0.00689531f, 0.04195742f, -0.05622155f, 0.06888895f, 0.00968939f, 
    0.00345733f, 0.00034389f, 0.05272301f, 0.03994643f, 0.03916642f, -0.02868255f, 0.03172152f, -0.07844685f, 
    -0.15120861f, 0.08586018f, -0.01217867f, 0.00313085f, -0.38526765f, 0.15247472f, -0.11528021f, -0.23991092f, 
    -0.08120047f, 0.06705805f, -0.02251818f, -0.01867871f, 0.09960064f, 0.05667717f, -0.05927085f, 0.02792869f, 
    -0.03381508f, -0.21198413f, 0.05334077f, 0.02182180f, -0.13963629f, 0.06492939f, -0.27360883f, 0.13432980f, 
    0.04226011f, -0.13117890f, 0.02848056f, -0.09936220f, 0.00843661f, -0.09588268f, -0.08509027f, -0.04766072f, 
    0.07338962f, 0.12607738f, 0.06369491f, -0.02097264f, 0.00946139f, -0.10790303f, -0.02886323f, -0.01902074f, 
    -0.02729112f, 0.02159017f, -0.04782156f, 0.01035999f, -0.10653679f, -0.03578584f, 0.13978219f, 0.12776840f, 
    0.05703678f, -0.04948775f, 0.01164040f, 0.03498913f, -0.00288728f, 0.09434456f, -0.00258755f, 0.00284710f, 
    0.01579083f, 0.09427098f, -0.00393181f, 0.06689936f, 0.12570693f, -0.06084513f, -0.00137192f, 0.10626040f, 
    -0.00075089f, 0.03384597f, -0.11217874f, 0.27658719f, -0.08835462f, 0.20030981f, -0.05396314f, -0.18633735f, 
    -0.01589690f, 0.07232517f, -0.07540014f, 0.01126203f, -0.08328409f, -0.01531432f, -0.01695765f, 0.01254947f, 
    -0.07540307f, -0.22227786f, -0.12093621f, -0.03569435f, 0.11028885f, 0.13689846f, 0.20758110f, 0.25363669f, 
    0.08676539f, -0.08783048f, -0.06138446f, 0.01887459f, -0.07886601f, 0.15252230f, 0.03304899f, -0.03239636f, 
    0.03626119f, -0.04406307f, 0.03752111f, -0.00902819f, -0.09425063f, -0.00141887f, -0.09030215f, -0.16799925f, 
    0.02430958f, 0.00365953f, -0.09402577f, -0.03792785f, -0.03319857f, 0.02630938f, 0.00035904f, 0.06070892f, 
    0.02454691f, 0.01567685f, -0.06740192f, -0.13720861f, 0.05580717f, -0.00751799f, 0.05653152f, 0.06100250f, 
    -0.02348205f, -0.01671303f, -0.03696259f, 0.04771110f, -0.02383802f, -0.02689400f, -0.08248439f, -0.03092198f, 
    -0.01564064f, 0.07126970f, 0.06511954f, 0.02264705f, -0.00182597f, -0.01975086f, 0.05358071f, 0.02407840f, 
    -0.07380037f, -0.04051330f, 0.08758249f, 0.02341532f, -0.12735750f, 0.00913987f, -0.03691858f, -0.02130011f, 
    0.06937312f, -0.05210526f, -0.00986600f, -0.09471992f, 0.03002557f, 0.00815647f, -0.03327214f, 0.10490062f, 
    -0.02881330f, -0.05951018f, 0.04612453f, 0.03518072f, 0.04870647f, -0.07581883f, 0.04172657f, 0.07745215f, 
    0.00450662f, -0.08936755f, -0.01589662f, 0.02313355f, -0.10111584f, -0.41586837f, 0.10300205f, -0.45598373f, 
    0.00639139f, -0.06414183f, 0.08461833f, 0.08000595f, 0.06859031f, -0.20135446f, -0.03188637f, -0.12153087f, 
    0.00780352f, -0.07180554f, -0.00162786f, -0.03795820f, -0.04343029f, -0.01943522f, -0.01268091f, -0.10850031f, 
    0.51355523f, -0.03881397f, 0.26135397f, 0.14403945f, -0.18039368f, -0.02647311f, 0.06153590f, -0.07980330f, 
    -0.04898765f, 0.09092364f, -0.05890581f, 0.05158076f, 0.02847419f, -0.00785185f, 0.03193642f, -0.18125136f, 
    -0.09880421f, -0.10254485f, 0.00147181f, -0.25402033f, -0.27473345f, 0.24112533f, -0.02180588f, 0.18208271f, 
    -0.03268989f, 0.02211722f, -0.09133305f, -0.04388411f, 0.06731211f, -0.00569722f, -0.05963036f, -0.02118645f, 
    -0.04754619f, 0.02919365f, 0.00049538f, 0.04505762f, 0.04128759f, 0.10949559f, -0.04968925f, -0.12209740f, 
    -0.19149470f, 0.00346445f, -0.03408866f, 0.17910153f, -0.17482427f, 0.05267929f, -0.23892261f, 0.14530227f, 
    0.03411291f, 0.00566087f, -0.08678985f, 0.00546127f, -0.06862871f, -0.04450800f, 0.03138829f, -0.01347893f, 
    0.04720110f, 0.21881869f, -0.17462206f, 0.02389251f, -0.10646210f, -0.09025861f, -0.05237654f, -0.08207831f, 
    -0.08481770f, 0.07283132f, -0.03632351f, -0.02450842f, 0.01193089f, 0.13106883f, -0.06975913f, 0.04041820f, 
    -0.10651100f, 0.09101585f, -0.09737878f, -0.01968757f, -0.01918590f, 0.07762014f, -0.03652442f, 0.13413569f, 
    -0.28291601f, -0.01741063f, -0.00887570f, -0.02069178f, -0.22254038f, 0.03323930f, 0.00508374f, 0.06178499f, 
    -0.05722337f, 0.02642979f, 0.07852114f, 0.00900845f, -0.11160614f, 0.03836852f, 0.04644509f, -0.05456560f, 
    -0.00928449f, -0.07739308f, 0.05563688f, 0.06370984f, -0.21048635f, 0.00432625f, -0.33257258f, -0.32333124f, 
    0.18745792f, -0.02322561f, -0.00603504f, -0.05416156f, -0.00729856f, 0.02929633f, -0.11565404f, 0.15878613f, 
    0.06225663f, -0.11492858f, 0.04936042f, -0.02813212f, -0.08581250f, 0.09157999f, 0.01549730f, 0.03623009f, 
    -0.12884888f, -0.09673304f, -0.08622172f, 0.00693024f, 0.15169467f, 0.05286292f, 0.05064654f, -0.02451364f, 
    -0.00981785f, -0.01864238f, 0.08671181f, -0.03827528f, -0.04618885f, -0.02297564f, -0.00743761f, -0.01188737f, 
    -0.05013031f, 0.02785135f, -0.05890368f, -0.04130944f, -0.77017993f, 0.39089051f, 0.37595505f, 0.05914465f, 
    -0.38548982f, 0.01174879f, -0.03604966f, -0.00395339f, 0.11072326f, 0.03578346f, -0.03989312f, -0.03808917f, 
    -0.09122317f, -0.04093872f, -0.03344908f, 0.02987847f, 0.02136639f, -0.00987652f, -0.06718052f, -0.14606418f, 
    -0.00098436f, -0.27030438f, -0.01571236f, 0.05533183f, 0.00893898f, 0.10074864f, 0.03291716f, -0.03530841f, 
    -0.06493043f, 0.09512591f, 0.08192669f, -0.01854922f, -0.00246086f, -0.03979469f, 0.00148941f, 0.00693821f, 
    -0.01948953f, 0.07520948f, -0.02934771f, -0.03750379f, -0.11493338f, -0.00408252f, 0.04281589f, 0.02448023f, 
    0.00032493f, 0.03900838f, -0.01323825f, -0.03253086f, -0.03771928f, 0.04338904f, -0.01661021f, -0.00100145f, 
    0.02652577f, 0.01690047f, 0.01072557f, -0.07991851f, 0.05872521f, 0.07909091f, 0.01611425f, 0.08859902f, 
    -0.17288728f, 0.02792777f, 0.07214124f, -0.11290362f, -0.10043900f, 0.06870380f, -0.05329347f, -0.04057659f, 
    0.00414712f, -0.00131263f, 0.02763897f, -0.02191809f, -0.03637230f, 0.08896094f, 0.01789003f, 0.05996498f, 
    -0.01070652f, -0.14590426f, -0.15968445f, -0.20195624f, -0.30486998f, 0.24561603f, -0.11397684f, 0.17520638f, 
    -0.03311969f, -0.02787190f, 0.04566482f, -0.19102037f, 0.01209963f, 0.11406258f, 0.00411365f, 0.02135361f, 
    -0.07049863f, -0.02184291f, -0.13594009f, 0.15306713f, -0.03059256f, 0.07740548f, 0.02049071f, 0.14133452f, 
    0.36398980f, -0.13594823f, -0.12053554f, -0.06820880f, 0.15042157f, -0.08136541f, 0.08540881f, -0.04269037f, 
    -0.07636406f, -0.15014990f, 0.02903144f, 0.02396880f, -0.13276100f, -0.07867778f, 0.11809916f, -0.15049234f, 
    -0.04262909f, 0.09173020f, 0.05016939f, -0.11104597f, 0.27129158f, -0.06458708f, -0.10375644f, -0.03547161f, 
    0.13442144f, 0.02312058f, 0.02587037f, -0.09479999f, -0.05844275f, 0.13362491f, -0.00512740f, -0.00283360f, 
    0.10110874f, 0.08788502f, 0.03420157f, -0.01649834f, 0.13141060f, -0.05742223f, 0.01275988f, 0.05268729f, 
    0.13921668f, 0.01446166f, -0.05457131f, 0.10258332f, -0.00991444f, -0.02480511f, -0.16971342f, -0.04619831f, 
    -0.11992857f, 0.07874487f, -0.17080389f, 0.01095562f, 0.04322410f, -0.11680633f, -0.03434966f, 0.04284259f, 
    0.08523660f, 0.00972489f, 0.01998818f, 0.09085177f, 0.02824351f, -0.35412082f, 0.08236963f, 0.19007343f, 
    -0.08429816f, 0.09071841f, -0.09249924f, -0.07408343f, 0.03957952f, 0.11780927f, -0.03709844f, -0.01813058f, 
    -0.03377467f, 0.04549868f, 0.11346601f, 0.09758699f, -0.12158664f, -0.02970633f, -0.06067281f, 0.26386461f, 
    -0.30883089f, 0.05196583f, 0.02184420f, -0.28782243f, -0.01042225f, 0.08337405f, 0.08460256f, 0.03996281f, 
    -0.08142034f, -0.12562244f, -0.02749201f, 0.05082189f, 0.02058850f, -0.15653838f, -0.07087068f, 0.01014037f, 
    -0.04996327f, 0.09813320f, -0.00354732f, -0.05541984f, -0.13720842f, -0.09220491f, -0.11888522f, -0.21473166f, 
    0.13410293f, 0.01144468f, -0.01388271f, -0.02266746f, -0.03554204f, 0.02914730f, 0.06629164f, 0.07769784f, 
    0.03146529f, -0.01666206f, 0.06167852f, -0.05543302f, -0.05773748f, -0.04794753f, 0.09050591f, 0.11877419f, 
    -0.01496372f, 0.11044081f, 0.23742588f, -0.10567675f, -0.12279995f, 0.06077550f, 0.08448340f, 0.16147423f, 
    0.22404364f, -0.14312965f, -0.01950970f, -0.06951829f, 0.06125918f, 0.03766016f, 0.03407115f, 0.01666516f, 
    -0.02573025f, -0.00259337f, 0.13072394f, 0.22295512f, 0.13730213f, 0.05373753f, -0.20095684f, 0.00629658f, 
    0.00250952f, -0.03107293f, -0.01423325f, -0.04654237f, -0.07088333f, 0.09754809f, 0.01729136f, -0.03690093f, 
    -0.09773515f, 0.03627329f, 0.05481511f, -0.11094632f, -0.16773425f, 0.14890252f, 0.08349001f, 0.19782552f, 
    -0.05216924f, -0.06962088f, -0.24587239f, -0.03356597f, 0.02393068f, 0.05832014f, 0.01475705f, -0.01691477f, 
    -0.03815903f, 0.01062678f, 0.00244540f, 0.06301342f, 0.09194938f, 0.07990290f, 0.03289820f, 0.02470143f, 
    0.04737469f, 0.18196709f, 0.03169410f, 0.00342244f, 0.06798699f, -0.00474221f, 0.21657535f, 0.06772442f, 
    -0.12070108f, 0.00694601f, 0.02705413f, -0.02666863f, 0.10519094f, 0.04580621f, 0.04149991f, -0.03147280f, 
    -0.00182724f, -0.01103618f, -0.01771868f, -0.05733641f, 0.01851270f, -0.05063390f, -0.08615748f, 0.22998428f, 
    0.11432206f, -0.00076811f, 0.04716074f, 0.01929376f, -0.05520528f, -0.02012798f, 0.03817704f, -0.01336200f, 
    0.03671990f, -0.05574256f, 0.16723870f, -0.13530749f, 0.08294381f, 0.00562053f, 0.05763734f, 0.03501141f, 
    0.05396988f, 0.04369941f, 0.19329524f, 0.17577372f, 0.09502079f, -0.04033088f, -0.04638630f, -0.04560304f, 
    0.03128549f, 0.01253049f, -0.05593853f, -0.08528544f, -0.06236857f, 0.11102329f, -0.17917018f, 0.05876848f, 
    -0.10857736f, 0.01016848f, -0.12445384f, -0.02638507f, 0.05259275f, 0.04080336f, 0.02310869f, 0.00880624f, 
    -0.23861718f, -0.19495621f, -0.14165044f, 0.03568937f, -0.19795604f, 0.08224413f, -0.05605868f, -0.10719982f, 
    0.06139718f, 0.09343286f, 0.14159246f, -0.02694176f, 0.02996588f, -0.08147048f, 0.02417203f, -0.00039316f, 
    0.03787789f, 0.02094174f, 0.02869136f, 0.08711038f, 0.20436542f, -0.03742996f, 0.20123024f, -0.23351321f, 
    0.16028871f, 0.04782137f, 0.01638229f, 0.11597010f, 0.04101501f, -0.04178859f, 0.12902850f, -0.07199440f, 
    -0.01289817f, -0.04833866f, 0.08952399f, -0.05237502f, 0.10334084f, -0.00846661f, 0.05708099f, 0.02882080f, 
    0.05368026f, -0.15169935f, -0.20259652f, 0.12864786f, 0.10328522f, -0.01365643f, 0.03546504f, -0.00006623f, 
    -0.01197672f, -0.00864402f, 0.08237585f, -0.04177502f, 0.02661376f, 0.00414160f, -0.01680043f, 0.06516059f, 
    -0.08623192f, 0.05464685f, 0.01547756f, -0.02776948f, 0.19677618f, -0.11112855f, 0.26083931f, 0.11801823f, 
    -0.33694738f, 0.34293053f, 0.17941983f, -0.03800870f, -0.08009131f, -0.01859179f, 0.06985015f, 0.00300722f, 
    0.01203719f, 0.04772065f, 0.06850644f, -0.00960875f, 0.06450492f, -0.07897438f, 0.00682125f, 0.11435259f, 
    0.20965476f, -0.11172588f, 0.23737431f, -0.15993717f, -0.15398087f, 0.01641618f, 0.04767748f, 0.02554935f, 
    0.07603083f, 0.00644777f, 0.00016676f, -0.02287247f, 0.03947905f, -0.02316471f, -0.02596787f, 0.02830645f, 
    0.04227567f, -0.09870567f, -0.00894229f, 0.33493495f, -0.09897693f, 0.08566415f, -0.18867266f, 0.05344979f, 
    -0.17056836f, -0.05146904f, -0.16607548f, 0.01543508f, -0.01452394f, 0.09142993f, -0.01604103f, 0.01974493f, 
    -0.00779641f, -0.06353600f, -0.00342724f, 0.04022621f, 0.03649938f, 0.20471938f, -0.12140439f, -0.07131633f, 
    0.04530664f, 0.04879656f, 0.08501271f, 0.13232391f, 0.02227992f, 0.07729259f, 0.07379672f, -0.04883180f, 
    -0.03611147f, 0.05680335f, 0.04878815f, 0.05246721f, 0.01111973f, 0.00306130f, -0.00478473f, -0.24161255f, 
    0.01239555f, -0.09719270f, -0.14554624f, -0.21663007f, -0.21610622f, 0.35655671f, -0.08712275f, 0.03763119f, 
    0.00742546f, -0.01170955f, -0.04161183f, 0.00461800f, 0.00959724f, -0.03539375f, 0.03208170f, -0.03324280f, 
    -0.10489065f, -0.02768492f, -0.08472184f, -0.11007270f, -0.03508014f, 0.09054899f, 0.04981244f, -0.11297242f, 
    0.11598790f, -0.07376289f, 0.04278608f, -0.03500865f, -0.17246531f, 0.04258301f, -0.00915712f, 0.00447326f, 
    -0.00084734f, -0.05901890f, 0.07779641f, -0.06494430f, -0.02591301f, -0.00446176f, -0.01944951f, -0.03460327f, 
    0.05802489f, 0.01313131f, -0.00037863f, 0.06667440f, -0.02970782f, -0.03676675f, -0.01615323f, 0.03032710f, 
    -0.14639540f, 0.00682844f, 0.08981470f, 0.06171120f, -0.00961655f, -0.02352035f, 0.02636871f, -0.05485165f, 
    -0.02180778f, -0.01033335f, -0.03096657f, -0.08695807f, 0.03683545f, 0.01519991f, 0.06212983f, -0.04914883f, 
    -0.52346075f, 0.08055443f, 0.04587775f, -0.12797806f, 0.00680273f, -0.04898879f, -0.04990518f, -0.12460629f, 
    -0.08527157f, 0.08011262f, -0.01815630f, 0.11257710f, -0.12467094f, -0.11382803f, -0.00690175f, -0.01738312f, 
    -0.26446071f, 0.00656237f, 0.10785635f, -0.04469861f, 0.40547958f, -0.01435907f, -0.34443143f, -0.40093786f, 
    0.20828284f, 0.02135635f, 0.11531927f, -0.01862383f, 0.01242876f, -0.00001370f, 0.07950740f, 0.03024182f, 
    0.01642498f, -0.05459172f, -0.02749789f, 0.00232580f, -0.02204189f, -0.14419077f, -0.09163962f, -0.02385272f, 
    -0.14165649f, 0.07820747f, 0.07998208f, -0.22199057f, -0.06381687f, -0.00419216f, -0.01815144f, 0.06773465f, 
    -0.01283602f, -0.02510413f, 0.13656032f, -0.02663087f, -0.02073882f, -0.06597012f, -0.00593973f, -0.00356103f, 
    0.02994278f, 0.06121243f, 0.00493862f, 0.05210259f, -0.10958660f, -0.13998577f, -0.23413895f, 0.07066830f, 
    0.00222606f, 0.11916235f, 0.08117803f, -0.00137003f, 0.02935679f, 0.02606460f, -0.00798514f, 0.03503184f, 
    0.02734214f, 0.02312415f, -0.02001174f, -0.14160326f, -0.09803765f, 0.11920560f, 0.09587632f, -0.04696613f, 
    -0.14081270f, -0.04287730f, -0.20737067f, -0.30605254f, -0.18214890f, -0.01465309f, 0.00284588f, -0.01686341f, 
    -0.03267571f, -0.11784774f, -0.05101747f, 0.01798001f, -0.08526821f, 0.08151677f, 0.09986380f, -0.08290911f, 
    -0.02959121f, 0.05359114f, 0.00334313f, -0.03138366f, -0.11122720f, -0.02467150f, -0.11859933f, -0.18142794f, 
    0.12328263f, 0.09316586f, 0.05848119f, 0.00911268f, -0.05842633f, -0.01007104f, 0.01058826f, -0.01849653f, 
    -0.03327388f, -0.09257647f, -0.05987484f, 0.04557886f, 0.04327877f, 0.09970746f, 0.03111855f, -0.00564178f, 
    -0.08902361f, 0.20167530f, 0.09634318f, -0.27510664f, 0.03960645f, -0.07026146f, -0.02548489f, -0.09796822f, 
    -0.01338844f, 0.02656803f, 0.10509565f, 0.00994088f, -0.05385203f, -0.13271984f, 0.02657728f, -0.05121875f, 
    -0.05939450f, 0.06866325f, 0.15967821f, -0.04914673f, -0.23262270f, -0.08425362f, 0.00483453f, 0.15219955f, 
    0.03774675f, 0.06103955f, 0.00632763f, -0.04880808f, -0.00579873f, 0.06594428f, -0.07757410f, -0.01586330f, 
    -0.01559770f, 0.00827258f, -0.02660038f, -0.08150540f, -0.03875289f, 0.05700390f, 0.08098282f, 0.03336325f, 
    -0.11506042f, 0.01071488f, 0.18647343f, -0.05807594f, -0.17516285f, -0.11800759f, 0.08993516f, 0.09613097f, 
    -0.09285519f, -0.11490166f, -0.03912292f, -0.05734323f, -0.03989747f, 0.08215167f, 0.08645123f, -0.02738910f, 
    -0.03180689f, -0.04141739f, 0.02696325f, -0.07379279f, -0.07911803f, 0.13578187f, -0.22337013f, 0.12632431f, 
    0.09210211f, 0.05602143f, -0.21428984f, -0.09443370f, 0.02261326f, 0.07245132f, -0.14729118f, 0.19108216f, 
    0.00021290f, -0.03749238f, -0.00743154f, 0.12841918f, -0.12537602f, 0.16108611f, 0.04572146f, 0.02212203f, 
    0.05491374f, 0.10650327f, 0.16079704f, 0.07509765f, -0.03670702f, -0.05683738f, 0.03753845f, -0.02219352f, 
    0.05621263f, 0.04366973f, 0.08353947f, 0.07469031f, 0.00609381f, -0.01982642f, -0.03597888f, -0.01302769f, 
    0.00246876f, 0.02820194f, -0.19998252f, -0.15231302f, -0.30388823f, 0.14736778f, -0.13268000f, -0.13636714f, 
    -0.02764462f, -0.03861039f, 0.06893836f, 0.02096559f, -0.03247773f, 0.11760667f, 0.08495472f, 0.10265551f, 
    -0.08167007f, 0.06912577f, 0.03038044f, -0.03078770f, -0.00492460f, 0.09097167f, -0.02505398f, 0.03364742f, 
    0.12809771f, -0.11242723f, 0.13804343f, 0.13443379f, -0.23136520f, 0.15450315f, 0.03872760f, -0.02496204f, 
    -0.02281904f, 0.23033661f, 0.00763336f, 0.01616470f, -0.07442887f, -0.01527406f, -0.02580223f, 0.01988008f, 
    0.11624744f, -0.02052461f, 0.02777335f, 0.16023724f, -0.45215836f, -0.13067739f, -0.14023316f, -0.17659438f, 
    0.29077756f, 0.04159772f, -0.00827362f, -0.03774620f, -0.01333280f, -0.04210001f, 0.13837098f, -0.22524031f, 
    0.08275864f, -0.16553882f, -0.02573620f, 0.01653468f, -0.08885755f, -0.06163906f, -0.04250870f, -0.15538837f, 
    -0.15546921f, -0.20444594f, -0.11346608f, -0.00369260f, -0.05848220f, 0.03821191f, -0.12154860f, -0.11663490f, 
    -0.01191579f, -0.01766897f, 0.00389185f, 0.06179438f, -0.10829844f, -0.05469272f, 0.02583420f, -0.01632083f, 
    -0.03480163f, 0.06780238f, 0.04017863f, 0.14781263f, -0.73906487f, 0.62957180f, -0.03988456f, -0.41553017f, 
    -0.14154956f, -0.03900169f, 0.00489609f, 0.09996118f, 0.04990470f, -0.04719151f, 0.07584214f, 0.09453533f, 
    -0.07778405f, 0.03285968f, -0.03901900f, -0.03100721f, -0.12891607f, 0.07402809f, 0.12686901f, -0.00889317f, 
    -0.25493199f, -0.02530205f, -0.21621843f, -0.15088058f, -0.19426665f, 0.14271393f, -0.05761105f, 0.01406547f, 
    -0.20494242f, 0.14232203f, -0.00274255f, -0.05201825f, 0.02196829f, -0.01102987f, -0.06937231f, -0.12084145f, 
    -0.07428617f, 0.04764500f, -0.00722376f, -0.00393241f, -0.03803582f, -0.09159894f, 0.10399010f, 0.04984855f, 
    -0.22578810f, -0.12338682f, 0.00365879f, -0.08266616f, -0.02402035f, 0.05615287f, 0.32220635f, -0.06947214f, 
    -0.12182442f, -0.04431384f, 0.10414280f, 0.10374360f, 0.05481713f, -0.03015648f, 0.01818606f, 0.12403050f, 
    0.05851887f, 0.06174573f, 0.09684584f, 0.03335562f, -0.14893439f, -0.06068099f, -0.14143422f, 0.00962978f, 
    0.00374958f, -0.01284718f, -0.01392755f, -0.13168636f, -0.05591770f, -0.07539047f, -0.00530828f, 0.00534911f, 
    0.10967690f, 0.02558831f, 0.02280348f, 0.05582442f, 0.28847542f, 0.05191876f, -0.07439633f, -0.33434430f, 
    0.07687594f, 0.06185381f, 0.09195568f, -0.02675273f, -0.01427037f, 0.06086303f, 0.01890303f, -0.07272942f, 
    0.02248391f, -0.01290482f, 0.01349199f, 0.08384454f, -0.02879264f, -0.19124295f, 0.05424440f, -0.07966881f, 
    0.50405461f, -0.04909578f, -0.31972018f, -0.02612012f, 0.13143875f, -0.01413444f, 0.21404257f, 0.08740395f, 
    -0.00213561f, 0.08060315f, 0.04459469f, -0.04290480f, -0.02574791f, -0.01970726f, 0.05182628f, 0.00879104f, 
    0.00468950f, 0.03004698f, -0.13209677f, 0.07945258f, 0.09224007f, 0.08893006f, -0.16081025f, 0.09747116f, 
    0.18732637f, 0.01334687f, -0.08406717f, 0.00617222f, -0.01592869f, 0.02872330f, 0.04097958f, -0.11934581f, 
    0.01693813f, 0.04419511f, 0.01773103f, -0.04992088f, -0.01594418f, 0.08867468f, 0.05824373f, -0.25296301f, 
    -0.36203623f, 0.50194901f, -0.46675456f, 0.11585033f, -0.09731139f, -0.03612174f, -0.06227060f, -0.06774971f, 
    0.05377885f, 0.13260522f, 0.09867573f, -0.08605860f, 0.02704328f, 0.01574952f, -0.02768215f, -0.03755140f, 
    0.02219707f, 0.08105101f, -0.05804967f, -0.06396684f, -0.12360924f, 0.05985527f, 0.20011875f, 0.11798471f, 
    -0.08100457f, -0.02009271f, 0.04395666f, 0.06081393f, 0.08424279f, -0.13003899f, 0.04069851f, 0.01414816f, 
    0.01981313f, 0.08841714f, -0.01082184f, 0.00754050f, -0.00647297f, -0.17018414f, -0.08993011f, -0.26328823f, 
    0.14262991f, -0.06184506f, 0.22957775f, -0.14437008f, -0.07484761f, 0.17066398f, 0.05994794f, 0.25184396f, 
    -0.07073825f, -0.04993056f, 0.06315518f, -0.06912944f, -0.03782067f, -0.00235509f, 0.10553854f, 0.08641274f, 
    0.05681711f, 0.08613534f, 0.00897667f, 0.13996387f, -0.02779389f, 0.07644071f, 0.25113586f, -0.04124591f, 
    0.00321099f, 0.04555240f, 0.00859218f, 0.13454410f, -0.02498006f, -0.31097159f, -0.03683174f, -0.03753243f, 
    0.05143242f, 0.03282859f, 0.02828511f, 0.05543913f, -0.01909688f, -0.07203173f, -0.06410941f, 0.14193322f, 
    -0.11347682f, 0.04206011f, -0.15757979f, -0.09329879f, 0.13739403f, 0.05186781f, 0.04382250f, -0.05949638f, 
    -0.04007324f, -0.01244576f, 0.15065636f, 0.15887198f, 0.05028797f, 0.11113634f, 0.06437475f, 0.01184690f, 
    0.02728974f, 0.17189389f, 0.11933981f, -0.06457685f, -0.07482174f, -0.10558526f, -0.20019031f, 0.08020545f, 
    0.03409147f, 0.06863112f, -0.05388101f, -0.02374005f, 0.01570014f, 0.02365600f, -0.00460008f, -0.00484992f, 
    0.11182841f, 0.00400815f, -0.10119597f, 0.13091208f, 0.07197718f, 0.14345533f, -0.03235965f, 0.02986106f, 
    -0.08816388f, 0.00390139f, -0.11769965f, 0.01775588f, 0.08465348f, 0.03523375f, 0.03009423f, -0.14269182f, 
    -0.09670694f, 0.08873953f, 0.03694642f, 0.08478042f, -0.01905846f, -0.00497372f, 0.02984303f, -0.00747210f, 
    -0.04842179f, -0.07727078f, 0.10259621f, 0.05300165f, 0.14891087f, -0.33875021f, 0.18871221f, -0.13387933f, 
    -0.02695854f, 0.13742658f, -0.07982481f, -0.15604423f, 0.06545549f, 0.11853506f, 0.04629169f, 0.03171471f, 
    0.08421202f, -0.01333781f, 0.07057502f, -0.04658330f, 0.05300841f, 0.00283690f, 0.16370219f, 0.13717128f, 
    -0.07708918f, -0.14429943f, -0.09427181f, -0.05710119f, -0.09653899f, 0.02928247f, 0.10186939f, 0.03454935f, 
    0.06254248f, 0.03670442f, -0.03069937f, -0.04150235f, 0.00403405f, 0.06997241f, -0.00681745f, 0.10444295f, 
    0.01391285f, 0.12011701f, 0.20094091f, 0.00300567f, -0.03870835f, 0.03010568f, 0.06166049f, -0.00247719f, 
    0.11280716f, -0.01365168f, -0.01521677f, 0.01196753f, -0.02057967f, 0.08015697f, -0.05086441f, 0.00839006f, 
    0.04879076f, -0.00917493f, -0.00158336f, -0.06577516f, 0.14104685f, -0.08861846f, 0.02030262f, -0.02692658f, 
    0.18535174f, -0.42184556f, -0.33718234f, -0.18729974f, 0.27650073f, -0.09665868f, 0.11578970f, 0.13156112f, 
    0.04049997f, -0.07018100f, -0.01455642f, 0.02672124f, -0.06834478f, -0.07399097f, 0.06255368f, -0.01796199f, 
    0.03953242f, -0.01144113f, 0.21400025f, -0.04970320f, -0.39684185f, 0.40057722f, 0.31268534f, -0.07677877f, 
    0.11645171f, -0.13836563f, -0.01198981f, -0.10235815f, -0.10969658f, 0.05844017f, 0.04957049f, 0.01263667f, 
    -0.03987012f, 0.04162102f, 0.00298759f, 0.01661346f, -0.03258026f, 0.00900351f, -0.01957945f, -0.04626162f, 
    -0.35521910f, 0.03518616f, 0.43057567f, -0.08098637f, 0.11967477f, -0.05603974f, -0.17926925f, -0.09357350f, 
    -0.11265451f, 0.02148103f, -0.08902869f, 0.01665349f, -0.01824339f, 0.01652712f, -0.00968244f, 0.01798115f, 
    0.03026310f, -0.02089372f, 0.06449259f, 0.02777435f, -0.17128105f, 0.14964409f, -0.02835170f, -0.01172155f, 
    0.27711394f, 0.01015894f, -0.02694361f, -0.00594461f, 0.03751813f, -0.01945500f, 0.11739169f, 0.09699345f, 
    0.12971182f, 0.02376006f, -0.00017784f, 0.04947537f, 0.02285705f, 0.01836549f, 0.05290407f, 0.01449502f, 
    0.06591900f, -0.12203667f, -0.06782634f, -0.08906206f, 0.00096884f, -0.00922948f, 0.04409314f, 0.04642427f, 
    -0.01275221f, 0.00764651f, -0.01831892f, -0.06379373f, -0.02009395f, -0.05726674f, -0.04857362f, -0.02680607f, 
    -0.04257924f, -0.00975080f, -0.02275274f, 0.04821783f, -0.16085593f, 0.02622393f, -0.15095294f, -0.00756711f, 
    -0.03997521f, -0.03927524f, 0.03047339f, -0.01639904f, -0.04547643f, 0.08431391f, -0.04488910f, 0.03447475f, 
    0.04685701f, 0.01070390f, -0.00868449f, -0.04359844f, -0.05311393f, -0.08029052f, 0.13260019f, -0.05971209f, 
    0.15218784f, 0.02218715f, -0.15197289f, -0.17014830f, -0.07529889f, -0.02364466f, 0.00315466f, 0.12413570f, 
    0.00490010f, -0.03947575f, 0.00408348f, -0.00222173f, -0.01819860f, -0.02545826f, 0.00560339f, 0.08262326f, 
    0.06328846f, -0.02964512f, -0.06737801f, 0.10213303f, -0.22332743f, -0.36187783f, -0.09789281f, 0.15852576f, 
    -0.00002008f, -0.00476622f, 0.02061078f, 0.13555434f, -0.05001881f, -0.09595387f, 0.00951947f, -0.01677418f, 
    -0.02455938f, 0.03444938f, 0.00760653f, 0.00167327f, 0.10025102f, 0.10207079f, -0.03174611f, 0.01072376f, 
    -0.34793350f, -0.45595846f, -0.74377286f, -0.24111573f, -0.00667944f, -0.14537881f, -0.18942197f, -0.18748109f, 
    -0.22918338f, -0.17614104f, -0.04329540f, 0.01995243f, -0.02053687f, 0.03398092f, -0.08075429f, -0.05665684f, 
    -0.02793312f, 0.09148768f, 0.08471058f, -0.05778409f, -0.07739698f, 0.05633433f, -0.01688424f, -0.06230327f, 
    0.22581212f, -0.01030634f, 0.01813075f, 0.07017971f, -0.00762360f, 0.17706086f, 0.09943554f, 0.10064016f, 
    0.06464787f, 0.00243298f, 0.03554354f, 0.00088154f, 0.08644604f, -0.06828874f, 0.03879213f, 0.01074366f, 
    -0.55030382f, 0.28201884f, -0.20868854f, -0.07862691f, 0.24948889f, 0.06042687f, 0.03426078f, 0.00328733f, 
    0.07947641f, -0.00915098f, 0.14413880f, 0.02566753f, 0.04780593f, 0.04018283f, -0.12676898f, 0.01209770f, 
    0.12613882f, -0.01908904f, 0.17084776f, -0.01259516f, 0.05118218f, 0.07810977f, -0.02493287f, 0.07226884f, 
    0.03156281f, 0.01181093f, -0.02767219f, -0.00482583f, 0.06909274f, 0.02872656f, -0.01135467f, 0.00459152f, 
    0.10373038f, -0.12606168f, -0.01307730f, -0.00267690f, 0.00315825f, -0.12826371f, -0.00036509f, -0.04207228f, 
    0.18362726f, 0.09175983f, -0.12573959f, -0.07673257f, 0.08352347f, -0.03851853f, -0.01421638f, -0.09272142f, 
    0.11429679f, 0.03348511f, 0.05308617f, -0.01399423f, -0.03835615f, -0.09991029f, 0.02975524f, -0.03333395f, 
    -0.04042302f, -0.06716289f, 0.03624646f, -0.01716683f, -0.01330033f, 0.00674237f, -0.09380256f, -0.06072032f, 
    0.12619601f, 0.02610770f, 0.11154451f, 0.05316675f, 0.03129586f, 0.13108738f, 0.02617430f, -0.04306463f, 
    -0.05751186f, 0.08751164f, 0.06684917f, 0.05333832f, 0.07736381f, -0.04167397f, 0.07817696f, -0.01746244f, 
    -0.15446696f, 0.22344269f, 0.11677841f, 0.14738192f, 0.02213820f, 0.04254075f, 0.03390203f, 0.04493770f, 
    -0.06662247f, -0.10530122f, -0.07673290f, 0.01936855f, 0.13172907f, 0.05611817f, 0.05757093f, 0.03049537f, 
    -0.01791527f, 0.03430314f, -0.11241795f, -0.04409105f, -0.13643312f, 0.10121670f, -0.02636917f, -0.14851470f, 
    0.28518277f, -0.01165203f, 0.01157804f, -0.00621108f, 0.03695339f, -0.03103476f, 0.11891051f, 0.05149467f, 
    0.04483755f, -0.02881704f, -0.03742388f, 0.03667650f, 0.08764686f, -0.07117902f, 0.11793555f, -0.05929761f, 
    -0.79165727f, -0.62582165f, -0.19740012f, -0.35476708f, 0.01145764f, -0.20522594f, -0.15445752f, -0.12711450f, 
    -0.09301738f, -0.21216728f, -0.00974724f, -0.01330291f, 0.00491635f, 0.02037999f, 0.03793741f, -0.00291248f, 
    -0.03488673f, 0.07591386f, 0.02662913f, -0.00721117f, -0.04613828f, 0.05428025f, 0.05065789f, -0.11451156f, 
    0.12010922f, -0.03870348f, -0.03494323f, -0.01613643f, -0.01209665f, 0.00843449f, 0.02092969f, 0.03498704f, 
    0.02174266f, 0.12428689f, 0.03863890f, -0.00303059f, -0.03102097f, 0.08449078f, -0.12735498f, 0.00054470f, 
    0.05429936f, 0.06950625f, -0.02361007f, -0.05311829f, 0.02190836f, 0.02279845f, -0.01610785f, -0.03271746f, 
    -0.00385954f, 0.02601847f, -0.00062812f, 0.01494665f, 0.02652602f, -0.05268339f, 0.00791755f, 0.01445761f, 
    -0.08429283f, -0.08538833f, -0.10380714f, -0.01446480f, 0.28093517f, -0.50400627f, -0.69205654f, -0.16633651f, 
    0.05056050f, -0.05406511f, 0.06676524f, 0.05206459f, 0.04610975f, -0.33246991f, 0.05077927f, -0.01559252f, 
    -0.10287799f, 0.00635793f, 0.10043769f, -0.05444170f, -0.03625309f, 0.15887599f, -0.00389604f, -0.04860485f, 
    -0.06043398f, -0.15923163f, 0.04200482f, 0.00469824f, -0.00410800f, 0.01861052f, 0.07029942f, -0.05529130f, 
    0.01838409f, 0.00240220f, 0.01976341f, -0.09744471f, -0.19412494f, -0.01157384f, 0.03210430f, -0.01186801f, 
    -0.02932854f, -0.05353383f, 0.05523862f, -0.09527709f, 0.13627930f, 0.25634870f, -0.00518215f, -0.04067719f, 
    0.01793908f, -0.04455983f, 0.05234222f, -0.14024869f, -0.05914534f, -0.01850383f, 0.08750575f, -0.05150886f, 
    -0.10314489f, -0.10161388f, 0.05626965f, 0.00981239f, -0.03969181f, -0.02098620f, 0.04157949f, -0.11234012f, 
    -0.35929313f, 0.21842249f, 0.25143990f, 0.00774320f, 0.00489998f, -0.07975119f, 0.00349362f, -0.05269843f, 
    -0.06606247f, 0.30413294f, -0.15869494f, 0.06006674f, 0.05224681f, 0.04727855f, 0.09445599f, -0.02768412f, 
    0.00535172f, -0.07660992f, 0.02592753f, 0.00485789f, -0.01757151f, 0.11109534f, -0.05472127f, 0.20187998f, 
    -0.15484531f, 0.14939147f, 0.11718219f, 0.04719186f, 0.04809650f, -0.07044549f, 0.06468548f, 0.00097808f, 
    -0.00918593f, 0.04971864f, 0.05534017f, 0.07808736f, 0.01877405f, 0.15282504f, -0.01771641f, 0.04274219f, 
    0.05350899f, -0.04138030f, 0.06234588f, -0.01555031f, -0.00839352f, 0.01435334f, 0.02734763f, 0.03381412f, 
    0.01137249f, 0.01032293f, -0.04720473f, -0.00608829f, -0.07590296f, -0.00926020f, -0.02595295f, -0.10668433f, 
    -0.00028217f, -0.01274222f, -0.06611847f, 0.02412365f, -0.78994638f, -0.82437783f, -0.53912097f, -0.24055891f, 
    0.25909573f, -0.11744723f, -0.12103358f, -0.13048901f, -0.14839233f, -0.22231010f, -0.03196409f, -0.03115619f, 
    -0.04290862f, 0.01473979f, -0.02987648f, -0.02600483f, -0.00728418f, 0.02945342f, 0.27818340f, 0.11195421f, 
    -0.04706778f, -0.09556322f, -0.29165566f, 0.03297147f, 0.12001523f, 0.02171656f, -0.05412882f, -0.16874479f, 
    0.12092943f, -0.26082283f, 0.04551303f, -0.00097643f, -0.14123902f, 0.01275410f, 0.05344278f, 0.00389552f, 
    -0.02975941f, 0.10564410f, -0.01071635f, -0.09422888f, 0.27514774f, -0.54022002f, -0.55029190f, -0.11928870f, 
    0.20832790f, -0.10886722f, 0.11500484f, 0.22213580f, 0.12268449f, -0.18858095f, -0.02401815f, -0.02302445f, 
    -0.03038076f, -0.02130273f, 0.02780995f, 0.01108035f, 0.03168032f, 0.01155431f, 0.16613857f, 0.02456201f, 
    -0.44114080f, -0.26495495f, -0.32073000f, -0.10383973f, -0.05194988f, -0.04353751f, 0.10660506f, 0.11176765f, 
    -0.00606992f, -0.05154938f, 0.00429965f, -0.01789230f, -0.00732022f, 0.03786577f, 0.03959767f, -0.04819540f, 
    -0.05592832f, 0.03786311f, 0.09971279f, 0.01540205f, 0.01918200f, 0.01049834f, 0.08993960f, -0.04948014f, 
    -0.03524283f, -0.01007601f, 0.00988711f, -0.02440924f, -0.02540486f, 0.06038853f, -0.00875346f, 0.00546906f, 
    0.03740608f, -0.00703131f, -0.04090156f, -0.02142254f, 0.04430155f, -0.00541528f, 0.02796525f, 0.02840930f, 
    -0.17407516f, 0.20850438f, 0.26305211f, -0.01006184f, -0.00801253f, -0.10502785f, -0.05980933f, -0.11496729f, 
    -0.09400298f, -0.03173944f, -0.11896621f, 0.00352334f, -0.05000862f, 0.00512009f, 0.03105367f, 0.00060052f, 
    -0.06377365f, -0.01752224f, -0.01473645f, -0.07231721f, -0.67200273f, -0.57126361f, -0.37620750f, -0.18324792f, 
    -0.17542402f, -0.20668669f, -0.06589521f, -0.07448148f, -0.11661204f, -0.16123222f, -0.00723915f, 0.00673429f, 
    0.02419020f, -0.03429263f, 0.00191913f, 0.01371625f, -0.01047311f, 0.02164782f, 0.11593246f, -0.11275144f, 
    -0.17554718f, 0.12035857f, 0.11799230f, -0.00207828f, 0.11785515f, -0.00931821f, 0.01808808f, 0.05363698f, 
    0.00612519f, 0.00975882f, -0.02085679f, 0.13451913f, 0.03772800f, 0.18719980f, 0.14718175f, 0.02550632f, 
    -0.05709115f, 0.08854327f, -0.24581976f, 0.15063038f, 0.22061123f, 0.00951522f, 0.05040204f, -0.09723173f, 
    -0.00721201f, 0.06347504f, 0.04972779f, 0.08884971f, 0.00007798f, -0.13133670f, 0.06776190f, -0.04331089f, 
    -0.02955271f, -0.03475427f, 0.05614804f, 0.00016396f, -0.03752714f, -0.03721918f, -0.11084636f, 0.04028111f, 
    -0.33930314f, 0.08686259f, 0.29529452f, 0.07597132f, -0.07940374f, -0.07930663f, -0.12712297f, -0.10722782f, 
    -0.07217905f, -0.00670331f, -0.02706717f, 0.04022952f, 0.00229806f, 0.02093859f, 0.04747966f, -0.01990341f, 
    -0.03891969f, 0.03497478f, -0.04377203f, -0.07753973f, -0.13552201f, -0.24942860f, -0.22206345f, -0.20057438f, 
    -0.00958579f, -0.04984614f, 0.07154430f, 0.10860878f, 0.01467249f, -0.06719428f, -0.03154486f, -0.00492810f, 
    -0.01687955f, -0.01485926f, 0.00086337f, 0.01341601f, -0.03108434f, -0.01016344f, 0.02846364f, 0.09135494f, 
    -0.18372986f, 0.14459188f, 0.23051718f, 0.05057273f, 0.19780256f, -0.01496436f, -0.03798422f, -0.08179887f, 
    -0.04875975f, 0.21089411f, -0.09628280f, 0.07661798f, 0.10643002f, -0.03042128f, -0.07535316f, 0.02588183f, 
    0.01585821f, 0.01102818f, 0.00734938f, 0.03627504f, 0.11069165f, 0.15099397f, -0.00098012f, 0.02397071f, 
    -0.01383433f, 0.04118426f, 0.02455847f, -0.01866924f, -0.05493650f, -0.06489730f, -0.01733008f, 0.00213647f, 
    0.00597367f, 0.00049850f, 0.03131298f, 0.03606303f, -0.04302491f, 0.05718295f, -0.09619588f, -0.04539588f, 
    -0.16470368f, -0.11770409f, 0.09056088f, 0.04305194f, -0.13264580f, 0.00702233f, 0.07692000f, 0.05693052f, 
    0.03705759f, -0.05970655f, 0.05071517f, -0.04485793f, 0.02747359f, -0.00902389f, 0.04171340f, 0.11616733f, 
    0.04137314f, 0.10068604f, -0.15973635f, 0.02977738f, -0.06911936f, -0.01354620f, -0.09749918f, -0.17334610f, 
    0.05015888f, -0.01190431f, 0.02027347f, 0.03252428f, -0.07294398f, 0.00142272f, -0.05340929f, -0.08085719f, 
    -0.03257356f, -0.04700744f, -0.04506167f, -0.06595793f, -0.07558161f, -0.20683926f, 0.03749539f, 0.08868643f, 
    0.09862892f, -0.12213337f, -0.09861061f, 0.11227822f, -0.17509407f, 0.04580614f, 0.15874989f, -0.08337736f, 
    -0.00991026f, 0.04866994f, -0.07181048f, 0.06461404f, 0.08080637f, -0.06789536f, -0.20383891f, 0.07080215f, 
    0.16667292f, 0.02841795f, 0.04483495f, 0.05636856f, 0.14968853f, -0.05228024f, -0.08514198f, -0.04983785f, 
    0.00595024f, 0.01381880f, -0.08057593f, 0.03328330f, 0.08073811f, 0.01939124f, -0.02103773f, -0.00484771f, 
    -0.00378978f, -0.13716894f, -0.05389429f, -0.06101516f, -0.08659630f, -0.07847495f, 0.04002148f, -0.02027424f, 
    -0.41449136f, -0.41997725f, -0.40889901f, -0.02392445f, 0.00390309f, -0.04068021f, 0.11472286f, 0.08913527f, 
    0.00149290f, -0.28247154f, 0.03738489f, -0.04208816f, 0.02035870f, 0.02015586f, 0.03055169f, 0.01471053f, 
    0.02392301f, 0.11302736f, 0.06343967f, 0.00614545f, -0.16401158f, 0.04605195f, 0.19551507f, -0.01901004f, 
    0.06223679f, -0.00524599f, -0.10197688f, 0.02927791f, -0.01277142f, 0.03775838f, 0.04568125f, 0.04882101f, 
    -0.07387386f, 0.06031261f, 0.04699060f, 0.01456766f, 0.00848010f, -0.00517964f, -0.07573265f, 0.01376614f, 
    -0.22402357f, 0.02839134f, -0.21059974f, -0.13652608f, 0.21340215f, -0.14442870f, -0.00548898f, 0.09766752f, 
    0.01124285f, 0.08144958f, -0.00338438f, 0.02113985f, 0.00766987f, 0.01666429f, -0.00127684f, -0.00472551f, 
    -0.02835523f, 0.01300311f, 0.13353217f, -0.09302312f, -0.14377573f, 0.10665219f, -0.02681361f, -0.07864741f, 
    0.09904318f, 0.05982006f, 0.04602849f, -0.00449440f, -0.01367939f, -0.08944973f, -0.09682929f, -0.00616467f, 
    0.10210080f, 0.03960669f, 0.05111136f, 0.06892894f, -0.09261576f, -0.01502058f, -0.19885710f, -0.02564892f, 
    -0.10490479f, 0.03700781f, 0.10152048f, -0.06035908f, 0.04071764f, 0.03269347f, 0.02639548f, -0.01566004f, 
    -0.02174347f, 0.10307341f, -0.06168060f, 0.05014977f, 0.02677514f, 0.14942142f, -0.05291980f, 0.01029352f, 
    -0.01230794f, -0.00966366f, 0.01884706f, 0.03620707f, -0.32194960f, -0.13934936f, 0.27121204f, 0.15750967f, 
    -0.15796833f, 0.02148048f, -0.13654026f, 0.09802484f, 0.03627006f, 0.05565110f, 0.06783815f, 0.08647657f, 
    -0.00346938f, 0.10711287f, -0.00703420f, 0.01392188f, 0.05981077f, 0.07747422f, -0.03448366f, 0.05322278f, 
    -0.33465871f, -0.04689661f, 0.12728417f, -0.13258417f, 0.45377660f, 0.02929991f, -0.05646018f, 0.00417705f, 
    -0.09762215f, 0.12866195f, -0.01937803f, 0.05723450f, -0.00523200f, 0.01445377f, -0.03280570f, -0.01290727f, 
    -0.01473030f, 0.03575616f, 0.08090495f, -0.00401690f, -0.26640761f, -0.19664715f, 0.20779283f, 0.00463028f, 
    -0.03032070f, -0.07630809f, -0.00683147f, -0.09360403f, -0.01456090f, 0.01451191f, 0.21422949f, -0.03368502f, 
    -0.01686168f, 0.05879433f, -0.04345438f, -0.03690973f, 0.02459036f, 0.00679021f, 0.03024543f, -0.00855152f, 
    -0.19561577f, 0.03741678f, 0.07662748f, -0.08365772f, 0.00796836f, -0.23966280f, -0.08182955f, -0.15591410f, 
    -0.15002893f, -0.04102853f, 0.01652185f, -0.09179053f, -0.02263184f, -0.04267238f, 0.04986100f, 0.01953441f, 
    -0.01335352f, -0.01868395f, 0.05654393f, -0.08819460f, -0.03766398f, 0.09770265f, 0.14790528f, -0.14154597f, 
    0.07636963f, 0.00576024f, -0.03118350f, -0.01594033f, 0.04114183f, -0.03777714f, 0.00143867f, -0.00740300f, 
    -0.00922541f, -0.02224828f, 0.01544809f, 0.04183294f, 0.04789605f, -0.10431149f, -0.00487734f, 0.02387515f, 
    0.25319368f, -0.00219818f, -0.08303171f, -0.07747848f, 0.13668148f, -0.06495239f, -0.03013769f, 0.10831954f, 
    0.08559930f, -0.11111920f, -0.01357492f, 0.00716827f, -0.07250527f, 0.02038723f, -0.00937130f, 0.00741529f, 
    -0.04949012f, -0.03039591f, -0.09353179f, 0.01394140f, -0.06687634f, 0.03946450f, 0.14788720f, -0.08967370f, 
    0.21558225f, 0.01817490f, 0.02220415f, -0.01419049f, 0.03468556f, 0.02430963f, 0.01134722f, -0.03004720f, 
    0.04630594f, -0.10134345f, -0.07893933f, -0.08145714f, 0.11987893f, 0.00167385f, 0.04214143f, 0.01255910f, 
    -0.52569622f, -0.04901213f, 0.28015199f, 0.07068470f, 0.21775627f, -0.16128114f, -0.01856725f, 0.00576356f, 
    -0.02087608f, 0.31374192f, -0.00665261f, 0.05231506f, 0.15342815f, -0.07932166f, 0.09624948f, -0.05700503f, 
    0.03823911f, -0.06621610f, 0.03301410f, -0.06147753f, -0.27940378f, -0.30851775f, -0.50323296f, -0.12233227f, 
    0.01462342f, -0.17996016f, -0.07802491f, -0.14814968f, -0.09002483f, -0.28681311f, -0.01946676f, 0.00835563f, 
    -0.00898283f, -0.05318206f, -0.01075031f, -0.00773653f, -0.01904893f, 0.02185116f, 0.12523347f, 0.05361779f, 
    -0.00060929f, -0.28150544f, 0.04151342f, 0.00825649f, 0.01432308f, 0.05694076f, 0.15233663f, -0.02353097f, 
    0.15817611f, 0.01686743f, 0.04925724f, 0.02917593f, -0.01520958f, 0.02155765f, 0.02474293f, 0.03645216f, 
    0.07094454f, 0.04279179f, 0.02864037f, 0.02471698f, -0.67529964f, -0.41452122f, -0.23993340f, 0.03271453f, 
    -0.05934680f, 0.00100937f, 0.06412444f, -0.16158222f, -0.09715363f, -0.18766010f, 0.04154776f, 0.01351734f, 
    0.00828364f, -0.02319403f, -0.01222688f, 0.00841881f, 0.02381964f, 0.08611009f, 0.08294209f, -0.03649593f, 
    0.03640687f, -0.03169208f, 0.04366447f, 0.05859338f, -0.10933586f, 0.01173642f, -0.03386231f, 0.01460843f, 
    0.02558198f, 0.00922528f, -0.05762220f, 0.04047911f, 0.01212265f, -0.06976143f, -0.06519342f, 0.08069276f, 
    0.02206153f, -0.01886770f, -0.04391015f, -0.00462659f, 0.11258030f, -0.03336115f, -0.07076535f, -0.06865332f, 
    0.04302906f, -0.03979805f, -0.01866670f, 0.02825505f, 0.01443310f, 0.07566257f, -0.04298449f, 0.04597430f, 
    -0.06955770f, -0.11969642f, -0.02230534f, -0.12780602f, -0.08179198f, -0.06257953f, -0.03898520f, -0.01077431f, 
    0.12058061f, 0.00012369f, -0.08691482f, -0.02518308f, -0.05980255f, 0.07050015f, 0.03512516f, 0.06043868f, 
    -0.02577247f, 0.03000226f, 0.03485289f, -0.06331611f, 0.04818039f, -0.12862019f, -0.00916008f, 0.04344388f, 
    0.02323825f, -0.07124437f, 0.01535301f, -0.01939546f, 0.12715545f, 0.44329375f, -0.32289344f, -0.06727048f, 
    0.03969782f, -0.12088954f, -0.03995316f, 0.09600572f, 0.14248435f, 0.07517559f, 0.11355665f, -0.00932543f, 
    0.07095499f, -0.02233224f, -0.05647413f, 0.02098244f, 0.14238589f, -0.02365895f, 0.11552003f, 0.04682918f, 
    0.13503124f, -0.16366300f, 0.20600919f, 0.12604314f, 0.35472256f, 0.03884918f, -0.07701584f, -0.02716893f, 
    -0.13879496f, -0.00446778f, 0.02062632f, 0.01825694f, 0.00924989f, 0.03381442f, -0.00505148f, 0.08994424f, 
    0.07922567f, -0.01087000f, 0.02168766f, 0.00141500f, 0.10146588f, 0.15433241f, -0.04682728f, 0.02286327f, 
    -0.22107725f, -0.01359159f, 0.01041137f, -0.00428178f, -0.02466178f, -0.06207356f, -0.13104732f, 0.04093815f, 
    -0.04469809f, -0.09776229f, -0.01848287f, -0.10928830f, -0.09953076f, 0.02545635f, -0.05319380f, -0.02498263f, 
    -0.17564261f, -0.07717320f, -0.07042224f, 0.15517691f, -0.17518587f, -0.01264960f, 0.02230911f, 0.12415581f, 
    0.00903252f, 0.00545751f, 0.02160899f, 0.04802751f, 0.01931547f, 0.01089325f, -0.03472422f, -0.01182536f, 
    0.03974838f, -0.02214517f, -0.00339069f, 0.04304137f, 0.01467239f, -0.14266668f, -0.10287067f, -0.06529243f, 
    -0.14118594f, 0.04967750f, -0.05617506f, 0.07157121f, -0.05887686f, -0.00608021f, -0.04999831f, 0.06509054f, 
    0.06677608f, 0.05426736f, 0.02795023f, 0.04207031f, 0.03478047f, 0.07307655f, 0.00377942f, -0.01933045f, 
    0.31108195f, -0.57914007f, -0.33833629f, -0.38878277f, -0.24891967f, -0.07836477f, 0.01182467f, -0.16706920f, 
    0.13426580f, -0.06255096f, 0.01997204f, 0.05929888f, -0.02411907f, -0.00661004f, 0.01036030f, -0.04250599f, 
    0.02416519f, -0.03617834f, 0.05145464f, 0.01759146f, -0.14705956f, -0.04513741f, -0.12981443f, 0.09671500f, 
    -0.01347174f, 0.02678858f, 0.03441056f, 0.11964303f, -0.02130767f, 0.02898262f, -0.11898881f, 0.08055960f, 
    -0.01703330f, 0.09105582f, 0.05311508f, -0.04191401f, -0.06804598f, -0.00149795f, -0.00044233f, 0.09263461f, 
    0.02744855f, 0.08886508f, 0.05430007f, -0.04056178f, -0.01555199f, -0.00166926f, -0.00216264f, -0.00993066f, 
    0.01166928f, -0.00724769f, 0.03607019f, -0.01107561f, 0.03061237f, 0.00171981f, -0.00203273f, -0.11120927f, 
    -0.15272401f, 0.03529817f, 0.03522412f, 0.00690991f, 0.12229419f, 0.20668222f, 0.05664512f, 0.00301336f, 
    -0.27572942f, 0.00003633f, 0.08663500f, -0.03229973f, 0.03506529f, -0.01344406f, -0.05836672f, 0.09660490f, 
    0.02346024f, -0.03943479f, -0.05919718f, -0.10722329f, 0.04753065f, 0.00166812f, -0.06869849f, 0.05413641f, 
    0.00583185f, 0.06022537f, -0.00663422f, 0.01828877f, -0.04924643f, 0.01885803f, 0.02528296f, 0.05586275f, 
    -0.08578896f, -0.02396793f, 0.03854760f, 0.02756092f, 0.00653591f, 0.01371282f, -0.01381044f, 0.01580226f, 
    -0.04081690f, -0.07830774f, -0.02469806f, 0.00119459f, -0.05521921f, 0.06547279f, 0.05947704f, -0.00724353f, 
    -0.03197494f, 0.01075289f, 0.01739726f, -0.00647761f, -0.09772451f, 0.01619372f, 0.03417533f, -0.01369465f, 
    0.01510178f, 0.01657187f, -0.03753817f, 0.01061578f, 0.03611893f, 0.05159749f, -0.09678011f, -0.07449405f, 
    -0.05989067f, -0.30571935f, -0.10223188f, -0.30953494f, -0.09790970f, 0.00197016f, 0.01716719f, -0.04063105f, 
    0.17661306f, 0.09216278f, -0.01360577f, -0.02072393f, -0.02483125f, -0.07051780f, -0.03514684f, 0.00643654f, 
    0.05191159f, -0.02457713f, 0.09429379f, -0.03360123f, 0.28888315f, 0.16290903f, -0.11733461f, 0.00340350f, 
    -0.22748433f, -0.06097980f, -0.00803079f, 0.02937224f, -0.08784124f, -0.09224337f, -0.10909499f, -0.07172446f, 
    0.07618906f, 0.02526685f, 0.00452791f, -0.07135224f, -0.14931093f, 0.06403676f, -0.07173971f, -0.08767916f, 
    -0.21156266f, -0.31696549f, 0.09158088f, -0.01078227f, -0.05298861f, -0.03393865f, -0.01668451f, 0.27467936f, 
    -0.13043320f, 0.03650330f, -0.12075847f, 0.13732572f, 0.02854312f, 0.08317723f, -0.01789421f, -0.04077663f, 
    0.02067750f, 0.06115936f, 0.03990193f, 0.02331529f, -0.00793706f, 0.06283060f, 0.00262638f, 0.01595657f, 
    -0.06106432f, 0.00267968f, 0.02783443f, 0.02230926f, -0.06989455f, -0.07935590f, 0.00244279f, -0.05548819f, 
    0.01511307f, -0.06977901f, 0.00924825f, -0.05622082f, -0.03346172f, 0.03681684f, -0.02516566f, -0.01895522f, 
    -0.00379866f, -0.01327042f, -0.08014727f, 0.04722718f, -0.01551634f, 0.01827180f, -0.02905679f, 0.02154144f, 
    -0.00457999f, 0.02445309f, 0.03839758f, -0.05086716f, 0.01067807f, 0.01890222f, -0.01455956f, -0.00375365f, 
    -0.00050944f, 0.02293515f, 0.00663341f, 0.01030947f, 0.13468543f, 0.10537567f, -0.20361219f, 0.04864781f, 
    -0.15141895f, -0.03448617f, 0.08298172f, -0.02140382f, -0.09393125f, -0.03055532f, -0.01646854f, 0.09150966f, 
    0.05250211f, 0.01660042f, -0.07031286f, -0.05543071f, -0.07625199f, 0.05256977f, -0.07809352f, -0.07882762f, 
    -0.18386815f, -0.06784631f, 0.05351355f, -0.09708296f, 0.06026153f, -0.01625279f, 0.01463829f, 0.01787917f, 
    0.03357579f, 0.01898425f, -0.09534542f, -0.05232340f, 0.08541704f, -0.00073488f, 0.03700913f, -0.00457653f, 
    -0.02040336f, -0.00480822f, 0.00293505f, 0.01871270f, -0.20270760f, 0.02087162f, -0.24214348f, 0.18255517f, 
    -0.09280176f, 0.03519238f, 0.05227764f, 0.14206345f, -0.06015299f, 0.00577188f, -0.14243062f, 0.06620515f, 
    0.02916028f, 0.08651194f, 0.04768181f, -0.00485364f, -0.07292870f, 0.00628750f, -0.07421219f, 0.08998606f, 
    0.32910773f, -0.51795292f, -0.10145255f, 0.21187535f, -0.18061931f, -0.03868958f, 0.05162643f, 0.04045351f, 
    -0.02788075f, 0.04443771f, -0.02289965f, -0.05212587f, -0.00895519f, -0.05153899f, -0.00862228f, 0.03555081f, 
    -0.03813364f, -0.04701362f, -0.03921070f, 0.04549457f, 0.00810639f, 0.04993691f, -0.03642527f, -0.01737382f, 
    -0.01023328f, -0.00447891f, 0.04051872f, 0.05431725f, 0.02432603f, -0.02671983f, -0.04640340f, -0.10621723f, 
    -0.02333912f, 0.02411188f, 0.07859126f, -0.07318360f, -0.00326575f, -0.00486959f, -0.04737490f, 0.01140834f, 
    -0.00468060f, 0.05118815f, -0.01056755f, -0.03638228f, -0.00373908f, -0.01820052f, 0.01526625f, -0.00902200f, 
    -0.02277672f, -0.03729402f, -0.10381755f, -0.17894952f, -0.08263246f, -0.07438479f, -0.08510511f, 0.00176681f, 
    -0.02555194f, -0.01277955f, 0.01567355f, 0.01136589f, -0.81586725f, -0.49004099f, 0.28449905f, 0.01254923f, 
    0.18551037f, -0.03359094f, -0.05865063f, -0.04787854f, -0.06545411f, -0.01416182f, 0.03576129f, 0.00503248f, 
    0.00182996f, 0.01549949f, -0.05642460f, 0.05480585f, -0.02833891f, -0.03850101f, -0.14176013f, -0.04275626f, 
    -0.11642648f, -0.03733302f, 0.03778785f, 0.00856336f, 0.04608239f, 0.03253935f, 0.03545901f, -0.01042212f, 
    -0.01869379f, -0.05088291f, 0.09534721f, -0.01234763f, -0.03322260f, 0.01338405f, 0.05558952f, -0.00351670f, 
    0.03295387f, 0.01602235f, 0.04704433f, -0.00146015f, -0.08562583f, -0.08873824f, -0.07877869f, 0.01184416f, 
    0.07714774f, 0.03398810f, -0.05073150f, 0.08629720f, 0.04816536f, 0.02581329f, -0.13066381f, 0.19486077f, 
    0.09646643f, 0.04441783f, 0.01871087f, 0.04988263f, 0.03735503f, 0.00490999f, -0.02033529f, -0.02752578f, 
    0.36667490f, 0.03775128f, -0.16410784f, -0.10205396f, -0.09746010f, 0.04438403f, 0.01345849f, -0.14098106f, 
    0.00788926f, -0.14876437f, 0.08125766f, 0.02713869f, 0.02645258f, 0.01692147f, -0.01579554f, 0.00784799f, 
    -0.00565225f, -0.00869170f, 0.00473132f, -0.01155888f, -0.12636440f, -0.24120678f, 0.26470196f, -0.19668162f, 
    0.16781852f, -0.05290250f, -0.03205527f, 0.09111439f, -0.21113949f, -0.02323877f, 0.07669758f, -0.01818837f, 
    -0.01984658f, 0.02884488f, -0.10822688f, -0.04482206f, -0.05804943f, -0.05010432f, 0.02598912f, -0.10437232f, 
    0.00398669f, 0.05978558f, 0.01473785f, 0.04761390f, -0.04484445f, 0.00674017f, -0.05508601f, 0.01742790f, 
    0.01756232f, -0.03440166f, 0.02997145f, -0.02164317f, 0.01536145f, -0.02035639f, 0.00481523f, -0.07357517f, 
    -0.15018354f, 0.08014675f, -0.02088706f, -0.00642857f, 0.00149359f, -0.55220449f, -0.19637421f, 0.49195671f, 
    0.08501504f, 0.10377992f, 0.01192424f, -0.08470204f, 0.04707563f, 0.07237162f, -0.00019337f, 0.00346522f, 
    -0.05528854f, -0.05894244f, -0.05936663f, -0.02612958f, -0.00967391f, 0.03172351f, 0.13075839f, -0.02915514f, 
    -0.49225253f, -0.34127879f, 0.29067501f, 0.15421675f, 0.23383877f, 0.01566529f, 0.06840115f, -0.03888208f, 
    -0.17787158f, -0.07791822f, 0.05000735f, -0.02874357f, -0.08684764f, -0.00243824f, -0.02584754f, 0.02873764f, 
    0.00571528f, -0.01353853f, -0.02439353f, -0.08191298f, -0.30364197f, -0.08189451f, -0.05657825f, 0.13453446f, 
    -0.17652310f, -0.01065452f, -0.01656255f, -0.11020577f, 0.06015036f, 0.08261215f, 0.05025456f, 0.03248903f, 
    -0.00232938f, -0.00479627f, -0.01486253f, 0.00650287f, -0.00272421f, -0.10024995f, -0.00674054f, 0.03724420f, 
    -0.05798909f, 0.17960489f, 0.11156861f, 0.11345179f, 0.07822358f, 0.05435312f, -0.01949130f, -0.06023936f, 
    -0.07986800f, 0.02596729f, 0.02079315f, 0.00491117f, 0.00503382f, 0.03356714f, -0.01567413f, 0.11269315f, 
    0.09097624f, 0.02254942f, -0.02041227f, -0.01883950f, 0.01878339f, 0.04763081f, -0.03920182f, 0.01200401f, 
    -0.12992875f, 0.00384163f, 0.02018489f, 0.02024007f, 0.01105026f, -0.01435872f, -0.06201473f, -0.01301529f, 
    -0.00373907f, -0.07291826f, -0.04599602f, -0.01970679f, 0.01232219f, 0.03242217f, -0.04152275f, 0.02171165f, 
    0.04210594f, -0.06507049f, -0.11190259f, -0.05512303f, -0.02761560f, 0.04778459f, -0.03341716f, 0.01076650f, 
    0.00484284f, -0.02628876f, 0.00586716f, 0.04363646f, 0.04436322f, 0.02762032f, 0.04053424f, -0.00783380f, 
    -0.00439892f, 0.00601785f, -0.00957254f, -0.01087633f, 0.40512687f, -0.39920375f, -0.35184288f, -0.25762823f, 
    -0.13537306f, 0.00632421f, 0.01371145f, -0.12455132f, 0.14626500f, 0.04066453f, 0.01641121f, 0.02786247f, 
    -0.01167358f, -0.01593024f, -0.01066435f, -0.06723867f, -0.00182589f, -0.02377709f, -0.03163207f, -0.06316032f, 
    -0.03001548f, -0.16635518f, 0.30382404f, -0.16659212f, 0.20080754f, 0.01498139f, 0.02238602f, 0.09523348f, 
    0.04444937f, 0.00078345f, -0.04255784f, -0.01425872f, -0.09802389f, -0.12292499f, -0.03946017f, -0.20122790f, 
    0.03989475f, 0.01078331f, -0.06854047f, 0.04729747f, -0.04716883f, 0.07559694f, 0.07894347f, -0.04279048f, 
    0.06245585f, -0.00194521f, -0.01869171f, 0.02864158f, 0.00193109f, 0.01923509f, -0.00004965f, -0.01582038f, 
    0.03305448f, 0.03390095f, -0.00273169f, 0.08081999f, -0.09092195f, -0.07810610f, 0.02106074f, -0.02341359f, 
    0.28867117f, -0.10090270f, -0.10961346f, -0.07769874f, -0.06595533f, 0.06355316f, 0.00104999f, 0.01967575f, 
    -0.06056431f, 0.00356037f, 0.05306471f, 0.01256890f, 0.09795175f, -0.01311115f, 0.02171409f, 0.02056560f, 
    0.02346265f, 0.02091442f, 0.01236665f, -0.02398035f, -0.03552869f, 0.08449060f, -0.05722021f, -0.00500737f, 
    -0.14856222f, 0.02598315f, 0.03747941f, -0.00146766f, -0.00699377f, 0.00130624f, 0.03076293f, 0.03633225f, 
    0.05968884f, 0.00397743f, -0.02499842f, 0.02735329f, 0.02558905f, -0.09915379f, -0.05724834f, -0.06337463f, 
    0.19355555f, -0.13409546f, -0.24234594f, -0.16365413f, -0.12619899f, 0.02834742f, -0.02246387f, -0.03582412f, 
    0.12120669f, 0.05217683f, -0.00591106f, 0.02818116f, 0.05506638f, -0.07866861f, 0.06174870f, -0.02189246f, 
    0.01416695f, -0.02490159f, 0.07916589f, 0.05315268f, -0.06883304f, -0.00322765f, 0.06370156f, -0.02133193f, 
    0.05638540f, 0.02543038f, -0.00299832f, 0.01178206f, 0.00648251f, -0.00288990f, -0.11692354f, -0.01121843f, 
    0.03265796f, 0.03592379f, 0.01081606f, -0.00180160f, -0.02254423f, -0.03320058f, 0.01928962f, -0.00824920f, 
    -0.07581946f, -0.06346387f, 0.14779377f, -0.02852301f, 0.12479242f, 0.06129624f, 0.02361989f, 0.10253179f, 
    -0.02744257f, -0.01907398f, 0.05881794f, 0.00978769f, 0.05614983f, -0.02259696f, -0.08295274f, -0.04402846f, 
    0.02638723f, -0.12819132f, -0.05603384f, -0.09470772f, 0.01512291f, 0.05135757f, -0.00615404f, 0.04500388f, 
    -0.08417047f, 0.01964950f, -0.00165404f, 0.00112163f, 0.00155355f, 0.00391803f, 0.06050093f, 0.03747109f, 
    0.01935015f, -0.00221911f, 0.00348040f, -0.08816753f, -0.03377854f, 0.08914201f, 0.00505294f, 0.02263269f, 
    0.23362088f, -0.72254759f, 0.19470669f, -0.23594153f, 0.11971362f, -0.14445063f, 0.09924813f, -0.11286749f, 
    0.15962785f, 0.03311351f, 0.01344573f, 0.05083277f, -0.03731263f, -0.04057585f, 0.09990632f, -0.10981144f, 
    -0.02629136f, -0.07396232f, 0.12549867f, 0.02926763f, 0.10182344f, 0.07497100f, -0.01794594f, -0.00661894f, 
    -0.08196976f, -0.00559541f, 0.05176345f, -0.00071580f, -0.03669555f, -0.01192312f, 0.02059827f, -0.00196241f, 
    -0.01536708f, -0.05063147f, 0.02602621f, -0.04468792f, -0.05806118f, 0.06368174f, -0.05225676f, -0.00923715f, 
    -0.07587508f, 0.03773001f, 0.14754722f, 0.17911963f, -0.01314771f, 0.03716029f, 0.05263608f, -0.05959966f, 
    -0.04360182f, 0.10324892f, -0.00513215f, -0.03778296f, -0.00536932f, 0.02466726f, 0.00152095f, 0.07317185f, 
    0.09389205f, -0.00819493f, 0.02526339f, -0.04668665f, 0.15113501f, 0.01020046f, 0.00598171f, -0.14937469f, 
    -0.02683436f, -0.10341585f, 0.02236849f, -0.01328463f, 0.04620915f, -0.02855730f, 0.04989801f, -0.06342466f, 
    -0.04888106f, 0.03695305f, -0.01804755f, -0.02387669f, 0.00238634f, -0.03140745f, 0.04316903f, -0.01338015f, 
    0.40905437f, -0.41908026f, -0.28411278f, 0.05927721f, -0.17679378f, 0.09658602f, -0.02959531f, 0.00637351f, 
    -0.05341425f, -0.12901142f, 0.01871315f, -0.03464090f, 0.04965845f, 0.00763062f, -0.06156767f, -0.00835596f, 
    -0.08480588f, 0.05163601f, -0.03306833f, -0.10082164f, -0.19427696f, -0.00161349f, 0.11030350f, 0.06694307f, 
    -0.00404605f, 0.03991057f, 0.03082791f, 0.12631652f, 0.02830113f, 0.02632823f, 0.07385538f, -0.09860864f, 
    0.05978388f, 0.04104780f, -0.09429798f, 0.04469792f, -0.02886039f, -0.07783981f, -0.02552885f, 0.02211156f, 
    0.11927427f, 0.15831025f, -0.19701008f, -0.06257667f, -0.12519769f, 0.01345422f, 0.07055730f, -0.07274344f, 
    -0.02231964f, -0.02525163f, -0.02084980f, -0.00115942f, 0.07475231f, -0.01612759f, -0.05704130f, 0.01266613f, 
    0.01736154f, -0.01872041f, 0.00916374f, 0.03638682f, 0.45975459f, 0.12909652f, 0.02751582f, -0.13666062f, 
    0.07792081f, -0.10482563f, 0.07105412f, 0.01506201f, 0.02741952f, -0.02389273f, 0.04183073f, -0.13245207f, 
    0.02039763f, -0.00123828f, 0.03323586f, -0.06269140f, 0.04248349f, -0.00981234f, -0.04448355f, 0.03902159f, 
    0.46530449f, -0.46810251f, -0.43178010f, -0.43342099f, -0.32340533f, 0.04313785f, 0.00176837f, 0.01469433f, 
    0.19579317f, -0.13604833f, 0.05110950f, 0.04177385f, -0.01174494f, 0.02860332f, 0.03274075f, -0.05035164f, 
    -0.00323264f, 0.00720061f, 0.03896464f, 0.02479190f, 0.08739562f, 0.00415783f, 0.07055611f, -0.09350201f, 
    0.03603030f, 0.03250415f, 0.10367390f, -0.01038656f, 0.02522201f, -0.04014650f, 0.05428790f, 0.13900939f, 
    0.11627349f, -0.00289165f, 0.01456292f, 0.00940755f, 0.07058590f, 0.04669305f, -0.00356676f, -0.02821683f, 
    0.21553196f, -0.17690693f, -0.13168380f, 0.04931730f, -0.07056087f, 0.12711336f, 0.01174653f, 0.02969592f, 
    -0.05752124f, 0.02818834f, 0.01033799f, 0.09407999f, 0.08117986f, 0.04160812f, 0.02918468f, -0.00641924f, 
    0.01129881f, -0.00521879f, -0.01212023f, -0.07680356f, -0.08452837f, 0.06226397f, 0.00996316f, -0.00678149f, 
    -0.01098479f, 0.02569196f, 0.01096923f, 0.05255976f, -0.02953260f, -0.03572845f, 0.00219875f, -0.00573069f, 
    0.05490088f, -0.02008557f, -0.00115678f, 0.06024582f, -0.02107747f, -0.03404147f, -0.07976285f, 0.04175944f, 
    -0.04805392f, 0.12404959f, 0.02053218f, 0.03097733f, -0.00770888f, -0.00026694f, -0.04401502f, -0.01791573f, 
    0.03960495f, 0.01039521f, 0.03974455f, 0.01126770f, 0.04111894f, -0.00956256f, -0.03238034f, 0.06391416f, 
    -0.18320177f, -0.14175197f, 0.01886584f, 0.05215073f, -0.12430739f, 0.08985739f, -0.22248888f, 0.08355280f, 
    -0.29303560f, 0.00566549f, 0.00551139f, 0.10369392f, -0.07796200f, -0.01075235f, -0.07504233f, -0.07222345f, 
    -0.09256942f, -0.03212546f, 0.02598960f, -0.06802485f, -0.09992976f, 0.05519031f, -0.04757362f, 0.04398095f, 
    0.58994389f, 0.46132594f, -0.20572370f, -0.11163991f, -0.33317703f, 0.05414022f, -0.13004249f, -0.04016010f, 
    -0.12714106f, 0.06553026f, -0.01703969f, -0.06775134f, 0.01347161f, 0.00615805f, -0.04708778f, 0.01019249f, 
    -0.00948729f, 0.04278920f, 0.00537611f, -0.06682573f, -0.01443502f, -0.23669490f, -0.13201933f, 0.23439486f, 
    -0.19267274f, -0.01344681f, 0.07268725f, -0.05531523f, 0.09991438f, 0.15037666f, -0.00097114f, -0.03059908f, 
    -0.09117643f, -0.06856461f, -0.05516804f, -0.03405053f, 0.06855872f, -0.09621346f, 0.07741599f, -0.03125487f, 
    -0.05017262f, -0.10519858f, 0.17085886f, -0.04905480f, 0.04503309f, -0.09381397f, 0.03574236f, -0.16512926f, 
    0.05277353f, -0.02815150f, 0.10116877f, 0.00599336f, 0.03241596f, -0.00565666f, -0.05874515f, -0.05894522f, 
    0.00329325f, -0.05781913f, 0.10878455f, -0.04269632f, -0.02825039f, -0.28576702f, -0.02848332f, 0.01201253f, 
    -0.05255775f, -0.03528965f, 0.02814530f, 0.02107555f, -0.06027436f, 0.07403192f, -0.02762778f, -0.04193316f, 
    0.03130011f, -0.01295798f, -0.05303270f, 0.02393120f, -0.02748492f, -0.04824743f, -0.00887885f, 0.06251085f, 
    0.06793419f, 0.05354474f, 0.01704673f, -0.01908568f, -0.07883345f, 0.01749812f, -0.00594985f, 0.01088789f, 
    -0.04514370f, -0.05163193f, 0.02062760f, -0.11802936f, -0.06133938f, -0.19371976f, -0.11399955f, 0.04359470f, 
    -0.03548773f, 0.02503669f, 0.00073120f, -0.01386744f, -0.00447436f, 0.03292058f, -0.03439222f, 0.00744497f, 
    -0.12030490f, -0.01482163f, 0.01478723f, 0.02650660f, 0.00263827f, -0.06083641f, -0.04087243f, 0.02302787f, 
    -0.00322057f, -0.01169609f, -0.04446923f, -0.01561963f, -0.09642196f, 0.02414277f, -0.01541887f, 0.02497353f, 
    0.00710348f, -0.02275302f, 0.04735024f, 0.00274275f, 0.00323168f, 0.00286547f, 0.00666642f, 0.01904171f, 
    -0.01632115f, 0.00117058f, 0.01570121f, -0.03861735f, 0.04108234f, -0.01994915f, 0.00980345f, -0.01842873f, 
    0.06280442f, -0.06972460f, 0.06742301f, 0.02605488f, 0.01573427f, -0.02736162f, -0.03891069f, -0.03837224f, 
    0.06139211f, 0.06107922f, 0.06289936f, 0.16906086f, -0.20330080f, -0.04203565f, -0.09026732f, 0.04805600f, 
    -0.03277007f, 0.00342521f, 0.00430609f, 0.02211650f, 0.07704648f, 0.03941096f, -0.05358500f, 0.04094295f, 
    0.55920196f, -0.04711848f, 0.13309924f, -0.07191576f, -0.01089835f, 0.07183655f, -0.10094864f, -0.04846175f, 
    0.06511974f, 0.04031553f, 0.05063151f, 0.05434711f, -0.01209748f, 0.00901641f, -0.02496794f, -0.17723379f, 
    -0.10465012f, -0.13017771f, -0.19144304f, -0.59008437f, 0.20448180f, 0.09102727f, 0.04008671f, -0.00061151f, 
    -0.16145392f, -0.04034904f, 0.09235780f, -0.00801621f, 0.02551001f, -0.06055786f, 0.00062404f, -0.04622835f, 
    0.05086541f, 0.01529461f, 0.06413499f, 0.00859234f, -0.01268203f, -0.09519989f, 0.05648378f, -0.07078899f, 
    0.24797797f, 0.24017389f, 0.00079527f, -0.07870281f, -0.15377367f, -0.00592792f, -0.13888364f, -0.15414444f, 
    -0.05486186f, -0.25760806f, -0.01341017f, 0.04297597f, 0.06883790f, 0.01710494f, 0.03944338f, -0.03706953f, 
    0.08618157f, 0.13693479f, 0.15471189f, 0.07503246f, -0.17326444f, -0.32230166f, -0.17372333f, -0.07801915f, 
    -0.03106868f, -0.08725723f, 0.12712550f, 0.08758802f, 0.08993573f, 0.09030581f, 0.07816230f, 0.03062337f, 
    0.00051657f, -0.07201538f, -0.05716297f, -0.02194291f, 0.06153368f, -0.04668985f, 0.06221319f, -0.02869451f, 
    0.01002569f, -0.17356785f, -0.60073334f, -0.24226661f, 0.03132716f, 0.11871386f, 0.04302754f, 0.14672966f, 
    0.09153670f, 0.07377143f, 0.02780608f, -0.02665889f, -0.01773162f, -0.00250149f, 0.00588719f, 0.01125136f, 
    0.02445599f, 0.06010087f, -0.01343264f, 0.05597844f, -0.22631343f, -0.26591671f, 0.16884935f, 0.05050201f, 
    0.19055811f, -0.05997432f, -0.00612691f, -0.03739764f, -0.05536482f, -0.07042045f, 0.04800200f, 0.00000761f, 
    -0.04913360f, 0.06185470f, 0.00074433f, -0.00409549f, -0.07443974f, -0.00790610f, -0.02368226f, -0.07090359f, 
    -0.30382133f, 0.04901547f, 0.08499029f, 0.03414513f, -0.14810447f, -0.03286319f, -0.08144600f, -0.01928772f, 
    0.00665834f, -0.09723043f, -0.02981805f, -0.00422714f, -0.02609383f, -0.04413570f, -0.01655111f, 0.02774452f, 
    0.04560051f, -0.00221784f, -0.05619459f, 0.04365608f, 0.47515199f, 0.25534511f, -0.02086685f, -0.14789826f, 
    -0.24861237f, -0.05312055f, -0.03367112f, -0.07899673f, -0.01906615f, -0.15476257f, -0.04227868f, 0.04798466f, 
    0.01652744f, 0.01010151f, 0.02032313f, -0.16770314f, -0.19756325f, -0.10638944f, -0.02183887f, -0.04878253f, 
    -0.21108529f, 0.08672759f, 0.14789526f, 0.09384881f, 0.01428391f, 0.04578965f, 0.04141099f, -0.09323179f, 
    -0.09402996f, 0.04605411f, -0.01522145f, -0.04637067f, -0.01277808f, 0.02551840f, -0.04261721f, -0.01615585f, 
    -0.06670316f, 0.02672885f, -0.02145984f, 0.01059414f, 0.03600178f, -0.01461766f, 0.09400170f, 0.12913042f, 
    -0.09921501f, 0.02174592f, -0.00221414f, -0.10218200f, -0.03391218f, 0.01981037f, -0.04078337f, -0.02661130f, 
    0.01458987f, -0.02030976f, 0.01828871f, 0.07778246f, 0.04221247f, -0.08794901f, -0.11923483f, -0.15319964f, 
    0.04256102f, -0.30313280f, -0.49821806f, -0.40588391f, -0.05582018f, -0.18041000f, -0.13207430f, 0.02041493f, 
    -0.06338584f, -0.22739641f, -0.00264175f, -0.02969171f, -0.03314630f, -0.00433197f, 0.06137524f, 0.05749903f, 
    -0.00760725f, 0.06348961f, -0.11377976f, -0.18491787f, 0.32422400f, -0.01507952f, -0.00743398f, -0.03941694f, 
    -0.07886166f, 0.03743668f, 0.06362636f, 0.05748802f, 0.06639822f, 0.00754348f, 0.06879719f, 0.02739293f, 
    0.00425453f, 0.07130788f, 0.03770579f, 0.01699785f, 0.13848493f, -0.05099370f, 0.09973872f, 0.06381205f, 
    0.13089085f, -0.40226018f, 0.32467759f, -0.11188551f, 0.35820544f, -0.03975388f, 0.12122826f, -0.06950961f, 
    0.04208632f, 0.00853766f, 0.01482457f, -0.05981213f, 0.00549264f, -0.05046508f, 0.01263306f, -0.02023323f, 
    0.05002714f, 0.01399881f, -0.20321037f, -0.06085235f, -0.04025543f, 0.04374149f, 0.03786930f, 0.04509782f, 
    0.05287071f, 0.02054880f, 0.08031259f, 0.00883512f, 0.04615129f, -0.01464430f, -0.00489911f, 0.00735519f, 
    0.05488858f, 0.05290861f, 0.04593799f, -0.00684637f, 0.04472650f, -0.03890907f, 0.01914878f, -0.04096534f, 
    -0.00954653f, 0.01315191f, -0.09371525f, -0.00743404f, -0.01272034f, -0.01647044f, 0.00792003f, -0.07936292f, 
    -0.03404623f, -0.05383044f, 0.02357986f, -0.00362039f, 0.07973425f, 0.03519711f, -0.02834573f, 0.00716553f, 
    0.09446409f, 0.07962890f, 0.08335315f, 0.10569775f, 0.20200974f, 0.13628148f, -0.02046326f, -0.00447857f, 
    -0.21995850f, 0.11999096f, -0.01530811f, 0.08531141f, 0.07135795f, 0.00046867f, 0.04152444f, -0.00518344f, 
    -0.03855638f, 0.07233612f, -0.01314696f, 0.08883247f, 0.04569703f, -0.00498283f, 0.14504370f, -0.00491845f, 
    -0.17122410f, -0.22820303f, -0.01121045f, 0.08907613f, 0.05069408f, -0.02624631f, 0.03009651f, 0.09164153f, 
    0.02724948f, 0.10196327f, 0.04398764f, -0.01779293f, -0.00045309f, -0.05800775f, -0.00262271f, -0.04986205f, 
    0.06655358f, 0.00248357f, 0.05118825f, 0.04387154f, -0.15994370f, -0.34785867f, 0.15356201f, 0.03633697f, 
    0.23017102f, -0.04098084f, 0.07168350f, -0.07983619f, -0.03218504f, -0.00757400f, 0.03526140f, 0.01365845f, 
    -0.00813180f, 0.09651802f, -0.03297319f, 0.03323942f, -0.09401490f, -0.09345039f, 0.05440018f, -0.12737155f, 
    0.10444862f, -0.50427282f, -0.49185631f, -0.34768882f, -0.13468643f, 0.01289254f, -0.09802100f, 0.08573640f, 
    0.04630919f, -0.10157808f, 0.00860316f, 0.01904983f, -0.02603915f, -0.00454343f, 0.01133735f, 0.00616143f, 
    0.04888469f, 0.04675835f, 0.03582229f, 0.12118484f, -0.13258800f, -0.05495373f, 0.03261585f, 0.07656860f, 
    -0.04500754f, -0.06471655f, 0.01752174f, 0.02633955f, 0.01607026f, -0.03505836f, 0.02404962f, 0.05865539f, 
    -0.03357450f, 0.08040962f, 0.02536718f, 0.03642632f, 0.01477008f, 0.06347264f, 0.00177249f, 0.05735486f, 
    -0.23672751f, -0.03960111f, 0.06406315f, -0.01143906f, -0.03895656f, -0.05488862f, 0.00132095f, -0.00071782f, 
    0.02145275f, -0.01784487f, 0.06837007f, 0.05171112f, 0.03747042f, 0.09460938f, 0.11318977f, -0.03513696f, 
    0.04351328f, 0.01334519f, 0.11823055f, 0.04860466f, 0.44804996f, -0.15564361f, -0.02357086f, -0.02816924f, 
    -0.15533671f, 0.18378070f, -0.00246008f, -0.07334962f, -0.09843482f, -0.05100180f, 0.01251383f, 0.04631350f, 
    0.07971149f, 0.01614656f, 0.04144229f, 0.05106694f, 0.08841603f, 0.11816882f, -0.03121465f, -0.02216493f, 
    0.24937584f, -0.09124482f, -0.07048000f, 0.03869100f, -0.11702202f, -0.10490689f, -0.09650666f, -0.14507250f, 
    -0.06112897f, -0.04301557f, 0.04964250f, 0.08195405f, 0.05753418f, -0.09045539f, 0.12783730f, -0.02099548f, 
    0.13485859f, -0.00129549f, 0.09447071f, 0.09874925f, -0.05228689f, -0.11757858f, -0.10464445f, -0.09357238f, 
    0.14664298f, -0.01538116f, -0.02991989f, 0.02480903f, 0.05007787f, 0.05067780f, -0.00443751f, -0.02071069f, 
    0.02772928f, -0.04760157f, -0.05744357f, -0.04120173f, 0.04085530f, 0.09153063f, 0.12422947f, 0.07951859f, 
    -0.00600515f, -0.30261388f, -0.41270316f, -0.23694913f, -0.05539767f, -0.00956008f, 0.00552535f, 0.06951707f, 
    0.05707142f, 0.14049989f, 0.05449613f, 0.01897858f, -0.04556047f, -0.00492008f, -0.07980704f, 0.03427514f, 
    0.02638800f, -0.03820308f, 0.04022326f, 0.02013699f, 0.22265925f, -0.10553949f, 0.07272923f, 0.14875872f, 
    0.08719098f, 0.10944797f, 0.10143489f, -0.07332892f, 0.01395028f, 0.07933531f, 0.02747028f, -0.00761585f, 
    0.02176405f, 0.01276578f, 0.07968727f, 0.00284275f, -0.03052888f, 0.00199737f, -0.15442975f, 0.04605026f, 
    -0.26871958f, 0.09080321f, 0.13141435f, 0.01075791f, -0.11426413f, -0.06649741f, -0.01922636f, -0.01198403f, 
    0.02719188f, 0.01518444f, -0.05794824f, -0.02284491f, -0.04377406f, -0.01459062f, 0.03024398f, 0.04972730f, 
    0.07810239f, 0.03247908f, -0.00094724f, 0.04468562f, 0.20283903f, -0.47246429f, -0.52500737f, -0.21867186f, 
    -0.12248628f, -0.00060596f, -0.17272615f, -0.03405193f, 0.02143528f, -0.16461110f, -0.02358980f, 0.00817370f, 
    0.02979549f, 0.02423050f, 0.04801469f, 0.08299894f, -0.00075941f, 0.05602749f, 0.04070903f, 0.08473795f, 
    0.63742739f, -0.26694533f, -0.09374404f, 0.05978427f, -0.09710231f, 0.10818953f, -0.08959716f, -0.13828799f, 
    -0.08156344f, 0.07800768f, 0.04408892f, 0.09628215f, 0.06346969f, -0.01109831f, 0.01723247f, 0.00600835f, 
    0.05463441f, 0.07761922f, 0.05158054f, 0.16859251f, 0.09223744f, 0.21062417f, 0.05200296f, 0.01171325f, 
    -0.25870210f, 0.05004528f, -0.08440658f, -0.10582247f, -0.06696784f, -0.19842446f, -0.01938427f, -0.00727987f, 
    0.04574279f, -0.01648189f, 0.01040532f, 0.00734600f, 0.03873372f, 0.11010210f, 0.05288307f, 0.02152108f, 
    -0.09082205f, -0.14380856f, 0.17452183f, 0.01347437f, -0.11165131f, 0.04480752f, -0.06690712f, -0.00574393f, 
    -0.02509975f, 0.01054917f, 0.00080178f, -0.01447300f, -0.00514219f, -0.04371352f, -0.02031314f, -0.01046855f, 
    -0.17229246f, -0.02138771f, -0.10085061f, -0.28410852f, 0.03006966f, 0.10827515f, 0.06351836f, 0.02911881f, 
    -0.22454621f, -0.09795061f, 0.00756857f, -0.05473401f, 0.03669358f, -0.05397159f, -0.02748696f, 0.03214535f, 
    0.03730273f, -0.00065714f, 0.01131803f, -0.02623183f, -0.01322596f, -0.06802843f, -0.05044581f, 0.01182267f, 
    0.08110102f, -0.11372682f, -0.13244694f, 0.01568989f, -0.00657127f, -0.08107422f, 0.03157011f, 0.00824909f, 
    -0.01115209f, 0.10702959f, 0.01950186f, -0.01926095f, -0.04607434f, -0.08437867f, -0.01937997f, -0.00471759f, 
    0.11623703f, 0.05797029f, 0.12547538f, 0.03268471f, -0.15371996f, -0.36655685f, -0.50435352f, -0.40832731f, 
    -0.06374318f, -0.02353366f, -0.00936144f, 0.04130218f, 0.06767549f, -0.06044832f, -0.03404848f, -0.04527971f, 
    -0.04987021f, 0.06430057f, 0.01686372f, 0.01979644f, -0.01016876f, -0.01623155f, 0.00498883f, 0.04600923f, 
    0.02036839f, -0.21706662f, -0.11131433f, 0.11403658f, 0.14566402f, 0.05353917f, -0.06999258f, -0.04503994f, 
    -0.03021823f, 0.03272503f, 0.07485021f, 0.00210004f, 0.05588349f, -0.00443248f, 0.05390962f, 0.10574435f, 
    0.05060949f, -0.05349528f, -0.08065140f, -0.05133438f, -0.58075297f, -0.02256402f, 0.15857649f, 0.09197567f, 
    0.00442396f, 0.00197578f, -0.08889450f, -0.01703511f, -0.01619563f, -0.05085594f, 0.01189637f, -0.04267447f, 
    0.00992462f, -0.04301418f, -0.05008422f, -0.07670755f, -0.00027685f, 0.05323279f, -0.09438284f, 0.05394953f, 
    -0.01359198f, -0.17528327f, -0.20495807f, 0.00327449f, -0.00229898f, -0.10000996f, -0.03201930f, 0.04488202f, 
    0.05142194f, 0.12617040f, 0.00033652f, 0.00752208f, -0.08380521f, -0.05878040f, -0.04310783f, -0.04128978f, 
    0.04621135f, 0.06458115f, 0.04437326f, 0.03193885f, -0.49516705f, 0.14740580f, 0.17248856f, 0.14849164f, 
    -0.12851836f, -0.06050580f, -0.09880672f, -0.09140823f, -0.03301439f, -0.09438011f, -0.06915203f, -0.04596465f, 
    -0.00971469f, -0.05371696f, -0.03370173f, -0.03785510f, -0.10277012f, -0.15488678f, -0.10927412f, -0.13346298f, 
    0.03110286f, -0.10692868f, -0.32826981f, -0.01449786f, 0.06402745f, -0.03987147f, 0.06633948f, 0.05046023f, 
    0.13952406f, 0.01966332f, 0.08565481f, -0.06429090f, 0.06299064f, -0.04107048f, -0.02471935f, -0.02711855f, 
    -0.01071358f, -0.02979696f, -0.00905504f, -0.04296331f, -0.22233391f, -0.12787940f, 0.06657711f, 0.03675361f, 
    0.02868702f, -0.03349979f, 0.02960490f, -0.02788775f, -0.00237501f, 0.04039197f, 0.03632329f, 0.05050223f, 
    0.03870172f, 0.04259567f, -0.01236053f, -0.02772144f, 0.05826815f, 0.07049930f, 0.05296877f, 0.07307935f, 
    0.00335344f, -0.17682019f, 0.22407813f, 0.09330152f, 0.08585656f, -0.05984523f, -0.04561226f, -0.09833971f, 
    -0.03838614f, 0.02037472f, -0.01698820f, -0.10844883f, 0.03850348f, -0.00412486f, -0.03057836f, -0.02621035f, 
    -0.23064891f, -0.07476091f, -0.35241410f, -0.02533403f, -0.29052648f, 0.13629080f, 0.12820710f, -0.03846654f, 
    -0.16237025f, -0.07720600f, -0.05892494f, -0.05549780f, -0.03621787f, -0.08550338f, -0.07343691f, -0.04461950f, 
    -0.03282474f, -0.06517125f, -0.04402105f, -0.00206746f, 0.01955626f, -0.06989149f, -0.07524428f, -0.02981756f, 
    0.13416569f, 0.14676775f, -0.42442483f, -0.14683118f, 0.08105032f, 0.17997426f, 0.01083389f, 0.09337524f, 
    0.16308112f, -0.01808612f, 0.03788000f, 0.01292020f, 0.02590292f, 0.06875914f, 0.19994628f, 0.08231208f, 
    0.06254150f, 0.09289586f, -0.07789448f, -0.04085413f, 0.06072665f, 0.15073919f, 0.09419185f, 0.01337396f, 
    -0.04758422f, -0.01010073f, 0.11263490f, 0.00893447f, -0.00400556f, -0.05337740f, -0.04572522f, -0.05380894f, 
    0.04840389f, 0.05598610f, 0.01619947f, -0.00069733f, 0.04371664f, 0.02662659f, 0.07169875f, 0.01890623f, 
    -0.07761784f, -0.03358318f, 0.15833561f, -0.08548000f, -0.12554909f, 0.06000922f, -0.08284385f, -0.02040484f, 
    -0.04625933f, -0.18188548f, -0.01562058f, -0.01283933f, -0.00835742f, -0.02942731f, -0.02937575f, 0.05861774f, 
    -0.02002648f, -0.05833459f, -0.09578528f, -0.32821605f, -0.02979928f, -0.05954259f, -0.14468852f, 0.01075374f, 
    0.01671798f, -0.01449589f, 0.01067303f, 0.10827341f, 0.05945182f, 0.10654261f, 0.01234048f, 0.03980630f, 
    0.03692520f, -0.03144225f, 0.01412464f, -0.04647736f, 0.04132500f, 0.02959556f, 0.04140769f, 0.06812061f, 
    0.17364989f, -0.24065553f, -0.29510534f, -0.10489827f, -0.00868293f, 0.02157801f, 0.06751667f, 0.12787813f, 
    0.11577518f, 0.09170636f, 0.01415215f, -0.05626420f, -0.03744675f, -0.01536545f, 0.00031473f, 0.02462445f, 
    0.03103490f, -0.00101028f, 0.11524586f, 0.02211269f, -0.52609998f, -0.18428929f, 0.16756894f, 0.08974984f, 
    -0.00398065f, -0.06384004f, -0.01990949f, -0.06701569f, -0.04070959f, 0.00030925f, -0.10199364f, 0.01822157f, 
    0.05622972f, 0.07786614f, 0.03304332f, -0.05301372f, 0.04051640f, -0.09954667f, -0.05198916f, 0.08394489f, 
    -0.02097086f, 0.00218844f, -0.13834903f, -0.07991478f, -0.14592630f, -0.01706395f, 0.01955919f, 0.04013590f, 
    0.07176425f, 0.03384643f, 0.08226827f, 0.00009338f, 0.00718447f, 0.05981820f, -0.00630914f, 0.04164054f, 
    0.01640632f, 0.01436798f, 0.04824090f, 0.01636884f, 0.03505404f, -0.13385868f, -0.25541759f, 0.06205366f, 
    -0.13331376f, -0.06990828f, -0.03019874f, 0.21736269f, 0.11943370f, -0.00294168f, 0.05486036f, 0.08339883f, 
    0.01251271f, -0.04061287f, 0.19957182f, -0.05004696f, -0.01628997f, 0.01846381f, -0.03876293f, 0.03269036f, 
    -0.09376510f, -0.32721531f, -0.58786935f, -0.27420709f, 0.23747450f, 0.06071715f, 0.07904824f, 0.12949133f, 
    0.06827263f, -0.00465404f, -0.04146739f, -0.07017089f, -0.06095645f, 0.00306726f, -0.03287151f, 0.04071175f, 
    0.01594485f, -0.01928077f, -0.00888857f, -0.03723823f, 0.02890853f, -0.06712519f, -0.14871323f, -0.16577975f, 
    -0.09471470f, -0.05622911f, -0.10919512f, -0.06093246f, -0.01375725f, 0.00699841f, 0.00208319f, 0.05524433f, 
    0.06622475f, -0.02641382f, 0.06696714f, 0.03565221f, 0.12425498f, 0.03508836f, 0.04847773f, 0.15034811f, 
    0.12207924f, -0.14200357f, -0.18606803f, -0.07362156f, -0.00548877f, -0.02869944f, -0.08766635f, -0.06305026f, 
    0.01472171f, 0.02484036f, -0.01886298f, -0.02959291f, -0.05346352f, -0.03583272f, -0.00710512f, 0.00423091f, 
    0.07003244f, 0.11038356f, 0.08512381f, 0.11698540f, -0.44313422f, -0.06803825f, 0.16067597f, 0.09066609f, 
    0.12575965f, -0.04237998f, -0.03983120f, -0.01704532f, -0.02383227f, -0.04598808f, 0.00895596f, -0.04985508f, 
    -0.01913262f, -0.03797649f, 0.00112852f, -0.14204228f, -0.10526300f, -0.10431378f, -0.16853774f, -0.04625716f, 
    -0.41666368f, -0.03621867f, 0.10147797f, 0.11938182f, -0.05817052f, -0.00791815f, -0.04215650f, -0.02552582f, 
    0.00494823f, 0.00041249f, -0.02355154f, -0.03078000f, -0.02493459f, 0.00713149f, 0.02815704f, 0.05164522f, 
    -0.05947973f, 0.06334223f, 0.00714688f, 0.05111260f, -0.05529179f, 0.05600939f, 0.07365678f, 0.05837164f, 
    -0.03399774f, -0.08642568f, 0.08020353f, -0.03565254f, 0.00198959f, -0.03078508f, -0.07520485f, -0.00517695f, 
    0.05727817f, -0.08993226f, -0.00022598f, 0.01867747f, 0.05256490f, -0.18485709f, 0.01014549f, -0.12406579f, 
    0.14897245f, -0.35176110f, -0.24502276f, -0.21566764f, -0.08200184f, -0.09259836f, 0.23115309f, 0.10439670f, 
    0.12404404f, 0.03134970f, 0.07731860f, -0.00190939f, 0.02355515f, -0.06096098f, -0.03305644f, 0.02110796f, 
    -0.00272212f, -0.02782865f, 0.02632521f, -0.05907658f, 0.02786620f, -0.16786094f, -0.33841115f, -0.28950819f, 
    -0.15682010f, -0.08955553f, -0.15489398f, -0.06239293f, -0.12694782f, -0.24496195f, 0.00820416f, -0.00890088f, 
    -0.00252860f, 0.05818430f, 0.04766980f, 0.03174242f, 0.00728979f, 0.10331682f, -0.03856662f, -0.19620033f, 
    0.30950391f, 0.05164309f, -0.04554552f, -0.01361810f, -0.07462805f, 0.07204542f, -0.06461119f, -0.01226487f, 
    0.03050194f, -0.05087617f, -0.02268284f, 0.04016380f, 0.03301626f, -0.09103586f, 0.10785872f, -0.03524274f, 
    0.11675530f, 0.02600756f, 0.00174504f, 0.16907679f, 0.07521514f, -0.09370232f, -0.20948744f, -0.11954901f, 
    -0.06844577f, 0.04957771f, -0.02425988f, 0.02105117f, 0.09202348f, -0.08652002f, -0.04251769f, 0.04972538f, 
    -0.02380488f, -0.02647877f, 0.02187182f, -0.00776005f, 0.09647000f, 0.06507516f, 0.13064282f, -0.00250049f, 
    -0.08048443f, 0.01099865f, 0.06399519f, 0.01442016f, -0.06118547f, -0.03791570f, 0.02979432f, 0.05235779f, 
    0.02117496f, -0.00400894f, -0.00900688f, 0.09537992f, 0.07759314f, 0.10076049f, 0.05564476f, -0.00322398f, 
    0.03775796f, -0.01648171f, 0.03930727f, 0.05212547f, -0.08254243f, 0.10140067f, 0.00902859f, -0.01437294f, 
    -0.11887673f, -0.06859806f, 0.02659653f, -0.01543169f, -0.00042975f, 0.00425546f, 0.04724237f, -0.02775184f, 
    0.01287784f, 0.09889653f, 0.07947652f, 0.04448704f, 0.14332420f, 0.06601036f, 0.10472225f, 0.02180180f, 
    -0.06395069f, 0.05815761f, -0.00369072f, 0.09087903f, -0.04075731f, 0.00547387f, -0.05476736f, 0.04243594f, 
    0.00943124f, 0.03434945f, -0.01129712f, -0.04591948f, -0.05790994f, 0.02178145f, 0.05079672f, -0.01935166f, 
    0.14914371f, 0.05415177f, 0.00987628f, 0.05756879f, 0.21602291f, 0.09409931f, 0.05572360f, 0.00592835f, 
    0.19571510f, 0.14373143f, 0.06853376f, -0.05139123f, -0.08940658f, 0.06890213f, 0.12893176f, -0.03897377f, 
    0.04122322f, 0.07302111f, -0.09549099f, -0.05746805f, -0.06843152f, 0.00115252f, 0.01590723f, -0.06172429f, 
    -0.17587240f, -0.35985884f, -0.38304052f, 0.02507792f, -0.12692659f, 0.01869241f, -0.01533841f, -0.04269478f, 
    0.05270373f, -0.04246317f, 0.00536938f, -0.00379846f, 0.04960662f, 0.00469848f, -0.05113070f, 0.08014625f, 
    0.12864655f, -0.10806442f, 0.04955760f, 0.19731157f, -0.26682082f, 0.08809943f, -0.14338475f, 0.13436103f, 
    0.08613580f, 0.01251519f, -0.00171242f, -0.03377638f, -0.06820536f, -0.03474055f, 0.06367595f, 0.01688596f, 
    -0.00013164f, -0.06150089f, -0.02105974f, 0.05682122f, -0.04065355f, -0.03376830f, 0.07589441f, 0.06869284f, 
    -0.05584383f, 0.39700323f, -0.62437969f, 0.14985816f, -0.11246797f, 0.03145857f, 0.09093618f, 0.25915250f, 
    0.02703836f, 0.03468184f, 0.06287857f, -0.04919569f, -0.08419567f, -0.03567140f, -0.11311366f, 0.05012895f, 
    -0.04417930f, -0.18530686f, -0.03462477f, -0.09350859f, 0.16604516f, 0.01220507f, 0.24601181f, -0.02584028f, 
    -0.36630782f, 0.13006023f, -0.13534866f, -0.14289257f, -0.09676269f, -0.15420087f, -0.03047217f, -0.01093032f, 
    0.02321139f, 0.07124873f, 0.02069903f, 0.02050372f, 0.00785154f, -0.00560741f, -0.03048234f, 0.05298451f, 
    -0.09750276f, 0.11977150f, -0.04528917f, 0.35026988f, -0.55856270f, -0.08207885f, 0.07985339f, -0.14784710f, 
    0.05208350f, 0.03314264f, 0.10235519f, -0.08173577f, 0.09814363f, 0.04116660f, 0.03706838f, 0.06382721f, 
    -0.00644638f, -0.00506272f, 0.01250567f, -0.00667742f, 0.08780183f, -0.08225462f, 0.04138930f, -0.03524606f, 
    -0.14001372f, 0.01757484f, -0.11777104f, 0.04888117f, 0.02652280f, -0.10618280f, -0.05905185f, 0.08378311f, 
    -0.04230092f, 0.04884984f, -0.03505344f, 0.03235664f, 0.04420446f, 0.07746629f, -0.01272946f, 0.09575814f, 
    0.02105542f, -0.04015069f, -0.15921834f, 0.04134991f, -0.04307864f, 0.04516063f, 0.08251335f, 0.18865199f, 
    -0.00399016f, 0.10373637f, -0.03048238f, 0.02931834f, -0.04906204f, 0.00296953f, -0.02254593f, 0.04083919f, 
    0.00784283f, 0.08876857f, -0.01707479f, 0.02683625f, -0.61519802f, -0.21835335f, -0.43864483f, 0.23597592f, 
    0.09341324f, -0.08891350f, 0.01721933f, 0.02526724f, -0.13345727f, 0.04350381f, -0.02955423f, -0.02631316f, 
    0.04591647f, -0.04950787f, -0.13127758f, 0.00419649f, 0.01522666f, 0.01640144f, 0.07698871f, 0.15262419f, 
    -0.25534770f, -0.09786593f, -0.24396046f, -0.30594769f, 0.13008960f, 0.17729996f, 0.01164029f, 0.12828767f, 
    -0.01279762f, -0.02713336f, 0.06755763f, -0.03591314f, -0.01861347f, 0.05231787f, 0.00308346f, 0.00294200f, 
    -0.03112560f, -0.10090517f, 0.05156725f, -0.04345395f, -0.11769323f, -0.08529519f, -0.23099387f, -0.31744486f, 
    0.17471853f, 0.18044433f, 0.08517963f, 0.01800470f, 0.12016541f, 0.03602901f, 0.04053419f, 0.02052846f, 
    -0.03480696f, 0.03658310f, -0.02548198f, -0.00285441f, 0.00119000f, 0.01648732f, -0.02859032f, 0.07337216f, 
    0.06007231f, -0.18054090f, 0.08934271f, 0.24912365f, -0.46712521f, -0.12977879f, 0.03259028f, -0.08299169f, 
    0.11125477f, 0.09866364f, 0.04316844f, 0.03799654f, 0.05028023f, 0.00589525f, 0.01600497f, -0.01394622f, 
    0.08018088f, 0.12620085f, 0.16377345f, 0.10283808f, -0.32087702f, 0.11409264f, -0.23003748f, 0.12653063f, 
    -0.03483417f, -0.00823343f, -0.16298284f, 0.01633235f, -0.11569719f, -0.02404978f, 0.07583264f, -0.06757970f, 
    0.00701220f, -0.04884435f, -0.10930698f, -0.00109311f, -0.13476270f, -0.05823096f, 0.02969148f, 0.03806748f, 
    0.02834214f, -0.55450577f, 0.10904929f, -0.07852604f, -0.28414500f, -0.01323840f, -0.06259865f, -0.00370540f, 
    0.06986715f, -0.00848766f, -0.01235357f, 0.00534016f, 0.03166320f, -0.17137656f, 0.07278090f, 0.12712972f, 
    0.03718954f, -0.05605332f, -0.02394294f, 0.15578844f, -0.06439437f, 0.06052238f, -0.12747280f, -0.05166335f, 
    0.00120283f, 0.05485401f, -0.05218818f, 0.05025535f, -0.06231668f, -0.10728673f, -0.01972600f, 0.05336301f, 
    -0.07259376f, 0.03075947f, 0.06343517f, -0.06349039f, 0.07525901f, -0.02025244f, -0.05255951f, 0.15344407f, 
    -0.11047779f, 0.12401102f, 0.04141800f, 0.06538876f, -0.11556736f, 0.01932344f, 0.05217461f, 0.16441509f, 
    -0.00565897f, -0.06135331f, -0.00114534f, 0.02635200f, 0.04701581f, -0.05566609f, -0.05687655f, 0.01985341f, 
    0.07307066f, -0.07350767f, 0.01861303f, -0.03938201f, -0.28847966f, 0.04328881f, -0.27888560f, 0.05968684f, 
    -0.04017353f, 0.04835818f, -0.04668844f, 0.01585941f, 0.04440915f, -0.03910287f, 0.01831258f, -0.06582814f, 
    -0.03492539f, -0.00950197f, -0.10080778f, 0.00204474f, -0.04962963f, 0.00700695f, 0.02715659f, 0.01825632f, 
    0.13569754f, -0.10581765f, 0.22796577f, -0.24553411f, -0.10567054f, -0.04342289f, -0.11140545f, -0.17976026f, 
    0.11375749f, 0.03681945f, 0.01354085f, 0.07437614f, -0.04662148f, 0.08936597f, 0.00835664f, -0.03028509f, 
    0.04932129f, -0.06842589f, -0.04599441f, 0.09140967f, 0.00406315f, -0.11554620f, -0.15692303f, -0.11699598f, 
    -0.20129609f, 0.04667903f, -0.12485103f, 0.02990289f, -0.01779881f, -0.08047995f, -0.08286286f, 0.10443342f, 
    -0.04755218f, 0.04533559f, 0.01146573f, 0.05852499f, -0.04471210f, 0.10541444f, -0.02482912f, 0.10601346f, 
    -0.60489482f, -0.04752814f, 0.01135779f, 0.05674853f, -0.31703740f, -0.06660850f, -0.00367441f, -0.05873287f, 
    -0.02969895f, 0.20234899f, 0.06725066f, -0.03706905f, -0.01949325f, -0.02281513f, -0.05105829f, 0.03369230f, 
    -0.03674158f, 0.03936075f, -0.05764391f, -0.23494866f, 0.03480241f, 0.06026604f, -0.00907382f, 0.09116492f, 
    0.01430921f, -0.00788071f, -0.01949589f, 0.01418476f, -0.04785509f, -0.02418887f, 0.01278231f, 0.05872941f, 
    -0.03914618f, 0.08937086f, -0.11373691f, -0.01256729f, -0.00720496f, 0.03777481f, -0.10779998f, -0.01889754f, 
    0.00221055f, -0.00639480f, 0.21005774f, -0.08410146f, 0.04067450f, 0.01815540f, -0.03135777f, 0.00404460f, 
    0.03308167f, -0.08147180f, 0.04942253f, 0.08410298f, 0.06922574f, -0.07774044f, -0.02078071f, 0.07214773f, 
    0.04481818f, -0.03771122f, -0.02458516f, 0.03196603f, 0.13309395f, 0.16503567f, -0.19644615f, -0.08916204f, 
    -0.11188888f, 0.13255788f, -0.07937275f, 0.13543695f, -0.07399024f, 0.06667461f, 0.02879110f, -0.00427806f, 
    0.02701786f, -0.05848284f, -0.04714580f, -0.01226360f, -0.02174120f, -0.03027514f, -0.06887077f, -0.14301310f, 
    0.01989975f, -0.22158721f, -0.06939672f, 0.05426486f, 0.04456729f, -0.00009037f, 0.13657661f, -0.11464912f, 
    -0.09789376f, -0.09075263f, 0.04044593f, 0.09653451f, 0.01296785f, -0.05056156f, -0.00932951f, 0.06658519f, 
    0.02014647f, -0.12957212f, -0.25697985f, 0.06062577f, -0.14775711f, 0.00193573f, 0.39184818f, -0.07895117f, 
    -0.19152732f, 0.07770755f, -0.25741792f, 0.13285027f, 0.02218596f, 0.12955947f, -0.11103530f, -0.00457940f, 
    0.04530945f, -0.08188221f, -0.05955279f, 0.05310409f, -0.00983886f, -0.11699477f, -0.11538783f, -0.04448316f, 
    0.00826864f, 0.17124063f, 0.03233578f, 0.38192773f, -0.21428011f, -0.05379529f, -0.09428731f, -0.16400112f, 
    -0.12839979f, -0.24934621f, 0.08654571f, -0.03046117f, 0.00009932f, 0.06282026f, 0.06084430f, 0.04122122f, 
    0.01554930f, -0.02510236f, 0.01593071f, -0.01402272f, 0.02349263f, -0.37282947f, 0.08180884f, -0.31501493f, 
    0.10179729f, -0.05494128f, -0.01550389f, -0.03087586f, -0.02892981f, 0.08884405f, 0.02985953f, 0.00132831f, 
    0.07564440f, -0.12083194f, -0.07291400f, 0.01205902f, 0.05667644f, -0.07700254f, -0.03631905f, 0.03950404f, 
    -0.06879880f, 0.03177724f, -0.07854857f, -0.09868540f, -0.02270123f, 0.08536222f, 0.00177533f, 0.11298309f, 
    0.03569986f, -0.01260059f, 0.04510805f, -0.04101563f, -0.04912569f, 0.03490239f, -0.00760689f, 0.03986203f, 
    -0.00264533f, 0.02479962f, -0.04055617f, 0.04957030f, -0.20103206f, -0.17167963f, -0.14890523f, 0.08107327f, 
    -0.38565713f, -0.03149145f, -0.37749133f, 0.10426857f, 0.03270083f, 0.18853065f, -0.00959800f, 0.04455068f, 
    0.09253119f, 0.00533276f, -0.02543529f, -0.00373810f, 0.04402426f, 0.04849199f, 0.12294872f, 0.00397450f, 
    0.16075234f, -0.04878042f, -0.03725861f, -0.01897566f, -0.31839979f, -0.01764280f, 0.04691509f, 0.14861205f, 
    -0.06495302f, 0.05014053f, 0.02366107f, -0.07176180f, -0.00043028f, -0.08453055f, 0.00260912f, -0.02641143f, 
    -0.02852851f, -0.08359326f, -0.07735378f, -0.17535807f, -0.00437625f, 0.47028077f, -0.56927204f, 0.12349936f, 
    -0.12140797f, 0.12773028f, 0.15746364f, 0.27483267f, 0.00602723f, 0.22699608f, 0.02631569f, 0.00699148f, 
    -0.03062361f, -0.02995807f, -0.06666569f, 0.00914173f, -0.01383232f, -0.09430227f, 0.03425088f, -0.05152545f, 
    -0.01194806f, -0.52222437f, -0.48754734f, 0.07123645f, 0.09297223f, 0.13359985f, -0.03855258f, 0.16293792f, 
    0.07137725f, 0.07553472f, -0.01666532f, 0.01565422f, 0.00490818f, -0.00573881f, -0.03653642f, -0.02356370f, 
    0.06005721f, 0.09789512f, 0.08602797f, 0.19462782f, -0.13251135f, -0.01949607f, -0.01033537f, 0.22729766f, 
    0.15706129f, 0.00682059f, -0.02575624f, 0.02888216f, -0.02604439f, -0.01557679f, -0.00895167f, -0.03406188f, 
    0.03449100f, -0.01825923f, -0.07244169f, 0.05950764f, 0.04711014f, 0.00441257f, 0.01228451f, 0.03497069f, 
    -0.03719299f, -0.02773228f, 0.21458890f, 0.11392616f, -0.06259682f, 0.06263974f, -0.02750901f, -0.09822553f, 
    -0.03440505f, -0.04050028f, 0.06879359f, -0.03480810f, 0.02228490f, 0.02888067f, -0.00254771f, -0.03674147f, 
    -0.05999207f, -0.04055136f, -0.01797740f, -0.00032828f, -0.13116992f, -0.01292512f, 0.47936058f, 0.39981255f, 
    -0.59943348f, 0.21645528f, -0.17620608f, -0.04172428f, 0.08193823f, 0.25878760f, 0.02087535f, 0.02294593f, 
    0.05364685f, 0.04400012f, 0.01095151f, -0.02331208f, 0.02461269f, 0.06735724f, 0.00553918f, 0.04128167f, 
    -0.01438132f, -0.34075943f, 0.00150293f, -0.34584531f, 0.00061659f, -0.06297655f, -0.05884209f, -0.14324608f, 
    -0.00498908f, -0.03311486f, 0.13341568f, -0.16113177f, 0.01438600f, 0.07903101f, -0.11717705f, 0.10077570f, 
    0.03752135f, -0.01236852f, -0.16891934f, -0.10295587f, 0.07795974f, -0.10020484f, -0.27306587f, -0.07751662f, 
    0.00413919f, -0.00116472f, -0.02430700f, 0.16720280f, 0.03954552f, 0.12716959f, -0.03912190f, -0.06788217f, 
    0.00901256f, -0.03282712f, -0.03111248f, -0.01725929f, 0.07206475f, 0.09860143f, 0.04226110f, -0.05175294f, 
    0.02490959f, 0.00252548f, 0.15914580f, -0.06623262f, -0.03232391f, -0.00153883f, 0.06808076f, -0.13867186f, 
    -0.12007862f, 0.04807977f, 0.00823925f, 0.02117087f, 0.08387092f, 0.05179365f, -0.02607567f, 0.04874882f, 
    -0.06061710f, -0.02383952f, -0.04855376f, 0.00106796f, -0.12624717f, -0.03889425f, -0.29059282f, 0.04869404f, 
    0.08278237f, 0.08555455f, 0.03672355f, 0.13616651f, -0.02524603f, 0.17165259f, -0.03514016f, 0.01072710f, 
    -0.03164813f, 0.04338615f, -0.02086745f, -0.00957225f, 0.05172461f, 0.02542615f, -0.02623641f, 0.08037481f, 
    0.00669894f, 0.14047098f, 0.15354428f, 0.48243681f, -0.16625148f, -0.04597322f, 0.07338316f, -0.23768549f, 
    -0.03895188f, -0.24399292f, 0.09785198f, -0.04560654f, 0.00692531f, 0.06541417f, 0.00544363f, 0.07688188f, 
    0.03692222f, -0.02758211f, 0.05045469f, 0.10026270f, 0.03230285f, -0.04794676f, 0.29383650f, -0.24950823f, 
    -0.03670691f, -0.02140278f, -0.09226891f, -0.09341905f, 0.12864867f, 0.08162659f, -0.01445168f, 0.04760456f, 
    0.05091611f, -0.00318626f, -0.00906063f, -0.01313516f, 0.04271610f, -0.07123822f, -0.07852156f, 0.01086180f, 
    0.01212106f, -0.41812786f, 0.08677088f, -0.29499945f, 0.15818208f, 0.00322819f, -0.06635454f, -0.06328399f, 
    -0.02900738f, -0.02463436f, 0.00405528f, -0.00673934f, 0.08911790f, 0.04065767f, -0.07905120f, -0.13174650f, 
    0.06921872f, -0.00552473f, 0.04842570f, 0.08205980f, -0.12877525f, -0.02806342f, -0.29971510f, 0.03274090f, 
    0.05481246f, 0.01633896f, 0.06041178f, 0.14008301f, -0.02619587f, -0.03771573f, 0.04657493f, -0.00657533f, 
    0.06459881f, 0.06846081f, -0.05715960f, 0.07822519f, 0.14686924f, 0.10585696f, 0.02062225f, 0.11041225f, 
    -0.42434946f, -0.18561757f, -0.09288938f, 0.27991039f, -0.17808382f, -0.20966145f, 0.07682842f, -0.20446137f, 
    -0.00877366f, 0.07054295f, 0.06990944f, -0.09330587f, 0.00774114f, 0.05972303f, 0.11841644f, 0.08090353f, 
    0.09350980f, -0.01135641f, 0.08186121f, 0.11782210f, -0.40685657f, 0.06080893f, -0.21280749f, 0.06257816f, 
    0.08248797f, -0.06142195f, 0.16266248f, 0.12920181f, -0.17004782f, -0.00116250f, 0.07041786f, 0.06669380f, 
    -0.03584496f, -0.01897047f, 0.00569949f, 0.01229523f, 0.17737128f, -0.13376337f, 0.03171964f, 0.01330612f, 
    0.21748808f, -0.17240083f, -0.40000296f, 0.16368467f, 0.12151596f, 0.04227557f, 0.04438651f, 0.11907792f, 
    -0.02810719f, 0.20681232f, -0.00199092f, 0.01151778f, -0.03338335f, 0.01611853f, -0.04600900f, -0.00605878f, 
    0.04740607f, 0.09125465f, 0.08206739f, 0.13566235f, 0.18115917f, 0.09494751f, 0.15863918f, 0.13178152f, 
    -0.03489966f, -0.02225571f, 0.07595415f, -0.18890920f, -0.15158129f, -0.02792832f, -0.00492662f, -0.04567147f, 
    0.11804502f, 0.01908461f, -0.00611612f, 0.04537795f, -0.00854960f, -0.07211008f, 0.00846883f, 0.01022167f, 
    -0.38353184f, 0.02467972f, -0.06856676f, 0.17868875f, -0.35597605f, 0.05032989f, -0.31310895f, -0.08414919f, 
    -0.06225192f, -0.01152587f, -0.02800279f, -0.00454063f, -0.02861798f, -0.02231012f, -0.02052084f, -0.04286030f, 
    -0.05477897f, 0.00730162f, -0.00985595f, 0.01580604f, 0.14341690f, -0.15458202f, 0.05554610f, -0.56088388f, 
    0.01667991f, -0.04287595f, -0.13213253f, 0.01011971f, 0.09922436f, -0.08244639f, -0.04941382f, -0.00970175f, 
    0.09405182f, -0.17864174f, 0.00929067f, 0.08661622f, 0.18459222f, -0.01058054f, -0.03046604f, 0.13017322f, 
    -0.11555362f, 0.18190636f, -0.06142415f, 0.33217987f, 0.13085043f, -0.19155724f, 0.08668673f, -0.18537612f, 
    0.10915890f, -0.09227284f, 0.03707068f, -0.06148926f, 0.02989766f, 0.02820648f, -0.03442274f, -0.00463684f, 
    0.04511236f, -0.01557610f, -0.05984608f, 0.01144733f, -0.30080202f, -0.18571433f, 0.03344942f, 0.05879451f, 
    0.14271149f, -0.35310546f, 0.22055261f, -0.20861247f, -0.29147765f, 0.06565088f, 0.01108199f, -0.07040381f, 
    0.05507050f, -0.01296988f, -0.00897812f, 0.15029511f, 0.06817720f, -0.02686312f, -0.04520863f, -0.04516855f, 
    0.05337840f, 0.11976497f, -0.08080284f, 0.35581270f, -0.57417333f, 0.00919153f, -0.02633241f, -0.15825756f, 
    0.13546588f, -0.04813072f, 0.03999075f, -0.04588206f, 0.04449553f, 0.06731966f, 0.07580572f, 0.04051704f, 
    0.05531346f, 0.08908138f, 0.05332937f, 0.02086034f, -0.07253116f, -0.25034115f, -0.24038412f, 0.13682777f, 
    0.02499463f, -0.21826573f, 0.17533226f, -0.11198365f, -0.00942205f, -0.11873329f, -0.13743053f, 0.00664231f, 
    -0.01486073f, -0.06696889f, -0.02105640f, 0.08578391f, -0.01098738f, -0.06132491f, -0.14846465f, -0.04883210f, 
    -0.08996952f, 0.03390234f, 0.13369188f, 0.09379615f, -0.10413554f, 0.08817764f, -0.05622831f, -0.00651456f, 
    0.04762069f, 0.02953744f, 0.06517214f, 0.04265691f, 0.01004243f, -0.04497166f, -0.01274762f, 0.02146295f, 
    -0.05968310f, -0.06336932f, -0.01835562f, -0.16444142f, -0.02986261f, -0.13833669f, -0.39484555f, -0.06333650f, 
    -0.02865250f, 0.02064585f, -0.05097051f, 0.15235263f, -0.00665068f, 0.03183650f, -0.02318086f, 0.00955191f, 
    0.08615822f, 0.00680645f, -0.00294311f, 0.03613403f, 0.11388649f, 0.06858111f, -0.09797482f, 0.10004194f, 
    -0.20308796f, 0.23447917f, -0.30184934f, -0.17832331f, -0.22169845f, 0.08031036f, -0.07580629f, 0.09973934f, 
    -0.11404181f, 0.12331530f, -0.03619569f, 0.05137639f, -0.07855553f, -0.01867498f, 0.08889533f, -0.08874588f, 
    0.03105465f, 0.08464472f, 0.00765193f, 0.00962175f, -0.04244211f, 0.07120083f, -0.18565804f, -0.07233642f, 
    0.01801348f, 0.05441391f, -0.08335400f, 0.05256756f, 0.01077366f, -0.07914437f, -0.03059485f, 0.01694364f, 
    0.02918495f, 0.00938858f, 0.01210605f, 0.08310685f, 0.10182962f, 0.04871357f, 0.02955600f, 0.11897528f, 
    -0.24232846f, 0.27574942f, 0.14161937f, 0.42112947f, -0.32288030f, 0.25884622f, -0.14834477f, -0.15486380f, 
    -0.30249557f, -0.15001652f, 0.06521537f, 0.01546850f, 0.05377425f, 0.00035982f, 0.07334180f, -0.00183396f, 
    -0.03393770f, -0.05228354f, 0.00279363f, 0.02094476f, -0.15312383f, -0.12866998f, 0.15605538f, 0.19901899f, 
    -0.27526456f, 0.04885988f, -0.14306757f, -0.10271183f, -0.03895355f, 0.17540191f, 0.06162877f, 0.02625519f, 
    0.04821488f, 0.07328377f, 0.00398958f, -0.01196728f, 0.07706854f, 0.13022158f, 0.15917099f, 0.08572745f, 
    0.22330183f, -0.66429991f, -0.21551232f, 0.08557128f, -0.10316013f, -0.09098251f, 0.07781842f, 0.06486791f, 
    -0.01723395f, 0.09525325f, -0.06049922f, -0.05213759f, -0.08888275f, -0.09046248f, -0.08552175f, 0.00758328f, 
    -0.00428382f, 0.01136727f, -0.14927162f, -0.01650402f, -0.21743548f, -0.08257639f, 0.00128335f, -0.13155366f, 
    0.02081697f, -0.13215977f, -0.11335481f, 0.11339646f, 0.05601358f, 0.20692435f, -0.03826264f, -0.02948643f, 
    0.00160170f, -0.04584460f, -0.03767962f, 0.05749394f, 0.02209696f, 0.07805098f, 0.02530733f, -0.05591989f, 
    -0.07860549f, 0.01704666f, -0.00853255f, -0.05212146f, 0.23552793f, -0.08451538f, 0.12615521f, 0.00549452f, 
    -0.01819915f, -0.03564366f, 0.02622553f, 0.10150226f, 0.01603582f, -0.00944174f, 0.06015689f, 0.05103317f, 
    0.12947389f, -0.06982540f, -0.02478147f, 0.03428112f, -0.14545117f, 0.09954777f, -0.00341214f, -0.10449805f, 
    0.10431722f, 0.09278572f, 0.11028119f, 0.06947555f, 0.01043832f, -0.14189310f, 0.12270618f, 0.00873706f, 
    -0.02656789f, 0.00810027f, 0.02656537f, 0.07721091f, -0.01845548f, -0.06568962f, -0.02682907f, -0.04661260f, 
    -0.03222969f, -0.13032293f, -0.10053510f, -0.01931449f, 0.06503085f, -0.04073885f, 0.12082919f, 0.04252144f, 
    0.09914234f, -0.02240577f, 0.03414884f, -0.01708334f, -0.01192167f, -0.01862164f, -0.01747572f, 0.04754198f, 
    -0.01453251f, -0.10744958f, -0.04039829f, -0.05150301f, -0.36501762f, -0.42857760f, -0.09827244f, -0.15169278f, 
    -0.12623709f, 0.09965048f, -0.18734102f, 0.04937379f, -0.08389948f, -0.15934716f, -0.06938408f, 0.04203081f, 
    -0.07142051f, -0.15520416f, 0.14075798f, 0.05784938f, -0.01518377f, -0.06896722f, -0.00775132f, 0.06647215f, 
    -0.34892070f, 0.09667116f, -0.33424798f, 0.31891543f, 0.06652655f, -0.03425853f, 0.08029934f, 0.17955112f, 
    0.21649382f, -0.08819694f, 0.01594537f, -0.01032038f, 0.00401031f, 0.01110331f, -0.02633809f, -0.02455456f, 
    -0.19598414f, -0.28231949f, -0.21623558f, -0.12611307f, 0.24054857f, -0.17545821f, 0.18868196f, -0.06678542f, 
    -0.06853490f, -0.07780191f, 0.00348137f, 0.04621725f, 0.06959144f, -0.08077781f, 0.02117019f, 0.02888563f, 
    0.01716360f, 0.01256386f, 0.04712902f, 0.06181250f, 0.04295510f, 0.02151515f, -0.01076657f, -0.14190757f, 
    -0.40010864f, -0.45229730f, -0.07602611f, -0.14493696f, 0.02030691f, -0.06677669f, -0.04891189f, 0.17788391f, 
    -0.11914299f, 0.00785203f, -0.09587440f, 0.09577356f, -0.03658438f, 0.02744041f, 0.02661996f, 0.08519097f, 
    0.01166543f, 0.08552984f, 0.05994308f, 0.11837132f, -0.11284661f, 0.09231260f, 0.13924819f, 0.08173528f, 
    0.07166558f, 0.01692255f, 0.03327687f, -0.19082983f, -0.04543484f, -0.00333154f, 0.01237689f, -0.02857010f, 
    -0.05838244f, 0.01969023f, 0.02783583f, -0.02805798f, -0.06325505f, 0.06789439f, 0.02866214f, 0.07887083f, 
    0.00859687f, 0.12622105f, -0.09723105f, 0.09805268f, 0.18054329f, 0.10467281f, -0.05538227f, 0.00600413f, 
    -0.06652126f, 0.04861199f, -0.13188966f, 0.06074788f, -0.03683899f, -0.01340137f, -0.00909265f, 0.06340463f, 
    -0.06396079f, -0.09284770f, -0.01179151f, 0.01373994f, -0.10694787f, 0.07389595f, -0.05958210f, -0.04442639f, 
    -0.09599418f, 0.05189085f, -0.04601413f, -0.02592347f, 0.02831757f, -0.01336850f, 0.07497068f, -0.01094994f, 
    -0.02791062f, -0.02893674f, -0.06133099f, 0.02854744f, -0.05532080f, -0.01855667f, 0.01653140f, -0.15771817f, 
    -0.03667688f, -0.38966769f, -0.39754748f, 0.02632293f, -0.29854912f, -0.11253287f, -0.22221620f, -0.00969352f, 
    -0.12478854f, -0.06514952f, 0.00958434f, 0.00558265f, -0.12066705f, 0.00725621f, 0.05787532f, -0.05398954f, 
    -0.00479342f, -0.05198740f, 0.00509770f, 0.01231654f, 0.33588848f, -0.20642200f, 0.05647251f, -0.12955846f, 
    0.00680659f, -0.05992028f, -0.05562737f, 0.07521254f, -0.00805067f, -0.04498667f, 0.01402590f, -0.09033538f, 
    -0.10055833f, -0.01565119f, 0.09684870f, 0.00363112f, -0.17961352f, -0.01698204f, -0.14320591f, -0.14705494f, 
    -0.20951279f, -0.10380542f, -0.11238195f, 0.04321801f, 0.03921933f, -0.13060188f, 0.02588008f, -0.16245830f, 
    0.18773848f, -0.03125058f, -0.15593585f, 0.02504757f, 0.00882273f, -0.04641549f, 0.04393895f, 0.04922164f, 
    -0.05669899f, -0.08671109f, 0.11470328f, -0.08759210f, -0.01154361f, -0.00774783f, 0.22564657f, 0.13060381f, 
    -0.06279831f, -0.03683126f, 0.07756846f, -0.05080925f, 0.08713740f, -0.12100334f, -0.10065570f, -0.00750787f, 
    -0.04310634f, -0.02355117f, -0.02581845f, -0.00424826f, -0.02695718f, 0.03107991f, -0.06180236f, -0.08428603f, 
    -0.26561758f, 0.00227881f, -0.65850204f, -0.10630743f, 0.00189059f, -0.05140707f, -0.01585778f, -0.01665344f, 
    -0.11154642f, -0.01721478f, -0.00274379f, 0.10237106f, 0.02973864f, -0.00349621f, 0.01273895f, 0.03641583f, 
    -0.04465374f, -0.08843265f, -0.09113842f, -0.13968533f, 0.24202856f, -0.10613468f, 0.18208723f, -0.00268419f, 
    -0.03242533f, -0.08754154f, 0.12707525f, 0.12513508f, 0.12926961f, 0.09567276f, -0.10355125f, 0.09156797f, 
    -0.00051084f, -0.08825386f, -0.01371211f, 0.01118229f, -0.02120003f, 0.04028295f, 0.07003965f, -0.07963029f, 
    -0.31646919f, 0.23440166f, 0.05148751f, 0.33457738f, 0.02132064f, 0.09873960f, -0.08730326f, -0.02720154f, 
    0.03055584f, 0.05881848f, -0.00414295f, 0.04388823f, -0.01794340f, -0.07737881f, -0.10097902f, -0.02484304f, 
    -0.13526034f, -0.01461176f, -0.26077607f, -0.21664998f, 0.04099832f, -0.01551267f, 0.08871004f, 0.11932717f, 
    -0.03453329f, -0.04780405f, -0.03774846f, 0.04642851f, -0.03700979f, -0.03405745f, 0.00878104f, -0.06072115f, 
    -0.08474864f, 0.14375573f, 0.07082529f, 0.01806339f, -0.03239165f, 0.10161427f, -0.07598814f, 0.06595273f, 
    -0.20455849f, -0.21895115f, -0.02045226f, 0.11799117f, -0.03405003f, -0.13232809f, -0.03207702f, -0.03145836f, 
    -0.01919322f, -0.07100482f, -0.05838755f, -0.04588358f, 0.05213610f, 0.05763181f, 0.12581505f, 0.12568139f, 
    0.00284699f, 0.07742540f, 0.04957084f, 0.11562122f, 0.02815947f, -0.26112133f, 0.24931031f, -0.02690500f, 
    0.06212134f, -0.12671907f, -0.06326314f, 0.03507307f, 0.07241011f, -0.01291829f, -0.00909033f, -0.05516816f, 
    -0.00782451f, 0.02291387f, -0.00005061f, 0.02683581f, 0.06747711f, 0.05387800f, 0.13943514f, -0.05970062f, 
    -0.02134234f, 0.15126207f, 0.05508222f, 0.10231521f, 0.01680245f, 0.04030475f, -0.04495392f, -0.08716777f, 
    -0.03685674f, 0.06236004f, -0.06798074f, -0.07649758f, 0.02709714f, -0.04900280f, -0.06539199f, -0.01704678f, 
    -0.01505103f, 0.01224234f, 0.06274179f, 0.00888581f, -0.18675032f, 0.06737895f, -0.03737757f, -0.05318783f, 
    -0.05395658f, -0.01614754f, -0.00143958f, 0.00876774f, -0.00080129f, -0.04933489f, 0.10496783f, -0.01556385f, 
    -0.06001066f, 0.06962636f, 0.02481745f, 0.01195769f, -0.09300616f, -0.02877714f, -0.10234178f, -0.15762371f, 
    -0.17661729f, -0.06439771f, 0.03291961f, -0.13371697f, 0.18177779f, -0.12881930f, 0.06971297f, 0.24933225f, 
    0.02732146f, 0.02781479f, -0.02947291f, 0.11013759f, 0.02201235f, -0.01219661f, 0.03666912f, 0.05337493f, 
    -0.03953800f, 0.05514272f, 0.02897420f, 0.05614361f, 0.03535613f, -0.05941514f, -0.01411927f, 0.04072527f, 
    -0.09801739f, -0.03211502f, -0.02753124f, 0.07041436f, -0.00212937f, 0.08162466f, -0.04686662f, 0.03505136f, 
    -0.08292370f, 0.03461194f, -0.05329681f, 0.00802696f, 0.03977099f, 0.09145321f, 0.06973322f, -0.03645271f, 
    0.02569372f, -0.22769246f, -0.06738123f, 0.03233004f, -0.09652901f, -0.08208763f, 0.00442412f, -0.03445859f, 
    0.00483904f, 0.05188196f, -0.01084076f, -0.10175065f, 0.10421486f, 0.03925378f, -0.03259408f, -0.05638191f, 
    -0.02845803f, 0.05641162f, 0.12560906f, 0.09382918f, -0.35628045f, -0.03888675f, -0.07773364f, 0.09608607f, 
    0.05387855f, 0.02125179f, -0.04614839f, -0.14495610f, 0.22305694f, 0.03646068f, -0.02299829f, 0.02440826f, 
    0.01241466f, 0.00778833f, -0.09395582f, 0.05582066f, 0.01056749f, -0.16408749f, 0.08759499f, 0.01979738f, 
    -0.53327537f, 0.07233559f, -0.18832919f, -0.02117309f, -0.11211091f, -0.02346773f, -0.03367588f, 0.13207541f, 
    0.15472844f, 0.13768753f, -0.10653069f, 0.06105142f, -0.03384586f, -0.06690682f, -0.08098000f, -0.09751317f, 
    0.12418107f, 0.13910732f, 0.17021835f, 0.27746230f, -0.08494692f, -0.07360721f, -0.10827213f, 0.22908619f, 
    -0.01341865f, -0.10717816f, 0.10853399f, -0.03370050f, -0.07006945f, -0.04519172f, -0.03135740f, -0.08485318f, 
    0.11820635f, 0.05872636f, 0.12901430f, 0.06395186f, -0.04276776f, 0.03021106f, 0.05808570f, 0.18405026f, 
    0.13463277f, 0.05236368f, 0.22881857f, -0.02206247f, 0.03155979f, -0.04312807f, -0.04666222f, -0.03891297f, 
    0.04155154f, 0.09675238f, -0.05766855f, 0.07417684f, -0.03437660f, 0.05136180f, -0.04968587f, 0.06178388f, 
    -0.02558706f, -0.00917295f, 0.09550016f, 0.08712585f, -0.15619798f, 0.22173041f, 0.18100020f, 0.18704526f, 
    0.01574715f, 0.12588902f, -0.04413844f, -0.02484550f, 0.13916117f, 0.11968155f, -0.20833091f, -0.01811291f, 
    0.00885024f, -0.02007267f, 0.01158436f, -0.03765038f, -0.00715717f, 0.04296413f, 0.02902401f, 0.03369895f, 
    -0.04764274f, -0.12484839f, 0.02244256f, 0.02582052f, -0.07542889f, -0.07225695f, -0.02922628f, -0.01566153f, 
    0.01378064f, 0.02790783f, -0.03952879f, -0.03327841f, 0.00514151f, 0.02588592f, -0.01972024f, -0.07845433f, 
    0.08885611f, 0.08047605f, 0.12325664f, -0.01951987f, -0.39157602f, -0.07299480f, 0.04158595f, -0.02069871f, 
    0.11573967f, -0.11645871f, -0.04650096f, -0.19433767f, 0.09344252f, -0.00208030f, -0.01166889f, 0.06902824f, 
    0.02532211f, 0.12230090f, 0.01920309f, 0.05084424f, -0.01757467f, -0.09494987f, 0.03704591f, -0.09508126f, 
    -0.54948825f, 0.09405377f, 0.05165181f, 0.19457223f, 0.04106830f, 0.07691518f, -0.11628027f, 0.04939607f, 
    0.31579122f, 0.09262455f, -0.02106799f, 0.06478162f, 0.04118384f, 0.07886294f, -0.02856526f, 0.06633453f, 
    0.03940850f, -0.09427252f, 0.25313982f, 0.30333719f, -0.33887827f, -0.35881507f, -0.06862893f, -0.02449320f, 
    0.03426069f, -0.08219189f, -0.14713921f, 0.10651387f, -0.10045845f, -0.04511897f, -0.10324039f, 0.08717440f, 
    0.00776062f, -0.02763838f, -0.00829815f, 0.04930400f, -0.04541304f, 0.03140481f, 0.01615991f, 0.01806142f, 
    -0.12088382f, -0.08101185f, -0.28173777f, 0.07947008f, 0.13172302f, -0.11116827f, 0.07289022f, -0.04319670f, 
    -0.04516210f, -0.11724854f, 0.00806849f, 0.02512605f, -0.04712616f, 0.03381592f, -0.02911643f, 0.07318774f, 
    -0.22224025f, -0.23586240f, -0.18654941f, -0.15198432f, 0.22006807f, -0.22802772f, 0.17131829f, -0.07072214f, 
    -0.12930365f, -0.03398788f, -0.07568665f, 0.04693392f, -0.01526600f, -0.06489841f, 0.02536138f, 0.01060647f, 
    -0.11207712f, -0.01824233f, -0.07095197f, -0.05502160f, -0.00668518f, 0.02329093f, -0.11073051f, -0.06051598f, 
    -0.27211446f, 0.04646878f, 0.00480919f, -0.01741281f, 0.00533788f, -0.02535961f, 0.05791279f, -0.00901602f, 
    -0.01020649f, 0.03496867f, 0.00596827f, -0.00517635f, -0.02057160f, 0.01675728f, -0.03629803f, 0.04420409f, 
    0.04491952f, -0.00335195f, 0.09280505f, 0.14426214f, -0.33322427f, 0.02330787f, -0.25599283f, -0.09505548f, 
    0.04835127f, -0.10199784f, -0.05779399f, -0.10626614f, 0.04785482f, -0.01603130f, -0.03347137f, 0.04319998f, 
    -0.02079070f, -0.08352674f, 0.00582455f, 0.02945730f, -0.03407965f, -0.03289215f, 0.00838307f, -0.02691481f, 
    -0.25506186f, 0.23074885f, -0.51088548f, 0.22319010f, 0.21362980f, -0.06690647f, 0.04948102f, 0.01772608f, 
    0.06861255f, 0.19903071f, -0.11244733f, -0.00904532f, 0.02655223f, -0.05349259f, 0.00871607f, -0.02609100f, 
    0.19936804f, -0.25021634f, 0.10640655f, 0.01158490f, -0.06047930f, -0.07580245f, -0.38300803f, 0.22620118f, 
    -0.09759594f, -0.05259583f, -0.10480355f, 0.00027284f, -0.04255800f, 0.02586472f, -0.06852081f, 0.05446975f, 
    -0.06768010f, -0.05839672f, 0.02202769f, -0.05782851f, -0.08052038f, -0.02828209f, 0.00514591f, 0.03773984f, 
    0.10301401f, -0.02325854f, 0.07474127f, -0.03198317f, 0.07434488f, -0.01602087f, 0.07775437f, 0.11647647f, 
    0.06214251f, -0.02887709f, -0.04255316f, 0.02741326f, 0.06555201f, 0.02720083f, -0.06447650f, 0.05257362f, 
    0.07688203f, 0.13953683f, 0.10827173f, 0.16123880f, 0.05577175f, -0.20994291f, -0.01275866f, -0.06005215f, 
    -0.02721658f, -0.13968638f, -0.06487918f, 0.03009870f, -0.12714869f, -0.11203465f, -0.05389798f, -0.02655296f, 
    -0.10308335f, 0.02368116f, 0.03174082f, 0.04669544f, -0.18528645f, -0.08891971f, -0.07469136f, -0.08827227f, 
    0.00897590f, 0.20354578f, -0.01361016f, -0.10389774f, -0.04879895f, 0.09704622f, -0.10379271f, 0.01350636f, 
    0.03738927f, -0.02364372f, -0.15036729f, 0.06422605f, -0.07372305f, -0.11222306f, -0.11740599f, -0.09531529f, 
    -0.09607153f, 0.01474952f, -0.04705761f, -0.09371222f, 0.03035405f, 0.01831607f, 0.03480495f, 0.05712246f, 
    0.03562829f, -0.02186324f, 0.01944290f, -0.04210904f, 0.01755871f, 0.07416093f, -0.01749280f, -0.06201371f, 
    0.05594344f, 0.01094925f, 0.03938926f, -0.02693630f, -0.03165039f, 0.05414559f, 0.08501527f, 0.06731302f, 
    -0.27457127f, 0.37242851f, 0.07905781f, 0.16538487f, 0.00526624f, -0.01396243f, -0.03204262f, -0.08865244f, 
    0.15947390f, 0.01230793f, -0.10490447f, -0.03719086f, -0.09493505f, -0.03340314f, 0.07497667f, -0.24720524f, 
    0.18806680f, -0.25129825f, -0.02226179f, -0.09787452f, -0.01662174f, -0.34597161f, -0.10792578f, -0.04008401f, 
    -0.23495141f, -0.12943713f, -0.14538002f, -0.04693621f, -0.09314628f, -0.04442273f, -0.09805889f, 0.01267461f, 
    -0.01707098f, 0.00105735f, 0.03857944f, 0.07074719f, -0.04835065f, -0.08285256f, 0.00694187f, -0.00241993f, 
    -0.08988786f, 0.16172835f, -0.32573852f, 0.12188782f, 0.03543503f, 0.12036458f, -0.00807262f, 0.09247400f, 
    -0.11672946f, -0.04901430f, -0.03975604f, -0.00062073f, -0.07577442f, -0.05912039f, 0.01874096f, -0.01324575f, 
    -0.11586277f, -0.16094123f, 0.00459773f, -0.02338633f, 0.00669277f, -0.20235877f, 0.14263305f, -0.12718584f, 
    -0.03014841f, 0.01332949f, -0.01933058f, 0.20055400f, 0.06670892f, 0.01663385f, -0.05725980f, 0.05877678f, 
    0.06624997f, 0.02451747f, 0.13468093f, 0.07107138f, 0.04121790f, 0.17303783f, -0.03931360f, 0.00954855f, 
    -0.02120564f, -0.08408902f, -0.17158847f, -0.04001349f, 0.00254798f, -0.04243680f, -0.05922095f, 0.09714884f, 
    -0.23330891f, -0.13758922f, 0.01463740f, 0.05221307f, -0.01754675f, 0.02761092f, 0.00147126f, 0.08432445f, 
    -0.16808541f, -0.22283684f, -0.19680703f, -0.15699485f, 0.12920916f, -0.01244949f, -0.04293939f, 0.12767123f, 
    0.08821700f, 0.05984581f, 0.03814794f, -0.01083255f, -0.00995599f, 0.01808374f, -0.04221869f, 0.04402447f, 
    0.01467344f, -0.01945838f, -0.06917796f, 0.00615508f, 0.04460598f, 0.05572903f, 0.06100955f, -0.02028230f, 
    -0.02088371f, -0.00614671f, 0.17591751f, -0.02239140f, 0.07935131f, -0.04100757f, 0.02311134f, -0.12562872f, 
    0.09585104f, -0.03679233f, -0.03856349f, 0.04888306f, -0.06090974f, -0.01384582f, 0.01074329f, 0.06700722f, 
    0.08247663f, 0.01164311f, 0.15091202f, -0.00312762f, -0.12726831f, 0.16383128f, 0.26122299f, 0.19106840f, 
    -0.12802006f, 0.07689757f, -0.03741227f, -0.16615030f, -0.10206896f, 0.06295626f, 0.00638251f, 0.16170736f, 
    0.08218772f, 0.01873543f, -0.15052710f, -0.11698053f, 0.00283226f, -0.07438184f, -0.01886207f, -0.00096966f, 
    0.16862868f, -0.09260295f, 0.17817272f, -0.04541524f, -0.10645658f, -0.00099052f, -0.10999586f, -0.04143498f, 
    0.00498583f, 0.02561469f, -0.07151226f, 0.07948541f, -0.07124197f, 0.01221575f, -0.06994059f, -0.00984150f, 
    0.01116953f, 0.01495332f, 0.04125884f, -0.06631847f, 0.46559620f, -0.14766374f, 0.37730801f, 0.03020041f, 
    0.01753804f, 0.17343554f, -0.02941042f, 0.10290808f, 0.03576122f, -0.02230385f, 0.05736516f, 0.07020542f, 
    0.01069808f, 0.03059806f, -0.12488451f, -0.02479545f, 0.10933156f, 0.07799636f, 0.01342661f, -0.00949232f, 
    -0.06865794f, 0.02273064f, -0.10020423f, -0.06857440f, -0.01095751f, -0.00304575f, -0.02277055f, -0.08495002f, 
    0.06469069f, 0.01664562f, -0.10613300f, 0.07786461f, 0.03152257f, -0.15876867f, -0.18312381f, 0.04011655f, 
    0.00625170f, -0.00896549f, -0.01370727f, -0.07501403f, 0.06660052f, -0.00448246f, 0.02911296f, 0.05310241f, 
    0.09620222f, 0.06460693f, 0.01160552f, 0.11622680f, -0.18409862f, 0.10089084f, -0.14557841f, 0.08147360f, 
    -0.05818943f, 0.06472743f, 0.17312640f, -0.10248862f, -0.02395416f, -0.01007989f, 0.01398798f, 0.19377342f, 
    -0.24313374f, -0.06658489f, 0.06322648f, 0.02183700f, 0.11380810f, -0.13479333f, 0.03754063f, 0.05400411f, 
    0.03515485f, 0.00485518f, -0.00131513f, 0.02788704f, -0.03194747f, 0.04908055f, 0.05593321f, 0.07680393f, 
    0.03187348f, 0.04485035f, 0.08198500f, 0.18406564f, -0.05207568f, 0.05188179f, -0.02599362f, 0.22105777f, 
    0.07662900f, -0.02702897f, -0.00929734f, 0.00735007f, -0.12949806f, -0.05103268f, 0.01811257f, 0.06409895f, 
    -0.04547828f, 0.00050255f, -0.00637935f, -0.04806734f, -0.17832859f, 0.01287064f, -0.09365434f, 0.00375980f, 
    -0.00633706f, -0.05083450f, -0.18318997f, 0.19246309f, -0.23578139f, -0.01539102f, -0.07627441f, 0.01373274f, 
    -0.00941348f, 0.00139130f, -0.01374289f, -0.04525167f, 0.00996910f, -0.04233674f, -0.07471636f, -0.00708214f, 
    -0.02289184f, 0.13094294f, 0.08673824f, -0.02930383f, 0.05054935f, -0.08538868f, 0.18619406f, -0.00705164f, 
    -0.11731441f, -0.01089697f, 0.07945028f, 0.00584158f, -0.00699489f, -0.09555200f, 0.02799871f, 0.04358065f, 
    -0.02617109f, 0.08679595f, -0.03609830f, 0.05334517f, -0.02582188f, 0.05895567f, -0.09582088f, -0.15476531f, 
    0.41727200f, -0.25896946f, 0.21338256f, -0.24154216f, -0.01352595f, -0.09681708f, 0.01482156f, -0.00571044f, 
    0.15392323f, -0.05678080f, 0.02234487f, 0.01125799f, -0.09681931f, -0.13265881f, -0.06631035f, -0.02637608f, 
    0.02459656f, 0.11221286f, 0.10223984f, -0.09722210f, -0.15622815f, 0.01710256f, -0.44342181f, -0.12600054f, 
    0.04831871f, 0.00915288f, -0.03229155f, 0.08575052f, 0.01728562f, -0.00820382f, -0.04191912f, 0.06816143f, 
    -0.03803463f, 0.04347594f, -0.05244171f, 0.05569482f, -0.07927311f, -0.13683802f, -0.09764879f, -0.16048740f, 
    -0.06782812f, 0.03733279f, -0.12939242f, 0.21552438f, 0.10647006f, -0.04784826f, -0.11453205f, 0.15450874f, 
    0.05035822f, 0.19958724f, -0.06608876f, 0.09727258f, -0.11713811f, 0.06718640f, 0.06547869f, -0.03295096f, 
    0.00020903f, 0.01440135f, 0.02059661f, 0.19447438f, -0.13181303f, 0.03332295f, 0.13493735f, -0.01825943f, 
    0.10567028f, -0.03065966f, 0.06084720f, 0.13012238f, 0.05611390f, -0.05292784f, 0.03599358f, 0.04256268f, 
    0.09930883f, -0.01038026f, -0.02704568f, 0.05366585f, -0.02887995f, 0.00043463f, 0.03099515f, 0.00578496f, 
    0.06191277f, -0.16680832f, 0.21525888f, -0.03652817f, -0.15892081f, -0.03313445f, -0.03927333f, 0.06254371f, 
    0.06235083f, -0.01989929f, -0.00502875f, -0.02428886f, 0.08236145f, -0.00583643f, 0.04398400f, 0.00233437f, 
    0.01977964f, 0.11244354f, 0.02204163f, 0.00077004f, -0.17161736f, -0.31389987f, 0.13048752f, -0.04233862f, 
    -0.08829281f, -0.05724252f, 0.00686359f, -0.00181880f, 0.07365119f, -0.06706709f, -0.06230340f, -0.00558925f, 
    -0.02888038f, 0.01055466f, 0.04469971f, -0.02948637f, 0.10440882f, 0.08850770f, 0.12396085f, 0.03042502f, 
    -0.09718944f, -0.05496057f, 0.12408090f, 0.03676202f, 0.06521556f, 0.06007754f, -0.00237474f, 0.03177812f, 
    0.01672514f, 0.05234118f, -0.13617843f, -0.02433880f, 0.15307082f, -0.04656671f, 0.08662903f, -0.03658212f, 
    -0.00402418f, 0.04011533f, 0.06675240f, 0.18426184f, -0.39646327f, -0.01062063f, 0.05239461f, -0.00325292f, 
    0.11236247f, 0.01695292f, -0.00642128f, -0.13578449f, 0.20476638f, 0.02219008f, -0.08603979f, -0.01932044f, 
    -0.05917729f, -0.05388368f, 0.10986069f, 0.18627514f, -0.10540832f, -0.06359405f, -0.02730846f, 0.01008795f, 
    -0.21456073f, -0.35039634f, 0.06682517f, 0.21238841f, -0.04861259f, 0.08454080f, -0.05798807f, 0.18016997f, 
    -0.06709351f, -0.17214759f, 0.01128138f, 0.00370664f, -0.00790127f, 0.05017805f, 0.02313450f, 0.09467641f, 
    -0.07571416f, 0.13900015f, -0.01105265f, 0.01015494f, 0.03569492f, -0.07275921f, -0.02001367f, -0.15736444f, 
    0.16034673f, 0.02434326f, 0.11448416f, 0.02317082f, 0.03773756f, 0.01264521f, -0.00347987f, 0.04880111f, 
    0.02498959f, 0.07142972f, -0.00002980f, -0.02745039f, 0.05172173f, 0.01029583f, -0.04337541f, -0.00836723f, 
    0.34372807f, 0.22220445f, 0.34230399f, -0.10742530f, -0.04214170f, 0.08793377f, -0.01272776f, 0.00065459f, 
    -0.01433389f, -0.10199670f, -0.10842750f, 0.00408373f, 0.03139591f, 0.00398753f, -0.01944103f, 0.01023470f, 
    -0.12732725f, -0.15275274f, -0.08474838f, 0.14671242f, -0.33433834f, -0.14843817f, -0.35152531f, 0.24775745f, 
    -0.07987396f, -0.04914881f, -0.02424887f, -0.05971808f, 0.12272862f, -0.00928708f, -0.05133834f, -0.07872536f, 
    -0.00675146f, -0.14348994f, -0.05617338f, -0.01689425f, -0.03280440f, -0.00245834f, -0.01260223f, 0.05095247f, 
    -0.18733837f, -0.12126378f, -0.20829143f, 0.17489141f, -0.30748382f, 0.07621913f, -0.05373050f, -0.07727391f, 
    -0.13800564f, 0.03810604f, -0.07470081f, -0.05233343f, 0.11195920f, 0.00341049f, -0.09235196f, 0.01288119f, 
    -0.03832437f, 0.09933893f, 0.04576598f, 0.00105194f, -0.25211596f, 0.01363672f, -0.13233568f, 0.02397813f, 
    -0.12457304f, -0.01315377f, 0.10184302f, -0.00062251f, 0.04831822f, 0.01067249f, -0.24042387f, -0.01826374f, 
    0.12181581f, 0.08496594f, 0.05303203f, 0.05447476f, -0.02151262f, 0.00647452f, -0.05733976f, 0.03559649f, 
    0.27334720f, 0.03853418f, 0.18852010f, -0.00927068f, -0.28081712f, -0.05142628f, 0.00506581f, -0.09282738f, 
    0.04936449f, 0.01706172f, -0.09375475f, -0.03527077f, 0.06182033f, -0.01168885f, -0.03444353f, -0.01772011f, 
    0.09919539f, 0.05163961f, 0.04956768f, -0.06424364f, -0.17443356f, -0.28052151f, 0.16986454f, -0.21031952f, 
    0.27552837f, 0.01791135f, 0.03539391f, 0.15381607f, 0.04517766f, 0.06333546f, 0.02690168f, 0.06673637f, 
    0.04182168f, -0.00741968f, 0.03096274f, -0.00188292f, 0.06855724f, 0.00305831f, -0.08239641f, 0.06002203f, 
    0.36808929f, 0.03949269f, 0.17803343f, 0.04246174f, -0.00187114f, 0.00086346f, -0.01626871f, -0.10108717f, 
    0.13405040f, -0.12390469f, -0.09833767f, -0.02637670f, -0.05527380f, -0.08908928f, -0.07228491f, 0.14263962f, 
    -0.01415922f, 0.00339432f, 0.03502617f, -0.04355285f, 0.14569299f, 0.14230144f, -0.09872091f, 0.10538506f, 
    0.09420783f, 0.03318106f, -0.08077775f, 0.01854019f, 0.01706394f, -0.09285840f, -0.03204629f, 0.04309568f, 
    -0.00698984f, -0.04003694f, -0.08639030f, 0.09627684f, -0.00060779f, 0.04257192f, 0.09907514f, 0.03306469f, 
    -0.04588620f, -0.26976588f, -0.21623231f, -0.25213316f, -0.10328029f, -0.06137835f, -0.01114842f, 0.05074652f, 
    -0.03828876f, -0.02985274f, -0.02388084f, 0.04342535f, 0.06684366f, -0.03162077f, -0.02687647f, 0.09204634f, 
    -0.00935927f, 0.07613876f, 0.04270630f, 0.05253007f, 0.03145872f, -0.11321464f, 0.13957568f, -0.18849440f, 
    0.11317085f, 0.11973039f, 0.18564396f, -0.08924795f, 0.11680882f, 0.01339050f, -0.06038333f, 0.06309669f, 
    0.06986404f, 0.11753236f, 0.14122045f, -0.01353919f, -0.00235370f, -0.02015695f, -0.16870104f, 0.04944619f, 
    -0.43800989f, -0.03658809f, -0.40085781f, 0.33232507f, -0.18369550f, 0.05643551f, 0.08896223f, -0.03061980f, 
    -0.01553285f, -0.02111606f, -0.08414393f, 0.08859657f, 0.07008167f, 0.09568041f, -0.03680146f, 0.05535642f, 
    -0.02357427f, 0.10187603f, 0.03581388f, 0.24039394f, 0.14831029f, -0.13425426f, 0.10883423f, -0.03774579f, 
    -0.06263915f, -0.01350242f, 0.02428759f, -0.02829556f, 0.13208123f, -0.05649655f, -0.00318063f, -0.02723292f, 
    -0.06479377f, -0.00501230f, 0.03088515f, -0.00369934f, 0.03284653f, 0.05428699f, -0.02157690f, -0.09889935f, 
    0.14573605f, -0.06539778f, 0.09521808f, -0.02346566f, 0.06448756f, 0.00998313f, 0.04467616f, 0.01056448f, 
    0.05137236f, -0.12704971f, -0.01733224f, -0.03465369f, 0.00808027f, 0.06200983f, 0.09854356f, -0.05187190f, 
    -0.04266126f, -0.00140070f, -0.07095071f, -0.04250591f, 0.16512927f, -0.03762406f, 0.17771862f, -0.15904990f, 
    0.15119514f, 0.11861327f, 0.13049167f, 0.03838907f, 0.03102658f, -0.01764479f, -0.01120753f, 0.07482486f, 
    0.05122536f, 0.07097000f, 0.01660841f, -0.08434897f, 0.03008945f, -0.11348199f, 0.00847296f, -0.07953455f, 
    -0.33319217f, 0.05577254f, -0.33561513f, 0.30962405f, -0.00475142f, -0.02226935f, 0.05807136f, 0.03849950f, 
    0.16646059f, 0.12709144f, -0.02835702f, -0.06745233f, -0.05606119f, 0.04130650f, 0.02772310f, 0.01660964f, 
    0.00392106f, -0.00336056f, -0.06519232f, 0.02995702f, -0.02400491f, -0.07049596f, -0.02948566f, 0.06805319f, 
    0.00360575f, -0.11426582f, 0.07790618f, -0.06815075f, 0.08134671f, -0.10593528f, -0.17707428f, -0.00957953f, 
    0.08010878f, 0.04017990f, 0.06008188f, 0.03690673f, -0.06007104f, 0.08709035f, -0.04579056f, 0.03885642f, 
    -0.10251841f, -0.36719146f, -0.13549507f, -0.09009179f, 0.12053515f, -0.03683832f, -0.30448401f, -0.15170932f, 
    0.00101429f, -0.06106145f, 0.06248820f, 0.04008055f, -0.03536772f, -0.06775906f, -0.07695273f, 0.02448462f, 
    0.01512694f, -0.08682824f, 0.09348895f, 0.01323114f, -0.02020108f, 0.03647590f, 0.06719965f, -0.08435904f, 
    0.01377146f, 0.00131244f, 0.01517341f, -0.09218352f, 0.09524709f, 0.05071645f, -0.02768967f, -0.01515100f, 
    -0.05662381f, -0.03425605f, 0.02138238f, -0.00534677f, -0.03588514f, -0.06213635f, 0.04612204f, -0.12524503f, 
    -0.06766546f, -0.03697088f, -0.07953185f, 0.10209528f, -0.01920686f, -0.02139987f, 0.11004579f, 0.03062172f, 
    0.08831638f, 0.03968336f, -0.13241668f, 0.05113458f, 0.03444505f, 0.01825513f, 0.00003386f, -0.07098550f, 
    -0.05402010f, 0.03285972f, -0.15199366f, -0.07368166f, 0.25422060f, 0.04705719f, 0.23153688f, 0.24123639f, 
    -0.08413780f, -0.09155499f, -0.16708519f, -0.00633716f, 0.11927752f, -0.14302048f, -0.08349694f, 0.04623244f, 
    0.05216643f, 0.06219211f, 0.08775455f, -0.03716040f, -0.08363517f, 0.10536081f, 0.20644107f, -0.04318410f, 
    -0.20917231f, 0.18825722f, -0.11832161f, 0.19163145f, -0.14849050f, 0.00087604f, -0.08189487f, 0.18292187f, 
    0.01656192f, -0.06751122f, -0.09795960f, 0.00442846f, -0.09852184f, -0.04838410f, -0.00710319f, 0.12621053f, 
    -0.19288869f, -0.10276361f, -0.10852885f, -0.15944275f, -0.03088412f, -0.17757168f, -0.08800534f, 0.17160985f, 
    0.02811832f, -0.08742260f, -0.06116343f, 0.08696611f, 0.12378014f, -0.14900744f, 0.01960552f, -0.04678599f, 
    0.03371033f, -0.06267153f, 0.09281440f, -0.08705828f, -0.10551576f, -0.02935627f, -0.01810742f, -0.09811743f, 
    -0.10072327f, -0.26804319f, 0.09325376f, -0.05185413f, -0.12247654f, 0.06541914f, -0.02626905f, -0.07107946f, 
    -0.03033187f, 0.00211391f, -0.02830453f, -0.04212468f, 0.01471874f, -0.11497009f, -0.03300110f, -0.04561789f, 
    -0.03525326f, 0.00679790f, -0.01542753f, -0.06202780f, -0.26512071f, 0.09843866f, -0.14332661f, 0.19089913f, 
    0.03765396f, -0.02298340f, 0.04711196f, 0.08729332f, 0.08945792f, -0.02396001f, -0.04442013f, -0.05972625f, 
    -0.07323771f, -0.01916697f, -0.01507362f, 0.07792452f, -0.01523486f, 0.01263308f, 0.05593187f, 0.07388866f, 
    0.16332138f, 0.04169431f, 0.05363432f, -0.00095358f, 0.02275753f, -0.02066748f, 0.09218141f, -0.03567173f, 
    0.06553016f, 0.00937062f, -0.02394673f, 0.05238631f, 0.01413570f, 0.00711401f, -0.00358763f, -0.02457475f, 
    0.03017855f, -0.01828876f, -0.05182543f, -0.05082961f, 0.18812439f, -0.34034920f, -0.09028938f, -0.22576042f, 
    0.07782602f, -0.06581534f, -0.27739149f, -0.03651941f, -0.01874025f, -0.19491810f, -0.02939336f, -0.00234249f, 
    0.05624358f, -0.02810386f, -0.04010990f, 0.00411174f, 0.03624588f, -0.01418287f, 0.08146600f, -0.08436484f, 
    -0.10085487f, -0.03163620f, 0.12947178f, 0.22812691f, -0.19715515f, -0.16375621f, -0.28950211f, 0.18107322f, 
    -0.05714473f, -0.07906386f, -0.04945382f, 0.09065802f, 0.00375101f, 0.09758113f, 0.03201311f, 0.06849129f, 
    -0.16724962f, -0.02612695f, 0.10517305f, -0.16524425f, 0.45501238f, 0.17552930f, 0.43408668f, -0.04550064f, 
    -0.09457213f, 0.06033469f, -0.02546814f, -0.17825659f, 0.02613654f, -0.12586300f, -0.06360891f, 0.04108714f, 
    0.04899618f, 0.02287388f, -0.00811638f, -0.09387881f, -0.02307744f, -0.02724515f, 0.00259255f, 0.12534550f, 
    0.31358951f, -0.26080909f, 0.14178108f, -0.03616969f, -0.07794164f, -0.01452340f, -0.15757963f, -0.01578111f, 
    0.01535219f, -0.07975738f, -0.02426071f, 0.02830724f, 0.01069244f, -0.03298205f, -0.06888243f, 0.04338823f, 
    0.01876855f, 0.01828344f, 0.07251002f, -0.04182627f, -0.14219759f, -0.12855260f, -0.13460080f, -0.05311651f, 
    0.13021815f, 0.00941184f, 0.07041828f, -0.01690074f, -0.00360162f, 0.02241927f, -0.02492537f, 0.05777806f, 
    0.07789885f, 0.05770067f, 0.05439578f, -0.04135337f, 0.03023314f, -0.01865268f, 0.09351572f, -0.04183571f, 
    -0.11942302f, -0.12097639f, -0.21531720f, 0.10020410f, -0.02457288f, -0.01671176f, -0.06330159f, -0.02019305f, 
    -0.03835644f, -0.03525405f, -0.01327061f, 0.05792935f, -0.02733998f, -0.14042269f, -0.05447730f, 0.03430320f, 
    -0.06162653f, -0.01400788f, -0.07163867f, -0.09504835f, 0.04897736f, -0.24491614f, -0.04456686f, -0.16445257f, 
    -0.12720825f, -0.11980362f, -0.18605535f, -0.02168682f, -0.08863850f, -0.03535682f, -0.00497853f, 0.02045063f, 
    0.11595127f, -0.03710106f, -0.07228146f, 0.03463220f, 0.03514797f, 0.00937222f, 0.10454319f, 0.01266310f, 
    -0.51891375f, 0.09735557f, -0.06817185f, 0.27938747f, -0.12762642f, 0.10114621f, -0.00125634f, 0.14627734f, 
    -0.02226224f, 0.00980322f, -0.11768545f, -0.11370189f, -0.12517117f, -0.04905808f, 0.02910892f, 0.09907228f, 
    -0.05361735f, 0.19665073f, 0.13015862f, -0.11038535f, 0.25702494f, -0.03533523f, 0.12596391f, 0.20865968f, 
    -0.12587917f, -0.01985428f, 0.00378822f, -0.04169964f, 0.03536286f, 0.00266847f, -0.12686272f, -0.01255775f, 
    0.00112928f, -0.03109260f, -0.05631055f, 0.01356127f, 0.08630231f, 0.13427143f, 0.06130329f, -0.04266872f, 
    -0.19401260f, -0.09530435f, -0.20947079f, 0.14604433f, 0.07821798f, -0.05083015f, -0.05063112f, -0.09489344f, 
    -0.07228778f, 0.05270803f, -0.01354549f, 0.01396518f, -0.09426468f, -0.11764090f, -0.04028392f, 0.03437639f, 
    -0.08744428f, -0.09443815f, -0.07047137f, -0.08662441f, 0.43188620f, -0.01211159f, 0.28600514f, -0.11727504f, 
    -0.10218146f, -0.03851376f, -0.07848001f, -0.14916874f, -0.00692507f, -0.05150345f, -0.05610006f, -0.00098600f, 
    0.03440213f, -0.03740683f, -0.06828055f, -0.02921904f, 0.07754235f, -0.07338812f, 0.07176550f, 0.04265430f, 
    -0.50346589f, 0.09017725f, -0.39430761f, 0.03062027f, -0.39875868f, 0.11555465f, 0.09059910f, 0.06237091f, 
    -0.03754940f, 0.12684812f, -0.10014522f, -0.02516771f, 0.03397724f, 0.17337979f, -0.05274864f, -0.02035439f, 
    -0.05086543f, 0.07665157f, -0.06261083f, 0.04456286f, -0.10764200f, -0.08026984f, -0.13063648f, 0.26254588f, 
    0.04800059f, -0.03020868f, 0.10048923f, 0.09741444f, 0.15163639f, 0.06369467f, -0.09979724f, 0.02788048f, 
    -0.03492234f, 0.01325494f, 0.05399852f, -0.07584068f, -0.01039448f, 0.04778827f, -0.05717982f, -0.03003384f, 
    -0.61488920f, 0.21135630f, -0.25027743f, 0.26050067f, 0.01512655f, -0.02476674f, -0.01551389f, 0.11418167f, 
    0.03110790f, -0.03025280f, -0.08231561f, -0.12854239f, -0.11761320f, 0.08200861f, -0.07522155f, 0.15551113f, 
    0.01713612f, 0.10550392f, 0.01945578f, -0.07127178f, 0.26302025f, -0.22967352f, 0.10957776f, -0.06820671f, 
    -0.11592589f, -0.02971466f, -0.02225597f, -0.07167167f, 0.03941431f, -0.01646492f, -0.10183637f, 0.00509301f, 
    -0.04591785f, -0.11366672f, -0.07839351f, -0.00352273f, 0.04774924f, 0.04236275f, -0.12723272f, 0.01441647f, 
    -0.26534289f, -0.15621558f, -0.03229172f, 0.20246254f, -0.13870704f, 0.16565678f, 0.00193097f, 0.18285967f, 
    -0.21495657f, 0.11560444f, 0.05752440f, -0.02693838f, 0.14272214f, 0.20684488f, 0.04621631f, 0.03643074f, 
    0.01387607f, 0.13594176f, 0.10945735f, 0.01969757f, 0.13025710f, -0.00387373f, 0.01800450f, 0.02446557f, 
    0.07624596f, -0.01510798f, 0.11874436f, -0.11076547f, 0.11727194f, 0.03556551f, -0.04682795f, 0.00653979f, 
    -0.05313888f, 0.06713082f, 0.00488803f, 0.02115574f, -0.03824329f, -0.03522855f, -0.08538994f, 0.02337486f, 
    0.29015633f, -0.15226893f, 0.15731041f, -0.02861145f, -0.03108239f, -0.07863186f, -0.19414440f, -0.06291994f, 
    -0.01695659f, -0.11799526f, -0.04591628f, 0.06065545f, 0.04187537f, -0.06009880f, -0.01974980f, 0.00325140f, 
    0.01575163f, 0.02287309f, 0.05457624f, 0.04294214f, -0.24632183f, 0.02185795f, -0.07021566f, 0.11177161f, 
    -0.06725278f, 0.04738409f, 0.01716228f, -0.03969760f, -0.00086462f, 0.12909873f, -0.12166206f, 0.01128546f, 
    0.02873919f, -0.04005130f, -0.07526405f, -0.01465310f, -0.02889551f, -0.00347419f, -0.00586629f, -0.01594868f, 
    0.20798263f, -0.26453415f, 0.30021226f, -0.22131127f, 0.07685748f, 0.02923366f, 0.06744958f, -0.20309560f, 
    0.06965358f, -0.02449704f, -0.00468111f, 0.04574463f, 0.06347409f, -0.00984748f, 0.02523875f, 0.01453721f, 
    0.08653173f, -0.03463959f, -0.01236466f, -0.04830970f, -0.30841261f, -0.09651176f, -0.50235790f, 0.45304257f, 
    0.18751441f, -0.03466014f, 0.11894371f, -0.06769856f, 0.12054609f, 0.09848908f, -0.18220019f, -0.09473082f, 
    -0.05296423f, 0.21668433f, 0.04284841f, -0.00533946f, -0.00295575f, 0.17559066f, -0.01038709f, -0.03059587f, 
    -0.19685744f, -0.03937025f, -0.14310341f, -0.00793093f, 0.00924173f, 0.14080739f, 0.09010125f, 0.06957403f, 
    -0.07164240f, 0.01727050f, -0.02565398f, -0.08054148f, 0.01159431f, 0.03358050f, 0.13462877f, -0.00843361f, 
    -0.06424903f, -0.04523323f, 0.03025545f, -0.00200348f, -0.74508083f, 0.09104028f, -0.12837887f, 0.27407202f, 
    0.26258385f, 0.09989483f, 0.11803696f, -0.03636254f, -0.03792509f, 0.26740977f, -0.10978895f, 0.11620430f, 
    -0.08564254f, -0.00559577f, -0.00606056f, 0.04948228f, 0.02576588f, 0.03961100f, 0.09782479f, 0.04881699f, 
    -0.14454237f, -0.19095856f, -0.02833333f, -0.22146016f, -0.53326952f, -0.03845261f, -0.06438798f, -0.08375452f, 
    -0.08278870f, 0.03041258f, -0.01968894f, -0.02762275f, 0.02466602f, 0.02307289f, 0.02039246f, 0.01945023f, 
    0.02300948f, 0.02781346f, 0.01073967f, 0.03630856f, -0.28822455f, -0.06341453f, -0.05875659f, 0.17123383f, 
    -0.00011815f, 0.10013972f, -0.06714578f, 0.16481423f, -0.10223956f, 0.06582461f, -0.11711188f, -0.00463467f, 
    -0.02911964f, 0.03346176f, -0.07410928f, 0.04117323f, -0.06222529f, -0.12920941f, 0.02904765f, -0.14320303f, 
    -0.05725894f, -0.23636308f, -0.02802783f, -0.02259462f, 0.13857388f, 0.05228477f, -0.07394184f, -0.03252049f, 
    -0.00199478f, -0.14852157f, 0.01540310f, -0.00185282f, -0.07814458f, -0.04956478f, -0.02625893f, 0.01463923f, 
    -0.05553980f, -0.02204897f, -0.10804357f, -0.18098512f, 0.25188535f, -0.22644356f, 0.06012160f, 0.05038163f, 
    -0.06681743f, -0.01625307f, 0.00996967f, -0.06776738f, 0.07955375f, -0.04010464f, -0.02390815f, 0.00580775f, 
    -0.08749307f, -0.01013491f, -0.03009542f, 0.06776982f, -0.01193817f, 0.08778273f, 0.11353792f, -0.04997998f, 
    0.32215199f, -0.08305748f, 0.33950898f, -0.05095367f, -0.14826794f, 0.00854580f, 0.08247948f, -0.12450103f, 
    0.10328411f, 0.05295982f, -0.01846403f, 0.00887998f, -0.05242357f, -0.00763581f, -0.01988289f, -0.02998893f, 
    0.17725691f, 0.11166234f, 0.05975787f, -0.10034035f, 0.14477219f, -0.05953439f, -0.19736637f, 0.06154365f, 
    0.12404229f, -0.03689164f, 0.11685443f, -0.11060420f, -0.00379983f, -0.09514731f, -0.08055177f, 0.03152996f, 
    0.08615547f, 0.05611005f, 0.02188436f, -0.01942406f, -0.00220286f, 0.03365636f, -0.08189625f, 0.02463801f, 
    -0.00804525f, -0.05017804f, -0.01527252f, -0.16617300f, 0.07529579f, 0.05417401f, 0.10422493f, -0.10039217f, 
    0.03894962f, 0.01645104f, -0.04985366f, 0.02393354f, 0.03473667f, 0.00858704f, -0.04721484f, -0.01935020f, 
    0.01716146f, 0.06786589f, -0.00144482f, 0.03937449f, 0.11478910f, -0.34765983f, -0.22228689f, -0.18354532f, 
    0.08183377f, -0.09458176f, -0.13097902f, 0.06035310f, -0.06362721f, -0.08149416f, -0.00354738f, -0.02037629f, 
    0.07493276f, -0.04299602f, -0.03961249f, 0.05865146f, -0.02874815f, -0.05535727f, 0.09803322f, 0.00187715f, 
    -0.15482801f, 0.14155404f, 0.15176074f, 0.28058043f, -0.18868993f, -0.04619963f, -0.12764244f, 0.14147556f, 
    -0.21354643f, 0.03861803f, 0.01519185f, -0.05170341f, 0.02902308f, -0.00978210f, 0.01492724f, -0.02144037f, 
    -0.06144785f, 0.09039140f, 0.08634913f, -0.07549302f, -0.06611757f, -0.11471820f, -0.08949635f, 0.06216384f, 
    0.07906988f, -0.08155620f, -0.13202763f, -0.06018332f, -0.18506739f, -0.03430581f, 0.06614307f, 0.01582084f, 
    -0.06212234f, 0.01182168f, 0.03131595f, 0.06457814f, -0.08648784f, -0.01205426f, 0.01550955f, 0.03355647f, 
    -0.06403821f, 0.07587642f, -0.11083850f, 0.11393291f, 0.07964449f, -0.07057013f, 0.05851920f, -0.00190631f, 
    0.01862603f, 0.06683192f, -0.07169530f, -0.00036743f, 0.05117969f, 0.11584724f, 0.02178296f, 0.00405090f, 
    -0.05527914f, -0.03581916f, -0.10227510f, -0.05478895f, 0.15219750f, 0.08805963f, 0.11452723f, -0.01121155f, 
    0.03659331f, 0.03424991f, 0.14811794f, -0.03034264f, 0.03031364f, -0.02060410f, -0.10117283f, 0.03090909f, 
    0.02210444f, 0.01249404f, -0.00550632f, 0.06542663f, -0.00010345f, -0.01847165f, -0.05877775f, 0.00093501f, 
    0.07375966f, 0.03150733f, 0.05354162f, 0.17808509f, -0.04002909f, 0.00932194f, 0.01828591f, -0.02770772f, 
    0.02657332f, -0.08570392f, -0.08074921f, -0.06938183f, -0.06769049f, 0.06309880f, 0.00566847f, -0.01103309f, 
    0.00626660f, 0.13296565f, -0.11726174f, -0.01692755f, 0.12901112f, -0.39128000f, 0.21950524f, 0.17412940f, 
    -0.05338132f, 0.01583441f, 0.10068340f, 0.00482116f, 0.15524921f, -0.25758344f, -0.06244775f, -0.09361932f, 
    -0.01395533f, 0.02090500f, 0.03151783f, 0.05098896f, -0.01329280f, 0.05999980f, 0.08353307f, -0.02945057f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14276031f, 0.05972633f, 0.05357670f, -0.06521071f, -0.05861965f, 0.04579785f, -0.00721898f, -0.06815581f, 
    0.03208302f, 0.01403220f, 0.00632605f, 0.02238319f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
