#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.92675382f, 0.60735422f, 0.32312712f, 0.05759569f, -0.05215669f, 0.18568146f, 0.62506366f, -0.52100712f, 
    -0.17410533f, -0.01909510f, 0.19349545f, 0.31153163f, -0.23443009f, 0.03963486f, -0.12494982f, 0.20484242f, 
    0.00592779f, 0.07866398f, 0.20698200f, -0.08756919f, -0.04046058f, 0.39712101f, 0.18500945f, 0.16440788f, 
    0.27430585f, 0.27685544f, 0.96551186f, 0.57812214f, 0.21902664f, 0.36789840f, -0.72292167f, -0.43630829f, 
    -0.46332717f, -0.76722741f, -0.01644727f, 0.35877764f, 0.17547825f, -0.25893590f, 0.04093499f, -0.12761877f, 
    -0.14683472f, -0.19927154f, -0.12619467f, -0.16666201f, -0.04283480f, 0.01409210f, -0.04623761f, -0.02157637f, 
    -0.09834636f, -0.05487606f, 0.51549965f, 0.43413058f, 0.58021647f, 0.01656883f, 0.27709436f, 0.66641313f, 
    -0.27246207f, 0.30846724f, 0.26142195f, 0.43920511f, 0.36546811f, 0.25760877f, 0.27940667f, 0.13892566f, 
    -0.29746482f, -0.03103705f, -0.19118898f, 0.08975369f, -0.15099570f, -0.15097260f, 0.14088361f, 0.12821232f, 
    0.22784777f, 0.03265418f, 0.28550953f, 0.50957572f, 0.58320677f, -0.44782862f, 0.68313748f, 0.86869144f, 
    0.37666410f, 0.14505008f, 0.33226964f, 0.59790838f, 0.38162422f, 0.09244796f, 0.11640198f, -0.20505428f, 
    -0.24700838f, 0.20860922f, 0.28832957f, -0.20940495f, 0.10834236f, -0.06930662f, 0.16820362f, -0.09617738f, 
    -0.16445304f, 0.05266739f, -0.05928545f, -0.05116023f, -0.40395850f, 0.27263695f, 0.56040436f, 0.44040382f, 
    0.36220172f, -0.86654222f, 0.55642140f, -0.47939855f, 0.28144702f, 0.33845404f, -0.54434788f, -0.48637214f, 
    0.00404838f, -0.03529537f, 0.06977557f, 0.22664197f, 0.21310484f, -0.07850636f, 0.08671578f, 0.13158359f, 
    -0.06413990f, -0.03404784f, -0.01770171f, 0.02153803f, -0.12959534f, 0.88608038f, 0.00524727f, 0.51493096f, 
    0.31574315f, -0.44737613f, -0.12040291f, -0.67970181f, -0.24326125f, 0.07258814f, -0.27634037f, -0.07446036f, 
    -0.03386387f, 0.11482506f, 0.30562586f, 0.15323646f, -0.17664525f, -0.12962033f, -0.02864821f, 0.19239053f, 
    0.22052355f, -0.34136474f, 0.39755431f, 0.42160800f, 0.12198438f, 0.10898660f, 0.35253647f, -0.52486479f, 
    -0.75878477f, -0.93545729f, -0.42942449f, 0.33034095f, -0.26420784f, 0.18079591f, 0.46672246f, 0.18957770f, 
    -0.43696937f, -0.19994085f, -0.06486104f, -0.30170786f, -0.43238398f, -0.07556742f, 0.05523207f, 0.04516178f, 
    0.06522386f, 0.10658715f, 0.22637099f, 0.11085203f, -0.24092065f, -0.02919110f, 0.03791719f, 0.62231123f, 
    0.65700155f, 0.69473517f, -0.00945791f, 0.06580432f, 0.25436789f, -0.39865461f, 0.02514624f, 0.35125047f, 
    0.14440927f, -0.62793499f, -0.24309537f, 0.02346438f, -0.05780754f, -0.00928140f, 0.02682721f, 0.53113818f, 
    -0.06825434f, -0.30015421f, -0.25340933f, 0.01212649f, 0.00688597f, -0.08354548f, -0.30022857f, -0.11819449f, 
    -0.29487866f, -0.69749296f, -0.47808617f, 0.34477836f, -0.20279193f, 0.01545815f, 0.18058881f, -0.20720740f, 
    0.66005820f, -0.31906989f, 0.00413158f, 0.06956560f, -0.19491212f, 0.24910532f, -0.12109428f, 0.11385011f, 
    0.18150550f, -0.07067678f, 0.06513920f, 0.41029114f, 0.18936142f, 0.23448449f, 0.54284632f, 0.27368236f, 
    0.31235951f, 0.62759084f, 0.76240695f, -0.65237427f, -0.70638621f, -0.81116939f, 0.17691152f, -0.29087701f, 
    -0.24121539f, -0.24076930f, 0.07161368f, 0.30885452f, 0.00887982f, 0.25206506f, 0.06871048f, -0.10888974f, 
    0.23379548f, -0.07106515f, 0.04516920f, 0.08375864f, 0.17599927f, -0.00499015f, -0.02350824f, -0.10871048f, 
    -0.07857873f, 0.07312120f, 0.85673058f, -0.01968318f, -0.38589737f, 1.05406976f, 0.16784695f, 0.37592766f, 
    0.34150094f, 0.00065584f, 0.33478805f, -0.16158345f, -0.27980599f, -0.07877450f, 0.26516950f, -0.36187050f, 
    -0.23185316f, -0.03217832f, -0.00725290f, 0.03627504f, -0.20906737f, -0.12344757f, 0.04877919f, 0.21903299f, 
    0.17752959f, 0.09768615f, 0.39255041f, -0.08164113f, -1.06086600f, -0.46756718f, 0.41382852f, -0.07059147f, 
    -0.37859961f, 0.86883229f, 0.29457521f, -0.55790579f, 0.36101392f, 0.22178899f, 0.12931050f, 0.01094403f, 
    -0.04658023f, -0.03893681f, -0.33724377f, 0.05117388f, 0.06688736f, -0.01878135f, -0.29870749f, 0.16915172f, 
    -0.15914489f, 0.00552995f, -0.16663378f, 0.04676022f, -0.65734333f, -0.78417492f, -0.24590588f, -0.54891384f, 
    -0.61232245f, 0.47511929f, 0.09795128f, 0.10952391f, 0.07818532f, 0.31804457f, 0.18788832f, 0.02479130f, 
    0.37944838f, 0.52908760f, -0.12900354f, 0.11324149f, 0.14340371f, 0.08088704f, -0.30079103f, 0.09390061f, 
    -0.07276080f, -0.23472947f, -0.05196924f, -0.33383980f, 0.19474953f, -0.45457685f, -0.36932915f, 0.55655241f, 
    0.48181880f, 0.40155026f, -0.92215955f, -0.09534302f, -0.33248654f, -0.35237372f, -0.04073916f, 0.34977138f, 
    0.42355540f, -0.15655087f, -0.09018447f, 0.04406094f, -0.06670491f, 0.03638102f, 0.40069419f, -0.09178902f, 
    0.16757093f, 0.12967101f, -0.05274941f, 0.24956059f, 0.26938161f, -0.11209409f, -0.25626725f, -0.21614662f, 
    0.32257184f, -0.51668423f, -0.65136278f, -0.28143853f, -0.08009349f, -0.58748245f, -0.62053555f, -0.49607122f, 
    -0.17941789f, 0.32116210f, -0.35691604f, 0.32438377f, -0.01139180f, 0.17226914f, 0.08618405f, -0.02569899f, 
    0.08192109f, -0.24492514f, -0.11579712f, 0.06148217f, 0.02229458f, 0.06365857f, -0.01957752f, 0.54838574f, 
    -0.44943663f, -0.55091208f, -0.33436128f, 0.45651087f, 0.68159598f, 0.53495866f, 0.20897993f, 0.44834316f, 
    0.34271497f, -0.53549248f, 0.15212689f, -0.49383712f, 0.11949414f, 0.06399588f, -0.01856340f, -0.10425040f, 
    -0.26647317f, -0.09060071f, -0.05253950f, -0.17707460f, 0.00968105f, -0.12838070f, 0.02962864f, -0.07550821f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25027612f, 0.27395085f, 0.13052486f, -0.04063758f, -0.12439993f, 0.28602755f, -0.04594408f, 0.23767829f, 
    0.07914376f, -0.04287942f, 0.21452335f, 0.03667212f, 0.15699218f, 0.22054526f, 0.36952266f, 0.16821843f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.26929918f, -0.09673272f, -0.04899602f, -0.12662393f, 0.15856910f, -0.06527833f, 0.04678775f, 0.02251982f, 
    -0.07119665f, 0.04297736f, 0.00880520f, 0.08929230f, 0.04559464f, 0.08266756f, 0.01500371f, -0.11882129f, 
    0.09832697f, 0.08528683f, -0.07264701f, -0.04875962f, -0.04231725f, -0.08543785f, 0.03624957f, -0.10910632f, 
    -0.17867830f, -0.01096532f, 0.00304782f, -0.01246700f, 0.01767397f, 0.00879544f, -0.07239407f, -0.19428906f, 
    0.06381759f, 0.12618832f, 0.05365536f, -0.04670901f, -0.14283323f, 0.13056675f, -0.00406088f, -0.23750785f, 
    0.02418113f, -0.02150227f, -0.10602134f, -0.06693952f, 0.13918626f, 0.00033247f, 0.13417126f, -0.07212275f, 
    0.03963315f, -0.18546008f, 0.13124919f, 0.05762021f, 0.08366939f, -0.00530569f, -0.08580914f, -0.00537511f, 
    -0.02022739f, 0.10454298f, 0.13782595f, 0.02579766f, -0.04565678f, -0.08297155f, -0.10350300f, 0.03279506f, 
    0.05867195f, -0.01405825f, -0.23925015f, -0.01023856f, 0.01029461f, 0.04588540f, -0.05695887f, -0.00348252f, 
    0.20464894f, 0.20475335f, -0.13738120f, -0.04056325f, -0.04964154f, 0.07873427f, 0.18847242f, -0.05041423f, 
    -0.03536352f, 0.00361371f, 0.06097703f, -0.08872292f, -0.18278176f, -0.00934064f, -0.20727037f, 0.05719094f, 
    -0.03773901f, -0.02194928f, 0.05449976f, -0.08924215f, -0.02043400f, 0.11811933f, 0.12385052f, 0.02258899f, 
    0.11384539f, 0.04628110f, 0.13198872f, -0.02450159f, -0.13785161f, 0.01090617f, -0.15885702f, -0.20863552f, 
    -0.00246450f, -0.15874432f, -0.00723658f, -0.10908412f, -0.33816159f, 0.02772539f, 0.02116631f, 0.17919515f, 
    0.00125167f, 0.00664014f, -0.00118792f, 0.04129627f, 0.17270525f, 0.00760685f, -0.09982356f, -0.06270147f, 
    0.08145912f, 0.05946010f, -0.18954077f, 0.03073374f, -0.07592150f, 0.00122155f, 0.04717230f, -0.04869885f, 
    0.07311535f, 0.12401854f, 0.08815204f, -0.03576206f, 0.45519552f, -0.00822784f, 0.35777140f, -0.18638429f, 
    -0.18568559f, 0.14223698f, 0.15461920f, 0.06312723f, 0.00658251f, 0.27641150f, -0.04882282f, 0.19384538f, 
    0.27589923f, 0.19707333f, -0.03975734f, -0.03837692f, -0.04407560f, 0.11717751f, -0.08028373f, 0.07971735f, 
    0.02413146f, 0.10149787f, -0.06056945f, 0.03263855f, 0.42741716f, -0.09689828f, 0.08071411f, -0.01451525f, 
    0.05432699f, -0.01890912f, -0.15384553f, -0.01088142f, 0.00874228f, 0.20308197f, -0.02209510f, -0.03482137f, 
    0.08169698f, 0.05719693f, 0.11973355f, -0.01533362f, 0.05377887f, 0.03689070f, -0.04443646f, 0.12204827f, 
    -0.10025332f, 0.01949951f, -0.04003572f, 0.05560612f, -0.00355767f, 0.05500020f, -0.01160207f, -0.12703568f, 
    0.04386963f, 0.03081292f, 0.10812900f, -0.07514888f, 0.09737524f, -0.07290856f, 0.11714093f, 0.14317381f, 
    -0.21537854f, -0.06753913f, 0.09991537f, -0.09834047f, -0.06858516f, 0.09222595f, 0.05565232f, 0.07220505f, 
    0.02460377f, -0.02104820f, -0.05949296f, -0.05086527f, -0.17376938f, 0.09812658f, 0.09151589f, -0.00167828f, 
    0.05038756f, -0.12188037f, 0.07703663f, -0.14171335f, 0.03190801f, -0.07825842f, 0.09036111f, -0.01391695f, 
    -0.01635378f, 0.04005459f, 0.14302331f, 0.11171360f, 0.06148820f, 0.04618934f, 0.01633610f, -0.12249949f, 
    -0.00998870f, 0.00085162f, 0.06495005f, -0.07435701f, 0.40046167f, -0.04442447f, 0.06794415f, 0.31661162f, 
    -0.06385120f, 0.04158637f, 0.00937371f, -0.10710565f, 0.04793319f, 0.02388168f, 0.12444802f, -0.01572007f, 
    0.00619987f, -0.11340695f, -0.19997725f, 0.23304589f, 0.08841603f, 0.10943186f, -0.04685162f, -0.01343837f, 
    0.04247543f, 0.06749018f, -0.15264045f, -0.02188508f, -0.22062698f, -0.13317659f, -0.00405063f, 0.00587698f, 
    -0.00254733f, 0.06093094f, -0.01815794f, -0.09313961f, -0.05662832f, 0.10456052f, -0.02006172f, 0.04074872f, 
    -0.06471968f, 0.08447590f, 0.03548332f, -0.11162136f, 0.09783568f, -0.01646156f, 0.06180044f, -0.02222397f, 
    0.05534449f, -0.00688338f, -0.04209987f, 0.01815700f, -0.29690936f, -0.26992193f, -0.06332069f, 0.05365261f, 
    0.02245178f, -0.04338689f, 0.01732239f, -0.04198653f, -0.08648265f, -0.13347387f, -0.02036001f, 0.06995235f, 
    0.17183462f, -0.15610684f, -0.16742718f, -0.03694066f, 0.08303497f, -0.02594509f, -0.01532567f, 0.07715023f, 
    -0.02747854f, 0.07691596f, 0.03950947f, 0.20336634f, -0.29201430f, -0.07098737f, 0.04862304f, -0.34636870f, 
    -0.19430605f, -0.03802579f, -0.01663223f, -0.11929062f, 0.01381206f, 0.00669609f, 0.06684624f, 0.04153858f, 
    0.12304927f, 0.05620509f, 0.02833965f, 0.33540383f, 0.06062630f, -0.02218709f, 0.05498703f, 0.05765396f, 
    0.04053199f, 0.07840866f, 0.08187553f, 0.08024825f, 0.44598570f, 0.08558019f, 0.04569483f, -0.06636041f, 
    -0.16527672f, -0.14548220f, 0.03086659f, -0.01175300f, -0.01622007f, 0.08008324f, -0.09298158f, 0.09723348f, 
    0.25127032f, 0.27516893f, 0.07722792f, -0.12838314f, -0.03541344f, -0.09364500f, 0.07175475f, 0.09255867f, 
    -0.09730158f, 0.00522809f, 0.08228994f, 0.02957658f, 0.13700347f, -0.04300286f, -0.09221983f, 0.11205243f, 
    0.05828618f, 0.06926897f, 0.05390419f, 0.06032996f, -0.04304551f, -0.03563077f, 0.20665914f, -0.04242603f, 
    -0.13334903f, 0.00727143f, -0.24133085f, -0.33923644f, -0.02265532f, 0.09533998f, 0.08155357f, -0.03377474f, 
    0.05863088f, -0.05765403f, -0.00566910f, 0.03910373f, 0.33886901f, 0.13699414f, 0.14738649f, 0.11592924f, 
    -0.00600108f, -0.04883289f, 0.06445523f, 0.01078083f, -0.05336570f, -0.15043813f, 0.00407521f, -0.05910084f, 
    0.34692797f, 0.00338288f, -0.02531942f, -0.01176464f, 0.17759341f, 0.14535420f, 0.06867290f, -0.21525152f, 
    0.03382206f, -0.02549787f, 0.03618558f, 0.00464800f, 0.16289832f, -0.25545618f, -0.20962714f, -0.06259292f, 
    0.17723338f, 0.07397384f, -0.01884254f, 0.06828814f, -0.00188066f, 0.07301343f, 0.08899550f, 0.05283660f, 
    0.25522125f, 0.15544608f, 0.06598903f, -0.24076821f, 0.11807357f, 0.16438478f, 0.04644500f, -0.05905359f, 
    -0.05098826f, -0.08668084f, 0.02786782f, 0.07710854f, -0.16479784f, 0.20210050f, -0.09725954f, -0.04231633f, 
    0.25770986f, 0.00809777f, -0.08006602f, -0.01242501f, -0.00891421f, 0.18808028f, 0.00849137f, 0.12257618f, 
    0.19447474f, -0.24286790f, -0.18648835f, -0.24221462f, 0.13101470f, -0.16854598f, -0.04355710f, -0.10416730f, 
    -0.00848484f, -0.04423729f, -0.01088952f, 0.09450929f, 0.14844641f, 0.11071116f, -0.13411264f, -0.00749913f, 
    0.09849554f, -0.05907430f, 0.02332547f, -0.02419961f, -0.04568117f, 0.01170405f, 0.06369388f, 0.04923502f, 
    0.18856047f, 0.14909779f, 0.05935092f, -0.06398270f, -0.10291412f, -0.15423165f, -0.09526433f, 0.12335274f, 
    0.04535922f, -0.01017568f, -0.07605414f, -0.06388488f, 0.22393496f, 0.11588810f, -0.12314221f, -0.17206874f, 
    0.17637411f, 0.02948923f, -0.02047759f, -0.05837279f, -0.03231033f, -0.07037126f, 0.02701413f, -0.04969523f, 
    0.06019482f, -0.03754311f, 0.11665992f, 0.08978996f, -0.06423074f, -0.09435125f, 0.13420220f, -0.00750872f, 
    -0.03672277f, 0.12941968f, 0.01717258f, 0.12286799f, 0.16947606f, 0.14354073f, 0.10466483f, -0.12427311f, 
    0.12107749f, -0.06875519f, -0.12583058f, 0.01277596f, 0.10799712f, 0.07390886f, 0.08816440f, 0.03809362f, 
    -0.31835231f, 0.04162490f, 0.07962377f, -0.22890741f, 0.16444340f, 0.04562255f, 0.04788180f, -0.07687669f, 
    0.07816226f, -0.03359361f, -0.02943128f, 0.05193954f, 0.17927282f, -0.07260070f, -0.02642236f, 0.01152080f, 
    -0.01270076f, 0.00496261f, -0.11853813f, -0.06943810f, 0.00401796f, -0.07765767f, -0.01557860f, -0.12195435f, 
    -0.09098955f, 0.01592441f, 0.07434698f, 0.23019555f, -0.07111422f, 0.11773022f, 0.07418182f, -0.09940942f, 
    0.01086303f, 0.02092486f, -0.03039041f, -0.09588300f, -0.12990589f, -0.06620122f, -0.14252700f, -0.02872686f, 
    0.10645835f, 0.00166463f, 0.09123025f, -0.05114409f, 0.01964302f, 0.04238246f, 0.05083503f, 0.06295792f, 
    -0.10324278f, -0.18317649f, -0.05911357f, 0.24400419f, -0.06371380f, -0.04136275f, -0.01659631f, 0.11712194f, 
    0.01127950f, -0.06387237f, -0.02348433f, 0.01182026f, 0.08633168f, 0.02400083f, -0.06897407f, -0.04826199f, 
    -0.01803456f, -0.03846947f, -0.04070810f, 0.14605971f, 0.04067989f, 0.06679435f, 0.00775676f, 0.10367097f, 
    -0.36738968f, -0.33607432f, 0.03587976f, 0.08238084f, -0.04076491f, -0.05198888f, 0.06047308f, 0.00361448f, 
    0.06864730f, -0.01710822f, 0.09600770f, 0.02725400f, 0.00981518f, 0.11757078f, 0.04667598f, 0.09758864f, 
    -0.00866239f, -0.10401379f, 0.05512770f, 0.06103361f, -0.08898262f, -0.11364315f, -0.05210174f, -0.02066742f, 
    -0.21110494f, -0.12195697f, 0.09118291f, -0.16010803f, -0.06394748f, -0.02539164f, 0.08027240f, 0.04977853f, 
    0.14357290f, -0.07538246f, 0.09467284f, 0.04064207f, -0.10012620f, 0.09318095f, 0.08703500f, -0.09594229f, 
    -0.07291428f, 0.04622081f, -0.09651671f, -0.03366564f, -0.00667294f, 0.08695530f, 0.01504213f, 0.17565924f, 
    -0.04374390f, -0.10268475f, -0.12939358f, 0.08714578f, 0.02204672f, 0.00501290f, -0.01347677f, -0.00820374f, 
    0.02826406f, 0.09230102f, -0.00986623f, 0.08763990f, 0.23915078f, -0.16995738f, -0.00024307f, 0.23820083f, 
    0.06433876f, 0.00089463f, 0.08508287f, 0.03396004f, -0.03039606f, 0.08205789f, -0.11525083f, 0.06872644f, 
    0.40297043f, -0.11356661f, -0.00490469f, -0.19492561f, 0.15796660f, -0.01256243f, 0.03548118f, 0.00287235f, 
    0.00327122f, 0.03340382f, 0.07426967f, -0.01266793f, -0.13901918f, -0.24212019f, -0.13387275f, -0.00833993f, 
    0.05894105f, -0.20296592f, 0.02636874f, -0.06860018f, -0.07727115f, -0.06882145f, -0.05895577f, -0.03637177f, 
    0.07406500f, 0.07050796f, -0.10817407f, 0.00651445f, 0.01708017f, 0.12738931f, 0.27983630f, 0.17659350f, 
    0.16085877f, 0.16688900f, 0.06436143f, -0.01491735f, -0.03493196f, -0.01884374f, 0.10962002f, -0.11122505f, 
    -0.06023104f, 0.04563635f, -0.05716098f, 0.09264376f, -0.00902876f, -0.10895822f, 0.02879727f, 0.15045629f, 
    -0.02026550f, 0.09800341f, -0.08725008f, 0.05727963f, -0.06708463f, 0.04607464f, 0.04557113f, -0.02732177f, 
    0.14836034f, 0.00527695f, 0.00287279f, -0.07104908f, 0.07402104f, 0.18798532f, 0.07031656f, -0.02256889f, 
    -0.06597552f, 0.02256985f, -0.07685076f, 0.14138785f, -0.06061032f, -0.01370991f, -0.11602782f, -0.00201210f, 
    0.05189607f, 0.02688753f, -0.02359409f, -0.11522488f, -0.07783507f, 0.01297790f, 0.02507777f, -0.05902504f, 
    0.06763008f, 0.04621021f, -0.01123499f, 0.04687476f, 0.17839409f, 0.26551044f, -0.01804590f, 0.10312515f, 
    0.06651159f, 0.06390241f, 0.07409906f, 0.06618717f, 0.00647596f, 0.02173783f, 0.04832454f, 0.04365592f, 
    -0.12624408f, 0.20686753f, 0.15007210f, 0.23744783f, 0.02208839f, 0.03993488f, -0.00543414f, 0.16325477f, 
    -0.06591763f, 0.00491678f, 0.04154608f, -0.05576027f, 0.16826403f, -0.03514007f, -0.01245170f, -0.20141283f, 
    -0.02795063f, 0.08713197f, 0.02464763f, -0.11089893f, 0.00103050f, 0.03503771f, -0.04878329f, -0.10461642f, 
    -0.21264170f, 0.08818474f, 0.05420521f, -0.03228653f, 0.11045913f, 0.05608470f, 0.01338444f, 0.00673689f, 
    -0.08686909f, 0.05997333f, 0.04391050f, -0.16475363f, -0.16095206f, -0.18692873f, 0.07966221f, 0.02144132f, 
    0.11908411f, 0.13052408f, -0.00148593f, -0.00930160f, -0.06193782f, -0.03383241f, -0.04164642f, -0.06499133f, 
    -0.07112785f, 0.25675046f, -0.15314014f, 0.00573776f, 0.06729000f, -0.03966214f, -0.08261894f, -0.05841500f, 
    -0.03107949f, 0.07313292f, -0.04640210f, 0.01532934f, 0.01230070f, -0.04300332f, -0.19000353f, -0.13035399f, 
    -0.00853287f, -0.09722833f, 0.07925265f, -0.02664624f, 0.07927759f, -0.17651616f, 0.08157238f, -0.00704654f, 
    0.07396023f, 0.11547863f, 0.21848758f, -0.02563787f, 0.01115620f, 0.05020456f, 0.06994420f, 0.07620672f, 
    -0.03880874f, -0.09877196f, 0.08572997f, 0.00581737f, -0.12404147f, 0.09462276f, 0.00723004f, -0.22148965f, 
    0.01414755f, 0.13242571f, 0.01519090f, 0.05663396f, 0.10712441f, -0.06077700f, 0.00065523f, -0.02898415f, 
    -0.22700053f, 0.00995642f, 0.16303018f, 0.28418967f, -0.05383923f, -0.02948016f, 0.05851731f, 0.13697574f, 
    -0.02548536f, 0.01312331f, -0.09348559f, 0.05238032f, -0.10649420f, 0.06668270f, 0.13653660f, 0.01466453f, 
    0.00327545f, 0.24344753f, 0.00746880f, 0.01079024f, 0.05488625f, -0.01442370f, -0.09845701f, 0.14621869f, 
    -0.06199415f, -0.12642059f, 0.07505590f, 0.13584450f, -0.07510533f, -0.08160313f, -0.18379594f, -0.11797193f, 
    -0.18762226f, -0.03047722f, -0.00200428f, -0.03156584f, 0.03636543f, -0.11353759f, 0.22762805f, 0.16833273f, 
    0.05027558f, 0.04554462f, 0.03929123f, -0.02484383f, 0.11282273f, 0.16986273f, -0.01490423f, -0.08894657f, 
    -0.02502470f, 0.09969465f, 0.06737276f, -0.11747578f, 0.02255901f, -0.12792908f, -0.04843726f, -0.04438234f, 
    0.01433598f, 0.08650560f, 0.03926836f, 0.06295504f, 0.22676151f, -0.15802875f, -0.05274460f, -0.09460679f, 
    0.06204274f, 0.07597051f, 0.17565857f, -0.08617135f, 0.01824392f, 0.19886228f, 0.10703483f, -0.01114883f, 
    0.21740735f, 0.00787214f, -0.04290787f, -0.03386726f, 0.10683881f, -0.08203299f, -0.01656071f, 0.06650775f, 
    0.05493871f, -0.00505250f, 0.05264702f, -0.07616059f, -0.05512922f, 0.00010681f, 0.32157832f, -0.08202660f, 
    0.04797312f, 0.03345914f, -0.06320332f, -0.00107746f, 0.03192705f, -0.02919643f, -0.11455850f, -0.09555710f, 
    0.41555378f, -0.02085780f, 0.01400707f, -0.02208916f, 0.11750588f, 0.06804022f, 0.00650623f, 0.02848249f, 
    -0.00952889f, -0.07501388f, -0.03304649f, 0.17890455f, -0.19785953f, 0.24151617f, -0.19078456f, 0.21132891f, 
    0.12334953f, -0.01340470f, -0.07339578f, 0.17551228f, 0.13607800f, -0.03649015f, 0.09543478f, 0.10497148f, 
    -0.15099415f, -0.03037830f, -0.01184533f, -0.07414097f, -0.05563794f, -0.03624469f, 0.18415563f, 0.06108408f, 
    0.00708704f, 0.01873827f, 0.05729560f, 0.06508945f, -0.04792754f, -0.01302502f, -0.01292602f, 0.27433005f, 
    0.01774337f, 0.13285442f, 0.00561825f, -0.06950413f, -0.07219249f, 0.02349910f, 0.06680018f, 0.01231911f, 
    -0.02350840f, -0.03633151f, -0.11731350f, 0.06782300f, -0.03642311f, -0.04193896f, 0.03804414f, 0.00421742f, 
    -0.03824573f, 0.16812703f, 0.08137061f, 0.08406954f, 0.19990420f, -0.13419001f, 0.02539082f, -0.14179069f, 
    -0.03791558f, 0.00592383f, 0.21983300f, 0.07103422f, -0.06709991f, -0.08932520f, 0.05097945f, -0.05363226f, 
    -0.18496481f, 0.23675847f, -0.02086834f, 0.06096405f, 0.11123625f, 0.06501460f, -0.01091661f, -0.03844757f, 
    -0.10822499f, 0.08505005f, 0.04223646f, 0.01459847f, -0.14945143f, 0.12409417f, -0.11886557f, -0.02234949f, 
    -0.02289701f, 0.11068646f, 0.00531792f, -0.05703890f, -0.03739353f, 0.02719488f, 0.05082844f, -0.05951684f, 
    0.08803323f, 0.18428738f, 0.00041392f, 0.37879556f, -0.00498012f, -0.03930670f, -0.01826312f, 0.01086318f, 
    -0.07073651f, -0.02258092f, 0.02497342f, 0.08323771f, -0.00639183f, 0.00832437f, -0.02408384f, -0.19373547f, 
    0.01617779f, 0.19692875f, 0.08202157f, 0.02037360f, -0.01834561f, 0.18816550f, 0.00310884f, 0.11180291f, 
    0.06910641f, 0.24479128f, 0.13059914f, -0.13649935f, -0.03881756f, 0.00331050f, -0.03613927f, 0.01164808f, 
    -0.18407361f, -0.07374898f, 0.09312563f, -0.05364209f, -0.13172801f, 0.01117561f, -0.17949834f, 0.16155556f, 
    0.02026012f, -0.05737969f, 0.10637312f, -0.15952773f, -0.03167861f, -0.10020173f, -0.03655747f, -0.09325041f, 
    0.04528073f, 0.10209857f, 0.03868821f, -0.11491673f, -0.02970994f, -0.00469459f, -0.02927853f, -0.00524810f, 
    -0.00217710f, 0.24133410f, -0.02655490f, 0.00372733f, 0.22722977f, 0.14612198f, 0.31909111f, -0.07847409f, 
    -0.00305123f, -0.05462931f, -0.02147574f, -0.06731119f, 0.04798436f, 0.09156891f, -0.00543327f, 0.03734865f, 
    0.09019574f, 0.16050479f, 0.04549970f, 0.03821527f, -0.01093097f, -0.09638042f, -0.20627096f, 0.02209660f, 
    0.04713595f, -0.01243029f, -0.08490650f, -0.08706556f, 0.27830341f, -0.01142056f, 0.04825547f, 0.08552191f, 
    -0.10644986f, 0.05277134f, -0.09667918f, 0.00118771f, 0.09425192f, 0.05465039f, -0.02561434f, -0.07629869f, 
    0.19344665f, -0.11619965f, 0.11087340f, -0.11801496f, -0.08953057f, -0.06744809f, -0.09183250f, 0.00901974f, 
    0.05197114f, -0.05846922f, -0.05181259f, 0.03250272f, -0.25670969f, -0.02754218f, -0.01636302f, 0.04466388f, 
    0.03214714f, -0.06076313f, 0.13202035f, -0.00522719f, -0.05281551f, -0.06265838f, 0.01484525f, -0.09317019f, 
    0.11698416f, -0.04225971f, 0.08903179f, 0.07037187f, -0.05216883f, -0.01536581f, -0.05365155f, 0.00248425f, 
    -0.05649709f, -0.00627351f, -0.05092232f, 0.09347836f, 0.04234448f, -0.02657118f, 0.06146844f, 0.02970533f, 
    -0.08592267f, -0.13627654f, 0.06539596f, 0.02415880f, -0.07545370f, 0.02403065f, 0.02874472f, -0.00675131f, 
    0.20884769f, 0.08647737f, 0.16957961f, -0.08199185f, -0.10014193f, 0.02490813f, 0.11829069f, -0.06500646f, 
    -0.03239692f, -0.08539922f, 0.01359194f, -0.01921504f, -0.13495702f, 0.29882967f, 0.24201769f, -0.10887507f, 
    0.07953898f, 0.11827329f, -0.13391192f, -0.08062279f, -0.02685309f, 0.05752583f, 0.03850035f, -0.01708763f, 
    0.30539191f, -0.25331560f, 0.17881040f, -0.04509365f, -0.01299995f, -0.00982398f, 0.01307196f, -0.12120347f, 
    0.11375646f, 0.04693121f, 0.09032611f, 0.08632162f, 0.20996362f, 0.05322446f, -0.10633616f, 0.02553479f, 
    -0.04861351f, -0.09039035f, 0.05896529f, 0.08472393f, -0.18105140f, -0.06791591f, 0.00867164f, -0.06947324f, 
    0.42529219f, 0.12272704f, -0.03359535f, -0.07000753f, 0.13269782f, 0.12649979f, 0.02578878f, 0.17558993f, 
    0.01680637f, -0.02819021f, 0.04038382f, -0.10864443f, 0.19149432f, 0.03868758f, 0.11132971f, -0.04076481f, 
    0.10721712f, -0.02062313f, -0.01557564f, -0.11877188f, 0.00443513f, -0.06876710f, -0.06361810f, -0.10705201f, 
    -0.24311909f, 0.03270543f, -0.05449818f, 0.07098597f, 0.11589373f, 0.15848643f, 0.22719643f, -0.05830548f, 
    0.08174116f, 0.10121256f, 0.00811370f, 0.08492079f, -0.05745896f, 0.14465049f, 0.29622874f, -0.12305374f, 
    -0.02417895f, 0.02356470f, 0.03886367f, 0.04572785f, -0.00172299f, 0.00446340f, 0.12912323f, -0.00734047f, 
    -0.15048106f, 0.21899396f, -0.06538183f, 0.02437950f, 0.08002208f, 0.07489406f, 0.00245121f, -0.07297406f, 
    -0.01732829f, -0.08168010f, -0.06945823f, 0.02511880f, -0.03086736f, 0.03121339f, 0.02290644f, -0.01916613f, 
    -0.08810458f, 0.01254820f, -0.05131324f, 0.00199767f, -0.04113384f, -0.00332679f, 0.00220017f, -0.08562820f, 
    -0.11679219f, -0.07237040f, -0.04380658f, 0.13202639f, 0.01170489f, 0.14550367f, 0.01930095f, -0.13831969f, 
    0.08695024f, 0.03503579f, -0.05728813f, 0.03088419f, 0.09660894f, -0.18523963f, -0.07443410f, -0.05192268f, 
    -0.02325970f, 0.01138356f, 0.02506816f, -0.07802133f, 0.08706886f, -0.01240062f, 0.06969453f, -0.01191280f, 
    -0.24192497f, 0.01426939f, 0.04690788f, 0.14588323f, -0.06379514f, -0.05967719f, -0.08766563f, 0.13996272f, 
    0.01114301f, -0.02809587f, -0.02235428f, -0.00574622f, 0.30707738f, 0.10377036f, 0.12548721f, -0.22748511f, 
    -0.02638269f, 0.12126918f, -0.13125633f, -0.04922216f, 0.07779623f, 0.01137964f, -0.04837470f, -0.07387055f, 
    -0.00717153f, 0.00045260f, -0.02026128f, -0.04121030f, -0.02308809f, -0.05724819f, 0.04967550f, 0.05321316f, 
    -0.05077244f, -0.05619854f, -0.03510554f, 0.02908850f, -0.02329682f, -0.02944770f, -0.01863983f, -0.04839338f, 
    0.04468539f, -0.06983989f, -0.01445163f, 0.07128178f, -0.04203573f, 0.04632435f, -0.01892435f, 0.01436066f, 
    0.01504162f, -0.02809223f, -0.08094760f, -0.05108673f, -0.02087351f, -0.08148942f, -0.07456408f, -0.07135075f, 
    -0.06714500f, 0.02453996f, 0.06300624f, 0.04974096f, 0.00081356f, 0.04030505f, -0.01074104f, -0.04943758f, 
    -0.04207320f, -0.00242974f, -0.03908237f, -0.02763173f, -0.03959206f, -0.02222199f, 0.01195411f, -0.06975178f, 
    0.03545011f, -0.06302849f, 0.03977447f, 0.04211402f, -0.05448177f, -0.05651478f, 0.00812364f, -0.01458577f, 
    -0.01085030f, 0.01396855f, 0.01240991f, -0.06561370f, 0.00600141f, 0.02919805f, -0.02036521f, -0.04685948f, 
    0.02541174f, 0.02861156f, 0.00742679f, -0.01934070f, 0.04750669f, 0.06691743f, 0.02534585f, -0.03349350f, 
    0.03049746f, -0.04747529f, -0.02336634f, -0.05470508f, 0.00882210f, 0.03914676f, 0.02836054f, -0.00476265f, 
    -0.03456109f, 0.00326139f, 0.00905099f, -0.00158102f, -0.04104130f, 0.00446786f, -0.01133150f, 0.02257916f, 
    -0.06170483f, -0.05436539f, 0.06589733f, 0.06007259f, 0.03078940f, -0.02873088f, 0.00680336f, -0.00598100f, 
    0.01714362f, 0.00320545f, -0.07405458f, -0.05862153f, -0.06501619f, -0.05949541f, 0.05703262f, -0.04269654f, 
    -0.02308954f, -0.04306322f, 0.01050661f, -0.01232535f, -0.01745594f, -0.00986538f, -0.02372222f, 0.03954509f, 
    0.07010642f, -0.05524901f, 0.01742845f, -0.01392553f, 0.02849891f, 0.06085073f, -0.06843755f, -0.05295012f, 
    -0.01603533f, 0.03498676f, 0.03848102f, 0.05884279f, 0.00216333f, 0.03744953f, 0.01935882f, -0.01205261f, 
    0.01194723f, 0.05972449f, -0.07385341f, -0.02246273f, -0.06907029f, 0.02654782f, -0.04422050f, -0.00056524f, 
    0.03358271f, 0.03686604f, -0.06370360f, -0.00380616f, -0.05834375f, 0.02505264f, -0.04951070f, 0.00297976f, 
    -0.08132880f, 0.00886901f, 0.04922169f, 0.02760530f, 0.00066117f, -0.01175296f, -0.04887346f, 0.05831434f, 
    0.00551762f, -0.06505758f, -0.03872921f, 0.02620836f, 0.00245615f, 0.02320717f, 0.02336415f, 0.01710798f, 
    -0.03288093f, -0.02572620f, 0.05235270f, 0.00544228f, -0.04912672f, -0.06290217f, 0.04440684f, -0.00020497f, 
    -0.02129038f, -0.00254399f, -0.01693047f, -0.03775798f, 0.05926053f, -0.02854263f, 0.03449915f, -0.02875358f, 
    -0.01504603f, -0.03485320f, -0.05843160f, -0.05208750f, 0.03611832f, -0.04805009f, -0.02354439f, -0.05862770f, 
    0.03585381f, 0.06597430f, 0.04121384f, 0.00683942f, 0.03393726f, -0.07387302f, 0.00217597f, -0.00440679f, 
    -0.17891753f, 0.06313457f, 0.07840332f, 0.09528676f, 0.05415053f, 0.05905447f, -0.01690555f, 0.02875455f, 
    0.07363085f, -0.03741318f, 0.02585833f, 0.06456863f, -0.21174957f, -0.05254498f, 0.10816872f, 0.12671119f, 
    -0.07137952f, -0.03630104f, 0.08932402f, 0.02768652f, -0.11709403f, -0.02407389f, 0.01226497f, 0.08558620f, 
    0.07998665f, 0.12951525f, -0.01986879f, 0.17267942f, 0.07688579f, -0.04048451f, 0.02811983f, 0.03910351f, 
    0.05854408f, -0.08447985f, -0.03667019f, 0.08977665f, -0.04187905f, 0.08553435f, 0.04264684f, -0.12013116f, 
    0.06769317f, -0.09113785f, -0.15205376f, -0.10392836f, 0.01793478f, -0.08377038f, -0.08870922f, 0.00316100f, 
    -0.05269959f, 0.19024807f, 0.17406498f, -0.08179044f, -0.12104143f, 0.19211617f, -0.03048786f, -0.13547558f, 
    0.07097448f, 0.01402976f, 0.00256669f, 0.12084381f, -0.01885249f, 0.04452639f, 0.09269145f, 0.07496303f, 
    -0.06305894f, -0.00314261f, 0.17867669f, -0.13586074f, 0.11387673f, -0.05585571f, 0.19513726f, -0.10739230f, 
    -0.02696720f, -0.24015181f, -0.08226713f, 0.06174943f, -0.04082534f, 0.04552878f, -0.13458684f, 0.15168560f, 
    0.16702047f, -0.02260236f, 0.13957192f, -0.04685685f, 0.21493430f, -0.06294046f, 0.19723704f, -0.00887444f, 
    0.05366490f, -0.07422637f, -0.04922803f, 0.02845377f, 0.06403420f, -0.00070424f, 0.00464600f, 0.01635171f, 
    -0.41164398f, 0.01952551f, -0.11832058f, -0.00093124f, 0.08067311f, 0.01092359f, 0.09519600f, -0.00966657f, 
    0.06500109f, 0.07857627f, -0.00566403f, 0.23713113f, -0.03475291f, -0.10168175f, -0.12181763f, 0.07467185f, 
    0.06322359f, -0.02549835f, 0.11006896f, 0.06237476f, -0.07496369f, -0.03561934f, 0.12336870f, -0.06244154f, 
    0.17036656f, 0.19826917f, 0.06641975f, -0.10330515f, -0.07451604f, 0.03035697f, -0.00410142f, -0.01713298f, 
    0.05411867f, -0.11048465f, 0.05570283f, 0.03539599f, -0.50074178f, 0.04101986f, -0.10937984f, -0.13088137f, 
    0.05464018f, -0.02205337f, -0.04807660f, 0.10480868f, 0.05229010f, -0.10089074f, 0.10743306f, -0.12283054f, 
    -0.33838490f, -0.22224954f, -0.19300361f, 0.07361583f, 0.06800950f, -0.07160636f, 0.01390044f, -0.04446246f, 
    0.11029460f, 0.03681320f, 0.16965739f, -0.01230810f, -0.02651041f, -0.02907287f, 0.17661335f, -0.17952067f, 
    0.05550139f, 0.03858761f, -0.02066375f, -0.04145247f, 0.05498054f, -0.02315919f, -0.02062968f, 0.09735259f, 
    0.08767430f, -0.03901728f, 0.16283441f, 0.02819841f, 0.00089437f, 0.06205331f, -0.00747275f, -0.00044903f, 
    -0.00836744f, 0.12958583f, 0.18824409f, 0.14524920f, -0.23018245f, 0.07012764f, -0.13516563f, -0.10916780f, 
    0.04809388f, 0.03009102f, -0.00358718f, -0.14077997f, 0.02451296f, 0.05860865f, -0.01035769f, -0.09241825f, 
    0.04713143f, 0.02804539f, 0.01016383f, -0.01600280f, 0.05236764f, 0.04124940f, -0.05963823f, -0.01997446f, 
    0.00069847f, -0.04461173f, -0.05750446f, 0.03100165f, 0.03423673f, 0.02866694f, 0.02057908f, -0.06253871f, 
    -0.03735040f, -0.04291862f, -0.01171022f, -0.03879131f, -0.03236482f, -0.01754375f, 0.04834640f, -0.02648155f, 
    -0.01979885f, 0.00384967f, 0.04564720f, -0.06652793f, 0.04314932f, -0.02605852f, -0.02507832f, -0.04786009f, 
    0.00717847f, -0.06946762f, 0.01958534f, -0.02578270f, -0.05174597f, 0.03421416f, 0.02011280f, -0.07161824f, 
    0.01162974f, 0.04718393f, 0.02498372f, -0.00693513f, -0.04862042f, 0.03591273f, 0.04934184f, -0.06794824f, 
    -0.06256481f, -0.05228761f, -0.03602979f, -0.07103850f, -0.05444405f, 0.03106346f, -0.04826933f, -0.06806438f, 
    0.05762509f, 0.04240080f, 0.06197488f, -0.03017628f, 0.05098788f, 0.05970434f, -0.05993144f, 0.05265791f, 
    0.00409531f, -0.03592893f, 0.07045177f, 0.00615862f, -0.04439111f, 0.00396885f, 0.02354785f, -0.03819231f, 
    0.04147365f, 0.02668892f, 0.00465041f, -0.00368065f, 0.03383203f, -0.01122393f, 0.00434114f, 0.06428581f, 
    -0.01829865f, -0.07669286f, -0.04590247f, -0.00321415f, -0.04605495f, -0.04126017f, -0.04545162f, -0.01205210f, 
    0.04090640f, -0.06183180f, -0.06121869f, -0.00032378f, 0.06475888f, -0.05972891f, -0.01875740f, -0.05051373f, 
    0.03215758f, -0.01759494f, 0.00678283f, 0.02946074f, -0.00399344f, 0.00458051f, 0.03135290f, -0.03944781f, 
    0.06326963f, 0.06372830f, -0.03361046f, 0.03266272f, 0.01678945f, -0.06882012f, 0.00774846f, 0.02078210f, 
    0.04956407f, -0.04888502f, -0.07755516f, -0.02485961f, 0.01411638f, 0.00754425f, -0.02566444f, -0.07130083f, 
    -0.03996956f, -0.01865450f, 0.05294060f, -0.03386923f, -0.00589086f, -0.03726633f, 0.05580454f, -0.01502085f, 
    -0.01551722f, 0.03195198f, -0.00133387f, -0.05756810f, -0.06699776f, 0.01781731f, -0.00202464f, -0.01876429f, 
    -0.01414246f, -0.02614886f, 0.01566973f, -0.05829706f, 0.00865330f, 0.01968017f, 0.04949994f, 0.05498576f, 
    -0.02058346f, -0.04216591f, -0.05845985f, -0.00415705f, 0.02755066f, -0.06331280f, -0.02762939f, -0.00653290f, 
    0.01505111f, 0.04427867f, -0.01343335f, -0.01574710f, -0.02600436f, -0.03277237f, -0.05329555f, -0.04722784f, 
    0.05016441f, 0.01226678f, -0.01376797f, 0.02355909f, -0.06006505f, 0.04654191f, 0.00706606f, -0.03255628f, 
    -0.02785645f, 0.03144860f, 0.01222575f, -0.03133253f, -0.07590698f, -0.05878850f, -0.01644654f, -0.06361556f, 
    -0.06832294f, -0.03382886f, -0.01050287f, -0.01543856f, -0.02257526f, -0.05631418f, 0.03093947f, -0.03752621f, 
    0.04893376f, 0.06014545f, -0.06373065f, 0.03075579f, 0.04141757f, -0.01111028f, 0.01766169f, -0.01024037f, 
    -0.21008633f, 0.04385287f, 0.04200043f, 0.02248538f, 0.22594960f, 0.12148926f, 0.10101563f, 0.02447253f, 
    0.06862054f, 0.11376131f, 0.01578540f, -0.04911222f, 0.05210743f, -0.05480566f, 0.04188257f, -0.01077488f, 
    0.01417633f, 0.04018341f, -0.07237743f, 0.03268501f, -0.05923652f, 0.04477932f, -0.07977551f, 0.07742666f, 
    -0.07648529f, 0.02299652f, -0.14932865f, -0.11016966f, 0.01424470f, 0.02221400f, 0.02973934f, 0.06320692f, 
    -0.01395762f, 0.01630109f, -0.07101957f, 0.11330298f, -0.16345461f, -0.04170680f, -0.16080151f, -0.31047088f, 
    0.03418610f, -0.03326262f, 0.15379271f, 0.04268993f, -0.06043538f, -0.10393687f, 0.02643335f, 0.11071058f, 
    -0.14501439f, 0.09477537f, 0.10530955f, -0.04679763f, 0.01480289f, 0.03789895f, 0.07163522f, 0.14704706f, 
    -0.10262195f, -0.08108516f, 0.07892596f, 0.15014257f, -0.08969394f, 0.13709401f, 0.15615797f, -0.01808565f, 
    -0.04231813f, 0.01369802f, 0.04023520f, 0.06911837f, 0.14919974f, -0.05343333f, 0.06028011f, 0.01343065f, 
    -0.14006993f, -0.04009616f, 0.02341732f, 0.33740357f, -0.14376353f, -0.10117283f, -0.02307367f, -0.00301479f, 
    -0.04486196f, -0.04735931f, -0.00336177f, 0.02710437f, -0.14683485f, 0.05324565f, 0.18188359f, -0.11020979f, 
    0.02037788f, 0.11089151f, 0.03797366f, 0.08036504f, 0.07109908f, 0.09320900f, 0.08657812f, 0.10646418f, 
    -0.10241337f, 0.13824730f, 0.15348564f, 0.05603013f, -0.04819023f, -0.01546501f, 0.01570979f, 0.02810572f, 
    0.00997249f, -0.07270916f, -0.03880662f, -0.06401822f, -0.05996878f, -0.22091366f, 0.05210218f, 0.26740620f, 
    0.02482885f, 0.04755190f, 0.08597835f, -0.07032664f, 0.04069749f, -0.02879027f, -0.09443210f, -0.14330785f, 
    -0.20903872f, 0.14583637f, 0.05199491f, -0.26442760f, 0.05967027f, 0.01169335f, 0.07231639f, 0.05110255f, 
    0.03297004f, 0.09538242f, 0.08581062f, 0.03173751f, -0.21605825f, 0.15019453f, 0.12260286f, -0.05157586f, 
    0.08426677f, 0.08057865f, 0.08472496f, -0.01553296f, -0.03515796f, 0.02922083f, -0.04118450f, -0.03030685f, 
    0.08057464f, -0.04884946f, -0.06295241f, 0.13082553f, -0.01847925f, -0.11080130f, -0.05844936f, 0.07109185f, 
    0.10505074f, -0.02058957f, -0.06206637f, -0.08203838f, 0.12964448f, 0.29073876f, 0.22376490f, -0.00209449f, 
    -0.04405170f, 0.01973374f, 0.09514529f, 0.00070034f, 0.03332095f, -0.00423428f, -0.05131907f, -0.05900352f, 
    0.35606065f, -0.08282062f, 0.17301565f, 0.01647644f, 0.07418820f, 0.00714158f, 0.02814308f, 0.07164183f, 
    0.02225369f, 0.03820615f, 0.06824668f, 0.09245254f, -0.35214388f, 0.06670491f, -0.06609675f, 0.11084732f, 
    -0.02251681f, -0.10727208f, 0.07176384f, 0.23887752f, 0.04067486f, 0.04019850f, 0.09928646f, 0.07902826f, 
    -0.20936921f, -0.02557051f, -0.14236188f, 0.17087945f, 0.04233624f, 0.11323789f, 0.14032082f, -0.02722693f, 
    -0.05868820f, 0.02328242f, 0.04795391f, 0.13750058f, -0.10587554f, -0.10257020f, 0.05435175f, 0.12077409f, 
    0.11912636f, 0.04413008f, -0.05575712f, 0.10471358f, -0.02716100f, 0.04675918f, -0.05862812f, -0.03050740f, 
    0.00921063f, 0.20936736f, 0.03541529f, -0.02657579f, -0.04357193f, -0.00532181f, 0.02925862f, 0.04459238f, 
    0.02354784f, 0.04627825f, -0.04802885f, 0.03612963f, -0.29676563f, 0.19970688f, -0.01862112f, -0.26332337f, 
    0.07603525f, 0.03825541f, -0.02343989f, -0.02743939f, -0.04377499f, -0.02994877f, 0.06138207f, 0.07906155f, 
    0.06783347f, -0.09802433f, 0.24685819f, -0.11963324f, -0.01884975f, -0.03996656f, 0.02195961f, -0.05918417f, 
    0.01423959f, 0.04905313f, 0.13595663f, 0.19133297f, 0.08140086f, -0.00184774f, -0.10491236f, 0.01711705f, 
    -0.09579861f, 0.00190017f, 0.05544779f, 0.08193622f, -0.07318518f, -0.15967014f, 0.02473088f, -0.08120450f, 
    0.18912725f, 0.16149183f, -0.12072047f, 0.11778940f, 0.00018944f, 0.04892665f, 0.04730450f, 0.10328024f, 
    -0.08386925f, -0.00815326f, 0.03064890f, -0.00551719f, 0.06174500f, 0.11855083f, 0.15313125f, 0.07130089f, 
    0.12588899f, -0.03672558f, 0.02812821f, 0.05837765f, 0.04575919f, 0.01981393f, -0.00170493f, 0.02364706f, 
    -0.31958079f, 0.07394803f, 0.13024735f, 0.08822529f, 0.07126284f, 0.09551496f, 0.10705235f, -0.17234078f, 
    -0.04579988f, -0.03209214f, -0.00769334f, -0.08081157f, -0.16292256f, 0.26947221f, 0.01773418f, 0.24338262f, 
    0.09134222f, -0.07748563f, -0.06102553f, 0.03700970f, 0.06234382f, -0.06750000f, 0.04008856f, 0.01790482f, 
    -0.00843443f, 0.13037632f, -0.03426115f, -0.24567848f, -0.16262802f, 0.01911812f, -0.00951946f, -0.01945348f, 
    -0.05123621f, 0.03496660f, -0.08179262f, 0.03102968f, -0.12637633f, -0.09244732f, 0.19027187f, -0.21459451f, 
    -0.04026102f, 0.07616262f, -0.13673234f, 0.19659193f, 0.11968337f, 0.09852669f, -0.05964295f, 0.00158745f, 
    -0.14794682f, -0.16029577f, -0.09954339f, -0.00865436f, 0.06562237f, 0.04027846f, -0.00785599f, -0.23013373f, 
    0.15588455f, 0.09015949f, 0.05918575f, 0.03903995f, 0.19743119f, -0.01135371f, 0.14305429f, -0.12349220f, 
    -0.04674278f, 0.00443909f, 0.07108245f, -0.05738232f, 0.01230767f, -0.02501608f, -0.12129787f, 0.09672619f, 
    0.04000794f, 0.06047006f, 0.17012745f, 0.12196578f, -0.08149181f, -0.09303641f, -0.05876990f, 0.16239530f, 
    -0.15150726f, 0.08882228f, 0.08209426f, 0.01326413f, -0.18289974f, 0.26653916f, -0.01352535f, -0.11769677f, 
    -0.04316142f, 0.02964600f, 0.04511513f, 0.00457448f, -0.00673647f, -0.04745106f, -0.02125005f, 0.06130257f, 
    0.07363373f, -0.11630253f, -0.20480821f, -0.06038420f, 0.11692734f, -0.10485619f, -0.14287615f, -0.04256656f, 
    -0.09864510f, -0.08643463f, 0.17259370f, -0.06026648f, -0.23591581f, -0.21274930f, -0.20380931f, 0.10587874f, 
    0.12547167f, 0.14387386f, 0.01686438f, 0.07258534f, 0.00687255f, 0.05278596f, 0.02554910f, -0.05834247f, 
    -0.01018057f, 0.04205614f, -0.12091883f, -0.11553655f, 0.13217737f, 0.07803962f, 0.09127890f, -0.02917472f, 
    0.03735688f, -0.07378490f, -0.05721796f, -0.01129725f, -0.17370252f, 0.12738775f, -0.05277415f, -0.08739807f, 
    -0.03017028f, -0.03766198f, -0.00130791f, -0.00636404f, 0.09340641f, -0.00443901f, 0.09981071f, -0.12835452f, 
    -0.26251784f, -0.02234645f, -0.11143025f, -0.20985393f, 0.01302124f, -0.18794394f, 0.09207951f, 0.03482182f, 
    -0.02687470f, -0.19351536f, -0.04906530f, 0.03862521f, -0.05549420f, -0.17935015f, -0.08417014f, 0.04172223f, 
    0.09082757f, -0.05773054f, -0.04308594f, 0.07500256f, 0.04301254f, -0.10346390f, -0.07844210f, 0.11359967f, 
    0.24996221f, 0.05346316f, 0.02228493f, 0.02612364f, -0.22610712f, -0.01073700f, 0.09944551f, -0.18236132f, 
    -0.02598625f, -0.13195829f, -0.04602429f, -0.05421451f, 0.06924220f, -0.09668183f, -0.27767298f, -0.05325370f, 
    -0.10339631f, 0.00615648f, 0.00041861f, -0.01269153f, 0.10038518f, 0.03722035f, 0.12691811f, 0.18930085f, 
    0.33958256f, -0.12082405f, 0.10533156f, 0.05779443f, -0.11452074f, -0.22995424f, 0.02130179f, -0.12121135f, 
    -0.00884098f, 0.00775730f, 0.03857229f, -0.08893870f, 0.29038572f, -0.18641844f, -0.00772644f, 0.16239402f, 
    -0.00902464f, 0.20076358f, 0.01754061f, 0.21207340f, -0.00533392f, 0.10429037f, 0.05339104f, -0.03658942f, 
    -0.02871706f, -0.08764698f, -0.13494855f, 0.06194557f, 0.03340377f, -0.01206644f, -0.13261674f, -0.03313372f, 
    0.00466245f, -0.01053322f, 0.11504231f, 0.10996678f, 0.46862286f, 0.08994980f, 0.10523947f, 0.07517191f, 
    -0.15476899f, 0.11289605f, -0.01129012f, 0.07498413f, -0.04157747f, 0.03100986f, 0.09776863f, -0.04453377f, 
    0.28409871f, 0.26545075f, 0.08193013f, -0.03301662f, -0.05419282f, 0.07731072f, 0.25363848f, 0.08089847f, 
    -0.00724421f, -0.03079819f, -0.05330740f, -0.00299278f, -0.28587586f, 0.03242216f, 0.05221037f, 0.16162309f, 
    0.00950226f, -0.07441215f, -0.14404143f, -0.00367320f, -0.24272862f, -0.01105966f, 0.01593809f, -0.03385851f, 
    0.05744023f, 0.14914411f, 0.01666369f, 0.34494939f, -0.01814164f, 0.04438393f, 0.04469413f, 0.05010871f, 
    0.01178808f, 0.01021835f, 0.01759155f, 0.16717510f, 0.04187848f, -0.00102259f, -0.11352125f, 0.05051244f, 
    0.03332623f, 0.01047582f, 0.03490235f, 0.10929307f, 0.14823844f, 0.06946648f, 0.04376621f, -0.02820497f, 
    0.04439560f, 0.06530844f, -0.02326877f, -0.08539123f, -0.01438775f, -0.02032212f, 0.00539995f, -0.00690969f, 
    0.04402747f, 0.05860968f, -0.06235047f, -0.02591421f, 0.31314257f, 0.06742190f, 0.09094259f, 0.17959510f, 
    -0.07713273f, 0.06342014f, 0.00066015f, -0.05846867f, -0.05861138f, -0.07132451f, -0.05189080f, -0.03160901f, 
    0.05291010f, -0.25896177f, -0.14976537f, -0.18593282f, -0.01593925f, 0.03820928f, -0.18488406f, -0.07905497f, 
    0.10558781f, -0.02395482f, 0.06755184f, 0.03179533f, 0.07896125f, -0.09277263f, 0.18804336f, -0.14232734f, 
    0.04365483f, 0.13495305f, -0.09770007f, 0.06408077f, -0.03251168f, 0.00079652f, 0.05106689f, -0.14057362f, 
    -0.09150764f, -0.00137754f, 0.02082948f, 0.23640837f, 0.14389314f, -0.07759966f, -0.07981492f, 0.12398574f, 
    -0.10046684f, -0.12670365f, -0.16140509f, 0.15675180f, 0.22325462f, 0.11001302f, -0.10533215f, 0.14981873f, 
    -0.04946984f, -0.01090476f, -0.09260155f, -0.18296655f, -0.00510419f, -0.07841544f, -0.14983606f, 0.02699914f, 
    0.37355223f, -0.08360456f, -0.17458275f, -0.04070164f, 0.08089769f, 0.07431146f, 0.12785876f, -0.03062919f, 
    -0.11117991f, -0.05582101f, 0.15142287f, -0.01268625f, 0.18590051f, 0.11734880f, -0.14293692f, -0.03090640f, 
    -0.03030640f, -0.03149320f, 0.08257187f, -0.10735421f, 0.06911036f, 0.16264416f, 0.13471851f, 0.06351341f, 
    -0.05967284f, 0.27985379f, -0.03561624f, -0.12955622f, 0.06485634f, -0.02049649f, -0.08274824f, -0.06155887f, 
    -0.13204342f, -0.21980314f, -0.11684403f, -0.17862393f, -0.21287890f, 0.10136009f, -0.11168841f, 0.01422547f, 
    0.06188274f, 0.10925692f, 0.12127326f, 0.04469177f, 0.02282206f, -0.01062517f, -0.08074216f, -0.08429231f, 
    0.07741880f, 0.09360390f, -0.16713761f, 0.03843002f, -0.02862263f, -0.10213181f, -0.00165474f, -0.08586711f, 
    0.04138282f, 0.12113553f, 0.18921691f, -0.05735644f, -0.43824852f, 0.27435514f, 0.32029125f, -0.02971558f, 
    0.04027000f, 0.01108015f, 0.11825734f, -0.08434916f, 0.03189440f, -0.01249361f, 0.03396133f, 0.11808420f, 
    0.12267796f, 0.00051760f, -0.06510050f, -0.16658728f, 0.11445503f, 0.14186408f, 0.01523380f, 0.03978013f, 
    0.13802533f, 0.04855041f, -0.13764714f, 0.01014597f, 0.25140789f, 0.00032138f, -0.27057406f, 0.21042646f, 
    0.03202678f, -0.09164757f, -0.11780490f, 0.02420706f, 0.06513508f, 0.04102187f, -0.09320430f, -0.09900501f, 
    -0.12054899f, 0.05815412f, 0.30157951f, -0.02356483f, -0.05205434f, 0.09865615f, 0.06152923f, 0.10719750f, 
    -0.08136978f, 0.04446303f, -0.08768263f, -0.07138404f, -0.04310471f, -0.15116410f, -0.07293981f, -0.18394905f, 
    0.05988136f, -0.01096404f, 0.26184320f, 0.04751731f, -0.05535019f, 0.02505094f, 0.13498488f, 0.13526730f, 
    0.41788760f, 0.14406584f, -0.02146961f, 0.11274299f, 0.05856268f, -0.06648511f, 0.05231814f, -0.02525872f, 
    0.08817684f, 0.03919740f, -0.03636466f, -0.03370187f, 0.23806117f, 0.04348555f, -0.05990883f, -0.24541640f, 
    0.08102290f, 0.04812741f, 0.00138537f, -0.00031836f, 0.11336327f, 0.01265405f, 0.09972649f, -0.02265787f, 
    0.01541617f, 0.02033580f, 0.00033674f, -0.00410491f, 0.03271284f, -0.00933004f, -0.08385548f, 0.09430068f, 
    -0.10932686f, -0.07322248f, 0.07416942f, -0.09314428f, -0.18601246f, 0.03298397f, -0.05141541f, 0.13679984f, 
    0.03747056f, 0.04700343f, -0.10298430f, 0.04327620f, 0.13151458f, 0.09288037f, -0.00052427f, -0.03270717f, 
    0.19202504f, -0.01536854f, -0.02894392f, -0.02973153f, 0.05444244f, -0.12104185f, 0.05078984f, 0.00502365f, 
    0.00893010f, 0.02141980f, -0.10693141f, -0.16698137f, 0.05542359f, 0.10891402f, 0.03010324f, -0.10972579f, 
    0.13773505f, -0.10253496f, -0.09597278f, 0.05218871f, 0.00782871f, 0.10474470f, -0.06753423f, 0.01749562f, 
    -0.25595480f, 0.12935534f, -0.00896194f, -0.12126682f, -0.03305978f, -0.08459845f, -0.02294253f, -0.08170056f, 
    0.08035412f, 0.02446899f, 0.01843304f, -0.01964635f, -0.06014588f, 0.31521180f, -0.05736893f, 0.04553399f, 
    -0.09034479f, 0.02078185f, -0.10040277f, 0.02340441f, -0.03159168f, 0.04624861f, 0.09859473f, -0.05590197f, 
    0.21427669f, -0.22059399f, 0.23216712f, -0.07899294f, 0.03767985f, -0.07829780f, -0.05130397f, 0.03967345f, 
    -0.01463208f, 0.09488916f, 0.03459974f, 0.05887511f, 0.21105906f, -0.02195862f, -0.07939337f, 0.10072858f, 
    0.08797780f, 0.00804608f, -0.08463015f, 0.02526210f, 0.02447199f, 0.11862192f, 0.08504521f, 0.12387534f, 
    -0.29499948f, -0.17387608f, 0.14451176f, -0.02136528f, 0.21691301f, 0.01544142f, 0.03958625f, -0.01424418f, 
    -0.03400488f, -0.14206974f, 0.09875703f, 0.04209831f, 0.12112372f, -0.07320966f, -0.16554515f, 0.06199843f, 
    0.02954599f, -0.03406138f, 0.07859483f, -0.03982726f, 0.03043064f, -0.05978298f, 0.19435780f, 0.03153021f, 
    0.01425800f, 0.02513737f, 0.09797531f, 0.04452532f, -0.09484860f, 0.06259341f, 0.10908632f, -0.03109040f, 
    -0.06275414f, 0.00285679f, -0.04412514f, 0.02855714f, -0.13130799f, 0.06542785f, -0.00342773f, -0.15500376f, 
    0.09610511f, 0.05906776f, 0.03329640f, 0.05229437f, -0.00089086f, 0.02212713f, 0.01057498f, -0.01949781f, 
    -0.12027118f, -0.05400555f, -0.27099895f, -0.00962665f, 0.03160790f, 0.10080409f, 0.12118552f, -0.13670151f, 
    0.14061664f, -0.02290522f, -0.15211596f, -0.09692905f, 0.14421611f, -0.11822199f, 0.01920048f, -0.00771808f, 
    0.11082611f, 0.01029200f, -0.03825147f, 0.08139477f, -0.02820671f, 0.01551449f, -0.00835253f, 0.09119160f, 
    0.00391998f, -0.01273416f, -0.00019764f, 0.03376104f, -0.09247827f, 0.00657485f, -0.06782062f, -0.05061006f, 
    -0.08038990f, -0.03250759f, -0.10364445f, -0.03450009f, -0.03755706f, -0.07864713f, -0.06632008f, -0.08644989f, 
    -0.01340535f, 0.03761277f, -0.04070015f, 0.03350374f, -0.05528389f, -0.04510435f, -0.08017897f, -0.09131613f, 
    -0.02646927f, -0.06559229f, -0.05075191f, 0.02342525f, 0.00818539f, 0.05691245f, -0.03463292f, -0.05441661f, 
    0.00059401f, -0.07186165f, 0.02998165f, -0.01941099f, 0.02631155f, 0.01323844f, 0.00091748f, 0.03392875f, 
    0.03771311f, 0.03434973f, -0.00658496f, -0.08710502f, -0.09375934f, -0.00575212f, -0.05858300f, -0.02283173f, 
    -0.07654776f, 0.00537989f, 0.00991608f, 0.04568048f, 0.00345223f, 0.04221491f, 0.00728615f, -0.07825281f, 
    -0.07344407f, -0.01587207f, 0.03157943f, 0.01142017f, -0.03891997f, 0.00290271f, 0.04958960f, 0.03102246f, 
    -0.01170763f, -0.04307954f, 0.01915167f, -0.01568667f, -0.05816564f, 0.00128467f, 0.01773912f, -0.03687675f, 
    0.05016084f, 0.02023020f, 0.02009657f, -0.09264359f, 0.02510820f, -0.03961705f, -0.04865262f, 0.00389748f, 
    -0.05821355f, 0.06220416f, -0.02007495f, -0.04787289f, 0.03062754f, -0.02388147f, -0.03222164f, -0.08426334f, 
    0.00907579f, 0.00025773f, -0.02327960f, -0.02437391f, 0.03621215f, -0.08552841f, -0.04198934f, -0.02991389f, 
    -0.05735840f, -0.05594357f, -0.05472440f, -0.06331604f, -0.01922830f, 0.01503142f, 0.00693872f, 0.01292986f, 
    0.04390464f, -0.08060329f, -0.04315609f, 0.05010365f, -0.02075482f, 0.01953389f, 0.01641304f, -0.03800889f, 
    -0.07988349f, -0.04660115f, -0.02266045f, -0.06642814f, 0.04064929f, -0.00757424f, -0.04199770f, 0.00966739f, 
    -0.02020956f, 0.00889224f, 0.02658476f, -0.07956343f, 0.00245631f, -0.08734497f, 0.05191661f, 0.05350519f, 
    -0.07495387f, -0.05553235f, -0.00094683f, 0.02414886f, 0.01111452f, -0.00855283f, -0.03450499f, -0.06981522f, 
    0.00151912f, 0.04395899f, -0.01562496f, -0.00320429f, 0.02577257f, -0.06179672f, -0.08264718f, -0.07154717f, 
    -0.05814933f, -0.09490949f, -0.06159736f, -0.00141641f, 0.02656376f, 0.01483818f, -0.00323376f, -0.00055064f, 
    -0.09115321f, -0.01804553f, 0.01695472f, -0.00793423f, 0.05598261f, -0.08123375f, -0.01478046f, -0.00449714f, 
    0.03885351f, -0.01229986f, -0.07552828f, 0.03972739f, 0.02940060f, -0.00365160f, 0.01878704f, -0.04936726f, 
    0.03723053f, -0.08489943f, -0.08778202f, -0.02883592f, -0.02748001f, 0.03838095f, -0.06792316f, 0.02521443f, 
    -0.03183896f, 0.03383594f, 0.04232540f, -0.01263452f, 0.00554597f, 0.04191576f, -0.01978187f, -0.05867788f, 
    0.05826541f, 0.02511094f, -0.02078439f, -0.06235977f, 0.01675998f, 0.04794311f, -0.03060549f, 0.03128448f, 
    -0.00275747f, -0.04364975f, 0.01795394f, -0.05533853f, -0.03400493f, -0.05695590f, 0.00166619f, -0.06270611f, 
    0.04572569f, -0.00873105f, -0.03124451f, -0.06033072f, 0.05914784f, -0.06689951f, -0.04938226f, -0.00593787f, 
    -0.05925449f, -0.04934272f, 0.03384355f, 0.03206940f, -0.00931625f, -0.05315106f, -0.02255858f, -0.03436835f, 
    0.00305096f, 0.04926128f, -0.05405767f, 0.00536300f, -0.04831490f, 0.02465618f, -0.01936433f, 0.04264295f, 
    0.05844974f, -0.06963354f, -0.02290778f, -0.06724189f, -0.04837982f, 0.05177547f, -0.06800978f, -0.07407717f, 
    0.05844747f, 0.01189508f, -0.06409551f, -0.00707133f, 0.05080861f, 0.04131670f, 0.03456791f, 0.04916411f, 
    -0.00218610f, -0.03498613f, 0.01634241f, -0.08047798f, -0.02381307f, -0.02480622f, -0.06366226f, 0.03089567f, 
    0.03679051f, -0.04233245f, 0.00654617f, 0.02540009f, -0.02865269f, 0.01249875f, 0.03451604f, 0.01414509f, 
    0.03249950f, 0.03827262f, -0.06391682f, -0.00785950f, -0.07571628f, -0.04765982f, -0.04014375f, -0.07054810f, 
    0.01079638f, 0.02042451f, -0.02385766f, 0.04351970f, -0.00087430f, -0.02161004f, -0.05971125f, -0.01094882f, 
    0.00052229f, 0.00679806f, -0.07558265f, 0.02207281f, 0.00797236f, -0.05655641f, -0.07192319f, -0.03258042f, 
    0.00195666f, 0.04387153f, -0.01784961f, -0.01854141f, -0.06862425f, 0.05918226f, -0.04842798f, 0.00644276f, 
    0.01095213f, 0.01605441f, 0.01992956f, 0.01568433f, 0.02060596f, -0.05044224f, -0.01890839f, 0.04874592f, 
    -0.03760162f, -0.02007244f, 0.04031654f, -0.00353417f, 0.01194897f, 0.05222055f, -0.02713276f, -0.06007655f, 
    -0.04528150f, -0.04337296f, -0.04290858f, 0.01470717f, 0.05670310f, 0.03431730f, -0.01714735f, -0.00625118f, 
    -0.07626397f, 0.03653450f, -0.07736606f, -0.03434097f, 0.00179843f, 0.04043561f, -0.00483413f, -0.06524738f, 
    0.03308972f, -0.00082494f, 0.04135239f, 0.00819768f, -0.01321296f, 0.02718263f, -0.01090214f, -0.03581895f, 
    0.01469858f, -0.03517578f, -0.03805651f, -0.07818510f, -0.03012389f, 0.02845915f, 0.01478885f, 0.02223882f, 
    -0.06120750f, 0.04525733f, 0.03723538f, -0.06307472f, -0.06586269f, -0.07519586f, -0.01533985f, 0.04311476f, 
    -0.07569106f, -0.05684284f, 0.02911605f, -0.01027369f, 0.04536030f, -0.02407301f, -0.01350650f, 0.02664359f, 
    -0.05035205f, 0.02148483f, 0.03103198f, -0.04660593f, -0.01537815f, 0.00014389f, -0.02600870f, -0.05128383f, 
    -0.02843679f, -0.07037578f, 0.05523866f, 0.03205546f, -0.03787978f, 0.03161082f, -0.01016173f, -0.02991411f, 
    0.02994864f, 0.04502349f, -0.02242005f, 0.04033343f, 0.04964509f, -0.07789353f, 0.02086681f, 0.01090924f, 
    -0.02077294f, -0.05378705f, 0.05578058f, -0.00306597f, -0.01046305f, 0.01497111f, -0.04746483f, 0.03636551f, 
    0.04542500f, 0.01870893f, -0.01929316f, -0.06456038f, -0.02088801f, 0.00950142f, -0.02374690f, 0.00999572f, 
    0.02982689f, -0.02200500f, -0.02777357f, -0.02307473f, 0.05315795f, 0.01647614f, -0.07521999f, -0.01566374f, 
    0.04493229f, -0.03158728f, -0.01776120f, 0.05135355f, -0.04499229f, -0.06541181f, -0.05907078f, 0.02770693f, 
    0.03228137f, -0.00181877f, -0.03543709f, -0.02563912f, -0.02828190f, -0.05938113f, -0.02825819f, 0.04011394f, 
    -0.01236281f, 0.04407503f, -0.02848528f, 0.00216447f, -0.02531485f, -0.02114444f, -0.02295749f, -0.05959909f, 
    -0.00662232f, 0.04730524f, 0.01647687f, 0.00309541f, -0.07161804f, 0.01792850f, -0.02762217f, -0.00573677f, 
    0.04315694f, -0.03695336f, 0.03047902f, 0.04092274f, 0.03617980f, -0.05565211f, -0.02500326f, -0.00250727f, 
    0.05398568f, 0.03697435f, 0.02569017f, -0.05412420f, -0.07314970f, -0.05463060f, -0.07480815f, 0.00799305f, 
    0.05184716f, 0.02169718f, -0.04476619f, -0.01607316f, -0.04910864f, -0.06212269f, 0.03774197f, 0.06110550f, 
    -0.01450404f, -0.06597209f, -0.03573760f, -0.00456145f, 0.00752318f, 0.03592503f, -0.04528702f, -0.03378484f, 
    0.05065760f, 0.00248208f, 0.01115978f, -0.00902796f, -0.03289561f, -0.00292113f, 0.00289111f, -0.03060645f, 
    -0.00512310f, 0.01030440f, 0.03045671f, -0.05354957f, -0.00385363f, -0.04245673f, -0.01126851f, 0.02094042f, 
    0.04267491f, -0.06211965f, -0.03808205f, -0.06185586f, -0.05257990f, -0.06597693f, 0.06396641f, -0.02652393f, 
    -0.02807827f, -0.05039057f, 0.03500338f, 0.00350117f, 0.06365927f, -0.06148953f, -0.04324573f, 0.05618749f, 
    -0.07180053f, -0.02752444f, -0.04981530f, 0.02304276f, -0.00890738f, -0.07564369f, -0.05590583f, -0.05821874f, 
    0.03975039f, 0.00243210f, 0.06295016f, 0.02041792f, 0.05797180f, -0.05674905f, -0.02359733f, 0.04503025f, 
    0.02091398f, 0.04511996f, -0.00237849f, -0.07633746f, 0.06277083f, 0.01080760f, -0.00134708f, 0.01173098f, 
    -0.00982565f, -0.04536251f, -0.01914860f, -0.04366069f, -0.05683845f, 0.04348104f, -0.02063983f, -0.01767803f, 
    -0.03004175f, 0.04512477f, 0.00960305f, 0.01411447f, 0.04927422f, -0.05583820f, 0.02658906f, 0.00372017f, 
    0.01069867f, -0.05086228f, 0.00481004f, -0.01107664f, -0.05870131f, 0.01366302f, -0.03526279f, 0.01583700f, 
    0.01477480f, -0.04153152f, -0.02249886f, 0.03649095f, 0.01354141f, -0.07739530f, -0.07650095f, -0.00408916f, 
    0.01551301f, -0.01484083f, -0.00529219f, 0.02433292f, -0.05230027f, -0.02952106f, -0.06048845f, -0.04080043f, 
    0.06363584f, -0.07401542f, -0.07798325f, -0.04037275f, 0.03159150f, 0.00282310f, -0.01186635f, -0.05537088f, 
    0.03004593f, -0.00112525f, 0.04047640f, 0.04659744f, 0.01066593f, -0.01750559f, -0.06739802f, 0.05960004f, 
    0.10715581f, 0.22917844f, 0.22724879f, -0.02210761f, 0.13040410f, -0.04575954f, -0.15904017f, 0.05786522f, 
    -0.00752512f, 0.01467156f, -0.04903303f, -0.00731159f, 0.05650891f, 0.11033688f, 0.22562954f, -0.24584462f, 
    -0.09391819f, -0.07142687f, 0.02743972f, 0.09564517f, -0.00434661f, 0.03685940f, -0.04505797f, 0.02831961f, 
    0.10969891f, -0.01285715f, 0.02849058f, -0.03808183f, 0.02175898f, 0.07787617f, 0.03119166f, -0.02056670f, 
    0.11202092f, -0.00528493f, -0.04561486f, -0.04404665f, -0.13536428f, 0.08463829f, 0.03116497f, 0.06848279f, 
    -0.02056858f, 0.10925171f, -0.02231834f, 0.04669179f, 0.01962879f, 0.02871064f, 0.15078446f, -0.05009085f, 
    0.17791450f, -0.19082093f, 0.11194686f, 0.11561431f, -0.08421894f, -0.01840545f, 0.03731014f, 0.06396660f, 
    0.11417711f, -0.07927945f, 0.05688069f, 0.13546956f, 0.22807735f, -0.06809082f, 0.21302663f, -0.02652952f, 
    -0.01171444f, -0.04037149f, 0.04379604f, -0.01303409f, -0.05589022f, -0.12542775f, -0.09641872f, 0.09374180f, 
    0.00317854f, -0.18722488f, -0.02279194f, -0.36991513f, 0.14980815f, -0.01892141f, -0.01075680f, 0.10940507f, 
    -0.10334498f, 0.02731182f, 0.10306437f, 0.11228803f, 0.11637382f, 0.06215068f, 0.07117509f, 0.02972198f, 
    -0.02658248f, 0.01418946f, -0.08454490f, 0.07706839f, 0.01686646f, 0.01242402f, 0.02364732f, -0.07787276f, 
    -0.20434588f, 0.04998833f, -0.29165080f, 0.08802479f, 0.02821352f, 0.08804099f, 0.06512798f, 0.02264197f, 
    0.15531611f, 0.01537319f, -0.11353833f, 0.02657476f, 0.16622196f, -0.01368962f, 0.31175870f, -0.10405470f, 
    -0.04205955f, 0.10899035f, 0.09013749f, 0.04395134f, 0.03874762f, -0.00678716f, 0.01898824f, 0.14311381f, 
    0.00961370f, 0.04977953f, -0.18151455f, 0.23651551f, 0.05783200f, 0.07374994f, -0.03319602f, 0.04371474f, 
    0.01706934f, -0.06379105f, 0.07483175f, 0.02568841f, -0.51710773f, -0.06811608f, -0.15683584f, 0.06046846f, 
    0.05676265f, 0.10664403f, 0.11802030f, 0.02880649f, -0.06449557f, 0.05066009f, 0.04142404f, 0.03034798f, 
    -0.06437416f, -0.19304007f, -0.05947650f, -0.16479458f, 0.06894015f, -0.02928415f, -0.01693545f, -0.00306821f, 
    0.01397761f, 0.05869839f, -0.01317868f, 0.10562073f, -0.12885939f, -0.14517632f, 0.13256508f, 0.13730294f, 
    -0.10010489f, -0.00115416f, 0.04727118f, 0.00224959f, 0.08383740f, -0.10988600f, -0.04982468f, -0.09205771f, 
    -0.16285728f, 0.12080049f, 0.08626781f, 0.01396870f, 0.04133572f, 0.02535236f, 0.00502720f, 0.16807877f, 
    -0.12044380f, 0.12180140f, 0.06149299f, 0.13902658f, 0.12828928f, 0.00424387f, 0.03105832f, -0.06937166f, 
    0.04404737f, 0.07903365f, -0.12446967f, 0.00380621f, 0.09473525f, 0.09614848f, 0.03850749f, 0.16710636f, 
    0.34611654f, -0.03149556f, -0.03494954f, 0.10709945f, 0.14502420f, 0.13592136f, 0.05133967f, -0.05668572f, 
    0.02826534f, -0.09562475f, 0.05358000f, 0.01341484f, 0.07971164f, -0.11690319f, -0.03419183f, -0.03757318f, 
    0.00642638f, -0.00405507f, 0.05247783f, 0.08322414f, -0.03625027f, 0.08978029f, -0.01392085f, 0.10282264f, 
    0.24433979f, -0.04411191f, 0.05561695f, 0.08193554f, 0.13229160f, 0.03683387f, -0.05924333f, 0.08617263f, 
    -0.00906060f, -0.16261089f, 0.00400494f, 0.08927030f, 0.13646404f, 0.01131775f, 0.05935567f, -0.02096323f, 
    0.22925079f, 0.01304663f, -0.05250840f, -0.07613540f, -0.10295361f, 0.03526792f, -0.04729731f, 0.10699172f, 
    0.06011777f, -0.08186669f, 0.08585522f, -0.19919553f, 0.01967453f, -0.06465537f, 0.02708691f, -0.06073428f, 
    0.08887080f, 0.02665714f, -0.05953271f, 0.13585503f, 0.02631822f, 0.21134548f, 0.00058056f, 0.06231961f, 
    -0.08049501f, -0.00133980f, 0.17921670f, -0.07430527f, 0.04150622f, 0.03498012f, 0.18540634f, -0.06601099f, 
    0.07151579f, -0.12347855f, 0.02579861f, 0.04850961f, -0.02435195f, 0.00935583f, -0.21203293f, 0.12538026f, 
    0.15096118f, -0.09978665f, -0.07228591f, -0.12435599f, 0.17816706f, -0.03212583f, 0.17512953f, 0.01445325f, 
    0.09997823f, -0.06008712f, -0.05902968f, 0.05755861f, 0.11460830f, -0.04615570f, -0.02802996f, -0.06786380f, 
    -0.30717796f, -0.08462452f, -0.07054028f, 0.06389238f, 0.08800332f, 0.03494662f, 0.13829246f, 0.05028489f, 
    0.05530637f, 0.09817637f, -0.03505510f, 0.30085665f, 0.12861864f, 0.16424206f, 0.08121242f, -0.04776577f, 
    0.03848274f, -0.10733449f, -0.02770927f, -0.15465020f, -0.00638111f, 0.02404976f, 0.08526436f, -0.04483505f, 
    -0.00607548f, -0.04068321f, 0.18113543f, -0.13020390f, 0.12527323f, 0.04484733f, 0.04452005f, -0.05026152f, 
    0.17807984f, -0.06121699f, 0.00531241f, 0.03165129f, -0.39604157f, 0.08729666f, -0.24789822f, 0.07289313f, 
    -0.00685838f, 0.02082822f, -0.02943088f, 0.10822201f, -0.05492918f, -0.17334841f, 0.07727552f, -0.21249659f, 
    -0.34762338f, -0.05814900f, 0.03217945f, 0.11641694f, 0.03288542f, 0.06704926f, 0.00254596f, -0.13151515f, 
    0.05407645f, 0.03390444f, 0.18595172f, -0.03819615f, -0.00549419f, 0.03050554f, -0.00155057f, -0.17854302f, 
    -0.02770905f, -0.00385289f, 0.07478549f, 0.06338084f, 0.00857212f, -0.10528535f, 0.03361890f, 0.24448094f, 
    -0.09353855f, -0.08805300f, -0.15627010f, 0.00348892f, -0.04408829f, 0.02609674f, 0.04878310f, -0.02926648f, 
    -0.03606636f, -0.02022053f, 0.05666128f, 0.08225490f, 0.02567526f, 0.10212419f, 0.04152210f, -0.06699983f, 
    0.00856871f, 0.03821830f, -0.05139912f, -0.05846288f, 0.12698732f, -0.03868971f, -0.01486347f, -0.09248243f, 
    -0.31886029f, -0.18007796f, 0.05360340f, -0.05703462f, 0.06996495f, 0.11456100f, 0.14978176f, -0.07544497f, 
    0.07456058f, 0.13982016f, 0.00810219f, 0.07272436f, -0.00924462f, 0.04748828f, -0.02293500f, -0.18116567f, 
    -0.05557622f, -0.04195665f, -0.02325683f, -0.02497687f, -0.07580758f, -0.04320393f, -0.03921496f, 0.12836201f, 
    -0.14105278f, 0.16531302f, 0.15486124f, 0.02007623f, -0.02197728f, 0.09803484f, -0.03768404f, -0.05208365f, 
    -0.07834937f, -0.08920988f, 0.11529708f, 0.05922528f, -0.28579706f, 0.08361770f, 0.12495410f, -0.24579783f, 
    -0.00931207f, -0.05209687f, -0.07130275f, -0.11647124f, 0.05422654f, -0.04326801f, 0.10196705f, 0.12117486f, 
    0.24045710f, -0.28709567f, 0.06236424f, -0.14120017f, -0.02258798f, 0.03601411f, -0.09495442f, 0.01765698f, 
    0.00860932f, -0.05393906f, 0.03194193f, 0.02612290f, -0.13805430f, 0.19030347f, 0.08754915f, 0.03704308f, 
    0.04794561f, -0.08481297f, 0.08980222f, -0.03336016f, 0.06666229f, 0.15709181f, -0.01603156f, -0.11282240f, 
    0.10088892f, 0.01998845f, -0.08214284f, 0.07916116f, 0.10693336f, 0.02333626f, -0.03202225f, 0.00871303f, 
    0.06969991f, -0.02724872f, -0.02060043f, -0.12782285f, -0.07999199f, 0.32495001f, 0.16790596f, -0.03599099f, 
    0.14029734f, -0.10094405f, 0.01463921f, -0.05897285f, -0.03801066f, -0.00233682f, -0.10843402f, -0.11451948f, 
    -0.24143328f, -0.10410396f, 0.17156135f, 0.12437334f, 0.14111772f, 0.18533894f, 0.14308803f, -0.07445783f, 
    0.09304249f, 0.14142884f, 0.01768909f, 0.07467023f, -0.14867930f, 0.11472703f, 0.19518472f, 0.13448186f, 
    0.07883038f, -0.10716071f, -0.03762969f, 0.09726866f, -0.02702194f, -0.01638975f, -0.01319078f, -0.07004202f, 
    -0.23498870f, 0.08065325f, 0.15261646f, -0.24144401f, -0.08199012f, -0.05101741f, -0.03222382f, -0.08276526f, 
    -0.07822605f, -0.07477852f, 0.02089312f, -0.11603931f, 0.28857467f, -0.01113150f, 0.00700049f, -0.09619657f, 
    -0.02837825f, 0.12104511f, -0.02102548f, 0.00159623f, -0.07577612f, -0.08708231f, 0.13399653f, -0.14380796f, 
    -0.20610368f, 0.17075104f, 0.00080285f, 0.15902050f, 0.06950215f, 0.18415946f, 0.03639058f, -0.07550374f, 
    -0.01381996f, 0.05401561f, 0.03870659f, 0.03363316f, 0.39736602f, 0.04169173f, 0.04005288f, -0.23746419f, 
    -0.04659836f, 0.00930058f, 0.03687125f, -0.03315709f, -0.03764760f, -0.07433406f, 0.15156649f, 0.15927643f, 
    0.06040781f, -0.03308927f, -0.07201824f, 0.24609733f, 0.17364755f, 0.01286960f, -0.04034574f, 0.05270227f, 
    -0.09693027f, 0.05649588f, -0.03312010f, -0.01464617f, 0.10968104f, -0.07374123f, 0.09164379f, -0.23928663f, 
    -0.02558383f, 0.04162602f, -0.03179038f, 0.01095984f, 0.06187753f, -0.00700118f, -0.11761143f, 0.05783303f, 
    0.20383206f, -0.15135206f, 0.08708354f, 0.07263838f, 0.08599705f, 0.01874452f, 0.04456943f, -0.09016823f, 
    0.11001906f, 0.04231776f, 0.09149942f, 0.03491884f, 0.24139005f, 0.03913438f, -0.14835124f, -0.10437034f, 
    0.01740374f, 0.02658900f, -0.05734771f, 0.13206644f, 0.05290443f, 0.09569108f, 0.08460454f, 0.10673501f, 
    0.01305062f, -0.10160366f, 0.00942476f, -0.03034308f, 0.03613850f, 0.10345532f, -0.01988178f, 0.05820353f, 
    0.13502716f, -0.07082441f, -0.00362221f, 0.04410181f, -0.19951907f, 0.05187104f, -0.00611844f, -0.21465172f, 
    0.08358973f, -0.02057915f, 0.05132471f, 0.08383984f, 0.02220825f, 0.06312983f, -0.02609294f, 0.15739612f, 
    0.03573552f, -0.03673911f, -0.00868588f, -0.20457281f, -0.04704007f, -0.03930973f, 0.06556927f, 0.08125004f, 
    -0.00057493f, 0.02538615f, -0.04836614f, 0.02311170f, 0.02497682f, 0.11670526f, 0.09862000f, 0.10093637f, 
    0.11351954f, -0.07739908f, 0.07954118f, 0.14280941f, 0.07219317f, 0.02031273f, -0.01521440f, 0.09084957f, 
    0.01670316f, -0.15794727f, -0.10801681f, -0.19463015f, -0.07628305f, -0.08438583f, -0.11631976f, -0.02890887f, 
    0.06480187f, -0.02501681f, -0.00952120f, -0.03404016f, 0.05786005f, 0.06252199f, 0.01355181f, 0.12768753f, 
    0.05295301f, -0.06419973f, -0.03257653f, -0.10141767f, -0.02290481f, -0.00686491f, -0.01041781f, -0.05983185f, 
    -0.00746944f, -0.03635489f, -0.00102376f, 0.07300323f, 0.02392772f, 0.01139458f, 0.12345618f, -0.00684793f, 
    0.12747726f, 0.03631129f, 0.02242181f, 0.14850461f, 0.26631218f, -0.19882168f, 0.15259627f, 0.11792730f, 
    0.04429850f, 0.03284391f, 0.03441610f, -0.02094770f, 0.01624477f, 0.07295968f, 0.03302213f, 0.06550493f, 
    -0.37133685f, -0.05793871f, 0.12998027f, -0.27246973f, 0.16624701f, 0.00156106f, -0.02616131f, 0.07671873f, 
    0.06089811f, -0.10004958f, 0.04131896f, 0.08644956f, -0.27499858f, 0.04419968f, -0.21217863f, 0.01395155f, 
    0.07757954f, 0.01056193f, 0.04507418f, 0.03003594f, 0.02704409f, -0.13228822f, 0.11059557f, -0.04701417f, 
    -0.19322321f, -0.08915715f, -0.16289438f, 0.01976805f, -0.01871829f, 0.07694519f, 0.03825853f, -0.07592520f, 
    0.03748951f, -0.02349712f, -0.03426295f, -0.04793890f, 0.21379490f, 0.18890265f, 0.05418966f, -0.05948606f, 
    0.07325012f, -0.00970583f, 0.09680755f, 0.13401969f, -0.02119597f, -0.03336041f, 0.05770904f, 0.14227493f, 
    -0.14899470f, 0.01198039f, -0.01382063f, 0.24917240f, -0.05197505f, 0.08502051f, -0.01317819f, 0.20882562f, 
    -0.11050560f, -0.00327888f, -0.06122848f, 0.05328582f, 0.02143939f, -0.11546694f, 0.07873797f, -0.04663952f, 
    0.04958868f, 0.01927456f, 0.04037990f, 0.05663792f, 0.07323620f, 0.12156703f, 0.02778208f, 0.02594842f, 
    -0.10466535f, 0.03343990f, 0.00965951f, -0.15228015f, 0.17039032f, 0.05849607f, -0.04671101f, 0.07942278f, 
    -0.08091629f, -0.07210325f, -0.18742716f, 0.04359439f, 0.15900874f, 0.26978078f, 0.12080376f, 0.02973711f, 
    0.02604955f, 0.01468921f, -0.16092020f, 0.05180597f, -0.00367335f, 0.04800337f, 0.14495516f, 0.14263594f, 
    0.17337440f, -0.18572827f, -0.07429208f, -0.26904315f, 0.06362677f, 0.05358611f, 0.04914669f, -0.00758306f, 
    0.04982335f, -0.07822870f, -0.08009948f, -0.06162653f, 0.21291785f, -0.03730216f, -0.04242594f, -0.22034064f, 
    0.09365153f, -0.01942812f, -0.06840411f, -0.12943499f, -0.03018497f, 0.05247198f, 0.01537488f, 0.06043448f, 
    0.12161304f, -0.27776030f, -0.20932896f, 0.11191167f, -0.08112350f, 0.01821730f, 0.02606222f, 0.03585177f, 
    0.00513264f, 0.09814499f, -0.00332994f, 0.08878144f, 0.02166187f, 0.00845960f, 0.08628405f, 0.14129351f, 
    -0.00875218f, -0.04006150f, 0.06569891f, 0.00112702f, -0.07037889f, -0.18442950f, -0.03030604f, 0.17709234f, 
    0.31232950f, -0.03877272f, -0.03726532f, -0.05017198f, 0.11000101f, -0.00074900f, 0.01605497f, 0.02227732f, 
    0.10703088f, -0.00757189f, -0.03635898f, 0.10105959f, 0.00086381f, -0.08228866f, 0.04394547f, -0.03034912f, 
    0.09149975f, 0.00026911f, 0.13004871f, -0.20009764f, -0.01113925f, -0.04373551f, 0.03786024f, 0.01941814f, 
    -0.21910024f, 0.00147249f, -0.10005467f, -0.06661692f, -0.03529674f, -0.08083993f, 0.02319166f, -0.00803878f, 
    -0.03319158f, -0.08104302f, -0.12508282f, -0.01426280f, -0.46355024f, -0.01417388f, 0.27338883f, -0.32094929f, 
    0.08469816f, 0.13612962f, 0.00378561f, 0.04981386f, 0.08131228f, -0.06464729f, -0.12144876f, 0.02685764f, 
    -0.01427974f, 0.06785002f, -0.27572751f, 0.09193286f, 0.10731098f, -0.10458578f, 0.12834390f, -0.06283695f, 
    0.03098757f, 0.05878901f, 0.06982627f, -0.03910443f, -0.26432809f, 0.05477410f, -0.09512347f, 0.05044056f, 
    0.00454631f, -0.04554585f, 0.05978467f, 0.12834600f, -0.07827669f, 0.07594167f, -0.00708519f, -0.10963652f, 
    0.20389186f, 0.06524583f, -0.06812280f, -0.24082489f, -0.00540690f, -0.06636074f, 0.03970823f, 0.10887827f, 
    0.14608327f, 0.00503529f, -0.14722763f, -0.01786523f, 0.38104239f, 0.03981186f, -0.26291019f, 0.17426622f, 
    -0.02239160f, -0.03438792f, 0.00602202f, -0.09831849f, 0.11264296f, -0.04505934f, 0.00940536f, 0.00668776f, 
    -0.21135540f, 0.02019071f, 0.13712919f, 0.05274301f, 0.02199269f, 0.15064180f, -0.07646624f, 0.12991205f, 
    -0.04153687f, 0.07488786f, 0.01829937f, 0.01666492f, 0.14276695f, 0.17069308f, 0.03762236f, -0.17515388f, 
    0.08445361f, -0.16224520f, 0.18925306f, 0.05929333f, -0.00165579f, 0.03164005f, -0.01381999f, 0.07289507f, 
    -0.23879181f, 0.20180832f, 0.05901916f, 0.04462272f, 0.00648091f, 0.02750711f, 0.03923870f, 0.02198515f, 
    -0.04553516f, -0.04021485f, -0.00401561f, 0.00387921f, -0.18147773f, -0.22230008f, 0.11910788f, -0.00443726f, 
    0.06973536f, 0.10679635f, -0.03966586f, 0.07016435f, 0.00582838f, -0.07845885f, 0.01782553f, -0.03196957f, 
    0.06559972f, 0.24256605f, -0.15205479f, 0.02162128f, 0.05174525f, -0.02407676f, 0.04151233f, -0.01959773f, 
    0.00326246f, -0.00470293f, -0.11328872f, 0.05165873f, 0.00117397f, 0.09453132f, -0.18714879f, -0.08235112f, 
    -0.06408205f, 0.05175220f, 0.02457492f, -0.10238174f, -0.05949210f, -0.16590491f, 0.07969128f, 0.00377091f, 
    0.00583907f, 0.19609623f, 0.12384775f, 0.06387951f, 0.09080020f, 0.01531362f, 0.02378941f, 0.01823421f, 
    0.05585845f, -0.05802664f, 0.15286240f, 0.16743076f, 0.03933760f, 0.08577350f, -0.06670574f, -0.13380480f, 
    -0.08058790f, 0.12711611f, 0.09110334f, 0.03601839f, 0.02839131f, -0.18331318f, 0.10610138f, -0.00743748f, 
    -0.25680524f, -0.15102339f, 0.11830178f, 0.03332901f, -0.06966253f, 0.09003195f, -0.00644431f, 0.23427561f, 
    -0.00798445f, 0.05426409f, -0.01288795f, 0.09451624f, 0.17275657f, -0.05697772f, -0.00819761f, -0.05816042f, 
    0.05325498f, 0.14925860f, -0.00887959f, 0.05149246f, 0.07962769f, 0.07268959f, -0.03037059f, 0.10320134f, 
    -0.20392618f, 0.02032060f, -0.05046995f, 0.09878777f, 0.05554445f, -0.04390505f, -0.01730292f, 0.02980009f, 
    -0.04151047f, -0.00472919f, 0.00200493f, 0.12669463f, -0.11924191f, 0.11603145f, 0.10368043f, 0.03603594f, 
    0.01581219f, -0.11146373f, 0.08032154f, -0.05186361f, -0.05251597f, -0.01524650f, 0.05532154f, -0.04510890f, 
    0.29706761f, 0.15136391f, -0.04397281f, 0.07416891f, -0.20244062f, -0.00876315f, 0.08578652f, -0.05343394f, 
    -0.07166448f, -0.03871251f, -0.05460909f, 0.12265380f, -0.31157473f, -0.10915772f, 0.08632205f, 0.01108005f, 
    0.03392202f, 0.06972272f, -0.04226763f, 0.07073463f, 0.12954415f, 0.12226683f, 0.10874716f, -0.03282735f, 
    0.05264116f, -0.11330234f, 0.03443642f, -0.05774040f, 0.11648167f, -0.22359224f, -0.11925241f, 0.06497490f, 
    0.05003224f, 0.08166362f, 0.01247624f, -0.05163477f, -0.22063020f, -0.07899024f, 0.19412501f, -0.04934777f, 
    -0.03897858f, 0.03001164f, -0.06015272f, -0.03168697f, 0.02635992f, -0.06666596f, -0.09622601f, -0.04298752f, 
    0.18616131f, -0.04593879f, 0.13626052f, -0.20421988f, 0.07552533f, -0.00350177f, 0.03580113f, 0.04790592f, 
    -0.04863809f, 0.12302903f, 0.13902503f, 0.12607433f, -0.35747752f, 0.29046303f, -0.22289659f, 0.09686201f, 
    0.01211553f, -0.05371678f, -0.03187517f, -0.09772088f, 0.10338610f, 0.04338462f, 0.06686270f, 0.08121569f, 
    -0.06870878f, -0.00524667f, 0.00973668f, -0.02729837f, -0.00744412f, -0.01225079f, 0.01811850f, -0.03857853f, 
    -0.08045848f, 0.03400052f, -0.00254686f, -0.00025104f, -0.02597225f, 0.01708653f, 0.05262170f, -0.04156965f, 
    0.00196016f, 0.03110708f, -0.03559948f, -0.07072618f, -0.04929379f, -0.00943377f, -0.05726745f, -0.09639532f, 
    0.00381326f, -0.04962894f, 0.01887914f, -0.02806978f, -0.10000097f, -0.00082864f, -0.03406015f, -0.01929308f, 
    0.01456677f, -0.06302740f, -0.04509066f, -0.08044174f, -0.00390180f, -0.06819435f, -0.00061914f, 0.02589037f, 
    -0.04911602f, -0.08853965f, -0.00388677f, -0.04288187f, -0.03529051f, -0.04124987f, -0.00594858f, -0.06088825f, 
    -0.06530070f, -0.01583035f, -0.06282567f, -0.05134873f, 0.07096058f, -0.02582988f, 0.06574237f, 0.05344718f, 
    0.04300381f, -0.04649886f, -0.07874039f, 0.02055557f, -0.06063491f, 0.02205812f, -0.06598859f, 0.03782734f, 
    0.04082628f, -0.06604394f, 0.04199954f, -0.01015868f, 0.04408264f, 0.05545884f, -0.01866869f, -0.01250596f, 
    -0.06595586f, -0.03610255f, 0.03043680f, 0.01581258f, 0.01237614f, 0.02833318f, 0.03256621f, 0.00095914f, 
    -0.06422798f, -0.08546218f, 0.05605959f, -0.06635049f, 0.01842280f, 0.05944815f, 0.03545764f, 0.04597582f, 
    0.01102598f, -0.06605303f, -0.09301245f, -0.05058212f, -0.08677533f, 0.00180785f, 0.01872085f, -0.06821835f, 
    -0.06522209f, -0.04487707f, 0.04889165f, -0.06073773f, -0.02231147f, 0.03663902f, 0.05539280f, -0.08065552f, 
    -0.04459018f, 0.04822807f, -0.03429559f, 0.04405814f, -0.03173357f, -0.01425540f, 0.06338701f, -0.01643468f, 
    -0.04976415f, -0.00354665f, 0.02851804f, 0.03303975f, -0.06290324f, -0.00643014f, 0.04109511f, -0.06907398f, 
    -0.07783804f, -0.05749062f, -0.02355368f, -0.05054115f, -0.05912740f, 0.00267470f, -0.00404254f, -0.01474651f, 
    -0.06179233f, 0.02107873f, -0.05006571f, 0.00810664f, -0.01712722f, -0.01988136f, -0.02875965f, -0.04110709f, 
    -0.06947637f, 0.02453194f, -0.04549342f, -0.04832555f, 0.03662706f, 0.01903956f, 0.04502780f, -0.00042957f, 
    -0.01493538f, -0.00487008f, -0.06907941f, -0.08181714f, 0.01455797f, -0.00129463f, 0.04021205f, 0.00817807f, 
    0.02344111f, -0.04686704f, -0.05423602f, 0.04609183f, 0.01526316f, -0.05108727f, 0.05734015f, 0.06375011f, 
    -0.02606850f, -0.04069513f, 0.04778998f, 0.00173829f, 0.02182060f, -0.03637314f, -0.03252896f, -0.01848850f, 
    0.03208663f, 0.03148805f, -0.02975484f, 0.05484875f, -0.01787263f, -0.05305664f, 0.00531926f, -0.00412087f, 
    -0.02161907f, -0.06514878f, 0.00250560f, 0.04602709f, -0.03865682f, 0.03194444f, 0.01023544f, -0.09525430f, 
    -0.01337046f, -0.05545336f, -0.02274617f, -0.07039704f, 0.00642830f, -0.10046016f, 0.06695056f, -0.07993555f, 
    -0.07152086f, 0.03908542f, 0.16422449f, -0.03708030f, -0.07705952f, -0.04648930f, -0.13896050f, 0.20285261f, 
    0.06982863f, -0.03889168f, -0.03264493f, -0.00388432f, -0.04089132f, 0.08425067f, 0.03635831f, 0.11072180f, 
    -0.10520899f, 0.05124600f, 0.06570685f, 0.07636347f, -0.09752297f, 0.01968934f, -0.04772320f, 0.08157145f, 
    -0.00141045f, -0.21545182f, 0.00675137f, 0.07727579f, -0.08124635f, -0.05231646f, 0.03975566f, 0.06703041f, 
    0.17372271f, 0.01039026f, 0.00783285f, -0.00735114f, 0.19142428f, -0.06664807f, 0.03116539f, -0.06413020f, 
    -0.12944338f, 0.02824415f, -0.04461538f, 0.03640786f, -0.03889133f, 0.01931974f, 0.03017307f, 0.00450401f, 
    -0.15850781f, 0.24747963f, -0.02323008f, 0.16767611f, -0.09333497f, 0.07101326f, 0.15240291f, 0.02495156f, 
    -0.01082939f, 0.04766738f, 0.11215813f, 0.04903210f, 0.06900624f, -0.10954275f, 0.11621293f, 0.09737092f, 
    -0.05979700f, 0.09245937f, -0.03031346f, 0.05763136f, 0.06888843f, -0.08198333f, 0.01598333f, 0.15237154f, 
    0.07865068f, -0.31111002f, 0.04214568f, -0.32551262f, 0.04023382f, 0.01828612f, -0.02331263f, -0.08798990f, 
    -0.02115471f, 0.06603919f, 0.04530603f, 0.14396380f, 0.15894933f, -0.21238536f, -0.07223942f, 0.16034515f, 
    -0.03148595f, -0.14228344f, 0.13438766f, 0.04397351f, 0.10728040f, 0.06432980f, 0.03683934f, 0.05469623f, 
    -0.00247033f, 0.19035631f, -0.32031760f, -0.09033731f, 0.03466929f, 0.03866431f, 0.03768912f, 0.07179886f, 
    0.16493459f, -0.02996233f, -0.07713024f, -0.04878374f, 0.12162349f, -0.17106655f, -0.07714633f, 0.00708510f, 
    0.04710836f, 0.15661949f, 0.24871129f, 0.12041298f, -0.05672945f, 0.04851530f, -0.02907957f, 0.03956334f, 
    0.30774698f, 0.05786344f, -0.13374810f, 0.21173339f, -0.18562476f, 0.16552475f, 0.05733263f, 0.08974653f, 
    -0.04720274f, -0.03843243f, 0.06820331f, 0.13397983f, -0.46791968f, 0.04192209f, -0.06548668f, 0.08569943f, 
    0.08125071f, 0.05374338f, 0.00836301f, 0.02305311f, 0.00193545f, 0.04429884f, -0.04753456f, 0.01622696f, 
    -0.01517970f, -0.13911600f, -0.12641545f, -0.13738787f, 0.01742812f, -0.07663911f, -0.00496970f, 0.05454889f, 
    0.05025605f, 0.07957725f, 0.06088926f, 0.06078666f, -0.21848246f, 0.01901374f, 0.08520582f, 0.15478083f, 
    0.03218418f, 0.01486159f, 0.00716765f, 0.03165371f, 0.05609359f, -0.11451679f, -0.02894668f, 0.05899072f, 
    -0.18002929f, 0.13780497f, 0.25888935f, 0.08599208f, -0.05633806f, 0.13766570f, -0.02732083f, 0.06943646f, 
    -0.09169137f, 0.18397741f, 0.12308601f, 0.05560336f, 0.01027925f, -0.06938224f, 0.02266150f, -0.12036715f, 
    0.08968017f, 0.06557480f, -0.00295704f, -0.06000587f, 0.00469298f, 0.08187796f, 0.01924679f, 0.02110269f, 
    0.13642687f, -0.01097972f, 0.02791694f, -0.04452635f, 0.19794326f, 0.06411692f, 0.06439990f, -0.04894695f, 
    0.02571941f, -0.02105907f, -0.11917052f, 0.06712134f, 0.05625749f, -0.19098902f, -0.00294312f, -0.08617368f, 
    0.07099041f, 0.09146187f, 0.02648307f, -0.14753993f, 0.05792920f, 0.11279264f, 0.14495009f, 0.02103661f, 
    0.15905945f, 0.18335687f, 0.03381302f, -0.30672613f, 0.05481246f, -0.03152037f, 0.15715753f, -0.11876272f, 
    -0.07937454f, -0.15025483f, -0.17553890f, -0.06670600f, -0.06741410f, 0.06330616f, 0.05635255f, -0.01896421f, 
    0.10860623f, -0.04091805f, 0.04632579f, 0.03651888f, -0.01901751f, -0.01236564f, 0.03252153f, 0.09656280f, 
    0.16210321f, -0.31049865f, 0.03070752f, -0.17688800f, 0.02225845f, -0.15560937f, -0.02614581f, -0.07878788f, 
    -0.01324161f, 0.03081015f, 0.01032839f, 0.29325983f, 0.03567282f, 0.15668894f, -0.05856518f, -0.09633432f, 
    -0.07263166f, 0.06879262f, 0.07409976f, 0.00387990f, -0.15265477f, -0.00145068f, 0.04323206f, -0.02563591f, 
    0.29611573f, 0.30774617f, -0.01922150f, 0.18229903f, 0.09468618f, 0.05297149f, -0.02435022f, 0.17796150f, 
    0.08336060f, 0.06025080f, -0.05566068f, -0.00725330f, 0.21572578f, -0.13243358f, 0.04108150f, -0.16467732f, 
    0.15526363f, 0.13905536f, -0.00609612f, -0.11251988f, -0.02027230f, -0.02752730f, -0.15584464f, 0.08603610f, 
    -0.02943735f, -0.03984033f, 0.08430661f, 0.09330042f, 0.00090100f, -0.09950513f, 0.00528521f, 0.03088054f, 
    -0.16041701f, 0.05229212f, 0.02491338f, -0.05977173f, -0.18681277f, 0.16978177f, 0.29447851f, -0.21852267f, 
    0.08678706f, -0.05088079f, -0.03045291f, 0.01807855f, 0.04267766f, -0.09196949f, -0.02467009f, -0.08303455f, 
    -0.23607197f, 0.12133057f, -0.12742540f, -0.05090138f, 0.12112585f, -0.05898771f, -0.05989665f, -0.12425075f, 
    0.01965343f, -0.02094457f, -0.18210842f, 0.05192557f, -0.01056992f, -0.06020848f, -0.03423958f, 0.00305214f, 
    0.12352210f, 0.04693637f, 0.06129984f, -0.05211094f, -0.03935215f, -0.04225285f, -0.11074288f, -0.02706329f, 
    0.09936266f, 0.11484587f, 0.07329424f, 0.07661598f, 0.03975222f, 0.01023561f, 0.02804871f, 0.02950617f, 
    0.00600108f, -0.00052515f, 0.02403138f, -0.17587000f, 0.01712682f, -0.06580174f, 0.04352094f, -0.01733543f, 
    -0.05375890f, -0.02118007f, -0.01416924f, -0.03100021f, 0.06410331f, 0.04140715f, 0.16814972f, -0.11582100f, 
    0.05696559f, -0.11368173f, 0.06215367f, 0.13190268f, 0.03187346f, -0.06424046f, -0.02154922f, 0.04779381f, 
    0.08152644f, -0.08568469f, -0.15021186f, 0.02402706f, 0.02769537f, 0.30306718f, 0.04976143f, 0.06970337f, 
    0.01180249f, 0.06061916f, -0.05981439f, -0.01965174f, -0.04181647f, -0.02702097f, -0.04311778f, -0.04298381f, 
    0.03183173f, 0.03433320f, 0.03303996f, 0.01323595f, 0.04389559f, -0.03668850f, 0.02617375f, 0.03629871f, 
    -0.07096127f, 0.00993101f, -0.05247591f, -0.03626423f, -0.02869746f, -0.03259910f, 0.00345655f, 0.02917132f, 
    0.02757395f, 0.03965120f, -0.01797973f, 0.04642563f, -0.00568239f, 0.06027006f, -0.00996947f, -0.07090918f, 
    -0.01114414f, -0.01026139f, -0.00700127f, 0.06042247f, 0.03179502f, 0.05979002f, -0.03247576f, -0.00387012f, 
    -0.00480328f, -0.06379358f, 0.03668190f, -0.04687588f, -0.00271522f, 0.00836721f, 0.05788894f, -0.04463749f, 
    0.05333425f, 0.02726292f, 0.02950476f, -0.06842592f, 0.00811751f, -0.07680395f, 0.05874938f, -0.07827859f, 
    -0.03446997f, 0.02129585f, 0.06058987f, 0.05128617f, 0.01348317f, 0.00568235f, -0.04426239f, 0.03643860f, 
    -0.08190328f, -0.04237049f, -0.03592559f, -0.00480658f, -0.07371799f, 0.00335920f, 0.01708442f, 0.02646578f, 
    -0.03639387f, 0.00978452f, 0.06023968f, -0.05272352f, -0.04716847f, -0.03783737f, 0.01507722f, 0.00079589f, 
    -0.08128790f, -0.02372447f, -0.03317421f, -0.00700430f, 0.01604414f, -0.07992335f, -0.02497417f, 0.01796764f, 
    0.03059246f, 0.02582177f, 0.01581148f, -0.01573092f, 0.04605605f, -0.02029468f, -0.06485908f, 0.06003098f, 
    0.05841029f, -0.03153463f, -0.00919567f, -0.07280432f, -0.01479546f, -0.05435751f, 0.00506257f, 0.01423311f, 
    -0.01074162f, -0.06439907f, 0.00791287f, -0.00008178f, -0.06265835f, -0.03886956f, -0.06196217f, -0.00975504f, 
    0.00108274f, -0.01129639f, -0.01917219f, -0.00714370f, -0.07153942f, 0.00206773f, -0.00397704f, 0.03817885f, 
    -0.04817703f, -0.07086069f, -0.02162195f, -0.05899922f, 0.05200695f, -0.01066129f, -0.07279886f, -0.04888596f, 
    -0.00165170f, -0.03242500f, -0.01161716f, -0.02014120f, -0.05929334f, -0.00238473f, -0.01499410f, 0.00266770f, 
    0.04943706f, -0.01160895f, 0.03296598f, 0.00238587f, -0.00558948f, -0.06209682f, -0.00302122f, -0.05290287f, 
    -0.02574315f, 0.03900192f, 0.03005628f, -0.02727266f, -0.03304842f, -0.04322730f, 0.03329032f, -0.01160161f, 
    -0.05821002f, 0.03878070f, -0.00144014f, -0.01346716f, 0.02151778f, 0.03465367f, -0.02839775f, -0.04395687f, 
    0.03193707f, -0.04023419f, -0.06563343f, -0.02947563f, -0.04956599f, -0.02652462f, -0.07253619f, 0.04907080f, 
    -0.03922683f, -0.04514328f, 0.01536464f, -0.00684899f, -0.04041276f, 0.05492316f, -0.02107410f, -0.07376070f, 
    -0.05442740f, 0.03502070f, -0.01496093f, 0.02226300f, -0.04025098f, 0.04917419f, -0.00104659f, -0.03482256f, 
    -0.02222655f, 0.03507489f, 0.04441672f, -0.03070882f, 0.05941309f, -0.02578549f, -0.05472688f, -0.03395848f, 
    0.01318320f, -0.07732654f, -0.05114582f, 0.04893679f, -0.02467031f, 0.03971007f, -0.00332344f, -0.04017330f, 
    -0.17288275f, -0.05718528f, 0.04956596f, -0.08179118f, -0.02852590f, -0.01577909f, 0.10505139f, 0.14224450f, 
    0.09880181f, -0.03122433f, 0.02955710f, 0.09077321f, -0.22723554f, 0.14309971f, -0.07780179f, 0.14004387f, 
    -0.00758773f, -0.00970171f, 0.13844582f, 0.00413090f, -0.09167396f, -0.07797243f, -0.07028185f, 0.09245831f, 
    -0.13198137f, 0.12644593f, 0.09304400f, 0.37015638f, 0.06603678f, 0.07366510f, 0.02270959f, 0.03009306f, 
    -0.05210600f, -0.03608942f, 0.12513392f, 0.09576000f, 0.38557786f, -0.13873880f, 0.05110143f, 0.19855648f, 
    -0.03366017f, -0.11100732f, 0.04387227f, 0.03525038f, 0.03426789f, 0.00643371f, -0.06938332f, 0.08589816f, 
    -0.14021417f, 0.00408295f, -0.16999158f, 0.06705943f, 0.02269398f, 0.19273242f, -0.02541148f, 0.01213214f, 
    0.13006933f, 0.10626621f, 0.11587014f, -0.07637466f, -0.38636234f, 0.01137581f, 0.14963102f, -0.00044214f, 
    -0.07640423f, 0.04995065f, 0.12158486f, -0.12256467f, 0.06428550f, 0.23278472f, 0.12928630f, 0.03869159f, 
    -0.05608365f, 0.00465549f, 0.12065349f, 0.07306378f, 0.02621158f, 0.02232149f, -0.02823848f, -0.09153871f, 
    0.02457114f, -0.08610965f, 0.06589619f, -0.07009993f, -0.21211872f, -0.20780915f, 0.04504522f, 0.11073082f, 
    0.09105330f, -0.13739602f, 0.05759557f, 0.01160053f, -0.03468860f, -0.00095757f, -0.03014166f, 0.00938545f, 
    -0.02274721f, -0.02278221f, -0.02957438f, 0.11664583f, -0.08408685f, 0.01828690f, 0.03993811f, 0.10970151f, 
    0.07524861f, -0.03759336f, -0.05035461f, 0.18871868f, -0.18475768f, -0.06961946f, -0.21072575f, -0.15644202f, 
    0.00085332f, 0.09868318f, -0.00915393f, -0.01774959f, -0.08293681f, -0.04784356f, 0.07706729f, 0.07904095f, 
    0.31953046f, -0.05350984f, 0.14495958f, 0.19595723f, -0.13320993f, 0.00455532f, -0.06617356f, 0.04511324f, 
    0.10976575f, 0.07453243f, 0.07148164f, 0.02801617f, 0.12292023f, 0.13644344f, 0.14951012f, -0.08907461f, 
    -0.13910601f, -0.03064906f, 0.00208024f, 0.09009133f, 0.05450967f, -0.06332579f, -0.05078531f, -0.06020362f, 
    0.04083460f, 0.20018697f, 0.03600634f, 0.12531796f, -0.08368083f, -0.13347048f, -0.06040957f, 0.08482189f, 
    -0.04700371f, -0.05821315f, 0.13324665f, 0.06141251f, 0.16277492f, -0.00785826f, -0.07966092f, -0.03898594f, 
    0.01152631f, 0.04321856f, 0.08169705f, 0.06462160f, 0.00870387f, -0.02401475f, -0.00159982f, 0.17576005f, 
    0.01900776f, -0.01782420f, -0.07648202f, -0.33447683f, 0.08827461f, -0.01026959f, 0.03569730f, -0.19574769f, 
    0.04928190f, -0.00333787f, -0.01663774f, -0.02015501f, 0.17653447f, -0.03121753f, 0.10838194f, 0.01659367f, 
    -0.04451928f, 0.03767029f, -0.06120899f, -0.14747785f, -0.08627860f, -0.10856862f, -0.06771574f, -0.07421907f, 
    -0.19283210f, -0.00980104f, 0.11513942f, -0.21386907f, 0.05350647f, 0.06009250f, -0.05252938f, 0.14126557f, 
    0.15291977f, -0.02547371f, 0.03236625f, 0.20918380f, -0.11790533f, 0.04861654f, 0.24398060f, -0.01350616f, 
    -0.41520372f, -0.13950741f, -0.08931451f, -0.11950655f, -0.01005216f, 0.18481737f, 0.03470922f, -0.02007905f, 
    -0.24312150f, -0.11017848f, -0.13536598f, -0.19063599f, 0.07569288f, -0.12414706f, -0.11842393f, 0.06292289f, 
    0.09592644f, 0.09569632f, 0.03171350f, 0.20539102f, 0.16657005f, -0.79116344f, -0.51825845f, -0.30784592f, 
    -0.07985279f, 0.06492587f, -0.00133531f, 0.16602550f, -0.00372467f, 0.03290409f, 0.09655891f, 0.10162865f, 
    -0.19998896f, 0.21034127f, 0.06692335f, -0.25844207f, 0.07732919f, -0.12277433f, -0.17384478f, -0.03719174f, 
    0.19175518f, 0.02819533f, 0.01144480f, 0.04129326f, -0.09730529f, 0.06873374f, 0.25356826f, 0.07794786f, 
    -0.10283710f, 0.04538498f, 0.02087974f, -0.06430317f, 0.05550207f, 0.11638092f, 0.03127784f, 0.00506034f, 
    -0.01457833f, -0.15973383f, -0.00667357f, 0.20191734f, 0.30434373f, 0.11045233f, -0.02741960f, 0.00277325f, 
    -0.05209005f, -0.01342926f, 0.06072058f, -0.04119637f, 0.13090529f, -0.02588090f, 0.08847982f, -0.11567734f, 
    0.11331239f, -0.06523582f, -0.15151691f, -0.05300916f, 0.20221370f, -0.00919906f, -0.00687087f, 0.06957140f, 
    -0.18001477f, 0.00590609f, -0.10857285f, 0.06929671f, 0.16485858f, 0.13991621f, -0.01704995f, 0.16563572f, 
    0.09318999f, 0.07030202f, -0.07908847f, 0.11578721f, -0.20611319f, 0.11898532f, -0.09747617f, 0.18663117f, 
    -0.03387331f, 0.08514874f, -0.07772368f, -0.01044285f, 0.00558506f, 0.05298140f, -0.03730975f, -0.22512242f, 
    0.25193450f, -0.19073807f, -0.25805256f, -0.18252271f, -0.09212680f, -0.04786653f, -0.15396394f, 0.01395628f, 
    0.07077651f, 0.07220013f, 0.00842276f, 0.04743668f, -0.20631425f, -0.00645242f, -0.01816501f, -0.00151088f, 
    0.14084198f, 0.20365261f, -0.05768947f, -0.14057773f, 0.02754513f, 0.00396733f, -0.09446812f, -0.12451670f, 
    -0.12169217f, -0.20110856f, 0.22831170f, 0.21996813f, 0.31595463f, 0.05907021f, 0.02103465f, 0.13302840f, 
    0.03688778f, 0.10539700f, -0.08267075f, -0.01945732f, 0.06321309f, -0.12634942f, 0.09186532f, -0.07255492f, 
    -0.03249980f, -0.00225024f, 0.02366642f, -0.19532093f, 0.17718171f, -0.04758362f, 0.03035734f, 0.00546113f, 
    0.12246499f, 0.03550636f, 0.29918155f, 0.31468344f, 0.08737973f, 0.06815679f, -0.09481841f, -0.06852520f, 
    -0.02298574f, 0.04396242f, -0.06141581f, -0.09533271f, -0.31247288f, -0.48423567f, -0.20709136f, -0.13830805f, 
    0.06508259f, 0.02535980f, -0.04085035f, 0.04480575f, 0.02851661f, 0.18286848f, 0.00556082f, 0.05141060f, 
    0.16404076f, -0.02476285f, -0.02758770f, 0.07499557f, -0.07256313f, -0.08915222f, -0.04341259f, 0.02885546f, 
    -0.21734837f, -0.01638581f, 0.04038094f, 0.10541931f, 0.29517254f, 0.25081995f, 0.02934657f, -0.01018062f, 
    0.03589492f, 0.01462903f, -0.06102882f, 0.05805116f, -0.09320170f, -0.11968411f, -0.00618457f, 0.06013200f, 
    0.09435115f, -0.16350850f, 0.08052945f, 0.11360581f, -0.17525214f, -0.03781098f, -0.06590167f, -0.07297175f, 
    -0.00052234f, -0.02557736f, 0.13299970f, -0.05058025f, -0.05372350f, 0.09501870f, 0.10523104f, -0.03263223f, 
    -0.12251486f, -0.19788158f, -0.00111636f, -0.00524269f, 0.04055334f, 0.05063890f, 0.01821125f, 0.06989403f, 
    0.04611871f, 0.07447470f, -0.04714244f, 0.01713927f, 0.05070014f, 0.09341381f, 0.02968126f, 0.05266888f, 
    -0.12605049f, 0.11984632f, 0.04529919f, -0.06457365f, 0.16492361f, -0.03959904f, -0.01533910f, 0.21949372f, 
    0.23666474f, -0.08853088f, -0.07484375f, 0.08908980f, -0.04038376f, -0.04092633f, -0.06334332f, 0.09336906f, 
    0.31892800f, -0.19747786f, -0.21204694f, -0.22937070f, 0.15067512f, 0.05044048f, 0.08264017f, -0.17527144f, 
    0.11562979f, 0.01818000f, 0.00168303f, -0.02733709f, 0.11747465f, 0.17072858f, -0.14969975f, 0.04203328f, 
    -0.12957077f, -0.16019066f, 0.05821863f, 0.00031998f, -0.03843593f, -0.11015625f, 0.03993212f, -0.09762059f, 
    0.11003233f, 0.00096914f, -0.02279293f, -0.20111457f, -0.04527679f, 0.14235224f, 0.17608684f, -0.00238554f, 
    0.17549057f, -0.04454155f, 0.00826268f, -0.14623457f, 0.17897002f, -0.17167397f, -0.28227791f, 0.04296383f, 
    -0.06770632f, 0.12646344f, -0.03690880f, 0.14450525f, -0.02643979f, -0.04099315f, -0.02147754f, 0.15191451f, 
    -0.04717134f, 0.02060241f, 0.03002973f, 0.17829813f, -0.04643249f, -0.05999141f, 0.02621996f, 0.02529450f, 
    -0.01113434f, -0.00317257f, -0.00147355f, -0.01122783f, 0.07907268f, 0.02369933f, -0.13598646f, -0.02288735f, 
    0.06777586f, -0.04376355f, 0.11356296f, 0.08636653f, 0.16972946f, 0.05544744f, -0.06167147f, 0.18100810f, 
    -0.04961976f, -0.02518866f, -0.02489544f, -0.41824642f, -0.14456250f, 0.08941649f, 0.03964135f, 0.05347623f, 
    0.19875683f, -0.02028739f, 0.00368133f, 0.00952854f, 0.11054918f, -0.12437947f, -0.24032480f, 0.03685346f, 
    0.07796007f, 0.04113384f, -0.00259415f, 0.08616661f, -0.01482787f, 0.06894208f, 0.04922043f, -0.00233711f, 
    -0.36690572f, 0.06081781f, 0.05811083f, 0.11264875f, 0.06153911f, 0.11768815f, 0.05817332f, 0.07852174f, 
    -0.00626279f, 0.04756594f, -0.01208913f, -0.04520724f, 0.22127220f, -0.32706779f, 0.12347572f, -0.35780612f, 
    -0.00617295f, -0.14174546f, 0.13836691f, -0.06045272f, -0.06042690f, 0.02899822f, -0.01586257f, 0.07009132f, 
    0.07442573f, 0.10417639f, -0.18010990f, 0.13944185f, 0.10632281f, 0.09668627f, 0.01644386f, -0.01176187f, 
    0.06597719f, 0.07704040f, -0.01150738f, -0.03256174f, 0.14197904f, 0.06240154f, -0.09452841f, -0.01242474f, 
    0.13852729f, 0.02281236f, -0.09510574f, 0.01610076f, 0.10691396f, 0.11974159f, 0.03420984f, -0.02983420f, 
    0.05592452f, -0.18878707f, -0.14019324f, -0.01241000f, 0.09628175f, 0.01588121f, -0.14410247f, 0.01855524f, 
    -0.01099170f, 0.13399446f, 0.04974850f, 0.08809035f, -0.00556638f, -0.14610845f, -0.05269872f, 0.14248893f, 
    -0.03546647f, 0.07571006f, 0.14277564f, -0.01634210f, 0.04414311f, -0.05471359f, -0.03442378f, 0.06013379f, 
    -0.15973201f, 0.22599052f, 0.04779254f, 0.13444734f, -0.01255638f, -0.08599386f, 0.11476047f, 0.02737316f, 
    -0.15809892f, -0.05481094f, -0.13643174f, -0.05030372f, 0.01618768f, -0.11079060f, 0.04624146f, 0.00026255f, 
    0.08054890f, 0.16983776f, -0.06996611f, -0.00499615f, 0.12438770f, 0.00500134f, -0.08495514f, 0.03052361f, 
    -0.20254783f, 0.04129418f, 0.08331820f, 0.13460103f, -0.13369645f, -0.04039782f, 0.07927806f, -0.04562669f, 
    -0.07321236f, 0.00638729f, -0.02655989f, 0.10030711f, -0.05765391f, 0.04289017f, -0.15088141f, -0.04821581f, 
    -0.12774937f, 0.08695783f, -0.04273982f, 0.10438009f, 0.03760398f, 0.21104880f, 0.13924152f, 0.01361866f, 
    -0.07014672f, 0.15026009f, 0.08603901f, -0.06786130f, 0.02722029f, -0.11915387f, -0.10149869f, 0.01710976f, 
    -0.04144365f, -0.12746559f, -0.06278342f, -0.08706602f, 0.04804531f, 0.08923794f, -0.16896965f, 0.18480632f, 
    0.07924587f, 0.06759959f, 0.00233500f, -0.10582705f, 0.08126483f, -0.04873054f, -0.07431858f, 0.02840993f, 
    0.08818400f, 0.01607629f, 0.09918169f, -0.08406238f, -0.04882438f, -0.01506564f, 0.06462675f, 0.05331523f, 
    0.06559953f, -0.01119199f, 0.02851394f, 0.11716455f, -0.20372498f, -0.00221648f, 0.08673768f, 0.01684388f, 
    0.15618823f, -0.10632535f, 0.13465029f, -0.03324635f, 0.12954193f, 0.18367274f, -0.04562188f, 0.11667915f, 
    0.10624199f, -0.03382785f, 0.07543115f, -0.11544994f, -0.03926879f, -0.07171603f, -0.09571054f, 0.03662731f, 
    -0.04878328f, -0.00821750f, 0.06138980f, -0.06039482f, -0.02534566f, 0.14404835f, -0.00432028f, -0.00091747f, 
    0.04577910f, 0.00297807f, -0.02946253f, -0.01839579f, 0.06549239f, 0.14605208f, -0.14048479f, 0.03904166f, 
    0.15033895f, -0.14359677f, -0.00899463f, -0.21759373f, -0.00142118f, -0.00057108f, 0.04564565f, 0.01082059f, 
    0.03494978f, 0.08842984f, 0.15328412f, 0.01016601f, -0.25528863f, 0.05218836f, -0.05534056f, 0.20467229f, 
    -0.08408181f, -0.09396472f, 0.09380421f, 0.05741116f, -0.09033661f, -0.05877256f, 0.04025307f, 0.17716239f, 
    0.05776478f, -0.00411371f, 0.00057874f, 0.05516923f, 0.03794587f, 0.05859857f, -0.00859778f, -0.07862007f, 
    0.02115024f, -0.01374285f, 0.03617840f, -0.05557241f, 0.00385164f, -0.04811241f, -0.06883316f, -0.05134826f, 
    -0.05654906f, 0.05067179f, 0.05727952f, 0.06244485f, 0.05239173f, 0.06168832f, 0.01253206f, -0.06737733f, 
    0.03636691f, -0.07456434f, -0.01136610f, -0.00703213f, 0.02831251f, 0.05017876f, -0.00618827f, -0.05606930f, 
    -0.04476631f, 0.06067489f, 0.04322891f, -0.03273599f, 0.00307359f, -0.01665222f, -0.02986725f, 0.04482419f, 
    -0.01376012f, -0.06734701f, -0.02881141f, 0.02677185f, 0.01299912f, 0.00497340f, -0.07303800f, -0.05684008f, 
    -0.06969994f, -0.00650372f, -0.05284297f, -0.02380686f, 0.04114652f, -0.02721454f, -0.06583582f, -0.00013736f, 
    -0.00727001f, -0.05266105f, 0.03238904f, -0.07947085f, -0.06424701f, -0.00526054f, 0.00820241f, 0.00228940f, 
    0.03088554f, -0.01916739f, -0.00784031f, -0.04316542f, 0.05163046f, -0.02539164f, 0.00064114f, 0.05757479f, 
    -0.05225642f, 0.00273815f, 0.01213331f, -0.06139486f, 0.00198725f, 0.05752825f, 0.06811982f, 0.00232374f, 
    -0.07328720f, -0.07398520f, 0.02546499f, -0.03217253f, -0.07005664f, 0.03624657f, -0.03672922f, 0.04603027f, 
    0.04549472f, -0.07159527f, -0.06387487f, -0.06385253f, 0.00957000f, 0.01554760f, 0.02573523f, 0.04013067f, 
    -0.04105134f, -0.03040529f, 0.03687341f, -0.07481448f, 0.04689036f, 0.06171096f, 0.00462094f, 0.00765849f, 
    0.03179016f, 0.04128154f, 0.05378444f, 0.01785337f, 0.03877313f, 0.00962369f, -0.01888597f, 0.04584642f, 
    0.04465717f, -0.00801402f, 0.02289439f, 0.01513190f, -0.03344434f, -0.04812847f, -0.04228683f, -0.06112136f, 
    0.00696026f, 0.04925124f, -0.04867595f, -0.04379095f, 0.04511071f, -0.03472764f, 0.01406997f, -0.07667243f, 
    0.01126382f, 0.05666288f, 0.06222462f, -0.03712401f, -0.01752951f, 0.06349516f, -0.04519485f, -0.07856935f, 
    -0.02424579f, 0.04792352f, -0.07204318f, 0.03555628f, -0.02587538f, 0.03609318f, -0.00636038f, -0.04219517f, 
    0.04009520f, -0.00769552f, -0.04918636f, -0.00832831f, 0.04351973f, 0.04838960f, -0.06141581f, 0.05202441f, 
    0.01629453f, 0.05779979f, -0.01879402f, -0.06375580f, -0.04960161f, 0.00553416f, 0.00659554f, -0.04138639f, 
    -0.04259129f, 0.01477421f, -0.02665514f, -0.07881623f, 0.01275907f, -0.00221284f, 0.05702484f, -0.06692849f, 
    -0.07308371f, -0.00497278f, 0.05745812f, -0.01621119f, -0.03522016f, -0.01732730f, -0.05093411f, 0.01754206f, 
    -0.02881080f, -0.05461755f, -0.03626919f, -0.02603921f, -0.05924746f, -0.00837903f, -0.00879344f, 0.02137965f, 
    -0.02952623f, -0.01509608f, -0.05097235f, -0.07294116f, -0.02560299f, -0.00902806f, 0.01463990f, -0.06822342f, 
    0.04715946f, -0.02863368f, 0.06157103f, -0.06657021f, -0.02380577f, 0.03108127f, -0.02733994f, 0.01143565f, 
    -0.04559284f, -0.04401884f, 0.04823360f, 0.04503267f, -0.03718666f, -0.06806414f, -0.00177074f, -0.07124631f, 
    -0.04636115f, 0.03684621f, -0.04166466f, -0.04489717f, 0.01865634f, -0.00522772f, 0.02105961f, -0.03064826f, 
    -0.00769652f, -0.06719424f, -0.02122326f, 0.04164925f, -0.07464963f, -0.06601849f, 0.03286412f, -0.01655676f, 
    -0.00972917f, 0.05169078f, -0.05429476f, -0.05456523f, -0.02807977f, 0.01547880f, 0.03638658f, 0.04484186f, 
    -0.02773027f, -0.05538767f, -0.02265577f, -0.07058395f, 0.01146332f, -0.01495322f, 0.01031502f, -0.03870783f, 
    0.05587192f, -0.07463868f, -0.06368185f, -0.01749090f, -0.02765542f, -0.06547634f, 0.06078102f, -0.00653020f, 
    -0.02615702f, -0.01438592f, -0.06560301f, 0.05475650f, 0.01990866f, -0.05464561f, -0.07274430f, 0.04795673f, 
    0.05053313f, -0.04233437f, 0.01486759f, -0.03696720f, -0.02423380f, -0.05432993f, -0.02246540f, 0.01998996f, 
    0.04506617f, 0.03704373f, 0.03077542f, -0.05971570f, -0.02619679f, 0.03904899f, 0.05188448f, -0.04696624f, 
    0.03675849f, 0.03674905f, -0.05812016f, -0.03283770f, -0.05368391f, -0.04469331f, -0.02282879f, -0.04307022f, 
    0.00887656f, -0.01382198f, 0.01969733f, 0.01367234f, 0.06144956f, -0.02773742f, 0.04709607f, 0.00963841f, 
    -0.04889124f, 0.05563720f, -0.03007625f, -0.04188014f, -0.01812796f, 0.05675749f, -0.03298964f, -0.04982641f, 
    -0.04200302f, 0.03639167f, -0.05009449f, 0.03511744f, 0.04160189f, 0.03178032f, -0.03227484f, -0.02250399f, 
    -0.00950378f, 0.02733985f, -0.06995743f, -0.03974241f, -0.05629470f, -0.04235206f, 0.00581246f, 0.03242549f, 
    0.03233763f, -0.02685407f, -0.02082953f, 0.00456731f, -0.02930420f, 0.04171114f, 0.03632774f, -0.05243507f, 
    -0.04424302f, -0.04087595f, 0.02336727f, -0.01718093f, -0.00369824f, -0.06879009f, -0.05754702f, -0.01047425f, 
    -0.00311563f, -0.05677226f, 0.06364909f, -0.04112905f, -0.06167375f, -0.01709262f, -0.02991469f, 0.02492301f, 
    -0.01292909f, -0.07722627f, 0.00570815f, -0.01820532f, 0.02709076f, 0.05592219f, -0.01270590f, -0.04844590f, 
    -0.07630952f, 0.03940359f, 0.03707821f, -0.05536946f, 0.00017238f, 0.03783958f, 0.01587711f, -0.03022653f, 
    0.04961078f, 0.02665143f, -0.06073790f, 0.05452802f, -0.04811743f, -0.03080246f, -0.05492629f, 0.04774205f, 
    -0.00749974f, -0.02431257f, 0.06489195f, -0.01501604f, 0.01187928f, -0.00301511f, 0.04605855f, -0.07320609f, 
    0.03397560f, -0.00499674f, 0.02085535f, -0.01534262f, 0.01829745f, -0.02719998f, -0.03721642f, -0.01924149f, 
    -0.03218210f, -0.06109568f, -0.06470841f, -0.02810653f, -0.05128112f, -0.05198639f, 0.04157565f, 0.05074411f, 
    -0.05579186f, -0.00012915f, -0.00324272f, -0.01110303f, 0.01719879f, -0.07321096f, 0.01758886f, -0.04821596f, 
    -0.07105998f, 0.05688120f, -0.06644783f, -0.06093277f, -0.03370257f, -0.06640861f, 0.00599684f, -0.01392194f, 
    0.00965357f, -0.02783276f, -0.02933598f, -0.07980987f, 0.01094779f, -0.02762508f, 0.01336129f, -0.01585812f, 
    -0.01683251f, 0.02977488f, -0.02009869f, 0.02184187f, -0.06324270f, -0.00485061f, -0.07735044f, -0.07385142f, 
    0.04448598f, 0.00352660f, -0.01021571f, 0.05144306f, 0.03390663f, -0.05123574f, -0.01674174f, 0.01610354f, 
    0.01975563f, 0.04954989f, -0.03804151f, -0.00160671f, -0.02134269f, -0.03897719f, 0.04689571f, -0.07001679f, 
    -0.02713932f, -0.02997512f, 0.04389446f, 0.02338553f, 0.03709940f, -0.05776857f, 0.05528770f, 0.04712706f, 
    0.01713472f, -0.06668119f, 0.06168397f, 0.03003474f, 0.00517479f, -0.05335156f, 0.05092473f, 0.01924732f, 
    0.03330616f, -0.03210204f, -0.00689682f, -0.06690449f, 0.03415560f, -0.01509131f, -0.04728458f, -0.01232942f, 
    0.01643998f, 0.03182156f, -0.05922738f, -0.01014588f, -0.03972659f, 0.00262590f, 0.01247514f, 0.01039178f, 
    0.01712960f, -0.01362609f, -0.05470298f, 0.01643189f, -0.05177804f, -0.07735910f, -0.04126400f, 0.05117593f, 
    -0.03886568f, 0.00966457f, -0.03061783f, -0.02244320f, 0.05316078f, -0.07335127f, -0.01411208f, -0.02353056f, 
    -0.05760513f, 0.03515673f, -0.03614960f, -0.07930599f, -0.00310038f, -0.07044145f, 0.06934453f, 0.00724626f, 
    0.02243899f, 0.06044895f, 0.00981389f, -0.07831779f, -0.06004709f, 0.04928336f, 0.05472346f, -0.00639183f, 
    0.00360611f, 0.04822243f, 0.00168621f, -0.01513891f, 0.04402584f, -0.00849725f, -0.04183205f, 0.04557681f, 
    0.01497451f, -0.02461549f, -0.04289157f, 0.01190796f, 0.02816342f, -0.06654248f, -0.05362041f, -0.06023410f, 
    0.05447999f, 0.04832959f, -0.02509816f, 0.02880625f, -0.04442934f, 0.04738935f, -0.01260251f, -0.02587644f, 
    -0.02199698f, 0.04474933f, 0.06078120f, -0.05109832f, -0.03338547f, -0.07328342f, 0.01595985f, 0.00520725f, 
    -0.04725621f, -0.02665843f, -0.06790287f, -0.02908567f, -0.00328037f, -0.02794427f, -0.01951719f, -0.02665846f, 
    -0.01288210f, -0.06030353f, -0.02426775f, 0.00778113f, 0.05251165f, 0.01679002f, 0.04876908f, -0.00017565f, 
    -0.00422127f, 0.02948709f, 0.04614712f, 0.05029655f, -0.06518455f, -0.05782899f, -0.03010890f, -0.04193432f, 
    0.04743266f, 0.00856334f, 0.02965659f, -0.00222804f, 0.00754651f, -0.07046860f, -0.08190724f, -0.01161497f, 
    -0.01545323f, -0.06419385f, 0.00043230f, -0.04004835f, -0.07743911f, -0.07544499f, 0.04490951f, 0.05579551f, 
    -0.04871847f, 0.06052328f, -0.01358514f, 0.03518634f, -0.05595696f, -0.03469952f, -0.04142797f, 0.01040108f, 
    -0.07164393f, -0.07043447f, -0.03424056f, 0.00832130f, -0.00373972f, -0.06967311f, 0.05909684f, 0.04448503f, 
    -0.06649458f, -0.05510325f, 0.01131144f, 0.05106087f, 0.04488920f, -0.00981006f, -0.03838236f, 0.00822720f, 
    -0.04513104f, -0.01511809f, 0.02984110f, -0.01566953f, 0.04921709f, -0.01864522f, -0.04935587f, 0.00320675f, 
    0.00081151f, -0.04609350f, 0.05788952f, -0.05776088f, -0.00949091f, 0.03933069f, 0.02927949f, -0.01279424f, 
    -0.05583593f, 0.02625670f, 0.04284971f, -0.00991968f, 0.00047540f, -0.01506982f, -0.00418334f, 0.06571341f, 
    -0.04062600f, -0.05759559f, -0.03400756f, -0.01649794f, -0.02260205f, -0.01952737f, 0.04445324f, 0.04059976f, 
    -0.01196813f, -0.03041873f, -0.03752724f, -0.05079087f, 0.01676648f, 0.00283940f, 0.05866959f, -0.06348595f, 
    -0.02157734f, -0.07409014f, -0.00660497f, 0.02868965f, 0.01456665f, -0.04916755f, -0.02459098f, -0.00423462f, 
    0.02261179f, 0.01860572f, -0.00215857f, -0.05774491f, 0.02969798f, 0.06096189f, 0.05928575f, -0.01616457f, 
    0.03164490f, -0.07063702f, -0.07332132f, -0.01953071f, -0.05529824f, 0.01767280f, 0.00337889f, 0.01992851f, 
    -0.02429752f, -0.00799181f, -0.05892576f, -0.00748219f, -0.00471080f, -0.01293184f, 0.00775672f, 0.05829765f, 
    -0.02385159f, 0.01434949f, -0.01424128f, 0.02038643f, -0.00614434f, 0.03188286f, 0.02584694f, -0.05554240f, 
    -0.01585502f, 0.01532398f, 0.04981006f, 0.04182704f, -0.00917821f, 0.00018535f, -0.05050858f, -0.05495241f, 
    -0.02221455f, 0.04528267f, -0.07605215f, 0.03574063f, 0.01717457f, 0.00769146f, 0.05642836f, -0.01309175f, 
    -0.00033089f, -0.03221637f, 0.04379320f, -0.01892446f, -0.03239744f, 0.03716618f, -0.01001914f, -0.06778249f, 
    -0.06803264f, 0.00142808f, 0.03457996f, 0.04714409f, 0.03145786f, -0.04973446f, -0.06402005f, 0.03187719f, 
    -0.01869439f, 0.04343468f, 0.02411923f, -0.05596768f, 0.00948884f, -0.02769151f, 0.02646801f, -0.02703558f, 
    -0.04918687f, 0.03110459f, 0.04050029f, 0.03894132f, -0.02685095f, -0.01961886f, -0.03356861f, 0.03461816f, 
    0.00461850f, -0.07664755f, -0.00046687f, -0.06101829f, -0.01758787f, -0.01344286f, 0.04113287f, -0.06616998f, 
    0.00354436f, -0.05217900f, -0.01015747f, -0.02582787f, -0.04768239f, -0.06665662f, -0.05505941f, 0.03025182f, 
    -0.06723285f, -0.07016116f, -0.06507134f, -0.05773777f, 0.05800754f, 0.03064731f, -0.05467581f, -0.04261842f, 
    -0.03184493f, -0.03910099f, 0.06352904f, 0.01174710f, 0.04066281f, 0.03065006f, 0.02353417f, -0.07348278f, 
    -0.00733346f, -0.01278137f, -0.03778730f, -0.01617674f, -0.01210883f, -0.00843724f, -0.01492577f, -0.01095137f, 
    0.03880323f, 0.02113449f, -0.05042634f, -0.04948914f, -0.00979255f, -0.06316645f, -0.00543100f, -0.03264163f, 
    -0.42882484f, -0.24157141f, -0.37017167f, 0.00982094f, -0.02064247f, 0.03715239f, 0.06611301f, -0.12127475f, 
    -0.08498117f, 0.13443676f, 0.11404470f, -0.02388427f, -0.09960412f, 0.09254608f, -0.17545070f, -0.21909681f, 
    0.20496467f, 0.08481102f, -0.05365489f, 0.10140417f, 0.01170333f, 0.03592048f, 0.05488294f, 0.02520736f, 
    -0.28026134f, 0.04248228f, -0.09863973f, 0.09380256f, 0.09195529f, -0.03874873f, 0.00640927f, -0.06365052f, 
    0.03256799f, 0.02370553f, 0.11066513f, 0.06799259f, -0.37818846f, 0.02707446f, -0.22179607f, -0.08378537f, 
    -0.07934041f, -0.15392737f, -0.03090272f, -0.07143099f, -0.00795955f, -0.01401570f, -0.07520093f, 0.20863785f, 
    -0.06141467f, -0.11160777f, 0.02495762f, 0.12348654f, 0.10463359f, -0.13179977f, 0.07349035f, 0.08219598f, 
    -0.09371109f, 0.06164622f, 0.05416002f, 0.07815731f, -0.00587338f, -0.18676421f, 0.12869634f, -0.07602431f, 
    0.05687415f, 0.10587791f, -0.05469747f, 0.04608656f, 0.14846396f, 0.09630740f, -0.02860823f, -0.03433746f, 
    0.02238346f, 0.18375359f, 0.01039607f, 0.06400573f, -0.18899481f, 0.09090336f, -0.07815534f, 0.04147311f, 
    0.11659376f, 0.08973303f, 0.09122916f, -0.15609664f, -0.58954525f, -0.11817034f, 0.00991490f, 0.05789206f, 
    0.18127926f, -0.04819147f, 0.04485998f, -0.03806086f, -0.12679301f, -0.11950760f, 0.03588326f, 0.06099759f, 
    0.09896787f, -0.10777961f, 0.27998745f, 0.02772013f, 0.01901556f, 0.00958992f, 0.12218231f, -0.10104959f, 
    0.12479097f, 0.09126983f, 0.02327956f, 0.10202179f, 0.07043988f, 0.24163729f, -0.11083060f, 0.14156887f, 
    0.15639725f, -0.07523257f, -0.11752041f, 0.03965751f, 0.04871454f, -0.04337522f, 0.02021842f, -0.06181862f, 
    -0.02891042f, -0.13210844f, 0.01504571f, -0.14386991f, -0.00004886f, -0.07814404f, 0.13697083f, -0.09892844f, 
    0.15610199f, 0.06236947f, 0.08396995f, 0.06801333f, 0.44748017f, 0.01364811f, -0.06805382f, -0.15728110f, 
    -0.11490902f, 0.02697039f, -0.01032439f, 0.03650123f, 0.20758139f, -0.06316277f, -0.02743044f, -0.00937589f, 
    0.14419994f, 0.15247063f, 0.04121007f, -0.11014976f, -0.11081211f, -0.03305129f, 0.04434115f, -0.02663928f, 
    -0.05568073f, -0.04769259f, 0.04658347f, 0.04076778f, 0.15257862f, 0.15827924f, 0.11518636f, 0.12309927f, 
    0.08420353f, 0.00023578f, 0.10912137f, 0.11889409f, 0.02258343f, 0.24453822f, 0.07758196f, 0.17513421f, 
    0.22174107f, 0.10471468f, -0.04106584f, 0.01154333f, 0.07019395f, 0.05770368f, 0.12032095f, 0.01846393f, 
    -0.06051325f, 0.02878532f, 0.07316980f, -0.01237046f, 0.12485278f, 0.10247725f, 0.00134776f, -0.02126383f, 
    -0.21868432f, 0.00300720f, -0.01121017f, 0.01687775f, -0.03950319f, -0.03759935f, 0.04697550f, -0.05033085f, 
    0.11628786f, -0.03418098f, 0.08650294f, 0.07277719f, -0.04679686f, 0.07036833f, 0.03938795f, -0.09940962f, 
    0.09739503f, -0.10183787f, -0.01318375f, 0.12920420f, -0.09598745f, -0.00388715f, 0.22450799f, 0.41376925f, 
    -0.06013427f, -0.11154095f, -0.05886510f, -0.04419889f, -0.02787852f, 0.03355769f, 0.02015237f, 0.22954492f, 
    0.28691417f, -0.04599091f, 0.12805891f, 0.09577553f, 0.11748824f, -0.02068953f, -0.02698786f, 0.01190215f, 
    0.12090146f, -0.11017793f, -0.01359059f, 0.02162567f, 0.42346439f, -0.05756095f, 0.11800405f, 0.18054447f, 
    0.13173059f, -0.00845060f, -0.02662003f, -0.03775505f, -0.08024774f, 0.15554513f, -0.04168780f, 0.12719402f, 
    0.04915325f, -0.00140260f, -0.04165723f, 0.10257467f, -0.08260906f, -0.01421705f, -0.10037787f, -0.13042897f, 
    0.10119516f, 0.19180873f, 0.04898908f, 0.10616497f, -0.02763857f, 0.08455176f, 0.13474964f, 0.17884806f, 
    -0.09294560f, -0.05483605f, 0.05047740f, -0.16775823f, -0.00069687f, 0.05842800f, 0.15693364f, 0.05325431f, 
    0.13882650f, -0.15576711f, 0.04126400f, -0.06870496f, 0.05359108f, 0.07684745f, -0.07550258f, -0.01007831f, 
    0.10170215f, -0.03918022f, -0.00842628f, -0.01560728f, 0.17968069f, -0.20317769f, 0.17848173f, 0.02520739f, 
    0.18840989f, -0.01944079f, 0.01859063f, -0.09418803f, 0.01201724f, -0.03611274f, -0.03910742f, -0.02209205f, 
    -0.36177033f, 0.09243534f, -0.07666232f, -0.00150365f, 0.16076702f, 0.21011522f, 0.20062262f, 0.01401926f, 
    0.10600105f, 0.09391496f, -0.13998033f, 0.24491856f, -0.21164243f, 0.11727453f, -0.13778797f, -0.25912988f, 
    -0.08637127f, -0.02523874f, 0.04595371f, -0.11755689f, -0.15487099f, -0.06379677f, 0.21054003f, 0.02988210f, 
    0.22134797f, 0.14327374f, 0.00683899f, 0.20143890f, -0.06773490f, 0.00332119f, 0.02722004f, -0.02885583f, 
    0.08645935f, 0.03104955f, 0.05324086f, 0.01665588f, -0.59393096f, 0.23267418f, -0.12354766f, -0.08043581f, 
    0.07139248f, -0.03466994f, -0.10355523f, 0.11456654f, -0.03081965f, -0.16712554f, -0.10101379f, -0.21238194f, 
    -0.40628707f, -0.12287644f, -0.01204688f, 0.04378885f, 0.04665026f, 0.04545297f, 0.04018658f, 0.02117692f, 
    -0.02356263f, 0.00443163f, 0.12938797f, 0.01491887f, -0.05292606f, -0.09623506f, 0.00389781f, -0.02252869f, 
    0.04353129f, -0.00214937f, 0.14458536f, 0.02785836f, 0.12960798f, -0.09691927f, 0.06099435f, 0.29836434f, 
    -0.31124452f, -0.24595664f, -0.10420462f, -0.20374653f, 0.08014596f, 0.02232247f, -0.13900743f, 0.05112768f, 
    0.05052185f, 0.01326767f, 0.15055168f, -0.04384987f, 0.27608958f, 0.05955437f, 0.11965358f, -0.20720425f, 
    -0.04455814f, -0.02594375f, 0.00611444f, -0.07951305f, 0.00322774f, -0.02567179f, -0.05833097f, -0.14949946f, 
    0.47252610f, 0.11423301f, -0.06029230f, 0.20209363f, 0.02839849f, -0.02539152f, -0.05682056f, 0.02196445f, 
    0.06513305f, -0.02678472f, -0.04268883f, 0.03707268f, 0.13813943f, 0.11888688f, -0.13049880f, 0.20261015f, 
    0.02622935f, 0.04861448f, 0.04165959f, 0.04634970f, -0.05005305f, -0.00182425f, 0.04214271f, 0.10310970f, 
    0.04831669f, -0.13051426f, 0.03265176f, 0.06894687f, 0.03829341f, 0.06865999f, -0.04229427f, 0.10520906f, 
    0.02875572f, -0.07316806f, -0.07631182f, 0.07482294f, -0.07523770f, -0.04084666f, -0.03054025f, -0.03643283f, 
    0.00622724f, 0.07354775f, 0.06769080f, 0.12744695f, 0.02695238f, 0.06467342f, -0.13585699f, 0.01814227f, 
    -0.15555312f, 0.35595712f, -0.05367176f, -0.03553424f, 0.01202921f, 0.04740895f, 0.09534607f, 0.04089150f, 
    -0.12043869f, -0.10790056f, 0.04809923f, -0.19020788f, 0.08321216f, 0.09911550f, -0.06184069f, 0.21291164f, 
    0.05028616f, -0.02277318f, -0.13419373f, 0.04381277f, 0.09166081f, -0.06649833f, -0.04191631f, 0.04338415f, 
    0.00222530f, -0.11761734f, -0.02996086f, -0.12895711f, -0.07983838f, 0.00766338f, 0.04960972f, -0.17154339f, 
    -0.00503087f, 0.10156248f, -0.01797161f, -0.09611774f, 0.27821317f, 0.35950726f, -0.19612665f, -0.00465955f, 
    -0.14169814f, 0.00930012f, 0.02840678f, 0.11128394f, 0.00178353f, 0.09400375f, 0.06609595f, 0.04125175f, 
    0.08348294f, 0.14367184f, 0.03097569f, -0.15492158f, -0.09799562f, -0.05418897f, -0.01306783f, 0.04361757f, 
    -0.04441092f, -0.06865522f, -0.02251788f, -0.12696677f, 0.28660297f, -0.10992627f, -0.21065810f, 0.28845182f, 
    0.02034448f, 0.03095055f, 0.10827772f, 0.20645332f, 0.08179589f, 0.07049044f, -0.02946718f, -0.02346250f, 
    0.00159754f, -0.12229785f, 0.06884324f, -0.06596298f, 0.04394972f, -0.00092559f, 0.02565796f, 0.02136836f, 
    -0.11692878f, 0.02262841f, -0.01436696f, -0.04082979f, -0.19134994f, 0.12301212f, -0.09429889f, 0.01458109f, 
    0.08344315f, 0.02292354f, 0.06714210f, -0.11891242f, 0.12060545f, -0.08759803f, 0.08390267f, 0.09018930f, 
    -0.06842761f, -0.15106967f, -0.09759317f, -0.00039614f, -0.08908321f, 0.08483925f, 0.11898004f, 0.00961369f, 
    0.01563021f, 0.07242960f, -0.04777094f, 0.08667197f, -0.22457446f, -0.03884702f, -0.07867808f, 0.02741949f, 
    0.10784751f, -0.02551988f, -0.16645800f, 0.06847592f, 0.00682703f, 0.05078871f, -0.13726942f, 0.01359089f, 
    -0.12581895f, 0.03308246f, 0.06489526f, 0.19183575f, -0.14304228f, 0.04368239f, 0.10292515f, -0.03416130f, 
    0.11007375f, 0.03686542f, 0.06721904f, 0.03822375f, -0.11701124f, -0.39179108f, 0.03385866f, -0.04227865f, 
    0.06071417f, 0.01715544f, 0.05971960f, -0.09373627f, 0.06943183f, 0.03003046f, 0.02580006f, 0.04008422f, 
    -0.08836029f, 0.02931961f, 0.06908217f, 0.01998171f, 0.09250948f, 0.05928620f, 0.07927828f, -0.03016544f, 
    -0.04979691f, 0.12233696f, 0.15943153f, -0.03593206f, 0.29488182f, 0.15348138f, 0.01991055f, -0.24467604f, 
    0.01327713f, -0.02632231f, 0.03886762f, 0.09474958f, 0.00399473f, 0.10464441f, -0.01310924f, -0.05188384f, 
    0.00612350f, 0.08665594f, -0.06792299f, -0.18590282f, -0.05834266f, 0.07201486f, 0.10353220f, 0.04045003f, 
    -0.02102156f, 0.05075495f, 0.12668471f, 0.06610428f, -0.35630491f, 0.10773806f, -0.08681886f, -0.23773266f, 
    0.10495400f, 0.14347549f, 0.12085459f, 0.16472447f, 0.09195794f, 0.01231079f, 0.14607094f, 0.07889771f, 
    0.14542903f, -0.27995774f, 0.20979339f, -0.13360459f, -0.00448582f, -0.04487462f, -0.01266732f, 0.05684026f, 
    -0.06383298f, -0.04888429f, -0.12548067f, 0.07934001f, -0.02926823f, 0.08535977f, 0.10388598f, -0.11384368f, 
    0.06917840f, -0.01684986f, -0.03551397f, 0.16455314f, -0.02424825f, -0.00311450f, -0.08310705f, 0.06678635f, 
    0.01759999f, 0.08553417f, -0.12896572f, 0.11534763f, -0.13760069f, -0.11863371f, 0.13355041f, 0.07203449f, 
    -0.21925624f, -0.06753939f, -0.01335746f, 0.00201176f, -0.30986997f, 0.16187519f, 0.04108259f, -0.07065672f, 
    0.07921670f, 0.09154335f, -0.00424604f, 0.05057668f, 0.02413190f, 0.03830790f, -0.04383268f, 0.01043795f, 
    -0.03309868f, -0.08333659f, 0.05308693f, 0.09386866f, -0.13581221f, -0.02373307f, 0.05318927f, -0.00802303f, 
    0.04085615f, 0.07430083f, 0.06456803f, -0.01744621f, -0.11682613f, -0.07731913f, 0.19964176f, 0.20881513f, 
    0.01048410f, -0.05418097f, 0.03375816f, 0.07852110f, 0.07150333f, -0.04861707f, -0.13184285f, 0.00916480f, 
    -0.43207830f, 0.07833339f, 0.05781156f, -0.19068711f, 0.07803281f, -0.05065981f, -0.00303010f, 0.07538887f, 
    -0.06371836f, 0.15585440f, 0.03959051f, 0.01641493f, 0.22159013f, -0.12422586f, 0.09045145f, -0.04822014f, 
    0.01438940f, 0.01314007f, 0.03182134f, 0.09176092f, 0.10825711f, 0.05819346f, 0.01946205f, 0.10368534f, 
    0.11903962f, 0.00774332f, -0.08355669f, -0.07800317f, -0.09960254f, 0.07545546f, -0.13292313f, 0.06860986f, 
    0.00591673f, -0.07167087f, -0.16880088f, -0.03402872f, 0.34819978f, 0.22284447f, 0.07537185f, -0.02173443f, 
    0.05102962f, 0.04727875f, 0.06981229f, -0.03469473f, 0.04232578f, 0.02333177f, -0.01890731f, -0.10461944f, 
    0.08791006f, -0.09801089f, -0.04040632f, 0.17077368f, -0.06108669f, -0.08882508f, -0.01502862f, 0.15556149f, 
    -0.15919939f, 0.00497569f, -0.01808808f, -0.07049529f, -0.23715793f, 0.17440076f, -0.05943633f, 0.06317296f, 
    -0.09080683f, 0.00046145f, 0.06925205f, 0.32289028f, 0.00320907f, 0.03753753f, 0.06592965f, 0.08473421f, 
    -0.41520807f, 0.05933201f, 0.19673371f, 0.12485753f, 0.02258894f, -0.04687127f, -0.05263793f, 0.11777448f, 
    0.09557442f, -0.00975904f, 0.08158781f, 0.04745897f, -0.16533165f, 0.00852877f, 0.18331142f, -0.03155237f, 
    -0.11049131f, -0.04434973f, -0.05820644f, 0.11562136f, -0.07065820f, -0.04683817f, -0.13314529f, 0.10913406f, 
    -0.02724466f, 0.07949220f, 0.08167823f, 0.09382620f, -0.02430992f, 0.03461187f, -0.10751516f, 0.05147671f, 
    0.12553449f, 0.00166639f, -0.06829847f, 0.05412173f, -0.11274371f, 0.13439557f, 0.12258843f, -0.24932815f, 
    -0.03875402f, -0.02105331f, 0.00443509f, 0.00272447f, -0.01319410f, -0.02818201f, -0.00103900f, 0.02256338f, 
    0.03511983f, 0.16136132f, 0.29572326f, 0.10593561f, -0.12924179f, 0.11440849f, 0.02064893f, -0.05102373f, 
    0.04402468f, -0.00658372f, 0.12190951f, 0.07646033f, 0.00125527f, -0.11648928f, 0.12255768f, -0.02762799f, 
    -0.12454300f, -0.03615201f, 0.07552884f, 0.02388780f, 0.08869617f, -0.11723834f, -0.01967176f, -0.03039937f, 
    -0.01644076f, -0.35110444f, -0.07610215f, -0.02089899f, -0.00790207f, -0.01267720f, 0.06617323f, 0.16470195f, 
    0.02394317f, 0.08561017f, 0.07053608f, -0.04642077f, 0.08647699f, 0.07352524f, 0.28236300f, 0.10641450f, 
    -0.06171922f, -0.06967308f, 0.05350142f, 0.01806482f, 0.05036254f, 0.02080013f, 0.06327207f, 0.06163137f, 
    -0.33741039f, 0.13241844f, -0.07649667f, 0.03982393f, 0.06403953f, -0.02874719f, 0.02357199f, 0.01056848f, 
    -0.01383858f, 0.05057795f, 0.05683475f, 0.11364254f, 0.01468260f, -0.09255295f, 0.10201573f, 0.24117023f, 
    -0.03059170f, 0.06340496f, 0.22214878f, 0.13261180f, 0.01931794f, -0.00329887f, -0.07221456f, -0.00448728f, 
    0.13742043f, 0.20950073f, 0.07891641f, -0.10401433f, -0.15921882f, 0.02860389f, -0.08277377f, -0.03867537f, 
    0.03560743f, -0.01778157f, -0.00073267f, -0.02451347f, -0.53049278f, 0.04318631f, -0.10019521f, -0.15168378f, 
    -0.02226423f, -0.07190087f, 0.05275300f, 0.16374461f, -0.00904147f, 0.17299138f, 0.02016372f, -0.10473619f, 
    -0.26480711f, -0.10961910f, -0.23247069f, -0.03385547f, 0.06656653f, 0.04743203f, 0.06832098f, 0.04691157f, 
    0.18780787f, 0.09868426f, 0.05884937f, 0.10736766f, -0.03034369f, 0.08436836f, 0.10581326f, -0.07454143f, 
    -0.03358284f, 0.02898216f, -0.00794400f, -0.05513215f, 0.09583367f, -0.06787982f, -0.04736754f, 0.04713639f, 
    -0.14700624f, 0.03587878f, 0.14651327f, 0.10699094f, 0.11453509f, 0.01137172f, -0.02475952f, 0.14872622f, 
    -0.07299361f, 0.18858075f, 0.04175563f, 0.08427434f, -0.24557871f, 0.05376929f, -0.09952982f, -0.03810758f, 
    -0.06724964f, 0.10570458f, 0.00556400f, -0.10120842f, 0.03913547f, 0.06778917f, -0.00664553f, 0.03006224f, 
    -0.03291909f, 0.03050539f, -0.01969511f, -0.02307936f, -0.06051765f, -0.06369434f, -0.00680660f, 0.03383345f, 
    0.00026829f, 0.03594582f, -0.01502912f, -0.03271290f, 0.05013216f, -0.00959126f, -0.05607172f, -0.01306709f, 
    0.05245939f, 0.04352028f, -0.06149012f, 0.05886679f, -0.03701628f, 0.01333649f, 0.04170642f, 0.01470271f, 
    -0.04329127f, -0.05562844f, -0.05272720f, 0.07090896f, -0.02027000f, 0.00546271f, 0.05179286f, -0.05695517f, 
    0.04893702f, 0.01089228f, -0.04822452f, -0.04715152f, 0.06359841f, 0.06915966f, 0.00229718f, -0.06923264f, 
    0.04198024f, -0.00601260f, -0.01565336f, -0.03238201f, -0.05278853f, 0.02436769f, -0.04607454f, 0.02360664f, 
    -0.06030595f, 0.00695737f, -0.00702609f, -0.04199950f, -0.02188327f, 0.04861123f, -0.04769812f, 0.05177023f, 
    -0.03816517f, -0.00244422f, 0.06486328f, -0.05671192f, -0.06912208f, -0.05865421f, -0.05986047f, -0.01202390f, 
    -0.02791559f, -0.03004778f, -0.06566999f, 0.01245725f, -0.03714480f, -0.01539581f, -0.03951924f, 0.07026634f, 
    0.04830438f, -0.05078270f, -0.04090244f, 0.00317600f, 0.03334747f, 0.05059847f, -0.02548747f, 0.03659727f, 
    -0.05232665f, 0.03998601f, -0.00183068f, 0.00655532f, -0.03945156f, 0.03975079f, 0.00174388f, 0.02232015f, 
    -0.00006496f, 0.01629050f, 0.04751356f, 0.03031569f, 0.04449379f, -0.05925278f, -0.01985717f, -0.05903980f, 
    0.02716218f, 0.06378724f, 0.04180848f, -0.05517879f, 0.01636176f, 0.05457987f, 0.01952576f, -0.02731498f, 
    -0.01909340f, -0.02778921f, -0.03738192f, -0.01970501f, 0.00158976f, -0.06531328f, -0.04718972f, 0.00155894f, 
    0.02129144f, -0.04011724f, -0.04782329f, 0.07128071f, 0.00159760f, 0.05994472f, -0.04808829f, -0.00094489f, 
    -0.04264518f, -0.05455684f, 0.04726093f, 0.05971706f, -0.06653992f, -0.01575144f, -0.05705835f, -0.06625238f, 
    -0.06516144f, 0.02345453f, -0.04181815f, 0.01234762f, -0.03040927f, 0.01683928f, 0.05353098f, -0.00691066f, 
    0.06243152f, -0.06869280f, -0.04051188f, 0.01323597f, 0.02580583f, -0.06578547f, -0.03481325f, -0.05156409f, 
    -0.02111488f, 0.03597381f, -0.03072923f, -0.03671736f, -0.04753191f, 0.01186657f, -0.04225909f, -0.06894153f, 
    0.05341084f, -0.02319824f, -0.06181533f, 0.03383653f, -0.01827108f, -0.05040266f, 0.04443508f, -0.00004991f, 
    -0.05503547f, -0.06777107f, 0.00844447f, 0.00147965f, 0.04009858f, 0.06923115f, -0.00522368f, 0.06600921f, 
    0.05486457f, -0.07017501f, 0.04725396f, -0.05915673f, -0.07039794f, -0.01543403f, 0.06952713f, 0.00919775f, 
    -0.06030654f, -0.05997722f, 0.03988187f, -0.04296711f, -0.02612053f, -0.03871924f, -0.03833590f, -0.06030418f, 
    -0.00797283f, 0.06339725f, 0.05396613f, -0.04129030f, 0.01015721f, 0.02524350f, -0.02311973f, 0.00995635f, 
    -0.06310525f, 0.05677100f, -0.06124089f, -0.05427546f, 0.02418830f, -0.02235188f, -0.03184190f, 0.00723318f, 
    0.00383666f, 0.01895509f, -0.04552292f, -0.06529983f, 0.05658474f, 0.05713381f, -0.02319953f, -0.03998934f, 
    0.05963531f, -0.02943472f, -0.00852327f, -0.06230309f, -0.07887710f, 0.00168707f, -0.04577285f, 0.05804947f, 
    0.00541587f, -0.01015660f, 0.04559555f, -0.00775732f, 0.00831850f, 0.02873453f, -0.00376620f, 0.02911100f, 
    -0.06186154f, 0.03718442f, 0.00790402f, -0.05814377f, 0.05434532f, -0.06850136f, -0.03289764f, -0.00245650f, 
    -0.06425641f, -0.07032016f, -0.07207672f, -0.01055500f, -0.06060340f, -0.00556783f, 0.01517527f, 0.04903222f, 
    -0.02505483f, -0.01937300f, -0.00303249f, -0.00798749f, -0.06714112f, -0.02111918f, 0.01297486f, -0.02591120f, 
    -0.01290026f, -0.01421885f, 0.05679492f, -0.06018571f, 0.02155595f, -0.02382814f, -0.07044976f, -0.00539580f, 
    -0.04134712f, 0.03818386f, -0.03802869f, -0.04670082f, -0.07123967f, -0.03424746f, 0.01716635f, -0.02239899f, 
    0.03652351f, -0.03349379f, 0.05362914f, -0.06669417f, -0.03753298f, -0.06275559f, 0.01339717f, -0.07356134f, 
    -0.06694345f, -0.00115536f, -0.01090437f, -0.01414827f, -0.00807479f, 0.06060151f, 0.01325344f, 0.05531964f, 
    -0.07223266f, -0.04069937f, 0.03140022f, 0.04596015f, -0.02211979f, -0.04422198f, 0.00693128f, -0.04616160f, 
    0.04557337f, 0.04363407f, -0.00365337f, 0.05858690f, -0.06095847f, 0.04771812f, 0.05840034f, 0.06126142f, 
    -0.00887477f, 0.02692516f, -0.01470228f, 0.02267580f, 0.05535446f, -0.03316150f, 0.00834025f, -0.06159349f, 
    -0.04793189f, 0.00806702f, -0.04135872f, 0.06030948f, -0.04477571f, -0.04891127f, -0.07470676f, -0.04015083f, 
    0.00422830f, -0.03181649f, -0.02849021f, -0.07599146f, 0.03000361f, 0.01923940f, 0.04497060f, -0.05751617f, 
    0.06322227f, 0.03722713f, -0.07468367f, -0.02080258f, -0.04614723f, -0.02867958f, -0.01894484f, 0.01592064f, 
    0.05953765f, 0.06283472f, -0.01494279f, -0.05858377f, -0.07634412f, -0.05467684f, -0.05791779f, -0.04270820f, 
    -0.02868895f, 0.00511326f, 0.00084199f, -0.07316065f, 0.02740568f, -0.06637974f, -0.00482181f, 0.02540491f, 
    0.04136908f, -0.00670449f, 0.04067676f, 0.05314979f, 0.01007619f, -0.06894042f, -0.06839605f, -0.05156120f, 
    0.04711237f, -0.07359698f, 0.00762431f, 0.01234360f, 0.01057681f, 0.03727848f, 0.06109932f, -0.06489614f, 
    -0.06800138f, 0.02753237f, -0.02910673f, -0.04834960f, -0.06499253f, 0.02352292f, 0.05449782f, -0.04939053f, 
    0.05208929f, -0.00511422f, -0.04092329f, -0.01290732f, 0.03801497f, -0.03019503f, 0.05449747f, 0.01194017f, 
    0.05421868f, -0.07041270f, -0.06505073f, 0.00273110f, -0.04843876f, -0.03422560f, 0.04297550f, 0.05269358f, 
    -0.00118923f, 0.06478018f, 0.03433613f, -0.07747974f, 0.04780490f, -0.00454895f, -0.02200653f, -0.01888363f, 
    0.03206754f, 0.02691511f, 0.05341341f, -0.02299092f, -0.05158879f, -0.00605741f, -0.05450835f, -0.06641841f, 
    -0.00622411f, -0.04703586f, 0.01224054f, 0.02056837f, -0.04630794f, 0.05046546f, -0.07659402f, -0.01937396f, 
    0.01605961f, 0.02886913f, 0.05270630f, 0.05641237f, -0.03824388f, 0.04612584f, -0.01421889f, -0.07286420f, 
    -0.00064332f, 0.04020018f, 0.02168530f, -0.02717709f, -0.00468864f, 0.04683335f, -0.02490935f, 0.06464998f, 
    -0.07582436f, -0.03616207f, -0.04231606f, -0.05873056f, 0.01879826f, -0.01275818f, 0.05813712f, 0.02226591f, 
    0.01580801f, 0.00932540f, -0.05396802f, -0.04288366f, 0.03268529f, 0.05123153f, 0.04056783f, -0.04916026f, 
    -0.01532520f, -0.06011054f, -0.01792094f, -0.00537577f, -0.05389114f, 0.05658624f, 0.02275504f, -0.02386603f, 
    0.05860666f, -0.07389800f, -0.02799269f, -0.05866284f, -0.00654662f, -0.02572902f, -0.01712654f, 0.00255200f, 
    -0.05532802f, -0.04021786f, -0.07040923f, -0.05047444f, -0.06482702f, 0.03614630f, 0.01739425f, -0.06559853f, 
    -0.01699683f, -0.00784862f, -0.04443023f, -0.07505865f, -0.04751194f, 0.03142444f, -0.01527814f, 0.00975505f, 
    0.00138938f, -0.01019184f, 0.04251947f, -0.05780995f, -0.01973591f, -0.05553871f, -0.06646434f, -0.02289665f, 
    0.05677107f, -0.06952546f, -0.05027442f, -0.01533100f, -0.00355478f, 0.01642145f, -0.06374695f, -0.02663867f, 
    -0.05669246f, 0.00576232f, -0.05695332f, 0.01631742f, 0.04811289f, 0.05685152f, 0.04263277f, 0.04382044f, 
    0.06677217f, -0.00154790f, 0.02297713f, 0.06567208f, -0.07738701f, 0.02441036f, -0.05363413f, -0.06698113f, 
    -0.02494617f, -0.05938359f, -0.00955269f, 0.06628603f, -0.01826039f, 0.00497435f, 0.02048879f, -0.05532750f, 
    -0.01986150f, -0.00634300f, 0.03153085f, -0.02744140f, -0.03780378f, -0.06131242f, 0.05942017f, 0.06374881f, 
    0.05587360f, -0.02834416f, -0.02450340f, -0.06103958f, 0.03816678f, -0.00381361f, 0.00095303f, -0.06435415f, 
    -0.05814822f, 0.01204142f, 0.04687703f, 0.00543730f, 0.05709932f, 0.03525509f, 0.01110914f, 0.05370760f, 
    -0.02391889f, -0.06559344f, -0.05626016f, -0.03628908f, -0.05122815f, -0.02110239f, -0.01107265f, -0.04280904f, 
    0.00483575f, -0.03539478f, 0.01539679f, 0.03127899f, -0.01642572f, -0.01034424f, -0.07572588f, 0.00664595f, 
    -0.04127488f, 0.01734181f, 0.00026504f, 0.03119228f, 0.02805863f, -0.04888494f, -0.03705571f, -0.05307271f, 
    0.05075578f, -0.05422069f, -0.03383940f, -0.04067654f, 0.05812922f, 0.01719672f, -0.02592661f, 0.01033935f, 
    -0.03669591f, -0.04784361f, -0.03852205f, -0.04079529f, 0.02544312f, -0.01020421f, -0.07193312f, 0.02011778f, 
    0.63799310f, 0.13559887f, 0.07605863f, -0.04110260f, 0.01441458f, 0.08807424f, 0.10206779f, -0.10328566f, 
    0.01459605f, -0.05228454f, 0.03050082f, 0.03433740f, 0.20498019f, -0.01659814f, -0.10730910f, 0.17357047f, 
    -0.10643226f, 0.06759071f, 0.01471860f, -0.05650222f, 0.00152691f, -0.01182260f, 0.19439100f, 0.10551963f, 
    0.33422947f, -0.02560591f, 0.06528640f, 0.10816932f, -0.06536692f, 0.06364454f, 0.10578254f, 0.09670789f, 
    -0.14452539f, -0.14102702f, 0.04396738f, -0.00499373f, 0.38095587f, -0.21160597f, 0.03951296f, 0.16482824f, 
    0.18226309f, -0.03130999f, 0.18089142f, -0.03326136f, -0.12717493f, 0.22136143f, -0.09968735f, -0.06849723f, 
    0.05362709f, 0.06837485f, -0.04489779f, -0.03501496f, 0.01803536f, 0.05771945f, 0.00610789f, -0.13270707f, 
    0.07244842f, -0.05422635f, -0.03863119f, -0.04865409f, -0.18838261f, 0.21447331f, -0.02018329f, 0.01259666f, 
    -0.02066662f, 0.00540365f, 0.03379880f, -0.01542794f, -0.10495272f, 0.07243232f, 0.16519783f, 0.00772548f, 
    -0.02969802f, 0.00107278f, -0.00115582f, 0.11456670f, 0.10686193f, -0.11400089f, -0.05588624f, 0.07212288f, 
    0.10422539f, -0.17422076f, -0.03743953f, 0.00284202f, 0.24694704f, 0.00650924f, 0.08759009f, -0.02554298f, 
    0.10857370f, 0.08372098f, 0.06074859f, -0.01440585f, 0.10753351f, -0.08563909f, 0.05214931f, -0.14004785f, 
    -0.19119041f, -0.08864515f, -0.09382920f, -0.05291449f, -0.06102995f, -0.01827139f, -0.05120896f, -0.00796229f, 
    0.06093350f, 0.08109254f, -0.04384276f, 0.15894286f, 0.07774244f, -0.03812582f, -0.13569345f, -0.11518343f, 
    0.04075359f, 0.02760459f, 0.17842253f, -0.19916980f, -0.07433511f, 0.04933674f, 0.20822485f, -0.04005169f, 
    0.08966921f, -0.17029789f, 0.14545357f, 0.10625674f, -0.00680264f, 0.06232918f, -0.00063759f, 0.04193755f, 
    0.02948710f, 0.02879933f, -0.02974917f, 0.04368083f, -0.08818016f, 0.13058896f, -0.01771964f, 0.18965843f, 
    0.04498553f, -0.07966721f, -0.00774627f, -0.01069295f, 0.00653263f, -0.20936272f, 0.00030480f, -0.01779270f, 
    -0.00432119f, 0.05988104f, 0.10984543f, 0.09957552f, 0.05880131f, -0.02463170f, 0.06221806f, 0.06291718f, 
    0.04361135f, -0.02983759f, 0.11012273f, 0.01465201f, 0.17334297f, -0.20756529f, -0.18467307f, -0.10283510f, 
    -0.03767671f, 0.00961340f, -0.01705640f, -0.02017055f, 0.01277036f, -0.12719299f, 0.09807594f, 0.09480832f, 
    -0.10563369f, -0.14201550f, -0.14311466f, -0.17846800f, -0.06922683f, -0.04640702f, 0.01879439f, -0.03538531f, 
    0.06472987f, -0.02705975f, -0.03587669f, -0.05586269f, 0.18289550f, -0.04398951f, 0.07526708f, 0.07692778f, 
    -0.03194881f, -0.13085857f, 0.01471246f, 0.02214291f, 0.07804964f, -0.05160422f, -0.08172118f, -0.15663570f, 
    -0.23102231f, 0.07383393f, 0.04673436f, 0.04255748f, 0.10809404f, 0.07048502f, -0.05640632f, 0.05286079f, 
    0.17919014f, 0.03874176f, -0.02998316f, 0.02010448f, -0.00940877f, 0.02132907f, 0.06737787f, -0.15041402f, 
    -0.00738883f, 0.05558529f, 0.04830447f, 0.08318314f, 0.04779243f, 0.08614974f, -0.05424739f, 0.00891449f, 
    -0.08546779f, -0.00191891f, -0.00838389f, 0.00301008f, 0.05220074f, -0.03644073f, -0.04929739f, 0.06899230f, 
    0.10355659f, 0.08346941f, -0.03013043f, 0.05156923f, -0.28132129f, -0.08517764f, 0.00164075f, -0.16293602f, 
    0.00065232f, 0.05041151f, 0.05393405f, 0.13413148f, 0.07225560f, -0.15983568f, 0.00171690f, 0.03361825f, 
    -0.15029210f, 0.13557023f, 0.23010893f, -0.00048150f, 0.05116475f, 0.06404828f, 0.14013089f, 0.18894684f, 
    0.00121034f, -0.12708724f, -0.04590526f, 0.01683817f, 0.06010343f, -0.00683009f, 0.28676060f, 0.05774071f, 
    0.07081048f, -0.07160121f, -0.07619698f, 0.08208253f, 0.09721756f, 0.01935196f, -0.06867685f, 0.01167458f, 
    -0.17603116f, -0.23796585f, -0.12832178f, -0.04305525f, -0.10532799f, -0.03825327f, 0.00186608f, -0.07412185f, 
    -0.03161094f, 0.09847628f, -0.02135085f, -0.02486246f, -0.04735088f, 0.16075766f, 0.15684465f, 0.08124252f, 
    -0.12223263f, -0.02670302f, 0.02752861f, 0.07766930f, -0.02761853f, 0.13763206f, 0.14241014f, 0.09058095f, 
    -0.05464436f, 0.12034822f, 0.14398935f, -0.09017812f, 0.02309435f, 0.02572997f, -0.03614940f, 0.05526349f, 
    0.03288657f, 0.06117615f, -0.08329795f, -0.12954378f, 0.25009453f, -0.26936516f, -0.11409034f, 0.42692462f, 
    0.17192087f, 0.15221253f, 0.03728595f, 0.13647756f, 0.11475578f, 0.03502079f, -0.03910824f, -0.03245537f, 
    -0.12644690f, 0.05772220f, 0.07773855f, -0.15295130f, -0.02878044f, -0.02223825f, -0.00168883f, 0.00721639f, 
    -0.02102373f, 0.04655991f, 0.11006909f, 0.01676168f, -0.28957957f, 0.02675209f, -0.06098759f, -0.13964765f, 
    0.04136780f, 0.06368153f, 0.04030701f, -0.06956518f, -0.03647014f, -0.00266139f, 0.05075989f, 0.06004472f, 
    -0.09050389f, -0.11444639f, -0.24505670f, 0.04062048f, -0.04707209f, -0.05033319f, 0.06780939f, -0.10556418f, 
    0.01127539f, 0.08734093f, -0.04754470f, 0.05481373f, -0.03567183f, 0.16487618f, 0.06715807f, -0.15795960f, 
    -0.01961856f, -0.06573865f, 0.05748586f, 0.03036581f, 0.04933865f, 0.00983339f, -0.08595740f, -0.04619530f, 
    0.07765186f, 0.00960874f, 0.24718153f, 0.26382920f, -0.01023367f, 0.07960574f, 0.15035941f, 0.06751460f, 
    -0.01306759f, 0.08246573f, 0.12859315f, 0.15208530f, -0.32669476f, -0.09938079f, -0.08673722f, 0.10385116f, 
    -0.05774619f, 0.02145698f, 0.09354128f, 0.06864381f, 0.09682253f, 0.06640643f, 0.05420396f, 0.04527961f, 
    -0.15848513f, 0.26225075f, 0.24412321f, -0.24770936f, 0.05619769f, -0.00239884f, 0.00330537f, 0.07814531f, 
    -0.01440465f, 0.05100876f, -0.08431016f, -0.03939642f, -0.00105092f, -0.03651151f, 0.19728400f, -0.21782012f, 
    -0.06051155f, 0.02229208f, -0.00090717f, -0.07488694f, 0.03316670f, 0.02042649f, 0.02634651f, -0.12414891f, 
    0.07548266f, 0.09272408f, 0.02592191f, -0.23806746f, -0.07468574f, -0.10964411f, 0.01224678f, -0.04222397f, 
    -0.09253945f, 0.18380187f, 0.02096102f, 0.02292232f, 0.07727096f, -0.07510418f, -0.04555385f, 0.17840324f, 
    0.01631679f, 0.03142841f, 0.04671540f, 0.03339850f, 0.07850660f, -0.10860039f, 0.14922503f, -0.12468345f, 
    0.15965924f, -0.25991991f, 0.14092746f, -0.06284402f, -0.02141608f, -0.06650755f, -0.09142933f, 0.15697885f, 
    0.01000133f, -0.12690103f, 0.01827298f, 0.08251878f, -0.15206555f, 0.02102400f, 0.11175296f, -0.18912944f, 
    0.05599755f, 0.05393344f, -0.03377818f, -0.09511461f, -0.09475315f, -0.01788035f, 0.01645423f, 0.02692975f, 
    0.01266629f, 0.23579437f, -0.05010866f, 0.20775872f, 0.02156014f, 0.02539569f, 0.12396716f, 0.09616935f, 
    -0.00251789f, 0.05804583f, -0.04164652f, 0.03047676f, -0.08254901f, 0.02503671f, 0.05452966f, -0.19503443f, 
    -0.02770125f, 0.12860723f, 0.01563545f, -0.01533203f, 0.00539825f, 0.07846104f, -0.04786396f, 0.05136937f, 
    -0.07348836f, 0.00180596f, 0.01458308f, 0.07405151f, 0.00132258f, 0.04843134f, -0.13503796f, 0.02498589f, 
    -0.04468568f, 0.08786301f, 0.05490371f, -0.05301373f, -0.34702584f, -0.00588792f, 0.25316200f, 0.00344149f, 
    -0.00588612f, -0.02041377f, 0.05747250f, -0.12728730f, -0.01028356f, -0.02345335f, -0.09687994f, -0.13006401f, 
    -0.19918534f, 0.15795562f, -0.04596117f, 0.00477803f, 0.03690778f, -0.13305284f, -0.02077409f, 0.00238843f, 
    -0.05279381f, 0.16195443f, 0.07326888f, 0.05249707f, 0.10841533f, -0.05698798f, 0.21916245f, 0.02499890f, 
    0.11419006f, 0.08316327f, 0.01436895f, -0.15960380f, -0.03364200f, 0.21084900f, -0.05938730f, 0.02267844f, 
    0.26497486f, 0.22230315f, 0.04712084f, 0.16677411f, 0.16747557f, -0.11230537f, 0.01462306f, 0.22376034f, 
    -0.01364373f, 0.02884240f, -0.20753050f, -0.07416122f, 0.07550354f, -0.17138760f, 0.02409859f, -0.10139543f, 
    -0.03391002f, 0.08983655f, 0.03300188f, -0.10696304f, 0.03310588f, -0.02563321f, -0.05107301f, -0.19101094f, 
    0.08218212f, -0.14852194f, 0.05761863f, -0.06870155f, 0.11105944f, -0.02761090f, -0.02447768f, 0.06983718f, 
    -0.01874039f, -0.08978801f, -0.13618040f, -0.02856215f, -0.08944343f, 0.12006801f, 0.03981581f, 0.31334868f, 
    0.11718573f, 0.00211463f, 0.06014513f, 0.18088321f, -0.02490306f, -0.06280214f, 0.01475019f, 0.08353306f, 
    0.36171359f, -0.10872130f, 0.11964516f, -0.03308414f, -0.04781111f, 0.06201980f, 0.12357682f, -0.05115794f, 
    0.08061358f, 0.09283220f, -0.10151886f, -0.05289286f, 0.23978290f, 0.08476520f, -0.09007271f, -0.06023040f, 
    0.01257796f, 0.00397778f, 0.00566317f, -0.01325007f, 0.09578662f, 0.05788678f, 0.05962126f, 0.06983034f, 
    0.07264156f, -0.17140195f, 0.04002335f, 0.04827389f, 0.04288041f, -0.03215790f, -0.04777138f, -0.03856899f, 
    -0.10083004f, -0.06536218f, 0.04074895f, 0.01892020f, 0.22878096f, -0.16795518f, -0.04664207f, 0.21978024f, 
    0.05986818f, 0.03800725f, 0.14284508f, -0.00177597f, -0.04687614f, 0.20136333f, -0.10514854f, -0.00487144f, 
    0.00972553f, -0.06573915f, -0.22512414f, 0.00016671f, 0.06899597f, -0.03642652f, -0.04628222f, 0.05634203f, 
    -0.01888204f, 0.02897377f, -0.18696524f, -0.20008765f, -0.21637824f, 0.03763883f, -0.01735274f, 0.09610746f, 
    0.12247293f, -0.01857578f, -0.02313213f, -0.08691242f, -0.07219663f, 0.14760448f, 0.07056382f, 0.02737851f, 
    -0.09008177f, 0.10879231f, -0.00538326f, 0.05868021f, 0.03262838f, -0.08225690f, 0.03516313f, -0.17814136f, 
    0.13476875f, -0.01275034f, -0.03182904f, -0.06484202f, -0.09512757f, 0.09894916f, -0.06437699f, -0.05949975f, 
    0.01465578f, -0.08174568f, 0.03000285f, -0.05268037f, -0.02919484f, -0.07118702f, 0.01999430f, -0.09318257f, 
    0.16008654f, -0.19290183f, 0.14151902f, -0.07129937f, -0.08662379f, 0.01567453f, -0.04808305f, 0.15632915f, 
    0.11226833f, 0.14495899f, 0.05963954f, 0.10219270f, 0.02360189f, -0.12697114f, -0.07747099f, -0.10771526f, 
    -0.04238285f, 0.06394398f, 0.06435199f, -0.15835720f, -0.05835889f, 0.06850386f, 0.02304813f, -0.00978476f, 
    -0.19577965f, -0.15014082f, 0.20342478f, -0.00383867f, 0.15968254f, 0.09770232f, -0.07801145f, 0.12826091f, 
    0.13778515f, 0.01715234f, 0.02661515f, -0.05117963f, 0.22994263f, 0.19963558f, -0.00988595f, 0.18061244f, 
    0.07071280f, -0.01145600f, 0.03812921f, 0.05464870f, 0.04208042f, -0.15622555f, 0.08601435f, 0.02289259f, 
    0.05810792f, 0.22677279f, 0.08694913f, 0.04777579f, -0.05612376f, -0.02721117f, 0.10954207f, 0.14130740f, 
    -0.01457300f, 0.02056405f, -0.03751048f, -0.02100952f, 0.23473720f, -0.02227283f, -0.16979986f, -0.01058346f, 
    0.07949078f, 0.01999084f, 0.04180323f, 0.12276860f, -0.04784048f, 0.03173164f, 0.09946509f, 0.05290154f, 
    -0.05108064f, -0.18362492f, -0.19510219f, -0.12293591f, 0.04565525f, 0.06213404f, 0.09871408f, -0.02436933f, 
    0.12617165f, -0.13258313f, -0.05816676f, -0.16079049f, 0.22272152f, -0.11829253f, 0.09679887f, 0.13704640f, 
    -0.01256004f, -0.16460879f, 0.04219529f, 0.01536569f, -0.04933824f, 0.01846165f, -0.02955122f, -0.10695222f, 
    -0.35896903f, -0.04467705f, 0.04320412f, 0.13922630f, 0.00700500f, -0.09910958f, -0.06166890f, 0.11416902f, 
    -0.01921596f, -0.01328640f, 0.05950723f, -0.02865250f, -0.10423020f, -0.13319093f, 0.08808240f, -0.09412846f, 
    0.11460335f, -0.04322934f, -0.05949884f, 0.02221605f, -0.02814291f, 0.03887039f, -0.10349794f, -0.05967527f, 
    -0.16219966f, 0.06196393f, 0.07052508f, -0.05002994f, -0.00500547f, 0.05392177f, 0.04839379f, -0.00405608f, 
    0.12876494f, 0.14948593f, -0.01983325f, -0.03127066f, -0.30706745f, 0.28237063f, 0.02707379f, -0.13712032f, 
    -0.14934541f, 0.10017693f, -0.10574716f, 0.01702127f, 0.10341645f, -0.09247609f, 0.15605406f, 0.04249663f, 
    -0.00568702f, 0.06765993f, 0.10223535f, 0.07525072f, -0.01750451f, 0.03099822f, 0.08157042f, 0.13721973f, 
    0.02118083f, -0.06982230f, 0.09731016f, 0.03283928f, 0.23494570f, -0.20775396f, 0.00368867f, -0.05488825f, 
    0.04542843f, 0.00262699f, -0.05757527f, 0.06416720f, 0.12430657f, -0.03889901f, -0.09130358f, 0.02773307f, 
    0.12526083f, -0.23957323f, 0.05354564f, -0.27897257f, 0.00951833f, 0.00703865f, 0.16963401f, -0.00625182f, 
    -0.07699276f, 0.08487611f, 0.08437055f, 0.01417601f, -0.12347282f, 0.02520403f, -0.01493898f, 0.11181778f, 
    -0.04955591f, -0.05642644f, -0.00865021f, 0.05466256f, 0.06532290f, -0.04175863f, 0.02562630f, 0.11816806f, 
    0.19795133f, -0.03359701f, -0.03505846f, 0.06086984f, -0.00173963f, 0.09524754f, 0.03164455f, -0.02748478f, 
    0.02294655f, 0.04739924f, 0.01714887f, -0.19463383f, 0.03434533f, -0.09167354f, 0.18853886f, 0.12606747f, 
    -0.01668491f, 0.12713329f, -0.05543237f, 0.21839362f, 0.00433479f, 0.00114119f, -0.06358472f, 0.09458023f, 
    -0.04205680f, 0.12247103f, -0.04399643f, 0.04456466f, -0.06876818f, 0.06527687f, 0.01117485f, -0.04954616f, 
    -0.07925079f, 0.02227495f, 0.05844361f, 0.01125555f, -0.02139760f, -0.05576433f, 0.01983986f, -0.03477278f, 
    -0.04338395f, 0.05589490f, 0.06576342f, 0.05465164f, 0.05340176f, 0.13590477f, 0.11118317f, 0.01231885f, 
    0.04069065f, -0.00856138f, -0.16120321f, -0.20107685f, 0.01318618f, 0.05560835f, 0.12380783f, 0.02749915f, 
    0.00386210f, -0.03123424f, -0.03836015f, 0.06760413f, -0.24920018f, 0.14941451f, 0.19594091f, 0.10518282f, 
    -0.02888471f, -0.07829102f, -0.05885711f, -0.01923985f, -0.06383609f, 0.05401142f, -0.03245046f, -0.13477680f, 
    0.03078776f, 0.26018524f, 0.25449714f, 0.31851268f, 0.00227419f, 0.09498637f, -0.05139378f, 0.06874447f, 
    -0.00963055f, 0.04853763f, 0.00996202f, 0.03581128f, 0.06713570f, -0.03114733f, -0.05140222f, -0.10749394f, 
    -0.01632597f, 0.15568988f, -0.05181947f, 0.03107864f, 0.03803365f, 0.12931263f, 0.08626902f, 0.12954144f, 
    -0.07299014f, -0.07939789f, 0.03347269f, -0.07015331f, -0.02421529f, -0.00316720f, 0.04583808f, 0.05207655f, 
    0.02767732f, -0.04064264f, 0.06316943f, -0.02578363f, -0.00814700f, 0.04975171f, -0.00660435f, 0.00819841f, 
    0.04962097f, -0.03087613f, 0.00826027f, 0.05535999f, -0.07357051f, -0.08018487f, -0.06617054f, -0.04917667f, 
    0.02351972f, -0.06943987f, -0.06388411f, -0.05891282f, -0.04574478f, 0.01221825f, 0.04233544f, 0.05654275f, 
    0.02551692f, -0.02821910f, -0.04035783f, -0.03297877f, -0.05143156f, -0.01729811f, 0.01224433f, 0.01313235f, 
    -0.03917157f, -0.07769774f, -0.00516185f, 0.03973769f, -0.00465926f, -0.00138236f, -0.01489725f, 0.01012614f, 
    0.05729334f, -0.01560414f, -0.05927386f, 0.04631102f, -0.01034092f, 0.05311815f, -0.04326450f, -0.01357120f, 
    -0.01080416f, -0.07250551f, -0.06117448f, -0.00846603f, 0.05135984f, -0.04957455f, -0.06450658f, 0.04796226f, 
    -0.04731674f, 0.01946410f, -0.02134333f, 0.02508179f, 0.03407941f, -0.02585631f, 0.05288180f, -0.07834831f, 
    -0.03951843f, -0.01298594f, 0.03392409f, 0.00777313f, 0.01477300f, 0.04091730f, 0.04889341f, -0.04087647f, 
    -0.01391851f, -0.02324190f, 0.06509292f, 0.05135608f, 0.01459836f, -0.06131338f, 0.00870447f, -0.04555924f, 
    -0.00415658f, -0.02428153f, -0.04131865f, -0.05790049f, -0.01740702f, -0.04300956f, 0.06230773f, 0.00371740f, 
    -0.07314887f, 0.01720686f, -0.07671900f, 0.03267111f, 0.01684053f, -0.01255339f, -0.01527061f, 0.01237037f, 
    0.00994424f, 0.02149005f, -0.04588258f, -0.05120463f, 0.02040843f, -0.07062538f, 0.04931539f, 0.05899560f, 
    -0.04038064f, 0.05079830f, -0.02482934f, -0.00809746f, -0.01148078f, -0.00908763f, 0.00633848f, 0.06343811f, 
    0.03521458f, 0.05864414f, -0.04968409f, -0.02495533f, -0.01089038f, 0.00228437f, -0.05692926f, -0.06392673f, 
    0.01616525f, 0.01371863f, -0.04974520f, -0.04959340f, 0.06073295f, 0.04425872f, 0.01118601f, -0.01578027f, 
    -0.02622541f, -0.00726443f, -0.05794439f, 0.03292314f, -0.02406161f, -0.02662301f, -0.03136727f, 0.03797808f, 
    -0.00938358f, -0.03945610f, -0.02171125f, -0.07633791f, -0.00799980f, 0.02484158f, -0.06550875f, -0.07772601f, 
    -0.03576521f, -0.01419565f, 0.05452202f, -0.00735232f, -0.02920518f, -0.02492044f, -0.00819533f, 0.06072650f, 
    0.01532512f, 0.04553528f, -0.07092594f, -0.06786300f, -0.07918321f, 0.02749680f, 0.03282452f, 0.03747065f, 
    0.04798580f, -0.07371540f, -0.04318058f, 0.02189761f, -0.03782590f, -0.00180066f, 0.04171845f, -0.01594009f, 
    0.02083036f, -0.01361746f, -0.01099572f, -0.03811362f, -0.05319508f, 0.03690703f, 0.04055003f, -0.00865524f, 
    -0.01968180f, -0.06657999f, 0.01259627f, -0.05521853f, -0.02459007f, 0.05008887f, 0.03925682f, -0.03370795f, 
    -0.36903250f, -0.21738157f, -0.06381873f, 0.03350599f, -0.01463872f, 0.03724563f, 0.14565776f, -0.06061260f, 
    0.04389279f, 0.04166812f, -0.02422632f, 0.13932239f, -0.27597129f, -0.16717879f, 0.09963589f, 0.29921949f, 
    -0.01567347f, -0.07769092f, -0.03677693f, 0.00923873f, -0.04912734f, 0.03804344f, -0.06634954f, -0.05020176f, 
    -0.13695204f, -0.19182803f, -0.00245770f, -0.06045497f, 0.10293781f, 0.00627694f, -0.02773541f, 0.06234342f, 
    0.03175679f, 0.00277348f, -0.01615539f, 0.09530849f, 0.22864926f, 0.00189371f, -0.03090437f, -0.00775756f, 
    -0.09789480f, 0.06744962f, 0.05831333f, -0.02691324f, -0.00031797f, -0.06608742f, -0.05253398f, 0.12178643f, 
    -0.32873866f, 0.08084078f, -0.04833140f, 0.14466654f, 0.02092231f, -0.01473549f, -0.07923658f, 0.06928273f, 
    0.02274379f, 0.22530866f, -0.06232820f, 0.16259934f, 0.07425965f, -0.07588512f, 0.01050656f, 0.17495339f, 
    -0.12740417f, 0.12606543f, 0.08142432f, -0.00056295f, 0.07820639f, 0.02549237f, 0.12529056f, 0.07297971f, 
    0.21571401f, -0.00918392f, -0.00175135f, 0.05391693f, 0.01878897f, 0.16525382f, 0.03042960f, -0.02438639f, 
    0.07360051f, 0.08370075f, 0.03959358f, 0.05282851f, 0.04500725f, -0.38828915f, -0.00903653f, -0.09582331f, 
    0.08606543f, -0.01972496f, 0.05364592f, -0.00816416f, -0.05488688f, 0.04888604f, 0.01494792f, 0.11422530f, 
    0.02152793f, 0.31308228f, 0.09972870f, 0.04405193f, 0.11026344f, 0.02415200f, 0.13325556f, 0.07909413f, 
    0.07387729f, 0.04220276f, 0.08802132f, 0.04716293f, -0.18815394f, 0.01734403f, -0.16783547f, -0.11001959f, 
    -0.00538420f, -0.00929249f, -0.01043891f, 0.01789176f, 0.03804687f, -0.04359082f, -0.01656539f, 0.02094793f, 
    0.36947623f, 0.06692399f, 0.03690892f, -0.00698675f, -0.14255850f, 0.03256948f, 0.02052764f, -0.09067924f, 
    0.04562483f, 0.13045385f, -0.01428031f, 0.05391357f, -0.20045765f, 0.32565042f, 0.21123731f, -0.01232587f, 
    0.01105099f, -0.07081766f, -0.12639374f, 0.08320085f, 0.05416846f, 0.04597199f, -0.18928903f, 0.02656361f, 
    0.12548144f, -0.00453367f, 0.09674031f, 0.04957865f, 0.09941278f, -0.07519469f, -0.10121067f, -0.03005286f, 
    0.05509623f, -0.02048615f, 0.08046915f, 0.10443795f, -0.10396352f, 0.07547500f, -0.02162836f, 0.09546111f, 
    0.00427668f, 0.05185068f, -0.01096882f, 0.05421957f, 0.01526309f, -0.00951306f, 0.10617437f, 0.12280940f, 
    0.05487575f, 0.04731748f, 0.16366042f, -0.01295223f, -0.10011936f, 0.02485678f, -0.03548541f, -0.05866041f, 
    0.09691718f, 0.07499008f, 0.06026194f, -0.02734146f, -0.03633738f, 0.08200034f, -0.09594971f, 0.04106838f, 
    -0.02789164f, 0.04631361f, 0.07362685f, -0.06108111f, -0.06843437f, -0.05197179f, -0.01829801f, -0.08247525f, 
    -0.00572053f, -0.01344409f, 0.31647435f, 0.13939184f, -0.00794480f, 0.03125353f, 0.12601487f, -0.06269681f, 
    0.00123943f, -0.07053002f, -0.07081600f, 0.10618079f, 0.06699131f, 0.08880561f, 0.26050633f, 0.13786151f, 
    -0.01780621f, 0.00609280f, -0.01823678f, -0.06096365f, 0.11689753f, 0.06844924f, 0.08221114f, 0.08373121f, 
    -0.05610456f, 0.07785320f, 0.20503573f, 0.12607980f, -0.08491718f, 0.10447285f, 0.14873637f, 0.00202910f, 
    0.04799032f, -0.03413624f, -0.03410932f, -0.02291668f, -0.04733263f, 0.16755277f, 0.00642589f, -0.04558694f, 
    0.12960762f, -0.18112628f, 0.09358447f, 0.01936324f, -0.05220355f, 0.05274762f, -0.13072529f, 0.05213047f, 
    0.23323618f, 0.05099062f, -0.07218404f, -0.06886116f, 0.03884115f, 0.20572135f, 0.05379340f, -0.04521104f, 
    0.07647258f, 0.24083711f, 0.19090188f, -0.04465489f, -0.05398457f, 0.21047211f, 0.05207657f, 0.13974430f, 
    0.08214390f, -0.06838184f, 0.06989250f, 0.01955585f, -0.03744510f, 0.13910480f, 0.19203173f, 0.02667755f, 
    -0.46918759f, -0.36272720f, -0.01648319f, -0.23508999f, -0.02565074f, 0.03786200f, -0.09375834f, 0.03996812f, 
    0.24704537f, 0.00211719f, -0.02443045f, -0.02694841f, 0.04162806f, 0.11334301f, 0.21678299f, 0.04157403f, 
    0.14292316f, -0.04081297f, -0.05501663f, 0.11016964f, -0.06497569f, -0.12518182f, -0.07213903f, -0.15987740f, 
    -0.03058102f, -0.33911195f, -0.32328627f, 0.04076010f, -0.03624782f, 0.15982392f, 0.04718693f, 0.03833568f, 
    0.15068172f, 0.03613155f, 0.05359493f, 0.28334948f, -0.12946764f, -0.16805074f, 0.04895170f, 0.00891442f, 
    -0.02022629f, -0.13278264f, -0.09261583f, -0.18251401f, -0.02831462f, 0.06068352f, 0.11711723f, -0.05724509f, 
    -0.15291333f, 0.02433357f, 0.09693000f, -0.00175863f, 0.01595145f, 0.05681011f, 0.12405167f, -0.01010093f, 
    -0.01146314f, -0.10425623f, 0.03852860f, 0.16213803f, -0.06044418f, -0.55466050f, -0.54172975f, -0.17916580f, 
    0.07211068f, -0.07755101f, -0.03426334f, -0.06499237f, 0.07246139f, -0.02940341f, 0.10567418f, -0.10101997f, 
    -0.64618725f, -0.36344600f, -0.31053492f, -0.21382399f, -0.10220812f, 0.12455393f, 0.10870133f, -0.02443513f, 
    -0.06087502f, 0.00570229f, 0.18992272f, 0.12324540f, -0.18404076f, -0.01379565f, 0.12386759f, -0.12916681f, 
    0.04025747f, -0.02839801f, 0.01072929f, 0.19543326f, 0.02604245f, 0.07373087f, 0.19955261f, 0.21942888f, 
    -0.24531792f, -0.21160337f, -0.36114180f, 0.03691841f, 0.13829452f, -0.06033335f, 0.00461341f, -0.14380205f, 
    0.14958039f, -0.13655527f, 0.08952950f, -0.10128932f, 0.02153003f, -0.22828633f, 0.00181295f, -0.41022322f, 
    -0.03183653f, 0.05864378f, -0.10417964f, -0.02107825f, 0.06800719f, 0.08848402f, -0.08140188f, 0.05245494f, 
    0.31267554f, 0.14889845f, 0.10549987f, 0.15565400f, 0.06988922f, 0.05622769f, -0.05057269f, 0.08050293f, 
    -0.05374972f, 0.09570966f, 0.12761699f, -0.04440692f, 0.34768596f, 0.17636348f, 0.05368113f, -0.00795141f, 
    -0.01255413f, 0.03168457f, -0.00679912f, 0.11602860f, -0.13311329f, -0.03594204f, 0.01077320f, 0.10790750f, 
    0.19871482f, 0.02119493f, 0.10404930f, 0.10802477f, -0.11774618f, 0.06150278f, 0.11034466f, 0.11372542f, 
    0.09571338f, 0.04611792f, -0.00314455f, -0.04565247f, -0.30073419f, 0.08221751f, 0.03368041f, -0.13670826f, 
    0.13814303f, 0.12471107f, -0.10328525f, 0.11516480f, 0.11530618f, 0.03815508f, 0.07710979f, 0.03605537f, 
    0.30657133f, -0.03488338f, 0.08488281f, -0.06292464f, 0.00552642f, 0.13007763f, 0.16707207f, -0.01188526f, 
    0.01430137f, -0.08357416f, 0.15831889f, -0.00399583f, 0.09743519f, 0.18125644f, -0.00403875f, -0.03191703f, 
    0.14342752f, -0.06445830f, -0.12572640f, 0.17636704f, -0.15374357f, -0.12603191f, -0.06820323f, -0.05134001f, 
    0.01492265f, -0.09231220f, -0.16828531f, -0.23189400f, 0.02236279f, -0.08882763f, -0.09178150f, 0.04422888f, 
    -0.00169284f, -0.00242455f, 0.05887152f, 0.10673901f, 0.15546890f, 0.31751871f, 0.10198615f, 0.25586364f, 
    0.00990385f, 0.04480992f, 0.06151741f, 0.06251732f, 0.04918440f, 0.01845812f, 0.09753978f, -0.10148381f, 
    -0.17834558f, -0.13398920f, -0.11128847f, -0.03207050f, 0.02930407f, -0.01140404f, 0.05494351f, -0.17178391f, 
    0.03894574f, -0.08258222f, 0.01712784f, -0.11969810f, 0.11246775f, 0.06429031f, 0.05706015f, 0.16920789f, 
    0.06363748f, 0.08912627f, -0.00212309f, 0.08741532f, 0.01339898f, -0.02199065f, -0.04794573f, 0.08422455f, 
    -0.15018551f, -0.06646913f, 0.12774235f, -0.06192575f, 0.04840481f, -0.00581507f, 0.01808550f, 0.08070333f, 
    -0.01382405f, -0.02319839f, 0.01697756f, 0.04813659f, -0.03759629f, -0.30829969f, -0.03491316f, -0.05430649f, 
    0.09933870f, 0.12142886f, 0.08437861f, 0.03176890f, 0.01561442f, -0.00374151f, 0.05930754f, -0.03575407f, 
    -0.23923345f, -0.27348852f, -0.13580374f, -0.24224789f, -0.02510667f, 0.14030695f, -0.04526729f, -0.05514275f, 
    0.08757278f, 0.07661967f, -0.12957433f, 0.01112059f, 0.12505014f, -0.05783259f, 0.04516135f, 0.10130425f, 
    0.05709219f, -0.00696398f, 0.00314140f, -0.03005610f, 0.05949485f, 0.06411178f, -0.09788800f, -0.02177236f, 
    -0.28848305f, 0.06402760f, -0.09041976f, 0.18409736f, -0.09364925f, -0.01592958f, -0.12844779f, 0.13170062f, 
    -0.12846923f, 0.09013344f, 0.02402850f, 0.04499983f, -0.04498240f, -0.13349874f, 0.05481507f, -0.25115845f, 
    0.02114466f, 0.14405841f, -0.14534041f, 0.05402241f, 0.01628998f, 0.08173996f, -0.00390898f, 0.03960812f, 
    0.02873033f, -0.06401805f, -0.16973050f, 0.01309056f, 0.03051146f, 0.04631309f, 0.07387644f, -0.13648091f, 
    0.03667004f, 0.08092088f, 0.10020572f, -0.00599900f, 0.16750892f, 0.30202278f, -0.12247762f, -0.24419288f, 
    0.22676936f, 0.04623598f, -0.04877532f, 0.02728515f, 0.09981290f, 0.00009834f, 0.02115819f, 0.10506895f, 
    0.02203518f, 0.07797928f, 0.08864104f, 0.14481880f, 0.00428313f, 0.07465304f, 0.02922611f, 0.07327605f, 
    0.02740434f, 0.06307366f, 0.12312653f, 0.12404343f, -0.25550261f, 0.03139203f, -0.13752416f, -0.10290825f, 
    -0.01842664f, 0.01106653f, 0.06422816f, -0.02617208f, 0.09184238f, -0.02496682f, 0.04424224f, 0.08611935f, 
    0.16434009f, -0.21884334f, 0.02750756f, -0.01488241f, 0.09464129f, -0.00726651f, 0.11513650f, 0.08316384f, 
    -0.05715770f, -0.00172519f, -0.04522583f, -0.06678957f, -0.15539500f, -0.00489790f, 0.07642119f, -0.08303063f, 
    0.20290720f, 0.02667784f, 0.03511324f, -0.00683156f, -0.00416288f, 0.18023032f, 0.02330662f, -0.00968229f, 
    -0.38922960f, 0.12551245f, -0.02283055f, 0.08373478f, -0.06452806f, -0.07081436f, -0.03620742f, 0.03305733f, 
    -0.02376961f, -0.05307069f, -0.07589637f, 0.01359172f, -0.38774750f, 0.17364812f, 0.05133038f, 0.14110079f, 
    0.11747116f, -0.10058163f, 0.02943853f, -0.09880769f, 0.01721598f, -0.05538510f, 0.08673189f, -0.01001410f, 
    0.14428127f, -0.25388965f, 0.16225746f, 0.02125728f, -0.10643066f, 0.03298662f, 0.08359168f, -0.07580833f, 
    0.09123029f, -0.03244514f, 0.06914955f, 0.10666365f, 0.09859379f, 0.16454732f, -0.02302911f, 0.24502385f, 
    0.11421979f, -0.07285353f, -0.09692824f, -0.02314095f, 0.07196449f, -0.03123309f, -0.06067162f, 0.09821504f, 
    -0.15727839f, -0.22256669f, 0.18281367f, -0.22426128f, 0.06646532f, 0.02104426f, 0.11568116f, 0.13869232f, 
    0.04908501f, -0.05562806f, 0.14774953f, 0.02121094f, 0.53854221f, -0.28038013f, -0.07252309f, -0.03838943f, 
    -0.00747917f, 0.12622121f, 0.12610152f, 0.16726239f, 0.10195686f, 0.04118322f, 0.11936988f, 0.13764788f, 
    0.00391765f, 0.07244218f, -0.08521952f, -0.16903679f, -0.14445135f, 0.08305526f, 0.09291620f, -0.12971911f, 
    -0.07958101f, 0.03791092f, 0.02442179f, -0.01194054f, 0.39895537f, 0.14474526f, -0.06005711f, 0.00887442f, 
    0.13707876f, 0.12571529f, 0.03344869f, 0.01066494f, -0.04022206f, 0.09022699f, 0.01721746f, 0.05724140f, 
    0.03268413f, 0.02497993f, -0.28016293f, -0.04836725f, 0.02755206f, -0.00929950f, 0.10177459f, 0.04176816f, 
    -0.05011423f, -0.02502148f, -0.00632209f, -0.00181376f, 0.01246204f, 0.08953103f, 0.09074315f, 0.01955527f, 
    -0.04797863f, -0.07378959f, -0.01232328f, 0.13313399f, 0.00108751f, -0.00645579f, 0.04003738f, 0.09214579f, 
    0.50170797f, 0.11785181f, -0.00798297f, 0.04474732f, 0.15057735f, 0.03218720f, 0.06970818f, -0.11129177f, 
    -0.10259862f, -0.00513770f, 0.00337007f, 0.00414187f, 0.23821226f, -0.07106005f, -0.03567163f, -0.12400795f, 
    0.05797380f, 0.08575323f, 0.04233126f, -0.03621364f, 0.03637240f, 0.01216892f, 0.08959118f, 0.02904076f, 
    0.33271316f, 0.08322074f, 0.10486314f, -0.07170593f, 0.05545373f, 0.01190411f, -0.00419494f, -0.04599946f, 
    0.00287118f, -0.03022156f, 0.02624447f, -0.01566687f, 0.00411801f, 0.00239833f, 0.01294021f, 0.17697547f, 
    0.19641224f, -0.04146713f, 0.09047747f, -0.04501623f, 0.02701729f, 0.19447657f, -0.04200664f, 0.00009571f, 
    0.26101872f, -0.24068066f, -0.02685902f, -0.14744726f, 0.03439973f, -0.01699602f, -0.01963666f, -0.02641736f, 
    0.00693746f, -0.10511672f, -0.01309877f, -0.04545375f, -0.07280710f, 0.18560681f, 0.03309119f, -0.15137513f, 
    0.01233214f, 0.01344868f, -0.00692830f, -0.00741573f, -0.14646547f, -0.13898382f, 0.08498462f, -0.07212345f, 
    -0.05395805f, 0.07137916f, 0.08037589f, 0.01112188f, 0.06766375f, -0.01826331f, -0.06443562f, 0.10287402f, 
    0.06054186f, -0.04461304f, -0.00896391f, -0.08846763f, 0.14878111f, 0.16718630f, 0.11281161f, 0.03843866f, 
    0.07700279f, 0.12488079f, -0.03937998f, 0.04359850f, 0.08287899f, -0.09486977f, -0.04922034f, -0.10046797f, 
    -0.13024491f, -0.15255684f, 0.07193219f, -0.01239943f, 0.06227936f, -0.05736941f, -0.07768678f, -0.09602459f, 
    -0.05049205f, 0.05353161f, 0.08595519f, 0.17475721f, 0.17963494f, 0.14540133f, 0.08213531f, -0.11879294f, 
    0.02424822f, -0.10568552f, -0.01511356f, -0.03529879f, 0.02425179f, 0.04924527f, 0.18168265f, 0.03674119f, 
    -0.15534769f, -0.01964488f, 0.12867656f, -0.02840311f, 0.21994677f, 0.02310324f, -0.02316189f, 0.05449584f, 
    0.10881761f, -0.06665646f, -0.06933589f, 0.08114017f, 0.04830946f, -0.05534514f, -0.21941414f, 0.12267567f, 
    0.13682497f, 0.03334963f, 0.06605069f, -0.03715216f, 0.09780004f, -0.04984106f, 0.00316547f, -0.04997126f, 
    -0.04420272f, -0.02828718f, 0.01340854f, 0.11374953f, -0.02838764f, -0.02025205f, 0.02664535f, -0.04606226f, 
    0.01873785f, -0.03037541f, 0.03198769f, -0.12424427f, 0.05675282f, -0.04319959f, -0.09362751f, -0.13430437f, 
    -0.03953369f, 0.01774103f, 0.01674614f, 0.00022575f, -0.03246863f, -0.03756768f, 0.09059675f, 0.01319655f, 
    -0.12212791f, -0.07159405f, -0.22721383f, -0.17334801f, -0.00597522f, -0.01770243f, -0.05582875f, -0.00098801f, 
    0.08060996f, -0.03654813f, -0.03501836f, 0.03709503f, 0.10745223f, 0.20073260f, 0.09317639f, 0.00118115f, 
    0.07258419f, -0.10721926f, -0.03711367f, 0.10366452f, 0.07808887f, 0.07131523f, 0.04596637f, 0.02003912f, 
    0.02699852f, 0.11770394f, 0.16062383f, 0.19434093f, 0.19600996f, 0.08879562f, 0.07364691f, -0.07771928f, 
    0.13939352f, -0.07138194f, 0.09367873f, 0.10387859f, -0.24550177f, -0.07796437f, 0.15440412f, 0.23285997f, 
    0.12921219f, -0.05376045f, -0.10152464f, -0.17464571f, 0.02031430f, 0.06271324f, 0.17900150f, 0.11924482f, 
    0.21020681f, 0.23118167f, 0.15625833f, 0.26387861f, 0.26256993f, 0.03198266f, -0.06365269f, -0.06895679f, 
    -0.02200840f, 0.00599012f, 0.08111615f, -0.03466861f, 0.31916440f, -0.02913262f, -0.01300309f, 0.16623014f, 
    0.15134178f, -0.19691180f, -0.08301499f, -0.01599214f, -0.10561209f, 0.10333665f, -0.06354631f, 0.03790652f, 
    -0.07238366f, 0.07700250f, 0.06562591f, 0.14136864f, 0.07589523f, 0.09423075f, -0.03342647f, -0.10494777f, 
    0.00437290f, 0.05242049f, 0.06389947f, -0.11339746f, -0.31909940f, 0.05514877f, 0.07550842f, 0.06022381f, 
    -0.04404304f, 0.03010932f, 0.06161190f, -0.16968730f, 0.12478120f, 0.00374850f, 0.11886290f, 0.00666521f, 
    -0.41228715f, -0.05749553f, 0.14375865f, 0.12653817f, -0.12046847f, -0.03880825f, -0.16459081f, 0.06062673f, 
    0.04271175f, -0.10188294f, 0.00832555f, -0.02012819f, 0.06460702f, -0.06200519f, 0.18868849f, 0.19212149f, 
    0.26409513f, 0.14341788f, -0.04154392f, -0.07411863f, 0.03363066f, -0.09959026f, -0.00420061f, 0.11845618f, 
    -0.04070786f, -0.06602362f, 0.22722073f, -0.08612656f, 0.17191498f, 0.07216512f, -0.08341706f, -0.16779786f, 
    0.00062945f, -0.08191605f, -0.08726049f, 0.15521587f, -0.07956060f, 0.03891798f, -0.33129081f, -0.08896208f, 
    0.07284144f, -0.02203953f, -0.02925071f, -0.05099496f, -0.06579882f, 0.03071278f, 0.23030388f, 0.04815625f, 
    0.24062222f, 0.08685803f, 0.17256688f, 0.00147303f, -0.03000562f, 0.02330886f, 0.01095870f, -0.05779677f, 
    0.08474587f, 0.07580651f, 0.09386840f, 0.04674310f, 0.00281721f, -0.00368566f, -0.07883635f, -0.08525848f, 
    -0.02319377f, -0.05506056f, -0.06504926f, 0.12260480f, -0.07179535f, -0.14167170f, 0.07274880f, -0.17838757f, 
    -0.23384708f, -0.09330085f, -0.07239930f, 0.06013726f, -0.02120850f, -0.09853774f, -0.07635438f, 0.09618821f, 
    -0.14244701f, 0.03541578f, 0.20279598f, -0.01097244f, -0.20023730f, -0.08881070f, 0.07822951f, -0.14244089f, 
    0.10617777f, -0.11419864f, 0.10287341f, 0.07053454f, 0.00187682f, -0.10763928f, -0.01905425f, 0.14329664f, 
    -0.08862577f, -0.35303670f, -0.24397129f, -0.42098767f, 0.00077565f, -0.08662001f, 0.09940360f, -0.04286970f, 
    -0.08996140f, -0.16571338f, 0.06626251f, 0.10611158f, 0.07688639f, 0.11507981f, -0.01407606f, 0.01977315f, 
    -0.04378562f, -0.14679638f, -0.04954838f, -0.09564574f, -0.02653093f, -0.03000333f, -0.04504600f, -0.07237743f, 
    -0.18483336f, -0.22960408f, -0.08324908f, 0.03699768f, 0.10577791f, -0.00961370f, 0.00693930f, -0.08202451f, 
    -0.04450319f, 0.01393520f, 0.05088892f, 0.04348977f, 0.05094496f, -0.32377979f, 0.03493432f, 0.00972984f, 
    -0.03326759f, -0.01714974f, -0.03590953f, 0.07979321f, -0.02660329f, -0.02339260f, -0.00678941f, 0.00753919f, 
    -0.08474612f, -0.05118124f, -0.03847340f, -0.28296411f, 0.13388081f, 0.03742635f, -0.00649757f, -0.00205284f, 
    0.10851784f, 0.00234436f, -0.00972040f, 0.01552421f, -0.25701562f, 0.13910447f, -0.02887226f, -0.12998587f, 
    0.15097941f, 0.07588562f, 0.00614404f, -0.01724388f, -0.03378175f, 0.06713524f, -0.04790610f, 0.05139720f, 
    0.10656516f, -0.09897245f, -0.00968715f, -0.03410231f, -0.04900109f, -0.13781062f, -0.10995969f, 0.07827389f, 
    0.08143169f, 0.05550792f, -0.00128998f, 0.16950035f, 0.29918757f, -0.03535281f, 0.06375703f, 0.07932851f, 
    -0.04281020f, 0.00442753f, 0.05400208f, 0.07084895f, -0.03127154f, -0.11962929f, 0.07205250f, 0.10765585f, 
    0.29583779f, 0.12507981f, 0.03184228f, 0.03250032f, 0.02282521f, 0.08751824f, -0.04593947f, 0.10755464f, 
    -0.01385893f, -0.00062314f, -0.06633706f, -0.06004497f, 0.08719137f, -0.21216480f, -0.02634054f, -0.12493195f, 
    0.05176366f, 0.05989967f, -0.12596826f, -0.01754585f, -0.01153637f, -0.02939862f, 0.00420962f, 0.04982933f, 
    0.05482160f, 0.12228438f, 0.16914582f, 0.04607524f, 0.13157648f, 0.03648422f, 0.23052542f, 0.05156632f, 
    0.04045238f, 0.19978194f, 0.07787895f, 0.00118139f, -0.12469419f, -0.02707148f, 0.16705245f, -0.12229225f, 
    0.10151619f, 0.01772898f, -0.11749705f, 0.08183466f, -0.02590450f, 0.00631731f, 0.06037811f, 0.03659716f, 
    -0.24176744f, 0.22711453f, -0.02849596f, -0.08341873f, 0.13653150f, 0.03075479f, 0.06070082f, -0.08985090f, 
    0.10501185f, -0.02648954f, -0.05055298f, 0.07432845f, -0.19855626f, 0.18017273f, -0.10441069f, -0.08400319f, 
    0.01361170f, 0.01507194f, -0.02695103f, 0.06924027f, -0.01929754f, 0.07322426f, -0.06383943f, -0.05893533f, 
    0.06186139f, -0.00933208f, -0.06808278f, 0.16449904f, 0.08924358f, -0.04970530f, 0.06620101f, -0.00963099f, 
    0.03362046f, -0.06826058f, 0.10099956f, 0.03625569f, -0.05989207f, 0.14052609f, 0.08037988f, -0.09298696f, 
    0.05423445f, 0.05253786f, 0.09644423f, -0.02175256f, 0.05905138f, 0.06288774f, 0.04583740f, -0.01946611f, 
    0.12416903f, -0.07762269f, 0.14172225f, 0.27662778f, 0.01993692f, 0.01667438f, -0.06596181f, 0.03942316f, 
    0.04969683f, 0.00187582f, 0.05917420f, 0.02405490f, -0.06200805f, 0.24168797f, -0.08950419f, -0.05314388f, 
    -0.07874791f, -0.02519362f, 0.08768149f, -0.05361790f, 0.04878248f, 0.02468509f, -0.01991011f, -0.09247558f, 
    -0.07268416f, -0.02603796f, -0.05198238f, -0.03225821f, 0.05380594f, 0.01222172f, 0.07048485f, -0.03648624f, 
    0.03312080f, -0.01677464f, 0.05551910f, -0.05378911f, 0.04294883f, -0.04963024f, 0.03488928f, -0.02092503f, 
    -0.04749311f, 0.05236435f, 0.00913948f, -0.00754637f, -0.01220524f, -0.02668063f, -0.04269698f, -0.02277965f, 
    0.04980936f, -0.04922179f, 0.01858416f, 0.05821251f, 0.00587335f, -0.04088097f, -0.03009859f, -0.00643326f, 
    -0.06194888f, -0.03454552f, -0.03106316f, -0.03784595f, -0.01933438f, -0.07763314f, 0.02704182f, 0.05260898f, 
    -0.04834302f, -0.00368369f, 0.00319919f, -0.07078200f, -0.02693099f, 0.05442740f, 0.00165051f, 0.01265887f, 
    -0.06363694f, -0.07013959f, 0.06474693f, -0.03815319f, 0.00749651f, 0.03703055f, 0.04615225f, 0.05044029f, 
    -0.00471867f, -0.03822529f, -0.05873742f, -0.03104133f, -0.04441756f, 0.07633001f, -0.01457788f, -0.07159081f, 
    0.02735948f, 0.02122123f, -0.00820856f, 0.03014801f, -0.02379296f, -0.07073597f, -0.06218726f, 0.03449487f, 
    -0.03932872f, 0.01546441f, -0.01285626f, -0.05886468f, 0.05715587f, 0.01024290f, 0.06315996f, 0.04440429f, 
    -0.06215242f, 0.00830373f, -0.04047953f, -0.03359351f, -0.08627751f, 0.06972039f, 0.01850026f, -0.04949649f, 
    0.01464012f, -0.04390159f, -0.02348402f, -0.02633680f, 0.05575411f, 0.02522328f, 0.04680485f, 0.01924768f, 
    -0.04153896f, -0.03598175f, -0.01299859f, 0.03316687f, -0.05730235f, -0.05773296f, 0.00509519f, 0.02867718f, 
    0.02682531f, -0.04096562f, 0.00464220f, 0.04791655f, -0.05962830f, -0.08116738f, -0.04573758f, 0.01121215f, 
    -0.06547914f, -0.05166834f, 0.02394391f, 0.01188272f, -0.01039948f, 0.03679784f, 0.07000005f, -0.02340536f, 
    -0.08174318f, 0.01986398f, 0.02206304f, 0.00882116f, -0.03843483f, 0.06412365f, -0.06063997f, -0.00428799f, 
    0.06078349f, 0.03127549f, 0.07567461f, 0.01087904f, 0.01687555f, -0.01623935f, -0.04412300f, 0.00631204f, 
    -0.03659637f, -0.06607072f, -0.07954513f, -0.04638579f, -0.02615586f, -0.08322595f, 0.05605658f, -0.03969711f, 
    0.01543314f, 0.02285047f, -0.03735893f, -0.05661344f, -0.02961871f, -0.03755064f, -0.05529890f, -0.00415682f, 
    0.03340363f, -0.06382570f, -0.06800426f, -0.05877985f, 0.03798202f, 0.03099034f, 0.04330524f, 0.00165265f, 
    0.00746810f, 0.02132756f, 0.05393156f, -0.06196467f, 0.04947635f, -0.03524755f, -0.04840244f, 0.01608311f, 
    0.05753328f, -0.04871345f, -0.00832591f, -0.02277510f, -0.00282483f, 0.03948450f, -0.01667289f, 0.01740839f, 
    -0.06825509f, -0.07311231f, 0.05109910f, -0.03308851f, -0.03760554f, -0.05616062f, 0.01941504f, 0.04879389f, 
    0.02226660f, -0.06091177f, -0.06076248f, -0.03675555f, -0.03564756f, 0.02938311f, -0.05034296f, 0.04125832f, 
    -0.01362049f, 0.00092785f, 0.02472564f, 0.06013349f, 0.01345735f, -0.02049811f, -0.05871481f, 0.01462889f, 
    0.03904584f, 0.04703317f, -0.01274861f, 0.06401779f, 0.04129647f, -0.04781888f, 0.00752622f, 0.02354497f, 
    -0.04338107f, -0.03496895f, 0.01350370f, 0.01099545f, 0.01604590f, -0.04244578f, 0.00323079f, -0.02758403f, 
    0.03666499f, -0.04361423f, 0.03445138f, -0.01611942f, 0.05612319f, -0.01615000f, 0.04862615f, 0.02767297f, 
    -0.07254860f, -0.06760725f, -0.07656793f, -0.08097593f, -0.04762929f, 0.03537808f, 0.05512443f, -0.05867611f, 
    -0.01674524f, 0.01916367f, -0.06392891f, -0.04755086f, -0.08046139f, 0.03629956f, -0.04485162f, 0.03773707f, 
    -0.01153785f, -0.03577900f, -0.05582312f, 0.04372658f, -0.05583528f, 0.03454015f, 0.01370926f, 0.05381459f, 
    -0.02872606f, 0.03257031f, -0.05231749f, -0.03702914f, -0.02453719f, 0.05312134f, -0.01184180f, 0.00451663f, 
    -0.04517823f, -0.07798687f, -0.01020753f, -0.07357558f, -0.02984554f, 0.05858728f, -0.02615434f, -0.04584688f, 
    0.01485408f, 0.00166728f, -0.06000442f, 0.01439019f, -0.00659496f, -0.06049732f, 0.02355698f, 0.01689455f, 
    -0.07198793f, 0.05556690f, -0.02505708f, 0.04085358f, 0.06038756f, -0.07100199f, -0.00013960f, 0.00297775f, 
    0.00637146f, 0.04121313f, -0.04428223f, 0.01126327f, -0.07128902f, 0.00369023f, 0.05022121f, 0.00152219f, 
    -0.02305561f, -0.07784560f, -0.01268146f, 0.00900594f, 0.02379670f, 0.01615675f, -0.05910752f, -0.07058775f, 
    0.01870813f, 0.05233423f, 0.01644034f, -0.00344121f, -0.04555098f, -0.01477667f, -0.03363362f, -0.05255907f, 
    0.03138756f, -0.05715172f, -0.01862217f, -0.06328942f, -0.02600452f, -0.07157198f, -0.07524706f, -0.01041796f, 
    -0.05082281f, 0.05944452f, -0.05422094f, 0.00465235f, -0.05533004f, 0.05102484f, -0.02487376f, -0.06790618f, 
    -0.04063764f, 0.06126669f, -0.05290994f, 0.05722089f, -0.04942037f, 0.03852827f, 0.02455058f, 0.02040895f, 
    -0.06311810f, 0.01490116f, 0.01591890f, -0.07462051f, 0.03193402f, 0.02110233f, -0.05805219f, -0.05558547f, 
    -0.04151310f, 0.04595533f, 0.01278561f, -0.00287925f, 0.01234343f, -0.03572688f, -0.03062462f, -0.03112967f, 
    -0.02117440f, -0.03030888f, -0.00754718f, 0.01143171f, 0.01675230f, 0.05802629f, -0.02279335f, 0.02252773f, 
    -0.01602411f, 0.03745307f, 0.02755705f, -0.07900463f, -0.05749598f, 0.02391161f, 0.02675795f, -0.02220462f, 
    0.01422685f, 0.04784954f, -0.07618778f, -0.02993089f, -0.04911188f, -0.00627595f, -0.05352682f, -0.06017651f, 
    0.05412689f, -0.00906929f, -0.00751641f, -0.02277159f, 0.00282383f, -0.01975587f, -0.02198452f, 0.01133592f, 
    -0.05214905f, -0.05923912f, -0.02009357f, 0.03514210f, -0.01110280f, -0.04113553f, 0.01012380f, 0.02330851f, 
    -0.02611691f, -0.05961424f, 0.07241204f, -0.05954996f, -0.09434465f, -0.02736689f, -0.02366162f, -0.02158061f, 
    -0.06109391f, 0.04797922f, 0.03323097f, -0.06678487f, -0.06575950f, 0.18364295f, 0.03704320f, 0.05853563f, 
    0.06136436f, 0.13270326f, 0.01264703f, -0.09754274f, 0.14876230f, -0.01124636f, 0.07872111f, 0.02105623f, 
    -0.06764928f, -0.05158168f, -0.15570253f, 0.09157864f, 0.00940569f, -0.00538201f, -0.01693236f, -0.08928414f, 
    -0.05625443f, 0.07400405f, 0.08282293f, -0.03710902f, 0.34111384f, -0.30702090f, -0.11178490f, 0.25846177f, 
    -0.12920287f, -0.04617428f, 0.06199400f, 0.01166154f, 0.04824392f, 0.06838166f, -0.00047616f, -0.02348037f, 
    -0.12002330f, 0.07001501f, -0.23697406f, 0.23821680f, 0.12113640f, 0.06260946f, 0.05121446f, -0.00965980f, 
    -0.02655524f, -0.05851645f, -0.00955723f, -0.08454169f, -0.18943268f, -0.11096492f, 0.04549768f, -0.00628974f, 
    0.01859493f, 0.05938393f, -0.05598937f, -0.07524428f, 0.07100110f, 0.11277804f, -0.09065864f, 0.09287754f, 
    -0.27536088f, -0.14051676f, 0.04063745f, -0.06465039f, -0.04983008f, -0.02986413f, 0.12775552f, -0.14985202f, 
    0.01122554f, 0.07614557f, 0.00050486f, 0.06143118f, -0.12761685f, -0.19609758f, -0.21124294f, 0.00565984f, 
    -0.12737215f, 0.10185093f, 0.06570600f, -0.03705616f, 0.03224986f, 0.03126337f, 0.05445108f, 0.04131707f, 
    0.34108585f, -0.18215340f, -0.18221198f, -0.09270649f, -0.10217116f, -0.15481940f, -0.19462848f, 0.17004596f, 
    -0.01812645f, -0.06532261f, 0.03992810f, 0.07252172f, 0.11325557f, -0.18297882f, -0.00817617f, -0.11318181f, 
    -0.08687674f, 0.03749430f, 0.12637834f, 0.02009287f, 0.08137122f, 0.09341283f, -0.07391420f, 0.11945030f, 
    0.13522986f, -0.15916732f, -0.05444334f, 0.30050752f, 0.05754047f, -0.00490354f, -0.08365154f, 0.15593125f, 
    -0.00875434f, -0.02501970f, 0.10959350f, 0.10219045f, 0.11710288f, -0.07191610f, -0.07598227f, 0.15861852f, 
    -0.03019725f, 0.00688427f, 0.18949081f, -0.07813033f, -0.06664751f, 0.04176901f, 0.00834745f, 0.07273696f, 
    0.39491171f, 0.21400096f, 0.13823919f, -0.13255721f, -0.03314701f, -0.13333195f, 0.04248459f, 0.23009424f, 
    -0.03137380f, -0.05653511f, -0.03877819f, 0.02214564f, -0.11974328f, 0.07443860f, -0.06750049f, 0.26253802f, 
    0.04669529f, 0.08457229f, -0.07975821f, 0.04817316f, -0.10843765f, -0.02349874f, 0.01239007f, -0.09222056f, 
    0.07658615f, 0.14146349f, -0.05833160f, -0.20028280f, 0.13984904f, 0.21407019f, 0.09518335f, -0.02899992f, 
    0.13343029f, 0.03656760f, 0.00989676f, -0.02278820f, 0.21127339f, -0.05975267f, 0.02836814f, 0.15139547f, 
    0.12943196f, -0.03490496f, 0.14912111f, 0.15451463f, -0.02059815f, -0.05485705f, 0.13222694f, 0.06309171f, 
    0.01083813f, 0.02187535f, 0.04295401f, -0.03736830f, -0.02029183f, 0.03403312f, -0.08035232f, 0.04522946f, 
    0.01255297f, -0.06274403f, -0.02905342f, -0.00889737f, -0.04465821f, -0.06129517f, -0.01153140f, -0.07142395f, 
    0.03690323f, 0.04645297f, 0.03378033f, 0.00029197f, -0.07806494f, -0.05180416f, -0.04185328f, -0.02107912f, 
    0.01573163f, 0.05439870f, -0.02005563f, 0.05538414f, 0.04100888f, -0.03138368f, -0.07324100f, 0.02775554f, 
    0.00311326f, 0.01647379f, 0.00708170f, 0.02233201f, -0.00347059f, 0.05515708f, -0.01861780f, 0.03856151f, 
    0.01208037f, 0.02924677f, 0.01031146f, 0.02776114f, -0.07586463f, 0.05486564f, 0.03602333f, -0.07262955f, 
    -0.01513540f, -0.04095441f, -0.05813785f, 0.00818483f, 0.03419780f, 0.03966153f, -0.01341832f, -0.03520525f, 
    0.00529503f, -0.02532119f, -0.04227977f, 0.04802440f, 0.01615132f, -0.00997931f, 0.02052671f, -0.04310970f, 
    0.05173082f, -0.06821361f, 0.05764896f, 0.05421536f, 0.01574159f, 0.02399160f, -0.06529208f, -0.05338885f, 
    0.00291542f, 0.06139540f, -0.06448162f, 0.05516168f, 0.02268268f, -0.06846852f, -0.05589496f, 0.02361880f, 
    -0.00728531f, 0.02811319f, -0.02164235f, -0.03060478f, -0.03213141f, -0.04582814f, -0.03031547f, -0.04853838f, 
    -0.01466456f, -0.07885639f, 0.04193999f, 0.05121955f, -0.03986486f, -0.05075946f, 0.03938885f, 0.04066228f, 
    0.01712958f, -0.03579605f, -0.08540478f, 0.00948724f, -0.06789067f, 0.01012721f, -0.07885981f, 0.02764951f, 
    0.06160715f, -0.01850128f, 0.05184367f, 0.04235355f, -0.07342007f, 0.01678316f, 0.05195425f, -0.07620511f, 
    0.04190635f, -0.05095769f, -0.08067968f, -0.06219919f, -0.06378733f, -0.02126705f, -0.05508922f, -0.03772568f, 
    -0.03626417f, -0.00445990f, -0.07666416f, 0.05748926f, -0.04934190f, -0.01552848f, -0.01030603f, -0.05678467f, 
    0.02594057f, -0.07019651f, 0.01808869f, -0.07051224f, 0.01386331f, -0.00540535f, -0.02074749f, 0.00975630f, 
    -0.03236699f, 0.02884019f, -0.08151889f, 0.04801140f, -0.07740160f, -0.06386595f, -0.03603369f, -0.03490707f, 
    0.02918095f, 0.04252997f, -0.06929167f, -0.02642333f, -0.06278016f, 0.03234566f, -0.04932408f, 0.06109127f, 
    0.05210031f, 0.01082464f, -0.04364361f, -0.01821516f, 0.00046647f, 0.05354989f, 0.03482079f, 0.04072209f, 
    0.01980514f, 0.05069469f, -0.05286336f, -0.02498020f, -0.06497531f, -0.03841821f, -0.01038408f, -0.06326966f, 
    -0.00966971f, -0.03575550f, -0.06783418f, -0.04080066f, 0.04682618f, 0.00005645f, 0.03094984f, 0.05267646f, 
    -0.03421438f, 0.03234848f, -0.06767119f, -0.04129797f, 0.05074815f, -0.02019710f, -0.01882982f, -0.05648563f, 
    0.00953692f, 0.05990702f, -0.01994353f, -0.00484266f, -0.07797375f, 0.00747699f, -0.08151167f, -0.07103113f, 
    -0.08382940f, -0.05856765f, 0.13649003f, 0.01376735f, 0.08904450f, 0.01495821f, -0.04163722f, 0.03521432f, 
    0.06400038f, -0.09650387f, -0.00820710f, -0.00149546f, -0.01892741f, -0.05059943f, 0.07957818f, -0.02871719f, 
    -0.10182144f, -0.05857630f, 0.02606306f, -0.04020606f, -0.06530644f, -0.02824688f, 0.04796058f, 0.06474020f, 
    0.12671210f, -0.02734577f, 0.15050487f, -0.03311246f, 0.01385587f, -0.01328525f, 0.03686331f, 0.05946514f, 
    0.06169285f, -0.17129450f, -0.03584276f, -0.05546801f, 0.04582792f, 0.09833933f, 0.14976639f, -0.00175525f, 
    0.08927734f, 0.03251161f, -0.04273463f, -0.13977778f, -0.00156234f, 0.06940319f, -0.01103657f, 0.05536109f, 
    0.12366963f, -0.20784482f, -0.01133965f, 0.03369777f, -0.09287363f, 0.00908314f, -0.05958356f, -0.03588597f, 
    0.17873235f, 0.04857577f, -0.04750198f, 0.26215744f, 0.10945331f, 0.00076835f, 0.05155776f, 0.04018002f, 
    -0.09192276f, 0.00832363f, 0.06860877f, -0.04356288f, -0.06023241f, -0.03722912f, 0.00675139f, 0.00654875f, 
    0.31721422f, -0.15142938f, -0.03450842f, -0.24178310f, 0.21594632f, 0.03248701f, -0.17283967f, 0.13567992f, 
    0.02539122f, -0.08774296f, 0.12752062f, 0.04174180f, 0.11487395f, -0.20688875f, 0.11875244f, -0.03416947f, 
    0.19073951f, -0.14814684f, -0.06383039f, -0.04450780f, 0.04798198f, -0.10243230f, -0.03804767f, -0.05942170f, 
    -0.36354002f, 0.10791095f, -0.20469376f, 0.07388525f, 0.18504436f, 0.23071715f, 0.15575477f, 0.05957216f, 
    0.05858248f, 0.15836349f, -0.03625208f, 0.17482778f, -0.10204829f, 0.10495332f, 0.20886973f, -0.31111148f, 
    0.01779987f, 0.02889595f, -0.01328349f, 0.01506446f, -0.10914172f, -0.10089885f, 0.08220839f, 0.14587420f, 
    0.03894346f, 0.16282174f, -0.01061643f, 0.03090857f, -0.01356553f, 0.14155166f, -0.01610089f, 0.00115036f, 
    0.05072582f, -0.02985755f, -0.00609369f, 0.04187639f, -0.53686255f, 0.12551476f, -0.19289836f, 0.07270527f, 
    -0.01734605f, 0.00475162f, -0.19323979f, 0.12005404f, -0.00628288f, -0.14279856f, -0.06519628f, -0.15934448f, 
    -0.23915179f, -0.13215593f, 0.01978659f, 0.06915632f, 0.09621584f, 0.02572733f, -0.04442285f, -0.05826290f, 
    0.07618640f, -0.06860711f, 0.08799593f, 0.00738624f, 0.08676033f, 0.00004846f, -0.04240897f, -0.11374549f, 
    0.00517643f, 0.01035276f, 0.13278207f, 0.08222315f, 0.12592867f, -0.07829706f, 0.13910809f, 0.11273323f, 
    -0.13337368f, 0.01605662f, 0.00111919f, 0.02953318f, 0.05491671f, 0.01552282f, 0.01445161f, 0.09485243f, 
    -0.06968413f, 0.08438774f, 0.09997237f, -0.00454292f, 0.27714232f, 0.13230515f, 0.16468866f, -0.08674270f, 
    -0.06756911f, 0.03870584f, -0.01288460f, -0.09226947f, 0.00817604f, 0.07316935f, -0.04592741f, -0.02408412f, 
    -0.08156922f, -0.03333377f, 0.02143493f, -0.04202886f, -0.03736736f, 0.00514774f, -0.06578146f, -0.01678076f, 
    -0.02634915f, 0.04690549f, 0.02178826f, -0.01794096f, -0.07055715f, 0.03011609f, -0.07012548f, -0.03723602f, 
    -0.02219084f, 0.02107633f, 0.05108578f, 0.05330658f, 0.00600033f, -0.07650176f, -0.00660124f, -0.01138331f, 
    0.01332778f, -0.03816573f, -0.06078104f, -0.05168263f, 0.03772355f, 0.03336837f, -0.07323466f, 0.05066037f, 
    -0.03146857f, -0.00367832f, 0.04117168f, -0.01262878f, 0.05396267f, -0.00496140f, 0.00240307f, 0.02706004f, 
    0.00470725f, -0.02147713f, 0.03280061f, -0.00659022f, -0.04290221f, -0.01669421f, -0.03231290f, 0.05108050f, 
    0.05920584f, -0.03850480f, -0.04836802f, 0.02389921f, -0.02907152f, -0.04994473f, 0.02592610f, -0.07566598f, 
    0.02516753f, -0.03918008f, -0.06644396f, -0.02102530f, 0.04612819f, 0.05777576f, 0.03469445f, 0.02079571f, 
    0.02921018f, -0.01843235f, -0.04908754f, -0.06561759f, 0.05675823f, -0.00469937f, 0.03058554f, -0.02509366f, 
    0.00683741f, -0.00158500f, -0.05865366f, 0.04812100f, 0.04053938f, 0.01039091f, 0.06378095f, 0.00819095f, 
    -0.02763779f, -0.05956965f, -0.01169662f, -0.00097446f, -0.01649829f, 0.01662570f, -0.05333494f, 0.05527463f, 
    0.03417746f, -0.00389918f, 0.03524709f, -0.02834314f, 0.05683454f, -0.02942517f, 0.03954691f, -0.05749739f, 
    -0.02674565f, 0.02909790f, -0.00904615f, -0.00629713f, -0.02370733f, -0.04038949f, 0.00405775f, -0.01987391f, 
    -0.07794878f, -0.02989807f, -0.06518570f, -0.06306317f, -0.06934862f, -0.01079887f, 0.07549646f, 0.00614819f, 
    -0.05105996f, -0.02277334f, 0.06797209f, -0.05827262f, -0.03815116f, 0.01488847f, 0.02872086f, -0.01793375f, 
    -0.04380880f, 0.06226858f, -0.03934367f, 0.03238254f, -0.00813103f, -0.03891135f, 0.04489589f, -0.01031579f, 
    0.01135629f, 0.00493413f, -0.05490546f, -0.00820038f, 0.01131020f, 0.03988757f, -0.05608752f, 0.03367609f, 
    0.01330346f, -0.02474084f, -0.06628168f, -0.03341600f, 0.05916243f, -0.05934067f, 0.04795990f, -0.06438960f, 
    -0.01117158f, 0.04363585f, -0.04113384f, 0.05262445f, -0.05495753f, 0.00003612f, -0.01247739f, -0.04599633f, 
    0.02010110f, -0.03842712f, 0.03736147f, 0.00618774f, -0.01504340f, -0.01439483f, -0.01186333f, 0.05484930f, 
    -0.07057749f, 0.00098797f, 0.03377847f, -0.01460361f, -0.05433215f, -0.03711444f, -0.05226391f, 0.02713038f, 
    -0.06855436f, 0.00956158f, -0.03778967f, 0.04960678f, -0.01701767f, 0.05912250f, 0.00227234f, -0.05906396f, 
    -0.06915995f, 0.05255560f, 0.01394227f, 0.05178943f, -0.00642674f, 0.01283004f, 0.04398268f, 0.01710000f, 
    -0.04875225f, 0.01023048f, -0.01662755f, -0.07640357f, -0.03978774f, 0.01035770f, -0.07031644f, 0.00850081f, 
    -0.07702143f, -0.01100567f, 0.04224596f, -0.17524374f, 0.14573653f, 0.11811189f, 0.12260255f, -0.00541123f, 
    -0.02765853f, -0.06988070f, -0.07073227f, -0.03191275f, -0.24574105f, -0.06131462f, 0.05007941f, -0.06615223f, 
    0.16692103f, 0.20945862f, 0.05300706f, 0.03305335f, -0.00450278f, 0.04257171f, 0.02284133f, -0.12746108f, 
    0.13430512f, 0.38976943f, 0.03174734f, -0.11995030f, 0.11893026f, 0.13383462f, 0.06815907f, -0.06382489f, 
    -0.02107458f, -0.01019376f, -0.02942849f, -0.08303958f, 0.22626257f, -0.06236382f, -0.18491535f, -0.00332054f, 
    0.11707275f, 0.07190783f, 0.06870577f, 0.00585761f, 0.01369014f, 0.08684724f, 0.21109636f, 0.01363510f, 
    -0.02107676f, -0.40823612f, -0.26275635f, -0.00540795f, 0.08453950f, -0.04941900f, -0.00292471f, -0.01691078f, 
    0.17800772f, -0.18155475f, 0.01104990f, 0.13230678f, -0.21840455f, -0.07280488f, -0.02751269f, -0.20248398f, 
    0.06002900f, 0.22306341f, 0.20029327f, -0.06324404f, 0.05368660f, 0.01385770f, -0.05274601f, 0.00634656f, 
    -0.22608972f, -0.20623074f, 0.07517812f, -0.14317361f, 0.01242702f, -0.09287595f, 0.07242449f, 0.06809773f, 
    0.05915391f, -0.05594988f, -0.10951530f, -0.00450889f, -0.20100169f, -0.25661835f, -0.03628754f, 0.02459094f, 
    0.10483222f, 0.17649195f, 0.08532196f, -0.02741178f, 0.00607236f, -0.16883235f, -0.04726276f, 0.06016511f, 
    0.32161373f, -0.24611819f, 0.03611807f, 0.04488578f, -0.17826362f, -0.20071748f, -0.00606526f, -0.00443852f, 
    0.00264885f, -0.01183911f, 0.23920119f, 0.13580133f, -0.00960315f, 0.09963763f, 0.28229168f, -0.42076603f, 
    -0.02133265f, 0.02382465f, 0.08628295f, 0.03663736f, -0.05752562f, 0.11278623f, 0.15593852f, 0.00972982f, 
    0.11183612f, -0.06254953f, -0.00896961f, 0.00381374f, 0.13671362f, -0.00618758f, 0.06040319f, 0.12932420f, 
    -0.03067693f, 0.01143764f, 0.00583575f, 0.08253859f, 0.56655008f, -0.19173028f, -0.07794625f, 0.00036820f, 
    -0.03003930f, 0.02552861f, -0.08895534f, 0.01727839f, 0.03274826f, 0.01958068f, 0.02466503f, -0.05461129f, 
    0.29461554f, 0.14401811f, -0.01446920f, -0.09835198f, -0.09452251f, -0.21201794f, 0.09074159f, 0.09457095f, 
    0.00638439f, 0.05497241f, 0.08731840f, -0.06000384f, -0.20195030f, -0.08014709f, 0.07478068f, 0.27448228f, 
    0.04713667f, -0.02087699f, 0.00465760f, 0.03173407f, -0.04656722f, 0.01136347f, 0.07720605f, -0.03403904f, 
    -0.08910570f, 0.03353755f, -0.06975714f, -0.12653182f, 0.03062982f, -0.01861293f, -0.02833270f, 0.02687101f, 
    0.05868479f, -0.11338297f, -0.02570531f, 0.12386535f, 0.20970991f, 0.12379283f, -0.10945510f, -0.01977929f, 
    0.08403909f, 0.00764935f, 0.03703735f, 0.07782611f, 0.04096992f, -0.03581860f, -0.02952806f, 0.02222744f, 
    -0.22226672f, 0.00586524f, -0.13839628f, 0.01238623f, -0.00308128f, 0.00195089f, 0.07062576f, 0.01654837f, 
    0.09832757f, 0.11196128f, -0.03554436f, 0.08903217f, 0.02251055f, -0.05638126f, 0.02740757f, 0.20921333f, 
    -0.02862346f, 0.06699118f, 0.04160677f, 0.06433001f, 0.04082005f, 0.07480957f, 0.01185496f, -0.03892001f, 
    -0.13886611f, -0.03902285f, -0.13522664f, -0.09306141f, 0.00352351f, -0.01076855f, -0.08886968f, -0.02630138f, 
    0.06910802f, 0.00057961f, -0.03598352f, 0.10587874f, -0.11589276f, -0.06147488f, -0.05054301f, -0.14486384f, 
    -0.00332243f, 0.08563556f, 0.02148552f, 0.03065043f, -0.05962449f, -0.12314447f, -0.04840543f, -0.01494454f, 
    -0.25326633f, 0.24301490f, 0.02438060f, 0.09450821f, 0.05636523f, -0.07258310f, 0.04089968f, 0.07662068f, 
    -0.02183799f, 0.04515466f, -0.08667574f, 0.06941652f, 0.12598075f, -0.01197747f, 0.13352460f, 0.12519431f, 
    0.04821781f, -0.01015686f, -0.03150358f, -0.03504547f, 0.18515909f, 0.03991975f, -0.00611171f, 0.03070643f, 
    0.00800251f, 0.12449796f, -0.00027517f, 0.18428610f, -0.02577124f, 0.05796548f, 0.05365377f, -0.01513420f, 
    -0.08487803f, -0.01344108f, -0.01292939f, 0.08676605f, 0.07086408f, -0.00113803f, -0.04573100f, -0.18003771f, 
    0.01764408f, 0.14051838f, 0.06289988f, 0.06739169f, 0.04154713f, 0.10135873f, 0.10538971f, 0.11939787f, 
    -0.06994102f, 0.31772360f, 0.19727777f, -0.01371878f, 0.00844901f, -0.00572042f, 0.06651761f, 0.00792118f, 
    -0.08592325f, -0.05420806f, 0.05064887f, -0.20568974f, -0.03082849f, -0.01942022f, -0.15163231f, 0.32446206f, 
    0.06741851f, 0.03058430f, 0.03410189f, -0.03272725f, 0.11298979f, -0.07850678f, -0.02975285f, -0.03603020f, 
    -0.03459681f, 0.05244161f, 0.10997991f, -0.24010333f, -0.07429329f, -0.04053448f, 0.01517206f, -0.03442344f, 
    -0.05208311f, 0.10732906f, 0.04245499f, 0.04827452f, -0.13613738f, 0.16032061f, 0.17614922f, -0.07569428f, 
    0.12212621f, -0.07990853f, 0.05136493f, 0.00764821f, 0.04187787f, 0.08297854f, -0.03426672f, -0.00339995f, 
    0.08682609f, -0.02563744f, 0.04826662f, 0.01548195f, 0.02998772f, 0.03251058f, -0.11786572f, -0.01785592f, 
    0.03707429f, -0.02282255f, 0.03526957f, -0.02489476f, -0.05031747f, 0.21576563f, 0.03521766f, -0.07171708f, 
    0.09026809f, -0.06182109f, 0.00001001f, 0.02439524f, 0.00166561f, 0.12286734f, -0.10999595f, 0.07024486f, 
    0.23537280f, -0.06597342f, 0.21679936f, 0.14780751f, 0.00584304f, -0.00462882f, 0.11925769f, 0.01947110f, 
    0.07957290f, 0.03284944f, 0.12568134f, -0.06338254f, -0.27147001f, 0.04659229f, -0.08873014f, 0.11839191f, 
    -0.03514549f, -0.04264307f, 0.08406384f, 0.06792202f, -0.05833226f, 0.03975808f, 0.06321724f, 0.10357472f, 
    0.28628728f, -0.11036458f, -0.22800709f, 0.25005475f, 0.09810383f, -0.08294039f, 0.07608368f, -0.16859347f, 
    -0.04550833f, 0.08150546f, 0.02048682f, 0.01546315f, 0.23795347f, 0.14159483f, -0.17093505f, 0.01400718f, 
    0.10936631f, 0.16115208f, -0.04549642f, 0.15312758f, 0.11163318f, 0.07285233f, 0.02594306f, 0.05174241f, 
    0.01058765f, 0.08120713f, -0.09496259f, 0.15366104f, 0.01092766f, 0.07132707f, -0.09413251f, 0.07979910f, 
    -0.03337724f, -0.05059576f, 0.02408439f, 0.05718794f, -0.29752091f, 0.07513068f, -0.15053652f, -0.08251938f, 
    0.06017607f, -0.16015795f, -0.01817369f, 0.06076863f, 0.01581277f, -0.03719475f, -0.06357471f, 0.16858110f, 
    -0.09896386f, 0.28336489f, 0.02558682f, 0.03116793f, 0.13041207f, -0.06149372f, 0.04681352f, 0.04726661f, 
    -0.14278680f, -0.05139858f, 0.04115039f, -0.10842101f, 0.11058657f, 0.01737677f, -0.02905995f, -0.05394572f, 
    0.06650038f, -0.06737897f, -0.08543707f, 0.01645227f, 0.18297972f, 0.08336043f, 0.07502705f, -0.05006314f, 
    -0.33608460f, 0.08327091f, -0.02323387f, 0.00544732f, -0.10511627f, 0.03978033f, -0.07148389f, -0.05856356f, 
    0.03727200f, -0.03119388f, -0.07214818f, -0.13806552f, -0.00325179f, 0.23511170f, -0.14083204f, 0.09704463f, 
    -0.08698261f, 0.04032340f, 0.02251607f, 0.06584646f, -0.04778653f, 0.08714931f, 0.10294755f, 0.08183073f, 
    0.17860492f, -0.09244827f, 0.30825633f, -0.03646300f, -0.04086044f, -0.04879086f, 0.08784238f, -0.05017563f, 
    -0.00278466f, -0.02723786f, 0.03912913f, -0.15046066f, 0.34440127f, 0.09846395f, -0.32654437f, 0.30837727f, 
    0.07927551f, -0.03841267f, -0.11267552f, 0.11062204f, 0.15553842f, 0.08733372f, -0.04220778f, 0.00111646f, 
    0.05036478f, -0.20521392f, 0.19128796f, -0.19437990f, 0.09261021f, -0.07263341f, 0.04127156f, 0.08272655f, 
    0.02704852f, -0.02290744f, 0.03991179f, 0.06885494f, 0.27949879f, -0.10981529f, -0.00693127f, -0.15860164f, 
    0.09088834f, 0.07129022f, 0.10809636f, 0.05287328f, 0.16245024f, -0.04598204f, 0.09885673f, 0.12204372f, 
    -0.09613445f, -0.15781794f, -0.05527175f, -0.07123830f, -0.10535797f, 0.03919756f, 0.05457952f, -0.10687464f, 
    -0.07017933f, -0.04346430f, 0.07153457f, -0.08297960f, -0.02983414f, 0.11629574f, -0.03284303f, -0.06643818f, 
    0.14052777f, 0.00655849f, 0.06813090f, 0.08282851f, -0.06223847f, 0.17784816f, -0.10712918f, 0.08119634f, 
    0.15789866f, -0.03625856f, -0.16614258f, 0.09128954f, -0.05186631f, -0.01700210f, 0.13610908f, -0.03500199f, 
    0.13038443f, -0.06966619f, 0.06457270f, 0.02810419f, -0.18583484f, -0.07717615f, 0.02122814f, -0.03455230f, 
    0.00292910f, 0.05261958f, -0.00057877f, 0.00845812f, 0.02939813f, 0.01431722f, 0.01268943f, 0.11481332f, 
    -0.03968725f, -0.02637069f, 0.00887575f, 0.04717980f, -0.05342244f, -0.00685722f, 0.00960411f, -0.03038023f, 
    -0.02810995f, -0.06312452f, 0.01049703f, 0.05821192f, -0.05223192f, -0.03444977f, 0.03135524f, -0.05540899f, 
    -0.09885015f, 0.02428172f, -0.04171339f, -0.07880390f, -0.09218535f, -0.01687689f, -0.07257393f, -0.01216691f, 
    -0.08939793f, -0.09392162f, 0.02528662f, 0.01649192f, 0.00655417f, -0.00983891f, 0.02114099f, -0.04418837f, 
    0.02060993f, -0.04467525f, -0.00960927f, -0.04974910f, -0.05522997f, -0.07363577f, 0.06268073f, 0.05843700f, 
    -0.07043824f, 0.00135916f, -0.06867199f, 0.05497823f, 0.03289376f, 0.02688742f, -0.03548477f, -0.06309794f, 
    -0.00239579f, -0.00975278f, -0.01645155f, -0.01932041f, -0.10145129f, 0.02559059f, -0.06376599f, -0.04232356f, 
    -0.02184702f, -0.07375161f, -0.07442106f, -0.02426037f, -0.04448677f, -0.11232776f, -0.02167186f, 0.03948284f, 
    -0.09271692f, -0.00190131f, 0.03492012f, 0.01949330f, 0.00574002f, -0.02282477f, -0.09714606f, -0.06646639f, 
    0.01358068f, -0.00019604f, -0.07822585f, -0.07513499f, 0.01591419f, 0.04456218f, -0.03612694f, -0.05516932f, 
    -0.04466611f, -0.05512140f, -0.01071633f, -0.01921000f, -0.07884826f, -0.05971975f, -0.08118300f, -0.06051894f, 
    -0.08135244f, -0.04440301f, 0.01094194f, -0.10103401f, -0.07861018f, -0.01940021f, -0.05105885f, -0.05199415f, 
    -0.02277237f, 0.04354428f, 0.00137699f, -0.03051735f, -0.02989948f, -0.02425074f, 0.02472685f, -0.02850828f, 
    -0.03389904f, -0.07920741f, 0.03887962f, -0.03335447f, -0.02051184f, -0.06320451f, -0.03371628f, -0.01909691f, 
    -0.07887989f, -0.06308797f, 0.03799179f, -0.03968544f, 0.04939819f, 0.03224981f, -0.06144658f, -0.01617104f, 
    -0.07928597f, -0.01056989f, -0.05925585f, -0.01173994f, -0.07586645f, -0.05791805f, -0.09943939f, -0.06800120f, 
    -0.07687427f, 0.03394589f, 0.03003203f, -0.02332968f, -0.06972790f, -0.00191715f, -0.06757820f, -0.01472483f, 
    0.00180300f, -0.04059311f, -0.06028309f, -0.07863567f, -0.08906709f, -0.06573328f, 0.01951028f, 0.04282660f, 
    -0.03906468f, -0.08756188f, -0.02514642f, -0.04097876f, 0.03199143f, 0.02890315f, -0.05732697f, -0.01071336f, 
    -0.07009857f, -0.04673556f, -0.07354663f, -0.10037505f, -0.02429185f, -0.01558607f, 0.02788521f, 0.01835108f, 
    0.01934857f, 0.05091950f, -0.08084612f, 0.01353516f, -0.03887657f, -0.08675569f, -0.06736990f, -0.01979392f, 
    0.00121217f, -0.09378023f, -0.01585784f, -0.08414424f, 0.03625340f, -0.02876485f, 0.02019677f, -0.04576728f, 
    -0.02290384f, -0.07740286f, -0.08298289f, 0.00630092f, -0.09938949f, 0.01304818f, 0.04508091f, 0.03131590f, 
    0.00608410f, 0.03485143f, -0.05481233f, -0.08208095f, -0.09632536f, 0.04841736f, 0.03522943f, 0.00527728f, 
    0.37183750f, 0.14247985f, -0.13813148f, 0.09070325f, -0.05085499f, 0.01194486f, 0.03619068f, 0.01688393f, 
    0.06252667f, 0.03750286f, 0.02485284f, 0.00267775f, 0.22594261f, 0.21058953f, -0.10005882f, -0.13251901f, 
    0.16934049f, -0.10177638f, -0.11272760f, 0.11968648f, 0.13623054f, 0.04873603f, -0.04392553f, 0.07348780f, 
    0.20868836f, -0.12102488f, -0.03041023f, 0.09808514f, 0.01693565f, 0.02180488f, -0.05249046f, 0.04654320f, 
    -0.08722832f, 0.00656891f, 0.13019437f, -0.03293969f, -0.23235114f, 0.11645962f, 0.11468011f, 0.26331884f, 
    0.01321367f, -0.01368078f, -0.09488358f, -0.02107685f, 0.00490595f, 0.10402038f, -0.10746082f, 0.02263485f, 
    0.07224055f, -0.10609007f, 0.05935843f, 0.09116818f, 0.04898806f, -0.08360079f, -0.01355885f, 0.01458978f, 
    -0.07015612f, 0.07402927f, -0.11625507f, -0.08734971f, 0.09259143f, -0.14936411f, 0.03639557f, -0.03191030f, 
    0.13201575f, -0.08903638f, -0.04684485f, -0.03399942f, 0.05354329f, 0.06373838f, -0.12801725f, -0.07466272f, 
    0.04058430f, 0.33542144f, -0.03176713f, -0.11841962f, -0.03897261f, 0.01396833f, 0.04356652f, -0.01036014f, 
    0.01505358f, 0.06907371f, 0.04732035f, -0.07542861f, -0.10308965f, 0.28316909f, -0.03701989f, 0.02183409f, 
    0.00978926f, -0.04555448f, -0.01779239f, 0.05704382f, -0.05572914f, 0.01072949f, 0.08515683f, -0.06011854f, 
    0.04242880f, 0.02042861f, 0.17891113f, -0.05070014f, -0.01857102f, 0.07324708f, 0.06054250f, 0.01819640f, 
    -0.07054815f, -0.06760655f, -0.09422199f, -0.01602159f, -0.01493602f, 0.26052982f, -0.23697175f, 0.08541779f, 
    0.05494541f, -0.05396775f, -0.29350716f, -0.03371261f, 0.15562819f, 0.03355957f, 0.05966141f, 0.09504911f, 
    0.03275976f, -0.04482581f, 0.01902959f, 0.12002071f, 0.03481506f, 0.05814604f, 0.11533367f, 0.02706775f, 
    0.08816196f, -0.07578176f, 0.06216313f, 0.03446778f, 0.04455550f, 0.06064506f, 0.11044961f, -0.05914838f, 
    0.07476863f, -0.04549754f, 0.02745962f, 0.09250800f, 0.07613647f, -0.01077453f, 0.06826773f, 0.08006117f, 
    -0.12856250f, -0.09735976f, 0.20231187f, -0.06563713f, 0.02649737f, 0.08422194f, 0.07185843f, -0.13390099f, 
    -0.05651912f, -0.05491289f, -0.00130300f, 0.07216773f, -0.03871523f, -0.02978961f, -0.20373078f, -0.02385030f, 
    0.00629000f, 0.05503147f, 0.04033510f, -0.04597823f, 0.02013721f, 0.05979765f, 0.03285358f, 0.06609042f, 
    -0.22845837f, -0.05444273f, -0.19343023f, -0.02461428f, -0.08317973f, 0.04406746f, 0.09743242f, -0.06882174f, 
    0.06050109f, -0.01210022f, -0.06604600f, -0.11352949f, 0.11163279f, -0.00716012f, 0.11601494f, 0.04084082f, 
    -0.08005919f, 0.02633559f, 0.04673998f, 0.04622836f, -0.00676372f, 0.04985350f, -0.02242600f, 0.16748191f, 
    -0.03991205f, 0.17412266f, 0.11577036f, -0.21190339f, 0.10018368f, -0.04623062f, -0.07353318f, -0.01675354f, 
    0.15875785f, 0.12528403f, -0.07386564f, -0.03884736f, -0.01022806f, 0.07239427f, 0.06113520f, -0.40211201f, 
    0.08604980f, 0.05812680f, -0.08965670f, -0.09000145f, 0.04442964f, -0.03494388f, -0.03151829f, 0.04823319f, 
    -0.27926758f, 0.04487513f, -0.01403429f, -0.06253177f, -0.03937247f, -0.00012020f, -0.08352210f, -0.10063647f, 
    0.01251040f, 0.09563766f, 0.08439878f, -0.00091637f, -0.20617776f, -0.13929793f, -0.13603333f, 0.05700210f, 
    -0.04831411f, -0.05166871f, -0.04596027f, 0.03239878f, 0.06208363f, 0.02704711f, 0.15865903f, 0.10987432f, 
    0.08622192f, -0.16509990f, 0.07661752f, -0.26425490f, -0.11260035f, -0.01390627f, -0.03001040f, 0.17488222f, 
    -0.00227906f, 0.06155668f, 0.02834763f, -0.14499287f, 0.00389022f, 0.04143145f, 0.18453151f, -0.17210203f, 
    0.16928451f, -0.09519665f, -0.11348204f, -0.10703795f, 0.02722284f, -0.00432406f, 0.02030504f, -0.11370004f, 
    -0.14772156f, 0.08678671f, 0.16908565f, 0.05932331f, 0.04826775f, 0.15195365f, -0.02762411f, -0.06129998f, 
    -0.06683939f, -0.08944675f, 0.18843330f, 0.05186432f, -0.17948432f, 0.27273238f, 0.10650721f, -0.21728997f, 
    -0.07959592f, 0.01071713f, -0.08315838f, -0.00913657f, -0.06222019f, 0.00684630f, 0.11943205f, -0.03314875f, 
    0.15964797f, -0.12847269f, 0.07740460f, 0.06330768f, 0.02786373f, 0.13220671f, -0.04902947f, 0.10117307f, 
    0.06357941f, -0.04986518f, 0.05146703f, 0.16261406f, 0.03086829f, -0.16348267f, 0.10520183f, 0.25770143f, 
    -0.03762504f, 0.05743405f, -0.08432936f, -0.00399437f, -0.00480092f, 0.14072981f, 0.03875438f, -0.06394812f, 
    -0.25011733f, -0.05129419f, -0.03818450f, -0.03785009f, 0.15648083f, -0.08640982f, -0.16037017f, 0.01414211f, 
    -0.00880220f, 0.03482350f, 0.14384636f, -0.04824179f, 0.31164321f, -0.12741989f, -0.08357774f, 0.02409924f, 
    0.03630637f, 0.10958076f, 0.08195648f, -0.24302283f, 0.09419172f, -0.10176863f, 0.12595598f, 0.03097371f, 
    -0.02635111f, 0.17226438f, 0.16063093f, 0.40397519f, 0.08719138f, 0.14338937f, 0.19379890f, 0.00138007f, 
    -0.19882923f, 0.05849265f, -0.07093107f, 0.14804654f, 0.07962303f, -0.02569238f, 0.03712014f, -0.21514013f, 
    -0.04450731f, 0.00536285f, -0.00559586f, -0.07078271f, -0.05057397f, -0.10341826f, 0.04083290f, -0.02848530f, 
    0.14841078f, 0.04615600f, -0.00322880f, 0.10921348f, 0.12706730f, 0.02043122f, 0.15177117f, -0.07309780f, 
    -0.05146949f, -0.09389668f, -0.13077348f, 0.04795789f, -0.15910283f, -0.26820111f, 0.03844084f, 0.08082607f, 
    0.07137498f, 0.08071860f, -0.07699323f, 0.03193809f, 0.07428505f, -0.00693579f, -0.00300651f, 0.11296237f, 
    0.07267970f, 0.22343385f, 0.04834319f, 0.12874667f, 0.18544836f, 0.06861366f, 0.08711810f, -0.05059552f, 
    0.01387099f, -0.03538084f, 0.00717288f, -0.00165707f, 0.01022100f, -0.11945097f, 0.10640592f, 0.11748141f, 
    -0.11907978f, -0.02045331f, -0.00516195f, 0.05547937f, -0.05617396f, -0.00809678f, -0.00703587f, 0.01050660f, 
    0.08501170f, 0.15975070f, -0.00612947f, -0.03735686f, -0.03977502f, -0.02554456f, -0.11135387f, 0.09389491f, 
    -0.01949090f, -0.03163968f, -0.00390214f, 0.02519352f, -0.26060241f, 0.11380433f, 0.00651981f, -0.27972531f, 
    -0.01100109f, 0.10461044f, -0.00692257f, 0.05874763f, 0.02267279f, -0.15191653f, 0.02677378f, -0.05482928f, 
    0.09513012f, 0.05910878f, 0.29857066f, -0.16709712f, -0.02983783f, -0.09197015f, 0.07936155f, 0.13636403f, 
    -0.12179583f, -0.00797451f, 0.08204842f, 0.09745985f, 0.12305270f, 0.16771261f, 0.04854201f, 0.02930944f, 
    -0.10601075f, 0.04851987f, 0.02916173f, 0.04748921f, 0.09667584f, -0.17200249f, 0.03548611f, -0.12638308f, 
    0.12078317f, 0.10442364f, -0.16746204f, 0.23161460f, -0.10134266f, 0.03183154f, 0.05313727f, 0.06727307f, 
    0.02716944f, 0.05758495f, -0.08015322f, -0.06350760f, 0.23989818f, 0.30837652f, 0.22585844f, 0.03310598f, 
    -0.07382920f, 0.08429848f, 0.05268901f, 0.06092415f, 0.04064484f, 0.10142164f, 0.08848489f, 0.12851313f, 
    -0.34810564f, 0.12194183f, 0.16248389f, 0.01766663f, 0.05132993f, 0.01247398f, 0.03986039f, -0.16770200f, 
    -0.12156133f, -0.05303127f, 0.00023044f, -0.07740463f, 0.00751425f, -0.01473888f, -0.14388831f, 0.43811664f, 
    0.17648773f, -0.03626910f, 0.13462922f, -0.01669187f, 0.15419540f, 0.08013593f, -0.08770384f, -0.19865964f, 
    -0.16491729f, 0.13534288f, 0.11031730f, -0.34531814f, -0.07902581f, -0.02349688f, -0.02336960f, -0.12090821f, 
    -0.07013869f, -0.06929498f, -0.13056865f, -0.04523886f, -0.26885787f, 0.07014827f, -0.02190199f, -0.11415374f, 
    0.15594427f, -0.05597671f, 0.02699301f, 0.00728138f, -0.03540390f, 0.11889619f, 0.10454115f, -0.12565149f, 
    -0.17816335f, -0.14766987f, -0.13759345f, 0.18413596f, 0.09538305f, 0.03601973f, 0.00207900f, -0.17709124f, 
    0.12160897f, 0.14156815f, -0.03418494f, 0.03629155f, 0.17480595f, -0.00471317f, 0.12284238f, -0.21076903f, 
    -0.07730975f, 0.04988779f, 0.04618021f, -0.06035306f, -0.02333062f, 0.05244487f, -0.10877091f, 0.05432085f, 
    0.15215872f, -0.10448751f, 0.13638441f, 0.07928526f, -0.06734847f, 0.01535873f, -0.00715662f, 0.17676871f, 
    -0.06615778f, 0.00419582f, -0.03288822f, 0.07337381f, -0.34836048f, -0.02315924f, -0.04203549f, -0.01947046f, 
    -0.12373514f, -0.01544098f, 0.07245283f, -0.04779896f, 0.01335661f, 0.01477057f, -0.04515131f, 0.05315219f, 
    -0.02639774f, 0.00169851f, 0.04816262f, -0.03383991f, 0.02437080f, 0.00786829f, 0.00191449f, -0.07911127f, 
    -0.06634415f, -0.04629495f, -0.00646351f, -0.06787924f, -0.05647502f, -0.04197399f, 0.05595558f, -0.05680183f, 
    -0.03157224f, -0.05608108f, 0.02919425f, -0.07843884f, -0.01780737f, 0.03434285f, 0.04220293f, 0.01862455f, 
    0.00408372f, -0.02643316f, -0.03454062f, -0.04258120f, -0.01436005f, -0.05170688f, 0.03969868f, 0.02019754f, 
    -0.02179111f, -0.06204195f, 0.00559352f, 0.01098562f, -0.03534595f, 0.05714176f, -0.05924466f, -0.02777069f, 
    0.05817150f, -0.02853503f, 0.06153265f, -0.06568294f, 0.04275614f, 0.03856758f, -0.00524534f, -0.01141999f, 
    0.01791029f, -0.05422730f, 0.01005282f, 0.00143724f, 0.03899601f, -0.03184476f, -0.04113901f, 0.03501336f, 
    -0.00200688f, -0.03528300f, 0.04571255f, 0.02183356f, 0.03178864f, -0.04951255f, 0.03834266f, -0.04532561f, 
    -0.04069062f, -0.03258361f, 0.00425530f, -0.01286215f, -0.06424602f, 0.01018489f, 0.05107212f, 0.06266324f, 
    0.00748419f, -0.04683769f, 0.05760073f, -0.05490292f, -0.03747009f, 0.00106979f, -0.00635132f, -0.06952244f, 
    -0.00454471f, 0.00419128f, -0.02148519f, 0.06502095f, -0.07460025f, -0.00930288f, 0.04929705f, 0.01841801f, 
    0.01060748f, -0.00665674f, -0.04793339f, 0.03977036f, 0.00939647f, -0.02861717f, 0.04501934f, -0.00099856f, 
    0.06212455f, -0.06909501f, -0.07328345f, -0.04893211f, -0.00958360f, 0.02645417f, -0.06741181f, 0.05603906f, 
    -0.00448279f, 0.04621837f, -0.05250359f, -0.00093360f, 0.00956413f, 0.00571944f, -0.02513647f, -0.04486352f, 
    -0.05833858f, -0.02544720f, -0.03173090f, -0.05894775f, -0.05861193f, 0.00908529f, -0.00222191f, -0.04008013f, 
    0.00971940f, 0.05972261f, -0.05947835f, -0.02864937f, 0.04834471f, -0.01417647f, 0.00974111f, -0.06855410f, 
    -0.00214764f, 0.02255577f, -0.06981713f, 0.00865305f, -0.03050762f, 0.03179020f, 0.05527952f, 0.06398454f, 
    0.05233356f, -0.05626177f, -0.07652596f, 0.01656502f, -0.07036560f, -0.03580585f, -0.03013544f, -0.04439725f, 
    0.05705402f, -0.07124627f, 0.04986148f, 0.02817025f, 0.03058489f, -0.03637750f, -0.05841444f, 0.02252157f, 
    -0.01848770f, -0.01958873f, -0.01218825f, 0.06037420f, 0.00418946f, -0.04323811f, -0.04658940f, 0.05757641f, 
    -0.02213803f, 0.04378211f, -0.02898066f, -0.02661542f, -0.06341555f, -0.01879601f, 0.04357851f, -0.01793450f, 
    -0.03699060f, 0.00165673f, -0.06189865f, 0.01669524f, -0.06622630f, 0.06249535f, 0.06417570f, -0.05711927f, 
    0.02289152f, -0.04319343f, 0.02636988f, 0.05152517f, 0.03270774f, 0.05860173f, -0.07704841f, -0.03387856f, 
    -0.03035517f, -0.04206381f, -0.05169713f, -0.00688352f, 0.01477329f, -0.03637848f, -0.06418388f, 0.04964519f, 
    -0.02865545f, 0.11647391f, -0.01546769f, -0.03832918f, -0.01208843f, -0.12525229f, 0.03822431f, -0.01187954f, 
    0.09800635f, -0.00424428f, -0.03219503f, 0.05754472f, -0.27655300f, 0.16815309f, 0.02709407f, 0.07746105f, 
    0.00857247f, 0.12057324f, 0.06390859f, 0.02464535f, -0.05060403f, 0.00192019f, -0.02053777f, 0.03722431f, 
    0.01411944f, 0.22454400f, 0.11341104f, 0.38820300f, 0.01502291f, 0.00422053f, -0.00077301f, 0.01436442f, 
    0.00362897f, 0.03186760f, 0.05272149f, -0.00291095f, 0.19120915f, -0.12004962f, 0.02186887f, 0.12721235f, 
    -0.12707946f, -0.14954162f, -0.08734158f, 0.04554202f, 0.02568746f, -0.05575153f, 0.03717615f, -0.01834381f, 
    -0.02210430f, 0.14257973f, -0.03470342f, 0.09516454f, 0.02525622f, 0.17983808f, -0.00582687f, -0.00868516f, 
    0.11091007f, 0.00340027f, 0.13846323f, -0.12475376f, -0.23248374f, 0.01508147f, -0.01377976f, -0.00637935f, 
    0.01691792f, -0.08260614f, 0.02044022f, -0.01156639f, 0.08825466f, 0.16843817f, 0.04876843f, -0.12445178f, 
    -0.17580038f, -0.09403988f, 0.09119653f, 0.09907044f, -0.06634572f, 0.08827604f, -0.06322550f, -0.01051742f, 
    0.04023222f, 0.04952660f, 0.09322327f, -0.07372644f, -0.00119575f, 0.04394777f, 0.01835228f, 0.15056495f, 
    0.00159263f, -0.01066677f, 0.09448542f, 0.05053969f, 0.07263642f, 0.02264604f, 0.05065537f, 0.04578010f, 
    -0.05003479f, -0.05389965f, 0.05854820f, -0.01104563f, 0.03299738f, 0.01339334f, -0.07633018f, -0.11053135f, 
    0.03518404f, -0.04005016f, -0.10345422f, -0.01160094f, 0.06014552f, 0.12674426f, -0.24606915f, 0.11595057f, 
    0.05124115f, -0.01197578f, 0.11279703f, -0.00927803f, -0.02727425f, -0.02651636f, 0.02641251f, -0.08870823f, 
    0.34655243f, -0.02369899f, 0.10425699f, -0.00026263f, -0.10542331f, 0.04576970f, -0.03945892f, -0.01210542f, 
    0.07079251f, 0.06939692f, -0.01238993f, -0.11831832f, 0.26908556f, -0.04688143f, 0.02935869f, -0.07103129f, 
    -0.08299499f, 0.00569279f, -0.00556173f, 0.08213365f, 0.04066524f, -0.09343624f, 0.13550456f, 0.03446241f, 
    -0.18261859f, 0.11691777f, 0.03594056f, 0.07238434f, 0.00830218f, 0.00989729f, 0.09216052f, -0.00624904f, 
    -0.09071757f, 0.09416864f, 0.11036148f, -0.03352645f, 0.01595611f, -0.08270757f, 0.06697836f, -0.03511274f, 
    0.01205899f, -0.03475578f, -0.03327641f, -0.10884742f, -0.02399988f, -0.03376968f, -0.03203445f, 0.09034742f, 
    0.12539057f, -0.01808420f, -0.15203781f, -0.12457236f, 0.09977610f, 0.02336884f, 0.02865744f, -0.14494038f, 
    0.00706315f, 0.02204265f, -0.01888794f, 0.11941112f, 0.09164149f, -0.13343766f, 0.08287878f, 0.08300421f, 
    -0.02302380f, 0.00683141f, -0.07433853f, -0.10447563f, -0.04405816f, -0.11549132f, -0.11066244f, 0.03731859f, 
    0.52443492f, 0.21254334f, -0.00392261f, 0.10852952f, -0.07932509f, 0.00605371f, 0.04463153f, -0.04898419f, 
    -0.16149689f, 0.02214806f, -0.00693915f, 0.07722902f, 0.27237487f, 0.11979046f, -0.06258800f, 0.04557079f, 
    0.10436288f, 0.00228770f, 0.02310151f, -0.01907132f, -0.04477867f, 0.02812438f, -0.00762490f, -0.04245277f, 
    0.25250384f, 0.14327717f, 0.08629594f, 0.12455366f, -0.15350389f, 0.11647113f, 0.01412805f, -0.03652117f, 
    -0.05086730f, 0.02770169f, 0.08395758f, -0.08326670f, -0.07205820f, 0.14942069f, 0.21418169f, 0.14765324f, 
    -0.02894871f, 0.03561713f, -0.01334632f, 0.06261063f, -0.01661146f, 0.14815892f, -0.05246782f, -0.09040423f, 
    0.37711099f, -0.17553496f, 0.10422562f, -0.07319501f, -0.06176716f, 0.06143906f, 0.01652973f, -0.15895982f, 
    -0.02112248f, 0.00500739f, -0.02745978f, -0.12073578f, -0.00511925f, 0.12836176f, -0.29216570f, -0.00678283f, 
    0.01473600f, -0.07813445f, -0.13520566f, 0.13302556f, -0.17299977f, -0.03684143f, 0.07267685f, -0.08982362f, 
    0.08130748f, 0.34822398f, -0.02997292f, -0.08377860f, 0.04656167f, 0.02193770f, 0.13047656f, -0.00668095f, 
    -0.03282043f, 0.01467260f, 0.07512404f, -0.02548182f, 0.08640061f, 0.47071317f, -0.11720005f, 0.07252434f, 
    0.01381415f, -0.02834076f, 0.01829848f, 0.06910878f, 0.08851561f, 0.04637803f, 0.04407907f, -0.06090740f, 
    -0.04201326f, -0.11234024f, 0.05124957f, -0.03144220f, -0.10742301f, 0.05879628f, -0.03783984f, -0.11702856f, 
    -0.12328648f, -0.10283017f, 0.00081318f, 0.06991440f, -0.06331916f, 0.26122665f, 0.01220157f, -0.05029061f, 
    0.04656252f, 0.01921157f, -0.02849616f, 0.02975493f, 0.07834717f, 0.04015181f, 0.08358940f, -0.03844287f, 
    -0.00771837f, -0.01470227f, 0.07555928f, 0.15917616f, 0.06222908f, 0.00075485f, -0.08147666f, 0.06100498f, 
    -0.13231628f, 0.03910818f, 0.03357451f, -0.06829428f, 0.57298243f, -0.14351718f, 0.12945190f, -0.01421889f, 
    0.02980776f, -0.00010897f, 0.06840936f, -0.00189475f, 0.09130544f, 0.04089398f, 0.08980291f, 0.13970256f, 
    -0.03801401f, 0.00449249f, 0.15904306f, 0.02921325f, -0.06290910f, 0.14093903f, 0.04601347f, 0.01110659f, 
    0.01956235f, -0.03503456f, -0.02161103f, -0.00569443f, 0.23661444f, -0.28266630f, -0.18922555f, -0.00961127f, 
    0.01576580f, -0.00683944f, -0.09391625f, -0.03928043f, -0.02569511f, 0.04838502f, 0.02418578f, -0.04692681f, 
    -0.26431820f, -0.00500673f, -0.26045004f, -0.07292181f, -0.03751017f, -0.03416973f, -0.00082626f, -0.09842190f, 
    0.01529382f, -0.05707696f, -0.12792853f, -0.03076887f, 0.23976219f, -0.12037396f, 0.09745885f, -0.07683541f, 
    0.05729887f, 0.12313282f, -0.10505398f, 0.05658380f, 0.03454501f, 0.03234183f, -0.05504132f, 0.13407655f, 
    0.24724685f, -0.15357772f, -0.05044044f, 0.09549801f, -0.05881067f, -0.02053041f, 0.10276850f, -0.09259024f, 
    0.01879845f, -0.04174775f, -0.04074012f, 0.21768083f, -0.01889330f, -0.13603669f, -0.08209273f, 0.33428928f, 
    -0.11970013f, -0.10277729f, 0.07486212f, 0.03167141f, -0.02771432f, 0.07493861f, 0.02503927f, 0.08963217f, 
    0.15708782f, -0.24931434f, 0.01041502f, 0.04540759f, 0.14764257f, 0.00079855f, 0.03186241f, 0.00192354f, 
    -0.02173308f, -0.16811374f, 0.04118527f, -0.03825827f, 0.16789024f, 0.10687968f, 0.12837434f, 0.08855795f, 
    0.10004979f, 0.02119804f, -0.06974662f, -0.11678708f, -0.07354666f, 0.10145941f, -0.15065219f, 0.05875818f, 
    -0.14016017f, 0.26153395f, -0.12794878f, 0.06262548f, 0.05087645f, -0.05258946f, -0.03738154f, -0.04882838f, 
    0.07418150f, 0.10635625f, -0.01090646f, 0.18747324f, 0.26365608f, -0.02299795f, -0.06908751f, 0.29120803f, 
    -0.13792683f, -0.04216908f, 0.09875984f, -0.03042257f, -0.02643301f, -0.05254270f, 0.04595890f, 0.05025588f, 
    0.51452541f, -0.05270306f, 0.04068293f, -0.09276565f, 0.01995701f, 0.11945715f, -0.03341030f, -0.05813264f, 
    0.07624845f, 0.01990034f, -0.01763690f, -0.13594492f, 0.28086922f, -0.20795488f, -0.07976420f, -0.04564239f, 
    0.11103200f, -0.07338684f, 0.05706410f, -0.04712908f, -0.03675843f, -0.03114446f, 0.04307322f, -0.01239021f, 
    -0.14148150f, 0.34713739f, 0.02469492f, -0.03700784f, 0.14945623f, 0.17333847f, 0.21539512f, 0.17213322f, 
    0.06039933f, 0.11408471f, -0.07608372f, 0.07898913f, -0.03869111f, 0.03752416f, -0.27217692f, -0.04084805f, 
    -0.02752482f, 0.00537231f, 0.02514027f, -0.08534361f, -0.05686376f, -0.01822866f, 0.08142791f, 0.08457542f, 
    0.14580026f, 0.03108535f, 0.02653964f, -0.00763240f, 0.00122245f, 0.16280706f, -0.01788305f, -0.06930420f, 
    0.09585016f, 0.00967350f, -0.04693461f, 0.00300164f, -0.54939270f, 0.48654142f, 0.02914298f, 0.00339359f, 
    -0.01417659f, -0.08686540f, -0.18192443f, 0.01198051f, 0.00855493f, -0.05793539f, -0.10733192f, -0.07521505f, 
    -0.20155288f, -0.14625798f, 0.09947353f, 0.14156359f, 0.08891433f, 0.03625998f, 0.06569458f, -0.03568502f, 
    0.09206880f, 0.03810578f, 0.13990279f, 0.10302757f, -0.16926290f, 0.02845807f, -0.12716603f, -0.01374805f, 
    0.06051781f, -0.02625638f, 0.09146466f, 0.03947810f, 0.02863773f, 0.00049383f, -0.05974883f, 0.16588007f, 
    -0.13440305f, -0.02712194f, 0.23601328f, 0.11006024f, -0.08042204f, 0.05275646f, -0.03363518f, -0.04164600f, 
    0.11444920f, 0.09526582f, 0.12392109f, -0.05956865f, 0.14508465f, -0.10017302f, 0.00602618f, -0.13843374f, 
    -0.07513921f, -0.00393349f, 0.01203088f, -0.18968619f, -0.01722050f, -0.01624428f, -0.02221605f, -0.09169599f, 
    0.00904302f, -0.08559283f, -0.12313079f, 0.08399116f, -0.03150463f, -0.10841966f, 0.11137424f, 0.01698443f, 
    0.04052607f, 0.01782068f, 0.00110505f, 0.14221346f, -0.11850370f, 0.05900916f, -0.06300741f, 0.13135517f, 
    -0.02883334f, 0.07322334f, 0.02227891f, 0.08955802f, -0.09974995f, -0.05522686f, -0.08434997f, 0.01355282f, 
    -0.10437074f, 0.20799211f, 0.16690922f, 0.31339493f, 0.02278570f, 0.12978071f, -0.02240412f, 0.03878196f, 
    0.09735455f, -0.03966049f, 0.00507990f, 0.07797298f, -0.14790569f, 0.10507954f, 0.00360962f, -0.09759949f, 
    0.07654574f, -0.12909834f, -0.11502405f, -0.09803695f, 0.03733311f, -0.02359529f, -0.10989849f, 0.17664640f, 
    0.01780152f, 0.15086898f, 0.05020824f, 0.03308648f, -0.00579251f, 0.04680878f, -0.03019670f, -0.05410535f, 
    -0.00603066f, 0.05283124f, 0.18523522f, 0.00128970f, -0.01634791f, 0.00993464f, -0.04492129f, 0.11032530f, 
    -0.00451007f, -0.09288664f, 0.04842052f, 0.03672708f, -0.00413796f, 0.03307276f, 0.10317578f, -0.17521229f, 
    -0.13570336f, -0.10614924f, -0.06480080f, -0.17687480f, 0.02968331f, 0.16887465f, -0.00251987f, 0.07910765f, 
    0.11018991f, -0.01167484f, 0.00521180f, -0.09429529f, 0.03429870f, 0.11098347f, -0.01993312f, 0.17222945f, 
    0.01912608f, -0.07158120f, 0.09582880f, -0.01934431f, 0.02783585f, -0.06362133f, -0.07291382f, -0.04741000f, 
    0.09088764f, -0.22053218f, 0.08046786f, 0.10692241f, 0.10390846f, -0.01549322f, 0.10254074f, -0.09064928f, 
    0.03891684f, -0.02879000f, 0.09902634f, 0.02185207f, 0.15290120f, 0.16529816f, -0.26470277f, 0.11275280f, 
    0.04416872f, 0.02067248f, 0.05295304f, 0.03422805f, -0.01390334f, 0.04553121f, 0.01070826f, 0.04527278f, 
    0.16810308f, -0.09125024f, 0.19710776f, -0.00901890f, -0.08914659f, -0.05453334f, 0.01771933f, 0.03550717f, 
    0.02195326f, -0.10063733f, -0.02362764f, 0.07126265f, 0.25516936f, -0.11865131f, -0.00443850f, -0.15385488f, 
    -0.10434160f, 0.07321113f, 0.01733087f, 0.14118670f, 0.07319788f, -0.13080843f, -0.01037623f, 0.00098351f, 
    -0.24047862f, -0.06033057f, -0.05032429f, -0.13213520f, -0.05706201f, 0.03032695f, 0.16243081f, -0.07644965f, 
    -0.00143608f, 0.03033499f, 0.18400493f, 0.08985150f, -0.07871199f, 0.04903465f, 0.06741737f, -0.03258659f, 
    0.15113752f, -0.03723534f, 0.05215583f, -0.04734527f, -0.02809675f, 0.15877233f, 0.02824330f, 0.14524834f, 
    0.04147940f, 0.05057061f, -0.08447780f, 0.04105160f, 0.03832838f, -0.10775891f, 0.05585868f, -0.11158451f, 
    -0.00204974f, 0.01342012f, 0.00377572f, 0.04854223f, 0.17705068f, -0.19328749f, 0.11149065f, -0.26209617f, 
    -0.00175672f, 0.02995428f, -0.07430083f, -0.21920675f, 0.04678662f, -0.05855100f, -0.11790425f, -0.04814829f, 
    -0.13895682f, 0.27298865f, 0.21437940f, -0.07630997f, 0.06389379f, -0.00264091f, 0.07404914f, 0.11285869f, 
    0.00190667f, 0.03253159f, 0.04445668f, -0.05223786f, 0.10272323f, 0.41275370f, 0.24254055f, 0.17708200f, 
    -0.04512725f, 0.01101035f, -0.06164583f, -0.09225435f, -0.05301376f, -0.03686929f, 0.12371723f, 0.08199798f, 
    0.05940371f, -0.10163331f, 0.11229620f, 0.05531865f, -0.10531853f, 0.04514921f, -0.04057226f, 0.02632272f, 
    -0.01396897f, 0.03017534f, 0.05235463f, 0.10064980f, 0.39230761f, -0.20126082f, 0.15957719f, -0.22379278f, 
    -0.04076209f, -0.05266643f, 0.02288020f, 0.11312156f, -0.05369433f, -0.18423828f, -0.01787237f, -0.02803770f, 
    0.06769843f, 0.24260893f, -0.01831142f, 0.12223437f, 0.07179956f, 0.15316129f, -0.16406301f, -0.07393295f, 
    -0.08980079f, -0.02783098f, 0.07663345f, -0.09273046f, -0.25262967f, 0.17794970f, 0.06646204f, 0.13924766f, 
    0.08653242f, 0.06217845f, -0.05957954f, -0.09845700f, -0.11995786f, 0.05031684f, -0.11165128f, 0.10149064f, 
    0.01577085f, -0.21936357f, -0.04029653f, -0.04385429f, 0.00708121f, 0.06098441f, 0.25632760f, 0.07268962f, 
    -0.09134991f, -0.12707861f, -0.02128879f, 0.05756874f, 0.03439016f, 0.18570067f, 0.23498860f, -0.00162956f, 
    0.01459630f, 0.01538364f, 0.25661129f, -0.01787863f, -0.03333017f, 0.00938837f, -0.00986916f, 0.02044147f, 
    -0.19938977f, 0.07583890f, -0.04102860f, -0.07327963f, -0.02305985f, -0.07048765f, -0.24145707f, -0.08920258f, 
    0.06111978f, -0.13854277f, -0.20141265f, -0.01038850f, -0.21267158f, -0.08366281f, -0.20268439f, 0.06158016f, 
    -0.09502460f, -0.00441265f, 0.25666514f, -0.02384085f, 0.09802536f, -0.14787573f, -0.04474816f, -0.08556379f, 
    0.16620490f, -0.08676907f, 0.01494466f, -0.02534069f, -0.06105723f, -0.07708278f, -0.02721122f, -0.05177268f, 
    -0.04688417f, 0.04509170f, 0.04787250f, 0.10648847f, -0.12189709f, 0.11300267f, 0.00328974f, -0.12367284f, 
    0.03398367f, -0.07473468f, 0.15313984f, 0.00694466f, 0.02137535f, -0.06566819f, 0.13326825f, -0.02226193f, 
    -0.03185180f, -0.02335539f, -0.19582669f, -0.11507366f, 0.04847638f, -0.07076106f, 0.02462507f, 0.07227947f, 
    0.08691143f, 0.05396467f, -0.19661683f, 0.05450483f, 0.40184024f, -0.13430594f, -0.03410888f, 0.27188081f, 
    0.02791902f, -0.13278487f, -0.16788961f, -0.05410432f, -0.05686926f, 0.14521891f, 0.00672363f, -0.02270595f, 
    -0.19962735f, 0.00701600f, -0.02388365f, -0.09622728f, 0.00162699f, 0.02698074f, -0.00913361f, -0.00402677f, 
    0.00733658f, 0.12043328f, 0.04445077f, -0.05854040f, 0.04476588f, -0.13353980f, 0.06102154f, -0.06301515f, 
    0.08624168f, -0.00198666f, 0.14890088f, 0.15852185f, 0.07602311f, -0.09657036f, 0.04893778f, 0.02059101f, 
    -0.25041580f, -0.09559155f, 0.00291844f, -0.02242675f, -0.09329359f, -0.04467973f, -0.13385452f, -0.05452992f, 
    -0.07873388f, -0.01065447f, -0.08823384f, -0.00919746f, 0.08086689f, -0.05701059f, 0.10253225f, 0.11376888f, 
    -0.04466851f, -0.14088835f, -0.06568021f, -0.04602163f, 0.00887666f, -0.00336052f, 0.08760952f, 0.05272426f, 
    -0.12864001f, -0.27657080f, -0.10208149f, -0.42509520f, 0.03421560f, -0.13525134f, -0.04729122f, -0.06159931f, 
    0.10363128f, 0.00945779f, -0.02327909f, -0.04704249f, 0.03183684f, -0.01032130f, 0.00768074f, -0.02307478f, 
    0.08803241f, -0.02275438f, -0.11511945f, -0.08633033f, 0.03552384f, 0.15980107f, 0.12407261f, 0.04853772f, 
    0.05812845f, -0.16577283f, -0.11071880f, 0.18260127f, 0.06505511f, -0.06428500f, -0.04014432f, -0.04198242f, 
    0.04591592f, 0.05231591f, -0.01946113f, 0.16458668f, 0.36116052f, -0.11260785f, -0.01766374f, 0.08353510f, 
    -0.11258286f, -0.02460883f, -0.00287432f, -0.00922744f, 0.03586045f, -0.03307536f, -0.07135867f, 0.22419463f, 
    0.36586565f, -0.18702634f, 0.09147972f, -0.19254753f, 0.25273457f, 0.05564894f, 0.13219698f, 0.07642423f, 
    0.04785519f, 0.04698385f, 0.08889125f, 0.04458157f, 0.05065872f, -0.38425580f, -0.08607214f, -0.06320717f, 
    0.05411069f, -0.08940942f, -0.06196249f, -0.03244288f, -0.01969859f, -0.07192475f, -0.04729094f, 0.04555285f, 
    0.12934224f, 0.01982298f, -0.15853968f, 0.05366899f, 0.10583410f, 0.12110265f, -0.03356596f, 0.14726046f, 
    0.09017593f, 0.16422373f, 0.07349028f, 0.04776303f, -0.08827332f, -0.18948655f, 0.19054708f, -0.26359609f, 
    0.05363865f, -0.02762237f, -0.08438423f, -0.02795021f, 0.00532214f, 0.06948967f, 0.01765048f, 0.11068714f, 
    -0.08854963f, 0.10171597f, -0.24784228f, 0.06239046f, 0.04715058f, -0.01108942f, 0.06565069f, -0.07039506f, 
    0.00898430f, -0.00581277f, -0.04722949f, 0.05831261f, -0.22941291f, 0.09612729f, -0.14872177f, 0.09326964f, 
    0.11804178f, 0.13644597f, -0.02507228f, 0.07312766f, 0.00291376f, 0.06907819f, -0.04029031f, -0.00276105f, 
    0.30331871f, -0.03945835f, -0.09004111f, -0.10416737f, 0.02563923f, 0.08119699f, -0.00653547f, 0.17674138f, 
    0.05740460f, -0.12087645f, 0.00744655f, 0.07486769f, -0.16821544f, 0.13296515f, 0.05226444f, 0.19431366f, 
    -0.02528580f, 0.05930471f, -0.01541498f, 0.09855238f, 0.06956995f, -0.03401424f, 0.07187125f, 0.01174170f, 
    0.00349260f, 0.21522336f, 0.21339150f, 0.15916567f, 0.05556852f, 0.16096120f, 0.01811075f, 0.07332341f, 
    0.08645462f, -0.01194541f, 0.07723603f, 0.04837118f, 0.28567061f, 0.11169928f, -0.07114531f, -0.05800541f, 
    0.00098173f, -0.09601676f, 0.13601746f, -0.06171571f, -0.02047137f, 0.17906275f, 0.08216006f, -0.03152213f, 
    -0.06975576f, -0.05934119f, -0.01507216f, 0.04758564f, -0.07309223f, 0.04499307f, -0.00427681f, 0.02250358f, 
    -0.07747404f, -0.04035283f, 0.05521800f, -0.05618153f, -0.02639753f, 0.01753708f, -0.04696469f, 0.05784296f, 
    -0.01643298f, -0.07775480f, 0.01276397f, 0.05391309f, 0.01234249f, 0.05281324f, 0.02451560f, -0.03500064f, 
    0.01881547f, 0.04605376f, -0.03867306f, -0.02123214f, -0.04136790f, 0.01384693f, -0.04315355f, -0.02181120f, 
    -0.06873665f, -0.06458931f, -0.00182440f, 0.03189659f, -0.05991394f, -0.02659744f, 0.03185597f, 0.05208970f, 
    -0.06486921f, -0.08046756f, 0.00221676f, -0.06025322f, -0.06638937f, 0.02569507f, -0.01093151f, 0.03123364f, 
    -0.05075092f, 0.01832316f, -0.05328785f, 0.01574310f, -0.06472728f, 0.03722497f, 0.06311762f, -0.06276850f, 
    -0.01698357f, -0.03409316f, -0.00222330f, -0.02365174f, -0.06984249f, -0.01559348f, 0.04334397f, -0.06755327f, 
    -0.04460730f, 0.05763330f, 0.04641610f, 0.04185969f, 0.06190329f, 0.00177673f, 0.05431120f, -0.02178361f, 
    0.04541123f, -0.07210353f, 0.01959165f, 0.05770896f, 0.00774037f, -0.03405667f, -0.00426399f, 0.05624493f, 
    0.03745153f, 0.03370161f, 0.01683662f, -0.04435372f, 0.02576965f, -0.03441961f, 0.04631002f, 0.00687726f, 
    0.05430195f, -0.05354153f, -0.06335580f, -0.05508961f, -0.02400932f, 0.05882269f, -0.06429682f, -0.01946925f, 
    -0.03758448f, -0.06267735f, -0.08152787f, 0.06198344f, -0.02652335f, -0.01030585f, 0.04871899f, -0.06474794f, 
    0.02791813f, -0.02668979f, -0.03716221f, 0.06403910f, 0.02794506f, 0.02967346f, -0.01191162f, -0.05535388f, 
    0.03908762f, 0.01508946f, 0.05399249f, 0.03130221f, -0.02819201f, 0.01305185f, 0.05700463f, 0.01905238f, 
    -0.04105506f, -0.07650052f, -0.00934076f, -0.04993099f, -0.04920939f, -0.01823572f, -0.07585404f, 0.06283534f, 
    0.03015578f, 0.03101722f, 0.01758490f, -0.05067980f, -0.00956107f, 0.01921828f, -0.03564981f, 0.03708921f, 
    0.00138615f, 0.06310311f, -0.03866550f, -0.05531440f, 0.05890635f, -0.05859796f, -0.08181811f, -0.00366869f, 
    0.01219193f, -0.02291765f, -0.08175342f, -0.01980765f, 0.06221825f, -0.04520540f, 0.00806959f, -0.06709380f, 
    -0.08092186f, 0.00632242f, 0.05763685f, 0.03113667f, -0.00877166f, -0.01891302f, -0.03931301f, -0.06973880f, 
    0.00290501f, -0.05062275f, -0.07509390f, -0.06496408f, -0.00368498f, -0.02449010f, 0.05402873f, -0.03261761f, 
    -0.06445988f, 0.04571570f, -0.06959521f, -0.00830398f, -0.05806838f, -0.03395536f, -0.01904144f, 0.03355855f, 
    -0.06570812f, -0.03900282f, -0.07911667f, 0.05365564f, 0.03391991f, 0.03917624f, -0.03373512f, -0.00519288f, 
    0.02507694f, -0.04399811f, 0.05012936f, 0.02097957f, -0.05921423f, 0.03361643f, 0.00318226f, -0.01979302f, 
    0.03220951f, -0.05740294f, -0.05576071f, 0.03350379f, -0.05637985f, 0.03872700f, 0.05409893f, -0.01059690f, 
    -0.07163054f, -0.05305851f, 0.01162572f, 0.05287443f, 0.01290166f, -0.07578681f, -0.06651292f, -0.04133669f, 
    0.01558467f, -0.04571052f, 0.04911323f, -0.01351398f, 0.02776588f, -0.01299665f, -0.01356717f, 0.05199444f, 
    -0.00194651f, 0.06126290f, -0.04948585f, -0.02211222f, 0.03977252f, -0.05340550f, -0.05591776f, 0.02936199f, 
    -0.02553277f, 0.01231155f, -0.00450440f, 0.06159830f, 0.04986682f, -0.04269600f, 0.01939970f, 0.01935085f, 
    -0.00899644f, -0.01254447f, -0.02043414f, 0.02189060f, 0.04943736f, 0.05548993f, 0.03197236f, -0.07248136f, 
    -0.06547712f, 0.02288785f, 0.01246924f, -0.06979696f, -0.02731738f, 0.04563791f, -0.00900073f, -0.03200635f, 
    0.02444788f, -0.07437958f, -0.05507196f, 0.02830418f, -0.04764317f, -0.04847015f, 0.00359782f, 0.04935595f, 
    0.05580404f, 0.01773775f, -0.07809584f, 0.05341115f, 0.03214232f, -0.01536808f, 0.05165885f, -0.03944900f, 
    0.05792298f, -0.01512008f, 0.05823163f, -0.06432637f, -0.05828602f, 0.01857685f, -0.00994696f, -0.03491078f, 
    0.03943231f, -0.04379860f, 0.05073210f, -0.04813596f, -0.03087881f, -0.04682174f, -0.04991392f, -0.03109429f, 
    0.00657795f, 0.03848067f, 0.02351064f, -0.01512231f, -0.01819133f, -0.02567927f, 0.02981373f, -0.05240595f, 
    -0.07807307f, -0.07789565f, 0.04281082f, 0.02545636f, -0.06525055f, 0.06556082f, 0.02256244f, -0.05600706f, 
    -0.01538764f, -0.05701375f, 0.01530263f, -0.07470019f, -0.01667157f, 0.05827560f, -0.06530259f, -0.02285416f, 
    -0.00503917f, 0.05071360f, 0.01487396f, 0.02955872f, -0.04729823f, -0.02806062f, -0.03575040f, -0.01167312f, 
    -0.03436756f, -0.04589823f, -0.07442062f, 0.01287265f, 0.04866971f, -0.01248578f, 0.03425137f, 0.06299773f, 
    -0.07740857f, -0.00980152f, -0.01124733f, 0.01568049f, -0.00893829f, -0.06788699f, -0.06408633f, -0.04073931f, 
    0.04190151f, 0.01566712f, -0.01078731f, 0.06102243f, 0.06241735f, -0.06518302f, -0.01462359f, -0.06262579f, 
    -0.04089993f, -0.06709612f, -0.01657555f, -0.04485141f, -0.04991068f, -0.06948574f, 0.01541158f, -0.00555194f, 
    0.00016038f, -0.00085978f, -0.02202014f, -0.05426229f, -0.04545316f, -0.04912257f, 0.04546779f, -0.01189765f, 
    0.01997333f, 0.00676248f, 0.04071743f, -0.03900347f, -0.07593492f, 0.05646680f, 0.04082257f, 0.01978119f, 
    0.03869652f, 0.03853458f, 0.01718515f, -0.06638388f, -0.04645489f, -0.01090677f, -0.03549515f, 0.02276882f, 
    -0.03489112f, 0.02009447f, 0.00735626f, -0.06282165f, -0.06523067f, -0.05873005f, -0.07003614f, 0.04980751f, 
    0.00597806f, -0.07051287f, -0.00172477f, 0.02615982f, -0.03065408f, -0.07010510f, -0.05620691f, -0.00405320f, 
    0.07472579f, -0.41851103f, -0.28444967f, 0.08309536f, -0.18103124f, 0.05061517f, -0.06795321f, -0.14295630f, 
    -0.02095753f, -0.05956691f, -0.08040813f, -0.03140163f, 0.20236802f, -0.05157941f, -0.11928035f, 0.37649554f, 
    -0.21233603f, -0.09112836f, -0.02832558f, -0.00550369f, -0.01173102f, 0.02327811f, -0.07631854f, -0.16166219f, 
    -0.29021758f, -0.35959727f, -0.26310802f, -0.15410931f, 0.11759499f, -0.22216053f, -0.00093175f, -0.01866555f, 
    -0.00776727f, -0.01470187f, -0.02333549f, 0.11588558f, -0.04206504f, -0.22239088f, -0.24757132f, -0.25039175f, 
    -0.05071386f, -0.06665157f, -0.10274780f, -0.10274296f, 0.02278629f, 0.07866590f, -0.00941014f, 0.03408520f, 
    -0.25798470f, 0.32720056f, -0.10093769f, 0.08335274f, -0.02927983f, -0.07515574f, -0.05597277f, 0.09965640f, 
    0.18425754f, -0.12113311f, -0.19745843f, 0.05694680f, 0.24733697f, 0.02652556f, 0.07268015f, -0.08979447f, 
    -0.11300907f, -0.05438082f, -0.04616109f, 0.02641441f, 0.22781701f, 0.08366255f, -0.01900256f, -0.00427192f, 
    0.22014898f, 0.10704371f, 0.07326747f, 0.32154560f, 0.05853261f, 0.06547129f, -0.04102789f, -0.10004521f, 
    0.10916959f, 0.02949226f, -0.13649327f, -0.03359303f, 0.21601327f, -0.30945787f, -0.08080121f, -0.02083254f, 
    -0.16145030f, -0.03425028f, -0.00843837f, -0.08973987f, 0.02509668f, -0.08943360f, 0.00051207f, 0.10183594f, 
    0.25164783f, 0.15278666f, 0.04819560f, 0.03024842f, 0.08344188f, 0.01043734f, 0.03794932f, 0.12717272f, 
    0.10073450f, 0.15864490f, 0.09036323f, -0.01683338f, 0.19948956f, 0.03142725f, -0.11485207f, 0.04387696f, 
    -0.11281507f, -0.11913659f, -0.07288020f, -0.05115825f, 0.02163755f, 0.11001008f, 0.09677757f, 0.10392406f, 
    -0.03953458f, -0.18583903f, -0.04949918f, -0.20749605f, 0.08104900f, 0.04533381f, -0.08078698f, 0.02309084f, 
    0.06983205f, 0.06967747f, -0.05889891f, -0.01803358f, -0.16414428f, 0.40175936f, 0.01404742f, 0.17499812f, 
    0.18296920f, 0.03759415f, 0.05714125f, 0.08721719f, -0.02236111f, -0.04263559f, -0.02979739f, -0.01962261f, 
    0.04699202f, 0.00167692f, 0.16300520f, 0.27257422f, 0.12266232f, 0.07923888f, 0.11977853f, 0.00848012f, 
    0.08175783f, 0.02043201f, 0.14009103f, -0.03205130f, -0.11016481f, 0.25413522f, 0.11135145f, -0.05401667f, 
    -0.04171455f, 0.18286972f, 0.09353579f, 0.20801061f, -0.16335841f, -0.00742603f, 0.05320546f, -0.01816327f, 
    0.32416859f, 0.16402395f, 0.33284709f, 0.18019211f, -0.01152220f, 0.14658484f, 0.14091280f, 0.05845342f, 
    0.04337635f, 0.09146050f, 0.07016429f, -0.09103167f, -0.02080624f, -0.05930034f, -0.17499894f, 0.06859009f, 
    0.09889255f, 0.00409037f, 0.08743002f, -0.01421799f, 0.00011864f, -0.00678881f, 0.09130214f, -0.12778521f, 
    0.16954207f, 0.02351398f, 0.10496490f, 0.03201503f, -0.00949204f, -0.08957814f, -0.08411891f, 0.18112750f, 
    0.08136461f, 0.06979699f, -0.05993893f, 0.05743774f, 0.00531256f, 0.09144831f, 0.05354254f, 0.37030569f, 
    -0.09760629f, 0.00652425f, 0.12846500f, -0.04846736f, 0.04035305f, 0.02885651f, -0.00614110f, 0.01364432f, 
    -0.08514820f, -0.16348806f, -0.04532299f, 0.11633001f, -0.08400571f, -0.10112699f, 0.03074407f, -0.02284191f, 
    -0.01194893f, 0.02280489f, -0.09242354f, -0.04350577f, 0.15319377f, -0.06957182f, 0.03872668f, -0.00842965f, 
    -0.08624726f, -0.03844103f, 0.06824656f, 0.03088575f, -0.06270295f, -0.02264830f, -0.03790619f, -0.08481600f, 
    -0.29133639f, 0.43046716f, -0.07926071f, 0.03640930f, 0.03558417f, 0.15466608f, -0.01954526f, 0.00218501f, 
    -0.06541647f, -0.04613234f, 0.01032426f, -0.13436034f, 0.15360653f, -0.00688290f, -0.03259390f, 0.25490475f, 
    -0.04661484f, -0.05044571f, -0.06999076f, -0.00947525f, 0.04431942f, -0.05661665f, -0.04064997f, 0.12921387f, 
    0.11945982f, -0.18353851f, -0.05658941f, -0.12504825f, 0.00634044f, 0.02470685f, 0.14358725f, -0.13604727f, 
    0.01225177f, 0.12034207f, 0.11614896f, 0.00454557f, 0.25671247f, -0.07117873f, -0.13270180f, 0.06372201f, 
    -0.17693283f, 0.00230488f, 0.18546003f, 0.09243077f, -0.00953858f, 0.08404019f, 0.06981009f, 0.01545020f, 
    0.12223601f, 0.16244766f, -0.12249747f, -0.11185298f, -0.04322834f, 0.02285912f, -0.15842874f, 0.06186608f, 
    0.00287334f, -0.02899131f, 0.02973946f, -0.06564461f, 0.28675833f, -0.28531763f, -0.24307163f, 0.13681363f, 
    -0.12922761f, 0.16272432f, 0.07730165f, 0.05958517f, -0.03947086f, 0.12950383f, -0.00858660f, 0.09460282f, 
    0.19915603f, -0.08593322f, 0.06290565f, 0.24060848f, -0.02995698f, 0.02355392f, -0.03622066f, -0.02522244f, 
    -0.07752893f, 0.03749635f, 0.02261192f, 0.00270924f, -0.28904343f, 0.27218568f, -0.00097778f, 0.07729615f, 
    0.01160690f, 0.06720059f, 0.00771582f, -0.02874916f, 0.01667585f, -0.04409467f, -0.03879593f, 0.07728259f, 
    0.00900526f, 0.03537127f, 0.07993811f, 0.02098011f, 0.01701168f, -0.06641082f, 0.01436798f, 0.07661814f, 
    0.00718206f, 0.08263818f, -0.02004574f, 0.02338940f, -0.24647385f, 0.02877042f, -0.05832365f, 0.11283601f, 
    0.06879196f, -0.04840168f, -0.13861030f, -0.01360812f, -0.07309238f, 0.00900728f, 0.00303394f, -0.04524677f, 
    -0.15837540f, 0.12723774f, 0.23116711f, 0.10239485f, -0.00507458f, 0.00128626f, 0.11028560f, -0.03901863f, 
    0.07598142f, 0.06883831f, 0.12711106f, -0.04253428f, 0.08862274f, -0.38193190f, 0.04087654f, -0.06685329f, 
    0.01869593f, -0.01905774f, 0.00717359f, -0.21102308f, 0.00954211f, 0.10119303f, -0.01307659f, -0.04831394f, 
    0.32381925f, 0.20529902f, 0.12179961f, -0.02919317f, -0.07385974f, -0.14515062f, -0.00085100f, 0.00547562f, 
    -0.15026592f, -0.03239186f, 0.02228964f, 0.01412401f, -0.14579955f, 0.03658406f, 0.11888445f, 0.10157412f, 
    0.07596804f, -0.09508497f, 0.03292722f, -0.01091806f, -0.09842175f, 0.00571185f, 0.15849744f, -0.05410096f, 
    0.11987854f, 0.02242021f, 0.04711314f, 0.14074352f, -0.08280700f, 0.03329473f, 0.09884934f, -0.08604643f, 
    -0.01105448f, 0.06825978f, -0.04669364f, -0.06276702f, 0.29540259f, 0.06695860f, 0.19796135f, 0.33559525f, 
    -0.00991678f, 0.02652619f, 0.01418251f, -0.12289283f, 0.02164292f, 0.19039102f, 0.00850133f, -0.10769362f, 
    0.24164748f, -0.03447810f, -0.04661012f, 0.01203867f, 0.01244774f, 0.00490840f, 0.04209445f, -0.04156589f, 
    0.09640029f, 0.08509129f, 0.01202778f, -0.02105859f, -0.04208932f, 0.10758451f, -0.14266583f, -0.00078997f, 
    -0.03854217f, -0.04744229f, 0.02436359f, 0.00729617f, -0.06046936f, -0.08928215f, 0.03531261f, -0.03019536f, 
    0.18638045f, 0.12657456f, 0.04180596f, -0.10733921f, 0.14469728f, 0.11641096f, -0.01932348f, 0.06272567f, 
    0.10900100f, 0.02211650f, 0.04841669f, -0.06156375f, 0.20815526f, -0.04402291f, -0.04423311f, 0.04130633f, 
    -0.02275908f, 0.00863920f, 0.05572645f, -0.01472037f, 0.05193725f, -0.13559932f, 0.05250685f, 0.01677689f, 
    -0.05767236f, -0.01515506f, -0.05055783f, 0.06883168f, -0.07701170f, 0.06071685f, -0.08495616f, -0.05251359f, 
    -0.03536566f, 0.03708408f, 0.00841254f, 0.13848917f, -0.09555425f, 0.17527215f, -0.00655670f, -0.40603897f, 
    -0.04701838f, -0.03776402f, -0.07853269f, -0.03517077f, -0.00873996f, 0.08325042f, 0.11283073f, 0.00355767f, 
    0.23534477f, 0.00179176f, 0.02530898f, 0.31287858f, 0.05625193f, 0.03565191f, -0.00096521f, -0.05620255f, 
    -0.00609776f, -0.02015845f, -0.07251152f, -0.03686565f, 0.28645936f, -0.03696606f, 0.12293445f, 0.03047314f, 
    -0.11153980f, -0.08986775f, -0.09292740f, -0.09364060f, 0.01108179f, 0.03256387f, -0.04624861f, -0.00685877f, 
    -0.01276299f, 0.15137643f, 0.25439242f, 0.11579401f, 0.03501859f, 0.02121636f, 0.09859844f, 0.09392750f, 
    -0.05964087f, -0.06094409f, -0.03907075f, 0.02157127f, -0.07028923f, -0.40494415f, -0.15143432f, 0.10437473f, 
    -0.04083988f, 0.01042702f, -0.05892896f, -0.12648973f, 0.05944781f, -0.01570083f, 0.11886594f, -0.02575851f, 
    -0.16565569f, 0.00435785f, -0.21309452f, -0.12888601f, 0.03852370f, -0.05956787f, -0.01028899f, -0.13853303f, 
    0.07917667f, -0.08520478f, -0.03567179f, -0.11002804f, 0.29952008f, -0.07885727f, 0.11442874f, -0.00989312f, 
    0.11781382f, 0.12736014f, -0.09069403f, -0.16348210f, -0.04249270f, -0.03805513f, -0.07648854f, -0.05963488f, 
    0.14382565f, -0.14676543f, 0.29108378f, -0.01309646f, -0.01470703f, -0.03098518f, -0.10716015f, -0.07453802f, 
    0.09546548f, -0.02469950f, -0.04152571f, -0.12830766f, -0.01915510f, -0.00273527f, -0.01175065f, 0.25717896f, 
    -0.07460535f, 0.09878080f, 0.06476876f, -0.03289618f, -0.00084590f, 0.05131330f, 0.17442237f, 0.02645147f, 
    -0.01742996f, -0.14448904f, 0.00637270f, -0.05352642f, 0.00523235f, -0.07069864f, 0.10669758f, 0.00438598f, 
    -0.02314836f, -0.07084381f, -0.10082235f, -0.06541299f, 0.30719438f, -0.15624657f, -0.06654041f, 0.00764740f, 
    0.01803602f, 0.00134678f, 0.15130308f, 0.00758188f, 0.06625718f, -0.02040575f, -0.05590657f, 0.04079074f, 
    -0.18324897f, 0.21929477f, -0.17063752f, 0.03691829f, 0.03110531f, 0.09530573f, 0.04482817f, 0.05346379f, 
    0.10653008f, -0.12810387f, 0.01273750f, -0.06436825f, -0.03697575f, 0.14589883f, 0.01506453f, 0.05478777f, 
    0.05413473f, 0.09974145f, 0.10613962f, -0.02852863f, -0.00836033f, -0.08775504f, 0.03439961f, 0.15151861f, 
    -0.13552228f, -0.34916991f, -0.00017246f, 0.01802990f, 0.01364929f, -0.14480001f, -0.13309035f, -0.03466486f, 
    0.05949298f, -0.02377793f, 0.01743728f, 0.00508142f, 0.11240249f, -0.14874922f, -0.02399414f, -0.02703154f, 
    -0.00868428f, 0.12139869f, 0.06972383f, 0.02572835f, 0.14584112f, -0.05147560f, -0.05588859f, 0.05701153f, 
    0.25371900f, -0.02804964f, -0.25702184f, 0.03084773f, 0.01981777f, -0.17033720f, -0.06653042f, 0.16273691f, 
    0.08101057f, 0.01375039f, 0.14690168f, 0.09468480f, 0.18848266f, -0.37979063f, 0.12889408f, -0.20958430f, 
    -0.00630867f, 0.01021250f, 0.18205443f, -0.04577110f, -0.14267178f, 0.17644690f, 0.08063442f, 0.02522444f, 
    -0.06198972f, -0.14539006f, -0.09683219f, 0.08385035f, 0.04938530f, 0.03428063f, -0.00886469f, 0.01222026f, 
    0.05530223f, 0.05536334f, -0.03692999f, 0.12076042f, -0.03742659f, 0.02823333f, -0.15520775f, 0.26455507f, 
    0.06765898f, 0.03477865f, 0.09780631f, -0.14247745f, -0.05959664f, -0.05860376f, 0.00208185f, -0.02310266f, 
    0.21543095f, -0.00665042f, -0.01297241f, 0.11377924f, 0.00651655f, -0.08325741f, 0.13052480f, 0.16544914f, 
    0.07448033f, 0.01745948f, 0.05516658f, 0.03494043f, -0.25289828f, 0.15863749f, 0.01942465f, 0.03151000f, 
    0.06772859f, 0.02448687f, -0.09572597f, 0.11109572f, -0.13497472f, -0.09875347f, 0.00958337f, -0.04955278f, 
    0.00491272f, 0.01910612f, 0.09229561f, 0.05511320f, 0.04310236f, 0.12154794f, -0.02700815f, 0.01073643f, 
    0.08007095f, 0.03049562f, 0.00897182f, 0.13515674f, -0.04488525f, -0.03126970f, -0.12745173f, -0.02068684f, 
    0.19495524f, -0.05295588f, -0.00145773f, -0.05477875f, 0.02263226f, -0.01192059f, 0.10093621f, -0.04351679f, 
    -0.35212350f, 0.31145635f, 0.16394579f, -0.01701193f, -0.00493315f, -0.06888448f, 0.03594344f, 0.15607277f, 
    -0.03544991f, 0.05399929f, -0.09575206f, -0.04620266f, -0.25290263f, 0.02540828f, 0.26604229f, 0.07483399f, 
    -0.13742585f, 0.03487597f, 0.11824508f, 0.03770588f, -0.12857804f, -0.04578361f, -0.08354345f, -0.07621776f, 
    -0.01957727f, 0.21202633f, 0.01201329f, 0.14499891f, -0.01420544f, -0.07182669f, 0.03747272f, -0.07365425f, 
    -0.04627297f, 0.20194699f, 0.06544642f, 0.04477823f, 0.16623257f, 0.06084729f, 0.09513921f, -0.16262843f, 
    -0.13517025f, -0.01089031f, 0.10916072f, -0.02443027f, 0.07998707f, -0.16990505f, 0.16787258f, -0.12875699f, 
    0.03896287f, 0.15386729f, 0.23779342f, 0.08503025f, -0.01433060f, 0.10185131f, 0.07548582f, -0.02056599f, 
    -0.01329942f, -0.01196783f, 0.06539033f, 0.09484329f, -0.06988129f, 0.02289870f, -0.02459194f, -0.05827745f, 
    -0.08954643f, -0.00423986f, 0.05355065f, 0.00090798f, -0.05182758f, -0.10944844f, -0.06463363f, -0.04860383f, 
    -0.01426970f, -0.01953207f, 0.00120327f, 0.20164263f, 0.02295679f, 0.13317464f, 0.08947167f, 0.15137133f, 
    -0.10295272f, 0.09876397f, 0.06113705f, 0.08023439f, 0.05963109f, 0.04493088f, 0.14029016f, -0.05841311f, 
    0.01528288f, 0.04109151f, 0.09580978f, 0.00070329f, 0.09909736f, 0.15661977f, -0.01867061f, 0.13728878f, 
    -0.17366573f, 0.18606241f, -0.12408832f, 0.02212501f, 0.03803084f, -0.00213098f, -0.04091871f, -0.14673470f, 
    -0.17461976f, -0.15180683f, -0.00043821f, -0.06340408f, -0.20173042f, 0.01437859f, 0.08648507f, 0.15377691f, 
    0.07139165f, 0.01585025f, 0.13569245f, 0.01625104f, 0.03289923f, -0.02817403f, -0.13242382f, -0.18577744f, 
    0.31742206f, 0.17048649f, 0.00457371f, 0.09089708f, -0.22647606f, 0.00160685f, -0.09261628f, -0.08126840f, 
    -0.10670217f, 0.11451802f, -0.01785506f, 0.05835024f, -0.04586001f, -0.03492686f, 0.15759608f, -0.13323887f, 
    0.00447397f, 0.02566833f, 0.08911219f, 0.00848725f, -0.05743327f, 0.19977868f, -0.01890353f, -0.00213358f, 
    0.06192704f, 0.02520649f, -0.03593323f, 0.00074600f, 0.07791798f, -0.10799139f, -0.08580361f, 0.00489271f, 
    0.12186303f, 0.13923749f, -0.08231683f, 0.02635255f, 0.10238554f, -0.15533549f, 0.14600965f, 0.12085672f, 
    -0.08947195f, -0.05894083f, -0.10331324f, -0.03772991f, 0.00782286f, 0.04173034f, -0.09840595f, -0.11993902f, 
    0.12847015f, 0.12485047f, 0.23915359f, -0.09135709f, 0.07393686f, -0.09545890f, -0.03929183f, 0.02368056f, 
    -0.12288472f, 0.06162437f, 0.03370168f, 0.02443276f, -0.11835068f, 0.09247990f, -0.01623930f, 0.11143650f, 
    0.09763957f, 0.12782936f, 0.01091375f, 0.08523630f, -0.02878799f, -0.06997094f, 0.04621472f, 0.00686556f, 
    0.21058317f, -0.06828020f, -0.15338509f, 0.00298761f, 0.07534757f, 0.05426726f, -0.26322272f, 0.21363246f, 
    -0.09451901f, -0.04954243f, 0.02070496f, -0.01265875f, -0.28475967f, -0.21895944f, -0.06862714f, 0.23171000f, 
    0.02478547f, 0.09117848f, 0.03052950f, 0.02534742f, -0.05978707f, -0.02758863f, -0.08253224f, -0.10144813f, 
    -0.06476448f, 0.02060860f, -0.20593926f, 0.21660432f, -0.04225161f, 0.04495688f, 0.03910761f, 0.04365877f, 
    0.01677063f, -0.01944194f, -0.04672561f, -0.30269372f, -0.14533001f, 0.18722899f, -0.02689517f, -0.03955023f, 
    -0.19275828f, -0.06002177f, -0.05099365f, 0.08392495f, 0.20308730f, 0.04957568f, -0.10758799f, -0.23307258f, 
    -0.26238301f, 0.10100141f, -0.07607692f, -0.05746975f, -0.06575201f, 0.04043674f, 0.14575747f, -0.08271679f, 
    0.12760521f, 0.01846456f, 0.14010417f, -0.10008477f, 0.18940474f, -0.09261185f, -0.04777901f, -0.01719263f, 
    -0.09073291f, -0.11985923f, -0.03854660f, -0.00405686f, -0.02397484f, -0.03813244f, -0.07603433f, 0.00012818f, 
    0.19609798f, 0.11966359f, 0.07219459f, 0.06254314f, -0.01268474f, -0.02719332f, 0.04496226f, -0.15510009f, 
    -0.31894207f, 0.05563522f, 0.08201946f, 0.10019177f, 0.18237370f, -0.22016281f, -0.26698625f, 0.13471304f, 
    -0.06363517f, -0.10525414f, 0.08546243f, 0.14125492f, 0.14069337f, 0.14563616f, 0.08884833f, 0.00612331f, 
    0.15290290f, 0.22666433f, -0.09712148f, 0.06295404f, 0.00702547f, -0.18141161f, -0.12582532f, -0.06181540f, 
    0.00126370f, -0.10118624f, -0.06827485f, -0.16534238f, 0.12333733f, 0.12173712f, 0.06927977f, 0.21054658f, 
    -0.05463715f, 0.08130549f, -0.03729133f, 0.08084529f, -0.06865732f, 0.14867263f, 0.05884771f, 0.07914504f, 
    0.42845342f, 0.09047937f, -0.13269866f, 0.24258538f, -0.16243890f, 0.03272497f, 0.00267722f, 0.06269587f, 
    -0.03253297f, 0.10872594f, -0.00518634f, -0.18821956f, 0.16393320f, 0.09995683f, 0.13537057f, 0.21044387f, 
    0.05333438f, -0.00411277f, -0.01206800f, 0.06357293f, -0.13779758f, 0.01494506f, -0.02431442f, 0.24523634f, 
    0.12685417f, -0.00017030f, 0.05535120f, 0.23534298f, -0.00659939f, -0.00861086f, -0.01537105f, -0.05429485f, 
    -0.03387574f, 0.05768485f, 0.06327512f, 0.11809591f, -0.27241880f, -0.07849862f, 0.08392838f, 0.06046216f, 
    -0.02413578f, 0.02590238f, -0.14661902f, -0.08520781f, -0.19472238f, -0.05248126f, -0.08365560f, -0.07934792f, 
    0.20068601f, 0.21962449f, 0.18872489f, 0.09201169f, -0.01967165f, -0.08954400f, -0.12435867f, -0.13109022f, 
    -0.06150399f, -0.03633561f, 0.14634354f, 0.20569079f, -0.14655934f, -0.11273688f, -0.01763879f, 0.12967755f, 
    -0.09897406f, 0.03383876f, -0.11708565f, -0.06605141f, 0.07070000f, -0.09235881f, -0.06272456f, -0.00003178f, 
    -0.06293545f, -0.05625847f, 0.04499171f, -0.06339780f, -0.06538367f, -0.03032213f, 0.03710355f, -0.03778077f, 
    0.03830888f, 0.05786313f, 0.01569465f, -0.03350701f, -0.01302637f, -0.00142032f, -0.05429937f, -0.06440759f, 
    -0.05795158f, -0.06649708f, 0.04633575f, 0.00057363f, 0.01348770f, -0.05190536f, -0.02146676f, -0.00135020f, 
    0.04170082f, -0.02580914f, 0.03079552f, 0.01791727f, -0.03174945f, -0.08001935f, -0.02670086f, -0.06347360f, 
    0.06448475f, -0.04529633f, 0.01871760f, -0.06441893f, -0.00380469f, 0.03747899f, 0.00812241f, 0.04708885f, 
    -0.04143158f, -0.06469845f, -0.07559833f, 0.06800177f, 0.04509524f, 0.01208331f, 0.04376946f, -0.06321549f, 
    0.00454618f, 0.03618003f, -0.00511130f, -0.04148289f, 0.02911151f, -0.06156396f, -0.03987960f, -0.05294288f, 
    0.02923280f, -0.00731633f, -0.06114131f, 0.04175578f, 0.05544724f, -0.03292572f, 0.03823382f, -0.07302059f, 
    -0.07223661f, 0.01199877f, -0.01847238f, 0.05408357f, 0.05932655f, 0.06218897f, -0.04544005f, -0.04898883f, 
    -0.04846004f, 0.03032560f, 0.06009464f, -0.02240528f, 0.01691152f, -0.01914519f, -0.05251571f, -0.04162559f, 
    -0.01504509f, -0.01960674f, -0.04111663f, 0.02369377f, -0.07827342f, -0.01550959f, -0.02711560f, 0.05500714f, 
    -0.01698213f, -0.04515128f, -0.00804326f, -0.00875957f, -0.08341792f, -0.01999537f, 0.00982098f, -0.05170048f, 
    -0.04945277f, -0.02098108f, -0.04375303f, 0.05633868f, -0.01902420f, -0.03483478f, -0.07993311f, -0.06911632f, 
    -0.01407090f, -0.05989677f, 0.05721413f, -0.04770968f, -0.03926554f, -0.07767721f, 0.00065770f, -0.05183561f, 
    -0.03882314f, 0.03306034f, 0.04346187f, 0.05263395f, 0.02937146f, -0.06893969f, 0.01730600f, 0.03711408f, 
    0.03531713f, -0.05001834f, -0.06495032f, 0.05632000f, -0.02626642f, 0.05496647f, -0.06282979f, 0.04002735f, 
    0.02551418f, -0.05341636f, -0.07528185f, -0.06049465f, -0.06002205f, 0.00040966f, -0.01906703f, 0.05425252f, 
    0.05086024f, -0.00245376f, -0.01550933f, 0.00639503f, 0.02153176f, -0.00860892f, 0.02171063f, 0.00350841f, 
    -0.05852004f, -0.02116999f, 0.06752912f, -0.06927173f, -0.01869282f, 0.05746856f, 0.04990487f, -0.05866607f, 
    0.06138676f, 0.01373040f, -0.02129764f, 0.00632904f, -0.05298246f, -0.01030893f, 0.06258830f, -0.03648118f, 
    -0.06640717f, 0.05386544f, -0.06897432f, 0.00813178f, 0.05616478f, 0.06132582f, 0.00940238f, -0.01637554f, 
    0.06226387f, -0.03646868f, -0.00409629f, 0.01266350f, 0.00765623f, -0.00048356f, -0.07938966f, -0.01655834f, 
    0.00609066f, 0.04623531f, 0.04258178f, -0.01325537f, -0.05031783f, 0.01844329f, 0.04739754f, -0.04347583f, 
    0.02681899f, -0.01885170f, 0.03626744f, -0.03455595f, -0.03521186f, 0.02212460f, -0.01084268f, 0.01188438f, 
    0.43144739f, 0.19979857f, -0.06093895f, 0.07576375f, 0.05387132f, -0.05886949f, -0.04702378f, 0.12024823f, 
    -0.16401681f, -0.05980961f, 0.05351514f, 0.07312682f, 0.18743475f, -0.06327318f, 0.02909580f, 0.01558240f, 
    0.16331297f, -0.05476566f, -0.04084126f, -0.02326963f, 0.07077117f, -0.00648047f, 0.05213743f, -0.09488981f, 
    0.18092972f, -0.11611896f, -0.09786468f, -0.06950265f, 0.03226649f, 0.08597528f, 0.03952404f, -0.00240077f, 
    -0.02902426f, 0.10058033f, 0.00041284f, -0.00828439f, -0.22452559f, 0.09993310f, 0.11715163f, 0.16696517f, 
    0.02591524f, 0.01892623f, 0.03401905f, 0.07734022f, 0.06677293f, 0.08734608f, -0.07503597f, -0.12765816f, 
    0.02363013f, 0.13475244f, 0.06317563f, 0.09963793f, 0.03151655f, -0.10157739f, 0.04724161f, -0.00833538f, 
    -0.11014155f, -0.08585350f, 0.12531015f, -0.05479516f, 0.39555702f, -0.00569192f, -0.17466927f, -0.06739380f, 
    0.02116192f, 0.02992496f, -0.17457101f, 0.14245422f, -0.00322043f, -0.15500487f, -0.09056418f, 0.03255665f, 
    -0.01238718f, 0.04057787f, 0.03419138f, -0.31421050f, 0.03484862f, -0.00369071f, 0.15474117f, 0.01129117f, 
    -0.13525315f, 0.06717747f, 0.02198957f, 0.03377030f, 0.16127738f, 0.25921288f, -0.24408652f, 0.05284277f, 
    -0.13949448f, 0.10520183f, -0.07006864f, 0.15957110f, 0.08179248f, 0.13242161f, 0.13308358f, -0.00078068f, 
    0.14781548f, 0.09985646f, -0.06485382f, -0.04546201f, -0.09333897f, -0.09400389f, -0.01832047f, -0.07084583f, 
    -0.06406043f, -0.14275993f, 0.13311234f, -0.23085818f, 0.17645563f, 0.18967147f, -0.13452613f, 0.07888276f, 
    0.02199609f, 0.05413887f, -0.15107548f, 0.10704791f, 0.20263784f, 0.05036073f, -0.07152015f, 0.17143430f, 
    0.12608141f, -0.08232708f, -0.05065770f, 0.16194488f, 0.07450286f, -0.07977373f, -0.03499950f, -0.02219004f, 
    -0.07058137f, -0.02191190f, -0.05702676f, -0.05447048f, 0.02402503f, -0.08138436f, 0.11481765f, -0.06159226f, 
    0.08522069f, -0.04414891f, 0.15371753f, 0.02419306f, 0.07230604f, 0.08410068f, 0.08180519f, 0.20148115f, 
    -0.01547023f, -0.09721167f, 0.03886024f, -0.24978825f, -0.02374776f, 0.03688547f, 0.03134919f, -0.02848157f, 
    -0.06093326f, -0.09185220f, -0.01445402f, -0.08275465f, -0.35291091f, -0.06524464f, -0.01918842f, 0.20698297f, 
    0.02865214f, -0.03635899f, -0.04119268f, -0.06930776f, -0.05790346f, 0.05965918f, -0.08432832f, -0.17108646f, 
    -0.16109352f, 0.15959026f, 0.04658259f, 0.08820532f, -0.11066122f, -0.00486374f, -0.06505565f, -0.04560657f, 
    0.12712385f, -0.00231967f, 0.05482023f, -0.01695340f, 0.03837697f, -0.09450775f, -0.10085710f, -0.12473366f, 
    0.03977808f, 0.09046923f, 0.01976685f, -0.12095611f, -0.02492565f, 0.10998425f, 0.13836393f, 0.19699545f, 
    0.08017718f, 0.19518113f, 0.18334128f, -0.15223204f, -0.09128810f, -0.09326348f, -0.09493177f, 0.01770616f, 
    -0.07410199f, -0.07725985f, -0.10538058f, -0.06004011f, -0.05681770f, 0.05346958f, 0.14493686f, -0.16301614f, 
    -0.02699163f, 0.02018557f, 0.12424286f, -0.09421128f, 0.08857179f, -0.04805093f, 0.07226485f, -0.01624727f, 
    0.10495207f, 0.15031084f, 0.03124283f, -0.02999948f, -0.08453665f, -0.05534422f, 0.09485961f, -0.10960624f, 
    -0.03143716f, 0.04448259f, 0.04902325f, -0.09040019f, 0.17235240f, -0.08152384f, 0.04613604f, 0.25543761f, 
    0.00534183f, 0.10303023f, 0.01108909f, 0.05461870f, 0.05589543f, 0.09381130f, 0.18414167f, -0.11235167f, 
    0.03739062f, -0.20240480f, -0.14900947f, 0.17250778f, -0.01449007f, 0.05245063f, 0.12044000f, -0.05197879f, 
    0.04797766f, -0.05563891f, -0.03116787f, -0.01371370f, -0.00321217f, -0.06810223f, -0.04385651f, -0.12059722f, 
    0.02259697f, 0.04488476f, -0.05557920f, 0.06681190f, -0.00659861f, -0.10051087f, -0.04277870f, 0.11690923f, 
    -0.12796469f, -0.11508451f, 0.08442570f, -0.21926118f, 0.04962157f, -0.04987555f, 0.09229726f, 0.07312978f, 
    0.02238091f, 0.07088764f, 0.08162881f, 0.07048440f, -0.01171714f, -0.06945736f, -0.05479376f, -0.01932333f, 
    -0.03772733f, 0.08857101f, -0.02597090f, 0.05144128f, 0.02623118f, -0.03755176f, -0.07167393f, 0.00891054f, 
    0.32834682f, -0.17569791f, -0.24278893f, 0.00342195f, -0.03431561f, 0.00387079f, -0.24408834f, 0.11386289f, 
    -0.07808944f, -0.02788772f, 0.20762837f, 0.07547556f, 0.01781666f, -0.12001891f, 0.28207976f, -0.23298344f, 
    -0.14261733f, 0.03877821f, 0.08277126f, -0.00146231f, -0.01351573f, 0.08080596f, 0.07513877f, 0.01546601f, 
    0.07121219f, -0.01571776f, -0.03240547f, 0.27663159f, 0.09481577f, -0.01995824f, -0.10769623f, 0.02492918f, 
    -0.07889024f, 0.03544924f, 0.11714164f, 0.00481169f, 0.25495952f, -0.18829519f, -0.10276885f, 0.07199487f, 
    0.05350880f, 0.00418425f, 0.02833530f, -0.05391211f, -0.08581289f, -0.02131525f, -0.05442059f, 0.07962934f, 
    0.28470334f, 0.08760262f, 0.07930720f, -0.16133970f, 0.01859919f, -0.02701700f, 0.03561871f, 0.25238425f, 
    -0.04168826f, -0.08735163f, -0.03616710f, 0.00129360f, -0.31705910f, -0.17660335f, 0.13615957f, 0.17484571f, 
    -0.06410263f, -0.04147210f, -0.04486434f, -0.02548808f, -0.02426130f, -0.08399876f, 0.07506548f, -0.19045207f, 
    -0.11067826f, 0.16197458f, -0.10955271f, -0.02909193f, 0.10881269f, 0.09790660f, -0.06432003f, -0.02368032f, 
    -0.04180664f, 0.02959398f, -0.10273831f, 0.04323686f, 0.33001775f, -0.03416482f, -0.09051961f, 0.04068121f, 
    0.11200791f, 0.09629449f, 0.05719886f, -0.01450267f, 0.05626434f, 0.06645262f, 0.12134443f, -0.00783509f, 
    -0.09817580f, -0.19587427f, 0.01210272f, -0.05674442f, -0.08627211f, -0.06523681f, 0.00833021f, 0.03908157f, 
    0.08853343f, 0.03780942f, 0.09693106f, 0.11162618f, 0.07934681f, 0.42150664f, -0.09581114f, 0.25769886f, 
    -0.06215716f, 0.12038077f, 0.10955915f, 0.00924400f, -0.04848775f, 0.04959784f, 0.01814200f, 0.06965178f, 
    -0.12707764f, -0.15986657f, 0.05391338f, 0.19452628f, -0.05046714f, 0.03511547f, 0.12393173f, 0.09408981f, 
    0.18247308f, -0.03663772f, 0.02123280f, 0.08284458f, 0.29370439f, -0.09367329f, -0.02788956f, -0.14264196f, 
    -0.10170127f, -0.07386113f, 0.11004392f, 0.05440578f, -0.07697984f, 0.03758309f, 0.00642455f, 0.12073072f, 
    -0.24058342f, 0.20766313f, -0.13165809f, 0.11549459f, -0.01664605f, 0.15767550f, 0.03062840f, -0.14392172f, 
    -0.05362204f, -0.00896208f, 0.13832346f, 0.03000386f, -0.14990631f, -0.00492790f, -0.00588569f, 0.13876766f, 
    0.00066109f, 0.08284027f, 0.07366765f, 0.02555351f, 0.03562867f, 0.13671745f, 0.02327796f, 0.05877441f, 
    -0.06447329f, -0.21240835f, 0.01185913f, -0.09018157f, 0.02043675f, -0.00532789f, 0.07556294f, -0.06001368f, 
    -0.07001288f, -0.08477900f, -0.01981704f, 0.04226658f, -0.24794608f, -0.15758187f, -0.07004641f, 0.12143782f, 
    0.12442489f, -0.08522043f, 0.12156630f, -0.09283574f, 0.07965477f, 0.04161660f, 0.04845146f, -0.08198398f, 
    0.02940303f, -0.01892943f, -0.24302340f, -0.11350843f, -0.03115376f, -0.04426568f, 0.01665679f, -0.04313657f, 
    0.04175455f, -0.13223061f, 0.02829501f, -0.00049132f, 0.00771416f, -0.02896590f, -0.13413005f, 0.00332863f, 
    0.00915682f, 0.07565259f, 0.22181456f, -0.03938404f, -0.08046693f, 0.02196134f, -0.04553086f, 0.15043414f, 
    0.33195457f, -0.19371469f, 0.05771656f, 0.07692263f, -0.16900986f, 0.14908262f, 0.05412065f, 0.14952540f, 
    0.01454099f, 0.11866987f, 0.06580597f, 0.06030389f, 0.00861953f, 0.11015385f, -0.02917826f, 0.01524551f, 
    0.04877657f, 0.06743231f, 0.00734160f, 0.13059218f, -0.01651724f, -0.04384397f, -0.06809088f, 0.02168918f, 
    -0.09765132f, -0.02472631f, -0.13210122f, -0.20320648f, -0.10912076f, 0.06516076f, -0.06166408f, -0.05929935f, 
    0.03318702f, 0.10322784f, 0.09852760f, -0.03749285f, 0.29972458f, 0.12633069f, -0.01467664f, 0.17282310f, 
    0.05573791f, 0.00841973f, 0.04665778f, 0.09982720f, -0.07024598f, 0.05543066f, -0.02334372f, 0.15222096f, 
    -0.03362373f, 0.07668287f, -0.05297504f, -0.03231747f, 0.05854891f, 0.00820404f, -0.02147402f, -0.00432185f, 
    -0.03508607f, 0.08743378f, 0.03371527f, 0.08888006f, 0.06738243f, -0.12170899f, 0.09762537f, -0.16152532f, 
    -0.06816558f, 0.02913811f, 0.07068823f, 0.02312391f, -0.00570636f, -0.07711526f, 0.02299373f, -0.09068155f, 
    -0.08601867f, 0.16301350f, 0.07418206f, -0.02407418f, 0.00291058f, 0.01688459f, -0.04234315f, 0.03239650f, 
    -0.00017519f, 0.08074754f, -0.06609235f, -0.06717205f, -0.02795947f, -0.22458234f, 0.12870722f, 0.07574019f, 
    -0.11309576f, -0.05524555f, -0.03718327f, -0.10196918f, 0.03708608f, 0.02437939f, -0.00227124f, -0.07606171f, 
    -0.05295188f, -0.15521568f, -0.10620899f, -0.23187505f, 0.05166858f, -0.15783224f, -0.07127939f, -0.08467689f, 
    0.01268027f, 0.06237565f, -0.05260681f, 0.02284764f, 0.16319087f, -0.07503267f, -0.01049788f, 0.02160810f, 
    -0.01642661f, 0.07458690f, 0.13273817f, 0.16035447f, -0.02108080f, -0.10524997f, 0.01004870f, -0.06441285f, 
    -0.14139263f, 0.11812488f, -0.06243239f, 0.10130975f, 0.03392843f, -0.02774548f, -0.03550170f, 0.11000015f, 
    -0.09657817f, 0.01531678f, -0.04673980f, 0.05550886f, 0.06904265f, 0.04014702f, 0.09534831f, 0.07047903f, 
    -0.01106435f, 0.09326855f, -0.09028441f, 0.05839096f, 0.10400994f, -0.10642542f, -0.03408696f, 0.06059000f, 
    0.13586158f, 0.05123606f, -0.01316124f, 0.06136024f, 0.04719229f, 0.02293874f, 0.19216317f, -0.06410242f, 
    -0.06441671f, 0.13395561f, 0.06461947f, 0.14463638f, 0.20353623f, -0.10094568f, -0.01375876f, -0.13701728f, 
    -0.16028954f, 0.09934224f, 0.00494548f, 0.01890072f, -0.01740906f, 0.12166475f, 0.06060687f, 0.16616072f, 
    0.09066226f, 0.26723754f, -0.07004613f, -0.02402085f, 0.02409131f, 0.02719260f, -0.04722402f, 0.12541528f, 
    0.00905079f, 0.08266848f, -0.03989146f, -0.11125852f, 0.03069821f, -0.24354354f, 0.01889879f, -0.01430765f, 
    0.02134519f, 0.02832253f, 0.05567971f, -0.05440659f, 0.04346542f, -0.02469670f, -0.05581402f, -0.02202003f, 
    -0.01421154f, 0.16404003f, -0.17088909f, 0.00942211f, 0.08590232f, -0.07330691f, -0.02801140f, -0.04816310f, 
    -0.05930701f, 0.04928061f, 0.05861113f, 0.09594539f, -0.42273259f, 0.25500157f, 0.08793769f, 0.13154556f, 
    0.15164648f, -0.07438128f, 0.09341168f, -0.18858066f, 0.00907859f, 0.16614488f, 0.00351269f, 0.02029290f, 
    0.28455704f, 0.14017001f, -0.01778986f, 0.09386656f, 0.09198198f, -0.12940602f, -0.08994459f, 0.13626191f, 
    0.08931573f, -0.04314899f, -0.18792328f, 0.03172947f, -0.19645382f, -0.02260329f, 0.02012370f, 0.12048674f, 
    -0.08923063f, -0.00259106f, 0.01517736f, 0.06121293f, 0.04476508f, -0.07157672f, -0.06196635f, -0.06864629f, 
    0.09630138f, -0.00067672f, 0.25318336f, 0.05578619f, 0.04600582f, 0.09782428f, -0.00534041f, 0.09296957f, 
    0.09702531f, -0.03340406f, 0.02119242f, 0.00133696f, -0.26117325f, 0.05114218f, -0.14795309f, 0.17165095f, 
    0.05054132f, -0.05836815f, 0.19891573f, 0.09316633f, 0.01672133f, 0.02824573f, 0.15557700f, 0.05300976f, 
    0.04947338f, 0.04378768f, 0.01664638f, -0.00699333f, 0.06369987f, -0.02224726f, -0.05803485f, -0.01928032f, 
    -0.03817031f, 0.04591490f, -0.00903609f, -0.02860716f, -0.06663564f, 0.00236670f, -0.06820107f, 0.02524938f, 
    -0.04628394f, 0.03286759f, 0.00103229f, -0.04266319f, 0.04480093f, -0.03491662f, -0.05237272f, -0.03503507f, 
    0.02228075f, -0.06891592f, 0.00843550f, -0.06625249f, -0.05774052f, 0.01607065f, -0.04626309f, -0.01777987f, 
    -0.00351283f, 0.00243146f, 0.03300397f, -0.05107709f, -0.03996897f, 0.00762821f, 0.03747233f, -0.01480510f, 
    -0.05046060f, 0.02639308f, 0.06644022f, 0.07256755f, -0.06487928f, -0.04919595f, -0.05126199f, -0.04084764f, 
    0.00385725f, 0.02105871f, 0.01720425f, 0.02218892f, 0.05278914f, 0.00893196f, -0.00573924f, -0.03695420f, 
    -0.02570610f, 0.01563782f, 0.06723052f, 0.03617652f, -0.02314668f, 0.03171542f, 0.03947390f, -0.03072601f, 
    0.00074909f, -0.05131022f, 0.00979100f, -0.06976490f, 0.00245996f, 0.05712358f, 0.00550649f, -0.04757342f, 
    -0.04684593f, -0.04922247f, 0.06742955f, -0.04491585f, -0.04718239f, -0.00833850f, -0.04146536f, -0.02152773f, 
    -0.04345541f, 0.00472291f, 0.02748621f, -0.03577304f, -0.02436136f, -0.00508300f, 0.06407000f, 0.06100303f, 
    0.01751132f, -0.04468621f, -0.03154892f, -0.01505659f, -0.01839544f, 0.02057592f, 0.06009687f, -0.06453989f, 
    -0.03991832f, -0.04947140f, -0.05259813f, 0.01385581f, -0.02972362f, 0.06544322f, -0.00377988f, -0.01158052f, 
    0.05637320f, -0.05167647f, -0.06266548f, -0.00932973f, -0.03271004f, -0.01216344f, -0.05586370f, -0.04531764f, 
    -0.05860491f, 0.02108526f, 0.06399097f, 0.06461076f, 0.02609930f, 0.03052128f, -0.06399596f, -0.07186466f, 
    -0.03382712f, -0.00564577f, -0.03215339f, 0.01227141f, 0.03575981f, -0.04187436f, -0.00843935f, 0.02470789f, 
    -0.06618083f, -0.07022788f, 0.06543357f, -0.07005479f, 0.02189171f, -0.00040616f, -0.00111953f, -0.01817932f, 
    0.02313877f, -0.06723931f, 0.04977582f, -0.05570508f, 0.04757166f, -0.01105636f, 0.04378173f, 0.05787862f, 
    -0.06496793f, 0.04768499f, 0.06100164f, -0.03994958f, -0.06090646f, -0.01989518f, 0.03747326f, -0.06351400f, 
    -0.01487540f, 0.01637088f, -0.01800441f, -0.03472979f, 0.04222554f, 0.04548344f, -0.01424367f, 0.01442319f, 
    -0.05268360f, 0.03422530f, 0.00257627f, -0.02372361f, -0.05749822f, 0.03009010f, -0.03973636f, 0.05286276f, 
    0.02730761f, 0.01689390f, 0.03794446f, -0.07141404f, 0.06072547f, -0.01757663f, 0.01682468f, 0.05983069f, 
    0.02058974f, -0.04311307f, -0.06825503f, 0.07005648f, 0.02018729f, 0.03574617f, -0.03725642f, -0.05087457f, 
    -0.02660042f, 0.00345331f, 0.00536191f, 0.05256354f, -0.05000663f, -0.03859837f, 0.01735415f, -0.01627140f, 
    0.06923109f, 0.16397756f, -0.00053849f, -0.05412864f, 0.08128078f, 0.10593208f, -0.03572292f, -0.22568187f, 
    -0.02820239f, 0.03620302f, 0.04082459f, -0.04503318f, -0.03837948f, -0.26209062f, 0.08103538f, -0.01602948f, 
    0.05536903f, 0.00790471f, -0.04989214f, -0.14629520f, 0.02700371f, 0.04268774f, 0.03648095f, -0.16696750f, 
    0.07311787f, 0.26558039f, -0.09419300f, -0.12986417f, 0.10410812f, 0.05386569f, 0.04086431f, -0.12099283f, 
    -0.09563213f, 0.13904186f, -0.07645552f, 0.03009830f, -0.17355205f, 0.02831567f, -0.26346967f, 0.02363499f, 
    0.09018534f, -0.02612070f, -0.02551877f, 0.02354751f, 0.08036046f, 0.05126566f, 0.15273888f, -0.05981930f, 
    0.09602117f, -0.07762468f, 0.17840579f, -0.05047949f, 0.07676058f, -0.21366149f, -0.01983621f, 0.03251893f, 
    -0.05378016f, -0.11982790f, 0.09283453f, 0.04600924f, 0.03927122f, 0.06290820f, 0.06242359f, -0.20583399f, 
    -0.03018824f, 0.14409733f, 0.03204127f, -0.06796709f, 0.14146812f, -0.11611611f, 0.10437166f, 0.04965600f, 
    -0.28657845f, 0.14078102f, 0.10520194f, 0.14627482f, -0.04624883f, 0.04407396f, -0.01899431f, 0.17657235f, 
    -0.07082121f, 0.03528757f, -0.03831333f, -0.00747063f, 0.03051541f, 0.02831634f, 0.07151898f, -0.01118518f, 
    0.01872880f, 0.25684571f, -0.04702200f, -0.00981679f, -0.01388384f, 0.06449072f, -0.05849221f, 0.15900327f, 
    0.09337015f, -0.01889030f, 0.24730437f, 0.11519547f, 0.03766770f, -0.10125940f, -0.13669291f, 0.02042814f, 
    -0.01742271f, -0.01958114f, 0.04091506f, -0.01801844f, 0.04710277f, 0.23508711f, 0.14465873f, -0.02440987f, 
    0.02988319f, -0.04898149f, -0.07835184f, 0.01097857f, 0.07567548f, 0.07563803f, 0.10537702f, -0.03361965f, 
    -0.05814939f, 0.10077925f, -0.07154092f, -0.06628041f, 0.06088809f, -0.18796197f, 0.07200527f, -0.10202607f, 
    -0.03388796f, 0.00907671f, -0.06035779f, 0.19572383f, 0.05306871f, -0.13662879f, -0.04058333f, 0.08215000f, 
    0.04513562f, 0.04242971f, 0.09064874f, -0.06397557f, -0.02905251f, 0.11756001f, 0.00970785f, 0.03145860f, 
    0.15420821f, 0.03626350f, 0.20600148f, 0.03550596f, 0.13650024f, 0.00536530f, 0.08667755f, 0.06359919f, 
    -0.08829398f, -0.06067706f, 0.02281570f, -0.11385896f, -0.26161823f, -0.02344568f, 0.31081417f, -0.03224124f, 
    -0.02299643f, -0.03857970f, 0.00517560f, -0.11990621f, 0.02626217f, 0.00576621f, -0.02531023f, -0.19704285f, 
    0.42058712f, -0.11052859f, -0.06787942f, -0.01179328f, 0.09313031f, 0.00225521f, 0.01216775f, -0.02094485f, 
    0.02417809f, -0.06695756f, 0.00744576f, -0.08091123f, -0.10412788f, 0.27922046f, -0.27254736f, 0.13051936f, 
    0.09442043f, 0.01739265f, -0.06170031f, 0.09961689f, 0.10561220f, 0.00835031f, 0.06762940f, 0.03643107f, 
    -0.12292853f, 0.32710263f, 0.23962383f, -0.03958161f, 0.03457619f, 0.04001660f, -0.06150921f, 0.08391433f, 
    0.12793477f, 0.10487822f, -0.02700474f, 0.05897408f, -0.03392289f, 0.29621115f, 0.39475724f, 0.13285340f, 
    -0.21300705f, -0.22363508f, -0.07915287f, -0.01356787f, 0.01412831f, 0.08049543f, 0.03330765f, 0.12471886f, 
    -0.00004932f, -0.18550159f, 0.16396299f, -0.00229111f, -0.03619418f, 0.03378658f, -0.01809721f, 0.07290699f, 
    0.05024701f, 0.05931324f, 0.10364899f, -0.06449223f, 0.22318605f, -0.28838471f, 0.03875450f, 0.20528996f, 
    0.00968067f, -0.03335270f, -0.02379671f, 0.03124905f, 0.06825802f, 0.00603895f, 0.12513983f, -0.03842734f, 
    0.18686016f, -0.18153359f, 0.11525861f, 0.27617303f, -0.02381025f, 0.09653317f, 0.06355152f, 0.03184080f, 
    0.02939407f, 0.13874526f, -0.03012050f, -0.08026300f, -0.10051353f, 0.11151169f, 0.24669261f, 0.20112769f, 
    0.03609584f, -0.01313585f, -0.06016416f, -0.14465109f, 0.12378863f, 0.08893031f, 0.12754281f, 0.08472428f, 
    -0.09337551f, -0.21301883f, 0.03364911f, -0.18845813f, 0.12610182f, -0.06865663f, 0.09384374f, -0.03525651f, 
    -0.10121628f, -0.06632107f, -0.02512082f, 0.12831527f, -0.04831774f, 0.13798578f, 0.29774916f, 0.08282492f, 
    -0.04390860f, -0.06529695f, -0.11744335f, -0.08971562f, 0.03073444f, 0.02449592f, 0.02037725f, 0.02549663f, 
    -0.24622254f, 0.07462462f, -0.09310558f, -0.12150418f, 0.22663082f, 0.21440238f, -0.03104700f, -0.01828236f, 
    0.16000658f, -0.10384870f, -0.17329688f, 0.13879991f, -0.34832045f, -0.03757655f, -0.03684172f, -0.15851018f, 
    0.04596730f, -0.06356143f, -0.02901169f, -0.15422615f, 0.01227821f, -0.02853670f, 0.03622328f, -0.01603022f, 
    0.08599289f, -0.00324488f, -0.12653285f, 0.14362627f, -0.08183818f, -0.00757440f, 0.02058594f, -0.00156084f, 
    -0.07150835f, 0.17112684f, 0.14261776f, 0.09887917f, -0.43812481f, -0.02701878f, -0.18932965f, -0.09784053f, 
    0.20400378f, 0.02455489f, 0.04460170f, 0.04442013f, -0.19063213f, 0.03476759f, 0.03614075f, -0.19427224f, 
    -0.27067506f, -0.16700377f, -0.10015340f, -0.13430986f, 0.12798390f, 0.03240239f, 0.06026570f, 0.13519265f, 
    0.02906905f, 0.01796489f, -0.09978679f, 0.03390900f, 0.19284654f, -0.06914894f, 0.01753974f, 0.12309820f, 
    -0.03256674f, -0.14724836f, 0.00626947f, 0.12475455f, 0.14208366f, 0.09678062f, -0.04086107f, 0.15751480f, 
    -0.21196121f, -0.06196769f, -0.01380443f, -0.09980927f, -0.05282979f, -0.02098637f, -0.13466184f, 0.02823517f, 
    -0.00426054f, 0.19904797f, -0.13051681f, -0.11443025f, 0.10787518f, -0.24311414f, 0.22115381f, -0.09629118f, 
    0.07841805f, 0.00364672f, 0.03371316f, 0.12870388f, -0.07914396f, 0.00175233f, 0.03144380f, 0.08050469f, 
    -0.03260095f, 0.02175837f, 0.03797626f, -0.04225690f, -0.03167708f, 0.03337001f, 0.05227019f, 0.00233390f, 
    -0.01772450f, -0.06238293f, -0.00876020f, -0.05933720f, 0.04172112f, -0.07571916f, -0.04606690f, -0.01132371f, 
    -0.03103887f, 0.03570471f, -0.05552337f, -0.03885690f, -0.04460211f, -0.05786783f, -0.00119777f, 0.04640146f, 
    -0.00913312f, -0.05390222f, -0.07949635f, -0.04268472f, 0.02260268f, 0.04397498f, 0.04963965f, 0.03711165f, 
    0.02067336f, -0.03893775f, -0.04399891f, 0.05512423f, 0.03124523f, 0.04433266f, -0.00525191f, 0.05975155f, 
    -0.05576345f, -0.01170594f, -0.07586446f, -0.02168547f, -0.01635079f, -0.02483570f, -0.07903314f, -0.06331734f, 
    0.03951250f, -0.03615471f, -0.03918864f, -0.05946771f, -0.06390359f, 0.05657978f, -0.07229771f, 0.05097616f, 
    0.02575009f, -0.02843731f, -0.07676060f, 0.03937801f, -0.06347481f, 0.02870282f, 0.05913378f, 0.01984485f, 
    0.01540967f, -0.06531392f, -0.00182224f, -0.06165897f, -0.04180513f, 0.00256232f, 0.00387693f, -0.02003476f, 
    -0.03197215f, -0.02233983f, -0.00792989f, 0.00753639f, 0.06056515f, 0.02402535f, -0.04074691f, 0.04054454f, 
    0.03708757f, -0.00189846f, -0.01357820f, -0.01518475f, -0.07791960f, -0.02160033f, 0.05544800f, 0.00754194f, 
    -0.06062360f, 0.02165273f, -0.02437428f, 0.04165280f, -0.02616990f, -0.00581561f, -0.00952857f, 0.05404737f, 
    -0.03009773f, -0.04280149f, -0.03480299f, -0.04086344f, 0.00560508f, 0.02896553f, 0.05396290f, 0.00732284f, 
    -0.04880766f, -0.00304634f, 0.01203158f, 0.05790412f, -0.06229773f, -0.01036299f, 0.06061153f, -0.06568069f, 
    0.00285128f, 0.00682611f, -0.07703587f, -0.03129554f, -0.07326877f, 0.03149150f, -0.06002440f, 0.04680263f, 
    -0.04530028f, -0.07319737f, -0.01030233f, 0.01572769f, 0.03165619f, 0.01614583f, -0.04072401f, -0.00769870f, 
    -0.06367550f, 0.04160652f, -0.06273078f, -0.05786950f, -0.06556994f, 0.02754755f, -0.07865894f, 0.00140813f, 
    0.00601082f, -0.06134003f, 0.02757332f, -0.00271846f, -0.03634094f, 0.02565643f, -0.01091999f, 0.04584474f, 
    0.04692458f, -0.01981292f, -0.00369242f, 0.05614246f, -0.06255523f, 0.05682267f, -0.04979512f, 0.00000968f, 
    0.01413099f, -0.04596576f, -0.03142262f, -0.00284522f, -0.05070303f, -0.06930918f, 0.02041655f, 0.00339432f, 
    0.05855403f, -0.00688775f, -0.01675867f, 0.04026574f, -0.05245361f, -0.04774163f, -0.05839991f, -0.00651842f, 
    -0.04292390f, -0.04985160f, 0.00189418f, -0.03780982f, -0.06882064f, 0.03971601f, -0.06377101f, -0.06948750f, 
    0.04994650f, -0.03391307f, 0.00433038f, -0.04991168f, 0.02097328f, -0.04233274f, -0.05591052f, -0.03184895f, 
    0.05039730f, 0.06275811f, -0.04478955f, -0.02290381f, 0.05388073f, 0.05920010f, -0.00593270f, 0.03317041f, 
    -0.14592274f, 0.11975933f, 0.00522834f, -0.16114385f, 0.14614680f, 0.14306304f, -0.09600424f, -0.06353492f, 
    0.02941108f, -0.06560618f, -0.04990546f, -0.01096239f, -0.00204868f, -0.01153167f, 0.26731953f, -0.13261455f, 
    0.04841859f, 0.04542637f, -0.16943650f, 0.02204624f, 0.01578638f, -0.00149798f, -0.01900472f, 0.07663854f, 
    0.10875375f, -0.12333328f, -0.03171126f, -0.45127410f, 0.15670259f, -0.07296579f, -0.13999768f, -0.14662158f, 
    0.00234873f, -0.00135217f, 0.03554951f, -0.10142151f, 0.13681446f, 0.03439113f, 0.08302058f, 0.07077489f, 
    -0.00761176f, 0.10680202f, -0.05002987f, -0.05199266f, 0.02750637f, -0.07364674f, 0.01772960f, -0.07540442f, 
    0.04781054f, -0.22940265f, 0.02391284f, 0.15829737f, -0.03687305f, -0.10329468f, -0.02516104f, 0.04743801f, 
    0.04333447f, -0.01286746f, -0.07302165f, 0.14547178f, 0.18293817f, -0.10046889f, 0.10550439f, 0.01954672f, 
    -0.02726739f, 0.04981681f, 0.03932457f, -0.18202759f, 0.03122594f, -0.12572953f, -0.08738600f, 0.10745905f, 
    0.21507949f, 0.02685090f, -0.08112411f, -0.01281497f, 0.07360673f, 0.06616951f, 0.12724651f, 0.05093634f, 
    0.00464517f, 0.02562110f, 0.09246416f, 0.18476745f, 0.07443175f, -0.19228470f, 0.16577037f, -0.05772664f, 
    0.00786999f, -0.03734768f, -0.14878270f, -0.07110271f, 0.06877906f, -0.09738091f, 0.08568540f, 0.13778834f, 
    -0.35075983f, 0.01083354f, -0.09532867f, 0.02873963f, 0.17881596f, -0.05215216f, -0.04716428f, -0.01316669f, 
    -0.04678930f, 0.08153234f, -0.07665225f, -0.02774498f, -0.45201656f, 0.01684943f, 0.24597691f, -0.21549772f, 
    0.02292375f, 0.06505682f, 0.03497293f, -0.05032002f, 0.01041628f, 0.00872256f, 0.03910934f, 0.05890453f, 
    -0.12503110f, 0.14346007f, -0.27789047f, 0.04957265f, 0.04971874f, -0.14293347f, 0.03419222f, -0.02237403f, 
    0.00116165f, 0.04120080f, 0.05471231f, 0.06175300f, -0.63391238f, 0.17438941f, -0.05558691f, -0.00798508f, 
    0.06403521f, 0.05369837f, -0.04917059f, 0.10008511f, -0.03847261f, 0.02385625f, 0.05664690f, 0.07011512f, 
    0.12692577f, -0.05035452f, -0.00696819f, 0.00416376f, 0.10395183f, -0.08417776f, 0.02457344f, 0.12778465f, 
    0.08612246f, 0.06178856f, 0.01253038f, 0.09280717f, 0.05156722f, -0.02002456f, -0.03531772f, 0.04686892f, 
    -0.07474057f, -0.03338526f, 0.03248299f, -0.02153952f, 0.14106217f, -0.04324637f, 0.03468240f, -0.03594561f, 
    -0.02306874f, -0.12850524f, 0.20160508f, -0.06974750f, 0.05457883f, 0.16129753f, 0.03199524f, 0.13164707f, 
    -0.07949442f, 0.05313465f, 0.02429163f, 0.02580273f, -0.05206230f, 0.32486877f, 0.00969042f, 0.14521535f, 
    0.03906173f, -0.04758840f, 0.11883644f, 0.09615120f, 0.09265795f, 0.05294281f, -0.00427940f, 0.00126969f, 
    -0.04470304f, -0.01894705f, 0.01970278f, 0.03381259f, 0.01123496f, 0.00106178f, 0.01205553f, 0.05249726f, 
    -0.06628481f, -0.06001872f, -0.04526212f, -0.05430365f, -0.07436832f, -0.08149654f, -0.06746243f, -0.08111832f, 
    -0.04133758f, -0.02014500f, 0.01497056f, 0.02995611f, 0.03149329f, -0.05176812f, 0.05574227f, 0.05210621f, 
    -0.01262611f, 0.03773868f, -0.03225764f, 0.03351064f, 0.04637789f, -0.04398502f, -0.01653033f, -0.02508869f, 
    -0.00854553f, -0.00579967f, 0.03222680f, -0.07529338f, -0.06115620f, -0.02263416f, -0.06818685f, -0.02774969f, 
    0.02318952f, -0.03582074f, 0.02776439f, -0.04822746f, 0.04221708f, 0.05728930f, 0.03351577f, -0.00894615f, 
    0.02624921f, -0.07013439f, 0.03062198f, -0.00752171f, -0.05297708f, 0.05424739f, -0.06444941f, 0.01019069f, 
    0.00588139f, 0.02370195f, -0.05822328f, -0.07305168f, -0.03020258f, 0.05346019f, 0.01683709f, -0.04734443f, 
    -0.06638176f, 0.01309208f, -0.03130871f, -0.05473782f, -0.06062087f, 0.00172432f, 0.04111895f, -0.01562215f, 
    -0.06534749f, -0.04708318f, 0.05590289f, 0.01417172f, -0.05166342f, -0.07505971f, -0.01575589f, -0.02935920f, 
    -0.01477245f, -0.00469446f, -0.04341252f, 0.04069970f, 0.01275437f, -0.03797399f, -0.06075678f, -0.02658009f, 
    0.02523451f, -0.05027797f, 0.01016121f, -0.02253487f, 0.01435908f, -0.00853297f, -0.02849953f, -0.03571777f, 
    0.04968409f, -0.05234139f, 0.03758076f, 0.05228501f, -0.02717322f, 0.05734185f, -0.04894590f, -0.08127005f, 
    -0.00665680f, 0.03178325f, -0.06404522f, -0.07445233f, 0.01936630f, -0.03122119f, -0.07960325f, 0.00837635f, 
    -0.01754070f, -0.00159615f, -0.03714563f, 0.02844821f, 0.06270999f, 0.00651496f, 0.03160880f, -0.02375303f, 
    -0.01751404f, 0.01079597f, 0.04939861f, -0.02480749f, -0.06009586f, -0.07153833f, 0.05868734f, -0.06786502f, 
    -0.06831632f, 0.00902344f, -0.06305176f, -0.00797889f, -0.01364487f, -0.07732907f, 0.02951144f, -0.03590312f, 
    0.02055947f, -0.01045371f, 0.05888769f, -0.00929057f, -0.03587203f, 0.00911997f, 0.01500274f, 0.05598767f, 
    -0.01376471f, 0.04614514f, 0.05700769f, -0.06261577f, -0.00798146f, 0.02937468f, 0.02731923f, 0.03381606f, 
    -0.01455673f, 0.05776898f, 0.05162634f, -0.00054388f, -0.05990162f, -0.03355084f, 0.02884662f, 0.01656158f, 
    0.01808698f, -0.00511390f, -0.01764832f, -0.00165179f, -0.01849282f, -0.05960929f, 0.01436080f, 0.01801715f, 
    -0.07995682f, 0.04950486f, 0.00757664f, 0.05556155f, -0.03687318f, 0.05747887f, 0.00867502f, -0.04641537f, 
    -0.06463465f, -0.05182485f, 0.05511682f, 0.01935889f, -0.07910296f, -0.04971328f, -0.05084158f, -0.01043214f, 
    -0.07983182f, -0.05930058f, -0.03153676f, 0.00654671f, -0.07206462f, -0.01845046f, -0.07743932f, -0.00018584f, 
    -0.12913285f, 0.17918146f, 0.09706949f, -0.09244467f, -0.03127119f, -0.11170166f, -0.10129034f, 0.01599955f, 
    0.13102943f, -0.06643413f, -0.08389917f, -0.08040941f, -0.29819959f, -0.06950295f, 0.22034779f, -0.39247829f, 
    -0.00478007f, -0.08893998f, -0.00582474f, -0.10825419f, 0.07192236f, -0.04351115f, -0.00008261f, 0.00867151f, 
    -0.14742154f, 0.20832996f, 0.08244565f, 0.12106472f, 0.10006686f, 0.03918185f, -0.03346831f, -0.10268458f, 
    -0.10129009f, 0.13686216f, 0.09427491f, -0.02931049f, -0.05559709f, 0.09549503f, 0.01303987f, 0.38063136f, 
    -0.06247902f, 0.05404060f, -0.15254930f, -0.01948107f, 0.15962937f, -0.08755516f, 0.11773443f, -0.18692504f, 
    0.15538648f, -0.19085494f, 0.19545791f, 0.07438856f, 0.07495787f, 0.06037900f, 0.05250054f, 0.09608253f, 
    0.10720802f, -0.03978194f, -0.08956502f, -0.02146048f, -0.11764099f, -0.09131390f, 0.15665309f, -0.21361622f, 
    0.02783543f, -0.00734833f, -0.11154895f, -0.11867380f, -0.04369016f, -0.00538759f, -0.00386084f, -0.00934346f, 
    -0.02906873f, 0.05363645f, 0.06432586f, -0.02918657f, 0.05273370f, 0.10939083f, 0.09064901f, 0.08502775f, 
    -0.00044808f, 0.03843359f, 0.08703130f, -0.01823436f, -0.04874520f, 0.16827054f, 0.05097172f, -0.02077545f, 
    -0.12678072f, -0.03488605f, -0.07890711f, 0.05096134f, -0.01886767f, -0.00911416f, 0.04314144f, 0.08759062f, 
    0.06912121f, -0.15705384f, 0.11995979f, 0.09069223f, 0.02987279f, 0.11228769f, -0.03683746f, 0.01518664f, 
    0.00583869f, -0.00359519f, 0.01464581f, -0.02211262f, -0.06025312f, 0.11250646f, 0.11969283f, 0.00770771f, 
    -0.02339786f, 0.02454921f, -0.03027514f, 0.08923814f, 0.03418989f, -0.04584519f, -0.03209530f, -0.05294942f, 
    0.04562151f, 0.12012295f, -0.01109328f, 0.19418949f, -0.09145273f, 0.04695822f, -0.03757305f, 0.03226532f, 
    -0.08551269f, -0.03651321f, 0.11223211f, -0.09557847f, 0.25528985f, -0.08379705f, 0.06102702f, -0.02067958f, 
    -0.04427084f, -0.02648132f, 0.10655546f, -0.08430424f, 0.05515930f, 0.14020351f, 0.14883785f, 0.00988132f, 
    0.12480368f, 0.21933512f, 0.17995939f, 0.11282861f, 0.00788814f, -0.03628167f, 0.07792055f, 0.13692302f, 
    -0.10776158f, 0.02028616f, -0.06458578f, 0.07841830f, -0.15942366f, -0.13484702f, 0.16413897f, -0.16376209f, 
    -0.11117319f, 0.04828973f, -0.01725940f, -0.09367773f, -0.03217407f, 0.01926890f, 0.06496380f, -0.01709839f, 
    0.17343092f, 0.11789324f, -0.05181128f, -0.02964001f, 0.18464378f, 0.00842388f, -0.01166706f, -0.04300670f, 
    0.02812335f, 0.12499043f, -0.00136955f, 0.01284699f, 0.12562619f, -0.00578334f, 0.00243745f, 0.10370988f, 
    0.13700280f, 0.13024347f, -0.10155361f, 0.02178676f, 0.04062213f, -0.06085019f, -0.01556430f, 0.02046408f, 
    0.06100765f, 0.05216402f, -0.00565131f, -0.03145298f, -0.07078794f, 0.06247456f, -0.06936834f, -0.04537303f, 
    -0.02811980f, -0.05672611f, 0.04113726f, -0.04382330f, -0.01882413f, -0.00926946f, 0.05010130f, -0.03267692f, 
    -0.05211776f, -0.04973998f, -0.03786200f, -0.07836769f, -0.07080097f, 0.00214363f, -0.00639397f, -0.07929017f, 
    -0.00184055f, 0.02243423f, 0.02536306f, 0.03272581f, -0.05994701f, -0.05809826f, 0.04294826f, 0.05777793f, 
    -0.02547972f, -0.04603293f, -0.05757985f, -0.06464759f, 0.05745945f, -0.01519022f, -0.06415007f, -0.03722749f, 
    -0.05747223f, -0.04751837f, -0.02964872f, -0.07615974f, 0.01842558f, 0.02470257f, -0.04114696f, -0.04142388f, 
    -0.01613097f, 0.02981589f, -0.01916266f, 0.01413891f, -0.01611109f, -0.00283757f, -0.05552320f, 0.03992756f, 
    0.01521612f, -0.03359667f, 0.05626807f, 0.01504105f, -0.02696218f, -0.01749759f, -0.07694706f, -0.03917827f, 
    -0.06559774f, 0.00282690f, 0.03718567f, 0.03217889f, 0.03298950f, -0.03116072f, -0.02253619f, -0.00844562f, 
    0.04781257f, 0.02038315f, -0.03958455f, -0.07646188f, -0.00793639f, -0.02523685f, 0.03290310f, -0.02904392f, 
    0.04500116f, -0.07093150f, 0.02183449f, -0.07162708f, -0.01459036f, 0.02165908f, -0.07418769f, 0.01008657f, 
    0.03037303f, -0.03504293f, 0.02900688f, 0.03687437f, -0.00103181f, -0.01248200f, -0.00626162f, 0.02479552f, 
    -0.00606892f, 0.00589631f, 0.05922472f, -0.07492883f, -0.00402857f, 0.02288981f, 0.06137596f, -0.03290590f, 
    -0.01924755f, 0.07508175f, 0.02803329f, -0.02849770f, -0.06839553f, -0.05536529f, 0.00485865f, 0.05658644f, 
    0.05318223f, 0.05901413f, 0.01040334f, 0.04427643f, -0.00012942f, -0.02111391f, 0.05571363f, -0.00654271f, 
    -0.04419553f, 0.00362064f, -0.03680178f, 0.00479165f, -0.07747686f, 0.05160914f, -0.01400838f, 0.05290263f, 
    0.03241758f, 0.02966892f, 0.05995513f, -0.03665780f, 0.01918800f, -0.01349043f, 0.01140074f, -0.02320543f, 
    0.05011101f, -0.07773707f, -0.00926378f, 0.02212080f, 0.01689676f, 0.02227174f, 0.05482423f, 0.05640873f, 
    -0.04907981f, -0.03304158f, -0.02784493f, -0.04564331f, 0.00225959f, 0.01982546f, 0.02270840f, -0.00195521f, 
    -0.07748013f, -0.02541552f, 0.02682709f, -0.04121118f, -0.04314451f, -0.07458114f, -0.07632276f, -0.08028863f, 
    -0.00174679f, 0.02848079f, -0.05716786f, 0.02504708f, 0.02191631f, -0.05231677f, -0.00745894f, 0.01728937f, 
    -0.05819286f, 0.02387375f, -0.02141521f, -0.04615920f, 0.01160884f, 0.00840423f, 0.03488678f, -0.01595400f, 
    -0.00755521f, -0.02922788f, -0.05021877f, -0.07529020f, -0.01548490f, -0.01343818f, 0.05589216f, -0.00300622f, 
    0.05154599f, -0.05442503f, -0.01975889f, -0.01228227f, 0.03790548f, -0.00759306f, 0.02671880f, -0.06025773f, 
    0.28241232f, -0.20089087f, -0.00925310f, -0.05841984f, 0.04458338f, 0.01198800f, 0.06623048f, -0.03603060f, 
    0.07010439f, 0.00718761f, 0.10271751f, -0.06104718f, 0.23087259f, 0.35416842f, -0.17506579f, 0.07891955f, 
    0.03901102f, 0.11245529f, 0.10258965f, 0.00221715f, 0.07729873f, -0.01446713f, 0.05310234f, 0.03704811f, 
    -0.08268876f, -0.00964368f, 0.01552705f, 0.10223574f, -0.08851752f, 0.11133511f, -0.00273450f, 0.06136280f, 
    0.08970024f, 0.00207292f, 0.03430272f, -0.03213011f, 0.06663009f, -0.11246064f, -0.03898260f, 0.03341100f, 
    0.08768584f, -0.07621481f, 0.02050353f, 0.03745889f, -0.03023228f, 0.14502211f, -0.07796684f, 0.04407487f, 
    -0.02013390f, -0.03080861f, -0.21092181f, 0.00063775f, 0.05251678f, 0.05064071f, 0.00000330f, -0.06282147f, 
    0.04211913f, 0.02342411f, 0.01649158f, -0.19452439f, -0.19179817f, 0.02709924f, -0.02587795f, 0.08489432f, 
    0.07440827f, -0.06017762f, 0.02092131f, -0.05565165f, 0.07203585f, 0.16426787f, 0.00458861f, 0.09496518f, 
    -0.13351919f, 0.02663874f, 0.06863376f, -0.14232031f, -0.00378568f, -0.09877215f, -0.09956991f, -0.11640704f, 
    0.12221424f, -0.09700436f, -0.02419518f, -0.09767818f, -0.18739058f, 0.00090326f, -0.08291515f, 0.13170645f, 
    0.07219239f, -0.07922371f, -0.01177824f, -0.05227422f, -0.00980012f, -0.07964614f, -0.01752556f, -0.08976711f, 
    0.25483552f, -0.21685366f, -0.05618379f, -0.10014918f, -0.00985930f, -0.10064587f, -0.01700686f, 0.04219060f, 
    0.09599799f, -0.05125424f, 0.02435235f, 0.11959918f, 0.21050549f, 0.02344846f, -0.11555257f, -0.09759708f, 
    -0.03713459f, 0.00112221f, -0.00682491f, 0.03086997f, 0.02617800f, 0.11571255f, -0.01597873f, 0.14163654f, 
    -0.05868986f, -0.36305672f, 0.03558897f, 0.09502323f, 0.11622666f, 0.09599757f, -0.06639826f, 0.12107018f, 
    0.03342950f, 0.01149497f, 0.05792502f, 0.04830468f, 0.40628096f, -0.06277959f, -0.08241081f, 0.07058242f, 
    -0.02338545f, 0.08026897f, 0.09134683f, 0.06494697f, -0.01019008f, -0.15866329f, 0.02232271f, 0.06075136f, 
    -0.00746337f, 0.08752841f, 0.07775855f, -0.04041997f, -0.03483742f, 0.10568544f, 0.13379835f, 0.03407544f, 
    -0.10310841f, 0.00993689f, 0.05418817f, -0.00795549f, 0.14789267f, 0.16390680f, -0.06183565f, 0.12378410f, 
    0.11537439f, 0.08688273f, 0.06111587f, -0.00252316f, -0.12650046f, 0.05899595f, 0.09406053f, 0.05902271f, 
    -0.08317664f, 0.07247851f, -0.30180576f, -0.08486030f, -0.01791838f, 0.04620541f, 0.09008577f, -0.14419983f, 
    0.11672445f, -0.05615835f, -0.06084432f, 0.05111403f, 0.29098704f, -0.15041251f, 0.08388006f, -0.06434871f, 
    -0.05637407f, -0.08359572f, -0.03584751f, 0.08133650f, 0.04187849f, -0.05091161f, -0.05923096f, 0.03746057f, 
    0.03167044f, 0.02198586f, -0.01394858f, 0.00300297f, 0.03543331f, -0.02882839f, 0.02623511f, -0.01760936f, 
    0.01181858f, -0.06081769f, 0.00144325f, -0.04766573f, 0.04831529f, -0.08316246f, -0.04924696f, 0.00475670f, 
    0.04857041f, -0.04199606f, -0.06560011f, 0.01570925f, -0.03459229f, -0.07807945f, -0.02327456f, -0.09016036f, 
    0.01161975f, -0.05243686f, -0.00950799f, -0.03965332f, -0.03367030f, 0.06446985f, -0.09233992f, -0.07120101f, 
    0.01744989f, -0.02456906f, -0.02597168f, -0.09393054f, -0.00840063f, -0.03705329f, -0.09745524f, 0.01571023f, 
    0.02291865f, -0.06992571f, -0.01645420f, -0.02953857f, -0.06745534f, 0.05675656f, -0.03449446f, -0.10322438f, 
    0.00791408f, 0.01916352f, -0.05006009f, -0.01061605f, 0.03425051f, 0.00996914f, 0.00850327f, 0.01336011f, 
    0.05344046f, 0.00767731f, -0.00002327f, -0.08810984f, 0.02261288f, 0.04859937f, 0.01240035f, -0.03002956f, 
    -0.00844312f, 0.03406222f, -0.08281478f, -0.10324860f, -0.02805519f, -0.07869851f, -0.07664681f, -0.08914960f, 
    -0.04872744f, -0.07590216f, -0.09267709f, 0.04438671f, -0.06538180f, 0.01021837f, 0.02971173f, 0.00747249f, 
    0.00882958f, -0.05816058f, -0.08342384f, 0.04791477f, -0.08138332f, -0.04163929f, -0.01176760f, 0.04778743f, 
    -0.02036301f, 0.01979831f, -0.02723404f, -0.12887953f, 0.05932372f, 0.04558695f, -0.04422692f, -0.02396434f, 
    0.02383150f, -0.01245511f, -0.10390463f, -0.01249205f, -0.02897071f, -0.03775465f, -0.00365021f, -0.02223264f, 
    0.01800050f, -0.05781678f, -0.02062666f, -0.08530873f, 0.01543688f, -0.03771416f, -0.05546219f, 0.05386958f, 
    -0.09378887f, 0.03916912f, 0.04043273f, 0.04190403f, -0.07676627f, 0.05757958f, -0.04526327f, 0.02365465f, 
    0.00909898f, -0.01068256f, -0.09321993f, 0.03735168f, -0.01917552f, 0.02805055f, 0.00428246f, -0.00141462f, 
    -0.03937018f, 0.04909343f, -0.04332531f, -0.00466045f, -0.03254138f, -0.07791786f, -0.03767731f, -0.02222477f, 
    -0.04180662f, -0.09793316f, -0.02959790f, 0.00884942f, -0.03093215f, -0.10302907f, -0.07131048f, -0.02394236f, 
    -0.03871400f, -0.00663007f, 0.02150371f, -0.10530029f, -0.07641239f, 0.00936178f, -0.06560376f, 0.01797962f, 
    -0.01385126f, -0.09114205f, -0.02503120f, 0.03527037f, 0.03583348f, -0.04699936f, -0.07252790f, -0.07257599f, 
    0.03614636f, 0.03473847f, -0.03528168f, 0.05204085f, -0.01476966f, -0.08553396f, -0.09395130f, -0.09769515f, 
    -0.08885661f, -0.04887048f, -0.03557008f, 0.00758584f, -0.02132549f, -0.04866777f, 0.04630641f, -0.05741965f, 
    0.02677372f, 0.00693152f, -0.00342613f, -0.03018067f, 0.00967279f, -0.08551904f, -0.01962990f, -0.03135993f, 
    0.02922771f, 0.01718757f, -0.04221653f, -0.01409872f, 0.01745470f, -0.04748466f, -0.06066298f, 0.02278625f, 
    -0.19712259f, -0.11693010f, -0.18154548f, 0.08630835f, 0.12817535f, 0.07286848f, 0.11421360f, -0.02818426f, 
    0.14268079f, -0.09362778f, 0.13278918f, 0.05512345f, -0.16748831f, 0.00195553f, 0.07920466f, 0.08904884f, 
    0.13849261f, 0.09270227f, 0.02253880f, 0.02530162f, -0.06452841f, 0.03933204f, -0.06281018f, 0.16533497f, 
    -0.04005152f, 0.10863525f, -0.05471070f, 0.04412955f, 0.04292302f, 0.03287284f, -0.06492113f, 0.09939651f, 
    -0.00383314f, -0.03455614f, 0.05645803f, 0.10914574f, 0.08591402f, -0.05990624f, -0.15128225f, -0.04943623f, 
    0.05074810f, -0.18142568f, -0.15647988f, -0.08498381f, -0.02415645f, -0.07230011f, 0.00375343f, 0.04548415f, 
    -0.23153724f, 0.11701919f, 0.02979289f, -0.05302354f, 0.08545731f, -0.01272811f, -0.12599005f, -0.10564958f, 
    0.13262096f, 0.04780169f, 0.00859136f, 0.00969877f, -0.08376226f, 0.00045207f, 0.05464808f, -0.03083443f, 
    0.04995732f, 0.13724013f, 0.18945567f, -0.14354225f, 0.15687659f, -0.01617287f, 0.10980806f, -0.07324907f, 
    -0.11502011f, -0.12716113f, 0.01803334f, 0.16380621f, -0.10235322f, 0.05846461f, -0.22120596f, 0.08931451f, 
    0.11542828f, 0.01126377f, -0.00762675f, -0.06274539f, -0.09842181f, -0.06771593f, 0.14676899f, 0.06817751f, 
    0.12074533f, 0.09438541f, -0.06925009f, -0.07632889f, -0.00184171f, 0.10221291f, -0.04515478f, 0.00022022f, 
    -0.24274163f, 0.06108489f, 0.12836568f, -0.01520362f, 0.00187256f, 0.05197528f, 0.10439572f, -0.00960540f, 
    0.00642428f, 0.04740034f, -0.11352289f, 0.16518122f, 0.11852023f, 0.07651938f, -0.19038714f, 0.07441086f, 
    0.18254554f, -0.04209227f, 0.03229577f, -0.10051940f, -0.04361904f, 0.02045770f, 0.12677824f, 0.06268062f, 
    0.18937664f, -0.11280838f, 0.18619591f, -0.16500807f, -0.13545838f, 0.03921713f, 0.01616864f, 0.06389036f, 
    0.13561207f, -0.03061030f, 0.02364234f, 0.06413307f, -0.21635576f, 0.01188314f, -0.04909134f, -0.20927773f, 
    -0.00472326f, 0.01044418f, -0.10425794f, 0.08931316f, -0.03601200f, 0.01371782f, -0.00946903f, -0.18463619f, 
    -0.12652268f, -0.08436569f, -0.09169400f, 0.14206515f, -0.05850246f, -0.07500679f, -0.03299591f, -0.12493572f, 
    0.10023350f, 0.04326910f, 0.20653801f, 0.04740240f, 0.00375344f, 0.24184191f, 0.12852490f, -0.23326662f, 
    0.04585640f, 0.06219019f, 0.04356336f, 0.10899216f, 0.09573644f, 0.08784615f, 0.02350120f, 0.19355059f, 
    0.18487416f, -0.15150981f, -0.00758018f, -0.10360645f, 0.05071886f, -0.06394199f, 0.14216803f, 0.03583988f, 
    0.00469517f, 0.08933059f, 0.08049595f, 0.10930710f, -0.16232084f, 0.14668810f, -0.04297093f, 0.04405389f, 
    -0.06180897f, 0.00933569f, 0.01258736f, -0.02363928f, -0.02074708f, -0.07584552f, 0.02021202f, -0.10690968f, 
    0.05451825f, -0.00149948f, -0.06568269f, -0.02289048f, 0.02238246f, 0.01228165f, -0.04869696f, -0.07386244f, 
    0.05803433f, 0.06132017f, -0.01392181f, -0.01253152f, -0.04922860f, -0.04146496f, -0.00717538f, 0.05065729f, 
    -0.00318520f, -0.00619290f, 0.02999580f, 0.03453887f, -0.08259285f, 0.03317687f, 0.03331589f, 0.00798523f, 
    0.02496695f, -0.03030139f, -0.06655052f, 0.06982664f, 0.04136382f, 0.00610190f, 0.05565448f, -0.01096151f, 
    0.03283522f, -0.04453933f, -0.00104927f, 0.05771003f, -0.07666334f, -0.00604092f, -0.00634786f, -0.03878315f, 
    0.04392916f, -0.08635879f, 0.02902836f, -0.08033680f, -0.07150923f, -0.02094961f, 0.06307179f, 0.05445435f, 
    -0.03835854f, -0.06562839f, -0.00144897f, -0.00137085f, -0.01425234f, -0.02620095f, -0.05407898f, 0.03751212f, 
    0.06583313f, 0.01478610f, -0.07104012f, -0.05379397f, 0.04804749f, -0.00186944f, -0.00824065f, -0.00035995f, 
    -0.02171758f, -0.00438599f, -0.01911211f, -0.03475401f, -0.00601926f, -0.01446603f, 0.00086937f, 0.00665490f, 
    0.02531699f, 0.03771024f, 0.00230772f, 0.02038646f, 0.02688175f, 0.00174719f, -0.03965665f, 0.04009369f, 
    0.03651291f, -0.05326937f, -0.05093703f, -0.03282035f, -0.01194845f, -0.02676385f, -0.03634835f, -0.05414203f, 
    -0.01994603f, 0.04370848f, 0.04650518f, -0.04235017f, -0.02904477f, 0.03241271f, -0.04069211f, -0.01456086f, 
    -0.03910758f, 0.05982551f, 0.04744202f, -0.02875442f, 0.02519592f, 0.06179714f, -0.04524684f, -0.02538200f, 
    0.01157439f, 0.04228037f, 0.05294094f, 0.01080182f, -0.07354436f, -0.04963734f, -0.05695816f, 0.05136638f, 
    0.02145801f, 0.06113732f, -0.06258452f, -0.03871015f, -0.06240898f, -0.05562094f, -0.05025518f, -0.05683441f, 
    -0.06787799f, 0.00020736f, -0.01470250f, -0.03130447f, -0.00302224f, -0.08075629f, 0.00537564f, -0.05469966f, 
    0.02781384f, 0.04007070f, 0.03959525f, -0.02933938f, 0.00696097f, -0.00260978f, -0.03972812f, 0.00083994f, 
    -0.05381298f, -0.04736328f, 0.02172296f, 0.04927626f, 0.00852546f, -0.02662091f, -0.04719476f, -0.02766154f, 
    -0.06103825f, -0.03323200f, -0.04928407f, -0.06998961f, 0.02961091f, -0.00919600f, -0.03641411f, -0.06800970f, 
    -0.01248503f, -0.06409959f, -0.04196876f, 0.02093751f, 0.02965987f, -0.06367997f, -0.05257002f, -0.08287261f, 
    0.02855056f, 0.00392170f, -0.02159992f, 0.03415031f, 0.04770634f, 0.02070984f, -0.02846655f, 0.05831834f, 
    -0.01315051f, -0.01029519f, -0.05215810f, 0.01924944f, -0.05474857f, 0.02490565f, 0.02997654f, 0.03398487f, 
    -0.01761593f, 0.02255161f, -0.02033225f, 0.00905492f, 0.02070863f, -0.07790317f, 0.00881314f, -0.03848690f, 
    0.00477447f, -0.00123442f, 0.04634088f, 0.01108030f, -0.04921839f, 0.01441992f, 0.01933567f, -0.00990962f, 
    -0.15134187f, -0.29239741f, -0.01390606f, 0.04621296f, 0.02359955f, -0.04553497f, -0.00381902f, 0.08418354f, 
    -0.02353970f, 0.01526142f, 0.09098323f, -0.07240394f, -0.22082943f, 0.04397808f, -0.09016632f, -0.05942166f, 
    0.10639314f, -0.03379053f, -0.00276410f, 0.06130613f, -0.05107366f, -0.05164362f, 0.04829935f, 0.06057216f, 
    -0.12887940f, 0.03342170f, 0.04504491f, 0.24534324f, -0.00944848f, -0.00953822f, -0.07811872f, 0.00648861f, 
    0.14242831f, -0.12152544f, 0.13634308f, -0.08587400f, -0.13736740f, 0.13496247f, 0.08922096f, 0.05330284f, 
    -0.10383750f, -0.13703124f, -0.17010505f, -0.06418009f, -0.04630817f, -0.00139554f, -0.04053585f, -0.00286740f, 
    -0.09832739f, -0.12927333f, -0.08177827f, -0.00162683f, 0.03712234f, 0.04282273f, -0.07705332f, 0.00015734f, 
    0.14244173f, 0.13780010f, 0.20103946f, -0.10288163f, 0.03015525f, -0.10825570f, -0.04824650f, 0.10655221f, 
    0.00869460f, -0.14004605f, 0.05629535f, 0.02227216f, -0.01598165f, 0.18209672f, 0.00861031f, -0.02427188f, 
    0.18927303f, 0.02726627f, -0.09569584f, -0.20164536f, -0.00251479f, 0.06905882f, 0.04332451f, -0.09593201f, 
    -0.02045690f, 0.02021236f, 0.16633950f, -0.01708658f, -0.07894906f, -0.07387482f, -0.06428868f, 0.20949706f, 
    0.04506043f, -0.10368160f, 0.01888211f, -0.07737456f, -0.12442150f, -0.09625474f, -0.01368188f, -0.03946494f, 
    0.16442321f, -0.03829677f, -0.11058443f, 0.01779767f, 0.04141701f, -0.05481860f, 0.14362308f, 0.04798782f, 
    0.13596153f, 0.06048325f, -0.04039248f, -0.02666995f, 0.09054331f, 0.01096413f, -0.03679041f, -0.02218995f, 
    -0.03821153f, 0.14912596f, -0.07512458f, 0.21036020f, 0.04590886f, 0.06250182f, 0.10764246f, 0.02176195f, 
    0.08626361f, -0.04235915f, -0.03562083f, 0.18713377f, 0.01647989f, 0.12672910f, -0.02287012f, 0.04691893f, 
    0.05943070f, 0.00966225f, -0.05664290f, -0.06554644f, 0.29499003f, 0.12931642f, -0.00040207f, 0.03339329f, 
    -0.06062764f, 0.07683467f, -0.07159238f, 0.04821951f, -0.03659195f, -0.03269489f, -0.03960155f, 0.07384945f, 
    0.11691076f, 0.12439347f, 0.03932106f, 0.05807054f, -0.07000311f, 0.00053855f, 0.07699603f, -0.05239573f, 
    -0.07669649f, 0.10207604f, 0.06248983f, 0.15227270f, -0.01034863f, -0.07501072f, -0.09476303f, -0.00776800f, 
    0.08236252f, -0.05528051f, -0.01192707f, 0.05140759f, -0.07563289f, -0.05679711f, 0.08888608f, 0.09299619f, 
    -0.09114567f, 0.18564871f, 0.02696307f, 0.17496659f, 0.01003633f, 0.12241154f, 0.09340438f, 0.05453448f, 
    -0.04885140f, 0.12666294f, 0.07279301f, 0.07442678f, 0.19108436f, -0.30685490f, 0.12774974f, -0.16014980f, 
    0.01324959f, 0.05237369f, 0.00837659f, -0.25528133f, -0.08089153f, -0.06565659f, 0.02638519f, -0.09950113f, 
    0.09198386f, 0.15526772f, -0.15429869f, 0.04699554f, 0.04089124f, 0.00330497f, -0.08160092f, 0.10382488f, 
    -0.05065414f, -0.12527418f, 0.07109049f, 0.07953946f, -0.08681044f, -0.18687254f, 0.12555426f, 0.08654480f, 
    0.11103036f, -0.15076630f, -0.06287436f, 0.03767867f, 0.05000485f, -0.00328205f, -0.08809847f, -0.05599721f, 
    0.14615536f, -0.04050079f, -0.06254278f, -0.03181824f, 0.06255394f, 0.00867086f, -0.06864292f, -0.10672864f, 
    0.03210470f, 0.00995928f, 0.03446536f, -0.07867624f, 0.05310128f, 0.13689755f, 0.06188345f, 0.11717267f, 
    0.01681239f, 0.01977256f, -0.04250133f, -0.02852124f, -0.06678011f, 0.05751688f, 0.11559103f, -0.11917824f, 
    -0.05648381f, -0.05045004f, 0.07886895f, 0.19067891f, 0.08183073f, -0.13897271f, -0.01739127f, 0.07864255f, 
    -0.07546963f, 0.08241382f, -0.04391845f, 0.16355471f, 0.33842361f, -0.14440642f, -0.04700693f, -0.04915954f, 
    -0.06926284f, 0.09025733f, 0.03225771f, 0.04299214f, 0.00292628f, -0.14642142f, 0.00016914f, 0.08364584f, 
    0.18182777f, 0.11141964f, 0.04990913f, -0.10165514f, 0.05672323f, 0.11732317f, 0.00257810f, 0.17895401f, 
    -0.05032095f, 0.09935473f, -0.01125625f, 0.09109256f, 0.20732312f, -0.05684954f, -0.05582156f, -0.04031176f, 
    -0.05443035f, 0.01711460f, 0.01348681f, 0.11399756f, 0.07777087f, 0.09844214f, -0.01117684f, 0.13277636f, 
    -0.13299568f, 0.20261957f, -0.07779631f, 0.06279992f, 0.11917856f, 0.03373058f, 0.00131222f, 0.10820479f, 
    -0.11897255f, 0.00190786f, 0.04413279f, -0.10813870f, -0.08503269f, 0.27231929f, 0.09884624f, -0.18878953f, 
    -0.00336309f, 0.04269560f, -0.04428272f, -0.01482765f, 0.07513075f, -0.01661792f, -0.00317913f, 0.10607148f, 
    0.17946282f, 0.12178934f, -0.13338241f, 0.17353337f, -0.08576176f, 0.00534983f, 0.05131439f, -0.06146617f, 
    -0.02102484f, -0.05800589f, -0.02706617f, 0.01512591f, -0.41479743f, 0.06878730f, 0.05388516f, 0.01346477f, 
    0.07889558f, -0.01982902f, 0.06064196f, -0.03782189f, 0.02536940f, 0.11723394f, -0.09514759f, 0.05360688f, 
    0.09271768f, -0.16617264f, 0.09686577f, -0.08007491f, 0.16946922f, -0.00632550f, -0.06843322f, -0.05290921f, 
    0.00230410f, -0.06703409f, 0.03355151f, -0.02677519f, -0.37182894f, -0.10352888f, -0.00903339f, 0.09531474f, 
    0.00743947f, -0.01273008f, 0.03244074f, 0.00609238f, 0.13379365f, 0.05686179f, -0.11750144f, 0.01340345f, 
    -0.05587615f, -0.04232331f, 0.14501439f, -0.18295312f, -0.05633685f, 0.09596164f, -0.02328788f, -0.03859001f, 
    0.07683245f, 0.04337040f, 0.06019262f, -0.00024208f, -0.03197196f, 0.18603043f, -0.07183255f, 0.06086229f, 
    0.01670821f, -0.03759439f, 0.02860469f, 0.01657497f, -0.01102230f, -0.01923244f, 0.04762394f, 0.05354154f, 
    0.05426420f, 0.03347240f, -0.09860476f, 0.12514272f, -0.06484185f, -0.05194708f, -0.11670005f, 0.05096515f, 
    -0.09306867f, 0.04173265f, 0.04614078f, 0.01898855f, 0.00762564f, 0.25465548f, 0.04530234f, 0.12113146f, 
    0.15620014f, -0.00370995f, -0.03073711f, 0.00731460f, 0.15886952f, -0.00392687f, 0.05643428f, -0.00043567f, 
    -0.02877401f, -0.11769941f, -0.18458179f, 0.05568252f, 0.02849461f, -0.08540150f, -0.02066151f, -0.10954173f, 
    0.00180156f, 0.09576232f, 0.03811760f, -0.01464825f, 0.33534405f, -0.20488107f, -0.17376839f, 0.20713522f, 
    -0.06364597f, -0.11398847f, -0.02361515f, -0.00231880f, 0.05879861f, 0.00041625f, -0.08285311f, 0.08019146f, 
    -0.26157016f, 0.20868644f, -0.24867941f, 0.31456736f, 0.06422901f, -0.02837200f, 0.10284851f, -0.07243375f, 
    -0.04964456f, 0.02592691f, 0.04460420f, 0.00471801f, 0.02236702f, -0.20584281f, 0.10537113f, 0.00925831f, 
    0.05911733f, 0.08169820f, -0.09168915f, -0.02002758f, 0.18598501f, 0.14174770f, -0.09582832f, 0.02331837f, 
    -0.28717485f, -0.08937289f, 0.09302554f, -0.13512556f, -0.09317227f, 0.04137503f, 0.02101732f, 0.01033141f, 
    0.00914288f, -0.07091162f, -0.01678190f, 0.03952117f, -0.05197962f, -0.13914049f, -0.19688149f, 0.02043142f, 
    -0.11231530f, 0.06682459f, -0.05155282f, 0.00507017f, 0.05555556f, -0.04030570f, 0.10086212f, 0.10245284f, 
    0.23151579f, -0.13443954f, -0.09050671f, 0.02953473f, -0.11595422f, -0.15665977f, -0.10305606f, 0.06904442f, 
    -0.02583821f, -0.13152768f, -0.00682067f, -0.00286902f, 0.22967772f, 0.06313002f, -0.12363497f, -0.16978775f, 
    -0.00160696f, -0.01172379f, 0.07519894f, 0.02276756f, 0.02036090f, -0.00316559f, -0.00754055f, 0.08946397f, 
    0.34907395f, -0.28086174f, -0.05610839f, 0.22031696f, -0.04092417f, 0.05870533f, -0.03040726f, 0.01863529f, 
    0.06345639f, -0.09186425f, 0.07105139f, 0.09973708f, 0.01223320f, -0.10499770f, -0.05294844f, 0.11542764f, 
    0.06798899f, -0.11581684f, 0.08956940f, 0.00330146f, -0.03385163f, 0.09462262f, -0.02285123f, 0.27645293f, 
    0.13162659f, -0.01553577f, 0.03790208f, -0.20064685f, -0.02672591f, -0.09075055f, -0.01406675f, 0.17659536f, 
    -0.09134225f, -0.06319336f, 0.09333960f, 0.03054940f, -0.28645906f, 0.07420282f, 0.05181031f, 0.27230993f, 
    0.08392838f, 0.07562537f, -0.00048745f, 0.04983303f, -0.05419446f, 0.10697026f, -0.01645503f, 0.04286510f, 
    0.05809306f, 0.15869401f, -0.12458578f, -0.20196706f, 0.00969681f, 0.03830446f, 0.10863774f, -0.08503555f, 
    0.14341429f, 0.07879959f, 0.07242283f, -0.09323569f, 0.07256211f, 0.10976112f, -0.03506247f, 0.04834297f, 
    0.11109544f, -0.05120323f, 0.06330311f, -0.01670213f, -0.04423464f, 0.00318210f, 0.14580268f, 0.06789503f, 
    0.00380607f, 0.04451258f, -0.07024541f, -0.02860826f, 0.00380513f, 0.05525411f, 0.02915349f, -0.02754279f, 
    0.04185470f, -0.01498852f, 0.03750752f, -0.07077549f, -0.02771876f, -0.07527706f, -0.05720848f, -0.05058092f, 
    0.03974057f, -0.00365442f, 0.01089352f, 0.00881914f, -0.01951936f, -0.00427972f, 0.01834030f, 0.00286580f, 
    -0.07705943f, -0.02198094f, 0.03234091f, 0.02509469f, -0.05130026f, 0.00310952f, -0.06993176f, -0.06399559f, 
    0.05283817f, 0.05243064f, -0.07097663f, -0.02212390f, -0.07562196f, 0.00355360f, -0.00468225f, 0.04697313f, 
    0.00362049f, 0.01125409f, -0.06159174f, 0.05140484f, -0.05461789f, -0.00541319f, 0.06300593f, 0.00455092f, 
    0.01748358f, 0.04611377f, 0.04486091f, -0.00860733f, -0.03590836f, -0.05904161f, -0.06648052f, 0.03751346f, 
    -0.01694954f, 0.04451395f, 0.01996137f, -0.01340451f, -0.06965929f, 0.00943353f, -0.00468456f, -0.06994165f, 
    -0.07157402f, -0.01314245f, -0.01666463f, -0.02416297f, -0.06348550f, -0.02384266f, -0.00149997f, -0.05219297f, 
    0.00569931f, 0.00550364f, 0.04092893f, 0.05933682f, 0.00251003f, -0.05335782f, 0.04350064f, 0.04963699f, 
    -0.06879804f, 0.00393145f, 0.05049615f, -0.05186132f, 0.01125953f, -0.06778271f, -0.03615723f, -0.01377819f, 
    -0.05501406f, -0.03205510f, 0.05734154f, -0.01912672f, -0.03303403f, -0.04286984f, 0.00025581f, -0.07262059f, 
    -0.06920291f, 0.01704959f, -0.05389116f, 0.03637062f, -0.02353266f, 0.00203802f, -0.07447792f, 0.01222671f, 
    0.05344790f, -0.00051376f, 0.04653922f, -0.03185355f, 0.05200526f, 0.05847652f, 0.00531803f, 0.03826689f, 
    0.02780079f, 0.00663764f, -0.03024863f, 0.02472756f, 0.04314036f, -0.03807863f, 0.02108048f, 0.01963445f, 
    0.04363733f, 0.00160106f, 0.03321187f, -0.00731560f, 0.02928362f, 0.01357325f, -0.02748580f, -0.02136993f, 
    -0.03122698f, 0.04210223f, 0.02961637f, 0.03967400f, -0.04823983f, 0.00063586f, -0.03334315f, 0.00230453f, 
    -0.03964623f, 0.05499862f, 0.01334971f, -0.03180080f, 0.05175478f, -0.03799805f, -0.04951147f, -0.03315873f, 
    -0.05349615f, 0.00635058f, -0.01022626f, -0.07143731f, 0.05555494f, -0.03280269f, 0.00876995f, -0.00020977f, 
    -0.07525450f, -0.00697351f, -0.04922238f, -0.04150673f, 0.04585637f, 0.06136673f, -0.00108344f, 0.04384819f, 
    0.05085211f, -0.04027652f, -0.03807655f, -0.07827315f, 0.01641145f, -0.04494635f, -0.06505634f, -0.05316800f, 
    0.02342398f, -0.05066210f, -0.06405614f, 0.00216457f, -0.01877922f, -0.01408765f, 0.06425086f, 0.06059435f, 
    0.01987444f, -0.02663374f, -0.00581725f, 0.00658527f, -0.05778681f, -0.02537365f, -0.03465041f, 0.06066364f, 
    -0.07535423f, -0.01353048f, -0.06599629f, -0.07820140f, 0.03266335f, -0.01169827f, -0.03089329f, 0.01221083f, 
    -0.03468951f, -0.02675821f, 0.02176798f, 0.03701143f, 0.02722576f, -0.00051631f, 0.01866838f, 0.00241963f, 
    0.04661367f, -0.05360381f, -0.07075879f, -0.05778135f, -0.02969649f, -0.00910593f, 0.03085286f, -0.07680233f, 
    -0.02108280f, -0.00502466f, -0.07201064f, -0.01505226f, -0.07635008f, -0.02645928f, -0.06755996f, -0.04558805f, 
    -0.05834901f, -0.01998963f, -0.01150309f, -0.01207327f, -0.02380310f, -0.04517362f, -0.07255592f, -0.00895094f, 
    0.03779257f, 0.05481731f, -0.05018472f, -0.06682526f, 0.01783447f, -0.07067367f, -0.04531005f, -0.03154895f, 
    -0.03027935f, -0.04755251f, -0.00009190f, 0.00327027f, -0.05939248f, 0.05379058f, -0.04305157f, -0.04088441f, 
    -0.03686135f, -0.06601067f, -0.01891753f, 0.05453695f, 0.05277272f, 0.03443265f, -0.07054281f, 0.01985094f, 
    0.01520916f, -0.00327302f, -0.05698442f, -0.03126787f, 0.00565275f, -0.01144249f, 0.02973181f, 0.04493227f, 
    -0.05939627f, 0.03584065f, 0.00423605f, 0.01181778f, 0.05605656f, 0.01530158f, 0.05205933f, -0.05298963f, 
    0.03366631f, 0.02965700f, 0.00222056f, 0.05424481f, -0.07703532f, -0.03120784f, -0.07784521f, 0.05216505f, 
    -0.05183114f, 0.01315131f, 0.03794777f, -0.05080185f, 0.00356313f, -0.05489211f, -0.06231540f, -0.07470004f, 
    -0.01420359f, 0.02817466f, 0.05707635f, -0.03801044f, -0.06377898f, 0.03096979f, -0.05513681f, 0.03024136f, 
    -0.06207645f, 0.06281026f, 0.05980328f, -0.06065542f, 0.00045562f, 0.04695714f, -0.01246170f, 0.01191173f, 
    0.00055539f, -0.03738491f, 0.02589490f, 0.05283710f, 0.02554628f, 0.03115237f, -0.03952603f, 0.04427603f, 
    0.05341153f, -0.04667617f, -0.01256038f, 0.05229075f, 0.05382928f, -0.04838113f, 0.04266420f, 0.01253178f, 
    0.02277063f, 0.04701310f, -0.02455504f, -0.03974627f, -0.03354546f, -0.07763938f, -0.07070228f, 0.06293153f, 
    0.00513903f, -0.00287364f, -0.04506091f, -0.06678117f, 0.06157174f, -0.07782102f, 0.00025345f, 0.05199320f, 
    0.03112421f, -0.00134403f, 0.03317135f, 0.01418284f, -0.01650500f, 0.05088710f, 0.01469349f, -0.03085442f, 
    0.04426856f, 0.03360031f, 0.02193903f, 0.00741439f, -0.00853554f, -0.07497732f, -0.02577831f, 0.00813950f, 
    -0.03187886f, 0.04019573f, 0.06369001f, -0.05690639f, -0.02140782f, -0.06690305f, 0.03712068f, -0.03977577f, 
    -0.00156856f, -0.06842441f, 0.00021897f, 0.05327602f, -0.05562307f, -0.00461014f, -0.04881606f, -0.07144134f, 
    -0.07273773f, 0.04551828f, -0.03151403f, -0.02701472f, 0.01511026f, -0.04873854f, -0.05350397f, 0.02021101f, 
    -0.00155650f, -0.00232373f, 0.05994520f, 0.05288669f, -0.05830181f, 0.02234713f, -0.04146800f, -0.03646705f, 
    0.04499621f, -0.03688911f, -0.03601323f, -0.00114889f, -0.05664878f, 0.04505618f, 0.00160843f, -0.01141084f, 
    -0.13554700f, 0.06271052f, 0.24819566f, -0.14842671f, -0.06919333f, -0.02461351f, -0.04353831f, 0.17158502f, 
    0.14724760f, 0.01092690f, 0.05548676f, -0.06979670f, 0.01368575f, 0.15878840f, 0.11046500f, -0.35718441f, 
    -0.01029601f, -0.12651989f, 0.04103826f, 0.03880168f, -0.04464892f, -0.01675403f, -0.03483682f, 0.00421652f, 
    -0.12246168f, 0.03609357f, 0.18631387f, -0.10438138f, -0.12042018f, 0.07933111f, 0.06991491f, -0.01814603f, 
    0.09608316f, 0.04696319f, 0.02009814f, -0.06196048f, 0.01102418f, -0.02601299f, 0.11387401f, 0.16432805f, 
    0.03917271f, 0.07322270f, -0.09198126f, 0.04100565f, 0.11150929f, 0.08241663f, 0.17219651f, -0.08730762f, 
    0.30625609f, -0.34609622f, 0.07799828f, 0.01401310f, 0.00452132f, 0.12201227f, 0.01904555f, 0.10403015f, 
    0.19182135f, 0.05193631f, 0.00748438f, -0.08809391f, -0.01379429f, 0.03921829f, 0.18736179f, -0.09379283f, 
    0.02389615f, -0.07430524f, -0.07669069f, -0.05413745f, -0.10969287f, 0.04938309f, 0.01221514f, 0.05936280f, 
    0.13943879f, -0.12755252f, -0.06847675f, -0.33759093f, 0.15918961f, -0.09773276f, 0.10495229f, -0.01334318f, 
    -0.00575321f, -0.01804699f, 0.09301665f, 0.02735849f, -0.11055223f, 0.02220491f, 0.05064726f, 0.02245337f, 
    -0.06280594f, -0.12377479f, -0.01442606f, 0.04025692f, 0.05344822f, -0.03796221f, -0.02675382f, -0.06053165f, 
    -0.12895051f, -0.13254584f, -0.19436185f, 0.07926176f, -0.01600113f, 0.10469272f, 0.03455402f, 0.07778309f, 
    0.08056163f, 0.10744563f, -0.07375716f, 0.08607100f, -0.02750995f, -0.17034265f, 0.28072625f, -0.21733822f, 
    -0.06662511f, 0.11125536f, 0.13296875f, 0.04483758f, -0.07727021f, -0.04710060f, 0.02201205f, -0.02646625f, 
    -0.16805539f, 0.08496501f, -0.11448045f, 0.24091110f, 0.07834848f, 0.00953825f, -0.04467328f, 0.05861836f, 
    -0.09582128f, -0.08051463f, 0.12972860f, 0.00525566f, -0.08530720f, -0.01103404f, -0.03220993f, 0.04509279f, 
    -0.05820397f, 0.07212127f, 0.10356107f, 0.04921028f, -0.03769284f, -0.05475442f, 0.10655034f, 0.09386268f, 
    0.00957224f, 0.02573654f, -0.07927915f, -0.04485521f, -0.00890409f, 0.08690444f, 0.01512486f, 0.19505751f, 
    0.00432122f, 0.04153703f, -0.13084182f, 0.14313938f, 0.11849818f, -0.17640682f, -0.06271444f, 0.02405689f, 
    -0.04950928f, -0.01727488f, 0.01088210f, -0.03557599f, 0.02156434f, -0.14785677f, 0.08372474f, 0.08227873f, 
    -0.24957062f, 0.09003100f, -0.00520596f, 0.07335525f, 0.13005702f, 0.13134228f, 0.02711003f, 0.19388865f, 
    0.02666861f, 0.15708831f, -0.05644488f, 0.00814634f, 0.28408757f, -0.12322764f, 0.13207647f, -0.05226249f, 
    0.10364756f, 0.05563135f, -0.05138857f, 0.05794919f, 0.01273696f, 0.01153014f, -0.05829437f, 0.07560195f, 
    -0.33361641f, -0.28396606f, -0.29502201f, 0.12833214f, -0.00841530f, 0.06236907f, 0.03856350f, -0.09551830f, 
    0.13743810f, -0.12842660f, 0.07108971f, 0.22424559f, -0.23269615f, -0.17100956f, -0.10226414f, 0.22438730f, 
    0.04422905f, 0.00965835f, -0.12501420f, 0.01718425f, -0.02253990f, 0.04381612f, -0.01420525f, 0.09529492f, 
    -0.12916124f, -0.17745024f, -0.02856123f, -0.00950967f, 0.27523825f, -0.10244522f, -0.09796762f, 0.10273594f, 
    0.10455202f, -0.15587224f, 0.00915218f, 0.13100944f, 0.10156461f, 0.03672819f, -0.04550146f, -0.05878981f, 
    0.00907756f, -0.16544797f, -0.07436224f, -0.13685693f, -0.05038686f, 0.06026417f, -0.10771669f, 0.18001902f, 
    -0.42658636f, 0.24476530f, -0.11370068f, 0.15782285f, 0.12318127f, -0.05419652f, -0.09204890f, 0.04874758f, 
    0.13425443f, 0.21849088f, -0.06034531f, 0.03852282f, -0.06201444f, -0.04794715f, 0.17545801f, 0.01305031f, 
    0.04273454f, 0.07995786f, 0.07780297f, -0.15384045f, 0.19412084f, 0.09882444f, 0.18797162f, -0.04290346f, 
    -0.06687907f, -0.03260865f, 0.02666191f, 0.18537366f, -0.10617435f, 0.08939397f, -0.06427068f, -0.00306151f, 
    0.16008095f, -0.02455977f, -0.04247325f, -0.09172325f, -0.21586689f, -0.22935843f, -0.07111531f, -0.09691783f, 
    0.17968504f, 0.02870299f, -0.00955464f, -0.03559977f, -0.08727188f, -0.08439386f, 0.00197039f, 0.03015655f, 
    0.16221306f, 0.05566436f, 0.19254445f, 0.15970032f, 0.10304900f, -0.01349153f, 0.16563578f, 0.16907875f, 
    0.09268483f, 0.08024827f, -0.02415850f, 0.11961211f, -0.08899124f, 0.06982047f, -0.25329795f, 0.04025540f, 
    0.10348202f, -0.10214728f, -0.08843090f, -0.00309157f, 0.05109570f, 0.01399620f, -0.00458069f, 0.12733032f, 
    0.24164209f, -0.04757751f, 0.17552543f, -0.19000162f, -0.05915950f, 0.04835092f, -0.00703449f, -0.03572033f, 
    0.28628883f, 0.02708960f, 0.01753243f, 0.06819993f, -0.14571723f, 0.19831112f, -0.07609054f, -0.12224379f, 
    -0.04502087f, 0.03342077f, -0.18519124f, 0.09240208f, 0.05102862f, 0.01395725f, 0.01787502f, -0.05277452f, 
    0.02585811f, 0.02330096f, 0.10185181f, 0.06317206f, -0.05459035f, -0.12767188f, 0.05591606f, -0.05152868f, 
    -0.02551548f, -0.08084461f, 0.24997310f, 0.04187660f, -0.18410251f, 0.15929627f, 0.13260821f, -0.05586166f, 
    -0.01352248f, 0.00755014f, 0.14846069f, 0.02288134f, -0.05915501f, 0.13523751f, 0.11955159f, 0.19687991f, 
    0.25799075f, -0.00542922f, 0.06081985f, 0.06904733f, 0.08500481f, -0.02052937f, 0.07479887f, -0.13117357f, 
    0.10568532f, 0.03781725f, -0.00535575f, -0.03364283f, -0.02013305f, 0.11523213f, 0.00524406f, 0.02642886f, 
    -0.08508012f, -0.10503228f, 0.07932846f, -0.03165137f, -0.09432583f, -0.07958638f, -0.05705446f, -0.11037806f, 
    -0.09025620f, -0.06865846f, 0.02476892f, -0.06205111f, -0.04615071f, -0.04930848f, 0.01455855f, -0.02061986f, 
    0.00636618f, 0.04467100f, -0.02102240f, -0.01149446f, 0.05216408f, 0.03888106f, 0.05304585f, -0.01853094f, 
    -0.04684259f, 0.04974412f, 0.03427711f, -0.04770060f, 0.04093965f, -0.04696023f, -0.04486734f, -0.02965055f, 
    0.00344878f, -0.04703867f, -0.00284925f, 0.01557905f, 0.02528035f, -0.08185832f, 0.05181158f, -0.00769624f, 
    0.04139201f, 0.00968727f, -0.04722207f, 0.05574962f, -0.02769807f, -0.03169730f, 0.06426246f, 0.03825874f, 
    -0.05670809f, -0.04103331f, 0.00103243f, -0.04560314f, -0.02996353f, -0.01400430f, -0.01553570f, -0.04123575f, 
    -0.03582477f, -0.06683275f, -0.08926370f, 0.00268126f, 0.06060594f, 0.03968213f, 0.04698555f, 0.02838994f, 
    -0.05732502f, -0.04482127f, 0.05046220f, 0.01456561f, -0.03941723f, -0.00316123f, -0.02300654f, 0.01822617f, 
    -0.06320882f, -0.05267229f, -0.03794998f, 0.05810514f, -0.08717329f, -0.04536348f, -0.07855851f, -0.07940563f, 
    -0.02016252f, -0.01453094f, 0.02430090f, 0.01760760f, -0.05649720f, 0.00194696f, 0.01165408f, 0.00438539f, 
    -0.02399197f, -0.01464758f, -0.06540545f, -0.00408410f, 0.02209192f, 0.04617632f, -0.04490275f, -0.05831903f, 
    -0.03287985f, -0.07775870f, -0.00878844f, -0.02326987f, 0.01852590f, -0.05533060f, 0.00900291f, -0.02307807f, 
    0.04323700f, -0.08004801f, -0.08275712f, -0.02546727f, 0.03062142f, -0.02279771f, -0.02316539f, 0.02549781f, 
    -0.06556153f, -0.02778258f, -0.05079553f, 0.01038048f, -0.05069045f, 0.01496976f, -0.00296978f, -0.00019237f, 
    0.02115692f, -0.07311018f, -0.07395397f, 0.04630970f, -0.02730862f, 0.02992723f, 0.00506915f, 0.04167593f, 
    0.02673184f, 0.04325884f, -0.00933206f, -0.00506751f, -0.07112141f, -0.02691755f, -0.02191060f, -0.03855586f, 
    -0.01715607f, 0.03109919f, 0.04153181f, 0.04780963f, -0.00569419f, -0.01678544f, -0.06267660f, 0.01653777f, 
    0.05567116f, 0.03885493f, -0.02305940f, -0.02825423f, -0.05742795f, -0.03358914f, -0.00484014f, 0.01507723f, 
    0.02687503f, -0.06938402f, 0.00151306f, 0.03731542f, -0.03722820f, -0.06778308f, 0.04388282f, 0.01431746f, 
    -0.02884554f, -0.01288680f, -0.00038578f, -0.07987408f, 0.02605223f, -0.00163899f, -0.00668939f, 0.02117951f, 
    -0.04927466f, -0.05395406f, -0.03962334f, 0.03181914f, 0.03676541f, 0.05262505f, -0.00744833f, -0.01221116f, 
    -0.03395688f, -0.02699386f, -0.02752183f, -0.00644457f, -0.01790507f, 0.02328761f, -0.00918708f, -0.06263400f, 
    -0.03337088f, 0.01830323f, -0.04706423f, 0.01023973f, -0.03357989f, -0.01918404f, 0.02938015f, -0.00988635f, 
    0.00630975f, 0.04667296f, -0.03527948f, 0.04216436f, -0.04500150f, 0.01714715f, 0.02482801f, 0.04031004f, 
    -0.08308852f, 0.18049419f, 0.07766930f, -0.02609596f, -0.11029825f, -0.17706463f, -0.06273758f, 0.03415610f, 
    -0.07671919f, -0.10332514f, -0.12803039f, -0.06453595f, -0.25181869f, -0.18591298f, 0.12692317f, 0.11129415f, 
    -0.12017698f, -0.06149569f, -0.00184247f, -0.10522516f, 0.03126362f, -0.03992123f, 0.03076501f, 0.02883142f, 
    -0.19468705f, 0.12398013f, -0.07551368f, -0.01193272f, -0.10905065f, 0.01299321f, -0.10711788f, -0.07153223f, 
    -0.15416372f, 0.03445043f, -0.03667369f, -0.07646993f, -0.00405235f, -0.10358191f, -0.10834996f, -0.05467486f, 
    -0.20084004f, 0.05347899f, -0.09196088f, -0.01062647f, 0.05771190f, -0.14991578f, 0.20465939f, -0.13285214f, 
    -0.11572119f, 0.17978571f, 0.10250045f, -0.10554387f, -0.00385213f, 0.09200620f, 0.08938113f, 0.04858139f, 
    -0.01832385f, -0.03103846f, 0.09763025f, -0.09617522f, -0.05532329f, 0.04379074f, 0.00968289f, -0.10317459f, 
    -0.02803190f, -0.13664824f, -0.13618547f, -0.04767122f, -0.04447150f, 0.07735478f, 0.00902606f, 0.01052778f, 
    0.07149949f, 0.06739534f, 0.04886137f, 0.22236247f, -0.00385216f, 0.01123186f, 0.12772359f, 0.00297024f, 
    -0.00029728f, -0.01075636f, 0.17730647f, -0.00180920f, 0.20529215f, 0.19736187f, 0.02289339f, -0.19147308f, 
    -0.08758331f, 0.06503841f, 0.03165491f, 0.09173006f, 0.11559559f, 0.10472040f, -0.02769524f, 0.14493416f, 
    0.08388323f, 0.07000411f, 0.11529569f, -0.05826591f, 0.06068503f, 0.02978510f, -0.18716742f, 0.00668671f, 
    -0.24815780f, -0.08521148f, -0.06923342f, -0.01322657f, 0.25837043f, -0.10121693f, -0.03061821f, 0.21489175f, 
    -0.09418238f, 0.01061309f, 0.18686497f, 0.05490132f, -0.02000845f, -0.05130452f, -0.02341469f, -0.16935471f, 
    0.13238700f, 0.07589839f, 0.02532316f, -0.06606435f, -0.16522853f, 0.01613433f, -0.20616828f, -0.04664714f, 
    -0.10068142f, 0.01731481f, 0.06314140f, -0.13754401f, 0.19673812f, 0.17435010f, 0.09718984f, -0.08022373f, 
    -0.05451325f, 0.03911360f, 0.02943433f, -0.13987942f, 0.13382971f, 0.06038840f, 0.08990591f, 0.01252824f, 
    0.03647903f, 0.26681834f, 0.07334889f, 0.18340625f, 0.11753656f, 0.01236075f, 0.15089329f, 0.20472085f, 
    0.07491034f, 0.12406193f, -0.06889426f, -0.03258697f, -0.14055952f, -0.09869717f, 0.10404599f, -0.12736359f, 
    0.01946499f, 0.05047303f, -0.07390291f, -0.11376327f, -0.05035841f, -0.16045566f, 0.03151989f, -0.03382591f, 
    0.17051642f, 0.01794195f, 0.24011756f, 0.14156282f, 0.01795304f, 0.04589532f, 0.04614717f, 0.04162420f, 
    0.01164870f, 0.06466752f, 0.04149674f, -0.01887743f, -0.16541193f, -0.13900173f, -0.04789727f, 0.05127147f, 
    -0.03766324f, 0.12905742f, -0.05940617f, 0.07444245f, 0.11677302f, 0.05188236f, 0.04758880f, 0.09074660f, 
    -0.01082108f, 0.04879873f, 0.00652592f, 0.05239147f, -0.02771950f, -0.02455470f, 0.05681150f, 0.03773899f, 
    -0.05149850f, 0.06246995f, -0.04230910f, 0.04372204f, -0.06102277f, 0.04945457f, 0.03899025f, 0.01263468f, 
    -0.02536954f, -0.05958292f, -0.01712173f, -0.06862354f, -0.04206724f, 0.06604898f, 0.02826674f, 0.01035515f, 
    -0.02896182f, -0.04672608f, -0.04018084f, 0.01886096f, -0.02676720f, -0.01306520f, 0.06674516f, 0.03874077f, 
    0.04179711f, 0.00901697f, -0.07778271f, -0.02067630f, -0.00807395f, 0.00815266f, -0.05619221f, 0.01476859f, 
    0.06307600f, -0.06059559f, -0.03211203f, -0.07170063f, -0.01319613f, -0.02252852f, -0.05052009f, -0.07574981f, 
    0.00191350f, -0.03795882f, -0.01680526f, -0.03438793f, -0.02616372f, 0.01443179f, 0.00990697f, -0.06487092f, 
    -0.03050549f, -0.07296036f, 0.03505777f, -0.04950380f, 0.02461219f, -0.04800666f, -0.04452746f, 0.04210852f, 
    -0.00316718f, -0.06565309f, -0.05738627f, -0.05158811f, 0.01002090f, 0.02053217f, 0.02337448f, -0.04980405f, 
    -0.00492402f, -0.02665726f, -0.07676930f, 0.01673793f, -0.07401719f, 0.03021824f, -0.00199321f, -0.06852842f, 
    -0.05676366f, -0.03611696f, 0.03633728f, -0.05510638f, 0.03064591f, 0.01639113f, -0.05564136f, -0.07684091f, 
    -0.07384878f, 0.06164747f, 0.05619306f, -0.03554544f, -0.01930519f, -0.00890788f, -0.05697725f, -0.05934106f, 
    -0.03598256f, 0.02671353f, -0.06004522f, 0.05813943f, 0.00825953f, -0.04823123f, -0.07344209f, -0.03579333f, 
    0.03685733f, 0.05044634f, -0.07576114f, -0.04517298f, 0.03813305f, 0.05605301f, -0.06934583f, 0.02396722f, 
    0.02905863f, -0.03654177f, 0.01009369f, -0.04918445f, -0.01574060f, -0.02550798f, 0.04942033f, 0.05986447f, 
    0.04948572f, 0.03381157f, 0.02278076f, 0.06631157f, -0.06329873f, -0.05352060f, -0.07785723f, 0.01603333f, 
    0.00927240f, -0.03181590f, 0.01276373f, 0.05741040f, 0.01280072f, 0.05704974f, 0.05062352f, -0.01001257f, 
    0.05702472f, 0.06237762f, 0.06177814f, -0.01357387f, -0.00065510f, 0.03159786f, 0.04325869f, 0.04913709f, 
    -0.02839583f, -0.06323372f, -0.06328883f, -0.03643454f, -0.06657232f, -0.07758389f, -0.02360423f, -0.05552122f, 
    0.05985989f, -0.06032855f, 0.03014357f, -0.00127760f, -0.04951539f, -0.05647157f, -0.07603315f, -0.02538130f, 
    0.03454593f, -0.00048470f, 0.01369708f, -0.06179640f, 0.01850418f, -0.00799487f, -0.00926631f, 0.00333093f, 
    -0.04550988f, -0.00168800f, -0.05284373f, -0.07086081f, 0.01305480f, 0.00129376f, -0.00083689f, 0.04810018f, 
    0.03928433f, 0.00734036f, -0.02561638f, -0.03642949f, 0.05332441f, 0.06390053f, 0.03906053f, 0.00855842f, 
    -0.03043471f, -0.02277063f, -0.04067165f, 0.02788761f, -0.03472387f, -0.00476649f, 0.06031020f, -0.05141161f, 
    -0.43176463f, 0.14503574f, 0.05796617f, -0.14934865f, 0.02610431f, 0.06894083f, -0.10496002f, 0.01768200f, 
    0.00591309f, 0.05552638f, -0.07525911f, -0.10096551f, -0.18372209f, -0.04929673f, 0.13797523f, -0.27629179f, 
    0.07571693f, 0.08939237f, -0.03629488f, -0.00038086f, 0.15792711f, 0.03348382f, -0.04963030f, -0.05955369f, 
    -0.12859145f, 0.10569641f, -0.08284374f, -0.01935162f, 0.05629737f, -0.05568153f, -0.00594180f, -0.08532926f, 
    0.05201011f, 0.13777830f, 0.07438466f, -0.02390594f, -0.08882741f, -0.09189028f, -0.09201126f, 0.07849899f, 
    -0.08457819f, 0.01714378f, 0.05271546f, -0.01606981f, 0.07754900f, -0.07013299f, 0.16627358f, -0.20742320f, 
    -0.04382165f, -0.18148218f, 0.15766238f, 0.13457772f, 0.14955364f, -0.09338017f, 0.04914589f, 0.13841419f, 
    -0.05234583f, -0.07277699f, -0.05657452f, 0.07382961f, -0.14953741f, -0.09014323f, 0.12371581f, -0.18139365f, 
    0.11834183f, 0.12740408f, -0.06390849f, -0.07948618f, 0.00178896f, 0.07601370f, -0.11785746f, 0.12742394f, 
    -0.43600121f, 0.03111636f, 0.13461187f, 0.17226952f, -0.11354543f, -0.00061677f, 0.07841041f, 0.06886537f, 
    -0.08605551f, -0.02628488f, 0.02544576f, 0.13311575f, -0.37570003f, -0.04225163f, 0.04580648f, -0.03847423f, 
    -0.05515807f, 0.12393527f, -0.06516413f, 0.03498135f, 0.06228935f, 0.15003604f, 0.03233944f, 0.07146201f, 
    0.11065411f, -0.16626258f, 0.04108812f, 0.00772704f, -0.03669736f, -0.05393913f, -0.22888519f, 0.00932495f, 
    -0.07981820f, -0.18180530f, 0.08158524f, -0.04734872f, -0.14990182f, 0.00107384f, 0.13974647f, 0.08046051f, 
    0.07375333f, 0.08939892f, 0.04022636f, -0.07005357f, 0.05892314f, 0.03933671f, -0.13251105f, -0.01266251f, 
    0.00625141f, 0.01891082f, -0.17321208f, 0.10688512f, -0.04262649f, -0.00910053f, 0.06251962f, 0.01966245f, 
    -0.07131240f, 0.12978274f, 0.10949699f, 0.08218116f, 0.32522732f, -0.21603540f, 0.12392759f, 0.07551920f, 
    0.02445711f, 0.09440946f, 0.09406743f, 0.00991183f, 0.07576735f, 0.20392776f, 0.03538231f, 0.20790128f, 
    0.40556157f, 0.15370172f, 0.13317959f, -0.06692147f, 0.07253004f, -0.14054963f, -0.16320905f, 0.20483491f, 
    -0.04821775f, 0.06416950f, -0.11616222f, 0.01755571f, -0.01691663f, 0.01504192f, 0.11609158f, 0.14957620f, 
    0.01194239f, 0.06452091f, 0.00591894f, -0.02083995f, -0.04549930f, -0.04350333f, -0.02058704f, -0.11496034f, 
    0.33511740f, 0.02779318f, 0.03346823f, -0.22382219f, 0.15761879f, 0.07453222f, -0.03054263f, -0.04291750f, 
    -0.02939028f, 0.06002987f, 0.02538544f, -0.02125856f, -0.18251619f, 0.21220103f, -0.04088600f, 0.28735983f, 
    -0.00539562f, 0.05672589f, 0.02727789f, 0.22241355f, 0.04150042f, -0.02795670f, 0.13304125f, 0.17901701f, 
    0.05360969f, -0.16513371f, -0.14661743f, 0.03800291f, -0.02377107f, 0.00531917f, 0.17696172f, -0.07792509f, 
    0.06827716f, -0.01255234f, 0.01462077f, -0.02010902f, -0.05570973f, 0.08227704f, -0.11622293f, 0.05047579f, 
    0.10619044f, 0.09675023f, 0.00775669f, 0.01367959f, 0.01874981f, 0.04830027f, 0.02348329f, 0.04375413f, 
    0.00435350f, 0.02420295f, 0.00261826f, 0.14378598f, 0.02219435f, 0.02736511f, 0.04548313f, 0.03855825f, 
    -0.14476363f, -0.00817966f, 0.05501994f, 0.00824701f, 0.23483612f, -0.23418757f, -0.11723568f, -0.00357377f, 
    0.08839971f, -0.08392037f, 0.07137932f, -0.03691128f, -0.05285394f, -0.06442092f, -0.02620651f, 0.06717537f, 
    -0.19788459f, 0.18931223f, -0.15275942f, 0.04646269f, 0.04079134f, 0.01281284f, -0.08099069f, 0.09046376f, 
    -0.01215655f, 0.03446391f, 0.02013191f, -0.05959544f, -0.37120995f, 0.04618274f, 0.14839213f, -0.04467696f, 
    0.11488603f, 0.06006095f, 0.12494982f, -0.08978958f, 0.11513598f, 0.25424516f, 0.12998179f, 0.02626899f, 
    -0.34540227f, 0.06614867f, 0.01517203f, 0.27020246f, -0.09126133f, 0.04771947f, -0.14027803f, -0.02394447f, 
    0.07645313f, -0.03753557f, -0.06867259f, -0.15586287f, -0.23187320f, 0.03158344f, -0.01399718f, 0.11063728f, 
    0.09933043f, 0.03034655f, 0.06314147f, -0.07258452f, -0.04851684f, 0.01670605f, -0.01664935f, 0.02541033f, 
    0.12161303f, -0.17755017f, 0.20104842f, -0.03205466f, -0.08576511f, -0.08083671f, -0.08044763f, 0.00280469f, 
    -0.04359828f, -0.01177188f, 0.08057356f, 0.03491323f, 0.14862533f, -0.01131231f, -0.27495345f, 0.02513044f, 
    0.04257049f, -0.07878788f, -0.04566126f, -0.08374123f, -0.02425291f, 0.13756350f, 0.03298041f, 0.05866363f, 
    0.02410709f, -0.16708983f, 0.14264208f, -0.13256037f, 0.02644480f, -0.04909797f, 0.02988795f, 0.07520550f, 
    0.20375995f, 0.05797651f, -0.00853481f, -0.02399484f, 0.32224837f, 0.02067152f, 0.00024237f, 0.06200157f, 
    -0.00653412f, 0.04450749f, 0.04513001f, 0.01257982f, 0.00110347f, -0.09911255f, -0.00289602f, -0.01426399f, 
    0.07468263f, 0.17597051f, 0.09282944f, 0.08227757f, -0.08076223f, 0.00375564f, 0.08077135f, -0.00605940f, 
    0.02086154f, 0.01879442f, 0.07435318f, 0.02763317f, 0.15622155f, 0.11953894f, 0.02604826f, -0.03570342f, 
    0.09814295f, 0.04909886f, 0.02335832f, 0.03104313f, -0.02569764f, 0.10941797f, 0.15020347f, 0.06319109f, 
    0.22214800f, -0.07528424f, -0.25201327f, -0.20485237f, 0.11167959f, -0.02881891f, 0.17746514f, -0.03196014f, 
    0.06609444f, -0.08661815f, -0.00115156f, -0.00388327f, -0.01483387f, -0.00383544f, 0.06735460f, 0.06108266f, 
    -0.08391728f, -0.06243189f, 0.06636804f, -0.00380971f, 0.00251436f, -0.07449454f, -0.06156782f, -0.00315350f, 
    -0.00917889f, -0.00123844f, -0.08190078f, -0.05829612f, -0.01375505f, -0.01947339f, -0.06710471f, 0.00835453f, 
    0.02585259f, 0.03423509f, -0.07250676f, 0.02359756f, -0.04223972f, 0.02281039f, 0.06609676f, 0.02032452f, 
    0.01448487f, 0.00229625f, -0.05543913f, 0.01152384f, 0.02075952f, 0.04193510f, -0.04211732f, -0.06185313f, 
    0.04036061f, 0.04361734f, -0.02288017f, 0.03176871f, 0.03686696f, 0.03620077f, -0.02868636f, -0.03059850f, 
    -0.00036707f, -0.06964028f, -0.08194308f, 0.00397284f, -0.00777375f, -0.01100398f, -0.07825320f, 0.05106882f, 
    -0.01928497f, -0.04548538f, 0.00835226f, 0.01615040f, -0.08042478f, 0.03669538f, -0.02020269f, -0.02260697f, 
    -0.00585487f, 0.03871288f, -0.04354208f, 0.05205240f, -0.01391517f, -0.02102901f, -0.07608427f, 0.01808340f, 
    -0.00764598f, 0.04589891f, -0.06274568f, -0.05011431f, -0.00492970f, -0.03738073f, 0.02458453f, 0.03022226f, 
    -0.03862182f, -0.05108638f, -0.06430499f, 0.01351854f, 0.00283052f, -0.07877154f, -0.02219813f, -0.05895026f, 
    0.04982531f, -0.03648167f, 0.02836004f, -0.01576751f, 0.02357795f, -0.03252788f, -0.09993562f, -0.00814044f, 
    -0.02011250f, 0.01087644f, 0.06422082f, -0.04310656f, -0.08737701f, 0.02227041f, 0.06219815f, 0.06882537f, 
    0.02777160f, -0.05092688f, -0.09205953f, -0.03393184f, 0.04467840f, -0.05143410f, -0.00116304f, -0.02741953f, 
    0.02159904f, 0.00454081f, 0.01185933f, -0.10853653f, -0.06794506f, 0.02565406f, -0.07847375f, 0.01975591f, 
    0.03928008f, 0.02175170f, -0.05367399f, 0.00786345f, 0.06299972f, -0.01623465f, -0.03088731f, 0.05599455f, 
    -0.09920319f, 0.05664250f, 0.01602161f, -0.01988675f, 0.03701759f, -0.01136657f, -0.05059627f, 0.00081634f, 
    -0.03824634f, 0.03068238f, 0.02684793f, 0.03007006f, -0.04920975f, 0.01821673f, 0.01145408f, -0.04496747f, 
    0.04635002f, 0.00591601f, -0.06912302f, -0.03628865f, -0.01226995f, 0.04000820f, -0.00438869f, 0.03773439f, 
    -0.05004194f, 0.02511478f, -0.02171026f, -0.04011860f, 0.05561868f, 0.01365776f, -0.07246123f, 0.02561637f, 
    0.01724089f, -0.01332295f, -0.07845486f, 0.01081099f, -0.07290654f, -0.03782596f, -0.03289657f, -0.08282913f, 
    -0.04620997f, -0.06433013f, 0.02242039f, -0.02719202f, 0.02116153f, -0.03858585f, 0.02981774f, -0.08044109f, 
    0.04271995f, 0.03788174f, 0.00710263f, -0.04237349f, 0.02775950f, -0.02950495f, 0.02660863f, -0.08081847f, 
    -0.02620183f, -0.02796619f, 0.02695720f, -0.08024610f, -0.01291470f, 0.02353518f, -0.02219781f, -0.07869660f, 
    -0.01236116f, -0.00436464f, -0.07590854f, 0.05616654f, 0.06183547f, -0.07351834f, 0.00714500f, 0.06800232f, 
    0.04768967f, -0.04294732f, -0.05249938f, 0.00821911f, 0.04638009f, 0.01080251f, 0.00186736f, 0.04786685f, 
    -0.32820913f, -0.39715868f, -0.32663348f, -0.00384768f, 0.06427468f, 0.01191402f, 0.08012900f, -0.09119006f, 
    -0.13930610f, 0.03326619f, 0.07814108f, 0.02649748f, -0.15317376f, 0.09934460f, -0.12677047f, 0.31352496f, 
    -0.00505397f, 0.25270474f, -0.02706519f, 0.02269248f, 0.00900142f, 0.07534029f, -0.12172583f, 0.02380078f, 
    -0.27868742f, -0.15332139f, -0.21846266f, 0.18912248f, -0.03186279f, -0.08150131f, 0.01243205f, -0.01612158f, 
    -0.01215671f, 0.00911981f, -0.17998394f, 0.02868406f, -0.25504693f, -0.13806042f, -0.26581118f, -0.23749299f, 
    -0.01504267f, -0.13450888f, 0.05580699f, -0.00111798f, 0.11600502f, -0.05013198f, -0.08660100f, 0.08229169f, 
    -0.45378646f, 0.20871079f, -0.01780060f, 0.15270266f, 0.09063040f, 0.09474860f, -0.03896240f, 0.00813153f, 
    0.12705961f, -0.11347245f, 0.10992645f, 0.07821513f, -0.07437282f, 0.06666780f, -0.01597844f, -0.00002185f, 
    0.14507842f, -0.02644841f, 0.04974182f, -0.00126390f, 0.15381190f, 0.09102423f, 0.13188733f, 0.05210773f, 
    0.10234720f, -0.02830243f, -0.05421993f, -0.06798095f, -0.06383454f, 0.08702672f, -0.04466243f, -0.03460766f, 
    0.02956272f, -0.02361312f, -0.02971888f, -0.07147823f, -0.15358707f, -0.27399763f, -0.10451250f, 0.16182804f, 
    0.10532779f, -0.01952084f, 0.05750562f, 0.00462373f, -0.07485334f, -0.02699320f, -0.00861213f, 0.08548963f, 
    0.28658408f, 0.14827515f, 0.10416711f, 0.10146152f, -0.01638693f, -0.09416825f, 0.02411308f, 0.02546556f, 
    -0.05544863f, -0.03386414f, 0.05373962f, 0.06436379f, 0.23046246f, 0.08976668f, -0.05924068f, 0.08851837f, 
    0.14590338f, 0.00645901f, -0.02502968f, 0.13365912f, -0.09847359f, 0.06031894f, 0.02208981f, -0.10228045f, 
    0.19839230f, -0.13502932f, 0.03267098f, -0.09568926f, -0.08750022f, -0.01070040f, -0.04858666f, 0.09716169f, 
    0.09904601f, 0.11760524f, -0.02190573f, 0.00558615f, 0.34332430f, 0.22308466f, -0.01965820f, 0.05431329f, 
    -0.19282319f, 0.07251269f, -0.00082209f, -0.05920893f, 0.04668024f, -0.10481834f, -0.08973696f, -0.01975779f, 
    0.16240287f, 0.05352137f, 0.02070422f, 0.06764605f, -0.06309156f, 0.07774030f, 0.18914741f, -0.07669928f, 
    0.09205409f, -0.06768984f, 0.15048604f, 0.08252619f, -0.05957520f, 0.19582270f, 0.27681053f, 0.08305489f, 
    0.01041554f, 0.07599732f, -0.04471464f, 0.12981100f, -0.15742996f, 0.08771054f, -0.04340204f, 0.01426463f, 
    0.28097698f, 0.18273485f, 0.16637011f, 0.01119157f, 0.10686517f, -0.00620596f, -0.03259428f, -0.07988904f, 
    0.11302292f, -0.08351811f, 0.15086831f, 0.03669138f, -0.01527272f, -0.10444582f, -0.01758822f, -0.06092809f, 
    0.03871535f, 0.05121186f, 0.11352368f, 0.04335277f, 0.04423138f, -0.03322480f, -0.02737361f, -0.02533133f, 
    0.25589082f, 0.18462324f, 0.13635454f, -0.03545426f, 0.13741677f, -0.00551924f, -0.01491740f, 0.00213790f, 
    0.06185835f, 0.11689724f, -0.06720686f, -0.11137291f, 0.19908628f, 0.16495012f, 0.04103125f, -0.21155304f, 
    0.03842631f, 0.16361873f, 0.04960420f, 0.00913662f, 0.07095848f, 0.04364788f, 0.02905337f, 0.03049186f, 
    0.15057299f, 0.18786180f, 0.01191095f, 0.17833576f, 0.00188623f, 0.05118364f, -0.09513553f, 0.05897179f, 
    -0.08633359f, 0.08260294f, -0.01925461f, 0.03431554f, -0.06707092f, -0.20458870f, 0.07057946f, 0.02446626f, 
    0.05267892f, 0.00372108f, 0.04131723f, 0.16068321f, 0.04332628f, 0.00208224f, 0.11018514f, -0.04830560f, 
    0.13352621f, -0.05753756f, 0.19269219f, -0.20005517f, 0.09658307f, 0.12652472f, 0.04150630f, 0.06122603f, 
    0.01088330f, -0.09636196f, -0.04754695f, -0.16896588f, -0.20567545f, 0.27963129f, 0.11659915f, -0.03963430f, 
    0.11164851f, -0.10776096f, -0.05420670f, 0.09427933f, 0.04171471f, 0.02081012f, -0.03349724f, 0.00621765f, 
    -0.24615008f, 0.15152043f, -0.06291775f, 0.21682866f, -0.05945418f, -0.07751089f, 0.05436103f, 0.02605730f, 
    0.02224309f, -0.01929072f, -0.00173059f, 0.04489160f, -0.05085378f, 0.44375396f, 0.10199621f, 0.01504885f, 
    -0.01501894f, 0.05274652f, 0.01896492f, 0.06398298f, 0.00974532f, 0.07140507f, 0.05733555f, -0.03836490f, 
    -0.09638785f, -0.18617202f, 0.16787565f, -0.04663298f, -0.06187734f, -0.08645510f, -0.15702204f, -0.08210944f, 
    -0.11036836f, -0.02022982f, 0.03574321f, -0.09252428f, 0.06564897f, -0.09122401f, -0.11224309f, 0.30388850f, 
    0.06307179f, 0.05891394f, 0.06996505f, -0.05639912f, 0.05222858f, 0.03791760f, -0.09364919f, -0.09518009f, 
    -0.31836772f, -0.02950396f, 0.18179692f, -0.19174320f, 0.10928386f, -0.00140738f, -0.02188332f, -0.02074550f, 
    -0.12891412f, 0.08661147f, 0.06073432f, -0.01324693f, 0.34474036f, -0.02790156f, -0.00943287f, -0.00902266f, 
    0.03307035f, 0.00806721f, 0.12791972f, -0.07951497f, 0.03490140f, -0.02284691f, 0.18555768f, -0.03900255f, 
    -0.06694447f, 0.17114267f, -0.04311861f, 0.12463605f, -0.09838296f, 0.02488893f, 0.03782423f, 0.02909655f, 
    -0.07446311f, 0.12120170f, -0.00552768f, -0.04911235f, 0.22027279f, -0.12983586f, 0.03613503f, -0.17952335f, 
    -0.01400461f, 0.08640342f, -0.08081030f, -0.00792077f, -0.03296573f, -0.03363937f, -0.05202784f, -0.02233824f, 
    0.01162959f, -0.07842591f, -0.12950768f, -0.00679098f, 0.03315596f, -0.05447622f, 0.03585909f, -0.02261436f, 
    0.01810425f, -0.02081036f, -0.15920685f, -0.03384402f, -0.16568284f, -0.17448930f, 0.09782681f, 0.16541605f, 
    0.07622940f, -0.00960713f, 0.06299142f, 0.22047143f, 0.05262811f, -0.03098775f, -0.08403011f, 0.06344488f, 
    0.42381027f, -0.07996988f, -0.08442064f, 0.14099136f, 0.02070787f, 0.05488137f, 0.07022679f, -0.16292720f, 
    0.00660628f, 0.03011996f, 0.13000815f, 0.03284303f, 0.32019946f, 0.22459167f, -0.12724178f, 0.14574285f, 
    -0.04151455f, 0.09279188f, 0.00980956f, 0.00662301f, 0.07709704f, 0.05178867f, 0.07281398f, 0.15204924f, 
    0.23677588f, 0.02638287f, -0.04864097f, 0.20187739f, -0.06638778f, 0.10083687f, 0.00116557f, 0.11964377f, 
    -0.00727684f, 0.03150644f, 0.09066176f, 0.04019206f, -0.01320309f, -0.06343768f, -0.02464850f, -0.20278208f, 
    0.06804805f, -0.02282222f, 0.12818210f, 0.03945595f, -0.03375707f, -0.06584813f, -0.06831150f, 0.12441362f, 
    0.04294423f, 0.28443611f, -0.04554747f, -0.09007670f, -0.06674323f, 0.03348700f, 0.03583491f, -0.16269563f, 
    -0.10661516f, 0.08585185f, -0.08874989f, -0.04961770f, -0.19437851f, 0.23462798f, 0.03730218f, 0.07356052f, 
    0.07406092f, 0.00734873f, 0.03786704f, 0.06020849f, 0.05572613f, 0.06413386f, 0.02379247f, -0.00162348f, 
    -0.25673050f, 0.05752268f, -0.16059498f, 0.12411524f, -0.13413024f, -0.13582517f, -0.06136699f, 0.00924170f, 
    0.05167932f, -0.13812415f, -0.12930645f, -0.09842049f, 0.00998896f, 0.32532898f, 0.07254338f, 0.07089233f, 
    0.01910546f, 0.01030178f, 0.09605833f, -0.07437824f, 0.04802304f, 0.06714141f, 0.03255641f, -0.04519869f, 
    -0.09421273f, -0.06737221f, 0.10623701f, -0.15182947f, -0.02614221f, -0.06970571f, 0.02556274f, -0.11864374f, 
    0.00607559f, -0.08445950f, -0.11486850f, -0.02359889f, 0.06671773f, 0.06273694f, -0.21463454f, 0.26751205f, 
    0.07556386f, -0.02576447f, -0.01969237f, -0.06172901f, -0.01842958f, 0.05724534f, -0.01058251f, -0.08489030f, 
    -0.04450447f, -0.13312840f, 0.28795281f, -0.31197613f, 0.05309038f, 0.06709216f, 0.02247873f, 0.00339926f, 
    0.07944704f, 0.07550056f, 0.08888958f, 0.06132979f, 0.18757860f, -0.00107685f, -0.00511935f, 0.01071329f, 
    0.08461114f, 0.00212482f, 0.00134246f, 0.14076078f, -0.00861952f, -0.21467087f, 0.08271084f, 0.02364873f, 
    -0.26649854f, -0.04724985f, -0.11980302f, -0.05236733f, -0.02888225f, 0.12079582f, 0.00797857f, -0.08135023f, 
    -0.03984621f, -0.00547936f, 0.10149270f, -0.10054657f, 0.38526973f, 0.08375383f, -0.08754200f, -0.04289138f, 
    0.08951472f, -0.05832450f, -0.02614304f, 0.03435264f, -0.05230074f, -0.00229112f, 0.05287816f, 0.06093230f, 
    0.02195524f, -0.16147861f, -0.27275679f, 0.02179802f, -0.07188933f, 0.00322132f, 0.04789284f, -0.06994970f, 
    -0.03098117f, -0.02136412f, 0.01406656f, 0.00924263f, -0.17568210f, -0.20433196f, 0.03612465f, -0.04122270f, 
    -0.07578464f, -0.11383472f, 0.03235974f, 0.19451815f, 0.00357627f, -0.01013054f, -0.01144249f, -0.05296011f, 
    0.29793492f, -0.09873868f, -0.17900704f, -0.03632032f, 0.04817476f, -0.03723711f, -0.16444393f, -0.09432371f, 
    -0.11274407f, -0.00632847f, -0.11911668f, -0.06425810f, 0.08237636f, -0.21117501f, -0.18373087f, 0.27624077f, 
    0.04647941f, 0.06216439f, 0.01273120f, -0.07515800f, -0.07486720f, -0.02417282f, 0.13287196f, -0.21459694f, 
    0.00155195f, -0.02800928f, -0.06905024f, -0.21704562f, 0.05387592f, -0.03983792f, 0.00174816f, 0.03158989f, 
    -0.03492115f, -0.07391607f, -0.08111120f, 0.06589283f, -0.06730236f, -0.01425314f, -0.08297297f, -0.14883725f, 
    0.07676553f, -0.03122625f, 0.11388489f, 0.12181090f, 0.01370120f, -0.00939138f, -0.06424526f, -0.12471464f, 
    0.04547742f, 0.06325981f, 0.07243055f, -0.12252622f, -0.13341889f, -0.18114908f, 0.00917995f, 0.14615032f, 
    0.02360444f, -0.20781866f, 0.00674210f, 0.07734857f, 0.25752717f, 0.12675008f, -0.03376989f, -0.06561724f, 
    -0.13889733f, 0.04818825f, -0.06173480f, 0.12357420f, -0.06291831f, -0.10680462f, -0.00797579f, 0.10793126f, 
    0.38310182f, 0.22849390f, 0.16513386f, 0.28342029f, 0.00695276f, 0.10522534f, -0.08170758f, 0.07715584f, 
    0.00022066f, 0.00754882f, -0.07479900f, -0.00849798f, 0.34336415f, -0.14007227f, -0.15377788f, -0.04840929f, 
    -0.15921611f, 0.09283178f, -0.03119378f, 0.10470025f, -0.00384474f, -0.03216105f, 0.09579748f, 0.07271692f, 
    0.19090165f, 0.06056199f, 0.17867288f, 0.08728963f, 0.09118307f, -0.11291792f, 0.03711241f, 0.02337150f, 
    -0.19643396f, -0.06209930f, 0.02041870f, -0.10353322f, 0.22742866f, 0.15568735f, -0.00482121f, 0.06766184f, 
    -0.02949154f, -0.01126813f, 0.03790538f, 0.02170940f, 0.03233910f, 0.03952697f, -0.06304314f, -0.05337826f, 
    -0.20351802f, -0.11956596f, -0.04015898f, -0.02163073f, 0.14278576f, -0.11871394f, -0.13168466f, -0.11499858f, 
    -0.06742927f, -0.07420164f, -0.07371263f, 0.01752846f, 0.09398922f, 0.17177887f, 0.00062286f, 0.14844349f, 
    0.16114590f, 0.14164230f, 0.14093524f, -0.06211467f, -0.10766774f, 0.04816166f, -0.08825199f, -0.00461091f, 
    0.23231876f, 0.07401125f, 0.25150138f, 0.20861734f, 0.03469053f, -0.05086063f, 0.19179837f, 0.01905049f, 
    0.06756342f, -0.16491243f, -0.04106994f, -0.24740061f, -0.09058893f, 0.13644150f, 0.11846545f, 0.06272021f, 
    -0.09693035f, -0.08119199f, -0.00638808f, -0.05659329f, -0.17081861f, -0.08307187f, -0.09966924f, -0.24336098f, 
    0.32671261f, -0.01262947f, 0.09878311f, 0.33488825f, -0.00336914f, 0.07556693f, 0.07492971f, 0.03042496f, 
    0.00006992f, -0.07751587f, -0.17338197f, -0.06883661f, 0.02999837f, 0.10489453f, -0.10147972f, 0.06959034f, 
    0.00430914f, 0.05486939f, -0.02514944f, 0.02897616f, 0.02167357f, 0.08654346f, 0.14716497f, 0.04609891f, 
    0.03059818f, -0.04048509f, -0.06762543f, 0.00076419f, 0.01622259f, 0.00562461f, -0.05822941f, -0.03904151f, 
    0.03474220f, 0.02348258f, -0.06035558f, -0.05668262f, -0.05605564f, -0.04497442f, -0.00956604f, -0.06476156f, 
    0.04133517f, -0.04072785f, -0.04810562f, -0.00163747f, 0.04001585f, -0.06611492f, -0.06436087f, -0.05803036f, 
    -0.03101238f, -0.06259476f, 0.01759269f, 0.04353793f, 0.03220854f, -0.07258293f, -0.00697990f, 0.04693716f, 
    0.04893735f, 0.02827970f, -0.02035657f, 0.00790974f, 0.02504287f, -0.02209943f, -0.06164437f, 0.00117425f, 
    -0.05962059f, -0.03659536f, -0.06746760f, 0.05252725f, -0.03438329f, -0.01609847f, 0.05543218f, -0.01753031f, 
    0.02186000f, -0.05541085f, 0.05222435f, 0.04429575f, 0.01575422f, 0.05802138f, -0.02501404f, -0.04991824f, 
    0.04355510f, -0.01406316f, -0.04746355f, 0.00398107f, 0.06113840f, 0.05679986f, 0.04157371f, 0.04109871f, 
    0.06442316f, 0.03735807f, 0.01324570f, 0.00065691f, 0.02923151f, -0.07431456f, -0.02859983f, 0.06048090f, 
    -0.03166950f, -0.03638018f, -0.02764486f, -0.05718044f, -0.02999458f, -0.06018323f, 0.06262894f, -0.01660924f, 
    -0.01116699f, 0.00753899f, -0.03051692f, -0.04223754f, 0.05941252f, 0.00108220f, -0.04724360f, 0.03034396f, 
    0.06428704f, -0.03837189f, -0.06023151f, 0.03730463f, -0.02375265f, -0.06168476f, 0.05082110f, 0.02007861f, 
    0.05868286f, 0.02305901f, -0.06192981f, -0.06633468f, 0.01440923f, 0.03864655f, 0.04433103f, -0.00313861f, 
    -0.03406154f, 0.02908461f, -0.03122914f, 0.04028234f, 0.00841902f, -0.05112931f, 0.04738560f, 0.02898287f, 
    0.01310358f, 0.06243458f, -0.02387587f, -0.02283831f, -0.05100992f, -0.07789480f, -0.07170665f, 0.01726987f, 
    -0.01819771f, -0.01548892f, -0.06628868f, -0.02745896f, 0.00476224f, 0.03631090f, 0.02569700f, -0.04411343f, 
    -0.05750544f, 0.06619078f, -0.05994213f, -0.06213645f, -0.06350110f, -0.03652554f, -0.07181830f, -0.05164421f, 
    0.01897619f, 0.00819214f, -0.07947438f, 0.01911641f, -0.05744664f, -0.05392682f, -0.06628769f, 0.05691043f, 
    -0.03200074f, -0.06747520f, -0.05605853f, 0.00186680f, 0.00799452f, -0.04197850f, 0.00405964f, 0.01360768f, 
    -0.04096979f, 0.04627360f, -0.01146386f, 0.04438524f, 0.03750038f, 0.02734385f, -0.01006049f, -0.07374581f, 
    -0.04905412f, -0.07070853f, -0.00101422f, 0.02158414f, 0.02304310f, -0.04924085f, -0.04029647f, 0.04293008f, 
    -0.04424408f, 0.00668018f, 0.02462784f, 0.00572985f, -0.01480591f, -0.03656624f, -0.00709643f, -0.05155173f, 
    -0.06934504f, 0.05068596f, -0.02836588f, -0.06557140f, 0.03820145f, -0.00242120f, 0.02538097f, -0.02360127f, 
    0.03798028f, -0.02957147f, 0.00048734f, -0.03993881f, 0.04703892f, -0.04268192f, 0.00281800f, 0.01897275f, 
    0.12463631f, 0.23546474f, 0.19012327f, 0.04394393f, -0.07275511f, -0.10191431f, 0.00013549f, 0.16115019f, 
    0.00137564f, 0.05358282f, 0.04976034f, 0.16158643f, -0.05182349f, 0.11109408f, 0.19022037f, 0.34706977f, 
    -0.11619583f, 0.02235537f, 0.11736463f, 0.03779050f, -0.06902929f, -0.07543820f, 0.04940056f, -0.00403198f, 
    0.15118001f, -0.15740500f, 0.01627376f, 0.21847641f, -0.12533043f, -0.02503119f, -0.00499868f, 0.02623793f, 
    0.10938990f, 0.08420209f, -0.00828033f, 0.05872122f, 0.32363519f, 0.10026944f, 0.18951367f, 0.00077589f, 
    -0.05069179f, 0.02224471f, 0.04323032f, -0.03309629f, -0.07479515f, -0.02537411f, 0.00500197f, -0.09060872f, 
    0.07310620f, 0.29709819f, -0.02380168f, 0.23136057f, -0.04750076f, 0.14966750f, 0.12605296f, -0.19317086f, 
    0.04648639f, -0.03074042f, 0.14487728f, 0.09682697f, 0.09598421f, 0.03020989f, -0.02671039f, 0.14740328f, 
    -0.09877335f, 0.01121116f, 0.02775702f, 0.04625830f, -0.07308833f, -0.10180704f, 0.04524423f, 0.00179075f, 
    0.02100153f, -0.24935852f, -0.02452548f, -0.23593526f, 0.13774358f, 0.03768095f, 0.05268335f, 0.10444032f, 
    0.03968498f, -0.00010533f, 0.04889687f, 0.09944657f, 0.28095317f, -0.10292760f, -0.09420097f, 0.05559953f, 
    -0.01505876f, 0.01020647f, 0.11165543f, 0.03754115f, 0.16691476f, 0.13620847f, 0.00807936f, -0.07885453f, 
    -0.18178478f, 0.16121656f, -0.29198533f, -0.02234935f, -0.01644683f, -0.03938825f, 0.01278300f, -0.08403285f, 
    0.06042662f, -0.15153798f, 0.02841604f, 0.03170844f, 0.06941455f, 0.05687226f, -0.00937768f, -0.17763020f, 
    -0.09212473f, 0.08254180f, 0.08173960f, -0.00631776f, 0.07571477f, -0.03149300f, 0.09565932f, 0.02473099f, 
    0.41288272f, 0.10032851f, -0.07974122f, 0.25223571f, -0.07670833f, 0.03569958f, -0.07767171f, 0.07396921f, 
    -0.12691966f, -0.01496938f, 0.08404926f, 0.02805908f, -0.38217300f, 0.04077037f, 0.01605865f, -0.03576294f, 
    0.08846279f, -0.01526419f, -0.01965868f, 0.07299548f, -0.10034353f, 0.05880322f, 0.02198211f, 0.06175137f, 
    -0.06112036f, -0.09015068f, -0.02901023f, -0.20455343f, 0.06784171f, 0.00211620f, 0.02695913f, -0.06403078f, 
    0.08670040f, 0.02119037f, -0.00091794f, 0.11710723f, -0.11297835f, -0.17432413f, 0.00212883f, 0.24205087f, 
    -0.04410416f, -0.04799393f, -0.01410005f, 0.05094180f, 0.03733367f, -0.04729961f, -0.09151059f, -0.05608764f, 
    -0.27267644f, 0.13136950f, 0.06837770f, -0.13507824f, -0.07445062f, -0.09022062f, -0.09628195f, 0.05105457f, 
    -0.04407704f, 0.04695827f, 0.14101237f, 0.01489643f, 0.09818269f, -0.13309598f, 0.00315477f, -0.15726188f, 
    0.05419016f, 0.11609385f, -0.02183301f, -0.12987575f, 0.00658921f, 0.06157647f, 0.06842427f, 0.05736237f, 
    0.04232922f, 0.07537279f, 0.26957786f, -0.18606497f, 0.11636410f, -0.10815696f, -0.08536354f, 0.04509365f, 
    -0.00469094f, 0.09924599f, -0.04729073f, -0.12657598f, 0.06828691f, 0.19764772f, 0.11717459f, -0.22362059f, 
    -0.07751936f, 0.03139199f, 0.03429596f, -0.01164076f, 0.05848183f, -0.04795049f, 0.03687060f, -0.03709737f, 
    -0.09428954f, 0.08952599f, -0.06240423f, -0.05468691f, -0.08716962f, -0.06128632f, 0.03349205f, 0.02077467f, 
    0.03968162f, 0.08364478f, 0.00641187f, 0.03635504f, 0.08141410f, -0.05583761f, -0.03805956f, -0.01225103f, 
    -0.06955941f, 0.11962715f, 0.16897181f, 0.08430934f, 0.07296072f, -0.05489382f, 0.14865585f, -0.12585630f, 
    0.18035139f, -0.10234145f, 0.02489019f, -0.00874534f, -0.07295475f, 0.16066130f, 0.08025458f, 0.11076840f, 
    -0.01570135f, -0.14614145f, -0.00205851f, -0.07026660f, -0.11954944f, 0.03941578f, 0.07295529f, -0.00493574f, 
    0.11420457f, 0.03543684f, -0.09071007f, 0.03219497f, -0.02760578f, -0.08090529f, -0.11605076f, 0.13768274f, 
    -0.10329651f, -0.12312961f, -0.02278845f, -0.02580876f, -0.00546822f, -0.20532729f, 0.24135455f, -0.05597779f, 
    -0.07540294f, 0.02885415f, 0.04598240f, 0.13019466f, -0.00070132f, 0.08651195f, 0.00259496f, -0.04098519f, 
    -0.10389846f, 0.11295041f, 0.09732256f, -0.01182353f, 0.11273046f, 0.07171898f, 0.03447208f, -0.01810590f, 
    0.11318636f, -0.13193926f, -0.07951646f, 0.00525795f, -0.15282536f, -0.09715900f, -0.24095194f, 0.08552362f, 
    0.05376089f, -0.02939598f, 0.09722197f, -0.10606007f, 0.07070343f, -0.35478041f, 0.23832679f, 0.06672672f, 
    -0.00269081f, 0.13229242f, 0.20034207f, 0.13998318f, -0.00475614f, 0.03425469f, -0.06738119f, 0.02730049f, 
    -0.24166439f, -0.06894907f, -0.04611405f, 0.09198231f, 0.07328612f, 0.06210989f, -0.04341554f, 0.07322731f, 
    -0.15498500f, 0.08589775f, 0.08765925f, 0.04177222f, 0.24405326f, -0.11589927f, 0.06324200f, 0.12340628f, 
    0.03140307f, 0.15390308f, 0.26222229f, -0.14929242f, -0.06967618f, 0.12482852f, 0.12224980f, 0.05981620f, 
    0.22546043f, 0.10028978f, -0.12931755f, 0.00413076f, -0.02437239f, 0.06622253f, 0.05040633f, 0.19269708f, 
    0.04332814f, -0.01508299f, -0.24232581f, 0.04394460f, 0.18245682f, -0.01720295f, 0.09231440f, 0.10205954f, 
    -0.11387122f, 0.07799219f, -0.13149291f, 0.07120373f, -0.09426025f, -0.02834965f, -0.04101165f, -0.13112850f, 
    -0.03463669f, 0.01347356f, 0.02564614f, 0.02644861f, 0.13114174f, 0.02704482f, -0.01617341f, 0.13366872f, 
    -0.01156609f, 0.05360684f, 0.00312049f, 0.03761470f, 0.01633713f, -0.12238736f, -0.06251761f, 0.10168944f, 
    0.19686286f, -0.04410454f, 0.02327091f, 0.17489745f, 0.09295300f, 0.09508906f, 0.04122586f, 0.09631082f, 
    0.02743359f, 0.31392941f, 0.02339831f, -0.02002539f, 0.12380870f, 0.02074836f, -0.09507331f, 0.01760782f, 
    -0.04557624f, -0.06775616f, -0.05011941f, 0.02374421f, -0.19000089f, -0.30078691f, 0.19098055f, -0.23885027f, 
    0.02800294f, -0.07458623f, -0.03492660f, 0.04122222f, 0.01562429f, -0.02809916f, 0.09903852f, -0.06701780f, 
    0.09770282f, 0.13015382f, -0.00514803f, -0.16219418f, 0.11880587f, 0.02082508f, -0.04322572f, -0.11500628f, 
    -0.00424800f, 0.09004296f, -0.04772981f, -0.13859195f, -0.07708546f, 0.12011397f, -0.00987847f, 0.23953286f, 
    0.10925334f, 0.05432580f, -0.00875227f, -0.03771226f, -0.02873746f, 0.00483791f, 0.07914822f, -0.12476868f, 
    0.15524098f, -0.16404276f, 0.19325559f, 0.01130802f, -0.02377539f, -0.16103616f, -0.06410360f, 0.03330209f, 
    0.05461658f, 0.01373149f, 0.04137753f, 0.02154900f, 0.20242774f, 0.07471900f, 0.03239296f, -0.18505906f, 
    -0.02318371f, 0.05182258f, 0.08620798f, -0.01163186f, -0.02727160f, -0.14183234f, 0.07972590f, -0.00680978f, 
    0.06849681f, 0.22133562f, 0.16213320f, 0.15554671f, 0.07283936f, 0.11068441f, 0.02082198f, 0.19616297f, 
    0.00583492f, 0.09656850f, 0.06502731f, 0.08461285f, 0.11415668f, 0.03023212f, 0.09532524f, -0.08159637f, 
    0.05785527f, 0.11900845f, -0.04479082f, 0.21020916f, -0.05703333f, 0.00376459f, -0.05919498f, 0.03439492f, 
    -0.20504135f, -0.00601482f, 0.05777152f, 0.08121367f, 0.04521450f, 0.01295911f, -0.15766373f, -0.01083024f, 
    -0.10057598f, -0.01666574f, 0.00090793f, 0.02787165f, 0.01312579f, 0.19740087f, 0.20183940f, -0.13126875f, 
    0.02570483f, 0.01731170f, -0.09057036f, -0.02008608f, 0.02337519f, 0.05739056f, -0.01485354f, -0.01204479f, 
    -0.02581191f, 0.18422253f, -0.07875373f, 0.02960525f, -0.00631246f, -0.08551271f, 0.02203829f, -0.08557399f, 
    -0.10299786f, 0.00558537f, -0.03689165f, 0.06707304f, -0.30684823f, -0.03374758f, -0.06987593f, -0.02268608f, 
    -0.01449461f, -0.02600410f, 0.02698125f, -0.05543748f, 0.00543720f, 0.18503219f, 0.10046981f, 0.00013497f, 
    0.18307203f, 0.01885606f, 0.18188693f, 0.15334386f, 0.11430391f, -0.06671377f, -0.04557839f, 0.11686061f, 
    0.02819510f, -0.05366341f, -0.04403593f, -0.02182111f, -0.30809903f, -0.20229164f, 0.19455688f, -0.08384125f, 
    -0.09289126f, 0.00845049f, 0.01236202f, -0.07521749f, 0.06760683f, 0.05394715f, -0.03427732f, -0.04875498f, 
    0.13853955f, -0.08862520f, 0.07226770f, -0.03105396f, 0.06577004f, 0.03191928f, -0.06022215f, 0.02273572f, 
    0.04406227f, 0.01953436f, -0.04115755f, 0.06786422f, -0.11552764f, 0.29214436f, -0.04407331f, 0.18643728f, 
    0.12360451f, -0.00348366f, 0.00765647f, 0.02702864f, 0.02593298f, 0.00858465f, -0.01458902f, 0.06516252f, 
    0.03143207f, -0.04440374f, 0.01759068f, -0.10771202f, -0.04613683f, -0.10436097f, 0.01487134f, -0.08139443f, 
    -0.06279755f, -0.03343382f, -0.01575950f, 0.06405595f, 0.13675988f, -0.02365073f, 0.07265367f, -0.05661067f, 
    0.03029088f, 0.04708811f, 0.02110945f, -0.03529500f, -0.00667690f, 0.02452841f, 0.01594611f, -0.03395240f, 
    -0.06727707f, 0.04362296f, -0.00469501f, -0.23802070f, 0.01058370f, -0.09451541f, -0.01274934f, -0.14014010f, 
    -0.01949761f, 0.09143605f, 0.03804342f, -0.04811410f, 0.10119686f, 0.01373336f, 0.14152378f, -0.01779200f, 
    -0.01174994f, 0.02810634f, -0.02138572f, -0.06318790f, 0.09463824f, -0.00408830f, 0.01277391f, -0.03636951f, 
    0.27115479f, -0.21204850f, -0.10449596f, -0.04181888f, -0.06285974f, -0.06382069f, -0.11328834f, -0.10047792f, 
    -0.03598382f, 0.14703512f, -0.00583042f, 0.09459877f, -0.10265329f, 0.01992014f, -0.18751904f, 0.03684114f, 
    -0.05642638f, -0.02138851f, 0.04790712f, -0.01347226f, -0.09797829f, -0.08335759f, 0.05572589f, -0.01673868f, 
    0.34968495f, 0.29770342f, 0.02814922f, 0.09730078f, 0.19122910f, 0.13671261f, 0.03791048f, 0.03906810f, 
    -0.01880139f, 0.09978797f, -0.02273123f, 0.01743745f, -0.01009215f, -0.20139812f, -0.05757956f, -0.15113313f, 
    -0.02905891f, 0.03423715f, -0.01359328f, -0.13281433f, -0.03184328f, -0.00724240f, -0.02993586f, 0.05357291f, 
    0.01410303f, 0.00500859f, 0.09033186f, 0.09464160f, 0.00933889f, 0.06770716f, -0.08614992f, -0.08736481f, 
    -0.09065373f, 0.05501164f, 0.14287739f, -0.00249452f, -0.37977087f, 0.06350450f, 0.10479727f, -0.29558358f, 
    0.02074358f, -0.08680787f, -0.09034401f, 0.04439417f, 0.00404379f, -0.02838778f, -0.09344493f, 0.02191004f, 
    -0.05430862f, 0.14248405f, -0.12741043f, 0.12841344f, 0.12327602f, -0.08168350f, -0.02054857f, -0.10336244f, 
    -0.01352741f, 0.10093883f, -0.03639394f, -0.05791829f, 0.51388216f, -0.04495422f, 0.06734162f, 0.15060996f, 
    -0.02977164f, 0.02340252f, -0.01175369f, 0.04653438f, -0.03419318f, 0.21276009f, -0.03024829f, 0.01302540f, 
    0.23303132f, 0.22900514f, 0.13846958f, 0.16976912f, 0.00792339f, 0.11147545f, -0.05351750f, 0.11593539f, 
    0.02609200f, -0.06214637f, -0.08392285f, -0.11705315f, 0.27971423f, -0.20526628f, 0.01457648f, -0.01750891f, 
    -0.12090817f, -0.01365066f, -0.00360585f, -0.10019586f, 0.12923658f, 0.02186282f, 0.15288050f, -0.10617973f, 
    0.03851494f, -0.00831590f, -0.13261662f, 0.00660492f, 0.07851956f, 0.01201676f, -0.10978731f, 0.05897009f, 
    0.05514719f, -0.06941827f, -0.09410340f, -0.05687232f, 0.21730001f, 0.05912303f, 0.08956385f, -0.06707919f, 
    0.09113315f, 0.06351257f, 0.02355180f, -0.03282108f, -0.00315713f, 0.06683116f, -0.03602278f, 0.06512258f, 
    -0.07772618f, 0.09445579f, 0.01541787f, 0.09486545f, -0.00733801f, -0.00184804f, -0.00151582f, -0.01868408f, 
    0.00407729f, 0.05505840f, -0.03098997f, 0.01435572f, 0.21919939f, -0.21022834f, 0.05194027f, -0.06184138f, 
    0.11414520f, 0.05818418f, 0.02252759f, 0.08345784f, -0.01761411f, 0.02103109f, 0.07173489f, -0.12489291f, 
    0.00034354f, -0.11725749f, -0.12598699f, -0.28944197f, 0.04573170f, -0.09873401f, 0.01825504f, -0.00190474f, 
    -0.02766606f, 0.16446504f, 0.02315622f, 0.00732110f, -0.26841006f, 0.06955653f, -0.04040162f, -0.05322101f, 
    -0.00253019f, 0.07621771f, 0.00472124f, 0.09128178f, -0.00697356f, -0.03123046f, 0.02835579f, 0.04166151f, 
    -0.02997201f, -0.03368421f, 0.18046294f, -0.00535919f, 0.04252584f, -0.18654190f, 0.00486068f, 0.13050044f, 
    -0.05089751f, -0.07756548f, -0.10906740f, 0.15342274f, 0.29209822f, 0.04378786f, 0.00978741f, 0.03949435f, 
    0.06931751f, 0.10589376f, -0.00464088f, 0.12355024f, 0.07962894f, -0.15379998f, -0.09969475f, 0.08127124f, 
    0.12988135f, 0.15254560f, 0.04066916f, 0.13840741f, -0.00157072f, 0.07632153f, 0.10369221f, -0.00952306f, 
    -0.02444368f, 0.14417192f, 0.02804156f, 0.09505843f, 0.03059080f, 0.07908978f, -0.01844120f, -0.14045133f, 
    -0.11095650f, 0.10361623f, -0.06355990f, 0.08020835f, 0.06551195f, 0.17991225f, 0.12872805f, 0.15439723f, 
    0.00924075f, 0.15754965f, 0.19737114f, -0.02884772f, -0.01490334f, -0.01201079f, -0.04061146f, 0.10016608f, 
    -0.06893969f, 0.01264030f, 0.08962578f, -0.15563634f, -0.04391109f, -0.00968494f, 0.07125349f, 0.11673565f, 
    0.08879948f, 0.09181094f, -0.11745319f, 0.04008758f, 0.17484841f, -0.03613751f, -0.07851748f, -0.03585250f, 
    -0.25956967f, 0.09974089f, -0.09610093f, -0.09251792f, 0.01376983f, -0.09857848f, 0.05165051f, -0.07698113f, 
    -0.03136317f, 0.02023043f, 0.00019302f, 0.02876131f, -0.13380621f, 0.10015185f, 0.03722443f, -0.08020626f, 
    0.11962453f, 0.02584103f, 0.06217175f, -0.09416207f, 0.06989036f, 0.21526088f, 0.00245344f, -0.00513801f, 
    0.07017732f, -0.02871419f, -0.05913171f, -0.03044395f, 0.06228958f, -0.05326408f, -0.04552475f, -0.04619674f, 
    0.06887402f, -0.07667180f, -0.05344724f, 0.03113815f, -0.14386983f, 0.16611923f, 0.16403364f, -0.01888467f, 
    0.05808504f, -0.00594811f, -0.05911516f, 0.07493590f, 0.11119911f, 0.13009675f, -0.14132242f, -0.14111282f, 
    0.13249090f, -0.06052763f, 0.16238038f, 0.18930660f, 0.03998698f, 0.12018473f, 0.03167970f, 0.15401796f, 
    0.02375847f, -0.00935415f, 0.02345688f, -0.07058947f, -0.22008616f, 0.02747066f, -0.11945931f, 0.10166701f, 
    -0.00439208f, 0.00053760f, 0.16159526f, 0.12000766f, 0.06158236f, 0.10354946f, 0.08654829f, 0.11302475f, 
    0.05203364f, -0.06852616f, -0.01501838f, -0.00322407f, -0.10651387f, 0.01858523f, -0.02410333f, 0.04055426f, 
    0.07577405f, -0.00615195f, 0.07487161f, 0.03057903f, 0.01345874f, 0.16929287f, -0.11962545f, -0.00925872f, 
    0.11141174f, -0.00915922f, 0.06398883f, -0.02062982f, 0.05466597f, 0.05581253f, -0.06761286f, 0.01052805f, 
    0.04555400f, -0.07207160f, 0.14984892f, -0.02759155f, 0.01764760f, 0.13639477f, 0.05524144f, -0.09708282f, 
    0.11406330f, 0.00761467f, 0.09801818f, -0.12465489f, 0.09865712f, 0.05891396f, 0.04060623f, 0.16728640f, 
    -0.02481591f, -0.00106224f, -0.07533085f, -0.12085999f, 0.05404715f, 0.15909046f, -0.03033928f, 0.03392658f, 
    0.12577154f, -0.29276913f, -0.24350356f, 0.05796911f, -0.03453959f, -0.01251163f, -0.04995965f, -0.01274187f, 
    0.12896404f, 0.05212654f, 0.01444080f, -0.04093868f, 0.01057026f, -0.04035133f, -0.08793153f, 0.03292213f, 
    0.04559166f, -0.02551425f, -0.04231845f, -0.07898718f, -0.01865982f, 0.16849561f, -0.04673151f, 0.08576261f, 
    0.10809797f, -0.02020687f, -0.00382860f, -0.27951941f, 0.11295516f, 0.02475750f, 0.04413412f, 0.08442608f, 
    0.09932939f, 0.04602663f, 0.07526558f, 0.01022940f, -0.14353187f, -0.15283474f, -0.06054630f, 0.01589412f, 
    0.11823983f, -0.09349834f, -0.07524752f, -0.06150583f, -0.02178138f, -0.19974911f, 0.05118549f, -0.13732207f, 
    0.27630296f, -0.14543951f, -0.11932440f, 0.02981018f, -0.03253733f, -0.02219105f, 0.15819934f, 0.12462673f, 
    0.17537794f, 0.08698926f, 0.08732547f, 0.17868249f, 0.08231667f, 0.17966026f, 0.13273187f, -0.28992832f, 
    -0.06011039f, -0.00068654f, -0.01561992f, 0.10589313f, 0.02196074f, 0.00400802f, 0.06159100f, 0.13881186f, 
    -0.00436213f, -0.14497007f, -0.07436246f, 0.14057589f, 0.06328733f, 0.12223148f, -0.00944773f, 0.11873484f, 
    0.06646528f, -0.11566888f, 0.06387310f, -0.04361489f, 0.32613817f, -0.01527946f, -0.10829167f, 0.12901244f, 
    -0.13421129f, 0.02835945f, -0.00058604f, 0.13935997f, 0.00545717f, -0.09199629f, -0.06882472f, 0.03650580f, 
    -0.01728380f, 0.02589329f, 0.07516041f, -0.13519868f, 0.03523484f, -0.00379809f, 0.05029839f, 0.09986569f, 
    -0.13156237f, -0.04849997f, 0.07138009f, 0.03419691f, -0.10686105f, -0.00944984f, -0.11547899f, 0.09745193f, 
    -0.01416436f, 0.05936996f, 0.02081214f, 0.05441443f, -0.08487437f, -0.05807341f, 0.23470573f, 0.08213180f, 
    -0.15953013f, 0.19510287f, -0.04988939f, 0.04624771f, 0.08742280f, -0.02810953f, -0.03869039f, -0.07325075f, 
    0.02782340f, 0.02851790f, -0.06733503f, -0.04745468f, 0.40623057f, -0.07886437f, 0.15560566f, -0.09713786f, 
    -0.00426280f, 0.01225962f, -0.08116396f, 0.00740169f, -0.03725724f, -0.02030190f, -0.02582247f, 0.00863259f, 
    0.07263443f, -0.13927169f, 0.25464323f, -0.18860064f, -0.05036207f, -0.03975527f, 0.00538028f, -0.03307194f, 
    0.08081923f, 0.10911429f, -0.04117718f, -0.16098014f, 0.08160669f, 0.09210378f, -0.10849420f, -0.04532485f, 
    -0.00265852f, 0.09020384f, 0.05518856f, -0.04845046f, -0.01963904f, -0.05421857f, 0.13739157f, -0.02535214f, 
    -0.18716919f, -0.06710663f, 0.08436130f, -0.09074173f, 0.00056569f, -0.01940079f, 0.01881134f, -0.05143828f, 
    -0.13358177f, -0.03031425f, 0.01274819f, -0.04878072f, 0.16792427f, -0.15373392f, -0.02152197f, 0.20898853f, 
    -0.00138910f, 0.03650159f, 0.07636170f, 0.10210907f, 0.12635112f, 0.00965673f, -0.02565074f, 0.02037277f, 
    0.00525888f, -0.05477118f, -0.13227835f, 0.02438709f, -0.03302830f, 0.10103644f, -0.00627342f, 0.11515460f, 
    0.05834463f, -0.02202577f, -0.19102621f, -0.09783046f, -0.16264418f, 0.07647800f, 0.07504298f, 0.00890997f, 
    0.07139731f, 0.03900403f, -0.12388318f, 0.03092194f, -0.07797673f, 0.14446950f, -0.03677008f, 0.17517050f, 
    0.04311901f, -0.01303342f, -0.04882707f, -0.07078297f, -0.01513044f, -0.07404424f, 0.17693931f, -0.15165229f, 
    0.06754511f, 0.00982191f, -0.05821946f, 0.02427322f, -0.06298257f, 0.07792880f, -0.03986127f, -0.10663006f, 
    -0.11773583f, 0.05255555f, -0.00831788f, 0.04183197f, 0.03666247f, -0.06962604f, 0.01851552f, -0.06763465f, 
    0.35557744f, -0.10773518f, -0.06325652f, -0.08223145f, -0.06054172f, 0.04888847f, -0.13259527f, 0.12393712f, 
    0.07978738f, -0.00795619f, -0.00194494f, -0.02975697f, 0.05479041f, -0.29775745f, 0.00785144f, -0.18034011f, 
    -0.08554357f, 0.04309610f, -0.01010949f, 0.00706210f, -0.05410453f, 0.02964318f, -0.01045656f, 0.05960005f, 
    -0.19978094f, -0.10141075f, -0.01008158f, 0.18355651f, 0.12021010f, 0.00522816f, -0.01963195f, 0.02562523f, 
    0.04246795f, -0.03918022f, 0.13806880f, -0.03604662f, 0.44822457f, 0.02250272f, 0.03470252f, 0.22219139f, 
    -0.03834000f, 0.08705474f, 0.12217663f, -0.07120474f, -0.06336401f, -0.09496546f, 0.07625093f, -0.04578894f, 
    0.24582808f, 0.28794792f, -0.01131472f, -0.03287979f, -0.07915214f, -0.03890736f, 0.08684475f, 0.23997481f, 
    -0.04608352f, -0.04027532f, -0.09321631f, -0.05551713f, 0.15177591f, 0.03635189f, -0.07778959f, 0.10996532f, 
    0.05554245f, 0.07742316f, -0.10593069f, 0.06172777f, -0.12948784f, -0.08611664f, 0.16742648f, -0.00924863f, 
    -0.09395968f, -0.03493986f, -0.14991389f, 0.11847232f, 0.08547717f, 0.10147671f, 0.14879900f, -0.01281930f, 
    0.11598092f, -0.03716539f, -0.10749916f, -0.02695706f, 0.19165020f, -0.16938698f, 0.02600211f, 0.03790969f, 
    0.13699967f, -0.02153840f, 0.02475342f, 0.00962393f, -0.01155019f, -0.00576986f, -0.01699658f, -0.04379200f, 
    -0.04746304f, -0.00986556f, -0.02513946f, -0.05264485f, -0.00583027f, -0.06356373f, -0.05760964f, -0.03044112f, 
    -0.04824762f, -0.02643107f, -0.03669733f, -0.03418576f, 0.05331462f, -0.01973989f, 0.06557161f, -0.01759624f, 
    0.00273784f, -0.03547218f, -0.02786132f, -0.02424721f, 0.05308012f, 0.05116617f, -0.03415681f, -0.05613445f, 
    0.04489909f, 0.01459899f, -0.06563561f, 0.03307091f, 0.05238086f, -0.01282539f, -0.07227916f, -0.06483624f, 
    0.00690280f, -0.02220666f, 0.02083701f, 0.05400839f, -0.00762934f, 0.04827743f, -0.04532657f, -0.06925847f, 
    -0.05285767f, -0.07528687f, -0.05018269f, -0.06288220f, -0.03276573f, 0.06172577f, 0.03682021f, 0.00114600f, 
    0.02271934f, -0.00190066f, 0.05285333f, 0.04506071f, 0.03987839f, -0.00073770f, -0.06184894f, 0.03466094f, 
    -0.00840585f, -0.05744688f, -0.01923707f, 0.06226741f, -0.06969263f, -0.06006746f, -0.03528700f, 0.06504652f, 
    -0.06732806f, -0.00221665f, -0.04882492f, -0.06516676f, -0.00922267f, -0.06385483f, 0.02596843f, 0.00290296f, 
    0.04034927f, 0.02036725f, -0.01109243f, -0.03341127f, -0.03066797f, -0.08636675f, 0.03336356f, -0.04433983f, 
    0.04682450f, 0.05272639f, 0.03312661f, 0.06453025f, 0.00892338f, -0.04453113f, -0.04556702f, -0.00949495f, 
    0.02487717f, 0.04932954f, -0.03676719f, -0.02005829f, -0.07586582f, 0.03000257f, -0.03183892f, 0.04062198f, 
    -0.03942051f, 0.00202621f, -0.02999236f, -0.00440387f, 0.06027527f, -0.05624828f, 0.03220686f, -0.00800710f, 
    -0.07075632f, -0.07194648f, -0.06711583f, 0.03817537f, -0.04216050f, -0.06577729f, 0.01693537f, 0.05902057f, 
    -0.00746021f, 0.00783056f, -0.00705745f, 0.04892085f, -0.05606947f, -0.05558022f, -0.00611432f, 0.00627869f, 
    -0.01902037f, -0.03423316f, 0.01551349f, -0.01511678f, 0.05973694f, -0.05539032f, 0.01244023f, 0.05990200f, 
    -0.00432022f, 0.05922511f, 0.05650066f, 0.03069533f, -0.00570630f, -0.04330005f, -0.06597935f, 0.05932555f, 
    -0.04492905f, -0.03687274f, -0.06200091f, -0.00299583f, 0.00815731f, -0.00582761f, -0.05573681f, -0.05251590f, 
    -0.05057760f, 0.05293935f, -0.07489663f, -0.06839073f, 0.03861159f, -0.06064779f, 0.05656489f, 0.03911240f, 
    0.02984906f, -0.02144963f, -0.01159859f, 0.00358467f, -0.07877352f, -0.02806533f, -0.02114293f, -0.05923601f, 
    -0.00093828f, -0.00771990f, 0.03173299f, -0.07445797f, -0.02672935f, -0.05444263f, -0.00856361f, 0.05644323f, 
    -0.05594913f, 0.00820858f, 0.01055995f, 0.00150215f, 0.01304324f, -0.06430503f, -0.04098872f, -0.05171354f, 
    0.05128145f, 0.05533891f, 0.06013015f, 0.01680278f, 0.03610710f, 0.04470215f, 0.01986084f, -0.00563228f, 
    0.05217130f, -0.04970011f, 0.02251000f, 0.02352775f, 0.01037495f, 0.01501343f, -0.00991614f, 0.02383666f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00859786f, -0.07831238f, -0.00683486f, 0.06955438f, 0.09665840f, -0.03720431f, -0.13387172f, -0.03735026f, 
    -0.01266624f, -0.03506657f, 0.09933219f, -0.00830799f, 0.16218719f, -0.04438548f, 0.12458859f, 0.01453884f, 
    0.03005549f, -0.02044974f, 0.08761428f, 0.05264419f, 0.07515550f, 0.09498297f, 0.01968742f, -0.03165755f, 
    -0.07815086f, -0.03041061f, -0.09518375f, -0.04512103f, -0.04319100f, -0.07451142f, 0.04101925f, 0.10776735f, 
    0.03906962f, -0.04527758f, 0.05753755f, 0.02754035f, 0.05307183f, 0.01401921f, 0.04781200f, 0.03236991f, 
    0.03356683f, 0.03247394f, -0.03717837f, -0.02913937f, -0.00634696f, 0.15290137f, 0.04055189f, -0.01384537f, 
    0.06569956f, 0.02026253f, 0.00639294f, 0.01338530f, 0.00422130f, 0.02871908f, -0.03656527f, 0.04060321f, 
    0.02698394f, -0.01807136f, 0.04503362f, 0.05828020f, 0.05195390f, 0.00749020f, 0.01232086f, 0.01318019f, 
    0.11490600f, 0.06766324f, -0.01184580f, -0.04347819f, 0.10290582f, 0.01861436f, -0.05790680f, -0.02688165f, 
    -0.10496758f, -0.05926634f, -0.02041793f, 0.00306173f, 0.00107268f, 0.04468821f, 0.03340314f, 0.13876410f, 
    0.04990183f, -0.07345134f, 0.06473890f, -0.09305308f, 0.00406322f, -0.07672856f, 0.02623218f, -0.04040315f, 
    -0.00880824f, -0.00668407f, 0.00965506f, 0.00861979f, 0.04016948f, -0.03194971f, 0.06651393f, -0.01775823f, 
    -0.08201916f, -0.03435963f, 0.07522716f, -0.06610482f, 0.02249783f, 0.06126878f, -0.04547213f, -0.07082886f, 
    0.08938480f, -0.01613889f, 0.00296977f, 0.04307066f, 0.06683659f, -0.06069914f, -0.02883168f, -0.06794712f, 
    0.01365885f, 0.05732524f, -0.04091635f, 0.07097534f, -0.00299807f, 0.03865316f, 0.07549384f, -0.06162528f, 
    -0.09712369f, 0.10210235f, -0.02385318f, -0.04482915f, 0.04447657f, -0.04663078f, -0.03859756f, 0.02876153f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.12699808f, 0.12027781f, -0.17823111f, 0.25085801f, -0.41683540f, -0.14458753f, 0.17687097f, 0.02068639f, 
    -0.16557635f, 0.00471292f, -0.24982402f, -0.12277451f, -0.35381320f, 0.31910670f, -0.12443105f, 0.02706780f, 
    0.02385259f, -0.05188975f, 0.15857650f, -0.12582016f, -0.22217466f, -0.06308441f, 0.38655907f, -0.16209614f, 
    0.02113144f, 0.20864776f, -0.04497477f, 0.05846589f, -0.00876197f, 0.09026038f, 0.31608197f, -0.02348344f, 
    0.03893070f, -0.07515939f, -0.04379861f, -0.05968360f, -0.43374619f, 0.09054316f, -0.08377639f, -0.03689100f, 
    -0.01072785f, 0.02340407f, -0.05317497f, -0.01332418f, -0.04559017f, -0.13292354f, -0.01146470f, -0.02907372f, 
    0.06161102f, 0.00617827f, 0.07310952f, -0.33101323f, 0.05042259f, -0.17212440f, -0.08312061f, -0.44545740f, 
    -0.02366867f, -0.10221092f, -0.00600526f, 0.07633933f, 0.06892397f, 0.21120533f, 0.04195405f, -0.28756475f, 
    -0.12047380f, -0.44285569f, 0.00258686f, 0.12851593f, -0.32753402f, -0.31664488f, 0.03865305f, -0.17570703f, 
    0.06549484f, 0.19588923f, -0.22702655f, 0.12916453f, 0.30077165f, 0.06901679f, -0.01917620f, -0.35939834f, 
    0.11506961f, 0.16041689f, -0.09921304f, 0.03317975f, 0.05235727f, 0.01475911f, 0.16837782f, 0.13096042f, 
    0.06961843f, 0.08886655f, -0.02112876f, -0.52910900f, 0.19253270f, -0.08233225f, 0.28168818f, 0.04465820f, 
    0.04114725f, -0.04801051f, -0.04433523f, 0.08787456f, -0.45037708f, 0.03795874f, 0.07503015f, 0.26118374f, 
    0.03504981f, 0.05961329f, -0.05117479f, 0.27234763f, -0.28756675f, 0.04648833f, -0.21977493f, -0.08830048f, 
    -0.03341151f, -0.35929087f, 0.05141032f, -0.64348745f, -0.19429675f, -0.33339438f, -0.46704271f, 0.04526604f, 
    0.25659546f, 0.04079378f, -0.06580562f, 0.18326485f, -0.01335205f, 0.20138712f, 0.05658719f, 0.08409862f, 
    -0.53245652f, 0.05889904f, 0.03315714f, -0.02710098f, -0.17498296f, -0.36431164f, 0.08921617f, -0.04258273f, 
    0.02299887f, 0.05176555f, -0.31423667f, -0.44104445f, 0.39538005f, -0.59807009f, 0.13713579f, 0.01349277f, 
    -0.07949707f, -0.04396896f, 0.04021842f, 0.05424739f, 0.07489020f, 0.03102932f, -0.21419895f, -0.18935491f, 
    0.05285129f, 0.06493334f, -0.08921260f, -0.02279334f, 0.08702220f, 0.11413255f, 0.24245703f, -0.34381765f, 
    -0.06469444f, 0.07407891f, 0.07016241f, -0.01692091f, -0.20182951f, 0.13350762f, 0.07493653f, -0.35048333f, 
    -0.11671501f, 0.08327268f, 0.05418931f, 0.00284858f, 0.10475441f, -0.13017097f, -0.21888676f, 0.11818454f, 
    -0.01737464f, 0.03151369f, -0.18875203f, 0.62291569f, 0.06891432f, -0.05805090f, 0.10761486f, 0.19848555f, 
    -0.15842527f, 0.00136019f, 0.00858187f, 0.11673890f, -0.05234040f, 0.05121487f, 0.07874008f, 0.07132948f, 
    -0.31498197f, -0.08248977f, 0.00907256f, -0.03366297f, 0.24498126f, -0.37128404f, -0.05540461f, 0.13431460f, 
    0.10118099f, 0.05483843f, 0.20410192f, 0.06946208f, 0.00558864f, 0.02287292f, -0.03869663f, 0.15715438f, 
    0.14777440f, 0.23074272f, 0.19786674f, -0.19325808f, 0.23855688f, -0.02943451f, 0.05990767f, 0.23390222f, 
    -0.00100490f, -0.20886669f, 0.05923633f, -0.06111127f, 0.14301029f, -0.05695227f, -0.41725355f, 0.04981504f, 
    0.12682495f, 0.02478060f, 0.20391504f, -0.07565292f, -0.17940716f, 0.01113883f, 0.18999787f, -0.17963427f, 
    0.04408635f, 0.06192433f, -0.05442184f, 0.18057111f, -0.11987533f, -0.07023125f, 0.21535197f, -0.08755652f, 
    -0.27991170f, -0.00973827f, 0.00633199f, -0.05553821f, 0.03070809f, -0.04823558f, 0.23790129f, -0.06714544f, 
    0.09298760f, 0.06787769f, -0.10919979f, -0.06570777f, -0.26649320f, 0.20144022f, 0.19940084f, -0.04639051f, 
    0.17394300f, 0.22448027f, -0.08231754f, -0.20141324f, 0.17831777f, 0.31954339f, -0.07981819f, -0.08871448f, 
    -0.28987703f, -0.06691007f, 0.05996232f, -0.07940806f, -0.11125521f, -0.11332940f, -0.11882643f, -0.01108591f, 
    -0.02003055f, -0.02720644f, -0.21502796f, -0.06953996f, 0.06276073f, -0.10831009f, 0.19169049f, -0.04450087f, 
    0.00350457f, -0.19253251f, 0.12842573f, -0.06686827f, 0.20367528f, -0.32375869f, -0.21140668f, -0.05745367f, 
    0.02275943f, 0.02982454f, -0.00892260f, -0.03644984f, -0.04375529f, -0.16102763f, -0.45075226f, 0.18734004f, 
    -0.37271631f, -0.07793780f, -0.00447421f, -0.03854297f, 0.19250105f, -0.39017606f, 0.22319815f, 0.19427031f, 
    -0.44292819f, 0.01812375f, -0.16869292f, -0.42044061f, -0.04714096f, 0.22883782f, 0.14645424f, 0.07867762f, 
    -0.37114263f, -0.03004533f, 0.07467150f, 0.19460697f, -0.05736299f, -0.16444424f, 0.03506546f, 0.19102888f, 
    -0.19651331f, -0.15970811f, 0.03912107f, -0.16210578f, -0.12529831f, -0.25668380f, -0.01016308f, 0.12987077f, 
    0.21839340f, -0.46316367f, -0.12652543f, 0.22755188f, -0.26687375f, 0.04762581f, 0.04553265f, -0.38604888f, 
    -0.31187627f, 0.14547217f, 0.08949289f, 0.20017128f, -0.10835547f, 0.00781757f, -0.37536755f, 0.13683942f, 
    0.22067186f, -0.19616380f, -0.02562775f, 0.03249444f, -0.09276257f, 0.02768807f, -0.12595870f, -0.00545819f, 
    -0.10588617f, -0.08272863f, 0.20986721f, -0.01313228f, -0.15169382f, -0.03520729f, -0.27897134f, -0.39906493f, 
    0.04203638f, 0.03661595f, -0.05194188f, -0.04993239f, -0.26998633f, 0.03242043f, -0.10883755f, 0.04128620f, 
    0.26975822f, 0.22520988f, 0.00035300f, 0.02608485f, 0.20881903f, 0.18203415f, -0.12073748f, -0.04796624f, 
    -0.03286839f, 0.19009212f, -0.20697464f, 0.30822799f, -0.27199432f, 0.02557318f, 0.19600132f, -0.07184670f, 
    0.08326732f, -0.09795332f, -0.14992817f, 0.15929739f, 0.13663098f, 0.00720858f, -0.25183791f, -0.01853796f, 
    -0.03086560f, -0.01075331f, 0.05153719f, 0.03125163f, 0.19568169f, 0.02612913f, -0.24639137f, -0.05445036f, 
    0.06947641f, -0.03448863f, -0.06552276f, -0.28724012f, -0.50434983f, -0.07595398f, -0.25685662f, 0.31301019f, 
    0.06459959f, 0.21246098f, -0.18373026f, -0.07571112f, -0.11905222f, -0.28868178f, -0.00594626f, 0.07811000f, 
    0.06959958f, -0.02550848f, -0.04470564f, -0.00518874f, 0.11566544f, -0.66720706f, 0.05222082f, -0.11154726f, 
    0.04372295f, 0.07630317f, 0.00591682f, -0.05329581f, -0.51024562f, 0.03812566f, -0.33870494f, -0.36335218f, 
    0.28324616f, 0.09143700f, 0.15303957f, -0.29864433f, -0.06084920f, -0.07888146f, -0.33321014f, -0.60294884f, 
    0.07651751f, -0.03030362f, -0.04073506f, 0.16355789f, -0.02147148f, -0.28744227f, 0.02073480f, 0.04580705f, 
    0.11264988f, 0.13475603f, 0.03102774f, -0.25360849f, -0.28060165f, -0.22242840f, -0.00313762f, -0.06705095f, 
    -0.35757509f, 0.02647769f, 0.18835585f, -0.30598271f, 0.23170140f, 0.08328960f, -0.04715842f, 0.19511724f, 
    0.17233184f, -0.19135250f, 0.19750048f, 0.08679938f, 0.19522157f, -0.04660510f, 0.27089050f, 0.07818624f, 
    0.16142827f, 0.06871130f, 0.01948602f, 0.11015765f, -0.76701880f, 0.02063249f, -0.15416873f, 0.06728549f, 
    -0.18514584f, 0.04605008f, 0.00682241f, -0.02545899f, -0.03089069f, 0.05624881f, 0.00582875f, 0.13065167f, 
    0.26509836f, 0.03798269f, 0.05753817f, -0.40760663f, 0.16267808f, -0.01612092f, 0.00063653f, -0.07379378f, 
    0.08313389f, -0.05998376f, 0.07129680f, 0.25119218f, -0.39162660f, -0.30625015f, 0.13996904f, 0.04140066f, 
    0.15595163f, -0.00733229f, -0.16704293f, -0.17552195f, 0.09803509f, 0.00643663f, -0.06664403f, -0.01809957f, 
    -0.22200957f, 0.03407844f, -0.38777709f, -0.20932235f, 0.11089111f, 0.16164368f, -0.25187334f, -0.01548739f, 
    0.26499254f, 0.07257773f, 0.18127586f, -0.15221579f, -0.32559046f, 0.15827827f, -0.18848692f, 0.04650066f, 
    0.08441328f, -0.00634859f, -0.01296603f, -0.02455408f, -0.20033441f, -0.12327147f, -0.07932658f, 0.28074196f, 
    -0.04986662f, 0.15747985f, -0.15188204f, 0.09723572f, 0.20922357f, 0.75758356f, -0.42198649f, 0.15086928f, 
    -0.01180756f, -0.03984001f, -0.03511599f, 0.06667802f, -0.37762022f, 0.06156855f, 0.02455578f, -0.21684943f, 
    0.16097575f, -0.04793788f, -0.01589837f, -0.08854306f, 0.02484810f, 0.15683153f, 0.13057762f, -0.07247210f, 
    -0.07842131f, 0.06891354f, 0.12732434f, -0.50668538f, -0.22287725f, -0.30461100f, -0.12504019f, 0.23157643f, 
    -0.10165053f, -0.02195131f, -0.03092775f, 0.12361293f, 0.02906290f, -0.04783862f, 0.02913902f, -0.23885302f, 
    0.14358117f, -0.21581648f, 0.02382850f, -0.20113468f, 0.07840814f, 0.11439315f, 0.08145388f, 0.12704870f, 
    -0.36641607f, 0.09116533f, -0.24824406f, 0.26209533f, -0.09418222f, 0.04485409f, -0.02181538f, 0.09416693f, 
    0.19550723f, -0.00106249f, 0.14990878f, 0.23987591f, -0.03322482f, 0.04247303f, -0.19604875f, -0.02199427f, 
    -0.02155866f, 0.26141280f, 0.00245673f, 0.01912134f, 0.14170603f, 0.04469197f, 0.12866221f, 0.07178413f, 
    0.11096554f, -0.07431754f, -0.24489176f, -0.03783989f, 0.15662563f, 0.00276722f, -0.21191446f, 0.08118153f, 
    0.05398557f, -0.00614113f, 0.02965488f, -0.07126567f, 0.15967478f, 0.00865570f, 0.29380238f, 0.00035011f, 
    0.11526984f, 0.03562312f, 0.06221260f, -0.04115093f, 0.03681795f, -0.12089857f, -0.14769483f, -0.05123510f, 
    0.09084728f, 0.05931621f, 0.10231926f, -0.35432637f, 0.01082392f, -0.30027738f, -0.00106578f, 0.00938673f, 
    -0.19050561f, -0.31470159f, 0.18020289f, 0.13928066f, -0.11488835f, -0.08328845f, 0.24120361f, 0.04707268f, 
    0.33812472f, 0.00396317f, 0.09028990f, 0.31963784f, -0.44269729f, 0.11379137f, -0.18858838f, 0.08039390f, 
    -0.01256820f, 0.02569605f, 0.01781241f, 0.23994799f, 0.23354191f, 0.16941433f, 0.21001588f, 0.08651239f, 
    -0.01735940f, 0.11083107f, 0.11858156f, 0.02519943f, -0.00100244f, -0.36612183f, 0.01247379f, -0.16829988f, 
    -0.06364886f, -0.04188377f, 0.05018670f, 0.00060263f, -0.08453236f, 0.23946278f, -0.02640282f, -0.01467070f, 
    0.22873214f, -0.00246080f, -0.02853584f, 0.08009348f, 0.03848809f, 0.05332128f, -0.29549679f, -0.14975952f, 
    -0.03007595f, 0.07238788f, 0.03557551f, 0.15238562f, 0.16380304f, -0.04832177f, 0.02484185f, 0.15171942f, 
    0.12896122f, -0.06240976f, -0.02391473f, -0.45935789f, 0.06588197f, 0.28137094f, -0.02654265f, -0.15077327f, 
    0.00691067f, -0.06682308f, 0.03479792f, -0.08480842f, -0.53307766f, 0.20648003f, 0.00126217f, -0.00212779f, 
    -0.10888856f, 0.29333061f, 0.15412779f, 0.02436484f, -0.02303036f, -0.07621393f, 0.02362069f, 0.10781451f, 
    -0.06805208f, -0.10793258f, -0.07553264f, 0.01392780f, -0.07376705f, -0.07856769f, -0.23891509f, -0.49702787f, 
    0.10532846f, -0.18667115f, -0.00772808f, -0.27288097f, 0.05187954f, 0.02720251f, 0.04623575f, -0.07204489f, 
    -0.27081242f, 0.01953498f, -0.07295509f, 0.02949185f, 0.22487994f, 0.00887961f, 0.02273755f, -0.07290877f, 
    -0.38076332f, 0.01130388f, 0.03980963f, -0.04603559f, 0.15800039f, 0.05364961f, -0.26108161f, 0.05965889f, 
    -0.61514956f, -0.08076663f, -0.00748308f, 0.14605272f, -0.05910090f, 0.11967902f, -0.00686404f, -0.07496014f, 
    0.10931782f, -0.14908482f, -0.16321667f, -0.15851840f, -0.08301727f, -0.05110886f, -0.35945746f, -0.06958121f, 
    0.29883766f, -0.32189611f, -0.15173924f, -0.16076954f, 0.07163510f, -0.01567062f, -0.07698753f, -0.03626244f, 
    -0.02339924f, -0.07741815f, 0.08602150f, 0.12526181f, 0.12612861f, -0.01110963f, 0.14306353f, -0.00037902f, 
    0.05694078f, 0.00573794f, 0.00043811f, -0.14539602f, 0.23371559f, 0.04465924f, -0.27596393f, -0.02367249f, 
    0.00179836f, -0.00898375f, -0.61008471f, 0.06954643f, -0.10875925f, -0.26900479f, 0.15133886f, 0.11005217f, 
    0.07844850f, 0.07745383f, 0.07015475f, -0.02569232f, 0.25733441f, -0.41878805f, 0.16209012f, 0.20213522f, 
    0.12831195f, -0.04414799f, 0.06863859f, -0.02886517f, -0.19159588f, 0.21495751f, -0.06769097f, -0.10598615f, 
    0.15294881f, 0.05535173f, -0.33640364f, -0.01871469f, 0.25414079f, 0.27597016f, -0.06035220f, -0.17501990f, 
    -0.30669734f, -0.00767185f, -0.03905937f, -0.07629944f, 0.06115875f, -0.29632691f, -0.01674731f, -0.41564342f, 
    0.03690521f, 0.28066733f, -0.04768477f, 0.14403990f, 0.25559133f, 0.19158186f, 0.06201728f, 0.18917662f, 
    0.16414416f, -0.32832968f, 0.22977076f, 0.13470952f, -0.54408234f, -0.01902068f, 0.06810604f, -0.80379778f, 
    -0.05552670f, -0.19208282f, -0.29619020f, 0.15988739f, 0.07805724f, 0.06405120f, 0.17768563f, -0.15587145f, 
    0.01470680f, -0.22563547f, -0.04989880f, -0.10103747f, 0.06453065f, -0.07443488f, -0.33250058f, -0.06868555f, 
    0.18832250f, -0.09686014f, 0.04831037f, -0.02114115f, -0.07332329f, 0.02263710f, 0.09634478f, -0.26362395f, 
    -0.03433225f, -0.02956926f, -0.05318968f, 0.03425832f, -0.26198909f, -0.03449307f, 0.12376691f, -0.00007307f, 
    0.17415218f, 0.01008039f, 0.06767894f, -0.03035800f, 0.28107491f, 0.14735411f, -0.87920266f, -0.06579868f, 
    -0.03269817f, 0.12504984f, -0.16538882f, -0.23534308f, 0.00831753f, -0.10310176f, -0.04731191f, -0.07789440f, 
    0.36299795f, 0.04732818f, 0.14535919f, 0.09815000f, 0.02133395f, 0.20630994f, 0.23224020f, 0.07209957f, 
    -0.03789371f, -0.05068373f, -0.00724164f, 0.20681879f, 0.15776402f, 0.12873313f, -0.11912020f, -0.06213563f, 
    -0.06846798f, 0.06733977f, -0.36845285f, -0.20244111f, 0.30214775f, -0.24261807f, -0.27477738f, -0.12453000f, 
    0.08059827f, -0.34886837f, 0.27234969f, 0.02897150f, 0.00539122f, 0.28457868f, -0.14287479f, -0.24215624f, 
    0.00601855f, -0.03400377f, 0.00293716f, -0.00092702f, 0.05781041f, -0.15288363f, -0.13455090f, 0.02639534f, 
    -0.15056835f, -0.04783510f, 0.04144382f, -0.00150788f, -0.15776633f, -0.14183573f, 0.18563038f, 0.00453122f, 
    0.04315846f, -0.07109134f, 0.13927720f, -0.05131476f, -0.25638065f, -0.17422375f, -0.10402192f, 0.01721342f, 
    0.21645063f, 0.03264701f, -0.04950449f, -0.25451916f, -0.03298053f, -0.13067156f, 0.05861922f, -0.07232764f, 
    0.12911879f, -0.13326152f, 0.02860861f, -0.01703536f, 0.11055232f, 0.09360018f, -0.07394581f, -0.05616610f, 
    0.13880163f, 0.13330972f, -0.00695491f, -0.37509817f, 0.01987530f, -0.01479757f, 0.01937510f, 0.05787345f, 
    -0.07108390f, 0.14906158f, -0.30960533f, 0.08420674f, 0.00606491f, 0.05845300f, -0.10919819f, -0.10738224f, 
    -0.39991072f, 0.05475559f, 0.06500910f, 0.10700845f, -0.44677401f, -0.02238873f, -0.02683890f, -0.07394215f, 
    0.17032582f, 0.00717548f, -0.21778402f, -0.04234184f, -0.21462965f, -0.02973557f, 0.08289240f, -0.03951174f, 
    -0.47012556f, -0.06884292f, -0.02677455f, -0.14047140f, 0.08355791f, -0.00319070f, 0.22024810f, 0.01714536f, 
    -0.11700193f, -0.06518560f, 0.00757311f, 0.02861993f, 0.00986151f, -0.23698483f, 0.18270455f, 0.06499420f, 
    -0.26921049f, -0.06672429f, 0.07706682f, 0.31097335f, 0.14960827f, -0.04264605f, 0.07043073f, -0.08214737f, 
    -0.31494051f, 0.10175009f, 0.03509053f, -0.23403177f, -0.05180220f, -0.09804927f, -0.07030600f, -0.04147916f, 
    0.05965587f, 0.04179058f, -0.21956421f, 0.02007608f, -0.16924043f, -0.39555106f, 0.13095586f, 0.01511031f, 
    0.01988845f, -0.03094230f, -0.17663157f, 0.13905273f, -0.15398231f, -0.19653551f, -0.33410454f, 0.15230781f, 
    0.05994352f, -0.21234116f, -0.01335015f, 0.00552900f, 0.13932772f, -0.25990397f, -0.29448527f, 0.23063463f, 
    -0.03511991f, 0.06092539f, 0.02871682f, 0.02335351f, 0.15360048f, 0.20444104f, -0.13647035f, -0.31688130f, 
    -0.28076965f, -0.06797498f, 0.04511175f, 0.07164969f, 0.10543406f, -0.26175344f, -0.13113010f, 0.05844448f, 
    -0.34106395f, -0.05331213f, 0.07873952f, -0.18497680f, -0.20128813f, 0.12916172f, 0.16430542f, 0.40941271f, 
    -0.07680922f, -0.07131235f, -0.08410044f, 0.01418158f, 0.01173351f, 0.00782473f, 0.02091962f, 0.00501597f, 
    -0.04517368f, 0.20602229f, 0.03932623f, 0.30477029f, -0.20290118f, -0.11567337f, 0.00281364f, 0.20143497f, 
    0.11106966f, 0.15222690f, 0.18087484f, -0.50978869f, -0.33271608f, -0.02117223f, -0.05133489f, -0.04452832f, 
    -0.23887523f, 0.19028260f, -0.28252050f, -0.18242738f, 0.00520505f, 0.08207256f, 0.12205332f, -0.08570276f, 
    -0.09523743f, -0.35971466f, -0.03628207f, 0.21942368f, -0.07213978f, -0.03394397f, 0.08211450f, -0.05349636f, 
    0.09843485f, 0.02250105f, 0.11507680f, 0.01123782f, 0.20239709f, 0.07142068f, -0.07608570f, 0.26154283f, 
    0.21245004f, -0.02372306f, 0.03586830f, -0.40220919f, 0.27012950f, 0.05630983f, -0.31487903f, -0.04633476f, 
    0.01759350f, 0.18766031f, 0.04355843f, -0.10776438f, -0.06103047f, 0.05789991f, -0.20233074f, 0.06589635f, 
    -0.05348271f, -0.48425469f, 0.13022313f, -0.02505526f, -0.15158276f, 0.11323429f, -0.22232677f, -0.01578624f, 
    -0.10757621f, -0.13596834f, 0.16772734f, -0.10773066f, 0.22724697f, -0.28053799f, 0.14506739f, 0.07727084f, 
    0.06982863f, 0.03629599f, 0.14043859f, 0.12903357f, 0.00134853f, -0.20508675f, 0.07102094f, 0.03049528f, 
    0.05261533f, -0.03114080f, 0.16761611f, 0.05297812f, 0.10119363f, 0.06328885f, -0.00272150f, 0.25192621f, 
    -0.05607837f, -0.08513739f, 0.28158638f, -0.00300357f, -0.43202657f, -0.31969196f, -0.48312813f, -0.03037793f, 
    0.08671306f, -0.02717697f, -0.07795193f, 0.06924178f, -0.01513582f, -0.21631661f, -0.29683375f, 0.25057933f, 
    0.11809968f, 0.04486402f, 0.00428570f, 0.00018972f, -0.14624684f, 0.06292772f, 0.24736792f, -0.22809072f, 
    0.13451511f, -0.03841617f, -0.21597525f, 0.02072072f, 0.09854201f, 0.02089412f, 0.16445538f, -0.17498922f, 
    0.20190372f, -0.03819868f, 0.05616687f, -0.09215821f, -0.01879511f, 0.11416849f, 0.05569502f, 0.33620772f, 
    -0.05488715f, -0.15729441f, -0.05886311f, -0.06158342f, 0.11209311f, 0.11252137f, -0.04676075f, -0.25543526f, 
    -0.08699162f, -0.30477279f, -0.35230559f, -0.19980004f, 0.12566614f, 0.04615321f, 0.06433523f, -0.25351489f, 
    -0.45964471f, -0.07605018f, -0.01267211f, 0.05073159f, -0.78059453f, -0.04547419f, 0.05604247f, 0.27610555f, 
    -0.40281239f, 0.05782202f, -0.04102617f, 0.34633934f, 0.00227878f, -0.03347715f, 0.23287170f, 0.07780883f, 
    0.23649710f, 0.01936007f, -0.21920076f, 0.04372503f, -0.10098041f, 0.00268997f, -0.45595065f, 0.18524592f, 
    -0.13959357f, 0.04438888f, -0.08143265f, 0.14375961f, -0.26186544f, -0.05217800f, -0.05668319f, -0.05747604f, 
    0.27261186f, -0.22671840f, 0.04211080f, -0.47593361f, 0.06784379f, -0.24701349f, 0.13144274f, -0.04127113f, 
    -0.14443126f, 0.12061778f, 0.36213079f, 0.05965295f, 0.17095964f, -0.02498268f, -0.07916000f, 0.04334514f, 
    0.07882606f, 0.21965395f, -0.06003308f, 0.24591839f, -0.02508476f, -0.08784520f, -0.35191780f, -0.08278675f, 
    -0.14601725f, 0.01745396f, 0.15042983f, -0.23875314f, 0.09366713f, -0.25217327f, 0.02893997f, 0.00173357f, 
    0.00743451f, -0.03374825f, -0.21020086f, -0.04408623f, 0.31896409f, 0.13755740f, -0.05313992f, -0.36774588f, 
    -0.05205342f, -0.10628224f, -0.18422113f, 0.06911619f, 0.22637554f, 0.35185745f, -0.13573499f, 0.00335152f, 
    0.05320673f, -0.04268509f, 0.01904800f, 0.00492212f, 0.33459631f, -0.17512988f, -0.33693057f, 0.17685297f, 
    -0.12164848f, -0.04693329f, -0.08459682f, 0.07233395f, -0.17689675f, 0.11785438f, -0.00426745f, 0.22354986f, 
    0.05193044f, -0.01412214f, 0.09142024f, -0.16388223f, -0.45010629f, 0.28826529f, -0.16048397f, 0.02984063f, 
    0.09852818f, 0.05324194f, 0.02229807f, 0.18056478f, 0.04451787f, 0.04976511f, 0.05891249f, 0.10379522f, 
    0.05654167f, -0.00210402f, 0.03558728f, -0.05756835f, 0.27208874f, -0.39859968f, -0.03794957f, -0.04588390f, 
    -0.49984589f, -0.08874550f, -0.02771124f, -0.38036445f, 0.11499260f, -0.04448678f, -0.03758803f, 0.17708410f, 
    -0.21180688f, -0.43218532f, 0.02892566f, -0.35476297f, -0.48728397f, -0.02267523f, -0.62592340f, -0.12614514f, 
    0.13219379f, -0.08266097f, -0.00373663f, -0.13109516f, -0.06289899f, -0.05898128f, 0.05266154f, 0.04499114f, 
    0.07080851f, -0.08391991f, 0.21623321f, 0.04640193f, 0.15519199f, -0.00812815f, 0.18416718f, -0.43466279f, 
    0.01897419f, -0.05770740f, -0.06188472f, 0.15451424f, 0.34199119f, -0.05256354f, -0.24084701f, -0.01463701f, 
    0.21063793f, 0.24884364f, 0.07307708f, 0.15979753f, -0.00121985f, -0.02490630f, -0.22947592f, -0.04870252f, 
    -0.65632045f, 0.05668937f, -0.38461584f, -0.10597112f, -0.03785548f, 0.18911041f, 0.24935746f, 0.07732680f, 
    -0.38044548f, -0.33746302f, 0.22796881f, -0.13066469f, -0.12988837f, 0.03625625f, -0.16373932f, 0.03506581f, 
    -0.30151302f, -0.08202119f, 0.14092858f, -0.20252500f, 0.05170337f, 0.22101098f, 0.26002896f, 0.07066377f, 
    0.04721554f, -0.08065071f, -0.11026178f, 0.06471378f, -0.23296924f, 0.22694467f, -0.08875425f, -0.37799296f, 
    0.00862499f, -0.03947802f, 0.00079367f, -0.07563399f, -0.33474481f, -0.38885769f, 0.26434544f, 0.26061380f, 
    0.04040527f, -0.07166570f, 0.01672673f, -0.07081344f, -0.16904764f, -0.26387334f, 0.36143827f, 0.15184221f, 
    -0.31854311f, 0.05868523f, -0.00245010f, -0.04216278f, 0.15108512f, 0.12390860f, -0.11113624f, 0.26295686f, 
    -0.15453510f, -0.05753405f, -0.14527206f, -0.56088126f, 0.15608114f, 0.06070532f, 0.15353315f, -0.53570479f, 
    0.04947441f, 0.06406470f, -0.03173941f, 0.05245585f, -0.01641526f, -0.26542953f, -0.00255323f, -0.42752424f, 
    0.12742864f, 0.27643555f, -0.04626468f, 0.13766320f, -0.05311321f, 0.13071327f, -0.07275710f, -0.33889812f, 
    0.04467405f, 0.15625088f, -0.22654730f, -0.11168925f, -0.06355972f, 0.01940045f, -0.08598416f, 0.21116850f, 
    0.13951382f, -0.23310539f, 0.17382108f, -0.44853711f, -0.23860736f, -0.06458794f, 0.24539033f, -0.18434273f, 
    -0.05177332f, 0.15186578f, -0.00907778f, 0.02937553f, -0.18174450f, -0.05733793f, -0.08318251f, 0.01436833f, 
    -0.48267439f, -0.04744098f, 0.13484755f, 0.05137809f, -0.16851471f, -0.05420332f, -0.30161726f, -0.07219829f, 
    0.03134685f, -0.03564484f, -0.02215779f, -0.27567816f, -0.03171707f, -0.05059590f, -0.17145197f, -0.05665481f, 
    -0.26990479f, 0.08477823f, -0.07531516f, -0.13826846f, 0.18185608f, 0.29187813f, 0.23669529f, 0.03292125f, 
    -0.14948756f, 0.07629529f, -0.19528419f, -0.24003743f, 0.19367191f, -0.11313304f, 0.15128629f, -0.07608738f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.00575608f, -0.03238111f, 0.02933192f, 0.02663876f, 0.06996755f, -0.05693841f, 0.09041789f, -0.13842711f, 
    0.00989740f, 0.00424311f, 0.12899734f, 0.07398514f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
