#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.57211602f, 0.80086470f, 0.19904956f, -0.32764068f, -0.37812653f, 0.09168932f, 0.28115720f, 0.83979112f, 
    0.74988836f, 1.09180808f, -0.28927013f, -0.13387339f, 0.21615893f, -0.50859392f, -0.09561011f, -0.17657003f, 
    0.03866683f, -0.11923163f, -0.13820092f, 0.00876742f, -0.05384035f, -0.28094018f, 0.06074314f, 0.15301751f, 
    -0.25027275f, -1.59300315f, 1.41363704f, 0.64407241f, -0.68029010f, -0.27666390f, 0.47360644f, -0.96445882f, 
    -0.88953197f, -0.24059840f, -0.92243397f, -0.40114549f, 0.00443774f, -0.42584968f, 0.62400228f, -0.14042330f, 
    -0.36317125f, 0.02169547f, 0.08683006f, -0.26120335f, 0.05689039f, 0.12986523f, 0.14295399f, 0.20283481f, 
    0.12573345f, -0.12578332f, -0.76339936f, -1.03517532f, -0.23247941f, 0.78017449f, 0.86435813f, -1.57764244f, 
    -0.32857302f, 0.15568155f, -0.99966264f, 0.05376285f, 0.25553888f, 0.33622572f, 0.28846556f, 0.20416120f, 
    0.38516462f, 0.38932082f, 0.55715269f, 0.45072308f, 0.21818884f, 0.24632120f, 0.14210694f, -0.15969998f, 
    0.01188705f, 0.30465317f, -0.11899912f, -0.90191782f, 0.27791256f, -0.69163197f, -0.92050755f, -1.22765863f, 
    0.75876492f, -0.61991489f, -0.64700341f, -0.39563486f, 0.23154891f, 0.41532457f, -0.57368749f, 0.42284769f, 
    -0.16073209f, -0.27920482f, 0.25641668f, 0.36797938f, 0.59091938f, -0.12500955f, 0.22466184f, -0.19655986f, 
    -0.32670432f, -0.15108557f, -0.17208827f, 0.32875502f, 1.51902246f, 0.96771413f, 0.40621689f, 1.32710445f, 
    1.54584825f, 0.71741825f, 0.16226412f, -0.90447444f, 0.25610381f, -0.39581224f, 0.13002160f, 0.48244679f, 
    -0.08201203f, 0.55539662f, -0.23305841f, 0.30871063f, 0.14477450f, 0.68103945f, 0.19648045f, -0.16822717f, 
    0.39938617f, 0.26703483f, 0.16137354f, -0.11054710f, 0.35433367f, -0.17783098f, 1.22875535f, 0.90456814f, 
    1.11885417f, 0.31020436f, 0.88336885f, 0.53052175f, -0.03964227f, -0.03784265f, 0.73128581f, 0.09196281f, 
    -0.69969076f, -0.10198902f, -0.38906345f, -0.40603054f, -0.02513210f, -0.46947435f, -0.19325575f, -0.48556408f, 
    -0.50822246f, 0.16588047f, -0.09503697f, 0.25682384f, -0.04148450f, -0.16944048f, 1.03559601f, 0.31695396f, 
    0.74685192f, 1.22294009f, 1.28365946f, 0.17199183f, 0.63041073f, 0.55666351f, 0.03882431f, 0.56430155f, 
    -0.73154420f, 0.22115874f, 0.64573830f, 0.29528728f, 0.21809351f, -0.29423589f, -0.09012177f, 0.67466372f, 
    -0.10013585f, 0.01365597f, 0.23136197f, -0.26066267f, -0.06088575f, -0.08037450f, 0.17293866f, -0.75093716f, 
    -0.90049124f, -1.15850639f, -0.12557450f, -0.19470222f, 0.51699746f, 1.00385320f, 0.07898693f, 0.31445941f, 
    0.88610178f, 0.39060423f, -0.54357350f, -0.45180783f, -0.14875293f, 0.29748753f, 0.33950335f, 0.34878650f, 
    -0.27602410f, 0.41795820f, -0.01778374f, -0.34881201f, -0.11639806f, 0.05576488f, 0.02948756f, 0.15016411f, 
    -1.33618903f, 1.26532125f, -0.47352690f, -0.34384775f, 0.49991041f, -1.17151105f, 1.17325127f, 0.41802806f, 
    -0.67297727f, 0.12322246f, -0.20956774f, 0.13890888f, 0.30075195f, -0.69776303f, -0.03774334f, 0.14889558f, 
    -0.16662285f, -0.08362865f, -0.20308694f, -0.37189561f, 0.07377421f, 0.05914195f, 0.04723836f, -0.10294242f, 
    -0.33745593f, 0.66339529f, 0.17957988f, -1.36382031f, -1.24170446f, 0.79740214f, 0.95032221f, -0.69324845f, 
    0.12647785f, -0.39441511f, -0.10528228f, -0.08094263f, -0.11044531f, -0.48037216f, -0.04149875f, -0.31664509f, 
    -0.13156013f, -0.14492740f, 0.03736759f, 0.16870011f, 0.27654916f, 0.38629282f, -0.27248859f, 0.00027480f, 
    0.24587050f, -0.12520605f, 1.20699954f, -0.17118710f, -1.08025980f, 0.33313257f, -0.71357530f, -0.63662231f, 
    0.46961829f, 0.12413956f, 1.13587499f, -0.03174004f, -0.47655746f, 0.49695334f, -0.06528331f, -0.12286355f, 
    0.14193232f, 0.19234425f, -0.70595562f, -0.32309586f, 0.08569977f, 0.02120795f, -0.13129862f, -0.03922147f, 
    -0.18377973f, -0.00712333f, -0.07320375f, 1.49500155f, 1.35801888f, 1.13860726f, -0.21391837f, 0.29432482f, 
    -0.86235797f, -0.95352089f, -0.56844586f, -0.34503999f, -0.03849828f, -0.02385082f, 0.13861276f, 0.08844753f, 
    -0.04849347f, 0.03184015f, -0.28580928f, -0.02927483f, -0.09903920f, -0.08841973f, 0.31729528f, 0.27968401f, 
    0.40712297f, -0.15892762f, -0.02865723f, 0.48419330f, -0.63940609f, 0.36137787f, -1.19566727f, -0.96205568f, 
    -0.07025491f, -0.35883138f, -0.15173052f, 0.90589714f, 0.71014977f, 0.15568085f, -0.57910955f, -0.22438012f, 
    -0.08615716f, 0.44650486f, -0.51754123f, -0.14425492f, 0.09092502f, 0.32325438f, 0.00562082f, -0.16714936f, 
    -0.71482599f, 0.15983380f, -0.27142614f, -0.57242292f, 0.00509688f, -2.01934886f, 0.59672600f, 0.24799077f, 
    -0.50200379f, -1.14852524f, 0.59637666f, 0.84300655f, -0.01762148f, 0.46219221f, -0.19116221f, -0.35701519f, 
    0.02932006f, -0.12301554f, 0.14382440f, 0.31260157f, -0.07027840f, -0.21740499f, -0.13816009f, -0.14707768f, 
    -0.22678223f, 0.44573832f, 0.29711628f, 0.48509341f, 0.31628737f, 0.66098762f, -0.78796774f, -1.73957527f, 
    -1.11108923f, -0.24694267f, -0.49556652f, -0.15033861f, 1.00899327f, 0.60224950f, -0.20291129f, 0.55759370f, 
    -0.27279800f, 0.14663605f, 0.28863519f, 0.27950805f, -0.34758741f, -0.41555321f, -0.13452396f, 0.02962389f, 
    -0.07636435f, -0.18021616f, 0.15752524f, -0.04334233f, 0.00214602f, -0.18505502f, 0.02637023f, 1.56672299f, 
    1.30746460f, -0.54722226f, -0.94695395f, -0.98129690f, 0.18543290f, 0.44367495f, -0.47504878f, -0.36923623f, 
    -0.01582504f, 0.19660380f, 0.31324360f, 0.39392996f, 0.60632753f, -0.03209461f, 0.12982188f, 0.30336571f, 
    0.27804217f, 0.27890024f, 0.08622154f, -0.07812950f, 0.14059082f, 0.53955406f, -0.12162499f, 0.31795356f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28611198f, 0.35192668f, 0.53109443f, 0.32453322f, 0.24762240f, 0.29532334f, 0.56635082f, 0.08576311f, 
    0.19266132f, 0.41355750f, 0.04282370f, 0.39610302f, 0.42594591f, -0.00755315f, 0.27076951f, 0.59334970f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.12796755f, -0.10392138f, -0.25388798f, -0.14291653f, 0.03463650f, -0.11104198f, -0.30143243f, 0.04313174f, 
    -0.10676112f, 0.01098269f, -0.00442907f, 0.05559037f, -0.88447702f, 0.52748501f, -0.02316713f, 0.19624430f, 
    0.08737244f, 0.04704217f, 0.03389577f, -0.07621811f, 0.00985554f, -0.23213777f, 0.06550346f, 0.08003718f, 
    -0.32023022f, -0.14124678f, -0.34494224f, 0.27315682f, 0.06660025f, -0.09438110f, -0.30355951f, -0.06462976f, 
    -0.09082741f, -0.15757327f, 0.02104692f, 0.16318861f, 0.52229077f, -0.35317585f, -0.00568190f, -0.26192340f, 
    0.00435427f, 0.05352434f, 0.01402777f, 0.16823900f, -0.03111943f, 0.16269231f, -0.06738715f, -0.04067362f, 
    0.06874748f, -0.06938381f, -0.00463665f, 0.35535768f, -0.33302918f, -0.13769539f, 0.05400010f, 0.10088440f, 
    -0.07583834f, 0.16905203f, -0.03282988f, -0.12792344f, 0.30390269f, 0.16504090f, 0.23084290f, 0.26093104f, 
    -0.21471103f, 0.02624626f, 0.11596838f, -0.14180502f, 0.00301745f, -0.00938291f, -0.13378789f, -0.16959734f, 
    0.11601566f, -0.17743796f, -0.29741639f, 0.29387024f, -0.12170443f, -0.13730864f, 0.15235095f, 0.04143445f, 
    -0.08852597f, 0.07143684f, -0.17588668f, 0.02088245f, 0.34854791f, 0.18072970f, 0.35878429f, -0.19227749f, 
    0.13101611f, 0.18042473f, 0.01836403f, -0.17515698f, -0.09823573f, 0.05483080f, -0.03330386f, 0.04253637f, 
    -0.01408867f, 0.22616504f, 0.28423861f, -0.15190722f, 0.01069629f, -0.21727897f, 0.00398256f, -0.13346142f, 
    0.03573097f, -0.00659892f, -0.07502525f, 0.07844473f, 0.19863567f, -0.43744928f, 0.62168062f, -0.49213627f, 
    -0.27021274f, 0.00657406f, 0.22168629f, 0.00897512f, -0.04339774f, -0.06470439f, -0.17164896f, -0.03778565f, 
    -0.03360911f, -0.16003081f, -0.27600020f, -0.06968049f, 0.12650079f, -0.26745510f, -0.04240977f, 0.04694192f, 
    0.07764024f, 0.14567451f, 0.16305479f, 0.08052028f, 0.30851358f, 0.18097968f, 0.18813355f, -0.34693855f, 
    -0.23192905f, -0.16203937f, -0.00576109f, 0.15210673f, 0.04188073f, -0.21708347f, -0.20050977f, 0.05758270f, 
    0.07400088f, 0.21050121f, 0.01664347f, -0.56022537f, 0.09795364f, -0.04488752f, 0.04273854f, -0.00848761f, 
    -0.09607806f, 0.06627953f, -0.15402701f, -0.09385066f, 0.73575509f, 0.17455798f, 0.31509915f, -0.25460064f, 
    0.02878038f, 0.17390987f, -0.11385117f, 0.10848303f, 0.16637391f, -0.13830483f, -0.03089884f, 0.03693994f, 
    -0.59978646f, -0.11055697f, -0.25759560f, -0.30044183f, -0.01380008f, -0.11451147f, -0.02814810f, 0.12905215f, 
    -0.08210339f, 0.07254564f, 0.01947401f, 0.22657761f, -0.29374623f, 0.38791177f, 0.32379371f, -0.48386070f, 
    -0.22702852f, 0.05094807f, 0.08855172f, 0.10062224f, -0.08887304f, -0.11842381f, -0.06226061f, 0.05399583f, 
    0.38428575f, 0.01450678f, 0.26717684f, 0.00363867f, -0.02939473f, -0.34899786f, -0.05466809f, 0.09856466f, 
    0.20887895f, 0.13095111f, -0.12720060f, -0.12104572f, -0.16237167f, -0.21565659f, -0.32878119f, -0.11751308f, 
    -0.23344746f, 0.09904768f, 0.03104954f, -0.07333740f, -0.03169207f, 0.15193070f, -0.09805916f, -0.20162857f, 
    -0.01530011f, -0.01010150f, 0.04540249f, -0.02439814f, -0.15073381f, 0.15337916f, -0.13327886f, 0.06881508f, 
    -0.13345110f, 0.11865871f, 0.28234497f, 0.15893273f, -0.31050360f, -0.15799175f, 0.17280550f, -0.08439875f, 
    0.00695228f, 0.10413291f, 0.32547444f, 0.02956807f, 0.01948639f, -0.06801626f, -0.04610558f, -0.08657170f, 
    0.23269480f, -0.40902644f, 0.45614457f, 0.27524137f, -0.21560876f, -0.06132851f, -0.19084907f, 0.05013478f, 
    0.09661605f, -0.05286656f, 0.02795074f, 0.10520324f, 0.25783232f, 0.02231559f, 0.23744196f, 0.23746757f, 
    0.07026339f, 0.07421438f, 0.02216988f, 0.07734208f, -0.21455821f, -0.07361376f, 0.12988754f, 0.05211231f, 
    0.52708751f, 0.19918841f, -0.00744550f, 0.35904723f, -0.12804642f, 0.02685509f, -0.01529172f, 0.10404510f, 
    0.18676481f, 0.01177410f, 0.15250613f, -0.12601028f, 0.12572891f, -0.16846314f, -0.37647486f, -0.19010389f, 
    0.00063205f, 0.05394408f, -0.07627250f, -0.13939115f, 0.21462227f, 0.08626751f, -0.09492443f, 0.04730014f, 
    0.19303855f, 0.19328035f, -0.22916791f, -0.65887141f, 0.03252744f, 0.12391133f, -0.06514593f, 0.01654943f, 
    0.10413388f, -0.19464099f, -0.02561140f, -0.00274798f, 0.13743353f, -0.46909490f, 0.12531979f, -0.88108224f, 
    -0.10910138f, -0.17077957f, 0.09389672f, 0.05193780f, -0.11069317f, -0.03065670f, -0.12047226f, 0.02018702f, 
    0.55596972f, -0.46556678f, 0.06431818f, -0.27171332f, 0.02341180f, -0.05476351f, -0.14341757f, 0.07631134f, 
    -0.28060994f, -0.03636808f, -0.31417686f, 0.24557108f, 0.23517874f, -0.09182401f, -0.03020340f, -0.04020631f, 
    0.02899129f, -0.04898049f, 0.11229936f, 0.06012522f, -0.02493582f, 0.03267151f, -0.03721921f, 0.05362633f, 
    -0.43183684f, -0.06069142f, -0.02618790f, -0.50569814f, 0.00563623f, -0.09115510f, -0.24010672f, 0.10911006f, 
    0.03216802f, -0.04726145f, 0.24261658f, -0.16750707f, -1.14543390f, 0.01353479f, -0.33560476f, -0.19267702f, 
    0.07875623f, -0.20857635f, -0.04001245f, 0.09149805f, 0.28875813f, -0.04845206f, -0.18230276f, -0.05645093f, 
    0.54840529f, -0.14421237f, 0.01091367f, 0.08411990f, -0.08532009f, -0.13668028f, 0.14605251f, -0.02849692f, 
    0.01940702f, -0.17794868f, -0.02222018f, 0.07756232f, 0.62114626f, -0.05728669f, 0.16557558f, -0.41688395f, 
    -0.06737613f, -0.13550372f, 0.04549638f, -0.01394540f, -0.13421382f, 0.01896440f, 0.22476736f, 0.08475340f, 
    0.03139833f, 0.19216928f, -0.04467382f, -0.03164764f, -0.20663851f, -0.24750401f, 0.29694706f, 0.12311410f, 
    -0.37742788f, -0.07143076f, 0.07560466f, -0.10654554f, 0.13773553f, 0.22789824f, -0.56984907f, -0.62295413f, 
    0.06325001f, 0.19955695f, -0.03527052f, -0.12181348f, -0.01854782f, -0.01870497f, -0.18015197f, -0.05551483f, 
    0.99754471f, -0.54038990f, -0.23068185f, -0.07592699f, -0.10780454f, 0.06195147f, -0.11365619f, -0.10598452f, 
    -0.14918837f, -0.15532781f, -0.01196131f, -0.19778034f, -0.45282862f, -0.11128610f, 0.10751327f, -0.23508321f, 
    0.28119323f, -0.17856331f, -0.12118795f, 0.03393125f, -0.04995591f, -0.11496444f, 0.02926336f, -0.16043022f, 
    0.38792706f, -0.31148443f, -0.06244653f, 0.04876079f, 0.18305483f, -0.02893000f, 0.01548190f, -0.12429606f, 
    -0.07078428f, -0.11852968f, 0.05089825f, -0.06827588f, 0.28000790f, -0.08582569f, -0.00343555f, -0.16827592f, 
    0.04248205f, 0.08836455f, 0.02088830f, -0.06854434f, 0.08117178f, 0.36927205f, 0.14600432f, -0.12387156f, 
    -0.09534134f, -0.03593373f, 0.06797072f, 0.04311627f, 0.05119373f, 0.06038031f, 0.08604858f, -0.13151424f, 
    -0.01570429f, 0.05507436f, -0.05018469f, 0.14205380f, 0.42643681f, 0.14676850f, 0.37404206f, 0.16458966f, 
    -0.27689224f, 0.07534015f, -0.14433154f, 0.26653114f, -0.07220776f, -0.09714729f, 0.14456826f, 0.07507155f, 
    0.37658691f, -0.23683794f, -0.43835872f, -0.14370069f, 0.21299811f, 0.24640748f, -0.07684321f, -0.29877326f, 
    0.03231879f, -0.05363810f, 0.23936628f, -0.00883617f, -0.58034521f, -0.18958661f, -0.00158467f, -0.18384588f, 
    -0.08023152f, -0.04053848f, 0.04817640f, -0.17867981f, -0.11921453f, -0.21521465f, -0.13576852f, -0.00665863f, 
    0.09653044f, 0.16980779f, 0.00273155f, 0.23163392f, -0.13754480f, -0.07556501f, 0.09852809f, 0.24353084f, 
    0.04000571f, 0.10804036f, 0.13253051f, -0.17248060f, -0.52627295f, 0.19024779f, -0.09268918f, -0.19459988f, 
    0.28187540f, 0.02281503f, 0.03630983f, -0.09663754f, -0.02623385f, -0.00679562f, 0.05720446f, 0.00377354f, 
    -0.21842737f, 0.38756260f, -0.29926586f, 0.33880657f, -0.14496137f, 0.04938015f, 0.02818698f, 0.02544746f, 
    -0.17806068f, 0.03433171f, -0.29659745f, -0.10087383f, 0.71874696f, 0.08504247f, -0.02948012f, -0.02930653f, 
    0.03384956f, -0.08198298f, -0.19468212f, 0.03674520f, -0.04169605f, -0.06774776f, 0.09918452f, -0.05366073f, 
    0.57952052f, 0.02257632f, 0.06877720f, 0.34310672f, -0.46704051f, -0.22632146f, -0.09172869f, 0.01652298f, 
    0.09088314f, -0.00647878f, -0.17844339f, 0.00074797f, -0.21886910f, -0.01130163f, 0.03709918f, -0.47043854f, 
    -0.05093548f, -0.05806465f, 0.24521700f, -0.03228601f, -0.25124532f, 0.05922904f, -0.02996415f, -0.11185532f, 
    -0.68186694f, -0.15274875f, -0.37339076f, -0.23020196f, -0.00959374f, 0.07814810f, -0.15823682f, 0.04667684f, 
    -0.18404187f, 0.02589484f, -0.15702191f, 0.14155093f, 0.83486336f, 0.39285460f, 0.05861682f, 0.13286687f, 
    0.11160846f, 0.01191631f, 0.10240267f, 0.17060055f, 0.00491076f, -0.03644975f, 0.00628694f, -0.12309498f, 
    -0.20461299f, 0.17516340f, 0.43027169f, 0.28399748f, 0.15331374f, 0.06744356f, 0.09610441f, -0.19935143f, 
    -0.11517862f, -0.00219492f, -0.19300729f, -0.09867688f, 0.02671419f, 0.26846582f, -0.04277324f, -0.18622746f, 
    -0.15172580f, -0.16964144f, 0.03505439f, 0.09260137f, 0.04913074f, -0.16013235f, -0.00441957f, 0.27338341f, 
    0.16354264f, -0.47582424f, -0.16237798f, 0.36647537f, -0.07340806f, 0.07188153f, -0.09779956f, 0.00179254f, 
    -0.03768273f, -0.26131213f, -0.08007184f, 0.01577268f, -0.38380423f, -0.07840927f, -0.46680391f, -0.01924480f, 
    -0.15898608f, -0.18727696f, 0.02360961f, 0.06744611f, 0.13010624f, -0.04030678f, 0.07413062f, 0.06300490f, 
    -0.97614980f, -0.96289539f, -0.02583080f, -0.16428301f, -0.19383289f, -0.02884845f, 0.09120861f, -0.18397672f, 
    0.05521700f, -0.07166648f, -0.18748198f, 0.06053473f, -0.11994299f, 0.20861256f, -0.26341894f, -0.26553822f, 
    -0.09359078f, -0.17297558f, 0.09106916f, 0.01865751f, 0.06450617f, -0.17549303f, 0.16914637f, -0.20660153f, 
    -0.67119098f, 0.52565891f, 0.23926549f, 0.02441335f, 0.18206921f, -0.13233806f, -0.02339867f, 0.22681174f, 
    0.17102246f, 0.20285650f, -0.08006678f, 0.17278169f, -0.00888226f, 0.26755142f, -0.10870321f, 0.14920597f, 
    0.01656158f, 0.07370900f, 0.12577662f, 0.03817579f, -0.01758278f, -0.02211100f, 0.17517985f, -0.04808048f, 
    0.41474780f, -0.34995425f, 0.10917547f, 0.10479020f, 0.03145524f, 0.02171640f, -0.06288837f, 0.02008251f, 
    0.02546465f, -0.04114228f, -0.06472142f, -0.06042947f, -0.26546291f, -0.80129403f, -0.26768082f, 0.38414803f, 
    0.07940558f, 0.13367860f, 0.20227565f, 0.03461737f, -0.00460410f, 0.16937596f, -0.03730427f, -0.09520213f, 
    -0.23773299f, -0.12745145f, -0.11116997f, 0.05571431f, -0.24681665f, 0.02709044f, 0.11910885f, -0.25898293f, 
    -0.02706036f, 0.10423575f, 0.03147572f, 0.29899314f, -0.06357172f, 0.46140030f, 0.32187515f, -0.20299487f, 
    -0.04710527f, 0.09135329f, 0.11137193f, 0.10931215f, 0.00748678f, -0.13918003f, 0.07041353f, -0.05302000f, 
    0.20323686f, -0.10896906f, -0.04003423f, -0.03249043f, -0.20740984f, -0.19755904f, 0.19253562f, 0.13430578f, 
    -0.18995360f, 0.02538513f, -0.10657942f, -0.01059219f, -0.17891879f, -0.66945618f, 0.12792881f, -0.02120225f, 
    -0.25710666f, -0.09085821f, 0.04319098f, 0.12006647f, 0.07647096f, 0.15558426f, -0.15292951f, -0.01678857f, 
    -0.25661242f, -0.31511900f, 0.32743248f, -0.01131170f, 0.02441352f, 0.11933766f, -0.01834038f, -0.00795273f, 
    0.02494865f, -0.00259016f, -0.01454133f, 0.15012105f, 0.39594865f, 0.21942027f, -0.02754327f, -0.48723662f, 
    -0.03806729f, 0.04539078f, -0.04561336f, 0.07725988f, 0.01956924f, -0.00165825f, 0.00160631f, 0.10451215f, 
    -0.39915738f, -0.26613334f, 0.29401022f, 0.37516537f, -0.02468138f, -0.19768848f, -0.20444198f, 0.10335526f, 
    0.12039796f, 0.02805980f, -0.24312320f, -0.10825360f, 0.14044113f, 0.00545283f, 0.31135625f, 0.46526316f, 
    0.13167790f, -0.01514278f, 0.23958598f, 0.30282283f, -0.12380163f, 0.29514760f, 0.15025102f, 0.19960605f, 
    0.18750551f, 0.06153044f, 0.08684931f, -0.00331154f, -0.15149790f, -0.00415777f, 0.05143838f, 0.06202739f, 
    -0.00413603f, 0.03532743f, -0.05558659f, -0.02098476f, -0.23341393f, 0.21487963f, -0.09247016f, -0.00610744f, 
    0.00527962f, 0.05316315f, -0.03616746f, 0.21555211f, -0.00764134f, 0.05891223f, 0.09820803f, 0.12742557f, 
    0.30260989f, 0.00889776f, -0.19162937f, 0.01878966f, -0.18957746f, -0.02152140f, 0.05190450f, 0.02703172f, 
    -0.04035936f, 0.08560730f, 0.04867638f, -0.09287532f, -0.51872164f, -0.12643723f, -0.22987200f, 0.32830301f, 
    -0.00258101f, 0.06233051f, 0.03151637f, 0.15490469f, -0.10450120f, -0.01682186f, 0.09190542f, 0.02550290f, 
    -0.22321934f, 0.14764567f, 0.15134621f, 0.04094451f, -0.31804800f, -0.02518339f, 0.21077150f, -0.17934391f, 
    0.07127222f, 0.05987413f, -0.11184046f, -0.11367529f, -0.10061869f, -0.26129588f, -0.72478735f, 0.24184929f, 
    0.23056519f, -0.15663233f, -0.05343069f, -0.13731401f, -0.13325308f, -0.12840638f, 0.13799751f, -0.06588450f, 
    -0.06498484f, 0.23023584f, -0.14044963f, 0.01447731f, -0.07756986f, 0.00020715f, -0.01588273f, -0.23734869f, 
    -0.10620415f, 0.00216511f, 0.11193032f, -0.06553963f, -0.42007372f, -0.43758646f, 0.34330478f, 0.31495094f, 
    -0.18085085f, -0.04740917f, -0.17032109f, -0.24975093f, 0.17147957f, 0.05321873f, -0.03351981f, -0.05625443f, 
    0.42414105f, -0.16497803f, -0.16704850f, 0.37890875f, -0.22606547f, -0.00021300f, 0.12355283f, 0.05402315f, 
    0.03674601f, -0.01115288f, 0.00021543f, 0.04093531f, 0.33055738f, -0.20544294f, -0.19428554f, -0.40346065f, 
    0.03945864f, -0.24917454f, 0.16121906f, 0.10132463f, -0.08529984f, -0.13425425f, -0.21677658f, -0.08494271f, 
    -1.12634575f, 0.26327333f, 0.17435092f, 0.30866611f, 0.27258858f, 0.06601279f, 0.03476171f, 0.18604565f, 
    -0.17338073f, 0.12763906f, 0.04910993f, 0.05431001f, -0.27448508f, -0.50314939f, 0.03148787f, -0.06746861f, 
    -0.13714993f, 0.05573231f, 0.05022409f, -0.04435376f, 0.04048855f, -0.06911626f, -0.09238671f, -0.13286340f, 
    0.67329538f, 0.03866222f, -0.03710908f, -0.25817153f, -0.14344464f, 0.01404488f, -0.14828871f, -0.12284628f, 
    0.00340029f, -0.24052352f, 0.04454932f, 0.04606197f, -0.24771251f, -0.21987106f, 0.64435470f, 0.39529085f, 
    -0.06009113f, -0.07979600f, -0.04757971f, 0.13969044f, 0.00244205f, 0.26541594f, -0.03504011f, -0.09149583f, 
    0.12745261f, -0.08744586f, -0.32259396f, -0.45270684f, 0.09553093f, 0.05554839f, 0.14732021f, 0.00744540f, 
    0.04308141f, 0.05504968f, 0.08656120f, 0.30584487f, -0.27278072f, -0.00862930f, -0.12331843f, 0.11350040f, 
    0.28456399f, 0.10695407f, -0.31200913f, -0.20120183f, 0.17745383f, -0.15054084f, 0.13761152f, -0.08463486f, 
    0.10601825f, -0.17362624f, -0.01860541f, -0.05329233f, 0.03615930f, 0.09995045f, 0.10847224f, -0.05966439f, 
    0.18750888f, -0.01358471f, 0.13157439f, 0.41157061f, -0.26575688f, 0.04240005f, 0.33105692f, 0.08669523f, 
    -0.12075813f, -0.21367031f, 0.18776882f, 0.11727907f, 0.16612820f, -0.08203077f, -0.42267013f, -0.26065624f, 
    0.05930506f, 0.12527002f, 0.48642632f, -0.32356355f, 0.22444978f, 0.02040187f, -0.09401364f, -0.02972599f, 
    -0.04472736f, -0.11256702f, 0.13880216f, -0.00201265f, -0.46559638f, 0.27968562f, -0.31997153f, -0.24369252f, 
    0.21017697f, 0.00798522f, -0.04496025f, -0.20886298f, -0.16678065f, -0.02253161f, -0.20213607f, -0.01074152f, 
    -0.45203918f, -0.34853131f, -0.07055516f, 0.24563293f, -0.06722519f, 0.02205646f, 0.03871733f, 0.13459830f, 
    0.10214043f, -0.08001968f, 0.01755317f, -0.07045896f, 0.15891549f, -0.16395807f, 0.16722876f, -0.04220711f, 
    0.10469484f, -0.09294125f, -0.27452299f, 0.24798365f, 0.11747008f, 0.03460848f, -0.05020467f, -0.10643087f, 
    0.10827433f, -0.12593171f, -0.20862146f, -0.13703619f, -0.09007287f, -0.17632084f, 0.05442351f, -0.22320601f, 
    -0.17600831f, 0.01786467f, -0.14720443f, -0.15238237f, 0.06537091f, 0.10736625f, 0.29760748f, 0.34033853f, 
    -0.13957499f, -0.18041529f, 0.04012758f, 0.10036290f, -0.22495297f, -0.02669219f, 0.06295030f, 0.03898218f, 
    0.24994631f, -0.03307519f, 0.03027950f, 0.11775307f, 0.13895768f, 0.14043622f, -0.25488862f, -0.27363095f, 
    -0.14584349f, -0.20450790f, -0.09032840f, 0.14563258f, -0.84816921f, -0.45733842f, 0.05714267f, 0.18924814f, 
    -0.04354986f, 0.18386912f, 0.05229087f, -0.01935988f, 0.13553193f, 0.00500369f, 0.02972959f, 0.10981830f, 
    -0.96652257f, -0.14425558f, -0.79200864f, -0.19512704f, 0.27499506f, 0.16991484f, -0.06219758f, 0.05446193f, 
    0.09064920f, -0.00665167f, 0.34887716f, -0.20673853f, -0.03664794f, 0.25435752f, -0.19590063f, 0.11355609f, 
    -0.12468769f, 0.02772378f, 0.02520391f, 0.06463730f, 0.10383854f, 0.03693710f, 0.13744263f, 0.17045644f, 
    -0.93861401f, 0.32022831f, 0.16075322f, 0.43067437f, -0.02203770f, -0.01635625f, 0.03754829f, 0.22334655f, 
    0.10084830f, 0.08238336f, 0.06220740f, -0.00503556f, 0.34767792f, -0.16977346f, 0.08331622f, -0.05098655f, 
    -0.00474461f, -0.03963657f, 0.05338122f, 0.14981702f, 0.03927708f, -0.01325400f, 0.13418318f, 0.10890383f, 
    0.11032166f, 0.08648658f, -0.01598077f, -0.23724002f, -0.02961054f, 0.02701399f, 0.14517649f, -0.05870545f, 
    0.09031525f, -0.10512701f, -0.15173490f, -0.36754349f, 0.20372491f, 0.06168032f, -0.51180631f, 0.21562235f, 
    -0.26803926f, -0.07507542f, -0.01502859f, -0.16642961f, -0.05113789f, 0.20757376f, -0.03118366f, -0.02139573f, 
    -0.32947287f, 0.38708180f, 0.06104200f, -0.63036323f, -0.17287458f, 0.05143813f, 0.01438203f, 0.15819333f, 
    0.06240552f, -0.02564256f, -0.23947506f, -0.29556859f, 0.51262748f, 0.00283344f, -0.15597335f, -0.03291043f, 
    -0.19715810f, -0.13008949f, 0.15521990f, 0.08628239f, -0.02738196f, -0.04381084f, 0.16317743f, 0.29574862f, 
    0.06231102f, 0.20467068f, 0.42503813f, -0.36414662f, -0.10852015f, 0.13661605f, -0.16360259f, 0.21633859f, 
    0.04382375f, 0.15107158f, 0.03993911f, 0.00874811f, -0.08328070f, -0.55154419f, -0.16703577f, -0.13458946f, 
    -0.14982894f, 0.15263672f, -0.10463684f, 0.01788238f, 0.28688183f, 0.08551320f, 0.11953774f, 0.02582633f, 
    -0.57567263f, -0.24216133f, -0.20017982f, 0.05568521f, 0.12159847f, -0.10608684f, 0.09964239f, -0.12068722f, 
    -0.11860081f, -0.01858855f, -0.02856511f, 0.07742092f, -0.13717192f, 0.04185596f, -0.25498852f, -0.04100591f, 
    -0.08502959f, 0.18969165f, 0.12612756f, -0.04351678f, 0.08996797f, 0.04847764f, 0.02564141f, 0.08654732f, 
    -0.48945719f, -0.14496277f, 0.40015516f, 0.20712255f, -0.02526326f, 0.27112508f, 0.23710252f, 0.06325441f, 
    -0.09276685f, 0.04731932f, 0.31930912f, -0.10703266f, -0.42232662f, 0.59091997f, -0.03193228f, -0.12317297f, 
    0.07565635f, 0.14698382f, 0.03870031f, -0.02620100f, -0.13369948f, -0.24700724f, -0.00684616f, -0.04991307f, 
    -0.59412062f, -0.18712687f, 0.15772474f, -0.04719402f, 0.16381183f, -0.06177771f, 0.31411460f, 0.05142210f, 
    0.23417808f, -0.11370862f, -0.05105795f, 0.00763790f, 0.73801535f, -0.20109138f, -0.08562726f, 0.00624000f, 
    -0.14169019f, 0.04318224f, -0.05549049f, -0.30225393f, -0.53440219f, -0.02805049f, 0.09749174f, -0.24622351f, 
    -0.09359735f, -0.29393315f, -0.19667466f, -0.76689738f, -0.11287025f, 0.02357801f, -0.09302686f, -0.34862056f, 
    0.06175455f, 0.01651052f, -0.04688155f, 0.28225467f, 0.07896277f, 0.00107286f, -0.10540486f, 0.50882298f, 
    0.17462097f, 0.16016616f, -0.16849636f, 0.11167209f, 0.05962474f, -0.06075258f, -0.22835450f, -0.17380658f, 
    -0.29043525f, 0.01379268f, -0.26570082f, -0.38317221f, -0.11528370f, -0.06516877f, -0.21315673f, -0.12632577f, 
    -0.07490066f, -0.13435768f, -0.11005130f, -0.14070277f, 0.21014251f, 0.08384098f, 0.14525114f, 0.44257793f, 
    0.09079693f, -0.17135300f, -0.02053219f, -0.24545431f, -0.14209580f, -0.09385506f, -0.10076152f, -0.15191954f, 
    0.19410160f, -0.27823877f, 0.19613303f, -0.32573265f, -0.04176553f, -0.05967926f, -0.06925975f, -0.07679007f, 
    -0.09463896f, 0.02861346f, -0.15438704f, -0.05038224f, 0.08083394f, 0.19553256f, 0.02685871f, 0.51248008f, 
    0.16881223f, 0.05970291f, 0.01297491f, 0.17043814f, -0.16538198f, 0.07117762f, 0.08418276f, -0.17642248f, 
    -0.98458618f, 0.47036514f, -0.38899618f, -0.16732034f, -0.04974980f, 0.02963715f, 0.13015902f, -0.14134589f, 
    -0.11762036f, 0.07662907f, -0.04705698f, -0.09788499f, -0.45846921f, 0.00450497f, 0.09127418f, -0.31212598f, 
    -0.04736136f, -0.04754915f, -0.08867992f, -0.21143718f, -0.06147766f, 0.02092145f, 0.08578715f, 0.09478108f, 
    -0.04048900f, 0.33512899f, -0.25744805f, -0.12377656f, 0.06403115f, 0.01232456f, 0.04668924f, -0.08492982f, 
    -0.19289614f, -0.08547666f, -0.12958696f, -0.21668695f, -0.21308115f, 0.33278462f, 0.18760239f, 0.08724260f, 
    0.19138852f, -0.02750732f, 0.11487731f, -0.07196181f, 0.04180396f, -0.02990671f, 0.15596496f, -0.19656165f, 
    0.40732697f, -0.82829249f, 0.50845265f, 0.08543197f, -0.02167405f, 0.05836848f, -0.14280012f, -0.13706124f, 
    -0.19112201f, -0.07519921f, 0.05643597f, 0.07144624f, 0.07914922f, 0.29274815f, -0.24683107f, 0.31665310f, 
    -0.00309276f, 0.01744215f, -0.20642653f, -0.08612832f, -0.07663566f, -0.01114930f, -0.02895479f, -0.24494654f, 
    0.07367231f, 0.39137262f, -0.19496693f, -0.08790108f, -0.19453453f, 0.15773873f, -0.01340545f, 0.04343999f, 
    -0.09638247f, -0.14454409f, 0.14948149f, -0.06176405f, -0.31054741f, -0.32390830f, -0.62020987f, -0.21096607f, 
    -0.02695680f, -0.19085591f, -0.08872174f, -0.02262218f, -0.21332482f, -0.15034576f, 0.10342319f, -0.08896271f, 
    0.08810007f, 0.12687986f, 0.15724258f, 0.19628707f, 0.20044555f, -0.00062910f, -0.04769237f, -0.09915345f, 
    -0.06807826f, -0.04853675f, -0.22796088f, 0.04046673f, 0.24022965f, 0.22281170f, 0.19811477f, 0.40999040f, 
    0.26440316f, -0.00449220f, 0.10890914f, -0.02479216f, 0.03158291f, 0.06108947f, 0.02800926f, 0.03817732f, 
    0.35177028f, 0.16941291f, 0.46082523f, 0.17416915f, 0.14802045f, 0.21150401f, 0.19189900f, -0.13419586f, 
    -0.14532079f, 0.15418467f, -0.30492011f, 0.01675307f, -0.44884592f, 0.16620377f, 0.04896165f, -0.18746206f, 
    0.12964505f, -0.06807670f, -0.14722103f, -0.00067263f, 0.20498061f, 0.03445025f, -0.09158441f, -0.12702821f, 
    0.32291692f, 0.15544009f, -0.20022026f, 0.02554769f, 0.02072393f, -0.00322724f, -0.16535108f, -0.08652966f, 
    -0.06522361f, 0.06020521f, -0.15519741f, 0.06999420f, -0.32400399f, -0.53270650f, -0.37547579f, -0.82599831f, 
    0.07092495f, -0.30363968f, -0.20258123f, -0.05263481f, 0.18061198f, 0.01380401f, -0.17728737f, -0.09655366f, 
    -0.63365197f, 0.03438225f, -0.04672362f, -0.15024950f, -0.13808858f, -0.22715616f, 0.18647234f, -0.09500795f, 
    0.11128453f, 0.09129602f, 0.22146997f, 0.17114221f, -0.28329405f, 0.36822212f, -0.16606168f, -0.46919498f, 
    -0.01841283f, -0.10883132f, -0.28409275f, -0.02523473f, 0.09774916f, -0.05031171f, 0.02678786f, 0.17817840f, 
    0.05502286f, -0.15336120f, 0.16088687f, 0.24954051f, 0.11028441f, 0.09012049f, -0.03075627f, -0.05725288f, 
    -0.03255942f, -0.16438942f, 0.27123770f, 0.15728366f, 0.36402395f, -0.00290428f, -0.09878016f, 0.24697296f, 
    0.29728660f, -0.13560383f, -0.13554238f, -0.11477017f, 0.04978403f, 0.00987238f, -0.10380914f, -0.06366752f, 
    0.42699033f, 0.01129730f, 0.08036456f, 0.36329657f, 0.07933415f, -0.08372400f, -0.01532644f, -0.03785033f, 
    0.00685253f, -0.12274659f, 0.11962141f, -0.37522367f, -0.13204941f, -0.16625936f, 0.30866855f, 0.31965241f, 
    -0.17856364f, -0.11524953f, 0.08668410f, -0.00675993f, 0.01264142f, 0.04924760f, -0.21384557f, 0.06622332f, 
    0.18579659f, 0.28645542f, -0.03463922f, 0.18824378f, -0.06697661f, 0.01190440f, -0.21881557f, -0.20626208f, 
    0.06877262f, -0.17786373f, -0.08285500f, 0.12561700f, -0.28558269f, 0.48407620f, -0.01840075f, -0.20683874f, 
    -0.18431339f, -0.04359628f, -0.14703371f, -0.00639073f, 0.06539850f, -0.05536707f, 0.07273271f, 0.04986051f, 
    -0.06284857f, 0.27979466f, 0.01806545f, 0.09578027f, 0.00987529f, -0.16882733f, -0.21940328f, 0.25723493f, 
    0.12908913f, -0.01176047f, -0.05107079f, 0.13247947f, -0.16794468f, -0.21876696f, -0.43963856f, 0.05003946f, 
    0.17170845f, 0.05718704f, -0.07509833f, -0.05029943f, 0.08795629f, 0.11622158f, 0.22203514f, -0.10039701f, 
    -0.27125487f, 0.06964906f, 0.06499550f, -0.11811206f, 0.12664068f, 0.15343645f, -0.26338586f, 0.05137516f, 
    -0.06473809f, -0.04140327f, -0.02610002f, -0.39469481f, 0.09726222f, -0.04516148f, 0.16205893f, -0.23991555f, 
    -0.15587610f, 0.23140959f, 0.21235985f, 0.00282105f, -0.08156236f, -0.10556430f, 0.00951316f, 0.07176675f, 
    -0.35201260f, -0.11912567f, 0.47579068f, -0.13770276f, -0.00458120f, -0.03318691f, -0.13974009f, 0.03654353f, 
    0.04594194f, -0.22476128f, 0.29602253f, -0.30015397f, 0.23213074f, 0.32521841f, -0.70968485f, -0.00763260f, 
    -0.07074718f, 0.00931697f, -0.19985777f, -0.25443324f, 0.14013423f, -0.05296678f, 0.06187535f, 0.13842817f, 
    0.37577590f, 0.22433777f, 0.05137640f, 0.36883354f, 0.17546459f, 0.20962055f, 0.21454771f, 0.03901965f, 
    0.07598624f, 0.14092048f, 0.12813029f, -0.10595518f, -0.31835446f, -0.39542568f, -0.13663214f, -0.46926650f, 
    -0.08563855f, -0.08462994f, -0.13029081f, -0.05834125f, -0.03167368f, -0.10315143f, 0.10303670f, 0.08478469f, 
    -0.06964191f, 0.09333868f, -0.02078160f, -0.16409808f, -0.08322281f, -0.09299102f, 0.16697393f, -0.09142088f, 
    0.17279375f, -0.04772052f, -0.09310761f, -0.23185383f, -0.40420187f, -0.33622402f, 0.25176403f, -0.55204749f, 
    -0.04605025f, 0.15691024f, -0.00971818f, 0.06365228f, -0.13333194f, -0.26507348f, -0.13644004f, -0.03593744f, 
    -0.64487374f, 0.85510147f, -0.39513472f, -0.55646676f, 0.09990515f, -0.04460193f, -0.04019982f, -0.09822965f, 
    -0.27177894f, -0.09366736f, -0.29441503f, -0.39484099f, -0.07971344f, 0.02208927f, -0.01012267f, -0.50415510f, 
    0.05792698f, 0.04907360f, -0.15120211f, -0.28401938f, 0.01131729f, 0.03037047f, -0.11605547f, 0.10670438f, 
    -0.57111621f, 0.10249849f, -0.44727474f, -0.19508065f, 0.12453970f, 0.11158799f, 0.15828939f, 0.07895701f, 
    0.01029604f, 0.09826455f, -0.07556095f, 0.13848902f, 0.00724003f, -0.51572514f, -0.19856869f, -0.11371258f, 
    0.32340115f, 0.01264194f, -0.10968929f, 0.10987494f, 0.09156836f, -0.16987310f, 0.23580609f, -0.06859956f, 
    1.03722334f, -0.77874941f, -0.21842822f, 0.08314240f, -0.05001573f, 0.12161092f, 0.00628555f, 0.26966923f, 
    -0.08676574f, 0.22977547f, 0.20425722f, -0.03160139f, -0.06142985f, 0.50150043f, 0.05130546f, 0.33517259f, 
    -0.10987294f, 0.04078794f, -0.05324607f, 0.14520615f, -0.17253090f, 0.09542891f, 0.07672051f, 0.11770219f, 
    -0.36326107f, 0.31297624f, 0.15731615f, -0.01073821f, 0.05612701f, 0.02301634f, -0.01843737f, 0.01572588f, 
    0.33997688f, -0.11441574f, 0.06634207f, 0.15536936f, 0.24098745f, -0.09086309f, 0.05483552f, -0.49827296f, 
    -0.09136281f, 0.16399491f, -0.09979321f, -0.14216231f, -0.21470089f, -0.07986672f, -0.12966047f, -0.11034939f, 
    0.09226888f, -0.40373078f, 0.21457471f, 0.14995241f, -0.25032505f, -0.03837169f, 0.17774054f, 0.44412449f, 
    -0.02450177f, 0.29840633f, 0.09203164f, 0.13030380f, -0.28071067f, -0.13363777f, 0.18642646f, 0.26020107f, 
    0.25415280f, -0.01101830f, -0.13105501f, -0.09693091f, 0.03330800f, 0.05889734f, 0.20602776f, 0.24415207f, 
    0.04429222f, -0.35702744f, 0.19250272f, 0.17901318f, 0.01059792f, 0.02386949f, -0.03691453f, -0.01645562f, 
    -0.04573921f, 0.16886812f, -0.37525436f, -0.05286624f, -0.09683870f, 0.38066155f, 0.51497340f, 0.04001814f, 
    0.21136636f, 0.05009796f, -0.07174078f, 0.02303039f, 0.01671718f, -0.08806059f, -0.05270177f, -0.05228284f, 
    -0.41986108f, -0.47006303f, -0.11390877f, 0.00729233f, 0.10478281f, 0.28509068f, 0.25861946f, -0.30966395f, 
    0.10955977f, -0.10134939f, -0.00876099f, 0.04811977f, -0.43527806f, 0.09380285f, -0.18409103f, 0.14534594f, 
    0.29825631f, 0.05390859f, 0.07477203f, 0.11020856f, -0.03907546f, 0.19963786f, -0.02466844f, -0.10712240f, 
    0.26907578f, 0.28690121f, -0.24570948f, 0.03819969f, 0.28615484f, 0.09941439f, 0.10326296f, 0.25122070f, 
    -0.18009467f, 0.21767411f, 0.10361291f, 0.22681469f, 0.02045479f, 0.13341567f, -0.18343709f, 0.07880135f, 
    -0.04580485f, 0.09162213f, 0.18123020f, -0.13706318f, -0.19332618f, -0.01654879f, 0.10276091f, -0.08076060f, 
    -1.05362296f, -0.69089878f, -0.25813112f, -0.36777350f, -0.05089147f, -0.01070413f, 0.02954817f, 0.11456318f, 
    0.04838802f, 0.12606603f, 0.28531191f, 0.11609109f, -0.57532185f, -0.07478449f, -0.46246386f, -0.37644657f, 
    0.27201229f, -0.08350807f, -0.32338521f, -0.17883125f, 0.09311038f, -0.39193928f, -0.01542256f, -0.19754143f, 
    -0.77167428f, -0.18415681f, -0.23588216f, -0.22631624f, 0.16899110f, -0.05248698f, -0.10779409f, 0.03524179f, 
    -0.04774977f, 0.13417758f, 0.32222611f, -0.06287102f, 0.49426520f, 0.23686890f, 0.02310169f, 0.16461419f, 
    -0.02441591f, -0.14650287f, 0.14232810f, 0.12196894f, 0.12174225f, 0.12234999f, -0.25427747f, 0.24061501f, 
    -0.20378190f, 0.34846959f, -0.25198516f, 0.05420746f, 0.13796672f, 0.17786548f, -0.04090023f, -0.02194376f, 
    -0.07208187f, -0.05615665f, 0.05480726f, 0.09115400f, -0.10565035f, -0.27905899f, 0.27293608f, 0.09670440f, 
    -0.05312796f, 0.12269846f, 0.10054819f, 0.09229222f, 0.14155780f, 0.04528671f, -0.12829867f, -0.00028345f, 
    -0.41077155f, -0.39261433f, 0.16870072f, -0.00708018f, 0.04217779f, 0.26032177f, 0.17866190f, -0.03590337f, 
    0.10236596f, -0.09803112f, -0.41184255f, 0.10361835f, -0.67227924f, 0.01761159f, 0.43233532f, -0.33800656f, 
    0.29040706f, 0.05657399f, -0.22006212f, 0.05022829f, 0.18246166f, 0.30677983f, -0.04780062f, 0.10006335f, 
    0.35681862f, -0.02132261f, 0.24603528f, -0.29068011f, -0.03419182f, 0.10806551f, -0.19624141f, -0.20229301f, 
    -0.20128359f, -0.17845693f, -0.04575453f, -0.14412320f, -0.02204376f, 0.06216310f, -0.35644239f, -0.07107531f, 
    -0.20078172f, -0.02962565f, -0.06602946f, -0.02306158f, 0.09781812f, 0.26103553f, 0.17418280f, -0.11535116f, 
    0.63331151f, 0.25668648f, -0.08780548f, -0.11039148f, -0.41787133f, -0.08267022f, -0.04068436f, -0.15061519f, 
    -0.04914529f, -0.18330920f, -0.01076591f, -0.16749495f, -0.76476884f, -0.40277708f, 0.10891823f, 0.21766736f, 
    0.31430990f, -0.02989420f, 0.06417704f, -0.07307840f, 0.20417634f, 0.22784989f, 0.25938359f, 0.11672427f, 
    -0.42582816f, 0.25575653f, -0.13081667f, -0.11360761f, 0.11514201f, -0.03177989f, -0.12906894f, 0.23717643f, 
    -0.15355960f, -0.17293714f, 0.09293413f, -0.02466309f, -0.12245259f, -0.17255747f, -0.02720054f, 0.39057782f, 
    -0.22036867f, 0.17814660f, -0.00723637f, -0.06570835f, -0.01011849f, -0.19704288f, 0.11672512f, 0.18436018f, 
    -0.40310621f, 0.38181329f, -0.24693319f, 0.14818378f, 0.14275682f, -0.04076702f, 0.10502575f, 0.07527348f, 
    -0.18322244f, -0.32046625f, -0.08315382f, -0.17218512f, 0.38040304f, -0.49432135f, -0.30598643f, 0.10073031f, 
    -0.23480490f, 0.16391586f, -0.25623351f, -0.03779604f, -0.01793825f, -0.08564056f, -0.20137922f, -0.26204410f, 
    0.18604508f, -0.36616367f, -0.17829251f, 0.24189360f, 0.13271344f, 0.10134509f, 0.01999363f, -0.13738519f, 
    0.03346866f, 0.09079294f, -0.05924497f, -0.11053097f, -0.21937588f, -0.62421411f, -0.16179691f, -0.38805097f, 
    0.02893911f, 0.12487077f, -0.04135168f, 0.05731919f, -0.09451589f, 0.08674355f, 0.10021166f, 0.02069175f, 
    -0.38012770f, 0.08136267f, -0.25824687f, -0.27110818f, 0.08044414f, 0.01379871f, 0.10707062f, 0.03309426f, 
    0.07419359f, -0.15836161f, -0.12243026f, 0.11730412f, 0.20224100f, -0.02731150f, 0.07951279f, 0.10928652f, 
    -0.08315353f, -0.15168044f, 0.24718583f, 0.17786111f, -0.40774938f, -0.06533780f, -0.12557761f, -0.17431577f, 
    -0.47245386f, 0.06740595f, -0.19120400f, -0.01212827f, -0.05391746f, -0.07956146f, 0.04278605f, 0.18082845f, 
    -0.25345203f, -0.06834339f, 0.16193582f, -0.04991675f, 0.20400807f, 0.00837617f, -0.24123262f, 0.53163815f, 
    0.32845032f, -0.13264428f, 0.05817262f, -0.12901278f, 0.06747294f, 0.03086144f, 0.12525287f, 0.17231317f, 
    -0.63412094f, 0.47408095f, -0.03928606f, 0.13664116f, 0.24687584f, 0.17908113f, -0.36475563f, 0.14829251f, 
    0.09580606f, 0.21170312f, -0.04674820f, 0.05564586f, 0.73674965f, 0.56279135f, -0.50683063f, 0.04783474f, 
    -0.08767694f, -0.07762539f, -0.05756606f, 0.06593280f, 0.25941661f, 0.13361458f, 0.08436447f, -0.00661798f, 
    0.13056736f, 0.22656199f, -0.26678368f, 0.23344146f, 0.17792171f, -0.03002991f, 0.03636445f, -0.26782113f, 
    0.21449377f, 0.23316677f, 0.03214080f, -0.02909318f, -0.34095502f, -0.09273351f, -0.15374516f, -0.01237929f, 
    -0.24553725f, 0.03835418f, -0.17365114f, 0.06361637f, -0.21070684f, 0.20989880f, 0.15832064f, 0.07145604f, 
    -0.10684064f, 0.21123952f, -0.19560967f, 0.16564466f, 0.01003745f, 0.11439510f, -0.10238615f, -0.31021139f, 
    0.19619091f, -0.00901898f, 0.05293204f, -0.00685680f, 0.48863131f, -0.08869920f, -0.31934398f, 0.12604131f, 
    0.21645063f, -0.11287680f, -0.17742200f, -0.07109622f, -0.07260346f, 0.17371629f, -0.18699020f, -0.03163472f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13588464f, 0.07584509f, -0.06501836f, 0.04028646f, 0.05508164f, -0.00664712f, -0.01538021f, -0.14997546f, 
    -0.09216755f, -0.06130898f, 0.32512781f, 0.00011679f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
