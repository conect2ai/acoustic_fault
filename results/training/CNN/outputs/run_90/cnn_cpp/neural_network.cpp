#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.23591031f, 0.48348132f, 0.51179820f, 0.68919039f, 0.84363389f, 0.61137897f, 0.23694116f, 0.10167857f, 
    -0.60388535f, -0.21701622f, -0.42131874f, -0.14019594f, 0.12624352f, 0.47121698f, 0.33713779f, 0.23068020f, 
    0.05917539f, 0.13596147f, 0.35992521f, 0.10685191f, 0.21069372f, -0.09300818f, 0.02796824f, 0.06258085f, 
    -0.00898500f, 0.62108296f, -0.48691124f, -0.65031403f, -0.15216844f, -0.30231678f, -0.58423728f, 0.60771447f, 
    0.19153123f, -0.44013274f, 0.19748871f, -0.08140607f, 0.17862834f, -0.08471209f, -0.28481433f, 0.12854038f, 
    0.01057890f, 0.01996021f, -0.36127812f, -0.23988940f, 0.05460935f, -0.16455808f, -0.15763605f, -0.00850504f, 
    0.07631685f, -0.02243540f, -0.47660881f, -0.76867396f, -0.41139269f, -0.27532169f, -0.26612389f, -0.47492042f, 
    -0.02404125f, 0.37694478f, -0.19480410f, 0.26293465f, -0.23470359f, 0.29291132f, 0.07172977f, -0.35946086f, 
    -0.33904976f, -0.26573089f, 0.37868735f, 0.31258559f, 0.00267440f, -0.36782435f, 0.16157249f, -0.16771592f, 
    -0.20275712f, -0.14398757f, 0.07648139f, -0.12836066f, 0.51257151f, -0.89444643f, 0.73351187f, -0.27111834f, 
    0.61966664f, -0.47623560f, -0.31284672f, -0.05235612f, -0.40961254f, 0.41004443f, -0.08137065f, 0.18681671f, 
    0.19953677f, -0.01065693f, 0.01341684f, 0.16930148f, -0.23260182f, -0.12116934f, -0.27329776f, -0.34327611f, 
    -0.25327179f, 0.12403503f, -0.24256994f, 0.32973984f, 0.62408257f, -0.31066850f, -0.71594560f, -0.37285393f, 
    -0.67824149f, -0.14098296f, 0.43172908f, -0.02042400f, 0.38827807f, 0.32154834f, 0.60562921f, 0.18424322f, 
    -0.35993129f, 0.01226456f, 0.00031152f, 0.34843716f, 0.00672919f, 0.05695729f, 0.11990444f, 0.05423458f, 
    -0.12919320f, 0.14986701f, 0.16391395f, 0.40314889f, -0.08404122f, -0.98233330f, 1.01505613f, 0.19788630f, 
    -0.90979767f, -0.61326194f, 0.67681938f, 0.03949445f, -0.52558118f, 0.58683950f, -0.18105975f, -0.44192818f, 
    -0.15346593f, -0.18138011f, 0.02486890f, -0.08370738f, -0.23256248f, 0.12695262f, 0.02779835f, 0.10260699f, 
    -0.16409412f, -0.13208716f, -0.03924619f, 0.12990789f, 0.36757526f, 0.03100636f, 0.09819179f, -0.36069345f, 
    0.20222989f, 0.65244478f, -0.44108278f, 0.13228191f, -0.72878069f, -0.24066296f, 0.05173103f, -0.38341069f, 
    -0.57367224f, 0.19636744f, 0.08067905f, -0.44768491f, 0.21655345f, -0.56562448f, -0.38700223f, -0.13886723f, 
    -0.22471282f, -0.32503185f, 0.36286521f, -0.06368474f, -0.07867263f, -0.25507075f, -0.06349388f, 0.49389976f, 
    0.58130080f, 0.06837062f, 0.55716014f, 0.27799487f, 0.16313002f, 0.04265222f, -0.32104689f, -0.37560147f, 
    0.28812337f, -0.03307091f, -0.24150808f, 0.27265096f, -0.46046951f, -0.08326192f, -0.23338072f, -0.19934386f, 
    -0.13556069f, -0.05758145f, -0.04906003f, -0.27677339f, 0.30419946f, 0.00352985f, -0.03796341f, 0.29453552f, 
    -0.42798653f, -0.48601899f, -0.24648441f, 1.03512287f, 0.19289234f, 0.17759360f, -0.06963194f, -0.23852536f, 
    0.25399387f, -0.03486678f, 0.35868689f, 0.17489426f, -0.32136169f, 0.01255943f, 0.24032265f, -0.06382911f, 
    -0.27675679f, 0.27409965f, -0.19672747f, 0.15266851f, -0.00641729f, 0.24641390f, -0.23600167f, 0.18174157f, 
    -0.59180564f, -0.22573067f, -0.69603884f, -0.13132925f, 0.50029415f, 0.52929074f, -0.84514505f, -0.18521486f, 
    -0.28582710f, -0.46248916f, -0.18103695f, 0.20103942f, 0.35993835f, 0.16069736f, 0.03853727f, 0.11665182f, 
    0.07797989f, 0.28455421f, 0.43138498f, -0.10556623f, -0.18527193f, 0.27685601f, -0.19032535f, -0.20308758f, 
    -0.21442553f, 0.19153038f, 1.13079059f, 0.26549226f, 0.79277474f, -0.32451361f, -0.38681486f, 0.30175298f, 
    -0.64168537f, 0.44120723f, 0.16031367f, 0.42340976f, 0.14667763f, 0.12070605f, -0.33885589f, -0.38324231f, 
    -0.45696950f, 0.11209562f, 0.00333643f, -0.21455880f, -0.49666661f, -0.39766952f, 0.10736942f, 0.06912544f, 
    0.33466676f, 0.20164339f, -0.46371606f, 0.07338168f, 0.76453608f, 0.48712513f, 0.78060400f, 0.31629729f, 
    -0.48246095f, 0.04433738f, -0.73868209f, 0.08026802f, -0.22387698f, 0.23884055f, 0.02027682f, -0.08385175f, 
    0.16890648f, -0.34927490f, 0.02648277f, 0.24610335f, 0.23104471f, -0.07260177f, -0.23398468f, -0.32019722f, 
    -0.17167225f, -0.36128172f, 0.17826036f, 0.14079680f, 0.18651293f, -0.74335831f, 0.91351241f, 0.10630941f, 
    -0.46144947f, 0.52415580f, -0.97980058f, 0.46495229f, -0.13208850f, -0.00408402f, -0.16569026f, -0.05795920f, 
    -0.03225643f, -0.06405332f, -0.08469225f, -0.01931414f, 0.15441173f, 0.03283759f, -0.05497366f, -0.18073128f, 
    0.42183721f, -0.07867464f, 0.10041460f, 0.21715687f, 0.18061990f, 0.74301434f, 0.73074669f, -0.87941068f, 
    -0.74500781f, -0.66635209f, 0.16112207f, 0.11085486f, -0.20687343f, -0.33928937f, -0.38428342f, -0.14950889f, 
    0.09082458f, 0.24716046f, 0.36016482f, -0.13342299f, 0.18169847f, -0.16147617f, 0.14900021f, 0.11471082f, 
    -0.16390064f, 0.29825220f, -0.15910266f, -0.01601412f, -0.19585304f, 0.17014596f, -0.27926877f, 0.58514905f, 
    -0.09455195f, -0.06541470f, 0.85365164f, 0.69281054f, -0.42005050f, -0.92558759f, -0.53302372f, -0.05355117f, 
    -0.09778694f, -0.01098805f, 0.36646038f, 0.43767852f, -0.07739668f, -0.11638534f, -0.24400960f, 0.10990551f, 
    -0.18926819f, 0.31069079f, 0.20741779f, -0.04241269f, 0.04242609f, 0.00669802f, -0.24217546f, 0.52835906f, 
    0.81639105f, 0.50851822f, 0.49883497f, 0.21931645f, -1.03811884f, -0.14243461f, -0.01623933f, -0.56484550f, 
    0.27230731f, 0.45993337f, 0.03378159f, -0.15168378f, 0.48114431f, -0.02981294f, 0.34834784f, 0.09685500f, 
    0.00339855f, 0.21252348f, -0.04597985f, 0.56790054f, 0.21466188f, -0.30326831f, 0.29007119f, -0.03929336f, 
    1.15880072f, 0.41873702f, -0.35649729f, 0.58979303f, 0.40602112f, -0.15974475f, -0.27103075f, 0.14721100f, 
    -0.13836454f, 0.19057955f, -0.29893959f, 0.18345474f, 0.27505979f, -0.50671935f, -0.28470477f, -0.13820566f, 
    -0.28494439f, 0.08507919f, -0.17612040f, 0.10372206f, 0.55041701f, 0.21802200f, -0.06345358f, -0.15386398f, 
    0.08318489f, -0.50588500f, -0.60959977f, -0.27977791f, 0.14608160f, -0.24096732f, -0.21899348f, -0.47217193f, 
    -0.44605780f, -0.40909469f, -0.08229832f, -0.22220783f, -0.19543280f, 0.27286160f, 0.34231666f, -0.30018967f, 
    0.16317545f, -0.43171161f, -0.14383703f, 0.09980433f, 0.14700533f, 0.22458054f, -0.08390911f, -0.12174705f, 
    0.29180029f, 0.31270516f, 0.86673379f, 0.20403191f, -0.66071475f, -0.90288615f, -0.04759440f, -0.14445354f, 
    0.43564254f, 0.00894061f, -0.28117943f, 0.27283004f, 0.37449884f, -0.31357655f, 0.29541329f, -0.30154827f, 
    0.03637880f, 0.04295605f, 0.05968799f, 0.13628890f, 0.04140110f, 0.22885261f, 0.02605503f, 0.02691742f, 
    0.04870704f, 0.28011379f, -0.10545490f, -0.73130149f, -0.24146152f, 0.25781810f, 0.19043066f, 0.11805759f, 
    0.03459451f, -0.05340477f, -0.64257377f, -0.70804554f, -0.17517075f, 0.05131227f, 0.65278369f, 0.38548404f, 
    -0.18471059f, 0.10463692f, 0.29876915f, -0.19515435f, 0.27116969f, 0.47354800f, 0.32480505f, -0.13367125f, 
    -0.23640139f, -0.43576100f, -0.10065228f, 0.10050904f, -1.23285019f, 0.08991936f, 0.04091683f, -0.44593418f, 
    -0.53825486f, 0.47189730f, -0.00014508f, 0.05842416f, 0.58824432f, 0.31448108f, 0.04171415f, -0.31348354f, 
    -0.07055842f, 0.08133835f, 0.23606622f, 0.06911055f, 0.03854850f, -0.19527785f, -0.07788008f, -0.10400917f, 
    -0.00155446f, 0.18503024f, 0.39548317f, 0.37765583f, 0.25840712f, -0.27706912f, -0.45890415f, -0.58970147f, 
    -0.45151085f, -0.30772591f, 0.50465411f, 0.47701374f, -0.54586148f, 0.13644469f, 0.55484229f, -0.33148885f, 
    -0.30665460f, 0.30862287f, 0.15549971f, 0.33543140f, -0.29159206f, -0.05602943f, 0.12579671f, -0.09832785f, 
    -0.21368879f, 0.01429674f, 0.05459947f, -0.19682020f, 0.02052617f, 0.21647042f, -0.78178537f, -0.26822734f, 
    -0.56208348f, -0.65348572f, -0.43863592f, 0.21481693f, -0.61319071f, -0.27782944f, 0.06195810f, -0.29015842f, 
    0.40101391f, -0.21371582f, 0.36134118f, 0.10716380f, -0.25180951f, 0.18118368f, 0.19105631f, -0.01580104f, 
    -0.32443759f, -0.12357096f, 0.06258760f, 0.11579028f, 0.14955884f, -0.12755977f, -0.02509163f, -0.71993619f, 
    -0.32502785f, 0.23072602f, 0.26542228f, -0.20501061f, -0.22636908f, 0.63581705f, 0.21617241f, 0.14373384f, 
    -0.45783818f, -0.14984341f, 0.27082723f, -0.49645746f, -0.03246576f, 0.08851893f, 0.19856356f, 0.21048148f, 
    0.28676450f, -0.32137179f, -0.01104659f, -0.13393246f, -0.23161055f, 0.38572156f, 0.34422573f, 0.30430311f, 
    0.43824971f, -0.71112829f, 0.63245165f, -0.48903105f, 0.37964025f, 0.43411073f, -0.63007587f, 0.73940104f, 
    0.00294915f, -0.02114134f, 0.25781566f, -0.05358970f, -0.25978470f, -0.09696589f, -0.07526666f, 0.05197631f, 
    -0.00984632f, -0.03200034f, -0.10321343f, -0.09423615f, -0.26175880f, 0.12514386f, -0.02232264f, -0.25402981f, 
    0.06073805f, 0.71075267f, 0.52114815f, 0.89415336f, 0.26852849f, 0.41376355f, 0.47862718f, 0.29907253f, 
    -0.16058467f, -0.08689089f, -0.00276472f, -0.02248543f, 0.34409899f, 0.18650697f, 0.00898149f, -0.07257462f, 
    -0.00002851f, 0.12477128f, 0.13290139f, 0.01897911f, -0.29225850f, 0.12584539f, -0.11162101f, -0.14402819f, 
    0.21358387f, 0.28322443f, 0.95677662f, 0.72013497f, 0.31173977f, 0.09727530f, 0.37822637f, -0.49998817f, 
    0.20258330f, -0.31196168f, 0.39599845f, -0.04912616f, -0.34637919f, 0.05286027f, -0.20643881f, 0.19094627f, 
    -0.10089614f, 0.10763298f, -0.40155038f, 0.19091910f, -0.00256093f, -0.06068433f, -0.24868251f, 0.25591832f, 
    -0.16342914f, -0.02349629f, 0.11465281f, 0.30040622f, 0.20231740f, 0.47135371f, 0.34679624f, 0.51328123f, 
    -0.41216925f, -0.83695972f, -0.66396493f, -0.80776387f, 0.40719488f, 0.20741871f, 0.52481198f, -0.35204741f, 
    0.14419113f, -0.13406235f, 0.01752465f, -0.48265156f, -0.28244802f, -0.10923503f, -0.11466872f, 0.22058344f, 
    0.19347684f, -0.17007530f, -0.13955833f, 0.03699499f, -0.50873703f, -0.47846031f, -0.31659156f, -0.28764585f, 
    -0.42992565f, 0.16362011f, 0.61141646f, -0.61736369f, -0.35221899f, 0.27604577f, -0.30151001f, -0.17696236f, 
    -0.26068151f, 0.03335616f, -0.09941848f, -0.31251210f, 0.27143735f, 0.10021937f, 0.01862663f, 0.02901758f, 
    0.13190365f, 0.07056881f, 0.19423783f, -0.21259584f, -0.01897181f, -0.10026868f, 0.07063145f, -0.57438791f, 
    -0.25370309f, 0.57080883f, 0.25453231f, 0.54395837f, 0.43099108f, 0.26618272f, 0.44686636f, 0.16428272f, 
    -0.29636812f, -0.35762078f, -0.11371891f, -0.03913466f, 0.38255924f, 0.12342709f, -0.30750725f, 0.34048855f, 
    -0.19565584f, -0.14661640f, -0.08999785f, 0.33322236f, -0.27967501f, -0.38675579f, 0.66335529f, 0.66435349f, 
    0.48903501f, 0.22166751f, -0.39111298f, 0.61402589f, 0.19555388f, 0.18199962f, -0.05402424f, 0.02624696f, 
    0.56291038f, 0.34406227f, 0.03145000f, -0.27949175f, -0.07071661f, -0.27057108f, -0.27956057f, 0.19074014f, 
    0.13877130f, 0.15384693f, -0.03897990f, 0.46227512f, 0.06788024f, -0.03937918f, 0.40147856f, -0.92491525f, 
    -0.03311684f, 0.24061108f, 0.44355699f, -0.68750638f, 0.13510238f, 0.47242975f, 0.15672064f, 0.09183696f, 
    -0.03257743f, -0.44711468f, 0.29008785f, 0.29194388f, -0.13479066f, -0.32880107f, -0.34884858f, -0.09004275f, 
    -0.20578471f, 0.02318316f, -0.02620035f, 0.20208390f, -0.06698114f, 0.20155004f, 0.13394596f, -0.01929536f, 
    0.89701635f, -0.42651123f, 0.56281048f, 0.59574848f, 0.00746736f, -0.51620400f, 0.54234135f, -0.52254927f, 
    0.19185111f, 0.36407095f, -0.07150470f, -0.00063348f, -0.36123273f, -0.02100964f, 0.19354205f, -0.37612334f, 
    -0.08425067f, 0.22463912f, 0.19373293f, 0.07345176f, -0.30311012f, 0.22819148f, 0.15322247f, -0.33487114f, 
    0.22483215f, -0.36018908f, -0.18551734f, -0.60135329f, -0.49866435f, -0.48854309f, 0.41365629f, 0.43961391f, 
    0.13070583f, -0.24248709f, 0.59578437f, -0.53842473f, -0.09948406f, -0.61925429f, -0.35823861f, -0.58014482f, 
    -0.19728003f, -0.09357777f, 0.23510037f, -0.15035084f, -0.22955450f, -0.13241012f, -0.09429043f, -0.28500363f, 
    0.00406537f, 0.24775720f, 0.78605896f, -0.44909534f, -0.17339912f, 0.21561761f, 0.37085921f, -0.31117743f, 
    -0.61845684f, 0.51328874f, 0.33751905f, -0.36239868f, -0.01970017f, -0.06724963f, -0.28352031f, -0.27707228f, 
    -0.33330044f, -0.07547612f, 0.39459294f, 0.08684036f, 0.34600103f, 0.35249823f, 0.09591126f, 0.00210852f, 
    0.34120223f, -0.24484512f, -0.30587494f, 0.77780235f, 0.57214320f, 0.66122544f, 0.45557553f, -0.62205595f, 
    -0.06723607f, -0.27293828f, 0.27944717f, 0.25609782f, 0.13077056f, -0.27098030f, -0.21363595f, 0.16700985f, 
    -0.12491639f, -0.45594159f, -0.16357356f, 0.20627971f, 0.03431672f, -0.31283581f, -0.09725916f, -0.07728583f, 
    -0.12185073f, -0.30457422f, -0.37254369f, -0.40295389f, 0.30188218f, -0.62150532f, 0.41297656f, 0.66021687f, 
    0.73589271f, -0.34855688f, 0.25844917f, 0.45155913f, -0.48930541f, 0.15565844f, 0.51624852f, 0.33578929f, 
    -0.06616434f, 0.07759376f, 0.25975391f, -0.28017950f, -0.02714746f, 0.25375575f, -0.06581343f, 0.28986794f, 
    0.00951202f, 0.20755148f, 0.28520295f, -0.06068106f, -0.01495778f, -0.44535631f, -0.43426478f, -0.04697817f, 
    -0.46606982f, 0.45889449f, -0.66317779f, -0.20977198f, -0.51977539f, -0.36001226f, -0.01269559f, 0.47615507f, 
    0.25791353f, -0.06644406f, 0.20481293f, 0.03152167f, -0.07822923f, -0.14076662f, 0.01964314f, -0.20515242f, 
    0.42288059f, 0.04315720f, 0.24790311f, 0.02525875f, 0.48771653f, 0.20541137f, 0.41485918f, 0.41174641f, 
    -0.51517606f, -0.62347716f, -0.74680972f, 0.83382779f, 0.43285972f, 0.21602000f, 0.73565531f, 0.29221702f, 
    -0.23849453f, -0.49713483f, -0.30171576f, -0.35765883f, 0.13534439f, -0.08676826f, -0.08541444f, -0.13983069f, 
    0.21003795f, 0.13081303f, -0.00064911f, -0.33428943f, -0.27038985f, -0.37914482f, -0.11491498f, 0.51498139f, 
    -0.81630921f, 0.54949325f, 0.71018475f, 0.63934648f, 0.28648070f, 0.49469727f, 0.59204704f, 0.28928605f, 
    -0.27778569f, -0.20024802f, -0.12116706f, -0.17056847f, 0.27624923f, -0.05769689f, -0.17853020f, -0.15919320f, 
    -0.19326702f, -0.04677578f, -0.16564739f, -0.07390173f, 0.07486865f, -0.20634785f, 0.12355257f, -0.06712354f, 
    -0.29896230f, -1.11556423f, -0.50107825f, 0.01041237f, 0.03191398f, 0.68620259f, 0.21227455f, 0.56450397f, 
    0.26129347f, 0.01458387f, -0.14342038f, 0.23805031f, -0.14786939f, 0.41374370f, 0.14085044f, -0.21634433f, 
    0.15759644f, 0.17941092f, -0.17751284f, 0.13358860f, -0.07992547f, -0.01838300f, 0.41869515f, -0.04078756f, 
    0.09742530f, 0.09171631f, -0.03402365f, 0.03123493f, 0.74039924f, 0.38976616f, -0.36322516f, -0.30894336f, 
    0.11088162f, 0.28922236f, 0.24948911f, -0.53119206f, 0.32988247f, -0.15702613f, 0.38399225f, 0.18752509f, 
    0.43272245f, -0.17010932f, -0.16577022f, -0.22177540f, -0.34723723f, 0.18272379f, -0.02432972f, -0.05388923f, 
    0.12248001f, 0.10175142f, 0.55443931f, -0.64495587f, 0.18665156f, 0.51768166f, 0.27825680f, 0.83311218f, 
    -0.51872718f, -0.33690491f, 0.40730944f, -0.18793964f, -0.23540677f, -0.14112379f, -0.39536804f, 0.22695805f, 
    -0.05610950f, 0.29131642f, 0.15680085f, 0.20302293f, 0.05775794f, -0.02014076f, -0.12424822f, -0.15904497f, 
    -0.00797652f, -0.11747981f, 0.01593823f, -0.04438305f, 0.52935690f, -0.49342009f, -0.09054157f, 0.65657884f, 
    0.71608675f, -0.59506756f, -0.46250731f, 0.20433703f, 0.38168779f, 0.05397861f, -0.15301234f, -0.52083772f, 
    0.14700958f, -0.23051925f, -0.10438499f, 0.02560907f, -0.00758929f, -0.06219215f, -0.16540378f, 0.15955642f, 
    0.15651706f, 0.12279724f, 0.21034108f, 0.24152245f, 0.51179475f, 0.72722763f, 0.34135899f, 0.73544008f, 
    0.33391711f, -0.32250294f, -0.01261266f, 0.20161577f, -0.03503215f, 0.38083887f, 0.35801065f, 0.25937295f, 
    0.09930164f, -0.33030674f, 0.23383713f, -0.02281918f, 0.15133880f, 0.26550204f, -0.10707780f, -0.17684373f, 
    0.06372608f, 0.12205519f, 0.02233366f, 0.14648767f, -0.12026376f, -0.51042712f, -1.31525230f, -0.37161228f, 
    0.40182441f, 0.25762847f, -0.64164054f, 0.60797679f, 0.77962768f, -0.77707142f, 0.05120049f, 0.29444844f, 
    0.14554201f, -0.04071763f, -0.11659531f, 0.13606882f, -0.30819178f, 0.05259506f, -0.21653432f, 0.09538806f, 
    -0.16248183f, -0.01449905f, -0.11754451f, 0.06568801f, 0.03026866f, -0.03960222f, -0.49652901f, 0.18784884f, 
    0.18429521f, 0.12838921f, -0.75739080f, 0.29492119f, -0.44131932f, -0.84414268f, -0.58026189f, -0.06179222f, 
    -0.16770513f, -0.08994930f, 0.15024669f, -0.06443226f, 0.29949811f, -0.10061598f, -0.02213839f, 0.32109627f, 
    0.01728418f, -0.33584043f, 0.09803320f, 0.26031625f, 0.12787476f, 0.03131340f, -0.07897372f, -0.72356135f, 
    0.40719500f, -0.43837592f, -0.15751523f, -0.15736645f, -0.01490850f, -0.32642707f, 0.20445842f, 0.30922568f, 
    -0.58377510f, 0.33640534f, -0.11846276f, -0.07471180f, 0.58718258f, -0.13299567f, 0.10352228f, 0.05018394f, 
    -0.01305100f, -0.30004480f, -0.10175934f, -0.03070431f, 0.14558218f, -0.13076767f, 0.24271950f, 0.22068520f, 
    1.04488039f, 0.18467811f, -0.01807336f, 0.59408468f, 0.64788401f, 0.17662346f, 0.33751434f, 0.00783348f, 
    0.37492058f, 0.42558375f, -0.48530340f, -0.15009694f, -0.28352717f, -0.13942620f, 0.15819386f, 0.01946811f, 
    -0.10195585f, -0.26585215f, -0.01249150f, 0.16464213f, -0.22410277f, -0.14832172f, 0.07739218f, 0.07348070f, 
    -0.30893502f, -0.64982510f, -0.63529170f, -0.57740104f, -0.26749036f, -0.17360623f, 0.50568491f, 0.43836436f, 
    0.15771763f, 0.38140297f, 0.66979122f, -0.11167111f, -0.33426186f, 0.23552456f, -0.07914179f, 0.26502585f, 
    -0.11286556f, -0.01441424f, 0.27168736f, 0.08768584f, -0.13751778f, -0.06839766f, -0.34533322f, -0.14051996f, 
    -0.16684826f, 0.02963326f, -0.75178474f, 0.33657759f, -0.47549129f, -0.21428053f, -0.52072877f, 0.39496866f, 
    0.36038151f, -0.33574536f, 0.60786760f, 0.23820533f, 0.04139199f, 0.20342797f, -0.05913808f, 0.14424220f, 
    -0.55028367f, 0.02981397f, 0.14790744f, 0.04646112f, -0.11253162f, 0.01223792f, -0.10477144f, -0.32194459f, 
    -0.19201565f, -0.42524850f, -0.08943973f, 0.91066343f, 0.42813963f, -0.59773952f, -0.06096698f, -0.96017599f, 
    -0.50961071f, -0.07888176f, -0.33297497f, 0.28297889f, -0.13820897f, 0.00174318f, 0.12853558f, 0.55110455f, 
    0.10385854f, -0.04252850f, -0.00548114f, -0.04469922f, -0.25242734f, 0.22790472f, 0.17008787f, -0.07692485f, 
    0.10885327f, 0.18631130f, 0.07259905f, 0.22223334f, -0.25398001f, -0.22699338f, -0.23105489f, -0.16916567f, 
    -0.41440266f, -0.44734058f, -0.00093612f, -0.12949072f, 0.24810396f, 0.54795927f, -0.54510331f, 0.34250233f, 
    0.12478286f, 0.08911677f, -0.11461487f, 0.32024366f, -0.16534185f, 0.26748309f, 0.07452677f, 0.38942987f, 
    -0.29821250f, -0.14521642f, -0.57817256f, 0.00459266f, -0.46225560f, 0.21117206f, 0.15864921f, 0.77122658f, 
    -0.19803369f, -0.67883122f, 0.12771805f, -0.65993387f, 0.19404261f, -0.52783310f, -0.45234382f, 0.10303953f, 
    0.01523971f, -0.08011234f, 0.51027340f, -0.12038499f, 0.30521873f, -0.20053419f, 0.09821034f, 0.21508184f, 
    0.26950440f, -0.33554530f, 0.18563959f, 0.33295321f, -0.06077325f, 0.04528481f, -0.53260350f, 0.54878259f, 
    0.95246351f, -0.30723384f, -0.61988932f, -0.62814873f, 0.71298563f, -0.33698282f, -0.16749337f, 0.44576567f, 
    0.05200190f, 0.52690494f, -0.36504295f, -0.09569046f, 0.23044837f, 0.28192836f, -0.03620832f, -0.02533073f, 
    -0.17759947f, 0.06427307f, -0.04256253f, 0.16026250f, 0.24598280f, -0.04047532f, 0.19837472f, -0.29201639f, 
    -0.00562050f, 0.28057852f, -0.66447973f, -0.69100398f, 0.51310241f, -0.43852416f, 0.15890683f, 0.39057520f, 
    0.39056331f, 0.26909783f, 0.21171790f, -0.16470684f, 0.27080435f, -0.17497864f, -0.26192576f, -0.23048282f, 
    -0.20200007f, 0.00434424f, -0.14996929f, 0.30953532f, 0.20805268f, 0.06012384f, 0.03372939f, 0.07082360f, 
    -0.39138588f, -0.40286428f, -0.62351876f, -0.79399508f, 0.02465128f, -0.54236370f, -0.56205589f, -0.37875775f, 
    0.03307164f, 0.25544310f, -0.00056124f, -0.38472870f, 0.27465460f, -0.17886902f, -0.13029426f, 0.01420065f, 
    0.43745646f, -0.07113115f, 0.34420201f, 0.46318945f, -0.33852202f, -0.02855732f, -0.13844743f, 0.11483440f, 
    0.23480417f, 0.41540697f, 0.74384874f, 0.49715844f, 0.42307857f, 0.41048822f, -0.49187136f, -0.13633670f, 
    -0.16099690f, 0.28875515f, -0.17146699f, -0.32050082f, -0.19850557f, -0.19287319f, -0.13368030f, 0.32407880f, 
    0.13191976f, -0.05516842f, 0.09908235f, 0.24325962f, 0.04383533f, 0.17327961f, 0.34767291f, 0.19121350f, 
    0.11139386f, 0.53118736f, -1.13820064f, 0.67474586f, 0.58655608f, -0.60269761f, 0.59227651f, 0.15111227f, 
    0.90679359f, 0.53128976f, 0.20049725f, 0.45737654f, -0.18629581f, -0.02081054f, -0.20649964f, -0.22570620f, 
    0.03108337f, 0.27409545f, -0.18668021f, -0.07512105f, 0.18756755f, 0.05037516f, 0.16495021f, 0.06903829f, 
    0.02588905f, -0.12239882f, 0.04874058f, -0.37033939f, 0.07753067f, 0.95716757f, -0.18519719f, 0.68944746f, 
    0.87759823f, -0.01745996f, 0.22798307f, -0.00596069f, -0.23082595f, -0.04664592f, -0.00086693f, 0.06119956f, 
    0.07315291f, -0.40141973f, -0.02511279f, -0.00736893f, 0.21163763f, 0.02243237f, 0.10758393f, -0.21235217f, 
    0.38350168f, 0.15068676f, 0.04881100f, 0.18899629f, 0.49770832f, -0.65183216f, -0.21650903f, 0.99989343f, 
    -0.49532542f, 0.58847857f, 0.64216530f, 0.24212536f, 0.11974850f, 0.22137345f, -0.22724636f, 0.04802924f, 
    0.13618024f, -0.17086940f, -0.20738558f, -0.47161651f, -0.07093217f, -0.11609916f, -0.08426810f, -0.07762495f, 
    0.07060181f, 0.20801613f, -0.00420612f, 0.09649095f, -0.13606061f, -0.08182286f, -0.59364027f, -0.72045982f, 
    -0.05980668f, -0.26975518f, -0.77360803f, 0.86449510f, 0.01071281f, 0.03477184f, 0.12783545f, 0.16562614f, 
    0.01392630f, 0.09460158f, 0.39877430f, 0.45071068f, -0.51481223f, -0.25715941f, 0.21536352f, -0.30793139f, 
    -0.33572170f, 0.19743986f, -0.03066408f, 0.21112871f, 0.04431058f, -0.03910033f, -0.68068534f, -0.46104759f, 
    0.67848462f, 0.54559517f, -0.84097981f, 0.32165721f, -0.07335569f, 0.27697796f, -0.34187147f, -0.06561685f, 
    0.07480991f, -0.21308616f, -0.23494452f, -0.11431046f, 0.24691817f, 0.15015563f, -0.16449116f, -0.25251380f, 
    -0.25347501f, -0.01835077f, 0.22225818f, 0.46597725f, 0.15263136f, 0.15790886f, -0.22716747f, 0.23046337f, 
    -0.71552259f, 0.43088007f, 0.25691935f, 0.29595214f, -0.50213957f, 0.78945750f, 0.47890893f, 0.48428553f, 
    -0.07334006f, -0.00900706f, -0.29640254f, -0.34173986f, -0.36050689f, -0.28698969f, -0.40474275f, -0.40061766f, 
    -0.33898684f, 0.25413498f, -0.19166185f, -0.06873409f, 0.20016013f, 0.01091118f, -0.03141174f, -0.00552726f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.04098809f, 0.24379419f, 0.13635638f, 0.04824038f, 0.26461068f, -0.00213855f, 0.08494536f, 0.15468040f, 
    0.08139432f, 0.16771591f, 0.19351257f, 0.02289916f, 0.14132780f, 0.19789180f, -0.07101323f, -0.02456013f, 
    0.07187030f, 0.21250407f, 0.32126763f, 0.17015055f, 0.00973526f, 0.01349153f, 0.20002620f, 0.19553433f, 
    0.10656022f, 0.25629690f, 0.14544272f, 0.14665866f, 0.00060558f, 0.17211759f, -0.02160985f, 0.07948407f, 
    0.18179312f, -0.01297359f, -0.16144525f, 0.09355555f, -0.05007211f, -0.01055157f, -0.09531914f, 0.05969078f, 
    0.24197236f, 0.17584103f, 0.17302217f, 0.12620144f, 0.17675555f, 0.21951051f, 0.20574334f, 0.24140465f, 
    0.09954249f, -0.10005233f, 0.11205752f, 0.20021576f, 0.01329672f, 0.05799248f, 0.04215027f, 0.10214352f, 
    0.09251103f, -0.00664041f, 0.06416630f, 0.10190446f, 0.08571313f, 0.15115626f, 0.02535469f, 0.01781918f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00004540f, 0.00616393f, -0.08061321f, 0.11343488f, -0.08115183f, 0.00753634f, 0.03683681f, 0.02583826f, 
    0.05598867f, -0.02715977f, 0.03787298f, -0.04013780f, -0.41811064f, -0.16397926f, 0.11719242f, -0.11529453f, 
    -0.06191387f, -0.02828867f, -0.12100840f, -0.08432761f, -0.10120776f, 0.02271738f, 0.11566728f, -0.09638847f, 
    -0.24579045f, -0.00886262f, -0.05868717f, -0.06033154f, -0.02442879f, -0.00513177f, 0.06196263f, 0.07470236f, 
    0.02332406f, 0.01579125f, -0.15075833f, 0.06701241f, 0.21533377f, -0.17971626f, -0.06002886f, -0.01479613f, 
    -0.11447918f, 0.01173239f, -0.14639521f, 0.07127282f, -0.06871609f, 0.02665142f, -0.04855813f, 0.09168303f, 
    0.05031976f, 0.00343943f, -0.09715370f, -0.11920184f, 0.00617136f, 0.03530100f, 0.03349581f, -0.08145185f, 
    0.04072168f, -0.01914409f, 0.03448882f, -0.04839478f, 0.28168187f, 0.23561832f, 0.07375203f, -0.07405547f, 
    -0.07678702f, 0.09857036f, 0.06338663f, -0.01537594f, 0.03066502f, 0.00849272f, 0.00497234f, 0.03167032f, 
    -0.06920143f, -0.09850499f, -0.10343364f, 0.21195760f, 0.10276242f, 0.02218098f, 0.08368382f, -0.08149711f, 
    -0.33992609f, 0.04462683f, -0.02836756f, -0.02320791f, 0.17441393f, 0.12499844f, -0.02467969f, 0.10280183f, 
    -0.15000828f, -0.02610372f, -0.01891913f, 0.05092042f, -0.04389945f, 0.13385622f, -0.01402984f, -0.03145790f, 
    -0.10816560f, 0.02854213f, -0.21224530f, 0.26721808f, 0.06874879f, 0.00118552f, -0.06092583f, -0.07159828f, 
    0.00957202f, -0.15249197f, 0.02310547f, -0.03032643f, -0.13365363f, -0.26931897f, -0.01694435f, 0.13680811f, 
    -0.07095370f, -0.00730995f, 0.06676172f, 0.02002504f, -0.03096170f, 0.01653964f, -0.07314358f, 0.05130824f, 
    0.17658760f, -0.21228094f, -0.00310678f, -0.04713306f, -0.28551894f, -0.04714114f, -0.02054399f, -0.01726964f, 
    -0.03997644f, 0.06125681f, 0.00742236f, -0.02959971f, -0.00945763f, 0.03503434f, -0.14736457f, 0.11694515f, 
    -0.18856300f, -0.10873245f, 0.02489177f, 0.04506561f, 0.05492142f, 0.06329788f, -0.08166998f, -0.04897163f, 
    -0.07164577f, -0.09682614f, 0.04435414f, 0.21982105f, 0.01333345f, 0.01835126f, 0.08679897f, -0.11109492f, 
    -0.15812549f, 0.07509737f, -0.11988414f, 0.03256339f, -0.13842471f, 0.09089036f, 0.06680121f, -0.46184772f, 
    -0.10374499f, -0.03748739f, -0.06266288f, -0.00890140f, -0.06212526f, -0.02696870f, 0.00072452f, 0.04366099f, 
    -0.05104608f, -0.01797986f, 0.27713114f, -0.16139747f, -0.04461054f, -0.16904747f, 0.05227404f, -0.08869375f, 
    0.13917243f, 0.05062298f, 0.00564389f, 0.00918609f, 0.15048186f, 0.17272487f, 0.00226416f, 0.04913243f, 
    -0.06690684f, 0.02829322f, -0.02300536f, -0.03295846f, -0.03886098f, -0.06559248f, 0.07818376f, -0.10809814f, 
    0.23710899f, -0.01240532f, 0.00018006f, 0.08718935f, -0.05055090f, 0.01162831f, -0.04989651f, 0.13932332f, 
    -0.02303487f, 0.10151652f, -0.06795564f, -0.02927791f, -0.24503051f, -0.06408954f, -0.04325869f, 0.10758020f, 
    -0.07277229f, -0.05304837f, 0.00398226f, 0.03707188f, -0.07404719f, -0.05691432f, -0.12608460f, 0.02722251f, 
    -0.25735343f, 0.14407276f, 0.10128394f, -0.36287495f, 0.00303788f, 0.04006514f, 0.05236635f, -0.01089708f, 
    -0.08874339f, -0.11188873f, 0.07309973f, -0.02982497f, -0.45053834f, -0.00430932f, 0.17419714f, -0.02468824f, 
    -0.05420791f, -0.00672510f, 0.05210861f, -0.08858424f, 0.14265440f, 0.05701895f, -0.07533514f, -0.03638434f, 
    0.39443451f, 0.07579583f, -0.09483279f, -0.13297473f, 0.03297088f, 0.09526783f, -0.05178204f, 0.04182700f, 
    0.02950295f, -0.02133572f, -0.06250408f, -0.04968516f, 0.22568768f, -0.01267975f, 0.13978969f, -0.15910943f, 
    -0.00377170f, 0.05449439f, -0.03651518f, 0.00288877f, 0.08022839f, -0.09614796f, 0.09057178f, 0.09128286f, 
    0.06210675f, -0.29101387f, -0.02447414f, -0.03729830f, -0.09523141f, 0.05991780f, -0.01990583f, 0.02177933f, 
    -0.06631038f, -0.04263701f, -0.06481222f, -0.08170041f, -0.23930499f, 0.04260143f, 0.08458038f, -0.05391492f, 
    0.08094119f, 0.10574293f, -0.07804228f, 0.06592720f, 0.05809819f, 0.04987670f, 0.09403069f, -0.14070581f, 
    0.14966576f, -0.22402354f, 0.15840927f, -0.26687732f, -0.10741392f, 0.02936185f, 0.02679965f, -0.04752931f, 
    -0.05205659f, -0.04542611f, -0.02862132f, -0.00500927f, 0.00567536f, -0.02534971f, -0.00606891f, -0.04227231f, 
    -0.11133716f, -0.13915081f, 0.07243530f, 0.01580330f, -0.03753406f, -0.02372248f, -0.02406490f, -0.04915226f, 
    0.12418184f, 0.03934781f, -0.03116552f, -0.09141500f, -0.11215869f, 0.01619882f, -0.06001569f, 0.09818673f, 
    0.00373075f, -0.00496072f, -0.08376645f, -0.13536839f, 0.13819328f, 0.01935240f, 0.14045283f, 0.02476703f, 
    -0.14082380f, -0.07091079f, -0.01461607f, -0.00184698f, -0.12686056f, -0.03431438f, 0.04003904f, 0.05948611f, 
    0.13387045f, -0.13913278f, 0.11546707f, -0.14300750f, 0.01728701f, 0.03689238f, -0.05039084f, 0.05710157f, 
    -0.05198445f, -0.02123007f, 0.05633815f, -0.00001490f, 0.05160136f, 0.14673536f, 0.20301278f, -0.10961581f, 
    -0.05023014f, 0.14733875f, -0.00376694f, -0.14249426f, -0.09231438f, 0.04364798f, -0.01881558f, -0.01809657f, 
    0.05594977f, -0.03437092f, -0.04220502f, 0.07831357f, -0.06109374f, -0.01346504f, -0.00076764f, -0.00561391f, 
    -0.04127392f, -0.00610117f, -0.12762934f, 0.10342304f, 0.08380171f, 0.21742323f, 0.00491899f, 0.18567573f, 
    0.05400268f, -0.00163697f, -0.03081174f, -0.14424185f, 0.01835955f, -0.06939547f, -0.02150493f, -0.04453364f, 
    0.15643243f, -0.18571943f, -0.07993723f, 0.32274586f, -0.11375201f, -0.11175322f, 0.01378222f, 0.02348782f, 
    -0.02412594f, 0.13789830f, -0.10310490f, 0.00321065f, 0.20090015f, 0.09687890f, 0.02792166f, -0.27351230f, 
    0.01935825f, -0.01195270f, 0.01995445f, 0.01901188f, -0.01207139f, 0.02068800f, -0.00872493f, -0.03509414f, 
    0.27142599f, -0.02131522f, 0.08781979f, 0.12551628f, -0.00084042f, 0.08756776f, -0.14996284f, 0.00373984f, 
    0.01351972f, -0.06789372f, 0.06732100f, -0.09305148f, -0.02005453f, 0.03833147f, -0.18813094f, 0.19231899f, 
    -0.04052801f, -0.11195826f, -0.01119537f, -0.04767786f, 0.02404812f, 0.00701773f, -0.00516677f, -0.00154417f, 
    0.05870653f, -0.01554289f, -0.22152801f, 0.16696016f, -0.16881393f, 0.10038745f, -0.08885656f, -0.00859162f, 
    -0.04443246f, -0.08143669f, 0.00175532f, 0.08630759f, -0.18268451f, -0.19113329f, -0.12566736f, 0.04079220f, 
    -0.06251206f, 0.02885957f, 0.00537313f, 0.04656532f, 0.12746406f, -0.01663657f, -0.03087709f, 0.04184819f, 
    0.32072276f, 0.03789123f, -0.01372837f, -0.17280613f, 0.05699519f, 0.07477768f, -0.01223667f, -0.09936661f, 
    0.01571426f, 0.09501225f, 0.07590049f, 0.13070104f, 0.06839915f, 0.08426065f, -0.16712853f, 0.17215000f, 
    -0.04660239f, 0.00105865f, 0.14203586f, -0.10175043f, 0.04076287f, -0.04939075f, -0.00684011f, -0.11345384f, 
    0.07482915f, 0.07339543f, -0.07391434f, -0.14121160f, 0.14254209f, 0.03425314f, -0.02864310f, 0.04602833f, 
    -0.09801085f, -0.05426217f, 0.00368265f, -0.01059956f, 0.00644350f, -0.01606803f, -0.14029121f, 0.09047952f, 
    0.03238258f, 0.00015515f, -0.01102352f, -0.02073988f, -0.10004808f, 0.05675202f, 0.04445119f, -0.09431092f, 
    0.15119094f, -0.27951530f, 0.01811681f, 0.27650625f, 0.10564563f, -0.05357445f, -0.02106765f, 0.02434092f, 
    -0.04672394f, 0.00162962f, -0.11044695f, 0.03166196f, 0.08989809f, -0.17440332f, 0.35001293f, 0.08161298f, 
    -0.00814383f, 0.01724754f, -0.02127325f, -0.03204608f, -0.03342220f, 0.07192200f, 0.03451349f, 0.02162666f, 
    0.08404920f, 0.09372170f, -0.03717167f, 0.02453220f, -0.18925872f, -0.03359168f, 0.07215768f, -0.05943757f, 
    0.01463583f, 0.07869361f, -0.02329192f, -0.02531266f, -0.49807405f, 0.09147234f, -0.19340476f, 0.12941533f, 
    -0.03757680f, 0.03246051f, -0.15426014f, -0.00802185f, 0.06286244f, -0.03890250f, -0.01427584f, 0.00954796f, 
    -0.08946723f, 0.21218432f, 0.01197551f, -0.04115614f, -0.02410430f, -0.02393135f, 0.00101382f, -0.07264309f, 
    -0.02504936f, 0.12937836f, -0.05435718f, 0.01331066f, -0.10561045f, -0.09670028f, -0.12967882f, -0.01105836f, 
    -0.02345916f, -0.03201177f, -0.02703627f, -0.07170262f, 0.05381851f, 0.07693851f, -0.08193213f, 0.04108586f, 
    0.16811411f, -0.08891469f, -0.02292958f, 0.27158698f, -0.16006345f, 0.01595660f, -0.09252774f, 0.04262467f, 
    -0.07962047f, -0.01399874f, 0.06616278f, -0.03103952f, 0.28382418f, 0.16282934f, -0.07255267f, -0.11853700f, 
    0.12862357f, -0.01391637f, 0.03595947f, 0.01067851f, 0.07678924f, -0.08020689f, -0.01875111f, 0.11304794f, 
    0.38747743f, 0.17817608f, -0.19952051f, -0.16326684f, 0.10272658f, -0.00274365f, 0.00625901f, -0.02424146f, 
    0.06202355f, 0.01359389f, -0.12794441f, -0.07282235f, -0.30434227f, -0.07548632f, 0.14578353f, -0.02140737f, 
    -0.07645192f, 0.02438993f, 0.00558932f, 0.03909709f, 0.03374930f, -0.03650738f, 0.03943032f, 0.04697621f, 
    0.11699409f, -0.17888908f, -0.08284046f, -0.08182733f, -0.02802272f, 0.00278161f, -0.00772958f, -0.00374063f, 
    -0.01626522f, -0.04611658f, -0.01598675f, 0.05188825f, -0.29429534f, 0.18246958f, -0.00302905f, 0.11868248f, 
    0.00120477f, -0.02472840f, -0.11284383f, 0.06068327f, -0.03100140f, -0.03549709f, -0.09600152f, 0.04725688f, 
    -0.12017284f, 0.06634681f, 0.12063363f, 0.06866288f, 0.05957983f, 0.03973111f, -0.07602669f, 0.00692769f, 
    0.07776371f, 0.12066004f, 0.03271499f, 0.00485773f, 0.02276753f, -0.11859152f, -0.14646755f, -0.07479355f, 
    0.07249517f, -0.04081289f, 0.05699602f, -0.12619278f, 0.00717077f, 0.02067587f, 0.07130656f, 0.01727647f, 
    -0.06272739f, -0.18027461f, 0.06409145f, -0.12732567f, -0.12461378f, 0.03155750f, 0.06398766f, 0.05096315f, 
    -0.09382376f, -0.03790740f, 0.11283541f, -0.07170489f, 0.03916240f, 0.03825532f, -0.02783865f, 0.01192287f, 
    -0.07634616f, -0.04993431f, -0.05140881f, 0.01242649f, -0.09456688f, 0.03063305f, -0.16120228f, 0.05203038f, 
    0.06483788f, 0.01903959f, 0.27373382f, -0.12536986f, 0.01288216f, 0.09512634f, 0.11537251f, -0.15043432f, 
    -0.04098500f, -0.09510307f, -0.06731466f, 0.06849516f, -0.16708243f, -0.12365173f, 0.18462214f, 0.00215966f, 
    -0.06495509f, 0.02228301f, -0.01018426f, -0.18589300f, -0.06017246f, -0.01096501f, 0.03416863f, 0.00394189f, 
    -0.13417311f, 0.17178559f, -0.24779901f, 0.31991771f, -0.03632091f, 0.07227436f, -0.09778557f, -0.04554459f, 
    -0.12917687f, -0.01218144f, 0.07508844f, 0.08718272f, -0.30881736f, -0.01601035f, -0.05431120f, -0.05646421f, 
    -0.02818233f, -0.09172072f, -0.00435335f, -0.07781734f, 0.01043173f, 0.04956982f, 0.00982291f, 0.08613131f, 
    -0.21619393f, 0.10152109f, 0.01892349f, 0.21027935f, -0.04089370f, 0.05927261f, 0.04294858f, -0.05605865f, 
    0.01463768f, -0.02275543f, 0.07225232f, -0.04203727f, -0.01840565f, 0.13341445f, -0.02480354f, 0.17997144f, 
    -0.06636892f, -0.03046741f, 0.05536679f, -0.01612119f, 0.11089952f, 0.01327596f, -0.06387492f, 0.06049005f, 
    0.22144452f, 0.20535938f, 0.03296684f, 0.16505440f, -0.13070869f, 0.03254176f, 0.00817571f, -0.00957843f, 
    0.07403944f, 0.13569024f, -0.12181570f, 0.08421636f, 0.27512640f, -0.15091270f, -0.05064099f, -0.13484266f, 
    0.01206985f, -0.01519445f, 0.00871643f, -0.04343231f, -0.11185442f, 0.01150090f, -0.04955450f, -0.02973868f, 
    0.14745203f, -0.02840511f, 0.06733245f, -0.01187589f, 0.01020739f, -0.10604493f, -0.02046608f, -0.07043695f, 
    0.07538389f, -0.20234939f, 0.05240078f, -0.12257752f, -0.27893999f, -0.03879696f, -0.08824068f, 0.00054493f, 
    0.09689258f, -0.08428396f, -0.01791610f, 0.00517501f, 0.01121978f, 0.01072401f, -0.11570553f, -0.05673289f, 
    0.28536013f, -0.37252674f, -0.16938835f, -0.15072733f, -0.05483989f, -0.02546719f, 0.04997197f, -0.01298439f, 
    -0.05322278f, 0.03488072f, -0.08111724f, 0.12961233f, -0.80485970f, -0.21594840f, 0.05617973f, -0.18140809f, 
    -0.03491542f, -0.12358138f, 0.01696134f, -0.05718635f, 0.10674213f, -0.07201767f, -0.03843553f, -0.07552447f, 
    -0.25861982f, 0.09500770f, -0.15492438f, -0.04609768f, -0.17202659f, -0.00167573f, -0.09581318f, 0.02629160f, 
    0.00734240f, -0.17415620f, -0.01859943f, -0.24448723f, 0.16151400f, -0.04536885f, 0.11085649f, 0.13396055f, 
    -0.00305060f, 0.01920230f, 0.05843903f, 0.04952955f, 0.02134912f, -0.16522609f, 0.04198429f, -0.10169882f, 
    0.09180710f, -0.03949982f, -0.20208995f, 0.09802145f, 0.09490516f, -0.03403495f, 0.00944496f, 0.04128624f, 
    -0.14278926f, 0.00038755f, -0.02048824f, 0.08523081f, -0.14816727f, 0.00084059f, -0.02617042f, -0.03958630f, 
    0.01972702f, 0.07471950f, -0.12206926f, 0.08184878f, -0.00275844f, -0.00409393f, 0.18576434f, 0.10726731f, 
    0.05462527f, 0.16673194f, 0.07809364f, 0.05390636f, -0.00001608f, -0.07245484f, 0.01055019f, -0.01926969f, 
    0.07940271f, -0.05684341f, 0.02609717f, -0.05450865f, 0.13563812f, -0.13332431f, -0.13921551f, 0.07058925f, 
    0.04505687f, 0.08710938f, 0.02238403f, 0.03829594f, -0.00194820f, -0.08940187f, 0.12882839f, -0.14424814f, 
    -0.05411548f, 0.26951841f, -0.05368509f, -0.01072168f, -0.11086754f, -0.00643819f, -0.00051381f, -0.01899790f, 
    0.19359858f, 0.05053512f, 0.10971338f, -0.04529569f, 0.20123270f, -0.19091657f, 0.14307959f, -0.33274809f, 
    -0.02397172f, 0.03477799f, -0.03820034f, 0.11381253f, -0.01561660f, -0.05530348f, 0.07774461f, -0.01472771f, 
    0.09646430f, -0.22708468f, -0.09510212f, -0.20488884f, -0.04237838f, -0.02316930f, 0.02242879f, -0.14843100f, 
    -0.11875249f, -0.01622831f, 0.06161525f, -0.15424894f, -0.06918675f, -0.02637993f, -0.04729150f, 0.06473326f, 
    -0.02765947f, 0.00604746f, -0.02986613f, 0.00992130f, 0.09951278f, 0.16659676f, -0.08875707f, 0.17094827f, 
    0.19773169f, -0.10645385f, 0.05395113f, 0.27958304f, -0.01030767f, 0.00509396f, 0.06460162f, 0.00246775f, 
    0.06812515f, -0.09858447f, 0.04417885f, 0.04858749f, -0.03094524f, 0.05196373f, 0.06218981f, -0.08383956f, 
    -0.10705997f, 0.00115485f, 0.02243808f, 0.02581669f, -0.01350896f, 0.07698881f, -0.03784116f, -0.05215446f, 
    0.39958420f, -0.16496141f, 0.02724303f, -0.35946470f, -0.00182688f, -0.07686009f, 0.06547376f, -0.08740339f, 
    0.07021818f, -0.08397698f, 0.06018890f, 0.10565975f, 0.04802787f, -0.04797401f, -0.08247416f, -0.01331467f, 
    -0.04317116f, 0.04803246f, -0.05075801f, -0.05285529f, -0.06442432f, 0.05598176f, 0.02798024f, 0.02675419f, 
    -0.34135729f, 0.02709587f, -0.03063296f, -0.09284815f, 0.04143706f, -0.13393521f, -0.01489573f, 0.00165766f, 
    0.07490802f, 0.05759808f, -0.03024422f, 0.00338699f, 0.11091341f, -0.03326412f, -0.02793694f, -0.08132081f, 
    -0.00783244f, -0.09193267f, -0.00162268f, 0.12787078f, -0.12280729f, 0.03048445f, -0.04350968f, -0.07237734f, 
    -0.03129037f, 0.05624548f, 0.06355388f, -0.01958162f, 0.03400179f, 0.03289367f, 0.15021998f, 0.09270833f, 
    0.01366230f, 0.03775704f, -0.00140227f, -0.01428932f, -0.18565601f, 0.03520970f, -0.16517639f, -0.02551001f, 
    -0.08700407f, 0.05175316f, -0.04055629f, -0.08782069f, 0.06276925f, 0.03638335f, 0.04318935f, 0.10033681f, 
    -0.09895900f, 0.05528359f, 0.06889436f, -0.13437983f, -0.01160898f, -0.00604456f, -0.08639305f, 0.06453514f, 
    -0.04208185f, 0.03764392f, 0.00605766f, 0.00304258f, 0.21976307f, 0.15567948f, 0.11791474f, 0.10477956f, 
    -0.08884170f, 0.00246477f, -0.02337418f, 0.00062566f, 0.03269964f, -0.06464682f, 0.00280202f, -0.01152099f, 
    0.30103767f, -0.04889901f, 0.08799053f, 0.15244517f, 0.04396062f, -0.12953965f, 0.11462308f, 0.04293034f, 
    -0.02119011f, -0.09348507f, -0.09260464f, 0.07324609f, -0.08454850f, -0.10638235f, 0.07423041f, -0.09436364f, 
    0.06746937f, 0.06044491f, 0.03747838f, 0.09658247f, 0.00216572f, 0.01538833f, -0.09871262f, -0.06113360f, 
    -0.08154293f, 0.04542483f, -0.15839329f, -0.03296902f, 0.09673816f, -0.15817024f, 0.07021141f, 0.02342529f, 
    0.06971166f, 0.13003203f, 0.01669692f, -0.10879908f, 0.14085968f, -0.09117736f, 0.05823185f, -0.06560072f, 
    0.01027596f, -0.01581805f, -0.08648305f, 0.07018535f, 0.11073420f, -0.00608412f, 0.00673246f, 0.01890423f, 
    0.07394672f, 0.02713595f, 0.14625889f, 0.09141387f, -0.23118944f, -0.01261711f, 0.04177376f, -0.00121700f, 
    -0.01762548f, 0.00800642f, 0.03489639f, -0.08224782f, -0.33037183f, -0.04815441f, -0.17895925f, 0.04867356f, 
    -0.01976704f, -0.02909203f, -0.02169147f, -0.02154568f, 0.00191193f, -0.02728846f, 0.01589124f, -0.02322173f, 
    0.26127023f, -0.01470107f, -0.06622352f, 0.07426092f, 0.00332238f, -0.06734188f, 0.05614473f, -0.07966765f, 
    0.01577640f, -0.03870809f, -0.00672330f, 0.01095423f, -0.10108495f, -0.07611617f, -0.04322657f, -0.08084218f, 
    0.07167220f, -0.04791168f, -0.05170268f, -0.17636286f, 0.10787532f, -0.03137700f, -0.01706303f, -0.10580301f, 
    0.11158893f, -0.14582394f, 0.08087303f, 0.05453237f, -0.15437481f, -0.15093996f, 0.00537182f, 0.02953406f, 
    0.00859571f, 0.04791343f, -0.05662344f, 0.02538686f, 0.15315129f, 0.03478473f, -0.00362140f, 0.02058790f, 
    -0.09162218f, -0.12451985f, -0.00031292f, -0.00710704f, 0.02055898f, -0.12851255f, 0.02193458f, -0.08595786f, 
    -0.15028399f, -0.05307766f, 0.14562416f, 0.17268167f, -0.11464962f, -0.07475437f, 0.00659283f, 0.08817239f, 
    -0.09829631f, 0.02749590f, 0.15668452f, -0.09851851f, -0.00261666f, -0.07893323f, 0.05562498f, -0.13329965f, 
    0.12023408f, 0.06202849f, -0.09381034f, 0.06111849f, 0.06051603f, -0.02100622f, 0.04871508f, -0.10405051f, 
    -0.05794412f, -0.21682130f, 0.07057968f, -0.03560624f, 0.22069088f, -0.12599571f, -0.12029608f, 0.08209643f, 
    -0.02364346f, 0.02391970f, -0.11800790f, -0.03767268f, 0.16604473f, -0.01349348f, 0.08517741f, 0.16367038f, 
    -0.03437899f, 0.08442611f, 0.01128535f, 0.00908767f, 0.02134702f, 0.08772956f, -0.00831867f, 0.01064620f, 
    0.27067205f, -0.03017601f, -0.11259446f, 0.00613785f, -0.00770476f, 0.02715385f, -0.08959764f, 0.05087638f, 
    0.06669269f, -0.06461003f, 0.01531847f, 0.09754393f, 0.19699101f, -0.00579996f, 0.02163881f, 0.08239771f, 
    0.00004250f, 0.09086784f, -0.07684027f, 0.03450046f, 0.06540149f, -0.09657340f, -0.19104423f, 0.08916989f, 
    0.19760221f, 0.02861238f, 0.01252850f, -0.13261253f, 0.01870281f, 0.09064277f, -0.05866675f, 0.01918657f, 
    0.02721967f, -0.06096107f, 0.08778835f, 0.01026922f, 0.01434484f, -0.08923389f, -0.02671782f, -0.14828557f, 
    -0.01462094f, -0.00143155f, -0.02442594f, -0.06246981f, 0.07087053f, -0.03140977f, 0.01476036f, -0.11216737f, 
    0.17409495f, 0.03994376f, 0.13549784f, 0.29277509f, -0.14400703f, -0.01871252f, -0.01860448f, 0.06325407f, 
    -0.00378715f, -0.01231406f, 0.03124105f, 0.08978316f, 0.28209808f, -0.05395759f, 0.00622835f, 0.14892489f, 
    -0.12779020f, -0.03536568f, -0.01422146f, 0.03775272f, -0.09003428f, -0.05492259f, 0.01214494f, 0.01641002f, 
    -0.21871340f, -0.09956383f, -0.05915763f, -0.00085788f, -0.00925309f, -0.01836325f, 0.03712221f, -0.00840304f, 
    0.00553824f, -0.05639498f, 0.02372544f, 0.07130492f, -0.16762608f, 0.02894169f, -0.12947698f, 0.03514003f, 
    0.06725749f, 0.04908062f, -0.07282502f, 0.08718324f, 0.02634476f, -0.04764570f, 0.03261570f, -0.07322114f, 
    0.30505592f, -0.02133881f, 0.14191929f, 0.17379925f, -0.09713806f, 0.00087693f, 0.05846926f, -0.00379310f, 
    0.03927321f, 0.03739219f, -0.04584797f, 0.04263470f, 0.19833359f, 0.06694899f, 0.02255637f, -0.05572912f, 
    0.08240462f, 0.01581851f, -0.13602977f, 0.05349881f, -0.00569713f, 0.13938713f, 0.02660994f, 0.02541307f, 
    -0.33101717f, -0.09929068f, -0.04395904f, -0.04308361f, 0.01000993f, -0.08811019f, -0.05857843f, -0.01585865f, 
    0.02746172f, -0.03737138f, 0.09203725f, -0.01285276f, 0.34737799f, -0.35140792f, -0.13197412f, -0.17208989f, 
    0.05867294f, -0.12517564f, -0.05297809f, 0.12491324f, -0.14000718f, 0.03635057f, -0.01427814f, 0.05882920f, 
    -0.05661301f, -0.03644306f, -0.02493147f, -0.07349732f, 0.05132968f, 0.08328836f, -0.13182974f, -0.17464653f, 
    -0.06624809f, 0.02425942f, 0.02871718f, 0.02410548f, -0.10730381f, 0.08843775f, -0.17497966f, -0.13847759f, 
    0.03498809f, 0.01914006f, 0.06509832f, -0.17443562f, 0.06872141f, 0.09389844f, -0.00707338f, 0.11362200f, 
    -0.59768665f, 0.06913172f, -0.36031780f, -0.20411433f, -0.11444377f, -0.01636798f, 0.08538868f, -0.05724786f, 
    0.12981285f, -0.07493404f, -0.02189667f, -0.09794755f, -0.29061630f, -0.03074194f, -0.03698873f, -0.05551956f, 
    -0.02771356f, 0.07019401f, -0.02485618f, 0.10100233f, 0.03454680f, -0.06628218f, -0.02348574f, -0.08786186f, 
    0.15480474f, -0.11753108f, 0.04026155f, -0.29655552f, 0.07984092f, 0.03988268f, 0.05729831f, -0.00478730f, 
    -0.02475184f, 0.02247382f, 0.05245560f, 0.09657353f, 0.12158938f, 0.00383964f, -0.10422691f, 0.29764938f, 
    -0.00553705f, -0.01096443f, 0.10879845f, 0.05255537f, -0.04134354f, 0.00138080f, -0.00665480f, 0.07890528f, 
    -0.21468271f, 0.12325751f, -0.09046175f, -0.14253660f, 0.01222542f, 0.02032144f, -0.00992877f, 0.07124679f, 
    0.07459866f, 0.15458983f, -0.00793355f, -0.02916899f, 0.12252016f, 0.12701613f, -0.01782945f, -0.03549962f, 
    -0.23830628f, 0.04174055f, -0.01728620f, 0.00628764f, -0.04139681f, 0.07642113f, -0.01663943f, 0.05823699f, 
    0.17087127f, -0.23140332f, -0.04718371f, 0.12694296f, 0.06508652f, 0.03816551f, 0.03325465f, 0.01660214f, 
    0.11172617f, -0.09538472f, -0.04551283f, 0.03929032f, 0.35721001f, -0.24393886f, -0.12561819f, 0.01544496f, 
    -0.03560920f, 0.12925816f, -0.00188629f, 0.15092650f, -0.02021628f, -0.12568302f, -0.03191183f, -0.02043586f, 
    -0.40352756f, 0.02625289f, -0.21532850f, 0.23121683f, 0.04349775f, 0.03724532f, 0.03660520f, -0.02887246f, 
    -0.07992052f, -0.01376013f, -0.11584197f, 0.01684393f, 0.08432135f, 0.01289427f, 0.04396021f, 0.16867952f, 
    -0.04978232f, 0.04790087f, -0.00578171f, -0.00717993f, 0.08211724f, 0.00068900f, -0.15806860f, -0.03093076f, 
    -0.00836055f, -0.05576038f, 0.04414087f, 0.01690267f, 0.07648760f, 0.02361491f, 0.03184026f, -0.10616688f, 
    0.08451062f, -0.01891802f, -0.05842942f, -0.01706253f, 0.32130751f, -0.05485198f, 0.03849885f, -0.07083276f, 
    -0.07874499f, -0.06340072f, 0.05626836f, 0.06419954f, -0.02606624f, 0.03610489f, 0.02586729f, -0.02923772f, 
    0.25614935f, -0.08831427f, -0.08434413f, 0.22092386f, -0.12573399f, -0.03790969f, 0.07475573f, -0.04037028f, 
    -0.00474541f, 0.02646324f, -0.09830733f, -0.02081959f, -0.02704062f, 0.05820372f, -0.05798319f, -0.18833429f, 
    0.16076970f, -0.03187681f, -0.03994739f, -0.01883812f, -0.06986832f, -0.01769038f, -0.00729229f, -0.05848217f, 
    -0.03798974f, -0.16271551f, 0.16106907f, 0.13608868f, -0.10280228f, -0.07144462f, 0.07292032f, 0.09199897f, 
    0.01253258f, -0.05778238f, 0.05247588f, -0.05139761f, 0.18266751f, 0.08104631f, -0.27786294f, -0.13697705f, 
    0.05549012f, 0.17477871f, 0.00193838f, -0.05572246f, -0.10455691f, 0.08566702f, 0.05092207f, 0.07398924f, 
    -0.23771973f, -0.12793222f, -0.01767923f, -0.16533849f, -0.05676968f, 0.02610422f, -0.03145780f, -0.10321689f, 
    0.05144740f, 0.09246341f, -0.03829565f, 0.01832490f, 0.09742529f, 0.01511940f, 0.06703669f, -0.01075809f, 
    0.03244559f, 0.02354741f, -0.03794697f, 0.00480971f, -0.00678266f, 0.09569854f, 0.04794364f, 0.05223990f, 
    0.08684952f, -0.23217291f, 0.04162946f, 0.12806131f, -0.00697333f, -0.00197229f, -0.12915675f, 0.00124394f, 
    -0.08845820f, -0.03234544f, -0.00370117f, 0.01294120f, 0.34264010f, -0.34349078f, -0.00731308f, -0.03526749f, 
    -0.01445481f, 0.08492979f, -0.03635227f, 0.00309100f, -0.05940226f, 0.00754337f, -0.13899134f, -0.11138558f, 
    -0.17808612f, 0.14011225f, 0.11469012f, -0.06269411f, 0.00435246f, -0.03400664f, 0.04645824f, 0.01874362f, 
    -0.13210632f, 0.00490393f, 0.05174555f, -0.08609273f, 0.14429148f, -0.01081583f, -0.22916180f, 0.06771565f, 
    0.00389888f, -0.02079018f, 0.02870719f, -0.13625957f, -0.21521428f, -0.02837432f, -0.06504187f, -0.07485963f, 
    -0.32296559f, 0.03804534f, -0.00388909f, -0.12796640f, -0.13997951f, 0.03236143f, -0.11533289f, -0.03733043f, 
    0.00572208f, 0.01785665f, -0.02563191f, -0.08626659f, -0.18245469f, 0.00509194f, -0.11970196f, -0.14964370f, 
    -0.00058797f, -0.03096187f, 0.04571735f, -0.07272030f, 0.00215889f, 0.02277296f, -0.07274298f, 0.00536403f, 
    -0.03819786f, 0.06870403f, 0.09046908f, -0.08923674f, 0.03120166f, -0.00340934f, 0.03132524f, -0.00701842f, 
    -0.07379349f, 0.03044397f, -0.02046188f, -0.07518002f, 0.10501461f, 0.14353599f, -0.13322753f, 0.06203754f, 
    0.07179061f, 0.01718856f, 0.09243419f, -0.05856067f, -0.07187370f, -0.04823421f, -0.09468887f, 0.04335044f, 
    0.01242006f, 0.07137764f, 0.00822870f, -0.21482648f, 0.04482317f, -0.08824743f, 0.03550275f, -0.06399211f, 
    0.03458172f, 0.08638983f, 0.07119698f, 0.04474583f, -0.07394510f, -0.05450000f, -0.10536771f, -0.19691959f, 
    -0.02001025f, -0.06106362f, -0.12445070f, 0.03148977f, 0.07896350f, 0.10076326f, 0.00247488f, -0.02403008f, 
    -0.12755343f, -0.03412035f, 0.08780621f, -0.06338502f, -0.13394001f, -0.06508620f, 0.05985366f, 0.02171640f, 
    -0.07821686f, -0.05152717f, -0.00991719f, 0.00904437f, 0.20160262f, -0.07269897f, 0.05459230f, 0.08860818f, 
    -0.02454001f, -0.09122998f, -0.03625751f, 0.05114833f, -0.10262004f, -0.00323028f, -0.07472840f, -0.12469652f, 
    0.33859426f, 0.10450849f, 0.03688310f, 0.14701521f, -0.07020540f, -0.07439963f, -0.14682794f, -0.02743227f, 
    -0.00818919f, 0.02083783f, 0.04280238f, -0.01196849f, 0.09049576f, 0.03158236f, 0.15456086f, 0.03327647f, 
    0.01449949f, -0.10710680f, -0.04662595f, 0.03632842f, -0.01689433f, 0.06176418f, -0.05738242f, 0.04153202f, 
    -0.30555674f, -0.03792647f, -0.04189876f, -0.12574844f, 0.00216764f, -0.05650216f, -0.18901469f, -0.06369261f, 
    0.05993433f, 0.02300560f, -0.03240422f, -0.05145902f, 0.17205627f, -0.08885922f, -0.20556311f, -0.01823001f, 
    -0.01712999f, -0.07354938f, -0.08928796f, -0.03707237f, 0.00021251f, -0.03367345f, -0.04691054f, -0.11833975f, 
    -0.25091028f, 0.19549261f, -0.04297414f, -0.02142385f, 0.06712795f, -0.00326964f, -0.04800563f, -0.06261719f, 
    -0.01602989f, -0.01261773f, 0.00468334f, -0.10184206f, 0.03790811f, -0.00146868f, -0.06043286f, 0.05615410f, 
    0.11303195f, 0.05107467f, 0.01609167f, -0.01022165f, 0.00227752f, 0.06512699f, -0.03113820f, 0.05420994f, 
    -0.01653371f, 0.02218382f, -0.08403473f, -0.16291098f, 0.03812066f, -0.02196239f, -0.01412913f, -0.01774106f, 
    -0.00555963f, 0.03576510f, 0.01405628f, 0.04217121f, -0.10087789f, 0.00985312f, -0.00057761f, 0.04574453f, 
    0.03045820f, 0.05894002f, -0.02319209f, -0.10011893f, -0.04447994f, -0.02982050f, 0.07386117f, -0.07250197f, 
    0.16753511f, -0.16844968f, 0.06058652f, -0.10816241f, 0.01284802f, -0.10060482f, -0.07377879f, -0.08269140f, 
    0.07256749f, 0.01670680f, 0.03299791f, 0.02535751f, 0.08519761f, -0.01520016f, 0.02197606f, 0.07821257f, 
    -0.07353812f, 0.06692130f, 0.03877154f, 0.07597765f, -0.06660222f, -0.05764638f, -0.01625222f, -0.04241001f, 
    0.08385736f, 0.02086374f, 0.05773771f, -0.11059400f, 0.04172710f, -0.01210239f, 0.05130719f, 0.01397575f, 
    0.00422699f, -0.00765453f, 0.03873315f, 0.07781769f, 0.12735061f, 0.02533240f, -0.12791927f, -0.12537910f, 
    -0.08928204f, 0.02426962f, -0.04695997f, -0.03020415f, 0.00916325f, 0.08678343f, 0.04010364f, -0.03963496f, 
    -0.07709160f, 0.07945321f, 0.03091514f, -0.07917850f, -0.01861342f, 0.05762880f, -0.03977699f, 0.09061369f, 
    -0.00070934f, -0.02510411f, -0.02500278f, 0.00818691f, 0.14330734f, -0.06638572f, 0.07150440f, 0.15271106f, 
    0.00901202f, -0.03642503f, 0.00539402f, 0.00356678f, -0.00934348f, 0.08773880f, 0.03274363f, -0.03717480f, 
    -0.30019394f, 0.13525079f, -0.17429610f, 0.06843491f, 0.10558804f, 0.03973990f, 0.01002133f, 0.11362419f, 
    0.06426061f, 0.00386265f, 0.01278838f, -0.07724829f, -0.19361284f, 0.01211149f, -0.06489246f, -0.06090135f, 
    -0.03052153f, 0.08219755f, 0.02082803f, 0.01566034f, -0.03076933f, 0.03193970f, 0.03695869f, -0.07961219f, 
    0.15248492f, 0.07411885f, 0.01675323f, 0.10285733f, 0.02629357f, 0.08908545f, -0.09036028f, 0.03457175f, 
    -0.01096968f, -0.02824090f, -0.00915625f, 0.03808913f, 0.17956443f, -0.08990805f, -0.06900918f, -0.02788359f, 
    -0.02248438f, 0.02094423f, -0.00768152f, -0.04139024f, -0.00864562f, -0.06876076f, 0.05470970f, -0.09546066f, 
    0.09922675f, 0.21281284f, 0.07061592f, 0.18755566f, -0.03010728f, -0.07561193f, 0.09244947f, 0.05743334f, 
    -0.09756847f, -0.01718312f, 0.09929425f, -0.00463731f, -0.20511101f, 0.08399282f, 0.03929964f, -0.07405835f, 
    0.10615149f, -0.01635518f, 0.02704857f, 0.01565038f, -0.00044302f, 0.00144319f, 0.01917120f, -0.04199388f, 
    0.08033539f, 0.08965065f, 0.11883894f, 0.18200496f, -0.12776801f, -0.02773191f, -0.09976812f, 0.01016429f, 
    0.02059414f, -0.03427216f, -0.06366209f, -0.03461017f, 0.05571672f, -0.17760301f, -0.01468307f, 0.00027322f, 
    -0.02847704f, 0.00680583f, -0.12364523f, -0.10282866f, 0.05089824f, 0.02823244f, 0.00779198f, -0.15227957f, 
    -0.21520361f, -0.11334379f, -0.00441469f, -0.03531632f, 0.12712206f, 0.07533639f, -0.10684281f, -0.01436668f, 
    -0.04506544f, -0.01013410f, -0.05965289f, -0.08677883f, 0.14986008f, -0.17966846f, -0.00449421f, -0.00106593f, 
    0.05946697f, -0.06230664f, 0.05232400f, -0.05474484f, 0.03062420f, 0.01840957f, -0.00940432f, 0.01969387f, 
    0.13941929f, 0.05039677f, -0.02235962f, 0.02319176f, 0.00651455f, 0.01756052f, 0.03916636f, 0.00573096f, 
    0.00311324f, -0.00025029f, 0.01255626f, -0.06763873f, 0.55202734f, -0.19607414f, -0.00318702f, 0.08281071f, 
    -0.12797667f, 0.07018650f, 0.00616860f, 0.00855612f, 0.00311035f, -0.05252767f, 0.08699238f, -0.05220597f, 
    -0.15405656f, -0.02074898f, -0.10681453f, -0.37931475f, -0.08431228f, -0.07937166f, -0.12917361f, 0.02183348f, 
    0.02105753f, 0.00361966f, -0.11316574f, 0.03148637f, -0.17572445f, 0.08248468f, -0.21011856f, -0.01018772f, 
    -0.07142210f, -0.04569611f, -0.04138968f, -0.03674795f, -0.03299252f, -0.00118457f, -0.08038589f, 0.01335310f, 
    0.03375112f, 0.09515813f, 0.04347819f, -0.16630122f, 0.08694906f, 0.04103945f, 0.03352182f, 0.09628384f, 
    -0.05307057f, -0.00805087f, 0.08445185f, -0.08758724f, 0.19850791f, 0.14627577f, 0.02590312f, 0.21803431f, 
    -0.13015501f, -0.10900617f, 0.06255165f, 0.08591413f, -0.01932861f, 0.02244378f, -0.09756753f, -0.05533914f, 
    0.23100068f, 0.12358982f, -0.04880849f, 0.01113178f, -0.04787252f, -0.05119345f, 0.01486572f, 0.02938794f, 
    -0.06966082f, 0.07493611f, -0.05127874f, -0.13878267f, -0.16561827f, 0.09212179f, -0.02355469f, -0.11618334f, 
    -0.03128230f, -0.02873682f, 0.07159440f, -0.05088489f, -0.10700304f, 0.01375234f, 0.02623424f, -0.09709977f, 
    -0.00609466f, 0.00750654f, 0.00957567f, 0.02452731f, -0.05949162f, 0.06875631f, 0.12373464f, 0.09561808f, 
    0.08090148f, 0.07678495f, -0.01915082f, -0.09030364f, -0.42554379f, 0.13543218f, -0.28374192f, -0.18478918f, 
    0.08900116f, 0.10805301f, -0.03459765f, -0.00417107f, -0.07361111f, -0.02907451f, -0.13367142f, -0.02682026f, 
    0.27357087f, -0.03602289f, -0.06410459f, -0.24354690f, -0.12079976f, 0.12973730f, -0.06071173f, 0.16372809f, 
    -0.02252271f, -0.14534992f, 0.04535936f, -0.11553233f, 0.09527565f, 0.14440614f, 0.16262403f, 0.01391189f, 
    -0.10820885f, -0.00622111f, -0.04683974f, -0.01206141f, -0.05283985f, 0.02102325f, -0.01220314f, -0.02985059f, 
    -0.26339757f, -0.21355508f, 0.08548807f, -0.00290012f, -0.02619630f, -0.08989553f, -0.04163027f, -0.08922143f, 
    -0.01886143f, 0.03203800f, 0.10420247f, -0.01697960f, 0.04777040f, 0.02617819f, -0.12522686f, -0.03716572f, 
    -0.03234811f, 0.07832917f, -0.04061551f, -0.07379285f, -0.05013004f, -0.00978741f, 0.01977802f, -0.02655538f, 
    0.32461998f, 0.02562825f, -0.10989121f, 0.08119597f, -0.03035066f, -0.03672021f, 0.01918145f, -0.01867106f, 
    -0.03324835f, 0.01679532f, -0.03303465f, 0.00268244f, 0.16912237f, -0.06774992f, 0.01251341f, 0.16724294f, 
    -0.08331110f, 0.01687807f, -0.00259308f, -0.04682925f, -0.02457741f, 0.05820805f, -0.05575784f, 0.08597076f, 
    -0.06450378f, -0.13309036f, -0.00672854f, -0.00867582f, -0.01715350f, 0.03037211f, -0.01922118f, 0.02028863f, 
    -0.01391047f, 0.08011708f, -0.00305815f, 0.05717467f, 0.38062695f, 0.07434306f, -0.00742367f, 0.05239699f, 
    -0.12169932f, -0.06088800f, 0.03176557f, -0.06409037f, -0.07469498f, -0.10341965f, -0.00057968f, -0.09497903f, 
    0.02378635f, -0.12080295f, -0.13878375f, -0.20395480f, -0.13777804f, 0.02837217f, -0.02508269f, -0.05814504f, 
    0.15980078f, 0.01481508f, 0.03808301f, -0.06731419f, -0.05222818f, 0.09339742f, -0.11902014f, 0.07092077f, 
    0.00725850f, 0.03402437f, 0.00574773f, 0.03803581f, 0.06141105f, 0.05640434f, 0.05304283f, -0.01660337f, 
    -0.14499018f, -0.44234291f, 0.12773408f, 0.11880108f, -0.09389725f, 0.03322956f, 0.04312181f, -0.05402087f, 
    -0.03402273f, -0.20666599f, -0.03146223f, 0.00043053f, 0.03961615f, -0.02847291f, 0.07616431f, 0.10573681f, 
    -0.06064398f, 0.02433081f, 0.04923967f, 0.06222705f, -0.00101538f, 0.00822916f, 0.05309938f, 0.03535545f, 
    0.02495157f, 0.04202652f, 0.03904540f, -0.04087389f, -0.05148754f, -0.01274243f, -0.01950230f, 0.11467333f, 
    -0.04344186f, 0.08851746f, -0.13013710f, 0.06508148f, 0.30949473f, 0.22391349f, -0.14150269f, 0.08907250f, 
    0.02867522f, 0.05231816f, 0.08391841f, 0.11047995f, 0.08222121f, -0.07285858f, -0.00891283f, -0.09339771f, 
    0.12124335f, -0.19449006f, -0.07492553f, -0.04687632f, -0.18102232f, 0.05806694f, 0.01583704f, 0.08687969f, 
    0.00674874f, -0.00730136f, -0.02233619f, -0.02502808f, 0.35042387f, 0.13261199f, 0.05620091f, -0.16245082f, 
    -0.01148122f, 0.04743139f, -0.05094573f, 0.11286793f, 0.00470056f, -0.01853981f, -0.05046276f, 0.04534900f, 
    0.29788053f, -0.03444294f, 0.04708711f, 0.12311501f, 0.03645972f, 0.03686481f, -0.01619195f, 0.02507296f, 
    0.13603000f, 0.13936539f, 0.02881779f, 0.03929006f, -0.00221220f, -0.18204147f, -0.10260675f, 0.01111935f, 
    0.07583733f, 0.03235160f, -0.08407298f, 0.02301157f, 0.02971804f, 0.00606944f, -0.02307996f, 0.05294940f, 
    0.03342155f, 0.03481785f, 0.03996613f, 0.06680338f, 0.09542578f, 0.03720819f, 0.13706595f, -0.01805975f, 
    -0.05567155f, 0.00203139f, -0.00870975f, -0.09795340f, -0.06275333f, 0.10157195f, 0.11663709f, 0.16586110f, 
    0.02609066f, -0.01457897f, 0.13831842f, -0.08561029f, 0.04031103f, 0.02936523f, -0.15465289f, -0.02596395f, 
    -0.09462932f, -0.28778204f, -0.33560514f, 0.07744765f, -0.09955060f, 0.00985351f, -0.03182524f, 0.02615611f, 
    -0.10662778f, 0.08795067f, -0.07934557f, -0.04541546f, 0.07472446f, -0.00719296f, -0.15555955f, 0.16904679f, 
    0.01083042f, 0.08916193f, 0.14750931f, 0.09058328f, -0.05855231f, 0.02513257f, 0.02211426f, -0.09430862f, 
    0.18790118f, -0.14135805f, -0.01237478f, 0.05102079f, 0.00286736f, 0.06859809f, 0.12371674f, 0.07038289f, 
    -0.02229409f, 0.12942354f, -0.02835523f, -0.04255602f, 0.09246734f, -0.12961976f, 0.06362876f, -0.00943176f, 
    -0.03844263f, -0.03732332f, 0.11215305f, 0.02581889f, -0.05882087f, 0.13171241f, -0.02434092f, 0.07506518f, 
    0.56907827f, 0.12885284f, 0.15537396f, 0.18362907f, 0.02001139f, 0.05820079f, -0.05798398f, -0.01091179f, 
    0.06667482f, -0.04134752f, -0.08760113f, -0.05999038f, -0.49398428f, -0.28849775f, 0.04746071f, 0.20300555f, 
    -0.03720545f, -0.00576319f, 0.01918118f, -0.01838926f, -0.04903440f, -0.05277836f, 0.02361239f, -0.07886468f, 
    0.33008742f, -0.32081297f, -0.17055459f, 0.06536090f, 0.07703537f, -0.00688408f, -0.10452951f, -0.03752787f, 
    0.04460668f, 0.02215770f, -0.07566627f, 0.04125851f, 0.09752659f, 0.08032666f, 0.11376328f, 0.00774155f, 
    0.05378378f, -0.02770689f, 0.04441420f, -0.02114092f, 0.04724912f, -0.01568291f, 0.02274109f, -0.01413910f, 
    -0.09754042f, -0.08600640f, -0.03089048f, 0.03690714f, -0.07471047f, 0.03755518f, 0.00405724f, 0.08807597f, 
    -0.07510486f, -0.01942080f, 0.02888172f, 0.07629798f, -0.21276887f, 0.00337206f, 0.15655629f, 0.04656570f, 
    0.15568034f, -0.04915416f, -0.01824774f, 0.00300426f, -0.03886097f, -0.07483764f, -0.11892609f, -0.02982011f, 
    -0.01308232f, 0.14384478f, 0.08631204f, -0.13967256f, -0.07319810f, -0.07718327f, 0.03366206f, 0.07471652f, 
    0.03260041f, -0.10278303f, 0.00892159f, -0.08706062f, -0.00462847f, 0.00152913f, -0.08318265f, -0.00844773f, 
    -0.06539553f, -0.10826823f, -0.01614792f, -0.09060419f, -0.04733669f, -0.04667198f, -0.07770751f, 0.03399228f, 
    0.11737611f, 0.07647920f, -0.06308793f, -0.00639743f, -0.13071662f, -0.03980188f, 0.03857814f, 0.01017921f, 
    0.05287452f, 0.00970421f, -0.02508745f, -0.07897717f, -0.08176672f, 0.23346972f, 0.04927677f, -0.00470731f, 
    -0.11311296f, -0.02038084f, -0.04337090f, 0.00894916f, -0.06060999f, -0.06242641f, -0.07488152f, 0.02547098f, 
    0.17315042f, -0.05153928f, -0.04990260f, 0.18888997f, -0.00644317f, 0.06206188f, 0.03288424f, -0.12505159f, 
    -0.02522499f, 0.02635478f, 0.01207044f, -0.01505815f, -0.34276667f, -0.54357058f, -0.10930355f, 0.01003866f, 
    -0.09270070f, -0.04295376f, 0.08421301f, -0.02425649f, -0.05490157f, -0.00400438f, -0.08030145f, 0.03839161f, 
    -0.11805665f, -0.22673351f, -0.25002071f, -0.07582286f, -0.04447429f, -0.02157211f, 0.02599040f, -0.03418887f, 
    -0.04571886f, -0.03155964f, 0.14117286f, 0.02308884f, -0.00088355f, -0.01100155f, 0.00775105f, 0.34147069f, 
    0.08426367f, 0.09682324f, -0.01120116f, -0.13490637f, -0.03561410f, 0.02592100f, 0.10800965f, -0.09795388f, 
    -0.00518934f, 0.04042061f, 0.01533752f, 0.00142403f, -0.10280209f, -0.04522562f, 0.01266605f, 0.08774897f, 
    0.07491741f, -0.03865379f, 0.01287532f, 0.01141225f, -0.09590589f, 0.06628291f, -0.13995208f, -0.11478501f, 
    -0.04879365f, -0.11348347f, -0.03339034f, 0.02622668f, -0.06082023f, 0.00739098f, 0.01578207f, -0.09472801f, 
    -0.24651490f, -0.30686989f, -0.18480268f, 0.01859360f, -0.01308371f, -0.07248467f, -0.09706449f, -0.05401245f, 
    -0.14180727f, 0.00450221f, -0.05227029f, 0.01116686f, -0.13616744f, 0.16787586f, 0.07460438f, -0.06428030f, 
    -0.05468795f, 0.01883323f, 0.01553531f, 0.04561190f, -0.04764329f, -0.00508201f, -0.01195318f, 0.02234467f, 
    -0.30906710f, -0.00536531f, -0.09295342f, 0.02312397f, -0.03651427f, 0.08643099f, -0.00905663f, 0.00416138f, 
    0.09581034f, -0.08926012f, 0.02941523f, 0.04809916f, -0.17053758f, -0.03012892f, 0.10459574f, -0.06121521f, 
    -0.10359086f, 0.01106502f, 0.05512044f, 0.07449692f, -0.02211432f, 0.04789582f, 0.01945665f, 0.08741466f, 
    0.10294384f, 0.14909354f, 0.13543084f, -0.01638529f, -0.04260967f, 0.13320193f, 0.00409158f, 0.02243757f, 
    -0.05913864f, -0.00776767f, -0.08691990f, 0.08100543f, 0.08816839f, -0.27396998f, -0.29784551f, 0.06782252f, 
    -0.10793998f, 0.03908702f, 0.07771622f, 0.09222187f, 0.00744066f, 0.14489250f, -0.05918335f, 0.12642433f, 
    -0.29245710f, -0.02305644f, 0.17222892f, 0.01413129f, 0.03524363f, 0.19124597f, -0.08922567f, -0.08883473f, 
    0.01037683f, -0.01464730f, -0.01795224f, -0.07411595f, 0.04060556f, 0.15552950f, 0.03703913f, 0.23305066f, 
    0.01299244f, -0.07710288f, -0.04129695f, -0.09690338f, -0.06254874f, 0.00453492f, -0.01217482f, -0.09683430f, 
    -0.32896876f, -0.06449247f, 0.05092712f, -0.18666847f, -0.01625193f, 0.05549708f, -0.04589065f, -0.04368961f, 
    -0.10401591f, -0.01629207f, 0.02716964f, -0.02458453f, -0.24056655f, -0.18959823f, 0.04281471f, -0.03779814f, 
    -0.11858930f, 0.01724775f, -0.03083173f, -0.01989163f, 0.04635642f, -0.00712328f, 0.06420916f, -0.00392028f, 
    0.13675971f, 0.07322285f, -0.14104775f, -0.07254990f, -0.07402445f, -0.04229868f, -0.01274150f, -0.05242831f, 
    -0.06256692f, -0.07085935f, 0.09310389f, -0.01931210f, -0.03864466f, -0.04110172f, 0.04689565f, 0.16160014f, 
    -0.07294711f, -0.01241155f, 0.01702078f, -0.11466889f, 0.10161144f, -0.09959156f, 0.00522788f, 0.06524426f, 
    0.05164330f, -0.08951487f, -0.03291022f, 0.19099450f, 0.04338251f, 0.02178158f, -0.01063697f, -0.02635946f, 
    0.02314383f, -0.02737580f, -0.02751337f, 0.04036315f, 0.36818242f, 0.25636613f, -0.17978311f, 0.05935330f, 
    -0.03446513f, -0.01911999f, -0.01441138f, -0.08574287f, -0.01757372f, -0.08236177f, -0.04682821f, -0.11923815f, 
    -0.20047589f, -0.22456479f, -0.15268502f, 0.15967771f, -0.02932022f, -0.00078594f, 0.00889057f, -0.02629602f, 
    -0.10075675f, -0.03547489f, 0.02853325f, -0.09194957f, 0.05172953f, -0.01407350f, 0.19525820f, -0.05525609f, 
    -0.01144540f, 0.05821216f, 0.02510886f, 0.02462003f, -0.05382846f, 0.02314906f, -0.01517127f, 0.04217196f, 
    0.20560700f, 0.05775191f, -0.02382937f, 0.09125590f, 0.06435458f, 0.04711574f, -0.06084709f, 0.07104700f, 
    -0.03150635f, 0.04879767f, -0.08569475f, 0.06283000f, 0.14642231f, 0.20916450f, -0.04479584f, -0.03873331f, 
    0.04693681f, -0.02699019f, 0.01615153f, -0.02117894f, -0.00247543f, 0.03174154f, -0.00113370f, -0.08188119f, 
    -0.41826707f, -0.23286442f, -0.17087922f, -0.13948540f, -0.03366562f, -0.06683526f, -0.07479086f, -0.07964081f, 
    0.05881194f, -0.01715704f, 0.12691213f, -0.00510738f, -0.02685333f, -0.00561497f, -0.06664216f, -0.21997036f, 
    -0.13406952f, -0.14068878f, -0.00264052f, -0.00830714f, -0.04781159f, -0.05255249f, -0.03214234f, -0.04686636f, 
    0.06399808f, 0.11131112f, -0.09910226f, -0.10332564f, -0.02501834f, 0.03894284f, -0.01512923f, 0.00069948f, 
    -0.02700048f, -0.01832000f, 0.01404368f, 0.02235812f, 0.16154177f, -0.21964614f, -0.08516925f, -0.01712777f, 
    -0.04749050f, 0.07059568f, -0.00841921f, 0.02725588f, 0.06512613f, -0.03140674f, -0.01970043f, 0.06820557f, 
    -0.11527321f, 0.14808801f, 0.01642646f, -0.01020609f, -0.06044425f, 0.06715389f, 0.02688147f, 0.13069564f, 
    0.00340032f, -0.02495719f, 0.01403979f, 0.11982666f, 0.14775661f, -0.20234056f, 0.04829876f, 0.08735571f, 
    -0.03095658f, 0.06208871f, 0.02143706f, 0.05058782f, -0.01846473f, -0.04538999f, -0.07060928f, 0.04430019f, 
    -0.43598211f, 0.33670402f, 0.04810548f, 0.00576183f, 0.01331754f, -0.01492976f, -0.02565811f, 0.10756429f, 
    -0.03381598f, -0.13146856f, 0.00393763f, 0.11583540f, -0.00133807f, 0.03352201f, 0.03145295f, -0.07635266f, 
    -0.08275607f, 0.05860733f, -0.02880418f, -0.04837123f, -0.00715487f, -0.00914016f, 0.03429442f, 0.02789460f, 
    -0.03983430f, 0.10285512f, -0.06457295f, 0.02862854f, -0.04324688f, -0.08723931f, 0.04520911f, -0.00830054f, 
    0.04586215f, -0.09654369f, -0.01151644f, 0.08410359f, -0.17154938f, -0.17233451f, -0.21671762f, -0.09239070f, 
    -0.02562464f, -0.01129684f, 0.00426390f, -0.04329386f, -0.10014948f, -0.06190351f, -0.03787153f, -0.02437223f, 
    -0.37029672f, 0.21903355f, 0.05177946f, -0.08441875f, -0.04430624f, -0.12361080f, -0.07424305f, 0.02563869f, 
    0.05808819f, -0.08170428f, -0.01655733f, -0.04127165f, -0.08359107f, -0.40381145f, -0.18554056f, -0.02517111f, 
    0.03544791f, -0.16196027f, -0.01774799f, -0.02819221f, 0.06509878f, -0.10740883f, 0.02129390f, -0.05870837f, 
    0.13345395f, -0.10617587f, -0.16205876f, -0.15010077f, -0.09204029f, 0.00634711f, 0.10895672f, -0.02642759f, 
    -0.05779229f, 0.05038914f, 0.02724192f, -0.09129392f, 0.08110245f, 0.08292912f, -0.02791712f, 0.09050051f, 
    -0.09608142f, -0.07035980f, -0.03191322f, -0.07571717f, -0.04158779f, 0.03547518f, 0.02978025f, 0.07163288f, 
    0.10187925f, 0.09679332f, 0.12061331f, -0.02492755f, 0.03784326f, 0.02253625f, -0.03782043f, 0.03404258f, 
    0.02709128f, -0.00172152f, 0.10513218f, 0.06364612f, -0.26311281f, 0.05671428f, -0.01304314f, -0.01233488f, 
    0.00525926f, 0.02530607f, -0.02399878f, -0.02955184f, -0.08668994f, 0.06174806f, 0.07638666f, 0.03576848f, 
    -0.08346966f, 0.09263587f, -0.05844063f, 0.01834513f, 0.06044832f, -0.07016992f, 0.03130488f, 0.15398465f, 
    -0.02140846f, 0.06185322f, 0.09571879f, -0.02785365f, -0.13192853f, 0.08282141f, 0.05006601f, 0.02480739f, 
    0.04041569f, 0.00677680f, -0.01067745f, -0.02301641f, 0.05240533f, -0.00873266f, -0.00482251f, -0.03263313f, 
    -0.13265719f, 0.02414496f, 0.21577942f, 0.10793765f, 0.06701503f, -0.01619717f, -0.01246846f, 0.14741956f, 
    -0.05243398f, 0.10934990f, 0.19053923f, 0.01584021f, 0.00510433f, 0.05256055f, 0.02512742f, -0.02591527f, 
    -0.09115711f, 0.11099511f, 0.01299046f, -0.06893738f, 0.03670866f, -0.02943424f, 0.16365944f, -0.00270088f, 
    -0.27202928f, 0.11108870f, 0.05463347f, 0.05201381f, -0.02656406f, 0.09392232f, 0.05171110f, 0.08997522f, 
    -0.04737897f, 0.05670870f, 0.07313772f, -0.03168253f, 0.46751383f, 0.19591723f, -0.09243420f, -0.08589362f, 
    0.04187210f, -0.13654253f, 0.07529376f, 0.00751508f, 0.07060117f, 0.03227493f, -0.07655046f, 0.01674813f, 
    0.02115801f, -0.00990920f, 0.01970149f, -0.13108024f, 0.07582127f, 0.00267671f, -0.10789542f, 0.00131485f, 
    -0.06386800f, -0.04591612f, -0.00610371f, 0.09048734f, 0.00444592f, 0.07722443f, 0.11295497f, 0.08151543f, 
    -0.02568882f, -0.04605717f, -0.02891116f, 0.02610811f, 0.02893515f, -0.09724643f, 0.06021420f, 0.06225542f, 
    -0.28000763f, 0.05557217f, 0.03392106f, -0.16270854f, -0.04741950f, 0.13411106f, -0.06484203f, -0.02758698f, 
    0.09281275f, -0.20173857f, -0.00454486f, -0.04453190f, -0.28471768f, -0.02511734f, 0.01271050f, 0.08116783f, 
    0.08923198f, -0.14550070f, -0.03888884f, -0.03473726f, 0.08032470f, 0.04589048f, -0.03934280f, -0.06080719f, 
    -0.22504131f, -0.09728124f, 0.11383027f, -0.01178808f, -0.01148084f, 0.09134346f, -0.05330805f, 0.05273449f, 
    0.01300247f, 0.05428137f, -0.05248515f, 0.15778458f, -0.13164629f, 0.14109494f, 0.21494882f, 0.07799146f, 
    -0.03126127f, 0.12637776f, 0.01708596f, 0.07383365f, 0.04862855f, -0.01009262f, -0.15262409f, -0.09080170f, 
    -0.07878472f, 0.00128831f, 0.10614896f, -0.19570896f, -0.02780970f, 0.02387308f, -0.03706352f, -0.00752889f, 
    0.01200446f, -0.06000427f, -0.07082729f, 0.04530963f, -0.04843622f, -0.12702891f, -0.00443097f, 0.02749435f, 
    -0.04256752f, -0.05702992f, 0.07012870f, 0.03518702f, -0.05460488f, 0.00585022f, -0.09469179f, -0.05972103f, 
    -0.34538054f, 0.06225979f, -0.09023476f, 0.02119295f, -0.04313505f, 0.18449287f, -0.10366166f, 0.04238991f, 
    -0.17216079f, -0.09484117f, -0.04168338f, 0.02447646f, -0.49486548f, -0.30066130f, 0.07079896f, 0.20295045f, 
    -0.16641816f, -0.22743683f, 0.02192751f, -0.01639179f, 0.09852640f, 0.06660553f, -0.06333362f, -0.23106712f, 
    0.24485679f, -0.10629312f, 0.17002046f, 0.15886399f, -0.14500023f, -0.08565519f, 0.05873588f, -0.13576299f, 
    0.01376351f, -0.01556171f, -0.02297558f, -0.05119981f, 0.03619097f, -0.01085308f, 0.07911751f, 0.05098532f, 
    0.04391633f, 0.02269760f, -0.09668966f, 0.01401065f, 0.00512547f, -0.06151913f, 0.02952329f, 0.02574281f, 
    0.15639079f, -0.17999299f, 0.02555186f, -0.07398859f, -0.06741069f, 0.04716173f, -0.00384260f, -0.00429097f, 
    0.04889189f, -0.04317245f, -0.05634547f, -0.12933487f, -0.19482170f, -0.03673714f, 0.14655149f, -0.03127496f, 
    0.00523493f, -0.05269422f, 0.03337848f, 0.12792458f, 0.10476996f, -0.04576338f, -0.04581764f, 0.08700852f, 
    0.27921265f, -0.03591987f, -0.10371234f, 0.00925018f, 0.06075870f, 0.06840202f, -0.06934133f, 0.06024053f, 
    -0.04283963f, -0.13328496f, -0.08106428f, -0.06366044f, -0.29350278f, -0.12584841f, 0.08930312f, 0.17435399f, 
    0.07941467f, 0.00920735f, 0.04255237f, 0.03082015f, -0.01539840f, -0.01852054f, -0.06735535f, -0.01449297f, 
    0.22105579f, 0.08123466f, 0.04118440f, 0.04179645f, 0.11287276f, 0.01605959f, 0.04263964f, 0.03528254f, 
    -0.01285426f, 0.07735353f, 0.08193331f, 0.05933714f, -0.03786179f, -0.03445536f, -0.00969144f, -0.13824816f, 
    -0.01622857f, -0.06728729f, -0.07533591f, 0.05585285f, -0.09525100f, -0.03246665f, -0.10124385f, 0.12248588f, 
    0.01333073f, -0.04654648f, -0.08932556f, -0.07829447f, 0.07356340f, -0.01104023f, -0.00335173f, -0.04134141f, 
    -0.02196004f, 0.09248261f, -0.13191876f, -0.05908211f, -0.03369844f, 0.07413267f, -0.06563183f, -0.10278932f, 
    -0.04469486f, 0.01793476f, -0.07183183f, 0.10413031f, 0.06709548f, 0.00028695f, 0.05874971f, -0.03500960f, 
    0.06022479f, 0.10697249f, 0.15851177f, 0.09721763f, -0.09357032f, 0.00485640f, -0.02136758f, -0.07240579f, 
    0.09381197f, -0.06998596f, -0.10529537f, 0.00487379f, -0.39545009f, -0.11313888f, 0.14312795f, 0.14150828f, 
    0.02655422f, -0.09972804f, -0.09768464f, -0.13333178f, 0.05892881f, -0.03172441f, 0.01056091f, -0.00217296f, 
    -0.19042812f, -0.01562003f, 0.14487465f, 0.11263894f, -0.07522763f, -0.02615051f, -0.02975513f, 0.05563612f, 
    -0.02607083f, 0.02523669f, -0.03559767f, 0.12400889f, -0.03258516f, -0.11745059f, -0.11921863f, 0.09568569f, 
    0.00296936f, 0.02543536f, 0.02712778f, 0.03286359f, 0.08908191f, 0.01989251f, 0.03172002f, 0.02677513f, 
    -0.38827673f, 0.15565854f, 0.05741600f, -0.07694764f, 0.01730448f, -0.01738508f, 0.04270621f, 0.06607121f, 
    0.05823171f, -0.08458377f, 0.02092397f, -0.16136158f, -0.13554315f, -0.01880267f, -0.01206235f, -0.21760261f, 
    0.04515434f, -0.00408165f, -0.10443534f, 0.08127519f, -0.02687077f, 0.04364117f, -0.01776398f, -0.09750447f, 
    -0.25623295f, 0.22344872f, 0.07621159f, -0.07228234f, -0.02338714f, 0.06404503f, -0.02563917f, -0.04390310f, 
    0.03633958f, -0.04632242f, -0.02046406f, -0.05070154f, -0.32849798f, -0.11996721f, 0.08854206f, 0.24420041f, 
    0.07035757f, -0.08691461f, -0.00841727f, 0.03739797f, -0.04376797f, 0.02032547f, 0.03622715f, 0.14225002f, 
    -0.03053561f, -0.04039460f, -0.16408655f, -0.03864150f, 0.03747202f, 0.07407934f, -0.03104324f, -0.13449953f, 
    0.15118776f, 0.01888899f, 0.08633453f, 0.06803359f, -0.07865714f, -0.06942650f, 0.09796799f, -0.17413867f, 
    -0.02376556f, 0.07733104f, 0.04934866f, 0.10208472f, 0.01002976f, 0.00081056f, 0.08027411f, 0.13274226f, 
    -0.28732440f, -0.14826643f, 0.00668802f, -0.02539681f, -0.02051461f, -0.02681134f, 0.06752627f, -0.15068334f, 
    -0.07358281f, -0.04523163f, -0.07894508f, -0.03239286f, -0.17809595f, 0.03429219f, 0.07600906f, -0.01795626f, 
    0.07638688f, -0.11490799f, 0.05643402f, 0.11119957f, -0.01327877f, -0.02001545f, -0.01992300f, -0.05299006f, 
    -0.38611707f, -0.10720649f, 0.12930228f, 0.25063151f, -0.04873224f, 0.03239802f, 0.10850870f, -0.03597295f, 
    0.00496454f, 0.02425217f, 0.05481241f, 0.06823260f, -0.12147424f, 0.08508352f, -0.17354374f, -0.04939337f, 
    -0.03108755f, -0.06559866f, 0.07648586f, 0.11940067f, -0.05102614f, 0.04040735f, 0.04141561f, 0.06172879f, 
    -0.38875329f, -0.00003445f, -0.17381945f, 0.02674908f, 0.02551433f, -0.07153468f, 0.00871197f, -0.02511702f, 
    0.03130673f, -0.03213457f, -0.06382936f, -0.00944179f, 0.09708976f, 0.08069704f, 0.00818780f, 0.22575514f, 
    -0.03387313f, 0.02666828f, 0.08947008f, -0.08602669f, -0.05452791f, 0.09416134f, 0.04751138f, 0.01118643f, 
    -0.05228037f, 0.19902360f, 0.00822548f, -0.01770575f, -0.08200327f, -0.03840627f, 0.02544418f, 0.00828307f, 
    0.02135762f, -0.06830774f, 0.00100890f, 0.03406050f, 0.26681599f, -0.17800038f, -0.13718866f, 0.06700055f, 
    0.07522681f, 0.01894267f, -0.08949672f, -0.01336226f, -0.07097136f, -0.12366849f, -0.00170107f, -0.02672165f, 
    -0.08603887f, -0.24616289f, 0.07936604f, 0.01855206f, -0.03503436f, -0.09584747f, 0.01710347f, 0.05800078f, 
    0.11529852f, 0.02286357f, -0.12292184f, -0.06018558f, -0.57461971f, 0.08479223f, -0.06561398f, -0.02191785f, 
    0.04962291f, -0.00819525f, -0.04539176f, 0.02595603f, -0.03710097f, -0.02842460f, -0.02602718f, 0.01699731f, 
    0.03540872f, -0.12592860f, 0.16710943f, -0.17879121f, -0.01819631f, -0.01886749f, -0.05917334f, -0.03886444f, 
    0.07421872f, -0.08510547f, -0.02176086f, 0.08661430f, 0.25590989f, 0.01489381f, -0.06712036f, -0.15589312f, 
    0.05344789f, 0.02641034f, 0.02669540f, -0.05770018f, 0.05078422f, -0.06073187f, 0.00621410f, -0.06685770f, 
    0.17205821f, 0.03929996f, -0.11604220f, 0.03302153f, 0.01756893f, -0.05024582f, 0.10619666f, 0.10909702f, 
    -0.04328517f, 0.00209872f, 0.07187510f, 0.09587914f, -0.40228426f, -0.04789485f, -0.03650726f, 0.28297132f, 
    -0.03870412f, 0.00227314f, 0.04983699f, 0.06357377f, 0.01651242f, 0.10619081f, -0.02902792f, 0.02562944f, 
    0.02637135f, 0.14386587f, 0.10966016f, 0.06232589f, 0.05634560f, 0.03497079f, 0.05787398f, 0.08393203f, 
    0.05549713f, 0.11200763f, 0.12234622f, 0.01834550f, 0.06766697f, -0.13166417f, -0.18501782f, 0.04716068f, 
    -0.02240433f, 0.05003147f, 0.00514097f, -0.09339299f, -0.00292999f, 0.08040832f, 0.01588860f, -0.13528404f, 
    0.06540660f, 0.01355939f, 0.14681242f, 0.22737317f, 0.06197436f, 0.06186372f, 0.03874819f, 0.07699481f, 
    -0.00235015f, 0.03380016f, 0.10061231f, -0.03857517f, 0.01202587f, -0.06451158f, 0.22940102f, -0.09423949f, 
    -0.06791497f, 0.12511195f, -0.09442587f, -0.12040430f, -0.12207415f, 0.01602506f, 0.08101100f, -0.08995780f, 
    -0.15586014f, -0.02478679f, 0.04526153f, -0.07436118f, -0.10717715f, -0.07463563f, -0.06940199f, -0.04941225f, 
    -0.02041642f, -0.00158573f, -0.06386399f, -0.00166614f, 0.23442915f, -0.05338149f, 0.07087315f, -0.05517779f, 
    0.06798516f, 0.07269079f, -0.11537031f, 0.04105011f, -0.00960593f, -0.02292837f, -0.06798548f, -0.08043677f, 
    0.07515010f, -0.07471876f, 0.00093779f, 0.28095272f, 0.00309950f, -0.03217626f, 0.13628033f, 0.07957151f, 
    0.11175804f, 0.06797585f, 0.03057102f, -0.04236178f, 0.09963476f, 0.14908215f, 0.19967687f, 0.07610615f, 
    -0.10756171f, 0.00358509f, 0.06187591f, -0.03335771f, 0.11538906f, 0.03727685f, 0.02641818f, -0.04740055f, 
    0.10231217f, 0.28175938f, -0.17681366f, -0.01092650f, -0.09311162f, 0.02777874f, 0.08664550f, -0.00102225f, 
    -0.05875857f, -0.03453238f, 0.02865376f, 0.08559636f, 0.18429181f, 0.33497837f, -0.24692792f, -0.23026243f, 
    0.13001677f, -0.04393891f, -0.05909571f, 0.13218927f, -0.00655621f, -0.14744629f, 0.00355330f, 0.00313106f, 
    -0.32591066f, 0.27310124f, 0.03138282f, -0.00740091f, -0.05385157f, 0.02739576f, -0.11511616f, -0.08404306f, 
    -0.07748537f, -0.00105196f, -0.00283818f, 0.08046647f, -0.20315661f, 0.10339913f, 0.06301270f, -0.05360289f, 
    0.06201177f, 0.01573639f, -0.01888151f, 0.04250938f, -0.01592545f, -0.12105979f, -0.07024202f, 0.09859480f, 
    -0.04675283f, -0.25080690f, 0.02155678f, -0.41361481f, 0.00356443f, 0.03459869f, -0.18227263f, 0.07966196f, 
    -0.06099020f, -0.07776578f, -0.00149105f, 0.05090488f, -0.20848505f, 0.10602856f, 0.01567546f, -0.14481440f, 
    -0.11647499f, 0.05397840f, 0.07834688f, 0.00090855f, -0.06706537f, -0.05329039f, 0.13798012f, -0.01619096f, 
    0.00535810f, 0.02840731f, 0.30193537f, -0.06159319f, 0.09148277f, 0.06476290f, 0.00877312f, -0.07929586f, 
    0.03324518f, 0.02715161f, 0.15822077f, 0.08233462f, -0.16854189f, -0.08621132f, -0.05425624f, 0.04130311f, 
    -0.03635731f, 0.02899991f, 0.00449010f, 0.05096040f, -0.01846141f, -0.06131336f, -0.14703530f, 0.03364202f, 
    -0.17502351f, -0.00814794f, -0.26688811f, 0.10328989f, 0.17839886f, 0.10326456f, 0.01619250f, -0.01030709f, 
    0.09621392f, -0.04981080f, -0.00804926f, 0.02363293f, -0.22636785f, 0.06675825f, 0.17339401f, -0.11615243f, 
    -0.03590361f, 0.07945924f, 0.17819285f, -0.12303784f, -0.11084024f, -0.13695320f, -0.16960046f, 0.05413248f, 
    -0.18234554f, -0.16409862f, -0.16286722f, -0.03732262f, 0.15643375f, -0.09370759f, 0.01438209f, -0.00963780f, 
    0.00772297f, -0.04455270f, -0.11163019f, 0.05707013f, -0.09107719f, -0.32822263f, 0.13030042f, 0.23482372f, 
    0.01888934f, -0.14975563f, -0.06044740f, -0.02641637f, -0.09709151f, -0.01849993f, 0.02891155f, -0.08308347f, 
    0.14223056f, -0.22315262f, 0.02466282f, 0.11256640f, -0.00800851f, 0.02687081f, 0.00605800f, 0.25734347f, 
    -0.10689038f, 0.08630936f, 0.04698697f, -0.05453658f, -0.10498163f, -0.10500930f, 0.10399003f, -0.04703337f, 
    -0.18206373f, -0.03691788f, 0.05624839f, -0.09393357f, -0.03583170f, -0.05149332f, -0.02407751f, -0.02209935f, 
    -0.13982452f, 0.05638691f, 0.01736111f, -0.27091661f, -0.05828473f, 0.05445782f, 0.05461827f, 0.06700284f, 
    0.06873479f, 0.16814026f, 0.03637830f, -0.00820138f, 0.09589306f, 0.02195010f, -0.05929750f, -0.19223887f, 
    0.07166255f, -0.00909836f, -0.03532491f, -0.06232253f, 0.00704279f, 0.00221486f, 0.08719607f, 0.09628947f, 
    0.00540093f, -0.09686054f, -0.03049855f, 0.18076675f, 0.14653711f, -0.08778920f, -0.01183489f, -0.05202364f, 
    0.11546844f, -0.19371721f, -0.04396158f, -0.07829116f, 0.01484761f, -0.00786723f, 0.19003527f, 0.07923495f, 
    0.00367936f, 0.00536821f, 0.04861964f, -0.09974308f, -0.04039523f, -0.19269176f, 0.08317234f, 0.25611335f, 
    -0.11970466f, -0.22072653f, -0.04415965f, 0.23220472f, 0.07285608f, -0.13072760f, -0.04180629f, 0.05843239f, 
    0.09777547f, -0.02453423f, -0.05803041f, 0.03032711f, -0.07597907f, 0.09918601f, -0.01081592f, 0.18395047f, 
    -0.06539299f, 0.02515413f, -0.00122645f, -0.00784166f, 0.06607100f, 0.05872862f, 0.10150237f, 0.05578282f, 
    -0.08001795f, -0.16120306f, 0.09903170f, 0.05960099f, -0.10847139f, 0.00477656f, 0.19500166f, 0.06556985f, 
    -0.06512239f, 0.11084065f, 0.09341251f, 0.05052568f, 0.22582459f, 0.03619358f, 0.08881912f, -0.06802316f, 
    -0.20372677f, -0.01301357f, -0.03970668f, 0.06448297f, -0.08716702f, -0.03978113f, 0.09758728f, 0.10111289f, 
    0.01856015f, -0.13061532f, 0.08104312f, -0.16869524f, -0.06499390f, 0.02418348f, -0.00391094f, 0.10670500f, 
    -0.02456351f, -0.00515767f, -0.01522966f, -0.08501826f, -0.02229648f, -0.10879734f, -0.10080259f, 0.12464395f, 
    0.10939519f, 0.04277932f, 0.14617519f, -0.05045725f, -0.07195361f, 0.08837883f, 0.22063565f, -0.05740441f, 
    -0.16443507f, -0.06517066f, -0.01849324f, 0.02843544f, 0.00746417f, 0.00242493f, -0.00579601f, 0.03415699f, 
    -0.02979960f, 0.05242797f, -0.09566196f, 0.00501384f, 0.01855294f, -0.11971519f, -0.20240366f, -0.00493204f, 
    0.04100531f, 0.01966357f, 0.03456493f, 0.07954942f, -0.05870918f, 0.05648262f, 0.28838399f, 0.17334190f, 
    -0.48638564f, -0.21924102f, -0.06751812f, 0.22229423f, 0.04509449f, 0.04355187f, 0.22759558f, -0.10087951f, 
    0.06987553f, 0.02471009f, -0.08529600f, 0.05245634f, -0.35139120f, -0.15342821f, -0.27560014f, -0.10651636f, 
    -0.03154957f, 0.07974992f, -0.04078216f, -0.03198427f, 0.05740586f, -0.03711309f, 0.13546516f, -0.09667612f, 
    -0.36493215f, -0.18017040f, -0.04284965f, 0.09788124f, 0.01011784f, 0.08151743f, -0.03627620f, -0.00955389f, 
    0.02162080f, -0.07161535f, -0.00105175f, 0.10765668f, -0.07278190f, 0.21137573f, 0.03870548f, 0.07124221f, 
    0.18489242f, 0.02282611f, 0.14561322f, 0.00189101f, 0.24198134f, -0.04291675f, -0.17124689f, 0.07112418f, 
    -0.24876413f, 0.01361228f, 0.09405795f, 0.07328833f, 0.02257011f, 0.00257088f, -0.01606273f, -0.08498310f, 
    0.06696787f, -0.21591006f, -0.00694714f, 0.02164207f, 0.04023825f, -0.03538056f, 0.22327563f, 0.20881866f, 
    0.12911800f, 0.14589487f, 0.01939956f, -0.03402608f, 0.05378260f, 0.00333924f, 0.02281589f, 0.03257155f, 
    0.04359610f, -0.01897694f, 0.03091902f, 0.01629302f, -0.08345105f, 0.04111892f, -0.01921371f, -0.07373977f, 
    -0.05134348f, -0.01107075f, 0.15463218f, -0.04142460f, 0.17464676f, -0.01105410f, -0.06225337f, 0.13503440f, 
    -0.02351628f, -0.05331972f, -0.02664007f, 0.07124960f, -0.06098524f, 0.02669138f, -0.07901299f, 0.06551612f, 
    -0.10005595f, 0.04141982f, -0.16489857f, 0.05706308f, 0.09570386f, 0.07244828f, 0.08539153f, 0.03134084f, 
    -0.01332692f, -0.22540522f, 0.03719844f, -0.11431173f, 0.08392897f, 0.12264343f, -0.01276288f, -0.16679464f, 
    -0.00167753f, -0.06955412f, -0.06776033f, -0.14690077f, 0.02578342f, 0.02132249f, -0.13027149f, 0.03506125f, 
    0.13265933f, 0.08735217f, 0.03833608f, 0.04342314f, -0.00694748f, 0.01835645f, 0.08468948f, 0.05919219f, 
    0.00967043f, -0.09622104f, 0.19765370f, -0.07223109f, -0.12760241f, -0.08269641f, -0.14020175f, -0.01793971f, 
    0.05435373f, -0.11724383f, 0.05583429f, 0.05174262f, -0.05101386f, 0.00451625f, 0.03727286f, 0.02619764f, 
    -0.17023300f, -0.03300787f, 0.02252886f, -0.05510191f, -0.00505021f, 0.05946606f, -0.08388000f, 0.06647474f, 
    -0.02938308f, -0.00742226f, 0.07802402f, -0.12240408f, 0.28322691f, 0.13961659f, -0.28917089f, -0.02054182f, 
    0.10909820f, 0.16612966f, 0.05760630f, 0.09798214f, 0.00951273f, -0.22068591f, -0.06301358f, -0.15385349f, 
    -0.09619870f, -0.08571150f, -0.09514052f, -0.05646515f, 0.00489865f, -0.13453881f, -0.02269676f, -0.06137207f, 
    -0.02785662f, -0.01907020f, -0.01133061f, 0.02512592f, 0.18072617f, 0.03676742f, 0.09797543f, 0.10011447f, 
    0.04393390f, -0.03742190f, -0.11318697f, 0.04497983f, -0.11399549f, -0.03702322f, 0.01845279f, -0.02672698f, 
    -0.08052431f, 0.08879201f, 0.10745683f, -0.28594401f, 0.03887080f, 0.03921231f, -0.02223969f, -0.05793897f, 
    0.05995202f, -0.03027654f, -0.00503472f, 0.06427521f, -0.00467018f, -0.01043032f, 0.10990980f, 0.17124243f, 
    -0.06086733f, -0.04768240f, 0.10891146f, -0.04423760f, -0.17106000f, 0.09401588f, -0.04550800f, 0.25181794f, 
    0.40602863f, 0.15546702f, -0.21503742f, -0.10882774f, 0.00735877f, -0.04829541f, -0.15915291f, -0.13750452f, 
    -0.04530421f, 0.05026900f, 0.02453890f, -0.06952526f, -0.39342928f, 0.18583903f, 0.13784721f, -0.05345740f, 
    -0.02487564f, 0.06793749f, -0.17019913f, -0.06273261f, -0.01149593f, -0.12825452f, -0.06475287f, -0.10108189f, 
    -0.38993129f, 0.04419610f, -0.08289369f, -0.12156208f, 0.11923683f, 0.02629470f, 0.12027913f, -0.13152915f, 
    0.04514891f, 0.03157838f, -0.03283264f, 0.03433345f, -0.02392419f, 0.07575428f, 0.06185870f, -0.31371656f, 
    0.02421068f, 0.01321899f, 0.06014686f, 0.07371689f, -0.09740572f, 0.05606659f, 0.04762159f, -0.02273489f, 
    -0.18211479f, -0.00069628f, -0.05492576f, 0.05976637f, -0.01689872f, -0.08084605f, -0.00873657f, -0.06136026f, 
    0.15326907f, 0.14726441f, 0.05276997f, 0.06200861f, 0.10170396f, 0.03873068f, -0.04665613f, 0.03169095f, 
    -0.02381026f, 0.05074278f, 0.08595555f, 0.13432932f, 0.12340850f, 0.02927468f, -0.03292235f, -0.03888955f, 
    -0.07032697f, 0.02611969f, 0.01089433f, -0.10036465f, 0.01800087f, 0.10339335f, -0.05525335f, 0.00904421f, 
    0.07451092f, -0.08974770f, 0.06792467f, -0.00301403f, -0.40552840f, 0.02118076f, -0.16597292f, -0.34124321f, 
    0.13295557f, 0.02328660f, -0.07628542f, 0.01700333f, -0.03100166f, -0.03626873f, -0.04372816f, -0.02413814f, 
    -0.07376353f, 0.17843297f, 0.18943782f, 0.15321405f, 0.03675285f, 0.09864094f, -0.02408294f, 0.11199471f, 
    -0.01730160f, 0.03264221f, 0.15829083f, -0.18512632f, -0.15814750f, -0.01049763f, 0.05073055f, 0.13480520f, 
    -0.01309847f, -0.01662212f, 0.04826032f, 0.01570940f, 0.11477140f, 0.04706972f, 0.01108442f, 0.11619103f, 
    0.03699840f, -0.01209573f, 0.18990013f, -0.20955744f, 0.00655495f, -0.03876522f, -0.04445018f, -0.18471244f, 
    -0.06325567f, 0.04451489f, -0.06648585f, -0.08151885f, -0.35257342f, -0.03487219f, -0.17143428f, -0.09373098f, 
    0.08380242f, 0.08156322f, -0.07644206f, -0.10774291f, 0.07847903f, -0.12199005f, 0.09957364f, -0.07978848f, 
    -0.02643210f, -0.12171023f, -0.08826523f, -0.06283896f, 0.00031711f, 0.08675002f, -0.11293667f, -0.17354792f, 
    -0.06390296f, -0.13632075f, -0.03174337f, -0.01134283f, 0.05701642f, 0.21014364f, 0.06825323f, 0.09290051f, 
    -0.08881278f, -0.05242170f, 0.05704214f, -0.05399904f, 0.00100058f, -0.21988589f, -0.06099028f, -0.04442979f, 
    0.13257012f, -0.00903606f, -0.08518538f, 0.06883966f, -0.04144556f, -0.12450870f, -0.10938048f, -0.04413621f, 
    0.01221652f, -0.05768953f, 0.06921417f, -0.13536608f, -0.05769264f, 0.08672380f, 0.03984043f, 0.09882387f, 
    -0.22286320f, -0.05291501f, 0.18888071f, 0.07206240f, 0.13157955f, 0.00017969f, 0.13205567f, 0.01097525f, 
    -0.05368193f, -0.01712685f, -0.07428990f, -0.02710322f, -0.04330296f, -0.10146399f, -0.05918470f, 0.04018980f, 
    0.02147785f, 0.08824762f, 0.00080048f, 0.16303267f, -0.01702615f, -0.14999589f, -0.23928232f, 0.07663132f, 
    0.01306321f, -0.13377820f, -0.03748829f, 0.04311983f, 0.05004581f, -0.05179714f, -0.07257373f, 0.08976349f, 
    -0.13073578f, -0.06237849f, -0.07989863f, 0.00134950f, 0.20590582f, 0.05200577f, -0.18360674f, -0.09588694f, 
    -0.10885090f, 0.02047407f, 0.00461353f, 0.11432046f, 0.07064210f, -0.00299310f, -0.01189211f, -0.03914004f, 
    -0.03811689f, -0.02092268f, 0.00723526f, 0.05370565f, 0.05481708f, 0.10028796f, 0.17683269f, 0.10946530f, 
    -0.02425359f, -0.00658653f, 0.14408775f, -0.06466204f, 0.01521449f, 0.04697600f, -0.06721068f, -0.10278299f, 
    0.12834343f, 0.00726068f, 0.03495002f, 0.02418837f, -0.19926223f, -0.05761734f, 0.31397873f, 0.13425279f, 
    0.04728408f, 0.04398295f, 0.12114033f, 0.05617329f, 0.12699419f, -0.02637461f, 0.05256710f, -0.03086443f, 
    0.11221822f, 0.19459487f, 0.10148871f, -0.22982153f, -0.04189226f, -0.11494609f, -0.11995377f, 0.07398686f, 
    -0.04152594f, -0.05178365f, 0.04875716f, -0.23122393f, -0.40316153f, -0.09204587f, -0.03816599f, -0.01334232f, 
    0.05127954f, -0.02469264f, 0.00013892f, 0.07993030f, 0.01733349f, 0.15413705f, 0.03473297f, -0.22740817f, 
    -0.12105762f, 0.00953090f, -0.06242494f, -0.04357178f, -0.06139769f, -0.09897905f, 0.11456997f, 0.00766456f, 
    0.03009009f, 0.04505247f, -0.16650032f, -0.08930397f, -0.01327111f, 0.12761806f, 0.07904584f, -0.04799853f, 
    -0.04822847f, 0.07798362f, -0.12047090f, -0.02809860f, 0.08211669f, -0.02458744f, 0.00317595f, -0.14367986f, 
    0.00025281f, -0.10519087f, 0.03249599f, -0.31294549f, -0.08366740f, -0.04932620f, -0.04287260f, -0.02861283f, 
    -0.04871995f, -0.10733750f, -0.11884255f, -0.14978929f, 0.04537402f, -0.08192505f, 0.06445166f, -0.06980103f, 
    0.04239299f, 0.06625610f, -0.01967230f, -0.04381944f, 0.00642591f, -0.04546438f, 0.07571244f, 0.02052054f, 
    -0.19372928f, -0.20878270f, -0.04132940f, -0.30815449f, 0.01562736f, 0.01285926f, -0.03667820f, -0.09824147f, 
    -0.08363231f, 0.08463223f, 0.01447914f, 0.09473488f, 0.25117543f, 0.02831707f, 0.06692383f, 0.34608430f, 
    -0.11920260f, -0.04069472f, -0.05825248f, -0.07977666f, 0.12056988f, -0.02969716f, -0.03800650f, -0.08065975f, 
    -0.14306857f, 0.04494092f, -0.08606755f, 0.06820008f, 0.07051273f, 0.04658378f, -0.11840665f, -0.11002779f, 
    -0.02952054f, 0.05817708f, 0.10698472f, -0.18529958f, 0.13384835f, 0.06418816f, -0.02977158f, 0.20570408f, 
    -0.10200236f, 0.13369061f, 0.10023795f, 0.01636372f, -0.05432686f, 0.16280511f, -0.01692374f, -0.00777691f, 
    -0.10940673f, 0.09720526f, 0.01700144f, -0.23903595f, 0.00404676f, 0.05554656f, 0.03569699f, -0.03202918f, 
    0.01371004f, 0.00618164f, 0.00365480f, 0.06424954f, -0.10426509f, 0.18682815f, -0.03460356f, -0.12761450f, 
    0.08873225f, 0.08641760f, 0.07171880f, 0.07654054f, -0.08621288f, 0.07541136f, 0.05898293f, 0.08227062f, 
    0.25674608f, -0.02767610f, -0.01704013f, -0.11495855f, -0.08002230f, 0.02721266f, 0.13294806f, -0.07235293f, 
    0.00584806f, 0.02162445f, -0.00037283f, -0.15215187f, 0.17351511f, 0.01765530f, -0.01937189f, -0.05221784f, 
    -0.06120570f, 0.15085830f, 0.02726758f, 0.04676438f, 0.03358680f, -0.01841457f, -0.04625458f, -0.06003518f, 
    -0.36028925f, 0.18906061f, -0.00756631f, 0.19589181f, -0.06608255f, 0.10027148f, 0.02781923f, 0.03137692f, 
    -0.06754056f, 0.16812177f, 0.07610855f, 0.04870214f, 0.13864638f, 0.18533683f, 0.13194045f, -0.41312021f, 
    0.05275778f, -0.08665605f, 0.03413457f, 0.01150030f, 0.11688433f, 0.11482602f, -0.03523807f, 0.01127113f, 
    -0.16070494f, 0.03596855f, 0.04322188f, 0.00111370f, 0.14362557f, 0.10132343f, -0.00726451f, -0.01715930f, 
    -0.12411178f, 0.05738542f, -0.06360885f, 0.00515875f, 0.16288865f, -0.29056883f, -0.12650158f, 0.28212100f, 
    0.12335606f, -0.01415052f, 0.06951048f, -0.04855260f, 0.05630195f, -0.05692919f, 0.01667272f, -0.01327029f, 
    0.03075307f, -0.17535780f, 0.07596825f, -0.08745671f, 0.02742004f, 0.02172313f, 0.02608656f, 0.03478716f, 
    0.03091882f, -0.08196376f, 0.00867062f, 0.03113759f, 0.05945594f, 0.20778762f, 0.01962558f, -0.12816983f, 
    0.14599688f, 0.05903012f, 0.03330196f, -0.00196998f, -0.13643035f, 0.07343819f, -0.08291220f, -0.00048059f, 
    -0.22137214f, 0.16566521f, 0.08890134f, -0.09767323f, -0.12591742f, 0.11334783f, -0.06307989f, 0.02116320f, 
    -0.14191937f, -0.06329945f, 0.02129307f, 0.07737882f, -0.09892041f, 0.03147637f, -0.07985630f, -0.19886878f, 
    -0.00210834f, -0.05209497f, -0.08305823f, -0.09903028f, -0.01109591f, -0.10645903f, 0.01733926f, -0.00688183f, 
    -0.19572999f, 0.02496807f, -0.16399056f, 0.17569579f, 0.08403026f, -0.03182015f, -0.07803775f, 0.14867292f, 
    -0.00771753f, -0.00204195f, 0.04688409f, -0.16545200f, 0.04445600f, -0.00717059f, -0.00176816f, -0.06132962f, 
    0.02182593f, -0.00922381f, -0.00930769f, -0.12041868f, 0.13303758f, -0.08970094f, -0.13461135f, -0.20054714f, 
    0.22089168f, -0.13345216f, -0.02650743f, -0.15349038f, -0.17655858f, 0.04657178f, -0.14226718f, -0.10288326f, 
    -0.21857677f, -0.00460376f, 0.02733680f, -0.08788788f, 0.04662472f, -0.06020717f, -0.04108159f, -0.03241445f, 
    -0.08906741f, 0.05022185f, -0.04894842f, -0.07034121f, -0.09187686f, 0.02303501f, -0.01300924f, 0.10555610f, 
    0.12030808f, 0.04651207f, -0.12665923f, -0.14299339f, -0.11283097f, -0.06456469f, -0.20433326f, -0.10665397f, 
    -0.14353950f, 0.11372504f, 0.05102308f, 0.02128240f, 0.16519046f, -0.33347416f, -0.01769822f, -0.12148331f, 
    -0.07064672f, -0.03021454f, -0.04650978f, -0.06808157f, -0.12637828f, 0.01874326f, -0.02766276f, -0.09752276f, 
    0.01764377f, -0.05353695f, 0.03577842f, 0.29602274f, 0.09455223f, 0.06235957f, 0.02208288f, -0.00856346f, 
    -0.07994848f, 0.10652066f, 0.10484735f, 0.08429922f, -0.06299677f, 0.05871149f, 0.01614536f, -0.00533256f, 
    -0.14527826f, -0.18559383f, 0.01713077f, 0.00564687f, -0.05028732f, 0.08403195f, -0.02953839f, 0.01482160f, 
    -0.30571982f, 0.22767942f, 0.05545638f, -0.03750121f, 0.15196377f, 0.10411642f, 0.05229128f, 0.09178171f, 
    -0.02622363f, 0.02390449f, -0.10683161f, 0.12061725f, 0.18221891f, 0.24830469f, -0.02567970f, -0.28449401f, 
    -0.02055527f, 0.05434144f, 0.01706969f, -0.00360663f, -0.01515881f, -0.06484415f, 0.03509260f, 0.01256482f, 
    0.12564890f, -0.14920808f, -0.14288408f, -0.18719152f, -0.15821303f, -0.04456739f, -0.11812627f, 0.00828235f, 
    0.01673547f, 0.05303195f, -0.03908299f, 0.15882461f, -0.45482475f, -0.20215476f, -0.00938494f, -0.01449489f, 
    0.08288437f, 0.02454297f, 0.01409724f, 0.10383524f, 0.07367475f, 0.01606489f, 0.02394743f, 0.01992287f, 
    -0.11914388f, 0.00259935f, -0.04032620f, 0.22959661f, -0.02430653f, -0.04205579f, -0.02108868f, 0.09274168f, 
    -0.00295180f, 0.07199418f, -0.03701657f, -0.03088892f, 0.28157565f, -0.18197216f, 0.13819306f, 0.02282207f, 
    -0.00109320f, 0.11325272f, 0.02235472f, -0.03428232f, 0.02242582f, 0.11867233f, 0.04251807f, 0.12772836f, 
    0.20650220f, 0.10492352f, 0.05376373f, 0.01724994f, 0.03126213f, -0.05663954f, 0.00111648f, 0.01025132f, 
    -0.09223522f, 0.08520635f, -0.02626753f, -0.04452383f, -0.16598640f, -0.08961117f, -0.26009306f, -0.08830313f, 
    -0.10900595f, -0.02623858f, -0.02107477f, -0.08096889f, 0.01890167f, 0.11775516f, -0.01015410f, 0.22262329f, 
    0.08680200f, 0.06272564f, 0.10235263f, -0.25463885f, 0.11775167f, 0.07755885f, 0.18769127f, -0.01065316f, 
    -0.22336483f, 0.00591000f, 0.01441545f, -0.01648379f, -0.25938985f, 0.15477656f, 0.08350619f, 0.03221602f, 
    -0.00438831f, -0.06161373f, 0.00998428f, 0.04371782f, 0.01706041f, -0.02115173f, 0.01099476f, 0.08807728f, 
    0.47454366f, -0.00351557f, 0.15441158f, 0.08303487f, -0.05122981f, -0.02380546f, 0.02326464f, 0.14534231f, 
    0.08495239f, 0.09416030f, -0.08267362f, -0.00105467f, -0.08644973f, 0.03757682f, -0.10028382f, -0.11555854f, 
    0.03422105f, 0.09998664f, -0.09262748f, -0.09377623f, -0.00184191f, -0.10794620f, -0.17723101f, -0.03054055f, 
    -0.29774761f, -0.12121084f, -0.30054268f, 0.20333414f, -0.00233609f, 0.06375375f, 0.02958444f, 0.07283408f, 
    0.03276488f, -0.09131017f, 0.09898901f, -0.04100583f, 0.27702552f, -0.16745698f, 0.10721399f, 0.04669062f, 
    0.04462070f, -0.03670694f, 0.04684667f, 0.05823186f, 0.07181267f, 0.01304275f, 0.04780798f, 0.04175987f, 
    -0.17731458f, -0.26495814f, 0.00629964f, -0.16317144f, -0.04567317f, 0.03954270f, 0.12060619f, 0.00156933f, 
    0.01272895f, 0.09562533f, -0.07394792f, -0.04335115f, 0.07648949f, 0.05959911f, 0.06284685f, -0.16037093f, 
    -0.03400576f, -0.02911399f, 0.02233617f, 0.02843604f, -0.05063599f, 0.04797550f, 0.14509837f, -0.19552696f, 
    -0.09615482f, 0.04286765f, -0.07674814f, -0.23927291f, -0.12906754f, 0.06331200f, 0.07010283f, 0.00953653f, 
    0.01053715f, 0.03298821f, -0.09220625f, -0.11031254f, -0.17285825f, -0.01744909f, 0.00826569f, -0.05920322f, 
    -0.04377441f, -0.07377538f, 0.01711200f, -0.00735638f, -0.05834216f, 0.08121364f, -0.00024828f, 0.03643176f, 
    0.01407745f, 0.17918150f, 0.07670508f, -0.15483084f, -0.00550716f, -0.03240650f, 0.01982650f, 0.01242791f, 
    -0.01203684f, 0.09657803f, -0.05435885f, 0.05807263f, 0.25116944f, -0.12271269f, 0.05036257f, -0.02920754f, 
    0.01658248f, 0.04184211f, 0.11328501f, 0.00267242f, 0.10905241f, 0.04496706f, 0.03741688f, -0.02535302f, 
    0.10288125f, 0.10045570f, -0.00194842f, 0.09586217f, 0.02988303f, -0.08260863f, -0.02212263f, 0.05206363f, 
    -0.04293833f, 0.05324744f, -0.00375283f, 0.01705959f, 0.02077398f, -0.03083770f, 0.10066798f, 0.11132990f, 
    -0.00148213f, -0.01484509f, -0.10192304f, -0.04636608f, -0.07942042f, 0.01493823f, -0.06134736f, -0.01511098f, 
    -0.22703801f, 0.11404806f, 0.14698112f, -0.08370864f, -0.14900844f, 0.00902334f, -0.00702336f, 0.11781666f, 
    -0.02495242f, -0.01367521f, -0.03568238f, 0.16286363f, -0.18445088f, -0.37403002f, -0.04885317f, -0.22524048f, 
    -0.08858811f, 0.03800156f, -0.08011341f, 0.03752349f, -0.02633945f, 0.07791294f, -0.08744076f, 0.20125328f, 
    -0.11756252f, -0.21885931f, 0.01433274f, 0.09541479f, -0.03944271f, -0.02129479f, 0.01316008f, 0.08675154f, 
    -0.01581642f, 0.06446303f, 0.00174851f, 0.12827480f, -0.18870495f, -0.06915166f, 0.08945043f, 0.21652013f, 
    0.15418263f, 0.08571365f, -0.08476987f, 0.02372100f, 0.01216879f, 0.01724731f, 0.02738956f, 0.02637322f, 
    -0.31853175f, -0.11192282f, 0.01082137f, 0.07306744f, 0.02562744f, -0.03499921f, 0.07451633f, 0.09424857f, 
    0.13889901f, 0.04131018f, -0.03725252f, 0.00046346f, -0.12306238f, -0.01822200f, -0.05877529f, 0.10866659f, 
    0.10684641f, 0.00871302f, -0.04827495f, -0.02330467f, -0.19401407f, -0.10544981f, -0.02809049f, 0.00262094f, 
    0.05782796f, -0.12937990f, 0.00904759f, 0.17715085f, 0.03631578f, 0.04490054f, 0.10049263f, -0.04222539f, 
    -0.11138055f, 0.05304694f, 0.00702767f, -0.31092533f, -0.21747606f, 0.06380148f, -0.12342677f, 0.26513919f, 
    0.00059193f, 0.04502558f, -0.03027891f, -0.07201655f, -0.10735906f, 0.07809655f, 0.07852533f, -0.04786721f, 
    -0.24824466f, 0.03638573f, -0.11156284f, -0.20096491f, -0.11106071f, -0.00505993f, 0.04088774f, -0.04584969f, 
    0.01967834f, -0.12314801f, -0.07307903f, -0.14211074f, -0.18619184f, 0.24058482f, 0.12157603f, -0.21558104f, 
    0.01088765f, 0.01165139f, 0.04534785f, -0.02234266f, -0.05824326f, 0.00342763f, -0.14579576f, -0.10016983f, 
    -0.07481658f, -0.33032298f, -0.10142269f, 0.27487502f, -0.01399608f, -0.09226961f, 0.09049552f, 0.05355451f, 
    -0.10360408f, -0.08771697f, -0.18256637f, 0.05536371f, 0.13579331f, -0.15378337f, -0.05980640f, 0.13912581f, 
    -0.09455753f, -0.05550527f, 0.01574958f, 0.01991889f, 0.02371446f, 0.08855164f, -0.08686980f, -0.05839933f, 
    0.19629666f, -0.36718208f, 0.31948459f, -0.22081965f, -0.06864823f, 0.01856898f, 0.00655955f, -0.12939592f, 
    -0.01905698f, 0.02256938f, 0.03578440f, 0.12758993f, -0.18843213f, 0.01937884f, 0.01199092f, -0.13837191f, 
    0.01779410f, -0.01691956f, 0.05772824f, -0.16463862f, -0.04873436f, -0.06884398f, 0.08898346f, 0.08670996f, 
    0.19637816f, -0.13988267f, 0.00696986f, -0.12215583f, 0.07995082f, 0.03510781f, -0.04743421f, -0.05271909f, 
    -0.00182664f, -0.11346877f, 0.17117323f, -0.11411287f, 0.32984138f, -0.12254038f, 0.04841430f, -0.15766789f, 
    0.12387685f, -0.12257303f, 0.02773456f, 0.04471596f, -0.08867617f, -0.06093450f, 0.22419065f, 0.13872938f, 
    -0.16181880f, -0.01212767f, -0.01465110f, -0.06992580f, -0.02351726f, -0.02861442f, 0.02417822f, -0.10087673f, 
    0.00934445f, 0.07807920f, -0.07846033f, -0.03567817f, 0.09606668f, 0.06191289f, 0.10893752f, -0.08669998f, 
    -0.06887001f, 0.07286365f, -0.06621026f, 0.00878087f, 0.04027412f, 0.01327089f, -0.06019995f, -0.05751161f, 
    0.18460727f, 0.05761245f, 0.18556295f, 0.07054210f, 0.05781015f, -0.00637839f, 0.01706177f, -0.07516881f, 
    -0.03054544f, 0.10144216f, -0.02581214f, -0.01602964f, -0.26889324f, 0.05729331f, 0.03913469f, 0.02056176f, 
    -0.11021563f, -0.02370259f, -0.01930825f, 0.04114055f, -0.02919975f, 0.05582076f, 0.06455670f, 0.01218293f, 
    -0.00861185f, 0.25853476f, 0.08732773f, 0.05496712f, -0.06303813f, 0.01118937f, -0.07086208f, -0.01650845f, 
    0.04011437f, 0.04587482f, 0.00381863f, -0.10035563f, 0.05416013f, 0.13561548f, -0.07325746f, 0.21615215f, 
    0.11361285f, -0.05551069f, 0.04580266f, 0.05683280f, -0.01645583f, 0.05781145f, 0.06418688f, 0.00743985f, 
    0.08218645f, 0.12373665f, -0.02347939f, 0.13209464f, -0.01679459f, -0.12648632f, -0.00268625f, -0.08009031f, 
    -0.09097569f, 0.00892622f, -0.12369513f, 0.04243103f, -0.23588817f, 0.01628201f, 0.08961225f, -0.10636231f, 
    -0.01843840f, -0.10279629f, -0.05756706f, -0.08027545f, -0.05468299f, -0.00772044f, -0.05657484f, 0.01664986f, 
    0.00906568f, 0.01736867f, 0.12517278f, -0.15968986f, -0.04009532f, 0.00328202f, -0.00797944f, -0.02470027f, 
    -0.01382837f, -0.09669094f, 0.02984283f, -0.07710740f, 0.02370103f, -0.10301876f, 0.17889650f, -0.11040340f, 
    -0.04174992f, -0.03993715f, 0.04870693f, -0.10297384f, -0.00645514f, 0.02409197f, -0.06110945f, -0.01199820f, 
    -0.07747661f, -0.07071875f, -0.13703102f, -0.20890881f, -0.04244836f, 0.03687268f, -0.04816665f, 0.01529533f, 
    -0.07982638f, 0.04539944f, -0.03377626f, -0.05462934f, -0.50820959f, -0.20365855f, 0.06902090f, -0.01050195f, 
    -0.06610037f, -0.07310668f, 0.01203114f, -0.06825997f, -0.10481431f, 0.06383204f, -0.06275638f, 0.01540345f, 
    0.11030186f, 0.01216422f, -0.15614885f, 0.06892937f, 0.01923515f, -0.07547591f, -0.01607114f, 0.01713829f, 
    -0.06272496f, -0.03655613f, -0.08522619f, -0.04409950f, -0.05084943f, 0.15265234f, -0.09581581f, 0.10926271f, 
    -0.04208953f, -0.03363483f, -0.05967594f, 0.00401940f, -0.00575944f, -0.00334834f, 0.03576555f, -0.06013345f, 
    -0.32297745f, 0.12508579f, -0.03891670f, 0.09287222f, -0.03753877f, -0.01070076f, -0.00373887f, -0.06234154f, 
    -0.04784772f, 0.01240684f, -0.01341089f, -0.06192923f, 0.01383082f, -0.12425783f, -0.16480139f, -0.15903775f, 
    -0.02169780f, -0.00970772f, 0.05023172f, -0.01943469f, 0.00325234f, -0.05300170f, 0.00314073f, -0.02096582f, 
    -0.20257415f, 0.17614488f, -0.00264332f, -0.04831580f, 0.01436673f, -0.05700262f, -0.09803265f, -0.03708412f, 
    -0.09850105f, 0.06579767f, 0.06485575f, -0.06522530f, 0.02822074f, 0.00488894f, 0.04769256f, 0.11274394f, 
    0.03301357f, 0.03719088f, -0.01414259f, -0.08987515f, -0.01329163f, -0.02637430f, -0.09043700f, -0.03470494f, 
    -0.11674014f, 0.08461938f, -0.07289538f, 0.10360682f, -0.00188932f, -0.06374459f, -0.01871312f, -0.05599093f, 
    -0.02125765f, 0.03208834f, -0.05526403f, -0.09022094f, 0.07601108f, -0.04135226f, 0.05255655f, 0.00697854f, 
    0.02788646f, 0.00882681f, 0.06867789f, 0.02355978f, 0.04333797f, 0.00038413f, -0.01974048f, -0.14392647f, 
    0.03259343f, 0.13744390f, 0.09447499f, 0.21021077f, 0.15667322f, 0.12400877f, 0.05466886f, 0.00152236f, 
    -0.01904105f, 0.05239001f, 0.00349237f, -0.01537812f, -0.05807506f, 0.15792812f, 0.06941401f, 0.06689836f, 
    -0.03937911f, 0.05698304f, -0.02222698f, -0.00780059f, -0.01548529f, 0.00199578f, -0.00911934f, -0.05989036f, 
    0.06738593f, 0.17093241f, 0.05504313f, 0.17988127f, 0.11583769f, -0.03410911f, -0.00206155f, 0.00856646f, 
    -0.06515125f, 0.00641788f, -0.00868216f, -0.05332108f, 0.13818024f, -0.08876697f, 0.17394862f, -0.03363357f, 
    0.04250387f, 0.04009894f, -0.00908721f, 0.03310990f, -0.06758074f, 0.01555569f, 0.08033010f, -0.04757547f, 
    -0.18916963f, -0.06223662f, -0.28892529f, -0.07687078f, -0.06722528f, -0.09458384f, -0.05971164f, -0.04290217f, 
    -0.01719831f, -0.04995758f, -0.05901007f, -0.04115962f, -0.17729880f, -0.02588319f, -0.03554140f, -0.08518136f, 
    0.00258128f, -0.02218761f, 0.01219905f, -0.08347505f, -0.01062916f, -0.03219743f, -0.00939582f, -0.07205682f, 
    -0.15929174f, -0.13804702f, -0.05562368f, 0.04195820f, -0.05254551f, 0.01210446f, -0.05382608f, -0.03204296f, 
    -0.06826526f, -0.00259222f, 0.06181129f, -0.02748919f, -0.12419742f, -0.14223342f, -0.22349641f, 0.02642089f, 
    -0.06451361f, -0.13450179f, -0.03984523f, -0.08249533f, -0.02442206f, -0.01614332f, 0.02734795f, 0.04498972f, 
    0.10207410f, 0.14693016f, 0.11981351f, 0.20190328f, 0.05131468f, 0.11932298f, 0.01589494f, 0.06742585f, 
    -0.10169561f, -0.03337659f, 0.02051450f, 0.02218810f, -0.21701546f, 0.02814348f, 0.06624882f, -0.00545608f, 
    -0.05198942f, 0.01141702f, -0.00501556f, -0.09661187f, 0.01935574f, 0.05120531f, -0.03840227f, -0.02623154f, 
    -0.22151136f, -0.02769695f, 0.04475810f, -0.14237604f, -0.06481116f, 0.04079426f, 0.03114466f, -0.04787660f, 
    -0.04917040f, -0.11361034f, -0.08396622f, 0.02042671f, 0.18060243f, -0.09248874f, 0.02303767f, 0.02999800f, 
    0.07895678f, -0.05172770f, 0.01991555f, -0.02161787f, 0.00631583f, 0.02835211f, -0.02027581f, -0.05233345f, 
    0.11922412f, -0.00351508f, -0.16174841f, -0.02730406f, -0.06206608f, 0.00118308f, -0.05113573f, -0.01276276f, 
    -0.11586411f, -0.02376687f, -0.04551462f, -0.01215309f, 0.08528756f, 0.17591031f, 0.13728912f, 0.15007423f, 
    0.09836407f, 0.03589749f, 0.07765041f, 0.02304685f, -0.06849261f, 0.01707705f, 0.01081784f, -0.07211403f, 
    0.04625443f, 0.02122092f, -0.01565311f, 0.01991804f, 0.05248256f, 0.07669005f, -0.04566414f, -0.03893176f, 
    -0.06522475f, -0.00737862f, 0.02570179f, -0.14653490f, 0.01503164f, -0.02246321f, -0.00790128f, -0.15420172f, 
    -0.03615428f, 0.00948154f, 0.05689928f, -0.05757355f, -0.06534888f, -0.01793169f, 0.01900730f, -0.06109423f, 
    0.13219309f, 0.06308824f, -0.19034515f, -0.04211541f, -0.10282340f, 0.00789824f, -0.00556073f, -0.10281724f, 
    -0.07561950f, -0.04084696f, -0.01414596f, 0.02718891f, 0.03655281f, -0.05677036f, 0.08550207f, 0.00250520f, 
    -0.09114008f, -0.00716057f, -0.00717812f, -0.03043833f, -0.06705721f, -0.00278769f, -0.05405506f, 0.01529889f, 
    0.12800142f, 0.15531226f, -0.14876691f, -0.01785569f, 0.01857703f, -0.03325092f, 0.02303281f, 0.04757547f, 
    0.06926104f, -0.00529676f, -0.02394517f, 0.03653155f, 0.09600778f, -0.10817671f, -0.04502765f, -0.07736378f, 
    -0.04841898f, -0.00829142f, 0.00697433f, -0.12567380f, -0.02826089f, -0.07367289f, 0.01735420f, -0.00987003f, 
    -0.04743859f, 0.08674457f, 0.05852257f, 0.08948924f, -0.00663087f, 0.05825948f, -0.04849037f, 0.00980313f, 
    -0.01421623f, -0.01007408f, -0.02866991f, -0.03429545f, -0.10806587f, 0.00177391f, -0.09705506f, -0.22597878f, 
    0.06927439f, -0.00127325f, -0.00596746f, -0.12853131f, -0.08480429f, 0.01143537f, 0.00030840f, -0.06661385f, 
    0.07187504f, 0.17590117f, -0.02394170f, -0.00894407f, -0.13068230f, -0.04515880f, -0.02474063f, -0.09972489f, 
    -0.09863271f, 0.01562710f, -0.10256886f, -0.03315926f, -0.19190302f, 0.12736695f, -0.15097944f, -0.14115059f, 
    -0.02817285f, -0.04490389f, -0.05540825f, -0.00668557f, -0.02017131f, 0.05162239f, 0.02485032f, -0.00687938f, 
    -0.16478123f, 0.07389608f, 0.01065131f, -0.27327231f, 0.07620132f, 0.04697327f, -0.00726224f, -0.02256343f, 
    -0.06120687f, -0.06687147f, -0.01941116f, -0.00577698f, 0.26082528f, -0.14817797f, 0.14260161f, -0.08110178f, 
    -0.02925686f, 0.02362039f, -0.02483181f, -0.02341210f, -0.00288098f, 0.04731800f, -0.04668582f, 0.02466201f, 
    0.07348686f, -0.01262966f, -0.08145875f, 0.17532532f, 0.00773035f, -0.08546834f, 0.00199099f, -0.02360147f, 
    -0.07872784f, 0.04865423f, 0.00900515f, -0.00838923f, -0.11083741f, 0.01032529f, 0.05198752f, 0.09017333f, 
    0.07069100f, -0.06094146f, -0.02127989f, -0.00701434f, -0.02134222f, 0.01272720f, 0.02887948f, -0.01868592f, 
    -0.17820843f, 0.01050607f, -0.11292819f, -0.06341417f, -0.08902411f, 0.02036701f, -0.04481334f, -0.03877650f, 
    -0.04015741f, -0.04367106f, -0.12760243f, -0.10729638f, -0.03223358f, 0.05821220f, 0.09392435f, 0.12214617f, 
    0.11156350f, 0.05219347f, 0.08051577f, -0.01195077f, -0.04375489f, -0.00308640f, 0.05358702f, 0.01633674f, 
    -0.09077248f, 0.12068585f, 0.04428956f, 0.10893829f, 0.08638323f, -0.05415329f, 0.12772793f, -0.00609157f, 
    -0.00768850f, -0.01550211f, -0.05106376f, -0.09008956f, 0.01604878f, 0.12994024f, -0.09011938f, 0.06618734f, 
    -0.14319420f, -0.02790814f, -0.01617601f, -0.00384740f, 0.01209097f, -0.00902017f, 0.04862282f, -0.09740220f, 
    0.05785466f, -0.01550139f, 0.03581962f, -0.11668554f, 0.08941943f, -0.00851243f, -0.01578065f, 0.01051768f, 
    -0.03081869f, -0.03627250f, -0.05283257f, -0.03314568f, 0.10874109f, -0.09274875f, 0.03598068f, 0.19103165f, 
    -0.05317453f, -0.16105360f, -0.09272927f, 0.03242893f, -0.08228242f, -0.01978283f, -0.07071473f, -0.10419919f, 
    0.34266311f, -0.03188768f, 0.10710427f, 0.05948341f, 0.14847034f, 0.00133687f, -0.02877015f, 0.00827910f, 
    -0.07746868f, -0.09223125f, -0.01882533f, -0.03586745f, 0.05586090f, 0.12001473f, 0.03681188f, 0.17546922f, 
    0.08131842f, -0.00411440f, 0.07741923f, 0.01407341f, 0.03658462f, -0.00105190f, 0.01491223f, -0.04527249f, 
    0.11162515f, 0.15555662f, 0.07411409f, 0.11357407f, 0.11684214f, 0.00684343f, 0.01159062f, 0.02040238f, 
    0.05362858f, 0.04290134f, -0.05576070f, -0.10737535f, -0.19222465f, -0.10175167f, -0.08160497f, -0.13562198f, 
    0.06656927f, -0.12083529f, -0.06485938f, -0.07015932f, -0.05525827f, 0.01804778f, 0.05822897f, 0.04357328f, 
    0.12812364f, -0.07024467f, 0.07397576f, 0.09172086f, 0.02371491f, -0.01123171f, -0.02361718f, -0.07805189f, 
    0.03690713f, -0.10460012f, -0.03874923f, 0.03426456f, -0.07356185f, 0.06228102f, -0.01535473f, -0.09438104f, 
    -0.03983286f, 0.00889784f, 0.01889703f, -0.09628926f, -0.06211765f, -0.01889233f, 0.00445955f, -0.04045786f, 
    -0.06739156f, 0.19993307f, 0.03593688f, -0.14200856f, -0.07847827f, 0.04410622f, -0.01623009f, 0.02025397f, 
    -0.04004914f, 0.03242338f, -0.07614084f, -0.05198029f, 0.15879972f, 0.08130571f, 0.14434023f, -0.05867676f, 
    -0.09974017f, 0.04874533f, -0.00874694f, -0.03780071f, -0.01241274f, -0.00635211f, 0.00631852f, 0.05438002f, 
    0.21801914f, 0.04329336f, 0.04090505f, 0.14592643f, 0.11610680f, 0.03198580f, 0.03298297f, -0.01288277f, 
    -0.00830622f, -0.04261755f, 0.00988182f, -0.10594113f, 0.17539704f, -0.12304549f, -0.03067072f, -0.19773868f, 
    -0.06635501f, -0.00896630f, -0.06839999f, -0.05931310f, -0.00386811f, -0.00032846f, 0.06649975f, -0.00237107f, 
    0.11293763f, -0.10837188f, -0.07526135f, 0.19354306f, -0.02033777f, -0.04745871f, -0.03189637f, -0.03569796f, 
    0.04154169f, -0.01570661f, 0.07417378f, 0.03490889f, -0.06554467f, 0.19457558f, -0.21830180f, -0.15388584f, 
    0.00011484f, 0.02167435f, 0.03835731f, 0.01892634f, 0.06115397f, 0.04455812f, -0.11101847f, 0.14010482f, 
    -0.23243673f, -0.07900376f, 0.09716561f, 0.03677990f, -0.08524004f, 0.03182455f, -0.17553115f, -0.02073586f, 
    0.07107016f, -0.15872459f, -0.01990847f, 0.04187426f, -0.03054159f, -0.00425399f, -0.06547195f, -0.13812156f, 
    -0.01460601f, -0.07382379f, -0.09306727f, -0.02829778f, 0.07320496f, -0.00402396f, 0.02072087f, 0.04311870f, 
    -0.03698484f, 0.22103862f, 0.02562374f, 0.09687372f, -0.02716637f, -0.03310689f, -0.08467422f, 0.00868082f, 
    0.04215771f, -0.11799387f, 0.02455014f, 0.07279270f, 0.11946762f, 0.00383363f, -0.18302689f, -0.21115588f, 
    0.12240649f, -0.11661717f, 0.08648163f, 0.00404422f, 0.12088475f, -0.14389895f, -0.01501651f, -0.03421459f, 
    -0.06609499f, -0.06236188f, 0.09627556f, -0.10363725f, 0.00940638f, 0.03112435f, -0.05719846f, 0.07246694f, 
    0.11354773f, 0.08523289f, -0.02226989f, -0.20901211f, 0.00236563f, -0.02577602f, -0.04938704f, 0.15738314f, 
    0.05045554f, -0.00570195f, -0.03759969f, -0.03636963f, 0.01580295f, -0.02101914f, -0.02798564f, -0.09439573f, 
    -0.15791786f, -0.17510659f, 0.11491791f, 0.14667600f, -0.05654170f, -0.09607650f, -0.06320424f, 0.11056399f, 
    0.06431036f, 0.12951402f, -0.10923039f, -0.02194715f, -0.18135583f, -0.04472341f, -0.04739594f, -0.15834510f, 
    -0.12460253f, -0.06849350f, -0.06110278f, 0.04409660f, -0.02082335f, 0.00469128f, -0.02072681f, 0.06350669f, 
    0.17300326f, 0.14530283f, 0.03397835f, -0.13707761f, 0.07087531f, 0.01816034f, 0.03881997f, -0.07993748f, 
    0.11279795f, 0.00057677f, -0.19692278f, 0.12390691f, -0.06767031f, -0.19938612f, -0.14285025f, 0.17604996f, 
    0.11786511f, -0.01557186f, -0.06773119f, -0.04228298f, 0.03383683f, -0.13936996f, 0.12370398f, -0.00552568f, 
    -0.14653893f, 0.14545935f, 0.03943836f, -0.14300369f, -0.00640293f, -0.00665778f, 0.00168039f, 0.08382829f, 
    0.06986676f, -0.05647194f, 0.03105781f, 0.08425052f, -0.02166700f, 0.19642749f, -0.23306270f, -0.12928806f, 
    0.05189385f, -0.06065477f, -0.18072258f, -0.00339902f, 0.05532544f, -0.03407215f, 0.03313919f, -0.06344954f, 
    -0.15593447f, -0.11454181f, -0.09396486f, -0.00928309f, 0.02743740f, -0.10048592f, -0.12619364f, -0.02100988f, 
    0.10202977f, 0.10498042f, 0.10639729f, -0.09504697f, -0.04890294f, -0.05917396f, -0.18160780f, -0.00262651f, 
    0.06293224f, -0.04158357f, 0.04089081f, 0.08023721f, 0.09736533f, 0.04155459f, 0.18188338f, 0.10238614f, 
    0.03763563f, -0.06128097f, -0.08212070f, 0.08904422f, 0.02416132f, -0.06467561f, -0.02650265f, 0.04535630f, 
    0.12461070f, -0.00823613f, 0.03553927f, -0.15601045f, -0.15697527f, -0.14465725f, 0.04722380f, -0.23604767f, 
    0.01118909f, 0.03834996f, 0.11814793f, 0.02854311f, -0.08082053f, -0.08148639f, 0.06916831f, -0.02366204f, 
    -0.05088713f, 0.25297648f, -0.18526319f, -0.01028090f, 0.03995945f, 0.00310439f, -0.05783400f, -0.16022620f, 
    0.03817539f, -0.02629709f, 0.00678872f, -0.00095565f, -0.06522197f, -0.17868447f, -0.03891798f, -0.09012955f, 
    -0.05261874f, 0.03829686f, 0.05274609f, -0.03947795f, -0.02201348f, 0.01837286f, 0.01865028f, 0.07301572f, 
    -0.06238732f, -0.12591983f, 0.13436931f, 0.01848869f, -0.01668652f, 0.02558297f, 0.13064219f, -0.10804900f, 
    0.01100245f, -0.00442641f, -0.02671747f, -0.00077869f, 0.04655812f, 0.14375970f, 0.07367216f, -0.02563634f, 
    0.00538925f, 0.05338310f, -0.03651178f, -0.07846233f, 0.02750940f, -0.00243254f, 0.05876442f, -0.13164623f, 
    -0.19030862f, 0.08032099f, 0.10221479f, -0.14321020f, 0.04670457f, -0.13253038f, 0.00304700f, -0.11433216f, 
    -0.03728402f, 0.06224929f, 0.05813148f, 0.09051932f, -0.01595242f, -0.14489709f, 0.03288621f, -0.11859839f, 
    -0.01692932f, 0.05419153f, 0.10292181f, -0.15409248f, 0.01760898f, 0.05643651f, -0.15286531f, 0.12237518f, 
    -0.04815690f, 0.18337303f, -0.08118998f, -0.04817223f, 0.02137216f, 0.02686052f, -0.07753225f, -0.18860269f, 
    0.05071742f, -0.06001778f, -0.00613270f, -0.02495715f, 0.14605078f, -0.00590609f, -0.10392784f, 0.15394787f, 
    0.10451498f, 0.04026401f, -0.08280265f, -0.05781322f, 0.00539926f, -0.06600838f, 0.03001676f, 0.01919468f, 
    -0.04458236f, -0.06560830f, -0.08216860f, 0.12681988f, 0.08490247f, 0.02335925f, -0.07672846f, -0.03921498f, 
    0.00865227f, 0.03797176f, 0.05603695f, 0.03772302f, -0.16148508f, -0.12219381f, -0.13339214f, -0.04509781f, 
    -0.01054387f, -0.09216466f, -0.03211026f, 0.08579311f, 0.08792967f, 0.03087975f, -0.00896141f, -0.04229756f, 
    -0.17714654f, -0.08678620f, 0.05095166f, -0.17432319f, -0.04674154f, -0.04840415f, 0.04055787f, -0.05573154f, 
    -0.01686135f, -0.05628822f, -0.09087145f, -0.07369699f, 0.00691132f, 0.10591347f, 0.02566001f, 0.13803315f, 
    -0.03315658f, -0.01328180f, -0.04163783f, -0.07849968f, -0.10105095f, -0.05365393f, -0.02449157f, 0.02942017f, 
    0.20054142f, 0.14037888f, -0.14306408f, 0.06955545f, 0.09476063f, -0.00784203f, -0.07578374f, -0.02040182f, 
    -0.02246538f, -0.00281633f, 0.00536500f, 0.01048877f, 0.11382578f, -0.08361411f, 0.09107869f, -0.04646127f, 
    0.04781523f, 0.05990625f, 0.07964481f, -0.02873341f, -0.02890190f, -0.09743606f, -0.04730673f, -0.03947996f, 
    0.03239287f, -0.04170842f, -0.02894631f, 0.02065527f, 0.02410265f, -0.01446189f, -0.02984129f, -0.06904741f, 
    0.03874607f, 0.00305535f, 0.03966972f, 0.02084437f, -0.02743442f, -0.05816101f, 0.03750931f, -0.00220814f, 
    -0.04568277f, -0.04215932f, -0.08224376f, -0.04591488f, -0.02344520f, -0.11963907f, -0.01296880f, -0.10207754f, 
    -0.28543305f, -0.08354428f, 0.02606676f, -0.02675224f, -0.05735010f, -0.07479756f, 0.03438122f, 0.07330601f, 
    0.04754454f, 0.06797164f, 0.01994865f, 0.09686808f, 0.09048428f, -0.05776081f, 0.01996636f, 0.02724191f, 
    0.09731617f, -0.03802337f, -0.03698818f, 0.01039096f, 0.04492309f, 0.01422446f, 0.03036937f, -0.05704661f, 
    0.14266045f, -0.05888160f, -0.06926014f, 0.08914975f, 0.06920848f, -0.05527120f, 0.02011280f, -0.08496894f, 
    0.06630281f, 0.04803617f, -0.05138804f, 0.04313368f, -0.09624491f, 0.07968455f, 0.03686762f, -0.13258532f, 
    0.00698985f, 0.05968866f, -0.02071963f, -0.01446393f, 0.03689506f, 0.12244212f, -0.00976578f, 0.08870971f, 
    0.12298547f, 0.19678929f, -0.08493820f, -0.02131348f, -0.05639423f, 0.11148448f, -0.13524812f, -0.00965010f, 
    -0.09621166f, -0.05957780f, -0.07914407f, -0.10259490f, 0.13396707f, -0.05456100f, 0.10495011f, 0.15376632f, 
    -0.00923247f, -0.00444936f, -0.08198027f, -0.03820735f, -0.01046201f, -0.07849953f, 0.01057455f, -0.08245324f, 
    -0.11360311f, 0.01722035f, 0.16943651f, 0.03058562f, -0.05053965f, 0.00417890f, 0.03384545f, -0.07422174f, 
    -0.08881284f, -0.00995061f, 0.00031826f, -0.00934495f, -0.19717322f, -0.13381696f, 0.02287209f, 0.07985903f, 
    0.05544503f, -0.08136842f, -0.04096328f, -0.00015815f, 0.05180430f, -0.03017606f, -0.07483389f, -0.00498242f, 
    -0.17314409f, -0.01107634f, 0.22281036f, 0.09043998f, -0.11468025f, -0.04736309f, -0.03006111f, -0.08839834f, 
    0.03186662f, 0.08512094f, 0.00805118f, 0.00846214f, -0.17535514f, 0.05675944f, 0.07511453f, 0.09364870f, 
    0.02506627f, 0.02187982f, -0.05943973f, 0.02904524f, 0.01548488f, -0.11111674f, -0.02848381f, 0.02588029f, 
    0.09085526f, -0.03850932f, 0.01637968f, 0.10564560f, 0.15781358f, -0.01362846f, -0.03440810f, -0.00426837f, 
    -0.04394266f, -0.04744350f, 0.02429693f, -0.06326637f, -0.29236928f, -0.04544643f, 0.11882316f, -0.03631371f, 
    -0.04569383f, -0.07956801f, 0.09037645f, -0.14741117f, 0.03249396f, 0.03519707f, -0.02475442f, 0.01601080f, 
    -0.05466351f, -0.16471796f, -0.13715678f, -0.30338129f, -0.06534031f, -0.05990898f, 0.10205372f, 0.00767997f, 
    0.08459263f, 0.00581007f, 0.03957792f, -0.04473456f, -0.10067344f, -0.05194291f, 0.07207865f, -0.14135912f, 
    -0.08190954f, -0.11359394f, 0.02529094f, 0.01924825f, -0.10838963f, 0.05065785f, 0.09160005f, 0.06206368f, 
    0.17558728f, 0.04064624f, 0.04615768f, 0.17532299f, 0.06721861f, -0.04398609f, 0.02599928f, -0.05870837f, 
    -0.10495619f, 0.00005085f, -0.08606756f, -0.03681286f, -0.13820255f, -0.06194374f, 0.24255757f, 0.10062020f, 
    -0.05843575f, -0.02896969f, -0.13176981f, -0.17623959f, 0.00965942f, -0.00103896f, 0.10878869f, -0.24529436f, 
    0.00651165f, -0.05714921f, 0.07802048f, 0.01557295f, -0.07660254f, -0.09055869f, -0.11333206f, -0.05785858f, 
    0.02227821f, -0.11866055f, 0.02527385f, 0.08777175f, 0.01828477f, 0.00828073f, -0.17647183f, -0.12157928f, 
    0.05149599f, -0.04894245f, -0.01248995f, -0.03522858f, 0.11814164f, 0.02271892f, 0.01561895f, 0.10363973f, 
    -0.01515190f, 0.02978779f, 0.01481407f, -0.04833851f, 0.06347577f, -0.10093361f, -0.00335294f, -0.09190894f, 
    -0.04320851f, -0.02055895f, -0.07496969f, 0.04909023f, 0.07507176f, -0.03689677f, -0.14762683f, -0.17551872f, 
    0.05465522f, -0.00206145f, -0.05425231f, -0.03499205f, 0.02961352f, 0.06883384f, 0.00078159f, 0.01536042f, 
    0.20215631f, -0.03598206f, -0.18556853f, 0.01436333f, -0.00660042f, -0.03151758f, 0.04164844f, -0.04100171f, 
    0.05944271f, 0.07093690f, 0.06109530f, 0.09985550f, 0.10055536f, 0.04854107f, 0.11376851f, 0.04680224f, 
    -0.06387422f, -0.03692566f, 0.12822676f, 0.00262979f, -0.00809133f, -0.08466071f, 0.08702389f, 0.02302495f, 
    -0.26357561f, 0.06549173f, 0.00267707f, -0.22746293f, -0.01687029f, -0.00160159f, -0.05306453f, -0.05375335f, 
    0.03230217f, -0.06035801f, 0.00426831f, 0.02239495f, -0.08402271f, -0.20460774f, 0.08999664f, 0.08900119f, 
    0.13296002f, 0.10013343f, -0.02860641f, -0.01391830f, 0.16022615f, 0.01617829f, 0.06887627f, 0.03482603f, 
    0.19755128f, 0.15158831f, -0.02507500f, 0.15439653f, -0.03551988f, -0.14365683f, -0.08516183f, -0.04116741f, 
    -0.00732136f, -0.00365020f, -0.02585239f, -0.05066689f, 0.08077469f, 0.02762821f, 0.05551434f, 0.05506211f, 
    0.03947872f, -0.00989387f, 0.02771951f, -0.06980142f, 0.06170223f, -0.02243837f, 0.03298292f, -0.10369626f, 
    0.27015415f, -0.04554179f, 0.11683815f, 0.00942948f, -0.13381074f, -0.08385052f, 0.02055297f, 0.08744949f, 
    0.12399267f, 0.03835572f, -0.07119082f, -0.08069841f, 0.01042757f, 0.10070515f, 0.03118437f, -0.03322143f, 
    0.04172457f, 0.02527849f, -0.00305191f, 0.05875860f, -0.03206329f, 0.04631826f, 0.05427545f, -0.12567537f, 
    -0.19049996f, -0.13732205f, 0.01761968f, -0.23745735f, -0.01710668f, -0.16962144f, 0.04174250f, 0.08083934f, 
    -0.00240353f, 0.10293841f, -0.14381550f, 0.09490989f, 0.13044381f, -0.12468848f, 0.02393391f, 0.03253454f, 
    -0.04097681f, -0.00122074f, 0.00682769f, -0.12466273f, 0.02409111f, -0.06196091f, -0.06939460f, -0.15351522f, 
    0.11639877f, 0.16593149f, -0.33623815f, -0.19015732f, 0.14204469f, 0.06230396f, -0.02393684f, 0.08390976f, 
    -0.14845362f, -0.07819465f, -0.25034088f, -0.08347552f, -0.27390403f, 0.10029826f, -0.14845471f, 0.11284034f, 
    0.04991152f, -0.01598612f, 0.02425061f, 0.09625421f, 0.00085960f, 0.02783724f, 0.07580949f, 0.09997390f, 
    0.13307607f, -0.11026990f, -0.21217428f, 0.03186112f, -0.02954821f, 0.02057289f, 0.07904351f, -0.07036029f, 
    -0.10226192f, 0.00788852f, -0.10096008f, -0.07009722f, -0.27823696f, -0.05189120f, 0.05728930f, -0.01932053f, 
    0.05727893f, 0.01677735f, 0.00163278f, 0.14663051f, -0.00556628f, 0.05969575f, 0.06243236f, -0.13222718f, 
    -0.02613462f, 0.12820964f, 0.04879078f, -0.00587643f, -0.00849047f, 0.00109138f, -0.05376321f, 0.05397710f, 
    -0.02052899f, -0.02348937f, 0.05581785f, -0.01764097f, -0.38377860f, -0.34746963f, 0.21957766f, -0.18694407f, 
    -0.02566774f, -0.02327588f, -0.06522872f, 0.00888066f, 0.01507484f, -0.01770592f, 0.16241722f, 0.03857313f, 
    -0.13368981f, 0.07899496f, -0.17903636f, 0.03427263f, -0.05027337f, -0.13389744f, 0.06570529f, -0.17332597f, 
    0.10234948f, -0.01800468f, 0.01674329f, 0.04598976f, -0.03378347f, -0.12417421f, -0.08638272f, -0.23241466f, 
    -0.10689072f, 0.03463444f, -0.06744848f, 0.02430190f, 0.04959200f, 0.03040635f, -0.06604307f, -0.00181990f, 
    -0.16047145f, 0.16741298f, 0.10296121f, 0.08145756f, -0.08359839f, 0.01890108f, -0.03215078f, 0.05600700f, 
    -0.00988903f, 0.00521830f, 0.01791304f, -0.05104802f, -0.15928666f, 0.00990682f, -0.14639169f, 0.08626353f, 
    -0.04948710f, -0.06493570f, 0.09927367f, -0.02754216f, 0.08553431f, -0.00201717f, -0.04062203f, -0.05411191f, 
    0.50494432f, 0.12344398f, 0.02268847f, -0.04049091f, -0.02289710f, 0.10906968f, 0.10951205f, -0.02823481f, 
    -0.01913955f, -0.01521244f, 0.02127155f, -0.06990525f, -0.18477648f, -0.00655975f, 0.07869492f, -0.17818525f, 
    -0.02678605f, -0.16070475f, -0.14844638f, 0.00871382f, 0.00426339f, 0.07678578f, -0.04949860f, -0.14949831f, 
    0.56418312f, 0.04034587f, -0.04260969f, -0.21036556f, 0.06650756f, -0.07192588f, -0.09437490f, -0.12421300f, 
    -0.16827637f, -0.02178391f, 0.11998963f, 0.04185037f, -0.29604346f, 0.06958693f, 0.30484203f, 0.00128428f, 
    0.00775299f, 0.02255947f, 0.02616700f, -0.05000696f, -0.01556049f, 0.01400343f, -0.03502494f, 0.03055709f, 
    -0.12788887f, 0.27677840f, -0.21251529f, -0.20445372f, -0.02018254f, -0.00337593f, -0.09070803f, 0.15412590f, 
    0.03029602f, -0.01569576f, -0.07995317f, 0.00781921f, 0.00944203f, -0.06841527f, 0.16993485f, -0.12419787f, 
    0.04426210f, 0.04076537f, -0.00878901f, 0.00707084f, 0.04223303f, -0.11505162f, -0.01826500f, -0.08226166f, 
    -0.46966964f, 0.14397608f, -0.15184717f, -0.08557208f, 0.07628284f, 0.01989578f, 0.07762823f, -0.03411497f, 
    -0.15535079f, 0.01365859f, 0.05417316f, 0.02271785f, -0.03023329f, -0.04013661f, -0.08508692f, 0.00831423f, 
    -0.00071338f, -0.03526133f, 0.04184598f, 0.01168421f, -0.01228364f, 0.04580889f, -0.18199638f, 0.06628203f, 
    -0.10165861f, 0.10484897f, 0.08668765f, 0.23716587f, -0.06245432f, 0.08030476f, -0.04713786f, 0.02487269f, 
    -0.06389121f, -0.00314022f, 0.03868027f, 0.09528763f, 0.02562876f, 0.16074498f, -0.10436233f, -0.00315321f, 
    0.03364702f, 0.01044243f, 0.02723480f, -0.01406330f, 0.06733589f, 0.06554197f, -0.17675506f, -0.07672123f, 
    -0.29265669f, -0.21200393f, -0.14146568f, -0.01706937f, 0.08250217f, -0.10045866f, 0.03239891f, 0.00797239f, 
    0.02373364f, -0.03336509f, 0.11329632f, 0.04092206f, -0.21020217f, 0.06307419f, 0.19827726f, -0.01183395f, 
    0.13569790f, -0.06047935f, 0.01277645f, -0.05421958f, 0.15486336f, 0.05832458f, -0.03797435f, 0.11174956f, 
    -0.20234604f, -0.25322703f, -0.09061691f, 0.20395033f, 0.01136640f, 0.00571220f, 0.06200166f, 0.04834420f, 
    0.03119358f, -0.09112102f, -0.07067020f, -0.10703181f, 0.09981525f, -0.09251221f, 0.02503978f, 0.26912892f, 
    0.01946085f, 0.07267532f, -0.02783624f, 0.02021500f, -0.02450878f, -0.02851081f, 0.14358300f, -0.06328616f, 
    0.47899520f, 0.02277173f, -0.14872211f, -0.12422336f, -0.04081827f, -0.03618780f, 0.13984777f, 0.09078077f, 
    0.04292241f, 0.07776994f, 0.00023609f, 0.02738810f, -0.10524479f, 0.18865471f, 0.04406175f, -0.20506778f, 
    0.12220354f, 0.02646536f, -0.12029774f, -0.08580071f, -0.12989323f, 0.04154366f, 0.02948267f, 0.02470861f, 
    -0.08835547f, 0.05431880f, 0.00883810f, -0.15733260f, -0.00858992f, -0.03017258f, -0.06106649f, -0.10166787f, 
    -0.02665089f, -0.01037206f, -0.04290021f, -0.02625081f, -0.20041250f, 0.09671455f, 0.02584015f, -0.39259458f, 
    -0.07040762f, 0.11441619f, 0.07973482f, -0.01474182f, 0.02963674f, 0.01350647f, 0.09104764f, -0.05217338f, 
    -0.11887716f, -0.18281075f, -0.09310411f, -0.05920151f, 0.12333278f, 0.08730531f, -0.10519791f, -0.11860882f, 
    -0.00266733f, 0.04505520f, -0.01883750f, -0.00645902f, 0.03863532f, 0.03874316f, -0.14507423f, 0.08375053f, 
    0.12234494f, 0.05396127f, -0.03883346f, -0.02299640f, -0.05769316f, -0.01343570f, 0.12022906f, -0.12669469f, 
    0.14984761f, 0.15497653f, 0.04956370f, -0.10086364f, 0.02440818f, 0.01380045f, 0.01165817f, -0.12672906f, 
    -0.11230119f, 0.05018560f, -0.03168489f, 0.10279179f, 0.12941569f, -0.01784297f, 0.08486576f, 0.19506636f, 
    -0.01042312f, 0.06203923f, 0.00343184f, -0.01901877f, -0.03409233f, -0.01571847f, -0.03559215f, 0.10664985f, 
    -0.19519229f, -0.05630613f, 0.06401065f, -0.11907494f, 0.05607434f, -0.00637213f, 0.02365648f, -0.04547458f, 
    -0.02504881f, -0.06505482f, 0.01612427f, 0.14564861f, -0.02493653f, -0.13000987f, 0.07016769f, -0.03574502f, 
    -0.02000077f, 0.04464110f, 0.02788804f, -0.01333256f, 0.05649728f, 0.06976875f, 0.09343839f, 0.02957085f, 
    0.18841933f, 0.12106918f, 0.01508893f, 0.18070683f, -0.11870886f, 0.04335705f, -0.00169911f, 0.00200303f, 
    -0.05722068f, -0.00465198f, -0.01564319f, -0.02539903f, 0.08383030f, 0.16161489f, 0.04454005f, 0.01704791f, 
    -0.01208964f, 0.06463984f, 0.08201965f, 0.02234058f, 0.04308036f, 0.06983934f, -0.10920607f, 0.02566247f, 
    -0.03504914f, 0.15151680f, -0.07470576f, -0.28204504f, 0.04174607f, -0.11879280f, -0.02126594f, 0.06480415f, 
    0.02377994f, -0.05051654f, -0.00715561f, -0.04607257f, -0.04220628f, -0.25926387f, -0.12658855f, 0.02973778f, 
    0.01126107f, 0.00692133f, -0.01469148f, -0.09615888f, 0.10454720f, -0.04593618f, 0.06814512f, -0.13534407f, 
    -0.28097251f, 0.10034684f, 0.27478829f, 0.00177323f, 0.02586921f, 0.00084526f, 0.06152308f, 0.10138706f, 
    0.15998104f, -0.03364291f, -0.00953559f, 0.07152507f, 0.23003078f, 0.03481957f, -0.15242654f, -0.05393326f, 
    0.06981957f, -0.06243347f, 0.00727752f, -0.00604832f, -0.00043545f, 0.05284259f, 0.09380525f, 0.11270165f, 
    0.14612956f, -0.00860398f, 0.08474693f, 0.14304908f, 0.03382164f, -0.02290652f, -0.05354063f, 0.08530142f, 
    0.02249990f, -0.09381551f, 0.03884197f, -0.00875623f, -0.16143019f, -0.01578576f, 0.05099052f, 0.02390287f, 
    -0.00387561f, 0.00635273f, 0.00894317f, -0.08437642f, 0.07823132f, -0.06237343f, -0.01090270f, 0.01345883f, 
    0.17438722f, 0.18951970f, -0.10366131f, -0.23659976f, 0.15565647f, 0.01516842f, -0.01881861f, 0.07485024f, 
    -0.11252473f, -0.00917409f, 0.10737592f, -0.01565467f, -0.42043743f, 0.33858091f, 0.01255949f, -0.22288522f, 
    -0.05030264f, 0.01965616f, -0.09442258f, -0.05937436f, -0.04251991f, -0.11634966f, 0.03134921f, 0.04404652f, 
    -0.07312315f, 0.02674379f, 0.04300943f, -0.12093326f, 0.06568295f, 0.07281701f, -0.02119090f, -0.12318730f, 
    -0.05137851f, -0.01415256f, 0.05541571f, -0.04872235f, 0.00478661f, -0.09546386f, -0.10877655f, 0.06391003f, 
    -0.02304108f, 0.06123584f, -0.00908773f, 0.02932603f, -0.05924936f, 0.07940089f, 0.11773434f, -0.08196474f, 
    -0.13242190f, 0.03626404f, -0.06478976f, -0.16448551f, 0.01421387f, 0.11208315f, 0.03255750f, -0.04536496f, 
    -0.03897932f, -0.03508896f, -0.03260958f, -0.00515255f, 0.01870102f, -0.16508226f, 0.07597396f, 0.20976126f, 
    -0.10319208f, 0.01980911f, 0.03960862f, 0.13742802f, -0.03937919f, -0.03045091f, -0.00787823f, -0.08205475f, 
    -0.31429988f, 0.13322437f, -0.18193378f, -0.03827582f, 0.12386549f, 0.05439348f, -0.08508065f, -0.00404490f, 
    0.08613972f, -0.06314141f, 0.06600596f, 0.00259500f, -0.02806652f, -0.04912374f, 0.08265301f, -0.23714305f, 
    0.06556325f, -0.02936497f, 0.07443314f, 0.03838041f, 0.03386580f, -0.00426773f, 0.03006738f, 0.11987504f, 
    -0.30158576f, -0.19218878f, 0.11734224f, 0.03418886f, -0.02778040f, 0.02241413f, 0.03553273f, 0.09847653f, 
    0.00718367f, 0.00960364f, -0.03872861f, -0.03552409f, -0.35102639f, 0.16109490f, 0.15264462f, -0.06641614f, 
    -0.06062248f, 0.02308449f, 0.02615427f, -0.05650120f, 0.02400226f, -0.05006377f, -0.04847749f, -0.06941207f, 
    -0.15081923f, -0.18402188f, 0.04090912f, -0.22852626f, 0.01818235f, 0.10220381f, 0.16044328f, -0.00392328f, 
    -0.12239186f, -0.07406060f, -0.04179252f, 0.14561118f, 0.23295705f, -0.11023884f, 0.07751644f, -0.34822357f, 
    0.00404220f, -0.00202844f, 0.02079246f, 0.13222557f, 0.04240498f, -0.01379416f, -0.03062572f, 0.00828499f, 
    0.06908493f, -0.27771235f, 0.33740446f, -0.04196811f, 0.16453730f, 0.01683202f, 0.05212833f, 0.00941633f, 
    -0.01278189f, -0.03414387f, 0.03443769f, -0.03252688f, 0.01340545f, 0.04596625f, 0.13033611f, -0.23494533f, 
    0.00839086f, -0.13016455f, 0.08426123f, 0.04203102f, -0.03640204f, 0.05968032f, 0.03100155f, 0.11492935f, 
    0.05382027f, -0.16679613f, 0.04524737f, -0.00896183f, 0.08793642f, 0.03965763f, -0.10281352f, 0.01272652f, 
    -0.06804461f, 0.03887871f, -0.03320290f, 0.03757990f, 0.02794346f, -0.33272275f, 0.07826446f, -0.11982252f, 
    0.04404788f, -0.01986140f, -0.01161730f, -0.12664132f, -0.13195327f, -0.07271852f, 0.00800603f, -0.23495996f, 
    0.20522371f, -0.54779702f, 0.13520250f, -0.01446586f, 0.09604798f, -0.01796769f, 0.02560002f, -0.04445128f, 
    -0.10791010f, -0.08400550f, 0.08953603f, -0.17298526f, -0.02690588f, 0.15050650f, -0.16923375f, -0.24026343f, 
    0.17598271f, 0.00918509f, -0.09534290f, -0.06730514f, -0.04033967f, 0.03110390f, -0.01752810f, 0.02854536f, 
    -0.28512701f, 0.09636767f, -0.16374634f, 0.04914734f, 0.12237058f, 0.04326428f, 0.14448807f, 0.04956639f, 
    -0.05834194f, 0.03245074f, -0.01965326f, 0.03750305f, -0.28652230f, -0.18808423f, 0.08871844f, 0.19715559f, 
    -0.09385216f, 0.04859542f, -0.03830353f, 0.03268254f, 0.05857209f, 0.09340280f, -0.12977788f, 0.04282205f, 
    0.25235733f, 0.32221296f, -0.09838275f, 0.00201434f, 0.07725194f, -0.04059131f, -0.03437136f, -0.00417153f, 
    -0.02412286f, 0.06689415f, 0.02347067f, 0.10786407f, -0.01519035f, -0.11408831f, 0.09880124f, 0.11996840f, 
    0.11282230f, 0.00611575f, -0.07347191f, -0.07846745f, -0.09994927f, 0.00733017f, -0.09442464f, 0.17066646f, 
    -0.45781970f, -0.15681571f, -0.17425005f, -0.21690524f, -0.00448102f, -0.12317094f, -0.09881885f, 0.01462803f, 
    -0.01138130f, 0.00735570f, 0.01941673f, 0.02969862f, -0.02409864f, -0.01307294f, -0.02904022f, -0.09055908f, 
    0.04964705f, 0.11629678f, 0.03922969f, -0.04314740f, 0.10846007f, -0.07742436f, -0.10701137f, -0.04743231f, 
    0.08157326f, 0.08259430f, -0.02119301f, -0.11940348f, 0.01098168f, -0.06501246f, -0.00084634f, -0.03293291f, 
    0.04814597f, -0.12858485f, 0.04557396f, -0.05539106f, -0.01609657f, -0.18923649f, 0.00328276f, 0.05321524f, 
    0.05263353f, -0.00460617f, 0.08998685f, -0.01636628f, 0.09276545f, 0.04641681f, -0.06327261f, -0.04531823f, 
    -0.06355959f, -0.03286472f, 0.05086391f, -0.07528867f, -0.00136411f, -0.04911809f, 0.11128514f, -0.09927148f, 
    0.07541067f, -0.06874329f, 0.03322146f, 0.10134018f, -0.53268218f, 0.07288182f, -0.07335503f, 0.03905309f, 
    0.09721049f, -0.03255425f, 0.00430475f, -0.07582901f, -0.01488253f, -0.00361962f, -0.11765970f, -0.13247432f, 
    0.10030710f, 0.00595377f, 0.09732872f, 0.11708987f, 0.08978118f, -0.04725958f, 0.11040084f, -0.03206183f, 
    0.01067667f, -0.04745758f, -0.10537122f, -0.10895451f, -0.08897198f, -0.03024021f, -0.10540831f, -0.01812133f, 
    0.04308738f, 0.04418858f, 0.03752952f, 0.02454867f, 0.09115876f, 0.00860559f, -0.05270645f, 0.04156944f, 
    0.18879317f, 0.04105510f, 0.00112404f, 0.05922256f, 0.04238204f, -0.26181534f, -0.09831993f, 0.05439368f, 
    0.01375673f, -0.01866385f, 0.05153802f, 0.21608517f, 0.26312208f, 0.16546333f, -0.10752289f, -0.00206240f, 
    -0.02106978f, 0.08742008f, -0.00623103f, 0.13170297f, -0.18571149f, 0.04972601f, 0.15023436f, 0.02792184f, 
    -0.42734283f, -0.17329432f, 0.09311032f, 0.04463709f, 0.08753300f, -0.02187737f, 0.03761377f, -0.09434725f, 
    0.05794941f, -0.12466804f, -0.06894053f, 0.10610484f, -0.12408188f, -0.13106057f, 0.01873340f, -0.17575200f, 
    -0.00057578f, -0.00933269f, -0.02924063f, 0.02334922f, 0.04815616f, -0.04811588f, 0.00233376f, 0.02902440f, 
    -0.30722359f, 0.10330106f, 0.08773268f, 0.16843258f, 0.12563485f, 0.02385174f, 0.02100364f, -0.00857961f, 
    0.01171333f, 0.03282297f, 0.14299563f, 0.00287836f, -0.17094547f, -0.05790586f, 0.09437342f, -0.03150422f, 
    -0.01134925f, -0.01421320f, -0.13953243f, -0.00851377f, 0.00595193f, -0.05967208f, 0.06029077f, -0.04816832f, 
    0.04743635f, 0.00291281f, -0.12924439f, -0.10684756f, 0.03779868f, -0.05749482f, 0.07940597f, 0.02415184f, 
    0.11460108f, 0.06993626f, 0.04368386f, 0.02835952f, -0.28865212f, 0.12691984f, -0.10191195f, -0.13945539f, 
    0.11791298f, 0.06877258f, -0.05733338f, 0.02583385f, 0.04779933f, 0.01361406f, 0.00387585f, 0.10933836f, 
    -0.36861333f, -0.38389781f, -0.03197308f, -0.03561458f, 0.04469023f, 0.05779275f, -0.01518323f, 0.11130960f, 
    0.07941315f, -0.02644539f, 0.10862926f, 0.07825746f, 0.24180230f, 0.02544258f, 0.00474411f, 0.04018174f, 
    -0.02725554f, 0.06158526f, 0.04318787f, -0.00841015f, -0.03331133f, 0.01839760f, -0.00064411f, 0.06547859f, 
    -0.03707223f, -0.14260969f, 0.07780984f, -0.02158374f, 0.00733262f, 0.10433703f, 0.05310998f, -0.08849830f, 
    0.07235281f, 0.00925817f, -0.02566168f, 0.00970578f, 0.24329188f, 0.20233442f, -0.07307341f, -0.02436987f, 
    -0.06773324f, 0.10553685f, -0.05225402f, 0.02377708f, -0.03699583f, 0.02828357f, 0.10226622f, 0.10352986f, 
    0.10827155f, 0.04788226f, -0.05352179f, -0.01721328f, -0.18397728f, -0.00329343f, 0.00006779f, -0.08705188f, 
    0.02977721f, 0.07433911f, 0.10178499f, 0.05561665f, 0.14336920f, 0.03765022f, -0.09634078f, 0.08820702f, 
    -0.01325287f, -0.00055936f, 0.05302104f, 0.02650674f, 0.01690963f, 0.01890092f, 0.05404936f, -0.08785424f, 
    0.15190132f, 0.01990397f, -0.00332627f, -0.19309026f, 0.00292979f, 0.04807136f, 0.10062245f, 0.01345473f, 
    -0.06101761f, -0.09468983f, 0.04217937f, 0.05524777f, 0.06412941f, -0.00319078f, -0.11738746f, 0.07853634f, 
    -0.00872966f, 0.15204284f, 0.05507091f, -0.04584931f, 0.09134486f, 0.03274180f, 0.04504784f, 0.03148054f, 
    -0.13621247f, 0.12823534f, 0.15619768f, -0.06678933f, 0.04424719f, 0.05197484f, -0.02994760f, 0.05593735f, 
    0.00564378f, 0.04478198f, 0.00447986f, 0.00804426f, -0.58443803f, -0.24515161f, -0.17187190f, -0.28986636f, 
    0.05600049f, 0.10048039f, -0.09716591f, -0.04246278f, 0.09894405f, -0.00154137f, 0.14462501f, 0.03016815f, 
    -0.49251243f, -0.29842860f, 0.09476375f, -0.05383013f, 0.02841834f, 0.01707342f, 0.03375257f, 0.01520860f, 
    0.00731276f, 0.07712385f, -0.03165883f, 0.04820196f, 0.20248267f, 0.06563711f, 0.12159117f, -0.19067319f, 
    0.08130525f, 0.00102083f, 0.04822233f, 0.10214308f, 0.00274901f, -0.02205116f, -0.15580614f, -0.00226538f, 
    0.19463612f, 0.06565107f, -0.16972713f, 0.04281299f, -0.13407099f, -0.08158091f, 0.03234297f, -0.09761787f, 
    0.06438015f, 0.00036813f, 0.02391618f, -0.10288130f, 0.16943683f, -0.01498967f, 0.00305426f, 0.04076038f, 
    0.00704851f, -0.06099662f, 0.11203254f, -0.03637555f, 0.00563740f, -0.04645555f, -0.01530885f, 0.13260075f, 
    -0.36255583f, -0.30463022f, -0.22726165f, -0.14608796f, 0.08612849f, -0.00418360f, -0.06775123f, -0.06886944f, 
    0.08913242f, 0.11702579f, -0.01958467f, 0.00117181f, 0.15826043f, 0.03632175f, -0.03527987f, 0.02865905f, 
    -0.09392185f, -0.01130081f, 0.05145904f, 0.03115625f, 0.13914563f, 0.02376163f, 0.03115432f, -0.04650640f, 
    -0.24401876f, -0.17573930f, 0.01254544f, 0.03999012f, 0.06982494f, 0.06624963f, 0.05689942f, -0.05809765f, 
    0.02212981f, 0.10133950f, 0.10499136f, -0.06276237f, 0.06772496f, 0.13284408f, -0.08313952f, -0.01903997f, 
    -0.13652986f, -0.01629610f, -0.07226174f, 0.02300068f, 0.06309161f, -0.14831206f, -0.18005531f, -0.14818722f, 
    -0.36166367f, -0.23937306f, 0.05701461f, -0.04944247f, 0.04697147f, -0.06889267f, 0.01435007f, -0.00079762f, 
    0.04966582f, 0.12130521f, -0.03237287f, -0.00451048f, -0.49566001f, -0.34470809f, 0.08643463f, -0.11729380f, 
    0.12888922f, -0.02938637f, -0.17181161f, -0.20511603f, -0.00366258f, -0.20397341f, -0.07560977f, -0.08105716f, 
    -0.16554415f, -0.04085302f, -0.12038665f, -0.04599858f, 0.02424168f, -0.11083341f, 0.00039496f, -0.01031543f, 
    -0.02926089f, 0.04097752f, -0.04090705f, 0.05878638f, 0.32835218f, 0.09251604f, -0.02162121f, -0.15758164f, 
    0.08126213f, 0.11948558f, 0.06642198f, 0.01714620f, 0.12767950f, 0.04687661f, 0.10930766f, 0.08401684f, 
    0.01479112f, -0.14858906f, -0.07906764f, -0.18016654f, -0.08540471f, 0.02272482f, 0.00786962f, -0.12310064f, 
    0.03549062f, -0.11563469f, -0.20501137f, -0.08986396f, 0.03966946f, -0.09325001f, -0.12853229f, -0.13771415f, 
    -0.02630073f, -0.01408370f, -0.06868347f, 0.07539052f, -0.07448792f, 0.03665798f, -0.10054906f, -0.09000564f, 
    0.16919437f, 0.03397660f, 0.01502839f, -0.02063976f, -0.06780915f, 0.03303552f, 0.08278707f, 0.04968902f, 
    0.02426222f, 0.10749014f, -0.03297631f, 0.00274686f, 0.02901466f, -0.00576201f, -0.12607460f, 0.03134172f, 
    0.06371303f, -0.04525939f, -0.00814577f, 0.06792248f, -0.00366316f, -0.01382892f, -0.02570838f, 0.00173372f, 
    -0.33788264f, -0.09474675f, 0.03780428f, -0.09125794f, 0.01033703f, 0.00344679f, 0.04856536f, 0.02794147f, 
    0.03175045f, 0.07212900f, 0.03318708f, -0.01174343f, -0.26433432f, -0.08208735f, -0.06706008f, 0.06501489f, 
    0.00167371f, 0.07360570f, 0.17893104f, 0.01980430f, 0.10447274f, 0.11023197f, 0.03299704f, 0.14939491f, 
    -0.40738031f, -0.10595510f, -0.20310663f, -0.05335128f, 0.04306861f, -0.01633218f, -0.02007429f, -0.04927024f, 
    -0.07084291f, -0.01052837f, 0.00497976f, 0.11146665f, 0.18932292f, 0.00542752f, -0.09817192f, 0.11081841f, 
    -0.01651554f, -0.02857571f, -0.04085568f, 0.05651800f, -0.06005752f, -0.06023740f, -0.09331745f, 0.05788418f, 
    0.06638567f, 0.16469653f, -0.09897030f, 0.16460739f, 0.11549132f, 0.00677069f, 0.05810073f, -0.12049726f, 
    -0.10806900f, -0.00294078f, 0.08567020f, -0.05737605f, 0.12116808f, -0.07588952f, 0.07824249f, -0.08875155f, 
    0.05250946f, 0.11066909f, 0.05160810f, 0.09950856f, 0.04462782f, 0.02716373f, 0.02478562f, 0.01529080f, 
    -0.36768422f, -0.30115932f, -0.21224941f, -0.08717377f, -0.03127317f, 0.03604296f, 0.06721968f, -0.06349717f, 
    0.06563493f, 0.00905230f, -0.07521991f, -0.04370017f, 0.19447614f, 0.09186766f, -0.03143338f, -0.02584815f, 
    -0.06310092f, -0.10233302f, 0.01358579f, -0.14740078f, -0.07138802f, 0.00058192f, -0.06732882f, -0.02346026f, 
    0.07414891f, 0.01313355f, -0.00175100f, -0.02085814f, -0.09327162f, -0.14842854f, 0.01630974f, 0.02974969f, 
    -0.08128671f, -0.08299398f, 0.02455780f, 0.01193479f, -0.35318843f, -0.19606726f, 0.28613898f, 0.00712854f, 
    0.22122824f, 0.00962385f, 0.07264871f, 0.00246670f, 0.10143489f, 0.09929551f, 0.00427085f, 0.07420201f, 
    0.13253297f, -0.03180880f, -0.01948362f, 0.05618997f, -0.02290353f, -0.10998876f, -0.12752254f, -0.09668233f, 
    -0.02324653f, -0.02934182f, 0.00360807f, 0.06361517f, -0.20781447f, 0.02315398f, 0.08734469f, 0.11266389f, 
    0.14060824f, -0.10674623f, -0.01408655f, 0.04805429f, -0.01201870f, 0.11373802f, 0.04701643f, 0.03142044f, 
    -0.22750381f, 0.08753020f, -0.05331026f, 0.10019588f, 0.10957698f, 0.00951349f, 0.02792098f, -0.07431399f, 
    0.05812918f, 0.03891746f, 0.02627103f, 0.08127806f, -0.02460968f, 0.01431833f, -0.02114107f, 0.01489683f, 
    -0.01020988f, -0.08377679f, 0.07453229f, 0.01727019f, -0.03527065f, 0.08715416f, -0.00721031f, -0.03740479f, 
    0.12507986f, 0.10595123f, -0.02909105f, -0.01954223f, 0.05541131f, 0.09765021f, 0.09737780f, -0.00943855f, 
    0.03364478f, 0.03029057f, -0.04589862f, -0.07958212f, -0.23341665f, 0.03736364f, -0.01658821f, -0.15803996f, 
    -0.02956126f, -0.09994518f, 0.00330644f, 0.08345810f, 0.13885228f, 0.17311978f, 0.01997484f, 0.19580688f, 
    -0.08600116f, 0.07440605f, -0.15620400f, -0.05719119f, 0.11743279f, -0.00700502f, -0.09396983f, -0.05703200f, 
    0.02905441f, 0.12519638f, -0.08679236f, 0.08106581f, -0.18365887f, 0.17188202f, 0.01129153f, -0.14907721f, 
    0.06486822f, 0.01557686f, -0.01216282f, 0.04766066f, 0.04163937f, 0.12116084f, 0.16834697f, 0.10660526f, 
    0.08788369f, -0.07931302f, -0.07397818f, 0.05911600f, -0.05084851f, -0.13901471f, 0.02153948f, -0.03465025f, 
    0.14106871f, -0.02774399f, 0.02928054f, 0.03910978f, 0.15709107f, -0.09265789f, 0.06865336f, -0.01319336f, 
    -0.01780285f, 0.10447058f, 0.03875978f, 0.04582563f, 0.01939989f, 0.02432020f, 0.03738470f, -0.08856384f, 
    -0.03104536f, 0.01339168f, -0.08075906f, 0.26618060f, -0.02647236f, -0.05647011f, 0.07420975f, -0.05100713f, 
    -0.08873472f, -0.01687909f, -0.02121983f, 0.11687060f, 0.22699900f, -0.24036819f, -0.12405785f, -0.08429441f, 
    -0.01869118f, -0.01359007f, -0.04206128f, -0.03997979f, 0.01234247f, -0.00579528f, -0.21145083f, -0.17482692f, 
    -0.04361833f, -0.28389281f, 0.12001015f, 0.06982748f, 0.02847554f, -0.01811927f, -0.03691549f, -0.00053153f, 
    -0.00093059f, -0.03243789f, -0.00906221f, 0.06240663f, -0.05326650f, 0.09766309f, 0.02606467f, 0.13551861f, 
    0.11485413f, -0.06434169f, 0.04887197f, -0.02848266f, -0.00849372f, 0.07020575f, -0.01505495f, 0.04365347f, 
    -0.05241393f, 0.21779524f, -0.18809886f, -0.01730543f, -0.16060176f, -0.03548817f, -0.04984729f, -0.10843981f, 
    -0.02536724f, 0.02355152f, 0.02574254f, -0.06256078f, 0.15655005f, -0.24180235f, 0.08717883f, -0.13289727f, 
    0.08980913f, -0.01750534f, 0.02063631f, 0.03597530f, -0.07301862f, 0.14071658f, 0.12475862f, 0.11855449f, 
    0.05426319f, 0.08806908f, 0.06010937f, -0.06600930f, 0.12113201f, -0.03559213f, -0.06342982f, -0.03455229f, 
    -0.04248927f, 0.06317909f, -0.08102368f, -0.12201229f, -0.07592203f, -0.01210526f, -0.16961142f, 0.08700830f, 
    -0.13824101f, 0.19381201f, -0.16751894f, 0.01890258f, 0.08480348f, 0.02133778f, 0.00208998f, 0.05587136f, 
    -0.00726737f, 0.01659567f, 0.12427002f, -0.07531793f, 0.11311385f, -0.02262219f, -0.04968100f, -0.00858451f, 
    0.19339378f, -0.01137423f, 0.11605086f, 0.13913332f, 0.13118556f, -0.04473186f, -0.11426236f, -0.04125577f, 
    0.04605836f, -0.08142744f, -0.02352118f, -0.03970472f, 0.04146213f, 0.03228499f, -0.00194864f, -0.00267006f, 
    0.08088935f, -0.10943925f, 0.00241085f, -0.02268213f, 0.09847288f, -0.02727328f, 0.07305312f, -0.17282988f, 
    -0.09582863f, 0.03257805f, 0.02569407f, 0.06249618f, -0.21814333f, 0.16443066f, -0.02852641f, -0.12625997f, 
    0.09648638f, 0.00848612f, 0.04796628f, -0.07776962f, -0.00568379f, -0.14113042f, -0.05055317f, -0.06471067f, 
    0.26226306f, 0.04518918f, -0.10818119f, -0.24616131f, 0.08130257f, -0.11552806f, -0.10734324f, 0.09048772f, 
    -0.05245620f, 0.03504474f, 0.19336258f, 0.00179805f, 0.18717675f, -0.05622980f, -0.11596229f, -0.13533965f, 
    0.01703984f, -0.12595189f, -0.04743136f, -0.01929416f, 0.03677080f, 0.11166704f, -0.02516292f, 0.07536423f, 
    -0.04575678f, -0.06215672f, -0.01074160f, -0.15838632f, -0.12316060f, -0.03123559f, 0.00531187f, 0.08032565f, 
    -0.04160013f, -0.09132490f, 0.03556377f, -0.04562616f, 0.12905817f, 0.08836670f, -0.28668705f, 0.12887822f, 
    0.15679112f, 0.05624689f, 0.01310693f, -0.00771533f, -0.01788674f, -0.02298281f, -0.11531874f, -0.01784094f, 
    0.13940082f, -0.07287443f, 0.04881256f, 0.37396404f, 0.08897876f, 0.00928692f, 0.08690170f, -0.01369302f, 
    -0.00331549f, -0.11004857f, -0.04193975f, 0.16221312f, 0.36692250f, 0.07128844f, -0.22615181f, -0.13603833f, 
    0.00278929f, 0.05764520f, -0.04894586f, 0.01491698f, 0.00023361f, -0.05655665f, -0.11493507f, -0.01058851f, 
    -0.15965655f, 0.36128360f, -0.11217604f, 0.01492543f, 0.21150143f, -0.01484799f, 0.01381930f, -0.09598521f, 
    0.09312727f, 0.00961087f, 0.00511822f, 0.09002315f, -0.00519538f, 0.06741066f, -0.06917138f, 0.03834201f, 
    -0.01617310f, 0.00242847f, -0.02959596f, 0.01408966f, 0.06033837f, -0.10058824f, 0.01884063f, 0.05799554f, 
    0.15423283f, 0.05399701f, -0.05006776f, 0.18233351f, 0.11067346f, 0.01987590f, 0.02357442f, -0.06564798f, 
    -0.03874945f, 0.08010219f, -0.00354586f, 0.02372110f, 0.00818655f, 0.10711824f, -0.03019414f, 0.16640286f, 
    -0.03215811f, -0.06680539f, 0.01981512f, 0.09354850f, -0.09072229f, -0.12892732f, -0.01300660f, -0.03894187f, 
    -0.18228969f, -0.05901364f, 0.05581162f, 0.00021217f, -0.07582304f, 0.07323978f, -0.08512262f, 0.07082997f, 
    -0.05454695f, 0.01289901f, 0.01446672f, -0.02149615f, 0.16792645f, -0.17327958f, -0.01813362f, 0.06581037f, 
    0.01123818f, -0.00781631f, 0.00856731f, 0.04335964f, 0.03335625f, -0.04653252f, -0.11719467f, -0.05649933f, 
    0.17343305f, -0.18098481f, -0.10483629f, -0.00407055f, -0.01829184f, 0.02974913f, -0.03282989f, -0.08347974f, 
    0.03619458f, -0.06520305f, -0.03759259f, 0.03021982f, -0.07281509f, 0.09585093f, 0.09544270f, 0.00194394f, 
    -0.13064292f, -0.12348370f, -0.03022196f, 0.06575903f, -0.09632219f, 0.09823667f, 0.11150861f, -0.09916599f, 
    -0.14488135f, -0.18582755f, -0.05553154f, 0.04281320f, -0.01032047f, 0.03916047f, -0.02029398f, 0.15412122f, 
    0.03310518f, 0.02437490f, 0.05019866f, 0.03678388f, 0.29303721f, -0.11876009f, -0.19785821f, -0.02661992f, 
    -0.06370226f, -0.01667670f, -0.00662926f, 0.01677573f, 0.03559136f, 0.05032201f, -0.11326706f, -0.02925836f, 
    0.26452759f, 0.12078247f, -0.18647274f, -0.07812504f, -0.08385790f, -0.01351369f, -0.02331069f, -0.02943429f, 
    0.09121233f, -0.03996188f, -0.05519148f, -0.07887846f, 0.34166580f, -0.03728288f, -0.21117772f, -0.05284322f, 
    0.11985519f, -0.11391933f, 0.04069748f, 0.13696551f, 0.00212191f, 0.05362397f, 0.06268910f, -0.00160608f, 
    0.15130259f, -0.08245689f, 0.01532126f, 0.09444051f, -0.11275353f, 0.10044662f, 0.01815908f, -0.10881262f, 
    -0.14283873f, 0.01507624f, -0.10023075f, -0.07642001f, -0.00439453f, -0.07552873f, -0.06066971f, 0.01906077f, 
    0.03978606f, -0.05539628f, 0.03431259f, 0.00142750f, -0.08316834f, -0.04147168f, 0.08214808f, -0.15699132f, 
    0.30564043f, -0.45302925f, -0.15022463f, -0.21913503f, 0.02858468f, -0.06193810f, -0.05736268f, -0.05546377f, 
    0.08196256f, -0.00333576f, -0.06718884f, 0.02477801f, -0.20582005f, 0.09310045f, 0.09001307f, -0.08869299f, 
    -0.06462820f, 0.10368790f, -0.00999401f, -0.01833218f, 0.10366244f, 0.06546627f, -0.08882648f, -0.02268495f, 
    0.14885154f, 0.08672083f, -0.03726356f, -0.08903564f, 0.18138155f, -0.01979034f, -0.01626372f, 0.01521219f, 
    0.03194901f, -0.00183047f, -0.00209503f, 0.09243973f, -0.02142830f, -0.10204406f, -0.06354699f, -0.06879366f, 
    -0.09520146f, -0.04449290f, 0.05215211f, -0.09836699f, -0.02554434f, 0.09531196f, 0.03202169f, -0.08072560f, 
    -0.22302230f, 0.18234879f, -0.10662834f, -0.02510351f, 0.12325412f, -0.02583749f, -0.08393384f, 0.01329148f, 
    -0.02953554f, -0.07953867f, 0.01898697f, -0.03053644f, 0.10497499f, 0.16577375f, -0.03194355f, -0.20801570f, 
    -0.06089319f, 0.02975957f, -0.05773897f, 0.02476156f, 0.08188818f, 0.03953256f, 0.05928644f, -0.01344689f, 
    -0.10020923f, 0.08060660f, -0.17036730f, -0.04094137f, 0.00654151f, 0.04793936f, 0.01325685f, 0.04130346f, 
    0.02276207f, -0.08989088f, -0.00645064f, -0.05500640f, -0.06957296f, -0.00760880f, -0.08682087f, 0.08091775f, 
    -0.05066244f, -0.05733053f, -0.07215834f, 0.05729648f, -0.07402665f, -0.03114873f, -0.00581546f, -0.11855589f, 
    -0.15299517f, -0.19110201f, -0.00848110f, 0.04124905f, 0.00187557f, -0.04972702f, -0.04334249f, 0.00889699f, 
    -0.00300059f, 0.10736401f, -0.02031234f, 0.05013054f, -0.33051646f, -0.30025366f, 0.03566381f, -0.14739394f, 
    0.04159343f, -0.02368278f, 0.00026172f, 0.00368046f, 0.04113616f, 0.05381821f, -0.01712337f, 0.08389600f, 
    0.02479861f, -0.10498901f, 0.04457439f, 0.02123190f, -0.04400645f, 0.00475915f, -0.14979936f, -0.00717944f, 
    -0.08749380f, 0.02576139f, 0.09814600f, -0.02950724f, -0.20623118f, 0.05292042f, -0.01026749f, -0.21128938f, 
    -0.02686776f, 0.06797123f, 0.06703471f, 0.04004901f, 0.01196528f, -0.00604728f, -0.00177796f, 0.13088174f, 
    0.19704910f, -0.28309900f, 0.10578082f, -0.02857009f, -0.04114559f, -0.03257778f, -0.00600796f, 0.08123042f, 
    -0.02439395f, -0.04940339f, 0.01986205f, -0.00581542f, 0.18154499f, -0.14748824f, 0.03177807f, 0.11912005f, 
    0.02765105f, -0.01559121f, -0.08545788f, -0.00378895f, -0.05418446f, 0.05876957f, -0.07904555f, -0.01811439f, 
    0.09966299f, 0.03946606f, -0.06647620f, -0.19482507f, 0.02307092f, -0.02338246f, 0.02994120f, 0.02742298f, 
    0.02015072f, 0.02082204f, -0.06282838f, 0.03814242f, -0.32293168f, 0.16107681f, -0.05729439f, -0.02754487f, 
    0.08636525f, -0.06190242f, 0.12544340f, -0.06943784f, 0.08058899f, 0.00464277f, 0.05323267f, 0.01386678f, 
    0.13137572f, -0.18399328f, -0.06882127f, 0.16916239f, -0.15932943f, 0.10114708f, 0.00384648f, -0.10692147f, 
    0.11652683f, -0.01436307f, -0.02971272f, -0.01279190f, -0.02965762f, -0.01450039f, 0.07569590f, -0.06169893f, 
    -0.04251935f, -0.02308768f, -0.07164120f, -0.07305294f, -0.04952482f, -0.04621603f, -0.06566489f, 0.00069547f, 
    -0.16806847f, -0.17120036f, -0.14122956f, -0.06191628f, 0.05269213f, -0.04385102f, 0.06623638f, 0.04289707f, 
    -0.01263912f, -0.01910212f, 0.01571837f, -0.02304887f, 0.06002040f, -0.09580997f, -0.00959091f, -0.00891859f, 
    -0.06092522f, 0.02525732f, 0.08037888f, 0.08573418f, -0.00399922f, -0.07285260f, -0.07338277f, -0.10019013f, 
    0.02353640f, -0.06700205f, 0.04478352f, 0.02793285f, 0.00700619f, 0.02993542f, 0.12221348f, -0.06564350f, 
    0.00492562f, -0.02357821f, -0.14855982f, 0.06654724f, 0.11923017f, 0.21684872f, -0.07229747f, -0.04013662f, 
    0.10222027f, 0.02516718f, -0.20868577f, 0.06911802f, -0.08368497f, 0.12324498f, -0.03318821f, -0.00648212f, 
    0.02096733f, 0.12128226f, -0.03541534f, -0.07440116f, -0.06093526f, 0.04549920f, -0.09898934f, -0.05940018f, 
    0.09057093f, 0.03920525f, -0.08378397f, -0.03375422f, 0.21940267f, -0.09358588f, -0.01480768f, 0.12845726f, 
    -0.04039202f, -0.02690474f, -0.05537818f, 0.04674001f, 0.08487087f, -0.09737664f, -0.03343675f, -0.09687672f, 
    0.43449783f, 0.09699681f, 0.02370423f, 0.13601352f, -0.02345840f, -0.02854315f, 0.00617759f, 0.06574947f, 
    -0.07032544f, 0.06838028f, 0.07348627f, 0.01948351f, -0.06943760f, -0.15209922f, -0.06006177f, -0.04606698f, 
    -0.00287597f, 0.13658170f, -0.08511174f, -0.07709746f, 0.08621930f, 0.02077256f, -0.00805902f, -0.02821658f, 
    0.16646509f, 0.11235366f, -0.09942444f, 0.09146918f, -0.14233470f, -0.15993346f, -0.12898749f, -0.07604530f, 
    -0.00228027f, -0.00029015f, -0.07714987f, 0.03006311f, 0.19308789f, 0.12036855f, -0.07971885f, -0.04371306f, 
    -0.01534580f, 0.02657725f, -0.10103595f, 0.03271566f, 0.05197918f, -0.14434573f, -0.04243049f, -0.10665959f, 
    -0.48861700f, 0.01639138f, -0.03875805f, -0.00622224f, -0.02398994f, -0.03026614f, 0.02754590f, 0.17061764f, 
    -0.07197005f, 0.06319317f, 0.09142224f, -0.05954991f, -0.12082173f, -0.16640697f, 0.10422090f, 0.18518756f, 
    -0.08323453f, 0.11410440f, 0.06526362f, -0.01080872f, -0.00717529f, -0.09156796f, -0.08161111f, -0.09418208f, 
    -0.29448178f, -0.29925475f, 0.11862116f, -0.05115135f, 0.17409378f, -0.00177048f, 0.07142420f, -0.04084184f, 
    0.12983295f, -0.12413444f, -0.18386251f, 0.00323088f, -0.01744480f, 0.19950305f, 0.01825138f, 0.00875644f, 
    0.08992212f, -0.09444349f, -0.01422192f, -0.04595374f, 0.00783383f, -0.02588917f, 0.05591917f, 0.02417297f, 
    -0.04021259f, -0.02949973f, 0.11681084f, -0.00620854f, -0.04167935f, 0.07411026f, -0.04855912f, -0.05314222f, 
    0.07797087f, 0.05886520f, 0.11014649f, -0.03680122f, -0.43782121f, -0.02972972f, -0.08950241f, -0.19028470f, 
    0.07230822f, 0.06270328f, 0.03696706f, 0.11697179f, 0.06248168f, 0.04345518f, -0.06709070f, 0.03751444f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04863058f, 0.01370679f, -0.03354413f, 0.03703355f, 0.00367975f, 0.00320410f, -0.00593350f, -0.05292953f, 
    -0.04177490f, 0.01936336f, 0.10365949f, 0.00543276f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
