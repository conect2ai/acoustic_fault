#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.83046478f, 0.78352457f, 0.44927669f, -0.88036788f, -0.96157384f, -0.76332307f, -0.18859874f, 0.26662573f, 
    0.16204992f, 0.72557193f, -1.42151737f, 1.03977489f, 0.70295191f, -0.62215167f, 1.13834894f, 0.03234335f, 
    -0.53814518f, -0.36688986f, 1.22012138f, 0.57096797f, 0.08114778f, -0.73366863f, -0.58239013f, 0.58254308f, 
    0.15483354f, -0.63743919f, 0.07863454f, 0.23413090f, 1.11457181f, -0.94350177f, 1.17206502f, 0.16806874f, 
    -1.22493267f, 0.15245631f, -0.03944043f, -0.08987425f, -0.29665542f, 0.27756140f, 0.55268019f, -1.22776461f, 
    -0.94218397f, -0.97858256f, 0.37425786f, -0.02236203f, 0.42112705f, -0.94844079f, -1.28538156f, -0.75084078f, 
    0.09914507f, 1.01193559f, 0.54802078f, -0.11883979f, 0.41644406f, -0.50397301f, 0.78079140f, 1.45539880f, 
    -0.89670116f, -0.08975735f, -0.89680862f, -0.63149315f, 0.29385453f, 0.28734830f, 0.65882021f, -0.56652504f, 
    0.15968511f, -0.85957068f, -0.67202652f, 0.91577560f, -0.96307719f, -0.30478859f, -0.48179623f, -0.25447601f, 
    -1.20733607f, -0.61533821f, -0.85817331f, -1.02026260f, 0.80921757f, 1.07207930f, 0.19665544f, -0.01124909f, 
    0.41271800f, 0.92717731f, 1.03223586f, 1.13170362f, 0.19726007f, -0.14270775f, 0.45595327f, 0.00725267f, 
    -0.11924195f, -0.34490862f, 1.17564201f, 0.42034835f, 1.11320400f, -0.20829166f, 0.16702902f, -0.35400358f, 
    0.33608562f, -0.05481653f, 0.49519384f, -0.27373829f, 0.67448765f, 0.61685103f, 0.40247473f, 1.05390620f, 
    0.96196175f, -0.58204877f, -0.33253700f, -0.80473614f, -0.67595786f, -0.77981102f, -0.76767057f, 0.39833111f, 
    -0.01648695f, -0.19192858f, -0.81698686f, -0.41686335f, -0.76502270f, -1.19632733f, -0.61335629f, -0.75825834f, 
    0.24416600f, 0.64377159f, 0.08542901f, 0.82641560f, -0.10976905f, -0.57212722f, 0.50694025f, -1.42687261f, 
    -0.96804523f, -0.56446201f, 0.55906779f, -0.59375453f, -0.18181731f, 0.36015666f, 0.43536061f, -1.20715511f, 
    -0.62644005f, -0.44881296f, -0.55196726f, -1.17398465f, 0.09373528f, 0.06991769f, 0.39579922f, 0.09741375f, 
    0.68079251f, -1.34353554f, 0.50038993f, 0.09363206f, -1.30432415f, -0.04403771f, 0.15165581f, 0.23932356f, 
    0.60168666f, -1.20296156f, -0.15231515f, 1.13194942f, 0.20610064f, -1.46714473f, 0.66291827f, 0.20423929f, 
    0.22257605f, 0.05215773f, 0.87630713f, -0.26969016f, 0.06007921f, -1.15040851f, 0.31696901f, 0.70735502f, 
    0.27498150f, -0.11239643f, 0.57619268f, -0.93470800f, -1.06792641f, -0.99055272f, 0.65570277f, 0.65535754f, 
    -0.56449473f, -0.21544234f, 0.52462786f, 0.42635614f, -1.36849976f, -0.39804175f, 0.98917156f, 0.71924299f, 
    0.61085474f, 0.78146911f, 0.30169168f, -0.02061070f, 0.36792615f, 0.77299184f, 0.62806946f, 0.79368162f, 
    -1.21935034f, -0.00142964f, -1.06046212f, 0.09574363f, -0.52653271f, -0.46219921f, 1.40501809f, -0.94284976f, 
    -0.42873350f, -0.38293546f, 0.18571368f, -0.34359714f, -0.13064413f, 0.36431131f, 0.36491588f, -0.41854721f, 
    0.98620689f, 1.30475020f, -0.13224368f, -0.01006875f, -0.55245090f, -0.72679162f, -0.20270786f, 0.00373326f, 
    0.77437228f, 0.20623861f, -0.93712658f, -0.24163871f, 1.03101969f, 0.54800469f, 0.91988450f, -0.36217031f, 
    -0.59637934f, -0.52230346f, 0.05156231f, 0.69072682f, -1.16408229f, 1.26059163f, -0.85922039f, 0.11550947f, 
    0.61891496f, -0.36339286f, 1.22988319f, 0.38931140f, -0.46929860f, 0.71281832f, 0.45100889f, 0.41393596f, 
    0.43914458f, 0.59333968f, -0.14794634f, 1.24181604f, 1.17231488f, 0.88285840f, -0.27146083f, 0.47096375f, 
    -0.25381222f, 0.12458573f, 0.63907778f, 0.28595659f, 0.41816249f, -0.45573273f, -0.37790105f, 1.48570979f, 
    0.91842747f, 0.68718630f, -0.21776862f, -0.06564647f, -0.01144825f, 0.62126857f, 0.88373733f, 0.64682382f, 
    -0.00212056f, -0.52880043f, 1.20265388f, -0.82893544f, 0.52340144f, 0.39144430f, -1.23040831f, -0.06846185f, 
    0.01544727f, 0.77443624f, 1.14259541f, 0.30672285f, -0.36947244f, -0.52477646f, 0.53010035f, 0.98242122f, 
    -0.46753821f, 1.10109901f, 0.42766538f, 0.12849838f, -0.23189370f, -0.59311408f, -0.53279275f, 0.28912321f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.33559597f, -0.18428507f, -0.02011536f, 0.14188561f, 0.28618816f, -0.05948362f, -0.03335118f, 0.17858879f, 
    -0.05665972f, 0.62909198f, 0.19104265f, 0.06895391f, 0.16199441f, -0.07999867f, 0.45444077f, 0.02575742f, 
    0.04945915f, 0.00308866f, 0.09342567f, 0.08216209f, 0.25622907f, 0.24959551f, -0.32390627f, 0.26471370f, 
    0.10081833f, -0.26254076f, -0.08069308f, -0.01314196f, 0.19509377f, 0.10497058f, 0.14944497f, 0.14205977f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.15411963f, 0.17123327f, 0.17651422f, -0.23534417f, -0.04564836f, -0.20681813f, 0.02471983f, -0.01135706f, 
    0.03251301f, 0.00227270f, -0.17136389f, -0.03971959f, -0.04766685f, -0.11112392f, -0.10712706f, -0.03465481f, 
    -0.24504219f, -0.12297383f, -0.00211343f, 0.14444146f, -0.12076319f, -0.37033260f, 0.00622749f, -0.03056593f, 
    0.10091234f, 0.02062684f, -0.13979760f, -0.68722260f, 0.08351054f, -0.26987725f, -0.13149241f, -0.04133885f, 
    0.01114129f, 0.21268572f, -0.07574663f, 0.08526434f, -0.18579504f, -0.12623496f, 0.09216744f, -0.07725757f, 
    -0.11311771f, 0.01108694f, -0.09939742f, 0.13234623f, 0.02350157f, 0.30400828f, 0.14795052f, 0.14931390f, 
    0.00407549f, 0.23051371f, 0.11289204f, 0.11111751f, 0.05654000f, 0.12351575f, -0.65109801f, 0.48271176f, 
    0.01131840f, -0.29214922f, -0.03046285f, -0.04761923f, -0.18527201f, 0.12933396f, -0.00086041f, -0.17403901f, 
    -0.05052077f, -0.06243680f, 0.13582760f, -0.08047307f, 0.19522105f, -0.21114896f, -0.16515481f, -0.11291957f, 
    0.44442049f, -0.24523143f, -0.24096066f, -0.01625427f, 0.11983313f, -0.10241177f, -0.11528815f, -0.15324262f, 
    -0.00473717f, 0.25734445f, -0.13241197f, 0.12630327f, -0.28982049f, 0.12149335f, -0.16315874f, 0.10786619f, 
    -0.08386280f, -0.05598075f, 0.23207371f, -0.02185610f, 0.05046824f, -0.18555351f, 0.05266291f, -0.01197178f, 
    -0.03652649f, -0.20765276f, -0.09855471f, 0.29866585f, 0.10360327f, 0.23472287f, 0.03198092f, 0.09302048f, 
    -0.07553728f, 0.04703739f, 0.06756242f, 0.01244171f, 0.11891036f, 0.25079966f, 0.42340019f, 0.17723285f, 
    0.12135524f, 0.24723497f, -0.00535101f, -0.07534866f, 0.20474029f, 0.34779289f, 0.22494686f, 0.15136455f, 
    0.26801470f, 0.25874460f, -0.00472456f, 0.06318127f, 0.05937734f, 0.17144954f, -0.03955450f, 0.00266427f, 
    0.26783264f, -0.16386263f, 0.18800676f, -0.15632255f, -0.06093087f, -0.07150557f, 0.08687303f, -0.07188558f, 
    -0.28506669f, 0.11749016f, 0.26599643f, -0.26271424f, 0.14495298f, 0.13331719f, 0.12033404f, -0.12611872f, 
    0.08210757f, 0.20967461f, -0.26355129f, -0.11159639f, -0.08639439f, -0.30344620f, -0.02573447f, -0.08652245f, 
    0.03198247f, -0.09019876f, -0.32181185f, 0.06165152f, 0.09193597f, 0.07733373f, -0.04059492f, -0.11076550f, 
    -0.03705833f, 0.02254161f, 0.03633259f, -0.45105797f, -0.33555678f, -0.14953671f, 0.02412478f, -0.08951472f, 
    -0.20803441f, -0.18269300f, -0.17913185f, 0.14041288f, -0.02706090f, 0.15133837f, 0.02960898f, 0.07190820f, 
    0.31221065f, 0.12196072f, 0.08014929f, -0.00549996f, 0.15640648f, 0.40548679f, 0.14763312f, 0.07022610f, 
    -0.03945526f, -0.05556631f, -0.03196492f, 0.00892338f, -0.06044283f, 0.04118503f, -0.42388237f, 0.10912152f, 
    -0.09395735f, -0.22627650f, -0.16147201f, 0.11016787f, 0.12149561f, 0.01539136f, 0.07005253f, 0.07171357f, 
    0.02081497f, -0.33008486f, 0.25843433f, -0.12656090f, -0.03346103f, -0.06866015f, -0.07983571f, 0.00547813f, 
    0.13190271f, 0.26327616f, 0.03333218f, -0.10704373f, -0.30168658f, 0.23804469f, 0.10771796f, 0.11514679f, 
    -0.24547583f, -0.16234608f, -0.40918881f, -0.12369543f, 0.11549099f, 0.13364215f, 0.06882208f, -0.14481977f, 
    0.20949394f, -0.26736131f, -0.06981152f, 0.04387555f, 0.35203287f, 0.04114987f, 0.11488675f, -0.17220251f, 
    -0.01182339f, -0.23102540f, -0.12342302f, -0.04298900f, -0.31284150f, 0.13059029f, 0.04337114f, 0.11223816f, 
    0.20302805f, 0.05569976f, 0.04527128f, 0.08321254f, 0.06227006f, 0.06205272f, -0.10838017f, 0.00470283f, 
    0.20756920f, 0.02728004f, -0.08817423f, -0.04916925f, 0.20331174f, -0.07636309f, -0.15634772f, -0.06491640f, 
    -0.03191487f, 0.10444127f, 0.03106739f, 0.05874098f, 0.10234825f, 0.40664840f, -0.00811752f, -0.14319795f, 
    -0.12892205f, -0.05673297f, 0.03428217f, -0.07980050f, 0.02678560f, -0.02077856f, 0.28937012f, 0.18352537f, 
    0.06508218f, 0.08799560f, -0.09335595f, 0.16111916f, -0.05173329f, 0.10704209f, 0.10426652f, 0.17394656f, 
    0.03546282f, 0.15883306f, 0.20897759f, 0.08212301f, 0.08311018f, 0.06180860f, -0.00064710f, -0.06861331f, 
    -0.30414179f, 0.18012315f, 0.15638776f, 0.18151027f, 0.01847334f, 0.03248230f, -0.10782382f, -0.06137018f, 
    0.01033795f, -0.28126928f, -0.26415130f, -0.13173234f, -0.00542924f, 0.09821919f, 0.01283156f, -0.12748478f, 
    0.10315179f, -0.05115472f, -0.32591331f, -0.29401496f, 0.02665380f, 0.10533975f, -0.14564934f, -0.28612193f, 
    0.09096854f, -0.06927746f, 0.01252905f, 0.29402962f, 0.18451561f, -0.08563662f, -0.03508632f, -0.00693667f, 
    0.01535948f, 0.12210314f, 0.05424546f, 0.05946903f, 0.32033023f, 0.33414546f, -0.02844918f, -0.01738778f, 
    -0.03696182f, 0.02708981f, -0.00324754f, -0.24774170f, -0.03944007f, 0.30983099f, 0.22157209f, 0.19947122f, 
    -0.10645878f, -0.13780913f, -0.08814328f, 0.06547509f, -0.00663786f, 0.06186986f, -0.04470392f, 0.13222985f, 
    0.11351816f, -0.03453572f, -0.05319280f, -0.08638225f, 0.09954531f, 0.16448560f, -0.10057183f, -0.12425834f, 
    0.07932735f, 0.21989825f, -0.05347519f, 0.05075966f, 0.08519004f, -0.12523440f, -0.02844875f, -0.42316404f, 
    0.06635979f, 0.03090103f, 0.13566937f, 0.21486890f, 0.11402860f, -0.11884391f, -0.01321045f, 0.20248070f, 
    -0.03354765f, -0.45727015f, -0.28752482f, -0.04326819f, 0.05191330f, 0.07052260f, -0.00045034f, -0.15960911f, 
    0.06552993f, -0.01510829f, -0.83398372f, -0.10034912f, 0.03573596f, 0.10544898f, -0.03949887f, 0.11403611f, 
    0.06950970f, -0.01842495f, -0.02472867f, 0.00489858f, -0.15388173f, -0.22451976f, -0.14120501f, 0.07327708f, 
    -0.06313383f, -0.18936470f, 0.03790707f, -0.19407721f, 0.25580919f, 0.26897988f, 0.34784064f, -0.10490766f, 
    -0.07220858f, 0.15832782f, -0.16976131f, -0.09985401f, -0.18901123f, 0.28057438f, 0.23336460f, 0.21019238f, 
    0.11326998f, 0.05063324f, -0.02690062f, -0.00324248f, 0.04469097f, 0.07824041f, 0.11609840f, -0.11698389f, 
    0.10453028f, 0.14720482f, -0.01700239f, 0.25257513f, -0.16142802f, 0.06193805f, 0.03009873f, 0.08158495f, 
    0.19391853f, 0.09132770f, -0.07588211f, -0.13694590f, 0.08470975f, -0.02938903f, -0.08626598f, -0.23431031f, 
    -0.14160657f, 0.10619818f, 0.15731587f, -0.00902016f, -0.26449770f, 0.02612747f, 0.07731584f, 0.10592295f, 
    0.13222612f, -0.09137876f, 0.15257157f, -0.07017594f, -0.20227432f, -0.06981704f, -0.19546063f, 0.04843047f, 
    0.01124828f, 0.26205042f, -0.15156969f, -0.15481301f, -0.01669001f, 0.08262281f, 0.10699305f, -0.20573209f, 
    -0.01967631f, 0.08912280f, 0.17894976f, 0.10438934f, 0.18058285f, 0.25939924f, -0.06351530f, 0.04596202f, 
    0.10244818f, -0.03685312f, -0.00431470f, 0.14002873f, 0.27109838f, 0.03945424f, -0.08709160f, -0.15184063f, 
    0.20421869f, -0.00839580f, 0.01722045f, -0.00684068f, 0.17370933f, -0.15722895f, 0.16766672f, 0.32960749f, 
    0.30852067f, 0.05483105f, -0.09960594f, -0.11449870f, -0.17917150f, -0.18873292f, -0.19309957f, -0.32530579f, 
    0.29562622f, -0.12685697f, -0.05871784f, 0.23783877f, 0.16665511f, 0.05206700f, -0.08250369f, -0.05992783f, 
    -0.15486430f, -0.25700003f, 0.24785814f, 0.06474053f, -0.16053230f, -0.27697575f, 0.02563094f, -0.02127654f, 
    0.04166097f, -0.35093597f, -0.33059216f, -0.10202383f, -0.00061733f, -0.27896646f, 0.17434993f, 0.15849569f, 
    0.04408146f, -0.02968874f, 0.40700331f, -0.10506205f, -0.05375912f, -0.02353253f, 0.11783627f, -0.14389345f, 
    0.03261706f, -0.00497531f, -0.32106259f, -0.29384258f, -0.19032891f, -0.12052888f, -0.20963489f, -0.02707600f, 
    0.24921481f, 0.00352426f, 0.13421765f, -0.71852171f, -0.27166045f, -0.15493672f, 0.09485542f, -0.03620226f, 
    0.04854672f, -0.01503639f, -0.01016317f, 0.15220314f, 0.03676869f, 0.11726087f, -0.13470802f, 0.04235515f, 
    0.13506402f, 0.08092277f, 0.07557625f, -0.10281770f, 0.03381641f, -0.10114370f, -0.39928430f, 0.03139590f, 
    0.04524365f, 0.20539494f, -0.03572085f, -0.15274049f, -0.03878229f, 0.24961798f, 0.28219131f, 0.18695696f, 
    -0.09046358f, -0.05106543f, -0.04900230f, 0.04431802f, 0.24334794f, 0.20328289f, -0.01535233f, -0.39283463f, 
    -0.25305805f, -0.14674766f, 0.09488229f, 0.08593953f, -0.11328671f, -0.10567936f, -0.06144748f, 0.04968199f, 
    -0.05960283f, 0.04673978f, 0.01620686f, 0.04176942f, -0.02974528f, 0.03726897f, 0.01605360f, -0.00056466f, 
    -0.05837872f, -0.05227417f, 0.02932326f, -0.01868409f, -0.05510394f, 0.04708277f, 0.05160579f, -0.04613252f, 
    0.03334379f, 0.00059793f, -0.03102144f, -0.04713258f, -0.03720020f, -0.02270278f, -0.04894590f, 0.03144458f, 
    -0.02862232f, -0.01822295f, 0.03302281f, -0.02387889f, -0.01422900f, -0.04395660f, 0.04953007f, 0.02551514f, 
    -0.04637571f, -0.05300845f, -0.04954510f, 0.00487474f, -0.01244524f, 0.03100790f, 0.01932032f, -0.03125971f, 
    -0.04820047f, -0.03391049f, 0.03653594f, -0.04063245f, -0.00910028f, 0.02787143f, 0.04522186f, -0.01672681f, 
    -0.03298394f, 0.04548630f, 0.02311652f, 0.00529366f, 0.03313976f, -0.01701774f, 0.01637591f, -0.05060002f, 
    0.01972812f, -0.04234805f, -0.01744213f, 0.00781630f, 0.00342693f, -0.00305915f, 0.00618100f, 0.00140108f, 
    0.04482522f, -0.02405937f, 0.00899069f, -0.01549357f, 0.02483872f, -0.05539708f, -0.04389748f, -0.02444804f, 
    0.00568359f, -0.02650315f, -0.03573156f, -0.01896539f, -0.03473391f, 0.02996944f, -0.02629031f, 0.01006253f, 
    0.00500432f, 0.00776772f, 0.03384538f, 0.02812135f, -0.01059358f, -0.05961382f, 0.02307823f, 0.01606946f, 
    0.02612543f, 0.04268042f, -0.06489892f, -0.00026028f, -0.02025426f, 0.01883289f, 0.00675491f, 0.04015705f, 
    0.02773445f, 0.02132248f, -0.04793686f, 0.00946133f, 0.03074157f, -0.03303370f, -0.04464722f, 0.01038224f, 
    -0.02632418f, 0.03722966f, 0.01805302f, -0.02619372f, -0.02752681f, -0.02114817f, -0.05153320f, -0.02572555f, 
    -0.04582864f, -0.05870849f, -0.01952218f, 0.02324620f, 0.01246574f, -0.01164698f, -0.03805534f, -0.02989844f, 
    0.00296729f, -0.05061431f, 0.03867154f, -0.05914136f, 0.03436933f, 0.04276436f, -0.05389694f, -0.03452729f, 
    -0.04604688f, 0.01915502f, 0.02968838f, 0.04223673f, 0.00105845f, -0.05173755f, -0.01649432f, -0.03368313f, 
    0.01089741f, 0.00320396f, -0.02978123f, -0.03925790f, 0.04230307f, -0.04699140f, -0.06460061f, 0.03661530f, 
    -0.02503483f, -0.01042862f, -0.05613920f, -0.03075600f, 0.01046857f, -0.03698211f, -0.04066703f, 0.03815833f, 
    -0.05353700f, 0.04440024f, -0.00216137f, -0.06485993f, 0.00177085f, 0.04729735f, -0.02216886f, -0.05012293f, 
    0.00106874f, -0.01984538f, 0.02988508f, -0.01641463f, 0.03861446f, 0.00419737f, -0.01742358f, -0.05121657f, 
    -0.02698115f, 0.02578480f, -0.04017475f, -0.01533006f, 0.00401349f, 0.03685258f, -0.01522476f, 0.02292226f, 
    -0.04150173f, 0.04325141f, 0.01285309f, -0.00393192f, 0.00593666f, -0.00574387f, 0.03404422f, -0.05767284f, 
    0.00158078f, -0.00463636f, -0.02716385f, 0.00752466f, -0.04057168f, -0.06534187f, -0.01049847f, -0.06159236f, 
    -0.05412910f, 0.01315520f, -0.04652710f, -0.04976553f, 0.01061035f, 0.04339042f, 0.03843711f, 0.01156959f, 
    -0.02819894f, -0.03172932f, 0.02383705f, -0.01610529f, 0.00326158f, -0.05013451f, -0.05319724f, 0.02711111f, 
    0.01045273f, -0.04680651f, 0.03461613f, 0.01219553f, 0.04732154f, 0.00727427f, -0.03194402f, 0.04097375f, 
    -0.04648736f, -0.01582534f, -0.05491230f, -0.06301078f, -0.02829041f, 0.01522530f, -0.05760720f, -0.02619650f, 
    -0.05910020f, 0.04227383f, 0.02136053f, 0.05135481f, 0.01583903f, -0.00442537f, -0.00650209f, -0.03953695f, 
    0.01152724f, 0.01496903f, -0.01187515f, 0.00046688f, -0.05968880f, -0.03205866f, 0.04317481f, -0.04414058f, 
    -0.02895163f, 0.00368840f, -0.01354837f, -0.04474353f, -0.03601835f, -0.01885391f, 0.01050237f, -0.03823944f, 
    -0.04055785f, -0.02487632f, -0.05680887f, -0.06367785f, 0.00790243f, -0.06443124f, 0.04588388f, -0.06550383f, 
    -0.02241876f, 0.03621906f, 0.00701836f, 0.04383954f, -0.04996993f, -0.05134979f, 0.00646904f, 0.03509314f, 
    -0.02489395f, -0.01427953f, 0.02552616f, 0.03905457f, 0.01304130f, 0.02654072f, -0.01062607f, -0.03138952f, 
    -0.01312375f, -0.02028343f, -0.02572513f, 0.03534121f, 0.03434696f, -0.00962205f, -0.04069874f, 0.03580399f, 
    0.02102727f, 0.01359522f, 0.02790882f, 0.04155723f, 0.04453472f, 0.03216450f, 0.03664137f, -0.00221283f, 
    -0.05756554f, -0.03912579f, -0.04596731f, -0.01900361f, 0.02813733f, 0.02578820f, -0.05247305f, 0.02766614f, 
    0.03961346f, -0.04060999f, -0.00183992f, -0.03179884f, -0.04434073f, -0.00171113f, -0.00360242f, -0.02118251f, 
    0.03256745f, 0.03061333f, 0.03155070f, 0.04745783f, -0.00398333f, 0.05628431f, 0.03528677f, -0.03599439f, 
    0.05437855f, -0.03618630f, 0.05496202f, 0.01912177f, 0.03486640f, 0.04270348f, -0.00777584f, 0.03353566f, 
    0.01398575f, 0.03135847f, -0.01469326f, -0.02452403f, -0.05095888f, 0.05235674f, 0.03121762f, 0.02559086f, 
    0.03034220f, 0.03373567f, -0.03923713f, 0.00183555f, -0.05068692f, -0.02297881f, -0.01668481f, 0.01987999f, 
    0.03599883f, 0.00354286f, -0.00836919f, -0.03152163f, -0.03099567f, -0.02838422f, -0.02217174f, 0.03610351f, 
    -0.05750656f, -0.02383178f, 0.00655648f, -0.03515783f, -0.04885030f, 0.02571489f, -0.01377288f, -0.01356573f, 
    -0.04189533f, 0.00754277f, -0.04122436f, 0.02437618f, -0.04824757f, -0.01240078f, 0.03767160f, -0.01518608f, 
    -0.03793031f, -0.04041831f, -0.05308359f, -0.03033038f, -0.00926803f, 0.00477701f, -0.02371461f, -0.05022529f, 
    0.01645759f, 0.00299424f, -0.02752227f, -0.01832645f, -0.01596242f, -0.01150629f, 0.01796632f, -0.05109402f, 
    -0.04531985f, -0.00403916f, -0.02548345f, -0.03536553f, 0.03689707f, -0.01314135f, 0.03057493f, 0.00173315f, 
    0.01242646f, -0.01523077f, -0.00491201f, -0.00693983f, -0.02067384f, 0.04617659f, -0.03293050f, 0.00598069f, 
    0.02394377f, 0.02974707f, -0.03097653f, 0.00441901f, -0.03873613f, -0.05168822f, 0.04630149f, -0.05555880f, 
    -0.03630159f, 0.00789822f, -0.03047762f, -0.02706676f, -0.01377273f, 0.02274282f, -0.02280327f, -0.00701304f, 
    0.02971561f, -0.02937419f, 0.00227409f, -0.02678627f, -0.00885949f, -0.00086398f, -0.02680430f, 0.04344994f, 
    -0.05121502f, -0.03248285f, 0.01206767f, -0.00787628f, 0.01514067f, -0.05453891f, 0.02484521f, -0.04423295f, 
    -0.05059275f, 0.03740829f, 0.03239089f, 0.03487194f, 0.01934285f, -0.05639371f, -0.01957021f, -0.03649498f, 
    0.04663230f, -0.05599617f, -0.04008691f, -0.00038235f, 0.04527922f, 0.04757675f, -0.04928523f, -0.05437791f, 
    0.00806882f, 0.05884399f, 0.00212615f, 0.03809124f, 0.00319168f, -0.02168641f, 0.01799031f, -0.00020605f, 
    0.02240813f, -0.02647645f, -0.02666337f, 0.03685893f, 0.00096761f, 0.00434958f, -0.04646935f, -0.04527951f, 
    -0.00378853f, -0.01073540f, -0.04545488f, -0.02792531f, 0.02213644f, -0.02673050f, -0.02301788f, 0.03709888f, 
    -0.02070860f, 0.00541181f, 0.02470552f, -0.01076376f, 0.02232285f, -0.04608845f, -0.02326770f, 0.03153071f, 
    0.02253088f, 0.04863438f, 0.01241115f, -0.02920174f, -0.02179263f, 0.00523509f, -0.04564625f, 0.00843009f, 
    -0.05807230f, 0.00771302f, -0.05748660f, 0.04457888f, -0.03814842f, 0.05530891f, 0.04690880f, -0.01768480f, 
    0.03935265f, 0.01836068f, -0.01336119f, -0.04283102f, 0.01820756f, 0.03416679f, -0.05357035f, 0.05209520f, 
    0.05321002f, -0.03920176f, 0.03858367f, 0.05599613f, -0.02055263f, -0.04961840f, -0.03712372f, 0.05411277f, 
    0.03517627f, -0.02415104f, 0.05040808f, -0.00723694f, -0.05161151f, 0.02591035f, 0.04277784f, -0.01646608f, 
    -0.03428328f, -0.01302868f, 0.04077198f, -0.01148719f, 0.05059995f, -0.04258528f, -0.04552779f, 0.00371214f, 
    0.03653403f, 0.00185803f, -0.00460707f, -0.03135282f, 0.00610563f, 0.01774373f, 0.02427010f, -0.05493461f, 
    0.00274300f, -0.05553773f, 0.00800944f, 0.04073614f, -0.00415627f, -0.00317605f, 0.02337580f, -0.05224127f, 
    -0.00386482f, -0.04029915f, 0.02772322f, -0.01452378f, 0.05599499f, -0.05436424f, 0.05179231f, 0.05784849f, 
    -0.04375092f, -0.02866194f, -0.03663744f, 0.01045920f, 0.00263382f, -0.02815187f, -0.00402257f, 0.05111672f, 
    0.04407359f, 0.02654438f, 0.05365098f, -0.05481359f, 0.01418492f, -0.03035682f, -0.05413082f, 0.02097333f, 
    -0.03206452f, -0.05456809f, -0.03445858f, -0.05550607f, -0.03147258f, -0.04313435f, 0.01985617f, -0.00795384f, 
    -0.02572726f, 0.00774922f, 0.01113471f, 0.03816723f, -0.00481354f, -0.04807414f, 0.03437708f, 0.00244444f, 
    -0.00014810f, 0.30801669f, -0.10028117f, 0.09576707f, -0.04190237f, 0.00006768f, -0.10658316f, 0.09935966f, 
    -0.11094351f, 0.37004146f, -0.27433148f, -0.04875728f, -0.00342339f, 0.27914947f, 0.22679992f, 0.05206481f, 
    -0.10012748f, 0.22239691f, -0.17957667f, 0.06899547f, 0.22722717f, 0.18111436f, -0.01760784f, 0.13176160f, 
    -0.08072301f, -0.03691791f, -0.23772575f, 0.17199823f, 0.52520716f, -0.01182868f, 0.12554309f, -0.11351179f, 
    -0.02358703f, 0.19914752f, -0.12506536f, -0.06660224f, 0.12166393f, 0.00557968f, -0.33026844f, -0.09642729f, 
    -0.02612820f, 0.07036746f, 0.04784354f, -0.07613013f, 0.00078921f, -0.20542111f, -0.44467553f, 0.43752724f, 
    -0.00389947f, 0.00229744f, -0.08142777f, -0.08983596f, -0.06045362f, -0.06077006f, -0.01088064f, 0.18953827f, 
    -0.12765305f, -0.01920666f, -0.15070195f, -0.02217044f, 0.02529027f, -0.14223997f, 0.02478432f, -0.31456512f, 
    -0.04981073f, 0.05497091f, 0.01947808f, 0.15622285f, 0.08812182f, 0.09820083f, -0.09341563f, 0.09234027f, 
    -0.55689299f, -0.53521198f, 0.29455435f, -0.06173730f, 0.01287978f, 0.05476147f, -0.07877604f, 0.00606916f, 
    0.08846349f, 0.06595252f, 0.35581318f, 0.07675155f, 0.34383219f, 0.21780847f, -0.00038416f, 0.04414477f, 
    0.10102521f, -0.01360908f, -0.05964871f, 0.24033973f, -0.09674325f, 0.27159894f, 0.02243694f, 0.11732933f, 
    -0.05152048f, 0.17267650f, -0.10675701f, -0.25193673f, -0.13584316f, -0.22272439f, -0.00458798f, -0.03159167f, 
    0.13482635f, 0.14384708f, 0.03183682f, 0.18166372f, -0.02712324f, 0.04385043f, 0.07685451f, -0.05031117f, 
    0.08777088f, -0.01314815f, -0.04512556f, 0.18833892f, -0.00517245f, -0.92335951f, -0.31074253f, 0.25732747f, 
    -0.09833191f, -0.05058278f, 0.12818059f, 0.05183969f, 0.14192167f, -0.01898632f, 0.37628001f, -0.23927100f, 
    0.13578658f, -0.03216273f, -0.00976529f, -0.09353148f, 0.04909601f, -0.15880513f, 0.12567507f, -0.34398210f, 
    -0.38266727f, 0.38071918f, 0.27517620f, 0.12326741f, 0.03459652f, -0.17353702f, 0.04767622f, -0.03443753f, 
    -0.12164497f, -0.24137473f, -0.18128777f, -0.10518783f, 0.09233367f, -0.26236114f, -0.02722272f, -0.08362895f, 
    0.16209906f, -0.09093789f, -0.38114458f, -0.45277861f, 0.03387117f, 0.02609309f, 0.12680930f, -0.03274943f, 
    0.02099405f, 0.15038845f, -0.00228745f, -0.04974996f, -0.17013241f, 0.17695421f, 0.08367870f, 0.11634384f, 
    -0.00236690f, -0.02970498f, 0.15528983f, -0.58449399f, -0.18079476f, 0.44229293f, -0.06100242f, -0.07854577f, 
    -0.04840001f, -0.09097552f, -0.03338362f, -0.23026493f, 0.05086324f, -0.19325556f, -0.14215264f, -0.02816280f, 
    0.00437060f, -0.00498093f, 0.09696483f, 0.00180931f, 0.01493180f, -0.25482473f, 0.35743508f, -0.14950666f, 
    -0.00101562f, -0.01526274f, 0.15349419f, -0.04084706f, -0.00100552f, -0.08184131f, 0.14467002f, -0.13066922f, 
    0.29769221f, 0.11686384f, 0.11146662f, -0.09936687f, -0.04641411f, -0.02325668f, 0.02325689f, -0.21073452f, 
    0.36389542f, -0.51868373f, 0.12237871f, -0.01436439f, 0.05224117f, -0.05949739f, 0.05786235f, 0.09402277f, 
    0.07604013f, -0.16103476f, 0.11947414f, -0.03208039f, -0.10356154f, 0.11404555f, 0.10708639f, 0.08385775f, 
    0.15190986f, -0.63015705f, 0.20679019f, -0.44369650f, -0.01478889f, 0.05556886f, 0.02576836f, -0.20360507f, 
    -0.16110261f, 0.06175183f, 0.21494952f, 0.10687291f, 0.19613925f, -0.02895993f, -0.01161207f, -0.09209629f, 
    0.03779835f, 0.13190432f, 0.15190412f, -0.15830633f, 0.36479139f, 0.01966055f, 0.27646723f, -0.00458011f, 
    0.01578503f, -0.22545357f, -0.00461125f, 0.08051862f, 0.09834655f, -0.07572956f, 0.17343089f, 0.06331177f, 
    0.15537277f, 0.07548465f, -0.11054535f, -0.00004941f, 0.13307881f, -0.09334269f, 0.15046841f, 0.02050944f, 
    0.17577548f, 0.26313952f, -0.05361747f, 0.05920748f, 0.05728013f, 0.10118908f, -0.28434309f, -0.23816425f, 
    -0.06207819f, -0.04239294f, -0.12466839f, 0.08550970f, -0.11328573f, -0.03354045f, -0.06559016f, 0.05254349f, 
    0.02938910f, -0.19800569f, 0.09934238f, -0.02916238f, -0.00897565f, -0.04636711f, 0.13993315f, 0.10978173f, 
    0.02100266f, -0.02621857f, -0.02842134f, -0.02332187f, -0.03727708f, 0.00243846f, -0.03644196f, -0.05472985f, 
    0.00919569f, -0.00452547f, 0.04065088f, -0.02352204f, -0.02972299f, 0.02890447f, 0.01482895f, -0.01009094f, 
    0.03172828f, -0.03384120f, 0.01384124f, -0.03094826f, -0.06400117f, -0.05409409f, -0.01967531f, 0.02828196f, 
    0.02869577f, 0.02903637f, -0.00091846f, 0.02138370f, 0.00684905f, -0.02315266f, 0.01151134f, 0.04545511f, 
    -0.00732644f, -0.06359217f, -0.01728045f, -0.02878095f, 0.00146414f, 0.00285755f, -0.02568731f, 0.04474173f, 
    -0.02183505f, -0.03042720f, 0.02291889f, 0.00484034f, -0.06398827f, -0.03503025f, -0.03618469f, -0.05464270f, 
    0.04153355f, -0.04712857f, -0.04403871f, -0.04957627f, -0.03364423f, 0.03782983f, -0.03787570f, -0.06401633f, 
    -0.01203180f, 0.03589692f, -0.05747103f, -0.01189833f, 0.02586135f, -0.01155729f, -0.00509131f, -0.02255343f, 
    -0.01846296f, -0.01094459f, 0.03269336f, -0.05360113f, 0.04863156f, -0.03707825f, -0.06453785f, -0.02532774f, 
    0.00375222f, 0.02890106f, -0.04322385f, -0.00002711f, -0.01909219f, -0.05227993f, 0.05242551f, -0.01299293f, 
    -0.01324443f, 0.03847828f, -0.05017491f, 0.04790922f, -0.01942945f, -0.04534207f, -0.06078165f, -0.02146938f, 
    -0.06050323f, -0.00836496f, 0.01978768f, 0.05147323f, -0.04282419f, -0.02538541f, 0.02910753f, -0.04634172f, 
    -0.05514648f, 0.00100945f, 0.05091507f, -0.06041396f, -0.01951360f, -0.01255213f, -0.03768038f, -0.03091147f, 
    -0.02892490f, 0.01290987f, 0.04952119f, 0.04283646f, -0.04682300f, 0.00036492f, -0.01728874f, 0.00916143f, 
    -0.06155834f, -0.04689905f, -0.00879157f, -0.05321984f, 0.00040796f, 0.01943143f, -0.04016462f, 0.03929209f, 
    -0.03092602f, 0.00500966f, 0.03602181f, -0.03596419f, 0.01102891f, 0.04482558f, 0.02484641f, 0.03087167f, 
    0.00932128f, -0.00811349f, -0.02894727f, -0.05453625f, 0.02696112f, 0.03315820f, 0.01457153f, -0.01779764f, 
    -0.05688134f, -0.05350773f, -0.02956032f, 0.03652276f, -0.00479369f, 0.01325276f, -0.02538106f, -0.00462075f, 
    -0.05591128f, 0.03877139f, -0.03680490f, 0.03684304f, -0.01061991f, 0.02097150f, 0.04032220f, 0.01317974f, 
    -0.04211444f, -0.03110558f, -0.02705335f, 0.03166387f, -0.03068387f, -0.04081969f, -0.00902666f, 0.00416416f, 
    -0.02336323f, -0.03245438f, 0.02798830f, -0.05802046f, -0.00121247f, 0.05145543f, -0.00885172f, -0.05131623f, 
    0.04226079f, 0.03220342f, 0.03944205f, 0.02913585f, 0.03617441f, -0.05113137f, -0.06595513f, 0.01436242f, 
    -0.01654867f, -0.01481361f, 0.04766490f, 0.00447817f, 0.04120756f, -0.00296043f, -0.00369262f, -0.02281020f, 
    -0.04317137f, -0.03622589f, 0.05089059f, 0.02180754f, -0.03335446f, -0.02784652f, -0.01561893f, -0.02078169f, 
    -0.04936830f, -0.02682291f, 0.01328770f, -0.03516798f, -0.04291557f, -0.00272330f, 0.02267404f, 0.02154028f, 
    0.04832586f, 0.03030250f, 0.04512018f, -0.00155309f, -0.02366402f, -0.04771208f, 0.02602222f, -0.06791064f, 
    -0.06239915f, 0.02066394f, -0.00374166f, -0.03998961f, 0.03493449f, -0.01215431f, -0.05762319f, -0.02677450f, 
    0.04785581f, 0.01130721f, -0.00583798f, -0.00557810f, 0.03304772f, -0.01308323f, -0.05780118f, 0.03241751f, 
    0.05067348f, -0.00163568f, -0.05626764f, -0.05521952f, -0.00793247f, -0.04252497f, -0.04533847f, 0.00481389f, 
    0.01407320f, -0.05345297f, -0.02438801f, -0.03290859f, -0.05870694f, -0.05450820f, 0.04943890f, 0.02169683f, 
    0.03925898f, -0.02557374f, -0.03019060f, 0.04478294f, 0.00356091f, -0.01499680f, 0.04078836f, 0.04797656f, 
    0.02270996f, 0.02702198f, 0.01501974f, 0.04850031f, 0.03846471f, -0.01060068f, -0.01510425f, -0.03883184f, 
    0.00760917f, -0.01572157f, 0.03154157f, 0.05052641f, -0.01890311f, -0.03709522f, 0.00440551f, -0.04892687f, 
    0.05595094f, -0.01717969f, -0.03900648f, 0.00514831f, -0.00454407f, -0.00155248f, 0.00708537f, -0.04132048f, 
    -0.03847018f, 0.02750175f, -0.01552643f, 0.00882755f, 0.00773165f, 0.02206576f, -0.02980418f, 0.01944673f, 
    0.00259848f, 0.00991893f, -0.00114657f, -0.00579057f, 0.03905117f, -0.01812869f, 0.03825394f, -0.04372297f, 
    -0.04912231f, -0.18738255f, 0.05897076f, 0.03878951f, 0.10425933f, -0.16597916f, 0.09382804f, -0.05895654f, 
    -0.04313523f, 0.23256943f, 0.04768196f, -0.33029476f, -0.24043977f, 0.11917412f, 0.13191213f, -0.08095077f, 
    0.07229669f, -0.25403324f, -0.18820523f, -0.07859378f, -0.32549727f, -0.03912228f, 0.21012223f, -0.05336812f, 
    -0.02330123f, 0.10097975f, -0.18041490f, 0.51409435f, -0.04223758f, 0.12398764f, -0.05929887f, -0.14678758f, 
    -0.08072150f, -0.12720951f, 0.06001297f, 0.05602655f, -0.05112123f, 0.04419108f, -0.07848465f, 0.07558827f, 
    0.00303572f, -0.21279472f, -0.07745834f, -0.11315243f, 0.04079570f, -0.08363159f, 0.10240319f, 0.53957361f, 
    0.07741186f, 0.07664555f, 0.19794637f, 0.03250281f, 0.04968416f, 0.04526535f, 0.09782127f, -0.11322755f, 
    0.00968308f, 0.14393134f, -0.04745301f, -0.03018353f, -0.06032373f, 0.17758544f, 0.05267595f, -0.17519687f, 
    0.21356115f, 0.08984231f, -0.03550526f, -0.04135000f, -0.14954072f, -0.11542668f, 0.06408554f, 0.00860040f, 
    -0.26921526f, 0.11797293f, 0.36084607f, -0.07054856f, 0.00314005f, -0.02262612f, 0.12715083f, -0.12523635f, 
    0.04786992f, -0.10289480f, -0.21001746f, 0.04649175f, 0.00970393f, 0.00728893f, -0.00781198f, -0.01476630f, 
    -0.06371636f, -0.19406278f, -0.15565583f, -0.27619675f, 0.20409988f, -0.01283771f, 0.11606853f, 0.08027285f, 
    -0.19382556f, -0.12085462f, -0.10625137f, 0.21824059f, 0.20846897f, 0.36204097f, -0.11048803f, -0.23103751f, 
    0.16033335f, 0.09596872f, -0.16140088f, 0.11472058f, -0.07324286f, -0.04073606f, 0.34217185f, -0.22036223f, 
    -0.13221507f, 0.18204449f, -0.01236195f, 0.12746514f, 0.02542257f, -0.11666480f, 0.30294198f, 0.28160229f, 
    0.04541889f, 0.10995319f, -0.01750274f, -0.00864416f, 0.03315131f, 0.20835413f, 0.21158868f, 0.19175260f, 
    0.03804462f, -0.07685426f, -0.08431580f, -0.18266582f, 0.08072252f, -0.03050176f, 0.05435483f, -0.12717351f, 
    0.02483872f, 0.26842409f, 0.07018986f, 0.06239348f, -0.22436601f, 0.13332808f, -0.03535070f, 0.14353603f, 
    0.22998434f, 0.01310068f, -0.23185806f, -0.01899593f, 0.02415761f, -0.15720798f, -0.19462918f, 0.02774032f, 
    -0.12794286f, 0.07913693f, -0.21082288f, -0.08060568f, -0.21823551f, 0.19841518f, -0.12666175f, -0.16357639f, 
    -0.06119907f, -0.08675832f, -0.17047222f, -0.10872120f, -0.17048441f, -0.16907570f, -0.02070720f, 0.20745784f, 
    -0.01724674f, 0.04033956f, 0.03485651f, -0.09201397f, 0.13999100f, 0.11400007f, 0.19319159f, -0.14916120f, 
    0.05323338f, -0.10311019f, 0.04325592f, -0.10445482f, 0.16546641f, 0.00112523f, 0.13024905f, -0.07879068f, 
    -0.03011074f, 0.00103427f, 0.17342874f, 0.04837437f, 0.10422177f, -0.27233940f, -0.21658872f, 0.09013478f, 
    0.34154972f, 0.15286997f, -0.11397030f, 0.13933554f, -0.24363291f, 0.08009225f, 0.46645373f, 0.01987659f, 
    -0.05288997f, 0.02643024f, 0.08674119f, -0.00075405f, 0.01595154f, 0.16594023f, 0.30511349f, 0.23962741f, 
    0.13447249f, 0.22483818f, 0.00686418f, -0.16247886f, -0.01738056f, 0.17886949f, -0.01357917f, -0.10581985f, 
    -0.10393079f, -0.14910984f, 0.08649348f, -0.26847920f, -0.08506726f, 0.21476509f, -0.03463199f, -0.30437487f, 
    0.13119784f, -0.25575697f, 0.22738715f, 0.30871341f, 0.23763043f, -0.02355505f, 0.07619939f, 0.05902263f, 
    -0.11070796f, -0.06227611f, -0.08475308f, 0.08702501f, 0.06378774f, 0.05400417f, -0.10075668f, 0.07745665f, 
    0.07791261f, -0.26282495f, 0.00068875f, -0.28643867f, -0.25478479f, 0.13620375f, 0.07724188f, 0.09298734f, 
    0.07906818f, 0.02810955f, 0.01468316f, -0.11169720f, -0.07170445f, 0.15985495f, 0.12808360f, -0.11440999f, 
    -0.02157420f, 0.05524253f, -0.09933643f, -0.03406723f, 0.01667630f, -0.27807313f, -0.18746594f, -0.07488151f, 
    -0.01707654f, -0.01592580f, 0.19853897f, 0.00777916f, 0.13152434f, -0.24679638f, 0.13180991f, -0.03283912f, 
    0.20282111f, 0.01637936f, -0.05216502f, -0.06731811f, -0.04766592f, 0.04133768f, 0.06540240f, 0.04960106f, 
    -0.01166222f, -0.36779386f, -0.25018844f, 0.14310813f, -0.04069525f, 0.00677415f, 0.21239485f, 0.00878290f, 
    0.37126136f, 0.30148557f, -0.17526016f, -0.07741875f, 0.01674681f, 0.01510318f, 0.10498826f, -0.04704601f, 
    0.07164994f, -0.58684427f, 0.01550712f, -0.12970382f, 0.21834594f, 0.11038975f, 0.19189732f, 0.03088673f, 
    0.02427005f, -0.05921362f, 0.39094743f, 0.24134824f, -0.17941615f, 0.33467698f, 0.02499772f, -0.03890791f, 
    -0.02722787f, 0.05869097f, 0.18792641f, 0.09791096f, -0.41656220f, -0.06586559f, 0.19672227f, -0.01624749f, 
    0.00574377f, 0.11429194f, -0.20027991f, -0.00035180f, 0.17127918f, 0.11619899f, -0.09698068f, -0.10266776f, 
    0.01023046f, 0.03696810f, 0.30546367f, -0.21298876f, -0.18195120f, -0.06667823f, 0.08497830f, -0.15573396f, 
    -0.20929921f, -0.06439035f, 0.05479728f, -0.05235700f, 0.16554882f, 0.02513111f, 0.33369207f, -0.07116117f, 
    0.02503098f, 0.31705454f, 0.03873193f, -0.15381794f, 0.08697516f, 0.07402201f, -0.15772069f, -0.29103994f, 
    -0.08562664f, -0.06017767f, -0.14433767f, 0.17368594f, 0.10263111f, -0.22068803f, -0.07879307f, -0.06398077f, 
    -0.56517869f, 0.06203734f, -0.07813387f, 0.04034486f, 0.17255776f, 0.10991243f, -0.05276436f, 0.06156921f, 
    0.04755052f, 0.55410779f, -0.05836798f, -0.08670676f, 0.08547024f, -0.01780004f, -0.02229970f, -0.04915123f, 
    0.08824234f, 0.10412836f, 0.34137326f, 0.28971508f, 0.08983425f, 0.04836759f, 0.17540474f, 0.02587982f, 
    0.12280102f, 0.24690169f, 0.00536910f, -0.42314723f, -0.25557560f, -0.13197884f, 0.15809943f, 0.18422058f, 
    0.17454360f, -0.19214074f, -0.02890204f, -0.08401757f, 0.09112937f, -0.06528611f, 0.05383764f, -0.24367492f, 
    -0.13151234f, -0.02641402f, -0.17099094f, 0.02330398f, -0.05716449f, -0.21849880f, 0.05484458f, -0.06905976f, 
    -0.11564945f, -0.08364800f, 0.07789315f, -0.16540381f, 0.17642778f, 0.01391004f, 0.05422965f, 0.16809994f, 
    -0.37323481f, 0.04272073f, -0.09130388f, -0.03859689f, -0.01012658f, 0.02622403f, -0.07059407f, -0.00838706f, 
    0.17008616f, -0.43190247f, -0.00771891f, 0.02014885f, 0.08062728f, -0.18519275f, -0.17747256f, -0.05949601f, 
    0.10325780f, -0.15460201f, 0.03836886f, 0.07460552f, -0.14855181f, -0.12330780f, -0.02727704f, 0.02525156f, 
    -0.15807249f, -0.16664565f, -0.16558442f, 0.00634594f, -0.12999539f, 0.07646999f, -0.05129823f, -0.02605045f, 
    0.16258353f, 0.02564943f, -0.13245165f, 0.09425227f, 0.10697069f, 0.10385138f, -0.12844580f, 0.09840091f, 
    0.15353592f, 0.12364928f, 0.03925057f, 0.11301265f, 0.02455613f, -0.17467637f, -0.11337421f, 0.07228291f, 
    -0.03980457f, 0.19059317f, -0.07934026f, 0.00243696f, -0.47196689f, -0.18934901f, 0.01028733f, 0.10722634f, 
    0.06084372f, 0.02482288f, 0.11570070f, 0.12418375f, -0.09446764f, 0.51115084f, 0.19789369f, -0.12613223f, 
    -0.01715224f, 0.11830330f, 0.14648570f, 0.01846565f, -0.07642046f, 0.19191435f, -0.22652435f, 0.17817080f, 
    -0.17526521f, 0.21515657f, -0.13947265f, -0.15461352f, 0.06989297f, 0.04243657f, -0.10374042f, 0.05076581f, 
    -0.13751687f, -0.04809292f, -0.01638049f, 0.22065188f, 0.01534978f, 0.01263737f, -0.08897524f, 0.21726908f, 
    0.03682287f, -0.07905569f, 0.28659016f, 0.17597722f, 0.19016431f, 0.07756547f, 0.03195582f, 0.14152648f, 
    -0.07593960f, 0.27945453f, 0.13622999f, -0.08685309f, -0.33706319f, -0.14093196f, 0.01860605f, -0.05912330f, 
    -0.05286682f, -0.14769585f, -0.17628473f, -0.04098262f, 0.11706090f, 0.09482105f, -0.03525934f, -0.09314779f, 
    -0.03527326f, 0.14488488f, 0.12651816f, 0.55447394f, 0.02470226f, -0.11135592f, -0.00389641f, 0.03714570f, 
    0.19231091f, 0.03122862f, 0.02368353f, 0.05844273f, -0.21018568f, -0.41303444f, 0.12970284f, 0.04067794f, 
    0.23282689f, -0.02452414f, -0.17186575f, -0.18225649f, -0.12710899f, -0.00058918f, 0.07434097f, 0.11757012f, 
    0.13603766f, -0.10639971f, 0.09124523f, 0.09013662f, 0.04966909f, 0.32092917f, -0.53076774f, -0.16137719f, 
    -0.06999452f, -0.24024752f, 0.15797000f, 0.00957303f, -0.05471153f, -0.05322255f, -0.01547128f, -0.34693277f, 
    0.06738762f, 0.11255179f, -0.01518769f, 0.04843909f, -0.05333022f, 0.03564735f, -0.09116963f, 0.21636242f, 
    0.25093251f, 0.09464417f, 0.08557890f, -0.09523313f, -0.10594160f, -0.09626257f, 0.09626377f, 0.11358114f, 
    0.13381970f, -0.12606247f, 0.01991964f, -0.35878235f, 0.00649377f, 0.19485173f, -0.04295283f, -0.16088258f, 
    -0.08951506f, -0.08611138f, 0.37841228f, 0.01866650f, -0.22001034f, -0.21684125f, -0.02143362f, -0.03040505f, 
    0.04009356f, -0.04376591f, 0.15108547f, 0.28817749f, -0.02341767f, -0.02534395f, -0.08284910f, -0.01917044f, 
    -0.14132707f, 0.03754928f, 0.08760199f, 0.08725055f, 0.15353023f, 0.12071051f, 0.00407341f, 0.18311894f, 
    -0.24066213f, 0.00018362f, -0.05207797f, 0.14370224f, 0.01208221f, -0.57437694f, 0.35255852f, 0.13961847f, 
    -0.03067078f, -0.12300073f, 0.21593308f, 0.02716318f, 0.06394979f, 0.13670903f, 0.13700557f, 0.05263422f, 
    0.23880824f, 0.03915044f, 0.00626869f, -0.04721931f, 0.11090636f, -0.08700507f, 0.07762183f, 0.22716609f, 
    0.06690986f, 0.01778594f, -0.21596576f, -0.05851545f, 0.09331148f, -0.05421180f, -0.01330041f, 0.06091576f, 
    -0.24810392f, 0.18288004f, -0.04688689f, 0.11878023f, 0.05087902f, -0.03421130f, -0.08031953f, -0.13158403f, 
    0.06678830f, 0.10399652f, -0.15565996f, -0.26552960f, -0.20256375f, 0.17749757f, 0.05329588f, 0.19898099f, 
    0.12532456f, 0.09522220f, 0.25568849f, 0.12825441f, 0.09289321f, -0.13502818f, -0.19737376f, 0.07084408f, 
    0.03753027f, 0.04285916f, 0.11052179f, -0.24717075f, 0.10275337f, -0.34107244f, 0.12938458f, 0.21347067f, 
    0.52558702f, 0.01323089f, 0.03124654f, -0.09981216f, -0.03137451f, 0.25069517f, 0.18870167f, -0.22233780f, 
    -0.25164294f, -0.02684803f, 0.08611950f, -0.01187551f, 0.23710342f, -0.04672867f, 0.21087901f, 0.10431133f, 
    -0.02636200f, -0.07099292f, 0.21206594f, 0.00977096f, 0.15716797f, 0.17588969f, -0.18977931f, 0.05822884f, 
    -0.01486901f, -0.06054823f, -0.12130658f, 0.17433310f, 0.16400324f, 0.09322123f, 0.06165302f, -0.05734842f, 
    0.02014181f, -0.30634460f, -0.05188791f, 0.08667082f, -0.02987899f, 0.05385363f, -0.10820132f, -0.08602753f, 
    0.15107863f, -0.32240355f, -0.01951727f, -0.13748179f, -0.09142558f, -0.04461081f, 0.01480804f, 0.06680465f, 
    0.12099235f, -0.12010477f, -0.15608624f, -0.34592754f, -0.18955278f, 0.07610030f, 0.05864479f, 0.13609529f, 
    -0.12998892f, -0.11388346f, -0.24240701f, 0.17051002f, -0.26936698f, -0.04956643f, -0.02717710f, 0.08729754f, 
    0.11860007f, 0.00265569f, 0.00567252f, -0.25933111f, 0.04969124f, -0.07248264f, 0.05880249f, -0.02249260f, 
    0.02721268f, 0.12305960f, -0.20280220f, 0.08982364f, -0.12084290f, 0.16170244f, -0.06872001f, 0.12240311f, 
    0.07164413f, 0.10758489f, -0.22668174f, 0.10216849f, 0.03600106f, 0.43027845f, 0.06513023f, -0.12272707f, 
    -0.14501168f, 0.03626105f, 0.04196016f, 0.27045482f, 0.25300711f, 0.10091310f, -0.16225532f, 0.11045575f, 
    -0.15352486f, -0.41762614f, -0.24029548f, 0.01746937f, 0.40168321f, 0.07956989f, 0.22626457f, 0.01468817f, 
    -0.08699881f, 0.26256084f, 0.09208152f, -0.00583810f, -0.10419156f, -0.04780446f, 0.12291986f, 0.04711078f, 
    -0.35018107f, 0.06010437f, -0.23031805f, 0.06603882f, 0.20785478f, -0.03892278f, -0.10936706f, 0.00327476f, 
    -0.12346867f, 0.05496912f, -0.14395052f, -0.07065768f, -0.16879916f, 0.00977137f, 0.12607443f, 0.10806147f, 
    0.25702897f, -0.03214103f, -0.24152105f, -0.08548422f, -0.05063479f, 0.24223465f, -0.00932946f, -0.10180089f, 
    0.05839478f, -0.10542316f, -0.00484900f, 0.09275554f, -0.05019336f, 0.01953329f, -0.06537911f, 0.06873045f, 
    0.06385013f, 0.15718798f, 0.00667937f, 0.11625587f, -0.20617978f, -0.01069292f, -0.11751974f, 0.17465012f, 
    -0.10179231f, 0.37473339f, -0.26507154f, 0.02559477f, -0.02115763f, -0.60769320f, -0.07859957f, -0.07315477f, 
    0.01858865f, 0.10266162f, 0.07412791f, 0.15299280f, -0.00805566f, -0.00913297f, 0.01672739f, 0.20096929f, 
    0.07019725f, 0.12323391f, -0.06233509f, 0.20309764f, -0.26900312f, 0.05120333f, -0.01685876f, 0.03676973f, 
    0.12769443f, -0.16910914f, 0.20105924f, -0.02454430f, 0.05416047f, -0.01732210f, 0.18323667f, 0.16352218f, 
    0.02749849f, -0.06492352f, 0.01671868f, 0.02800856f, -0.00115098f, -0.02971891f, 0.03929444f, -0.04378911f, 
    0.04822712f, 0.04629996f, 0.04490050f, -0.04692217f, 0.03107856f, -0.03193515f, 0.01445482f, -0.01595490f, 
    0.03628105f, -0.03699054f, 0.03303355f, 0.01671787f, -0.00471012f, 0.00530223f, 0.03719356f, -0.05671532f, 
    -0.03760022f, -0.05727600f, -0.04267459f, 0.03169817f, -0.00062558f, -0.03611315f, -0.01237708f, 0.01604777f, 
    -0.02761291f, -0.03740945f, -0.01281232f, -0.03523738f, -0.00606322f, 0.04110062f, -0.04491324f, -0.04382763f, 
    -0.05243988f, -0.04394515f, 0.00442011f, -0.04052294f, -0.03970254f, -0.03506208f, -0.00025468f, 0.03292749f, 
    -0.02190020f, -0.04728221f, 0.03709140f, -0.06574657f, -0.01617781f, -0.06619627f, 0.00648110f, -0.02616111f, 
    -0.04022600f, -0.02768104f, -0.03255028f, 0.03419937f, -0.02223554f, -0.03265778f, 0.02409525f, 0.03116471f, 
    -0.06176955f, 0.02836518f, -0.04833975f, -0.05206874f, -0.01999289f, -0.06001297f, -0.04911420f, -0.02893438f, 
    -0.02379331f, -0.05191872f, 0.03441521f, -0.00294013f, 0.02785218f, -0.00132499f, 0.03661198f, -0.03181095f, 
    0.00471375f, -0.00634011f, 0.05048179f, 0.02992687f, -0.05209420f, 0.04077761f, -0.06604773f, -0.00476315f, 
    0.00819704f, -0.05392548f, 0.02853752f, -0.04652229f, -0.03044931f, -0.01286006f, 0.04685907f, -0.03229399f, 
    0.03643207f, 0.04315424f, 0.03697038f, -0.00306864f, 0.05287979f, -0.05574947f, -0.03738617f, -0.04503969f, 
    0.03683291f, 0.04247108f, -0.01761777f, 0.01162341f, -0.06059899f, -0.01787751f, 0.00950838f, -0.01544867f, 
    -0.02550886f, -0.05437146f, 0.04740617f, -0.05968153f, 0.04695558f, 0.00492861f, -0.04495082f, 0.01475926f, 
    -0.03419159f, -0.01419863f, -0.01222958f, -0.01072751f, 0.02320311f, 0.01167477f, -0.05361509f, 0.03554990f, 
    0.04097324f, 0.00100023f, -0.05738701f, -0.00391678f, -0.00309645f, -0.02287744f, -0.01343481f, 0.04170251f, 
    -0.03152216f, 0.03049661f, 0.00979998f, -0.06542014f, -0.04557691f, -0.05044908f, 0.03843371f, 0.00450774f, 
    0.00596871f, -0.01953660f, 0.00909755f, 0.04055777f, -0.02108766f, -0.00707077f, 0.01949310f, -0.05256165f, 
    -0.01398320f, 0.03729716f, -0.04366603f, 0.00360192f, 0.03344347f, 0.01808831f, 0.03495081f, -0.04157507f, 
    0.03167931f, 0.00428600f, 0.05071471f, -0.03746995f, 0.01322278f, 0.00059779f, -0.05337140f, 0.04761436f, 
    -0.00625877f, 0.00058875f, 0.02582383f, -0.03108847f, 0.00563930f, -0.00342512f, -0.04544660f, -0.05641397f, 
    0.05002284f, 0.01570671f, -0.05879500f, -0.03447002f, 0.01992470f, -0.04490938f, 0.03064534f, 0.04243170f, 
    -0.00458737f, -0.05763474f, -0.04266950f, 0.01737712f, -0.06482471f, 0.04888366f, -0.02238817f, 0.02955960f, 
    0.00187170f, -0.00892936f, 0.03244241f, -0.03348830f, -0.03077154f, 0.04244872f, 0.03590140f, 0.02428575f, 
    0.04209888f, -0.05564944f, 0.04999020f, 0.02348306f, 0.03471341f, 0.01132652f, -0.06756698f, -0.00344129f, 
    -0.06236125f, 0.00374626f, -0.06371292f, 0.02047435f, 0.00258820f, 0.02326172f, -0.03117481f, -0.02130689f, 
    0.02589497f, -0.00210307f, -0.03731940f, -0.03022440f, -0.01100046f, -0.03077853f, 0.00733896f, 0.00825818f, 
    -0.04045335f, 0.04713690f, 0.00404746f, 0.04924768f, -0.00563305f, -0.00042021f, -0.00674758f, -0.02002890f, 
    0.00670047f, 0.03548824f, -0.01356638f, -0.01388899f, -0.00434988f, -0.04520418f, -0.05416402f, 0.01909974f, 
    0.04043090f, 0.00492165f, -0.04210266f, -0.06297448f, -0.04583345f, 0.03230104f, 0.03913967f, -0.04035379f, 
    -0.04684769f, -0.02288359f, 0.04663819f, -0.02026144f, -0.05588333f, -0.05467080f, 0.00303350f, -0.04081708f, 
    0.04840502f, -0.04269303f, -0.01972266f, 0.04792475f, -0.01057609f, -0.00469658f, 0.02579641f, -0.04032333f, 
    0.00213051f, 0.04813639f, 0.00789233f, 0.02096081f, -0.00312649f, 0.01878866f, 0.00533974f, -0.00052899f, 
    -0.02782898f, -0.01259445f, -0.04484823f, 0.02470734f, 0.04011890f, -0.02107761f, -0.04618138f, -0.06562447f, 
    -0.04609961f, -0.01641813f, -0.04356855f, -0.06652740f, -0.02790311f, 0.00651547f, 0.02002786f, 0.04370359f, 
    -0.05774985f, 0.01255041f, 0.02237704f, 0.03033288f, -0.04163745f, -0.03996626f, -0.00637491f, 0.02321017f, 
    0.03768593f, 0.04645955f, -0.02635312f, -0.05171502f, 0.03255170f, -0.02843703f, -0.00629153f, 0.02097731f, 
    -0.01364911f, 0.04437929f, -0.02466867f, -0.00400208f, -0.01721928f, -0.04286711f, 0.01173624f, 0.03464888f, 
    0.00168905f, 0.02575417f, -0.02371809f, -0.01765759f, -0.04606329f, -0.03772204f, 0.01265679f, 0.04586724f, 
    0.01182963f, -0.05714677f, -0.02303793f, 0.03310087f, 0.02961765f, -0.06112818f, -0.01864509f, -0.04668599f, 
    -0.06626974f, 0.00229296f, -0.00705852f, -0.00938445f, -0.03489210f, 0.01243209f, 0.00072801f, -0.01756748f, 
    0.01928884f, 0.02944200f, 0.00137534f, 0.01626563f, -0.01899670f, -0.03414057f, 0.01038646f, -0.03685790f, 
    -0.05957057f, -0.04455048f, 0.05089411f, -0.02486950f, -0.03062141f, 0.03138927f, 0.01302474f, -0.06601086f, 
    0.02921640f, 0.01087023f, 0.01505492f, 0.02100889f, -0.05287548f, 0.03759472f, -0.02516435f, 0.01109795f, 
    -0.04722502f, -0.03531062f, -0.05226026f, 0.04293106f, -0.01417054f, -0.02593360f, 0.01432041f, -0.03626016f, 
    -0.03396470f, 0.02327027f, 0.01566488f, -0.06388243f, -0.06124958f, -0.04624091f, -0.00035760f, -0.06355955f, 
    0.04230718f, 0.03810965f, -0.05012010f, -0.03588415f, -0.03629114f, -0.02891636f, -0.06287839f, 0.04766003f, 
    0.03312860f, -0.00581348f, -0.01496558f, -0.05129029f, 0.00524911f, -0.03558217f, 0.02197060f, -0.03847338f, 
    0.01954628f, 0.02069988f, -0.04656114f, -0.05418226f, -0.02684628f, 0.01119796f, 0.04549516f, -0.04448272f, 
    -0.05632830f, 0.04992896f, -0.00758085f, 0.03440773f, -0.03712266f, -0.02233787f, 0.01574633f, -0.04656938f, 
    0.04907039f, -0.01977110f, 0.02874781f, 0.02711806f, -0.00955425f, -0.06280930f, -0.03221289f, -0.06062022f, 
    -0.02648305f, -0.03762926f, -0.00291787f, -0.03705505f, 0.02294291f, -0.00155238f, 0.04415773f, 0.04729830f, 
    -0.03686372f, -0.02317137f, -0.01464432f, 0.03038445f, -0.02145593f, 0.01909233f, 0.03263854f, -0.04905378f, 
    -0.05583178f, 0.05080202f, -0.03506821f, 0.04111027f, -0.01591364f, 0.03643381f, 0.03983757f, -0.05010505f, 
    0.03434649f, -0.03208841f, 0.04322173f, -0.02306321f, -0.01301978f, -0.03243237f, 0.03844821f, 0.03754504f, 
    -0.04959588f, 0.00797731f, -0.03336810f, -0.03344720f, 0.04679526f, 0.00751429f, 0.01832593f, 0.04232170f, 
    -0.03267352f, -0.06807401f, 0.00950148f, -0.02797547f, 0.02874783f, 0.01752023f, 0.02192257f, -0.01097425f, 
    -0.06179484f, 0.02706874f, 0.04187381f, 0.02093676f, -0.01503502f, 0.02036604f, 0.01016031f, 0.04893293f, 
    0.00873198f, -0.02222451f, 0.03715254f, -0.00339851f, 0.02528666f, -0.06281652f, -0.03074974f, 0.05478946f, 
    0.02010590f, 0.03010233f, -0.01203029f, 0.04398207f, -0.02278378f, 0.01205065f, 0.04811664f, 0.02759304f, 
    0.01757592f, -0.06805874f, -0.01268375f, 0.04535715f, -0.06221944f, -0.02180390f, -0.01384139f, 0.03237256f, 
    -0.02777929f, 0.02002041f, 0.02571164f, -0.02735605f, 0.04533460f, 0.00338906f, -0.04112624f, -0.06208263f, 
    0.00896265f, -0.06093068f, 0.00442431f, 0.01791746f, -0.05380329f, -0.06750757f, 0.03461616f, -0.00189099f, 
    0.02190591f, -0.03472093f, 0.04521024f, -0.01197285f, -0.05041321f, 0.01699870f, -0.03457886f, 0.00153313f, 
    -0.03787200f, -0.00742890f, -0.03492240f, 0.01041154f, -0.01856072f, 0.02292147f, 0.02157690f, 0.03778796f, 
    -0.06305489f, 0.00671642f, 0.04285191f, -0.05281008f, 0.00708896f, 0.02438030f, -0.05946885f, 0.02219515f, 
    -0.05228165f, 0.01405057f, 0.00231166f, 0.05066700f, -0.01366941f, -0.05676838f, -0.03084748f, -0.06463136f, 
    -0.04820557f, 0.03172577f, 0.01330293f, 0.00477754f, -0.06159018f, -0.06473268f, -0.02519892f, -0.01120027f, 
    0.04179017f, 0.01784576f, -0.03298293f, -0.06268094f, -0.05931374f, 0.02282320f, -0.05029766f, 0.03381464f, 
    0.02127012f, 0.03920261f, -0.04038689f, -0.06886296f, -0.02466046f, -0.04208237f, -0.00411189f, -0.00601629f, 
    -0.05165115f, 0.04411419f, -0.06945738f, 0.02216456f, -0.06566462f, -0.06611447f, -0.06788898f, 0.00175082f, 
    0.01223515f, -0.00459835f, -0.05826843f, -0.03730780f, -0.00358529f, 0.02369617f, -0.04492317f, -0.02120114f, 
    -0.02435701f, -0.02836519f, 0.04199408f, -0.00320725f, 0.01132088f, 0.00147242f, 0.01008310f, -0.00127106f, 
    0.02374813f, 0.03331519f, -0.04112751f, 0.04405538f, 0.03459711f, 0.04901314f, -0.03101251f, -0.02713029f, 
    -0.04662378f, 0.01364583f, -0.01174287f, -0.05735627f, 0.05339289f, 0.01251228f, -0.01728297f, -0.05631321f, 
    0.05291653f, -0.00682826f, -0.05074443f, -0.02548485f, 0.05022763f, -0.03610842f, 0.03501533f, 0.00814453f, 
    -0.01660466f, -0.04251041f, -0.02437069f, -0.05879351f, -0.00564801f, -0.02614215f, -0.02819566f, 0.02965935f, 
    -0.00019850f, -0.01471047f, -0.03442699f, -0.02079606f, -0.05866215f, -0.00392416f, -0.04903323f, 0.04569127f, 
    0.02834667f, -0.00444489f, -0.00469481f, -0.04354729f, 0.00532700f, -0.02694302f, 0.03416362f, -0.03907489f, 
    0.02796426f, -0.00966708f, 0.03053026f, -0.02503005f, -0.01431740f, 0.04721569f, -0.03842428f, 0.02830174f, 
    0.00813536f, -0.04010393f, 0.03471562f, -0.04487547f, 0.04993098f, -0.00767036f, -0.06114288f, -0.04495032f, 
    -0.06011381f, 0.04741956f, 0.02584008f, 0.03962090f, 0.02865736f, -0.02156045f, 0.02039972f, 0.00944633f, 
    -0.00203304f, -0.01953950f, 0.05086773f, -0.06436083f, -0.03865909f, -0.02453437f, -0.00570711f, 0.04715028f, 
    0.03483695f, -0.04378786f, 0.00656236f, 0.01682704f, -0.03642535f, -0.02523230f, -0.01128287f, -0.00033257f, 
    -0.03006522f, -0.00399702f, 0.00359496f, -0.06311585f, 0.05413945f, 0.04226226f, -0.03545119f, -0.01754989f, 
    0.03614569f, -0.05072184f, 0.01932695f, -0.04836608f, -0.01064407f, -0.01230696f, 0.04737018f, -0.05352759f, 
    -0.02755719f, -0.00952012f, -0.05304023f, -0.00125911f, 0.04514666f, -0.00725523f, -0.04466626f, -0.01735803f, 
    -0.01068542f, 0.00560165f, -0.04614604f, -0.00965495f, 0.05363360f, 0.02118915f, -0.02511902f, 0.03590297f, 
    0.05385906f, -0.03192811f, 0.04336647f, -0.03204020f, -0.01223920f, 0.01384583f, 0.05188775f, 0.04406348f, 
    0.03894312f, -0.04342956f, -0.01370853f, -0.03097650f, 0.03438342f, 0.00751219f, -0.05037280f, 0.00086192f, 
    -0.00932151f, -0.05344738f, -0.01505735f, -0.04580391f, -0.02002301f, 0.03788602f, -0.06134103f, 0.00748921f, 
    -0.00930724f, -0.06095295f, 0.04686850f, 0.04761126f, 0.01816235f, 0.01652054f, -0.06222786f, -0.00928722f, 
    -0.03516765f, 0.01964520f, -0.04024851f, 0.01492181f, 0.00701857f, 0.05481911f, -0.03016304f, -0.06292585f, 
    0.04539910f, 0.01962185f, -0.05156212f, -0.02417655f, -0.05877915f, -0.01434626f, 0.02663217f, -0.02711807f, 
    -0.04658327f, -0.03788765f, 0.02018302f, -0.05920559f, -0.03948960f, -0.02622734f, 0.03929460f, -0.04681063f, 
    0.04731508f, -0.00591184f, 0.02664708f, -0.06227729f, 0.02418661f, -0.00656743f, 0.03078779f, -0.02186706f, 
    -0.04705920f, -0.02089330f, 0.00250522f, -0.01384326f, -0.03988680f, 0.03874698f, 0.05688410f, -0.01283881f, 
    0.01269699f, 0.01615129f, 0.01154169f, -0.04842448f, 0.02305456f, -0.02415464f, -0.02870737f, -0.03736778f, 
    -0.00666157f, -0.02838673f, 0.02225734f, 0.01492174f, 0.02865241f, -0.05332945f, -0.03321159f, 0.03595039f, 
    0.02480975f, -0.05306735f, -0.04621512f, -0.00260225f, -0.00988119f, -0.04410207f, 0.04909154f, -0.00482893f, 
    -0.01341053f, -0.01073018f, 0.05222629f, 0.03405505f, -0.02878420f, 0.04652524f, -0.01574874f, -0.06769809f, 
    -0.04646751f, 0.04331173f, 0.03762187f, -0.01316295f, 0.01283945f, -0.04965257f, -0.06356960f, -0.04738942f, 
    -0.06385783f, 0.05077662f, 0.01052534f, -0.06024775f, -0.00095877f, -0.04643729f, -0.00255798f, -0.05072463f, 
    -0.05306032f, -0.01322660f, -0.03475659f, -0.04372134f, 0.01864918f, -0.03633319f, -0.00708358f, -0.01932739f, 
    0.01825407f, 0.05316561f, 0.03482502f, 0.01432566f, -0.04996374f, 0.01004572f, 0.02684142f, 0.00668430f, 
    0.05397183f, -0.04053953f, 0.03541150f, -0.05789475f, 0.00868226f, -0.01958192f, 0.02356763f, -0.03901171f, 
    0.02319573f, 0.00610948f, 0.01304664f, 0.02811363f, -0.00296698f, -0.03295861f, -0.05749194f, -0.01468197f, 
    0.25924477f, 0.06459105f, 0.12460833f, 0.03981730f, -0.06162129f, 0.14647546f, 0.00303709f, -0.02290198f, 
    0.19612442f, -0.09827264f, -0.30356115f, 0.23523948f, 0.09613454f, 0.04458522f, 0.07399914f, -0.06956679f, 
    0.23366655f, -0.14100160f, -0.22507729f, -0.29077181f, -0.15455417f, -0.09333820f, 0.21098116f, -0.06710285f, 
    0.05353497f, 0.06871509f, -0.20235494f, -0.00277408f, -0.23979734f, -0.09957217f, 0.03715164f, 0.10047583f, 
    -0.03460180f, 0.00261590f, 0.04131489f, 0.18521878f, 0.33010909f, 0.25568619f, 0.19890979f, 0.00851191f, 
    -0.02050115f, 0.05128057f, -0.01918161f, -0.08269656f, 0.31313547f, 0.31472588f, 0.17851153f, -0.06710593f, 
    -0.04348816f, -0.06217964f, 0.20190234f, -0.26729402f, 0.33616859f, -0.04082847f, 0.33651850f, -0.10772751f, 
    -0.16848290f, -0.11127316f, -0.04484244f, 0.21045844f, -0.06401256f, -0.06342395f, 0.26168668f, -0.03895283f, 
    -0.00558164f, 0.01056298f, 0.03302048f, -0.16937998f, 0.23677734f, 0.21144965f, 0.11556768f, -0.00445697f, 
    0.02596442f, 0.06373210f, -0.03806315f, 0.06127474f, -0.18595150f, -0.11819623f, 0.20383218f, 0.26419500f, 
    0.12674202f, -0.81760037f, -0.55010551f, -0.14325178f, 0.13213950f, 0.00758802f, 0.19378014f, 0.05987013f, 
    -0.12143423f, -0.23915812f, -0.72909731f, -0.52995867f, 0.07531050f, -0.11866839f, 0.15195738f, 0.06850722f, 
    -0.11885861f, 0.01450703f, 0.04553492f, -0.42229226f, -0.04379885f, 0.10349499f, 0.02902314f, 0.04678434f, 
    0.18773985f, -0.09545255f, 0.07429592f, -0.12500997f, 0.14569776f, 0.16731247f, 0.19427782f, -0.13502204f, 
    -0.04134925f, 0.18239923f, -0.04413813f, -0.00853009f, -0.09963788f, 0.20891629f, 0.12438916f, -0.02769426f, 
    -0.26146954f, -0.10036471f, 0.07627205f, -0.04438792f, -0.01105698f, 0.01100474f, -0.04386232f, 0.12096281f, 
    0.17061283f, 0.12582824f, -0.11446320f, -0.23894677f, 0.13783081f, 0.06653178f, 0.18237819f, 0.17557649f, 
    0.00602805f, 0.04374713f, -0.05058026f, -0.12358518f, -0.06786818f, 0.20867506f, -0.01221579f, 0.05650114f, 
    0.32482919f, -0.00473897f, 0.03774813f, 0.11883732f, 0.15011960f, -0.04965296f, -0.06303716f, 0.03470798f, 
    0.26887295f, -0.07426631f, 0.14251700f, 0.21050353f, 0.23199169f, -0.27924022f, 0.16677098f, 0.10466624f, 
    0.17905216f, 0.14511940f, -0.36533144f, -0.34931338f, 0.01272611f, -0.06372709f, 0.07913155f, 0.00822441f, 
    0.16439214f, -0.08857802f, -0.29508254f, 0.17166257f, 0.04060349f, 0.15755130f, -0.08596777f, -0.13401040f, 
    0.10930216f, -0.00180918f, 0.12761194f, -0.00850658f, -0.08590969f, 0.05109280f, -0.08815046f, -0.04547482f, 
    -0.01333498f, 0.00005210f, -0.04626462f, 0.09830477f, 0.05689274f, 0.27037531f, -0.11690507f, 0.35535249f, 
    0.11078502f, -0.12976219f, 0.14136070f, 0.02154963f, 0.06503397f, 0.08354993f, -0.00887906f, -0.27124053f, 
    0.12273113f, 0.24106975f, 0.03108839f, -0.13402577f, 0.14294414f, 0.10822938f, 0.00109096f, -0.03895659f, 
    0.05784167f, 0.04947266f, 0.24048766f, -0.31576461f, 0.23141336f, -0.03189464f, -0.11972846f, -0.07969973f, 
    0.12938787f, -0.16155763f, -0.09397406f, 0.08465609f, -0.13855904f, 0.03371292f, 0.02447549f, 0.22918922f, 
    -0.28322640f, 0.26531759f, 0.08295467f, 0.01128835f, 0.03482758f, -0.04604631f, 0.04144638f, 0.11985254f, 
    -0.04466252f, -0.01168934f, -0.43585810f, -0.22995986f, 0.05568031f, -0.03080797f, -0.00962326f, -0.12934734f, 
    -0.04233581f, -0.06306119f, -0.17140934f, -0.82424849f, -0.72540981f, -0.15033272f, 0.08418705f, 0.01004093f, 
    0.17027766f, 0.00543866f, -0.09029643f, 0.02248982f, 0.19532692f, 0.24260673f, -0.05464039f, -0.00641677f, 
    0.21563564f, 0.34915820f, -0.00210658f, 0.24317130f, 0.05048842f, -0.95570683f, -0.39632100f, -0.05193233f, 
    0.10409362f, 0.08965775f, 0.08929691f, 0.10441025f, -0.15508294f, -0.14255650f, 0.21484822f, 0.11132333f, 
    -0.15884605f, -0.20576811f, 0.11995833f, 0.05381128f, -0.07245909f, 0.09508235f, -0.08852638f, -0.59219849f, 
    -0.42596912f, 0.04669502f, -0.11175133f, 0.10116419f, 0.16330369f, 0.18506479f, 0.09620580f, -0.17151478f, 
    0.07642379f, 0.00749040f, -0.04450594f, 0.07972116f, 0.05257174f, 0.11376278f, -0.10492749f, -0.14106943f, 
    0.03058564f, -0.78151703f, 0.34854394f, 0.14586706f, 0.23980844f, 0.10406705f, -0.18800610f, 0.00564600f, 
    -0.10256629f, 0.25559029f, -0.17993243f, -0.14366423f, -0.22384146f, -0.03700020f, -0.04114290f, 0.08345164f, 
    0.06617249f, -0.16960604f, 0.02265348f, -0.25980127f, -0.72739625f, -0.03509410f, -0.09366705f, 0.13327645f, 
    -0.07222162f, 0.03183042f, 0.00111601f, -0.04765595f, 0.07586808f, -0.09574404f, -0.16533640f, -0.09093804f, 
    0.09188586f, 0.29515690f, -0.08576686f, 0.06588800f, 0.13964628f, 0.15996158f, -0.26184630f, 0.09852133f, 
    -0.18134969f, -0.04294831f, -0.20121419f, 0.06905071f, 0.07858172f, 0.09211300f, -0.13118872f, -0.43190244f, 
    -0.04899730f, -0.16040035f, 0.19694746f, 0.26640275f, -0.05377882f, 0.00053170f, 0.05741972f, 0.04511154f, 
    -0.39467117f, -0.28293040f, 0.14722946f, 0.23252469f, 0.18018267f, -0.12461313f, -0.06067850f, -0.27894247f, 
    0.41914460f, 0.05170922f, -0.01462229f, 0.36845931f, -0.12809771f, -0.05892663f, -0.02287094f, 0.00333228f, 
    0.07659041f, -0.21927054f, -0.06627194f, -0.10275918f, 0.08103904f, 0.09840593f, 0.14982551f, -0.09465472f, 
    -0.04295623f, 0.09531765f, -0.19483596f, 0.05452772f, 0.06503403f, 0.16593423f, 0.07624403f, 0.04340415f, 
    0.04711504f, -0.05317470f, 0.19913755f, 0.12184115f, 0.28599781f, -0.08401579f, 0.18550073f, 0.01706542f, 
    -0.17072289f, -0.02616161f, 0.09504568f, -0.03052331f, 0.07753289f, -0.18530799f, -0.07564625f, -0.02105193f, 
    0.12013758f, -0.15553676f, -0.04752456f, 0.07796516f, -0.19505443f, 0.30415940f, -0.17703940f, 0.12330969f, 
    0.07036521f, -0.08797923f, -0.19543640f, 0.09228632f, -0.02535651f, 0.02667243f, -0.19489163f, -0.40182963f, 
    -0.00231946f, 0.04347662f, 0.15235849f, 0.26031339f, -0.00939997f, -0.04073740f, 0.06662757f, -0.02581127f, 
    -0.22690873f, -0.15237010f, -0.00190820f, 0.02901270f, 0.18307133f, -0.24559885f, 0.03761278f, -0.00455113f, 
    -0.51755977f, 0.08278351f, 0.25882074f, 0.13638988f, 0.11952306f, -0.16990648f, -0.09574674f, -0.00442412f, 
    0.19655371f, 0.21325389f, 0.03694535f, -0.21201535f, 0.00092933f, 0.10036802f, -0.06441194f, -0.05734697f, 
    0.07956171f, 0.12173738f, -0.06441950f, -0.00391081f, -0.23609257f, 0.02115138f, 0.01233933f, 0.07115770f, 
    0.00677920f, -0.09834016f, 0.20927334f, 0.19382812f, -0.05525243f, 0.05674255f, -0.18712214f, -0.11251739f, 
    0.11891948f, 0.19245341f, 0.10584193f, -0.00063531f, -0.12369062f, 0.27802187f, 0.05064699f, -0.00467466f, 
    0.10993098f, 0.05868949f, 0.08278030f, -0.00931377f, 0.08414819f, 0.08648150f, 0.18111970f, -0.09185825f, 
    0.04989186f, 0.10211996f, 0.07858877f, -0.10673706f, -0.06702945f, -0.10247929f, -0.55743867f, -0.28059965f, 
    0.17459585f, 0.05222998f, 0.11799203f, 0.15129079f, -0.02370862f, -0.09811298f, -0.01976768f, -0.11917025f, 
    -0.00915718f, -0.27457035f, 0.18524510f, 0.25303254f, 0.04783266f, -0.26402581f, -0.12325215f, -0.11720716f, 
    0.07900439f, -0.11435617f, -0.12060720f, 0.03416938f, 0.03238663f, -0.01184533f, 0.24587493f, 0.01989052f, 
    0.10847848f, -0.06121268f, -0.07775459f, -0.62305439f, 0.05671800f, 0.04206783f, 0.06264556f, 0.13759078f, 
    0.11632673f, -0.27285293f, -0.23350675f, -0.28042153f, 0.09133776f, -0.38365209f, -0.07921254f, 0.10497553f, 
    0.10851088f, 0.11545939f, 0.11618005f, -0.14409629f, 0.05344058f, 0.12099639f, 0.04541384f, 0.13604917f, 
    -0.00291199f, -0.16883533f, 0.11345806f, 0.25614309f, 0.25905547f, 0.22430257f, 0.12138022f, -0.08669361f, 
    0.14433335f, -0.26776305f, -0.00632647f, 0.12230072f, -0.09439615f, -0.04357963f, -0.09864621f, -0.04062626f, 
    0.14824688f, 0.04855802f, 0.03867881f, -0.12212262f, 0.04418898f, 0.37328199f, 0.08603140f, 0.25377026f, 
    0.11538668f, 0.06615889f, -0.04087546f, 0.04310953f, -0.00059873f, -0.02184498f, -0.02039476f, -0.33012143f, 
    0.10407771f, 0.15160027f, 0.26274803f, 0.06270464f, -0.06973621f, -0.00492181f, -0.10602009f, 0.19750316f, 
    0.07685498f, 0.12227189f, 0.04665680f, -0.08843765f, -0.13604058f, 0.16185959f, -0.16057417f, -0.09426670f, 
    0.21226063f, -0.43816471f, 0.05646000f, 0.11293274f, 0.07030394f, 0.01085493f, 0.05682648f, 0.13656901f, 
    -0.04463109f, -0.27373657f, -0.00198451f, -0.08955175f, 0.15516964f, -0.12580147f, -0.18372445f, 0.06959756f, 
    0.11005276f, 0.03513531f, 0.00926350f, -0.20752966f, -0.42334649f, -0.11826628f, -0.16630881f, 0.06968036f, 
    -0.10987204f, -0.18688285f, 0.04295648f, 0.07322276f, -0.14568971f, 0.05176669f, 0.01498065f, -0.11411413f, 
    -0.17694844f, 0.04537774f, -0.03419986f, -0.16464092f, 0.43138716f, 0.21629326f, -0.23983160f, -0.29840419f, 
    0.00583473f, 0.04064254f, 0.26126921f, -0.19635747f, -0.05260850f, -0.21772647f, -0.17862932f, -0.19375499f, 
    0.01163928f, -0.02281968f, -0.04333782f, 0.05165241f, -0.12234253f, 0.05367872f, 0.12717989f, 0.00514964f, 
    -0.36456123f, -0.19127811f, 0.02920816f, 0.21083207f, 0.15978292f, 0.13343577f, 0.03130083f, -0.32150272f, 
    0.31289434f, -0.08215906f, -0.26432082f, 0.19111767f, -0.07713436f, 0.05006173f, 0.08881174f, -0.14512430f, 
    0.00180636f, 0.09704330f, 0.13129096f, 0.17697854f, 0.10205969f, -0.02078357f, 0.15854822f, 0.01619105f, 
    0.07141846f, -0.04431690f, 0.11910046f, 0.02065019f, 0.09633174f, 0.02275510f, -0.03227281f, 0.24094863f, 
    0.09432372f, -0.10025915f, 0.00089188f, 0.07482628f, 0.31703049f, -0.23096390f, 0.07100035f, -0.06323346f, 
    -0.22725447f, -0.00147143f, 0.21199146f, -0.06817165f, 0.18029997f, 0.05448283f, -0.19515841f, -0.03395700f, 
    -0.00006547f, -0.13488241f, 0.36197942f, 0.12335718f, -0.21699628f, 0.15934713f, -0.01898306f, -0.44576395f, 
    0.10023725f, 0.05514168f, 0.08417567f, 0.11626919f, -0.18363571f, -0.13164951f, -0.56853539f, -0.44909260f, 
    -0.15765451f, -0.11028291f, 0.08311117f, -0.06557543f, 0.14680180f, 0.28239226f, -0.19248785f, -0.21564734f, 
    -0.32492340f, -0.21483366f, 0.00989789f, 0.09183478f, -0.05217303f, -0.29235724f, 0.10190845f, 0.11654617f, 
    -0.57321632f, 0.15894413f, 0.06794166f, -0.24344294f, 0.01921221f, 0.06702219f, 0.04773203f, 0.06436209f, 
    0.10335193f, -0.06668878f, 0.10448025f, 0.14458495f, 0.10318028f, -0.00247660f, -0.19471094f, -0.15016048f, 
    -0.03205626f, -0.06110918f, -0.08934854f, 0.03482365f, -0.02764505f, -0.16895375f, -0.02442044f, 0.02273999f, 
    0.39325121f, -0.03654339f, 0.13718262f, 0.12645969f, -0.21369542f, -0.41804606f, 0.13388307f, 0.06631322f, 
    0.02694692f, -0.03678829f, 0.02943583f, -0.06024037f, -0.41384467f, 0.28758842f, 0.09666370f, 0.05351182f, 
    0.08518608f, -0.00890540f, -0.09049619f, -0.02344162f, -0.02385332f, 0.15995550f, 0.14137955f, -0.05628843f, 
    -0.03612027f, -0.02914887f, 0.17285523f, 0.05849719f, 0.00729656f, -0.02378232f, -0.25377050f, -0.50688064f, 
    -0.15356067f, -0.11524008f, -0.04529264f, -0.23530288f, 0.11189765f, 0.10047868f, -0.18887790f, 0.00244927f, 
    0.10272865f, 0.08027506f, -0.00662171f, 0.04198984f, 0.14628078f, 0.12489938f, 0.17896666f, -0.02599447f, 
    0.01717519f, 0.03203482f, -0.03845098f, 0.13705762f, 0.00430146f, -0.02280304f, 0.13889332f, -0.05786485f, 
    -0.13996631f, -0.07870886f, -0.17166008f, -0.46278405f, -0.25974223f, 0.16896887f, 0.17344035f, 0.21644682f, 
    -0.00477042f, -0.18874021f, -0.25280765f, -0.18723203f, 0.06679635f, -0.05393890f, 0.06606285f, 0.05596348f, 
    0.04863181f, -0.09699327f, -0.04962486f, 0.24545853f, 0.18038478f, 0.11936144f, 0.01772044f, 0.10447895f, 
    0.17737748f, -0.05115079f, -0.01003139f, -0.10324423f, 0.12744904f, -0.00935685f, 0.05438452f, -0.11514176f, 
    0.18193185f, 0.09575742f, -0.02434118f, -0.17713155f, -0.25545144f, -0.02244048f, 0.25550988f, -0.00948350f, 
    0.17453177f, -0.06639796f, 0.22729649f, 0.16075771f, -0.17710935f, 0.16829512f, -0.11855654f, 0.30106416f, 
    -0.00240015f, 0.09543760f, -0.05244959f, 0.12673801f, 0.13898310f, -0.11701234f, -0.04429362f, 0.05965042f, 
    -0.01539876f, -0.00352048f, 0.05162499f, 0.14894792f, 0.13408397f, 0.15721212f, -0.01788326f, 0.04393222f, 
    0.14839356f, 0.33360082f, 0.04588437f, -0.31976393f, 0.05302016f, 0.13081281f, -0.27052543f, 0.17993957f, 
    0.19428648f, 0.44024292f, -0.02533782f, 0.11654963f, -0.09970655f, -0.04789815f, 0.21656404f, -0.24948154f, 
    0.04449721f, -0.21850193f, -0.31641170f, 0.12374843f, 0.34354818f, -0.10004993f, 0.19817184f, 0.12753923f, 
    -0.16965546f, 0.19548650f, 0.04119371f, -0.13602379f, -0.11667028f, 0.07044785f, 0.09318538f, 0.07388177f, 
    -0.19499108f, 0.20961273f, -0.07908203f, 0.23899962f, 0.32829762f, 0.26389721f, 0.13307427f, -0.13297932f, 
    -0.05659143f, 0.08692885f, 0.11449347f, 0.19797893f, 0.10596313f, 0.04699531f, -0.03307424f, -0.63311434f, 
    0.21503431f, 0.15319651f, 0.24302554f, -0.11274372f, 0.05124969f, -0.13447843f, 0.24578336f, 0.02184580f, 
    0.03078402f, -0.37039846f, -0.01088668f, 0.01897644f, -0.36511824f, 0.03376807f, 0.18579736f, 0.15791208f, 
    -0.20409393f, -0.24054836f, -0.04281557f, 0.18469130f, 0.04682795f, 0.09395187f, -0.03929656f, -0.15664169f, 
    -0.32222986f, -0.36739007f, -0.20422143f, -0.04441356f, 0.15072183f, 0.15140773f, 0.11507414f, -0.12299799f, 
    -0.15642843f, -0.17417046f, 0.25683478f, 0.29330236f, 0.04864747f, 0.19697954f, 0.15864389f, 0.17704606f, 
    0.16748859f, -0.01237862f, 0.00094716f, 0.20266737f, 0.25255969f, -0.13056214f, 0.11541717f, 0.00632385f, 
    -0.02671166f, 0.06455997f, 0.16001615f, 0.10030853f, 0.07859826f, -0.02363153f, 0.07401752f, 0.02538118f, 
    -0.02250130f, 0.00825929f, 0.15595883f, -0.22767517f, 0.14897816f, 0.32098076f, -0.23397286f, 0.18232185f, 
    -0.16226320f, 0.00198149f, 0.15195514f, 0.17710951f, -0.16361363f, -0.31796828f, 0.13014346f, -0.28145790f, 
    0.27057442f, 0.22471842f, 0.13705093f, 0.17726451f, 0.09236046f, -0.15285678f, -0.21095546f, 0.26852092f, 
    -0.17402396f, -0.06250305f, -0.04599528f, -0.15717192f, -0.08384836f, 0.03501446f, 0.00754779f, -0.51093388f, 
    -0.10621649f, 0.00035296f, 0.31436014f, 0.05645492f, 0.09494805f, -0.02909114f, 0.23418482f, 0.12644607f, 
    -0.23353027f, -0.05502109f, -0.36595401f, 0.03395815f, -0.00620727f, -0.14933383f, -0.07958996f, -0.04281719f, 
    0.05029670f, -0.22171964f, -0.05742291f, -0.20620057f, -0.05646397f, -0.12268750f, 0.13138555f, -0.10908207f, 
    0.06899264f, -0.08461139f, 0.04294831f, -0.00118760f, 0.07630062f, 0.01682727f, 0.21870206f, -0.01786057f, 
    0.14766908f, -0.18305716f, 0.11216432f, -0.54349005f, -0.35197493f, -0.40768448f, 0.21488211f, 0.04256295f, 
    0.01912532f, 0.19595252f, 0.02937707f, -0.09698304f, -0.13413808f, -0.45118293f, 0.42721713f, -0.17426758f, 
    -0.16100666f, 0.08718479f, 0.19689943f, -0.15553622f, -0.08203049f, 0.07325439f, 0.31560239f, 0.08063681f, 
    -0.14128481f, 0.05821586f, -0.00398550f, -0.09013557f, 0.09865844f, 0.04236172f, 0.04469677f, -0.01498682f, 
    -0.08169597f, -0.00417931f, -0.24827236f, -0.21290411f, -0.15923037f, -0.13640307f, 0.09481015f, -0.01918146f, 
    0.23540573f, 0.03288950f, 0.15539774f, 0.03205155f, 0.04467180f, 0.12389304f, 0.21206656f, 0.08736086f, 
    -0.24333581f, -0.11420195f, 0.20651402f, -0.04965635f, 0.15358537f, -0.25494412f, -0.00507766f, 0.32394236f, 
    -0.11631491f, 0.01467279f, -0.29445398f, -0.12121583f, 0.06373920f, 0.23738505f, -0.25332528f, -0.04531647f, 
    -0.09648783f, 0.07125925f, -0.26178384f, -0.02077230f, 0.11390103f, -0.17465164f, -0.02806605f, -0.09524917f, 
    -0.04811799f, 0.07613937f, -0.22713117f, 0.06015008f, 0.26665288f, 0.20838389f, 0.03931037f, -0.00641045f, 
    0.15901846f, -0.13372983f, 0.08407965f, 0.11607907f, -0.08419028f, -0.23765768f, 0.02092195f, 0.02306658f, 
    0.04377231f, 0.10976526f, -0.12153909f, -0.05981279f, 0.00195082f, -0.30131859f, 0.38643104f, 0.36662298f, 
    0.16847162f, 0.05807432f, 0.12551318f, 0.17803270f, -0.13956277f, 0.21013443f, 0.40223902f, -0.16793117f, 
    0.09610303f, 0.03726092f, -0.00831035f, 0.13888533f, 0.17303972f, -0.21604705f, -0.03502172f, -0.13106674f, 
    0.02912586f, 0.11533587f, 0.11376396f, 0.04067769f, -0.05604791f, -0.20224567f, -0.00185665f, 0.17534448f, 
    0.00564094f, 0.03036566f, -0.01749732f, 0.02267189f, 0.00842922f, -0.06787915f, -0.04281877f, -0.03713676f, 
    -0.02872500f, 0.04223277f, -0.01513808f, -0.07000323f, 0.00526538f, 0.03518941f, 0.00673410f, 0.00226682f, 
    -0.02567406f, 0.01820272f, 0.01147268f, 0.01340726f, -0.01170836f, -0.03357806f, -0.03793506f, -0.00739518f, 
    -0.04255908f, -0.00282965f, 0.04232518f, -0.06663424f, -0.04271824f, -0.01156806f, -0.04850141f, 0.01869760f, 
    0.04944150f, -0.02168068f, -0.00841718f, -0.01438127f, -0.01127183f, 0.03205356f, -0.05518382f, -0.04524067f, 
    -0.05868855f, -0.05578332f, 0.03924478f, -0.04624223f, -0.03236188f, -0.04863105f, -0.00259342f, 0.00946641f, 
    -0.00149426f, 0.01099792f, -0.04648814f, -0.05566605f, 0.00520368f, -0.03025317f, 0.03643357f, -0.05080507f, 
    0.02123397f, -0.00214618f, 0.01659684f, -0.02862355f, -0.04791444f, -0.00208656f, -0.00121834f, 0.03224355f, 
    -0.04893927f, -0.03733736f, 0.01707174f, 0.02976117f, 0.03208852f, -0.03677113f, 0.02983488f, 0.02934600f, 
    -0.06362293f, 0.04349360f, -0.05525417f, 0.02543549f, -0.03095378f, 0.00134842f, -0.04975804f, -0.01050391f, 
    0.03018604f, -0.04480770f, -0.01860366f, -0.03093537f, -0.00428424f, -0.00652798f, 0.01710112f, -0.04277314f, 
    -0.01284828f, -0.03339007f, -0.01371617f, 0.03119556f, -0.00568920f, -0.01607601f, -0.03502931f, 0.03158671f, 
    -0.01332267f, -0.06636784f, 0.01915722f, 0.00126618f, -0.02282147f, -0.02123718f, -0.06894507f, 0.01955149f, 
    -0.02086578f, -0.00965100f, -0.03058021f, -0.05275149f, 0.04784487f, 0.05024474f, 0.02114102f, 0.02300595f, 
    0.03303638f, 0.01855609f, 0.00887600f, -0.04195514f, 0.00196774f, -0.03843432f, 0.00812250f, -0.00790554f, 
    0.00780496f, -0.03239404f, 0.01464968f, 0.03382480f, -0.04856184f, -0.00510075f, 0.02917859f, 0.03243189f, 
    -0.03946349f, -0.03290847f, 0.03500289f, -0.00930904f, 0.04697612f, -0.04659289f, -0.01008674f, 0.03661588f, 
    -0.00635679f, -0.05260563f, -0.05239619f, -0.02016636f, 0.04370958f, 0.00489005f, 0.01690269f, 0.03985510f, 
    0.00709534f, -0.00789759f, 0.02859548f, 0.01821072f, 0.01400987f, -0.06242092f, 0.03032191f, -0.01016924f, 
    0.03659440f, 0.03573623f, -0.06131174f, -0.00619823f, -0.05897273f, 0.03537156f, -0.05489272f, 0.00295841f, 
    0.00546860f, 0.02837271f, -0.05567506f, -0.03039403f, -0.00912523f, 0.01737127f, -0.00115802f, -0.01338323f, 
    0.00221724f, -0.00114998f, 0.04415075f, 0.03792517f, 0.04012874f, -0.05236770f, 0.00975703f, 0.03474239f, 
    0.00084896f, -0.01681101f, 0.02763303f, -0.06368084f, -0.01085517f, -0.05201589f, -0.03811636f, -0.05174486f, 
    -0.03696691f, 0.04380446f, 0.00096556f, 0.00735819f, 0.04277601f, 0.03812599f, 0.00982805f, -0.04286084f, 
    -0.04215731f, 0.02044307f, -0.04785113f, -0.04164324f, -0.02562445f, 0.00341177f, 0.02997139f, -0.02045486f, 
    0.03470914f, -0.00204778f, 0.02589962f, 0.02047942f, -0.03823294f, -0.00085780f, 0.02426090f, -0.04556939f, 
    -0.03515838f, -0.00577388f, 0.04204215f, 0.04372247f, 0.00153986f, -0.02646076f, 0.04405972f, -0.05029375f, 
    -0.02144757f, -0.05786964f, -0.06063353f, -0.02492132f, -0.06493309f, 0.04184562f, -0.04803592f, 0.00975658f, 
    -0.03859986f, 0.04535603f, 0.00923627f, -0.04115683f, -0.04302267f, 0.01946286f, -0.03436409f, 0.04315584f, 
    0.03612842f, 0.00535510f, 0.01369378f, 0.00806744f, 0.00870989f, -0.05051895f, 0.02716343f, 0.04207745f, 
    -0.01584110f, 0.04433936f, 0.04854549f, 0.02866143f, 0.00892548f, -0.04116964f, -0.04507431f, 0.00819434f, 
    -0.02283589f, -0.06401664f, 0.02271013f, -0.03228334f, -0.05845208f, -0.01846830f, 0.00910342f, -0.06407505f, 
    -0.00393613f, -0.03957443f, -0.05205544f, 0.03915515f, 0.00329659f, 0.04001930f, -0.00612412f, 0.00366639f, 
    0.04467764f, -0.02054033f, -0.02395339f, -0.06155653f, -0.03868721f, 0.01614908f, 0.02155746f, 0.04979630f, 
    0.04347727f, -0.00201275f, -0.03059938f, -0.05635802f, -0.04026469f, -0.04851824f, -0.06078096f, -0.03419773f, 
    -0.05822653f, 0.03437860f, -0.02988336f, 0.00638482f, 0.01169901f, 0.04426013f, 0.04082220f, 0.01881112f, 
    0.04916338f, 0.00185963f, -0.01552718f, -0.03492573f, -0.00380075f, 0.05212150f, 0.04299970f, -0.01054079f, 
    -0.05319932f, -0.01999900f, -0.05052556f, 0.05077600f, -0.03182437f, -0.01803097f, 0.02690645f, 0.04851554f, 
    -0.02229124f, -0.02685402f, -0.02008879f, -0.02866605f, 0.01305470f, -0.04465612f, -0.02857888f, -0.04977114f, 
    -0.06285942f, -0.01483265f, 0.00749136f, -0.04002677f, 0.04467424f, -0.00366890f, 0.03865445f, 0.01343712f, 
    0.04248918f, -0.04620314f, 0.01031320f, 0.04144885f, 0.04313892f, -0.01848117f, -0.01666267f, 0.02402530f, 
    -0.02124110f, 0.00623974f, 0.01421308f, -0.00788847f, -0.02975956f, -0.01437609f, 0.02667641f, -0.02132425f, 
    -0.05626031f, 0.02208456f, -0.00453511f, 0.01292847f, 0.04181091f, 0.04947328f, 0.00521361f, -0.02710851f, 
    -0.03370276f, 0.05518549f, -0.00888871f, 0.05121304f, 0.04203947f, -0.01595418f, 0.04976309f, 0.04153538f, 
    -0.06491617f, -0.02672847f, -0.04576056f, 0.02642436f, 0.00853939f, -0.04903604f, 0.00821083f, -0.04921262f, 
    -0.01208749f, -0.05145730f, -0.02864218f, 0.00548669f, -0.00010888f, 0.01205425f, -0.00585473f, -0.04392557f, 
    0.04909316f, -0.00054763f, -0.05635810f, -0.01907269f, -0.01013010f, -0.01704433f, 0.04771979f, -0.03782403f, 
    -0.03033347f, -0.05654540f, -0.03780340f, -0.05897597f, -0.00699337f, -0.01357523f, 0.01857429f, -0.02591493f, 
    -0.04768611f, 0.04012003f, 0.02590353f, 0.04222385f, -0.03796694f, -0.03531649f, 0.03623503f, 0.03040528f, 
    -0.01056544f, 0.05014795f, 0.00656155f, 0.00896509f, 0.05256468f, -0.05666012f, 0.05775699f, -0.06294445f, 
    0.00188310f, -0.01377611f, 0.01144336f, -0.06066733f, -0.05358992f, 0.04152416f, -0.04822379f, -0.00829666f, 
    0.03784254f, 0.02184126f, -0.00356980f, 0.02068545f, -0.00605523f, -0.01399512f, 0.02953923f, -0.01356421f, 
    0.03249827f, -0.04024223f, 0.00698498f, 0.01352451f, -0.00227411f, -0.02573576f, 0.00781064f, -0.04096750f, 
    -0.01993827f, 0.03202485f, -0.01454456f, -0.04945890f, -0.03610834f, -0.02552043f, -0.00787478f, -0.05032326f, 
    -0.05512565f, -0.01065537f, -0.00117520f, 0.05175615f, 0.04192733f, 0.05016540f, -0.01619185f, -0.05223252f, 
    0.04799018f, -0.06108366f, -0.06342770f, -0.05142955f, -0.03434040f, -0.04491961f, -0.00444536f, 0.03701930f, 
    -0.06052038f, -0.06081022f, -0.04507935f, -0.03827047f, -0.02100231f, 0.04280110f, -0.03168644f, 0.03574064f, 
    0.04010622f, -0.00153871f, 0.02487011f, 0.04498069f, -0.03416257f, 0.01186258f, 0.01868222f, 0.01749007f, 
    0.04926256f, -0.06484118f, 0.00841007f, -0.05650843f, -0.04760414f, -0.00449544f, -0.03832713f, 0.04263609f, 
    -0.05604087f, -0.03329749f, 0.01154789f, 0.02864897f, -0.05873748f, 0.02517022f, 0.04204735f, -0.02430119f, 
    0.00837938f, 0.04747057f, 0.00845022f, -0.00774611f, -0.02129220f, 0.02356602f, 0.03651272f, -0.03665959f, 
    -0.01649599f, -0.05437818f, -0.00931419f, -0.04049302f, 0.04447356f, -0.03109055f, -0.04309519f, -0.06232904f, 
    -0.05148418f, -0.01675053f, -0.02333454f, -0.03730015f, -0.02494968f, 0.04344527f, -0.05941577f, -0.02113006f, 
    -0.02254512f, -0.04887483f, -0.00554096f, 0.00940721f, -0.05760882f, -0.06201601f, -0.01390836f, -0.05251676f, 
    0.03843730f, 0.03503869f, -0.00798434f, -0.02271749f, -0.03856447f, -0.02735978f, -0.03758951f, -0.05657762f, 
    -0.00090811f, 0.05125010f, -0.03607982f, 0.02735393f, -0.06183332f, 0.04054875f, -0.01919469f, 0.00199220f, 
    -0.06412174f, -0.01739650f, -0.05307243f, 0.00843021f, 0.03013252f, 0.01950639f, 0.01072418f, -0.01018106f, 
    -0.01470451f, 0.02746407f, 0.05023365f, 0.01403146f, -0.04046519f, 0.03049954f, -0.02498006f, -0.04689747f, 
    -0.00206667f, 0.04081367f, -0.03988898f, 0.04804344f, -0.00796598f, -0.01877298f, 0.00812610f, -0.01882564f, 
    -0.03768821f, 0.04557366f, 0.03380474f, -0.04852976f, -0.05913352f, -0.06299581f, -0.02830234f, -0.00002410f, 
    0.05150797f, 0.02545883f, 0.00025658f, -0.04767698f, -0.01942290f, -0.03244523f, 0.01813595f, 0.01081560f, 
    -0.03967772f, 0.02956187f, -0.05817398f, 0.05112260f, -0.02807900f, -0.01563093f, -0.05692230f, -0.05931016f, 
    0.00864295f, -0.02713950f, 0.03163852f, -0.03655759f, 0.01857840f, 0.02256440f, -0.02712672f, -0.03367531f, 
    -0.00344813f, 0.00352035f, 0.04506831f, 0.01058907f, -0.00842684f, -0.00803139f, -0.04038327f, 0.02217332f, 
    -0.00312789f, -0.03930662f, 0.02222472f, 0.01338949f, 0.00774741f, -0.03443640f, 0.02968683f, -0.01839945f, 
    -0.04654020f, 0.03852899f, -0.01934103f, 0.04058455f, 0.02147451f, -0.05910099f, 0.02173332f, 0.01252349f, 
    0.00891308f, 0.04022313f, -0.03426655f, 0.03712158f, 0.04151760f, 0.00114315f, -0.06289726f, -0.05101706f, 
    0.02547885f, -0.02218953f, -0.02763712f, 0.02979453f, 0.03189681f, -0.04051986f, -0.03926599f, 0.00183967f, 
    -0.01765412f, 0.00043981f, 0.00624923f, 0.02290437f, 0.05172975f, -0.05020183f, -0.04864961f, -0.02232452f, 
    0.04730866f, -0.06442907f, 0.00884966f, -0.04062920f, -0.03646240f, 0.04884097f, -0.01346638f, 0.00260061f, 
    0.01099934f, -0.00675235f, -0.03578237f, -0.03058182f, 0.00468379f, 0.04201585f, -0.03632800f, 0.05011682f, 
    -0.04818634f, -0.06323215f, -0.01808902f, -0.03947833f, -0.03226232f, -0.02856997f, -0.04753824f, 0.04177782f, 
    0.00337160f, -0.00998108f, 0.01240190f, 0.00749525f, -0.04219144f, 0.00585959f, -0.01054621f, -0.01074925f, 
    -0.00674655f, -0.03883303f, -0.05761493f, 0.01017473f, -0.01945786f, -0.04464389f, -0.02180899f, 0.00079739f, 
    -0.01955562f, -0.02776320f, 0.00745649f, -0.00185788f, 0.01261367f, -0.03455925f, -0.05890943f, 0.00461112f, 
    -0.04097881f, -0.03745575f, 0.00311729f, -0.01173184f, 0.02215324f, 0.04471229f, -0.00340620f, -0.01358715f, 
    0.03103039f, 0.00631617f, 0.02897578f, -0.02429715f, 0.03356662f, 0.00005000f, -0.03506444f, -0.05400786f, 
    -0.01172986f, 0.00494199f, 0.04437377f, 0.04053601f, 0.01008107f, -0.03958426f, -0.00170373f, 0.01080250f, 
    -0.05762203f, 0.00100732f, 0.02930040f, -0.06485586f, -0.05727338f, -0.00462666f, -0.03921612f, -0.02325048f, 
    -0.04095931f, -0.05778119f, -0.05340867f, -0.03330257f, -0.05793022f, 0.01306384f, -0.02722314f, 0.02798226f, 
    0.02099005f, 0.02792426f, -0.05518534f, 0.04450700f, -0.04096158f, -0.01403292f, 0.00265166f, -0.02065725f, 
    -0.00942860f, -0.04590341f, 0.02260615f, -0.03226734f, 0.00002234f, -0.03682447f, -0.00846126f, -0.04822512f, 
    0.02963842f, 0.02040983f, 0.01949007f, 0.00200010f, -0.04285652f, 0.04890457f, -0.02731399f, 0.03582620f, 
    -0.03293036f, -0.05998075f, -0.03017354f, 0.03644200f, -0.06076787f, -0.03318963f, -0.03770230f, 0.02025679f, 
    0.02181276f, 0.04712042f, -0.06317447f, -0.04258295f, -0.05998158f, 0.05158915f, 0.00839009f, -0.03785576f, 
    0.04963664f, 0.01983878f, 0.03610691f, -0.05295167f, -0.05540828f, -0.02739201f, 0.03847641f, 0.02053550f, 
    -0.01207709f, -0.06167095f, -0.00942198f, -0.05851466f, -0.01283357f, -0.00808655f, 0.02505964f, -0.04940407f, 
    0.04959642f, 0.01723970f, 0.01237926f, -0.05127975f, 0.03519255f, 0.01158618f, -0.04609621f, -0.00796852f, 
    0.02352787f, 0.04703978f, -0.06411812f, -0.02480145f, 0.02110634f, -0.01137761f, 0.00476418f, -0.03903525f, 
    0.00143443f, 0.00023649f, 0.02819805f, 0.05158565f, -0.03649184f, -0.03218718f, 0.00034493f, -0.05631370f, 
    0.01078171f, 0.01842407f, 0.04451310f, 0.04868244f, -0.06126172f, -0.06078657f, -0.04724447f, -0.00325914f, 
    0.04425258f, -0.05651541f, -0.04683147f, -0.02781164f, -0.05521702f, -0.00157798f, -0.06210208f, -0.04003362f, 
    -0.01577407f, -0.00232847f, -0.04769237f, -0.05598049f, 0.05155037f, -0.03163639f, -0.03186309f, 0.04164897f, 
    -0.02748616f, -0.03746736f, 0.04226238f, -0.01569890f, 0.01627086f, -0.04195591f, 0.02530259f, -0.00912320f, 
    0.04006037f, -0.02853541f, -0.01386271f, -0.00661478f, -0.03323767f, 0.02097574f, -0.06048568f, -0.01822854f, 
    -0.02998375f, -0.06043816f, -0.03370271f, -0.00162734f, 0.04241778f, 0.00586005f, -0.01615683f, -0.01384618f, 
    -0.06517233f, -0.01216784f, -0.01050540f, -0.01144485f, -0.05266361f, -0.00644214f, 0.02619669f, -0.00241119f, 
    -0.00626453f, -0.06261402f, -0.00227568f, -0.06301650f, -0.01901459f, -0.04290134f, -0.04285740f, 0.02195239f, 
    0.02242753f, -0.02727460f, 0.21618670f, -0.13295487f, 0.04856652f, -0.03479089f, 0.05446561f, -0.10639335f, 
    0.21950287f, -1.03481901f, 0.04407898f, -0.19279362f, 0.25505102f, -0.06992415f, 0.15589425f, 0.05249678f, 
    0.01261604f, 0.06689419f, 0.25786585f, -0.37496915f, 0.08329041f, -0.10692105f, 0.06759158f, 0.02808951f, 
    0.06853475f, -0.16752507f, 0.02192097f, 0.00569637f, -0.12106716f, 0.12762591f, -0.20428681f, 0.08266803f, 
    0.23411332f, -0.03645465f, -0.03561546f, -0.00021817f, -0.01588046f, -0.20721149f, 0.14471768f, -0.07903694f, 
    -0.04676994f, -0.08122210f, 0.02688763f, -0.00746980f, -0.08353234f, -0.41647974f, 0.30181369f, -0.24886636f, 
    0.06646612f, 0.02136468f, -0.07474296f, -0.20861422f, 0.11575401f, 0.10856153f, 0.01974893f, -0.03818225f, 
    0.07616322f, 0.05412395f, -0.17541236f, 0.06167854f, -0.09515055f, 0.06012721f, -0.01798299f, -0.28515911f, 
    -0.03851421f, 0.09750693f, 0.03723118f, 0.17927539f, 0.13193725f, -0.16326566f, -0.15190968f, -0.11943027f, 
    -0.52168351f, -0.00711441f, -0.31873015f, 0.06395702f, 0.20485529f, -0.01225148f, 0.03400866f, -0.03281990f, 
    0.26456779f, 0.01441496f, -0.04581719f, 0.36263809f, 0.17166567f, 0.15240246f, -0.01659951f, 0.20969993f, 
    0.05306668f, 0.20982148f, -0.09873828f, 0.00784310f, 0.42180613f, -0.17891558f, 0.21184714f, -0.13978657f, 
    0.08837201f, -0.04221374f, 0.08820461f, 0.26821584f, 0.25120997f, 0.04617535f, 0.15834542f, 0.07864926f, 
    0.07433242f, 0.02832064f, -0.09171806f, 0.12880728f, -0.04112436f, -0.16986547f, -0.07758167f, -0.09100409f, 
    0.12559178f, -0.14020118f, 0.03114795f, -0.03065385f, 0.07256052f, 0.05651084f, -0.07346405f, -0.31677034f, 
    0.02979447f, -0.14803529f, -0.01752086f, -0.03927993f, 0.14059076f, 0.12406146f, 0.15291727f, 0.24606970f, 
    -0.03115918f, 0.05358608f, -0.02538960f, -0.05529589f, 0.06061048f, -0.09214764f, -0.02213610f, -0.00829802f, 
    -0.04691575f, -0.20260182f, 0.18202503f, 0.06468986f, 0.00336041f, 0.11969898f, -0.01705467f, -0.04669251f, 
    -0.19666809f, -0.47495776f, 0.11866745f, 0.07279284f, 0.13861430f, -0.07234760f, -0.09316894f, 0.00624535f, 
    0.11302082f, 0.04015709f, -0.26422757f, -0.15621325f, 0.12279029f, 0.12276766f, -0.06089206f, -0.26595971f, 
    -0.04856510f, -0.17781970f, 0.04472828f, -0.08492570f, -0.04759492f, -0.06953358f, 0.01300910f, 0.04863048f, 
    -0.00932297f, -0.13171390f, -0.05661669f, -0.17274645f, 0.21903270f, -0.27235854f, -0.07910881f, 0.16095597f, 
    -0.06225128f, 0.21106941f, 0.21711193f, -0.09659034f, -0.02163470f, 0.19129628f, -0.11275503f, 0.13843276f, 
    0.02401562f, 0.16865000f, 0.01443183f, 0.06055105f, -0.04060215f, 0.10159746f, 0.01479414f, 0.31515521f, 
    0.06401549f, 0.15575291f, -0.11760566f, -0.01624494f, -0.10254625f, 0.07307565f, -0.05359480f, -0.30287716f, 
    -0.35210964f, -0.17207539f, -0.06322274f, -0.04967831f, -0.22560070f, 0.06123582f, 0.05005417f, 0.34446928f, 
    0.17410803f, 0.22614665f, 0.05248150f, 0.20060097f, -0.06234368f, 0.30441403f, -0.06046196f, 0.08380478f, 
    -0.12898111f, -0.15022396f, 0.00474675f, 0.05291118f, -0.01937959f, 0.19568256f, 0.06128014f, 0.01185003f, 
    -0.02961099f, -0.11619453f, 0.36216760f, 0.01890614f, 0.10303848f, 0.03066574f, 0.06787257f, -0.11362054f, 
    0.02712479f, -0.15558822f, -0.20241673f, -0.11801973f, -0.31502065f, 0.09948590f, 0.09489288f, -0.14275633f, 
    -0.26604936f, -0.07169627f, -0.10479451f, -0.22052355f, 0.04379624f, 0.38272604f, 0.02868920f, 0.03570979f, 
    0.01620576f, 0.08672896f, -0.03389169f, -0.12040362f, -0.40528622f, -0.15520455f, -0.12523691f, 0.12087326f, 
    0.06504090f, -0.13492794f, -0.02954106f, 0.02073236f, 0.13272019f, -0.02328050f, -0.04475627f, 0.29430929f, 
    0.21509618f, -0.08718594f, 0.06593737f, 0.00610407f, 0.01709980f, 0.04614493f, -0.24331774f, -0.02671036f, 
    -0.09457338f, -0.02683879f, -0.21798500f, -0.01716596f, 0.15652390f, 0.00489484f, -0.02755152f, -0.27884281f, 
    0.00855832f, -0.00419184f, 0.08362319f, 0.25076374f, -0.39995107f, 0.19864564f, 0.05029193f, 0.24239503f, 
    0.02033642f, -0.06140928f, 0.02377535f, 0.00863340f, 0.04976871f, 0.02350651f, -0.04038700f, -0.06033687f, 
    0.03467738f, 0.05326408f, 0.02115918f, 0.04559429f, -0.05125913f, 0.05164332f, -0.05702284f, -0.04678915f, 
    0.04262066f, -0.04365409f, -0.00201210f, 0.04143187f, -0.00175788f, 0.03544397f, -0.03373950f, -0.03060304f, 
    -0.05974668f, -0.06135848f, -0.06017184f, -0.05847450f, -0.03023224f, -0.02543518f, 0.00952317f, 0.04358796f, 
    0.00331560f, -0.04584772f, -0.03721793f, 0.02161009f, 0.00860519f, -0.01488092f, -0.03479077f, 0.00337166f, 
    0.03993434f, -0.04564902f, 0.03411451f, -0.04195365f, -0.00359425f, 0.03572061f, 0.01942961f, -0.02750435f, 
    0.04631011f, -0.01136474f, -0.04916825f, -0.01350551f, -0.02753365f, -0.01472628f, 0.04010760f, -0.02118050f, 
    0.01980017f, -0.04488577f, 0.01480838f, -0.01442945f, 0.01880138f, 0.04087819f, -0.05668906f, 0.00137736f, 
    0.00661814f, 0.03878263f, 0.03868032f, -0.01324704f, 0.04863119f, 0.03119488f, -0.01777245f, -0.00279938f, 
    0.04303330f, -0.01615307f, 0.03187045f, -0.02778053f, 0.04041768f, 0.04475458f, -0.00730293f, 0.03368611f, 
    -0.02358892f, 0.00704751f, -0.04792654f, -0.05595297f, -0.03368086f, 0.03757041f, 0.02205694f, 0.02514249f, 
    -0.06474768f, -0.05721103f, -0.03046767f, -0.00485539f, 0.03340742f, -0.01561876f, -0.05076941f, -0.06321496f, 
    -0.04790567f, -0.01991547f, -0.00678041f, 0.04391363f, -0.04017181f, -0.01522055f, -0.01772587f, -0.00101647f, 
    0.04050125f, -0.01761152f, -0.06507891f, 0.01956952f, -0.02870944f, 0.01425579f, -0.01289029f, 0.04650224f, 
    0.00593310f, -0.03893456f, 0.04030177f, 0.04522610f, 0.02639753f, 0.01954599f, -0.00841555f, 0.01887213f, 
    0.04165057f, -0.00632261f, -0.00518118f, 0.02992527f, -0.03381383f, -0.00800354f, -0.00204950f, 0.04630290f, 
    0.03918955f, -0.05499794f, 0.04337027f, -0.01760807f, -0.04568859f, -0.03569952f, -0.03485848f, 0.04574581f, 
    0.00522977f, -0.02716671f, -0.06409513f, -0.01749570f, 0.01762332f, -0.03675094f, -0.03100622f, -0.00242173f, 
    0.00424004f, -0.04152931f, 0.04682878f, 0.01658155f, -0.06137566f, -0.05234119f, -0.02413775f, 0.02343596f, 
    0.04932806f, -0.00312170f, -0.02765707f, -0.04598900f, 0.04683422f, 0.03474611f, -0.00191552f, -0.04492378f, 
    0.00645715f, -0.01868121f, -0.00623795f, -0.04846737f, -0.05501776f, -0.05532420f, -0.00608614f, 0.03010819f, 
    -0.03946010f, 0.00087524f, -0.01642571f, -0.02830831f, -0.02262926f, -0.01793319f, 0.01560579f, -0.06085099f, 
    -0.06454434f, 0.03859216f, 0.02562979f, 0.02992565f, 0.04810528f, 0.02343550f, 0.01124663f, -0.05593443f, 
    0.03131853f, 0.02306496f, -0.03436312f, 0.00572709f, -0.00367898f, -0.03410074f, -0.01858132f, -0.02108276f, 
    -0.03076754f, -0.03138774f, -0.05675675f, -0.01723789f, -0.03841711f, -0.06055457f, 0.04637507f, 0.01874140f, 
    -0.01637967f, -0.06487922f, 0.04351382f, 0.02455796f, -0.00073548f, -0.01236665f, 0.00875963f, 0.02841420f, 
    0.00670293f, -0.06243539f, -0.02217582f, 0.02479568f, -0.04712063f, -0.01506606f, -0.01207599f, -0.00586593f, 
    -0.00966758f, 0.03648278f, -0.00398717f, 0.04922784f, 0.00409726f, -0.05246781f, 0.00132351f, -0.04070885f, 
    0.05262925f, 0.00553112f, 0.00920817f, -0.01193022f, 0.03983488f, 0.02323715f, -0.00264700f, -0.04970251f, 
    -0.01772257f, -0.06095504f, -0.01165401f, 0.00570169f, 0.03140104f, 0.04486338f, -0.02313855f, -0.04751495f, 
    0.04488057f, -0.02765004f, 0.03367041f, -0.04359943f, -0.05632797f, -0.01236111f, -0.04932030f, -0.04212609f, 
    0.00918501f, -0.05811003f, 0.04851015f, -0.00138462f, -0.03039167f, -0.06256262f, 0.04884050f, 0.04482115f, 
    0.05023488f, 0.05259687f, -0.04134260f, -0.05496850f, 0.03820735f, -0.05624446f, 0.01834622f, -0.00907879f, 
    0.00475690f, 0.01304844f, -0.02107823f, -0.01793122f, 0.03934678f, -0.00712981f, -0.03371109f, -0.02053328f, 
    0.03767576f, -0.04126833f, 0.03057254f, -0.06195413f, 0.02209970f, 0.00953069f, -0.02307502f, 0.01504119f, 
    0.00208084f, -0.00499773f, 0.02506144f, -0.03285222f, -0.04741619f, -0.03825705f, -0.05416381f, 0.04850099f, 
    -0.04668128f, 0.02043820f, 0.01187092f, 0.04077137f, 0.02535063f, -0.03300212f, 0.04866051f, -0.01445005f, 
    0.05682652f, 0.01438152f, 0.01435431f, -0.05167181f, 0.05393069f, 0.01016343f, -0.04087898f, 0.02785859f, 
    -0.00419316f, 0.03558081f, -0.02121389f, -0.04883231f, 0.03331515f, 0.00337738f, 0.05927437f, -0.03309642f, 
    -0.04224454f, -0.04772554f, -0.03395358f, -0.05718573f, -0.05690773f, -0.05006919f, 0.02210105f, -0.04690784f, 
    -0.04561434f, -0.04752897f, -0.03497575f, 0.04838634f, -0.04226434f, 0.05004719f, -0.06067171f, 0.00277053f, 
    -0.00722584f, 0.01361994f, -0.00133054f, 0.04227922f, -0.01318087f, -0.03683954f, 0.01657439f, 0.04148570f, 
    -0.03947551f, 0.00021441f, 0.05006738f, 0.03658422f, -0.04356123f, 0.02387526f, 0.00823386f, -0.05693421f, 
    0.00360493f, 0.05260655f, 0.00056794f, 0.02790337f, -0.01722968f, -0.04870124f, -0.05762022f, -0.02078466f, 
    -0.03226553f, 0.01605609f, 0.00170742f, -0.05878467f, -0.04499064f, 0.02043272f, -0.00249319f, -0.03323976f, 
    0.03596832f, 0.03594255f, -0.01718564f, 0.02496978f, -0.03398973f, 0.02756719f, -0.06071904f, 0.02718309f, 
    -0.04804100f, -0.05430638f, -0.04056674f, 0.01635952f, 0.02404486f, -0.02589117f, -0.02582070f, 0.04452667f, 
    0.02986587f, 0.00886751f, -0.00598103f, -0.05259919f, -0.06363964f, 0.04838877f, -0.04078838f, 0.00795976f, 
    0.02658181f, -0.05902811f, -0.02742154f, 0.04570284f, -0.00068317f, -0.01166814f, -0.01618837f, -0.05265499f, 
    -0.05669416f, -0.01660155f, -0.05603077f, -0.05733133f, 0.02503890f, -0.05345445f, -0.06418185f, -0.00492412f, 
    0.04818050f, 0.01910362f, -0.00910295f, 0.04428392f, 0.00701651f, 0.05178157f, -0.00501300f, -0.01831810f, 
    -0.01248399f, 0.03719651f, 0.00725021f, 0.01411541f, -0.02320484f, -0.01642845f, -0.03822088f, -0.03162656f, 
    -0.01110153f, 0.02979255f, 0.01055077f, 0.05383262f, -0.05751652f, 0.02444123f, -0.05376856f, -0.04909093f, 
    0.04043202f, 0.04115075f, -0.02015877f, 0.02874304f, 0.05113013f, 0.03142563f, -0.04451027f, 0.01127899f, 
    -0.02960763f, -0.02028267f, 0.02443371f, -0.03486893f, 0.01937607f, 0.03707781f, 0.05708485f, -0.03414233f, 
    0.05646407f, 0.05391400f, 0.00212737f, -0.02124674f, 0.03284647f, -0.05529694f, 0.01139339f, 0.05541944f, 
    -0.00256463f, -0.02936785f, -0.04260277f, -0.04285511f, -0.00587640f, -0.02273706f, 0.01339424f, 0.02878299f, 
    0.02756882f, 0.02783575f, 0.04091655f, -0.01376076f, 0.01341609f, -0.02015589f, -0.01941149f, -0.03670202f, 
    0.02451619f, -0.00664097f, -0.05256573f, 0.00167388f, 0.01244856f, -0.03505132f, 0.05067996f, 0.00582622f, 
    -0.00068104f, -0.05942928f, -0.02911496f, -0.00646116f, 0.01495985f, 0.01679937f, -0.06641648f, -0.06273606f, 
    0.00518142f, 0.05050063f, -0.03238655f, -0.04451649f, 0.00558733f, -0.02067687f, 0.00909355f, 0.03809693f, 
    0.04198068f, -0.05406249f, -0.05396764f, -0.05871797f, -0.02691319f, 0.01266656f, 0.02060178f, 0.05180902f, 
    -0.01127931f, -0.04897862f, -0.03348735f, 0.03144394f, -0.02782000f, -0.04843345f, -0.04594304f, -0.04207311f, 
    -0.04284846f, -0.04622659f, 0.01591310f, -0.06086977f, -0.01895804f, 0.05223735f, -0.02727628f, 0.02995382f, 
    0.02741234f, -0.06983772f, -0.00315642f, -0.03484041f, 0.02832556f, -0.02829949f, 0.05390221f, 0.04941074f, 
    -0.04236326f, 0.02648990f, 0.03982276f, 0.04025334f, 0.02864568f, -0.00128488f, 0.03056686f, -0.04380083f, 
    0.00491372f, -0.01187712f, -0.04791478f, -0.01484248f, -0.04099356f, -0.03204406f, -0.02902100f, -0.00852161f, 
    0.01896912f, -0.03990102f, -0.01598491f, -0.01002906f, 0.03244013f, 0.01205082f, 0.01744939f, -0.00473767f, 
    -0.04624967f, -0.02499051f, -0.04606273f, -0.01149659f, -0.01871212f, 0.05159941f, -0.01629168f, -0.03577669f, 
    -0.04365700f, 0.00942387f, -0.04132280f, -0.02396108f, 0.05710324f, -0.01982303f, 0.04484626f, -0.00611051f, 
    0.02642396f, 0.04907101f, 0.03625742f, -0.04320845f, -0.04065489f, -0.00329211f, -0.03026518f, -0.05647642f, 
    -0.05745310f, 0.01238815f, 0.02309095f, -0.03323859f, -0.04808015f, -0.00737104f, -0.02710719f, 0.03383358f, 
    0.03675435f, 0.28866771f, -0.11253664f, 0.02488362f, 0.04974863f, -0.03844957f, -0.07189430f, 0.02277357f, 
    -0.13887836f, -0.30435485f, 0.25241905f, -0.21622951f, -0.19331777f, 0.18382922f, 0.09246376f, 0.06717309f, 
    -0.13602068f, 0.03572270f, 0.01108436f, 0.02449517f, -0.30839401f, 0.06881446f, 0.02402126f, 0.21047364f, 
    -0.19568677f, 0.19647278f, 0.20254290f, 0.05758576f, -0.14374810f, -0.05609298f, 0.00051133f, 0.04578060f, 
    -0.11792687f, -0.20024137f, 0.05129154f, 0.13915414f, 0.14575125f, 0.20032236f, -0.04163345f, 0.00440097f, 
    0.03026941f, -0.08011918f, -0.12170295f, 0.11220716f, 0.05924528f, 0.26337436f, 0.15394911f, 0.26253203f, 
    -0.18448040f, 0.05054775f, -0.05147354f, 0.02001283f, -0.03250212f, 0.06333765f, 0.06888135f, 0.16061842f, 
    0.09759297f, 0.12171453f, 0.00449664f, -0.07050304f, -0.20831242f, 0.04752513f, 0.05358145f, -0.34352878f, 
    -0.06016608f, -0.15753998f, -0.06144691f, -0.13702634f, -0.03633112f, 0.09265917f, -0.12738040f, 0.12159836f, 
    0.45160317f, -0.00802429f, -0.14331485f, -0.37888178f, 0.15048318f, -0.08382592f, -0.13291673f, -0.12865216f, 
    0.15757887f, -0.17368042f, -0.06329346f, -0.14915037f, -0.07519087f, 0.12434221f, 0.04705759f, 0.05791811f, 
    0.02221757f, 0.12278864f, -0.11656303f, 0.05753403f, -0.14424610f, -0.18601052f, 0.31351036f, 0.13132796f, 
    -0.03400049f, -0.06456738f, -0.11991753f, -0.05333599f, 0.02634231f, -0.15796864f, -0.02597765f, -0.02837528f, 
    0.22122967f, 0.09491173f, 0.07528458f, 0.22290866f, -0.28275266f, -0.32569566f, 0.24855871f, -0.15490343f, 
    0.01496078f, -0.00213378f, 0.14782006f, 0.12737589f, 0.18305783f, 0.21528818f, -0.13211516f, 0.13790058f, 
    -0.23765782f, 0.12138394f, 0.02191889f, 0.09663436f, 0.17202073f, 0.09951698f, 0.44560778f, -0.23661831f, 
    0.00596658f, -0.20433730f, 0.20287134f, -0.26985571f, -0.04258137f, -0.12735605f, -0.11847319f, -0.46297988f, 
    -0.45333821f, -0.10574353f, -0.44979069f, -0.16478115f, -0.19715378f, -0.00099558f, 0.04738956f, 0.18215166f, 
    -0.09546404f, -0.01171077f, -0.28981021f, -0.02096924f, 0.08860766f, -0.01160423f, -0.00978792f, -0.01068727f, 
    -0.26405564f, 0.06045130f, 0.20939043f, -0.50595683f, -0.12639827f, 0.00520154f, -0.24852942f, 0.03573034f, 
    -0.09142531f, 0.04131232f, 0.47694075f, -0.01908687f, -0.21470907f, 0.22643556f, -0.20042822f, 0.19663937f, 
    -0.23613161f, 0.08959568f, -0.11264927f, -0.03786080f, -0.27391642f, 0.29869023f, 0.08777112f, -0.29278639f, 
    -0.24419080f, -0.04238288f, 0.08199240f, 0.12390152f, 0.41148534f, 0.10098676f, -0.10392024f, -0.05362838f, 
    0.02358469f, 0.01282534f, -0.11228709f, 0.08257208f, -0.06535035f, -0.07127586f, 0.26884508f, 0.03204336f, 
    -0.02587727f, 0.23613964f, -0.00807842f, 0.00542681f, 0.06357124f, 0.14309368f, 0.24292067f, 0.25231278f, 
    -0.13689350f, 0.07597004f, 0.13302484f, 0.15538213f, -0.04641135f, 0.03449892f, -0.32914540f, 0.31043604f, 
    -0.27475253f, -0.32288939f, -0.15502870f, 0.15343784f, 0.12482318f, -0.08236305f, -0.07209612f, -0.02904142f, 
    0.02612793f, 0.08427642f, 0.10682740f, -0.02060969f, -0.22119562f, -0.06551050f, 0.13345212f, -0.04889454f, 
    0.06993633f, 0.56595457f, 0.07324041f, -0.34853360f, 0.04122002f, 0.09891933f, 0.03152558f, -0.26233962f, 
    0.04687819f, -0.04280252f, 0.30356812f, 0.15022820f, 0.11592928f, -0.15189227f, -0.12194052f, 0.07603399f, 
    -0.15475747f, 0.13905361f, 0.02319986f, 0.00537843f, 0.20469813f, 0.08596490f, -0.15707131f, 0.16396752f, 
    0.21327055f, 0.00090799f, -0.16883235f, -0.23477234f, -0.04232682f, 0.15703560f, 0.34006682f, -0.04771613f, 
    0.01657109f, -0.05803018f, -0.01689879f, 0.03112407f, 0.01148269f, -0.11866303f, 0.05568166f, -0.10826547f, 
    0.00385259f, 0.01936008f, 0.22444007f, -0.18855885f, -0.05058908f, 0.08641902f, 0.67100787f, 0.12905967f, 
    0.01810216f, -0.07494434f, -0.15468977f, 0.04153018f, -0.00406623f, 0.15965350f, -0.07886710f, -0.65191370f, 
    -0.28233117f, -0.25971681f, -0.05436539f, 0.08202192f, 0.17126326f, 0.06834103f, -0.06002557f, 0.08634493f, 
    -0.12557474f, 0.10403885f, 0.24868408f, -0.04357342f, -0.00265930f, -0.10451164f, -0.00620999f, -0.01578924f, 
    -0.07859865f, 0.36175656f, -0.29264295f, 0.16500778f, -0.06346121f, -0.01614557f, 0.16566704f, -0.06117264f, 
    0.09906040f, -0.21532443f, -0.15919726f, -0.13348264f, -0.02475983f, 0.13033357f, 0.21423091f, -0.15391126f, 
    0.03539648f, -0.01159737f, -0.07585359f, 0.31241822f, 0.27166280f, 0.00739559f, -0.09927150f, -0.03760321f, 
    -0.00905457f, -0.08544091f, 0.05985999f, 0.06288142f, 0.15223216f, -0.05960965f, 0.33482802f, -0.17333150f, 
    -0.00299216f, -0.34161666f, -0.03082872f, 0.02664839f, 0.08338852f, 0.03972017f, -0.14537592f, -0.09720112f, 
    0.12478889f, 0.09150624f, 0.03298764f, 0.04256323f, 0.16223370f, -0.01004894f, 0.03931330f, 0.05416301f, 
    -0.06941445f, -0.14375274f, -0.17805079f, -0.23425446f, -0.03201555f, 0.01950336f, 0.11809672f, 0.21290831f, 
    0.06685960f, 0.13318220f, -0.26050359f, -0.17224975f, -0.29247528f, 0.09888624f, -0.00231503f, 0.22680971f, 
    0.31530902f, -0.15063260f, 0.01476642f, 0.07221543f, 0.01183732f, -0.12353846f, 0.10994564f, 0.12123694f, 
    -0.19975880f, -0.26143533f, -0.06289507f, 0.16276494f, 0.04426035f, 0.01768018f, 0.16909832f, -0.01978682f, 
    -0.04741143f, -0.09990108f, -0.44047770f, -0.16771218f, 0.04753123f, -0.03172002f, -0.06310725f, 0.04970592f, 
    0.00598815f, -0.07719229f, 0.11309628f, -0.14292185f, -0.01506101f, 0.17241898f, -0.16945879f, 0.13103198f, 
    0.32512179f, 0.11274100f, 0.20710626f, -0.29021388f, -0.10108071f, -0.18265431f, 0.14116256f, 0.04277351f, 
    -0.11218727f, 0.18257993f, -0.14229849f, -0.11529639f, 0.08307128f, 0.10667410f, 0.02720799f, -0.08441594f, 
    0.06261051f, 0.11747182f, 0.03828444f, -0.19264542f, 0.15837604f, 0.02028847f, -0.10576732f, -0.11488645f, 
    0.31444123f, 0.02836117f, -0.01055526f, -0.14192407f, 0.23983692f, -0.00704763f, 0.05939413f, 0.04931129f, 
    -0.16789815f, 0.13024630f, -0.05413435f, -0.07282916f, 0.10702524f, 0.10679997f, -0.02671100f, 0.14077951f, 
    0.19989084f, -0.17826235f, 0.10438059f, -0.15459266f, 0.05677263f, 0.06069910f, -0.10390619f, -0.15267263f, 
    0.03230082f, 0.24176997f, -0.29538929f, 0.10561202f, -0.06911626f, 0.05900458f, 0.14160268f, -0.11990045f, 
    0.28054339f, 0.14813064f, -0.03299633f, -0.11797532f, -0.27877855f, 0.14515205f, 0.05100912f, 0.04843687f, 
    0.06179768f, 0.06943553f, -0.17619956f, 0.00024825f, -0.08385734f, 0.02824331f, 0.05108090f, 0.04314579f, 
    -0.11991894f, -0.10802191f, -0.00694736f, -0.01168454f, 0.20910284f, -0.28266871f, -0.37743974f, -0.04212634f, 
    -0.13520765f, 0.31148651f, 0.06541536f, 0.15483457f, -0.08966812f, -0.14220043f, 0.15969549f, 0.31452751f, 
    0.06812291f, -0.22735783f, -0.05792317f, -0.04612548f, -0.07992738f, 0.05796879f, -0.06836572f, 0.12981994f, 
    0.03629405f, 0.24000078f, 0.01617773f, -0.09385433f, -0.02577358f, 0.28600693f, -0.07246510f, 0.45422673f, 
    0.00848902f, 0.32349411f, 0.11856852f, -0.21375288f, 0.03648293f, 0.08463402f, -0.11154941f, -0.10341582f, 
    -0.24930188f, -0.13956164f, -0.09093811f, 0.10301508f, 0.11212613f, 0.06690043f, -0.12902163f, 0.20868371f, 
    -0.05057087f, 0.37297422f, 0.26325229f, 0.15238665f, 0.08442029f, -0.13283938f, 0.01119482f, 0.01410364f, 
    -0.16574508f, -0.01468439f, -0.41454726f, -0.13892433f, 0.04660279f, 0.00733145f, 0.12061374f, -0.04729105f, 
    0.00996386f, 0.00114763f, -0.10526446f, -0.56302565f, -0.05845832f, 0.01838802f, 0.02277946f, -0.19831695f, 
    0.03023844f, -0.02244055f, 0.09550463f, 0.03582501f, -0.21224506f, -0.11148518f, -0.18813862f, 0.13701145f, 
    0.12436873f, 0.17397402f, -0.15384814f, 0.02813101f, -0.07384648f, -0.33667073f, -0.08666156f, -0.01864103f, 
    -0.01852155f, 0.07572555f, 0.04966917f, 0.26311466f, 0.06130915f, -0.25169700f, 0.31328210f, -0.05610907f, 
    -0.24220490f, 0.24663521f, -0.04010571f, 0.15066238f, 0.01010964f, 0.25002152f, -0.06114998f, -0.19254327f, 
    -0.17921709f, -0.04126780f, 0.17318758f, -0.08555672f, 0.25164622f, 0.18314628f, -0.09502790f, 0.01234416f, 
    0.00218276f, 0.16613537f, -0.06347280f, 0.04243055f, -0.09453698f, -0.10369986f, 0.05626655f, 0.06260785f, 
    -0.18111783f, -0.19466376f, -0.12999281f, -0.05228507f, -0.12976405f, -0.08756170f, 0.04665085f, 0.11968137f, 
    -0.24061097f, -0.04195680f, 0.10395168f, 0.19489317f, 0.06368798f, -0.06248220f, 0.03314765f, 0.04939968f, 
    0.01332676f, 0.04588876f, -0.10652888f, 0.14123319f, 0.14636752f, 0.03800216f, 0.14399093f, -0.07168125f, 
    -0.05773695f, 0.03912874f, -0.00223039f, 0.11734910f, 0.08149259f, 0.03656136f, -0.00924473f, 0.06957046f, 
    0.11307096f, -0.03747363f, 0.17884223f, 0.04263940f, 0.14969012f, 0.09685904f, 0.03031786f, 0.17366882f, 
    0.08586821f, 0.13781966f, -0.10775226f, -0.07277839f, -0.19608563f, -0.12246598f, 0.13206659f, 0.11213652f, 
    0.08410380f, 0.13864100f, -0.03990581f, -0.21299084f, -0.03688630f, 0.00100199f, -0.05828757f, -0.19723283f, 
    0.09790167f, -0.03173461f, 0.04724328f, -0.08910424f, 0.10145295f, 0.09945174f, 0.00233448f, 0.03377451f, 
    -0.10214213f, 0.09568036f, -0.01346927f, 0.04853027f, 0.25940385f, 0.00863794f, -0.10251494f, -0.24129276f, 
    -0.13659887f, -0.03673880f, 0.08678149f, -0.07833579f, 0.07084707f, 0.08984488f, 0.20869845f, -0.04063582f, 
    0.17296487f, -0.05367439f, 0.20123474f, 0.24088302f, 0.16925570f, -0.08389400f, -0.19014536f, 0.16705413f, 
    0.09524331f, -0.10331869f, -0.11257437f, -0.01083205f, 0.03306028f, 0.10567002f, -0.03379158f, 0.14379841f, 
    0.15944919f, -0.05271556f, -0.12413971f, -0.05633695f, -0.05929421f, 0.24494439f, -0.04303372f, 0.07356116f, 
    0.04311452f, 0.11224465f, -0.15481631f, 0.05386998f, 0.20380092f, 0.02014322f, -0.15826125f, 0.01360962f, 
    0.19249469f, 0.12629208f, -0.20936717f, -0.19251733f, 0.05858144f, -0.09009144f, 0.01520032f, -0.07059971f, 
    0.09091141f, 0.12374993f, -0.14143170f, -0.10771823f, -0.06081293f, 0.17436099f, -0.02276827f, -0.04682604f, 
    -0.25189862f, -0.08114780f, 0.07410053f, 0.14906666f, -0.04023363f, 0.09476484f, -0.05597417f, 0.06615536f, 
    -0.00981913f, -0.24645409f, -0.12956090f, -0.05547275f, -0.39392224f, -0.11466915f, 0.08937982f, 0.04490152f, 
    0.07271322f, 0.15595390f, -0.32062241f, -0.04891117f, -0.14611278f, -0.01705307f, 0.04619180f, 0.17173493f, 
    0.11448531f, -0.18952923f, 0.08833607f, 0.27207452f, -0.24555124f, -0.09490044f, 0.03115671f, 0.26793811f, 
    0.16803882f, -0.03918689f, -0.19698079f, -0.24167415f, 0.11183261f, 0.06667842f, -0.00597763f, 0.06749666f, 
    0.14536655f, 0.04139930f, -0.17065918f, -0.15900558f, 0.15952799f, -0.18014666f, -0.10217083f, 0.25769687f, 
    0.13047861f, -0.00080764f, -0.19328788f, -0.22581881f, -0.02379058f, 0.06471382f, 0.14653969f, -0.07784426f, 
    -0.19295947f, -0.03821251f, 0.04361900f, 0.22594701f, -0.01196315f, -0.10694076f, 0.23319548f, 0.06529063f, 
    0.03198013f, -0.10952381f, -0.14836268f, -0.12661926f, 0.00934797f, -0.00112334f, -0.05699070f, 0.23428488f, 
    -0.09420537f, 0.19481213f, 0.06672488f, 0.05210548f, -0.02748285f, -0.17957292f, -0.04703976f, -0.06462131f, 
    0.24258459f, 0.05282119f, 0.10341735f, 0.01775037f, 0.05704987f, -0.01821055f, -0.02034458f, -0.07763916f, 
    -0.00495756f, 0.17131625f, 0.14836037f, -0.01904535f, 0.24741559f, -0.08588712f, -0.06191433f, -0.14862098f, 
    -0.00669320f, -0.07204464f, -0.14769535f, 0.17944467f, -0.03007002f, 0.09795742f, 0.05946421f, -0.17105667f, 
    -0.11596141f, -0.07249241f, 0.00778665f, -0.00885093f, 0.21800482f, 0.12682609f, 0.07234990f, 0.11152411f, 
    0.10806834f, -0.15196629f, -0.18959095f, -0.16733807f, -0.18642661f, -0.13083145f, 0.02680600f, 0.14641277f, 
    -0.09697872f, -0.06205168f, -0.17829169f, -0.03399653f, 0.05515682f, -0.45473975f, 0.19118470f, 0.25627533f, 
    -0.13202693f, 0.23020372f, 0.01474636f, -0.08167136f, -0.08615838f, -0.12245559f, -0.23395272f, 0.10395876f, 
    -0.18269259f, 0.04589273f, 0.21683463f, 0.08957612f, -0.14772134f, -0.26076615f, 0.07887733f, 0.37759870f, 
    0.22547902f, -0.21276972f, -0.04429708f, -0.06500529f, 0.01988359f, 0.09790147f, 0.00632596f, 0.11671755f, 
    -0.11759278f, -0.22084130f, -0.22501922f, -0.09041928f, -0.16109495f, 0.10321887f, -0.09553743f, -0.02959944f, 
    0.05267639f, 0.01052791f, -0.25178584f, -0.16037327f, 0.10248358f, 0.05317901f, -0.05886729f, 0.04279382f, 
    -0.01447563f, 0.01841343f, 0.11956692f, 0.09670635f, -0.07204016f, -0.21087082f, -0.24608073f, 0.00316895f, 
    -0.07194415f, -0.04878717f, 0.12298416f, -0.59700000f, 0.27903101f, 0.07371666f, -0.02930238f, -0.23531953f, 
    -0.07463913f, 0.01940875f, -0.05235217f, 0.03308725f, 0.02212117f, -0.21147659f, -0.20280515f, -0.23099107f, 
    -0.09009057f, 0.16744030f, 0.02839218f, -0.11960283f, -0.02978290f, 0.11728611f, 0.22770871f, 0.24315745f, 
    0.00586670f, 0.06676789f, -0.14922108f, 0.09641942f, 0.03562574f, 0.10013683f, -0.12128630f, 0.27592799f, 
    0.41195214f, -0.03631553f, -0.17046538f, -0.10455385f, 0.00229578f, -0.02412963f, -0.30129877f, -0.10337918f, 
    0.10819858f, 0.19937873f, 0.01807888f, -0.02398844f, 0.04550723f, -0.08501837f, -0.11232226f, -0.42733502f, 
    0.18196115f, 0.02221027f, 0.21469533f, 0.08999001f, 0.25624642f, -0.04423107f, -0.01282528f, 0.00381881f, 
    0.04677419f, 0.12443314f, -0.21621567f, -0.13633813f, -0.12064003f, -0.08838532f, -0.05637548f, -0.05046855f, 
    0.01929254f, 0.11400075f, 0.10923337f, 0.00846697f, -0.02431878f, -0.00139278f, -0.05360913f, -0.11020184f, 
    0.06892826f, -0.13586843f, 0.15762115f, 0.06974936f, -0.27533165f, -0.19581209f, 0.23467946f, 0.24914080f, 
    -0.15428194f, -0.04840972f, 0.09069716f, 0.22631766f, 0.27590016f, 0.26276615f, 0.17958805f, 0.23469202f, 
    -0.01503691f, -0.05703584f, -0.10121520f, -0.00721809f, 0.03456161f, 0.07815456f, 0.31677070f, 0.39889723f, 
    0.15737401f, 0.23765765f, 0.03584398f, 0.08488876f, 0.07663858f, -0.04354502f, 0.31950307f, 0.07971565f, 
    0.20343275f, 0.00677373f, 0.00335496f, 0.06961690f, -0.20122968f, 0.08061702f, -0.21989408f, 0.17173518f, 
    -0.21994907f, 0.21557358f, 0.09478507f, 0.20279615f, 0.07317854f, -0.14632903f, 0.04199557f, -0.00624573f, 
    0.07213872f, 0.16544165f, -0.26124737f, -0.25390205f, -0.13028441f, 0.32896590f, -0.04560861f, -0.04463690f, 
    0.10148574f, -0.03024170f, -0.02185304f, -0.15816611f, 0.06540748f, -0.20763645f, 0.15361880f, 0.07653838f, 
    -0.03310442f, -0.01024928f, 0.11275593f, 0.07320244f, 0.24704668f, 0.04324668f, 0.05976082f, -0.13954584f, 
    -0.15887268f, 0.05338270f, 0.05502271f, -0.02366171f, 0.11083392f, 0.39478987f, -0.04600047f, 0.23413627f, 
    0.06653909f, -0.07076997f, 0.09391458f, -0.21697415f, 0.19399026f, -0.07212762f, -0.00884086f, 0.16158684f, 
    0.03041891f, -0.00078752f, 0.03644669f, 0.07287935f, 0.17298765f, -0.09808455f, -0.64366543f, -0.22460616f, 
    -0.19734973f, 0.18019299f, 0.13337593f, -0.24411230f, 0.05547706f, -0.04959431f, 0.24954899f, 0.12719983f, 
    0.08108864f, 0.13027227f, -0.02013940f, -0.15829025f, -0.15095878f, 0.04973057f, 0.04931322f, -0.13115303f, 
    -0.22721557f, -0.03998744f, -0.32462788f, -0.09727409f, 0.01997664f, -0.01104773f, 0.00648043f, -0.05795606f, 
    -0.00426114f, -0.11895978f, 0.11614821f, 0.05402384f, 0.00697496f, -0.31859371f, 0.13865827f, -0.06589318f, 
    -0.09677445f, 0.11019561f, -0.33933803f, 0.14382008f, -0.01785697f, 0.01941267f, 0.05516450f, -0.01857402f, 
    -0.16929051f, -0.02274157f, -0.13832852f, -0.11834900f, 0.26087192f, 0.02677953f, -0.11329883f, -0.43274391f, 
    0.24958281f, 0.13079940f, 0.11270903f, -0.28390041f, -0.08623844f, 0.05868763f, -0.03225554f, 0.00010299f, 
    -0.03607665f, -0.10168523f, -0.12831560f, 0.20640963f, -0.15533082f, -0.28518966f, -0.08350824f, -0.03072119f, 
    0.11289441f, -0.14967531f, 0.16160475f, 0.07181718f, 0.09420533f, 0.22034243f, 0.23218073f, -0.10671407f, 
    -0.13448127f, 0.05767487f, -0.04096318f, -0.29269075f, 0.13400948f, 0.16715594f, -0.03946998f, 0.22697575f, 
    0.01429464f, 0.15293838f, -0.03146179f, -0.05159309f, -0.11474466f, 0.05076629f, 0.20748582f, -0.14991134f, 
    -0.12092168f, 0.08185122f, 0.08064745f, 0.20215932f, -0.08134437f, 0.01949337f, -0.02452696f, -0.14298506f, 
    -0.08672946f, -0.05876882f, -0.11176206f, 0.20680961f, -0.01385290f, -0.15545006f, -0.10356924f, -0.00597565f, 
    -0.07436313f, 0.50265974f, 0.07049623f, 0.04662270f, 0.02199441f, -0.07625292f, 0.09568773f, 0.05923864f, 
    -0.00014919f, -0.02095187f, -0.30185676f, -0.07062226f, -0.06690632f, 0.20169720f, -0.04250058f, -0.05705042f, 
    0.02883878f, 0.08733096f, 0.11976973f, -0.42170510f, -0.31644189f, -0.39608511f, 0.08201558f, -0.03668273f, 
    -0.11279599f, 0.12618960f, 0.18857841f, 0.16533387f, -0.26004091f, -0.18084110f, -0.50103831f, 0.26077405f, 
    0.14438510f, 0.11855762f, -0.03205691f, -0.06525665f, 0.09714951f, -0.02125287f, -0.08033391f, 0.16250578f, 
    0.08140779f, 0.05995514f, -0.01702842f, 0.16681847f, -0.01072046f, -0.10304760f, -0.51198399f, -0.07190249f, 
    -0.22446005f, 0.03104149f, 0.10792970f, -0.07571936f, -0.36852139f, 0.18536262f, 0.07504597f, 0.07863899f, 
    -0.45721659f, -0.34884670f, 0.22693929f, 0.21787700f, 0.03799416f, -0.15724428f, -0.01763693f, 0.13715439f, 
    0.14304774f, -0.06870601f, 0.39239326f, -0.32837340f, 0.01549981f, 0.00696686f, -0.09250049f, -0.08760981f, 
    0.07151984f, 0.08292383f, 0.08792975f, 0.14356154f, 0.13711062f, 0.03212187f, -0.19069763f, -0.05372892f, 
    0.04122233f, 0.11130463f, 0.11848582f, -0.08216482f, -0.17266783f, 0.14888120f, -0.08858543f, -0.14506797f, 
    -0.09948926f, -0.00507232f, -0.03700121f, 0.22321780f, 0.20621312f, 0.22821744f, -0.00386205f, -0.00887702f, 
    -0.12462207f, 0.23700912f, 0.23456302f, 0.13611136f, 0.06655095f, -0.04976251f, 0.08539577f, 0.16691470f, 
    -0.19559790f, 0.00224119f, 0.14998263f, -0.01186076f, -0.03623747f, 0.13626915f, -0.31915823f, 0.38131461f, 
    0.21721599f, 0.14358723f, -0.07830364f, -0.10713951f, -0.16848969f, -0.01035750f, -0.03068152f, 0.10575617f, 
    -0.02834746f, 0.04682560f, -0.02180981f, 0.02141085f, -0.03211986f, -0.16760497f, -0.00699082f, -0.33963999f, 
    -0.09684486f, 0.20424829f, 0.26202294f, -0.03141169f, 0.03857944f, 0.10031428f, -0.03298231f, -0.11310951f, 
    0.26825404f, -0.24467491f, -0.23745120f, 0.18990843f, 0.09236006f, 0.15905610f, 0.15711248f, 0.03512692f, 
    -0.09956093f, 0.03852183f, 0.15872881f, -0.33881301f, -0.09354910f, -0.18490760f, -0.00333421f, 0.02726577f, 
    0.05642486f, 0.20292041f, -0.06321663f, -0.20095460f, -0.20779186f, 0.11592541f, 0.01228714f, -0.00795654f, 
    -0.08256917f, -0.04070819f, 0.37649933f, 0.07148177f, -0.10848913f, 0.14665250f, -0.00375052f, -0.03322370f, 
    0.11119347f, 0.10916877f, -0.00155621f, 0.17518498f, 0.47656384f, 0.36450279f, 0.30114049f, -0.03038184f, 
    -0.14932235f, 0.07949307f, -0.05265823f, -0.01560630f, 0.07017196f, -0.31458560f, -0.28297919f, -0.27845889f, 
    0.03282202f, 0.06326854f, 0.04042143f, 0.04412459f, -0.02246259f, -0.02578759f, 0.14181177f, -0.08087683f, 
    -0.12092586f, 0.18693987f, 0.04052662f, -0.08723935f, 0.19648243f, -0.11983511f, -0.16105394f, -0.40045756f, 
    0.01915490f, -0.05678537f, 0.14620376f, 0.06291465f, -0.11273875f, 0.06071443f, -0.05380515f, -0.02121637f, 
    0.11694723f, -0.00427864f, -0.09844691f, -0.08438288f, 0.11696676f, 0.01626379f, 0.07633721f, -0.02425097f, 
    0.15706332f, -0.35468665f, -0.52554482f, -0.36544952f, 0.09058284f, 0.14580558f, 0.24071434f, 0.18709235f, 
    -0.00774378f, -0.20884126f, 0.27051151f, 0.25958756f, 0.04453307f, -0.01498227f, -0.04351992f, -0.14414780f, 
    0.06323763f, -0.00243026f, 0.12631480f, 0.22116891f, 0.05214020f, 0.03361192f, 0.19510174f, -0.11056832f, 
    -0.14962973f, -0.19390732f, 0.08841586f, 0.05833232f, 0.36788195f, 0.35099176f, 0.23020080f, -0.08770705f, 
    -0.09539542f, 0.17451896f, 0.14185737f, -0.05416643f, 0.04226354f, 0.04460459f, -0.27130261f, 0.02096389f, 
    0.14537409f, -0.01163620f, 0.10642825f, 0.00769028f, 0.17651667f, 0.27200747f, 0.52300876f, 0.13093477f, 
    0.17986080f, -0.06343111f, -0.24722309f, -0.05563384f, 0.21080053f, 0.01330608f, 0.12817149f, 0.17910168f, 
    0.00878219f, -0.13861738f, 0.04303048f, 0.16767061f, 0.10213213f, 0.23572870f, -0.02018198f, -0.01808369f, 
    -0.02955105f, -0.00693097f, 0.01352282f, 0.03289574f, 0.00757231f, -0.06285250f, 0.00319262f, 0.03470777f, 
    0.00088824f, -0.03625892f, 0.02720696f, -0.06591949f, 0.00942231f, -0.02998843f, -0.00437308f, -0.06310847f, 
    0.05152798f, -0.04684835f, -0.01250176f, -0.06407068f, 0.04329076f, 0.02848476f, -0.04687196f, -0.04600100f, 
    -0.03331584f, -0.06246239f, -0.02328438f, 0.03299574f, -0.01873957f, -0.04172584f, 0.04113089f, -0.02172629f, 
    0.03279775f, -0.04579144f, 0.00117666f, 0.00711241f, -0.06358682f, 0.03720346f, 0.00236808f, -0.01822671f, 
    -0.02681099f, -0.05332062f, -0.01508780f, 0.02522887f, -0.06667413f, 0.04316797f, -0.00308124f, 0.02199589f, 
    -0.05581772f, 0.00788611f, 0.03741141f, -0.02776510f, -0.02299668f, -0.00538630f, 0.02327572f, -0.01642471f, 
    0.00554585f, -0.03295163f, 0.03535814f, -0.04143129f, -0.06538802f, -0.03258562f, 0.01112188f, -0.04842137f, 
    0.00465249f, 0.02517639f, -0.06047248f, 0.03069285f, -0.06977015f, 0.04484409f, -0.03482711f, -0.04506606f, 
    0.03127865f, 0.04933808f, 0.02971398f, -0.06305782f, -0.00561537f, 0.01297541f, -0.02592860f, 0.03311337f, 
    -0.01085549f, -0.01955558f, -0.03098017f, -0.02222598f, 0.04182690f, -0.00719374f, -0.02337012f, 0.04162172f, 
    -0.03216199f, -0.00547287f, -0.04070359f, -0.00035696f, -0.06303050f, -0.05984004f, 0.01021747f, 0.02972700f, 
    0.03200982f, 0.01648050f, -0.05488894f, 0.01554996f, -0.00588000f, 0.00028448f, 0.04465432f, 0.04008553f, 
    0.01361728f, -0.01247606f, -0.02247711f, -0.06934208f, -0.02010814f, 0.00047541f, 0.02709982f, -0.05669611f, 
    0.04481755f, 0.04155669f, -0.04718240f, -0.05340645f, -0.00091898f, -0.05594777f, -0.03518121f, 0.02118775f, 
    -0.06396218f, -0.04178743f, 0.04170213f, 0.04931373f, -0.00455534f, 0.03773858f, -0.03565849f, -0.04945557f, 
    0.00808071f, 0.02238949f, -0.04285290f, 0.02386919f, -0.06029526f, -0.06425150f, -0.06957138f, -0.00233197f, 
    -0.01173697f, -0.03156188f, 0.02561068f, 0.00758691f, -0.04568065f, -0.00869206f, -0.02212872f, -0.01380314f, 
    0.01449550f, -0.06167546f, -0.00851361f, 0.02784576f, -0.04469772f, -0.04219176f, -0.05831833f, 0.00305173f, 
    0.00842102f, -0.04890936f, 0.00682388f, 0.04303861f, 0.04151835f, -0.06134258f, -0.03034490f, -0.03830536f, 
    0.02474735f, 0.01486578f, -0.02672067f, -0.05282567f, -0.01528647f, -0.03941683f, 0.00482349f, -0.06567344f, 
    -0.02930111f, -0.01595814f, -0.06764912f, 0.00884653f, -0.05892873f, -0.03894805f, -0.05804240f, -0.04713590f, 
    -0.05073282f, -0.07191303f, 0.01090506f, -0.00139297f, -0.04609444f, -0.05190000f, 0.02831551f, 0.03185400f, 
    -0.01172982f, -0.01004488f, 0.00540716f, -0.02488192f, 0.03255047f, -0.00450239f, -0.03441758f, -0.05058596f, 
    0.01430938f, 0.02087585f, 0.00277385f, -0.05918085f, 0.03419566f, -0.01210550f, -0.00335468f, -0.06312142f, 
    0.00331610f, -0.02815204f, -0.01047984f, 0.03064557f, -0.05180793f, -0.04451742f, -0.00725967f, -0.05998781f, 
    0.04211543f, -0.05357617f, -0.00264217f, -0.03251464f, 0.02525928f, -0.00733712f, 0.02075509f, 0.00389280f, 
    -0.00567673f, 0.02983972f, 0.01452222f, -0.00940985f, 0.00570351f, -0.00953033f, 0.00219555f, 0.00048664f, 
    0.03001262f, -0.03860009f, 0.01685432f, 0.00317168f, -0.03376890f, 0.03789804f, -0.06858550f, 0.04467643f, 
    0.02556095f, 0.03035083f, -0.05217286f, 0.01141023f, 0.04663460f, -0.00707819f, 0.04980967f, -0.02069107f, 
    0.03404695f, 0.02236657f, 0.02690222f, -0.01555090f, 0.02581431f, -0.07115612f, -0.02332819f, 0.00126006f, 
    -0.01296593f, 0.03222006f, 0.04668429f, -0.05847140f, -0.06166004f, 0.02907388f, -0.00330321f, -0.01126437f, 
    0.02456238f, 0.02682798f, 0.03904836f, 0.01382668f, -0.02485255f, 0.00755721f, -0.06343088f, -0.06125155f, 
    -0.02168292f, -0.03017605f, 0.01640854f, 0.00401619f, 0.02076089f, -0.05640824f, 0.04353543f, 0.02632311f, 
    0.04204584f, 0.02015487f, 0.04330496f, 0.03996860f, -0.04357723f, -0.04716411f, 0.00054632f, -0.04674242f, 
    -0.01022869f, 0.01148394f, -0.02549539f, 0.00097359f, -0.04728471f, -0.01740000f, 0.00141688f, -0.00503991f, 
    -0.11141180f, 0.27962309f, 0.00334179f, 0.15990941f, 0.07959639f, 0.01658335f, -0.09770601f, 0.01781936f, 
    -0.20710799f, -0.33448434f, 0.39001545f, 0.05754074f, 0.14165404f, 0.19699362f, 0.09746730f, 0.06450077f, 
    -0.21519665f, -0.07907657f, -0.07293800f, 0.09346229f, -0.06985844f, 0.05380953f, -0.12782472f, -0.07210495f, 
    0.01665228f, 0.12598461f, -0.05701578f, 0.14760171f, -0.53881586f, -0.24465786f, -0.08301312f, 0.09457366f, 
    0.04028840f, -0.23002841f, 0.11008901f, -0.04556705f, -0.08955097f, 0.03033017f, 0.08525054f, 0.10884577f, 
    0.04811997f, -0.14130518f, -0.08698557f, -0.01094323f, 0.08733799f, 0.27521768f, -0.24063970f, 0.12630178f, 
    -0.12111109f, -0.03130884f, 0.11476025f, -0.02989858f, -0.00335141f, 0.14125402f, -0.21357396f, -0.42841020f, 
    -0.19156606f, 0.10977940f, 0.21841386f, 0.03008622f, -0.16951525f, -0.06950691f, -0.03922617f, -0.10713137f, 
    -0.15762953f, -0.28570867f, 0.06617862f, 0.03114386f, 0.14610627f, -0.11331035f, 0.02727164f, -0.07583492f, 
    0.55559647f, 0.05130121f, -0.00881811f, -0.18662672f, -0.01486612f, 0.16754648f, -0.33263871f, -0.25646469f, 
    -0.04152684f, -0.01929424f, 0.21543416f, 0.23240139f, -0.03429626f, 0.03116248f, 0.01568736f, -0.03700944f, 
    0.02919766f, -0.04762477f, 0.07797955f, 0.08141278f, -0.01863198f, 0.02710602f, 0.07057368f, 0.03068752f, 
    0.21591492f, 0.10319793f, -0.21052544f, -0.03302816f, 0.03272974f, -0.08629970f, -0.06994117f, -0.05972087f, 
    0.01529692f, -0.19138150f, 0.04128806f, -0.09263596f, -0.11521892f, -0.39973673f, 0.05093386f, 0.12891999f, 
    0.18988797f, 0.09656598f, 0.08782049f, 0.05505267f, -0.02273248f, 0.34089682f, -0.27104500f, 0.03220582f, 
    -0.09571623f, 0.28021988f, -0.07283492f, 0.02621024f, 0.01794580f, 0.04097986f, 0.37901551f, -0.09785339f, 
    -0.08955875f, -0.02076505f, 0.03457170f, 0.04221819f, 0.17719522f, -0.05893172f, 0.13487476f, 0.02839244f, 
    0.04616791f, 0.34547955f, -0.00154075f, -0.21890765f, 0.25171161f, -0.01517309f, -0.03020919f, 0.11861874f, 
    -0.29216161f, 0.20667382f, 0.25359780f, 0.12681808f, 0.36279929f, -0.05786181f, -0.06231171f, 0.00102478f, 
    0.03886102f, 0.50862795f, -0.00323463f, -0.05811006f, -0.06571198f, -0.20434590f, -0.07833932f, -0.11976996f, 
    0.07431674f, -0.24277243f, 0.06299585f, -0.01989094f, -0.05377611f, -0.08282378f, -0.12022363f, -0.03985038f, 
    -0.12617293f, 0.00279442f, -0.04117871f, 0.21668735f, -0.12483419f, 0.12536931f, 0.05721168f, -0.26185158f, 
    -0.21401063f, 0.18642935f, 0.03786673f, 0.19140339f, 0.26247284f, -0.03794318f, -0.35213935f, -0.07972021f, 
    0.12660809f, -0.14611623f, 0.07148466f, -0.05655182f, -0.03582443f, 0.28534797f, 0.31104454f, -0.04973321f, 
    0.14678113f, -0.00021697f, -0.07774219f, 0.13120992f, 0.07707203f, 0.03394182f, 0.14156812f, -0.27336141f, 
    -0.21283644f, 0.17908934f, 0.23115419f, -0.12193242f, -0.06315906f, 0.05353586f, -0.09431045f, 0.27752796f, 
    0.01945687f, -0.27204055f, 0.01567015f, 0.31915176f, -0.03713947f, -0.08848369f, 0.05572643f, -0.15881598f, 
    -0.02951512f, 0.05393644f, -0.11719050f, -0.00756449f, -0.29963356f, 0.07126392f, 0.13303684f, 0.10325751f, 
    0.22271727f, -0.12808478f, 0.18324509f, -0.36906359f, 0.08503955f, 0.09622312f, 0.08036079f, -0.18497002f, 
    -0.03472986f, -0.05416060f, -0.16534218f, -0.03712163f, 0.03987017f, -0.15453818f, 0.07530541f, -0.01061031f, 
    -0.04323345f, -0.06554729f, -0.07921544f, -0.19149595f, 0.34821790f, 0.17614093f, -0.12370127f, -0.02301672f, 
    0.06170109f, -0.08392927f, -0.01431639f, -0.41496891f, -0.11589837f, -0.15515135f, 0.11772203f, -0.06940455f, 
    0.05701984f, -0.16969195f, -0.07931965f, -0.06677919f, 0.27343446f, -0.25497305f, 0.27149263f, 0.07699708f, 
    0.08267108f, 0.13960427f, -0.13860092f, -0.10321918f, -0.22236913f, -0.01910032f, 0.25049230f, -0.06931037f, 
    -0.16591991f, -0.01301136f, 0.01094384f, -0.22814988f, -0.01696608f, 0.14865796f, 0.08494631f, -0.21786682f, 
    -0.02242999f, -0.06310055f, 0.15327279f, 0.10380270f, -0.00369372f, 0.01500460f, -0.09235100f, -0.12859794f, 
    0.19366813f, -0.25744787f, -0.07311999f, 0.01890012f, 0.13906972f, 0.02685169f, 0.00285269f, -0.15145995f, 
    -0.00327610f, 0.35348368f, 0.08360340f, -0.23541266f, 0.18773483f, 0.19986004f, -0.07868989f, 0.08962229f, 
    0.16439171f, 0.20549925f, 0.13283546f, -0.39608917f, 0.19730996f, 0.21719699f, 0.01619620f, -0.03005417f, 
    0.21000336f, -0.07341675f, -0.02827071f, 0.30745941f, -0.30485719f, -0.14664459f, -0.42676008f, -0.06367841f, 
    -0.08354688f, -0.01076742f, 0.04321022f, 0.04358562f, -0.09526575f, -0.18775909f, -0.18868439f, 0.03780868f, 
    0.05377524f, 0.16608436f, -0.02659359f, -0.12270425f, 0.07140195f, 0.22510900f, 0.17146395f, 0.15321879f, 
    -0.03421901f, 0.01271858f, -0.06390248f, -0.01270210f, 0.07739690f, 0.15619849f, 0.59404308f, -0.07628909f, 
    0.00492928f, 0.11387440f, 0.15859598f, -0.17804682f, -0.09943069f, -0.03362866f, -0.26088753f, -0.03610076f, 
    0.11541028f, -0.17312200f, 0.09484158f, 0.17337944f, 0.03109398f, -0.29511595f, -0.34962928f, -0.27194527f, 
    -0.14030598f, 0.34303546f, 0.02003548f, -0.02410767f, -0.01145637f, -0.09135687f, -0.05717409f, 0.20017643f, 
    0.01284068f, -0.11041982f, -0.25019714f, 0.11188275f, -0.02407326f, -0.09828390f, 0.03476306f, -0.00288577f, 
    -0.09132750f, 0.24309109f, 0.02565952f, -0.32890555f, 0.18290097f, 0.27218318f, 0.05263329f, -0.03227613f, 
    0.01824003f, 0.12537099f, 0.05536205f, -0.10599891f, -0.15714534f, 0.02866547f, 0.04264955f, 0.04547775f, 
    -0.01617854f, -0.09401933f, 0.11809126f, 0.25164416f, 0.08566239f, 0.19393660f, -0.10248713f, -0.00404563f, 
    0.20838904f, 0.10676508f, -0.11528598f, 0.10737339f, -0.02163514f, -0.16785136f, 0.56861669f, 0.06777756f, 
    0.09700790f, 0.14995113f, -0.07140557f, 0.33569846f, -0.05604079f, -0.08390321f, 0.61303955f, 0.18018070f, 
    -0.38388199f, -0.03323939f, -0.05291082f, 0.11096440f, -0.05036646f, -0.09281625f, 0.01234112f, -0.42781883f, 
    0.34701461f, 0.15121609f, 0.01454867f, -0.32581767f, -0.16333300f, -0.08338977f, 0.00805495f, 0.09680936f, 
    0.23438612f, 0.01728302f, -0.02351721f, 0.03541502f, -0.10246034f, 0.16423708f, 0.10097782f, -0.09928278f, 
    -0.07222588f, -0.65470010f, -0.09623562f, -0.31438366f, -0.00328442f, 0.03280100f, -0.16889220f, -0.11045933f, 
    -0.09640359f, 0.03635477f, -0.29898214f, -0.23168133f, -0.03822434f, -0.04724084f, -0.12034319f, 0.02794443f, 
    0.13513304f, -0.04454241f, 0.13933693f, 0.20131345f, 0.29047906f, -0.08035266f, -0.14227974f, -0.00510251f, 
    0.15772612f, 0.02304979f, 0.05529208f, 0.01990443f, -0.36479697f, 0.05322162f, -0.01150120f, -0.10284905f, 
    -0.05396223f, -0.01494854f, 0.03553503f, 0.20690504f, 0.06441234f, 0.17048106f, -0.31404138f, 0.13808800f, 
    0.14662865f, 0.03158369f, 0.15551236f, -0.07553274f, -0.04513598f, 0.30024585f, 0.47517306f, 0.15102595f, 
    -0.20229027f, 0.08393445f, -0.21756211f, -0.10719739f, 0.16472808f, -0.13094939f, 0.06836332f, 0.13978194f, 
    -0.03062150f, 0.08858122f, -0.01489634f, 0.01709746f, 0.07125568f, -0.17145178f, -0.12314291f, -0.09049669f, 
    0.20197207f, -0.42874795f, -0.17211972f, 0.06788381f, -0.13372988f, 0.00318918f, 0.13000388f, 0.10977294f, 
    0.03582394f, 0.14272554f, -0.10747518f, -0.07234864f, -0.08630557f, -0.16686372f, 0.08727694f, -0.25788972f, 
    -0.24791907f, 0.18058482f, 0.12263859f, -0.30005372f, 0.13852698f, 0.05237014f, -0.27991134f, -0.19489394f, 
    0.05210557f, 0.04832353f, 0.14696874f, 0.07418095f, -0.38218719f, -0.05125543f, 0.06953902f, 0.00772654f, 
    0.13472068f, -0.01489146f, -0.01915840f, 0.10008612f, -0.05090437f, -0.28566360f, 0.01509362f, 0.08706140f, 
    0.09910977f, -0.24804766f, -0.04150395f, 0.00071553f, -0.10668159f, -0.17926516f, -0.26240009f, 0.07494707f, 
    -0.01462474f, -0.10430976f, 0.07210996f, 0.29632124f, 0.08762460f, -0.09528526f, -0.45698461f, 0.15704870f, 
    -0.02454271f, -0.17243418f, 0.18359183f, -0.10705109f, -0.11368450f, -0.04486816f, -0.01099474f, -0.06573302f, 
    -0.08113462f, -0.00488755f, 0.09991813f, 0.00492068f, -0.04701819f, 0.08363674f, -0.02870552f, -0.13002720f, 
    -0.05648373f, 0.01120597f, 0.19790417f, -0.18513222f, -0.07053012f, 0.24439445f, -0.10114735f, 0.07562231f, 
    0.10103273f, 0.51944512f, 0.20190585f, -0.29265162f, -0.02130868f, -0.02091531f, 0.05683227f, 0.09847338f, 
    -0.03463386f, 0.28465948f, -0.09258584f, -0.23417082f, 0.15035425f, -0.10193791f, -0.01347194f, 0.01921749f, 
    -0.15881498f, -0.01696952f, -0.10467574f, -0.56374669f, 0.06028947f, 0.07931873f, 0.33507586f, 0.04769313f, 
    -0.02960271f, -0.02563386f, 0.03577289f, -0.01995620f, 0.20648596f, 0.29700571f, 0.19012395f, -0.10719731f, 
    0.02203912f, 0.13239227f, 0.12916832f, 0.08313207f, 0.24610735f, -0.44497928f, 0.00264433f, -0.31688181f, 
    0.16098417f, 0.01540316f, -0.03414793f, -0.02922719f, -0.06037406f, -0.16027650f, -0.57890117f, -0.27203214f, 
    0.10851305f, -0.01298988f, 0.03930377f, 0.11977796f, -0.19755058f, -0.01289608f, -0.05089704f, 0.02124614f, 
    -0.15348211f, 0.05872197f, 0.00474101f, 0.18543674f, 0.24926926f, 0.18515998f, 0.17649879f, -0.19168606f, 
    -0.44094720f, -0.08836982f, -0.40625882f, -0.05191398f, -0.01247703f, -0.05660441f, 0.11528511f, -0.18680081f, 
    -0.01703885f, 0.08736841f, -0.00524114f, 0.29318619f, 0.00865028f, 0.17772004f, 0.04162124f, -0.11106894f, 
    0.15840335f, -0.01360989f, -0.15516439f, -0.05848614f, -0.02102116f, -0.08493640f, 0.26210007f, -0.13037942f, 
    -0.11548892f, 0.01916940f, -0.04417676f, 0.18611537f, 0.18918851f, -0.13056751f, -0.03336747f, 0.16177709f, 
    -0.26074725f, 0.20162503f, 0.29756063f, 0.16787381f, -0.01460852f, 0.06488633f, 0.04012809f, 0.12112499f, 
    0.01092415f, 0.04550890f, 0.23037301f, 0.09187975f, -0.09734549f, -0.63533306f, -0.35887638f, 0.06654961f, 
    -0.06609973f, 0.17726329f, -0.00127859f, 0.11182884f, 0.09683310f, 0.07313153f, -0.46981597f, 0.11881647f, 
    -0.21057855f, 0.04793138f, 0.02370698f, 0.14355735f, -0.01117015f, -0.02662757f, 0.09876251f, -0.08936221f, 
    -0.03497533f, -0.11105514f, -0.01158634f, 0.22962587f, 0.02548967f, -0.08607046f, 0.16305947f, -0.13274147f, 
    0.12437804f, -0.16441442f, -0.21805045f, -0.07759024f, 0.32598954f, -0.07173109f, -0.09244984f, -0.03817493f, 
    -0.17189376f, -0.06119803f, -0.35055345f, -0.23056634f, 0.07472136f, -0.24958780f, 0.03822563f, 0.13993725f, 
    0.07736319f, 0.35864216f, -0.20883068f, -0.12394211f, -0.21283762f, -0.06521444f, 0.11046463f, 0.04916067f, 
    0.14829828f, -0.14788459f, 0.09084321f, -0.28276145f, -0.36336729f, -0.02392377f, 0.13317040f, -0.07598956f, 
    0.18144409f, 0.02052439f, 0.06169915f, 0.07607091f, 0.23091884f, -0.04758508f, -0.18233280f, 0.13039328f, 
    -0.08531398f, 0.00853410f, -0.07496618f, -0.04355489f, 0.07948964f, -0.00624897f, 0.06029717f, 0.29995903f, 
    -0.23337694f, 0.13033617f, 0.16211464f, -0.05728128f, -0.03525146f, 0.25004292f, -0.51497746f, -0.11058722f, 
    -0.35187358f, -0.08716784f, -0.11860142f, -0.04713075f, 0.00388850f, -0.06793257f, 0.01748567f, 0.06419619f, 
    -0.15358926f, 0.09750433f, -0.02039589f, 0.01928300f, -0.07454141f, -0.07978649f, 0.10856900f, 0.06238747f, 
    -0.19958039f, -0.03915336f, -0.27203488f, -0.04904717f, -0.21697941f, 0.07424093f, 0.14970283f, 0.12190630f, 
    0.22351462f, -0.10826726f, -0.20630565f, 0.09359208f, 0.00345115f, 0.23243350f, 0.02216915f, 0.07084370f, 
    -0.14581878f, -0.08538756f, -0.21245928f, 0.13483900f, -0.16701609f, 0.07068236f, -0.02931408f, -0.21170267f, 
    0.08013919f, 0.12040277f, 0.14521395f, -0.13015595f, -0.20655802f, 0.20409757f, -0.06540297f, 0.10959747f, 
    0.07649370f, -0.05950885f, 0.11145749f, 0.03926505f, 0.13104877f, 0.27027288f, -0.04804086f, 0.16821015f, 
    -0.23122050f, -0.09143844f, 0.08734820f, 0.14208482f, 0.04971782f, 0.04223653f, -0.28200155f, -0.17034653f, 
    -0.11801091f, 0.00739397f, 0.29515675f, 0.02633747f, 0.12774561f, 0.13463101f, 0.13262223f, -0.16978133f, 
    -0.14219657f, 0.15038131f, -0.13569097f, -0.07307333f, 0.00550576f, 0.02613955f, 0.07502698f, 0.20750625f, 
    0.02598297f, -0.06259101f, 0.01233092f, 0.06927112f, -0.19268765f, 0.24624774f, 0.13499968f, 0.00438955f, 
    0.47483909f, 0.22409746f, -0.10764170f, 0.21888380f, -0.10636680f, 0.21211591f, -0.03449780f, 0.01017191f, 
    -0.07048880f, 0.18786097f, -0.01402273f, 0.06573019f, 0.04008587f, 0.14649294f, 0.01497892f, -0.01710442f, 
    0.12582119f, 0.11744777f, 0.34235537f, 0.22615151f, 0.13536806f, -0.07841437f, -0.02153135f, 0.21702082f, 
    -0.09770519f, 0.18680558f, 0.29586038f, -0.08974391f, 0.04268111f, 0.03787886f, -0.07815688f, -0.05222772f, 
    0.08451077f, 0.13419773f, 0.00514410f, 0.12576184f, 0.32891452f, 0.08924318f, -0.20418809f, 0.09495787f, 
    -0.16058542f, 0.10051029f, -0.14689764f, 0.06959013f, -0.13542780f, -0.24765672f, 0.03494382f, -0.42179340f, 
    0.13680382f, 0.03867769f, 0.06437284f, 0.13902818f, -0.08572084f, -0.00561215f, 0.32408080f, 0.25732780f, 
    0.14273782f, 0.08367746f, 0.00345903f, 0.11023430f, 0.10987047f, -0.01450174f, -0.06379320f, 0.26917765f, 
    -0.37922886f, 0.10950091f, 0.16291302f, -0.04202108f, 0.05664165f, 0.04901724f, -0.08908071f, -0.15645199f, 
    -0.11910414f, 0.43533272f, -0.19385470f, -0.06444286f, 0.03451136f, -0.03643721f, 0.08095638f, 0.12005333f, 
    0.09870041f, 0.39888942f, 0.07140563f, 0.10736193f, -0.22729011f, -0.11274730f, -0.12125745f, -0.03006394f, 
    0.06387477f, -0.02512323f, 0.55242521f, 0.19333501f, 0.06101704f, 0.02405153f, 0.00558245f, -0.02022163f, 
    -0.00130878f, 0.12583655f, 0.05676002f, -0.05807298f, 0.06449749f, -0.09977356f, 0.21612272f, -0.05978554f, 
    -0.31844351f, -0.22250330f, 0.18946417f, -0.00955797f, -0.07749919f, -0.18870877f, -0.26737195f, 0.06973410f, 
    -0.10918301f, -0.10728849f, 0.13057563f, -0.26909703f, -0.14463581f, 0.16812743f, -0.11815134f, -0.12704352f, 
    0.18757871f, -0.23295139f, 0.11426341f, -0.08178977f, -0.09728596f, -0.07044972f, -0.34352881f, -0.07210374f, 
    -0.08845139f, 0.03073060f, 0.02296214f, 0.08529444f, 0.00736825f, 0.23929617f, -0.12687290f, -0.48475674f, 
    -0.15104580f, -0.21213174f, -0.06952814f, -0.01925709f, -0.05995499f, -0.15604924f, 0.03434689f, -0.00629064f, 
    -0.06350396f, -0.34840068f, 0.14788832f, 0.08769770f, 0.24182650f, 0.02335035f, 0.19826983f, 0.25489914f, 
    -0.17708704f, -0.87375939f, 0.03908943f, 0.03194309f, -0.07649723f, 0.08803767f, 0.09211655f, -0.08406797f, 
    -0.03918349f, 0.18722722f, 0.11329581f, 0.08116066f, 0.07545637f, -0.00318821f, 0.09262133f, -0.04471664f, 
    -0.07210102f, 0.07839775f, 0.25770235f, 0.06625286f, -0.10237319f, -0.38838083f, -0.04251469f, 0.03449316f, 
    0.17015609f, 0.04665155f, -0.04183430f, -0.16202135f, -0.61362541f, 0.21308942f, 0.46448210f, -0.02532168f, 
    -0.16164985f, -0.22302818f, -0.03770703f, -0.02482509f, -0.01980669f, 0.22943617f, 0.01227858f, -0.31914955f, 
    0.16519628f, -0.18329033f, 0.09953420f, 0.02115861f, -0.13565338f, 0.13759284f, -0.04474820f, -0.22584125f, 
    0.30729058f, 0.23942061f, -0.02942874f, -0.10509449f, 0.05358180f, 0.11807416f, -0.01157691f, -0.15794867f, 
    0.12055086f, 0.03247703f, -0.00171348f, 0.07252114f, -0.12479430f, -0.04926654f, -0.01677564f, 0.04282751f, 
    -0.08390237f, 0.21222340f, 0.07017417f, 0.09362517f, -0.12683380f, -0.10157988f, -0.13261056f, -0.00786148f, 
    -0.08444483f, -0.23331922f, -0.65527153f, -0.11152804f, 0.14632250f, 0.14301790f, -0.13777566f, -0.12117729f, 
    -0.28225493f, -0.02994547f, 0.12628710f, -0.13735110f, 0.08743802f, -0.07958482f, 0.01199783f, -0.05454765f, 
    -0.08203973f, 0.06647565f, 0.11461061f, 0.65982091f, 0.26193002f, -0.15839186f, -0.07461882f, -0.05570357f, 
    -0.10159376f, 0.08699744f, 0.09287940f, 0.02675100f, -0.04938712f, -0.14686754f, -0.43733385f, 0.06366792f, 
    0.11056157f, 0.05691420f, -0.25839844f, -0.11152291f, 0.04570357f, 0.29408309f, 0.01406160f, -0.14497130f, 
    0.25035924f, 0.03014458f, 0.09194940f, 0.11497172f, -0.04013410f, 0.02171606f, 0.32005584f, 0.10576325f, 
    0.10577089f, 0.05517925f, 0.09450680f, -0.26458097f, -0.25886929f, 0.13335338f, -0.09275640f, -0.09057573f, 
    -0.02695907f, 0.19756673f, 0.15139660f, -0.31728429f, -0.10753497f, -0.16532585f, 0.26405209f, -0.00149499f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.13034374f, 0.11680158f, -0.04928642f, 0.02043026f, 0.12561464f, -0.01628408f, -0.07585606f, -0.04943194f, 
    0.02592923f, -0.04056707f, -0.02790002f, -0.05030341f, 0.06136242f, 0.10134622f, 0.19907285f, 0.10273676f, 
    0.04328923f, -0.02095238f, 0.04492249f, 0.08437375f, -0.03182738f, -0.05598288f, -0.06992843f, 0.07196321f, 
    -0.04265962f, -0.09664649f, 0.08102472f, -0.05333335f, -0.01567015f, -0.04593464f, 0.23712471f, 0.01916221f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.66959953f, -0.49214464f, -0.00827330f, 0.13064186f, -0.43087205f, -0.06298149f, 0.20334989f, -0.90230429f, 
    0.27503610f, -0.06559621f, -0.14769845f, -0.18059357f, 0.10788482f, -0.13059638f, 0.06986408f, 0.14012344f, 
    0.09139756f, 0.13994455f, -0.02143110f, -0.11871846f, -0.04470612f, 0.08512001f, -0.13566902f, 0.13296072f, 
    -0.38016748f, -0.39867842f, 0.11008996f, -0.02235602f, -0.25691679f, -0.43158802f, -0.34364805f, 0.42392784f, 
    0.19760746f, -0.22240181f, -0.11506309f, -0.10486928f, -0.26401207f, -0.10800312f, -0.27369550f, -0.05543925f, 
    -0.39637485f, -0.08612697f, 0.07010941f, -0.01059654f, -0.36591887f, 0.49949947f, 0.75803691f, -0.07973674f, 
    -0.15963095f, 0.02583987f, -0.07790132f, -0.15291320f, -0.05904347f, 0.12621297f, -0.26609117f, -0.19354656f, 
    -0.41884995f, 0.08136217f, 0.27809423f, -0.15703316f, 0.49628702f, 0.42242640f, 0.22536534f, -0.09474442f, 
    -0.13182512f, 0.27062920f, 0.09504799f, -0.12220518f, -0.11281571f, 0.13674763f, -0.21988691f, -0.02509485f, 
    -0.09690318f, 0.14824069f, 0.07189295f, -0.16066723f, -0.38958082f, 0.26572475f, -0.51651508f, -0.08618300f, 
    -0.02884876f, -0.07424835f, 0.14305906f, -0.41412929f, 0.00870161f, -0.03465436f, 0.90367734f, -0.27832255f, 
    0.18618390f, -0.52470118f, 0.21263376f, 0.12192290f, 0.53827584f, -0.68283021f, -0.34666961f, -0.16855873f, 
    -0.40032998f, 0.18644643f, -0.01023759f, 0.03164982f, 0.17251040f, -0.08017416f, 0.40875229f, -0.17795330f, 
    0.14616019f, -0.10006499f, 0.00001633f, -0.15048227f, 0.29275170f, 0.04940667f, -0.27739814f, -0.33308408f, 
    0.04491546f, -0.13695547f, 0.17007859f, 0.19648874f, 0.12809366f, -0.17515825f, 0.15418296f, 0.42195326f, 
    -0.11377140f, -0.73105156f, -0.50424051f, -0.05853965f, -0.00625073f, 0.52141601f, -0.78185189f, -0.30827066f, 
    0.10741438f, 0.04336233f, -0.07014938f, 0.00060702f, 0.15855043f, 0.04886337f, 0.37443846f, -0.33534977f, 
    0.33010006f, -0.12896238f, -0.14563847f, -0.00799458f, -0.17914890f, -0.35803080f, -0.33452570f, -0.18833689f, 
    0.02848790f, 0.11390124f, -0.05407030f, 0.75546473f, -0.03483084f, -0.14444168f, -0.01444770f, 0.10594184f, 
    0.32220304f, -0.20785500f, 0.05617484f, 0.12423690f, 0.21684507f, -0.60676450f, 0.16036719f, -0.67877197f, 
    -0.02772282f, 0.25783205f, -0.17610236f, -0.10942175f, 0.05954894f, -0.10241733f, -0.63837260f, -0.04698136f, 
    0.16643171f, 0.02268957f, 0.06287545f, -0.09047734f, -0.43291068f, 0.04498647f, 0.44898862f, 0.39459124f, 
    0.15212673f, 0.02253757f, 0.16736367f, 0.23428859f, 0.08737204f, -0.16692016f, -0.51226264f, -0.32963952f, 
    0.17127591f, 0.48168957f, -0.19453274f, 0.12980440f, -0.53960872f, 0.05350837f, 0.23579006f, -0.05298916f, 
    -0.54128468f, -0.50253963f, 0.01611513f, 0.05298293f, 0.13689496f, -0.08179128f, 0.03270648f, 0.38939813f, 
    -0.01268669f, -0.02409778f, 0.13219978f, -0.07165021f, 0.17874041f, -0.70308089f, 0.10680231f, 0.54400194f, 
    -0.02195319f, 0.06625159f, 0.05666492f, 0.26479742f, 0.09420685f, 0.12976342f, -0.45965168f, 0.26303080f, 
    0.05109406f, -0.90330958f, -0.44150248f, -0.10897031f, 0.38711074f, -0.38723037f, -0.27915260f, 0.22544728f, 
    0.55097026f, -0.12264477f, 0.10543422f, 0.14696717f, -0.16107264f, -0.06124328f, 0.45891759f, -0.47997105f, 
    -0.23899159f, 0.16355294f, 0.13772652f, -0.02897534f, -0.00012915f, -0.19775869f, -0.13362724f, -0.22381818f, 
    0.16005282f, 0.12110372f, 0.10133510f, 0.00935504f, -0.06311305f, 0.01799908f, 0.26120496f, 0.00692364f, 
    0.07213704f, 0.91256630f, -0.19686849f, -0.00314745f, -0.54068160f, 0.04763086f, -0.34891826f, -0.36302936f, 
    -0.54017979f, -0.41804811f, -0.00316487f, 0.09449629f, -0.05912277f, 0.02425709f, 0.36199254f, 0.19772430f, 
    -0.00635050f, -0.00100670f, 0.02296172f, -0.00784625f, -0.40624011f, -0.14929424f, -0.49184525f, -0.11306000f, 
    0.05481910f, 0.15355255f, -0.04676209f, -0.08195204f, -0.11981626f, 0.05893809f, -0.16097800f, -1.06105447f, 
    -0.35497448f, 0.06716508f, 0.45832542f, -0.12217005f, -0.39737377f, 0.78865266f, 0.27577341f, 0.18655996f, 
    -0.02194421f, -0.09301950f, 0.16028155f, 0.10589429f, 0.88397634f, -0.01587334f, -0.13578825f, -0.38955307f, 
    -0.14688163f, -0.12621827f, 0.05027235f, 0.00629993f, -0.25333896f, -0.73292416f, -0.76425129f, 0.33194479f, 
    -0.09201828f, 0.10731989f, 0.13938615f, -0.94676548f, 0.10429738f, 0.10608028f, 0.16917777f, 0.24920519f, 
    0.25083467f, 0.00339188f, 0.25205970f, 0.15016873f, -0.24967057f, -0.43616834f, 0.56929612f, -0.15525785f, 
    -0.74965936f, 0.73368907f, 0.06475925f, 0.14038379f, 0.05557826f, -0.15435801f, -0.31135112f, 0.33353928f, 
    -0.29177237f, -0.15900213f, 0.01206448f, -0.10396424f, 0.48636675f, 0.70516461f, -0.44768345f, -0.48109320f, 
    -0.10639931f, -0.04466383f, -0.17770727f, -0.33881858f, -0.12083261f, 0.02614990f, 0.05972792f, -0.01182399f, 
    -0.68451351f, -0.08223597f, 0.15812621f, 0.11367606f, -0.09559525f, -0.41375181f, -0.27620003f, 0.03416796f, 
    -0.53460294f, -0.57757336f, -0.09256670f, 0.02356215f, -0.58468443f, -0.14562209f, -0.33918470f, 0.85042620f, 
    0.51105100f, -0.15366153f, -0.03281229f, 0.15068324f, 0.21362339f, -0.09174784f, -0.12912261f, -0.59873664f, 
    0.15671110f, -0.00056425f, -0.16201717f, 0.14142168f, -0.09639320f, -0.17594746f, 0.08224254f, -0.14221074f, 
    0.37378514f, 0.25993630f, -0.22300731f, 0.16574404f, -0.04721531f, 0.17279390f, -0.49637249f, 0.22158919f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00675293f, 0.10536359f, -0.06842994f, -0.19015422f, 0.01735777f, 0.21147764f, -0.24060915f, -0.44065323f, 
    0.05399702f, 0.20381723f, 0.10288145f, 0.09672189f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
