#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.86712426f, -1.60017502f, -0.46528715f, 0.48671466f, -0.46254849f, 0.09852564f, -0.18974377f, -0.96455914f, 
    -0.83180368f, -0.64992303f, -0.29698586f, -0.56806439f, -0.81250072f, -0.31493607f, -0.40574238f, -0.38521314f, 
    -0.52223694f, -0.51719618f, 0.48779052f, -0.45740706f, 0.28884268f, -0.25135678f, -0.36707523f, 0.24950513f, 
    -0.21606757f, -1.64826190f, 0.44061542f, 0.74614722f, 0.47345302f, -0.18839319f, -0.73326170f, -0.70094931f, 
    0.27201894f, 0.66210526f, 0.67390978f, 0.13875549f, 0.16614671f, 0.31270537f, -0.29403499f, -0.38696128f, 
    0.04973594f, 0.15204912f, -0.35935801f, -0.28142160f, 0.24525145f, 0.10459063f, -0.17003652f, 0.15006508f, 
    -0.04049063f, 0.29675716f, -0.94774824f, -0.08423403f, -0.66083801f, -0.83881038f, -0.91391814f, 0.57355297f, 
    0.95965791f, -1.27617431f, -1.40528274f, 1.16512585f, 0.01598380f, -0.08622343f, -0.39132553f, -0.64079368f, 
    0.30748534f, -0.04844167f, 0.31743255f, 0.24151437f, -0.12519360f, -0.03038857f, 0.05844887f, -0.21821596f, 
    -0.16650432f, -0.54454190f, -0.35260034f, 0.40833676f, 0.16255614f, 0.30058679f, 0.01299333f, -0.06072503f, 
    0.76949769f, -0.38659781f, -0.23157363f, -0.06727311f, -0.01395182f, 0.28897032f, -0.32183746f, 0.09773465f, 
    -0.02552311f, -0.24585998f, -0.09227820f, -0.56795937f, -0.17906775f, 0.80340022f, -0.44041699f, -0.42129928f, 
    0.43319553f, -0.12396307f, 0.03653990f, 0.06063546f, 0.60559183f, 0.05323588f, -0.22475827f, 0.42967945f, 
    -0.25002414f, 0.95041060f, 1.07104015f, 0.62253350f, -0.30271986f, -0.54776758f, 0.00667790f, 0.21267310f, 
    0.15657863f, -0.16808411f, 0.07176170f, 0.15024759f, -0.04774288f, -0.01451451f, -0.23531535f, 0.37527099f, 
    0.28124186f, 0.12700649f, -0.19505705f, -0.04265617f, 0.02164591f, 0.46296087f, -1.65203106f, -1.03186405f, 
    0.45352036f, 0.69810808f, 0.90828723f, 0.84084314f, -0.10433062f, -0.39658797f, -0.13188341f, -0.17941929f, 
    -0.32987857f, 0.25174722f, -0.02085859f, 0.55973393f, -0.48299158f, 0.04665633f, 0.11913323f, -0.18678513f, 
    -0.56693691f, 0.23230742f, -0.15500861f, 0.47953737f, 0.11021344f, 0.05747215f, -0.13519818f, -0.54809320f, 
    -0.79947901f, -0.88577789f, -1.01746595f, -0.86557007f, -0.64756685f, -0.21406031f, -0.81577182f, -0.99563348f, 
    0.14475822f, -0.48273870f, 0.51059437f, -0.31090194f, -0.12379741f, 0.15967076f, 0.12016434f, 0.06098015f, 
    0.05260156f, 0.18764248f, 0.20410196f, 0.36575046f, 0.14736915f, 0.28796878f, 0.59322071f, -1.88187766f, 
    0.09924121f, -0.42637360f, -1.10750377f, -1.09351969f, 0.51012635f, 0.37635040f, 0.04959508f, 0.53985870f, 
    0.56750977f, -0.32782039f, -0.04856556f, 0.14781937f, 0.66076636f, -0.24760079f, -0.08523013f, -0.11506363f, 
    -0.41659713f, 0.22222236f, 0.09021755f, -0.16780251f, 0.36659664f, 0.21715276f, -0.25878686f, -0.52406836f, 
    0.86513430f, 0.64433420f, 0.82091892f, 0.40840617f, -0.56994414f, -0.31745201f, -0.32634947f, -0.11969485f, 
    -0.32081798f, 0.32129100f, 0.06537320f, 0.49522555f, -0.20465586f, -0.34599844f, -0.45429903f, -0.24760078f, 
    -0.22729343f, 0.04825726f, 0.34662285f, 0.02131517f, -0.08242071f, 0.06669141f, -0.20027035f, -0.26245695f, 
    0.03833107f, -0.14398183f, 0.29906112f, 0.23291747f, -0.28223708f, 0.40507656f, -0.61894077f, 0.21812981f, 
    -0.18488741f, 0.83491606f, -0.03130833f, 0.15650947f, -0.76186806f, -0.04049099f, 0.06020470f, 0.05278696f, 
    0.61102003f, -0.35048786f, -0.27363271f, -0.24124685f, 0.12498116f, -0.35151863f, 0.08983058f, 0.32103840f, 
    -0.03997201f, 0.02115373f, -1.64569163f, -0.79320157f, 0.70288521f, 0.71633881f, 0.45316625f, 0.92098838f, 
    -0.45624807f, -0.51070774f, 0.18277572f, -0.06281310f, 0.31496626f, -0.18308748f, -0.34262213f, 0.34543172f, 
    -0.91410291f, 0.05343099f, -0.36513054f, -0.27328885f, -0.61572576f, -0.60161972f, -0.71623385f, -0.43004775f, 
    -0.37960917f, -0.22098480f, -0.86266083f, -0.71593088f, -0.94992977f, -1.12564564f, -0.69180375f, 0.08177216f, 
    -0.12923369f, 0.22183560f, 0.88711965f, 0.89140421f, 0.63377953f, 0.29494911f, 0.02570228f, -0.03094890f, 
    -0.00572329f, 0.11593558f, -0.08605682f, 0.06302560f, 0.04041331f, 0.19091745f, -0.11796019f, -0.25031447f, 
    0.09511945f, -0.01007814f, -0.26023749f, 0.35414067f, -0.97279483f, -0.14422877f, 0.52856439f, 0.77174860f, 
    0.09364755f, 0.15119040f, -0.78991395f, -0.58812028f, 0.50484622f, 0.14171474f, -0.06345098f, -0.21779202f, 
    -0.49776936f, 0.38139352f, 0.63224733f, -0.05851519f, -0.25273752f, -0.20405558f, -0.09371109f, -0.06340279f, 
    0.42066258f, 0.25267953f, 0.31925121f, 0.27079701f, -0.27907169f, 0.49908546f, -0.46824944f, -0.58533263f, 
    -0.71044368f, -0.69205678f, -0.69357830f, -0.38989553f, -0.75419647f, -0.52405822f, -0.63259459f, -0.05568374f, 
    0.53211659f, -0.13641645f, -0.26833904f, -0.02537162f, -0.17470402f, 0.25811261f, -0.29760250f, -0.51265436f, 
    -0.37633574f, -0.62621790f, -0.12641412f, -0.26270092f, -0.58147418f, -0.61924887f, -0.01679159f, -1.36123633f, 
    -0.23739162f, 0.70145106f, 0.14128815f, -0.10468900f, -1.34330559f, -1.21639514f, -0.07069724f, -1.12828338f, 
    0.60235012f, 0.49262446f, -0.12800020f, 0.77566504f, -0.13248388f, 0.24559073f, -0.25833550f, -0.30575684f, 
    -0.60128951f, -0.19363101f, -0.20649000f, 0.20389099f, 0.02570903f, -0.11750670f, -0.15907755f, 0.19384377f, 
    -0.43053922f, 0.53947145f, 1.38672543f, 0.84392804f, -0.85167050f, -0.80359101f, -0.69898975f, -0.41442251f, 
    0.49764857f, -0.20888638f, 0.35284889f, -0.51043546f, 0.18829113f, 0.44519031f, 0.06051176f, -0.14330073f, 
    -0.04915928f, 0.23194912f, -0.02598440f, -0.00872610f, -0.20208456f, -0.13598204f, 0.12454394f, -0.32258928f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.11717398f, 0.41605070f, 0.57785690f, 0.70999885f, 0.56931424f, 0.50377184f, -0.13352643f, 0.37458953f, 
    0.39264637f, 0.79382628f, 0.35310587f, 0.23891658f, 0.46327037f, -0.37818244f, 0.54833144f, 0.53705096f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.61246216f, 0.26165792f, -0.00386323f, -0.29014757f, 0.24477074f, -0.03311398f, 0.28417513f, -0.05583457f, 
    -0.06289122f, -0.23343071f, -0.18490039f, 0.04893814f, -0.35581580f, 0.06891600f, 0.74395967f, -0.65801656f, 
    -0.37691277f, -0.22886923f, 0.13336889f, 0.07138586f, -0.16324106f, -0.30608714f, -0.09774014f, -0.17094527f, 
    0.36498910f, 0.27129614f, -0.46047309f, -0.26769406f, 0.10078822f, 0.15878783f, 0.04522732f, -0.04952303f, 
    -0.13511546f, -0.07175186f, 0.12740599f, -0.00221626f, -0.61570621f, -0.69222581f, -0.38169280f, 0.17772034f, 
    0.08893026f, -0.08186767f, 0.07179312f, -0.00355200f, -0.04182840f, -0.07587491f, -0.14806333f, 0.01695600f, 
    -0.00195188f, 0.05091149f, -0.29360569f, -0.02085472f, -0.04206810f, 0.01542909f, 0.02355751f, -0.02122917f, 
    -0.31229609f, -0.12346077f, -0.25487727f, -0.21684317f, 0.13746892f, -0.13186035f, -0.16689643f, 0.04441845f, 
    0.16361988f, 0.06821959f, 0.00384881f, -0.44012919f, 0.15195078f, -0.18903419f, -0.17297298f, -0.11174659f, 
    0.42457482f, 0.23047818f, -0.16506952f, -0.41625082f, 0.20200843f, 0.05568818f, 0.04662327f, 0.16814308f, 
    0.04660612f, 0.03262917f, 0.04154673f, 0.05314932f, 0.07575856f, -0.08017529f, -0.04542245f, -0.19483544f, 
    0.07055029f, 0.29523635f, -0.08586036f, -0.06494626f, -0.07699837f, -0.00794164f, -0.04635855f, -0.01342822f, 
    -0.82380170f, -0.59237570f, -0.34117398f, -0.14799927f, 0.13343748f, 0.13842100f, 0.13193160f, 0.01466539f, 
    -0.05493350f, 0.07588145f, 0.03833229f, 0.04792579f, -1.02025437f, -0.27885002f, 0.06951735f, -0.20764771f, 
    -0.12979013f, 0.10626911f, 0.08044712f, -0.05121643f, -0.03716153f, -0.09736254f, -0.12580790f, 0.02411401f, 
    0.63364607f, 0.12639298f, -0.04864929f, -0.35063523f, -0.13046250f, -0.04024258f, -0.07401758f, 0.03049355f, 
    -0.12317689f, 0.09575511f, -0.08650585f, 0.07560784f, 0.22963691f, 0.06763755f, -0.03169987f, -0.07648262f, 
    0.19129315f, 0.20460945f, 0.22354040f, 0.04226107f, -0.07741068f, -0.08716325f, -0.17217085f, 0.01310684f, 
    0.11592919f, 0.08651048f, 0.28390494f, -0.21170904f, 0.08081464f, -0.19197334f, -0.20422246f, -0.09794410f, 
    0.11880507f, -0.14278583f, -0.13134439f, -0.12538464f, 0.39664966f, 0.10874548f, -0.13259667f, -0.13942811f, 
    0.12009472f, -0.04871769f, -0.00760684f, 0.06701137f, -0.33202705f, -0.05077659f, -0.00296642f, 0.18279591f, 
    0.52269435f, 0.28641275f, -0.31984821f, -0.44139838f, -0.10025001f, -0.14080431f, -0.02679550f, -0.00910002f, 
    0.13842206f, 0.03269469f, -0.06844199f, -0.17903391f, -0.73837739f, 0.28241625f, 0.51289183f, -0.62928104f, 
    0.05889274f, -0.13650116f, -0.17448811f, -0.18242233f, 0.04343909f, 0.01606784f, 0.10532281f, 0.08630108f, 
    0.28859332f, 0.12701958f, 0.34863743f, 0.10543457f, -0.14634913f, -0.14566083f, -0.15982603f, 0.02480079f, 
    0.15712878f, -0.04598365f, 0.08477019f, -0.01363681f, -0.86865872f, 0.36718130f, 0.10469325f, -0.22110443f, 
    0.22052756f, 0.30656487f, -0.09655962f, -0.08628058f, 0.06260135f, -0.02287336f, -0.08189660f, 0.42604312f, 
    0.66515005f, -0.03395833f, 0.09376930f, -0.16845487f, 0.15996660f, -0.07189462f, -0.26160339f, -0.32408464f, 
    0.04226999f, 0.02943050f, -0.06444804f, -0.07553517f, 0.33136031f, 0.29433760f, 0.22051938f, 0.23523934f, 
    -0.10581908f, 0.06227130f, 0.10515101f, 0.01356041f, -0.08469049f, 0.12091332f, 0.05565441f, -0.03985566f, 
    0.56337452f, -0.12163758f, 0.11335711f, 0.21985649f, -0.11674575f, -0.07156072f, -0.10468525f, -0.06114564f, 
    0.13035573f, 0.02811386f, 0.08137219f, -0.03949412f, 0.46522701f, -0.20491330f, 0.37491232f, 0.14090644f, 
    -0.07960159f, -0.09674037f, 0.14168380f, 0.02744192f, 0.07827879f, -0.03560909f, 0.29387468f, -0.16005877f, 
    0.15013798f, 0.36325791f, 0.32039574f, -0.01423686f, -0.20759207f, 0.14642954f, 0.08208843f, -0.23919278f, 
    -0.10372632f, -0.07506520f, 0.02338436f, -0.02378861f, -0.33591017f, 0.14889699f, -0.09164824f, -0.12919079f, 
    -0.03942629f, 0.24666142f, -0.09878214f, -0.14715056f, -0.16035879f, -0.14807253f, 0.15449974f, -0.27835143f, 
    0.46714836f, 0.34931135f, 0.25235194f, -0.27176934f, -0.03863116f, -0.16511798f, -0.14598766f, 0.02058655f, 
    0.03123029f, -0.05625377f, 0.09718100f, 0.04467015f, 0.23102838f, 0.06435480f, 0.10108752f, 0.01814772f, 
    0.06945486f, -0.08271211f, 0.03997396f, 0.14044325f, -0.02007371f, 0.22121738f, -0.11268345f, -0.12359483f, 
    0.33461532f, 0.11793380f, -0.16529705f, -0.05668598f, 0.03391012f, -0.08363865f, 0.07318309f, -0.02489087f, 
    -0.13211709f, -0.42198119f, -0.49943665f, -0.43690369f, -0.31157410f, 0.03437664f, -0.30430824f, -0.14626965f, 
    -0.07332376f, 0.02612509f, 0.02739744f, -0.17439115f, 0.07594208f, 0.01071707f, -0.09457790f, -0.09601709f, 
    -0.47233415f, -0.14464480f, -0.01763057f, -0.08649360f, 0.01297893f, -0.11118577f, 0.15352024f, 0.36025748f, 
    -0.12922619f, -0.05883229f, 0.33187726f, -0.11420934f, 0.21222779f, -0.01677279f, -0.16662732f, -0.21689753f, 
    -0.17321151f, 0.20449731f, -0.14794785f, 0.27443829f, 0.02436738f, 0.16781253f, -0.13111986f, 0.12415400f, 
    -0.86976033f, -0.11432688f, -0.62811315f, -0.05501171f, -0.06356478f, -0.04010867f, 0.25544813f, 0.28390270f, 
    0.01899509f, -0.05079688f, 0.01799678f, 0.09808858f, -0.21265297f, 0.29334146f, -0.24927363f, -0.06865314f, 
    -0.14512479f, -0.09009650f, -0.10920151f, 0.00836087f, -0.01628937f, -0.01109248f, -0.05923830f, -0.08537730f, 
    -0.57889247f, 0.07743448f, 0.29532078f, -0.02256358f, 0.04387432f, 0.03449855f, 0.26191530f, 0.16627038f, 
    -0.04462895f, 0.02361506f, 0.07390355f, -0.26622948f, 0.78941375f, 0.06328911f, -0.58497006f, 0.19932570f, 
    0.05810265f, 0.14346400f, -0.01799540f, 0.13608798f, -0.00825275f, 0.00323692f, -0.31099039f, -0.07038732f, 
    0.38305154f, -0.68205673f, 0.60288495f, 0.49619636f, 0.06463964f, 0.04374688f, -0.11010421f, 0.18264788f, 
    0.12908949f, 0.19467664f, -0.11130805f, 0.15941931f, -0.32246813f, 0.19148566f, -0.06336158f, -0.58751726f, 
    -0.04786297f, -0.03212295f, -0.06380814f, 0.12796904f, 0.04348996f, -0.12329195f, 0.21839686f, -0.26577079f, 
    0.07270558f, -0.01181602f, -0.32256100f, -0.13969050f, 0.09107216f, -0.23564824f, 0.06659979f, 0.19579560f, 
    -0.00737126f, 0.05716075f, 0.10317629f, 0.13162890f, -0.08314728f, -0.17407799f, 0.29917973f, 0.24628885f, 
    -0.10154847f, 0.03791833f, 0.06901889f, -0.09213091f, 0.05622314f, -0.08755740f, -0.04361759f, -0.34579983f, 
    -0.80160421f, -0.16632712f, -0.30024895f, -0.35363299f, -0.38002497f, -0.01873154f, 0.08595884f, -0.17258461f, 
    0.00534495f, -0.08673804f, 0.00380614f, -0.08488234f, 0.45578796f, 0.34189492f, 0.25505692f, 0.72213262f, 
    -0.06456039f, -0.08702621f, 0.04055711f, 0.12052765f, 0.22103594f, -0.29638076f, 0.18347843f, 0.08562402f, 
    -0.88020706f, 0.10627064f, 0.37088636f, -0.72831583f, -0.01961870f, -0.12560801f, -0.07805836f, 0.15541123f, 
    -0.02652663f, -0.07239466f, -0.00298852f, 0.00348052f, 0.02696293f, -0.33526388f, -0.31261137f, 0.15925936f, 
    0.05899425f, 0.01906506f, 0.11378244f, 0.04526981f, -0.05539123f, 0.09498142f, -0.03211465f, 0.21955255f, 
    0.02331665f, -0.06928775f, -0.07270169f, 0.13301471f, 0.02598650f, -0.06418625f, -0.07944024f, 0.01779975f, 
    0.12913446f, 0.05780472f, 0.22846663f, 0.11575380f, -0.56131864f, 0.65311307f, 0.14153554f, 0.20050496f, 
    -0.01926673f, 0.13264371f, 0.01174881f, -0.04791158f, -0.02719766f, 0.11694825f, 0.05281722f, 0.17200950f, 
    0.07628009f, 0.03155080f, -0.27281454f, 0.08372434f, 0.05450889f, -0.31590551f, -0.01460564f, -0.05180739f, 
    -0.21924958f, 0.02372724f, -0.05656957f, -0.01226790f, -0.89809233f, 0.06019747f, -0.00432446f, -0.18215220f, 
    -0.08266667f, 0.21305275f, -0.04990740f, -0.47537231f, 0.04105337f, -0.07355372f, -0.17606109f, 0.06620263f, 
    -0.87710541f, -0.26085445f, -0.14829858f, -0.30258122f, 0.05942557f, -0.17727607f, 0.00233674f, -0.15203291f, 
    -0.09598134f, 0.01154856f, 0.03959829f, -0.11330618f, -0.44003582f, 0.19419929f, -0.12229189f, 0.24702370f, 
    -0.09564719f, -0.05870348f, -0.02929907f, -0.00756051f, 0.01024068f, 0.10673790f, -0.08020033f, -0.00006028f, 
    -0.44806063f, 0.25174969f, -0.22052167f, 0.41511920f, 0.13740523f, 0.02463731f, -0.04859279f, 0.02809266f, 
    -0.16046450f, 0.02893549f, 0.01291239f, -0.07414240f, 0.78777975f, 0.22908270f, 0.01446297f, -0.68319643f, 
    0.10967994f, -0.19068177f, -0.14430586f, -0.35173309f, 0.10761141f, 0.29453513f, -0.23196666f, -0.06390456f, 
    -0.02601842f, -0.36130625f, -0.21231724f, 0.19631757f, 0.18858175f, -0.20198244f, 0.00852176f, -0.29025862f, 
    -0.18902889f, 0.06291760f, -0.01493828f, 0.02417135f, -0.79464799f, -0.21030577f, 0.80709523f, -0.45261943f, 
    -0.32034022f, -0.23054498f, -0.35953000f, -0.06838779f, -0.05139232f, -0.15407252f, 0.29133934f, -0.24008298f, 
    -0.35888934f, -0.16875294f, -0.27754876f, -0.23653138f, 0.25512943f, 0.14173673f, -0.03770059f, 0.20270294f, 
    -0.36729330f, -0.15617459f, -0.13074887f, -0.38227794f, -0.22190544f, 1.12283659f, -0.32842070f, -0.22669800f, 
    0.15889814f, -0.05735195f, 0.06800687f, -0.39240110f, -0.12382785f, 0.05018250f, -0.15954472f, 0.14536978f, 
    0.04699897f, -0.19377288f, -0.14579125f, 0.43272534f, -0.08060054f, 0.12263180f, 0.11962702f, -0.08666476f, 
    0.16777730f, 0.07531997f, -0.08900680f, -0.12073440f, 0.72433704f, -0.44937256f, 0.13318488f, 0.40169552f, 
    0.09630769f, 0.23191845f, 0.08045258f, 0.02314874f, 0.02175518f, -0.01303575f, 0.15378523f, 0.01388983f, 
    -0.98611361f, 0.01240765f, 0.13178012f, 0.20531267f, -0.23867597f, -0.02255511f, -0.18855150f, 0.04792363f, 
    0.05995638f, 0.15318334f, -0.17691329f, 0.07992773f, 0.68813229f, -0.23433442f, -0.24983278f, -0.79459906f, 
    -0.50997585f, -0.24345054f, -0.41218373f, -0.11289516f, -0.31515816f, -0.13192855f, 0.25421047f, -0.40815681f, 
    -0.27977493f, 0.63596976f, -0.05867566f, -0.20173763f, 0.02041480f, 0.19072983f, -0.07337743f, -0.06931248f, 
    -0.27272424f, -0.05644291f, 0.19952343f, 0.07490692f, 0.09659453f, -0.32514125f, -0.46584922f, 0.39090019f, 
    0.38831636f, 0.27116379f, 0.14168136f, -0.12837231f, -0.09774654f, 0.08682325f, 0.13862750f, 0.02602273f, 
    0.28639632f, 0.48376057f, 0.11700698f, -0.62662685f, -0.03574977f, 0.01732224f, -0.10944217f, -0.04574614f, 
    0.09085569f, -0.19428614f, -0.11797369f, 0.16149507f, -0.19392270f, -0.20558305f, 0.07725028f, 0.50011241f, 
    -0.19890042f, 0.02795882f, 0.00077919f, 0.21447872f, 0.10067099f, 0.13512172f, -0.05474916f, 0.07010686f, 
    0.03959399f, -0.04684717f, -0.28810427f, 0.31849653f, 0.13252254f, 0.01820254f, 0.01808433f, 0.32240924f, 
    -0.26984903f, 0.07263497f, 0.11575166f, -0.03385594f, 0.03834572f, 0.47178912f, -0.32904726f, 0.40396443f, 
    0.06160444f, -0.30678302f, 0.20476942f, -0.18126881f, 0.03049280f, 0.20240904f, -0.05448810f, 0.25059161f, 
    -0.12301902f, -0.15520947f, -0.11192571f, 0.06694382f, -0.18721741f, 0.13597324f, -0.11927579f, -0.12993234f, 
    -0.06141536f, 0.14169085f, -0.24291928f, 0.05222250f, -0.03213989f, -0.02816412f, -0.52844352f, -0.16106693f, 
    -0.39657730f, -0.09992995f, 0.33041653f, -0.08711179f, -0.11071291f, -0.06865541f, -0.03102698f, -0.30032158f, 
    -0.16340959f, -0.00922671f, -0.20714241f, 0.14439721f, -0.04585349f, -0.18236762f, -0.19400878f, -0.33567432f, 
    -0.10977381f, 0.00435199f, 0.04772792f, 0.07269049f, -0.16730686f, -0.33847618f, -0.37893438f, 0.13305233f, 
    0.09047786f, 0.07648984f, -0.04258446f, -0.08301535f, -0.04732338f, -0.04489966f, -0.08703677f, -0.14319938f, 
    0.16301161f, -0.03475083f, 0.04736351f, -0.19643795f, 0.17350334f, 0.10407289f, 0.08951274f, -0.07555018f, 
    -0.05714799f, -0.18933499f, -0.07089145f, 0.02401556f, 0.16571109f, -0.72169715f, -0.35822451f, -0.08621331f, 
    -0.06889988f, 0.13200301f, -0.13579176f, -0.06950084f, 0.14061967f, -0.08268150f, -0.09588704f, -0.23542275f, 
    -0.01839490f, 0.16452481f, 0.25129032f, 0.11553551f, -0.05218359f, -0.04799644f, 0.03762076f, 0.12422049f, 
    0.11762961f, 0.04747238f, 0.02422024f, -0.11074194f, -0.21124682f, 0.20975754f, 0.10956569f, 0.12402979f, 
    -0.17869714f, -0.27340108f, -0.04728944f, -0.06492029f, 0.06590800f, -0.10535327f, -0.14567780f, 0.17876142f, 
    0.46225128f, -0.64586288f, -0.08142020f, 0.30973908f, 0.12287878f, 0.04578660f, 0.18688999f, 0.00940254f, 
    0.15578413f, 0.22137634f, 0.19074760f, -0.08762131f, -0.63895625f, -0.45955938f, 0.16008788f, -0.28999072f, 
    0.06324139f, 0.00519875f, -0.02064009f, -0.04540035f, 0.12681605f, -0.15420777f, -0.01935978f, -0.06457893f, 
    0.14421095f, -0.33699271f, 0.03688046f, 0.04262502f, -0.14157329f, -0.13204716f, -0.04260278f, -0.21849473f, 
    0.00350949f, 0.39494863f, 0.17107187f, 0.42911947f, -0.32557094f, -0.07564910f, 0.13524167f, 0.01584104f, 
    -0.05196524f, 0.08782782f, -0.03656773f, 0.18595046f, 0.09870230f, -0.12286230f, -0.16993032f, -0.01723532f, 
    0.10152618f, -0.17745633f, -0.19997951f, 0.23796687f, 0.05764192f, 0.03950142f, -0.21531850f, -0.16165245f, 
    -0.03627871f, -0.14672394f, -0.41150099f, 0.03391058f, 0.22084290f, 0.29263926f, 0.36769348f, 0.26809567f, 
    0.17472024f, -0.02955977f, 0.09505998f, -0.03031294f, 0.03194875f, -0.14976841f, 0.27038777f, -0.00885921f, 
    0.33086288f, 0.28761858f, 0.81435531f, 0.02090982f, -0.14381711f, 0.07212511f, -0.17674799f, 0.06976706f, 
    -0.06211955f, -0.06376036f, -0.09769709f, -0.02580243f, 0.00104405f, -0.25990763f, 0.31671476f, 0.58980483f, 
    -0.34916222f, 0.05529221f, 0.10450190f, 0.04896839f, 0.00464447f, 0.05533722f, 0.08405268f, 0.18641305f, 
    0.06114428f, 0.34180796f, 0.24367292f, -0.25665674f, 0.06507786f, 0.04181356f, 0.00730902f, 0.01727177f, 
    -0.01919691f, 0.09567656f, 0.04950268f, 0.21582362f, -0.41917744f, -0.46203959f, 0.24620740f, 0.61299026f, 
    0.13462023f, -0.27690822f, -0.05726461f, 0.25683078f, 0.09669852f, 0.05726152f, 0.05487725f, 0.05196062f, 
    -0.46806556f, 0.40106130f, 0.21076201f, -0.36006111f, -0.04293256f, -0.02187407f, 0.12214714f, 0.53160369f, 
    0.05691408f, -0.09055188f, -0.06085056f, -0.02985251f, -0.01453062f, 0.13360824f, -0.43777338f, -0.13810706f, 
    0.01138749f, 0.07759438f, 0.06717022f, 0.05250915f, 0.22020993f, 0.06003150f, -0.11521795f, 0.24215963f, 
    -0.47330779f, -0.20155674f, -0.47771943f, 0.15769802f, 0.13149540f, -0.08546235f, -0.04413807f, -0.19471075f, 
    0.15727560f, 0.21123399f, -0.15657559f, -0.01056198f, 0.05802334f, -0.01013784f, -0.11074593f, -0.23677646f, 
    -0.02720743f, -0.00924573f, -0.00248936f, 0.13445060f, -0.01301271f, 0.22044012f, -0.05919676f, -0.03501310f, 
    0.12909305f, 0.09183711f, 0.01327811f, 0.03286004f, 0.37171212f, 0.17770232f, -0.09107444f, 0.02462348f, 
    -0.01996305f, 0.09093990f, 0.10060630f, 0.17445089f, -0.65852094f, -0.33274370f, -0.34121740f, -0.27359292f, 
    0.04407271f, -0.09853751f, 0.10230666f, 0.09455917f, 0.13269158f, 0.27689773f, -0.20645349f, -0.22344044f, 
    0.02032980f, -0.31836441f, -0.58380359f, 0.48847985f, 0.11438453f, 0.02119964f, 0.02983919f, 0.06133688f, 
    -0.04473405f, -0.13396539f, -0.16542985f, 0.11092470f, -0.20964146f, 0.06545981f, -0.12399974f, 0.48663577f, 
    0.06553090f, 0.11420198f, -0.07052994f, -0.07663177f, 0.15320887f, 0.01425498f, 0.02762385f, 0.29454634f, 
    -0.26015890f, -0.08230031f, 0.31742132f, 0.08032458f, 0.00363571f, 0.00006674f, 0.01731396f, -0.07118435f, 
    0.17003560f, -0.44447845f, -0.32904804f, -0.25255617f, -0.07708210f, -0.82734984f, -0.12056062f, -0.27394781f, 
    -0.13453746f, -0.25586489f, -0.13109322f, 0.10565444f, -0.05800732f, -0.19760419f, 0.05120165f, 0.03326971f, 
    -0.04071553f, -0.16181341f, 0.25703248f, 0.22557463f, -0.20539856f, 0.24938607f, 0.09018201f, 0.00204496f, 
    0.10467128f, 0.29122373f, -0.13570444f, 0.07501478f, 0.14336340f, 0.08228171f, 0.01003336f, -0.09836039f, 
    0.02853369f, -0.07375781f, -0.10958008f, -0.27017248f, 0.03803501f, -0.33399838f, 0.02494509f, -0.19477944f, 
    0.41143444f, 0.17235126f, 0.07336184f, -0.27293235f, 0.04037364f, 0.04492176f, 0.03192314f, -0.45307118f, 
    0.01694744f, -0.12996182f, -0.03743022f, -0.10454012f, -0.12758154f, -0.49539101f, 0.47751087f, -0.14060707f, 
    0.35896802f, -0.01031826f, -0.13639869f, 0.12836173f, 0.00551116f, 0.07828066f, -0.06779513f, -0.02380314f, 
    -1.03771782f, -1.62604690f, -0.84812164f, 0.53748274f, -0.00398867f, 0.00336763f, -0.01780684f, -0.46394828f, 
    -0.08935300f, 0.02127438f, 0.07161365f, -0.17241846f, -0.13081896f, -0.29675367f, -0.04559678f, 0.52574152f, 
    -0.21585956f, -0.08367107f, 0.05494421f, 0.14387813f, -0.00910018f, 0.05941049f, 0.22163360f, -0.32799169f, 
    -0.63880026f, -0.60960287f, 0.21017316f, 0.31488240f, -0.36625642f, 0.27706742f, 0.44840038f, 0.03057160f, 
    -0.02188357f, -0.07969657f, 0.20527603f, -0.02751093f, 0.18935426f, -0.13045505f, 0.10927359f, -0.03267237f, 
    0.20368008f, 0.15485612f, -0.07878602f, -0.07185441f, 0.12309648f, -0.07575212f, -0.02285666f, 0.22730951f, 
    -0.02932184f, -0.02851605f, 0.16365747f, -0.12400827f, 0.14448638f, 0.06706018f, 0.12041411f, -0.22437868f, 
    0.15908024f, 0.03017180f, 0.05119261f, -0.11351395f, -0.60493672f, 0.37045228f, -0.07377621f, -0.05850663f, 
    0.08036822f, -0.02919465f, -0.19529818f, 0.00637311f, 0.16225135f, 0.23241916f, 0.11951692f, 0.08634210f, 
    -1.13269472f, -1.22511280f, -0.80152994f, -0.46631986f, -0.27799189f, -0.41261446f, -0.30302656f, -0.37784544f, 
    0.02723758f, 0.00591821f, -0.13734816f, -0.08986052f, -0.32688555f, 0.37315828f, 0.65949219f, 0.18695168f, 
    -0.13637009f, 0.11843702f, -0.05284656f, -0.00025777f, -0.06761981f, 0.09674688f, 0.02800740f, 0.26756856f, 
    0.24295090f, -0.14599083f, -0.52876711f, -0.19175030f, 0.08019459f, 0.15152611f, 0.12595183f, -0.18536709f, 
    -0.01822411f, -0.00873607f, -0.08043861f, 0.13820364f, 0.14461862f, 0.09697953f, 0.10144901f, 0.28079206f, 
    -0.08799887f, 0.05954262f, 0.00124499f, 0.18146378f, -0.08395702f, 0.06369297f, 0.18190649f, -0.18457468f, 
    -0.11780773f, -0.24616177f, 0.29844928f, -0.31674612f, -0.05371667f, 0.15540963f, 0.08682505f, 0.14848757f, 
    0.17665406f, 0.40243104f, 0.26961309f, 0.19533788f, -0.48906556f, 0.75680435f, 0.22215211f, 0.22457637f, 
    -0.20373186f, -0.16709204f, -0.19657564f, 0.43908751f, 0.06301624f, 0.23487015f, 0.14771034f, 0.11887087f, 
    -0.28413451f, -0.31455323f, -0.39588082f, 0.24247354f, -0.12530766f, 0.05561852f, -0.26012924f, -0.25165382f, 
    0.19744301f, -0.16943291f, 0.10380046f, -0.17901517f, -0.28278440f, -0.29404685f, -0.68885088f, -0.14994900f, 
    -0.19185874f, 0.30388170f, 0.17952688f, -0.31743208f, -0.05002604f, 0.01691165f, 0.09837454f, 0.03533560f, 
    -1.18895173f, -0.52290624f, -0.05605983f, 0.17559306f, 0.12248781f, -0.15741825f, -0.41164714f, -0.43432483f, 
    0.09673614f, -0.00608481f, 0.17122336f, 0.13776119f, -0.34057927f, -0.55828673f, -0.88072991f, 0.26270247f, 
    0.07008460f, 0.25505811f, 0.18729398f, 0.13568470f, -0.06054351f, -0.20108692f, 0.01813939f, -0.02435460f, 
    -0.13101169f, -0.41834995f, 0.52786356f, -0.30931786f, -0.25687337f, -0.13801244f, 0.08151527f, 0.42175308f, 
    -0.08124257f, -0.07049263f, -0.22541484f, 0.18318236f, 0.68564153f, -0.02871236f, -0.16785166f, 0.23675996f, 
    0.00670012f, 0.12904608f, -0.17708084f, -0.05002951f, -0.15395068f, 0.22864030f, -0.15509568f, -0.03817546f, 
    -0.09628332f, -1.17157936f, -0.04701887f, -0.25260901f, -0.01373674f, -0.10218655f, 0.13347811f, 0.11335640f, 
    0.14124723f, -0.07592416f, -0.06787544f, -0.11542708f, -0.06804314f, 0.05054733f, 0.18998343f, -0.42054588f, 
    -0.06364899f, -0.03411579f, -0.09733218f, -0.06634025f, 0.07345312f, -0.00698613f, -0.08353911f, -0.25323138f, 
    0.04648137f, 0.22314304f, -0.11426008f, 0.07429966f, 0.05005302f, -0.00510364f, 0.02973426f, -0.02894456f, 
    -0.20955746f, -0.03721462f, -0.26316398f, -0.21405452f, 0.31936583f, -0.32786849f, 0.43602833f, -0.49894387f, 
    -0.10206064f, 0.05829858f, -0.02087030f, -0.01698364f, 0.02340428f, 0.10597479f, 0.09762654f, 0.03367349f, 
    -0.55173498f, -0.53744203f, -0.53199250f, 0.29029137f, 0.03712165f, -0.15292555f, 0.07890984f, 0.25492713f, 
    0.04505877f, -0.01812334f, 0.03842479f, 0.06676984f, 0.84070730f, -1.02178347f, -0.44508907f, -1.11083543f, 
    -0.08638109f, -0.04875642f, -0.19022530f, 0.06811281f, 0.10011342f, 0.00937201f, 0.07433897f, 0.08250110f, 
    -0.02198927f, 0.17653573f, 0.10590473f, -0.20487243f, 0.04139046f, 0.08602295f, -0.02434200f, 0.04102314f, 
    0.09592769f, 0.15212862f, 0.07298329f, 0.03701324f, -0.11483975f, 0.15103033f, 0.20789371f, 0.00158246f, 
    -0.11203197f, -0.04978903f, -0.14489432f, -0.10259527f, 0.08732998f, -0.19954123f, -0.34940565f, -0.24886484f, 
    0.34188905f, -0.28199533f, 0.12403286f, -0.58598071f, -0.06570460f, -0.09881732f, -0.18391548f, 0.14819172f, 
    0.04322939f, 0.19653104f, 0.07387967f, -0.03145365f, 0.79457670f, -0.57836539f, -0.16729264f, -0.38113758f, 
    -0.00485067f, -0.22103430f, 0.07680869f, -0.21413048f, -0.01067152f, 0.03891625f, -0.03694535f, -0.14106439f, 
    0.46878156f, 0.08991765f, 0.27523801f, -0.00447338f, -0.46536079f, 0.13781266f, -0.13568035f, -0.06438656f, 
    -0.05181028f, 0.11296346f, 0.08650564f, 0.02117004f, -0.94028294f, -0.32099470f, -0.31249222f, 0.35276058f, 
    0.04095030f, -0.13106260f, 0.21574567f, -0.02212174f, 0.17393148f, -0.01632874f, 0.06220030f, -0.25598302f, 
    -0.79793733f, -0.86325502f, 0.91846550f, 0.39177853f, 0.09744730f, 0.04430599f, 0.11019407f, -0.03424898f, 
    0.00194613f, -0.04956204f, 0.09222923f, -0.07817221f, 0.12976001f, -0.73996413f, 0.10778146f, -0.18300779f, 
    0.01135190f, 0.01696811f, -0.03650139f, -0.21698725f, 0.13646163f, 0.04227887f, 0.02375828f, -0.00241780f, 
    0.26986384f, -0.16059422f, -1.05103493f, -0.92435688f, -0.20785320f, -0.28841102f, 0.27271503f, -0.07205652f, 
    0.01511020f, -0.09755842f, 0.05949914f, -0.00486342f, 0.80463248f, 0.19259115f, -0.70517772f, -0.24219772f, 
    0.45387024f, -0.16469710f, -0.04665997f, 0.05745828f, 0.31912479f, -0.13521822f, 0.39038450f, 0.20910627f, 
    0.07118965f, -0.43399101f, 0.17708588f, 0.31233799f, 0.04323781f, 0.35442689f, 0.25158662f, -0.04047249f, 
    -0.17600009f, -0.04663163f, -0.01439611f, -0.07383408f, 0.12568547f, 0.03635957f, -0.27363840f, 0.02007014f, 
    -0.07490226f, -0.11465222f, -0.06483059f, 0.03683510f, -0.01165504f, 0.05087299f, -0.08738466f, -0.00710331f, 
    -0.45440263f, -0.24308810f, 0.17307907f, -0.22619562f, -0.31314874f, 0.03460481f, 0.06271284f, 0.02870104f, 
    0.14893234f, 0.18427709f, 0.20896728f, 0.19631645f, -0.33753955f, -0.44374585f, -0.35584396f, -0.22709543f, 
    -0.21700582f, 0.12907550f, 0.17864218f, 0.11189280f, 0.05168878f, -0.07180563f, -0.02276294f, 0.39435297f, 
    -0.16011286f, -0.89132625f, -0.34095973f, 0.38799095f, -0.05678758f, -0.18757938f, 0.09535054f, -0.09329609f, 
    -0.09633669f, -0.02155213f, 0.14129940f, 0.14758368f, -0.32936633f, -0.66772979f, -0.26226309f, 0.26720425f, 
    0.11804265f, 0.20562628f, 0.12065674f, 0.42327952f, -0.18621981f, 0.21841715f, -0.12798980f, -0.08836664f, 
    -0.28046781f, 0.25450629f, 0.05360802f, 0.09896963f, -0.24966988f, -0.17964385f, -0.18392812f, -0.07482960f, 
    -0.27591404f, -0.11173270f, -0.09013379f, -0.02841818f, 0.22769088f, 0.22738983f, -0.05239489f, -0.46665192f, 
    0.14690831f, -0.13108452f, 0.01935996f, 0.14094019f, -0.06610467f, -0.00420962f, 0.06762186f, 0.16301019f, 
    0.03725210f, 0.14777875f, -0.37132752f, -0.55756086f, 0.04489321f, -0.01050809f, 0.31237733f, 0.10566292f, 
    0.02888657f, -0.00215332f, -0.30075851f, -0.51719916f, -0.14700013f, -0.60742104f, -0.32579094f, -0.22947519f, 
    -0.07060459f, 0.06663991f, 0.16756144f, 0.09681287f, 0.15731019f, 0.03178849f, -0.04552143f, -0.02642055f, 
    0.34647992f, -0.14610744f, -0.00449343f, -0.52569366f, 0.18304534f, -0.14007601f, 0.09676447f, -0.08145223f, 
    -0.05795490f, 0.40233144f, 0.16903740f, 0.29603329f, -0.55170786f, -0.34732538f, -0.28069130f, -0.15316194f, 
    0.12709181f, 0.10716537f, 0.06974701f, -0.06927992f, -0.12459991f, 0.03581447f, -0.08840389f, -0.13285291f, 
    0.66480488f, -0.98277318f, -0.20561244f, -0.34067822f, -0.07736962f, 0.01030969f, 0.23052965f, 0.27077663f, 
    0.14174204f, 0.11016149f, -0.09595262f, 0.04618266f, 0.70472002f, 0.31861049f, 0.30466986f, -0.20173378f, 
    -0.06629252f, -0.20424201f, -0.04764372f, -0.40191999f, 0.02327998f, -0.00124520f, -0.02308244f, -0.12848268f, 
    -0.02934768f, -0.28905398f, 0.42740145f, 0.10371436f, -0.29301202f, 0.12305922f, 0.03744368f, 0.20195456f, 
    0.13919608f, 0.07563248f, 0.21482149f, -0.13972953f, -1.26744473f, -0.11090627f, -0.35458446f, 0.37040713f, 
    -0.43424451f, -0.10880443f, -0.02062537f, -0.21769100f, 0.23483397f, 0.02609563f, -0.16679609f, -0.01318918f, 
    -0.05828661f, -0.42112410f, 0.01073643f, -0.88186997f, -0.34348235f, 0.18426093f, -0.21534096f, -0.14084978f, 
    0.31342971f, -0.13648179f, 0.15672705f, 0.04447198f, 0.10173478f, -0.44413561f, 0.07693338f, 0.03808949f, 
    -0.07278578f, 0.10798748f, -0.08530619f, -0.09825094f, 0.00768125f, 0.06904931f, -0.12528944f, 0.02094883f, 
    -0.12314210f, 0.17568094f, 0.27099174f, 0.07330912f, 0.15833203f, 0.15024403f, -0.19809484f, 0.07491370f, 
    0.12014222f, -0.00657058f, 0.13032317f, 0.17047165f, 0.59725547f, -0.79713756f, 0.36895949f, 0.15401717f, 
    0.18712114f, -0.21955144f, -0.19026868f, -0.00731963f, -0.44466186f, -0.08130879f, -0.09161911f, 0.13317738f, 
    -0.18124068f, 0.37002897f, -0.35362673f, -0.71210623f, -0.10548630f, -0.22600789f, 0.27028149f, 0.34727830f, 
    0.00473964f, -0.00860385f, -0.05730052f, -0.08874879f, -0.42804244f, 0.38950351f, -0.27356842f, -0.10287733f, 
    -0.26174498f, -0.37362036f, -0.15218730f, -0.16377008f, 0.27249882f, -0.13971265f, 0.15786345f, 0.25745839f, 
    -0.28982091f, -0.73595476f, -0.30590895f, 0.07485422f, -0.10838026f, 0.37837455f, 0.15999556f, 0.03666864f, 
    0.03955122f, 0.03380734f, -0.07235198f, -0.09236639f, -0.44463497f, 0.23344363f, -0.50073999f, 0.01138178f, 
    0.25258169f, -0.14628324f, 0.12888974f, -0.23191237f, 0.26537067f, -0.12167275f, 0.15146133f, -0.13272639f, 
    -0.34779784f, -0.32574669f, -0.09211861f, 0.54045123f, 0.01761833f, 0.21462727f, -0.04618321f, -0.05806285f, 
    -0.05434749f, 0.24762601f, 0.24265790f, 0.12428525f, 0.76978767f, 0.13831295f, 0.90903211f, 0.26767823f, 
    0.10441034f, -0.59458601f, 0.03683648f, -0.38391778f, -0.08561487f, -0.13347080f, 0.07438195f, 0.21158293f, 
    0.31375387f, -0.27517679f, -0.30061072f, 0.26686481f, 0.05555379f, 0.23419580f, -0.15419218f, 0.18537101f, 
    0.06376222f, -0.39489961f, -0.05863015f, -0.07061683f, -0.26104057f, 0.23234420f, 0.25250429f, -0.58584410f, 
    -0.15959060f, -0.21917616f, 0.24695604f, 0.22832380f, 0.07411017f, 0.20141141f, -0.07452594f, 0.01571171f, 
    0.42079812f, -0.18823902f, -0.13672824f, 0.19855000f, -0.00403475f, -0.11338021f, -0.01621806f, 0.09857778f, 
    0.07157476f, 0.01756754f, -0.05225951f, -0.16453904f, 0.23787072f, -1.10915542f, -0.00899545f, -0.22500420f, 
    0.16461527f, 0.35059157f, 0.14521906f, 0.07182173f, -0.04891187f, -0.13958393f, 0.00272887f, -0.13873327f, 
    -0.24087957f, -0.66445512f, -0.73793232f, 0.13685533f, -0.06093582f, 0.18280761f, -0.30225453f, -0.07515956f, 
    0.08822127f, 0.02386553f, 0.05800544f, -0.21321592f, 0.07287519f, -0.08978304f, 0.34236026f, -0.68924534f, 
    -0.41704142f, 0.37274271f, -0.08814307f, 0.32322606f, -0.10290235f, 0.03693684f, 0.07019592f, 0.21751380f, 
    -0.19666561f, 0.23515527f, 0.43470439f, 0.31854966f, 0.08969835f, -0.15847714f, 0.07158909f, 0.16281785f, 
    -0.23154429f, 0.07544988f, 0.03212808f, -0.19392172f, 0.05903600f, -0.18335937f, -0.42801556f, 0.59499151f, 
    -0.21376872f, -0.17743525f, -0.00012106f, -0.17152855f, 0.17277309f, 0.20027827f, -0.20179424f, 0.18810214f, 
    0.10134652f, -0.31120202f, 0.36418140f, -0.09980811f, -0.37344044f, 0.05906230f, -0.00123009f, 0.15240322f, 
    -0.12291766f, -0.04988039f, 0.07613924f, 0.32475784f, -0.53203881f, 0.92218083f, -0.65802789f, 0.46207497f, 
    0.10079877f, 0.16203582f, -0.12481419f, 0.44439742f, 0.01411591f, 0.27181846f, 0.26467136f, 0.50585181f, 
    -0.22153151f, -0.51572430f, 0.38786510f, 0.44036415f, -0.08075447f, 0.13552903f, -0.10128342f, 0.09795462f, 
    0.16042611f, -0.05355986f, 0.17401695f, 0.23759320f, 0.46343642f, 0.40242088f, 0.15890037f, -0.43373773f, 
    0.15623471f, -0.45347708f, 0.01563691f, 0.24134368f, -0.28491598f, 0.41729125f, -0.35056478f, -0.36844125f, 
    -0.13299620f, 0.21803163f, -0.14325871f, -0.27793398f, -0.31740952f, -0.16501597f, -0.37520951f, -0.21550837f, 
    -0.05068418f, 0.09679838f, 0.10088693f, -0.08727624f, 0.01431182f, 0.51642710f, 0.25477573f, -0.00652585f, 
    -0.22779097f, 0.00444162f, 0.35869360f, -0.06297169f, -0.17133513f, -0.01290831f, -0.67738575f, 0.20615557f, 
    0.01421021f, 0.94512576f, -0.31570211f, -0.05929824f, 0.02786136f, 0.00513636f, 0.15932935f, 0.10421893f, 
    -0.24488491f, -0.47171322f, -0.62624478f, -0.53455740f, -0.45621490f, -0.05214447f, -0.00458565f, 0.00973522f, 
    -0.14483486f, -0.13046028f, 0.03904829f, -0.10674417f, 0.02832893f, 0.07727329f, -0.15916599f, -0.26946399f, 
    -0.34790897f, 0.25111687f, -0.40152755f, -0.06775028f, -0.01983277f, 0.09880874f, -0.00835242f, -0.19971222f, 
    -0.07060792f, 0.25631943f, -0.13381217f, 0.21924578f, -0.40054080f, 0.03038817f, -0.05520481f, -0.05719621f, 
    0.10128520f, -0.10706619f, -0.01198613f, 0.25875250f, -0.09093380f, 0.27451986f, -0.39998001f, -0.27559313f, 
    -0.66075683f, 0.56364143f, -0.34608793f, 0.37363958f, 0.15730758f, 0.13113007f, 0.07378540f, 0.00814857f, 
    -0.39424458f, 0.23596719f, -0.10621677f, -0.03307471f, -1.04124749f, -0.13284566f, 0.04185651f, -0.08583672f, 
    -0.20553981f, 0.16661009f, -0.08005951f, -0.11743475f, -0.04361370f, -0.18105939f, 0.09566306f, -0.16889744f, 
    -0.18374136f, -0.85337138f, -0.08329108f, 0.38803241f, -0.06047726f, 0.07152030f, -0.02484470f, -0.16639419f, 
    -0.07274054f, 0.11363842f, 0.13022411f, 0.04642186f, -0.15921243f, -0.49223554f, 0.17447060f, -0.32630077f, 
    0.46322206f, -0.03109252f, 0.12733157f, 0.09443494f, -0.09215252f, 0.19346245f, 0.33217314f, -0.04976412f, 
    -0.47236705f, 1.09356236f, -0.64363003f, 0.39027116f, -0.19555226f, -0.03815516f, 0.41119367f, -0.23517978f, 
    -0.00193176f, 0.08824056f, 0.04604623f, -0.05695102f, 0.15424420f, 0.23367880f, 0.28408885f, 0.31092352f, 
    0.04164442f, 0.06937610f, -0.01192673f, 0.12256143f, -0.11482041f, -0.08037112f, 0.40636966f, 0.24411868f, 
    -0.35073534f, 0.10858594f, -0.26952079f, -0.06509642f, -0.01295748f, 0.07766531f, 0.08139227f, 0.03031649f, 
    -0.17194557f, 0.07778195f, 0.08497303f, -0.05052749f, -1.06835961f, 0.27535611f, -1.05171525f, 0.64858860f, 
    0.12579808f, -0.15739816f, 0.22359154f, 0.26507756f, -0.32118520f, -0.18184006f, -0.17887372f, -0.09433299f, 
    0.06732751f, 0.10758820f, 0.33260724f, -0.28419399f, -0.18626811f, -0.03537878f, -0.37000322f, -0.15535910f, 
    0.04563102f, -0.17535086f, -0.27479768f, -0.27307466f, 0.01208344f, -0.35565236f, -0.17568082f, -0.39872050f, 
    -0.00437524f, -0.03703970f, 0.02400422f, -0.15844586f, 0.04312967f, 0.10025784f, -0.00795088f, -0.16742812f, 
    0.38739514f, 0.27177915f, 0.39350894f, 0.01472587f, -0.23118463f, -0.14756815f, 0.02860279f, -0.00248271f, 
    -0.26319894f, 0.09153263f, -0.11035050f, -0.10261860f, 0.51416022f, -0.46037737f, 0.14391555f, 0.05364851f, 
    -0.12941918f, 0.03841091f, -0.11020450f, 0.07669211f, 0.03349134f, -0.11699656f, 0.10467231f, 0.00778708f, 
    -0.71258837f, -0.48837796f, -0.17769915f, 0.46502045f, 0.35407600f, -0.07069541f, 0.08717643f, -0.17482460f, 
    0.10373633f, 0.00822300f, 0.34813440f, 0.23515955f, -0.01951796f, -0.29658899f, -0.20499694f, -0.08232208f, 
    0.15142290f, 0.02414030f, -0.13172171f, 0.05675501f, 0.00690556f, 0.07201951f, 0.17388712f, -0.18511425f, 
    -0.25287753f, 0.45701614f, 0.16511470f, 0.13215847f, 0.37276879f, -0.27111170f, 0.02153424f, -0.10972586f, 
    0.07943068f, -0.03474808f, -0.13248339f, -0.02259420f, -0.47308400f, -0.35163310f, -0.05848836f, -0.11336010f, 
    -0.09244474f, -0.25177926f, -0.26941743f, -0.10202803f, 0.03718602f, 0.17562796f, 0.00666195f, 0.01767914f, 
    -0.82628745f, -0.95331728f, 0.16361994f, 0.30639851f, -0.13617010f, -0.05081586f, -0.15452118f, 0.10681864f, 
    -0.02075143f, -0.00183135f, 0.14461304f, 0.16098484f, 0.46114197f, 0.59955943f, -0.36395749f, 0.03579764f, 
    0.10954119f, -0.13891430f, 0.14468792f, 0.17186275f, -0.02187925f, 0.14260904f, -0.05931045f, 0.10724843f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.32988995f, 0.07948998f, 0.16288634f, -0.20046610f, -0.17904551f, 0.20616588f, 0.09785610f, -0.20066068f, 
    0.17087048f, 0.02684240f, 0.05354572f, -0.11109339f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
