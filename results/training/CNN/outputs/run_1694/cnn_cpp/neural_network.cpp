#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.11654011f, 0.60793447f, 0.28728336f, -0.56022102f, -0.27182648f, -0.05895915f, 0.32357088f, -0.01434253f, 
    0.48489982f, 0.02085760f, 0.37157631f, -0.30836436f, 0.18978654f, -0.15000896f, 0.20314068f, 0.08152258f, 
    0.03934109f, 0.11262907f, 0.44656172f, 0.49258077f, 0.05656081f, 0.25736198f, -0.12698168f, -0.15598053f, 
    -0.16037999f, -0.24236993f, -0.37625572f, -0.53746188f, -0.61004555f, -0.36674622f, -0.41312972f, -0.75427717f, 
    0.00074909f, 0.37144336f, 0.03212941f, -0.12437515f, -0.89754301f, 0.10582080f, 0.68030411f, -0.22999205f, 
    -0.61329818f, 0.27259442f, 0.32311457f, 0.10021128f, 0.02913025f, 0.02521962f, 0.55968517f, 0.54794937f, 
    0.52159822f, -0.74949300f, -0.64673340f, 0.12853456f, -0.26377341f, 0.11085192f, -0.18745661f, -0.75626457f, 
    0.63860422f, 0.15093887f, 0.64628369f, 0.06461612f, 0.09160732f, -0.44724706f, -0.48754865f, -0.32347354f, 
    0.32793328f, 0.12638138f, 0.00638559f, 0.27305260f, 0.34668025f, 0.25048766f, 0.13870910f, -0.23687410f, 
    0.54740012f, 0.27686542f, -0.74018872f, 0.42170981f, -0.18784411f, -0.17727508f, 0.20721976f, -0.56827223f, 
    -0.49750361f, 0.94300687f, -0.40541753f, 0.09346327f, 0.55093408f, -0.40770948f, -0.47121590f, -0.35351771f, 
    -0.03027692f, 0.30707410f, -0.73375434f, 0.80619562f, 0.24924639f, -0.62086982f, -0.35618997f, -0.32907310f, 
    0.27678758f, -0.02794998f, -0.19506696f, 0.01036750f, -0.41664645f, 0.46436977f, -0.14843886f, 0.55574358f, 
    0.11442367f, -0.14561373f, -0.29063705f, 0.30965546f, -0.43403077f, -0.45825380f, -0.89604473f, 0.83409894f, 
    -0.34583357f, -0.65579498f, -0.74812096f, -0.11874326f, -0.23403351f, 0.63518679f, -0.64668906f, 0.21501613f, 
    0.04516239f, -0.01368746f, 0.35040918f, -0.07127003f, 0.10759036f, -0.33268598f, 0.60052568f, -0.60897648f, 
    0.43726993f, -0.58618832f, -0.46752417f, -0.57113630f, -0.21158490f, -0.26929381f, -0.44839677f, -0.45524764f, 
    0.51054490f, 0.04979028f, -0.55344880f, -0.44876838f, -0.71098691f, 0.12017960f, 0.46609956f, -0.26687509f, 
    -0.68191034f, -0.76296657f, -0.30460826f, 0.68365026f, 0.48233387f, -0.07572447f, 0.07774229f, 0.05937780f, 
    0.22274281f, -0.26242629f, 0.18689446f, 0.04395131f, -0.18087851f, 0.50024354f, -0.72565210f, -0.11185105f, 
    0.17330080f, 0.44069177f, 0.28329480f, 0.18620965f, 0.44665703f, -0.49492553f, -0.08232493f, 0.05728060f, 
    0.17374519f, 0.02187300f, -0.28583908f, -0.89445871f, 0.20137618f, 0.43636820f, 0.51998013f, -0.55484366f, 
    -0.11324125f, 0.02571488f, 0.00665053f, 0.24638613f, 0.29901603f, -0.84059602f, 0.38627335f, -0.79745001f, 
    -0.44244689f, -0.15514565f, -0.44381341f, 0.03857918f, -0.70374626f, 0.57742351f, 0.56435496f, -1.01616621f, 
    -0.37240505f, 0.23731045f, -0.13120559f, 0.20846742f, -0.10596114f, -0.00534743f, -1.07866430f, -1.01378715f, 
    -0.11263940f, 0.64455384f, 0.76179153f, -0.04448385f, 0.07038484f, -0.33792514f, 0.08405472f, 0.12118997f, 
    0.04812682f, -0.04883327f, 0.24378815f, -0.37682372f, 0.11991964f, -0.53679752f, 0.34454760f, 0.27296165f, 
    0.85171783f, -0.88013029f, -0.96904695f, 0.41400972f, 0.44924378f, 0.40837449f, -0.18889944f, 0.15723117f, 
    -0.13403073f, -0.42266768f, 0.16058245f, 0.41364291f, -0.32182443f, 0.62449425f, -0.13406773f, -0.31448057f, 
    0.35812640f, 0.02148737f, -0.72110701f, 0.15958519f, -0.74264157f, 0.57569844f, -0.17942856f, 0.04129346f, 
    0.05572138f, 0.10039793f, 0.45025221f, 0.64734364f, -0.29268286f, -0.53962088f, 0.02638373f, -0.36267027f, 
    -0.31757128f, 0.25842583f, 0.19307478f, 0.56862646f, -0.25796214f, -0.79559684f, 0.60344791f, 0.53490287f, 
    -0.21273752f, -0.32384869f, -0.25816715f, -0.24437001f, -0.35775661f, -0.76450306f, 0.99724746f, 0.56962925f, 
    -0.81327528f, -0.01248631f, 0.34699246f, -0.17066862f, 0.07794560f, -0.22524418f, -0.68994415f, -0.63927728f, 
    -0.55516315f, -0.18868290f, -0.30174169f, -0.10451447f, -0.25956389f, -0.13784997f, 0.04516329f, -0.16257596f, 
    -0.04546563f, 0.23024079f, 0.43017119f, 0.10879357f, -0.30491325f, 0.26203457f, 0.21147391f, 0.16263211f, 
    0.35633922f, 0.57667273f, -0.75341898f, 0.44204941f, -0.20498198f, -0.25403064f, 0.11972426f, -0.29450297f, 
    0.29651237f, -0.77582049f, -0.52417594f, -0.44456729f, -0.45522630f, -0.15294006f, -0.56163818f, 0.28289115f, 
    0.29525214f, 0.07424749f, 0.26953188f, -0.53540182f, -0.33848014f, -1.01471305f, -0.21567473f, 1.03940105f, 
    -0.39472413f, -0.45538688f, -0.42341894f, 0.79458106f, 0.31137684f, -0.88245481f, -0.60927826f, 0.47435576f, 
    -0.42296132f, -0.50675356f, 0.24024250f, 0.22874580f, 0.98264718f, -1.01663125f, -0.95657355f, -0.04353684f, 
    -0.09816043f, 0.68280077f, -0.09138293f, 0.41655058f, -0.43714818f, -0.25286680f, -0.34652150f, -0.43455783f, 
    0.16113158f, 0.23056458f, -0.04356867f, 0.41240540f, 0.33109000f, 0.01181396f, 0.51531297f, -0.10042454f, 
    0.02204323f, 0.07455566f, 0.38331202f, 0.02019834f, -0.00871034f, 0.31299916f, -0.14144042f, -0.72096699f, 
    0.23652196f, 0.68140566f, -0.59329683f, -0.25841945f, 0.69455791f, -0.41733116f, 0.08910038f, 0.29536003f, 
    0.01277840f, -0.22922879f, -0.79824257f, 0.53444487f, 0.48500562f, 0.23904119f, -0.35411435f, 0.32154858f, 
    -0.12535793f, 0.04893306f, -0.20040645f, 0.09713755f, -0.05691589f, 0.08924034f, 0.25396633f, -0.16549249f, 
    0.35148922f, -0.10111317f, 0.50107336f, 0.40754199f, -0.01873303f, -0.01573534f, 0.57225156f, 0.08861201f, 
    -0.31676894f, 0.29369324f, 0.00513966f, -0.69840974f, -0.49874637f, 0.32642382f, -0.39244986f, 0.11768096f, 
    -0.15447417f, 0.32960176f, 0.44923440f, 0.09220897f, -0.14560735f, 0.56753522f, -0.43325549f, -0.18128675f, 
    0.45185918f, -0.13510452f, -0.59199917f, 0.60833347f, -0.06101922f, 0.24327326f, -0.09364738f, 0.52761567f, 
    -0.14241405f, 0.00603444f, -0.19183797f, 0.24735859f, -0.09956295f, 0.20703037f, 0.49679053f, -0.07903726f, 
    -0.16175547f, 0.23118049f, 0.45445272f, -0.28348464f, -0.09117255f, 0.06465799f, 0.19317898f, -0.88999504f, 
    -0.59328133f, -0.14732490f, 0.75269276f, -0.27579892f, -0.44729540f, 0.13420464f, -0.48976287f, -0.37446848f, 
    -0.02827687f, -0.90610182f, 0.13514072f, -0.74390519f, -0.35608321f, -0.38483816f, -0.07031038f, -0.31022468f, 
    0.16660526f, 0.63394362f, 0.09390258f, 0.24756339f, -0.42502168f, -0.61120969f, -0.82125902f, -0.58327425f, 
    0.03082258f, -0.17052115f, 0.38131461f, 0.11699312f, -0.71541697f, 0.15996745f, 0.34791210f, 0.40054038f, 
    0.01333949f, -0.33549401f, -0.09063224f, -0.62453526f, 0.43581158f, 0.29729268f, -0.46068141f, 0.27618739f, 
    0.15821022f, 0.44016886f, -0.63610017f, 0.11482479f, -0.76020855f, -0.27301380f, 0.15328023f, -0.30825162f, 
    0.25141749f, 0.02532151f, -0.71065372f, 0.47954816f, -0.45278403f, -0.54819989f, -0.42864981f, 0.72576821f, 
    -0.32084987f, -0.62020659f, -0.03441932f, -0.44182733f, 0.08568647f, 0.44877383f, 0.67827940f, 0.54718119f, 
    -0.49207297f, -0.38729361f, -0.04359439f, -0.02802710f, 0.04456167f, 0.04349453f, 0.02829596f, -0.15791553f, 
    0.10474458f, -0.52873409f, -0.66495007f, -0.51293981f, -0.55919278f, -0.39927560f, -0.40716365f, -0.51819265f, 
    0.50000489f, -0.57097077f, -0.33342013f, -0.62836224f, -0.44632435f, -0.80869812f, 0.25036415f, 0.21679877f, 
    -0.41000369f, -0.63404554f, 0.14628926f, -0.51189339f, 0.32141379f, -0.09073845f, -0.40032130f, 0.51759177f, 
    0.04552373f, 0.31911916f, 0.28623244f, -0.67453253f, 0.44375601f, -0.63754517f, -0.82114512f, -0.66013736f, 
    0.30100891f, 0.45776090f, -0.28299418f, 0.10458385f, 0.57721019f, -0.52185279f, -0.47829303f, -0.28035513f, 
    0.12236951f, 0.23301558f, -0.04112149f, 0.37506917f, -0.49832880f, -0.68619436f, 0.99006313f, -0.16446897f, 
    -0.67428720f, 0.29140422f, -0.33083534f, -0.47933465f, 0.32471696f, -0.79056621f, -0.11008353f, -0.12480218f, 
    0.04528466f, -0.40678665f, 0.34693268f, 0.03260454f, 0.10022423f, 0.45165998f, 0.40166250f, 0.80818373f, 
    -0.68283230f, -0.12351574f, -0.20928626f, 0.04886064f, 0.33518261f, -0.37745440f, 0.12246064f, 0.46136045f, 
    0.49730071f, 0.22435188f, -0.33401969f, -0.11513848f, -0.19645828f, -0.07992056f, -0.45272723f, -0.21747072f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00731228f, 0.24960478f, 0.14576997f, 0.18347582f, 0.02519245f, -0.00624009f, 0.17961839f, 0.24025683f, 
    0.09759951f, 0.10335983f, 0.19544671f, 0.23267347f, -0.25796869f, 0.29405969f, -0.14721380f, 0.26333496f, 
    0.03769014f, 0.00534353f, 0.28663564f, 0.02046577f, -0.17642929f, 0.09820243f, -0.08815666f, 0.21008103f, 
    0.28074053f, 0.20120671f, 0.09633748f, 0.12773606f, 0.15600307f, 0.30725181f, -0.06625409f, -0.14850286f, 
    0.03862844f, -0.29173687f, -0.16653240f, 0.03175380f, -0.03491203f, 0.18414845f, 0.13900146f, 0.27573687f, 
    0.14178266f, 0.14212005f, -0.21319699f, 0.13691297f, 0.12948728f, -0.03608419f, 0.06881753f, 0.06643175f, 
    -0.04834537f, -0.12121636f, 0.02428355f, 0.14337032f, 0.27706429f, 0.30227777f, 0.26382294f, -0.18563838f, 
    -0.13291796f, 0.23436584f, -0.03464741f, 0.17906556f, 0.17378549f, 0.17753449f, 0.00756905f, 0.17809205f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02671783f, 0.01820353f, 0.07697102f, -0.00677177f, -0.02556858f, -0.12066851f, -0.05998074f, 0.18127832f, 
    0.00036999f, 0.03042899f, 0.02344477f, 0.07569529f, -0.01650782f, -0.07601750f, -0.07985789f, -0.02675193f, 
    0.01378369f, 0.03490640f, -0.08273157f, -0.09636281f, -0.00647683f, -0.02983696f, -0.04876233f, 0.03569270f, 
    0.01523967f, -0.00289890f, -0.01166256f, -0.02525521f, 0.03141072f, 0.03772506f, -0.15483978f, -0.03713671f, 
    -0.15387411f, -0.08231535f, -0.06080190f, -0.01947098f, -0.02834533f, -0.06686917f, -0.00865964f, -0.06932347f, 
    -0.31267071f, 0.02391532f, -0.24122451f, 0.25367472f, 0.10627254f, -0.00554762f, -0.00170631f, 0.01075353f, 
    0.07203577f, 0.02931118f, -0.02240114f, -0.01673242f, 0.03337747f, 0.02378015f, 0.03903807f, 0.07606335f, 
    0.09897834f, 0.04122983f, 0.08746397f, -0.04243640f, 0.23541684f, 0.16024819f, 0.11911809f, -0.30244610f, 
    -0.10641146f, 0.13461323f, 0.14699964f, -0.01060125f, -0.05380876f, -0.05518443f, 0.01392869f, 0.02025195f, 
    -0.00390950f, -0.00284222f, 0.02795448f, 0.00867603f, -0.06899568f, 0.00295199f, -0.05372993f, 0.02510079f, 
    0.01945467f, 0.15666206f, 0.35957009f, -0.19631842f, 0.02857647f, -0.12490684f, 0.02791775f, 0.01819944f, 
    0.01900439f, -0.11328082f, 0.13618910f, -0.06600112f, -0.17394157f, -0.05433936f, 0.00366145f, -0.01640309f, 
    -0.01845147f, 0.00986692f, -0.18913025f, 0.07130774f, -0.20447670f, 0.27500317f, -0.43718007f, -0.03756534f, 
    -0.01693882f, 0.00625992f, -0.15874854f, -0.10383223f, 0.07570099f, 0.00722478f, 0.01644414f, 0.00873204f, 
    0.07617769f, 0.07735072f, 0.02914763f, -0.02013310f, 0.14643331f, 0.00980307f, 0.03839682f, -0.00349894f, 
    0.30517089f, -0.45329553f, -0.21950020f, -0.13559568f, -0.10619836f, -0.05287744f, -0.08336186f, 0.07721324f, 
    0.00938158f, 0.04549471f, -0.02210407f, 0.07139856f, -0.06474087f, 0.16693452f, 0.00671032f, -0.05512364f, 
    0.02717291f, -0.00047254f, -0.02073298f, 0.08907867f, -0.03670281f, -0.01141190f, 0.00666944f, 0.01471591f, 
    0.01257224f, 0.00847870f, 0.00437206f, 0.01111390f, 0.00230494f, -0.00753233f, -0.08546698f, -0.07371310f, 
    -0.08558843f, -0.03599978f, -0.06053974f, 0.00305386f, -0.04260404f, 0.03679518f, -0.02175766f, -0.00236712f, 
    -0.00000598f, -0.19355069f, 0.02806542f, 0.04084004f, -0.14726421f, -0.12656817f, 0.02376325f, -0.02648038f, 
    0.03204618f, 0.00666758f, -0.03440683f, -0.02476238f, 0.02541095f, 0.00817274f, 0.01750503f, -0.04371447f, 
    -0.09370308f, 0.21568118f, -0.07183886f, 0.06002918f, -0.23513155f, -0.11165767f, -0.23191309f, 0.05362136f, 
    0.00413189f, -0.02470783f, -0.06420377f, -0.24469468f, -0.08672494f, -0.05764288f, -0.00570887f, 0.01043821f, 
    0.03194539f, 0.04926145f, 0.03726254f, -0.14915220f, 0.13346542f, -0.12227222f, -0.10289183f, -0.13147455f, 
    -0.11264117f, 0.21049479f, 0.16076995f, -0.10042556f, -0.08424069f, -0.14878628f, 0.10332835f, -0.12604687f, 
    -0.00758012f, -0.07101540f, 0.00254152f, -0.01328482f, -0.02788649f, -0.01470597f, -0.03639646f, -0.07510658f, 
    0.03543946f, 0.02037466f, -0.15134864f, 0.07557943f, -0.13022301f, -0.13306251f, 0.01920868f, -0.03415557f, 
    0.02363012f, -0.03936964f, -0.06156099f, 0.06724259f, -0.01819214f, 0.02044097f, -0.03029909f, -0.05742077f, 
    -0.11211050f, -0.03330987f, -0.04138947f, -0.09531641f, 0.02038093f, -0.00261358f, 0.00177671f, 0.01593134f, 
    0.25580126f, 0.17854354f, -0.19671220f, -0.07172073f, -0.04152314f, 0.07020424f, 0.07475562f, 0.18900248f, 
    -0.15517153f, 0.11391657f, -0.03358905f, 0.01712269f, -0.00103641f, -0.00359473f, 0.04693212f, -0.03418028f, 
    -0.06720492f, -0.02471685f, -0.07519491f, 0.02829489f, -0.12408323f, -0.40100121f, -0.17841451f, -0.06713778f, 
    -0.04137341f, -0.03435970f, -0.06303590f, 0.07277624f, -0.03578927f, 0.05788528f, -0.06605340f, -0.03044949f, 
    -0.08970011f, -0.04209251f, 0.03026566f, 0.01277583f, -0.06119869f, 0.01546174f, -0.14586823f, 0.03048924f, 
    0.09655731f, 0.26080021f, 0.13474977f, -0.38413471f, 0.07295197f, -0.08724289f, -0.05445350f, 0.06991820f, 
    -0.16786139f, 0.03646399f, 0.01933920f, -0.06317354f, -0.02612607f, 0.05396029f, 0.00516180f, 0.04687805f, 
    -0.03980742f, 0.00046661f, 0.00704667f, 0.16086082f, 0.10388996f, 0.17021818f, -0.12483656f, -0.18074539f, 
    -0.18286097f, -0.01243023f, 0.04926132f, -0.21712694f, 0.03810901f, 0.02814826f, 0.03782552f, 0.00755262f, 
    0.00570945f, -0.03462405f, -0.04224841f, -0.05500766f, -0.03891035f, -0.03686958f, -0.12265447f, 0.05856136f, 
    0.21789348f, 0.13593850f, -0.23663341f, 0.03474029f, 0.06045461f, 0.09056301f, 0.05889241f, 0.06510944f, 
    -0.00705609f, -0.01951931f, 0.00627806f, -0.00081419f, -0.06592730f, 0.01572789f, 0.03468415f, 0.00997376f, 
    0.06491954f, 0.02213965f, -0.00815845f, -0.00809782f, 0.08811685f, 0.08954038f, -0.06223400f, 0.07625473f, 
    -0.04246756f, 0.01714965f, -0.07319362f, 0.05390620f, 0.03290972f, 0.04089784f, 0.07774938f, 0.04857251f, 
    -0.03486732f, -0.01896477f, 0.01238893f, -0.09055765f, -0.06897661f, -0.01473091f, -0.06558377f, -0.04327542f, 
    -0.33779556f, 0.02583167f, 0.01872631f, -0.14925458f, -0.01995986f, -0.01489720f, -0.02481942f, -0.04112289f, 
    -0.03366079f, 0.00736613f, 0.00815221f, -0.01534113f, -0.01345121f, 0.04306380f, 0.03596677f, 0.13331968f, 
    0.00932389f, -0.13487898f, -0.06390237f, -0.02854824f, 0.10416301f, 0.17282870f, 0.14362945f, -0.24373074f, 
    0.05946813f, -0.16555066f, 0.06834841f, 0.03611506f, 0.06514771f, -0.13785622f, 0.12011314f, -0.13686883f, 
    -0.01344342f, -0.07650502f, -0.01569468f, -0.07487454f, -0.03200849f, 0.01956581f, -0.11760812f, 0.07089248f, 
    0.12383769f, 0.29785648f, 0.18645938f, -0.37339464f, 0.01478728f, 0.01175581f, -0.00239411f, 0.16965903f, 
    -0.15866475f, 0.06547289f, 0.00140087f, 0.00944127f, -0.04024003f, 0.01595616f, -0.01264719f, 0.03689126f, 
    -0.10021301f, -0.05261737f, 0.08570456f, 0.07583288f, -0.17555702f, 0.08711442f, -0.40042493f, 0.00501327f, 
    -0.28784186f, -0.07627349f, -0.12345800f, -0.06648292f, 0.13684821f, 0.05708237f, -0.09142899f, -0.01245936f, 
    -0.05035329f, -0.02180877f, 0.05029314f, -0.07963817f, -0.00862018f, -0.08059560f, -0.15402293f, -0.10888984f, 
    0.40825921f, 0.19726463f, -0.31099650f, -0.11016297f, -0.03486691f, 0.12955375f, 0.14046942f, 0.18142295f, 
    0.13191299f, 0.00836495f, -0.01882139f, 0.01697160f, -0.05156892f, 0.05477867f, 0.09157523f, -0.00351623f, 
    0.06338953f, 0.03861300f, 0.05621063f, -0.00827070f, -0.06519762f, -0.10366135f, 0.00227903f, 0.02306364f, 
    -0.02440667f, -0.01427615f, 0.02773481f, -0.07602073f, 0.02518578f, -0.01426023f, -0.02949404f, -0.01167845f, 
    0.01875415f, -0.03175214f, -0.06729838f, -0.07876537f, -0.15882905f, -0.16957408f, 0.00356101f, -0.08527246f, 
    0.07548649f, -0.13946575f, -0.49235237f, 0.08561821f, 0.05079648f, 0.11642006f, 0.02052666f, 0.04572589f, 
    -0.15349773f, -0.02675558f, -0.06656566f, -0.04827018f, -0.13956849f, -0.12070133f, -0.06444238f, 0.00689809f, 
    0.03606373f, -0.05492212f, -0.01304118f, 0.02321684f, -0.12402437f, -0.10056067f, 0.07050370f, 0.02129763f, 
    0.02919274f, -0.06977144f, -0.03285377f, 0.08697669f, 0.06411842f, 0.01716406f, -0.17843275f, -0.01340794f, 
    -0.10997201f, -0.20531362f, -0.27690053f, -0.09154226f, -0.04970481f, 0.00131433f, -0.04512191f, -0.00979103f, 
    0.17678919f, 0.11528172f, -0.09071738f, -0.05163830f, 0.06670329f, 0.06227320f, 0.08524288f, 0.08685481f, 
    -0.08223469f, -0.05184200f, -0.08462822f, -0.05411885f, 0.04654723f, 0.00131896f, 0.02080644f, -0.01914719f, 
    0.01463142f, 0.02035460f, 0.00022286f, -0.01499177f, 0.15727837f, 0.15547164f, -0.11357135f, -0.00387176f, 
    0.02837015f, -0.02624914f, 0.00062189f, 0.01674848f, -0.04446291f, -0.11674357f, 0.09797107f, 0.07235948f, 
    0.02021698f, 0.04395651f, 0.04045175f, -0.02006071f, -0.05009549f, -0.00893466f, -0.08431395f, 0.00647781f, 
    0.30248472f, 0.16742457f, -0.15277782f, -0.36925691f, -0.01468827f, -0.10093376f, -0.18983664f, 0.07059050f, 
    -0.11586896f, -0.02244536f, -0.01380210f, -0.00917659f, -0.01903949f, -0.04945767f, -0.13520421f, -0.03262033f, 
    -0.02306277f, 0.09350972f, -0.09878494f, 0.05862750f, -0.91242683f, 0.05666323f, 0.36698541f, 0.24788220f, 
    0.02848512f, -0.04901697f, -0.05145391f, -0.03335210f, 0.02272890f, -0.02843787f, 0.06142705f, -0.00642355f, 
    0.02298359f, 0.04586470f, 0.00308114f, 0.05115649f, 0.18977761f, 0.00032892f, -0.16390944f, -0.02474282f, 
    0.24568817f, 0.17503569f, 0.06095420f, -0.15984549f, -0.03734827f, 0.18721889f, 0.11877479f, 0.17844261f, 
    -0.06836930f, -0.01660094f, 0.00389847f, 0.00083925f, -0.03505807f, -0.01092896f, 0.04351033f, -0.01709740f, 
    -0.06152389f, -0.00520263f, -0.07096650f, -0.04344463f, 0.07017329f, 0.01641532f, -0.01865977f, 0.03544223f, 
    0.05542548f, -0.01161955f, -0.00384585f, 0.01421546f, 0.04988761f, 0.06673772f, -0.01329788f, -0.15667881f, 
    -0.14757337f, 0.01682260f, -0.04225692f, -0.06936742f, -0.00807973f, -0.01703941f, -0.03371620f, -0.01463381f, 
    -0.18329102f, -0.11986195f, -0.19457509f, 0.15303206f, -0.06973906f, -0.05740581f, -0.02952311f, -0.09046193f, 
    0.07479228f, -0.00453466f, -0.06554615f, 0.01690848f, -0.04948327f, 0.06736436f, 0.02562477f, -0.03765834f, 
    -0.10075520f, -0.16912167f, 0.05705659f, -0.27593169f, 0.35665876f, 0.32317746f, -0.00483656f, -0.34475690f, 
    -0.15375941f, 0.13984621f, 0.06646374f, 0.08177489f, 0.01900602f, -0.03897377f, 0.03787683f, 0.00058185f, 
    0.00380081f, 0.00379136f, 0.05542646f, 0.02262805f, -0.02861273f, -0.02341559f, -0.01924427f, 0.00889519f, 
    0.21395755f, 0.17983662f, 0.19732881f, -0.07877116f, -0.15324710f, 0.04038659f, 0.03039949f, 0.04583462f, 
    -0.06909009f, -0.02480176f, 0.01965577f, 0.01802086f, -0.03499143f, -0.09682869f, -0.07834934f, 0.13607436f, 
    -0.03918476f, -0.06986193f, 0.13754135f, -0.12487488f, -0.29890612f, 0.12447049f, -0.00561553f, 0.02543474f, 
    -0.52283341f, 0.00761853f, -0.24006854f, 0.15339440f, -0.07004831f, -0.05923720f, -0.03735688f, 0.04549467f, 
    -0.07741978f, -0.03395119f, 0.06654019f, -0.06493190f, 0.03944295f, -0.00752704f, -0.10688005f, -0.01737065f, 
    0.26957354f, 0.10965473f, -0.25731817f, -0.06197533f, -0.04366724f, 0.15815490f, -0.01337614f, 0.12593040f, 
    0.07700798f, 0.06857719f, -0.04943124f, -0.01819914f, -0.05678746f, 0.07037272f, -0.02640302f, 0.08616897f, 
    -0.04409128f, -0.01791066f, 0.00873271f, 0.07632785f, 0.08657556f, 0.10386322f, -0.10104270f, 0.06937250f, 
    0.05989179f, 0.07484932f, 0.02377469f, 0.05815746f, -0.03545406f, -0.05829564f, -0.06456448f, -0.04660495f, 
    -0.10265318f, -0.00772580f, -0.00773238f, -0.02421143f, 0.01156780f, -0.03316850f, 0.02403319f, 0.02507517f, 
    -0.06656962f, -0.04114589f, -0.03825723f, 0.03759626f, 0.01298327f, 0.01415128f, 0.00752941f, -0.01512007f, 
    0.03281947f, 0.00413147f, -0.05016792f, 0.00673829f, 0.00542704f, -0.04243724f, -0.02854703f, -0.03327154f, 
    -0.02983985f, -0.03278630f, -0.03139602f, 0.02150626f, -0.74290365f, -0.02928227f, 0.35684094f, -0.01436814f, 
    0.06733189f, -0.23422104f, -0.21587235f, -0.06885796f, 0.04038027f, -0.12316953f, 0.01601754f, -0.07706229f, 
    -0.06228635f, 0.03045483f, 0.01989707f, -0.15053546f, -0.03088705f, -0.01483122f, -0.07005046f, -0.16449253f, 
    -0.05724754f, -0.31139559f, -0.44922209f, 0.12050154f, 0.06827692f, 0.06018443f, 0.03900523f, 0.01561665f, 
    -0.02605123f, 0.01608432f, -0.06085044f, 0.03503465f, -0.03438134f, -0.08281584f, -0.02809349f, 0.02838287f, 
    0.03084597f, -0.00742408f, 0.02388478f, -0.00358495f, -0.04030101f, -0.02340396f, -0.00135502f, 0.02212134f, 
    0.03763705f, -0.03726695f, 0.02278871f, 0.02864077f, 0.00173332f, 0.04701133f, -0.10128245f, -0.05159041f, 
    -0.06040307f, -0.08257034f, -0.03788107f, -0.01182275f, -0.01014159f, -0.00220358f, -0.00148299f, -0.02317589f, 
    -0.11653890f, -0.05715495f, -0.01858224f, 0.02604811f, 0.02792078f, 0.02627141f, 0.03610926f, 0.00485644f, 
    0.03323594f, 0.04872686f, 0.00914016f, 0.03650814f, 0.04232041f, -0.03985945f, 0.01748400f, -0.07029852f, 
    0.00633720f, -0.07212272f, 0.00494497f, 0.03308699f, 0.15642849f, 0.23904933f, 0.12071951f, -0.12980874f, 
    -0.00214902f, -0.04038097f, 0.02789080f, 0.09380498f, -0.01881266f, -0.03834977f, 0.06409108f, -0.06380720f, 
    -0.04902251f, 0.02931030f, -0.02434208f, -0.01388903f, -0.02663309f, -0.06217925f, 0.01114770f, 0.00397833f, 
    -0.35321257f, -0.33788931f, -0.17131095f, 0.09059610f, -0.19013076f, 0.03047543f, 0.07640970f, -0.03645172f, 
    -0.11175507f, -0.03900833f, -0.16249044f, 0.02465086f, -0.00649740f, -0.14347051f, -0.12718813f, -0.14471945f, 
    0.13483654f, -0.11016873f, -0.20003161f, 0.02155069f, -0.02186867f, -0.01074176f, 0.03572514f, 0.01368590f, 
    0.00776552f, -0.00186224f, -0.00374978f, 0.06089230f, -0.00272895f, 0.00335661f, 0.01335552f, 0.05281818f, 
    0.04452109f, 0.05348886f, 0.02191466f, -0.04325236f, -0.04323215f, -0.14010574f, -0.05019266f, -0.06300258f, 
    -0.00321185f, -0.03052720f, -0.04751493f, 0.04719798f, 0.05199577f, 0.00996244f, -0.00499886f, -0.00166243f, 
    0.03891357f, 0.01570725f, -0.08505646f, -0.13390557f, -0.14108711f, -0.10761154f, -0.12141153f, -0.04460558f, 
    0.01503946f, -0.10673524f, -0.02059305f, 0.01356843f, 0.37686542f, 0.21929906f, 0.01993732f, -0.36337185f, 
    -0.06901132f, -0.02455128f, 0.11671883f, 0.00663938f, 0.07295387f, 0.03904344f, 0.01468338f, 0.01551067f, 
    -0.02147828f, -0.10153304f, 0.00607419f, -0.07655592f, 0.00619262f, 0.06431159f, -0.05716590f, -0.01509082f, 
    0.29553834f, 0.25663036f, 0.11842240f, -0.44367158f, -0.00924820f, 0.11068669f, 0.05180991f, 0.11840480f, 
    -0.18577184f, 0.03460112f, -0.02887370f, -0.01180067f, -0.01204869f, -0.01336442f, -0.08397654f, -0.00296364f, 
    -0.03671069f, -0.05557609f, 0.19394074f, -0.15281022f, -0.00752467f, 0.33749425f, -0.01127036f, -0.16581482f, 
    -0.05939205f, -0.01428451f, 0.00418284f, -0.07758732f, -0.07156862f, -0.01782389f, 0.01726225f, -0.00691750f, 
    -0.01758304f, 0.01973286f, 0.03645916f, 0.04745072f, 0.07496049f, 0.03268637f, -0.06099970f, 0.11928981f, 
    -0.13354535f, -0.02909024f, -0.15247433f, 0.05401685f, -0.00085632f, -0.01258653f, 0.01041238f, 0.04302894f, 
    0.03615342f, 0.04291247f, 0.01859737f, -0.13742334f, -0.22870696f, 0.00130491f, 0.02811333f, 0.02520033f, 
    0.07405911f, -0.01774233f, 0.05025456f, -0.06735749f, -0.63676286f, -0.43402943f, 0.42340609f, -0.11969425f, 
    0.05658725f, -0.10158063f, -0.01706858f, -0.02203650f, 0.05585788f, -0.11311883f, -0.05869013f, -0.00387179f, 
    -0.03610088f, -0.04303512f, 0.04128889f, -0.15560092f, -0.16848797f, -0.07846475f, -0.12840652f, -0.06988030f, 
    0.12777576f, 0.09819391f, 0.03515805f, -0.09001546f, 0.00036058f, 0.04288119f, 0.05762112f, 0.14018816f, 
    0.06067872f, -0.01074768f, -0.05537516f, -0.00839078f, -0.02779422f, -0.10159186f, -0.15665609f, 0.02132152f, 
    -0.06096653f, -0.09283545f, 0.06166705f, 0.00573066f, 0.08496972f, 0.20486373f, 0.06575359f, -0.22668685f, 
    0.02511035f, -0.05810489f, 0.02617324f, -0.06736781f, -0.02913694f, -0.02113014f, 0.05048347f, -0.10176045f, 
    0.02250686f, -0.04189776f, -0.04472947f, -0.04577369f, -0.03748580f, -0.00443198f, 0.12246003f, -0.25436145f, 
    -0.25741318f, -0.13353074f, -0.24484196f, -0.05272391f, -0.21897918f, -0.05533426f, -0.04157749f, -0.09119587f, 
    0.00942147f, -0.02739225f, 0.02968146f, 0.02801883f, -0.02641268f, 0.00324380f, 0.00086705f, -0.03990626f, 
    -0.05137497f, -0.08883221f, -0.01867891f, -0.08001948f, 0.11549672f, 0.27719986f, 0.24382538f, -0.21329254f, 
    -0.13229844f, 0.02008056f, 0.08851019f, 0.08529095f, 0.00407268f, 0.06066989f, -0.01745818f, -0.04880109f, 
    -0.00405167f, -0.01034329f, -0.00938499f, -0.09137084f, -0.08744358f, 0.03627685f, 0.11399697f, 0.11611401f, 
    0.22081615f, 0.29502907f, -0.05330893f, -0.30290151f, -0.05878345f, 0.05741064f, 0.07083976f, -0.11936621f, 
    -0.01275657f, 0.12399978f, 0.01910414f, -0.01208312f, 0.00074534f, 0.03611884f, -0.02297127f, 0.01421791f, 
    -0.02107526f, 0.01513523f, 0.09330565f, 0.23306601f, 0.20140935f, 0.14501704f, -0.03379483f, -0.03454109f, 
    0.00603550f, -0.00695200f, 0.02918628f, -0.01668406f, -0.05544036f, -0.10096593f, -0.01403366f, -0.16976932f, 
    -0.03111800f, -0.05684947f, 0.01789624f, -0.05949827f, -0.01094012f, -0.03059469f, 0.00419904f, -0.04787442f, 
    0.26024085f, 0.26609582f, -0.00782355f, -0.40236500f, -0.05076045f, 0.03692482f, 0.14848253f, -0.09569601f, 
    -0.01861123f, 0.12864880f, 0.04387952f, 0.02955523f, 0.01272073f, -0.01156656f, -0.06745852f, -0.02189548f, 
    -0.00293633f, -0.03092254f, -0.17361864f, -0.03020920f, 0.08315030f, 0.10058782f, -0.00373548f, -0.02564270f, 
    -0.09114163f, -0.08151837f, -0.16372551f, -0.07105406f, -0.05720672f, -0.01025553f, -0.04996137f, -0.02439994f, 
    -0.05987259f, -0.02372919f, 0.01852041f, -0.05086073f, -0.02062576f, -0.00413261f, -0.10610984f, -0.10588715f, 
    0.24917875f, 0.17118378f, 0.13466944f, -0.46591803f, 0.14523019f, -0.04136622f, 0.10456996f, 0.01831636f, 
    0.01134351f, -0.16752847f, 0.00104081f, -0.07714978f, -0.01215144f, -0.07973486f, -0.12763722f, -0.03566412f, 
    -0.09778487f, 0.01723834f, 0.12608436f, -0.10945554f, 0.16676652f, 0.14842746f, 0.15941764f, -0.14489785f, 
    0.00501997f, 0.01859469f, 0.05872311f, 0.05097606f, -0.02422101f, -0.11430200f, -0.02872971f, -0.18530913f, 
    0.01803483f, 0.00511969f, 0.02675770f, -0.01383515f, -0.03932834f, 0.03761810f, -0.05669066f, -0.01754627f, 
    -0.30041686f, -0.26148939f, -0.10501073f, 0.18536785f, -0.16736226f, -0.00570983f, 0.02273228f, -0.04557604f, 
    0.08121533f, 0.02757768f, 0.00364390f, 0.03764693f, -0.01188296f, -0.00391636f, 0.02230703f, -0.06352013f, 
    0.03932366f, -0.01954414f, 0.07310899f, -0.15192698f, -0.28249460f, 0.17565225f, 0.23498927f, 0.00092051f, 
    -0.07271526f, -0.02158273f, -0.00412788f, -0.04732262f, 0.03288938f, 0.01630310f, 0.00787131f, -0.01531574f, 
    0.00407321f, 0.02067270f, 0.03465397f, 0.15398709f, 0.04925677f, -0.01516216f, 0.06299688f, 0.02837626f, 
    0.03665950f, -0.01574994f, 0.03166904f, -0.04679313f, 0.02829542f, 0.03379699f, 0.06323881f, -0.12908450f, 
    -0.04850141f, 0.04762474f, -0.04314329f, -0.06534913f, 0.00305762f, 0.07542103f, 0.00586251f, -0.02750510f, 
    -0.07118686f, -0.10016480f, 0.00578836f, 0.05052013f, -0.03167863f, 0.01820803f, 0.10033751f, -0.00557288f, 
    0.06244817f, 0.02125071f, -0.00753987f, -0.00317429f, 0.00646234f, -0.04639996f, 0.01041848f, 0.07116652f, 
    0.01212209f, 0.03558728f, -0.04752128f, -0.06406816f, -0.04611608f, -0.05372934f, 0.00723378f, 0.00785173f, 
    0.33781320f, 0.17938139f, 0.05601124f, 0.16623782f, 0.15972310f, -0.01114276f, -0.05603566f, -0.00040369f, 
    -0.03849095f, -0.04104888f, -0.02405433f, 0.00627709f, -0.02334480f, -0.00049239f, 0.03076394f, -0.04779615f, 
    -0.07119337f, 0.03458108f, 0.12206962f, 0.04139795f, -0.17470676f, 0.13254732f, -0.10889561f, 0.15388735f, 
    0.13067973f, 0.04112574f, 0.06919008f, 0.13972847f, -0.00888570f, 0.02999314f, -0.00866229f, -0.00171610f, 
    0.03493808f, 0.02729794f, 0.01142882f, 0.06129621f, 0.00523579f, 0.02996632f, -0.13723511f, 0.08583581f, 
    -0.51103687f, -0.09816840f, -0.01350919f, -0.24158202f, 0.08577923f, 0.01155534f, -0.05834994f, 0.17678623f, 
    0.20780379f, 0.05733282f, -0.07028724f, 0.10127699f, 0.02550040f, 0.08686802f, -0.02868610f, -0.05394407f, 
    0.00997722f, 0.04301430f, 0.15417187f, 0.00623988f, -0.05263454f, 0.21758722f, -0.04256506f, -0.01975352f, 
    0.04448340f, 0.06398357f, -0.05854606f, -0.18074659f, -0.06290308f, -0.16339804f, -0.02409646f, 0.00270862f, 
    0.04754550f, -0.00396232f, 0.00956235f, 0.04715207f, 0.13172731f, 0.12393138f, 0.01348461f, 0.07797273f, 
    0.13460988f, -0.28095388f, 0.13041264f, 0.07491174f, 0.12877360f, -0.03114817f, 0.03302819f, -0.02973909f, 
    -0.05826828f, 0.00527577f, 0.03462630f, 0.10303162f, 0.11386487f, -0.03066968f, -0.11972134f, 0.11394723f, 
    -0.03238727f, -0.04959327f, 0.04972596f, -0.21554804f, 0.03458830f, -0.00335724f, 0.08924444f, 0.03946380f, 
    0.03747368f, 0.00970403f, 0.00713926f, -0.00183221f, -0.00831089f, -0.02274125f, 0.06705961f, -0.02480524f, 
    -0.03314992f, 0.04877046f, 0.04138589f, -0.05341719f, -0.04253911f, -0.06192516f, 0.03168099f, 0.01923132f, 
    0.18675344f, 0.31611148f, -0.11295740f, 0.04931768f, -0.29674265f, -0.00113128f, -0.11937729f, 0.00220391f, 
    -0.02819376f, -0.08962739f, -0.01791804f, 0.02019174f, 0.00807467f, -0.06257655f, 0.02824534f, -0.03602468f, 
    -0.14344101f, -0.05699496f, 0.01610226f, -0.04867971f, 0.43781772f, 0.24777186f, -0.15535668f, 0.06556492f, 
    -0.17157355f, 0.02509291f, -0.00008445f, -0.09234145f, -0.02917411f, -0.12480042f, -0.05093162f, 0.04288093f, 
    0.03500689f, 0.03210426f, -0.04303074f, 0.21118005f, 0.29284555f, 0.00355389f, 0.09716317f, 0.07737945f, 
    -0.25064716f, -0.32428727f, -0.05283153f, -0.18475927f, 0.00511372f, 0.12837046f, -0.02730548f, -0.20639667f, 
    0.04333433f, 0.06351718f, 0.01380459f, -0.01595558f, 0.01685083f, 0.02119411f, -0.01287143f, -0.00616391f, 
    0.00148479f, 0.02544335f, 0.05287549f, -0.14483428f, 0.00559308f, -0.01373603f, 0.12794116f, 0.08968967f, 
    0.09287530f, -0.04679566f, 0.05450366f, 0.03133453f, -0.02810144f, -0.02572065f, 0.13424148f, -0.14589423f, 
    0.12273273f, 0.03204644f, -0.06661806f, 0.00021608f, -0.00361691f, 0.03206319f, -0.01812459f, -0.08827923f, 
    0.22515617f, 0.34107968f, 0.13787852f, 0.16966625f, -0.12920289f, 0.09244619f, 0.02928458f, -0.04515047f, 
    0.24206948f, -0.03924205f, 0.04904957f, -0.03136835f, 0.00663656f, -0.07628129f, -0.01089603f, -0.05146774f, 
    0.00056948f, -0.31855574f, 0.03147608f, 0.15100403f, 0.47909576f, 0.19045460f, 0.04941119f, 0.12099778f, 
    0.10312892f, -0.02452613f, 0.03658993f, -0.05477480f, -0.02017897f, 0.00170457f, -0.06672842f, 0.00122942f, 
    -0.08131970f, 0.05406744f, 0.01613822f, -0.06445283f, 0.08416240f, -0.02555653f, -0.09852769f, -0.00419847f, 
    -0.19611575f, -0.02101908f, -0.53076428f, -0.36073250f, -0.17819127f, -0.06720177f, -0.07425232f, -0.12712312f, 
    -0.03139319f, -0.02915167f, -0.03147227f, 0.00844438f, -0.00301955f, -0.03520844f, 0.00802380f, 0.00760783f, 
    -0.11809588f, -0.23205559f, -0.16235550f, -0.29478133f, -0.10088849f, -0.10265739f, -0.11000054f, 0.03031180f, 
    -0.08329249f, 0.04841482f, -0.02727732f, -0.17365594f, 0.11954358f, 0.03794537f, 0.00517858f, 0.02194103f, 
    -0.00882433f, 0.05921527f, 0.07768957f, -0.01976393f, -0.00388714f, -0.03442314f, 0.02284283f, -0.06939147f, 
    0.09785548f, -0.21257459f, -0.05673057f, -0.03506627f, -0.07673676f, -0.03010453f, -0.00551941f, 0.06852578f, 
    0.02135259f, -0.20056380f, 0.01917418f, -0.10666830f, 0.03425202f, -0.03605078f, -0.06849803f, 0.00912486f, 
    -0.00157197f, -0.02334563f, 0.01652783f, -0.00828705f, 0.03733891f, -0.03492146f, -0.03627336f, -0.04471732f, 
    0.02365527f, -0.01268431f, 0.04457627f, -0.02924636f, 0.06262204f, 0.03876996f, 0.01694006f, -0.09640683f, 
    0.07294742f, 0.06078430f, -0.07086591f, -0.10049755f, 0.02544104f, -0.03418222f, -0.00253470f, -0.14615381f, 
    0.33687538f, 0.06378990f, 0.08289170f, 0.02638772f, 0.20545255f, 0.00534690f, 0.02305416f, -0.08214603f, 
    0.00450669f, -0.02347753f, -0.01848367f, -0.02649642f, 0.02398918f, 0.02525447f, 0.01173790f, 0.04961316f, 
    0.04642631f, 0.00699878f, 0.04455847f, -0.02730332f, -0.33805287f, 0.07396875f, -0.22385320f, 0.01180322f, 
    0.13074769f, 0.15328315f, 0.00720151f, 0.05434844f, 0.05498719f, -0.06382699f, -0.22005774f, 0.07229678f, 
    0.05508417f, 0.04784607f, -0.03351214f, -0.12153815f, 0.04900367f, 0.10418180f, -0.02603382f, -0.11057800f, 
    -0.30915877f, 0.19389832f, -0.33108738f, -0.20221120f, 0.16054349f, 0.12635040f, 0.13687594f, -0.17053793f, 
    0.01046189f, -0.00851313f, -0.02831539f, 0.03931341f, 0.00727556f, -0.02281806f, 0.00074715f, -0.04903236f, 
    -0.04809211f, 0.05272142f, -0.29949880f, -0.16897002f, -0.18236957f, -0.18510842f, 0.04620063f, 0.04801168f, 
    -0.57223696f, 0.04321983f, 0.02265905f, 0.04503924f, 0.05380358f, 0.06156897f, 0.00391866f, -0.01149545f, 
    -0.03238465f, 0.11217211f, -0.03007714f, 0.11672762f, -0.17646466f, 0.05829836f, 0.05820288f, -0.07433219f, 
    0.22772852f, -0.17347689f, 0.15511534f, 0.01716915f, 0.04840828f, 0.05029937f, 0.03639487f, 0.14165719f, 
    -0.03203675f, -0.25683779f, 0.18136871f, -0.08903365f, -0.03210299f, -0.10172544f, -0.13126709f, 0.06785947f, 
    -0.02570209f, -0.03532422f, -0.05589078f, -0.06011318f, 0.10232511f, 0.04482918f, 0.01396799f, 0.03916642f, 
    0.04948820f, 0.03358523f, 0.00051258f, 0.05293894f, -0.00279565f, 0.00427173f, -0.06533902f, -0.03419391f, 
    0.01778597f, 0.02223230f, -0.06338838f, -0.06041827f, 0.17255305f, -0.03014808f, 0.04504536f, 0.01766394f, 
    0.79993445f, -0.11204902f, -0.09840386f, 0.00986874f, -0.22554071f, -0.08546772f, 0.07183397f, -0.03299310f, 
    -0.12464854f, 0.08126285f, 0.10239409f, -0.14603761f, -0.09163172f, -0.03551401f, 0.00031809f, -0.01498594f, 
    0.00038626f, -0.11643170f, -0.00897068f, 0.02801784f, 0.08733252f, -0.04263759f, 0.09156829f, -0.02604849f, 
    0.11541063f, -0.06162027f, -0.00053939f, -0.01207033f, -0.02717040f, 0.06650609f, 0.12929867f, 0.02023130f, 
    0.01736173f, -0.04615223f, 0.08055335f, -0.08413525f, 0.02344219f, 0.01652364f, -0.03482365f, 0.01128107f, 
    -0.30748555f, -0.10071247f, -0.07377125f, -0.02068795f, -0.01069147f, 0.01147303f, 0.07625003f, 0.04880618f, 
    0.04759737f, -0.22782815f, -0.11037423f, -0.02093094f, 0.02443771f, -0.02785905f, -0.07068350f, 0.02997531f, 
    0.03838171f, -0.02461855f, 0.00432024f, 0.04367445f, -0.07576428f, -0.07393211f, -0.15082423f, -0.06902296f, 
    -0.10026497f, 0.07275116f, 0.05358496f, 0.07213803f, -0.09507468f, 0.03266636f, 0.22980291f, 0.06375299f, 
    0.09374744f, 0.00109192f, 0.01918716f, -0.02227082f, 0.00496682f, 0.01208807f, 0.02794880f, 0.01533735f, 
    -0.06539050f, -0.13995937f, -0.03545954f, -0.11162390f, 0.07126391f, 0.03211320f, -0.05097446f, 0.03245086f, 
    0.14109223f, 0.02490852f, 0.11826171f, -0.00884808f, 0.12654181f, -0.01656625f, 0.00385829f, -0.02826670f, 
    -0.06926151f, -0.23751089f, -0.06614216f, -0.00542738f, 0.08770286f, -0.37934116f, 0.01495999f, -0.14815322f, 
    0.14699437f, 0.02046098f, 0.00177611f, 0.00723839f, -0.05852714f, -0.02409494f, 0.02306839f, -0.02223605f, 
    -0.00534906f, -0.00236350f, -0.01977765f, 0.04945093f, 0.08765848f, -0.02473137f, 0.14018522f, 0.12578417f, 
    0.03682530f, 0.17779741f, 0.16327089f, 0.24031489f, 0.04842878f, -0.02280129f, 0.10288438f, 0.03641396f, 
    0.03646075f, -0.09871482f, -0.02007903f, -0.02972948f, 0.03253624f, -0.03177946f, 0.01018946f, 0.01634795f, 
    0.05790212f, -0.01384800f, -0.06102145f, 0.01527566f, 0.05818009f, 0.03334586f, -0.03432456f, 0.01925633f, 
    -0.00825137f, -0.01330568f, -0.02535101f, -0.00297883f, 0.02616985f, -0.06430490f, -0.08294512f, 0.03703501f, 
    0.00882755f, 0.00266413f, -0.03470529f, -0.05180206f, -0.07579718f, 0.03519193f, -0.00891062f, -0.03799525f, 
    -0.09111016f, 0.05670536f, -0.08770097f, 0.00881358f, 0.04809842f, 0.11558151f, -0.03677887f, -0.06931490f, 
    0.01736560f, -0.16825637f, -0.13087161f, 0.15705477f, 0.14909585f, -0.00558715f, -0.17160219f, 0.08740037f, 
    -0.01232539f, 0.18751368f, 0.02853298f, 0.05868372f, -0.07673264f, 0.11789172f, 0.04804368f, 0.26201412f, 
    0.15650658f, -0.12471523f, 0.05662980f, -0.04058165f, -0.04532884f, -0.05586327f, -0.01572445f, 0.00456939f, 
    -0.01802543f, -0.00320492f, -0.00530450f, 0.01045001f, -0.01740171f, -0.00078248f, -0.03813893f, 0.00669667f, 
    -0.07113086f, 0.58528370f, 0.08089890f, 0.22676413f, -0.15698473f, -0.03004623f, 0.04983681f, 0.18876088f, 
    -0.11805779f, -0.01350482f, -0.03072175f, 0.03061001f, 0.02682920f, -0.02622677f, 0.06871668f, 0.04921270f, 
    -0.29831883f, -0.04391689f, -0.11476596f, -0.09587058f, 0.30026671f, -0.30304369f, -0.52677613f, -0.11367285f, 
    -0.43486515f, -0.21439695f, 0.05524836f, -0.18480779f, 0.11335491f, 0.09715363f, -0.01513158f, -0.01168940f, 
    0.07412074f, 0.02433535f, -0.03277490f, -0.03650562f, -0.02758581f, -0.12951294f, 0.01910129f, 0.10556484f, 
    0.64375019f, 0.40775561f, -0.32708317f, 0.10225675f, -0.02787249f, -0.19128530f, 0.11003490f, -0.05439062f, 
    -0.19149502f, 0.14522137f, 0.01951874f, -0.07865711f, -0.18968293f, -0.04258159f, -0.03909231f, -0.01267584f, 
    0.02487717f, -0.04087826f, -0.13755560f, 0.08509549f, -0.00673607f, -0.12016978f, -0.17649028f, -0.07455173f, 
    -0.10404356f, -0.03621610f, 0.01283140f, 0.05469177f, 0.03301161f, 0.03267689f, -0.02346750f, 0.12303441f, 
    0.01057636f, 0.05975848f, 0.01033396f, -0.02781692f, -0.01918116f, 0.03938640f, 0.01566102f, 0.02036875f, 
    0.16223800f, 0.03499944f, 0.05926198f, 0.06437581f, 0.05304516f, -0.03885460f, 0.03259111f, -0.02452462f, 
    -0.03095494f, -0.01662314f, -0.03144835f, 0.06211914f, 0.00107212f, -0.04998253f, 0.00582295f, -0.10829327f, 
    -0.05623378f, -0.04103224f, 0.04194229f, -0.00724496f, -0.32054332f, -0.04129997f, 0.09010132f, -0.07530684f, 
    0.04373498f, 0.09626695f, -0.09945582f, 0.12951884f, 0.01845459f, 0.01316395f, 0.06557640f, 0.01829945f, 
    0.04294908f, -0.04643241f, -0.03846784f, 0.08086545f, 0.19044301f, 0.11271597f, 0.07993264f, 0.06363936f, 
    0.33906668f, -0.22634895f, -0.08504533f, 0.00151900f, -0.08769713f, -0.03447961f, -0.00286882f, 0.00776096f, 
    0.03184844f, -0.05336542f, 0.05112593f, 0.01822009f, -0.11740059f, -0.08390635f, 0.02349831f, 0.01394360f, 
    0.02035124f, -0.10906415f, 0.04885456f, 0.02684800f, 0.07687482f, 0.03333221f, 0.02445644f, -0.01038604f, 
    0.03161895f, -0.05507340f, 0.01758939f, 0.01567504f, -0.05076805f, 0.01115068f, -0.02567345f, 0.01731566f, 
    -0.09593034f, -0.02882334f, 0.02712729f, -0.07356852f, 0.04817810f, -0.04877389f, 0.04450842f, 0.04268455f, 
    0.16752458f, 0.10687995f, 0.08817723f, 0.09445114f, 0.12173114f, -0.01110604f, 0.00072593f, 0.00781868f, 
    -0.01796369f, -0.03630573f, 0.00968490f, 0.04629323f, -0.02373899f, -0.02488503f, -0.00584125f, -0.04436417f, 
    -0.01355764f, -0.13546446f, -0.01350685f, 0.00929154f, -0.25746614f, -0.03021812f, -0.14238648f, -0.06620283f, 
    0.10157483f, -0.06358836f, 0.14366712f, 0.11775687f, 0.13354059f, 0.02989232f, -0.06694376f, 0.06432036f, 
    0.03439267f, 0.03180684f, -0.02562906f, 0.01452017f, 0.01227455f, 0.01524907f, 0.01247481f, 0.02452639f, 
    -0.12209290f, -0.21882753f, 0.04069147f, -0.02384738f, -0.08931967f, -0.05796688f, -0.00821182f, -0.13279259f, 
    0.05602374f, 0.06039537f, 0.10840318f, 0.07384292f, -0.14177744f, 0.16151322f, 0.00899797f, -0.10341969f, 
    0.19169824f, -0.17530914f, 0.22467978f, 0.07851478f, 0.05228026f, 0.07900676f, 0.00679601f, 0.05933309f, 
    0.05961299f, -0.05495479f, -0.03679433f, -0.06609097f, -0.01494048f, -0.03368386f, -0.02641929f, -0.05559355f, 
    0.01741154f, -0.00416170f, -0.02128443f, 0.00986573f, -0.09765922f, 0.05273796f, -0.00569425f, -0.05353882f, 
    0.18644419f, 0.02943341f, 0.00158147f, 0.05602491f, 0.03819884f, 0.00345496f, -0.01189940f, -0.01444916f, 
    -0.00702009f, -0.02783893f, -0.04391116f, 0.07223675f, 0.12958419f, -0.02890940f, 0.11194737f, 0.03096717f, 
    0.04489455f, -0.07861304f, 0.00680399f, -0.06030466f, 0.17983846f, 0.17812440f, 0.00534630f, -0.07654626f, 
    0.10501813f, 0.10424771f, -0.17885184f, 0.06192484f, 0.16957194f, -0.09031359f, 0.07781272f, 0.02524618f, 
    0.00577549f, -0.15346234f, 0.00954581f, 0.05722490f, 0.04538947f, -0.00218995f, -0.11877330f, -0.07290678f, 
    -0.12171485f, 0.18828315f, -0.05448291f, 0.10579423f, 0.04843070f, -0.20740514f, -0.09688988f, 0.07436341f, 
    -0.02448630f, 0.10902938f, 0.00703565f, 0.01364709f, 0.07038297f, 0.00643823f, 0.03342068f, 0.01865787f, 
    0.03542199f, 0.05989605f, -0.28992498f, -0.08775175f, 0.07607553f, 0.05400505f, -0.53268760f, -0.17820522f, 
    -0.56929964f, -0.01670481f, -0.24596323f, -0.16201505f, -0.05192274f, 0.06031568f, -0.01708767f, -0.00755978f, 
    -0.01149024f, 0.01818992f, 0.00421462f, 0.02484566f, -0.01254271f, -0.41626003f, -0.05348182f, -0.10240321f, 
    0.29664603f, -0.00196904f, 0.15765536f, 0.03421116f, -0.04844673f, 0.00775681f, -0.04513807f, 0.04580247f, 
    -0.06544425f, -0.03209038f, 0.01601836f, -0.17314978f, 0.01909202f, -0.09702958f, -0.12327767f, 0.05091216f, 
    -0.04075495f, -0.09139661f, -0.06378724f, -0.04077952f, -0.34950176f, -0.21943258f, 0.00381525f, -0.18007314f, 
    0.40132058f, -0.11574781f, -0.03097256f, 0.16965489f, 0.03083402f, 0.08057616f, 0.02787895f, 0.07809637f, 
    -0.01110017f, -0.05551255f, 0.07518030f, 0.35363212f, -0.05062187f, 0.09569424f, 0.13895437f, 0.02661366f, 
    -0.34636071f, -0.06254219f, -0.01614015f, -0.10443872f, 0.05346781f, -0.01659167f, 0.14074786f, -0.12273172f, 
    0.21167225f, 0.12811498f, 0.07901615f, 0.01485894f, -0.05305741f, 0.03122215f, 0.04538104f, -0.09606603f, 
    -0.02027395f, -0.15858059f, 0.09864156f, -0.05489868f, -0.34299245f, 0.15745212f, -0.16757479f, 0.14150287f, 
    -0.11502271f, -0.01638949f, -0.02767256f, -0.02276483f, 0.12283681f, 0.03682192f, 0.02752215f, 0.07890139f, 
    0.05735718f, 0.02319360f, 0.02759496f, -0.04135208f, 0.06211677f, -0.00130152f, -0.16082700f, 0.08110993f, 
    0.03912906f, -0.02816561f, 0.13097908f, 0.04326677f, -0.14741883f, 0.06585045f, -0.04361112f, -0.00504585f, 
    -0.00084786f, 0.00885250f, -0.01816186f, -0.06966193f, -0.02323446f, 0.06294546f, -0.01929477f, 0.02303998f, 
    0.08625512f, -0.02177482f, 0.09585658f, -0.00796053f, -0.05397776f, 0.12622450f, -0.03276012f, 0.00229523f, 
    -0.19695593f, 0.12041460f, -0.06432041f, -0.07546429f, -0.13547400f, 0.04947653f, 0.00588959f, 0.02517082f, 
    0.07148319f, 0.01442420f, 0.06289025f, -0.12786400f, -0.08395552f, 0.06682025f, -0.23651724f, -0.15127407f, 
    -0.13718514f, 0.07590144f, -0.17367730f, 0.09768569f, 0.02554327f, -0.00373780f, -0.15394194f, -0.18146150f, 
    -0.14217137f, -0.13253732f, 0.03175347f, 0.01560918f, -0.03614537f, 0.04344820f, 0.10596757f, -0.00389265f, 
    -0.01997764f, 0.08698180f, -0.00308845f, -0.03837921f, -0.19313186f, -0.12664245f, -0.07298574f, 0.08183310f, 
    -0.02145522f, 0.01294356f, 0.03925351f, 0.03481172f, 0.13471428f, -0.07075860f, -0.07855744f, 0.10340836f, 
    0.01551870f, 0.01414738f, 0.00270940f, -0.01585208f, 0.05524357f, 0.08651391f, -0.00317083f, 0.02501684f, 
    -0.29951864f, 0.14538138f, -0.20487924f, 0.01005839f, 0.09086375f, -0.00905745f, -0.13010664f, -0.37993735f, 
    0.22400370f, -0.12607676f, -0.07967676f, -0.03379131f, -0.07115965f, 0.08159873f, 0.06127390f, 0.01527185f, 
    0.00460428f, 0.03352838f, 0.02235333f, -0.05513583f, -0.17894994f, -0.16460794f, 0.05612190f, -0.02778944f, 
    -0.14685969f, 0.11236470f, 0.11256731f, -0.02489257f, 0.05053323f, 0.10608057f, 0.02662575f, 0.02879753f, 
    0.03592796f, 0.14660747f, 0.03133928f, -0.01576814f, -0.02462056f, -0.02008594f, 0.07602246f, 0.08805589f, 
    -0.61427307f, 0.06504388f, -0.17461807f, 0.01107668f, -0.08452606f, -0.04162804f, -0.06548122f, 0.07348015f, 
    0.07811762f, 0.03025670f, 0.07868678f, 0.04926828f, 0.02043842f, -0.06234148f, -0.06729580f, -0.13368048f, 
    0.04630561f, -0.04557118f, -0.15767750f, 0.05101088f, -0.47199038f, -0.08642451f, -0.08247057f, 0.03258870f, 
    -0.04114172f, 0.08371339f, 0.20003693f, 0.14558962f, 0.04160430f, -0.06877197f, -0.11007790f, 0.03497511f, 
    0.04094994f, 0.05296272f, 0.02945499f, -0.00826069f, 0.02552162f, -0.01598668f, -0.05422533f, 0.03206252f, 
    -0.18408620f, 0.01280466f, 0.15611742f, -0.00339793f, -0.02659508f, 0.02484416f, -0.03699835f, 0.03422053f, 
    -0.05806776f, -0.00567728f, -0.04946715f, -0.02331736f, -0.01284946f, 0.05507526f, -0.06990987f, 0.02488877f, 
    -0.01159380f, 0.05602771f, 0.03185610f, 0.04846198f, 0.35706562f, 0.13270134f, 0.05230040f, -0.01069950f, 
    0.08725781f, -0.07014515f, -0.04600795f, -0.03180796f, -0.01581836f, -0.00676808f, -0.02322936f, -0.02872424f, 
    0.02579905f, -0.01616692f, 0.00201700f, -0.05620982f, -0.17158160f, -0.14342910f, 0.00740800f, -0.05116855f, 
    -0.10178757f, -0.04772918f, -0.03155892f, -0.02274459f, 0.05704850f, -0.02352933f, -0.22404253f, -0.20084126f, 
    -0.09849350f, 0.03727993f, 0.01794543f, -0.05536173f, -0.00120557f, 0.02962566f, -0.09509434f, 0.01814095f, 
    -0.07669509f, -0.07987228f, -0.07274960f, -0.00223732f, 0.01579929f, -0.01043062f, -0.01027220f, -0.00788555f, 
    0.00330313f, 0.01250320f, 0.00456661f, 0.04526745f, 0.00523377f, 0.02939346f, -0.06376249f, -0.07569872f, 
    -0.03701093f, 0.04050874f, 0.05239539f, 0.01180668f, -0.00061743f, -0.00907857f, 0.02643983f, -0.03437068f, 
    -0.18430924f, -0.15063335f, 0.10322782f, -0.37194824f, -0.08956161f, 0.01001055f, -0.00765437f, -0.02071737f, 
    0.05124028f, 0.03757509f, -0.00702512f, 0.00610623f, 0.00417847f, -0.00289962f, -0.02577625f, 0.07804956f, 
    -0.02163774f, 0.06875437f, -0.02929978f, -0.01472385f, -0.14825951f, 0.21044251f, -0.19402914f, 0.13521196f, 
    -0.06086747f, 0.04546869f, 0.03479452f, 0.06671984f, 0.07455516f, -0.02860297f, 0.00114554f, 0.03275628f, 
    0.04936622f, 0.04361942f, -0.02552283f, -0.01043287f, -0.00177916f, -0.01718324f, -0.06959695f, 0.03744354f, 
    0.27318773f, 0.07874571f, -0.22893198f, -0.01464245f, 0.06562820f, 0.06076884f, -0.01095144f, -0.18756992f, 
    -0.04424383f, 0.01041758f, -0.09156996f, -0.02614576f, -0.08684160f, 0.04474423f, -0.07244281f, 0.01698882f, 
    0.00049162f, 0.05674112f, 0.01190603f, -0.02820336f, -0.44719291f, -0.13089526f, -0.11235384f, -0.45059684f, 
    0.05644395f, 0.05472863f, -0.03069830f, -0.10805832f, 0.03825689f, 0.10945746f, -0.00792987f, 0.03156086f, 
    0.06241446f, -0.03608438f, 0.00802348f, -0.12055168f, -0.16889168f, -0.17100975f, 0.03807175f, 0.11841482f, 
    0.06677221f, 0.02184099f, 0.13507321f, -0.08679708f, 0.26752231f, 0.03276670f, -0.04480714f, -0.04092848f, 
    0.01325101f, -0.04226303f, 0.11259965f, -0.01562144f, 0.04060183f, -0.03458694f, 0.16050459f, 0.08938658f, 
    0.07044505f, 0.06093602f, -0.08564728f, 0.05243384f, 0.05952029f, -0.09920748f, -0.03291299f, -0.01315405f, 
    0.08252804f, -0.01993154f, -0.00214367f, 0.01410768f, 0.04110464f, 0.02054978f, -0.05160058f, -0.01733286f, 
    0.01029003f, 0.06483082f, 0.02901425f, 0.07607052f, 0.01297945f, -0.00389781f, 0.00893434f, -0.06677097f, 
    -0.16031793f, 0.11329050f, 0.26331162f, -0.15086913f, -0.50193357f, -0.00868981f, 0.04307958f, -0.01183670f, 
    -0.04362855f, 0.06974378f, -0.05219496f, 0.00228802f, -0.06757601f, 0.03642326f, -0.05195589f, 0.20524547f, 
    0.01926270f, 0.00981006f, 0.14656584f, 0.03924466f, -0.72974062f, 0.47573793f, -0.07578740f, -0.13316371f, 
    -0.07819937f, 0.06887507f, -0.02614918f, -0.03093142f, -0.04215794f, -0.00798604f, -0.00245141f, 0.02490392f, 
    0.08968675f, -0.05440970f, 0.01544805f, 0.00011897f, -0.06285451f, 0.00828747f, 0.09628016f, -0.02829286f, 
    0.15418768f, -0.01908458f, 0.14406712f, -0.19134045f, 0.00680134f, 0.10772924f, 0.03535894f, -0.08974051f, 
    0.01220231f, -0.00536823f, 0.02892127f, -0.02895839f, 0.00537571f, 0.03537298f, -0.05005196f, 0.06312688f, 
    -0.03078743f, -0.02904553f, 0.09495815f, 0.15218699f, 0.14622445f, -0.01945564f, -0.08860325f, -0.05266929f, 
    0.03533601f, 0.01138833f, 0.00158292f, 0.00647953f, -0.00089291f, 0.02477547f, -0.03920857f, 0.04845075f, 
    0.09964089f, -0.05192769f, 0.05531511f, 0.04140926f, 0.04090967f, 0.02439780f, 0.05796606f, 0.03924888f, 
    -0.38921189f, -0.28998625f, 0.25602907f, 0.33148906f, -0.37867233f, 0.00713956f, -0.05740738f, -0.01893419f, 
    0.06312033f, -0.11111355f, 0.02030919f, 0.01046803f, -0.01487327f, 0.03864307f, -0.07800790f, -0.01000412f, 
    -0.01691962f, 0.04932488f, 0.10656723f, -0.10955131f, -0.06645609f, 0.07246044f, -0.08852532f, -0.01092883f, 
    0.03812996f, -0.04372464f, 0.01285049f, -0.05873482f, -0.00362468f, 0.04439080f, 0.03488254f, -0.00371940f, 
    -0.01971800f, 0.01560673f, -0.02101753f, 0.07973487f, -0.01545771f, 0.15470986f, 0.08064554f, -0.04833769f, 
    -0.62521726f, 0.03131748f, 0.01586408f, 0.16168185f, -0.32568640f, -0.13222678f, -0.12312598f, -0.17468081f, 
    -0.08984551f, -0.01995536f, 0.00278901f, -0.02774445f, -0.00701606f, 0.03653453f, -0.03960892f, -0.07055870f, 
    -0.01000091f, 0.11587692f, 0.03690907f, 0.06663017f, 0.08959498f, -0.32126874f, -0.02303985f, -0.11535320f, 
    -0.06162795f, 0.14103512f, 0.08795862f, -0.03755038f, 0.02369394f, 0.01919983f, -0.00760621f, 0.00156335f, 
    0.01417859f, 0.02912059f, -0.05737594f, 0.04717544f, -0.01337967f, -0.00452949f, 0.08740836f, 0.09018470f, 
    -0.03199210f, -0.09139612f, 0.35053104f, 0.15221100f, 0.09861054f, -0.03377088f, -0.05330646f, 0.01909974f, 
    0.11341315f, -0.16452867f, 0.03334375f, -0.02642286f, 0.07012414f, -0.01235809f, 0.04588280f, 0.02756951f, 
    -0.03318511f, 0.00460021f, 0.01533763f, -0.05916486f, 0.10042708f, -0.09582479f, 0.03594093f, -0.01495041f, 
    0.08729583f, 0.10210941f, -0.14886352f, -0.05634623f, -0.03538379f, 0.07843930f, -0.16448539f, -0.05223074f, 
    0.06134383f, 0.01165573f, 0.00540725f, 0.06817180f, -0.03025457f, -0.08901348f, 0.08109400f, -0.08045297f, 
    -0.19623840f, -0.09713714f, 0.04993554f, -0.10659045f, -0.08012740f, 0.04051667f, 0.00648440f, -0.01463959f, 
    0.01793522f, 0.05397715f, 0.04109108f, 0.01058171f, 0.00355585f, 0.06850868f, -0.01022638f, 0.00516717f, 
    0.03195002f, 0.12151629f, -0.03419042f, -0.08753195f, 0.28634748f, 0.03120778f, -0.17466652f, 0.19216292f, 
    0.07155020f, 0.16463977f, -0.14071389f, -0.09467735f, 0.04489792f, 0.01892953f, -0.03436660f, 0.15766202f, 
    0.06257527f, 0.03642535f, -0.05506606f, 0.03846402f, -0.04669021f, 0.01634432f, 0.09682680f, -0.01777699f, 
    -0.43875626f, -0.18161684f, -0.36143968f, 0.11991033f, -0.33803043f, -0.14075175f, 0.00680873f, -0.07767095f, 
    0.01790156f, 0.01740389f, -0.03202692f, -0.03476576f, -0.03592585f, -0.00055553f, -0.01654771f, -0.07976808f, 
    -0.02857171f, -0.03547968f, -0.03484461f, 0.12070995f, -0.16577436f, -0.00068432f, 0.12263623f, -0.06512969f, 
    -0.09104426f, 0.09357863f, -0.05887710f, -0.17651479f, -0.10551597f, 0.04918119f, -0.02099766f, -0.03904372f, 
    -0.00263021f, 0.02259612f, -0.01720729f, 0.10485579f, 0.04527878f, -0.03465577f, 0.09072444f, 0.02063167f, 
    -0.16330262f, -0.27813220f, 0.71107435f, 0.28078946f, 0.35259342f, -0.16746828f, -0.07827885f, -0.00150480f, 
    0.20019069f, -0.10232014f, 0.02417376f, 0.02490212f, 0.04516146f, -0.09372132f, 0.07936028f, 0.04480210f, 
    0.01301124f, -0.00603309f, -0.01787557f, -0.01082866f, -0.06224806f, 0.04602205f, -0.03324748f, -0.05041275f, 
    0.04415215f, -0.03574232f, 0.00531305f, -0.02337518f, 0.02382226f, -0.00130273f, 0.09132473f, 0.02900071f, 
    -0.02945146f, 0.07095782f, 0.08596036f, 0.04145363f, -0.07612824f, 0.01204447f, 0.03275437f, -0.02099263f, 
    -0.11719657f, 0.24662057f, 0.41971758f, 0.01757477f, 0.14615405f, -0.04050916f, -0.00315220f, 0.04115587f, 
    -0.02214152f, 0.05265771f, 0.05994633f, -0.01974698f, 0.00540600f, -0.06068498f, 0.07585196f, 0.01879637f, 
    0.01279549f, -0.01347262f, 0.07589769f, -0.02528884f, 0.16919051f, 0.04434836f, -0.10252069f, -0.04676418f, 
    0.09040646f, 0.04593446f, -0.01058515f, 0.00965523f, 0.00638576f, 0.07378304f, -0.20246437f, 0.06200792f, 
    0.04472265f, 0.04050036f, 0.00245366f, 0.09827004f, -0.07727559f, -0.01106047f, 0.07343581f, 0.02677584f, 
    0.11530097f, -0.05748439f, 0.07518347f, 0.24089658f, 0.00065738f, 0.04303479f, -0.10249768f, 0.03964800f, 
    0.06341721f, -0.20264441f, 0.04290618f, 0.09979013f, 0.03321386f, 0.02383708f, 0.02666451f, -0.01114086f, 
    -0.02146059f, -0.02579266f, 0.07159328f, -0.01358818f, -0.15537447f, 0.09299687f, -0.01045181f, 0.11223088f, 
    0.02278630f, 0.01705246f, -0.09101468f, -0.25511938f, -0.14579631f, -0.24446867f, -0.04821176f, -0.01848932f, 
    0.06524589f, -0.01410842f, -0.02250495f, 0.01404383f, -0.00140297f, -0.04711331f, 0.03037797f, -0.09446968f, 
    0.09423579f, 0.27146021f, 0.18825205f, 0.20592594f, 0.13461962f, 0.09327359f, 0.04143120f, -0.10735021f, 
    0.06580433f, -0.07603600f, -0.01077891f, 0.01647120f, -0.02625795f, -0.08522376f, 0.10521591f, -0.00493559f, 
    0.13243461f, 0.09968334f, -0.02734905f, -0.01485293f, 0.15954201f, 0.05667672f, 0.14650200f, -0.20350328f, 
    0.12801039f, -0.00512451f, -0.00032901f, -0.01187853f, 0.04827013f, 0.00658548f, 0.02198843f, -0.02283992f, 
    -0.02609629f, 0.02388479f, -0.00276732f, -0.04232017f, 0.06101177f, -0.01744104f, 0.06768611f, -0.04963106f, 
    -0.04134087f, -0.02677514f, 0.17349343f, 0.25041524f, 0.04186077f, 0.00030102f, -0.00770438f, 0.04397341f, 
    0.03112709f, 0.03606039f, -0.01092907f, -0.01905456f, 0.03598903f, 0.02152862f, -0.00543952f, -0.03234124f, 
    0.01708079f, -0.01399927f, -0.05937601f, -0.03089389f, 0.02924343f, -0.08008716f, -0.01998427f, -0.00128725f, 
    0.05887730f, 0.02466657f, -0.05912564f, 0.00849995f, 0.06292739f, 0.01340717f, -0.12776686f, -0.11977754f, 
    -0.02512545f, -0.03553208f, -0.06537186f, -0.00839337f, -0.08054408f, -0.02990437f, 0.00983063f, -0.00792044f, 
    0.04715743f, -0.00741860f, 0.18716846f, -0.19381884f, -0.06754304f, -0.01790492f, -0.11105999f, -0.13142829f, 
    -0.09325016f, 0.07086870f, -0.04391997f, 0.05694691f, -0.08560688f, -0.04086666f, -0.01356482f, 0.09282782f, 
    0.03990097f, -0.28227773f, 0.01822431f, 0.01417444f, -0.17464499f, -0.34918717f, -0.13725129f, -0.13954942f, 
    -0.23260713f, 0.01327149f, 0.06223983f, -0.04300520f, 0.15107197f, -0.14269133f, -0.01718649f, -0.00947555f, 
    0.03142209f, 0.02965587f, -0.02871583f, 0.00494134f, 0.00283985f, -0.02748683f, -0.04243797f, -0.00496510f, 
    -0.10583451f, -0.00691986f, -0.14506327f, 0.33269459f, -0.11468019f, -0.00594224f, 0.06856471f, -0.03551196f, 
    -0.14663868f, 0.26639009f, 0.02040975f, 0.01461787f, 0.08094516f, 0.03231200f, -0.10071322f, 0.03899880f, 
    0.04246438f, -0.04347390f, -0.00053254f, -0.02743840f, -0.45055586f, -0.08053865f, 0.01677194f, -0.29285827f, 
    -0.21748051f, -0.09749658f, -0.06999891f, -0.26998034f, -0.17018317f, 0.08724385f, -0.00046650f, -0.06441499f, 
    0.02257121f, -0.00084626f, -0.00131438f, 0.08941570f, 0.03885799f, -0.13431868f, 0.07286508f, 0.02126994f, 
    -0.19703846f, 0.55332482f, 0.31951165f, 0.03094088f, 0.17327432f, -0.18394294f, 0.00923680f, -0.03688013f, 
    -0.04477597f, 0.09637786f, 0.01821174f, 0.14493249f, -0.14449988f, 0.02331794f, 0.08502260f, 0.02533457f, 
    -0.06098190f, -0.04012591f, 0.02146086f, -0.04290322f, 0.04138324f, 0.04323408f, 0.13804831f, 0.00338987f, 
    0.10918162f, 0.00535581f, -0.05919736f, -0.00648362f, 0.07663241f, -0.20948711f, -0.03148962f, -0.04161899f, 
    0.02230721f, -0.00504565f, 0.03314862f, 0.04919400f, -0.08044851f, -0.06226359f, 0.00978789f, -0.02283131f, 
    -0.07496738f, -0.03279752f, -0.03748486f, -0.06431027f, 0.04788325f, -0.02022635f, -0.01974428f, -0.04779792f, 
    0.00635041f, 0.03433912f, 0.00115546f, -0.05829788f, -0.02396991f, 0.00492411f, 0.00423349f, 0.03254845f, 
    -0.02026081f, 0.00374409f, 0.04949579f, -0.03015154f, 0.42101485f, 0.17583936f, -0.30920011f, -0.02913970f, 
    0.14750376f, -0.20627727f, 0.16054708f, -0.06198701f, -0.05106439f, -0.06809565f, -0.05116308f, -0.02520930f, 
    -0.00898861f, -0.03910913f, -0.03335369f, 0.04528945f, -0.03578668f, 0.06890396f, -0.05234373f, -0.02799504f, 
    -0.06666404f, -0.03244241f, 0.40134555f, 0.02645689f, 0.05326126f, -0.00498972f, -0.01280587f, 0.05353198f, 
    0.03477802f, -0.02547235f, 0.08287805f, -0.03215057f, -0.04736856f, 0.05563159f, 0.14645916f, 0.04115514f, 
    -0.03057449f, 0.05511329f, 0.08217943f, -0.05913474f, 0.04626623f, 0.01413573f, 0.00804144f, -0.00886488f, 
    0.08914984f, -0.01795490f, -0.02388274f, 0.05687758f, 0.00069386f, 0.00825523f, -0.04682772f, 0.01450275f, 
    -0.11653874f, -0.01960101f, 0.01625881f, 0.02527577f, -0.09191543f, 0.00574736f, -0.02252942f, -0.01850901f, 
    -0.13379253f, -0.26860124f, -0.08396747f, -0.13718916f, -0.02730300f, -0.01450842f, -0.05740939f, -0.06491818f, 
    -0.01275637f, 0.02031754f, -0.05918924f, -0.10097872f, -0.03400979f, 0.00207847f, 0.00526002f, -0.06406540f, 
    -0.12372784f, -0.04497741f, 0.04999050f, -0.01261520f, 0.17064759f, 0.03161175f, -0.06782205f, 0.05942609f, 
    0.09327517f, -0.06807643f, -0.01183632f, -0.11007860f, 0.02962114f, 0.05137495f, 0.02028676f, -0.00109383f, 
    0.04839683f, 0.01268591f, -0.02554929f, 0.01845603f, 0.01029083f, -0.00320753f, -0.02842216f, 0.00325840f, 
    0.30609557f, -0.28285268f, -0.05253556f, -0.06699093f, 0.03909330f, 0.03742909f, -0.08648374f, 0.02002300f, 
    0.00720343f, -0.04281652f, 0.05726093f, -0.08104138f, -0.02707077f, 0.11439632f, 0.12512054f, 0.11947031f, 
    -0.02467131f, -0.10765127f, 0.15090223f, -0.09528373f, -0.09524962f, -0.07139097f, -0.01705787f, -0.13560089f, 
    0.01295174f, -0.07008592f, -0.14766169f, -0.12570703f, 0.00559346f, 0.06726262f, -0.01713402f, -0.05416986f, 
    0.06988912f, -0.00405886f, -0.06614603f, -0.05985245f, -0.07279626f, -0.03657453f, -0.02014470f, -0.00346349f, 
    -0.10404152f, -0.00175840f, -0.10163525f, -0.05405300f, -0.01959578f, 0.03124110f, -0.02800701f, 0.00317602f, 
    -0.02308996f, 0.01731726f, -0.06981433f, -0.13865775f, 0.04866630f, -0.06648216f, 0.01200042f, -0.01272563f, 
    -0.05767107f, -0.05470265f, 0.09549490f, 0.00104221f, -0.15682444f, -0.00832806f, 0.39077356f, 0.41413960f, 
    0.05415971f, 0.05319474f, 0.01255139f, -0.08745132f, 0.20370708f, -0.04771079f, -0.03328861f, 0.04779907f, 
    -0.00400774f, 0.03234055f, -0.14196910f, 0.01658084f, -0.00166898f, 0.00352325f, -0.02053418f, 0.01094891f, 
    -0.24896605f, -0.48251528f, -0.66928822f, 0.07042418f, -0.40625307f, -0.06143447f, 0.05531168f, -0.01121990f, 
    0.03098870f, 0.11019044f, -0.01906514f, -0.00752343f, -0.00218884f, -0.06617375f, -0.04012457f, -0.02544016f, 
    0.00372533f, 0.00169237f, -0.05438975f, 0.07466522f, -0.58601880f, 0.05980240f, 0.30220354f, -0.10105090f, 
    -0.07804833f, -0.07527624f, -0.12694895f, -0.22671355f, -0.05486196f, -0.08380494f, 0.02457262f, -0.02264391f, 
    0.00581722f, -0.02233768f, 0.02002307f, 0.05684003f, -0.02352319f, 0.11912037f, 0.02941937f, 0.04445658f, 
    -0.17579943f, 0.09362508f, 0.10749561f, -0.01949044f, -0.01058614f, -0.02190361f, -0.07516085f, -0.01450590f, 
    -0.02843118f, 0.08760864f, -0.06031962f, -0.10818875f, -0.07851711f, -0.13048778f, 0.04515984f, 0.02049480f, 
    0.04499483f, -0.02035765f, 0.02242972f, -0.06049750f, 0.04330197f, 0.04662719f, -0.36611819f, -0.15595239f, 
    0.06949723f, 0.13913104f, 0.02719847f, -0.06470519f, -0.10847573f, 0.03180570f, -0.07075460f, 0.08050490f, 
    0.02124439f, 0.06451851f, -0.06660967f, 0.13075489f, -0.03548335f, -0.01581552f, 0.01600372f, 0.00494108f, 
    0.16318677f, 0.05942975f, 0.13620265f, 0.18626760f, 0.13341485f, -0.07816722f, 0.07541808f, 0.05799955f, 
    0.03926850f, 0.08889738f, 0.00324584f, -0.00919478f, -0.04215078f, 0.09397337f, 0.00119114f, 0.04481014f, 
    0.01691697f, -0.07394888f, -0.09160637f, 0.11814974f, 0.37431297f, 0.04461765f, -0.33936608f, 0.15314844f, 
    -0.00679643f, -0.04799976f, 0.09443174f, -0.00177546f, -0.04103469f, 0.05840860f, 0.01012463f, -0.03327961f, 
    0.00767802f, 0.00590168f, -0.02538444f, 0.02626987f, -0.00462929f, 0.07023801f, -0.08615471f, -0.03404913f, 
    -0.23932168f, 0.00326627f, 0.23446295f, -0.01563039f, -0.00108469f, -0.00381605f, 0.01695700f, -0.06735899f, 
    -0.00238789f, 0.06108020f, 0.01833901f, -0.01430283f, 0.01495097f, 0.01810439f, -0.00384955f, 0.08985929f, 
    -0.05579203f, -0.05030978f, -0.01847973f, -0.00113251f, -0.48288238f, -0.68109685f, -0.07605186f, -0.10224919f, 
    -0.27938715f, 0.00445012f, 0.01363910f, 0.03056961f, 0.01805735f, -0.07029640f, -0.05955691f, -0.01835237f, 
    -0.01834314f, -0.04123687f, -0.00455851f, -0.12282714f, -0.04343968f, -0.07035732f, 0.05120375f, 0.17236371f, 
    -0.83448744f, -0.04650408f, -0.37237275f, 0.03585997f, -0.57396436f, 0.12475038f, 0.17534775f, -0.17637655f, 
    -0.01880350f, -0.12543404f, -0.01409615f, 0.01001763f, -0.06841576f, 0.04346824f, -0.08950306f, 0.02725770f, 
    0.02548563f, -0.04205089f, -0.04422185f, 0.04301034f, 0.16949648f, -0.03395829f, 0.09813784f, 0.07526646f, 
    0.05322590f, 0.08379926f, -0.10309355f, -0.09948238f, -0.01394854f, -0.10566895f, 0.06303476f, 0.06536613f, 
    0.03056202f, 0.02758449f, 0.02123374f, 0.01149717f, -0.01987730f, -0.04701786f, 0.07665858f, -0.04482163f, 
    -0.67364103f, -0.36450800f, -0.36095142f, -0.05264804f, -0.35782525f, 0.09234498f, 0.08586796f, -0.15116526f, 
    -0.01404245f, -0.09483178f, 0.04319935f, 0.01389226f, 0.01219596f, -0.00304996f, -0.07546940f, -0.02701387f, 
    0.00904564f, 0.00206778f, -0.13548999f, -0.09032888f, -0.00921451f, -0.05989356f, -0.01558820f, 0.03260963f, 
    0.00987344f, 0.05287594f, 0.02306805f, -0.07019944f, -0.12824982f, -0.13896181f, 0.00738568f, -0.02153119f, 
    -0.01508659f, 0.03516259f, 0.00620617f, 0.07405069f, -0.02400632f, -0.04532712f, -0.00254036f, -0.12366124f, 
    0.57774717f, 0.38681570f, -0.36617416f, 0.20801713f, 0.19625561f, -0.10103185f, -0.07080759f, -0.12650114f, 
    -0.04409512f, 0.01440960f, -0.04344376f, -0.03462382f, 0.01818226f, -0.08686914f, -0.05713054f, -0.09931012f, 
    0.08771974f, 0.05737066f, -0.24491319f, 0.07192849f, 0.04875807f, 0.11143314f, -0.12410720f, 0.22545950f, 
    0.07236893f, 0.00096479f, -0.04431396f, 0.03349643f, -0.08190341f, 0.03117592f, -0.00992396f, 0.04804827f, 
    0.02960142f, 0.03322977f, 0.01096173f, -0.00335065f, -0.03423136f, 0.00557362f, -0.04039800f, -0.02641723f, 
    -0.00384306f, -0.16445178f, 0.18535608f, -0.20064516f, -0.12121969f, 0.01780755f, 0.04161569f, -0.07741865f, 
    -0.00539390f, 0.02510172f, -0.01324542f, -0.00331360f, -0.04443426f, 0.04579928f, -0.02186805f, 0.12978472f, 
    -0.05951623f, -0.22598605f, 0.03258496f, -0.05702950f, -0.27407825f, -0.17845547f, 0.26274690f, -0.10079726f, 
    -0.05462835f, 0.01511117f, 0.01679417f, -0.00720382f, 0.04985363f, 0.00742099f, 0.02089741f, 0.00836984f, 
    -0.00545228f, 0.01328494f, -0.02067011f, 0.05825054f, 0.01728134f, 0.08129180f, 0.00160517f, 0.00854459f, 
    0.19562890f, 0.03909833f, 0.26912215f, -0.43326330f, 0.05216090f, -0.00076856f, 0.08192944f, -0.04748950f, 
    0.09814152f, 0.12858476f, 0.10843252f, -0.00663781f, 0.02680022f, -0.04107926f, 0.13159524f, 0.05118318f, 
    0.06265995f, -0.04917433f, 0.03098956f, -0.08309373f, -0.17356005f, -0.08913269f, -0.06174465f, -0.00455814f, 
    -0.14235495f, -0.04247663f, -0.02919819f, -0.04961273f, -0.08004670f, -0.12906583f, 0.00726309f, -0.00936432f, 
    -0.01611426f, -0.03615387f, -0.11760908f, -0.01591968f, -0.08561007f, 0.11535051f, -0.13470173f, -0.11772258f, 
    -0.48793706f, -0.35336664f, 0.12587900f, -0.02649926f, -0.15542547f, -0.08255965f, 0.02295065f, -0.00579171f, 
    0.11147550f, 0.09171050f, 0.03568049f, 0.11580320f, 0.04823969f, -0.05154613f, 0.03434160f, -0.00364021f, 
    -0.01319101f, -0.03456069f, -0.07900242f, 0.04902464f, 0.03163882f, -0.11832364f, -0.09164056f, -0.06900666f, 
    0.14998409f, 0.04868186f, 0.00709896f, -0.06145937f, 0.03135157f, -0.07519604f, 0.06912744f, -0.00080396f, 
    0.01247897f, -0.04946513f, 0.04177758f, -0.06327026f, -0.01630085f, 0.08022246f, -0.11082742f, 0.01922403f, 
    0.31364870f, 0.31551352f, -0.12340596f, -0.37335819f, 0.18811834f, 0.08057099f, 0.00692582f, -0.00547708f, 
    0.00386139f, -0.13369782f, 0.04452621f, -0.00090671f, -0.09490576f, -0.04231802f, -0.04143688f, 0.10452206f, 
    0.08039448f, -0.06262619f, 0.05068815f, -0.05245494f, -0.13716714f, 0.03784243f, 0.73784560f, -0.19024199f, 
    0.53471291f, -0.41899538f, 0.20604523f, 0.12074953f, -0.10495800f, -0.03211736f, 0.12844500f, -0.00816791f, 
    -0.08158813f, 0.09149528f, 0.14527863f, -0.04604665f, -0.12884003f, 0.15284646f, -0.11834408f, -0.03294498f, 
    -0.52611482f, 0.52541262f, -0.10349663f, -0.33697486f, -0.12973194f, 0.19588690f, 0.14469622f, -0.00434189f, 
    0.01228915f, 0.01413375f, -0.01971041f, -0.10378235f, -0.02367328f, -0.07514917f, -0.02991042f, 0.01063362f, 
    0.03022251f, 0.00938239f, 0.06582940f, 0.02647540f, 0.13271067f, -0.13510191f, -0.11024361f, -0.06769992f, 
    -0.31816849f, 0.11580078f, -0.09220705f, 0.03313466f, -0.00515421f, -0.08114237f, -0.16154362f, -0.02261633f, 
    0.01520036f, -0.02499565f, -0.05481611f, -0.01480692f, -0.02993459f, -0.12348370f, -0.01939093f, -0.00094981f, 
    -0.04991274f, -0.19386353f, -0.12861909f, 0.18343414f, 0.23584197f, -0.07538468f, 0.02439447f, -0.15202294f, 
    -0.01721406f, 0.00452139f, 0.00385992f, -0.01572029f, 0.04613093f, 0.03270911f, -0.09089613f, -0.01907872f, 
    0.08386704f, -0.08649160f, 0.00644418f, -0.01939928f, -0.71017200f, -0.10309964f, -0.07307387f, 0.22915980f, 
    -0.01787178f, -0.03151199f, -0.08733580f, 0.06711715f, -0.15981816f, 0.06084201f, -0.10250030f, 0.06022792f, 
    -0.14276631f, 0.00922074f, 0.25235337f, -0.02654593f, -0.02066330f, 0.04026765f, -0.06589559f, -0.14879888f, 
    0.22588101f, 0.02945398f, 0.07613213f, -0.30121383f, 0.19782045f, -0.04634399f, 0.09991626f, 0.01534962f, 
    0.01665425f, -0.05406523f, 0.00136335f, -0.04389223f, 0.00225757f, -0.04439820f, 0.11539762f, -0.12657379f, 
    -0.11348180f, -0.07522278f, 0.09415703f, -0.00106370f, -0.42542875f, 0.48938352f, -0.00296063f, -0.19946003f, 
    -0.53225899f, 0.16603979f, -0.04789639f, -0.08032391f, -0.02573664f, -0.07234202f, 0.17045343f, -0.10697968f, 
    0.09063245f, -0.23603888f, -0.12447188f, 0.00626750f, 0.10893680f, -0.11490561f, 0.10555307f, -0.08587523f, 
    0.02141063f, 0.01201259f, -0.28473806f, 0.06797728f, 0.26527143f, 0.03147470f, 0.07632206f, -0.05875753f, 
    0.01143690f, 0.08594108f, -0.03555527f, 0.11476641f, -0.04995341f, -0.01519754f, 0.00665877f, -0.07903598f, 
    0.00404508f, 0.07511378f, 0.12633270f, -0.00246741f, -0.99238634f, 0.45042032f, 0.07094004f, -0.30696002f, 
    -0.16200243f, 0.01875938f, 0.06242280f, 0.04891691f, -0.09295898f, -0.12569861f, -0.06870631f, 0.03533154f, 
    -0.11222309f, 0.04774462f, -0.12797886f, -0.02749656f, -0.00294520f, 0.07557695f, -0.05006587f, -0.13332047f, 
    -0.35766041f, -0.10466198f, -0.02318268f, 0.13814968f, 0.10844575f, -0.03534822f, 0.05197119f, 0.07686201f, 
    -0.00852968f, -0.02027898f, 0.03633558f, 0.04180481f, 0.02583679f, -0.03237638f, 0.00017529f, 0.03539263f, 
    0.01218954f, 0.11892068f, 0.04735966f, -0.09272566f, 0.09820223f, 0.02587754f, -0.07689936f, -0.12394106f, 
    0.12663206f, -0.03252840f, 0.03606905f, 0.00892584f, 0.07336590f, 0.02058225f, 0.02406355f, -0.07818918f, 
    -0.04163602f, -0.01154972f, 0.03126341f, -0.04999997f, -0.03664482f, -0.06488229f, -0.04688398f, 0.06435413f, 
    -0.49081761f, 0.44857344f, -0.07208675f, -0.14015928f, 0.30198753f, 0.28202307f, 0.09952026f, -0.05231657f, 
    0.03235295f, -0.05818361f, -0.17552060f, 0.00635864f, 0.01416584f, 0.04705988f, 0.07334762f, -0.07377949f, 
    -0.01691604f, -0.04600682f, 0.04816290f, -0.03355753f, -0.02176041f, 0.04986639f, -0.02975747f, -0.37616518f, 
    -0.05782508f, 0.05564046f, -0.02274979f, 0.16898307f, 0.05205809f, 0.13954061f, -0.15205087f, -0.07043351f, 
    -0.12596588f, -0.02624054f, -0.06280365f, 0.02048869f, -0.07156032f, -0.11054539f, -0.00319383f, -0.11638819f, 
    -0.13655618f, -0.32127088f, 0.22179447f, -0.03747218f, -0.08311082f, -0.10740347f, -0.07889215f, -0.02282132f, 
    -0.04654802f, -0.08078239f, 0.01604592f, -0.06137657f, 0.01533417f, 0.01747128f, -0.06220463f, -0.10865252f, 
    -0.10547774f, 0.02806689f, -0.04061430f, -0.08920426f, 0.15582900f, 0.54700071f, 0.30759242f, -0.30867043f, 
    0.38905239f, 0.06135097f, 0.07281800f, -0.03961890f, 0.04296364f, -0.25157499f, -0.09268586f, -0.00387830f, 
    -0.18924966f, -0.01233668f, -0.17059249f, -0.03918653f, -0.04273799f, 0.07169383f, 0.03489645f, -0.12672986f, 
    -0.23108405f, -0.13083841f, 0.02042609f, -0.03831297f, 0.09673975f, -0.05601512f, 0.10664678f, 0.07743202f, 
    -0.01243276f, 0.04713936f, -0.00317034f, 0.00310022f, -0.00447435f, -0.00716175f, -0.04288162f, 0.04237767f, 
    0.04089753f, 0.19665350f, -0.08263209f, -0.07646877f, -0.04166280f, 0.26715413f, -0.11886884f, 0.37641302f, 
    0.41503701f, -0.18047658f, -0.00215804f, -0.05480096f, -0.04138936f, -0.09937578f, -0.07845221f, -0.03448959f, 
    0.05188781f, -0.09951395f, -0.09555781f, -0.06309070f, 0.07390392f, 0.02596521f, 0.08765570f, -0.00258013f, 
    -0.25563395f, 0.37162563f, 0.03131715f, -0.20365064f, 0.26321232f, 0.31713963f, 0.06077941f, -0.10060954f, 
    -0.05871072f, -0.01118166f, -0.21391408f, -0.01992313f, 0.06545983f, 0.03113789f, 0.18561643f, -0.07016943f, 
    0.03207288f, -0.10035969f, 0.06509071f, 0.06162168f, -0.12305579f, -0.14857571f, 0.04790291f, -0.19933504f, 
    -0.15653963f, -0.09053524f, 0.07528792f, -0.04398943f, -0.00735731f, -0.09912922f, 0.07202245f, -0.01737901f, 
    -0.08723503f, -0.05407696f, 0.01096779f, -0.10753984f, -0.02256555f, 0.13882948f, -0.09023662f, -0.15414444f, 
    -0.08282494f, 0.39642441f, 0.07730089f, 0.12240237f, 0.24202335f, 0.07915669f, -0.01652191f, 0.02984968f, 
    -0.06707951f, 0.05702137f, -0.07374917f, -0.00385892f, 0.04916206f, 0.02822502f, 0.08482219f, 0.02695590f, 
    -0.05437883f, 0.00585745f, -0.01143701f, -0.04035841f, 0.43522197f, 0.67130446f, -0.08341880f, -0.52935833f, 
    -0.39893639f, -0.09168229f, -0.19456293f, -0.01101550f, -0.28381631f, 0.06297369f, -0.12954094f, -0.15941676f, 
    0.00339339f, 0.02653811f, 0.05913500f, -0.01903211f, 0.10313085f, -0.15313524f, -0.04261990f, 0.04228807f, 
    -0.05739465f, -0.27080613f, -0.33547375f, -0.00989446f, 0.29921132f, 0.14933148f, 0.09141116f, 0.03289193f, 
    -0.03098367f, -0.08503000f, -0.01046345f, 0.10671394f, 0.01734154f, 0.07964144f, -0.00914038f, -0.09400340f, 
    -0.02504636f, 0.11685840f, 0.07025366f, -0.09334363f, -0.28752282f, 0.05768827f, -0.20391245f, 0.17970879f, 
    0.16434963f, 0.07388267f, 0.03459013f, 0.09615469f, -0.02091907f, 0.10419769f, 0.05116404f, 0.02180493f, 
    -0.01976822f, -0.00631517f, -0.11955493f, 0.09751522f, 0.02533039f, 0.13404968f, 0.06360771f, -0.15366879f, 
    -0.46555513f, 0.34067956f, 0.03127767f, 0.03834286f, 0.11439785f, 0.02402212f, -0.03701456f, -0.03176535f, 
    -0.01830245f, -0.02668031f, -0.16075772f, 0.04983526f, -0.04640476f, -0.07817642f, 0.06129399f, 0.00370435f, 
    -0.00696812f, 0.05813206f, -0.08347517f, -0.14538717f, 0.67665827f, 0.34000057f, 0.29703042f, -0.73327649f, 
    -0.03417952f, -0.16610651f, -0.09216588f, 0.10175505f, -0.14746755f, 0.02932222f, -0.00652218f, -0.06459976f, 
    0.09351634f, 0.02379010f, 0.08275081f, 0.03521272f, -0.05841671f, -0.09245136f, 0.10159133f, -0.00490825f, 
    -0.01177780f, -0.03165955f, -0.19746664f, -0.04810361f, 0.24855103f, 0.00729036f, -0.04174138f, -0.03692729f, 
    -0.05062182f, -0.08643404f, 0.04726360f, 0.07474090f, 0.00686921f, 0.11583785f, 0.06760338f, -0.05230545f, 
    0.08963347f, 0.11996804f, -0.08738723f, -0.00754646f, -0.14125583f, -0.10678325f, -0.05089324f, -0.08157247f, 
    -0.07047267f, 0.04005140f, 0.04891758f, -0.04114354f, 0.03862030f, -0.01274452f, -0.08762561f, -0.08414051f, 
    -0.04260113f, -0.04508820f, -0.12632753f, 0.07211225f, 0.03113335f, 0.00258954f, 0.00755476f, -0.14927235f, 
    -0.53469306f, 0.11902031f, -0.01245483f, 0.08230678f, 0.40291637f, -0.07872701f, 0.10564402f, -0.11258706f, 
    -0.19630271f, 0.06079709f, 0.09752551f, -0.09102959f, 0.00618862f, -0.01453061f, -0.18776925f, 0.01282824f, 
    0.08402490f, 0.18339400f, -0.03082737f, -0.21011743f, 0.03990258f, -0.06456630f, -0.16291855f, -0.04844011f, 
    0.24631523f, 0.17494433f, 0.07165740f, 0.07596005f, 0.04323352f, 0.04464914f, -0.00094861f, 0.10851923f, 
    0.04411239f, 0.01321551f, 0.03670196f, 0.01390464f, -0.02065361f, 0.07237515f, 0.02398865f, 0.08700360f, 
    0.03523970f, 0.03083311f, -0.10289183f, -0.22415173f, 0.19073117f, -0.06335750f, 0.02128083f, -0.10234499f, 
    0.09870909f, -0.08181439f, 0.01627357f, 0.01562551f, -0.20435919f, -0.07646508f, 0.05752699f, -0.01347469f, 
    0.14420684f, 0.01626756f, -0.09224002f, 0.03781827f, -0.00043442f, 0.20521210f, 0.13431574f, 0.40538645f, 
    0.28579524f, -0.07695298f, -0.29152280f, 0.00491886f, 0.09554114f, -0.08629046f, 0.01610415f, 0.04947152f, 
    -0.05529618f, 0.02604113f, -0.03553993f, -0.19512057f, 0.01466290f, -0.01522644f, 0.02428652f, -0.12350211f, 
    -0.16369858f, 0.06229575f, 0.01240450f, 0.00832937f, 0.36276704f, -0.03561474f, -0.03472767f, 0.11457657f, 
    -0.09728960f, -0.08025349f, -0.06696919f, 0.13014941f, 0.00932398f, 0.07499553f, 0.11975443f, 0.05426815f, 
    0.04001421f, 0.16664907f, -0.01294025f, -0.03014152f, -0.17534915f, -0.05705917f, -0.18470970f, 0.03272877f, 
    0.24896151f, 0.09706178f, 0.00138959f, 0.06418188f, -0.01580222f, 0.00760024f, -0.06657650f, 0.05350569f, 
    0.07122868f, -0.02669977f, -0.00099395f, 0.10022242f, 0.01830493f, -0.06411539f, 0.01541867f, 0.05528644f, 
    -0.38753194f, -0.20777194f, -0.18163942f, -0.06380058f, -0.12675674f, -0.03591679f, -0.16103812f, 0.06449379f, 
    -0.06821846f, -0.09740537f, 0.00667530f, 0.02768416f, -0.00890253f, 0.01433004f, -0.13802125f, 0.05671069f, 
    0.04130672f, -0.04588505f, 0.03918243f, -0.11520650f, 0.45644149f, 0.46783334f, -0.09719085f, -0.42776623f, 
    -0.06719586f, -0.18975465f, -0.04867749f, -0.03966548f, -0.16537853f, -0.09007074f, 0.01508537f, 0.05258395f, 
    -0.04073520f, 0.01838504f, 0.05349006f, 0.11729565f, 0.01992856f, -0.13508917f, -0.06318691f, -0.04189210f, 
    0.41268358f, 0.10924000f, -0.11732386f, 0.04105266f, 0.00060774f, 0.18165380f, 0.09526129f, 0.04171612f, 
    0.00960188f, -0.00291147f, -0.11745717f, -0.00402161f, 0.06016060f, 0.06949209f, -0.02831207f, -0.07353343f, 
    -0.08372197f, 0.00779164f, 0.08319332f, -0.04396773f, -0.15545838f, -0.06470751f, -0.13307111f, -0.16214003f, 
    -0.11598720f, 0.01524301f, -0.02967215f, 0.06222092f, -0.06470880f, -0.05970074f, -0.09917591f, -0.03941211f, 
    -0.14267679f, -0.07997821f, -0.02011677f, 0.05134914f, 0.03752478f, 0.00606865f, -0.00144401f, -0.04063651f, 
    -0.23326686f, -0.25785977f, -0.26245633f, -0.05420928f, -0.36102641f, 0.20141228f, -0.06400396f, 0.01347441f, 
    0.06856155f, 0.03353516f, -0.08719224f, -0.00465461f, 0.08203164f, 0.07222129f, -0.01952646f, -0.02288714f, 
    0.01174545f, -0.03165813f, -0.13669187f, -0.09216467f, 0.00350627f, 0.01241981f, -0.05480391f, -0.23878798f, 
    0.17157498f, 0.06114028f, 0.03016311f, -0.01813604f, 0.01529215f, 0.03647180f, 0.03697909f, 0.08180494f, 
    -0.00513072f, -0.00831769f, 0.00120599f, 0.15868980f, 0.01598299f, 0.08653285f, 0.10023815f, 0.12692752f, 
    0.12510023f, 0.03073323f, 0.14946704f, -0.10908147f, -0.09820804f, -0.08167689f, -0.09946927f, -0.08375298f, 
    -0.18445715f, -0.09367744f, -0.14002873f, -0.17266303f, 0.02596072f, 0.17320907f, 0.01848671f, -0.00238783f, 
    -0.00365632f, 0.07514314f, -0.03716126f, -0.04106530f, -0.24393496f, -0.67286497f, -0.19283089f, -0.04107500f, 
    -0.14895876f, -0.00234313f, -0.00948811f, 0.05118774f, 0.01013773f, -0.20539457f, 0.15821567f, 0.04659386f, 
    0.13395426f, -0.03773208f, 0.13286784f, 0.12633881f, 0.18707392f, 0.14719227f, -0.00332425f, -0.16233934f, 
    -0.20559536f, -0.15370257f, -0.22588955f, 0.02889261f, -0.10049335f, 0.17310128f, -0.08092465f, 0.09965047f, 
    0.05431732f, 0.07502475f, 0.05039460f, -0.10316891f, -0.07678866f, -0.11018744f, -0.05109042f, 0.02457635f, 
    -0.05080311f, 0.00620256f, 0.01286391f, -0.21736142f, -0.11083169f, 0.14884925f, -0.01426819f, -0.12354703f, 
    0.30330968f, 0.05925962f, 0.06005035f, -0.06808267f, -0.00065993f, -0.03465719f, -0.12168784f, 0.07538025f, 
    -0.06552954f, 0.03468806f, 0.12594020f, -0.07512018f, 0.00350012f, 0.05977158f, 0.12263453f, 0.07753891f, 
    -0.12645853f, 0.09408570f, -0.14216660f, 0.06731334f, 0.09460098f, 0.02514068f, -0.00203838f, -0.02638450f, 
    0.03710151f, -0.00470062f, -0.12987883f, 0.04069088f, -0.06963667f, -0.14115378f, -0.08121670f, 0.01684236f, 
    -0.01605917f, 0.19033077f, -0.17541803f, -0.11353680f, -0.10972133f, -0.14680724f, 0.11617744f, 0.03246377f, 
    0.13525231f, -0.15045603f, 0.03568238f, 0.11874490f, 0.05893193f, 0.01010860f, 0.05699215f, 0.06107682f, 
    -0.00783295f, 0.07217365f, 0.12966880f, -0.10393121f, -0.03068118f, 0.09022140f, -0.03354843f, -0.05004352f, 
    0.48972082f, 0.13780732f, -0.16033022f, 0.32169616f, -0.08073752f, 0.26246408f, 0.05431361f, 0.09885143f, 
    0.03293299f, 0.03716239f, -0.07450052f, -0.16652261f, -0.02824795f, -0.03784725f, -0.07837683f, -0.03689721f, 
    -0.15799595f, 0.01448827f, -0.02578134f, -0.07482563f, 0.78202003f, -0.03291117f, 0.11418293f, -0.42240673f, 
    -0.36707193f, 0.07485187f, 0.11383928f, 0.04882221f, -0.01707079f, -0.18769860f, 0.14433099f, 0.09561465f, 
    0.25160411f, -0.13801464f, -0.14815502f, -0.21697603f, -0.04070041f, -0.14367853f, 0.13378416f, 0.03923153f, 
    0.07900150f, 0.13749492f, -0.14027791f, -0.14515543f, 0.06777898f, -0.00459540f, -0.03466671f, -0.00047334f, 
    -0.01849505f, -0.02718799f, -0.12451962f, -0.03888169f, -0.07278919f, 0.06655133f, 0.03032615f, -0.04763267f, 
    0.08447421f, 0.07388967f, -0.11046004f, 0.09954555f, -0.02480979f, 0.03556488f, -0.11939099f, -0.17916241f, 
    0.11818880f, -0.00226179f, -0.00424178f, -0.05631318f, -0.03234150f, -0.11508800f, -0.01859624f, 0.02113527f, 
    -0.15659229f, -0.01167720f, 0.03710665f, 0.04703112f, -0.09652332f, 0.00351492f, -0.24762394f, -0.00941651f, 
    -0.25068936f, 0.00365333f, 0.36630535f, 0.32532972f, 0.37770179f, -0.13612457f, -0.03801990f, -0.08031543f, 
    0.02440414f, -0.12522009f, -0.01573830f, 0.01743372f, 0.02331968f, -0.02340234f, 0.06483608f, -0.08796730f, 
    0.03625153f, -0.03129482f, 0.00427800f, 0.02421715f, 0.06765324f, -0.21368174f, -0.08589610f, -0.00476798f, 
    0.23970091f, -0.01984734f, 0.12087274f, -0.00585983f, 0.04851289f, 0.08536102f, -0.05240320f, -0.00849701f, 
    -0.06700248f, -0.13025577f, -0.04773930f, -0.00706877f, -0.02271885f, 0.01366244f, -0.02536279f, -0.09033775f, 
    -0.08154460f, -0.02388226f, -0.14860559f, 0.07991978f, 0.19461080f, -0.01485962f, 0.11897734f, 0.12265436f, 
    0.09092665f, 0.09561462f, 0.05476027f, 0.00414413f, 0.06699378f, -0.06448238f, -0.07261311f, -0.00745523f, 
    0.02107750f, -0.07793298f, 0.02096668f, -0.01702828f, -0.08050752f, -0.14771917f, -0.13014556f, -0.03939192f, 
    0.17081103f, 0.07752695f, 0.14880566f, 0.07850758f, -0.05800080f, -0.04633858f, 0.00915177f, 0.05680434f, 
    0.01659885f, 0.04372463f, -0.10034007f, -0.02482645f, 0.06727485f, 0.00839890f, 0.09459778f, -0.03265620f, 
    0.04101888f, -0.04970377f, -0.19836819f, 0.03273521f, 0.12000339f, 0.02118753f, 0.14652704f, 0.10243428f, 
    0.10523870f, 0.06130134f, 0.06934299f, -0.03505430f, -0.02253920f, 0.10447686f, 0.00962148f, 0.00281287f, 
    -0.09604269f, 0.19579314f, -0.20179218f, 0.01982531f, -0.05134463f, 0.02824447f, -0.02656811f, -0.01666832f, 
    0.18441167f, -0.06555821f, 0.04019187f, -0.04139018f, -0.05614577f, 0.03480758f, 0.03890064f, -0.03050010f, 
    -0.01202811f, -0.06641549f, -0.00046924f, -0.03399903f, -0.07385253f, -0.06334185f, -0.02316776f, -0.06353381f, 
    -0.10269952f, 0.15650123f, -0.00251520f, -0.20093499f, 0.13589141f, 0.04086384f, 0.04742441f, -0.19219536f, 
    -0.06857877f, -0.12225376f, -0.16257095f, 0.05894590f, -0.00698977f, -0.05581496f, 0.03283085f, 0.14991051f, 
    0.01657965f, -0.08757643f, -0.16817681f, -0.12648365f, 0.07556359f, -0.02649457f, -0.20192111f, -0.13442104f, 
    0.21103652f, 0.09578048f, 0.01634486f, -0.02747946f, 0.05157389f, -0.12314656f, 0.05327741f, 0.10722173f, 
    -0.04262028f, 0.09223080f, -0.07069690f, 0.02273207f, -0.05078191f, 0.12776715f, -0.00955136f, -0.09485387f, 
    -0.65331244f, 0.04815454f, 0.04456354f, 0.00891784f, 0.45399591f, -0.28560743f, 0.08800012f, -0.20488946f, 
    -0.01691999f, -0.03848463f, 0.05729256f, -0.00134062f, 0.03137084f, -0.05037114f, -0.07185582f, -0.00314864f, 
    0.03187568f, 0.02716543f, -0.03436439f, -0.02906469f, -0.18005468f, -0.41614804f, 0.21286249f, 0.01684408f, 
    0.06069967f, -0.11756711f, -0.04542416f, -0.03965696f, 0.10865686f, 0.01344623f, 0.04754027f, 0.04642836f, 
    0.05421612f, -0.07381126f, 0.06953734f, -0.04996395f, -0.01318264f, -0.01941099f, 0.05237459f, 0.04740732f, 
    -0.03634785f, 0.05647008f, 0.00449060f, 0.16842623f, 0.08166678f, 0.04953018f, 0.18805955f, -0.13852397f, 
    0.03490489f, 0.08082424f, 0.09350652f, -0.04294997f, -0.01090493f, -0.00967470f, 0.07307180f, -0.03257146f, 
    -0.02369218f, -0.07792500f, -0.01952452f, -0.07915066f, 0.00744811f, -0.01459286f, -0.04252545f, -0.01736496f, 
    -0.00141539f, 0.00960574f, 0.01279626f, 0.02226102f, 0.01221531f, -0.00695307f, 0.02160208f, -0.07142631f, 
    -0.00933496f, -0.07143185f, -0.00698486f, 0.05267590f, 0.00048543f, -0.01160947f, -0.01274595f, -0.00119301f, 
    0.16025765f, 0.08461317f, -0.15800481f, -0.01918710f, -0.05045732f, 0.03100155f, 0.03265507f, 0.06625699f, 
    0.02941294f, 0.08254709f, 0.05940463f, 0.05547667f, -0.01479333f, -0.01235196f, 0.03177380f, 0.05685350f, 
    0.04235328f, 0.08988976f, -0.05680230f, 0.06462345f, 0.04689575f, 0.11454938f, 0.16876711f, 0.15317519f, 
    0.10065324f, -0.16397487f, -0.13546124f, -0.09269415f, -0.04156695f, 0.05506534f, 0.03077727f, 0.01369492f, 
    -0.00092097f, 0.04288165f, -0.00532240f, 0.02609603f, -0.02397246f, -0.03750268f, 0.06205424f, -0.01311580f, 
    -0.18315965f, -0.01084016f, -0.06229229f, 0.20365950f, -0.11242800f, -0.07426155f, -0.03104134f, -0.06429645f, 
    -0.14841379f, 0.01978164f, -0.10020120f, -0.09515341f, 0.11098427f, 0.03076846f, -0.01463926f, 0.01746353f, 
    -0.05518109f, -0.08249241f, -0.16360229f, -0.09438760f, 0.29301822f, -0.05264894f, -0.22302854f, 0.25740039f, 
    0.04142944f, 0.01109427f, -0.00102912f, 0.12609382f, 0.00908768f, 0.04218527f, -0.01885844f, 0.01358621f, 
    -0.03578226f, 0.05300751f, -0.00732876f, -0.10374796f, -0.14138868f, -0.13065159f, -0.04589809f, -0.25895074f, 
    -0.21617018f, -0.17492098f, -0.02392776f, -0.16482870f, -0.16330779f, -0.00001803f, -0.00949081f, 0.03387592f, 
    0.03058586f, 0.08579168f, -0.07184802f, 0.05480785f, -0.06208243f, -0.10233016f, -0.15686014f, -0.03151933f, 
    -0.06358152f, -0.00847179f, -0.00206913f, 0.17274156f, 0.00891007f, -0.01964156f, -0.02697164f, -0.06713802f, 
    -0.01716678f, 0.04184759f, -0.00853585f, 0.00067416f, 0.03915604f, 0.01208070f, -0.00229766f, -0.12571821f, 
    0.10766828f, -0.04450919f, -0.01389135f, 0.01642822f, 0.01466422f, -0.00218906f, -0.05786299f, 0.06932358f, 
    -0.32230616f, 0.15055951f, -0.02437464f, -0.16100390f, -0.34813473f, 0.10684097f, -0.00667942f, -0.05513780f, 
    0.02913082f, 0.01933005f, 0.02234898f, -0.05603858f, -0.02915774f, 0.08959176f, -0.16767691f, -0.06478309f, 
    -0.05410468f, -0.07483074f, 0.02382467f, 0.14098771f, 0.38962361f, -0.11291041f, 0.17242016f, -0.28883034f, 
    0.29707426f, -0.04236274f, 0.02813305f, 0.17392674f, 0.02049483f, -0.02548158f, 0.04080946f, -0.02872585f, 
    -0.01915857f, 0.02690589f, -0.02692964f, -0.06488195f, -0.22528936f, -0.09824093f, -0.17271607f, -0.19078211f, 
    0.12278016f, 0.08029068f, -0.12591290f, 0.28680840f, 0.04431969f, 0.02394273f, 0.01311961f, 0.02752043f, 
    -0.01223820f, 0.08356931f, 0.01923850f, -0.07056053f, 0.03223397f, 0.00525159f, -0.01876638f, -0.04061855f, 
    0.04875659f, -0.15641332f, -0.07216777f, -0.09456485f, 0.01686776f, -0.05696118f, 0.02183740f, -0.05367177f, 
    -0.05788763f, 0.04301489f, -0.00671791f, -0.00871387f, 0.02634270f, 0.01894646f, -0.13417323f, -0.07226096f, 
    -0.13764752f, -0.01021307f, 0.05956855f, -0.04739309f, -0.06233043f, 0.02621901f, -0.00839318f, -0.07341906f, 
    -0.07717270f, -0.12153815f, 0.29563069f, 0.08820308f, 0.01609302f, -0.18904591f, 0.01662660f, -0.17790875f, 
    -0.06243011f, -0.13858251f, 0.01545718f, 0.00545136f, 0.01471283f, 0.04190379f, -0.01034118f, -0.00666609f, 
    0.16869949f, 0.05853124f, -0.00282269f, 0.04340715f, -0.09633072f, -0.15843953f, -0.03187796f, -0.22253957f, 
    -0.11081333f, 0.05650252f, 0.01366351f, 0.00666375f, 0.10805234f, -0.01909025f, 0.01008841f, -0.01921965f, 
    0.00723611f, -0.04847991f, -0.04594654f, -0.00323905f, 0.01829368f, -0.07307087f, 0.00878195f, 0.10447827f, 
    0.19306035f, 0.07449247f, 0.18001118f, 0.05096241f, 0.18417215f, 0.15004395f, 0.16838013f, 0.07726943f, 
    0.09345219f, 0.11864939f, -0.03198623f, -0.00722654f, -0.02002235f, 0.00793342f, 0.02006068f, 0.14867283f, 
    0.14322947f, -0.10179614f, 0.09423207f, 0.16913119f, 0.01002304f, 0.11338337f, 0.10655420f, 0.22667743f, 
    0.08650415f, -0.02608551f, -0.01624375f, 0.09592316f, -0.07797040f, 0.16508666f, -0.00188664f, -0.06524739f, 
    0.02359179f, -0.07040452f, -0.00300383f, -0.04977462f, -0.00639040f, -0.06158736f, -0.00338053f, -0.16190422f, 
    0.22810438f, -0.10831122f, 0.20874450f, 0.06101575f, 0.01007946f, -0.07505420f, -0.04955931f, -0.01226346f, 
    0.00473282f, 0.11710361f, 0.12795749f, -0.04615301f, -0.03030175f, 0.00991185f, 0.06485033f, 0.04363053f, 
    0.03474243f, 0.03878910f, -0.00957076f, -0.01091951f, -0.02494626f, 0.07034690f, 0.03047733f, 0.02337462f, 
    -0.05275838f, 0.08730108f, -0.00728281f, -0.00846734f, -0.00176299f, 0.12217316f, 0.13283135f, -0.01173010f, 
    -0.00971278f, 0.00861795f, 0.07441718f, 0.00335966f, -0.12606584f, 0.01668244f, -0.22799446f, -0.21646914f, 
    -0.03287363f, 0.04719218f, -0.10931171f, 0.07839179f, 0.07665256f, -0.02682367f, -0.01660955f, 0.02197195f, 
    0.07368459f, 0.03478982f, 0.06629464f, -0.00444455f, 0.00168243f, -0.02435700f, 0.06775963f, -0.02694568f, 
    0.08122344f, -0.07918961f, -0.06285316f, 0.10222887f, 0.05708312f, -0.00888050f, -0.19653301f, 0.09326617f, 
    -0.31733701f, 0.07181450f, -0.10643343f, 0.04422880f, -0.10623099f, -0.00939060f, 0.00291341f, -0.03914825f, 
    0.00602345f, 0.00474926f, 0.03088824f, 0.03014578f, -0.11267994f, 0.00651115f, -0.03704638f, -0.11912462f, 
    0.09233879f, 0.00318189f, 0.14029935f, 0.16993903f, 0.08276800f, -0.00572164f, 0.05307946f, 0.00457246f, 
    0.03909600f, 0.03813037f, -0.00045522f, -0.01887497f, 0.03748256f, -0.00968756f, 0.01203450f, 0.09238391f, 
    0.11892038f, -0.08796778f, 0.06504745f, 0.24235082f, -0.22953539f, -0.19107506f, -0.07571357f, -0.18451695f, 
    -0.17201948f, 0.01422445f, -0.06140853f, -0.02720795f, -0.16820841f, 0.01977012f, -0.01776683f, -0.02665907f, 
    0.12302107f, -0.03612680f, -0.05937503f, -0.15637928f, -0.02968311f, 0.01110050f, -0.06251469f, -0.10468094f, 
    0.01892725f, -0.18139325f, 0.15138228f, 0.17469557f, 0.05220393f, -0.29819700f, -0.06992985f, 0.04421664f, 
    -0.20124803f, 0.18164892f, -0.07249655f, 0.06891915f, -0.01502119f, -0.02199972f, 0.02425127f, -0.00427401f, 
    0.03384886f, 0.03031378f, -0.02271954f, -0.02012244f, 0.05619736f, -0.03772712f, -0.09164786f, -0.05787046f, 
    -0.02840945f, 0.01872853f, -0.02234247f, 0.06525354f, 0.04284394f, -0.00433201f, 0.04366552f, 0.00246898f, 
    -0.04739208f, -0.07192757f, 0.01309989f, 0.01788128f, -0.07845926f, 0.02239453f, -0.04373910f, -0.04117827f, 
    -0.30430454f, -0.22382933f, 0.11366545f, -0.00944593f, 0.02484767f, -0.10582656f, -0.03772680f, -0.06343832f, 
    -0.02964799f, -0.08923853f, 0.02018782f, -0.09193193f, -0.10509515f, 0.11372737f, -0.01919305f, -0.00074108f, 
    0.02905315f, -0.02807230f, -0.00211234f, -0.05568798f, 0.00812057f, -0.14394405f, 0.01814479f, 0.05905038f, 
    -0.08351862f, 0.09094529f, -0.02371743f, -0.01251821f, -0.04613521f, 0.02642434f, 0.06224615f, -0.05930274f, 
    -0.00877147f, -0.08686863f, 0.15094769f, 0.01027283f, -0.13945666f, -0.02522392f, -0.14365885f, -0.03022108f, 
    0.11182866f, 0.10861693f, 0.15496822f, 0.07240151f, 0.00500289f, -0.10418410f, -0.13697797f, -0.12298504f, 
    0.06069217f, -0.05968527f, 0.14658915f, -0.08366421f, 0.01126666f, 0.06724842f, 0.05213828f, 0.07408238f, 
    0.00688167f, -0.05525088f, -0.04572297f, -0.06638663f, 0.13056208f, 0.01247444f, 0.18207252f, -0.17767851f, 
    0.04426905f, 0.08281114f, -0.01749494f, 0.03559503f, -0.08950729f, 0.07560270f, 0.01343779f, -0.07122885f, 
    0.02975911f, 0.01293800f, -0.00542319f, 0.01774246f, -0.07748021f, -0.09997425f, -0.03146344f, -0.13943832f, 
    -0.07877619f, -0.27377456f, -0.00086129f, -0.06910880f, -0.08181782f, -0.09041977f, 0.02046503f, 0.09012215f, 
    -0.20902704f, -0.04962855f, -0.06735009f, -0.01362801f, -0.02910144f, 0.00591586f, -0.11361088f, -0.09232967f, 
    0.01876426f, 0.11402395f, 0.07142314f, 0.20706202f, 0.41279599f, -0.35143125f, -0.45955262f, 0.28911561f, 
    -0.05895305f, 0.10090888f, 0.01327954f, -0.01400263f, 0.04786978f, -0.01812669f, 0.13953048f, -0.07827521f, 
    0.02068570f, 0.03747072f, 0.08952690f, -0.06400820f, 0.02891070f, 0.01098785f, -0.20843209f, 0.07749047f, 
    0.01360434f, 0.02441801f, 0.07430170f, 0.12311411f, 0.06660417f, -0.15447320f, 0.01521094f, -0.11878283f, 
    0.00112143f, -0.03487395f, 0.02608085f, -0.01700850f, 0.00263565f, 0.02795537f, 0.02566233f, -0.00207799f, 
    -0.03474078f, -0.03243227f, 0.06999367f, 0.07390250f, 0.02909433f, 0.02856512f, 0.04076323f, -0.01601386f, 
    0.01368350f, 0.04330159f, 0.02448468f, 0.00115336f, 0.02155842f, 0.06147749f, -0.03313823f, -0.01878018f, 
    -0.03588972f, -0.02183831f, 0.01254567f, 0.11323527f, 0.02186668f, -0.03461812f, -0.03320627f, 0.01211696f, 
    -0.01735951f, -0.06695025f, 0.04208400f, -0.08982093f, -0.15278639f, 0.12224293f, 0.08217677f, -0.04350655f, 
    -0.04011494f, 0.02795190f, 0.07760714f, -0.05764804f, 0.15191852f, -0.00086776f, -0.06326836f, -0.10185788f, 
    0.00152095f, -0.12250593f, -0.05998824f, 0.01640342f, 0.18085657f, 0.18102877f, 0.23656045f, 0.28342187f, 
    0.15179521f, -0.19425508f, -0.14155720f, -0.07329796f, -0.07979352f, 0.11668921f, 0.04895866f, 0.05052869f, 
    0.04033955f, 0.01103507f, 0.04589984f, 0.04096502f, -0.05138983f, -0.01012090f, -0.00840372f, -0.04001037f, 
    -0.31574023f, -0.06746387f, 0.02163729f, -0.32486954f, 0.03115260f, -0.12203675f, 0.12464427f, -0.01844406f, 
    -0.06447201f, -0.06877278f, 0.02697668f, -0.03240222f, -0.00665633f, 0.09662969f, 0.01360041f, -0.00833928f, 
    0.05123853f, 0.05300553f, 0.01917392f, 0.13026793f, -0.19443725f, -0.18152340f, -0.10039712f, -0.28868940f, 
    0.07110066f, 0.16006918f, 0.09288559f, 0.01487750f, -0.18921651f, -0.01918307f, -0.00126675f, -0.01805986f, 
    0.06558997f, -0.09502393f, -0.00532982f, 0.09078734f, -0.09877260f, 0.06452074f, -0.08525891f, -0.04997535f, 
    -0.12718639f, -0.10193486f, 0.25053152f, -0.06598418f, 0.01154274f, -0.12642023f, 0.01197678f, -0.08154564f, 
    -0.17582725f, -0.17530669f, 0.03610827f, -0.13474153f, -0.02332837f, 0.02191738f, 0.02899373f, 0.03990857f, 
    0.01215761f, -0.01703825f, 0.02079544f, -0.10709384f, 0.15973099f, 0.03078717f, 0.06681351f, 0.03801396f, 
    0.04598220f, -0.01225097f, -0.01369709f, -0.00326566f, -0.03746760f, 0.05875096f, 0.13561745f, -0.08280450f, 
    -0.03227869f, 0.01651401f, 0.00627648f, 0.05043982f, 0.03736397f, 0.01803803f, -0.05792344f, -0.04546533f, 
    0.02701854f, 0.01268570f, -0.04286749f, -0.06472781f, -0.03802616f, 0.05234915f, -0.01351122f, 0.05346029f, 
    -0.00208105f, 0.03436600f, 0.05586845f, 0.02456561f, -0.02068079f, -0.02302632f, 0.08470991f, 0.09784332f, 
    0.01653142f, -0.04872037f, -0.02885901f, 0.02662821f, -0.08648886f, -0.25858787f, -0.02270060f, -0.05333482f, 
    0.00221726f, 0.01839367f, -0.09271243f, -0.06641508f, -0.03694699f, -0.08222131f, 0.03898492f, -0.24672633f, 
    0.02212322f, -0.03577609f, 0.05444380f, -0.14889106f, -0.14243580f, -0.04591155f, -0.09803309f, -0.02819087f, 
    -0.15374640f, -0.06998733f, 0.20530058f, -0.04827405f, -0.04147251f, -0.12063386f, -0.02785166f, -0.02871369f, 
    0.06513254f, 0.09457202f, 0.07872108f, -0.10702194f, 0.05525732f, -0.02509136f, 0.07550478f, 0.02615215f, 
    0.01573573f, -0.00664514f, -0.10159007f, 0.02867849f, 0.02091902f, -0.01183780f, 0.01091725f, -0.03726605f, 
    -0.02096247f, 0.02574329f, -0.02700757f, -0.04110780f, 0.02956027f, 0.03006181f, 0.05542304f, -0.03952784f, 
    -0.05497766f, -0.07542747f, -0.02831868f, 0.04152177f, -0.01606289f, 0.01706217f, -0.04161606f, 0.00484565f, 
    0.07774476f, 0.04828704f, -0.00286855f, -0.00554946f, -0.03053937f, 0.09738536f, 0.06428643f, 0.01446738f, 
    0.05098188f, 0.03537479f, 0.10362419f, 0.12709089f, 0.07567374f, -0.03368829f, 0.07839859f, 0.13668655f, 
    0.02481790f, -0.04225789f, -0.04854075f, 0.01644677f, -0.03291044f, 0.07853962f, 0.08829773f, 0.18658146f, 
    -0.01520055f, 0.00602333f, -0.01031650f, -0.06791938f, -0.13198771f, -0.04694226f, -0.00481631f, 0.01281956f, 
    0.00789374f, 0.01254546f, 0.02792197f, 0.02568021f, -0.05415081f, -0.03242470f, -0.13155513f, -0.05393719f, 
    0.08826777f, -0.10942125f, -0.13559818f, -0.04691168f, -0.18139955f, 0.12705897f, -0.16804920f, -0.04561879f, 
    0.09182582f, 0.00605653f, -0.10123251f, -0.02097197f, 0.08311642f, -0.44602311f, 0.07269179f, -0.00166053f, 
    -0.22830509f, -0.02644379f, -0.28025776f, -0.00247633f, 0.00355419f, 0.06376541f, 0.05261577f, 0.07083371f, 
    0.10653155f, 0.04838355f, 0.13842267f, -0.01629157f, 0.00915252f, 0.05407266f, 0.03175591f, 0.07481625f, 
    -0.03326242f, 0.02998047f, 0.04696726f, 0.04082307f, -0.04006140f, -0.10810831f, -0.02418424f, 0.02723766f, 
    0.01042428f, 0.00341258f, 0.03582262f, -0.01320319f, -0.07161225f, 0.04316197f, 0.03993788f, 0.06252588f, 
    -0.03346196f, 0.02602632f, -0.00274197f, 0.07973255f, 0.05655109f, 0.07243366f, 0.06299417f, 0.03692343f, 
    -0.05013032f, -0.04725423f, -0.06583867f, -0.05623301f, -0.02944725f, -0.18436700f, -0.06334812f, 0.11414222f, 
    -0.00319822f, -0.10428256f, -0.14598854f, -0.00816584f, -0.21362825f, -0.09684633f, -0.06691082f, 0.01534005f, 
    -0.01199390f, -0.01764103f, -0.15974078f, 0.01005004f, 0.03981553f, -0.03204842f, -0.04099447f, 0.01871543f, 
    -0.00618216f, 0.02997988f, 0.19236337f, 0.08223456f, 0.15270501f, -0.18085833f, 0.15041387f, -0.03118265f, 
    0.01743871f, -0.02213705f, -0.03564589f, 0.00785435f, -0.03394518f, 0.05454523f, 0.05465467f, -0.02305107f, 
    -0.00266966f, -0.10446393f, -0.06510916f, 0.01006319f, 0.19165400f, 0.06542341f, 0.05848648f, 0.18372005f, 
    0.24902585f, 0.17670485f, 0.16751704f, 0.15212804f, 0.10876393f, 0.21546550f, -0.01220842f, -0.00808762f, 
    -0.00622107f, -0.03163718f, -0.02206752f, 0.10236154f, 0.02389973f, 0.01681867f, 0.19305351f, 0.09984306f, 
    -0.44207159f, 0.07144789f, -0.04117634f, -0.09802547f, -0.01258647f, 0.05050270f, 0.05220947f, -0.04293460f, 
    0.03404264f, 0.10596653f, -0.01443854f, -0.04689115f, 0.09470637f, 0.04200312f, -0.07865436f, -0.01249440f, 
    0.00385583f, -0.07284983f, -0.07172644f, 0.05467463f, -0.10810018f, -0.13854432f, -0.10224868f, 0.18114752f, 
    -0.42801100f, 0.00333190f, -0.03791737f, -0.15254246f, -0.06259210f, -0.01192338f, 0.19433172f, -0.10442248f, 
    -0.07052983f, 0.12751512f, -0.04144604f, 0.05982568f, 0.11320414f, 0.00852142f, -0.28708467f, -0.04183672f, 
    -0.10121010f, -0.14414540f, 0.10050072f, 0.07095183f, -0.03401856f, -0.19117229f, -0.01993782f, -0.02826063f, 
    -0.28331351f, -0.12005664f, 0.01635269f, -0.00824224f, 0.04735915f, -0.16730243f, 0.03174135f, -0.06991287f, 
    -0.07044350f, 0.10556569f, -0.04233343f, -0.00175696f, -0.03918624f, 0.04030854f, 0.06139374f, 0.07147706f, 
    0.07631480f, -0.09727552f, -0.02623877f, 0.00500081f, 0.00194448f, -0.03874319f, -0.09288503f, -0.04370777f, 
    -0.01792923f, -0.03387529f, 0.00186435f, -0.06676100f, -0.07266915f, -0.00302600f, -0.08812907f, -0.18302208f, 
    -0.07078832f, -0.05019310f, -0.19308709f, -0.08059686f, 0.14058271f, -0.02953050f, -0.08197872f, -0.00796677f, 
    -0.08250857f, -0.00406431f, 0.02307049f, 0.01365509f, 0.07449152f, -0.04047145f, 0.03307757f, -0.05376113f, 
    -0.00166717f, 0.04138421f, -0.05574219f, 0.01161547f, 0.03063564f, 0.10074861f, 0.09995431f, 0.11230119f, 
    0.08269094f, -0.03813037f, 0.09541542f, -0.04033332f, 0.12291836f, 0.11501390f, 0.01532756f, -0.00466538f, 
    -0.02866166f, 0.00158090f, 0.00602097f, 0.13776533f, 0.15096028f, -0.04997501f, 0.15485206f, 0.18607657f, 
    0.13687290f, 0.05851306f, 0.38408521f, 0.05150709f, 0.08987170f, -0.05562502f, -0.00170571f, 0.11317914f, 
    -0.02077324f, 0.07161093f, 0.04931704f, -0.02402316f, -0.02579796f, -0.00578593f, -0.00081328f, -0.02781660f, 
    0.03303198f, -0.15528695f, -0.03684238f, -0.11098433f, 0.05111339f, 0.15073217f, 0.01208548f, 0.07810004f, 
    -0.03876320f, 0.02887666f, -0.07891153f, -0.07912676f, -0.08314533f, 0.06232959f, 0.07865160f, -0.00277439f, 
    0.00615010f, 0.01975936f, 0.01596900f, 0.06447849f, -0.00256725f, -0.10958234f, -0.13025609f, -0.05519369f, 
    0.02208809f, 0.10374502f, 0.35294205f, 0.18672039f, 0.20522688f, -0.07680594f, 0.00808921f, 0.13558108f, 
    -0.02025165f, 0.08711783f, 0.03987852f, 0.04655858f, 0.02777102f, -0.05311377f, 0.00598153f, 0.03689725f, 
    -0.00933441f, -0.12064196f, 0.00178322f, -0.10445641f, -0.03745064f, 0.00126807f, 0.09484129f, 0.04367292f, 
    0.01021201f, -0.02838580f, 0.07594385f, -0.03587296f, -0.00064681f, -0.01805795f, 0.02711081f, 0.00919419f, 
    0.02581819f, -0.06791093f, -0.04672418f, -0.07443015f, -0.06604475f, -0.09308455f, -0.01770080f, -0.15700492f, 
    -0.11790075f, -0.15612930f, 0.00338815f, 0.03287452f, -0.08288437f, -0.27740109f, -0.01903886f, -0.04055421f, 
    -0.18096907f, -0.11956933f, -0.05585774f, -0.06204165f, -0.03918106f, 0.04954314f, -0.08859470f, -0.11141227f, 
    -0.03016433f, 0.03782833f, 0.09259336f, -0.00093179f, 0.03683936f, 0.09638482f, 0.08054907f, 0.13506651f, 
    0.03428913f, -0.11864681f, -0.10061703f, -0.02181347f, 0.02459076f, -0.04556229f, 0.05182702f, 0.01244279f, 
    -0.03119111f, -0.01390795f, 0.05003414f, 0.01684599f, -0.08603670f, -0.01953258f, 0.00007796f, -0.06522571f, 
    0.06685130f, -0.06280773f, -0.08871984f, 0.02406499f, -0.06381182f, 0.04934951f, 0.00038802f, -0.07567006f, 
    0.03175535f, 0.01571763f, 0.02008249f, -0.02087911f, 0.04186533f, -0.03898867f, -0.00294697f, -0.21559329f, 
    -0.05719499f, -0.06744977f, -0.09060244f, -0.05679422f, 0.11214974f, 0.17313702f, -0.37492421f, 0.07258162f, 
    0.08159304f, -0.00691182f, 0.00000041f, -0.00580420f, 0.06688599f, 0.06690320f, 0.05346215f, 0.03878678f, 
    0.02115030f, 0.01408188f, 0.00025733f, 0.05191331f, 0.11717354f, 0.12912843f, -0.00177602f, 0.11716044f, 
    -0.08006179f, 0.02061671f, -0.12114309f, 0.10647058f, -0.03290045f, -0.01437823f, -0.22627179f, 0.17226258f, 
    -0.01601039f, -0.02844563f, -0.09876434f, 0.02798085f, 0.00389996f, -0.02632586f, -0.01448130f, 0.00362431f, 
    0.09562990f, 0.17433545f, -0.12014722f, -0.01384463f, 0.02778294f, -0.01882674f, -0.09804390f, -0.02750663f, 
    -0.01021787f, 0.00972276f, 0.00977196f, -0.00776172f, -0.03720647f, 0.06773324f, 0.03987151f, -0.00586208f, 
    0.10533993f, 0.06028217f, 0.08332278f, 0.04795284f, 0.06562938f, 0.06747876f, 0.03159496f, 0.06715691f, 
    0.06589322f, -0.02378204f, -0.04618118f, -0.22754508f, 0.07892446f, 0.03056990f, 0.01753904f, -0.05401701f, 
    -0.01442388f, -0.02341251f, 0.08173133f, 0.01230214f, -0.01239296f, 0.00836215f, -0.06377710f, -0.12776144f, 
    -0.08892348f, -0.01817510f, 0.01789240f, -0.12840427f, 0.07959264f, -0.08204458f, 0.10058466f, 0.04115339f, 
    -0.11075263f, 0.02365005f, 0.13072324f, 0.03338150f, -0.07499392f, -0.01246518f, 0.03318792f, -0.00896285f, 
    -0.00223343f, -0.01666254f, -0.00792526f, -0.03896046f, 0.01008089f, 0.00553268f, 0.09359394f, 0.02704063f, 
    0.12831718f, -0.08854720f, 0.15782852f, 0.26944962f, -0.28376719f, -0.02195866f, 0.03684714f, -0.13056420f, 
    -0.05767496f, 0.03525531f, 0.13493265f, -0.03447799f, -0.01106996f, -0.10043937f, 0.14119835f, -0.01414678f, 
    0.00230738f, -0.02179478f, -0.01706212f, 0.13172963f, -0.31993139f, -0.22723089f, -0.16854616f, -0.13228466f, 
    0.00173860f, 0.06311812f, 0.01475923f, -0.12081312f, 0.00578148f, 0.02382552f, 0.03941144f, -0.01278151f, 
    -0.05167888f, -0.03264791f, -0.01811092f, 0.17457020f, 0.02166062f, 0.03582070f, -0.10213860f, -0.04506667f, 
    0.23271391f, 0.14258060f, -0.13273427f, 0.02077910f, -0.09816716f, 0.01682973f, -0.02228246f, 0.04868941f, 
    -0.05773445f, -0.07340439f, -0.02072402f, -0.09993085f, -0.26913536f, 0.00294487f, 0.32288620f, -0.11160875f, 
    -0.07793713f, 0.04915914f, -0.00510498f, -0.10592447f, -0.14936641f, 0.03652469f, -0.18309848f, 0.04079294f, 
    0.03521359f, 0.01580932f, -0.04466816f, -0.07617920f, -0.02177917f, 0.05779419f, 0.07948080f, 0.09534860f, 
    -0.04350670f, 0.08986389f, -0.03118692f, -0.02319415f, 0.05370238f, 0.14898132f, 0.00125247f, -0.05393459f, 
    0.37947938f, 0.08577079f, -0.27057868f, -0.42649820f, 0.27716810f, 0.06437478f, 0.09399924f, -0.06913925f, 
    -0.01184534f, -0.05517152f, 0.04138547f, 0.05158173f, -0.02775682f, 0.04339934f, 0.10989491f, 0.03392784f, 
    0.04171550f, -0.17880140f, 0.04709044f, -0.18466890f, -0.31833291f, -0.25194135f, 0.02783910f, -0.04598270f, 
    0.17948209f, -0.23422548f, 0.10601494f, -0.16233960f, -0.04842324f, 0.10261644f, 0.08194154f, -0.04544469f, 
    -0.00624030f, -0.05776120f, 0.04423837f, -0.14765309f, -0.09362593f, -0.02714073f, 0.03988618f, 0.17705661f, 
    -0.21706010f, 0.15518655f, 0.22678046f, 0.10535454f, -0.24908587f, -0.03522646f, -0.08789781f, 0.15636083f, 
    0.04230128f, -0.02036568f, -0.02632850f, 0.07850093f, -0.04160870f, -0.00953076f, 0.01616597f, 0.06715839f, 
    -0.02695717f, 0.15468617f, -0.06884351f, 0.05836631f, 0.10386115f, -0.28060824f, -0.14918421f, -0.00312658f, 
    0.09188367f, 0.03290340f, -0.11339491f, -0.08008357f, 0.00834061f, 0.08043253f, -0.08007183f, 0.18497047f, 
    -0.11680791f, 0.02865519f, 0.08921736f, 0.05381371f, -0.10837106f, 0.03414607f, 0.01429604f, 0.21106237f, 
    -0.22628205f, -0.00496179f, 0.08088776f, -0.29108068f, -0.03666571f, 0.14134715f, -0.06907389f, 0.00285926f, 
    -0.15921411f, 0.09485229f, -0.02218276f, 0.03157015f, 0.01129225f, 0.01325124f, 0.02904454f, 0.13072439f, 
    -0.13596880f, -0.27342978f, -0.12036416f, -0.08440981f, 0.07859620f, -0.22400743f, 0.10751034f, 0.03175042f, 
    0.08561373f, 0.00900328f, -0.02022781f, -0.01410513f, -0.04545831f, 0.00251692f, 0.09474333f, 0.02986789f, 
    0.13650720f, -0.04570193f, 0.11901651f, -0.13264392f, -0.15960200f, 0.00642018f, 0.25431332f, -0.11687781f, 
    0.22152445f, 0.00894562f, 0.33496732f, 0.17833219f, -0.22621700f, 0.00351059f, 0.05304793f, -0.03737018f, 
    0.07525541f, -0.00198393f, 0.02599936f, 0.01767721f, 0.03962387f, 0.02039101f, 0.02639724f, -0.13914242f, 
    -0.00574309f, -0.01645116f, -0.10730209f, -0.10920188f, -0.04307155f, 0.09921343f, 0.22096206f, -0.08741300f, 
    -0.03235952f, -0.00713094f, -0.04693945f, 0.09460989f, -0.00672890f, -0.10924672f, -0.02277813f, -0.00076743f, 
    -0.04944719f, -0.04137372f, 0.04488341f, 0.04719020f, -0.00746163f, 0.08798833f, -0.05709336f, 0.04017841f, 
    -0.37552482f, -0.03449262f, -0.24866094f, -0.23181492f, -0.16111928f, -0.00919876f, 0.00923501f, -0.07240184f, 
    -0.04059134f, 0.20972386f, 0.03619923f, 0.11350755f, -0.09246698f, -0.05370232f, -0.08584611f, -0.01137805f, 
    -0.00117325f, 0.05249621f, -0.01619659f, 0.06525014f, -0.05076970f, -0.06180634f, 0.00754358f, 0.00770498f, 
    0.11607638f, -0.13671429f, -0.13813989f, -0.02823219f, 0.08882222f, -0.23531549f, -0.06013579f, 0.10181552f, 
    -0.03207278f, -0.01127053f, 0.00297230f, 0.10728315f, 0.07004251f, 0.04327337f, 0.14818782f, 0.36562735f, 
    -0.18177542f, -0.08390787f, -0.10037766f, 0.14699271f, -0.13632916f, 0.08228911f, -0.06457306f, -0.03264829f, 
    0.03181874f, 0.03586818f, -0.03729769f, 0.03461593f, -0.01168417f, 0.00026340f, 0.00774115f, -0.09353776f, 
    -0.13421053f, 0.18910156f, -0.00838973f, -0.06076538f, -0.08432140f, -0.21692902f, 0.38143331f, 0.03753073f, 
    -0.19819041f, -0.13796420f, -0.05294931f, -0.16077898f, 0.01543535f, 0.02933497f, 0.20447646f, -0.11655010f, 
    -0.04714546f, -0.06191363f, 0.11291619f, 0.16958460f, -0.01428468f, -0.05055115f, -0.01416697f, 0.18416877f, 
    0.41305816f, -0.14982869f, 0.26976973f, 0.18783036f, -0.26740754f, -0.09467652f, -0.03529304f, -0.05190754f, 
    0.10813564f, -0.01384713f, 0.02396134f, 0.03084643f, 0.06246161f, -0.00599084f, 0.00595538f, -0.09968251f, 
    0.01587775f, -0.12119058f, -0.05823409f, -0.26453981f, 0.63335592f, 0.02942323f, -0.14396669f, -0.30146545f, 
    0.28071427f, 0.01760909f, 0.00296728f, -0.01362536f, -0.08025826f, -0.02216827f, 0.03581502f, -0.02209876f, 
    -0.07362130f, -0.04937079f, -0.01761722f, 0.07037959f, 0.22471398f, -0.03377266f, 0.02302728f, 0.12952681f, 
    -0.49468237f, 0.05098869f, -0.31348047f, -0.26478809f, -0.25329208f, 0.01265850f, -0.09128708f, -0.04344340f, 
    0.01090051f, 0.07907944f, -0.03725455f, 0.04826210f, -0.12327588f, 0.04102737f, -0.01301004f, -0.10332271f, 
    -0.06272481f, -0.02201515f, 0.02670525f, 0.05587154f, -0.03843898f, -0.08225365f, -0.08104486f, 0.07540770f, 
    0.01507374f, -0.04441286f, 0.03370323f, -0.07570279f, -0.04758270f, 0.03620624f, 0.01964805f, 0.04227440f, 
    0.09862033f, -0.03765925f, 0.09951719f, 0.20825814f, -0.11461182f, -0.07745626f, 0.00431880f, 0.11194909f, 
    -0.38151321f, -0.08191281f, -0.22986332f, -0.21337344f, -0.00989550f, 0.04456681f, -0.07006913f, 0.01353464f, 
    0.05308680f, -0.05626751f, -0.06943442f, 0.13258308f, 0.07544341f, -0.10280029f, -0.05004787f, -0.03067165f, 
    -0.05087600f, 0.10111337f, -0.00540602f, 0.01534605f, -0.24636659f, -0.12554948f, -0.23263830f, 0.16325718f, 
    -0.06846750f, 0.04787442f, -0.17953664f, -0.09558555f, 0.09644090f, -0.12070116f, -0.00884859f, -0.01992719f, 
    -0.01761399f, 0.21088926f, -0.13360354f, 0.11642157f, 0.01696124f, 0.09517707f, 0.05590494f, 0.03111024f, 
    -0.29132047f, 0.11896487f, 0.03889839f, -0.20417054f, -0.11271143f, -0.00233456f, -0.00577215f, 0.05616088f, 
    -0.02606246f, 0.25376064f, 0.01888229f, 0.04383802f, -0.08998128f, -0.02915970f, -0.01506432f, 0.01668209f, 
    -0.02210218f, 0.05934542f, -0.02040340f, 0.11235875f, 0.10596222f, -0.09956653f, 0.08043677f, -0.15965824f, 
    -0.02398145f, -0.14706072f, 0.07082552f, -0.01590252f, 0.06765039f, -0.03068004f, -0.20601581f, 0.00041375f, 
    -0.09163675f, -0.07669517f, -0.02217237f, 0.03790453f, 0.05013483f, 0.00814885f, 0.03463280f, 0.22558968f, 
    0.16099685f, 0.04355274f, 0.12256391f, -0.02807566f, -0.18004119f, -0.02136945f, 0.02272719f, -0.02855893f, 
    -0.04913464f, 0.00692692f, -0.05449005f, -0.02866661f, -0.09917323f, -0.04312626f, 0.01355166f, 0.05488419f, 
    -0.15584376f, -0.04909587f, 0.05245158f, -0.17102227f, -1.18960953f, 0.08245952f, 0.03714034f, 0.44498599f, 
    -0.25651717f, 0.06400603f, -0.11720587f, -0.08262492f, 0.06920336f, 0.11262121f, -0.13597076f, 0.07464037f, 
    -0.08350718f, -0.00394125f, -0.04235853f, -0.07674260f, -0.22452037f, 0.14871621f, -0.05907171f, -0.13818531f, 
    -0.08616222f, -0.05857591f, 0.04907286f, -0.10273712f, -0.11573426f, 0.18283525f, -0.02791171f, 0.03723742f, 
    -0.02323789f, 0.07993703f, 0.05158055f, 0.01266437f, 0.01503417f, 0.04007773f, -0.02187976f, 0.01543638f, 
    0.02392210f, -0.03106670f, 0.03108711f, 0.00037326f, 0.00143444f, 0.05380591f, -0.00714183f, -0.03165731f, 
    -0.00261812f, -0.00753982f, 0.02115465f, -0.08895689f, -0.03668984f, 0.02422564f, 0.29409346f, 0.03406527f, 
    0.04719550f, -0.04220576f, 0.06689246f, 0.00996725f, 0.05088357f, 0.02163224f, 0.00233528f, 0.06227436f, 
    0.47772869f, 0.01311967f, -0.21412905f, -0.16352375f, -0.02416125f, -0.08228877f, 0.19097832f, 0.10796649f, 
    -0.11828452f, 0.15713695f, 0.17514269f, -0.14036328f, -0.18665065f, -0.05210970f, 0.23390792f, -0.00631368f, 
    0.00171805f, -0.16508923f, -0.02310413f, 0.11503440f, -0.12304451f, -0.12225624f, 0.11784341f, -0.12458634f, 
    -0.20763618f, 0.14386687f, 0.12694946f, 0.10526282f, -0.00605436f, -0.12885000f, 0.00852463f, -0.06335319f, 
    -0.02861941f, -0.04927235f, -0.00519331f, -0.01296758f, 0.06256217f, 0.04472489f, 0.07457793f, 0.04406416f, 
    0.36757231f, -0.35621372f, 0.03055719f, -0.01569106f, -0.09422191f, 0.05864831f, -0.11621899f, -0.18316033f, 
    0.02819057f, 0.16031913f, 0.04868770f, -0.01243160f, -0.02258456f, -0.06360941f, -0.01649517f, -0.24949959f, 
    0.01754970f, -0.04275164f, -0.05983688f, -0.06150561f, 0.33826235f, 0.12786578f, 0.00023598f, 0.01176963f, 
    0.02997728f, 0.09563818f, -0.06093265f, 0.16121805f, -0.07469846f, 0.14273576f, 0.05973109f, -0.06775293f, 
    -0.03787726f, -0.05093172f, -0.11884432f, 0.02801035f, 0.01718140f, 0.06813472f, 0.10371044f, 0.04447719f, 
    -0.17393465f, -0.37733349f, -0.04255639f, -0.10701940f, -0.11891951f, 0.12455757f, -0.03012602f, -0.04566858f, 
    0.13734357f, -0.02971514f, -0.01248622f, 0.04232679f, 0.23275344f, -0.05426351f, -0.10373081f, -0.08086856f, 
    -0.01276649f, 0.03941470f, 0.07176089f, -0.01791750f, -0.06869245f, 0.01085941f, 0.02457861f, -0.09457541f, 
    -0.04589250f, 0.01845236f, 0.01348648f, -0.01289344f, -0.01403455f, 0.00762175f, 0.06314830f, -0.05490694f, 
    -0.04951104f, -0.05694427f, -0.07096557f, -0.04222210f, 0.04163374f, 0.04880144f, -0.01330592f, -0.00109491f, 
    -0.14975491f, -0.09567813f, -0.21221498f, 0.01106003f, 0.03349185f, 0.04940415f, 0.02772411f, -0.03202997f, 
    -0.04773141f, -0.00080677f, 0.11905576f, -0.07688951f, 0.02948963f, 0.03421319f, 0.02439067f, -0.02855932f, 
    0.01714070f, 0.15757763f, 0.05459967f, -0.01976838f, -0.25439075f, -0.39643809f, -0.06440865f, 0.33953154f, 
    -0.29916164f, 0.04827956f, 0.04063468f, -0.08543839f, 0.05602147f, 0.19224989f, -0.08356956f, 0.08604965f, 
    -0.08053089f, 0.05345052f, 0.02861634f, -0.01798268f, -0.08125224f, 0.04426498f, -0.08168744f, 0.10938182f, 
    -0.34225014f, 0.20427391f, -0.37609991f, -0.27318218f, 0.01707324f, 0.05554892f, -0.03657786f, 0.03871759f, 
    -0.20236619f, -0.01836888f, -0.04494587f, 0.02660863f, 0.00480839f, -0.04476063f, -0.03198699f, -0.02198891f, 
    -0.05245924f, 0.15792018f, -0.09818944f, -0.00036978f, 0.00869380f, -0.15357593f, -0.13370100f, 0.04830911f, 
    0.01880087f, 0.04374481f, 0.02683008f, -0.06724148f, 0.04322376f, -0.01405288f, 0.02619712f, -0.02584399f, 
    0.18292977f, 0.11257519f, 0.01387990f, 0.00113217f, 0.00389501f, 0.06935170f, -0.01339463f, -0.04383744f, 
    -0.05056473f, -0.06406850f, -0.20240670f, 0.07072401f, 0.02768493f, 0.04231066f, 0.06472987f, 0.03519156f, 
    -0.06028530f, -0.01304403f, 0.08058719f, -0.16049945f, -0.02261504f, 0.04501443f, 0.02442291f, -0.08213127f, 
    -0.04972572f, 0.26293921f, 0.01567967f, -0.08720448f, 0.04588907f, -0.11336076f, 0.09261637f, 0.00485381f, 
    -0.24016568f, 0.07439829f, -0.04790416f, 0.01318563f, 0.04188241f, 0.03253852f, 0.05885779f, -0.12053860f, 
    -0.03800183f, -0.02982826f, 0.04671326f, -0.05619893f, 0.06853871f, 0.05464707f, -0.00145827f, 0.02601457f, 
    0.05465355f, 0.32110983f, -0.19745918f, 0.13668874f, 0.01731524f, -0.01690930f, -0.02580900f, 0.13308883f, 
    -0.09841128f, -0.04839347f, 0.05706187f, -0.06064684f, -0.00376496f, 0.10660512f, -0.13683262f, 0.19948775f, 
    -0.18280508f, 0.17302787f, 0.07610679f, -0.02672525f, -0.08221318f, -0.00442143f, -0.06765760f, -0.03762552f, 
    0.01492481f, 0.14729427f, -0.02603253f, 0.01261852f, -0.00193555f, -0.03756747f, -0.05685691f, -0.04222514f, 
    -0.02041969f, -0.03750781f, 0.08851830f, -0.05813317f, 0.10772282f, -0.01109026f, -0.00884762f, 0.07867249f, 
    -0.11469308f, -0.06795599f, -0.18094547f, -0.09599745f, 0.04227187f, -0.03834765f, -0.00527731f, 0.00208470f, 
    -0.04011670f, 0.00683353f, 0.17147933f, -0.01752401f, -0.05456777f, -0.05115877f, -0.11437357f, -0.03631049f, 
    -0.05822589f, 0.21951155f, 0.01724053f, 0.06998954f, -0.32008311f, -0.05945487f, 0.06937163f, -0.04379532f, 
    -0.11777499f, -0.06825773f, 0.11564486f, 0.07176139f, -0.03731202f, -0.03188524f, 0.02159270f, -0.04503183f, 
    -0.01467140f, 0.14894502f, 0.08092111f, -0.02310500f, -0.16666445f, -0.13697927f, 0.03073852f, -0.06016870f, 
    0.20090669f, -0.15779449f, 0.24568971f, 0.07642359f, -0.23748909f, 0.36414933f, 0.11716722f, -0.10189661f, 
    -0.00870250f, 0.00580199f, 0.05124573f, 0.01538853f, 0.00203526f, 0.01923651f, 0.01875535f, -0.00715741f, 
    0.02138230f, -0.06599378f, -0.02952957f, 0.12040313f, -0.10792704f, -0.00943694f, 0.20067444f, 0.06551179f, 
    0.02739911f, -0.19039410f, 0.12433579f, 0.02169719f, 0.11777226f, 0.03620178f, 0.02726894f, 0.01017401f, 
    0.02910933f, -0.04413661f, 0.02825589f, -0.11482131f, 0.02351133f, 0.01347717f, -0.05803902f, 0.00027677f, 
    0.23293711f, -0.03484160f, -0.26371285f, -0.12590761f, 0.09650626f, -0.04309077f, 0.00626840f, -0.05428043f, 
    -0.03866732f, 0.01567325f, 0.10542701f, 0.16257511f, -0.05692305f, 0.03623082f, 0.16927099f, -0.08033946f, 
    0.03169937f, 0.16522624f, 0.02624168f, 0.07206373f, -0.16424674f, 0.22786638f, 0.05837489f, 0.24604365f, 
    -0.06199081f, 0.19745798f, -0.28910014f, -0.00718073f, 0.02225090f, -0.06209793f, -0.04990253f, -0.15748852f, 
    0.00632661f, 0.04111530f, -0.03404181f, -0.08710822f, 0.02584320f, 0.04651473f, -0.03033232f, 0.07669890f, 
    0.04725768f, -0.00396333f, 0.05187878f, 0.09926867f, -0.11987103f, 0.05434370f, -0.08841828f, 0.02196557f, 
    -0.03901538f, -0.09536595f, -0.07290936f, -0.01878837f, 0.03226129f, 0.06553658f, 0.01449893f, 0.07736125f, 
    -0.00377033f, 0.08135752f, -0.15031496f, -0.10906981f, 0.04762176f, -0.18562272f, 0.23539093f, -0.01208626f, 
    -0.17768291f, 0.10615006f, 0.01841746f, -0.02197829f, -0.00995852f, 0.08916871f, 0.06280681f, 0.00400066f, 
    0.01498185f, 0.00447183f, 0.06717360f, 0.02093261f, 0.00769325f, -0.05071658f, 0.05375981f, 0.22143666f, 
    0.37885177f, -0.01318597f, -0.40555882f, -0.10659698f, 0.05804721f, 0.06236995f, 0.08642642f, 0.04081264f, 
    -0.08017148f, 0.00335744f, -0.01350011f, 0.01371204f, -0.02160171f, -0.07748356f, -0.03766863f, 0.01844406f, 
    -0.02021023f, 0.03813384f, -0.13803399f, -0.05243291f, 0.09781004f, 0.04870001f, 0.20516139f, 0.11022984f, 
    -0.03558676f, 0.04517729f, -0.07845035f, 0.10360070f, 0.06514537f, -0.05724457f, 0.03292916f, 0.02859848f, 
    0.02456949f, 0.00270423f, -0.00928143f, 0.08258970f, 0.01558774f, -0.24967036f, -0.27217427f, -0.36871454f, 
    0.09023062f, -0.05299879f, 0.16111788f, -0.12811702f, -0.12837952f, 0.02053826f, 0.05737317f, 0.01625759f, 
    0.00628880f, -0.07883609f, 0.01922869f, 0.00057020f, 0.06036503f, 0.04688666f, -0.01264544f, -0.04003908f, 
    -0.02900125f, 0.00342063f, -0.03788163f, -0.06644548f, -0.06445300f, 0.11856715f, 0.09997286f, -0.19723426f, 
    -0.04079186f, -0.04142209f, 0.05291466f, 0.08870796f, -0.00327892f, 0.06928165f, 0.04476437f, -0.07297558f, 
    -0.05062195f, -0.02343478f, 0.04161662f, 0.02893852f, 0.03534639f, -0.01169241f, 0.03977772f, 0.04205791f, 
    0.22825830f, -0.05668589f, 0.14794384f, -0.07556842f, -0.27146453f, -0.00276756f, 0.03466070f, 0.10448214f, 
    -0.19979963f, -0.08306415f, -0.04853177f, -0.03477292f, -0.01752681f, -0.01029641f, 0.02701074f, -0.03972154f, 
    0.02744203f, 0.00268825f, 0.10970599f, 0.10531034f, 0.17558526f, 0.11748345f, -0.09668481f, 0.00908328f, 
    0.01325945f, -0.07500764f, -0.12168600f, 0.07698121f, -0.03468213f, 0.07658150f, -0.10286454f, -0.01816223f, 
    0.04866368f, 0.00525329f, -0.01011074f, 0.08671776f, 0.04505087f, 0.11291198f, -0.07053124f, 0.13373639f, 
    0.15981631f, -0.18428217f, 0.27347499f, 0.06668761f, -0.25819570f, 0.22950575f, 0.04398682f, 0.07372053f, 
    -0.01373752f, 0.19098836f, -0.05723079f, 0.05418370f, -0.05317165f, 0.00825803f, 0.11459864f, 0.11036815f, 
    -0.02772572f, 0.04242088f, -0.07196085f, 0.07269759f, 0.00937128f, 0.00696501f, 0.10352801f, 0.06796788f, 
    -0.15855271f, 0.04388233f, -0.04722799f, -0.10523647f, -0.03365032f, 0.14172035f, 0.07674234f, -0.02567353f, 
    -0.03662110f, -0.05637012f, -0.03060740f, 0.03723070f, 0.03919163f, -0.02414968f, 0.04058363f, 0.12870488f, 
    0.64354420f, 0.06267619f, -0.28099665f, -0.21354158f, 0.20232439f, 0.08494443f, 0.05637301f, -0.09004607f, 
    -0.09030318f, 0.07380489f, 0.02390824f, 0.02340767f, 0.01952405f, 0.03084762f, 0.03426376f, 0.20539594f, 
    0.04594747f, 0.04655511f, -0.07424290f, 0.09991863f, -0.02453053f, -0.00167106f, -0.15212297f, 0.04461279f, 
    0.00374061f, 0.15164793f, 0.06416713f, -0.00130078f, 0.01063443f, 0.01209901f, 0.00967382f, 0.00831067f, 
    0.00601718f, 0.00709521f, -0.00430567f, -0.11529500f, -0.07293983f, 0.08401141f, 0.04685092f, -0.05468153f, 
    0.08840547f, -0.16805263f, -0.18440160f, -0.11949773f, 0.12824900f, -0.11042022f, 0.05930267f, 0.10883496f, 
    0.03690442f, -0.00112578f, -0.03334061f, 0.01290453f, -0.04866198f, -0.09828684f, 0.01132845f, -0.05435030f, 
    -0.03938422f, -0.04587117f, 0.11377092f, -0.04357100f, 0.04782643f, 0.04044130f, -0.00048249f, -0.02440410f, 
    0.00268954f, -0.03002029f, -0.03401136f, 0.00553365f, 0.00789600f, 0.00928587f, 0.05379078f, -0.01179318f, 
    0.01372356f, -0.03144625f, 0.03692225f, 0.01694454f, -0.03845927f, -0.04023081f, -0.05100400f, -0.00661934f, 
    -0.13763736f, -0.05953642f, 0.02411424f, -0.12432401f, -0.09892754f, -0.01136288f, 0.03324438f, 0.00447211f, 
    -0.01471553f, -0.02621151f, -0.01107970f, -0.02068534f, 0.00139597f, 0.00918255f, -0.01773609f, 0.04583599f, 
    0.04666868f, 0.03508657f, 0.00414214f, 0.04373289f, -0.47931993f, -0.50983781f, -0.27070755f, -0.06999656f, 
    -0.16499172f, -0.20424168f, -0.01553918f, -0.06451984f, -0.09287138f, -0.09736897f, -0.02654066f, 0.00422488f, 
    0.01238704f, -0.06384935f, 0.01224394f, -0.00989764f, 0.02938109f, 0.01791826f, 0.11059197f, -0.10383206f, 
    -0.33214936f, -0.25138727f, -0.02191611f, 0.06011278f, 0.19033834f, -0.05246956f, 0.12523848f, -0.00702613f, 
    0.00315799f, 0.11380159f, 0.06097033f, 0.01282190f, 0.06642095f, -0.01342836f, 0.05418994f, 0.01543787f, 
    -0.02341250f, -0.04038749f, 0.08514845f, -0.10888279f, -0.07997260f, -0.49958506f, -0.24201651f, 0.03344961f, 
    0.18498044f, -0.03613013f, 0.13844532f, 0.04263977f, 0.09005608f, -0.00529142f, 0.01218920f, -0.01732060f, 
    -0.03074872f, 0.02945344f, 0.00486599f, 0.06264620f, -0.00971860f, 0.01103078f, 0.08650864f, 0.01227449f, 
    0.03293987f, 0.08360990f, 0.03836110f, -0.02612708f, -0.00466776f, 0.04264768f, 0.00108498f, -0.10584484f, 
    0.00246547f, 0.07236028f, -0.00646928f, -0.04014247f, 0.08577149f, 0.08607250f, -0.14118105f, -0.02230525f, 
    0.00195934f, -0.04832797f, 0.08780721f, 0.05794830f, 0.01316060f, 0.01855587f, 0.01741478f, -0.01347323f, 
    -0.00567293f, 0.00713447f, -0.01654065f, -0.00641296f, 0.01031264f, 0.03275704f, 0.11349580f, 0.01765239f, 
    0.09671512f, -0.01429774f, 0.03168922f, -0.00753565f, -0.04440977f, -0.08980568f, -0.01619852f, -0.02182147f, 
    -0.17584568f, -0.04993523f, 0.20535438f, -0.08046541f, -0.08619121f, 0.06934069f, 0.00260016f, 0.00611358f, 
    0.04984307f, -0.09685690f, 0.02753771f, 0.02498002f, 0.06029566f, -0.01775729f, 0.12371939f, 0.01742583f, 
    0.21689814f, 0.07604469f, -0.10858878f, 0.05089126f, 0.12374965f, -0.12540641f, -0.03106805f, 0.00005820f, 
    0.02190635f, -0.01878682f, 0.09710205f, 0.18729576f, 0.11624879f, -0.12168936f, 0.06904121f, 0.01153430f, 
    -0.06133730f, 0.02720179f, 0.06207727f, -0.02924441f, -0.05391531f, 0.08447060f, -0.12352444f, 0.01286695f, 
    -0.60327750f, -0.51732320f, -0.65263450f, -0.22860357f, 0.29508457f, -0.05154403f, -0.02317912f, 0.05419429f, 
    -0.02026182f, -0.14186904f, -0.01408068f, 0.02678929f, 0.04962803f, -0.03530591f, 0.06291281f, 0.03028243f, 
    0.03519392f, 0.06375620f, 0.11747337f, -0.04701306f, 0.01757510f, 0.06349770f, -0.05689310f, -0.03221493f, 
    -0.03742868f, -0.01739723f, 0.03077836f, -0.03782885f, -0.02678683f, 0.15939872f, 0.07098466f, -0.02744599f, 
    0.04342504f, 0.12107449f, -0.02918041f, 0.03144982f, 0.04657694f, -0.05809508f, 0.02511170f, -0.03019487f, 
    -0.09665544f, -0.52588826f, -0.57854992f, -0.12335532f, 0.07106710f, 0.07741304f, -0.09825129f, -0.15194152f, 
    -0.08335505f, -0.14760530f, -0.00681774f, 0.05229659f, 0.00354152f, 0.08361321f, -0.08277599f, -0.08491044f, 
    -0.01234062f, 0.20317660f, 0.00669102f, -0.07024080f, -0.07354825f, 0.07495767f, -0.02636845f, -0.01377943f, 
    -0.01716828f, 0.03782945f, 0.02855677f, 0.04055620f, 0.04842515f, 0.06110986f, 0.06098570f, -0.08988177f, 
    0.12137805f, 0.02476984f, -0.01319474f, 0.04636720f, 0.08603253f, -0.00208345f, 0.00707421f, 0.08764476f, 
    -0.52109128f, -0.42996100f, -0.52829164f, -0.12063688f, 0.07275961f, -0.03137023f, 0.08818059f, 0.13045889f, 
    -0.17181677f, -0.18969248f, 0.00654814f, 0.00894548f, -0.01561194f, 0.04300984f, 0.04843134f, 0.00656635f, 
    0.03756087f, 0.18518272f, 0.10614779f, 0.05452321f, -0.46526212f, -0.53647786f, -0.54348916f, 0.03152541f, 
    0.06709778f, -0.04320546f, 0.02461476f, -0.03671693f, 0.07819816f, -0.19484779f, 0.02501825f, -0.00215017f, 
    -0.00156428f, -0.05720781f, 0.05912612f, 0.03252936f, 0.02304042f, 0.07268248f, 0.15975578f, 0.00738860f, 
    -0.33427238f, 0.33115166f, 0.45109802f, -0.05432264f, 0.09805803f, -0.02974834f, -0.08784395f, -0.07487321f, 
    -0.10020821f, 0.23295794f, -0.09581674f, 0.06576566f, 0.05306637f, 0.05274829f, 0.01688321f, -0.01174075f, 
    -0.03783800f, -0.03925167f, -0.03034829f, 0.00295695f, -0.08829942f, -0.08948510f, 0.08115256f, 0.07811499f, 
    0.06664653f, -0.00487120f, -0.00918028f, -0.02845829f, 0.06189685f, -0.15815815f, 0.05022196f, -0.01574964f, 
    -0.10083091f, 0.03442034f, -0.00050380f, 0.00134546f, -0.01690140f, 0.06435473f, -0.02104880f, -0.06510985f, 
    0.13180578f, -0.00147996f, -0.23367710f, -0.15604362f, 0.02279844f, 0.01773789f, 0.01914501f, 0.07412554f, 
    -0.08328573f, 0.03342997f, -0.03315670f, 0.02817300f, -0.02355042f, -0.03543669f, 0.02940430f, -0.06761749f, 
    0.01745582f, -0.09620605f, 0.09816468f, 0.06844967f, -0.30923072f, -0.17195943f, 0.13668184f, 0.16749689f, 
    0.01993812f, -0.03448956f, -0.02711250f, -0.02847398f, -0.00004420f, 0.13494357f, 0.22853500f, -0.07640229f, 
    0.01050510f, -0.00469471f, -0.02108361f, -0.00793204f, 0.01094281f, -0.02223597f, 0.07056854f, 0.07841198f, 
    -0.63463539f, -0.38529521f, -0.53834099f, -0.17657909f, 0.03654481f, -0.20301959f, 0.01874550f, 0.05776921f, 
    -0.17475374f, -0.12245624f, -0.04476067f, -0.01508197f, -0.01073624f, 0.05155843f, 0.08738168f, -0.01995063f, 
    0.00284649f, 0.02102474f, 0.22332710f, -0.02548129f, 0.45760059f, 0.19408086f, -0.20544936f, -0.04735139f, 
    -0.14622591f, 0.08957130f, 0.09418668f, 0.14518788f, 0.19701482f, -0.19056518f, 0.09809002f, 0.05607662f, 
    0.05092646f, -0.12249193f, 0.09557176f, 0.05209255f, -0.05185318f, -0.01503736f, -0.14735562f, 0.05003501f, 
    -0.36059409f, 0.08339441f, 0.44509408f, -0.21271972f, 0.25694603f, -0.14351805f, -0.12216966f, -0.03823895f, 
    -0.22931197f, 0.19453722f, -0.05550627f, 0.07403306f, 0.02618640f, 0.04991071f, -0.06519415f, 0.01465594f, 
    0.01113960f, -0.00977144f, 0.06009460f, 0.03767455f, 0.02586588f, 0.01626711f, 0.01761985f, -0.05290520f, 
    0.03662625f, 0.02979174f, 0.00318361f, 0.00590635f, 0.03330260f, 0.03178913f, -0.01193472f, -0.07426652f, 
    -0.03412723f, 0.08337566f, -0.03556503f, -0.05149436f, 0.04954870f, -0.01670116f, -0.06750876f, 0.00192140f, 
    -0.25222421f, 0.45814013f, 0.11646257f, 0.04859311f, 0.21836358f, -0.00971971f, 0.01794806f, -0.03912842f, 
    0.03946114f, 0.06427637f, 0.06710722f, 0.07192776f, 0.06625208f, 0.03828853f, -0.00771067f, 0.04470474f, 
    -0.03010482f, 0.02650805f, -0.00975519f, 0.01343134f, -0.04918256f, -0.07380709f, 0.14522694f, -0.03563020f, 
    0.03229911f, 0.00361235f, 0.06303846f, 0.04881335f, -0.02530213f, 0.03715789f, 0.07316452f, -0.02810179f, 
    -0.02139845f, 0.01047715f, -0.10692849f, -0.10111948f, 0.04773845f, -0.07335202f, 0.01461929f, 0.01418263f, 
    -0.40866295f, 0.32449490f, 0.39422819f, -0.05346579f, -0.00334290f, -0.05536128f, -0.08235186f, -0.01105641f, 
    -0.05502306f, 0.13701367f, 0.04614113f, 0.05233707f, -0.00792857f, 0.06988098f, 0.00377128f, 0.01492496f, 
    -0.01624157f, 0.02168129f, -0.07152390f, 0.00257675f, 0.06291253f, 0.17602627f, -0.16369961f, -0.05450644f, 
    0.06927692f, -0.05077427f, -0.01472516f, -0.16740684f, 0.06254995f, -0.22915375f, -0.02412672f, -0.11103647f, 
    -0.12338709f, -0.00803299f, 0.04311244f, -0.00539896f, -0.05210847f, 0.05670694f, -0.19714630f, -0.15143655f, 
    0.09669130f, -0.06725061f, -0.10350729f, 0.02096007f, -0.16523360f, 0.03708263f, 0.14375302f, -0.10654373f, 
    0.08559199f, 0.12793759f, -0.03610959f, 0.02959937f, -0.00751200f, 0.03301280f, -0.00372819f, 0.10631812f, 
    0.07649404f, 0.05328822f, 0.15416084f, 0.12969178f, -0.15830112f, -0.01301608f, -0.45592660f, -0.23434879f, 
    0.19871931f, -0.00752664f, 0.02011211f, 0.09872144f, -0.04195383f, 0.05891623f, -0.03598474f, 0.00850828f, 
    -0.00049761f, -0.03047557f, 0.04027355f, 0.00368661f, -0.06276588f, -0.15843308f, 0.18283708f, -0.02281683f, 
    -0.34776965f, -0.36602211f, -0.33663100f, -0.22847998f, -0.04243414f, -0.08224122f, -0.00096473f, 0.00055624f, 
    -0.15815718f, -0.07179380f, -0.01204254f, -0.00246126f, -0.01981953f, 0.03932941f, 0.00056594f, -0.02904962f, 
    -0.03171550f, 0.03649830f, 0.01059188f, -0.06197310f, -0.10633698f, -0.07582837f, 0.11475212f, -0.07857144f, 
    -0.06329850f, -0.00305054f, -0.02983421f, -0.07951766f, -0.03662558f, -0.03842332f, 0.10112257f, -0.02657802f, 
    -0.06119064f, 0.02583243f, -0.00360312f, 0.01593292f, -0.02406837f, -0.05461879f, -0.04887865f, -0.06022768f, 
    0.21736403f, 0.08054335f, -0.01008009f, -0.12579128f, 0.06186422f, 0.06429701f, -0.12617333f, 0.07936146f, 
    0.11106195f, -0.22467697f, 0.06534187f, 0.01430232f, -0.01837328f, 0.10791235f, 0.08928552f, -0.10783502f, 
    -0.04856618f, -0.05847050f, -0.24879722f, -0.07238291f, -0.49953833f, -0.52959883f, -0.05609951f, -0.12653024f, 
    -0.26429817f, -0.31766334f, -0.14321165f, -0.01757084f, -0.05902044f, -0.16971801f, -0.02568395f, -0.00235350f, 
    -0.01265789f, -0.05058881f, 0.02176033f, -0.02384168f, -0.01973933f, 0.03121156f, 0.05398878f, -0.13642028f, 
    -0.25190505f, -0.15570000f, -0.27408442f, -0.49383286f, 0.05804427f, -0.25860330f, -0.07882308f, -0.00471154f, 
    0.14485632f, -0.01680835f, 0.05415131f, -0.03238687f, 0.04258537f, 0.00331004f, -0.11579250f, -0.02239041f, 
    0.07182410f, -0.11533652f, 0.12380726f, -0.00382935f, 0.36483955f, 0.27538303f, -0.13631497f, 0.19881888f, 
    -0.13205509f, -0.06274008f, 0.19135523f, 0.05811615f, 0.01805009f, -0.46782973f, 0.00917376f, 0.04454983f, 
    -0.07577349f, -0.00462559f, 0.08541822f, -0.05619332f, 0.01127494f, 0.11406817f, -0.12162369f, -0.03740985f, 
    -0.44082204f, 0.83203292f, -0.07482961f, 0.10887073f, 0.38932464f, -0.09110346f, 0.18687777f, -0.01125811f, 
    0.03430882f, 0.03184953f, 0.06247457f, -0.01834799f, 0.09159049f, -0.04665066f, -0.08784474f, 0.03153371f, 
    -0.00940162f, 0.06762170f, 0.09098364f, -0.05088773f, -0.18582591f, 0.15719213f, 0.22665572f, -0.02421341f, 
    -0.03261246f, -0.09197889f, -0.05018750f, -0.08353052f, -0.08592996f, 0.00683672f, -0.12442370f, -0.04052185f, 
    0.02482126f, 0.02053361f, 0.04867407f, -0.00329358f, -0.00475169f, -0.02835236f, -0.04880024f, -0.05239079f, 
    0.03016985f, -0.00442073f, -0.02203623f, -0.06667950f, -0.08493148f, 0.01533111f, -0.00848402f, 0.05942688f, 
    -0.03843191f, 0.00219609f, -0.05029421f, -0.06571558f, -0.01725402f, -0.05692125f, -0.05436656f, 0.02802640f, 
    -0.05258832f, -0.04064346f, -0.04995738f, 0.01705939f, -0.10778056f, 0.02254892f, -0.39322406f, -0.10815808f, 
    0.29255393f, -0.00127813f, 0.09752540f, 0.13283171f, 0.02460574f, 0.19318679f, -0.05668189f, 0.00149239f, 
    0.01403897f, -0.00899748f, 0.08265197f, -0.07580077f, 0.04645806f, -0.08452234f, 0.14319371f, 0.00023310f, 
    -0.11136613f, 0.09555946f, 0.23223394f, 0.07875898f, 0.17728694f, 0.03368912f, -0.04799565f, -0.01938825f, 
    -0.04965132f, 0.03191288f, -0.00770095f, 0.13812225f, 0.04773154f, 0.04155133f, -0.05312062f, 0.00123715f, 
    -0.02950983f, 0.04742388f, -0.03602227f, 0.02212110f, -0.05026511f, 0.06309167f, 0.06378634f, 0.00144425f, 
    0.04077915f, -0.01487028f, -0.04508022f, 0.00405662f, -0.00615353f, 0.07143594f, 0.04060591f, 0.07421425f, 
    0.10637438f, 0.09809235f, -0.01134967f, -0.01749942f, 0.01131258f, -0.08331065f, -0.00933609f, -0.02301437f, 
    -0.01188038f, -0.08146028f, 0.04561454f, -0.07962779f, -0.04365810f, -0.01550355f, -0.06362814f, 0.01212944f, 
    -0.06180451f, -0.01295781f, -0.07544937f, -0.11979686f, -0.07682315f, -0.10417617f, -0.06979261f, -0.10356277f, 
    -0.12302457f, -0.05189281f, -0.05605147f, 0.00129410f, -0.28846982f, -0.01166819f, 0.27815464f, -0.04965642f, 
    0.02900763f, -0.24927646f, -0.12437385f, -0.07979243f, -0.14802675f, -0.01803205f, -0.04468451f, -0.01221270f, 
    -0.00504286f, -0.00018020f, 0.03615094f, -0.02537239f, -0.01465826f, -0.01146022f, 0.06917570f, -0.06614547f, 
    -0.05271964f, -0.02662181f, 0.29703823f, 0.06593905f, 0.20244367f, 0.11633087f, 0.08232328f, 0.05302324f, 
    0.09590710f, 0.01170955f, -0.03528255f, 0.04219124f, 0.01703573f, -0.01410014f, 0.02302936f, -0.03789125f, 
    0.08790165f, 0.04717146f, -0.02088196f, 0.02961220f, 0.08810453f, -0.17754358f, -0.18433431f, -0.05089685f, 
    0.07973771f, -0.04446567f, 0.07267296f, -0.01489091f, 0.00383626f, 0.00797745f, -0.02964726f, -0.01435957f, 
    -0.13594437f, -0.05717142f, 0.01810336f, -0.06590448f, -0.01508772f, -0.02174834f, -0.04362535f, 0.00125594f, 
    -0.01950067f, 0.02099443f, -0.00043385f, -0.01316353f, -0.01213018f, 0.02295019f, -0.01422660f, 0.01210569f, 
    -0.00101618f, -0.04065081f, -0.05912255f, -0.00540388f, 0.06564419f, -0.00201265f, 0.00126252f, 0.10843052f, 
    -0.10437648f, -0.00851309f, -0.14560446f, -0.04175421f, -0.13913535f, -0.51577955f, 0.12024388f, -0.01288505f, 
    0.08373128f, -0.01022006f, -0.16490319f, -0.12247005f, -0.09642959f, 0.02887844f, -0.00581462f, 0.04672292f, 
    -0.00219422f, -0.09016907f, -0.09563289f, 0.07934073f, 0.05484084f, 0.00170129f, 0.02312134f, 0.01488319f, 
    -0.49120313f, -0.44868779f, -0.44206464f, -0.28466815f, 0.31620252f, -0.09929433f, -0.03055492f, -0.10646007f, 
    -0.10801300f, -0.24591605f, -0.00646397f, -0.02791469f, -0.01974346f, 0.02160203f, 0.01841422f, -0.03111919f, 
    0.00435651f, 0.06559341f, 0.17661887f, 0.10703103f, -0.17435703f, -0.67989635f, -0.60174894f, -0.15056388f, 
    0.00735240f, -0.08675424f, 0.10424627f, 0.13762075f, -0.04158460f, -0.18746348f, -0.00188873f, -0.03997172f, 
    -0.01418287f, 0.02184546f, 0.03393720f, -0.02819930f, 0.04495300f, 0.10701744f, 0.01156129f, 0.01889028f, 
    -0.01677943f, 0.16019081f, -0.01596257f, -0.00503803f, 0.13863526f, -0.02470439f, -0.02883407f, -0.04456428f, 
    0.06940170f, -0.07557926f, 0.19388019f, 0.06436314f, 0.14824273f, -0.06024108f, -0.03179291f, 0.04779040f, 
    -0.01116050f, -0.15586755f, -0.00903944f, 0.01578755f, 0.06611793f, 0.04567156f, -0.02062816f, 0.12127236f, 
    0.23874344f, -0.03023854f, -0.02312757f, 0.07888503f, -0.02663997f, 0.18107444f, 0.00464171f, 0.05273783f, 
    0.14973012f, 0.03393659f, 0.05856613f, -0.09293246f, 0.01809718f, -0.05362286f, 0.07514704f, -0.11176260f, 
    -0.02515107f, -0.23171398f, 0.10440753f, 0.22755054f, 0.32161200f, 0.02673909f, -0.05060526f, 0.06379937f, 
    -0.12540035f, 0.05531640f, 0.04945645f, 0.01950130f, 0.01945990f, -0.05551114f, -0.07955731f, -0.06192933f, 
    0.02762985f, 0.03887228f, 0.07724059f, 0.02433565f, -0.06476489f, -0.43496177f, -0.41055331f, 0.01885555f, 
    0.28293526f, 0.04651764f, -0.02465953f, -0.00674156f, -0.06038317f, -0.08459368f, -0.02295787f, -0.03010467f, 
    -0.04068512f, 0.02382783f, 0.04730298f, 0.04568243f, 0.02037160f, 0.00921403f, 0.13633022f, 0.04516993f, 
    0.28744552f, 0.04396080f, -0.19853024f, -0.17696559f, -0.01416115f, 0.05046935f, -0.00015593f, 0.11747859f, 
    0.02482148f, -0.03136787f, 0.01720395f, -0.00491748f, -0.02866017f, -0.04967845f, 0.01862584f, -0.00507039f, 
    -0.04683826f, 0.07336634f, -0.03628373f, 0.04040257f, -0.30406976f, -0.24508616f, -0.54094952f, -0.25590110f, 
    0.00270470f, -0.26564929f, -0.00268565f, -0.10791273f, -0.01877262f, -0.39807817f, 0.01735301f, -0.03164342f, 
    -0.02974442f, 0.03209594f, 0.06898203f, 0.02609127f, -0.03014824f, 0.04623779f, 0.08820941f, 0.07460273f, 
    -0.27117774f, -0.63300514f, -0.59067905f, 0.01351937f, -0.07418627f, 0.02947639f, 0.15200482f, -0.13571157f, 
    -0.13229986f, -0.59607118f, 0.03720587f, -0.03189774f, -0.09690449f, -0.07048193f, 0.02420389f, -0.00774530f, 
    -0.01501301f, 0.10321859f, 0.04561983f, 0.05551996f, -0.35523087f, 0.03928351f, 0.29646271f, 0.01908492f, 
    -0.02811389f, -0.07705016f, -0.18222231f, -0.01276243f, -0.00032869f, -0.04155709f, -0.00235924f, 0.03430602f, 
    0.02087784f, -0.00681966f, 0.05166517f, -0.02662470f, -0.04485385f, 0.06477450f, -0.07705506f, 0.00381500f, 
    -0.30513930f, -0.68863517f, -0.63401598f, -0.08356165f, 0.06049142f, 0.00388888f, 0.09060466f, -0.02091591f, 
    -0.05674610f, -0.32033375f, 0.02507139f, 0.03488532f, -0.00024465f, -0.06170039f, 0.02540169f, -0.01438051f, 
    0.02894099f, 0.06044503f, 0.24738896f, 0.03339680f, 0.17718251f, 0.07823078f, -0.18455943f, -0.09672311f, 
    0.05888348f, -0.12148473f, -0.01456334f, 0.07825352f, 0.16852319f, -0.01332782f, 0.11940613f, 0.00737456f, 
    -0.01428279f, -0.03603839f, 0.02413003f, 0.03058313f, -0.03988267f, 0.04290745f, 0.03961961f, -0.01210677f, 
    -0.04789356f, -0.19494809f, -0.50110316f, 0.15498658f, 0.27056187f, 0.05045231f, 0.04424955f, -0.07945015f, 
    -0.00792219f, 0.05115150f, -0.05573225f, -0.01463912f, -0.01459197f, 0.04730376f, 0.07248708f, 0.02996165f, 
    0.01476241f, -0.07470779f, 0.23238164f, 0.05805973f, -0.33778721f, 0.26335895f, 0.10719502f, 0.01248548f, 
    -0.02605857f, -0.10667965f, -0.03838721f, -0.06482757f, -0.07010379f, 0.11802828f, -0.06027051f, 0.04860490f, 
    -0.03874153f, 0.01607676f, 0.02010675f, -0.01726910f, -0.00319015f, -0.01135822f, 0.04749732f, -0.02567358f, 
    0.27579147f, 0.01083236f, -0.12263560f, -0.11439331f, 0.03443852f, 0.05329212f, -0.05869766f, 0.13877822f, 
    0.09479190f, -0.07807151f, 0.08010478f, -0.00260157f, 0.04422517f, -0.12115975f, 0.02864180f, 0.04469376f, 
    -0.06963404f, -0.03647608f, -0.07646964f, 0.03026994f, -0.15703662f, -0.14151588f, -0.14763267f, -0.21008570f, 
    -0.02603522f, 0.02728837f, 0.05842607f, 0.09432042f, 0.00598984f, -0.01961969f, -0.02422393f, -0.01703568f, 
    0.02675291f, 0.01502461f, 0.00859390f, 0.01259205f, 0.03389444f, 0.00357757f, -0.01212451f, -0.01016327f, 
    -0.02642112f, 0.01187556f, -0.06707603f, 0.07516800f, -0.15068929f, 0.04302811f, 0.00850615f, 0.07529735f, 
    0.04808908f, -0.02309459f, 0.03806209f, 0.03026609f, -0.00637786f, 0.01478145f, -0.02900909f, 0.03159712f, 
    -0.00028711f, 0.02763474f, 0.00201955f, 0.03636983f, 0.03054942f, 0.05862192f, -0.02246990f, -0.01742297f, 
    -0.01038879f, -0.01709371f, -0.03480135f, -0.00075259f, -0.01407675f, -0.05572657f, -0.08102206f, -0.13728958f, 
    -0.12862258f, -0.00277094f, -0.06384859f, -0.00122380f, -0.00260423f, 0.00954595f, -0.01023137f, -0.01399440f, 
    -0.08650033f, 0.05844219f, 0.03212886f, 0.00505708f, -0.08199516f, 0.02557241f, -0.00121624f, 0.00979645f, 
    -0.01165540f, -0.03466960f, 0.02715961f, -0.01170170f, 0.00850427f, 0.03193773f, -0.01139856f, 0.03143631f, 
    0.00413625f, -0.07338620f, -0.02191312f, -0.03551317f, 0.23142919f, -0.25137711f, -0.21944411f, 0.04992324f, 
    -0.06986320f, -0.10878776f, 0.08225907f, -0.07454107f, 0.09466103f, 0.03178454f, 0.01352883f, 0.00834453f, 
    0.00825435f, -0.01141388f, 0.01983572f, -0.02716655f, -0.00254662f, -0.01950461f, -0.05884521f, -0.11007220f, 
    0.31646657f, -0.20459370f, -0.19414771f, 0.20827579f, -0.16476734f, 0.15947516f, 0.11392467f, 0.15247910f, 
    -0.02861597f, -0.09636974f, -0.07923901f, 0.05028953f, 0.03355898f, 0.00483767f, 0.00246819f, -0.03237781f, 
    0.06052460f, 0.01572136f, -0.06737690f, -0.11867363f, 0.09722313f, 0.13708767f, 0.11016925f, -0.13741778f, 
    -0.13221842f, -0.06374843f, -0.05179285f, -0.26712367f, 0.04256326f, 0.06307688f, 0.04987309f, 0.04676409f, 
    0.04801110f, 0.01887732f, -0.00831925f, -0.00522825f, 0.01631463f, -0.14433357f, 0.03623454f, -0.02230002f, 
    0.00201985f, -0.03610686f, -0.02149434f, -0.03656978f, -0.19199041f, -0.00021717f, 0.00762154f, -0.03578595f, 
    0.04338279f, -0.02229074f, -0.06035549f, 0.00854129f, -0.02026969f, -0.05103976f, -0.07277210f, 0.02237120f, 
    0.03412145f, -0.08921970f, 0.00251901f, 0.05805124f, 0.06010491f, 0.06406832f, -0.01101225f, -0.05371180f, 
    -0.07548719f, 0.03214056f, 0.01660931f, -0.01724003f, -0.04071714f, -0.06384232f, -0.09196512f, -0.14573446f, 
    -0.14155850f, -0.17953770f, -0.15951250f, 0.03406437f, 0.01117314f, 0.00625832f, -0.02601389f, 0.02949281f, 
    -0.06309560f, 0.06464749f, 0.23926239f, -0.12557682f, 0.20091712f, -0.00929071f, 0.04706589f, 0.08648737f, 
    -0.03478016f, 0.02138065f, 0.01888102f, -0.00277463f, 0.04397104f, 0.02825941f, -0.04203968f, -0.03932331f, 
    -0.03344556f, -0.00836985f, -0.04699595f, -0.14907144f, 0.01064030f, 0.06799454f, 0.18194348f, -0.16505788f, 
    0.03651847f, -0.05532508f, -0.11618945f, -0.00349486f, -0.08565883f, 0.11774651f, 0.03420872f, 0.03593446f, 
    0.04551075f, 0.03064276f, -0.03913179f, 0.04334714f, -0.08895794f, 0.06492841f, -0.04180951f, -0.04889860f, 
    0.01559137f, -0.28156513f, -0.13587295f, 0.37398896f, -0.32969141f, -0.07770608f, 0.06066689f, -0.00202705f, 
    -0.01092530f, 0.03934248f, -0.05578595f, 0.02084751f, -0.01423294f, 0.01753556f, -0.00276967f, -0.03100532f, 
    0.01460716f, -0.07504426f, -0.02645762f, -0.00483122f, 0.00923949f, 0.11064629f, -0.08884516f, 0.00412072f, 
    -0.08118287f, -0.03987148f, 0.05067648f, -0.01329300f, -0.04886127f, 0.00426550f, -0.10646724f, -0.01530413f, 
    -0.05511386f, -0.06741972f, -0.11785981f, 0.05392712f, -0.02206127f, -0.02773928f, -0.03294998f, 0.01901429f, 
    -0.16385520f, -0.39136767f, 0.32832432f, -0.39371055f, 0.02094838f, -0.18471913f, 0.17082468f, -0.00596793f, 
    0.26675993f, 0.02962388f, 0.00887983f, -0.02301414f, -0.02209716f, -0.06314268f, -0.01495188f, -0.00838985f, 
    -0.02717805f, 0.12368278f, 0.03416445f, 0.01712948f, -0.04646466f, -0.10096136f, -0.03293452f, -0.02302889f, 
    -0.05583363f, -0.00614232f, 0.00946521f, 0.04877418f, -0.04706832f, -0.02163962f, 0.01452054f, -0.03636803f, 
    0.00238351f, -0.02561760f, -0.03512736f, 0.03887459f, -0.14717408f, -0.13262250f, 0.04375748f, 0.01640813f, 
    -0.30207604f, -0.37323642f, 0.15378097f, 0.22251824f, 0.16750318f, 0.04988562f, 0.05561363f, 0.08953162f, 
    -0.11690935f, 0.09225080f, 0.01177732f, 0.00087665f, 0.00728529f, -0.01144668f, -0.03246205f, 0.05845647f, 
    0.08548184f, 0.06051216f, 0.06777877f, -0.01194803f, -0.16455314f, -0.33338991f, -0.03772329f, 0.22654532f, 
    -0.13024113f, 0.01325561f, 0.00544845f, -0.03778853f, -0.02658128f, 0.06590788f, -0.01591860f, -0.00200955f, 
    0.01573860f, -0.06604383f, -0.00679281f, 0.00613330f, 0.02249369f, -0.09669160f, 0.01164947f, -0.04675029f, 
    0.25219458f, 0.02259611f, -0.12129959f, -0.11416133f, -0.06325982f, -0.03736904f, 0.03039923f, -0.06584226f, 
    0.04753146f, -0.04321672f, 0.06153179f, 0.05964192f, 0.04231820f, 0.02309465f, 0.05530792f, 0.00486202f, 
    0.03544882f, 0.00950969f, 0.04292775f, 0.03223459f, 0.05518106f, 0.01320062f, 0.00290450f, -0.03345113f, 
    -0.07198448f, -0.03541822f, 0.10307799f, 0.04801872f, -0.03568438f, 0.00235960f, -0.00401462f, -0.06967262f, 
    0.01892394f, 0.01113909f, 0.01726082f, 0.02324275f, -0.03579670f, -0.01829316f, -0.08070830f, 0.04988854f, 
    -0.05737740f, 0.03684507f, 0.02015313f, -0.01032087f, -0.07639607f, -0.02415868f, 0.01686048f, -0.02715592f, 
    -0.04348893f, -0.00408275f, 0.01755772f, 0.02468864f, 0.00596349f, 0.01748884f, -0.01474791f, -0.06803980f, 
    -0.00021041f, -0.10683505f, -0.01801655f, -0.01365339f, 0.31261450f, -0.01508575f, 0.07889900f, -0.11213906f, 
    -0.07699635f, -0.12358151f, 0.19872402f, -0.04380253f, 0.02527143f, -0.02708034f, -0.01024511f, -0.01350341f, 
    0.16626084f, -0.00854082f, 0.03948272f, 0.00603847f, 0.05939985f, 0.00217195f, 0.01816658f, -0.09642890f, 
    -0.29864603f, -0.30194128f, -0.10521640f, 0.22074591f, 0.21665809f, 0.06224804f, -0.04270139f, -0.00138406f, 
    -0.08429207f, 0.07947433f, 0.01445827f, -0.01227555f, -0.07398502f, 0.00423572f, 0.00368397f, 0.07079536f, 
    0.07445614f, -0.04761210f, 0.11157390f, 0.04016375f, -0.38165531f, 0.11742355f, 0.32613921f, -0.01390535f, 
    0.22745688f, 0.04756280f, 0.05479484f, -0.05944040f, 0.03842520f, 0.08097297f, 0.08697434f, 0.02228837f, 
    0.04533500f, -0.01350778f, 0.08247893f, 0.02577158f, -0.01481861f, -0.08106938f, -0.14937940f, -0.00875754f, 
    0.56606179f, -0.56639135f, -0.66804737f, -0.32908183f, -0.26588815f, 0.03108527f, -0.01980056f, -0.32973996f, 
    0.22232302f, -0.04410867f, 0.01065872f, 0.07220438f, 0.02004800f, 0.00881721f, 0.07320768f, -0.00224630f, 
    0.02440794f, -0.01712113f, 0.07105229f, 0.04060734f, 0.02814768f, 0.04819208f, 0.01787297f, -0.00786090f, 
    -0.00804562f, -0.04012462f, -0.00110000f, 0.00514157f, -0.03819086f, -0.05136009f, -0.01244379f, -0.02447958f, 
    0.01993995f, -0.03323092f, -0.04069823f, -0.07032347f, -0.06390483f, 0.01339772f, -0.02664742f, 0.03122000f, 
    -0.07591380f, -0.21347807f, -0.13515498f, -0.11635876f, -0.08783248f, -0.03038375f, -0.08637257f, 0.08541495f, 
    0.07255781f, 0.03499252f, -0.08412902f, 0.01986773f, 0.04571310f, 0.03579483f, -0.06093973f, 0.02313814f, 
    -0.01338943f, 0.02432739f, 0.04503725f, 0.01334173f, 0.06291624f, 0.11244278f, -0.10088576f, 0.00573937f, 
    -0.16960010f, 0.00407445f, 0.02261372f, 0.05785865f, -0.02991354f, -0.07453644f, -0.18672487f, 0.03233847f, 
    0.05062395f, -0.12820937f, -0.14064355f, 0.01051862f, -0.03096608f, 0.02270983f, -0.04846158f, 0.06099715f, 
    0.58357430f, -0.22968780f, -0.14144817f, -0.18499599f, -0.04995998f, -0.10059718f, 0.04624270f, -0.00062525f, 
    -0.03933650f, -0.15079360f, 0.05845723f, -0.10146679f, 0.03771193f, 0.05146786f, 0.00962337f, -0.02714705f, 
    -0.02971781f, 0.01992302f, 0.04173392f, -0.00257605f, -0.17609018f, -0.14908433f, 0.14881998f, 0.05977642f, 
    0.10737218f, -0.08504310f, 0.07700273f, 0.04690423f, 0.07400425f, 0.07434152f, -0.03962031f, 0.07215864f, 
    -0.04971222f, 0.04173099f, 0.00413239f, 0.03630131f, 0.00567930f, -0.04450960f, -0.07129135f, -0.03733060f, 
    0.24002877f, -0.41119662f, 0.22493732f, -0.17314671f, 0.14486365f, -0.05048910f, -0.04496552f, -0.16782865f, 
    0.08002238f, -0.01378386f, -0.02731459f, 0.04571251f, -0.05085177f, -0.07340348f, -0.05084658f, -0.01766202f, 
    -0.02045779f, 0.00714111f, 0.04724088f, -0.03006457f, 0.09680557f, 0.26230764f, -0.07201000f, 0.05977329f, 
    -0.40558013f, -0.03322452f, 0.11752827f, -0.05986296f, -0.06330314f, -0.03721404f, -0.01845738f, 0.07185827f, 
    0.02907686f, -0.01595664f, 0.01305278f, -0.10830447f, -0.05858963f, 0.07459932f, -0.12417830f, 0.02536285f, 
    0.32831317f, -0.20243236f, -0.20528910f, -0.18256319f, -0.09915604f, 0.01754531f, 0.01815287f, -0.05989356f, 
    0.14324072f, -0.01471884f, 0.00392133f, -0.02676250f, -0.02145824f, -0.05700528f, -0.03198781f, -0.03496329f, 
    -0.07872166f, 0.01051097f, -0.02891895f, 0.00146112f, 0.04428051f, 0.06379140f, 0.05076853f, -0.09366895f, 
    -0.01704977f, 0.02559589f, 0.02280566f, 0.03710999f, -0.02179439f, -0.05073535f, -0.06998314f, -0.14313450f, 
    -0.02867711f, 0.03500794f, 0.04111882f, 0.02522867f, 0.02562947f, 0.02424164f, 0.00567833f, 0.00362858f, 
    -0.03065734f, 0.02563315f, 0.17393045f, -0.12959433f, 0.14321630f, -0.05733716f, 0.01918980f, 0.00831920f, 
    0.03649995f, 0.03008937f, 0.01880121f, -0.03168286f, 0.09854084f, -0.01584611f, -0.09444534f, -0.01083864f, 
    -0.12832381f, -0.14314492f, 0.00082245f, 0.04353768f, 0.46873128f, -0.20615211f, -0.25228941f, -0.17903063f, 
    0.09951945f, 0.01814713f, -0.03682343f, -0.05870184f, 0.12885293f, 0.09007763f, 0.03929684f, 0.04360653f, 
    0.03564820f, -0.00089357f, 0.00258471f, -0.01733499f, -0.00634247f, -0.00326222f, -0.04812120f, -0.06285205f, 
    -0.50337619f, 0.20007133f, -0.42189857f, 0.12612234f, 0.01396284f, 0.33046037f, -0.02810102f, 0.09286258f, 
    -0.15121242f, -0.01438655f, -0.01676553f, 0.02503808f, -0.06945241f, -0.00051144f, -0.00309940f, 0.04889173f, 
    0.13632217f, 0.08815765f, 0.10347781f, 0.13197674f, -0.75174469f, -0.00092910f, 0.61581951f, -0.08597027f, 
    0.32962278f, 0.08976058f, -0.20952806f, -0.00123107f, 0.09121072f, 0.05575708f, 0.08879106f, 0.00482076f, 
    0.01951378f, 0.04894453f, 0.00764669f, 0.06912404f, -0.11656521f, 0.05031856f, -0.29207590f, -0.01034500f, 
    -0.46392202f, -0.56748867f, -0.49837157f, -0.39406034f, -0.16035260f, 0.08118927f, -0.17742428f, 0.21562956f, 
    -0.09919686f, -0.04338914f, -0.06524547f, 0.06878648f, 0.08434921f, 0.01757307f, 0.00487874f, 0.01789485f, 
    -0.03037187f, 0.04495659f, 0.03029805f, 0.01901907f, 0.10801799f, -0.04597142f, -0.08243515f, -0.06360935f, 
    -0.03698240f, 0.06308787f, -0.00320084f, 0.03861910f, -0.01490919f, -0.00765844f, -0.03031288f, -0.04853084f, 
    0.06155727f, 0.02411166f, 0.02655911f, -0.00516807f, 0.02078759f, 0.00526507f, 0.00719512f, 0.00332575f, 
    0.02210406f, 0.03493917f, 0.06026408f, 0.02548989f, -0.04034372f, -0.00152705f, -0.02139796f, -0.02910361f, 
    -0.03174587f, -0.02711083f, 0.05025038f, -0.00813986f, -0.01237489f, -0.02569424f, -0.06198981f, 0.00956515f, 
    0.02864562f, 0.00974698f, 0.04712692f, 0.02699571f, 0.24782479f, 0.28751519f, -0.37380230f, 0.10569763f, 
    -0.34717920f, -0.01629125f, 0.08495843f, -0.05971351f, -0.13842148f, 0.00054091f, -0.05076149f, 0.10045837f, 
    0.01674595f, -0.02430263f, -0.01138442f, 0.00595838f, -0.11693084f, 0.04604811f, -0.05602108f, -0.06424031f, 
    0.05997745f, 0.02953344f, -0.05761269f, 0.00273291f, -0.06130117f, -0.01406803f, 0.01319343f, 0.00326971f, 
    0.05125829f, -0.03972546f, 0.01211485f, -0.03851037f, -0.00409867f, 0.04398281f, -0.08639047f, -0.01201263f, 
    -0.00142437f, 0.01111362f, 0.03796178f, 0.02163638f, 0.03053528f, 0.06177802f, 0.00156350f, -0.01026128f, 
    -0.05654322f, 0.03078157f, 0.00459507f, -0.01249435f, -0.01808509f, -0.03405326f, -0.10830247f, -0.07235392f, 
    0.04722043f, -0.08263618f, -0.04417972f, 0.00468754f, -0.00397812f, -0.02721784f, 0.03485462f, 0.01259741f, 
    -0.02537728f, 0.11472331f, 0.00336197f, 0.07936851f, -0.08593202f, 0.00216963f, 0.01559534f, 0.02681354f, 
    -0.02643894f, -0.02952395f, 0.04229311f, 0.02547317f, 0.04781650f, -0.01606801f, -0.03611313f, -0.04511552f, 
    -0.02590563f, 0.11844876f, 0.00212218f, 0.05621547f, 0.29563144f, -0.23810233f, -0.21843092f, -0.03296402f, 
    -0.10620590f, 0.15625219f, -0.08542423f, -0.03506356f, -0.03383123f, 0.01579178f, 0.10540531f, 0.04977634f, 
    0.08030003f, -0.01711486f, -0.01178710f, 0.01063673f, -0.01223139f, 0.01780377f, -0.04352209f, -0.02070604f, 
    -0.01842115f, 0.15660928f, -0.09942584f, 0.03562814f, -0.00938206f, -0.12321153f, 0.02364756f, 0.06200275f, 
    -0.10527939f, -0.03403552f, -0.02816142f, -0.09331128f, 0.04029381f, -0.02718821f, -0.11228770f, -0.07468219f, 
    -0.07068300f, 0.07815381f, -0.29486606f, 0.01696010f, 0.00852270f, 0.05648426f, 0.02265456f, -0.02391661f, 
    -0.05615452f, -0.00423918f, 0.04945339f, -0.01447439f, 0.01340430f, -0.04281770f, 0.07513242f, 0.03723534f, 
    -0.02462197f, -0.00440319f, -0.02188275f, -0.00467014f, -0.01163989f, 0.06089913f, 0.04416262f, 0.02799670f, 
    -0.01405400f, 0.10063295f, 0.09008816f, 0.00354281f, 0.01686219f, -0.00192719f, -0.00735600f, 0.00275706f, 
    -0.00515091f, -0.02865579f, 0.06523343f, -0.04349460f, -0.06256711f, -0.07251295f, -0.09628347f, -0.06558653f, 
    0.04071236f, -0.00690446f, 0.03252845f, 0.02169572f, 0.39431784f, -0.48037952f, 0.14976010f, -0.35129353f, 
    -0.27953982f, -0.12949957f, 0.10025954f, -0.24552326f, 0.25542787f, 0.06496353f, -0.00268728f, 0.01563471f, 
    0.00332461f, -0.06206730f, 0.03152644f, -0.11874419f, -0.02901716f, -0.13743059f, 0.11086401f, -0.01178834f, 
    -0.37158114f, -0.28350559f, -0.21872769f, 0.29014364f, 0.18642683f, 0.01836177f, -0.03612600f, -0.01317128f, 
    0.06832190f, 0.02207680f, 0.03176209f, -0.03672528f, -0.07226485f, -0.10441321f, -0.07338305f, -0.01209352f, 
    -0.01531537f, -0.02417118f, 0.26669747f, -0.03285855f, -0.41729957f, -0.25606763f, 0.18352920f, -0.00299945f, 
    -0.01816816f, 0.03420644f, -0.05701306f, 0.00134837f, -0.06615975f, 0.08215695f, 0.04236573f, 0.02106143f, 
    0.02971768f, -0.01871212f, -0.01562153f, 0.07184268f, 0.07951019f, 0.08902457f, -0.03691179f, -0.09064935f, 
    -0.06266423f, 0.03327104f, -0.08641656f, 0.02588716f, -0.05100863f, 0.00428714f, 0.03140567f, 0.05624363f, 
    -0.00076748f, 0.01240264f, -0.11337907f, 0.11792858f, -0.02471775f, -0.03596192f, -0.00477574f, 0.03800181f, 
    -0.03698659f, -0.03551067f, 0.06026363f, 0.06674881f, 0.18473354f, 0.38634121f, 0.01418482f, 0.04398168f, 
    -0.57615459f, -0.07458795f, 0.14254335f, -0.03929688f, -0.01918421f, 0.03213434f, -0.13752137f, 0.06857342f, 
    -0.08917971f, -0.07161390f, -0.07440177f, -0.18439326f, -0.07298435f, 0.00291018f, -0.08353696f, -0.08635770f, 
    0.22964892f, -0.35623699f, -0.23623078f, -0.25709486f, -0.21251880f, 0.07434701f, -0.01693472f, -0.06173136f, 
    0.02038678f, -0.01473617f, 0.02393454f, -0.01996040f, 0.03391185f, -0.10757289f, 0.00882594f, -0.00444994f, 
    -0.07544886f, 0.03982005f, 0.02091416f, 0.01959939f, 0.02385074f, -0.19601706f, 0.06693778f, 0.19897790f, 
    -0.04258940f, -0.00477431f, 0.00748758f, 0.02355679f, -0.03021301f, -0.09219293f, 0.04774758f, -0.01832917f, 
    0.00249656f, -0.05821615f, -0.06428011f, 0.06882890f, -0.05039323f, 0.00204046f, 0.09024756f, -0.05168629f, 
    -0.11704846f, 0.10204936f, 0.06255361f, -0.01605150f, 0.00050710f, -0.02741091f, -0.02954154f, -0.06125124f, 
    -0.01669673f, 0.00003313f, 0.06699383f, 0.01306965f, 0.03133018f, 0.00597820f, -0.00911774f, 0.04643574f, 
    -0.06081649f, -0.04873013f, -0.04632220f, 0.04537189f, -0.15199463f, -0.13895279f, -0.21766064f, 0.23080592f, 
    0.00732959f, 0.07274368f, 0.07341424f, -0.04341414f, 0.00976134f, 0.11265567f, 0.01586247f, -0.04631338f, 
    -0.11023571f, -0.05591457f, -0.07237366f, 0.00687869f, 0.08422022f, -0.01426143f, 0.10475595f, -0.02384374f, 
    -0.53669190f, -0.40913418f, 0.13591644f, 0.29051024f, 0.31712833f, -0.12515269f, 0.05195382f, 0.11273497f, 
    -0.02010469f, 0.07804466f, -0.01565660f, -0.01034673f, -0.05007337f, -0.05454994f, -0.00539194f, -0.03498697f, 
    0.00040307f, -0.09210830f, 0.12756528f, -0.16933171f, 0.39798504f, -0.22080928f, -0.01680254f, -0.09507314f, 
    -0.08120620f, -0.00055884f, 0.03159689f, 0.01152830f, -0.03307784f, -0.03043727f, 0.06593799f, -0.03836223f, 
    0.03109491f, 0.03602298f, 0.02500747f, -0.00757940f, 0.03709206f, -0.03021226f, -0.01016747f, -0.02006321f, 
    -0.69252533f, -0.60418588f, 0.23642015f, 0.31601936f, 0.26968515f, -0.04295744f, 0.03312407f, 0.05783976f, 
    -0.03571326f, 0.13012554f, 0.09427163f, 0.02214565f, 0.03253555f, -0.00571474f, -0.01007245f, 0.01763720f, 
    0.05174785f, -0.11058776f, 0.03832222f, -0.04108312f, -0.08114917f, -0.07544913f, -0.18209265f, 0.04941086f, 
    -0.00979956f, 0.04838533f, -0.05960441f, -0.01913178f, -0.01339143f, 0.05226962f, 0.04371148f, -0.04970178f, 
    -0.03369810f, 0.00162344f, -0.02849361f, 0.02008411f, 0.02763014f, -0.02623596f, -0.06756470f, 0.03758961f, 
    0.19826330f, -0.16277535f, -0.03724371f, 0.20643345f, 0.06547628f, 0.06138575f, 0.14763361f, -0.15774226f, 
    0.00853187f, -0.00906815f, -0.01902712f, 0.01878807f, -0.02710097f, -0.00449649f, -0.01898868f, 0.06948528f, 
    -0.01692351f, 0.10188353f, 0.09128179f, -0.05757819f, 0.58562630f, -0.36214411f, -0.20837525f, -0.15895210f, 
    -0.13588336f, 0.00721031f, -0.05023005f, -0.03526441f, -0.06618252f, -0.18640602f, 0.01825298f, -0.02640042f, 
    0.04825808f, -0.00523442f, -0.02326847f, 0.02856041f, -0.03590531f, 0.03567034f, -0.00367120f, -0.04468222f, 
    -0.09505177f, 0.13146125f, 0.10612912f, -0.01772373f, 0.03639897f, -0.05839640f, 0.04959058f, -0.03208861f, 
    -0.02513020f, 0.03450374f, 0.05269440f, 0.01577681f, 0.04927489f, -0.01320954f, -0.00305936f, -0.04372213f, 
    -0.05672377f, -0.09019154f, 0.01362311f, 0.02024377f, -0.10493482f, 0.13051176f, 0.00438967f, -0.04860155f, 
    -0.12678620f, -0.02176914f, 0.06085903f, -0.02800033f, -0.04013224f, 0.00360509f, 0.02148785f, 0.02156379f, 
    0.02932359f, 0.01963945f, -0.02612927f, 0.05670325f, 0.05266206f, -0.02236662f, -0.06421745f, -0.12016027f, 
    0.11031542f, 0.04089715f, -0.04971928f, -0.01610535f, -0.07774994f, -0.03292550f, -0.09797528f, -0.09968794f, 
    -0.09794325f, -0.14879374f, -0.06244948f, -0.00355856f, 0.04839855f, -0.01811854f, -0.03558931f, -0.00612798f, 
    0.06522050f, 0.10492658f, 0.12019465f, 0.07130487f, -0.09766187f, -0.05828806f, 0.03361804f, -0.02106906f, 
    -0.02278608f, -0.02596230f, 0.00856441f, 0.00529159f, 0.01839270f, 0.00950258f, 0.03425934f, 0.04572084f, 
    0.02841820f, 0.04762391f, 0.04917292f, 0.02341923f, 0.04840440f, -0.01775490f, 0.02003650f, 0.09146944f, 
    -0.57581705f, 0.07905868f, 0.19305982f, 0.07264422f, -0.12011414f, -0.03516598f, -0.09565524f, -0.04595811f, 
    -0.04883710f, -0.04812294f, -0.02257179f, -0.06621314f, -0.03983203f, -0.08256634f, -0.08042554f, -0.14102344f, 
    -0.11532267f, -0.09579258f, -0.17563590f, -0.07123535f, -0.12909135f, -0.41355410f, -0.48018146f, -0.29699966f, 
    -0.04596407f, -0.00448958f, -0.01436104f, -0.01174326f, 0.09131148f, 0.09613717f, -0.03002729f, -0.00617167f, 
    -0.00503336f, 0.00124060f, -0.00345067f, 0.03949994f, 0.02378567f, 0.00927876f, -0.00357034f, 0.07363995f, 
    0.37028378f, -0.08358242f, -0.09471700f, -0.17370972f, -0.03153680f, 0.07481773f, 0.01824753f, -0.06997731f, 
    -0.04664104f, -0.05476854f, -0.05334910f, 0.03898666f, 0.23755322f, 0.00375881f, -0.00339181f, -0.00428863f, 
    0.04252547f, 0.01825444f, 0.15203434f, 0.01458278f, -0.07952847f, 0.00848452f, 0.11156941f, -0.08760639f, 
    -0.12338687f, 0.06107356f, -0.17302448f, 0.04866601f, 0.03903665f, -0.20082542f, -0.09590764f, 0.03112019f, 
    -0.03782856f, -0.08609545f, 0.03213985f, -0.00176220f, 0.04247856f, -0.05048966f, -0.02765357f, 0.05742246f, 
    0.06191884f, 0.10452297f, 0.11443986f, -0.00320203f, -0.11680856f, -0.05865759f, -0.04634560f, -0.12368457f, 
    0.06972425f, -0.05077796f, 0.03926091f, -0.02457209f, 0.11594307f, -0.00881049f, 0.02152293f, -0.08710745f, 
    0.02818447f, -0.01132858f, -0.02786930f, -0.05212800f, 0.03326311f, 0.00693026f, -0.00624620f, -0.05659601f, 
    -0.08797316f, -0.08551665f, 0.02921483f, 0.00351943f, 0.00267769f, -0.05903275f, -0.00663725f, 0.04620207f, 
    0.06061566f, 0.09174594f, 0.08377736f, 0.01959374f, 0.02794570f, -0.01610119f, 0.07528864f, 0.01356859f, 
    -0.20995809f, -0.22135167f, 0.17694996f, 0.14040226f, 0.18523169f, 0.03655455f, -0.09536295f, 0.04872030f, 
    -0.04708337f, -0.08994249f, 0.04547944f, -0.06272459f, 0.06557813f, -0.00173432f, 0.00234784f, -0.23914953f, 
    -0.02095904f, -0.13529775f, -0.23058215f, -0.13521805f, 0.13898517f, -0.29161820f, 0.07913036f, 0.08268571f, 
    -0.09352158f, 0.13647398f, -0.03450224f, -0.08864237f, -0.01412050f, 0.01612309f, 0.01969596f, -0.00321751f, 
    -0.02590317f, 0.01692988f, -0.00037015f, 0.11919440f, 0.05707995f, 0.04865388f, -0.07822701f, 0.06006518f, 
    0.51243818f, 0.09283966f, 0.00283365f, -0.22850592f, 0.02196286f, 0.13014513f, -0.05132402f, 0.01674867f, 
    -0.01367169f, -0.20666207f, 0.02141516f, 0.05129342f, 0.07109478f, 0.04869617f, 0.04400964f, 0.05235124f, 
    0.01563074f, 0.04935053f, 0.10486866f, -0.03495120f, 0.01435381f, 0.06544399f, 0.01392835f, -0.05830832f, 
    -0.13541277f, -0.06420958f, 0.02656111f, -0.00881525f, 0.03529515f, 0.03733465f, 0.02106238f, 0.06612469f, 
    0.04748384f, 0.06757723f, 0.03094612f, 0.05097577f, 0.01395627f, -0.00710465f, 0.00201934f, -0.03266199f, 
    0.00944400f, -0.31037989f, -0.44317943f, -0.16451998f, 0.09932003f, -0.01772797f, -0.14142680f, 0.14685377f, 
    -0.04670793f, -0.09629652f, -0.00375068f, -0.04695726f, 0.00085086f, 0.00796035f, 0.08614079f, 0.00973276f, 
    -0.00078983f, -0.00139601f, -0.00360316f, -0.11592231f, 0.11422107f, 0.04120863f, 0.05057159f, 0.00130631f, 
    -0.03653685f, -0.01550176f, -0.02613946f, -0.05704561f, -0.02979259f, 0.07535199f, 0.07778843f, 0.00348409f, 
    0.00470940f, 0.03312466f, -0.01420533f, -0.08772173f, 0.09553444f, -0.02484150f, -0.10393796f, -0.05478175f, 
    0.42042115f, -0.16657719f, 0.09669682f, -0.00491776f, -0.15199377f, 0.04603381f, -0.16073532f, -0.11634729f, 
    0.01730063f, -0.06211919f, 0.01405551f, -0.02100193f, -0.00113652f, 0.00449209f, -0.02410649f, -0.03495231f, 
    0.03494358f, -0.05264780f, -0.26206324f, -0.32098418f, 0.21389581f, 0.03436026f, 0.01218406f, -0.11435089f, 
    -0.05946134f, 0.07687131f, 0.02268075f, 0.01335319f, -0.04296168f, -0.18118130f, -0.02927375f, 0.07991593f, 
    0.02176274f, 0.01257586f, 0.02546660f, 0.01060620f, 0.05923654f, 0.11528009f, 0.12035272f, -0.10342339f, 
    -0.11018647f, -0.17422397f, -0.23922828f, -0.07840519f, -0.05300641f, -0.08573766f, -0.00705939f, 0.07920696f, 
    0.06013284f, 0.11261099f, 0.09339379f, -0.06325532f, 0.00149297f, -0.04688459f, -0.06249413f, -0.01872294f, 
    0.01322133f, 0.03064716f, 0.02917600f, 0.01196965f, -0.02680155f, -0.07059430f, -0.07282259f, 0.03669208f, 
    -0.15422344f, -0.09016769f, 0.00647500f, 0.03537161f, -0.03888032f, 0.01063433f, 0.04056069f, 0.05564380f, 
    -0.08004754f, -0.03148203f, 0.02655823f, 0.02468024f, 0.17062026f, 0.09399203f, 0.12277537f, 0.05573514f, 
    -0.03645748f, 0.19386452f, 0.10739271f, 0.05244841f, -0.09950450f, -0.00363793f, -0.06261665f, -0.02215922f, 
    -0.02205523f, -0.04877793f, -0.03943752f, -0.02971316f, 0.03876711f, -0.05859937f, -0.04272312f, -0.05504160f, 
    0.08076274f, 0.01226667f, 0.01595055f, -0.03362019f, 0.28501552f, -0.10953166f, -0.13149470f, -0.23158161f, 
    0.00423331f, 0.02921407f, -0.13045555f, -0.01629065f, -0.01571206f, 0.21484639f, -0.02300483f, 0.08985434f, 
    0.01567218f, -0.01854784f, 0.06709588f, 0.02157527f, 0.07923519f, -0.00057260f, 0.01709723f, 0.14728208f, 
    0.37690648f, -0.09969935f, -0.16524272f, -0.11137607f, -0.18001448f, -0.03212125f, -0.22530155f, -0.07931779f, 
    -0.04360687f, -0.12160999f, -0.00415988f, -0.00474614f, 0.00884474f, -0.01528146f, -0.00221201f, 0.03280166f, 
    0.04705533f, 0.04407322f, -0.23909567f, -0.27181214f, -0.45143396f, -0.19557564f, 0.05547273f, 0.06637367f, 
    0.31989476f, 0.10246429f, 0.08266191f, 0.03279113f, -0.00925447f, -0.05888176f, 0.01254911f, 0.00147223f, 
    0.08515549f, 0.03538042f, -0.02616697f, -0.05624738f, -0.14338379f, 0.00808639f, 0.03303569f, 0.05325549f, 
    -0.13139267f, -0.26424924f, -0.70448875f, -0.34126392f, 0.02081809f, -0.14622943f, 0.05060222f, 0.16293322f, 
    0.21685904f, -0.00140011f, 0.06023370f, -0.07455184f, -0.03409677f, -0.01368563f, 0.00045287f, 0.00080481f, 
    -0.01674408f, 0.01410034f, -0.03336417f, -0.02856694f, -0.07992474f, -0.03478660f, 0.01510106f, 0.00706414f, 
    -0.10707808f, -0.00550171f, -0.02944787f, 0.00060750f, 0.03594157f, -0.00525935f, -0.00680079f, 0.04640752f, 
    0.00376982f, 0.02177894f, 0.07503951f, 0.04154475f, 0.10134503f, 0.06753298f, 0.02862370f, 0.10197721f, 
    -0.16404742f, -0.47082534f, 0.01162041f, -0.00407643f, 0.12641990f, -0.04048818f, 0.06350650f, 0.09923615f, 
    0.03356664f, 0.05350173f, 0.06381228f, 0.02826061f, 0.00952402f, 0.08175688f, -0.05573730f, -0.04517652f, 
    0.02996398f, -0.03407497f, 0.03699849f, -0.04229759f, 0.05220942f, 0.05188688f, -0.00726532f, -0.04972981f, 
    -0.21131015f, -0.06492538f, 0.12394345f, -0.01559993f, 0.03893643f, -0.05990798f, 0.08339266f, 0.02374382f, 
    -0.01348166f, 0.09400713f, 0.10911739f, 0.00122043f, 0.14712253f, -0.01292580f, 0.07465469f, -0.04205165f, 
    0.03920492f, -0.22420052f, -0.25463432f, -0.08831263f, -0.02953201f, 0.01542109f, 0.02408998f, 0.04866350f, 
    0.06836493f, 0.19944297f, 0.01536934f, -0.01917249f, -0.06971759f, -0.08414219f, -0.02356720f, 0.00127535f, 
    0.03676387f, 0.00981122f, -0.00389781f, 0.03598313f, -0.01262924f, -0.15606289f, -0.07613913f, 0.03768965f, 
    0.01980458f, -0.02017057f, -0.06557701f, -0.14516860f, -0.01237281f, -0.02482021f, 0.00281348f, 0.12483682f, 
    0.00528680f, -0.00717968f, -0.01448456f, 0.01278347f, 0.07856937f, 0.11265829f, 0.05856503f, 0.12618035f, 
    0.27989465f, 0.18363516f, -0.10025073f, -0.06910960f, 0.05862702f, 0.10379041f, -0.12362323f, -0.00991731f, 
    0.08656929f, 0.03435230f, 0.05951458f, 0.03044381f, 0.00875742f, 0.05713595f, 0.06065045f, 0.01040434f, 
    0.04189929f, 0.01158604f, -0.21335840f, -0.31258768f, 0.57244521f, 0.30283895f, 0.14393070f, -0.05390375f, 
    -0.13381332f, -0.01076912f, -0.00949390f, -0.03950753f, 0.03841651f, -0.14430876f, -0.01631942f, -0.02851567f, 
    0.01153679f, -0.04914942f, -0.00663239f, -0.00170028f, -0.09452333f, -0.16265532f, 0.03601784f, -0.03957054f, 
    -0.19162941f, -0.26934034f, -0.37448615f, -0.33128339f, -0.02213491f, -0.00947277f, -0.03898720f, 0.06079854f, 
    0.04014520f, -0.12877478f, -0.02881822f, -0.01924194f, -0.02756630f, -0.02684559f, 0.01760929f, 0.03138575f, 
    -0.01362574f, -0.00410109f, 0.06376284f, 0.02629206f, -0.07743146f, -0.08010880f, -0.08479631f, -0.00791980f, 
    -0.09839460f, -0.07560381f, -0.06874281f, -0.00519914f, 0.01065045f, -0.02046668f, 0.05708176f, 0.07495884f, 
    0.07683030f, -0.00622310f, 0.03297941f, -0.05916556f, 0.04947401f, 0.01931880f, 0.08879247f, 0.09690889f, 
    -0.27430946f, -0.15399103f, -0.02410073f, 0.07758728f, 0.05107693f, 0.00722186f, -0.05798058f, 0.03224102f, 
    0.04618517f, -0.03677065f, 0.03578153f, 0.03349251f, 0.06594191f, 0.07166842f, 0.10068472f, -0.08677849f, 
    0.02411962f, 0.04036577f, -0.00793148f, 0.10075201f, -0.29006168f, -0.35238275f, -0.43473163f, -0.28492910f, 
    -0.15847941f, -0.06610680f, 0.02817772f, 0.09924093f, 0.01285212f, 0.00102476f, -0.02951641f, -0.03996316f, 
    -0.01734895f, 0.01453993f, -0.00593152f, 0.00786604f, 0.01377723f, 0.02241824f, 0.03402727f, 0.01986002f, 
    0.28463587f, -0.36441919f, -0.21512018f, 0.10473298f, 0.17421690f, -0.01884126f, 0.10450150f, 0.07230534f, 
    0.16198036f, 0.13148198f, 0.07413787f, -0.05039064f, 0.00940040f, 0.03931859f, -0.02239687f, -0.07735920f, 
    -0.23686551f, 0.02701364f, -0.14530565f, -0.27239013f, -0.67019320f, -0.52165002f, 0.03663902f, 0.18004641f, 
    0.18816245f, 0.06617211f, 0.16628419f, -0.08329834f, -0.04488555f, 0.03708488f, 0.00990943f, -0.00007684f, 
    0.04704164f, 0.07872913f, 0.01783373f, 0.00903196f, -0.01304430f, -0.14474724f, 0.05219099f, -0.02016256f, 
    -0.09329849f, -0.87418950f, -0.41596657f, -0.09795751f, 0.17110184f, 0.03777080f, 0.17141505f, 0.22961976f, 
    0.07265709f, 0.15505259f, 0.03974745f, -0.00908539f, -0.05971804f, 0.07944701f, -0.08325422f, -0.03683746f, 
    0.07680038f, -0.05873669f, -0.02133707f, 0.00953587f, -0.09021832f, -0.16030183f, -0.11276992f, -0.04797272f, 
    -0.02706187f, -0.06436227f, 0.01390611f, 0.06225814f, 0.08230765f, 0.07708590f, 0.04135218f, -0.02765615f, 
    -0.03488552f, -0.10266043f, -0.04994932f, -0.02067171f, 0.04088255f, 0.05550094f, 0.06669477f, 0.00781243f, 
    -0.16762112f, 0.04762050f, 0.11974487f, 0.01808398f, -0.09998489f, -0.05049652f, -0.02038044f, -0.03429630f, 
    0.00856597f, -0.00809977f, 0.02427849f, 0.03141838f, 0.00365068f, 0.05413117f, 0.05622918f, 0.01093010f, 
    0.06823010f, 0.03303288f, -0.01528631f, 0.02419714f, 0.46841359f, 0.19786710f, 0.00921387f, -0.05083413f, 
    -0.10198357f, 0.12747045f, 0.05170368f, 0.13031913f, 0.08060348f, -0.06271855f, 0.03012433f, -0.06737901f, 
    0.06636662f, 0.04820096f, -0.04665543f, 0.03083217f, 0.04251842f, -0.03964758f, 0.08720731f, -0.09585913f, 
    -0.18799940f, -0.21792518f, 0.08677549f, 0.01634609f, 0.02506178f, -0.12070413f, 0.05723607f, 0.06624438f, 
    0.06005302f, 0.03072839f, 0.07123122f, 0.02719862f, 0.08008824f, -0.04549585f, -0.02734390f, -0.02222564f, 
    0.00567597f, -0.00722912f, 0.02790003f, -0.00561528f, -0.01974699f, -0.01754873f, 0.00294128f, 0.00213211f, 
    -0.09124816f, -0.02435849f, 0.05291592f, 0.02054215f, 0.03809949f, -0.00495302f, 0.10024817f, 0.03168288f, 
    0.01498259f, 0.03727197f, 0.03257121f, -0.01129517f, 0.04181864f, -0.02107009f, 0.10692114f, 0.03244720f, 
    -0.28406417f, -0.00641685f, 0.09478686f, -0.02622597f, -0.14274482f, -0.09990734f, -0.02747074f, -0.02967102f, 
    -0.00509201f, -0.00464196f, -0.07471675f, -0.02633154f, -0.04989010f, -0.01184152f, -0.01523925f, 0.04426300f, 
    0.09133586f, 0.02040517f, 0.03837962f, -0.01274947f, 0.04624939f, -0.06786992f, -0.18604246f, -0.07087787f, 
    -0.06992888f, -0.06836912f, -0.01702226f, -0.01404169f, 0.01365249f, 0.00887386f, -0.00568059f, -0.04834700f, 
    0.00272278f, -0.04958131f, -0.01486127f, -0.01937750f, 0.03948551f, 0.00479320f, 0.05775461f, 0.03980548f, 
    -0.09225803f, 0.00972778f, 0.04297048f, -0.01568647f, -0.04646617f, 0.01463278f, 0.15555094f, 0.06963497f, 
    0.07271961f, -0.01652571f, 0.03174646f, 0.10527501f, -0.02070068f, -0.00120948f, 0.11651104f, -0.03504628f, 
    0.18763803f, -0.08001749f, 0.15977134f, -0.06098659f, 0.05370032f, 0.04011350f, -0.01853753f, -0.00786164f, 
    -0.13320810f, -0.07228397f, -0.13570862f, -0.11624827f, -0.03476043f, -0.08490136f, -0.05110007f, 0.01755059f, 
    0.03528174f, -0.00548986f, 0.02874100f, -0.03519016f, 0.08634929f, 0.06415531f, 0.03303454f, 0.05130612f, 
    -0.18549307f, -0.07157352f, 0.03023342f, -0.00245655f, -0.06636391f, -0.02988029f, -0.04056529f, -0.00302098f, 
    -0.00929037f, 0.00677394f, 0.00468325f, 0.06011096f, 0.03569950f, 0.09858800f, 0.07979831f, -0.00869347f, 
    0.02323773f, 0.04579718f, 0.00626962f, 0.07826968f, -0.03215928f, 0.01702935f, -0.65359849f, -0.22169018f, 
    -0.06158229f, 0.12651740f, -0.14035620f, 0.21200134f, 0.12822337f, -0.00744833f, 0.00013249f, 0.00957861f, 
    -0.00879354f, 0.00116544f, 0.10991072f, 0.05446072f, 0.00804542f, 0.02207663f, -0.02424589f, 0.06851640f, 
    0.30631277f, -0.42155579f, -0.42107198f, -0.06176108f, -0.14061767f, -0.09593426f, -0.20542140f, -0.04569466f, 
    -0.02674536f, -0.20549992f, 0.02363156f, 0.00477801f, 0.02039245f, -0.00566809f, 0.04117573f, 0.06148334f, 
    0.01247724f, 0.00791203f, -0.12113340f, 0.03962616f, 0.17192018f, 0.00369411f, 0.20224722f, 0.08126083f, 
    -0.14276102f, 0.07121886f, 0.05634064f, -0.16942391f, -0.11000790f, -0.15092859f, -0.04706375f, -0.01698623f, 
    0.02069058f, -0.01267061f, -0.03580041f, 0.06267031f, 0.02458065f, -0.11501448f, -0.16250437f, -0.38009405f, 
    -0.28942153f, -0.22381449f, 0.13315293f, -0.03619356f, 0.10539858f, -0.07925154f, 0.03283344f, -0.04774213f, 
    -0.04299365f, -0.04045414f, -0.02669576f, 0.09308805f, 0.02353366f, 0.09378344f, 0.06512845f, -0.02019751f, 
    -0.02359383f, -0.04995201f, 0.01955191f, -0.06440776f, 0.36550093f, 0.25660232f, -0.12151545f, -0.20987958f, 
    -0.06145972f, -0.04851491f, 0.13653690f, -0.02481616f, 0.11381034f, -0.02717425f, 0.00503682f, 0.06704976f, 
    0.03900085f, -0.07379892f, -0.01457173f, 0.06389119f, 0.05594800f, -0.05020644f, -0.00285054f, 0.02942612f, 
    0.12481770f, 0.17461407f, -0.23612371f, -0.10788724f, 0.00484738f, 0.08415123f, 0.06352013f, 0.06544544f, 
    0.05593723f, 0.00970902f, 0.02233808f, -0.01557712f, -0.05487614f, 0.00306222f, 0.05355197f, 0.09887859f, 
    0.02447052f, 0.00023066f, 0.07408406f, -0.10469644f, 0.35374916f, 0.05218637f, -0.09232834f, -0.11982413f, 
    -0.09456977f, 0.05072952f, -0.07098372f, 0.07581564f, 0.06141236f, 0.02010573f, 0.01392180f, 0.04423922f, 
    0.03009030f, 0.00498142f, 0.02743091f, -0.01533827f, 0.05647449f, -0.02734225f, 0.11084858f, 0.05636854f, 
    -0.36886862f, 0.04128220f, 0.06382544f, 0.07898252f, 0.06268127f, -0.00530430f, -0.01871317f, -0.00183751f, 
    0.04470750f, -0.02157707f, 0.01403555f, -0.00015131f, 0.04442409f, 0.00771248f, -0.06997896f, -0.00600396f, 
    -0.03423956f, 0.00733920f, 0.05606372f, 0.03267467f, -0.15842476f, -0.30781287f, -0.18006293f, -0.21833611f, 
    -0.17262515f, -0.11360798f, -0.13976945f, -0.08142040f, -0.17580138f, -0.35980466f, -0.00100566f, -0.03429350f, 
    0.00166399f, 0.02736233f, 0.03365173f, 0.07918083f, 0.01130521f, 0.13371393f, 0.02638428f, -0.19046080f, 
    0.26851192f, -0.51227164f, -0.46229798f, -0.03745611f, -0.15654366f, -0.05698572f, -0.09108347f, 0.15140112f, 
    0.07457633f, -0.06252792f, -0.02496485f, -0.01666771f, 0.01724107f, 0.01555679f, 0.02375286f, 0.01107473f, 
    0.05865983f, 0.09738805f, -0.04258533f, -0.01029977f, -0.00955439f, -0.18410832f, -0.21193741f, -0.05183599f, 
    0.04693090f, -0.01364113f, -0.02638035f, 0.02804648f, 0.04605386f, 0.14071403f, -0.03361057f, 0.02878775f, 
    0.00312631f, -0.03342333f, -0.03897590f, -0.06219564f, 0.01509875f, 0.08570029f, 0.00831747f, 0.07440686f, 
    0.50062251f, -0.02528944f, -0.15254688f, -0.02853293f, -0.24171714f, -0.00458875f, -0.12791330f, -0.08638392f, 
    0.04598834f, -0.05656488f, 0.01774590f, -0.04000428f, 0.08581369f, -0.03022134f, 0.04264188f, -0.02242794f, 
    0.05549271f, 0.08453808f, 0.05202789f, 0.06909543f, 0.04649434f, -0.06024267f, -0.06217511f, 0.03003700f, 
    0.06823042f, -0.01865519f, 0.02109313f, 0.01692245f, 0.02975094f, -0.08560087f, 0.00004558f, 0.05403599f, 
    0.10027763f, 0.02234505f, -0.07189642f, -0.01690940f, 0.01800652f, 0.08354433f, 0.06394286f, 0.06352759f, 
    0.37362158f, 0.14207260f, -0.12177804f, -0.07311879f, 0.00656852f, 0.13104835f, -0.15611425f, 0.12292488f, 
    0.04460742f, -0.05573436f, -0.00003702f, 0.05663828f, 0.05836136f, 0.06627822f, 0.04381897f, 0.01897785f, 
    -0.07610179f, -0.07537206f, 0.09180394f, -0.16183525f, 0.11023673f, -0.21199265f, -0.25068432f, -0.12824319f, 
    -0.06051134f, -0.04992108f, -0.00204058f, 0.08089824f, -0.01248959f, 0.17157449f, -0.09310672f, -0.02046151f, 
    -0.03588176f, -0.04317325f, -0.03796434f, 0.01366701f, 0.02544712f, 0.04009415f, 0.02197888f, 0.01602006f, 
    -0.25637013f, -0.00109557f, 0.01417887f, 0.13943946f, 0.12017449f, 0.01112014f, -0.00213135f, 0.01854778f, 
    0.06317290f, -0.09061209f, -0.02680858f, -0.00823892f, 0.03169568f, -0.07159297f, -0.01218254f, -0.05721565f, 
    -0.09925659f, 0.01216211f, -0.00284298f, 0.06601997f, -0.39309070f, 0.15274139f, 0.17398775f, 0.14443257f, 
    -0.07098200f, -0.01534908f, -0.07610677f, -0.07051691f, -0.07113873f, -0.08599123f, -0.04022969f, -0.05320463f, 
    -0.01836757f, -0.04319047f, -0.05489604f, -0.06238806f, -0.06396679f, -0.06835926f, -0.17221335f, -0.14482071f, 
    -0.14526628f, 0.29550681f, -0.38400754f, 0.04060851f, -0.04728936f, 0.07730090f, -0.02092759f, 0.12019900f, 
    0.06130212f, -0.04513699f, 0.09086211f, -0.02621572f, -0.12439638f, -0.15696833f, -0.08380301f, 0.06020487f, 
    -0.02206533f, -0.12972797f, 0.02029535f, -0.11411041f, -0.07109956f, 0.13522176f, 0.04083875f, -0.02634281f, 
    0.05512685f, 0.05968358f, -0.01334046f, -0.02552669f, -0.05172114f, -0.03671495f, 0.02972032f, 0.05760451f, 
    -0.03258252f, -0.01668153f, -0.06237538f, 0.04282885f, 0.03024144f, -0.11604957f, -0.00123363f, -0.01419093f, 
    -0.04154018f, -0.18503614f, -0.23184539f, -0.02213815f, 0.08488475f, 0.03169235f, 0.04851120f, 0.13574986f, 
    -0.01125456f, 0.06425864f, -0.03554259f, -0.02999525f, 0.00938325f, 0.01578797f, 0.01819139f, -0.00380871f, 
    0.09089631f, -0.00344688f, 0.01633184f, 0.06713834f, -0.14748105f, -0.04562142f, 0.40369365f, 0.14636143f, 
    -0.25212967f, 0.14812382f, -0.19401336f, 0.09229965f, 0.08584071f, 0.14185575f, 0.04685748f, 0.01569978f, 
    0.03266184f, 0.03608875f, 0.00573958f, 0.00717213f, -0.00651708f, 0.03996533f, -0.01342491f, -0.02147011f, 
    -0.14835180f, 0.00750630f, -0.21107143f, 0.12402961f, -0.10209804f, -0.12401586f, -0.11328197f, 0.07390468f, 
    -0.11311979f, -0.07813221f, 0.06569853f, -0.04258515f, -0.00936941f, -0.06987340f, -0.01219726f, 0.04212765f, 
    -0.03481714f, -0.11715591f, 0.06743249f, -0.10343939f, 0.23506150f, -0.23691006f, -0.12725402f, 0.22501096f, 
    -0.15705357f, 0.01532767f, 0.27309251f, 0.22454304f, -0.14898951f, 0.17899631f, -0.00136055f, -0.03074393f, 
    -0.14094010f, -0.01922735f, -0.06341172f, -0.03831797f, 0.06109395f, -0.01070214f, -0.10800536f, -0.08163503f, 
    -0.17985481f, 0.01435459f, 0.07170769f, 0.32309276f, 0.11696281f, -0.06132130f, 0.11901668f, -0.17596006f, 
    0.10305128f, -0.11814318f, 0.07238965f, -0.06854608f, 0.11582789f, -0.12420268f, 0.01967296f, 0.16836686f, 
    0.04727576f, -0.08734768f, 0.00278197f, 0.14406054f, -0.16784529f, 0.07218272f, -0.01302030f, 0.17409140f, 
    0.17579648f, -0.02769995f, 0.10877039f, 0.02908908f, -0.08632261f, -0.10413239f, 0.04837104f, 0.09715720f, 
    0.03436914f, -0.15402347f, 0.01722114f, 0.03263831f, 0.02657289f, -0.09351962f, -0.00875503f, 0.03852058f, 
    0.20726949f, -0.70332187f, -0.18103878f, -0.18693808f, 0.06341357f, -0.13960503f, -0.00275187f, 0.09064550f, 
    0.11860830f, 0.11796287f, -0.08916958f, 0.03388211f, -0.00173227f, -0.07343783f, -0.06856629f, 0.05650698f, 
    0.12239560f, 0.19540615f, -0.02141489f, 0.10491655f, 0.14829725f, -0.40063590f, -0.09850141f, -0.03752156f, 
    -0.05117140f, 0.15452401f, 0.00108648f, 0.03970449f, -0.15508333f, 0.04843453f, 0.01729499f, -0.09277488f, 
    -0.07843623f, 0.00467629f, -0.04110207f, -0.02849971f, -0.03300712f, 0.07999009f, -0.13326164f, -0.00017985f, 
    -0.15266833f, 0.19503665f, -0.55471027f, 0.15114650f, -0.13438711f, -0.02198045f, 0.00295935f, 0.06952371f, 
    -0.19761400f, 0.13924854f, 0.02927526f, -0.03935840f, 0.00532642f, 0.02822939f, -0.05542170f, 0.01559316f, 
    -0.00324633f, -0.03782002f, 0.02015404f, -0.02101259f, -0.15273793f, 0.08025751f, 0.06873263f, 0.19795252f, 
    0.09692176f, 0.06145243f, -0.02408084f, -0.03626790f, 0.06672062f, -0.25655189f, 0.07831641f, 0.13302907f, 
    0.01628768f, -0.08821208f, -0.08861614f, 0.04689251f, 0.00983564f, -0.08207393f, -0.09587862f, 0.05647928f, 
    0.23259707f, -0.51126474f, -0.09756229f, -0.15277810f, -0.24057943f, -0.49528259f, 0.08840147f, -0.06140001f, 
    0.13383904f, 0.02705566f, 0.05957827f, 0.01306665f, 0.03150780f, 0.01921887f, -0.02196769f, 0.01628467f, 
    0.06643783f, 0.16742565f, -0.04686331f, -0.01403420f, -0.14335907f, -0.02497588f, 0.00103433f, -0.05637855f, 
    0.07437661f, 0.03301786f, 0.01020869f, -0.06690068f, -0.04795983f, -0.15324819f, -0.03448249f, 0.00714748f, 
    0.07954592f, -0.04335771f, 0.01352943f, 0.13237157f, 0.03748885f, -0.12000271f, -0.03184837f, 0.02783744f, 
    0.40342844f, -0.59066755f, -0.37099516f, -0.03158072f, -0.00488581f, 0.05027699f, -0.08646972f, -0.01677348f, 
    -0.00872229f, 0.05859882f, -0.00575671f, 0.00772545f, 0.04997034f, 0.03534512f, -0.04141476f, -0.05121185f, 
    0.00852321f, -0.01309665f, 0.05116783f, 0.15004478f, 0.01515467f, 0.16506582f, -0.19140807f, 0.00089118f, 
    -0.09824003f, -0.05475907f, 0.02612832f, 0.08545294f, -0.05440395f, 0.16339578f, -0.03498071f, -0.01889448f, 
    -0.04132113f, -0.00683908f, -0.09597395f, 0.01269656f, 0.06075100f, -0.01344086f, 0.02952880f, -0.00513315f, 
    0.09704164f, 0.03441536f, 0.10182162f, 0.30348697f, -0.16994284f, -0.05868620f, 0.07954393f, -0.31215563f, 
    -0.14036512f, -0.25903645f, 0.03946147f, -0.05749488f, 0.02397988f, 0.12346350f, 0.05779441f, 0.02740569f, 
    0.01171677f, 0.02030282f, 0.02427236f, -0.01241226f, -0.02284159f, 0.16122770f, -0.05616736f, -0.07685939f, 
    0.01076177f, -0.08024390f, 0.15909836f, -0.05861336f, -0.03360089f, 0.02019442f, -0.06911778f, -0.04814853f, 
    0.02313110f, 0.02837623f, 0.02844542f, 0.02611581f, -0.05065170f, -0.08840422f, -0.16871782f, -0.07872818f, 
    -0.13454671f, -0.09553003f, -0.41666800f, 0.07625980f, 0.13925664f, -0.04386649f, 0.17687327f, 0.12831274f, 
    0.05262927f, 0.02923414f, 0.04786086f, -0.01761148f, -0.00383697f, 0.00072925f, -0.02373589f, 0.03986157f, 
    0.07262266f, -0.12422921f, -0.00331603f, 0.03278935f, -0.20228167f, -0.16991179f, -0.17056324f, -0.08458728f, 
    -0.12471259f, -0.36638230f, 0.18271536f, 0.11544105f, -0.11778376f, 0.03884385f, 0.03881928f, 0.02560392f, 
    0.05846944f, -0.03738641f, -0.04697590f, 0.10509256f, -0.06218956f, -0.06703463f, -0.05500761f, -0.17986873f, 
    0.05404252f, -0.34832636f, -0.23723474f, -0.04765441f, -0.04668926f, 0.13971975f, -0.24349475f, 0.00210991f, 
    -0.12093145f, 0.03298986f, 0.04479097f, 0.00213985f, 0.06612403f, 0.00701435f, -0.03994774f, -0.00877727f, 
    -0.00262449f, 0.04866493f, 0.08393829f, 0.21465206f, -0.20751837f, 0.28942615f, 0.01416864f, -0.68248665f, 
    -0.03809825f, -0.10829853f, -0.07113954f, 0.04208604f, -0.06040686f, 0.19269408f, 0.02849350f, 0.05607661f, 
    -0.09839619f, -0.07082487f, -0.04517923f, 0.01094511f, 0.14364448f, -0.05755940f, 0.02960435f, 0.00289836f, 
    -0.19503278f, 0.22277841f, -0.01554305f, 0.62805021f, -0.62652582f, -0.10238808f, 0.18355735f, -0.40569279f, 
    0.03307698f, -0.16326055f, 0.10980593f, -0.09901532f, 0.09459180f, 0.14561622f, 0.09841540f, 0.07714043f, 
    0.06907227f, 0.00571961f, 0.03677940f, 0.06879312f, -0.05797372f, -0.00928374f, -0.07284165f, -0.09381858f, 
    0.06987412f, 0.06611496f, -0.03421550f, 0.10961738f, -0.03365376f, -0.07306942f, 0.00899014f, -0.01318576f, 
    -0.00300536f, -0.02811692f, -0.03168167f, 0.05483801f, -0.08886921f, -0.04575083f, -0.06978678f, 0.01684126f, 
    0.06441271f, -0.06372609f, 0.29652098f, 0.03665299f, -0.23817667f, 0.07266689f, -0.19044504f, -0.12554809f, 
    0.10567783f, -0.13421968f, 0.00695572f, 0.04039310f, 0.00537488f, 0.14527737f, 0.00300164f, 0.04749693f, 
    0.02333067f, 0.06251106f, 0.00533164f, 0.08235537f, -0.40228784f, 0.00781962f, -0.03230017f, -0.03288487f, 
    0.13850544f, 0.04348819f, 0.05871725f, -0.12752444f, 0.03163100f, -0.07533774f, 0.02473597f, 0.08108191f, 
    -0.06724826f, -0.05119870f, 0.05742574f, 0.19809352f, -0.06288084f, -0.06692968f, -0.06485877f, -0.10544781f, 
    0.06727026f, 0.06963094f, 0.05488883f, -0.09242991f, -0.07997305f, -0.10732155f, 0.03027837f, -0.25755718f, 
    -0.18067572f, -0.10776345f, 0.04392587f, -0.04005238f, 0.07108402f, 0.01146581f, 0.02194189f, 0.02943827f, 
    -0.05457622f, 0.05051326f, -0.02882666f, -0.11537796f, 0.10152841f, 0.22987850f, 0.41155794f, -0.09986360f, 
    -0.24561141f, -0.01820750f, -0.09714859f, 0.04068965f, 0.02349299f, 0.08730707f, -0.06742060f, -0.04052893f, 
    0.03741317f, -0.00870768f, 0.01331459f, 0.01566928f, -0.00108799f, 0.01986307f, -0.10423076f, -0.18783130f, 
    -0.19119406f, -0.14108117f, -0.04390255f, 0.12076133f, -0.02524749f, -0.12482562f, 0.10659170f, -0.14672764f, 
    0.08441931f, -0.03158373f, 0.03240749f, -0.04471866f, 0.13059247f, 0.11372860f, -0.00036256f, 0.00575320f, 
    0.09045237f, -0.04976173f, 0.02640056f, 0.01767457f, -0.53240949f, -0.00626871f, -0.92119563f, 0.14068748f, 
    0.03200588f, -0.02405873f, 0.04537603f, 0.10881553f, -0.08401801f, -0.00012416f, 0.03393026f, -0.03300775f, 
    0.06350541f, -0.01601702f, -0.06726824f, 0.04975345f, 0.03018311f, -0.03318413f, 0.09060062f, 0.14178813f, 
    -0.08933429f, -0.04928397f, 0.20310956f, 0.17092240f, -0.22820126f, -0.05156757f, -0.04516173f, 0.01490705f, 
    0.13671179f, 0.14836781f, 0.05332119f, -0.01055849f, 0.04190613f, 0.01139980f, -0.02002886f, -0.06818247f, 
    0.00280661f, 0.08950315f, 0.04421723f, 0.00405418f, 0.03994303f, -0.06342057f, 0.06753274f, 0.07869987f, 
    0.16828653f, -0.05661805f, 0.09201204f, -0.05827672f, -0.00924399f, -0.10063810f, -0.04712735f, 0.03805658f, 
    0.09418357f, -0.01882434f, 0.04497400f, 0.05100427f, 0.01194886f, -0.05222602f, -0.06322732f, -0.01227539f, 
    -0.13133539f, 0.26201111f, -0.15448284f, -0.07551225f, -0.25148550f, -0.09389304f, 0.02781665f, 0.05301228f, 
    -0.14018029f, 0.19548497f, -0.01531707f, 0.05893730f, -0.19537361f, -0.15058723f, 0.07671327f, 0.08709722f, 
    0.02866001f, 0.12136362f, -0.01880852f, -0.09650718f, -0.44793680f, -0.15147041f, 0.17598209f, 0.09657228f, 
    -0.26834011f, 0.13136044f, -0.17625891f, 0.00542362f, 0.05705217f, 0.14313228f, 0.00723994f, -0.06914431f, 
    0.01089464f, 0.01865024f, -0.08126456f, -0.00263193f, -0.01491246f, 0.01301311f, -0.06593762f, -0.06803656f, 
    -0.16554949f, -0.24064252f, -0.48295906f, 0.31388289f, -0.15395600f, 0.18681479f, -0.35336119f, 0.12784186f, 
    -0.05961395f, -0.16424195f, -0.05178552f, 0.04563882f, 0.02568126f, -0.00147684f, 0.21137632f, 0.06280361f, 
    0.00951418f, 0.05080622f, 0.12758434f, 0.20846157f, -0.36053786f, 0.31096217f, -0.18896016f, -0.84957463f, 
    0.00093890f, 0.06331890f, -0.16568789f, 0.02464330f, 0.00063906f, 0.09123103f, 0.03374418f, -0.04964355f, 
    -0.03938606f, 0.04478855f, 0.01786648f, -0.07208296f, -0.00920097f, -0.06967071f, -0.19008535f, 0.02093771f, 
    -0.13283995f, -0.55016351f, 0.52294707f, 0.01374943f, -0.82230765f, 0.18194529f, -0.48136255f, -0.11682551f, 
    0.17574394f, -0.06733500f, -0.12216640f, 0.08446677f, -0.01115999f, -0.02472593f, 0.12280623f, 0.04819101f, 
    -0.01412865f, -0.02768994f, -0.02530526f, 0.06235949f, 0.12387599f, 0.10138301f, 0.26667064f, 0.09406915f, 
    -0.07251655f, 0.12105221f, -0.01357534f, -0.17523296f, -0.08455359f, -0.01750125f, 0.05116616f, 0.05992428f, 
    0.08226357f, 0.03589842f, 0.04640239f, 0.00353587f, -0.06496824f, -0.04610895f, 0.01644668f, 0.05402279f, 
    -0.02885237f, -0.05848501f, 0.02819792f, -0.18479967f, 0.13080984f, 0.02039447f, 0.08812721f, 0.01150051f, 
    0.00197158f, -0.05827865f, 0.08671156f, 0.08293494f, 0.03070919f, 0.02431307f, -0.02313457f, 0.04155663f, 
    0.00247298f, -0.05576104f, -0.04464274f, 0.04022654f, -0.50450629f, 0.14380142f, -0.58368146f, 0.20778547f, 
    -0.14293709f, 0.03463832f, -0.11906974f, 0.06015135f, -0.04785866f, -0.05184608f, 0.03272688f, -0.02648673f, 
    0.01583487f, -0.05506503f, -0.08513967f, 0.02337173f, -0.08587640f, 0.02185421f, 0.05720497f, 0.10105708f, 
    0.20332354f, 0.19329521f, 0.17107615f, -0.05369508f, 0.02246915f, -0.05940894f, -0.14017694f, -0.15807377f, 
    0.07803593f, -0.12981661f, 0.00063586f, 0.06328869f, 0.03728817f, 0.14472850f, -0.00431852f, 0.06318936f, 
    0.04809496f, 0.00693552f, 0.00033012f, 0.06382804f, 0.02215147f, 0.12661566f, 0.08087724f, 0.02439698f, 
    0.09147261f, 0.09900389f, -0.02900336f, -0.07335632f, -0.09837040f, -0.18393026f, 0.00413152f, 0.11745797f, 
    -0.10073396f, -0.02838629f, 0.02570592f, 0.02599783f, -0.05982501f, -0.09004200f, -0.02083076f, -0.03091967f, 
    -0.26540554f, -0.06114680f, -0.14955328f, -0.31175533f, 0.04845596f, 0.05851336f, -0.03300820f, 0.07642290f, 
    0.05790381f, -0.00538653f, 0.19762799f, 0.04626951f, -0.00411305f, 0.06418372f, 0.02569298f, 0.13486904f, 
    0.03939797f, 0.05571071f, -0.00377181f, 0.04584054f, -0.21354526f, 0.01105976f, 0.10704006f, 0.15766202f, 
    -0.07675474f, 0.11632635f, -0.05599235f, -0.09822220f, -0.04992817f, -0.01418371f, 0.00887639f, -0.09476406f, 
    -0.04713201f, -0.01168509f, -0.01207197f, 0.06228775f, -0.01751365f, -0.03637940f, -0.03291259f, -0.05939091f, 
    -0.23406105f, 0.14530498f, -0.00925088f, -0.38399523f, 0.01372375f, -0.00510395f, -0.09666558f, -0.09716409f, 
    -0.00022363f, 0.11127034f, 0.02119447f, 0.04366457f, -0.01172342f, 0.05463477f, 0.00989495f, 0.12693159f, 
    -0.00147269f, 0.04478662f, -0.11115173f, -0.02278841f, -0.03585825f, -0.07329912f, -0.27367041f, -0.08038248f, 
    -0.12185241f, 0.18887897f, 0.15929575f, 0.11316936f, 0.07128181f, -0.05641694f, 0.07914931f, -0.05080726f, 
    -0.08611654f, -0.07488564f, -0.05226449f, 0.03578312f, -0.02753086f, -0.02165562f, -0.02248165f, -0.02539894f, 
    0.01285686f, -0.09147117f, 0.05293674f, -0.14910968f, 0.04397149f, 0.00869865f, 0.03325453f, 0.05747645f, 
    -0.04604400f, 0.03712848f, 0.08886622f, 0.08421095f, -0.06817597f, 0.08805573f, -0.06726386f, -0.02745676f, 
    0.07329825f, -0.03022062f, -0.11145885f, 0.06271125f, -0.11036865f, -0.04028448f, 0.00162821f, 0.20267378f, 
    -0.34527969f, -0.17616962f, 0.10915779f, -0.10162439f, 0.01550031f, 0.12281736f, 0.11956025f, -0.07215092f, 
    0.06358134f, 0.04534005f, 0.03042586f, 0.02423873f, 0.05977674f, 0.00054573f, 0.08944814f, -0.04611667f, 
    -0.16103667f, -0.20653729f, -0.16404636f, 0.09305800f, -0.23496786f, 0.02875809f, -0.20026723f, 0.11842339f, 
    0.03242156f, 0.11052558f, 0.04717884f, 0.03859032f, 0.08886981f, -0.02496243f, -0.00393823f, 0.01400755f, 
    0.06611297f, 0.01962446f, 0.07129301f, 0.00661189f, 0.35452056f, -0.14150411f, -0.33640957f, 0.00839679f, 
    0.08201246f, 0.20893508f, 0.03548940f, 0.07875291f, -0.10099494f, 0.08105909f, -0.00469049f, 0.01245553f, 
    0.00026139f, -0.01363512f, -0.06154790f, 0.00492867f, -0.02164557f, 0.06013131f, 0.04435252f, 0.06174018f, 
    0.01388345f, -0.06925155f, 0.04701826f, -0.19139598f, -0.14223371f, 0.02396950f, -0.13850479f, 0.05114581f, 
    -0.05067153f, -0.09061793f, -0.11232556f, 0.12067011f, -0.04328630f, -0.06200110f, -0.06904048f, 0.06740746f, 
    0.07475231f, 0.05511824f, -0.02830517f, 0.16661152f, -0.60727179f, -0.04149403f, -0.40239698f, 0.08595614f, 
    0.02959032f, 0.04652992f, -0.00030351f, 0.05488701f, -0.00583937f, -0.09182384f, -0.07222549f, 0.00648413f, 
    -0.03604322f, -0.15438718f, -0.00399339f, -0.01971766f, -0.09135174f, -0.10980888f, 0.04856738f, 0.07788613f, 
    -0.13928719f, 0.23001902f, -0.10324144f, 0.01432748f, -0.13159612f, 0.05126244f, -0.08467799f, -0.00478790f, 
    0.01472459f, 0.07140358f, 0.01328384f, 0.01371827f, -0.05440374f, 0.00399459f, -0.00581847f, 0.07012919f, 
    -0.01448000f, 0.15354462f, 0.11432871f, 0.03309253f, -0.11997628f, 0.06683601f, -0.23693214f, -0.02910339f, 
    -0.16085498f, -0.08402573f, 0.03977066f, 0.05489391f, -0.02515753f, 0.04389275f, 0.01163437f, 0.01727666f, 
    -0.01855857f, -0.07513340f, -0.05598227f, -0.02280921f, 0.02248936f, 0.01221373f, 0.08278807f, -0.05096277f, 
    -0.13059899f, 0.17887203f, -0.12952906f, -0.14782314f, 0.03074864f, 0.00500027f, 0.02495327f, 0.06611948f, 
    0.02138689f, 0.10252955f, 0.03549500f, -0.00216093f, -0.01623860f, -0.04097631f, -0.02051112f, 0.02221374f, 
    0.05236777f, -0.05074660f, 0.02587199f, -0.01851896f, -0.02678942f, -0.16680872f, -0.18125707f, 0.10820606f, 
    0.02783794f, 0.04011755f, -0.09522200f, -0.02112528f, 0.01158618f, 0.17692399f, -0.01842726f, 0.04884053f, 
    0.00932951f, 0.05238081f, -0.00855003f, -0.01391838f, 0.07623705f, 0.23681130f, 0.13359049f, 0.17950188f, 
    0.24054487f, -0.34862718f, 0.17371240f, -0.07550530f, -0.21126746f, -0.16353445f, -0.33266222f, 0.11784305f, 
    0.16544445f, 0.29579553f, -0.07281385f, 0.01713833f, 0.04249661f, -0.00254877f, -0.12255055f, 0.00910050f, 
    0.07082919f, -0.02971136f, 0.01250001f, -0.03077025f, 0.02532222f, 0.01106924f, 0.07901197f, 0.01932441f, 
    -0.02890421f, -0.06741686f, 0.11812939f, -0.14324604f, -0.10784133f, 0.03332988f, 0.00935688f, -0.02164024f, 
    0.10112617f, -0.00986421f, 0.02181409f, 0.04978769f, -0.05787432f, -0.00976763f, -0.05535267f, -0.10377033f, 
    0.26377833f, -0.11826637f, -0.11267246f, 0.03371971f, -0.27348295f, -0.06555492f, -0.12692401f, 0.14884815f, 
    0.00460327f, 0.13879929f, -0.00768725f, -0.05880273f, -0.01542614f, -0.02233391f, -0.12420293f, 0.03895028f, 
    -0.03504814f, -0.08505190f, 0.01106619f, -0.04092993f, -0.18303284f, 0.34534854f, 0.03748036f, -0.14318180f, 
    -0.07648718f, 0.05427628f, -0.13018943f, 0.04922502f, -0.02910018f, 0.07269233f, 0.02076058f, 0.06405982f, 
    -0.07092986f, -0.02616131f, -0.05173251f, -0.03091477f, 0.04299146f, -0.00657247f, 0.01350239f, -0.08704348f, 
    -0.33987921f, -0.01907930f, -0.43345910f, 0.04118614f, -0.42533207f, -0.07279154f, -0.00819495f, 0.06360056f, 
    0.11392803f, 0.05607075f, 0.02978228f, 0.04103144f, 0.02159794f, 0.00862858f, -0.00571455f, -0.11163015f, 
    0.08425801f, 0.03089279f, 0.06384484f, 0.04751426f, -0.07380629f, 0.04529281f, 0.06727979f, 0.06161577f, 
    -0.16300067f, -0.11489239f, -0.09480189f, -0.03514306f, -0.01451083f, -0.04456866f, 0.10713952f, -0.02683781f, 
    0.04629089f, 0.02006779f, 0.01489202f, -0.01009903f, -0.08797146f, 0.02755263f, -0.00351818f, -0.05863710f, 
    -0.25145018f, 0.29444116f, -0.43386993f, -0.29491675f, -0.14191960f, -0.06660832f, -0.07690652f, 0.12170929f, 
    -0.21524481f, 0.08550605f, -0.03216429f, 0.08142430f, -0.11448619f, -0.03522925f, 0.08480065f, -0.04769302f, 
    0.10415599f, -0.00558306f, 0.01621708f, -0.01705342f, -0.09449255f, -0.15123673f, -0.46639928f, 0.03086676f, 
    0.08036076f, 0.06464244f, 0.07332136f, 0.14255048f, -0.01103306f, 0.09382382f, 0.01376224f, -0.01902623f, 
    -0.02794923f, 0.06657181f, 0.01988875f, 0.01461493f, 0.09564224f, 0.06024961f, -0.02605881f, 0.07090130f, 
    -0.29603136f, -0.42749092f, 0.23478751f, 0.03994758f, -0.07638083f, -0.16129008f, 0.09882186f, 0.12226273f, 
    -0.19463132f, -0.09035613f, -0.02037732f, 0.05686158f, -0.04009200f, 0.10005140f, 0.09181913f, 0.05220152f, 
    0.03411753f, 0.16196685f, 0.07750688f, 0.18351893f, 0.02542426f, -0.13594504f, -0.00377488f, 0.12061392f, 
    -0.05790984f, -0.06058324f, -0.00657961f, 0.08835582f, 0.01046661f, 0.01469333f, -0.02161758f, 0.00178561f, 
    -0.00723547f, 0.04143081f, 0.02132655f, -0.01828774f, -0.00147595f, 0.09865500f, 0.02133337f, 0.10301425f, 
    0.06690406f, -0.16273278f, -0.09379702f, 0.08319164f, -0.10283890f, -0.11342375f, -0.08419264f, -0.02268908f, 
    -0.26847461f, -0.12189075f, -0.04605351f, 0.01441601f, -0.07511341f, 0.04773518f, 0.04193851f, -0.04185359f, 
    -0.08283310f, -0.17583236f, -0.08497421f, -0.01918537f, -0.24444838f, 0.03376437f, -0.22224662f, -0.06885161f, 
    0.08517125f, -0.07082444f, -0.05250410f, -0.07384261f, -0.02234233f, -0.03148399f, -0.03560106f, 0.02946293f, 
    -0.00469592f, -0.03079539f, 0.03393315f, 0.05936741f, -0.04195947f, -0.09989510f, -0.03088877f, 0.01408183f, 
    0.01346890f, 0.03083473f, 0.10720889f, -0.17723157f, 0.13436438f, -0.16311763f, -0.01481407f, 0.07544157f, 
    -0.00043113f, 0.05563344f, -0.04117770f, 0.01220067f, -0.12648468f, 0.06338181f, 0.08273657f, 0.06346054f, 
    -0.04126328f, 0.07666832f, -0.07553741f, 0.11301506f, -0.13460790f, -0.49258381f, -0.37990537f, 0.19725300f, 
    -0.11478502f, -0.03429141f, -0.23873007f, 0.21532834f, -0.43046519f, 0.05655783f, -0.04479455f, 0.03067711f, 
    -0.16539717f, 0.05187093f, 0.04240556f, -0.02468009f, -0.11264645f, -0.05153241f, 0.09629908f, 0.09928023f, 
    -0.01254607f, 0.04779437f, 0.16114126f, -0.02467870f, -0.06384066f, 0.05805954f, -0.10562710f, 0.06210953f, 
    0.11998243f, 0.01300657f, -0.11975965f, -0.00933872f, -0.09406257f, -0.01602535f, -0.13324961f, -0.11469760f, 
    -0.18396740f, 0.03159524f, -0.14618585f, -0.19511566f, 0.16722301f, -0.24356531f, 0.09803103f, -0.09978011f, 
    -0.18027994f, -0.12874413f, -0.04582316f, 0.04381602f, 0.02148511f, -0.01258622f, 0.07734831f, 0.01443741f, 
    -0.03146042f, 0.00852383f, 0.04204251f, -0.02220873f, 0.01126371f, 0.05807362f, 0.00259226f, -0.03690466f, 
    0.04853540f, 0.07168941f, -0.21362768f, 0.26976287f, 0.15022300f, 0.00245816f, -0.05468705f, 0.06344166f, 
    -0.25300553f, 0.06093946f, 0.06242727f, 0.03849140f, -0.27868313f, 0.04889414f, 0.09506943f, -0.09869646f, 
    0.00838483f, -0.07032242f, -0.12566952f, 0.07454098f, -0.29476523f, 0.17156486f, -0.30069891f, 0.16201106f, 
    -0.00310663f, -0.01693098f, -0.05933837f, 0.00216524f, 0.24015792f, 0.22305860f, -0.14441130f, -0.03994639f, 
    -0.04093197f, -0.12273887f, -0.04562317f, -0.10849608f, 0.11471283f, -0.21762449f, 0.13070369f, 0.16007350f, 
    -0.07831600f, -0.04462230f, -0.19294147f, -0.11521714f, 0.09599611f, -0.10095862f, -0.02381003f, 0.19755597f, 
    -0.01458128f, 0.06402718f, -0.03748038f, 0.07624173f, -0.05767725f, 0.05605746f, 0.07369532f, 0.08854864f, 
    -0.08506038f, -0.00110951f, -0.07376373f, -0.11820102f, -0.07552402f, -0.16295089f, 0.20064455f, -0.09372785f, 
    -0.09648469f, -0.03129220f, -0.07861459f, 0.04744219f, 0.15344867f, 0.00209765f, 0.00562795f, 0.10788535f, 
    -0.03383037f, 0.07621048f, 0.01271633f, -0.13552620f, 0.00113345f, 0.06529168f, 0.07931849f, -0.00008687f, 
    -0.17051025f, 0.05785319f, -0.60907710f, 0.12740900f, 0.21745390f, 0.00560740f, 0.05020274f, 0.17117801f, 
    -0.25409824f, 0.06008771f, -0.08098958f, 0.03774099f, 0.02742362f, -0.08055566f, -0.09691191f, -0.04256002f, 
    0.00760735f, -0.29882804f, -0.01834947f, -0.03834636f, -0.28647205f, 0.09682883f, 0.05489376f, 0.11079606f, 
    -0.03559058f, 0.08378269f, -0.03092106f, -0.00515843f, 0.13343412f, -0.06800906f, -0.04055616f, -0.02332327f, 
    0.07800367f, -0.05590181f, -0.02255803f, -0.01901031f, -0.03924527f, -0.01095861f, 0.02704477f, 0.06893175f, 
    -0.32192093f, 0.06743994f, -0.25695983f, 0.01380933f, -0.00540136f, 0.12077644f, -0.12533905f, 0.04878394f, 
    0.12592176f, 0.03709874f, -0.06604896f, 0.11040619f, 0.02647164f, -0.04431388f, -0.01443426f, 0.07961997f, 
    -0.15548663f, -0.23025320f, -0.15358089f, -0.06528605f, -0.16032512f, 0.00361203f, 0.13727012f, -0.07486900f, 
    0.04868858f, 0.01019555f, -0.05109112f, 0.15405385f, -0.00053286f, -0.03791257f, 0.02060284f, 0.05389345f, 
    0.10322894f, 0.00142979f, 0.00058778f, 0.07952654f, -0.03769092f, 0.06504846f, -0.05628093f, -0.05489678f, 
    0.12104475f, 0.14234693f, -0.05480311f, -0.05297606f, 0.01656411f, 0.14928953f, -0.01048279f, -0.13234505f, 
    -0.09712643f, 0.01414526f, -0.15005419f, 0.09864000f, -0.03456427f, -0.08953349f, -0.08399473f, 0.06260506f, 
    0.00407713f, -0.10621512f, 0.04587607f, 0.04265565f, -0.11320867f, -0.18842721f, 0.21005940f, -0.01914655f, 
    -0.15096360f, 0.01750359f, 0.13485177f, 0.00195983f, -0.00599799f, -0.03388917f, 0.02239346f, 0.03968596f, 
    0.03483939f, 0.10650776f, -0.01600829f, -0.02461783f, 0.15271385f, 0.13894618f, 0.07096007f, 0.19034424f, 
    0.03191577f, -0.18397500f, 0.00268787f, -0.12318224f, 0.00781046f, 0.04575814f, -0.06692094f, 0.05039570f, 
    0.02211723f, -0.01957001f, -0.13445717f, 0.05720556f, 0.02232408f, 0.00983574f, 0.04599750f, 0.09653907f, 
    -0.11534688f, -0.00576937f, 0.00824555f, -0.01377249f, 0.25967044f, 0.10463654f, 0.12260001f, 0.17982510f, 
    0.20010591f, 0.02863014f, 0.11401603f, 0.12443707f, -0.05081754f, 0.12243696f, -0.19023235f, 0.04371716f, 
    -0.05469754f, 0.01302850f, 0.12340411f, 0.03962877f, -0.08533134f, -0.06016147f, 0.10377489f, 0.09770801f, 
    -0.41651708f, 0.02968904f, -0.04561453f, 0.06986603f, -0.04555185f, 0.10353249f, -0.05900579f, 0.09720793f, 
    0.02935010f, -0.09997129f, -0.07195422f, 0.11428896f, 0.07452378f, -0.05611234f, 0.00532328f, 0.06355722f, 
    -0.05469366f, -0.15416902f, -0.24722537f, -0.20134394f, 0.10780504f, -0.10113037f, 0.04443515f, 0.36553991f, 
    -0.04263220f, -0.04934697f, 0.01793588f, 0.20875388f, -0.01189091f, -0.14883238f, 0.02456756f, -0.01994554f, 
    0.01188520f, 0.10854807f, 0.08643551f, -0.01209893f, -0.04951042f, 0.11314535f, -0.10126333f, 0.09445978f, 
    0.11093701f, 0.18029027f, 0.03453217f, -0.07246058f, 0.09470273f, 0.10599969f, -0.16718474f, -0.02188599f, 
    -0.04129161f, -0.02571706f, -0.25421831f, 0.14997566f, -0.08018458f, -0.11961287f, -0.14064780f, 0.00218119f, 
    -0.02831769f, -0.00615270f, -0.01869668f, -0.07897540f, -0.12169771f, -0.03911476f, -0.00976435f, 0.15053163f, 
    -0.07244530f, 0.08463873f, 0.01084316f, -0.04966978f, -0.07532425f, 0.08040015f, -0.02525216f, -0.05092324f, 
    0.06630856f, 0.05148181f, -0.13293962f, -0.05410445f, 0.09856480f, 0.02416510f, 0.11486461f, 0.00168934f, 
    -0.18490893f, 0.23413442f, -0.04437853f, 0.03924823f, 0.00716246f, 0.06347951f, -0.03962286f, -0.02695040f, 
    -0.01226398f, 0.01757126f, 0.01965909f, -0.00584732f, 0.00368508f, 0.01248264f, -0.06675433f, -0.08660592f, 
    -0.04191467f, -0.07562762f, 0.02086245f, -0.04087001f, 0.24919392f, -0.31532338f, 0.28145373f, -0.04046334f, 
    -0.05892653f, -0.05918549f, -0.07277082f, 0.03513515f, 0.06986695f, -0.08445738f, -0.01300609f, 0.07015777f, 
    0.00041185f, 0.06284176f, 0.02519009f, -0.01389322f, 0.12190207f, 0.08995713f, 0.08493865f, -0.02573995f, 
    0.26053488f, -0.08212755f, -0.06991716f, 0.12710637f, 0.17739809f, 0.09859709f, 0.10810309f, 0.17213860f, 
    0.06002288f, 0.06378924f, -0.15973072f, 0.11569192f, 0.09353828f, -0.12718625f, -0.11738379f, 0.05170885f, 
    0.02357636f, 0.03532623f, 0.15989450f, 0.07853486f, -0.21160722f, -0.02436603f, -0.27034941f, 0.16702271f, 
    -0.01832557f, 0.00829432f, 0.01073649f, 0.02058323f, 0.14853878f, 0.04736689f, -0.08625836f, -0.14544761f, 
    0.02121248f, 0.04672302f, 0.02663874f, 0.04501547f, 0.05804593f, -0.20576270f, 0.21009864f, 0.19874054f, 
    -0.09413270f, 0.09696832f, -0.29079399f, 0.14030617f, 0.11180270f, 0.00807228f, 0.02495205f, 0.08253498f, 
    0.02440547f, -0.04047045f, -0.09178356f, -0.03694670f, -0.00876927f, -0.06716627f, 0.08183633f, -0.12439667f, 
    -0.07570972f, -0.15041347f, 0.01025484f, 0.00566760f, 0.17317225f, -0.44141641f, 0.15932728f, -0.09758777f, 
    -0.04090927f, -0.24247007f, -0.01772538f, 0.05165287f, 0.00819972f, -0.10138956f, -0.07534436f, 0.03605220f, 
    -0.05417872f, 0.00161274f, 0.05050880f, 0.05638253f, -0.10270933f, 0.03894852f, -0.04727075f, -0.11451664f, 
    -0.21881658f, -0.00217572f, -0.18846039f, 0.01056195f, 0.07114419f, -0.08638936f, -0.03262442f, -0.14735036f, 
    0.02269784f, -0.00864543f, -0.03096846f, 0.05777881f, -0.04353573f, -0.06554598f, -0.01046020f, 0.01985134f, 
    0.00846998f, -0.07392082f, 0.02950604f, -0.04679592f, -0.13003449f, -0.16445416f, -0.16756698f, -0.04276688f, 
    -0.13658389f, 0.01681676f, 0.04521925f, 0.02786481f, -0.14453711f, -0.04842937f, -0.03922684f, 0.04305135f, 
    -0.05038545f, -0.01399086f, 0.01042066f, -0.08784570f, 0.06264889f, 0.00279566f, -0.00360554f, 0.15610358f, 
    0.20099637f, -0.12565365f, -0.59781128f, 0.31195223f, -0.10358554f, -0.05264390f, -0.10438069f, 0.23465461f, 
    -0.10817151f, -0.02683615f, 0.03552467f, -0.03691350f, -0.16265526f, 0.05867366f, 0.09021831f, 0.00522834f, 
    0.11961456f, 0.12438532f, 0.06800706f, 0.17769495f, -0.37204388f, -0.02700697f, -0.20796433f, -0.05238539f, 
    0.12360334f, -0.15347034f, -0.06279068f, -0.12862299f, 0.00151731f, -0.06961260f, -0.05676998f, 0.09052595f, 
    0.01970397f, -0.00863088f, 0.02189211f, 0.01668552f, 0.02389840f, -0.04456716f, 0.05670155f, 0.04309272f, 
    -0.49732018f, -0.11373195f, 0.15537393f, -0.04521996f, -0.00929296f, -0.05039587f, 0.09649514f, -0.20830265f, 
    0.05792585f, -0.08054686f, -0.01630195f, -0.01809815f, -0.09989063f, 0.04423066f, 0.06640055f, 0.15160726f, 
    -0.09714256f, -0.00524929f, -0.32567227f, -0.18101026f, -0.16244997f, 0.08941060f, 0.15866193f, 0.20970857f, 
    -0.07911321f, 0.11560348f, 0.23777999f, 0.03553705f, 0.03897351f, -0.11739197f, -0.08811780f, -0.06131162f, 
    -0.03863185f, -0.01984729f, 0.02742006f, -0.02183466f, 0.08555153f, -0.04820187f, -0.00698362f, 0.04386022f, 
    -0.63670224f, 0.11370049f, 0.14633292f, 0.13120079f, 0.01337984f, -0.01438296f, -0.01768069f, -0.25636888f, 
    0.00949178f, 0.01958276f, 0.05825288f, -0.00745091f, -0.04200204f, -0.09968635f, 0.03387788f, -0.05418184f, 
    0.00186073f, -0.01457183f, -0.01811297f, -0.03016239f, -0.00236274f, 0.06293791f, 0.00137123f, 0.05424152f, 
    -0.01042301f, -0.04135773f, 0.02208038f, -0.07199300f, -0.01264612f, 0.02678178f, 0.00409700f, -0.00387321f, 
    0.02123032f, -0.03702382f, -0.06909803f, 0.00039423f, 0.00128548f, 0.00652063f, 0.01102027f, 0.10377198f, 
    -0.03175608f, -0.15084898f, 0.10168130f, -0.06440337f, -0.18461633f, -0.04714857f, -0.11317565f, -0.06524433f, 
    0.04968642f, 0.02033214f, -0.08110453f, -0.00790835f, 0.02667329f, -0.01828274f, -0.04264529f, -0.04526728f, 
    0.02132410f, 0.03601432f, 0.06841382f, 0.07864986f, 0.14093694f, -0.29516158f, 0.22251886f, -0.02392903f, 
    0.03490447f, -0.15676875f, 0.01919391f, 0.06876268f, 0.03305356f, -0.06908029f, -0.03035736f, 0.03324137f, 
    -0.02355223f, 0.00230286f, 0.05079515f, 0.09675409f, 0.02599711f, 0.06441835f, 0.08378386f, -0.15168338f, 
    0.06590786f, 0.10208961f, 0.10884118f, 0.08579358f, -0.05113393f, 0.12528059f, 0.02498556f, -0.00794296f, 
    0.01656933f, 0.08936029f, -0.09043445f, 0.05284577f, -0.06235413f, -0.01413835f, -0.23298413f, -0.06681119f, 
    -0.05800793f, 0.00114351f, 0.00752411f, -0.13616075f, -0.12828182f, -0.07823523f, 0.10927638f, 0.01394911f, 
    -0.16051531f, -0.00245069f, 0.01030940f, -0.08528998f, -0.01588155f, -0.00859829f, 0.00160072f, -0.02935354f, 
    0.00476616f, 0.02457561f, -0.02796936f, -0.01049920f, -0.01225797f, -0.00823466f, 0.09382575f, 0.01217956f, 
    -0.07112049f, -0.26781431f, 0.02072547f, -0.21553309f, -0.41043895f, -0.02415427f, -0.11943100f, -0.12300795f, 
    0.03913252f, -0.07698935f, -0.14114192f, 0.05366303f, -0.02198156f, -0.00597180f, -0.04409006f, 0.09458718f, 
    0.12501447f, 0.03651401f, 0.02503941f, -0.11819711f, -0.08248407f, 0.05926383f, 0.00929280f, -0.11814364f, 
    0.05876675f, -0.06066597f, 0.03672383f, 0.07441178f, 0.01194358f, 0.03958212f, -0.00265663f, 0.10555924f, 
    -0.03803210f, 0.04682750f, -0.00637483f, 0.05493601f, 0.08051372f, -0.00381070f, 0.06440295f, 0.11861789f, 
    0.03147021f, 0.08086493f, 0.33894786f, 0.04635740f, -0.00439681f, 0.08922049f, 0.13286990f, 0.13433929f, 
    0.15074119f, 0.01824227f, -0.04004811f, 0.04882419f, 0.04669845f, -0.02207064f, -0.11488108f, -0.15009375f, 
    0.13472201f, 0.15656602f, 0.04982574f, 0.03181060f, -0.35697806f, -0.43353817f, -0.08728716f, -0.09323554f, 
    -0.25984809f, -0.09297593f, -0.04856770f, 0.14579786f, 0.19880955f, 0.06030709f, -0.12295364f, 0.12448846f, 
    -0.03663224f, 0.05851864f, -0.16081534f, 0.03916335f, 0.04952111f, 0.12107762f, 0.21842708f, 0.19970129f, 
    -0.05221191f, -0.04481682f, 0.16323122f, -0.05086708f, -0.24527477f, -0.03743529f, -0.01963792f, -0.14846538f, 
    0.07823244f, -0.02395259f, -0.14512405f, 0.00893963f, -0.01547486f, 0.07153840f, 0.01142992f, -0.03155251f, 
    0.10679816f, 0.06448942f, 0.11397900f, 0.04668191f, -0.04382095f, 0.05479266f, -0.52741057f, 0.09382134f, 
    0.21896911f, 0.05627284f, -0.01569872f, -0.03863624f, -0.19369459f, 0.10345611f, -0.06314783f, 0.08859234f, 
    -0.06324516f, -0.05936096f, 0.04572840f, -0.01723165f, -0.04979476f, -0.14435670f, 0.05341619f, 0.00988610f, 
    -0.46412829f, -0.04419257f, -0.07074517f, 0.02486243f, 0.10169113f, -0.09655397f, -0.04942823f, -0.04078312f, 
    0.21737538f, 0.03646088f, -0.02317978f, 0.08134499f, 0.02153959f, 0.07394601f, -0.01304932f, 0.00968117f, 
    -0.02952077f, -0.21227090f, 0.01356924f, -0.14847757f, -0.14303505f, -0.09737786f, -0.01862285f, 0.00133629f, 
    0.06700508f, -0.07696542f, -0.08985777f, -0.13860396f, 0.04143218f, -0.04458648f, 0.01524012f, 0.05692296f, 
    0.00071698f, -0.01734926f, -0.05104789f, 0.04732078f, -0.08722109f, -0.10052850f, -0.07929082f, -0.02161351f, 
    0.04035042f, -0.02046066f, -0.15504587f, 0.25620511f, -0.07692509f, -0.00700484f, -0.01983954f, 0.09151889f, 
    -0.13393468f, -0.04823567f, 0.09046520f, 0.01313425f, -0.04593762f, 0.04761034f, 0.00903520f, -0.07052484f, 
    -0.14114995f, 0.12002056f, -0.07889934f, 0.02080972f, 0.13358778f, -0.34360626f, 0.24209742f, 0.13294710f, 
    0.14924528f, -0.22093609f, -0.01474750f, 0.06247222f, -0.03970809f, -0.05039087f, -0.12267363f, -0.09933304f, 
    -0.25210541f, 0.26172143f, 0.07676484f, -0.12015905f, 0.00909034f, 0.11231150f, -0.10151318f, 0.08228584f, 
    -0.01400255f, 0.06679320f, 0.13759671f, 0.15173708f, 0.04897541f, -0.04098842f, 0.01363206f, -0.01672572f, 
    0.01386910f, -0.07734969f, -0.05327592f, 0.05334713f, 0.10437740f, -0.07012380f, -0.00554292f, -0.03299930f, 
    0.00600228f, -0.00276342f, 0.06509842f, -0.07924291f, -0.11604437f, -0.02698668f, 0.20698425f, 0.03656343f, 
    0.14210254f, -0.07449850f, -0.06322613f, 0.06634144f, -0.00694866f, 0.03023084f, 0.03280240f, -0.00352134f, 
    0.02535034f, 0.11006695f, 0.02848251f, 0.04048968f, 0.09831683f, -0.01394789f, 0.04439202f, -0.01487766f, 
    -0.04976718f, -0.09366266f, -0.15031514f, 0.08907347f, -0.13612656f, 0.05298304f, -0.02848450f, 0.08484891f, 
    0.02245567f, -0.10506582f, -0.09988794f, 0.01170256f, 0.01716376f, -0.01939279f, 0.04274376f, 0.01260969f, 
    -0.03911885f, 0.08286802f, 0.02850555f, 0.01813495f, -0.11856160f, -0.13481008f, -0.50758684f, -0.09411321f, 
    -0.00710792f, -0.06383901f, -0.03749780f, 0.10883404f, -0.10166053f, -0.14405668f, 0.03524214f, 0.05410001f, 
    -0.00308076f, -0.01823683f, -0.04915894f, 0.07961402f, -0.07937505f, -0.08568120f, -0.16765486f, -0.31164461f, 
    -0.35891953f, 0.03762236f, -0.17976721f, 0.03240991f, -0.10353395f, 0.14256085f, -0.23274800f, -0.16254856f, 
    0.00024884f, -0.01495019f, -0.14057116f, 0.11794571f, 0.03348088f, -0.00263427f, 0.04799238f, 0.08330257f, 
    -0.02871558f, -0.10176058f, -0.17316104f, 0.00197882f, -0.03091661f, -0.01249955f, -0.04757776f, 0.07589804f, 
    0.20709322f, -0.01701716f, 0.04482481f, 0.10667852f, 0.02640309f, 0.00100629f, -0.01152536f, 0.04296270f, 
    0.02772424f, 0.04350464f, 0.06052205f, 0.03904884f, 0.05425420f, 0.09481361f, 0.04456168f, 0.09565125f, 
    -0.48431599f, -0.04090980f, -0.05287574f, -0.17063931f, 0.00311924f, 0.10392611f, -0.17125659f, 0.17146999f, 
    0.08249816f, 0.13511987f, -0.10508585f, 0.15706387f, 0.03257038f, -0.01170733f, -0.00676068f, 0.06891041f, 
    -0.01811849f, 0.02820458f, 0.06326967f, 0.16818361f, -0.10256656f, -0.10678864f, -0.02743921f, 0.12939966f, 
    0.02161045f, -0.05162833f, 0.06050281f, 0.15929925f, -0.05061607f, -0.07323684f, -0.02592260f, -0.03901769f, 
    0.01262447f, 0.10380001f, 0.08183745f, -0.01937251f, 0.07162486f, 0.13625596f, 0.03016104f, 0.15537302f, 
    -0.21728413f, -0.09199830f, 0.29538172f, 0.15581854f, 0.19143634f, -0.12966678f, -0.00400096f, 0.11457676f, 
    0.19108932f, 0.07216582f, 0.00208608f, -0.04952043f, -0.00109271f, -0.00423497f, 0.02529891f, 0.05381002f, 
    -0.05023947f, -0.00594192f, 0.04626951f, -0.00769247f, 0.09786338f, 0.01119866f, 0.19215535f, -0.02627641f, 
    0.14718363f, 0.04694274f, 0.03170804f, 0.01897550f, 0.02975470f, 0.07854455f, -0.10660822f, 0.04122807f, 
    0.02401987f, 0.00761016f, 0.01362967f, 0.11519931f, 0.05565194f, -0.03282608f, 0.14491788f, 0.08564907f, 
    0.08954870f, -0.07169649f, -0.44835976f, 0.35106823f, -0.06758994f, -0.15451002f, -0.18720885f, 0.25742140f, 
    -0.24252923f, -0.16724165f, -0.02498340f, 0.00879467f, -0.13458614f, 0.13368315f, 0.12970537f, -0.02810927f, 
    -0.06512444f, 0.20836310f, -0.12454279f, 0.11356550f, 0.04159837f, -0.17087148f, -0.07421377f, -0.06412547f, 
    -0.00120063f, -0.10354438f, -0.04362728f, 0.01685797f, -0.19837159f, -0.16443172f, -0.11645092f, 0.01675726f, 
    -0.09991242f, -0.01315403f, 0.02651102f, 0.05922925f, -0.22506371f, -0.14572734f, -0.13238250f, -0.05427231f, 
    0.31423172f, 0.07547808f, 0.29182824f, -0.13109784f, 0.00528361f, 0.10080562f, 0.05721401f, -0.09570492f, 
    -0.00059165f, -0.04673939f, -0.08592128f, -0.01033262f, 0.04382870f, -0.00742085f, 0.00659907f, -0.07814710f, 
    0.06694209f, -0.17077301f, -0.12103768f, 0.06801790f, -0.05097220f, -0.03270810f, 0.00782090f, -0.00146245f, 
    0.01395535f, -0.02681945f, 0.04233431f, -0.02760192f, 0.11918999f, 0.03715085f, -0.03091068f, 0.05564899f, 
    0.00686666f, 0.03966701f, 0.02170906f, -0.06283367f, -0.01244406f, 0.02249752f, -0.02552280f, -0.07257549f, 
    0.20256983f, -0.04444801f, 0.09220836f, 0.00481661f, -0.03061433f, -0.04867395f, -0.02077695f, -0.02592121f, 
    -0.04038711f, 0.01362295f, -0.08036014f, 0.00619449f, 0.02778717f, -0.01338584f, -0.00476963f, 0.03453657f, 
    0.08098534f, -0.01087821f, 0.03341830f, -0.01987808f, 0.21374702f, -0.18649150f, -0.08557183f, -0.13097440f, 
    -0.04483076f, -0.06287888f, -0.23315772f, -0.09248929f, -0.10371729f, -0.02397348f, 0.00632902f, 0.05349686f, 
    0.06265064f, -0.01219157f, -0.04611883f, -0.00153510f, -0.05073199f, 0.01192080f, 0.00882611f, -0.10926771f, 
    -0.08833250f, -0.15868580f, 0.06547190f, -0.03331270f, 0.22530317f, 0.13336532f, -0.05582470f, 0.07820041f, 
    -0.03518095f, -0.06195436f, 0.04502807f, -0.01916412f, -0.08186421f, 0.01777052f, -0.12103646f, 0.09844914f, 
    -0.01200264f, -0.01027725f, -0.09736612f, 0.03337542f, 0.44205141f, 0.17271617f, 0.25729671f, 0.02668935f, 
    -0.41009173f, -0.04057130f, 0.02172254f, 0.07563731f, -0.01009669f, 0.04915186f, -0.12763841f, 0.05205762f, 
    -0.00121279f, 0.04291953f, -0.07242574f, -0.08209564f, 0.11218690f, 0.03892503f, 0.08895871f, 0.05345231f, 
    -0.33652464f, 0.02885341f, -0.26743010f, 0.10430472f, 0.05289801f, 0.11413886f, 0.08228886f, 0.14317393f, 
    -0.19677067f, -0.04834850f, 0.02294029f, -0.03638045f, 0.07239699f, 0.18958347f, -0.02668693f, 0.02860578f, 
    0.04796752f, 0.14651397f, 0.01693169f, 0.03035376f, -0.11545762f, -0.03763872f, -0.02509416f, -0.03911189f, 
    0.02350094f, -0.01916147f, 0.07061808f, 0.03685660f, 0.06586345f, -0.00221204f, -0.06684678f, 0.05927331f, 
    0.00750579f, 0.03183189f, -0.01790334f, 0.01598218f, -0.00134071f, 0.01476650f, -0.05264755f, -0.04333699f, 
    -0.46340373f, -0.23882535f, -0.09721100f, 0.15819536f, -0.01878672f, 0.03542201f, 0.06632599f, 0.03702323f, 
    -0.02955341f, 0.07521483f, -0.13762929f, 0.00850437f, 0.10526607f, -0.00080437f, -0.01555956f, 0.10530687f, 
    -0.11948185f, 0.19669263f, 0.13557367f, -0.02930960f, 0.08461301f, 0.22771296f, 0.21839517f, 0.18541655f, 
    -0.33093169f, 0.00542894f, 0.00963973f, 0.12651813f, 0.00682982f, -0.02736324f, -0.10288379f, 0.02110716f, 
    0.03723227f, 0.01587950f, 0.01452238f, 0.03155185f, 0.00769251f, 0.12029159f, 0.15939289f, -0.21703306f, 
    0.25112489f, -0.11472235f, 0.16912280f, -0.03285411f, 0.16749744f, -0.05188904f, -0.26331773f, -0.13370633f, 
    0.12219705f, -0.08618578f, 0.01631640f, -0.01054300f, 0.02045015f, -0.00521207f, -0.03687605f, 0.05201303f, 
    -0.05658608f, -0.13500749f, -0.03739454f, 0.12223677f, -0.11882427f, 0.02900261f, -0.07600457f, 0.05922994f, 
    0.10420161f, 0.11416978f, 0.09731991f, 0.06350415f, -0.03511576f, -0.03846517f, -0.06125006f, -0.09682360f, 
    0.02733431f, -0.00611193f, 0.01367953f, 0.03685744f, 0.00989932f, -0.04275873f, 0.04680821f, -0.08864130f, 
    -0.26588324f, -0.03531417f, -0.14975820f, 0.20621043f, -0.17709804f, -0.02392718f, -0.06765885f, 0.18847297f, 
    -0.08566625f, 0.06810502f, -0.01892923f, -0.00856502f, -0.01379691f, -0.00189622f, 0.09782650f, 0.19645731f, 
    0.01755211f, 0.20693162f, 0.03466368f, 0.07717675f, -0.26677853f, -0.05644749f, -0.06697957f, 0.19701132f, 
    -0.12382028f, 0.01069086f, 0.02340352f, 0.01056074f, 0.02265449f, -0.08843656f, -0.10185830f, -0.08133603f, 
    -0.04388000f, 0.06646802f, -0.02794560f, 0.11137684f, 0.04109958f, 0.11554062f, -0.09724201f, -0.00256272f, 
    0.05442077f, 0.01431515f, 0.09385525f, 0.10806623f, -0.02554171f, 0.03512944f, -0.26493755f, 0.07340431f, 
    0.03751716f, -0.27334791f, -0.05527988f, -0.01130302f, 0.05056058f, -0.00561433f, 0.05796619f, 0.08327354f, 
    -0.03970883f, 0.10594440f, 0.05853491f, 0.01288400f, 0.07719446f, -0.17984281f, 0.00182812f, -0.02158942f, 
    0.10560889f, -0.09793327f, -0.10991539f, -0.04614536f, -0.09613261f, -0.09247882f, 0.08040503f, 0.06393882f, 
    -0.00364580f, 0.00574856f, 0.01669442f, 0.03403779f, -0.08768489f, -0.03048036f, -0.08780968f, 0.12592305f, 
    -0.43735337f, -0.00522083f, -0.24372421f, 0.21515968f, -0.16174829f, 0.04585933f, -0.02727240f, 0.03350034f, 
    -0.05108531f, 0.10841986f, -0.09722152f, -0.13051812f, -0.03454800f, -0.02386185f, 0.00298072f, -0.01527837f, 
    -0.07103126f, -0.04850499f, -0.06340371f, -0.02682973f, -0.07096472f, 0.09466057f, -0.07532197f, 0.17239806f, 
    0.04039146f, -0.02352759f, 0.06932200f, -0.01736954f, -0.24857345f, -0.00219809f, 0.02458331f, 0.07227620f, 
    -0.09557544f, 0.04710792f, -0.04099204f, -0.13580887f, -0.12523466f, 0.04754702f, -0.09105277f, -0.10038713f, 
    0.20806819f, 0.03775038f, 0.22687572f, 0.02832910f, -0.10794248f, -0.05896349f, -0.02899768f, 0.00247820f, 
    0.00246980f, -0.03455269f, -0.08013653f, -0.05188495f, -0.00033069f, -0.09345896f, -0.03125430f, 0.02828660f, 
    0.05216895f, -0.03394383f, -0.01702152f, 0.10771466f, -0.35476586f, -0.22738297f, -0.00948022f, 0.13738857f, 
    0.07762908f, 0.13163418f, 0.02897733f, 0.14727728f, -0.01458875f, 0.02498783f, -0.04339524f, -0.00422828f, 
    -0.05276230f, 0.08668011f, -0.09145277f, -0.03132916f, -0.03170603f, -0.11031795f, 0.02322602f, -0.03457560f, 
    0.00025653f, -0.15216908f, -0.21689522f, -0.06519337f, 0.00760187f, 0.02128481f, -0.14262982f, 0.02389889f, 
    0.07644203f, -0.24905659f, -0.03233392f, 0.01062395f, 0.04950522f, 0.04958447f, 0.01274193f, 0.00492790f, 
    -0.03896628f, 0.12666814f, 0.09792387f, -0.03572465f, 0.19013955f, -0.25341538f, 0.11884732f, 0.29017690f, 
    0.22898987f, -0.06481598f, 0.11597739f, -0.11154228f, 0.09632600f, -0.04020923f, -0.12373992f, 0.04515307f, 
    -0.06057147f, -0.03317119f, 0.06752601f, -0.03465480f, 0.01645231f, -0.04686077f, 0.06066529f, 0.02606151f, 
    -0.62125748f, -0.12078556f, -0.41783211f, 0.07549287f, -0.57727587f, 0.05526958f, 0.12435018f, 0.04397411f, 
    -0.23816626f, 0.02586884f, -0.11895055f, -0.06039140f, 0.09058081f, 0.10455031f, -0.04669755f, 0.00013803f, 
    -0.01474771f, 0.07462206f, 0.02256748f, 0.05132087f, 0.09808094f, -0.00962636f, 0.10086696f, 0.01745156f, 
    0.00632400f, -0.02451930f, 0.11660564f, 0.01591180f, 0.02729905f, 0.02506279f, -0.06211403f, 0.06688885f, 
    -0.02182748f, -0.02511012f, -0.00628153f, -0.00520397f, -0.05689996f, 0.03991292f, -0.05949529f, -0.12523869f, 
    -0.56788903f, -0.02054914f, -0.34284443f, 0.25130945f, -0.17116424f, 0.02905341f, 0.12567312f, -0.02325527f, 
    0.17854559f, 0.01824852f, -0.08902349f, -0.04189381f, -0.01290962f, 0.02552383f, 0.02967200f, -0.01466107f, 
    -0.02034180f, 0.07664372f, -0.06989332f, 0.10961679f, -0.02920812f, 0.03337725f, -0.18259676f, 0.00382731f, 
    0.20620698f, 0.05280975f, 0.16517369f, 0.06350432f, -0.07215045f, -0.00702875f, 0.00548821f, 0.08605380f, 
    0.03538597f, 0.00708714f, 0.08840916f, -0.11163559f, -0.07701753f, 0.00478165f, 0.00256443f, -0.00367327f, 
    -0.25764969f, -0.04899947f, 0.01322878f, 0.17032829f, 0.06863189f, -0.04018038f, -0.09515662f, -0.09279683f, 
    0.05558637f, 0.10665699f, -0.06259485f, -0.08390713f, -0.17837083f, -0.16247675f, -0.07063824f, -0.04623098f, 
    -0.06276654f, -0.07171216f, -0.00260827f, -0.11090109f, -0.10784843f, -0.18163015f, 0.04578502f, 0.18495683f, 
    -0.00350170f, -0.15518856f, -0.09815556f, 0.09015922f, 0.03844346f, -0.06687306f, -0.01042432f, -0.00016559f, 
    -0.02359542f, -0.04799901f, 0.06567828f, -0.07540529f, -0.01628810f, 0.16684175f, -0.13212252f, -0.35067350f, 
    -0.32769653f, -0.20357904f, -0.05478656f, 0.25574669f, -0.14065611f, 0.17856720f, -0.02976489f, 0.22769709f, 
    -0.18251531f, -0.05460860f, 0.07254617f, 0.01769675f, 0.12435350f, 0.08931065f, 0.09684096f, 0.08242278f, 
    -0.00666632f, 0.13524684f, 0.08371358f, 0.06113626f, 0.23471223f, -0.17083137f, 0.27472335f, -0.29579914f, 
    0.19360869f, 0.03125716f, 0.05706214f, 0.00064864f, 0.02819619f, -0.00400358f, -0.10017402f, -0.00129045f, 
    -0.02648873f, 0.01291856f, -0.09272803f, 0.03267571f, 0.08486409f, 0.02202391f, -0.12432623f, 0.06426941f, 
    0.03599608f, -0.03009051f, -0.04484393f, -0.25710204f, -0.24895675f, -0.05667035f, -0.17352800f, -0.07182377f, 
    -0.01117802f, 0.00023403f, 0.06046539f, 0.06337959f, 0.06906562f, -0.06168906f, -0.05908305f, 0.05827291f, 
    0.01930087f, -0.02527772f, 0.00488480f, -0.00952658f, -0.18021324f, 0.05362036f, -0.08056072f, 0.03850679f, 
    -0.05369003f, -0.01674529f, 0.03640011f, 0.07893090f, -0.04484156f, 0.03462856f, -0.08063962f, 0.05739726f, 
    -0.01782613f, 0.05679798f, 0.00651006f, 0.04899387f, -0.13444525f, -0.05769395f, -0.06961364f, -0.18190761f, 
    -0.08521291f, -0.25922510f, 0.30306408f, 0.03163042f, -0.04283454f, 0.03716878f, 0.12026507f, -0.08299302f, 
    0.28920975f, 0.13325709f, -0.10786093f, -0.01623587f, -0.02000117f, 0.01091887f, -0.10327782f, 0.00015532f, 
    0.13040888f, 0.11581592f, 0.15385516f, -0.15353607f, -0.04893898f, -0.14088838f, -0.25672784f, -0.02067193f, 
    -0.24087048f, -0.03215080f, -0.08568605f, -0.06109398f, -0.21084148f, -0.01367297f, 0.04137273f, 0.08203512f, 
    0.02249754f, -0.04341771f, -0.05083504f, -0.02425561f, -0.00143759f, -0.00908653f, -0.03909846f, -0.05068253f, 
    0.13908173f, -0.62194234f, 0.35480517f, -0.07727820f, 0.10867072f, -0.07291284f, 0.07038049f, -0.19400023f, 
    0.07766798f, -0.31545532f, -0.06066127f, -0.05587672f, 0.13653357f, -0.00873137f, -0.04365940f, 0.11181214f, 
    0.13061404f, 0.07530202f, 0.12048919f, -0.04083344f, 0.38883027f, -0.19227003f, -0.01766504f, 0.29063094f, 
    0.35351810f, -0.03802534f, 0.13018945f, -0.06058534f, 0.23666450f, -0.07976766f, -0.11023027f, 0.14444615f, 
    -0.02355269f, 0.08229413f, 0.10790050f, 0.07498252f, -0.01319388f, 0.07181890f, 0.11795393f, 0.02727597f, 
    -0.33390802f, -0.23143403f, -0.15431677f, 0.39312714f, -0.49063283f, 0.13481583f, 0.09622164f, -0.19146204f, 
    0.17307709f, -0.11283951f, -0.05512666f, -0.04206586f, -0.00441723f, -0.02135436f, 0.11914577f, -0.09141197f, 
    -0.08677378f, 0.12002862f, 0.02136553f, 0.01930789f, -0.14283545f, 0.01789435f, -0.20380175f, 0.13075387f, 
    0.02868761f, -0.03844967f, -0.01017576f, 0.01269069f, -0.01265148f, -0.00740490f, -0.06009657f, 0.05797552f, 
    0.02408581f, -0.11222429f, -0.02922036f, -0.00532750f, -0.07222718f, -0.05715265f, -0.09790260f, -0.13564207f, 
    0.01008641f, 0.07047636f, -0.09468530f, 0.10778668f, -0.02062205f, -0.07621165f, 0.10985346f, 0.06726527f, 
    0.09611907f, 0.04267018f, -0.11387433f, -0.04564908f, 0.00025259f, 0.01597392f, -0.04728106f, 0.04957722f, 
    0.02648508f, 0.00945524f, -0.10775425f, -0.02016279f, 0.16721800f, -0.22197059f, 0.34158081f, -0.37295964f, 
    0.25823390f, 0.10176612f, 0.21467325f, -0.00588958f, 0.04041441f, -0.07788784f, -0.07633934f, 0.08568119f, 
    0.10442713f, 0.05746301f, 0.02968794f, 0.01419163f, 0.16356872f, -0.06507690f, -0.16725788f, 0.05923097f, 
    -0.43790558f, 0.23810039f, -0.36429197f, 0.10792921f, 0.04882352f, 0.04633977f, 0.12257040f, -0.03405141f, 
    0.10022636f, 0.00233885f, -0.02665830f, -0.13434403f, 0.01686514f, 0.06866769f, 0.05480406f, -0.00282896f, 
    0.01124156f, -0.02420836f, -0.02412874f, 0.06739572f, -0.10412236f, -0.02005357f, -0.10897394f, 0.06562781f, 
    -0.05899237f, 0.02251601f, 0.04739421f, 0.03735989f, 0.04934768f, -0.04018654f, -0.01431278f, 0.01242516f, 
    0.02254457f, 0.00104666f, 0.06777734f, 0.04447632f, -0.00605259f, 0.04473491f, -0.16399336f, -0.00110626f, 
    0.16884793f, -0.03683055f, -0.11793101f, 0.03847606f, 0.09134588f, -0.05700602f, 0.08085831f, -0.06655001f, 
    0.11542528f, 0.05486377f, -0.20607296f, 0.01281971f, 0.05357121f, 0.00137033f, -0.03620593f, 0.04595532f, 
    0.05695714f, -0.03672543f, -0.10779368f, -0.01703943f, -0.07966738f, -0.14448725f, -0.20321612f, 0.03998176f, 
    0.04073012f, -0.02171798f, 0.01742669f, -0.07068273f, -0.15556091f, -0.02497377f, -0.08001342f, 0.10437503f, 
    -0.05683311f, -0.07610847f, -0.11720401f, -0.03193630f, -0.09433714f, -0.00242829f, -0.08403253f, -0.03634115f, 
    0.10995428f, 0.02614622f, -0.17700708f, 0.19956644f, 0.38324946f, -0.02834415f, 0.16961561f, -0.16769607f, 
    0.02206182f, 0.07515982f, 0.05243303f, 0.07988890f, 0.02977077f, 0.03862021f, 0.07217315f, -0.03208689f, 
    -0.16087168f, -0.01941823f, -0.09142892f, 0.00097145f, 0.14645326f, 0.25495338f, 0.24247752f, -0.04737243f, 
    -0.30864212f, 0.01111914f, -0.03026111f, 0.09112082f, -0.03421811f, -0.00136041f, -0.08378036f, -0.04315839f, 
    0.06451868f, -0.03112039f, -0.00593350f, 0.02596151f, -0.05339889f, -0.07215458f, 0.02178501f, -0.03090906f, 
    -0.04140947f, 0.03170222f, -0.03926484f, 0.01410029f, -0.01479327f, -0.00655621f, 0.10179214f, 0.04081662f, 
    0.10054193f, 0.01988687f, -0.14522211f, -0.02071774f, -0.05001318f, 0.01109547f, -0.02724777f, 0.01812457f, 
    0.01219399f, 0.02841896f, -0.12115502f, -0.09107453f, -0.19981377f, -0.21164803f, -0.02285196f, 0.11278556f, 
    -0.19065946f, 0.04472356f, 0.04155706f, 0.11459809f, -0.20309378f, 0.09638815f, -0.00581331f, -0.00236843f, 
    0.15984648f, 0.03814675f, -0.06218869f, 0.01642254f, 0.05112488f, 0.09917990f, 0.06831895f, 0.01692859f, 
    -0.04603640f, -0.22854935f, -0.17064451f, -0.23294728f, -0.11200081f, -0.00401931f, -0.22569221f, 0.01650057f, 
    -0.03308704f, -0.17165157f, -0.04536764f, 0.03783533f, 0.00654056f, -0.02293828f, -0.00335721f, 0.05007897f, 
    -0.06362993f, 0.02664451f, 0.10580307f, -0.05814176f, 0.28368953f, 0.00575858f, 0.22753620f, 0.14402972f, 
    -0.07676894f, 0.07182495f, -0.18738438f, -0.08643491f, -0.03701922f, -0.26078394f, -0.08073644f, 0.09181365f, 
    0.02282751f, 0.01881415f, 0.03221716f, 0.01908280f, -0.06504893f, 0.09303951f, 0.09412938f, 0.01560566f, 
    -0.19750901f, -0.11785776f, -0.07201289f, 0.00838834f, -0.07743362f, -0.01132367f, 0.17543617f, -0.03563519f, 
    0.09686457f, -0.03746693f, -0.24466544f, 0.04950128f, 0.15312958f, 0.13405545f, 0.03041429f, 0.02687857f, 
    -0.05329620f, 0.09210861f, 0.01851599f, 0.06220896f, 0.02873976f, -0.05074286f, 0.00116092f, -0.03564846f, 
    0.21628244f, 0.01013950f, 0.10372051f, -0.06213514f, 0.13428032f, 0.03324933f, 0.03047268f, -0.10552741f, 
    -0.02324064f, -0.13138309f, -0.06352819f, -0.05964385f, 0.07813231f, 0.04486481f, 0.29340801f, -0.05161216f, 
    0.12846796f, -0.10679556f, -0.07866728f, -0.21563295f, -0.10872574f, 0.02148088f, 0.07273665f, -0.00523821f, 
    -0.03963434f, -0.03736571f, 0.05823912f, 0.02287772f, 0.01293241f, 0.06397120f, 0.04638661f, 0.01699405f, 
    0.05960071f, 0.01309810f, -0.01914949f, 0.09328075f, 0.02981376f, -0.26196593f, 0.13475694f, 0.00348283f, 
    0.05706499f, 0.02753987f, -0.03485801f, 0.00644478f, -0.05007916f, -0.05752494f, -0.03702829f, 0.04113923f, 
    0.00773426f, 0.09536140f, -0.01245449f, 0.01485683f, -0.00541648f, -0.10239917f, -0.04831377f, -0.01208284f, 
    0.30694696f, -0.04394398f, 0.23275463f, 0.16336015f, -0.02882235f, -0.08840885f, 0.11632829f, -0.09138758f, 
    0.11681901f, 0.00264094f, -0.17048462f, 0.01212979f, 0.01336842f, 0.00368643f, 0.01667780f, 0.00430952f, 
    0.02710907f, 0.01142850f, 0.07081960f, 0.05911366f, 0.07192945f, -0.31648317f, -0.35168198f, -0.31472221f, 
    0.10980783f, -0.16791172f, -0.28830120f, -0.01340474f, -0.03931262f, -0.10783314f, -0.00486266f, 0.04450100f, 
    0.07854708f, -0.02791042f, -0.04644946f, 0.06157075f, -0.02657274f, -0.13369083f, 0.02752428f, 0.03895175f, 
    -0.18274860f, -0.36420900f, -0.40754700f, 0.14234217f, 0.06181142f, -0.10617489f, -0.19483298f, -0.07379646f, 
    0.04572212f, -0.07629938f, -0.05483992f, 0.05229719f, 0.06303895f, -0.03855242f, 0.12817398f, 0.04936076f, 
    0.03158205f, 0.05694339f, 0.08210329f, 0.02453485f, -0.22534560f, -0.07769430f, -0.06596804f, 0.24408698f, 
    0.08061196f, -0.08078610f, -0.04463935f, -0.05722704f, -0.02566762f, 0.04220889f, -0.05780660f, -0.06052887f, 
    -0.14132404f, -0.10419977f, -0.09446532f, -0.02580847f, -0.06138397f, -0.08676302f, -0.06065514f, -0.11439091f, 
    -0.01135181f, -0.15761440f, -0.00288859f, 0.17666747f, -0.02745816f, -0.17444620f, -0.21427546f, 0.05043178f, 
    -0.06011134f, -0.14820966f, -0.01413689f, 0.07025510f, 0.00697629f, 0.01260093f, 0.08641349f, 0.02017989f, 
    -0.04354921f, 0.06210886f, -0.07220431f, -0.01458197f, 0.24450688f, -0.13475198f, 0.26279590f, -0.06059347f, 
    0.11229010f, -0.00402658f, 0.02027898f, -0.11194225f, 0.05610549f, -0.04898240f, 0.01525408f, 0.00265119f, 
    -0.13046497f, 0.02809559f, 0.04297125f, -0.11516768f, 0.11542458f, -0.05195097f, -0.01591346f, -0.04274648f, 
    0.00251693f, -0.49483606f, 0.26656523f, -0.00717822f, 0.09604642f, 0.03934124f, -0.06199069f, 0.14894941f, 
    -0.00490406f, -0.12923513f, 0.07949787f, 0.00842313f, 0.11538358f, 0.11934903f, 0.02038562f, 0.08155418f, 
    0.02554586f, -0.06577080f, -0.04891546f, -0.08740577f, 0.05221768f, -0.20743665f, 0.12227547f, -0.09445605f, 
    0.09161276f, 0.01419782f, -0.04224421f, -0.17159122f, -0.00856254f, -0.00798659f, 0.00666345f, -0.02113554f, 
    0.01678832f, -0.06987735f, -0.06404875f, -0.06509531f, 0.01545878f, -0.04820714f, -0.03242239f, -0.16639973f, 
    0.24671654f, -0.16811202f, 0.32509723f, 0.03901205f, -0.14091408f, -0.04212589f, -0.03649538f, -0.20220426f, 
    0.23812161f, 0.00716342f, -0.06657105f, -0.03293702f, -0.06233884f, 0.00846810f, -0.07530535f, -0.03146461f, 
    0.08226392f, -0.00772180f, 0.13039409f, -0.03430513f, 0.30961964f, -0.06069683f, 0.22910619f, -0.01421035f, 
    -0.07535934f, -0.02878438f, -0.05033309f, -0.09626425f, -0.01410336f, -0.04137921f, -0.08318096f, 0.01586337f, 
    0.01647063f, -0.09371541f, -0.06534684f, 0.01606822f, 0.07553416f, -0.06743679f, 0.04975279f, 0.06886905f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13389900f, 0.09549175f, 0.02594014f, -0.05507489f, -0.04381769f, -0.00662374f, -0.00065834f, -0.06391849f, 
    0.00373633f, 0.00890942f, -0.01638665f, 0.00226367f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
