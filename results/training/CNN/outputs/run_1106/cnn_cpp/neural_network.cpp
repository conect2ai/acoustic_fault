#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.70442086f, 0.60788786f, -0.29780430f, -0.49541244f, 0.37208810f, 0.14406514f, -0.09950946f, 0.18067943f, 
    -0.52459139f, -0.50861961f, 0.34197706f, -0.02696534f, 0.40631956f, -0.34350920f, 0.17936039f, 0.42606351f, 
    -0.13802241f, -0.24551652f, -0.09466960f, -0.39064071f, -0.05849426f, 0.20218623f, 0.30315122f, 0.04828085f, 
    0.10638522f, -0.96013999f, -0.33522364f, -0.31812155f, -0.76807970f, -0.32260528f, 0.33318767f, 0.26553732f, 
    -0.15396744f, 0.08295970f, 0.31744868f, -0.39734283f, -0.47767970f, -0.53962463f, -0.02281439f, -0.03075557f, 
    0.31713530f, -0.11266472f, 0.09669077f, 0.16435431f, -0.46380556f, -0.13580266f, -0.17478099f, -0.18943380f, 
    -0.27847999f, -0.34969583f, 0.31395519f, 0.77276969f, 0.50166166f, 0.03634560f, -0.92670286f, -0.34339452f, 
    0.10144842f, -0.24911761f, -0.26559162f, -0.36223078f, 0.32319835f, -0.42040375f, -0.21207009f, 0.14342229f, 
    0.36413062f, -0.02451441f, 0.32092473f, 0.08986209f, 0.17486145f, -0.34534201f, -0.06244634f, 0.11135475f, 
    -0.20148957f, -0.12199429f, -0.41175479f, -0.86975479f, -0.14714146f, -0.64815301f, -0.12361900f, 0.55263686f, 
    0.33312199f, 0.31298333f, 0.00915345f, 0.21505369f, -0.09715960f, 0.32647184f, 0.19769987f, 0.17734553f, 
    -0.19553295f, -0.05107962f, -0.13854954f, -0.19352336f, -0.28361267f, 0.01839025f, -0.13073604f, -0.09368192f, 
    0.02643033f, -0.26760006f, -0.23343398f, -0.23957902f, -0.30227098f, -0.14777890f, -0.04290380f, -0.06672267f, 
    -0.27042559f, -0.38282889f, -0.70517665f, -0.37944242f, -0.54385370f, -1.04537892f, 0.37065700f, 0.59672648f, 
    -0.14319523f, -0.16777599f, -0.02505033f, -0.07531045f, -0.02230589f, -0.23330002f, -0.44409463f, -0.31507269f, 
    -0.41508752f, 0.21755056f, 0.00240536f, -0.08062760f, -0.05983896f, -0.77491081f, 0.00717191f, 0.85606933f, 
    -0.33631578f, -0.56843626f, 0.25410005f, 0.07054881f, -0.26047581f, -0.03959896f, 0.20960677f, 0.28652275f, 
    0.15521555f, -0.17288031f, -0.17446287f, -0.26256192f, -0.32536018f, -0.01353542f, 0.27998930f, -0.51466894f, 
    -0.21305136f, 0.09257575f, -0.20981574f, 0.42049962f, 0.08112600f, -0.14990127f, 0.52555406f, -0.04242389f, 
    0.09052464f, 0.44756997f, -0.28470999f, -0.17651169f, 0.22581671f, 0.32876483f, 0.15879779f, 0.39728689f, 
    0.00597071f, 0.17711967f, -0.01062037f, 0.23369123f, 0.13944264f, 0.02205815f, -0.16076331f, -0.01427583f, 
    0.06887337f, -0.17810315f, 0.16846915f, -0.30214053f, -0.27702922f, 0.40752745f, 0.10853349f, -0.64159042f, 
    -0.61359090f, -0.20894291f, -0.69176912f, -0.59274799f, 0.59587514f, 0.34700784f, 0.09081618f, 0.08241257f, 
    0.58822185f, -0.25883618f, -0.29823250f, 0.16794568f, 0.57241809f, -0.07207894f, -0.06159595f, 0.05938694f, 
    -0.03969933f, -0.08150147f, 0.24230716f, -0.00624733f, 0.15024118f, 0.53575855f, -0.04979332f, -0.02316387f, 
    -0.03809834f, 0.46206895f, 0.63763511f, -0.33413011f, -0.19643271f, -0.73655713f, -0.17992324f, -0.01428850f, 
    0.34541574f, 0.31183088f, -0.10404386f, 0.20929950f, 0.24531668f, -0.55246925f, 0.30302104f, -0.04773986f, 
    0.27297541f, -0.14946538f, -0.15546764f, -0.29591554f, -0.26813707f, 0.18061973f, 0.20936610f, 0.06710661f, 
    -0.32510450f, 1.03251588f, -0.60533023f, -0.93462414f, -0.60638690f, -1.06568027f, 0.34038413f, 0.30599964f, 
    0.34341452f, -0.05585424f, -0.15838628f, -0.20396949f, 0.30045864f, 0.34821942f, -0.15173206f, 0.31406224f, 
    -0.05299028f, -0.08819907f, 0.08358920f, -0.18539059f, -0.17606708f, -0.05189632f, -0.33553812f, -0.11593362f, 
    0.11245531f, -0.01201243f, -1.02393746f, -0.60672355f, -0.11116670f, 0.40357068f, 0.62955910f, 0.53000396f, 
    0.52661103f, 0.40438151f, 0.35839394f, 0.53630948f, -0.24350816f, 0.19192241f, -0.07664960f, 0.33265525f, 
    -0.09095680f, -0.16844043f, -0.05737365f, 0.07295260f, -0.17883873f, -0.07885622f, 0.04772004f, 0.08643202f, 
    0.10637314f, 0.34882030f, -0.20562506f, 0.47142112f, 0.79823929f, 0.72110450f, -0.47012374f, 0.35588613f, 
    -0.86059427f, -0.82175714f, 0.00283624f, 0.61382163f, -0.15140204f, -0.19173598f, -0.31246045f, -0.21319222f, 
    0.01791966f, -0.07314958f, 0.10039748f, 0.19497253f, 0.21283463f, -0.18494570f, 0.11979833f, -0.09357761f, 
    -0.11576905f, -0.36180949f, 0.21855260f, 0.03532611f, 0.04101325f, -0.30492055f, -0.00695208f, -0.13678078f, 
    0.45945448f, 0.45574385f, -0.04556813f, -0.15619642f, -0.13919951f, -0.12483994f, 0.37072629f, 0.05234803f, 
    -0.24577415f, 0.03713443f, -0.01796927f, -0.30043960f, -0.30742726f, 0.08558130f, -0.24897085f, 0.60127103f, 
    -0.40355974f, 0.24019361f, 0.40841219f, 0.24467374f, 0.15397963f, -0.51370722f, -0.63863933f, -0.15058592f, 
    -0.16988246f, 0.07665790f, -0.44594851f, -0.34001511f, -0.49103060f, -0.06334893f, -0.07858309f, 0.51267952f, 
    0.37217182f, 0.43041950f, 0.40215537f, 0.09392684f, -0.13065629f, 0.18064110f, 0.14593771f, -0.29934043f, 
    0.33064061f, 0.30454609f, 0.23635799f, -0.13591765f, -0.05154867f, 0.10571717f, -0.33131042f, -0.06952885f, 
    0.25978312f, 0.32317615f, 0.32497102f, -0.65423709f, -0.41167399f, 0.01867816f, 0.41981646f, 0.12594967f, 
    0.03174257f, -0.14331755f, -0.14001790f, 0.07433564f, 0.43534768f, -0.05155542f, -0.09731902f, -0.08182020f, 
    -0.10999239f, -0.41917440f, 0.11150499f, 0.20678955f, 0.15721484f, 0.45916674f, 0.10396957f, -0.81507391f, 
    -0.59325963f, -0.35032490f, -0.01719413f, -0.16468903f, -0.00810027f, -0.18928201f, -0.68918276f, -0.71204692f, 
    -0.37051523f, -0.37435195f, -0.08279810f, -0.21770714f, -0.37266427f, -0.38909352f, -0.13497917f, -0.08384057f, 
    -0.16269235f, -0.05116155f, -0.21731755f, -0.04521358f, 0.03187996f, 0.08319628f, -0.02189033f, 0.01191061f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.23654850f, -0.01597637f, 0.27964911f, -0.00843997f, 0.16443804f, 0.36285889f, 0.13038741f, -0.00863780f, 
    0.21789241f, 0.50816780f, 0.17453013f, 0.26365340f, 0.12182990f, -0.01081765f, 0.27260339f, -0.20610285f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.16298394f, 0.23852412f, -0.10902672f, -0.15497258f, 0.22876266f, -0.12773144f, -0.07273787f, -0.20064755f, 
    -0.00695958f, -0.19826286f, 0.00401316f, -0.19429941f, 0.04720371f, -0.15023708f, 0.04278240f, 0.24431694f, 
    0.10250555f, -0.00721835f, 0.00171720f, -0.00831864f, 0.17424011f, -0.03055865f, 0.18107958f, 0.37909698f, 
    -0.39323449f, 0.60320872f, 0.04017107f, 0.24261211f, 0.17987034f, -0.01132693f, 0.03358496f, 0.08113913f, 
    0.20609717f, 0.09753571f, -0.02547272f, 0.12131515f, 0.34537786f, -0.01008004f, -0.11129973f, 0.28935072f, 
    -0.03290422f, -0.12272061f, -0.05236227f, -0.06681568f, 0.29832101f, 0.06155210f, 0.09293699f, 0.09672540f, 
    0.16796805f, 0.12046970f, 0.01466402f, 0.23801048f, 0.12279344f, -0.03291734f, 0.14014503f, 0.30484000f, 
    0.13295501f, -0.16127630f, 0.00381498f, 0.11121192f, 0.18136080f, 0.20843951f, -0.11996532f, 0.23551314f, 
    0.16219546f, -0.04069729f, 0.00110962f, -0.12373126f, -0.03987013f, 0.15570679f, 0.02781611f, -0.06537942f, 
    -0.27239522f, -0.19134897f, -0.09634454f, -0.15722278f, -0.22222741f, -0.22556810f, -0.00602551f, -0.21547103f, 
    -0.12588762f, 0.24121314f, 0.01294635f, 0.13111067f, 0.24599949f, -0.23740859f, 0.00161244f, 0.07598300f, 
    -0.16159086f, 0.26044115f, -0.05739748f, -0.08411782f, 0.14009210f, -0.30342844f, -0.12765461f, -0.05319251f, 
    -0.22550632f, 0.07524586f, -0.16931450f, 0.11709130f, -0.05248274f, 0.07557148f, -0.02550628f, -0.23493417f, 
    0.16519023f, -0.03122346f, 0.01408058f, 0.10562485f, -0.49011427f, 0.04255999f, 0.40608102f, 0.18055667f, 
    -0.03509668f, -0.08504890f, 0.10490364f, -0.14731772f, -0.09992933f, -0.00800535f, -0.06199270f, 0.07298196f, 
    0.20632753f, 0.29577044f, -0.04426927f, -0.04621591f, 0.02637236f, 0.14109169f, 0.07626477f, -0.04676769f, 
    -0.07728622f, 0.00535772f, 0.13211277f, 0.09411906f, -0.06433056f, -0.21003692f, 0.47679925f, 0.25675663f, 
    -0.08598772f, 0.01650429f, -0.04549515f, -0.29693493f, 0.10824293f, -0.09200905f, 0.03907689f, -0.08818506f, 
    -0.05956616f, 0.16583097f, 0.14267650f, -0.47515261f, 0.10470788f, -0.21624349f, -0.19299094f, -0.06012734f, 
    -0.07987881f, -0.19234771f, -0.21683313f, -0.42147407f, 0.39620906f, -0.15106684f, 0.00514106f, -0.07848878f, 
    0.15925045f, 0.07658053f, 0.09813506f, 0.18205741f, 0.06246517f, 0.04944840f, -0.09212048f, -0.07456808f, 
    0.30887425f, -0.02065817f, 0.33568156f, 0.28107136f, -0.04123167f, -0.16193995f, 0.04333625f, -0.24017186f, 
    -0.14919430f, -0.12970126f, -0.20191948f, -0.17658094f, -0.17358372f, -0.10866091f, 0.04966253f, -0.06808802f, 
    -0.12088137f, -0.01587418f, 0.01111748f, 0.15524743f, 0.00024696f, 0.01148361f, 0.06674773f, 0.07583578f, 
    -0.01563075f, -0.00990419f, -0.00579136f, -0.03511896f, -0.02422734f, -0.04251589f, -0.05899051f, 0.00759569f, 
    0.04168830f, -0.01804004f, 0.03879685f, 0.03269956f, 0.03093026f, 0.06152658f, 0.03578397f, 0.03778677f, 
    -0.08274223f, 0.03776614f, 0.03566787f, -0.03439960f, 0.04394650f, 0.03729390f, -0.05539943f, -0.03558741f, 
    0.00196481f, 0.02809471f, 0.01185919f, -0.04893181f, -0.05594291f, -0.03651619f, -0.05188357f, 0.03231872f, 
    0.00305433f, 0.03845505f, -0.04592581f, 0.01658705f, -0.00705823f, -0.06020412f, -0.07643943f, 0.01917217f, 
    -0.02727704f, 0.01701444f, -0.06153566f, -0.00670812f, 0.00658968f, 0.02016351f, 0.03864435f, -0.06781191f, 
    -0.03666830f, -0.01763968f, -0.00861299f, -0.01961002f, 0.04887177f, 0.00765164f, -0.04990804f, 0.00520632f, 
    -0.02353986f, -0.03377953f, 0.06660562f, -0.02516139f, -0.00803963f, -0.04587998f, -0.05931244f, -0.02506943f, 
    -0.00879985f, 0.05576795f, 0.03646273f, 0.05659194f, 0.00794827f, 0.01036549f, -0.01035063f, -0.00656821f, 
    0.00801275f, -0.00097466f, 0.05258667f, 0.04732465f, 0.06481303f, -0.04716332f, -0.07110690f, -0.02974393f, 
    0.00635783f, 0.05028197f, -0.01215740f, -0.02535078f, 0.02283309f, 0.07065148f, 0.03607602f, -0.04228693f, 
    0.01803113f, -0.00995314f, -0.01231829f, 0.04132293f, -0.01449704f, 0.04044090f, -0.07681105f, -0.05920729f, 
    -0.02149471f, 0.02453019f, 0.00678126f, -0.05847122f, -0.01378050f, 0.02777977f, 0.01994454f, 0.01165148f, 
    -0.04469432f, -0.00972365f, -0.05370564f, 0.01227165f, -0.04479252f, -0.00658725f, -0.01074085f, 0.03073095f, 
    -0.00448122f, -0.00223599f, -0.05876225f, -0.04225560f, -0.00638719f, -0.08145638f, 0.04078246f, 0.03403951f, 
    -0.06426422f, -0.05122476f, 0.04769468f, 0.07907292f, 0.06906223f, -0.02833334f, -0.06306297f, -0.03351391f, 
    -0.02388101f, -0.04246191f, 0.06740881f, -0.05189686f, 0.06452294f, 0.01102668f, 0.03130328f, -0.06255575f, 
    0.00875524f, 0.05238615f, 0.05867879f, 0.06331750f, 0.01914613f, 0.02643365f, -0.06266864f, 0.02253687f, 
    -0.00532019f, -0.01689699f, -0.06614666f, -0.05683794f, 0.06775980f, -0.05593173f, -0.01656555f, -0.03401962f, 
    0.02813173f, -0.06371260f, -0.03269026f, -0.01551146f, -0.05892822f, 0.00104752f, -0.01475409f, -0.05757258f, 
    0.01832648f, -0.02333560f, -0.01728340f, 0.03818962f, 0.02283243f, -0.00673393f, -0.01662933f, -0.05029169f, 
    0.03368544f, -0.00986263f, -0.04363878f, 0.05115528f, -0.04963797f, -0.07210872f, -0.00476172f, -0.02892505f, 
    0.01934434f, -0.05591803f, 0.01698531f, -0.02379308f, -0.03905923f, -0.06025980f, -0.06053271f, 0.05248832f, 
    0.00167679f, 0.04394317f, -0.03941905f, -0.05689552f, 0.00320287f, -0.02493270f, -0.06142621f, 0.02910338f, 
    -0.18230218f, -0.36881346f, -0.31892699f, -0.42257687f, 0.00942857f, -0.01284334f, -0.09621143f, -0.06240384f, 
    -0.04578518f, 0.02234870f, 0.04792687f, -0.03430811f, 0.36765289f, 0.18730396f, 0.30977830f, 0.35392565f, 
    0.27720681f, 0.20894215f, 0.03055916f, -0.19219469f, 0.00960762f, 0.08547240f, 0.11158168f, 0.15316983f, 
    -0.28083846f, -0.28658623f, 0.12879296f, -0.17711850f, -0.00408975f, -0.10203585f, -0.25916541f, 0.08638404f, 
    -0.02331968f, -0.01644900f, -0.03768858f, 0.13716283f, 0.01781400f, -0.36895365f, -0.22931519f, 0.27440178f, 
    0.16798259f, 0.00427045f, 0.08134748f, 0.04749455f, -0.23584601f, 0.13220619f, 0.13488443f, -0.01097062f, 
    0.23911209f, 0.13700773f, -0.03030610f, 0.23385523f, -0.14685656f, -0.13308272f, 0.01848795f, 0.29611331f, 
    -0.13173771f, 0.06985900f, -0.10328391f, 0.21331115f, -0.06119087f, 0.03454051f, -0.02638032f, -0.02620568f, 
    0.00328777f, -0.00733646f, -0.16250958f, -0.07080677f, -0.09311759f, 0.14580964f, -0.10243788f, 0.10641063f, 
    -0.41380668f, -0.34680444f, -0.20354152f, -0.26315850f, -0.16348909f, -0.18527497f, 0.02174527f, -0.30643407f, 
    -0.04834786f, -0.06644525f, 0.07229764f, -0.00625082f, 0.30547053f, -0.06674238f, 0.23565626f, -0.03003545f, 
    0.08602781f, 0.30106375f, -0.00060904f, -0.01665843f, 0.21317959f, -0.04078352f, 0.13666564f, -0.04452583f, 
    -0.00994448f, -0.47123024f, -0.01723428f, -0.41475907f, 0.12324511f, -0.14877896f, -0.14926872f, 0.05986490f, 
    0.05717531f, -0.05474052f, -0.08241360f, 0.09596059f, 0.36210650f, -0.01936337f, 0.25753415f, 0.32016709f, 
    0.07964345f, 0.08632407f, 0.18277696f, -0.24187811f, 0.05429251f, -0.05347727f, 0.12701488f, 0.12402498f, 
    -0.39052144f, -0.26458815f, -0.66755593f, -0.16759510f, 0.06589430f, -0.00850529f, 0.12147311f, -0.01590968f, 
    -0.07951250f, 0.13001363f, 0.01728311f, 0.10698932f, -0.29842034f, -0.72813064f, 0.34263179f, -0.49431387f, 
    0.01043005f, -0.19993210f, -0.23397249f, -0.24590492f, 0.00380711f, -0.01224862f, 0.03067244f, 0.09923767f, 
    0.07312981f, 0.16103153f, -0.18482959f, -0.16979547f, 0.12600027f, -0.10895894f, -0.03769267f, -0.03193484f, 
    -0.02438156f, 0.00013526f, -0.08117657f, -0.06162651f, 0.02578655f, 0.12173591f, -0.00471066f, 0.32962495f, 
    0.06002028f, -0.02286642f, 0.21904147f, 0.09824926f, 0.14261568f, 0.02793509f, -0.03980450f, 0.05524989f, 
    -0.29497093f, -0.11048561f, 0.05914196f, -0.24638152f, -0.05461099f, -0.13966276f, 0.00758212f, 0.01289650f, 
    -0.04230971f, 0.00796463f, 0.02874766f, -0.16566214f, 0.35071373f, 0.30576083f, 0.30282053f, 0.27375191f, 
    -0.13292834f, -0.03852967f, 0.10163545f, -0.03424605f, 0.06882928f, -0.04526469f, -0.08155819f, 0.09736475f, 
    0.17895252f, 0.05895840f, 0.29130623f, -0.07906108f, -0.11830216f, 0.15002751f, -0.18469928f, 0.15930182f, 
    0.01479170f, -0.06866906f, 0.10840745f, 0.05047132f, -0.20360279f, 0.10088357f, 0.08543339f, -0.13277690f, 
    -0.06564219f, -0.27136448f, -0.08564483f, 0.04439178f, 0.10116637f, 0.06355226f, -0.00875163f, 0.16896608f, 
    0.15102549f, 0.32514158f, -0.04879688f, 0.19717447f, 0.22470936f, -0.01830323f, 0.07039857f, 0.03636345f, 
    -0.00525520f, -0.07499812f, -0.08984103f, -0.03882971f, -0.14740995f, -0.06035074f, -0.02440546f, 0.01994763f, 
    -0.13826853f, 0.07307177f, -0.14259663f, -0.00499120f, 0.07037839f, -0.08567966f, 0.02095154f, 0.08182608f, 
    0.07076091f, 0.22106861f, 0.40210611f, 0.23269515f, 0.10759190f, 0.13628948f, 0.09214197f, -0.05433853f, 
    0.06852433f, 0.13038397f, 0.14977492f, -0.01000034f, -0.29856834f, 0.16583008f, -0.10499284f, 0.10181050f, 
    -0.03900917f, -0.10024050f, 0.27165505f, -0.12196604f, 0.02736090f, -0.01407494f, 0.07083008f, -0.10452534f, 
    0.02102697f, -0.18894163f, -0.09296979f, 0.05482905f, 0.09194008f, 0.01348923f, -0.04149072f, 0.00456623f, 
    -0.06799044f, 0.04698840f, -0.01986409f, 0.02216199f, -0.20737548f, 0.23595318f, -0.11408574f, -0.13019860f, 
    0.03955824f, -0.18082221f, 0.05435030f, -0.08642451f, -0.08939517f, 0.14002162f, -0.03870811f, -0.11163361f, 
    -0.25895995f, 0.12932645f, 0.34824485f, 0.12283431f, 0.01044434f, 0.05839406f, 0.12830469f, -0.11914422f, 
    -0.06642807f, 0.02026233f, 0.26107576f, -0.04578004f, -0.12281522f, 0.02880220f, 0.02936898f, -0.11979413f, 
    0.03098131f, -0.10593274f, -0.06598663f, 0.26799142f, -0.10836679f, -0.01509815f, -0.10714733f, -0.07750393f, 
    -0.27738523f, 0.00019937f, -0.06262399f, 0.06395330f, 0.03080788f, -0.07172550f, -0.13252772f, -0.11022744f, 
    0.07906625f, -0.03685610f, 0.08256116f, -0.01987256f, 0.52347261f, -0.06996712f, -0.26476514f, 0.07430480f, 
    0.08887820f, 0.00232298f, 0.05381826f, 0.07497708f, -0.07669549f, -0.11097220f, -0.00434667f, 0.01025849f, 
    -0.02533221f, 0.05698314f, -0.04612742f, 0.10253650f, -0.06375850f, 0.33506799f, 0.08832210f, -0.13440007f, 
    -0.08356013f, -0.03903031f, 0.01296991f, 0.09805177f, -0.00444949f, -0.11149675f, 0.16678894f, 0.04090314f, 
    -0.01123798f, 0.14597432f, 0.09757980f, -0.03764512f, 0.01022088f, 0.04982509f, 0.02685502f, -0.15019672f, 
    -0.08215564f, -0.00294615f, 0.03411017f, 0.05129143f, 0.09837522f, 0.07270380f, -0.07471333f, 0.09270606f, 
    -0.11133723f, -0.02274677f, -0.04824532f, 0.03264878f, -0.13824433f, -0.10988113f, 0.24537081f, 0.15914576f, 
    -0.07558463f, 0.12072845f, 0.02991241f, 0.00244038f, 0.00056029f, 0.11044208f, 0.15018430f, -0.02808312f, 
    -0.07020688f, -0.21242081f, -0.19511066f, -0.20859396f, -0.03486145f, -0.04988726f, -0.07703134f, -0.24003895f, 
    -0.11597696f, 0.06834273f, -0.06923951f, -0.09296608f, 0.15277046f, -0.00699280f, 0.30885446f, 0.26341334f, 
    -0.03470911f, 0.19097856f, 0.00396682f, 0.04322022f, -0.00031707f, 0.10231064f, 0.17748336f, 0.12308773f, 
    0.03907355f, -0.44911388f, 0.05749023f, -0.36533973f, -0.00101383f, 0.00672446f, -0.07207304f, -0.06514505f, 
    0.19985071f, 0.16273831f, 0.13358171f, 0.14746183f, -0.12464431f, 0.16402434f, 0.14119442f, 0.07812428f, 
    0.12787226f, -0.19463669f, -0.02714279f, 0.06350782f, 0.09189773f, 0.14287420f, 0.14771555f, 0.25624013f, 
    -0.04030574f, -0.04418413f, -0.37362981f, -0.20788378f, -0.07637608f, -0.11651595f, -0.05471849f, -0.07334778f, 
    0.12797605f, -0.07073452f, -0.07137722f, 0.12241299f, 0.24569477f, 0.07464775f, 0.26906341f, 0.04778842f, 
    0.26740783f, 0.07805310f, -0.08711447f, 0.03507040f, 0.15034953f, 0.20991340f, 0.09473081f, 0.11235183f, 
    0.04162775f, 0.23216549f, -0.19250229f, 0.17971341f, -0.14153925f, -0.05725456f, 0.28991732f, -0.15050294f, 
    -0.15281017f, 0.00300498f, 0.12663551f, 0.07508004f, 0.07330986f, -0.17814185f, 0.48370898f, 0.13336770f, 
    -0.02246089f, 0.15599489f, -0.08891643f, 0.14875576f, -0.09288701f, -0.24662292f, -0.01819625f, -0.10246120f, 
    0.28482828f, -0.33677572f, -0.19848120f, -0.16384692f, 0.04299868f, -0.01367921f, -0.07795604f, 0.03900408f, 
    0.04406811f, 0.15831402f, -0.09879489f, 0.03603808f, 0.55090004f, 0.32777748f, 0.12726662f, 0.01893841f, 
    -0.00478222f, 0.06886174f, 0.17496698f, -0.09033374f, -0.01970530f, -0.07318766f, 0.08235941f, 0.16527244f, 
    0.10067645f, -0.23844463f, 0.16233751f, 0.12055925f, -0.14581104f, -0.14099646f, -0.06575119f, 0.01182861f, 
    -0.00606980f, 0.03644023f, 0.04491475f, 0.06986424f, -0.38534561f, -0.17760944f, 0.41507751f, -0.25626436f, 
    -0.05114543f, 0.11742644f, -0.16765988f, -0.05292570f, -0.00982554f, 0.02965353f, -0.01927466f, 0.01467440f, 
    -0.10344512f, 0.18017526f, 0.07336269f, 0.04267919f, 0.23372382f, -0.10110181f, -0.12028183f, 0.07687458f, 
    0.00377507f, -0.08180827f, -0.21785793f, -0.19369200f, -0.08223572f, -0.17670208f, -0.20372304f, -0.22716704f, 
    0.08405679f, -0.05579058f, 0.00587607f, 0.22054479f, 0.14713752f, 0.01019974f, -0.02335620f, -0.08900750f, 
    0.00876562f, -0.13113353f, -0.16749114f, 0.08169104f, -0.04598914f, 0.08009946f, 0.07012697f, -0.12839885f, 
    -0.13387938f, -0.26452935f, -0.15774491f, -0.13353664f, 0.15984192f, 0.17148134f, 0.09403457f, -0.02821312f, 
    0.09998909f, -0.05649171f, -0.00154864f, -0.05805340f, -0.07636199f, -0.07260565f, -0.15797617f, -0.06284807f, 
    0.01233028f, 0.06152900f, 0.04446847f, -0.01308623f, -0.02889262f, -0.03780267f, 0.06269360f, -0.05089593f, 
    0.02381766f, 0.02796542f, -0.05116645f, -0.01020341f, -0.01937656f, -0.05274955f, 0.03675748f, -0.01673792f, 
    0.02320688f, 0.05842634f, -0.00400044f, 0.00442748f, -0.04170497f, -0.06308290f, -0.07767074f, -0.06008587f, 
    0.04460414f, -0.07193274f, 0.06589827f, 0.04702464f, 0.04557610f, 0.03498105f, -0.00275201f, -0.04280350f, 
    0.06329838f, -0.05365690f, -0.03538997f, 0.02624549f, -0.03500529f, 0.02999404f, 0.04748535f, 0.01722298f, 
    -0.05881662f, -0.02414897f, -0.03923590f, 0.05111155f, 0.00508403f, -0.07277238f, -0.02797821f, 0.03632705f, 
    -0.03477943f, 0.05985839f, -0.05344734f, -0.02174831f, -0.07572086f, -0.03567532f, 0.00972594f, 0.05206921f, 
    0.05280190f, 0.04816171f, 0.00061926f, 0.03963261f, 0.01767675f, -0.04221044f, -0.06690609f, 0.06668950f, 
    -0.07487529f, -0.04230024f, 0.04458393f, -0.04846279f, 0.05269783f, 0.06508037f, 0.02790751f, -0.02434870f, 
    -0.01550926f, -0.06054798f, 0.04311117f, -0.02105883f, -0.07837061f, -0.04796942f, -0.01915178f, -0.03343095f, 
    0.00808407f, -0.03194578f, 0.02598969f, -0.04976828f, -0.02558563f, -0.00763058f, -0.01416645f, -0.07628887f, 
    0.02532434f, -0.00066112f, -0.05232550f, -0.03886937f, -0.03919762f, -0.07240324f, 0.00056469f, 0.04520757f, 
    0.02499093f, 0.05534991f, 0.01656302f, 0.02023382f, -0.06763978f, -0.03688805f, -0.02986305f, -0.07559298f, 
    0.04976715f, 0.06581584f, -0.05609977f, 0.04187859f, 0.01116296f, -0.05119527f, 0.06358955f, -0.01699541f, 
    0.00235129f, -0.07528115f, -0.07052242f, -0.02298431f, 0.03241356f, -0.07534933f, 0.00990291f, -0.04991234f, 
    -0.04534183f, -0.07024273f, -0.02341262f, 0.04242889f, 0.04207944f, -0.04852496f, 0.00922162f, -0.07201224f, 
    0.00060359f, -0.00075926f, 0.02131252f, 0.03200766f, 0.06429942f, 0.00340699f, 0.00242926f, 0.05870555f, 
    -0.02993482f, 0.00465780f, 0.00120782f, 0.01039316f, -0.03588372f, -0.00383434f, -0.06470867f, 0.03973677f, 
    0.03553253f, -0.06141949f, -0.06051849f, -0.02699381f, -0.04141486f, 0.00146194f, 0.00236044f, -0.07645296f, 
    -0.06270089f, 0.00363448f, -0.00452564f, -0.04008554f, 0.03784545f, 0.03564405f, -0.00199794f, -0.04179178f, 
    0.05747215f, -0.01614824f, -0.01607060f, 0.01399652f, -0.05830889f, -0.05523293f, 0.00225043f, 0.05182073f, 
    0.01527458f, 0.03013315f, -0.07479572f, 0.02700091f, -0.04206884f, 0.02149898f, 0.05705175f, -0.03525411f, 
    -0.00358580f, -0.07816992f, 0.06502946f, -0.02882461f, -0.03883673f, 0.01693847f, -0.06637697f, -0.04309001f, 
    0.03992966f, -0.01483828f, 0.01072526f, 0.03626828f, 0.02882835f, -0.02639334f, -0.04258463f, -0.06734598f, 
    -0.36118248f, 0.39504424f, -0.12633598f, 0.30750299f, 0.10290738f, 0.03655495f, -0.00732375f, -0.13673186f, 
    -0.25763303f, 0.03582368f, 0.08457252f, -0.36323845f, 0.12324110f, -0.08179767f, -0.07593238f, 0.02534010f, 
    0.09979038f, -0.01456517f, 0.08994325f, 0.17559575f, 0.06213473f, 0.06998510f, 0.13280664f, 0.22801733f, 
    0.01663558f, -0.13653946f, 0.19669391f, 0.23734985f, -0.10771766f, 0.04949353f, -0.08991564f, -0.10945806f, 
    0.19768046f, 0.04790936f, -0.04334431f, 0.06821986f, 0.41908151f, 0.26493061f, -0.29856831f, -0.18257564f, 
    0.08925116f, 0.03361948f, 0.13846818f, 0.07278074f, 0.14577992f, -0.04829488f, 0.11132526f, 0.12120054f, 
    0.13079493f, -0.01912356f, 0.04915432f, 0.21396969f, 0.08892539f, 0.00176285f, -0.03426032f, 0.11897057f, 
    0.03221732f, -0.12514055f, 0.05526439f, -0.07154504f, 0.44223800f, 0.08642181f, 0.06645587f, 0.06711057f, 
    0.05398150f, 0.17598937f, 0.04843740f, 0.07594900f, 0.11189020f, 0.16495132f, -0.02449324f, -0.06320792f, 
    -0.11078107f, -0.11061275f, -0.26166275f, -0.07349272f, -0.27201426f, -0.10801506f, -0.19642162f, -0.12973782f, 
    -0.17165373f, 0.13879335f, -0.03170947f, -0.00312020f, 0.26391408f, -0.35738954f, 0.18600504f, 0.09614350f, 
    -0.02953589f, 0.08061470f, -0.04484580f, 0.10101276f, 0.10769681f, -0.00662635f, -0.07420240f, 0.01693037f, 
    -0.05526793f, -0.08852022f, 0.11830755f, 0.03323787f, -0.39927179f, 0.04488044f, -0.04321034f, -0.29172263f, 
    0.04911313f, -0.04260293f, -0.09610030f, 0.09815957f, -0.36813027f, 0.20915735f, -0.09831435f, 0.39299572f, 
    -0.07507071f, -0.09479330f, 0.23223808f, -0.06067124f, -0.04926952f, 0.03080137f, -0.12455130f, 0.13675630f, 
    0.21789233f, 0.32688010f, -0.23235832f, -0.59592623f, 0.15532123f, 0.15984945f, -0.01463667f, 0.14918372f, 
    0.01114456f, 0.16385789f, -0.01238825f, 0.02087570f, -0.18711938f, -0.20177580f, 0.43630964f, -0.01185585f, 
    -0.21087304f, 0.25122648f, -0.07543055f, -0.08257430f, 0.08207089f, 0.03556671f, 0.16722418f, -0.17756464f, 
    -0.13602638f, 0.42024124f, 0.17856807f, -0.22257750f, 0.00649537f, -0.14204243f, -0.09981076f, -0.05078992f, 
    -0.16451652f, -0.02899366f, -0.12971067f, -0.19506344f, 0.16843794f, -0.12217987f, -0.21705858f, -0.34654522f, 
    0.15370828f, 0.16537523f, 0.00008754f, 0.10855971f, 0.06497133f, 0.17581294f, 0.17650960f, -0.03226348f, 
    -0.12731288f, 0.02131496f, 0.21806882f, 0.05063455f, -0.01744463f, 0.06970564f, -0.00762346f, -0.11940489f, 
    -0.19391838f, -0.23242213f, -0.20228571f, -0.21454787f, 0.09395155f, 0.08519685f, -0.13781165f, 0.05078934f, 
    0.13175543f, 0.01782755f, 0.00476539f, 0.06054469f, -0.20704010f, -0.10003825f, -0.01869774f, -0.07372062f, 
    -0.17988232f, 0.43210688f, 0.12289313f, 0.05215688f, 0.25700721f, -0.16928616f, 0.05425839f, -0.14087144f, 
    0.00988040f, -0.16764747f, -0.08581136f, -0.27040175f, 0.04495268f, -0.10780047f, -0.10076337f, 0.15750039f, 
    0.12150784f, 0.05072169f, 0.16874364f, 0.10435428f, 0.04996813f, -0.09021669f, 0.17746325f, 0.35208502f, 
    0.09563537f, 0.36384779f, -0.01481451f, 0.39156592f, -0.10626187f, 0.19484563f, 0.12118367f, 0.25382826f, 
    0.12589632f, -0.05736208f, -0.05928389f, 0.07167634f, 0.11949096f, 0.30030912f, 0.09376909f, 0.09705830f, 
    0.12240542f, -0.06213715f, -0.03772186f, -0.02421681f, 0.28690574f, 0.05247021f, 0.04443916f, 0.15144612f, 
    0.21603611f, 0.02663848f, 0.36983627f, 0.28708208f, 0.21568309f, -0.10296343f, 0.09200201f, 0.05417258f, 
    0.26230976f, -0.19390762f, 0.13360171f, 0.01471745f, 0.02192741f, 0.12280332f, 0.14331375f, 0.24486467f, 
    -0.07537924f, -0.00385646f, 0.13699354f, -0.08543736f, 0.14855504f, 0.07106087f, -0.08397135f, -0.10839440f, 
    -0.08489818f, -0.22804545f, -0.26529780f, -0.19831216f, -0.21885093f, -0.15196627f, -0.15766834f, -0.31684306f, 
    0.02202377f, 0.27587870f, -0.09200381f, 0.05134583f, 0.10877617f, -0.20490783f, -0.17301974f, -0.06350282f, 
    0.06707750f, 0.17105743f, -0.11659160f, 0.00403721f, -0.02167604f, -0.18615483f, -0.13202034f, 0.06228937f, 
    -0.09908406f, 0.14256592f, -0.28971469f, -0.02111865f, -0.39571527f, 0.04313401f, -0.02027102f, -0.18892549f, 
    0.10963560f, 0.01543190f, -0.02173706f, 0.02827049f, -0.43015593f, 0.25246349f, 0.07856281f, 0.29496449f, 
    -0.14326194f, -0.14486845f, 0.14933856f, 0.02477427f, -0.05841688f, 0.06942191f, -0.07275075f, 0.10465284f, 
    0.18418311f, 0.39452934f, 0.01778454f, -0.23242018f, 0.18101451f, 0.14500438f, -0.04252695f, -0.17781013f, 
    -0.13101543f, 0.06181899f, 0.05481081f, 0.19128914f, -0.32638773f, -0.24222393f, -0.18158793f, 0.27958560f, 
    -0.19712844f, 0.02628299f, -0.02737521f, -0.19576812f, -0.07892247f, 0.08407661f, -0.03273477f, -0.18877903f, 
    -0.13573386f, -0.07142675f, 0.34383839f, -0.19140129f, 0.01452126f, -0.03277070f, -0.25031576f, -0.15921058f, 
    -0.13279593f, -0.34898439f, -0.08199821f, -0.19192846f, 0.27559218f, -0.00836597f, 0.12824945f, -0.03449303f, 
    0.17057441f, 0.16707847f, -0.04168136f, 0.17306978f, 0.13847134f, -0.06161854f, -0.14010292f, -0.13403876f, 
    0.14904891f, -0.14394233f, 0.14509363f, 0.03825078f, 0.04147783f, -0.18810341f, -0.13135192f, -0.11929788f, 
    -0.14024754f, -0.00697081f, -0.05877960f, -0.22513589f, -0.14905202f, 0.02269038f, 0.09131172f, 0.15797560f, 
    0.01752501f, -0.00447920f, 0.01420156f, 0.13470183f, -0.03908132f, 0.01888578f, 0.09351797f, 0.16450699f, 
    -0.17320029f, -0.12559427f, 0.07250830f, -0.30218416f, 0.11965391f, 0.05588283f, 0.13415730f, 0.03850152f, 
    -0.01426982f, 0.04330558f, 0.01259811f, -0.07512395f, -0.11539023f, -0.21503940f, 0.09902830f, 0.00414744f, 
    -0.26010871f, 0.15080434f, 0.06673087f, 0.01286557f, 0.11925065f, 0.07190798f, 0.21711123f, 0.13321045f, 
    0.02842119f, -0.07100341f, -0.09270058f, -0.09086430f, 0.04995716f, 0.06578495f, 0.06534885f, -0.05380649f, 
    0.10631428f, -0.09397481f, 0.08733942f, 0.25676686f, -0.30984384f, 0.15184593f, 0.43333256f, 0.21313685f, 
    0.03750271f, -0.06193044f, -0.03103448f, -0.07551607f, 0.07770936f, 0.29716170f, 0.40982425f, 0.09381547f, 
    -0.26859233f, -0.32134694f, -0.41331950f, -0.40176159f, -0.01121595f, 0.05522450f, -0.03770668f, -0.21145871f, 
    0.01396788f, -0.02469628f, 0.05229744f, -0.08051714f, -0.09865832f, 0.13506567f, 0.16912544f, 0.28965694f, 
    0.15465988f, 0.08579899f, -0.26590583f, 0.03775224f, 0.13263962f, 0.23230480f, 0.24514578f, 0.07573655f, 
    0.02270324f, -0.00190661f, -0.04112528f, 0.07054752f, 0.05917678f, -0.01882603f, 0.03938211f, 0.09010262f, 
    -0.05148670f, 0.06774199f, 0.07286952f, 0.15162857f, -0.11230266f, -0.03464166f, 0.09047068f, 0.07453599f, 
    0.02029070f, 0.09755038f, -0.06068869f, 0.06003851f, 0.15813613f, 0.02110723f, -0.10131582f, 0.09115650f, 
    0.25059116f, 0.17890456f, -0.11400464f, -0.04529773f, -0.04639088f, -0.00036244f, 0.01625759f, 0.10398377f, 
    -0.14893189f, 0.06565099f, 0.01830246f, -0.03448788f, -0.29170582f, 0.34652159f, -0.04709794f, -0.13421001f, 
    -0.16657324f, 0.01567979f, 0.09706700f, 0.11837014f, 0.13064168f, 0.12988764f, -0.00748676f, 0.24185289f, 
    -0.22776328f, -0.07626207f, -0.09306042f, 0.15701130f, 0.10994538f, -0.00230176f, 0.00165883f, -0.03478041f, 
    0.09229354f, 0.11414461f, 0.23618349f, 0.08302905f, 0.05202586f, -0.10983224f, -0.08726430f, -0.12441903f, 
    0.22420047f, 0.16853188f, 0.13309561f, 0.11202157f, -0.16454965f, -0.04972915f, 0.03107193f, 0.00063031f, 
    -0.05170412f, -0.12369770f, 0.03558462f, -0.11881410f, -0.01800135f, -0.10670564f, -0.08244358f, 0.09404910f, 
    0.03880146f, -0.01535614f, 0.12166031f, -0.08044460f, -0.02382352f, -0.16583295f, -0.05412515f, -0.06223385f, 
    -0.20705317f, -0.09521783f, -0.11499876f, -0.08628272f, 0.09572047f, 0.03880879f, -0.00520498f, -0.00305726f, 
    0.22994077f, -0.23787870f, -0.18570790f, -0.05636762f, 0.18096004f, 0.11105774f, 0.03158762f, -0.01635869f, 
    0.06022255f, 0.01163098f, 0.08051141f, -0.00549571f, -0.17870790f, -0.22130211f, -0.16174813f, -0.26257765f, 
    -0.08383960f, -0.09186146f, -0.06673193f, -0.27547449f, 0.03143816f, -0.02221330f, -0.03829650f, -0.04965100f, 
    0.00224576f, -0.06550746f, 0.02955891f, -0.06871527f, 0.04157624f, -0.04250009f, 0.01576889f, -0.02450251f, 
    0.03135319f, 0.05120540f, 0.06147654f, 0.05576056f, 0.02720920f, -0.05261973f, 0.01264899f, -0.00302386f, 
    0.01033303f, -0.06339142f, -0.00041664f, 0.03553426f, -0.03342816f, 0.04102724f, -0.06956522f, 0.00600095f, 
    0.00488757f, -0.05156268f, 0.03749885f, -0.06837179f, -0.04395046f, -0.08665283f, -0.02086195f, 0.02989512f, 
    -0.04993456f, -0.07152966f, -0.05505004f, -0.07539280f, 0.03403096f, -0.01589561f, -0.05907040f, 0.04316292f, 
    -0.00692523f, 0.00024998f, 0.05775975f, 0.02551537f, -0.02201558f, -0.03787114f, 0.04106725f, 0.02582740f, 
    -0.04152419f, 0.01080582f, -0.00909837f, -0.03015454f, -0.06917980f, -0.06583256f, -0.00739434f, 0.04916098f, 
    -0.01189245f, 0.01358790f, -0.03660559f, -0.00416660f, 0.00718478f, -0.00981408f, 0.00121943f, -0.07282450f, 
    -0.07143618f, -0.07440437f, -0.01069112f, 0.04814475f, 0.02634566f, -0.00181969f, -0.04194516f, -0.06914598f, 
    0.03045350f, -0.06038607f, 0.04701344f, -0.05993449f, 0.04202919f, -0.07203029f, -0.07449192f, -0.06299809f, 
    0.03697588f, -0.08001202f, 0.04038083f, -0.07693804f, -0.04693720f, -0.07050908f, -0.01704912f, -0.04431641f, 
    -0.01212390f, -0.00319831f, -0.01889314f, 0.00925357f, 0.04798096f, 0.03937542f, 0.04084632f, -0.05417486f, 
    -0.04642346f, 0.04016799f, 0.01123675f, -0.02647319f, 0.02787608f, -0.03076222f, -0.03638058f, 0.02250046f, 
    -0.00226552f, 0.02134875f, -0.04182489f, -0.03983593f, -0.00430692f, -0.02830381f, -0.00789556f, -0.04265622f, 
    -0.07906971f, -0.01388717f, 0.01523385f, -0.03236109f, -0.03877747f, -0.00014824f, -0.05842524f, -0.07415601f, 
    0.03947958f, 0.04587834f, -0.03435656f, 0.05712030f, -0.07437269f, 0.02948262f, 0.05112069f, 0.00831358f, 
    0.01167474f, 0.05201073f, -0.06337146f, 0.03040454f, -0.01415744f, -0.02309963f, -0.06784625f, 0.05416096f, 
    -0.05331998f, -0.08230454f, -0.04718399f, -0.01848236f, 0.03106286f, 0.05387733f, 0.03803822f, -0.03256079f, 
    0.04337646f, -0.01604705f, 0.03694147f, 0.03367711f, -0.00330688f, 0.00433677f, -0.02509745f, -0.06129039f, 
    -0.03430183f, -0.05837480f, -0.00121177f, -0.02642705f, -0.04779739f, -0.04186035f, -0.03617569f, 0.02531687f, 
    0.03588653f, 0.03487058f, -0.00113647f, -0.05280548f, -0.01638754f, -0.04761586f, -0.04159972f, 0.03959654f, 
    0.00663428f, 0.02953668f, -0.03527001f, -0.04729342f, 0.05005675f, -0.01836512f, -0.03661473f, 0.02136965f, 
    -0.05020434f, -0.03754684f, -0.07216930f, -0.07352335f, 0.02055178f, 0.04388291f, 0.04061805f, -0.04864953f, 
    -0.01772365f, 0.04791053f, 0.05461093f, 0.05178802f, 0.00301802f, 0.01769305f, -0.05491799f, 0.01654937f, 
    0.05300164f, 0.04419015f, -0.23585984f, 0.16872236f, 0.16189931f, 0.06822404f, -0.02084173f, -0.02331411f, 
    -0.12592259f, -0.06985112f, -0.17685772f, -0.48783812f, 0.12698720f, 0.13515489f, -0.14279097f, -0.00775396f, 
    -0.06018371f, 0.19641489f, 0.07213397f, 0.02333148f, 0.06365198f, 0.09722645f, 0.01593424f, 0.19188128f, 
    0.04661473f, 0.34020862f, -0.45741677f, 0.37702855f, 0.06845476f, -0.11407360f, -0.14730521f, 0.08373850f, 
    0.14535487f, 0.09204235f, 0.09827372f, 0.10827144f, 0.02961259f, 0.13829035f, 0.02669610f, 0.22672527f, 
    -0.25100207f, 0.00384274f, -0.09883451f, -0.11297350f, 0.19688632f, 0.20096610f, 0.24769598f, 0.20986323f, 
    0.27356505f, 0.16101354f, 0.23753852f, 0.10767127f, 0.05114321f, -0.03922855f, 0.00811813f, -0.00222385f, 
    0.13525307f, -0.05935312f, 0.06322864f, -0.10534032f, -0.08932094f, 0.20295033f, 0.01411767f, 0.00846905f, 
    0.04631538f, -0.10837813f, 0.05402568f, -0.00654556f, 0.06983017f, -0.07222912f, 0.12293663f, 0.03421628f, 
    0.04053877f, -0.35924742f, -0.14388682f, -0.02957297f, -0.03675418f, 0.03224392f, -0.25189236f, -0.29935431f, 
    -0.04168500f, 0.21408106f, -0.10581483f, 0.29516372f, 0.08111649f, 0.03705615f, -0.41906625f, -0.19797611f, 
    -0.04991420f, -0.02433105f, 0.00074607f, -0.01760817f, 0.06479993f, -0.08193519f, -0.09465297f, -0.14867572f, 
    -0.39862260f, -0.07153956f, -0.19716351f, 0.18034612f, -0.07341661f, 0.22440594f, 0.06080183f, -0.27502307f, 
    0.11898219f, -0.30018532f, 0.20520219f, 0.29979914f, 0.01322064f, -0.02680301f, 0.07440660f, 0.07701168f, 
    -0.01217819f, -0.16559967f, -0.03021021f, 0.04238004f, -0.03732424f, 0.11358462f, -0.08703692f, 0.13193405f, 
    0.02183214f, 0.01475870f, -0.00032399f, 0.22935025f, -0.10114517f, -0.15762734f, -0.24965356f, -0.41922867f, 
    0.10854611f, 0.10303529f, -0.06764012f, 0.10597421f, 0.07057257f, 0.43337992f, -0.13241893f, 0.23536964f, 
    0.09109808f, 0.15528585f, -0.05065014f, -0.13953507f, -0.17195545f, -0.23199044f, -0.10153408f, -0.17208648f, 
    0.17545418f, -0.06887800f, -0.21789460f, -0.25253877f, -0.06467935f, 0.09314645f, -0.13573262f, 0.14127818f, 
    -0.25974289f, -0.17461309f, -0.43302462f, -0.48772013f, 0.24354047f, 0.34238231f, 0.21245231f, -0.21225484f, 
    -0.01015275f, 0.08061117f, 0.09483095f, -0.12487742f, 0.14113753f, -0.04718157f, 0.10891169f, -0.09358284f, 
    -0.33223045f, -0.12930590f, 0.21124388f, -0.16368090f, 0.27263463f, 0.12991980f, -0.19748631f, -0.02603154f, 
    -0.13625182f, -0.46680203f, -0.22248453f, -0.34724510f, 0.39338630f, 0.17438097f, -0.02646538f, -0.00960563f, 
    0.18710804f, 0.27517688f, 0.16778508f, 0.11427939f, -0.03560884f, 0.00112758f, 0.06793232f, 0.04785518f, 
    -0.53195179f, -0.10333119f, -0.08416311f, 0.09168054f, -0.02525467f, -0.15965199f, 0.12366072f, -0.01763329f, 
    0.15211953f, 0.06528284f, 0.04667280f, 0.28680056f, 0.01357826f, 0.20201133f, 0.10891724f, -0.18883106f, 
    0.03167662f, -0.15578750f, -0.16392067f, 0.24281819f, -0.15746050f, -0.14786208f, -0.13097607f, -0.20548128f, 
    -0.26277849f, -0.14483634f, 0.07970081f, -0.18352439f, 0.12817715f, 0.26612726f, 0.09847688f, -0.10623201f, 
    -0.12372809f, 0.02547571f, -0.09643794f, -0.13916951f, 0.23043898f, 0.06481615f, -0.01293954f, -0.12235855f, 
    0.05327212f, -0.03085341f, 0.01239244f, -0.07518677f, 0.04289201f, 0.05212947f, -0.23210618f, -0.07800119f, 
    0.09844173f, 0.03903055f, -0.07726055f, -0.03510559f, 0.16939472f, 0.12876104f, 0.16148289f, 0.06274896f, 
    0.06019600f, 0.09982660f, 0.01274686f, -0.05013442f, 0.48150191f, 0.09183353f, 0.19132002f, 0.04459120f, 
    0.01248521f, 0.20398274f, 0.27616438f, 0.43252504f, 0.19490024f, -0.14083351f, 0.14864394f, 0.05574796f, 
    -0.34508675f, 0.01165245f, 0.06025493f, -0.22662272f, -0.23180728f, 0.03694129f, -0.28329033f, 0.09772451f, 
    0.22363564f, 0.00917922f, 0.18057738f, 0.01960257f, -0.33371910f, -0.13776274f, -0.07140869f, -0.03854890f, 
    0.04578459f, -0.08761548f, -0.02483409f, 0.04068663f, -0.03066640f, 0.24032752f, 0.13498236f, 0.15290131f, 
    -0.12744007f, 0.30865926f, 0.02347486f, 0.15998137f, -0.14446849f, -0.16196355f, -0.00883627f, -0.03856830f, 
    0.03086952f, 0.12110979f, 0.05779251f, -0.04474478f, -0.01582281f, -0.04809575f, -0.07511524f, 0.10506232f, 
    0.13651039f, 0.14538930f, -0.04873126f, 0.15839566f, -0.05328785f, 0.01564346f, -0.05081851f, -0.01079714f, 
    -0.12555695f, -0.15765060f, 0.06377028f, -0.21225293f, -0.43360245f, -0.16149339f, -0.25413468f, -0.19511318f, 
    0.14479430f, 0.19026101f, 0.22406976f, 0.01666048f, -0.44587862f, 0.44139415f, -0.21361423f, 0.16908595f, 
    -0.13596587f, -0.13987385f, -0.04144452f, -0.02939680f, 0.02069132f, 0.01933950f, -0.09141031f, -0.06310958f, 
    0.09638215f, -0.14639759f, -0.01689355f, 0.08771385f, -0.11630248f, -0.00745055f, 0.21070370f, 0.07421420f, 
    0.17222244f, 0.15744793f, 0.08631878f, 0.03949871f, 0.24504764f, -0.18983808f, -0.16663606f, -0.32097176f, 
    0.08872933f, 0.23026474f, -0.00797593f, 0.22572769f, -0.12417810f, -0.04709846f, 0.01431069f, 0.09237058f, 
    0.02216347f, -0.04699918f, -0.02219604f, 0.04386299f, -0.10630143f, 0.19814649f, -0.05832138f, 0.11969673f, 
    0.11132545f, 0.22464466f, 0.13179979f, 0.33023459f, -0.05506016f, 0.17423809f, 0.09195712f, -0.06550560f, 
    0.21694018f, 0.05195902f, 0.17816445f, 0.16726179f, 0.09820054f, -0.07430378f, -0.03833994f, -0.07765756f, 
    0.14191265f, -0.10968795f, 0.33647636f, -0.35498649f, -0.11999504f, 0.20158720f, -0.11243290f, 0.01400052f, 
    0.00287793f, 0.00131481f, 0.05953026f, 0.07623693f, -0.32989281f, 0.03037288f, 0.26830447f, 0.14713715f, 
    0.06003117f, -0.11116034f, -0.01133012f, -0.06698298f, -0.02848139f, 0.06240306f, 0.13446136f, 0.09244347f, 
    -0.08336304f, 0.23882167f, 0.09948336f, 0.27255023f, 0.38593161f, -0.15920924f, -0.04458109f, -0.05690680f, 
    0.17264009f, 0.18032478f, -0.01246057f, 0.04766830f, -0.21861872f, -0.17615718f, 0.00588931f, -0.03274589f, 
    -0.17133102f, -0.13094325f, -0.04971473f, -0.03021210f, 0.09434385f, 0.22742648f, 0.16673100f, 0.06147653f, 
    -0.13910805f, 0.10025018f, 0.16211244f, 0.02769325f, 0.01674890f, 0.12259563f, 0.10583152f, -0.11066858f, 
    0.03160679f, -0.04765620f, 0.02783729f, -0.00602041f, -0.11478304f, 0.07720649f, -0.03790494f, 0.25906619f, 
    0.16324091f, -0.17033970f, 0.29999721f, -0.19335856f, 0.19701216f, -0.03935353f, 0.28550836f, -0.03733446f, 
    0.07689273f, 0.04674536f, -0.00952713f, 0.13947609f, 0.07496788f, -0.02558365f, 0.19438508f, 0.07233080f, 
    0.06746188f, 0.17664504f, 0.03721533f, 0.23489693f, -0.28682166f, -0.03111279f, 0.11759483f, 0.06510300f, 
    -0.04345849f, 0.08799448f, 0.15864727f, 0.13563804f, -0.00310598f, -0.10287880f, -0.15776224f, 0.06531955f, 
    0.10593394f, 0.04517021f, 0.20776425f, 0.13197418f, 0.15549225f, 0.11985869f, 0.06326678f, -0.05215862f, 
    0.01423451f, 0.22955346f, 0.22568974f, 0.00230540f, -0.08128235f, -0.01010379f, 0.13765730f, -0.05152659f, 
    0.00739790f, 0.06104656f, 0.01761589f, 0.01603970f, 0.02919177f, -0.05434764f, 0.02498429f, 0.08478232f, 
    -0.28952545f, -0.19493972f, -0.05540427f, 0.16014622f, -0.01096821f, -0.15424407f, 0.06035924f, 0.10028090f, 
    0.20932132f, -0.03382847f, 0.06640796f, 0.06766322f, 0.61521006f, -0.25459874f, 0.43632537f, 0.08645037f, 
    0.10113683f, 0.06434802f, -0.03370335f, 0.10446903f, -0.03238406f, -0.07888457f, -0.00632870f, -0.10066131f, 
    0.17475143f, 0.06249542f, -0.16524100f, -0.06613494f, 0.12003668f, 0.09517564f, -0.01932569f, 0.01135752f, 
    -0.10084174f, -0.06437110f, -0.09485696f, -0.01300557f, -0.02612610f, -0.43324000f, 0.00183037f, -0.04335771f, 
    -0.06996626f, -0.07923045f, -0.14129479f, -0.05610711f, 0.11657718f, -0.09270022f, -0.09734237f, -0.18987857f, 
    0.33118698f, -0.13505630f, -0.08950663f, 0.06935439f, 0.15867081f, -0.07955489f, -0.08496027f, 0.03623256f, 
    0.01930937f, 0.06650677f, 0.03405147f, 0.01735973f, -0.35753503f, -0.12559456f, 0.20391974f, -0.01665429f, 
    -0.07054063f, 0.00129449f, 0.02894297f, -0.20087841f, 0.07819051f, 0.04633617f, -0.13663733f, -0.09032167f, 
    -0.12096874f, -0.01612469f, 0.20180947f, -0.25207430f, -0.24573301f, 0.09005455f, -0.15664254f, 0.08045812f, 
    -0.15539488f, 0.14698915f, 0.01957374f, 0.00040332f, 0.22957766f, -0.09799690f, 0.00038389f, 0.09528459f, 
    -0.11132032f, -0.07973870f, 0.04712261f, 0.12503012f, -0.07992286f, 0.01567624f, 0.09157072f, 0.21631514f, 
    -0.13973494f, 0.11156465f, 0.21473511f, 0.08237556f, -0.08392007f, 0.13541414f, 0.03801642f, -0.01999824f, 
    0.25004494f, -0.00753233f, 0.08705216f, 0.30314997f, 0.19255884f, 0.06491413f, -0.02820266f, -0.06851214f, 
    0.07007796f, -0.00523444f, -0.04908528f, -0.04747170f, -0.05095684f, 0.24367435f, 0.36843789f, 0.10651843f, 
    -0.30255485f, -0.29714203f, -0.23733808f, 0.05093961f, -0.06002619f, -0.06036049f, 0.00206003f, 0.06879839f, 
    0.10189326f, 0.09892251f, 0.06359930f, -0.01055258f, 0.24627076f, 0.16692066f, 0.17282483f, 0.05768070f, 
    0.02262547f, 0.05853540f, 0.09851237f, 0.15414666f, 0.09867179f, 0.28248590f, 0.25227556f, 0.06933057f, 
    -0.05220826f, -0.04839244f, -0.09851498f, -0.02321929f, -0.04072084f, -0.14980534f, -0.02356507f, -0.11908612f, 
    0.08074303f, 0.01968000f, -0.06273166f, 0.11455997f, 0.34084162f, -0.01324280f, -0.04243235f, 0.01162378f, 
    -0.19914821f, 0.07118316f, -0.00384413f, -0.09477263f, 0.04287492f, -0.09877761f, -0.21600774f, 0.00415877f, 
    0.25684470f, 0.16774330f, 0.28093332f, 0.10050916f, 0.33110428f, 0.18424907f, -0.04982159f, -0.03577869f, 
    0.18463935f, 0.14079167f, 0.17581934f, 0.11067639f, -0.29322016f, 0.03284647f, 0.11646492f, -0.09352773f, 
    -0.04795152f, 0.05604721f, 0.30152178f, 0.13998666f, -0.06450297f, 0.08534384f, 0.02694708f, 0.07579362f, 
    -0.10458472f, 0.14478374f, -0.34522048f, 0.01057607f, 0.01330866f, 0.03467092f, -0.12446546f, -0.03301752f, 
    -0.10957722f, -0.09067530f, 0.03928304f, -0.00869699f, 0.32420465f, 0.03906377f, 0.29094729f, -0.01452175f, 
    0.13550642f, -0.12736191f, 0.10620069f, -0.10058015f, -0.00380781f, -0.10871249f, 0.03884902f, 0.01388148f, 
    0.13772537f, 0.22980532f, -0.00376221f, -0.19839884f, 0.28730184f, 0.18178342f, -0.09144338f, 0.09758367f, 
    -0.09226469f, -0.19328371f, -0.04713648f, -0.20015851f, -0.14111914f, -0.29084703f, -0.28111848f, -0.11402647f, 
    0.01588966f, -0.14206031f, -0.09420055f, 0.08946093f, 0.03163371f, 0.12962423f, -0.07164533f, -0.25444931f, 
    0.31432679f, 0.23960613f, -0.17954125f, 0.22578917f, 0.26744190f, 0.04738062f, -0.07879969f, -0.18800572f, 
    0.05181684f, -0.01674237f, 0.12432918f, -0.00248984f, -0.35952118f, -0.25397211f, -0.18856761f, -0.26571271f, 
    0.00312861f, -0.12406970f, -0.12202984f, 0.00578891f, 0.06745669f, -0.02654632f, -0.08188394f, -0.00428165f, 
    0.01134447f, -0.01615038f, -0.10277904f, -0.11976409f, -0.00912865f, -0.02852532f, 0.25315902f, -0.06755957f, 
    -0.00847007f, 0.10949712f, -0.07664559f, 0.16950412f, 0.09011468f, 0.14843330f, 0.02011412f, -0.25971010f, 
    0.16487469f, 0.11892904f, 0.16299674f, 0.22017427f, -0.01403773f, 0.11401362f, -0.06919917f, -0.24784480f, 
    0.13618223f, -0.31801024f, 0.04811521f, -0.14719053f, -0.12034390f, 0.12613799f, 0.10411003f, 0.09725025f, 
    -0.23580956f, 0.01515026f, 0.09010299f, -0.05501159f, -0.17713378f, 0.15056005f, 0.07548308f, -0.08072925f, 
    -0.04518153f, 0.02925254f, -0.08730467f, -0.13868627f, -0.16777822f, 0.08396220f, 0.00880616f, -0.07503664f, 
    0.04095770f, 0.05158704f, -0.10212826f, -0.11022221f, -0.13075176f, 0.07103788f, -0.05305585f, -0.10559171f, 
    -0.11405152f, 0.09509937f, 0.07147367f, 0.14882815f, -0.01399306f, -0.16433197f, 0.17221098f, -0.14243874f, 
    -0.15653116f, 0.18876648f, -0.11362324f, 0.34687859f, 0.15783313f, 0.09754582f, -0.01664294f, 0.09605358f, 
    0.24387431f, 0.08094683f, 0.02528589f, 0.00163395f, -0.04381568f, 0.07902075f, 0.05154254f, -0.05721167f, 
    0.19556285f, -0.11479362f, 0.09442542f, 0.01521659f, -0.28360167f, -0.28767571f, -0.26439330f, -0.18436018f, 
    0.15838473f, 0.10127780f, -0.03455417f, 0.06281746f, -0.15109858f, -0.03158726f, -0.02205068f, 0.04928083f, 
    0.43813431f, 0.22935931f, 0.14494352f, 0.12232188f, 0.06689802f, 0.12619282f, -0.04390490f, 0.13967948f, 
    -0.06744254f, 0.09419254f, 0.08109686f, -0.01870818f, 0.32521912f, -0.18298934f, -0.21828038f, -0.17835836f, 
    0.06156721f, 0.18791746f, 0.11016969f, 0.26080227f, 0.13694955f, 0.04461108f, -0.04143605f, -0.01741112f, 
    -0.04134700f, -0.17795283f, -0.18571500f, 0.01253112f, -0.12544779f, -0.06602975f, -0.09581208f, -0.11032054f, 
    0.22238013f, 0.06321374f, 0.21313426f, 0.11358789f, 0.05318103f, 0.52276450f, 0.07966487f, 0.02327639f, 
    0.21664532f, -0.19669913f, -0.05789502f, -0.01550688f, -0.02721077f, 0.02039539f, -0.08448333f, 0.06426158f, 
    -0.01133083f, -0.13290153f, -0.08546490f, 0.11887957f, 0.06348974f, 0.14915808f, 0.00796951f, 0.07241195f, 
    0.17398070f, 0.03277305f, 0.03135422f, 0.19796370f, -0.24521789f, -0.05072049f, -0.09690278f, -0.25269872f, 
    0.00712618f, -0.08678146f, 0.08519823f, -0.05087252f, -0.10552288f, -0.25403041f, -0.18579075f, -0.01051607f, 
    0.06397662f, 0.11589838f, -0.13079865f, -0.18213113f, 0.10518946f, 0.14906856f, -0.07759777f, -0.10921337f, 
    0.07092404f, 0.11103190f, 0.12750478f, 0.05924547f, 0.28715599f, 0.27998126f, 0.08589266f, -0.09932619f, 
    0.18369208f, 0.00489169f, 0.02574685f, 0.03589768f, 0.10231689f, -0.02599231f, -0.00418585f, 0.04703797f, 
    0.04777598f, 0.00324936f, -0.00020553f, 0.02975337f, -0.05047218f, 0.02893267f, -0.01170111f, -0.05143616f, 
    0.05627664f, -0.01316436f, 0.06377850f, -0.00358743f, 0.04083931f, 0.00547486f, -0.06820481f, -0.05050486f, 
    0.00462623f, -0.05705262f, 0.03818572f, 0.00317442f, 0.02065322f, 0.03896093f, -0.02365955f, -0.05115776f, 
    -0.00828027f, -0.00492443f, 0.05139704f, -0.06497500f, -0.05385081f, 0.00345788f, -0.02899046f, 0.05546042f, 
    0.00073520f, 0.00567819f, 0.02422337f, 0.01008921f, -0.04290810f, -0.02809955f, -0.06404860f, -0.03370411f, 
    -0.04190951f, 0.00179437f, -0.00080833f, 0.05257212f, 0.01208281f, -0.06144915f, 0.00386069f, -0.03095068f, 
    0.04390440f, 0.05583329f, -0.07187753f, -0.06069599f, -0.04297144f, 0.04147420f, 0.05225579f, 0.04074107f, 
    0.05183649f, -0.06004639f, 0.05795861f, 0.00988655f, -0.04359925f, -0.05487586f, -0.01916890f, 0.05854338f, 
    -0.06848858f, 0.00711226f, -0.01315208f, -0.05162552f, -0.07132434f, 0.02424298f, 0.03634923f, -0.01616537f, 
    -0.00919025f, 0.04100423f, -0.04915375f, 0.02837989f, 0.01774802f, -0.00181398f, -0.07612099f, -0.05791730f, 
    0.06764516f, -0.06623842f, 0.03091281f, -0.07273820f, 0.02084385f, -0.05742855f, -0.02607531f, -0.02421845f, 
    -0.04479745f, -0.05642252f, 0.01493717f, -0.01367989f, -0.04298511f, 0.02138285f, 0.05372684f, 0.04860672f, 
    -0.06817147f, -0.01609571f, -0.01695225f, 0.01750624f, -0.08011115f, -0.02219847f, -0.04103108f, 0.05607933f, 
    -0.07502176f, -0.01798684f, -0.07646925f, 0.03462002f, -0.05730865f, -0.00603654f, -0.05168162f, 0.00605827f, 
    -0.05876227f, 0.03477037f, -0.00973145f, 0.03979787f, -0.03068541f, 0.04939577f, -0.07663521f, -0.07751501f, 
    -0.01302680f, -0.03811527f, 0.04905160f, -0.07835538f, -0.04451295f, -0.02773291f, -0.05071637f, -0.05067804f, 
    -0.01183099f, -0.04232768f, 0.01341963f, -0.07226355f, -0.08092482f, -0.01689588f, 0.05519851f, 0.04014400f, 
    -0.05054925f, 0.02111585f, -0.04769260f, 0.01416626f, 0.01378563f, -0.04927894f, -0.02084422f, -0.02921872f, 
    0.00819945f, -0.01257641f, -0.03193736f, 0.04589892f, 0.02836554f, -0.02045454f, -0.06729431f, 0.04373782f, 
    0.05033837f, -0.00046181f, 0.04137622f, 0.03948604f, 0.00819070f, 0.05430157f, 0.03322646f, -0.05525837f, 
    -0.02921831f, 0.00237918f, 0.05957146f, 0.02534722f, -0.01440561f, -0.07635343f, 0.01707922f, -0.00562445f, 
    0.03580141f, 0.05313246f, 0.03332103f, 0.05024046f, -0.04625533f, 0.05797139f, 0.03501349f, -0.00056457f, 
    0.05809209f, -0.00058083f, -0.07713712f, 0.02527665f, -0.01740166f, 0.02854201f, 0.06675782f, -0.03331300f, 
    0.04417872f, -0.04667905f, 0.04087666f, -0.05429986f, 0.03818639f, -0.04283541f, -0.06842133f, 0.01720353f, 
    0.26720718f, -0.29093844f, 0.16880429f, -0.07635575f, 0.06767387f, -0.16007672f, 0.04518614f, -0.09395469f, 
    -0.00731345f, 0.05029070f, -0.04301995f, 0.03942615f, -0.10866447f, 0.06540641f, 0.11306110f, 0.26749671f, 
    0.00963369f, 0.11806749f, -0.07221344f, -0.08451727f, 0.00054574f, 0.06171865f, 0.01931220f, -0.03446580f, 
    0.14300193f, 0.03214663f, -0.05340424f, -0.08212162f, 0.18572645f, 0.15975925f, 0.05900003f, -0.08064435f, 
    -0.10240538f, 0.13035265f, -0.19632345f, 0.04230718f, -0.11002363f, -0.10976437f, 0.46556807f, 0.17615454f, 
    -0.14111574f, -0.10914870f, -0.07073431f, -0.05768438f, 0.00779611f, 0.10772518f, -0.06287794f, 0.08619712f, 
    -0.20790593f, -0.12503764f, -0.01812105f, 0.01937034f, -0.05036332f, 0.03424553f, 0.01617868f, 0.16472954f, 
    -0.12555836f, -0.00226859f, -0.06115220f, 0.05121872f, -0.01058895f, 0.14434412f, 0.10765430f, 0.07765691f, 
    -0.02742377f, -0.06168402f, 0.09252013f, -0.12132689f, 0.12930930f, -0.10816542f, 0.08056273f, 0.17363080f, 
    0.04387841f, 0.06537289f, 0.08837120f, 0.02775296f, -0.09736061f, 0.04188782f, -0.04630060f, 0.02124353f, 
    0.22331874f, 0.04339327f, 0.12740344f, 0.14815818f, -0.17530836f, 0.16576357f, 0.16049416f, 0.06912650f, 
    -0.11428103f, -0.12729841f, 0.20803167f, -0.01544454f, -0.04193320f, -0.14537871f, 0.02160580f, 0.02701820f, 
    0.11859292f, 0.01448563f, 0.11113665f, -0.00134575f, -0.04157352f, 0.09080821f, 0.05105476f, -0.04196291f, 
    -0.07324202f, 0.04615215f, -0.04359373f, 0.06879329f, 0.25315055f, 0.22991236f, 0.35990557f, -0.24317271f, 
    0.06809736f, -0.00218839f, 0.05272258f, 0.01700738f, 0.16334142f, 0.10899483f, -0.04707842f, 0.00356222f, 
    -0.03156193f, -0.00937094f, 0.04097958f, 0.07300662f, -0.13137712f, -0.07782502f, -0.04666332f, 0.00818919f, 
    0.27939275f, 0.12379407f, 0.23727322f, 0.24311322f, 0.09272840f, -0.02726419f, -0.22755460f, 0.16456959f, 
    -0.02725896f, 0.00381512f, 0.24308257f, -0.05546239f, -0.05762665f, -0.04833149f, -0.02076879f, -0.01965684f, 
    0.13454902f, -0.10819140f, -0.07318259f, 0.02725346f, 0.22871901f, -0.17732407f, -0.03389904f, 0.04887346f, 
    -0.06438699f, -0.09152396f, 0.10468686f, 0.04033405f, -0.36403474f, -0.08017278f, -0.08003306f, 0.10997792f, 
    -0.09017428f, 0.01728269f, 0.22426899f, 0.14140439f, -0.11115925f, -0.05730529f, -0.06288425f, 0.00080759f, 
    -0.13214958f, 0.12170884f, -0.31018722f, -0.06720559f, 0.03653540f, -0.07609451f, 0.05348523f, 0.00572513f, 
    -0.05923126f, -0.06789108f, 0.06154665f, 0.02400891f, -0.17237791f, -0.29577267f, 0.01406290f, 0.20965955f, 
    -0.26051706f, 0.07391038f, -0.05032177f, -0.00371223f, 0.03667479f, 0.04989112f, -0.02858521f, -0.05689975f, 
    -0.33720699f, 0.00401461f, 0.02723040f, 0.10622142f, 0.19367433f, -0.14506575f, 0.16010050f, -0.23412356f, 
    0.02497511f, -0.07257101f, 0.05482066f, -0.01090462f, 0.12298740f, -0.21429251f, -0.00509709f, 0.18118608f, 
    0.00717681f, 0.12928031f, 0.09034673f, 0.10867994f, -0.05884304f, 0.00569883f, 0.06414768f, 0.01649295f, 
    -0.10464466f, -0.20083943f, 0.31632867f, 0.17593785f, -0.06924494f, 0.14644144f, 0.08467638f, 0.10876365f, 
    0.16572043f, 0.05971227f, -0.10513520f, -0.00910103f, 0.34402537f, 0.13312890f, 0.12054700f, -0.03192808f, 
    0.16539356f, -0.05572586f, 0.12462563f, 0.01824835f, 0.06129910f, -0.01202372f, -0.12902269f, 0.02260767f, 
    -0.16930263f, -0.32974792f, -0.10409648f, 0.02169211f, 0.03450401f, -0.12447128f, 0.04090520f, 0.26633567f, 
    0.08482020f, 0.00846787f, 0.00985311f, -0.01773587f, 0.47145492f, 0.14478676f, 0.17936878f, 0.31938264f, 
    0.12771851f, 0.18736069f, -0.04150992f, 0.02350509f, 0.16206482f, 0.22395480f, 0.07820594f, 0.21783280f, 
    -0.23592271f, 0.03551938f, -0.17419036f, -0.19874337f, -0.06943370f, -0.01740946f, -0.14555675f, -0.11089170f, 
    -0.03007101f, -0.02532611f, -0.01117419f, -0.15007031f, 0.16520621f, -0.07724634f, 0.41935432f, 0.36683285f, 
    0.06304372f, 0.07694104f, 0.16732295f, 0.26105088f, -0.08374559f, -0.03479879f, -0.04977113f, 0.17387016f, 
    0.26624748f, 0.06072499f, -0.24118830f, -0.10294436f, -0.10770094f, -0.04461839f, -0.13384075f, 0.02532475f, 
    0.03475545f, -0.01090632f, -0.20278984f, -0.04723494f, -0.29891032f, 0.36700106f, 0.07079478f, 0.27683255f, 
    0.05275157f, 0.16360287f, 0.13078645f, -0.06180518f, 0.14109330f, -0.02612472f, 0.09426531f, 0.06412654f, 
    0.11527162f, 0.19301182f, -0.24489705f, -0.43177277f, -0.05741322f, 0.03467396f, -0.03639142f, 0.14692719f, 
    0.02839656f, 0.15420279f, 0.05103157f, 0.21717177f, -0.28114721f, -0.19494696f, 0.09042819f, -0.00867167f, 
    -0.09269936f, -0.09076683f, 0.12413244f, -0.06819417f, -0.04181012f, 0.06360953f, 0.05608398f, -0.01228268f, 
    -0.13225412f, -0.12840423f, 0.09829377f, -0.09125416f, -0.01621642f, -0.27236021f, -0.02694490f, 0.14246769f, 
    0.03569216f, 0.11187527f, 0.18094286f, -0.00745974f, -0.15963781f, -0.29430875f, -0.33041885f, 0.14377542f, 
    0.08381563f, 0.03131948f, -0.01236930f, 0.10877774f, -0.11824884f, 0.01441191f, -0.06129143f, 0.06208906f, 
    0.21301205f, -0.00165319f, -0.34172410f, -0.10456803f, -0.15152156f, -0.09083393f, 0.01420791f, -0.08768516f, 
    0.05547909f, -0.02256139f, 0.01922361f, 0.07090860f, -0.37494361f, -0.24169238f, -0.25955310f, 0.09845895f, 
    -0.06490271f, -0.06182661f, 0.00919664f, 0.00635869f, -0.02784491f, 0.00636926f, 0.01955503f, 0.15084478f, 
    0.08226584f, 0.01169770f, -0.02790254f, 0.18234695f, 0.04781842f, -0.04142421f, -0.08513349f, -0.03414671f, 
    -0.08836708f, -0.10457186f, -0.01245803f, -0.03629346f, 0.35504270f, 0.02656557f, -0.20317726f, 0.34087980f, 
    0.10954392f, 0.04140118f, -0.10498224f, -0.15792932f, 0.03484428f, 0.04894215f, 0.00926131f, 0.20261662f, 
    -0.07400176f, 0.41556114f, 0.03431710f, 0.10003544f, -0.09426691f, -0.02515728f, 0.02665061f, 0.13590144f, 
    0.00770961f, 0.06322838f, 0.01242448f, 0.07845193f, 0.32333401f, -0.24316670f, -0.09188727f, 0.28091949f, 
    0.03968700f, 0.09064291f, -0.17348038f, -0.13648745f, 0.00295301f, -0.07940529f, 0.04765259f, 0.16947371f, 
    0.26086763f, 0.07909603f, -0.06207173f, 0.13106020f, -0.03456336f, -0.05117791f, -0.01638157f, 0.51354855f, 
    -0.03889297f, 0.15040879f, -0.02616420f, -0.13489228f, -0.02644954f, 0.16631593f, -0.14664841f, -0.08815050f, 
    -0.08919499f, 0.00579124f, -0.10465962f, -0.06425581f, -0.11887347f, -0.05768412f, -0.16379799f, 0.07346048f, 
    -0.11369356f, -0.00936333f, 0.10399277f, -0.09399732f, 0.05931070f, -0.01032311f, -0.21855347f, -0.11150591f, 
    -0.10077880f, 0.01542753f, 0.17227587f, 0.03118459f, 0.39299440f, 0.26226723f, -0.23460886f, -0.12926409f, 
    -0.06671641f, 0.12036519f, 0.01458123f, -0.00022219f, -0.00507144f, -0.21926858f, -0.02311180f, -0.02366207f, 
    -0.16094048f, 0.07607408f, 0.04139141f, -0.01334692f, 0.08010948f, -0.00443751f, 0.02583888f, -0.38551044f, 
    -0.05212075f, -0.15410574f, 0.12825018f, 0.15036374f, -0.21573821f, -0.14488135f, 0.42725432f, 0.20671827f, 
    0.02587242f, -0.15645388f, 0.03505348f, -0.07177280f, -0.16543129f, 0.05683788f, -0.03580317f, 0.07504511f, 
    0.26420373f, 0.41629034f, 0.03838167f, 0.11046054f, 0.09155990f, 0.09085790f, 0.09147052f, -0.07285455f, 
    -0.02534171f, -0.08693853f, -0.02188789f, 0.07678817f, 0.15135397f, 0.19158304f, -0.10259702f, 0.19402684f, 
    -0.04848511f, -0.12592702f, 0.15044476f, -0.09416208f, 0.06498378f, -0.04581662f, 0.07140128f, -0.09296491f, 
    0.03865610f, 0.15459134f, 0.00124216f, -0.21513470f, -0.00229107f, -0.09794091f, 0.02884682f, 0.09578077f, 
    -0.14312324f, -0.12001289f, -0.03381801f, -0.16687293f, -0.04152403f, 0.47095340f, -0.00995373f, 0.15609865f, 
    0.13169011f, -0.02048173f, 0.19588351f, 0.07961950f, -0.02740177f, 0.06715361f, -0.09560447f, -0.06392315f, 
    0.00774804f, 0.33478466f, 0.16022867f, -0.05067164f, 0.18255353f, -0.28551438f, 0.00080972f, -0.07525087f, 
    -0.06518725f, -0.14309384f, -0.05669080f, -0.13742688f, 0.16383743f, -0.11525674f, -0.12490305f, 0.06728634f, 
    -0.13844851f, 0.20448264f, 0.02339331f, 0.21802650f, 0.05196147f, -0.05945088f, 0.02107251f, -0.01341181f, 
    0.23782870f, 0.04062237f, -0.12664203f, 0.11050294f, -0.00456874f, 0.22990608f, -0.02531003f, 0.07591196f, 
    -0.00609252f, 0.07504283f, 0.08592366f, 0.01502094f, 0.43090209f, 0.41521826f, 0.32847172f, -0.01061949f, 
    0.23681980f, -0.04433654f, 0.21737008f, 0.20751818f, -0.04405878f, -0.03886058f, -0.07381932f, -0.09116738f, 
    0.23137721f, -0.15274397f, 0.34640878f, -0.11365161f, -0.19286802f, -0.06289501f, 0.01066487f, 0.17101583f, 
    -0.09621392f, -0.02843576f, 0.10623489f, -0.11163112f, -0.27866858f, 0.08524439f, -0.13927433f, -0.05607809f, 
    0.23201217f, 0.12392367f, -0.08884338f, -0.12618127f, -0.07297941f, -0.25905079f, -0.03834162f, -0.05438262f, 
    0.14705151f, 0.06065795f, 0.06076460f, 0.02007271f, 0.00053122f, -0.01386831f, 0.03194913f, -0.07240275f, 
    -0.08860298f, 0.04547978f, -0.12448968f, -0.01195018f, 0.08757181f, -0.05531026f, 0.22829334f, -0.14771922f, 
    -0.05030839f, 0.03399860f, 0.07536579f, 0.24233046f, 0.05323646f, 0.09092879f, -0.10821756f, 0.01826534f, 
    -0.10576876f, -0.08878708f, -0.05086472f, -0.11584795f, 0.00582812f, -0.10658833f, -0.12550682f, -0.04611035f, 
    0.06267925f, 0.08493657f, -0.09199757f, 0.04583934f, -0.15671532f, 0.04769611f, -0.08525664f, -0.19573316f, 
    0.21311100f, 0.00560270f, -0.00713817f, -0.14290263f, 0.08087072f, 0.25914076f, 0.13806275f, -0.06285152f, 
    0.12314506f, -0.06723882f, 0.47513172f, -0.06413565f, 0.09867945f, -0.08784548f, 0.21728499f, 0.09497891f, 
    -0.06888714f, 0.25294951f, -0.25051335f, 0.05905680f, 0.28223264f, 0.00077938f, -0.02574323f, -0.08064939f, 
    -0.09216598f, 0.10612895f, 0.03221789f, 0.24475473f, -0.02066914f, -0.02257581f, -0.10553588f, -0.10862220f, 
    -0.51932985f, -0.16184597f, -0.05431714f, -0.13273549f, 0.03136383f, 0.02902301f, -0.09027912f, -0.18389796f, 
    0.04187620f, 0.01822348f, 0.03010515f, 0.08760993f, 0.43562108f, 0.02429601f, 0.14256400f, -0.17096761f, 
    -0.18429761f, -0.25464380f, -0.29277697f, 0.04174834f, -0.00791421f, 0.06617083f, -0.15563725f, -0.00162877f, 
    -0.12034540f, 0.11107188f, -0.29367721f, 0.13501535f, 0.07017486f, 0.19011173f, -0.00193285f, 0.12879305f, 
    0.31819296f, 0.25648963f, 0.14745507f, 0.18176046f, -0.09730892f, -0.12915201f, -0.07467331f, -0.13017924f, 
    0.14004321f, 0.16108009f, 0.15522914f, 0.09848434f, -0.03576472f, 0.07584580f, -0.05592684f, 0.01545983f, 
    -0.13621680f, 0.06432692f, -0.02070539f, 0.03232256f, -0.03569566f, 0.13796051f, 0.10703283f, -0.00144975f, 
    0.18302087f, 0.05914663f, 0.01613869f, 0.05945181f, 0.21807756f, 0.33204970f, 0.10743760f, 0.17383878f, 
    0.18144324f, -0.02108824f, 0.02464330f, 0.11989853f, -0.02655366f, -0.03533888f, -0.16708462f, -0.09657849f, 
    -0.02681273f, 0.14014353f, 0.36268443f, -0.14093207f, -0.04007704f, 0.08809488f, -0.13625218f, -0.09119984f, 
    -0.12924065f, -0.02598154f, -0.01098758f, -0.23626441f, 0.11686742f, -0.14747368f, -0.02233506f, 0.13205746f, 
    -0.10261639f, 0.01030804f, 0.27202550f, 0.03187399f, -0.00446759f, 0.13028811f, 0.24593581f, 0.13884401f, 
    0.21665117f, -0.25120980f, 0.43228593f, 0.08157060f, -0.02646259f, -0.02592972f, 0.13215797f, 0.08900598f, 
    0.11611935f, 0.10064333f, 0.17683783f, 0.07924496f, 0.02570634f, 0.10979344f, 0.11783872f, -0.11306035f, 
    0.20770498f, -0.06183179f, -0.07171258f, 0.03475344f, 0.12320975f, 0.24118394f, 0.25169170f, 0.16285099f, 
    -0.30657083f, -0.33457163f, -0.11704130f, -0.02583713f, -0.09819411f, 0.09610701f, 0.06412448f, 0.13945462f, 
    0.09365752f, 0.03868155f, 0.01055745f, -0.16460639f, 0.19263735f, -0.07147340f, 0.22864525f, 0.16733958f, 
    0.09176496f, 0.16991964f, -0.04190532f, -0.22900328f, 0.00383801f, 0.34946004f, 0.14054780f, 0.03192892f, 
    0.15126409f, 0.10481380f, -0.20939265f, -0.05199041f, 0.09810653f, -0.10172043f, -0.02700074f, -0.19770518f, 
    -0.19236657f, -0.01250864f, 0.05060986f, 0.05749334f, 0.21100275f, 0.04044654f, 0.36450195f, 0.29618067f, 
    -0.08055556f, 0.01924668f, 0.09904639f, -0.02526626f, -0.20794116f, -0.16807659f, -0.24905178f, -0.03604725f, 
    0.41667953f, -0.07685857f, 0.08894650f, -0.17633104f, 0.00733573f, 0.11454961f, -0.04391773f, -0.04328911f, 
    0.00557376f, 0.15701570f, 0.01173270f, 0.06580792f, -0.01218224f, 0.38359451f, 0.06409134f, 0.13473049f, 
    -0.08503934f, 0.19252697f, 0.20187362f, 0.03350220f, 0.00875436f, 0.00386180f, 0.06286719f, 0.11028840f, 
    -0.07249526f, 0.21606697f, -0.41950271f, -0.20210432f, 0.22792611f, -0.06659248f, 0.04356536f, 0.15374790f, 
    -0.16668540f, -0.02994785f, 0.13366853f, 0.28979200f, 0.23893633f, -0.39121139f, 0.47995266f, -0.22125678f, 
    -0.12824519f, 0.00654177f, 0.07774691f, 0.04158244f, -0.04253506f, 0.04592205f, 0.12072778f, -0.15397727f, 
    -0.17146970f, 0.12296946f, 0.10604174f, 0.11947739f, 0.12834685f, 0.00496264f, -0.12143807f, 0.10152363f, 
    -0.28396705f, -0.22625273f, 0.06492210f, -0.11517093f, -0.40319914f, -0.44312364f, -0.30481455f, -0.09552003f, 
    -0.01782687f, -0.02862414f, 0.05203170f, 0.03551279f, 0.09457473f, 0.11554565f, -0.13179411f, -0.20566878f, 
    0.28543857f, 0.16798098f, -0.16476196f, 0.08489030f, 0.01377224f, -0.12777449f, 0.03229387f, -0.17369345f, 
    -0.12394720f, -0.13720705f, -0.06634311f, -0.24005520f, -0.26114330f, -0.13063189f, -0.15272492f, 0.11937796f, 
    0.00054164f, -0.02157192f, -0.02008529f, -0.08176724f, -0.07224451f, 0.05104487f, -0.07951940f, -0.16063361f, 
    -0.12146027f, -0.02300839f, -0.10355490f, 0.17150925f, -0.00484587f, -0.00570101f, 0.01919748f, -0.12474654f, 
    -0.11855119f, 0.00805986f, -0.03381941f, 0.14226691f, 0.42850253f, 0.17411077f, -0.07815900f, 0.05431069f, 
    0.21620460f, 0.01101739f, -0.02022858f, -0.10851216f, 0.04436698f, -0.15585375f, -0.07715088f, 0.02348008f, 
    -0.28791288f, -0.01890704f, 0.29322168f, 0.06958025f, -0.02955962f, 0.13437229f, -0.05917622f, 0.16774729f, 
    -0.05580280f, 0.04295301f, 0.08616683f, -0.07714733f, 0.20562354f, -0.08985804f, -0.25484732f, 0.00720914f, 
    -0.02805267f, -0.02296738f, -0.02332442f, -0.05508884f, -0.10231882f, -0.20721699f, -0.13361338f, -0.01389164f, 
    0.27005571f, 0.08543687f, -0.15861319f, 0.09124181f, 0.16777357f, 0.03482833f, -0.02308478f, 0.37172541f, 
    -0.00736356f, 0.16173260f, -0.05167232f, 0.04141680f, 0.12402931f, -0.07868422f, -0.13118984f, -0.09874057f, 
    -0.03142887f, 0.05059746f, -0.02199656f, 0.12772669f, 0.03616612f, 0.07180562f, -0.21610510f, 0.20008387f, 
    -0.17762844f, -0.04590089f, 0.13976721f, 0.00895815f, 0.01127540f, -0.02158220f, -0.06287969f, -0.06470555f, 
    0.14795779f, 0.11829390f, 0.15015569f, 0.08257377f, 0.02866183f, -0.22073384f, -0.24826179f, -0.18427233f, 
    0.20543982f, 0.22794129f, 0.05444799f, -0.06614897f, -0.13158651f, -0.07884534f, -0.05474349f, 0.00165088f, 
    -0.00939994f, 0.18993834f, 0.00607204f, 0.08609024f, 0.18551478f, -0.00659186f, -0.03543617f, -0.11203624f, 
    -0.04430218f, 0.00351481f, -0.05836231f, 0.21076736f, -0.08673809f, -0.40970412f, 0.13647865f, 0.23644733f, 
    0.08628345f, 0.04823383f, 0.08694062f, -0.00205122f, -0.05682920f, -0.01478789f, -0.06692273f, -0.08037665f, 
    0.17135213f, 0.19903612f, -0.02691771f, -0.03487634f, -0.04426323f, 0.14179362f, 0.05257845f, -0.13880417f, 
    -0.04630953f, -0.15974638f, 0.01652981f, 0.15590847f, -0.00146550f, 0.29617459f, 0.36288154f, 0.23823649f, 
    -0.07007600f, -0.19316189f, -0.06797627f, -0.12647104f, 0.03753251f, -0.06381958f, 0.05275508f, -0.01891888f, 
    0.02994931f, 0.12726125f, -0.04639794f, -0.14993200f, 0.01015573f, 0.01536972f, -0.00872047f, 0.01977801f, 
    0.01091173f, 0.04413098f, -0.06576596f, -0.00168339f, 0.11350470f, 0.24563815f, -0.05428964f, -0.04690168f, 
    0.21720017f, 0.16412932f, 0.21610235f, 0.25288206f, -0.07162032f, 0.01531272f, -0.04052432f, 0.05439146f, 
    0.13377619f, 0.07144507f, 0.22822848f, 0.00242345f, 0.17609949f, -0.05758090f, -0.07200190f, -0.09241267f, 
    0.01711803f, 0.02825340f, 0.07739478f, 0.09646197f, 0.21497341f, 0.27562919f, -0.05087694f, 0.02781983f, 
    0.14801988f, 0.05273252f, 0.11233013f, 0.15888506f, 0.04081478f, -0.00031596f, -0.09189086f, 0.11989027f, 
    0.04882789f, 0.17317379f, -0.31923106f, -0.27559608f, 0.11938120f, -0.00606372f, 0.05699218f, 0.14690325f, 
    -0.09112273f, 0.00497758f, -0.16340400f, -0.32134196f, -0.06190721f, -0.07459864f, -0.13990006f, -0.18767305f, 
    -0.04058768f, 0.20459646f, 0.04204804f, 0.11835220f, 0.01833942f, -0.01591930f, 0.12390518f, 0.30122250f, 
    0.25357720f, 0.29245493f, -0.33699349f, 0.00918188f, -0.09716230f, 0.17119865f, 0.06694093f, 0.17997505f, 
    -0.05640674f, 0.12654486f, 0.18164425f, 0.25406954f, 0.10184823f, 0.34682897f, 0.14689986f, 0.14538403f, 
    0.02460415f, 0.12802677f, -0.09998157f, -0.06462086f, 0.20033240f, 0.18117088f, 0.28396073f, 0.22022782f, 
    0.32604438f, 0.29205671f, 0.01390542f, -0.10915019f, 0.03508731f, -0.02901344f, -0.02932842f, -0.11847597f, 
    0.10759874f, 0.02460124f, 0.10281347f, -0.15890628f, -0.18895222f, -0.02407303f, 0.15132047f, 0.06776197f, 
    -0.17847762f, 0.12784995f, 0.00301557f, 0.08347695f, 0.09139063f, 0.17617202f, -0.04701448f, 0.02500881f, 
    0.10622176f, -0.22241455f, -0.08767369f, -0.01407899f, 0.22937797f, -0.04166508f, 0.06796909f, 0.00620115f, 
    0.07441663f, 0.16314639f, 0.04147434f, 0.07779789f, 0.05592720f, -0.09171939f, -0.51467794f, -0.29688755f, 
    0.07333773f, 0.05594266f, -0.17763703f, 0.03099806f, 0.04049698f, -0.15798189f, -0.14385848f, -0.10471480f, 
    -0.22770213f, 0.07775094f, -0.38223732f, 0.18958232f, -0.26128000f, 0.12663352f, -0.09568416f, -0.01222462f, 
    0.15871428f, -0.05769017f, 0.08702149f, 0.06103538f, -0.08595031f, 0.02243363f, -0.00258769f, -0.21480240f, 
    0.04127041f, -0.05584890f, 0.03007123f, 0.22684853f, -0.05617572f, 0.04631277f, -0.01935401f, -0.00470499f, 
    0.20690107f, -0.07759865f, -0.05864638f, 0.20384851f, 0.14596200f, -0.14737099f, -0.08569748f, -0.01471379f, 
    0.01238212f, 0.06364231f, 0.12615258f, 0.01598977f, -0.12395345f, 0.29445234f, -0.56014144f, 0.02946136f, 
    0.15643632f, 0.05805011f, 0.02279182f, -0.03897889f, 0.14956197f, -0.07488797f, 0.11160563f, -0.06926647f, 
    0.06202447f, -0.21253663f, 0.27422917f, -0.06799503f, 0.00390857f, 0.17997526f, -0.12273466f, -0.08598054f, 
    -0.13139956f, -0.42253280f, -0.12292112f, -0.13357542f, 0.41368544f, 0.35153583f, 0.29596695f, -0.24742518f, 
    0.00484487f, 0.21722318f, 0.12990610f, -0.09296241f, 0.14756928f, -0.23568647f, -0.12532364f, -0.17202421f, 
    -0.10762648f, -0.04693788f, 0.20588189f, 0.11923914f, 0.20410016f, 0.14012548f, -0.19196798f, -0.10132434f, 
    0.13710126f, -0.28044617f, -0.16816403f, -0.20088771f, 0.41898316f, 0.23566678f, -0.06928816f, -0.20096101f, 
    0.07948115f, -0.02872500f, -0.01885144f, 0.08298562f, -0.02644010f, -0.01089666f, 0.14705542f, 0.05098256f, 
    -0.24330543f, 0.25924185f, -0.02615734f, 0.09636536f, 0.17680696f, 0.28485292f, -0.02135926f, 0.08477554f, 
    -0.02761346f, 0.04266099f, 0.05513125f, 0.02304401f, 0.30238485f, 0.03004083f, -0.40666726f, -0.17627408f, 
    0.06211913f, 0.09063390f, 0.19197632f, 0.08181965f, -0.03136505f, -0.06579284f, -0.06117081f, -0.02782338f, 
    -0.03601352f, -0.01224701f, 0.15408340f, 0.40331239f, -0.15809110f, 0.22565340f, 0.13055460f, 0.30058202f, 
    -0.12400712f, -0.14954711f, 0.00583354f, -0.09975840f, 0.08081863f, 0.07611080f, -0.09545639f, -0.30154222f, 
    -0.02569037f, 0.06384877f, 0.00062593f, -0.16836445f, -0.11463234f, -0.02375133f, -0.09808330f, -0.01777891f, 
    0.30872992f, -0.10096447f, 0.26650023f, 0.13393733f, 0.14928237f, 0.05557566f, 0.14521283f, 0.17330985f, 
    0.02542795f, 0.07246500f, 0.09530295f, -0.11020831f, -0.15533672f, -0.07693869f, -0.08256768f, 0.06577747f, 
    0.02454839f, 0.01973689f, -0.00933471f, 0.03987551f, -0.00080927f, 0.07982957f, -0.19136211f, 0.15390971f, 
    -0.00683810f, -0.06432858f, 0.00661735f, -0.07899496f, 0.08024340f, 0.00963475f, -0.13802405f, -0.05248768f, 
    0.10850409f, 0.15151739f, 0.07066946f, -0.08385763f, 0.00617092f, -0.07354736f, -0.33005622f, -0.21768761f, 
    0.23224922f, 0.03216888f, 0.05088432f, 0.08417005f, -0.02646871f, 0.21474549f, -0.02450175f, -0.00103652f, 
    0.10475495f, 0.32896918f, -0.02208789f, 0.03952023f, -0.10880651f, -0.13704199f, 0.05373010f, -0.00294124f, 
    -0.06791606f, -0.08172220f, -0.02001730f, 0.00047498f, -0.16920811f, -0.36845106f, -0.19694073f, 0.28411376f, 
    0.02430441f, -0.01332093f, -0.08320884f, 0.31504983f, 0.00435060f, 0.09153271f, -0.09327839f, -0.12987693f, 
    0.03564205f, 0.17388006f, -0.20864755f, -0.26222628f, 0.14044756f, 0.10069272f, -0.02961220f, -0.15727323f, 
    -0.01303743f, 0.05890996f, 0.08691505f, 0.15603627f, 0.19308338f, 0.16230211f, -0.07094818f, 0.05440711f, 
    -0.14282878f, -0.06440001f, -0.06979657f, -0.02201826f, -0.09733869f, 0.00313027f, 0.04850341f, -0.10852111f, 
    -0.06585734f, -0.05482339f, -0.03561126f, 0.08745202f, -0.01444599f, 0.37666166f, -0.02225126f, 0.02019585f, 
    0.11568082f, -0.01687949f, 0.07812062f, 0.21406773f, 0.04813387f, 0.10537694f, -0.01587233f, -0.17737873f, 
    0.08434576f, 0.13587965f, 0.16605954f, -0.00426789f, -0.10742915f, 0.07697319f, -0.05174121f, 0.01582278f, 
    0.12993549f, 0.13831623f, 0.17838058f, -0.25135887f, 0.09098155f, -0.08945413f, -0.07596327f, 0.02368804f, 
    0.06175072f, 0.01048103f, 0.14740348f, 0.00069482f, 0.20923996f, 0.14569937f, -0.09836297f, 0.17657402f, 
    0.14768796f, 0.15504509f, 0.07037599f, 0.02022725f, -0.07030028f, -0.11309598f, 0.02174857f, 0.03996686f, 
    0.06191109f, 0.05611402f, -0.07525112f, -0.06674033f, 0.00341059f, -0.04435740f, 0.00838587f, 0.05441894f, 
    -0.00144787f, -0.06381115f, -0.03622038f, -0.02790092f, -0.00031610f, -0.07760348f, 0.03526198f, 0.04005054f, 
    0.01813829f, -0.01082721f, -0.07132038f, 0.01307329f, -0.00316631f, -0.07774393f, 0.05661809f, 0.01232347f, 
    -0.05954773f, 0.01886121f, 0.05765887f, 0.01637176f, 0.05235697f, -0.02862669f, 0.02544337f, 0.00114455f, 
    -0.06969376f, -0.01416154f, 0.05949321f, -0.03438863f, -0.01066403f, -0.06896762f, 0.00197210f, -0.04678602f, 
    0.00175872f, -0.05371123f, -0.04119817f, -0.02515623f, -0.01313593f, 0.05082556f, 0.01079758f, 0.03023656f, 
    -0.01038090f, -0.05788524f, -0.03703605f, -0.07900179f, 0.00449432f, -0.07599641f, 0.02436560f, 0.04996513f, 
    -0.04421314f, -0.02776209f, -0.05305714f, -0.01382536f, 0.02483051f, 0.00428968f, -0.01031462f, -0.07394464f, 
    -0.06598381f, -0.06240259f, -0.03820580f, -0.07241612f, -0.02444956f, -0.06398671f, -0.08033155f, -0.05263612f, 
    0.03551532f, -0.05891357f, 0.03422318f, -0.06945144f, -0.05831925f, -0.05785155f, -0.02125431f, -0.06954766f, 
    -0.03212377f, -0.05744350f, 0.03938827f, 0.05258919f, -0.05906356f, -0.05788830f, 0.00106471f, -0.02712220f, 
    0.03469144f, -0.02135863f, 0.04877746f, -0.04627641f, -0.01443260f, 0.04835353f, -0.03667059f, -0.02016072f, 
    0.04564268f, -0.04176312f, -0.05321710f, -0.03266935f, -0.06962544f, 0.06220241f, -0.03145429f, -0.05251427f, 
    -0.02475527f, -0.07622553f, 0.05003368f, 0.02129944f, 0.02342469f, -0.07357049f, 0.01648583f, -0.05583626f, 
    -0.06726410f, -0.07327745f, 0.02143041f, 0.02560508f, 0.03811242f, 0.01155832f, 0.02031136f, -0.04410587f, 
    -0.06066404f, 0.05987037f, 0.06191069f, -0.06601071f, 0.02466263f, 0.02096917f, 0.01597152f, 0.02563148f, 
    0.01052283f, 0.04679599f, 0.01911058f, -0.00316485f, -0.03305323f, -0.05251224f, -0.01085671f, -0.01702392f, 
    -0.00282991f, -0.01559517f, 0.01363875f, 0.01018200f, 0.03019970f, -0.03059707f, -0.06612805f, 0.03278655f, 
    -0.04924915f, 0.05385651f, -0.00407755f, 0.01215745f, 0.04384255f, -0.02225318f, 0.01668463f, -0.07509859f, 
    0.00277092f, -0.01463949f, -0.00816736f, -0.06874000f, -0.06136288f, 0.00240537f, 0.06195565f, 0.03054824f, 
    0.02001250f, -0.04675382f, -0.07142048f, 0.05014653f, 0.04942821f, -0.01009088f, -0.01101490f, 0.02109431f, 
    -0.05204707f, -0.06210333f, -0.00972264f, 0.02470129f, -0.04934811f, -0.06378068f, -0.07703049f, 0.00129154f, 
    -0.06629514f, -0.06690051f, -0.05030457f, 0.05292286f, -0.01089773f, 0.00242464f, 0.02966241f, 0.00614566f, 
    0.05270192f, -0.05727069f, -0.07074921f, -0.03882675f, -0.00583663f, -0.05399518f, 0.00856265f, -0.06154858f, 
    0.04884948f, -0.03941833f, -0.09567067f, -0.10255988f, -0.10345695f, -0.11855262f, 0.11252402f, 0.03388653f, 
    0.12748145f, 0.07127827f, -0.09625293f, 0.07065758f, -0.04636452f, 0.13732140f, 0.27938065f, 0.11001668f, 
    0.21486217f, 0.07703619f, -0.01817142f, 0.12165409f, 0.07219863f, -0.11441319f, 0.01180563f, -0.18098110f, 
    -0.11904540f, 0.28182045f, 0.01225730f, -0.33532181f, 0.05996131f, -0.00329993f, 0.01563783f, 0.18945573f, 
    -0.05347369f, 0.08173515f, 0.15209740f, 0.02063954f, -0.07163988f, -0.17650785f, -0.13918963f, 0.15032579f, 
    -0.11301350f, -0.07770704f, -0.05945557f, -0.02861418f, -0.05338554f, -0.07775483f, 0.02439768f, 0.06653183f, 
    -0.19109151f, 0.07543538f, -0.23153542f, 0.03546441f, 0.02475473f, 0.00067912f, -0.01400443f, 0.12878689f, 
    -0.00247345f, -0.02587529f, -0.17209750f, 0.15059343f, -0.07067563f, 0.05514085f, 0.08941968f, -0.20574789f, 
    -0.11436363f, 0.07055220f, -0.12696923f, 0.35183659f, 0.17799602f, 0.00099429f, 0.07517271f, 0.03328103f, 
    0.10507720f, 0.12350896f, 0.23138376f, 0.10322110f, 0.01854205f, 0.11943012f, 0.09420019f, -0.05865953f, 
    0.11855897f, 0.00290834f, 0.14040866f, 0.11086246f, -0.09620139f, -0.17645405f, -0.10595389f, -0.15622951f, 
    -0.12311309f, 0.08118021f, 0.01952515f, -0.06527685f, -0.03543374f, -0.19662318f, 0.07017723f, -0.13622086f, 
    0.01821990f, 0.03700734f, 0.08259935f, 0.19339731f, 0.26293048f, 0.03945499f, -0.13276747f, -0.00342624f, 
    0.11520855f, 0.08143081f, 0.08091300f, 0.00843038f, 0.17087735f, -0.08556136f, 0.31172338f, -0.41679347f, 
    0.03062253f, -0.00372951f, 0.23511826f, -0.10345092f, 0.05453324f, 0.11189134f, -0.04455332f, -0.05274718f, 
    0.06810056f, -0.09231877f, 0.03486409f, 0.25188103f, -0.09065010f, -0.02442774f, -0.09652664f, -0.02209747f, 
    0.06582111f, -0.05087994f, 0.10062134f, 0.01988550f, 0.04428403f, 0.31408051f, 0.15290765f, 0.24262443f, 
    0.19961226f, -0.09547206f, 0.01988302f, -0.08327916f, 0.00688403f, -0.01976267f, 0.04098498f, -0.02562712f, 
    0.09094800f, -0.05381669f, 0.05630191f, -0.18777193f, 0.17898402f, 0.06370741f, 0.07686193f, 0.04813794f, 
    0.11100502f, 0.02446619f, -0.06421770f, -0.16375326f, -0.09053391f, 0.02583577f, -0.07009545f, 0.00551085f, 
    0.18492395f, -0.04922406f, 0.01397723f, 0.01612084f, -0.11779211f, -0.07486938f, -0.01343393f, -0.02871636f, 
    0.08065058f, 0.07326549f, -0.03042624f, 0.24877486f, 0.20724870f, 0.03456799f, -0.03075976f, -0.11784514f, 
    -0.05458144f, 0.00739553f, -0.02442563f, 0.02499183f, 0.17365378f, 0.11321710f, 0.23073167f, -0.17445630f, 
    0.00477267f, -0.11888634f, -0.02606157f, 0.21351342f, 0.11303744f, -0.12643452f, -0.04429963f, 0.01940006f, 
    -0.23235644f, 0.24019463f, -0.39120597f, 0.01063782f, 0.25936192f, 0.00806651f, 0.15386611f, 0.02110632f, 
    0.07406283f, -0.02541622f, -0.08713254f, -0.01146792f, -0.02317820f, 0.01220018f, -0.03547475f, -0.28817073f, 
    0.04712023f, 0.01471341f, 0.09743985f, 0.28434289f, -0.05989320f, -0.13907431f, -0.07712501f, -0.02708663f, 
    0.09024007f, 0.01285542f, -0.09296639f, -0.02308838f, -0.01518731f, 0.20512873f, 0.11524215f, 0.20553096f, 
    -0.03465076f, -0.03184206f, 0.09726418f, 0.11806548f, 0.12713806f, 0.27872887f, 0.18973771f, 0.01788381f, 
    0.01780795f, -0.02691320f, -0.00632879f, -0.06811750f, 0.04248411f, 0.01412528f, -0.01524722f, 0.01492662f, 
    0.10376902f, 0.16525555f, -0.13519822f, -0.09789324f, 0.18144740f, 0.03969216f, 0.04539050f, -0.07876834f, 
    0.13740207f, -0.14716318f, 0.03541774f, -0.07527933f, 0.03412118f, 0.00438422f, 0.14870082f, -0.08456578f, 
    -0.00432887f, 0.24494240f, -0.08125081f, 0.30529410f, 0.25181729f, 0.08106095f, 0.01879716f, 0.09839941f, 
    -0.08861408f, -0.03434899f, -0.07097101f, -0.05462374f, -0.06762695f, 0.00341308f, -0.02399495f, 0.00245378f, 
    0.00260986f, 0.04604452f, -0.01459681f, 0.02310939f, -0.24500518f, -0.29817778f, -0.42739075f, -0.18384722f, 
    0.03535083f, 0.11334059f, -0.04037951f, -0.00206471f, 0.01953102f, 0.07984799f, 0.10443176f, 0.05255862f, 
    0.04254793f, 0.03425035f, -0.35627249f, 0.36285618f, -0.24092640f, 0.02020315f, -0.04799682f, 0.11708954f, 
    0.17860110f, -0.04796878f, -0.07628923f, -0.02214182f, -0.02201373f, 0.08425227f, -0.07268262f, -0.22823323f, 
    -0.02263630f, 0.00787995f, 0.03364465f, 0.10361911f, 0.01905588f, 0.01525732f, -0.04162269f, -0.10510764f, 
    0.23660836f, -0.06131727f, 0.18206279f, 0.06441712f, -0.06577075f, -0.05246636f, -0.13744441f, -0.08760875f, 
    0.07780559f, -0.03226555f, 0.15952624f, 0.04454953f, -0.56303370f, 0.25547200f, -0.40513569f, 0.20484720f, 
    0.06265825f, -0.05249817f, 0.11993247f, 0.08685417f, 0.06093248f, 0.01752102f, -0.00364397f, -0.02295073f, 
    0.01841015f, -0.13538979f, 0.22154111f, -0.12928347f, -0.10438981f, 0.10610745f, -0.06739543f, -0.00421838f, 
    0.27933493f, 0.06004185f, 0.11179437f, 0.09124014f, 0.23138151f, 0.02328422f, 0.09819993f, -0.25103787f, 
    0.08706085f, 0.14129701f, 0.00781716f, 0.00882778f, 0.01624698f, -0.03429056f, -0.05729178f, 0.03880288f, 
    0.05925878f, -0.18615355f, 0.02983025f, 0.18775265f, 0.03991978f, 0.22963028f, -0.03156764f, 0.11412247f, 
    0.06368775f, -0.02962313f, -0.05670748f, 0.08849643f, 0.08875258f, 0.25144672f, 0.01404524f, -0.23963287f, 
    0.12977512f, -0.11157554f, 0.05492117f, 0.19860564f, -0.04805720f, -0.02822042f, -0.00996501f, 0.08528604f, 
    0.21525735f, 0.03809999f, 0.06047443f, 0.22926863f, 0.02874598f, -0.10020281f, 0.20117213f, -0.02100357f, 
    0.04466059f, 0.02988116f, -0.00122391f, 0.15809004f, 0.01813349f, 0.00743576f, 0.01685690f, 0.01510671f, 
    0.05152671f, -0.00168918f, -0.14197798f, -0.06261104f, -0.02670784f, -0.06139871f, -0.22005267f, -0.13088341f, 
    -0.01142063f, 0.22146206f, -0.09622058f, 0.08324276f, 0.18378794f, -0.00649450f, -0.09543856f, 0.03065820f, 
    -0.00205307f, 0.07968914f, -0.15482368f, 0.00993411f, 0.47657692f, -0.32588553f, -0.09079688f, -0.16440040f, 
    -0.16611588f, -0.08243670f, -0.12061780f, 0.07235169f, 0.11433785f, -0.04054453f, -0.14215365f, 0.07239639f, 
    -0.09252392f, 0.03345532f, 0.27585602f, 0.30882782f, -0.02968499f, 0.00586167f, 0.11580449f, 0.32093680f, 
    -0.15871149f, 0.04556061f, 0.03352129f, 0.04794020f, 0.19267029f, 0.07065049f, 0.00053860f, 0.03672558f, 
    -0.06099899f, -0.09431835f, 0.10192171f, 0.04507018f, -0.08826268f, -0.16988498f, -0.04981307f, 0.01188757f, 
    0.07506257f, 0.15972051f, 0.05053158f, 0.00157415f, -0.06522439f, 0.11325998f, -0.08667462f, -0.10799974f, 
    0.15382421f, 0.00662479f, 0.09322958f, 0.00782717f, 0.17771070f, 0.27699578f, 0.03829234f, -0.10801420f, 
    -0.16576165f, -0.23500012f, 0.12907834f, 0.17853278f, -0.10346036f, -0.05290494f, 0.15415476f, -0.06768134f, 
    -0.26753962f, -0.09981013f, 0.17112513f, 0.05021111f, 0.00759153f, 0.04245969f, 0.10458347f, -0.09056830f, 
    0.06675994f, -0.03711438f, 0.11516382f, 0.11964840f, 0.05457707f, -0.02469742f, 0.15651962f, -0.06255072f, 
    -0.00770809f, -0.08315464f, -0.00185043f, -0.08786093f, 0.17979006f, 0.11765691f, 0.06735291f, -0.16193944f, 
    0.34784013f, 0.22235034f, 0.08820903f, -0.05365278f, -0.13976504f, -0.01029102f, -0.00378259f, 0.03023238f, 
    0.06797311f, 0.06566571f, 0.05170394f, -0.10348485f, 0.09701382f, 0.26389405f, 0.00868016f, 0.21454906f, 
    -0.20613843f, -0.06886737f, 0.04081572f, -0.16731574f, 0.01544956f, 0.00964085f, 0.07242361f, 0.06498321f, 
    0.12863101f, 0.10960475f, -0.01711245f, 0.15542811f, 0.07011748f, -0.05234484f, 0.15366821f, 0.01335049f, 
    -0.05397315f, 0.13973166f, 0.03089464f, -0.09576441f, -0.16407990f, -0.01232322f, 0.03601561f, 0.01639479f, 
    0.08122720f, -0.06615031f, 0.07279728f, 0.02672782f, -0.18642519f, -0.04584083f, 0.00535040f, 0.04577646f, 
    -0.21231803f, 0.09498361f, 0.05920327f, -0.02077374f, -0.05046671f, 0.01070694f, -0.00329802f, 0.00711108f, 
    -0.01371637f, -0.05286541f, 0.04404441f, 0.09706032f, -0.10931139f, -0.18983604f, 0.19224127f, 0.25739703f, 
    -0.09036624f, -0.00491901f, 0.05636529f, 0.21068884f, -0.07888430f, -0.13208383f, 0.00876402f, 0.01189465f, 
    -0.04129773f, -0.05243869f, -0.02395804f, 0.06088767f, -0.01391357f, -0.01849481f, -0.06224704f, 0.03918570f, 
    -0.00708895f, -0.03239770f, 0.02154095f, 0.00111537f, -0.07448269f, 0.01617193f, -0.00576485f, 0.04571120f, 
    -0.05041653f, -0.04282080f, 0.01109469f, 0.01041101f, -0.08053610f, -0.05515685f, 0.05089981f, -0.06656344f, 
    -0.00317153f, -0.05049139f, -0.05731214f, 0.05315758f, -0.00256907f, 0.00626142f, -0.01240355f, 0.04235290f, 
    -0.02199801f, -0.05722940f, -0.04367348f, -0.04638809f, 0.06303718f, -0.04057732f, 0.03125677f, 0.02260843f, 
    -0.04133831f, 0.06042256f, 0.01847748f, 0.02307451f, -0.00948698f, -0.01019984f, -0.05881054f, -0.04557841f, 
    -0.05041382f, 0.04979314f, -0.07008441f, 0.00428468f, -0.06910217f, 0.04251916f, -0.01617072f, 0.01421178f, 
    -0.04971236f, -0.05645876f, 0.01024334f, -0.08053195f, 0.05227213f, 0.04450338f, -0.03556288f, -0.02866768f, 
    0.03400429f, -0.06923102f, -0.07588490f, -0.00601526f, 0.06285954f, 0.05837891f, -0.04425641f, -0.06028155f, 
    0.00141969f, -0.01063584f, -0.00592106f, 0.01602576f, -0.05432108f, 0.03938107f, 0.00378811f, -0.00042107f, 
    0.05751495f, -0.06718985f, -0.01666402f, -0.06527784f, -0.05643732f, -0.00242908f, 0.04243578f, 0.03476486f, 
    -0.05759610f, -0.04575394f, 0.00490681f, 0.02381201f, -0.02715477f, -0.05998483f, 0.01282883f, -0.01384240f, 
    -0.06805223f, 0.00672268f, -0.01363754f, 0.05824306f, -0.06141527f, 0.03928174f, 0.02786521f, -0.00808893f, 
    -0.07736801f, -0.01787723f, -0.01761724f, 0.02769624f, -0.06151460f, -0.03551327f, 0.01887427f, -0.07570183f, 
    0.06244536f, -0.06172195f, -0.07297249f, -0.07425943f, 0.00643040f, -0.07152843f, -0.00062403f, -0.05481247f, 
    0.01468564f, -0.00252999f, 0.03838314f, 0.03246565f, -0.06901618f, -0.00027621f, -0.04843923f, -0.03638497f, 
    -0.03903255f, -0.07401925f, 0.02062617f, 0.05319503f, 0.02069462f, -0.01901703f, -0.07220443f, -0.06116949f, 
    0.03377734f, 0.01450877f, 0.05279355f, 0.05216779f, 0.00961653f, 0.00023367f, 0.03221763f, -0.00779331f, 
    -0.01984170f, 0.06042171f, -0.01600538f, -0.05612250f, 0.06082536f, -0.06433222f, 0.04502446f, 0.03132286f, 
    -0.05159120f, 0.00510605f, -0.07352573f, 0.05524601f, 0.02614716f, 0.03960868f, -0.00690512f, 0.05414677f, 
    -0.06119584f, -0.05480817f, 0.06735000f, 0.06700505f, 0.02919696f, -0.04773133f, -0.04738140f, -0.07736767f, 
    0.00905246f, 0.00617434f, -0.06186770f, -0.04236731f, 0.06307263f, -0.06935894f, 0.05348810f, -0.01519211f, 
    -0.06421790f, -0.06126117f, 0.00416342f, -0.05877273f, -0.02511955f, -0.02944837f, -0.06798398f, 0.03907760f, 
    -0.07783277f, 0.01927540f, -0.07237417f, 0.02510903f, 0.05647236f, 0.03511364f, -0.00078208f, -0.02246595f, 
    0.05828623f, -0.05462831f, 0.17377561f, 0.07854320f, -0.14471321f, 0.23840566f, -0.13234559f, -0.00294589f, 
    -0.05626077f, 0.03308152f, 0.18242855f, 0.00170022f, -0.01789825f, 0.17727758f, 0.20506188f, -0.03284961f, 
    -0.09940919f, -0.16734663f, 0.08536083f, 0.06342035f, -0.08524328f, 0.02792337f, 0.07916787f, 0.07569165f, 
    -0.07557686f, 0.17250237f, 0.22194435f, 0.27762946f, 0.07613270f, -0.00452601f, -0.08162705f, -0.15578511f, 
    0.11436570f, -0.04711650f, -0.11739253f, 0.06015262f, -0.16857207f, 0.04444948f, -0.27245268f, -0.05913377f, 
    0.10461396f, 0.04640823f, 0.09540564f, 0.13970917f, 0.02596699f, -0.06265483f, -0.02811007f, -0.02350275f, 
    0.13810834f, 0.11118844f, 0.45563421f, 0.12580496f, 0.18372159f, 0.19540143f, 0.07386763f, -0.19744153f, 
    0.00154251f, 0.06271322f, 0.09133200f, -0.02768132f, 0.09925009f, 0.12798801f, -0.01862684f, 0.06502875f, 
    0.15260126f, -0.16699779f, 0.34636137f, -0.03217496f, -0.02841317f, -0.03980554f, 0.15422784f, 0.04534915f, 
    -0.07092793f, -0.12943351f, 0.06897929f, 0.07655370f, -0.02209999f, -0.06108822f, -0.07915517f, 0.10682374f, 
    -0.14636661f, 0.02780078f, 0.03565582f, 0.01739836f, -0.24622774f, 0.09524344f, -0.03270757f, 0.20278998f, 
    0.11933286f, -0.13956267f, 0.21918578f, -0.03125551f, 0.03296383f, 0.10085757f, -0.15459771f, 0.02981505f, 
    -0.17837262f, 0.06234585f, 0.28898010f, 0.19376627f, 0.03447254f, -0.04634484f, 0.20100670f, -0.11152703f, 
    -0.00591535f, 0.07811348f, 0.01977075f, 0.14111783f, -0.44941226f, 0.00056155f, 0.00193190f, 0.19051002f, 
    0.02035971f, -0.12866251f, -0.06974182f, 0.20556946f, -0.09691527f, -0.00606903f, -0.20534052f, -0.07113586f, 
    -0.18126471f, -0.06954734f, -0.09168961f, -0.05108193f, 0.06139957f, 0.08417515f, 0.07740058f, 0.07662523f, 
    0.05120371f, 0.03719458f, -0.03620900f, 0.05380118f, 0.28527012f, -0.09001403f, 0.06771661f, 0.16491644f, 
    -0.05639743f, 0.08087007f, 0.01908188f, 0.09084267f, 0.02275033f, -0.00851628f, -0.03399773f, -0.03425498f, 
    0.01717962f, 0.08366904f, -0.18937096f, -0.02487662f, -0.14817101f, 0.10093028f, -0.09778671f, -0.17129821f, 
    0.03462628f, 0.02355658f, -0.06136036f, 0.04276637f, 0.20401371f, -0.04351624f, -0.00023728f, -0.10455115f, 
    0.01164152f, 0.07811421f, -0.05661253f, 0.12826575f, 0.12188925f, 0.04368464f, 0.00409543f, -0.10542762f, 
    0.03000596f, 0.01670736f, -0.03714568f, -0.05557212f, -0.00778931f, 0.16991402f, 0.02075509f, -0.07143351f, 
    -0.00961520f, 0.03087205f, -0.07224762f, 0.21573468f, -0.20006463f, -0.02166579f, 0.01995436f, 0.05129081f, 
    0.10942981f, 0.15000699f, 0.01136562f, -0.02611390f, -0.08053737f, -0.07339805f, 0.12325574f, 0.02060604f, 
    0.07729580f, 0.09434054f, 0.08633065f, -0.09175177f, -0.20109618f, 0.15539640f, 0.06437511f, 0.09728543f, 
    -0.04017288f, 0.04212029f, -0.02151214f, 0.08574107f, -0.07542124f, -0.05273468f, -0.29367867f, -0.05262705f, 
    0.14249079f, -0.02689343f, -0.03080193f, -0.08297887f, -0.02935210f, 0.04785157f, 0.01287204f, 0.16961764f, 
    -0.23983195f, 0.25941762f, 0.00595366f, 0.19963051f, 0.01116366f, -0.17360204f, -0.04004766f, 0.10780055f, 
    0.02717337f, 0.16611515f, 0.18691145f, -0.06760380f, 0.03265170f, -0.13238136f, -0.28053784f, -0.10815752f, 
    -0.20789140f, -0.01724912f, -0.07172743f, -0.06728731f, 0.01623565f, 0.15679924f, 0.12898251f, -0.08674652f, 
    0.05916227f, 0.13573961f, -0.03286227f, 0.15772822f, -0.06397751f, -0.04586670f, 0.00109812f, 0.01706261f, 
    -0.14100051f, 0.02468697f, 0.00340784f, 0.17801251f, -0.27255061f, -0.10830835f, -0.35374826f, 0.05090953f, 
    -0.15909652f, -0.05985926f, 0.06578992f, -0.09148009f, 0.13768548f, 0.06061383f, 0.07946926f, 0.04990705f, 
    0.11582655f, -0.00036574f, 0.19216995f, 0.12866747f, 0.08944688f, -0.01484232f, 0.14497434f, -0.00412910f, 
    0.09619456f, 0.08554960f, 0.12813896f, 0.18298219f, -0.00017671f, -0.12650041f, -0.30976468f, -0.25067005f, 
    -0.10494430f, 0.10118120f, -0.02969233f, 0.08475128f, -0.04016280f, -0.12279851f, -0.05546193f, 0.04706836f, 
    0.00883192f, 0.25864324f, 0.09591722f, 0.06983493f, 0.25617510f, 0.04051172f, -0.08853874f, -0.03089331f, 
    0.09539385f, 0.06628307f, 0.20330608f, -0.02562476f, -0.11841243f, -0.81417722f, -0.10520163f, 0.02185845f, 
    -0.02303245f, -0.00059277f, 0.09523475f, 0.03715632f, 0.05509169f, 0.04305046f, 0.09459269f, 0.03582058f, 
    0.18264450f, -0.06455575f, -0.22301267f, -0.14637856f, -0.14933832f, 0.00518144f, 0.03059012f, 0.01096374f, 
    0.22076647f, 0.08005611f, -0.00707134f, 0.01332642f, 0.53598863f, 0.08107879f, 0.70456254f, 0.21724913f, 
    0.14462471f, -0.08104924f, -0.07471684f, -0.03101631f, 0.08387329f, -0.08620959f, -0.03505862f, 0.00536341f, 
    0.13871802f, 0.25043613f, -0.17417020f, -0.09929068f, 0.04105458f, 0.06262501f, 0.05107584f, -0.07642284f, 
    -0.05037643f, 0.03988403f, -0.01549528f, 0.00992937f, 0.02531426f, -0.04813743f, -0.02480451f, -0.14231786f, 
    0.03913331f, -0.05147976f, 0.00356423f, -0.03902899f, -0.09955309f, -0.01856859f, -0.06410360f, -0.06323392f, 
    0.32110029f, 0.03131700f, 0.18614702f, -0.05254333f, 0.24433741f, -0.03632656f, -0.11144677f, 0.01370085f, 
    0.02210418f, -0.02104236f, 0.11806047f, 0.02140892f, 0.30734608f, 0.12056585f, 0.05177673f, -0.19464089f, 
    0.08592719f, -0.00163787f, 0.09095901f, -0.05239220f, 0.08101694f, -0.09031934f, -0.04373231f, 0.03645150f, 
    0.24816953f, 0.15728165f, 0.13730027f, -0.01216505f, 0.04803132f, -0.06293124f, -0.07775573f, 0.08916359f, 
    -0.00236681f, -0.18627739f, -0.02170801f, -0.31717435f, -0.17190880f, -0.15217976f, -0.17882642f, 0.01104588f, 
    -0.02712576f, -0.01036224f, 0.01130369f, 0.06243274f, 0.11536052f, 0.02619971f, 0.20728129f, 0.31078830f, 
    0.21777749f, 0.28019121f, -0.12881096f, 0.27711630f, 0.11924092f, 0.13213536f, 0.19909684f, 0.06267716f, 
    0.09633083f, 0.08092205f, 0.06015277f, 0.16189250f, 0.11379518f, -0.00789710f, 0.04529656f, 0.03250334f, 
    -0.10781110f, 0.01154419f, -0.09058081f, -0.03395774f, 0.18735629f, 0.16044277f, 0.11545043f, 0.07963653f, 
    0.14331056f, 0.06394402f, 0.40620157f, 0.25481164f, -0.00990723f, -0.07312392f, 0.09855403f, 0.14116764f, 
    0.07041315f, -0.04507674f, 0.12476573f, 0.01657772f, -0.09916443f, 0.16183078f, -0.08489548f, 0.26987219f, 
    -0.11340133f, -0.09337360f, 0.01979634f, -0.29554415f, 0.11871894f, 0.01737047f, 0.01114267f, -0.02550089f, 
    0.14005503f, -0.13416950f, -0.20375867f, -0.14797896f, -0.05615719f, 0.02332608f, -0.05825993f, -0.22085460f, 
    -0.09042340f, 0.03776273f, -0.04417049f, 0.04890244f, 0.24370311f, 0.21288112f, -0.00961812f, -0.02640535f, 
    -0.06881766f, -0.07871889f, -0.13480920f, 0.07422272f, -0.01987584f, -0.22583160f, -0.21079145f, -0.07526400f, 
    -0.27047923f, 0.05659714f, -0.13573684f, -0.03118841f, -0.23758696f, 0.21055816f, 0.07901375f, -0.08890732f, 
    0.05004813f, -0.03684197f, 0.22503068f, 0.09380345f, -0.15406512f, 0.22073179f, 0.03568198f, 0.04715758f, 
    -0.11222806f, -0.18763503f, 0.01426927f, 0.10904063f, 0.05497959f, 0.02542071f, 0.00513815f, 0.16834712f, 
    0.14318690f, 0.23134367f, -0.15552661f, -0.17840686f, 0.11132279f, 0.02249290f, 0.02270984f, -0.09051164f, 
    -0.04167926f, 0.08294290f, -0.03239867f, 0.11046661f, 0.25892898f, -0.20252955f, -0.10233644f, -0.07611624f, 
    -0.03867082f, 0.16218790f, 0.10043656f, -0.17840941f, -0.12210232f, 0.10262832f, 0.00611071f, 0.01057587f, 
    0.04143501f, 0.00063307f, 0.22772744f, 0.00073665f, -0.01900043f, 0.05724272f, -0.21791011f, -0.22677080f, 
    -0.35193744f, -0.41620913f, -0.05919586f, -0.22975917f, -0.03027321f, -0.00132124f, 0.30020300f, 0.21322730f, 
    0.01732368f, 0.09858181f, 0.05523702f, 0.00852416f, 0.09927256f, -0.09929055f, -0.14104304f, -0.23286724f, 
    -0.00408441f, 0.11511347f, 0.02062937f, -0.17616564f, 0.05034670f, -0.18053350f, -0.11693551f, -0.11368092f, 
    -0.27489176f, -0.01765630f, 0.00570273f, -0.20542206f, -0.07195100f, -0.23534934f, 0.02693662f, 0.13845240f, 
    -0.16562471f, -0.00823293f, -0.15553889f, 0.07000218f, -0.02273952f, 0.09547485f, 0.17131522f, 0.06584770f, 
    -0.30609700f, 0.05822250f, -0.13175391f, -0.10626096f, 0.01748335f, 0.08277088f, 0.11102281f, -0.19058470f, 
    0.07150855f, 0.00739801f, 0.06049592f, 0.08364792f, -0.04268657f, 0.04689558f, 0.08215573f, -0.21303312f, 
    0.11315663f, 0.05853337f, 0.14793003f, 0.22416522f, -0.12457367f, -0.07189022f, -0.12542216f, -0.20423760f, 
    -0.05830504f, -0.29674530f, 0.20654480f, -0.04132167f, -0.02543046f, 0.06107571f, -0.02260908f, 0.12899189f, 
    -0.04120316f, -0.02065191f, 0.09428103f, -0.10273469f, -0.11756861f, 0.13950318f, -0.08852665f, -0.30942225f, 
    -0.06684580f, -0.04379277f, 0.03230104f, 0.02876488f, 0.01461652f, 0.11896924f, -0.04850149f, -0.09334961f, 
    -0.05415680f, 0.10839713f, -0.07378747f, -0.00352591f, 0.16135766f, 0.04981448f, 0.04261926f, -0.15461355f, 
    -0.05779133f, -0.06697909f, 0.00684725f, 0.17917727f, 0.13572410f, -0.07112745f, 0.14008328f, 0.15760396f, 
    0.03966939f, 0.10846574f, 0.03043721f, 0.28463709f, 0.32231954f, 0.09712056f, 0.08384028f, 0.21579295f, 
    -0.07647924f, 0.02493277f, 0.04540814f, -0.13057368f, -0.08849804f, -0.11770239f, -0.05429241f, -0.08179869f, 
    0.24492039f, -0.11970544f, 0.06264463f, -0.06214142f, -0.28760314f, -0.52255285f, -0.13583501f, -0.18902178f, 
    0.18227452f, 0.10875924f, -0.02749254f, 0.06688944f, -0.05093792f, 0.18047917f, 0.07311780f, 0.13172257f, 
    0.32138133f, 0.18396032f, -0.00460703f, 0.07993157f, 0.06102804f, -0.10008535f, -0.12717496f, 0.21276742f, 
    -0.00920513f, 0.13440324f, -0.05920368f, -0.01171199f, 0.06958956f, -0.07451320f, -0.21070679f, -0.04384907f, 
    0.08963104f, 0.29800162f, 0.05814525f, 0.09711540f, 0.17062891f, 0.03390530f, 0.08832203f, -0.03490119f, 
    0.05268428f, -0.37526959f, -0.07860941f, -0.37945545f, -0.29016390f, -0.16394913f, -0.08190018f, -0.07706948f, 
    0.13493441f, 0.12141063f, 0.14551659f, 0.12985484f, -0.22348505f, 0.13507651f, 0.23665234f, 0.10862278f, 
    0.07766921f, -0.07220405f, -0.15229914f, -0.00757490f, -0.02433166f, -0.06524145f, -0.03027520f, -0.02109614f, 
    -0.07310815f, -0.12056923f, 0.00857439f, 0.10439315f, -0.05832645f, 0.00208584f, 0.03938612f, -0.12717848f, 
    0.25853828f, 0.07153864f, 0.15707846f, 0.10938251f, 0.15305579f, -0.23565826f, -0.13560311f, -0.21721341f, 
    0.15323983f, 0.07752936f, -0.04456624f, 0.18233350f, -0.02972507f, -0.12992662f, -0.01944155f, 0.07893452f, 
    0.17076802f, -0.16326042f, 0.09443898f, -0.02399527f, -0.02388916f, 0.17972732f, -0.02193010f, 0.04370799f, 
    0.06655536f, 0.22392333f, 0.03552216f, 0.17718776f, 0.02136825f, 0.21235156f, 0.18436015f, -0.16102795f, 
    0.20203431f, -0.04961317f, 0.14808756f, -0.04880176f, -0.04882528f, 0.05313892f, 0.02831041f, 0.13740136f, 
    -0.05749133f, 0.09016605f, -0.25404850f, -0.14734781f, -0.07909901f, 0.11731873f, 0.10015253f, -0.11149202f, 
    -0.03015640f, 0.02114606f, 0.08948812f, 0.03672139f, -0.12354061f, 0.17332500f, 0.36752978f, 0.00308411f, 
    0.20400846f, -0.04728551f, -0.00729561f, -0.01916522f, -0.03646789f, -0.13057970f, 0.11515003f, 0.24598959f, 
    -0.03271957f, 0.03221464f, -0.03517928f, 0.05509521f, 0.13571441f, -0.06379950f, -0.12548746f, -0.04649173f, 
    0.17734201f, 0.08679713f, 0.09109057f, 0.04350809f, -0.20009468f, 0.02361866f, -0.29879618f, 0.09447277f, 
    0.04743819f, -0.02393965f, 0.02261274f, 0.16250947f, 0.13789253f, -0.02807474f, 0.04288542f, 0.04501448f, 
    0.25967735f, 0.40368274f, 0.19851975f, 0.08339676f, 0.25965136f, 0.04099523f, 0.10581473f, -0.18560958f, 
    0.06251467f, -0.20208545f, -0.06189756f, 0.00600511f, 0.07000315f, 0.03345519f, -0.01891542f, -0.00166394f, 
    0.17004058f, -0.01564549f, 0.18972361f, 0.04618188f, -0.09609301f, 0.20797624f, 0.10472171f, -0.00261726f, 
    -0.25289845f, -0.35824054f, -0.27480051f, 0.03910094f, -0.13228419f, -0.11550442f, 0.04340272f, 0.00637968f, 
    -0.03567310f, 0.14964312f, 0.01478350f, 0.06463839f, -0.09886097f, -0.12414378f, 0.06921414f, 0.01418674f, 
    0.11729246f, 0.27076998f, 0.07853897f, 0.04989510f, 0.17115432f, -0.04832939f, -0.04203860f, -0.04951727f, 
    -0.22624847f, -0.27870938f, -0.13094702f, 0.05389605f, -0.10255377f, -0.15461728f, -0.15916204f, -0.04848676f, 
    0.15163675f, 0.15894376f, 0.06282874f, 0.01075759f, 0.18803628f, 0.10469261f, -0.03379971f, 0.14469363f, 
    0.16647638f, 0.07758120f, 0.06211578f, -0.16065849f, 0.04391691f, -0.05577850f, -0.00916423f, -0.05096828f, 
    -0.12181617f, -0.28965953f, 0.19590309f, 0.04038592f, 0.12709600f, -0.06014173f, 0.06065620f, 0.12436564f, 
    -0.14473850f, -0.08473747f, -0.05504528f, 0.06607295f, -0.23307091f, -0.51992196f, 0.08444669f, 0.03877211f, 
    -0.18270995f, -0.01394818f, -0.21882366f, -0.01278540f, 0.08566455f, 0.04617349f, -0.02480515f, 0.01047576f, 
    -0.04947187f, 0.11488587f, -0.11061253f, -0.13383956f, 0.18681256f, 0.04508346f, -0.06499511f, -0.20197944f, 
    0.14893241f, -0.10757041f, -0.13274604f, -0.13863316f, 0.58633363f, -0.05543860f, 0.18320777f, -0.09803827f, 
    0.18239024f, 0.22879502f, -0.04594984f, 0.28833589f, 0.15410145f, 0.08729181f, -0.01185587f, 0.02854570f, 
    -0.14811514f, -0.47569621f, 0.24094075f, 0.35492098f, -0.11342236f, 0.05719937f, 0.06098922f, 0.03897832f, 
    -0.04188568f, 0.01320930f, -0.15349534f, 0.01894494f, -0.04848293f, 0.18202862f, 0.30047491f, 0.03839390f, 
    0.12318384f, -0.00573474f, 0.00437021f, 0.00292106f, -0.00151246f, -0.03018884f, -0.10579262f, -0.05753270f, 
    -0.31565928f, 0.15529239f, 0.00690159f, 0.19148648f, -0.05379996f, 0.14002892f, -0.02243935f, 0.08989367f, 
    0.00172921f, -0.04315036f, 0.11276875f, 0.11091589f, 0.00801695f, 0.18959680f, -0.07368924f, -0.47909245f, 
    0.05489716f, -0.09997565f, 0.06103594f, 0.27394214f, -0.19863421f, -0.02193494f, -0.27974081f, -0.09344564f, 
    -0.18463959f, -0.10632068f, 0.22782487f, 0.14464787f, -0.04092286f, 0.04793704f, -0.02167067f, 0.15479255f, 
    -0.05817974f, -0.07644278f, 0.06101794f, -0.07594620f, 0.21065415f, -0.02644913f, -0.41278380f, -0.37023416f, 
    -0.02132798f, 0.00953505f, 0.12169638f, -0.02369361f, 0.10012940f, -0.00055097f, -0.01101493f, -0.13315070f, 
    0.19002964f, 0.05207436f, 0.24668896f, 0.10476328f, 0.14816941f, 0.13322946f, -0.01738678f, -0.15711559f, 
    0.01782049f, 0.04706610f, 0.12140056f, 0.02903460f, 0.15910313f, -0.03488946f, 0.10756753f, -0.00266340f, 
    -0.06702218f, 0.07050981f, 0.02893932f, 0.17967306f, 0.00140680f, -0.15753198f, 0.15416318f, 0.04292063f, 
    -0.07255291f, -0.08131435f, -0.02524841f, -0.12364291f, 0.01340135f, 0.11467256f, -0.16255459f, 0.03217653f, 
    0.00686525f, 0.02605907f, 0.09209480f, -0.07097044f, 0.03661922f, 0.17007184f, -0.17220220f, -0.00760879f, 
    0.11707894f, 0.11788990f, 0.07298703f, 0.10084404f, -0.02997131f, 0.12459128f, 0.01597846f, -0.07358219f, 
    -0.09567714f, -0.07462069f, 0.22295098f, 0.26806277f, 0.03454088f, 0.09061911f, -0.01872222f, 0.09350676f, 
    -0.06071471f, 0.10268345f, 0.33518970f, 0.10726768f, -0.24412492f, -0.11991555f, -0.43300024f, 0.41722235f, 
    0.05018778f, 0.14200632f, 0.08548236f, 0.37751216f, 0.01978888f, -0.03811688f, -0.12958688f, -0.05890862f, 
    0.03362819f, 0.08208735f, -0.17062645f, -0.31080091f, -0.09131196f, 0.06923438f, -0.05428410f, -0.06826552f, 
    0.13648105f, 0.16756956f, 0.01785979f, -0.12897560f, -0.01097136f, 0.18049623f, 0.14874335f, 0.14629376f, 
    0.03533256f, 0.03801407f, -0.23289029f, 0.08436243f, 0.02807333f, 0.04694304f, 0.13718498f, -0.07185409f, 
    -0.06228572f, 0.19455741f, -0.02197238f, 0.14003225f, -0.41019163f, 0.28297213f, 0.12951422f, -0.02036542f, 
    0.17048422f, 0.14913167f, -0.02177224f, 0.12145711f, 0.38341743f, -0.02933657f, 0.03585478f, -0.02271418f, 
    -0.03819990f, 0.06972259f, -0.04137371f, -0.08888903f, -0.04097826f, 0.10369024f, 0.05636013f, -0.09404615f, 
    0.02287632f, 0.06416827f, 0.10024169f, -0.06108700f, 0.14256339f, 0.10333265f, -0.08745401f, -0.08131252f, 
    0.02025131f, 0.13974874f, 0.02476835f, 0.09332754f, 0.24578971f, 0.20055729f, -0.04585248f, -0.14999157f, 
    0.20447546f, -0.13809648f, 0.10635566f, 0.05358687f, 0.01938136f, -0.04808751f, -0.10631483f, -0.05003707f, 
    -0.16538550f, -0.14615646f, 0.07753526f, -0.05164532f, -0.10351987f, -0.20635065f, -0.01920584f, -0.03326766f, 
    0.02687515f, 0.10533400f, 0.07800947f, 0.22509554f, 0.13394991f, 0.09181058f, 0.12027441f, 0.07426148f, 
    0.21066271f, -0.03325248f, 0.00491296f, 0.03839749f, 0.04208650f, -0.04387926f, -0.23958768f, -0.29908291f, 
    -0.14325958f, -0.06479105f, 0.32261866f, -0.16674715f, -0.02300962f, 0.06106228f, 0.02878464f, 0.12616833f, 
    -0.13504691f, 0.08224276f, -0.06579311f, -0.22815093f, 0.06745601f, -0.19678414f, -0.16754828f, -0.10299971f, 
    -0.04052231f, -0.07362863f, 0.03405807f, 0.00949338f, -0.11988840f, -0.12260115f, -0.18440917f, -0.11682779f, 
    -0.34917092f, -0.22130848f, -0.11683603f, 0.08565677f, -0.09403469f, 0.09233626f, -0.02078874f, 0.16301200f, 
    -0.05960425f, 0.05689624f, 0.04530737f, 0.11713701f, 0.22722617f, 0.01844529f, 0.07879492f, 0.09588933f, 
    0.02269257f, 0.09738313f, 0.09797788f, 0.19749551f, 0.21765406f, 0.02851677f, 0.02491057f, 0.16104271f, 
    -0.03048577f, 0.05293506f, 0.00333628f, -0.02441871f, -0.09376203f, -0.03850149f, 0.03532514f, -0.14043950f, 
    0.16315462f, -0.11537535f, 0.16556364f, 0.08518485f, -0.18815786f, -0.11370112f, 0.07854135f, -0.02018554f, 
    0.04303584f, -0.01393664f, 0.14666645f, 0.06986399f, -0.11797394f, 0.05451331f, 0.12669186f, -0.07461817f, 
    0.35388064f, 0.19531634f, 0.20996661f, -0.02304302f, 0.11678531f, -0.10769624f, -0.00703372f, -0.02123658f, 
    0.03061015f, 0.14988543f, -0.07493215f, 0.03715939f, 0.06370502f, 0.03309647f, 0.26336488f, -0.02344353f, 
    0.03151903f, 0.24769023f, 0.21859656f, 0.14043894f, 0.16150241f, 0.08478049f, 0.03545799f, -0.05345736f, 
    -0.05840763f, -0.00460174f, -0.13878469f, -0.09448519f, -0.19958855f, -0.06198068f, -0.05669760f, -0.15854853f, 
    0.19764765f, 0.03583528f, 0.19635451f, 0.02454198f, 0.16094328f, 0.26916280f, 0.30737597f, 0.01743638f, 
    0.04664650f, -0.11782521f, -0.02324677f, -0.16784988f, -0.07389830f, 0.03915846f, -0.00503333f, -0.01268561f, 
    0.04082035f, -0.00979616f, -0.17630853f, -0.00913156f, 0.11095263f, 0.00202137f, 0.13803940f, 0.09042189f, 
    0.01531239f, 0.18206403f, 0.09678373f, 0.06173708f, -0.26776040f, -0.18310972f, -0.25963277f, 0.00642191f, 
    0.09248658f, -0.12590279f, 0.01426555f, 0.00529500f, -0.13105801f, -0.09101515f, -0.07027628f, 0.00354919f, 
    0.21134898f, 0.14693111f, -0.17029938f, -0.09132262f, -0.03940074f, -0.09921023f, 0.03316678f, -0.01402099f, 
    0.01641160f, 0.07055112f, 0.04539553f, 0.17148261f, -0.19978492f, -0.08712998f, 0.13680916f, 0.14490932f, 
    0.06178695f, 0.04948682f, 0.12323836f, 0.13056035f, 0.03644952f, 0.08645615f, -0.07258312f, 0.02830748f, 
    -0.04419534f, 0.05595366f, 0.03811301f, -0.05398633f, 0.03842453f, 0.01742202f, 0.00945207f, -0.06563750f, 
    0.02892425f, -0.04786053f, -0.02970132f, -0.00178785f, -0.01345871f, -0.00089109f, -0.05114701f, -0.01611581f, 
    -0.06137886f, -0.01373065f, 0.01119801f, -0.03519793f, -0.06852350f, 0.05836229f, -0.05156115f, 0.02920644f, 
    -0.01680662f, 0.02105961f, -0.00662526f, -0.02270976f, 0.00847811f, -0.00433292f, 0.02214227f, 0.00729611f, 
    0.07341345f, -0.06748419f, 0.02352334f, 0.01669103f, -0.06713726f, -0.00268312f, -0.08165897f, 0.03854942f, 
    -0.00920108f, -0.04960755f, -0.05404954f, 0.01555631f, 0.05960281f, -0.03301787f, -0.03977397f, -0.04991989f, 
    0.03926928f, 0.03594923f, -0.01108444f, -0.08769932f, -0.08625580f, -0.01894655f, 0.06315362f, -0.06986591f, 
    -0.07014228f, -0.07475873f, -0.07213681f, -0.02177864f, 0.00980134f, -0.06097981f, -0.05713633f, 0.02565197f, 
    -0.07123448f, -0.07941774f, 0.02177435f, -0.08185510f, -0.06315437f, -0.05394221f, -0.06399828f, -0.05407688f, 
    -0.04012372f, -0.07287120f, 0.05513240f, -0.01769193f, 0.00668970f, -0.05415081f, -0.03607117f, 0.05132303f, 
    -0.03062765f, -0.06799062f, 0.06791594f, 0.05161854f, 0.03274218f, 0.05961410f, 0.00272757f, 0.04223232f, 
    0.03202993f, -0.05494005f, 0.03490165f, 0.02351242f, 0.05040988f, -0.05273325f, -0.03260757f, -0.05008646f, 
    0.01616635f, 0.05075543f, -0.03350114f, 0.05685419f, 0.02377358f, 0.01127391f, 0.00385905f, -0.07176311f, 
    -0.08032584f, 0.07788964f, 0.05629137f, -0.01918866f, 0.02656078f, 0.01574244f, 0.02954098f, -0.02239558f, 
    -0.01672985f, -0.00629534f, 0.01360303f, 0.05159552f, 0.05465661f, -0.00036395f, -0.04521261f, 0.02271944f, 
    -0.01657833f, -0.02964032f, -0.06921823f, -0.00526230f, -0.02838503f, 0.06298809f, -0.06131149f, -0.01267992f, 
    -0.04883088f, 0.01908929f, 0.03459227f, -0.04103274f, -0.04721381f, -0.00909611f, -0.01555055f, 0.02671923f, 
    0.05666877f, -0.05570762f, -0.00795232f, 0.00778899f, -0.07771078f, 0.01472246f, -0.03987314f, -0.01788709f, 
    -0.00150747f, 0.05874868f, 0.04239940f, -0.04309500f, -0.01087703f, -0.03562488f, 0.01010136f, 0.02650757f, 
    0.00739221f, -0.06726176f, 0.03735980f, 0.02108755f, -0.00173786f, -0.02123419f, 0.03698769f, -0.02890545f, 
    -0.06376532f, -0.02255516f, -0.01509029f, -0.06209321f, -0.00862380f, -0.05141005f, -0.04418505f, -0.03632407f, 
    -0.04622019f, 0.01218027f, -0.06002462f, 0.04865151f, -0.04652429f, 0.05076187f, -0.01545987f, 0.06387718f, 
    0.03586103f, -0.06903405f, 0.02518490f, 0.06295391f, -0.09834011f, 0.00453435f, -0.03559924f, -0.06439288f, 
    -0.00410827f, -0.02983764f, 0.03982138f, -0.02707981f, -0.03188813f, -0.06144198f, -0.06738317f, -0.06857858f, 
    -0.00743731f, -0.01494905f, 0.23297596f, -0.44419843f, 0.08964606f, 0.09488047f, -0.28619954f, 0.12474038f, 
    -0.03879365f, -0.04147326f, -0.06819306f, 0.04922642f, 0.03052924f, -0.05921604f, 0.07522590f, 0.19109587f, 
    -0.01404981f, -0.02608485f, 0.03220554f, 0.00100327f, -0.07009130f, -0.04692809f, 0.14493541f, 0.12933625f, 
    0.05321644f, 0.04434752f, 0.27102202f, 0.10258178f, 0.01585598f, 0.05963218f, 0.12686285f, 0.12350056f, 
    0.07847448f, 0.05468509f, 0.06453269f, -0.01083214f, -0.42845789f, 0.06475309f, 0.29987252f, 0.14261338f, 
    0.02295943f, -0.17932057f, -0.07639109f, -0.19202785f, -0.12339056f, 0.01331545f, 0.16691187f, 0.15600580f, 
    -0.05878963f, -0.12195905f, -0.10385996f, 0.05762104f, 0.12784220f, 0.08950666f, 0.04222272f, -0.02762798f, 
    0.10698406f, -0.09058106f, 0.00571501f, 0.05926406f, -0.01844928f, 0.12318740f, -0.03417655f, 0.19044051f, 
    0.13954438f, -0.05445347f, 0.03653531f, -0.15098107f, 0.18869363f, 0.35903567f, 0.10333531f, 0.05657325f, 
    -0.07943803f, -0.07621093f, -0.06495409f, 0.00407668f, 0.08339065f, -0.13915542f, 0.28448635f, -0.02993604f, 
    0.11636279f, 0.19279690f, 0.11010006f, 0.12416399f, -0.07319289f, -0.26205325f, 0.08287452f, 0.09626360f, 
    0.10932072f, 0.18102771f, 0.11638694f, 0.01497782f, -0.10156508f, -0.08556963f, -0.19575503f, 0.04557991f, 
    0.42074400f, 0.30428746f, -0.22532164f, 0.01582992f, -0.06578476f, -0.10387384f, -0.14116307f, 0.02380171f, 
    0.00755164f, 0.28299463f, -0.11875547f, -0.11125149f, -0.22157007f, 0.14581847f, 0.15765777f, 0.05869193f, 
    -0.07220475f, 0.06870515f, 0.07845134f, 0.16117449f, -0.00254759f, 0.00511037f, 0.04182844f, 0.01749031f, 
    -0.35652515f, 0.11777252f, -0.01238529f, 0.10083799f, 0.20281382f, 0.07707714f, -0.00912250f, -0.10142403f, 
    -0.03125474f, -0.04615051f, 0.08592627f, 0.21697384f, 0.35012937f, -0.57195193f, 0.09062294f, -0.08862669f, 
    0.01199474f, -0.02483276f, -0.00833379f, 0.03615384f, -0.11895801f, 0.02272451f, 0.02244645f, -0.07671910f, 
    -0.08934782f, -0.07606606f, 0.07086533f, -0.11757801f, 0.24993451f, 0.15007481f, -0.27398524f, 0.01808102f, 
    0.05621795f, -0.07439464f, 0.13629539f, 0.11901102f, 0.00706604f, -0.35976484f, -0.09871817f, -0.02576516f, 
    0.12803160f, 0.06491630f, -0.05507356f, 0.13051541f, -0.02509884f, -0.12151879f, -0.07723336f, -0.05775504f, 
    0.56338239f, -0.08696139f, -0.23325752f, -0.07360897f, 0.15149476f, -0.12083732f, 0.07657620f, -0.02863470f, 
    0.12173269f, 0.07507312f, 0.14414956f, -0.00109763f, -0.26779956f, -0.18076722f, -0.05281516f, 0.01358247f, 
    -0.14095742f, 0.00729616f, 0.03821081f, -0.07743015f, -0.00024785f, 0.10066143f, -0.13228418f, 0.02071946f, 
    -0.01488219f, 0.01021992f, -0.04165473f, -0.01753926f, 0.01229830f, 0.05932834f, 0.02340994f, 0.05306582f, 
    0.06138813f, 0.00020082f, -0.03620994f, 0.01308915f, 0.05150957f, -0.06402010f, -0.06311006f, -0.02723036f, 
    -0.04638945f, -0.00357146f, 0.01312194f, 0.05260149f, 0.04528811f, 0.03558312f, -0.05964791f, -0.02133493f, 
    -0.04319324f, -0.00879580f, -0.01489928f, -0.01084667f, 0.06395759f, -0.02829737f, 0.06322993f, -0.03418618f, 
    -0.00859170f, -0.04460381f, -0.03859146f, -0.00937786f, -0.01359773f, 0.02512349f, -0.00186240f, 0.01246606f, 
    -0.06657420f, 0.05281827f, -0.00629235f, -0.05445778f, -0.05819212f, 0.04290780f, -0.02602112f, -0.03369177f, 
    0.00668112f, 0.03332755f, 0.03159421f, 0.02065291f, -0.01393045f, 0.04325983f, -0.03725491f, 0.05151208f, 
    0.02062408f, 0.03831270f, -0.06761809f, -0.03936014f, 0.00964867f, -0.03359604f, 0.04710194f, -0.04557485f, 
    -0.06119146f, 0.06211104f, 0.05631443f, 0.03033888f, -0.07116726f, -0.02465962f, 0.04390202f, -0.06001527f, 
    0.06355613f, -0.01126552f, -0.01017292f, -0.05192924f, -0.04109033f, -0.04252563f, 0.00656892f, -0.04114191f, 
    0.00100035f, -0.03972110f, -0.02966521f, 0.00607837f, -0.05805434f, -0.00474023f, 0.03477579f, 0.04394463f, 
    -0.02856140f, -0.02921493f, 0.04768031f, -0.04179762f, -0.05220713f, -0.00073312f, 0.01106386f, 0.06060353f, 
    0.01237521f, 0.03351762f, -0.05443310f, -0.06710151f, 0.00721258f, -0.03667608f, -0.05916628f, -0.07231460f, 
    -0.06250548f, -0.01233219f, 0.01865183f, 0.04082559f, -0.02854013f, 0.03622064f, 0.02154038f, 0.01490561f, 
    0.00826269f, -0.06479444f, -0.06016506f, -0.05537482f, 0.01808595f, 0.00109871f, -0.00844218f, -0.06263926f, 
    0.01642541f, 0.01698534f, 0.06892109f, -0.06355762f, 0.02813498f, 0.04352026f, -0.00364790f, -0.04694054f, 
    -0.02596058f, -0.05814080f, -0.03382159f, -0.02996719f, 0.00434757f, 0.00311576f, -0.04747827f, -0.04874353f, 
    0.05157750f, -0.07197466f, -0.02477897f, 0.03410550f, -0.02030285f, -0.00267670f, -0.06438594f, 0.00730609f, 
    -0.03045157f, -0.02394524f, -0.06004586f, -0.00567438f, -0.03372727f, -0.02870906f, 0.00487360f, 0.03727603f, 
    -0.04905095f, -0.06658377f, -0.01839544f, -0.04105626f, -0.03155570f, -0.03870353f, 0.05419996f, -0.00564442f, 
    -0.01216691f, 0.06043822f, -0.00783502f, 0.05809044f, 0.05684152f, -0.01050785f, 0.04126266f, 0.02512047f, 
    -0.06292949f, 0.06595947f, 0.01680512f, 0.05065510f, 0.06449167f, -0.06164245f, 0.03487655f, -0.02247886f, 
    -0.07582648f, 0.03288298f, -0.07343025f, -0.04597992f, 0.02477179f, -0.04459759f, 0.04612879f, -0.03640953f, 
    0.05750077f, -0.07543889f, -0.03384178f, 0.01239737f, -0.00837191f, 0.04889188f, 0.00137373f, 0.00437861f, 
    -0.12618321f, -0.07199511f, 0.15896676f, -0.28094271f, -0.16999917f, -0.09126076f, -0.07964948f, 0.20760666f, 
    0.11910611f, -0.13179976f, -0.09209321f, -0.00414584f, -0.31461921f, -0.19437021f, -0.05707711f, -0.08093343f, 
    -0.00513133f, -0.06157462f, 0.10016294f, 0.04890196f, 0.09950706f, -0.04115533f, 0.16569690f, 0.04570998f, 
    0.11768189f, 0.45847723f, -0.17524132f, 0.16924764f, 0.26777264f, -0.07230157f, 0.04305364f, 0.21317843f, 
    0.10827168f, 0.11952675f, 0.13144821f, 0.07217506f, 0.06801588f, -0.02636255f, 0.37071192f, 0.10236145f, 
    -0.09045918f, -0.05826635f, -0.01821807f, -0.01906012f, 0.03833560f, 0.05232532f, 0.10140052f, 0.02504326f, 
    -0.23791498f, -0.04554316f, 0.21167928f, 0.10017675f, 0.06648296f, 0.07045126f, 0.16869977f, -0.07829081f, 
    0.22223277f, 0.07784501f, 0.12597169f, -0.01112595f, -0.11606120f, 0.10811897f, 0.00139628f, 0.32245559f, 
    0.01156756f, 0.22075720f, 0.17340054f, 0.00609330f, 0.20620561f, 0.09028959f, 0.26439828f, 0.09733231f, 
    0.01192115f, -0.11215160f, -0.12731941f, -0.00541110f, -0.06626898f, 0.00000025f, -0.07600413f, 0.00537173f, 
    0.03207406f, 0.09326667f, 0.00030030f, 0.16325256f, -0.24579087f, -0.02993887f, -0.09443121f, -0.06674656f, 
    -0.06693428f, -0.04784857f, 0.17393011f, 0.17310332f, 0.01460013f, -0.13037793f, -0.05125005f, 0.06188055f, 
    -0.04326097f, 0.11984675f, -0.07833958f, 0.25382194f, -0.00816655f, 0.17673823f, 0.02912635f, 0.07091431f, 
    0.07246879f, 0.06689698f, 0.26172775f, -0.08414745f, -0.15979521f, 0.19336236f, 0.26632324f, -0.18583997f, 
    0.07543434f, 0.03352141f, 0.07250360f, 0.15181150f, 0.06996454f, 0.10279234f, 0.05025864f, 0.11905882f, 
    -0.21275349f, -0.09400045f, -0.25639588f, -0.03807690f, -0.10663600f, -0.09386876f, -0.12007233f, -0.06853747f, 
    0.19369379f, -0.13991518f, 0.10089869f, 0.00546903f, 0.27773559f, -0.11097060f, -0.23453359f, 0.12556058f, 
    0.18753862f, -0.07657730f, 0.13716345f, -0.06576491f, -0.09759112f, 0.07910703f, 0.00808653f, -0.04916159f, 
    -0.01329738f, -0.09213179f, -0.02547393f, -0.29994956f, 0.05833114f, 0.06333791f, 0.10134717f, 0.06904347f, 
    0.05016736f, -0.06065720f, 0.17287596f, 0.01629410f, -0.06865505f, -0.29027936f, 0.11197108f, 0.04646595f, 
    0.02577460f, -0.00075079f, 0.00642460f, -0.03240147f, 0.01276215f, -0.08459828f, -0.12297263f, 0.08173709f, 
    0.28617564f, -0.10755546f, -0.17864996f, 0.04867930f, 0.07677334f, -0.02476209f, 0.05708963f, 0.02135983f, 
    -0.02954291f, 0.07788231f, 0.04767974f, 0.04125749f, -0.42760921f, -0.22035347f, 0.14144595f, -0.07026948f, 
    -0.13522975f, -0.05099208f, -0.08906782f, 0.07477333f, 0.11734715f, 0.11507614f, 0.09476531f, 0.01000588f, 
    0.05327270f, 0.00179372f, -0.06135485f, 0.05470770f, 0.05221948f, -0.00511249f, 0.05517238f, -0.05854068f, 
    -0.00044096f, 0.03186643f, 0.04135444f, -0.01025596f, 0.04277115f, -0.06408770f, -0.02138659f, 0.06410124f, 
    0.02568024f, -0.06032313f, 0.06717511f, 0.05007568f, 0.00503401f, 0.01101087f, -0.00199825f, 0.03676063f, 
    -0.02566542f, -0.06258041f, 0.03007787f, 0.06544567f, 0.05968269f, 0.02061690f, -0.02109294f, -0.05672339f, 
    -0.06534013f, -0.03710951f, -0.02354076f, 0.04219276f, -0.00691193f, 0.04475464f, 0.02149576f, -0.02489461f, 
    0.05481998f, 0.01516341f, -0.01820816f, -0.06243215f, 0.02135497f, 0.04591624f, 0.05543190f, -0.02604237f, 
    0.00008874f, -0.03211588f, -0.05720676f, -0.05929499f, -0.01250985f, -0.08117728f, -0.04942315f, -0.04409875f, 
    -0.05254132f, 0.03639887f, -0.05424032f, 0.02712647f, -0.05283201f, -0.02289670f, -0.00918594f, -0.04889341f, 
    -0.03660587f, -0.03523651f, -0.05626591f, 0.04305889f, -0.04254624f, -0.01105344f, 0.07087697f, -0.06035165f, 
    0.01535541f, 0.02816765f, 0.06018572f, -0.01480440f, -0.02899771f, 0.01406628f, 0.03836638f, -0.00125201f, 
    -0.01160348f, -0.05517772f, 0.04662766f, 0.03038971f, -0.01686910f, 0.02284089f, -0.05716273f, -0.04972727f, 
    0.02202665f, -0.05709800f, -0.02578771f, -0.07420895f, 0.03074835f, -0.06366330f, 0.04414207f, 0.03273464f, 
    -0.03977346f, -0.02714259f, 0.06332015f, -0.05698959f, 0.05083765f, 0.02970576f, 0.04919356f, 0.03266250f, 
    0.01397835f, -0.05713077f, -0.02156995f, -0.07617245f, -0.05622566f, 0.02853208f, -0.05621300f, -0.02225290f, 
    -0.05421145f, -0.02884346f, -0.03643552f, -0.05068197f, 0.06383537f, 0.06650131f, -0.04872535f, 0.01277584f, 
    0.05177231f, -0.00038312f, -0.07291911f, -0.07290056f, -0.08218765f, -0.02919476f, 0.05648187f, -0.07291614f, 
    -0.03484406f, -0.06499927f, -0.01242167f, 0.04813328f, 0.00701850f, -0.01554783f, -0.01699690f, -0.04543230f, 
    -0.01027167f, -0.07583991f, 0.04862434f, -0.05502241f, -0.01690005f, 0.00531794f, -0.05818675f, -0.02524753f, 
    -0.07962499f, -0.05470869f, -0.03498303f, -0.01799881f, -0.06082385f, 0.00104956f, 0.01440919f, -0.04747650f, 
    0.04027954f, -0.00136969f, -0.05091072f, 0.03571877f, 0.05436900f, -0.02407663f, -0.00615431f, -0.03674225f, 
    -0.05576612f, 0.00797674f, -0.01840492f, -0.07163658f, -0.04946969f, -0.00173954f, -0.01654824f, -0.04137678f, 
    -0.03234952f, -0.05867753f, -0.01981320f, 0.01897328f, 0.02886738f, 0.04614662f, -0.04292875f, 0.01904385f, 
    0.02437649f, -0.07427067f, 0.00544418f, -0.00138890f, -0.00215874f, 0.01921637f, -0.04638310f, 0.04787035f, 
    -0.02834459f, -0.01978892f, 0.05868847f, -0.05860716f, -0.07319240f, 0.01982500f, -0.04309944f, -0.07140871f, 
    -0.36418715f, -0.06208462f, 0.28771293f, -0.11973831f, 0.21524493f, 0.09349251f, -0.07522891f, 0.04988083f, 
    -0.11453197f, -0.03635209f, -0.05131444f, 0.01274340f, 0.00073479f, -0.15871458f, -0.02048606f, 0.11266322f, 
    -0.03057909f, 0.00327981f, 0.13163415f, -0.01609907f, -0.11904215f, -0.07862400f, -0.00725345f, 0.20525597f, 
    0.02996770f, -0.09221555f, 0.32704237f, 0.23023252f, 0.21439205f, 0.26487631f, 0.11807841f, 0.02000472f, 
    0.02117194f, 0.17393886f, 0.04834455f, -0.06073481f, -0.19535930f, 0.16092627f, 0.25822875f, -0.11133263f, 
    0.11173060f, -0.06232366f, 0.08923763f, -0.03146680f, 0.06610024f, 0.09744448f, -0.00358527f, -0.03945128f, 
    -0.04337111f, -0.27965114f, -0.08960511f, -0.09105131f, 0.12182859f, 0.15176743f, 0.06043075f, -0.10612679f, 
    0.21190986f, 0.01765076f, 0.09515945f, -0.05868413f, 0.28829661f, 0.17957808f, 0.04364289f, 0.35209486f, 
    0.16859852f, 0.08284328f, 0.14658974f, -0.06987745f, 0.18917145f, 0.20956157f, 0.16458258f, 0.11345883f, 
    -0.19748935f, -0.14922199f, -0.16824304f, -0.18945995f, -0.08614984f, -0.16622941f, 0.14863925f, 0.09290546f, 
    0.01339288f, 0.15535180f, -0.04043678f, -0.03929777f, -0.14966002f, -0.13930197f, 0.21768270f, 0.33173078f, 
    0.08997077f, 0.12667461f, 0.05868911f, 0.11829129f, -0.06756812f, 0.02260541f, -0.24785548f, 0.15812562f, 
    0.26709789f, 0.30121249f, -0.21695751f, -0.02028117f, -0.17462963f, -0.05923720f, 0.00650400f, 0.17729782f, 
    -0.02384274f, 0.07480487f, -0.09285336f, 0.09063645f, -0.37119764f, 0.34693944f, 0.05263423f, 0.28550246f, 
    0.03616387f, 0.07659240f, -0.00146231f, 0.09550495f, -0.05587723f, 0.08412308f, -0.03531664f, -0.03542659f, 
    -0.30687439f, 0.13997772f, -0.06333185f, -0.08830912f, 0.06259004f, 0.10224638f, -0.02749153f, 0.04028223f, 
    -0.10416104f, 0.02802265f, 0.01003779f, 0.11316952f, -0.05596399f, -0.26942715f, 0.07158951f, -0.00577050f, 
    0.01315865f, -0.00250377f, 0.01475247f, 0.13437270f, -0.00031149f, -0.06299905f, 0.10295497f, -0.11974710f, 
    -0.16295114f, -0.07617967f, 0.26818702f, -0.08185199f, -0.03986772f, -0.06420753f, -0.25925237f, -0.02521699f, 
    -0.05742032f, -0.02163106f, 0.09876879f, 0.00539081f, 0.16567156f, -0.35649779f, -0.05286632f, -0.16527861f, 
    0.07583560f, 0.21945001f, -0.16039844f, 0.08820935f, -0.09202915f, -0.05145537f, -0.11288561f, -0.11042717f, 
    0.48983827f, -0.01645794f, -0.08206072f, -0.00867338f, 0.02693625f, 0.08188878f, 0.03678099f, 0.03675410f, 
    -0.01147213f, -0.00429136f, 0.08086415f, 0.19468156f, -0.26065874f, -0.20622060f, -0.18102472f, -0.05327812f, 
    0.06116024f, -0.02600234f, -0.04390169f, -0.16592450f, -0.03876758f, 0.04019997f, -0.03056472f, -0.02589397f, 
    0.30947745f, -0.04441920f, -0.14154947f, -0.01721732f, 0.07643439f, -0.08527209f, 0.13064288f, 0.04174663f, 
    0.08399794f, -0.14089455f, -0.09363263f, -0.09438139f, -0.02925662f, 0.05034656f, -0.11593897f, 0.09235268f, 
    0.06712015f, 0.17853233f, -0.00510535f, -0.08120129f, 0.16033533f, -0.02051568f, 0.07435665f, 0.12855768f, 
    0.28605911f, 0.18719077f, -0.43216467f, 0.02393642f, 0.16322756f, 0.08231515f, 0.24876979f, 0.09189790f, 
    0.02409817f, 0.07598687f, -0.02226305f, 0.16984862f, -0.16469099f, 0.12035283f, 0.32315883f, 0.25158527f, 
    -0.00306370f, 0.02275504f, -0.08326142f, -0.04084075f, 0.01682213f, 0.01328684f, -0.09036408f, 0.14270362f, 
    0.33425134f, 0.23722973f, 0.17409112f, -0.02357289f, 0.04045635f, 0.05601049f, 0.19020152f, 0.13106591f, 
    -0.04155906f, 0.04824378f, 0.09759927f, -0.12660286f, -0.24314924f, 0.08348648f, 0.02086270f, 0.00362873f, 
    0.07399814f, -0.01270642f, 0.01459286f, 0.03892677f, -0.03784387f, -0.06977171f, 0.04943071f, 0.08152448f, 
    -0.01381788f, -0.07708386f, -0.10819795f, -0.04072218f, -0.06830134f, 0.06332063f, -0.13349926f, -0.06202258f, 
    0.05507450f, 0.08284967f, 0.14784367f, 0.07872309f, 0.18917465f, 0.14651340f, -0.09873848f, -0.13350934f, 
    -0.02393020f, -0.10644441f, 0.09685048f, 0.10196038f, 0.02900157f, -0.01197504f, 0.07572208f, -0.08181182f, 
    -0.20192540f, -0.09187721f, -0.35904619f, -0.10236666f, -0.09437956f, -0.00426589f, 0.09047329f, 0.00654082f, 
    0.17503446f, -0.03231292f, 0.16784824f, 0.08340435f, 0.58820528f, 0.14733754f, 0.22796139f, -0.13799416f, 
    0.18975517f, -0.05353498f, -0.14601092f, 0.07698943f, 0.03418011f, -0.06958091f, 0.03952591f, 0.12068666f, 
    0.21701986f, 0.01583126f, 0.32388577f, 0.17046234f, -0.14060533f, -0.13056020f, -0.08615807f, -0.10816130f, 
    -0.01916358f, -0.03008718f, -0.00199269f, 0.14442396f, -0.18199368f, 0.05523419f, -0.85212868f, 0.20083849f, 
    -0.11406450f, 0.11278050f, 0.14659962f, 0.06010197f, 0.06938635f, -0.10554634f, -0.00211528f, -0.07796755f, 
    0.15803631f, -0.31425974f, -0.00420620f, 0.08416792f, 0.11606929f, 0.14169510f, 0.04420569f, 0.01952234f, 
    -0.07285315f, -0.20142211f, -0.13824748f, 0.09596535f, 0.07910258f, 0.43184674f, 0.37447473f, 0.10814229f, 
    0.01627058f, 0.00496674f, 0.17107423f, 0.00444211f, 0.04345762f, -0.02320307f, -0.05608909f, -0.00378109f, 
    -0.38784558f, -0.24565284f, 0.00823069f, -0.06907523f, 0.09665580f, 0.05739075f, 0.02357178f, 0.07588173f, 
    -0.07701597f, -0.03530148f, -0.08826883f, -0.03642355f, 0.26348871f, 0.10876910f, 0.05543889f, 0.07122433f, 
    -0.04932546f, 0.11139897f, 0.07029898f, 0.08016336f, 0.02539027f, -0.01671183f, 0.02123062f, 0.02076108f, 
    0.13005784f, -0.05808999f, 0.25665128f, -0.01536166f, 0.01497189f, -0.15570891f, -0.03827095f, -0.09485751f, 
    -0.05128490f, 0.00455791f, 0.04595049f, 0.03747218f, -0.07613312f, -0.02095425f, -0.00069190f, 0.26956415f, 
    0.03017724f, -0.06090567f, 0.03350883f, -0.14074945f, 0.10472915f, 0.06466994f, 0.05864110f, 0.09418081f, 
    0.15094164f, -0.12530227f, 0.13300940f, 0.03632224f, 0.04490892f, 0.01538851f, 0.13087842f, 0.01069359f, 
    -0.00336410f, -0.00118375f, -0.05211686f, -0.07615071f, -0.19622150f, -0.04061562f, 0.07578823f, -0.08046903f, 
    -0.07667693f, 0.02723802f, -0.00757045f, 0.01153385f, -0.13902341f, -0.02614456f, -0.04045449f, -0.07148805f, 
    -0.22205950f, -0.24926087f, 0.18888864f, 0.15122256f, -0.11721919f, 0.01325197f, 0.08862693f, 0.22091658f, 
    -0.06468617f, 0.10709886f, 0.02543654f, 0.16891482f, -0.05730776f, 0.04115519f, -0.00098117f, 0.24453776f, 
    0.08678298f, -0.00010198f, 0.04026853f, -0.12818810f, -0.02428178f, 0.04249421f, 0.09160884f, 0.12703761f, 
    0.15484019f, 0.09593352f, -0.01700729f, 0.00739112f, -0.03866982f, -0.00446063f, 0.03181280f, -0.08384278f, 
    0.18808326f, 0.00887848f, 0.07158833f, 0.02660987f, -0.03875167f, 0.01886813f, 0.19521895f, 0.11737798f, 
    -0.05984102f, -0.02100135f, 0.05132422f, 0.05348623f, -0.07124180f, -0.13180038f, -0.02748283f, -0.08099624f, 
    0.28064206f, 0.11635914f, 0.15137668f, -0.13473208f, -0.00470823f, 0.04749020f, -0.04320063f, 0.04637116f, 
    -0.02133884f, 0.11567786f, -0.02744796f, -0.02432983f, 0.25697368f, 0.00836200f, 0.13960876f, -0.02309229f, 
    0.10560483f, 0.12432677f, 0.05104953f, 0.07375171f, 0.17512235f, 0.03982427f, 0.09221068f, 0.01092503f, 
    -0.17616022f, 0.08424296f, -0.06673133f, -0.11238112f, -0.07632672f, -0.08370893f, -0.05088635f, -0.09372894f, 
    0.10484692f, 0.06889387f, 0.00752037f, 0.20890205f, 0.50197083f, -0.29880714f, 0.20197877f, -0.14137675f, 
    0.00412859f, -0.08712953f, 0.05354588f, -0.11962659f, -0.11055721f, -0.04049761f, -0.08112930f, 0.02142549f, 
    0.03487594f, -0.03584868f, -0.05856669f, 0.04150962f, 0.13862017f, -0.09300085f, -0.01964912f, 0.05680667f, 
    -0.02181387f, 0.00952210f, -0.01710829f, 0.08496952f, -0.35352451f, -0.08349670f, -0.05071175f, 0.02338886f, 
    -0.01374555f, -0.03204613f, 0.06269535f, 0.10465147f, -0.02935826f, 0.01568080f, -0.07811555f, 0.04007821f, 
    0.02552473f, 0.07994601f, -0.13706179f, -0.13977697f, -0.04946313f, -0.13198675f, 0.03819716f, 0.00527692f, 
    -0.07523789f, -0.01421049f, 0.05945132f, 0.02776333f, -0.23030539f, -0.20046625f, -0.00710807f, 0.35980994f, 
    -0.12391666f, 0.06656740f, -0.02354040f, -0.14456797f, -0.00184060f, 0.03182912f, 0.03107665f, 0.06024257f, 
    -0.27630311f, 0.06564853f, 0.27778071f, 0.10089324f, 0.07892919f, 0.02673115f, -0.08213804f, 0.08918316f, 
    -0.04912453f, 0.06836885f, 0.03322623f, 0.05244583f, 0.23909540f, -0.12300714f, -0.22840932f, 0.04144729f, 
    0.07255002f, 0.11854590f, 0.14920121f, -0.01670022f, -0.04725997f, 0.06290030f, 0.01342217f, 0.08409265f, 
    0.06717832f, -0.32534954f, 0.20090096f, 0.31167114f, -0.15440401f, 0.11428536f, 0.04641527f, 0.01785754f, 
    -0.01107524f, -0.10984081f, -0.03534589f, -0.08098055f, 0.00496995f, 0.03120153f, 0.11170835f, -0.24476057f, 
    0.04397402f, 0.03471003f, 0.08251995f, -0.16715632f, -0.11566456f, 0.08615084f, -0.11252494f, -0.14729697f, 
    -0.03969393f, -0.33782858f, 0.16334450f, 0.17735736f, 0.00778791f, 0.00418670f, 0.02945160f, 0.01660170f, 
    0.05972667f, 0.00491659f, 0.07001198f, 0.06472251f, 0.24500719f, 0.04127463f, -0.03893455f, 0.23441678f, 
    0.04477102f, 0.05913930f, 0.00907713f, -0.15592705f, -0.04111383f, 0.02582332f, -0.02087797f, 0.11703861f, 
    -0.02755067f, -0.03313072f, -0.03322587f, -0.24283680f, -0.04336877f, 0.01809795f, -0.01490886f, -0.04615989f, 
    0.08893247f, 0.14170258f, 0.13213116f, -0.01019969f, 0.12050963f, 0.16990219f, 0.12325366f, 0.20698471f, 
    0.03318519f, 0.07282785f, 0.09891656f, 0.09615646f, 0.02285748f, 0.18824506f, -0.15470392f, 0.04344990f, 
    0.22459151f, 0.13938038f, 0.00651433f, -0.29169384f, -0.04096152f, -0.02448602f, 0.03691350f, -0.00671181f, 
    -0.20451802f, 0.06403068f, -0.10078173f, -0.01395948f, -0.32143942f, 0.00668932f, -0.06593201f, 0.48480475f, 
    0.14125970f, 0.11316188f, -0.06204352f, 0.15174912f, 0.03370108f, 0.08477483f, 0.06420953f, 0.10006887f, 
    -0.11221953f, 0.24947101f, -0.16336548f, -0.40873721f, 0.08754396f, 0.20941041f, 0.04520530f, 0.01072039f, 
    0.08628213f, 0.21981373f, 0.01540588f, 0.22653458f, 0.23124857f, -0.12855780f, -0.01817620f, -0.19090056f, 
    -0.21467178f, 0.01656672f, 0.01983706f, -0.05421129f, -0.04535465f, 0.09157752f, 0.00791897f, -0.05341583f, 
    -0.06327175f, -0.03918944f, -0.05185433f, 0.02492187f, -0.03840840f, 0.07455721f, 0.01943209f, 0.00453013f, 
    -0.03117232f, 0.08015162f, 0.13125990f, 0.07112459f, -0.19908901f, -0.13664941f, -0.09885262f, 0.03712507f, 
    -0.10003410f, 0.07017158f, 0.07984709f, 0.02388211f, -0.00827153f, 0.04485007f, -0.04068608f, -0.01316632f, 
    0.16407622f, 0.17190841f, -0.15121594f, -0.30965343f, -0.00124056f, -0.10160679f, -0.12452064f, -0.02611311f, 
    -0.02796358f, 0.08722224f, 0.16841619f, 0.06991087f, -0.15649687f, -0.21696374f, -0.35882637f, 0.28573745f, 
    -0.03618732f, -0.01514199f, -0.11554819f, -0.16505706f, -0.11572416f, -0.00124430f, -0.07070467f, 0.09186523f, 
    0.35618639f, 0.11448206f, -0.02557609f, 0.05173608f, 0.01867122f, -0.14166765f, 0.13602775f, -0.08005532f, 
    -0.07518753f, -0.02974804f, -0.01570108f, -0.00267307f, -0.19695246f, -0.26241806f, 0.03825710f, 0.11692505f, 
    0.17469476f, -0.10840044f, -0.03056782f, 0.09651594f, 0.01416162f, 0.04475852f, 0.03146927f, 0.12676181f, 
    0.24114920f, 0.08232721f, 0.02169974f, 0.01357502f, -0.00135819f, 0.00469451f, 0.24518147f, -0.02708934f, 
    0.26606199f, 0.08552096f, 0.15850684f, 0.14604881f, 0.04734270f, -0.05455159f, -0.02860254f, 0.00913205f, 
    -0.04152865f, -0.06083214f, -0.05719246f, 0.01515480f, 0.17040923f, -0.13153109f, 0.03735946f, 0.04840822f, 
    -0.45315117f, -0.47493014f, -0.24794757f, 0.10516427f, 0.16513829f, -0.01740746f, -0.13022080f, -0.01338094f, 
    -0.10281027f, -0.20072885f, -0.04154409f, 0.06690137f, 0.12193098f, -0.07228635f, 0.17407939f, -0.09791144f, 
    0.16504355f, -0.11067736f, 0.10559145f, 0.01766362f, 0.11820630f, 0.06602480f, 0.16470261f, -0.12175308f, 
    0.16012044f, 0.21625970f, 0.12149888f, 0.05114884f, -0.09267363f, 0.00307649f, -0.00862431f, -0.01589829f, 
    0.01448114f, 0.14367487f, 0.02286303f, 0.10710184f, -0.05416314f, -0.13473682f, 0.16241111f, 0.07337216f, 
    -0.02629814f, -0.06666683f, -0.07070157f, 0.01304885f, -0.11085855f, -0.22546583f, 0.00113242f, -0.18938771f, 
    0.19510594f, 0.08877724f, 0.11087906f, 0.04593201f, -0.12103000f, 0.08326285f, -0.04960156f, 0.01716983f, 
    0.04264239f, -0.01977033f, 0.07763732f, -0.05243052f, 0.06324375f, 0.18342632f, -0.06394797f, -0.34151244f, 
    -0.14749774f, -0.06381317f, 0.13302265f, -0.08942973f, 0.26158917f, 0.09239378f, 0.03932110f, 0.05624318f, 
    0.09918581f, 0.02846489f, 0.21768473f, 0.13234164f, 0.03969779f, 0.07452560f, 0.01588925f, 0.00666179f, 
    -0.07718377f, -0.08325484f, 0.12885395f, 0.08680594f, 0.19558448f, 0.11023436f, 0.18320920f, 0.03121037f, 
    -0.23511998f, -0.00385265f, 0.07839037f, -0.08412764f, 0.01662847f, 0.06970775f, -0.10667515f, -0.08001225f, 
    -0.09590070f, 0.08225130f, 0.05557384f, 0.07404931f, 0.26289526f, 0.06347075f, -0.04807614f, -0.05988971f, 
    -0.05426011f, 0.02182098f, -0.15155059f, -0.11592959f, -0.08407443f, -0.12540424f, -0.01112837f, -0.00000673f, 
    0.27726135f, 0.03879977f, -0.03561971f, 0.02473486f, -0.14086761f, -0.02575698f, -0.00535701f, -0.11199018f, 
    0.03057824f, 0.08312711f, -0.05236259f, 0.14013118f, -0.03404112f, 0.10494341f, 0.08307076f, 0.03081273f, 
    -0.18230137f, -0.19962636f, -0.10354096f, -0.16349983f, -0.39632404f, -0.54246694f, -0.09964655f, -0.20968321f, 
    0.16181937f, -0.06687564f, -0.06216440f, 0.03217722f, -0.13548622f, 0.01678012f, -0.01808960f, 0.04207624f, 
    0.06440765f, 0.13263163f, 0.10054072f, -0.26510239f, -0.01493923f, 0.14741617f, -0.04277745f, 0.20078665f, 
    0.05373384f, -0.08518822f, -0.00658628f, -0.01800533f, -0.32966602f, -0.11288188f, 0.06010831f, -0.12377869f, 
    -0.03029213f, -0.13239565f, -0.01396919f, -0.03204313f, -0.02340169f, -0.08301523f, 0.05791714f, 0.14257067f, 
    0.10352539f, 0.23522335f, -0.13338910f, 0.28289026f, 0.25088120f, 0.04523301f, 0.02844068f, 0.10837445f, 
    -0.06213744f, -0.01479041f, 0.02965415f, -0.14086753f, -0.34327942f, 0.03794778f, 0.01212778f, -0.12388945f, 
    0.01414529f, -0.07291108f, 0.02398180f, -0.03862018f, 0.07931079f, 0.13541403f, 0.09533432f, 0.05953050f, 
    0.11503571f, 0.23264912f, 0.37852985f, 0.09748675f, 0.15557846f, 0.06899986f, 0.13032560f, -0.34018975f, 
    0.05934571f, -0.07564049f, -0.01310039f, -0.09731543f, -0.31985459f, 0.05121360f, -0.18013057f, 0.28063071f, 
    0.02110363f, 0.02277066f, 0.10319222f, -0.19124210f, 0.14228992f, 0.11311637f, 0.23480129f, -0.02794491f, 
    0.05179585f, -0.18850321f, -0.10525417f, 0.07341277f, -0.00935868f, -0.04582170f, 0.06230608f, 0.03069255f, 
    -0.00386431f, -0.02222574f, -0.07035401f, 0.09652461f, -0.32812616f, -0.15299045f, -0.09879334f, 0.02033639f, 
    0.14718312f, 0.07512629f, 0.14427270f, 0.01319680f, -0.00893949f, -0.01012298f, -0.16571228f, 0.07533430f, 
    -0.03496730f, 0.21982223f, -0.05165249f, 0.29409766f, 0.05629215f, 0.05366120f, -0.09868782f, 0.14019716f, 
    0.04304991f, 0.05375987f, 0.20921788f, -0.08358427f, 0.01979997f, 0.06902143f, -0.07463396f, 0.06728001f, 
    0.08361124f, 0.05883619f, 0.04182265f, 0.24301885f, -0.04178193f, -0.04539580f, -0.14376490f, 0.00159497f, 
    -0.33392021f, -0.31901976f, -0.06867786f, 0.07436696f, 0.05850310f, -0.03629302f, -0.11880557f, -0.00728855f, 
    0.11223815f, -0.02379739f, -0.00627799f, 0.11904620f, 0.47148308f, -0.38708013f, -0.02042726f, 0.24825771f, 
    0.12559815f, 0.09594511f, -0.02769825f, 0.13781638f, -0.07365263f, -0.02308230f, -0.11919875f, 0.00105634f, 
    -0.02256530f, -0.18651830f, -0.03928107f, -0.15554807f, 0.03007759f, 0.15785426f, -0.06905485f, -0.08928571f, 
    0.03852114f, -0.16612412f, -0.02508097f, 0.05008984f, 0.21724437f, -0.23585188f, 0.12278417f, -0.06408086f, 
    0.08948334f, 0.09277753f, -0.08480489f, 0.01998104f, 0.07011195f, -0.00822033f, -0.06596543f, -0.09019542f, 
    0.11549006f, -0.42176667f, 0.05483817f, 0.02476831f, 0.05209196f, 0.04244822f, -0.03079671f, 0.09397472f, 
    -0.09097119f, 0.10680956f, 0.07701502f, 0.05643633f, -0.33315936f, -0.02002791f, 0.20711090f, 0.08192619f, 
    0.05426118f, 0.05665014f, 0.00926614f, -0.11528419f, 0.03064149f, 0.05010990f, 0.03576254f, 0.01355104f, 
    -0.09593041f, -0.06630705f, 0.01563062f, -0.06878094f, 0.03598661f, -0.12238093f, -0.01694877f, -0.10268322f, 
    -0.09030803f, -0.00470224f, 0.03757898f, -0.02900542f, -0.04666041f, 0.00684647f, -0.04855390f, -0.01030015f, 
    -0.10720442f, -0.06474495f, -0.02562521f, 0.05161600f, 0.04225422f, -0.08019165f, -0.03312483f, 0.02427231f, 
    -0.03508907f, 0.04824417f, -0.02031308f, -0.01166382f, -0.01237634f, -0.02752819f, -0.01533333f, -0.04549745f, 
    0.00133184f, -0.09952947f, -0.03195268f, 0.02754347f, -0.09373302f, 0.01680863f, -0.03297555f, 0.03027289f, 
    0.03054951f, -0.04086521f, -0.08240121f, 0.02312001f, -0.00891443f, -0.00333289f, -0.06987807f, -0.01164925f, 
    0.03115398f, 0.00363913f, 0.04896513f, -0.05404481f, -0.10057089f, -0.10179946f, -0.09336449f, 0.03046066f, 
    -0.00836549f, -0.02462892f, 0.01100863f, 0.05342595f, -0.09902804f, 0.02760759f, -0.04071696f, -0.10324396f, 
    0.05592910f, -0.07619046f, -0.10829457f, 0.05019500f, -0.04384366f, -0.00869154f, -0.08654104f, -0.04416241f, 
    -0.03598216f, 0.01611452f, -0.06991136f, -0.01825016f, 0.00175917f, -0.08205173f, -0.00159122f, -0.08651333f, 
    -0.06709564f, 0.05956357f, -0.02129576f, -0.08624244f, -0.05514938f, -0.06440798f, -0.05728793f, -0.06694463f, 
    -0.01537803f, 0.06408032f, -0.08414589f, -0.01325994f, -0.02657570f, -0.03786992f, 0.01983501f, -0.09487483f, 
    0.02113446f, -0.13637592f, -0.04411357f, -0.07187776f, -0.08137124f, -0.01372476f, -0.05770116f, -0.05875977f, 
    0.02341111f, 0.02974645f, -0.06392526f, -0.05510065f, -0.03697951f, 0.00820834f, 0.05698203f, -0.09504610f, 
    -0.04318902f, -0.09039121f, 0.06357358f, -0.04295301f, 0.04040290f, 0.01034044f, -0.03856625f, 0.02945262f, 
    -0.06512870f, -0.04650656f, -0.02590496f, 0.02564982f, 0.03094494f, -0.02967350f, -0.01335422f, 0.00630055f, 
    -0.06575134f, 0.05981676f, 0.04080482f, 0.02098636f, 0.01066188f, -0.00414844f, 0.01590004f, -0.00664462f, 
    0.05659032f, -0.04649031f, -0.03267113f, -0.07354444f, -0.07130831f, -0.00785790f, -0.04588838f, -0.08219515f, 
    0.02515101f, -0.04784382f, -0.03195694f, -0.07390103f, -0.04391816f, -0.11965852f, -0.08891341f, -0.04166608f, 
    -0.07600278f, 0.03449307f, -0.01520066f, -0.03883126f, 0.03904294f, -0.03571191f, 0.04111598f, 0.00930665f, 
    -0.00831266f, 0.00716404f, 0.02317879f, -0.06793137f, -0.00298997f, 0.06422659f, 0.00720055f, -0.02639215f, 
    -0.08968969f, -0.08308233f, 0.02670628f, -0.07619650f, -0.02290295f, -0.04259421f, -0.07439312f, 0.03213246f, 
    0.03749615f, -0.08258567f, -0.04810031f, -0.06765334f, 0.01894435f, 0.03287167f, -0.05884857f, -0.06282467f, 
    0.02855326f, -0.00644016f, 0.01483728f, -0.00653867f, -0.00206265f, -0.02937326f, 0.02085017f, -0.05619992f, 
    0.01485532f, 0.14926393f, 0.05294852f, 0.07411601f, 0.17547983f, 0.07542673f, -0.08738167f, 0.03076653f, 
    0.18904339f, -0.04507090f, -0.02896265f, -0.03472579f, -0.28429240f, -0.07240420f, -0.02048927f, -0.10427869f, 
    -0.14770374f, -0.11663713f, -0.02685958f, 0.26688254f, -0.05066941f, -0.13588376f, -0.10616272f, -0.03988877f, 
    0.05299990f, 0.34579396f, -0.24961866f, 0.13686506f, 0.17856187f, 0.02513406f, 0.18625058f, 0.12264656f, 
    -0.03180551f, -0.12463741f, 0.01759625f, -0.01450261f, 0.10348509f, 0.08874195f, 0.18018016f, -0.15686968f, 
    -0.01692021f, -0.01713890f, -0.03079647f, 0.02569139f, 0.19195171f, -0.03153238f, -0.06270735f, 0.05172903f, 
    0.01589889f, 0.22827628f, 0.31434357f, 0.11169842f, 0.18497202f, 0.06376533f, 0.09363182f, -0.09824654f, 
    0.05186736f, -0.05211065f, 0.18625958f, -0.15023489f, -0.01064379f, 0.07092124f, 0.07382169f, 0.17335896f, 
    0.02912262f, -0.01983625f, 0.15113644f, 0.13612069f, -0.01688746f, -0.17093740f, 0.19871925f, -0.05592826f, 
    0.04236653f, -0.12399094f, -0.14569481f, -0.11237527f, -0.00483105f, 0.10014712f, -0.16743954f, -0.00570567f, 
    -0.04102637f, 0.01858437f, 0.00952258f, -0.04165593f, -0.07810485f, 0.10514552f, -0.17257571f, -0.01700282f, 
    -0.02582596f, -0.23940820f, 0.16722827f, 0.18530650f, 0.11884470f, 0.08564693f, -0.00354345f, 0.04849558f, 
    -0.37242952f, -0.01418757f, -0.11392298f, 0.27626088f, -0.14300625f, 0.01503119f, 0.07997077f, -0.02279355f, 
    0.06675322f, -0.10304780f, 0.26630071f, -0.07894014f, -0.14507172f, 0.23979190f, 0.14248767f, -0.03327520f, 
    -0.07504514f, -0.13448228f, -0.04961115f, 0.17645246f, 0.01688276f, -0.03433064f, -0.09812057f, -0.14585623f, 
    0.10764780f, 0.06473500f, 0.07462570f, -0.02766353f, -0.06433529f, -0.07478429f, -0.06908635f, -0.06020559f, 
    0.12563404f, 0.14044310f, -0.00296204f, -0.06252552f, -0.14757843f, 0.15377419f, -0.52685589f, 0.29468846f, 
    -0.01665065f, 0.09851791f, -0.06273096f, 0.09099241f, 0.04734616f, -0.10698469f, -0.04480176f, 0.00183637f, 
    0.07176710f, -0.07564494f, 0.11538598f, 0.02039961f, -0.15644124f, 0.13031246f, 0.14130802f, -0.13083856f, 
    0.00224807f, 0.00205002f, -0.02546320f, -0.06713012f, 0.16680492f, -0.05163065f, 0.06249336f, 0.03651608f, 
    -0.04570683f, 0.17289934f, 0.01166513f, -0.02316070f, 0.04172537f, 0.11487626f, 0.09221586f, -0.04782513f, 
    -0.02139344f, -0.09401856f, -0.06053208f, 0.18529636f, -0.12398772f, 0.01252931f, -0.04461567f, -0.02758656f, 
    0.03774014f, -0.01362391f, -0.07397775f, 0.02309081f, -0.23040703f, -0.14026214f, 0.14273354f, 0.00775177f, 
    -0.08203959f, -0.02983785f, -0.05165665f, 0.17689233f, -0.07449959f, -0.01480450f, 0.11383706f, 0.13834938f, 
    0.18079609f, 0.10283062f, -0.26082975f, -0.11259236f, 0.02528318f, -0.12694004f, 0.20824057f, -0.08729476f, 
    -0.04301675f, 0.04751831f, -0.08690218f, -0.01594029f, 0.09709677f, 0.11684695f, 0.12306483f, -0.10209793f, 
    0.03359335f, 0.05034216f, -0.02615886f, 0.12419051f, 0.18065034f, -0.05605919f, -0.05115828f, -0.01694199f, 
    -0.00255771f, 0.04256227f, -0.07053970f, -0.32464135f, 0.05308306f, -0.03025566f, -0.00133200f, -0.00343157f, 
    -0.01453666f, 0.03583355f, 0.12409643f, 0.06655578f, 0.14930081f, 0.05124036f, -0.14106824f, 0.15560810f, 
    0.02205810f, -0.00422540f, -0.02140469f, -0.00486856f, 0.12971397f, 0.04357784f, 0.09480173f, 0.15801269f, 
    0.10546075f, 0.12152017f, -0.30125371f, -0.16644822f, -0.01686127f, 0.03762728f, -0.00351007f, 0.04638365f, 
    -0.00929659f, -0.13205625f, -0.21431656f, -0.04518300f, -0.10524885f, -0.07185142f, 0.14906044f, -0.29021600f, 
    -0.10163533f, 0.07784051f, -0.19134244f, 0.25488651f, 0.07417548f, 0.00428891f, -0.05442893f, -0.12821518f, 
    -0.01559639f, 0.10444093f, 0.03394591f, 0.12546806f, -0.10536918f, -0.02270336f, 0.06188661f, 0.00697614f, 
    -0.07784799f, -0.05528640f, -0.03958783f, -0.00762006f, 0.06209083f, -0.04693081f, -0.07430654f, -0.05486621f, 
    0.03852902f, 0.15617307f, -0.20425333f, -0.10467482f, -0.05805100f, -0.04530880f, 0.21584013f, 0.01362944f, 
    -0.04451568f, -0.10422279f, -0.15445818f, 0.00788647f, 0.15101589f, 0.01205522f, -0.04339722f, 0.02162615f, 
    0.12546045f, -0.06770366f, 0.01757674f, -0.01109112f, 0.40925878f, -0.15439345f, -0.08107040f, -0.14119297f, 
    -0.01606146f, 0.10937722f, 0.03345949f, -0.13311273f, 0.04006439f, 0.01897271f, 0.08319101f, 0.01751584f, 
    0.09136670f, -0.07247484f, 0.21315148f, 0.12347699f, -0.06015047f, -0.02258080f, 0.02858619f, 0.07601897f, 
    -0.13843307f, -0.06274668f, -0.08220495f, -0.13394347f, -0.42224231f, 0.23442109f, 0.14086179f, 0.00711254f, 
    0.15061842f, 0.00103662f, -0.01795967f, -0.01703315f, 0.07023798f, 0.00959130f, 0.06616145f, 0.09073065f, 
    -0.01611429f, 0.09895352f, 0.18682048f, 0.05818075f, 0.10328724f, 0.00663743f, 0.02433944f, 0.08311222f, 
    0.06491738f, -0.07732320f, -0.05155308f, -0.01026951f, 0.07787578f, 0.22733894f, 0.07988972f, -0.03604335f, 
    0.01935994f, -0.03037360f, 0.03276160f, -0.06505599f, 0.00327972f, -0.14267260f, 0.06957645f, 0.04276514f, 
    -0.12786968f, -0.00918565f, 0.14375240f, 0.22946942f, 0.05533057f, -0.01221973f, 0.05571137f, 0.02441585f, 
    0.00531681f, -0.09073841f, 0.03090062f, -0.08344223f, 0.32977268f, 0.26386833f, 0.19799556f, -0.16925916f, 
    0.14463075f, -0.05245588f, 0.04640463f, 0.20620033f, 0.04686008f, -0.11895556f, -0.20684694f, -0.13852987f, 
    0.30689299f, 0.07702933f, -0.04643881f, 0.04202935f, 0.06770398f, 0.14865603f, -0.02520027f, 0.07398313f, 
    -0.02969994f, -0.13986869f, -0.02333551f, -0.17199035f, -0.22687267f, 0.00347120f, 0.18793167f, -0.10020394f, 
    -0.07594016f, 0.09762796f, 0.05153781f, 0.08493902f, -0.01136950f, 0.01929414f, 0.13475762f, 0.20565322f, 
    0.26632661f, 0.31559843f, -0.23171254f, 0.07755604f, 0.33629897f, 0.11417808f, 0.12275486f, -0.06639566f, 
    0.11110505f, 0.19159633f, 0.12745790f, 0.23523448f, -0.07531244f, 0.25967708f, 0.24218258f, 0.12997890f, 
    -0.05726222f, -0.15178606f, -0.04809695f, 0.13779855f, 0.35051242f, 0.08856785f, 0.17227925f, 0.21957174f, 
    0.14939289f, 0.18188517f, 0.12344399f, -0.02253561f, 0.15772347f, 0.12507978f, 0.04182572f, -0.20343551f, 
    0.14835665f, -0.10435688f, 0.17626265f, -0.07646386f, 0.08252876f, 0.19543646f, 0.21374775f, 0.05052187f, 
    0.09243193f, 0.00606350f, 0.25129348f, 0.01845728f, 0.06862810f, 0.08090461f, 0.14355662f, -0.00447914f, 
    0.00328179f, -0.18937606f, -0.29212809f, -0.07057205f, 0.00415648f, 0.01285812f, -0.08946136f, 0.13806160f, 
    -0.09677000f, 0.15284069f, -0.00451487f, 0.04388738f, 0.01656392f, 0.35458389f, 0.13340229f, 0.09774905f, 
    -0.07430343f, -0.16324307f, -0.01662082f, -0.03642621f, -0.06621339f, -0.12838581f, -0.23452827f, -0.10519309f, 
    -0.26653880f, -0.06712466f, -0.19115010f, 0.13344227f, -0.26403835f, 0.15805203f, 0.08680829f, -0.14274187f, 
    0.06036689f, 0.06342363f, 0.22771168f, 0.16570848f, 0.02791059f, 0.47024038f, 0.01087698f, -0.05379426f, 
    -0.06943485f, -0.13069315f, -0.01129472f, 0.04536243f, -0.03721993f, 0.12062331f, -0.08114684f, -0.03027000f, 
    -0.06277040f, 0.05454049f, 0.44714019f, 0.33565417f, 0.09786370f, -0.16087057f, -0.12509449f, -0.03296151f, 
    -0.02161371f, 0.09423457f, 0.05927590f, -0.07777703f, -0.04016690f, -0.07005213f, -0.50769919f, 0.07044044f, 
    0.04918988f, 0.18887793f, -0.08273368f, 0.03064169f, -0.07771135f, 0.02135625f, 0.06861422f, -0.01431350f, 
    -0.01697610f, 0.05867575f, 0.22728613f, 0.08567732f, -0.02920384f, 0.09400383f, -0.00954959f, -0.06461783f, 
    -0.17723984f, -0.26365492f, -0.12621546f, -0.26445112f, 0.09981935f, -0.00902370f, 0.15763649f, -0.16948223f, 
    0.02339503f, 0.16133420f, 0.09585641f, 0.06916399f, 0.10258015f, -0.04019313f, -0.08819040f, -0.15478694f, 
    -0.18863185f, -0.05299459f, 0.05235062f, 0.22802123f, -0.04108866f, 0.09644023f, -0.00713803f, 0.08187676f, 
    -0.18282239f, -0.19542277f, -0.24306832f, -0.19499961f, -0.01474767f, -0.09318505f, -0.04888366f, -0.09399244f, 
    -0.00316469f, 0.09542003f, -0.01807072f, 0.00303711f, -0.06074093f, 0.06983353f, 0.04291052f, -0.08490077f, 
    -0.31113163f, -0.29863071f, -0.16833411f, 0.05918765f, -0.05921499f, -0.09225095f, -0.00396154f, -0.25285107f, 
    0.00675949f, 0.07288019f, 0.13719437f, 0.20816241f, 0.45943019f, 0.36821929f, 0.33873072f, 0.36192912f, 
    0.17119668f, -0.03132759f, -0.04369723f, 0.00940856f, 0.13166904f, 0.03142153f, -0.06695499f, -0.13546246f, 
    -0.35590217f, -0.13524377f, 0.31819841f, -0.19157490f, 0.21473725f, -0.01184928f, 0.00790163f, 0.01536860f, 
    -0.05738617f, 0.23929307f, -0.08298392f, -0.06329615f, 0.10075846f, -0.15532832f, -0.19016610f, 0.26016968f, 
    0.02776093f, -0.06397417f, 0.01699495f, -0.05378965f, -0.13343899f, -0.11503423f, -0.05920336f, 0.06244131f, 
    0.09323197f, 0.03890349f, -0.35069099f, -0.09851521f, 0.15799636f, 0.19459978f, 0.07608666f, 0.38701969f, 
    -0.03220160f, 0.10655490f, -0.08280066f, 0.12907435f, 0.42966834f, 0.21065095f, 0.06774465f, -0.18333799f, 
    0.05490552f, 0.04062859f, 0.04609139f, 0.25102904f, 0.10922315f, -0.11985596f, 0.00058850f, 0.14939998f, 
    -0.19144477f, 0.03645374f, 0.02637675f, -0.03750739f, -0.20664908f, -0.04779095f, -0.16445905f, -0.10535625f, 
    0.16523688f, -0.03939899f, 0.11845510f, 0.08308920f, -0.01711124f, -0.18379936f, 0.08410162f, -0.05712381f, 
    -0.00236848f, 0.05040579f, 0.15190464f, -0.05745126f, 0.03713876f, -0.01076683f, 0.11622171f, 0.00088221f, 
    0.05069464f, -0.09454151f, 0.13395363f, -0.09743155f, 0.14540592f, -0.21075849f, -0.07623359f, -0.24442181f, 
    0.04549668f, 0.02225986f, -0.28719518f, 0.16785203f, 0.21854708f, -0.05410348f, 0.22686689f, 0.15213898f, 
    -0.01438583f, 0.09129054f, 0.13801488f, -0.18530011f, 0.05394669f, -0.01122091f, 0.04964028f, -0.00421584f, 
    -0.12267720f, -0.06252109f, 0.02001774f, -0.06909173f, -0.16861846f, 0.05635679f, -0.05106008f, -0.04277365f, 
    0.00137829f, -0.03575251f, 0.07682451f, 0.07147844f, -0.26236042f, -0.01027304f, 0.24955252f, 0.15598398f, 
    -0.10865522f, -0.14104876f, -0.11728130f, -0.07550448f, 0.05056787f, 0.02909990f, -0.08012723f, -0.03907758f, 
    -0.01889951f, 0.02102088f, -0.21431838f, -0.15554501f, 0.26297686f, -0.05557607f, 0.03928070f, 0.17984892f, 
    0.13476089f, 0.17886411f, -0.04647725f, -0.06410437f, -0.13810897f, -0.00135272f, -0.32415193f, -0.01919637f, 
    0.15357295f, 0.07584504f, 0.13602838f, 0.27372912f, 0.15667543f, 0.05917319f, 0.07048535f, 0.01911182f, 
    -0.08870713f, 0.02491949f, 0.05765465f, 0.08548344f, 0.04328337f, -0.01894363f, 0.02433856f, -0.07316588f, 
    0.01723223f, 0.01225158f, -0.00444698f, 0.15278096f, 0.13334094f, 0.13699199f, -0.00541606f, 0.07247817f, 
    0.05272981f, 0.05680215f, 0.26144218f, 0.15303206f, 0.05096300f, -0.06731166f, -0.04629473f, -0.01360458f, 
    0.50468385f, 0.10656275f, 0.02472371f, 0.19566627f, 0.22893071f, -0.02207681f, -0.01212667f, -0.02081431f, 
    -0.02035723f, -0.10199358f, -0.14484014f, -0.05462720f, -0.76407158f, -0.74757880f, -0.64948851f, -0.59683198f, 
    -0.04301151f, 0.13513398f, 0.20700365f, 0.11221460f, 0.09280466f, 0.10783996f, 0.11343216f, 0.24466451f, 
    0.42955604f, -0.05747936f, -0.03811458f, -0.04702489f, -0.05119945f, 0.07077380f, 0.38550493f, 0.19700673f, 
    0.09593341f, 0.04993483f, 0.12396887f, -0.06512275f, 0.00005004f, 0.25438240f, -0.00906670f, -0.12240565f, 
    -0.03046079f, 0.02865116f, 0.07629024f, 0.03049165f, 0.13090830f, 0.05625007f, 0.04244210f, 0.14583322f, 
    -0.52158040f, -0.27525577f, 0.07377610f, 0.01837311f, 0.16984881f, 0.05929771f, 0.11161473f, 0.05310876f, 
    -0.00633728f, -0.00864856f, 0.06125490f, 0.10919688f, -0.09694970f, -0.26222819f, 0.12427861f, -0.07204225f, 
    0.03032283f, 0.07678581f, -0.14325088f, -0.01789881f, 0.12093949f, 0.13900769f, 0.10691892f, -0.12970084f, 
    0.20475425f, 0.08902368f, -0.01131045f, 0.11245123f, -0.03291053f, 0.03068469f, 0.01219752f, -0.11079443f, 
    0.03559741f, -0.02509598f, -0.04737779f, 0.01424790f, -0.06906999f, -0.24663045f, 0.05078435f, -0.11625399f, 
    -0.01085612f, -0.10905325f, -0.22059025f, -0.02960278f, -0.16057625f, -0.07458661f, -0.01398394f, 0.04941113f, 
    0.22989637f, 0.04203689f, -0.00904218f, 0.17029278f, -0.05589930f, 0.08187039f, -0.12253031f, 0.14782280f, 
    -0.02806577f, 0.13925438f, 0.09411933f, -0.23841403f, 0.54308897f, -0.02789865f, -0.54659271f, -0.43513069f, 
    0.03492722f, 0.02056194f, 0.11505438f, 0.01484255f, 0.34159291f, 0.03422196f, -0.02856920f, -0.00577670f, 
    0.14859001f, -0.06097252f, 0.17572421f, 0.01503535f, -0.10709877f, 0.00245424f, -0.11825357f, 0.03834917f, 
    -0.04932353f, 0.01312282f, -0.03885346f, -0.07789866f, 0.23558950f, 0.24636458f, 0.21939626f, 0.05646421f, 
    -0.04663405f, 0.10855069f, -0.03360212f, -0.06678075f, 0.06416486f, 0.09837655f, 0.08163926f, 0.04366861f, 
    -0.10760055f, 0.04335476f, 0.11732233f, 0.27166352f, 0.12654425f, -0.02981327f, -0.11211869f, 0.03214356f, 
    -0.06673446f, -0.06384313f, -0.07287907f, 0.07031351f, -0.27836263f, -0.10621040f, 0.06410433f, -0.14672785f, 
    0.23046939f, 0.10534120f, 0.03762890f, 0.08358958f, -0.12541281f, -0.07510317f, 0.01934738f, 0.03600830f, 
    -0.12814355f, 0.18869188f, 0.28673384f, 0.10253435f, -0.09917181f, 0.03967176f, 0.03511674f, 0.09689562f, 
    -0.08599236f, -0.04821892f, 0.00117784f, -0.09826630f, -0.29811409f, -0.56475300f, -0.60743380f, -0.40440670f, 
    0.36134291f, 0.11628751f, 0.07824843f, -0.05946202f, 0.01225651f, 0.04732223f, -0.01169342f, 0.01702452f, 
    0.11999859f, -0.33130476f, -0.05477596f, 0.12400681f, -0.22624831f, -0.12894243f, 0.08859148f, -0.16818868f, 
    -0.13251297f, 0.11553386f, 0.06900783f, 0.18485586f, 0.48956820f, 0.27882740f, 0.24286956f, 0.33715153f, 
    0.22402674f, 0.02378414f, -0.02594500f, -0.00745846f, 0.11060639f, 0.02781343f, -0.02243521f, -0.04188086f, 
    -0.01174292f, -0.16795923f, 0.21151938f, -0.20577146f, -0.08802311f, 0.00079865f, -0.03470787f, -0.11824498f, 
    0.11691649f, 0.06733300f, -0.17425917f, 0.03319942f, 0.15047695f, -0.00381869f, -0.17431909f, 0.24535292f, 
    0.00264686f, -0.02937375f, -0.01244272f, 0.12011666f, -0.04165640f, 0.01873404f, -0.05295714f, 0.15100949f, 
    0.00736796f, -0.09419665f, -0.04756746f, 0.00255405f, -0.00730103f, 0.01461882f, -0.04243713f, 0.28805912f, 
    -0.12630016f, 0.11649110f, -0.18392982f, 0.06505633f, 0.38740727f, 0.19906524f, 0.23733445f, -0.14942756f, 
    -0.00131202f, 0.00588641f, 0.01586494f, -0.09408548f, -0.15575640f, -0.18227319f, -0.11156929f, 0.14974655f, 
    -0.18241619f, -0.07570848f, -0.03178341f, -0.11733015f, -0.12608570f, 0.07158326f, -0.06732165f, 0.03570345f, 
    0.01723420f, 0.07523484f, 0.04840864f, -0.06211367f, 0.14101940f, 0.35010996f, 0.39294055f, 0.14457972f, 
    0.11453309f, -0.03047310f, 0.08250260f, -0.09481117f, -0.03088058f, -0.01667317f, 0.09075122f, -0.17786813f, 
    -0.02546328f, -0.29565880f, 0.30441859f, -0.27075517f, -0.01708730f, -0.15008019f, 0.16848290f, -0.21505389f, 
    -0.03348576f, 0.04615676f, -0.08289409f, 0.20989999f, 0.35508162f, 0.00627739f, 0.20547754f, 0.07845117f, 
    0.02360361f, 0.07269578f, -0.02102940f, -0.13532925f, 0.12634929f, 0.14297368f, -0.02851664f, -0.26824462f, 
    -0.24200584f, 0.12356629f, 0.13581309f, 0.08216839f, -0.01234677f, 0.05374212f, 0.06706212f, 0.09245420f, 
    -0.04917752f, 0.03191670f, 0.02067756f, -0.04654330f, -0.25722381f, -0.25990960f, 0.05446567f, -0.13933516f, 
    -0.17220694f, 0.01997478f, 0.09695216f, 0.01065807f, -0.06844181f, 0.02941770f, 0.00658783f, -0.00435947f, 
    0.00271510f, 0.21742035f, -0.17695160f, 0.21024367f, 0.06789102f, -0.13794294f, 0.09140578f, 0.11046221f, 
    -0.10609358f, 0.13124201f, -0.06269465f, 0.02610377f, -0.20074889f, 0.27746034f, -0.04156486f, 0.14875868f, 
    0.09180131f, 0.12986545f, 0.15373832f, 0.23055364f, 0.00801282f, 0.14121622f, 0.03413102f, -0.00125089f, 
    -0.32508498f, 0.18583959f, 0.01477177f, 0.02246716f, -0.09695856f, 0.06972237f, 0.08786375f, 0.02132718f, 
    -0.01418351f, -0.11417820f, -0.08039683f, 0.04457578f, 0.14707273f, 0.11251701f, -0.11884297f, 0.24344668f, 
    0.03002095f, 0.11829808f, 0.10491744f, 0.15369728f, -0.04404084f, -0.03916362f, -0.04493237f, -0.01605180f, 
    -0.04967660f, -0.39158458f, -0.12248325f, 0.08976654f, -0.19707532f, -0.26910087f, 0.17187826f, -0.12651619f, 
    0.01510249f, 0.15389533f, 0.09192539f, 0.07464938f, 0.18425362f, 0.12785892f, 0.12155437f, 0.12491832f, 
    0.06878419f, 0.00486160f, -0.04500996f, 0.09809372f, 0.13899793f, 0.06198967f, -0.01581610f, -0.16679844f, 
    -0.01349075f, -0.03264067f, 0.00795135f, -0.19044943f, 0.18370968f, 0.07687305f, 0.00908538f, -0.30611664f, 
    -0.14168650f, 0.20965126f, -0.19578579f, 0.02291344f, 0.09416063f, -0.00778620f, 0.21815789f, 0.28862241f, 
    -0.09177960f, 0.04146623f, 0.00150447f, 0.08306839f, -0.00603738f, 0.01339157f, -0.05262294f, -0.02699608f, 
    -0.07100844f, -0.05553703f, -0.18663496f, -0.21295393f, -0.09200549f, 0.09779962f, -0.03783359f, 0.08369259f, 
    -0.02006741f, 0.17510504f, -0.09815099f, 0.10577976f, 0.25918394f, 0.14545311f, 0.17366147f, -0.14407894f, 
    -0.09011554f, -0.03462796f, 0.10121062f, 0.18785642f, 0.04834238f, -0.10580985f, -0.00132857f, 0.07483357f, 
    -0.07700287f, 0.13594475f, 0.18313147f, 0.01914056f, -0.15105608f, 0.09386256f, 0.00726491f, 0.07067824f, 
    0.07523046f, 0.00195250f, 0.22953488f, 0.05326286f, -0.09395581f, 0.27893695f, 0.23497190f, 0.13614252f, 
    -0.13651559f, -0.16016869f, 0.08876567f, 0.00428539f, -0.01506686f, -0.16683738f, -0.01535570f, -0.01310629f, 
    -0.06746677f, 0.01208848f, 0.11708535f, 0.01023679f, 0.02487872f, -0.05024058f, 0.17032340f, -0.11494505f, 
    -0.05285889f, -0.03964990f, -0.05195185f, 0.30519524f, 0.20843259f, -0.02753260f, 0.14441791f, -0.19217354f, 
    -0.03963643f, 0.01721597f, -0.08729191f, 0.04258945f, 0.09438832f, 0.06779506f, 0.05634098f, -0.00229951f, 
    -0.10109799f, -0.05205003f, 0.11503845f, 0.17237663f, -0.08622013f, -0.01906614f, 0.08210940f, 0.07269585f, 
    0.11528411f, 0.08287112f, 0.06165756f, -0.07415528f, -0.38137072f, 0.28047809f, -0.14082035f, -0.09973226f, 
    0.08684308f, -0.01269362f, 0.20125651f, 0.00905739f, -0.11558492f, -0.03663756f, -0.08924425f, 0.04411405f, 
    0.08967280f, -0.04905721f, -0.13741718f, 0.08092660f, 0.05390086f, -0.26955536f, 0.09135376f, 0.22559053f, 
    -0.13297467f, 0.07534582f, 0.08063451f, -0.00978106f, -0.20979282f, 0.17949651f, -0.04707489f, 0.03267012f, 
    -0.21294236f, -0.11953747f, 0.19314493f, -0.00961292f, -0.05537471f, -0.07812740f, 0.07046477f, -0.04263447f, 
    -0.31348068f, 0.15167373f, -0.17372984f, -0.05601066f, -0.06848802f, 0.14152034f, 0.12311757f, 0.01946508f, 
    0.05419737f, 0.05420629f, 0.08573967f, 0.11466338f, 0.20448120f, -0.05494237f, -0.20998994f, -0.05674741f, 
    -0.01618452f, 0.12384821f, 0.06400929f, 0.07578662f, 0.01312413f, -0.03524282f, -0.01343146f, 0.07246505f, 
    -0.20316982f, 0.03287143f, -0.17362861f, -0.00574822f, -0.13047163f, 0.14469139f, -0.10355182f, -0.04726843f, 
    -0.06691498f, 0.03930513f, 0.02007081f, -0.02562502f, -0.01826577f, -0.01213070f, -0.12983382f, -0.13956285f, 
    0.08779941f, 0.04381775f, 0.00369177f, 0.00607600f, -0.00844358f, -0.06425528f, -0.02335190f, 0.05136596f, 
    -0.22176798f, -0.13475366f, 0.07169857f, 0.17024411f, -0.04566022f, -0.02142756f, -0.07778591f, 0.18846056f, 
    -0.06131597f, 0.02435018f, 0.12530926f, -0.14913048f, -0.08023135f, -0.01635443f, -0.43131605f, -0.21921878f, 
    0.12350628f, 0.07701737f, 0.08944171f, 0.05591867f, 0.04115590f, 0.14120792f, 0.03382367f, -0.03593786f, 
    0.34660766f, 0.11999302f, 0.04126178f, -0.00420161f, 0.12516955f, 0.00061168f, 0.13421123f, -0.01024317f, 
    0.05153262f, -0.02838155f, -0.04236153f, 0.10343780f, -0.01885454f, -0.10343975f, -0.07630634f, 0.02653935f, 
    -0.01032155f, -0.00969663f, -0.09944726f, -0.06790797f, 0.07888456f, 0.10186712f, 0.10299870f, 0.15163727f, 
    -0.07449453f, -0.12905551f, 0.00471078f, 0.06661364f, -0.09094732f, -0.15783809f, 0.03459598f, 0.01021917f, 
    -0.10771369f, -0.05942398f, -0.10348397f, -0.10275594f, -0.16297911f, -0.44147182f, -0.15244888f, -0.06699512f, 
    0.25501660f, 0.38191268f, -0.08373798f, -0.03133838f, 0.00994947f, 0.10506878f, -0.03823651f, -0.01283581f, 
    0.05831347f, 0.05864932f, -0.07728033f, 0.08621382f, 0.17494078f, -0.10020560f, -0.17192441f, 0.17738128f, 
    0.04297122f, 0.06352565f, 0.08350186f, 0.03659783f, 0.10690673f, -0.40744233f, -0.41215125f, 0.32059327f, 
    0.25643218f, 0.31417084f, 0.02585590f, 0.13197948f, 0.12467475f, -0.16748144f, -0.02379193f, 0.01170217f, 
    -0.15002137f, -0.22688566f, -0.11309032f, -0.24167182f, -0.09822196f, -0.05408632f, 0.00745169f, -0.00393068f, 
    0.01593308f, 0.03017495f, -0.04152229f, -0.03320490f, -0.19116074f, 0.06648192f, 0.54525954f, 0.04470780f, 
    0.17272778f, -0.08957441f, -0.23256943f, 0.04891693f, 0.04024239f, -0.05917687f, 0.02716215f, 0.01292395f, 
    -0.01069130f, 0.09260616f, -0.03819580f, -0.07112227f, -0.20403266f, -0.16293386f, -0.02097718f, -0.15852360f, 
    0.11096132f, 0.07421362f, 0.05862060f, 0.09891618f, 0.44950545f, 0.11361235f, -0.03532357f, -0.01489239f, 
    0.18202391f, 0.05855060f, 0.04248969f, 0.12541938f, 0.00660418f, 0.03073223f, 0.01123381f, 0.09224471f, 
    0.07133097f, -0.08791506f, 0.39275414f, -0.08869152f, 0.00101565f, 0.02789813f, -0.08223671f, 0.07259771f, 
    -0.01411738f, 0.14301772f, 0.06997431f, 0.00406154f, 0.23410049f, 0.38506249f, 0.05974036f, -0.14368290f, 
    0.18471214f, 0.00986090f, 0.12977952f, -0.05875571f, 0.10024174f, -0.01578781f, -0.01509609f, 0.13140789f, 
    0.30534539f, 0.06465389f, 0.19964913f, -0.00082452f, 0.11527584f, -0.00244853f, 0.07693271f, -0.03192170f, 
    0.03336674f, -0.01768108f, -0.01097273f, -0.11254729f, -0.06865512f, -0.23043498f, 0.13839790f, 0.33760378f, 
    -0.13423544f, 0.10354468f, -0.00808628f, -0.06608436f, -0.00626763f, 0.13532025f, 0.18221180f, 0.31533989f, 
    0.16771822f, 0.17437352f, -0.20194593f, 0.07978975f, -0.10529438f, -0.10171048f, 0.03237842f, -0.15593287f, 
    0.37662685f, 0.09730523f, 0.00849872f, 0.31870666f, -0.01191017f, 0.03392309f, 0.15574630f, 0.21750580f, 
    0.02496936f, -0.11256174f, -0.02454593f, 0.00034800f, 0.16076757f, 0.17920014f, 0.23427108f, 0.21834463f, 
    -0.08031329f, -0.08549201f, 0.06509649f, 0.09082808f, 0.00501698f, -0.04499616f, 0.06352125f, 0.12000795f, 
    -0.01280721f, -0.08847792f, 0.13641272f, -0.08362795f, 0.01624812f, 0.15082616f, -0.05000075f, 0.16676717f, 
    0.08628470f, -0.08973084f, 0.12364745f, -0.23939294f, -0.17570062f, 0.03156079f, 0.04276542f, -0.09432149f, 
    0.15094969f, 0.14249142f, -0.02295192f, 0.06215605f, 0.03207974f, -0.02120603f, -0.00187333f, -0.07081331f, 
    -0.01735909f, 0.00307192f, -0.10770725f, -0.05498133f, 0.18431938f, 0.07203761f, 0.03939967f, 0.03050949f, 
    -0.11164311f, -0.03982034f, 0.09904720f, 0.03095050f, 0.17279387f, -0.07285449f, -0.00216491f, 0.08007240f, 
    0.05891955f, -0.09179046f, -0.10844463f, -0.36533305f, -0.00313747f, -0.06786376f, 0.05435460f, -0.10677525f, 
    0.08609660f, -0.14497682f, -0.07434259f, -0.04366019f, -0.18496503f, 0.19221979f, 0.30372828f, 0.04676288f, 
    -0.04162994f, -0.26621279f, -0.08265739f, -0.20103694f, -0.04778723f, 0.08187632f, 0.29489329f, 0.05454018f, 
    0.10078046f, 0.01773170f, 0.01098790f, 0.08385652f, 0.18461308f, 0.00727974f, -0.00862218f, 0.13388382f, 
    -0.17380376f, -0.06871461f, -0.01821839f, 0.05351686f, 0.35591966f, -0.21141191f, -0.03671020f, -0.21133669f, 
    -0.22845112f, 0.12103086f, 0.07427854f, 0.03488312f, 0.12929021f, -0.01354988f, -0.02463042f, 0.06477402f, 
    0.00164034f, 0.14290553f, 0.06929186f, -0.15703253f, 0.32464862f, -0.02340178f, -0.04505136f, -0.01690254f, 
    -0.14771616f, -0.10545053f, -0.09500793f, -0.24315645f, -0.01358973f, -0.12373837f, 0.04188696f, 0.09755007f, 
    0.14366250f, -0.00236201f, 0.01251616f, -0.00003831f, 0.21491994f, 0.04895018f, -0.04608645f, 0.07210007f, 
    0.12908833f, -0.06688318f, -0.05863039f, 0.08174673f, -0.03111803f, -0.09652629f, 0.06125446f, 0.03095169f, 
    -0.08933410f, -0.13192472f, -0.08858417f, -0.07553466f, -0.26571730f, -0.31379798f, 0.07990188f, 0.06638918f, 
    -0.12627582f, 0.05600949f, -0.00308427f, -0.04431724f, -0.11600669f, -0.11248948f, -0.04408590f, -0.09507630f, 
    0.34544113f, -0.12608157f, 0.19438230f, 0.03683885f, -0.19509782f, 0.20246480f, -0.16718236f, -0.01397917f, 
    -0.19929697f, 0.10015637f, 0.03560517f, -0.01149827f, 0.23468477f, 0.16247430f, 0.08055427f, 0.24567266f, 
    -0.05102979f, -0.05377399f, 0.02323436f, -0.22230653f, -0.04047768f, 0.20789443f, 0.23903029f, 0.31810591f, 
    0.00173258f, 0.07004505f, 0.10217808f, 0.03031500f, -0.04804992f, -0.10485733f, -0.17446822f, -0.29350665f, 
    0.15409975f, 0.13232344f, -0.09442142f, 0.07519943f, 0.00456677f, -0.12612593f, -0.23963109f, 0.08122940f, 
    -0.03489580f, -0.02273539f, 0.03676741f, 0.07912477f, 0.06109914f, 0.03278577f, 0.12026776f, 0.01541459f, 
    0.12900625f, -0.05603783f, 0.12183342f, 0.13097490f, -0.15980430f, 0.02859516f, -0.06508055f, 0.00093439f, 
    -0.02945275f, 0.08219320f, -0.06343729f, 0.00258845f, 0.04888028f, 0.03191539f, -0.13157089f, 0.00126568f, 
    0.00275827f, -0.17055859f, 0.23301049f, -0.17546716f, -0.14923333f, -0.06918442f, -0.01396588f, -0.06143956f, 
    0.01738910f, 0.05351073f, 0.04535744f, 0.04473751f, 0.04623857f, -0.00297041f, 0.05324305f, 0.07634053f, 
    0.00958677f, 0.10051685f, -0.01711952f, -0.02647942f, 0.10024887f, 0.24536452f, 0.20532535f, 0.07627398f, 
    -0.06814755f, -0.11384238f, 0.03450313f, -0.02437126f, -0.07964657f, -0.12474158f, -0.12790368f, -0.04560706f, 
    -0.00736930f, -0.01817422f, 0.32436419f, -0.18351924f, 0.14687608f, 0.02046185f, 0.07987723f, -0.16676921f, 
    -0.05667917f, 0.04376753f, -0.00778567f, 0.13011442f, 0.08919644f, -0.23442391f, 0.16090064f, 0.12752937f, 
    0.04681007f, -0.08156541f, 0.04387813f, -0.02085873f, -0.08734541f, 0.02616196f, 0.11801966f, 0.01748303f, 
    -0.18941374f, -0.05990311f, -0.19637156f, -0.01295421f, 0.02477557f, -0.05259571f, 0.15112628f, 0.11745223f, 
    -0.02658028f, 0.00172701f, -0.16837482f, -0.04288265f, 0.51291358f, -0.08508760f, 0.47807285f, -0.24847171f, 
    0.02192918f, -0.03371523f, -0.01154417f, 0.08402000f, 0.01468829f, 0.05886795f, -0.00263962f, 0.06926303f, 
    0.02915886f, 0.32902512f, -0.25475353f, 0.11366983f, 0.03537245f, 0.07408889f, 0.07869641f, -0.09228626f, 
    -0.32020804f, -0.02620562f, -0.17411800f, -0.10152409f, -0.15838344f, 0.17466077f, 0.10237421f, 0.04710367f, 
    -0.06613684f, -0.16415395f, 0.06856443f, 0.00622791f, 0.06375308f, -0.02572609f, -0.03313441f, -0.07910129f, 
    -0.08135421f, 0.30479920f, 0.01342681f, -0.08726273f, 0.04573603f, 0.02263824f, 0.03376988f, -0.09028403f, 
    -0.09484671f, -0.07545037f, -0.09656668f, -0.01841285f, 0.24761917f, -0.05308218f, -0.11971948f, 0.20028301f, 
    0.03391378f, 0.08494217f, 0.07226424f, -0.10011265f, -0.11755931f, -0.02787339f, -0.05109049f, -0.12219885f, 
    0.53748435f, -0.08116280f, 0.13448313f, -0.09054674f, -0.08786277f, 0.01709977f, 0.10089339f, -0.13233066f, 
    0.04822942f, -0.10097814f, -0.05466700f, -0.01117052f, -0.17127465f, 0.11512662f, 0.33636498f, 0.10781775f, 
    0.03150525f, 0.06641340f, 0.07505297f, -0.06770065f, 0.06588797f, 0.06163444f, 0.13372093f, -0.02199507f, 
    0.41966128f, 0.00941280f, -0.01888790f, -0.18882634f, 0.18558921f, 0.02883120f, 0.23255818f, -0.01381256f, 
    -0.04625365f, 0.06704052f, 0.05147029f, 0.18175675f, -0.28857720f, -0.07468870f, 0.26727477f, 0.22110505f, 
    -0.10098176f, -0.14373229f, -0.20658213f, -0.01377722f, 0.00777407f, -0.00751875f, 0.00978897f, 0.17074816f, 
    -0.16682176f, 0.03814748f, 0.07902713f, -0.11255560f, -0.11179865f, 0.10501391f, 0.08485675f, -0.00751354f, 
    -0.07838058f, -0.00142155f, 0.04368721f, 0.01825761f, -0.26005813f, 0.07508129f, 0.30727783f, -0.08123414f, 
    -0.00280063f, -0.02479717f, -0.01182207f, 0.06518205f, -0.07748497f, -0.07196182f, 0.16965380f, -0.01724581f, 
    0.17147288f, 0.12132360f, 0.07890163f, -0.00274214f, 0.04136822f, -0.06987625f, -0.04361197f, -0.13281089f, 
    0.15864415f, 0.01269105f, -0.00666345f, 0.10418966f, -0.18686308f, 0.21755096f, 0.07006408f, -0.09491522f, 
    -0.01067297f, -0.17938468f, 0.01163421f, -0.09489575f, -0.11876468f, -0.08671042f, 0.03022398f, -0.10303260f, 
    0.01601867f, -0.02396637f, 0.15119244f, -0.01572378f, -0.03849277f, -0.00806960f, 0.08871171f, 0.04611470f, 
    -0.05621247f, 0.10699012f, 0.12912074f, 0.07278587f, 0.74693525f, 0.30449495f, 0.28036192f, -0.42261755f, 
    0.07304922f, -0.00591505f, -0.05217002f, 0.14266381f, 0.14909405f, 0.03805337f, -0.00893993f, -0.04923518f, 
    -0.11276400f, -0.05455731f, 0.20900397f, 0.23046067f, -0.08025568f, -0.16888170f, -0.15702040f, -0.08176133f, 
    0.00643282f, 0.01489701f, 0.13116601f, 0.02725064f, 0.26662493f, 0.11944343f, -0.40578163f, 0.04772064f, 
    0.03009659f, 0.01243464f, 0.01827301f, 0.04551299f, -0.21314195f, 0.10163183f, -0.11586335f, -0.01344658f, 
    0.04644496f, -0.06986757f, -0.09266316f, 0.15596026f, 0.24644753f, 0.06324159f, -0.00426319f, 0.08186989f, 
    -0.04704482f, -0.13150667f, -0.00850544f, -0.05324188f, -0.30593732f, -0.00699960f, -0.04569010f, 0.01714172f, 
    0.10993098f, 0.05452989f, 0.13156398f, 0.01273783f, -0.07312179f, -0.14024264f, -0.09182181f, -0.04536491f, 
    -0.32244051f, 0.04724592f, -0.13372242f, -0.00057122f, -0.03067322f, 0.02982823f, -0.02067964f, -0.05175538f, 
    -0.09187905f, -0.05695863f, -0.02774929f, -0.14237148f, -0.12549320f, -0.05377226f, 0.17722335f, 0.19408029f, 
    0.00821143f, 0.13504170f, 0.03775419f, 0.05765234f, -0.03017837f, -0.00579417f, 0.11453536f, -0.02871105f, 
    -0.02450253f, -0.14994273f, -0.20580159f, 0.23932549f, -0.21195719f, 0.02851455f, 0.12339334f, -0.09991096f, 
    -0.04307588f, 0.00680738f, 0.11338948f, 0.14472994f, 0.07726855f, 0.23511992f, 0.31005505f, -0.07904065f, 
    0.24046606f, -0.01536280f, 0.03145131f, 0.08847655f, 0.14946456f, 0.08167679f, -0.07138410f, -0.14056405f, 
    -0.09505564f, -0.42587292f, 0.08534237f, -0.38033387f, 0.07170855f, 0.02184766f, 0.01582078f, -0.09365714f, 
    -0.08460259f, -0.04387103f, -0.03824231f, 0.04123020f, 0.06751434f, 0.03289093f, -0.13844319f, 0.04336518f, 
    0.00147054f, -0.04926973f, 0.02924684f, 0.16235274f, 0.13790826f, -0.02729938f, 0.03466003f, 0.12337563f, 
    -0.05687095f, 0.06208807f, -0.04962674f, -0.12942903f, -0.16166730f, 0.02068984f, -0.07518200f, 0.03107584f, 
    -0.03259583f, 0.08605896f, 0.05641275f, 0.11852299f, 0.38499475f, -0.00250469f, 0.24180369f, -0.20060883f, 
    -0.02063036f, -0.04526509f, 0.04252619f, 0.31014761f, -0.02150553f, -0.11239045f, 0.10774345f, -0.02184638f, 
    -0.02082619f, 0.05239753f, 0.00700224f, -0.01902114f, -0.15717508f, 0.12332551f, -0.10394070f, -0.00566242f, 
    0.04189827f, -0.11822960f, 0.05282015f, 0.00133724f, -0.05606966f, 0.11241326f, 0.24468756f, 0.15173790f, 
    -0.14260851f, -0.12591934f, 0.10086187f, -0.11987549f, 0.01486954f, 0.02532913f, 0.07876622f, -0.11845495f, 
    0.01433509f, -0.17307596f, 0.29609227f, 0.00451421f, -0.03810497f, -0.05890003f, 0.01618041f, -0.02744697f, 
    -0.14234243f, 0.05961509f, 0.01335257f, 0.04396896f, 0.47918493f, 0.11876478f, -0.00675395f, -0.00901728f, 
    0.02632745f, 0.09199664f, 0.08136853f, -0.01078878f, 0.19700317f, -0.08299855f, -0.01853500f, -0.07513837f, 
    0.03081506f, -0.18029496f, 0.13560569f, -0.06727578f, -0.20684804f, -0.10733165f, -0.06314160f, -0.10104597f, 
    0.15515284f, 0.23680757f, 0.04262563f, -0.21452603f, -0.28826195f, 0.10483259f, 0.13157809f, -0.06792066f, 
    -0.06164283f, -0.00968596f, -0.05195769f, 0.11287088f, -0.11756942f, 0.05710215f, -0.09798875f, -0.06103960f, 
    0.06233652f, 0.20647652f, -0.19298227f, 0.14878617f, -0.00857431f, 0.04114613f, 0.24378698f, -0.03060404f, 
    0.04693978f, 0.10609072f, -0.14590043f, 0.00181496f, -0.13429493f, 0.11724568f, -0.09623033f, -0.01558936f, 
    0.00153495f, -0.05143003f, 0.14430316f, 0.04392780f, 0.07320052f, 0.10975355f, 0.08119416f, 0.02983412f, 
    -0.42708126f, 0.06223296f, -0.00433061f, -0.03175202f, -0.02818996f, 0.18686658f, 0.06934468f, 0.03916803f, 
    -0.02441804f, 0.02649353f, -0.10588433f, -0.08340123f, 0.22673003f, 0.11365759f, 0.08453727f, 0.05278685f, 
    0.15391380f, -0.03505541f, 0.16036382f, 0.10950270f, -0.06163543f, -0.12810688f, -0.06618325f, -0.17061135f, 
    0.48931286f, 0.22365575f, 0.18650775f, 0.07188084f, -0.03214667f, -0.11154827f, -0.00025639f, -0.05669060f, 
    -0.02773825f, 0.07933626f, 0.04165098f, 0.04139616f, 0.04018398f, -0.08327143f, -0.16804314f, -0.09441486f, 
    0.11609864f, 0.04827568f, 0.15460527f, 0.13815723f, -0.07912928f, 0.11388144f, -0.02590876f, -0.04259116f, 
    0.44747445f, -0.14241011f, 0.38746747f, 0.13815184f, -0.20087028f, 0.06219621f, 0.30186191f, -0.14902286f, 
    0.02667910f, -0.00213856f, 0.11055126f, 0.08128583f, -0.01140104f, 0.00222077f, 0.00523653f, -0.41161910f, 
    -0.08204769f, 0.05365688f, -0.01853384f, -0.06609160f, -0.03665998f, 0.00938524f, -0.06171172f, 0.04150651f, 
    -0.34005904f, -0.31911004f, 0.17231995f, -0.05667925f, -0.07704617f, -0.05419548f, -0.04733370f, 0.21609238f, 
    -0.19827507f, 0.06062943f, 0.16877063f, 0.13007972f, 0.00928191f, -0.20654708f, 0.21161550f, -0.03458482f, 
    0.07620613f, 0.03250976f, 0.08887248f, -0.03949583f, -0.04609229f, -0.02953385f, 0.07551519f, 0.05069809f, 
    0.21034226f, 0.14436549f, -0.00531260f, 0.02495153f, 0.04462424f, 0.02213747f, -0.06636386f, -0.06080980f, 
    0.04507422f, -0.03224543f, -0.01719476f, -0.00274727f, -0.10939761f, 0.02522713f, 0.01652231f, -0.13842069f, 
    0.07950485f, -0.26385340f, -0.02465511f, -0.01157506f, -0.16854714f, 0.04156521f, -0.12012768f, -0.11117254f, 
    0.38241327f, 0.02557298f, 0.23095834f, -0.00303762f, -0.06576436f, 0.22089167f, 0.11610397f, 0.10434652f, 
    -0.02130502f, 0.10461821f, 0.10135150f, -0.02978259f, 0.22018705f, 0.00035018f, -0.35731333f, -0.13533434f, 
    -0.01854333f, 0.14552718f, 0.09485535f, 0.17662565f, 0.14293317f, 0.17873913f, 0.06123295f, 0.12790287f, 
    0.06887320f, 0.12702052f, -0.01524211f, -0.14839590f, 0.02977360f, -0.03281455f, -0.03935717f, -0.00566535f, 
    -0.09548584f, 0.15270407f, 0.07436874f, 0.16476993f, 0.58410859f, 0.14250264f, 0.04280704f, -0.01468011f, 
    -0.39329076f, -0.10820230f, 0.06862077f, -0.05300826f, 0.06757988f, 0.10995595f, -0.02451591f, -0.01034873f, 
    -0.01140616f, 0.00540596f, 0.09738085f, 0.26053938f, 0.20212425f, 0.14309263f, 0.01551212f, 0.01324814f, 
    -0.09983505f, -0.12498060f, -0.11466571f, 0.05452109f, -0.54328150f, 0.04694058f, -0.17164850f, -0.10067903f, 
    0.08643599f, 0.06143666f, 0.01106721f, -0.12379956f, -0.09236821f, -0.02032178f, -0.09737226f, -0.08476131f, 
    -0.00863215f, 0.31346166f, -0.13222145f, -0.03135182f, -0.03242770f, -0.13736022f, -0.11566745f, 0.01085972f, 
    -0.09297803f, -0.20235063f, -0.11743920f, -0.16418041f, -0.13500068f, -0.19114065f, -0.25180671f, -0.00171069f, 
    0.06941248f, 0.00453412f, -0.00414928f, 0.08314504f, -0.21941425f, 0.09440064f, -0.02836210f, -0.04677708f, 
    -0.04390948f, 0.04127054f, 0.08322363f, -0.01964515f, -0.20045695f, 0.06785383f, -0.29136574f, -0.05365447f, 
    -0.18989055f, 0.14328851f, 0.08862771f, -0.08675383f, 0.38295180f, -0.05156092f, -0.18393458f, 0.10945630f, 
    0.15215540f, 0.05757926f, 0.18320110f, 0.04661664f, 0.00830600f, 0.06428975f, 0.06508874f, 0.11457627f, 
    -0.24950151f, -0.10811988f, 0.37393278f, 0.07215608f, -0.23140286f, 0.01610664f, -0.10996046f, -0.01834223f, 
    0.03152368f, 0.01712957f, 0.00129755f, -0.01866416f, 0.31815502f, 0.00261520f, -0.27883109f, -0.09052086f, 
    0.07608815f, 0.09335534f, -0.07621177f, -0.10254534f, -0.06499662f, 0.03984161f, 0.14239669f, 0.11894910f, 
    -0.04110249f, -0.14382854f, -0.07200950f, 0.15661892f, -0.08118179f, -0.01223197f, 0.04120775f, 0.32474583f, 
    -0.08489584f, 0.14305069f, -0.01873331f, 0.05134160f, 0.15203632f, -0.09260136f, -0.14792916f, 0.07001235f, 
    -0.02437170f, 0.06591442f, -0.04617248f, 0.11817892f, -0.05322251f, 0.08990201f, 0.02225262f, -0.00879268f, 
    0.08304734f, 0.07086808f, 0.12740682f, 0.13694046f, -0.02198876f, -0.05224309f, 0.01658322f, -0.11908042f, 
    -0.01594030f, -0.06371212f, -0.05896127f, -0.06158934f, 0.04188736f, -0.13232283f, -0.04917702f, -0.01866085f, 
    -0.07706853f, 0.07223517f, -0.10030356f, -0.06122575f, 0.08295670f, 0.10552336f, 0.00489267f, 0.05681777f, 
    0.36303896f, 0.10129016f, 0.38466996f, -0.11484024f, 0.23669530f, 0.12052789f, -0.19758742f, -0.02994762f, 
    -0.12300384f, 0.03051635f, -0.06465947f, -0.00914404f, -0.21038593f, -0.40743235f, 0.01307717f, 0.39078498f, 
    0.03774171f, 0.07325968f, 0.19729437f, 0.08327642f, 0.13989960f, 0.03096878f, -0.00150194f, 0.12786759f, 
    0.08504800f, 0.10756404f, -0.38813862f, -0.21974757f, -0.09178744f, -0.07492366f, 0.06824953f, -0.07612282f, 
    -0.03715137f, -0.02620414f, 0.02757627f, 0.03723858f, 0.49769390f, 0.00851746f, 0.84355527f, -0.02379237f, 
    -0.02029644f, -0.14581305f, -0.04405764f, 0.02653029f, -0.11706001f, -0.01073151f, -0.06914737f, 0.04214373f, 
    -0.11290850f, 0.30542710f, -0.17892613f, 0.05287275f, 0.08112322f, 0.00751628f, 0.09573959f, -0.02919675f, 
    -0.12187286f, 0.06832846f, -0.07223378f, 0.07997186f, -0.14318046f, -0.03334475f, -0.32639682f, -0.01681542f, 
    0.05091322f, -0.15451412f, 0.07621641f, 0.03071145f, 0.05167487f, 0.14074726f, 0.02441399f, -0.15346347f, 
    0.14132960f, 0.24749878f, 0.14778031f, -0.06665456f, 0.11529993f, -0.07217529f, -0.12934463f, -0.12314731f, 
    -0.20254397f, -0.08502476f, 0.07159869f, -0.00052180f, 0.06702736f, 0.08324598f, -0.09078517f, 0.01862252f, 
    0.05221890f, -0.04431452f, 0.14276443f, 0.10458215f, -0.14242658f, -0.14939818f, -0.14659028f, -0.11289506f, 
    0.18042721f, 0.26659372f, -0.04650862f, -0.12153967f, 0.18427385f, 0.03656217f, -0.06440806f, 0.09128870f, 
    0.08044871f, -0.07163291f, -0.01481307f, -0.04839544f, -0.35509408f, -0.10915890f, 0.01146153f, 0.04040155f, 
    -0.14332519f, -0.12348151f, 0.00754758f, 0.11340320f, 0.02787241f, -0.08850779f, -0.10675556f, -0.00842353f, 
    0.10353182f, 0.39127019f, -0.40129298f, -0.04462851f, 0.17349547f, 0.08241718f, 0.10010079f, 0.18431403f, 
    -0.01254557f, -0.01744738f, -0.03143079f, -0.03329092f, 0.10684706f, -0.12968872f, 0.20841224f, 0.07200670f, 
    -0.00091751f, 0.01837821f, 0.02778363f, 0.00395402f, 0.04857104f, 0.09592327f, -0.00723142f, -0.00440024f, 
    0.06573571f, 0.35638049f, 0.26089483f, 0.17413050f, 0.09660021f, 0.01747269f, 0.13151488f, 0.00226465f, 
    0.14799209f, -0.09276833f, 0.19171213f, -0.16317299f, -0.20284335f, 0.06220280f, -0.10529181f, -0.03478372f, 
    -0.12717739f, -0.02107284f, 0.02887310f, -0.00902347f, -0.03011367f, 0.09262847f, 0.10053850f, -0.04642214f, 
    -0.03392540f, -0.07604587f, -0.04836385f, 0.08826738f, 0.04517055f, -0.01001135f, -0.09343022f, 0.00783383f, 
    0.10074986f, -0.12528466f, -0.09199443f, 0.09807257f, 0.04447326f, -0.00609584f, -0.28613457f, -0.22454289f, 
    -0.04052709f, -0.09990365f, 0.02120744f, 0.03114697f, 0.15388507f, 0.05441710f, -0.00271958f, 0.11304609f, 
    -0.20021413f, -0.00832464f, -0.41532809f, 0.19306386f, 0.03549805f, 0.00263481f, -0.05862020f, -0.03249614f, 
    0.28063217f, -0.06127076f, 0.20166194f, -0.02067029f, 0.03632226f, 0.18637881f, 0.15437147f, -0.23089410f, 
    0.01786253f, -0.17779084f, 0.04560519f, -0.02834171f, 0.03582051f, 0.02743516f, -0.04287632f, 0.00900070f, 
    0.38788554f, 0.06359905f, 0.16017447f, 0.11993982f, -0.01720106f, -0.15082504f, -0.12302068f, 0.04854999f, 
    0.02996548f, -0.07952785f, 0.04906502f, 0.02559972f, -0.09764459f, 0.16923848f, -0.67736596f, 0.29813111f, 
    0.13751034f, 0.02170037f, 0.02743091f, -0.06169928f, 0.12287670f, -0.09210927f, 0.09290405f, 0.00888870f, 
    0.17495707f, -0.09536824f, 0.13314369f, -0.11190227f, 0.11807017f, 0.09264810f, -0.04565853f, -0.06902158f, 
    0.03349882f, -0.11725359f, -0.04339889f, 0.03490275f, 0.08565603f, 0.00758512f, 0.18375088f, 0.05323544f, 
    0.10015035f, 0.12318291f, 0.03089472f, 0.01433271f, 0.24395195f, 0.00132566f, 0.00466052f, 0.01847364f, 
    0.11687080f, -0.20720826f, 0.09990952f, 0.21100600f, -0.01987191f, 0.04075992f, -0.00175424f, 0.01563698f, 
    0.03693188f, 0.00502017f, -0.07508106f, -0.00764927f, -0.26104867f, -0.12543970f, 0.35663903f, -0.13170458f, 
    0.03680635f, -0.02233983f, -0.08680715f, 0.17260778f, 0.02602777f, -0.02387100f, 0.12941280f, 0.10470556f, 
    -0.01106443f, -0.10740219f, -0.13642459f, -0.24474913f, -0.08443470f, -0.09134210f, 0.19945578f, 0.01150530f, 
    0.18685500f, 0.01649605f, -0.01010964f, 0.05022266f, -0.16501610f, 0.23185083f, 0.23196170f, 0.06076116f, 
    0.04083446f, 0.00360271f, -0.00334261f, 0.07560643f, 0.09246396f, -0.10453641f, -0.02432735f, -0.07435336f, 
    -0.08414094f, 0.32938644f, -0.41439238f, 0.03515060f, 0.23257722f, -0.02972860f, 0.04726561f, 0.03267785f, 
    -0.02105966f, 0.04777444f, 0.00646903f, 0.01642076f, -0.07441013f, -0.16362739f, 0.04732371f, 0.13898605f, 
    -0.02228978f, -0.02249299f, -0.07106518f, -0.03462102f, -0.05765624f, -0.05288982f, -0.00863567f, 0.08579686f, 
    0.13270670f, 0.40092951f, 0.19268869f, 0.01617515f, -0.02908715f, 0.01565250f, 0.13017517f, -0.01168211f, 
    0.00039497f, -0.11957497f, -0.09509134f, 0.00885209f, -0.16372636f, 0.11957952f, -0.02619567f, -0.02808943f, 
    -0.12057957f, -0.02840821f, 0.12293144f, 0.11339501f, 0.05142730f, -0.13786420f, 0.12294979f, -0.03913188f, 
    -0.24367176f, -0.27866587f, -0.00621060f, 0.04280848f, -0.04928758f, 0.05635984f, -0.01030613f, -0.01824122f, 
    0.18549329f, 0.01234139f, 0.02630562f, 0.08555465f, -0.15480447f, 0.02475995f, -0.27053323f, -0.12251245f, 
    -0.00382037f, 0.09295961f, 0.01617216f, -0.05179729f, -0.00252758f, -0.07655624f, 0.02982240f, 0.12036391f, 
    -0.34648818f, -0.06655193f, -0.24460304f, 0.15535586f, 0.00380081f, 0.04653680f, -0.00359808f, -0.05868165f, 
    0.25643390f, 0.04216978f, 0.25821835f, -0.05098769f, 0.32178181f, 0.00726515f, 0.22361739f, -0.26875314f, 
    0.17494969f, -0.08048008f, -0.10736416f, 0.06555512f, -0.02777651f, 0.07796808f, 0.00904949f, -0.06560779f, 
    -0.11520860f, -0.32744804f, 0.07755136f, 0.11846207f, -0.12133748f, -0.12030261f, -0.14763644f, -0.01999661f, 
    0.11804461f, -0.00188482f, 0.08175065f, 0.09343051f, -0.33590552f, -0.11768492f, -0.60067058f, 0.24121398f, 
    0.02352095f, -0.07688830f, -0.12605777f, -0.05590304f, 0.03444917f, -0.14163049f, 0.00022670f, 0.04124344f, 
    0.16632544f, -0.20931810f, 0.05200143f, -0.03041526f, 0.00452749f, 0.20340168f, 0.05847421f, -0.03587739f, 
    0.05878166f, -0.02737008f, -0.01285792f, 0.09913322f, 0.14895774f, 0.20697252f, 0.22220123f, 0.11519169f, 
    0.05304608f, 0.07885698f, 0.04450956f, 0.00714765f, -0.01520644f, -0.09552296f, -0.02082378f, 0.04949342f, 
    -0.21377894f, -0.26828900f, 0.05185663f, 0.07069567f, -0.06199145f, 0.14971852f, 0.00701968f, 0.12432998f, 
    0.16725035f, 0.06872986f, -0.04561030f, 0.04324635f, 0.07712478f, 0.13674179f, 0.27892643f, -0.04742538f, 
    0.06357311f, 0.07977698f, 0.09361202f, 0.18484710f, 0.04494645f, 0.04073804f, 0.01423935f, -0.04609174f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02823413f, -0.04423499f, -0.05520516f, 0.09112625f, 0.14618821f, -0.00416942f, -0.11588418f, -0.10069686f, 
    0.13034192f, 0.03203770f, -0.12368155f, 0.16519798f, 0.14869109f, 0.14909557f, 0.06215976f, -0.03440045f, 
    0.26895708f, 0.01983859f, -0.11821157f, 0.02457699f, 0.01744703f, -0.07241686f, -0.05993368f, -0.00827724f, 
    0.00931274f, 0.20667176f, 0.04604203f, 0.04537471f, -0.07762947f, 0.02980880f, 0.00680514f, -0.00562284f, 
    0.15207349f, 0.01887889f, -0.09733798f, 0.18400529f, -0.01197192f, 0.12863657f, -0.07805712f, 0.16340658f, 
    -0.07479257f, 0.03371501f, 0.10735915f, 0.16107008f, -0.04655551f, 0.24387197f, 0.13229635f, -0.00733149f, 
    0.01100995f, 0.05275115f, 0.06499980f, 0.03813896f, 0.13281213f, -0.09192362f, 0.15593670f, -0.02847119f, 
    -0.04360022f, -0.06348824f, 0.17638719f, -0.00876035f, 0.11730874f, -0.01759535f, 0.07618878f, 0.17640364f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.00072194f, -0.06591518f, 0.09415402f, -0.33190179f, 0.17921971f, -0.02159237f, 0.22567827f, -0.02832749f, 
    -0.08932023f, 0.01881900f, 0.35024899f, -0.02164961f, -0.56703895f, -0.25615391f, 0.14198512f, -0.00560020f, 
    -0.36717415f, -0.42030677f, 0.10280614f, 0.05508812f, -0.42416269f, 0.17798817f, 0.44219702f, 0.10987932f, 
    0.03085597f, -0.11601993f, 0.25488508f, -0.32025793f, 0.04278783f, 0.01898493f, 0.04490979f, -0.19560084f, 
    -0.06952322f, 0.15038592f, 0.10299873f, -0.40455848f, 0.00837291f, -0.69935870f, 0.10817614f, -0.69070596f, 
    0.08908296f, -0.30845717f, 0.05712913f, -0.50032139f, -0.14573523f, -0.15822297f, -0.38814518f, -0.00651416f, 
    -0.21976565f, 0.23465319f, 0.15542167f, 0.10254744f, -0.29450738f, 0.14103861f, 0.08004085f, 0.16327702f, 
    -0.09545831f, 0.13411769f, -0.17313348f, 0.16275214f, -0.21890169f, 0.02964222f, -0.34950396f, -0.01930230f, 
    -0.39888835f, -0.11772686f, 0.49684894f, -0.08336338f, 0.20054433f, -0.03351850f, -0.55681229f, -0.87804401f, 
    -0.14323181f, -0.08218844f, -0.81251150f, -0.01255540f, -0.00301945f, -0.05433813f, 0.29147372f, -0.09364345f, 
    0.08659979f, -0.24952038f, 0.03326325f, 0.18788612f, -0.16916521f, 0.13277023f, -0.54287100f, -0.03308878f, 
    -0.05242340f, 0.20166636f, -0.25788492f, 0.17405528f, -0.01206795f, -0.09165267f, 0.15015271f, -0.54743296f, 
    0.17124045f, 0.02727588f, -0.11174903f, 0.17587130f, -0.01039880f, -0.17985120f, 0.03358673f, -0.16596514f, 
    -0.07082079f, -0.62924582f, 0.01345446f, 0.15363970f, -0.19588228f, 0.30111027f, -0.19823232f, 0.03330700f, 
    -0.22173400f, 0.09360174f, -0.31753081f, 0.26995352f, 0.22354521f, 0.21392928f, 0.08091730f, 0.10066627f, 
    -0.04851133f, 0.09858840f, 0.26703498f, 0.29929894f, 0.44531360f, 0.27713710f, -0.11925016f, 0.16040321f, 
    0.31189626f, 0.00584420f, -0.48089758f, -0.16800028f, 0.46746340f, 0.01657865f, 0.21263041f, -0.06231788f, 
    0.09507122f, -0.02403552f, -0.78949630f, 0.13318367f, 0.23806624f, 0.19690102f, -0.38106090f, -0.11369389f, 
    0.07673216f, 0.26590306f, -0.21050183f, -0.09318317f, 0.24972901f, -0.15870641f, -0.60284972f, -0.83158427f, 
    0.03121520f, 0.14946291f, -0.15766670f, -0.04014431f, -0.07439107f, 0.07492022f, -0.32427561f, -0.28047252f, 
    -0.05647963f, 0.07274984f, -0.23003590f, 0.11544841f, 0.08287804f, 0.12511970f, -0.10740080f, 0.03679763f, 
    0.07619557f, 0.30426559f, -0.38895965f, -0.02047415f, -0.22035064f, 0.16916212f, -0.14549382f, -0.02224856f, 
    -0.05101726f, 0.03755315f, 0.24586070f, 0.31733564f, -0.42411816f, 0.15654829f, 0.19022666f, -0.24517508f, 
    0.15998557f, 0.01267051f, 0.05246061f, 0.22594137f, -0.33717790f, -0.22648805f, -0.05189802f, -0.08116747f, 
    0.28164315f, -0.10595433f, 0.24452718f, -0.22595282f, 0.08254546f, 0.11414846f, 0.28501052f, 0.24864410f, 
    -0.13218901f, -0.08623695f, -0.11964376f, -0.10676565f, -0.21039361f, 0.12913600f, -0.33351171f, 0.09943993f, 
    -0.21617994f, 0.38731030f, 0.16945061f, 0.00482567f, 0.33272415f, 0.23730049f, -0.24630678f, 0.23866355f, 
    0.00573653f, -0.38590381f, -0.19007677f, -0.20433481f, 0.05239162f, 0.05502135f, -0.04755122f, -0.01596622f, 
    -0.10737818f, 0.15980707f, -0.11080069f, -0.14394028f, -0.12708594f, 0.22542651f, 0.11679941f, -0.29648969f, 
    0.02394194f, 0.33874503f, -0.15666106f, 0.04685220f, 0.38012812f, -0.16450427f, -0.11019489f, 0.04015272f, 
    -0.34781665f, -0.22866084f, -0.11346647f, 0.15917148f, -0.45147878f, 0.10547446f, -0.27418056f, 0.15282439f, 
    0.14916863f, 0.04960239f, -0.30938599f, -0.16162387f, 0.10619239f, 0.23092400f, -0.47075242f, -0.24369507f, 
    0.24700166f, 0.03727251f, 0.07658128f, 0.18609183f, -0.10072818f, -0.04684642f, -0.02979180f, 0.12373576f, 
    -0.27334690f, -0.03931594f, 0.32523578f, -0.17512481f, 0.11448074f, -1.06794620f, -0.48193374f, -0.12402575f, 
    0.02628284f, -0.21790285f, 0.18157287f, -0.29999223f, -0.23757552f, -0.11689153f, 0.08002060f, -0.05923140f, 
    -0.10075049f, -0.21078841f, -0.25706512f, 0.19750984f, -0.08618449f, 0.08869123f, 0.21560308f, 0.29848906f, 
    -0.40225938f, 0.21108653f, -0.10384441f, -0.33633652f, 0.01661511f, -0.29400602f, 0.09060544f, 0.03861257f, 
    -0.01419612f, -0.13043037f, 0.23404741f, 0.03258079f, -0.12344399f, -0.26535812f, 0.22912501f, 0.05747078f, 
    0.25642514f, -0.07337298f, 0.27795291f, -0.17576781f, 0.06491986f, -0.09172522f, -0.12192610f, 0.01541380f, 
    0.26027021f, 0.13717189f, 0.03695949f, -0.09635182f, -0.13844050f, -0.19967890f, 0.29909995f, 0.22354832f, 
    -0.15407521f, -0.06451941f, -0.09909554f, 0.12127978f, -0.06731164f, 0.10671429f, -0.26778087f, -0.00876612f, 
    -0.00773432f, -0.02313637f, -0.16919893f, 0.23529011f, 0.03976787f, -0.22327659f, 0.20146501f, -0.04649920f, 
    -0.17048337f, -0.37839270f, -0.45905933f, 0.19085974f, -0.72672725f, 0.02704748f, 0.09975352f, 0.08102097f, 
    -0.05451054f, 0.05184815f, 0.43435860f, -0.24601999f, 0.06847142f, 0.08540127f, 0.03466840f, -0.27379212f, 
    0.31984657f, 0.28838202f, 0.12081314f, -0.02433885f, 0.11681357f, 0.07677183f, -0.11174805f, 0.02202353f, 
    -0.07502092f, 0.06319814f, -0.01536563f, -0.13890588f, -0.26287204f, -0.19921355f, 0.36438736f, -0.13002729f, 
    0.15830655f, 0.03366009f, 0.07569276f, -0.02132507f, 0.09690697f, -0.22540194f, -0.19559193f, 0.23685881f, 
    -0.22777084f, -0.30969256f, 0.05816040f, 0.00091815f, -0.56509233f, -0.37879086f, 0.21132831f, 0.27562323f, 
    -0.60723317f, -0.11424489f, -0.32075968f, -0.18672773f, 0.49302307f, 0.05434727f, -0.21984108f, -0.09185845f, 
    0.35209832f, 0.05790702f, -0.50372428f, -0.44008425f, 0.03736314f, -0.04575264f, 0.18499716f, -0.01308701f, 
    0.18991637f, 0.30934405f, -0.70536965f, -0.63135731f, 0.48641056f, -0.76246172f, 0.10656513f, -0.30130371f, 
    -0.03459768f, -0.15088123f, -0.01655582f, -0.36290181f, -0.10093661f, -0.22544582f, -0.32441413f, 0.13792804f, 
    0.05318543f, -0.35337737f, -0.32091585f, -0.07368043f, 0.11181231f, 0.22574636f, -0.12751207f, 0.02232843f, 
    -0.01030388f, 0.34181505f, -0.00053150f, 0.20948742f, 0.11820885f, 0.13747652f, 0.04360353f, -0.00336441f, 
    -0.05049296f, -0.00481815f, 0.20884107f, -0.60071582f, 0.26028717f, -0.27940995f, -0.00115214f, -0.27398950f, 
    0.23098993f, -0.22122250f, 0.29101294f, -0.05178674f, 0.32615563f, -0.49591815f, -0.05833969f, -0.57580131f, 
    0.27607509f, -0.08478087f, -0.23129210f, -0.05790345f, -0.30815238f, 0.00427949f, 0.50024545f, 0.32847628f, 
    -0.19139056f, -0.02992355f, -0.11486581f, -0.01082373f, -0.36176986f, 0.08038133f, -0.02849668f, -0.05772469f, 
    -0.33322367f, 0.27408671f, -0.00347360f, -0.47535533f, 0.02637119f, -0.00524471f, 0.19494316f, 0.15559612f, 
    -0.06955296f, 0.05503068f, 0.20880124f, 0.22866596f, 0.05829919f, -0.21421525f, 0.13668852f, 0.22043288f, 
    0.04661153f, -0.33141670f, 0.25849172f, 0.02574142f, -0.07570092f, -0.34116596f, -0.03074836f, 0.14612244f, 
    -0.00503484f, -0.22933005f, -0.53324711f, -0.18283057f, 0.03574755f, 0.02867349f, -0.18994811f, -0.06115466f, 
    0.21273492f, 0.08692415f, -0.16920446f, -0.49160290f, 0.07797167f, -0.61349809f, -0.36869800f, -0.17149815f, 
    0.12591781f, -0.19247605f, -0.33967507f, -0.06699392f, -0.00197561f, 0.05438525f, 0.22058086f, -0.31939939f, 
    0.05266321f, -0.08768372f, -0.11085328f, -0.35766301f, -0.04091602f, 0.11469837f, -0.22537781f, -0.44961298f, 
    0.15148154f, 0.06381361f, -0.25844035f, 0.34270152f, 0.13288923f, 0.13942429f, 0.26808617f, -0.02739048f, 
    0.07292300f, 0.31929228f, -0.06410173f, -0.44334882f, -0.14400272f, 0.18658680f, -0.39609006f, 0.14531778f, 
    -0.03094980f, 0.11709536f, 0.01747435f, -0.06962994f, 0.06935536f, -0.05674530f, 0.31021604f, -0.76525807f, 
    0.38310054f, -0.54640633f, 0.17271030f, 0.24704914f, -0.06647446f, 0.07393947f, -0.04038433f, 0.10020331f, 
    0.10159353f, 0.35946232f, -0.65916252f, 0.08278769f, 0.26504070f, -0.28979424f, 0.00090617f, -0.04460675f, 
    -0.16743383f, -0.16440050f, -0.73771882f, 0.14035434f, -0.34313390f, -0.41804042f, 0.14233078f, 0.29420432f, 
    -0.23929645f, -0.15713106f, -0.51219124f, -0.33863607f, -0.19820735f, 0.21024351f, -0.19379070f, -0.11164149f, 
    0.20161250f, 0.03411281f, -0.32615077f, -0.10448974f, -0.01137143f, -0.05735523f, -0.66065639f, 0.20499589f, 
    0.05818203f, -0.05300197f, 0.20443115f, -0.25035515f, -0.17475897f, 0.01185547f, -0.06476874f, -0.01787042f, 
    0.18613851f, -0.05134742f, 0.45886120f, -0.31373280f, -0.13656081f, 0.03887036f, 0.37347949f, -0.05441296f, 
    0.07681377f, 0.27105972f, 0.23106728f, -0.10479309f, -0.10103785f, -0.34494781f, -0.18085031f, 0.02663414f, 
    -0.42243531f, -0.14867361f, -0.67267573f, -0.04317439f, -0.07851202f, 0.21492726f, 0.01542722f, 0.14590238f, 
    0.03841022f, 0.00105362f, 0.30712077f, -0.05372157f, -0.34734586f, -0.01136230f, -0.13554952f, 0.06255609f, 
    0.05750478f, 0.10397343f, 0.15508176f, 0.03773637f, -0.16715993f, -0.13465589f, 0.11641935f, -0.50886214f, 
    0.07199480f, -0.50598520f, 0.21595377f, -0.57999885f, -0.25752190f, -0.50898105f, 0.40044668f, 0.26311073f, 
    -0.95712334f, 0.05369492f, -0.58560252f, 0.22592524f, -0.78845716f, -0.00352969f, -0.21018603f, -0.38576460f, 
    -0.29048195f, 0.00651108f, -0.35738352f, 0.32727578f, -0.35587421f, -0.22637138f, 0.10380792f, 0.11173725f, 
    0.25700456f, 0.31605038f, 0.11567511f, 0.23828575f, -0.07862490f, 0.03217809f, -0.60593647f, 0.30747429f, 
    0.08387849f, -0.33468816f, -0.02294553f, 0.33302334f, 0.07032990f, 0.19908176f, -0.65044868f, -0.28378209f, 
    -0.13025573f, -0.38901722f, 0.28868487f, 0.17136322f, 0.08216377f, -0.31550506f, -0.09238233f, -0.08823165f, 
    -0.07445158f, 0.10883899f, 0.01807726f, 0.12947235f, 0.41671959f, -0.27704746f, -0.29969624f, -0.02218184f, 
    0.30905366f, -0.51019371f, 0.10995249f, 0.10558620f, -0.26987672f, 0.34299439f, 0.31346974f, -0.35204035f, 
    -0.40512815f, -0.01637347f, 0.20937037f, 0.27702856f, 0.33045185f, -0.26498747f, -0.21099843f, -0.05326294f, 
    -0.17048228f, -0.00040804f, -0.17836434f, 0.42822859f, -0.36317137f, 0.09957913f, -0.21737282f, -0.30496839f, 
    0.14044352f, 0.09128616f, 0.20502535f, -0.61289883f, 0.41094163f, 0.31240034f, 0.06867007f, -0.11690924f, 
    -0.00613792f, -0.41997924f, 0.01107685f, 0.32328373f, 0.37793094f, -0.15050562f, 0.00330365f, 0.06327866f, 
    0.03352271f, 0.00478543f, -0.65388077f, -0.38087264f, 0.03719410f, 0.23413715f, 0.22865972f, 0.04648221f, 
    -0.27947471f, -0.22054423f, -0.05971806f, 0.01344273f, 0.11688700f, 0.30455208f, 0.05470495f, 0.17256509f, 
    0.08632895f, 0.10334639f, -0.41102797f, 0.20355137f, 0.06618334f, -0.07202125f, 0.29249501f, 0.04038611f, 
    -0.28965333f, -0.32645783f, -0.00923686f, -0.41546100f, -0.19281220f, -0.14823925f, -0.17249271f, -0.17153187f, 
    0.12585391f, 0.56139416f, 0.07994990f, -0.45014718f, 0.13135494f, 0.32566413f, -0.34146729f, -0.21078992f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.27047738f, 0.03987254f, 0.01359188f, -0.07714306f, -0.06521423f, 0.13720447f, 0.06578191f, -0.03370804f, 
    0.02284745f, 0.13893533f, 0.15931758f, -0.09185674f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
