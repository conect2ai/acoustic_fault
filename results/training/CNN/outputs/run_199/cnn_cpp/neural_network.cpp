#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.92640072f, -0.32663915f, 0.09648433f, 0.22500354f, 0.98713160f, 0.94879067f, -0.21393782f, 0.17234036f, 
    0.12580504f, 0.28101870f, -0.12452673f, 0.25693756f, -0.17267819f, 0.38630736f, 0.18523897f, 0.03509450f, 
    -0.10889035f, 0.08162928f, 0.15695474f, 0.06491126f, 0.26331165f, 0.13895687f, 0.09449376f, -0.00952164f, 
    -0.06455234f, -0.01992411f, 0.47195831f, -0.66901165f, -0.36854079f, -0.53799689f, -0.37767327f, -0.56019986f, 
    -0.35442042f, -0.06496747f, -0.32023633f, 0.37949833f, 0.08212487f, 0.46113229f, 0.13334110f, -0.22945765f, 
    -0.25652719f, 0.28973997f, 0.14752565f, -0.03255417f, 0.17886652f, 0.14813973f, 0.11848779f, 0.18934752f, 
    0.25782713f, 0.17276384f, 0.32242632f, 0.51629162f, 0.17331599f, -0.17080392f, -0.34495047f, -0.59032667f, 
    -0.59342802f, -0.56304413f, -0.00974706f, -0.19966224f, 0.31652024f, 0.28771120f, -0.10160173f, 0.07355903f, 
    -0.27990976f, -0.14106621f, 0.13795236f, 0.22361451f, 0.17426147f, -0.39597115f, -0.01399047f, -0.07244353f, 
    0.07754673f, 0.30914757f, 0.46981916f, 0.56305850f, 0.53898990f, 0.72138536f, 0.58826357f, 0.27706009f, 
    0.21504310f, -0.51652169f, 0.27817461f, -0.39222187f, -0.23642638f, -0.39353818f, -0.38310629f, -0.26063854f, 
    0.09512874f, -0.16074575f, 0.32558149f, 0.49286047f, 0.02845167f, 0.24844386f, 0.24715333f, 0.01384222f, 
    -0.09260441f, -0.06453128f, -0.14925897f, 0.21701579f, -0.19331180f, -0.74722040f, -0.53234941f, -0.43516779f, 
    -0.25561163f, 0.25591862f, -0.17848405f, -0.40256920f, -0.16377266f, -0.19729459f, -0.10854443f, 0.28916109f, 
    0.22286053f, 0.06248634f, 0.21422617f, 0.25078246f, 0.31981999f, 0.33626893f, 0.17835508f, 0.40070301f, 
    -0.09711237f, 0.18194334f, 0.02521490f, 0.12669531f, 0.28647372f, 0.16377312f, -0.65598786f, 0.46274167f, 
    0.36388940f, 0.67184228f, 0.00661718f, -0.13626043f, -0.71598023f, -0.67320770f, -0.10240039f, 0.27909431f, 
    0.28722998f, 0.02125895f, 0.10155490f, -0.15428588f, -0.11410131f, 0.21864228f, 0.06842076f, 0.30067801f, 
    0.11004738f, 0.07501150f, 0.46356907f, -0.17566459f, -0.08106861f, 0.33781391f, -0.59672654f, -0.56828249f, 
    -0.27773365f, -0.35937968f, 0.07818371f, -0.21604976f, -0.10287689f, -0.01248917f, -0.54950023f, -0.31212744f, 
    0.09681789f, 0.54719329f, 0.37173077f, 0.28601584f, -0.03979803f, -0.20776846f, -0.33055785f, -0.17481405f, 
    -0.36527163f, 0.28813967f, 0.18343391f, -0.40035129f, -0.01039364f, 0.15373796f, -0.03785941f, 0.18870446f, 
    -1.03240752f, -0.62081981f, 0.01329642f, -0.31584391f, -0.60979944f, 0.55909073f, -0.32727045f, 0.32619008f, 
    0.41990498f, 0.52347094f, 0.11697526f, -0.19938357f, -0.02092794f, -0.16132507f, -0.21708460f, -0.07456215f, 
    0.13691872f, 0.11501268f, -0.06054395f, 0.15431976f, 0.30012053f, 0.05225560f, 0.08447043f, 0.09417792f, 
    -0.39467159f, -0.74210829f, 0.08928972f, 0.41831014f, -0.57132953f, -0.20287684f, 0.69933033f, 0.54144049f, 
    -0.33469653f, -0.20058638f, -0.13891406f, -0.08922651f, -0.50543249f, -0.16268638f, 0.32855994f, -0.20551066f, 
    -0.13231267f, 0.09018981f, 0.10195185f, -0.16058534f, -0.16988541f, -0.09858193f, 0.38914075f, 0.38398629f, 
    0.23797841f, 0.72959316f, 0.76543063f, 0.42543790f, -0.06626605f, -0.26243737f, -0.64023286f, 0.20732315f, 
    0.23488326f, -0.08445407f, -0.27218482f, 0.26408443f, 0.08259952f, -0.43092123f, 0.31073725f, 0.15617731f, 
    0.07854999f, 0.15563007f, 0.45832112f, -0.09587822f, 0.11616487f, 0.50721067f, -0.15447688f, -0.26752418f, 
    0.24108206f, -0.26117721f, 0.66891450f, 0.00464585f, 0.10492188f, 0.05200848f, 0.24269286f, 0.82440585f, 
    0.51630372f, 0.57483709f, 0.53350937f, 0.22583735f, -0.13727814f, -0.13256854f, -0.36599824f, -0.08040389f, 
    0.25733715f, -0.18435062f, 0.00308229f, -0.09016571f, 0.31049442f, 0.19435427f, -0.14437518f, 0.15617138f, 
    -0.39503822f, -0.14914827f, 0.02143116f, 0.23914072f, 0.48546389f, -0.55914253f, -0.81339562f, -0.11531075f, 
    0.08511027f, -0.30352759f, 0.40268943f, -0.34469262f, -0.29062271f, -0.00588593f, 0.03190323f, 0.31122574f, 
    0.04523702f, -0.11559790f, 0.37866291f, -0.28240395f, -0.00327566f, 0.26197448f, 0.36748311f, 0.20192157f, 
    0.15879853f, 0.00752416f, -0.48853278f, -0.07496005f, -0.04482609f, -0.82855886f, -0.39883831f, 0.11148655f, 
    -0.15198551f, -0.74820524f, -0.38401210f, 0.12002900f, -0.65467143f, -0.00382762f, 0.40994135f, 0.27864793f, 
    -0.16479516f, -0.06881822f, 0.12303009f, -0.20809567f, 0.06856311f, 0.21648447f, 0.24674980f, -0.23198986f, 
    -0.10179906f, -0.17129038f, -0.09437872f, -0.04249324f, 0.34912857f, -0.13159962f, -0.81183612f, -0.62688816f, 
    -0.57459563f, -0.28751990f, -0.05669462f, -0.42937019f, 0.11885372f, 0.41953924f, 0.13281640f, -0.06674457f, 
    -0.26904276f, 0.06873108f, 0.29341340f, -0.12789027f, 0.07638479f, 0.19041097f, -0.24638581f, 0.17352402f, 
    0.39302483f, -0.23950680f, 0.11107066f, 0.20126373f, 0.14118029f, 0.17735626f, -1.42440450f, 0.52747726f, 
    0.74671316f, -0.71881986f, -0.68283689f, 0.23015440f, -0.01779135f, 0.20487326f, 0.63416940f, -0.24559106f, 
    -0.19651987f, -0.07847255f, -0.27721688f, 0.03791281f, -0.05647397f, -0.28161544f, -0.02983226f, -0.23691319f, 
    -0.21543525f, -0.42586896f, 0.16755883f, 0.29048631f, 0.13144237f, 0.04485838f, 0.21024700f, -0.05676486f, 
    0.07482006f, -0.38615355f, 0.01961944f, -0.28000569f, 0.78511518f, -0.66861939f, -0.57530892f, -0.40643609f, 
    0.46274790f, 0.17972812f, -0.27235520f, 0.43384287f, 0.14754397f, 0.16678961f, 0.07407173f, -0.12274320f, 
    -0.10573543f, 0.18160361f, 0.13063130f, -0.30584189f, -0.31019300f, 0.23507383f, 0.04489122f, 0.04297660f, 
    0.67678666f, -0.43834880f, 0.78849930f, 0.84050030f, 0.07324757f, 0.27042779f, 0.21016271f, 0.17550232f, 
    0.19489734f, 0.02191749f, 0.05244931f, -0.31458935f, -0.50693208f, 0.22954074f, -0.57053071f, 0.06926329f, 
    -0.24771044f, -0.07849916f, 0.04714137f, -0.21818529f, -0.19137476f, 0.37284517f, -0.01407716f, 0.17950600f, 
    0.10904669f, -0.21023807f, 0.69082314f, 0.08379876f, -0.26381698f, 0.48394150f, -0.83703339f, -0.33257496f, 
    -0.17581865f, 0.23776060f, -0.75367421f, -0.10520966f, -0.27629626f, 0.08409430f, 0.31709173f, 0.01983009f, 
    0.31421450f, 0.01199071f, -0.13607691f, -0.01965223f, -0.12779756f, 0.01224677f, -0.05466031f, -0.05929939f, 
    0.07633840f, 0.02278582f, 0.42507398f, 0.73518807f, -0.23258007f, -0.61153048f, -0.41175810f, 0.49003333f, 
    -0.07101057f, -0.78282702f, -0.46347961f, -0.39898229f, 0.42938808f, -0.23364265f, -0.27890930f, -0.14568199f, 
    -0.18955171f, -0.12583679f, -0.19659764f, -0.07201804f, -0.19714984f, -0.34510374f, -0.08436388f, 0.19499962f, 
    0.10228791f, 0.22706780f, -0.04200735f, -0.67777663f, 0.60995936f, 0.14660348f, -0.82806933f, 0.92795813f, 
    0.75015724f, -0.41180122f, 0.03503888f, 0.01016780f, -0.02694442f, 0.02949710f, -0.24218293f, -0.04805654f, 
    0.19577788f, 0.10252189f, 0.06980360f, -0.00144701f, -0.42701042f, 0.10275030f, -0.31024829f, 0.32020900f, 
    0.07934408f, -0.04981358f, 0.14932086f, -0.18919909f, 0.99931633f, -0.13700451f, 0.84574217f, -0.46196619f, 
    -0.42269427f, 0.60215157f, -0.74804801f, 0.28561649f, 0.39164916f, 0.45622429f, 0.24552006f, -0.09142224f, 
    -0.45409009f, 0.04105562f, 0.05864677f, 0.36882380f, 0.15630366f, -0.06930368f, -0.26205343f, 0.09086157f, 
    0.45847824f, -0.10156018f, 0.25364920f, 0.00016776f, 0.32490054f, -1.14681828f, 0.01703965f, 0.03809561f, 
    -0.17560594f, -0.79679364f, 0.64138818f, 0.54932100f, -0.43353739f, 0.12843764f, 0.29690948f, 0.08394919f, 
    -0.24932174f, 0.15498859f, 0.21788231f, -0.04407300f, -0.10909355f, -0.23232542f, -0.06313419f, -0.31104821f, 
    0.00549243f, -0.09601662f, -0.28481436f, 0.08734487f, -0.01399849f, 0.03585818f, -0.31964388f, -0.72424340f, 
    -0.35760233f, -0.28079876f, 0.01101369f, 0.52178490f, 0.13450392f, 0.53960663f, 0.56548011f, 0.10447190f, 
    0.40471569f, -0.06000323f, -0.28998563f, 0.48679432f, 0.27805817f, 0.13821480f, 0.05117517f, 0.29161671f, 
    0.06857536f, -0.05845061f, 0.08070917f, -0.36692902f, 0.27640018f, -0.06017078f, 0.16287865f, 0.87667239f, 
    0.55620277f, -0.48147878f, 0.88568991f, -0.22945085f, 0.27118677f, 0.32485202f, -0.01653224f, 0.34137693f, 
    0.13703823f, -0.02561313f, -0.03399834f, 0.16787603f, 0.06665484f, 0.00573256f, 0.46215108f, 0.10437753f, 
    -0.28699169f, 0.28228819f, 0.10675749f, 0.15187475f, -0.44105864f, -0.34288046f, -0.21785048f, 0.17995897f, 
    -0.80803889f, -0.91592592f, -0.25890294f, 0.29119012f, -0.02021513f, 0.29173318f, 1.05989146f, 0.47141585f, 
    -0.77834880f, 0.06798857f, 0.01795072f, -0.33933887f, 0.00612627f, -0.39463803f, 0.02982341f, -0.08315001f, 
    0.02718621f, -0.14754070f, 0.00099368f, -0.34683889f, 0.20587039f, -0.09160070f, -0.06755298f, 0.20942897f, 
    -0.06243350f, 0.42298838f, 0.85174257f, 0.79592186f, 0.64348423f, 0.34334344f, 0.80589062f, 0.01948654f, 
    -0.17738689f, -0.26340657f, -0.46087235f, 0.39412341f, 0.29773757f, 0.03977663f, 0.27545917f, -0.21595365f, 
    0.23977076f, -0.20309155f, 0.10507474f, 0.00591607f, -0.03234644f, -0.08349077f, -0.18720067f, 0.03221263f, 
    0.01578130f, 0.24915798f, 0.47719729f, 0.06258936f, -0.46983653f, -0.34066108f, 0.43758091f, 0.10130046f, 
    -0.36212233f, -0.38610601f, -0.52299082f, -0.52233177f, -0.37152880f, -0.49013758f, 0.21653472f, 0.40628335f, 
    -0.04491559f, 0.16056110f, -0.34087127f, -0.24114758f, 0.21507208f, -0.15287694f, -0.47401312f, -0.01052261f, 
    0.15143353f, 0.00189520f, 0.24030887f, 0.62533540f, 0.39175186f, 0.55755967f, 0.46891803f, 0.73887151f, 
    0.04609411f, -0.13386081f, -0.56180006f, -0.46398124f, -0.51513052f, 0.26897380f, 0.39852944f, 0.07187517f, 
    -0.07115672f, -0.18139859f, 0.05395224f, 0.16175863f, -0.20873038f, -0.06349786f, 0.34806263f, -0.33069485f, 
    0.25361910f, 0.14391594f, 0.00074162f, -0.21181570f, -0.01900813f, 0.62588418f, -0.39654559f, 0.02577093f, 
    -0.98781836f, 0.55325198f, 0.05851967f, -0.15049277f, 0.71469992f, -0.02844830f, -0.40157336f, -0.35652849f, 
    0.04134535f, -0.27789938f, 0.17065884f, -0.02341242f, -0.15809608f, -0.13642955f, 0.16343907f, -0.19693294f, 
    0.15593891f, -0.07587069f, 0.19714485f, -0.08340817f, 0.32618904f, 0.76802176f, 0.72323835f, 0.76657289f, 
    0.27851558f, 0.06096753f, -0.11727974f, -0.33093855f, 0.02532587f, 0.31586912f, 0.40855300f, -0.05826015f, 
    0.20182088f, 0.05140382f, -0.12002145f, 0.24827975f, 0.18170276f, 0.21913488f, -0.10910345f, -0.33767369f, 
    0.10851366f, 0.08526322f, 0.36367661f, 0.11309300f, -0.21573432f, 0.02733624f, 0.21042065f, -0.65889913f, 
    0.29231834f, 0.55294800f, 0.45517915f, -0.61639845f, -0.73048407f, -0.16071323f, 0.00658067f, -0.60944903f, 
    0.35388044f, 0.33403665f, 0.10570997f, 0.02859526f, 0.26012224f, -0.43270952f, 0.02441693f, 0.03607569f, 
    -0.22261213f, 0.13435085f, 0.23753707f, -0.09510326f, -0.23301548f, -0.20949505f, -0.05133494f, -0.39158946f, 
    0.85807008f, -0.27202514f, -0.78233665f, -0.44993392f, 0.73437554f, 0.15126275f, -0.38142899f, 0.03656507f, 
    0.46828410f, 0.29090941f, 0.02503702f, 0.16669817f, -0.15133661f, 0.01986660f, -0.10112138f, -0.26075307f, 
    0.32636547f, -0.06384102f, -0.11857451f, 0.24500842f, -0.07851617f, -0.11485294f, 0.14092469f, 0.02018838f, 
    -0.57106239f, -0.23838721f, -0.40115818f, 0.16967842f, 0.51169199f, -0.99847001f, 0.15777230f, 0.58657742f, 
    -0.36672062f, 0.17239781f, 0.04664394f, 0.07695771f, 0.45180130f, -0.22648712f, 0.43800771f, 0.29809552f, 
    0.12299607f, -0.14151601f, 0.47459146f, 0.09717260f, -0.03476427f, -0.25537598f, -0.07135036f, -0.16652630f, 
    0.24124320f, 0.87187266f, 0.79917395f, -0.62517118f, -0.21540660f, 0.59143972f, 0.24638069f, 0.29058626f, 
    -0.30716938f, 0.50162011f, -0.10472229f, 0.11275638f, 0.35491756f, -0.06721798f, 0.18494542f, -0.02245142f, 
    0.00069951f, 0.04981522f, -0.09927459f, -0.18973930f, 0.02600046f, 0.06127675f, 0.02284038f, 0.13165802f, 
    -0.04887246f, 0.07911380f, 0.83481377f, 0.71241713f, -0.28339225f, 0.37985036f, 0.54215002f, -0.23698340f, 
    0.22656500f, 0.19309106f, 0.42959106f, 0.64123487f, -0.35250968f, 0.09199766f, 0.00092713f, -0.53120977f, 
    -0.01902759f, -0.25052053f, -0.00553711f, -0.16242151f, -0.24258634f, 0.29262868f, 0.07455931f, -0.16479614f, 
    0.33762157f, 0.06365383f, 0.17352784f, 0.83815986f, -0.30435356f, -0.73968351f, 0.75019068f, 0.24914278f, 
    -0.14917094f, 0.02969549f, -0.34686202f, 0.33271718f, 0.29159465f, -0.58412880f, 0.17578520f, 0.21984020f, 
    0.08560220f, -0.40036061f, -0.44800851f, 0.35105848f, 0.12588501f, -0.36921009f, -0.27479833f, -0.14314899f, 
    -0.17722590f, -0.48435584f, 0.03617770f, 0.25811636f, -0.13026637f, 0.48875645f, 0.60782427f, 0.52134597f, 
    0.01791588f, 0.35455695f, 0.21368282f, 0.15450729f, -0.24307348f, -0.26497638f, -0.43478593f, -0.31504926f, 
    -0.02206295f, -0.10908189f, 0.40029681f, -0.02326665f, -0.22986783f, -0.04146937f, 0.15615097f, 0.05188895f, 
    0.32872245f, 0.21301365f, 0.23407084f, 0.49029624f, 0.22173117f, -0.42876843f, -0.90241963f, -0.75842595f, 
    -0.01046976f, -0.04196127f, 0.18647237f, 0.30265298f, -0.07277956f, 0.21060836f, 0.38268453f, -0.50419199f, 
    0.01601615f, 0.10624099f, 0.39466816f, 0.45169470f, -0.48193347f, -0.06413338f, 0.15015683f, -0.18283534f, 
    -0.06674964f, 0.29699764f, 0.15813671f, -0.05241606f, 0.10028461f, -0.00920007f, 0.61726177f, 0.03122293f, 
    -0.55118829f, 0.50225633f, 0.01032753f, 0.64323908f, -0.45310518f, -0.05408802f, 0.31846929f, 0.02699508f, 
    -0.53009182f, -0.31622466f, -0.06559420f, -0.03340952f, 0.05359915f, 0.23130918f, -0.13840762f, -0.11000453f, 
    -0.23854659f, 0.38718513f, 0.06193198f, 0.30063275f, 0.49014172f, -0.12432718f, 0.39482138f, -0.55373079f, 
    -0.85904986f, 0.06288488f, 0.98641497f, 0.67576802f, 0.60264069f, 1.02610457f, -0.16185150f, 0.55161226f, 
    0.00933154f, -0.01184756f, 0.22203945f, -0.21164477f, 0.16878463f, -0.16526572f, -0.07405324f, 0.00744556f, 
    0.06460296f, -0.12470165f, -0.09260517f, -0.01123875f, 0.10635912f, -0.13115028f, -0.16961370f, -0.11896758f, 
    0.64272082f, 0.72008854f, 0.42147142f, 0.13421230f, 0.70774400f, -0.14824894f, -0.49852893f, -0.46159589f, 
    0.42733896f, -0.13752325f, 0.03900012f, 0.18195583f, 0.21982305f, 0.09020697f, -0.10924730f, -0.13868295f, 
    -0.01821426f, 0.11238910f, -0.09369545f, -0.30256444f, 0.16196129f, 0.20289113f, 0.41647652f, -0.22857757f, 
    -0.02203072f, -0.07501515f, -0.44194615f, -0.66238165f, -0.36675701f, -0.52506047f, 0.08903414f, 0.75453836f, 
    0.14287367f, 0.11031917f, 0.30579057f, -0.13887632f, 0.34269917f, 0.04864577f, 0.07667729f, 0.07667481f, 
    0.06912385f, 0.08991662f, 0.17758696f, 0.15863398f, -0.20304491f, 0.12498518f, 0.22977355f, 0.02780435f, 
    0.14212026f, 0.14538310f, -0.06848939f, 0.07964158f, -0.55039507f, -0.47003850f, 0.23095913f, -0.22258969f, 
    -0.42615187f, -0.44973072f, -0.38303670f, 0.24357350f, -0.26014441f, -0.25858250f, 0.33310226f, -0.43997404f, 
    -0.35910022f, 0.31203103f, 0.14220975f, 0.46674642f, -0.14416872f, 0.19795914f, -0.34193736f, 0.13418803f, 
    -0.41190574f, -0.14945643f, 0.12301509f, -0.41301158f, -0.76987553f, -0.80136919f, -0.54553086f, 0.12679203f, 
    0.00336645f, 0.72227353f, 0.27295700f, 0.31355512f, 0.39386603f, 0.02997007f, -0.30474925f, -0.27720642f, 
    -0.23846027f, 0.03095104f, -0.11262680f, -0.00013289f, -0.26711637f, -0.11576126f, -0.25545377f, -0.29869083f, 
    -0.16184863f, -0.03789323f, -0.21187647f, -0.29630968f, -0.76790875f, 0.63736969f, -0.25430948f, 0.40863931f, 
    -0.22559543f, 0.45962286f, 0.04409748f, 0.16800532f, -0.41888508f, 0.39259359f, -0.20909141f, 0.02803559f, 
    0.21152012f, 0.13639307f, 0.33880776f, -0.09169280f, -0.21861224f, -0.21423067f, 0.25601301f, 0.22758700f, 
    0.38089207f, 0.15833628f, 0.03774618f, 0.10030816f, -0.34550837f, 0.85459310f, 0.57524312f, -0.23130047f, 
    0.63449508f, 0.17928068f, 0.21369310f, 0.17881365f, -0.38733509f, 0.35480466f, -0.09171617f, -0.25044379f, 
    -0.11466037f, -0.13252942f, 0.04009997f, -0.22955500f, 0.12832634f, -0.08195974f, -0.10673171f, -0.22566600f, 
    0.09404930f, -0.45188558f, -0.14021856f, -0.58588898f, -0.22960450f, -0.24847524f, 1.14876986f, -0.41764411f, 
    0.19613683f, 0.99576974f, 0.67674446f, 0.33297470f, 0.49036771f, -0.06574393f, 0.04919906f, 0.04879173f, 
    -0.34064072f, 0.31864265f, -0.36216936f, 0.17699243f, -0.11592030f, -0.01838370f, 0.11363481f, -0.05333944f, 
    0.14298655f, -0.36045188f, 0.03825613f, 0.21435806f, 0.20111762f, 0.01719704f, 0.06309874f, -0.35235593f, 
    0.18350974f, -0.18720709f, 0.18225320f, -0.80585277f, 0.34131867f, 0.55333650f, 0.18452379f, 0.20929174f, 
    -0.05150697f, 0.07467879f, -0.21465451f, -0.02640766f, -0.19164374f, 0.19514439f, 0.20976461f, -0.47910485f, 
    0.07108606f, -0.35007378f, -0.34206167f, 0.00149513f, 0.16635524f, 0.34170026f, 0.26650769f, 0.06002275f, 
    0.96552640f, -0.01674146f, -0.45521313f, -0.35434037f, -0.53936678f, -0.18916517f, -0.59492910f, -0.41103774f, 
    0.08980360f, -0.37264165f, 0.20517457f, -0.24111784f, 0.48157084f, -0.25751120f, -0.08675923f, 0.04431189f, 
    -0.28051424f, -0.11246168f, -0.20701927f, 0.20113656f, 0.08474877f, 0.35719854f, 0.27357137f, -0.10884944f, 
    -0.14742547f, 0.81547219f, -0.14052804f, 0.39770508f, 0.07793797f, -0.19136234f, -0.53166693f, -0.01249340f, 
    -0.49674976f, 0.34755769f, -0.03492783f, -0.45820394f, -0.07560582f, 0.22348285f, -0.17109016f, -0.21533050f, 
    -0.58631980f, -0.51780051f, -0.33274752f, 0.19173215f, -0.25014251f, 0.28983793f, 0.28983551f, -0.18588030f, 
    -0.11323766f, 0.33704111f, -1.17889500f, 1.06694174f, 0.46019441f, -0.67554355f, 0.79949480f, 0.44756973f, 
    0.50443125f, -0.33435798f, -0.01640119f, -0.49407127f, -0.21750760f, 0.28491285f, 0.34370160f, -0.11856112f, 
    -0.23764154f, 0.12977532f, -0.12679201f, 0.05528575f, -0.27101111f, -0.02420939f, 0.05770449f, -0.21848366f, 
    -0.23179588f, -0.05196129f, 0.06443294f, -0.87826300f, -0.29416585f, -0.09022658f, -0.34041861f, -0.03212255f, 
    -0.48744836f, 0.48937383f, 0.36274442f, 0.21476924f, 0.35354006f, -0.68277961f, 0.07143232f, 0.26945072f, 
    -0.48201886f, -0.39675394f, 0.13768964f, -0.06940690f, 0.31626222f, -0.14585671f, 0.09969256f, 0.02527170f, 
    -0.22648057f, 0.17449468f, -0.19433782f, -0.17616571f, 0.42245540f, 0.26620531f, -0.45797193f, -0.37945348f, 
    -0.44562259f, 0.74958533f, 0.43775427f, 0.64681262f, 0.36116806f, -0.09710886f, 0.42825332f, 0.05607138f, 
    -0.06180179f, 0.00455928f, 0.24370381f, -0.19643483f, -0.21228130f, 0.12739319f, -0.04524789f, 0.03785485f, 
    -0.05143658f, 0.15671413f, -0.10536769f, -0.06580441f, 0.19972949f, 0.36395243f, 0.65437055f, 0.67596036f, 
    0.56785959f, 0.21601218f, -0.81291229f, 0.23253219f, -0.65048319f, -0.83192801f, 0.42292345f, 0.37238345f, 
    0.54214150f, 0.04041373f, 0.41272187f, 0.03685510f, -0.02720460f, -0.50266802f, 0.06226796f, -0.05676956f, 
    -0.16633022f, -0.03492603f, 0.09119281f, -0.05546630f, 0.26591000f, -0.11004430f, -0.99664241f, 0.85759336f, 
    0.73349953f, -0.43114993f, -0.46705833f, -0.32853010f, 0.68732643f, 0.05707901f, -0.46470565f, -0.10181799f, 
    0.06898124f, 0.40212080f, -0.10710273f, -0.00699276f, 0.07733035f, -0.07769617f, -0.11584848f, 0.07143603f, 
    -0.14501449f, 0.04136740f, 0.24315085f, 0.28283712f, 0.28054693f, 0.44762659f, -0.13892694f, 0.10757766f, 
    0.18906265f, 0.43770042f, 0.13754004f, 0.05884280f, -1.00731480f, 0.38077641f, 0.28107798f, -0.20411132f, 
    -0.64549297f, -0.20523667f, -0.07693314f, -0.45546564f, 0.14069711f, -0.15345269f, -0.14523135f, 0.02514967f, 
    0.22216640f, 0.16509956f, -0.07424263f, -0.05761241f, -0.22844721f, -0.31412557f, -0.23628063f, -0.35507196f, 
    0.84124684f, 0.53305155f, -0.68280697f, 0.69756460f, -0.54301113f, 0.24210472f, -0.02583453f, -0.37518573f, 
    0.44932812f, -0.24151850f, 0.13342007f, 0.11634719f, -0.07193353f, 0.20177171f, -0.24681637f, 0.16388592f, 
    -0.27635014f, -0.16675732f, -0.09775896f, -0.31907105f, -0.35792381f, 0.20814772f, -0.12014562f, 0.05785719f, 
    0.17576492f, -0.12967546f, 0.30082855f, 0.44606504f, -0.79684621f, 0.33835620f, -0.62473655f, -0.42287341f, 
    -0.39067867f, -0.67702663f, -0.48107782f, 0.14789955f, 0.48975614f, -0.06148588f, 0.07998242f, 0.07457520f, 
    -0.28837794f, 0.20173274f, -0.00863216f, 0.02049187f, 0.62414753f, -0.18789534f, 0.13284518f, 0.11640713f, 
    -0.05722157f, 0.24991554f, -0.43853211f, -0.24861807f, -0.31223774f, -0.38530970f, 0.02681553f, -0.01361287f, 
    -0.03474123f, 0.13883494f, -0.20283622f, -0.73004800f, 0.54803854f, 0.20952091f, -0.37747675f, 0.21925654f, 
    0.07651801f, -0.16056481f, 0.20985492f, -0.52347821f, -0.30753237f, 0.12596115f, 0.15629883f, -0.20010646f, 
    0.47024530f, -0.08495319f, 0.30386561f, -0.22623387f, 0.10870894f, -0.63441604f, -0.76800972f, -0.50865155f, 
    0.40219170f, 0.39209160f, 0.52503300f, 0.24195877f, 0.48351499f, -0.35286185f, -0.23616947f, -0.27165899f, 
    -0.23380016f, -0.49917370f, -0.17748185f, 0.15424296f, -0.00389224f, 0.14732347f, 0.16435663f, -0.24244367f, 
    -0.19806880f, -0.08784992f, -0.36725217f, 0.34058255f, 1.02187991f, 0.62504888f, 0.12488292f, -0.67585862f, 
    -0.84962195f, -0.58130497f, 0.32437456f, -0.05466551f, -0.20309834f, 0.09610464f, -0.11205164f, 0.33450833f, 
    0.19892059f, -0.09903666f, -0.33739418f, -0.24335948f, -0.07004590f, 0.00516046f, 0.11640647f, 0.02143561f, 
    -0.18151422f, 0.08760778f, -0.09885927f, -0.35264194f, -0.01434969f, -0.35036287f, -0.52199012f, 0.37005496f, 
    0.51242095f, 0.09961630f, -0.15611455f, -0.01620225f, 0.52636987f, -0.33585939f, -0.46515420f, 0.07133295f, 
    -0.05688122f, -0.36979690f, 0.35256466f, 0.54520786f, 0.04857799f, -0.11040368f, 0.19149257f, -0.22456853f, 
    0.12786616f, 0.25943923f, 0.33491081f, 0.11555709f, 0.03005182f, -0.03912016f, -0.61387497f, 0.09063558f, 
    -0.45526311f, -0.34359735f, -0.31546208f, 0.18320857f, 0.21850355f, -0.14017443f, 0.38820162f, 0.29602581f, 
    0.15409648f, 0.48005882f, 0.38799578f, 0.06915825f, -0.13036479f, 0.30303541f, 0.15689096f, 0.44566303f, 
    0.28029850f, -0.13987072f, 0.12673368f, -0.30422479f, -0.27763206f, -0.40650094f, -0.12345733f, -0.23745278f, 
    0.10449602f, 0.76452553f, 0.81846482f, -0.80652589f, 0.01246604f, -0.51990557f, 0.14392300f, 0.25617558f, 
    -0.03062545f, -0.11986849f, 0.26239446f, 0.23152746f, -0.37170881f, 0.08651928f, -0.35532534f, 0.24990353f, 
    0.22318523f, 0.17129582f, -0.23580565f, 0.13402358f, -0.29090923f, -0.33348036f, -0.29242629f, -0.09946834f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.04824097f, 0.18958443f, 0.24732496f, 0.06146670f, 0.21593033f, 0.22102009f, 0.18181635f, 0.16713020f, 
    0.02108259f, -0.07905211f, 0.05624005f, 0.31915382f, 0.22316559f, 0.16301452f, 0.23114640f, 0.23429765f, 
    0.11942817f, 0.21443920f, 0.15907896f, -0.01039288f, 0.09513097f, 0.01799789f, 0.07476602f, 0.34051082f, 
    0.11998919f, 0.10384000f, 0.07726323f, -0.06198184f, 0.03277637f, 0.37193102f, -0.02260363f, -0.05986044f, 
    0.17815895f, 0.18441567f, 0.28610039f, 0.21002972f, 0.19777408f, 0.08169256f, 0.03282042f, 0.00987042f, 
    0.08202754f, 0.31656024f, 0.36800331f, 0.01332990f, 0.13628060f, 0.25570068f, 0.07841682f, -0.04183823f, 
    0.05243580f, -0.05211963f, 0.19670591f, -0.00740414f, 0.04867068f, 0.06162065f, 0.06460217f, 0.06466730f, 
    0.16735116f, 0.22692823f, 0.32805574f, -0.15150201f, -0.01428796f, 0.07001310f, 0.29433990f, 0.11270623f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.31814465f, -0.24749392f, 0.12320189f, 0.21312782f, 0.05622647f, 0.04484738f, -0.01817559f, 0.02784188f, 
    0.02330938f, 0.10604499f, 0.03922044f, -0.03547563f, -0.19272983f, -0.20084080f, 0.17006432f, 0.03595743f, 
    -0.08426893f, 0.03106253f, 0.08493026f, -0.00133735f, -0.03523065f, -0.01588756f, -0.01990404f, -0.06150549f, 
    -0.06932611f, -0.07173726f, 0.11384727f, 0.13126445f, -0.05944247f, -0.02587825f, -0.00876688f, -0.06023695f, 
    0.02217382f, 0.02224716f, 0.00174063f, -0.04253853f, 0.09025826f, 0.05350900f, -0.03326823f, 0.12547009f, 
    -0.04920132f, -0.07194921f, 0.05085259f, 0.13543825f, -0.02130174f, 0.04088914f, 0.02551607f, -0.01992227f, 
    -0.11634591f, -0.19714546f, 0.07359225f, -0.14402218f, 0.02186469f, 0.00954287f, 0.02374772f, 0.01037405f, 
    0.00991182f, -0.05115362f, 0.00378083f, 0.01106072f, 0.16041656f, -0.12197769f, 0.02356862f, 0.01579698f, 
    -0.23576014f, -0.02411471f, 0.06148950f, -0.11775060f, -0.11137571f, 0.00038017f, -0.02507075f, 0.04933073f, 
    -0.35664868f, -0.14676295f, 0.01530631f, 0.01621570f, 0.02199482f, 0.02656141f, 0.03413088f, 0.01205603f, 
    0.07431649f, 0.02535179f, 0.02081998f, -0.06231480f, -0.28599626f, -0.17482257f, -0.12975305f, 0.05411711f, 
    0.02131206f, -0.08402430f, 0.12437501f, -0.01904252f, 0.01363199f, 0.09091946f, -0.01876014f, 0.00045591f, 
    -0.05559317f, 0.08694494f, 0.04421600f, -0.01606556f, 0.05981237f, 0.07623598f, -0.11692829f, 0.07830645f, 
    0.14613561f, 0.00169332f, -0.02547987f, 0.06987733f, 0.07195868f, 0.12083141f, -0.00745631f, -0.12087364f, 
    -0.17600143f, 0.03572630f, -0.10846947f, -0.10989896f, -0.03641981f, 0.07378398f, 0.06339159f, -0.11151356f, 
    0.15586473f, -0.08429055f, 0.05041257f, -0.00870485f, -0.03490039f, -0.04001797f, 0.11084868f, -0.01651512f, 
    0.00067586f, -0.04501075f, -0.01188510f, 0.01796314f, -0.14333919f, -0.04889358f, 0.09678040f, -0.34016520f, 
    -0.03660490f, -0.03476235f, 0.06218623f, -0.06860099f, -0.02009959f, -0.15601034f, -0.05158189f, 0.07062823f, 
    -0.18365851f, -0.40256104f, 0.07904755f, 0.10998605f, -0.09670056f, -0.07313247f, -0.03016914f, -0.04213027f, 
    -0.03182538f, 0.08732428f, -0.15576749f, 0.03602885f, 0.02811265f, -0.15880261f, 0.00007746f, -0.29513681f, 
    0.00159667f, -0.02522969f, 0.14815766f, -0.00035179f, -0.03811904f, -0.01252479f, 0.05601458f, -0.04376848f, 
    0.21395886f, 0.06438772f, 0.06010162f, 0.14069735f, -0.06011864f, 0.00946560f, -0.05121880f, -0.03169682f, 
    0.04723976f, -0.04765418f, 0.00101388f, -0.01316962f, 0.05532532f, -0.19165628f, -0.03497015f, -0.12383766f, 
    -0.05307579f, -0.16562983f, -0.11014582f, -0.04950427f, -0.11234283f, 0.03946609f, -0.08363199f, 0.03711459f, 
    0.15873365f, -0.06811375f, -0.11637761f, 0.30694851f, -0.02126394f, -0.01649076f, 0.02577674f, 0.03331491f, 
    0.00390184f, 0.01644018f, -0.06388263f, -0.12591626f, -0.12789083f, 0.13746025f, 0.04387934f, -0.06439168f, 
    -0.11331371f, -0.11380704f, 0.00960201f, -0.01477808f, 0.01461161f, 0.08152394f, -0.02723266f, -0.06898872f, 
    -0.10274998f, 0.08523852f, 0.06542838f, -0.24981156f, -0.11623988f, 0.09776040f, 0.09528856f, 0.04212927f, 
    -0.02304393f, -0.08470986f, -0.03555440f, 0.01746545f, -0.12483659f, -0.14443547f, 0.20196241f, -0.07550695f, 
    -0.00375887f, 0.06981025f, 0.02067447f, -0.12843040f, 0.01055723f, -0.00749137f, 0.04914320f, 0.04178897f, 
    0.18245077f, -0.22164805f, 0.01506070f, -0.03969714f, -0.01150915f, -0.05578161f, -0.07104547f, -0.04141561f, 
    0.02535747f, 0.01412384f, -0.01250354f, 0.01100990f, 0.51215833f, -0.00303801f, -0.00403966f, -0.13446599f, 
    -0.03223677f, 0.04991099f, -0.08695922f, 0.07295913f, -0.03213903f, 0.04528916f, -0.00018742f, 0.08533967f, 
    0.01035198f, 0.08086250f, 0.00918161f, -0.20117642f, 0.08070109f, 0.01590596f, -0.01872207f, 0.02110715f, 
    0.04302993f, 0.01785689f, -0.13608965f, -0.01742345f, 0.02450589f, -0.05638300f, -0.07337484f, 0.07586779f, 
    -0.10573945f, 0.04743650f, 0.01729531f, 0.01413859f, 0.05871524f, -0.04132881f, 0.04135847f, 0.03325575f, 
    -0.03847806f, 0.17424133f, 0.19073199f, -0.11743690f, 0.08840943f, 0.03735580f, -0.07686025f, 0.05414896f, 
    -0.01326036f, 0.05513760f, 0.01779427f, 0.02610119f, -0.09288576f, 0.03422191f, -0.08431491f, 0.01222452f, 
    -0.17376131f, -0.05651941f, 0.02343794f, 0.06799378f, -0.01296551f, 0.06329466f, -0.01660319f, -0.04156876f, 
    0.12636213f, -0.06798149f, 0.15669893f, -0.04745855f, -0.00012146f, -0.16504273f, -0.04452318f, 0.03993276f, 
    0.02419823f, -0.01491183f, -0.01218659f, -0.14723653f, 0.19232598f, 0.05986639f, -0.00886039f, -0.08495977f, 
    -0.17808634f, 0.06031560f, -0.06550727f, 0.08395697f, -0.00432575f, -0.03126239f, -0.07808869f, -0.06713340f, 
    0.38904142f, 0.10385452f, -0.16110094f, -0.10683174f, 0.00179089f, -0.02306712f, 0.03557314f, -0.12370540f, 
    -0.03461004f, -0.00235614f, 0.02101031f, 0.03268782f, 0.10998067f, -0.06161659f, -0.15262902f, -0.02171022f, 
    -0.12619291f, -0.17698877f, -0.04423194f, 0.03139571f, 0.01490510f, 0.05732324f, 0.01741885f, 0.03366534f, 
    0.22408369f, -0.18882120f, -0.02841575f, 0.08137096f, -0.03608555f, 0.08151630f, 0.08340956f, -0.16379219f, 
    0.04652232f, 0.01087472f, -0.05762342f, -0.08272199f, 0.34542373f, -0.05420802f, 0.04413403f, -0.15722412f, 
    0.02451557f, -0.00557074f, 0.18596283f, -0.04899096f, -0.05922499f, -0.03343875f, 0.00051995f, -0.01924678f, 
    -0.29904628f, 0.07498291f, -0.14254308f, 0.08511851f, 0.00544995f, -0.06520797f, -0.15630521f, 0.03000338f, 
    0.08066259f, -0.02825069f, 0.02801340f, 0.06897771f, 0.03715150f, 0.01583962f, 0.14984839f, -0.32668123f, 
    -0.19486544f, 0.02381050f, 0.02203001f, 0.09035546f, 0.01761747f, 0.07491241f, 0.04661902f, -0.06928469f, 
    0.05071332f, -0.09030814f, 0.05984212f, 0.12159365f, -0.13908717f, -0.10399312f, -0.01320662f, 0.08943386f, 
    -0.03567473f, 0.05902429f, 0.04994268f, -0.06090903f, 0.01356594f, -0.09376348f, -0.01009347f, 0.28409374f, 
    -0.08945531f, 0.00283907f, -0.03089227f, 0.00457945f, -0.01482044f, 0.04495626f, 0.00197057f, 0.07012692f, 
    0.00586460f, 0.09841462f, 0.02328352f, 0.11191328f, -0.04439055f, -0.12103803f, -0.00886890f, -0.02749011f, 
    -0.01935045f, 0.00805065f, -0.12018115f, -0.01006722f, -0.03260195f, -0.04999515f, -0.00627681f, -0.01813952f, 
    -0.00240280f, -0.06531364f, -0.02478869f, 0.04555890f, 0.05081365f, -0.03663360f, 0.00694670f, 0.02979200f, 
    0.20154573f, -0.16063105f, -0.09898427f, 0.18500957f, 0.06593558f, -0.01220778f, 0.00209429f, 0.03832973f, 
    -0.18352892f, -0.11693096f, -0.01628809f, -0.06418002f, -0.46110016f, 0.18975712f, 0.05071126f, 0.29534492f, 
    -0.02683643f, 0.01835647f, 0.05543789f, -0.05173925f, 0.00648625f, -0.06620946f, -0.01387887f, -0.02244285f, 
    0.16528815f, 0.01402524f, 0.09427656f, -0.16050997f, -0.09489176f, 0.00326673f, -0.08132870f, -0.02357818f, 
    0.04301629f, -0.02881142f, 0.02926025f, -0.04938529f, -0.02773313f, -0.03123005f, -0.01002747f, -0.37495816f, 
    0.02580878f, -0.00084381f, -0.01454068f, 0.00923150f, 0.02933916f, -0.04840494f, -0.07692535f, 0.03642513f, 
    -0.04739830f, -0.17119330f, 0.09882876f, -0.03372609f, -0.02244593f, -0.02692816f, 0.02284748f, 0.06166922f, 
    -0.00686447f, 0.02473678f, 0.08205137f, 0.00554025f, 0.01677364f, 0.16361620f, 0.12818164f, -0.26118678f, 
    0.05459630f, 0.14082441f, 0.11222783f, -0.03608320f, -0.08496986f, 0.00579592f, -0.05893744f, 0.07917114f, 
    0.13665123f, 0.08081020f, -0.04016194f, 0.00297937f, 0.03515461f, 0.02542169f, -0.00786027f, -0.06903292f, 
    0.09832108f, -0.08620468f, -0.02737253f, -0.07604253f, -0.02851384f, -0.05636442f, -0.08888432f, 0.11595806f, 
    -0.15697372f, -0.00268708f, -0.02448268f, 0.08774658f, 0.04627771f, -0.02705398f, -0.04989840f, -0.06006917f, 
    0.22254150f, -0.06489199f, -0.08788683f, 0.36221486f, -0.04802297f, -0.03555094f, 0.00096383f, 0.01412097f, 
    -0.14909792f, 0.11147232f, 0.07997900f, -0.15579416f, 0.22699398f, 0.16947727f, 0.00423678f, -0.13295373f, 
    -0.05169058f, 0.03796481f, -0.05362995f, -0.04747485f, -0.05455092f, 0.03862805f, -0.04283816f, -0.01957183f, 
    -0.15972424f, -0.12784874f, 0.08712777f, -0.08734225f, -0.04661300f, 0.06566970f, -0.01299362f, 0.10157884f, 
    -0.10048916f, -0.13280001f, 0.02410092f, 0.05065423f, 0.12685265f, -0.02747625f, -0.07158195f, 0.11351638f, 
    0.20035243f, 0.04032683f, 0.04335795f, -0.03987284f, -0.09214551f, 0.08676191f, -0.09816571f, 0.08253717f, 
    -0.13885355f, -0.13577659f, 0.21282732f, -0.16675873f, -0.01106837f, -0.06434001f, 0.12164108f, -0.11406845f, 
    0.04470028f, -0.18958436f, -0.11015001f, -0.00299833f, 0.12541223f, 0.07688975f, -0.09530258f, -0.04587798f, 
    -0.04175084f, -0.05245275f, 0.02679604f, 0.05578038f, -0.00208168f, 0.01879108f, 0.05115286f, -0.01048024f, 
    -0.06243381f, -0.07135537f, -0.09437050f, -0.23168699f, -0.04732575f, 0.01529175f, 0.12096134f, -0.08015218f, 
    -0.01870598f, 0.05322238f, -0.09859500f, 0.08284318f, 0.12604296f, 0.04546000f, -0.02187941f, 0.18213736f, 
    -0.15047255f, -0.03363626f, 0.00760901f, 0.01596942f, -0.09338870f, 0.03988569f, -0.00116948f, 0.01898643f, 
    -0.16930379f, 0.01984778f, 0.18088742f, 0.01925335f, 0.05857566f, 0.15068959f, 0.06801087f, -0.04947767f, 
    0.03308593f, -0.00736072f, 0.06859690f, -0.04592132f, 0.02299832f, 0.14244756f, -0.14421132f, 0.07732618f, 
    -0.15917507f, -0.02733778f, 0.02080878f, -0.02746037f, 0.09650654f, 0.01539169f, 0.06383248f, 0.01354118f, 
    0.03647083f, -0.01984982f, -0.08743770f, 0.11389433f, -0.15383299f, -0.01251651f, -0.11971825f, 0.05010490f, 
    0.06731024f, -0.07814622f, 0.00430212f, -0.00137381f, -0.24514969f, 0.09599112f, 0.07274383f, -0.08041997f, 
    0.01400597f, 0.10934884f, -0.00051926f, 0.02281338f, -0.05469975f, -0.22030284f, -0.05891408f, -0.03314616f, 
    -0.38338655f, 0.05885953f, -0.01031305f, -0.02708444f, -0.01776585f, 0.11600887f, 0.03329061f, 0.03842227f, 
    -0.07752552f, 0.00563727f, 0.04436345f, -0.08148844f, 0.22136769f, 0.11075065f, -0.03896007f, -0.39861137f, 
    0.16827150f, 0.02768224f, 0.06620863f, 0.06552475f, -0.04418089f, 0.01898162f, -0.06051223f, -0.00801711f, 
    -0.42353287f, 0.20646900f, 0.07875811f, -0.13488401f, 0.02528846f, -0.03569822f, -0.14205360f, 0.09670597f, 
    -0.03518653f, -0.04588472f, 0.02864439f, 0.02022721f, -0.05576606f, 0.05664562f, -0.12477045f, 0.19502884f, 
    -0.10004745f, 0.06566357f, -0.05852082f, -0.03346475f, 0.00376664f, -0.05888872f, 0.10360475f, 0.03686326f, 
    0.19356790f, -0.04654956f, 0.02753164f, -0.10937719f, -0.00747704f, -0.08446899f, -0.04342106f, -0.09500160f, 
    0.07939968f, -0.08994391f, -0.10812145f, -0.00532976f, -0.16627277f, 0.08310936f, -0.24692655f, 0.37004206f, 
    -0.03657994f, 0.02322954f, 0.15223400f, -0.10105923f, -0.02896087f, 0.07552357f, -0.10487677f, -0.00719406f, 
    0.30176297f, -0.13009980f, 0.11728107f, -0.04053944f, -0.11540857f, -0.03056600f, -0.11000934f, 0.00463172f, 
    0.01089660f, -0.01404975f, -0.04917322f, 0.11132503f, -0.15785742f, -0.26141879f, -0.09910745f, -0.23802470f, 
    0.06905591f, 0.02803242f, 0.03676630f, 0.11857269f, -0.05660912f, 0.03814317f, 0.11751498f, 0.00645052f, 
    -0.09002919f, -0.05142822f, -0.15982579f, -0.05679566f, 0.00233415f, 0.00434340f, 0.06484211f, 0.12899746f, 
    0.02470548f, 0.03740911f, 0.15118404f, 0.07522164f, 0.24239708f, 0.09778436f, 0.05873793f, 0.11843272f, 
    -0.13789719f, 0.04733829f, -0.01544742f, 0.00739605f, 0.01208421f, -0.06927235f, -0.10333154f, -0.01027306f, 
    0.08947781f, 0.05827796f, 0.08100594f, 0.04583761f, 0.01829347f, 0.03217498f, 0.08614834f, 0.06495778f, 
    0.01431483f, 0.05848076f, 0.05013742f, 0.03668443f, -0.10133577f, -0.18351878f, 0.11119935f, -0.07942197f, 
    -0.00457023f, 0.05056231f, -0.09315880f, 0.10730991f, 0.05222353f, 0.06829162f, 0.13173129f, -0.06831872f, 
    0.09220057f, -0.05411694f, 0.07414314f, -0.03672060f, -0.00450361f, -0.11676451f, 0.00952505f, 0.10440353f, 
    -0.03269738f, -0.08128234f, 0.01237864f, -0.13574432f, 0.31731379f, -0.20580798f, -0.36451238f, -0.00101757f, 
    -0.09455594f, 0.02288968f, 0.01516897f, 0.10916209f, 0.10953017f, -0.08036104f, -0.04488269f, 0.04222588f, 
    -0.20795752f, 0.00036793f, -0.17388330f, 0.07309669f, -0.19278227f, 0.00161471f, -0.08912266f, -0.10703143f, 
    -0.02676238f, -0.05902075f, -0.04085226f, 0.03320676f, 0.05398140f, 0.02256226f, -0.05213037f, 0.04850911f, 
    -0.02923239f, -0.15408958f, -0.08654024f, 0.09370769f, 0.07519247f, 0.04464116f, -0.08356608f, 0.14340605f, 
    0.25732452f, -0.03984327f, 0.10221369f, 0.02357519f, 0.00572935f, -0.03255514f, -0.09361786f, -0.04353693f, 
    0.00489619f, 0.07423291f, -0.06372839f, -0.03818586f, 0.13989708f, -0.05080954f, 0.09398527f, -0.12895256f, 
    0.09861547f, -0.03978719f, -0.01751054f, 0.01802049f, 0.05356681f, 0.05104728f, 0.09998748f, 0.02705705f, 
    -0.01886632f, 0.01368678f, 0.04463690f, 0.15272857f, -0.02461095f, 0.08647098f, -0.08146957f, 0.07825191f, 
    -0.06798503f, -0.01927839f, 0.12307502f, 0.03584156f, 0.04281859f, -0.08385276f, 0.06540103f, -0.14139119f, 
    0.04381334f, -0.11231478f, 0.10299300f, 0.10844508f, -0.01871588f, 0.07171718f, -0.00142756f, 0.10854426f, 
    -0.64517885f, -0.03570055f, -0.24217002f, -0.17306790f, -0.01682115f, -0.02677203f, 0.08038947f, 0.11922339f, 
    0.03630011f, -0.04667028f, -0.09730669f, -0.11702400f, -0.19958827f, 0.00184136f, 0.04781721f, -0.04095460f, 
    0.02043612f, 0.01261824f, 0.14484124f, -0.10995580f, -0.01236860f, -0.10664985f, -0.05578700f, 0.01588634f, 
    0.08902611f, 0.05789478f, 0.15063524f, 0.09699534f, -0.12369829f, 0.01347134f, 0.02852678f, -0.02765461f, 
    0.04377507f, 0.12466665f, -0.03929750f, -0.03899134f, -0.09584046f, 0.01355834f, -0.01632947f, -0.13325465f, 
    0.08090935f, 0.04070712f, 0.02911549f, 0.11349384f, -0.01563298f, -0.03523289f, -0.15055931f, 0.09326763f, 
    0.09188601f, -0.17616045f, -0.07347409f, -0.33495569f, -0.07078519f, -0.05041358f, 0.02248227f, 0.02427593f, 
    -0.13973385f, -0.03143290f, -0.01719151f, -0.06320675f, -0.01081551f, 0.06597646f, -0.03900876f, -0.18456063f, 
    -0.03709963f, -0.00346088f, 0.03318108f, -0.07603863f, 0.10830841f, 0.09853707f, -0.11095070f, 0.01497199f, 
    0.14580855f, 0.18357752f, 0.01603803f, -0.10857765f, -0.07920299f, -0.04993409f, 0.01884467f, 0.08629261f, 
    -0.01451871f, -0.00258615f, 0.14415476f, -0.13203487f, -0.58723491f, -0.08298448f, 0.04958131f, 0.01298166f, 
    0.00697959f, 0.03954946f, 0.03309005f, -0.03782964f, -0.13665055f, -0.04028006f, -0.05779565f, 0.00956475f, 
    0.12948053f, 0.04036638f, -0.07870505f, -0.02702496f, 0.11223933f, 0.09240308f, -0.12230478f, 0.05626611f, 
    -0.01590345f, 0.07188074f, 0.01650771f, 0.04566631f, 0.26112446f, -0.13259171f, -0.02222651f, 0.02780882f, 
    -0.06024325f, -0.03039153f, -0.20721395f, 0.05158959f, -0.00315772f, 0.14102712f, -0.09449469f, 0.02011264f, 
    0.16581237f, 0.08077331f, -0.29285458f, 0.20162280f, -0.06675232f, 0.04582120f, -0.00931948f, -0.12087138f, 
    0.05407919f, -0.03278960f, -0.08290175f, -0.01350044f, 0.09248903f, 0.09256465f, 0.26636434f, 0.11552715f, 
    -0.11022547f, 0.00681024f, 0.03245296f, -0.03193678f, 0.03642687f, 0.04527142f, -0.01860400f, 0.07263389f, 
    -0.12565409f, -0.16356733f, -0.00629716f, -0.30450791f, 0.02833819f, 0.03606525f, 0.13945301f, 0.00372617f, 
    -0.13150038f, -0.01182985f, -0.11661266f, 0.01799958f, 0.07816084f, -0.06754375f, 0.20795317f, 0.06253355f, 
    0.05408104f, -0.03359623f, 0.03867241f, -0.03698182f, -0.07373860f, 0.02423632f, 0.12125567f, -0.09085897f, 
    -0.26569021f, -0.17258796f, 0.03381654f, -0.02771388f, 0.00067206f, -0.10087892f, -0.00496841f, 0.17574818f, 
    0.07708532f, -0.05566564f, 0.01879579f, -0.05489106f, 0.09141540f, 0.10123655f, 0.04608737f, 0.18872705f, 
    -0.03427149f, -0.06707967f, 0.07106100f, -0.02369485f, -0.07114936f, -0.02423786f, 0.07462866f, -0.04515357f, 
    -0.44728532f, -0.05227175f, -0.05318043f, 0.11759941f, -0.02749234f, 0.01899935f, -0.10339891f, -0.00796869f, 
    -0.07054541f, 0.01788611f, 0.02498125f, 0.02320997f, -0.27342078f, -0.10228383f, 0.12160893f, -0.28536728f, 
    -0.11129240f, -0.04425919f, -0.01973594f, 0.12036692f, 0.02669874f, -0.00265108f, -0.05074424f, 0.04645937f, 
    0.18786848f, -0.02330436f, 0.01001150f, -0.04871750f, 0.02797384f, 0.04981121f, -0.12462996f, 0.07068907f, 
    -0.10270364f, -0.00097569f, -0.02965312f, -0.07085882f, 0.18328094f, -0.07852636f, 0.05671741f, 0.05490422f, 
    -0.10262986f, -0.11592405f, 0.05344537f, -0.01495960f, -0.16321194f, -0.02750974f, -0.10263742f, -0.00747137f, 
    0.26155818f, 0.05361032f, 0.10951826f, 0.11174974f, -0.03823316f, -0.02119458f, 0.10990502f, -0.02253441f, 
    -0.06014337f, 0.04275340f, -0.09420145f, 0.07650243f, 0.16264665f, -0.14981064f, -0.05449702f, -0.08104196f, 
    0.02436318f, 0.13888733f, -0.13562438f, -0.10806917f, -0.03634961f, -0.30181456f, 0.15678504f, -0.23654291f, 
    0.06524795f, 0.07821557f, -0.03575468f, 0.22182986f, -0.20391706f, 0.10327190f, 0.02661983f, -0.00583988f, 
    -0.01879728f, 0.06034999f, 0.03991197f, 0.11854438f, 0.31214580f, 0.01380864f, -0.20746024f, -0.08011784f, 
    -0.02232827f, 0.01344404f, -0.01873584f, -0.01832236f, -0.06706069f, -0.01443965f, -0.00473670f, -0.00032750f, 
    0.02811995f, -0.23177515f, 0.12834443f, 0.04704110f, -0.12482610f, -0.07111751f, 0.02471374f, 0.03934238f, 
    0.04432051f, 0.05324553f, 0.13236326f, -0.03569058f, 0.42005992f, -0.04697786f, -0.14449504f, 0.07368078f, 
    0.05930178f, 0.15457323f, -0.05720523f, -0.01801175f, -0.09516508f, 0.12203567f, 0.02321927f, -0.00805969f, 
    0.10255677f, -0.05406231f, 0.09685252f, 0.31574288f, -0.06900492f, -0.06294562f, 0.18101674f, 0.05827222f, 
    -0.00487492f, -0.11312933f, 0.00454406f, 0.11116941f, 0.16684762f, -0.09653364f, -0.09732305f, -0.17246692f, 
    0.03304460f, 0.02890298f, 0.02660884f, 0.06623769f, 0.00381608f, -0.06523019f, -0.01746258f, 0.00148092f, 
    0.13343900f, -0.01714833f, 0.05348686f, -0.36413121f, 0.04689414f, 0.04950450f, 0.00838456f, -0.01201112f, 
    0.04560233f, -0.15214202f, 0.06188109f, -0.07037642f, 0.28844690f, 0.04306338f, -0.03387219f, -0.11391324f, 
    0.01074267f, -0.05672980f, -0.12221824f, -0.03033861f, 0.02792104f, 0.00288643f, -0.14516565f, -0.13974905f, 
    -0.01212160f, 0.10222842f, -0.02795170f, 0.14579853f, 0.09302211f, -0.06647338f, -0.04354996f, -0.17120999f, 
    0.00702564f, 0.12695444f, 0.06903742f, 0.04471356f, 0.24564508f, -0.09876712f, 0.02410769f, 0.06776411f, 
    0.07289223f, 0.06936248f, -0.10770477f, -0.00910744f, 0.00349304f, -0.02592277f, 0.00346316f, -0.07454340f, 
    0.32915694f, -0.11853027f, 0.15489331f, 0.19572948f, -0.07779413f, 0.04241420f, -0.04771186f, -0.01171094f, 
    0.16002260f, -0.09152518f, -0.03573932f, 0.16341436f, -0.06907170f, -0.16400149f, -0.00505276f, 0.00866995f, 
    0.02309171f, 0.00540710f, 0.01384283f, -0.01548889f, 0.00204280f, -0.23375405f, -0.09765683f, 0.15724616f, 
    0.09921633f, -0.24184002f, -0.09915062f, -0.10032298f, 0.06615382f, -0.03548368f, 0.07812553f, 0.03549667f, 
    -0.03873762f, 0.11983537f, -0.08232684f, -0.07777933f, 0.13510484f, -0.13547124f, -0.07251530f, 0.06407805f, 
    -0.09798555f, 0.02891078f, 0.00682809f, 0.11194078f, 0.02966325f, -0.09241369f, -0.17719334f, -0.26697788f, 
    -0.21407807f, 0.08645581f, -0.21300237f, -0.14720052f, -0.08407840f, 0.12142367f, 0.02457996f, -0.05818031f, 
    0.01082581f, 0.00934082f, 0.08227014f, 0.03622186f, -0.02448201f, -0.09714611f, 0.02991142f, -0.17509799f, 
    0.06119005f, 0.08253428f, -0.08962100f, -0.04013085f, 0.06293810f, -0.05003341f, -0.00090139f, 0.04851930f, 
    0.14868955f, -0.22924967f, 0.00495219f, -0.02079293f, -0.03263440f, -0.00772654f, -0.18645154f, 0.01088015f, 
    -0.07123930f, -0.04266169f, -0.03126827f, 0.03623467f, -0.11386295f, 0.07093416f, 0.08950069f, -0.04602745f, 
    -0.01563480f, 0.03586871f, 0.02243512f, 0.02645276f, 0.09337951f, 0.03307471f, -0.03131186f, -0.02435650f, 
    -0.47086307f, 0.04584345f, -0.28799137f, -0.18568380f, -0.05950815f, 0.05530912f, 0.02718958f, -0.00270461f, 
    -0.04278135f, 0.05181294f, 0.07137581f, -0.06147224f, -0.08079347f, 0.01051513f, -0.05069534f, 0.03434517f, 
    0.06489532f, 0.03917417f, -0.11464783f, 0.01594737f, -0.07267428f, -0.01389244f, -0.13118182f, 0.03752533f, 
    0.17649668f, -0.21690308f, -0.03311057f, 0.09374768f, 0.04177476f, -0.03501233f, 0.03086255f, 0.15246890f, 
    -0.06822754f, 0.02814746f, -0.12670322f, 0.01057506f, -0.05629260f, 0.07847270f, -0.12940453f, -0.11227289f, 
    0.06465259f, -0.02909626f, 0.01248740f, 0.03359108f, 0.07847918f, 0.21733657f, 0.18225558f, -0.04783710f, 
    0.02794313f, -0.09682498f, -0.15151867f, -0.02591945f, 0.00744567f, 0.09827638f, -0.03548087f, 0.09414656f, 
    0.03595977f, -0.03942289f, -0.07677144f, 0.03602689f, -0.07132973f, -0.14768329f, 0.01801136f, -0.17006040f, 
    0.04423236f, -0.09654678f, -0.05770581f, -0.07232590f, 0.03845424f, -0.03252758f, 0.03866078f, -0.03906753f, 
    0.34509751f, 0.08433722f, -0.05782975f, -0.28478223f, 0.04415552f, -0.14112739f, 0.10279403f, 0.02540366f, 
    -0.08793836f, -0.02181156f, -0.00295726f, -0.01329702f, -0.16950426f, 0.02222755f, -0.10736539f, 0.28057411f, 
    -0.01769533f, -0.04828403f, -0.01550861f, -0.05488404f, -0.03943697f, -0.01195669f, -0.03818279f, 0.08679507f, 
    -0.10207862f, 0.01298583f, 0.06130860f, -0.01037745f, 0.00196810f, -0.07865038f, 0.04373043f, 0.07432279f, 
    0.03192367f, -0.00974455f, 0.03621993f, 0.01147126f, -0.16090044f, 0.05161000f, -0.22824404f, 0.05534845f, 
    -0.00283385f, -0.11353658f, -0.11214089f, -0.07257006f, 0.08688073f, -0.13446517f, 0.05380375f, -0.04657203f, 
    -0.25940758f, 0.08535878f, 0.13608153f, -0.05164957f, 0.13625735f, 0.06507284f, -0.06289943f, -0.03060981f, 
    -0.01200573f, -0.10669248f, 0.08209272f, -0.07026498f, -0.39298877f, -0.01685366f, -0.10177592f, -0.27154183f, 
    -0.01042929f, 0.00322417f, -0.03859381f, -0.10897562f, -0.00542981f, -0.08498904f, -0.03457514f, -0.02063756f, 
    -0.05753149f, -0.01071521f, 0.00418135f, -0.05467179f, 0.00773087f, -0.01818826f, 0.01606871f, -0.01738202f, 
    -0.04245221f, 0.00911048f, 0.00234714f, -0.12882371f, -0.20005864f, 0.08305414f, -0.14676456f, 0.04692858f, 
    0.08299051f, 0.00756475f, -0.00717545f, -0.02623471f, 0.00206514f, -0.08525897f, -0.05801469f, -0.04541110f, 
    -0.16724978f, -0.09917670f, 0.06739014f, -0.06509062f, -0.05105663f, -0.07159899f, -0.02047038f, 0.00432298f, 
    -0.12154209f, -0.03044114f, 0.01387414f, -0.02716628f, 0.05329506f, -0.12483083f, 0.01127024f, 0.05113150f, 
    -0.02662863f, -0.02547199f, 0.12675570f, -0.01141014f, -0.00786504f, -0.07970759f, -0.08805001f, -0.04937871f, 
    0.09928718f, -0.00236610f, 0.04541640f, -0.21021780f, -0.03181872f, -0.02285890f, -0.10904554f, 0.00311648f, 
    0.00316788f, 0.01350967f, 0.04934891f, -0.23784180f, 0.25189009f, -0.22740398f, 0.23660302f, 0.11291090f, 
    -0.06877631f, -0.02383764f, 0.05374361f, -0.01327714f, 0.02245245f, -0.01882970f, 0.04111799f, -0.02608889f, 
    0.21738803f, 0.04711494f, -0.09561587f, 0.03426200f, -0.04328917f, -0.14126018f, -0.11573320f, 0.00656914f, 
    0.01006619f, -0.02813048f, 0.07807626f, -0.09236452f, -0.07447087f, 0.10240940f, -0.06561836f, -0.03130592f, 
    0.07669196f, -0.06046018f, 0.09809191f, -0.02128091f, -0.08025444f, -0.05280388f, -0.02430420f, 0.03409803f, 
    -0.09586218f, 0.17428760f, 0.03524430f, -0.00285710f, 0.06144893f, -0.03827583f, 0.00967675f, 0.07175916f, 
    0.00266404f, -0.06903662f, 0.00376722f, 0.00535580f, -0.23092929f, 0.00293500f, -0.08992244f, -0.07310303f, 
    -0.03652331f, -0.01284284f, 0.08079039f, -0.02557169f, -0.03510955f, 0.00624802f, -0.06896868f, 0.02461685f, 
    0.40280223f, -0.15690218f, -0.10191870f, -0.07444517f, -0.03260987f, -0.02148983f, 0.03818956f, -0.10252434f, 
    -0.03128030f, 0.04633884f, 0.05231161f, -0.14777774f, -0.23334193f, -0.00634833f, 0.03648844f, 0.14916021f, 
    0.00836184f, -0.03818347f, -0.08138452f, 0.08167777f, -0.12954783f, -0.01824279f, 0.05516766f, -0.00424061f, 
    0.28373775f, -0.01305009f, -0.21955462f, -0.10710386f, -0.05528024f, 0.00461277f, 0.04251589f, -0.04039356f, 
    -0.04422125f, 0.03405043f, 0.03123975f, 0.04340668f, -0.08824045f, 0.07090145f, 0.06848536f, -0.22791666f, 
    0.01636342f, -0.03079753f, -0.07819109f, 0.12140560f, -0.12439945f, -0.00295753f, 0.02130921f, -0.04690873f, 
    -0.13826774f, 0.01726779f, -0.06072005f, -0.05950039f, 0.02886662f, 0.05280098f, -0.03131182f, 0.10139613f, 
    -0.02535447f, 0.07035521f, -0.00356516f, -0.00327157f, 0.03634699f, -0.05593219f, -0.33662593f, -0.06844094f, 
    0.03271990f, 0.02088025f, -0.02114074f, -0.03917924f, -0.05867580f, 0.03444213f, -0.06874441f, -0.03053015f, 
    -0.09805118f, -0.23791100f, -0.02487575f, -0.28960472f, 0.01703496f, 0.00761080f, 0.07293274f, -0.03968342f, 
    -0.02374537f, 0.03558090f, -0.04720826f, -0.02710212f, 0.14531377f, 0.09681245f, 0.04775118f, 0.08857484f, 
    -0.05355873f, 0.02089518f, 0.00208814f, -0.00249582f, -0.01101915f, -0.01134963f, -0.09815393f, 0.01346511f, 
    -0.31189716f, 0.07186070f, 0.06114130f, 0.00988457f, 0.07868642f, 0.02363786f, -0.04364290f, 0.00213818f, 
    -0.07063571f, -0.11104667f, 0.07829202f, -0.12612706f, 0.38940170f, 0.11245321f, 0.04569705f, -0.14012027f, 
    0.06716633f, -0.05160550f, -0.07572541f, 0.11035358f, 0.02776533f, 0.03971322f, -0.05693172f, -0.13808954f, 
    0.10325388f, 0.09028228f, 0.05692970f, 0.19106413f, -0.08073000f, -0.04522830f, -0.03614972f, 0.10818086f, 
    -0.09747757f, -0.00520778f, 0.00609336f, -0.05972865f, 0.18040943f, -0.10458570f, -0.00536360f, -0.04811236f, 
    0.01981070f, 0.00488961f, -0.01826036f, 0.01659892f, -0.04723001f, 0.03863641f, 0.03924837f, -0.01306491f, 
    0.22003430f, -0.16381782f, 0.17174685f, 0.04859492f, -0.02580115f, -0.08153979f, -0.10253939f, 0.02683727f, 
    0.08695897f, 0.00814299f, 0.00689971f, -0.04512474f, 0.13166727f, 0.00169479f, -0.03933305f, 0.03169818f, 
    0.04484094f, 0.02028227f, 0.00212752f, -0.04153229f, -0.01619340f, 0.05426691f, -0.09187421f, 0.04658498f, 
    -0.29696712f, -0.11845008f, -0.04206425f, -0.26679060f, 0.06749447f, 0.00547444f, 0.01514096f, -0.08853106f, 
    -0.09203809f, 0.19456939f, 0.06215338f, 0.00681275f, 0.05337150f, 0.12807418f, -0.03472851f, 0.06735695f, 
    0.01820998f, 0.08300552f, -0.03499594f, -0.19092707f, -0.03493632f, 0.01492044f, -0.07119479f, -0.11187717f, 
    0.05142168f, 0.03242962f, -0.10278400f, 0.12793915f, 0.01191366f, 0.04190297f, -0.02954382f, -0.02486506f, 
    -0.10057260f, 0.05680031f, 0.10015089f, -0.00290372f, -0.03731020f, 0.10581764f, -0.03396741f, 0.03331131f, 
    -0.00246077f, 0.08151855f, 0.08709683f, -0.05054779f, -0.01283201f, -0.01022261f, 0.00139589f, -0.01287444f, 
    0.06569448f, -0.06632689f, -0.05606861f, -0.06913892f, 0.09119369f, 0.10514349f, -0.05076814f, 0.08678583f, 
    0.06036058f, 0.01799428f, 0.07789368f, -0.11493865f, 0.17782231f, 0.04553921f, 0.09773304f, -0.04744057f, 
    0.05840724f, -0.09031074f, 0.04093570f, 0.00792588f, -0.01212153f, -0.02222457f, 0.04737251f, 0.00383753f, 
    0.38658753f, -0.08504450f, -0.13476743f, 0.03880380f, -0.00069704f, -0.01829160f, 0.02730756f, -0.06183174f, 
    0.02786463f, -0.02412706f, 0.07958193f, -0.04037555f, 0.24439649f, -0.12768514f, -0.04650711f, -0.17074196f, 
    0.10460446f, -0.07968391f, 0.15527077f, -0.06489579f, -0.08056603f, -0.02153635f, 0.12271111f, -0.00406995f, 
    0.14145422f, -0.05276593f, 0.02225438f, -0.04595205f, 0.01594062f, -0.01568611f, 0.11938104f, 0.02604794f, 
    -0.00440737f, 0.01967810f, 0.03295525f, -0.00048404f, 0.01246831f, -0.12567623f, -0.09832592f, -0.01932293f, 
    0.04560117f, -0.04745083f, 0.00958637f, 0.06369603f, -0.07739665f, 0.13198486f, -0.07993441f, -0.07717536f, 
    -0.05836999f, 0.02051349f, -0.05258482f, -0.09240296f, -0.01417704f, -0.00915924f, -0.07048307f, -0.03777803f, 
    0.08526491f, 0.02672747f, -0.00860600f, 0.02532660f, 0.23772290f, -0.04903693f, 0.03296780f, 0.13945194f, 
    -0.14897752f, -0.06845187f, 0.00397195f, -0.03666681f, 0.01620829f, -0.09145606f, -0.11533535f, 0.01940929f, 
    -0.00532487f, -0.24796101f, -0.11377467f, 0.13964882f, 0.01530046f, -0.07504404f, -0.04798959f, -0.04263876f, 
    -0.05046472f, 0.01219302f, -0.01340878f, 0.05313994f, 0.28017199f, -0.32759216f, 0.12196131f, 0.00682671f, 
    -0.07003816f, -0.00686028f, 0.01939300f, -0.03623706f, 0.07909762f, 0.07179765f, -0.04576739f, 0.06437920f, 
    -0.00757371f, 0.12985745f, -0.11333860f, -0.02562745f, 0.08939981f, 0.03941817f, 0.06732622f, -0.13095954f, 
    -0.01478652f, 0.11788314f, -0.02585799f, -0.07565022f, 0.20386688f, 0.10646785f, 0.05528984f, 0.15035465f, 
    -0.17240286f, -0.09702921f, -0.04745223f, 0.03258194f, -0.02305144f, -0.08548696f, 0.00051853f, 0.03101174f, 
    -0.20320170f, -0.19456568f, -0.09390090f, 0.01521576f, -0.05153428f, -0.11195612f, -0.00677704f, -0.09560394f, 
    -0.00115557f, 0.00229333f, -0.10013583f, -0.00847683f, 0.21902171f, -0.02511591f, 0.11523549f, 0.18574834f, 
    -0.13836026f, 0.06890999f, -0.02623867f, 0.15481779f, -0.01755925f, -0.01699037f, 0.00944855f, -0.01628329f, 
    0.08925683f, 0.11912113f, -0.06982937f, -0.15074560f, -0.09752460f, 0.01715042f, 0.00609609f, 0.08815596f, 
    -0.09855365f, -0.06426846f, -0.06898447f, -0.10976123f, 0.12340850f, -0.13370129f, -0.04531039f, -0.06817919f, 
    0.01052178f, -0.00466119f, 0.07563983f, -0.01767112f, -0.09338810f, 0.01234470f, 0.00987795f, -0.04173829f, 
    -0.22551607f, -0.07716458f, 0.05386113f, -0.12677948f, 0.01599214f, 0.02074183f, -0.04332089f, 0.04719598f, 
    0.00216181f, 0.04444421f, 0.02871460f, -0.08959244f, 0.11841856f, 0.08214857f, 0.07840847f, 0.10801117f, 
    -0.05565659f, -0.16351588f, -0.00745048f, 0.12589909f, 0.00552970f, -0.03576307f, 0.03269952f, -0.08314610f, 
    -0.35926399f, -0.10340761f, 0.01862016f, -0.21252289f, 0.03115741f, -0.03762576f, 0.04616858f, -0.02567166f, 
    -0.05571890f, 0.05464493f, 0.04759302f, -0.10806362f, -0.35955343f, 0.24081203f, -0.01317219f, -0.08730357f, 
    -0.04141414f, -0.00731454f, 0.06688071f, -0.00696718f, 0.09610613f, 0.08584595f, -0.01172167f, 0.07391798f, 
    0.29011121f, -0.10624550f, -0.11606019f, -0.01170952f, 0.06899005f, -0.10867746f, 0.05053388f, -0.06655233f, 
    -0.07608802f, 0.00848738f, -0.10620282f, 0.07698806f, 0.28572610f, -0.00547041f, -0.25543419f, 0.03397042f, 
    -0.08331595f, 0.05252181f, -0.00706997f, 0.02642218f, 0.03824152f, 0.11539360f, -0.04060766f, 0.04278832f, 
    0.03456990f, 0.13955043f, 0.16146530f, 0.11893967f, -0.00919838f, -0.07632967f, 0.08553878f, 0.04253536f, 
    0.03461784f, -0.16837783f, 0.04827029f, 0.01673890f, 0.15059599f, 0.08329161f, -0.06301501f, -0.07975633f, 
    0.08857910f, 0.13970546f, -0.03786068f, -0.07452920f, -0.03454104f, 0.05203194f, -0.05611312f, -0.11703544f, 
    0.31205037f, 0.04805436f, -0.18459849f, -0.22542056f, 0.00945933f, 0.02844500f, -0.01589618f, 0.02349063f, 
    0.01084648f, -0.08152853f, 0.03309031f, -0.08668235f, 0.05771737f, 0.11429930f, -0.19727013f, -0.03201102f, 
    0.08086352f, 0.04069422f, -0.00873246f, 0.00544815f, -0.07634731f, 0.06062385f, -0.10438038f, 0.08561936f, 
    0.16253266f, -0.11890788f, -0.09553993f, -0.03329590f, -0.00378219f, -0.11045276f, -0.02911223f, 0.01586639f, 
    -0.06690827f, 0.08591159f, 0.02664477f, -0.04996888f, 0.00933446f, 0.04026505f, -0.10621933f, -0.08385636f, 
    0.09256703f, -0.00811920f, 0.05596546f, -0.00284619f, -0.06376003f, -0.06084533f, -0.02784384f, -0.09850629f, 
    -0.10957352f, -0.03678440f, -0.08364857f, -0.06898741f, -0.01326999f, -0.04640948f, -0.02576404f, 0.03264200f, 
    0.09202998f, -0.10350432f, 0.07106569f, -0.02814516f, 0.10456022f, 0.09941931f, 0.06005655f, 0.29022968f, 
    0.01575719f, -0.06767128f, 0.06855681f, 0.08693332f, -0.07576524f, -0.00236500f, -0.02442574f, -0.00681983f, 
    -0.43837619f, 0.19200601f, -0.17658594f, -0.22380921f, -0.11801668f, 0.01874163f, 0.04413277f, -0.05163809f, 
    -0.13717428f, -0.03137900f, -0.00824126f, -0.03298664f, 0.08262486f, 0.07173909f, -0.09003299f, -0.09762574f, 
    -0.09727580f, 0.06701781f, -0.02933320f, -0.01483660f, 0.13045232f, -0.00837090f, 0.07037273f, -0.07812776f, 
    0.09356618f, 0.08974829f, 0.07441280f, -0.01574362f, -0.03761276f, -0.05576988f, 0.04472788f, 0.07383576f, 
    -0.10545549f, 0.06747770f, -0.05039309f, -0.13893144f, -0.11947072f, -0.06145824f, -0.07077902f, 0.02175511f, 
    -0.13355052f, 0.05333674f, 0.05195278f, -0.05822462f, 0.00523372f, 0.04755159f, -0.03335983f, 0.00964346f, 
    -0.47750607f, 0.01223188f, -0.30923241f, 0.15215205f, -0.11572702f, 0.14489070f, -0.06982563f, -0.08154642f, 
    -0.04298324f, -0.06961623f, -0.02175969f, -0.04290592f, 0.10974605f, 0.03125939f, -0.09951547f, 0.12054949f, 
    -0.04556044f, 0.08343149f, -0.01828881f, -0.02102641f, 0.06221529f, -0.01453863f, -0.09883898f, 0.00480673f, 
    -0.02958197f, -0.02309879f, -0.15611123f, 0.14001012f, 0.03499394f, 0.06777659f, 0.02831413f, 0.04851305f, 
    0.03295076f, -0.03752586f, -0.06727920f, -0.11823191f, -0.05495294f, -0.58031017f, -0.19403312f, 0.20682198f, 
    -0.13265949f, -0.06592477f, 0.06755748f, -0.02098894f, -0.00540509f, -0.08065760f, 0.04045166f, 0.11621987f, 
    0.12667336f, -0.06591352f, -0.14945325f, -0.05757985f, -0.10157823f, -0.09578446f, -0.06739714f, -0.00452572f, 
    -0.06323359f, -0.01706129f, -0.07951869f, -0.03406292f, -0.09676106f, 0.00341089f, 0.11281279f, 0.27778861f, 
    0.06813739f, 0.03626110f, 0.01236076f, -0.07125558f, -0.04571660f, -0.00318075f, -0.08989474f, -0.05682084f, 
    0.04811294f, 0.13520415f, 0.07781358f, 0.02717219f, 0.02176209f, -0.09473916f, 0.00057805f, -0.00229191f, 
    0.03265993f, -0.03725752f, 0.00826238f, 0.06598066f, 0.11423480f, 0.01925555f, -0.03817186f, 0.01686103f, 
    -0.19004911f, 0.02474365f, -0.03880124f, 0.03446196f, -0.04085197f, -0.05239394f, -0.12944330f, 0.02817080f, 
    0.06263255f, 0.07892043f, 0.05877072f, 0.00021916f, -0.06539872f, -0.01248056f, 0.04036001f, -0.02688989f, 
    -0.06841438f, -0.14316805f, 0.02965913f, 0.00117778f, -0.43032309f, -0.10840855f, 0.06709189f, -0.09560055f, 
    -0.10629506f, 0.06669088f, -0.02534462f, 0.08560720f, -0.06820150f, -0.08445010f, 0.04186441f, -0.06252208f, 
    -0.37734589f, -0.17538333f, -0.10664083f, -0.23704013f, -0.12059375f, -0.08493598f, -0.01073207f, -0.02852422f, 
    -0.00597570f, -0.03664641f, 0.12841983f, -0.03319488f, 0.06078069f, -0.01930993f, -0.12328596f, 0.03069890f, 
    -0.15688270f, 0.09147584f, -0.05547434f, 0.08063081f, 0.03776315f, 0.01825779f, -0.00523221f, 0.02024636f, 
    0.11870652f, 0.07583179f, 0.16157761f, 0.03705424f, -0.03414439f, -0.08957168f, 0.02881198f, -0.05581234f, 
    -0.00787790f, 0.00531026f, -0.09238279f, -0.03882268f, 0.10832658f, -0.06911623f, -0.15606602f, -0.05417510f, 
    -0.12207133f, -0.00056758f, -0.03121904f, -0.05921058f, -0.01457072f, -0.04549230f, 0.08334082f, -0.05166182f, 
    -0.10844398f, 0.15336394f, 0.19408856f, -0.17019846f, 0.02900025f, 0.04770792f, -0.00238047f, 0.04819310f, 
    0.10369412f, 0.05896447f, -0.00973960f, -0.02142703f, 0.27336219f, 0.26046103f, -0.04939846f, 0.09460793f, 
    0.00842318f, 0.10724287f, -0.05787933f, 0.06541718f, 0.02718887f, -0.06865860f, 0.02932885f, -0.03958340f, 
    -0.30825379f, -0.23856959f, -0.12663499f, -0.00780899f, -0.06762736f, 0.02921032f, -0.04415764f, 0.06871631f, 
    0.02283871f, -0.02903622f, 0.05028774f, -0.04715626f, 0.20960309f, 0.17433761f, 0.06642276f, -0.01615062f, 
    0.04972722f, 0.05878852f, 0.08111420f, -0.01040152f, -0.05846456f, 0.03328957f, 0.09112655f, -0.07979926f, 
    0.26237741f, 0.08637475f, -0.02443834f, 0.02950434f, -0.06806462f, 0.03077555f, -0.02102414f, -0.00282808f, 
    -0.03116930f, 0.06267663f, 0.03195693f, -0.07246938f, 0.43440452f, 0.13997146f, -0.05467730f, 0.03583224f, 
    -0.04271502f, 0.00076192f, -0.00068431f, 0.02196115f, -0.01200816f, -0.02394032f, -0.01724076f, -0.00691804f, 
    -0.26425248f, -0.17007148f, -0.27390769f, -0.14895537f, -0.09406798f, 0.06549032f, 0.01949076f, 0.04042615f, 
    0.02186076f, 0.09177204f, -0.02430261f, -0.07366057f, -0.02371676f, 0.15803546f, -0.04233306f, -0.15847529f, 
    0.05826254f, -0.00622177f, 0.01822044f, 0.03142883f, 0.02938191f, -0.11698240f, 0.02511317f, 0.03175033f, 
    0.04568120f, -0.00769544f, -0.12337214f, -0.22376794f, -0.01218637f, -0.01280499f, -0.10002118f, -0.07308639f, 
    -0.04907982f, -0.06371838f, 0.04646146f, -0.05840847f, 0.11118636f, -0.35955057f, -0.35378814f, -0.07627521f, 
    -0.02851717f, -0.02840732f, 0.18185340f, -0.07630561f, 0.01901704f, -0.04870608f, 0.01391105f, -0.00066956f, 
    0.01871694f, -0.13392703f, 0.08723574f, -0.03867362f, 0.05675181f, -0.03495931f, 0.10648955f, 0.10099111f, 
    -0.06040132f, 0.06699434f, -0.05135559f, -0.03565180f, 0.06988708f, -0.38437161f, -0.05515942f, 0.27653301f, 
    -0.02666859f, -0.09382291f, 0.05537610f, 0.07681959f, 0.03760828f, 0.00245613f, -0.06263094f, -0.01062042f, 
    0.14071228f, 0.02016227f, 0.12259829f, 0.02589049f, -0.01764739f, 0.08332193f, -0.03032499f, 0.06937079f, 
    -0.03293194f, -0.01527229f, -0.03833840f, -0.00146113f, -0.15571171f, -0.39370349f, 0.05953183f, 0.21384349f, 
    -0.01024031f, 0.05773720f, -0.11124095f, 0.10182467f, 0.03281932f, -0.04539188f, -0.07366796f, -0.06754310f, 
    -0.13217962f, -0.07552047f, 0.02550786f, -0.09387427f, 0.04988013f, 0.14124487f, 0.06385211f, -0.00348669f, 
    -0.02252619f, 0.03360432f, -0.00948435f, -0.04686790f, -0.24547590f, -0.33810943f, -0.25914407f, 0.07478300f, 
    -0.03860842f, -0.07378840f, 0.03172647f, -0.04553009f, -0.00311170f, -0.03246301f, -0.09218992f, -0.02941101f, 
    0.18143487f, 0.11309323f, 0.13763331f, 0.19912851f, -0.01666566f, 0.09990414f, -0.00722928f, -0.15696447f, 
    -0.07014351f, 0.07014185f, 0.03825794f, -0.04396351f, 0.08247232f, 0.21641514f, 0.12780681f, -0.07423134f, 
    -0.06975713f, 0.02541068f, -0.03757734f, 0.00949001f, -0.00514477f, -0.06945039f, -0.06073055f, 0.06446633f, 
    -0.13832253f, -0.00874876f, 0.15295418f, 0.01927171f, 0.03535495f, -0.04059718f, 0.18672755f, -0.11870627f, 
    -0.11454187f, 0.03317281f, -0.18167108f, -0.02685516f, 0.25685284f, -0.14049740f, -0.11717955f, -0.11794515f, 
    -0.16302490f, -0.03963908f, 0.04367277f, -0.02187050f, -0.11954045f, -0.05580123f, -0.03071994f, -0.05113934f, 
    -0.25914383f, -0.20111328f, -0.18738239f, -0.03723764f, -0.03716805f, 0.06092240f, -0.08795086f, 0.01715012f, 
    0.00183549f, 0.02493905f, -0.01522771f, 0.10156532f, 0.15833910f, 0.02448720f, 0.11334955f, 0.09917072f, 
    0.00210988f, -0.10641207f, 0.04208971f, -0.07008263f, 0.01012026f, 0.02167785f, -0.03157675f, 0.03515071f, 
    -0.37301809f, -0.17760219f, -0.02472047f, -0.02532641f, -0.09984308f, -0.10711741f, -0.00174554f, 0.00959222f, 
    -0.02283332f, -0.08890673f, 0.11452338f, -0.04981132f, 0.22974940f, 0.07696978f, -0.10711209f, 0.05342675f, 
    -0.10311530f, 0.00568755f, -0.04151984f, -0.07477839f, -0.04442524f, 0.02178346f, 0.06205181f, 0.02017916f, 
    0.18011869f, 0.09832002f, -0.04745053f, 0.11880674f, 0.01446898f, 0.07178655f, -0.01134649f, 0.08471187f, 
    -0.09246850f, -0.06771778f, -0.02839527f, -0.00915174f, -0.10832989f, 0.15430626f, -0.15391779f, 0.04486559f, 
    0.01696389f, -0.04513504f, 0.10887410f, 0.00245855f, -0.01077552f, -0.02802808f, 0.15063056f, -0.01622821f, 
    0.13972224f, -0.24117282f, -0.13257813f, -0.02796259f, 0.02104327f, -0.02116893f, -0.06350224f, -0.07069933f, 
    0.05593481f, 0.01151903f, -0.08712236f, -0.03044220f, 0.04736327f, -0.05644202f, -0.07029933f, -0.00413979f, 
    -0.07395686f, -0.05663142f, 0.04779911f, -0.11364341f, -0.09877147f, 0.07238024f, 0.00126427f, 0.08558168f, 
    0.06790470f, 0.09636532f, 0.04040624f, 0.03207127f, -0.01659322f, -0.02515985f, 0.00752933f, -0.08132774f, 
    0.03379150f, 0.01292482f, 0.00755502f, 0.09486492f, -0.02501797f, 0.06119706f, -0.08383159f, 0.03534343f, 
    -0.04509550f, -0.05371873f, 0.02387047f, 0.01649381f, -0.04023780f, -0.04399277f, 0.10646371f, 0.00685769f, 
    0.09621426f, 0.19458659f, -0.09240204f, 0.01254651f, -0.03131053f, -0.02649771f, 0.02742434f, 0.12742047f, 
    -0.05791198f, -0.14672762f, -0.00052847f, 0.10945583f, 0.10259108f, -0.10588019f, -0.20071837f, 0.03817303f, 
    -0.03426344f, -0.00126357f, 0.09933340f, 0.01538627f, 0.01890852f, 0.00376479f, 0.05575893f, 0.03169011f, 
    -0.22955275f, -0.25706124f, -0.09129733f, 0.04992711f, -0.02996375f, 0.01227978f, -0.06425671f, -0.02814731f, 
    0.08320860f, -0.01361639f, 0.01200075f, 0.07923259f, 0.05678017f, -0.00944333f, -0.03833691f, -0.04902536f, 
    0.03699105f, -0.00594875f, -0.00415414f, -0.01958023f, -0.00069154f, 0.00031062f, -0.01149878f, -0.01487758f, 
    0.24326257f, -0.05295923f, 0.05324841f, -0.04471528f, -0.01915040f, 0.06951623f, -0.00020212f, 0.00698269f, 
    0.00645865f, 0.04936555f, -0.06964663f, -0.04095541f, -0.05117816f, 0.01317684f, 0.03104042f, -0.03489169f, 
    -0.07314238f, -0.09231540f, 0.07551529f, -0.12186873f, 0.04585053f, 0.00727875f, 0.07328577f, 0.05988819f, 
    0.42796877f, 0.17251396f, 0.16647249f, 0.03373286f, 0.07292340f, 0.02652071f, 0.03813349f, 0.09806458f, 
    0.05216640f, 0.04039926f, -0.16196328f, -0.08242314f, -0.15035819f, 0.11348687f, 0.06768543f, -0.05727155f, 
    -0.06401817f, -0.05895781f, -0.02445318f, 0.03415571f, -0.12046205f, -0.01176934f, -0.01034104f, -0.04741402f, 
    -0.17642611f, -0.10227847f, 0.06646217f, -0.04459050f, 0.01710553f, 0.05135194f, 0.01972198f, -0.03756248f, 
    -0.03963464f, -0.07153547f, -0.06784790f, 0.02772197f, -0.49105978f, 0.02217331f, 0.01876286f, 0.22468673f, 
    0.05433069f, 0.01368259f, -0.03957114f, -0.06704433f, -0.06267159f, 0.00907342f, 0.05612315f, -0.03102959f, 
    -0.15275887f, 0.31585228f, 0.24207221f, -0.12137735f, -0.03989781f, 0.00019025f, -0.05559067f, 0.09540767f, 
    0.04759265f, 0.02124564f, -0.05767908f, 0.03318583f, -0.41193044f, 0.27878192f, 0.19199409f, 0.06897004f, 
    -0.02178102f, 0.12492514f, 0.08328402f, -0.00380717f, -0.05608407f, -0.00993266f, 0.04169297f, -0.00545958f, 
    0.27782774f, -0.07064787f, -0.24958047f, 0.01362102f, 0.05305033f, -0.02707154f, 0.08636107f, 0.05973881f, 
    0.07513309f, -0.02282606f, 0.05807512f, -0.10474660f, 0.11385308f, 0.19035611f, 0.07333343f, 0.06423154f, 
    0.12942304f, -0.01204612f, -0.03028067f, 0.00901343f, -0.00402341f, -0.13375436f, -0.09405419f, -0.10081152f, 
    0.09036345f, 0.14559378f, 0.12735386f, -0.03110708f, -0.08381712f, -0.08540903f, 0.03277550f, -0.05021003f, 
    -0.01868944f, -0.00017411f, -0.01157922f, -0.06337555f, -0.28538710f, -0.03001672f, -0.07925200f, -0.15921703f, 
    -0.04172338f, 0.04184918f, 0.02553852f, 0.02336972f, -0.03584678f, 0.03095948f, -0.02424841f, 0.08668951f, 
    0.01273379f, 0.07477134f, -0.23356605f, 0.01264584f, -0.07296953f, 0.06299642f, -0.03686610f, 0.05177392f, 
    0.02330503f, 0.16647980f, -0.12067625f, 0.13302588f, -0.06187159f, 0.07224201f, 0.23036788f, 0.02551317f, 
    -0.07065764f, -0.01723988f, 0.04102679f, -0.07913113f, 0.01796843f, -0.03058583f, 0.06789742f, -0.02824142f, 
    -0.11979419f, 0.08303593f, -0.20959394f, -0.15494673f, -0.11855560f, -0.00934200f, -0.04517568f, -0.01172750f, 
    -0.03530920f, -0.04143265f, -0.01573870f, 0.12293805f, 0.03246905f, -0.07081805f, -0.02885397f, 0.11241098f, 
    0.05697670f, -0.03599166f, 0.09997363f, 0.05275448f, -0.11323143f, -0.00694249f, -0.09453768f, 0.04472500f, 
    -0.14785559f, -0.11552625f, -0.20351902f, 0.01178556f, 0.08942143f, -0.01095401f, 0.13481842f, -0.04953792f, 
    0.09951314f, -0.05360593f, -0.03341712f, -0.06395134f, 0.14014763f, -0.07112830f, -0.13020577f, 0.02744806f, 
    0.07723404f, 0.03616669f, 0.13440469f, -0.00873103f, -0.00277053f, 0.07143003f, -0.04109376f, 0.06211635f, 
    -0.06210522f, -0.13564187f, 0.10215698f, 0.02296109f, -0.18405342f, 0.08875522f, 0.04456428f, 0.09362816f, 
    0.11447664f, 0.08366867f, -0.04343383f, -0.09077691f, 0.10677862f, 0.13661318f, 0.10866801f, -0.09347314f, 
    -0.07627203f, 0.06098010f, -0.00069657f, 0.02703262f, 0.07769226f, 0.07151533f, 0.04188835f, -0.04299800f, 
    -0.05531442f, 0.10212386f, 0.13488226f, 0.17670013f, 0.12475495f, 0.00221465f, 0.04993387f, 0.14029604f, 
    0.02696202f, 0.00040227f, -0.07874597f, 0.01163666f, -0.17360826f, 0.01195338f, 0.13889807f, -0.05950004f, 
    0.14202881f, -0.05773408f, -0.09557338f, 0.04090610f, 0.14930971f, -0.07558098f, -0.12924209f, -0.00642967f, 
    -0.21336974f, 0.02041399f, -0.01505816f, -0.12496102f, 0.09474245f, 0.02835441f, 0.02798260f, 0.02054044f, 
    -0.06931064f, 0.01827514f, 0.01545117f, 0.07494107f, -0.44766772f, 0.16857864f, 0.11242262f, 0.12239695f, 
    0.08218196f, 0.14060012f, -0.04173634f, 0.08550326f, -0.15911062f, 0.04369610f, 0.08510524f, -0.13472904f, 
    -0.48696861f, -0.12542740f, 0.00401201f, -0.11527313f, 0.05923834f, -0.04151823f, -0.02427957f, 0.08628818f, 
    -0.08987062f, -0.11139233f, -0.00394477f, 0.05319054f, -0.08392642f, -0.21338759f, 0.16572610f, -0.06925850f, 
    -0.03688459f, -0.06882238f, 0.10794192f, 0.01634439f, 0.01188335f, -0.03000558f, -0.04857641f, -0.04113775f, 
    -0.21635878f, -0.09428401f, -0.01781158f, 0.07946832f, -0.14594121f, 0.04579692f, 0.04005513f, -0.05476989f, 
    0.08698609f, -0.01835641f, 0.03239480f, 0.05599146f, 0.10654493f, 0.00618275f, -0.14759180f, 0.10050263f, 
    -0.09450757f, -0.05208079f, 0.03394991f, -0.05074041f, -0.13720384f, -0.03601602f, 0.03393372f, -0.04357204f, 
    -0.16721156f, -0.03844983f, -0.03975216f, 0.03948644f, 0.10889801f, -0.03611755f, 0.11195061f, 0.15455164f, 
    0.09348875f, 0.07878543f, 0.04583494f, 0.00559249f, -0.02842650f, 0.01011839f, -0.09581558f, 0.29128149f, 
    0.06165184f, 0.07954684f, -0.04207198f, 0.03677402f, 0.08438225f, 0.05921477f, -0.06236186f, -0.02146866f, 
    0.56897765f, 0.17293620f, -0.09498370f, -0.22964713f, -0.05105441f, 0.03736936f, 0.04771978f, 0.03820181f, 
    0.00696709f, -0.05971800f, -0.01160149f, 0.05646799f, -0.03006799f, -0.17823966f, 0.15719141f, 0.11403684f, 
    0.07607213f, 0.03270804f, 0.04076108f, -0.05709123f, -0.03092068f, -0.03236170f, 0.06918035f, 0.06885073f, 
    -0.17017739f, 0.28368106f, 0.05972511f, -0.07004795f, 0.03976372f, 0.04788071f, -0.02649132f, 0.07428099f, 
    0.02923574f, -0.03084571f, 0.00227446f, 0.08817202f, -0.03904034f, 0.06604099f, 0.03967253f, 0.17896506f, 
    -0.02589697f, -0.06338239f, 0.04686027f, -0.13686186f, 0.15393017f, -0.06460434f, 0.01962440f, -0.08026687f, 
    -0.14057109f, 0.02353253f, 0.04611544f, -0.02154258f, -0.01425551f, 0.03824409f, 0.06953550f, -0.04303538f, 
    0.02767588f, 0.02641107f, -0.00141928f, 0.11253271f, 0.42263559f, -0.00536096f, -0.41931337f, -0.05619217f, 
    0.02193440f, -0.07862406f, 0.00247915f, 0.00790781f, -0.05207325f, -0.04248072f, -0.01181481f, -0.00257101f, 
    -0.17177232f, -0.16670094f, 0.14521769f, -0.16047819f, 0.09152557f, 0.01328567f, -0.03376963f, -0.12576032f, 
    0.03717164f, -0.05741399f, -0.12986508f, -0.01440920f, -0.06625368f, -0.01463077f, -0.03765853f, -0.04241380f, 
    0.12665209f, 0.05861485f, -0.02098641f, 0.08406910f, 0.03945168f, 0.00357289f, -0.04282277f, 0.02764275f, 
    -0.04227197f, 0.09974390f, -0.08979355f, 0.07876880f, -0.01266188f, -0.09796340f, 0.00793767f, -0.04656903f, 
    -0.06044415f, -0.19796979f, 0.05137412f, 0.02918958f, -0.06406529f, 0.08383549f, -0.06631119f, 0.02374009f, 
    0.01358918f, 0.04734034f, 0.04567172f, 0.04725020f, -0.07955965f, 0.02005433f, 0.09242934f, -0.18444014f, 
    -0.66105467f, 0.06882243f, -0.06339376f, -0.19878203f, -0.00462040f, -0.11203521f, 0.01403771f, 0.03429471f, 
    -0.00582709f, -0.03999314f, 0.07104461f, 0.06339026f, -0.13945834f, 0.19517621f, -0.03522218f, -0.12575556f, 
    -0.02321132f, -0.03435067f, 0.06883843f, 0.11121908f, -0.05832651f, -0.03733590f, 0.08434754f, -0.08979127f, 
    0.08123475f, 0.12978859f, 0.06729040f, 0.04802572f, -0.09124734f, -0.19331786f, -0.06530134f, 0.15555121f, 
    0.01078317f, -0.03546852f, 0.11848853f, 0.08946958f, -0.12813182f, 0.01202917f, 0.04909879f, 0.08565882f, 
    0.09176548f, -0.00323547f, -0.03485037f, -0.01888714f, 0.11715804f, -0.01479252f, 0.00498174f, 0.00272116f, 
    -0.07929331f, -0.02273500f, -0.08158631f, 0.05588498f, 0.03839584f, -0.05242336f, 0.02755660f, 0.01840018f, 
    -0.06133217f, -0.06212945f, -0.01765633f, -0.05440119f, -0.06408251f, -0.14053403f, 0.02894793f, 0.06209774f, 
    -0.07010479f, -0.02275396f, -0.06940092f, 0.01458403f, 0.05469877f, 0.06677309f, -0.01334715f, 0.00769768f, 
    -0.25050831f, -0.10411431f, 0.11023544f, 0.08040508f, 0.08113234f, -0.11780162f, -0.11045744f, -0.18554589f, 
    -0.00409814f, -0.08510783f, -0.07988087f, 0.01095641f, -0.15137957f, 0.00885641f, -0.06675248f, 0.12891750f, 
    0.11813953f, 0.04780265f, 0.00246047f, -0.05841979f, -0.01609286f, -0.06037192f, -0.09973594f, -0.05029459f, 
    -0.02732670f, -0.02172995f, 0.01810545f, 0.17615713f, -0.06977262f, -0.04233356f, 0.02037310f, 0.05273972f, 
    0.09799807f, 0.04576125f, -0.03061571f, -0.10695142f, 0.12939852f, -0.18357879f, -0.11163464f, -0.07224560f, 
    -0.17291294f, 0.00924844f, -0.09127752f, 0.01042597f, -0.00595747f, 0.03954535f, -0.08963442f, -0.06133125f, 
    0.13020708f, -0.14217933f, 0.15119977f, 0.08170138f, -0.07976837f, -0.03034321f, 0.02430113f, -0.04090242f, 
    0.00821409f, -0.03555058f, 0.02741318f, -0.05623703f, 0.09240916f, 0.17430365f, -0.05021620f, 0.19049716f, 
    -0.02838294f, 0.04542212f, 0.03251976f, -0.05737938f, -0.04099859f, -0.00542389f, -0.01021387f, 0.02165196f, 
    0.04612144f, 0.14833188f, 0.01949150f, -0.14473727f, 0.05869954f, -0.06517699f, 0.02497804f, 0.01243229f, 
    0.02153917f, -0.00876758f, 0.05829597f, 0.00722510f, -0.27570930f, 0.11022243f, -0.02204462f, 0.04162436f, 
    0.06818752f, -0.08432292f, -0.02070718f, -0.00696091f, -0.12997881f, -0.01095996f, -0.06618950f, 0.00300878f, 
    0.06248520f, 0.10918321f, -0.03618768f, 0.15300930f, 0.09249519f, -0.04713838f, 0.07232862f, -0.04617869f, 
    0.05216776f, 0.00657097f, 0.01328615f, -0.04488177f, -0.21990763f, 0.16349189f, -0.11011079f, -0.18400399f, 
    -0.11086249f, 0.05120093f, -0.00489518f, -0.03631669f, 0.07455811f, 0.02273080f, -0.03157227f, -0.01226712f, 
    -0.09841572f, -0.10740744f, 0.09774018f, 0.22075145f, -0.22764924f, -0.03981932f, -0.12810588f, -0.00262770f, 
    -0.01870533f, 0.01052742f, -0.04308775f, 0.05499009f, -0.37914279f, 0.15593803f, 0.17491652f, 0.13520385f, 
    0.10678800f, -0.03071609f, -0.03402882f, -0.01848577f, -0.03105616f, 0.07811566f, -0.07207430f, -0.01534514f, 
    0.05053867f, -0.07809123f, 0.03366472f, 0.18461563f, 0.01077429f, -0.04094163f, 0.04588034f, 0.04437547f, 
    0.00245740f, 0.03008437f, -0.09897779f, 0.07168195f, -0.29605517f, -0.02678340f, 0.01530574f, 0.21429376f, 
    0.03997694f, 0.00714003f, 0.10214544f, 0.12674095f, 0.03197079f, -0.06251396f, 0.11365282f, 0.09605591f, 
    -0.08919820f, -0.23778416f, -0.08208896f, -0.04678142f, -0.04065993f, 0.15969197f, 0.00735626f, 0.02246024f, 
    -0.04346898f, -0.05879177f, -0.04208374f, -0.06073386f, 0.10578375f, 0.07166553f, -0.05050713f, -0.01989172f, 
    0.03300039f, 0.02709240f, 0.08296180f, 0.14253463f, -0.06550371f, 0.03065225f, 0.06444391f, 0.00687972f, 
    0.13563238f, 0.24902970f, 0.02275125f, 0.00001621f, 0.00594810f, -0.01333685f, 0.01146401f, 0.00065745f, 
    -0.05293699f, 0.05137426f, -0.13046913f, -0.00868146f, -0.28932673f, -0.11202899f, -0.12355820f, -0.03598519f, 
    0.04488276f, 0.02496695f, 0.02248461f, -0.03089308f, -0.03743402f, -0.00287333f, -0.03426968f, 0.03709276f, 
    0.05909403f, -0.03889169f, -0.10535222f, 0.02014905f, -0.12548989f, -0.04239621f, 0.02370620f, -0.06650520f, 
    -0.11976432f, 0.06523300f, 0.02479934f, 0.00608572f, -0.13983683f, -0.01100214f, 0.04439218f, 0.04880922f, 
    -0.10404881f, -0.03396524f, -0.06955516f, -0.06199046f, -0.02694783f, -0.00853042f, 0.08828701f, 0.00556922f, 
    0.02812304f, 0.43046528f, -0.24054594f, -0.19159776f, 0.02047593f, 0.03978219f, 0.08196412f, 0.05722494f, 
    -0.01211480f, 0.13064204f, -0.09654415f, -0.03061043f, -0.27794528f, 0.04668936f, 0.11412282f, 0.21977906f, 
    0.01072756f, 0.00174074f, -0.02379619f, 0.04394025f, 0.04299033f, 0.06201304f, -0.01771301f, 0.14130379f, 
    -0.15596764f, 0.17822441f, -0.10160675f, 0.08363678f, 0.01342576f, 0.04333410f, 0.05691372f, -0.15951172f, 
    -0.01498381f, 0.02972802f, 0.12650439f, 0.05539577f, -0.62795800f, -0.23074785f, 0.21039115f, 0.14719258f, 
    -0.06782685f, -0.09355548f, -0.06260860f, -0.05938166f, 0.08273677f, -0.09085514f, -0.03264220f, -0.04469094f, 
    -0.06847672f, 0.04447208f, 0.00927106f, -0.08415128f, -0.06177880f, -0.05024789f, 0.03895121f, -0.02176326f, 
    -0.01977787f, -0.02791866f, -0.05148181f, -0.05914683f, -0.04487827f, -0.04121598f, 0.15785052f, -0.04355481f, 
    0.05295376f, 0.03400411f, 0.06465708f, -0.03686012f, -0.01095412f, -0.06314214f, -0.01272810f, 0.00932179f, 
    -0.02308456f, 0.17779526f, -0.04753957f, -0.12803447f, -0.11107025f, -0.02363312f, 0.06481052f, -0.07062471f, 
    0.02902793f, -0.06003059f, 0.07600281f, 0.06963681f, -0.15683533f, -0.06704868f, 0.14987852f, -0.03364322f, 
    -0.05785941f, -0.07475660f, -0.01842225f, -0.15269248f, 0.05395922f, -0.07180045f, 0.01903556f, -0.12940872f, 
    0.01083660f, 0.14138994f, -0.02697347f, -0.19106354f, 0.05423102f, -0.15614007f, 0.04600973f, 0.06765943f, 
    -0.06351786f, 0.01803322f, 0.06459621f, -0.01053774f, -0.17262413f, -0.28007135f, 0.10974164f, 0.32861143f, 
    -0.05358471f, 0.01543554f, 0.02178962f, 0.03051847f, 0.00462648f, 0.12557667f, 0.10284348f, 0.11824267f, 
    -0.09353697f, -0.39302018f, 0.21679866f, -0.11302614f, -0.04405101f, 0.10765887f, 0.06090844f, -0.05783185f, 
    -0.01733711f, -0.00048670f, -0.00433985f, -0.12020913f, -0.15042070f, -0.09233540f, 0.03189592f, -0.14620909f, 
    0.01337978f, -0.02098749f, 0.06883962f, -0.03930465f, -0.08926780f, -0.05237372f, 0.01613025f, -0.09207203f, 
    0.07276610f, 0.04361875f, 0.14249153f, 0.12630905f, 0.08866399f, 0.02236704f, 0.03897413f, 0.07629442f, 
    0.08534352f, 0.11497860f, 0.00482403f, 0.01298889f, 0.00870461f, -0.19909458f, 0.00354025f, -0.38118097f, 
    0.02582909f, 0.03336045f, 0.05461789f, 0.04669160f, 0.03227418f, 0.07727391f, -0.02208507f, 0.05397225f, 
    -0.18416533f, 0.07583898f, 0.08725211f, -0.14940383f, 0.04871987f, -0.02229938f, -0.04672734f, 0.08789512f, 
    0.07516184f, 0.07073054f, 0.01615237f, 0.10483344f, -0.02762821f, 0.09692071f, 0.08986946f, 0.17528513f, 
    -0.05590606f, -0.06530966f, 0.03060228f, -0.01244588f, 0.04274666f, -0.06503076f, 0.01076189f, 0.13530079f, 
    -0.04223318f, 0.12748206f, -0.05539599f, 0.17188640f, -0.00707189f, 0.04025109f, -0.02857850f, -0.04730977f, 
    -0.09935541f, -0.20565315f, 0.03468274f, 0.15098619f, -0.02962470f, 0.00072547f, 0.10426784f, 0.08128711f, 
    -0.10561601f, -0.07314004f, 0.03132483f, -0.11824533f, 0.03933413f, 0.11077467f, 0.06097962f, 0.17548612f, 
    -0.19241446f, -0.02652362f, -0.10436108f, 0.05740629f, 0.03365438f, 0.02057093f, -0.05819249f, 0.04558833f, 
    0.05196232f, 0.06698047f, 0.13634081f, 0.12301607f, 0.01311630f, 0.01835679f, 0.11726607f, -0.02463112f, 
    -0.07038526f, 0.06892616f, 0.02029722f, 0.03581813f, -0.06341775f, 0.05225225f, 0.11937423f, 0.10709932f, 
    -0.15580562f, -0.26145944f, -0.10026816f, 0.13351475f, 0.03366970f, -0.05325852f, 0.04747146f, 0.01070143f, 
    -0.08603538f, 0.14638937f, 0.07344895f, 0.16558774f, -0.49172381f, -0.27665803f, -0.05473892f, 0.11699352f, 
    0.08553278f, -0.05563854f, -0.03846516f, 0.03535712f, -0.01561499f, -0.20171939f, -0.00957108f, -0.01494462f, 
    -0.12547404f, 0.20585476f, -0.15179805f, -0.08245557f, 0.06585671f, 0.06833354f, 0.21769537f, 0.13436526f, 
    0.03904146f, 0.01590718f, -0.13459221f, -0.19920164f, 0.14727125f, 0.04105196f, -0.09773584f, 0.10790116f, 
    -0.05648486f, 0.03199124f, 0.05033292f, 0.06791561f, -0.03308182f, 0.08529324f, 0.10848487f, 0.01031231f, 
    0.14700976f, 0.19389807f, 0.18030411f, -0.03913302f, -0.00758477f, -0.00135239f, -0.16653651f, -0.10547707f, 
    -0.09599528f, -0.02551124f, -0.03733039f, 0.00441589f, -0.08213514f, -0.09130652f, 0.12252598f, 0.07898343f, 
    0.01657405f, -0.01847196f, -0.06644727f, -0.00729995f, -0.06256092f, 0.14368987f, -0.08800886f, 0.00665353f, 
    -0.08029877f, 0.06409836f, -0.11985721f, -0.04151023f, 0.00802826f, 0.01500627f, -0.14576705f, -0.00823462f, 
    0.03400395f, -0.09760150f, -0.00937470f, 0.04032143f, -0.17250983f, -0.16429482f, -0.19053391f, 0.06845136f, 
    0.13488221f, 0.12366053f, -0.09812783f, -0.12971444f, -0.00151383f, 0.03833356f, -0.00848689f, 0.09830111f, 
    -0.29474917f, -0.25539842f, 0.01080880f, 0.23892626f, 0.00481171f, -0.15223467f, 0.00395511f, -0.02296259f, 
    -0.00253486f, -0.01280297f, -0.01856108f, 0.00763584f, -0.19640084f, -0.08796870f, -0.03724571f, -0.10390215f, 
    -0.04345362f, 0.03973776f, -0.04249300f, 0.07203547f, 0.05781454f, 0.08307260f, 0.15113749f, -0.13163644f, 
    -0.16904899f, 0.05452650f, 0.00633731f, -0.00055363f, -0.00488231f, -0.04018860f, -0.02604735f, -0.05423800f, 
    0.05737338f, -0.06999881f, -0.01216925f, 0.02784202f, 0.16070107f, -0.04036098f, 0.06859585f, 0.17665642f, 
    0.07676703f, 0.02404772f, 0.13616171f, 0.00332997f, -0.05243919f, -0.00158279f, 0.10285625f, 0.16336001f, 
    -0.08609914f, -0.05818239f, 0.09966762f, 0.21170455f, 0.08680643f, 0.01957921f, -0.02422640f, 0.07145741f, 
    0.09703550f, -0.07578422f, -0.13747947f, -0.15750374f, -0.32661352f, 0.00806020f, 0.14995730f, 0.11070951f, 
    -0.03295458f, 0.01603960f, 0.02348777f, 0.03649279f, 0.03608639f, 0.03037405f, -0.01994951f, -0.05259211f, 
    0.06268903f, 0.02398948f, -0.12343422f, 0.18459028f, -0.00702581f, -0.08308654f, -0.04543357f, -0.05598097f, 
    0.18146384f, 0.06204670f, -0.04039798f, 0.12611924f, -0.40555716f, -0.22983557f, -0.15992701f, 0.04654304f, 
    -0.00666566f, -0.02840973f, 0.07895754f, -0.09181366f, -0.02443485f, -0.05894867f, 0.00703691f, -0.15795779f, 
    -0.31425235f, -0.09260619f, -0.16990650f, 0.04379854f, 0.04847093f, -0.02656202f, 0.10808991f, -0.11953694f, 
    0.22071505f, 0.09335364f, 0.01792160f, 0.13341138f, 0.14007829f, 0.20756717f, 0.16587739f, -0.04537257f, 
    -0.02497034f, -0.03023536f, -0.11372478f, -0.09616537f, -0.06590643f, -0.04441029f, -0.08697806f, 0.11317603f, 
    -0.33730057f, 0.19839926f, 0.04665450f, -0.29331982f, 0.12715830f, 0.05232731f, 0.00703500f, 0.10284611f, 
    -0.00541992f, -0.14276399f, 0.05119619f, -0.11063065f, -0.04938859f, -0.07848371f, 0.09791294f, 0.16538112f, 
    -0.01657330f, 0.13125175f, 0.06667776f, -0.01682504f, -0.03952449f, -0.05519328f, -0.00992998f, 0.06079226f, 
    0.16932575f, 0.05625012f, 0.03843111f, 0.22328490f, -0.06164224f, 0.09813830f, 0.02872214f, -0.12364655f, 
    0.04557587f, -0.06205696f, 0.16375451f, 0.09317928f, 0.01785371f, 0.02478926f, 0.16638261f, 0.18464811f, 
    -0.02021427f, -0.04217673f, 0.10304566f, -0.00852829f, 0.03906347f, -0.03352207f, -0.01449399f, 0.30000141f, 
    0.20254500f, 0.01328176f, -0.15439284f, -0.00564275f, 0.00884768f, 0.04369605f, -0.07507622f, -0.05603451f, 
    -0.11337262f, 0.00804904f, 0.05464527f, -0.03333963f, 0.10519886f, 0.13785805f, 0.03848833f, -0.00494143f, 
    0.02579453f, -0.00587352f, -0.02819302f, 0.02163167f, -0.01443763f, -0.00628753f, 0.01711010f, 0.07198475f, 
    -0.07787327f, -0.06902838f, -0.07216369f, -0.12120291f, -0.00607109f, -0.07317954f, 0.01141637f, 0.15605183f, 
    -0.12671146f, -0.00080276f, 0.16009469f, 0.13911806f, -0.14592886f, -0.21240892f, -0.08614310f, 0.05548734f, 
    0.09911267f, 0.11270481f, -0.03372966f, -0.08146109f, 0.09550530f, -0.09265498f, 0.10900666f, -0.08983310f, 
    -0.18163854f, -0.11427553f, -0.13488814f, -0.23974815f, 0.03227419f, 0.02168605f, -0.07774795f, -0.05361620f, 
    -0.00910645f, -0.05101135f, -0.04141011f, 0.13485479f, 0.06895033f, -0.04048735f, -0.05979549f, -0.02963727f, 
    0.01991373f, 0.07999285f, 0.01651999f, -0.10487638f, 0.03784108f, -0.06229260f, -0.05178994f, 0.10337339f, 
    0.07664061f, 0.00589179f, 0.04710229f, -0.32292837f, -0.11307593f, 0.01309062f, -0.14383842f, -0.01509613f, 
    0.02407416f, -0.06344175f, -0.08328350f, -0.11749288f, 0.02148499f, -0.12039281f, 0.00208620f, -0.19283418f, 
    0.02146084f, 0.03789471f, -0.04129057f, -0.03278201f, 0.00756903f, -0.09836688f, 0.03824353f, 0.00868261f, 
    -0.10611425f, 0.04803276f, 0.08755697f, 0.07917789f, -0.06178283f, 0.07019588f, 0.07643371f, 0.05251070f, 
    0.02547229f, 0.08340157f, 0.03027340f, -0.10934530f, -0.48128220f, 0.00544820f, -0.22412051f, -0.19167121f, 
    0.07586904f, 0.11766709f, 0.04059184f, 0.09735412f, 0.07252116f, 0.10725441f, 0.14044698f, -0.20886494f, 
    0.07752925f, 0.20765270f, -0.05354492f, -0.24048376f, -0.02840186f, 0.01846540f, 0.05175947f, -0.06560160f, 
    0.09592634f, 0.20361342f, -0.15906918f, 0.07588208f, -0.55793393f, 0.24996763f, 0.11099172f, -0.25256649f, 
    0.14549027f, -0.09824944f, -0.00991587f, -0.09021393f, -0.00553433f, -0.06020124f, -0.03294007f, -0.14508641f, 
    0.05826863f, -0.06515710f, -0.00027484f, -0.05111681f, 0.00153194f, -0.08398788f, 0.05456533f, 0.09291426f, 
    0.00661604f, 0.03031553f, 0.06433380f, -0.05748948f, -0.17667307f, -0.01776297f, -0.16877553f, -0.00218107f, 
    0.09213489f, 0.09191581f, 0.00322211f, 0.03550740f, 0.12865546f, 0.02393382f, 0.04594397f, 0.09122346f, 
    -0.09975751f, -0.08124316f, -0.00306078f, -0.00022808f, 0.08694667f, 0.08390470f, -0.11209358f, 0.03107328f, 
    -0.16122943f, 0.01509321f, 0.04100923f, 0.01297532f, -0.14056131f, -0.05068466f, -0.29620886f, -0.21956529f, 
    0.07066870f, 0.05758433f, -0.04610185f, -0.22830077f, 0.00763925f, 0.06239262f, -0.22155227f, -0.07813057f, 
    -0.33893159f, 0.05095405f, 0.15677924f, -0.08062089f, 0.02913677f, -0.01662944f, 0.11753299f, 0.11589035f, 
    -0.07584687f, 0.02588007f, -0.03282700f, -0.11628185f, 0.09946952f, -0.05766271f, 0.16867855f, -0.00436082f, 
    0.01767248f, 0.00009460f, -0.09013757f, -0.21975569f, -0.07977965f, 0.00518371f, -0.08598511f, 0.01137922f, 
    -0.28782427f, 0.06856865f, 0.07668243f, 0.00189071f, 0.06629415f, -0.09657596f, -0.01467906f, 0.01618610f, 
    0.08816656f, -0.07490380f, -0.02558341f, 0.00343251f, -0.11011051f, 0.08186946f, -0.05687704f, -0.01820410f, 
    -0.02362812f, -0.02237475f, 0.11953449f, 0.01897510f, 0.10186511f, 0.03714515f, -0.10970180f, -0.11316561f, 
    0.11487553f, -0.03247199f, 0.04986569f, 0.18603659f, 0.06331022f, -0.20479418f, -0.04775833f, 0.00759286f, 
    0.07252830f, -0.09843713f, -0.09544954f, -0.00596365f, 0.07892382f, -0.02986203f, 0.15349451f, 0.17135583f, 
    -0.02380319f, -0.09059884f, 0.07869736f, 0.13502251f, 0.04741734f, -0.14007425f, 0.05226988f, -0.20379128f, 
    -0.21201333f, -0.31110936f, 0.36498651f, 0.23459059f, 0.03843003f, 0.08626178f, -0.13138920f, -0.04539056f, 
    -0.00791345f, 0.00691347f, 0.02771180f, -0.10429256f, 0.02385254f, -0.00295091f, -0.22988474f, -0.06065990f, 
    0.00023368f, 0.00590990f, -0.00655384f, -0.10023303f, 0.04090878f, -0.14983112f, 0.04819921f, -0.11491661f, 
    0.19708668f, 0.21643803f, -0.07251117f, -0.08127539f, -0.01087967f, -0.09717513f, 0.03625778f, -0.04519344f, 
    0.05660058f, 0.05304728f, -0.04286243f, -0.00738937f, 0.22997786f, -0.02737181f, 0.03857928f, -0.02856771f, 
    -0.06195625f, -0.03496643f, 0.05308338f, -0.00151290f, -0.13321519f, -0.07422403f, 0.04441148f, 0.04094254f, 
    -0.29776582f, -0.17267166f, 0.04799997f, 0.19797088f, -0.02955071f, -0.22375187f, 0.07797304f, 0.12055179f, 
    0.12049415f, 0.07166146f, -0.07426603f, 0.15774985f, 0.11788407f, -0.05340372f, -0.05469398f, 0.12754151f, 
    -0.08892894f, -0.06543752f, -0.01300115f, 0.00631289f, 0.01278577f, 0.01528907f, 0.07195047f, -0.11613499f, 
    -0.13352099f, 0.09017506f, -0.02425297f, -0.05058374f, 0.02125525f, 0.14612810f, 0.06945988f, -0.12912920f, 
    -0.20519668f, -0.15611431f, 0.00372052f, 0.01247703f, -0.02799173f, -0.01083097f, 0.07716399f, 0.05732342f, 
    -0.11634149f, -0.10569879f, 0.08498351f, 0.05990990f, -0.14842521f, -0.03726764f, 0.00408172f, 0.23199928f, 
    -0.20310006f, -0.27825424f, 0.01239082f, 0.05755704f, 0.10196632f, -0.01613790f, 0.05753693f, 0.01162388f, 
    0.06377922f, 0.13347617f, -0.28341049f, 0.15297115f, 0.21843047f, 0.13659559f, -0.07978874f, -0.06444144f, 
    0.04477195f, 0.06639206f, -0.18765281f, -0.06082727f, -0.02138912f, -0.06998989f, -0.03873946f, -0.02538861f, 
    0.10245438f, 0.01971243f, -0.04982066f, 0.15193045f, -0.07667680f, -0.11650243f, 0.01961589f, -0.01677089f, 
    0.05799738f, -0.03486914f, -0.00389352f, -0.02578833f, -0.03664035f, 0.12079754f, -0.01226128f, -0.19016729f, 
    0.11335783f, -0.04100665f, 0.10184493f, 0.04873254f, 0.10868397f, 0.07066581f, -0.04239297f, -0.02600842f, 
    -0.13411875f, -0.04124164f, -0.15680480f, -0.10167871f, 0.04201609f, 0.08777266f, -0.17519794f, -0.15502076f, 
    0.06809495f, -0.01384071f, 0.17312750f, 0.05685677f, 0.15796216f, 0.01480958f, 0.12121318f, 0.04913120f, 
    -0.07027675f, 0.05069221f, -0.09750000f, 0.11736044f, -0.10489766f, -0.07891548f, 0.04174384f, -0.02985042f, 
    0.08464388f, -0.04427962f, 0.21041267f, -0.20702954f, -0.20472242f, -0.04359599f, -0.01958170f, 0.10148608f, 
    0.00517899f, -0.05486496f, -0.01361847f, -0.08107115f, 0.03514376f, -0.15886548f, -0.07706150f, 0.20987482f, 
    0.00072429f, -0.03916567f, -0.06654196f, -0.02337161f, -0.07399979f, -0.00401996f, -0.17909594f, -0.02173487f, 
    -0.11088138f, -0.03336249f, -0.04112665f, -0.00326586f, 0.13778158f, -0.04843408f, -0.07497989f, -0.01482913f, 
    -0.02340153f, 0.00779577f, -0.13611309f, -0.10301378f, -0.06439596f, 0.18184982f, 0.17252082f, -0.18970269f, 
    0.09629715f, 0.02888322f, 0.03246093f, 0.03303446f, 0.07195073f, -0.11390226f, -0.02311357f, -0.09803274f, 
    0.01199634f, -0.05748421f, -0.17719340f, -0.24409434f, -0.01428855f, -0.06275336f, -0.00462289f, -0.08432258f, 
    -0.02407426f, -0.07989681f, -0.08564274f, -0.14796077f, 0.24357517f, -0.05249836f, -0.24079999f, -0.15800211f, 
    0.10086636f, 0.00712829f, 0.03656559f, -0.11592849f, 0.08169352f, -0.04085669f, 0.05107527f, -0.14490941f, 
    0.10862154f, 0.07204378f, 0.00536569f, -0.14327486f, -0.02725427f, 0.16831081f, -0.06562100f, -0.07601814f, 
    0.07368179f, -0.15559733f, 0.05234708f, -0.01710415f, 0.18962108f, 0.03850534f, -0.01060778f, -0.16523999f, 
    -0.00346401f, -0.01299917f, 0.04851329f, -0.22653155f, -0.16313502f, 0.07076117f, 0.12776530f, -0.02183374f, 
    0.31408933f, -0.28768286f, 0.05425844f, -0.17562377f, 0.03704822f, -0.04888200f, 0.02572687f, -0.17773597f, 
    0.01746367f, 0.06840190f, 0.05787338f, -0.00820418f, -0.18949230f, 0.04689709f, 0.04063296f, 0.13833059f, 
    0.13760306f, -0.03967825f, -0.01256768f, 0.05826293f, 0.02160385f, 0.02177384f, -0.03167619f, -0.00282956f, 
    -0.18053500f, -0.10750093f, -0.12774913f, -0.10458658f, -0.03391041f, -0.14971137f, 0.03541097f, 0.16703807f, 
    -0.07876392f, -0.00898567f, -0.01051695f, -0.03108653f, 0.03933504f, -0.15886624f, -0.17812027f, 0.10019286f, 
    -0.09858281f, 0.09823658f, 0.05610313f, -0.01837438f, 0.05921920f, -0.25643480f, 0.08108980f, 0.04050443f, 
    0.01593450f, -0.07137772f, -0.05949686f, -0.07187639f, -0.05712583f, -0.00331396f, 0.05248547f, 0.00043820f, 
    0.08885776f, 0.06434433f, -0.11331633f, -0.03406899f, -0.15200098f, 0.00074164f, -0.10577784f, -0.22759822f, 
    -0.17015614f, 0.00505361f, 0.05583243f, -0.06151438f, 0.07580607f, -0.07554254f, -0.07999181f, -0.00178958f, 
    0.17952891f, -0.10249776f, -0.05412025f, 0.04067774f, -0.06671000f, -0.03022484f, -0.14296181f, -0.05998411f, 
    -0.08703965f, 0.03175897f, 0.08935552f, -0.08794611f, 0.16039306f, -0.04040098f, -0.05435735f, 0.11985586f, 
    0.11694343f, 0.06934175f, 0.03967282f, 0.03195211f, -0.07571992f, -0.00510017f, -0.05799792f, 0.09844209f, 
    0.09174442f, -0.14616250f, 0.02169941f, -0.14657828f, -0.00757895f, 0.00036869f, 0.04234862f, 0.00834143f, 
    -0.08874894f, 0.00165800f, 0.13916199f, 0.08704060f, -0.04455366f, 0.15888298f, 0.08043146f, -0.07247715f, 
    -0.04997388f, -0.02074638f, -0.12241872f, -0.11776228f, -0.11795317f, 0.03870541f, -0.07425399f, -0.06230865f, 
    0.08415186f, -0.11536515f, -0.25125667f, 0.19614860f, 0.02282461f, 0.03527254f, -0.00444173f, 0.10311714f, 
    -0.07438701f, 0.13378097f, 0.09550663f, 0.02087918f, -0.17046374f, -0.11785395f, 0.09574920f, -0.01625477f, 
    -0.00795170f, -0.00702399f, -0.01540084f, 0.03654465f, -0.26058078f, 0.06002830f, 0.06549014f, -0.02803126f, 
    -0.42815799f, 0.30771565f, 0.04702545f, 0.20838369f, -0.06024858f, 0.07755865f, 0.14429191f, 0.02698551f, 
    -0.06816748f, -0.01651307f, 0.11096770f, -0.23033109f, 0.22675218f, -0.00915650f, 0.00292815f, -0.00232863f, 
    -0.15119170f, 0.02590233f, -0.06874215f, 0.02899983f, -0.07091308f, 0.02041333f, 0.00882138f, 0.07808479f, 
    -0.27089441f, -0.17107466f, 0.06914287f, -0.11258891f, -0.05349185f, 0.06285422f, 0.03905568f, -0.00955968f, 
    -0.13334446f, -0.05921216f, -0.12326559f, -0.06884915f, -0.14919385f, 0.15101108f, 0.10749543f, 0.10484426f, 
    -0.05568976f, 0.06687529f, 0.07124180f, 0.03627954f, 0.09112668f, -0.08582873f, 0.11895510f, -0.22383550f, 
    0.19237232f, -0.47163111f, -0.07433914f, -0.06401484f, 0.01231617f, 0.07366718f, 0.07771979f, -0.00368616f, 
    0.03166131f, 0.07002200f, 0.06795526f, 0.17754249f, 0.08762038f, 0.03567790f, 0.04641455f, -0.11288396f, 
    -0.06189675f, -0.05926164f, 0.06244129f, 0.10514995f, 0.03850629f, -0.04395468f, -0.00867813f, -0.06878138f, 
    0.02409687f, -0.06354579f, -0.19176480f, -0.21640901f, 0.04498414f, -0.08648197f, -0.04493339f, -0.20922419f, 
    0.04605830f, 0.02141437f, 0.02324751f, -0.08399671f, 0.06644803f, 0.18040302f, 0.06109748f, -0.31793082f, 
    -0.02040081f, 0.07698789f, 0.03675143f, 0.00386207f, -0.05111686f, -0.00249208f, 0.02153710f, -0.12492672f, 
    -0.05794074f, 0.17758907f, 0.19310533f, 0.29709503f, -0.08193245f, 0.05813531f, 0.00066987f, -0.06755907f, 
    0.00188394f, -0.03552534f, -0.06528500f, 0.02884619f, -0.15966474f, 0.21888594f, 0.09038828f, 0.02924722f, 
    0.00557865f, 0.01217492f, -0.03964616f, 0.09583013f, -0.04307649f, 0.01663399f, 0.02854358f, -0.08460159f, 
    0.30980304f, 0.16481170f, 0.04724754f, -0.07581681f, 0.01961051f, 0.10921749f, 0.08889040f, 0.12454624f, 
    0.03680857f, -0.02816916f, -0.08559912f, 0.07052567f, 0.06943637f, 0.08948255f, -0.37164736f, 0.25229082f, 
    -0.09979219f, -0.01170776f, 0.00588162f, 0.02877180f, -0.13203767f, 0.13435353f, -0.01096473f, 0.01284578f, 
    -0.18396956f, -0.08326369f, 0.14332658f, 0.04684821f, -0.02080259f, 0.17061055f, 0.14198102f, -0.01143161f, 
    0.05738224f, -0.13318834f, 0.08658824f, -0.08891223f, -0.38712126f, 0.14488950f, 0.01742409f, 0.21360153f, 
    0.07221776f, -0.08887647f, -0.05249674f, 0.02176882f, 0.06488040f, 0.04211456f, 0.02093474f, 0.07168441f, 
    -0.45241922f, 0.24384753f, 0.17332973f, 0.00620104f, 0.01160640f, -0.03533407f, -0.02479515f, 0.07723612f, 
    -0.06024170f, -0.04300214f, 0.04312504f, 0.06482574f, 0.06816421f, -0.03760298f, 0.12834740f, -0.27229816f, 
    -0.14757167f, 0.03287145f, 0.04194338f, -0.00166112f, 0.02177961f, 0.14370210f, -0.03198363f, 0.02488525f, 
    0.16709132f, 0.01740830f, -0.01539524f, -0.00818017f, 0.09692951f, -0.06571930f, -0.06539252f, 0.04855557f, 
    -0.02149514f, -0.08244475f, -0.03621477f, -0.08747552f, -0.12223367f, -0.07978790f, 0.09668739f, -0.26950002f, 
    -0.02334535f, 0.00316170f, 0.01198864f, -0.12199050f, -0.09999790f, 0.02176568f, -0.07746872f, 0.05230569f, 
    -0.17233165f, 0.03748951f, -0.00558505f, -0.03785679f, -0.12013049f, 0.03573488f, -0.05420538f, 0.09291480f, 
    0.00795738f, -0.11667118f, -0.08669553f, -0.00150806f, 0.32650128f, -0.53265333f, 0.02903221f, -0.01416141f, 
    -0.01692394f, 0.10135686f, -0.00741246f, 0.13476688f, 0.04993812f, 0.04642884f, 0.08188487f, 0.02458044f, 
    -0.13812058f, 0.20537132f, 0.05691366f, -0.12901044f, -0.00324748f, 0.00511046f, -0.10376664f, 0.00941186f, 
    -0.02796662f, 0.13237719f, 0.03923165f, 0.08825500f, -0.02588497f, -0.16453949f, -0.07751854f, -0.00396488f, 
    -0.04431997f, 0.04949272f, 0.06328102f, -0.17918426f, -0.07241010f, 0.05137007f, 0.01434603f, -0.06708345f, 
    -0.04143365f, 0.11728623f, -0.14316757f, -0.02078443f, -0.06162197f, 0.01804018f, -0.00962034f, 0.02708242f, 
    0.02362155f, -0.01807284f, 0.04565354f, -0.03807143f, -0.20257159f, -0.16983540f, -0.01970063f, -0.16771550f, 
    -0.02262924f, -0.03875767f, -0.08183438f, 0.03873318f, 0.06169723f, 0.02392661f, 0.16290726f, 0.15526788f, 
    0.20729177f, 0.02836146f, 0.04671826f, 0.05144101f, -0.00510986f, 0.05408798f, -0.02828440f, 0.09215342f, 
    0.05311166f, 0.06307190f, 0.07680508f, -0.07624227f, -0.08087318f, 0.18283267f, -0.00280157f, -0.05924744f, 
    0.00107775f, 0.08184074f, 0.08053278f, 0.08661949f, 0.10460934f, 0.02692300f, 0.02326536f, 0.03522764f, 
    0.24012671f, -0.13687336f, 0.12450945f, -0.36248925f, -0.02866879f, 0.06395424f, -0.01605981f, 0.09225543f, 
    -0.03851976f, 0.06702453f, 0.00366326f, -0.01700880f, 0.19890359f, 0.08347952f, 0.13611779f, 0.07861293f, 
    -0.08976744f, -0.00506168f, -0.14213751f, -0.19167373f, -0.09725024f, -0.03900220f, 0.18038730f, 0.04446926f, 
    -0.16738796f, -0.14365765f, -0.24887246f, 0.05970310f, 0.00747672f, 0.11136603f, 0.00163852f, 0.04975092f, 
    0.03038359f, 0.01753354f, 0.08646493f, 0.13228559f, -0.05783118f, 0.01483992f, -0.10115395f, -0.08765756f, 
    0.04005219f, 0.02504643f, 0.03069641f, 0.00820693f, -0.15948589f, -0.00375360f, 0.10583004f, 0.09040497f, 
    0.03884437f, -0.18043575f, -0.07890771f, 0.17058818f, -0.03401703f, -0.06449354f, 0.08986364f, 0.02782411f, 
    0.10176315f, -0.00843027f, -0.13336891f, 0.14750253f, -0.10586703f, -0.28709570f, -0.14723180f, -0.07876202f, 
    0.05126528f, -0.03784692f, 0.02231154f, 0.04096033f, -0.09034482f, 0.08235912f, 0.03304048f, 0.15556321f, 
    -0.00536311f, -0.20226458f, -0.20003240f, 0.15731339f, 0.00489362f, 0.00489620f, -0.06366925f, -0.00771694f, 
    0.05156950f, -0.06165056f, 0.02710019f, -0.02535862f, 0.00043678f, 0.18339723f, -0.02056836f, -0.26265317f, 
    0.07024010f, 0.05803337f, -0.04473912f, 0.06405941f, -0.01723393f, -0.04902532f, -0.05722319f, 0.06848073f, 
    0.14988595f, -0.20425129f, -0.08040315f, 0.07778009f, 0.11362757f, 0.06099153f, -0.03888080f, -0.06244277f, 
    -0.05944940f, -0.01348114f, -0.01746032f, -0.12532429f, 0.14794360f, 0.01429815f, 0.15677232f, -0.23363777f, 
    0.06208517f, -0.00049310f, 0.05075074f, 0.05276573f, -0.11421912f, 0.01259857f, -0.02563349f, 0.09704902f, 
    -0.19553126f, 0.06597272f, 0.14822517f, 0.23780781f, 0.05886462f, -0.00345849f, -0.06070422f, 0.08771432f, 
    0.01122538f, 0.11312218f, 0.07237195f, 0.03623956f, 0.03009932f, -0.16688693f, -0.05040303f, 0.03906811f, 
    -0.02629430f, 0.07184190f, -0.00809347f, 0.00267354f, 0.03669922f, -0.15035658f, -0.04538895f, -0.00581528f, 
    0.09312756f, 0.00148652f, -0.12548313f, 0.10002077f, -0.02580291f, 0.05342681f, -0.03478651f, -0.08858667f, 
    0.03905166f, 0.00602653f, 0.17257771f, -0.16278285f, -0.26120362f, -0.05577050f, -0.28256032f, 0.09522632f, 
    -0.02745166f, -0.07229274f, 0.09342127f, -0.10972564f, 0.11675248f, -0.04962352f, -0.04573625f, 0.15663491f, 
    -0.22343832f, -0.21395592f, 0.06127286f, 0.26601261f, 0.02127313f, -0.00782795f, -0.08581931f, -0.03433142f, 
    0.05721446f, -0.07766835f, 0.00404090f, -0.04785822f, 0.15618658f, -0.12907819f, 0.13311605f, -0.14367977f, 
    0.14794242f, 0.06747814f, -0.03149307f, -0.02405265f, -0.06663901f, -0.03535142f, 0.04157514f, 0.06482528f, 
    -0.22089848f, -0.22761706f, 0.01079583f, 0.04202456f, 0.04735020f, 0.01314031f, 0.12525037f, 0.14823630f, 
    -0.07553064f, 0.04640279f, -0.11336096f, -0.03850198f, 0.05273363f, 0.04162428f, 0.20307368f, -0.14504056f, 
    0.09112114f, -0.09190875f, 0.08558319f, -0.05419867f, 0.08681640f, 0.06785536f, -0.12278204f, 0.02479781f, 
    -0.04506122f, 0.07809399f, -0.16090415f, 0.00851007f, -0.00951282f, 0.03664617f, -0.03462153f, -0.15339078f, 
    -0.12848786f, 0.00068764f, -0.01694184f, -0.14700146f, 0.04509259f, 0.16108596f, 0.02902840f, 0.16988717f, 
    -0.00751216f, -0.05331564f, -0.03619080f, 0.00629458f, 0.04774741f, 0.04411920f, -0.03469990f, -0.04017088f, 
    -0.16872910f, -0.00259014f, -0.10800800f, 0.07053149f, 0.03900187f, -0.15734889f, -0.04441373f, -0.03610727f, 
    -0.05686326f, 0.02928383f, 0.02162093f, -0.01733364f, 0.01264410f, -0.03108509f, -0.10425354f, -0.07274424f, 
    -0.14970870f, 0.01233784f, 0.00070104f, -0.04867660f, 0.03958522f, 0.01100380f, 0.01400791f, 0.01846244f, 
    0.00712986f, 0.15432595f, 0.12419036f, 0.14164533f, 0.05015259f, 0.06570137f, -0.05460693f, -0.02096022f, 
    -0.02571443f, -0.04838359f, -0.03469785f, -0.01686606f, 0.01098064f, -0.07928149f, -0.06817389f, 0.00577234f, 
    -0.02763908f, -0.04841139f, -0.01423013f, -0.01475879f, -0.02398662f, 0.02270385f, -0.13660681f, 0.00004825f, 
    0.11402140f, -0.02459336f, 0.11955085f, 0.09777724f, 0.03486369f, 0.09331161f, 0.01112550f, -0.08699003f, 
    -0.02111381f, 0.01445960f, -0.06766053f, -0.01833011f, 0.15171990f, 0.24626021f, 0.19697134f, 0.06116999f, 
    -0.05824642f, -0.01287827f, 0.04840473f, -0.03149080f, -0.07996436f, 0.03819083f, -0.00585136f, -0.05717707f, 
    0.19126025f, 0.06792229f, 0.13823982f, 0.03675072f, 0.01038451f, -0.00182370f, 0.01525556f, 0.10860781f, 
    -0.02908819f, 0.05318410f, 0.05115380f, -0.01417938f, -0.02338764f, -0.21414149f, -0.11172665f, -0.15324175f, 
    -0.01180498f, -0.03100580f, 0.04533420f, -0.07667585f, 0.01693211f, -0.02830471f, 0.03133609f, -0.06460559f, 
    -0.04504003f, 0.01097413f, -0.10439371f, -0.11240138f, -0.12023003f, 0.04705577f, -0.01995207f, -0.11209495f, 
    0.04987317f, 0.05213297f, 0.02249179f, -0.07927339f, 0.06358774f, 0.12064965f, 0.05511308f, 0.14052722f, 
    0.03624053f, -0.07241943f, -0.02635602f, 0.04743486f, 0.01070462f, -0.04601834f, -0.08038701f, -0.07252593f, 
    0.18623279f, 0.10845346f, 0.13374147f, 0.01735263f, -0.07975132f, -0.04011628f, -0.00684842f, -0.00138493f, 
    0.05251696f, -0.00864474f, -0.09244026f, -0.04671545f, 0.10702179f, 0.19893539f, 0.12088777f, 0.19685657f, 
    0.06157964f, 0.08328249f, 0.00090206f, -0.01759964f, -0.01189269f, 0.01674992f, -0.07210545f, -0.08807009f, 
    0.18340461f, -0.02298403f, 0.07501518f, 0.11470471f, 0.11572038f, 0.07394692f, 0.00370114f, -0.03454695f, 
    -0.10278704f, -0.04906756f, 0.00328425f, -0.08248114f, -0.19753547f, -0.00005355f, -0.05653369f, 0.03442201f, 
    -0.05800210f, -0.00715147f, -0.05877926f, 0.00624603f, -0.08890817f, 0.01777940f, 0.02368283f, -0.00219440f, 
    0.03165128f, -0.02889100f, -0.07762273f, -0.12231213f, -0.03981719f, -0.06414960f, -0.06011757f, -0.11225971f, 
    -0.03029720f, -0.06597330f, -0.00869421f, -0.07254721f, -0.09029018f, -0.10336764f, 0.05904527f, 0.13631044f, 
    0.04464508f, -0.08085419f, -0.07793031f, -0.00074936f, -0.05296914f, -0.01912643f, 0.00032785f, 0.02187302f, 
    -0.09673126f, 0.04972611f, -0.08992262f, 0.19809459f, -0.09071138f, -0.08791357f, -0.04384613f, 0.04312002f, 
    -0.00132822f, 0.01122990f, -0.05504655f, 0.03812889f, -0.13430044f, 0.16429070f, -0.10219325f, 0.14567925f, 
    0.08267081f, -0.00488720f, -0.04577374f, -0.00950322f, -0.02154738f, -0.00213796f, -0.00031293f, -0.00319207f, 
    -0.23419648f, 0.02051682f, -0.17553402f, -0.10233103f, 0.03161906f, -0.02540257f, -0.10132279f, -0.01401335f, 
    0.05133078f, -0.02071691f, -0.03302929f, 0.05061997f, 0.17471859f, 0.15687938f, 0.08643909f, 0.18945372f, 
    0.11730877f, 0.06556124f, 0.07009596f, -0.00825086f, 0.02981247f, 0.03048417f, -0.03486528f, 0.03197199f, 
    -0.17497578f, 0.11921326f, 0.05142907f, -0.00838498f, 0.00756252f, -0.04427296f, -0.01957787f, -0.11525863f, 
    -0.00491574f, -0.00162535f, 0.02440788f, -0.02298036f, -0.34024581f, 0.19430238f, 0.01982503f, -0.14107685f, 
    -0.11136838f, -0.00182271f, 0.07277356f, -0.05948361f, -0.01416430f, -0.06300113f, -0.03246161f, -0.06416369f, 
    0.14749852f, 0.12448477f, 0.15203393f, 0.01633630f, 0.03079411f, 0.00819871f, 0.01812512f, 0.04144618f, 
    -0.01976315f, 0.10867944f, -0.00621374f, -0.08757856f, -0.26110658f, 0.07427306f, -0.01791982f, -0.11544607f, 
    -0.05786597f, -0.11240270f, -0.00161677f, -0.06382205f, -0.08762993f, -0.02445710f, 0.02144626f, 0.00121334f, 
    -0.03931138f, 0.08701530f, 0.09005345f, 0.23433122f, -0.08403460f, 0.02341094f, -0.06377222f, 0.00999284f, 
    -0.02076626f, 0.00581673f, -0.02968761f, 0.03624961f, -0.28129438f, -0.11336042f, -0.08105924f, 0.13007662f, 
    -0.04621744f, -0.01725438f, -0.03634241f, -0.04507388f, -0.08375974f, -0.02090095f, 0.01438571f, -0.02076462f, 
    0.07016785f, 0.05363473f, -0.10794000f, -0.01433621f, -0.08856104f, -0.01137531f, 0.06518205f, -0.01929114f, 
    -0.02657415f, 0.00543907f, -0.01818366f, 0.01228603f, -0.16390184f, -0.06549152f, -0.09269785f, -0.29618543f, 
    0.05191633f, 0.00729208f, -0.06366204f, -0.04429397f, -0.08563649f, 0.02103292f, -0.01036441f, -0.08534325f, 
    0.17424573f, 0.02423881f, -0.05788122f, -0.02389816f, -0.09336508f, -0.07737887f, 0.01407321f, -0.10254349f, 
    -0.06358033f, -0.04039643f, -0.01328339f, -0.00978241f, -0.03522297f, 0.11702456f, -0.04448839f, 0.08948573f, 
    0.06919093f, -0.05801336f, 0.01742982f, 0.03961293f, 0.00721289f, 0.03705210f, -0.02482006f, -0.01706141f, 
    0.24273767f, -0.15966608f, 0.15673792f, -0.13628049f, -0.08505734f, -0.02907695f, -0.02602326f, -0.04043980f, 
    -0.00696585f, 0.05374427f, -0.00938444f, 0.00890966f, -0.35435525f, 0.10732908f, -0.06239792f, -0.01316461f, 
    0.07570792f, 0.03846492f, -0.06262352f, 0.03715080f, 0.02170073f, -0.05064377f, 0.02367811f, -0.03930070f, 
    -0.25125328f, 0.06146847f, -0.06627984f, -0.18683492f, 0.05652047f, -0.02131237f, -0.13179708f, -0.00775824f, 
    -0.04901193f, 0.01243638f, -0.04809766f, -0.10156906f, 0.01806603f, 0.13478205f, -0.03280270f, -0.10619616f, 
    -0.07121003f, -0.00103636f, -0.06348766f, -0.01561131f, -0.06912858f, 0.05266256f, -0.05093362f, -0.09787352f, 
    0.01659069f, -0.14300022f, -0.03004539f, -0.07725820f, 0.00233598f, -0.10584331f, 0.02568105f, -0.07091138f, 
    0.00560338f, -0.02343993f, 0.02007710f, 0.05484372f, -0.20685180f, 0.04744633f, 0.17476226f, 0.02965258f, 
    -0.02717813f, 0.07946242f, -0.05008901f, -0.01908595f, -0.09503733f, 0.06610481f, -0.00378414f, 0.02582907f, 
    0.10848828f, 0.12490305f, 0.07169045f, -0.06113080f, -0.02665573f, 0.00381788f, 0.00751398f, 0.01637360f, 
    -0.03416835f, 0.07677410f, -0.01736839f, 0.03388698f, -0.36667201f, -0.02104872f, 0.18488312f, -0.12732910f, 
    -0.07171875f, 0.00436915f, -0.05498264f, -0.07584021f, -0.04301516f, 0.02956699f, -0.05591327f, -0.03927912f, 
    -0.18025827f, 0.04107922f, -0.12826844f, -0.07906557f, 0.07370618f, 0.04008767f, -0.08229272f, -0.00410244f, 
    -0.07497500f, 0.00069925f, 0.07829601f, 0.01883390f, 0.09968425f, 0.10234398f, 0.16505714f, 0.04997629f, 
    0.03383125f, 0.05708994f, 0.04349945f, -0.02443209f, -0.05998627f, -0.05686745f, -0.07025913f, -0.02874356f, 
    0.01761606f, 0.01631474f, 0.03247470f, 0.14948186f, 0.05985487f, -0.06369133f, -0.03115036f, 0.05222653f, 
    0.02034424f, -0.00807747f, -0.02515317f, -0.09719190f, -0.08159158f, 0.10872547f, 0.16169122f, 0.07706703f, 
    0.07435189f, 0.08095866f, 0.04595512f, 0.01049728f, -0.08134031f, 0.02426655f, 0.02783743f, 0.00453057f, 
    -0.04809384f, -0.10840845f, -0.00775961f, -0.04045215f, -0.04117534f, -0.02905891f, 0.04209771f, -0.05513924f, 
    0.03386205f, -0.04283705f, -0.04099080f, -0.00562941f, -0.10264184f, 0.17090453f, 0.02561252f, -0.00892030f, 
    -0.06989648f, -0.02629956f, -0.00942694f, -0.01630830f, -0.04426169f, 0.00158144f, -0.04243438f, -0.09281841f, 
    -0.06975886f, 0.07099931f, -0.05216375f, -0.04288656f, -0.06677146f, 0.02439293f, -0.00620428f, -0.02034962f, 
    -0.09886218f, -0.02352072f, -0.12112959f, -0.09057127f, -0.02111228f, 0.00739178f, 0.03509771f, -0.00963087f, 
    -0.04648422f, 0.04093043f, -0.01390355f, -0.00646321f, -0.01341802f, -0.03244367f, 0.00916935f, 0.03238275f, 
    -0.01585869f, 0.14950147f, -0.15439636f, 0.17027737f, -0.08745997f, -0.03182364f, -0.09240463f, -0.06870304f, 
    -0.06977314f, -0.01087912f, 0.05011515f, -0.02797598f, 0.12760779f, -0.07206039f, -0.18254834f, 0.01720612f, 
    -0.03764848f, -0.01767294f, -0.01072953f, -0.12109864f, -0.02889591f, -0.05049760f, 0.09124049f, -0.01373505f, 
    -0.02856081f, -0.03303284f, 0.04238730f, 0.10731865f, 0.00499379f, -0.07367954f, -0.03041685f, -0.09483050f, 
    -0.02902694f, -0.03295381f, -0.01733329f, -0.02754023f, 0.16031381f, -0.05103702f, 0.13146819f, 0.07010982f, 
    0.11682456f, 0.10607882f, 0.02421541f, -0.04035537f, -0.06357293f, 0.07241745f, -0.03412342f, 0.00287881f, 
    -0.08211449f, 0.05508823f, -0.03648771f, -0.05729855f, -0.05894784f, -0.06269895f, -0.03521797f, -0.00722158f, 
    0.07868646f, 0.04762236f, -0.02136147f, -0.04898230f, 0.04956901f, -0.27880806f, -0.10782602f, -0.09498403f, 
    -0.03566566f, -0.03949747f, -0.00239729f, 0.01985748f, -0.02858229f, 0.00857129f, 0.03108439f, -0.03385909f, 
    0.29852444f, 0.04101604f, 0.11747210f, 0.12349619f, 0.11724047f, 0.07275284f, 0.06745997f, -0.01934989f, 
    -0.01842777f, -0.09794050f, 0.01681789f, -0.01403665f, 0.19145569f, -0.28496066f, 0.12143951f, 0.05413072f, 
    -0.09161515f, -0.01537916f, 0.02935208f, -0.08476962f, -0.01859601f, -0.02340029f, -0.03532873f, -0.00125133f, 
    -0.11746293f, 0.21538416f, -0.09041237f, -0.02669978f, -0.12063013f, 0.02737181f, 0.07889078f, -0.04548028f, 
    -0.10201636f, -0.02708629f, 0.04341361f, 0.03831847f, 0.09333754f, -0.21400370f, 0.00293889f, 0.21195732f, 
    -0.06450350f, -0.11256967f, -0.05720863f, -0.02959407f, -0.10771534f, -0.11288379f, -0.09348935f, -0.07987129f, 
    0.08388001f, 0.04830918f, 0.08028752f, 0.09521735f, 0.01819704f, -0.03089877f, 0.01733423f, 0.02980620f, 
    -0.02178909f, -0.04146529f, -0.00952701f, -0.05601265f, 0.13807023f, 0.19813061f, 0.08300593f, 0.09657843f, 
    0.03517940f, 0.05592097f, 0.07222586f, 0.00945443f, 0.01977891f, 0.10707942f, -0.03245259f, -0.03081565f, 
    -0.02437844f, -0.20519243f, -0.04881690f, 0.12508930f, -0.12064949f, -0.09127767f, -0.08320894f, 0.01629333f, 
    0.00527523f, -0.08711869f, -0.05032546f, -0.10611062f, 0.18259378f, -0.10902043f, -0.10514148f, -0.05965112f, 
    -0.05722700f, -0.08539928f, 0.01632451f, -0.00936419f, 0.04415115f, 0.02678368f, -0.04532211f, -0.08127390f, 
    -0.09439421f, 0.05997213f, -0.01119221f, -0.01294561f, 0.06990705f, -0.08625580f, 0.02022997f, -0.05497923f, 
    -0.05228685f, -0.03281135f, -0.01522680f, -0.01564725f, 0.07226533f, 0.00792967f, -0.10810649f, -0.06215618f, 
    0.01889223f, -0.06397183f, 0.01631051f, -0.05828224f, -0.04191570f, -0.02452794f, -0.02867252f, -0.03879618f, 
    -0.05407393f, 0.03412661f, 0.12431383f, 0.10301734f, -0.12032276f, 0.00392783f, 0.02335053f, -0.02505217f, 
    0.00012441f, 0.06031290f, -0.02553756f, -0.01462796f, -0.11624470f, 0.27952072f, -0.15963212f, -0.23996942f, 
    0.01774607f, -0.07971088f, 0.00106886f, -0.02920903f, 0.03573386f, -0.02152550f, 0.09976888f, 0.06861927f, 
    0.01201567f, 0.04049157f, -0.19680107f, -0.17665665f, 0.09822842f, -0.03825779f, -0.00596184f, 0.01475189f, 
    0.02337622f, -0.04818699f, 0.06774692f, 0.05034210f, -0.12928051f, -0.03687098f, 0.06601792f, 0.14979920f, 
    0.05685696f, 0.06639924f, -0.08028423f, -0.02664327f, -0.02462292f, 0.09917077f, 0.09642348f, 0.09222779f, 
    -0.18691681f, 0.11731635f, 0.02351142f, -0.16459273f, -0.06301241f, 0.01014803f, -0.01083652f, -0.09057272f, 
    0.02769828f, 0.06281978f, -0.02528879f, -0.00615008f, -0.17906064f, -0.08068011f, -0.09544370f, -0.01378958f, 
    -0.08345247f, -0.01714712f, -0.03123039f, -0.04781029f, -0.01306904f, -0.02490882f, 0.01811169f, 0.09241526f, 
    -0.11511479f, 0.03682184f, -0.04063737f, -0.12912454f, -0.00104753f, 0.04346185f, 0.06653494f, 0.00136441f, 
    -0.01655185f, -0.04255244f, 0.01643351f, 0.00189437f, -0.05327288f, 0.08924653f, 0.03884405f, -0.07171050f, 
    0.00606870f, 0.07915992f, -0.08536503f, 0.04145092f, 0.10750990f, -0.06271494f, 0.01951327f, 0.03427339f, 
    0.05272901f, -0.14872853f, 0.01144164f, -0.14506534f, -0.04766180f, 0.02352163f, 0.11810242f, -0.14289424f, 
    0.04217254f, 0.09474547f, -0.10093798f, 0.05597462f, 0.13753314f, 0.00437960f, -0.17892501f, -0.04806847f, 
    0.05426450f, 0.08881038f, 0.01336830f, 0.09316573f, 0.02158870f, -0.06948885f, 0.10196512f, 0.06118327f, 
    0.18326330f, 0.17149925f, -0.04650507f, 0.07793371f, -0.09354667f, -0.04336921f, -0.04101845f, -0.00396047f, 
    -0.02951659f, 0.02888846f, 0.05963640f, -0.01980397f, -0.07294323f, 0.28298795f, -0.16545607f, -0.13697663f, 
    0.05476595f, -0.02881606f, -0.16712546f, 0.07863190f, 0.05623814f, -0.01253671f, 0.04194888f, -0.01541528f, 
    -0.20669681f, -0.03710816f, -0.10589110f, -0.27498543f, -0.04327793f, -0.08325218f, -0.05844242f, -0.06879694f, 
    -0.00162353f, -0.08362284f, 0.00343757f, 0.06520397f, -0.26704979f, 0.02057450f, 0.14187135f, -0.02567933f, 
    -0.05061352f, 0.04414620f, 0.02484146f, 0.04046236f, -0.06420260f, -0.03191674f, 0.00697030f, -0.05970458f, 
    0.00537536f, -0.05390931f, -0.02246195f, -0.19563130f, 0.05287973f, -0.02866931f, 0.07038409f, 0.02654100f, 
    0.12026282f, -0.01355389f, -0.11657097f, -0.02928468f, -0.04912835f, 0.09896075f, -0.02939699f, -0.11813566f, 
    -0.03755880f, -0.03868835f, -0.08328500f, -0.04062298f, 0.07432833f, 0.10214891f, 0.09471971f, -0.08470771f, 
    0.09543449f, -0.02865011f, 0.12211326f, 0.12311632f, 0.08471757f, -0.00692329f, -0.01206439f, -0.12718059f, 
    0.00722085f, -0.07279827f, 0.01454905f, 0.00281157f, -0.23167764f, -0.17049648f, -0.19115087f, -0.23203878f, 
    -0.01015864f, -0.02537121f, -0.12716696f, 0.06005552f, 0.04152092f, 0.05502781f, 0.08458026f, 0.07507354f, 
    0.08656906f, 0.25858945f, -0.30703601f, -0.03433352f, 0.01358041f, -0.05275585f, 0.00886209f, -0.07949674f, 
    0.02999219f, -0.10860283f, -0.06862945f, 0.01453800f, 0.00664311f, 0.06600461f, -0.01535416f, 0.08678818f, 
    -0.07193128f, -0.06067915f, -0.07757287f, 0.00715918f, 0.08127737f, -0.00566161f, -0.02399100f, -0.06977981f, 
    0.07911807f, 0.24084742f, -0.07630993f, 0.00693107f, -0.07960858f, 0.03778001f, -0.05084113f, -0.09397911f, 
    0.05515902f, -0.06446599f, -0.06194911f, 0.08131402f, 0.00559686f, -0.16504715f, 0.14551096f, -0.02675790f, 
    0.08597885f, -0.11048484f, 0.04820509f, -0.02009533f, -0.09236705f, -0.02201020f, 0.06035873f, -0.04008150f, 
    -0.01479829f, -0.07008760f, 0.20560439f, 0.13895215f, -0.07639281f, 0.02586439f, 0.04884749f, -0.18040654f, 
    -0.06670704f, -0.02205274f, 0.06722648f, 0.01505697f, 0.16192424f, 0.01155659f, -0.01410547f, 0.08415565f, 
    0.09321250f, -0.09345748f, -0.02752992f, -0.01927332f, -0.09395982f, 0.00430381f, 0.01406355f, 0.09273577f, 
    0.01221561f, -0.13799740f, -0.00093190f, -0.00931340f, -0.06583776f, -0.06308447f, 0.08481783f, -0.11412133f, 
    0.01566651f, -0.04793635f, -0.13513778f, 0.00999948f, 0.07214643f, 0.01300873f, -0.00454894f, 0.09711529f, 
    0.07226428f, 0.06706473f, -0.08681797f, -0.08219343f, 0.05308974f, 0.00022792f, 0.05312142f, 0.06000671f, 
    -0.10194586f, -0.11751222f, -0.27279219f, 0.00553738f, -0.04854633f, 0.07985250f, -0.01089270f, -0.06062373f, 
    0.01640940f, -0.11730952f, 0.04829989f, -0.13240859f, -0.16891961f, -0.06169866f, -0.01860979f, 0.17717455f, 
    0.06418956f, 0.05407389f, 0.02534086f, -0.04963465f, 0.00631168f, 0.07192687f, -0.01408856f, 0.04588617f, 
    0.05936667f, 0.02764908f, -0.08018658f, -0.06294023f, 0.00986002f, 0.01145143f, -0.04911954f, 0.02679062f, 
    0.00772880f, -0.04759013f, -0.00821702f, -0.14422671f, 0.04378658f, -0.10488854f, -0.01401413f, 0.05873739f, 
    0.06164970f, -0.03331998f, -0.06958758f, 0.02126137f, 0.05393301f, 0.01172711f, -0.05986206f, 0.01659685f, 
    -0.04370755f, -0.10791606f, 0.04471947f, -0.08840287f, -0.01321398f, -0.05982347f, -0.06251524f, 0.08030719f, 
    0.00211353f, 0.05721135f, -0.10020404f, -0.04399252f, 0.01151174f, 0.21648824f, -0.17178968f, 0.07269350f, 
    0.10999510f, -0.06375448f, 0.01379945f, 0.04797465f, -0.02381518f, -0.10177793f, 0.05435938f, 0.10542359f, 
    -0.11389007f, 0.04962261f, 0.03531896f, -0.03615836f, -0.08802111f, 0.00989123f, -0.08292890f, -0.02432708f, 
    -0.03043428f, 0.07374533f, 0.04804965f, 0.08661488f, 0.02994288f, 0.06436676f, -0.07944852f, 0.03225259f, 
    0.02267063f, 0.01232777f, -0.09886319f, -0.02724526f, 0.04985037f, -0.02564565f, -0.01780027f, 0.01938394f, 
    0.11817171f, 0.02190607f, -0.07947194f, 0.04579603f, 0.10512219f, -0.03959376f, -0.04786637f, -0.07560926f, 
    -0.06017893f, 0.05895683f, -0.06359836f, -0.01635224f, -0.11223587f, 0.02537436f, 0.12486906f, 0.03718986f, 
    -0.04895591f, -0.03938439f, 0.02889484f, 0.02172635f, 0.05736749f, -0.10060608f, 0.01034153f, -0.00736917f, 
    0.04069080f, -0.00337559f, -0.01978006f, -0.00808240f, 0.06885825f, 0.03573957f, 0.00646644f, -0.09200697f, 
    0.06728057f, -0.00261897f, -0.01545760f, -0.03354078f, -0.13133693f, 0.05074895f, 0.21931691f, -0.01939575f, 
    0.06285318f, -0.00726899f, -0.01068477f, 0.06632949f, -0.02073503f, 0.05010253f, 0.04659702f, -0.19432239f, 
    -0.01537412f, -0.09156013f, 0.07640762f, 0.02537790f, 0.03190468f, 0.07197974f, 0.02894769f, 0.00059198f, 
    0.11336587f, 0.02573762f, -0.01006085f, -0.05264775f, 0.08817889f, -0.23210330f, 0.15913559f, 0.14798814f, 
    -0.12924205f, -0.00966967f, -0.07781300f, 0.00855469f, 0.08424838f, -0.12465146f, -0.04226010f, 0.00606531f, 
    -0.01556938f, -0.14789128f, -0.00535955f, 0.04483653f, 0.12253726f, 0.02672552f, 0.03850444f, -0.01446925f, 
    0.08463392f, 0.02650241f, 0.07377595f, -0.07825555f, 0.03546509f, 0.13680312f, 0.00178260f, 0.11987071f, 
    -0.05320400f, 0.03048092f, 0.03476126f, 0.06967237f, 0.03742759f, -0.06364050f, 0.07360338f, -0.03358698f, 
    -0.28202394f, 0.07102181f, -0.10665408f, -0.16628146f, -0.00087005f, -0.00883057f, -0.20575409f, -0.05811476f, 
    0.06503244f, -0.03837788f, 0.05667946f, 0.05112884f, -0.23122378f, 0.02253115f, 0.12660725f, 0.13310800f, 
    -0.07277768f, -0.08790963f, -0.09827046f, -0.21534446f, -0.02531902f, -0.05566458f, -0.06338017f, -0.13023296f, 
    0.02165336f, -0.01092152f, 0.02412923f, -0.00284682f, -0.01299225f, -0.14839700f, -0.04482542f, -0.02798177f, 
    -0.03424855f, -0.02884118f, 0.05706738f, -0.12299058f, 0.03799619f, -0.15301172f, -0.00959690f, 0.16353221f, 
    -0.01888164f, -0.04338247f, -0.06188013f, -0.06342817f, -0.08725713f, 0.01660232f, 0.06961883f, -0.03173449f, 
    0.09270307f, -0.02700402f, 0.05103021f, 0.07956452f, 0.02327484f, -0.05447328f, 0.05062661f, -0.05175920f, 
    0.02253880f, -0.06989836f, 0.04227767f, 0.03856363f, 0.11308856f, -0.02074362f, -0.01721227f, -0.04344910f, 
    0.01274102f, -0.00119447f, 0.08091310f, 0.00593100f, -0.08634617f, -0.02598480f, -0.07929233f, -0.03167093f, 
    -0.19562413f, 0.08919799f, -0.15199073f, -0.12074970f, 0.02131278f, 0.01743016f, 0.00871571f, 0.02287236f, 
    0.14097176f, 0.10863655f, -0.00718805f, -0.03498444f, -0.07436785f, -0.12311943f, -0.07953136f, -0.02017318f, 
    0.03593148f, 0.01933089f, -0.06860482f, -0.00194835f, 0.00764979f, 0.02837716f, 0.07289020f, -0.18020542f, 
    0.05374991f, 0.01382076f, -0.06154337f, 0.03512562f, -0.05122116f, -0.04286562f, -0.25717834f, -0.02841258f, 
    -0.00839105f, -0.04949426f, 0.09385178f, -0.10496135f, -0.16049165f, -0.09857263f, 0.22732036f, 0.02589183f, 
    -0.09038642f, -0.12216154f, 0.10284757f, -0.16903506f, 0.01849792f, -0.05460280f, -0.01784587f, -0.02012958f, 
    0.06828725f, 0.25330478f, 0.00627420f, 0.02468100f, -0.08669139f, -0.00119563f, -0.01399637f, 0.00342548f, 
    -0.02257832f, -0.04814407f, 0.01641452f, -0.01807315f, 0.10130480f, -0.03200203f, -0.36259678f, 0.11601291f, 
    0.09387775f, -0.02206338f, -0.00059087f, -0.07295692f, 0.10490393f, -0.02130200f, 0.18428899f, -0.02363378f, 
    0.21652102f, 0.06360107f, -0.08845029f, -0.04975288f, 0.01009094f, -0.00591903f, 0.05174245f, -0.03733537f, 
    -0.04663259f, -0.02367485f, 0.04332587f, 0.05062977f, -0.13278903f, -0.27763510f, -0.02115615f, 0.07001863f, 
    0.10295621f, -0.06960622f, -0.03245235f, -0.08142167f, 0.08469797f, 0.09771590f, 0.04149583f, -0.01665734f, 
    -0.00546940f, -0.14288558f, 0.04829524f, -0.00302818f, 0.02190674f, -0.06018990f, -0.05663668f, -0.00296313f, 
    0.03023741f, -0.03551555f, -0.03187866f, -0.11192811f, 0.03052230f, -0.09773663f, -0.20101336f, -0.35645357f, 
    -0.02811777f, 0.08782464f, -0.07898248f, 0.03520648f, 0.05413339f, 0.10758257f, -0.01095902f, 0.08253406f, 
    -0.07501792f, 0.01825340f, 0.12117600f, -0.26675892f, -0.01484857f, 0.02609237f, 0.01526755f, -0.08497872f, 
    -0.01764249f, -0.02240534f, -0.17011672f, 0.14564745f, -0.02631161f, 0.17984270f, 0.00676735f, 0.14358735f, 
    -0.05102633f, 0.04361056f, -0.08457164f, -0.00800043f, 0.02445434f, -0.09167978f, 0.02575086f, -0.06264948f, 
    0.24184404f, 0.14586893f, -0.29890224f, -0.17974953f, 0.03935245f, 0.06654429f, -0.06954056f, -0.03251216f, 
    0.04507295f, 0.08345817f, -0.03943066f, 0.02195296f, -0.20277487f, -0.15130843f, 0.04982087f, 0.01118468f, 
    0.02215813f, -0.05366479f, -0.05958848f, 0.06819526f, 0.02815874f, 0.13438086f, -0.10571343f, 0.05182584f, 
    -0.01763345f, 0.04428942f, -0.02687573f, 0.04677160f, 0.01554510f, 0.01962892f, -0.12152825f, -0.01226692f, 
    -0.03741284f, -0.05808952f, 0.14222406f, 0.03882804f, 0.11164206f, -0.13321488f, 0.07320052f, -0.05081185f, 
    0.02288674f, -0.10033017f, -0.09710094f, 0.04735183f, 0.01245665f, 0.05500983f, 0.05306786f, 0.00670495f, 
    0.09341959f, 0.48566326f, -0.49449331f, -0.15359378f, 0.08932190f, 0.02176738f, -0.01827405f, -0.10372771f, 
    -0.18203843f, -0.03172810f, 0.05744235f, -0.07559274f, -0.07051882f, -0.11485827f, 0.18555652f, -0.13616191f, 
    0.01343430f, -0.02880074f, -0.08153078f, 0.01859928f, -0.05552940f, -0.03915108f, -0.01382377f, -0.12188259f, 
    0.05765092f, 0.06802143f, 0.18593906f, -0.21528797f, -0.03675795f, -0.00141819f, -0.11634440f, -0.06249977f, 
    -0.06402073f, 0.01194349f, -0.04751074f, -0.03412807f, 0.06885844f, -0.12344531f, -0.09357691f, -0.12806624f, 
    0.07612302f, -0.01763760f, -0.00504653f, 0.02064755f, -0.15028970f, -0.04021888f, -0.11625211f, -0.10480230f, 
    -0.11139343f, -0.13329504f, -0.02470572f, 0.00784620f, 0.02136389f, 0.01820941f, -0.02433316f, -0.04500009f, 
    -0.06568513f, -0.09235626f, -0.19127341f, -0.08212196f, -0.04605344f, 0.34795687f, -0.20033433f, -0.20538367f, 
    0.06169647f, -0.02952443f, 0.05043698f, 0.03447134f, -0.08571571f, 0.04556272f, -0.03600801f, 0.05740981f, 
    -0.06076610f, -0.19816370f, -0.13598539f, 0.17888910f, 0.01998272f, -0.05908247f, -0.01688389f, -0.05202059f, 
    0.06251815f, 0.02235913f, -0.06804510f, -0.10460932f, -0.26008803f, -0.19756204f, 0.01921054f, -0.02854331f, 
    -0.00902099f, 0.07289516f, 0.01292406f, -0.07484056f, 0.03149446f, 0.18478489f, -0.09817892f, 0.08578445f, 
    0.05782510f, -0.02210771f, -0.00320854f, 0.12669465f, 0.04053601f, 0.05145340f, -0.05121863f, -0.08501390f, 
    -0.05949399f, -0.04022485f, 0.02534695f, 0.06415867f, 0.05827783f, -0.06003302f, 0.19355945f, 0.13115174f, 
    0.04682574f, 0.07375824f, -0.02646633f, -0.12367965f, -0.03475899f, -0.11159851f, 0.00193410f, -0.16927513f, 
    -0.02120372f, 0.12645809f, -0.10725523f, 0.14582488f, 0.14679700f, -0.01564554f, 0.03149065f, -0.00073332f, 
    0.03050680f, -0.00265695f, -0.06103876f, 0.01750727f, -0.12633938f, -0.16556625f, 0.15482688f, -0.01949432f, 
    0.01908450f, 0.12880535f, -0.00865579f, 0.07570309f, 0.02156886f, 0.10665207f, 0.00456284f, -0.02248123f, 
    -0.06001553f, -0.08246873f, -0.00526288f, 0.05597722f, -0.04221867f, 0.04719812f, 0.07956660f, -0.01597274f, 
    -0.00592691f, 0.03757663f, 0.12700097f, -0.06166653f, 0.07554934f, -0.08441716f, 0.03627233f, 0.05124984f, 
    0.02696506f, -0.00322220f, -0.07467710f, 0.11777492f, -0.01844059f, -0.11458241f, -0.08928731f, 0.00623119f, 
    -0.18902178f, -0.14331722f, 0.16970903f, 0.06798407f, 0.18092175f, -0.05466697f, -0.03953021f, -0.03608967f, 
    0.03267686f, 0.04922703f, 0.10239416f, 0.16806111f, -0.12660466f, 0.19733855f, 0.02623676f, -0.27297166f, 
    -0.03907994f, -0.01589679f, 0.04870271f, 0.04786952f, 0.10929728f, 0.00347872f, -0.05473385f, -0.04739426f, 
    0.24618557f, 0.08184154f, -0.01453760f, -0.18893394f, 0.00905739f, 0.01872915f, 0.00773386f, 0.01319472f, 
    0.02399863f, 0.00545888f, -0.03808540f, 0.04057264f, -0.00614562f, -0.39119950f, -0.08277496f, -0.09428210f, 
    -0.11293763f, 0.02138393f, 0.01128639f, 0.06522272f, -0.00020119f, -0.02767945f, 0.03793312f, 0.01291428f, 
    -0.10456231f, 0.08155203f, 0.20228118f, 0.03589612f, 0.08334927f, 0.00947364f, -0.13328388f, -0.02552758f, 
    0.02439376f, -0.02427581f, 0.11169055f, 0.07083080f, -0.15987062f, -0.03496764f, -0.14340988f, -0.20881660f, 
    -0.03081106f, 0.02386679f, 0.01607458f, 0.04557173f, -0.01407566f, -0.17588678f, 0.21856101f, 0.03010374f, 
    0.54322833f, -0.01295673f, 0.07765601f, -0.02033740f, -0.03769866f, 0.06843374f, 0.04086158f, 0.09837079f, 
    -0.01580043f, -0.01187154f, -0.01015041f, -0.08021009f, -0.23405696f, -0.08072782f, 0.04330108f, 0.01933881f, 
    0.01841558f, -0.07236315f, -0.05020367f, -0.06710037f, 0.13656132f, 0.06747369f, 0.07580125f, 0.04849476f, 
    0.19041473f, -0.06416636f, -0.06968945f, 0.04050632f, -0.03064884f, -0.06584869f, 0.03784421f, 0.14704201f, 
    0.04185923f, -0.12690187f, 0.02136424f, -0.07172790f, -0.44487011f, 0.10172886f, -0.00341506f, -0.00151547f, 
    0.10462153f, -0.01338737f, 0.13469729f, -0.07337669f, 0.10092554f, 0.02425647f, -0.02081249f, 0.02739609f, 
    0.30569500f, -0.09303749f, -0.08841292f, 0.04822337f, 0.01332341f, -0.02345153f, -0.03270758f, -0.01603899f, 
    -0.06595311f, 0.08024695f, -0.04286370f, 0.02871641f, -0.12814976f, 0.13069977f, -0.17388515f, -0.31003302f, 
    0.14616880f, -0.04810119f, -0.11962448f, 0.02441487f, -0.03720781f, 0.09260193f, -0.07808118f, -0.14591290f, 
    -0.25293553f, 0.03616303f, -0.12240124f, 0.09871124f, -0.04452151f, 0.12325480f, -0.01500515f, 0.03438415f, 
    -0.02285985f, 0.05801912f, -0.13113669f, 0.00892810f, -0.18062714f, 0.06639495f, -0.30738163f, -0.25275102f, 
    0.03332594f, 0.00289105f, -0.02104460f, 0.09635554f, -0.05640708f, 0.03227148f, 0.03992743f, -0.13013539f, 
    -0.18141332f, -0.00441363f, 0.22840956f, -0.04073351f, -0.03625639f, -0.11692620f, 0.07174554f, 0.03538799f, 
    0.10043555f, -0.05735015f, 0.01544338f, 0.10945609f, 0.03162371f, -0.02208570f, 0.15475479f, -0.19707526f, 
    0.08718681f, 0.15935192f, -0.03989289f, -0.08474886f, -0.06958014f, -0.10371843f, -0.00144655f, -0.06978928f, 
    0.02636185f, 0.04746219f, -0.15332393f, -0.16442089f, -0.15057236f, -0.05403883f, 0.11469076f, -0.00164796f, 
    0.11292873f, -0.02496995f, -0.01372263f, -0.01067160f, -0.13321774f, -0.23420332f, 0.31528172f, -0.22954118f, 
    -0.03846726f, -0.02848415f, 0.10827291f, -0.03724306f, 0.04096860f, 0.02211750f, 0.08580691f, 0.08187057f, 
    0.17711696f, -0.17147511f, -0.05503118f, 0.01289790f, 0.05655394f, -0.06967252f, 0.10904239f, -0.06479860f, 
    0.12063795f, -0.00238383f, 0.02752896f, -0.09198385f, -0.28819650f, 0.39836228f, 0.08604185f, 0.01632678f, 
    0.10942341f, 0.08044607f, -0.06085108f, 0.05519253f, -0.04146261f, -0.01585314f, 0.07632221f, -0.06802284f, 
    -0.08089800f, 0.02308061f, -0.09034090f, -0.00183575f, -0.00455211f, 0.06225441f, 0.06039631f, -0.09300668f, 
    0.13373965f, 0.02446545f, 0.09982716f, 0.02673672f, -0.50631928f, 0.20570761f, 0.06625986f, 0.01600445f, 
    0.10253175f, -0.14869452f, 0.05306965f, -0.01241349f, -0.04271993f, 0.15463595f, 0.02834269f, 0.04871020f, 
    0.08048636f, -0.12317427f, -0.05293150f, -0.19673122f, 0.18150559f, 0.03301072f, 0.00168343f, -0.10651820f, 
    -0.10770997f, -0.13979034f, -0.10488552f, 0.07529072f, -0.17367631f, -0.05385123f, 0.09685661f, -0.03291658f, 
    0.05114893f, -0.00655491f, -0.07046307f, -0.08945416f, 0.10150498f, 0.01671915f, -0.04871802f, 0.12717345f, 
    -0.30278146f, 0.15862080f, 0.03392404f, -0.16906580f, 0.07804015f, 0.03420851f, 0.00319932f, -0.03848541f, 
    -0.08270761f, -0.24450053f, 0.08395591f, 0.02300648f, -0.11777931f, 0.08406184f, -0.05151242f, 0.15578350f, 
    0.05415865f, -0.17056255f, -0.07282088f, -0.08415810f, 0.01815476f, 0.00684348f, -0.04893649f, 0.08439329f, 
    -0.13929108f, 0.05366199f, 0.03864102f, -0.28696415f, -0.00049245f, 0.10486501f, -0.01542524f, -0.05359213f, 
    -0.01617311f, -0.08337415f, -0.07179505f, -0.04449163f, -0.20374663f, -0.21572253f, 0.08436577f, 0.00852093f, 
    0.01072348f, -0.04508060f, -0.12551717f, 0.04168267f, 0.00661850f, 0.01215410f, -0.07838804f, 0.03959804f, 
    -0.02375793f, -0.11777249f, 0.10695002f, -0.09195887f, -0.12317498f, 0.07706644f, 0.11197356f, 0.07131027f, 
    0.00141876f, 0.10343883f, -0.03374272f, 0.04582908f, -0.05205564f, -0.24124299f, -0.14927761f, 0.11406112f, 
    0.05737630f, -0.03147167f, -0.04473173f, 0.10078611f, 0.00330679f, 0.03301167f, 0.11805912f, -0.03295929f, 
    0.16921796f, -0.10572857f, 0.03185208f, -0.05851801f, -0.01974789f, -0.04906596f, -0.04761245f, -0.08613024f, 
    0.03101824f, -0.00521113f, -0.06942333f, 0.20140095f, -0.44409260f, 0.14176668f, 0.01138725f, -0.11559364f, 
    0.02450790f, 0.00194753f, 0.02892232f, 0.09263165f, 0.10777226f, 0.09959634f, 0.02811379f, 0.06875817f, 
    -0.32656515f, 0.32758215f, -0.31487951f, -0.15498269f, 0.08756300f, 0.01968971f, 0.13475345f, -0.05148182f, 
    -0.07009603f, -0.01165551f, 0.14023413f, -0.02643428f, -0.12934956f, 0.10053866f, 0.10380182f, 0.13412885f, 
    0.07571102f, 0.06800608f, -0.02953429f, 0.03140793f, 0.12067498f, 0.21266040f, 0.00095639f, 0.04156255f, 
    -0.00474801f, 0.22091928f, 0.13256823f, -0.04079541f, -0.06624138f, 0.01812047f, -0.05109444f, -0.11715952f, 
    -0.02079100f, -0.14469004f, -0.03644361f, -0.08775399f, -0.06962308f, 0.05130343f, 0.02423216f, -0.23536450f, 
    -0.11722615f, 0.02878626f, -0.02480449f, -0.10292810f, -0.08204819f, 0.05658650f, -0.14014217f, 0.26786107f, 
    0.25115895f, -0.19215117f, -0.11575546f, -0.15432282f, 0.01669766f, 0.00239340f, -0.02463831f, 0.04029757f, 
    -0.06915255f, -0.07112903f, 0.11911467f, -0.07810517f, 0.24231558f, -0.18861730f, 0.08366994f, 0.12384386f, 
    0.08182386f, 0.10093252f, 0.06345687f, 0.13346358f, -0.03742450f, -0.05947717f, 0.03419976f, -0.05313752f, 
    -0.00809930f, 0.00489606f, 0.32434309f, 0.07127172f, 0.02044477f, 0.06417303f, -0.00962164f, 0.15043071f, 
    -0.02033080f, 0.04839655f, -0.05055158f, -0.08114504f, -0.13629819f, -0.03835401f, 0.06187190f, -0.29119027f, 
    -0.00198774f, 0.01729489f, -0.00221832f, 0.07066803f, -0.08046708f, 0.05781873f, 0.01707017f, -0.01996621f, 
    0.27194324f, -0.26357228f, 0.18472035f, -0.06137275f, 0.08697522f, 0.04750008f, -0.11387427f, -0.01102290f, 
    -0.08935892f, -0.00574405f, -0.06747278f, 0.12412570f, 0.03620711f, -0.10822348f, -0.03176317f, 0.07122795f, 
    -0.10626417f, -0.13370930f, 0.05565647f, 0.10503863f, 0.13209234f, -0.01023702f, 0.05739029f, -0.04898687f, 
    -0.25671890f, 0.15713884f, 0.12076820f, -0.07403333f, -0.05650285f, 0.00102731f, 0.07077262f, -0.11586916f, 
    0.07615033f, -0.05793370f, -0.02641387f, -0.03800469f, 0.04155691f, -0.03617392f, -0.06636097f, -0.35588428f, 
    0.08260865f, -0.03799142f, 0.03312733f, -0.14404605f, 0.00614456f, -0.00528961f, -0.05916919f, -0.02120898f, 
    0.01759034f, -0.15651014f, -0.06014622f, 0.23212205f, -0.16045517f, 0.01742257f, -0.02618911f, 0.09955070f, 
    -0.07528649f, 0.02585384f, 0.07456917f, 0.00957373f, -0.14462124f, -0.17476064f, 0.12129697f, -0.11710167f, 
    0.02919905f, 0.06525327f, 0.04327362f, 0.15975587f, -0.03500569f, 0.06260373f, 0.01820409f, 0.02309027f, 
    0.32266054f, -0.04375351f, 0.08717681f, 0.19879286f, 0.00101399f, 0.09173844f, 0.07685354f, -0.00948234f, 
    -0.09339119f, 0.07312289f, -0.02049611f, 0.17667526f, 0.20827116f, 0.06171831f, -0.05035087f, -0.02067826f, 
    -0.06196012f, -0.00837913f, 0.05058209f, 0.01786670f, -0.01027450f, -0.00507599f, -0.07134062f, -0.07004077f, 
    -0.08054855f, -0.11015300f, 0.15173310f, 0.01835733f, -0.03322686f, 0.07364054f, 0.00110894f, 0.02830047f, 
    -0.06459247f, -0.02946960f, -0.21340062f, -0.03454556f, 0.02526556f, 0.15278405f, -0.06420694f, 0.09210636f, 
    -0.02434353f, 0.01101165f, 0.09941667f, 0.03138368f, -0.00019158f, -0.01752758f, -0.05209497f, -0.03855054f, 
    -0.35388437f, -0.23006169f, 0.05126848f, -0.14925785f, 0.08632076f, -0.20508532f, 0.06709141f, 0.05747115f, 
    0.02781395f, 0.09481091f, 0.03375761f, 0.11559658f, 0.13335907f, 0.11504733f, 0.08740778f, -0.03903589f, 
    0.02557220f, 0.04802758f, 0.03908645f, 0.00536312f, 0.02026444f, 0.06439929f, 0.13444591f, -0.01352845f, 
    0.09112713f, 0.09885418f, 0.17687322f, -0.01619738f, 0.10132074f, 0.02753597f, 0.02709550f, 0.06609987f, 
    0.00434428f, 0.03089941f, 0.02721405f, 0.04223668f, -0.49527389f, -0.22388372f, -0.06705237f, -0.24406484f, 
    0.06846771f, -0.01766016f, -0.09281957f, -0.03644336f, -0.02460125f, 0.01786722f, 0.02365115f, -0.05417268f, 
    0.14715818f, 0.10233986f, -0.07131118f, 0.03196793f, 0.02695414f, 0.11698491f, 0.08496208f, 0.00565068f, 
    0.05542555f, 0.11697952f, 0.09381163f, 0.07905214f, 0.17244349f, 0.15622878f, 0.01926392f, -0.05686308f, 
    -0.06437322f, 0.03483043f, 0.01254270f, 0.13688625f, 0.06587545f, 0.10208886f, 0.14007106f, 0.11711206f, 
    0.32229075f, 0.13235493f, -0.01225132f, -0.04080294f, -0.07981829f, 0.03765297f, 0.05144152f, -0.00359460f, 
    -0.07042981f, -0.00731066f, -0.05212828f, -0.00250110f, 0.12896048f, -0.05885977f, -0.05018434f, 0.00481082f, 
    0.04416489f, -0.02606464f, 0.00384303f, -0.03349414f, 0.07506109f, -0.03081971f, 0.02519867f, 0.00827022f, 
    0.15105696f, -0.02774139f, 0.01928315f, 0.06013086f, -0.04598101f, 0.09968583f, -0.06400347f, -0.07265370f, 
    0.09918447f, 0.10355294f, -0.07445596f, 0.00393471f, -0.24733204f, -0.07352970f, -0.06537866f, 0.03054244f, 
    0.00610375f, 0.00200312f, -0.09494853f, -0.08201625f, -0.02203540f, 0.05908748f, 0.00260821f, 0.09914096f, 
    0.03056694f, -0.15573268f, 0.01912894f, -0.07417317f, -0.00165312f, 0.01050613f, 0.02078086f, -0.03435775f, 
    -0.00974164f, 0.09194411f, -0.08754990f, 0.04666087f, 0.06328061f, -0.07661748f, 0.06287486f, -0.07663863f, 
    0.07334141f, -0.04389203f, 0.01095930f, 0.01150437f, -0.07586070f, -0.01073691f, 0.01108586f, 0.03360029f, 
    0.08007767f, 0.10839388f, -0.05131816f, -0.08901621f, 0.13993433f, 0.15962316f, -0.06987866f, 0.01152221f, 
    -0.08721839f, -0.01418807f, 0.05499031f, 0.09483965f, 0.05930150f, -0.04144119f, 0.03275269f, -0.08824036f, 
    -0.06283557f, 0.06854709f, 0.03289267f, -0.15967840f, 0.08129811f, 0.11902002f, -0.01760602f, -0.01034814f, 
    -0.14699158f, 0.07443572f, -0.07954900f, -0.01609822f, 0.01692041f, 0.08234711f, -0.00745808f, 0.01437597f, 
    0.00796128f, 0.04667908f, -0.07569242f, -0.06751055f, 0.14727046f, -0.02962168f, -0.09515539f, 0.12889498f, 
    0.10475042f, 0.05490738f, 0.03267089f, -0.07933822f, -0.00414145f, 0.00041150f, -0.08330705f, 0.06807658f, 
    -0.11733258f, -0.17356543f, -0.02469199f, -0.09021309f, 0.00325830f, 0.00374110f, -0.01813217f, -0.05659211f, 
    0.02236291f, 0.00638264f, -0.09278221f, 0.02875380f, 0.08605549f, -0.00061304f, 0.07821969f, -0.04048994f, 
    0.04414514f, 0.01890923f, -0.00310745f, 0.15265723f, -0.01540545f, -0.03647996f, -0.02566403f, 0.06635213f, 
    -0.26461312f, -0.00648950f, 0.01944018f, 0.00624013f, 0.13099667f, -0.02012056f, -0.05454823f, -0.01777128f, 
    0.05716999f, -0.01284399f, -0.06351165f, -0.02425781f, -0.20582406f, 0.07579003f, -0.06456057f, -0.08280945f, 
    0.15746418f, -0.12509349f, -0.02885523f, -0.13193530f, 0.03779599f, 0.09538395f, -0.09906913f, 0.00954073f, 
    -0.42001164f, -0.26732329f, 0.17226437f, 0.19613814f, 0.06116762f, -0.00071281f, 0.03565524f, -0.04051428f, 
    0.01838919f, 0.06580986f, -0.05755180f, 0.19839728f, 0.05481625f, 0.13299242f, -0.10902154f, 0.09256519f, 
    -0.13175172f, -0.05573867f, 0.06272158f, -0.04769270f, -0.03175082f, -0.06639794f, -0.04512976f, -0.11298485f, 
    0.13644089f, -0.02243376f, 0.05946184f, 0.01974537f, -0.05715539f, 0.02410723f, 0.02560966f, 0.08576146f, 
    0.04439462f, 0.08359888f, 0.02968452f, 0.04930237f, -0.28551066f, -0.20889726f, -0.05271628f, -0.02267664f, 
    0.02378785f, 0.01768246f, -0.08527217f, 0.03475432f, 0.09353131f, 0.03557207f, 0.01333760f, 0.14168014f, 
    0.21194081f, 0.07224327f, -0.10486662f, 0.17669749f, -0.07659236f, -0.05738454f, -0.06367046f, -0.01210533f, 
    -0.04072255f, -0.13935865f, -0.06742410f, -0.03711173f, -0.55218267f, -0.25197211f, -0.13802582f, -0.31196457f, 
    0.03711018f, -0.00505628f, -0.06390450f, -0.08048452f, 0.10400720f, 0.00755271f, 0.06011408f, 0.00393854f, 
    0.12787463f, -0.10441915f, 0.07637060f, -0.04161252f, 0.06705727f, 0.04211387f, 0.06466974f, -0.01626634f, 
    0.04615407f, 0.09296472f, -0.09295810f, -0.20065238f, -0.09265915f, 0.00082252f, -0.13554491f, -0.30144820f, 
    0.00716741f, -0.02262404f, 0.00347890f, -0.00337529f, 0.05634625f, 0.09222482f, 0.04946719f, 0.11186228f, 
    -0.15784754f, -0.07544954f, -0.02203445f, -0.00307136f, -0.04830769f, 0.07509305f, -0.02977229f, -0.04416088f, 
    0.17103228f, -0.01883007f, -0.02578752f, -0.02829046f, -0.32566291f, -0.13331413f, -0.09819423f, -0.09954606f, 
    0.10162690f, -0.01089416f, -0.05489735f, 0.00936538f, -0.00221469f, -0.03904019f, -0.02647751f, 0.12233522f, 
    0.11286411f, 0.16947317f, -0.00597421f, -0.06780031f, 0.09914183f, -0.03707226f, 0.00641476f, 0.11694130f, 
    -0.04293299f, -0.02597202f, 0.01962787f, 0.02496338f, -0.09173596f, -0.14775006f, -0.20016706f, 0.02348763f, 
    -0.05461489f, -0.03937926f, -0.02833048f, 0.01800568f, 0.06615689f, 0.07595094f, 0.01062262f, -0.10822541f, 
    0.09894927f, 0.11385698f, -0.02682390f, -0.03040851f, 0.08114202f, 0.04533709f, -0.10988717f, 0.18982351f, 
    -0.10864309f, 0.08648596f, 0.07858956f, 0.14761499f, -0.44610575f, -0.36408865f, -0.07593650f, 0.04464853f, 
    0.04489752f, 0.05605899f, -0.01831342f, 0.00650461f, 0.16873957f, 0.03776172f, 0.01019455f, 0.09164881f, 
    -0.31130177f, -0.23982784f, -0.26646298f, -0.00492096f, 0.06305575f, 0.08514175f, 0.04523874f, 0.00292178f, 
    0.05828331f, -0.01521040f, 0.07635594f, 0.06698373f, -0.21501048f, -0.19041541f, -0.07624921f, 0.01798137f, 
    0.06286994f, -0.02331782f, -0.06024695f, 0.12691686f, 0.03507408f, -0.18741621f, 0.01322847f, -0.00521784f, 
    -0.12879756f, 0.03358175f, -0.06425466f, -0.12493919f, 0.06030857f, -0.03396629f, 0.03189630f, 0.07510005f, 
    0.11684759f, 0.03481728f, 0.04055231f, 0.05118551f, 0.16948967f, -0.03637980f, -0.06944145f, 0.13065895f, 
    -0.01230677f, -0.00690452f, 0.07336696f, 0.03195498f, 0.07045453f, 0.14888152f, 0.06524476f, -0.00884221f, 
    -0.31530285f, -0.24894707f, 0.04627089f, -0.07793189f, 0.05699696f, 0.01010718f, 0.04109491f, -0.11843244f, 
    0.19015752f, 0.09238767f, 0.03590258f, 0.08638415f, 0.30034345f, 0.09140097f, -0.18989690f, 0.04460413f, 
    -0.05862999f, -0.13616024f, -0.06660131f, 0.17148058f, -0.02867471f, -0.11419424f, -0.15283290f, -0.08379709f, 
    -0.20792128f, -0.16921122f, -0.04552734f, -0.14863870f, 0.07724527f, -0.00455129f, -0.03792949f, 0.05755773f, 
    0.06476938f, 0.06973684f, 0.10888393f, 0.11271844f, 0.11529972f, 0.07350087f, -0.00017224f, -0.00193352f, 
    -0.13570791f, -0.00006539f, -0.00047016f, 0.05477965f, 0.12108213f, -0.02623569f, 0.14321184f, -0.05495558f, 
    0.12755427f, 0.07118545f, -0.06855392f, 0.11154883f, -0.01502799f, -0.02610421f, -0.05040255f, 0.04828716f, 
    -0.02765604f, -0.06304349f, 0.01446164f, -0.06955723f, 0.22390482f, 0.02478760f, 0.01969844f, -0.06899969f, 
    -0.16782627f, -0.14620368f, 0.02939147f, -0.06320996f, -0.05955541f, -0.06306718f, -0.25356662f, -0.15805584f, 
    -0.13383147f, -0.06165279f, -0.09072351f, 0.08501178f, 0.01505463f, 0.00325555f, 0.03684740f, 0.03789543f, 
    0.08593820f, 0.19292708f, 0.01031319f, 0.02737919f, -0.35100752f, -0.30376971f, 0.03072160f, -0.15838376f, 
    0.03597303f, -0.03688946f, -0.16102639f, -0.03582797f, -0.02107644f, -0.15936121f, -0.09875407f, -0.01875923f, 
    -0.26821959f, -0.28072670f, -0.12177554f, -0.11922190f, -0.08840310f, -0.05038196f, 0.00468200f, -0.01291065f, 
    -0.03261050f, 0.04441350f, -0.00840226f, 0.00908800f, 0.14456873f, -0.02932876f, -0.00340013f, -0.01296178f, 
    -0.09092533f, 0.00452326f, 0.08371222f, -0.03491725f, 0.12533413f, -0.06997629f, 0.04261722f, 0.00445904f, 
    -0.16334684f, -0.08716714f, 0.24205165f, -0.01350474f, 0.08795487f, 0.05547680f, -0.03182429f, 0.00580083f, 
    -0.03547324f, -0.02599428f, -0.03557187f, 0.06922095f, -0.18251342f, -0.26375601f, 0.24494338f, 0.03858382f, 
    0.09243986f, 0.15730676f, -0.00034463f, 0.08844236f, 0.11382337f, 0.01269990f, -0.16141035f, -0.05751092f, 
    -0.15330350f, 0.05061251f, -0.23219223f, -0.14183503f, -0.01030109f, -0.02472136f, -0.08296847f, 0.02556326f, 
    0.04527966f, -0.02040224f, 0.03122615f, 0.03251475f, 0.04959240f, 0.04794519f, 0.02171544f, -0.09403013f, 
    -0.09678384f, -0.05570118f, -0.01275870f, -0.03377830f, 0.02760831f, 0.00010069f, 0.09880573f, -0.04375072f, 
    0.17402962f, -0.03384293f, -0.00954132f, -0.04799791f, -0.08639186f, -0.08313879f, 0.00661131f, 0.07128008f, 
    -0.01496084f, -0.01363600f, -0.00635131f, -0.02445645f, -0.03399715f, -0.01981304f, -0.00283199f, -0.03051630f, 
    0.02659992f, 0.04913300f, -0.04757981f, 0.00010957f, 0.10601661f, 0.00186091f, 0.00503879f, 0.03113399f, 
    -0.32625276f, 0.04006189f, -0.21042164f, 0.00840634f, -0.06206162f, -0.03939103f, 0.08736478f, -0.02126206f, 
    0.05146600f, 0.09938221f, 0.08406547f, 0.09105685f, -0.17808802f, -0.02052380f, -0.02317992f, -0.11400373f, 
    -0.00689964f, 0.04593162f, -0.15179409f, -0.02917693f, -0.08667636f, -0.05112093f, -0.05586714f, -0.07775139f, 
    -0.29972669f, -0.29346308f, 0.21327707f, -0.02878932f, 0.05217426f, 0.03115047f, 0.02774323f, 0.00289029f, 
    0.11750243f, -0.05059479f, -0.06537779f, 0.00975486f, 0.10695907f, 0.15895553f, 0.02702268f, -0.09438807f, 
    0.14046310f, 0.08100912f, 0.06669828f, 0.05995292f, 0.02595456f, 0.18540359f, 0.01654554f, 0.05556923f, 
    0.21333434f, 0.08504108f, 0.08639573f, -0.01719732f, 0.14209658f, 0.09121110f, -0.05339987f, -0.03068309f, 
    0.02655710f, 0.05145554f, -0.07219677f, 0.04464523f, 0.11336125f, -0.02225745f, -0.05527492f, -0.06990778f, 
    -0.13263205f, -0.02695966f, -0.05689446f, 0.02072516f, 0.05130772f, -0.07125620f, -0.07814267f, -0.11029738f, 
    -0.54487067f, -0.21862315f, 0.16326359f, 0.08372101f, 0.09345704f, 0.00665008f, -0.06871095f, 0.01439764f, 
    0.05511375f, -0.16493869f, -0.00934441f, -0.09089307f, -0.03107976f, 0.02453445f, -0.07937921f, 0.05357724f, 
    -0.03268410f, -0.11236826f, -0.04778912f, 0.06284598f, -0.09345862f, 0.05598440f, -0.04542575f, 0.03801468f, 
    0.15586351f, 0.06975794f, -0.05119199f, -0.02640193f, -0.04241123f, -0.06837635f, -0.02585099f, 0.00027571f, 
    -0.08595431f, -0.03314116f, 0.17794988f, 0.04833800f, -0.20140873f, 0.00483645f, -0.02886022f, 0.05326362f, 
    0.02986487f, -0.04163479f, -0.11393983f, -0.06908654f, -0.02439788f, -0.03257900f, 0.04616397f, -0.02215442f, 
    0.08315510f, -0.31697229f, -0.06135162f, 0.14580275f, -0.02383251f, 0.02882492f, 0.02166171f, -0.01649911f, 
    -0.04404124f, -0.00537188f, -0.03485783f, 0.01203683f, 0.10555477f, -0.01729255f, -0.15959349f, -0.03658610f, 
    0.01262680f, 0.10881163f, -0.10252360f, -0.11287680f, -0.00959528f, 0.04152065f, -0.14549920f, -0.06147296f, 
    0.29258516f, 0.02366002f, -0.08912630f, 0.01981061f, 0.06166459f, 0.00708736f, 0.06280092f, -0.05813648f, 
    0.02019549f, -0.00949242f, 0.00948177f, 0.06129530f, 0.05638208f, -0.09097096f, -0.12003534f, -0.20929767f, 
    0.06403522f, -0.01219371f, -0.08495097f, 0.00690084f, -0.05723606f, -0.08665338f, 0.04398880f, -0.12261478f, 
    0.14818497f, -0.03444285f, 0.03110361f, 0.02185565f, -0.12071262f, -0.11504605f, -0.10396396f, -0.05195170f, 
    -0.04172727f, -0.06115301f, -0.06751332f, -0.10932301f, -0.01945746f, -0.10091276f, -0.09660842f, 0.20518094f, 
    0.09355102f, -0.09818316f, 0.03465825f, -0.04153860f, -0.00326231f, 0.00688481f, -0.12038170f, -0.02730848f, 
    -0.23397648f, 0.08586942f, -0.13472289f, 0.01893225f, 0.01266232f, -0.02992908f, 0.01313582f, -0.01788897f, 
    0.06788024f, -0.04482837f, 0.00118371f, 0.05362546f, 0.06433529f, 0.16590898f, -0.04049487f, -0.19735472f, 
    0.09416626f, -0.08830374f, 0.02380544f, -0.07234276f, 0.03436586f, 0.01437612f, -0.07836919f, -0.07842328f, 
    -0.18796512f, -0.00093818f, 0.13204007f, 0.09465901f, 0.01388070f, -0.16199987f, -0.03215771f, 0.10615865f, 
    -0.02727043f, 0.06433577f, 0.05589246f, -0.03816469f, 0.29002869f, 0.24748684f, -0.00822705f, -0.11890616f, 
    -0.01466443f, 0.02927419f, 0.04557494f, -0.07625960f, 0.01402809f, -0.00014304f, -0.11174800f, 0.04935981f, 
    -0.42113593f, -0.49656585f, -0.11250804f, -0.10409517f, 0.05943004f, 0.08234099f, 0.09917942f, 0.06218944f, 
    -0.08987860f, -0.06626772f, -0.03315893f, -0.01148228f, -0.00837141f, 0.11026243f, -0.02353382f, 0.15725270f, 
    0.08648026f, -0.03964100f, -0.04551926f, -0.12875497f, 0.02530485f, -0.03148741f, -0.12099832f, -0.06002444f, 
    -0.18457294f, 0.19162090f, -0.18348019f, -0.05011494f, 0.05071137f, -0.00143054f, 0.05386682f, -0.09093513f, 
    -0.11794116f, -0.00078101f, -0.09551911f, -0.04961148f, 0.14926186f, 0.15040268f, -0.05956524f, -0.01624198f, 
    -0.07488091f, -0.17150524f, -0.07319101f, -0.02636064f, 0.00879371f, 0.03359154f, -0.00740508f, -0.09675309f, 
    -0.17156985f, -0.00714206f, 0.11556569f, -0.02472922f, -0.12592836f, 0.13255322f, -0.07536676f, -0.06770182f, 
    0.03866396f, 0.00102160f, 0.08457420f, 0.11022685f, 0.15112017f, -0.29063651f, -0.06930526f, 0.16444445f, 
    -0.05504733f, 0.05322713f, -0.09645787f, -0.00160454f, -0.02752412f, 0.00249710f, -0.09351820f, 0.13169959f, 
    -0.03613939f, -0.15415300f, -0.12327787f, -0.23454839f, 0.05146843f, 0.02153002f, 0.06470132f, 0.06961326f, 
    -0.03239618f, 0.02672696f, -0.05478641f, -0.09602718f, -0.01572427f, 0.02628398f, -0.04068665f, 0.08804370f, 
    -0.08832013f, 0.02594012f, 0.00947070f, 0.06295865f, 0.09665798f, -0.13866870f, -0.12684269f, -0.05401306f, 
    0.22324827f, -0.12499132f, -0.06751632f, 0.10204688f, -0.05041100f, -0.11214468f, -0.02908461f, -0.07591545f, 
    0.12024327f, 0.03988627f, 0.06608570f, 0.02250581f, -0.08289289f, -0.33708704f, 0.16145182f, 0.25654325f, 
    -0.07252461f, 0.11064678f, 0.03310208f, 0.13137282f, 0.04685480f, 0.03884215f, 0.06259767f, 0.07933301f, 
    0.11826012f, -0.16952743f, -0.03734691f, -0.19315958f, 0.03853804f, -0.06491921f, 0.00492661f, 0.09876377f, 
    -0.24440017f, -0.04412548f, 0.04450908f, -0.02514570f, -0.09119716f, -0.16240880f, 0.03153436f, 0.07014029f, 
    -0.01817403f, 0.10798091f, -0.07962856f, -0.01025025f, 0.07475368f, -0.02845498f, 0.01328792f, 0.13660739f, 
    0.00128437f, -0.09719600f, 0.02254704f, -0.01078512f, -0.05506204f, 0.02731141f, -0.03806083f, 0.09755588f, 
    -0.13364756f, 0.02170640f, -0.00007077f, -0.06987385f, -0.08518045f, -0.12236124f, 0.03922071f, -0.01401273f, 
    0.07292888f, 0.00163405f, -0.00884360f, 0.04205173f, -0.00478212f, 0.02110880f, -0.05997127f, 0.07418393f, 
    -0.22275043f, -0.07045266f, 0.08765814f, 0.07544765f, -0.05537281f, -0.02625912f, 0.07602233f, -0.04800281f, 
    -0.02440127f, 0.02941776f, 0.08121207f, -0.00331950f, 0.27766860f, -0.32824340f, -0.07486912f, -0.03266188f, 
    0.02101316f, -0.01699692f, -0.12787224f, -0.06784619f, -0.03302905f, 0.05710300f, -0.01526125f, 0.06473279f, 
    -0.06979930f, 0.07169394f, -0.13648501f, 0.12488476f, 0.08784259f, -0.01353922f, -0.01217614f, 0.02629504f, 
    0.04655104f, -0.03607496f, -0.03962958f, 0.08137266f, 0.27797520f, -0.06030003f, -0.17524509f, 0.14830966f, 
    0.02445553f, -0.04530277f, -0.00035761f, -0.05666227f, 0.01969237f, -0.07290965f, 0.01474008f, -0.07096833f, 
    -0.15710017f, 0.01694878f, -0.08030187f, -0.13148145f, -0.03742239f, 0.04002565f, -0.06310891f, 0.05598326f, 
    -0.09145594f, 0.06894893f, 0.01811713f, -0.04930864f, 0.28853309f, 0.11336681f, -0.07115215f, -0.13608836f, 
    -0.02903349f, 0.00342093f, 0.02256645f, 0.05049800f, 0.05638377f, 0.03556876f, -0.01821298f, 0.05642838f, 
    -0.14609763f, 0.01693618f, -0.03894584f, -0.09402876f, 0.07289251f, -0.04432807f, 0.03213073f, 0.13506247f, 
    0.06590867f, -0.09273988f, 0.02235360f, -0.07644093f, 0.07383016f, -0.28401569f, -0.04659774f, 0.07670239f, 
    0.00618363f, 0.06899132f, -0.11492319f, 0.04373363f, -0.00432768f, 0.05721835f, -0.10507248f, 0.01302970f, 
    -0.50598603f, 0.29197934f, -0.05471155f, -0.02010591f, -0.00305330f, 0.00459022f, 0.02901029f, 0.01187361f, 
    -0.03774008f, -0.01441490f, -0.10792793f, -0.03692016f, 0.13406508f, -0.05137866f, -0.05596365f, 0.21292028f, 
    0.07588317f, 0.01797125f, 0.04108863f, -0.00185658f, 0.13499607f, 0.04308424f, 0.05330457f, -0.01018824f, 
    -0.05525677f, 0.26041573f, -0.20329438f, 0.09980379f, 0.12942891f, 0.07323116f, 0.09098818f, 0.12703860f, 
    0.08585805f, -0.01787815f, -0.00640546f, -0.03347352f, -0.07041324f, 0.07966980f, -0.09727471f, -0.00728911f, 
    0.04915265f, -0.00449297f, 0.11226559f, 0.09317706f, 0.16776779f, 0.07629106f, -0.05947947f, 0.05438284f, 
    0.06494009f, -0.25786203f, 0.10289937f, 0.03933844f, -0.01901372f, 0.00265813f, 0.00971143f, 0.00495040f, 
    0.02254532f, -0.03743950f, -0.02248212f, -0.03416492f, 0.19672170f, -0.03341779f, -0.02278854f, 0.05102149f, 
    -0.03972546f, 0.03636130f, 0.00115696f, 0.03955029f, 0.12728557f, -0.07520921f, 0.05341250f, 0.08619786f, 
    -0.02345491f, 0.02748392f, 0.07778683f, 0.01049139f, 0.11151751f, 0.02247060f, -0.02818853f, 0.03664837f, 
    -0.09523565f, -0.05584693f, -0.00592900f, -0.03242736f, -0.00770299f, -0.11944189f, 0.07005379f, -0.26356184f, 
    -0.00119804f, -0.01619345f, 0.08798580f, 0.01646473f, -0.08232371f, 0.04432802f, -0.02724355f, 0.10643839f, 
    0.29792586f, 0.09968691f, -0.15245102f, 0.07877821f, 0.02352630f, 0.05212012f, -0.01236379f, -0.08229001f, 
    0.08785175f, 0.02512838f, 0.03289846f, -0.04223754f, -0.01210970f, 0.00211045f, -0.11467555f, 0.08562494f, 
    -0.01902613f, -0.02797549f, -0.00271208f, -0.06862371f, -0.05779501f, -0.00472591f, 0.03185306f, -0.06995693f, 
    0.08874702f, 0.05524262f, -0.15369929f, 0.12165829f, 0.00456598f, -0.03586217f, 0.04734568f, -0.05233560f, 
    -0.06153322f, 0.00431316f, -0.02999127f, -0.06077671f, -0.06845421f, -0.03714968f, 0.03309501f, -0.07508483f, 
    -0.09046528f, -0.00867067f, 0.07884381f, 0.02716416f, -0.04107953f, 0.11395860f, 0.10530233f, -0.07058480f, 
    -0.16948634f, -0.08629964f, 0.05534144f, 0.05399451f, -0.01347271f, 0.06443056f, -0.08571833f, -0.01887325f, 
    -0.04291992f, -0.02545530f, -0.09641317f, 0.06238517f, -0.13714267f, -0.05982433f, -0.03992913f, -0.12597315f, 
    -0.01082815f, 0.02508716f, 0.04613364f, -0.05299785f, 0.03583034f, 0.01896205f, 0.05706653f, 0.07314742f, 
    -0.11557109f, -0.24521890f, 0.02043072f, -0.14882408f, 0.01654889f, 0.05412741f, 0.00338954f, -0.07966620f, 
    0.01317148f, -0.01494476f, -0.12637910f, -0.00805743f, -0.24904722f, -0.22122748f, 0.00078321f, 0.07054243f, 
    0.03954810f, -0.00721993f, -0.12057811f, 0.10680488f, -0.10594562f, 0.08471714f, 0.04470988f, -0.11032975f, 
    0.13304412f, 0.08900207f, 0.00739375f, -0.02747594f, 0.13388716f, -0.12849954f, -0.19920829f, 0.02309970f, 
    -0.03818285f, 0.09335515f, 0.02213580f, 0.08914069f, 0.20689045f, 0.28530273f, -0.09361544f, -0.16241692f, 
    0.22881535f, -0.18730430f, -0.22965099f, 0.05914192f, 0.10930561f, 0.05001293f, 0.03025743f, 0.04023838f, 
    -0.23504755f, 0.04094994f, 0.13175884f, 0.17924479f, 0.03612038f, 0.01529821f, 0.03907983f, 0.12824488f, 
    -0.04680075f, -0.05703429f, 0.11865114f, 0.12195389f, -0.38575163f, 0.24972619f, -0.10103913f, -0.11296907f, 
    -0.12916799f, 0.05711935f, -0.02554812f, -0.00084115f, 0.01556969f, -0.00136129f, -0.02338950f, -0.14804874f, 
    -0.20637481f, -0.44009551f, -0.03140699f, -0.00256807f, 0.14019857f, 0.04270925f, 0.00475875f, 0.04499026f, 
    -0.00462587f, 0.02484080f, 0.08806521f, -0.07187196f, 0.48807847f, 0.02761410f, -0.28811926f, -0.04002495f, 
    0.01629848f, -0.11650112f, 0.03925373f, 0.02193723f, -0.03468605f, 0.05426698f, 0.00135580f, 0.11966237f, 
    0.12929131f, -0.00587989f, 0.02158294f, 0.15269074f, -0.19180419f, 0.02810955f, -0.20750651f, -0.01356511f, 
    -0.04874763f, -0.02483696f, 0.14022489f, -0.07923307f, -0.03724717f, 0.02853184f, -0.06798192f, -0.22718617f, 
    0.03742042f, -0.05361244f, 0.02197101f, -0.04654539f, 0.11428288f, -0.00568708f, -0.12571330f, -0.03989630f, 
    0.04791364f, -0.07103838f, 0.07083444f, -0.18118280f, 0.12730628f, 0.05185380f, -0.05211832f, -0.03906306f, 
    -0.03545611f, 0.11923381f, -0.01114130f, 0.03354694f, 0.11648656f, -0.05991881f, -0.13993187f, 0.37844855f, 
    -0.10646181f, -0.02781306f, 0.05053823f, 0.05411170f, 0.02308859f, 0.00064434f, -0.05852089f, -0.08878381f, 
    -0.05540828f, -0.00990511f, 0.14152177f, 0.00260393f, -0.02192383f, 0.02773344f, 0.00273652f, -0.15757582f, 
    0.00508849f, -0.04254484f, 0.03498512f, -0.07157052f, -0.02754203f, -0.05479790f, -0.08138046f, -0.00110779f, 
    -0.07825711f, -0.01858106f, -0.00719491f, -0.09430268f, -0.04309830f, -0.03168574f, -0.00776041f, -0.06241399f, 
    0.22241759f, 0.16451886f, 0.04541918f, 0.02064012f, 0.03488717f, -0.01391102f, -0.07371714f, -0.01768192f, 
    0.10647638f, 0.05550741f, 0.03807539f, 0.02384621f, -0.11162255f, 0.01482277f, 0.08727258f, -0.15023850f, 
    -0.06607634f, 0.09459425f, -0.04642120f, -0.00747316f, -0.02797986f, -0.23266058f, 0.08107287f, -0.00965040f, 
    0.18199652f, 0.05379415f, -0.03258641f, 0.10418075f, -0.04801727f, 0.07077935f, 0.01191954f, -0.05968264f, 
    0.01089562f, -0.03652409f, -0.07382549f, -0.07646042f, 0.06307338f, 0.02854804f, 0.10284010f, -0.16984302f, 
    -0.01456124f, 0.07311862f, -0.07005271f, 0.05699801f, 0.01005339f, -0.04377788f, 0.07777750f, -0.04154657f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07362586f, 0.02451879f, -0.04205214f, -0.03919523f, 0.04721377f, 0.03684440f, 0.03794978f, -0.02666212f, 
    -0.02562961f, -0.02115232f, 0.02645984f, 0.04584474f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
