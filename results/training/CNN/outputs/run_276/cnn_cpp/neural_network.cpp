#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.35301369f, -0.07819059f, 0.54591513f, 0.07990620f, 0.73107666f, 0.52078223f, -0.19657268f, -0.47750369f, 
    0.00041535f, 0.10678268f, 0.25282794f, 0.38225973f, 0.04755000f, 0.10404927f, 0.12311953f, -0.22765529f, 
    0.03693771f, 0.16515984f, -0.10376625f, 0.24872068f, 0.16108161f, -0.08097439f, 0.15332790f, 0.05255238f, 
    0.17091568f, -1.29154253f, 0.22809917f, -0.15612720f, 0.55836326f, -0.46272486f, 0.45688069f, 1.09429181f, 
    -0.36703211f, 0.41096604f, 0.29535073f, 0.06377719f, -0.23726986f, 0.09325195f, -0.22161622f, 0.13073084f, 
    0.08560926f, -0.06004948f, -0.15830173f, -0.03297992f, 0.11797863f, -0.01137235f, -0.26861450f, 0.12017030f, 
    0.05673014f, 0.21727222f, 0.12697990f, -0.39750278f, 0.19676577f, 0.52900976f, 0.49378100f, 0.57651013f, 
    0.24331748f, 0.17133747f, -0.64262128f, 0.38074353f, -0.43172348f, 0.25222215f, 0.30417225f, 0.48014459f, 
    0.12816930f, -0.23299921f, -0.45528722f, -0.04482077f, -0.03485924f, -0.32067242f, 0.34818289f, -0.11227807f, 
    -0.13880517f, -0.07250951f, -0.12321892f, -0.63062823f, -0.69974065f, -0.19498914f, 0.43983492f, 0.48576298f, 
    0.60914326f, 0.55426753f, 0.27625635f, 0.28607690f, 0.05805683f, 0.11174281f, -0.15628985f, -0.20266668f, 
    0.37812158f, 0.18198459f, 0.30583549f, 0.27300590f, -0.08497911f, 0.22022232f, 0.04415850f, -0.13806713f, 
    -0.07900980f, -0.17890319f, -0.20144270f, -0.14783059f, 0.82724631f, 0.56347781f, 0.20691893f, 1.04461157f, 
    0.70645350f, 0.51018178f, -0.13573740f, -0.12588294f, -0.42411175f, -0.11471610f, 0.21168195f, 0.01701021f, 
    0.11186705f, 0.08935370f, -0.22088480f, 0.12148228f, 0.03117059f, 0.36501634f, 0.16975352f, -0.08594152f, 
    0.23265724f, 0.29439664f, 0.10440221f, -0.19858688f, 0.17754252f, -0.59101391f, -0.42347413f, 0.32135123f, 
    0.31059435f, 0.38961068f, -0.80724919f, -0.26320505f, -0.47506931f, -0.28884655f, 0.02755734f, -0.26192003f, 
    0.17790382f, 0.38813183f, 0.10663078f, -0.07822943f, 0.22333796f, 0.09452272f, 0.34755427f, 0.31116015f, 
    0.19393510f, 0.10223483f, -0.03601437f, -0.33954531f, -0.22770670f, -0.21623221f, 0.82774228f, 0.54544687f, 
    0.27544990f, 0.31732085f, 0.69019634f, 0.37720105f, 0.29723310f, 0.08421132f, 0.16533601f, 0.43886790f, 
    -0.32974404f, -0.29722649f, -0.10464453f, -0.26009014f, -0.13215303f, -0.34907767f, -0.00158991f, -0.15115610f, 
    0.04488720f, -0.10262429f, 0.26109365f, 0.13236141f, 0.23663069f, 0.16312267f, 0.23161401f, 0.72483826f, 
    0.62754476f, 0.43522775f, 0.65394080f, 0.32153064f, -0.78753209f, 0.38080963f, -0.52667028f, -0.45622018f, 
    0.04203317f, 0.16227762f, 0.04841929f, -0.11816972f, 0.23173444f, 0.30222455f, -0.21622759f, 0.15712394f, 
    0.14147593f, 0.01891124f, -0.15247373f, -0.31414890f, 0.23250429f, -0.07553463f, 0.10858379f, 0.24203642f, 
    0.47275299f, -0.59103310f, -0.43978682f, 0.42270654f, 0.80369043f, 0.00828952f, 0.57013470f, -0.22555906f, 
    0.56097484f, 0.58823425f, -0.24339741f, 0.10160398f, -0.26173717f, 0.16504860f, -0.11798257f, -0.11886842f, 
    0.03451744f, 0.02774576f, -0.17531186f, -0.25534558f, -0.05843127f, -0.10265405f, 0.05975151f, -0.02762241f, 
    -0.05827355f, -0.63699239f, 0.59591079f, 0.85981083f, -0.04383753f, 0.44189554f, -0.55505282f, 0.65631402f, 
    -0.53557563f, -0.88470125f, -0.34709385f, 0.29539567f, 0.29089111f, 0.07139815f, 0.04632074f, -0.04664510f, 
    -0.06993051f, -0.14376175f, 0.00386859f, -0.05062167f, -0.09145769f, 0.18773553f, 0.14558564f, 0.26063535f, 
    0.23127984f, 0.06932633f, 0.75852567f, 0.52786100f, 0.34024978f, 0.76994044f, 0.04596283f, 0.02541398f, 
    0.42855653f, 0.42731860f, 0.46443838f, 0.04248176f, 0.01597848f, -0.06433977f, 0.33410183f, -0.30627987f, 
    0.11278614f, -0.19080937f, -0.16836137f, 0.32908437f, -0.38811234f, -0.18796282f, 0.14859900f, 0.03892672f, 
    -0.22372839f, -0.05570986f, -0.32632348f, -0.44388866f, -0.38046056f, -0.25255498f, -0.32189319f, -0.33688504f, 
    -0.48112449f, 0.59054470f, 0.36716932f, -0.28202891f, 0.18833975f, -0.38611838f, 0.01965549f, -0.09907363f, 
    0.01457355f, -0.00586918f, -0.07516052f, -0.03028297f, -0.13549748f, -0.04955129f, -0.27632219f, 0.05657798f, 
    0.40302613f, -0.39093131f, -0.15304472f, 0.00955403f, 1.02727926f, 0.72733712f, 0.64064819f, -0.64646345f, 
    -0.86252815f, 0.00134645f, -0.23691824f, -0.16379657f, -0.39149198f, -0.30137834f, 0.27578780f, 0.06361694f, 
    -0.27596679f, -0.01645786f, 0.03139688f, 0.00488951f, -0.02476659f, -0.00104033f, -0.00358385f, -0.02910725f, 
    -0.14098538f, 0.34701455f, 0.21636057f, -0.14807020f, 0.03094332f, -0.29490733f, 0.66482735f, 0.60938752f, 
    0.63405049f, 0.20356731f, 0.16489537f, -0.10799658f, -0.98689902f, -0.05263695f, -0.14607920f, -0.13996395f, 
    -0.27596575f, -0.07631425f, 0.18875894f, -0.08287877f, -0.11941258f, -0.00739206f, -0.02760420f, -0.10155125f, 
    -0.00310699f, -0.11003218f, -0.05585663f, -0.31160125f, -0.16144916f, -0.27344334f, 1.00872052f, 0.33979550f, 
    0.14337136f, 0.52562392f, -0.00995127f, 0.68556261f, -0.10250328f, -0.55733120f, 0.55785090f, -0.03335829f, 
    0.10732968f, 0.01155927f, -0.31100550f, 0.14038816f, -0.01300051f, 0.44800439f, -0.06408561f, -0.02778256f, 
    -0.17914617f, 0.37408617f, 0.10884360f, -0.08631396f, 0.18246335f, -0.28838068f, 0.44647500f, -1.03657627f, 
    0.70668364f, 0.30646670f, -0.62654179f, 0.27873999f, 0.76462144f, -0.38475826f, -0.28998953f, 0.59025723f, 
    -0.64849240f, -0.22193025f, -0.17496257f, -0.27998680f, 0.27309152f, -0.31667104f, -0.37377414f, -0.15597749f, 
    -0.05828847f, -0.32615599f, -0.04584957f, 0.02836584f, 0.10960354f, -0.13219979f, 0.10242403f, -0.08124544f, 
    0.29915324f, -0.13020086f, -0.55021387f, -0.79999626f, -0.43012726f, 0.20876764f, -0.12891376f, -0.36211383f, 
    -0.54225653f, -0.30610159f, -0.17865512f, 0.18313158f, 0.32747975f, 0.30125940f, -0.00631783f, 0.18817176f, 
    0.19177613f, -0.00043515f, 0.14448448f, 0.27286953f, 0.01765955f, 0.10836507f, -0.29952794f, -0.11179121f, 
    0.08648161f, 0.51832652f, 0.38281536f, -0.35009092f, -0.89447314f, -0.25815326f, 0.52694678f, -0.31966510f, 
    0.28534499f, 0.33332151f, -0.28040451f, -0.70100820f, 0.00745953f, -0.09239677f, 0.00305625f, 0.12037538f, 
    -0.14967655f, 0.06045546f, 0.03771820f, 0.23836654f, 0.04794560f, 0.06542304f, -0.10615956f, -0.30962506f, 
    0.02554299f, 0.03303254f, -0.20704702f, 0.02984842f, 0.46384865f, -0.57484871f, 0.02787758f, 0.29871142f, 
    -0.70686787f, -0.43577430f, -0.90668237f, -0.54689109f, -0.23564783f, 0.19192421f, 0.33991176f, 0.30077380f, 
    -0.30514348f, 0.15946621f, 0.08036814f, 0.27380753f, -0.01196180f, 0.36200926f, -0.23458582f, 0.06461245f, 
    0.02621194f, -0.12281097f, 0.35485169f, -0.79911548f, 0.33193693f, 0.60159349f, 0.65311831f, -0.46308818f, 
    -0.53230202f, 0.26742890f, 0.41989642f, 0.13357869f, -0.47667214f, -0.19898279f, -0.26059186f, -0.19893576f, 
    -0.04021860f, -0.05742365f, -0.15596686f, 0.30040863f, -0.01658758f, 0.10264126f, -0.26957446f, -0.10996412f, 
    -0.27934122f, -0.46003881f, -0.37488338f, -0.20663372f, 0.79672456f, 0.79485166f, -0.08745000f, 0.13489923f, 
    -0.93874782f, -0.07957131f, 0.18593162f, -0.28689092f, -0.09550934f, 0.57771498f, 0.40007678f, 0.17301063f, 
    0.39191020f, 0.08561105f, -0.52739835f, -0.04055914f, -0.34683529f, 0.26863590f, 0.13156933f, -0.03111348f, 
    -0.03060252f, -0.12533863f, 0.02263652f, 0.04972981f, -0.01091609f, -0.31866854f, -0.88083023f, -0.71486902f, 
    0.05600960f, -0.06428301f, 0.40768310f, 0.47680902f, -0.55183172f, 0.44610763f, -0.13392858f, -0.22768170f, 
    0.11435060f, -0.15728034f, 0.31650761f, 0.28145218f, 0.06647809f, -0.05455052f, 0.19979976f, 0.20147742f, 
    0.11455305f, 0.11188153f, -0.09052572f, -0.08325580f, 0.20828049f, -0.05059139f, -0.63632482f, -0.68385613f, 
    -0.58293021f, -0.58060950f, 0.43062869f, -0.78316927f, 0.00853560f, 0.05189467f, 0.28908789f, -0.45560530f, 
    -0.38988742f, -0.23542176f, -0.11181078f, -0.25185499f, -0.51258689f, 0.31420201f, 0.00269896f, 0.17393719f, 
    0.06443539f, -0.17284685f, 0.28342217f, 0.05921531f, 0.36161128f, 0.32919410f, 0.20811547f, 0.88954848f, 
    0.21248612f, -0.68311054f, -0.81479114f, -0.67586362f, 0.25504529f, 0.46533218f, 0.62694651f, 0.60391104f, 
    -0.03745942f, 0.25329918f, 0.07526822f, -0.38107026f, -0.28821176f, 0.06127512f, 0.29519877f, -0.13043854f, 
    0.09978782f, 0.14630252f, 0.27483687f, -0.05952905f, -0.05570424f, 0.25946981f, 0.00957310f, -0.20352195f, 
    0.70136589f, -1.39324856f, -0.10916402f, 0.89182156f, -0.06877840f, -0.72905487f, 0.60673273f, 0.57779199f, 
    -0.58685660f, 0.01345137f, 0.27767161f, 0.31317645f, -0.08857864f, -0.21914870f, 0.29001790f, -0.18264340f, 
    0.21434532f, 0.20091519f, 0.00624124f, -0.08020922f, 0.14366132f, -0.01752894f, -0.05577209f, 0.05157069f, 
    0.22281530f, -0.73237216f, -0.44132003f, -0.44795129f, -0.50109184f, 0.07947814f, 0.41363868f, -0.13964312f, 
    -0.12598868f, -0.14668912f, -0.56733477f, -0.26077500f, 0.26673800f, 0.25666317f, 0.32264403f, -0.26256874f, 
    -0.15902176f, 0.02176948f, -0.43513885f, -0.13137174f, 0.13640800f, 0.04012600f, 0.02608415f, 0.02942698f, 
    -0.00838925f, -0.32079491f, -0.98899466f, 0.87857229f, -0.05733337f, -0.35074666f, 0.05907913f, -0.64484423f, 
    -0.03427176f, -0.20953739f, -0.12418252f, -0.16798370f, -0.17299835f, 0.34729499f, -0.13134767f, 0.22962590f, 
    -0.05706355f, -0.04765553f, -0.24473630f, 0.00821061f, -0.28107679f, -0.16246390f, 0.21473458f, 0.08573791f, 
    0.29209247f, 0.11904337f, -0.06773033f, -0.06301180f, -0.59000665f, -0.66935074f, 0.02942547f, -0.41126847f, 
    -0.01714911f, 0.54869217f, 0.30471784f, 0.43959263f, 0.19685461f, 0.25030792f, 0.09537921f, 0.18120499f, 
    0.04104483f, -0.13969879f, -0.31896618f, -0.47142032f, -0.19859624f, 0.09081334f, -0.27938804f, -0.12088112f, 
    -0.00465806f, 0.04764537f, -0.19273160f, 0.24224190f, 0.09739651f, 0.04328389f, -0.18699664f, 0.00286678f, 
    -0.15154426f, 0.22714594f, 0.23582140f, 0.05692247f, -0.21948765f, -0.68687284f, -0.25341499f, 0.24848220f, 
    -0.00740731f, 0.37676188f, 0.48841083f, 0.16236398f, -0.16066441f, 0.44285020f, 0.19888921f, 0.51273859f, 
    0.09094377f, 0.27432281f, -0.53627622f, -0.08196525f, 0.29224887f, -0.80454421f, -0.14862007f, -0.60159683f, 
    -0.66714311f, -0.27231720f, 0.02190155f, 0.90007550f, 0.24990222f, 0.15152954f, 0.68619800f, -0.18966056f, 
    -0.35987809f, 0.21596770f, -0.31012794f, -0.01769342f, -0.06746060f, -0.09521549f, 0.13057190f, 0.12813416f, 
    -0.37260401f, 0.15316446f, 0.01316049f, 0.23558760f, 0.10167139f, 0.09721450f, -0.37809885f, -0.67143935f, 
    -0.70832264f, -0.03399312f, 0.33260441f, -0.63467026f, 0.38316602f, 0.37112516f, -0.35230157f, 0.38225463f, 
    0.41029716f, 0.23252045f, 0.20050658f, 0.11378974f, 0.38596588f, -0.15296119f, 0.31479651f, 0.37864816f, 
    -0.14181590f, -0.03786234f, 0.18338816f, -0.06287514f, -0.09289478f, 0.17885555f, 0.11368789f, -0.66889936f, 
    0.10512621f, 0.55531877f, 0.78166819f, -0.34867305f, 0.31377310f, -0.01304765f, 0.12179569f, -0.16822411f, 
    -0.19992587f, -0.18329380f, -0.11077395f, -0.25076732f, -0.06689083f, 0.17736177f, -0.17462145f, -0.23249151f, 
    0.20649764f, 0.15170036f, 0.01378381f, 0.14876382f, -0.02232537f, 0.09196540f, 0.12733394f, -0.48779196f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.26777831f, -0.10559951f, 0.10443065f, 0.16002394f, -0.10244287f, 0.01882231f, 0.10659415f, 0.04209468f, 
    0.16484828f, 0.03876821f, 0.17614512f, -0.02039999f, 0.14666148f, 0.00534368f, 0.20130457f, 0.02974003f, 
    0.38492316f, -0.10864300f, 0.19476795f, -0.05329725f, 0.11620912f, 0.07013661f, 0.01799324f, 0.05249486f, 
    -0.02651772f, 0.04163214f, 0.24790999f, -0.00071565f, 0.07670065f, 0.07374386f, 0.14633071f, 0.09542025f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01698200f, -0.02044469f, 0.05027224f, -0.02431804f, 0.02185600f, 0.02605855f, -0.02804063f, -0.00644285f, 
    0.03002465f, 0.00707794f, 0.00129017f, 0.00091684f, 0.02746596f, -0.03349109f, 0.03143061f, -0.00543795f, 
    0.02627668f, -0.05358431f, 0.01491486f, -0.03803185f, -0.01436910f, -0.02081193f, 0.00676178f, -0.03616922f, 
    -0.02767149f, -0.02793354f, -0.05704863f, 0.02202176f, -0.03302670f, -0.02433708f, -0.05101545f, 0.02279427f, 
    -0.00594880f, -0.01479355f, -0.05230646f, 0.04352814f, 0.02941296f, -0.00665272f, 0.03685106f, -0.03458840f, 
    0.03527411f, -0.00468364f, -0.04228909f, -0.05421893f, -0.03760543f, 0.03413787f, -0.01155178f, -0.05485880f, 
    0.00891247f, 0.01015421f, -0.03427332f, -0.01277456f, 0.02308724f, 0.01647856f, -0.03767125f, -0.04757651f, 
    -0.01369665f, 0.02682815f, -0.03392204f, 0.02855993f, 0.02814504f, -0.03818879f, -0.01675344f, -0.00200080f, 
    -0.04714924f, 0.02536164f, 0.01650670f, 0.02170498f, -0.00521411f, -0.04998789f, 0.00732547f, -0.02777590f, 
    -0.02878218f, -0.06219926f, 0.01183149f, 0.03214427f, -0.00989278f, -0.02614351f, -0.01342559f, 0.02340869f, 
    -0.05491025f, -0.05396479f, -0.02875163f, 0.02875056f, -0.01004121f, -0.02118772f, 0.03830072f, 0.03230416f, 
    0.03765472f, -0.02493937f, 0.02363730f, 0.03521270f, -0.03049029f, -0.05822247f, -0.06176930f, -0.00641635f, 
    -0.04198035f, -0.00779373f, -0.05184906f, 0.04322376f, -0.03783032f, -0.03995512f, 0.03369853f, 0.00486231f, 
    -0.05456195f, 0.02364907f, -0.04536844f, -0.01151385f, 0.03312741f, 0.03621861f, -0.01943042f, -0.03615407f, 
    -0.01054636f, 0.01865839f, -0.05118652f, -0.01400058f, 0.03563908f, -0.06047635f, -0.01627779f, -0.01484820f, 
    -0.00044756f, -0.06003634f, -0.03720432f, 0.02275900f, 0.01298006f, 0.03420446f, -0.02379374f, -0.02420978f, 
    0.00768768f, -0.03064202f, 0.04768278f, -0.03013982f, -0.03315756f, -0.01179329f, -0.02650715f, -0.05037628f, 
    0.00818442f, 0.01163875f, -0.01325013f, -0.03166213f, 0.02077819f, 0.04347137f, 0.00594305f, 0.01429968f, 
    0.01208325f, -0.06069877f, 0.03900862f, 0.00011156f, 0.00936985f, -0.05698166f, 0.00023728f, 0.03720905f, 
    -0.02183092f, 0.01875016f, -0.04217226f, 0.02402600f, 0.00226612f, -0.04519323f, 0.01047899f, -0.04448920f, 
    0.01616139f, -0.03703357f, -0.04064783f, -0.01518504f, 0.03777175f, -0.02948878f, 0.03637933f, -0.03749546f, 
    -0.01444171f, -0.00739452f, -0.03684185f, -0.03619790f, -0.01660751f, -0.03237363f, -0.03837725f, -0.04014196f, 
    0.02612735f, 0.00767630f, -0.02312714f, -0.01083326f, -0.01400485f, -0.03146521f, -0.04966754f, 0.03445729f, 
    -0.05570312f, -0.01434059f, -0.02712557f, -0.05282513f, 0.02371418f, 0.00462079f, -0.04206752f, 0.00554457f, 
    0.00968677f, -0.00627018f, -0.04427764f, 0.02376423f, -0.03766727f, -0.03321950f, -0.01525106f, 0.01958323f, 
    -0.03715134f, 0.03996231f, 0.02637659f, -0.02803301f, -0.00519205f, -0.04267513f, 0.03570659f, -0.01008470f, 
    -0.01994412f, 0.03491025f, -0.01882826f, -0.01863642f, -0.03222840f, 0.03939699f, -0.01689550f, -0.00777107f, 
    -0.04240388f, 0.01961292f, -0.00499520f, -0.03056324f, 0.03093208f, -0.05617960f, 0.03134267f, -0.00161471f, 
    -0.00295410f, -0.05526594f, -0.03116652f, 0.00266068f, 0.01418783f, -0.01108942f, -0.00882167f, 0.02696422f, 
    0.02774421f, 0.01473832f, -0.01234298f, 0.00178983f, -0.00523315f, 0.03327977f, 0.01172968f, -0.03188080f, 
    -0.02616563f, 0.03706589f, 0.03436676f, 0.04068537f, 0.02075825f, 0.03909279f, -0.04760138f, -0.02686831f, 
    -0.02388824f, 0.00776419f, -0.00288758f, -0.00857177f, -0.04537031f, 0.02467743f, -0.05187421f, -0.01419723f, 
    0.02350982f, -0.04880055f, -0.04780172f, -0.01434008f, 0.02598070f, 0.02438259f, -0.02067524f, 0.02410330f, 
    -0.01842860f, -0.01699005f, -0.04327065f, 0.00260401f, -0.00479646f, -0.04115075f, 0.00123187f, -0.01022753f, 
    0.03740253f, -0.00113613f, -0.03692123f, -0.00005746f, 0.01919015f, -0.03884510f, 0.01928710f, 0.00563949f, 
    -0.00327419f, 0.00402131f, -0.00362505f, 0.03132541f, -0.03811754f, -0.02064114f, -0.00246482f, 0.04196706f, 
    0.03120187f, -0.05342782f, 0.03349488f, -0.01390119f, -0.02826208f, -0.04204351f, -0.02086996f, -0.00665820f, 
    0.02845500f, 0.01270044f, 0.01919475f, -0.02969675f, -0.03867725f, 0.01691061f, -0.02599427f, 0.02040249f, 
    -0.03549903f, -0.02337782f, 0.02556117f, -0.00244112f, 0.04019419f, -0.00735388f, -0.03936351f, 0.04076321f, 
    0.00132511f, 0.01231721f, -0.01280335f, -0.05755384f, 0.00960678f, 0.03268854f, -0.01760892f, -0.03877708f, 
    -0.04815675f, -0.05525239f, 0.02483607f, 0.00550057f, 0.04151497f, -0.01050482f, 0.00617561f, -0.00760037f, 
    -0.04383361f, 0.02539497f, -0.01868147f, -0.03268005f, 0.04083126f, -0.05926964f, 0.02947360f, -0.04701801f, 
    -0.06050473f, 0.01040241f, 0.03238602f, -0.00325461f, 0.00781874f, 0.04505546f, 0.00653313f, -0.01234784f, 
    -0.03442636f, -0.01414506f, 0.01418017f, 0.03018426f, -0.03296921f, -0.06062973f, -0.04185789f, 0.03670396f, 
    -0.00597959f, -0.00768475f, -0.02866458f, -0.03230201f, 0.02484402f, -0.03689237f, 0.03842872f, 0.03438322f, 
    0.02083236f, 0.01008799f, 0.02121169f, 0.00117659f, 0.00968897f, 0.03885289f, 0.02824074f, 0.04653094f, 
    0.01382867f, 0.04678943f, 0.03447527f, -0.01500708f, -0.02746686f, -0.01050244f, 0.04208775f, 0.00975169f, 
    -0.00948714f, -0.03944621f, -0.03306900f, 0.00434466f, 0.03646384f, -0.00280691f, -0.00938946f, 0.03824187f, 
    0.07098924f, -0.11906090f, -0.17296821f, 0.20281826f, 0.03717208f, 0.02608558f, -0.10851979f, -0.07358851f, 
    -0.03021088f, 0.03330002f, -0.11408976f, 0.03262378f, -0.16233233f, -0.23009010f, 0.13020259f, 0.04907972f, 
    0.09061355f, -0.10133597f, -0.01504413f, 0.21677919f, -0.11760188f, 0.01901343f, 0.01302839f, 0.06413294f, 
    -0.08371807f, -0.13645606f, -0.06757624f, -0.06219431f, 0.10731692f, -0.08506427f, 0.04216820f, 0.00814449f, 
    0.07143409f, 0.01733741f, -0.00437539f, 0.04074573f, -0.15801808f, -0.27540684f, 0.25698161f, 0.05378355f, 
    -0.17348491f, -0.13654958f, -0.01321177f, 0.15662757f, -0.05777646f, -0.04128612f, 0.06191188f, -0.01137700f, 
    -0.04216812f, 0.11438727f, -0.11294025f, 0.10703833f, 0.17072918f, -0.05355108f, 0.06469417f, -0.11332215f, 
    -0.00593069f, -0.03593066f, 0.01024734f, -0.00146374f, -0.25607216f, 0.01328420f, 0.05198966f, -0.01479279f, 
    -0.06869616f, 0.07360984f, -0.02948897f, -0.04826537f, 0.08835469f, -0.10800129f, 0.04052524f, -0.09845651f, 
    0.18593104f, 0.06601027f, -0.14331600f, 0.04560579f, 0.20014310f, -0.02747764f, -0.02249333f, -0.05869811f, 
    -0.03610110f, 0.07701058f, 0.00257040f, -0.05981683f, 0.11403663f, 0.05603873f, -0.04976849f, 0.07332865f, 
    0.27561024f, 0.05849085f, 0.05232228f, -0.15056895f, 0.03159007f, 0.08169314f, -0.00492818f, 0.02943557f, 
    -0.05148241f, -0.04010465f, -0.05552099f, -0.02986642f, 0.00519272f, -0.01439758f, 0.10334643f, -0.03530750f, 
    0.00485417f, -0.06315353f, -0.06789601f, -0.00066405f, 0.37463307f, -0.22622474f, -0.09401517f, 0.35288897f, 
    -0.06313884f, -0.05961213f, 0.01336200f, -0.04565334f, -0.01806746f, 0.14936531f, -0.03571508f, 0.07774282f, 
    0.19594914f, -0.04320184f, 0.02005510f, -0.25921652f, 0.16142748f, 0.00792538f, 0.02099412f, -0.00776518f, 
    0.01040659f, 0.04672801f, 0.09827728f, -0.09278695f, -0.07765971f, 0.18287779f, 0.24081153f, 0.25480062f, 
    0.15154652f, -0.01385548f, -0.00879840f, -0.01004020f, 0.02863505f, -0.16037449f, 0.09732411f, 0.04273565f, 
    0.27773282f, -0.01503299f, -0.04330394f, 0.00051345f, 0.01911654f, 0.05815586f, 0.02209969f, -0.05293986f, 
    0.17841852f, 0.11470214f, -0.04124090f, -0.01125724f, 0.03118821f, -0.05398304f, -0.07454934f, 0.06247397f, 
    0.12479125f, 0.00476064f, -0.12637809f, -0.00073667f, 0.10720185f, 0.09546144f, 0.01558065f, -0.06373180f, 
    -0.02384179f, 0.08690070f, 0.06957569f, -0.06240545f, -0.01682919f, 0.13162909f, 0.01888327f, -0.08384129f, 
    -0.04734743f, -0.13862488f, -0.05876621f, -0.10581749f, 0.49561322f, 0.27392146f, -0.16176441f, -0.01967770f, 
    0.04752940f, 0.14481451f, -0.15512311f, 0.04261781f, 0.09244469f, -0.00484901f, 0.10831276f, 0.15829378f, 
    0.13303331f, 0.21602355f, -0.12044425f, 0.19876017f, -0.02568141f, -0.05576155f, -0.05959171f, 0.04756352f, 
    0.10981730f, -0.00573684f, -0.04615039f, -0.00082821f, 0.06410262f, 0.32597071f, -0.40833715f, 0.11582883f, 
    -0.07346506f, 0.12586744f, 0.11648247f, 0.02915424f, 0.04218708f, -0.04662735f, 0.15623383f, -0.07656101f, 
    -0.00233098f, -0.01717888f, -0.21330090f, 0.15297641f, -0.05877094f, -0.08441620f, -0.05372808f, 0.04049646f, 
    -0.02277748f, -0.10493790f, 0.08526438f, -0.13545220f, 0.35611224f, -0.30864203f, 0.19714126f, -0.48580757f, 
    0.11475514f, 0.02218883f, 0.00423023f, -0.11978205f, -0.08882869f, 0.21521382f, -0.11166269f, 0.08656308f, 
    0.04249228f, -0.12243300f, -0.12960444f, 0.01199770f, 0.13934512f, -0.02342906f, -0.03087567f, -0.01703251f, 
    -0.04029546f, 0.10998533f, 0.13607292f, 0.04717492f, -0.02275098f, 0.10533130f, 0.40092903f, 0.10596101f, 
    -0.11901596f, -0.00662839f, -0.08103087f, -0.08187362f, -0.10913120f, 0.02858301f, -0.02684364f, -0.05407224f, 
    -0.08948726f, -0.01963202f, 0.09673986f, 0.02838928f, -0.07074479f, -0.03110111f, -0.04912973f, -0.13671665f, 
    -0.05056284f, -0.05635124f, 0.04366701f, 0.02907293f, -0.24902636f, 0.38728118f, -0.12316139f, 0.45510715f, 
    0.08466622f, 0.03497065f, -0.04847969f, 0.01838697f, 0.08939297f, 0.01197677f, 0.07999044f, -0.01092482f, 
    0.11074849f, 0.29536259f, 0.11342014f, -0.49428278f, 0.06610934f, -0.08753249f, 0.13823430f, -0.03466482f, 
    0.01401933f, 0.11283905f, -0.05484480f, 0.01510402f, 0.03979597f, 0.19623606f, 0.08923426f, -0.01543495f, 
    0.19790946f, -0.02936751f, 0.05681190f, -0.01609176f, -0.01717029f, -0.04059155f, -0.08761272f, 0.18543307f, 
    0.06720175f, 0.03578275f, 0.02879121f, 0.16017565f, -0.03293972f, -0.00394402f, -0.03514539f, -0.12796484f, 
    0.05956908f, -0.03215041f, 0.10049170f, 0.08697872f, 0.04010141f, 0.21642174f, 0.35609603f, 0.17618053f, 
    0.10031228f, 0.20566972f, -0.06100304f, 0.08507668f, -0.01293182f, 0.05848766f, 0.16152619f, -0.01882846f, 
    -0.04843238f, -0.12928461f, 0.02829563f, -0.07605109f, -0.03746525f, -0.07699525f, 0.07009058f, -0.20253962f, 
    -0.02059912f, 0.01978100f, 0.05255163f, -0.16960557f, -0.32931894f, 0.08324572f, 0.22062084f, 0.54233748f, 
    -0.08270336f, -0.00408567f, 0.13582551f, -0.01147761f, -0.12861158f, -0.07273577f, 0.05238224f, -0.13083962f, 
    0.15619494f, 0.23003913f, 0.20630975f, 0.00075008f, -0.15754855f, 0.02938876f, 0.02823867f, -0.06866542f, 
    0.05626811f, 0.08843152f, 0.06430244f, -0.11730845f, 0.26844770f, -0.30551556f, 0.07248286f, -0.37059915f, 
    -0.03478277f, -0.04151322f, -0.00433766f, 0.00248297f, 0.03380112f, 0.07223216f, 0.05400846f, 0.02104732f, 
    0.19057012f, 0.20522285f, 0.05807994f, 0.05060349f, -0.04370670f, -0.04769927f, -0.02402818f, -0.01604372f, 
    -0.01097183f, -0.08049884f, -0.00687543f, -0.10117254f, 0.14630845f, -0.24871385f, 0.01398307f, 0.16621831f, 
    -0.06442566f, -0.07509947f, 0.09665533f, -0.00572662f, 0.01055965f, 0.08074918f, -0.05813573f, 0.10520630f, 
    0.23402414f, -0.12137938f, -0.17799056f, -0.00228212f, -0.02020470f, 0.12023316f, 0.03811346f, -0.07271001f, 
    -0.01198835f, 0.01875908f, 0.03246750f, 0.01742376f, 0.20176141f, -0.21568194f, -0.04201834f, 0.09443320f, 
    0.13040143f, -0.00143494f, -0.07270907f, 0.07509086f, -0.05650387f, 0.03687639f, 0.03643168f, 0.01372623f, 
    0.00503134f, 0.19993386f, 0.11909702f, 0.02202104f, -0.00186398f, -0.00527630f, -0.03662574f, -0.03080775f, 
    -0.05038917f, 0.16869329f, -0.16012949f, -0.14544107f, -0.10314967f, -0.11958458f, 0.01796471f, -0.10486791f, 
    0.06409150f, -0.02478744f, 0.00662292f, -0.07406931f, -0.11604561f, 0.00377053f, -0.04708929f, -0.07245562f, 
    0.00279669f, 0.26956844f, 0.05512820f, 0.09050051f, -0.00908620f, 0.04557369f, -0.02206522f, -0.04382537f, 
    -0.10511591f, 0.00210456f, 0.05696784f, -0.01037385f, 0.50945187f, 0.26572859f, -0.19215164f, -0.12725356f, 
    0.09756581f, -0.09531492f, -0.05371289f, 0.02805976f, 0.06587154f, 0.05732100f, -0.07718386f, 0.07731564f, 
    0.00120573f, 0.02205892f, 0.21798465f, -0.03083075f, 0.01148654f, 0.07342221f, -0.04457970f, 0.07445884f, 
    0.03934599f, 0.06788127f, 0.03819117f, 0.01236065f, 0.41968474f, -0.39596042f, -0.21889248f, -0.11805863f, 
    0.07919262f, 0.08285012f, 0.03799087f, 0.09367039f, -0.03511126f, 0.02484201f, 0.03258397f, 0.03108535f, 
    -0.05136469f, 0.29356700f, 0.07614939f, 0.15332167f, 0.07270015f, -0.02431319f, 0.04171251f, 0.07551415f, 
    0.06981474f, 0.02051509f, 0.00181819f, 0.03262134f, -0.01868803f, -0.05065913f, -0.14598528f, -0.01230241f, 
    -0.05199201f, 0.04165867f, -0.06032490f, -0.04228329f, 0.06498343f, 0.03161925f, 0.18173274f, 0.09733011f, 
    0.66848367f, 0.03883963f, -0.22691886f, 0.06772675f, -0.01574990f, 0.07288151f, -0.06607972f, -0.03305623f, 
    -0.01096629f, -0.03090126f, 0.06100256f, 0.08190874f, 0.35577402f, -0.16307811f, -0.03716754f, -0.17312197f, 
    -0.08205682f, -0.08767018f, 0.05343599f, -0.00465458f, 0.06703425f, 0.07103253f, 0.04313327f, 0.00681906f, 
    0.37026143f, 0.17036407f, 0.25949818f, 0.06173034f, -0.00540532f, 0.03753471f, -0.06901256f, 0.05160541f, 
    -0.13430193f, 0.07278080f, -0.03013178f, -0.09321614f, -0.64811808f, -0.41536033f, 0.16518572f, 0.15520616f, 
    -0.11044557f, 0.11873499f, -0.06291329f, -0.06804821f, -0.00872230f, 0.03139948f, 0.11964665f, 0.11644953f, 
    -0.02094508f, -0.04359077f, -0.10614860f, -0.17431433f, 0.00485708f, 0.03332924f, -0.12676615f, -0.03386422f, 
    -0.06305103f, -0.00811371f, -0.06555254f, -0.01428336f, 0.18191394f, 0.33885759f, 0.07348238f, -0.06263499f, 
    -0.08233396f, -0.05016436f, 0.00870794f, 0.10759398f, 0.09672654f, 0.07204615f, -0.03559441f, 0.07206136f, 
    -0.04998069f, -0.13002050f, -0.32472998f, -0.08070367f, -0.01544209f, -0.03325496f, 0.05768877f, 0.04289570f, 
    0.08633878f, 0.03644876f, -0.09973143f, -0.01171175f, 0.25065729f, -0.04390195f, 0.01756456f, 0.20877418f, 
    -0.09971441f, -0.15905662f, 0.02561351f, -0.01276215f, 0.14416435f, -0.07781681f, 0.04583561f, 0.02719764f, 
    0.54120457f, 0.44316471f, 0.17126334f, -0.06316230f, 0.01319581f, 0.04030058f, -0.08603142f, 0.07760300f, 
    0.01580954f, 0.12183034f, 0.00667786f, 0.03361853f, 0.11502214f, -0.26060656f, 0.10195397f, -0.03009513f, 
    0.07390077f, 0.10664802f, 0.05535279f, -0.04582474f, -0.01354578f, 0.03673954f, -0.07230016f, 0.02988369f, 
    -0.09287123f, 0.05762766f, -0.05934204f, -0.06985968f, -0.07028093f, -0.00058891f, -0.14333667f, -0.13475107f, 
    -0.05265757f, 0.07304839f, -0.10399023f, 0.12521131f, 0.12241940f, 0.19247314f, -0.07592607f, 0.05054853f, 
    0.14729241f, -0.05508532f, -0.00499973f, 0.15369253f, -0.02222002f, -0.04169761f, 0.06591018f, -0.05445018f, 
    0.52088380f, -0.10195690f, -0.17622937f, 0.15062433f, 0.21216820f, -0.02924437f, 0.12661833f, -0.03580866f, 
    0.08155128f, -0.07372494f, 0.11605705f, 0.02011055f, -0.08335148f, -0.08648404f, 0.07986821f, 0.06055144f, 
    -0.07040697f, 0.06009762f, -0.10554685f, -0.08497298f, 0.02553373f, 0.08205679f, 0.11664069f, -0.01584908f, 
    -0.23765500f, -0.37732723f, -0.27700058f, -0.13294952f, -0.00546294f, 0.11147825f, 0.00654230f, 0.03457185f, 
    -0.09123985f, -0.07374872f, 0.04827834f, -0.03981278f, -0.13269241f, -0.07727204f, 0.04512821f, 0.04630514f, 
    0.17386465f, -0.07302876f, -0.01777643f, 0.05980115f, 0.02559247f, 0.08037201f, -0.01485816f, -0.03849004f, 
    0.11593422f, 0.08314309f, -0.04338299f, 0.12036299f, -0.04238603f, -0.01635982f, 0.15402703f, 0.08113936f, 
    -0.01460640f, -0.12161164f, -0.18331493f, -0.07740266f, 0.18818165f, -0.12904339f, 0.00067551f, -0.10519192f, 
    0.04225953f, 0.11648716f, -0.16393179f, 0.03989383f, -0.05317681f, 0.10471671f, -0.08415406f, 0.06862822f, 
    0.07751820f, -0.04020914f, 0.09511068f, 0.09832899f, -0.02367677f, 0.04610135f, 0.01788721f, -0.06253591f, 
    0.03029871f, -0.10625429f, 0.01630252f, -0.06410856f, 0.22554871f, -0.07897352f, 0.06052659f, 0.24347235f, 
    0.03536670f, 0.01940837f, -0.02043749f, -0.14066692f, -0.01896937f, -0.00496369f, -0.01185123f, 0.09833335f, 
    0.21393192f, 0.04548125f, 0.17344147f, 0.11751641f, -0.07750643f, 0.06500129f, 0.00679788f, 0.13600992f, 
    -0.08302656f, -0.00626320f, 0.09199550f, -0.02817449f, -0.48640510f, -0.08858330f, 0.03000092f, -0.02310272f, 
    -0.02410707f, 0.05487151f, 0.11250285f, 0.00392985f, -0.00638455f, 0.04382852f, 0.04440549f, -0.02899373f, 
    0.19827361f, 0.05435906f, 0.22097424f, -0.08184931f, -0.04606106f, -0.02501325f, -0.13572526f, 0.15095197f, 
    -0.04208086f, -0.10040982f, -0.05263419f, 0.07375428f, 0.07463106f, 0.12030302f, -0.19084483f, -0.10515968f, 
    -0.01206054f, 0.10751995f, -0.07342365f, 0.02562379f, 0.00627509f, 0.05073194f, -0.05002918f, 0.02051418f, 
    0.14192098f, -0.09244663f, 0.45809066f, -0.05826788f, 0.03850705f, 0.00464354f, 0.01287332f, -0.01341412f, 
    0.04440522f, 0.09641152f, 0.00816658f, 0.14627877f, 0.25830138f, 0.04434001f, -0.26999837f, -0.06323225f, 
    0.09890264f, 0.05464058f, -0.08131462f, -0.06779867f, 0.02973551f, -0.00491869f, 0.14508361f, 0.02014921f, 
    0.19294107f, 0.02255758f, 0.28785536f, -0.04569426f, -0.03433727f, -0.01672189f, 0.09484203f, 0.08440312f, 
    0.16005911f, 0.12951283f, 0.12760888f, 0.02213914f, 0.41927740f, 0.33397177f, 0.35852751f, -0.06113543f, 
    -0.03068655f, 0.05058639f, 0.12544474f, 0.00770539f, -0.07709325f, 0.11302995f, 0.12563963f, 0.13900019f, 
    0.28188953f, -0.29464296f, 0.03653899f, -0.36398149f, 0.11086501f, 0.04549709f, 0.00715190f, 0.00608885f, 
    0.09788357f, 0.00028803f, -0.00447768f, -0.00413584f, 0.26577321f, 0.13237521f, -0.14265622f, -0.03586740f, 
    -0.09360038f, 0.10562054f, 0.04302300f, -0.03721211f, -0.05485772f, 0.02777079f, 0.04531091f, -0.03734183f, 
    0.15108719f, 0.24475768f, 0.27216259f, 0.07294781f, -0.07749408f, -0.01357239f, 0.06609959f, 0.18459558f, 
    -0.05681374f, -0.00002281f, -0.00299965f, 0.13442406f, -0.05883737f, -0.04137318f, -0.35988879f, 0.07647811f, 
    0.07956599f, -0.07426243f, 0.08349088f, -0.04080201f, 0.19517499f, 0.01142879f, 0.03436447f, -0.13288459f, 
    -0.13447124f, -0.09945802f, 0.01253182f, 0.13500530f, 0.00550548f, -0.05144769f, 0.20014271f, -0.00379437f, 
    0.08344253f, -0.01658487f, 0.08906765f, 0.01962904f, 0.32038176f, 0.02766223f, 0.07206243f, -0.13342106f, 
    -0.06513357f, 0.22640461f, 0.09901264f, -0.14957735f, -0.03196189f, -0.05263387f, 0.06291304f, 0.03302656f, 
    0.26518399f, -0.14036290f, 0.11538623f, 0.02730769f, 0.03641725f, 0.03508826f, 0.00587583f, -0.05539933f, 
    -0.06721129f, 0.07270417f, -0.04216221f, 0.13286367f, -0.13626319f, -0.10461563f, -0.06949741f, 0.22465594f, 
    -0.22453684f, 0.16101392f, -0.02710711f, 0.05297435f, -0.16283220f, 0.19544469f, -0.13087417f, 0.08628222f, 
    -0.02910544f, -0.22479656f, 0.01036632f, 0.06693120f, 0.06836732f, -0.03407263f, 0.13258742f, 0.04071569f, 
    0.01386180f, 0.13825579f, 0.13308920f, -0.08670183f, -0.18612623f, -0.28035811f, 0.07471438f, 0.15851229f, 
    0.01229355f, -0.12767617f, 0.02580129f, -0.07787254f, 0.01319443f, -0.04957855f, 0.02795245f, -0.17502128f, 
    -0.18731019f, 0.00536117f, -0.04766112f, 0.32949466f, -0.00027583f, -0.03120823f, 0.10458732f, -0.09496652f, 
    -0.12904783f, 0.07995728f, 0.13517945f, 0.08407570f, -0.14834839f, 0.12866172f, -0.28221101f, -0.22307433f, 
    0.07357179f, 0.15202947f, -0.15298261f, 0.08911926f, 0.12272320f, -0.10328850f, -0.15774681f, 0.00550869f, 
    0.14403124f, 0.00584948f, 0.22889856f, -0.00302420f, -0.04662118f, -0.08900072f, 0.15177764f, 0.02449897f, 
    0.00529471f, -0.22123504f, 0.07446996f, 0.00971805f, 0.24986486f, -0.21769474f, -0.26044178f, 0.03187105f, 
    0.10606865f, 0.12990786f, -0.05471316f, 0.10416260f, -0.05715129f, 0.09240185f, -0.04826237f, 0.05828578f, 
    0.22937514f, -0.17763396f, -0.22386387f, -0.13439523f, 0.18973677f, 0.14717872f, -0.07781042f, -0.07353748f, 
    0.16746461f, -0.00088772f, -0.16516544f, 0.04439724f, 0.19604251f, -0.41145495f, 0.04906133f, -0.03624899f, 
    0.12188897f, -0.26659831f, 0.14682867f, 0.05402241f, -0.09617749f, 0.03005822f, -0.03492344f, 0.04375963f, 
    0.33671570f, -0.30333221f, 0.00051393f, 0.05720343f, -0.01748660f, 0.09841812f, -0.14439401f, 0.19571459f, 
    -0.04137223f, -0.11751299f, 0.06586765f, -0.05858975f, 0.16093105f, -0.15801348f, -0.12454738f, -0.08874181f, 
    -0.09217157f, 0.10393178f, 0.03592500f, 0.06423602f, -0.01621456f, 0.16707641f, -0.03211864f, 0.12440382f, 
    -0.13434175f, 0.00886953f, -0.25671911f, -0.08402095f, -0.00888586f, 0.10486163f, 0.04210252f, 0.11067270f, 
    -0.02552927f, 0.09446838f, -0.07752262f, 0.07026563f, -0.03142153f, -0.17650174f, -0.07690339f, 0.06027830f, 
    -0.06090634f, -0.02992553f, 0.03227822f, 0.05181004f, 0.00145269f, 0.00788237f, 0.00160931f, -0.02911202f, 
    0.02645208f, 0.06443755f, 0.00540258f, 0.08728258f, 0.01778395f, 0.09269121f, -0.01664882f, -0.02611712f, 
    -0.23766010f, 0.09840324f, 0.06818262f, 0.07971994f, -0.02685260f, -0.13258456f, -0.22744760f, 0.06210880f, 
    0.04838717f, 0.04885870f, -0.01435937f, 0.01529249f, 0.12985243f, -0.01716777f, 0.12956440f, 0.11579183f, 
    0.35765237f, -0.17356963f, -0.06678081f, -0.02700645f, 0.07464240f, 0.07160590f, 0.10834546f, 0.06164147f, 
    -0.07791797f, -0.15211150f, 0.18397628f, -0.00792135f, 0.02836427f, 0.02274417f, -0.21134642f, 0.00179960f, 
    -0.10717216f, 0.14389704f, -0.02683247f, 0.01654815f, -0.04936752f, 0.04648115f, -0.07471436f, -0.04510917f, 
    0.08140634f, -0.19199733f, 0.08017712f, 0.17574744f, -0.04157719f, 0.11581637f, 0.03525851f, 0.14440657f, 
    -0.02851166f, 0.12079480f, 0.02979459f, -0.00563104f, -0.14625970f, -0.04501921f, -0.14938600f, 0.03059455f, 
    0.04784336f, 0.09460954f, 0.00714427f, 0.15881765f, -0.14169464f, 0.19540469f, -0.02665359f, 0.17280848f, 
    0.12514468f, -0.02942489f, 0.07219715f, 0.16375263f, 0.03350647f, -0.07614601f, 0.12441826f, 0.06450900f, 
    0.11136277f, 0.05249421f, -0.01833181f, 0.14071868f, 0.12794617f, 0.03616514f, 0.10265006f, 0.03107186f, 
    -0.01444352f, -0.04653772f, -0.05012123f, 0.22228743f, -0.15144616f, 0.12461121f, -0.04199990f, 0.12406094f, 
    0.20963459f, -0.27183622f, -0.09311079f, -0.18729287f, -0.11143196f, -0.20346522f, 0.00952499f, 0.04396945f, 
    -0.01106946f, 0.04689492f, -0.02644421f, 0.01133713f, 0.06347579f, 0.15576805f, -0.09566065f, -0.07496551f, 
    -0.05099732f, -0.02830987f, -0.14201382f, 0.17014408f, 0.06970181f, -0.08836655f, 0.10010394f, 0.04942523f, 
    0.12956686f, -0.15775011f, -0.27680388f, -0.02833162f, -0.00071621f, -0.03431436f, 0.04382871f, 0.04311112f, 
    0.08082143f, 0.03009884f, -0.02014997f, 0.12347967f, 0.22469954f, 0.04027565f, -0.06300446f, 0.09245172f, 
    -0.16413477f, -0.08546296f, 0.05432992f, 0.00463522f, 0.13320565f, 0.14217132f, -0.09875654f, -0.03461911f, 
    0.24569409f, -0.27787903f, -0.16145340f, 0.03108254f, 0.03824694f, -0.04230278f, 0.17532788f, 0.07331844f, 
    -0.00333741f, -0.00598726f, -0.00908044f, 0.03283974f, -0.03897424f, 0.23512965f, -0.23000394f, 0.03002278f, 
    -0.14105916f, 0.02615906f, 0.08570398f, 0.01626080f, 0.09156398f, 0.07455907f, 0.06748566f, -0.06425252f, 
    -0.04933116f, -0.18810230f, -0.08779720f, -0.15712291f, 0.02491077f, -0.11736187f, -0.00217755f, -0.01146343f, 
    0.13540943f, -0.01827774f, -0.01933509f, 0.05472151f, -0.11066257f, 0.13267976f, 0.07114706f, 0.10302366f, 
    -0.05467677f, -0.04233667f, -0.10152582f, -0.09950989f, 0.14705031f, 0.00374625f, 0.03116920f, -0.14754891f, 
    0.15793209f, 0.06318336f, 0.05665439f, 0.07851200f, 0.04306210f, -0.11864570f, -0.03621381f, -0.07853604f, 
    0.14987640f, 0.12661350f, 0.14995411f, 0.14341277f, -0.00677424f, 0.03034913f, -0.12545113f, -0.16660759f, 
    -0.08454827f, -0.18077233f, 0.00918623f, -0.02825324f, 0.12047800f, -0.23859011f, 0.00305868f, 0.08508847f, 
    -0.09280464f, -0.42903027f, 0.14703985f, -0.06669834f, -0.00354587f, -0.08664451f, -0.03665240f, 0.09892617f, 
    0.17551768f, -0.00303232f, 0.01148072f, 0.02853433f, -0.12651573f, 0.13366173f, -0.08970223f, -0.07359765f, 
    0.11559630f, 0.14581230f, -0.08086129f, 0.13458657f, 0.04931157f, 0.06617320f, -0.03507087f, -0.05665898f, 
    0.32252684f, -0.09834103f, -0.16492778f, 0.09616423f, -0.08810354f, 0.12781464f, 0.05103382f, 0.03061412f, 
    -0.03965240f, 0.16029669f, 0.13473088f, 0.06861412f, -0.06467257f, -0.19203737f, -0.22350705f, -0.01109497f, 
    -0.01653446f, 0.05683838f, -0.03547675f, -0.13022746f, -0.10147704f, 0.00778292f, 0.08921388f, -0.11701664f, 
    0.08200327f, 0.10003632f, -0.01216928f, 0.27638382f, -0.08320677f, 0.18915406f, 0.13265301f, -0.05372302f, 
    -0.02091447f, 0.02745307f, 0.10657798f, -0.07896256f, -0.29140797f, -0.11419404f, -0.08151451f, -0.36258617f, 
    -0.01234116f, -0.00932763f, -0.13355482f, -0.13254538f, -0.03756076f, 0.04863991f, -0.09991011f, 0.03764492f, 
    0.13877471f, -0.36442474f, -0.13773726f, 0.11692072f, 0.18991148f, -0.12033336f, -0.05898194f, 0.07824684f, 
    0.02404220f, 0.03274557f, 0.13179517f, 0.09147498f, 0.40488869f, -0.02096295f, -0.05722236f, 0.24830776f, 
    -0.17673324f, -0.01641611f, 0.00565362f, 0.13557461f, -0.05016586f, -0.01728640f, 0.03155450f, 0.06144638f, 
    0.01735778f, 0.18586035f, 0.20158991f, -0.20513529f, 0.07575171f, -0.05860559f, 0.07330418f, -0.01595728f, 
    0.17834853f, -0.00741309f, 0.09634966f, 0.04210006f, -0.19182587f, -0.40802217f, 0.08122104f, -0.14607336f, 
    0.07024059f, 0.00556747f, -0.01589627f, -0.14595461f, -0.08874716f, 0.01738009f, -0.05386820f, 0.08066296f, 
    -0.68353695f, -0.07300366f, 0.06093426f, 0.13575299f, 0.10399237f, 0.05124906f, 0.04807625f, -0.02867390f, 
    -0.02004098f, 0.00045830f, 0.12257031f, 0.07281914f, 0.21323869f, 0.12265756f, 0.05085379f, -0.10125601f, 
    -0.16076727f, 0.01261582f, 0.13717557f, -0.08249658f, 0.05579155f, -0.11210028f, 0.06522363f, 0.11072393f, 
    -0.14468652f, 0.27369606f, 0.00290481f, -0.08039553f, 0.07417642f, 0.05779573f, 0.06928280f, -0.01838159f, 
    0.11260527f, 0.11237945f, 0.09609766f, 0.08591605f, -0.05650333f, -0.03897022f, -0.07387017f, -0.00642607f, 
    0.11268660f, -0.00439035f, -0.01666441f, 0.19752489f, 0.09888136f, -0.03405904f, -0.11999250f, -0.00284362f, 
    0.07757733f, -0.23319735f, -0.01303937f, 0.11096893f, -0.18678065f, 0.14100753f, -0.27400494f, -0.13980550f, 
    -0.10336021f, 0.14477481f, 0.09173764f, 0.03173671f, 0.04217298f, 0.06263392f, -0.14328752f, 0.08090676f, 
    -0.05004980f, -0.09039212f, 0.06681529f, -0.02392778f, -0.07003662f, 0.08374608f, 0.07385007f, -0.04854532f, 
    0.12540847f, 0.16612354f, -0.11638517f, 0.00677095f, 0.11162166f, 0.12147044f, 0.08193915f, 0.04077430f, 
    -0.07278730f, -0.08780999f, 0.23549564f, -0.06741391f, -0.08291183f, -0.13007955f, 0.03646638f, -0.01855780f, 
    0.00238454f, -0.02977715f, -0.01898997f, 0.03197263f, -0.04930597f, 0.11414614f, 0.11937903f, 0.05994531f, 
    -0.05820184f, -0.00170699f, -0.10974851f, -0.00576419f, 0.06474125f, -0.11664491f, -0.02299834f, -0.02428407f, 
    0.05587393f, 0.05994438f, -0.01779015f, -0.00783933f, 0.25408274f, 0.28170910f, 0.11199874f, -0.07414056f, 
    0.10154922f, 0.09145009f, -0.02813980f, 0.03484768f, -0.02421472f, -0.08612569f, 0.07012520f, -0.00803795f, 
    -0.31057465f, 0.00028430f, -0.04502887f, -0.12921551f, 0.07460995f, 0.05303920f, 0.05518093f, -0.07097910f, 
    -0.07542798f, 0.00348467f, 0.03980220f, 0.14958230f, -0.23761661f, 0.04959371f, -0.06048052f, -0.10586968f, 
    0.10311100f, 0.09529794f, 0.10102161f, -0.05935936f, 0.12254898f, 0.01933180f, 0.06541165f, 0.00993037f, 
    0.22006904f, 0.09191761f, -0.13153598f, -0.03642008f, -0.11949522f, 0.14383470f, -0.00443485f, 0.09886244f, 
    -0.08759227f, -0.02033082f, -0.02810723f, -0.08152980f, -0.06378976f, 0.08886692f, 0.11565170f, 0.26564732f, 
    0.09042400f, 0.05471656f, 0.22185661f, 0.04859479f, 0.07052449f, 0.01019897f, -0.11194512f, 0.04957026f, 
    -0.22031388f, -0.05126082f, -0.02118990f, 0.03104437f, -0.08523070f, 0.01531447f, -0.09166728f, 0.04686093f, 
    -0.01014329f, -0.09895693f, -0.01816756f, 0.09414759f, -0.09065424f, -0.10310529f, 0.11853169f, 0.04486929f, 
    -0.11630383f, -0.10609964f, -0.06527905f, 0.06854264f, -0.04538481f, -0.11391626f, 0.01360752f, 0.01726888f, 
    -0.28915006f, 0.35872769f, 0.01948627f, 0.17030555f, -0.06302590f, 0.01836285f, 0.02491959f, 0.03846758f, 
    -0.05475408f, 0.10924966f, -0.05893248f, 0.07184345f, -0.24644798f, -0.03698850f, 0.41160917f, 0.15741964f, 
    0.08729233f, -0.13814846f, -0.05359197f, 0.02659171f, -0.09257149f, 0.07123647f, -0.02745777f, 0.08391291f, 
    -0.20800206f, -0.01101391f, -0.09710367f, -0.10444617f, -0.10767514f, 0.00063326f, -0.02393300f, -0.03649789f, 
    0.00111085f, 0.06176443f, -0.04512471f, -0.02603265f, 0.02167913f, 0.07493073f, 0.16684885f, -0.08232723f, 
    0.04273780f, 0.02925934f, 0.12709664f, 0.08506576f, -0.17824002f, 0.02273899f, 0.04566152f, 0.15243351f, 
    -0.00090742f, 0.03116266f, 0.14022382f, 0.12980576f, -0.10516890f, 0.13746133f, -0.03654797f, 0.10483764f, 
    -0.08811935f, 0.05627397f, -0.00028912f, -0.14711364f, 0.03393068f, 0.17221367f, 0.12377963f, 0.13612802f, 
    -0.03375744f, 0.06001329f, 0.08989292f, 0.11018637f, 0.02148598f, 0.11214466f, -0.01122448f, 0.08510298f, 
    -0.02294938f, 0.22719270f, -0.15131068f, -0.06149099f, -0.02766681f, -0.06379250f, 0.00689832f, 0.04664310f, 
    0.08724815f, -0.06044246f, -0.05520636f, -0.13110511f, 0.31813097f, 0.21107857f, 0.22547752f, 0.03041256f, 
    0.11601505f, -0.09550127f, 0.20085716f, -0.05471734f, 0.03674937f, -0.19308408f, 0.14345859f, 0.18285802f, 
    -0.00805982f, 0.00347605f, 0.17879736f, 0.11056505f, 0.02063048f, -0.00912851f, 0.03552103f, -0.02040831f, 
    0.01747665f, -0.01026446f, -0.13403086f, 0.04387728f, 0.33764625f, 0.02761214f, 0.15639353f, -0.05158595f, 
    -0.00363074f, 0.00062067f, 0.11572311f, -0.02163372f, -0.03150342f, 0.02586743f, -0.05053423f, 0.17963998f, 
    0.02093006f, -0.00284578f, 0.30293375f, 0.04384329f, -0.00188126f, 0.01821872f, -0.08045547f, 0.16141084f, 
    0.01840680f, -0.05352671f, -0.10740604f, 0.14406005f, 0.00678334f, 0.18799280f, 0.30097187f, 0.33618695f, 
    0.02260277f, -0.00387315f, 0.23732297f, 0.12979080f, 0.02865138f, 0.12823752f, 0.16265553f, 0.13651973f, 
    -0.16445136f, -0.03422920f, 0.13607736f, -0.03194819f, -0.06794141f, 0.14606969f, 0.00663618f, -0.01801027f, 
    0.09051795f, 0.06041879f, -0.14078131f, -0.01374145f, -0.30647698f, 0.22120851f, 0.13438657f, -0.11838883f, 
    0.08956432f, -0.06737301f, 0.06669649f, -0.06183704f, 0.13879517f, -0.04013566f, 0.08317685f, -0.10872734f, 
    0.03006151f, 0.30886021f, 0.12668622f, 0.35522676f, 0.03312993f, -0.05448013f, 0.07096770f, 0.10978688f, 
    -0.04651545f, 0.13614966f, 0.21980578f, -0.11117748f, 0.03594625f, 0.00492490f, -0.01960479f, -0.15221310f, 
    0.06129276f, 0.26151344f, -0.00786669f, -0.11297193f, 0.09569326f, 0.10456558f, 0.10155427f, -0.10813646f, 
    -0.34851366f, 0.28521872f, 0.06120896f, 0.11897827f, 0.01686474f, -0.00124694f, -0.01729035f, -0.04005541f, 
    -0.03425729f, 0.04282882f, -0.07492618f, -0.01160814f, -0.02162934f, 0.05621719f, -0.03469482f, 0.16091777f, 
    0.16493125f, 0.10519989f, -0.05806492f, 0.08431046f, 0.13263196f, 0.04289734f, 0.08555003f, 0.07399312f, 
    0.25617164f, 0.02045104f, 0.36003944f, 0.35921705f, 0.00567553f, -0.14279966f, -0.01557338f, 0.01862906f, 
    -0.07742357f, -0.00147861f, -0.00836731f, -0.01512099f, -0.09078699f, 0.15801720f, -0.11583095f, -0.09961907f, 
    0.09590963f, 0.00395108f, 0.17041847f, -0.02471720f, 0.11961717f, 0.06003942f, 0.01817499f, 0.15424263f, 
    -0.03244988f, 0.15745901f, 0.13233793f, -0.07312667f, 0.09772409f, -0.03196282f, 0.08449937f, 0.05804745f, 
    0.17445798f, -0.15016147f, -0.02309295f, -0.06716315f, -0.07996164f, 0.11050875f, 0.08810291f, -0.22344476f, 
    0.25249115f, 0.11588851f, 0.09107891f, 0.06580126f, -0.01379760f, -0.01109902f, -0.11331633f, 0.11046267f, 
    -0.49614125f, 0.06425163f, -0.01674671f, 0.02841878f, 0.22780067f, -0.12842850f, -0.04981916f, -0.00452186f, 
    0.02887561f, 0.05760809f, -0.19491093f, 0.02672889f, -0.01825284f, 0.20653866f, 0.20132315f, 0.08687166f, 
    0.18839760f, 0.10198565f, 0.10951670f, 0.07781632f, 0.02832499f, -0.05629570f, 0.03555561f, -0.03628422f, 
    -0.03550786f, -0.03797995f, -0.05628592f, 0.03164605f, -0.02612574f, 0.00367770f, -0.03204641f, 0.01269092f, 
    0.00019150f, -0.02947429f, -0.05177310f, -0.02121746f, -0.02492751f, 0.04134794f, -0.00167007f, -0.03324459f, 
    0.02228304f, -0.01225937f, 0.00396613f, 0.01816444f, -0.04543902f, -0.03199130f, 0.01007082f, -0.04942850f, 
    -0.04735624f, -0.01510410f, -0.05069106f, -0.04895025f, -0.00027446f, -0.00332381f, 0.00023833f, -0.00711194f, 
    -0.02242904f, -0.00018284f, -0.01797060f, -0.00279675f, 0.00029312f, 0.01564097f, -0.02667757f, -0.01751844f, 
    0.03262820f, -0.02773844f, 0.00801710f, -0.02504423f, -0.02738060f, 0.04707722f, -0.03193055f, -0.04600916f, 
    0.01637581f, -0.05716456f, -0.01578301f, -0.02287658f, 0.01220525f, 0.00652811f, -0.02550984f, -0.00901778f, 
    0.03278774f, 0.00429551f, 0.03070999f, -0.01778467f, 0.03242462f, -0.03917229f, -0.05819831f, 0.00979005f, 
    0.02191924f, -0.02119260f, -0.01932999f, -0.01032591f, -0.04548969f, -0.00715963f, -0.01269659f, 0.00572670f, 
    0.00977617f, -0.00812759f, -0.04654502f, -0.02463377f, 0.04226921f, -0.04139468f, 0.04243388f, -0.04666803f, 
    0.02114479f, -0.05813403f, 0.02671874f, 0.03817273f, -0.03782287f, 0.03275517f, 0.00751968f, -0.00756191f, 
    0.02765985f, -0.05100795f, 0.00028718f, 0.04079729f, -0.04266763f, -0.01304078f, -0.02725730f, -0.03512936f, 
    -0.01047331f, -0.00992750f, -0.01740678f, -0.05429653f, -0.01159240f, 0.01222628f, 0.03628995f, 0.01188224f, 
    0.00453729f, -0.02838074f, 0.00274287f, 0.00892574f, 0.02013935f, -0.04437337f, 0.03284055f, -0.05111563f, 
    -0.03553008f, -0.00855525f, 0.03898950f, 0.00890786f, 0.00575936f, 0.01485448f, -0.02336749f, -0.01719956f, 
    0.02143167f, 0.02428823f, -0.01965710f, -0.00495049f, 0.00253999f, -0.04510185f, -0.02216853f, -0.03875300f, 
    0.03522999f, -0.04437885f, -0.00320463f, 0.03942881f, -0.04690326f, -0.04044133f, -0.01123563f, 0.03286061f, 
    0.01141296f, 0.00967671f, -0.00640541f, 0.02884806f, 0.01226977f, -0.02115279f, -0.01458368f, -0.04733187f, 
    0.04139471f, 0.03639612f, 0.00708374f, -0.05281768f, -0.00189639f, -0.03520901f, -0.00710257f, 0.02664842f, 
    -0.03439744f, -0.01223630f, 0.00211675f, 0.01736397f, -0.01693442f, -0.01261137f, -0.04555431f, 0.02086253f, 
    -0.02552835f, -0.01590157f, -0.00841807f, 0.03234761f, -0.00407754f, 0.00117149f, 0.03854473f, 0.00250328f, 
    0.00624142f, 0.02746867f, 0.03508791f, -0.05531213f, 0.00175551f, -0.01258576f, 0.03402285f, 0.03350283f, 
    0.01736945f, -0.05072343f, 0.00055885f, 0.03118083f, -0.03317555f, 0.01587185f, 0.02599429f, -0.01026350f, 
    0.03687678f, -0.02511551f, 0.01607071f, -0.00317738f, -0.02695221f, 0.01932611f, 0.01715040f, 0.02944348f, 
    -0.04155677f, 0.03742082f, -0.02215202f, -0.01934911f, 0.00998902f, -0.02932018f, 0.03800893f, -0.04209469f, 
    -0.02862523f, -0.03607094f, -0.00978012f, -0.02962304f, -0.05523886f, -0.00223183f, -0.00370669f, -0.04022823f, 
    -0.00617119f, 0.02699143f, 0.00245359f, 0.03611293f, 0.02537819f, -0.04979306f, -0.04286817f, 0.01722478f, 
    -0.04152018f, 0.04327119f, -0.02974521f, -0.04214102f, -0.04628624f, -0.01721372f, -0.01089768f, -0.05085284f, 
    -0.03941168f, -0.01808370f, 0.02985635f, 0.01610673f, -0.05479107f, 0.03985001f, 0.01221729f, 0.00968827f, 
    0.02933375f, -0.04071212f, -0.03319384f, -0.03395187f, -0.02249491f, -0.01615456f, 0.01604370f, 0.04138131f, 
    0.01322349f, 0.04185609f, -0.01346331f, -0.02251659f, -0.02532383f, 0.01961337f, -0.04023511f, 0.03279229f, 
    0.00956891f, -0.00742633f, 0.02030141f, -0.04151172f, 0.00899123f, -0.00803206f, -0.01159227f, 0.03917632f, 
    -0.01349161f, -0.04869043f, 0.02741181f, 0.00070958f, -0.00740569f, 0.00506291f, -0.03488446f, 0.02145768f, 
    0.04661252f, 0.00711990f, 0.01809472f, -0.02730115f, 0.04806728f, -0.05118381f, -0.05338160f, -0.01880192f, 
    0.03576596f, 0.00405797f, 0.00419789f, -0.04262565f, -0.04620051f, 0.03164343f, 0.01498881f, -0.04013836f, 
    0.03959725f, 0.00714408f, -0.03741857f, -0.03111508f, 0.02240024f, -0.02016994f, -0.03003007f, 0.00013946f, 
    -0.01449369f, 0.00693439f, -0.05416717f, 0.00246356f, 0.00386238f, -0.04248888f, 0.02123308f, 0.03796347f, 
    -0.04509499f, 0.04099946f, -0.03629625f, 0.03840050f, -0.01459998f, -0.01907731f, 0.02525894f, -0.01427578f, 
    -0.00025452f, 0.03918371f, 0.04474748f, -0.04454612f, -0.04681119f, -0.03681026f, -0.03673595f, -0.03719238f, 
    -0.04346706f, -0.05705456f, -0.01704568f, -0.05192849f, -0.01551522f, 0.00437161f, 0.02602513f, 0.00876892f, 
    -0.00149030f, 0.02468727f, -0.01290841f, -0.00479079f, 0.01400346f, 0.02289297f, 0.00253318f, 0.02029350f, 
    -0.02776725f, 0.02115854f, 0.04018738f, 0.00789368f, -0.02440309f, 0.00773667f, -0.02711526f, -0.04909781f, 
    0.03315939f, -0.04325543f, 0.03542632f, -0.03925863f, -0.02153029f, -0.03925470f, -0.03325402f, 0.02095102f, 
    -0.04027261f, -0.01697018f, 0.00168187f, -0.01952142f, -0.01336015f, -0.03021525f, -0.04990005f, 0.02691623f, 
    -0.00602942f, -0.02282644f, 0.04471620f, 0.03034628f, -0.04234981f, -0.02102987f, -0.02691431f, 0.04369527f, 
    0.00253899f, -0.04621128f, 0.03900542f, -0.01358094f, -0.00688967f, -0.00913804f, -0.02263195f, -0.01939717f, 
    0.03915054f, 0.04080208f, -0.01822817f, -0.01312175f, 0.00714309f, -0.01422319f, -0.02747828f, -0.02742101f, 
    0.01721955f, -0.00405993f, -0.03881667f, -0.02500982f, -0.00183816f, -0.05148868f, -0.01017468f, -0.04506664f, 
    0.05520012f, 0.33486527f, 0.10229408f, -0.15508428f, -0.01595240f, 0.10051177f, 0.03943042f, 0.11056646f, 
    0.05259310f, 0.05749067f, 0.17894544f, 0.16829890f, -0.39857021f, -0.24426794f, -0.02695133f, 0.22833982f, 
    -0.06993568f, 0.01883072f, 0.18408526f, -0.14829054f, 0.15884230f, 0.04997223f, 0.09430960f, 0.04312968f, 
    0.17002605f, 0.14335604f, 0.18159051f, -0.03218289f, 0.03515222f, -0.11169030f, -0.10181192f, 0.27395403f, 
    0.02812546f, -0.06699774f, 0.12259630f, -0.16970024f, 0.08267884f, 0.00488432f, -0.03580710f, -0.00719212f, 
    -0.04360332f, 0.01140873f, -0.03762443f, -0.12767375f, 0.02895797f, 0.01875939f, 0.02157245f, 0.11942966f, 
    -0.19086264f, 0.18146124f, 0.27874136f, -0.24950342f, 0.09540687f, -0.02007831f, 0.05869249f, 0.04961921f, 
    0.11984695f, 0.09199854f, 0.17396249f, 0.20426834f, 0.30917230f, -0.00207043f, -0.07895155f, -0.42160776f, 
    0.03046030f, -0.10887472f, -0.09810247f, 0.00826009f, 0.07578011f, 0.29057813f, 0.29093948f, -0.04620316f, 
    0.07126562f, 0.16324493f, 0.18069467f, 0.00862561f, 0.03983217f, 0.06214028f, 0.10212525f, 0.00442931f, 
    0.12379403f, 0.11202208f, 0.02212540f, -0.10949061f, 0.04283805f, 0.12207466f, 0.10513315f, 0.06593058f, 
    0.17611796f, 0.19289012f, 0.01892955f, 0.02651216f, -0.00717370f, 0.09834049f, 0.13174364f, 0.17612888f, 
    0.01734345f, 0.02575553f, -0.00483167f, -0.16392478f, 0.11050723f, -0.06465952f, 0.06157302f, -0.02772743f, 
    0.11763979f, -0.12884228f, 0.11978512f, -0.06552823f, 0.16505337f, -0.11858743f, -0.30120993f, -0.11471345f, 
    0.06270618f, 0.11966088f, 0.05376717f, -0.01074640f, 0.09991402f, 0.11486395f, 0.06416895f, 0.12242863f, 
    0.24511297f, 0.20891491f, 0.25300881f, 0.22445852f, 0.17919616f, 0.02834042f, -0.10157534f, 0.10093363f, 
    -0.07463884f, -0.11632790f, 0.06518901f, 0.08462559f, -0.00381545f, -0.25406453f, -0.34144428f, -0.03102236f, 
    0.10488500f, 0.16693172f, -0.17536728f, 0.03866416f, 0.18627089f, 0.03469290f, -0.09471507f, -0.17310399f, 
    -0.16232325f, 0.19614021f, 0.05610759f, 0.25256148f, 0.19192429f, 0.00079932f, 0.13413544f, -0.00169345f, 
    0.05435111f, -0.09521450f, 0.00828397f, 0.25770766f, -0.28074953f, 0.06037465f, 0.29352131f, -0.15891130f, 
    0.09183595f, -0.00370772f, -0.08536264f, 0.02088960f, 0.03631115f, 0.04216070f, 0.05410678f, 0.02184154f, 
    -0.31748044f, 0.09893015f, 0.27441674f, -0.01121990f, 0.23532309f, 0.24952000f, -0.05306739f, -0.10108350f, 
    0.14935021f, 0.09182616f, 0.04607758f, 0.22461718f, -0.31099918f, -0.37013629f, 0.21068506f, 0.10568570f, 
    -0.00527933f, -0.00171670f, -0.17295627f, 0.08974782f, 0.03237242f, 0.12247171f, -0.05222110f, -0.16759750f, 
    -0.08965461f, 0.06668191f, -0.17369141f, 0.00947133f, 0.12345769f, 0.10088880f, -0.13121523f, 0.09299950f, 
    0.15911043f, 0.04772282f, 0.33627304f, -0.10312283f, 0.00387584f, -0.01795633f, 0.04306010f, 0.13784552f, 
    0.10639893f, 0.00168933f, -0.17904283f, 0.02170327f, 0.17493033f, 0.05239588f, 0.08983032f, -0.20878126f, 
    0.05993660f, 0.10266078f, -0.16396965f, 0.02873179f, -0.10203411f, -0.04183295f, 0.09073667f, -0.11674783f, 
    0.05019017f, 0.11882216f, 0.35968211f, 0.08565661f, 0.23197073f, -0.21758477f, 0.06753255f, -0.06115809f, 
    0.17638715f, -0.04476834f, -0.34604722f, -0.01653248f, 0.04711542f, -0.11321124f, -0.05643617f, -0.09843582f, 
    0.14359744f, 0.16179825f, 0.10219735f, 0.09648082f, 0.09863658f, -0.03775135f, 0.15226503f, 0.00634852f, 
    -0.03208505f, -0.21622564f, 0.15767297f, -0.01487066f, -0.23673961f, -0.13188045f, -0.13149777f, 0.09894398f, 
    0.04135535f, 0.21693361f, -0.03197234f, -0.02034354f, 0.08966108f, 0.17366178f, 0.13513936f, 0.01636947f, 
    0.16471146f, -0.32681668f, -0.05895409f, -0.12945841f, 0.12891278f, 0.29084080f, -0.00551404f, -0.04465510f, 
    0.12625401f, -0.00026202f, -0.05111264f, 0.04989332f, 0.13309626f, 0.16639431f, -0.17114191f, 0.18628156f, 
    0.12451863f, -0.13242191f, -0.07110828f, -0.02259527f, 0.15046780f, -0.01312742f, -0.05886575f, 0.05879471f, 
    -0.09516510f, -0.08085550f, -0.15069902f, -0.13428207f, 0.02853995f, -0.01270041f, -0.11734545f, 0.17154564f, 
    0.17930833f, -0.05768806f, 0.14890674f, 0.16732475f, -0.16306774f, -0.18492763f, -0.07276101f, 0.03855039f, 
    -0.02629706f, 0.09587462f, 0.04410358f, 0.04253700f, -0.01695751f, 0.04059093f, -0.07092331f, 0.07908355f, 
    -0.03830410f, -0.28450122f, -0.19209734f, 0.20485832f, 0.13866940f, 0.08098733f, 0.02576898f, 0.12241790f, 
    0.05837303f, 0.12768281f, -0.05903041f, 0.06608398f, -0.08125015f, -0.18005811f, 0.03836865f, 0.05791537f, 
    -0.01808534f, 0.04332818f, 0.02452249f, -0.02041883f, -0.10468248f, -0.03490287f, 0.00345083f, 0.00852615f, 
    0.16062126f, -0.03013783f, -0.05586629f, 0.10423964f, 0.02427177f, 0.10990599f, -0.08902150f, 0.06827500f, 
    -0.03840143f, 0.28646192f, 0.18258496f, 0.19091980f, -0.06116560f, -0.31726196f, -0.14330378f, 0.03089554f, 
    -0.11242896f, 0.11709841f, 0.02681678f, -0.03327817f, 0.05263899f, -0.00790015f, 0.10528271f, -0.04950748f, 
    -0.05758434f, -0.10232294f, -0.02831415f, -0.17445369f, 0.01242672f, 0.08457857f, 0.02494795f, 0.11219178f, 
    0.02378831f, 0.12233240f, 0.15120046f, 0.07579590f, 0.04055829f, 0.05033497f, 0.09013466f, 0.01899585f, 
    -0.05948189f, -0.12519279f, 0.06634716f, 0.07575717f, -0.05323523f, 0.11459165f, -0.03938423f, -0.06316637f, 
    -0.00894619f, 0.01857042f, 0.02049906f, -0.03616035f, -0.01347523f, -0.02507657f, 0.02746784f, 0.03407455f, 
    -0.03124917f, 0.01511828f, 0.02441455f, -0.04558479f, -0.00184152f, 0.01428818f, -0.05570393f, -0.03164096f, 
    0.00569370f, -0.03875939f, -0.00934950f, -0.03322461f, 0.01899809f, 0.02338331f, -0.03469688f, 0.04245652f, 
    0.02023777f, -0.03745849f, 0.03470726f, -0.04314191f, 0.02316079f, -0.01463127f, 0.02062168f, -0.01743869f, 
    -0.02071581f, 0.01123505f, 0.03636814f, 0.00771316f, 0.01271318f, -0.02127434f, 0.02248760f, 0.02921060f, 
    0.03919672f, -0.02692061f, 0.01991210f, -0.03341814f, -0.04749795f, -0.04117090f, -0.04515739f, -0.01826344f, 
    0.02191509f, -0.05339121f, -0.04535090f, 0.02987801f, -0.00117413f, -0.03439351f, -0.05469168f, 0.03991637f, 
    -0.03846858f, 0.01071429f, 0.02369895f, 0.00098232f, -0.04730201f, -0.03631736f, -0.04372317f, -0.00227933f, 
    -0.05020844f, -0.01034773f, 0.02423174f, 0.01012670f, -0.03520470f, -0.02280285f, -0.04293054f, 0.04535852f, 
    -0.01370769f, 0.01699005f, 0.03577815f, 0.04440856f, 0.00661609f, -0.01823100f, 0.04850186f, 0.01482756f, 
    -0.02560231f, -0.00016705f, -0.05539580f, -0.06342223f, 0.02846580f, -0.00053955f, -0.04484805f, -0.03594477f, 
    -0.04802240f, 0.03176517f, -0.00802138f, 0.04359799f, -0.02019947f, -0.00155943f, -0.02009351f, 0.01744003f, 
    -0.04615122f, 0.02606383f, 0.00347184f, -0.02472305f, -0.00539505f, -0.01538669f, -0.01528014f, 0.02714287f, 
    0.01020523f, 0.01081943f, 0.02646783f, -0.05689920f, -0.04114875f, 0.02095727f, 0.01959516f, -0.00105135f, 
    -0.06157134f, -0.03853826f, 0.02610480f, 0.03406384f, -0.00977793f, -0.03206528f, -0.03969029f, 0.01232868f, 
    -0.03419556f, -0.02847491f, -0.02353898f, 0.02470501f, 0.02304432f, 0.02406573f, -0.05403680f, 0.02884893f, 
    -0.00823290f, -0.01858458f, -0.04397257f, -0.05816007f, 0.01348336f, 0.00205015f, 0.01619234f, 0.00946331f, 
    -0.05148106f, 0.02520455f, -0.04806284f, -0.00013492f, 0.03469524f, -0.00461631f, 0.02899622f, -0.03224549f, 
    -0.01322113f, 0.03614784f, -0.05887245f, -0.03593351f, -0.01209805f, -0.00021130f, -0.01190544f, -0.04501061f, 
    -0.00952324f, -0.02351450f, -0.00665238f, -0.02331927f, 0.03746020f, -0.05829901f, -0.01524534f, 0.03288192f, 
    -0.03317882f, -0.05108640f, 0.00179216f, -0.03866762f, -0.02661982f, 0.00914650f, 0.02203493f, 0.02404600f, 
    -0.03723600f, 0.00311906f, -0.04939904f, -0.00195723f, 0.03883584f, 0.00062989f, -0.01270366f, -0.04178442f, 
    0.03268534f, -0.04654288f, -0.02861453f, 0.02029770f, -0.00763900f, -0.05763189f, -0.04571375f, -0.04811227f, 
    -0.01633349f, -0.04666751f, -0.06197883f, 0.03091696f, 0.00897682f, -0.03479303f, -0.05697708f, -0.01876257f, 
    0.04602892f, -0.03241725f, 0.00123244f, 0.01986367f, -0.02196755f, 0.02484718f, -0.04888565f, 0.03649234f, 
    0.02859086f, -0.03684937f, 0.05302170f, -0.02751081f, 0.04615750f, -0.05916873f, 0.00743863f, 0.01323687f, 
    0.04036922f, 0.04168206f, -0.03062441f, 0.00696109f, 0.00940235f, 0.02975389f, -0.01517836f, -0.05464046f, 
    0.01906762f, 0.01162047f, -0.01055130f, -0.00013828f, -0.01284845f, 0.03272807f, -0.02346937f, -0.04486945f, 
    -0.02529437f, 0.01412572f, 0.03720984f, -0.03697591f, -0.00518331f, 0.00681330f, -0.04764995f, -0.06407258f, 
    -0.05181768f, -0.00798421f, -0.04680403f, -0.02164385f, -0.05668413f, -0.01497805f, 0.01604550f, -0.02167185f, 
    -0.00779017f, -0.03604205f, -0.02244439f, 0.05046030f, -0.02397876f, -0.06069040f, 0.02352915f, 0.00730560f, 
    -0.00322388f, -0.04281302f, -0.01470126f, -0.04986629f, -0.00266249f, 0.05180036f, 0.02297578f, 0.03744280f, 
    -0.00380216f, 0.02110573f, -0.02855997f, -0.04765492f, -0.02984331f, -0.02814012f, -0.03906804f, -0.00640047f, 
    -0.04609184f, 0.04870917f, 0.01401020f, -0.04910238f, -0.02516577f, -0.03829928f, -0.01677632f, -0.03483745f, 
    -0.05403520f, -0.00921907f, -0.05337237f, -0.03210700f, 0.02377124f, -0.01536657f, -0.03264904f, -0.05442102f, 
    0.01752507f, -0.03432521f, -0.02597806f, -0.02183330f, 0.02402852f, 0.05012622f, -0.05569007f, 0.02384752f, 
    0.04122264f, 0.02540388f, 0.01283361f, -0.00163707f, -0.04404097f, -0.01236955f, -0.01998782f, -0.06665936f, 
    -0.01672026f, -0.00799185f, -0.05679901f, -0.00763498f, -0.03936671f, 0.05492824f, -0.02460093f, -0.05034357f, 
    -0.05253456f, -0.02189924f, -0.03359164f, 0.02220243f, -0.04228045f, -0.00731488f, -0.03197019f, 0.01141167f, 
    0.00602182f, -0.02638816f, -0.01566084f, -0.05040104f, -0.03871654f, 0.00897371f, -0.01873090f, -0.01554159f, 
    -0.00768418f, 0.01938156f, -0.01218805f, -0.02390698f, -0.05865096f, -0.05598804f, -0.01616783f, 0.00537957f, 
    -0.03703871f, -0.01612737f, -0.06159112f, 0.00908445f, -0.01251816f, -0.05498854f, 0.03337878f, -0.00181113f, 
    -0.01564558f, -0.00434163f, 0.03197141f, -0.04278958f, -0.05258008f, -0.03756921f, -0.02562132f, 0.02593668f, 
    -0.01562389f, 0.02969254f, -0.03043156f, -0.01514807f, -0.01411149f, -0.04388671f, -0.00035629f, -0.01812644f, 
    -0.04442103f, 0.00654711f, -0.01902717f, 0.03051704f, -0.03779737f, 0.02398871f, -0.02766306f, -0.05828622f, 
    -0.03042212f, 0.01819932f, -0.03348159f, 0.03393745f, 0.01531057f, 0.02976435f, 0.00699515f, -0.00130750f, 
    -0.01807583f, 0.03017063f, 0.05338497f, -0.04580274f, 0.01408217f, 0.02946646f, -0.04596851f, -0.02729765f, 
    -0.05168395f, -0.00730539f, 0.02762329f, 0.03544716f, -0.02725127f, -0.00040300f, 0.02868398f, -0.04602244f, 
    -0.00726716f, -0.28878972f, 0.28608787f, 0.12375093f, -0.04043971f, 0.06287071f, 0.13729651f, -0.00054291f, 
    -0.01981084f, 0.08794159f, 0.05720226f, 0.09976868f, 0.12149153f, 0.24604692f, 0.05236768f, -0.21956369f, 
    0.06274465f, 0.09526233f, -0.09940860f, -0.02884198f, 0.01492349f, 0.00039066f, 0.03463674f, 0.04910600f, 
    0.02756192f, 0.13430735f, 0.20717846f, 0.21789581f, -0.02633728f, -0.02870722f, -0.01614004f, 0.09048192f, 
    0.15938444f, -0.08496019f, 0.06841981f, -0.21538256f, -0.17286123f, 0.34401500f, 0.22978655f, 0.13877255f, 
    0.00716777f, 0.04011767f, 0.04972457f, 0.05050071f, 0.03413142f, 0.12492085f, -0.13659960f, 0.05627292f, 
    0.28406757f, -0.20853327f, 0.19101259f, 0.53603745f, -0.09560870f, 0.03953268f, 0.00761779f, 0.02193861f, 
    0.07934586f, -0.01246779f, 0.14064433f, 0.17699452f, -0.04650478f, -0.00398215f, -0.12779804f, 0.14116833f, 
    -0.06372419f, -0.02548959f, -0.14019303f, 0.14291567f, -0.01216392f, -0.03115898f, 0.20351514f, 0.07288292f, 
    0.47040087f, -0.24283195f, 0.07777832f, 0.14641869f, -0.03513910f, -0.04790741f, 0.01178102f, 0.05536226f, 
    0.08146693f, 0.04482128f, -0.02120676f, 0.07395946f, 0.15754203f, -0.14227578f, 0.00346291f, 0.42147139f, 
    -0.14509489f, 0.04368696f, -0.01468614f, 0.02812224f, 0.02064301f, -0.05718135f, -0.01308196f, -0.05350688f, 
    0.21227837f, 0.01159489f, -0.02833766f, 0.21892352f, -0.01631416f, -0.02360279f, -0.01507571f, -0.13956518f, 
    -0.04429022f, -0.01960657f, 0.10553326f, -0.08366998f, -0.50860602f, 0.47283491f, 0.06912209f, 0.10179863f, 
    -0.09411746f, -0.00240696f, 0.11192624f, -0.09236351f, 0.02649637f, 0.00818626f, 0.04922736f, 0.08851628f, 
    0.28473970f, -0.21129033f, -0.19015053f, 0.24182488f, -0.05008279f, 0.05589427f, 0.04377447f, -0.03740918f, 
    -0.03270285f, -0.08155136f, 0.04291979f, -0.05752762f, -0.04935997f, 0.27202216f, 0.06476940f, -0.05222945f, 
    0.15920880f, 0.05828449f, -0.06776391f, 0.07534277f, 0.17112824f, -0.03532516f, -0.14928591f, -0.18965988f, 
    -0.16918956f, 0.36718002f, -0.00619189f, -0.27469990f, -0.06563662f, -0.03370610f, 0.06316219f, -0.00988839f, 
    0.00835623f, -0.06007226f, -0.00404232f, 0.04835357f, -0.22004426f, -0.04861444f, -0.06653556f, 0.36319488f, 
    0.02822973f, -0.03989766f, 0.04502035f, -0.13115840f, 0.02260150f, -0.05037927f, 0.04418553f, 0.05822450f, 
    0.24916455f, -0.39420474f, -0.09257475f, 0.16094556f, -0.04538252f, -0.09516088f, -0.03678924f, -0.06307793f, 
    0.04444992f, 0.02576309f, 0.02479490f, 0.15079670f, 0.20030363f, 0.10300355f, -0.01973647f, -0.05380967f, 
    0.14586908f, 0.01699862f, -0.02572946f, 0.12935117f, 0.00997151f, -0.04750302f, 0.01832881f, -0.23185521f, 
    0.08878090f, 0.02618840f, 0.08361188f, -0.14126377f, 0.00066437f, 0.01359623f, 0.13453667f, 0.16316220f, 
    0.16423926f, 0.06669439f, 0.24152134f, 0.08111521f, 0.00805438f, -0.13977312f, 0.01988222f, -0.31653368f, 
    0.09503365f, 0.02583286f, -0.05973105f, -0.09956237f, -0.15749104f, -0.01295714f, 0.00083110f, 0.04158458f, 
    -0.16663958f, 0.20593221f, 0.31156752f, -0.06966576f, 0.08040264f, 0.03303689f, 0.14232105f, -0.01562393f, 
    -0.05116212f, 0.06236027f, 0.08912435f, 0.00241680f, -0.42873445f, 0.08477750f, -0.30537447f, 0.09441526f, 
    0.03842480f, 0.07896025f, -0.12720889f, -0.02375364f, -0.12490028f, 0.04942745f, 0.00551823f, 0.00421145f, 
    0.01310934f, -0.16009794f, -0.40596354f, -0.17708965f, 0.05966814f, -0.06921505f, 0.10539291f, 0.03450209f, 
    -0.01422721f, -0.11543839f, 0.17946319f, 0.03808185f, 0.19193377f, 0.06925275f, -0.01259286f, -0.00031949f, 
    0.02373389f, -0.10984103f, 0.09418462f, 0.11374857f, -0.04224067f, -0.08614770f, 0.08146711f, 0.01217940f, 
    -0.15088907f, 0.14550395f, 0.14628394f, -0.06230424f, 0.10417189f, 0.07722658f, 0.20221688f, 0.12732720f, 
    0.16690703f, -0.04585217f, -0.04680522f, 0.07671741f, 0.33220837f, 0.07105870f, -0.04397013f, -0.40338141f, 
    -0.17458421f, 0.03591985f, 0.11330776f, -0.21630844f, -0.04310470f, 0.04357954f, -0.22620043f, 0.11215151f, 
    -0.49316838f, -0.02022257f, 0.03666653f, 0.21625489f, -0.19370925f, 0.02452973f, -0.10537849f, -0.02297517f, 
    0.11511339f, -0.02757149f, -0.00802735f, 0.15422860f, -0.22567697f, 0.03238644f, 0.11248299f, -0.25025454f, 
    0.13125029f, -0.00918603f, 0.16299742f, 0.09601303f, -0.08830401f, -0.07936485f, -0.06431194f, -0.07451161f, 
    -0.16314138f, 0.49317962f, 0.07472105f, -0.09445935f, 0.06683267f, 0.01502558f, 0.00322493f, 0.04695398f, 
    0.16471715f, 0.02832469f, 0.02279818f, -0.02623344f, 0.22676091f, 0.08225679f, -0.14230131f, 0.01916190f, 
    -0.05561265f, 0.04869726f, 0.09111679f, 0.06975753f, -0.13006957f, -0.07110702f, 0.05623364f, 0.05853307f, 
    0.08211935f, -0.16678381f, 0.02946484f, -0.21642414f, -0.04496535f, 0.10803019f, -0.20803079f, 0.06043739f, 
    0.07185785f, 0.31878984f, 0.13639289f, 0.14003649f, 0.20389035f, 0.32107565f, 0.00932596f, -0.01524262f, 
    -0.01167298f, -0.02438660f, 0.15527081f, 0.06514739f, 0.08393593f, -0.14272191f, 0.09299686f, -0.04033909f, 
    -0.08156817f, 0.19482760f, -0.01110359f, 0.02225919f, 0.17036240f, -0.00847323f, -0.10954399f, 0.16440430f, 
    -0.06661958f, 0.03177182f, 0.04018634f, 0.12234734f, -0.40928951f, 0.08977143f, -0.08605717f, 0.12138138f, 
    -0.10069571f, -0.11964031f, 0.05345555f, 0.14530227f, -0.06133589f, 0.08986273f, 0.08849180f, -0.04772943f, 
    -0.01958062f, 0.03784954f, -0.03490798f, -0.05667125f, 0.02045854f, -0.04026182f, -0.01455061f, 0.00314510f, 
    -0.03912266f, -0.00242537f, -0.00631915f, 0.02878821f, 0.03899683f, -0.05538078f, 0.04466473f, 0.03526921f, 
    -0.03096061f, -0.03425039f, -0.05573086f, -0.05256664f, -0.05317452f, 0.02795798f, 0.01027309f, -0.00371998f, 
    0.02924302f, 0.03372767f, -0.04977180f, -0.01633597f, -0.04723774f, 0.02939993f, 0.02609424f, -0.03872457f, 
    0.03481769f, -0.01325647f, 0.01066475f, -0.01417186f, -0.05467433f, -0.00057014f, -0.03984476f, -0.02399159f, 
    -0.00924906f, -0.02112303f, 0.01851087f, -0.00007336f, -0.02925399f, -0.05267349f, -0.01287358f, -0.00855512f, 
    -0.02725449f, 0.01688628f, 0.00921314f, -0.02011150f, 0.02742941f, -0.02979187f, 0.01337181f, 0.02686069f, 
    0.02174032f, 0.04137846f, -0.00638921f, 0.01073713f, 0.01501705f, -0.01028715f, -0.04141091f, 0.00457811f, 
    0.00658264f, 0.00924828f, -0.02703398f, -0.01391532f, -0.03482576f, 0.04053888f, -0.02489026f, -0.03324846f, 
    -0.04156436f, 0.02504324f, -0.04933618f, 0.01390940f, 0.02279451f, 0.00892626f, -0.00021472f, 0.00222237f, 
    -0.05541473f, 0.00452773f, 0.02023911f, 0.02963261f, -0.03858374f, -0.04510941f, 0.00862448f, -0.01204515f, 
    -0.03686216f, -0.01826052f, -0.03232267f, -0.01140137f, -0.04928903f, -0.01454530f, 0.00087081f, -0.02102350f, 
    0.04110878f, 0.00185486f, 0.04397359f, 0.01499694f, -0.03141999f, 0.00372933f, 0.01944041f, -0.02871688f, 
    -0.04667858f, -0.01838568f, -0.03945997f, -0.01832087f, 0.03782823f, -0.01650477f, -0.01826935f, 0.00383489f, 
    0.00371197f, 0.04549292f, -0.03257627f, -0.05000376f, -0.01886616f, -0.02983989f, -0.03232804f, -0.05254690f, 
    0.02210587f, 0.00542923f, 0.00772013f, 0.02515628f, -0.04280381f, -0.00475140f, 0.02196929f, -0.02753149f, 
    0.04232562f, 0.03703960f, 0.00471890f, 0.03533269f, 0.01951348f, -0.00990748f, -0.00501187f, 0.02070395f, 
    0.01540263f, 0.01470236f, 0.04500355f, 0.03416026f, 0.03756690f, 0.01665628f, 0.03006792f, -0.03707786f, 
    0.01884194f, -0.03611712f, -0.01564059f, -0.04221583f, -0.02884312f, 0.03555644f, -0.04069781f, -0.01708212f, 
    -0.02869283f, 0.02532647f, -0.01065691f, 0.03271488f, -0.04809731f, 0.02688902f, -0.02533330f, 0.04208646f, 
    0.02095067f, 0.00159215f, 0.02985716f, 0.00866831f, 0.04358668f, -0.02868266f, 0.02945442f, -0.03670223f, 
    -0.03413043f, -0.04799870f, -0.03688829f, -0.04784451f, 0.02712182f, 0.01060685f, -0.01437902f, -0.04748427f, 
    0.00261645f, -0.00544669f, -0.05031851f, 0.03631343f, -0.03362464f, -0.01873616f, 0.00416007f, -0.04061654f, 
    -0.01591863f, -0.01298579f, -0.03097545f, -0.00046586f, 0.01745863f, 0.00391243f, 0.02323234f, 0.01213875f, 
    -0.02191669f, 0.01205418f, -0.01291912f, -0.01500935f, 0.02991548f, 0.00195428f, -0.04858095f, 0.04440847f, 
    0.03040554f, -0.02828216f, -0.02433803f, 0.02877547f, 0.00213672f, -0.05180116f, -0.00453469f, -0.01324497f, 
    -0.01029410f, -0.01349759f, -0.00922856f, -0.01891865f, 0.03079303f, -0.03134486f, 0.04073519f, -0.02965268f, 
    -0.05133132f, 0.02507189f, -0.04727270f, 0.02306888f, -0.04778901f, -0.02151311f, 0.03768486f, -0.04343278f, 
    -0.01826382f, 0.02094688f, -0.03241383f, 0.00744635f, -0.00714149f, -0.00654243f, 0.02604535f, -0.01535929f, 
    -0.05046958f, -0.00999721f, 0.01558821f, 0.01098076f, -0.01966274f, 0.02857138f, -0.00555611f, 0.04237183f, 
    0.01944841f, -0.03689478f, 0.04459086f, -0.01205753f, -0.01097345f, 0.04013425f, -0.01203030f, -0.02588931f, 
    0.00705166f, -0.00922738f, -0.05127637f, -0.01558409f, 0.02414027f, -0.02489471f, -0.01028798f, -0.04136556f, 
    -0.00126645f, 0.01032643f, -0.01891156f, -0.04887431f, -0.01095886f, -0.00538132f, 0.01609338f, -0.05620443f, 
    0.02543117f, -0.03184504f, 0.01063693f, 0.04164230f, -0.04940231f, -0.00580933f, -0.02136327f, 0.02007254f, 
    0.02178759f, 0.00720153f, 0.03249584f, -0.04463414f, -0.03529942f, -0.02428504f, -0.01814048f, 0.04150533f, 
    0.01898449f, -0.05234768f, -0.02868077f, -0.05671341f, -0.04619244f, 0.01399664f, -0.01328507f, -0.04628844f, 
    0.01117549f, 0.02349586f, 0.04416412f, -0.02270327f, -0.00847968f, 0.02488207f, 0.01435724f, -0.02137489f, 
    0.00618149f, -0.01855354f, -0.00234221f, -0.02889114f, -0.02410304f, 0.00500995f, -0.00990540f, -0.05186086f, 
    0.02963413f, 0.03405371f, -0.02754146f, -0.03475024f, 0.02108568f, 0.01839871f, -0.05058610f, -0.01794903f, 
    0.01686366f, 0.03458735f, -0.05032478f, -0.00978964f, 0.00282670f, -0.01064451f, -0.01216316f, -0.00310383f, 
    -0.04961228f, -0.02172918f, -0.02424223f, -0.01653328f, -0.03432151f, -0.03682337f, -0.02677585f, -0.03835199f, 
    -0.01465037f, -0.00101332f, -0.01710092f, -0.04093947f, -0.05389329f, 0.00591000f, -0.02924223f, 0.04452599f, 
    0.00731654f, -0.04448018f, 0.04374358f, -0.01266123f, -0.00586818f, -0.00869309f, 0.03890630f, -0.00387373f, 
    -0.00110107f, 0.01210724f, -0.03768628f, 0.02018882f, -0.03331121f, 0.00822751f, 0.03133790f, 0.02635366f, 
    -0.00617686f, -0.00804528f, -0.03825483f, -0.02109136f, -0.04443169f, -0.01896570f, -0.02455776f, 0.04419024f, 
    -0.00659300f, -0.03240840f, -0.04276739f, -0.01739462f, 0.02838564f, -0.04950459f, -0.00822165f, -0.04954179f, 
    0.03520574f, -0.03070655f, 0.00564638f, -0.00703890f, 0.03001546f, -0.02326112f, -0.00110228f, 0.02672349f, 
    -0.04598419f, 0.03810276f, -0.02973291f, -0.02319107f, -0.02693645f, 0.03739801f, -0.01757257f, 0.00798841f, 
    0.00622951f, 0.04459242f, 0.02096173f, 0.02297547f, 0.01768951f, -0.01175106f, -0.04195920f, -0.04624046f, 
    0.02078928f, -0.04850390f, -0.01449844f, -0.04672818f, 0.03308517f, 0.04614739f, 0.00304468f, -0.03553291f, 
    -0.02441806f, 0.00807772f, -0.00437060f, -0.01443457f, 0.04153302f, 0.00444095f, -0.00682442f, 0.02209814f, 
    -0.05246280f, -0.03022563f, -0.00417134f, -0.04833465f, -0.01072009f, 0.03005999f, -0.04223237f, -0.00403525f, 
    0.00643732f, -0.04554549f, 0.04389677f, -0.01174933f, 0.03427490f, 0.00700408f, 0.02294086f, -0.00644984f, 
    0.04591886f, -0.03603633f, 0.01491783f, 0.00279684f, -0.02609704f, 0.04260180f, -0.03401691f, -0.01288795f, 
    -0.01805297f, -0.04650977f, 0.02932023f, -0.03054594f, -0.00902255f, -0.02949797f, -0.05389531f, -0.00649849f, 
    -0.01197345f, -0.01403133f, -0.02965996f, -0.01437580f, 0.04261122f, 0.01631233f, -0.01763037f, 0.02785167f, 
    -0.00482094f, -0.04863513f, -0.04906863f, -0.05708143f, 0.03279375f, -0.01762763f, 0.02368283f, 0.02814844f, 
    -0.02074278f, 0.01754721f, -0.01052125f, -0.02765147f, 0.01945420f, -0.02997059f, -0.04676524f, -0.02615727f, 
    0.00878303f, -0.01243767f, -0.00676089f, 0.01734172f, 0.02403806f, -0.00738421f, 0.00902681f, -0.02916137f, 
    0.03325971f, -0.00948618f, -0.00053620f, -0.02035659f, -0.05164316f, 0.02920640f, -0.03674157f, 0.01641951f, 
    0.01093940f, -0.04175831f, -0.05422552f, -0.04216493f, -0.02785970f, -0.05583288f, 0.03333692f, -0.03838631f, 
    -0.05393707f, -0.00382056f, -0.00161976f, -0.02955064f, 0.03926180f, -0.03351107f, -0.01740993f, -0.00171552f, 
    -0.03203282f, 0.04546432f, -0.00545012f, 0.01523742f, -0.00852491f, -0.03527371f, -0.03750545f, -0.02330059f, 
    0.04071736f, 0.01633387f, -0.02772872f, -0.04477707f, -0.00685741f, -0.00861927f, 0.02956207f, 0.03256330f, 
    -0.03398897f, 0.03858152f, -0.03777050f, -0.00215127f, -0.04497563f, 0.01041528f, -0.04866081f, 0.03663461f, 
    0.02290374f, 0.01956890f, -0.03877014f, 0.00948593f, 0.00555577f, 0.02464185f, -0.02696224f, -0.05691586f, 
    0.00222761f, -0.03394454f, -0.02178326f, 0.02130260f, -0.04898917f, -0.02121568f, 0.02667375f, -0.01165024f, 
    0.00686015f, -0.00914530f, 0.03271591f, 0.00387243f, -0.00794434f, -0.01742467f, -0.03896295f, -0.02947731f, 
    0.03805216f, -0.04556116f, 0.02414164f, -0.00640071f, 0.03706101f, -0.00823361f, -0.00816284f, -0.04795485f, 
    0.01961534f, 0.00952525f, -0.01935072f, -0.04320974f, -0.05412844f, 0.02569731f, 0.01410069f, -0.03554170f, 
    -0.04686938f, -0.04000429f, 0.03032929f, -0.01361461f, 0.02716275f, 0.03238109f, 0.00580481f, -0.04243921f, 
    -0.01714043f, 0.02060326f, 0.00345667f, 0.02026365f, 0.03706055f, 0.01252001f, 0.01284121f, 0.03045241f, 
    -0.01431804f, -0.04521878f, -0.05266810f, -0.00958019f, 0.01277700f, 0.00233710f, 0.02158030f, -0.04566300f, 
    0.02973904f, -0.00264696f, 0.00467533f, 0.02838639f, 0.00286371f, -0.04569424f, -0.00573020f, -0.04131953f, 
    -0.02126371f, -0.04230304f, 0.03686266f, 0.00760379f, 0.02865253f, -0.02963126f, 0.00693722f, -0.04176664f, 
    -0.03651495f, -0.02530787f, 0.02852757f, 0.04339832f, 0.04119974f, -0.00067597f, -0.00955632f, 0.03372021f, 
    0.01728234f, -0.03084173f, -0.03417465f, 0.02886582f, -0.05382464f, 0.00523986f, 0.00637812f, -0.04426388f, 
    0.03598532f, -0.04936759f, 0.02115187f, 0.03414804f, 0.03001195f, -0.02895917f, 0.00555244f, -0.01763891f, 
    0.00794368f, 0.04072013f, 0.00358965f, 0.02902482f, -0.03760836f, -0.05303773f, 0.02536650f, 0.00106255f, 
    -0.04726699f, -0.02045869f, 0.00666431f, -0.04856578f, -0.00051862f, -0.00511073f, 0.02976176f, 0.00980832f, 
    -0.04042391f, -0.01779630f, 0.01399842f, -0.01063337f, 0.04317773f, -0.04951141f, 0.03854344f, -0.02999282f, 
    0.00880893f, 0.02482267f, 0.01502186f, -0.05398934f, -0.01383621f, -0.00190488f, 0.01539109f, -0.03474325f, 
    0.03522651f, -0.01649917f, 0.00738050f, 0.02495159f, 0.00329907f, -0.00193855f, -0.02004877f, -0.01499579f, 
    -0.04552151f, -0.05360786f, -0.00995360f, -0.02294264f, 0.04077045f, -0.04233383f, -0.03013979f, 0.04592479f, 
    0.00729892f, 0.03005436f, 0.01876227f, -0.03988144f, -0.00847186f, -0.01868133f, 0.03010756f, -0.05118934f, 
    0.04376229f, -0.04938772f, 0.01376918f, 0.04821542f, -0.05036437f, 0.00998744f, 0.03326856f, 0.01139669f, 
    0.02480852f, -0.02618102f, 0.03163298f, -0.03811496f, -0.03728734f, -0.05079346f, -0.05338873f, -0.01128385f, 
    -0.00078956f, -0.03794792f, -0.00860348f, 0.01626334f, -0.04141359f, -0.04209629f, -0.01049779f, -0.03011342f, 
    0.00413081f, -0.05506652f, -0.01972908f, 0.01369082f, -0.05322542f, -0.02730357f, -0.04698252f, -0.01941789f, 
    -0.01194764f, 0.05066790f, 0.02993872f, 0.02642152f, -0.05255407f, -0.02593690f, -0.04316611f, 0.03030203f, 
    -0.04192232f, -0.02976127f, -0.05124301f, 0.03208192f, -0.03587468f, 0.03462289f, -0.02532497f, 0.02839934f, 
    0.00132792f, 0.00943587f, 0.00537735f, 0.03160707f, 0.00254998f, 0.00614625f, -0.03984010f, 0.03940842f, 
    0.03468945f, -0.03888290f, 0.04391910f, 0.00166904f, 0.02375285f, 0.03877493f, 0.04297612f, -0.00643297f, 
    0.00258265f, -0.00789391f, -0.05074354f, -0.02657125f, -0.01929842f, -0.04898726f, 0.02294560f, -0.04372323f, 
    -0.01062185f, 0.01777710f, 0.03866503f, -0.04634355f, -0.01557190f, -0.00811858f, -0.00164654f, -0.02822884f, 
    0.01992913f, -0.02253661f, -0.01719713f, 0.02829138f, 0.00148808f, 0.04156668f, 0.03854357f, 0.02079089f, 
    -0.04090938f, -0.02905987f, -0.04293573f, 0.02353872f, 0.03009733f, 0.04117060f, -0.04197265f, 0.02183819f, 
    -0.05378964f, -0.05047228f, -0.04359508f, -0.01340155f, 0.02448472f, 0.00851356f, 0.01796461f, 0.02892117f, 
    -0.02950448f, 0.02819698f, 0.03661572f, 0.03853033f, -0.03669108f, -0.02321487f, -0.04094097f, -0.05418327f, 
    0.01817734f, -0.05567754f, -0.03931426f, 0.03911305f, -0.01690936f, -0.01740120f, -0.00975259f, -0.04019086f, 
    0.03408884f, -0.02505818f, -0.04747337f, -0.04225820f, 0.03236766f, -0.00714847f, 0.02186021f, 0.03276783f, 
    0.04367548f, -0.02510794f, 0.04121009f, 0.00159235f, -0.03217476f, 0.01402983f, -0.04951304f, 0.01392836f, 
    -0.03135384f, 0.01415642f, -0.01665252f, -0.02626205f, 0.00852414f, -0.03616530f, -0.04278346f, 0.01334384f, 
    -0.04262914f, -0.02230727f, -0.01187730f, -0.04333873f, -0.03078510f, 0.02940590f, 0.00160991f, -0.05730454f, 
    -0.03191432f, 0.03339440f, 0.02976540f, 0.00753950f, 0.01483242f, 0.00712685f, 0.00248540f, -0.02231945f, 
    0.01552537f, 0.00228755f, 0.00844523f, -0.04138021f, 0.02509165f, -0.04733420f, 0.01644135f, -0.05293098f, 
    -0.04668577f, 0.01686842f, -0.04899545f, 0.02943109f, -0.02553674f, -0.05397433f, 0.00334630f, -0.05793092f, 
    0.02235326f, -0.04564857f, -0.01373951f, 0.01504346f, 0.02471075f, 0.02336941f, 0.00895510f, -0.02028862f, 
    0.00737155f, 0.04229935f, 0.00667915f, 0.01375189f, -0.01076008f, 0.00449556f, -0.01020678f, -0.02974935f, 
    -0.03103102f, -0.04508705f, -0.05253210f, 0.03416336f, 0.01335676f, 0.01579237f, 0.03804908f, 0.00279519f, 
    -0.02108804f, -0.05085557f, 0.04009283f, -0.05483300f, 0.00899330f, -0.01445952f, -0.04506948f, 0.04041471f, 
    0.02936143f, -0.04308719f, -0.05172395f, 0.00942725f, -0.05852593f, 0.01192544f, -0.02474909f, 0.01548241f, 
    -0.05519941f, -0.02629611f, 0.00698462f, -0.00539081f, -0.01916710f, -0.01480608f, -0.05489770f, -0.01902088f, 
    0.00636611f, -0.04481846f, 0.00549796f, -0.00805580f, -0.03148339f, 0.04096188f, -0.04823158f, 0.02177915f, 
    0.03531504f, -0.00811156f, 0.00080465f, 0.02260677f, -0.01085369f, -0.01325426f, -0.05120246f, -0.02601860f, 
    -0.00724651f, -0.01693687f, 0.03416457f, -0.03531889f, -0.01967258f, -0.02660316f, 0.03699519f, 0.02244948f, 
    -0.00581460f, 0.01746708f, -0.05737606f, -0.02416036f, 0.02895989f, -0.05008980f, 0.01847323f, -0.02787947f, 
    0.00023056f, -0.05308385f, -0.03182203f, -0.00652980f, -0.04939288f, -0.02917661f, 0.03464475f, -0.04565587f, 
    0.02428076f, -0.01923137f, -0.02233412f, 0.02881308f, -0.05304807f, -0.04953526f, -0.05259481f, -0.04393302f, 
    -0.05173810f, -0.01344656f, -0.00582737f, -0.03018587f, 0.02298202f, -0.03335091f, 0.00528414f, -0.01556118f, 
    -0.00052227f, 0.03426458f, 0.03354494f, -0.04290462f, 0.02319468f, 0.02303083f, 0.00097330f, -0.03314926f, 
    0.04074502f, 0.01746075f, -0.02662358f, 0.02996777f, -0.04041250f, -0.00604464f, -0.00163563f, -0.05341298f, 
    -0.01632125f, -0.03344866f, 0.03346913f, 0.00612079f, 0.00808836f, -0.05236791f, -0.02582700f, -0.01923764f, 
    -0.01303425f, -0.01510503f, -0.00122385f, -0.03514708f, -0.04506211f, 0.01586706f, 0.02917473f, -0.02376585f, 
    -0.04806206f, -0.00233236f, -0.03704159f, -0.03462139f, 0.00512134f, -0.02839426f, 0.01823699f, -0.04733512f, 
    0.01742640f, -0.02523312f, -0.02343532f, -0.02916625f, -0.00446528f, -0.03296337f, -0.03256709f, 0.00270875f, 
    -0.02441655f, -0.00109970f, 0.01863300f, 0.00234366f, 0.04410385f, -0.03370724f, 0.02716960f, 0.01410026f, 
    -0.03403126f, 0.03376691f, -0.04335477f, 0.01127224f, 0.02768024f, -0.04004160f, -0.04828399f, 0.00955079f, 
    -0.04118874f, 0.02983985f, -0.03257275f, -0.04112818f, -0.00611179f, -0.03723583f, 0.00182981f, -0.04158679f, 
    0.01512332f, 0.01543355f, -0.02824256f, -0.05405919f, 0.01075014f, -0.03356682f, -0.00186817f, 0.03645181f, 
    -0.04527853f, -0.05702878f, -0.01391150f, 0.00081286f, 0.02041536f, -0.00498454f, 0.01413212f, 0.03435101f, 
    -0.00602275f, 0.02161535f, -0.01692509f, -0.01110134f, -0.05942493f, 0.03991547f, -0.03226497f, -0.02246808f, 
    0.01601095f, -0.03398397f, 0.02351260f, 0.02574736f, 0.01002147f, 0.03284794f, -0.02557887f, -0.03470543f, 
    -0.00680634f, -0.04158284f, -0.03350543f, -0.02170295f, -0.03550387f, -0.01762133f, 0.02517481f, 0.02535631f, 
    0.00963239f, 0.01902852f, 0.03943576f, 0.03673001f, -0.03210980f, 0.02681467f, -0.05889925f, 0.00167038f, 
    0.03287196f, -0.05174975f, 0.02362021f, 0.03352826f, 0.01237437f, 0.03619706f, -0.05105419f, -0.04886396f, 
    0.01614440f, 0.01280301f, -0.00272955f, -0.03128294f, -0.05204770f, -0.01167892f, 0.04057257f, -0.00933866f, 
    0.04146838f, 0.00685789f, -0.05169122f, -0.00799060f, 0.02506786f, 0.03541281f, -0.02970102f, 0.00842986f, 
    -0.04778075f, -0.00205920f, -0.05203753f, -0.01024095f, 0.00916896f, -0.01476821f, 0.02552092f, -0.00708714f, 
    -0.00184113f, 0.00087700f, -0.00921021f, -0.04953356f, -0.02403042f, 0.00268530f, -0.00750042f, -0.03581651f, 
    0.00918310f, 0.00444382f, -0.00628848f, 0.03069663f, 0.00703317f, 0.02388594f, -0.03266247f, -0.03611212f, 
    -0.05830003f, -0.03279940f, -0.04248041f, 0.03975371f, 0.03584406f, 0.00855383f, -0.02985124f, 0.02335590f, 
    -0.02676557f, -0.02447835f, 0.03213388f, -0.00024026f, 0.00057333f, -0.04203774f, 0.03451455f, -0.05331334f, 
    -0.05470507f, -0.01279446f, -0.03996358f, 0.04138558f, 0.01039845f, -0.05421409f, -0.03970371f, -0.02323808f, 
    0.05376526f, 0.08946458f, 0.06930456f, 0.11952226f, 0.02799290f, 0.04910608f, -0.03288141f, 0.06946980f, 
    -0.06309125f, -0.04646488f, -0.10456868f, -0.07609005f, -0.71395880f, -0.06165233f, -0.17237739f, 0.09883527f, 
    0.06649803f, -0.05013674f, 0.08470343f, 0.09321829f, -0.11037236f, -0.02373720f, -0.02067239f, 0.03918876f, 
    0.05500653f, 0.17760769f, -0.13585393f, 0.11107711f, -0.01959958f, 0.09879987f, 0.05711769f, -0.08950455f, 
    0.04978614f, -0.06238500f, -0.05549182f, 0.28552586f, 0.16091579f, 0.18256159f, -0.28319409f, -0.12387913f, 
    0.00517595f, -0.02108957f, 0.00540936f, 0.00915376f, -0.04205808f, 0.09834594f, 0.13371637f, 0.00098109f, 
    0.01843494f, -0.13361877f, 0.04644167f, 0.13074912f, 0.06289790f, -0.00393058f, -0.00546103f, -0.02354249f, 
    0.03342891f, -0.08840823f, -0.09563461f, -0.08708467f, -0.21672535f, 0.26429629f, 0.11214829f, 0.08158921f, 
    0.03894247f, 0.07559256f, -0.00463230f, 0.00621325f, -0.01296939f, -0.00394905f, -0.04330235f, 0.07008018f, 
    0.00232443f, 0.11535801f, -0.20944716f, 0.03716362f, -0.03658427f, 0.03365090f, -0.01487572f, 0.08355734f, 
    -0.05147979f, -0.06376459f, 0.04976327f, 0.11745782f, -0.09627903f, -0.06329601f, 0.14117889f, 0.00259497f, 
    0.00935786f, 0.05705430f, 0.00557543f, 0.01133840f, 0.01205860f, -0.04485678f, 0.06008316f, -0.03326679f, 
    0.16754098f, -0.05329305f, -0.07767119f, -0.08979532f, 0.08067355f, 0.07675735f, 0.05148949f, -0.03998021f, 
    0.02760462f, 0.12344561f, 0.02032227f, 0.00102508f, -0.07157832f, 0.21089175f, 0.16372833f, -0.06022449f, 
    -0.08196680f, 0.06935437f, 0.00566291f, 0.03180668f, -0.07036908f, 0.00817810f, 0.06219914f, -0.10926407f, 
    -0.01780039f, -0.10903633f, 0.09796445f, 0.11084250f, -0.02666914f, -0.07400637f, 0.06413423f, 0.04969640f, 
    0.25310409f, 0.03411204f, -0.04060144f, 0.17395701f, -0.03458949f, 0.08886224f, -0.04338638f, 0.01230280f, 
    -0.09472979f, -0.20114455f, -0.01829704f, -0.08184128f, -0.00703470f, 0.21074879f, 0.07795934f, -0.05946520f, 
    0.55361032f, -0.14493269f, -0.04197205f, 0.12465493f, 0.00514720f, 0.04707340f, -0.02977727f, 0.03323724f, 
    -0.01018471f, 0.13258649f, 0.14033821f, -0.02537995f, 0.32873309f, -0.07950214f, -0.11567781f, -0.08758879f, 
    -0.04183174f, 0.17009218f, 0.09061160f, -0.01044001f, 0.01271205f, -0.18270658f, 0.20555460f, -0.05899267f, 
    0.28644857f, 0.12718709f, 0.05209524f, -0.16874267f, 0.01734204f, -0.07601489f, -0.03445255f, 0.02999439f, 
    -0.25300750f, 0.02581376f, 0.07555381f, -0.05380845f, 0.16207890f, 0.12819478f, -0.13216288f, -0.02471521f, 
    0.00001909f, -0.01490465f, -0.02566382f, 0.07736475f, -0.09367314f, 0.11530770f, 0.12383404f, -0.04325744f, 
    0.31178430f, -0.09338067f, 0.04529381f, 0.16855286f, 0.02022932f, 0.08478438f, 0.10384358f, 0.06067427f, 
    -0.08230680f, 0.11208515f, -0.05184186f, -0.08789435f, -0.08919952f, -0.18972613f, 0.09545368f, 0.07449921f, 
    -0.01688484f, 0.00048920f, 0.05882849f, 0.09423026f, -0.00311334f, -0.05040182f, -0.05537675f, -0.03758915f, 
    0.11093286f, -0.17055477f, -0.09455930f, 0.19053720f, 0.03095531f, 0.14961275f, 0.10126340f, 0.16779192f, 
    0.06290311f, 0.09884703f, 0.02225539f, 0.09989669f, -0.15028879f, 0.18268158f, -0.07348158f, -0.15106261f, 
    -0.00838823f, 0.01529651f, 0.00558740f, -0.00016941f, 0.02866426f, -0.04705004f, 0.07799317f, 0.07335928f, 
    0.35232139f, -0.22374374f, 0.03959778f, 0.04607678f, -0.00642323f, -0.06369814f, -0.01087311f, 0.04651329f, 
    0.09394410f, -0.04404030f, -0.06212291f, 0.15783229f, 0.31033567f, -0.02525219f, -0.16347338f, 0.18692641f, 
    -0.03408322f, 0.01649437f, 0.00478751f, 0.11997747f, -0.08308060f, 0.03519414f, -0.06939089f, 0.08450881f, 
    0.35810825f, 0.01407252f, 0.08078960f, 0.07040434f, 0.07182445f, -0.21878496f, -0.05227361f, 0.00284611f, 
    -0.01655205f, -0.11278812f, -0.02331009f, 0.06655367f, 0.10623801f, -0.44713610f, 0.26562044f, -0.10244722f, 
    0.10571318f, 0.01607628f, -0.09791034f, 0.11361235f, -0.02330661f, -0.00149685f, -0.04455479f, -0.05590345f, 
    -0.60644299f, 0.06968946f, 0.13282058f, 0.08039723f, 0.08581634f, -0.00851595f, -0.00246191f, 0.00260293f, 
    -0.09666055f, -0.03649672f, -0.00889602f, -0.05611959f, 0.43549725f, 0.15147835f, -0.09925002f, 0.13052733f, 
    -0.16769831f, -0.16954711f, 0.02464120f, 0.06480548f, 0.01387661f, 0.13175383f, 0.07083875f, 0.14629719f, 
    0.19576865f, 0.13845892f, -0.03828145f, -0.04935799f, -0.12603335f, 0.03028113f, 0.12383624f, 0.02907236f, 
    0.03327502f, 0.01623397f, -0.03910799f, 0.13919823f, -0.08632265f, -0.11298072f, -0.08284445f, -0.00437444f, 
    0.01630828f, 0.04610442f, -0.14850140f, 0.00893650f, 0.03485450f, 0.05039604f, -0.01662293f, -0.01892267f, 
    0.12217079f, 0.07255893f, -0.00472706f, 0.22860210f, 0.02915150f, -0.00634670f, -0.03806291f, -0.17170630f, 
    -0.05751122f, -0.03319988f, -0.01962962f, 0.04326889f, -0.23422551f, -0.22233339f, -0.09589665f, -0.09437165f, 
    0.02871824f, -0.05225485f, -0.12038836f, 0.01803216f, 0.07683442f, -0.00963102f, 0.02371163f, -0.01454832f, 
    0.25557631f, 0.06048476f, -0.05683613f, 0.04631177f, -0.01119810f, 0.08873346f, 0.10319222f, -0.07842945f, 
    0.15555646f, -0.04042546f, 0.05164082f, -0.18920916f, -0.05883138f, -0.10293149f, -0.03142292f, 0.02427226f, 
    0.01857494f, 0.06135220f, -0.05384853f, -0.10021193f, -0.06263254f, -0.04481633f, -0.04795793f, 0.12855121f, 
    0.02847790f, 0.02507408f, -0.24807535f, -0.12430906f, 0.14538534f, -0.09458028f, 0.01289145f, 0.02877813f, 
    0.08739202f, 0.01137627f, 0.10564449f, 0.08134494f, 0.39070278f, 0.35690022f, 0.08677886f, -0.13494511f, 
    0.00135126f, 0.02985912f, -0.05976338f, 0.25945467f, -0.00049446f, 0.10618243f, 0.06355101f, -0.05049414f, 
    -0.31825164f, -0.01341902f, -0.07423951f, -0.11783456f, 0.15344562f, 0.06852140f, 0.05744036f, -0.01491832f, 
    -0.06048680f, 0.07326345f, -0.04922714f, 0.32445630f, 0.03171142f, 0.07754199f, 0.04572642f, -0.09612016f, 
    0.06943592f, -0.06609529f, 0.15379743f, 0.01912508f, 0.06092439f, -0.13803293f, 0.06237724f, 0.07308413f, 
    -0.11162523f, 0.02183094f, -0.43145606f, -0.28676212f, 0.09540313f, -0.00562367f, 0.04717128f, -0.04338485f, 
    -0.15687111f, -0.00762959f, -0.01374801f, -0.05817541f, 0.12424856f, 0.03851987f, 0.08049839f, 0.33302909f, 
    0.02424481f, 0.12865180f, 0.13367453f, 0.03437898f, 0.07569787f, 0.04047652f, -0.15128133f, 0.12418990f, 
    -0.26684552f, -0.08765458f, -0.22379573f, -0.19102576f, 0.12371364f, 0.10366790f, -0.04451525f, -0.07832138f, 
    0.05909000f, -0.13140368f, -0.04346133f, 0.15960911f, -0.19781263f, -0.06585260f, 0.06906409f, -0.17780529f, 
    0.05243008f, -0.07905261f, -0.07149537f, 0.00524806f, -0.06175621f, -0.02668643f, -0.05170502f, -0.06555199f, 
    -0.39239702f, 0.25935853f, -0.15218556f, 0.00507479f, 0.06245010f, -0.04983916f, 0.11534436f, 0.07229702f, 
    -0.02908999f, 0.15796629f, -0.07626893f, 0.07841060f, 0.25349486f, -0.02936302f, 0.16242814f, 0.05831730f, 
    0.06660026f, -0.16753477f, -0.09175012f, 0.11182070f, -0.05702399f, -0.03602594f, 0.00040457f, -0.03487018f, 
    -0.34717119f, -0.06253405f, -0.16806313f, -0.33733445f, 0.02897808f, 0.09961049f, 0.00110771f, -0.01619503f, 
    0.05514342f, 0.17032772f, 0.01790150f, 0.04967385f, 0.18806551f, 0.06474670f, 0.12555207f, 0.17935832f, 
    -0.10575365f, 0.01372329f, 0.16011421f, 0.07293572f, -0.08868882f, 0.01156789f, 0.05185317f, 0.06265830f, 
    -0.18147838f, -0.15239634f, 0.41343740f, -0.11710721f, -0.00732506f, 0.11423067f, -0.02594283f, -0.01497613f, 
    -0.00431631f, 0.08845861f, 0.00609991f, -0.08793098f, -0.07763928f, 0.11156479f, -0.03437822f, 0.00053961f, 
    -0.07392411f, 0.03217175f, -0.01872873f, -0.01933355f, 0.03792302f, 0.13123645f, -0.11393910f, 0.21119477f, 
    -0.09358741f, 0.11668102f, -0.13229232f, -0.20005350f, 0.09968375f, -0.02267667f, 0.16935666f, 0.08552809f, 
    0.07149507f, -0.04263463f, 0.01845932f, -0.06952437f, 0.19501498f, 0.19432133f, -0.01006821f, 0.12904230f, 
    0.08699682f, 0.09044001f, 0.23854180f, -0.03466900f, 0.06053937f, -0.13627039f, 0.03951091f, 0.26712245f, 
    -0.17893641f, 0.02162398f, 0.14476879f, 0.14603251f, 0.04047709f, -0.08513097f, 0.05664649f, -0.10281640f, 
    -0.06205752f, -0.00663857f, -0.16677310f, 0.10699932f, -0.05431307f, 0.10373376f, 0.20363910f, 0.09798633f, 
    0.06258681f, 0.08947183f, 0.01867933f, 0.00983211f, -0.07650915f, 0.00398895f, -0.06855404f, 0.18714246f, 
    -0.06830069f, 0.09014247f, 0.18705769f, 0.11145508f, 0.08991805f, -0.04122300f, -0.09514218f, 0.19086683f, 
    -0.06136163f, -0.02610466f, -0.13153850f, 0.12768856f, -0.01742122f, 0.13645400f, 0.00566442f, 0.16924581f, 
    -0.16452797f, 0.15367018f, 0.21182659f, 0.00693577f, 0.04156782f, 0.18118452f, 0.16458543f, 0.06862189f, 
    -0.24369918f, -0.03333352f, 0.32898730f, -0.08975842f, -0.05770640f, 0.16571492f, 0.06384678f, 0.01830341f, 
    0.10137403f, 0.14428481f, -0.11987417f, -0.06785387f, -0.06929816f, 0.14728145f, -0.00535803f, 0.07907557f, 
    -0.01329296f, -0.09093212f, 0.14487182f, 0.10271844f, 0.10457332f, -0.10995430f, -0.04235893f, -0.06122862f, 
    0.08018957f, 0.24571441f, 0.00484054f, 0.59785211f, -0.01261737f, -0.07294091f, 0.04435486f, -0.02766752f, 
    -0.03892221f, 0.22728434f, 0.22859384f, -0.09869222f, -0.23006511f, 0.05057529f, 0.20391707f, -0.01159425f, 
    -0.00774650f, 0.11857092f, 0.08307900f, 0.08819416f, -0.01776885f, 0.01545427f, 0.14985368f, -0.19665398f, 
    -0.08886797f, 0.25759149f, -0.13728912f, 0.06447846f, 0.10416240f, -0.02483286f, 0.07169685f, 0.00236054f, 
    -0.11236040f, -0.02924585f, -0.07251609f, -0.01740161f, 0.00534238f, 0.14044079f, 0.00176990f, 0.12821107f, 
    0.12826769f, 0.11513134f, -0.10646581f, 0.08206544f, 0.12131582f, 0.00198789f, 0.03609732f, 0.02499216f, 
    0.34433663f, -0.00977019f, 0.29882652f, 0.36635774f, -0.03378675f, -0.01297883f, 0.01067624f, -0.10710604f, 
    -0.14751431f, -0.04880160f, 0.06482790f, -0.05863761f, -0.08036070f, 0.28637531f, -0.07696081f, -0.04397037f, 
    -0.05078722f, -0.06489620f, 0.05550200f, -0.07426363f, 0.21404758f, 0.10875244f, -0.04985676f, -0.00391711f, 
    -0.12291801f, 0.11907212f, 0.16866195f, -0.06603957f, 0.12960285f, 0.02232678f, 0.31895816f, 0.08150677f, 
    0.17571159f, -0.08852866f, -0.05981547f, -0.02697546f, 0.12194166f, 0.14280777f, 0.06027025f, 0.10416912f, 
    0.19745284f, -0.03572830f, -0.06736559f, 0.09799308f, 0.03126519f, 0.07842109f, -0.03944216f, 0.14146861f, 
    -0.06707165f, -0.04812042f, -0.03021394f, 0.05674446f, 0.09172013f, -0.06470228f, 0.00708675f, -0.05166296f, 
    0.01676693f, 0.09602472f, -0.21375234f, -0.04220653f, -0.10041739f, 0.24494815f, 0.07450341f, -0.06316615f, 
    0.06316735f, 0.13422529f, -0.01683547f, 0.04849779f, 0.01640844f, -0.06148841f, 0.03979046f, 0.00364024f, 
    0.02613286f, -0.05542327f, -0.03632613f, 0.01112986f, -0.01845527f, 0.03343697f, -0.03766145f, -0.03366929f, 
    0.01057854f, 0.00439317f, 0.02170986f, -0.00722077f, -0.05899604f, 0.02528707f, -0.05894298f, -0.00489827f, 
    -0.01682059f, 0.02060232f, 0.04299145f, 0.00506420f, 0.03426304f, 0.00384113f, -0.00268723f, 0.01928668f, 
    -0.00184453f, -0.02537189f, 0.02182844f, -0.02074298f, -0.05828970f, -0.01576719f, 0.01779705f, -0.04413309f, 
    -0.03411128f, 0.01137308f, 0.01946214f, 0.03186946f, -0.01198401f, 0.01433823f, 0.01481509f, -0.02959856f, 
    0.01653419f, -0.01733058f, 0.02925816f, 0.03789057f, 0.01984439f, 0.03343479f, 0.01536111f, -0.00928800f, 
    -0.02044508f, 0.01998129f, 0.04324375f, -0.03564971f, 0.02882666f, -0.01749541f, 0.01394682f, -0.04740041f, 
    -0.01639242f, 0.00978478f, 0.02779348f, -0.03871303f, 0.03476618f, -0.00411988f, 0.01360508f, -0.05250837f, 
    0.03698231f, 0.03794735f, -0.02363626f, -0.03520994f, -0.01701558f, -0.03229399f, 0.02687833f, -0.02905248f, 
    -0.03926545f, 0.04016022f, -0.04367616f, -0.02103369f, 0.00993426f, -0.04539354f, -0.02027667f, -0.04940534f, 
    -0.00769140f, 0.01160713f, -0.02903254f, -0.04721975f, 0.03387789f, 0.01973744f, 0.00939953f, -0.02460979f, 
    0.02789991f, -0.00782300f, 0.03397942f, -0.05720680f, -0.01982838f, 0.02572338f, 0.03609365f, 0.02274106f, 
    -0.05657654f, 0.02410173f, -0.02834518f, -0.01997176f, -0.02733933f, 0.01088442f, 0.01488821f, -0.05562336f, 
    -0.00395267f, 0.01912334f, -0.03943490f, 0.02511138f, 0.04595272f, 0.03836534f, 0.00082876f, -0.04305934f, 
    -0.00992786f, -0.00472023f, -0.01991140f, 0.00194163f, -0.03639763f, -0.01255747f, 0.00960980f, -0.02376115f, 
    -0.00561009f, -0.05536328f, -0.01579804f, -0.05533997f, 0.02329849f, -0.03624362f, -0.02892639f, -0.00711725f, 
    0.03603442f, -0.01723536f, 0.01499946f, 0.02417039f, -0.01274523f, 0.00566611f, 0.03461352f, -0.00266053f, 
    0.03538064f, 0.03792686f, -0.00168813f, -0.05269315f, 0.01148429f, 0.01036952f, -0.03356450f, -0.04201087f, 
    -0.00364442f, -0.03189624f, 0.05176126f, -0.04786703f, -0.04444928f, -0.01730256f, -0.05225120f, -0.02897596f, 
    0.01585744f, 0.03986324f, 0.00454110f, 0.02821981f, -0.00669870f, -0.03809596f, -0.02622661f, 0.01419512f, 
    -0.04740047f, 0.03245270f, -0.03781589f, 0.02439860f, -0.03590400f, -0.05631097f, -0.03995306f, 0.02441041f, 
    0.03803676f, 0.01631539f, 0.03908631f, -0.00503226f, -0.02376467f, -0.02957820f, -0.02096527f, 0.00938814f, 
    -0.02884800f, 0.00283469f, 0.00329833f, -0.04114924f, -0.03822322f, 0.00782755f, 0.00470457f, -0.04505887f, 
    -0.03402033f, -0.02500074f, -0.00546362f, -0.03155703f, 0.00902827f, -0.05876132f, 0.04565027f, -0.04549637f, 
    -0.01841961f, 0.02116541f, -0.02241134f, 0.03188879f, -0.00898356f, 0.01614152f, -0.04201495f, -0.03467181f, 
    -0.01694871f, -0.03806872f, 0.02673172f, -0.03505832f, -0.05843087f, 0.03538541f, -0.02560409f, 0.04937655f, 
    0.02532957f, -0.00135145f, -0.04859393f, -0.04445670f, -0.00409802f, 0.01369631f, 0.03109646f, -0.00617709f, 
    0.01768369f, -0.04448895f, 0.02569833f, 0.03901382f, -0.06067327f, 0.02419670f, -0.05814803f, -0.01044042f, 
    -0.04357699f, -0.01653031f, 0.00849012f, -0.01232581f, -0.03368145f, -0.04765390f, 0.00088206f, -0.00725852f, 
    0.01111367f, -0.01519489f, -0.00375130f, 0.02529858f, -0.00172882f, -0.05099745f, 0.02091769f, 0.02087760f, 
    -0.02764737f, -0.04829856f, 0.03362768f, -0.00934629f, 0.01127331f, -0.05129068f, -0.03420537f, 0.04456568f, 
    0.03257686f, -0.01854247f, -0.00987377f, 0.02212871f, -0.06015174f, 0.01714777f, -0.01482820f, -0.01999423f, 
    -0.01605356f, -0.00572474f, 0.01436740f, -0.04600229f, -0.02219018f, 0.03996370f, -0.00841036f, -0.01435606f, 
    0.00408059f, 0.01276769f, -0.04752820f, -0.03080468f, 0.02071640f, 0.02063083f, 0.01760592f, 0.03919138f, 
    0.01538200f, 0.02340721f, -0.03584122f, -0.00242148f, -0.05005483f, -0.01273176f, 0.01097675f, -0.03636149f, 
    -0.02932717f, -0.04186673f, 0.01334000f, 0.02722908f, -0.03155981f, 0.01431329f, -0.01448367f, 0.03118080f, 
    0.01588820f, -0.00099107f, -0.01716446f, -0.05518509f, 0.00558240f, 0.00397513f, 0.02335875f, 0.01620573f, 
    -0.02769950f, -0.03971700f, -0.02255860f, -0.00487912f, -0.02281671f, -0.04336830f, -0.05436275f, -0.03264726f, 
    -0.03703776f, 0.00446476f, 0.00521461f, -0.00125927f, -0.03624084f, -0.04563871f, -0.00928618f, 0.00778315f, 
    -0.01645220f, -0.00576128f, -0.02702398f, 0.03020536f, -0.04142901f, -0.01790008f, -0.02722701f, 0.00007974f, 
    0.00762716f, -0.04181036f, -0.05740836f, -0.00731681f, 0.01732851f, -0.02104661f, 0.01169456f, 0.01946184f, 
    0.03406265f, -0.02504351f, -0.05863860f, 0.02286209f, 0.00702535f, -0.01768240f, -0.00364905f, -0.02610804f, 
    -0.00064589f, -0.05071713f, 0.01795907f, 0.01516448f, -0.04566331f, -0.04830981f, 0.00850432f, 0.00311921f, 
    0.00010077f, 0.02513244f, -0.04136503f, -0.03305995f, -0.06023091f, -0.05107268f, -0.04907238f, -0.04595303f, 
    0.01145235f, -0.04400424f, 0.00608751f, -0.00063844f, -0.02920620f, -0.03816967f, -0.03832728f, 0.01560122f, 
    -0.02300889f, 0.03267817f, 0.00197668f, 0.02392150f, 0.01534999f, -0.03020358f, -0.04650683f, -0.03893038f, 
    -0.03749583f, 0.01697366f, -0.00245632f, 0.03023699f, 0.01688749f, -0.02571304f, -0.05068736f, -0.03578302f, 
    0.01432241f, -0.01943360f, 0.02119779f, -0.02814071f, -0.03599115f, -0.02129016f, 0.01035361f, 0.01462330f, 
    0.15816395f, -0.05026175f, 0.02550931f, 0.10875533f, -0.04986482f, -0.00341306f, 0.11551080f, 0.03918837f, 
    0.05095283f, 0.06376858f, 0.07486473f, 0.14218584f, 0.06024899f, 0.12970206f, 0.16614817f, -0.01010224f, 
    -0.10415606f, 0.06698910f, 0.05723859f, -0.04991562f, 0.06415929f, -0.15730117f, 0.03087103f, -0.05139516f, 
    -0.09477413f, -0.20889246f, 0.26574156f, -0.02331588f, 0.03047056f, 0.00161160f, -0.08118124f, 0.15973723f, 
    -0.09302498f, -0.02775568f, 0.09153727f, 0.03442688f, -0.34146610f, -0.05289366f, 0.15070459f, -0.14599414f, 
    0.03217924f, 0.08817126f, 0.11438476f, -0.11579013f, 0.00260117f, -0.02419659f, 0.00991473f, 0.00982369f, 
    0.23929763f, -0.09528746f, 0.21267049f, -0.27763543f, -0.10633672f, 0.04573211f, 0.11519571f, 0.05476750f, 
    0.07897088f, -0.01867532f, 0.12602574f, 0.11303540f, 0.15172112f, 0.10873624f, -0.15429278f, -0.20153046f, 
    0.06475425f, 0.02048572f, 0.06565566f, 0.00689040f, 0.02868301f, 0.08097102f, 0.21813406f, -0.10103086f, 
    -0.10290457f, -0.07325386f, 0.27809957f, -0.08683825f, -0.03864460f, 0.00701209f, 0.00017195f, 0.06463216f, 
    0.18920654f, -0.00254305f, 0.04960005f, -0.09481107f, 0.18024711f, 0.23328322f, 0.05514255f, -0.00754045f, 
    -0.04728997f, -0.00855865f, 0.01419023f, 0.04680521f, -0.08356663f, -0.02939717f, 0.06076259f, 0.16532716f, 
    0.02026257f, 0.11053865f, 0.09764975f, -0.11736988f, -0.05828887f, -0.06172148f, 0.07254568f, 0.12194075f, 
    0.06369446f, -0.06583221f, 0.02355003f, -0.00570487f, 0.01744577f, -0.14079723f, 0.05872263f, 0.32054695f, 
    0.03575836f, -0.03093377f, -0.01180605f, 0.06796692f, -0.09311973f, 0.10446199f, 0.05798657f, 0.18768106f, 
    -0.08567080f, 0.17563058f, 0.07353675f, -0.06804067f, -0.00207797f, 0.08016048f, 0.02695271f, 0.09585660f, 
    -0.18615957f, -0.01388795f, 0.06592626f, -0.11489462f, -0.26665667f, -0.00311587f, -0.19013815f, -0.14611909f, 
    0.11326256f, 0.17986071f, -0.01092658f, -0.03080611f, 0.06357063f, -0.25992295f, 0.13714893f, 0.02837514f, 
    -0.07191092f, 0.14063334f, -0.12672219f, 0.34787130f, -0.04907227f, -0.11967190f, 0.00695404f, 0.02488363f, 
    0.08554549f, -0.00347273f, -0.00899084f, -0.04052373f, 0.04439621f, 0.18720673f, 0.21263589f, -0.01616009f, 
    -0.01864088f, 0.01752255f, 0.04770054f, 0.02998714f, -0.02390001f, 0.04376085f, 0.01903267f, 0.13714877f, 
    -0.13556832f, -0.01913504f, -0.16767974f, 0.07614298f, 0.02434122f, 0.09648901f, 0.05227224f, -0.09715278f, 
    0.11890655f, -0.05644444f, -0.13795377f, 0.04763310f, 0.04753408f, -0.26455083f, 0.49582684f, 0.16613388f, 
    0.06309187f, -0.00121468f, -0.01710863f, 0.00538881f, 0.10898152f, -0.10392947f, -0.13540435f, 0.08252122f, 
    0.10948715f, -0.24967210f, -0.17631000f, 0.15638937f, -0.00835567f, -0.03549998f, -0.07012045f, -0.06941036f, 
    0.14172694f, -0.00524973f, 0.18372214f, 0.06597236f, 0.43438995f, -0.25729552f, -0.03850482f, 0.19334669f, 
    -0.01808471f, 0.05615069f, -0.02571180f, -0.16388638f, 0.05981043f, 0.05436876f, 0.12171151f, 0.01171353f, 
    0.03167501f, -0.04802098f, 0.11844583f, 0.25988123f, -0.05599019f, -0.09390434f, 0.02610308f, -0.06870438f, 
    -0.00508851f, -0.14818391f, 0.09028384f, 0.06562498f, 0.02503375f, 0.05161438f, 0.32512772f, -0.05035089f, 
    0.06629837f, -0.01290083f, -0.01938201f, 0.11510778f, 0.09349988f, 0.03387823f, -0.07640090f, 0.06751721f, 
    0.08057008f, 0.07786284f, -0.00113586f, 0.20733392f, 0.06823966f, 0.03893229f, -0.04713613f, 0.03337541f, 
    0.00947585f, -0.03250782f, 0.02235099f, -0.00816957f, -0.31762841f, 0.11147003f, 0.12750386f, -0.24480733f, 
    0.08858816f, 0.15925990f, -0.00348814f, -0.14692855f, 0.10415346f, 0.04470718f, 0.12455991f, -0.07160884f, 
    0.01314572f, 0.14831077f, -0.05452935f, -0.17604804f, 0.05207866f, 0.12685969f, -0.01627538f, -0.02077971f, 
    0.04059538f, 0.12002604f, 0.02943901f, -0.22206667f, -0.00038686f, 0.01683477f, -0.35678360f, -0.00272200f, 
    0.21957874f, -0.01877431f, 0.03039349f, -0.24896783f, 0.09802706f, 0.07815815f, -0.07991665f, 0.01511843f, 
    -0.09011637f, 0.14396785f, 0.06724300f, -0.04391588f, 0.14289558f, 0.05412798f, -0.03988036f, 0.01993880f, 
    0.12523867f, 0.04143248f, 0.02499886f, 0.03435035f, -0.08605070f, -0.22480597f, -0.04706896f, -0.06484248f, 
    0.03584831f, 0.13166809f, 0.01968762f, -0.01886191f, 0.06864502f, 0.13912269f, 0.03339380f, 0.15762872f, 
    -0.07057322f, -0.01898316f, 0.10028697f, 0.32468051f, 0.01507356f, -0.05693644f, -0.08140551f, 0.02166872f, 
    -0.00918999f, 0.04997732f, 0.02624788f, 0.00471658f, -0.24994177f, 0.01304537f, -0.09684681f, -0.09783834f, 
    0.03258109f, -0.05824765f, 0.07448336f, -0.09969684f, 0.03030436f, -0.06209493f, 0.05730861f, 0.12349325f, 
    -0.02375428f, -0.06937574f, 0.04218282f, -0.01159296f, 0.00346253f, 0.03352949f, -0.14953429f, 0.13308398f, 
    0.08773451f, 0.02729564f, 0.17930363f, -0.03421370f, -0.29107583f, 0.06164174f, -0.15284115f, -0.25221330f, 
    0.03621504f, 0.20117262f, 0.08804273f, -0.04677170f, -0.02808755f, -0.07769687f, 0.00843145f, 0.02582557f, 
    -0.58937746f, 0.25891927f, 0.01638706f, -0.18957119f, 0.19194159f, -0.03449744f, -0.02728834f, 0.09702397f, 
    -0.06900437f, -0.00154060f, -0.06600233f, 0.15735762f, 0.06505846f, 0.02288472f, 0.23438865f, -0.07372788f, 
    0.04029443f, 0.01915802f, 0.15284742f, 0.09370581f, 0.13502152f, 0.10824406f, 0.00263042f, -0.16779178f, 
    0.24797510f, -0.20501997f, 0.04906457f, 0.33643401f, 0.02710284f, 0.07502883f, 0.02252308f, -0.02164344f, 
    0.07968538f, 0.02224714f, -0.00896584f, -0.02740869f, 0.01603645f, 0.07890811f, 0.13107324f, -0.15933077f, 
    -0.05718735f, -0.00911040f, 0.09834334f, 0.10007134f, -0.04437519f, -0.05751383f, -0.01825774f, -0.08700802f, 
    0.08534918f, -0.17456599f, 0.21628100f, 0.10131104f, 0.00075411f, 0.14047931f, -0.02736469f, -0.09218082f, 
    0.01508604f, -0.07921421f, 0.11472219f, 0.05077074f, -0.09957555f, -0.08414299f, 0.19391567f, 0.03401913f, 
    0.00231834f, -0.04125410f, 0.00376304f, -0.10527832f, -0.00562734f, 0.00037637f, -0.03492232f, -0.06301049f, 
    0.14063025f, -0.26747042f, 0.13923338f, 0.16241387f, 0.13443455f, 0.10275806f, -0.01323212f, -0.13087672f, 
    -0.02663945f, -0.05820576f, -0.02419516f, 0.14755587f, -0.06973229f, 0.16247368f, -0.11307787f, 0.15426058f, 
    0.05934308f, 0.09329804f, 0.04198235f, -0.06180096f, -0.04114951f, -0.04518597f, 0.07849001f, -0.05325098f, 
    0.08667744f, -0.27677959f, -0.00340630f, -0.08628743f, 0.09477457f, -0.00531567f, -0.00633408f, -0.01160598f, 
    0.05937712f, -0.01560819f, 0.05977081f, -0.09673576f, 0.31447402f, 0.06489641f, -0.12218577f, -0.04700709f, 
    0.12967342f, 0.04162154f, 0.10427122f, -0.07266559f, -0.15085194f, -0.00659314f, 0.08086742f, 0.05665854f, 
    0.17099482f, -0.01051575f, 0.15536578f, -0.09815880f, -0.07480111f, 0.10868433f, 0.01636754f, 0.01375575f, 
    0.14149265f, 0.06372599f, 0.04991354f, -0.00556785f, 0.37646791f, 0.07480352f, -0.00421896f, 0.26350161f, 
    0.06284390f, 0.04027511f, 0.03680439f, 0.13204050f, -0.00945030f, -0.05997862f, 0.00529078f, -0.00010569f, 
    -0.09305000f, -0.02742600f, -0.09829936f, -0.14299749f, 0.05434607f, -0.01044151f, 0.00398207f, 0.04009858f, 
    -0.01218822f, -0.05119045f, 0.11511146f, -0.13092172f, -0.07671161f, 0.12164212f, -0.18943411f, 0.04986997f, 
    0.05968093f, -0.04933140f, 0.04473715f, 0.05644045f, 0.11585250f, -0.02288740f, 0.12968488f, 0.03542546f, 
    0.34778836f, 0.08244706f, -0.31340098f, 0.08686025f, -0.09441571f, -0.04447287f, -0.00967142f, 0.10385622f, 
    0.12823322f, 0.03318787f, -0.04500628f, -0.14132723f, 0.62512118f, -0.18157703f, -0.12954389f, 0.28068411f, 
    0.06189022f, 0.00903951f, 0.06926240f, -0.07651004f, 0.07920699f, 0.06797713f, 0.05898920f, 0.02706236f, 
    0.42875835f, -0.36154020f, -0.29830766f, 0.17455870f, -0.07044452f, -0.07130107f, -0.09314167f, 0.00095815f, 
    -0.06437010f, -0.04433026f, -0.06429861f, 0.00801590f, 0.04803598f, -0.31255323f, 0.24258702f, 0.31094185f, 
    -0.03829177f, -0.02669454f, -0.01516340f, 0.05439497f, -0.03436363f, 0.04449036f, -0.05625330f, -0.00160376f, 
    0.04854807f, -0.24807100f, -0.10480604f, -0.13224664f, -0.05884028f, -0.05382661f, 0.03038005f, -0.05411505f, 
    0.04452112f, 0.08593880f, -0.00636478f, 0.12383005f, -0.06519020f, -0.02620944f, 0.00428441f, 0.07257304f, 
    0.05225172f, 0.06327424f, 0.03690283f, -0.04886340f, -0.02676560f, 0.07727954f, 0.03426366f, 0.03374108f, 
    -0.09378090f, -0.08070201f, -0.09835861f, 0.22128025f, 0.10365224f, -0.02753358f, 0.04730165f, 0.04500217f, 
    -0.03015436f, -0.00318763f, 0.03924715f, -0.01286342f, -0.29824466f, 0.28795502f, 0.02327058f, -0.10954639f, 
    -0.13881779f, 0.02156600f, 0.01350110f, 0.00295881f, 0.02222620f, 0.06657355f, 0.01560033f, 0.21172166f, 
    0.35350072f, 0.16031957f, -0.16070765f, 0.09543306f, -0.01503311f, -0.04308185f, -0.08055385f, 0.04698945f, 
    0.05117734f, 0.08928084f, 0.11237592f, 0.15132186f, 0.17800505f, -0.17497054f, -0.01843430f, -0.11332975f, 
    -0.05679233f, -0.07258749f, -0.02080260f, -0.08857069f, 0.02105275f, -0.02430840f, 0.10826559f, 0.03534256f, 
    -0.11302315f, 0.24306773f, -0.08350267f, -0.08792050f, -0.07030925f, -0.04710966f, 0.11373201f, -0.18551911f, 
    0.08161285f, 0.06607586f, -0.03028526f, -0.09668062f, -0.03152845f, -0.13499480f, -0.23599166f, 0.01181390f, 
    0.08515103f, -0.11468928f, 0.16957353f, 0.03378572f, -0.08825234f, -0.10328191f, -0.07751936f, 0.04908897f, 
    0.26970994f, -0.05872717f, 0.20575382f, 0.01804423f, 0.15032347f, 0.07142009f, 0.07079130f, -0.01816551f, 
    0.00319657f, -0.04155525f, 0.02786133f, -0.04498477f, 0.03254336f, -0.11947425f, -0.04170808f, -0.02530603f, 
    -0.01894419f, 0.06306770f, -0.01632907f, -0.09841871f, -0.01064753f, 0.04491462f, 0.02912816f, 0.14774169f, 
    -0.09361709f, 0.26297739f, -0.00933486f, 0.06920896f, -0.09665865f, 0.06084419f, -0.10882863f, 0.09926135f, 
    0.01195687f, 0.03946776f, 0.05009040f, 0.01716164f, 0.03407682f, -0.08997739f, 0.01908074f, 0.02326854f, 
    0.05958196f, -0.11396925f, -0.04987185f, -0.00717535f, 0.05654082f, 0.06255111f, 0.03175050f, -0.04259524f, 
    -0.00569531f, -0.07879973f, 0.04622720f, -0.08123497f, -0.12865756f, -0.05146800f, -0.02222397f, 0.12975730f, 
    0.09013671f, -0.01922117f, 0.03879786f, -0.06071118f, -0.07924484f, 0.03288863f, -0.04756919f, -0.09844942f, 
    -0.04259934f, -0.02634722f, -0.01867506f, -0.11151700f, -0.04449762f, -0.15216005f, -0.03768107f, -0.03739466f, 
    0.05742459f, 0.04947694f, 0.04996102f, 0.01194407f, 0.06072320f, -0.10533645f, -0.00387941f, -0.08209498f, 
    -0.09122225f, -0.05326460f, -0.07847841f, 0.05617217f, -0.10384039f, -0.14681466f, 0.16999720f, -0.08407782f, 
    -0.06906517f, 0.02190077f, -0.03098706f, 0.01028397f, 0.10134611f, -0.00122673f, 0.11313160f, 0.00679935f, 
    0.02868822f, -0.04741367f, 0.01179002f, 0.03694875f, 0.03305598f, -0.03924973f, -0.00215178f, 0.01870139f, 
    -0.03604259f, -0.03883582f, -0.02805446f, 0.00763872f, -0.00317623f, 0.02031425f, -0.03514314f, -0.03000764f, 
    -0.05319469f, -0.03138302f, 0.03865786f, 0.02035846f, -0.00653833f, 0.03655612f, 0.03159035f, -0.04074588f, 
    0.01979299f, -0.04821935f, -0.04955523f, 0.03367581f, 0.00610381f, 0.01364496f, -0.00515665f, -0.02292134f, 
    0.00816602f, -0.02385705f, -0.02514768f, 0.03870375f, -0.05401819f, -0.05245661f, 0.02868265f, -0.00719487f, 
    -0.03392480f, 0.00822795f, 0.01853722f, -0.05234453f, -0.03641377f, 0.03887342f, -0.05319356f, 0.03377314f, 
    -0.01668193f, -0.05044640f, -0.02417538f, -0.02095524f, 0.00748838f, -0.03971995f, -0.03360677f, 0.02537217f, 
    -0.05095538f, 0.02440691f, 0.04311819f, -0.03195296f, 0.04187484f, 0.03609119f, -0.02034734f, 0.04011714f, 
    -0.04694158f, -0.01693651f, -0.00079497f, -0.03563376f, 0.00275655f, 0.01717054f, -0.04829819f, 0.04629702f, 
    -0.00838710f, 0.00253273f, 0.03299480f, -0.04982629f, -0.04982270f, -0.00169187f, -0.05415943f, -0.00174973f, 
    -0.01699052f, 0.03981575f, -0.00833657f, 0.02197888f, -0.00093272f, 0.04011569f, 0.03405194f, -0.00188025f, 
    0.03192400f, -0.01795759f, -0.03478931f, -0.03440483f, -0.05583038f, -0.04021381f, -0.00262868f, 0.00886227f, 
    -0.01749283f, -0.05325506f, -0.04685279f, -0.02180828f, 0.03037800f, -0.00727524f, 0.03209217f, 0.04492364f, 
    -0.01975604f, -0.01205770f, 0.03460390f, 0.01888813f, -0.05600017f, -0.02289506f, -0.03475000f, -0.01821575f, 
    0.00725821f, 0.02599209f, -0.05154911f, 0.00182079f, 0.04541407f, -0.05207079f, 0.01222743f, -0.05163473f, 
    -0.04022153f, -0.03157870f, 0.02685812f, -0.01382736f, 0.01992432f, 0.03143612f, -0.04503635f, 0.02016825f, 
    0.01254912f, 0.02790500f, 0.02109829f, 0.03825097f, -0.00531740f, 0.01445119f, 0.04149935f, -0.04282622f, 
    0.03790621f, 0.01193530f, -0.01016743f, -0.04887560f, -0.02592489f, -0.03227314f, -0.02922035f, -0.01580738f, 
    0.02547136f, -0.03127394f, -0.01364859f, -0.02076506f, 0.03987075f, -0.05556436f, -0.04344302f, 0.03557510f, 
    -0.02490076f, -0.01266384f, 0.00029541f, 0.00977381f, 0.02829898f, 0.00258709f, 0.02027911f, 0.03637954f, 
    -0.04423232f, -0.03379331f, 0.03701313f, -0.02027507f, -0.00483983f, 0.03556755f, 0.03553133f, -0.03506174f, 
    0.02930493f, 0.03474042f, -0.02724334f, -0.00996873f, 0.02344097f, -0.02503583f, -0.02253592f, 0.03905364f, 
    -0.00904516f, -0.03160032f, 0.00997678f, 0.04050187f, 0.03519924f, -0.05080888f, 0.02890419f, 0.03341971f, 
    0.00862981f, 0.04260502f, -0.00248454f, 0.01243376f, 0.04025307f, -0.02561164f, -0.01265693f, -0.02507083f, 
    -0.00981382f, -0.02205769f, 0.03747851f, -0.03501083f, -0.03703654f, -0.02401988f, 0.01643144f, 0.01435382f, 
    -0.05360410f, 0.04073764f, -0.00909247f, -0.00957228f, -0.04432144f, -0.02866368f, -0.02806135f, -0.05048726f, 
    0.02927202f, -0.03131919f, -0.02286694f, -0.02619898f, 0.01500938f, -0.03053027f, 0.00664345f, 0.03923070f, 
    0.03209154f, -0.01985060f, 0.02035813f, 0.01198656f, -0.04262387f, -0.04562325f, -0.02729851f, 0.01482322f, 
    0.01240587f, -0.02741274f, 0.01165258f, -0.04164753f, -0.00905655f, -0.01947970f, -0.04613888f, 0.01837807f, 
    -0.02447506f, -0.04602549f, -0.01787025f, -0.03269835f, 0.00445457f, 0.03301873f, -0.04482960f, -0.04167912f, 
    -0.00489523f, 0.03871564f, -0.05005298f, -0.01272706f, -0.02078235f, 0.01053366f, -0.03683549f, 0.00384611f, 
    -0.04074137f, -0.00003557f, -0.04416046f, 0.02876054f, -0.04460459f, 0.04346832f, 0.03185335f, 0.02523834f, 
    -0.04385575f, 0.02551973f, -0.02408820f, -0.00891022f, -0.04566105f, -0.03482700f, -0.02690855f, -0.00090453f, 
    -0.05127992f, 0.00670626f, -0.04759503f, -0.01553860f, -0.02100855f, -0.03650438f, -0.01591185f, 0.00015657f, 
    -0.03974155f, 0.04493448f, -0.00773375f, -0.02902250f, -0.01991980f, -0.03079263f, 0.03407072f, 0.00262851f, 
    0.02450335f, -0.02142299f, 0.04529511f, -0.04988449f, 0.02931516f, -0.01021879f, -0.01667096f, -0.04178713f, 
    -0.05560105f, -0.04418845f, -0.03811492f, -0.01005209f, -0.02123306f, 0.03488777f, -0.02581406f, -0.04344064f, 
    -0.02802622f, -0.04089322f, -0.02310422f, -0.00845239f, -0.00047765f, -0.01104001f, 0.03560553f, 0.02087879f, 
    0.00570854f, -0.04347583f, -0.05305984f, 0.03305275f, -0.00276220f, -0.00148613f, -0.04590210f, -0.04369166f, 
    0.02768815f, -0.00333844f, 0.01721532f, -0.04815701f, -0.01940293f, 0.03754664f, -0.01133925f, -0.03979220f, 
    0.02523402f, -0.05377714f, 0.04421154f, -0.03393650f, -0.02718657f, -0.00186722f, -0.03754015f, 0.04409488f, 
    -0.01260881f, -0.04988794f, 0.02236441f, -0.02046219f, -0.04252658f, -0.05297513f, -0.02460956f, 0.01566158f, 
    0.02100313f, -0.03562477f, -0.05581953f, -0.02651058f, -0.04075773f, -0.02576444f, -0.01652121f, -0.02770583f, 
    -0.00778556f, -0.00807210f, -0.01270950f, 0.00828284f, 0.04199093f, -0.01572423f, -0.00124906f, 0.02123287f, 
    -0.03286183f, -0.03662310f, -0.02237661f, 0.03535001f, -0.03510670f, -0.02897395f, 0.02454956f, 0.01101789f, 
    -0.03199434f, -0.03094122f, 0.01714399f, -0.05475803f, -0.00139829f, -0.03433844f, 0.00001877f, -0.00947445f, 
    -0.01049417f, -0.01493461f, 0.01698016f, -0.02152168f, -0.03542639f, 0.02572056f, 0.03520407f, 0.00113943f, 
    0.00070980f, 0.02173492f, 0.02111563f, -0.02348727f, -0.04782026f, -0.01770984f, -0.02399371f, 0.02688423f, 
    0.03391423f, 0.00897208f, -0.02797129f, -0.03049300f, 0.02763347f, 0.02969521f, -0.05357619f, -0.02691109f, 
    0.04235433f, 0.04361222f, -0.02707751f, -0.04905247f, -0.03566517f, 0.00060879f, -0.02059981f, 0.03077590f, 
    -0.04677300f, 0.03783650f, -0.04204729f, 0.04456419f, 0.02741656f, -0.05428975f, -0.02269212f, 0.04161552f, 
    0.00130508f, -0.02836761f, 0.01288957f, -0.02179238f, 0.01441509f, -0.04249056f, -0.04213905f, -0.03519657f, 
    -0.01505726f, -0.03722274f, -0.04339836f, 0.03314929f, -0.02057078f, -0.02450965f, -0.03203844f, -0.00731958f, 
    0.03944935f, 0.00659839f, -0.05421308f, -0.05233126f, -0.03021441f, -0.00120227f, -0.04885471f, 0.04009983f, 
    0.01058916f, -0.04149000f, -0.05518561f, -0.04111459f, -0.00632090f, 0.00210863f, 0.01043689f, -0.03634051f, 
    -0.01395857f, -0.01477037f, 0.01620332f, -0.05297180f, -0.00520349f, -0.01581232f, -0.03978195f, 0.03858515f, 
    0.03632887f, -0.05362867f, 0.02765160f, 0.02414893f, 0.03663286f, -0.02648179f, -0.03360881f, 0.00611793f, 
    -0.05266854f, 0.02272472f, 0.01917425f, -0.03262347f, -0.01616911f, -0.01970899f, -0.04342027f, -0.00329882f, 
    -0.04500585f, -0.01054543f, 0.01843734f, 0.00997633f, -0.02502717f, 0.02447734f, 0.01347768f, 0.03693740f, 
    -0.02449623f, 0.00459782f, 0.00524962f, -0.01342389f, -0.00194945f, -0.05294524f, -0.00657413f, -0.05084056f, 
    0.04224641f, 0.00322707f, -0.02469475f, -0.00750139f, -0.00628418f, 0.02176054f, 0.01201492f, -0.00586230f, 
    -0.00199545f, 0.00712030f, -0.05705179f, 0.02723235f, 0.00190861f, -0.01792617f, -0.02556372f, -0.00863932f, 
    -0.00649630f, -0.00878349f, 0.02552567f, 0.04760627f, -0.04388260f, -0.01477030f, -0.01567165f, -0.04981671f, 
    -0.00771629f, -0.01499343f, 0.02331392f, 0.02331277f, 0.04162072f, -0.01271573f, 0.00283171f, -0.05128123f, 
    0.04165054f, 0.00501930f, -0.00805650f, -0.03366574f, -0.03732308f, -0.03903203f, -0.00714709f, -0.02839763f, 
    0.04059184f, -0.02553960f, -0.00042053f, -0.02302229f, 0.00157896f, 0.03899293f, -0.05089329f, -0.01004431f, 
    0.04108493f, -0.00312662f, -0.02551872f, -0.05257921f, 0.04337035f, 0.00290281f, 0.00858315f, -0.01132700f, 
    -0.04447745f, 0.03021485f, 0.00538346f, -0.00492220f, -0.02826041f, -0.04991946f, -0.00464500f, -0.04389448f, 
    0.03126711f, -0.00280747f, -0.01120967f, -0.00422860f, -0.03586299f, 0.00458249f, 0.04188237f, 0.01887373f, 
    -0.04172582f, -0.02749505f, -0.03879401f, -0.04093828f, -0.04377141f, 0.04178229f, -0.03007057f, -0.01718074f, 
    0.00145889f, -0.02156424f, 0.03988814f, 0.01064903f, 0.02668707f, 0.02873095f, 0.01522866f, -0.00640993f, 
    -0.00927219f, 0.04013216f, -0.00632104f, 0.00976735f, -0.01927305f, -0.05536515f, 0.00492718f, -0.05543011f, 
    0.03256523f, -0.05298377f, -0.01276151f, -0.02225349f, 0.04163776f, -0.03782863f, 0.01504760f, 0.01869364f, 
    0.01919477f, 0.04226109f, -0.05271713f, -0.03928206f, -0.05489617f, -0.03157814f, 0.04094828f, -0.00430973f, 
    -0.02977507f, -0.02728855f, -0.01214759f, 0.02756187f, -0.05077315f, -0.01532915f, 0.01596220f, -0.02815298f, 
    -0.02477252f, -0.00879852f, 0.02863099f, -0.02806129f, 0.04476219f, 0.03003155f, 0.01067958f, -0.05688696f, 
    -0.05583826f, 0.00529987f, 0.04188200f, -0.05508529f, -0.03969363f, -0.04717857f, -0.03686161f, -0.03909558f, 
    -0.02918494f, -0.00835529f, 0.00085848f, -0.05576383f, 0.00059375f, -0.00226360f, 0.03512497f, -0.03713049f, 
    -0.04272926f, -0.02866610f, 0.02817894f, -0.05307966f, 0.00573657f, -0.03109541f, -0.04425951f, 0.03322335f, 
    0.03968832f, 0.00378355f, 0.00060296f, 0.03743403f, -0.04226379f, 0.02505966f, -0.05382791f, 0.03974678f, 
    0.01509468f, -0.01187268f, -0.03512250f, -0.01976950f, 0.04489013f, 0.00863036f, -0.02168788f, -0.04488967f, 
    0.03307245f, 0.01035884f, 0.04144067f, -0.04899743f, -0.02596438f, -0.01881247f, 0.03080423f, 0.04258898f, 
    -0.01563438f, -0.04598865f, -0.00223417f, 0.03324768f, 0.00555375f, 0.03782018f, -0.03922665f, -0.05078117f, 
    -0.03196082f, -0.04415337f, -0.03287590f, -0.03442816f, -0.05808799f, -0.03005215f, -0.01861761f, -0.05211804f, 
    -0.05278313f, -0.00500233f, 0.01177708f, -0.00007079f, 0.04454998f, 0.02109245f, -0.00988336f, -0.01040259f, 
    -0.02834806f, 0.00680144f, -0.04818971f, -0.03120293f, -0.01912240f, -0.04843397f, 0.01096885f, -0.03244950f, 
    -0.03423744f, 0.03366134f, -0.04637140f, 0.02432187f, -0.04143263f, -0.03667412f, 0.01457050f, -0.01841024f, 
    0.03927189f, 0.01104272f, 0.00609680f, -0.02321892f, -0.01847628f, 0.00907535f, -0.03782368f, 0.02722197f, 
    0.00793984f, 0.00010680f, -0.03463005f, 0.02738322f, -0.02014980f, 0.02944888f, -0.02166542f, -0.03465573f, 
    0.03012236f, 0.02761595f, 0.03475333f, 0.02777197f, 0.02497678f, 0.02849964f, 0.00614980f, -0.04630693f, 
    -0.02920038f, 0.04631251f, -0.05293799f, 0.03847214f, -0.01359873f, -0.04214924f, -0.03309381f, -0.04642393f, 
    0.01684958f, -0.01879210f, 0.03767859f, 0.01050716f, -0.05569779f, 0.04217010f, 0.01440205f, 0.01170695f, 
    -0.01936999f, -0.01699055f, -0.05532968f, -0.01385750f, 0.02650810f, -0.02370296f, 0.02401405f, 0.00883805f, 
    -0.04607977f, -0.02827894f, -0.03898375f, -0.02575694f, -0.00522459f, 0.03430161f, 0.03219746f, -0.04618596f, 
    -0.05461379f, -0.04894270f, -0.04847135f, -0.02545276f, 0.03496164f, -0.00307894f, 0.04010821f, -0.04624883f, 
    0.02678080f, -0.01584744f, -0.00996870f, -0.05840207f, 0.03857198f, 0.03509402f, -0.01436114f, 0.04048597f, 
    -0.18798921f, 0.04363345f, 0.08093350f, -0.23305599f, -0.09748594f, -0.13247527f, -0.16692717f, -0.10647184f, 
    0.06534304f, -0.08203883f, -0.08627678f, -0.08500302f, 0.14062144f, -0.17953636f, 0.08286950f, 0.10728498f, 
    0.10555346f, 0.01473447f, -0.04285874f, -0.13357328f, 0.07915267f, -0.08213073f, 0.08635450f, 0.00243437f, 
    -0.02908633f, 0.00810236f, -0.04108211f, -0.17296967f, -0.03237855f, -0.01545203f, -0.00714529f, 0.00081583f, 
    -0.01035773f, 0.05209876f, -0.09147279f, -0.08946181f, -0.27814966f, -0.23553701f, -0.17123705f, 0.06148312f, 
    -0.01654832f, 0.16438881f, 0.01561627f, 0.06142876f, 0.07791381f, 0.10508279f, 0.04298633f, -0.07486989f, 
    0.21855095f, 0.37380114f, 0.29684070f, 0.04982497f, -0.15031986f, 0.16867253f, 0.02430481f, 0.10024569f, 
    0.03581913f, 0.08341078f, -0.08438440f, -0.12547897f, -0.05407964f, -0.20315409f, 0.10204474f, 0.08429349f, 
    0.02550600f, 0.02824917f, 0.17129435f, 0.03391427f, -0.02300629f, -0.08361957f, -0.17841776f, -0.02780406f, 
    0.02053833f, 0.21060190f, 0.40740696f, 0.19662817f, -0.12479840f, -0.07379802f, -0.04658369f, 0.12208834f, 
    -0.12690984f, -0.02489761f, 0.04664570f, 0.13784687f, -0.03779166f, 0.28081024f, 0.35413539f, 0.03847688f, 
    -0.16639838f, -0.06453019f, -0.05738712f, 0.10944268f, 0.12411002f, 0.03106543f, -0.01512171f, -0.07259185f, 
    -0.02240844f, -0.16564400f, 0.08708405f, 0.11263580f, 0.02731240f, 0.13388158f, -0.13722977f, 0.03419117f, 
    -0.11099458f, -0.03304134f, -0.03822352f, 0.03545365f, -0.34116235f, -0.15606304f, 0.28452978f, -0.08035733f, 
    0.06029522f, -0.03322890f, -0.06343941f, -0.03917374f, -0.07457029f, 0.07921475f, -0.13113458f, -0.02635728f, 
    0.19777994f, 0.28758851f, 0.17855828f, 0.25552574f, -0.10433561f, -0.08134933f, 0.11015148f, 0.06920434f, 
    -0.00960574f, 0.16512111f, 0.03850188f, 0.02043055f, -0.13091661f, 0.00224083f, 0.24683119f, 0.04465568f, 
    0.02280485f, 0.02791306f, 0.14755294f, -0.00828860f, -0.13047294f, -0.09960508f, 0.04361188f, 0.32311925f, 
    -0.40550542f, -0.15284535f, 0.18622532f, -0.03191359f, -0.11310624f, 0.14421745f, -0.02601440f, -0.00070845f, 
    -0.04509963f, -0.02886640f, 0.01354431f, -0.07452499f, -0.00747998f, 0.25391206f, 0.14070943f, -0.04255897f, 
    -0.07884242f, 0.19197696f, 0.10835883f, 0.18768740f, -0.06032776f, -0.03151778f, 0.00332729f, -0.02789300f, 
    -0.06335232f, 0.45937529f, 0.12961087f, 0.10616530f, -0.17620254f, 0.00335029f, -0.02271042f, 0.00381025f, 
    -0.02283383f, -0.05029102f, 0.02443151f, -0.16774738f, 0.36239728f, 0.43277389f, -0.23928975f, -0.20700252f, 
    -0.12853631f, 0.00938158f, 0.15304555f, -0.14744012f, -0.00033078f, -0.00852431f, -0.02778080f, 0.21319944f, 
    -0.09043026f, 0.12489115f, 0.29815462f, 0.09485926f, 0.00930126f, 0.00676093f, 0.23135306f, 0.07600328f, 
    -0.02330852f, -0.01759249f, -0.03183826f, -0.03950783f, 0.20806715f, -0.06359863f, -0.12680046f, 0.07142760f, 
    -0.04837016f, -0.10534997f, 0.33076304f, 0.02753789f, 0.01529370f, -0.03034624f, -0.03372976f, 0.03566176f, 
    -0.01655057f, 0.00785029f, 0.19902357f, -0.20511805f, 0.07914213f, 0.00979331f, -0.07746425f, -0.04653278f, 
    -0.01162729f, -0.02650752f, -0.06905492f, 0.14802781f, 0.33908653f, -0.10438317f, 0.02830219f, 0.10551875f, 
    0.15458252f, 0.16589816f, 0.26917845f, 0.18585169f, 0.04352036f, 0.07327875f, -0.06261952f, 0.03253473f, 
    -0.27881032f, -0.02503224f, 0.29393655f, -0.04440793f, -0.14696877f, 0.22983709f, 0.07123205f, -0.02386254f, 
    -0.01469453f, 0.07851929f, -0.20719081f, -0.17936246f, -0.43000016f, 0.10839587f, 0.10335537f, -0.07474582f, 
    0.19203080f, 0.03787745f, 0.00751938f, 0.09791472f, -0.07348455f, -0.08994150f, -0.08681980f, 0.01194005f, 
    0.02805744f, -0.04963539f, -0.09148494f, 0.04385725f, -0.05914984f, -0.00081600f, -0.10343919f, 0.23589905f, 
    -0.10386118f, -0.02474287f, 0.05596466f, 0.18418996f, 0.10911961f, 0.00581388f, -0.00492423f, 0.12307771f, 
    -0.08052266f, 0.11619844f, -0.00489492f, -0.04520772f, 0.09437975f, 0.12657197f, 0.24012689f, 0.04453846f, 
    0.70594043f, -0.02440921f, 0.05217864f, -0.11418576f, -0.18004945f, 0.01488413f, -0.00806985f, 0.08842684f, 
    -0.06642238f, 0.11624528f, -0.04806800f, -0.10661680f, 0.01306806f, 0.11776692f, 0.00874590f, -0.05108091f, 
    0.11258798f, -0.01589209f, 0.07126220f, 0.10112803f, 0.08961494f, 0.09641164f, -0.00444380f, -0.02172580f, 
    0.03521921f, -0.18851444f, 0.04809570f, -0.12958106f, 0.03522841f, 0.02612079f, 0.05810454f, -0.10611146f, 
    -0.11494263f, -0.02207293f, 0.00587862f, -0.00238614f, -0.02672798f, 0.06907800f, 0.08205085f, 0.07410199f, 
    -0.00701455f, 0.23730341f, 0.14377515f, 0.06055688f, -0.00100708f, 0.01523748f, 0.23230194f, 0.16782904f, 
    -0.06926095f, 0.18580283f, -0.03716648f, -0.09056365f, 0.18050244f, -0.11523084f, 0.21989697f, -0.14350186f, 
    -0.08011084f, -0.28006136f, -0.13444877f, -0.15277669f, -0.16695780f, 0.08162407f, 0.20107359f, 0.15735491f, 
    0.08957410f, 0.09099626f, 0.04918694f, 0.00307015f, -0.02394302f, 0.05661511f, -0.03426893f, 0.22474259f, 
    -0.07093177f, -0.08911658f, 0.03833320f, 0.14322810f, -0.06012761f, -0.00688097f, -0.03002671f, 0.15811528f, 
    0.00494965f, -0.02631893f, -0.11601654f, -0.00694930f, 0.24371691f, 0.08836038f, -0.13219851f, -0.13508013f, 
    0.09846799f, 0.13644741f, 0.00019409f, 0.08126660f, -0.00774559f, -0.06553919f, -0.04551335f, -0.04361806f, 
    -0.02358960f, -0.05368333f, 0.04308993f, -0.00365908f, 0.02906535f, -0.00550328f, -0.02838371f, 0.02028893f, 
    0.03828789f, -0.05799853f, 0.03434190f, -0.04742682f, 0.00245535f, -0.03410839f, 0.01959966f, 0.00819490f, 
    -0.02402067f, 0.01682997f, -0.05746260f, -0.05579208f, 0.02046459f, -0.05675400f, 0.03549793f, -0.05425712f, 
    0.01942572f, -0.03849104f, -0.05540209f, -0.03838779f, -0.01054387f, -0.03563787f, 0.03157265f, -0.04344171f, 
    -0.04718525f, -0.05306699f, -0.01914481f, 0.02707785f, 0.02759102f, 0.03416901f, 0.00716411f, -0.01648670f, 
    0.01038204f, -0.04981046f, 0.04131532f, -0.00845856f, -0.03925816f, -0.02474740f, 0.02671516f, -0.03562845f, 
    0.03581787f, -0.01079586f, -0.04076771f, -0.02319215f, -0.03875017f, -0.03229141f, 0.01437004f, -0.04238945f, 
    -0.01342984f, 0.01916272f, -0.00013451f, 0.00520030f, -0.03480599f, 0.00562058f, 0.02587874f, 0.03860920f, 
    -0.01254565f, -0.02329219f, -0.02003937f, -0.03325087f, 0.03161459f, -0.01545154f, 0.00055384f, -0.01037852f, 
    -0.03924971f, -0.05911204f, -0.00645321f, 0.00828775f, -0.01577395f, -0.03574392f, 0.03717888f, -0.00025623f, 
    -0.00713694f, -0.00018285f, 0.02017244f, -0.01560616f, -0.00005101f, -0.02894131f, -0.03396545f, -0.02152247f, 
    -0.02132939f, -0.03415923f, -0.04017644f, 0.00544408f, 0.00535962f, -0.03298196f, -0.03373526f, -0.05020645f, 
    -0.03671018f, 0.00069311f, 0.00330040f, 0.00786125f, 0.02963048f, -0.04402279f, 0.01471653f, 0.00271342f, 
    0.01897057f, 0.03331930f, -0.01253628f, -0.00455194f, 0.03936668f, -0.01155035f, -0.00641424f, -0.02508153f, 
    0.01372099f, -0.03081342f, -0.05532071f, 0.00686767f, -0.00027160f, 0.04609660f, -0.04172711f, -0.02047395f, 
    -0.02398555f, 0.00047823f, 0.01763852f, -0.01492412f, -0.00765862f, -0.05752989f, 0.01354599f, -0.04111240f, 
    -0.05186045f, 0.02954976f, 0.00162563f, 0.01062831f, -0.00039322f, -0.01791721f, 0.02085664f, 0.03539723f, 
    -0.04419832f, -0.00142534f, 0.02156909f, -0.02140197f, -0.05601342f, 0.04909603f, -0.04890051f, 0.01205686f, 
    0.02133502f, -0.04041215f, 0.03970397f, -0.01959143f, 0.01416577f, 0.01238120f, -0.00649021f, -0.02480610f, 
    0.03399115f, -0.02355920f, 0.04246096f, -0.02417353f, -0.05141102f, -0.02064544f, 0.00279085f, 0.01116963f, 
    -0.00248616f, -0.00512352f, 0.04665585f, -0.02632416f, 0.01149427f, -0.02960104f, -0.01760724f, 0.00711635f, 
    0.02724037f, 0.03145621f, -0.02932809f, 0.00936050f, 0.02948193f, 0.00037744f, -0.03666050f, -0.04066177f, 
    0.00218870f, -0.02114665f, -0.05426848f, -0.05656940f, 0.03938045f, 0.01259964f, 0.03064441f, 0.00274977f, 
    0.02430845f, -0.02305963f, -0.04196654f, -0.02312726f, -0.04167034f, 0.01015780f, 0.02356751f, 0.03505905f, 
    0.00155688f, 0.01170259f, -0.03046585f, 0.02127882f, 0.02234144f, 0.04155486f, 0.01978401f, -0.04850083f, 
    0.01323080f, -0.01197997f, -0.03010620f, -0.03068154f, -0.04654492f, -0.05445447f, 0.01789221f, 0.03055348f, 
    0.02419489f, 0.01535364f, -0.02442716f, 0.00542100f, -0.03221444f, -0.00323215f, 0.00733047f, -0.00687896f, 
    -0.02752249f, 0.00099746f, -0.04078314f, 0.03942654f, 0.00499921f, -0.01624750f, -0.01437704f, -0.03285459f, 
    -0.01665862f, 0.00700854f, 0.04353132f, -0.05799065f, 0.00839298f, -0.05032432f, -0.00344957f, -0.04364544f, 
    -0.01841754f, -0.02108518f, -0.00938849f, 0.01631608f, -0.02028988f, 0.01604701f, 0.04181945f, -0.03191794f, 
    0.03932587f, -0.05087798f, -0.01512668f, 0.02672266f, -0.00240047f, -0.02209132f, 0.02000902f, -0.04721884f, 
    0.01276609f, -0.03604963f, -0.00746108f, -0.01794692f, -0.00529983f, 0.03743805f, -0.03528150f, -0.04799382f, 
    -0.01156679f, 0.01138368f, -0.04160191f, -0.02972181f, 0.01988240f, -0.02959982f, 0.03465479f, 0.01437996f, 
    0.00936574f, -0.00420332f, -0.00039894f, 0.00949890f, 0.01729719f, 0.01372224f, 0.01207348f, -0.05014971f, 
    0.01946718f, -0.01848097f, -0.00145976f, 0.00863963f, -0.01919434f, 0.00306192f, -0.00068591f, 0.01057214f, 
    -0.01215028f, 0.03230127f, 0.03827740f, -0.02749689f, -0.04368156f, 0.05056822f, -0.03348495f, -0.00792115f, 
    0.05018552f, 0.00334404f, -0.00491395f, 0.03313868f, -0.04116422f, -0.04411582f, -0.01543913f, 0.02195719f, 
    -0.03138629f, -0.00279695f, 0.02439550f, -0.01769048f, 0.01607998f, 0.00895675f, 0.01699267f, -0.01185638f, 
    -0.00313972f, 0.02390884f, -0.04521996f, 0.01467936f, -0.01092671f, 0.01203544f, 0.01776061f, -0.04164657f, 
    -0.01682003f, -0.02429399f, 0.03531284f, 0.01320645f, -0.02049585f, 0.01834451f, -0.00024407f, -0.02343038f, 
    0.01964693f, -0.03039871f, -0.02037144f, 0.02477735f, -0.05426089f, 0.03765922f, -0.04708429f, -0.01704452f, 
    0.02292225f, 0.00832607f, -0.04514720f, -0.00265497f, -0.04976182f, 0.02502373f, -0.04362947f, -0.02360247f, 
    -0.03838320f, -0.00145936f, 0.04263443f, -0.01593450f, -0.04069371f, -0.05738738f, -0.00491260f, -0.02474970f, 
    0.01823536f, -0.05757365f, -0.02084171f, 0.00827380f, -0.03838322f, 0.01315567f, -0.02953691f, -0.04975984f, 
    0.04536393f, 0.01167012f, -0.03293354f, -0.00353178f, -0.05138007f, -0.04784638f, -0.03220237f, 0.02496644f, 
    -0.03455178f, 0.04088110f, -0.01954756f, -0.00351403f, 0.04230797f, 0.01616088f, -0.04097877f, 0.02706645f, 
    0.00785510f, -0.03076471f, -0.04841885f, 0.02280580f, 0.02425849f, 0.01833599f, -0.05030996f, 0.03488681f, 
    0.02534496f, 0.03329213f, -0.05656671f, -0.02984931f, -0.02126340f, 0.00181926f, -0.00242362f, 0.03319815f, 
    -0.12459207f, -0.08976445f, 0.05085745f, 0.05751962f, 0.09896063f, 0.09317663f, 0.04457582f, -0.06452425f, 
    0.10590660f, -0.09001681f, 0.07488046f, -0.01197230f, -0.01630137f, 0.11319163f, -0.00423900f, 0.01837064f, 
    0.14381795f, -0.07632135f, -0.11775385f, 0.00939866f, 0.06987218f, 0.03958136f, 0.03483966f, -0.08896427f, 
    0.15524705f, 0.06676829f, 0.21460551f, 0.16879046f, -0.06161520f, -0.04623586f, 0.03071847f, 0.03980280f, 
    0.10871784f, -0.04381755f, -0.11423267f, -0.06065300f, 0.32446265f, 0.16339613f, 0.05113119f, 0.08572371f, 
    -0.20862365f, -0.06808627f, -0.03200503f, 0.14970794f, 0.07834028f, 0.05915613f, -0.00249506f, -0.11254691f, 
    -0.28377312f, -0.21301681f, -0.11002917f, 0.21396481f, 0.11220641f, 0.09507979f, -0.04093895f, 0.02602934f, 
    0.10900185f, -0.04938079f, 0.00449588f, -0.03954846f, 0.00431556f, 0.10183864f, 0.06340681f, 0.08310928f, 
    -0.06644306f, 0.03027942f, 0.02841970f, 0.11168107f, 0.03316976f, 0.03602923f, 0.04509996f, 0.11545513f, 
    0.00829324f, -0.05123124f, -0.15781574f, 0.01816110f, 0.17501150f, 0.13125680f, 0.01895514f, -0.01201861f, 
    -0.01613054f, 0.03093133f, -0.08479553f, 0.07778764f, -0.52654064f, -0.22046734f, 0.04876469f, 0.02972826f, 
    0.09466833f, 0.15898532f, 0.06345582f, -0.03052833f, 0.04145978f, 0.10279214f, -0.01773947f, -0.09222796f, 
    0.29905877f, -0.21434876f, -0.01077815f, 0.09275921f, 0.10761175f, 0.09170279f, 0.03533570f, 0.01453257f, 
    -0.12082908f, -0.09393954f, -0.04909020f, -0.09941112f, 0.00392325f, 0.42866629f, -0.13561870f, 0.03765875f, 
    0.02148719f, 0.04352043f, 0.05246418f, -0.00140163f, 0.08792119f, 0.01003806f, -0.09565182f, -0.09115551f, 
    0.02937728f, -0.26964462f, -0.12108744f, -0.04874598f, 0.04144263f, -0.00231703f, 0.00637645f, -0.02506251f, 
    -0.00604616f, -0.00007716f, -0.06949623f, 0.03164654f, 0.33868939f, 0.10256127f, 0.10158703f, 0.10575020f, 
    -0.02732957f, -0.06025189f, 0.03599719f, 0.04067561f, -0.00667925f, 0.04257710f, -0.11618608f, -0.02021481f, 
    -0.59133130f, -0.21024951f, 0.01061043f, -0.15143161f, 0.10990123f, 0.10275736f, -0.01358039f, 0.01671813f, 
    0.09176044f, 0.08383635f, -0.06327646f, -0.03132157f, -0.03039345f, -0.07417335f, -0.17137882f, 0.24966204f, 
    0.08993568f, 0.08872604f, -0.12517773f, -0.00063077f, 0.05688576f, -0.08429499f, -0.02874967f, -0.04227181f, 
    -0.20785478f, -0.36735731f, 0.02674994f, 0.00302470f, 0.09483289f, 0.04447522f, 0.12939300f, 0.01333167f, 
    0.06953684f, 0.04430082f, 0.09533913f, 0.04015501f, 0.51550448f, 0.40064752f, -0.34121078f, -0.22520442f, 
    0.08512665f, 0.08970995f, -0.00151114f, 0.09074124f, -0.06856581f, 0.02542440f, -0.16965616f, -0.05785423f, 
    0.03831948f, 0.06254070f, -0.03173322f, -0.12322242f, 0.02247178f, 0.00170458f, 0.06170657f, 0.11665504f, 
    0.11011249f, 0.05590916f, 0.02635047f, 0.01675909f, -0.40442729f, -0.12454587f, -0.09622501f, -0.07499308f, 
    0.08333839f, 0.10504408f, 0.11091936f, 0.03043767f, 0.06997555f, -0.08074766f, -0.10277346f, -0.12090430f, 
    0.13824947f, 0.04313720f, -0.03660321f, -0.19963120f, 0.10311212f, -0.00338417f, 0.00852285f, 0.01053165f, 
    -0.03961063f, 0.06645019f, 0.00663999f, 0.04159619f, -0.31690112f, 0.07520501f, -0.25126404f, -0.16859904f, 
    0.07049141f, 0.11131643f, 0.01971105f, 0.05439720f, -0.05626761f, -0.02956926f, -0.10444067f, 0.01208824f, 
    -0.35857418f, -0.33987525f, -0.08593001f, 0.07552602f, -0.00050505f, 0.07726981f, 0.00693585f, -0.03154588f, 
    -0.05039665f, 0.07676459f, -0.00027889f, 0.01761142f, 0.37132075f, -0.02783085f, -0.11067789f, 0.05008030f, 
    -0.10469602f, -0.04128463f, -0.03876587f, 0.09345672f, -0.06311394f, -0.05495718f, 0.02472410f, 0.01724226f, 
    0.00258635f, -0.21682692f, 0.10160441f, -0.03990803f, 0.16923980f, -0.07477149f, 0.02491964f, -0.02862213f, 
    -0.04103150f, -0.05996317f, 0.03967794f, 0.12634087f, -0.08209907f, -0.14328876f, 0.21608450f, 0.03672377f, 
    -0.20232081f, -0.03708823f, 0.06167479f, 0.15324365f, 0.01526734f, -0.02344144f, -0.03816941f, -0.07655494f, 
    0.18617055f, -0.09775112f, 0.21230769f, -0.10273447f, -0.01980597f, 0.07863221f, 0.02008857f, 0.03194065f, 
    -0.08748366f, 0.16490299f, 0.00801066f, -0.02744402f, 0.26308560f, 0.30154479f, -0.07079384f, -0.13273834f, 
    -0.07809244f, -0.13168719f, 0.13554153f, 0.01598100f, -0.02564603f, -0.06738465f, -0.03762410f, -0.02876244f, 
    0.24181773f, 0.32216430f, -0.12952705f, -0.22269697f, 0.02076741f, 0.13768232f, 0.07137936f, -0.04542201f, 
    0.04202660f, 0.18027902f, 0.00784738f, 0.09073461f, 0.39800179f, 0.02064070f, 0.19506228f, 0.00133869f, 
    -0.15912297f, 0.01229503f, -0.08149747f, 0.12062412f, -0.06845617f, -0.07416432f, -0.00977362f, -0.03377021f, 
    0.03922831f, -0.11029860f, 0.03240542f, -0.08401650f, -0.06748760f, -0.03642411f, 0.09743062f, -0.02552258f, 
    -0.11893219f, 0.20209230f, 0.09817645f, 0.05727684f, 0.15369444f, 0.18983383f, 0.05016515f, 0.30248615f, 
    -0.15720251f, -0.16751239f, 0.07385032f, 0.04238951f, 0.00615120f, 0.06293425f, -0.00668971f, -0.07688198f, 
    0.63725740f, -0.05461793f, 0.00350220f, 0.06183313f, -0.08773772f, 0.08920147f, 0.00564752f, -0.01875236f, 
    0.03389744f, 0.05744482f, 0.08975711f, 0.01324765f, -0.01733597f, -0.06236036f, -0.25142020f, 0.09370778f, 
    -0.08362523f, 0.00990715f, -0.01413777f, 0.01150241f, -0.03309608f, -0.03986208f, 0.00919361f, 0.13125542f, 
    -0.12479164f, 0.17885417f, -0.13661231f, -0.21973908f, 0.06789188f, -0.00104850f, -0.07349341f, 0.09871026f, 
    -0.00953006f, -0.04024596f, 0.09770880f, -0.09148222f, -0.04731825f, 0.07250911f, -0.05939844f, 0.12147319f, 
    -0.04124571f, -0.04431791f, 0.03856921f, 0.02484844f, 0.13678765f, 0.11931553f, 0.07889827f, 0.08785710f, 
    0.15365037f, -0.10512133f, -0.02321689f, 0.06076510f, -0.10183879f, -0.06182875f, 0.09199661f, 0.08845792f, 
    -0.00298509f, -0.06847650f, -0.01019880f, -0.06108819f, 0.36761659f, 0.01358367f, 0.02967473f, 0.01531917f, 
    -0.03170536f, -0.07107717f, 0.05401754f, -0.02626676f, -0.11131074f, -0.05423978f, 0.05021086f, 0.04940472f, 
    -0.53584081f, -0.13453338f, -0.29673579f, -0.43610436f, 0.04650187f, -0.10466285f, -0.08421430f, -0.01479259f, 
    -0.03102227f, -0.04784635f, -0.01393545f, -0.13023616f, 0.31356353f, 0.03491934f, 0.12328479f, -0.18567972f, 
    0.09896214f, 0.02674216f, 0.04063756f, 0.07346746f, -0.11350226f, 0.07757384f, -0.02287631f, -0.04475801f, 
    -0.45165583f, 0.06401668f, -0.29184821f, -0.14693853f, -0.01914497f, -0.01453937f, -0.03374918f, -0.02530484f, 
    0.08407319f, 0.11776867f, 0.00809457f, 0.06345561f, -0.29659727f, -0.11373378f, -0.21788329f, -0.32010403f, 
    0.12464605f, -0.02524033f, -0.07372825f, -0.01992170f, -0.11039841f, 0.13768016f, 0.02694959f, 0.03359848f, 
    -0.15519364f, -0.11437720f, -0.03485653f, 0.03028523f, 0.00504802f, -0.01291551f, 0.04230917f, -0.05593276f, 
    0.05401978f, -0.04876880f, 0.10427415f, -0.01877672f, 0.40997976f, -0.24799395f, -0.23137176f, -0.18319120f, 
    0.04755148f, 0.06377652f, -0.00814459f, 0.04127928f, 0.03336013f, 0.07856035f, 0.06903684f, -0.10488014f, 
    -0.43429342f, -0.17615567f, -0.19208916f, -0.21072194f, 0.07088938f, -0.05327088f, -0.07242428f, -0.00807340f, 
    -0.01561426f, -0.06182412f, 0.02680525f, 0.19786514f, 0.49175537f, 0.08567262f, 0.11826641f, 0.15972508f, 
    -0.01712810f, 0.22024114f, -0.01702395f, 0.05708701f, -0.06242217f, 0.19869457f, -0.07150255f, 0.04430058f, 
    -0.19255587f, -0.12025351f, 0.02998653f, 0.12819226f, 0.19292559f, -0.06475578f, 0.07574801f, -0.08861519f, 
    -0.07213838f, 0.06308755f, -0.01951599f, 0.11258411f, -0.22147211f, -0.16152535f, 0.02077319f, -0.15062726f, 
    0.09326006f, -0.08707052f, 0.01281759f, -0.00822298f, -0.06534006f, -0.02347134f, 0.04163287f, -0.03077259f, 
    -0.38855746f, -0.18684345f, -0.01110018f, -0.12141056f, 0.18462840f, -0.01697615f, 0.19171363f, -0.05420211f, 
    0.07812686f, 0.06090896f, 0.08805412f, 0.06232120f, -0.23991844f, 0.04655912f, 0.18646383f, 0.06890390f, 
    0.06449867f, 0.00401124f, 0.04968382f, 0.04434866f, -0.11337070f, 0.05252119f, -0.03550191f, 0.01622974f, 
    0.08138297f, 0.22454856f, 0.02381886f, 0.02139487f, 0.09095623f, 0.03470419f, -0.05742105f, 0.03105239f, 
    -0.13132885f, 0.01724025f, 0.01902777f, -0.04051943f, 0.09211434f, 0.17660430f, 0.03373011f, 0.05655346f, 
    -0.03735925f, -0.01608950f, -0.04304561f, 0.05036524f, 0.06277537f, 0.06291157f, -0.03524192f, 0.02946381f, 
    0.28039062f, 0.15135705f, -0.03882611f, 0.18954803f, 0.00874942f, -0.00720381f, 0.01429794f, 0.09806041f, 
    -0.02802384f, 0.10212438f, -0.03319205f, -0.05721691f, 0.08845488f, -0.20777164f, 0.06322628f, 0.06571279f, 
    0.01213049f, -0.00106552f, -0.19086881f, -0.08558315f, 0.00753833f, -0.05772997f, 0.09044437f, -0.08394813f, 
    -0.16434725f, 0.06444299f, 0.11089411f, 0.00717284f, 0.09028670f, 0.07369997f, -0.09996627f, 0.03088238f, 
    0.00379378f, -0.06776762f, 0.00203632f, -0.03739376f, 0.34122729f, 0.09367556f, 0.04840461f, 0.16333306f, 
    -0.11651888f, 0.11791010f, 0.11400062f, -0.00820040f, -0.03710463f, 0.00949853f, -0.04562583f, 0.09674132f, 
    0.26325369f, -0.23372403f, 0.28929406f, 0.15419225f, 0.06585944f, 0.18451089f, -0.02975667f, -0.06498244f, 
    -0.00874860f, 0.03816121f, -0.02347240f, -0.00888185f, 0.14984484f, -0.07173594f, 0.01229503f, -0.01509495f, 
    0.07697615f, -0.04419756f, -0.00475678f, 0.10905772f, 0.00947679f, 0.02661972f, -0.05991081f, -0.14591429f, 
    0.54729944f, -0.13049208f, 0.11141657f, 0.06514676f, 0.02234003f, -0.06006319f, -0.02100694f, 0.06957344f, 
    -0.22845998f, 0.10603187f, 0.07656942f, 0.07616080f, 0.35757938f, 0.20696938f, 0.08300313f, 0.34515190f, 
    -0.11139442f, -0.04237473f, 0.14418018f, 0.06266342f, -0.08181757f, -0.05690505f, -0.01723128f, 0.04733044f, 
    0.18135367f, -0.12544967f, -0.02892166f, 0.08277756f, 0.00365226f, 0.09817800f, 0.05694812f, 0.06512565f, 
    -0.03846933f, 0.07304956f, -0.01410912f, 0.03733176f, 0.37022293f, 0.08666406f, 0.14385824f, -0.03082876f, 
    -0.09278631f, -0.02624318f, -0.05445661f, -0.07251050f, 0.03451880f, -0.08499496f, -0.12830792f, -0.07434539f, 
    0.24760467f, 0.05280520f, -0.12624584f, 0.13195503f, -0.00994084f, 0.11547130f, 0.07234212f, 0.04913213f, 
    -0.02289054f, 0.04669127f, -0.14678514f, 0.07999040f, 0.37893590f, 0.15865558f, 0.05168302f, 0.11686056f, 
    -0.01573531f, 0.11847190f, -0.06881177f, -0.01234569f, -0.00156297f, 0.05550761f, 0.15935357f, 0.02379845f, 
    0.31410882f, -0.20614520f, 0.08683790f, -0.02158261f, -0.13616946f, 0.13278650f, 0.07624712f, -0.01225254f, 
    -0.11190287f, 0.01034722f, 0.01984182f, -0.10892164f, 0.12853748f, 0.11060505f, 0.06616449f, 0.17654932f, 
    0.04686949f, -0.12660143f, -0.01889389f, -0.03243909f, -0.04436026f, -0.00495262f, 0.01495683f, 0.08710900f, 
    -0.04531626f, -0.01038304f, -0.03270913f, 0.02570186f, 0.01851582f, 0.00345970f, 0.00898613f, 0.04572694f, 
    -0.05076629f, -0.01624545f, 0.02915428f, 0.03703966f, -0.02715566f, -0.02726058f, 0.03927943f, -0.04924133f, 
    0.04613236f, 0.01423125f, -0.05019138f, -0.01585574f, -0.04986440f, -0.00429330f, -0.02464789f, -0.00010847f, 
    0.00816005f, -0.01957001f, 0.00546082f, 0.02428663f, 0.03672717f, -0.00944537f, 0.03546567f, -0.01103902f, 
    0.00220409f, 0.03794375f, 0.04434747f, 0.01998084f, -0.01671304f, -0.05260945f, 0.02529069f, -0.04918871f, 
    -0.00090330f, 0.01949200f, 0.01908622f, -0.05627563f, -0.03848179f, 0.01726322f, -0.01221973f, -0.04555957f, 
    0.03941798f, -0.04699209f, -0.05067149f, 0.03867454f, 0.04336311f, 0.03016723f, -0.03752710f, -0.02221685f, 
    0.00165235f, -0.03300462f, -0.04674958f, -0.00621438f, -0.02209240f, 0.02121344f, -0.02047835f, 0.00355708f, 
    -0.03346917f, 0.02289277f, -0.03420774f, 0.00675401f, 0.03426554f, -0.00179056f, -0.02875092f, 0.01642077f, 
    0.02586932f, -0.04944591f, 0.03557755f, 0.03922012f, 0.02280540f, -0.03650353f, -0.05474773f, 0.00576561f, 
    -0.05553188f, -0.03229171f, -0.03240604f, -0.04440236f, 0.02900925f, -0.01501435f, -0.03104050f, 0.02826558f, 
    0.01450769f, -0.03047412f, -0.01429664f, -0.03468141f, -0.03978125f, -0.01013508f, -0.04405236f, -0.03657971f, 
    0.03207461f, -0.02973144f, 0.02744005f, -0.04030191f, -0.05360015f, -0.01788928f, -0.02472978f, 0.03427356f, 
    -0.05528108f, 0.00773462f, 0.00252836f, -0.05529330f, -0.04789525f, -0.03377172f, -0.04136905f, -0.03021872f, 
    -0.02964162f, -0.04397380f, 0.03050390f, 0.04340913f, 0.00434660f, -0.02399214f, 0.05275701f, -0.01599609f, 
    -0.03979127f, -0.00821049f, 0.02596330f, -0.02082243f, -0.02754871f, 0.03079132f, 0.01191376f, -0.01603224f, 
    -0.00207770f, -0.04450738f, 0.03165942f, -0.01001386f, -0.05281950f, 0.02904796f, -0.03512318f, 0.01581907f, 
    0.00576001f, -0.02055374f, 0.00704267f, 0.03474031f, -0.02930128f, -0.00403208f, -0.01728389f, 0.01609846f, 
    -0.01185424f, -0.01875761f, 0.04029391f, 0.04034514f, -0.01087304f, -0.02627812f, -0.03531560f, 0.02415391f, 
    -0.01789709f, -0.05123654f, -0.02506143f, -0.05453473f, -0.04748816f, -0.01252023f, 0.00415995f, 0.01638087f, 
    0.03925434f, -0.03245249f, -0.04854852f, 0.03882106f, 0.01622928f, -0.03004709f, -0.01111070f, -0.04477576f, 
    -0.02632317f, -0.04935139f, 0.02941298f, 0.03599294f, 0.00510752f, -0.02047787f, 0.02444643f, -0.00396511f, 
    0.00904044f, 0.01538380f, -0.00375981f, -0.03933277f, -0.03353770f, 0.01497008f, -0.01240515f, -0.04243798f, 
    -0.04587482f, -0.00994853f, -0.05274520f, -0.04858296f, -0.01789921f, -0.02114858f, -0.00472445f, -0.00487030f, 
    0.01484516f, 0.05047750f, -0.05196214f, -0.00838586f, 0.00506786f, -0.01645503f, 0.04047461f, -0.00732411f, 
    -0.01728218f, -0.01826829f, 0.02050606f, 0.04408666f, -0.02626278f, 0.02864050f, -0.02756043f, -0.04664367f, 
    0.01227681f, -0.04891559f, -0.03398900f, -0.04739232f, 0.03474312f, 0.01215182f, -0.01499024f, -0.03922824f, 
    0.03601790f, -0.02894735f, 0.01016679f, 0.03072499f, -0.01890870f, 0.00844073f, -0.05623082f, 0.02419061f, 
    0.02717124f, -0.01008435f, -0.00679773f, -0.02477758f, 0.02739264f, -0.01566551f, -0.03520615f, 0.00612425f, 
    0.04177048f, -0.00890424f, 0.03086540f, 0.01548803f, -0.05626476f, 0.02819320f, 0.01608517f, 0.02068384f, 
    0.00521430f, -0.04183097f, -0.01195856f, 0.03398958f, -0.04969290f, 0.02630786f, 0.00211714f, -0.01089383f, 
    -0.00170702f, -0.04586035f, -0.05438386f, -0.05806579f, -0.01652728f, 0.01619964f, -0.00472386f, 0.00766653f, 
    0.03890417f, 0.03539932f, 0.03333371f, 0.00711544f, -0.02817902f, -0.04753416f, -0.00253067f, -0.05371568f, 
    0.02072430f, -0.03016339f, 0.00878255f, 0.04332947f, -0.04128375f, -0.01639237f, 0.01779309f, -0.04915826f, 
    0.03263806f, 0.01042716f, 0.00921565f, 0.01781033f, -0.01823064f, -0.03192365f, 0.01934255f, -0.04258509f, 
    -0.00646836f, 0.03302426f, -0.00333258f, -0.00477272f, 0.03438753f, -0.01429194f, 0.04557354f, 0.04458757f, 
    0.01029301f, 0.03358073f, 0.01112971f, -0.05043993f, 0.03484271f, 0.04013843f, -0.05113484f, -0.02280408f, 
    0.01483450f, -0.04812307f, -0.02370592f, -0.02248845f, -0.05280365f, 0.00978501f, -0.03812870f, -0.00110825f, 
    -0.00790894f, -0.05182385f, -0.01539485f, 0.03690894f, -0.00386194f, -0.00045397f, -0.04269709f, -0.00466750f, 
    -0.01678428f, 0.03778216f, -0.03933275f, -0.02457402f, 0.02832910f, 0.01380574f, -0.04493234f, 0.00567236f, 
    0.04168051f, 0.00340349f, 0.03204715f, 0.00564961f, 0.03492874f, -0.02952387f, 0.00020167f, -0.05637728f, 
    0.03512666f, 0.04221461f, -0.00783037f, 0.04307656f, -0.02977485f, 0.03696107f, -0.00930447f, 0.03005176f, 
    -0.00632018f, -0.02469540f, -0.04799040f, 0.02614587f, 0.02701554f, -0.01775702f, 0.03341467f, -0.00516040f, 
    -0.04586901f, -0.02659793f, 0.03079808f, 0.01770394f, 0.00737649f, -0.02436039f, -0.02484875f, -0.01136808f, 
    -0.05470011f, -0.03782777f, -0.00082016f, 0.00094490f, -0.01761541f, -0.01898869f, 0.00038155f, -0.01892682f, 
    0.04104313f, -0.03520399f, 0.03318773f, -0.05801279f, -0.05374238f, -0.01697233f, -0.01086569f, -0.02921994f, 
    0.03747367f, -0.04679716f, -0.00408280f, 0.03674427f, -0.02452506f, 0.02959015f, -0.00938879f, -0.02557331f, 
    0.03812382f, -0.03489782f, 0.02660678f, -0.03364716f, -0.02790241f, -0.04136077f, -0.02632339f, 0.03528006f, 
    0.03176887f, 0.00143937f, 0.02386156f, -0.01527362f, -0.00653496f, -0.02058846f, 0.00114895f, 0.04368446f, 
    -0.03114498f, 0.01581455f, 0.02558117f, -0.03938065f, -0.00720207f, -0.01538491f, 0.01772596f, -0.03812088f, 
    -0.01513267f, -0.05168436f, -0.03771523f, 0.04396277f, 0.02263444f, -0.04945282f, 0.04126478f, -0.03483969f, 
    -0.03940366f, 0.04206107f, -0.04334268f, -0.00260343f, -0.01075053f, 0.02433072f, -0.00721008f, -0.03006003f, 
    -0.05398723f, -0.02072985f, 0.00781672f, -0.04668153f, 0.04395843f, -0.03842610f, 0.02886028f, -0.05717132f, 
    0.00657425f, 0.00825316f, -0.00944833f, 0.02506134f, -0.03799756f, -0.00402346f, -0.02188968f, -0.04747624f, 
    -0.00306031f, -0.03893805f, -0.03418050f, -0.04462406f, -0.00013353f, -0.03579314f, 0.03408201f, 0.00183878f, 
    -0.02419697f, -0.00509866f, -0.05603023f, 0.00089590f, 0.01173212f, -0.03019087f, 0.02939776f, 0.01817201f, 
    0.03000991f, -0.00702897f, 0.02540135f, 0.03086062f, -0.03727606f, 0.02570903f, -0.03136864f, 0.02319735f, 
    0.00514072f, 0.01555838f, -0.05678076f, -0.02204952f, 0.02384031f, -0.01522807f, 0.02554945f, 0.00885944f, 
    -0.01941415f, -0.02999948f, 0.04120082f, -0.00483585f, -0.00127916f, -0.01949977f, -0.02067412f, -0.04602172f, 
    0.01250213f, -0.04817320f, -0.02729616f, 0.02707330f, -0.00832297f, 0.01929761f, -0.00416878f, 0.01724008f, 
    -0.03957703f, 0.00405237f, 0.03943717f, -0.01236393f, -0.03620798f, 0.02528366f, -0.02823635f, -0.04878248f, 
    -0.00182112f, -0.02374462f, 0.04767711f, 0.00764795f, -0.03195512f, -0.03264242f, 0.01772531f, 0.00407152f, 
    0.01793812f, -0.01530493f, -0.01424089f, -0.03056425f, -0.01410832f, 0.01713138f, -0.00417555f, -0.02384564f, 
    0.03367118f, 0.02723112f, 0.02245671f, -0.05174039f, -0.04912041f, -0.02970830f, 0.02667228f, -0.00580152f, 
    0.02213827f, -0.02149340f, -0.01130438f, -0.01509672f, -0.01159004f, 0.01461419f, -0.02925032f, -0.02481952f, 
    -0.00635995f, -0.00478881f, -0.03069131f, 0.03068303f, -0.05350517f, 0.00358740f, -0.02340596f, -0.04060252f, 
    -0.02813836f, -0.01257971f, 0.02229713f, -0.04139447f, -0.00229822f, -0.02887406f, -0.05683853f, -0.03252793f, 
    -0.04406724f, -0.00489878f, 0.00267188f, -0.05326123f, -0.01928384f, -0.05064249f, -0.03394631f, -0.03263523f, 
    -0.01861968f, 0.01955215f, -0.04075091f, 0.04316354f, 0.03088954f, 0.00352231f, -0.02223887f, -0.02380269f, 
    0.03522005f, -0.00747378f, -0.00356119f, 0.00157219f, 0.01384130f, -0.01566985f, 0.04284327f, 0.02027211f, 
    0.00386214f, 0.03170458f, -0.00115272f, 0.03527475f, -0.01534525f, 0.00632933f, 0.02553261f, -0.01167414f, 
    -0.05651131f, 0.00991476f, 0.04118684f, -0.05578585f, -0.00531391f, -0.02540567f, 0.01580450f, -0.05603566f, 
    -0.02097917f, -0.00755971f, -0.04007633f, 0.00878014f, -0.03138934f, -0.03077253f, 0.00881958f, -0.05210517f, 
    -0.03694992f, -0.01969827f, 0.01050153f, 0.01481702f, -0.03766742f, 0.01746555f, 0.03149528f, 0.02561582f, 
    0.00734004f, 0.01803762f, -0.01336774f, 0.04913724f, -0.04310996f, -0.04065343f, 0.02967519f, 0.02993896f, 
    0.02127334f, -0.00073097f, -0.00443260f, -0.02839746f, -0.05608616f, 0.02601030f, -0.02150504f, -0.01917455f, 
    0.01548062f, 0.01175334f, -0.04836242f, -0.04389537f, 0.02696198f, -0.02810619f, -0.03183861f, -0.02883129f, 
    -0.02342026f, -0.04771577f, -0.05339824f, 0.02363980f, -0.04794693f, -0.01690616f, -0.05176836f, -0.02376322f, 
    0.01963009f, -0.01755932f, -0.00708532f, -0.04823983f, 0.02282977f, -0.04043003f, -0.03437539f, -0.04887551f, 
    -0.04442685f, -0.02877834f, -0.04815318f, 0.03071862f, -0.05213879f, -0.04585736f, -0.03661220f, -0.03254070f, 
    0.02811889f, -0.00569325f, -0.04640653f, 0.03189650f, -0.04534521f, -0.02647653f, 0.02672186f, 0.03245980f, 
    0.01909408f, 0.03274522f, 0.01664232f, -0.05322818f, -0.00348761f, 0.00835677f, -0.03393758f, 0.01548547f, 
    -0.01488648f, -0.04545604f, -0.03844257f, -0.03739427f, 0.04026868f, -0.03608131f, 0.02452525f, -0.02628049f, 
    -0.00657108f, -0.01148878f, 0.01193151f, 0.00033331f, 0.00477840f, 0.04243413f, -0.04796395f, 0.02905202f, 
    -0.01094827f, -0.00068430f, -0.04153972f, 0.04033647f, 0.00415382f, 0.02157074f, -0.03035519f, -0.01522181f, 
    -0.05470415f, -0.05641975f, 0.00561257f, -0.01185259f, 0.04800295f, -0.04022039f, -0.04805494f, -0.00116252f, 
    0.03653342f, -0.05239790f, 0.02139932f, 0.04397089f, 0.04292170f, -0.05449622f, -0.00430354f, 0.02180466f, 
    -0.02890001f, -0.03560728f, 0.01704310f, 0.01017242f, 0.00098891f, 0.00434985f, -0.01135855f, 0.03028828f, 
    -0.03342729f, 0.02426049f, -0.01757697f, 0.02820957f, -0.01410558f, -0.02281823f, 0.01758933f, 0.01538299f, 
    0.00688071f, -0.04735253f, -0.02634087f, -0.01671543f, -0.05593859f, 0.01296345f, 0.04386984f, -0.01777017f, 
    0.04445284f, 0.04376399f, -0.04687043f, -0.03204983f, 0.02413244f, 0.01423385f, -0.01510819f, 0.03538391f, 
    -0.03774668f, -0.04560653f, -0.03812490f, 0.00044428f, -0.05657638f, -0.04439087f, -0.05069123f, -0.04048310f, 
    -0.00611671f, -0.03607960f, 0.03151444f, -0.04876941f, -0.01530383f, -0.04766934f, 0.00559089f, -0.01187211f, 
    0.04278249f, -0.00285506f, -0.04161113f, 0.03674785f, -0.03360920f, 0.00289462f, 0.01368505f, -0.04791488f, 
    -0.03205284f, -0.05227005f, -0.03881101f, -0.04361735f, -0.01430269f, -0.01588018f, -0.03484248f, -0.01623441f, 
    -0.03275634f, 0.01697541f, -0.03862780f, 0.03676602f, -0.02344909f, -0.03244898f, 0.01359511f, -0.00583469f, 
    0.01053536f, 0.05690445f, -0.08886671f, 0.07039480f, 0.16146028f, -0.02859443f, -0.08236477f, -0.06672841f, 
    0.14287187f, -0.01021947f, -0.08705635f, 0.06128083f, 0.44415677f, -0.26154631f, -0.01503790f, 0.09295174f, 
    0.01249919f, -0.03596880f, -0.06924798f, 0.17082864f, 0.04861674f, -0.05128220f, -0.00094496f, 0.02798169f, 
    0.00960598f, -0.10270261f, -0.10159449f, 0.00492200f, 0.09047991f, -0.10314534f, 0.05008576f, -0.03957789f, 
    0.12347476f, 0.04220796f, -0.01000197f, 0.19067509f, 0.01443412f, -0.41526258f, 0.01086535f, 0.13140225f, 
    -0.14441566f, -0.14588815f, 0.07542820f, 0.20328958f, -0.00823729f, -0.11227649f, 0.02804234f, -0.07974452f, 
    0.01218053f, 0.03774975f, -0.24201295f, -0.04514831f, 0.08955961f, -0.02581242f, 0.01531927f, 0.00559758f, 
    -0.02677434f, 0.00359760f, -0.00289256f, -0.20361844f, -0.23275581f, 0.31809187f, 0.18903491f, 0.17307886f, 
    -0.03103227f, 0.15858378f, 0.17849708f, -0.05541134f, 0.05591977f, -0.19442508f, -0.18032560f, -0.18179919f, 
    -0.17784590f, -0.03498293f, -0.16075934f, 0.06830918f, 0.24236035f, -0.04514607f, 0.00846482f, 0.01599110f, 
    -0.13462956f, -0.05159869f, 0.03846580f, 0.15173462f, -0.39300460f, 0.16439043f, 0.05305743f, -0.06048563f, 
    0.21183638f, 0.00624414f, -0.03781298f, -0.01311933f, 0.13170241f, 0.05936371f, -0.05119830f, 0.04021616f, 
    -0.14972481f, -0.02858439f, 0.13949554f, 0.21830848f, 0.03991894f, 0.04401350f, -0.01524382f, 0.22975712f, 
    0.04760514f, 0.00456409f, 0.07186179f, 0.29543748f, -0.00047793f, 0.20012768f, -0.07369675f, 0.00575092f, 
    0.16183116f, 0.02663490f, -0.10124404f, 0.13341665f, 0.01577841f, 0.03977022f, -0.03125697f, 0.00985234f, 
    -0.09936142f, -0.15726261f, -0.03854961f, -0.24251828f, 0.08150877f, -0.03524332f, 0.04909329f, 0.05376292f, 
    0.08091993f, 0.11839306f, 0.11679288f, -0.00116427f, -0.17664719f, -0.07679886f, -0.00489809f, -0.10310233f, 
    -0.13320185f, -0.02011253f, 0.15683527f, 0.06904462f, -0.08808672f, -0.17183068f, 0.22743572f, 0.34302625f, 
    0.04743756f, -0.10353544f, 0.09202971f, 0.05423895f, 0.01832353f, 0.10834096f, -0.11926661f, -0.06047154f, 
    0.17137231f, 0.10371640f, 0.05164121f, 0.02076036f, 0.20700732f, 0.17682752f, -0.03988681f, -0.02250820f, 
    0.12881264f, -0.01967006f, -0.03980136f, 0.19579919f, 0.11423847f, 0.06195614f, 0.04277057f, 0.02461451f, 
    -0.08822936f, 0.17861545f, -0.01060435f, -0.05762973f, 0.03063361f, 0.08223873f, 0.04139961f, 0.04462527f, 
    0.07977897f, -0.13196248f, 0.06557500f, -0.21607170f, 0.39994067f, -0.05114422f, -0.19697239f, -0.20389500f, 
    -0.03586045f, 0.04390594f, -0.10481305f, 0.08411778f, 0.18184438f, 0.12872681f, 0.00326893f, 0.28665426f, 
    0.16763581f, -0.00210591f, -0.03939950f, 0.01915820f, -0.02704053f, -0.06520856f, 0.05236595f, -0.03074779f, 
    0.07412810f, -0.21966694f, -0.14017954f, 0.15440713f, -0.38201806f, 0.04227941f, -0.11464725f, 0.20263252f, 
    -0.06007339f, 0.07109787f, 0.17959517f, -0.10687143f, 0.12101408f, -0.03929246f, 0.06553204f, 0.07914842f, 
    0.09909575f, 0.04292728f, -0.15609024f, -0.24211220f, 0.09823795f, 0.04186971f, -0.04799826f, 0.10856207f, 
    0.15575136f, -0.16740440f, -0.11942202f, -0.04301362f, 0.04992343f, -0.03625750f, 0.20384002f, -0.20364636f, 
    0.01100845f, 0.01991982f, 0.28744355f, 0.27337080f, -0.04085068f, 0.17865205f, 0.01837063f, 0.21946624f, 
    -0.13664170f, -0.13010365f, -0.03430543f, 0.17817296f, 0.13023429f, 0.13957272f, -0.04275987f, -0.08675218f, 
    0.11254068f, 0.30803257f, -0.05569860f, 0.00964303f, 0.07330979f, -0.12496223f, 0.11745420f, 0.00974474f, 
    -0.18074322f, -0.06672948f, 0.00304212f, 0.00940105f, 0.01740702f, -0.09095671f, -0.05809142f, 0.05073481f, 
    -0.15828493f, 0.12806375f, -0.15861985f, -0.15662953f, -0.28003556f, -0.31696635f, -0.06221007f, -0.09294013f, 
    -0.11089142f, 0.01718600f, 0.08425928f, 0.02584767f, -0.43266180f, 0.13798995f, -0.04163190f, 0.45872584f, 
    -0.01523343f, 0.13211513f, -0.04392701f, 0.15903465f, 0.00314289f, -0.01901172f, 0.30945182f, 0.06430845f, 
    0.11034554f, -0.00712372f, 0.11685148f, -0.26858595f, 0.28322142f, -0.05365643f, 0.15647441f, -0.00636567f, 
    -0.09059574f, 0.11888533f, -0.12298802f, -0.06884309f, 0.25549507f, 0.11679855f, -0.14095572f, -0.25802144f, 
    -0.04860034f, -0.10444734f, -0.04199217f, -0.01699424f, 0.17340575f, -0.00876192f, 0.05579375f, 0.15703307f, 
    0.01644921f, 0.06042024f, -0.02212200f, -0.12894249f, -0.06754760f, 0.08222570f, 0.11422410f, -0.05784398f, 
    -0.01571210f, 0.07994784f, 0.03413442f, 0.11747629f, -0.05290943f, 0.04607709f, 0.18944836f, -0.04537961f, 
    0.17100345f, 0.10714018f, -0.01690840f, 0.00579487f, 0.08752164f, 0.20089102f, 0.10898835f, 0.06990240f, 
    -0.06647308f, 0.01241868f, 0.06058561f, 0.00843737f, 0.07335254f, -0.12829278f, 0.16589274f, -0.06005901f, 
    0.04352106f, -0.35998645f, -0.01461354f, -0.16953374f, -0.17237017f, -0.19222629f, 0.02685631f, 0.13247068f, 
    -0.22171219f, -0.07091442f, 0.05283703f, -0.05398314f, -0.12759522f, 0.06035891f, -0.13704936f, 0.02631770f, 
    0.05543672f, 0.21420868f, -0.00759915f, 0.12509862f, -0.11255534f, 0.02729539f, 0.05278410f, -0.02755742f, 
    0.02567317f, -0.04551957f, -0.13319005f, -0.12606734f, 0.20639871f, -0.14663154f, 0.10245372f, -0.25008467f, 
    0.09196557f, 0.05590062f, -0.06827899f, 0.02954502f, 0.05162187f, 0.00068608f, -0.01580835f, 0.10412461f, 
    -0.04283893f, 0.02766988f, 0.02736370f, -0.03440374f, -0.05230622f, -0.05060150f, -0.01829187f, -0.01564638f, 
    0.02909290f, 0.04158567f, 0.02252531f, -0.02937887f, -0.02184114f, -0.04475027f, 0.03625753f, -0.03909233f, 
    -0.05707771f, -0.02137243f, 0.04484422f, -0.04411266f, -0.04705590f, 0.01399428f, 0.00755410f, 0.02523575f, 
    -0.05676852f, -0.00860435f, -0.03299439f, 0.01472515f, -0.02295081f, 0.04321521f, 0.00671294f, -0.02946058f, 
    0.03894424f, -0.02436031f, 0.03215588f, -0.05390793f, -0.00198844f, -0.02861086f, -0.03584457f, -0.04829960f, 
    0.04279193f, -0.04495329f, 0.02877133f, 0.03308318f, 0.02997052f, -0.05325516f, 0.01145607f, 0.01741398f, 
    0.03421443f, 0.03662778f, -0.04637084f, 0.00217386f, 0.04320140f, -0.05019349f, 0.03253371f, 0.01134349f, 
    -0.04894754f, -0.02100587f, -0.02710478f, -0.00883785f, -0.01002623f, 0.00866049f, 0.00769484f, 0.02808745f, 
    -0.00469870f, 0.05079525f, -0.01914696f, -0.01568670f, 0.03758565f, -0.02167941f, 0.01865502f, -0.00596586f, 
    -0.02454912f, -0.00642292f, 0.03737234f, -0.00488818f, -0.01263427f, 0.01650435f, -0.04437004f, -0.04731481f, 
    -0.05720488f, 0.03621854f, 0.01535685f, -0.02721901f, 0.02754431f, -0.02443441f, -0.01586903f, 0.02324597f, 
    0.01179033f, -0.06572561f, 0.03432446f, 0.00327772f, -0.01998394f, -0.05243010f, 0.02905519f, 0.02880801f, 
    0.03886161f, 0.01614616f, -0.04391223f, -0.00264173f, -0.00893424f, -0.03992592f, -0.01402358f, -0.02341418f, 
    0.03475669f, -0.04115340f, -0.02506843f, -0.03961717f, 0.01165207f, -0.01958633f, -0.04253982f, -0.00460933f, 
    -0.00728997f, 0.01788486f, -0.03891905f, -0.00471945f, -0.01537663f, 0.00823332f, -0.00616379f, -0.00149104f, 
    -0.02647153f, -0.00878056f, -0.02859073f, 0.02435946f, 0.02146465f, -0.04163381f, -0.03713057f, -0.03737980f, 
    -0.01949348f, -0.02564472f, -0.01800519f, -0.04821700f, -0.04250485f, 0.02654567f, 0.00048058f, -0.01134839f, 
    0.02619868f, 0.03369907f, 0.00507802f, -0.00639909f, -0.04991126f, -0.02041296f, 0.00524060f, -0.01568942f, 
    -0.02143297f, -0.05335470f, -0.03790589f, -0.04872600f, 0.00619444f, 0.03715855f, 0.01694033f, -0.04294255f, 
    0.01376725f, -0.02991073f, -0.03389862f, 0.00361862f, 0.02772666f, 0.02831511f, -0.04933482f, -0.01872788f, 
    -0.04806674f, -0.00008832f, 0.00849018f, -0.00542627f, 0.00372872f, -0.03518775f, -0.05226411f, 0.01413565f, 
    0.05202796f, -0.04773147f, 0.02308505f, -0.05022644f, 0.03835394f, -0.00781264f, 0.03955399f, 0.03198727f, 
    0.01655117f, 0.02697203f, -0.04483017f, 0.03998767f, -0.06136730f, 0.02561759f, -0.05846264f, -0.03182637f, 
    0.00823008f, -0.00146697f, -0.03178182f, -0.03081821f, 0.02037427f, 0.00259862f, 0.03111311f, -0.03904250f, 
    -0.01072430f, -0.03610158f, -0.02550191f, 0.01153377f, -0.02874289f, -0.02969032f, 0.03766830f, -0.01491522f, 
    0.03621727f, 0.00164877f, 0.01881260f, 0.01104289f, 0.00202996f, -0.00192039f, -0.00648764f, -0.02427256f, 
    0.03638037f, -0.03290934f, -0.04372284f, 0.03003690f, 0.02475112f, 0.01673883f, 0.01568540f, -0.05283039f, 
    0.00703557f, -0.01501653f, -0.03958687f, 0.00339487f, 0.01323440f, -0.00885090f, 0.00825865f, 0.01581507f, 
    -0.04154592f, 0.02974832f, 0.01060916f, 0.00563818f, 0.02552569f, -0.02215805f, 0.00318097f, 0.02226005f, 
    -0.04102251f, -0.00062426f, 0.04306847f, 0.00743832f, -0.04339297f, -0.00566974f, -0.05017987f, 0.01203837f, 
    -0.01606735f, -0.01148820f, 0.01306190f, 0.01866817f, -0.02540461f, -0.02558975f, -0.01527997f, 0.02026211f, 
    -0.03136726f, -0.04036731f, -0.01188700f, -0.05426139f, 0.03835239f, 0.00351724f, -0.06262099f, -0.04935905f, 
    -0.01650202f, 0.00349991f, -0.01429518f, -0.00197372f, -0.05065125f, 0.00318259f, -0.03818800f, 0.02086310f, 
    -0.00720466f, -0.00424454f, -0.05104233f, 0.01552503f, -0.05574045f, -0.03739401f, -0.01998196f, 0.04586314f, 
    0.04561862f, -0.00520414f, 0.01209871f, 0.00168376f, 0.01297799f, -0.00149597f, 0.00772947f, 0.02326724f, 
    0.04461458f, 0.02222686f, 0.00763356f, -0.00051391f, -0.00530032f, -0.04584415f, 0.00048456f, -0.00867311f, 
    -0.05923192f, -0.04783182f, -0.04133377f, -0.02348740f, 0.03381921f, -0.00028635f, 0.00628122f, -0.01240084f, 
    0.01541002f, -0.05182100f, -0.00972706f, -0.01409489f, -0.03941834f, -0.05037041f, -0.01407491f, 0.01955529f, 
    -0.02792512f, 0.02574287f, 0.04451440f, 0.01254662f, -0.03830411f, -0.00582910f, 0.02174021f, -0.00434111f, 
    0.01698991f, -0.01987299f, 0.03809038f, -0.05074344f, -0.05536700f, 0.01605010f, -0.01133186f, -0.00884740f, 
    0.02755946f, 0.01750607f, -0.04293558f, -0.01204244f, 0.02826534f, 0.02308423f, -0.00067292f, 0.03937735f, 
    0.04840134f, -0.02669561f, -0.00104008f, -0.03802297f, 0.01287860f, 0.01553229f, -0.04124082f, -0.04777815f, 
    -0.00600541f, -0.04289304f, -0.03151104f, -0.04544575f, 0.00416540f, 0.00895890f, 0.01214949f, 0.01412779f, 
    0.02314155f, 0.02204465f, 0.01493809f, -0.04994649f, -0.04088294f, 0.03952519f, 0.03492693f, 0.01165812f, 
    -0.05423051f, -0.00883654f, -0.04878398f, -0.03419907f, -0.01386378f, -0.04276229f, 0.00330886f, -0.03505761f, 
    -0.03021398f, 0.00632920f, -0.04926495f, 0.04181658f, 0.00061613f, -0.01855221f, -0.05105960f, -0.02936470f, 
    0.03738066f, -0.03503284f, -0.04768997f, -0.04321213f, -0.02627704f, -0.04192486f, 0.02023016f, -0.05894570f, 
    -0.02924680f, 0.01823550f, 0.01922675f, 0.01617762f, 0.01521636f, 0.01880047f, -0.03270989f, -0.01702461f, 
    0.00553760f, 0.03520396f, -0.02246165f, -0.01778597f, -0.00249011f, 0.00206674f, -0.05263616f, 0.00992482f, 
    -0.01083483f, -0.03118143f, -0.02595038f, -0.00602498f, 0.01640947f, -0.05289605f, 0.00693814f, -0.05395352f, 
    -0.03089702f, -0.05949172f, 0.01314041f, -0.04972025f, 0.02272369f, 0.02743199f, -0.04585461f, -0.03958011f, 
    0.01748515f, -0.01997720f, 0.02581185f, -0.00314291f, -0.04669522f, -0.05378587f, 0.02921247f, 0.03184641f, 
    0.00913306f, -0.02869069f, -0.04305141f, 0.01994755f, 0.00844922f, -0.00916401f, -0.03098092f, -0.03631506f, 
    -0.05011570f, 0.02888221f, 0.02080359f, -0.01269288f, 0.02001977f, 0.02426018f, -0.01064733f, 0.02168448f, 
    0.02896751f, -0.01620642f, -0.03600898f, 0.01214653f, -0.01901776f, -0.00458239f, 0.02212784f, -0.06083582f, 
    -0.01959359f, -0.04395781f, -0.02283764f, 0.03329889f, -0.06130346f, -0.05698290f, -0.03810308f, -0.02034527f, 
    -0.01691107f, -0.01652682f, 0.03396044f, -0.04373746f, 0.03696883f, -0.01797899f, -0.02755849f, -0.04272639f, 
    -0.01907993f, -0.02543234f, -0.01091018f, 0.00496449f, -0.03090324f, -0.01954702f, -0.05026954f, 0.03939377f, 
    -0.05796134f, 0.03669269f, 0.03457369f, 0.03243387f, -0.00162927f, -0.02902222f, -0.01653198f, 0.01304869f, 
    -0.01114769f, 0.01347939f, 0.01537411f, 0.03856437f, -0.05420992f, -0.04244319f, 0.03821513f, -0.00937092f, 
    0.04010744f, -0.05952917f, 0.02898899f, 0.00632885f, 0.00622511f, -0.02594517f, -0.03076946f, 0.02257582f, 
    -0.00661030f, 0.03489537f, -0.02606251f, -0.00724118f, 0.00636044f, -0.01856223f, -0.05135453f, 0.03675833f, 
    -0.00501817f, -0.01334088f, 0.00937861f, 0.02604745f, 0.00675265f, 0.03028955f, -0.02835636f, 0.00096921f, 
    0.01896187f, 0.00118828f, 0.03464253f, 0.00137000f, -0.00747587f, 0.01650331f, 0.00308365f, -0.01296999f, 
    0.01819762f, -0.04247992f, -0.05077019f, -0.05174171f, -0.01317363f, -0.03500447f, -0.03201032f, 0.03326787f, 
    -0.04721088f, 0.01941392f, -0.03702373f, -0.05047211f, -0.01507007f, -0.00532962f, -0.03751167f, 0.02350459f, 
    -0.04170697f, -0.01175927f, -0.04212758f, -0.05611287f, 0.03334890f, 0.02515444f, -0.01877642f, 0.01170242f, 
    -0.01868294f, 0.00190820f, -0.01615591f, -0.04723240f, -0.04663315f, -0.05249224f, 0.00958433f, 0.01841770f, 
    0.00598979f, -0.01194748f, 0.02898316f, -0.04447035f, 0.03475720f, -0.04224114f, -0.00340467f, -0.04285134f, 
    0.01165652f, 0.02849876f, 0.03588347f, 0.00790050f, 0.01738985f, -0.03739531f, -0.03526995f, 0.00605941f, 
    -0.04142505f, -0.02475411f, -0.02113451f, -0.01268695f, -0.04554277f, -0.01921374f, -0.06073206f, 0.03178519f, 
    0.03779215f, 0.00275701f, 0.03863294f, 0.03988320f, -0.01455123f, 0.01094233f, -0.05346085f, 0.01056457f, 
    0.02606830f, -0.04665131f, -0.00832755f, 0.02982545f, -0.00140281f, 0.02589056f, 0.03878472f, -0.05199260f, 
    0.00280468f, 0.01978015f, 0.01986483f, -0.03509361f, 0.00924186f, 0.00667720f, -0.03007874f, -0.01840875f, 
    -0.02112452f, -0.05272420f, -0.04091388f, 0.01782616f, -0.03698972f, 0.01547990f, -0.00902078f, -0.03692692f, 
    -0.00975987f, -0.03235391f, 0.01453961f, -0.01010810f, -0.01287772f, -0.05252470f, -0.02218425f, -0.02816729f, 
    0.01198226f, -0.02908147f, 0.02875101f, 0.01984012f, 0.03205530f, 0.02116835f, -0.01247553f, -0.03247317f, 
    -0.02067602f, -0.03993035f, 0.02728183f, 0.02105571f, -0.03242020f, 0.03938174f, 0.00517502f, -0.04441035f, 
    0.01255829f, 0.02761747f, 0.01760542f, -0.01658215f, -0.03990873f, -0.00545570f, 0.01797760f, -0.01991586f, 
    0.02004854f, 0.02290833f, 0.00572708f, 0.00665347f, -0.00773817f, -0.00486867f, 0.02304711f, -0.02436876f, 
    -0.03301235f, -0.05880548f, 0.03979160f, -0.00998663f, -0.00647885f, -0.04703344f, -0.01404354f, 0.00524966f, 
    0.00868172f, -0.04359882f, -0.05155626f, -0.02753438f, -0.01628000f, -0.02485473f, 0.04083746f, -0.01225966f, 
    -0.03353293f, -0.04125192f, 0.01052493f, 0.01921937f, -0.04960561f, -0.03946603f, -0.03554837f, -0.04263647f, 
    -0.02075592f, -0.01765341f, -0.03661022f, -0.01000281f, 0.00579916f, 0.02126316f, 0.02671953f, 0.00596737f, 
    -0.01639223f, -0.01286830f, -0.00430479f, 0.01068590f, 0.02870719f, 0.02756119f, 0.03671688f, -0.04364033f, 
    -0.04425830f, 0.03357113f, -0.02081683f, -0.05301851f, -0.02788142f, -0.00999482f, -0.01228608f, -0.01250319f, 
    0.01848945f, 0.01024848f, -0.03409908f, -0.00190791f, -0.01534979f, -0.05033682f, -0.02534200f, 0.03714891f, 
    -0.05846177f, -0.01672973f, -0.01912047f, -0.02775752f, -0.03903223f, 0.03595437f, -0.01734228f, -0.01636811f, 
    -0.04033960f, -0.02368964f, -0.00732817f, 0.01499828f, 0.02400855f, 0.02256156f, -0.04967614f, 0.03938720f, 
    -0.03818552f, 0.02457538f, 0.00686064f, -0.05034707f, -0.01323483f, -0.01403540f, -0.05103064f, -0.04720875f, 
    0.01437932f, 0.00878645f, 0.02254403f, -0.03654093f, -0.01996289f, 0.02562052f, 0.01015874f, -0.05306841f, 
    -0.05654626f, 0.00183524f, 0.02863543f, 0.01365779f, 0.02619334f, 0.03081014f, -0.05573536f, -0.01266874f, 
    0.00646279f, 0.00648113f, -0.00427295f, -0.03331315f, -0.02343482f, 0.00411614f, 0.02251641f, 0.02690558f, 
    0.00412168f, -0.05479576f, -0.02324837f, 0.01033772f, -0.00574072f, 0.01346488f, -0.04585326f, -0.00338828f, 
    -0.04962240f, 0.04240032f, -0.03900832f, 0.03473705f, -0.05561507f, -0.05817595f, -0.02729326f, -0.00938158f, 
    0.01271415f, -0.05157286f, 0.03414904f, 0.03136358f, -0.05513134f, 0.02596574f, 0.01240580f, -0.02584885f, 
    -0.03650133f, -0.14723995f, 0.16638780f, 0.08288939f, -0.12124178f, 0.01033078f, 0.00353719f, -0.08925992f, 
    0.02659748f, 0.01353347f, -0.01737956f, -0.04187264f, 0.39808157f, -0.01606585f, 0.02697843f, 0.10354450f, 
    -0.03406776f, -0.06177483f, -0.03695894f, -0.01936522f, 0.03836869f, 0.05757507f, 0.08601540f, 0.01660717f, 
    0.41147304f, -0.17533673f, 0.08983929f, 0.16413146f, -0.15439968f, 0.09816845f, 0.09188685f, -0.08827797f, 
    0.06447672f, -0.00462157f, -0.08838821f, -0.14043823f, 0.12218533f, -0.18856880f, 0.03022312f, 0.15250483f, 
    -0.05314543f, 0.08049347f, -0.06124058f, 0.01590656f, 0.04270707f, 0.15135248f, 0.01031658f, -0.07285004f, 
    0.02494958f, -0.09035522f, 0.09662214f, 0.22904569f, -0.00757197f, 0.05649011f, -0.07586360f, -0.05341317f, 
    -0.05680709f, 0.09458172f, -0.02752905f, 0.05956601f, -0.12060166f, -0.08552807f, 0.22956140f, 0.05670303f, 
    0.09826516f, 0.04282067f, 0.08745703f, 0.05805954f, -0.07227494f, -0.14336129f, -0.08525972f, -0.08069823f, 
    -0.20548837f, 0.06666259f, 0.06309600f, 0.09040868f, -0.06885257f, -0.18805021f, -0.02771950f, 0.05803569f, 
    -0.16478577f, 0.00790272f, 0.08818748f, 0.18439059f, -0.00608551f, 0.13379405f, -0.24852362f, -0.10717383f, 
    -0.02352727f, -0.02430913f, -0.01062108f, 0.00674860f, 0.05561139f, 0.04288626f, -0.02598253f, 0.04015776f, 
    0.48143411f, -0.28395435f, 0.16872671f, 0.09848707f, -0.16704039f, 0.19555078f, -0.09211652f, -0.07985333f, 
    -0.05710858f, -0.04075422f, 0.08610298f, -0.00212112f, 0.04328262f, 0.01347667f, 0.02230269f, -0.05466846f, 
    0.18463543f, 0.13904268f, 0.09711079f, 0.02349547f, 0.01337384f, -0.03072987f, -0.05504419f, 0.00228860f, 
    -0.05896747f, 0.04238145f, -0.16968229f, 0.07440705f, -0.11020377f, -0.08009613f, 0.06248024f, -0.00909312f, 
    -0.11140095f, -0.05165994f, 0.05828040f, 0.02790589f, 0.19996147f, 0.08140680f, 0.30134043f, -0.06312342f, 
    -0.02738447f, 0.07607413f, 0.03758583f, -0.06065582f, 0.05090410f, -0.05787508f, -0.00251211f, 0.14519042f, 
    -0.17826691f, -0.00884245f, -0.38787204f, 0.07880727f, -0.01790262f, 0.00836374f, -0.12414064f, 0.17857240f, 
    -0.05075121f, -0.06872562f, -0.05094641f, -0.05194082f, 0.25477839f, -0.06323562f, -0.21489307f, 0.03906627f, 
    0.24526037f, -0.03907172f, 0.10769305f, 0.04639513f, -0.02055834f, -0.01651616f, 0.12114102f, -0.05111090f, 
    0.01398648f, -0.16642979f, -0.06244239f, 0.21756044f, -0.20472619f, -0.11132529f, 0.01270380f, 0.07764149f, 
    -0.07347324f, 0.07743312f, 0.02493393f, 0.05893430f, 0.03113928f, 0.07710820f, -0.02241479f, -0.01728379f, 
    0.07128796f, -0.03170207f, 0.01622081f, -0.01352018f, 0.02148755f, 0.16266283f, -0.02742241f, -0.05094717f, 
    0.14919873f, -0.04293299f, 0.00542523f, -0.09562565f, -0.08168025f, -0.04230490f, 0.09340908f, -0.00441995f, 
    -0.04569277f, -0.00870704f, -0.00426450f, 0.01012992f, 0.03515798f, -0.02980707f, -0.16113365f, -0.08832084f, 
    -0.06377556f, -0.07696776f, 0.10902793f, 0.06459570f, -0.12264935f, 0.08787940f, -0.03951958f, 0.05421882f, 
    0.22033118f, -0.02508277f, -0.04025047f, -0.01166157f, 0.12490478f, -0.04777188f, -0.02882237f, -0.03607346f, 
    0.12159955f, 0.00038486f, -0.09077659f, -0.05833704f, 0.01808728f, 0.10573170f, 0.05787933f, 0.03791799f, 
    0.09859896f, 0.03536467f, 0.10489188f, -0.06902514f, -0.07935257f, -0.10092349f, -0.04293464f, 0.00371358f, 
    -0.05656929f, 0.10576396f, -0.18533978f, 0.11031244f, 0.03730802f, 0.02473843f, -0.10555328f, 0.06482754f, 
    -0.00789098f, 0.17860799f, 0.01488941f, 0.05376732f, 0.43205571f, -0.01515789f, 0.02936518f, -0.15899265f, 
    0.00266233f, 0.10165036f, 0.04777938f, -0.07894978f, -0.06293806f, 0.00856047f, -0.04204804f, -0.02173000f, 
    -0.14794557f, -0.05874591f, 0.17095882f, -0.20892823f, -0.10374684f, -0.00267237f, 0.05508225f, -0.04132964f, 
    -0.05639553f, 0.02692672f, -0.12718888f, 0.15156625f, 0.05785676f, -0.31606174f, -0.14606817f, -0.10635808f, 
    -0.11861274f, 0.05966752f, 0.05927822f, 0.10698573f, -0.05477007f, -0.00290842f, -0.02851008f, 0.12188710f, 
    0.86746442f, -0.36823684f, 0.28929701f, 0.19635941f, -0.17192349f, 0.11611579f, 0.04414494f, -0.00262532f, 
    0.08612244f, 0.09919067f, 0.07640329f, -0.02707356f, 0.33230963f, 0.16731392f, 0.06280871f, -0.06826683f, 
    -0.20910487f, -0.06342158f, 0.04905596f, -0.17564121f, -0.06315940f, -0.03152521f, 0.02041723f, -0.09287468f, 
    -0.13964786f, 0.23006305f, -0.05237227f, -0.31615624f, 0.07696419f, 0.12064558f, -0.06886648f, 0.03449298f, 
    -0.03040982f, 0.01021884f, 0.02894829f, 0.04921436f, 0.48923409f, -0.10502184f, 0.03296988f, -0.04172579f, 
    -0.09426312f, 0.02489434f, 0.00531964f, 0.01071504f, -0.10304549f, -0.04453290f, 0.09140817f, 0.16364090f, 
    0.11333488f, -0.06469569f, -0.06320282f, -0.07173546f, -0.11091059f, -0.07359792f, -0.07211240f, 0.16282181f, 
    0.04223082f, -0.04796056f, -0.06734624f, -0.03349901f, 0.13011613f, 0.27816203f, 0.04696885f, -0.15698594f, 
    -0.04641391f, -0.05922889f, 0.00470435f, -0.13846397f, -0.02523979f, 0.08737835f, -0.02035340f, 0.10359713f, 
    0.23128663f, -0.04766405f, 0.16698866f, 0.06763623f, -0.19791123f, 0.06227203f, 0.05821438f, 0.01108880f, 
    -0.00217427f, -0.07021669f, 0.11341513f, 0.09755173f, 0.11732185f, -0.08968205f, -0.08988912f, 0.19962698f, 
    0.06775544f, -0.10418008f, 0.01954539f, -0.04342808f, 0.08650236f, 0.06721140f, 0.08039437f, 0.08892634f, 
    -0.14653717f, 0.15490921f, 0.02669895f, -0.08580604f, 0.05265535f, -0.06775083f, 0.04350974f, -0.00166979f, 
    -0.07920161f, -0.05906779f, -0.00240755f, -0.01150319f, -0.42326221f, -0.09482159f, -0.23069632f, 0.02869315f, 
    0.10252682f, 0.07766050f, 0.00715462f, -0.08102295f, 0.04737432f, 0.00941209f, -0.01331198f, 0.04897282f, 
    -0.02663872f, 0.31439036f, -0.22467284f, 0.10210513f, 0.08217649f, 0.10382074f, 0.03617386f, 0.00221484f, 
    0.07261735f, -0.02935478f, 0.01364922f, -0.01872968f, 0.08043948f, 0.28103960f, -0.22605842f, 0.05857759f, 
    0.06785246f, -0.04877202f, 0.05956494f, -0.06089865f, 0.07692989f, 0.02509474f, 0.05387720f, 0.05856440f, 
    0.02280015f, 0.16721512f, 0.01388633f, 0.38853508f, 0.06443845f, -0.03329385f, 0.00801518f, 0.10793796f, 
    0.08561271f, -0.09458291f, 0.05691088f, -0.08701824f, -0.20239295f, -0.07224923f, 0.10347837f, 0.08708886f, 
    -0.05844796f, -0.10762774f, -0.08102444f, 0.08335821f, 0.05411959f, 0.06203509f, 0.10020315f, 0.23040189f, 
    0.16070826f, 0.10213312f, -0.18719600f, 0.22375347f, 0.00525728f, 0.07931173f, -0.05510336f, -0.02169507f, 
    0.05039247f, 0.03156171f, 0.00346002f, -0.02246583f, -0.29458496f, -0.28085363f, 0.08334001f, 0.22990350f, 
    0.01130278f, 0.10334530f, 0.01179916f, 0.02415804f, 0.14872660f, -0.09261303f, 0.08865296f, -0.02965556f, 
    -0.08658889f, 0.27416182f, -0.04495564f, 0.18969965f, 0.09065757f, -0.08699208f, -0.02483536f, -0.08880546f, 
    -0.01017121f, 0.05002367f, 0.04545816f, -0.04330329f, -0.44367379f, 0.19970085f, 0.06390530f, -0.27743223f, 
    -0.03424168f, 0.03124058f, 0.02607504f, -0.07608842f, -0.05607536f, 0.01386883f, 0.05159434f, 0.02065644f, 
    0.41839951f, -0.15908153f, 0.03156189f, 0.41933841f, 0.01813480f, -0.01430440f, -0.00137151f, -0.04942092f, 
    0.07942142f, -0.02088570f, 0.00837710f, 0.07843498f, -0.06002429f, -0.12146937f, -0.00442812f, -0.11293625f, 
    0.04369179f, -0.09794229f, -0.05866105f, 0.11558930f, 0.01462680f, 0.28275156f, -0.13632289f, -0.04685715f, 
    0.38494596f, 0.15889682f, 0.09284732f, -0.23846535f, 0.08005477f, 0.18305932f, -0.03196519f, 0.00931365f, 
    -0.07343718f, 0.00843436f, 0.08540959f, 0.14578626f, -0.23248503f, -0.03570917f, 0.08786500f, 0.06128571f, 
    -0.02417163f, 0.06268821f, 0.00449216f, 0.02913394f, 0.03018296f, -0.07571254f, 0.16992490f, -0.03462533f, 
    0.22139716f, 0.25543121f, 0.17846738f, -0.10390227f, 0.13664281f, 0.04300827f, -0.04065170f, -0.05468154f, 
    -0.11471759f, -0.04392320f, 0.11560875f, 0.03631415f, 0.06327906f, 0.09830042f, -0.10268424f, -0.13759002f, 
    -0.00917369f, -0.08759317f, 0.02552282f, 0.10784370f, -0.01766253f, 0.02841818f, 0.16526280f, -0.07422244f, 
    0.01640560f, 0.23720506f, 0.15015961f, 0.04361299f, 0.09795519f, 0.13968259f, 0.02978096f, 0.15443514f, 
    0.06114282f, 0.06662434f, 0.06806197f, -0.04655908f, -0.04550497f, 0.10349515f, 0.19579038f, -0.15634960f, 
    0.05422616f, 0.11690761f, -0.04913358f, 0.15799242f, 0.03380785f, 0.00633937f, 0.06478107f, 0.01542415f, 
    -0.02483165f, 0.04463680f, 0.00706632f, -0.31681067f, 0.01685138f, 0.13411266f, 0.02886853f, 0.12327819f, 
    0.08107162f, 0.16696201f, 0.11189851f, 0.05973364f, -0.05111253f, -0.02958576f, -0.07051269f, 0.15688734f, 
    0.09362391f, -0.01605341f, -0.07146730f, 0.04158698f, -0.08257811f, 0.03245048f, 0.08916450f, -0.01409758f, 
    0.19445843f, 0.03549169f, -0.11831650f, -0.13590874f, -0.00895104f, -0.05420928f, 0.08022524f, -0.02041462f, 
    -0.02621023f, -0.14052764f, 0.09120204f, 0.07616197f, -0.10504664f, -0.03856621f, -0.05796604f, 0.18589579f, 
    0.01524074f, -0.11419129f, 0.04579522f, 0.10980565f, 0.00498507f, 0.05018457f, 0.09445646f, 0.06618223f, 
    0.10974817f, -0.23432001f, 0.04211798f, 0.04114835f, 0.07215453f, 0.04210117f, 0.08478133f, 0.19572262f, 
    -0.00838179f, -0.05928018f, -0.05259490f, 0.09870405f, 0.29813147f, 0.14713609f, 0.22088462f, -0.08445755f, 
    -0.09131203f, 0.05453216f, -0.18449345f, 0.01994379f, -0.02819272f, -0.08900040f, -0.05671528f, 0.03710166f, 
    -0.71538317f, 0.10592970f, -0.18724708f, 0.14673725f, 0.00499358f, -0.03422521f, 0.03367759f, 0.00500791f, 
    0.04683227f, -0.06909512f, -0.01062534f, 0.08637259f, -0.19552501f, 0.00068412f, -0.06851957f, 0.08308332f, 
    0.00927785f, -0.11345007f, 0.01493121f, 0.16758245f, -0.09049558f, 0.07119054f, 0.09226550f, -0.04296529f, 
    0.14746732f, -0.10939114f, -0.01640346f, 0.03305112f, 0.06708052f, -0.06082798f, 0.08266998f, 0.14330821f, 
    0.08598977f, 0.06359493f, 0.00661182f, 0.09877716f, -0.06842930f, -0.02517369f, -0.10054900f, 0.11207451f, 
    -0.04281903f, 0.07088847f, -0.03418022f, 0.05694989f, -0.04973100f, 0.06382804f, 0.05962008f, -0.01397005f, 
    0.05901357f, 0.08598854f, -0.08577006f, -0.00886107f, 0.15908009f, 0.02146067f, 0.03346103f, -0.13279311f, 
    -0.04240271f, 0.16749197f, -0.01985855f, 0.12255381f, 0.01801540f, -0.26205117f, 0.02289081f, -0.02593782f, 
    -0.02071569f, -0.04108553f, 0.07783183f, 0.12128866f, 0.07193574f, 0.06219290f, -0.00377538f, -0.07537859f, 
    -0.01832577f, -0.10155524f, -0.11251754f, 0.04392610f, -0.00957842f, -0.00803799f, -0.03367692f, 0.04706656f, 
    0.17615840f, 0.02352075f, 0.07498103f, -0.02205597f, -0.19316547f, 0.10314454f, -0.03941887f, 0.05858364f, 
    -0.05524713f, -0.04209805f, 0.03529688f, 0.06775178f, -0.17550455f, -0.05698797f, -0.01257773f, 0.15950498f, 
    0.06401125f, 0.05338090f, -0.00316127f, -0.07427933f, -0.03756203f, -0.04775257f, -0.06627617f, -0.04825365f, 
    0.00563333f, -0.00312263f, 0.05181987f, -0.05156121f, 0.68758744f, -0.00976041f, 0.02569740f, 0.07228758f, 
    -0.09481463f, 0.05292950f, -0.11376975f, 0.03840868f, -0.02188557f, 0.19240001f, 0.01715527f, 0.03497779f, 
    0.14955360f, 0.15383986f, -0.16655312f, 0.17057121f, -0.00971698f, -0.08287907f, 0.07885506f, -0.04093813f, 
    0.08420292f, 0.10924029f, 0.00396329f, -0.12388381f, 0.42322165f, 0.06797882f, 0.19631721f, 0.18281141f, 
    0.02814029f, -0.03268647f, -0.05766551f, 0.17518896f, -0.05634004f, 0.03777944f, 0.00516186f, -0.04676336f, 
    -0.06090746f, 0.17273329f, -0.15810831f, -0.01359610f, 0.05299262f, -0.12440909f, -0.05580420f, 0.01897972f, 
    -0.11829842f, 0.18263783f, -0.12784213f, -0.17298137f, 0.01495391f, -0.19540608f, -0.09940067f, 0.04642726f, 
    -0.04211678f, -0.02105613f, -0.01595946f, 0.16973917f, -0.03841422f, -0.08020103f, -0.12857881f, -0.01138230f, 
    0.30900007f, 0.21120261f, 0.05055142f, 0.16379406f, 0.01079658f, 0.08960769f, 0.04406333f, 0.01145095f, 
    -0.06623097f, 0.10378274f, -0.02308204f, 0.04936842f, 0.37402150f, 0.11193778f, -0.12558413f, -0.02890425f, 
    0.03301943f, -0.07640091f, -0.04018085f, 0.03457030f, 0.08526161f, 0.02985013f, -0.12286858f, -0.08340385f, 
    -0.02166563f, 0.05304044f, 0.02445185f, 0.28075200f, 0.09226625f, 0.02049226f, -0.00933721f, 0.12250571f, 
    -0.00816010f, 0.12966745f, -0.02563839f, 0.00315073f, 0.23828426f, -0.06838762f, -0.32854709f, -0.30738792f, 
    0.03210583f, 0.08559310f, 0.03288401f, -0.03577520f, 0.06789742f, -0.04108880f, 0.07385635f, -0.03044104f, 
    0.04082273f, 0.05524146f, -0.11378546f, 0.18754148f, 0.05801046f, 0.07290079f, 0.03710592f, 0.00367659f, 
    0.03857901f, 0.05031832f, -0.04076155f, 0.08503611f, 0.23682658f, 0.04226052f, 0.02856355f, -0.00588618f, 
    -0.16477574f, 0.07111466f, 0.00543932f, 0.03597683f, 0.08085085f, 0.16561963f, -0.05295685f, -0.05478396f, 
    0.15135801f, 0.00611048f, 0.20030753f, -0.32455802f, -0.00790656f, 0.07799963f, 0.10938950f, -0.11999997f, 
    -0.01456700f, -0.08046040f, 0.01953786f, 0.09471940f, -0.15516371f, -0.02282927f, -0.22571765f, -0.12290412f, 
    -0.07508387f, -0.11422706f, -0.03543629f, -0.03174732f, 0.04918560f, -0.06860377f, -0.07905070f, 0.02975611f, 
    0.12889539f, -0.22204764f, 0.31118041f, 0.11621211f, 0.08317748f, -0.02236197f, -0.00298627f, 0.17021556f, 
    -0.04410968f, 0.04143316f, 0.09171942f, -0.11530996f, -0.61061805f, -0.08771189f, -0.16633087f, 0.05306175f, 
    0.01302436f, 0.20130087f, 0.02618591f, -0.04458033f, 0.02103867f, 0.03260153f, 0.09357083f, -0.03030836f, 
    -0.07395137f, 0.03118876f, 0.01470318f, -0.29589599f, 0.09543453f, 0.05850374f, 0.07142961f, -0.03813095f, 
    -0.03778360f, 0.04413022f, -0.08509228f, 0.01979160f, -0.21677716f, 0.25096464f, 0.07676153f, -0.18667740f, 
    -0.01580472f, -0.05449659f, 0.00462778f, 0.06680142f, 0.00831649f, -0.00309992f, -0.08179335f, 0.09241479f, 
    -0.16730462f, 0.13433486f, -0.16279207f, -0.33915713f, 0.06363852f, 0.11868895f, 0.04691383f, -0.05068348f, 
    -0.02656757f, 0.14092420f, -0.16518858f, -0.13254748f, -0.07609204f, 0.04271581f, -0.19321080f, 0.18283205f, 
    -0.19094813f, 0.00063131f, -0.01930524f, -0.02877416f, 0.01581530f, -0.00102743f, 0.03659831f, 0.01504577f, 
    0.08806971f, 0.17346153f, 0.17555293f, -0.18027207f, 0.00573273f, -0.03643114f, 0.00723118f, -0.03619681f, 
    0.02513705f, 0.13145186f, -0.00440070f, -0.03721394f, 0.36376998f, -0.09396701f, -0.04192381f, 0.08918010f, 
    0.03278955f, 0.00531948f, 0.09841752f, 0.17924966f, -0.05036985f, -0.11047229f, -0.08284762f, 0.08583281f, 
    -0.19310212f, 0.01900835f, -0.08954364f, -0.07517018f, -0.04977691f, 0.13348137f, -0.00676725f, 0.04677859f, 
    0.03298974f, 0.06996606f, 0.11947665f, 0.21288954f, 0.10672881f, 0.11179809f, 0.20358595f, -0.04420549f, 
    -0.02659841f, 0.03675278f, 0.13388905f, 0.10653622f, -0.15199295f, -0.03996049f, 0.03322483f, -0.09995348f, 
    0.28442153f, -0.11443342f, -0.24128303f, 0.36064824f, 0.05952495f, -0.06685937f, 0.07107577f, -0.10278716f, 
    -0.00964255f, 0.02327263f, 0.08190992f, 0.04372701f, -0.19619519f, -0.08611802f, 0.14499943f, -0.13813967f, 
    -0.02709317f, 0.06624790f, 0.01195443f, 0.03630139f, 0.09319813f, -0.09588119f, -0.02169470f, -0.32140142f, 
    -0.14466915f, -0.17188951f, -0.19026525f, -0.39216599f, 0.00306570f, 0.14008939f, 0.08393092f, -0.08498966f, 
    0.03222201f, -0.10414274f, 0.03198332f, -0.05724308f, 0.09197160f, 0.06764414f, 0.06585782f, 0.02383557f, 
    0.08294541f, -0.14262027f, -0.03051135f, 0.15824358f, 0.00308328f, 0.00202434f, -0.10115387f, -0.12645780f, 
    0.04386514f, 0.00911167f, -0.01185695f, 0.05643348f, -0.04847223f, 0.05832103f, 0.10303632f, 0.10458218f, 
    -0.06989426f, 0.05425291f, -0.14871837f, -0.06371038f, 0.72062898f, 0.12213861f, 0.15853894f, 0.01052652f, 
    0.03404034f, -0.07454227f, -0.10911637f, 0.08688964f, 0.02753715f, 0.18160857f, 0.04523904f, 0.08726144f, 
    0.31568617f, -0.09705235f, -0.09286504f, 0.10445527f, 0.03577105f, 0.12828022f, -0.08644035f, -0.07933183f, 
    -0.04640050f, -0.07260913f, 0.09259654f, -0.01361198f, -0.03733898f, 0.10703850f, -0.08279692f, 0.23369458f, 
    0.04204395f, 0.05313797f, 0.00544485f, -0.09042644f, -0.05702211f, -0.04087254f, -0.01088742f, 0.02851054f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02373437f, -0.01870583f, -0.04553516f, 0.10304761f, 0.10856841f, 0.03265395f, 0.02345036f, 0.07042708f, 
    -0.04186082f, 0.00653207f, 0.00513408f, -0.05079506f, -0.04066438f, 0.12283468f, 0.00128077f, 0.03855366f, 
    0.04532719f, 0.00125044f, -0.02970545f, 0.02862992f, -0.02981053f, -0.05935332f, 0.10587440f, 0.03996736f, 
    0.03011790f, -0.03051705f, 0.09484760f, -0.04154145f, 0.00870410f, 0.00988216f, 0.11747132f, 0.00622300f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.13563773f, -0.64918596f, 0.03613778f, -0.11025617f, -0.24771389f, 0.24294986f, 0.06546166f, -0.16699128f, 
    -0.18083917f, 0.39998153f, 0.14604719f, -0.04037877f, -0.10151327f, -0.53676784f, 0.16045906f, 0.16121100f, 
    0.14745553f, -0.04085025f, 0.01992341f, -0.15307580f, 0.12101788f, -0.09049439f, -0.46118769f, -0.91123617f, 
    0.06425768f, -0.12847692f, -0.23237802f, 0.05325649f, -0.05400874f, 0.07297347f, -0.08529672f, 0.39377809f, 
    -0.11764459f, -0.39524046f, 0.20454180f, 0.32632583f, 0.15218313f, -0.27498522f, 0.08316686f, 0.11106093f, 
    0.00147986f, 0.17530014f, 0.12242151f, 0.05002822f, 0.02775273f, 0.37439975f, -0.48652133f, 0.01331110f, 
    -0.21445538f, -0.09859346f, 0.16407828f, -0.06349858f, 0.03655076f, -0.06263233f, -0.07694204f, 0.12406948f, 
    0.00152086f, -0.11490285f, -0.58352572f, 0.09067833f, -0.08620235f, 0.17403284f, 0.20507671f, 0.14435557f, 
    -0.08034825f, 0.19488613f, 0.12803279f, 0.34547925f, -0.53816831f, -0.47286257f, -0.11713581f, -0.01842709f, 
    -0.17861818f, -0.11781335f, -0.02670687f, -0.16491362f, 0.03250308f, -0.53907192f, 0.09008873f, 0.07453298f, 
    -0.42983040f, 0.27470499f, -0.07641565f, 0.00416998f, 0.10686147f, -0.17383984f, 0.26107392f, 0.06060465f, 
    -0.13009408f, -0.07398167f, 0.10509831f, -0.01301865f, 0.06192834f, 0.09322076f, -0.42025751f, 0.41776651f, 
    0.13486487f, -0.08716886f, -0.58423382f, -0.22277986f, -0.16165480f, 0.14401631f, 0.05746448f, -0.42659852f, 
    -0.16719541f, 0.11872210f, -0.07211400f, -0.04995168f, 0.09616835f, 0.32559407f, 0.15928012f, 0.08502474f, 
    -0.15809304f, 0.39227909f, 0.13574447f, -0.11281054f, -0.14253981f, 0.09469534f, 0.28971821f, -0.11181293f, 
    -0.08379280f, 0.02469848f, 0.27884713f, -0.12234952f, -0.02352369f, 0.34552902f, 0.01159356f, -0.83689594f, 
    -0.09495619f, 0.23213142f, -0.47810850f, -0.02713436f, -0.07993640f, 0.12502249f, 0.15318085f, -0.06729025f, 
    0.07302539f, 0.04391441f, -0.08536690f, -0.05624981f, 0.10513281f, 0.12797624f, 0.16378327f, -0.00131145f, 
    -0.04548520f, -0.49907076f, -0.15084365f, -0.13708739f, 0.30841151f, -0.01608713f, 0.02389419f, -0.65134603f, 
    0.10189349f, 0.13474658f, 0.28770357f, 0.15675849f, -0.00106563f, -0.52383214f, 0.22367284f, -0.30648148f, 
    -0.16920602f, -0.20241630f, -0.06050387f, 0.31674042f, -0.29047450f, 0.02746168f, -0.15579505f, 0.40007490f, 
    -0.10786152f, 0.05284923f, -0.04738504f, 0.07793508f, -0.12585935f, -0.10401304f, -0.06395801f, -0.00333670f, 
    0.46063906f, 0.20059282f, 0.02971994f, -0.14213510f, -0.10476348f, 0.16280165f, -0.65828162f, -0.14086743f, 
    0.03392703f, -0.00850382f, -0.55607373f, -0.04119672f, -0.01926593f, -0.51559114f, 0.01038581f, -0.55855352f, 
    0.12447599f, 0.00206295f, 0.30538553f, 0.16661339f, -0.23474844f, -0.06798314f, -0.17148837f, 0.14666720f, 
    -0.11292991f, -0.70627564f, 0.06137083f, -0.04881028f, -0.01844758f, -0.17507459f, -0.21625850f, 0.17504407f, 
    0.32175845f, -0.01707147f, -0.11366665f, 0.03351935f, 0.28587204f, 0.03812249f, -0.38193366f, -0.06383676f, 
    -0.13648695f, 0.00907054f, 0.52721637f, -0.08944181f, -0.14055087f, 0.34211293f, -0.48008251f, -0.28828830f, 
    0.01700435f, 0.45625845f, -0.06171134f, -0.27546555f, -0.32507876f, 0.13147944f, 0.03887975f, -0.14763933f, 
    0.15292120f, -0.36696419f, -0.01182935f, 0.03728930f, -0.10279128f, -0.27791727f, 0.22170655f, 0.03865943f, 
    -0.01319635f, -0.51814473f, -0.12166483f, -0.03382099f, 0.25729078f, 0.17094976f, -0.04539042f, 0.37902284f, 
    0.09183685f, 0.16574672f, -0.56089157f, -0.10248367f, 0.07647028f, 0.17908970f, -0.39124128f, -0.08010846f, 
    0.03583121f, 0.53179145f, 0.20939569f, -0.27290455f, -0.06639937f, -0.38739204f, -0.17323752f, 0.20783164f, 
    -0.05094571f, 0.25085875f, 0.06554577f, 0.02162130f, 0.08784776f, -0.43962991f, -0.62196887f, 0.13664706f, 
    -0.10718691f, 0.05259586f, -0.09531080f, 0.00067362f, -0.21247619f, 0.11138305f, -0.05525950f, -0.21016297f, 
    -0.10573249f, 0.13968530f, 0.14265122f, -0.06720483f, -0.08150192f, 0.07687200f, 0.18232539f, 0.15096930f, 
    -0.11122361f, -0.27661738f, 0.42744035f, -0.10132264f, -0.69287050f, 0.07039586f, 0.13187689f, 0.15910280f, 
    -0.02785182f, -0.74898398f, 0.05774336f, 0.14961854f, 0.06951047f, 0.14021274f, 0.32965189f, 0.13417700f, 
    -0.26243815f, -0.54493403f, -0.05673656f, -0.12123489f, 0.00600048f, 0.02305434f, -0.42994973f, 0.28679553f, 
    -0.13631548f, -0.16156675f, 0.15626656f, -0.01532311f, -0.02477403f, -0.58692038f, 0.33716977f, 0.32636616f, 
    0.14847484f, -0.21267037f, -0.71617639f, 0.02448487f, 0.47912726f, -0.25049299f, -0.06117763f, 0.22023638f, 
    -0.04177072f, 0.23072310f, -0.07225173f, 0.06889877f, 0.02746786f, -0.14744009f, 0.06382188f, -0.15159369f, 
    -0.09190804f, -0.46743312f, 0.12028179f, 0.10053056f, -0.38201892f, 0.16902412f, 0.41278890f, 0.50409281f, 
    -0.02861961f, 0.10123218f, -0.06990158f, -0.09965200f, 0.02270849f, -0.00690059f, -0.12724788f, 0.13716853f, 
    -0.09917054f, 0.36815685f, 0.24884051f, 0.10954479f, 0.47169149f, -0.13238719f, -0.15483724f, -0.20159549f, 
    0.01172176f, -0.18033631f, -0.09669326f, 0.10894088f, -0.06029197f, 0.38999197f, 0.09494586f, -0.04849650f, 
    0.07184662f, 0.47828555f, 0.09399280f, 0.06058421f, -0.57603735f, 0.02335682f, -0.25372687f, -0.27485579f, 
    -0.04954321f, 0.08298012f, 0.12137828f, 0.16867381f, -0.14864732f, -0.29684269f, -0.30642611f, 0.05832435f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12232202f, 0.11180587f, -0.18625632f, -0.12930588f, 0.06085302f, 0.21151017f, -0.14354323f, -0.23631123f, 
    -0.24761827f, -0.11029871f, 0.18043119f, -0.22496416f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
