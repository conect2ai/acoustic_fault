#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.16282463f, 0.68563926f, 0.21467216f, -0.69219857f, -0.10182609f, -0.27588111f, -0.07669237f, 0.18430722f, 
    1.05918467f, -0.29074165f, -0.43894637f, -0.83028084f, -0.77770525f, -1.29789281f, -1.11667275f, 0.09420089f, 
    -0.84733748f, 0.03711218f, 0.70480698f, 0.63946527f, 0.51939553f, 0.71419770f, 0.47325826f, 0.35475606f, 
    -0.12699039f, 0.36109754f, 0.28806186f, 0.24048957f, -0.09130286f, -0.56087857f, -0.29105940f, -0.36416453f, 
    -0.01913371f, 0.50522387f, -0.97189087f, -0.89430439f, -1.24349320f, -0.89142758f, -0.72193629f, 0.42681336f, 
    0.08046205f, 0.45093527f, -0.67650890f, 0.11110629f, -0.89353138f, -0.52558345f, 1.25787616f, 0.34881809f, 
    -0.85746628f, -0.26432443f, 0.77781141f, 0.34945488f, -0.75379014f, -0.45185837f, 0.36919835f, 0.11516090f, 
    0.18997692f, 1.05494010f, 0.92559993f, 1.15149903f, -0.19271219f, 0.30723244f, -0.45760226f, -0.88340288f, 
    -1.08222771f, -0.60372257f, 2.03115082f, 0.28014252f, -0.32013580f, -0.28557187f, -0.41069251f, -0.13564174f, 
    -0.54705381f, -0.75305992f, -0.75278771f, 1.12175047f, -0.68908936f, 1.30961013f, 0.28372386f, 0.05827910f, 
    0.49741000f, 0.84060305f, 0.56630123f, 0.23793407f, -1.30905390f, -1.09483850f, -1.01477385f, 0.78319579f, 
    0.58114153f, -0.16163822f, -1.24895310f, 0.01419136f, -0.17021230f, -1.55008137f, 0.60271353f, -1.36411643f, 
    -0.44123197f, -0.48746639f, -0.61790866f, 1.04273319f, 0.56045628f, 0.66742867f, -0.06557206f, 0.05552896f, 
    -0.29567614f, 0.08201709f, -0.55455691f, -0.49865863f, 0.16123495f, 1.25055754f, -0.75573879f, 0.44325355f, 
    0.58203536f, 0.57089305f, -0.08414862f, 0.18946847f, 0.34932908f, 0.07556813f, 0.00639211f, -0.25972340f, 
    0.48753166f, -0.15539101f, 0.10638789f, 0.35069606f, 0.80147773f, 0.85702270f, -1.59787750f, -0.62807810f, 
    -0.81407923f, 0.04970783f, -0.45394176f, -0.20620316f, 0.50277323f, 0.74095500f, 0.35395467f, 1.54607260f, 
    -1.27997363f, 1.14575493f, 0.31402615f, 0.10166567f, 0.13855848f, 0.32462403f, 0.14898129f, 0.03721522f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.82245916f, -0.55352521f, -0.56951630f, 0.79024833f, -0.21522021f, 0.10448604f, 0.45907709f, -0.22351933f, 
    0.61251092f, 0.54961354f, -0.34553823f, 0.78587598f, 0.24815351f, 0.43025061f, 1.03766870f, 0.42452243f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.74379396f, -0.20219846f, 0.18358172f, 0.03503669f, 0.06385180f, 0.00617652f, 0.11445634f, 0.14231499f, 
    0.11751780f, -0.12400009f, 0.31459594f, -0.43784535f, -0.24612188f, -0.02793676f, -0.22097223f, 0.09626611f, 
    -0.08245768f, 0.08810554f, -0.07609457f, -0.11288663f, -0.00889232f, -0.27096412f, -0.26697248f, -0.21483926f, 
    -0.05288980f, -0.07601017f, -0.00394562f, 0.32510072f, 0.18452655f, -0.30053556f, 0.19290698f, 0.31842202f, 
    0.26945412f, 0.38811299f, -0.00850198f, 0.54831094f, -0.19948521f, -0.19265258f, 0.25728872f, -0.13646248f, 
    0.27276370f, -0.11945962f, -0.09774691f, -0.18389159f, -0.23646517f, -0.09249251f, -0.43406767f, -0.31857890f, 
    -0.01206514f, 0.05065366f, -0.09574983f, 0.16037266f, -0.04155092f, 0.22130330f, -0.25137910f, -0.13042334f, 
    -0.11053421f, 0.04131850f, -0.12596948f, -0.11856297f, -0.04614565f, 0.08733411f, 0.21337755f, -0.80403453f, 
    -0.25948071f, 0.25266632f, -0.28983539f, -0.04134115f, -0.00452079f, 0.01078892f, 0.02110161f, 0.10801034f, 
    -0.45210597f, 0.19760326f, 0.32258511f, 0.07762538f, 0.05335159f, 0.05196467f, -0.02306185f, -0.00748046f, 
    -0.13574579f, 0.29273596f, -0.50095117f, -0.74947113f, -0.19580103f, 0.23055878f, -0.14124848f, 0.13441962f, 
    0.22423896f, 0.14738664f, -0.49286315f, -0.33327639f, 0.02681335f, 0.03936851f, -0.02936168f, 0.11083852f, 
    -0.04321359f, 0.05759069f, 0.09794230f, 0.39405438f, 0.04885000f, 0.00104146f, 0.15303376f, 0.08334224f, 
    -0.13623101f, 0.02659294f, -0.00929265f, 0.20377168f, 0.10548967f, 0.10110477f, -0.01179002f, 0.01357349f, 
    0.05434411f, -0.00642530f, 0.09913969f, 0.01966019f, 0.03603094f, -0.08981185f, 0.10907770f, -0.10314784f, 
    -0.07691769f, -0.11998276f, 0.03114118f, 0.29044184f, 0.15630934f, 0.26026016f, -0.62702751f, 0.26283336f, 
    0.18954003f, 0.11177367f, 0.10002337f, -0.02828544f, 0.25657651f, 0.06295069f, 0.00741695f, 0.58809334f, 
    0.43224978f, 0.13193935f, -0.14546394f, -0.17758815f, 0.48918650f, 0.09313724f, -0.30528882f, 0.14156443f, 
    0.51804847f, -0.36991432f, -0.19386691f, 0.22312272f, 0.13280334f, 0.25203681f, 0.30809134f, 0.14135799f, 
    -0.05022414f, -0.00870251f, -0.12029165f, -0.72555202f, -0.07040568f, -0.23792736f, -0.15885082f, -0.09447090f, 
    0.13515486f, -0.03715344f, -0.14779325f, 0.05052349f, 0.07094341f, -0.13217770f, -0.28799173f, -0.37260500f, 
    0.03272372f, 0.03443154f, -0.08075783f, -0.32232457f, -0.31936270f, -0.09194746f, 0.08025710f, 0.06087461f, 
    0.13676462f, 0.16236274f, 0.32010317f, 0.57817912f, 0.39552698f, -0.28365177f, -0.20988061f, 0.02065909f, 
    0.01211476f, 0.07424431f, 0.13313380f, -0.07351927f, 0.37429452f, -0.60439801f, -0.35274655f, -0.32239175f, 
    -0.27750647f, 0.04642349f, -0.16265784f, 0.10499933f, 0.22627015f, 0.36290848f, 0.03764086f, 0.30785918f, 
    0.08416221f, -0.24502860f, -0.08009655f, -0.15472752f, 0.09237479f, 0.14577970f, 0.28243011f, -0.24863228f, 
    -0.62723720f, -0.00085406f, -0.17176794f, -0.16373320f, -0.07148089f, -0.04185073f, 0.09753640f, 0.15345462f, 
    0.05270814f, 0.38318166f, -0.04148612f, -0.06936358f, -0.01730121f, 0.07578003f, -0.02629671f, -0.03991361f, 
    -0.14794217f, 0.52160066f, -0.43127301f, -0.96655244f, 0.01572168f, 0.06664537f, 0.29637986f, 0.11424559f, 
    -0.01773853f, -0.20374443f, -0.55235058f, 0.00289749f, -1.48168755f, -0.06963380f, -0.01360040f, -0.21270511f, 
    -0.12134926f, -0.15185730f, 0.10828646f, 0.21215181f, -0.40953988f, -0.02997193f, 0.14578342f, 0.31902307f, 
    -0.02109303f, 0.05422607f, -0.02643147f, 0.45587850f, 0.09057909f, 0.03516998f, -0.01942142f, -0.25111333f, 
    -0.35227233f, 0.01111335f, 0.00977312f, -0.12284089f, -0.16295604f, 0.03689149f, 0.17362218f, -0.15109053f, 
    0.02013424f, -0.03164633f, -0.04145943f, 0.00871261f, 0.00374870f, 0.05353602f, -0.49551010f, 0.44627577f, 
    0.64188188f, -0.09287293f, -0.05671997f, -0.00677493f, 0.14742438f, 0.12199158f, -0.08243133f, 0.42302689f, 
    -0.31395003f, -0.20435102f, 0.20114084f, 0.00804870f, 0.23704988f, 0.27741525f, 0.02179095f, 0.05143616f, 
    -0.02926814f, -0.21839301f, 0.39974570f, -0.03906154f, 0.19581787f, -0.16549288f, 0.26945499f, 0.02531282f, 
    0.22730348f, 0.15776639f, -0.09680077f, -0.66955447f, 0.14264323f, 0.00604337f, -0.06203615f, 0.11858015f, 
    0.20983279f, 0.00351618f, -0.06639507f, -0.12260567f, 0.14193244f, 0.14501391f, 0.01137915f, -0.23722900f, 
    -0.22764532f, -0.28654239f, -0.12896134f, -0.16534589f, 0.39710420f, -0.37088042f, -0.05706361f, 0.02177144f, 
    0.14016825f, -0.21666250f, 0.01500146f, -0.18618664f, -0.05883425f, -0.06275355f, -0.05724682f, -0.30766857f, 
    -0.23361762f, -0.37216631f, -0.19035801f, -0.47400025f, -0.24780880f, 0.05552911f, -0.29114971f, 0.11455578f, 
    0.12385019f, -0.15479358f, 0.11973649f, -0.15273240f, -0.10523526f, -0.32099563f, -0.19534852f, -0.09486201f, 
    0.01595028f, 0.19918798f, 0.24590136f, 0.12233247f, -0.01776663f, -0.16887911f, -0.15619612f, -0.13859937f, 
    0.02228310f, -0.23922192f, -0.07745983f, -0.03227716f, 0.03782115f, -0.15507337f, -0.38262030f, -0.08253584f, 
    0.03536142f, -0.11990771f, -0.25301772f, 0.05654749f, 0.01920350f, 0.15304774f, 0.18660933f, 0.23554087f, 
    0.14695564f, 0.07199559f, -0.37801316f, 0.12855843f, 0.30182570f, 0.05172386f, 0.29797676f, 0.35646495f, 
    0.37871656f, 0.14241706f, -0.12347101f, 0.16169885f, 0.51822639f, 0.13020727f, -0.09739805f, 0.10281622f, 
    0.02423079f, -0.14281870f, 0.12968390f, -0.25031754f, -0.09324875f, 0.28425118f, 0.13217594f, -0.05640509f, 
    0.11994730f, -0.19626905f, -0.16323002f, -0.01428983f, -0.14349459f, 0.02292527f, 0.15629572f, 0.38087958f, 
    0.34886917f, -0.08858440f, 0.09733630f, -0.02790383f, 0.04462341f, 0.01763313f, -0.14513017f, 0.06335796f, 
    0.07217172f, -0.07722124f, -0.20794451f, 0.43145409f, 0.19701093f, 0.30910158f, 0.06441427f, 0.17811249f, 
    0.07456449f, -0.15334438f, -0.08424882f, -0.18460557f, 0.25886026f, 0.13676572f, 0.07890346f, 0.29245418f, 
    0.26322758f, 0.22808902f, 0.18349966f, -0.01648689f, -0.13707797f, -0.06509293f, 0.19999340f, 0.01176570f, 
    0.18001902f, 0.04377136f, -0.18472266f, -0.01466806f, 0.04833795f, -0.01859235f, -0.16126394f, -0.24802111f, 
    -0.28800887f, 0.82250178f, 0.92216086f, 0.75072986f, -0.01894461f, -0.02032647f, -0.28603035f, 0.08255441f, 
    -0.14075842f, 0.05720234f, 0.48253611f, 0.24851426f, 0.23125537f, 0.06736907f, 0.07772411f, 0.07446690f, 
    0.24977876f, 0.24130234f, 0.03411383f, -0.03523759f, -0.10107137f, 0.00324555f, -0.02256688f, 0.01759789f, 
    -0.06769077f, 0.01129063f, 0.07919613f, 0.12509948f, -0.47570240f, -0.07364687f, 0.10224531f, 0.22836617f, 
    0.14058493f, 0.08379919f, -0.10355695f, -0.04938114f, 0.13948475f, -0.10454609f, -0.22986931f, 0.08843553f, 
    0.24598035f, -0.37176087f, -0.11277184f, 0.09568757f, 0.21495467f, 0.25728792f, 0.42400548f, -0.15452513f, 
    0.01194102f, -0.34420186f, -0.29680994f, -0.13208374f, 0.16297784f, 0.13687098f, 0.20825887f, -0.68733740f, 
    -0.08877858f, 0.29917449f, 0.18461780f, 0.33693552f, 0.03694852f, 0.04468168f, 0.16603298f, 0.20394748f, 
    -0.04494816f, 0.27239177f, 0.29396957f, 0.04985089f, -0.08006811f, -0.01554281f, -0.01471051f, 0.08123036f, 
    0.09360091f, 0.27214456f, 0.06142069f, -0.18736929f, -0.00976351f, -0.00567582f, -0.20321189f, 0.02401692f, 
    -0.16325086f, -0.09837025f, 0.06580709f, -0.17579581f, 0.23022865f, 0.00635555f, -0.12289919f, -0.13647030f, 
    -0.07648162f, -0.23136175f, 0.17720219f, 0.46906033f, 0.16031668f, 0.02639165f, 0.25266576f, -0.10278397f, 
    -0.00638905f, 0.16158874f, -0.12494066f, 0.26047382f, 0.34152147f, -0.19254220f, -0.25184804f, -0.58457917f, 
    -0.37867573f, -0.21146965f, -0.06649130f, 0.00695813f, -0.12988557f, 0.17772651f, -0.05224236f, 0.03159956f, 
    -0.10169417f, -0.01585720f, 0.01988596f, -0.06879181f, -0.22751252f, -0.28096175f, 0.12329119f, 0.33344293f, 
    0.24083546f, 0.26945895f, 0.03659105f, -0.03015584f, 0.03600250f, -0.09304530f, -0.02245272f, -0.00820508f, 
    0.19505575f, -0.07312981f, -0.08103833f, 0.06092026f, 0.14885844f, -0.12914561f, -0.09217164f, -0.03883236f, 
    -0.16532399f, 0.20851144f, 0.02019211f, 0.08982465f, 0.04513090f, -0.16321261f, -0.06887481f, 0.08156665f, 
    0.27078730f, -0.62872797f, -0.48321021f, -0.25180683f, -0.26423690f, 0.17051649f, -0.36565667f, 0.04825532f, 
    -0.10123957f, 0.15668818f, 0.00891098f, 0.00658479f, -0.02842279f, -0.16092384f, -0.03873508f, 0.06249940f, 
    -0.00667229f, 0.02955764f, 0.19698717f, -0.31281659f, -0.03299945f, 0.55579001f, 0.02164202f, 0.14082593f, 
    -0.19122835f, -0.01034015f, 0.29909721f, 0.53280443f, 0.62699068f, -0.26011205f, 0.24996598f, -0.15589474f, 
    0.05235360f, 0.05889594f, -0.12837018f, -0.08562175f, 0.18990591f, 0.14459722f, -0.05298328f, 0.34317580f, 
    0.13357131f, -0.22048613f, -0.00055062f, 0.04935200f, 0.05434884f, -0.06505769f, -0.09223949f, -0.05122853f, 
    0.01224747f, -0.29618347f, -0.08363215f, 0.08214551f, 0.08418252f, -0.01740186f, 0.08898336f, -0.32634729f, 
    -0.46768251f, 0.48569721f, -0.02544970f, 0.15782239f, -0.03953014f, 0.07784984f, -0.01631150f, 0.03073220f, 
    -0.06173420f, 0.02555148f, 0.17570688f, 0.06938394f, -0.14467642f, 0.12471092f, 0.03221375f, 0.04700562f, 
    0.03747664f, -0.79412472f, -0.46491796f, -0.26559332f, 0.01832218f, 0.25412947f, -0.35281760f, 0.16635200f, 
    0.13361320f, 0.09822337f, -0.10794117f, -0.65335929f, -0.20135935f, -0.16116668f, -0.15337116f, -0.34676623f, 
    0.12738714f, 0.03035718f, -0.10757666f, -0.02886885f, 0.07010377f, 0.34253201f, 0.05968116f, 0.06171433f, 
    -0.17990802f, 0.18216124f, -0.10378335f, 0.09707754f, 0.25410721f, -0.05596882f, -0.36471507f, -0.40066424f, 
    -0.43431103f, 0.09592299f, 0.01575788f, 0.22737350f, 0.13856851f, -0.00623502f, -0.02714093f, -0.12153541f, 
    -0.22062430f, -0.03634164f, 0.04502781f, 0.07335973f, 0.12160370f, -0.01215082f, 0.64595228f, -0.48802403f, 
    0.24091615f, -0.02113421f, 0.10334755f, -0.11867985f, 0.03754413f, 0.07293273f, 0.04045873f, 0.04066380f, 
    0.11082450f, 0.07435380f, -0.35973904f, -0.14535882f, 0.09678153f, 0.18846416f, -0.09370606f, 0.25133798f, 
    -0.50171912f, -0.31129041f, 0.10762436f, -0.09336950f, 0.18673851f, -0.09852511f, 0.09423701f, -0.11796773f, 
    -0.00350456f, 0.29112500f, 0.31529891f, 0.03749361f, 0.13901027f, -0.14216802f, 0.08870157f, 0.00348963f, 
    -0.11562715f, -0.08852607f, 0.20320189f, 0.23057117f, 0.12421392f, -0.22739775f, 0.01363932f, -0.18305515f, 
    -0.31891122f, -0.03746691f, 0.03338835f, -0.06123287f, 0.02145956f, -0.00454994f, -0.00308075f, -0.13578387f, 
    -0.29675093f, -0.01982985f, -0.07225548f, -0.14191984f, 0.62473667f, 0.03426058f, -0.28145191f, 0.05573871f, 
    -0.07285684f, 0.07890465f, -0.05131289f, 0.19392362f, 0.01279366f, -0.35275695f, 0.12196541f, 0.17761928f, 
    0.08661025f, 0.23599078f, -0.23850510f, 0.20600945f, 0.42955208f, 0.09223132f, 0.11359972f, 0.19532631f, 
    0.21119507f, -0.01157391f, 0.20330590f, -0.80826008f, -0.15309611f, -0.27298644f, -0.12433853f, 0.80954504f, 
    0.63188237f, -0.98788917f, 0.05744518f, -0.19695739f, 0.29844493f, -0.09381241f, 0.17488903f, -0.00668731f, 
    0.03848613f, -0.06374877f, -0.32318413f, 0.09439324f, 0.02799316f, -0.15972358f, 0.01875888f, 0.12552936f, 
    0.14345229f, 0.21012199f, 0.33464262f, 0.20532613f, -0.18979643f, 0.04594734f, 0.05214422f, 0.05676923f, 
    -0.07213767f, 0.03533895f, 0.88598520f, 0.05546947f, 0.06124053f, 0.05412593f, -0.11534760f, 0.19901042f, 
    -0.28615358f, -0.14500329f, -0.17583710f, -0.55566776f, -0.10674767f, 0.05315570f, -0.05595133f, 0.18384823f, 
    0.01328768f, 0.16100872f, -0.08946525f, -0.27686271f, 0.15884371f, 0.12146790f, -0.01206161f, -0.04546080f, 
    -0.22895493f, -0.15299281f, -0.03506533f, 0.06173034f, -0.02571196f, 0.04431470f, 0.11059554f, -0.09134106f, 
    0.15399146f, -0.18091197f, -0.16362163f, 0.08328710f, 0.23933385f, 0.29553264f, 0.34447461f, 0.35749483f, 
    -0.10361247f, 0.22031517f, -0.15618515f, -0.01772849f, 0.14156964f, 0.06618264f, 0.18700184f, -0.12841764f, 
    0.09725748f, -0.39143521f, 0.17992780f, 0.16370341f, 0.20276599f, -0.11341837f, 0.07472321f, -0.26513106f, 
    -0.08280197f, -0.06423190f, -0.04245995f, -0.01860402f, -0.00654801f, -0.03585960f, -0.10109276f, -0.13137610f, 
    -0.05661147f, -0.03890198f, -0.08040155f, 0.01651674f, 0.00007189f, -0.01658247f, -0.07087238f, -0.01467231f, 
    -0.09897650f, -0.03912661f, 0.06296502f, 0.02678728f, 0.00850949f, 0.03242217f, -0.04199470f, 0.03234803f, 
    -0.02020638f, -0.09954368f, -0.10019622f, -0.09543458f, 0.03752446f, -0.06683163f, -0.08299100f, -0.02327319f, 
    -0.06004488f, -0.05941226f, -0.02110485f, 0.00888204f, 0.03797742f, -0.03774709f, 0.02260842f, -0.01901628f, 
    -0.04555916f, -0.04869649f, 0.01627928f, -0.06790503f, -0.07103182f, 0.06291819f, 0.04282307f, -0.03474706f, 
    0.04441511f, 0.00151346f, 0.04342123f, 0.04781314f, -0.08969372f, -0.02478980f, -0.01653852f, 0.06949278f, 
    0.07569224f, -0.03500909f, 0.08662962f, -0.04755685f, -0.02126252f, -0.09340619f, -0.06036301f, -0.04836734f, 
    -0.07536653f, 0.03302058f, -0.02521414f, -0.06214786f, -0.12714846f, -0.07253322f, -0.00345483f, -0.09373627f, 
    -0.03481513f, 0.06273233f, 0.03576893f, -0.07964361f, -0.11126760f, -0.12839802f, -0.10420160f, -0.07093599f, 
    -0.03075594f, -0.08099942f, -0.09815202f, 0.01080079f, -0.10445155f, -0.08057316f, -0.01811172f, 0.01734499f, 
    -0.07852023f, 0.00596787f, -0.08044773f, 0.05568819f, 0.01518630f, 0.03982237f, 0.01216645f, -0.04960452f, 
    0.00177963f, -0.01796742f, -0.05876999f, -0.02937461f, 0.06314403f, -0.07185479f, -0.03691593f, -0.08370689f, 
    -0.04913487f, -0.03284700f, 0.03368517f, -0.04347640f, -0.04472809f, 0.06762986f, -0.00659382f, 0.07246473f, 
    -0.02003842f, -0.05232051f, -0.03711600f, 0.04871612f, -0.06569963f, 0.03969610f, 0.04604769f, 0.02302643f, 
    -0.02751370f, 0.04351489f, -0.06091341f, -0.00496021f, 0.01163188f, 0.03319440f, -0.07645950f, -0.09042271f, 
    -0.05403038f, -0.10185367f, -0.01830514f, -0.13469006f, -0.12367920f, -0.11508797f, -0.03198288f, -0.01315569f, 
    0.07963560f, -0.05530729f, 0.03059690f, 0.04552047f, 0.03130416f, 0.02274032f, 0.07645644f, -0.11529542f, 
    0.53231561f, 0.31271467f, 0.89875680f, 0.05197911f, -0.02920289f, 0.07521945f, 0.18069208f, 0.51231861f, 
    0.21329130f, 0.32896104f, 0.30971622f, -0.13833494f, -0.18125126f, -0.20681173f, -0.01549944f, 0.19777364f, 
    -0.07913687f, 0.17867555f, 0.14825721f, 0.06312067f, -0.21240501f, -0.40784442f, 0.03719943f, -0.22526635f, 
    -0.08373512f, 0.11289310f, -0.09984140f, -0.16605328f, 0.03712158f, -0.01379993f, -0.08801176f, 0.06617212f, 
    -0.07205173f, -0.06445988f, -0.11881579f, 0.38561985f, 0.27316031f, -0.00613777f, -0.36906728f, 0.02876867f, 
    0.05251939f, 0.05879952f, -0.11613253f, 0.07181480f, 0.14016493f, 0.22470430f, -0.13379854f, 0.20994487f, 
    -0.19556117f, -0.27142894f, -0.16331300f, -0.11727688f, 0.05554716f, 0.11027759f, -0.16787522f, -0.21303010f, 
    0.00922175f, -0.21769279f, -0.16303603f, -0.20860262f, -0.18332268f, -0.26709154f, 0.05146316f, -0.24315655f, 
    -0.41162181f, -1.16567874f, -0.11841887f, -0.21615382f, -0.02008863f, -0.14813931f, -0.16083789f, -0.18788202f, 
    -0.24987064f, -0.32486889f, 0.49040776f, -0.12485619f, -0.04353472f, -0.31413701f, 0.06654264f, -0.12345883f, 
    -0.08192790f, 0.08622359f, -0.20796035f, 0.28491929f, -0.37207770f, 0.13943662f, -0.12865470f, 0.06741578f, 
    0.21983039f, 0.21862251f, 0.29402155f, 0.03874002f, 0.03304139f, -0.02131760f, 0.04032911f, 0.09850289f, 
    -0.08110847f, 0.01631842f, 0.02616961f, -0.01139175f, -0.12557070f, 0.42538080f, -0.25754866f, 0.04192724f, 
    -0.11733629f, -0.04949081f, 0.07266339f, 0.11484554f, 0.20877147f, 0.00425995f, -0.34364656f, -0.14409260f, 
    -0.00156315f, -0.19604801f, 0.07832348f, -0.04785831f, 0.10319893f, -0.05881084f, -0.08020253f, -0.07257283f, 
    0.08431780f, 0.18012044f, -0.01152014f, 0.46970701f, 0.38295379f, 0.00826079f, 0.36284268f, -0.33918029f, 
    -0.23152156f, -0.11261231f, -0.04242538f, 0.06037204f, 0.02247842f, 0.00194096f, 0.02027318f, 0.02490622f, 
    0.23678108f, -0.13359620f, -0.21844515f, 0.23272201f, 0.51813233f, 0.12640892f, -0.07485849f, -0.03743577f, 
    -0.04984359f, -0.05715511f, -0.02041406f, 0.00034956f, -0.05782335f, 0.02606983f, 0.07403596f, -0.03569829f, 
    0.02017496f, -0.00137876f, 0.01888178f, 0.05965909f, 0.00815436f, 0.05580499f, -0.06457005f, 0.07411028f, 
    -0.06387299f, -0.04073597f, -0.06557276f, 0.01534076f, 0.01894250f, -0.01977885f, -0.07372759f, 0.03789396f, 
    0.02580821f, -0.02674860f, 0.02973063f, 0.06734655f, -0.07102852f, -0.04048078f, 0.05169756f, -0.06272446f, 
    -0.01497139f, -0.06964958f, -0.01662756f, -0.09167922f, 0.07411387f, -0.05013164f, -0.05485885f, -0.06415771f, 
    0.02979825f, 0.00379337f, -0.01331238f, 0.01435284f, -0.07790433f, 0.05610485f, -0.03686586f, -0.05203733f, 
    0.05819595f, -0.02886428f, 0.05002349f, -0.06767924f, 0.02666026f, -0.04924943f, 0.06824410f, -0.02076491f, 
    -0.08348481f, -0.03806493f, -0.03794542f, 0.02265311f, -0.08270951f, -0.05028022f, 0.02134909f, -0.07588692f, 
    0.07777046f, -0.07487953f, -0.00841482f, -0.06192524f, -0.02852162f, -0.06550539f, -0.02874599f, 0.02508936f, 
    -0.08153607f, -0.03024079f, -0.07675581f, 0.03907426f, 0.06164484f, -0.00415373f, 0.00690343f, 0.03849952f, 
    0.05713056f, 0.02622619f, -0.04671191f, -0.06156383f, 0.03519481f, 0.00980142f, -0.04851958f, 0.00675540f, 
    0.06492633f, -0.04469141f, 0.00594056f, -0.04197790f, -0.00537461f, -0.04362281f, 0.02910884f, 0.04414289f, 
    0.06213498f, -0.02463324f, -0.06767387f, -0.05436886f, -0.07625105f, -0.05011019f, -0.05550570f, 0.06006102f, 
    0.03373351f, 0.04213409f, -0.01963405f, -0.01282261f, 0.03420272f, -0.01208036f, -0.05368313f, -0.01805531f, 
    -0.07506755f, 0.04882271f, -0.04260398f, -0.05030554f, -0.06373754f, -0.01347210f, -0.03040094f, -0.04433678f, 
    0.00446599f, -0.05774791f, -0.07888172f, 0.03100173f, -0.07966655f, -0.02399193f, 0.02666106f, 0.02711102f, 
    0.00008921f, -0.08519198f, -0.08762443f, -0.08722042f, -0.00182520f, 0.06088702f, 0.03022279f, 0.06142604f, 
    -0.04204749f, -0.03375584f, -0.02049120f, 0.03519361f, -0.04195593f, -0.04741097f, -0.03185409f, -0.05819984f, 
    -0.09443017f, 0.24470413f, 0.04294908f, 0.10639764f, -0.00513289f, 0.04658081f, 0.31972572f, 0.19152153f, 
    0.15592684f, -0.37151042f, -0.67089522f, 0.08109654f, -0.03516012f, -0.14513879f, -0.11167639f, 0.02177872f, 
    0.13525845f, -0.11717385f, -0.64001369f, -0.34582788f, -0.00427234f, -0.61020291f, -0.34870443f, -0.30523843f, 
    0.04633467f, -0.13672426f, -0.10191821f, 0.11338597f, -0.09938926f, 0.22424455f, 0.20000264f, 0.02777934f, 
    0.23121618f, 0.39202845f, 0.27177352f, 0.09093471f, -0.12894325f, 0.04180724f, -0.00215675f, -0.04147123f, 
    -0.00436329f, 0.03350925f, -0.03530041f, -0.05861920f, 0.06496947f, 0.07272219f, -0.26736948f, -1.04248750f, 
    -0.15656021f, -0.16367015f, -0.37783733f, -0.15681386f, 0.20994362f, -0.07188038f, -0.20978589f, 0.17675376f, 
    -0.15815166f, 0.04719790f, -0.05807323f, -0.24749306f, 0.08571575f, -0.04417552f, -0.06722329f, -0.17999032f, 
    0.34854952f, -0.14542297f, 0.10272287f, -0.02691848f, -0.21493320f, -0.04344120f, -0.13361499f, -0.04122726f, 
    -0.57927436f, -0.07823347f, -0.00969151f, 0.29989880f, 0.29458502f, 0.02481410f, -0.01788834f, 0.23397018f, 
    0.31041738f, 0.14944853f, -0.14346395f, 0.30025390f, -0.00522365f, -0.12642927f, 0.00847635f, -0.09276896f, 
    -0.07661933f, 0.13325191f, -0.22159506f, 0.09482297f, 0.38474813f, 0.06488638f, -0.12161599f, 0.08303820f, 
    0.08710066f, -0.00683993f, 0.00447770f, -0.61177105f, -0.16106397f, 0.24767567f, -0.01385346f, 0.15727395f, 
    -0.04884716f, 0.05762663f, -0.01130662f, 0.19939691f, 0.44751254f, -0.11834513f, 0.11880552f, -0.15202948f, 
    -0.04133162f, -0.32117507f, 0.09114987f, 0.16074723f, 0.20236905f, -0.33326817f, -0.12246566f, 0.00005141f, 
    -0.11163310f, -0.27166116f, 0.00710203f, 0.13199155f, 0.27039644f, -0.00679408f, -0.09527122f, 0.09412501f, 
    0.31686118f, 0.22914797f, 0.08788285f, 0.20373149f, 0.00730762f, 0.12033051f, 0.14518920f, -0.03551940f, 
    -0.09588029f, -0.54111642f, 0.06488462f, -0.22124296f, -0.39563254f, -0.10786796f, -0.07241106f, 0.34323508f, 
    -0.50123745f, -0.14811587f, -0.49454573f, 0.20936680f, -0.11665707f, 0.04348613f, 0.11631548f, 0.08843216f, 
    0.12582959f, 0.41925153f, 0.89776087f, 0.70592487f, -0.35542741f, -0.08792938f, 0.00359147f, 0.12409401f, 
    0.12339365f, 0.10095432f, -0.08728364f, 0.11193397f, 0.24141756f, -0.17258237f, -0.18955278f, -0.23904213f, 
    0.14580297f, -0.04898788f, 0.05323165f, -0.20174666f, -0.26500165f, 0.14258020f, 0.19265957f, 0.20800751f, 
    0.10830118f, 0.04096519f, 0.19272974f, -0.03047091f, 0.52159882f, 0.28981072f, 0.08924279f, -0.26545614f, 
    -0.11355135f, -0.19753988f, 0.08772515f, -0.22552469f, -0.15328991f, -0.50600117f, -0.27246964f, -0.11189179f, 
    -0.23839475f, -0.03860051f, -0.06831782f, 0.18398027f, 0.02787674f, 0.02843788f, 0.26255283f, 0.46417683f, 
    0.38620046f, -0.34980369f, -0.03158000f, -0.19497722f, 0.06376994f, -0.00865236f, 0.11926463f, 0.10487574f, 
    -0.41647181f, -0.23365934f, -0.32521603f, -0.22990847f, -0.18155083f, -0.00337196f, -0.24097165f, 0.02819999f, 
    0.24435970f, -0.57747173f, -0.24934758f, 0.07512227f, 0.05774375f, -0.13698554f, 0.16312845f, 0.13961750f, 
    0.07791822f, -0.08140510f, 0.25029543f, -0.04008273f, -0.03470851f, -0.10219199f, 0.11206526f, 0.05882885f, 
    0.13426666f, 0.33546308f, -0.04531881f, 0.27489176f, -0.11303712f, -0.18819253f, -0.28423855f, 0.01095635f, 
    0.17174876f, 0.00540599f, -0.06612454f, 0.23203647f, -0.23300356f, -0.23008209f, 0.03875127f, 0.17736426f, 
    0.12281026f, 0.01029301f, 0.06901957f, 0.12197202f, 0.13259625f, 0.22824806f, 0.16791338f, -0.40165654f, 
    -0.28822091f, 0.15212993f, 0.03996020f, -0.02942465f, -0.13059320f, 0.01554878f, 0.15699245f, 0.12947612f, 
    0.23144327f, -0.04249961f, 0.09798332f, 0.29813814f, 0.20641021f, 0.17707984f, 0.10570719f, -0.45002660f, 
    0.42312896f, 0.04166190f, -0.24883550f, -0.05959374f, 0.00882517f, 0.13211004f, -0.09571820f, 0.26655328f, 
    -0.41034752f, -0.25268757f, 0.06839896f, -0.21446308f, -0.24882723f, 0.17883615f, 0.24031132f, -0.00567570f, 
    0.03436879f, -0.04889807f, -0.07020257f, -0.07431620f, 0.02634676f, 0.00077242f, 0.02558157f, 0.00799940f, 
    -0.01906809f, 0.07539168f, -0.02459537f, -0.05786362f, 0.01113909f, 0.04742330f, 0.05152588f, 0.06994106f, 
    0.04157926f, 0.00891925f, -0.07535426f, 0.01530681f, -0.05156690f, -0.04049742f, -0.03382054f, -0.04304593f, 
    -0.03437206f, 0.01524673f, -0.03567999f, -0.01767148f, -0.00610819f, -0.06954090f, 0.05315382f, 0.05409316f, 
    -0.07419037f, -0.08283859f, -0.02431317f, 0.02310823f, -0.08299993f, -0.04233461f, -0.01893279f, 0.08184027f, 
    -0.04549978f, -0.01436102f, -0.03373253f, -0.02591948f, -0.07671498f, 0.02008840f, 0.00364295f, 0.03475241f, 
    -0.05613138f, 0.03283872f, -0.03350057f, 0.05443041f, -0.07305530f, -0.07676033f, 0.06889784f, -0.03437959f, 
    0.02894074f, -0.04756726f, 0.00868809f, -0.02672601f, 0.04763642f, -0.04402990f, 0.02192743f, 0.01749597f, 
    0.03407501f, -0.01989403f, -0.05264740f, -0.06955430f, 0.00672888f, -0.02355596f, -0.03539163f, -0.09495897f, 
    -0.07506044f, -0.07027537f, 0.06573235f, -0.04269347f, 0.05379076f, 0.03956560f, -0.00226814f, -0.01387774f, 
    -0.04676208f, -0.06084185f, -0.03997678f, -0.06997909f, -0.07610337f, -0.08274771f, -0.08530421f, -0.06229692f, 
    -0.07350738f, 0.02954328f, 0.03217942f, -0.05446665f, -0.03764915f, -0.00970325f, -0.07884766f, -0.00871812f, 
    0.00859838f, -0.00082005f, 0.03738478f, 0.06822494f, -0.04732681f, -0.07424914f, 0.04375638f, -0.07274342f, 
    0.04748372f, -0.00235458f, -0.08676028f, 0.02164146f, -0.08700249f, -0.00904694f, 0.00519478f, 0.06816682f, 
    -0.08924701f, -0.02849046f, 0.04254338f, 0.00630247f, 0.05929800f, 0.05792176f, 0.06793376f, -0.07311705f, 
    0.06181296f, -0.01408588f, -0.06963191f, -0.04524803f, 0.02143036f, -0.09332041f, -0.00712986f, -0.00495207f, 
    0.02223560f, -0.01301094f, -0.01362267f, -0.05491880f, -0.08479120f, 0.04970909f, 0.01186486f, 0.02466792f, 
    -0.00931515f, -0.00087072f, 0.02034755f, -0.03899893f, -0.01912133f, -0.06068447f, -0.01922625f, 0.02018691f, 
    -0.21719342f, -0.03073976f, 0.06736948f, 0.03858859f, 0.10419429f, 0.18604240f, -0.09661913f, -0.03260891f, 
    0.15697686f, -0.41701123f, 0.00534689f, -0.24184990f, -0.06058573f, 0.06705890f, 0.16212095f, 0.15072109f, 
    0.13564421f, -0.26907507f, 0.13114288f, -0.01388908f, 0.20150730f, -0.12443542f, -0.26342461f, -0.20001486f, 
    0.09433617f, -0.47533777f, -0.08925425f, -0.12406780f, 0.48448083f, -0.23457599f, -0.03662365f, 0.06966709f, 
    0.08925241f, -0.33558065f, 0.07854736f, -0.36154237f, 0.48957995f, -0.16299121f, -0.10849039f, -0.04056407f, 
    -0.20392016f, -0.16560352f, 0.03436704f, 0.08253396f, -0.22769731f, -0.05798651f, 0.55350411f, 0.24718796f, 
    -0.03724029f, -0.06063798f, -0.06352521f, -0.14538473f, 0.04812577f, 0.09690556f, 0.09205000f, 0.23555097f, 
    0.16642928f, -0.01640760f, -0.05464624f, -0.05122162f, -0.19256829f, -0.49850217f, -0.12764794f, 0.13973884f, 
    -0.39666072f, -0.21387771f, -0.24437618f, -0.22793704f, -0.31370136f, 0.08171664f, -0.32269156f, -0.09958907f, 
    -0.05540336f, -0.48405766f, -0.64139533f, 0.05262559f, 0.17394267f, -0.30423856f, 0.06122928f, 0.06689429f, 
    -0.02397841f, -0.69725996f, -0.30692115f, 0.77670020f, 0.05915795f, 0.05283707f, 0.37275019f, -0.07766432f, 
    0.05771907f, 0.55506855f, 0.00447625f, -0.00027186f, 0.04889083f, 0.01422340f, -0.13784689f, -0.09476335f, 
    -0.10871526f, -0.01208171f, -0.15488072f, 0.02089278f, 0.06345399f, 0.18627787f, -0.12007716f, 0.02943885f, 
    -0.02249890f, -0.06869218f, 0.04623320f, 0.22563280f, 0.00825733f, 0.32835713f, -0.12601218f, -0.02915573f, 
    0.27615425f, 0.11024282f, 0.08246002f, -0.35022965f, -0.06281107f, -0.05751298f, -0.08309441f, -0.11401090f, 
    0.13768739f, -0.05844527f, -0.11463021f, 0.24399272f, -0.08781444f, 0.36613885f, 0.27376109f, -0.11128122f, 
    -0.00802278f, 0.00215714f, -0.02409442f, -0.03674959f, 0.07400437f, -0.02953766f, -0.03890489f, 0.20563348f, 
    0.37378651f, 0.73090410f, -0.11907019f, 0.29276085f, 0.09030038f, -0.11670851f, 0.34935811f, 0.29404622f, 
    -0.57990569f, 0.69615644f, -0.04130045f, 0.38404053f, 0.03233512f, 0.04411407f, -0.12776768f, 0.06565430f, 
    -0.22781800f, 0.01553670f, -0.42887315f, 0.60686684f, -0.13219932f, -0.32630280f, -0.26002032f, 0.02647334f, 
    0.00332960f, 0.00367575f, -0.10953693f, -0.08731738f, 0.25023156f, 0.09338380f, -0.10229087f, -0.00825559f, 
    0.13759625f, 0.05178509f, -0.12936366f, 0.09022006f, -0.56060356f, 0.54808336f, -0.14299612f, -0.31557950f, 
    0.10206450f, 0.06710868f, 0.04593739f, 0.23429368f, -0.21437398f, 0.02563014f, 0.43705526f, -0.07062084f, 
    0.06250589f, 0.14514670f, 0.02861299f, -0.13122067f, -0.00085445f, -0.22751257f, -0.10467591f, -0.72913653f, 
    0.12306610f, 0.31857294f, -0.26723993f, -0.19922788f, 0.09649462f, 0.27800706f, 0.23232375f, 0.16338430f, 
    0.28527173f, -0.14940107f, -0.45588291f, -0.13895479f, 0.01798720f, 0.09789269f, 0.17569368f, -0.15178116f, 
    -0.74143285f, 0.15235336f, -0.40497866f, -0.30352938f, -0.53854042f, 0.05102980f, 0.05286447f, 0.15515101f, 
    -0.28400335f, 0.69106436f, 0.61309469f, -0.00561573f, -0.26284477f, -0.31438664f, 0.06182335f, -0.05227546f, 
    0.17523187f, 0.19638118f, 0.36651194f, 0.31080079f, -0.03909171f, 0.07446126f, 0.09130703f, 0.13851634f, 
    0.09013142f, -0.19063337f, 0.01891688f, 0.18897502f, 0.46399429f, 0.17019781f, 0.17623603f, -0.14409979f, 
    0.00254077f, 0.04922766f, -0.00182079f, -0.51896763f, 0.12339566f, 0.29923505f, 0.16395807f, 0.03447491f, 
    -0.06333157f, 0.29344261f, 0.17619404f, 0.24983953f, 0.01795301f, -0.01688128f, 0.22726680f, 0.04484370f, 
    -0.00352083f, 0.04246137f, -0.16510877f, 0.00208890f, 0.02546588f, 0.19744623f, -0.04514960f, -0.02972367f, 
    0.00499032f, 0.01975956f, -0.05037392f, 0.14612098f, -0.23467407f, -0.17185053f, -0.01952750f, 0.20772257f, 
    0.25542918f, 0.05457797f, -0.12359389f, 0.14510760f, 0.20959492f, 0.03237914f, 0.13223489f, -0.34938031f, 
    -0.34245202f, -0.03157639f, -0.16632901f, 0.38590053f, 0.41451293f, 0.45498392f, -0.10505941f, -0.54180342f, 
    -0.63403153f, -0.51340115f, -0.22720085f, 0.13636531f, 0.17003109f, 0.23773347f, 0.11835678f, -0.13385051f, 
    0.31582183f, -0.00717431f, 0.48285490f, 0.35751882f, 0.07760772f, 0.19953598f, 0.04996021f, 0.02310950f, 
    0.05645229f, -0.26806757f, -0.28181571f, -0.29708150f, -0.29096937f, 0.01150815f, -0.09236383f, -0.20091756f, 
    0.06692119f, -0.01970980f, -0.25482923f, 0.03831688f, 0.13367867f, 0.04050091f, 0.09897938f, -0.00872884f, 
    0.05492172f, 0.05091728f, -0.12024526f, -0.40190825f, -0.07565037f, 0.32591963f, 0.08938126f, 0.10262390f, 
    0.00319373f, -0.27521461f, 0.20270276f, -0.15379898f, -0.24921343f, -0.27510458f, -0.30462608f, 0.01905912f, 
    -0.14326683f, 0.14316989f, 0.24671963f, -0.02955022f, -0.23021477f, 0.20944645f, -0.18331537f, -0.48438630f, 
    -0.02284505f, 0.05788546f, -0.07905808f, -0.28367668f, 0.01009051f, -0.22687840f, -0.15772381f, 0.13373034f, 
    0.04331689f, 0.07736298f, 0.04772254f, 0.03291781f, -0.25211608f, 0.13656090f, -0.05778737f, -0.13964897f, 
    0.03011638f, 0.12542556f, 0.12613095f, 0.28230524f, 0.20470078f, -0.03538773f, 0.10955010f, 0.32734883f, 
    -0.00352870f, -0.26523373f, -0.13500586f, 0.42018250f, -0.01319746f, 0.07628483f, 0.25005201f, 0.00487989f, 
    0.13829777f, 0.45544791f, -0.18302599f, 0.35553375f, 0.48809400f, 0.03313185f, -0.06776964f, 0.09503911f, 
    0.25446790f, -0.17597958f, -0.69025230f, 0.00439239f, -0.43823946f, -0.20827748f, -0.06046854f, 0.14632636f, 
    0.21103117f, -0.10333867f, -0.03214270f, -0.01802422f, -0.16034250f, -0.25667861f, -0.04618561f, 0.06259865f, 
    -0.07365112f, 0.20709634f, -0.23319338f, 0.26248682f, -0.05247342f, -0.08620942f, -0.04297873f, 0.14734896f, 
    0.07648715f, -0.07905678f, -0.02012150f, 0.09283270f, 0.15917422f, 0.33713543f, 0.31139812f, 0.26012385f, 
    0.28665131f, -0.16583927f, 0.02183832f, 0.01009673f, 0.04225068f, 0.18253259f, 0.13330336f, -0.45753258f, 
    -0.51715499f, -0.34030157f, 0.02392566f, -0.11754990f, 0.07599802f, -0.12316493f, 0.28874823f, 0.18643402f, 
    0.19929808f, 0.11049461f, 0.14534049f, 0.19438027f, 0.12188868f, -0.13744600f, 0.17937380f, -0.16180268f, 
    0.04974662f, -0.18807590f, 0.00241293f, 0.54454070f, 0.12301061f, -0.02795048f, -0.14982234f, -0.16703625f, 
    0.09873180f, -0.03668617f, 0.18443681f, 0.29413328f, 0.06236504f, -0.05464752f, -0.01408944f, -0.00267966f, 
    -0.26629403f, 0.02500650f, 0.16645542f, -0.14708377f, 0.59142923f, 0.00228329f, 0.07312533f, 0.17779583f, 
    0.26116371f, 0.05974174f, 0.22579767f, 0.08053862f, 0.07871812f, -0.62917817f, -0.09475506f, 0.03286982f, 
    -0.18620294f, 0.12437962f, 0.12089594f, -0.16276462f, 0.16189590f, 0.95611143f, 0.00900550f, -0.12023340f, 
    -0.17328788f, 0.01338727f, 0.04689702f, 0.00127912f, 0.15296310f, 0.17279984f, -0.11595435f, 0.43508703f, 
    0.01983417f, 0.07135911f, 0.14905098f, 0.06018291f, 0.03010876f, -0.03008517f, 0.14884995f, -0.24284315f, 
    -0.28130984f, 0.32807595f, -0.08170804f, 0.09189743f, 0.29329422f, -0.03458482f, 0.01876227f, 0.24164669f, 
    -0.02035670f, -0.52288359f, -0.16382207f, 0.03147247f, 0.08627772f, 0.22476044f, 0.12696530f, 0.02680972f, 
    -0.18233490f, -0.20384264f, 0.41588655f, 0.10198828f, -0.12664242f, -0.04068278f, -0.11015579f, 0.14001508f, 
    -0.17286097f, -0.12773262f, 0.60823709f, -0.39635020f, -0.28177884f, -0.02506848f, 0.14001039f, 0.29552838f, 
    0.07772583f, -0.15975231f, 0.00751475f, -0.02251278f, 0.46392930f, -0.16506800f, -0.05984054f, -0.02066927f, 
    -0.05817681f, 0.03700854f, 0.11694708f, 0.15349565f, 0.13902360f, -0.11473190f, 0.01658874f, -0.00302890f, 
    0.10434102f, 0.26374239f, 0.09736453f, -0.12976192f, -0.13831539f, -0.02030612f, -0.06892567f, -0.12388456f, 
    -0.12149549f, -0.07548480f, 0.23908965f, 0.18000074f, -0.09506164f, -0.05438565f, -0.08029948f, -0.88902020f, 
    -0.08728617f, 0.21114078f, -0.06811909f, 0.06021596f, 0.00402368f, 0.01584088f, 0.01149492f, -0.04992706f, 
    0.15643652f, -1.00763154f, 0.14390126f, -0.09336031f, -0.24346496f, 0.00975212f, -0.08200880f, -0.46058905f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.74065691f, 0.56086498f, 0.32958317f, -0.15356889f, -0.11747367f, -0.33848828f, -0.02579671f, 0.00200189f, 
    0.05208899f, 0.89860570f, 0.30898046f, -0.09280337f, 0.07556523f, 0.09589986f, 0.10546145f, 0.21168493f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.41078195f, 0.08642690f, -0.03500081f, 0.32392108f, -0.35968849f, 0.64954829f, -0.00286821f, 0.41823304f, 
    0.19409893f, -1.14150751f, 0.46559557f, -0.10838912f, 0.08690330f, -0.25226259f, 0.15725183f, -0.53026873f, 
    0.00027919f, 0.03713569f, 0.38322505f, -0.09960503f, -0.53881490f, -0.12841251f, 0.05297523f, -0.32316330f, 
    0.00811021f, 0.23627435f, 0.47206992f, -0.19676167f, 0.62903839f, -0.47734898f, 0.48801091f, -0.23525907f, 
    0.41249514f, -0.23708290f, -0.20178635f, 0.22247076f, 0.80428970f, -0.43844458f, 0.12911616f, -1.32181740f, 
    0.01040591f, 0.72366434f, -0.36463997f, -0.09447127f, -0.08288146f, 0.24235998f, -0.12723871f, -0.22655907f, 
    -1.03250599f, -0.03071284f, 0.12806371f, 0.02084955f, -0.04757505f, 0.28652346f, 0.14311604f, 0.27412409f, 
    0.22674304f, 0.55748051f, -0.20188114f, 0.18749647f, -0.33145484f, 0.38493925f, -0.06456834f, 0.27984488f, 
    -0.20726405f, -0.13653301f, -0.18455261f, 0.40090874f, -0.40799248f, -0.31372032f, -0.13704416f, -0.11122307f, 
    0.05252332f, -0.60558319f, 0.38105848f, 0.04761496f, -0.11591875f, 0.40126163f, 0.36218929f, 0.05870441f, 
    0.18353595f, -0.36049587f, 0.49564096f, 0.38999650f, -0.20544508f, -0.05799976f, 0.18924069f, 0.18777882f, 
    0.12848866f, 0.25413734f, 0.06050942f, 0.20479837f, -0.18054610f, -0.35586110f, 0.15236266f, -0.34742618f, 
    0.69636458f, 0.96624821f, -0.20303570f, 0.07084610f, -0.18841352f, -0.41948810f, -0.22055916f, -0.76558661f, 
    -0.03211570f, 0.09117736f, -0.73711324f, 0.16463150f, -0.44930956f, -0.10878388f, -1.18089271f, -0.00522338f, 
    -0.43763351f, -0.08155612f, -0.34474611f, 0.25917503f, 0.59380662f, 0.19146933f, -0.07308027f, 0.01114051f, 
    0.15533563f, -0.12791047f, 0.14083356f, 0.11919275f, 0.38354474f, -0.36547309f, -0.35093239f, 0.53123248f, 
    0.23198687f, -0.47712982f, 0.58441490f, -0.95830625f, 0.02469596f, -0.03217864f, 0.09378564f, 0.17122567f, 
    0.21189712f, 0.20134449f, 0.00982907f, 0.06399110f, -0.01112312f, -0.16995786f, 0.11409891f, 0.48046014f, 
    -0.05587254f, 0.66055071f, -0.51326156f, 0.07986529f, -0.57487994f, -0.08852965f, -0.16024609f, -0.48601118f, 
    -0.01832497f, 0.33926639f, 0.57433790f, 0.20731317f, -0.61087996f, 0.32492331f, -0.55925041f, 0.39992121f, 
    0.17986301f, -0.42568558f, 0.14440568f, -0.68173033f, 0.00005631f, -0.22092000f, -0.10870647f, 0.10841933f, 
    -0.06248686f, 0.14045933f, -0.48175544f, 0.03217081f, 0.32628721f, 0.79820782f, 0.43370852f, -1.08494139f, 
    0.32685834f, -0.50870341f, 0.15798387f, 0.16861130f, 0.19638504f, -0.31435934f, -0.14393106f, 0.99160331f, 
    -0.19398354f, -0.14777657f, -0.89013928f, 0.15771523f, -0.43054250f, 0.23305701f, -0.49837536f, -0.00383073f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.56262469f, 0.44222647f, 0.35500211f, 0.11629868f, -0.42251793f, 0.13518515f, -0.22920209f, -0.46472043f, 
    -0.45418110f, 0.57899886f, -0.10937040f, 0.06508400f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
