#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.69692767f, -0.74646252f, -0.26289901f, -0.00599948f, -0.04749265f, -0.13940191f, -0.11945856f, 0.36155567f, 
    -0.28303903f, 0.44561914f, -0.32327598f, -0.06031881f, -0.41351140f, -0.28930542f, 0.04763930f, 0.04095978f, 
    -0.07930095f, -0.30091035f, 0.18689790f, 0.45831388f, -0.02071591f, -0.32543465f, 0.20501715f, -0.17848185f, 
    -0.16133778f, 0.22666553f, 0.56070161f, 0.09030300f, -0.29032949f, -0.37771162f, -0.28066421f, -0.22270650f, 
    -0.03468139f, -0.46363339f, -0.55800003f, -0.17558201f, 0.01980027f, 0.17997563f, -0.01171204f, -0.18664663f, 
    0.24832886f, 0.34340370f, 0.16983166f, 0.20171182f, -0.00530040f, -0.01564542f, -0.20946942f, -0.09590740f, 
    -0.19054230f, -0.17141972f, -0.51932704f, -0.54000664f, 0.11288201f, 0.50739938f, 0.20683312f, 0.15271674f, 
    0.07070679f, -0.27201325f, -0.06499464f, 0.18112244f, -0.23642960f, 0.11539217f, -0.21924064f, -0.20252863f, 
    -0.33987769f, 0.03050414f, 0.21943349f, 0.15761487f, 0.40771717f, 0.14844184f, -0.30078471f, -0.16496797f, 
    -0.29837856f, -0.12568881f, -0.23505597f, 0.21725672f, 0.35133788f, 0.12855220f, 0.00217689f, 0.01934739f, 
    -0.04892204f, 0.31600308f, 0.20772795f, 0.20931174f, -0.08692211f, -0.01033502f, -0.10960276f, 0.14533795f, 
    0.19196802f, -0.01042094f, 0.06420644f, -0.05965801f, -0.31396851f, -0.24612872f, -0.01967360f, -0.16511157f, 
    0.16086860f, 0.24772345f, 0.19552885f, -0.10202980f, -0.00208988f, -0.39463344f, 0.07157122f, -0.15017882f, 
    -0.51309192f, 0.11194915f, -0.45315686f, -0.21214470f, 0.08651128f, -0.14241688f, -0.39878407f, -0.11253157f, 
    -0.34284270f, -0.45086136f, -0.14158134f, -0.10177497f, 0.01623275f, 0.13845652f, -0.22807778f, 0.37693769f, 
    -0.25801000f, 0.08966759f, -0.10758630f, -0.50218433f, -0.21302755f, -0.00342180f, 0.49393210f, -0.36729234f, 
    -0.33851272f, -0.51733011f, -0.21097888f, -0.05589730f, 0.55001670f, -0.30183515f, -0.35882804f, 0.03533543f, 
    -0.27523017f, 0.01859822f, 0.03210857f, -0.42677546f, -0.17525858f, -0.45499426f, -0.28753647f, -0.16740479f, 
    0.20099935f, 0.12525511f, -0.18685445f, -0.10518128f, 0.06232091f, 0.44972166f, -0.49763128f, -0.75561249f, 
    -0.34012070f, 0.20034860f, 0.15490857f, -0.61336017f, -0.76364279f, -0.61363232f, -0.41965693f, -0.42427379f, 
    0.46748886f, 0.11677106f, 0.19665045f, 0.30859241f, 0.12635648f, 0.06001026f, -0.22271706f, -0.05240703f, 
    -0.15588047f, 0.14165746f, 0.24522848f, -0.04200030f, -0.07178044f, -0.09869494f, 0.03679875f, 0.83732998f, 
    -0.80194157f, -0.49926320f, -0.10099154f, 0.42679518f, -0.11274081f, -0.01749261f, 0.42813155f, 0.19317839f, 
    0.04993281f, -0.20148358f, -0.06611119f, -0.24773732f, -0.39921334f, 0.26823691f, -0.12430266f, 0.16833663f, 
    -0.06605466f, 0.03878257f, -0.44415638f, -0.48166305f, -0.32075053f, -0.45454654f, -0.33721158f, -0.27294871f, 
    0.08064640f, -0.00654286f, -0.10821391f, -0.20073675f, -0.26605284f, 0.18431059f, 0.04812694f, -0.08354236f, 
    -0.01765092f, 0.08219563f, 0.24878532f, -0.14657314f, 0.26839525f, 0.18868406f, 0.04271795f, 0.08512638f, 
    0.21963525f, -0.00554102f, 0.01158026f, 0.07932615f, 0.17773484f, 0.05251471f, -0.06325594f, 0.05780628f, 
    0.13577807f, -0.70001370f, 0.04358312f, -0.05552279f, 0.17255203f, -0.09042691f, -0.33076364f, 0.00219653f, 
    0.36346388f, 0.43104321f, -0.04755460f, 0.28209454f, -0.04746824f, 0.01912740f, -0.09908731f, 0.24041481f, 
    -0.52180564f, -0.35401928f, 0.28625491f, -0.14470321f, 0.08378394f, -0.00291196f, 0.31436348f, 0.19398718f, 
    -0.25903085f, 0.39344686f, 0.74284947f, -0.18058749f, -0.15638794f, -0.26210654f, -0.20399043f, 0.25463402f, 
    0.18046120f, -0.00698867f, -0.11115297f, 0.15696073f, -0.15983698f, 0.48108295f, -0.34296519f, -0.27516085f, 
    0.16398886f, 0.24861167f, -0.04993841f, -0.18171608f, -0.28535038f, 0.01654267f, 0.17290641f, -0.28571355f, 
    -0.02542971f, -0.17797570f, -0.22054924f, 0.12878336f, 0.45067847f, 0.52879834f, -0.36790621f, -0.01763000f, 
    -0.35944468f, -0.15639538f, -0.17206320f, 0.11990159f, -0.56409633f, -0.22842836f, 0.00113330f, 0.10763710f, 
    0.04047434f, 0.25004902f, 0.32741749f, -0.09791657f, 0.13133137f, -0.19571453f, 0.17259753f, -0.19297405f, 
    -0.14775527f, -0.24491572f, -0.12824577f, 0.23433085f, 0.03358176f, 0.25097209f, -0.07547431f, 0.28331330f, 
    0.11481672f, 0.21234727f, -0.06455944f, -0.54943913f, -0.44123808f, -0.16632029f, 0.14880431f, 0.10436188f, 
    0.14242363f, 0.17354958f, 0.32896733f, -0.13867559f, -0.43739876f, -0.03574017f, 0.17686436f, 0.01779875f, 
    0.22894545f, 0.42300871f, -0.06927866f, -0.33101672f, -0.30061817f, -0.12678519f, 0.43210497f, 0.40049276f, 
    -0.61787868f, -0.30123690f, -0.76256651f, -0.73102498f, -0.50995219f, -0.63290149f, -0.45045105f, 0.62664425f, 
    0.08255424f, 0.27433702f, 0.42989516f, -0.16889492f, -0.03825065f, 0.00889953f, -0.17412600f, -0.32471916f, 
    -0.53597307f, 0.10394798f, -0.14699723f, -0.04889682f, -0.12900218f, -0.28787655f, -0.42227560f, -0.47565433f, 
    -0.51438761f, -0.12514099f, -0.53147656f, -0.57910895f, -0.41009220f, -0.46676850f, -0.47887561f, -0.55515707f, 
    0.15037738f, -0.35723230f, 0.07636990f, -0.01699007f, -0.28736198f, -0.08290315f, -0.03368742f, -0.08592058f, 
    0.15052961f, -0.06658142f, -0.08355869f, -0.05996384f, -0.15721117f, -0.00726837f, 0.19115305f, 0.24718809f, 
    0.20161852f, -0.34747732f, -0.33366215f, -0.78158605f, 0.27409983f, -0.05576150f, 0.26153436f, 0.52082103f, 
    0.15825818f, -0.20435694f, -0.26568136f, 0.08420906f, -0.19177289f, -0.21005601f, -0.19624405f, -0.45157555f, 
    -0.35047594f, -0.38915583f, -0.45405409f, -0.02037572f, 0.04620858f, 0.25696328f, -0.09741194f, -0.23182616f, 
    0.74415380f, 0.59673327f, -0.15091412f, -0.41967911f, -0.74740732f, 0.40570599f, -0.00383019f, 0.10971499f, 
    -0.18688940f, -0.21764222f, -0.25424176f, 0.17106836f, -0.09059851f, 0.35477036f, -0.34247920f, 0.16445835f, 
    -0.09919662f, 0.02333800f, -0.10164598f, 0.05082262f, 0.07480839f, 0.15227476f, -0.03579456f, -0.17609021f, 
    0.10343529f, -0.71612990f, -0.54417413f, 0.13347727f, 0.32043663f, 0.31060749f, 0.26123258f, -0.19872436f, 
    -0.16237485f, 0.49546173f, 0.45228779f, -0.19488432f, 0.18487972f, 0.07835003f, 0.14128388f, -0.41393214f, 
    -0.34423435f, -0.09772338f, 0.26451597f, -0.04198019f, 0.23395154f, -0.00429877f, 0.15956265f, -0.15125935f, 
    -0.13528500f, -0.06727314f, 0.41546920f, -0.01819620f, 0.35249746f, -0.45262867f, -0.18904740f, -0.44775113f, 
    0.34096903f, -0.07521118f, 0.02171119f, 0.15331821f, -0.02873358f, -0.02717404f, 0.05329113f, -0.05330826f, 
    0.20863098f, -0.04195401f, 0.06867981f, -0.12633942f, 0.05719300f, 0.12380029f, -0.25494102f, 0.22604229f, 
    0.16691755f, -0.24598636f, 0.21484637f, -0.36653349f, -0.00782974f, -0.12116629f, -0.00720041f, 0.34816974f, 
    0.73284960f, 0.36211136f, -0.21198224f, -0.43333116f, -0.49746245f, 0.14817685f, 0.28663161f, -0.05831786f, 
    -0.31528699f, 0.22398230f, -0.02457368f, -0.42627084f, 0.03471238f, 0.28413790f, -0.14561671f, 0.15576129f, 
    -0.00718380f, -0.10187765f, 0.03480256f, 0.16442002f, -0.19026905f, 0.56697160f, 0.43266585f, -0.37028721f, 
    0.01357049f, -0.18585867f, 0.29065511f, 0.11025195f, -0.14384145f, -0.04857999f, -0.11350659f, -0.07026415f, 
    -0.29762930f, -0.24328436f, 0.20240647f, -0.12097648f, 0.28432614f, 0.18314818f, -0.06081767f, 0.01958300f, 
    0.18128070f, -0.15989144f, -0.15255517f, -0.25743499f, -0.18635394f, 0.41712368f, 0.24153781f, -0.16167508f, 
    0.03099791f, -0.46843264f, 0.31451294f, 0.14454015f, -0.42930558f, -0.57892209f, 0.03972144f, 0.02789965f, 
    -0.26482916f, -0.41726729f, -0.19705692f, 0.62317365f, -0.24479623f, -0.32772160f, 0.21473278f, 0.33868659f, 
    -0.27672380f, -0.14659038f, -0.43933579f, 0.35724714f, -0.09070089f, 0.11196981f, 0.18750139f, 0.23488759f, 
    0.41135836f, -0.24899481f, -0.68237048f, 0.02368379f, 0.12159747f, -0.42788950f, -0.50475621f, -0.25363323f, 
    0.37142253f, 0.00064693f, 0.10127417f, -0.09687334f, 0.14152037f, -0.21771859f, 0.06475484f, 0.29303315f, 
    0.14185688f, 0.08089387f, 0.01673842f, -0.09275265f, -0.08698227f, -0.44670406f, 0.13652667f, -0.85309219f, 
    -0.73038012f, -0.57665408f, -0.06167595f, -0.35855556f, 0.54012668f, 0.42682871f, 0.18791360f, 0.16601832f, 
    0.37175030f, 0.20184590f, 0.12120505f, 0.10336983f, -0.11313825f, -0.18895359f, -0.21872550f, -0.13433829f, 
    -0.02039886f, -0.24917750f, -0.23818299f, -0.08042536f, -0.24018005f, -0.12318412f, -0.25996226f, -0.14119115f, 
    -0.83979827f, -0.37821367f, 0.07495196f, 0.94117892f, -0.04102148f, 0.82180995f, -0.72771633f, -0.72596681f, 
    0.30902550f, -0.37352043f, -0.41814756f, 0.21303557f, 0.20656961f, -0.27288085f, -0.13279380f, -0.17722343f, 
    0.20458317f, 0.21141292f, -0.03115957f, 0.15889299f, 0.16586611f, 0.12737028f, -0.16862169f, 0.11180191f, 
    -0.01997466f, -0.25505301f, -0.34138036f, -0.47460240f, -0.55737120f, -0.12057255f, -0.20180774f, -0.12837799f, 
    -0.37702248f, -0.52439761f, -0.47990388f, 0.04029060f, 0.35956079f, -0.29327422f, -0.05925910f, -0.31637251f, 
    -0.37938073f, -0.07646707f, -0.06695013f, -0.23750183f, -0.46057490f, -0.13144992f, -0.10416370f, 0.20181946f, 
    0.21754326f, -0.02081674f, 0.59319186f, 0.36876360f, 0.09855305f, -0.03261197f, 0.06326962f, -0.03576962f, 
    -0.16304830f, 0.14366379f, 0.11178058f, 0.16500166f, -0.22212021f, 0.16589968f, -0.14662343f, 0.13765699f, 
    -0.21637933f, 0.11534103f, -0.07153855f, 0.14381117f, -0.16376823f, -0.27955058f, -0.23148920f, 0.16812438f, 
    -0.08109279f, -0.16481799f, -0.37324473f, 0.24437179f, -0.35706273f, -0.15395926f, -0.17175944f, -0.67178130f, 
    -0.41750556f, -0.30461469f, -0.22666717f, -0.45316145f, -0.78889948f, 0.03112217f, -0.35921156f, 0.18161818f, 
    0.11315924f, 0.00317353f, -0.00232796f, -0.28884998f, -0.07293297f, -0.34730288f, 0.00702465f, -0.18005596f, 
    -0.06603961f, 0.16782926f, 0.17131501f, -0.02098994f, -1.00808942f, -0.27915516f, -0.71491736f, -0.49158877f, 
    -0.17082381f, 0.61950094f, 0.55572575f, 0.00625687f, -0.00774353f, 0.55120635f, 0.41685739f, 0.30009717f, 
    -0.20813537f, 0.21921539f, -0.39453760f, -0.29045013f, -0.27001891f, -0.25943568f, -0.08639533f, -0.10651003f, 
    0.12075218f, 0.01405562f, 0.27656063f, 0.27624598f, 0.03042113f, -0.06468138f, -0.23319563f, 0.10802225f, 
    0.31870180f, -0.24117185f, -0.66430914f, -0.29989737f, 0.30136451f, -0.00346654f, -0.21741347f, -0.03458660f, 
    0.09042615f, 0.34827062f, -0.19873394f, -0.24887784f, -0.25617644f, 0.08247364f, -0.01348812f, 0.03050890f, 
    -0.63476306f, -0.22112150f, 0.10093543f, 0.07097662f, 0.11078697f, 0.24599020f, 0.38576066f, 0.68223166f, 
    0.18776855f, -0.72289473f, -0.73779368f, -0.19277884f, 0.02208093f, 0.43223727f, 0.02533340f, -0.11023881f, 
    -0.02421125f, -0.13214163f, 0.50599712f, -0.35560310f, 0.01795991f, -0.14451751f, -0.00044816f, 0.12061935f, 
    -0.18589395f, 0.35408288f, 0.09763877f, 0.15166265f, -0.36083412f, -0.15764965f, 0.21246246f, -0.26658973f, 
    -0.06101186f, 0.08649683f, 0.23177131f, 0.03186742f, 0.08504327f, -0.23792854f, -0.19582929f, 0.24088575f, 
    0.13536263f, 0.07627632f, -0.18463270f, -0.01135432f, -0.37235919f, -0.16361637f, -0.12366971f, -0.16676211f, 
    0.22498140f, 0.37637591f, -0.11058777f, 0.06942956f, -0.05401188f, -0.29201451f, 0.03261102f, 0.50616080f, 
    -0.41288537f, -0.79949206f, 0.37562460f, 0.31412053f, 0.23402616f, -0.47315991f, -0.53556812f, 0.59389246f, 
    0.43574864f, -0.10967116f, -0.25614113f, -0.16618085f, 0.04962089f, 0.47360387f, -0.01118394f, -0.12943801f, 
    0.13154139f, 0.01442997f, -0.33483729f, 0.18570429f, -0.00687273f, 0.08275311f, -0.19856998f, -0.00879299f, 
    0.26464200f, -0.77333128f, -0.24749102f, -0.26016170f, 0.19311400f, 0.09378432f, 0.12932877f, -0.10424689f, 
    -0.14272743f, 0.02246564f, 0.17915106f, -0.06079327f, -0.03403978f, 0.05386904f, 0.31290126f, 0.29033747f, 
    0.30565158f, 0.05646813f, -0.10455874f, 0.03779649f, -0.05775676f, -0.09913541f, -0.25340268f, 0.11816098f, 
    -0.11863476f, -0.32672745f, 0.71555316f, -0.00491624f, -0.35949686f, -0.32955170f, -0.33204451f, 0.20275317f, 
    0.14099507f, -0.05032326f, -0.35739782f, -0.08219566f, -0.16035885f, -0.04372221f, -0.21934588f, -0.16200148f, 
    -0.27233535f, -0.10124053f, -0.02749008f, 0.09125118f, 0.10173920f, -0.10601091f, 0.09668352f, -0.06054619f, 
    0.12249876f, 0.40050307f, 0.20566186f, -0.98244113f, 0.25291252f, 0.37407818f, -0.80849886f, -0.69644779f, 
    -0.00874691f, -0.09464813f, -0.02859954f, 0.31844732f, 0.40608013f, -0.51737386f, -0.41128707f, -0.19739096f, 
    -0.12090646f, 0.00863380f, 0.35382700f, -0.21917577f, -0.13753925f, -0.33477047f, -0.38283449f, -0.01550973f, 
    -0.27501300f, -0.14196545f, -0.23384365f, -0.03554465f, 0.67580140f, 0.17644528f, -0.19528919f, -0.46210599f, 
    -0.55125809f, 0.17989004f, -0.08989172f, 0.35824433f, -0.04363653f, 0.00659723f, -0.03531687f, 0.17825308f, 
    0.49847373f, -0.38856992f, -0.00149166f, 0.10607491f, -0.14291814f, -0.23400217f, -0.01636596f, -0.18619446f, 
    -0.03646513f, -0.00563814f, 0.12363464f, 0.03144527f, 0.35134441f, 0.19518745f, 0.00568265f, -0.33342943f, 
    -0.41998619f, -0.43435651f, -0.07533684f, 0.00277295f, 0.00474584f, 0.07648292f, 0.22793555f, 0.25648996f, 
    0.15758127f, 0.29922247f, 0.23082703f, 0.14487544f, 0.17539997f, -0.12492783f, 0.01783078f, -0.32893845f, 
    0.06782652f, 0.27191320f, 0.18242106f, -0.17514415f, -0.18826883f, -0.18456255f, 0.58505404f, 0.53798550f, 
    -0.83495790f, -0.64760143f, -0.59403837f, -0.67012382f, -0.41473347f, 0.37254697f, 0.73132128f, 0.65003961f, 
    -0.04904127f, 0.01094152f, 0.41092488f, 0.23975374f, -0.00693053f, -0.11884472f, -0.12045328f, 0.10242670f, 
    0.03714051f, -0.21851593f, -0.13536486f, -0.09442610f, 0.06816372f, 0.02276156f, -0.13611843f, 0.27756542f, 
    0.01457213f, -0.26296407f, 0.12747344f, 0.45849916f, -0.00708657f, 0.23184128f, 0.22859675f, -0.14271586f, 
    -0.34247211f, -0.15935329f, -0.22688459f, -0.08848340f, -0.27150941f, 0.20034550f, -0.06132144f, 0.14745560f, 
    0.19148117f, 0.23272364f, 0.16301332f, 0.25037301f, -0.23101586f, -0.25091809f, -0.37403089f, -0.22273538f, 
    0.23230261f, -0.61598051f, -0.59261823f, -0.64436805f, 0.13486557f, -0.26122439f, -0.42583022f, 0.14550233f, 
    0.01434146f, -0.33964637f, 0.52247268f, 0.52829295f, 0.60767168f, -0.34709954f, 0.02502735f, -0.25695014f, 
    -0.29281917f, -0.29155052f, -0.27656257f, 0.29766020f, 0.25581345f, 0.11893359f, 0.00285800f, -0.38968334f, 
    0.00955840f, -0.42113638f, -0.01270887f, 0.02343319f, 0.25717524f, -0.23558773f, 0.17941380f, 0.12873223f, 
    -0.07866043f, -0.12215400f, 0.27904820f, -0.00592957f, -0.11914547f, 0.17457132f, -0.46195668f, 0.22733435f, 
    0.10084268f, 0.19632258f, -0.35573727f, 0.16281113f, -0.46677348f, 0.12902527f, 0.09508850f, -0.06501871f, 
    0.00838444f, 0.49837056f, -0.63579321f, 0.39261922f, 0.63155949f, 0.54214400f, 0.11843259f, -0.32015079f, 
    -0.62420326f, -0.23472735f, 0.03865970f, -0.01652075f, -0.25048009f, -0.29529431f, -0.19535631f, 0.31804234f, 
    0.24265316f, -0.21320042f, 0.04470763f, 0.15591837f, 0.09544881f, 0.10104956f, -0.13295087f, 0.08116930f, 
    0.06115939f, 0.28812665f, -0.19453295f, 0.02023539f, -0.27509877f, 0.24967220f, 0.38968486f, 0.22506043f, 
    0.17241798f, 0.58807921f, 0.50834680f, 0.44342369f, 0.28272298f, -0.17001775f, 0.04428789f, 0.32769412f, 
    -0.04400669f, -0.04226712f, -0.02388047f, -0.13905588f, -0.11046269f, 0.13470119f, -0.13128333f, 0.15151490f, 
    -0.12981190f, -0.07235473f, -0.09878841f, 0.14487971f, -0.77569848f, 0.54244626f, -0.19658898f, 0.27557197f, 
    0.27635664f, -0.11939452f, -0.48053178f, -0.24004953f, 0.50995588f, 0.25900522f, -0.16956015f, -0.24296494f, 
    -0.10504132f, 0.00099380f, -0.19423407f, 0.14106573f, 0.18727188f, 0.04277043f, 0.22153333f, -0.10935733f, 
    -0.16470017f, -0.21941723f, -0.02511614f, -0.13475257f, -0.09774505f, 0.01156849f, -0.99086350f, -0.28842446f, 
    0.54869336f, 0.59254974f, 0.54926926f, 0.75972420f, 0.15983041f, -0.90892023f, -0.51028293f, -0.34538382f, 
    -0.06818987f, 0.33594880f, -0.39284360f, -0.07689020f, -0.08226279f, 0.18882386f, -0.05734602f, 0.16593215f, 
    0.09555961f, 0.11016870f, -0.28333065f, -0.30370274f, 0.24726447f, 0.19980951f, 0.10666957f, 0.57503170f, 
    0.35027033f, -0.04099968f, -0.72782165f, -0.55971575f, -0.09697203f, -0.21288888f, 0.21437700f, -0.15377624f, 
    0.04816378f, 0.36201537f, -0.23757926f, 0.39828178f, 0.25692618f, -0.38354132f, 0.08360646f, -0.09616116f, 
    -0.06016828f, -0.13741261f, 0.02880242f, 0.08078173f, -0.06248572f, 0.04502425f, -0.05157777f, -1.26372170f, 
    -0.51841068f, -0.54174381f, -0.79340261f, -0.94911861f, 0.55693907f, 0.22240549f, 0.04378974f, 0.13054000f, 
    0.43345365f, 0.02212977f, -0.10605156f, -0.24527048f, -0.25289369f, 0.07600257f, -0.26337636f, 0.30165160f, 
    -0.18128335f, -0.13232014f, -0.14250053f, -0.11957487f, -0.08844464f, 0.11893520f, 0.10144634f, -0.00657623f, 
    -0.09457561f, -0.10607923f, -0.06350787f, -0.02943113f, 0.30859983f, 0.48784137f, -0.56457973f, -0.28735381f, 
    0.11646470f, 0.20189992f, -0.16650471f, -0.05371765f, -0.06292161f, -0.14365111f, 0.23128207f, -0.08923088f, 
    -0.06029830f, 0.04780465f, 0.38138232f, -0.30108446f, -0.05931164f, 0.02991319f, -0.10879746f, 0.17874064f, 
    0.01990768f, -0.38036969f, 0.00354114f, 0.38692442f, 0.03486694f, -0.50021958f, -0.06157354f, -0.47090599f, 
    0.33452258f, 0.26496249f, 0.25924984f, 0.07450117f, -0.13933612f, -0.27982366f, 0.79543716f, -0.37939236f, 
    0.07512052f, -0.18022932f, -0.26658508f, -0.20395401f, 0.35301372f, 0.35919216f, 0.16609092f, 0.19793776f, 
    -0.12480994f, -0.27914897f, 0.79044372f, -0.55505764f, -0.36325875f, -0.48773876f, -0.88707751f, 0.44575822f, 
    0.09613334f, -0.02943677f, 0.14459296f, 0.10402711f, 0.02176188f, -0.01861865f, 0.05187773f, 0.25356492f, 
    0.07686757f, -0.14902802f, -0.10312028f, -0.13172771f, 0.09100274f, -0.14614417f, 0.08251388f, -0.17810427f, 
    -0.15332313f, -0.09910730f, -0.27060473f, 0.66061437f, -0.16564445f, -0.16752584f, -0.19487771f, -0.50610274f, 
    0.50451308f, -0.11239670f, -0.10440183f, -0.38142514f, 0.22351100f, 0.04281632f, 0.15314347f, 0.03777744f, 
    -0.25293660f, 0.07893089f, 0.38484326f, 0.00395264f, 0.26746255f, 0.07237817f, -0.43323216f, 0.14605013f, 
    -0.38905349f, -0.30396631f, -0.05289458f, 0.13418059f, 0.18256390f, 0.47375661f, 0.33564749f, -0.08654239f, 
    -0.06071470f, -0.43453509f, 0.30194175f, -0.24289218f, -0.15248306f, 0.03426325f, -0.03543276f, -0.06007152f, 
    0.43019459f, -0.21697150f, -0.17812613f, 0.00057582f, -0.14845416f, 0.04654383f, 0.03439618f, 0.18679816f, 
    -0.08156548f, 0.17341758f, -0.17045544f, -0.13167967f, 0.24249762f, -0.31029862f, -0.71308225f, -0.39204586f, 
    -0.50465405f, -0.76018798f, 0.05380359f, 0.12855795f, -0.24044487f, -0.03820899f, 0.27241805f, -0.16240963f, 
    0.05631816f, -0.23692137f, -0.29865146f, -0.15706152f, 0.05901257f, 0.45622647f, -0.02381881f, -0.15292643f, 
    -0.25246057f, -0.04389268f, -0.17226905f, -0.12256531f, -0.11170522f, -0.25143293f, -0.56273347f, -0.22785933f, 
    0.05747213f, 0.34583423f, 0.25379744f, 0.19362785f, 0.18367030f, -0.10900481f, 0.32977387f, 0.09766490f, 
    -0.32627514f, 0.59398818f, -0.30212516f, -0.06941860f, -0.25585076f, 0.38510507f, 0.11187476f, -0.34811476f, 
    -0.38764077f, -0.03689975f, -0.20706259f, 0.27383769f, 0.06917447f, -0.06155078f, 0.13754047f, 0.06641610f, 
    0.97581941f, 0.57179177f, -0.60595220f, -0.35350755f, -0.54651493f, -0.15226418f, 0.54321003f, -0.17255689f, 
    -0.42716542f, 0.16027783f, -0.02252067f, -0.17980874f, -0.05243523f, -0.26974675f, 0.22817063f, -0.05720997f, 
    -0.01704059f, 0.31259626f, -0.23385493f, -0.11788113f, -0.11265618f, -0.11604150f, 0.18364283f, -0.37563115f, 
    0.06930290f, -0.64911842f, 0.12698905f, -0.19379026f, 0.10861293f, 0.22979900f, -0.07930849f, -0.33292702f, 
    -0.05071773f, 0.13505001f, 0.27427238f, 0.37956315f, 0.26329106f, -0.27452260f, 0.05537632f, -0.08181322f, 
    -0.14259130f, 0.17184371f, -0.09409167f, -0.36413226f, -0.04490848f, 0.43627727f, -0.11537413f, 0.24012394f, 
    -0.04592798f, -0.10666923f, -0.18979037f, -0.56978780f, -0.50231802f, -0.29597494f, 0.08896099f, 0.09885126f, 
    -0.06208988f, -0.23760431f, -0.25843143f, 0.38335067f, -0.10838315f, 0.60344297f, 0.07553042f, 0.04566270f, 
    -0.28929296f, -0.31724694f, -0.19745068f, -0.26129201f, -0.07655460f, 0.18386438f, 0.32776672f, 0.13429216f, 
    -0.09124390f, 0.26195568f, -0.38696891f, 0.26721030f, 0.34312376f, -0.09630409f, -0.00597512f, 0.15274546f, 
    0.03171891f, -0.19267410f, -0.20754448f, 0.03034060f, 0.09430266f, 0.11968838f, -0.19484515f, -0.12040640f, 
    0.25142899f, -0.14809638f, -0.16101655f, -0.11978972f, 0.16205475f, 0.20713809f, 0.21599133f, 0.11738564f, 
    0.13621745f, 0.03701410f, -0.37609640f, 0.23540379f, -0.48079342f, -0.22138782f, 0.33984154f, -0.39214963f, 
    -0.14372729f, -0.04669627f, -0.33251345f, -0.24455684f, 0.30452308f, 0.11307590f, 0.20570494f, -0.07322274f, 
    -0.28394681f, 0.34250203f, 0.03563945f, 0.01698015f, 0.09718592f, 0.12776200f, -0.09205087f, -0.14180952f, 
    -0.32383466f, -0.15353857f, -0.15957928f, -0.19135879f, -0.06577902f, -0.15669009f, -0.10455499f, 0.02628776f, 
    0.27274364f, -0.09628034f, 0.05223205f, 0.19085644f, 0.26801786f, -0.19419663f, -0.13857383f, 0.10175966f, 
    0.00599222f, -0.02132505f, -0.02732057f, -0.20393579f, 0.02480114f, 0.21008834f, 0.03226816f, -0.45352542f, 
    0.21574570f, 0.13123010f, -0.35774583f, 0.20734993f, 0.31462774f, -1.22115719f, 0.02030378f, 0.36996245f, 
    0.14665310f, 0.44277281f, -0.37324801f, -0.50324923f, -0.08642261f, 0.42744973f, 0.03685013f, -0.03329073f, 
    -0.29909179f, -0.18052609f, 0.00125901f, -0.00956035f, -0.12672450f, -0.38372195f, -0.13553265f, -0.36677250f, 
    -0.29478019f, -0.20061657f, -0.24409510f, -0.02152848f, -0.15761675f, -0.37757084f, -0.67054653f, -0.31597689f, 
    -0.03439064f, -0.37868124f, -0.56572109f, -0.14262331f, 0.07228851f, 0.33772039f, 0.13544051f, -0.00173321f, 
    -0.42018259f, -0.17117195f, 0.14133789f, 0.19260131f, -0.07982809f, 0.10207521f, 0.12834139f, 0.08217429f, 
    0.15120524f, 0.24711484f, 0.20549634f, -0.05292275f, 0.17072128f, 0.12550229f, -0.26277867f, 0.20240873f, 
    -0.35449296f, -0.57514304f, -0.22675805f, 0.03876557f, -0.29764262f, 0.04471856f, -0.38802463f, -0.37226218f, 
    -0.31153291f, -0.22913514f, -0.10730866f, 0.06659473f, -0.13579613f, -0.37360159f, -0.14029714f, 0.23842803f, 
    -0.27981770f, -0.34206340f, -0.23524567f, 0.01295883f, 0.19303052f, 0.32894623f, 0.00795806f, 0.19522069f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.19089364f, -0.13336739f, -0.09952204f, -0.05271705f, -0.31335464f, 0.16727492f, 0.35641330f, -0.03791290f, 
    -0.27732986f, 0.23664805f, 0.17966765f, 0.00629642f, 0.00139478f, -0.07103816f, -0.39324939f, -0.16689357f, 
    0.36649370f, -0.03180412f, 0.11250512f, 0.19687583f, 0.27979344f, 0.26470134f, 0.13498157f, 0.06340945f, 
    0.10566409f, -0.26107559f, 0.17245784f, -0.22296751f, 0.33150429f, 0.33587334f, 0.42361405f, 0.24145180f, 
    0.35791588f, 0.12430311f, 0.06395344f, 0.21059148f, 0.37432793f, -0.13634574f, 0.36415863f, 0.02402261f, 
    0.44155276f, 0.05070207f, 0.07317080f, -0.01775533f, 0.01082963f, 0.19874999f, 0.23842669f, 0.11331978f, 
    0.30209249f, 0.07092635f, 0.17669617f, 0.23128642f, 0.17416473f, -0.20740685f, 0.33080071f, 0.21742198f, 
    -0.05595823f, 0.08008838f, 0.18073238f, 0.12268218f, 0.10701483f, 0.10178786f, 0.07438339f, 0.20037565f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.43218926f, 0.13568108f, 0.05517576f, -0.19096974f, 0.12274836f, 0.13435616f, 0.12960510f, -0.04591354f, 
    -0.04470405f, 0.06412963f, 0.03032996f, -0.11295602f, 0.08295743f, 0.06196804f, -0.07370793f, 0.09314228f, 
    0.06223001f, 0.07487477f, -0.01401178f, 0.18439665f, 0.05201409f, 0.06948949f, 0.03703779f, 0.04970982f, 
    0.33471674f, 0.17196412f, 0.04688964f, -0.09703908f, 0.07439871f, -0.03175971f, 0.09187163f, -0.13377586f, 
    0.02596154f, 0.00051994f, 0.02326134f, -0.03289926f, -0.13820133f, -0.04320238f, -0.08548889f, -0.05032318f, 
    0.05089316f, 0.02695906f, 0.04284339f, 0.00427727f, 0.00519029f, 0.00694310f, -0.03666320f, -0.07568718f, 
    0.29437798f, 0.27794734f, 0.13275470f, -0.13961305f, 0.07717599f, -0.01040336f, 0.05244632f, 0.02349595f, 
    -0.04309660f, 0.04464101f, -0.06569931f, 0.05991499f, 0.04481931f, 0.03538029f, -0.04886872f, -0.00838247f, 
    0.11070333f, -0.09649719f, -0.14858122f, -0.12513913f, -0.05991831f, -0.08230525f, -0.02580369f, -0.12397901f, 
    0.28796652f, 0.28583828f, -0.06411365f, -0.31132793f, -0.04785647f, -0.00170179f, 0.01786855f, 0.03568064f, 
    0.02298235f, -0.02548638f, 0.00412426f, -0.00686939f, -0.25862294f, -0.16512126f, -0.02046114f, 0.06646916f, 
    -0.03674030f, 0.01619245f, 0.03449385f, -0.08336616f, 0.05581534f, 0.10222509f, -0.01313510f, 0.13949338f, 
    -0.01396600f, -0.01484753f, 0.05302260f, 0.03326906f, 0.01051060f, -0.00127421f, -0.07418191f, -0.09654156f, 
    -0.06010308f, -0.03567784f, -0.00694475f, -0.01842336f, -0.24823685f, -0.00176561f, 0.25691962f, -0.11766507f, 
    -0.04597454f, -0.06582896f, 0.03514501f, -0.04350453f, -0.11815280f, -0.18627432f, -0.04202431f, -0.05668522f, 
    -0.32728741f, -0.16615796f, 0.01932782f, 0.11528572f, 0.01547871f, -0.02360638f, -0.04115842f, -0.03530420f, 
    -0.12171666f, -0.15052459f, -0.04281619f, -0.11134209f, -0.03661968f, 0.02820229f, -0.00999978f, -0.02245138f, 
    -0.00251218f, -0.09298318f, -0.19534284f, 0.05647175f, 0.07060707f, 0.02601696f, 0.05197837f, -0.03832464f, 
    0.05097062f, 0.06257185f, -0.31577086f, -0.04882146f, -0.09721816f, 0.01624146f, 0.11169494f, -0.03808970f, 
    -0.02548120f, 0.02636219f, 0.02430695f, -0.09693155f, 0.18993184f, 0.21018593f, -0.15843940f, -0.10328222f, 
    -0.12658328f, 0.12389378f, -0.08060180f, 0.14793031f, -0.02867533f, 0.01205565f, 0.00711197f, -0.03589869f, 
    0.38544133f, 0.19392322f, 0.07935671f, -0.19943982f, 0.20934455f, 0.05317443f, 0.06312931f, 0.15826067f, 
    -0.03349571f, -0.02066457f, -0.00807546f, -0.01138689f, -0.06026908f, -0.41148859f, 0.00007997f, 0.10291298f, 
    0.04466442f, 0.03398097f, -0.03719049f, -0.01507797f, -0.06455448f, -0.19196726f, -0.08014368f, 0.14539696f, 
    -0.25410467f, -0.62719411f, -0.31958303f, 0.13326672f, -0.12194866f, 0.03483769f, -0.02678202f, -0.13079609f, 
    -0.13087419f, -0.01974195f, -0.01400799f, -0.07939742f, 0.23256975f, 0.20668140f, 0.12098613f, -0.07310133f, 
    -0.02339258f, 0.08766165f, 0.02153419f, -0.02443031f, 0.05822826f, 0.02375976f, 0.03867971f, -0.11878846f, 
    -0.02108720f, 0.00149503f, 0.07635483f, 0.04640819f, -0.15671216f, -0.12245952f, 0.01512080f, -0.06925002f, 
    -0.26340830f, 0.01505648f, -0.00778243f, -0.07488113f, 0.02626177f, 0.06937301f, -0.11783288f, 0.04743040f, 
    -0.04389007f, 0.01540584f, 0.00453323f, -0.17100939f, -0.17778008f, -0.08135708f, 0.02327975f, -0.11152095f, 
    -0.56897247f, -0.00793627f, -0.01835162f, 0.18161803f, 0.00197500f, 0.01140224f, -0.07437179f, 0.07377528f, 
    -0.07488386f, 0.03942022f, 0.01091250f, 0.02321541f, 0.05706325f, 0.16918562f, -0.39958978f, -0.11576516f, 
    -0.07217788f, -0.13746102f, -0.02291844f, -0.18443178f, -0.13167824f, -0.10683790f, 0.09192728f, 0.04973203f, 
    0.15125328f, -0.00249862f, -0.19187242f, -0.06509495f, 0.03320239f, -0.14393476f, 0.08764949f, -0.08109898f, 
    0.00787097f, 0.04415191f, 0.06588820f, 0.04053521f, 0.22703992f, 0.12014855f, -0.12026476f, -0.01431595f, 
    0.07765183f, 0.10306470f, 0.05487094f, -0.06636912f, -0.04387536f, 0.01295784f, -0.04183422f, 0.13084963f, 
    0.42360657f, 0.36993191f, -0.11882864f, -0.24991089f, -0.03348432f, -0.07706723f, -0.01457646f, 0.01665562f, 
    -0.01170724f, 0.01388733f, 0.03341609f, -0.07090557f, 0.29955065f, 0.19248831f, -0.20770751f, -0.15213832f, 
    0.19082429f, 0.13178913f, 0.01272896f, -0.05888358f, -0.01851748f, -0.08298307f, -0.03305769f, -0.04860779f, 
    -0.49696457f, -0.19306639f, -0.02953660f, 0.06746753f, 0.00341066f, 0.03392569f, 0.01453665f, 0.02580976f, 
    -0.04578851f, 0.05757074f, -0.07734984f, -0.01219639f, 0.26109639f, 0.06027735f, -0.05787316f, -0.22028609f, 
    0.04495574f, -0.00725562f, -0.02257478f, 0.07389668f, -0.02887593f, 0.00955354f, 0.01225890f, -0.01075545f, 
    0.13757519f, 0.07078644f, -0.12161028f, -0.04283101f, 0.08089361f, 0.10587014f, -0.03446214f, -0.00408738f, 
    -0.07443397f, -0.09643685f, -0.14709644f, -0.09513535f, -0.05453400f, 0.01753938f, 0.13428590f, -0.20119123f, 
    0.03815852f, -0.08333711f, -0.15091597f, -0.10026616f, -0.03447152f, -0.11209168f, -0.08193871f, 0.00478655f, 
    -0.11483321f, -0.41945574f, -0.07880826f, 0.08087609f, -0.01868209f, 0.07584921f, -0.04599248f, -0.16589101f, 
    0.09704410f, -0.11679151f, -0.00560792f, -0.13345753f, 0.03189123f, 0.12763280f, 0.08369040f, -0.14109147f, 
    -0.03251074f, -0.05061162f, 0.02778014f, 0.02279201f, 0.07891858f, 0.00533920f, -0.02057675f, -0.00375056f, 
    -0.03358993f, 0.04586292f, 0.34251487f, -0.28387284f, -0.04264750f, -0.05386747f, 0.09937926f, -0.02265306f, 
    -0.06302493f, -0.11522599f, -0.03865071f, -0.18385540f, 0.17103204f, 0.06943572f, 0.06817960f, 0.01861018f, 
    0.01018122f, 0.09241765f, -0.02825273f, 0.03827431f, 0.04401505f, 0.01926677f, 0.00415384f, 0.06141863f, 
    0.07360043f, 0.03458463f, -0.37244248f, -0.04798808f, 0.05649133f, 0.01323155f, -0.07797542f, -0.08636124f, 
    0.02065606f, -0.01785632f, -0.00814991f, 0.03421596f, -0.08849458f, 0.15801327f, 0.13685980f, -0.12227719f, 
    -0.11112496f, 0.07169467f, -0.17879544f, 0.07882018f, -0.14127640f, -0.01075377f, -0.06892700f, -0.12321106f, 
    -0.05649473f, -0.29596251f, -0.29636878f, 0.08547621f, 0.02281302f, -0.06753962f, -0.02850839f, -0.04935633f, 
    -0.11716544f, -0.10767864f, -0.23797220f, -0.00886771f, 0.06060168f, 0.02040544f, -0.00282194f, 0.03111382f, 
    0.01384744f, 0.01090880f, 0.05991064f, 0.00120261f, -0.20296244f, -0.08650463f, 0.00175280f, 0.06573863f, 
    -0.12483364f, -0.20086139f, -0.02275903f, 0.03251085f, 0.04134608f, -0.02128682f, 0.03879815f, -0.00285424f, 
    -0.08058970f, -0.08784225f, -0.06493807f, 0.11514772f, -0.09490770f, -0.12783335f, 0.03911611f, 0.03478039f, 
    0.03760725f, 0.01394127f, 0.10959589f, -0.09582181f, -0.02197517f, -0.00107342f, -0.00029818f, 0.03423231f, 
    0.24431960f, 0.18459694f, -0.23423027f, -0.17065574f, -0.01983482f, -0.17615598f, -0.09268432f, 0.00228264f, 
    -0.06794836f, -0.04754340f, 0.07869881f, -0.06532696f, 0.00377917f, 0.07843395f, -0.01471848f, -0.00834301f, 
    -0.14286244f, -0.10327166f, 0.11385551f, 0.01901896f, -0.10099635f, -0.03154315f, -0.14814925f, -0.17356369f, 
    -0.19365478f, 0.10864861f, 0.17481546f, -0.29991740f, -0.01237150f, -0.11747129f, -0.08618023f, -0.05541816f, 
    0.03751714f, -0.02712244f, 0.01645436f, 0.03769288f, -0.04696082f, -0.09302567f, 0.03197652f, 0.05487335f, 
    0.04453342f, -0.01445905f, 0.03564043f, 0.03602206f, -0.14748158f, -0.14038573f, -0.01127345f, -0.03567481f, 
    -0.13919158f, 0.27109993f, 0.19359666f, -0.05836952f, -0.03214749f, -0.00314312f, 0.05747275f, 0.03546955f, 
    0.00864225f, -0.11361652f, -0.05466221f, 0.01463105f, 0.51315826f, -0.32075685f, -0.24425837f, 0.01870843f, 
    -0.04019154f, -0.04757646f, 0.13691284f, -0.05251244f, -0.07516798f, -0.06505527f, 0.04331932f, -0.02171223f, 
    0.10342637f, -0.28560698f, 0.07726353f, -0.13493899f, -0.15390266f, 0.01988707f, -0.10368876f, 0.00625871f, 
    -0.02038538f, -0.01489040f, -0.03777907f, -0.07410806f, 0.16870795f, 0.05071484f, -0.02257021f, -0.11049967f, 
    0.03292606f, 0.18432316f, -0.08481942f, -0.03552482f, -0.00373228f, -0.00035961f, 0.01129678f, -0.02747281f, 
    -0.08016501f, 0.17326944f, -0.08601542f, -0.02404488f, -0.16070171f, -0.07223333f, 0.01888292f, 0.00711091f, 
    -0.03318568f, -0.08684062f, 0.02090885f, -0.04361463f, -0.27150863f, -0.16370706f, 0.27708107f, -0.28259936f, 
    -0.09576208f, 0.00730995f, -0.10743800f, 0.11618721f, 0.05521073f, -0.07970341f, -0.10221206f, -0.01144239f, 
    -0.00217506f, -0.19882984f, -0.16162612f, 0.07758860f, 0.03133391f, 0.02177525f, -0.04200027f, -0.02217065f, 
    0.10143761f, 0.04222802f, -0.06422012f, 0.01407662f, -0.05297704f, -0.00644256f, -0.17840059f, 0.05770988f, 
    -0.04460664f, -0.03333281f, -0.16197096f, -0.09646571f, -0.09522778f, -0.04677813f, 0.03337909f, 0.10111248f, 
    -0.26985225f, -0.21849291f, -0.10617618f, 0.14916340f, 0.04293286f, -0.00197259f, -0.00500208f, -0.02556760f, 
    -0.03488148f, 0.05607459f, -0.00159459f, -0.01449290f, 0.26346850f, 0.20096827f, -0.00933005f, -0.04323270f, 
    0.18998535f, 0.09757966f, 0.08427735f, -0.00709320f, -0.04905400f, 0.01166643f, -0.01790976f, 0.04591585f, 
    -0.23533240f, 0.00170206f, 0.02198606f, -0.20577972f, 0.01495403f, -0.00592471f, 0.10930735f, 0.01028594f, 
    -0.14994650f, 0.11065962f, 0.01326304f, -0.25195843f, -0.29868668f, -0.05711336f, -0.06393100f, 0.13711116f, 
    -0.14838845f, 0.03489255f, -0.10748115f, -0.14173837f, 0.00537444f, 0.01012063f, -0.05136955f, 0.05800391f, 
    0.05128543f, 0.11656411f, -0.04386918f, -0.01786393f, 0.05209782f, 0.13144673f, -0.00461684f, -0.13405071f, 
    0.02407397f, -0.16567022f, -0.02280380f, 0.00285672f, 0.24290808f, 0.21804790f, -0.27323583f, -0.11843704f, 
    0.13089663f, -0.01407362f, 0.03824353f, -0.03083742f, -0.08376072f, -0.10012071f, -0.03778126f, -0.03316632f, 
    -0.10888959f, -0.05288794f, -0.02056168f, 0.03345553f, -0.21303415f, 0.00531713f, 0.08242176f, 0.02190452f, 
    -0.04483145f, 0.01494748f, -0.04104980f, -0.10913329f, -0.00762299f, 0.12579556f, 0.09260257f, 0.01818115f, 
    0.06455273f, -0.05059936f, 0.03732507f, -0.06210046f, -0.02053846f, 0.04298230f, 0.06853874f, 0.13097745f, 
    -0.02161730f, 0.04231219f, 0.02669989f, 0.05296616f, 0.03802747f, 0.01062459f, -0.00191418f, 0.03198266f, 
    -0.02679504f, -0.12613174f, -0.03485973f, -0.21457691f, 0.20751752f, 0.16254908f, 0.25996062f, -0.12415131f, 
    -0.16482468f, 0.04075566f, -0.00991155f, 0.02474272f, -0.15232638f, -0.08540180f, -0.02549740f, -0.02828264f, 
    0.05945858f, 0.02704544f, 0.11391866f, 0.02197335f, 0.00554621f, 0.20461641f, -0.00625142f, -0.09053402f, 
    0.00110843f, 0.05053919f, 0.03840516f, 0.03966254f, 0.20818911f, 0.10126244f, -0.16659738f, -0.18717968f, 
    0.15008378f, 0.00148954f, 0.02470471f, -0.02190898f, -0.05867175f, -0.01847928f, -0.06829937f, -0.04910998f, 
    0.01250925f, 0.10893480f, -0.14173181f, 0.02848371f, 0.05654744f, 0.12237857f, -0.03729969f, -0.22723658f, 
    -0.01454327f, 0.00168163f, -0.05778060f, -0.04740927f, 0.02387904f, -0.00539744f, -0.04578289f, -0.24508961f, 
    -0.12452612f, -0.04704974f, -0.14188789f, 0.01759369f, -0.01589965f, -0.01746916f, -0.02118081f, 0.05489736f, 
    0.04421566f, 0.08773608f, -0.05389005f, -0.08016711f, -0.10447405f, 0.07969469f, -0.06222447f, -0.00436322f, 
    0.15618695f, -0.31742316f, -0.12134929f, -0.01181994f, 0.19059880f, 0.07696494f, 0.19273837f, 0.11364713f, 
    -0.02373551f, -0.06820884f, 0.01389261f, -0.00351749f, -0.03520682f, -0.00928825f, -0.03901905f, 0.03213058f, 
    0.08627290f, 0.32919520f, -0.10587606f, -0.18055315f, 0.01956280f, -0.09867183f, -0.20892261f, 0.13700125f, 
    -0.06257173f, -0.04064474f, 0.03318512f, 0.03383600f, 0.00052264f, -0.21877441f, 0.11766846f, -0.13079824f, 
    0.02901042f, 0.10155090f, 0.14731809f, -0.08649821f, -0.00324328f, -0.08993703f, -0.04640580f, 0.15138820f, 
    -0.29131341f, 0.06105244f, -0.05823707f, 0.15184736f, -0.07872599f, -0.04854305f, 0.10381305f, -0.06777097f, 
    -0.06240044f, -0.00123475f, -0.00008372f, 0.03729436f, 0.22839391f, 0.04587973f, 0.04073009f, 0.03312008f, 
    -0.00347432f, -0.00789006f, -0.07182153f, -0.16115399f, -0.23358828f, -0.17571370f, -0.29759991f, -0.16044679f, 
    -0.05145982f, 0.02121231f, -0.04319904f, -0.09250288f, 0.02340910f, -0.04519320f, 0.02268078f, -0.00328597f, 
    -0.12641768f, -0.10238574f, 0.02189980f, -0.06539962f, -0.22763214f, -0.01418723f, 0.06648237f, -0.08252586f, 
    0.03549359f, 0.00590573f, 0.02924906f, 0.07336622f, 0.00088053f, 0.18631361f, 0.01690440f, -0.08980755f, 
    0.44278061f, -0.11829584f, -0.00893530f, -0.13331723f, -0.01074915f, -0.00190652f, -0.03053583f, 0.01518628f, 
    -0.08169043f, 0.05924646f, -0.06322581f, -0.09823981f, 0.15884893f, -0.06837877f, -0.14934617f, -0.10011093f, 
    0.11176960f, -0.00231062f, -0.01982539f, -0.00173012f, 0.00017200f, 0.08616774f, -0.02599102f, -0.04580009f, 
    0.03878682f, -0.00285278f, -0.07452764f, -0.01562291f, 0.02934130f, -0.01768801f, 0.01078047f, 0.05282041f, 
    -0.16046380f, -0.02796916f, 0.11502799f, -0.04129840f, -0.18572707f, -0.25241083f, -0.10052184f, -0.19145538f, 
    -0.17037161f, -0.06740160f, 0.03761257f, 0.33985588f, -0.05244358f, -0.02307052f, -0.01224431f, 0.12848385f, 
    0.07689740f, 0.17303774f, 0.20818760f, 0.05062615f, -0.12462615f, -0.10944656f, -0.03850086f, -0.36744365f, 
    -0.01485637f, -0.01049639f, -0.00007461f, 0.03074342f, -0.06844250f, 0.28625515f, -0.20254844f, -0.34479228f, 
    -0.05793928f, 0.02966064f, 0.01748118f, 0.05352671f, -0.08465979f, -0.04054290f, -0.19322546f, -0.35301515f, 
    0.56728822f, -0.07019305f, -0.02219444f, -0.06816343f, -0.07121826f, -0.09861173f, 0.09565580f, 0.01961834f, 
    -0.00469660f, -0.01319115f, -0.10586128f, 0.05854949f, 0.03533595f, 0.19913946f, -0.10855220f, 0.00983875f, 
    -0.03978235f, -0.04060430f, -0.00808823f, 0.01696244f, -0.23935680f, 0.00594266f, -0.21499658f, 0.06328634f, 
    0.18859144f, -0.06041580f, 0.08776779f, 0.03105708f, -0.06926210f, 0.04349657f, -0.05659683f, 0.00188494f, 
    -0.06550077f, 0.15835248f, -0.00683929f, -0.03827152f, 0.09475844f, -0.22865579f, -0.06002267f, 0.19353740f, 
    0.03901829f, -0.07831000f, 0.08164363f, 0.12084134f, 0.07222906f, 0.05844773f, 0.03570911f, 0.10232058f, 
    0.16234341f, -0.02272894f, 0.10953947f, -0.04528647f, 0.03867842f, -0.01597672f, -0.07102147f, 0.02704473f, 
    0.09533253f, 0.00022347f, -0.03378920f, 0.02398754f, 0.35555878f, -0.25739005f, 0.30444872f, -0.15490814f, 
    -0.12104858f, -0.05644307f, -0.05324424f, -0.13047355f, 0.11351172f, 0.10552195f, 0.02932173f, -0.28644359f, 
    0.06946950f, -0.06949265f, 0.05805296f, -0.43425673f, -0.12979175f, 0.04330101f, -0.17962676f, 0.02203353f, 
    -0.04605474f, 0.00925587f, 0.03916131f, 0.07855465f, 0.20783162f, -0.17521326f, -0.24190661f, -0.10733981f, 
    -0.08996020f, 0.01427446f, 0.02737994f, -0.04912993f, -0.04916063f, -0.19678947f, -0.17250687f, -0.03262411f, 
    -0.38639995f, 0.05608804f, -0.28311846f, -0.00350323f, 0.15530474f, -0.17295806f, 0.07634641f, 0.27109659f, 
    0.03305726f, -0.04763541f, -0.01860007f, 0.00811632f, 0.10153393f, 0.00846032f, 0.15540332f, 0.14788909f, 
    -0.06611817f, 0.15073186f, 0.06803588f, 0.14620495f, -0.02734783f, 0.00798169f, -0.04124762f, 0.03890816f, 
    0.13525183f, 0.15650783f, 0.09454778f, 0.04515470f, 0.04423903f, -0.00244945f, -0.01589162f, 0.00792968f, 
    0.00231075f, 0.08741996f, -0.12259505f, 0.17534901f, 0.08038092f, 0.13591547f, 0.26268429f, -0.10692485f, 
    -0.08337575f, -0.06500140f, 0.03283155f, -0.04594041f, 0.01018137f, 0.01501202f, 0.03954262f, 0.03252489f, 
    0.06209219f, -0.13519064f, -0.35262227f, -0.30369502f, -0.08107768f, -0.01170617f, 0.03452898f, 0.11973950f, 
    -0.01329283f, 0.06636446f, 0.07895827f, 0.04493972f, -0.26172665f, -0.01142802f, -0.12770124f, -0.24391150f, 
    0.06973634f, 0.11902143f, 0.08469751f, -0.08031276f, -0.04497444f, 0.01973470f, -0.01273664f, 0.11136638f, 
    0.24930607f, -0.17287757f, 0.20629844f, -0.19860625f, 0.05966653f, 0.10042840f, 0.11123914f, -0.02508105f, 
    -0.05845773f, 0.19407041f, -0.10995191f, 0.12106960f, -0.09461220f, 0.19739580f, -0.07713926f, -0.08733158f, 
    -0.11012898f, 0.11397303f, 0.00958843f, -0.02572831f, 0.08797572f, 0.00760539f, 0.01714033f, 0.01502778f, 
    -0.69755489f, 0.21500504f, -0.01205873f, -0.03611437f, -0.11554083f, 0.12177062f, 0.10835264f, -0.09812698f, 
    0.07129251f, -0.09295916f, 0.05438964f, 0.14797470f, -0.18544033f, -0.00074706f, -0.01054668f, -0.02618672f, 
    0.10136104f, -0.00202241f, 0.03712536f, 0.07072621f, -0.00980231f, 0.03044387f, 0.03936599f, -0.06195023f, 
    0.38256958f, 0.10071643f, 0.06134829f, -0.20787053f, -0.04242545f, -0.12393901f, 0.07383849f, -0.03733994f, 
    -0.00750361f, -0.04107070f, -0.00941657f, 0.00843499f, -0.00206670f, 0.17756884f, 0.01873075f, 0.00019199f, 
    0.26636264f, 0.07762451f, -0.09314245f, -0.05289790f, 0.06975029f, 0.09792152f, 0.06415983f, -0.21112731f, 
    0.46054414f, -0.04400025f, -0.06938425f, -0.07595854f, -0.05094172f, 0.12027711f, 0.03893539f, -0.02551715f, 
    -0.01722958f, 0.09842853f, -0.08895058f, -0.10008618f, -0.05894499f, -0.11570532f, -0.02814588f, -0.07649322f, 
    -0.00955804f, -0.00770997f, 0.01858230f, 0.08552567f, 0.10505967f, -0.15547101f, 0.00957863f, -0.04365589f, 
    -0.40474436f, -0.15471131f, 0.19220883f, -0.06247296f, 0.01695686f, 0.07685720f, -0.03781498f, 0.06217054f, 
    0.24866582f, 0.06148790f, -0.00928533f, -0.01444338f, 0.10927296f, 0.04877406f, -0.00121475f, 0.01326325f, 
    -0.02731111f, -0.09976418f, -0.06659912f, 0.06617932f, 0.10405874f, -0.09517249f, 0.02008359f, -0.05804379f, 
    -0.13143508f, -0.24339682f, -0.29925701f, 0.09658451f, 0.12806131f, 0.06976639f, 0.05459423f, 0.01383915f, 
    0.13268651f, 0.06454523f, -0.14171395f, 0.07717526f, -0.03130424f, 0.00272061f, 0.02984356f, 0.07499216f, 
    0.12225187f, 0.08131635f, 0.03486399f, -0.02561519f, 0.00875267f, 0.04407924f, -0.12530464f, -0.06540431f, 
    -0.21338078f, 0.06144568f, -0.16815107f, -0.17118619f, 0.06908854f, -0.25670350f, -0.03702941f, 0.12104779f, 
    -0.06411113f, 0.03121928f, 0.01185176f, 0.00447048f, 0.23540874f, 0.14564614f, 0.16040815f, 0.12691540f, 
    -0.06930314f, -0.01959538f, -0.05132134f, -0.08307511f, 0.11148714f, 0.05269450f, 0.01812216f, 0.00520338f, 
    -0.58357072f, 0.17967908f, -0.01083722f, -0.03049840f, 0.06373550f, 0.04375063f, -0.35932806f, -0.19796531f, 
    0.02938970f, -0.09194431f, -0.04456185f, 0.02621257f, 0.25204811f, -0.26394796f, 0.11871830f, 0.23281544f, 
    -0.02819099f, -0.04651017f, 0.17482720f, -0.04265672f, 0.27829853f, -0.06725720f, 0.08853696f, 0.02664537f, 
    0.04379601f, -0.18162832f, -0.07739837f, -0.12101416f, -0.04365687f, 0.06047032f, -0.03676866f, 0.07679020f, 
    0.07363686f, -0.01591036f, -0.04310242f, 0.09579599f, 0.37649813f, 0.20472319f, 0.07418694f, -0.23254389f, 
    0.10962128f, 0.05653535f, -0.07696062f, -0.21545827f, -0.02622826f, 0.03802599f, -0.08562901f, -0.12099665f, 
    -0.04599709f, 0.10665967f, -0.04096328f, 0.09666251f, -0.02473876f, 0.04675596f, -0.01107509f, 0.01955231f, 
    -0.06862962f, 0.02920464f, 0.06559939f, -0.02552097f, -0.21731947f, -0.12981369f, -0.13433430f, -0.18568031f, 
    0.08347753f, -0.04191489f, -0.04078067f, 0.07801320f, -0.08852504f, -0.26883075f, 0.21590634f, 0.03287761f, 
    0.27901793f, -0.18115917f, -0.10325889f, -0.11903505f, 0.01181969f, 0.05437344f, -0.00448651f, -0.02229596f, 
    -0.01117164f, -0.08226414f, 0.16085365f, 0.05332879f, 0.18469876f, -0.10502194f, 0.05911310f, -0.14946061f, 
    0.10379537f, 0.03453088f, -0.02507440f, -0.27938330f, 0.12877180f, -0.05357274f, 0.06581661f, 0.09547476f, 
    0.32942650f, 0.08625582f, 0.04386885f, -0.01179888f, -0.03646846f, 0.04112808f, -0.06071440f, 0.00694050f, 
    -0.03496471f, 0.03335466f, 0.04990355f, -0.01172369f, 0.30652618f, 0.18755862f, 0.13230465f, -0.02113913f, 
    -0.00049178f, -0.00362164f, -0.23598488f, -0.09014426f, -0.01220860f, 0.01054565f, -0.12146755f, -0.08320199f, 
    0.03060886f, 0.06459448f, 0.07859141f, 0.18696284f, -0.02494444f, 0.01784982f, -0.01876156f, 0.06748753f, 
    -0.06734346f, 0.13866848f, -0.11425689f, 0.12688793f, 0.01290196f, -0.29454786f, 0.35355330f, -0.24523388f, 
    0.06214653f, -0.05096943f, 0.04700972f, -0.06257454f, 0.04966246f, -0.15242681f, -0.01273057f, 0.02339116f, 
    0.03064028f, -0.07130446f, -0.11626005f, 0.01001159f, -0.01707213f, -0.01738329f, 0.05514938f, 0.10272051f, 
    -0.26979810f, 0.10504704f, 0.00461268f, 0.05658036f, -0.17507075f, -0.15543835f, -0.02083346f, 0.04042722f, 
    0.02512787f, 0.17401703f, 0.03389915f, 0.13685916f, -0.06339882f, -0.05322395f, 0.01266675f, 0.02807049f, 
    0.05933356f, -0.02622757f, -0.00123676f, -0.00391983f, 0.17063335f, -0.09706190f, -0.01701366f, 0.10468345f, 
    -0.03364863f, -0.03392470f, 0.07710556f, -0.00479774f, -0.07992292f, -0.02117527f, -0.02647973f, -0.06152747f, 
    -0.04848103f, 0.04588357f, -0.02189840f, 0.01412621f, 0.20929727f, -0.20272182f, 0.14813071f, -0.07849958f, 
    -0.03688734f, 0.06197257f, 0.07884634f, 0.05601695f, -0.01410287f, 0.08826781f, 0.05750550f, 0.00731663f, 
    0.04366502f, 0.04827666f, -0.08320206f, 0.04462554f, -0.28123689f, -0.02545210f, -0.27501926f, -0.22140715f, 
    0.13334242f, -0.01180537f, -0.00804976f, 0.06897192f, -0.07725021f, 0.09415226f, -0.18509576f, -0.29015332f, 
    -0.13611302f, 0.08279341f, 0.12873498f, 0.01768008f, -0.07356445f, -0.02115237f, -0.06307086f, -0.07559334f, 
    -0.08474112f, -0.03938408f, -0.03326950f, -0.00594302f, 0.06377157f, 0.03901438f, -0.02396481f, 0.05504556f, 
    0.04290452f, -0.02608222f, 0.22059381f, -0.02749222f, -0.05038740f, 0.01028142f, -0.01389101f, -0.00927060f, 
    0.04650415f, -0.02085329f, 0.24403907f, 0.33581296f, -0.02298546f, -0.10377757f, 0.12752035f, 0.08977784f, 
    0.00186250f, 0.02811053f, -0.02581139f, -0.01153996f, -0.06930128f, -0.18998957f, 0.02118728f, -0.34372750f, 
    0.05274978f, -0.06852997f, -0.08737229f, -0.28794345f, 0.01156908f, -0.03318992f, 0.07234055f, -0.01291268f, 
    -0.04422550f, -0.04162882f, -0.06362732f, 0.07564127f, 0.00812883f, 0.02049555f, 0.00004767f, 0.02418257f, 
    0.05430412f, 0.05044268f, -0.03808775f, 0.00730545f, -0.17660108f, -0.33913302f, -0.21197538f, -0.05860367f, 
    -0.04599562f, -0.02843650f, 0.06113986f, -0.00694376f, -0.01969424f, -0.07889563f, -0.02673560f, 0.16549584f, 
    -0.61062437f, -0.05325287f, -0.04564623f, 0.07961811f, -0.00758554f, 0.09878170f, -0.07447656f, -0.06116165f, 
    0.00278599f, 0.07381801f, -0.13221732f, -0.09493918f, 0.06750964f, 0.22749951f, 0.02936533f, -0.19123086f, 
    0.06403505f, 0.09557264f, 0.01202829f, -0.01353857f, -0.03642868f, -0.00761719f, -0.03000806f, -0.00219947f, 
    -0.36266488f, -0.31938350f, -0.35227093f, -0.15337349f, 0.04563276f, -0.02293163f, -0.01951982f, 0.14793293f, 
    0.02683153f, 0.06916624f, -0.01191219f, -0.00717130f, -0.03772329f, 0.11712164f, 0.04078209f, 0.07177542f, 
    -0.04738169f, 0.01327269f, 0.01391619f, -0.05957051f, 0.13597770f, 0.19029821f, 0.04565426f, 0.15824883f, 
    -0.04287788f, 0.00675088f, 0.00642415f, 0.02379453f, -0.05749104f, -0.00379845f, 0.06613251f, -0.07210995f, 
    0.06277803f, 0.00708087f, -0.03930056f, 0.00370509f, -0.08368811f, 0.04148804f, -0.25190464f, -0.00269032f, 
    0.12234250f, 0.10014752f, -0.06981681f, 0.05146324f, 0.05428038f, 0.03470700f, -0.04643175f, -0.03488033f, 
    -0.11055643f, 0.05304210f, 0.07518943f, -0.07084747f, -0.02788880f, -0.02861080f, -0.00798445f, -0.05027819f, 
    0.03652205f, 0.17434917f, -0.39102277f, 0.29045483f, -0.05665812f, -0.06246316f, 0.03533126f, -0.19624111f, 
    -0.00534181f, -0.03222722f, -0.28490379f, -0.22382551f, -0.03818764f, 0.07488526f, -0.00193476f, -0.03963597f, 
    -0.04497869f, 0.04813571f, 0.07661044f, -0.12932177f, 0.08318807f, -0.36330888f, -0.05421157f, -0.00796603f, 
    -0.05425298f, 0.00417849f, 0.04503306f, -0.08105069f, -0.28808409f, -0.64039719f, 0.02056668f, -0.33114973f, 
    0.10993578f, -0.07175194f, -0.03079856f, -0.16071665f, 0.06735668f, -0.00540372f, 0.00304763f, 0.05192010f, 
    -1.02140355f, -0.52797192f, -0.25494492f, -0.28360745f, -0.14936784f, -0.08342003f, 0.05195102f, -0.05621803f, 
    0.02628035f, -0.05959581f, 0.03642907f, -0.02443609f, -0.20810162f, 0.30684289f, 0.16154554f, 0.15244152f, 
    0.00688827f, -0.00904097f, -0.00724694f, -0.03130656f, -0.00526985f, 0.00394923f, 0.05985024f, -0.08638860f, 
    -0.09447021f, 0.12631220f, 0.00026861f, -0.36975944f, -0.10560951f, -0.01286858f, -0.26864246f, 0.08540236f, 
    0.00926977f, -0.13075221f, 0.02941355f, 0.06239783f, -0.00944167f, 0.06163533f, -0.06864664f, 0.26264188f, 
    0.03539044f, -0.05362745f, 0.00276216f, 0.10529732f, 0.00592208f, -0.05930192f, 0.06510573f, 0.02364906f, 
    -0.01459597f, -0.00992454f, 0.03791122f, 0.04005890f, 0.00947591f, -0.04804100f, -0.05711797f, 0.05635061f, 
    0.15043315f, 0.00449576f, -0.02401722f, 0.02490193f, -0.01728023f, -0.06840589f, 0.00702637f, -0.16605103f, 
    0.03213710f, -0.25880146f, -0.04547438f, 0.27595115f, -0.04951214f, -0.05714576f, 0.07114661f, -0.07000142f, 
    0.16796452f, -0.13640566f, 0.03166965f, -0.27970532f, 0.03507441f, 0.00011671f, 0.04705488f, 0.00526926f, 
    0.03186025f, 0.09690707f, -0.09653948f, 0.07133282f, -0.37053564f, -0.04527399f, 0.19384918f, -0.23785397f, 
    0.00767231f, 0.08893905f, -0.02694957f, -0.14357559f, -0.01537969f, 0.09010238f, -0.01256094f, -0.12863679f, 
    0.01491964f, -0.03356244f, 0.18309602f, -0.39416170f, 0.21752879f, 0.10925307f, -0.13438988f, -0.02454439f, 
    0.04192332f, 0.12309107f, 0.00657550f, -0.03333066f, -0.00813684f, 0.08984208f, 0.37151682f, 0.18199255f, 
    0.00295002f, -0.04705816f, 0.03598727f, 0.04132101f, 0.01354610f, 0.02032128f, 0.11586030f, -0.10313562f, 
    -0.18538840f, 0.24003024f, -0.39166999f, -0.07601052f, 0.04169373f, -0.24510846f, -0.19510925f, 0.11557358f, 
    -0.02373753f, 0.09634674f, -0.02755613f, -0.05841372f, -0.47135788f, -0.11463960f, 0.06901661f, -0.42605692f, 
    -0.06744263f, -0.08095706f, 0.00792555f, -0.15518245f, -0.06691100f, -0.07250068f, -0.03505870f, -0.00097402f, 
    -0.06396191f, -0.03635493f, 0.09088895f, -0.03754741f, -0.00441588f, 0.01370306f, 0.02385295f, 0.00636068f, 
    0.01493251f, -0.11854175f, 0.17379163f, 0.14463462f, -0.71200526f, -0.18739888f, -0.20624337f, -0.22815517f, 
    -0.02779818f, 0.07541849f, 0.08231528f, -0.33104530f, 0.01634655f, -0.07154997f, -0.05029101f, -0.01773928f, 
    0.10737881f, 0.15460186f, 0.40072900f, 0.15030888f, 0.04700201f, -0.09435063f, 0.04597910f, -0.10484620f, 
    0.02524183f, -0.25357553f, -0.04293138f, -0.03373760f, 0.03857495f, 0.13342488f, -0.21576187f, -0.00117022f, 
    -0.06726005f, 0.11209332f, 0.07787780f, -0.09230354f, 0.02973215f, -0.06085159f, 0.11398476f, -0.01919712f, 
    -0.07624533f, 0.18542662f, 0.05213236f, -0.08011735f, -0.02249598f, 0.02728901f, -0.19725570f, 0.19846377f, 
    0.05444595f, -0.00717514f, -0.05934254f, -0.15267380f, -0.03571894f, 0.05265525f, -0.07243696f, -0.13571903f, 
    -0.00711346f, 0.13380058f, -0.03079421f, 0.09899884f, -0.04402125f, -0.02130100f, 0.08420237f, -0.10468283f, 
    0.25162500f, -0.05467602f, -0.25532010f, 0.08611437f, -0.16398235f, 0.08674894f, -0.12265038f, -0.00008748f, 
    0.03493581f, 0.02100874f, -0.03912727f, -0.09440025f, 0.05439792f, -0.11831667f, 0.08299333f, 0.14872581f, 
    0.01252862f, -0.03013170f, 0.04728434f, -0.06390037f, -0.05997913f, 0.07254021f, 0.04351883f, 0.06459766f, 
    -0.33001989f, -0.03380664f, 0.22306718f, -0.16168210f, -0.00235578f, 0.07745228f, -0.03410035f, 0.03009541f, 
    -0.07191377f, -0.05651718f, 0.01150418f, -0.03687331f, 0.47380269f, 0.25254205f, 0.19910312f, 0.43993041f, 
    0.04484548f, 0.09959111f, 0.01245461f, -0.03182158f, -0.07121650f, -0.07841709f, -0.01736371f, -0.01357942f, 
    -0.21618198f, 0.10664772f, -0.01435018f, -0.16736937f, -0.03188890f, 0.09643756f, -0.01145942f, -0.05311593f, 
    0.05959126f, 0.05993935f, -0.13332948f, 0.12034940f, 0.00473636f, 0.04501987f, 0.04016684f, 0.05365865f, 
    -0.04026011f, -0.04003776f, -0.00281846f, -0.11862822f, -0.01487630f, -0.05616643f, -0.01923737f, 0.05069164f, 
    -0.13086596f, 0.34079850f, -0.00991306f, 0.16248740f, -0.06236695f, 0.10155566f, 0.03442783f, -0.35491866f, 
    -0.02910100f, 0.00951595f, 0.01329278f, 0.06262629f, -0.01884188f, -0.11526618f, -0.07046574f, -0.02556831f, 
    0.04535246f, -0.01500593f, -0.03547171f, 0.12820236f, 0.17764609f, -0.01737599f, -0.07414239f, 0.02846917f, 
    -0.21547610f, 0.07828155f, -0.45310798f, 0.22221345f, -0.06983159f, 0.01700225f, 0.05000207f, 0.06088277f, 
    0.01741094f, 0.08622248f, -0.12881353f, -0.00865241f, -0.01744673f, -0.14447623f, 0.02070254f, 0.02998468f, 
    0.06806507f, 0.11776512f, -0.09058835f, 0.04193819f, -0.08562678f, -0.08700334f, -0.02714050f, 0.12986128f, 
    -0.19600117f, 0.17165843f, -0.07630118f, -0.10783632f, 0.07156176f, 0.00339468f, 0.02151143f, 0.03840490f, 
    -0.03698182f, 0.00212975f, 0.04701971f, -0.01343550f, -0.14852177f, -0.02985626f, -0.05317954f, 0.03061694f, 
    -0.04225576f, 0.02787683f, 0.03919617f, 0.07967236f, -0.14390793f, -0.03727400f, 0.20850255f, -0.23428942f, 
    0.05847175f, -0.17412263f, -0.12307806f, 0.03806309f, 0.00691114f, 0.01385642f, 0.00171423f, 0.06297888f, 
    -0.01507138f, 0.05769023f, -0.02368202f, 0.00573739f, 0.07279737f, 0.04048636f, -0.11590988f, -0.09261964f, 
    0.07158230f, -0.11562981f, 0.08393145f, 0.04196604f, 0.05810859f, 0.07472039f, 0.14293645f, -0.11581448f, 
    -0.05026288f, -0.13199356f, 0.09319247f, -0.04522361f, 0.05612353f, -0.09903605f, -0.20490484f, -0.05580818f, 
    0.11155265f, -0.01342440f, -0.09008231f, 0.13910557f, 0.16054565f, 0.51464570f, 0.52434546f, 0.41591477f, 
    -0.06817906f, 0.01451125f, 0.04888104f, 0.08583198f, 0.02116602f, 0.00203189f, -0.04912744f, 0.09381616f, 
    -0.16229571f, 0.05700929f, -0.06434398f, 0.05783980f, 0.05649788f, 0.04791760f, -0.05181029f, -0.03731470f, 
    -0.06197717f, -0.01470675f, 0.08990777f, -0.05109142f, 0.16520035f, -0.05191027f, -0.28039074f, 0.12026120f, 
    0.11461458f, 0.02414517f, -0.03092140f, 0.06807593f, 0.05503858f, -0.02297175f, 0.06521697f, 0.02897732f, 
    -0.11575406f, 0.30665377f, 0.16180174f, 0.05286183f, -0.01235494f, -0.00474619f, 0.00930955f, -0.05054913f, 
    -0.00763009f, 0.02143406f, 0.08289564f, 0.09189595f, -0.01385914f, 0.03651159f, 0.03633462f, -0.08826566f, 
    -0.02637987f, 0.14440586f, -0.13517497f, -0.06910954f, 0.00054601f, 0.15839083f, 0.10872688f, 0.13790667f, 
    -0.13942786f, -0.10999296f, 0.22988011f, -0.29333389f, 0.02836347f, 0.01979745f, -0.02180552f, 0.14206223f, 
    -0.03131469f, -0.05215878f, 0.08115768f, -0.06976937f, -0.08135567f, 0.16129255f, 0.34366986f, 0.14437088f, 
    -0.10141133f, 0.02701077f, 0.07391124f, -0.12010016f, 0.02703875f, 0.01739598f, -0.03297837f, 0.10497879f, 
    0.10549933f, -0.29082942f, -0.32351685f, 0.11076859f, -0.04841944f, 0.03639352f, 0.00482757f, 0.04620079f, 
    0.11047366f, 0.01552276f, -0.27617073f, 0.21046309f, 0.09482092f, -0.04478440f, 0.19017011f, -0.22861351f, 
    -0.01342411f, -0.05462961f, 0.14467226f, -0.19188499f, 0.09052271f, -0.09457298f, -0.05342186f, 0.02876736f, 
    -0.11093102f, -0.04872095f, -0.10153259f, 0.04391818f, 0.04876577f, -0.08836586f, -0.15476947f, 0.17059876f, 
    0.04567080f, -0.13125417f, 0.00806730f, 0.03173488f, -0.05980555f, -0.07723514f, 0.00649177f, 0.01218557f, 
    0.02698863f, -0.06682794f, 0.04544816f, -0.03642784f, 0.03020462f, -0.08238000f, -0.00733606f, -0.07812568f, 
    0.19395620f, 0.05990100f, -0.09897689f, -0.14006072f, 0.12849154f, -0.22169739f, 0.02953468f, 0.07272451f, 
    0.00279420f, -0.01842791f, 0.01886454f, -0.01437034f, -0.02317944f, 0.00693789f, 0.01475376f, -0.00616577f, 
    -0.04557949f, 0.07970066f, -0.07061583f, -0.01474834f, 0.00615765f, 0.10882809f, 0.08344259f, 0.05734057f, 
    -0.17634563f, -0.03519515f, -0.09320143f, 0.07687788f, -0.06083241f, 0.09325495f, -0.00380826f, 0.05073892f, 
    -0.03734874f, -0.01226947f, 0.10354317f, -0.13501334f, 0.13753901f, -0.10985281f, -0.27897388f, 0.09220700f, 
    0.00247252f, -0.03030860f, -0.04946133f, 0.01305729f, -0.06876517f, -0.04192086f, -0.03009216f, 0.04639895f, 
    0.12390433f, 0.15540841f, 0.15062013f, 0.19968757f, -0.01729746f, -0.05346783f, 0.22445424f, -0.04633313f, 
    -0.02053938f, 0.02795062f, 0.05165962f, -0.07024061f, -0.02142182f, -0.21534821f, 0.00734422f, -0.03816847f, 
    -0.09969565f, 0.12095139f, 0.03689057f, -0.20588951f, 0.00481401f, -0.10645808f, -0.05691030f, -0.03643986f, 
    -0.04347923f, 0.04703766f, -0.16959094f, -0.06508554f, 0.04097519f, 0.03749802f, 0.00333162f, -0.10782832f, 
    0.01793524f, -0.07082316f, -0.00829400f, 0.08869745f, 0.03670135f, -0.10959576f, 0.22186047f, 0.08635321f, 
    -0.10599592f, 0.12698385f, 0.16701859f, -0.02356071f, 0.07141080f, 0.15315332f, -0.01899839f, 0.11767629f, 
    -0.23224440f, 0.34007165f, -0.11466877f, 0.19451289f, -0.00578984f, -0.02737962f, 0.02023929f, 0.05553792f, 
    -0.05340810f, -0.03746555f, -0.00218431f, -0.02021439f, -0.32549161f, -0.07342800f, 0.03875766f, 0.14487772f, 
    -0.03622552f, -0.06829463f, -0.14601666f, 0.01365565f, -0.07021062f, -0.07770964f, 0.05778739f, -0.02102094f, 
    -0.06913112f, -0.23526296f, 0.08004980f, 0.09206286f, -0.06845307f, 0.03759918f, 0.13729668f, 0.12320466f, 
    0.11757699f, 0.12986629f, -0.12477292f, -0.09960573f, 0.07775191f, -0.02218752f, 0.04350928f, 0.20692897f, 
    -0.06207152f, 0.03561042f, -0.01230878f, -0.02210395f, 0.01449521f, 0.10844310f, 0.12621775f, -0.07349490f, 
    0.01784403f, -0.11715267f, -0.18766813f, 0.05760583f, 0.09108417f, 0.07838155f, 0.02638434f, 0.06624861f, 
    0.03122692f, -0.01971241f, 0.08351704f, -0.10045429f, -0.18029779f, 0.40720236f, -0.25619560f, 0.12032581f, 
    -0.02851405f, -0.07921229f, -0.03117095f, -0.04973888f, -0.07656342f, 0.25655371f, -0.12034017f, -0.00052875f, 
    -0.14093575f, -0.19826297f, -0.16715042f, 0.20209914f, -0.07304104f, 0.01532639f, -0.00867583f, -0.05337626f, 
    0.10233272f, 0.12216544f, -0.09705543f, -0.03098612f, 0.42897618f, -0.05352241f, -0.05123549f, -0.23096524f, 
    0.08740880f, 0.03006020f, -0.16356155f, 0.00846556f, 0.04891055f, 0.03452827f, 0.06638198f, -0.09529746f, 
    -0.37812832f, -0.00218102f, -0.26876897f, 0.01603436f, -0.02852837f, 0.19071741f, 0.28648838f, -0.12587966f, 
    0.00758920f, 0.08273692f, -0.01914533f, 0.00999642f, 0.31225625f, -0.27752116f, 0.36781716f, -0.06172601f, 
    -0.25972396f, 0.05518978f, 0.06163433f, -0.00476902f, 0.00358177f, 0.07649784f, 0.12686132f, -0.04532161f, 
    -0.02557171f, -0.11832573f, 0.14246157f, 0.13297455f, 0.15859221f, 0.12648812f, -0.17854419f, 0.03331916f, 
    0.03393383f, -0.34872782f, 0.04844894f, 0.09422429f, 0.08840999f, -0.04749059f, 0.14588721f, 0.04736262f, 
    0.12326335f, 0.08151962f, 0.03913448f, 0.12636837f, -0.02393909f, 0.06657366f, 0.06153587f, 0.03271328f, 
    -0.13689050f, -0.20221335f, -0.11306667f, 0.09581750f, -0.02423876f, -0.03669044f, -0.05906690f, 0.01753694f, 
    0.00487084f, 0.03150962f, -0.07165746f, -0.10265762f, 0.12781252f, 0.10235589f, 0.10961325f, 0.23095024f, 
    -0.01561820f, 0.05562043f, -0.08197005f, -0.00268892f, -0.03035117f, 0.17964502f, -0.00605371f, 0.04796966f, 
    -0.41618615f, -0.02155172f, 0.26723018f, 0.18953007f, -0.01741607f, 0.06876409f, -0.18366975f, -0.07538699f, 
    0.05904103f, 0.03745724f, 0.13230817f, -0.09961494f, -0.28126183f, 0.04588422f, -0.08459234f, -0.39988384f, 
    0.21775454f, 0.13701919f, -0.07014298f, 0.02351030f, -0.07340242f, 0.05062472f, -0.08595981f, -0.12672941f, 
    -0.26134467f, -0.03358150f, -0.10617722f, -0.13906023f, 0.02408104f, 0.15849996f, -0.29548231f, -0.05443908f, 
    -0.04432904f, -0.28558823f, -0.11015362f, -0.10969312f, -0.13379519f, 0.26571757f, -0.03167208f, 0.00877682f, 
    0.00785106f, 0.02263441f, -0.02620876f, -0.09680970f, -0.12356126f, -0.15964495f, 0.22432628f, -0.08385102f, 
    0.40960136f, -0.10754555f, 0.25311989f, -0.17110284f, -0.18027018f, 0.04866558f, -0.01033952f, -0.01872658f, 
    -0.02684947f, 0.01323014f, -0.11133587f, 0.09995483f, -0.55544615f, -0.33187193f, 0.09989144f, 0.28842869f, 
    0.05613198f, 0.01081409f, 0.05297730f, -0.10174995f, 0.15853781f, -0.06621772f, -0.04349095f, -0.22421744f, 
    -0.10172625f, -0.13455695f, 0.15740003f, 0.22820351f, 0.04632578f, 0.14297904f, -0.04369906f, -0.06951698f, 
    0.02153285f, -0.04654510f, -0.06809215f, 0.05068756f, -0.13318357f, -0.04980549f, 0.00900845f, 0.08298957f, 
    0.22612651f, 0.11988922f, 0.03148812f, 0.02877207f, -0.12692596f, -0.00949870f, 0.01033205f, -0.09328473f, 
    -0.29256141f, 0.28820789f, -0.02275556f, -0.07148089f, 0.01491502f, 0.11468610f, -0.01431521f, 0.05750766f, 
    -0.30576453f, 0.08896804f, -0.27307317f, 0.06656266f, -0.02804488f, -0.08080464f, -0.05329851f, 0.19721833f, 
    -0.02972366f, 0.06572317f, 0.05665813f, 0.03604558f, -0.01433598f, 0.07002450f, -0.05564875f, 0.00208475f, 
    -0.34622779f, 0.00219010f, 0.02061800f, -0.13910443f, -0.05152663f, -0.07012913f, -0.12909031f, 0.04284736f, 
    0.01510863f, 0.10992531f, 0.06436162f, 0.00555038f, -0.03130546f, -0.19221151f, -0.00963190f, 0.25630406f, 
    0.00754739f, 0.05488210f, 0.07082620f, 0.08385494f, -0.07291067f, -0.02714039f, 0.03922785f, -0.14710675f, 
    0.06955605f, -0.27235833f, -0.18224630f, 0.09836008f, 0.15975918f, 0.11536295f, 0.07826424f, -0.22064476f, 
    -0.04230242f, 0.06383238f, 0.00595392f, -0.01197090f, 0.05682123f, 0.00306233f, -0.06282544f, 0.09875640f, 
    -0.12391756f, -0.07347380f, -0.12084609f, -0.00938839f, -0.03088829f, -0.05957690f, 0.05924601f, -0.10742816f, 
    0.04853041f, 0.05868544f, 0.02079469f, 0.28808311f, -0.04264764f, 0.01367013f, -0.24039046f, 0.05798285f, 
    -0.05378461f, -0.01277148f, -0.01138885f, -0.04031004f, 0.02508549f, -0.09711036f, -0.00529922f, -0.17287306f, 
    -0.12695339f, -0.11335323f, -0.16508687f, -0.03124478f, -0.15182030f, -0.04021626f, 0.03733090f, -0.14226183f, 
    -0.15201260f, 0.13676883f, -0.12016862f, -0.76971352f, -0.17472777f, -0.10645957f, -0.25602615f, 0.17505220f, 
    0.07276027f, 0.07608888f, -0.03104160f, -0.15754701f, -0.02417410f, 0.29905406f, -0.11793388f, 0.02693679f, 
    0.01651234f, 0.03126661f, 0.13782196f, -0.17739543f, -0.24070244f, -0.08147869f, -0.04621976f, 0.06969409f, 
    -0.13100964f, 0.04354263f, 0.09152291f, 0.34034935f, 0.00146281f, -0.13389997f, 0.08642795f, -0.00322222f, 
    0.00392952f, 0.04425196f, 0.03296128f, 0.01899162f, 0.47774449f, -0.07164853f, 0.09596374f, 0.18826239f, 
    0.01198493f, -0.06781739f, -0.02827464f, -0.12922369f, -0.13833964f, -0.07135504f, -0.03105018f, 0.08413068f, 
    -0.29788274f, 0.18144500f, -0.06357367f, 0.30421534f, 0.04101477f, 0.03031291f, -0.22871719f, -0.10695358f, 
    -0.05934190f, 0.15287241f, 0.09721041f, -0.01567353f, -0.23508769f, -0.04642890f, 0.02837721f, 0.30603200f, 
    0.00600851f, 0.10147533f, -0.01696842f, 0.13960773f, -0.00540590f, 0.10015780f, -0.05648326f, -0.01585045f, 
    -0.02439428f, 0.09198847f, -0.10360289f, 0.29102063f, -0.17978671f, -0.07895959f, -0.05793872f, -0.08763555f, 
    -0.05429402f, -0.08389716f, -0.04118256f, 0.02084671f, 0.32834870f, 0.38924280f, 0.07592765f, 0.38238293f, 
    -0.16744544f, 0.11550342f, -0.08119545f, 0.05813660f, 0.12836415f, 0.05534004f, -0.01176976f, -0.06715643f, 
    -0.06733353f, -0.08936193f, -0.13687295f, 0.14769277f, 0.01003777f, 0.11776502f, 0.01870627f, 0.11783005f, 
    -0.03678861f, 0.02380348f, 0.00457022f, -0.12314615f, 0.02664880f, 0.04778085f, 0.14337431f, -0.05932783f, 
    0.09129209f, -0.10637784f, -0.30167606f, -0.19521943f, -0.15140544f, 0.06386475f, 0.03577000f, 0.11462888f, 
    0.25316700f, 0.37057504f, 0.21481325f, 0.10722271f, -0.22699665f, 0.00960362f, -0.15393651f, -0.11321747f, 
    0.00595150f, -0.01278372f, -0.02042167f, 0.05806516f, -0.34704188f, -0.03733040f, -0.27745885f, -0.43476474f, 
    0.33959654f, 0.16107421f, 0.15607405f, -0.02076022f, -0.06107743f, -0.12677267f, -0.07320534f, -0.20122957f, 
    0.36943287f, 0.11607753f, -0.06471612f, -0.12003269f, -0.14180744f, 0.07277206f, -0.10167699f, -0.13167088f, 
    -0.07466465f, 0.13229109f, 0.11539043f, -0.05455377f, -0.31638464f, 0.94322956f, -0.36791441f, 0.02225426f, 
    0.16123579f, -0.01730115f, 0.00245640f, -0.16245705f, -0.25799236f, -0.11515447f, -0.07922368f, 0.05654988f, 
    0.06302279f, 0.03878834f, 0.01480006f, -0.18360288f, -0.10064875f, -0.07673870f, -0.02649643f, 0.02049204f, 
    -0.08118790f, -0.07319940f, -0.07603767f, -0.07086241f, 0.19001569f, -0.18446440f, 0.05421885f, 0.18081133f, 
    0.19049722f, -0.02503178f, -0.01958157f, -0.05082885f, -0.06804995f, 0.05642844f, 0.00106253f, 0.09376102f, 
    0.00194828f, -0.00791018f, 0.07540942f, -0.40401006f, 0.01303177f, -0.07594016f, -0.07055626f, -0.10929573f, 
    -0.07990535f, 0.04473872f, -0.13862774f, -0.06111527f, 0.06151939f, 0.04001717f, 0.17821243f, -0.14330980f, 
    -0.04075286f, 0.12454395f, -0.02157958f, -0.08835164f, 0.07777520f, 0.32194197f, -0.03550799f, -0.12033015f, 
    -0.41992953f, -0.08668217f, 0.10653039f, 0.34935561f, 0.02321759f, 0.10554118f, 0.03651493f, 0.03579006f, 
    -0.05582193f, -0.13736872f, -0.00648359f, 0.15184994f, -0.41324016f, -0.08471310f, 0.04246921f, 0.19736142f, 
    0.03732425f, 0.01532093f, 0.14721957f, 0.03211676f, 0.00060560f, 0.09570757f, 0.11499283f, -0.16612363f, 
    -0.12012932f, -0.01590152f, -0.16324855f, -0.09399034f, -0.04762806f, -0.23337595f, -0.19438194f, -0.06252290f, 
    0.00083521f, -0.04086594f, 0.17396307f, -0.05181413f, -0.12018500f, -0.20698735f, 0.01277616f, 0.21309674f, 
    -0.00829076f, -0.01096344f, 0.02596761f, -0.07561591f, 0.05073635f, 0.09433862f, -0.08605485f, 0.17705564f, 
    0.18430126f, 0.37363482f, -0.24825126f, -0.45806643f, -0.13918187f, 0.01895245f, -0.04089944f, 0.13882060f, 
    -0.29753146f, 0.01166620f, -0.08436727f, 0.02423408f, 0.24364313f, -0.05659067f, 0.23570961f, -0.17308043f, 
    -0.03627412f, -0.13013294f, -0.13750528f, 0.06311298f, 0.03265874f, 0.05315721f, 0.12325350f, 0.03138955f, 
    -0.39166623f, -0.05461889f, -0.29671285f, -0.05748634f, 0.18269016f, 0.03387320f, 0.05740761f, -0.03887963f, 
    0.08762396f, 0.04644505f, 0.05034376f, -0.05600865f, -0.00989262f, -0.07575490f, -0.01653478f, 0.24151282f, 
    0.09619656f, 0.07065701f, -0.11426675f, 0.07024629f, 0.13335042f, 0.10356935f, 0.08936206f, -0.08135504f, 
    0.16869529f, 0.04593586f, 0.06661221f, -0.18051307f, -0.07288231f, -0.03205096f, -0.11071566f, -0.20651740f, 
    -0.03508820f, -0.26523191f, 0.01227019f, 0.01842315f, -0.18086645f, -0.13215880f, -0.08336782f, 0.19618784f, 
    -0.04239076f, 0.03377637f, 0.03052608f, -0.03268520f, 0.01441601f, 0.03627777f, 0.06336939f, -0.03300434f, 
    0.12641107f, 0.07919325f, 0.03519519f, 0.07532310f, 0.07175421f, -0.38763574f, 0.15800197f, -0.00175409f, 
    -0.20162328f, 0.10753862f, -0.18594992f, 0.07230110f, 0.14375180f, 0.19823723f, -0.11145225f, -0.20879036f, 
    -0.00411765f, -0.04154032f, -0.04460566f, -0.08297208f, -0.04620377f, 0.00686747f, -0.04760276f, -0.00813758f, 
    0.30119947f, 0.00806291f, 0.03142503f, 0.13861817f, 0.03140935f, -0.17868783f, -0.11175405f, -0.16041355f, 
    -0.04030065f, 0.06391068f, 0.00096069f, 0.06386916f, -0.05052790f, -0.00064896f, -0.12253886f, 0.19449668f, 
    -0.10369773f, -0.03996260f, 0.00379629f, -0.02690886f, -0.04707180f, 0.05560608f, -0.15477127f, -0.11306208f, 
    -0.29570919f, -0.12231833f, 0.10757036f, 0.02663937f, -0.17442371f, -0.08506477f, -0.05883103f, -0.08365697f, 
    -0.04951818f, -0.00424597f, -0.07135432f, 0.00748435f, 0.19797224f, 0.18635488f, 0.05541566f, 0.20346810f, 
    0.03988408f, -0.02824030f, -0.07334723f, -0.04390785f, 0.00139291f, -0.03420946f, 0.02774315f, -0.12171028f, 
    -0.00824745f, -0.31551287f, 0.07466223f, 0.14385703f, -0.10736288f, -0.06670484f, 0.00979966f, -0.04704593f, 
    -0.17725259f, 0.13442224f, -0.01137877f, 0.08821373f, 0.05747490f, 0.06195963f, 0.01379385f, 0.04596123f, 
    0.05357183f, 0.06974834f, 0.03583034f, 0.02680040f, 0.02567841f, -0.01407244f, 0.02286663f, -0.15267152f, 
    -0.11610202f, 0.03149540f, -0.01416842f, -0.04723238f, 0.10876315f, 0.02022585f, -0.00462799f, -0.01651902f, 
    -0.03777250f, -0.09472166f, 0.13481629f, 0.07087103f, -0.09156962f, 0.08399474f, 0.04926544f, 0.00638210f, 
    -0.00371266f, -0.02896762f, -0.13821894f, 0.03783721f, -0.08607332f, -0.08302341f, -0.07633175f, -0.08517329f, 
    0.12326631f, 0.11179727f, 0.36707860f, 0.22501267f, -0.09671742f, -0.04115213f, -0.16905589f, -0.01418353f, 
    0.01799438f, 0.05125464f, -0.03839421f, 0.03566695f, 0.02762070f, -0.14558257f, -0.15811859f, -0.25908896f, 
    0.01194758f, 0.09872348f, -0.06508221f, 0.03240937f, 0.15794210f, 0.03596476f, 0.14536169f, 0.16445933f, 
    0.11747941f, 0.03472663f, 0.04690685f, 0.01630561f, 0.03639164f, 0.06117624f, -0.01465893f, 0.05404916f, 
    0.09167583f, 0.07399056f, -0.02340003f, 0.01951048f, 0.03058569f, 0.05069368f, 0.04615742f, -0.17586420f, 
    -0.00992576f, -0.00740278f, 0.04430351f, -0.03621882f, 0.10209194f, -0.31023487f, -0.14966762f, -0.05249630f, 
    0.05526301f, -0.00138557f, -0.15399979f, -0.07277039f, -0.00740243f, -0.00640977f, -0.01396539f, 0.11181857f, 
    0.07040810f, -0.05698549f, 0.00679201f, 0.16722149f, -0.00368522f, 0.22168711f, -0.02765157f, 0.13292047f, 
    0.00302570f, 0.14574589f, -0.02787531f, 0.04665662f, 0.06467836f, -0.11484863f, -0.05332385f, -0.04915099f, 
    -0.04934687f, -0.06421040f, 0.11925559f, 0.14524542f, 0.11942933f, 0.04555291f, -0.00149566f, -0.03178535f, 
    0.02751466f, 0.06813563f, -0.04224094f, 0.10831156f, 0.06414051f, 0.23931018f, 0.17954631f, 0.38515082f, 
    0.04427923f, 0.02706140f, -0.05274743f, -0.09073194f, 0.05799882f, -0.00860798f, 0.09980563f, -0.00021160f, 
    0.04233631f, 0.10392810f, 0.15440525f, 0.16061489f, -0.06330066f, 0.04394019f, -0.01916765f, 0.15800631f, 
    0.05885743f, 0.02013217f, 0.02467261f, 0.04312382f, -0.18438649f, 0.05618901f, -0.01523752f, 0.12931912f, 
    -0.01885886f, -0.03134885f, 0.01659434f, 0.02789264f, -0.02231233f, -0.33512396f, -0.00603176f, 0.03796730f, 
    -0.07094269f, 0.21248341f, -0.40329847f, -0.01654726f, 0.09812985f, 0.03620765f, -0.11957964f, -0.06966769f, 
    0.03755281f, -0.01267489f, -0.00934792f, -0.07501554f, 0.12413582f, -0.14651866f, -0.00573789f, 0.05096439f, 
    -0.00131507f, 0.00202646f, 0.03802001f, 0.01601222f, -0.03455245f, 0.11540168f, -0.10070088f, 0.03580647f, 
    -0.01302132f, -0.03136956f, -0.02870288f, 0.02008552f, -0.01875887f, 0.04037708f, -0.00209072f, -0.10224825f, 
    0.05279176f, -0.03280668f, 0.05612925f, -0.03526860f, 0.06383839f, -0.18655860f, -0.10544040f, 0.05626421f, 
    0.00604988f, -0.05518840f, -0.03539453f, -0.05232783f, -0.23038897f, -0.04178238f, -0.11484184f, -0.05142263f, 
    0.12418075f, 0.15426694f, -0.38925087f, 0.10707620f, 0.09165122f, 0.01163527f, 0.01102769f, -0.09819186f, 
    0.08211219f, -0.08592111f, 0.13066335f, -0.01442606f, 0.00561440f, 0.28823912f, -0.35646889f, 0.04308096f, 
    -0.05672679f, -0.15432055f, 0.10357472f, 0.09704636f, -0.13123120f, -0.09127542f, -0.11026767f, 0.08106849f, 
    0.05640841f, 0.16817215f, 0.00644644f, 0.15588686f, 0.05464685f, -0.03463846f, -0.11011548f, 0.04336529f, 
    0.02024265f, 0.00701198f, -0.00814917f, -0.10697217f, 0.13833772f, 0.11811713f, 0.11148110f, 0.08872680f, 
    -0.03854410f, -0.04519018f, 0.01925286f, 0.07052588f, 0.10767549f, -0.06321088f, 0.05723067f, 0.10202651f, 
    0.19109648f, -0.52202588f, 0.26353383f, -0.00093813f, -0.06651810f, -0.09908226f, 0.16726296f, -0.14605097f, 
    0.02455782f, -0.09053815f, -0.03972208f, -0.03684730f, 0.05609168f, 0.10467579f, 0.11383562f, 0.13137835f, 
    -0.03455575f, -0.01614134f, -0.03595725f, 0.04985094f, 0.02126636f, -0.01928227f, 0.08011851f, -0.02188757f, 
    0.08412573f, -0.15757406f, -0.14033756f, -0.05393811f, 0.03930501f, 0.01888084f, 0.09001642f, -0.06032756f, 
    0.05991558f, 0.03416414f, 0.04968878f, 0.05446267f, 0.06261411f, 0.19879015f, 0.13717912f, 0.13245760f, 
    -0.03436144f, -0.02667871f, 0.06676590f, 0.16860998f, -0.00215880f, 0.00506848f, 0.03501113f, 0.04432764f, 
    0.31747717f, 0.33018339f, 0.07330537f, 0.21155801f, -0.00431442f, -0.09665251f, -0.03114607f, 0.00703403f, 
    -0.01953356f, -0.24296993f, -0.05358501f, 0.01284684f, -0.10159247f, -0.02884158f, 0.09104628f, -0.04167311f, 
    -0.09973367f, -0.19143358f, 0.02813662f, 0.04175976f, -0.01500613f, -0.08876971f, -0.03878881f, -0.22967830f, 
    0.01614861f, 0.15176000f, -0.02825596f, -0.17877750f, 0.01314408f, -0.15553026f, -0.10547161f, -0.19164504f, 
    0.06355526f, -0.07151487f, 0.00412410f, -0.18837681f, -0.02868824f, -0.07739855f, 0.05937728f, -0.00702380f, 
    -0.01353089f, -0.03334837f, 0.07137571f, 0.02788416f, -0.07290302f, -0.01797227f, -0.03938853f, -0.06482541f, 
    0.05852727f, -0.41695502f, -0.00828454f, -0.10083501f, -0.17584528f, -0.02863956f, -0.08049860f, -0.08497661f, 
    -0.16260619f, -0.05452838f, -0.11100267f, 0.01958117f, 0.05214081f, 0.03537390f, 0.04457331f, 0.08318486f, 
    -0.12621312f, -0.12181804f, -0.04070259f, -0.04315858f, 0.01746890f, -0.03047792f, -0.08783396f, 0.09210596f, 
    -0.07557350f, -0.00609997f, -0.01574844f, 0.05453710f, 0.07887049f, 0.04798992f, -0.04356823f, 0.04184995f, 
    0.00781631f, 0.02321223f, -0.02146299f, -0.02619441f, -0.13891618f, -0.16397706f, -0.21842887f, -0.00072409f, 
    -0.17048527f, -0.08007445f, 0.05221817f, -0.08660660f, 0.04067892f, -0.03843755f, 0.12228205f, 0.10643935f, 
    -0.06087209f, -0.11916226f, -0.11576572f, 0.01051485f, 0.03442533f, -0.02779019f, -0.04574977f, -0.02456084f, 
    -0.09195767f, -0.08619241f, 0.06407697f, -0.20244087f, 0.08030298f, 0.06682833f, 0.05127121f, 0.03622445f, 
    0.00556357f, 0.03092314f, 0.08147514f, 0.03511516f, 0.17187685f, 0.06894235f, -0.06503157f, 0.00058602f, 
    -0.38911018f, -0.00895662f, 0.04632203f, -0.01336287f, 0.06056106f, 0.08217719f, -0.00501570f, -0.01207938f, 
    -0.13543835f, 0.03106946f, -0.01081194f, 0.00410421f, 0.00311845f, 0.01850788f, 0.06238053f, 0.03916414f, 
    0.11372148f, 0.06228315f, -0.09512673f, -0.08651756f, 0.01040418f, -0.06606287f, 0.11223676f, 0.08445926f, 
    0.12604047f, 0.12700009f, 0.27820137f, -0.02842890f, -0.02468543f, 0.01434689f, -0.05229458f, -0.16543739f, 
    0.25802639f, -0.01374706f, -0.13200185f, 0.04571532f, 0.08790737f, 0.06589260f, -0.08964612f, 0.05389418f, 
    -0.03553224f, -0.03401951f, 0.09017054f, -0.00834524f, -0.09492882f, -0.01031606f, 0.01204622f, -0.33976942f, 
    -0.02540577f, -0.17725231f, -0.08243454f, 0.38909668f, -0.07250679f, 0.05717466f, -0.01782994f, -0.01793352f, 
    -0.01820202f, -0.00979821f, -0.01108712f, 0.03539383f, 0.12644470f, 0.02171658f, -0.06188243f, -0.05656849f, 
    0.09499525f, 0.05178884f, 0.07153525f, 0.11242835f, -0.15009432f, 0.06725180f, -0.11987066f, -0.05662777f, 
    0.13154222f, -0.26580960f, -0.05197882f, 0.13052174f, -0.00929981f, -0.01577448f, 0.07050011f, 0.07163254f, 
    -0.01686639f, -0.01617735f, 0.06339846f, 0.04829668f, -0.07334847f, -0.64587677f, 0.23962338f, -0.16200286f, 
    -0.10589598f, 0.18325892f, -0.10703108f, -0.03482677f, -0.17366035f, 0.01306104f, -0.06853808f, -0.10615101f, 
    -0.29809806f, 0.04468210f, -0.01032356f, 0.29855347f, 0.05833086f, 0.00307962f, -0.05266758f, -0.15806445f, 
    -0.00978582f, 0.04695170f, -0.02565159f, -0.18276723f, -0.01151237f, 0.04623928f, 0.09353382f, 0.19785818f, 
    -0.10163659f, -0.15250047f, 0.12787500f, -0.06260896f, -0.04090956f, -0.04481897f, 0.01627534f, 0.02337171f, 
    0.03364810f, -0.14538558f, 0.01811535f, 0.02248082f, -0.07954066f, 0.06064362f, -0.07281523f, 0.04628451f, 
    -0.17624578f, -0.07447619f, -0.12548169f, -0.08075782f, 0.14018731f, 0.07178997f, -0.29916450f, -0.00654304f, 
    -0.16057196f, 0.05576505f, -0.03381912f, -0.11896770f, 0.08252268f, -0.07027771f, -0.28656864f, 0.02559204f, 
    -0.12574576f, 0.06254063f, 0.08495397f, 0.02496878f, 0.03745347f, -0.05233278f, 0.01012170f, 0.05939873f, 
    0.02406630f, -0.01050839f, -0.19050188f, 0.09427457f, 0.20993114f, -0.00383297f, -0.06473191f, 0.00596238f, 
    0.03168185f, -0.13193493f, -0.11352973f, -0.20613216f, -0.03285681f, -0.10579357f, -0.24345833f, 0.02357554f, 
    0.10478971f, 0.01856470f, -0.03380515f, 0.08394331f, -0.04108326f, 0.01237086f, 0.05764465f, 0.00109055f, 
    0.11184391f, -0.05668963f, -0.09439694f, -0.07109735f, -0.08979119f, 0.00820178f, 0.03579020f, 0.10789779f, 
    -0.05731058f, -0.11690855f, -0.02912704f, -0.04579243f, -0.00103679f, -0.02775941f, 0.13411072f, 0.13324071f, 
    0.13326287f, -0.44636908f, -0.05349224f, -0.11409137f, 0.00286248f, 0.02352521f, 0.06977260f, -0.01948696f, 
    -0.03245919f, -0.03236401f, -0.03815094f, -0.16906306f, 0.21028668f, 0.12898028f, -0.33119804f, 0.18131885f, 
    0.06367725f, 0.00924821f, -0.10259802f, -0.23180538f, 0.04135584f, -0.06699365f, 0.00806979f, -0.05623465f, 
    0.12934873f, 0.10384358f, 0.08350097f, -0.01098154f, 0.02429706f, 0.03578290f, 0.01453350f, -0.10593179f, 
    -0.04510302f, -0.07338279f, -0.04161496f, -0.02075717f, 0.05163046f, 0.08734787f, 0.16177620f, 0.08984527f, 
    -0.09736305f, -0.02431115f, -0.07797369f, -0.03000252f, 0.08888902f, -0.01858404f, -0.02992858f, 0.01901477f, 
    0.00045003f, 0.03384129f, -0.14999282f, 0.15931055f, 0.15466119f, 0.06661301f, -0.08559121f, -0.13743028f, 
    -0.06768925f, -0.06344862f, -0.08418744f, 0.04572925f, 0.08348797f, 0.04283137f, 0.01247151f, 0.03241495f, 
    0.07585388f, -0.08813851f, -0.09186973f, -0.06026739f, 0.03077586f, -0.07379805f, -0.09812473f, 0.12245815f, 
    0.08334351f, -0.04663910f, 0.06891686f, 0.02529440f, 0.03969667f, 0.04765511f, -0.08714353f, 0.02488395f, 
    -0.08011232f, -0.15499645f, -0.13491097f, -0.33529541f, -0.13867691f, -0.10859092f, -0.05910180f, 0.17832884f, 
    0.01087535f, -0.02085781f, -0.05742621f, -0.10558533f, 0.09556560f, -0.01462062f, 0.24869886f, 0.36799106f, 
    -0.15514447f, 0.02761013f, -0.02020519f, -0.12220752f, -0.18196312f, -0.22368482f, -0.04494370f, 0.00260584f, 
    0.05346655f, 0.01104761f, 0.01280437f, 0.07108469f, -0.01284516f, -0.03588687f, 0.10967027f, 0.05542636f, 
    0.00017690f, 0.01720419f, -0.14489758f, 0.02706732f, 0.03299745f, -0.10706364f, 0.05598194f, -0.05627894f, 
    -0.09564570f, -0.01174652f, 0.04366017f, 0.06605037f, -0.04584268f, -0.16033314f, -0.05638360f, 0.12962300f, 
    0.05032109f, -0.02124539f, -0.00037905f, 0.03514311f, 0.03992225f, 0.07847419f, -0.08919254f, 0.05678750f, 
    0.08159177f, -0.04134072f, -0.07957732f, 0.02596410f, -0.08546042f, -0.03095984f, 0.11038230f, -0.10396356f, 
    -0.12122200f, -0.14447306f, 0.07423292f, -0.11890240f, 0.03149767f, -0.07058769f, -0.01541411f, 0.04262508f, 
    -0.26711923f, 0.16135122f, 0.02147371f, -0.14364588f, -0.11436363f, -0.18227145f, -0.00365339f, 0.12784582f, 
    -0.01190859f, -0.00246148f, -0.03350170f, 0.00395363f, 0.04318499f, 0.05581099f, 0.04224053f, 0.09509928f, 
    0.15900947f, -0.14974646f, 0.06264793f, 0.12536904f, -0.21270932f, -0.06843150f, -0.03577411f, -0.11490057f, 
    -0.00444844f, -0.04002941f, 0.06495888f, -0.27826989f, 0.20489243f, 0.15373172f, -0.15163998f, 0.14408231f, 
    -0.00250397f, 0.04423439f, -0.14367133f, -0.10321998f, 0.03509662f, 0.09169482f, 0.04337782f, 0.10190947f, 
    0.30466625f, 0.05425727f, 0.16722545f, -0.11058455f, 0.11747981f, 0.03492440f, 0.03576382f, 0.01620268f, 
    0.12801477f, -0.04683698f, -0.04905508f, 0.02075726f, 0.01971106f, -0.30893445f, 0.01319718f, -0.01541913f, 
    0.01014990f, -0.09109936f, 0.08264291f, 0.10043721f, -0.03734461f, -0.55910891f, -0.17360535f, -0.34963611f, 
    0.07568198f, -0.02842056f, -0.06360571f, -0.04412612f, 0.04291777f, 0.01721201f, -0.10257843f, 0.10033925f, 
    0.07583100f, 0.05874036f, -0.04941575f, 0.00655194f, 0.06848395f, -0.09289937f, -0.10983586f, 0.30901626f, 
    -0.18027544f, 0.08270904f, 0.06220026f, -0.02459778f, -0.09961324f, 0.04197964f, 0.11253516f, 0.08761788f, 
    -0.08444425f, -0.01436001f, -0.23354003f, 0.04390465f, 0.02251684f, -0.00963133f, -0.06142410f, 0.05521088f, 
    0.17242745f, -0.07654797f, 0.04599756f, -0.16286802f, -0.17462949f, -0.02027974f, -0.13558319f, 0.25174397f, 
    -0.05857107f, -0.00285521f, -0.01432988f, 0.02233939f, -0.00574682f, 0.00872359f, 0.04648080f, 0.13351481f, 
    0.07374902f, 0.05194705f, -0.04923285f, -0.05556655f, -0.05830740f, 0.05298023f, 0.06542681f, -0.00454577f, 
    0.02948503f, 0.03967164f, -0.26388943f, -0.10251272f, 0.02176331f, 0.17503737f, 0.10844021f, -0.11661610f, 
    0.09999263f, -0.15339173f, -0.04420904f, -0.28257701f, -0.08293881f, -0.14126013f, -0.05106508f, -0.07771315f, 
    0.02965233f, 0.08717516f, 0.09304999f, 0.07825838f, 0.18433806f, 0.12993473f, -0.00724617f, -0.06087666f, 
    0.02889900f, 0.00587662f, 0.06706139f, 0.08338179f, 0.44673914f, -0.18998368f, -0.17323521f, -0.24248300f, 
    0.09266218f, 0.01738244f, 0.02064264f, -0.01678750f, 0.07640272f, -0.03267680f, 0.11099371f, -0.00468938f, 
    0.03047802f, 0.04071705f, -0.42022318f, -0.01079839f, 0.11826733f, 0.16404119f, -0.03808516f, -0.01184481f, 
    0.07113837f, 0.01037598f, -0.03143407f, -0.05508627f, -0.27935940f, -0.48843515f, 0.25246981f, 0.04914476f, 
    -0.03074709f, -0.00126767f, -0.05976278f, 0.02405878f, 0.01996932f, -0.17345040f, 0.24110062f, -0.07645423f, 
    -0.22392987f, -0.00632079f, -0.13020855f, 0.01450419f, 0.10207243f, -0.16686583f, 0.14708208f, -0.00422983f, 
    0.23565367f, -0.10350642f, 0.02987614f, 0.09107482f, -0.00118949f, 0.32324669f, -0.05964313f, -0.20569684f, 
    0.03067437f, 0.15195455f, 0.00455169f, -0.05783083f, 0.29613477f, 0.03750875f, -0.20618843f, 0.04103379f, 
    -0.25047415f, 0.16914149f, -0.09174624f, 0.06761103f, -0.01724367f, -0.03654663f, -0.00196601f, 0.13946763f, 
    -0.02261887f, 0.03144824f, -0.02857266f, -0.15762727f, 0.06453786f, 0.20046146f, -0.37894598f, -0.31793752f, 
    0.14913464f, 0.03111470f, 0.01453350f, 0.36255631f, 0.02072245f, 0.00959865f, -0.00085659f, 0.14398901f, 
    -0.06744004f, 0.09883182f, -0.23518005f, 0.15621231f, 0.04126169f, -0.00484681f, 0.07108795f, 0.10233900f, 
    -0.01281950f, -0.07733057f, 0.09442956f, 0.03168992f, -0.41281551f, -0.11321419f, -0.17420460f, -0.23583430f, 
    0.03383984f, -0.00996577f, -0.03561128f, -0.00908705f, 0.02602196f, -0.06990227f, 0.00449428f, -0.06634218f, 
    0.19484545f, -0.13317022f, 0.19917366f, 0.07250905f, -0.09838392f, 0.12394203f, -0.06348183f, -0.14905845f, 
    0.09363558f, 0.05788788f, 0.12966576f, 0.03200282f, 0.05288692f, 0.19253004f, -0.05062287f, -0.11782657f, 
    0.16030133f, -0.03263512f, 0.10420642f, -0.03561893f, 0.05131656f, 0.00051163f, 0.12647495f, 0.01011390f, 
    0.02417769f, -0.20487687f, -0.03113715f, 0.11623017f, 0.01190136f, 0.03875721f, 0.06844575f, 0.00443296f, 
    0.05050324f, -0.07762739f, -0.03519744f, -0.31457746f, 0.16528498f, 0.08507414f, -0.00968001f, 0.04178920f, 
    0.22150333f, 0.22622395f, -0.18934508f, -0.17292641f, 0.04892002f, 0.06426843f, 0.04557158f, 0.04204328f, 
    -0.64707935f, -0.21079348f, -0.06581645f, -0.17439426f, -0.03680339f, 0.05531372f, -0.02474075f, -0.12132537f, 
    0.19589964f, 0.13990904f, 0.00845173f, -0.10206316f, 0.30440739f, 0.00193160f, 0.12906653f, 0.26077607f, 
    0.01758015f, 0.11383724f, -0.03233818f, -0.01429382f, 0.04959047f, 0.11328173f, -0.00815709f, 0.13418746f, 
    -0.01505741f, -0.05558320f, -0.36247563f, 0.10423383f, 0.02947028f, -0.00862555f, -0.08691680f, 0.02359857f, 
    -0.07220939f, -0.15327017f, 0.12726519f, 0.15593135f, -0.05324414f, -0.10497475f, 0.09616652f, 0.30118221f, 
    0.12951589f, -0.07450274f, 0.02375807f, -0.03440682f, -0.05880427f, 0.06427132f, 0.02085799f, 0.12579285f, 
    0.43609679f, -0.29895848f, 0.02926008f, 0.19516578f, 0.15145563f, -0.06786065f, 0.01445997f, 0.00954450f, 
    0.01903556f, 0.15145133f, -0.07110944f, 0.02552458f, -0.12680937f, -0.04810052f, 0.01630790f, -0.05394209f, 
    -0.01326693f, -0.07389137f, -0.06728413f, 0.00286316f, 0.10278781f, -0.11310294f, -0.04607688f, -0.07791915f, 
    -0.00951280f, 0.14327016f, 0.00141671f, -0.08827928f, -0.05038784f, 0.10310310f, -0.08991332f, 0.00859990f, 
    0.07608931f, 0.09670796f, -0.01840863f, 0.01781269f, -0.24573746f, -0.02119349f, 0.12543949f, -0.09249623f, 
    0.03031279f, -0.04107447f, 0.00559949f, 0.09433157f, -0.02397353f, -0.08560354f, -0.31002036f, 0.02684738f, 
    -0.05323263f, -0.00496987f, 0.00840451f, -0.09225696f, 0.06047969f, -0.03476208f, -0.02894462f, 0.05724453f, 
    0.15369207f, -0.08158141f, 0.04682791f, 0.10634186f, 0.09094798f, 0.00588979f, -0.08407763f, -0.03715505f, 
    0.01481142f, -0.06708766f, -0.02037613f, -0.03571473f, -0.16439939f, 0.13742292f, -0.03946996f, -0.00196517f, 
    0.62557089f, -0.18227112f, -0.15064265f, -0.01795144f, -0.06988025f, -0.06703722f, 0.03272030f, 0.06242663f, 
    0.01471826f, 0.00641011f, -0.08301456f, -0.20783712f, -0.14947958f, -0.04621871f, -0.14359142f, -0.13153563f, 
    0.00020898f, -0.09547254f, -0.02787400f, 0.11740719f, -0.27785543f, 0.09352428f, -0.06528965f, -0.06609847f, 
    0.19369319f, -0.06101432f, 0.11905272f, -0.09793847f, 0.04189198f, 0.05325159f, -0.00588033f, -0.10763694f, 
    -0.18042390f, -0.04091291f, 0.17274663f, -0.01544227f, -0.01353759f, 0.01698948f, 0.00125915f, -0.03667071f, 
    -0.11586498f, -0.08197825f, -0.08200884f, 0.04644739f, 0.14779615f, 0.01360711f, 0.19298257f, 0.39769733f, 
    -0.26052567f, -0.54302174f, 0.31080815f, 0.09150563f, 0.01136415f, 0.17396836f, 0.00442335f, 0.13164584f, 
    0.04706612f, 0.08756237f, 0.01296258f, 0.01549720f, -0.17770194f, -0.19721606f, 0.01768231f, 0.03220752f, 
    0.01285169f, -0.09218615f, -0.03813494f, -0.06524327f, -0.01732584f, -0.04848133f, 0.03907429f, 0.16764160f, 
    -0.36463732f, -0.07525977f, 0.19821233f, 0.06852688f, -0.01047937f, -0.14387198f, 0.05719179f, 0.20254010f, 
    -0.04083168f, -0.10895487f, -0.01380113f, -0.14307533f, 0.01465608f, 0.24543606f, -0.17989954f, -0.16935131f, 
    -0.19315182f, -0.11895361f, -0.16889511f, 0.06591413f, -0.12218107f, 0.06399091f, -0.17082267f, 0.00523242f, 
    -0.04641350f, 0.09841385f, 0.00797578f, 0.13545978f, -0.01673636f, 0.14437979f, 0.03712359f, 0.07283017f, 
    -0.19069454f, 0.06163085f, 0.02427641f, -0.05720270f, -0.47643471f, -0.17403165f, -0.27227366f, -0.14832623f, 
    -0.08902184f, 0.04041504f, 0.00844487f, 0.06749601f, 0.12902498f, -0.09971354f, 0.05057198f, -0.03812012f, 
    -0.08509741f, -0.13222581f, 0.18043469f, -0.05870383f, 0.05588825f, -0.06400023f, 0.04000970f, 0.04851073f, 
    0.21340203f, 0.14250527f, 0.02715438f, 0.19931318f, -0.09956538f, -0.14568260f, -0.02746493f, 0.13544755f, 
    0.06234882f, -0.03094655f, 0.21909127f, -0.05683556f, -0.11659756f, 0.27678996f, 0.00575990f, 0.02759055f, 
    0.08494227f, -0.16887593f, -0.13009506f, -0.13772430f, 0.03988038f, 0.02498579f, 0.02914281f, 0.06964099f, 
    -0.03656029f, 0.02235279f, 0.04979929f, -0.31660879f, -0.05736990f, 0.07095595f, -0.17202537f, -0.06115248f, 
    -0.05919177f, 0.07344564f, 0.01469532f, 0.34824130f, -0.04276932f, 0.04695865f, 0.09077213f, 0.00446055f, 
    -0.28584734f, -0.07086468f, -0.25903606f, 0.15199549f, 0.07456158f, -0.08710118f, 0.08383528f, -0.01451360f, 
    0.00365816f, -0.00127641f, 0.00400608f, 0.12190725f, -0.02235576f, -0.03357852f, -0.07653294f, -0.16695036f, 
    0.03314182f, -0.01568635f, -0.06277560f, 0.00204761f, -0.05586624f, -0.18091831f, 0.12870926f, -0.12173704f, 
    -0.23412699f, -0.24459533f, 0.12036627f, 0.07576706f, 0.08218070f, -0.06000485f, -0.01800080f, -0.02875592f, 
    0.21714376f, -0.29635304f, 0.03281261f, 0.11313850f, -0.08187634f, 0.23343974f, -0.37133867f, 0.12266563f, 
    0.06624951f, 0.00292567f, -0.04379014f, 0.09891183f, -0.07021984f, 0.06043670f, -0.07913835f, -0.17901626f, 
    0.11075232f, 0.02448550f, 0.00143401f, -0.24396273f, -0.16865553f, 0.06026246f, 0.06747687f, 0.02591961f, 
    0.24104457f, -0.10630488f, 0.05846627f, -0.05221227f, 0.08114287f, 0.03901446f, -0.14409453f, -0.18119715f, 
    -0.01954655f, -0.01717922f, 0.06690764f, -0.04702701f, 0.07052472f, 0.05331388f, -0.01445567f, 0.04562913f, 
    -0.19812892f, -0.05185469f, 0.07701036f, 0.08799855f, -0.18092304f, -0.00417935f, 0.11813907f, 0.07405001f, 
    0.17314887f, 0.07371784f, -0.05341837f, -0.11435262f, 0.11805319f, -0.03614607f, 0.00580300f, -0.00168466f, 
    0.07603618f, -0.00448636f, 0.01387833f, 0.10488196f, -0.33813855f, 0.08968538f, -0.00386534f, -0.14450350f, 
    -0.09848271f, -0.17930622f, 0.03384595f, 0.02995064f, -0.06916817f, 0.00960269f, -0.04278484f, -0.00500209f, 
    0.05693342f, -0.08154991f, 0.24675022f, 0.28997496f, -0.12648201f, 0.08683617f, 0.52082723f, 0.28186756f, 
    -0.00393545f, -0.01189944f, 0.01527932f, 0.01632427f, 0.17110083f, -0.05455614f, -0.40350392f, -0.24122746f, 
    -0.08200260f, -0.15489574f, -0.28196710f, -0.07521051f, 0.17554870f, 0.11756474f, 0.10062295f, 0.10919600f, 
    0.04053126f, 0.07385779f, 0.00184500f, -0.02638071f, 0.11519010f, 0.22281617f, 0.11800206f, -0.11473817f, 
    0.01956095f, 0.06557912f, 0.09600886f, 0.09109984f, 0.09235018f, 0.02527048f, 0.08885705f, 0.04222656f, 
    -0.10195023f, -0.21635842f, -0.16429664f, 0.23844126f, -0.25927255f, 0.11860834f, 0.18593396f, 0.20800129f, 
    0.06843120f, 0.02045581f, 0.14992234f, -0.04961160f, -0.17292498f, -0.18681008f, -0.22955133f, -0.22818068f, 
    -0.07751603f, 0.04476027f, 0.13302325f, -0.07434230f, 0.09174541f, 0.04622067f, -0.04129133f, 0.08364610f, 
    -0.06471620f, -0.02354345f, 0.05627612f, 0.13981950f, 0.09245883f, 0.03467572f, 0.16046725f, -0.00346528f, 
    0.02030259f, 0.11151746f, 0.07601946f, 0.01503326f, -0.01732004f, -0.01351758f, 0.00045258f, -0.05943367f, 
    -0.04592373f, -0.03661222f, -0.03792801f, 0.05546237f, -0.00930730f, -0.08901746f, -0.11613256f, -0.13145159f, 
    -0.20442832f, -0.27216309f, -0.05657884f, 0.25378376f, 0.01743389f, 0.06609014f, -0.01164443f, -0.16896848f, 
    0.02003253f, -0.05267175f, 0.01994383f, 0.04103401f, -0.45157281f, -0.14475809f, 0.18074295f, -0.40511286f, 
    -0.00348957f, -0.07867876f, 0.06531633f, -0.01712131f, -0.00460110f, 0.05049631f, 0.08531215f, -0.10487958f, 
    -0.78555721f, -0.57608771f, -0.09211239f, 0.20106478f, -0.10364296f, -0.03899403f, -0.24427012f, -0.34035406f, 
    0.02126914f, -0.07971784f, 0.06612106f, 0.02631508f, -0.06436914f, 0.22048324f, -0.18774410f, 0.00749792f, 
    -0.03914076f, 0.01896683f, 0.04835685f, 0.16590433f, 0.17940372f, 0.06212687f, 0.47448874f, 0.12950240f, 
    0.12755784f, 0.09739369f, -0.02450682f, -0.03648767f, -0.04647999f, -0.28051093f, -0.11476128f, -0.15942261f, 
    0.00863549f, -0.07933152f, -0.06951761f, -0.01354118f, -0.15602334f, -0.01414907f, 0.09571285f, 0.19923641f, 
    -0.15674518f, -0.03351077f, 0.03193123f, -0.02372028f, -0.10288674f, -0.18236725f, 0.07445424f, 0.05223409f, 
    0.19972192f, 0.05964190f, -0.05895882f, 0.10802763f, 0.03980276f, 0.01947625f, 0.05648302f, 0.05943836f, 
    0.07919142f, -0.04318886f, 0.31380385f, -0.00786037f, -0.03334988f, -0.14474064f, -0.06027635f, -0.11749354f, 
    -0.05792291f, 0.07608739f, 0.21240179f, -0.07750089f, -0.03122913f, -0.05333272f, 0.05896059f, 0.13316306f, 
    0.08882467f, -0.22105707f, -0.06426518f, 0.25987983f, 0.02775279f, 0.05378887f, 0.15618429f, -0.00937099f, 
    0.01619408f, -0.05356173f, 0.02066915f, 0.14575088f, -0.24078727f, -0.78392226f, -0.36359340f, -0.51619983f, 
    0.05897208f, -0.00211941f, -0.07876436f, -0.22181620f, 0.02440933f, -0.00483056f, 0.03070908f, 0.01552900f, 
    -0.27968261f, -0.48803049f, -0.46649686f, -0.21452218f, -0.14536764f, -0.12347844f, -0.00403238f, -0.37074092f, 
    -0.01998858f, 0.01311495f, -0.02002091f, 0.03417893f, 0.03266381f, -0.07111544f, -0.12690507f, -0.07723214f, 
    -0.06573809f, -0.09056502f, 0.00048054f, 0.02856187f, 0.01744214f, 0.16638473f, 0.09884599f, 0.24468809f, 
    0.29636979f, 0.17658408f, 0.16525212f, -0.29003349f, 0.04858916f, -0.09740393f, 0.06770270f, -0.01175320f, 
    0.02549259f, 0.09912408f, -0.02833520f, -0.02813211f, -0.11899156f, 0.02455346f, 0.13779376f, 0.09841651f, 
    -0.00807038f, 0.00137895f, -0.02043303f, 0.03523852f, 0.04058509f, 0.11995009f, 0.06039324f, 0.08429251f, 
    0.20613532f, 0.02403067f, -0.08172195f, 0.05893747f, -0.01636048f, -0.07752992f, 0.12829709f, 0.09941423f, 
    0.08235539f, -0.00205307f, -0.06106400f, -0.09141923f, -0.38655058f, -0.19714010f, 0.24806778f, 0.13083789f, 
    -0.01643203f, -0.00437861f, 0.14369026f, -0.28121197f, 0.02498938f, -0.06854127f, -0.04882960f, -0.01895069f, 
    0.01318854f, -0.06641470f, -0.02454859f, 0.03659915f, 0.02845584f, 0.05106590f, -0.01338762f, -0.02704267f, 
    -0.05449377f, -0.07312001f, 0.06773549f, 0.02562815f, 0.13537973f, -0.36742660f, -0.00819756f, 0.16718794f, 
    0.09808247f, -0.00679482f, 0.14390893f, -0.08806651f, -0.01334770f, -0.06154716f, 0.03576495f, 0.17049399f, 
    0.15103987f, -0.25922737f, -0.05871842f, -0.05904658f, 0.05697120f, 0.04179808f, 0.11642196f, -0.08137818f, 
    -0.03465561f, -0.04942118f, -0.02932503f, 0.05901354f, -0.36241341f, 0.28530982f, 0.28856578f, 0.07879809f, 
    -0.05949704f, 0.04772680f, 0.01851160f, -0.04678795f, 0.06950939f, 0.16158704f, -0.01276956f, 0.07893746f, 
    -0.40453085f, -0.44412422f, -0.07929454f, 0.30622500f, 0.06942747f, 0.08039466f, -0.05978793f, -0.37331924f, 
    0.05232995f, 0.00010946f, 0.04456116f, 0.08864122f, -0.44721010f, -0.68436635f, -0.13658498f, -0.22958781f, 
    -0.23070528f, -0.20050836f, -0.11620988f, -0.27945036f, -0.00461955f, -0.01334640f, -0.04790470f, -0.04484076f, 
    0.11980955f, 0.02264951f, -0.14416075f, -0.09045454f, -0.05121936f, 0.01294120f, -0.04015345f, 0.07145316f, 
    -0.06960989f, -0.01500054f, -0.14746486f, -0.15912215f, -0.43889436f, -0.52411783f, -0.38702977f, -0.24644987f, 
    0.02929932f, -0.29265624f, -0.08438198f, -0.23036158f, -0.01385570f, -0.04025214f, -0.03884488f, 0.02804443f, 
    -0.41603005f, 0.09134622f, 0.60583395f, 0.21119589f, -0.05545176f, -0.07170796f, -0.19659242f, 0.09979878f, 
    -0.12052529f, 0.07486430f, 0.02707004f, 0.05566740f, 0.20342579f, 0.02582000f, -0.24834065f, -0.63498586f, 
    -0.08201529f, -0.19154498f, 0.08518182f, 0.04685451f, -0.08859102f, 0.11695252f, -0.11234770f, -0.04797981f, 
    0.37307808f, -0.04059661f, 0.04734317f, -0.01794034f, 0.00479632f, -0.05811233f, 0.05879900f, 0.01015701f, 
    0.09911287f, 0.01479703f, -0.02123749f, -0.04735936f, 0.03953978f, -0.03729255f, -0.12801589f, 0.04978590f, 
    0.12094181f, -0.03133269f, 0.10864285f, -0.01851653f, 0.01694735f, -0.00572643f, -0.03512521f, 0.03777226f, 
    -0.10200939f, 0.09577949f, -0.09064411f, -0.05746637f, -0.07436307f, 0.01740340f, -0.03654218f, -0.01668315f, 
    -0.08728459f, -0.01653034f, 0.04372909f, 0.01579497f, -0.10940300f, 0.00721427f, -0.03994596f, -0.02005505f, 
    -0.02662945f, -0.00376214f, -0.07287315f, 0.07987295f, 0.08287783f, 0.05171305f, 0.03641211f, 0.06820173f, 
    -0.23665640f, -0.21254492f, -0.10207403f, -0.27025408f, -0.08548749f, -0.08930804f, 0.08201355f, -0.02101682f, 
    -0.01373770f, -0.02576374f, -0.01955767f, 0.00919867f, -0.06140436f, -0.35868755f, -0.03172770f, -0.11294706f, 
    -0.22867544f, -0.01359421f, 0.13414814f, -0.00969807f, -0.07677928f, 0.07047007f, 0.02452923f, 0.01830226f, 
    0.24906987f, 0.09326876f, -0.07878166f, -0.05621385f, 0.06642538f, -0.19498235f, 0.07272893f, 0.08463215f, 
    -0.01131205f, 0.07680909f, 0.01119092f, -0.11149576f, 0.21163647f, 0.21365499f, -0.01940762f, -0.06058475f, 
    -0.05586530f, -0.01793312f, -0.14266938f, -0.06577209f, -0.02451814f, -0.04237276f, 0.04007489f, -0.04000134f, 
    0.54344344f, 0.24971376f, -0.35167471f, 0.11205384f, -0.06740746f, -0.03107298f, -0.13684990f, 0.22167030f, 
    0.07624757f, 0.03957970f, -0.00405638f, 0.04143924f, -0.04455873f, -0.05757631f, -0.02473881f, 0.04526559f, 
    0.07460926f, -0.00503272f, 0.09650078f, -0.13193397f, -0.03068843f, -0.04575023f, 0.07230056f, 0.07555716f, 
    -0.19112903f, 0.57565928f, 0.17203331f, -0.12229744f, -0.13749161f, 0.05212643f, -0.13103564f, -0.07836326f, 
    -0.04863689f, -0.22662956f, -0.03144354f, 0.03322745f, -0.03865090f, -0.04407066f, 0.08702790f, 0.04423875f, 
    -0.05321484f, -0.15055025f, 0.08518148f, 0.05754669f, -0.04547711f, -0.00737567f, 0.00789169f, -0.19373186f, 
    -0.38716772f, -0.47692209f, -0.41872987f, 0.19869144f, -0.14009993f, 0.24772002f, -0.09073554f, -0.11819670f, 
    -0.02497042f, -0.01267659f, -0.02917239f, 0.09317640f, -0.01003295f, 0.02499965f, 0.00190049f, -0.05655373f, 
    -0.00296077f, -0.06821737f, 0.01940601f, 0.00212143f, -0.06259244f, -0.00587061f, -0.06570172f, 0.01388783f, 
    0.07474025f, -0.00002507f, -0.13571909f, 0.01119199f, -0.01124841f, -0.01374604f, 0.03352549f, 0.12195029f, 
    0.07205136f, 0.09279522f, 0.02556071f, 0.08731017f, -0.39195243f, -0.02638022f, 0.07064906f, 0.20456223f, 
    0.11787715f, -0.06637903f, 0.00075979f, -0.08297434f, -0.02620604f, 0.12817353f, -0.04903366f, 0.10659303f, 
    0.36672804f, -0.11220153f, -0.06549608f, 0.01805915f, -0.00430849f, -0.06867899f, 0.10227571f, 0.10381156f, 
    0.08210865f, -0.00330222f, 0.00959657f, -0.11581709f, -0.61262941f, -0.02973249f, 0.22292039f, 0.21232761f, 
    -0.09140069f, -0.02448159f, 0.03401360f, -0.00266254f, -0.04663179f, -0.01160730f, 0.13459118f, 0.01795208f, 
    -0.02357624f, -0.10294593f, 0.03254855f, 0.07204408f, 0.06237677f, 0.02539204f, 0.04260740f, 0.08098646f, 
    0.03709742f, -0.04869386f, -0.02817137f, 0.10079287f, -0.03281986f, -0.09329188f, 0.06756766f, 0.04995684f, 
    0.02399446f, 0.14468186f, -0.34649384f, -0.12251201f, 0.04999236f, -0.17271085f, 0.06251758f, -0.13356660f, 
    0.21070744f, 0.24444802f, 0.07957275f, 0.09692377f, -0.01280888f, 0.03705523f, 0.00625565f, -0.03327959f, 
    0.07833154f, 0.03384267f, -0.00475030f, 0.18447727f, 0.18719862f, 0.03748857f, -0.03455941f, -0.01623435f, 
    0.06156581f, -0.02914624f, 0.09904987f, 0.10806995f, 0.07449576f, 0.07742427f, -0.00383666f, -0.21968874f, 
    -0.05947126f, -0.21894795f, -0.14776175f, 0.00131406f, 0.03753711f, 0.04082105f, 0.13973890f, -0.05518804f, 
    0.02066371f, -0.01281241f, -0.02521271f, 0.03102654f, -0.64547771f, -0.47962549f, -0.22554934f, 0.07966893f, 
    -0.07646488f, 0.02111978f, 0.17843878f, 0.02235480f, -0.00778015f, 0.04494973f, 0.08049585f, -0.09811630f, 
    0.10825948f, -0.01606151f, 0.04591494f, 0.01021477f, -0.02366592f, 0.01164810f, -0.07916599f, 0.08904473f, 
    0.00050312f, 0.09931788f, 0.23223394f, -0.01375453f, 0.11334781f, -0.00352210f, -0.14694759f, -0.43673775f, 
    0.04656121f, 0.12150546f, 0.07292406f, 0.06460609f, 0.01638800f, 0.15403153f, 0.05721946f, -0.03392840f, 
    -0.04821561f, 0.22845508f, 0.28776523f, 0.02935923f, -0.00123471f, -0.10319140f, -0.05706470f, 0.00030819f, 
    -0.08180498f, -0.02337669f, -0.15746826f, -0.00661894f, -0.61073953f, 0.32496411f, 0.33507165f, -0.17841737f, 
    -0.06358667f, -0.26600528f, -0.14017053f, -0.08058388f, -0.05756383f, 0.01218113f, -0.04098840f, 0.02017748f, 
    -0.12199707f, -0.16397463f, -0.02584585f, 0.17631042f, 0.00586188f, 0.12301464f, -0.02269174f, -0.18605773f, 
    0.01927747f, -0.02786839f, 0.05094986f, 0.01133298f, 0.08413006f, 0.01946129f, -0.01608578f, 0.01761412f, 
    -0.05372833f, 0.05402345f, 0.09842119f, -0.03496276f, 0.24330769f, 0.03637412f, 0.06213754f, 0.06971654f, 
    -0.12901251f, 0.03269501f, -0.00650010f, -0.17168127f, 0.04203354f, -0.15100831f, 0.04626064f, -0.07413298f, 
    0.01930287f, 0.12489826f, -0.13375261f, 0.03728694f, 0.12392742f, -0.28788084f, -0.37623265f, -0.19841669f, 
    -0.06229237f, -0.00000107f, 0.06018950f, 0.01417257f, 0.01529543f, 0.03290514f, 0.18818767f, 0.05694829f, 
    -0.20196304f, -0.02362023f, -0.07689094f, -0.04093255f, 0.03652536f, 0.14791831f, -0.03492749f, -0.12469288f, 
    -0.00090182f, -0.01203893f, -0.02554981f, 0.04018588f, -0.51581985f, -0.66544825f, -0.34005800f, -0.02218856f, 
    -0.06774279f, -0.15463561f, -0.21971384f, -0.10081448f, 0.01312131f, -0.00167359f, -0.03255671f, -0.01201293f, 
    0.24411765f, -0.30505267f, -0.35821432f, -0.24285021f, 0.05524039f, -0.10344537f, -0.08753085f, 0.12390990f, 
    -0.00699490f, -0.00225917f, -0.01768273f, 0.11338803f, -0.19916172f, 0.11695745f, -0.08312800f, 0.16039386f, 
    0.13356861f, 0.07937571f, 0.13273054f, 0.02890698f, -0.01360404f, 0.00513514f, -0.05839753f, 0.06619854f, 
    0.03220922f, 0.04360741f, 0.10573357f, -0.08966468f, 0.05071974f, -0.13116983f, 0.00640181f, 0.07924896f, 
    -0.05831655f, -0.05157663f, 0.01854199f, -0.00231189f, -0.00742602f, 0.11478813f, -0.05295811f, 0.00695354f, 
    0.02438888f, 0.03005602f, -0.00340171f, -0.00467081f, 0.07800580f, -0.04559081f, -0.09318376f, -0.13217735f, 
    -0.12910144f, -0.20007911f, 0.17888597f, -0.17609757f, 0.06142247f, 0.05668072f, 0.15788573f, 0.02447151f, 
    -0.02613498f, -0.07505433f, -0.02564968f, 0.03185860f, -0.54368317f, 0.65585411f, -0.32037729f, 0.02604257f, 
    0.04345955f, -0.17700920f, 0.03644648f, -0.02014377f, -0.10344918f, -0.02063869f, -0.08319566f, -0.01170524f, 
    -0.21309590f, -0.45180753f, 0.16513449f, 0.25635162f, 0.04611437f, 0.04144946f, 0.04543179f, 0.07224033f, 
    -0.01507862f, 0.03383921f, 0.00964670f, 0.02055422f, 0.05989557f, -0.26912999f, 0.08619997f, 0.03244895f, 
    0.06319588f, -0.07906764f, 0.01033470f, -0.08173075f, 0.13024218f, 0.15207618f, 0.16332410f, 0.02385657f, 
    -0.00497672f, -0.00318684f, -0.00804151f, 0.03193137f, -0.02414567f, 0.04046313f, -0.04119635f, 0.00097418f, 
    -0.00370148f, 0.02674904f, 0.06031576f, 0.08458646f, 0.20150171f, -0.00551388f, -0.11515746f, -0.02203037f, 
    0.04452037f, 0.00477088f, 0.00922259f, -0.09762602f, -0.11460049f, -0.00670724f, -0.02490011f, 0.00606843f, 
    -0.11576129f, 0.00386091f, 0.13093795f, 0.08035897f, 0.05327807f, -0.03117150f, 0.01644201f, -0.02925132f, 
    -0.11299123f, -0.05736563f, -0.00990965f, -0.11539585f, -0.03267271f, 0.14576493f, -0.20711014f, -0.03169753f, 
    -0.05586769f, -0.12515087f, 0.03661809f, -0.01798071f, -0.00402828f, 0.05383012f, -0.01745596f, -0.01291139f, 
    -0.03207389f, -0.01237376f, 0.10239659f, -0.11312798f, -0.05371089f, 0.04422786f, 0.02630893f, 0.07268924f, 
    0.14320476f, 0.06548924f, 0.02158516f, -0.03196871f, -0.49053138f, -0.17822334f, -0.09328040f, 0.54974693f, 
    0.06015771f, 0.06463332f, -0.09151801f, 0.05751147f, 0.01865100f, -0.09688342f, 0.04144202f, 0.00745896f, 
    -0.21068728f, -0.32737622f, -0.21980472f, 0.02094058f, 0.02589585f, -0.01010020f, 0.00513177f, 0.22005066f, 
    0.01564212f, -0.03249776f, -0.08251353f, -0.03856072f, 0.02014038f, 0.06674638f, -0.04576204f, 0.09598790f, 
    -0.01310270f, 0.06342196f, 0.00779121f, 0.03887459f, -0.02785099f, 0.05080316f, 0.10216337f, 0.02046076f, 
    -0.20254037f, 0.19362408f, -0.05109615f, 0.14369503f, -0.08278595f, 0.00330820f, 0.13568164f, -0.00426560f, 
    -0.07507900f, -0.04270581f, 0.01886729f, 0.05302732f, 0.30508178f, 0.01782919f, 0.00074038f, -0.32653278f, 
    0.03088284f, 0.06684402f, -0.03916762f, 0.01560137f, -0.02272200f, 0.01104246f, -0.06431156f, -0.08732437f, 
    -0.02819331f, 0.02439724f, -0.01800851f, 0.04123930f, -0.06966714f, 0.06770209f, -0.01230285f, -0.10871208f, 
    -0.11986197f, -0.05054371f, -0.02934850f, -0.03931250f, 0.02206050f, 0.06804124f, 0.08296731f, -0.09049028f, 
    -0.02183752f, 0.06614023f, 0.02356079f, 0.07602935f, -0.08184568f, 0.01907493f, 0.03485462f, -0.02466155f, 
    -0.01939663f, 0.05306499f, 0.05447660f, 0.03670378f, -0.00491343f, 0.05186212f, -0.04683365f, -0.00903096f, 
    -0.03640676f, 0.01653826f, 0.05427398f, 0.01015799f, 0.14485694f, 0.27771425f, 0.11538758f, -0.16402484f, 
    -0.05950679f, 0.00471784f, -0.07038713f, 0.05419166f, -0.02795720f, -0.07523415f, 0.04188626f, -0.05119250f, 
    -0.14939752f, 0.11138099f, 0.05606243f, 0.04881760f, 0.10231908f, -0.10248201f, 0.07467090f, -0.00746054f, 
    -0.00346913f, -0.12021902f, 0.04167938f, -0.02264753f, 0.34084821f, -0.27231303f, -0.35087705f, -0.33235517f, 
    0.00195218f, -0.06380283f, -0.00241625f, 0.06723356f, 0.14434582f, 0.03956089f, 0.02451562f, -0.08089576f, 
    0.31493086f, -0.44210994f, 0.41882193f, -0.56157386f, -0.23666206f, 0.11649548f, -0.17083147f, 0.17010982f, 
    -0.02224391f, -0.00123430f, 0.01752902f, -0.05875009f, -0.30630413f, -0.07467695f, -0.06570742f, 0.12906241f, 
    -0.06557982f, -0.02655721f, 0.00296756f, 0.04233227f, 0.00007919f, -0.01484516f, 0.03620857f, 0.01898903f, 
    0.01942300f, -0.01210907f, 0.08862232f, -0.00492844f, 0.02465546f, -0.05586229f, -0.05886355f, -0.02638022f, 
    0.11049990f, -0.12139842f, 0.07872693f, 0.05484316f, -0.26556599f, 0.16477109f, -0.17891280f, 0.32883006f, 
    0.02496708f, 0.03274029f, 0.12486506f, 0.07516731f, -0.01688839f, -0.05825457f, -0.07245387f, -0.03526330f, 
    0.60980338f, -0.12028877f, -0.45733342f, -0.35449222f, -0.04227510f, -0.04154309f, -0.01420342f, 0.05181919f, 
    -0.03745867f, 0.01271130f, 0.14079215f, 0.03134274f, -0.42311463f, -0.21725217f, -0.28003898f, 0.21826787f, 
    -0.11122347f, -0.02368092f, -0.10332134f, -0.19983850f, 0.00373438f, -0.03424349f, -0.02157093f, -0.09767666f, 
    -0.32730100f, 0.24644727f, -0.32150826f, 0.18921997f, -0.01804430f, 0.11403788f, 0.06899460f, 0.00199987f, 
    -0.00265999f, -0.01587574f, 0.05414300f, -0.02385673f, 0.11507854f, -0.05909575f, 0.08058355f, -0.14309393f, 
    0.00737335f, 0.04050983f, -0.09412866f, 0.04257051f, -0.01422587f, 0.05919510f, 0.01482813f, 0.00649678f, 
    0.26444551f, 0.05564025f, -0.06478605f, -0.06408849f, 0.06046710f, 0.02898031f, -0.07635990f, -0.13930500f, 
    -0.09392417f, 0.15693708f, -0.05448090f, -0.09806475f, 0.27145794f, -0.20818715f, -0.05464070f, -0.11692926f, 
    -0.05785129f, 0.02479350f, -0.06005368f, -0.10491627f, 0.07773722f, 0.11179722f, -0.00887866f, -0.10254503f, 
    -0.26443750f, 0.11075705f, 0.21037641f, 0.06301212f, 0.09718740f, 0.01385488f, 0.10454212f, 0.05869526f, 
    -0.02755690f, 0.04212121f, 0.03258980f, 0.03135077f, -0.28080612f, -0.26624906f, -0.24861725f, 0.10312487f, 
    -0.06456111f, 0.18760440f, -0.02104523f, 0.05233885f, 0.05805721f, 0.00888822f, -0.08940754f, 0.15852435f, 
    -0.17620456f, 0.00665248f, 0.02692476f, 0.13813846f, 0.01368188f, -0.04126567f, -0.03256686f, -0.00025620f, 
    -0.01724704f, -0.14096282f, -0.04605246f, -0.01715216f, -0.00865866f, -0.03902981f, -0.01958060f, 0.01884638f, 
    0.01968899f, 0.00841921f, -0.01182282f, 0.06070444f, -0.11619005f, 0.01791402f, 0.10113971f, 0.03002457f, 
    -0.11454926f, -0.23367448f, -0.15104131f, -0.04094396f, -0.05457590f, -0.02907205f, 0.00310258f, -0.02740167f, 
    -0.09663630f, 0.06098878f, 0.11077033f, -0.07291450f, 0.05466176f, 0.03709378f, 0.00258602f, 0.04895014f, 
    0.00003149f, -0.02213019f, -0.08725182f, -0.10150078f, -0.03191778f, 0.09009232f, 0.07510225f, 0.03580633f, 
    -0.31830239f, -0.28789118f, -0.35402772f, 0.13040581f, 0.04283560f, -0.11402990f, 0.07295117f, -0.07371094f, 
    -0.03018147f, -0.03755112f, 0.07629565f, 0.06999572f, 0.14249708f, 0.04667510f, 0.01895018f, -0.12326456f, 
    -0.10952032f, 0.06199555f, -0.03591614f, 0.04490551f, -0.01129165f, -0.00854579f, 0.04126397f, 0.02388451f, 
    0.05593712f, -0.06322944f, -0.14754611f, 0.00840891f, -0.18606158f, -0.12577622f, 0.02236578f, -0.09089737f, 
    0.02463320f, 0.05713617f, 0.03601470f, -0.04949237f, 0.06738542f, 0.07703739f, -0.09446766f, -0.07078840f, 
    0.00483718f, 0.06234280f, 0.02139160f, -0.00897626f, -0.07500390f, -0.08109844f, -0.26052853f, -0.24615405f, 
    0.29590490f, -0.09659909f, 0.11488811f, -0.05983361f, 0.01130838f, 0.02240548f, -0.10277915f, -0.12462766f, 
    -0.10596389f, -0.10371437f, -0.05259849f, 0.06755923f, -0.01789871f, -0.01797229f, 0.15487595f, -0.14698084f, 
    0.00234020f, -0.13106656f, 0.02903536f, 0.03222147f, -0.05978739f, 0.07135157f, -0.02764521f, -0.09654961f, 
    -0.20051679f, 0.08066276f, -0.14084449f, 0.11057115f, 0.01146519f, -0.06157043f, 0.04302182f, 0.03456939f, 
    0.01808049f, -0.02766997f, 0.02933054f, -0.07071438f, 0.17568025f, -0.45590252f, -0.44908679f, -0.43489453f, 
    -0.10494564f, -0.06794634f, -0.08898941f, 0.08304807f, 0.08513964f, 0.06210778f, -0.02432187f, 0.02202143f, 
    0.13187420f, -0.07914826f, 0.14012045f, -0.28094351f, 0.03654732f, 0.00984436f, -0.12624457f, 0.02022246f, 
    -0.03089876f, -0.03799525f, -0.04449072f, -0.03990032f, 0.15245499f, -0.11463434f, -0.06781169f, 0.05167038f, 
    -0.04595952f, -0.14337109f, -0.28956482f, 0.00318337f, -0.10618777f, 0.13939326f, -0.11194846f, 0.02099977f, 
    -0.14852488f, -0.25985393f, -0.00320450f, -0.12244868f, -0.04955636f, 0.04570111f, 0.01210409f, 0.05991686f, 
    -0.00963593f, 0.04147887f, -0.07714041f, 0.00227648f, -0.03401914f, 0.09099140f, 0.14234434f, 0.02177405f, 
    -0.05056558f, 0.00013036f, 0.00866882f, 0.09273151f, -0.03072174f, 0.00543150f, -0.08703716f, -0.04977728f, 
    0.06784853f, 0.10341244f, -0.03298879f, -0.08576450f, 0.05216792f, -0.05937191f, 0.01646648f, -0.01465039f, 
    0.00887742f, 0.06794811f, 0.02563001f, -0.00276064f, -0.35083187f, -0.38222608f, -0.23158176f, -0.38488275f, 
    -0.09646320f, 0.04431316f, 0.14780839f, 0.09384235f, 0.08901490f, -0.01319502f, -0.01931345f, -0.04890466f, 
    0.18549013f, -0.00206788f, 0.00850500f, -0.21133459f, 0.03642993f, -0.01169561f, 0.03828074f, 0.02553281f, 
    -0.02618781f, -0.01553435f, 0.01595922f, -0.36909401f, -0.38513941f, 0.35619321f, -0.28856233f, 0.18369871f, 
    -0.11735849f, 0.03831715f, -0.11087852f, 0.03485338f, 0.00490975f, 0.08598787f, -0.02102409f, 0.02620488f, 
    -0.05996114f, -0.12362143f, 0.24514735f, -0.02150133f, 0.03550879f, 0.08497736f, -0.01601663f, 0.01340025f, 
    0.00846583f, -0.06298525f, 0.12897246f, 0.06751280f, -0.43578258f, -0.13292506f, 0.04050867f, -0.07475700f, 
    0.13400818f, -0.10651311f, 0.08031529f, -0.03316201f, -0.08986606f, -0.03779021f, 0.02484193f, 0.07770989f, 
    0.04019042f, 0.06090134f, 0.05561755f, 0.00007804f, -0.04058477f, -0.03283849f, 0.04194960f, 0.09568787f, 
    -0.01542826f, 0.00820428f, 0.00508460f, -0.05491861f, 0.02325169f, -0.10707331f, 0.03943131f, -0.03849183f, 
    0.01568975f, 0.03826222f, 0.01192182f, 0.02875748f, -0.00761760f, -0.01904436f, -0.04602515f, -0.02812454f, 
    0.10705119f, 0.04900311f, -0.01621445f, -0.04438653f, 0.07417032f, 0.02199932f, -0.00636692f, 0.00760857f, 
    -0.04834219f, -0.03984649f, -0.00470865f, -0.03253387f, 0.36113217f, -0.22694834f, 0.05500333f, 0.13772984f, 
    -0.08120918f, -0.09110403f, -0.03022927f, -0.07679400f, 0.08736917f, 0.04678660f, -0.02625211f, 0.05233727f, 
    0.16559479f, -0.16960797f, -0.19506240f, -0.16505839f, 0.04439382f, 0.01133628f, -0.11286258f, -0.06278026f, 
    0.06392026f, 0.01722666f, 0.05792055f, 0.00032585f, -0.35524634f, -0.13659695f, 0.31231362f, 0.03853085f, 
    0.02432371f, -0.09612710f, 0.06746044f, 0.02356968f, -0.02315067f, -0.05021134f, -0.07572660f, -0.05167289f, 
    0.11889408f, 0.06986558f, -0.33972585f, 0.03370732f, 0.01976122f, 0.07884009f, 0.10853634f, 0.00460473f, 
    0.02777127f, -0.04602259f, 0.00543283f, -0.10453144f, -0.30231610f, -0.11682330f, 0.03370627f, 0.22900712f, 
    0.09545093f, 0.15297592f, -0.00093308f, -0.12735978f, 0.00888235f, -0.03247238f, -0.07301943f, -0.00216565f, 
    0.06105070f, 0.12344050f, -0.10919322f, -0.03453687f, 0.04194415f, -0.00087613f, 0.09007415f, 0.02010913f, 
    0.02495614f, 0.04071143f, -0.06759388f, -0.03881957f, -0.16007236f, 0.04196350f, -0.05075205f, -0.13126099f, 
    -0.02854118f, 0.03266182f, -0.02921609f, -0.01975825f, 0.01408237f, 0.05047709f, 0.09710587f, 0.12917089f, 
    0.02640757f, -0.00999423f, 0.04104388f, 0.14419366f, 0.12160736f, 0.04972082f, -0.10038222f, -0.13085027f, 
    -0.06301229f, -0.02301423f, -0.06879486f, -0.07832695f, -0.18280445f, -0.21002632f, 0.16252676f, 0.36769390f, 
    -0.10227259f, 0.02174069f, 0.01451310f, 0.00858953f, -0.01356197f, 0.09411151f, 0.17275612f, -0.04803505f, 
    0.29190147f, -0.16705249f, -0.28130296f, -0.10359949f, -0.09078097f, 0.09985949f, 0.12989055f, -0.02138479f, 
    -0.00680191f, 0.00835723f, 0.06245895f, 0.03231454f, 0.17765677f, -0.12556519f, -0.06177296f, -0.06818599f, 
    0.00903172f, -0.01815536f, 0.03415172f, -0.07725541f, -0.09330073f, -0.20515829f, -0.15046541f, -0.30285826f, 
    -0.13717842f, -0.14608794f, -0.09561676f, -0.02794110f, -0.00513194f, -0.03448071f, 0.04460267f, 0.09031144f, 
    0.00928031f, 0.03316904f, 0.00946566f, 0.02190662f, 0.02652882f, -0.02017015f, -0.13523544f, -0.07061848f, 
    0.11354904f, -0.04732092f, 0.00897986f, 0.06387350f, 0.03297530f, 0.12784632f, 0.03507658f, 0.21542870f, 
    -0.31314462f, -0.02834435f, 0.18182272f, -0.02691259f, -0.07108919f, -0.00690741f, -0.01830245f, -0.04737891f, 
    0.00546808f, -0.09469555f, -0.09469291f, -0.17153297f, -0.18528725f, -0.02479541f, 0.16753879f, 0.04837378f, 
    0.17142674f, -0.02685285f, -0.02853257f, -0.09302393f, 0.02542960f, -0.13312645f, -0.06233085f, -0.07814354f, 
    -0.09918417f, -0.11027198f, 0.08376537f, -0.25445944f, -0.07287209f, -0.06954215f, -0.10402785f, -0.10490146f, 
    -0.13951616f, 0.13732880f, -0.08430784f, 0.01741492f, 0.16462901f, -0.12627794f, -0.28472376f, -0.26225513f, 
    0.08437807f, -0.06505267f, 0.10392791f, 0.04871110f, 0.00899028f, 0.11992468f, -0.03239575f, -0.09464227f, 
    0.03153203f, -0.22617550f, -0.40746874f, -0.38501292f, -0.17927891f, -0.26739252f, -0.14567809f, -0.28721365f, 
    -0.04147591f, -0.04291460f, -0.05250428f, -0.00474212f, -0.51506758f, 0.15875240f, 0.03505179f, 0.25805932f, 
    0.00434320f, 0.02690636f, -0.04756570f, -0.02761541f, -0.01277725f, 0.12408184f, -0.10893390f, 0.01217319f, 
    -0.62049776f, -0.07033993f, 0.23930420f, 0.18304105f, -0.02255792f, -0.00712246f, -0.20969722f, 0.06175923f, 
    -0.11509517f, 0.01140303f, 0.03862472f, 0.04544979f, -0.04036290f, -0.06085733f, -0.20922470f, -0.12294922f, 
    0.01315561f, -0.01519902f, 0.03958501f, -0.00226148f, 0.02385963f, 0.02580774f, -0.03562229f, 0.00039751f, 
    -0.07701605f, 0.04164729f, -0.01286200f, -0.04323295f, 0.06847788f, 0.04663911f, -0.08122408f, 0.00094829f, 
    0.02570486f, 0.03715757f, 0.07439286f, 0.10462008f, 0.02357931f, -0.01747315f, -0.01596516f, -0.18776600f, 
    -0.21600708f, -0.07003399f, 0.12612452f, 0.02324341f, 0.11157800f, 0.11801548f, 0.06305845f, 0.01505512f, 
    -0.27527398f, 0.01217728f, 0.15894814f, 0.01327749f, -0.04820310f, -0.03072754f, -0.13164808f, -0.02767152f, 
    -0.25825796f, -0.02727957f, -0.05616900f, -0.16474269f, -0.43955576f, -0.27159142f, 0.33794731f, 0.23481111f, 
    -0.01694612f, 0.03372072f, -0.06987844f, 0.08137758f, -0.01019066f, -0.05628967f, 0.00881130f, 0.11680612f, 
    -0.13662837f, -0.09006264f, -0.01097922f, 0.15290676f, 0.10565101f, -0.01925129f, -0.10713425f, 0.01195901f, 
    -0.00583643f, 0.06194277f, 0.00188262f, -0.02149215f, -0.29128820f, -0.20414740f, -0.13964316f, -0.00276457f, 
    -0.00991553f, 0.01681035f, 0.06127727f, 0.00044509f, 0.04257080f, -0.02007305f, -0.00641538f, -0.27900463f, 
    0.27909568f, 0.56261748f, -0.16797549f, -0.33455002f, 0.13150206f, -0.13757427f, 0.02037081f, -0.14914656f, 
    0.00259311f, 0.08038600f, 0.01468398f, 0.13218115f, -0.37042212f, -0.30827075f, -0.40339220f, -0.10110157f, 
    0.01232901f, -0.01875614f, -0.00618307f, -0.07715784f, -0.00889954f, 0.00091186f, 0.02366574f, 0.07083596f, 
    -0.38216755f, 0.10869705f, -0.07613576f, -0.10762896f, 0.02732501f, -0.03760327f, -0.00581540f, -0.06696177f, 
    -0.22610995f, -0.05677302f, -0.27937669f, -0.09298931f, -0.29955193f, -0.43748876f, -0.27929229f, -0.13395919f, 
    -0.08137383f, -0.07830902f, -0.21379143f, -0.21893786f, 0.00633572f, 0.04359588f, 0.00238558f, 0.04995053f, 
    -0.27900371f, -0.45275009f, -0.13361481f, 0.01593043f, -0.11872447f, 0.14991517f, 0.13402355f, 0.09311043f, 
    0.15421134f, 0.13205811f, 0.05040767f, 0.02660301f, 0.29705372f, 0.13712473f, -0.07661425f, 0.21879704f, 
    0.16523097f, 0.01325390f, 0.02775575f, 0.20259523f, 0.15627657f, 0.13118844f, 0.11683402f, 0.17820743f, 
    -0.30390576f, 0.06510440f, 0.08143185f, 0.31689194f, 0.00728354f, 0.06216790f, 0.08710670f, 0.15695202f, 
    -0.14360456f, -0.04056526f, -0.00862952f, 0.09196185f, 0.15487561f, 0.14832528f, -0.00465484f, 0.05163908f, 
    0.00613000f, -0.10305953f, -0.04796305f, -0.05537730f, 0.04061536f, 0.04949540f, 0.11851005f, 0.04594352f, 
    0.31438255f, 0.06672368f, -0.19379969f, -0.08165297f, 0.11650803f, 0.08576725f, 0.08571573f, 0.03883624f, 
    0.08317890f, -0.04460157f, 0.04402361f, 0.04217586f, -0.07254072f, -0.15127559f, -0.14413475f, -0.06935115f, 
    0.08564574f, 0.05226720f, 0.04597719f, 0.05405096f, -0.05091182f, -0.10934217f, -0.12776330f, -0.14514479f, 
    -0.21458341f, -0.13155414f, 0.17660950f, 0.23026191f, -0.06459445f, -0.02969303f, 0.00991653f, -0.06638089f, 
    0.03397385f, 0.01286471f, 0.09558783f, 0.06276399f, -0.15632845f, -0.21523562f, -0.23233813f, 0.03317309f, 
    0.11112333f, 0.02824076f, -0.03943930f, 0.08104208f, -0.00596326f, 0.01139890f, -0.03326320f, -0.29254436f, 
    -0.39217386f, -0.08590331f, 0.01089157f, 0.11438317f, 0.06952661f, 0.05120151f, 0.04025079f, -0.00322379f, 
    0.02611949f, 0.09565327f, 0.11391661f, 0.26564708f, -0.10199090f, -0.08386414f, -0.10183417f, -0.06082483f, 
    -0.03072556f, -0.01205452f, -0.01081630f, -0.01800910f, -0.00619577f, 0.02902050f, -0.12532061f, -0.10919979f, 
    -0.26325727f, -0.01371568f, -0.06625396f, -0.03474658f, 0.13055372f, 0.06365179f, 0.08413511f, 0.01171600f, 
    -0.12451390f, -0.07674713f, -0.00732955f, 0.12067711f, -0.09844372f, -0.07340284f, 0.05421611f, -0.09907781f, 
    -0.02793130f, -0.02492048f, 0.04868613f, -0.15020548f, -0.05667826f, -0.03841560f, -0.10698928f, -0.07980911f, 
    0.25747085f, -0.37431869f, -0.26533884f, 0.00856294f, -0.05759341f, 0.01847887f, 0.08590141f, 0.10430065f, 
    -0.22920643f, 0.10084651f, 0.05186445f, 0.01237815f, -0.02658802f, -0.13206525f, -0.11376292f, 0.04080844f, 
    0.03436957f, -0.11484306f, 0.02063877f, 0.09343052f, 0.09562223f, 0.07750681f, 0.01766380f, 0.08444670f, 
    0.56187212f, 0.24326409f, 0.10437737f, -0.18789425f, 0.10140353f, -0.21468225f, -0.03479667f, -0.00607953f, 
    0.01032929f, 0.01952765f, 0.03535615f, -0.01945495f, -0.08068068f, -0.07116191f, -0.06695861f, -0.12453355f, 
    -0.06038323f, 0.00125801f, -0.00837239f, -0.00599599f, 0.14398994f, 0.05669410f, 0.07119363f, 0.06895684f, 
    0.31876636f, 0.20477946f, -0.07749279f, -0.21683806f, -0.01074108f, -0.04027584f, 0.13518474f, -0.03901353f, 
    0.02396168f, 0.06791686f, -0.07600848f, 0.02679434f, 0.19005954f, 0.17402202f, -0.22923718f, 0.04216272f, 
    -0.18804552f, 0.04150990f, 0.08589123f, -0.14227106f, 0.13053554f, -0.08933983f, 0.10883605f, 0.07348951f, 
    -0.02752722f, 0.16367206f, -0.03944097f, 0.06607279f, 0.08686786f, 0.01811297f, -0.05072930f, 0.07600219f, 
    -0.02120663f, -0.02366139f, 0.18091266f, 0.02557521f, -0.60233653f, -0.56497765f, -0.49112654f, 0.13190190f, 
    0.14075060f, 0.22925098f, 0.18160416f, 0.17882560f, -0.01578106f, -0.02243095f, 0.04613723f, 0.04168096f, 
    0.18373238f, 0.07840310f, 0.06164384f, -0.13871828f, 0.11701397f, -0.12299652f, 0.00764003f, 0.02364351f, 
    0.09328625f, 0.05664482f, 0.02245566f, 0.06119798f, 0.25798771f, -0.09900551f, -0.05142902f, 0.05353246f, 
    0.08500948f, 0.13020270f, 0.11505224f, 0.02275122f, -0.13483003f, -0.06580138f, 0.03283758f, 0.03389791f, 
    -0.14469376f, -0.13568504f, 0.04239490f, 0.02467470f, 0.00601899f, 0.06214296f, 0.06295873f, -0.02932189f, 
    0.00919036f, -0.01641295f, -0.07292794f, -0.10828184f, -0.15168126f, -0.19489415f, 0.03543173f, 0.09918431f, 
    -0.00843420f, 0.00603019f, -0.06353652f, 0.01676623f, 0.09180287f, -0.07889347f, -0.00179014f, -0.13080426f, 
    -0.04593710f, 0.09975571f, -0.00963290f, 0.02894163f, -0.07577670f, 0.00869729f, 0.02066068f, 0.00618458f, 
    -0.04779290f, 0.07252824f, 0.01309138f, -0.00050074f, 0.00247835f, -0.23168471f, -0.30421090f, -0.07491287f, 
    -0.04767479f, 0.12870689f, -0.00836982f, -0.12683329f, -0.11424511f, -0.07569532f, -0.13596997f, -0.11569510f, 
    0.02656395f, -0.08399040f, -0.07626900f, -0.15332764f, -0.05093367f, -0.00933971f, -0.03401904f, -0.02076155f, 
    0.08648209f, 0.14579734f, 0.00741806f, 0.16726555f, -0.28225037f, 0.02765779f, 0.14458153f, 0.28827247f, 
    0.07634719f, 0.12599169f, -0.04025756f, 0.19422112f, -0.05068488f, -0.03816083f, 0.04413880f, -0.05507711f, 
    0.15805544f, -0.24480537f, -0.13150021f, -0.00701576f, -0.03979598f, -0.03087855f, -0.06567869f, -0.01493138f, 
    0.05145989f, 0.05622602f, -0.00231532f, -0.01005855f, -0.20477271f, -0.55553997f, -0.37812567f, -0.10574783f, 
    0.06514423f, 0.10401458f, 0.08795725f, -0.00371033f, -0.09874569f, 0.16328229f, 0.05606591f, 0.00592205f, 
    0.04196962f, -0.06532001f, 0.12795913f, -0.12832443f, -0.10889261f, -0.00076492f, 0.00893071f, -0.00321740f, 
    -0.04071647f, 0.10949107f, 0.05417984f, 0.11293530f, 0.04596404f, -0.09823706f, 0.01393155f, 0.01815433f, 
    0.05098483f, -0.02894840f, 0.04123645f, 0.04607315f, -0.12701751f, -0.13683680f, -0.17506836f, -0.26882190f, 
    -0.00650170f, -0.01136559f, -0.01839894f, -0.05499454f, -0.02833285f, -0.00170119f, 0.03560278f, 0.04759860f, 
    0.07529181f, 0.07547007f, 0.08257821f, 0.08709740f, 0.56203806f, 0.01434674f, -0.23647432f, -0.32888675f, 
    0.07167319f, -0.01311446f, 0.03013180f, 0.05335357f, 0.06261735f, 0.07676011f, 0.05915694f, -0.10898732f, 
    -0.01642222f, -0.14775859f, -0.16714799f, 0.05145399f, -0.08109304f, 0.07149563f, 0.10518983f, 0.23239201f, 
    -0.00009476f, -0.07134694f, -0.00639107f, 0.03544869f, -0.02069012f, -0.38425395f, -0.05162694f, -0.00320518f, 
    0.03918818f, -0.01984297f, -0.17553262f, -0.08816045f, 0.00723694f, 0.11380065f, 0.07038564f, 0.08365065f, 
    -0.31412029f, 0.03352772f, 0.08899846f, -0.00976933f, 0.03536189f, -0.07024141f, -0.35906127f, -0.01056495f, 
    0.01068214f, -0.00476235f, 0.13492987f, 0.09556900f, -0.09128367f, 0.23680572f, -0.27204764f, -0.16861680f, 
    0.02151815f, -0.05481420f, 0.08930679f, 0.17596753f, 0.03823940f, 0.06628139f, -0.04961113f, -0.02995794f, 
    -0.05666279f, -0.26384068f, 0.17818661f, 0.09673530f, 0.02610979f, 0.05435558f, -0.22924128f, 0.09096728f, 
    0.21418107f, 0.14101972f, 0.18777923f, 0.10169394f, -0.23706999f, 0.10670515f, -0.00200795f, -0.00413670f, 
    0.07968033f, -0.09966834f, 0.05483709f, -0.08547416f, 0.12579672f, -0.01422223f, 0.07536666f, -0.01732805f, 
    0.03045315f, -0.17201208f, 0.03773481f, -0.23448686f, 0.02522115f, -0.04576549f, -0.02226548f, 0.03174213f, 
    0.07397792f, 0.01198840f, 0.01079622f, 0.20604533f, -0.16897482f, -0.02377038f, -0.42657766f, -0.13708064f, 
    -0.04993593f, -0.06974463f, 0.14209062f, 0.03787659f, 0.04414151f, 0.05640733f, 0.08332893f, 0.00258636f, 
    0.06286763f, 0.03106099f, 0.03873636f, -0.11995661f, 0.02879000f, -0.12098107f, 0.12263677f, 0.13766420f, 
    -0.07104997f, 0.01604719f, -0.01595780f, -0.02815160f, 0.14582761f, -0.25529444f, 0.30341074f, 0.03448259f, 
    0.07124583f, -0.04188929f, 0.09247241f, -0.01635214f, 0.01044174f, 0.00111492f, 0.01345107f, 0.05430192f, 
    0.05147282f, 0.17611992f, 0.02994696f, -0.08135912f, -0.01882997f, 0.15459153f, 0.12768449f, -0.02870761f, 
    0.07451107f, 0.06648421f, 0.09453243f, -0.03107634f, -0.06235077f, 0.08371007f, 0.19585133f, 0.09549378f, 
    0.18266679f, -0.25352636f, -0.07985487f, -0.04067855f, 0.12500997f, -0.00621772f, -0.09709229f, 0.05521664f, 
    0.01728613f, -0.07617931f, 0.20939641f, -0.42240542f, 0.11643958f, 0.04843630f, -0.02906046f, -0.02156799f, 
    0.05430488f, 0.07575668f, 0.02696179f, 0.00401393f, -0.14960572f, 0.15476595f, -0.44348329f, 0.05114125f, 
    0.07434976f, -0.06647798f, 0.17577459f, 0.16639283f, -0.06812989f, -0.12995854f, -0.02603149f, -0.01742027f, 
    0.12579486f, 0.04424825f, 0.16248316f, -0.27537292f, 0.07111029f, 0.15651603f, -0.03884876f, -0.07779244f, 
    0.15478997f, 0.04722546f, -0.03032209f, 0.00128203f, 0.02009657f, 0.54687470f, -0.38133886f, -0.05864160f, 
    -0.17743400f, -0.02357733f, 0.12648496f, 0.03719384f, 0.04187172f, 0.03029370f, 0.02022394f, -0.09056190f, 
    -0.23710874f, 0.09245108f, -0.03063535f, -0.08747515f, -0.02365410f, -0.06377590f, 0.09873570f, 0.34200305f, 
    0.03760055f, 0.08636775f, 0.06858455f, -0.05302544f, 0.02009066f, 0.04846943f, 0.03399358f, -0.16121097f, 
    0.00520267f, -0.00832908f, 0.01617802f, -0.06321597f, 0.02414581f, 0.12277759f, 0.03671709f, -0.01976049f, 
    -0.20585047f, 0.16689187f, -0.15696612f, -0.43204415f, 0.00107481f, -0.15320548f, 0.15689236f, 0.03461612f, 
    0.14830141f, 0.00554000f, -0.01585742f, -0.00066282f, -0.07383374f, -0.01634941f, 0.18335487f, 0.13201372f, 
    0.02147551f, 0.00926389f, -0.05795822f, -0.09378133f, 0.11683509f, -0.10622220f, -0.10772057f, 0.14938700f, 
    -0.11777434f, 0.10485852f, -0.10909010f, -0.41642004f, 0.17946537f, 0.01125429f, -0.08048745f, 0.03465583f, 
    -0.10263531f, -0.13991943f, 0.07878587f, 0.04872743f, -0.02500701f, -0.19133048f, 0.19282137f, -0.12238653f, 
    0.01096595f, 0.03102604f, -0.29786491f, -0.12514767f, -0.04028413f, 0.05226883f, -0.06474201f, 0.02132610f, 
    -0.09231092f, -0.06728409f, -0.11990269f, 0.04941154f, -0.06599654f, 0.06963757f, 0.04046328f, -0.01054987f, 
    0.12934454f, -0.03771545f, 0.05599599f, 0.09503672f, 0.21015203f, -0.52441508f, 0.08512177f, -0.41600320f, 
    -0.13772620f, 0.06024212f, -0.19877262f, -0.02210774f, -0.02852318f, -0.03800208f, -0.04633979f, 0.11171129f, 
    0.10059318f, 0.23092668f, -0.08171465f, -0.22763476f, -0.26947942f, -0.00089957f, 0.13441694f, 0.11775823f, 
    -0.00141937f, -0.01769964f, -0.06292976f, 0.02607818f, 0.25277126f, 0.14503601f, 0.23807196f, 0.20603751f, 
    0.03394190f, -0.09491590f, -0.12269581f, -0.09200586f, -0.05157629f, 0.08404225f, 0.00467174f, 0.15358087f, 
    -0.06987790f, -0.59455580f, -0.20924543f, -0.15230258f, -0.14893655f, 0.13513801f, -0.15500824f, 0.07550480f, 
    0.02913710f, -0.07005803f, -0.02571450f, 0.02650108f, -0.36135167f, -0.02470707f, 0.14490062f, -0.22216110f, 
    0.08105960f, -0.14240874f, -0.06642830f, 0.17645510f, 0.00818557f, 0.02362648f, 0.01156976f, -0.01152106f, 
    0.04542532f, -0.01125096f, -0.11681242f, -0.08350576f, 0.06331254f, -0.01523001f, 0.08518934f, -0.08000457f, 
    0.22018728f, -0.02783640f, 0.09034861f, 0.04812233f, -0.06430872f, 0.09045440f, -0.06083193f, -0.33857310f, 
    -0.18755929f, -0.06941181f, 0.06587212f, 0.22062814f, 0.00785949f, 0.08857754f, 0.06002080f, -0.11221728f, 
    0.19191581f, 0.10454385f, 0.16558319f, -0.07847065f, 0.01899938f, -0.01198232f, -0.20907880f, -0.17554107f, 
    -0.12732103f, -0.07997401f, 0.01210374f, 0.10619436f, -0.12688170f, 0.00066202f, -0.27910513f, 0.13377598f, 
    0.03373564f, 0.00015707f, 0.01367212f, 0.13002127f, 0.01588853f, -0.08111002f, -0.06006042f, -0.11952745f, 
    -0.40221909f, 0.40894648f, -0.43516341f, -0.33540836f, 0.00971457f, -0.14395078f, 0.19037360f, -0.07646387f, 
    -0.09993450f, 0.05052660f, -0.08481265f, 0.00737501f, -0.05694459f, -0.35890242f, -0.14266324f, 0.02511778f, 
    -0.06279211f, 0.05813484f, 0.09875197f, -0.03185792f, 0.01165479f, -0.02282389f, -0.11687015f, -0.03308890f, 
    -0.17910068f, 0.11976232f, -0.25828063f, 0.32888615f, -0.00653352f, -0.27393377f, 0.06967922f, -0.07062075f, 
    -0.01296526f, -0.05080114f, 0.04072588f, -0.00559662f, 0.07555018f, 0.06262105f, 0.12075835f, 0.18153784f, 
    -0.19871527f, 0.01817218f, -0.19283925f, -0.07222034f, 0.04211141f, -0.02954098f, 0.02591474f, 0.00790718f, 
    0.04897879f, -0.36889383f, -0.04692148f, -0.22325945f, -0.02662219f, -0.01076791f, 0.11776381f, 0.03783118f, 
    -0.07017830f, 0.03573072f, -0.04007220f, -0.03274152f, -0.33653554f, 0.12142485f, -0.30184668f, -0.02927312f, 
    -0.01570399f, -0.09521980f, -0.01693668f, -0.12309930f, 0.21187380f, 0.02512894f, 0.13457303f, 0.01740978f, 
    -0.08800122f, 0.22481646f, 0.11009666f, -0.24782883f, -0.03282866f, -0.14270137f, 0.07261439f, -0.03994358f, 
    -0.05952474f, 0.02922750f, -0.06619165f, -0.04369417f, -0.01082537f, 0.31992912f, 0.19845659f, -0.08907476f, 
    0.01055738f, -0.04728049f, -0.08598106f, -0.07657440f, 0.11360889f, 0.07244258f, 0.08936641f, 0.00609125f, 
    -0.06819588f, 0.29255384f, 0.34888440f, -0.36814982f, 0.01490281f, -0.25430506f, 0.01079927f, -0.14247994f, 
    -0.06281378f, 0.01736837f, 0.09082581f, 0.10164034f, -0.08821136f, -0.20016429f, 0.02780926f, -0.10239765f, 
    0.03466397f, 0.20038553f, 0.19418187f, 0.09816425f, 0.05950573f, 0.03049416f, -0.03023399f, 0.06800132f, 
    -0.13168336f, 0.15470371f, 0.36622941f, -0.24571304f, 0.11993960f, -0.40924457f, 0.04903522f, 0.02962724f, 
    0.06617494f, 0.05584273f, -0.02227554f, 0.01888913f, 0.02987930f, -0.09264625f, -0.12660885f, 0.01906823f, 
    -0.11777843f, 0.09787709f, -0.05171693f, -0.04798948f, 0.11632786f, -0.11263222f, -0.36372891f, -0.20941249f, 
    0.14068294f, -0.31344146f, -0.40638456f, -0.13533625f, 0.02134231f, 0.02698933f, 0.23656130f, 0.03802709f, 
    -0.04509990f, -0.11554122f, 0.02096537f, -0.01239742f, 0.03045231f, 0.06876795f, 0.14259493f, 0.26318580f, 
    0.01572867f, -0.00854668f, -0.02800157f, -0.05261289f, 0.15012725f, 0.07042255f, -0.09623470f, 0.05953509f, 
    -0.24096240f, -0.20327811f, -0.19136877f, 0.17279679f, 0.07109021f, 0.11442143f, 0.03188007f, -0.28580293f, 
    0.15906180f, 0.03163599f, 0.04897787f, 0.09464350f, -0.33052814f, -0.44362891f, 0.13838713f, -0.17990497f, 
    0.06638765f, 0.05219343f, -0.12529635f, 0.22656254f, 0.07225239f, -0.07144356f, -0.05569860f, 0.02126474f, 
    -0.02989263f, 0.44602108f, -0.49192214f, -0.21940918f, -0.06525972f, -0.05168148f, 0.06661104f, -0.04695636f, 
    0.09419508f, -0.04914545f, -0.03277535f, -0.00911254f, 0.09453022f, -0.02572717f, 0.10712123f, -0.26602373f, 
    -0.10011461f, -0.16708916f, 0.01919248f, 0.08723793f, 0.04663878f, -0.03626081f, 0.04394772f, 0.04537445f, 
    0.25010014f, -0.44307876f, -0.12166054f, -0.00430907f, -0.05162242f, 0.01538419f, 0.13165723f, -0.04774766f, 
    -0.00953801f, -0.05572688f, -0.07111655f, 0.02314873f, 0.03304355f, 0.41226324f, -0.55690408f, 0.10827994f, 
    -0.27060360f, -0.06158063f, 0.14145817f, -0.09190630f, 0.11069881f, -0.05573916f, -0.04749951f, 0.07816150f, 
    0.17390704f, 0.15659887f, 0.21115725f, -0.19492878f, -0.04920306f, -0.10249227f, -0.06868842f, -0.09208846f, 
    -0.07283236f, 0.05538008f, 0.10585620f, 0.06974154f, 0.12038052f, -0.00902530f, 0.08328364f, -0.12693816f, 
    -0.01849329f, -0.06632195f, 0.06301408f, 0.10415853f, 0.08200504f, 0.01539358f, -0.04304226f, 0.09316519f, 
    -0.27665976f, -0.04883315f, -0.25550696f, -0.12784131f, 0.09608430f, 0.07030733f, 0.10455347f, 0.03645407f, 
    0.04345935f, -0.02677866f, -0.13796985f, -0.05512896f, -0.07916278f, 0.13828421f, 0.18586946f, -0.15398474f, 
    0.05002567f, 0.07732169f, -0.04488819f, 0.14348967f, 0.14124654f, 0.02561537f, 0.01123510f, 0.05563527f, 
    -0.28000987f, 0.27235678f, 0.11234950f, 0.19870533f, 0.07128043f, 0.00099752f, -0.04604233f, -0.06547719f, 
    0.00487015f, 0.13142695f, -0.03885680f, -0.25007531f, -0.43982813f, 0.07570800f, -0.49089587f, 0.13932411f, 
    -0.12720144f, -0.16795002f, 0.17571847f, -0.00466830f, -0.04600032f, 0.02109601f, 0.07097347f, 0.05577436f, 
    0.20256923f, -0.14996324f, 0.23954438f, 0.03844584f, 0.08275498f, -0.04362454f, -0.17428485f, -0.06959721f, 
    0.07363771f, 0.13270175f, -0.14490114f, 0.12014300f, 0.21710885f, 0.30613211f, 0.09076288f, -0.46947411f, 
    -0.06281887f, -0.18159588f, 0.02237875f, 0.10015914f, 0.02488841f, -0.07951020f, 0.00586203f, -0.06050875f, 
    -0.04942900f, -0.09076662f, -0.00832413f, -0.04398360f, -0.01229096f, 0.13436398f, -0.12942396f, -0.04349883f, 
    -0.01035211f, -0.06457642f, -0.04792983f, -0.03642736f, 0.13582958f, -0.06563615f, 0.20566198f, -0.08094458f, 
    -0.05243184f, -0.03297126f, -0.02521339f, -0.07144280f, -0.00389958f, -0.05217888f, 0.01206131f, 0.08890063f, 
    0.19625427f, -0.06974635f, 0.02756990f, 0.12428976f, 0.07349883f, -0.11302068f, -0.02536292f, 0.01353071f, 
    -0.05197940f, -0.06804729f, -0.17049192f, -0.14451548f, -0.56732810f, -0.03182997f, -0.07286733f, 0.40419987f, 
    0.02847965f, 0.09141729f, 0.00471085f, -0.02559157f, 0.03267492f, 0.02651863f, 0.09551488f, 0.03576845f, 
    -0.17760287f, 0.10297982f, -0.17910033f, -0.09153771f, -0.12897630f, -0.08136640f, -0.02732361f, 0.03335018f, 
    0.07532105f, -0.05924804f, 0.03641649f, 0.00669085f, -0.12459037f, -0.01332709f, 0.08415304f, -0.30335870f, 
    -0.11608281f, -0.14696263f, -0.08702801f, 0.12767534f, -0.03461590f, 0.03608753f, -0.01442736f, -0.04643142f, 
    -0.27936262f, -0.05240841f, 0.30088109f, -0.05171068f, -0.03189778f, -0.10007687f, 0.01194100f, 0.04549606f, 
    -0.16461515f, 0.05551406f, -0.14550452f, -0.11787695f, 0.07590902f, -0.23872453f, -0.05088255f, -0.15381052f, 
    -0.02846894f, 0.05150826f, -0.00350609f, -0.23226893f, -0.14181069f, -0.07150976f, -0.14261627f, -0.05592280f, 
    -0.31276742f, 0.03449210f, -0.10027893f, -0.11425577f, 0.09064684f, 0.07798595f, -0.09516727f, -0.25894722f, 
    -0.13259432f, -0.22080337f, -0.10360669f, -0.28782058f, 0.05249908f, -0.23439863f, -0.12973060f, -0.41779265f, 
    -0.03281713f, 0.04576174f, 0.06369340f, -0.02749296f, 0.00400145f, 0.05553799f, -0.18237200f, 0.03530031f, 
    -0.26176798f, -0.05873447f, -0.29945281f, 0.20644285f, -0.00024980f, 0.06324433f, -0.06259980f, -0.01224984f, 
    -0.01745438f, 0.12768909f, -0.13825631f, 0.00097684f, 0.13341533f, -0.50667375f, 0.15463908f, -0.13193427f, 
    -0.09392045f, 0.11658160f, 0.21999077f, 0.08361053f, 0.20779304f, -0.08393239f, 0.03730839f, 0.09181149f, 
    -0.38523296f, 0.00432176f, -0.16948716f, 0.11881886f, -0.00326764f, 0.15409717f, -0.07687774f, -0.07048535f, 
    -0.02787717f, 0.12610030f, -0.01362118f, -0.04950526f, -0.49337554f, 0.47464973f, -0.05021838f, -0.13229546f, 
    0.05948845f, 0.09240820f, -0.19844835f, 0.19664124f, -0.10373038f, -0.19260621f, -0.10371498f, -0.34417245f, 
    -0.01129660f, -0.11046504f, 0.02072903f, 0.07480212f, -0.14076632f, -0.03896649f, 0.06075245f, -0.10698625f, 
    -0.06933808f, 0.03187104f, 0.04341269f, 0.05272716f, 0.17132792f, -0.04743614f, 0.16230170f, 0.01807360f, 
    -0.22807395f, 0.00186408f, 0.11290975f, 0.10079324f, 0.06597789f, -0.00170372f, 0.16132669f, 0.15484329f, 
    -0.15603778f, 0.24405840f, 0.21249568f, 0.01115547f, 0.09039389f, -0.27335760f, -0.03170652f, -0.05470931f, 
    -0.31261930f, -0.17409977f, -0.17893755f, -0.11871174f, -0.11170177f, -0.00115250f, 0.14738849f, -0.11552267f, 
    -0.10560461f, 0.03182397f, 0.17884836f, -0.00844981f, 0.04939798f, 0.03484160f, 0.02560717f, -0.07686657f, 
    -0.09178331f, -0.22526687f, -0.04815379f, 0.06099764f, 0.02442747f, 0.04259048f, -0.00692922f, -0.12596448f, 
    0.04489462f, -0.02969187f, -0.12029669f, -0.04811396f, 0.00106545f, -0.07148559f, -0.09788778f, 0.14006349f, 
    -0.16034207f, -0.00302776f, 0.06922647f, -0.22126707f, -0.00453382f, 0.10347716f, -0.16705780f, 0.04257881f, 
    -0.21194080f, -0.25122073f, -0.25946808f, 0.06692890f, -0.02483756f, 0.07438209f, -0.15247117f, -0.04201768f, 
    0.09485801f, 0.11068731f, 0.02176609f, -0.01343704f, -0.00512843f, -0.12971221f, 0.10170675f, -0.06024298f, 
    0.05676702f, 0.10346384f, 0.00788528f, 0.04762085f, -0.07470711f, -0.21561171f, -0.18770887f, -0.21545538f, 
    0.05641081f, -0.01956329f, 0.17862083f, 0.33913514f, 0.03047411f, -0.05008316f, 0.17246155f, -0.09844273f, 
    -0.11146963f, 0.12351805f, -0.04767374f, 0.02073882f, -0.31307438f, 0.25833628f, -0.13820073f, -0.00637729f, 
    0.03000916f, -0.08298105f, 0.08351126f, 0.00382497f, -0.12346029f, -0.01196786f, 0.09010509f, 0.04355748f, 
    -0.12902723f, -0.06244038f, 0.20965852f, 0.03151818f, -0.06098807f, -0.20658337f, 0.23363163f, 0.25269750f, 
    -0.20480712f, 0.10585392f, 0.11824621f, 0.02192218f, 0.17487898f, -0.02448884f, 0.12655467f, 0.09208111f, 
    -0.11059300f, 0.01247231f, 0.00171482f, 0.07857545f, 0.09286502f, -0.01147432f, -0.01377199f, -0.06641642f, 
    0.16734795f, -0.19435096f, 0.15281892f, -0.06072321f, -0.08952524f, -0.19579414f, 0.01696043f, -0.01434098f, 
    -0.12322423f, -0.00945694f, -0.12120440f, -0.09961478f, -0.04643619f, 0.23054692f, 0.08452260f, 0.29313576f, 
    0.10453737f, -0.02416816f, 0.02239440f, -0.11317077f, 0.15291314f, 0.06245017f, -0.29535463f, -0.03530442f, 
    -0.00787316f, -0.16116862f, 0.13369235f, 0.16168706f, 0.01915955f, -0.10578836f, 0.11681882f, -0.05513704f, 
    0.03772360f, 0.00316424f, -0.04144794f, -0.14207746f, 0.06757939f, 0.03862220f, -0.05386163f, 0.03119711f, 
    0.09011996f, -0.01977181f, -0.16701229f, 0.09479073f, -0.01369170f, -0.03278952f, -0.19429994f, -0.19841981f, 
    -0.25725076f, -0.03027617f, -0.01376594f, 0.06220727f, 0.03702153f, 0.25946000f, 0.06628066f, -0.03307449f, 
    -0.26472336f, 0.03019353f, 0.10591039f, -0.02387398f, -0.09526259f, -0.14712434f, 0.16974986f, 0.00201261f, 
    -0.18924467f, -0.13832605f, -0.14705750f, 0.02500415f, 0.12047813f, 0.14807370f, 0.10759722f, -0.00108235f, 
    -0.13019411f, 0.13201469f, -0.05452790f, -0.06198782f, -0.17870277f, -0.10486466f, -0.00885169f, -0.03280269f, 
    -0.19568174f, 0.02944810f, -0.06482278f, -0.03626964f, -0.20710222f, -0.25929421f, -0.02154505f, 0.08597425f, 
    0.01967686f, -0.00314941f, -0.24567926f, 0.19395496f, 0.07183324f, 0.08215444f, -0.00115584f, 0.08391524f, 
    0.15486349f, 0.21690726f, 0.22217922f, -0.04805925f, 0.01310939f, -0.04177943f, 0.06642857f, 0.06809731f, 
    -0.10642294f, 0.16923434f, 0.01292121f, 0.00057759f, -0.07111732f, -0.07499976f, 0.15430915f, 0.06966705f, 
    -0.02656590f, 0.09889829f, -0.07331693f, -0.00499014f, -0.00170879f, 0.04744054f, 0.14641011f, 0.16720641f, 
    0.01597961f, -0.25218704f, 0.33677340f, 0.29062697f, -0.16005671f, -0.15775914f, 0.10567214f, 0.03173772f, 
    -0.04654281f, -0.02386518f, 0.14783411f, 0.00466253f, -0.18499270f, -0.08283035f, -0.03758695f, -0.06172715f, 
    0.03769530f, 0.03136348f, 0.04237791f, -0.07753114f, 0.11554852f, 0.00293269f, 0.05057233f, 0.04962952f, 
    -0.39703670f, 0.30770388f, 0.22181691f, 0.13192718f, -0.10177903f, -0.04142251f, 0.03567867f, 0.12344889f, 
    0.02810643f, 0.09694163f, -0.01075505f, 0.01314887f, -0.17591067f, 0.18724568f, -0.02854323f, -0.13533206f, 
    -0.01448810f, 0.08234318f, -0.07402447f, 0.20345606f, -0.14898308f, 0.04586602f, -0.10998639f, -0.02973516f, 
    0.07318807f, -0.08816646f, -0.00174570f, 0.14378974f, 0.03181328f, 0.00407630f, -0.08079831f, 0.10208131f, 
    0.12117947f, 0.00027227f, -0.03404380f, 0.11116351f, 0.34929302f, -0.13889018f, 0.08342483f, -0.09086204f, 
    -0.11328015f, 0.02297733f, 0.08662434f, 0.12669435f, -0.01315299f, -0.03974840f, -0.15892109f, -0.30411366f, 
    0.01712711f, -0.11640438f, 0.17265730f, 0.12561685f, -0.04337360f, 0.00880129f, -0.02048338f, 0.04359567f, 
    -0.09307522f, -0.11499152f, 0.12949227f, 0.17667383f, -0.15277185f, -0.11622698f, -0.02909172f, 0.04009695f, 
    0.07861037f, -0.05250536f, 0.16950484f, -0.07126509f, -0.11771399f, -0.15257044f, -0.07168706f, -0.00280834f, 
    -0.19921923f, 0.10921893f, -0.16353592f, 0.05866086f, -0.08498597f, -0.10369856f, 0.10423056f, -0.06110020f, 
    0.06626981f, -0.08809849f, -0.04709069f, 0.04923793f, -0.14075862f, 0.02505450f, 0.03713822f, -0.24281217f, 
    -0.07675845f, -0.00491280f, -0.10801481f, -0.18416418f, -0.02617806f, -0.00356381f, 0.02149573f, -0.16092315f, 
    -0.24692349f, -0.05846743f, 0.20817330f, 0.22247420f, -0.12977485f, 0.12227540f, 0.03468629f, 0.11970044f, 
    0.03292479f, -0.18860924f, 0.07616799f, 0.01179137f, -0.01526726f, -0.08321485f, 0.34333009f, 0.04412168f, 
    -0.04370139f, 0.10843337f, 0.11048152f, 0.03822817f, 0.05377389f, 0.07210241f, 0.27520034f, 0.19499968f, 
    -0.30072358f, -0.07571565f, -0.34577712f, -0.22818124f, -0.10159644f, 0.02790202f, 0.04934909f, -0.07941698f, 
    0.01719418f, 0.14149587f, -0.09759319f, 0.00389523f, -0.31274760f, -0.17509200f, 0.08607581f, -0.46728948f, 
    -0.13225384f, -0.19475433f, -0.12794369f, 0.08083811f, 0.05126209f, -0.03113865f, 0.05855448f, 0.02643783f, 
    -0.09550928f, 0.12945966f, -0.23458891f, -0.16408497f, -0.05530933f, 0.15537192f, 0.11234485f, 0.06383213f, 
    -0.17884357f, -0.00841489f, -0.21264379f, -0.16708201f, -0.23782913f, -0.01872553f, 0.09698290f, 0.12333388f, 
    -0.08507030f, 0.12077986f, -0.33344090f, 0.05823632f, 0.00658743f, -0.12758365f, 0.11920261f, 0.04882663f, 
    -0.03821214f, 0.00364429f, 0.28567693f, -0.13828593f, 0.00371161f, 0.13491356f, 0.17710099f, -0.13276845f, 
    -0.13962787f, 0.04126465f, 0.15562794f, 0.12075768f, 0.12839742f, -0.04868741f, -0.04811631f, 0.01867340f, 
    0.00828688f, -0.02660646f, -0.03832355f, 0.07702486f, 0.00263124f, 0.21664180f, 0.01275738f, -0.14781432f, 
    -0.23856790f, 0.05259484f, -0.23928355f, 0.18259078f, 0.01590380f, 0.00553316f, 0.12706065f, -0.13433093f, 
    0.10798545f, -0.01840822f, -0.06641319f, -0.01755700f, 0.05748103f, 0.49066675f, 0.29001847f, -0.12007957f, 
    -0.14606066f, -0.08034302f, 0.14452341f, 0.19528197f, -0.09052775f, 0.06151187f, -0.10716954f, 0.01088369f, 
    -0.03783109f, 0.16734211f, -0.12547764f, 0.12504002f, -0.00015152f, -0.11740372f, 0.03309988f, 0.08953495f, 
    -0.14200415f, -0.00525268f, -0.21436614f, -0.41456226f, -0.08155493f, 0.06686496f, -0.11465295f, 0.25457799f, 
    0.10506085f, -0.00581909f, -0.16684556f, 0.01357247f, -0.06752246f, -0.25704795f, -0.10726117f, -0.07517254f, 
    -0.13463932f, -0.10380413f, 0.26593035f, 0.05683284f, -0.08894396f, 0.02749043f, 0.15161020f, -0.01641553f, 
    -0.00083231f, -0.06524289f, 0.12888318f, 0.08516445f, -0.14669700f, -0.06883944f, -0.18257365f, 0.03569509f, 
    -0.05693331f, -0.12163098f, -0.11455943f, 0.06254931f, -0.01071291f, -0.04296747f, -0.18288293f, -0.32294253f, 
    -0.02142333f, 0.19095172f, 0.20281558f, 0.10567126f, 0.02340748f, -0.05896136f, 0.04142343f, -0.03001994f, 
    -0.07803216f, -0.09192726f, 0.12695861f, 0.03737732f, 0.17418638f, -0.39777407f, 0.03239290f, 0.04337008f, 
    -0.09690298f, 0.15009189f, -0.03393036f, -0.02365927f, -0.06706933f, 0.18372034f, -0.27388108f, 0.07887309f, 
    -0.31182933f, 0.08291342f, 0.00485520f, 0.04870214f, -0.06781800f, 0.06916216f, 0.17152333f, -0.06114730f, 
    -0.04110851f, -0.02657988f, 0.12357356f, 0.09110189f, 0.10193580f, -0.15278476f, 0.23849219f, 0.24773368f, 
    -0.09604617f, 0.08249220f, 0.02572481f, 0.00091847f, 0.07757931f, -0.00829445f, 0.14287156f, 0.10830723f, 
    0.05001069f, -0.17942397f, 0.04301641f, -0.02563326f, -0.04913354f, 0.01997773f, 0.08409436f, 0.03176302f, 
    0.09335075f, 0.05829120f, 0.00162390f, 0.00762737f, -0.34843442f, 0.24965602f, 0.06444021f, -0.01844300f, 
    0.01539681f, 0.16325001f, -0.20736982f, -0.03539895f, -0.10904594f, -0.16674601f, -0.16816343f, -0.20163006f, 
    -0.06947581f, 0.18171541f, -0.00362928f, 0.00427094f, -0.08272989f, 0.11333140f, 0.06201937f, 0.06368876f, 
    0.15406223f, 0.00872050f, 0.10442162f, 0.14036630f, 0.05404053f, 0.08677208f, -0.08411746f, -0.14442223f, 
    -0.14313468f, 0.11549031f, 0.13508506f, 0.04606535f, -0.09975826f, -0.05815269f, -0.20860928f, -0.26343814f, 
    0.00090851f, 0.01207435f, 0.10424017f, 0.04021889f, -0.04960149f, 0.01671796f, -0.13194014f, 0.18666974f, 
    -0.05429551f, 0.12995067f, -0.01995944f, 0.00000124f, -0.17951287f, -0.02012830f, -0.14469874f, 0.23543963f, 
    -0.05610204f, 0.07609854f, -0.04077066f, 0.11550339f, 0.06300791f, 0.05103068f, 0.02818283f, 0.19349481f, 
    0.10963960f, 0.08970637f, 0.22030890f, -0.26659417f, 0.12235986f, 0.12090565f, 0.05997960f, -0.06629007f, 
    0.06818494f, 0.06293921f, 0.08208439f, 0.14745986f, 0.17422980f, -0.02809535f, 0.34096077f, -0.21982095f, 
    -0.00990884f, -0.16210060f, -0.06355833f, 0.08428487f, -0.02905471f, 0.02644020f, 0.01480012f, -0.02588307f, 
    -0.09673966f, 0.01663833f, -0.25120121f, 0.01419861f, -0.00402174f, 0.05794654f, 0.11259142f, -0.12181772f, 
    0.00343349f, 0.03823847f, 0.11642330f, 0.21233551f, 0.21310693f, -0.09518006f, 0.00411163f, -0.07314680f, 
    0.03207915f, 0.08626229f, -0.02042815f, -0.00702262f, -0.07443482f, 0.02294085f, 0.01065549f, -0.03968465f, 
    0.21089894f, -0.24722666f, 0.07414645f, 0.00602778f, -0.15685578f, 0.06139195f, 0.05444599f, -0.04865163f, 
    0.16014756f, 0.11585309f, 0.00032195f, 0.02906334f, 0.01232362f, -0.35047427f, 0.17887746f, -0.32353565f, 
    0.07680607f, -0.01089064f, -0.06537160f, 0.17426848f, -0.01975420f, 0.06597333f, -0.16947222f, 0.02843609f, 
    -0.19751513f, -0.31290385f, -0.01056124f, 0.06399843f, -0.04358287f, -0.10698663f, -0.04895156f, -0.14244552f, 
    0.05272214f, -0.05857917f, 0.04141946f, -0.05667298f, -0.12664025f, -0.01075130f, 0.01255953f, 0.17565504f, 
    0.05869093f, 0.04060684f, -0.03122684f, 0.17238405f, -0.04484541f, 0.16549915f, -0.05401854f, 0.15083607f, 
    -0.06398125f, -0.00178450f, 0.09778502f, 0.12722017f, 0.01774458f, 0.00554830f, -0.06432579f, -0.03476159f, 
    0.02594282f, -0.13027397f, -0.15829420f, -0.01684489f, 0.02144347f, -0.02307690f, -0.17335506f, 0.10811583f, 
    0.04315081f, 0.00513795f, -0.04101802f, 0.05639785f, -0.06688729f, -0.02684095f, -0.05384474f, -0.17467059f, 
    -0.20940688f, 0.14316916f, -0.21695064f, 0.35685182f, -0.03610127f, 0.10020108f, 0.08668970f, 0.07141954f, 
    -0.08771068f, 0.11558809f, 0.13056715f, 0.17166892f, 0.44163334f, -0.11055509f, 0.36541617f, -0.07527442f, 
    0.09922318f, -0.03735980f, -0.05495822f, 0.02349948f, 0.02302151f, -0.01142909f, -0.02813237f, 0.03354014f, 
    0.02710968f, 0.40525085f, -0.00499200f, 0.09671494f, -0.16459817f, 0.01992792f, -0.09084266f, 0.01043639f, 
    0.09969123f, -0.05828237f, 0.17730743f, 0.09601372f, -0.11674853f, -0.56173062f, 0.35118964f, -0.16006371f, 
    0.04325432f, -0.01707901f, -0.03092926f, -0.03400773f, -0.04063721f, 0.02335505f, 0.10013480f, 0.01422919f, 
    0.17466173f, -0.27635410f, -0.18803811f, -0.08644225f, 0.01182845f, -0.12585938f, -0.06425334f, -0.01291620f, 
    -0.01230923f, -0.00080561f, -0.05883072f, -0.09035356f, 0.00382798f, -0.39467555f, 0.10149509f, -0.17393148f, 
    0.00643449f, -0.00321474f, -0.05154194f, -0.03166014f, -0.00478576f, 0.07117809f, 0.08748098f, -0.02139229f, 
    -0.07647367f, -0.35468835f, 0.43889931f, -0.04718802f, 0.02451347f, 0.12540425f, -0.06911684f, 0.06539372f, 
    0.00911527f, -0.04039079f, 0.12332401f, 0.02109069f, -0.13866089f, -0.32181755f, -0.23881260f, 0.10514863f, 
    0.03877293f, 0.03503773f, 0.05329499f, -0.05769828f, 0.12710029f, -0.02010427f, 0.10060563f, -0.03468848f, 
    0.05739165f, 0.08372224f, -0.00435179f, -0.03472673f, 0.04955255f, 0.13480565f, 0.10615186f, -0.05851588f, 
    -0.06871897f, 0.02412821f, 0.02910055f, -0.05049907f, -0.19018264f, 0.21701336f, -0.16883071f, 0.06339142f, 
    -0.02236779f, 0.12082779f, 0.04537532f, 0.03609505f, -0.13154125f, -0.01359976f, 0.06048993f, -0.01936484f, 
    0.04867369f, 0.14550589f, 0.03538255f, -0.03795201f, -0.04080384f, 0.06109215f, 0.09460964f, -0.01177639f, 
    -0.07112303f, 0.04418747f, -0.02860084f, -0.00451659f, -0.17452729f, 0.28034928f, -0.25475463f, 0.21010384f, 
    -0.04100929f, 0.10612316f, 0.15794113f, -0.10390981f, 0.01186279f, 0.11180452f, 0.17474283f, 0.01458910f, 
    -0.16682567f, 0.12424666f, 0.17725864f, 0.10736255f, -0.23418328f, 0.02560128f, 0.04330394f, -0.07887145f, 
    0.01758985f, 0.07321606f, 0.01568725f, -0.03536753f, -0.38850155f, -0.10791383f, -0.37114662f, -0.06209981f, 
    0.01429643f, -0.12294230f, -0.05144673f, -0.08427916f, -0.12109180f, 0.06260751f, 0.11189231f, 0.09604009f, 
    -0.25452811f, -0.16613565f, 0.32038420f, 0.48502040f, 0.18998888f, -0.16633983f, 0.13959508f, -0.04714550f, 
    -0.03060654f, -0.02978387f, -0.05641570f, -0.01240199f, -0.33782899f, -0.13617656f, -0.07225789f, -0.04013407f, 
    -0.15434864f, 0.02472396f, -0.32763067f, -0.09556618f, -0.05224486f, 0.00130080f, -0.11116613f, -0.08298918f, 
    0.26689836f, 0.01779403f, 0.16520479f, 0.18163933f, 0.01077602f, 0.07223657f, -0.03762920f, 0.13572328f, 
    -0.07829198f, 0.04858024f, 0.14151518f, -0.03679058f, -0.12555701f, -0.20993948f, 0.20543228f, -0.11488616f, 
    -0.22544375f, -0.16823591f, 0.01322784f, -0.03772659f, 0.02994009f, 0.00626480f, -0.04251566f, -0.00101688f, 
    -0.62128139f, 0.09524648f, -0.32438737f, 0.14819621f, 0.16659512f, -0.04145806f, -0.11533976f, 0.16266665f, 
    -0.19347852f, -0.04359689f, -0.11392435f, -0.01609316f, 0.22536759f, -0.13008149f, 0.12911762f, 0.01756953f, 
    0.09745044f, -0.12539926f, 0.04043584f, 0.17148918f, -0.13096221f, 0.07565299f, 0.05463851f, -0.00286480f, 
    -0.00431613f, -0.23848675f, 0.42406526f, -0.49318400f, 0.00767626f, 0.01164127f, 0.01550210f, 0.03364602f, 
    -0.04916102f, 0.07101386f, -0.09880966f, -0.22994877f, 0.00586682f, -0.01442140f, -0.04538626f, 0.05905775f, 
    0.05832317f, -0.11331682f, -0.08805767f, -0.03071605f, -0.18143776f, -0.12317961f, -0.13134535f, -0.04198635f, 
    0.17473368f, -0.41903162f, 0.29860070f, 0.19425502f, 0.21836549f, 0.07194877f, -0.00742516f, 0.13742441f, 
    -0.00547868f, 0.00887163f, 0.15071696f, 0.12692417f, -0.17637162f, 0.05429840f, -0.06459375f, 0.08461332f, 
    0.04131538f, 0.04994641f, -0.03465533f, -0.04537823f, 0.05771745f, 0.04689755f, -0.04153443f, 0.04300461f, 
    -0.10472596f, 0.01668750f, -0.03935595f, -0.04978460f, -0.04707213f, 0.04597075f, -0.06792634f, -0.04447075f, 
    -0.17289327f, -0.04090447f, -0.06202720f, -0.16346811f, -0.18590714f, 0.07148495f, -0.01266457f, -0.57316184f, 
    -0.05608862f, -0.11184056f, 0.10152951f, -0.02063394f, 0.03862631f, 0.00923547f, 0.16926907f, 0.04606793f, 
    -0.02427926f, -0.15796025f, 0.20231667f, -0.08730154f, -0.07400429f, 0.04955755f, 0.07466397f, 0.03026030f, 
    -0.12356276f, 0.10077724f, 0.00378812f, -0.11822399f, -0.15814698f, -0.12529005f, 0.03713380f, 0.06999060f, 
    -0.05294505f, 0.00702663f, 0.02920692f, -0.20513195f, 0.00731441f, 0.14704582f, -0.02193715f, -0.10199492f, 
    0.18445744f, -0.40307733f, 0.28953677f, -0.14536917f, 0.03878768f, 0.14980565f, -0.04349773f, 0.08495778f, 
    -0.09373774f, 0.11563323f, 0.05763454f, -0.00532983f, 0.06548378f, 0.16509950f, -0.11967105f, 0.01280547f, 
    -0.05666924f, 0.11377004f, 0.11220503f, 0.04626556f, 0.01869490f, 0.06917851f, -0.07079208f, 0.07050138f, 
    -0.17528269f, -0.59098101f, 0.13314778f, -0.10851116f, -0.11012558f, 0.01590339f, -0.03294548f, -0.03060045f, 
    0.05547932f, 0.05999125f, 0.07208687f, -0.21659900f, -0.27535570f, 0.11514944f, -0.17127688f, -0.12901294f, 
    0.05854816f, -0.09079136f, 0.05445435f, -0.10089748f, -0.13969198f, -0.08473156f, -0.05171920f, -0.14095885f, 
    0.38522586f, 0.28469262f, 0.28405809f, 0.02512198f, 0.09656432f, -0.08288791f, 0.06499001f, -0.03226974f, 
    -0.06447226f, 0.05468085f, -0.06573151f, -0.05961059f, -0.26988745f, -0.18213154f, -0.21015324f, -0.09669679f, 
    0.09650163f, -0.01970327f, 0.02574465f, -0.05053956f, 0.04545192f, 0.04839450f, -0.00716909f, -0.03837340f, 
    0.14164568f, -0.15637739f, 0.00610077f, 0.15344974f, 0.09371141f, -0.11422513f, 0.05493207f, 0.11835476f, 
    0.02087058f, 0.14645754f, 0.04870512f, 0.07042647f, -0.61445057f, 0.21980211f, 0.00646245f, 0.07814257f, 
    0.09818345f, 0.09909629f, 0.14732344f, 0.03579746f, -0.24235182f, 0.03580599f, -0.10491197f, 0.06361764f, 
    0.25202590f, 0.03174550f, 0.29109767f, 0.11825649f, 0.13673817f, -0.06050751f, -0.01490445f, -0.15398778f, 
    -0.03939400f, 0.02982419f, -0.06743001f, 0.14838403f, -0.21551439f, 0.19294956f, -0.14108264f, -0.39349639f, 
    -0.06269740f, -0.11298154f, -0.05703434f, 0.00943236f, -0.05906771f, 0.01886178f, -0.10483977f, -0.02163726f, 
    0.05817678f, 0.11052325f, -0.04040232f, 0.19698317f, 0.01703368f, -0.01383226f, 0.05599863f, -0.07534120f, 
    -0.11620862f, 0.17345993f, -0.10245407f, -0.10353323f, 0.02510040f, -0.56323785f, 0.55786717f, 0.24032696f, 
    0.15495592f, -0.08747783f, 0.09775213f, -0.11819854f, 0.07571951f, 0.01195976f, 0.08848011f, -0.04155262f, 
    -0.34343994f, -0.15740778f, -0.02819854f, 0.11476221f, 0.02910801f, 0.01931145f, -0.00511549f, 0.06850173f, 
    -0.00456501f, -0.00207036f, -0.04161683f, 0.07722288f, -0.40892816f, 0.16249250f, -0.06749982f, 0.12845714f, 
    -0.11217655f, -0.13901511f, 0.20328486f, 0.06111619f, -0.10233061f, 0.00216990f, 0.04425497f, -0.06352913f, 
    0.21545386f, 0.17521389f, 0.44043684f, 0.11136378f, 0.03129299f, 0.04117210f, -0.17675644f, -0.04547500f, 
    -0.15495093f, 0.03806855f, -0.10619841f, -0.11220722f, -0.15159515f, 0.32013577f, -0.10249231f, -0.12996092f, 
    0.03865930f, -0.05659963f, 0.13874674f, 0.13640442f, 0.04278902f, 0.15530567f, 0.09559723f, 0.08685442f, 
    -0.32566708f, 0.00786571f, -0.18355849f, 0.02781432f, 0.12788941f, 0.01672103f, -0.06235869f, -0.12847789f, 
    -0.02682829f, -0.03270456f, 0.16682933f, -0.04846192f, 0.50117922f, -0.21991952f, 0.39784119f, -0.01755032f, 
    -0.00149507f, 0.08457753f, -0.00823560f, 0.09014317f, -0.04878220f, 0.06549865f, 0.06474966f, 0.19452354f, 
    -0.22577687f, 0.10960460f, -0.24416533f, 0.24323989f, -0.03530279f, -0.12542450f, 0.12953342f, -0.01484077f, 
    -0.11541551f, -0.00931107f, -0.05533411f, -0.26784316f, -0.27204818f, -0.27232504f, -0.04535853f, 0.05534415f, 
    -0.19256324f, -0.04367628f, -0.00899735f, -0.03580051f, 0.00320228f, -0.00599371f, -0.17483349f, -0.14552683f, 
    -0.06831262f, 0.28049588f, -0.00484547f, -0.05341214f, -0.00597392f, 0.01356405f, 0.02226115f, -0.10836095f, 
    -0.03280066f, -0.03030824f, -0.10852608f, 0.02078648f, -0.10551013f, 0.07942872f, -0.23421216f, 0.11756562f, 
    -0.08700028f, -0.16081190f, 0.18485563f, 0.15643953f, 0.11739856f, 0.11353382f, -0.04676159f, 0.12157323f, 
    0.06942286f, -0.05077648f, -0.14382070f, -0.07694287f, 0.01226070f, -0.02102376f, -0.05493454f, 0.02344278f, 
    -0.06355963f, 0.06381863f, -0.01003919f, -0.15168780f, -0.40030146f, -0.56752396f, -0.05220008f, -0.10773851f, 
    0.00485060f, -0.03527746f, 0.03055689f, 0.02281719f, 0.01756900f, -0.00961359f, 0.22800444f, 0.12040272f, 
    0.27186576f, 0.10514171f, 0.21476912f, -0.15643790f, 0.12561731f, 0.06963829f, 0.08995488f, 0.02929630f, 
    -0.11881603f, -0.07528913f, -0.10163280f, -0.10776727f, -0.18639301f, 0.14408845f, -0.01944648f, -0.02412545f, 
    -0.25591069f, -0.07912341f, -0.12574296f, -0.02585249f, -0.02587795f, 0.01512288f, -0.05847534f, -0.10016130f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15489069f, 0.12002327f, 0.02300382f, -0.05912635f, -0.06924345f, 0.05065539f, 0.00458290f, -0.10897516f, 
    0.03203254f, 0.03723438f, 0.00358285f, -0.01994863f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
