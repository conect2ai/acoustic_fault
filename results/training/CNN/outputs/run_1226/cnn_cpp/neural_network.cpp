#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.08555488f, 0.00924729f, -0.11493842f, 0.46965975f, 0.46213266f, 0.70418274f, 0.97259569f, -0.76381791f, 
    -0.38194135f, 0.90834862f, 0.10275515f, -0.23161729f, -0.78077847f, -0.21288669f, -0.29959604f, 0.57534438f, 
    0.87066102f, 0.45390242f, -1.07289553f, 0.82455999f, 0.15518112f, -0.83803964f, 0.33984271f, 0.09131333f, 
    -0.53711826f, 1.13582861f, -0.50869828f, -0.41187108f, -0.14855517f, -0.53113395f, 0.75436431f, -1.22708678f, 
    -1.03238118f, -0.44635695f, 0.09431680f, 0.08972646f, 0.25578728f, 0.38915297f, -0.07936169f, 0.02130697f, 
    -0.49179548f, 0.08328532f, -0.17341714f, -0.84257966f, -0.40377605f, 0.32998222f, 0.25082034f, -0.14536275f, 
    0.61264944f, 0.58599514f, 0.41076544f, 0.58695734f, -0.65448183f, 0.27909285f, 0.24776144f, -0.45213419f, 
    -0.99741107f, -0.28357506f, 0.67891592f, 0.98005837f, -0.62351680f, -0.32339925f, -0.41374290f, -1.12941015f, 
    -0.84168017f, -0.74705881f, 0.04228640f, 0.16166306f, 0.24808875f, 0.61215937f, 0.68284792f, 0.52473617f, 
    -0.31472757f, -0.58575249f, -0.08788915f, -0.07008807f, -0.07136416f, -1.05209827f, -0.32827532f, 0.33180600f, 
    0.70605063f, -0.30273145f, 0.61025250f, 0.12333257f, 0.36089525f, 0.17671400f, 0.52000171f, -0.44030729f, 
    -0.90426016f, 0.46807486f, 0.23004198f, 1.09702051f, 0.31551147f, -0.79842174f, -0.27976137f, 0.54715598f, 
    -0.39172167f, -0.27498621f, 0.01104549f, -1.01073945f, -0.75446069f, 0.36034027f, 0.61202514f, -0.79334617f, 
    -0.97093046f, -0.50184131f, -0.25681317f, -0.73017651f, 0.15485524f, -0.22259495f, -0.18589026f, 0.15099645f, 
    0.90436369f, -0.49197724f, 0.46922004f, -0.69404525f, 0.05144642f, 0.15078843f, -0.24157786f, 0.37645286f, 
    -0.23233300f, -1.13457024f, -1.45188701f, 0.20010079f, -0.49367779f, -0.72748953f, -0.70831203f, -0.60327041f, 
    -0.95799375f, -0.21822622f, 0.53912342f, -0.26094294f, -0.16089286f, 1.10946262f, -0.99426514f, 0.64356953f, 
    -0.40159658f, -0.85777628f, -0.50323081f, -0.04649580f, 0.52454919f, 0.46826622f, 0.40114701f, 0.40271756f, 
    -0.20345986f, 0.27841920f, -0.37482238f, -1.37504494f, -0.36304000f, -0.62312847f, 0.39182851f, -0.81540430f, 
    1.26044226f, -0.10341843f, 0.21260622f, 0.49531010f, 0.90551490f, 0.20429599f, 0.14512865f, 0.17946017f, 
    0.49119091f, 0.04977450f, -0.09386200f, -0.33152127f, -0.42919633f, -1.14822447f, -0.36225855f, -1.22889006f, 
    0.64076197f, 0.49523395f, 0.49687803f, 0.85280573f, 1.25330341f, -0.71201730f, 0.35188034f, -0.71036291f, 
    -0.55927253f, 0.17402174f, 0.22330850f, 0.25479144f, 0.68119079f, -0.39535847f, 0.49048421f, -0.50968635f, 
    0.31276822f, 0.20441292f, 0.78596002f, -0.46586725f, -0.21042836f, 0.77984613f, 0.23261769f, 0.57359880f, 
    0.16470231f, -0.51440990f, 0.48826185f, 0.58733600f, -0.00821933f, 0.26586023f, -0.63587987f, -0.25538659f, 
    -1.24090374f, 0.21088646f, -0.17315800f, -0.41586435f, -0.61114901f, -0.64942008f, -0.62031525f, 0.50898832f, 
    0.04383339f, 0.42701793f, -0.31311673f, 0.75873804f, -0.35235959f, -0.11074425f, 0.66957259f, -0.70129919f, 
    -0.61128783f, 0.45801768f, 0.92899203f, 0.49689347f, -0.16336788f, -0.81983674f, 0.14709885f, -0.25604239f, 
    0.04975419f, -1.03189015f, -0.12172006f, 0.45837495f, -0.43827420f, 0.93100405f, -0.36453903f, 0.34524161f, 
    -0.65115970f, -0.90072960f, 0.67709827f, -0.45732167f, -0.16270897f, 0.37415487f, -0.07210606f, 0.33495870f, 
    0.06941614f, -0.67709571f, -0.22407193f, -1.13316965f, -0.80836749f, 0.25448337f, 0.79295063f, -0.53498399f, 
    -0.31021735f, -0.06441770f, 0.31394374f, 0.40613079f, -0.95875359f, -0.79195613f, -0.33516857f, 0.81338197f, 
    0.42418972f, 0.02246975f, -0.62105793f, -0.77040631f, -0.44991925f, -0.21652448f, 0.92129636f, -0.57770151f, 
    0.17130490f, 0.72263414f, 0.09078484f, 0.58370131f, -0.03718754f, 0.43476784f, -1.02047372f, 0.09402868f, 
    0.32404113f, 0.37038130f, 0.68951917f, -0.81009525f, 0.17839590f, 0.48475274f, 0.42685214f, 0.55700386f, 
    -0.79127628f, -1.20013416f, 0.61898333f, 0.53720850f, 0.51810151f, 0.19808467f, 0.38425925f, 0.33457848f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.40075839f, -0.00260612f, 0.44265702f, 0.26472178f, 0.13079761f, 0.28939965f, -0.16513018f, 0.68439931f, 
    -0.33191884f, 0.34286910f, -0.14882006f, -0.66122746f, 0.37427166f, 0.35213950f, 0.58752990f, 0.33152202f, 
    -0.12756342f, -0.27115062f, 0.05713007f, 0.17159335f, 0.55079418f, 0.23069568f, -0.41663393f, 0.43648848f, 
    -0.12027247f, 0.32227865f, 0.28717098f, -0.14391787f, 0.24111173f, -0.17593116f, 0.09497268f, 0.27991226f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.00326488f, 0.09868974f, 0.33223408f, -0.23101746f, -0.13345321f, -0.34508154f, 0.01528618f, -0.19159241f, 
    0.03567069f, -0.45164499f, -0.26683721f, -0.12941733f, 0.13223878f, -0.00583138f, 0.14296517f, 0.00807364f, 
    0.11821523f, 0.39866582f, 0.20951617f, 0.53912270f, 0.07114945f, 0.06647082f, 0.19690627f, -0.08577361f, 
    0.16444539f, 0.13424973f, -0.27623242f, 0.09549012f, -0.35416082f, 0.19767825f, -0.14490539f, 0.03845415f, 
    -0.03930977f, -0.07764661f, 0.08612497f, 0.13183458f, -0.22239767f, 0.23164643f, 0.08094402f, 0.17856458f, 
    -0.11761647f, -0.23469158f, -0.20221914f, -0.02640275f, 0.04683655f, 0.04426416f, 0.12797114f, 0.32762468f, 
    -0.30292416f, -0.06849191f, -0.37985826f, -0.03013601f, -0.12301123f, 0.14910616f, -0.07256805f, 0.21600780f, 
    -0.00645869f, 0.09333792f, -0.04268022f, -0.19415756f, 0.15450181f, -0.14946902f, -0.03797231f, 0.30741861f, 
    -0.23871380f, -0.35908255f, 0.13597085f, 0.08889290f, -0.02684445f, 0.07936293f, -0.00478743f, 0.02353264f, 
    0.24969128f, 0.25865671f, 0.32833105f, -0.08900625f, -0.00578742f, -0.06884840f, -0.05478036f, -0.04274790f, 
    0.18405564f, -0.19377747f, 0.10263868f, 0.12548161f, -0.09240744f, 0.04249752f, -0.00659739f, -0.07011177f, 
    -0.04845137f, -0.16719265f, -0.13976559f, -0.00077305f, -0.25006875f, -0.04252142f, 0.03111181f, -0.17692773f, 
    0.10582950f, 0.09789050f, 0.11236232f, 0.34666571f, -0.41950172f, 0.04000654f, -0.07521096f, -0.13922432f, 
    -0.43947914f, -0.02700385f, 0.20858780f, -0.13533701f, -0.19571669f, 0.30630127f, 0.44500473f, -0.28384754f, 
    -0.02674426f, -0.11621923f, 0.01432483f, -0.13211288f, -0.02773251f, 0.30879584f, -0.33717084f, -0.05842831f, 
    -0.08667520f, -0.08868707f, -0.00835963f, 0.08034316f, 0.30037186f, 0.12999763f, 0.10757997f, 0.18919349f, 
    0.00692972f, -0.13866253f, -0.12190206f, -0.03251297f, 0.00377611f, 0.09802295f, -0.04934958f, -0.23630798f, 
    -0.35263383f, -0.36339548f, 0.35318798f, -0.15916693f, 0.16144426f, -0.01102312f, 0.00664973f, -0.02754130f, 
    -0.49824449f, 0.40534785f, 0.40054294f, 0.15008655f, 0.14329734f, -0.14621095f, -0.00008662f, 0.01894612f, 
    0.05667646f, 0.02207243f, 0.12748358f, 0.19953398f, -0.60456210f, 0.00832063f, -0.45062405f, 0.09843627f, 
    -0.12251961f, -0.04144793f, -0.02695707f, -0.23744275f, 0.20467871f, 0.03759174f, -0.00701129f, 0.15899068f, 
    -0.00671015f, -0.05238251f, 0.22678566f, -0.78296149f, -0.66572887f, 0.38727832f, -0.13210654f, 0.18213667f, 
    0.10678726f, 0.01722957f, 0.08993344f, -0.02329161f, -0.11768141f, 0.09933258f, 0.01267034f, 0.05878924f, 
    0.03866481f, 0.01917711f, 0.00051715f, -0.06468202f, 0.13980237f, -0.21389450f, 0.11471290f, 0.08381780f, 
    0.07764905f, -0.03463082f, 0.07808451f, 0.16127014f, -0.14354916f, 0.04575451f, 0.09390814f, 0.02249543f, 
    -0.00875534f, 0.03756433f, -0.02821000f, -0.05053342f, 0.13869946f, -0.11759991f, -0.16406342f, -0.14617351f, 
    0.22046474f, 0.13976975f, -0.23798344f, 0.07465605f, -0.23460940f, 0.00011963f, 0.06829123f, -0.03516590f, 
    0.07529079f, -0.21689247f, -0.20310320f, -0.22133483f, 0.10256762f, -0.33912143f, 0.06586000f, 0.01403306f, 
    0.01624942f, -0.12228946f, -0.01477576f, -0.04447912f, -0.01143729f, -0.17239219f, -0.05407571f, -0.05870216f, 
    -0.07229931f, -0.03545767f, -0.16786444f, 0.08860060f, 0.18520106f, 0.16107470f, -0.19665776f, 0.12159374f, 
    -0.12139840f, -0.05695887f, -0.06473634f, 0.70031399f, 0.24487728f, 0.04912226f, -0.20787415f, 0.12396040f, 
    -0.08733830f, 0.03855947f, 0.28051099f, 0.03819078f, 0.02126594f, -0.22375570f, -0.01703169f, 0.00579662f, 
    -0.02867115f, -0.16837752f, 0.24015725f, -0.08014450f, -0.25667378f, -0.01878710f, 0.13530512f, 0.00045917f, 
    -0.02321626f, 0.20077489f, 0.00327639f, 0.01242031f, 0.12428898f, 0.01640301f, 0.34062171f, 0.26764235f, 
    -0.20222636f, -0.13772167f, 0.33272946f, -0.03077465f, 0.08986981f, 0.00362608f, 0.06326953f, -0.02014796f, 
    -0.17189711f, -0.10950267f, 0.06468597f, -0.22925147f, -0.07445861f, 0.15822454f, -0.04655191f, 0.01226160f, 
    0.18411289f, 0.19122042f, -0.16642028f, -0.07217007f, 0.04604078f, 0.05451111f, 0.08063444f, 0.01065833f, 
    0.16316798f, 0.05220137f, 0.08810097f, 0.04713400f, -0.06525659f, 0.22531173f, 0.09410974f, -0.12813589f, 
    -0.06578422f, 0.15051414f, -0.46679142f, -0.01650054f, 0.36691418f, -0.01022235f, 0.26074716f, -0.06418902f, 
    0.27141932f, 0.29556006f, 0.24280566f, -0.44544190f, 0.61169779f, -0.31432533f, 0.20216995f, -0.12398837f, 
    0.16297962f, -0.00284540f, 0.03442450f, 0.01429249f, 0.37929964f, 0.38589022f, 0.02768614f, 0.08862752f, 
    -0.02476384f, -0.07934467f, 0.00898263f, 0.14166027f, 0.16476303f, 0.17063765f, 0.15922847f, -0.07408008f, 
    -0.10949858f, -0.05084724f, -0.09729908f, -0.11640189f, -0.15081511f, -0.10151932f, 0.02275121f, -1.05565763f, 
    -0.25359914f, -0.17557208f, 0.21752624f, -0.06568079f, 0.02149974f, -0.13404614f, -0.10617758f, -0.48615101f, 
    -0.47821704f, -0.20962013f, -0.09718157f, 0.05083468f, 0.18347651f, 0.08041804f, 0.01625086f, -0.03371423f, 
    0.08479331f, 0.42993057f, -0.05568464f, 0.02691048f, -0.23388197f, -0.03428105f, 0.00056813f, 0.01972548f, 
    -0.00396553f, 0.05270007f, 0.03820115f, 0.15340871f, 0.10668566f, 0.04513678f, -0.05240745f, -0.02826474f, 
    0.11510482f, 0.23608942f, 0.15537596f, -0.09653244f, 0.06361596f, -0.03180612f, -0.07945255f, -0.13170910f, 
    0.11677735f, 0.16265436f, 0.18853492f, -1.08903861f, 0.20268553f, -0.45994833f, 0.06338002f, -0.21079440f, 
    0.15746813f, 0.06149347f, -0.06497928f, -0.02755969f, 0.05352282f, 0.33133093f, -0.18598145f, -0.03914980f, 
    0.17578356f, 0.03225871f, 0.14086987f, 0.10902684f, -0.08851763f, -0.62283635f, 0.20160750f, 0.39461702f, 
    0.34764078f, 0.16370878f, 0.03683644f, 0.05523684f, -0.08889128f, 0.05648573f, -0.68166053f, -0.23877051f, 
    -0.68826306f, -0.10352278f, 0.11347535f, 0.05839159f, 0.04121985f, -0.00404709f, 0.09437070f, -0.18682440f, 
    -0.39511147f, -0.01575940f, 0.05951843f, 0.17710595f, 0.10163133f, 0.20290869f, 0.11612499f, 0.06198673f, 
    -0.28719729f, -0.45118582f, 0.38213634f, 0.14529873f, 0.08158465f, -0.06804916f, 0.01052828f, 0.07715642f, 
    0.07391759f, 0.08647641f, 0.17146009f, -0.21158594f, -0.07931513f, 0.02852694f, -0.07484840f, -0.22565463f, 
    -0.27236873f, -0.35432169f, -0.43164632f, 0.03098902f, 0.12227108f, -0.06097949f, -0.04654689f, -0.11738394f, 
    0.05450646f, -0.00342991f, 0.03185571f, 0.39583004f, 0.25185925f, -0.05500088f, -0.04901483f, 0.11401483f, 
    -0.20031774f, -0.09038625f, 0.19133987f, 0.02912088f, 0.22023423f, 0.27272195f, 0.07047475f, -0.02795874f, 
    -0.06184658f, -0.08332720f, 0.15662462f, 0.12816514f, 0.19118537f, 0.17073463f, 0.12986612f, 0.03976484f, 
    0.03288652f, -0.10294727f, -0.09365629f, 0.00141024f, -0.02778032f, 0.01943370f, -0.77210456f, -0.67793381f, 
    -0.69965011f, -0.07873458f, -0.18732022f, 0.20384911f, 0.07412050f, -0.02373639f, -0.08948233f, 0.17811228f, 
    0.19094722f, 0.09455065f, -0.05215666f, 0.06268898f, -0.01970488f, 0.10487723f, 0.15072325f, 0.07289708f, 
    0.05749443f, 0.08637697f, -0.03087595f, 0.07663387f, -0.15408902f, -0.12535928f, -0.04794472f, 0.11279892f, 
    0.16535351f, -0.57763797f, 0.22228703f, -0.00899449f, -0.07153916f, -0.16144674f, 0.20234874f, 0.14400451f, 
    -0.00355826f, -0.13067313f, 0.15662612f, 0.07314195f, 0.03275949f, -0.01680825f, 0.15019506f, -0.06692366f, 
    0.10436854f, 0.17918257f, 0.24880037f, -0.62002367f, 0.71086496f, -0.59938657f, 0.08664887f, -0.32955691f, 
    0.20370804f, 0.07119157f, 0.02888602f, -0.13254084f, -0.70760298f, -0.75377989f, -1.02424979f, -0.19955479f, 
    -0.35938123f, 0.16245328f, 0.06141873f, -0.06904431f, -0.05435631f, 0.01752120f, -0.13360025f, -0.23973911f, 
    -0.08946397f, 0.02245943f, -0.06059366f, -0.17857699f, -0.03765807f, -0.19717388f, 0.03179970f, 0.01933256f, 
    -0.31817079f, -0.05929980f, 0.12526634f, 0.08639307f, 0.09218596f, 0.16705784f, -0.17504886f, -0.01317513f, 
    -0.29956439f, -0.31021890f, -0.11697199f, 0.20874217f, 0.09333675f, 0.01538739f, -0.14281937f, -0.09515274f, 
    -0.07470933f, 0.03422936f, 0.01855469f, 0.09048702f, 0.07087763f, 0.03260072f, 0.20837897f, 0.10301793f, 
    0.45376003f, 0.36085594f, 0.13445017f, -0.07277709f, -0.02476915f, -0.04523938f, -0.08226209f, -0.00442590f, 
    0.14035860f, -0.35203502f, 0.41733181f, -0.14876640f, 0.31286871f, 0.02254526f, -0.18767053f, -0.12060151f, 
    -0.05980062f, 0.09185655f, 0.02422490f, -0.24780980f, -0.23437488f, -0.17382364f, 0.01387025f, -0.12392281f, 
    -0.21547087f, 0.05945862f, 0.02464101f, 0.02848570f, -0.18189900f, 0.01615414f, 0.18335608f, -0.00732395f, 
    -0.03462575f, 0.02789079f, 0.03458776f, 0.02240280f, 0.11791836f, -0.02647428f, -0.04436687f, -0.01138316f, 
    -0.02196368f, -0.04723249f, 0.02597742f, 0.08025211f, -0.02376485f, 0.29229233f, -0.24231867f, 0.18126352f, 
    0.17420872f, -0.04105503f, 0.05356062f, -0.12929042f, 0.13716123f, 0.09768441f, 0.17799212f, -0.58320928f, 
    0.42382053f, 0.31822512f, -0.10900736f, 0.13318813f, -0.16207625f, 0.04919398f, 0.01593122f, -0.14067562f, 
    -0.73616582f, -0.28933391f, -0.61381942f, 0.12088467f, -0.09677065f, -0.28794470f, -0.06035457f, -0.05349023f, 
    -0.10260955f, -0.03357041f, 0.10088836f, -0.11370619f, -0.06118839f, 0.02411337f, 0.08158585f, 0.07475977f, 
    -0.04146632f, -0.08762467f, 0.37521696f, -0.27920291f, -0.13281725f, -0.07018404f, 0.10140567f, 0.14540735f, 
    -0.13165177f, -0.00126197f, 0.04176518f, 0.02075754f, -0.04708791f, -0.24849521f, -0.27777019f, -0.05332435f, 
    0.04240667f, 0.05145985f, 0.06640436f, -0.05601785f, -0.33131227f, -0.12622859f, 0.06806719f, 0.17534636f, 
    -0.03904092f, -0.04834850f, 0.06707525f, -0.21013814f, 0.34149423f, -0.38125360f, -0.09133831f, -0.42619279f, 
    0.02697765f, 0.20545410f, -0.16572008f, 0.14796367f, 0.01041039f, 0.11414163f, -0.18995817f, -0.09032893f, 
    0.63861972f, 0.08159725f, 0.25637263f, 0.04736901f, 0.00497381f, 0.05115461f, 0.10209519f, 0.15352039f, 
    0.27516755f, 0.05814631f, -0.20353422f, 0.10778173f, -0.09885465f, -0.02053509f, 0.02276767f, -0.23666520f, 
    -0.58335596f, -0.52136171f, -0.31825909f, 0.15647763f, -0.03460176f, 0.01191131f, 0.05421278f, -0.13226324f, 
    -0.02591521f, -0.09683088f, -0.12524749f, -0.11624736f, -0.03270927f, 0.00592903f, 0.18464406f, -0.08728837f, 
    -0.06114866f, 0.05996100f, -0.78626984f, -0.28591585f, -0.38444006f, -0.23626238f, 0.10052855f, -0.42797038f, 
    -0.12244862f, -0.02029174f, -0.19022462f, 0.31355357f, -0.02782556f, 0.12417468f, -0.03290571f, 0.01026397f, 
    0.16582017f, 0.04456846f, 0.00727322f, -0.02216373f, 0.30341399f, 0.01611420f, -0.05458593f, 0.06898241f, 
    -0.08918453f, 0.01042680f, 0.11483788f, 0.03305275f, 0.10305616f, 0.31947696f, 0.14165825f, 0.10194130f, 
    -0.07353470f, 0.08926491f, 0.03871851f, -0.05761948f, -0.09429482f, -0.09783586f, -0.17921755f, -0.00452094f, 
    -0.30706471f, -0.08499917f, -0.07384111f, -0.06704722f, 0.06664837f, 0.06353353f, 0.06108433f, -0.04108350f, 
    0.03780516f, 0.01777050f, 0.02942091f, 0.05334875f, 0.07808708f, -0.07790773f, -0.03715308f, 0.21597704f, 
    -0.10304295f, -0.16728397f, -0.15320568f, -0.05193473f, 0.06837586f, 0.04565190f, 0.13203977f, 0.03755741f, 
    -0.12475853f, 0.24755308f, 0.12926167f, -0.05686256f, 0.07447840f, 0.14849873f, 0.16733490f, -0.10162943f, 
    -0.07534204f, 0.34242231f, -0.30514002f, 0.26881456f, -0.01403052f, 0.05355189f, 0.03351690f, 0.07041325f, 
    0.09991062f, -0.20296206f, 0.12663355f, -0.84287226f, -0.21224645f, 0.13384086f, -0.03945110f, -0.17040733f, 
    -0.15311542f, 0.02795045f, 0.16528264f, -0.05142526f, -0.14799517f, 0.18963993f, 0.39336413f, -0.05652135f, 
    0.16771573f, 0.13816665f, -0.06937135f, 0.11562829f, 0.19978678f, 0.05803288f, -0.05515010f, 0.08241474f, 
    -0.03793167f, -0.01436407f, 0.13212591f, 0.03577976f, 0.04457314f, 0.13175738f, -0.47056237f, -0.15749513f, 
    0.16565962f, 0.02521319f, -0.06154156f, 0.03891916f, 0.28531399f, -0.04162620f, -0.04184207f, -0.35329339f, 
    0.17214431f, 0.14961725f, 0.07456838f, 0.12175433f, 0.14892861f, 0.02610661f, 0.04584918f, 0.09016956f, 
    0.01289081f, -0.03478328f, 0.04434497f, -0.04418090f, 0.02565261f, -0.06045763f, 0.00555856f, -0.04158411f, 
    -0.03395807f, -0.05737366f, 0.04049457f, -0.02692476f, -0.04947022f, -0.00863260f, -0.05296575f, 0.02417944f, 
    -0.06077847f, 0.02829096f, 0.01930235f, -0.05086181f, 0.01957006f, -0.06403190f, 0.03026596f, -0.03028747f, 
    0.02231980f, 0.02252620f, 0.03598899f, 0.03196825f, -0.03918016f, 0.00660774f, -0.03936216f, 0.03341374f, 
    -0.03924754f, 0.01708489f, -0.03526104f, -0.01663454f, -0.04650253f, -0.05401825f, -0.02165283f, -0.04311445f, 
    -0.00130605f, 0.03359043f, -0.04918083f, 0.03226948f, -0.01385572f, 0.02122978f, -0.05491823f, -0.02337665f, 
    -0.04418026f, -0.05563470f, -0.00908733f, 0.01242040f, 0.03090342f, -0.01809147f, -0.04082389f, 0.01319310f, 
    0.00941375f, -0.00884240f, 0.00121404f, -0.00582912f, -0.03201209f, 0.00549999f, -0.03868085f, -0.01685462f, 
    0.04265607f, 0.02519687f, 0.00176500f, 0.05025214f, 0.02207016f, -0.03279594f, 0.02249805f, 0.04817593f, 
    0.03415214f, -0.01591420f, -0.05262880f, 0.05409519f, 0.04080621f, 0.03662572f, -0.00728515f, 0.00877027f, 
    0.01361949f, 0.03831866f, -0.00864878f, -0.06421264f, 0.01146844f, 0.00423456f, -0.02674796f, 0.04065473f, 
    0.01466036f, 0.03650286f, -0.06159841f, -0.00998472f, -0.03544748f, 0.02190276f, -0.06751255f, -0.05364760f, 
    -0.05821503f, 0.03080216f, 0.01669746f, 0.02398159f, -0.06900782f, -0.00950488f, 0.02184095f, 0.03693453f, 
    -0.03293122f, -0.01290600f, 0.02021422f, 0.00018890f, 0.02596179f, -0.05037014f, -0.00112678f, 0.00788161f, 
    -0.03381461f, 0.04268310f, -0.02629605f, -0.03477550f, -0.05565547f, -0.01523897f, -0.05606145f, 0.03666420f, 
    -0.02497149f, -0.00788676f, -0.00071920f, 0.02018852f, -0.01844911f, -0.01588558f, -0.01265604f, 0.02867518f, 
    0.04205586f, -0.06703874f, 0.04829581f, 0.04375281f, -0.01594846f, 0.04229107f, 0.03680753f, 0.00360740f, 
    -0.01270323f, 0.01462859f, 0.02590246f, 0.03042418f, -0.04341869f, 0.03283064f, 0.02501756f, -0.01544640f, 
    0.06520010f, 0.00722030f, -0.01091496f, 0.04808494f, 0.02905274f, 0.03813812f, 0.02452564f, -0.03802793f, 
    -0.04031880f, 0.04133892f, -0.05502397f, 0.02583372f, 0.00489874f, -0.02998077f, 0.00636104f, -0.05829744f, 
    -0.00212350f, -0.06699135f, -0.00995331f, -0.03282238f, 0.00149153f, 0.02261945f, -0.01050440f, -0.04820206f, 
    -0.00139618f, -0.06001687f, -0.05070635f, 0.04027813f, 0.04811112f, -0.02661196f, -0.01701052f, -0.03506012f, 
    -0.02845708f, 0.00623198f, 0.00755023f, -0.05778052f, -0.03108852f, 0.02567274f, -0.00169794f, -0.00008069f, 
    -0.02487058f, -0.00375971f, 0.04351791f, -0.05960243f, 0.00189105f, 0.02850069f, 0.04695633f, 0.03631175f, 
    -0.02561639f, 0.00746629f, -0.05770405f, 0.04753270f, 0.03470163f, -0.06097152f, 0.04914218f, -0.02567988f, 
    -0.04949914f, -0.05647497f, -0.04925503f, 0.00843709f, -0.04950494f, -0.06814262f, -0.04872050f, -0.04442795f, 
    -0.02922459f, -0.00097404f, 0.04721011f, -0.00698069f, -0.03045804f, -0.04073467f, 0.00263352f, 0.01806100f, 
    0.03654338f, -0.00220629f, -0.02300706f, -0.03992495f, -0.03122345f, -0.04874983f, 0.03255555f, -0.03639664f, 
    0.03682975f, -0.04828277f, -0.03394847f, -0.04348288f, 0.03265025f, 0.00765582f, 0.04081525f, -0.00952501f, 
    0.02720049f, -0.04763767f, 0.01690528f, -0.05010946f, -0.02380412f, 0.01120470f, 0.01471931f, -0.05618285f, 
    0.04819740f, 0.02711522f, 0.00348016f, 0.04874584f, -0.04654012f, -0.06072934f, -0.00235253f, -0.03132174f, 
    -0.04266060f, 0.03320540f, 0.00147211f, -0.04030081f, -0.05786711f, 0.04049059f, 0.00073987f, 0.02275679f, 
    0.03717526f, -0.02712316f, -0.03549965f, 0.01411602f, 0.04881026f, -0.05269220f, 0.03711648f, 0.04754891f, 
    -0.00867774f, -0.00700970f, 0.02827796f, -0.06106774f, 0.03734157f, 0.01442001f, -0.03765523f, -0.03218052f, 
    -0.04783501f, 0.03390034f, -0.03338629f, 0.04374078f, 0.02090914f, -0.00008103f, -0.05920927f, 0.03349132f, 
    -0.05458616f, 0.01002170f, -0.00421315f, -0.05793895f, 0.00334075f, 0.01638865f, -0.00824632f, 0.01909192f, 
    -0.15287656f, -0.01056008f, 0.42442608f, -0.12982692f, -0.14440224f, -0.25976655f, 0.08832846f, 0.08455828f, 
    0.11358210f, -0.10949074f, -0.05723705f, 0.11026739f, -0.13953842f, -0.13637468f, 0.18007983f, 0.02009146f, 
    -0.08893415f, -0.08851725f, 0.25279614f, 0.40564647f, -0.13474514f, -0.27881745f, 0.13371508f, 0.08902802f, 
    -0.36252576f, -0.06565242f, 0.19980238f, -0.17606020f, -0.07076824f, 0.43418974f, -0.14106242f, -0.08467957f, 
    -0.01776023f, 0.03049581f, 0.10182044f, -0.00192473f, -0.12571260f, 0.18089734f, -0.04130242f, 0.07877536f, 
    0.00356746f, -0.04813949f, -0.06623673f, 0.00794798f, 0.04793485f, -0.08628280f, 0.02463001f, 0.25068298f, 
    0.04366208f, -0.25973728f, -0.22164135f, -0.00067576f, 0.17453451f, 0.16298403f, -0.20885833f, -0.00620455f, 
    0.10456266f, 0.03532173f, -0.48925230f, 0.09056185f, 0.03440631f, -0.09743880f, 0.04940874f, -0.16635118f, 
    0.04722018f, 0.40280434f, 0.05573865f, 0.19840524f, -0.05793532f, 0.11422411f, -0.01683416f, 0.10817821f, 
    -0.18108787f, -0.02872317f, 0.16791186f, -0.10160517f, 0.03219083f, -0.03242878f, -0.02712893f, -0.14408226f, 
    -0.10286461f, -0.20768943f, 0.09594029f, -0.09187175f, 0.22415832f, -0.19008839f, -0.09468540f, -0.01859747f, 
    0.32597375f, -0.08335502f, -0.38834211f, 0.25870326f, -0.09368997f, -0.13006656f, -0.03418276f, -0.08874055f, 
    -0.09551791f, -0.04981776f, -0.10973248f, -0.04432294f, -0.33408424f, 0.35772666f, -0.08175392f, 0.00464304f, 
    -0.09602010f, 0.05985138f, 0.00405714f, 0.05377134f, 0.17611282f, 0.18246603f, 0.50880742f, -0.10302332f, 
    -0.27001557f, 0.10125136f, 0.07960884f, 0.20421526f, 0.13513950f, -0.15504420f, -0.01441489f, 0.33125147f, 
    -0.06947478f, -0.01973261f, -0.17144203f, 0.03257998f, -0.15645346f, -0.16148120f, 0.08025556f, 0.31024864f, 
    0.35583133f, -0.00395568f, -0.05837601f, -0.01562988f, 0.00429354f, -0.05971025f, 0.05766664f, -0.04911248f, 
    0.35631263f, 0.36165175f, -0.04238354f, -0.09858808f, 0.11283982f, -0.11873881f, 0.03206249f, 0.02501880f, 
    -0.35128024f, 0.41563046f, 0.39570811f, -0.16395597f, 0.00731338f, -0.22714199f, -0.06589819f, 0.18299663f, 
    -0.19786590f, -0.14596236f, -0.06268526f, 0.17915210f, -0.05632525f, 0.06859680f, -0.20940842f, 0.17712463f, 
    -0.06914704f, 0.05318196f, -0.03627703f, -0.02845902f, 0.51078391f, -0.03647270f, -0.04273145f, 0.02308799f, 
    0.11861899f, -0.06570835f, -0.03628087f, -0.25712317f, 0.24751030f, 0.14635010f, 0.00617114f, 0.06965920f, 
    -0.07444792f, -0.18036090f, 0.00219529f, -0.07541668f, -0.21141542f, 0.12941636f, 0.41357693f, -0.06860045f, 
    -0.05055024f, 0.09931215f, 0.08662312f, 0.12687580f, -0.05645901f, -0.10881568f, 0.15602143f, 0.01859017f, 
    -0.06586171f, 0.03925953f, -0.04202080f, 0.11447763f, 0.12162171f, 0.01305847f, -0.24838635f, -0.32733980f, 
    0.10840056f, 0.04302388f, 0.08494102f, -0.07340937f, 0.02023099f, 0.00987159f, -0.08692470f, -0.08454562f, 
    0.27379051f, 0.18323493f, 0.03979925f, -0.08280699f, -0.04736867f, 0.11555707f, 0.04874440f, 0.00641102f, 
    0.09100121f, 0.26001060f, -0.06568100f, -0.07427799f, 0.11156251f, -0.34398553f, -0.02330153f, 0.11683367f, 
    -0.10068750f, 0.03810487f, -0.04591531f, 0.15185462f, -0.01125334f, -0.03207753f, -0.09880473f, 0.03153185f, 
    0.21479326f, -0.00417467f, 0.02538836f, -0.09885880f, 0.22587253f, -0.16311099f, -0.28842956f, 0.26726484f, 
    0.02038541f, -0.01392474f, -0.10611846f, -0.10507316f, -0.56636679f, 0.51545513f, -0.24957080f, 0.01113009f, 
    -0.00324796f, -0.12802723f, -0.06940144f, -0.06790026f, -0.07371512f, -0.15016383f, 0.20678824f, 0.06936535f, 
    0.07278663f, -0.17586485f, 0.03541379f, 0.19164704f, -0.08626439f, -0.18074530f, 0.08856434f, 0.06956540f, 
    0.03313728f, 0.09624264f, 0.09435374f, 0.00053326f, 0.04224345f, 0.00500514f, -0.08324499f, -0.01061817f, 
    -0.08985560f, -0.05839496f, 0.27603403f, -0.01294361f, -0.13312587f, -0.18402147f, 0.06482764f, -0.10494935f, 
    0.01133102f, 0.39692667f, -0.07358108f, -0.21294853f, -0.00315014f, -0.02883348f, -0.05130863f, 0.02218446f, 
    0.00319238f, 0.19827358f, 0.20118469f, -0.10796910f, -0.04966798f, 0.00798100f, 0.19580308f, 0.07282621f, 
    0.23086189f, 0.16522673f, 0.18061668f, -0.42657831f, 0.04042761f, -0.12735279f, -0.01869588f, -0.11373553f, 
    -0.04214051f, -0.52144676f, 0.59748256f, -0.21569508f, 0.20805603f, 0.03354876f, 0.04250642f, -0.03225076f, 
    -0.06532600f, 0.09825333f, -0.12311390f, -0.40866345f, -0.11474118f, 0.09296050f, -0.19027469f, -0.16820437f, 
    -0.07699960f, 0.08207041f, 0.04291004f, 0.04599095f, -0.29153025f, 0.01703969f, 0.09746289f, 0.04683103f, 
    0.07567056f, -0.05360619f, 0.12572223f, 0.14541535f, 0.39996180f, 0.00340635f, 0.19325505f, -0.00326671f, 
    -0.09297296f, -0.21049838f, -0.09284090f, 0.08408173f, -0.06943700f, 0.13371310f, -0.38727385f, -0.12104937f, 
    0.18434660f, -0.24441198f, 0.09656355f, 0.23695488f, 0.26856858f, 0.03095093f, 0.01784431f, -0.23164360f, 
    0.38097429f, 0.51695180f, -0.07337157f, 0.13899167f, -0.13193169f, -0.01882998f, -0.01436752f, 0.03560477f, 
    -0.34524292f, -0.08031812f, -0.05839755f, -0.03845853f, 0.08793087f, -0.23039435f, -0.09348430f, -0.10421728f, 
    -0.05586847f, -0.06302077f, 0.10755520f, 0.02135056f, -0.13805702f, -0.21741545f, -0.09227098f, 0.20965269f, 
    0.08845075f, 0.22329129f, -0.09054670f, -0.40646234f, -0.15739320f, -0.08076808f, 0.02598021f, -0.11788414f, 
    0.16908650f, -0.09356221f, -0.03155092f, -0.14943102f, -0.00817933f, 0.04000458f, -0.17255791f, -0.12092693f, 
    -0.01111685f, -0.04583844f, 0.25455716f, 0.02113732f, -0.28056198f, 0.05723446f, 0.21225893f, 0.09023395f, 
    -0.10329787f, 0.00114381f, 0.11487455f, -0.03455668f, 0.25028458f, -0.18319608f, -0.51578224f, 0.03202102f, 
    0.08865056f, 0.11939095f, 0.01225128f, 0.10969453f, -0.07178605f, -0.00788532f, -0.11068960f, 0.14880292f, 
    0.85563087f, 0.18272956f, 0.00009861f, -0.12771900f, -0.15743856f, 0.12908649f, 0.17830662f, 0.02710773f, 
    0.43428287f, -0.01180230f, 0.05421231f, -0.09755998f, -0.09152785f, 0.13613510f, 0.06081633f, -0.07699612f, 
    0.00056938f, -0.85821748f, -0.50167644f, 0.02003512f, -0.11700088f, -0.02550879f, -0.01704963f, -0.11957846f, 
    -0.15453294f, -0.15101987f, -0.21260294f, -0.18046632f, -0.15280047f, -0.26865143f, -0.17303006f, -0.03777197f, 
    -0.07091683f, 0.17658493f, -0.57667679f, 0.01795983f, -0.36025172f, -0.14544889f, -0.00719602f, -0.18733354f, 
    -0.03745814f, -0.00096038f, -0.24029480f, 0.12005725f, -0.13750999f, -0.10610457f, 0.00595895f, -0.11659850f, 
    0.19496015f, 0.03047556f, -0.01707389f, -0.37973106f, 0.13706920f, -0.06068171f, -0.32321271f, 0.09732932f, 
    0.06943427f, 0.03673291f, 0.16278124f, 0.09729300f, 0.16201940f, 0.10129811f, -0.00880307f, -0.07547414f, 
    0.14931113f, -0.06448613f, -0.00764446f, -0.22461773f, -0.00294326f, -0.24689300f, -0.20536143f, -0.12518033f, 
    -0.09680881f, -0.09645167f, -0.07520939f, 0.17812042f, -0.11654545f, 0.01854338f, -0.04942616f, -0.14784537f, 
    0.09375530f, -0.00358517f, 0.21253066f, -0.06749949f, -0.25488916f, -0.03035067f, 0.15249518f, -0.00284341f, 
    -0.02801001f, -0.50664657f, -0.00742844f, -0.18363379f, -0.19687295f, -0.11351001f, 0.01258327f, -0.15270315f, 
    -0.12862752f, -0.25600085f, -0.29992968f, 0.43029597f, 0.04012622f, -0.14765972f, 0.09166032f, -0.19859207f, 
    0.01721179f, 0.25348186f, -0.19094160f, 0.37903053f, 0.01789710f, -0.03733347f, 0.00829782f, 0.02331547f, 
    0.23098697f, 0.10286830f, 0.30054221f, -0.24575387f, -0.09177244f, 0.03830648f, -0.06755194f, 0.23924324f, 
    -0.06055859f, 0.02990229f, 0.11973629f, -0.06312833f, -0.07229877f, 0.06178172f, 0.44361982f, -0.11800101f, 
    -0.15456237f, 0.24251854f, 0.04156590f, 0.36902925f, 0.26590523f, 0.25700781f, -0.15613206f, -0.12876293f, 
    -0.12671059f, -0.05085259f, 0.05023334f, -0.08941639f, 0.04907194f, -0.08034175f, -0.11413662f, -0.27588007f, 
    0.15051936f, 0.10318083f, 0.08274636f, -0.24675126f, 0.07054268f, -0.00169257f, 0.11269078f, -0.17746903f, 
    0.32196176f, 0.10090937f, -0.04253393f, -0.13806555f, 0.08179648f, 0.03093005f, -0.03110835f, 0.10285660f, 
    -0.00082681f, 0.07335933f, 0.06182214f, -0.10241154f, 0.01395784f, 0.09863513f, 0.20361246f, -0.02872184f, 
    -0.02711251f, -0.08365569f, 0.00198229f, -0.03739907f, 0.07869004f, -0.11041883f, 0.11494838f, -0.07149038f, 
    0.16464727f, 0.09393142f, -0.07173169f, -0.24947369f, -0.03188601f, 0.25476483f, -0.19515915f, 0.15677035f, 
    -0.00675850f, -0.18258113f, 0.11852908f, 0.02332166f, 0.50349873f, -0.04952273f, 0.09281858f, 0.09896905f, 
    0.08388834f, 0.16831169f, 0.04362321f, -0.10261718f, -0.09828265f, -0.11794049f, 0.03035165f, 0.02331587f, 
    -0.05877998f, 0.07297932f, 0.02754592f, 0.04968159f, 0.02322574f, 0.06500103f, -0.00330438f, 0.13318041f, 
    0.05921145f, 0.17026593f, 0.16108783f, 0.02041053f, -0.03691293f, 0.03957606f, -0.17531405f, 0.00481675f, 
    -0.04980384f, -0.20768289f, -0.22352892f, -0.04489108f, -0.11124945f, 0.13471861f, -0.18818796f, -0.01019379f, 
    -0.01247603f, 0.12618095f, 0.09245878f, 0.06694722f, -0.04149632f, 0.14767976f, -0.02748773f, -0.06625157f, 
    -0.05262783f, 0.05764122f, -0.06354500f, -0.24385485f, 0.04110318f, -0.01438350f, 0.09555473f, 0.01872376f, 
    -0.07683699f, -0.07613578f, -0.10430896f, 0.19205672f, 0.09954491f, -0.05823620f, 0.01569078f, 0.22020254f, 
    -0.06109269f, -0.10811932f, 0.06719394f, -0.16472885f, 0.19200642f, 0.06409740f, -0.03435883f, 0.06608526f, 
    -0.09427600f, -0.02132131f, 0.07878930f, -0.25107038f, -0.09353830f, -0.08004919f, 0.17410287f, -0.06361538f, 
    -0.01919329f, 0.03922655f, -0.35967019f, -0.44564745f, 0.06145815f, -0.04593299f, 0.10625743f, -0.20019940f, 
    0.30391124f, -0.10859102f, 0.13033225f, -0.22779010f, -0.14051326f, 0.04637181f, 0.37067306f, -0.20183878f, 
    0.08378450f, 0.04435445f, 0.06898480f, 0.06813292f, 0.14474532f, -0.17019947f, 0.34140942f, 0.35651600f, 
    -0.09329472f, -0.01436710f, -0.11793870f, -0.13654287f, 0.19361307f, -0.13137013f, 0.00926421f, 0.05732293f, 
    0.18328764f, 0.18773350f, 0.09246495f, -0.04174632f, 0.08952418f, -0.08050171f, 0.05746320f, -0.22082593f, 
    -0.31173670f, -0.22130890f, -0.27375206f, -0.00760348f, 0.03812125f, -0.23079604f, 0.01892655f, 0.17166951f, 
    -0.00330447f, 0.02003928f, -0.03400537f, 0.10817863f, -0.04098844f, 0.07717053f, 0.03606167f, 0.03932349f, 
    0.10415858f, -0.06789605f, 0.28702292f, -0.07645684f, -0.09220532f, 0.08667747f, 0.04017529f, 0.04980615f, 
    0.14618702f, 0.17684224f, -0.09854657f, -0.24804521f, -0.19834031f, -0.03742207f, 0.00773083f, -0.17221613f, 
    -0.06572001f, -0.08879625f, -0.06519051f, -0.11788937f, -0.07942960f, 0.04176819f, 0.09274956f, 0.10403616f, 
    0.06375314f, 0.16234566f, -0.00474711f, 0.14571312f, 0.07291892f, -0.06465038f, 0.06165118f, 0.14845371f, 
    -0.00602375f, -0.03563124f, 0.22953075f, 0.01347647f, 0.02556860f, 0.11929027f, -0.12385416f, 0.28935024f, 
    0.24115527f, -0.01975206f, -0.00367332f, -0.12593186f, 0.05836458f, -0.07788782f, -0.27786434f, 0.06950689f, 
    -0.14970800f, 0.10151871f, 0.25340575f, -0.02535948f, -0.01647414f, 0.15236193f, -0.06887308f, -0.02354597f, 
    -0.08244031f, -0.07207851f, 0.10495885f, -0.12177875f, -0.01816653f, -0.06094030f, 0.22105649f, 0.02442444f, 
    -0.06699418f, -0.22995977f, 0.30062643f, 0.08660258f, 0.06360832f, 0.12980694f, -0.02416490f, 0.28989041f, 
    -0.01435535f, -0.09196040f, 0.15659519f, -0.04033083f, -0.07275192f, -0.00347259f, -0.06096506f, -0.00951643f, 
    0.27497551f, 0.18823522f, -0.05826240f, -0.38306016f, 0.06911639f, 0.18740702f, -0.14923152f, -0.00543929f, 
    -0.00681204f, 0.08089469f, -0.10040336f, -0.06574703f, -0.41670471f, 0.27633819f, 0.25084057f, -0.04587523f, 
    -0.25847149f, -0.25944462f, 0.18299401f, -0.14923909f, 0.00873459f, 0.02821593f, -0.00702672f, 0.06774920f, 
    -0.02436508f, -0.02048521f, 0.04459493f, 0.08847599f, -0.23100677f, -0.16830260f, 0.04738430f, 0.05310062f, 
    0.02740861f, -0.08291124f, 0.05558056f, -0.07117928f, 0.15128475f, -0.07438087f, 0.07046610f, 0.12014133f, 
    0.08911751f, 0.14769818f, 0.04659293f, -0.03232566f, 0.04558399f, 0.11550907f, -0.01555298f, -0.04537611f, 
    0.01432057f, 0.02892440f, -0.03767271f, -0.00085198f, 0.02335575f, 0.03694937f, -0.05401878f, 0.03318787f, 
    0.01970323f, 0.05224054f, 0.01053420f, -0.06131721f, -0.04260104f, -0.00117116f, 0.01987653f, -0.04201907f, 
    -0.02987968f, -0.02332989f, -0.03847808f, -0.04438321f, 0.04462912f, -0.05167387f, -0.06145942f, -0.05085327f, 
    0.03941880f, 0.04450367f, 0.01015815f, 0.03534542f, -0.03908254f, -0.04235175f, 0.02928447f, -0.01415205f, 
    -0.05893417f, -0.03293937f, 0.00162686f, 0.00207448f, 0.05031843f, -0.04954420f, 0.05183115f, -0.00654855f, 
    0.02030719f, -0.01245470f, 0.02924068f, 0.03018235f, -0.01210853f, -0.06185726f, -0.00834246f, 0.05194741f, 
    0.01681841f, 0.03092986f, 0.00914435f, 0.03615095f, -0.04208797f, 0.01806512f, -0.03713179f, -0.00180539f, 
    0.00779371f, -0.02565235f, -0.01681938f, 0.02347053f, -0.04973262f, 0.00303278f, -0.01551092f, 0.02266872f, 
    -0.01721250f, -0.00436618f, -0.04852692f, 0.05051795f, -0.03730003f, -0.05116743f, -0.01387490f, -0.06076049f, 
    -0.04907907f, 0.05176399f, -0.00154017f, -0.06529127f, 0.02069458f, 0.01547117f, -0.05577421f, 0.04825812f, 
    -0.02312479f, -0.02984138f, 0.03387795f, 0.03618632f, -0.05515616f, -0.01666927f, 0.02175640f, 0.03398351f, 
    0.01288497f, -0.00456255f, -0.06309088f, 0.02252870f, -0.02652646f, -0.01723015f, -0.06351849f, 0.04161941f, 
    0.04081854f, -0.05493351f, 0.03733879f, 0.02746174f, 0.04129544f, 0.02906393f, -0.05351756f, -0.02119232f, 
    -0.04303176f, -0.02790763f, -0.04875819f, -0.00320035f, 0.00888485f, 0.01671964f, -0.04983974f, 0.01320552f, 
    -0.02944954f, -0.00393348f, -0.01714922f, 0.04369555f, -0.02101377f, -0.05966513f, 0.04913496f, 0.04315264f, 
    0.03163989f, -0.01678554f, 0.00808046f, 0.01015270f, -0.02995550f, -0.03567400f, 0.01967965f, 0.04800656f, 
    -0.06500483f, -0.00741506f, -0.04140843f, 0.02630071f, 0.04237461f, -0.03788351f, -0.00094284f, -0.02005514f, 
    0.00892940f, -0.03626436f, -0.06219707f, -0.04321356f, -0.04911987f, 0.01066505f, -0.03547515f, 0.04703415f, 
    0.03329026f, 0.01406797f, 0.00839587f, -0.00560952f, -0.00819193f, -0.06556739f, 0.00199062f, -0.04566889f, 
    -0.04932187f, 0.00613893f, -0.00971439f, -0.04991822f, 0.02308576f, -0.02565982f, 0.05663884f, -0.00737648f, 
    0.03291053f, -0.03165202f, 0.03582124f, 0.00294917f, 0.04564835f, -0.02447281f, 0.00417322f, 0.03788475f, 
    -0.04269195f, 0.03228942f, -0.04544754f, -0.03183091f, 0.00657692f, 0.04850823f, 0.02232028f, 0.01373017f, 
    0.01372165f, -0.04151921f, -0.05003173f, 0.02805925f, -0.00547489f, 0.03629295f, 0.01978532f, -0.01219743f, 
    0.00873245f, -0.02685449f, -0.04455115f, -0.00580997f, -0.01740330f, -0.04984448f, -0.01038201f, -0.05715971f, 
    0.05402183f, -0.06487078f, 0.04832909f, 0.03779884f, -0.00710625f, 0.00883278f, -0.03695624f, 0.02197048f, 
    -0.03350059f, -0.00871817f, 0.00190007f, -0.04411164f, 0.02009837f, 0.04997449f, -0.05089724f, -0.01627452f, 
    0.03454980f, -0.05440825f, 0.01534021f, 0.02434832f, -0.03169475f, 0.02291739f, -0.04042669f, -0.05216897f, 
    -0.05800853f, -0.02309419f, -0.04206636f, -0.01335157f, 0.01824231f, -0.03322810f, -0.02719669f, -0.04647099f, 
    0.01356066f, 0.02574853f, -0.06360149f, -0.03967279f, 0.00231055f, -0.06271844f, -0.01978095f, -0.00761547f, 
    0.00400770f, -0.02045574f, -0.05742707f, -0.04475681f, 0.02466224f, -0.01859780f, -0.06334557f, -0.03124189f, 
    -0.04804827f, -0.06543701f, 0.00346539f, -0.04672652f, 0.02312813f, -0.01639083f, 0.04552579f, -0.02560342f, 
    -0.04762655f, 0.03028540f, 0.01918710f, 0.00098998f, -0.00946441f, 0.02516741f, -0.02046093f, -0.06339327f, 
    -0.00814164f, 0.02263763f, -0.00085813f, -0.05940401f, -0.06161765f, -0.00483341f, 0.01353655f, -0.05610159f, 
    0.02351222f, -0.03154396f, 0.01685940f, -0.00292580f, -0.05965932f, 0.04026668f, -0.01765108f, -0.00626908f, 
    -0.03087725f, 0.03131616f, -0.02244408f, -0.04846196f, 0.01745739f, 0.02239592f, 0.05230848f, 0.04826237f, 
    0.04723403f, 0.03042448f, 0.00551895f, -0.02627342f, 0.03270438f, -0.00583895f, 0.01005456f, -0.04786067f, 
    -0.18498757f, 0.14356434f, -0.06876422f, -0.05172767f, 0.17889941f, 0.00606096f, 0.12613559f, 0.12835458f, 
    0.20980152f, 0.13813403f, -0.47480479f, -0.22999844f, -0.08265283f, 0.16186030f, -0.04368852f, 0.12103921f, 
    0.14012402f, -0.09848452f, 0.66205275f, -0.15116900f, 0.14934281f, 0.11088050f, -0.04573566f, 0.04476834f, 
    0.16111358f, -0.00950884f, 0.55086195f, 0.06411073f, -0.09361885f, 0.11602394f, -0.07101112f, -0.08383813f, 
    -0.10398427f, 0.13834842f, 0.05122703f, 0.10227469f, 0.22659196f, -0.02615147f, 0.10861975f, -0.17327926f, 
    -0.08142304f, -0.02366257f, 0.19621751f, -0.02476585f, 0.33025604f, -0.16408712f, 0.06353160f, -0.05545684f, 
    -0.13375269f, 0.03861745f, -0.14666134f, -0.00773487f, 0.06404857f, 0.06711134f, -0.05600272f, 0.23786426f, 
    0.15317430f, 0.19611518f, -0.12313297f, -0.19696613f, -0.15623100f, -0.13361372f, 0.27605769f, -0.04943972f, 
    0.03729247f, -0.04473912f, -0.08038493f, 0.10967924f, 0.03193557f, 0.14816095f, -0.04560708f, -0.12315563f, 
    -0.20608644f, -0.34601334f, -0.37500697f, 0.05393993f, 0.04764261f, -0.13719766f, 0.04600826f, -0.15378173f, 
    0.14765653f, 0.30597419f, -0.12475227f, -0.00850313f, 0.00592441f, 0.15980412f, 0.04031712f, 0.17917687f, 
    -0.06900292f, -0.06402058f, 0.54212290f, -0.34915054f, 0.05173968f, -0.17002882f, -0.08601720f, -0.26119822f, 
    -0.19871071f, 0.06700649f, 0.00560831f, -0.24466491f, -0.29377854f, -0.37168604f, -0.63819760f, -0.19793025f, 
    -0.26211882f, 0.00815186f, 0.21224487f, -0.02209430f, -0.30974227f, 0.00450966f, 0.01392371f, 0.01214693f, 
    0.15846059f, -0.05189750f, 0.16888459f, 0.19130334f, 0.24429645f, -0.07133025f, 0.12501553f, 0.06565046f, 
    -0.18746004f, -0.07075311f, 0.15264983f, 0.30836976f, 0.08783827f, 0.14895141f, 0.35246831f, 0.14142571f, 
    0.26905224f, 0.13822269f, 0.04252605f, 0.01268100f, 0.04024456f, -0.07770181f, 0.25667122f, -0.11567211f, 
    -0.36634380f, -0.04262146f, 0.13065881f, 0.19660899f, 0.15093608f, 0.27232370f, 0.07630365f, -0.05901615f, 
    -0.15730825f, -0.79149652f, 0.46530190f, -0.05206396f, -0.09467889f, -0.05978497f, -0.02321328f, 0.09293944f, 
    0.28307101f, -0.10245372f, -0.01770988f, -0.42420450f, -0.40535873f, -0.19167168f, 0.01689483f, 0.05233391f, 
    -0.17088334f, -0.19027537f, -0.63704044f, -0.75909698f, -0.25256723f, 0.10197518f, 0.07120159f, -0.15315312f, 
    0.03925155f, 0.14856277f, -0.05217592f, -0.21305299f, -0.29369143f, -0.07082353f, -0.14954536f, 0.08660130f, 
    -0.23999935f, -0.12319537f, 0.10500694f, 0.22739613f, 0.07596590f, 0.00542665f, 0.05500381f, -0.08320377f, 
    0.16955456f, 0.16036838f, 0.15601295f, -0.00935719f, 0.26067069f, 0.18649137f, 0.20786344f, -0.04476799f, 
    0.13089320f, -0.23577291f, -0.09639273f, -0.05248365f, -0.08125289f, 0.24941583f, -0.34990832f, -0.23317941f, 
    -0.11881586f, -0.24516442f, -0.15720478f, -0.03840711f, -0.02351298f, 0.01145467f, 0.08997212f, -0.08380738f, 
    0.02082662f, 0.25552064f, -0.03549928f, -0.07697548f, 0.05579837f, 0.11160170f, -0.10875233f, 0.35825431f, 
    -0.05652568f, -0.34134141f, -0.07604700f, 0.04689154f, -0.36320248f, 0.15048552f, 0.09749438f, 0.01632288f, 
    0.18661802f, 0.33972234f, -0.11647750f, 0.03880968f, -0.07739913f, 0.17273891f, 0.15557529f, 0.03786082f, 
    0.10293891f, 0.03837307f, -0.22586325f, 0.12043254f, 0.15428272f, 0.18556152f, 0.09538830f, 0.18439877f, 
    0.00385684f, -0.03805873f, 0.09492125f, -0.05230316f, -0.41369647f, -0.06867436f, -0.26953742f, -0.32030705f, 
    -0.30970967f, -0.16300417f, 0.02731889f, -0.14825521f, -0.19863664f, 0.03935809f, 0.15176530f, 0.03085565f, 
    0.11237904f, 0.09546462f, -0.10994346f, -0.12158221f, 0.09847809f, 0.02230924f, -0.35066763f, -0.25205550f, 
    -0.32423687f, -0.02911969f, -0.29287273f, 0.00373041f, -0.02535813f, 0.02566243f, -0.16698472f, -0.35148147f, 
    -0.34473646f, -0.19428627f, -0.05701290f, 0.13498797f, 0.13807052f, 0.08453180f, -0.01017636f, -0.71469855f, 
    0.14339253f, 0.06792504f, -0.15428641f, 0.10088366f, 0.27107590f, -0.00262413f, -0.14549091f, 0.01144775f, 
    -0.08789520f, -0.06869366f, -0.14619085f, 0.09853970f, -0.09510044f, -0.21695423f, -0.25947258f, -0.13725759f, 
    -0.09518345f, -0.09018975f, -0.05932596f, -0.03812886f, -0.04938967f, 0.12493135f, 0.01694542f, -0.06667987f, 
    0.00989305f, 0.15279543f, -0.27592039f, -0.24252474f, 0.60060567f, -0.00092148f, 0.03224646f, 0.14994457f, 
    -0.00014868f, 0.05556720f, -0.03282125f, 0.05798113f, 0.37318531f, -0.01527913f, 0.03181357f, 0.04578172f, 
    0.11044623f, -0.06542437f, 0.01588462f, -0.09775398f, 0.02496406f, 0.00485562f, 0.07038727f, 0.05056265f, 
    -0.07938407f, 0.04347217f, -0.11451026f, 0.00863604f, -0.12068629f, -0.05564635f, -0.12570925f, -0.12933448f, 
    0.03530721f, -0.01468289f, -0.19462843f, -0.22223420f, -0.16339274f, -0.15196545f, -0.00659942f, -0.33459443f, 
    -0.12079486f, 0.01206997f, 0.01321889f, -0.06856698f, 0.15188639f, -0.04926147f, -0.05981667f, 0.22217879f, 
    0.14066732f, -0.09184748f, -0.00849646f, -0.05055469f, 0.05336675f, 0.09888419f, 0.11068140f, 0.11404773f, 
    0.21997528f, 0.28278208f, 0.29869974f, -0.07183497f, 0.04917543f, 0.15915264f, 0.05194091f, 0.01630225f, 
    0.11809897f, -0.04628273f, -0.12363318f, 0.11265527f, 0.08359354f, 0.03403888f, -0.03269093f, 0.01994157f, 
    -0.19134256f, -0.24676484f, 0.01036051f, -0.28399310f, -0.07737200f, 0.13066459f, 0.06238129f, 0.08764278f, 
    0.10843029f, 0.08137909f, 0.03076895f, 0.30875397f, 0.37438944f, -0.14890249f, 0.11199398f, 0.05505945f, 
    -0.00182379f, 0.11602679f, -0.17470871f, -0.40246257f, 0.05548203f, -0.28684318f, -0.17555745f, -0.10082847f, 
    -0.05157854f, -0.15673381f, -0.13521187f, -0.03385275f, -0.15080313f, 0.03046128f, 0.42579645f, -0.05832038f, 
    0.06512671f, 0.01871381f, 0.06718884f, -0.10320175f, 0.03334405f, -0.23710731f, -0.09254521f, 0.19687270f, 
    -0.12161677f, 0.01651006f, 0.26961157f, 0.02231076f, 0.02641988f, -0.02018372f, 0.01935789f, 0.07398427f, 
    0.09486227f, -0.20487025f, 0.10644797f, 0.10410400f, -0.26201573f, 0.04887033f, 0.07593841f, 0.03221781f, 
    0.02864627f, 0.58814353f, 0.13516776f, 0.05657679f, 0.11068124f, 0.08461672f, -0.02011794f, -0.04048621f, 
    -0.03518409f, 0.03287404f, -0.08753133f, 0.08417774f, 0.06901769f, -0.06401855f, -0.14876632f, -0.09805180f, 
    -0.13800320f, -0.03833004f, 0.25623980f, 0.45933330f, 0.35856858f, -0.05378738f, 0.06447031f, 0.03967640f, 
    0.02496261f, -0.00744277f, 0.00163460f, -0.02501425f, -0.29342204f, -0.46707621f, 0.06341314f, -0.02836672f, 
    0.02447831f, 0.04293358f, 0.12957306f, 0.22645505f, -0.05157032f, -0.10604041f, -0.01997327f, 0.04390083f, 
    0.03491042f, 0.07818744f, -0.46210805f, 0.27135801f, 0.06358564f, -0.22441551f, -0.27024782f, -0.10687307f, 
    0.00664788f, 0.01700895f, 0.04582250f, 0.12565990f, 0.06361445f, 0.03125160f, 0.12035540f, 0.35356662f, 
    0.13281724f, 0.12895551f, 0.05953271f, 0.04001300f, 0.22716367f, 0.06407467f, -0.30454957f, -0.08235499f, 
    -0.16520801f, 0.05719065f, 0.05687598f, 0.14414465f, 0.12413792f, -0.05501208f, -0.02377593f, -0.23150022f, 
    -0.40990713f, -0.34057063f, 0.00455861f, 0.05437152f, -0.17158900f, 0.08471373f, -0.14858271f, 0.11058202f, 
    -0.06119516f, 0.02993393f, 0.06765444f, 0.25300601f, 0.13270271f, -0.09372744f, -0.01633259f, -0.11163130f, 
    -0.19528091f, -0.01380307f, 0.11539776f, -0.17658137f, 0.04210781f, 0.14218131f, 0.03537676f, 0.04981203f, 
    0.04898991f, -0.13056745f, -0.10237359f, 0.21558882f, 0.23756525f, 0.15820152f, 0.05367727f, -0.03712684f, 
    0.12061538f, 0.03448847f, 0.16795082f, -0.00601679f, 0.14476305f, -0.09823221f, -0.22654536f, 0.09947038f, 
    0.01332151f, -0.09710236f, -0.04723094f, -0.23621415f, -0.23792286f, 0.04467822f, 0.05915017f, -0.11820013f, 
    0.06224452f, -0.02356325f, -0.00821987f, -0.05089677f, 0.03381922f, 0.05481452f, 0.04102221f, -0.03577190f, 
    0.15586281f, -0.15398806f, -0.18013020f, 0.06083815f, 0.11828525f, 0.08849242f, 0.12430686f, 0.10946691f, 
    -0.01172203f, -0.26077348f, 0.06476870f, 0.18601730f, -0.04926819f, -0.03048481f, -0.03007941f, 0.15829965f, 
    -0.03454607f, -0.01548463f, 0.00362724f, 0.01448810f, 0.00399337f, 0.04611924f, -0.03385236f, -0.01777542f, 
    -0.06056310f, -0.05072055f, 0.02820447f, -0.04627685f, -0.05130997f, 0.04493282f, -0.04293054f, 0.04573824f, 
    -0.01429380f, -0.04726477f, 0.04218687f, -0.00962239f, -0.01389850f, 0.01809333f, -0.05267456f, 0.04369717f, 
    -0.02837782f, 0.01474989f, 0.03227218f, 0.00594641f, -0.05010461f, -0.04156293f, 0.04493436f, 0.00675304f, 
    -0.02630681f, -0.05312648f, 0.04397188f, -0.04750265f, -0.02998253f, -0.01750072f, -0.03739099f, -0.00203515f, 
    0.05002850f, -0.02714961f, -0.02113106f, -0.01372476f, 0.04884482f, -0.00109029f, -0.06196159f, 0.02876741f, 
    -0.00811198f, -0.01792470f, 0.01609148f, 0.00207952f, -0.04518283f, 0.02339813f, 0.00753991f, 0.03275316f, 
    -0.05837581f, -0.02940909f, -0.02538664f, -0.02210998f, 0.02184003f, 0.00298935f, 0.02813061f, 0.02307425f, 
    -0.00732626f, 0.03259296f, 0.00510954f, 0.04114832f, -0.05449913f, -0.06157620f, 0.03472294f, 0.01398392f, 
    0.03895862f, -0.04034204f, -0.05467697f, -0.02511039f, -0.01285926f, 0.04276844f, -0.02804575f, 0.03469898f, 
    0.03312438f, -0.05639020f, -0.05572779f, 0.00411677f, -0.03881292f, 0.04494612f, -0.01635809f, -0.05605951f, 
    0.02308742f, -0.03756727f, 0.04085160f, -0.03084442f, 0.01355098f, 0.04760805f, -0.00979987f, 0.02892319f, 
    -0.00210197f, -0.03082351f, -0.02015803f, -0.05716388f, 0.02801492f, 0.05040118f, -0.00723061f, -0.04251819f, 
    0.01508882f, 0.03761076f, -0.06655758f, -0.01086822f, -0.00128754f, -0.02609278f, 0.03762821f, -0.04960058f, 
    0.01217583f, 0.00685632f, 0.00522973f, -0.04134866f, 0.02640116f, -0.03411595f, -0.02558844f, -0.04476906f, 
    0.01877248f, -0.03851902f, -0.04560962f, 0.02213921f, -0.00054113f, 0.02418781f, -0.04748921f, -0.03945101f, 
    -0.04067880f, 0.01449184f, 0.03157115f, -0.05403586f, -0.06266690f, -0.02584970f, -0.06042093f, 0.01320175f, 
    -0.02421205f, -0.00304765f, -0.00352614f, 0.00170827f, 0.04658892f, 0.04532981f, -0.03405377f, -0.01102461f, 
    0.04179015f, -0.06786169f, 0.03914492f, 0.02524531f, -0.00244874f, 0.04878088f, -0.00103027f, 0.00076352f, 
    0.03821567f, -0.04940943f, -0.05427682f, 0.05354226f, -0.04153915f, 0.00877983f, -0.00059354f, 0.05284901f, 
    0.01311269f, 0.04008320f, -0.02225721f, 0.03039600f, -0.05772801f, 0.00602543f, 0.03187264f, -0.03264331f, 
    -0.05781602f, 0.02135769f, 0.03651781f, 0.05254238f, -0.05681197f, 0.03300559f, -0.00282820f, -0.04207439f, 
    -0.04995357f, -0.05222721f, 0.01345478f, -0.05794074f, 0.02854974f, 0.00915516f, -0.05026381f, 0.00262090f, 
    -0.03270611f, -0.02503354f, -0.03328490f, -0.05328051f, -0.06277508f, -0.04820655f, -0.00247236f, -0.01815834f, 
    0.03660597f, 0.06283338f, 0.04136583f, 0.01693185f, -0.01194273f, -0.01602436f, 0.01022931f, 0.00751275f, 
    0.03210986f, -0.00640124f, 0.01674636f, 0.01780345f, 0.05829369f, -0.02274812f, -0.03007657f, 0.01288378f, 
    0.00630252f, -0.05548640f, -0.05780656f, -0.06315591f, 0.01686564f, -0.02559894f, -0.02779448f, -0.03938008f, 
    0.01190095f, 0.05338543f, -0.02469161f, -0.04740468f, -0.03063370f, 0.00736995f, -0.01488078f, 0.04986167f, 
    -0.05769572f, -0.02634733f, -0.06048874f, -0.04798184f, -0.06295388f, 0.00325223f, 0.02741745f, -0.01699116f, 
    0.04397103f, 0.03521181f, -0.06449784f, 0.00566359f, -0.05424339f, 0.03892323f, 0.00231081f, 0.00636670f, 
    -0.03221499f, -0.05234259f, -0.05037411f, -0.00352195f, 0.03572265f, 0.05144319f, 0.00440403f, -0.02753537f, 
    0.00650822f, -0.02325753f, 0.02812439f, 0.04890068f, 0.01208757f, -0.02342803f, -0.03655490f, -0.05395973f, 
    0.01662469f, -0.03304694f, 0.02843283f, 0.01313347f, -0.02182166f, 0.01188060f, -0.00727546f, 0.03162114f, 
    0.02457412f, 0.04647075f, -0.05111433f, 0.00430724f, 0.00085773f, -0.05647464f, -0.02951911f, 0.02811939f, 
    -0.01614157f, -0.00023951f, -0.03889456f, -0.02256307f, -0.00546780f, -0.03221719f, 0.00774018f, 0.01209036f, 
    -0.04082352f, -0.03164269f, 0.04672969f, -0.05463138f, 0.02280148f, 0.03757550f, 0.00324959f, 0.01401331f, 
    -0.05619552f, 0.09405380f, 0.01903166f, -0.02356021f, 0.23781581f, -0.01069982f, -0.08666051f, -0.05752683f, 
    -0.29507500f, 0.16812809f, 0.12844013f, -0.07983387f, 0.02610482f, 0.01890290f, -0.20431736f, -0.03657374f, 
    -0.02547766f, -0.02190275f, 0.33406493f, 0.08159724f, -0.15853453f, 0.10693824f, 0.06208753f, 0.10767663f, 
    0.14834313f, -0.25401041f, 0.08204915f, -0.02425796f, -0.48450285f, -0.24693704f, -0.09527642f, -0.03840358f, 
    0.10984130f, -0.01739580f, -0.02570881f, 0.14103289f, -0.41432235f, 0.24989276f, 0.57239681f, -0.17601508f, 
    -0.24827188f, 0.05596429f, -0.06746455f, 0.21690539f, -0.02874105f, -0.10129338f, 0.23350750f, 0.18877122f, 
    -0.03150350f, 0.19304368f, -0.06359684f, -0.09705310f, 0.20364507f, -0.27913350f, -0.07716226f, -0.53720737f, 
    -0.14865731f, -0.02085782f, -0.31204766f, 0.01470820f, 0.02518915f, -0.20315218f, -0.09141339f, -0.33690739f, 
    -0.30208647f, -0.28428915f, -0.08101177f, 0.10973674f, 0.03012612f, 0.05495060f, -0.11880801f, 0.04444669f, 
    0.28008080f, -0.01822218f, 0.09518564f, -0.02832212f, -0.24176441f, 0.16575421f, -0.29431471f, -0.06230688f, 
    0.00421861f, 0.00763930f, 0.07937228f, 0.15820211f, -0.02304911f, 0.09196306f, -0.05248401f, 0.15068826f, 
    0.14951079f, -0.22052865f, 0.33030823f, 0.41156527f, 0.37486345f, -0.02120855f, 0.05477953f, -0.05377007f, 
    0.00924067f, -0.13173914f, -0.07312492f, 0.41526112f, -0.23096247f, -0.05012069f, -0.11673654f, -0.60827929f, 
    0.03796395f, 0.04709659f, -0.04719199f, -0.04648767f, -0.07281988f, -0.11900541f, 0.25172555f, -0.02102809f, 
    0.17532247f, -0.21253940f, -0.06426113f, 0.23864549f, 0.00041853f, 0.18754166f, 0.13945875f, 0.09895983f, 
    -0.11899256f, -0.16301468f, 0.03446168f, 0.04908036f, 0.09400389f, -0.04410348f, 0.24637988f, -0.16166398f, 
    -0.14349906f, -0.06767813f, 0.17770152f, 0.29951021f, -0.04164117f, -0.09436686f, 0.02599490f, -0.21417733f, 
    -0.04169163f, -0.13692142f, 0.10619900f, 0.08157932f, -0.08238969f, 0.16427831f, -0.14915928f, 0.11716592f, 
    0.16232203f, -0.21872324f, -0.09086151f, 0.01111084f, 0.03314606f, 0.09431773f, -0.05934254f, 0.02516213f, 
    -0.03468242f, -0.10647986f, 0.09223823f, 0.07180345f, -0.09967509f, -0.09517635f, -0.07989174f, 0.21748887f, 
    -0.05858681f, -0.19695251f, 0.02728177f, -0.26526493f, -0.05451196f, -0.21898770f, -0.08930670f, 0.12916908f, 
    -0.14709511f, 0.07477394f, 0.03377109f, -0.32920480f, 0.03728389f, 0.00916812f, -0.23784842f, -0.11511793f, 
    0.09088758f, -0.04094923f, 0.15642214f, -0.13899218f, 0.14653780f, 0.13336267f, 0.06712582f, -0.05585085f, 
    0.18916640f, 0.06025890f, 0.01810992f, 0.11553808f, 0.12328712f, 0.17064966f, 0.30059651f, 0.00772512f, 
    0.12583846f, 0.00169359f, 0.14611308f, 0.16292822f, 0.18192373f, -0.08508956f, 0.31335425f, -0.39543042f, 
    -0.05753601f, -0.04240246f, -0.09373701f, 0.05820375f, -0.05046650f, 0.00471639f, -0.01111746f, -0.03395131f, 
    0.32656994f, 0.25487533f, 0.14122722f, 0.06781869f, -0.03904245f, 0.12572345f, 0.12789774f, 0.22755532f, 
    0.36852375f, 0.14974265f, -0.28183216f, -0.04893653f, -0.03683627f, -0.01013889f, -0.02089964f, 0.08577553f, 
    -0.23526213f, 0.36750820f, -0.06196035f, -0.19918241f, -0.06571381f, 0.26285157f, 0.06705501f, 0.14536825f, 
    0.05933880f, 0.29753965f, -0.18318093f, 0.16363733f, 0.12713549f, -0.06968979f, 0.05466149f, -0.01800390f, 
    0.21969897f, -0.05895342f, -0.14024296f, -0.01218159f, -0.29225054f, -0.17557757f, -0.16883960f, -0.23480897f, 
    0.05026743f, -0.07919598f, -0.14487985f, 0.01096579f, 0.26447999f, -0.28202549f, -0.34925744f, -0.12312515f, 
    -0.05969618f, 0.01943975f, 0.07243030f, -0.06171296f, 0.00128419f, -0.14156690f, -0.17006895f, -0.04449314f, 
    -0.00368162f, 0.15392412f, -0.01383847f, 0.00203700f, -0.10953851f, -0.22835794f, -0.25099578f, -0.21636134f, 
    -0.08804120f, -0.12970704f, 0.00609801f, -0.04170083f, 0.19919534f, -0.07546879f, -0.00058582f, -0.13099004f, 
    -0.15411842f, -0.20302905f, -0.01291511f, 0.15769060f, -0.11929750f, 0.22654510f, -0.05629894f, 0.02082784f, 
    -0.07006147f, 0.01530262f, 0.22735679f, 0.09127977f, 0.01151115f, -0.10169328f, -0.05589050f, 0.05118227f, 
    0.10947882f, 0.09171993f, -0.11721919f, -0.10727995f, -0.11637967f, -0.09762368f, 0.17288329f, -0.12225873f, 
    -0.05523988f, 0.06886562f, -0.35860199f, -0.08319285f, 0.14169250f, 0.04755618f, -0.26782140f, 0.14439027f, 
    -0.09901799f, 0.09283134f, 0.19151232f, 0.40276405f, -0.06403989f, -0.09046548f, -0.03846771f, 0.03347590f, 
    0.05190716f, 0.06830046f, 0.00499175f, 0.00140485f, -0.13646370f, -0.06308480f, 0.01484904f, -0.01830265f, 
    0.03105494f, -0.10023328f, -0.02327458f, -0.40805805f, 0.01610445f, 0.07063226f, -0.01611561f, 0.18591918f, 
    0.07094043f, -0.08274814f, -0.13592149f, -0.04310726f, 0.00380436f, 0.08028035f, 0.12523134f, 0.30255920f, 
    0.12672345f, -0.18477547f, 0.16147158f, -0.27610514f, 0.19633438f, 0.13478331f, -0.20024627f, -0.34940815f, 
    0.13853125f, -0.13039197f, -0.09131553f, 0.04680125f, 0.03787027f, -0.13128406f, -0.02861988f, -0.03978792f, 
    0.23305103f, 0.15659755f, 0.05033680f, 0.03597927f, 0.05536263f, 0.04106961f, 0.09105162f, 0.14153269f, 
    -0.01523366f, -0.11799832f, 0.02028801f, 0.16615428f, 0.11360353f, 0.02743574f, -0.26104200f, 0.11678589f, 
    0.11222988f, 0.14791329f, -0.20243403f, -0.10278140f, -0.02680894f, -0.02556946f, -0.05579361f, 0.03317908f, 
    -0.01507055f, -0.05489560f, -0.00782532f, 0.66104484f, 0.40158069f, -0.23556985f, -0.07587925f, -0.01310862f, 
    -0.05494367f, -0.18759772f, -0.24543573f, 0.01870309f, -0.24246618f, -0.01973066f, 0.22565734f, -0.13426560f, 
    -0.01266591f, 0.12163706f, 0.11076305f, 0.18997763f, 0.09203842f, -0.06147651f, 0.08611923f, -0.68098235f, 
    -0.01400519f, -0.03103293f, -0.02735304f, 0.03705914f, 0.04341345f, 0.19510593f, -0.05248903f, 0.01021791f, 
    -0.01138420f, 0.06499409f, -0.10080598f, 0.10963616f, -0.03995348f, 0.12333604f, -0.08955353f, 0.06778540f, 
    0.07878172f, -0.14553933f, -0.13421483f, -0.04630159f, -0.00918453f, -0.06454615f, 0.04212461f, 0.02170883f, 
    0.09068879f, -0.00368906f, -0.26826081f, -0.18884605f, -0.01331381f, -0.11466878f, 0.02626915f, 0.13529912f, 
    0.00375557f, 0.08472785f, 0.07067170f, 0.16468135f, 0.04473266f, -0.01866893f, -0.26844159f, -0.11277542f, 
    -0.07130055f, -0.04974449f, 0.13503267f, 0.18598357f, -0.18959722f, -0.23835501f, -0.00598124f, 0.00714336f, 
    0.09762518f, -0.04251597f, 0.03970749f, -0.05126199f, -0.41171274f, 0.05384783f, -0.10141780f, 0.10951326f, 
    0.19071041f, -0.04568682f, -0.06404071f, -0.07092375f, -0.04548847f, 0.08927487f, 0.19859402f, 0.15813853f, 
    -0.12779367f, 0.07407787f, -0.09566217f, 0.06013602f, 0.23441140f, 0.10585143f, 0.01152509f, 0.18467112f, 
    0.12646042f, 0.15151657f, 0.09214130f, 0.01858428f, 0.11285178f, 0.07981255f, 0.46374187f, 0.43021789f, 
    0.10765579f, 0.00545331f, 0.20683308f, -0.26068619f, -0.16545679f, -0.05135857f, -0.22603995f, -0.03998297f, 
    0.11676337f, 0.14435746f, -0.10007891f, -0.05653827f, -0.01645390f, -0.05237835f, 0.22085528f, 0.09767249f, 
    -0.11821762f, -0.09253985f, 0.14343686f, 0.04163374f, 0.18203798f, -0.07078674f, 0.03546420f, 0.10848766f, 
    -0.00273267f, 0.02268412f, 0.22151814f, -0.04643074f, 0.02690328f, 0.03873009f, 0.18629505f, -0.06985296f, 
    0.05884732f, -0.05353728f, -0.00742490f, 0.05060176f, 0.09610239f, -0.09822645f, 0.00449756f, -0.17662045f, 
    0.19374299f, 0.10807847f, 0.03233815f, 0.22261685f, 0.27561158f, -0.04317021f, -0.08939277f, -0.01039746f, 
    -0.00153196f, 0.12363295f, 0.04660504f, -0.12853152f, 0.07094709f, 0.26860243f, -0.04239751f, -0.12481877f, 
    0.04722437f, -0.02798691f, 0.13738322f, 0.02899404f, -0.23594023f, -0.05071491f, 0.00059206f, 0.11249202f, 
    -0.19420581f, -0.15394522f, 0.10520501f, -0.16844477f, -0.17019874f, -0.20879512f, -0.09390080f, 0.14054163f, 
    -0.02284154f, -0.33957985f, -0.17094997f, 0.02865035f, -0.03477358f, -0.05175995f, 0.05658932f, 0.09186157f, 
    0.00722905f, -0.25106996f, -0.17671208f, -0.07353599f, -0.07479012f, -0.08310528f, -0.01609970f, 0.02841502f, 
    0.27334175f, 0.13225324f, 0.19690843f, -0.35963404f, -0.05381218f, -0.02075544f, -0.00658261f, 0.02280441f, 
    0.10623293f, 0.15439302f, 0.09934716f, 0.43993521f, -0.06250308f, 0.06388695f, 0.18822840f, -0.02713218f, 
    -0.17552440f, -0.01736242f, 0.03950458f, -0.29349047f, 0.01563372f, -0.02873196f, 0.09258673f, 0.33355001f, 
    -0.28837985f, -0.03379453f, 0.23264048f, -0.30561116f, -0.03974227f, 0.63763291f, 0.08001436f, -0.10099484f, 
    -0.03195607f, -0.08024726f, -0.02949289f, -0.18213534f, -0.03242406f, 0.04643809f, 0.18895777f, 0.14534014f, 
    -0.02815046f, 0.04433471f, 0.10180483f, -0.06565765f, 0.21851073f, 0.23580119f, 0.09389718f, -0.03822967f, 
    0.11090004f, -0.05906003f, -0.05766862f, 0.14468636f, 0.09327459f, -0.10924885f, 0.12393007f, 0.26262894f, 
    0.16545677f, -0.25260055f, -0.02600907f, -0.12411633f, -0.28571445f, -0.06356245f, 0.18057382f, 0.21860473f, 
    -0.41329801f, -0.08173648f, 0.20546161f, -0.23499510f, 0.04346674f, 0.12388454f, 0.07749558f, -0.17195232f, 
    0.25535527f, -0.01429729f, 0.02169573f, -0.07453854f, -0.12064712f, 0.06850377f, -0.01624637f, -0.06872177f, 
    -0.15912201f, 0.19544131f, 0.11227024f, -0.08974731f, -0.01443475f, -0.04035190f, -0.21764921f, -0.08107132f, 
    0.04233383f, -0.08331595f, -0.06587573f, 0.00682846f, 0.04665371f, 0.19963695f, 0.00229955f, -0.05384327f, 
    0.36920297f, 0.26293781f, -0.01700273f, -0.30099452f, 0.17187640f, 0.46798357f, 0.03101803f, 0.05739488f, 
    0.00840429f, 0.07423647f, 0.25551903f, 0.17262401f, 0.20104636f, 0.00006802f, 0.12275820f, -0.20719154f, 
    0.07699675f, 0.06665556f, -0.14660937f, 0.10234708f, -0.03409423f, -0.32623792f, -0.25924900f, 0.15520173f, 
    -0.01477504f, -0.10655412f, -0.10098068f, 0.03824632f, 0.03614364f, -0.06761784f, 0.46360874f, -0.28236145f, 
    -0.29438394f, 0.05234550f, -0.12110264f, 0.08323539f, -0.02021307f, -0.18844676f, 0.16084483f, 0.02536174f, 
    -0.17389336f, 0.15142944f, 0.02727553f, -0.06370335f, 0.05166377f, 0.08812536f, -0.01189370f, -0.02843255f, 
    -0.49309996f, 0.47855282f, -0.34502253f, 0.16828170f, -0.09522805f, 0.06966180f, -0.05843198f, -0.00941319f, 
    0.04012455f, 0.19858654f, 0.18561038f, 0.06616527f, 0.12784298f, -0.11441663f, 0.04321619f, 0.08776185f, 
    -0.04734718f, -0.06460276f, -0.10018457f, -0.26701063f, -0.14557637f, -0.09705143f, -0.02218469f, 0.01355389f, 
    0.05312727f, -0.05915482f, -0.03527667f, 0.42203674f, 0.47117096f, 0.04739583f, 0.21990214f, -0.19661680f, 
    0.16303724f, 0.01040115f, 0.13919733f, 0.10036978f, 0.00336802f, 0.04456621f, 0.24504316f, 0.07549520f, 
    -0.05646954f, 0.03663466f, -0.02826001f, 0.08347325f, -0.04743091f, 0.23727523f, 0.26223427f, 0.10292566f, 
    0.17026988f, 0.07160083f, -0.03514573f, 0.16094342f, 0.06867794f, -0.01988486f, -0.09474004f, -0.13079546f, 
    -0.25878376f, -0.08923774f, 0.08948708f, 0.05402958f, -0.03416651f, 0.02613166f, 0.14765312f, 0.10294035f, 
    0.10599689f, 0.09376165f, 0.10543071f, 0.03546776f, 0.01806918f, 0.13413836f, -0.19750518f, -0.15318228f, 
    0.33237264f, 0.17894877f, -0.12286879f, 0.00156439f, 0.08204396f, 0.12486940f, -0.14841777f, 0.09140481f, 
    -0.02115239f, -0.44858557f, -0.38045806f, 0.20589997f, -0.18321942f, 0.24970901f, -0.27614349f, 0.14592800f, 
    -0.03367880f, -0.02868152f, 0.16429210f, 0.01301058f, 0.21416572f, -0.06557650f, 0.07691620f, -0.11955898f, 
    -0.12029394f, -0.06519639f, 0.37377575f, 0.21089241f, 0.29961416f, 0.79251605f, 0.02205812f, -0.16012017f, 
    -0.08964475f, -0.17682534f, -0.03470055f, -0.02667348f, 0.01665239f, -0.04758128f, -0.16018574f, -0.20083191f, 
    -0.08299307f, -0.06119282f, -0.31732488f, -0.09866955f, -0.24280070f, 0.20147860f, -0.04381781f, -0.00375505f, 
    0.01055068f, -0.28218707f, 0.06650516f, 0.10229088f, 0.06636634f, 0.03650340f, 0.21521483f, 0.00814039f, 
    -0.09885821f, 0.19841231f, -0.18072599f, -0.03532394f, 0.09682146f, 0.09883653f, -0.11010674f, -0.07617342f, 
    -0.23098496f, 0.01657079f, 0.00415455f, -0.17588688f, -0.13183713f, 0.00768243f, 0.14557883f, -0.13648231f, 
    0.08175281f, 0.22539362f, 0.30583414f, -0.00328392f, -0.06791446f, -0.02500663f, -0.02244608f, -0.01041431f, 
    0.39164966f, 0.38279638f, 0.09053154f, -0.24229689f, 0.12059146f, 0.13826971f, 0.15400559f, -0.20595281f, 
    -0.06368744f, -0.18658727f, -0.92645407f, 0.07400759f, -0.03447831f, 0.25688991f, 0.13112117f, 0.10243151f, 
    0.17506599f, 0.05183384f, 0.01009411f, -0.31118259f, -0.28749356f, -0.65841216f, -0.21948700f, 0.00132009f, 
    0.08990831f, 0.11044545f, 0.00842334f, 0.08573397f, 0.03245993f, -0.35301542f, -0.15637369f, 0.03023218f, 
    -0.00195046f, 0.15194131f, 0.06347807f, 0.00833037f, 0.02154867f, -0.04509434f, 0.08979248f, 0.25308079f, 
    -0.10901014f, -0.02489953f, 0.06260239f, 0.03677458f, -0.03389938f, 0.15885650f, 0.21531808f, -0.35028997f, 
    -0.43677869f, -0.07065032f, -0.13579997f, 0.09096175f, 0.09433769f, 0.10892650f, 0.07497737f, -0.15115665f, 
    0.21624169f, 0.49585426f, 0.11345585f, 0.07024458f, -0.16466096f, -0.00341497f, -0.01759222f, 0.02553454f, 
    0.07736647f, -0.37984091f, -0.58005220f, -0.37782219f, -0.01746159f, -0.10680254f, -0.14081921f, -0.16467500f, 
    -0.00185397f, -0.13645479f, 0.23156454f, 0.29138950f, -0.15582976f, -0.08199688f, -0.00693844f, 0.17101750f, 
    0.17794983f, 0.12887207f, -0.24585655f, -0.34705678f, -0.44553769f, -0.08540615f, -0.07699275f, 0.02713836f, 
    -0.08746827f, -0.08705734f, -0.02818482f, 0.09788593f, -0.67305297f, -0.44284570f, -0.17791112f, -0.06482673f, 
    -0.02966844f, 0.14025615f, 0.01255472f, 0.26213297f, 0.06654872f, 0.04355638f, 0.39824665f, 0.08516722f, 
    0.11046181f, 0.14052869f, 0.23153327f, -0.04009616f, 0.25702867f, -0.06922770f, -0.79353142f, -0.78215349f, 
    0.07784112f, -0.08433547f, 0.10669551f, 0.15341020f, -0.05094838f, 0.09895611f, -0.09247732f, -0.27431974f, 
    0.41161641f, 0.21148835f, 0.18421616f, -0.10210957f, 0.20617238f, 0.05461182f, 0.04089517f, 0.24962854f, 
    0.26186123f, 0.37439573f, 0.10942739f, -0.00348386f, 0.10291845f, 0.04816314f, -0.15174191f, -0.07771484f, 
    0.02340693f, 0.16689155f, -0.51899451f, -0.06880959f, -0.45548555f, -0.00210201f, 0.04957727f, -0.11911274f, 
    0.00184823f, -0.16881233f, -0.14202853f, -0.10668454f, -0.07911418f, -0.00771780f, -0.13793170f, 0.09721879f, 
    0.03322084f, 0.04783580f, -0.02220637f, 0.07461555f, -0.24136786f, -0.10192988f, -0.05478078f, 0.06017746f, 
    -0.05855277f, -0.07675172f, -0.11817529f, 0.34591767f, -0.28811720f, -0.38939726f, 0.05668723f, 0.00032377f, 
    0.17296498f, 0.06729297f, -0.02389383f, -0.20238970f, -0.01362571f, 0.14547311f, -0.09790563f, 0.12493346f, 
    0.14359978f, 0.05260228f, -0.00606671f, 0.00570719f, 0.03662981f, 0.16958286f, -0.15225571f, 0.04546266f, 
    0.08202852f, 0.15077583f, 0.08366879f, 0.00244183f, 0.01389832f, -0.14716290f, 0.51520038f, -0.26547524f, 
    -0.31597480f, -0.14491014f, 0.08699737f, -0.06926198f, 0.13864692f, 0.13820969f, 0.15871944f, 0.01771251f, 
    -0.09400927f, 0.23478241f, 0.12374663f, 0.08565078f, -0.15289524f, 0.29625854f, 0.15658772f, 0.05084238f, 
    -0.46466884f, -0.50393498f, 0.07022360f, -0.00551820f, -0.03005528f, -0.17114855f, 0.21559624f, -0.02276611f, 
    0.05687208f, -0.50519085f, 0.13923396f, -0.01537427f, 0.24335241f, 0.31400940f, 0.19974004f, 0.15882653f, 
    0.07834874f, 0.29792029f, 0.19070983f, -0.08022433f, 0.08998269f, -0.02808382f, -0.03757865f, 0.01307917f, 
    0.22105405f, 0.07679163f, 0.20105898f, -0.67723197f, -0.27990320f, -0.41895971f, -0.19942845f, -0.03122119f, 
    0.09322187f, -0.16214882f, -0.27607614f, 0.00875140f, 0.10128390f, 0.27664429f, -0.09399548f, 0.03132025f, 
    0.15752999f, -0.07144405f, 0.05410458f, 0.20529136f, 0.30813020f, -0.15541379f, 0.24378935f, 0.07995325f, 
    -0.11019067f, -0.16059013f, -0.00357618f, 0.13647288f, -0.19799179f, -0.15718770f, -0.45347291f, -0.11282001f, 
    -0.09669671f, -0.18774043f, -0.03424660f, -0.15471780f, 0.23728085f, -0.06306823f, -0.17984252f, 0.28611302f, 
    0.11422341f, 0.30575404f, 0.03926644f, -0.14910662f, -0.12541534f, 0.06102836f, 0.00769561f, 0.02476236f, 
    0.03956184f, -0.00718030f, -0.09731852f, 0.09175729f, 0.35268858f, 0.14422044f, -0.07475547f, 0.01916506f, 
    -0.03096597f, -0.11077186f, 0.01541121f, 0.01118626f, -0.06393279f, -0.09310298f, -0.11653454f, 0.24341168f, 
    0.13574007f, 0.14385222f, 0.01526736f, -0.15822139f, 0.25694191f, -0.06566165f, 0.24935058f, -0.05842550f, 
    0.34023175f, 0.02136141f, 0.18409836f, -0.10288078f, 0.14438707f, 0.12767866f, 0.15327395f, -0.05987233f, 
    -0.02764616f, 0.00452217f, 0.07675023f, 0.14388974f, -0.06813362f, -0.09536196f, -0.06234353f, 0.09798767f, 
    -0.02670608f, 0.06236447f, 0.06173828f, -0.20758614f, -0.19976906f, -0.07139134f, -0.04069741f, -0.10731646f, 
    0.07654110f, 0.14983386f, 0.03630789f, -0.07441700f, 0.14771700f, 0.02397877f, 0.13989823f, -0.09798356f, 
    0.07024384f, -0.05981152f, -0.03947662f, 0.12800986f, -0.25667477f, -0.26914218f, -0.01226576f, 0.13507883f, 
    -0.06865209f, -0.00378421f, -0.12072215f, -0.00281344f, -0.13833149f, 0.05357999f, 0.08473744f, 0.17756861f, 
    -0.05879884f, -0.38993606f, 0.04080012f, 0.11732081f, -0.22258787f, -0.08851855f, 0.18116339f, -0.01951652f, 
    0.18469465f, 0.07765430f, -0.05310528f, -0.04969869f, -0.03793509f, 0.00328259f, 0.03649956f, -0.05675772f, 
    0.12994209f, -0.40425256f, -0.18076280f, -0.11999582f, -0.18373258f, -0.03697834f, -0.05009716f, -0.08486079f, 
    -0.27451244f, 0.06566570f, -0.02702140f, -0.28735662f, -0.15660864f, 0.03146940f, 0.15727064f, -0.15562588f, 
    -0.16577952f, 0.06467682f, -0.28481257f, -0.08954322f, 0.18259940f, 0.13507921f, -0.23174760f, 0.06527314f, 
    0.10139074f, 0.23189425f, 0.27710176f, 0.12141624f, -0.07430411f, -0.15625438f, 0.15690684f, 0.07837629f, 
    0.13863535f, -0.07186207f, 0.04138008f, 0.11963942f, 0.08352800f, 0.02672678f, 0.11545277f, 0.02543801f, 
    0.02441061f, -0.00605341f, 0.00914869f, 0.04492129f, 0.09043046f, -0.12655368f, 0.14923304f, -0.03767556f, 
    -0.18188173f, 0.11891030f, 0.07447378f, 0.06548825f, -0.19243178f, 0.20299515f, 0.27279836f, 0.16876529f, 
    -0.01848987f, -0.53459752f, -0.13265796f, 0.07879423f, 0.15985340f, 0.07114581f, 0.19093712f, 0.26820940f, 
    0.05428259f, -0.11631972f, -0.21151148f, -0.16937134f, 0.16259547f, 0.00760026f, 0.01819491f, 0.03252498f, 
    -0.02440794f, 0.15394360f, 0.06549045f, -0.16995847f, -0.04365504f, -0.03021719f, -0.21149379f, -0.06933496f, 
    0.15581852f, 0.11994398f, 0.12462996f, -0.12554896f, 0.21741690f, -0.08017834f, 0.06884333f, 0.07590182f, 
    -0.16265151f, 0.23373468f, -0.03546949f, 0.12732559f, 0.06725906f, -0.00758874f, 0.09407335f, 0.22032353f, 
    0.14059240f, 0.15001662f, 0.04739087f, 0.30874953f, 0.25410113f, -0.19467832f, -0.05951298f, -0.09737353f, 
    -0.07657646f, -0.08178288f, -0.02793319f, 0.00246036f, 0.17578369f, 0.07742877f, -0.21016219f, -0.23846439f, 
    0.25799981f, -0.04411061f, -0.13880174f, -0.04644347f, 0.10289945f, -0.26228428f, -0.43149173f, 0.11414740f, 
    -0.19401278f, 0.01193146f, 0.02389634f, 0.14498156f, 0.14924692f, 0.06277110f, 0.20952506f, -0.00665481f, 
    0.05290179f, -0.12730470f, -0.27835292f, 0.24708000f, -0.15674354f, 0.19149032f, 0.03813349f, -0.12094895f, 
    0.11775133f, 0.24734129f, 0.05270330f, 0.09785204f, 0.03496250f, -0.11853193f, 0.34587425f, -0.20468557f, 
    -0.08863574f, 0.19267720f, -0.07290907f, -0.01248875f, -0.00526425f, 0.03668378f, 0.04715908f, 0.12564059f, 
    0.00015736f, -0.12231139f, -0.31061628f, -0.16832027f, -0.11584571f, -0.04904848f, 0.30027622f, -0.27304223f, 
    -0.26362860f, 0.03603310f, 0.03418643f, 0.14603588f, 0.04932486f, 0.17185786f, 0.05037269f, -0.16010019f, 
    -0.09591633f, 0.02376029f, -0.15699495f, -0.37269005f, -0.29431349f, -0.09996024f, -0.11462194f, -0.09868503f, 
    0.08971801f, 0.06662045f, 0.00121395f, 0.08136092f, 0.25806803f, 0.20432682f, 0.14203122f, -0.02016417f, 
    -0.10392925f, 0.08875357f, 0.13556392f, 0.00479413f, 0.08171853f, 0.22769164f, 0.24432747f, -0.07185917f, 
    0.03348402f, -0.05751514f, 0.04390541f, 0.20389083f, 0.15427725f, 0.01067857f, 0.12460338f, 0.28307843f, 
    -0.19141787f, 0.02164513f, -0.10541689f, 0.10788053f, -0.08671197f, 0.19366537f, 0.02315127f, 0.14406587f, 
    -0.11733695f, -0.11616518f, 0.07285965f, 0.04550452f, -0.01441387f, -0.08851285f, -0.07080448f, 0.03825244f, 
    0.10060582f, 0.05103592f, 0.48368740f, 0.16863996f, 0.07526360f, 0.10988267f, 0.01680975f, -0.11270142f, 
    0.12443629f, -0.11020960f, 0.13267574f, -0.11708439f, 0.17285196f, 0.50014788f, 0.06531104f, -0.00085820f, 
    -0.06055858f, 0.08555890f, 0.04247063f, 0.18246596f, 0.11991137f, -0.27087572f, -0.20042902f, 0.01972149f, 
    0.06795662f, 0.05864104f, -0.02557661f, 0.12801185f, 0.08827534f, -0.24135159f, -0.05131260f, -0.15620688f, 
    0.10660227f, 0.00532605f, -0.09397088f, 0.09707054f, 0.03627280f, 0.11512784f, -0.11823232f, 0.31242034f, 
    0.08273482f, 0.03747390f, -0.13971174f, -0.03879302f, -0.13649614f, 0.10539349f, -0.04266946f, -0.17181183f, 
    -0.14771029f, 0.30512884f, 0.12782867f, 0.20637669f, 0.08800030f, 0.18459752f, 0.19912888f, 0.14167325f, 
    -0.17271324f, 0.19702297f, 0.20882156f, 0.16881779f, -0.04450867f, -0.02237434f, 0.05160524f, 0.14051637f, 
    -0.01082037f, 0.10994139f, -0.00023241f, -0.18533468f, -0.14161004f, -0.00332785f, 0.06776411f, -0.07551442f, 
    0.11163316f, -0.02460555f, 0.21600702f, -0.19266197f, -0.31926867f, -0.16676442f, -0.03256688f, -0.13498865f, 
    -0.06481574f, -0.08097635f, -0.01991643f, -0.48507053f, -0.10507046f, 0.38285145f, 0.08554936f, -0.04416590f, 
    -0.07272254f, 0.03086441f, 0.05017153f, 0.16897842f, -0.12922277f, 0.29684839f, 0.28713232f, 0.23619492f, 
    0.04470051f, 0.07401644f, 0.24979109f, -0.13444117f, 0.05513938f, -0.03018457f, -0.20860891f, 0.54571956f, 
    0.08191286f, 0.01325613f, -0.01223044f, 0.08364709f, 0.11822386f, 0.01132185f, -0.04157258f, 0.16206904f, 
    0.51990575f, 0.06482188f, -0.07591537f, -0.12977068f, 0.22424211f, 0.03570703f, 0.12574720f, -0.18530254f, 
    0.12447880f, 0.33414042f, -0.02045187f, 0.01519242f, 0.06360033f, 0.04452224f, 0.08148232f, 0.05441871f, 
    0.13901435f, 0.05013578f, 0.34516820f, -0.07498969f, -0.10788697f, -0.01983144f, 0.10597512f, 0.12161704f, 
    0.06846654f, -0.31461540f, -0.19836870f, -0.33299899f, 0.02832656f, -0.08478412f, -0.18590021f, 0.15405223f, 
    0.13211043f, 0.04951732f, -0.08468559f, 0.22222458f, 0.53382659f, 0.14811943f, 0.02549516f, 0.08074341f, 
    0.08839435f, 0.00313366f, 0.09102335f, -0.30725014f, -0.15622628f, -0.06506357f, -0.03735928f, 0.07486977f, 
    -0.16064145f, 0.04340284f, -0.14856094f, 0.20568138f, 0.20494451f, 0.01604459f, -0.14669631f, 0.02076046f, 
    -0.11727700f, -0.03031210f, 0.10274962f, 0.05189635f, -0.12332465f, -0.16367914f, -0.20107971f, -0.15351167f, 
    -0.05586066f, -0.14054580f, -0.12177606f, -0.02576040f, 0.04883328f, -0.02120293f, -0.08159040f, -0.00808881f, 
    0.15159835f, 0.01716825f, -0.10969049f, -0.03146954f, 0.05785337f, 0.04018112f, 0.08175930f, -0.13426498f, 
    0.06299488f, -0.26491654f, -0.05047596f, 0.17020698f, -0.09005947f, 0.22800140f, 0.09465367f, 0.07478809f, 
    -0.22784933f, -0.17846446f, -0.02349547f, -0.19114478f, 0.03163754f, -0.33562288f, 0.03597586f, 0.05009547f, 
    0.02331650f, -0.02994575f, 0.02896383f, 0.12704715f, 0.28354484f, -0.00311109f, 0.03718092f, 0.04539056f, 
    0.02202085f, -0.00878803f, 0.08697318f, 0.28724334f, -0.02233131f, 0.04118143f, -0.18565284f, 0.19719230f, 
    -0.01352442f, 0.17020902f, 0.06203090f, -0.29608658f, -0.13312481f, 0.00038498f, 0.18366621f, -0.12382656f, 
    0.04406007f, 0.08829570f, 0.11287434f, 0.11665229f, -0.14703472f, 0.13155945f, 0.17154305f, 0.12149493f, 
    -0.04883555f, 0.06667177f, 0.15368724f, -0.02099723f, 0.19231252f, -0.26682255f, -0.30107144f, -0.18020831f, 
    0.01981471f, -0.01243035f, -0.15955375f, 0.10335439f, 0.09601393f, 0.06491440f, -0.26255697f, -0.15130818f, 
    -0.19801548f, 0.06274119f, 0.15218356f, -0.15373939f, -0.01014411f, 0.12411781f, 0.04337712f, -0.32926038f, 
    -0.16878672f, 0.06314276f, -0.02049587f, 0.16285624f, -0.10609528f, 0.14711308f, 0.07081042f, 0.13526650f, 
    -0.02278399f, -0.00347431f, -0.03931662f, -0.03978617f, 0.00419485f, 0.00303263f, -0.03416117f, -0.04417546f, 
    0.01832348f, -0.00692223f, -0.02809519f, 0.03720632f, 0.03921145f, 0.03885013f, 0.01531266f, 0.04056350f, 
    -0.04381722f, -0.05209377f, -0.01758724f, 0.04130748f, 0.04435450f, -0.04288718f, -0.04217619f, -0.02822581f, 
    0.04609322f, -0.05196001f, 0.00820231f, -0.04453437f, -0.04344925f, 0.05323751f, 0.00539443f, 0.03011729f, 
    -0.00620478f, -0.01285244f, -0.01604411f, 0.00277771f, -0.02951180f, 0.00879698f, -0.01202084f, -0.00902222f, 
    0.03793451f, -0.01758247f, -0.04899683f, -0.02683265f, -0.02833581f, 0.02421828f, -0.00838363f, 0.02601673f, 
    0.03896055f, -0.03572082f, 0.03571292f, -0.00071432f, 0.04755741f, -0.01301840f, 0.04191549f, -0.03716884f, 
    0.04400117f, -0.00017019f, -0.05787525f, 0.05215764f, 0.03672838f, -0.03755600f, 0.04390500f, 0.04601073f, 
    -0.02231377f, 0.03635300f, 0.03982240f, -0.03524700f, -0.04038904f, 0.03053929f, 0.02144734f, -0.04530273f, 
    -0.00171162f, -0.00551199f, -0.05334941f, 0.02487675f, -0.04324043f, 0.00230757f, 0.01898303f, -0.05019024f, 
    0.01638387f, -0.04639445f, 0.00574205f, -0.02131650f, 0.03882330f, -0.03422841f, -0.02786551f, 0.00655375f, 
    0.04078161f, -0.05236850f, -0.04409622f, -0.03074334f, 0.00688443f, 0.02792514f, -0.03046176f, 0.00067719f, 
    -0.00040059f, 0.00818438f, -0.02488481f, -0.04795641f, -0.06091858f, -0.04574184f, -0.05660982f, 0.05387877f, 
    0.03340485f, -0.05040371f, -0.01688537f, 0.04756530f, 0.02923848f, -0.01184883f, 0.00412783f, -0.06119075f, 
    -0.06129748f, -0.03889169f, 0.03180468f, -0.04280206f, 0.01339157f, -0.04160485f, -0.05209696f, -0.03453796f, 
    -0.01391465f, -0.00710074f, 0.03459712f, -0.02912348f, 0.01836197f, -0.02895986f, 0.01001444f, 0.03450634f, 
    -0.04978283f, 0.01182539f, 0.05752255f, 0.01315642f, -0.03970647f, -0.03329403f, -0.03011803f, -0.00727197f, 
    -0.04811692f, -0.03301800f, 0.01080013f, -0.05406003f, 0.02072825f, 0.00254238f, -0.03671091f, 0.05062949f, 
    -0.02423200f, 0.02840632f, 0.02683798f, -0.02108074f, -0.03923868f, -0.01594929f, -0.03377032f, -0.01922353f, 
    -0.01187591f, -0.02636253f, -0.02339060f, -0.01025431f, 0.03883765f, -0.02312700f, -0.01034443f, -0.02193136f, 
    0.02521938f, -0.02222010f, 0.03787071f, -0.01172517f, -0.05837809f, -0.01275161f, -0.00166752f, -0.01634033f, 
    0.00976516f, 0.02936895f, -0.03951291f, -0.04805066f, 0.03356111f, 0.02170930f, 0.01234696f, -0.03609499f, 
    -0.06567983f, 0.02899287f, -0.00217874f, -0.01338993f, -0.05970553f, -0.01484302f, -0.06851982f, -0.03523517f, 
    0.03720440f, 0.02290265f, -0.05074805f, -0.06060211f, -0.05378924f, -0.02544227f, 0.00436434f, 0.02632826f, 
    -0.06856901f, 0.03498574f, 0.03522501f, 0.02551632f, 0.02076319f, -0.00243019f, -0.05707791f, -0.04791205f, 
    0.01404771f, -0.04723359f, 0.02818667f, -0.06482882f, -0.05904702f, -0.02843277f, -0.02674322f, -0.04350121f, 
    -0.01497441f, -0.05964778f, -0.06405361f, 0.03624680f, -0.01824533f, -0.02942730f, -0.01071146f, -0.04723573f, 
    -0.02377105f, -0.00038627f, 0.02893407f, 0.02703487f, -0.04798171f, -0.01603811f, 0.02963233f, 0.01307646f, 
    -0.02304243f, 0.05480745f, 0.02615192f, 0.00600469f, -0.04066719f, -0.00963575f, -0.05547687f, -0.03152201f, 
    -0.01932635f, -0.03588930f, -0.04619925f, 0.03208229f, 0.03502235f, 0.00770205f, -0.02785794f, -0.03603033f, 
    -0.03022864f, -0.00142295f, 0.00172421f, -0.01128119f, -0.02833634f, -0.02437170f, 0.03014110f, -0.03057135f, 
    0.01016286f, -0.01264100f, 0.02347427f, 0.01129584f, -0.02353501f, -0.02024715f, -0.03719182f, -0.01717124f, 
    -0.03281866f, 0.02758401f, 0.01922374f, -0.01696398f, -0.06340147f, 0.01813917f, 0.02785872f, -0.05114038f, 
    -0.00053865f, 0.03544588f, -0.00347635f, 0.00239306f, -0.05071454f, -0.03530913f, -0.02492685f, -0.02491049f, 
    -0.00974839f, 0.02265714f, 0.04781554f, -0.03396951f, -0.05764847f, 0.03483858f, 0.03797142f, -0.04750320f, 
    -0.06326349f, 0.03410620f, -0.03532605f, 0.04784097f, 0.02625958f, 0.02944561f, -0.00633301f, 0.03303905f, 
    -0.00558306f, 0.17842792f, 0.09413210f, 0.03634077f, 0.15292175f, -0.09884187f, -0.10373243f, -0.11460199f, 
    0.05349019f, -0.00400285f, -0.23040125f, 0.04051038f, 0.11517733f, 0.03275247f, 0.25470167f, 0.31604004f, 
    -0.12834226f, 0.28005365f, 0.27910176f, 0.01567383f, 0.30859569f, 0.12161365f, -0.06116047f, 0.09273808f, 
    0.07541609f, -0.09053968f, 0.35649699f, -0.02304403f, -0.29658124f, -0.43274245f, 0.11573447f, -0.11019265f, 
    -0.15021393f, 0.11750095f, 0.07380162f, 0.14797738f, -0.15927315f, 0.08156362f, -0.06312761f, 0.04502979f, 
    0.00338093f, -0.05417895f, -0.27977839f, 0.17453268f, 0.06802765f, 0.03628072f, 0.07111268f, 0.10895362f, 
    0.06793163f, 0.10050900f, 0.07678811f, -0.09980345f, -0.14225832f, -0.04514150f, -0.28153548f, -0.02849022f, 
    -0.29554251f, -0.30834803f, -0.01366294f, -0.09547091f, -0.12099864f, 0.09015313f, -0.00946237f, -0.16235732f, 
    0.22467171f, 0.01527379f, 0.06427234f, 0.08274315f, 0.09851726f, 0.05956205f, 0.07180337f, 0.04320915f, 
    0.24338880f, 0.07545474f, -0.24907480f, 0.02922350f, 0.02077938f, 0.00889376f, -0.01703400f, -0.09508795f, 
    -0.32987174f, -0.03492633f, 0.12481856f, -0.04248850f, -0.09547925f, 0.08199729f, 0.00434409f, 0.09476270f, 
    -0.06918454f, 0.11883765f, -0.12631305f, -0.14813444f, -0.16716294f, -0.09965038f, -0.00993562f, 0.05426605f, 
    0.15007186f, -0.18152255f, 0.21676204f, -0.18118842f, -0.05777563f, -0.23348373f, -0.01747970f, -0.13128300f, 
    -0.24465838f, 0.04205339f, -0.19005774f, -0.24258187f, -0.11635348f, -0.00900943f, 0.06374879f, 0.01409848f, 
    0.39864752f, -0.32632455f, 0.08442126f, 0.14804375f, 0.10608622f, -0.23493484f, -0.52654850f, -0.37534544f, 
    0.20047550f, 0.09746449f, 0.12500331f, 0.11973041f, -0.14945157f, -0.08808783f, 0.02759772f, -0.06312294f, 
    0.22105204f, 0.07003453f, -0.16332760f, 0.00974812f, 0.05137517f, -0.12882829f, 0.06319380f, 0.10852148f, 
    0.01773943f, -0.21915120f, -0.05510868f, 0.18930766f, 0.10049918f, 0.17743728f, 0.10628762f, -0.04546175f, 
    -0.32380930f, -0.58167320f, -0.15131906f, -0.01499464f, 0.11538281f, -0.10375051f, 0.03009569f, -0.02824963f, 
    -0.03622158f, -0.17497395f, 0.02623123f, -0.03810000f, -0.09815450f, -0.18698406f, -0.15425606f, 0.10771606f, 
    -0.00096886f, 0.08269960f, 0.05564932f, -0.01839816f, -0.46713749f, -0.04180223f, 0.01612655f, 0.09639967f, 
    0.15273906f, 0.02242067f, -0.17850731f, 0.12781969f, -0.34419182f, 0.11401540f, -0.12353953f, -0.11877596f, 
    0.30249813f, 0.16696452f, -0.02561248f, -0.09572428f, 0.24143001f, 0.01486399f, -0.17848963f, -0.11473648f, 
    0.11633331f, 0.08093698f, -0.04167351f, 0.19587274f, 0.19378224f, 0.04221753f, -0.03759150f, 0.09597965f, 
    0.06753631f, 0.02389261f, 0.02833941f, 0.10308954f, 0.13917166f, 0.16237201f, 0.11615564f, 0.14899912f, 
    -0.19014911f, -0.11427955f, -0.12505159f, -0.24874705f, -0.19134513f, -0.25130808f, 0.27650413f, 0.00745319f, 
    -0.14988106f, 0.04944865f, -0.07143022f, 0.06774174f, 0.03041526f, 0.20212668f, 0.08982845f, 0.16988669f, 
    -0.10931977f, -0.23867771f, 0.06246896f, -0.07718181f, 0.02557202f, -0.10330092f, 0.16161121f, 0.28617388f, 
    0.06521387f, -0.06850916f, -0.08408980f, -0.14400566f, 0.04565730f, 0.13808282f, -0.15712264f, 0.06505693f, 
    0.13682517f, 0.29881105f, 0.03721874f, 0.07863112f, 0.04133885f, -0.03053741f, 0.20630918f, -0.01410158f, 
    -0.08966227f, -0.01262246f, 0.18940040f, 0.05754453f, 0.32393688f, 0.14987034f, -0.19119106f, 0.06963538f, 
    0.10886841f, 0.19853514f, -0.09327240f, -0.21950510f, -0.05092733f, -0.08158249f, 0.03056088f, -0.14352116f, 
    -0.03511154f, -0.36695111f, -0.07757437f, -0.17535643f, 0.22266458f, -0.03633465f, -0.14182928f, -0.17763601f, 
    0.02577111f, 0.04905605f, 0.06461100f, 0.02271636f, -0.10337228f, -0.14791250f, -0.14980680f, 0.06300399f, 
    0.12714732f, -0.23635851f, 0.01890407f, 0.18895735f, 0.13586229f, 0.11409271f, 0.07418778f, -0.00695196f, 
    0.06096911f, -0.20559394f, 0.02015622f, -0.07803053f, 0.18026084f, 0.16661444f, -0.04220640f, 0.04472790f, 
    -0.15720356f, -0.04252706f, -0.01491473f, -0.02937765f, -0.21555902f, -0.12969390f, 0.19871855f, 0.12902761f, 
    0.10462709f, 0.10753029f, 0.22423901f, 0.07554124f, 0.08859459f, -0.06927513f, -0.01171590f, 0.04390484f, 
    -0.00079066f, -0.29032123f, 0.50651217f, -0.03919786f, 0.08407325f, -0.04331121f, -0.05593474f, 0.35116804f, 
    0.24231191f, -0.16416059f, 0.05540085f, -0.17886849f, 0.13799903f, 0.32338318f, 0.06804203f, 0.04765980f, 
    -0.11537598f, 0.06326693f, -0.02546296f, -0.13133429f, 0.33599752f, 0.08796666f, 0.18981440f, 0.01284535f, 
    0.05853086f, -0.03280162f, 0.15345973f, 0.28380397f, 0.14992191f, 0.04306213f, 0.06846874f, -0.10590704f, 
    -0.01079687f, -0.15156353f, -0.16444349f, 0.14666563f, 0.08084027f, 0.10651358f, 0.07601681f, -0.17814603f, 
    -0.08173618f, -0.05509414f, 0.05336293f, 0.39043239f, -0.08280126f, 0.00842675f, 0.15838118f, 0.17656693f, 
    -0.25180066f, -0.06786591f, 0.40065867f, 0.03794463f, 0.04193483f, -0.04385146f, 0.03875078f, -0.09978542f, 
    -0.10577191f, 0.08705911f, 0.30704278f, 0.13792628f, -0.06651074f, 0.01342373f, -0.09679279f, 0.00083707f, 
    -0.17039652f, 0.29940528f, -0.00497449f, -0.09776935f, 0.02397457f, -0.09557462f, -0.18626632f, 0.25979134f, 
    -0.02122050f, 0.13230464f, 0.37130570f, 0.08532874f, 0.22502598f, 0.09881883f, -0.01067831f, -0.19295138f, 
    0.04328016f, 0.05022602f, 0.19275305f, -0.43711111f, 0.42524958f, 0.31293401f, 0.01707736f, -0.06685764f, 
    0.05323204f, 0.05647650f, 0.24686256f, -0.03735781f, -0.23965581f, 0.03336509f, -0.07940061f, 0.18534364f, 
    -0.21181358f, -0.20250100f, 0.05840249f, -0.06345714f, 0.08726282f, -0.13899302f, 0.28989047f, 0.54785067f, 
    0.13993840f, -0.08651856f, -0.07573684f, 0.10524800f, -0.08905640f, -0.01794929f, -0.13642469f, -0.19355814f, 
    -0.05328082f, 0.01432818f, 0.13639915f, 0.19976109f, -0.04925868f, 0.01665443f, 0.10895853f, 0.18245271f, 
    -0.21594258f, 0.11583402f, -0.21287438f, -0.09333406f, -0.06628063f, -0.09621429f, 0.05447868f, 0.04794977f, 
    0.52757138f, -0.11906652f, 0.25023183f, 0.23710275f, -0.29640371f, -0.10462623f, 0.12200056f, -0.10321749f, 
    -0.06716825f, 0.03221848f, 0.10419992f, -0.06177911f, -0.11397993f, 0.26154390f, 0.02442014f, 0.17321037f, 
    -0.00632627f, 0.03474078f, 0.35397616f, 0.05374203f, 0.21529247f, 0.11886208f, -0.01005926f, -0.08530020f, 
    0.06653628f, -0.05564320f, -0.19891092f, 0.13512947f, 0.24656634f, 0.12657137f, 0.08181126f, 0.01044211f, 
    -0.19981657f, 0.00160888f, -0.01853773f, -0.31558666f, -0.28642735f, -0.03575103f, -0.07414933f, 0.26451594f, 
    -0.11608505f, 0.08377268f, -0.04503009f, 0.02609372f, -0.27011335f, 0.03036164f, 0.18593499f, 0.05702995f, 
    -0.04095361f, -0.03526538f, -0.04671489f, -0.15721728f, 0.00604129f, -0.16140872f, -0.04840752f, 0.00521046f, 
    -0.07784306f, -0.05619149f, 0.07481543f, 0.16011783f, 0.08085915f, -0.09938861f, -0.04487537f, -0.16418284f, 
    0.11898775f, 0.00041648f, 0.19596119f, -0.06520440f, -0.02708200f, -0.10872429f, -0.05801371f, 0.12808517f, 
    0.05798262f, 0.09413001f, 0.19596529f, -0.08027250f, -0.00038555f, -0.00962046f, 0.01237175f, -0.31297034f, 
    0.11939158f, -0.01201736f, 0.19870743f, 0.04527010f, 0.16534808f, -0.13987510f, -0.00063469f, 0.13466378f, 
    -0.28804559f, 0.27504474f, -0.14633110f, 0.12194593f, 0.03805567f, -0.33278048f, 0.09876563f, -0.00346541f, 
    0.36612350f, 0.19235779f, 0.14577371f, -0.30049932f, -0.16979164f, -0.06986631f, 0.46498582f, -0.10547998f, 
    -0.03039910f, 0.01568336f, -0.06268550f, 0.00970286f, -0.07803126f, 0.08159371f, -0.36585334f, 0.15712427f, 
    -0.10657208f, 0.20498466f, -0.14354315f, 0.04250770f, -0.03721811f, 0.19217899f, -0.05384320f, -0.01038161f, 
    -0.26389918f, -0.36781910f, -0.20840473f, 0.07259998f, 0.17848735f, 0.12198109f, 0.08190565f, -0.02258783f, 
    -0.20823291f, -0.04801051f, 0.06448261f, 0.17131147f, -0.08736542f, 0.01637166f, -0.08960126f, -0.04178590f, 
    -0.07201361f, 0.01655660f, -0.13076088f, -0.06707235f, -0.01994389f, -0.05035006f, 0.09255639f, 0.01050031f, 
    -0.20898753f, -0.42835647f, -0.55694157f, 0.01706496f, 0.06809440f, 0.04508022f, 0.16913730f, -0.03624268f, 
    0.12062413f, 0.33413130f, 0.01845638f, -0.18929894f, -0.14437842f, -0.05096408f, -0.28556496f, -0.06404119f, 
    -0.00192006f, 0.07485855f, -0.38016129f, -0.63582432f, -0.31169620f, -0.04185865f, 0.08106204f, -0.21425371f, 
    0.23952502f, -0.10902289f, -0.01769323f, 0.23230250f, 0.35573569f, 0.14502475f, -0.19267412f, 0.11905474f, 
    0.01415059f, 0.01866142f, -0.21400437f, -0.01401168f, -0.27811676f, 0.39313185f, 0.19828090f, 0.11119749f, 
    0.11425861f, 0.02214631f, 0.05667126f, -0.02771582f, -0.12736668f, 0.05862688f, 0.03919640f, -0.37718755f, 
    -0.15603171f, -0.37950757f, 0.01686499f, 0.04454575f, 0.13418280f, 0.27086267f, 0.37653023f, 0.10845505f, 
    0.17009680f, -0.07776667f, 0.18295528f, 0.27392626f, 0.21789522f, 0.04801411f, 0.10206964f, -0.23722719f, 
    0.02044326f, -0.07848019f, -0.05958498f, 0.00050449f, 0.25775266f, -0.15660574f, 0.03483410f, 0.06584375f, 
    0.17030482f, 0.30262592f, 0.42193460f, -0.05483827f, -0.04968179f, 0.16823357f, 0.04562776f, -0.00860281f, 
    -0.07119832f, -0.47837231f, -0.09439987f, -0.08670991f, 0.08302972f, -0.09072881f, -0.04517120f, 0.14228937f, 
    0.07265957f, 0.30141351f, -0.39289623f, -0.24777712f, -0.29523069f, 0.29314676f, -0.19951393f, -0.04013038f, 
    0.09745885f, -0.00096399f, -0.11016078f, 0.65705061f, 0.22079630f, 0.01533111f, 0.08331956f, -0.07975629f, 
    0.01141437f, 0.25452390f, 0.00005533f, 0.02893903f, 0.13219310f, -0.45756412f, -0.31163689f, -0.06635219f, 
    -0.20915303f, 0.18370698f, -0.09035744f, 0.15652037f, 0.17024717f, 0.03716863f, 0.10704073f, 0.00498008f, 
    -0.08832980f, -0.08192673f, -0.22809771f, -0.05123238f, 0.06315383f, 0.05495942f, 0.05205164f, -0.18127078f, 
    0.13237154f, 0.09572223f, 0.10664199f, 0.17087221f, 0.01429958f, 0.08930741f, -0.12303554f, 0.30961436f, 
    0.12949283f, -0.32566911f, 0.01745953f, 0.01074531f, 0.09253591f, 0.25395134f, 0.01180170f, 0.11682692f, 
    0.31573021f, 0.40055490f, -0.02985238f, 0.04632620f, -0.40258673f, -0.07511230f, -0.12514292f, -0.06091493f, 
    0.16157787f, -0.37554178f, -0.32648006f, -0.45984840f, -0.01466388f, -0.39867091f, 0.14596134f, -0.06778279f, 
    0.27912024f, 0.01381556f, 0.04652521f, 0.30049002f, 0.35591811f, -0.16698274f, -0.21656184f, -0.05356066f, 
    -0.02430289f, 0.04228939f, 0.02916195f, -0.01687000f, -0.82169718f, -0.61863267f, -0.03368517f, -0.35095954f, 
    -0.21500224f, -0.25396630f, 0.19188717f, -0.12366025f, -0.28048819f, -0.29022405f, -0.43457788f, -0.14224017f, 
    0.29817069f, -0.17966670f, 0.03094371f, -0.03591739f, 0.23173474f, -0.14649323f, -0.52356184f, -0.29065299f, 
    -0.17297763f, -0.11366139f, 0.08534843f, 0.08337245f, 0.05168934f, 0.03315487f, 0.12197983f, 0.29075679f, 
    0.58346492f, 0.09639224f, 0.14156780f, 0.17598891f, 0.28148547f, 0.01722177f, -0.03401593f, 0.22741494f, 
    -0.54243463f, -0.33263910f, -0.11476009f, 0.01324879f, -0.06337661f, 0.08122390f, 0.07753189f, 0.05459805f, 
    -0.55433649f, -0.36824173f, -0.42406219f, -0.31463027f, -0.23325011f, 0.02256281f, 0.07674860f, 0.35197020f, 
    0.09082857f, 0.43489024f, -0.32242885f, 0.15184830f, 0.21565698f, 0.11575896f, 0.02528384f, 0.03986338f, 
    0.07335006f, -0.01326641f, 0.67095232f, -0.08459278f, -0.22348040f, -0.02562304f, 0.09201215f, -0.15423010f, 
    0.34229732f, 0.01468365f, 0.22136995f, 0.23339443f, 0.35956910f, 0.22552088f, -0.04837090f, -0.13553900f, 
    0.26501152f, -0.01756918f, 0.20422831f, 0.03919385f, 0.34413707f, -0.11223827f, 0.19637001f, 0.14610752f, 
    -0.02061936f, 0.10506749f, 0.35094690f, 0.10926373f, 0.02718825f, -0.39941242f, 0.08793201f, -0.87754864f, 
    -0.00611501f, -0.40878946f, 0.01525533f, 0.07985804f, 0.04833483f, 0.08914800f, -0.63909835f, -0.28652486f, 
    0.28692868f, 0.01234246f, -0.14525592f, 0.13061377f, -0.19020195f, 0.01185834f, -0.10428032f, 0.66700268f, 
    -0.47902378f, -0.98684919f, 0.12901790f, 0.02957549f, 0.29279271f, 0.09680941f, 0.25669169f, 0.10804648f, 
    -0.15674169f, -0.18207361f, 0.15901531f, -0.03645461f, -0.01549330f, -0.01833539f, 0.09082758f, -0.06617638f, 
    0.18151499f, -0.29155543f, -0.39495590f, -0.12737164f, -0.08924956f, 0.11054100f, -0.06846914f, 0.06225037f, 
    -0.15039079f, 0.21344942f, -0.20852838f, 0.18960492f, 0.61936742f, -0.14068270f, 0.12541147f, 0.06577698f, 
    -0.07423892f, 0.18587501f, 0.29848865f, -0.12439795f, -0.02506207f, 0.37751317f, 0.08634609f, 0.01271800f, 
    -0.06533924f, 0.14903463f, -0.06624284f, 0.14014122f, 0.70348877f, 0.01775360f, 0.04288345f, 0.01845786f, 
    -0.00460598f, -0.10458149f, -0.04998948f, 0.15847303f, 0.00709128f, 0.21583353f, -0.51914042f, 0.09411594f, 
    -0.25724149f, -0.05686310f, -0.00188012f, 0.09261960f, 0.05349978f, -0.06967634f, -0.63152158f, -0.14932953f, 
    -0.47909930f, 0.17930247f, 0.09664301f, -0.35321778f, 0.24146183f, 0.09491613f, -0.02860491f, 0.20961623f, 
    0.25593221f, -0.04947715f, 0.02312657f, 0.15659380f, 0.08728550f, 0.18021391f, -0.02729184f, 0.05420545f, 
    -0.07155993f, -0.12110904f, 0.23785511f, -0.14445712f, -0.20141549f, -0.35847351f, -0.14934206f, -0.17822413f, 
    0.29575899f, 0.11536687f, -0.14391181f, 0.02682591f, -0.11857134f, -0.12335499f, -0.05530586f, 0.17521693f, 
    -0.01240356f, -0.15150264f, 0.34703812f, -0.58798796f, -0.45528638f, -0.06494736f, -0.23386398f, -0.10361847f, 
    -0.19701384f, 0.13467152f, -0.27967021f, -0.27682430f, -0.34507844f, 0.28984508f, -0.05642629f, 0.13062876f, 
    -0.22815688f, -0.01236972f, 0.02361673f, 0.01672632f, -0.18854791f, -0.11661224f, 0.31631207f, 0.13737230f, 
    0.01970285f, -0.09944687f, 0.19813061f, 0.10376580f, 0.13755164f, 0.06304317f, 0.02864409f, -0.00860905f, 
    -0.00066055f, 0.05026419f, 0.15084541f, 0.05245790f, 0.08940400f, -0.00013430f, -0.14487484f, 0.37302449f, 
    0.37825647f, 0.17424807f, 0.01914110f, 0.14408542f, -0.10717481f, -0.08545587f, 0.30093938f, 0.23976384f, 
    -0.29195699f, -0.19695260f, 0.05357659f, 0.11767951f, -0.13408627f, 0.07173103f, -0.18014689f, -0.07039589f, 
    -0.28516096f, 0.21984212f, 0.39514881f, -0.07794134f, 0.02507644f, -0.06641772f, 0.01584302f, -0.30412549f, 
    0.20364876f, 0.02496385f, -0.11932554f, 0.10658239f, -0.03909402f, 0.01762167f, -0.23453550f, 0.21047886f, 
    0.24865438f, 0.20000701f, -0.20326795f, 0.09274770f, 0.15919980f, -0.05109167f, -0.06345192f, -0.10317475f, 
    0.02993429f, -0.17892765f, -0.21459183f, 0.95676535f, -0.55818999f, -0.67663860f, -0.04838793f, 0.24968284f, 
    0.16204841f, 0.21984150f, -0.06715814f, 0.09383418f, 0.23649621f, -0.28554630f, 0.24354659f, 0.17350844f, 
    -0.05539804f, 0.08085041f, -0.06915910f, -0.07858008f, 0.05039718f, -0.29318845f, -0.14396347f, 0.38871267f, 
    -0.01825564f, -0.00142609f, -0.33575621f, -0.21179785f, -0.11591204f, -0.03620138f, -0.43313816f, 0.28888541f, 
    -0.16218823f, 0.05731506f, -0.15253170f, -0.08540553f, -0.10468140f, 0.18372475f, -0.05907918f, -0.13596418f, 
    -0.08387332f, 0.49115977f, 0.19754544f, -0.10093850f, -0.10257304f, 0.03672791f, -0.10979296f, 0.14610386f, 
    -0.60035884f, -0.78170145f, 0.19813876f, 0.08449423f, -0.24913502f, -0.07152856f, 0.05321497f, 0.00317853f, 
    0.04014710f, -0.42671749f, 0.19842720f, 0.35237971f, -0.08502633f, -0.00524797f, -0.08818094f, 0.00973862f, 
    0.01806779f, -0.00120228f, 0.32107785f, -0.09092265f, -0.17903569f, 0.00188752f, 0.09390055f, 0.09393030f, 
    0.02198632f, 0.11516664f, -0.00499912f, -0.33626187f, -0.27210987f, 0.30722719f, 0.05001510f, 0.03516281f, 
    -0.27552718f, -0.08480721f, -0.12923242f, 0.01008295f, -0.50398934f, 0.01504966f, -0.03221293f, 0.02531478f, 
    0.09283857f, -0.09621964f, 0.06037373f, 0.11665770f, 0.04337820f, -0.21642743f, -0.43077737f, -0.14075902f, 
    -0.15489353f, -0.23095454f, 0.02612681f, 0.02474100f, 0.13731572f, -0.24856770f, -0.06956869f, -0.47717962f, 
    0.18165669f, -0.07567702f, -0.20879312f, 0.02812676f, 0.02446095f, 0.12483547f, 0.12343864f, -0.16390501f, 
    -0.15293634f, -0.14938666f, -0.12970629f, 0.06162060f, -0.19716403f, 0.00455959f, 0.13831836f, 0.00620691f, 
    -0.16843587f, -0.05565762f, 0.09100376f, 0.18912673f, 0.12306480f, 0.10473886f, 0.09498911f, -0.11052089f, 
    -0.01050770f, 0.13293099f, 0.04272453f, -0.06480381f, 0.00345690f, 0.06986750f, 0.06980403f, 0.03893788f, 
    0.12383646f, 0.20361090f, -0.12572661f, -0.06646688f, 0.41962868f, 0.13134053f, 0.06979502f, 0.17585237f, 
    0.18866459f, 0.05785947f, 0.20443952f, 0.39048508f, -0.04725212f, -0.15077944f, -0.06665754f, 0.05042371f, 
    -0.11103316f, -0.01007434f, 0.04739943f, 0.19388124f, 0.11373281f, -0.20497926f, -0.14938679f, -0.02015525f, 
    0.03687661f, -0.01453439f, -0.06145211f, -0.27206323f, -0.01889605f, -0.04999261f, -0.15439036f, 0.01179135f, 
    0.09761308f, 0.07721934f, 0.01199626f, 0.11945195f, -0.00996850f, 0.09375239f, -0.18411238f, -0.14431132f, 
    -0.25801131f, -0.01583478f, 0.11045622f, -0.10178972f, -0.26345587f, 0.01447948f, -0.23501469f, -0.16372222f, 
    0.03468253f, -0.03134010f, -0.02290670f, -0.04931568f, -0.05931488f, -0.04877879f, -0.00125580f, -0.08196519f, 
    0.28058848f, -0.31678024f, 0.05354696f, -0.08707248f, -0.04954872f, -0.09906811f, 0.21689931f, 0.12190113f, 
    -0.00691710f, 0.08710491f, -0.09038644f, 0.08652614f, -0.00754366f, 0.15956241f, 0.08130960f, 0.13782506f, 
    -0.18042193f, -0.00189743f, 0.21037056f, -0.12643911f, 0.06266443f, -0.00779439f, 0.05545985f, 0.17274575f, 
    -0.11662003f, -0.13671355f, -0.08666719f, 0.40397656f, -0.21807866f, 0.00688774f, -0.06793027f, 0.00001104f, 
    -0.14536420f, -0.22794817f, 0.06936746f, -0.05143445f, -0.09100287f, 0.00326380f, -0.01114023f, 0.12355459f, 
    0.19909278f, 0.01071694f, 0.02860568f, -0.03427538f, 0.11761931f, -0.06219544f, -0.13880326f, -0.51197994f, 
    0.12071362f, 0.03710077f, 0.21513887f, -0.03002910f, 0.00960512f, -0.06510599f, 0.02380453f, 0.23419462f, 
    0.07930451f, -0.04993349f, -0.07381866f, -0.00426932f, -0.03900394f, -0.14855629f, 0.00944931f, 0.13775121f, 
    0.10881821f, -0.03460513f, -0.16546883f, -0.01175504f, 0.01822754f, -0.02917855f, -0.07824803f, 0.11903397f, 
    0.13313378f, -0.22731631f, -0.13345475f, 0.02607249f, -0.01616268f, 0.22043899f, 0.12845272f, -0.04390789f, 
    0.11073963f, -0.03190429f, -0.02999319f, 0.04127542f, 0.27141613f, 0.02819914f, 0.09794632f, -0.23610243f, 
    0.04159134f, 0.00956091f, 0.22152533f, 0.16953720f, -0.17420329f, -0.02552896f, -0.03667819f, -0.06097616f, 
    0.15770908f, 0.07322384f, 0.05660408f, 0.03307166f, 0.02448105f, 0.11478770f, 0.25489107f, 0.12094466f, 
    0.09602612f, 0.13981791f, 0.23811227f, 0.09438896f, 0.14440858f, 0.16641207f, 0.17710271f, -0.00162554f, 
    0.13119416f, 0.11371168f, -0.08479997f, -0.08300000f, 0.12334591f, 0.13082476f, 0.14252992f, 0.14389980f, 
    0.05917793f, 0.05260776f, 0.10800693f, 0.02402197f, 0.18281691f, 0.08673891f, 0.19452921f, 0.00336539f, 
    0.06566592f, 0.01689566f, -0.04081311f, -0.29978502f, -0.09961475f, 0.00646226f, -0.09830230f, 0.11180357f, 
    0.03201791f, 0.16948181f, -0.04855236f, 0.16077963f, -0.02746896f, -0.11569612f, 0.12159525f, 0.10725696f, 
    0.15998504f, -0.17384067f, 0.15404765f, 0.14379513f, 0.04917656f, 0.09466431f, -0.19680645f, 0.05186294f, 
    0.01352959f, -0.15188241f, 0.09166487f, 0.09299815f, 0.09020660f, -0.16090629f, 0.04734213f, -0.26543263f, 
    -0.05457459f, 0.10249242f, -0.00282007f, -0.04973336f, 0.05137729f, 0.06513649f, 0.08485049f, -0.00572861f, 
    0.14243689f, -0.10148538f, -0.05785587f, -0.07132255f, -0.13753210f, -0.06315965f, 0.11498430f, -0.04393616f, 
    -0.07004218f, 0.01858390f, 0.07340467f, -0.02086150f, -0.12131789f, -0.34243169f, -0.04769972f, 0.09586195f, 
    -0.15174216f, -0.10409822f, -0.26533368f, -0.29181421f, -0.27530867f, -0.01591357f, -0.03793432f, 0.14925167f, 
    0.12173326f, 0.13918032f, 0.00741105f, -0.09670635f, 0.09687415f, 0.05636831f, 0.03082367f, -0.10811856f, 
    0.15797552f, 0.06739312f, 0.16481644f, -0.06670168f, 0.05745166f, 0.15488876f, 0.09473705f, 0.02389988f, 
    -0.00547839f, -0.11123370f, 0.03010898f, 0.05852199f, 0.18922675f, 0.03491138f, -0.09497824f, -0.05339544f, 
    -0.17543633f, -0.04003351f, 0.10210998f, -0.07695398f, 0.05441671f, -0.01165572f, -0.04784466f, -0.12374647f, 
    -0.01871067f, -0.11268586f, -0.00302091f, 0.15358402f, -0.18435743f, 0.16139978f, 0.08683720f, 0.04299460f, 
    0.20106749f, 0.12339539f, 0.65679592f, 0.28759199f, -0.13779669f, -0.50501913f, 0.21001448f, 0.07036344f, 
    -0.00556738f, -0.02486258f, 0.03750125f, 0.21801317f, -0.15334545f, -0.16246621f, -0.00233132f, -0.10555977f, 
    -0.01244567f, 0.12689839f, -0.00036951f, 0.01011447f, -0.27761370f, -0.05792285f, 0.03127630f, -0.05482627f, 
    -0.15094532f, 0.01458117f, -0.42372420f, -0.10947037f, -0.16824524f, -0.11688095f, 0.10876789f, 0.10708095f, 
    -0.04115107f, -0.00782507f, -0.16162494f, -0.11740489f, 0.07387394f, 0.06828429f, 0.19448605f, 0.09759559f, 
    0.07215311f, -0.03713286f, 0.01106412f, -0.01517260f, -0.03118458f, -0.12888123f, 0.01217657f, 0.29415125f, 
    0.01731227f, -0.00506617f, -0.00957944f, -0.08037291f, -0.20051731f, -0.00567398f, -0.03067865f, 0.01692821f, 
    0.56799340f, -0.11913694f, -0.07092091f, -0.08740399f, -0.07713086f, -0.07675623f, 0.22280422f, -0.07665069f, 
    0.06545316f, 0.03042541f, 0.05181318f, -0.02087333f, -0.02459828f, 0.12405337f, -0.05564126f, -0.05722703f, 
    -0.10501654f, -0.10613074f, -0.00690550f, -0.03457885f, 0.00943903f, -0.00724159f, -0.04362491f, -0.07111471f, 
    -0.07101553f, 0.09955522f, -0.09987773f, 0.53829396f, 0.47322011f, -0.35641488f, 0.06431407f, 0.00577723f, 
    0.03252963f, 0.18729936f, 0.09388616f, -0.15488686f, -0.28325468f, -0.05479835f, -0.05934718f, -0.02674327f, 
    -0.34611869f, -0.17530914f, -0.19200422f, 0.06876279f, 0.15005389f, 0.10216061f, 0.22028314f, 0.13921927f, 
    -0.02586570f, -0.07850705f, 0.06971368f, -0.11588661f, -0.02625016f, -0.19746760f, 0.25863481f, -0.03614158f, 
    -0.24577862f, -0.04184192f, 0.12872262f, -0.01579133f, 0.03206049f, -0.09214339f, 0.14120433f, -0.00659245f, 
    -0.12633030f, 0.18682845f, 0.01797140f, -0.21675140f, -0.02325093f, -0.01445199f, 0.10115630f, 0.16233002f, 
    0.48052433f, 0.21926196f, 0.13270910f, -0.13487744f, -0.04796688f, 0.00583098f, -0.05977519f, 0.11389895f, 
    0.19526877f, -0.03440177f, 0.18603796f, 0.09842207f, -0.01451036f, 0.00834359f, -0.22134764f, -0.03293879f, 
    0.05725407f, -0.10106804f, 0.41283354f, 0.07952150f, -0.11925618f, 0.08119494f, -0.05636216f, 0.03329349f, 
    0.04354741f, -0.04468065f, 0.06705862f, -0.72487539f, 0.12976041f, 0.36626428f, -0.10934473f, 0.10579368f, 
    0.02757427f, 0.20569476f, 0.16818613f, 0.06942194f, -0.44502035f, -0.12368215f, 0.03439400f, -0.32423422f, 
    0.06710052f, -0.01141232f, 0.10507357f, 0.09824237f, 0.00312915f, -0.10868432f, 0.14603670f, 0.20661274f, 
    0.01227106f, 0.20394778f, -0.06101966f, 0.22318855f, 0.15585448f, -0.00954395f, 0.30827880f, -0.05612047f, 
    -0.31595144f, 0.11023854f, 0.00862841f, 0.07837386f, 0.14606577f, -0.02414189f, -0.20997030f, -0.27819410f, 
    0.04453419f, 0.04179108f, -0.13893931f, 0.03388910f, 0.13802122f, -0.16238992f, -0.03822805f, 0.08836243f, 
    0.06109950f, 0.20124166f, 0.06384839f, 0.00128085f, 0.07012270f, 0.12702473f, 0.13761413f, -0.02765565f, 
    -0.21866545f, 0.46763179f, 0.13856786f, -0.01637440f, -0.15559182f, 0.03269151f, 0.10582958f, -0.18495908f, 
    -0.03364421f, -0.00454196f, -0.19407642f, -0.11087904f, 0.07802181f, -0.20552902f, -0.22377783f, 0.15281896f, 
    0.09605521f, -0.18975593f, -0.12561506f, 0.56591672f, -0.11858594f, -0.64924991f, -0.17399859f, -0.15354943f, 
    -0.13404137f, 0.01377289f, 0.08335861f, 0.08667786f, 0.41638932f, -0.02865667f, -0.48185095f, -0.05069416f, 
    -0.06052581f, -0.00675729f, -0.20707709f, 0.05645780f, -0.13280556f, -0.00439466f, 0.19083510f, 0.13937558f, 
    0.06003742f, 0.19816238f, -0.20976713f, -0.04001577f, 0.12538311f, 0.19842842f, 0.06373496f, 0.20003386f, 
    -0.12335870f, -0.03114556f, 0.10914849f, -0.26239976f, 0.03155852f, 0.08130030f, 0.15035759f, -0.11693045f, 
    0.01767536f, 0.10294475f, 0.05421919f, -0.07068406f, -0.03982236f, 0.04896614f, 0.07394608f, 0.02229697f, 
    0.04617561f, -0.03300063f, 0.03607894f, 0.02149794f, 0.04729316f, -0.06391889f, -0.01829909f, -0.04079047f, 
    0.03927641f, 0.01496570f, -0.05435567f, -0.01500746f, -0.00237239f, 0.02314972f, 0.00896776f, -0.02141889f, 
    0.00845131f, -0.00110481f, 0.02350069f, -0.06491419f, -0.06557534f, -0.01854786f, -0.04280557f, 0.04718220f, 
    -0.03023613f, -0.05047740f, 0.01593334f, 0.04223698f, 0.04918893f, 0.03039865f, -0.00388111f, 0.03084468f, 
    0.03394974f, 0.05251646f, -0.02131938f, -0.04135093f, -0.01683673f, -0.05956005f, -0.00261163f, -0.00773086f, 
    0.05249187f, -0.05638076f, -0.06551987f, 0.02123898f, -0.03233901f, 0.03873714f, -0.03515935f, -0.03206705f, 
    0.00526783f, -0.04307374f, 0.01491999f, -0.06196136f, 0.00175406f, -0.05736628f, -0.02962024f, 0.04903743f, 
    0.00550008f, 0.04939142f, -0.01209948f, -0.00971768f, -0.00700196f, -0.01216542f, -0.03574983f, 0.05074866f, 
    0.03168393f, 0.04684823f, -0.04720619f, 0.03007005f, -0.00648953f, -0.01453119f, 0.04479919f, 0.02934277f, 
    -0.03008069f, -0.02066649f, -0.00609636f, -0.04742083f, 0.04338372f, -0.05005369f, -0.03430022f, -0.00581809f, 
    0.04988673f, 0.01594771f, -0.00439943f, 0.01383891f, -0.03481064f, 0.02169291f, 0.00279212f, -0.01491234f, 
    0.00741682f, -0.05468572f, -0.02702450f, 0.01196452f, 0.03150478f, -0.03198446f, -0.04374057f, 0.05506879f, 
    -0.06616512f, -0.01719251f, -0.01963057f, 0.00982746f, 0.00020524f, 0.01524573f, 0.02705474f, -0.04806570f, 
    -0.04545588f, 0.03589627f, -0.00386874f, -0.01247090f, 0.00455586f, -0.00980791f, -0.00721617f, -0.00582652f, 
    0.03640843f, -0.00189482f, 0.01651391f, 0.02855097f, 0.04053265f, -0.00926162f, -0.03255541f, -0.04258974f, 
    0.05224323f, 0.03983065f, 0.03540287f, -0.05688715f, -0.01402497f, 0.00598330f, 0.02209872f, -0.04867302f, 
    -0.01186257f, -0.00585635f, -0.04786875f, -0.03431034f, 0.02001044f, -0.05900300f, -0.04748878f, 0.03388189f, 
    0.04108276f, -0.03444918f, 0.04648655f, -0.03837006f, -0.06038680f, -0.02279311f, -0.06245624f, -0.03360662f, 
    -0.02469327f, -0.02705431f, 0.04180185f, -0.05676061f, 0.02693236f, -0.00872849f, 0.04819353f, 0.02776135f, 
    -0.05308204f, 0.00313338f, 0.02913098f, -0.00890505f, -0.02919095f, 0.02361011f, -0.01848812f, -0.03216961f, 
    0.01382142f, -0.00289181f, 0.00800255f, -0.05583053f, -0.02236181f, 0.00733355f, 0.02057868f, 0.05273666f, 
    0.00050067f, 0.02769125f, -0.00586302f, -0.02877144f, -0.00582698f, -0.05792767f, -0.04968163f, 0.03681760f, 
    -0.03046713f, 0.01701268f, 0.04419199f, -0.02285839f, 0.00481814f, -0.02934942f, -0.00117826f, -0.01972632f, 
    -0.06025359f, 0.00264437f, 0.02568666f, -0.03762919f, -0.00166031f, 0.00352469f, -0.00872567f, -0.04051076f, 
    -0.04079057f, -0.02432605f, -0.03127487f, 0.02548305f, 0.03830768f, 0.05109912f, 0.03066768f, -0.05599942f, 
    0.04932952f, 0.00480185f, 0.04509297f, -0.05351033f, -0.02395834f, -0.07047957f, 0.02966554f, -0.05539642f, 
    -0.03733704f, 0.03213456f, -0.01829573f, 0.01573198f, 0.01436728f, -0.05822309f, 0.01326462f, -0.03424647f, 
    0.05517787f, 0.01790657f, -0.04030122f, 0.03047592f, -0.01239542f, 0.05164250f, -0.01139060f, -0.05541990f, 
    0.00214632f, 0.04293252f, -0.03285628f, -0.03727864f, 0.01023449f, 0.00743956f, 0.02528378f, -0.03619114f, 
    -0.01621124f, 0.01305522f, -0.03536390f, -0.02339818f, 0.05091220f, 0.00213474f, -0.04323505f, 0.03570630f, 
    -0.04806963f, 0.02633826f, 0.01391764f, 0.00986450f, -0.05528983f, 0.00890913f, -0.03959861f, 0.02583495f, 
    -0.04823080f, 0.00833644f, -0.03141666f, -0.06180904f, -0.03853370f, -0.03362237f, 0.01602312f, 0.00075408f, 
    0.00748693f, -0.01597199f, -0.01177558f, 0.00120375f, 0.04169187f, -0.00308101f, -0.05021531f, 0.03246758f, 
    0.00039904f, -0.01951549f, 0.05196714f, 0.03118002f, 0.03603796f, -0.01212094f, -0.00398209f, 0.02773292f, 
    0.03700304f, -0.04034754f, -0.06136537f, 0.04879820f, -0.03992729f, -0.06303555f, -0.03813360f, 0.02706668f, 
    -0.03547293f, -0.02185743f, 0.02162166f, -0.04448111f, 0.00714806f, 0.02206399f, -0.05515477f, -0.02284774f, 
    -0.03865324f, -0.01877180f, 0.01980521f, -0.00905894f, -0.03000499f, -0.00867896f, -0.04513826f, -0.02685409f, 
    -0.00959917f, -0.05382328f, -0.06174051f, -0.01472049f, 0.02519221f, -0.02784980f, -0.00419823f, 0.01133027f, 
    -0.05708152f, 0.00631551f, -0.06047035f, -0.00073807f, -0.01206543f, 0.03974709f, 0.00955877f, -0.04212048f, 
    0.02556532f, 0.00366415f, 0.04561969f, 0.02668841f, -0.06546459f, 0.04000686f, 0.01013881f, -0.03876906f, 
    -0.05882242f, -0.02070426f, 0.04881333f, -0.02910794f, 0.00913410f, 0.03858600f, -0.05354359f, -0.00885820f, 
    -0.06824382f, -0.01832625f, 0.04238923f, -0.05469994f, -0.01880701f, 0.02927984f, -0.01111534f, 0.03156198f, 
    0.03561516f, -0.00590287f, 0.02368454f, -0.03308900f, -0.01182961f, -0.05592739f, 0.00801562f, 0.03232820f, 
    -0.06461588f, -0.01289866f, 0.01204089f, -0.05252223f, -0.06051730f, 0.00294347f, -0.00100398f, 0.01692305f, 
    0.01535010f, -0.00715780f, -0.04988118f, -0.06574125f, 0.01753268f, 0.03369316f, 0.01245721f, 0.00460986f, 
    0.04030095f, -0.05100287f, -0.00990630f, -0.05452143f, 0.02062290f, -0.05277146f, 0.00686397f, -0.06724853f, 
    -0.03870456f, -0.01081705f, -0.04394353f, -0.01899036f, -0.03439116f, -0.00451773f, -0.01175289f, -0.04118697f, 
    -0.03000242f, 0.03950140f, -0.01885747f, 0.04995936f, 0.04895782f, 0.01574719f, -0.04808792f, -0.03800344f, 
    0.04735461f, 0.03653716f, -0.02468643f, -0.01216762f, -0.04972684f, 0.02053959f, 0.02138322f, -0.03741248f, 
    0.02688715f, -0.04008294f, -0.00347732f, 0.05012352f, -0.00514222f, 0.02705028f, -0.00305483f, -0.01272473f, 
    -0.03784716f, -0.04082685f, 0.00411690f, -0.05025316f, -0.04140402f, 0.04558636f, -0.06017611f, -0.04080762f, 
    -0.04489728f, 0.01910607f, 0.02657911f, 0.02671194f, 0.01189260f, 0.00478564f, 0.02437299f, 0.02851820f, 
    -0.03384350f, -0.02725651f, -0.03201392f, 0.03511962f, 0.03034740f, -0.00219924f, -0.06025748f, 0.05061200f, 
    0.02012689f, -0.00501359f, -0.00818165f, -0.03395022f, -0.06577401f, -0.00520825f, -0.05852188f, -0.02259064f, 
    0.01934714f, -0.04820603f, -0.03797174f, 0.00397444f, 0.02276065f, 0.01534911f, -0.03147999f, 0.00819515f, 
    0.00322718f, -0.03846227f, 0.00721308f, -0.00461504f, -0.01759353f, 0.03243103f, -0.05173494f, 0.02068903f, 
    -0.05569981f, 0.00710894f, -0.00162125f, 0.02377305f, -0.06270437f, 0.03462273f, -0.04207198f, 0.03145416f, 
    0.03342329f, -0.06020616f, 0.01008413f, 0.04456511f, -0.05794570f, -0.05447262f, 0.02328426f, -0.02180448f, 
    -0.02234435f, 0.02400098f, -0.02201583f, 0.03648358f, -0.03568331f, -0.05721785f, -0.00296102f, -0.02591971f, 
    -0.05683208f, -0.02070742f, 0.03393472f, 0.02161224f, -0.04774715f, 0.02683910f, 0.02000079f, 0.03687529f, 
    -0.03610809f, -0.03195913f, 0.01086982f, -0.01722005f, 0.04704862f, 0.05055185f, 0.01114510f, -0.02112715f, 
    -0.03653072f, -0.01081893f, 0.03714793f, 0.00420496f, -0.04478592f, 0.03682287f, -0.01378822f, -0.04093149f, 
    0.02530594f, -0.04980741f, 0.02672971f, 0.00286502f, -0.04070976f, 0.04177003f, -0.03140373f, -0.05303340f, 
    0.02111099f, 0.00393071f, -0.03254327f, 0.00392748f, -0.00657559f, -0.01413196f, -0.04984440f, 0.04896945f, 
    0.01741098f, -0.01725457f, 0.00702625f, -0.05417521f, 0.03599960f, 0.04588550f, 0.00346354f, -0.02402829f, 
    -0.05012089f, -0.03591210f, -0.00116683f, 0.01595085f, 0.02856461f, -0.00667472f, -0.05653984f, -0.04913110f, 
    -0.00012804f, -0.01982685f, -0.03966294f, -0.03906918f, 0.03666116f, -0.00681594f, 0.00374812f, 0.02977214f, 
    -0.00802296f, -0.02012744f, -0.05154765f, -0.06449810f, -0.02890813f, -0.06630621f, -0.01823213f, 0.02238430f, 
    0.00304185f, -0.00899437f, -0.00820837f, -0.03316766f, -0.02881683f, 0.04463957f, -0.05694192f, -0.03673203f, 
    0.00594823f, -0.02942183f, 0.00751011f, -0.00226688f, 0.04705564f, 0.03890104f, -0.05216228f, 0.03529990f, 
    0.03006128f, 0.00160926f, -0.01766436f, 0.03661839f, -0.00412594f, 0.03777113f, -0.04645814f, -0.00264544f, 
    -0.04451945f, 0.00045077f, -0.04256983f, -0.06017927f, 0.04128011f, -0.06651878f, 0.00759645f, 0.04228523f, 
    0.09679326f, 0.07950145f, 0.05513050f, 0.02869491f, -0.14068522f, -0.02109155f, 0.12793459f, 0.11541376f, 
    0.03860242f, -0.39803568f, -0.04377113f, -0.38244778f, 0.34112215f, 0.12723547f, -0.26929742f, 0.06278682f, 
    0.00954246f, 0.04661046f, 0.42332703f, 0.41706818f, -0.28072992f, 0.05508446f, -0.01431780f, -0.10292541f, 
    -0.06185050f, 0.02366116f, 0.18201296f, -0.02166354f, -0.44857430f, -0.07582334f, 0.00553327f, -0.09199516f, 
    -0.13939385f, -0.02217341f, -0.02151269f, 0.06691267f, -0.15327355f, -0.01546422f, 0.14316240f, 0.06747032f, 
    0.01021377f, -0.05982853f, 0.30046433f, 0.29321393f, 0.40815288f, -0.00396465f, 0.00497439f, -0.01053574f, 
    -0.23837060f, -0.42441854f, -0.06403634f, 0.02259495f, 0.15812668f, 0.07197290f, -0.28338397f, 0.09457232f, 
    0.14387701f, 0.08483753f, 0.05877722f, -0.03114483f, -0.03816503f, 0.08835813f, -0.31244448f, 0.29136989f, 
    0.57001787f, 0.40884861f, -0.06535584f, 0.02446805f, 0.09594452f, 0.04411449f, -0.10156909f, 0.03321010f, 
    -0.20472974f, -0.88728970f, 0.00380192f, 0.01925816f, 0.00653649f, -0.01582962f, -0.12985222f, 0.04990500f, 
    0.05301335f, -0.04710842f, 0.06577665f, -0.11687621f, -0.01423441f, -0.20349786f, -0.25888208f, 0.02319941f, 
    0.13740835f, 0.24167266f, -0.12349038f, 0.09719973f, 0.12232307f, -0.11524687f, -0.05063964f, -0.08821619f, 
    0.17737861f, 0.03043194f, -0.00067539f, -0.11498007f, -0.15220179f, -0.12158290f, -0.12472662f, -0.01504364f, 
    -0.27569792f, 0.08138607f, 0.10760364f, -0.11439694f, -0.03104294f, -0.10875650f, 0.10738927f, 0.02816435f, 
    -0.06076425f, -0.03345528f, -0.05910833f, 0.12333856f, 0.12667283f, -0.13829198f, -0.38170174f, -0.00629103f, 
    0.00112664f, 0.05101915f, -0.11649588f, -0.03602747f, 0.05302909f, 0.11980132f, 0.35897425f, -0.05708200f, 
    0.76522058f, -0.00311631f, -0.12636229f, 0.00166063f, -0.11174200f, 0.08326177f, 0.04258438f, -0.07013662f, 
    0.11369646f, -0.28173193f, 0.10103644f, -0.00297790f, 0.04495960f, 0.07155668f, 0.06241663f, 0.04906856f, 
    -0.70310384f, -1.50883615f, -0.12773047f, -0.12995964f, -0.13204184f, 0.00696470f, 0.05637882f, -0.06526239f, 
    0.21649139f, 0.04253124f, -0.06207415f, 0.04029445f, -0.62715852f, -0.46777150f, -0.20446275f, 0.20120090f, 
    0.07420906f, 0.09500418f, -0.63747597f, -0.81223637f, -0.52213097f, -0.07614212f, -0.11460426f, -0.12785251f, 
    0.03771883f, -0.00300321f, -0.01006413f, 0.16581905f, -0.15147467f, 0.33459070f, 0.12100106f, -0.06270500f, 
    -0.14735907f, 0.02538127f, 0.01108337f, -0.08644245f, 0.09476207f, -0.00783928f, -0.27938569f, 0.15442455f, 
    0.04668875f, 0.08562595f, 0.09776700f, -0.12160344f, 0.09397845f, 0.02166823f, 0.03677215f, 0.10154101f, 
    0.07338352f, 0.04726258f, -0.13672896f, -0.14768396f, -0.24038456f, -0.02759768f, -0.27885193f, -0.25184804f, 
    0.05184185f, -0.05411968f, -0.08058450f, -0.02842741f, 0.02755400f, -0.07481327f, -0.09641431f, 0.07258590f, 
    -0.06704613f, 0.07887793f, -0.07199127f, -0.00921259f, -0.02953614f, -0.01538121f, -0.14082752f, 0.06032213f, 
    0.14842638f, -0.09212328f, 0.08431720f, 0.08671661f, -0.23263925f, -0.35899556f, -0.26522267f, -0.16428605f, 
    0.17160995f, 0.08219890f, -0.16332245f, -0.16569953f, -0.00722760f, 0.01433000f, -0.07830211f, 0.13642934f, 
    0.01810573f, 0.05252543f, -0.03828633f, 0.20903026f, 0.06226221f, 0.10788959f, 0.02415005f, -0.22925070f, 
    0.08625399f, 0.12588446f, 0.26437977f, 1.05822408f, -0.05336243f, 0.33897918f, -0.06535948f, 0.15866201f, 
    -0.06807918f, -0.15069869f, -0.02611484f, -0.04517313f, -0.01046292f, 0.18577871f, 0.60769123f, -0.09458252f, 
    -0.05922735f, 0.08834507f, -0.14604186f, 0.17434262f, -0.08278760f, 0.10649815f, -0.07861064f, -0.11279195f, 
    -0.60224277f, -0.37806520f, 0.04269440f, 0.16609131f, 0.11140922f, 0.05772538f, 0.25355947f, -0.06199554f, 
    0.22072911f, 0.04616433f, -0.14522439f, 0.04718299f, -0.03084729f, -0.07816328f, 0.08436810f, 0.14104387f, 
    0.28219348f, 0.16507535f, -0.29404986f, -0.23463877f, 0.08341009f, 0.04338453f, 0.07584131f, -0.01869500f, 
    0.00885899f, -0.08304631f, 0.19839144f, 0.10947970f, -0.22709696f, -0.15739572f, -0.10831127f, -0.23393531f, 
    -0.14920641f, 0.03139294f, -0.12143123f, -0.00895679f, -0.07480691f, 0.16169816f, 0.05480208f, 0.06578942f, 
    0.08401805f, 0.32619727f, 0.04805888f, -0.01012779f, 0.50491327f, 0.15785393f, 0.15097301f, 0.24754858f, 
    0.04405130f, 0.10454067f, -0.01532612f, 0.23175110f, 0.14541984f, 0.15716244f, -0.12232313f, 0.06219413f, 
    -0.06226326f, 0.06420666f, 0.04734857f, 0.18040913f, 0.00179627f, -0.05805237f, 0.06989092f, -0.02130787f, 
    -0.11559530f, 0.04067519f, -0.13820915f, 0.04470509f, -0.22041036f, 0.04462308f, -0.07280350f, 0.15330368f, 
    0.06908162f, 0.01401849f, -0.05205076f, -0.21654436f, -0.22317857f, -0.08459374f, -0.36945778f, 0.13118403f, 
    0.04264372f, 0.03647780f, -0.02208964f, -0.22892544f, -0.16114180f, -0.06216913f, -0.24011853f, -0.03901729f, 
    -0.15835436f, -0.13012260f, -0.15879123f, -0.17809932f, -0.06290886f, 0.20534819f, 0.06336772f, 0.05277283f, 
    0.18121374f, 0.21665862f, 0.15962140f, -0.14332719f, 0.02063479f, -0.09176158f, 0.12555602f, 0.10307329f, 
    0.17630388f, -0.05621770f, -0.02816171f, 0.17579381f, 0.09882434f, 0.14163126f, 0.16959684f, -0.20676662f, 
    -0.22005427f, -0.12206540f, 0.09883945f, -0.15627041f, 0.16625233f, -0.05658582f, 0.04416810f, 0.03162605f, 
    -0.18643655f, -0.15499197f, 0.01391969f, 0.10313472f, -0.02426285f, -0.01699017f, -0.07232486f, -0.01554376f, 
    -0.19229148f, -0.02834920f, -0.07934552f, -0.15977901f, -0.06219107f, -0.15819584f, 0.39449891f, -0.23296238f, 
    0.04433557f, -0.15041271f, -0.09243865f, -0.27747175f, -0.11813711f, 0.18472458f, 0.05624945f, -0.26085722f, 
    0.11464037f, -0.01846647f, 0.00927350f, 0.02514420f, 0.01435510f, -0.06266966f, 0.18126911f, 0.01169004f, 
    0.13600886f, -0.04975502f, 0.02229619f, -0.19161165f, 0.00447529f, -0.01226489f, -0.00672343f, -0.09362730f, 
    -0.12929347f, -0.02959979f, -0.28986794f, -0.11874209f, 0.00394282f, 0.09016670f, 0.08406452f, 0.12628692f, 
    -0.07077238f, 0.15937367f, 0.42114803f, 0.13806027f, 0.25146776f, 0.00523552f, 0.03020517f, 0.05235964f, 
    0.05497601f, 0.05950489f, 0.07671844f, 0.09815433f, 0.23533955f, -0.01527276f, 0.03649196f, -0.12993610f, 
    -0.15399067f, 0.06490104f, -0.07250137f, 0.00087638f, 0.06794263f, 0.01218764f, 0.03567785f, 0.09937157f, 
    0.14212303f, 0.16280495f, 0.10210361f, 0.19672450f, -0.10443293f, 0.21751869f, -0.06748810f, 0.06212791f, 
    0.05731293f, -0.08012126f, 0.25533396f, 0.17029943f, 0.11362427f, 0.12042619f, 0.27166513f, -0.07397223f, 
    -0.14784198f, -0.01536634f, -0.23558353f, 0.15597987f, -0.17422393f, 0.06784285f, 0.14328468f, 0.16792499f, 
    -0.01145478f, -0.06654356f, -0.01198739f, 0.03069843f, 0.10701144f, 0.05450632f, 0.17087543f, 0.31351009f, 
    -0.11034906f, -0.07328455f, 0.08162080f, -0.15003383f, 0.11413492f, -0.06543884f, -0.17792206f, -0.00867030f, 
    -0.01621492f, 0.25519645f, 0.06988078f, 0.14827383f, 0.08742149f, -0.03296486f, -0.11868163f, -0.01571509f, 
    0.06047157f, -0.14462514f, 0.23239952f, -0.00206059f, -0.12147123f, 0.07958842f, -0.07801001f, -0.15979072f, 
    -0.26177365f, -0.23731066f, 0.10171295f, 0.06763945f, 0.09236225f, -0.16089346f, -0.05897114f, -0.06954484f, 
    0.01122665f, -0.26707679f, -0.04401166f, -0.08742282f, 0.05922153f, 0.23903441f, 0.09523270f, 0.07270530f, 
    -0.13147825f, -0.06472720f, -0.39657113f, 0.19931081f, 0.36136919f, 0.08714666f, -0.03292874f, 0.04714102f, 
    0.10103601f, 0.14213228f, 0.11764254f, 0.03100083f, -0.18044241f, -0.19024166f, -0.01721312f, 0.11648598f, 
    -0.06788700f, -0.26641631f, -0.16953704f, -0.33348042f, -0.27446198f, 0.06091125f, 0.12114713f, 0.07555012f, 
    0.07044642f, 0.02005045f, 0.13891314f, -0.06984854f, 0.10858211f, 0.07525110f, 0.14171697f, 0.00848545f, 
    0.13483137f, 0.04436561f, -0.07377036f, 0.00219105f, 0.27148256f, 0.16215914f, 0.07343306f, -0.11754677f, 
    -0.15890001f, -0.02855247f, -0.04492024f, -0.05363611f, -0.06313744f, 0.02055612f, -0.13215053f, 0.13022815f, 
    0.12691532f, 0.23691031f, 0.17022340f, -0.15491797f, -0.36209154f, -0.16669579f, 0.03261037f, 0.14127389f, 
    0.14757514f, 0.15581302f, 0.15747885f, -0.02431507f, -0.00244657f, 0.19877051f, 0.04475332f, 0.09703995f, 
    0.01722886f, -0.02166792f, -0.27215788f, 0.24045585f, 0.06744664f, -0.26245180f, 0.23427498f, -0.07668436f, 
    0.09380106f, -0.04551558f, 0.08261281f, -0.23789227f, 0.16066192f, -0.07815865f, 0.01481332f, -0.05141706f, 
    0.03518194f, 0.04668519f, -0.04372927f, 0.08825729f, -0.05774811f, -0.02363916f, -0.02701191f, 0.04442713f, 
    0.00174443f, 0.01859663f, 0.31011233f, 0.39540255f, 0.21665588f, 0.23919250f, 0.21314925f, 0.11643371f, 
    -0.25721660f, -0.31600153f, -0.24661747f, 0.09214329f, 0.09008596f, 0.11257809f, -0.20437151f, -0.08130936f, 
    -0.31026310f, -0.28846502f, -0.16629355f, -0.16077164f, 0.05151164f, -0.02934524f, 0.09490463f, 0.23372997f, 
    0.52038431f, 0.06315976f, 0.27130440f, -0.35316113f, -0.06715278f, 0.12622757f, 0.06132425f, 0.10782650f, 
    -0.16281503f, 0.36479217f, -0.19060837f, -0.19262770f, -0.06025469f, -0.08446471f, 0.08633905f, -0.03132629f, 
    0.11398211f, 0.14085941f, 0.09568933f, 0.04880323f, -0.32102135f, -0.13435400f, -0.26929390f, -0.02274442f, 
    -0.08332575f, 0.35304862f, -0.16979030f, -0.22375968f, -0.01689786f, -0.03687341f, 0.11444592f, -0.10430155f, 
    -0.09460562f, 0.23375276f, 0.13485062f, -0.02001979f, 0.29000375f, -0.35036781f, 0.00405725f, -0.04876522f, 
    0.06932459f, 0.23908976f, -0.06034019f, 0.11869766f, -0.08989625f, 0.27092314f, -0.05746223f, -0.05680392f, 
    -0.31234881f, -0.02444725f, -0.11498827f, 0.06351615f, -0.26523939f, 0.27140653f, 0.24126318f, 0.43532124f, 
    -0.02172912f, -0.04493440f, -0.04049810f, -0.04078245f, 0.04491308f, -0.14357775f, -0.09056928f, 0.42009965f, 
    -0.05206341f, 0.02205533f, -0.04083967f, 0.08168895f, -0.04787477f, 0.01932127f, 0.11496718f, 0.22338839f, 
    0.11998811f, -0.21913926f, 0.00266796f, -0.19515501f, -0.04646719f, 0.08507958f, 0.05429876f, 0.10358628f, 
    0.51263338f, 0.35327569f, 0.06596985f, -0.12063183f, -0.13805772f, -0.11124303f, -0.06870278f, -0.13851258f, 
    -0.04531545f, 0.13398865f, 0.11633325f, 0.04390680f, -0.24416137f, -0.44392121f, -0.16339827f, 0.21711892f, 
    0.19692232f, 0.06023990f, 0.58277047f, 0.38679916f, 0.09527069f, -0.15697698f, -0.21137555f, -0.16645907f, 
    0.13293537f, 0.04246434f, -0.09613892f, -0.08468214f, -0.19114672f, -0.16068502f, 0.08739446f, 0.07014249f, 
    -0.04175264f, 0.04527893f, 0.10453411f, -0.29938966f, -0.32047090f, -0.25753576f, -0.17359912f, 0.11044283f, 
    -0.02094817f, 0.01646450f, 0.08429167f, -0.02672976f, -0.13799268f, -0.05955734f, 0.00103837f, 0.06254143f, 
    0.23492904f, 0.10074282f, -0.08496775f, 0.09085894f, -0.05703306f, -0.11586772f, -0.07309194f, -0.30832988f, 
    -0.16296162f, 0.00725510f, -0.11511537f, 0.10369714f, 0.07422315f, -0.05257758f, 0.11145435f, -0.15561812f, 
    0.07685480f, -0.01709432f, 0.13965578f, 0.11235599f, -0.13750002f, 0.19464968f, 0.14858627f, -0.15054321f, 
    -0.21599959f, -0.09572274f, 0.02158407f, 0.00972712f, -0.07410645f, -0.18614849f, 0.21003637f, -0.25672346f, 
    -0.02997301f, -0.36969659f, 0.05873384f, 0.30392176f, 0.06186964f, -0.11717991f, -0.14138937f, -0.16007479f, 
    0.05370204f, -0.03235427f, -0.16042702f, 0.12289115f, -0.14848924f, -0.18902805f, -0.12498768f, 0.10379425f, 
    0.28177491f, -0.13482469f, 0.11342508f, -0.21694829f, 0.05563340f, -0.51798421f, 0.10429525f, -0.14857200f, 
    -0.13193436f, 0.07095823f, -0.02127522f, 0.15327254f, -0.06352668f, -0.03681434f, 0.25468564f, -0.12671256f, 
    -0.20712908f, -0.06558725f, -0.10975805f, 0.04775679f, -0.05934384f, 0.26841873f, 0.13000280f, 0.01487413f, 
    -0.48199487f, -0.37115058f, -0.28372073f, 0.13386896f, 0.20425472f, 0.24510346f, -0.20026027f, 0.23214446f, 
    -0.10400932f, -0.16293225f, -0.51247233f, -0.21255825f, 0.06834021f, 0.22411124f, -0.00341933f, 0.12045221f, 
    0.13981445f, -0.00909766f, -0.28172463f, -0.36292100f, 0.10664124f, 0.13762163f, 0.14851597f, 0.07734212f, 
    -0.12595859f, 0.04354794f, 0.06583118f, 0.04504857f, 0.13937612f, 0.22137529f, -0.25632223f, 0.02055742f, 
    0.00039957f, -0.09055453f, 0.03973518f, -0.01343360f, 0.17685933f, 0.15502842f, 0.08664601f, -0.23021697f, 
    -0.45473596f, -0.33723602f, 0.04057276f, 0.09239319f, -0.33904380f, -0.10148184f, -0.02137674f, 0.07173806f, 
    -0.05027463f, -0.17126921f, 0.04846034f, 0.39857703f, -0.05572924f, 0.12390403f, -0.03894547f, -0.01017700f, 
    0.07471377f, -0.02418278f, 0.06520073f, 0.00157348f, -0.26747382f, 0.02704462f, -0.14338031f, 0.14390300f, 
    0.14611724f, 0.01620178f, 0.13938576f, 0.10879495f, -0.03360531f, 0.04819058f, 0.02693318f, -0.08317245f, 
    0.12103069f, 0.19653548f, 0.23641397f, -0.31686068f, -0.01406989f, 0.03201051f, -0.12145585f, 0.12230136f, 
    -0.19485366f, 0.07794958f, -0.05043278f, 0.22639626f, 0.04054988f, 0.14996038f, 0.17920004f, -0.29153523f, 
    -0.21144415f, 0.14508092f, 0.09637441f, -0.02637562f, -0.12841909f, 0.49408290f, -0.06532972f, 0.00829105f, 
    -0.13937649f, -0.09039573f, -0.26621106f, 0.10796784f, 0.37961817f, 0.22202516f, -0.11642243f, -0.07432516f, 
    -0.17211229f, -0.05360201f, 0.02871653f, -0.42286196f, 0.17174600f, 0.24463159f, 0.12080655f, 0.05305463f, 
    0.25121707f, -0.07878130f, -0.40157655f, -0.01449565f, -0.44507694f, -0.00039868f, -0.04919160f, -0.11915988f, 
    0.24179390f, 0.15487514f, -0.08248255f, 0.38801575f, 0.13927640f, 0.31202906f, -0.07341242f, 0.00608186f, 
    -0.04118047f, -0.05849575f, 0.00694678f, -0.01306976f, 0.08397031f, 0.09432830f, -0.09802228f, 0.12259714f, 
    0.06370867f, -0.00616752f, -0.09814905f, 0.12429691f, 0.16103187f, 0.10781129f, 0.09679000f, 0.24092636f, 
    0.13271648f, 0.09802144f, 0.14654207f, 0.03524755f, 0.03859942f, 0.05479551f, 0.08218075f, -0.19282854f, 
    0.14023054f, 0.05362550f, -0.01472628f, -0.16278203f, 0.23338778f, -0.01700377f, 0.24123959f, -0.26617011f, 
    0.02336439f, -0.01255441f, 0.06518448f, 0.05783617f, -0.08937114f, 0.09505658f, -0.23061076f, -0.10228334f, 
    -0.32904506f, 0.18047470f, -0.25261056f, 0.29708374f, 0.03001740f, 0.08835808f, -0.39397103f, -0.32601902f, 
    -0.12696731f, 0.11344193f, -0.01941408f, 0.13025798f, 0.15267009f, 0.06935462f, 0.20710273f, -0.25708982f, 
    -0.16811040f, -0.22836290f, -0.18558140f, -0.10360160f, -0.34108466f, 0.33967212f, 0.20247969f, 0.05838555f, 
    -0.16884184f, -0.26824549f, -0.21594544f, -0.05699850f, 0.10893831f, -0.35151672f, -0.05977621f, -0.17012084f, 
    0.27564171f, 0.01145724f, 0.13919474f, -0.02930073f, -0.10153778f, -0.02054178f, -0.20301060f, 0.13194242f, 
    -0.04027930f, 0.02146448f, 0.19640285f, 0.09881230f, 0.07103538f, 0.04278500f, -0.01856348f, -0.27157751f, 
    0.10578649f, 0.07570131f, 0.12894098f, 0.04903897f, 0.17099109f, -0.07694077f, 0.24394298f, -0.00830438f, 
    0.01204783f, 0.13985123f, 0.00791369f, -0.03773509f, -0.13345587f, -0.04908336f, 0.24084616f, -0.11008713f, 
    0.07825538f, -0.17578259f, 0.05470942f, -0.03635883f, 0.01803972f, 0.27726170f, -0.04935789f, 0.16441324f, 
    0.49365851f, -0.03924873f, 0.07541497f, -0.11052625f, 0.08736482f, 0.06881225f, 0.04582873f, 0.11935394f, 
    -0.08300146f, 0.11229607f, 0.03823057f, -0.08063392f, 0.06176652f, 0.05973149f, 0.10505845f, 0.14001432f, 
    0.14480932f, 0.21942554f, -0.56817329f, 0.06580644f, -0.53291756f, 0.16497730f, 0.16985245f, 0.19932836f, 
    -0.12692924f, 0.05017686f, 0.16200294f, 0.36316669f, -0.24151513f, 0.02635234f, 0.23705234f, -0.05325135f, 
    0.12519959f, 0.12757993f, 0.11761261f, 0.02631466f, 0.08221600f, -0.01848349f, -0.04476716f, 0.23088750f, 
    0.20212975f, 0.13894111f, -0.05803956f, 0.16280517f, 0.14514890f, -0.12384056f, -0.08144737f, 0.14041625f, 
    0.09509398f, 0.15891069f, 0.14248897f, -0.46713045f, -0.31394088f, -0.56596321f, 0.07581105f, -0.19760513f, 
    -0.05400912f, -0.01620303f, 0.24382348f, 0.10262175f, -0.29866210f, -0.48696214f, -0.18532348f, -0.09308232f, 
    -0.04787926f, 0.23478919f, 0.03906905f, 0.00392204f, -0.03207387f, -0.02727766f, -0.15039381f, -0.07175068f, 
    -0.07801034f, 0.09884327f, 0.18492897f, -0.13969426f, 0.08886154f, 0.05758615f, -0.26399118f, -0.13248169f, 
    0.08498090f, 0.11974537f, -0.23633078f, -0.02772001f, 0.12513183f, 0.17264177f, -0.00511638f, 0.17237003f, 
    0.19242467f, 0.17874250f, -0.03665633f, -0.02994271f, 0.60999554f, 0.02832722f, 0.13684496f, -0.13423441f, 
    0.13375497f, -0.01983113f, 0.23196064f, -0.18734068f, 0.12078435f, 0.17664616f, 0.08454802f, 0.09479147f, 
    -0.25109693f, 0.18778145f, -0.01651877f, -0.00334067f, 0.17305033f, 0.06507254f, 0.29406053f, -0.14834590f, 
    -0.16119331f, 0.08688787f, -0.11851268f, -0.00947984f, 0.14244114f, 0.04152831f, 0.03685674f, 0.02636072f, 
    -0.08417838f, 0.09428591f, -0.02825768f, -0.15332612f, 0.05064918f, 0.05428942f, -0.05464473f, -0.04051608f, 
    -0.20550501f, 0.03846081f, -0.11637318f, -0.06632443f, -0.15265529f, -0.46150887f, 0.18189774f, -0.28832510f, 
    -0.09068061f, -0.12494901f, 0.09503333f, 0.04772963f, 0.08491367f, -0.03507839f, 0.05004184f, -0.01698008f, 
    -0.25024086f, 0.05975759f, 0.15748115f, 0.01784998f, -0.04855080f, -0.35930267f, 0.15728940f, -0.03804298f, 
    0.16419385f, -0.13739254f, 0.10783722f, -0.13635838f, -0.04546136f, -0.02834982f, 0.11612949f, -0.04358533f, 
    -0.07481693f, -0.10449271f, 0.35241583f, 0.12854995f, -0.14682449f, -0.02512575f, -0.09539586f, -0.10935394f, 
    -0.03122181f, 0.04184102f, -0.00129275f, -0.02025804f, -0.27857599f, 0.23675033f, -0.08873081f, -0.09549611f, 
    -0.19486836f, 0.11328153f, -0.05654156f, 0.04541229f, -0.00804355f, -0.17420451f, 0.30768076f, -0.15922211f, 
    0.15038888f, -0.03125608f, 0.11762071f, -0.11171069f, -0.08163411f, -0.01252769f, -0.06708843f, 0.12309048f, 
    -0.05391243f, -0.11682533f, -0.01681663f, 0.12766290f, -0.01821327f, 0.13318235f, 0.17657487f, 0.19114459f, 
    0.35808864f, 0.18649343f, -0.02907469f, 0.00281205f, 0.05312212f, -0.04276827f, -0.01689194f, -0.06520507f, 
    -0.08597641f, -0.11064067f, 0.08127881f, 0.14701129f, 0.19141936f, -0.17057590f, 0.32282385f, -0.05563936f, 
    -0.19043593f, 0.05058154f, -0.19415599f, -0.04002281f, -0.21882692f, 0.04926265f, 0.17512801f, -0.02960169f, 
    0.08766460f, -0.00251130f, 0.09154293f, -0.12526639f, -0.10223098f, -0.04098267f, -0.08087798f, -0.02316816f, 
    0.09062302f, 0.04229802f, -0.38303497f, -0.12347581f, -0.13309450f, -0.07100288f, -0.05417510f, -0.40138209f, 
    0.04454823f, 0.12759006f, 0.19398478f, 0.21697243f, 0.18086953f, 0.22662476f, -0.24065116f, 0.05891825f, 
    0.19392379f, 0.13946201f, 0.06689578f, -0.06708036f, 0.29645434f, 0.22296408f, 0.35365471f, -0.28774965f, 
    0.11410435f, -0.14972492f, -0.15507010f, 0.14332749f, 0.10536267f, 0.34360278f, 0.19162548f, 0.03546883f, 
    -0.05567978f, -0.01983271f, -0.04422329f, 0.01980563f, 0.12820287f, 0.09480128f, 0.08612654f, 0.05153343f, 
    -0.41066191f, 0.03518492f, -0.03358437f, 0.06181100f, 0.13057595f, -0.08235446f, 0.02179517f, 0.28166851f, 
    0.16081816f, 0.52227187f, -0.01612919f, 0.20318253f, -0.24738243f, 0.15304731f, 0.15642273f, -0.08592483f, 
    -0.31192330f, 0.14200178f, 0.00852834f, -0.12686676f, -0.17355411f, 0.01998468f, -0.00475742f, 0.10138822f, 
    -0.03856708f, -0.17085224f, -0.26445824f, 0.53414041f, 0.02776251f, 0.01452824f, -0.11157641f, -0.08210979f, 
    0.08728149f, -0.05234928f, 0.04973691f, -0.00621360f, 0.22986321f, -0.15678844f, -0.05964580f, 0.10122325f, 
    -0.17393665f, -0.17584747f, 0.12069886f, -0.59174407f, 0.02395377f, 0.48949748f, 0.02048371f, 0.22196698f, 
    -0.54392225f, -0.00505181f, -0.23974665f, 0.02291358f, -0.00719053f, -0.24187894f, -0.17464811f, 0.09821401f, 
    -0.00972815f, -0.03764793f, 0.09614938f, -0.36700094f, 0.14283696f, -0.10826367f, -0.06877516f, -0.23254459f, 
    -0.09660991f, 0.11936758f, 0.12213665f, -0.06634056f, 0.12289750f, -0.04252735f, -0.41986284f, -0.09566308f, 
    -0.03235999f, -0.02444746f, 0.17418316f, -0.13171248f, 0.09292506f, -0.07898928f, 0.15193875f, -0.06553077f, 
    -0.14178993f, -0.33880338f, -0.00176998f, 0.08190152f, 0.13562551f, -0.17879702f, -0.05390937f, 0.07675815f, 
    -0.02561531f, 0.09232750f, 0.08106452f, -0.20318812f, -0.31405205f, -0.02875588f, 0.12651716f, 0.02089981f, 
    0.14915246f, -0.01048253f, 0.25332677f, -0.01666204f, -0.14450926f, 0.00482141f, 0.15411562f, 0.08104064f, 
    0.18338875f, -0.01455154f, -0.05363658f, -0.06860676f, 0.23652472f, -0.34463748f, 0.32949224f, -0.20417188f, 
    -0.32911783f, 0.12420527f, -0.10751500f, 0.00779856f, 0.25598148f, 0.09238788f, 0.06659662f, -0.06382676f, 
    0.04952582f, 0.08971668f, -0.16535828f, 0.13481249f, -0.12464143f, -0.06091028f, -0.00808521f, 0.14973998f, 
    -0.03778985f, 0.08090413f, 0.14901076f, -0.18237853f, 0.11092426f, 0.16033743f, 0.09673358f, 0.00990191f, 
    -0.03983227f, -0.23973455f, -0.19776753f, 0.13035114f, -0.00861966f, 0.16714633f, -0.35104740f, 0.11390237f, 
    -0.19330129f, -0.21596642f, -0.06826337f, -0.07298303f, 0.01002509f, 0.08731353f, 0.30794445f, 0.39122272f, 
    0.27369833f, 0.34790948f, 0.06931084f, -0.18237063f, -0.07289811f, 0.07699873f, 0.08140036f, 0.10980247f, 
    0.24332157f, 0.30702299f, 0.04848628f, -0.07885209f, -0.10448383f, -0.06987229f, -0.00296152f, -0.03320220f, 
    0.09860253f, -0.17715681f, -0.25578934f, -0.10375092f, -0.13062845f, -0.13977917f, -0.08757398f, 0.28779426f, 
    -0.02359015f, 0.25385332f, -0.44790497f, -0.78454190f, -0.17161548f, 0.08723662f, 0.04720116f, 0.08054957f, 
    0.09780676f, -0.03244599f, 0.04248245f, 0.05990607f, -0.09901018f, -0.05720804f, -0.00968537f, 0.08036647f, 
    0.05490373f, 0.11169486f, -0.09871108f, 0.05208790f, -0.11958399f, -0.08087622f, 0.24620555f, -0.21146372f, 
    -0.37913126f, -0.05944949f, 0.25508547f, 0.01295627f, 0.11069132f, 0.30933771f, -0.06897303f, 0.07613721f, 
    0.07878159f, 0.08300310f, 0.03877414f, -0.18431467f, -0.11293687f, 0.03293588f, 0.19898191f, 0.02060116f, 
    0.09731617f, 0.03231125f, -0.00922584f, -0.10498744f, -0.03994257f, 0.05261107f, 0.14303041f, -0.02009355f, 
    0.28627616f, -0.09296659f, 0.06640606f, -0.27761468f, -0.11668137f, 0.09273480f, 0.03209155f, -0.06041267f, 
    0.25538787f, 0.55796945f, 0.29758403f, 0.03403507f, 0.12272305f, -0.12818646f, -0.18612145f, -0.18153006f, 
    -0.19907555f, -0.01441914f, -0.11063789f, 0.00155531f, -0.02075271f, -0.09946239f, 0.05504142f, 0.32689625f, 
    0.15945093f, 0.00327413f, 0.41894710f, 0.53622717f, 0.31005707f, -0.10780659f, -0.19200002f, 0.03577846f, 
    -0.00163904f, 0.04544780f, -0.10326820f, -0.54369766f, -0.91505063f, -0.75290418f, 0.07426504f, -0.07610095f, 
    0.02029292f, 0.15684122f, 0.15333478f, 0.11433878f, -0.65777868f, -0.27038449f, -0.11240812f, 0.05291589f, 
    -0.03781424f, 0.10220411f, 0.11066015f, 0.02473517f, -0.00271784f, -0.36910710f, -0.33920914f, -0.18659270f, 
    0.01545739f, 0.06385566f, -0.10661823f, 0.09234427f, 0.01218159f, 0.08207879f, 0.05301371f, 0.14367706f, 
    0.02103937f, 0.02432366f, 0.07166883f, 0.25402978f, 0.06170137f, -0.03114232f, 0.17269710f, -0.54327041f, 
    -0.27900738f, 0.00934801f, 0.05614821f, -0.04790212f, -0.05019920f, 0.18971354f, 0.05033556f, -0.12327105f, 
    -0.46095118f, -0.64658958f, -0.02552258f, -0.08284181f, 0.20022565f, -0.04861463f, 0.10765960f, -0.22634640f, 
    -0.14293161f, -0.10086925f, -0.05185329f, 0.24511495f, -0.24246024f, -0.06398944f, -0.26238260f, 0.18406390f, 
    0.03319493f, -0.00722489f, -0.34277716f, -0.15672146f, -0.23756142f, 0.02391810f, -0.21217999f, -0.02473257f, 
    0.19189130f, 0.02732286f, 0.21179675f, 0.32836804f, -0.06242731f, 0.17217769f, -0.18667856f, -0.01218844f, 
    -0.13439684f, -0.06544030f, -0.02445271f, 0.07060531f, 0.00555365f, 0.01993247f, 0.11785146f, -0.25370833f, 
    -0.02508650f, -0.00508678f, 0.08177317f, -0.00135879f, 0.19804260f, 0.17399578f, 0.02988158f, 0.20489304f, 
    0.08179738f, 0.10493363f, -0.30055454f, 0.03024566f, -0.01460123f, 0.16758078f, 0.28114188f, -0.11460705f, 
    0.22298734f, -0.22919719f, -0.23417559f, -0.36711133f, 0.02238101f, 0.13790178f, 0.05442294f, -0.02118907f, 
    -0.08086646f, 0.15095772f, -0.04602127f, -0.14090122f, -0.14623974f, -0.00563085f, 0.06759621f, 0.12683702f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.02596942f, 0.24902342f, 0.07511149f, 0.02462071f, 0.05362201f, 0.17087743f, 0.38746583f, -0.05955744f, 
    0.32241982f, 0.07218375f, 0.02569970f, 0.10983395f, 0.12516814f, -0.10753524f, 0.34801152f, 0.25857276f, 
    0.31948686f, -0.06060556f, 0.24049070f, -0.05985698f, -0.02065056f, 0.18313918f, 0.13626516f, -0.19694766f, 
    0.02029256f, 0.03975414f, 0.09481312f, 0.05077626f, 0.01517144f, -0.12668872f, 0.23119597f, 0.12534139f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.36883476f, -0.12446570f, -0.37915495f, 0.11888583f, -0.45527497f, 0.34008455f, 0.02897478f, -0.09306993f, 
    -0.33020744f, 0.34154376f, 0.12318069f, -0.08193243f, 0.40814197f, -0.09567212f, 0.06695014f, -0.39221016f, 
    -0.62217569f, 0.09451676f, -0.13547853f, -0.07799342f, 0.54855138f, -0.17124522f, 0.07314167f, 0.42290881f, 
    0.01153767f, 0.13113041f, 0.23901610f, 0.18790872f, 0.15946212f, -0.00720618f, -0.57259375f, 0.33828565f, 
    0.20274727f, 0.26708743f, -0.26232281f, -0.02768386f, -0.13081004f, -0.58906353f, 0.22300249f, 0.11611741f, 
    -0.44740561f, 0.07072512f, -0.10374029f, 0.24816917f, 0.31782821f, 0.00826708f, 0.06256078f, -0.03083601f, 
    0.12941888f, -0.06263831f, 0.25878313f, -0.38941136f, 0.56525135f, -0.18219367f, 0.19282645f, -0.36142749f, 
    0.13917193f, -0.03951009f, -0.16198513f, 0.16773051f, -0.30602905f, -0.22262840f, 0.10347701f, -0.16275091f, 
    -0.09340694f, -0.62550461f, 0.26068884f, 0.14435433f, 0.09387297f, 0.50824678f, 0.23990987f, -0.09142622f, 
    0.21780685f, -0.10600254f, 0.11411394f, -0.36351594f, 0.08567809f, -0.28277954f, -0.32329199f, 0.21029919f, 
    0.04947602f, -0.00431591f, -0.05325219f, 0.01550484f, -0.35271975f, 0.18965895f, -0.06116150f, -0.24305293f, 
    0.03313243f, 0.05817191f, 0.53901106f, -0.24680656f, -0.23348142f, 0.23785287f, -0.29383048f, -0.25904262f, 
    -0.13193406f, -0.70979136f, -0.88484377f, 0.04383909f, 0.28382114f, -0.63790077f, -0.12597600f, -0.11892018f, 
    0.09410394f, -0.11026894f, -0.00800997f, 0.48424160f, 0.14244278f, 0.14486834f, -0.33162868f, 0.07367767f, 
    0.23676805f, -0.14708275f, -0.11489945f, 0.36017564f, -0.04067712f, -0.90844768f, -0.18078525f, 0.58480024f, 
    -0.13897650f, 0.09458346f, -0.04113875f, -0.49618399f, 0.12885307f, 0.37582862f, -0.71363425f, -0.13667467f, 
    -0.03947901f, -0.16436300f, -0.04016169f, -0.17404619f, 0.06211276f, -0.31496513f, 0.14521447f, -0.13136348f, 
    -1.26730096f, 0.15370113f, 0.02371028f, 0.20683147f, -0.49855030f, 0.41708407f, 0.07676999f, -0.36106622f, 
    0.13198924f, -0.14554158f, -0.17464347f, -0.14798866f, 0.05191144f, 0.32542741f, -0.28828460f, -0.16814649f, 
    -0.08842845f, -0.11072759f, 0.01804405f, 0.15419941f, 0.31757277f, 0.08429000f, 0.04376328f, 0.61347950f, 
    -0.34326813f, 0.20914994f, -0.00938692f, 0.12227808f, -0.31186551f, -0.68002290f, 0.01873362f, -0.10196935f, 
    -0.01214161f, 0.31484783f, -0.10434800f, -0.40178102f, -0.20595466f, -0.04945194f, -0.26125115f, 0.33544609f, 
    0.01915590f, -0.04856812f, -0.38385576f, 0.16094057f, 0.01957240f, 0.80327582f, 0.29328379f, 0.08441291f, 
    0.09059016f, -0.02398692f, -0.13527192f, 0.09099778f, 0.01585688f, -0.25285536f, -0.01167453f, -0.04777316f, 
    -0.16850007f, -0.16390498f, 0.74832886f, -0.05224473f, -0.33752033f, 0.80327475f, -0.31462055f, 0.06393346f, 
    -0.38717180f, -0.34384209f, -0.01846764f, 0.00410694f, 0.14879622f, -0.38985062f, 0.41623786f, -0.20523335f, 
    -0.06973817f, -0.15171014f, 0.44272965f, -0.10003852f, -0.35476163f, 0.23142876f, 0.06034010f, -0.30735004f, 
    0.01253054f, 0.02795546f, 0.23022084f, -0.29542968f, -0.03402549f, -0.01106713f, 0.11052097f, -0.95551461f, 
    0.46723142f, 0.58169478f, -0.27215120f, 0.16305511f, -0.14021130f, 0.02309661f, -0.24051899f, 0.04995179f, 
    0.06315906f, -0.07693225f, 0.03029310f, -0.11157661f, -0.18326978f, 0.37450376f, -0.52306104f, -0.03228187f, 
    -0.17538032f, -0.02132941f, 0.18462846f, 0.02632103f, 0.02089505f, -0.36101228f, -0.23875162f, 0.17471863f, 
    0.11957807f, 0.04081308f, 0.08641287f, 0.06153981f, -0.14745697f, 0.07480625f, 0.14959262f, -0.17016460f, 
    0.14517030f, -0.11661990f, 0.19784549f, 0.03853674f, -0.19507127f, -0.25292644f, 0.23167823f, -0.06833104f, 
    0.67055708f, 0.30710664f, 0.00468617f, 0.67941177f, -0.38334835f, -0.46619669f, -0.19193940f, 0.21464112f, 
    0.18745197f, 0.02901990f, -0.02309337f, -0.27663141f, -0.35443899f, -1.35747147f, 0.11868159f, 0.27988476f, 
    -0.17153576f, -0.03444075f, -0.39380121f, 0.48908502f, -0.24063191f, -0.58689487f, 0.05076850f, -0.29083827f, 
    -0.72107059f, -0.12929949f, -0.26982781f, -0.15917830f, 0.10687812f, 0.36320639f, 0.17599162f, -0.11878517f, 
    -0.73434472f, -0.41687655f, 0.11388424f, -0.02075880f, -0.18472719f, -0.03830763f, 0.68706298f, -0.10850980f, 
    0.21479452f, -0.02201857f, 0.06341793f, 0.35935575f, -0.14825284f, -0.55969417f, -0.25999036f, -0.39156291f, 
    0.17594944f, -0.13204210f, -0.46668476f, -0.47518757f, 0.46988776f, 0.10917103f, -0.07033998f, 0.25308686f, 
    1.02707410f, -0.28466344f, -0.10784377f, -0.13243204f, 0.37371710f, 0.07208025f, -0.27285543f, -0.06268493f, 
    -0.05447666f, 0.20108239f, 0.03047254f, -0.81757891f, 0.06857948f, -0.40043962f, 0.12762240f, 0.21648230f, 
    0.03332632f, -0.00004597f, -0.34788656f, -0.28964266f, -0.75543851f, 0.67974246f, 0.25757185f, 0.04965597f, 
    -0.08017182f, -0.00558878f, -0.14235491f, 0.48552486f, -0.24682659f, -0.53442615f, 0.12275767f, 0.06116333f, 
    -1.18713868f, -0.14976276f, 0.14209062f, 0.07291093f, 0.37756804f, -0.44269794f, -0.02126560f, -0.12885363f, 
    0.60787326f, -0.34044591f, 0.03052391f, 0.02646942f, 0.14353360f, 0.22650865f, 0.09771665f, -0.09811533f, 
    0.16682629f, -0.16878347f, -0.33261928f, 0.12234863f, -0.46779031f, 0.13134265f, 0.03339587f, 0.22054598f, 
    -0.16269456f, 0.12549704f, -0.96736020f, -0.30075315f, -0.61503482f, -0.12374152f, 0.55549484f, -0.27874595f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.32249025f, 0.45771095f, 0.15467392f, 0.04722565f, -0.00918144f, 0.22363232f, -0.35398525f, -0.55903119f, 
    -0.13592133f, 0.23319831f, -0.23256405f, -0.00545177f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
