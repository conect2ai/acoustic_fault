#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.84793055f, -1.36267066f, -1.01971495f, 0.05555565f, 0.21823259f, -0.48251873f, -0.03278518f, 0.62906092f, 
    -0.09806035f, -1.58823216f, -0.87544328f, -0.19584621f, 0.09318855f, 0.16588651f, -0.90333110f, -0.52913404f, 
    -0.93380320f, -0.89369404f, -1.20350885f, -0.09419844f, 0.03150076f, 0.38280901f, 0.81887931f, 0.39783540f, 
    0.82253599f, 0.89133054f, 0.08259208f, 1.17048430f, 0.91627938f, 1.16895366f, -1.21090508f, -0.26170567f, 
    -0.20644261f, 0.26062611f, 0.39075169f, -0.33374366f, -0.03109681f, 0.23631206f, -0.29057348f, -1.25999117f, 
    -1.08331060f, -0.45923036f, -0.19404024f, 0.60911036f, 0.88698596f, 1.18210852f, -0.19672023f, 0.00162486f, 
    -0.71142232f, 0.95596921f, -1.11379087f, -0.16781344f, 0.43476647f, 0.48736346f, -0.07988467f, -0.00243881f, 
    1.23388994f, 0.55671090f, -0.16840473f, -0.30282211f, -0.04899255f, -0.32141113f, -0.08316759f, -0.37440926f, 
    0.11638077f, 0.81748039f, 0.73010540f, 0.21587850f, 0.62582380f, -0.18327104f, -0.14510266f, -0.62724000f, 
    -0.20412442f, 0.47089136f, 0.05871469f, 0.31254631f, 0.65671629f, 0.51267391f, -0.23866493f, 1.02832758f, 
    -0.46937171f, 0.43211517f, 0.68076789f, -0.44395375f, 0.43483910f, -0.42634282f, -0.50482768f, -0.69960505f, 
    -0.66286498f, -0.95478904f, -1.09801686f, -0.93952167f, -0.85619390f, -1.24825549f, -1.27616894f, -1.31092298f, 
    -0.12602814f, -0.16338204f, 0.05955051f, 0.18043888f, -0.16351813f, -0.12917253f, 0.49248067f, -0.12802748f, 
    -0.39231718f, 0.50299418f, -0.32664472f, 0.82282370f, 1.27037537f, 0.06248511f, -0.35429493f, 0.70273238f, 
    0.55567563f, 0.50787431f, 0.38610262f, 0.44763848f, 0.27554053f, -0.31614089f, -0.76308542f, -0.66358608f, 
    -0.06430666f, 0.29794630f, 1.74034894f, -0.12808436f, -0.05638468f, -0.41242325f, -0.41208112f, 1.29032862f, 
    0.18067773f, 0.82312077f, 0.73878896f, 0.85354429f, 0.35216129f, -0.15084130f, 0.19475630f, 1.18159044f, 
    -0.11653326f, 0.47514442f, 0.00530511f, 0.04452288f, 0.27211338f, -0.05146422f, -0.34228855f, 1.30175138f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.60914254f, -0.00075144f, 0.02531669f, 0.36067250f, 0.78967625f, 0.01011575f, 0.93757617f, -0.04169042f, 
    0.87906444f, 0.35839874f, -0.28614795f, 0.92745835f, -0.11312263f, -0.22907862f, -0.56533748f, 0.30183467f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.26752809f, -0.47610101f, 0.19819933f, -0.13091740f, -0.01705748f, -0.05750587f, 0.14622848f, -0.02768215f, 
    0.17799655f, 0.46967876f, -0.04463018f, -0.09407660f, 0.03704040f, -0.09310441f, 0.14486347f, 0.05271607f, 
    0.01980002f, -0.04918807f, 0.15075369f, 0.16973110f, 0.03475871f, -0.07215741f, 0.00695124f, -0.19156443f, 
    -0.05001864f, 0.02033209f, 0.32712838f, -0.77088940f, 0.18631427f, -0.19952030f, -0.18625833f, 0.33740377f, 
    0.07177275f, -0.03462319f, 0.39419410f, 0.29577675f, 0.68374091f, 0.41523722f, 0.40994826f, -0.05113084f, 
    0.16373590f, 0.09962336f, 0.20807388f, 0.16693635f, 0.16522972f, -0.12631729f, 0.18971251f, 0.67683733f, 
    -0.13763858f, 0.04133261f, 0.28673655f, 0.22008371f, -0.00675138f, 0.54148394f, -0.38120961f, 0.49630663f, 
    0.61248481f, 0.06657760f, 0.32854646f, 0.03628525f, -0.02329400f, 0.02114985f, -0.07239002f, -0.35976812f, 
    0.17796688f, -0.11979902f, 0.07701858f, 0.09923793f, -0.04300657f, -0.24453360f, -0.25811017f, -0.18797573f, 
    0.01808105f, 0.18516470f, -0.21353039f, -0.01158897f, -0.03577797f, -0.38037696f, 0.09560060f, -0.06883669f, 
    -0.06485944f, -0.32812995f, -0.06454979f, 0.05116620f, -0.18606502f, 0.01936284f, -0.07740033f, -0.10541030f, 
    -0.20611379f, -0.34008339f, 0.26494786f, -0.36948204f, 0.40140891f, 0.29312062f, 0.10764724f, 0.02210745f, 
    -0.11534529f, -0.24145740f, -0.03983893f, -0.07873758f, 0.03568620f, 0.26677680f, 0.09393627f, 0.16139767f, 
    -0.28176954f, -0.06306753f, 0.16806863f, 0.30165100f, -0.21086890f, -0.14477742f, 0.23119268f, 0.01506156f, 
    -0.16984035f, 0.09961969f, -0.02052348f, 0.23656829f, 0.20825019f, 0.51449835f, -0.17932242f, -0.09700468f, 
    -0.17739047f, -0.34881407f, -0.43982503f, -0.17157863f, -0.64507174f, -0.03266396f, -0.15124840f, 0.41964507f, 
    -0.03660338f, 0.15022624f, -0.06339036f, -0.32892051f, -0.14422846f, 0.12703677f, -0.05689408f, -0.47334266f, 
    0.03310366f, 0.38285807f, 0.15145977f, 0.11594004f, 0.17059797f, -0.05519113f, 0.37139159f, 0.24583058f, 
    -0.12088525f, 0.07034989f, -0.19060439f, -0.14329444f, 0.07626541f, -0.12421669f, 0.08521727f, -0.01466592f, 
    0.14705274f, -0.29971215f, -0.09805698f, 0.32013634f, -0.06236907f, -0.17548172f, 0.06971218f, 0.03974417f, 
    -0.25866637f, -0.29029623f, 0.25725582f, 0.14247562f, -0.13605972f, -0.03017444f, 0.10725763f, 0.03056760f, 
    -0.02326510f, 0.24458338f, 0.21119885f, -0.40164226f, -0.14128938f, 0.13459854f, -0.19685917f, -0.04265860f, 
    -0.14556575f, -0.03063662f, 0.18584083f, -0.04448492f, -0.31614849f, -0.33114865f, 0.06685241f, 0.01202380f, 
    0.10926481f, 0.04035146f, 0.29526788f, 0.15610617f, 0.37172905f, -0.46308869f, -0.48399478f, 1.00555456f, 
    -0.31576666f, 0.20306613f, -0.07029336f, 0.17392612f, 0.45667684f, 0.23486631f, 0.16269647f, 0.06100986f, 
    0.16394809f, 0.11430438f, -0.10413744f, 0.00505301f, 0.05523757f, 0.12095775f, 0.08380339f, 0.09832892f, 
    -0.00163391f, 0.15894049f, -0.08068948f, -0.05177115f, 0.04837993f, 0.20428088f, -0.23561370f, -0.63266516f, 
    0.21131313f, 0.25359023f, 0.19596423f, 0.08616468f, 0.13816087f, 0.35113004f, -0.07433708f, 0.05498171f, 
    0.01992140f, 0.08822656f, 0.08092694f, -0.29103285f, 0.11639040f, 0.09585019f, 0.18201295f, 0.13378063f, 
    -0.17363340f, -0.15483281f, -0.26712063f, -0.15863563f, 0.06509116f, -0.08626424f, -0.17364733f, 0.10385879f, 
    0.14899269f, 0.14203316f, 0.08091222f, 0.26903671f, 0.10573397f, 0.02973745f, 0.10958995f, 0.08177715f, 
    0.20231728f, 0.34003314f, 0.28082708f, 0.30903035f, 0.15279441f, -0.04245798f, -0.20887895f, 0.10197144f, 
    -0.27348119f, -0.34187487f, -0.12651886f, 0.01735777f, 0.23021853f, -0.07478057f, -0.40165725f, -0.63153678f, 
    0.24969861f, 0.07994768f, -0.06805703f, -0.29769868f, -0.20912507f, -0.27120987f, 0.31417045f, 0.17614399f, 
    -0.26678315f, -0.05280399f, -0.45360714f, -0.20329477f, 0.09974550f, -0.06618641f, -0.08921553f, 0.13995045f, 
    -0.24167225f, 0.20732450f, -0.22488596f, -0.06931169f, -0.00023294f, -0.11702033f, -0.12950853f, 0.18593784f, 
    -0.50404459f, -0.07455574f, 0.39852616f, 0.14715879f, 0.21780461f, -0.15127362f, -0.11365381f, 0.06785726f, 
    0.20125866f, -0.16671976f, 0.06565912f, 0.26243514f, -0.12983124f, 0.09698429f, -0.05999855f, -0.05237867f, 
    0.27874142f, 0.22615172f, -0.37949815f, 0.11970609f, 0.08668744f, -0.00580266f, -0.13265523f, -0.22931173f, 
    -0.20806845f, -0.06693926f, -0.03407689f, 0.61402255f, 0.07454257f, 0.27867419f, 0.07678141f, 0.09836489f, 
    -0.17752908f, -0.26565909f, 0.08441513f, 0.01589296f, 0.19677268f, -0.33743423f, -0.33298513f, -0.00830566f, 
    0.26620731f, 0.13622724f, 0.22501671f, 0.22571294f, 0.09313284f, 0.30765197f, -0.38590899f, -0.10596042f, 
    -0.23991148f, -0.03946920f, -0.21768154f, -0.01842168f, 0.27553588f, -0.06728482f, 0.18664086f, 0.43880513f, 
    0.51728606f, -0.02650062f, 0.03780355f, 0.40577048f, 0.20930481f, 0.30543226f, 0.09872930f, -0.86557782f, 
    -0.13775393f, -0.43677494f, 0.01638978f, -0.15351115f, -0.01027125f, -0.31950718f, 0.04525100f, -0.22358251f, 
    -0.01247801f, -0.12602085f, 0.07497878f, 0.25127426f, 0.24411593f, -0.06184719f, 0.26949146f, 0.46488827f, 
    0.34081486f, -0.42461193f, -0.07049417f, 0.01761749f, -0.04462300f, 0.07025118f, -0.07988052f, 0.23726124f, 
    0.21998282f, 0.05328169f, -0.35869503f, -0.36532131f, -0.08882115f, 0.12221369f, -0.18529674f, -0.28784406f, 
    -0.10841687f, -0.05413052f, 0.11974145f, -0.29699653f, -0.04499348f, 0.64636165f, 0.01049424f, 0.08764540f, 
    0.41652450f, 0.25092280f, 0.15565133f, 0.25897080f, 0.23949845f, 0.27540809f, 0.06031701f, -0.06976768f, 
    0.18681136f, -0.13387136f, -0.25069982f, 0.23110369f, -0.13942590f, -0.47635981f, -0.82045490f, 0.65144253f, 
    -0.25687632f, 0.15997256f, -0.28247035f, -0.36220777f, -0.36299273f, -0.16908765f, -0.25232312f, -0.10717487f, 
    -0.10906017f, 0.10978027f, -0.06717701f, -0.21153079f, 0.01372175f, 0.22964469f, -0.20623325f, 0.27449274f, 
    0.25188050f, 0.88888329f, -0.06423536f, 0.00502397f, 0.11372161f, -0.14708368f, -0.03058672f, -0.23716967f, 
    -0.50493008f, 0.75841600f, 0.78896314f, -0.01354839f, 0.10864258f, -0.00914290f, -0.02452843f, 0.05086160f, 
    -0.07587240f, -0.35365561f, -0.07346154f, 0.39174214f, 0.01426504f, -0.12351651f, -0.15159132f, 0.11393581f, 
    -0.01589059f, 0.09853518f, -0.01337781f, 0.19383305f, 0.28830224f, -0.39133444f, -0.23780654f, 0.13701397f, 
    -0.11135264f, -0.12268994f, -0.01502328f, -0.12987815f, -0.47405222f, 0.04315348f, -0.00293594f, 0.06561648f, 
    -0.08407824f, 0.11990282f, -0.22250257f, 0.19618355f, -0.37590718f, -0.68252814f, -0.48710868f, 0.08728813f, 
    0.19136137f, 0.00778212f, -0.00409109f, 0.05485814f, -0.01324439f, -0.99130511f, -0.09447596f, 0.24785073f, 
    -0.20918457f, 0.11720752f, -0.12420759f, -0.11096828f, -0.26009029f, -0.00480291f, 0.40145987f, 0.21047793f, 
    0.23524572f, 0.12067162f, 0.06095286f, -0.00903665f, 0.39673081f, 0.52805257f, 0.22010994f, -0.02401314f, 
    -0.07899844f, 0.09007872f, -0.36970326f, -0.01693594f, -0.64171904f, 0.24736869f, -0.26670140f, -0.02744530f, 
    0.10737002f, 0.09111998f, 0.21464252f, 0.04807474f, -0.04374865f, 0.24519525f, -0.07517822f, 0.00566931f, 
    -0.07648529f, 0.22360291f, 0.03683243f, -0.00817973f, 0.08470771f, 0.02685874f, 0.08163805f, 0.11422631f, 
    0.05549085f, -0.06351898f, -0.78055841f, 0.01179984f, -0.35577872f, -0.03669067f, -0.07299790f, -0.31921831f, 
    -0.04706359f, 0.02048454f, -0.10024233f, 0.00309876f, 0.30641875f, 0.20590524f, 0.13054876f, 0.03500197f, 
    0.39405292f, 0.02317154f, 0.25271210f, 0.27950296f, 0.14810322f, 0.23508438f, -0.02156657f, -0.10393762f, 
    -0.00744737f, -0.18136901f, -0.12674040f, 0.07245073f, 0.27501118f, -0.28048795f, 0.03051325f, 0.22993124f, 
    0.11669846f, -0.16204636f, -0.22618236f, 0.16813888f, 0.11771210f, -0.18565610f, 0.04571478f, -0.02120546f, 
    -0.08365624f, -0.07513619f, -0.31141335f, -0.30668911f, -0.03462293f, -0.10001546f, 0.03336835f, 0.18629478f, 
    0.00348360f, 0.02863138f, -0.12119723f, -0.00352241f, -0.09138227f, 0.03718339f, 0.23328166f, 0.16191374f, 
    -0.60162288f, 0.15355776f, 0.40586525f, 0.09133709f, 0.03440230f, -0.10838091f, 0.05559995f, 0.03234537f, 
    0.09432820f, 0.10408619f, 0.11450461f, -0.25468117f, -0.01868972f, -0.14979377f, -0.15086642f, 0.00286401f, 
    -0.17966780f, -0.00716757f, -0.38591123f, 0.19368131f, 0.27651879f, -0.05812737f, 0.03521444f, -0.27964199f, 
    0.13633534f, -0.05567541f, 0.06955318f, 0.63267297f, -0.56563491f, -0.51448387f, 0.22485067f, 0.07998065f, 
    0.18313496f, 0.17919821f, 0.11143837f, 0.11941522f, 0.30364811f, -0.14793642f, -0.78229016f, 0.13742782f, 
    0.30769548f, 0.37112352f, 0.17353180f, -0.02484990f, 0.28075722f, 0.49655855f, -0.82732981f, -0.51460320f, 
    0.36445338f, 0.37836513f, 0.05601161f, 0.04566045f, -0.27102444f, -0.18842733f, -0.37649426f, 0.07509224f, 
    0.24416251f, 0.17314938f, 0.21114799f, -0.08011783f, 0.17226110f, 0.26024973f, 0.03968787f, -0.04972634f, 
    0.29450324f, -0.10362918f, -0.27935463f, -0.22702019f, -0.08336360f, -0.24797165f, -0.03437298f, -0.12510158f, 
    0.09982499f, 0.40542454f, 0.34906572f, 0.28407168f, -0.00850791f, -0.04022660f, 0.03457150f, 0.05016733f, 
    0.17683868f, -0.23838301f, -0.64272267f, -0.61718744f, -0.03450239f, 0.01867202f, -0.07785045f, -0.24617535f, 
    -0.02713851f, 0.16485196f, 0.08548788f, 0.28834835f, -0.18173343f, -0.15345676f, -0.07476386f, -0.25107741f, 
    0.12957393f, 0.15839510f, -0.14966296f, 0.12499914f, 0.01373729f, 0.02439732f, 0.15427344f, 0.10972617f, 
    -0.08881437f, 0.26159090f, 0.22589882f, -0.03508175f, 0.28208917f, 0.21793491f, 0.15789974f, 0.04031555f, 
    0.02092992f, -0.05986014f, -0.06332805f, 0.11802062f, 0.03234765f, 0.12228953f, -0.32946709f, 0.04003061f, 
    -0.58333999f, -0.20286748f, -0.18420468f, -0.06222716f, -0.20553498f, 0.08811946f, -0.12063283f, 0.27598611f, 
    0.05968430f, -0.05882403f, -0.12520213f, 0.12519622f, 0.00548181f, -0.26302141f, -0.08612797f, 0.26048422f, 
    -0.14124772f, -0.02923378f, 0.13492578f, 0.09821549f, -0.11031647f, 0.30425796f, 0.13091233f, -0.07960486f, 
    -0.07009453f, -0.32465321f, 0.05248571f, 0.02497380f, -0.04861914f, -0.27286524f, 0.01828759f, 0.08592237f, 
    0.07671776f, -0.68286717f, -0.24123414f, 0.37534332f, 0.00853426f, -0.06073602f, 0.04379873f, 0.22038764f, 
    0.01605508f, -0.00406833f, 0.21484059f, -0.02664851f, -0.27898061f, 0.01284418f, -0.03863778f, -0.01098871f, 
    0.08346358f, 0.00433207f, 0.27892718f, 0.30303177f, -0.15888955f, 0.11254393f, 0.13163240f, -0.06500380f, 
    -0.01128675f, -0.02527701f, -0.04958342f, 0.18653072f, 0.04742615f, 0.36146986f, 0.34858263f, 0.00458544f, 
    0.07098984f, -0.06719884f, 0.10035211f, 0.28762132f, -0.04482850f, -0.00962605f, -0.09526940f, 0.22358546f, 
    0.01152982f, -0.17336141f, 0.23131973f, 0.08018751f, -0.16642606f, -0.14264779f, -0.01586654f, -0.42937037f, 
    0.39947996f, 0.05313867f, 0.05517259f, 0.14946392f, 0.10201112f, -0.19090825f, -0.16755873f, -0.29812309f, 
    -0.09673348f, 0.06161346f, -0.30027211f, -0.08006791f, -0.07318207f, -0.04796032f, -0.18541288f, -0.15136662f, 
    -0.00760172f, 0.00120865f, -0.28402239f, 0.02933720f, 0.09407783f, -0.05875677f, -0.02266328f, -0.09236136f, 
    0.09695078f, 0.44592360f, -0.01554154f, -0.01562739f, -0.03252213f, -0.14345649f, 0.28366736f, 0.08681359f, 
    -0.18181771f, 0.10799595f, 0.22052836f, 0.22572753f, 0.58357686f, 0.06535110f, -0.08586917f, 0.04961036f, 
    0.14536807f, -0.03463767f, -0.02147756f, 0.15795359f, -0.03425411f, 0.18459478f, -0.25114208f, 0.17003362f, 
    -0.03519544f, 0.02158049f, 0.04478572f, 0.22276415f, 0.17334144f, 0.04229598f, -0.37226751f, 0.04493395f, 
    0.07696413f, 0.17885567f, 0.13764474f, 0.18047762f, 0.11982845f, -0.46415079f, -0.96245337f, -0.77912301f, 
    -0.04762411f, 0.13345686f, 0.19257741f, -0.11079793f, -0.18205062f, -0.14220217f, 0.28554416f, 0.19532487f, 
    -0.29164919f, -0.08704903f, -0.09552063f, -0.23188372f, 0.11417916f, -0.00632549f, -0.08233733f, 0.39608604f, 
    -0.19198358f, -0.27515048f, -0.13865674f, -0.01232924f, -0.03160844f, -0.13169953f, 0.25591502f, 0.01296098f, 
    0.22987202f, -0.83291572f, -0.04980291f, 0.13653973f, 0.19534005f, 0.25625765f, 0.07614134f, 0.07351002f, 
    -0.00186925f, 0.40831178f, -0.46539167f, -1.09852660f, 0.04004756f, -0.06361769f, 0.03705194f, 0.14475785f, 
    0.03680683f, 0.09069484f, -0.34306222f, -0.10360271f, 0.19136971f, 0.04231820f, 0.12408420f, 0.03124542f, 
    -0.05042890f, 0.06950072f, -0.04705838f, 0.57945168f, -0.30613536f, -0.48230916f, 0.01812497f, 0.11240314f, 
    -0.02132768f, -0.25048575f, 0.16271353f, 0.07309914f, -0.10899022f, -0.12108524f, -0.08736031f, -0.28521925f, 
    -0.06783294f, 0.06825909f, 0.12671767f, 0.05438666f, 0.15594113f, -0.22277337f, 0.17249340f, 0.68512768f, 
    0.31992006f, -0.30032280f, -0.08253432f, -0.01213709f, -0.02081845f, -0.09366205f, -0.08938966f, 0.07699841f, 
    -0.04899053f, -0.19763823f, -0.00076657f, 0.00188554f, 0.40635309f, -0.07793876f, 0.08888805f, 0.04463768f, 
    0.35819525f, -0.03936397f, -0.27460739f, -0.22966342f, 0.00639966f, -0.10636555f, -0.10363878f, 0.31159657f, 
    0.13422523f, 0.46189755f, 0.14169280f, 0.29587618f, 0.20939051f, 0.13706933f, 0.06195374f, 0.06728356f, 
    0.15677227f, -0.41973847f, 0.21621032f, 0.23214516f, -0.17036572f, -0.01815897f, -0.12769096f, 0.01328988f, 
    0.13506036f, 0.23932399f, -0.85316777f, -0.67283338f, -0.49615502f, 0.00268896f, 0.02376310f, 0.00494729f, 
    0.10240366f, -0.11486964f, 0.12171075f, -0.16213247f, -0.02997067f, 0.21646167f, 0.32436734f, -0.09584907f, 
    -0.25786191f, 0.40558252f, -0.02015909f, -0.12729903f, -0.09237942f, 0.12286025f, -0.14172943f, -0.12612531f, 
    -0.09156645f, -0.06973097f, -0.01634702f, -0.15532614f, 0.22600897f, -0.91943240f, -0.66873825f, -0.03139324f, 
    0.27400163f, 0.16107401f, -0.05531423f, -0.09263264f, 0.04041986f, 0.20518886f, 0.12617090f, 0.31983769f, 
    -0.09531055f, -0.03882688f, -0.26514950f, 0.06396408f, 0.00038628f, 0.04124427f, -0.01948444f, 0.22408603f, 
    -0.12575831f, 0.12864654f, 0.04566004f, -0.16072606f, -0.27431640f, 0.04863621f, -0.16826701f, -0.14185388f, 
    0.16425328f, 0.27715132f, -0.18099141f, 0.29017210f, -0.13958725f, 0.25425717f, 0.09092671f, 0.03787600f, 
    -0.03432986f, 0.71010095f, 0.52008259f, -0.13006571f, -0.09750327f, -0.00078575f, 0.15518038f, -0.03040924f, 
    -0.01078067f, -0.12083187f, 0.11365429f, -0.02689274f, -0.05579344f, 0.09341853f, -0.13118316f, -0.09565777f, 
    0.04223685f, 0.01307169f, -0.19479944f, -0.11152083f, -0.21853860f, -0.09801767f, 0.12819207f, 0.06962108f, 
    0.16935062f, 0.21494901f, -0.08264269f, -0.23119770f, 0.09743073f, 0.13634416f, -0.19755550f, -0.17372902f, 
    -0.28286740f, -0.21071315f, -0.11870487f, -0.19115908f, -0.18684541f, -0.25679433f, -0.15253884f, 0.20431538f, 
    -0.01643608f, -0.22795859f, 0.19426768f, -0.24963076f, 0.19376227f, -0.30848494f, -0.04728379f, 0.06315850f, 
    -0.33229220f, -0.09257181f, 0.00045987f, 0.07259817f, 0.32651654f, 0.09929549f, 0.04771264f, 0.28775468f, 
    -0.00376359f, 0.00808546f, 0.17848510f, 0.17442463f, 0.09955885f, 0.13747177f, 0.06110875f, 0.28717551f, 
    0.20526803f, -0.10399172f, -0.14380394f, -0.07546709f, -0.18290436f, -0.11681571f, 0.05424250f, -0.02905785f, 
    0.07399864f, 0.15384087f, 0.11602083f, -0.04553465f, 0.00163942f, 0.06495560f, 0.11067894f, -0.06980740f, 
    0.04014216f, 0.15866189f, 0.60937923f, 0.66938955f, 0.20022158f, 0.03801342f, 0.01696426f, 0.24005052f, 
    0.07689810f, 0.03635142f, 0.13274944f, -0.11754293f, 0.03164503f, -0.39813501f, 0.08256445f, -0.21175045f, 
    0.08078871f, -0.25221950f, -0.18608052f, -0.30371153f, 0.24813859f, 0.07317863f, 0.11528727f, -0.10313318f, 
    0.00337058f, -0.23947443f, 0.17151642f, 0.14678280f, -0.08420470f, 0.30166247f, -0.91408157f, -0.27833727f, 
    -0.09187555f, 0.32387543f, 0.19009364f, 0.22038932f, 0.42571232f, 0.16041476f, 0.22891699f, 0.03258868f, 
    0.07374132f, 0.04655999f, 0.19465226f, 0.08478513f, 0.10650008f, -0.00266846f, 0.19005325f, 0.06144331f, 
    0.02288458f, 0.11838645f, 0.35164362f, 0.23302546f, 0.04484929f, 0.03036938f, -0.12110110f, -0.29861262f, 
    -0.42008537f, -0.82611972f, -1.16502070f, -0.00958136f, -0.07356340f, 0.15191574f, 0.05263220f, -0.11949336f, 
    -0.07117088f, -0.06719852f, -0.42352754f, -0.97512263f, -0.23199925f, -0.13984767f, 0.27927500f, -0.00028456f, 
    0.06758658f, 0.07878766f, 0.02706830f, -0.33511788f, -0.49433523f, 0.06365214f, 0.07104101f, 0.12409350f, 
    0.14027898f, 0.17918897f, 0.20988050f, 0.68048459f, 0.34683621f, 0.39534235f, -0.24336565f, -0.21416385f, 
    -0.03354168f, -0.06661054f, 0.25030792f, 0.12632592f, -0.46927992f, -0.58861977f, 0.33682063f, 0.18688574f, 
    0.24446166f, -0.19658142f, 0.13954888f, 0.14063935f, 0.19086041f, 0.32174066f, 0.68644094f, -0.16645734f, 
    -0.19354939f, 0.13473411f, 0.04772140f, 0.06971727f, -0.06500690f, -0.06444316f, 0.28874108f, -0.05867119f, 
    0.26571003f, -0.02081526f, -0.05804038f, 0.06371242f, 0.22020476f, 0.14363135f, 0.23177101f, -0.30203274f, 
    -0.08701563f, 0.06537058f, -0.09042512f, -0.01586732f, 0.01335312f, 0.02641331f, -0.09873819f, 0.20887692f, 
    0.20191132f, 0.21210963f, 0.03653217f, -0.10091680f, -0.00541380f, -0.16309838f, -0.20802392f, -0.14614762f, 
    -0.07352101f, 0.12010656f, -0.11142288f, -0.05677943f, -0.07868180f, 0.01877136f, 0.04389024f, -0.04321723f, 
    -0.09972877f, 0.24259013f, 0.58318883f, 0.26265723f, -0.08182368f, 0.06902035f, -0.49105173f, 0.03996264f, 
    -0.01379381f, -0.06045663f, -0.09742118f, -0.10280523f, 0.12069895f, 0.33473983f, 0.01932284f, 0.05104463f, 
    0.09325509f, 0.26334116f, 0.33565804f, 0.13418002f, 0.31668213f, 0.15479663f, -0.02767384f, -0.26275671f, 
    0.03546223f, -0.08663429f, -0.16495773f, -0.00527881f, -0.06492722f, -0.55890000f, -1.23405707f, 0.08810193f, 
    0.03813077f, 0.01057677f, -0.37908429f, -0.60649669f, -0.64257371f, -0.09667893f, 0.30991933f, 0.04081384f, 
    -0.21435231f, -0.24230784f, -0.02417539f, -0.11022300f, -0.31218332f, -0.12371951f, -0.10839795f, 0.56863773f, 
    0.18956649f, 0.41854045f, -0.12394620f, 0.00481622f, -0.25137496f, 0.12570725f, 0.13836376f, 0.00376144f, 
    0.11169080f, -0.24188319f, 0.42652845f, -0.05900418f, 0.09072538f, -0.13708185f, 0.05941140f, 0.06565642f, 
    0.17241968f, 0.11222400f, 0.22651519f, 0.56989163f, -0.04352988f, -0.09483128f, 0.02792436f, 0.14067353f, 
    0.04277740f, -0.04208288f, -0.09131207f, -0.38708740f, 0.01249507f, 0.00559792f, 0.02468807f, -0.02830974f, 
    0.00239439f, 0.11643966f, 0.36775857f, 0.03038140f, -0.28424659f, -0.48440328f, 0.17627499f, -0.21747743f, 
    0.39726809f, 0.18087266f, -0.15231885f, 0.04486434f, -0.12111495f, 0.02680233f, -0.11743658f, 0.03920980f, 
    -0.09561712f, 0.16033675f, -0.23939058f, 0.20393117f, 0.12614682f, -0.05865912f, -0.52774042f, -0.28794438f, 
    -0.03704686f, -0.14837916f, -0.29178387f, -0.07109373f, 0.18053304f, 0.28450722f, -0.45276451f, -0.37531602f, 
    -0.15713096f, -0.29097366f, -0.09674241f, 0.25709814f, 0.03028600f, 0.32229277f, 0.02453859f, -0.00726633f, 
    -0.24013618f, 0.20357510f, -0.37731573f, -0.11249071f, -0.05894217f, -0.12529916f, 0.00766858f, 0.30145696f, 
    -0.49190149f, 0.22668697f, 0.15319604f, -0.13651189f, -0.02058371f, -0.06702240f, 0.03346224f, -0.19234701f, 
    -0.23935418f, -0.14517626f, -0.14084244f, -0.29731029f, -0.02147247f, 0.01967069f, 0.00662606f, 0.18989587f, 
    -0.05626327f, 0.12047675f, -0.06636659f, 0.01256721f, 0.27532110f, -0.10512276f, 0.11072344f, -0.11178483f, 
    0.14147188f, 0.12876987f, -0.00229412f, 0.29416516f, -0.06327954f, 0.00436654f, -0.07236712f, 0.10890310f, 
    -0.03487832f, -0.10636823f, 0.12148051f, 0.34561414f, -0.18807475f, -0.34080580f, 0.31299779f, 0.06844835f, 
    -0.17389031f, 0.06179380f, 0.33131987f, 0.09976040f, 0.28356776f, -0.13987666f, 0.28989661f, 0.38839215f, 
    0.10884571f, 0.03040947f, -0.34321705f, -0.00317315f, -0.07364763f, -0.22358590f, -0.00370206f, 0.29918024f, 
    0.16539571f, -0.20439519f, -0.16558571f, -0.03138288f, 0.18582055f, 0.00143101f, 0.23347782f, -0.63124567f, 
    -0.37244776f, -0.38868836f, 0.12604702f, -0.03029986f, 0.22631413f, -0.01959637f, -0.12049673f, 0.02983655f, 
    0.36131665f, 0.43915278f, -0.13330126f, -0.02184759f, -0.21563302f, 0.06730856f, 0.00906219f, 0.10762385f, 
    0.03712775f, 0.61888039f, 0.30091062f, -0.10000000f, 0.13130964f, -0.05855128f, 0.15870491f, -0.08949511f, 
    -0.14530793f, -0.46537399f, 0.00636260f, 0.13737613f, 0.12973846f, 0.26296562f, 0.04114543f, 0.14568670f, 
    -0.03494081f, 0.28367490f, 0.32191449f, -0.48131540f, -0.08342255f, 0.11650149f, 0.16969123f, 0.12762442f, 
    0.17707463f, -0.18392435f, 0.45685092f, 0.19991484f, -0.00698260f, 0.08825295f, 0.26805705f, 0.07569026f, 
    0.23761989f, 0.08105963f, 0.26298860f, 0.08515624f, 0.19954705f, -0.07695974f, -0.80911708f, -0.60039490f, 
    -0.10688749f, 0.38727453f, 0.38709205f, 0.48457515f, -0.12286691f, -0.03782451f, -0.18594454f, -0.46986362f, 
    -0.30258420f, 0.03278909f, 0.12567376f, 0.12093512f, -0.18453044f, -0.33423385f, -0.43638697f, 0.04056778f, 
    -0.02749085f, 0.08426110f, 0.12169664f, 0.16782871f, 0.03667531f, 0.10269554f, -0.55677873f, -0.53443855f, 
    -0.20208916f, -0.02766013f, 0.11614992f, 0.07751134f, -0.10999611f, -0.21935743f, -0.11591601f, 0.02364666f, 
    0.07121117f, 0.05013146f, -0.01121714f, -0.03901317f, 0.08688183f, -0.07269495f, 0.17408520f, -0.04557614f, 
    -0.53049552f, -0.67685151f, 0.41128650f, 0.85753059f, 0.40096101f, 0.07926926f, 0.12094892f, 0.03277032f, 
    0.12833074f, 0.04866614f, -0.22712032f, 0.34599596f, 0.17841642f, -0.33606920f, -0.10074809f, -0.13365436f, 
    -0.34846726f, 0.19522557f, 0.27769738f, 0.23243378f, 0.24414700f, 0.01189930f, -0.04146553f, 0.01612961f, 
    0.04988740f, -0.04931587f, -0.04255106f, 0.14893837f, 0.15039352f, -0.19188212f, -0.75096911f, -0.31672120f, 
    0.36141217f, -0.23554555f, -0.19164734f, -0.20807609f, -0.18533069f, -0.21342504f, 0.16881990f, 0.10694258f, 
    0.03835514f, 0.00954744f, -0.18046987f, -0.06732970f, -0.07866269f, -0.26112315f, -0.00707007f, 0.05234880f, 
    -0.00388093f, -0.10414135f, -0.11846788f, 0.37947798f, 0.06344903f, 0.41691586f, -0.01232580f, 0.15789095f, 
    -0.06159831f, -0.03923220f, 0.00683856f, -0.06003008f, -0.01520406f, -0.04048352f, -0.00882320f, -0.02203208f, 
    -0.09124528f, -0.06360564f, -0.05132871f, -0.05394409f, 0.00179153f, 0.06094932f, 0.06211726f, -0.02244557f, 
    -0.08644132f, -0.05020808f, -0.06819460f, 0.01176488f, 0.06456333f, 0.03911336f, 0.00062580f, 0.01220413f, 
    -0.06530802f, 0.01528046f, 0.00560504f, 0.04877089f, 0.03596335f, -0.00998164f, -0.01327809f, -0.05412947f, 
    -0.01965912f, -0.03540668f, 0.04717733f, 0.06429243f, -0.01384008f, -0.09076335f, -0.02002351f, 0.07204417f, 
    -0.08139631f, 0.01054382f, -0.07279168f, -0.02419883f, -0.03502952f, -0.00944118f, -0.01634257f, -0.08207226f, 
    -0.06783906f, -0.00925264f, -0.01676939f, 0.02494605f, 0.06433706f, -0.00049659f, 0.06909754f, -0.06547035f, 
    0.05643332f, 0.02680509f, 0.03289923f, -0.09626582f, -0.09329874f, 0.03094539f, 0.02765484f, -0.02299549f, 
    -0.04819404f, -0.00461031f, 0.02974365f, -0.08728581f, -0.01650483f, -0.01994521f, 0.05826455f, -0.08707672f, 
    -0.04834273f, -0.00969017f, -0.09546503f, 0.04119613f, 0.02992298f, 0.03549991f, 0.02081103f, 0.00646246f, 
    -0.10064460f, -0.07331874f, -0.04976019f, 0.01590236f, 0.02056468f, -0.01976255f, -0.03655523f, -0.05144249f, 
    0.01150806f, 0.01798370f, 0.03978631f, 0.03264908f, -0.01342830f, -0.01283242f, 0.04368526f, -0.03826702f, 
    0.03697386f, -0.07450675f, 0.04752104f, -0.02943488f, 0.05127262f, 0.01162239f, -0.09214891f, 0.03090267f, 
    0.03219893f, -0.07667419f, 0.07010756f, -0.02983019f, 0.03936758f, 0.02635909f, 0.03567757f, -0.08276301f, 
    0.03141982f, -0.02381401f, -0.04387774f, 0.05964525f, 0.02197501f, -0.00142921f, 0.08201347f, 0.02398128f, 
    0.06684007f, 0.05237668f, 0.06210302f, -0.06940463f, -0.07414367f, 0.05844280f, -0.01402589f, 0.00662964f, 
    -0.00070126f, -0.08010805f, 0.05226403f, -0.00359156f, -0.02759560f, -0.05908012f, 0.03899426f, 0.03074975f, 
    -0.07108714f, -0.03222407f, -0.06992111f, -0.02210332f, 0.05607771f, -0.06785282f, 0.01641020f, -0.07922012f, 
    0.47809508f, 0.12538917f, -0.00007088f, -0.10510082f, -0.04388718f, -0.18882301f, -0.02073465f, -0.07862963f, 
    0.07831480f, -0.13920248f, -0.04567304f, -0.06260186f, -0.13909017f, -0.06089767f, -0.10563156f, 0.17669576f, 
    0.01387825f, 0.00475279f, 0.44332349f, 0.17749336f, -0.07416345f, -0.10589460f, -0.13367037f, -0.21313331f, 
    0.15892747f, 0.05908381f, -0.10829274f, 0.09014004f, -0.11799816f, 0.23723701f, 0.20873840f, 0.28015983f, 
    -0.00676218f, 0.23728405f, 0.11351977f, -0.12385795f, -0.02057418f, 0.27026975f, 0.11741625f, 0.12655795f, 
    0.10061046f, 0.04208337f, -0.16090383f, -0.15627442f, -0.21432121f, -0.52657658f, 0.56866795f, -0.33545974f, 
    -0.05471192f, -0.12312191f, 0.24530266f, 0.16763580f, -0.17141351f, -0.25843361f, -0.52876788f, -0.56632918f, 
    -0.20753442f, -0.18065029f, 0.21155682f, -0.34142011f, 0.13393526f, -0.16563737f, -0.00104285f, 0.18202832f, 
    0.27750045f, 0.19613247f, -0.63702065f, -0.00548328f, -0.04420051f, 0.07350343f, -0.00415093f, -0.01577291f, 
    0.11088868f, 0.38862932f, -0.05914765f, -0.33111525f, 0.09259245f, -0.13325724f, -0.04391111f, 0.02166143f, 
    -0.08795971f, 0.06735017f, -0.08340904f, 0.13948071f, 0.07379850f, -0.02468028f, 0.01415962f, -0.05899078f, 
    -0.25661388f, 0.14510444f, 0.31258598f, 0.54565477f, 0.46027458f, -0.24571851f, -0.11189670f, -0.08333112f, 
    0.07825354f, -0.02014590f, 0.10509422f, 0.06837261f, 0.00430676f, 0.26404849f, -0.15726846f, -0.11363438f, 
    -0.13806921f, 0.00476845f, -0.08318458f, 0.01972843f, 0.07470312f, 0.12036461f, 0.15754084f, -0.19302681f, 
    -0.30872041f, -0.21959411f, 0.16494097f, -0.00075267f, 0.03220534f, -0.44358072f, 0.78611434f, -0.26314238f, 
    -0.36225241f, -0.36934447f, -0.28091297f, 0.09832631f, 0.07085792f, 0.05981194f, 0.22829109f, 0.30825409f, 
    0.10335746f, -0.46650952f, -0.07317403f, -0.20588632f, 0.04805354f, -0.08851078f, 0.03431185f, -0.12647346f, 
    0.02231502f, 0.08715165f, 0.03099086f, 0.19928387f, 0.24539620f, -0.06919150f, -0.08934382f, 0.11518599f, 
    0.33055428f, -0.52099854f, 0.10021830f, 0.04456494f, 0.00047926f, 0.24640633f, 0.18005261f, 0.01163642f, 
    0.09871489f, 0.28095651f, -0.31694895f, -0.10240823f, 0.09170782f, 0.02551889f, 0.04444254f, 0.09239539f, 
    0.10693112f, 0.23731439f, 0.06405451f, -0.39656082f, -0.16344863f, -0.05794528f, 0.07943802f, -0.01732822f, 
    -0.17844707f, -0.57572603f, -0.39251053f, 0.22385617f, 0.39672661f, -0.22898430f, -0.06652798f, -0.33351704f, 
    0.07893215f, 0.07304960f, -0.07405230f, -0.15078017f, -0.14773427f, -0.05203428f, -0.24923544f, 0.33999568f, 
    0.00734537f, -0.04082881f, -0.14579158f, -0.36210340f, -0.36673847f, -0.04423158f, 0.13908066f, -0.09112988f, 
    0.21642014f, 0.40466952f, -0.04170896f, 0.07711466f, -0.20112014f, -0.15797630f, 0.32511210f, 0.48342022f, 
    -0.14404091f, 0.02632438f, 0.08766880f, -0.21592432f, 0.10748357f, 0.04496744f, -0.16709049f, 0.04051398f, 
    0.17310147f, -0.16915730f, 0.14039469f, -0.04093067f, 0.01090638f, 0.11809271f, 0.21896464f, -0.15441431f, 
    0.16451572f, 0.28476191f, -0.05541040f, 0.10084058f, -0.04894003f, 0.09007987f, 0.16174364f, -0.11884614f, 
    -0.18952054f, 0.05276777f, 0.07678202f, 0.54449677f, 0.06606202f, -0.06482196f, 0.05472127f, 0.20949233f, 
    0.22603203f, 0.06996448f, 0.02789103f, -0.27689859f, -0.25055259f, 0.18576549f, -0.01152052f, -0.05913418f, 
    0.02836981f, 0.05421402f, -0.03018289f, 0.13477388f, -0.10343328f, -0.05508802f, 0.13335787f, 0.32593319f, 
    0.12714837f, -0.09496640f, 0.35919341f, -0.06359463f, -0.08588251f, 0.04329139f, -0.29636374f, 0.00080741f, 
    0.04073080f, 0.24371505f, 0.03032221f, -0.38654041f, -0.12230537f, 0.10339244f, -0.37353185f, 0.05171476f, 
    -0.15639761f, 0.31977752f, 0.32526594f, 0.08476631f, 0.09045570f, -0.01663215f, -0.19727726f, 0.17916274f, 
    -0.35012525f, -0.03100147f, 0.08815503f, 0.09842923f, -0.05851875f, -0.12583260f, -0.19140257f, 0.15059976f, 
    0.20486772f, -0.44937634f, 0.14828511f, 0.20525143f, -0.23911282f, 0.39784428f, -0.00743971f, -0.19196670f, 
    -0.51878262f, -0.15007605f, 0.75746977f, 0.26570848f, 0.14554243f, -0.08054430f, -0.10484438f, 0.10974706f, 
    -0.01068026f, -0.70187980f, -0.15843020f, -0.17397575f, 0.01305265f, 0.01854039f, 0.04575644f, -0.14949666f, 
    -0.00497580f, 0.07979129f, 0.11191183f, 0.06054977f, 0.11461709f, -0.00985425f, -0.24732588f, -0.04446390f, 
    0.02564899f, -0.02969649f, 0.12206679f, -0.31846371f, 0.04190850f, -0.13213782f, 0.23153222f, -0.14341629f, 
    0.09416571f, 0.17653501f, -0.00916405f, 0.01514944f, 0.21064588f, 0.22251153f, 0.29520437f, -0.15161158f, 
    0.01940446f, 0.00024946f, 0.00428267f, 0.00240187f, -0.20101111f, -0.39806214f, 0.44643283f, -0.26350093f, 
    -0.07051227f, 0.04126756f, -0.02913322f, -0.06828215f, 0.17763987f, -0.11711372f, 0.39673117f, 0.03493005f, 
    -0.03425349f, -0.06900924f, -0.08608954f, -0.10044777f, -0.01497833f, 0.02782931f, 0.07262357f, 0.17266072f, 
    0.10481919f, -0.01943803f, -0.21014623f, -0.26182571f, -0.16881084f, -0.09299776f, 0.31284046f, 0.14001930f, 
    0.17993122f, 0.00239514f, 0.05609302f, -0.45070142f, -0.04209483f, 0.19908124f, -0.10434806f, 0.20100901f, 
    0.13007459f, 0.04908453f, -0.00390130f, 0.19183668f, -0.02863159f, 0.08313370f, -0.01124621f, 0.40142107f, 
    0.49620423f, 0.59063721f, -0.08085629f, -0.08703610f, 0.42934620f, -0.06438909f, -0.06105705f, -0.06872877f, 
    -0.08641721f, -0.05801289f, -0.30179003f, -0.21030608f, 0.20725247f, 0.11153004f, -0.04711781f, 0.11099207f, 
    -0.26381540f, 0.24515949f, 0.01861373f, 0.10123692f, 0.17301255f, 0.19003177f, -0.12101169f, -0.16523017f, 
    -0.20362131f, 0.24025173f, 0.35475916f, 0.09784634f, 0.04869822f, -0.19686586f, 0.20330104f, 0.52066445f, 
    -0.37526354f, -0.05008144f, -0.34287629f, -0.01357379f, 0.14498998f, 0.04586218f, 0.14986978f, 0.05409485f, 
    -0.07828825f, -0.06540588f, -0.31187853f, 0.23873840f, -0.00954163f, 0.32181215f, -0.02878941f, 0.07268204f, 
    0.01556392f, -0.17093588f, -0.03669066f, 0.16537063f, -0.18930821f, -0.03306594f, -0.01369764f, -0.23331404f, 
    0.07135384f, -0.07613545f, 0.03900972f, 0.01982035f, 0.04750002f, 0.00343356f, -0.08638823f, 0.07036998f, 
    -0.02624275f, -0.00299046f, -0.00106779f, -0.09037596f, 0.02280376f, -0.06530079f, -0.04396081f, 0.06634620f, 
    0.06395034f, -0.01790795f, 0.06969996f, -0.04308211f, 0.06221178f, -0.04087429f, 0.03284682f, -0.08057498f, 
    -0.02640346f, -0.04589621f, 0.07028838f, -0.06312444f, -0.04071916f, -0.01746726f, -0.04096594f, 0.01091808f, 
    0.01548528f, -0.02828301f, -0.02232278f, 0.03896608f, 0.04085347f, -0.06491058f, -0.00511757f, 0.04552115f, 
    0.03380426f, 0.04350089f, -0.07766550f, -0.03123585f, 0.07069381f, 0.01733226f, 0.01619436f, -0.06402579f, 
    -0.01513798f, 0.01772015f, 0.01946583f, 0.06645229f, -0.02200892f, -0.01290461f, 0.05785805f, 0.04555286f, 
    -0.02408537f, 0.01308039f, -0.02684019f, -0.03761850f, 0.06884377f, 0.01876231f, 0.00323507f, -0.05908389f, 
    -0.05483633f, -0.00926891f, -0.04846134f, -0.05402583f, -0.02604418f, -0.02765535f, -0.06794226f, 0.06191508f, 
    0.07520927f, -0.02547303f, -0.06680088f, -0.01675509f, 0.02454858f, -0.05344956f, -0.00329482f, -0.05781190f, 
    -0.03880998f, -0.06908274f, -0.05321053f, -0.03931106f, -0.04101719f, -0.05732231f, -0.02640208f, -0.04735582f, 
    -0.08062841f, 0.01938277f, -0.05460738f, -0.03808856f, 0.00330325f, -0.08074448f, -0.05026451f, -0.00286827f, 
    0.04947630f, -0.06662220f, -0.05286733f, -0.08244667f, 0.00786546f, 0.01630447f, 0.01520179f, 0.02318698f, 
    0.02305673f, -0.05168664f, 0.06040030f, 0.04477148f, -0.02477317f, -0.03689981f, -0.00428000f, 0.02303702f, 
    0.02405144f, 0.01227727f, 0.03019786f, -0.00082736f, -0.07675321f, 0.03370374f, 0.03290066f, 0.03815764f, 
    -0.02672297f, -0.08680586f, -0.05045803f, -0.05080258f, -0.00687116f, -0.06105497f, 0.03193142f, 0.01020387f, 
    0.02676524f, -0.08144248f, -0.05954197f, 0.00960193f, -0.08191417f, -0.06640729f, 0.04355948f, 0.01185730f, 
    -0.04400628f, -0.05469582f, 0.04832409f, -0.05694614f, -0.09183323f, 0.00388783f, -0.00101591f, -0.07406703f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.00910073f, 0.31826207f, 0.69712591f, 0.40292841f, 0.35472041f, 0.08650627f, 0.28239438f, -0.19673295f, 
    0.18217643f, 0.04612258f, -0.17590341f, -0.03034223f, -0.04895260f, 0.15938960f, 0.19191785f, -0.00393879f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.19372390f, -0.42804852f, -0.37861857f, 0.11808408f, 0.04162297f, -0.73920494f, 0.09327431f, 0.53505570f, 
    -0.39802217f, -0.30138806f, 0.45050389f, -0.24052361f, 0.33638507f, -0.22401258f, -0.40043274f, -0.21262039f, 
    -0.16818929f, 0.23388159f, -0.11768618f, 0.20761569f, 0.23058493f, 0.07575810f, -0.18751888f, -0.15469651f, 
    0.42012534f, 0.73539960f, 0.22333820f, 0.05633600f, -0.10779396f, -0.47741947f, -0.53004831f, -0.14245793f, 
    -0.35266238f, 0.19349572f, 0.25797838f, 0.83092785f, -0.41609365f, -0.52338552f, -0.43509573f, -0.19027026f, 
    -0.82513630f, 0.17515209f, -0.16108374f, -0.16175489f, -0.30488876f, 0.06561147f, 0.47015303f, 0.04082468f, 
    0.55167174f, -0.23759253f, -0.53149921f, -0.64141351f, -0.30949318f, -0.07674262f, -0.23494673f, 0.18301938f, 
    -0.53115469f, -0.32398713f, 0.04564242f, -0.02212871f, -0.29482698f, 0.35956588f, 0.43345490f, 0.12012374f, 
    -0.34818351f, -0.35739708f, -0.09104680f, -0.44290191f, -0.22605342f, 0.35719121f, -0.06755183f, -0.20199393f, 
    -0.04706255f, 0.30077246f, 0.25464067f, 0.00931364f, 0.72894919f, 0.11278286f, 0.27980673f, -0.00428787f, 
    -0.14422418f, 0.45411140f, -0.02484356f, -0.35345921f, -0.12003153f, 0.73593855f, -0.45404020f, -0.11461899f, 
    -0.07892784f, 0.06764192f, 0.26881492f, 0.00102350f, -0.05117728f, -0.45576659f, -0.00462503f, -0.14998187f, 
    -0.74082911f, -0.00657671f, 0.21470143f, 0.42800027f, 0.92612398f, -0.60774070f, 0.56362891f, -0.02846329f, 
    -0.80355048f, -0.73167682f, -0.53033322f, 0.06216563f, -0.86826605f, 0.06883479f, 0.24718468f, -0.16378509f, 
    0.11346071f, 0.10485842f, -0.69852918f, 0.08476122f, -0.48012704f, 0.23518440f, 0.12269108f, -0.23975481f, 
    0.56919914f, 0.27769735f, -0.12459999f, 0.16409397f, 0.28832689f, 0.12130185f, 0.33117574f, 0.18246575f, 
    0.24610737f, 0.13557476f, -0.14167388f, -0.52531832f, 0.12683734f, -0.02053693f, 0.86126977f, -0.81848508f, 
    -0.04926175f, 0.04852730f, 0.46274972f, 0.02567968f, -0.70685905f, -0.08270431f, -0.33976114f, -0.02295417f, 
    -0.21077694f, -0.54685766f, -0.12653242f, -0.09651706f, 0.71739388f, 0.21455240f, 0.22971453f, -0.10080775f, 
    -0.50413072f, 0.53715819f, -0.51068401f, -0.11086450f, 0.11981861f, 0.61135668f, 0.10176411f, 0.19084583f, 
    0.51078284f, 0.49834472f, 0.41088018f, 0.02741534f, -0.76103300f, -0.38017863f, 0.31748679f, -0.64020234f, 
    -1.14097345f, 0.29169112f, 0.04967050f, 0.03023886f, 0.45148680f, -0.83174866f, -0.47975498f, -0.23339584f, 
    0.33784711f, -0.49138278f, 0.67871118f, -0.24898179f, -0.16667190f, 0.08626671f, -0.44626197f, -0.08129770f, 
    0.18034793f, -0.85815197f, -0.31067076f, -0.09731779f, -0.71764773f, -0.06058783f, 0.08472538f, 0.02720658f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.82944447f, 0.34720600f, 0.65315562f, 0.10752481f, 0.15090837f, -0.21342371f, -0.46010846f, -0.76228130f, 
    -0.06199732f, 0.01409551f, 0.02840934f, 0.05300916f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
