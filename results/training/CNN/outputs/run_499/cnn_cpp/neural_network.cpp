#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.64330935f, -0.15633373f, 0.13914438f, 0.26624089f, 0.29770944f, -0.41355479f, -0.27165771f, -0.25135812f, 
    -0.48880842f, 0.30040288f, -0.22567637f, -0.20528831f, -0.19084823f, -0.46395084f, -0.31974161f, -0.49032199f, 
    -0.18432602f, 0.22641732f, 0.05917031f, -0.18308322f, 0.03822490f, -0.08724858f, -0.30296421f, -0.32730243f, 
    -0.17361434f, -0.63050377f, -0.46894544f, -0.58752441f, -0.59635282f, -0.32712692f, 0.49808496f, -0.14946735f, 
    -0.21669777f, -0.07720383f, 0.45434651f, 0.15182818f, 0.03526315f, -0.12639126f, 0.20137723f, 0.33680019f, 
    -0.02407358f, 0.18987654f, -0.07268269f, 0.29642379f, 0.28769234f, -0.01431060f, -0.10839287f, -0.09577642f, 
    -0.03918416f, 0.14579475f, -0.51435077f, -0.60326213f, -0.25663921f, -0.22941951f, 0.24196525f, -0.31491786f, 
    0.63741207f, 0.18402864f, 0.19972242f, 0.04417615f, 0.16319753f, -0.17453355f, -0.27999619f, -0.22844079f, 
    -0.16271162f, 0.17493829f, -0.10974059f, -0.24758162f, -0.32128713f, 0.19673763f, -0.01926972f, -0.01023768f, 
    0.15440586f, 0.45501131f, -0.09691539f, 0.51132786f, 0.39753571f, 0.65126956f, 0.38134122f, 0.57233161f, 
    0.40585032f, 0.14826609f, -0.15346040f, -0.52824926f, 0.06639463f, 0.36100680f, 0.29282182f, -0.07242483f, 
    0.15614247f, -0.01882134f, 0.32509255f, -0.18731561f, -0.31201717f, -0.02961850f, -0.22674063f, 0.20562580f, 
    -0.00255634f, 0.21913171f, -0.10388655f, 0.01786819f, 0.80024648f, 0.16973566f, -0.90815145f, -0.92350996f, 
    -0.28984693f, 0.33039722f, 0.15897751f, 0.02371261f, -0.18149401f, 0.12462990f, -0.35811189f, 0.10781264f, 
    -0.15497585f, 0.13491429f, -0.15986317f, -0.14109780f, -0.06911262f, 0.02159020f, 0.26495460f, 0.20571992f, 
    0.08262929f, -0.07700519f, -0.07027391f, -0.10963535f, 0.20528650f, -1.04887259f, 0.90367973f, -0.05305924f, 
    -0.45115569f, -0.09275825f, 0.24532229f, 0.13153756f, -0.25416911f, 0.43791789f, -0.34378576f, -0.24094653f, 
    0.07184125f, -0.33502728f, 0.08431324f, -0.13848516f, -0.34210798f, 0.01111721f, -0.14528908f, -0.03434729f, 
    -0.12473571f, -0.06094028f, -0.02117315f, -0.01726639f, 0.09627154f, -0.14946286f, -0.25644037f, 0.30738157f, 
    -0.42114377f, -0.65679926f, -0.35123676f, 0.68945557f, -0.59700894f, -0.08378825f, 0.54659438f, -0.46756169f, 
    -0.46282488f, -0.31142440f, -0.13930754f, 0.03397033f, -0.03318971f, 0.14698911f, 0.03693607f, -0.02702647f, 
    0.01916936f, -0.10336449f, 0.21357627f, -0.02139623f, 0.24052499f, 0.19973768f, 0.24032708f, 0.14552820f, 
    -0.08164611f, -0.25109491f, 0.41270214f, -0.23693328f, -0.08488758f, -0.59757453f, -0.10249016f, -0.43216118f, 
    -0.47262785f, -0.35358757f, 0.17264488f, 0.25981435f, 0.11454174f, -0.30695015f, -0.22948603f, -0.17851779f, 
    -0.50626546f, 0.18798782f, 0.24434283f, -0.03008347f, 0.10303243f, 0.08961049f, 0.16201900f, -0.03662963f, 
    -0.29422998f, 0.43494490f, 0.57240814f, -0.76115608f, -0.44566530f, -0.13858721f, -0.14457893f, -0.53922194f, 
    -0.34692183f, -0.12585904f, 0.04862697f, 0.42508447f, 0.33130741f, 0.00037219f, -0.05924736f, 0.14782067f, 
    -0.02449162f, -0.09574869f, 0.02578910f, -0.13543211f, 0.19825281f, 0.27181214f, -0.12264241f, 0.22569039f, 
    0.36429906f, 0.33635417f, -0.25100708f, -0.39883453f, -0.23107684f, -0.10349820f, -0.44219485f, -0.79057491f, 
    -0.24865410f, -0.09803120f, -0.39373073f, -0.07522179f, -0.16824938f, 0.47480762f, -0.08249063f, -0.26132214f, 
    -0.17038426f, 0.08862121f, -0.23365408f, 0.18796325f, -0.04456494f, -0.03194305f, -0.12031731f, 0.16441947f, 
    -0.11132088f, 0.14838818f, 0.66145295f, 0.40272671f, 0.30160493f, 0.76009488f, 0.54480803f, 0.36681029f, 
    -0.10729244f, 0.05339660f, 0.20170301f, 0.16725376f, -0.03712023f, 0.10086136f, -0.11235943f, -0.17497657f, 
    0.12246711f, 0.21943806f, -0.11441126f, 0.11028035f, -0.34188470f, 0.29375222f, -0.14778501f, -0.18165879f, 
    0.34368157f, -0.09037957f, 0.24616535f, -0.49235487f, -0.97666383f, -0.65059566f, 0.02844120f, 0.09289946f, 
    0.50761718f, 0.80123258f, 0.08528236f, 0.49032363f, 0.38374630f, -0.38056758f, -0.03854858f, -0.21163659f, 
    -0.09890458f, -0.09440853f, -0.10633410f, 0.06151685f, -0.14451705f, -0.01597696f, -0.14406213f, -0.12653829f, 
    -0.27090111f, -0.05264116f, -0.11366130f, 0.08259390f, -0.46681577f, 0.62177998f, 0.09370581f, 0.22729653f, 
    0.27419320f, 0.25033951f, 0.73597014f, 0.04451916f, 0.11523342f, 0.50729877f, -0.45599383f, -0.15951011f, 
    0.21612948f, -0.39137372f, 0.08350439f, -0.01140247f, -0.16535003f, -0.22999413f, -0.10305011f, -0.24138501f, 
    -0.19002731f, 0.07996644f, -0.16846164f, 0.17203166f, -0.14529367f, 0.16262820f, 0.44064003f, 0.06409728f, 
    0.50057113f, 0.69663805f, 0.41490027f, -0.21056053f, 0.33395600f, 0.09794585f, 0.18204048f, -0.33682188f, 
    -0.22713812f, -0.38178167f, -0.26814097f, 0.08936781f, 0.24905752f, 0.24591479f, -0.35644642f, 0.02248495f, 
    -0.06574313f, -0.26896936f, 0.10144421f, 0.02764066f, 0.35162374f, 0.04452983f, -0.58112794f, -0.35923368f, 
    0.43365562f, 0.40952456f, 0.48870191f, -0.27531943f, -0.32241783f, 0.46920186f, -0.25215223f, 0.09649589f, 
    0.34242788f, 0.01371517f, -0.01945451f, 0.25942510f, 0.13380654f, 0.33993489f, 0.14200687f, 0.10288838f, 
    0.34859678f, 0.34810951f, -0.11843470f, -0.00766777f, -0.15763742f, -0.00175966f, 0.18117130f, -0.72089958f, 
    0.77948684f, 0.01757176f, -0.20304240f, 0.51248753f, -0.49560425f, 0.00285991f, -0.44588873f, -0.13205756f, 
    -0.31245294f, 0.23193835f, -0.14903852f, -0.03205438f, -0.05785798f, -0.37279800f, 0.08858661f, 0.04987630f, 
    -0.34413892f, -0.22247811f, -0.04306223f, 0.00743957f, -0.12322532f, -0.05578595f, -0.17744803f, 0.12690583f, 
    -0.15002047f, -0.96377110f, -0.53606272f, 0.39742845f, -0.12888135f, -0.70502895f, 0.66679507f, 0.06189374f, 
    -0.69819587f, 0.35945204f, 0.42390832f, 0.07898331f, -0.03962738f, 0.10977600f, 0.24155124f, -0.27258110f, 
    -0.02259521f, 0.22458506f, -0.00507810f, -0.12747112f, 0.06155908f, -0.03596873f, -0.10256244f, -0.06412683f, 
    -0.04724065f, 0.83900023f, 0.23369087f, 0.69637489f, -0.15440316f, -0.46631733f, 0.02431878f, -0.33464438f, 
    -0.13457279f, 0.02082101f, 0.38678908f, -0.18498352f, -0.18950664f, -0.03207752f, -0.01869340f, -0.18984950f, 
    -0.06138173f, -0.02500497f, -0.00566037f, -0.29013976f, 0.19776092f, -0.17660417f, 0.28132698f, -0.21166751f, 
    -0.08586957f, -0.12298125f, -0.02821561f, 0.33239055f, -0.53946334f, -0.20330873f, 0.39953369f, -0.02450786f, 
    -0.27104971f, -0.77688920f, -0.49573025f, -0.02980849f, 0.34243855f, 0.19389473f, 0.09159645f, -0.35478446f, 
    0.07752201f, 0.30154249f, -0.09445827f, 0.09985726f, -0.17230080f, -0.24265496f, 0.11106893f, 0.21471873f, 
    -0.04280148f, 0.30491126f, -0.20730026f, -0.39842328f, -0.04881978f, -0.12037684f, 0.56478286f, 0.22583058f, 
    -0.14034444f, 0.35970443f, 0.44727704f, 0.16813824f, 0.52767509f, 0.18658659f, -0.47364005f, 0.32865942f, 
    -0.17705278f, -0.15497300f, -0.06602684f, -0.21264526f, -0.40921313f, 0.03561996f, -0.44568387f, 0.18903582f, 
    0.12936465f, -0.17105050f, 0.26393774f, 0.14826307f, 0.41462290f, 0.12384652f, 0.04665845f, 0.47478124f, 
    -0.33486822f, 0.26555577f, 0.67773181f, -0.10509101f, 0.05196922f, 0.14573056f, 0.44326511f, 0.20713720f, 
    -0.14931349f, -0.17176749f, -0.04883954f, -0.25788465f, -0.33700085f, -0.21116829f, 0.20242956f, -0.01054092f, 
    0.05434074f, 0.16368152f, 0.25286162f, 0.19694716f, 0.09421928f, 0.35290712f, 0.70981091f, -0.19960293f, 
    -0.21989226f, 0.07842536f, -0.21275988f, 0.08765801f, 0.08836687f, -0.26038280f, -0.63531607f, -0.06874972f, 
    -0.27701575f, -0.26335198f, 0.09906861f, 0.34943783f, 0.14845817f, 0.14292686f, 0.21478426f, 0.13394849f, 
    0.46844712f, -0.19758338f, -0.27233341f, -0.22999208f, -0.22811589f, 0.25323316f, -0.59912694f, -0.33158648f, 
    -0.55517191f, -0.50459999f, -0.15019374f, -0.31498468f, -0.07819009f, 0.41288853f, 0.08758693f, 0.07331012f, 
    -0.05568564f, 0.07147759f, -0.05570103f, 0.09828338f, 0.31086144f, 0.07557479f, 0.05358182f, -0.06324169f, 
    0.26470298f, -0.11840358f, 0.20170194f, -0.27101889f, 0.31730551f, -0.26116541f, -0.00477120f, 0.27094495f, 
    0.06312314f, -0.48542491f, -0.51819319f, -0.40017885f, 0.30675805f, -0.19909680f, 0.47903118f, 0.54198968f, 
    0.00703689f, -0.19715318f, 0.19153266f, -0.10444979f, -0.16102916f, 0.06485078f, 0.30191281f, -0.14480244f, 
    -0.30090067f, -0.17115499f, 0.09669882f, -0.18412976f, -0.14104369f, -0.17509535f, -0.18100582f, -0.38092485f, 
    0.02718795f, 0.22813047f, 0.25770891f, 0.33498424f, 0.10391474f, 0.24210480f, -0.72006160f, -0.62560087f, 
    -0.73055017f, -0.29924715f, 0.32899955f, -0.04333296f, 0.23410019f, -0.02346304f, 0.17457116f, -0.10258184f, 
    0.06851687f, 0.34431964f, 0.07766089f, 0.39524299f, 0.14909139f, 0.02181112f, 0.15350564f, 0.34231940f, 
    -0.20170486f, -0.60084933f, -0.43175375f, -0.02927433f, 0.13966659f, -0.43976623f, 0.13530485f, 0.48228604f, 
    0.20988412f, 0.54144335f, -0.08188456f, 0.15095346f, 0.34465900f, 0.21025702f, 0.09319364f, -0.55932295f, 
    -0.29420969f, 0.02976929f, 0.00720393f, 0.13090432f, -0.00163217f, 0.18729655f, -0.08674914f, 0.26857948f, 
    -0.07934053f, 0.06898387f, -0.43660584f, 0.70268077f, -0.48702627f, -0.77278167f, -0.22328754f, 0.07229572f, 
    0.50736594f, -0.48530120f, 0.24688756f, 0.51300246f, 0.34542078f, -0.18073823f, -0.12299532f, -0.31351390f, 
    0.04885229f, 0.08457111f, -0.18574372f, 0.13558793f, -0.05552346f, -0.29350129f, -0.26300558f, 0.06616077f, 
    0.26043084f, 0.30883515f, 0.28789949f, 0.41666493f, 0.46890420f, 0.58199209f, 0.42018625f, 0.36510453f, 
    -0.28947860f, -0.10182299f, -0.22542204f, -0.45987561f, -0.33003753f, 0.04735260f, 0.48965788f, 0.30826065f, 
    0.31704190f, 0.15474205f, -0.26034322f, 0.40656376f, 0.24882442f, -0.07805978f, -0.22876716f, 0.00679726f, 
    0.01188171f, -0.13484365f, -0.15554880f, 0.02477189f, 0.12278166f, -0.18158548f, 0.07945045f, 0.45919639f, 
    -0.25482550f, 0.07860969f, -0.84350777f, 0.06402328f, 0.16127695f, -0.21237150f, 0.06030954f, 0.16122141f, 
    0.35708174f, -0.22849309f, 0.15876372f, -0.05341282f, -0.29580519f, 0.44786599f, 0.31774473f, -0.12308601f, 
    -0.08179284f, 0.37787858f, -0.35225561f, -0.00534956f, -0.04862805f, 0.97608674f, 0.61450827f, 0.58049697f, 
    0.36235768f, 0.40169176f, -0.57817352f, 0.29856771f, -0.36591741f, -0.04011410f, 0.03512878f, 0.13315901f, 
    0.01909856f, -0.00776508f, 0.00184917f, -0.01925541f, -0.01033781f, -0.01802920f, 0.25888795f, 0.13132834f, 
    -0.07520957f, 0.01393298f, 0.04390422f, -0.05722347f, 0.03983694f, 0.16204762f, 0.52511877f, -0.43317595f, 
    -0.36571455f, 0.07963214f, 0.23244429f, -0.43078375f, 0.00214267f, 0.19170509f, -0.42537227f, -0.42158803f, 
    -0.69102383f, -0.06992600f, -0.22663060f, -0.39567152f, -0.09746902f, -0.16977994f, -0.13156664f, -0.01844701f, 
    0.12254941f, -0.18355033f, 0.04261732f, -0.09979648f, -0.19585833f, 0.03053511f, -0.00067246f, 0.37132996f, 
    0.20144762f, -0.41969982f, -0.02104267f, 0.47816217f, -0.38950253f, -0.80562109f, 0.26563382f, -0.03272230f, 
    0.32303411f, -0.35367990f, -0.47001624f, -0.05567301f, -0.38015071f, -0.46714714f, 0.01967526f, -0.14160751f, 
    -0.00903623f, -0.01783123f, -0.21814063f, 0.28593576f, 0.28036216f, -0.17500781f, -0.07832228f, -0.19842787f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.09591109f, 0.05056968f, 0.04734562f, 0.28897542f, 0.09562852f, 0.08565383f, 0.20053232f, 0.06063803f, 
    0.13704593f, 0.23248172f, 0.14824457f, 0.16069221f, -0.11250155f, 0.04625085f, 0.09971363f, 0.24324216f, 
    0.00471770f, -0.03306923f, 0.35799712f, 0.26965597f, 0.31038764f, 0.06766525f, 0.27285498f, -0.04525794f, 
    0.15856148f, 0.26640865f, 0.08625221f, 0.14498669f, 0.18049392f, -0.00439010f, -0.13178849f, 0.18153334f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.34563136f, 0.07901909f, 0.07130987f, -0.08616207f, -0.05137157f, 0.01817856f, 0.04223898f, -0.07226067f, 
    -0.02946717f, -0.14852893f, -0.03063287f, -0.02110047f, -0.25274783f, 0.10688040f, 0.17269710f, -0.10441656f, 
    -0.01850026f, 0.03807685f, 0.03393748f, 0.07728819f, 0.02230713f, 0.02549567f, 0.08952896f, 0.04907159f, 
    0.16557255f, -0.02310494f, 0.14852878f, -0.04020071f, 0.04368373f, 0.00713374f, -0.11119945f, -0.07378397f, 
    0.06550611f, -0.03087013f, -0.09760560f, -0.01443495f, 0.03261232f, 0.24972536f, -0.10634100f, -0.12935826f, 
    0.00861631f, 0.10127998f, 0.03470452f, 0.00135422f, 0.00862661f, 0.02126097f, 0.05969373f, -0.00640577f, 
    0.09904059f, 0.26585802f, 0.10417183f, -0.13786560f, 0.06953348f, 0.13360465f, -0.04801110f, 0.11059068f, 
    -0.02026873f, 0.01329671f, 0.06298015f, -0.00741653f, -0.47070777f, -0.44528413f, 0.02067873f, 0.09161658f, 
    0.12819095f, 0.00524485f, 0.10592130f, -0.05823855f, -0.00472219f, 0.12630804f, -0.01619703f, 0.02336455f, 
    -0.28589103f, 0.05460141f, 0.23247956f, -0.04806762f, -0.03962058f, -0.00524493f, -0.05262449f, -0.01979031f, 
    0.19068208f, 0.02931454f, 0.01798172f, 0.11895768f, -0.20703638f, 0.04734245f, -0.00874359f, -0.03742446f, 
    -0.05807917f, 0.10628239f, 0.09915497f, -0.01762121f, 0.00065081f, 0.13391611f, -0.00488121f, -0.08109784f, 
    -0.01471603f, 0.05394918f, 0.04229291f, -0.13425921f, 0.06025648f, 0.01310102f, 0.06960368f, 0.02244907f, 
    -0.06385071f, 0.02542245f, 0.10653730f, 0.10111879f, -0.22563943f, -0.05638388f, 0.11448590f, -0.20956813f, 
    0.08708497f, 0.06998268f, 0.07579874f, 0.11211247f, -0.11141326f, -0.10704873f, -0.03158408f, 0.01938367f, 
    -0.11304921f, 0.11084680f, 0.05139716f, 0.05629543f, 0.01384324f, -0.04937349f, -0.01181247f, -0.04841270f, 
    0.11954679f, 0.13541518f, 0.02743096f, 0.03570038f, 0.19357616f, -0.08190534f, 0.09865374f, -0.03714942f, 
    0.13976219f, 0.07160472f, -0.05019986f, 0.08151174f, 0.10589226f, 0.03496096f, -0.03186590f, 0.06418731f, 
    0.37799290f, -0.05472492f, 0.18366656f, -0.02890513f, -0.00380092f, 0.13579434f, 0.07248615f, -0.08915470f, 
    0.10424908f, 0.06333394f, 0.07517762f, 0.00074811f, -0.02788423f, 0.09682334f, 0.07239384f, -0.01727667f, 
    0.04289520f, 0.03486243f, 0.00058509f, -0.08740453f, 0.00554121f, 0.02715546f, 0.02421341f, 0.02725962f, 
    0.21023849f, -0.01431075f, 0.10904195f, -0.08719216f, 0.03165828f, 0.06097694f, -0.04850708f, 0.02786044f, 
    0.06181013f, -0.05507046f, 0.00987871f, 0.14320736f, -0.03361892f, -0.14432572f, -0.16528378f, -0.12545756f, 
    -0.12336610f, -0.04049853f, -0.05015145f, -0.06587262f, 0.05510456f, 0.01368180f, 0.04963601f, 0.03138372f, 
    0.34250137f, 0.03014459f, 0.00082659f, 0.02054409f, -0.04609571f, 0.09363918f, 0.05574173f, 0.08953648f, 
    -0.02947338f, 0.02213325f, 0.18391955f, 0.03987163f, 0.06502502f, 0.09633502f, 0.08418730f, 0.08673921f, 
    0.04562147f, -0.11997125f, -0.02382336f, -0.12786008f, -0.09377754f, -0.10461804f, 0.00802667f, -0.00196166f, 
    -0.10830352f, 0.13315339f, -0.16252510f, -0.20553710f, -0.07635167f, 0.14377314f, 0.11074803f, 0.04205079f, 
    0.08186331f, -0.03000662f, 0.11161915f, -0.02559836f, 0.25198138f, -0.11023235f, 0.10580181f, 0.29224131f, 
    -0.11987933f, 0.01442533f, 0.05556833f, 0.05560334f, 0.06438993f, 0.04130518f, 0.09310922f, 0.02365845f, 
    0.15665424f, 0.04782444f, -0.03331213f, 0.08559875f, 0.02451823f, 0.05369726f, 0.00777862f, -0.00599316f, 
    0.00398847f, 0.12128409f, 0.00464542f, 0.05937014f, -0.04641107f, -0.04504490f, -0.14027104f, 0.07479039f, 
    -0.05296585f, 0.14086083f, -0.08660080f, 0.05497533f, 0.06719793f, 0.13278581f, -0.02170997f, 0.04123867f, 
    -0.02375366f, -0.09808589f, 0.10633815f, 0.05685255f, 0.07153847f, 0.02815047f, -0.01083205f, 0.01755319f, 
    0.09715068f, 0.00108496f, 0.00647385f, -0.02141340f, -0.02355904f, 0.13538000f, 0.05582653f, -0.08851928f, 
    0.08642574f, -0.12319912f, -0.02744966f, 0.12095428f, 0.09362332f, -0.03971078f, 0.05739530f, -0.00884106f, 
    -0.09756643f, 0.20837544f, -0.08665643f, -0.16136940f, 0.02680148f, -0.02377998f, 0.01950435f, 0.02254825f, 
    -0.00543069f, 0.06071159f, -0.03762638f, 0.00422127f, 0.11526615f, -0.15862304f, 0.02112280f, 0.21345316f, 
    0.08599409f, -0.10706365f, -0.01617888f, -0.00347704f, 0.00304863f, -0.05775505f, -0.06743462f, 0.03835307f, 
    0.07109708f, -0.07997070f, 0.05438830f, -0.07782716f, -0.00909544f, -0.01951350f, -0.03979155f, 0.04718591f, 
    0.00239430f, 0.06744766f, 0.15775721f, -0.04328930f, 0.13941427f, 0.18135265f, -0.15153818f, -0.19786222f, 
    0.04156079f, -0.05646760f, -0.01593333f, 0.05717300f, 0.06227284f, 0.13343875f, 0.15687917f, 0.02837691f, 
    -0.12261071f, 0.09288771f, 0.14533028f, 0.04965222f, -0.02936138f, -0.02246240f, 0.12678161f, -0.08407896f, 
    0.01273299f, 0.20539400f, 0.08425643f, 0.01748937f, 0.03081818f, 0.05708308f, 0.02429491f, 0.05572455f, 
    0.04773141f, -0.07528727f, -0.06412588f, -0.03600559f, -0.12960044f, -0.04684342f, -0.00944849f, 0.03147873f, 
    0.03618569f, 0.07251385f, -0.22333412f, -0.04567689f, -0.10471290f, 0.05125432f, 0.05482293f, 0.09681320f, 
    0.00321865f, 0.02498408f, -0.10260814f, 0.01514298f, -0.10432515f, 0.03499679f, 0.24637808f, -0.11318432f, 
    -0.07589944f, 0.10023455f, 0.11329012f, 0.18543808f, 0.04121101f, -0.07900887f, 0.03535676f, 0.02252584f, 
    0.16033965f, -0.05427250f, 0.00065119f, 0.01612418f, -0.06445017f, 0.04456984f, -0.03224356f, -0.11069934f, 
    0.00951142f, 0.03204575f, 0.02962550f, 0.01724597f, 0.27358103f, 0.15671472f, 0.13380502f, 0.17645368f, 
    0.02600756f, 0.00271000f, 0.02009570f, -0.05225552f, -0.07010690f, -0.03625986f, 0.05506077f, -0.12222692f, 
    0.04406070f, 0.09317038f, 0.14053473f, 0.09104447f, 0.06534641f, 0.09032901f, -0.03732318f, -0.02923903f, 
    0.00298282f, 0.08808707f, 0.21742897f, -0.06291168f, 0.10488030f, -0.13440795f, -0.27310774f, -0.13994133f, 
    0.11203307f, -0.00274226f, 0.04193380f, -0.12306564f, -0.03841170f, 0.02000675f, 0.10272034f, -0.06997602f, 
    -0.10471854f, 0.11526448f, -0.14767674f, 0.24734597f, -0.08598877f, 0.09452967f, 0.01458490f, -0.10097227f, 
    0.02938936f, 0.07860593f, -0.05837898f, 0.06655362f, -0.16148791f, 0.17998713f, -0.21268240f, -0.04757037f, 
    0.08498893f, 0.01162048f, 0.01086861f, -0.04904824f, -0.10170761f, -0.04742356f, -0.05859062f, 0.11874755f, 
    0.18896109f, 0.15886562f, -0.23053418f, 0.26017806f, 0.12143207f, 0.03213324f, 0.01338621f, 0.06148013f, 
    -0.14362037f, -0.02981515f, -0.07529708f, -0.04678951f, 0.01254972f, 0.18496700f, 0.06893019f, 0.00028036f, 
    -0.01929628f, 0.08439906f, 0.03738433f, 0.02425204f, 0.00944497f, 0.01516537f, -0.04894072f, -0.00401965f, 
    0.39742440f, -0.05947380f, -0.04722522f, 0.09476623f, -0.02718074f, 0.08770521f, -0.01191419f, 0.12153142f, 
    0.04606369f, -0.06553333f, -0.04689723f, 0.01332609f, 0.13936934f, 0.28436586f, -0.14714979f, -0.01557050f, 
    0.10210968f, 0.02992276f, -0.09520835f, -0.00950067f, 0.07159451f, 0.10311610f, 0.00343888f, -0.10175941f, 
    -0.11738898f, -0.03111447f, -0.13116889f, -0.14172123f, 0.12170897f, 0.02371162f, 0.00629852f, -0.02232183f, 
    -0.08971445f, -0.06796762f, 0.12332942f, 0.05079857f, 0.05068327f, -0.00100566f, 0.19209540f, 0.13416582f, 
    0.00465751f, -0.09128906f, 0.04194914f, 0.18764623f, -0.07653399f, -0.06502237f, 0.06754800f, 0.10540751f, 
    0.00088015f, -0.05745682f, -0.11779730f, -0.14120913f, 0.07766636f, -0.02668287f, -0.08118404f, 0.16888461f, 
    0.02761584f, 0.04075607f, -0.03349343f, 0.05005329f, -0.09307316f, -0.11077152f, -0.18067157f, -0.21614815f, 
    0.12452158f, 0.08333173f, 0.06615511f, 0.03548484f, -0.04134718f, -0.04115128f, 0.02031689f, 0.00486926f, 
    0.13182022f, 0.01228374f, -0.13383161f, -0.01480107f, -0.06809040f, -0.02070564f, -0.01656936f, 0.00275044f, 
    -0.13173895f, -0.06940590f, -0.06920236f, -0.14821878f, 0.01624785f, -0.16008136f, -0.03160018f, 0.09545051f, 
    -0.03823652f, 0.03100426f, -0.01134420f, 0.04098713f, -0.07325947f, -0.01003863f, 0.00845403f, 0.07102425f, 
    0.57685947f, 0.23770140f, 0.24244134f, 0.02613713f, 0.02032441f, 0.06342711f, 0.08058217f, -0.09354875f, 
    -0.07760273f, 0.02896941f, 0.04623808f, -0.06340932f, -0.13264668f, -0.06461760f, 0.13908267f, -0.27790406f, 
    -0.06217892f, 0.03956626f, 0.04118479f, -0.08189595f, 0.03488005f, 0.08345435f, 0.12388074f, 0.06878713f, 
    -0.06890268f, 0.00411374f, -0.27376175f, -0.01799967f, 0.02249536f, -0.02851410f, -0.09723435f, 0.04096136f, 
    0.00435667f, -0.04719621f, -0.01613223f, -0.04131068f, -0.06254704f, -0.18388858f, -0.05803457f, -0.12074009f, 
    0.04830286f, -0.02956152f, -0.05847665f, -0.07002249f, 0.08461450f, 0.11135600f, 0.02668858f, 0.00776447f, 
    0.10601798f, -0.08956195f, 0.00276803f, -0.07562681f, 0.04770669f, 0.08946791f, -0.01685092f, 0.00841251f, 
    0.03635845f, -0.01198382f, 0.05229582f, 0.14679609f, -0.07784862f, -0.14450495f, -0.02926371f, 0.10346522f, 
    0.10147797f, 0.03106801f, 0.02575605f, -0.08169613f, -0.11558144f, -0.13627371f, -0.15470110f, -0.06019883f, 
    0.14053400f, 0.20180842f, 0.18771528f, 0.15530340f, -0.02810853f, 0.01588047f, 0.06898961f, -0.13896497f, 
    -0.08893927f, 0.00622847f, -0.02439701f, -0.05166838f, -0.09224262f, 0.19904245f, 0.00429139f, 0.24554035f, 
    0.03480146f, 0.03457863f, 0.00501389f, 0.13020717f, 0.06793123f, -0.03232725f, 0.03977744f, -0.10028498f, 
    -0.09786523f, -0.01314895f, -0.09465285f, 0.20273711f, -0.03558026f, -0.12197593f, -0.07886107f, -0.07580511f, 
    -0.00993678f, -0.07691140f, -0.06009172f, -0.09783977f, 0.05512403f, -0.03284072f, 0.17054963f, 0.04394481f, 
    0.02322182f, 0.03813934f, -0.00354745f, -0.01490853f, 0.06972907f, 0.10211302f, -0.02086758f, 0.06669398f, 
    -0.13401866f, 0.18639666f, 0.07502659f, 0.34116393f, 0.03825789f, -0.00162144f, -0.01397730f, 0.13144968f, 
    0.03187596f, 0.11768614f, 0.09012368f, 0.02420378f, -0.11150774f, -0.01269544f, -0.08543052f, 0.02422366f, 
    0.03612035f, -0.07194988f, -0.03288030f, -0.07502336f, 0.01005845f, 0.08444054f, -0.08221816f, -0.12281011f, 
    0.00239662f, 0.12902044f, 0.01603488f, -0.02214689f, 0.02908915f, -0.04805995f, 0.06845967f, -0.02868937f, 
    0.18508600f, -0.00505414f, 0.02382909f, -0.04157874f, -0.06973595f, 0.03900537f, -0.33550128f, -0.17081843f, 
    0.19614956f, 0.02918140f, 0.04260958f, -0.04705067f, -0.04834122f, 0.02076913f, -0.06254032f, 0.00502275f, 
    0.07209647f, 0.11438704f, 0.16549896f, 0.09464657f, 0.09765182f, -0.09896171f, -0.00296104f, 0.12322251f, 
    0.06361917f, -0.03663604f, -0.05570211f, 0.00329746f, 0.13695565f, 0.29366332f, -0.16521765f, 0.00508297f, 
    0.04098344f, -0.09621318f, -0.00340571f, 0.03147725f, -0.00192116f, -0.03493049f, 0.00636604f, 0.13788675f, 
    -0.17808077f, 0.14183284f, 0.07727232f, 0.02530213f, -0.13740385f, 0.01963232f, 0.15321615f, -0.03500854f, 
    -0.02621271f, 0.00492797f, 0.16587541f, 0.14824404f, 0.15615037f, -0.37580267f, -0.01088160f, -0.15643375f, 
    0.06491568f, -0.05493110f, -0.05251361f, -0.03204190f, 0.12030526f, -0.05672526f, 0.04722025f, -0.06037642f, 
    -0.14451464f, 0.11361311f, 0.04101902f, -0.00640023f, 0.10088445f, -0.11928306f, -0.10600175f, 0.09406810f, 
    0.00861588f, 0.10363337f, 0.17933261f, -0.18670566f, 0.32356468f, 0.05798673f, -0.25550520f, -0.26302293f, 
    0.12167903f, 0.14045830f, -0.00190435f, 0.00745422f, -0.00915374f, 0.00944601f, 0.02101299f, 0.06342747f, 
    -0.16498834f, 0.40438595f, 0.01844157f, 0.30259269f, -0.02223693f, -0.01342077f, -0.11316713f, -0.02192516f, 
    0.06243115f, 0.05681320f, -0.07110126f, 0.14683785f, -0.34137037f, -0.47367409f, 0.23496552f, 0.22806990f, 
    -0.03647266f, 0.08490700f, -0.09737361f, 0.00214273f, -0.09610854f, -0.01489118f, 0.16035745f, 0.18573122f, 
    0.13962813f, -0.09251229f, 0.13325298f, 0.12475749f, 0.05015920f, 0.04045499f, -0.11189030f, 0.12315247f, 
    -0.11660399f, 0.03277520f, 0.07101442f, 0.04151884f, -0.04678713f, 0.21347237f, 0.03367658f, 0.06776037f, 
    -0.03889250f, 0.05729180f, 0.00147046f, 0.06170099f, 0.02833334f, 0.02171523f, -0.00813541f, 0.17698523f, 
    0.23116802f, -0.10072465f, 0.21257952f, 0.01882725f, -0.06447901f, 0.03283161f, -0.03905005f, -0.06881844f, 
    -0.12806250f, -0.09558446f, -0.10751751f, 0.15300076f, -0.10431208f, 0.25366542f, 0.01671055f, 0.07838853f, 
    -0.10044788f, 0.09748714f, 0.01179553f, -0.02891045f, 0.05548244f, -0.01574729f, 0.03642261f, 0.01713207f, 
    -0.04210253f, 0.02184909f, -0.19037431f, -0.16051295f, 0.24007531f, 0.00650674f, -0.04998927f, 0.00546701f, 
    0.08339044f, -0.05330893f, 0.03337742f, -0.08689966f, -0.05323288f, -0.06420779f, -0.06402965f, -0.08462607f, 
    0.12539274f, 0.00215052f, 0.10540882f, 0.07167285f, 0.04079764f, 0.12784477f, 0.12149411f, -0.01764502f, 
    0.16272622f, -0.29427809f, 0.15065141f, -0.17120196f, 0.21798655f, 0.02565811f, 0.07566339f, -0.00227084f, 
    0.13082382f, -0.03064426f, -0.03096207f, 0.10670612f, -0.02808590f, -0.08937342f, -0.08787253f, -0.29462063f, 
    0.20516424f, -0.02429317f, -0.05948438f, -0.01975849f, -0.05921635f, -0.00381958f, 0.06159512f, -0.03123688f, 
    0.09584136f, 0.10359371f, 0.11237711f, -0.00579168f, 0.04797426f, 0.10426223f, 0.14178064f, 0.16397539f, 
    0.05924745f, -0.10955477f, 0.17816564f, -0.02805274f, -0.02387796f, -0.39825994f, 0.01522305f, -0.13837031f, 
    -0.16801105f, -0.03874843f, 0.00281776f, 0.12290566f, 0.02889308f, -0.06681634f, 0.13302585f, 0.06423675f, 
    -0.18859108f, 0.13161899f, -0.14688620f, 0.08373691f, 0.20650735f, -0.02655710f, -0.03991236f, -0.12159945f, 
    0.08122171f, 0.00803672f, 0.03234817f, -0.10286190f, 0.49557739f, 0.09116159f, 0.05932226f, -0.16013174f, 
    -0.03918949f, -0.01355597f, -0.04250563f, -0.05583471f, 0.04971725f, 0.02409358f, 0.01451272f, 0.17675808f, 
    -0.04411437f, -0.06850869f, 0.02780598f, 0.19378604f, -0.01701891f, 0.02734043f, 0.12806310f, 0.17655845f, 
    -0.00672146f, 0.08598913f, 0.11436471f, -0.04562011f, -0.18018061f, -0.01593896f, 0.02599532f, -0.13604139f, 
    -0.05610037f, -0.04136960f, 0.05108733f, 0.13435592f, 0.05372743f, 0.11594434f, -0.01968134f, 0.04375690f, 
    -0.09310845f, 0.06155088f, -0.05808957f, 0.00140542f, 0.16209401f, 0.06741629f, -0.03723939f, 0.01365510f, 
    0.04473438f, -0.03230831f, -0.01814404f, -0.01863215f, 0.04974839f, -0.15239900f, 0.20190006f, 0.04643367f, 
    -0.12626854f, -0.02480504f, 0.02965613f, 0.13730112f, 0.12782599f, -0.01727049f, 0.00618226f, -0.16081041f, 
    -0.03827694f, -0.04278971f, -0.05631862f, 0.02280164f, 0.03726556f, -0.00693375f, -0.09171649f, -0.01558225f, 
    0.05924883f, 0.04159513f, 0.01937831f, -0.09230523f, 0.09712210f, 0.10016912f, -0.00543265f, 0.14190644f, 
    0.12215108f, -0.06075807f, -0.02177225f, 0.17485611f, 0.01461304f, 0.03594632f, 0.09822426f, -0.08020671f, 
    0.09145772f, 0.11393026f, -0.13992530f, -0.09930087f, 0.06401243f, 0.00154546f, -0.08249728f, 0.01101504f, 
    0.09102807f, -0.08616926f, -0.14532244f, -0.02823995f, -0.06967288f, 0.03453800f, -0.00470711f, 0.02980488f, 
    0.16427223f, 0.06723013f, -0.08305573f, -0.13615274f, 0.13702440f, 0.01388024f, -0.15954891f, -0.09478266f, 
    0.42843157f, -0.40422094f, 0.31765088f, 0.00838090f, 0.11927886f, -0.01354171f, -0.05946095f, 0.09290732f, 
    -0.02858279f, 0.14984241f, 0.08867072f, -0.09949650f, 0.26972625f, 0.07998750f, -0.26997477f, -0.16708399f, 
    0.01264252f, 0.02718681f, 0.04438144f, 0.03993632f, 0.04726344f, 0.14661780f, -0.03678601f, -0.04500160f, 
    0.12270851f, 0.12551597f, -0.03628758f, 0.01744330f, 0.05776659f, 0.09621533f, 0.19628696f, -0.09628434f, 
    0.00249902f, 0.09354857f, -0.06736481f, -0.06124069f, 0.19832215f, 0.08844820f, -0.24301320f, -0.25129208f, 
    0.19008413f, -0.01173468f, -0.05484480f, 0.01731821f, -0.00655632f, 0.03489023f, -0.22171457f, 0.01656827f, 
    -0.10272197f, 0.22069481f, -0.41740835f, 0.21534558f, -0.06070657f, -0.13715807f, 0.13356778f, -0.06762084f, 
    0.10268985f, 0.06137154f, 0.07844111f, 0.20958909f, 0.02436885f, 0.31665325f, -0.22157748f, 0.02719929f, 
    0.04702692f, 0.06832819f, 0.14242983f, -0.14204220f, 0.06749950f, 0.10992628f, 0.07229741f, 0.14190947f, 
    0.23625126f, -0.06009680f, 0.04985483f, -0.03383984f, -0.11368120f, -0.08489127f, 0.03920453f, -0.09703717f, 
    -0.06678651f, 0.19847548f, 0.06471837f, 0.22068001f, 0.51954764f, -0.05333947f, -0.03728958f, -0.07500196f, 
    0.06400853f, -0.05938942f, 0.07456281f, 0.09927204f, -0.03392341f, -0.25434032f, -0.02977049f, -0.05156650f, 
    0.29861444f, -0.15333217f, -0.12629177f, 0.17647351f, 0.04424869f, 0.04311110f, -0.15714833f, 0.18596663f, 
    -0.17766565f, -0.07624686f, 0.37667391f, -0.11128801f, 0.02540017f, 0.08469883f, -0.16708380f, -0.24010621f, 
    0.21358377f, -0.03033779f, -0.02186477f, -0.07820604f, 0.02384730f, -0.00296910f, 0.28662062f, -0.05060618f, 
    -0.41946346f, 0.21682858f, 0.05922794f, 0.54184121f, 0.02367426f, -0.03113326f, 0.19529791f, -0.09374810f, 
    -0.05618412f, -0.14072430f, -0.04571811f, 0.10944604f, 0.28669384f, -0.19261149f, -0.24195878f, -0.15458672f, 
    -0.02912061f, 0.08664690f, 0.02853401f, -0.13439140f, -0.09856185f, 0.01774121f, 0.02615090f, 0.27678975f, 
    -0.08775724f, 0.02996209f, -0.06749284f, 0.22988778f, 0.00384931f, -0.05842749f, -0.02611123f, 0.01876952f, 
    -0.21484388f, 0.02121641f, 0.02805110f, 0.01251290f, -0.21918967f, 0.21506736f, -0.05881625f, -0.02964767f, 
    0.04390725f, 0.17057994f, -0.16218017f, -0.01521369f, 0.10015359f, -0.00907520f, 0.11076961f, 0.17745976f, 
    0.31279132f, -0.26668337f, -0.00911181f, -0.24405257f, -0.05384755f, 0.02942039f, 0.08064207f, -0.07627323f, 
    -0.07904005f, -0.00504243f, -0.24845420f, -0.03353232f, -0.13560741f, 0.22138661f, -0.03967400f, -0.06483643f, 
    0.02563968f, 0.11860614f, 0.03186417f, 0.00362627f, 0.14730532f, 0.06757051f, -0.10397476f, 0.08630399f, 
    -0.16296116f, 0.14606214f, -0.06141168f, -0.24958235f, 0.04483754f, 0.01935374f, -0.03961393f, 0.05870999f, 
    0.06242003f, 0.04557814f, 0.10016130f, -0.06681043f, 0.01213311f, -0.30799380f, 0.03741063f, 0.27244511f, 
    -0.08447737f, -0.05860934f, 0.01494270f, 0.26602712f, 0.05266410f, 0.03446843f, 0.13420540f, 0.22385468f, 
    0.31575182f, -0.32095182f, -0.12380424f, -0.11717385f, 0.21860525f, 0.14094478f, 0.05160724f, 0.12803556f, 
    0.01933499f, 0.01848836f, 0.07675280f, 0.17339276f, -0.00275040f, -0.02289279f, -0.33510813f, -0.20337145f, 
    0.10398639f, 0.07834956f, -0.13979025f, 0.09446912f, 0.08534915f, -0.03351108f, 0.08345452f, -0.04499870f, 
    0.31387287f, 0.19815537f, -0.07973817f, 0.01622521f, 0.02923059f, 0.01336219f, 0.04484008f, 0.24786118f, 
    0.15479249f, -0.19333774f, -0.08329703f, -0.28627816f, 0.20708431f, -0.04151345f, 0.01812572f, -0.27497551f, 
    -0.11281685f, -0.03301262f, 0.00271410f, 0.03639123f, 0.15532768f, -0.06730182f, 0.12703674f, -0.11976914f, 
    0.55513924f, 0.01209309f, -0.00467287f, -0.03539553f, 0.00075561f, 0.02519197f, 0.01465919f, -0.03091315f, 
    -0.04192233f, 0.04935649f, 0.02615018f, -0.08077380f, -0.28566372f, 0.13952044f, 0.17002428f, -0.15028608f, 
    -0.02313947f, 0.31978193f, 0.04354141f, 0.00435148f, 0.08133923f, 0.00801077f, -0.03904419f, 0.12810510f, 
    0.08835714f, -0.02459554f, -0.11731245f, -0.06067341f, 0.09846646f, 0.01889578f, 0.06844077f, -0.04957970f, 
    -0.03933069f, -0.08177345f, -0.00076278f, -0.07478337f, 0.16581312f, -0.28352302f, 0.05980040f, -0.01239525f, 
    -0.00798451f, -0.18362196f, 0.05569587f, 0.04471573f, -0.01887354f, 0.17739230f, 0.12361296f, 0.06567658f, 
    -0.03808500f, 0.09774210f, -0.01370772f, -0.11054803f, 0.14130811f, 0.12364834f, -0.01393366f, 0.00028699f, 
    0.07274574f, 0.08396590f, 0.08867506f, 0.10917493f, 0.06457656f, -0.04402836f, 0.03173574f, 0.10143504f, 
    -0.04569446f, -0.08585433f, 0.02233415f, 0.02924088f, 0.03978805f, -0.36363149f, -0.09988791f, -0.16668692f, 
    0.23705052f, 0.11779552f, -0.17725822f, 0.26297456f, -0.04239439f, 0.02162852f, 0.04477306f, 0.11392725f, 
    -0.03808253f, -0.23515479f, -0.05634236f, -0.10818563f, -0.41383168f, 0.01639174f, 0.12774581f, 0.33640799f, 
    0.06438956f, 0.09724393f, 0.04834421f, 0.42776221f, 0.15690467f, -0.04272604f, 0.22829291f, -0.18668881f, 
    0.07142921f, 0.26777205f, 0.04819226f, -0.27576721f, 0.06219006f, 0.15307793f, -0.07866853f, 0.08375580f, 
    -0.05970635f, -0.11441381f, -0.15684731f, -0.01667699f, 0.23930369f, 0.01834777f, 0.15143766f, -0.05145610f, 
    0.04063157f, 0.10853764f, -0.11916978f, -0.01149633f, -0.07601704f, 0.06385022f, -0.06985971f, -0.06146635f, 
    0.10124846f, -0.22144537f, 0.14636371f, 0.14856905f, -0.03621970f, 0.04042464f, -0.11972140f, 0.06991995f, 
    -0.08169191f, 0.14626452f, 0.06571011f, -0.04023477f, -0.10505550f, 0.13211040f, 0.03435415f, -0.21238412f, 
    0.03219112f, -0.03441802f, -0.01167478f, 0.03704918f, 0.21818186f, 0.11021489f, -0.17067669f, -0.17421681f, 
    -0.17140785f, 0.19296142f, 0.10927196f, 0.07929660f, 0.10537077f, 0.07326250f, 0.18302071f, -0.02523433f, 
    0.03990000f, 0.03262135f, -0.15120704f, -0.04804233f, -0.27145225f, 0.29844210f, 0.07369682f, -0.19975403f, 
    0.07394711f, 0.02344001f, -0.07644044f, -0.02363607f, 0.11403693f, 0.10485379f, -0.19681555f, -0.04328409f, 
    0.07273103f, 0.13580504f, -0.19284254f, -0.06670116f, 0.09529608f, -0.30189618f, 0.02832925f, 0.03202417f, 
    0.03346897f, 0.10316432f, 0.07228106f, 0.18209639f, -0.18417536f, 0.27220309f, -0.12144805f, 0.01845286f, 
    -0.07511110f, -0.04036908f, 0.06473800f, -0.17342219f, -0.19097182f, 0.15666892f, 0.06977104f, 0.12373777f, 
    0.00406140f, -0.08118545f, 0.11697134f, -0.00199891f, 0.07782848f, 0.14791386f, 0.10000109f, 0.04646033f, 
    -0.02866655f, 0.02964926f, 0.09562032f, 0.05181077f, -0.27688450f, 0.12527129f, -0.03361207f, 0.07948935f, 
    0.20702599f, 0.02819180f, 0.05839954f, 0.00104226f, 0.13011813f, 0.10350267f, 0.14701301f, 0.05946884f, 
    0.00565636f, -0.20884672f, -0.05513908f, 0.05078315f, 0.20597434f, 0.10530270f, 0.18004170f, 0.08536784f, 
    -0.00942790f, -0.04919382f, -0.08092288f, 0.07670546f, -0.09044593f, 0.27087182f, 0.15836993f, -0.02955562f, 
    -0.06862570f, 0.07665811f, -0.03908559f, 0.00309449f, -0.04088036f, -0.00202467f, -0.06124696f, 0.05849682f, 
    0.13773042f, 0.05795868f, 0.11159065f, 0.11443572f, 0.12148826f, -0.00152458f, -0.06290714f, 0.14025000f, 
    0.12080061f, 0.07017443f, 0.06432416f, 0.02741382f, 0.24200796f, -0.28800741f, 0.33499759f, 0.15075222f, 
    0.18366785f, -0.10936628f, 0.11111289f, 0.06739254f, -0.01838886f, 0.05266671f, 0.15846159f, 0.06315472f, 
    0.03212563f, 0.12167358f, 0.17916872f, 0.04508437f, -0.00076712f, -0.03520685f, 0.09674212f, 0.09279715f, 
    0.07255015f, -0.04212118f, -0.00805969f, 0.13626356f, -0.06410198f, -0.01360231f, -0.00015825f, 0.09810471f, 
    -0.04383711f, -0.05586628f, 0.01719446f, 0.00724571f, -0.04339486f, 0.01459052f, 0.13269487f, 0.01202033f, 
    -0.09471426f, -0.02367711f, 0.11852366f, 0.05016434f, 0.08971845f, -0.09302063f, -0.04621392f, -0.06909725f, 
    -0.09544004f, -0.02505114f, 0.12399580f, 0.03078224f, -0.01178440f, -0.10510378f, 0.04658159f, 0.15124278f, 
    -0.11360393f, 0.03290119f, -0.00948060f, -0.01662285f, -0.00986080f, -0.08401670f, 0.00953118f, 0.10231072f, 
    -0.11676813f, 0.34817442f, 0.13051049f, 0.03377389f, -0.04359557f, -0.01750703f, 0.06774630f, -0.04228157f, 
    0.07120743f, -0.05951393f, -0.00168217f, -0.06916946f, -0.43549427f, -0.06655852f, 0.01332342f, -0.07479433f, 
    0.14474341f, 0.11121092f, -0.03715866f, -0.09471782f, 0.06347425f, 0.14468369f, 0.13032927f, 0.11691390f, 
    0.07241326f, 0.06818777f, 0.20536815f, 0.04590481f, -0.03097758f, 0.04268027f, 0.05311834f, -0.01051402f, 
    0.05151598f, 0.08438049f, 0.01260400f, 0.02582033f, 0.19913244f, 0.31535399f, 0.13118671f, 0.08781517f, 
    -0.00665433f, -0.04690091f, 0.03515806f, -0.10980532f, 0.03995260f, 0.11466028f, -0.02530202f, 0.06144233f, 
    0.18793038f, -0.25851536f, 0.15468493f, -0.23243003f, 0.05330417f, -0.03611461f, 0.03140876f, -0.02215573f, 
    0.18609866f, 0.10276142f, 0.00291090f, -0.02776839f, -0.14729176f, -0.03910530f, 0.18693860f, 0.02985687f, 
    0.02403671f, -0.13060574f, 0.05141319f, 0.00926479f, 0.07869710f, 0.04945023f, 0.01838714f, -0.03703059f, 
    -0.46227089f, -0.17612895f, 0.09646031f, -0.18801512f, 0.07409780f, -0.05389509f, 0.00129774f, 0.16269308f, 
    0.10311848f, 0.05923938f, 0.09362533f, -0.11987083f, 0.22970474f, 0.08967869f, 0.02667136f, 0.12316148f, 
    0.02370982f, 0.03633836f, 0.03793001f, -0.03528066f, -0.01719612f, -0.00122397f, -0.00245148f, -0.04226947f, 
    -0.28189874f, 0.19482823f, 0.15929438f, 0.13895321f, -0.00559962f, -0.01374886f, -0.08910345f, 0.05576007f, 
    0.01153082f, 0.05921796f, 0.07081185f, 0.05603310f, -0.05312155f, -0.12766443f, 0.09090727f, -0.17554434f, 
    -0.08347319f, -0.04524727f, 0.08386552f, -0.04902469f, -0.06480037f, -0.15121540f, 0.10380501f, 0.06619111f, 
    -0.22113551f, 0.26122838f, 0.05891817f, 0.02154109f, -0.10932658f, -0.03063522f, 0.02546592f, -0.05981477f, 
    0.03221743f, 0.03523175f, 0.03359622f, -0.07863434f, 0.14679959f, 0.06801420f, 0.10868022f, 0.05432546f, 
    -0.04492942f, -0.08652948f, 0.03503381f, 0.04904915f, 0.14236574f, -0.00517683f, 0.05504381f, -0.02725798f, 
    -0.21583401f, -0.12744471f, -0.06233629f, 0.14924979f, 0.20670216f, 0.03416252f, -0.01307531f, 0.11488242f, 
    0.10180108f, -0.00209509f, 0.00276084f, -0.02406653f, 0.14443637f, 0.12405620f, -0.00730949f, 0.19925368f, 
    -0.03306135f, -0.01330302f, -0.04772110f, 0.09692524f, 0.06444680f, 0.12541731f, -0.03132460f, 0.07619271f, 
    -0.19386840f, 0.08941941f, 0.02649884f, -0.22251309f, -0.14121073f, 0.03531690f, -0.03551778f, 0.08269356f, 
    -0.03206614f, -0.04294499f, 0.03078614f, -0.04123981f, 0.03490703f, -0.05432947f, 0.05886646f, 0.09120008f, 
    0.16696203f, -0.01534745f, 0.06110003f, 0.00296177f, -0.02401021f, -0.02860519f, -0.00883384f, 0.04256113f, 
    -0.12292138f, 0.00368543f, -0.00046203f, -0.02127115f, 0.16315031f, -0.10644425f, 0.03772176f, 0.02699474f, 
    -0.04352681f, 0.01393108f, 0.06051289f, -0.00063328f, 0.11531498f, -0.00740407f, 0.13757315f, -0.12328823f, 
    0.05429053f, 0.01606757f, 0.03171274f, 0.05081737f, -0.11946317f, 0.01012727f, 0.04644958f, 0.06962535f, 
    0.05556743f, 0.00313734f, -0.07473534f, -0.00912945f, -0.04452236f, 0.01106704f, 0.05903623f, 0.09816196f, 
    -0.11142066f, -0.01108853f, 0.04395059f, -0.09976321f, -0.02157261f, 0.05791230f, 0.32186291f, -0.02527681f, 
    -0.07259140f, -0.06945390f, -0.01068776f, 0.00945855f, 0.00483737f, -0.06921595f, 0.04696650f, -0.05405208f, 
    0.38036066f, 0.07306440f, -0.06928533f, 0.03391182f, -0.09994273f, -0.02197719f, 0.16989297f, 0.00561320f, 
    -0.10174410f, 0.08411732f, 0.03732786f, -0.05572886f, -0.00853255f, -0.22114784f, 0.16490924f, -0.01845844f, 
    -0.10535748f, 0.12686618f, -0.02427546f, 0.02997052f, -0.12661757f, 0.11906988f, -0.03442274f, 0.00530964f, 
    0.09824683f, -0.16846736f, -0.05280918f, 0.05104053f, 0.06896565f, -0.00423076f, -0.01349900f, 0.08555683f, 
    -0.06793737f, 0.04739482f, -0.07275732f, 0.05732098f, 0.35909021f, 0.19194697f, 0.00563465f, 0.30786794f, 
    -0.00346715f, -0.00163239f, 0.03613523f, 0.06422900f, -0.12137292f, -0.01208333f, -0.00595273f, -0.05543298f, 
    0.07089718f, 0.00451520f, 0.02041745f, 0.08300923f, -0.07451653f, 0.07383487f, -0.00266407f, 0.06173809f, 
    -0.01177899f, 0.06741564f, 0.25554302f, 0.08893953f, -0.11760744f, -0.19433530f, 0.02579916f, -0.03392472f, 
    -0.03582092f, -0.14534363f, 0.10558780f, -0.01305483f, 0.03019488f, 0.02085218f, 0.10388130f, -0.12798268f, 
    -0.07523485f, -0.22176570f, -0.10122723f, 0.10179632f, 0.04618671f, 0.04209787f, 0.26916519f, -0.16394004f, 
    -0.02564499f, 0.02052837f, 0.02946685f, -0.13106991f, 0.20701405f, 0.45461062f, -0.17210484f, -0.20920067f, 
    0.00484055f, 0.05832274f, 0.05117493f, 0.07294142f, 0.04584555f, -0.03151296f, -0.10181411f, 0.03946424f, 
    0.17552722f, 0.19178623f, -0.26459506f, 0.17096499f, -0.00408757f, -0.03025899f, 0.03149124f, 0.02123539f, 
    -0.10984502f, 0.03274635f, -0.05452127f, -0.03443307f, 0.03250889f, 0.02145154f, 0.07133371f, -0.04139768f, 
    0.04680865f, 0.06708699f, -0.03967690f, 0.02533587f, 0.08645630f, 0.02668840f, -0.04551589f, -0.06008279f, 
    0.13637894f, -0.25101155f, -0.05984216f, 0.05584710f, 0.00246839f, 0.08018947f, 0.04732215f, 0.17690730f, 
    0.21255349f, 0.11269294f, -0.03731587f, -0.13293365f, 0.21310672f, 0.05509967f, -0.11271923f, -0.00804120f, 
    0.01825360f, 0.06413865f, -0.05490953f, 0.01791655f, 0.08785134f, 0.16092451f, 0.00594864f, 0.00496547f, 
    -0.00150437f, -0.07546710f, -0.04340339f, -0.08925786f, -0.15138857f, 0.00096507f, 0.04241332f, 0.06937665f, 
    -0.09282468f, -0.06038028f, 0.14365406f, -0.00432938f, 0.03430247f, -0.06496686f, 0.11448546f, 0.21323685f, 
    -0.16326176f, -0.01590375f, -0.06403586f, 0.10941537f, -0.10744654f, -0.02472910f, 0.04687488f, 0.08953270f, 
    -0.27701819f, 0.07167660f, -0.14820574f, -0.03205852f, -0.02006645f, -0.00028602f, -0.02382401f, 0.17225169f, 
    0.02178458f, -0.03903722f, 0.02731830f, -0.00212636f, -0.00042559f, -0.04946849f, -0.11600951f, -0.12237364f, 
    -0.08267155f, 0.11181575f, 0.05087586f, 0.16827005f, 0.03322022f, 0.01678037f, 0.02106665f, -0.06122842f, 
    -0.04857214f, 0.09067758f, -0.28165674f, 0.02969730f, -0.10383373f, -0.07302366f, -0.02416048f, 0.01480518f, 
    -0.02208403f, -0.02879871f, -0.15496545f, -0.15801045f, 0.01724984f, 0.10727439f, 0.10950079f, 0.16744037f, 
    0.12988520f, 0.06293028f, 0.10005987f, 0.05701896f, -0.02052087f, -0.01168442f, 0.05582668f, -0.02375680f, 
    0.43612599f, 0.14705168f, 0.20358688f, 0.06785166f, -0.07055216f, 0.13488981f, 0.07218741f, -0.01839967f, 
    -0.03958919f, -0.01231370f, -0.13812102f, 0.03006052f, -0.42400232f, -0.03787162f, 0.01875635f, -0.17455682f, 
    -0.02806697f, 0.09485567f, 0.02232068f, 0.09879810f, 0.09820290f, 0.02191900f, 0.08422545f, -0.01005484f, 
    0.04409260f, -0.13746759f, -0.12884718f, -0.02618325f, 0.10507494f, -0.06774052f, -0.11070856f, -0.04033257f, 
    0.04197454f, -0.08489510f, -0.01733938f, 0.06354146f, -0.07099629f, -0.07547645f, -0.01627545f, -0.02694475f, 
    0.04296674f, -0.01195557f, -0.02448365f, -0.08048186f, -0.01176396f, -0.03427792f, 0.00888767f, -0.08109305f, 
    0.04614260f, -0.03940733f, 0.13668029f, -0.10884163f, -0.07239236f, -0.00867187f, 0.09749663f, -0.07186520f, 
    -0.02006571f, 0.02715997f, 0.03760008f, -0.04340488f, -0.12901461f, 0.02886412f, -0.04988950f, -0.03205877f, 
    0.17696778f, -0.12258272f, 0.07906932f, -0.09624484f, -0.00323829f, -0.18391198f, -0.04938194f, -0.02588417f, 
    0.25250086f, 0.21159682f, 0.15121303f, 0.10114786f, -0.03614799f, -0.00561446f, 0.01705459f, 0.03183771f, 
    -0.05363379f, -0.05783757f, 0.05278688f, 0.04741072f, -0.06813630f, 0.00357898f, 0.00584150f, 0.20433429f, 
    -0.01860097f, 0.16608664f, 0.09726973f, -0.01957159f, 0.00529054f, 0.03345752f, -0.00052459f, 0.02699128f, 
    -0.15413040f, -0.15705319f, 0.00944891f, 0.16553113f, -0.00099557f, -0.02943620f, -0.02951545f, 0.00874744f, 
    0.02083988f, 0.03602932f, 0.09062134f, -0.04146298f, 0.02861697f, 0.16360070f, 0.10866018f, -0.03093131f, 
    -0.15128645f, 0.05540989f, 0.02674221f, 0.00538628f, -0.01954458f, 0.12654205f, 0.05759539f, -0.03250216f, 
    -0.23976725f, 0.26207051f, -0.06129101f, 0.17368042f, -0.03222893f, 0.03287414f, -0.04355486f, 0.00095744f, 
    0.03677332f, -0.01411198f, -0.01906451f, 0.03736448f, -0.25650883f, -0.08951306f, 0.10442464f, 0.14232261f, 
    0.03017790f, -0.05657648f, -0.09115352f, -0.03178087f, 0.08041345f, 0.05149661f, -0.10675120f, -0.10842993f, 
    -0.06410921f, 0.06974509f, 0.05060249f, -0.01901519f, 0.04431796f, 0.02330704f, -0.00374030f, -0.01929106f, 
    0.13929658f, -0.07306653f, -0.11871938f, 0.05204660f, -0.07414001f, 0.14453347f, 0.00092264f, -0.18200013f, 
    0.00091813f, -0.03138376f, 0.09031282f, 0.04177865f, 0.14939763f, 0.12218852f, -0.04092833f, -0.00342904f, 
    0.14988929f, -0.10580531f, 0.31077057f, 0.02269297f, 0.18563181f, 0.00372710f, -0.06520329f, 0.07106877f, 
    -0.02492713f, -0.12717743f, -0.02490680f, 0.03947983f, 0.07829142f, 0.01926199f, -0.08397981f, 0.11746944f, 
    0.03161900f, -0.08493982f, 0.00960873f, -0.07850203f, -0.06250336f, -0.06418914f, -0.00503593f, 0.07644805f, 
    -0.33708104f, -0.00645722f, 0.14549099f, 0.23917627f, -0.09183609f, -0.02284397f, -0.00663071f, 0.04213214f, 
    0.09612727f, 0.05893189f, 0.03969474f, 0.13972305f, 0.24362586f, 0.03869608f, -0.08499933f, -0.00015933f, 
    0.00587399f, -0.08903480f, -0.07327282f, -0.03118019f, 0.10181770f, -0.04013442f, -0.01241024f, 0.08796687f, 
    -0.09140982f, 0.31279278f, 0.05303096f, 0.07079221f, -0.09442928f, 0.00721729f, 0.04149392f, 0.04973119f, 
    0.02704203f, 0.12447678f, 0.08245646f, 0.03901711f, -0.12085146f, -0.16279252f, 0.07554376f, 0.04199691f, 
    -0.06766111f, -0.04298243f, -0.05106435f, 0.02076751f, -0.10043742f, -0.05558779f, -0.00540588f, 0.07628241f, 
    -0.05313828f, -0.12091343f, 0.16882752f, -0.13497187f, 0.00256598f, -0.02140941f, -0.04336781f, 0.07253758f, 
    -0.15804154f, 0.11964239f, -0.02527711f, 0.11401346f, 0.43255410f, 0.46853513f, 0.14813645f, -0.06475230f, 
    0.10168508f, 0.02508553f, 0.08298125f, 0.01120524f, -0.03331149f, -0.17637002f, 0.04545253f, -0.02567132f, 
    0.32551244f, 0.07673965f, 0.04286312f, -0.19375153f, 0.06306769f, 0.02267468f, 0.11952882f, 0.09938657f, 
    -0.15000597f, 0.00934162f, 0.08613823f, 0.08102529f, 0.31363770f, -0.00664278f, 0.02666846f, 0.18014944f, 
    0.01126716f, -0.03089856f, 0.00226768f, 0.00836403f, 0.01745707f, -0.07180054f, -0.05076460f, 0.04140765f, 
    -0.01791752f, 0.07612612f, 0.27034047f, -0.09076723f, 0.09246999f, 0.07007712f, 0.10599937f, 0.02560481f, 
    -0.08618842f, 0.07104342f, -0.05054305f, -0.09961933f, 0.21276142f, 0.01231506f, 0.19098823f, 0.12340471f, 
    -0.10124096f, 0.08302169f, 0.00255093f, -0.04794319f, -0.01353319f, 0.03775469f, -0.03524092f, 0.01157351f, 
    -0.00949101f, -0.16825391f, -0.15114965f, 0.19815882f, -0.06552915f, 0.03859773f, -0.01239276f, 0.10083540f, 
    -0.04981701f, -0.06624216f, -0.01090932f, -0.04203002f, -0.08147929f, 0.32480276f, 0.04036349f, 0.04758047f, 
    0.04098117f, -0.00712825f, 0.09360717f, -0.07313945f, 0.04348752f, 0.01363291f, 0.12376556f, -0.01272685f, 
    -0.10554869f, 0.13807541f, 0.10149679f, 0.12458061f, -0.09925763f, -0.01872126f, -0.04320504f, -0.04207737f, 
    0.08585088f, 0.04544812f, -0.06268866f, -0.00968444f, 0.08022850f, -0.14054233f, 0.05067319f, 0.21947864f, 
    -0.15549435f, -0.04891281f, 0.03164839f, 0.09617996f, -0.00140224f, 0.04139818f, 0.09311407f, 0.04202354f, 
    -0.16795026f, -0.03918084f, 0.00367847f, 0.09003133f, 0.00264698f, 0.04869314f, 0.09004010f, -0.07770361f, 
    0.07682245f, -0.02588919f, 0.04605604f, -0.02435726f, -0.08261117f, 0.11544172f, 0.24873905f, -0.08163578f, 
    0.07411428f, -0.06746264f, 0.06233230f, 0.00128490f, 0.03497904f, 0.03204106f, -0.07310558f, -0.13566190f, 
    -0.31865484f, -0.03573158f, 0.11799945f, 0.04700957f, -0.00374157f, -0.03999621f, -0.12737037f, -0.06760389f, 
    0.07232498f, 0.04509067f, -0.19278361f, 0.15749067f, 0.12873696f, -0.10984841f, -0.16661677f, -0.05106075f, 
    0.02799318f, -0.02487541f, 0.00890260f, 0.11851849f, -0.05770560f, 0.12868315f, -0.09553027f, 0.15277138f, 
    -0.01372631f, 0.02790084f, 0.31926426f, 0.12237564f, -0.03208721f, -0.01030716f, 0.01334130f, 0.05255274f, 
    -0.02428717f, 0.06041100f, -0.04289734f, -0.00331316f, -0.19042581f, 0.27538624f, 0.03341549f, -0.13967979f, 
    0.04631201f, 0.04987115f, -0.12757106f, 0.07719015f, -0.07215181f, 0.01348868f, -0.02162693f, -0.00953973f, 
    -0.26332912f, 0.12615390f, -0.06753910f, -0.02625857f, -0.10820781f, 0.05983849f, -0.03094388f, -0.00778141f, 
    -0.01054675f, -0.01186137f, -0.05428829f, 0.04397173f, 0.04136217f, 0.16266219f, 0.24665494f, -0.27839306f, 
    -0.06323434f, -0.05744058f, 0.22362633f, 0.17774948f, 0.00706772f, 0.04438064f, 0.02100589f, -0.09484238f, 
    0.07907040f, 0.18961206f, -0.03703398f, -0.02689432f, -0.07263691f, -0.11966641f, 0.03883889f, 0.02131521f, 
    0.03606023f, 0.00667561f, 0.02132920f, 0.02072063f, 0.27458119f, -0.07900019f, -0.00409999f, -0.17638621f, 
    -0.09136195f, 0.15136731f, -0.00959238f, -0.02570507f, -0.04693840f, -0.00074006f, 0.01062124f, -0.03031708f, 
    0.08350798f, -0.01510401f, 0.13822287f, 0.01625884f, 0.05643897f, 0.05407718f, 0.01593617f, 0.03358253f, 
    -0.00006894f, 0.01176973f, 0.06063134f, -0.05662221f, 0.08429172f, 0.33165050f, -0.03541112f, -0.07911874f, 
    -0.01220190f, 0.05737645f, 0.12550883f, -0.00755421f, 0.02012693f, 0.03772637f, -0.00708177f, 0.00376641f, 
    0.26568243f, 0.23951818f, 0.03215706f, -0.18724315f, 0.08829892f, 0.12120688f, 0.02250009f, -0.07738763f, 
    0.05522919f, -0.03448524f, -0.05883822f, -0.02927871f, -0.20179279f, -0.11191808f, 0.03353572f, 0.05908320f, 
    -0.00616244f, 0.00877669f, 0.11210109f, 0.06579407f, -0.02404437f, 0.02331307f, -0.05493945f, 0.02905756f, 
    0.31169957f, -0.04360148f, -0.02548241f, -0.05344190f, 0.02899768f, 0.11918586f, 0.02696496f, -0.03666001f, 
    -0.05583865f, -0.04903039f, -0.10238608f, -0.04371578f, -0.04872401f, -0.25270066f, -0.12337838f, 0.06872490f, 
    -0.14795691f, 0.07094231f, 0.03990665f, 0.13619484f, -0.00238617f, -0.00318328f, -0.06145578f, -0.16749766f, 
    0.01485594f, -0.03894240f, 0.19957915f, 0.15679362f, -0.03250162f, 0.05840015f, -0.00346903f, -0.10319018f, 
    0.00526766f, 0.06104707f, 0.09750259f, 0.00166060f, 0.27083030f, -0.05298050f, 0.03741945f, 0.19162634f, 
    -0.00129555f, 0.04656544f, -0.09606545f, -0.05717073f, -0.07868470f, 0.05851835f, -0.02325744f, -0.07741393f, 
    -0.11026849f, -0.08478070f, 0.07655033f, 0.08966308f, -0.08319571f, 0.08867793f, 0.12262919f, -0.06992840f, 
    0.11589333f, 0.07170459f, -0.06948178f, 0.23479858f, 0.11478747f, -0.35477695f, -0.10891982f, -0.26149613f, 
    -0.03099187f, -0.00732739f, -0.00911466f, -0.00598269f, 0.10341942f, -0.04328018f, -0.00201761f, -0.10103084f, 
    -0.13444619f, 0.16983372f, -0.11902731f, -0.02847240f, 0.00806755f, 0.15353699f, -0.17526381f, 0.12771921f, 
    0.00056987f, 0.04330501f, 0.11823536f, -0.16156910f, 0.18228748f, 0.04998827f, 0.03120175f, -0.25319889f, 
    -0.04522567f, 0.03480776f, 0.01612342f, 0.02267125f, -0.04391431f, 0.02445243f, 0.10080811f, 0.04922502f, 
    0.03526477f, 0.05147829f, 0.14522099f, -0.35468492f, 0.03614331f, -0.07979018f, 0.16694689f, 0.17240436f, 
    -0.13411655f, -0.03104141f, 0.00743015f, 0.11727199f, -0.10694499f, -0.02158363f, 0.06554147f, 0.00061268f, 
    0.01757124f, 0.10536242f, 0.05739848f, -0.05823672f, -0.11158402f, -0.04864796f, 0.08294792f, 0.03933379f, 
    -0.00730654f, -0.08631186f, 0.10008622f, -0.13536963f, 0.02681976f, 0.01516251f, -0.00247751f, -0.00023273f, 
    -0.00140303f, -0.01370167f, 0.11042327f, 0.13689990f, -0.30865571f, 0.10884329f, 0.03227769f, 0.07646136f, 
    -0.09714481f, 0.17116863f, -0.11634355f, -0.10167621f, 0.05243153f, -0.04951214f, -0.05298886f, 0.07866145f, 
    -0.33320552f, 0.07817522f, 0.25275850f, -0.26752582f, 0.03281976f, 0.15383169f, -0.00392270f, 0.02511868f, 
    -0.09141648f, 0.10157740f, -0.09386083f, -0.00060455f, -0.14515102f, -0.10900217f, 0.27783629f, -0.10422941f, 
    0.00274139f, -0.00632028f, 0.07749430f, 0.07061569f, -0.03946033f, 0.04886309f, -0.03366239f, 0.00384494f, 
    0.15908448f, 0.09580067f, -0.03459762f, 0.11739196f, -0.19673006f, -0.03173934f, -0.02985761f, 0.16220874f, 
    0.07370373f, 0.05540025f, -0.01156909f, -0.06378553f, 0.17763826f, -0.05170191f, -0.11857976f, -0.02336322f, 
    0.09063020f, 0.06969116f, 0.02507003f, 0.14880168f, 0.13223101f, 0.16516155f, 0.03875927f, 0.08930898f, 
    0.41340819f, -0.09433673f, 0.24995488f, 0.03154796f, 0.03786821f, 0.11727981f, 0.09820721f, -0.07566579f, 
    0.02942107f, 0.03782238f, 0.07833474f, 0.05530616f, 0.09061563f, 0.02711963f, 0.08274849f, 0.11073168f, 
    -0.08175451f, -0.03175545f, -0.03317543f, 0.03200376f, -0.07189726f, -0.00736747f, 0.15135133f, -0.01932772f, 
    0.00079878f, 0.09289590f, -0.02202976f, 0.24817780f, -0.02883463f, 0.15259431f, 0.00369032f, -0.00669939f, 
    -0.02192148f, -0.15565574f, 0.01978442f, -0.12964788f, -0.03425935f, -0.23010288f, 0.04000747f, -0.32374141f, 
    -0.08670437f, -0.08507574f, 0.04996201f, 0.01129287f, -0.05381222f, -0.03361100f, 0.03317592f, -0.15442958f, 
    0.02557639f, -0.15104073f, -0.17206948f, 0.14493597f, -0.05372352f, 0.02993242f, -0.02896490f, -0.06151463f, 
    0.06996102f, 0.02143244f, -0.08570406f, 0.04384581f, 0.26467940f, 0.13916565f, 0.01731786f, -0.02310515f, 
    -0.06811570f, -0.03236346f, 0.06056197f, 0.09282112f, -0.09789582f, 0.09500660f, -0.04303066f, 0.14150114f, 
    -0.05494019f, -0.04645389f, 0.25768489f, -0.10195765f, -0.03622020f, 0.01908896f, -0.00060952f, 0.04364405f, 
    0.08915920f, 0.04528411f, -0.01215166f, -0.05058467f, 0.07156409f, 0.15773316f, 0.03130117f, 0.10239235f, 
    0.02721319f, 0.02873966f, -0.00035457f, -0.00734403f, -0.01418227f, 0.13353685f, 0.09783752f, 0.08025651f, 
    -0.04845399f, 0.13075417f, 0.07869066f, 0.08276033f, -0.07929255f, 0.06249117f, -0.00826354f, -0.05503095f, 
    -0.06593583f, 0.06883871f, 0.03061968f, 0.12950312f, 0.13051903f, 0.13566881f, 0.08447807f, -0.21633828f, 
    -0.16520973f, -0.09403589f, 0.08058112f, 0.31372967f, 0.14092180f, -0.02959692f, -0.00965872f, -0.07527889f, 
    -0.06604876f, 0.07510573f, -0.27704149f, -0.05888636f, -0.07534751f, -0.02264799f, -0.02420452f, 0.19700186f, 
    0.05285466f, -0.03037099f, -0.13478510f, 0.00835688f, -0.00087695f, -0.05997169f, -0.04115432f, -0.14541069f, 
    0.02793975f, 0.04456462f, 0.05547798f, 0.24986964f, 0.05530520f, -0.05886264f, 0.17019634f, -0.14008641f, 
    0.12234574f, 0.35623962f, 0.01568268f, -0.07205148f, -0.08031416f, 0.02198506f, 0.05627541f, -0.04032126f, 
    -0.03065334f, -0.06584475f, -0.02095792f, -0.03791521f, 0.00223706f, 0.03297358f, -0.18599279f, 0.02092031f, 
    -0.00663104f, -0.04374601f, 0.02541619f, -0.03239965f, -0.00598348f, -0.04454533f, -0.08507954f, -0.03527868f, 
    0.43611577f, -0.19989817f, 0.19084862f, -0.34962124f, -0.00336703f, 0.03519130f, -0.08718948f, -0.01268817f, 
    -0.01964943f, 0.00497388f, 0.04470123f, -0.05207833f, 0.25342074f, 0.30518955f, -0.07364826f, -0.11224780f, 
    -0.07572848f, -0.06858855f, 0.15259676f, 0.08667613f, 0.09156979f, 0.09297840f, -0.03605476f, -0.05699345f, 
    -0.07371489f, -0.04143270f, 0.05319339f, 0.07960108f, 0.04743125f, 0.03406283f, 0.13153277f, -0.14641859f, 
    -0.05726551f, 0.01561035f, -0.14700308f, 0.12357961f, 0.35288897f, 0.29248735f, 0.01359317f, -0.10836221f, 
    -0.10196035f, -0.00324210f, -0.06433868f, 0.16298158f, 0.02384295f, -0.01569351f, -0.21664998f, 0.01027232f, 
    -0.02596932f, -0.03824308f, -0.28250459f, 0.14668569f, -0.11298319f, 0.10184174f, 0.01251407f, -0.10319430f, 
    0.12389603f, 0.07783840f, 0.02101103f, 0.22396167f, 0.02872624f, -0.00767166f, 0.15199998f, -0.09168594f, 
    -0.15412416f, 0.07776924f, 0.07945564f, -0.12849113f, -0.01500742f, 0.05011531f, 0.07945598f, 0.18046859f, 
    -0.20491950f, -0.01310081f, 0.15370868f, 0.23983701f, -0.04977548f, -0.09881125f, -0.00354415f, 0.02153559f, 
    0.09687234f, 0.08011159f, 0.11333970f, 0.03939974f, 0.02879811f, 0.01375114f, 0.16765410f, -0.16630855f, 
    0.04028350f, -0.02746860f, 0.09291960f, 0.07405875f, 0.02043908f, -0.05388062f, 0.08751623f, 0.14495322f, 
    -0.10806056f, -0.04295555f, 0.03364784f, 0.20931791f, -0.13098137f, -0.09187883f, 0.03514439f, -0.05819826f, 
    -0.12878084f, -0.05624764f, 0.05699480f, 0.08106951f, -0.09081879f, 0.06921661f, -0.10867627f, 0.17304040f, 
    0.14802110f, 0.02404353f, -0.06633525f, -0.00392201f, -0.00752666f, -0.01275629f, 0.06896573f, -0.00229299f, 
    -0.32654491f, 0.18832783f, 0.18917063f, 0.20148523f, 0.01870793f, 0.01337145f, -0.15788160f, -0.01275516f, 
    -0.01061337f, 0.07885448f, 0.07572485f, 0.14117512f, 0.40698892f, 0.09271085f, -0.08829518f, -0.35624033f, 
    0.03032679f, 0.08013062f, 0.00977246f, -0.07630515f, 0.03733573f, -0.07229574f, 0.15008326f, 0.02742650f, 
    -0.06223626f, 0.09212267f, 0.08076981f, -0.25766751f, 0.10268379f, -0.04968832f, -0.00608159f, 0.13702044f, 
    -0.07274779f, -0.05932833f, -0.08963913f, -0.01202302f, -0.00162991f, -0.03498543f, -0.15961295f, -0.00218941f, 
    0.07088948f, -0.10079130f, 0.04047988f, -0.00255751f, 0.01768258f, 0.06650537f, 0.08655868f, 0.00345766f, 
    0.18826994f, -0.03646284f, 0.02054974f, -0.47361967f, 0.06808613f, -0.03184804f, 0.09461431f, 0.04640944f, 
    -0.09503680f, -0.07325842f, 0.00934105f, 0.06671716f, -0.06364012f, 0.08420242f, -0.02067562f, -0.05327056f, 
    -0.04748834f, 0.02923651f, 0.08169015f, 0.02800282f, 0.16200359f, 0.02566583f, -0.02299359f, -0.00537795f, 
    0.02947966f, -0.02072318f, -0.06907982f, 0.20690133f, 0.18789347f, -0.03950408f, -0.04013772f, -0.00545339f, 
    0.02683305f, 0.00716128f, -0.00672700f, -0.13498428f, -0.27027243f, 0.08005196f, 0.12199384f, 0.25928491f, 
    -0.04903006f, -0.15645871f, -0.02195742f, -0.02816254f, 0.05556776f, -0.07168171f, 0.07633202f, -0.05911311f, 
    0.37435368f, 0.01768429f, -0.03837327f, 0.17441596f, 0.02570839f, -0.04585474f, -0.07956805f, 0.07286222f, 
    0.04042719f, -0.05338507f, 0.00553566f, 0.04115616f, 0.16938807f, -0.01903593f, -0.16283748f, 0.23469113f, 
    0.02764353f, -0.08124043f, -0.03385733f, 0.00980858f, 0.03160432f, -0.07433256f, 0.02171701f, 0.10229260f, 
    -0.05661050f, -0.02518907f, 0.19359009f, 0.10174674f, 0.00708088f, -0.00370597f, 0.10036590f, 0.05816612f, 
    0.00619665f, 0.07738194f, 0.13086897f, 0.05043998f, 0.06033559f, 0.15792160f, 0.01023723f, -0.17492729f, 
    -0.00611757f, 0.04297640f, -0.12505545f, -0.02035141f, 0.04412835f, 0.15590040f, -0.02754893f, -0.09749704f, 
    -0.55140507f, -0.15194756f, 0.10422235f, -0.10535944f, 0.00649697f, -0.00696472f, -0.03713142f, -0.09265883f, 
    0.08115466f, 0.16516611f, -0.01041590f, 0.10040338f, 0.22852372f, -0.01452949f, -0.07268095f, -0.21677674f, 
    0.09063208f, 0.18435493f, -0.03403976f, -0.01857423f, 0.04618559f, 0.06996630f, -0.01984215f, 0.10861285f, 
    -0.10267746f, 0.17109154f, 0.00864745f, 0.04910420f, 0.00500172f, -0.00629324f, 0.03600825f, -0.03802599f, 
    0.00629066f, -0.08136129f, 0.06263135f, 0.06641684f, 0.20275985f, 0.07635023f, 0.03763087f, 0.04615024f, 
    0.07979409f, 0.00410682f, -0.03266558f, 0.18678984f, -0.00893381f, 0.05162500f, 0.01605818f, 0.10250534f, 
    -0.10876233f, 0.22131109f, -0.14666337f, 0.08364457f, 0.05836843f, 0.07511956f, -0.01819362f, -0.01526966f, 
    -0.08152270f, -0.05066195f, 0.08941688f, 0.06536040f, -0.01629960f, -0.06142707f, 0.07405172f, -0.27519703f, 
    -0.04468201f, -0.02566193f, 0.04545195f, 0.10689137f, -0.03364396f, -0.02315077f, 0.03716062f, -0.06136355f, 
    -0.12321367f, -0.05799152f, -0.01332349f, 0.07141824f, -0.13771686f, -0.00897741f, 0.04861362f, 0.01648317f, 
    0.02956725f, -0.06769377f, 0.02829897f, -0.04521304f, -0.11096826f, 0.06841277f, 0.08585778f, -0.05412467f, 
    -0.04275517f, 0.04568986f, -0.01221604f, 0.18400468f, 0.12999064f, 0.07740481f, -0.01275266f, 0.11214575f, 
    -0.07137460f, 0.05203221f, 0.06006923f, -0.23601501f, 0.05356726f, 0.11006075f, -0.07294208f, 0.07057866f, 
    0.06022533f, 0.08267415f, 0.03833386f, 0.01765508f, 0.17316474f, 0.16688444f, 0.16117732f, 0.04298644f, 
    0.11492727f, 0.05647181f, 0.01363091f, -0.02704578f, -0.06189354f, 0.06255243f, 0.05887454f, 0.01809761f, 
    0.24097127f, 0.06002272f, 0.14366044f, -0.07137094f, 0.07061774f, 0.05693530f, -0.04966123f, -0.02094476f, 
    -0.02409744f, -0.07783774f, 0.16459458f, 0.06259549f, -0.21052636f, -0.23471741f, 0.01575022f, 0.09406852f, 
    0.03693354f, 0.12095033f, -0.10609856f, -0.06194549f, 0.03774949f, 0.06541512f, -0.10404684f, -0.08396633f, 
    0.07325771f, 0.09134630f, 0.00691284f, 0.00459249f, -0.01053115f, 0.01264009f, 0.04113666f, 0.02076021f, 
    -0.07673305f, -0.11701724f, 0.10266804f, -0.15240149f, -0.21356142f, -0.24787261f, -0.03953029f, 0.31252828f, 
    0.00018457f, 0.01379982f, -0.09757040f, 0.03024315f, -0.02380222f, -0.00142955f, 0.04267973f, -0.16050816f, 
    -0.16483581f, 0.14600915f, -0.21157821f, -0.05476648f, 0.06337503f, -0.13696264f, 0.03837460f, -0.06169266f, 
    -0.02993117f, 0.00480882f, 0.08366966f, 0.05189524f, -0.01961493f, -0.12584652f, -0.15702312f, 0.21477461f, 
    -0.07452681f, -0.06175449f, 0.02134926f, -0.11881965f, 0.02780467f, 0.08622485f, 0.01171140f, -0.10419238f, 
    -0.20119037f, 0.04377427f, -0.01231035f, 0.10214273f, -0.07984564f, 0.03676877f, -0.02224533f, 0.02390369f, 
    0.03384408f, 0.04059918f, 0.21812773f, 0.15818691f, -0.11364572f, -0.27587289f, 0.01223563f, 0.18000285f, 
    0.24966070f, -0.04865741f, 0.03981062f, 0.08938645f, 0.16473486f, 0.07140143f, 0.01372438f, 0.06079644f, 
    -0.18229307f, -0.04653387f, -0.17965062f, 0.06806482f, 0.09286004f, -0.01383180f, 0.14060438f, 0.13912445f, 
    -0.03023343f, 0.03506926f, -0.01634320f, 0.04941246f, -0.13975126f, 0.13753189f, 0.13194937f, -0.07423563f, 
    0.07881545f, 0.04644581f, -0.01241262f, 0.01234500f, 0.06475328f, 0.01248242f, -0.08796674f, 0.05571569f, 
    -0.15418991f, -0.09891399f, 0.27046388f, 0.21245712f, -0.01380795f, 0.02353214f, -0.01488644f, 0.09056053f, 
    0.08478795f, -0.00673175f, 0.03960525f, -0.00816090f, 0.21978623f, -0.11008110f, 0.24782467f, 0.05408431f, 
    -0.02628401f, -0.04776726f, -0.02997880f, 0.03700409f, -0.06685658f, -0.00190233f, 0.06160096f, -0.06914433f, 
    0.08821956f, -0.22947487f, 0.10070291f, 0.07709915f, 0.07057594f, 0.02363315f, 0.06006876f, 0.08650688f, 
    0.03201016f, 0.02472990f, 0.01956884f, 0.03543926f, -0.03369492f, 0.02194437f, -0.12792858f, 0.10922588f, 
    -0.08737911f, -0.04075958f, 0.01615395f, 0.02457173f, -0.02566924f, -0.03641131f, 0.03097397f, 0.03977228f, 
    -0.14298719f, 0.03468338f, 0.17600384f, 0.00925663f, 0.00477756f, -0.02507057f, -0.07197372f, -0.10477938f, 
    -0.09828948f, -0.09003662f, 0.00902206f, 0.02734294f, -0.02003701f, -0.05895460f, 0.15252545f, 0.25632277f, 
    -0.14624594f, 0.02701497f, -0.00958632f, -0.11967119f, -0.03200165f, -0.05759131f, 0.01948304f, -0.00847035f, 
    0.02235664f, 0.10514806f, 0.00577981f, -0.00365657f, 0.14294611f, 0.02083873f, 0.08547319f, -0.00103875f, 
    -0.01718445f, 0.00506486f, -0.05573525f, -0.03201955f, -0.46027428f, 0.11661313f, -0.02047616f, 0.02502844f, 
    0.18700908f, 0.07118005f, -0.01867803f, -0.02336564f, 0.02185793f, 0.00762557f, 0.10822538f, -0.08057991f, 
    0.03992852f, 0.01820307f, 0.09733854f, -0.04965650f, 0.05676119f, -0.00506533f, 0.14561114f, 0.00931346f, 
    0.08648102f, 0.06181162f, -0.03614546f, -0.09207924f, 0.28812841f, 0.10819609f, 0.10926234f, 0.04058391f, 
    0.07037638f, 0.02015186f, -0.04388330f, -0.06540289f, 0.07584986f, 0.04208612f, -0.00146739f, 0.06386662f, 
    0.06371651f, -0.07840836f, -0.05660425f, -0.07030349f, 0.11544280f, -0.02097360f, 0.01415057f, 0.04211746f, 
    0.08378045f, 0.10464781f, 0.16797252f, 0.10860052f, -0.08854980f, -0.00524536f, 0.15915602f, 0.02410641f, 
    -0.13006820f, -0.00088708f, 0.08025247f, -0.05456112f, 0.05547787f, 0.09564837f, 0.00934940f, 0.01564686f, 
    -0.76153392f, -0.34691295f, -0.10136103f, -0.07413549f, 0.11318139f, 0.03057053f, -0.12701818f, 0.06420993f, 
    0.09144344f, 0.06479160f, -0.02032017f, -0.01414009f, 0.16835006f, -0.05924655f, 0.07925225f, -0.12997416f, 
    0.04463762f, 0.09026504f, -0.01657373f, 0.04456291f, -0.05234332f, 0.05969970f, -0.07691762f, 0.09101214f, 
    -0.04991292f, -0.05932602f, 0.35165173f, 0.15061317f, -0.02259131f, -0.04421309f, 0.01281178f, 0.02731616f, 
    0.01327071f, 0.08061069f, 0.00681764f, 0.00323339f, -0.05911257f, 0.09743246f, -0.03357964f, -0.17270771f, 
    -0.00402010f, 0.02105042f, -0.04132285f, 0.18366884f, 0.00458565f, -0.04418772f, 0.10502869f, 0.02899263f, 
    -0.37128264f, 0.24271123f, 0.07185155f, -0.16720423f, -0.02095560f, 0.00820546f, 0.05127136f, -0.00444249f, 
    0.03344902f, -0.05511973f, 0.02274979f, -0.05149242f, 0.22631420f, -0.04901792f, 0.23129162f, -0.03473574f, 
    -0.17252131f, -0.09441002f, 0.11081001f, 0.00278218f, 0.02951544f, 0.10329328f, 0.11660992f, 0.03486381f, 
    0.02888614f, -0.17553534f, -0.24658282f, 0.26059404f, 0.05425323f, -0.01401602f, 0.03864747f, 0.11146424f, 
    0.11260485f, 0.00186606f, -0.03869271f, 0.05590790f, 0.18382375f, -0.15802582f, 0.00145361f, 0.14727776f, 
    -0.05156838f, -0.04307412f, -0.03406405f, 0.09459135f, -0.01512453f, 0.02158478f, -0.00263206f, -0.07191471f, 
    -0.03998642f, 0.14285690f, 0.22693427f, -0.09889492f, -0.08544739f, 0.13576509f, -0.09877139f, 0.07090193f, 
    -0.02081974f, 0.01095271f, 0.08681918f, 0.06835866f, -0.11621085f, 0.21038282f, -0.11752824f, 0.01599183f, 
    0.19055930f, 0.05240578f, 0.07001621f, 0.00315013f, 0.02804919f, 0.10508007f, -0.05762380f, -0.04298326f, 
    0.14417373f, -0.29240146f, 0.15933363f, -0.04842537f, 0.07930465f, -0.02642083f, 0.12135096f, -0.04035893f, 
    -0.01047485f, -0.07012593f, -0.01671608f, -0.04168762f, -0.04229817f, 0.04371767f, 0.13638334f, -0.04341679f, 
    0.01786611f, 0.15229881f, 0.02436787f, 0.05154329f, -0.12381296f, -0.05393947f, 0.02997968f, 0.14760911f, 
    0.02887908f, -0.05849528f, -0.14035362f, 0.01552948f, -0.04809473f, 0.08590402f, 0.02562437f, 0.01656350f, 
    -0.06430068f, -0.11976199f, -0.03106415f, -0.10937406f, -0.09534592f, -0.16095337f, 0.18968639f, -0.02172524f, 
    -0.07865820f, 0.02834580f, -0.00321407f, 0.03237135f, 0.11646266f, -0.08798179f, -0.04797751f, -0.09689503f, 
    0.08223882f, 0.08155110f, -0.19200310f, 0.13064671f, -0.08937245f, -0.08145843f, -0.02007787f, -0.09168084f, 
    -0.00528236f, 0.10182849f, 0.14425008f, -0.13003859f, 0.15938571f, -0.32968274f, -0.10286769f, 0.17773268f, 
    -0.06004484f, 0.05559665f, 0.07046414f, -0.08380575f, 0.05777252f, 0.18140212f, 0.00568138f, -0.03389223f, 
    0.04552203f, 0.28715831f, -0.00211585f, 0.10212934f, -0.08079407f, -0.04826899f, -0.07310613f, -0.06009711f, 
    0.06684429f, 0.04044990f, 0.09705566f, -0.10658462f, -0.04748500f, 0.04325587f, 0.16568549f, -0.17922334f, 
    0.01214666f, -0.09048299f, -0.01819539f, 0.03446710f, 0.01446272f, -0.03936523f, 0.04082561f, 0.05626203f, 
    0.16672291f, -0.11526475f, 0.16511680f, 0.16471317f, -0.03596510f, -0.17711475f, -0.02682731f, -0.08439453f, 
    0.14848186f, -0.02190926f, -0.06434645f, 0.06033882f, -0.01478803f, 0.04811690f, -0.25056499f, -0.19183043f, 
    0.23576404f, 0.09807861f, -0.04664805f, -0.03650652f, 0.04162414f, 0.02255861f, 0.03412591f, 0.04911381f, 
    -0.20605284f, 0.42449683f, 0.11743203f, 0.14721557f, -0.10383087f, 0.10935020f, -0.20039789f, 0.02772625f, 
    0.14686763f, -0.03611041f, 0.09327754f, 0.08665919f, -0.31243879f, -0.29614577f, -0.00177435f, 0.04702527f, 
    0.12480466f, -0.04544448f, 0.00513386f, 0.03061788f, 0.02642435f, -0.07233948f, -0.05526347f, -0.17537360f, 
    -0.23481305f, -0.05362814f, 0.26745120f, -0.06076752f, 0.06513555f, 0.10544967f, -0.00456786f, 0.07286713f, 
    0.05422122f, 0.08770461f, -0.11658203f, -0.02482634f, 0.23989853f, 0.06716275f, -0.03135585f, 0.07971681f, 
    -0.01326026f, -0.09372271f, 0.09816353f, 0.03354295f, -0.00850993f, 0.16921452f, 0.03119013f, 0.07028442f, 
    0.20714809f, 0.09397957f, 0.01427271f, -0.20056328f, 0.01086461f, -0.06125516f, -0.04714599f, -0.04714535f, 
    0.00068634f, -0.07386000f, 0.05647651f, 0.10820968f, -0.16831218f, 0.10628360f, 0.05281775f, 0.01095938f, 
    -0.01522425f, -0.06706676f, -0.07748813f, 0.02895989f, 0.08140066f, 0.08299971f, -0.01926999f, -0.06160852f, 
    -0.26648837f, -0.09491888f, -0.23449124f, -0.21197005f, 0.34218052f, 0.00111367f, -0.06977689f, -0.04866339f, 
    0.10044619f, 0.08567335f, 0.06778744f, 0.14940715f, 0.27049705f, 0.14854048f, 0.03978167f, 0.03896763f, 
    0.02527417f, -0.10955039f, 0.04945890f, -0.02744726f, 0.02900863f, -0.11799864f, -0.09981819f, -0.23403592f, 
    0.21374127f, -0.16865784f, -0.18602322f, -0.16816576f, 0.10674911f, -0.10286799f, -0.17776592f, -0.09956762f, 
    0.18074635f, 0.00963467f, 0.01739324f, 0.02277336f, -0.26223475f, -0.20153208f, -0.25086445f, -0.14910619f, 
    0.10141536f, 0.02500411f, -0.05750390f, -0.10975351f, 0.03675982f, -0.03491597f, 0.05970005f, 0.11464939f, 
    0.12193184f, 0.02418131f, 0.06151487f, -0.02362260f, 0.05292541f, 0.11321827f, 0.11520788f, 0.00579426f, 
    0.06381524f, 0.02327671f, 0.12723850f, 0.28475651f, 0.21953347f, 0.03298000f, -0.19391996f, -0.04158451f, 
    0.06104910f, 0.06643563f, -0.10950070f, 0.11389139f, 0.03398829f, 0.09979616f, 0.11779678f, 0.08658393f, 
    0.10429232f, -0.10172108f, 0.04627081f, -0.04627187f, -0.00246884f, 0.01224777f, -0.01569237f, 0.01952955f, 
    -0.13438852f, -0.02872232f, 0.06205599f, -0.02404282f, -0.05428570f, -0.22359914f, 0.00238705f, -0.00883991f, 
    0.10981418f, -0.03420081f, -0.05952559f, -0.22132246f, 0.05416261f, 0.01788036f, -0.06931797f, 0.11402559f, 
    0.14788501f, 0.02421383f, -0.03793680f, 0.08280199f, -0.01207267f, -0.02749710f, 0.11451628f, 0.13398357f, 
    0.12512979f, 0.08685245f, 0.16931209f, -0.00912917f, 0.24122256f, -0.01911899f, -0.05560731f, -0.01282193f, 
    -0.01595747f, 0.00913096f, -0.02601282f, 0.12357367f, 0.05495896f, 0.07034954f, 0.04959235f, 0.05675615f, 
    0.12049370f, 0.01347347f, -0.30760509f, -0.00976007f, 0.07957408f, 0.08646976f, 0.08987377f, 0.00119557f, 
    -0.00823380f, 0.05659147f, 0.09038378f, 0.03373616f, -0.19129099f, -0.38347360f, 0.10914836f, -0.14839026f, 
    -0.05447017f, 0.17996493f, -0.02895823f, -0.00232773f, -0.03243015f, 0.11448758f, 0.05015788f, 0.04095168f, 
    0.08615188f, -0.20940804f, 0.15373333f, 0.03511076f, -0.02231577f, 0.07531360f, -0.01118387f, -0.08460138f, 
    0.07830826f, 0.07783852f, 0.05492651f, -0.08150952f, 0.03810359f, 0.05985193f, 0.10479427f, -0.17755803f, 
    -0.01066877f, -0.03472225f, -0.02663921f, 0.16806924f, 0.07888475f, -0.17598842f, -0.08190865f, -0.10496590f, 
    0.11270930f, 0.17637956f, -0.10432315f, -0.15758686f, 0.21551466f, 0.03111243f, -0.00713575f, 0.10260738f, 
    0.04963004f, 0.18230568f, 0.00449773f, -0.02851204f, 0.22107211f, 0.13131998f, 0.14023034f, 0.00746193f, 
    -0.01436661f, -0.05795392f, 0.05052778f, 0.11782139f, 0.08842837f, -0.01265365f, 0.08416086f, 0.05324335f, 
    0.05620733f, -0.03158235f, 0.17687514f, 0.07331316f, 0.05002755f, -0.02034278f, 0.05273248f, 0.07613661f, 
    0.09577224f, 0.01015782f, 0.06200526f, 0.07086919f, -0.19002458f, -0.11560847f, -0.27894893f, -0.19157331f, 
    0.09490228f, 0.11566146f, 0.04987242f, -0.05636278f, -0.05828283f, 0.05070210f, 0.07680939f, -0.06649838f, 
    0.07385292f, 0.25663161f, 0.16212822f, 0.02935489f, -0.05076101f, 0.01410270f, 0.05748584f, 0.07018388f, 
    -0.03579142f, 0.16888504f, 0.17436695f, 0.00671024f, -0.48822838f, -0.44538847f, -0.33210406f, -0.08364104f, 
    0.17864858f, 0.12861614f, -0.08165137f, -0.07617570f, -0.18670559f, -0.00598931f, 0.12019990f, -0.05033997f, 
    -0.15770781f, 0.12412469f, -0.05221567f, 0.16441767f, -0.00352249f, -0.17189723f, -0.05059611f, 0.14206007f, 
    0.12880152f, -0.00558895f, -0.06125264f, -0.09743901f, -0.17764594f, 0.03093332f, -0.07108162f, 0.16730036f, 
    0.12165108f, -0.01053813f, -0.02040686f, 0.09982070f, 0.18406716f, 0.05805175f, 0.03842878f, 0.02746649f, 
    -0.09762041f, 0.11776804f, -0.01910874f, -0.20591973f, 0.03480356f, 0.05269161f, 0.02893873f, 0.04467330f, 
    0.11596029f, 0.13170503f, 0.06091208f, 0.11283018f, 0.06449689f, -0.07011806f, -0.13547429f, -0.18107186f, 
    -0.11266275f, -0.03551232f, -0.05771617f, -0.02956314f, 0.03374700f, -0.02105495f, -0.00020367f, 0.02010594f, 
    -0.03357017f, -0.13526347f, -0.05925333f, -0.08145785f, 0.02592376f, -0.19013345f, 0.12778321f, 0.13492507f, 
    -0.04902570f, 0.00305352f, 0.05312330f, 0.00152050f, 0.16902433f, -0.06593873f, 0.00676939f, 0.13769974f, 
    0.20360391f, 0.07526129f, 0.07584853f, 0.02392820f, 0.10850334f, 0.05886037f, 0.14626905f, 0.05766036f, 
    -0.21290867f, -0.03406551f, -0.35356548f, 0.53723854f, 0.02294012f, 0.07602374f, 0.04637885f, -0.08339851f, 
    0.18085296f, -0.03807662f, 0.09014311f, 0.01468987f, 0.23743847f, 0.07158592f, 0.00313049f, 0.07618436f, 
    -0.06365906f, 0.09291994f, -0.09008268f, 0.11957614f, 0.16791762f, 0.15327971f, 0.01724864f, 0.15287244f, 
    0.14693823f, -0.15868928f, -0.03286990f, 0.16295020f, -0.06207705f, 0.18925016f, -0.09048816f, 0.01441757f, 
    -0.10830275f, 0.13303342f, 0.09885117f, -0.11581005f, 0.28181863f, -0.00243824f, 0.10355292f, -0.02762845f, 
    0.19845660f, 0.07900508f, 0.01595103f, 0.02661869f, 0.16826142f, -0.04507349f, 0.26075307f, 0.09464584f, 
    0.29422113f, -0.12876356f, -0.23062871f, 0.24046727f, -0.14260812f, -0.01456829f, -0.07856417f, -0.08973433f, 
    0.10664097f, -0.03738100f, -0.02050864f, 0.00434139f, 0.10861319f, 0.14519234f, -0.06773489f, 0.13055117f, 
    0.12557022f, 0.02216674f, 0.03761997f, -0.03062821f, 0.26505989f, 0.07533099f, 0.06019885f, 0.14984161f, 
    -0.10124061f, 0.04567537f, 0.03849406f, -0.16797444f, 0.20536219f, 0.07883106f, 0.04505725f, 0.06505673f, 
    0.13112552f, 0.03091636f, 0.09133285f, 0.07266461f, -0.07976799f, -0.14493312f, -0.15777102f, -0.05560999f, 
    -0.14441076f, -0.07960334f, 0.14380406f, 0.11024030f, 0.00993060f, 0.02294237f, 0.07471474f, 0.08127799f, 
    -0.24055485f, -0.12128107f, -0.30248660f, 0.00367701f, 0.15892094f, -0.06785250f, 0.13445805f, 0.24200480f, 
    -0.03435477f, -0.03493332f, -0.02374770f, 0.14077069f, -0.24069674f, 0.08143286f, -0.05591125f, -0.16792490f, 
    0.17511141f, -0.03690572f, 0.11007422f, 0.13791831f, 0.10501549f, 0.14895543f, -0.02854602f, 0.05310839f, 
    -0.01602247f, 0.14199145f, 0.26142889f, 0.02520349f, 0.03554095f, -0.02529384f, 0.11263891f, 0.16810048f, 
    0.16483577f, 0.01209777f, -0.07872461f, -0.00620288f, 0.27562857f, 0.29508227f, 0.12930655f, 0.21273516f, 
    0.15642039f, 0.04168319f, 0.03767132f, 0.23416005f, 0.17386287f, 0.02963124f, 0.09127686f, 0.18961929f, 
    -0.14915845f, 0.18471709f, -0.09013567f, -0.14460489f, 0.14214385f, -0.03811114f, 0.20912607f, 0.01602613f, 
    0.03666602f, 0.00675413f, -0.01429192f, -0.00756436f, -0.28920820f, 0.14251895f, 0.02998296f, 0.15423432f, 
    0.13743091f, 0.16349946f, 0.01005140f, 0.13021100f, 0.22623052f, -0.02936049f, 0.08457997f, 0.12918270f, 
    0.39905563f, -0.00027397f, -0.12169333f, 0.23783466f, 0.09354489f, 0.07825822f, 0.18146248f, 0.02866520f, 
    -0.12959196f, 0.03607410f, 0.02999078f, 0.07452125f, -0.14035794f, -0.18214449f, 0.12824662f, -0.06976780f, 
    0.04146400f, -0.09511057f, 0.20426781f, 0.13974759f, 0.12544860f, 0.07946484f, 0.00592424f, 0.03809026f, 
    0.22572045f, -0.09451970f, 0.03517713f, 0.06148765f, 0.34535912f, 0.15443045f, 0.09920837f, 0.09352449f, 
    0.08154356f, 0.11885437f, 0.14475800f, 0.00261888f, -0.00413559f, -0.01358098f, 0.14305261f, 0.26226294f, 
    0.11890034f, -0.01950340f, 0.00048112f, -0.11626936f, 0.08282043f, -0.03536590f, 0.16573957f, -0.02463968f, 
    -0.17442639f, -0.08032700f, -0.05967299f, -0.19192070f, -0.06485695f, 0.06516673f, 0.14324982f, -0.04653640f, 
    0.03637234f, 0.06358174f, 0.12704185f, 0.00918093f, -0.30137801f, -0.13907827f, -0.03581630f, 0.08859442f, 
    0.06109814f, 0.07629249f, -0.00912483f, -0.03051411f, 0.05876591f, 0.12447220f, 0.02677007f, 0.10604517f, 
    0.43333665f, -0.15720356f, 0.01892668f, 0.17158546f, 0.18810248f, 0.13113433f, 0.06438008f, 0.14403833f, 
    0.14065833f, 0.01050802f, -0.02703821f, 0.05191193f, 0.12182310f, -0.01741626f, 0.13795617f, -0.13890302f, 
    -0.01050450f, 0.05406439f, -0.06873592f, -0.02835461f, -0.00262265f, 0.13860884f, 0.08491267f, 0.06939760f, 
    -0.08848740f, -0.05036773f, -0.04126474f, 0.38399762f, -0.03096418f, 0.14185001f, -0.00537143f, 0.03845297f, 
    0.00245896f, 0.20493278f, -0.08446465f, 0.09727354f, 0.18023951f, -0.02080375f, 0.02964100f, 0.11884815f, 
    0.07943292f, 0.07370423f, 0.10763125f, 0.05483760f, 0.12909126f, 0.07320420f, 0.01175911f, 0.04319653f, 
    0.29462492f, 0.02288953f, 0.07784332f, -0.01305320f, 0.20224063f, 0.16402493f, 0.08092272f, 0.12837784f, 
    -0.00790700f, -0.01288109f, 0.03020619f, 0.02824907f, -0.22885236f, 0.11881020f, 0.07874393f, -0.08859442f, 
    0.20035918f, 0.14176351f, 0.09905446f, -0.05029084f, 0.15559308f, 0.16366345f, 0.13558006f, 0.18647903f, 
    -0.26974732f, -0.04475565f, 0.02167384f, -0.27305707f, 0.24000528f, -0.10788926f, 0.07437362f, 0.08507918f, 
    0.21198264f, 0.00673015f, 0.15294938f, 0.09814853f, -0.13719082f, 0.18415862f, -0.22741455f, 0.03688248f, 
    0.23576815f, -0.05132909f, 0.08611761f, -0.01977711f, 0.18233486f, 0.09665824f, 0.14440453f, 0.02803766f, 
    -0.03249182f, 0.01256343f, 0.00598036f, 0.01172572f, -0.01734312f, 0.00247396f, -0.00082636f, -0.01560716f, 
    -0.02834147f, -0.01415328f, 0.02196986f, -0.03411310f, -0.01000220f, -0.05393793f, -0.04808455f, -0.05640848f, 
    -0.04096366f, 0.00693349f, 0.02377171f, 0.02500672f, 0.00511566f, 0.00350937f, -0.00864146f, 0.01715746f, 
    0.01857638f, -0.02876733f, 0.00424020f, -0.01794298f, -0.05152757f, 0.00564900f, -0.04845737f, -0.05718933f, 
    -0.00466783f, -0.03724102f, -0.03010887f, -0.04537706f, -0.04529673f, 0.01964849f, -0.03852142f, -0.04649223f, 
    0.02694902f, 0.01817207f, -0.04015295f, 0.01285706f, -0.03137426f, 0.04137068f, 0.01067500f, 0.01607647f, 
    0.03133940f, 0.01545523f, 0.01510236f, -0.05636710f, 0.04256132f, 0.03473215f, 0.00449830f, 0.04271875f, 
    -0.04878826f, 0.01437988f, 0.01978630f, 0.00731273f, -0.02679734f, -0.04725181f, -0.02450062f, -0.04106845f, 
    0.02432733f, 0.01770789f, 0.02257546f, -0.02098958f, 0.00860647f, 0.02855978f, -0.00545454f, 0.01508017f, 
    0.00254694f, 0.03414485f, 0.00819734f, -0.02035746f, -0.05451759f, 0.00222167f, -0.05291758f, 0.00479306f, 
    -0.01526586f, 0.03305554f, -0.00227855f, -0.01733579f, 0.04214163f, -0.01654797f, -0.05393891f, 0.02474204f, 
    0.00347976f, -0.00705123f, -0.01005370f, 0.03430692f, -0.00795118f, 0.03261447f, 0.01906724f, 0.02842476f, 
    -0.02535509f, 0.03291253f, -0.01281675f, 0.03710956f, -0.00193529f, 0.01468846f, -0.02436215f, 0.04312788f, 
    -0.04429822f, 0.02586688f, -0.04727368f, -0.01687016f, 0.00570489f, -0.00163220f, 0.03778163f, 0.00204184f, 
    0.04372252f, 0.03835024f, -0.00570175f, -0.01564100f, 0.03040546f, -0.05714705f, -0.04534814f, -0.05161497f, 
    -0.03184684f, 0.02488215f, -0.02966541f, -0.00468667f, 0.01513058f, 0.01808546f, -0.00169974f, -0.04919375f, 
    0.01938627f, 0.04022530f, -0.01489300f, 0.02712139f, 0.02056720f, 0.02221772f, -0.01222484f, -0.05397100f, 
    0.03697080f, -0.00133303f, -0.01389536f, -0.00626208f, 0.04045300f, -0.03269532f, 0.00412253f, -0.02186421f, 
    -0.02249912f, -0.00624974f, 0.00492452f, 0.03355628f, -0.00533571f, -0.03722658f, 0.02621088f, 0.03795154f, 
    0.02604869f, -0.03692480f, -0.00849389f, 0.00428813f, 0.02818711f, -0.00406781f, -0.04504852f, -0.01727711f, 
    0.00827903f, 0.02682742f, -0.01699020f, 0.04452929f, -0.00267596f, 0.01202878f, -0.02805831f, -0.03245650f, 
    0.00143645f, 0.02607718f, 0.02176600f, -0.01683055f, -0.02965554f, 0.01562655f, 0.02812300f, -0.04357063f, 
    0.01582772f, 0.00987607f, 0.01997006f, -0.02065181f, 0.00442482f, -0.01304551f, -0.03675187f, 0.04025601f, 
    -0.00575746f, -0.04071120f, -0.03366582f, -0.02424898f, 0.00157156f, 0.02566300f, -0.02371180f, -0.05536666f, 
    -0.00039649f, 0.00704119f, -0.01259265f, 0.03457903f, 0.01775841f, 0.02354736f, -0.00397490f, 0.02352265f, 
    0.02217338f, -0.00165071f, -0.03820369f, 0.04045720f, -0.02256574f, 0.00073330f, 0.02521764f, -0.00067180f, 
    -0.05085320f, -0.02811689f, -0.02118882f, -0.01155574f, -0.05351341f, 0.02824529f, -0.02894194f, -0.01775159f, 
    -0.02579902f, -0.05144882f, 0.03195026f, 0.03756781f, -0.05571637f, 0.02654896f, -0.03362990f, 0.02918455f, 
    -0.02741499f, 0.03901261f, 0.02925207f, 0.03167759f, -0.02726232f, -0.01242462f, 0.02602740f, 0.02887196f, 
    -0.01199023f, -0.00142726f, -0.04410742f, 0.00874364f, 0.01240376f, 0.01510831f, -0.01336927f, 0.00522603f, 
    0.00685981f, -0.00438117f, -0.04215820f, 0.02312079f, 0.00681536f, 0.00733011f, 0.03457678f, 0.00272658f, 
    0.01822645f, 0.03963417f, -0.01234122f, 0.01725036f, -0.00025860f, 0.01793563f, -0.01785694f, -0.04964216f, 
    0.02896140f, 0.01304405f, 0.04371320f, -0.04201832f, 0.04099268f, -0.01494263f, -0.00918616f, 0.05118516f, 
    0.01611081f, -0.02542806f, -0.00187864f, -0.01244965f, 0.04320266f, 0.03710558f, -0.05261566f, 0.03851651f, 
    0.00829601f, 0.02459144f, 0.03821504f, 0.01289856f, 0.02908550f, -0.04345953f, -0.00248720f, 0.02816048f, 
    0.01402078f, -0.05164695f, 0.01424821f, 0.03347330f, -0.05663283f, -0.03309331f, -0.01460438f, -0.02269040f, 
    -0.01310399f, -0.00168547f, -0.02040704f, -0.03554203f, -0.02228879f, -0.01246426f, -0.05330693f, -0.03838568f, 
    -0.02998876f, 0.01499654f, -0.01372381f, 0.04377986f, 0.03484714f, -0.00175719f, -0.01508487f, -0.04903876f, 
    -0.04172359f, 0.01896514f, -0.02724850f, 0.02644865f, 0.03943718f, -0.03993569f, 0.00974819f, -0.04327704f, 
    -0.05481200f, -0.00108094f, -0.02882675f, 0.02862936f, 0.02136651f, -0.05178898f, -0.03998690f, 0.01177528f, 
    -0.04729926f, -0.03107077f, -0.00693313f, -0.05286457f, -0.00250123f, 0.02560798f, -0.02122253f, 0.02431019f, 
    -0.02011926f, -0.03384938f, -0.05554315f, 0.00932999f, -0.02318852f, -0.00375748f, -0.01690558f, -0.03710255f, 
    0.00726554f, -0.00006576f, -0.03638802f, 0.00543068f, -0.02072386f, -0.01992371f, -0.05474274f, 0.02982032f, 
    -0.05567792f, -0.04230310f, 0.00549414f, -0.02140925f, 0.02256769f, -0.05359078f, -0.00624253f, 0.00700427f, 
    -0.05079259f, 0.01330598f, -0.00062519f, 0.03608710f, -0.01929721f, -0.05068684f, 0.00197323f, 0.02820106f, 
    0.02679376f, -0.04071167f, -0.00255003f, -0.03710590f, -0.00440037f, 0.00444577f, -0.05417270f, -0.00657059f, 
    -0.01740233f, -0.01539994f, -0.02079189f, 0.00751986f, -0.05486199f, -0.04717067f, -0.01328807f, 0.02893964f, 
    0.02476750f, 0.02878268f, -0.03639156f, -0.05162936f, 0.01780266f, 0.02184580f, -0.04165798f, -0.01847912f, 
    -0.23818161f, -0.15366638f, -0.03666847f, 0.12067146f, -0.05631342f, -0.07914723f, 0.03218037f, 0.11614221f, 
    -0.06348597f, 0.01662862f, 0.17545830f, 0.05389285f, 0.11730449f, -0.09873172f, 0.08794849f, 0.41269955f, 
    0.16130824f, 0.06997629f, 0.06041605f, 0.09474961f, 0.07717073f, 0.07810287f, -0.01032771f, -0.02715709f, 
    -0.33375555f, 0.27523652f, 0.09100515f, -0.01654872f, 0.06241308f, 0.09984087f, 0.06217873f, 0.13674976f, 
    -0.07832115f, 0.05771834f, 0.04562356f, -0.01195904f, 0.37378904f, -0.06727629f, -0.01364441f, 0.18502952f, 
    0.04081424f, 0.02591428f, -0.01238359f, -0.01293927f, 0.07117844f, 0.03353569f, -0.01655800f, 0.08145816f, 
    0.11363657f, 0.09531115f, 0.00637901f, -0.03737079f, -0.10280503f, -0.02148533f, -0.07326557f, -0.06456525f, 
    -0.04131062f, 0.11367252f, -0.06274924f, -0.01505203f, -0.15288472f, -0.03085731f, 0.09396266f, 0.01510456f, 
    -0.05532567f, -0.02193585f, -0.11488844f, 0.00279542f, -0.03160005f, -0.16123107f, -0.05250919f, -0.01282130f, 
    0.31247288f, -0.06539536f, -0.08175023f, -0.06695751f, 0.17550357f, 0.08582587f, 0.00563868f, 0.08818216f, 
    0.00297843f, -0.09134807f, -0.02357712f, 0.11027692f, -0.29480568f, 0.04831471f, -0.02990651f, 0.07051592f, 
    -0.09324270f, -0.07817294f, 0.00122564f, 0.13934073f, -0.04308867f, -0.03544653f, -0.03142733f, 0.03251261f, 
    0.05875771f, 0.06237481f, 0.13018987f, 0.03711024f, -0.12463810f, -0.02244277f, 0.05201595f, 0.02316431f, 
    0.10383494f, -0.04415208f, 0.07447983f, 0.03692395f, 0.02247193f, 0.14958581f, -0.08767877f, 0.08434167f, 
    -0.12858756f, -0.02230833f, -0.04287357f, 0.06833696f, -0.02815309f, -0.02381882f, 0.04210063f, 0.02099672f, 
    0.51444185f, -0.21051081f, 0.02735194f, 0.21745303f, 0.15329775f, 0.03625917f, -0.09110153f, -0.03910689f, 
    -0.10166214f, 0.00583272f, -0.01993197f, 0.02956238f, -0.21268952f, 0.30271232f, 0.14173566f, 0.12621118f, 
    0.27455577f, -0.02449570f, 0.09167097f, 0.02296692f, -0.08406720f, -0.00261782f, -0.05174463f, -0.08974767f, 
    -0.14604992f, 0.18318519f, 0.12420263f, 0.01789941f, -0.03721233f, -0.04340602f, -0.06473114f, -0.00845488f, 
    -0.00394158f, 0.09019504f, -0.02150562f, -0.03295289f, 0.59750098f, -0.03725494f, 0.10313346f, 0.07410438f, 
    0.01802315f, -0.02442526f, -0.07424094f, 0.01580398f, -0.06235935f, -0.00893674f, 0.07828772f, -0.00051212f, 
    -0.20690678f, -0.07048032f, -0.18836714f, -0.00938952f, 0.06042976f, -0.01207690f, -0.14715591f, 0.05458742f, 
    -0.16870864f, 0.09449509f, 0.14419296f, 0.02320468f, -0.33130902f, -0.20518552f, 0.10129185f, 0.20614463f, 
    -0.12256100f, -0.03128507f, -0.09932677f, -0.07307301f, 0.05603689f, 0.03140689f, 0.10718822f, 0.13706020f, 
    -0.47676051f, 0.20499907f, 0.02540828f, 0.12816674f, 0.17944480f, -0.04012612f, -0.04912605f, -0.08609918f, 
    0.00431500f, -0.09450885f, -0.11025704f, -0.00948354f, 0.49108890f, -0.03288996f, 0.06393518f, -0.29924810f, 
    -0.07433778f, -0.09379975f, -0.19246100f, -0.09131087f, 0.10400169f, 0.15025699f, 0.11040398f, 0.05662859f, 
    -0.32717079f, -0.08638322f, 0.14162551f, 0.13397354f, -0.12617861f, -0.11959483f, -0.03651298f, -0.07889464f, 
    0.09051382f, 0.01677789f, -0.06436548f, 0.07626363f, -0.30042610f, 0.22557369f, -0.06778018f, -0.04336024f, 
    0.06738387f, -0.03264119f, -0.06493659f, 0.10085540f, -0.10143967f, 0.00202044f, 0.06846907f, -0.07612062f, 
    -0.02903349f, 0.13946864f, 0.05446633f, -0.07985920f, 0.01840797f, -0.04167257f, 0.04375433f, 0.01397448f, 
    -0.03160037f, -0.10648593f, -0.03193930f, 0.02648672f, 0.01789114f, 0.05960495f, 0.11987248f, 0.02118144f, 
    -0.00596547f, -0.01474813f, -0.00014109f, 0.00574313f, -0.06706909f, 0.03766450f, 0.02184091f, 0.08165614f, 
    0.12366635f, 0.18204623f, 0.11160409f, 0.27045086f, 0.07166942f, 0.11840778f, -0.04289570f, -0.06789817f, 
    -0.00355787f, 0.02597936f, -0.02232099f, -0.03310491f, 0.23765767f, 0.12587653f, -0.10972767f, 0.05677572f, 
    0.00628994f, 0.00316744f, 0.07347225f, -0.09223501f, -0.13509546f, 0.09008352f, -0.07359436f, 0.01939834f, 
    -0.13285568f, -0.14753768f, 0.01000298f, 0.24297653f, -0.18663572f, -0.20047121f, -0.05364643f, -0.16329102f, 
    0.07649676f, -0.06309912f, 0.10746070f, 0.14406431f, -0.13527469f, 0.07978512f, -0.04710310f, 0.12462662f, 
    0.15688947f, 0.19680777f, 0.03867447f, -0.07243075f, 0.07339350f, 0.08258422f, -0.01682312f, -0.08632309f, 
    0.37738204f, 0.00884152f, -0.02177575f, -0.02136528f, 0.10766630f, -0.00749904f, 0.16382302f, 0.04481005f, 
    -0.00681809f, 0.06251792f, 0.07657916f, -0.06753136f, 0.18702921f, -0.11303583f, -0.09931980f, 0.19891326f, 
    -0.03307531f, -0.03409520f, -0.03558973f, -0.12432492f, 0.00582077f, 0.02042101f, 0.03117023f, 0.08209946f, 
    -0.06877891f, -0.14985025f, -0.23737626f, -0.06372289f, 0.01308802f, 0.00185381f, -0.14972152f, 0.09890528f, 
    0.21058537f, 0.00807230f, -0.06595757f, 0.01682658f, 0.62302315f, -0.01583345f, -0.24592003f, 0.19105734f, 
    -0.02049660f, -0.11601568f, -0.03510604f, -0.04145289f, 0.15776405f, -0.05784443f, 0.04146640f, -0.08029173f, 
    -0.03502078f, 0.17310867f, -0.04036948f, 0.32593381f, 0.00488540f, -0.01755334f, -0.10523417f, -0.08754832f, 
    -0.10128125f, -0.01732840f, 0.13125135f, -0.05948519f, 0.30134678f, 0.01070841f, -0.09631167f, 0.11843587f, 
    -0.03237928f, -0.08266167f, -0.01974566f, -0.00043073f, 0.09841665f, 0.07685083f, -0.05114196f, -0.04585221f, 
    -0.04081898f, -0.01314347f, 0.02067531f, -0.03610335f, -0.01823321f, -0.02485877f, -0.01080865f, -0.00036264f, 
    -0.01945423f, -0.05136547f, -0.02329293f, -0.03256995f, 0.00496558f, 0.01087102f, -0.01613555f, -0.04684632f, 
    0.02517146f, -0.03919083f, 0.00211810f, 0.00816898f, 0.04447261f, 0.01253379f, 0.01112420f, 0.03001278f, 
    -0.01940398f, -0.04973513f, -0.01987846f, -0.03765706f, -0.03099639f, 0.00304205f, -0.00134389f, -0.00216934f, 
    -0.04305622f, -0.02927755f, 0.02642728f, -0.04300639f, 0.02006818f, -0.02929225f, -0.05191300f, 0.00106464f, 
    0.04029575f, -0.01911431f, -0.01065411f, 0.04969064f, -0.03485456f, 0.02374483f, 0.04724128f, 0.00312003f, 
    0.01603073f, -0.04372964f, -0.01877815f, -0.01443644f, 0.02454720f, -0.05278874f, -0.01414899f, -0.03207755f, 
    -0.03060709f, 0.02634381f, 0.01432226f, -0.03878832f, -0.04303971f, -0.01557979f, -0.01152301f, -0.00148876f, 
    -0.00780165f, -0.03290985f, -0.00537757f, 0.03117553f, -0.01489088f, 0.02048896f, 0.01714292f, -0.02135982f, 
    0.01831342f, 0.00790052f, 0.00476663f, 0.02448816f, -0.04493111f, 0.03056092f, -0.00836141f, -0.00602611f, 
    0.00698611f, -0.02343881f, -0.04272484f, -0.04586104f, 0.00268375f, 0.01433635f, 0.00093673f, 0.02290528f, 
    0.04567046f, -0.01713406f, -0.03884057f, 0.01996852f, -0.04061988f, -0.01427241f, 0.00604932f, -0.03475890f, 
    0.00885268f, 0.03143371f, -0.01910908f, 0.00454973f, 0.02407845f, -0.02235977f, 0.01863484f, 0.01814758f, 
    0.01685391f, -0.04721711f, -0.03145621f, -0.04074596f, 0.02791677f, -0.04058966f, 0.03258996f, 0.04173147f, 
    -0.02407480f, 0.03139088f, -0.00560904f, 0.02117804f, -0.03425882f, -0.01704824f, -0.04285327f, -0.02723461f, 
    0.00481735f, -0.00360912f, -0.03936534f, -0.05132898f, -0.05501277f, 0.00132394f, -0.02195710f, 0.01538040f, 
    0.00077725f, 0.03014627f, -0.02487763f, 0.03465071f, -0.04311928f, -0.01759119f, 0.00824987f, 0.04203078f, 
    -0.01537507f, -0.02332638f, -0.04078037f, 0.02421024f, -0.04314010f, -0.02987515f, -0.02716999f, 0.01932464f, 
    -0.01202274f, -0.00066472f, -0.01646790f, -0.01463070f, -0.01691513f, 0.01873875f, 0.01959511f, 0.02396418f, 
    0.04070131f, -0.02870721f, -0.02443201f, -0.00742431f, 0.03318538f, -0.00139173f, -0.01612858f, 0.01291742f, 
    0.03592488f, 0.04597489f, -0.04613338f, -0.02278260f, -0.05772986f, -0.03002977f, 0.03142413f, -0.01382396f, 
    0.01015532f, -0.01931594f, 0.04450574f, -0.04481427f, -0.01146357f, 0.00046199f, -0.03344091f, 0.02196916f, 
    -0.04110951f, 0.04393498f, 0.01166310f, 0.01349774f, -0.02118372f, -0.04300185f, -0.03939871f, -0.01532878f, 
    -0.03932999f, 0.03860731f, -0.03939972f, -0.05710480f, -0.00749912f, 0.02235603f, -0.04462180f, -0.03585122f, 
    0.01832671f, -0.00321558f, -0.00094323f, 0.01663458f, -0.00257070f, -0.04310004f, 0.02616814f, -0.01099343f, 
    0.00094630f, -0.01499434f, 0.02772962f, 0.04169775f, 0.01379981f, 0.03168955f, 0.03652287f, -0.01691746f, 
    -0.03029508f, 0.02783271f, -0.04978485f, 0.03797657f, 0.04588326f, 0.02805818f, -0.02982498f, -0.03510341f, 
    -0.01890995f, -0.01626820f, -0.00625899f, -0.01684262f, 0.01394349f, -0.04908123f, -0.05332317f, 0.01279928f, 
    -0.00644059f, -0.04688299f, 0.05095678f, -0.00172932f, -0.00075900f, -0.03557423f, -0.03082767f, 0.00546708f, 
    -0.00808386f, -0.00686285f, -0.02032577f, -0.04898176f, -0.00069325f, -0.05495634f, 0.00493313f, -0.04241389f, 
    -0.02452141f, 0.03716814f, 0.01521398f, 0.01638100f, -0.00974123f, 0.02437314f, 0.03752551f, 0.02016299f, 
    0.03808149f, -0.02657287f, 0.01968450f, -0.00275536f, -0.00921638f, 0.03139220f, 0.04744608f, -0.02630574f, 
    -0.01159333f, 0.04064817f, -0.04250030f, -0.04519199f, -0.00777271f, 0.02637197f, -0.04814876f, 0.00953218f, 
    0.02984366f, -0.04463339f, 0.01657349f, -0.02886617f, 0.04505653f, -0.04215057f, 0.00359616f, -0.03047836f, 
    0.03519668f, -0.02036740f, 0.01137131f, -0.05209350f, -0.02541252f, 0.02619037f, -0.01021325f, -0.01150571f, 
    0.00100345f, 0.02397302f, -0.01133925f, -0.02099486f, -0.05434714f, 0.03677604f, -0.05104803f, -0.02925912f, 
    0.02080345f, 0.02805239f, -0.03448342f, -0.00114624f, 0.04493461f, 0.03072411f, -0.04923525f, -0.00729923f, 
    -0.04453276f, 0.00163088f, -0.02247521f, -0.01908790f, -0.05755365f, -0.03987372f, 0.03531910f, 0.03098312f, 
    0.02433391f, -0.01362394f, 0.02200152f, -0.01624671f, 0.03338291f, -0.03494497f, -0.02181606f, -0.02696392f, 
    -0.01748958f, -0.01785547f, 0.01623411f, 0.00238006f, -0.05260780f, -0.04439921f, -0.00899564f, -0.05052311f, 
    0.02809360f, -0.04206132f, -0.05583254f, -0.01809358f, -0.02039249f, -0.01673669f, -0.01361429f, 0.00184061f, 
    -0.05049160f, 0.00269333f, 0.00389973f, -0.01083856f, 0.03272648f, 0.04160912f, -0.00292737f, -0.04928407f, 
    -0.00920533f, -0.05636171f, 0.00534719f, -0.03440733f, 0.02820740f, -0.00289063f, 0.03702587f, -0.01811513f, 
    0.02207882f, 0.04328406f, -0.02269651f, -0.01411781f, 0.00220773f, -0.04907151f, 0.02493395f, 0.03921856f, 
    0.02898740f, -0.02126308f, -0.01805495f, 0.03457814f, -0.00771292f, -0.00552783f, 0.02068192f, 0.02293738f, 
    0.05564494f, -0.00137956f, -0.01569253f, -0.01054178f, -0.04646334f, -0.05715447f, -0.03575448f, 0.03086749f, 
    0.02157047f, 0.00330661f, -0.03789581f, -0.01003656f, -0.05560438f, 0.00311964f, -0.02923392f, 0.03842847f, 
    0.01146447f, 0.04292407f, -0.01259554f, -0.02670582f, -0.05811992f, 0.01204874f, 0.01574322f, 0.02455309f, 
    -0.00504000f, -0.00415332f, -0.02446864f, 0.02092423f, -0.03951818f, 0.00101636f, -0.03458326f, -0.04623161f, 
    -0.01010254f, 0.04284861f, 0.02836124f, -0.01954187f, -0.00040533f, 0.04195601f, -0.01395350f, 0.03011431f, 
    -0.04518858f, 0.03899113f, -0.02988794f, -0.04646036f, 0.04292885f, 0.00640284f, -0.00752773f, -0.01634421f, 
    -0.05346155f, -0.03474918f, 0.02673414f, -0.04205878f, 0.00979851f, 0.02829306f, 0.00109919f, 0.01897740f, 
    0.05248486f, -0.04777693f, -0.02934731f, -0.05374800f, -0.05394895f, 0.03257716f, 0.04200427f, -0.04663313f, 
    -0.03457962f, -0.01999564f, -0.03722914f, -0.05351643f, 0.03025700f, 0.01516927f, 0.00630574f, -0.04232585f, 
    -0.03242027f, 0.03866822f, -0.02609081f, 0.02977068f, 0.00760861f, 0.02033785f, -0.02317605f, -0.01645141f, 
    0.00265371f, 0.04317546f, -0.04861886f, -0.02941198f, -0.02184964f, -0.00317272f, 0.04540521f, -0.00132812f, 
    -0.05118720f, -0.02633769f, -0.00910683f, -0.00434537f, -0.03769773f, 0.01297070f, 0.03494184f, -0.03089152f, 
    -0.02004546f, -0.02180996f, 0.01018256f, -0.04630606f, 0.00035296f, 0.03898966f, -0.02331273f, 0.01781831f, 
    -0.00880837f, -0.03980742f, 0.01041175f, 0.04292069f, 0.00781850f, -0.04511581f, -0.01356296f, 0.01430077f, 
    -0.00100435f, 0.01472971f, -0.02103483f, -0.01863672f, 0.04589781f, -0.03354969f, 0.00185175f, -0.01674127f, 
    0.00451732f, 0.00492358f, 0.05183722f, 0.03809814f, 0.00008008f, -0.01357086f, -0.00383124f, -0.02041133f, 
    0.04281932f, 0.01677974f, -0.01679519f, -0.03478721f, 0.01531387f, -0.01710139f, 0.01441349f, -0.03681995f, 
    -0.02137111f, 0.02092954f, -0.00573631f, -0.01462179f, -0.05591531f, 0.02605049f, -0.02538484f, -0.01691074f, 
    -0.04206910f, -0.01681646f, 0.00469662f, -0.04012327f, -0.04191728f, 0.04245781f, 0.03235720f, -0.03441489f, 
    0.00288461f, -0.02820713f, 0.03753236f, -0.00377187f, -0.02460493f, -0.03644867f, 0.04201429f, -0.01086585f, 
    0.04956611f, -0.04943898f, -0.03159768f, 0.03402640f, -0.05182613f, -0.02666474f, -0.04265074f, -0.04067609f, 
    -0.00723385f, -0.01532460f, -0.02986730f, 0.04293143f, -0.03804995f, -0.00157593f, 0.01732461f, 0.01204384f, 
    0.00756329f, 0.02905944f, 0.01430564f, 0.00213962f, 0.01295196f, 0.01557196f, -0.01318030f, -0.00370298f, 
    -0.04561669f, 0.03443676f, 0.04275446f, -0.00888129f, -0.01309881f, 0.02800404f, -0.05246017f, 0.02321120f, 
    -0.05015273f, 0.02019667f, -0.00714213f, -0.00381158f, -0.02407607f, -0.04989924f, -0.04667645f, 0.03425531f, 
    -0.00368579f, 0.01972630f, 0.04376651f, -0.05629062f, -0.03618908f, -0.02121344f, 0.00544934f, 0.02885932f, 
    0.01038397f, -0.04456162f, -0.00804539f, 0.02013463f, -0.03750900f, 0.02285159f, 0.00828764f, -0.01252639f, 
    0.03133926f, -0.04099137f, 0.00376394f, 0.02339725f, 0.00244412f, -0.03742407f, 0.01177518f, 0.00281460f, 
    -0.03785681f, 0.03639708f, 0.03538207f, -0.00716267f, 0.00668925f, 0.02406513f, 0.02249189f, -0.03313612f, 
    0.02475296f, 0.04200429f, 0.01839672f, 0.00076643f, 0.00127959f, 0.04323388f, 0.01749778f, -0.00913626f, 
    -0.05515692f, -0.03862269f, -0.02683736f, 0.02473717f, -0.02085764f, 0.02366065f, -0.02093269f, 0.03265348f, 
    -0.03231139f, -0.04456467f, -0.05034162f, -0.00058132f, -0.03724916f, 0.02322061f, 0.00452378f, 0.03939959f, 
    -0.00247287f, -0.01666103f, -0.00326971f, -0.00579037f, -0.00821386f, 0.02913166f, 0.03375303f, 0.01001216f, 
    0.04165868f, -0.05471940f, -0.00585328f, 0.02162820f, 0.00434962f, -0.01786375f, 0.01181765f, -0.04218640f, 
    -0.02097937f, -0.04592698f, 0.01882278f, -0.04354356f, -0.00254411f, 0.02365818f, -0.04697952f, -0.04310857f, 
    0.03347014f, 0.01867595f, -0.03513257f, 0.01279849f, -0.01784275f, 0.03488211f, 0.02829977f, 0.02357078f, 
    -0.03752059f, -0.01926095f, 0.02532979f, 0.03546757f, 0.01716901f, -0.04476859f, -0.05456638f, 0.00148804f, 
    -0.02858969f, -0.00335727f, -0.02592588f, -0.05535813f, -0.00160844f, -0.01320228f, -0.03980395f, 0.02788923f, 
    -0.03724834f, -0.02767820f, -0.02001085f, 0.02788846f, -0.05480377f, -0.02385846f, 0.01971999f, -0.02959690f, 
    -0.01738094f, -0.00857144f, -0.04700604f, -0.00998386f, 0.01041776f, -0.01391733f, -0.05520985f, -0.04203559f, 
    0.02264682f, 0.01686399f, 0.04089014f, 0.03729656f, 0.01654983f, -0.04529372f, 0.01601122f, 0.01798973f, 
    -0.00600651f, -0.00644041f, 0.02145857f, 0.04319593f, -0.04264809f, -0.00446079f, -0.00859383f, -0.01647438f, 
    0.00188487f, -0.03803048f, 0.01259104f, 0.03899981f, -0.03480935f, 0.01611310f, 0.03292914f, -0.03998995f, 
    -0.00019169f, 0.00740951f, 0.03380844f, 0.01321849f, 0.02069002f, -0.04374193f, -0.03676569f, -0.05285630f, 
    0.03264104f, 0.00800747f, -0.00690074f, -0.01373469f, 0.01400902f, 0.03804212f, -0.05427399f, -0.02066181f, 
    0.03640673f, -0.01429843f, -0.04775266f, -0.01365795f, -0.03677398f, -0.04818108f, 0.03726579f, 0.00345330f, 
    0.02242031f, -0.05546470f, 0.03519823f, 0.02570518f, -0.02167616f, -0.03902489f, -0.04395914f, 0.02908976f, 
    0.04767752f, 0.00767465f, 0.01582446f, -0.00233142f, -0.03181047f, 0.03720538f, -0.03942522f, -0.03245584f, 
    0.02271439f, 0.03863550f, 0.04311319f, -0.01002718f, 0.04341019f, -0.00114215f, 0.04415428f, -0.00558381f, 
    -0.05351465f, -0.04048730f, 0.02903049f, 0.04180897f, -0.00936115f, -0.03239049f, -0.05057646f, 0.04124248f, 
    0.01148952f, -0.02528970f, -0.01027213f, 0.02986235f, -0.02872122f, 0.04490354f, -0.02465002f, 0.04513144f, 
    0.16953816f, 0.28437844f, -0.09281532f, -0.07948142f, 0.12137585f, 0.01522157f, -0.01052493f, 0.26602617f, 
    -0.03967585f, -0.03519605f, -0.00606806f, -0.13085526f, -0.00468988f, 0.06927075f, -0.08447959f, 0.10517918f, 
    0.01173958f, 0.15202066f, 0.09223665f, 0.07107382f, -0.04805521f, 0.14186512f, -0.08639943f, 0.05113510f, 
    0.19944777f, -0.01009794f, -0.05353380f, 0.00051514f, -0.01603094f, -0.03234486f, 0.11763292f, 0.00229497f, 
    0.16910058f, -0.02407851f, -0.24613899f, 0.17125818f, -0.12222910f, -0.01645345f, 0.23964068f, 0.13192099f, 
    -0.01864304f, 0.08275603f, 0.09419169f, 0.07967128f, 0.15759444f, 0.07494843f, -0.03677405f, 0.11335769f, 
    0.21664590f, -0.28071183f, -0.00981178f, -0.12407985f, 0.06956781f, 0.01068445f, 0.12809445f, 0.03218836f, 
    0.18089132f, -0.08673765f, 0.10028099f, -0.00030487f, -0.06987109f, 0.07680398f, 0.01891774f, 0.10542136f, 
    -0.02020792f, -0.00258655f, -0.03409267f, 0.18890099f, 0.15309474f, 0.20372015f, -0.00979968f, -0.03514916f, 
    -0.06219600f, -0.28122917f, 0.15540825f, -0.05102981f, 0.03494368f, 0.09725917f, 0.13723743f, -0.00434798f, 
    0.24973071f, 0.10716781f, -0.03887041f, -0.07070935f, 0.33445397f, -0.03765639f, 0.06626971f, 0.02859227f, 
    0.11441828f, -0.03258255f, 0.13449781f, 0.08712945f, 0.07171188f, 0.07337745f, -0.00533893f, 0.03150105f, 
    -0.20156731f, 0.30620134f, -0.13798742f, 0.28167683f, -0.00418286f, 0.01243895f, -0.07909904f, -0.00260050f, 
    0.17834468f, 0.15564695f, 0.16486107f, 0.11099640f, 0.22773162f, -0.02965917f, 0.09613221f, 0.14585099f, 
    0.18620512f, -0.03540919f, 0.02499648f, 0.01318681f, -0.00108296f, 0.03481150f, 0.08416177f, 0.05028160f, 
    0.00530334f, -0.10893518f, 0.18778014f, -0.10928608f, 0.00327563f, 0.03644176f, 0.06586065f, -0.08886948f, 
    0.03667505f, 0.03699691f, 0.02620394f, 0.22703558f, 0.34788865f, 0.06326068f, -0.20993793f, -0.18375427f, 
    -0.04108468f, 0.05813771f, 0.03650963f, 0.00646535f, -0.05660227f, -0.08707932f, -0.08275858f, -0.04964949f, 
    -0.32303104f, 0.09566186f, -0.04932661f, -0.18496042f, -0.07743250f, 0.02639011f, -0.13502583f, -0.08605649f, 
    -0.03976037f, 0.02634445f, 0.14339934f, 0.06500553f, -0.17418423f, 0.03689057f, 0.14683248f, 0.07543444f, 
    0.10736812f, -0.01973823f, 0.09161323f, -0.05333130f, 0.16137239f, 0.03111665f, 0.02773566f, 0.12658334f, 
    -0.06116921f, 0.15803833f, -0.05995438f, -0.02822397f, 0.08389836f, -0.07647116f, -0.06856075f, 0.05793818f, 
    -0.09755575f, 0.12271757f, 0.09667462f, 0.16678135f, 0.27622736f, 0.35255426f, -0.06347935f, 0.20356151f, 
    0.16810603f, 0.06461523f, 0.02720402f, -0.02417557f, -0.07437450f, 0.11375690f, 0.01696511f, 0.27132934f, 
    0.16518219f, -0.00540089f, -0.12663881f, 0.06950504f, -0.03661959f, 0.08144995f, 0.07814505f, 0.19895567f, 
    -0.00463953f, -0.06597299f, 0.02137489f, -0.00816726f, -0.30015042f, -0.11083011f, 0.10871317f, 0.26686221f, 
    0.12142459f, 0.00132665f, -0.06078023f, -0.08961677f, 0.08368013f, -0.10445735f, 0.10747339f, -0.10525549f, 
    0.35173300f, -0.05791381f, 0.04476242f, 0.11434404f, 0.02848802f, 0.05851848f, 0.07029645f, -0.01225455f, 
    -0.00157759f, 0.08876141f, 0.08821280f, 0.16048357f, 0.09497657f, 0.07787661f, -0.11411028f, 0.15870506f, 
    0.02770402f, 0.07007802f, 0.07011628f, 0.08302997f, 0.09006566f, 0.06342278f, 0.08244488f, 0.02593973f, 
    0.19595054f, -0.21987358f, 0.11595001f, -0.05409222f, 0.03846389f, 0.03509818f, 0.08847982f, 0.12146924f, 
    0.15912014f, -0.00651165f, 0.01128979f, 0.01931654f, 0.01808449f, 0.01116114f, -0.00570448f, 0.20055296f, 
    0.09544714f, 0.14171469f, -0.08436552f, -0.17564781f, -0.01992734f, 0.18705890f, 0.06585041f, 0.26885754f, 
    0.18158235f, -0.06904556f, 0.04597755f, -0.17421579f, 0.11986035f, 0.12399805f, -0.00030319f, -0.01394236f, 
    0.00519436f, 0.21796885f, 0.05717772f, 0.03676434f, 0.03357927f, -0.22257952f, 0.01015032f, -0.05773229f, 
    0.05108161f, -0.04467638f, 0.05811118f, -0.19633789f, -0.04039761f, 0.06752596f, -0.10437317f, 0.12540261f, 
    0.24173868f, -0.07989746f, 0.16426694f, 0.26395336f, 0.13781710f, -0.00518323f, 0.14442389f, -0.03969818f, 
    -0.00649739f, 0.12854621f, 0.08629519f, 0.11433609f, -0.05040614f, -0.04814529f, -0.12948136f, -0.07941756f, 
    -0.08351576f, 0.05623616f, 0.05185714f, 0.19011752f, 0.15584910f, -0.01897551f, 0.11090620f, 0.09778414f, 
    -0.21534987f, -0.11568531f, -0.20887463f, 0.01740254f, -0.10057244f, 0.01356019f, 0.11129650f, 0.05166918f, 
    0.12638298f, 0.05711968f, -0.01985211f, 0.11080282f, 0.00998427f, 0.01942272f, 0.16834669f, 0.17246738f, 
    -0.00972438f, 0.04880055f, -0.01442955f, 0.00863803f, 0.01872429f, -0.09398816f, 0.10350735f, 0.10052333f, 
    0.09822812f, -0.12716612f, 0.01075667f, 0.04346633f, 0.00635988f, 0.07592180f, -0.09757800f, 0.13433546f, 
    0.10271347f, 0.13996391f, 0.15690123f, 0.23282516f, -0.12581919f, -0.16151509f, 0.13940583f, 0.09582614f, 
    -0.01650984f, 0.08383887f, 0.05793773f, -0.08059063f, 0.07800676f, -0.00967316f, 0.25390455f, 0.16500224f, 
    0.03930882f, -0.11507459f, 0.23762241f, 0.01910224f, 0.05175686f, 0.14601819f, -0.00091475f, 0.12835027f, 
    0.01914694f, -0.10929085f, 0.05531957f, -0.10684167f, 0.01468267f, 0.02648541f, 0.07187144f, 0.05608568f, 
    0.14000802f, 0.09981810f, 0.04069512f, 0.19009216f, 0.18701114f, -0.07806978f, 0.04851130f, 0.02287955f, 
    -0.22393708f, -0.15483990f, 0.05789929f, -0.05120010f, 0.01161215f, 0.05936578f, 0.07775353f, -0.12143163f, 
    0.04881289f, 0.08894657f, 0.07094039f, 0.18334676f, -0.05024898f, 0.01454546f, -0.02833152f, 0.05147607f, 
    -0.06431351f, -0.04173345f, -0.04869099f, -0.12179060f, 0.00943036f, -0.04475463f, 0.06155634f, -0.13958919f, 
    -0.10943558f, -0.14554168f, 0.01991129f, 0.03097245f, 0.10319062f, -0.00701982f, 0.06236708f, 0.10291471f, 
    -0.09006073f, 0.04059561f, 0.17000367f, -0.07671227f, 0.18369839f, 0.05732282f, -0.04031379f, 0.02088002f, 
    0.09182403f, -0.00044221f, 0.03521299f, -0.02207058f, -0.03602186f, -0.03675136f, 0.10794928f, -0.06325028f, 
    -0.16361344f, 0.19521692f, -0.16568181f, 0.50168699f, 0.01937084f, 0.01963428f, -0.03182402f, -0.08090980f, 
    0.01606308f, 0.03102659f, -0.00920999f, 0.03911632f, 0.35514590f, -0.00239925f, 0.03839259f, 0.07020186f, 
    0.07422733f, -0.05122729f, 0.09424950f, -0.03633102f, 0.00855764f, -0.02816754f, 0.05775464f, 0.25873461f, 
    0.17846037f, 0.21361117f, -0.21510297f, 0.21917036f, -0.10012233f, 0.00602278f, 0.00416706f, 0.01424452f, 
    -0.23590015f, -0.02941199f, -0.00391302f, 0.08210465f, -0.14986797f, 0.04010944f, 0.04992730f, -0.01541237f, 
    0.09650768f, 0.03496865f, -0.04652501f, 0.03757947f, 0.07411411f, -0.06390216f, 0.20804426f, 0.00628225f, 
    0.42449337f, -0.36884487f, -0.03306341f, 0.10554962f, -0.03578228f, -0.02027263f, 0.04580463f, 0.03742316f, 
    -0.04610760f, -0.03898802f, -0.12693876f, -0.03803435f, 0.06469954f, 0.11324143f, -0.20411949f, 0.06791456f, 
    -0.09808113f, 0.06371048f, -0.04679024f, -0.08177354f, 0.06907684f, 0.01231737f, 0.00976267f, 0.05631824f, 
    -0.09363999f, 0.34047124f, -0.04307187f, -0.11443507f, 0.03883083f, 0.03009897f, 0.06238179f, 0.09033603f, 
    0.08059057f, -0.02098981f, 0.01379935f, -0.14056018f, -0.36911049f, -0.25821933f, 0.13595323f, 0.11900790f, 
    -0.03345029f, 0.08413225f, -0.00999768f, 0.00077624f, 0.05225987f, 0.06761318f, 0.10539195f, 0.12530877f, 
    -0.08047227f, -0.03665077f, -0.09803177f, 0.10371400f, 0.14304297f, 0.07177256f, 0.16674162f, 0.17998986f, 
    0.00680815f, -0.03593358f, -0.01499029f, 0.00976592f, 0.05267366f, 0.18400541f, -0.14301173f, -0.14118999f, 
    0.11032335f, -0.00251667f, 0.05443149f, 0.12521060f, -0.05680052f, -0.00264286f, -0.03570600f, -0.04726630f, 
    0.15630537f, -0.06203761f, 0.20144914f, -0.09301342f, -0.03235539f, -0.03337743f, 0.06549468f, -0.04798993f, 
    0.06698844f, -0.02595863f, -0.09565832f, -0.21393993f, -0.04906863f, -0.11117970f, 0.22579266f, 0.07111339f, 
    -0.02407244f, -0.07640316f, 0.11553171f, 0.08042151f, 0.06522237f, -0.09277376f, 0.11121881f, -0.04552753f, 
    -0.26940933f, 0.10626718f, 0.21247268f, -0.16546801f, 0.07894628f, -0.07641649f, 0.06380171f, -0.03679347f, 
    0.06490421f, 0.12696511f, -0.01182759f, -0.07973192f, 0.11881119f, 0.24099500f, -0.05337252f, -0.04190154f, 
    0.05593907f, 0.20492250f, 0.04306906f, 0.14038058f, 0.06006486f, 0.12869513f, 0.01329290f, 0.06299777f, 
    -0.18245874f, 0.08055574f, -0.09018610f, 0.18690592f, 0.05753410f, -0.02985860f, -0.13525227f, 0.02335899f, 
    -0.09972896f, -0.01522762f, -0.07823531f, -0.01326121f, -0.15739164f, -0.20504019f, 0.23982988f, -0.27671200f, 
    0.00747134f, -0.15014924f, 0.14626049f, -0.09078064f, -0.05982243f, -0.07944319f, 0.05365631f, -0.03972793f, 
    -0.12391861f, 0.09712365f, -0.00129646f, 0.07607394f, 0.16611686f, -0.00578577f, -0.00786029f, 0.01064160f, 
    0.02805657f, -0.01535335f, 0.05968732f, -0.03395358f, 0.11927135f, 0.05018130f, -0.02715419f, 0.09906572f, 
    0.08183847f, -0.10774547f, 0.06703208f, 0.07522461f, 0.08112805f, -0.20549129f, 0.06187595f, -0.26613414f, 
    -0.20576593f, 0.02534463f, 0.06951144f, 0.15264067f, 0.02050036f, -0.02474282f, 0.06476988f, -0.05533988f, 
    -0.04326408f, -0.05967523f, 0.07508602f, 0.01888405f, -0.17190786f, 0.12300494f, -0.03817805f, 0.30082622f, 
    0.02462367f, 0.07908007f, -0.00655877f, 0.20757225f, 0.14608957f, 0.08901966f, 0.09912837f, 0.10120833f, 
    -0.04542303f, -0.10279944f, -0.05370525f, -0.12589362f, -0.06803214f, 0.09494360f, -0.03146334f, 0.08707569f, 
    0.03937284f, -0.15614386f, -0.06316747f, -0.12966475f, 0.09420589f, -0.03801473f, 0.22259428f, 0.05332852f, 
    0.12516980f, -0.00291696f, -0.05252425f, -0.12310264f, -0.04232489f, 0.07983407f, -0.08094692f, 0.00090194f, 
    -0.12373898f, 0.10334731f, 0.07052980f, 0.24819472f, 0.17645232f, 0.03692951f, -0.08277024f, 0.10307030f, 
    -0.10407294f, 0.09437912f, -0.00226784f, -0.04603475f, 0.17121427f, -0.09046719f, 0.09009518f, 0.00493892f, 
    0.04407724f, 0.06389189f, 0.12671225f, 0.07144784f, 0.04208419f, 0.00015877f, -0.06050552f, -0.04454836f, 
    0.14938276f, 0.10226593f, 0.02602354f, 0.05905763f, 0.11657828f, 0.06081400f, 0.14396878f, 0.04978787f, 
    -0.02259592f, -0.09912268f, -0.12463539f, -0.17792377f, -0.03408456f, 0.29927075f, 0.05610490f, -0.09714425f, 
    0.10272465f, -0.04529306f, 0.03212187f, 0.09946098f, 0.06626090f, 0.07876040f, -0.01827141f, -0.00327002f, 
    0.03135371f, 0.09102009f, -0.03966014f, -0.08596583f, 0.10897528f, -0.16403913f, 0.13295102f, 0.01348041f, 
    -0.05170123f, 0.10546087f, 0.06236412f, 0.12856856f, -0.05659107f, 0.12155398f, -0.25192261f, 0.00468508f, 
    -0.01288854f, 0.03796641f, -0.10851248f, -0.13345303f, -0.11250126f, 0.17984186f, 0.03743682f, 0.04550443f, 
    -0.00828123f, -0.02688590f, -0.02926016f, -0.02530114f, -0.01461811f, 0.02532877f, -0.03428482f, -0.00810238f, 
    -0.04989390f, -0.00341151f, -0.00502908f, 0.02852096f, 0.00267706f, 0.01316216f, -0.01383468f, -0.00981398f, 
    0.03241971f, -0.02871390f, -0.05104148f, 0.01183696f, -0.05921278f, 0.05079896f, 0.01124586f, 0.02277922f, 
    0.00522341f, 0.03766489f, 0.00401574f, 0.02329159f, 0.01909602f, 0.00809408f, 0.02254367f, 0.03606218f, 
    -0.01008942f, 0.02618629f, 0.01247522f, -0.01018158f, -0.02195909f, -0.03030803f, 0.02038689f, 0.01191240f, 
    -0.04902584f, -0.05492571f, -0.00940496f, -0.01141737f, 0.00049205f, 0.01084934f, -0.03930402f, 0.03553224f, 
    0.00712725f, 0.02739643f, -0.04271356f, -0.02871047f, -0.02363969f, 0.01080068f, -0.00520032f, -0.03095656f, 
    0.01266769f, 0.03509884f, -0.02982973f, -0.03294978f, -0.00184595f, 0.04084776f, 0.00767447f, 0.01769621f, 
    -0.01395105f, -0.03698487f, -0.01201583f, 0.00930674f, -0.04618215f, -0.03986774f, -0.04627188f, -0.03021352f, 
    0.03567754f, -0.04308777f, 0.04751386f, -0.03306882f, -0.01471867f, 0.00619527f, 0.00100275f, -0.04279698f, 
    -0.01232046f, -0.01916704f, -0.05490992f, -0.02462498f, 0.02827585f, -0.05566560f, -0.02771222f, -0.00999897f, 
    0.00218962f, -0.00091267f, -0.03659977f, -0.04231463f, 0.03559284f, 0.00686553f, -0.05329897f, 0.03622257f, 
    -0.02658724f, 0.03611620f, 0.02888542f, -0.02366352f, -0.04713118f, 0.04488117f, 0.01881265f, 0.02487055f, 
    0.04152620f, -0.03036464f, 0.03721490f, 0.02209135f, -0.00622855f, -0.01667575f, -0.00491095f, -0.03513958f, 
    -0.04464743f, -0.00015483f, 0.00618859f, -0.03505991f, -0.01502824f, 0.02884742f, -0.02682799f, 0.02715381f, 
    -0.00475959f, 0.05077823f, 0.00519741f, 0.05539536f, 0.00604812f, -0.02505219f, -0.03375645f, -0.02913385f, 
    -0.02712939f, -0.00068772f, 0.03270945f, 0.03912106f, 0.03956642f, -0.03198379f, -0.01871665f, -0.01562339f, 
    0.01588001f, -0.02721795f, 0.03332180f, -0.01803260f, -0.03108788f, -0.04093734f, 0.03286739f, 0.02232782f, 
    0.03246602f, -0.05265785f, 0.02001792f, -0.02144098f, 0.01175425f, -0.02425879f, -0.01004594f, -0.02544065f, 
    0.01769851f, -0.02445781f, -0.04249121f, 0.03988258f, 0.04314695f, -0.03470486f, -0.01606067f, 0.04811685f, 
    -0.02941556f, 0.01680485f, 0.03122574f, -0.02471928f, 0.04017721f, 0.00767274f, -0.03590161f, -0.02654491f, 
    -0.06297868f, -0.04798531f, 0.04320957f, -0.02339909f, -0.02346778f, -0.04332412f, 0.03392586f, -0.00014591f, 
    -0.02916699f, -0.03112276f, 0.03717484f, 0.01125859f, -0.01850064f, 0.00299891f, -0.02321670f, -0.02592382f, 
    -0.05149632f, -0.01444098f, -0.02115370f, -0.01025875f, -0.05662523f, 0.03083843f, 0.02383810f, 0.02410734f, 
    -0.04206173f, 0.02729284f, -0.03523220f, 0.02821512f, -0.03156033f, 0.03725771f, -0.01711261f, -0.02791427f, 
    -0.03587841f, -0.00683488f, -0.03065699f, -0.04469855f, 0.03631598f, 0.04327743f, -0.01953792f, -0.03691526f, 
    -0.00699819f, -0.02159404f, 0.01634345f, 0.04067838f, -0.03206092f, 0.01371718f, -0.04076002f, 0.00586532f, 
    -0.05205667f, 0.02644777f, 0.00002102f, 0.02776182f, -0.03068661f, 0.02037769f, 0.02311647f, -0.04761475f, 
    -0.05676917f, 0.02279245f, -0.02500501f, 0.03796671f, 0.03695154f, -0.00102660f, -0.03592566f, -0.03506460f, 
    -0.00073644f, 0.04169192f, 0.04643956f, -0.02604828f, -0.01449107f, 0.01441059f, 0.00923059f, 0.00982503f, 
    0.03771049f, 0.01039388f, 0.05043724f, -0.00119888f, 0.01987356f, 0.00381493f, -0.02682793f, -0.04795587f, 
    -0.00154245f, -0.03243314f, 0.00592623f, -0.00973317f, -0.05569256f, 0.03315393f, 0.04176651f, 0.02734986f, 
    -0.02827713f, 0.03983583f, -0.00649861f, 0.03988945f, -0.04924745f, 0.00009452f, -0.01327285f, -0.01557922f, 
    0.03645755f, 0.01662713f, -0.00715582f, 0.02878185f, -0.02605365f, 0.03807339f, 0.02480816f, -0.04127195f, 
    0.03003834f, -0.03530347f, -0.01796375f, 0.02977201f, 0.00135570f, -0.04324071f, -0.03936241f, 0.02333833f, 
    -0.00766470f, 0.02926658f, -0.05772093f, -0.03378167f, -0.01348751f, 0.04742324f, -0.02067306f, 0.01187311f, 
    -0.05561495f, -0.02886330f, -0.04899804f, 0.01836387f, 0.00273375f, -0.04055806f, 0.04972743f, -0.04085443f, 
    -0.03503690f, -0.04234860f, 0.03626972f, -0.05667201f, -0.01438256f, -0.01314574f, 0.02825502f, -0.02070628f, 
    -0.04894364f, -0.00648463f, 0.00203559f, 0.04034494f, 0.00249447f, -0.04128992f, 0.00420521f, -0.01932688f, 
    -0.00215847f, -0.04290824f, 0.03940596f, -0.03552178f, -0.00427132f, -0.02065747f, 0.03892573f, 0.02926487f, 
    -0.03999106f, -0.04864469f, 0.05003585f, -0.00413718f, 0.01204122f, -0.04164262f, 0.01897974f, -0.03047269f, 
    -0.00648517f, -0.02144623f, -0.02524799f, 0.03900863f, 0.03569863f, 0.03580245f, -0.00583369f, -0.00908518f, 
    0.00807627f, 0.03345897f, 0.01556807f, -0.04316765f, -0.03967870f, -0.01737313f, -0.01781238f, -0.03104476f, 
    -0.02781350f, 0.01153156f, -0.00346654f, 0.00066944f, 0.04469989f, -0.03582468f, 0.03271724f, 0.02439842f, 
    0.00769118f, 0.00000641f, -0.05055570f, -0.04119609f, -0.06008004f, -0.04049110f, 0.02865981f, 0.00340299f, 
    0.00077955f, 0.01749435f, 0.00714690f, 0.03196343f, -0.04636188f, 0.03729109f, 0.02314183f, 0.04908312f, 
    0.01564734f, -0.00166484f, -0.02582655f, 0.01449544f, -0.04050327f, -0.01822133f, -0.04088438f, -0.03072070f, 
    0.04237886f, -0.05029816f, 0.00074117f, 0.02363146f, -0.02016089f, 0.04013647f, 0.00146633f, -0.04560984f, 
    0.03250986f, -0.00565612f, -0.07437687f, 0.10815454f, -0.00000209f, 0.05640917f, 0.07065381f, 0.15177251f, 
    0.01689296f, 0.11435623f, -0.07083263f, 0.12773702f, 0.25164449f, -0.14828515f, -0.05757413f, -0.09928910f, 
    -0.10454153f, -0.03281574f, -0.02761637f, 0.19160518f, -0.01928948f, -0.05113760f, -0.12541927f, -0.00690289f, 
    0.08175786f, 0.08789674f, -0.26818982f, 0.03986361f, -0.18084516f, 0.06327252f, -0.23187760f, 0.07065177f, 
    0.00611436f, 0.00269420f, 0.14247376f, -0.06233189f, -0.04048308f, -0.02364136f, 0.24815202f, -0.02593395f, 
    -0.11982465f, -0.01147434f, -0.02003955f, 0.03983836f, 0.02756708f, 0.06657742f, -0.00444751f, -0.05422347f, 
    0.05913460f, -0.29416060f, 0.20483626f, -0.35335127f, 0.08778898f, -0.09899066f, 0.28002548f, 0.14737831f, 
    -0.13364193f, -0.03608602f, 0.02514488f, 0.10554507f, 0.26102066f, 0.24774291f, -0.21015751f, -0.15545624f, 
    -0.13613541f, 0.22628018f, 0.10396491f, 0.00810311f, -0.05981775f, 0.11330481f, 0.08798190f, 0.07076311f, 
    -0.24023592f, -0.25561035f, 0.04294884f, -0.19216998f, -0.03693009f, -0.09282663f, 0.06459121f, 0.05355728f, 
    0.04352927f, 0.05109060f, 0.10794417f, 0.02968524f, -0.14298019f, -0.01625634f, 0.02749407f, -0.02152176f, 
    -0.01978580f, 0.11896193f, -0.09256505f, 0.00822755f, 0.08463588f, 0.03850407f, -0.14609508f, 0.02510613f, 
    -0.49556488f, 0.21068987f, 0.12311523f, -0.18210925f, 0.01688340f, 0.16344085f, -0.00035187f, 0.08657500f, 
    0.03684174f, 0.14761178f, -0.10637229f, -0.08457141f, 0.02200224f, -0.26094851f, 0.22151923f, -0.08197197f, 
    0.12843972f, 0.04670292f, 0.26462734f, 0.09903532f, -0.07405389f, 0.08302234f, -0.02227190f, 0.07299962f, 
    0.14412850f, -0.04485171f, 0.10958361f, 0.21958049f, -0.16894490f, 0.06559893f, 0.01086301f, 0.20868279f, 
    0.04374450f, -0.02745198f, 0.02570250f, -0.00391195f, 0.32731274f, -0.09825543f, -0.23344499f, -0.01363762f, 
    0.02443998f, 0.02352163f, -0.12893006f, 0.13632686f, 0.05431742f, 0.11930076f, 0.15664645f, 0.12362615f, 
    0.19672650f, -0.06950289f, 0.16174890f, 0.00822544f, -0.02471138f, 0.20847601f, 0.04534299f, 0.05250281f, 
    -0.08135406f, 0.13116466f, 0.18073675f, 0.10775641f, -0.04777143f, -0.14342107f, 0.06338682f, 0.09686276f, 
    0.07105418f, 0.08768722f, 0.08594679f, 0.15928978f, 0.05787051f, -0.05159768f, 0.13025340f, -0.00999638f, 
    -0.02363319f, 0.29256812f, -0.13314641f, 0.22514741f, 0.04241409f, 0.04593939f, -0.03326833f, 0.09129579f, 
    -0.09612348f, -0.15235639f, 0.00786107f, -0.10196332f, 0.21543594f, 0.20215365f, -0.16706675f, -0.27562061f, 
    0.01724522f, 0.05775266f, 0.11422554f, -0.02952958f, -0.11104781f, 0.01594784f, -0.08460795f, -0.12066378f, 
    0.28626406f, -0.14556737f, -0.17385563f, 0.23678240f, -0.07637487f, 0.10854945f, -0.03518371f, -0.02379076f, 
    -0.01818595f, -0.11095705f, -0.02842509f, 0.14470777f, -0.07445547f, 0.00437287f, 0.08447108f, 0.02674627f, 
    0.02262101f, 0.21174441f, 0.11155525f, 0.08794329f, -0.02599166f, 0.01128740f, 0.05619107f, 0.09341504f, 
    0.25291386f, -0.04364004f, 0.24349287f, -0.12401792f, 0.05977198f, 0.12628363f, 0.03448268f, -0.01138831f, 
    0.05237617f, 0.01982386f, -0.05309167f, 0.01917000f, 0.22202951f, 0.23752844f, -0.05452274f, 0.25848988f, 
    0.13215102f, 0.07934470f, 0.08820230f, -0.00590820f, 0.06729753f, 0.15175770f, 0.05069740f, 0.03329926f, 
    -0.01869360f, -0.07275055f, 0.12874280f, 0.03417984f, 0.02894671f, 0.07646152f, 0.04497040f, 0.02728685f, 
    0.04094656f, 0.08454473f, -0.00031137f, 0.11117244f, 0.17655060f, 0.18561837f, -0.05301436f, -0.21590497f, 
    0.04336910f, -0.01564038f, 0.11430193f, 0.21667922f, 0.12604201f, -0.01018307f, -0.05449226f, 0.01415111f, 
    0.17583434f, 0.07965059f, -0.18955320f, -0.01356631f, -0.16166970f, -0.14570335f, -0.03857593f, 0.19011052f, 
    0.06499364f, -0.00250041f, 0.01188818f, 0.02275313f, 0.02870892f, -0.18505298f, 0.11365613f, -0.04332826f, 
    -0.00110639f, 0.01635338f, 0.12784612f, 0.01695665f, -0.01398508f, 0.04067781f, 0.21573772f, 0.02689146f, 
    0.14606093f, 0.21254221f, 0.26348862f, 0.07467144f, 0.10426302f, 0.12797211f, 0.06064964f, -0.05079503f, 
    -0.09884787f, -0.11116247f, -0.03100738f, 0.04380387f, -0.10260150f, 0.04609193f, -0.24829896f, -0.06945340f, 
    -0.05666021f, -0.08441179f, -0.10538602f, 0.12756324f, -0.04103139f, 0.01965735f, -0.02224431f, 0.07558901f, 
    0.36839941f, -0.18639646f, 0.06222827f, -0.33346793f, -0.19884662f, 0.09803271f, -0.09750915f, -0.04246232f, 
    0.06232365f, -0.08076999f, 0.04852872f, -0.01677712f, 0.08821085f, 0.32895622f, 0.12307718f, 0.09728637f, 
    -0.02301987f, 0.08528805f, 0.00268824f, 0.11496194f, 0.12327441f, 0.00117256f, -0.20041314f, -0.00768188f, 
    -0.10388832f, -0.08483902f, 0.02664765f, 0.10778634f, 0.11911080f, 0.05724977f, 0.07662242f, -0.15785167f, 
    -0.00194843f, 0.00608221f, -0.14401475f, 0.17484006f, 0.13781397f, 0.25183374f, 0.17151476f, 0.09080287f, 
    -0.10422602f, 0.06542265f, 0.00260187f, 0.07238170f, 0.15953843f, 0.03666965f, -0.15565696f, 0.08363968f, 
    0.02257106f, -0.05514160f, -0.19384727f, -0.13259444f, -0.04940774f, 0.17145143f, -0.06345627f, -0.05240056f, 
    -0.02324010f, 0.07032989f, 0.02306720f, 0.16706140f, 0.01637201f, -0.11527191f, 0.18336295f, -0.05066539f, 
    -0.12001019f, 0.13249797f, 0.26822460f, -0.05440033f, 0.02669333f, -0.03402181f, 0.03832152f, 0.16957094f, 
    0.03448143f, 0.02419099f, -0.01338329f, -0.01651774f, 0.03544782f, 0.05668948f, -0.00947383f, 0.02584919f, 
    0.02997534f, -0.00350011f, -0.04912694f, -0.02419866f, 0.01451100f, -0.04447544f, -0.03250045f, -0.00075673f, 
    -0.00980467f, 0.01449924f, -0.02039677f, -0.03275383f, -0.00019830f, -0.03644020f, -0.00570444f, -0.04367013f, 
    -0.05553667f, 0.02212539f, 0.02680969f, -0.03708519f, -0.05014186f, 0.02482834f, -0.02274325f, -0.05737231f, 
    0.00570149f, 0.00591694f, 0.03214888f, -0.00991000f, -0.00580199f, 0.00462961f, 0.02646371f, 0.03263930f, 
    -0.01064834f, 0.01961479f, 0.02019574f, 0.01209762f, 0.01303949f, 0.02251817f, -0.03935123f, -0.04949364f, 
    0.00219359f, -0.04711964f, 0.00774544f, -0.03419156f, 0.04083432f, -0.02145003f, -0.02508141f, -0.03841238f, 
    -0.03014673f, 0.00446207f, -0.00777812f, 0.04051972f, -0.04325138f, 0.00067899f, 0.02518870f, 0.00078862f, 
    0.04744464f, 0.03551089f, -0.01381836f, -0.04509279f, -0.03197291f, -0.03720759f, -0.04145683f, 0.03892564f, 
    0.01769410f, -0.02914023f, 0.02218531f, 0.03204062f, 0.00156613f, -0.04127325f, 0.00511849f, 0.02673686f, 
    0.02084365f, 0.01091764f, 0.00287086f, -0.04131488f, -0.04946633f, 0.02113876f, -0.00696880f, 0.00797439f, 
    -0.03811770f, -0.02045888f, -0.01631435f, -0.02596149f, -0.02744308f, -0.01244508f, 0.00144492f, -0.03561027f, 
    0.03694715f, 0.02761904f, 0.01757057f, -0.05196292f, 0.03688584f, 0.01683355f, -0.00379483f, -0.01864887f, 
    0.00657208f, -0.04430319f, -0.00410671f, -0.01331812f, -0.02613971f, 0.03690071f, -0.01398195f, 0.03523006f, 
    0.02750777f, -0.03397945f, -0.00820289f, 0.03391765f, -0.03891528f, -0.00177472f, -0.04067717f, -0.01971948f, 
    -0.01002261f, -0.03196846f, -0.03844364f, -0.04211338f, -0.00144617f, 0.03279471f, 0.02831821f, 0.03978282f, 
    0.03003788f, -0.04189648f, -0.03686642f, -0.03661702f, 0.03620932f, 0.03599526f, 0.00444321f, 0.02116230f, 
    -0.01250449f, -0.02111111f, -0.05203710f, 0.03893194f, 0.03037811f, 0.03238747f, 0.00138579f, -0.01656208f, 
    0.02036937f, 0.04480060f, -0.00546023f, -0.01507950f, 0.04098704f, -0.05099317f, -0.05641057f, -0.01741742f, 
    0.01748599f, -0.00283731f, 0.01322230f, 0.02553112f, -0.04479460f, -0.03417362f, 0.00619683f, 0.00991130f, 
    0.00804807f, 0.02831901f, 0.00102859f, -0.04198050f, -0.01760367f, -0.00996195f, 0.02073276f, 0.02966959f, 
    -0.01634759f, -0.00872017f, 0.01289373f, 0.03974819f, -0.02186688f, -0.03481828f, 0.02447176f, 0.01158139f, 
    -0.04207399f, -0.05688823f, 0.00628140f, 0.01967652f, -0.04355531f, 0.03041002f, 0.03302512f, -0.02824913f, 
    -0.04837598f, 0.00456228f, 0.00075157f, 0.01649328f, -0.05091068f, 0.01888223f, -0.04972135f, -0.04102812f, 
    -0.02413100f, -0.01904605f, -0.02976559f, 0.00086036f, -0.05298151f, -0.05673658f, -0.04233248f, -0.03570533f, 
    0.00731903f, 0.02628031f, 0.04242153f, -0.04381051f, 0.00716802f, -0.03495384f, 0.00262477f, 0.01701491f, 
    -0.03654460f, -0.00409200f, 0.04058617f, -0.01000471f, 0.03133834f, 0.00003067f, -0.01224298f, -0.02710967f, 
    0.02973057f, 0.03243247f, 0.01636565f, 0.00907905f, 0.03217487f, -0.05163303f, -0.03360672f, -0.01208400f, 
    -0.00742753f, -0.03757251f, -0.02203621f, -0.04025663f, -0.00257694f, 0.01826751f, 0.01426050f, 0.01216731f, 
    0.03468075f, -0.02412586f, -0.03688454f, -0.02890889f, -0.05520077f, 0.00278884f, 0.04577568f, 0.02495560f, 
    -0.01688416f, 0.03552435f, -0.02059112f, -0.05862953f, 0.00424992f, 0.04194668f, -0.05796519f, 0.01995992f, 
    -0.03048154f, -0.04843744f, -0.04676234f, -0.02656194f, 0.02193827f, -0.03094329f, -0.05778591f, 0.00872893f, 
    -0.01579934f, 0.00656219f, -0.03226612f, -0.01848682f, 0.02553724f, -0.03143626f, 0.01138747f, -0.03494337f, 
    -0.04616285f, -0.05093881f, -0.04418602f, -0.03230583f, -0.05232529f, 0.02463225f, 0.03880827f, 0.00322900f, 
    -0.00159660f, -0.05604513f, 0.00735023f, -0.00263306f, -0.00671901f, -0.03311383f, -0.04903898f, -0.00639542f, 
    0.01025589f, -0.02209181f, -0.04674247f, -0.03912040f, -0.03395871f, -0.04078964f, -0.03710669f, -0.04360632f, 
    -0.04547001f, -0.00241519f, -0.02353236f, -0.02462064f, -0.02339715f, 0.00536975f, 0.02059005f, -0.03470124f, 
    -0.03426482f, -0.03528521f, -0.02094021f, 0.02402439f, -0.05411538f, 0.01190139f, 0.03553630f, 0.00267299f, 
    -0.05508652f, -0.05351530f, 0.04226856f, -0.04479021f, 0.02542254f, 0.04386606f, -0.02406166f, -0.02346650f, 
    -0.05730348f, 0.04003566f, -0.02690200f, -0.01735321f, -0.04303430f, -0.02850981f, 0.02521044f, 0.02016648f, 
    0.04233155f, 0.03984687f, 0.03579963f, 0.01299719f, -0.04656751f, 0.01859540f, 0.02927922f, 0.01271637f, 
    -0.02591253f, -0.02295095f, -0.05297839f, 0.03627658f, -0.05698235f, -0.00574582f, 0.00649795f, -0.02988100f, 
    -0.04376597f, -0.02977394f, -0.05456927f, -0.01801004f, -0.01503553f, -0.00765910f, -0.00769396f, -0.05536147f, 
    -0.03525470f, -0.03754094f, -0.03751825f, -0.00397712f, -0.01736259f, 0.00355396f, 0.03241967f, -0.05110202f, 
    -0.05747365f, 0.03476680f, -0.00167889f, -0.01606893f, 0.02021215f, -0.00153940f, 0.01094396f, -0.01234633f, 
    -0.03776573f, 0.00070418f, -0.04071734f, -0.01185717f, 0.01904165f, 0.00142113f, 0.01119695f, 0.02036838f, 
    0.00340554f, -0.04521328f, -0.05073325f, -0.01076477f, -0.01201122f, -0.01046206f, -0.01746459f, -0.02798113f, 
    0.02767895f, -0.01338018f, -0.01137760f, 0.00080618f, -0.04479050f, -0.02306428f, 0.00586482f, 0.01172028f, 
    0.24174646f, 0.17721167f, -0.13726810f, 0.08369259f, 0.03997602f, -0.04286530f, -0.03376159f, 0.05935580f, 
    -0.02000627f, -0.08080228f, 0.02516729f, -0.10454834f, 0.02498796f, 0.03618997f, 0.11094514f, 0.08341470f, 
    0.04549832f, 0.00162326f, -0.01288160f, 0.07865357f, -0.02102926f, -0.00351962f, 0.01774317f, 0.08728561f, 
    0.08637863f, -0.02477477f, 0.03347901f, 0.06729410f, -0.00736942f, 0.01868310f, -0.10121024f, -0.06232553f, 
    0.05446396f, -0.01549669f, -0.07185891f, 0.03017073f, 0.12904602f, -0.05559383f, -0.08016548f, -0.07469723f, 
    0.03955760f, 0.06904747f, 0.10187728f, 0.03469693f, 0.12486365f, -0.00226491f, -0.05847267f, 0.04885241f, 
    0.08896442f, 0.09541586f, 0.13345006f, -0.24901325f, -0.02957921f, 0.04578430f, -0.04033291f, 0.07183974f, 
    -0.06587232f, 0.00041535f, 0.02142072f, -0.01811132f, -0.65879363f, -0.11178207f, -0.18026365f, -0.05090419f, 
    -0.01070864f, 0.05889275f, -0.09699221f, -0.01430297f, 0.02404951f, 0.03076714f, -0.04443533f, -0.21655299f, 
    -0.26680467f, -0.18324879f, 0.07564490f, -0.12920122f, 0.07140960f, 0.01329049f, 0.00662890f, 0.01000864f, 
    0.12396117f, 0.03553861f, 0.02893792f, 0.03085062f, -0.10617323f, 0.01159687f, -0.10026381f, 0.10490696f, 
    -0.00119388f, 0.07171097f, 0.07328096f, -0.01578239f, -0.05594012f, 0.21998094f, -0.15316547f, -0.00457731f, 
    -0.06343988f, 0.21544737f, -0.04256308f, -0.11034478f, 0.02469480f, 0.01695411f, 0.00623989f, 0.06507695f, 
    0.16190718f, 0.03019837f, 0.15468661f, 0.09116051f, -0.08996126f, 0.07804891f, 0.06006921f, -0.06364483f, 
    0.10701930f, -0.11958986f, 0.07266691f, 0.14514700f, -0.06295691f, 0.00399413f, 0.08243867f, -0.08431024f, 
    0.14017373f, -0.24540879f, -0.11623821f, 0.04219684f, 0.05762307f, 0.05308471f, 0.03337203f, -0.05370292f, 
    -0.01642068f, 0.05255275f, 0.05943518f, 0.18234318f, 0.37570953f, 0.09442561f, -0.07329903f, 0.07934072f, 
    0.11621493f, -0.04253488f, -0.01080748f, 0.12681128f, 0.03137522f, -0.09930964f, -0.06532501f, -0.07331690f, 
    0.12146526f, 0.01522747f, -0.01736176f, -0.22990997f, 0.05641007f, 0.10468800f, -0.11966100f, -0.08276292f, 
    0.07993320f, 0.00232801f, 0.05437439f, -0.08277496f, -0.03278999f, -0.18648553f, -0.08858658f, -0.01738974f, 
    0.07753029f, 0.08668169f, 0.04141956f, 0.01557733f, 0.08639131f, -0.08178975f, 0.09890558f, 0.07102909f, 
    -0.13302338f, 0.19900790f, -0.14156291f, -0.02921707f, 0.03560662f, 0.07685199f, -0.07879706f, 0.08855116f, 
    -0.19344313f, -0.01606767f, 0.06262410f, 0.23880075f, 0.05869899f, -0.04939554f, -0.31460890f, -0.08903507f, 
    0.04048313f, 0.17211559f, -0.00983123f, -0.10435426f, -0.03942793f, 0.05483437f, -0.02032432f, 0.14301199f, 
    0.46780404f, -0.00796995f, -0.04966336f, 0.22494358f, -0.01030058f, 0.03395942f, -0.06442913f, -0.01161121f, 
    -0.09515639f, -0.05410810f, 0.11076567f, -0.00199970f, 0.04782344f, -0.27356052f, 0.10584155f, -0.07522751f, 
    -0.10037108f, -0.04913797f, 0.04700082f, -0.09493563f, 0.05247715f, -0.02199931f, 0.04595009f, -0.00405415f, 
    0.13645138f, -0.14646797f, -0.12555991f, -0.16112219f, -0.06846443f, 0.05487435f, 0.09114493f, 0.01458436f, 
    0.10558845f, 0.07461170f, 0.12379101f, 0.07804772f, 0.15365589f, 0.09922945f, -0.13551280f, 0.14404196f, 
    0.04019336f, 0.14513107f, -0.06842253f, 0.05500745f, 0.13990086f, 0.09682965f, 0.00066301f, -0.02639758f, 
    0.18511938f, -0.16233882f, 0.03684678f, -0.09844280f, 0.02088434f, 0.05866725f, 0.06594533f, 0.03132575f, 
    0.00735311f, 0.03052563f, -0.06909768f, 0.07538521f, -0.07995673f, -0.15086408f, -0.01477092f, -0.03610705f, 
    0.02669338f, 0.14358971f, -0.07105532f, 0.00593341f, -0.10830873f, 0.16863438f, -0.06798138f, 0.17406420f, 
    0.27301040f, 0.05881597f, 0.11590168f, 0.07403395f, -0.03570452f, 0.03769252f, -0.07825692f, 0.03366189f, 
    0.02648126f, 0.06102069f, 0.03829791f, 0.00038347f, 0.01589804f, 0.00253522f, 0.09439313f, -0.17209658f, 
    -0.01658848f, -0.17977870f, 0.07484911f, -0.07339069f, -0.02314782f, -0.00911847f, -0.00488266f, -0.10605672f, 
    -0.04432522f, -0.01896450f, 0.05377235f, 0.07255219f, 0.05064812f, 0.03496339f, 0.09637479f, -0.08205085f, 
    -0.00195890f, 0.12667565f, 0.07631298f, 0.06555895f, -0.07827977f, -0.10881537f, -0.13082868f, 0.06528457f, 
    -0.01014395f, 0.00244455f, 0.02456366f, 0.15719831f, 0.10534155f, -0.04922573f, 0.05562505f, 0.00518283f, 
    0.10184268f, -0.18077208f, 0.01161576f, -0.14321801f, -0.07520082f, -0.02983941f, 0.00975300f, 0.03274107f, 
    0.17445473f, -0.05335752f, 0.12719347f, 0.06931247f, -0.14982577f, -0.01994749f, -0.11493518f, 0.04326535f, 
    0.05848966f, 0.05006225f, -0.00850583f, 0.03769615f, 0.04464259f, -0.00455332f, 0.04370165f, -0.10033730f, 
    -0.22487904f, 0.09566396f, 0.11521006f, 0.05297473f, -0.07882022f, -0.10084897f, -0.05124752f, -0.11606520f, 
    0.15724798f, 0.14650311f, 0.11244039f, 0.13015777f, 0.12074976f, -0.23412754f, -0.33827195f, 0.09773235f, 
    0.00027689f, 0.05008034f, 0.06265012f, -0.00137261f, 0.01307795f, 0.00815828f, 0.04267237f, 0.08856750f, 
    -0.15383062f, 0.10670817f, -0.05519678f, 0.13731490f, 0.07076587f, 0.02151117f, -0.16363409f, 0.11012679f, 
    -0.02208208f, -0.09534891f, -0.03306331f, -0.01861928f, -0.04721525f, 0.13030019f, -0.00459418f, -0.02601711f, 
    -0.00068022f, -0.04782380f, 0.13054743f, 0.13166904f, 0.16497345f, -0.13635960f, -0.08138692f, 0.07205606f, 
    0.28761920f, -0.03425321f, -0.03373430f, -0.00718779f, 0.00069417f, -0.06309561f, 0.01956484f, -0.01493284f, 
    -0.02192777f, -0.05381617f, -0.00188245f, -0.05369705f, -0.01063102f, 0.18328342f, 0.23097908f, 0.09190403f, 
    -0.00292200f, 0.06480672f, 0.14139466f, 0.14739136f, -0.10784785f, -0.10792242f, 0.09600398f, -0.01552134f, 
    0.20508061f, -0.05666476f, 0.08932731f, 0.05658701f, -0.08680125f, 0.06682920f, -0.17699330f, -0.11456221f, 
    -0.04703079f, -0.00229244f, 0.08048213f, 0.02002784f, 0.07186320f, 0.23169899f, -0.00437497f, 0.02073510f, 
    0.19940363f, -0.02054440f, 0.03581275f, -0.07372828f, 0.04775377f, 0.09396937f, 0.02558490f, -0.10328518f, 
    -0.12568049f, 0.24507630f, 0.16106933f, 0.06018135f, 0.04108956f, 0.12992834f, 0.02738986f, 0.04600602f, 
    0.00266832f, -0.03144126f, 0.02861360f, 0.03251483f, -0.29409724f, -0.21123514f, -0.44440141f, -0.29311511f, 
    0.06626832f, 0.09170560f, 0.05646828f, -0.06653763f, 0.02503908f, 0.07251702f, -0.01622366f, -0.01319709f, 
    -0.52068347f, 0.19470890f, -0.19409157f, -0.02046405f, 0.04994843f, -0.04584663f, 0.02895467f, 0.06384771f, 
    0.13430400f, -0.06919292f, -0.01231346f, 0.08824503f, -0.46263862f, 0.03754007f, -0.29830426f, -0.19900329f, 
    -0.09342194f, 0.00291776f, 0.03295358f, -0.03021180f, -0.09079195f, 0.16585414f, -0.02718643f, -0.11647000f, 
    0.13830534f, -0.09544765f, -0.10883612f, -0.50006223f, 0.06798141f, -0.00272647f, 0.09776892f, 0.05001921f, 
    0.13397528f, -0.04724903f, 0.03777999f, 0.02746836f, -0.37701327f, -0.07916307f, -0.18037471f, -0.33386350f, 
    0.06618875f, 0.06640823f, 0.02262229f, 0.13569105f, 0.00057679f, 0.07170033f, -0.01888819f, -0.11844423f, 
    -0.01151564f, 0.02111032f, 0.13104005f, 0.13492939f, 0.09569549f, 0.00646186f, -0.09303960f, -0.03934450f, 
    -0.02818996f, 0.05927828f, 0.05353246f, 0.05760926f, 0.30656403f, 0.03683208f, 0.25122911f, 0.28178301f, 
    0.01568693f, -0.05898194f, -0.05739105f, 0.14763197f, 0.04229804f, -0.00249599f, -0.05917402f, 0.00366133f, 
    0.53333169f, 0.12859848f, 0.17722279f, 0.03809612f, 0.15698864f, 0.08302583f, -0.07131255f, 0.00560208f, 
    0.11587897f, 0.06894013f, -0.00722999f, 0.02340804f, 0.14645667f, 0.04941904f, -0.01493742f, 0.11547258f, 
    0.07870526f, 0.04675748f, -0.10066964f, -0.00515041f, 0.05484162f, -0.00365856f, 0.07003631f, 0.03445674f, 
    0.27433458f, 0.06993360f, -0.10904452f, 0.09251560f, 0.02531678f, -0.01536153f, -0.14422230f, 0.06784567f, 
    -0.09250862f, -0.11197919f, -0.05339792f, -0.05018250f, -0.04913665f, -0.13312253f, -0.17642480f, -0.16200854f, 
    0.01632218f, 0.10504404f, -0.07042136f, -0.06900071f, -0.00744650f, 0.05798656f, 0.03060152f, -0.09180994f, 
    0.70369685f, -0.04803583f, 0.09928875f, 0.03580686f, -0.12499099f, 0.11615579f, -0.02637408f, 0.03391765f, 
    -0.05171752f, 0.08486082f, 0.09400007f, -0.02451508f, -0.15744126f, -0.13652533f, 0.13160853f, -0.16457377f, 
    0.03810982f, 0.22914788f, -0.01305256f, -0.12943585f, 0.00078656f, 0.03772527f, 0.06010737f, 0.07111425f, 
    -0.21421042f, -0.07929200f, -0.30032638f, -0.36126164f, 0.07856827f, 0.02017708f, -0.00440201f, -0.04597117f, 
    0.15186308f, -0.03964627f, 0.02593236f, -0.03935092f, 0.46235600f, 0.09491369f, 0.01191216f, 0.21585678f, 
    0.03302919f, -0.01097564f, -0.09495153f, 0.05365420f, 0.11305095f, 0.12819067f, -0.00834964f, -0.01662765f, 
    0.08908731f, 0.14132108f, 0.06021916f, 0.06976476f, -0.02341092f, 0.01312101f, 0.02742017f, 0.01952006f, 
    -0.04633294f, 0.05994034f, -0.00696901f, 0.13895683f, -0.15786766f, -0.26778653f, -0.18588354f, -0.06686434f, 
    0.04977013f, 0.15495078f, 0.01918978f, -0.00168401f, -0.12800936f, -0.00749954f, -0.20415616f, -0.00692665f, 
    0.23426799f, -0.00615655f, 0.05151484f, 0.22627126f, -0.05653679f, 0.09107769f, -0.02605281f, 0.06874809f, 
    0.02165266f, -0.09739809f, -0.02683898f, 0.04672084f, -0.13246313f, 0.31953630f, 0.08218759f, 0.09174757f, 
    -0.02199792f, -0.05864196f, 0.17668855f, 0.28769004f, 0.16547561f, -0.04107714f, 0.09638250f, -0.08769901f, 
    -0.32111228f, 0.17045593f, 0.00248935f, -0.14860867f, 0.03719673f, -0.00749970f, -0.04133061f, -0.04313975f, 
    -0.01229525f, 0.04801916f, -0.00153359f, -0.03774556f, 0.17754968f, -0.04389476f, 0.09919488f, 0.20041950f, 
    0.08427320f, -0.10878407f, 0.08291709f, 0.01277995f, 0.03917537f, -0.01748796f, 0.05771270f, 0.04061753f, 
    0.08137032f, 0.04820434f, 0.12071892f, -0.03639029f, -0.05917167f, -0.15432975f, 0.02904636f, 0.11418057f, 
    0.07696829f, -0.00067625f, 0.15905158f, -0.01428366f, -0.10767019f, 0.06473256f, 0.01856522f, 0.02989055f, 
    0.15146579f, 0.04199025f, -0.14517760f, -0.04433342f, 0.09049465f, 0.09027150f, 0.00480485f, -0.13964693f, 
    -0.32750043f, 0.22540066f, 0.07603034f, -0.10909556f, -0.04201671f, -0.09189244f, 0.00197116f, -0.15754373f, 
    0.15794417f, 0.14358309f, 0.14406711f, -0.08024532f, 0.03529691f, 0.01904872f, -0.04687239f, 0.23673356f, 
    0.06214386f, 0.01396841f, -0.08608419f, -0.08638806f, -0.03579813f, 0.03325047f, -0.09931381f, -0.06399955f, 
    -0.08962753f, 0.07517552f, -0.15271579f, 0.00743646f, 0.01511292f, -0.05035220f, -0.01280273f, 0.09449882f, 
    -0.03104405f, 0.14559850f, -0.10197493f, -0.01208080f, -0.02178757f, -0.03897355f, 0.01584999f, 0.01404594f, 
    -0.09329756f, -0.06484231f, 0.10630219f, 0.11220480f, -0.00385397f, 0.00978682f, 0.01730818f, 0.04564076f, 
    -0.02897056f, -0.01298724f, -0.04422672f, -0.04071423f, -0.02132146f, -0.00570325f, -0.01975559f, -0.04074894f, 
    0.04750340f, -0.00046371f, -0.01580530f, -0.00484338f, -0.02202851f, 0.02508083f, -0.04736522f, -0.04458432f, 
    -0.01292565f, -0.04628618f, -0.00580860f, -0.02379149f, 0.01528420f, -0.01645979f, -0.02380264f, -0.04283746f, 
    -0.02552763f, 0.01854149f, -0.02312188f, -0.05055076f, -0.02617525f, 0.03341230f, 0.03404399f, -0.04019117f, 
    -0.03188608f, -0.04703879f, -0.04806997f, -0.05063104f, -0.03428853f, -0.04253980f, 0.02705872f, 0.04053178f, 
    0.02084212f, -0.01392790f, 0.03084658f, -0.04328760f, 0.04459774f, -0.02488210f, 0.00449950f, -0.01482273f, 
    0.01077286f, 0.02632982f, -0.04324160f, -0.02659938f, -0.01277588f, -0.01378184f, 0.00302074f, -0.01748141f, 
    0.01578350f, 0.00936101f, -0.04957159f, -0.00840843f, 0.03399929f, 0.03359212f, 0.00181243f, -0.02939147f, 
    0.02917315f, -0.00339557f, -0.03400133f, -0.02548223f, -0.00706187f, -0.00260437f, -0.02681991f, -0.03331203f, 
    0.02242806f, 0.03316047f, -0.03328389f, -0.03335354f, -0.04846694f, -0.01675754f, 0.01402521f, 0.03132976f, 
    0.02271853f, -0.00120132f, -0.02645921f, 0.00001970f, 0.01159223f, -0.00200403f, -0.04634812f, 0.01692650f, 
    0.04230149f, 0.01355506f, -0.03030321f, -0.04121825f, 0.00709294f, -0.03741831f, 0.01385264f, 0.04825588f, 
    0.01943572f, 0.00989971f, -0.03776085f, 0.03254578f, -0.03144575f, -0.04107140f, -0.05205248f, -0.00569665f, 
    -0.05569958f, -0.04531280f, -0.04024738f, -0.05031029f, -0.03777834f, -0.01485519f, 0.00049125f, 0.03692060f, 
    0.00069792f, 0.04611369f, 0.01794019f, -0.00896787f, 0.01061998f, 0.02559065f, 0.01311226f, -0.05285591f, 
    0.03056858f, 0.00034502f, 0.03769164f, -0.00307387f, -0.02363382f, 0.00201637f, -0.00195648f, 0.01743032f, 
    -0.05594835f, -0.02018501f, -0.00383033f, 0.00186112f, -0.03494203f, -0.04977226f, -0.02107853f, -0.00784593f, 
    -0.03168114f, 0.03192481f, -0.03932909f, 0.00931572f, -0.02773564f, -0.02647174f, 0.03400226f, 0.00051039f, 
    0.02642229f, 0.03139418f, -0.04997994f, -0.02315184f, -0.01065304f, -0.03816469f, -0.04914580f, 0.04239793f, 
    0.00904839f, -0.04834123f, -0.03994808f, 0.01463023f, -0.05625191f, 0.01213729f, 0.04474220f, -0.02353575f, 
    -0.00156758f, 0.02559910f, -0.00655432f, 0.00077407f, -0.00784950f, -0.02893494f, -0.02198595f, 0.01543628f, 
    0.01729046f, -0.00234780f, -0.01652763f, 0.02595489f, 0.02324028f, -0.01934233f, -0.04195572f, 0.00594630f, 
    0.03053344f, 0.00479248f, -0.01164284f, -0.03671461f, -0.02220808f, 0.00298068f, 0.00864752f, 0.04125144f, 
    -0.00941902f, -0.04037614f, -0.02832009f, -0.00698915f, -0.01786791f, 0.01850099f, -0.01658930f, 0.00760650f, 
    -0.02185374f, -0.04376765f, -0.00090539f, -0.00604963f, -0.03499768f, 0.03216609f, 0.01139865f, 0.01917126f, 
    0.01565827f, 0.00063072f, 0.01170585f, -0.01141608f, -0.04336369f, 0.04194592f, -0.04611753f, 0.01768136f, 
    -0.02217481f, 0.01995806f, 0.00787876f, -0.02840652f, -0.03140747f, 0.02274041f, 0.01950591f, -0.04582928f, 
    -0.00434431f, 0.02710817f, 0.02103857f, -0.05535249f, -0.00852099f, 0.01010725f, -0.02437697f, 0.01506502f, 
    -0.03583483f, -0.03089071f, -0.03090997f, -0.01408679f, 0.01094253f, 0.00224391f, 0.01534577f, -0.05298074f, 
    -0.01317725f, 0.03702804f, 0.03826299f, -0.05314066f, -0.02808392f, -0.05395264f, -0.05422930f, 0.02662879f, 
    -0.01596797f, -0.02863502f, 0.02490122f, 0.00197620f, 0.01503512f, -0.05236807f, -0.00980311f, 0.01133918f, 
    0.03767300f, 0.02026704f, 0.00673153f, 0.03617925f, -0.01139608f, -0.03163175f, -0.02726411f, 0.00153422f, 
    -0.01033505f, 0.01744411f, -0.03468198f, -0.04742345f, 0.02847765f, -0.01479953f, -0.04548117f, 0.02113150f, 
    0.02854256f, 0.03556767f, 0.03848752f, -0.02594602f, -0.05369369f, -0.01185068f, 0.03579983f, 0.02635121f, 
    0.01470462f, -0.04338922f, 0.04411133f, 0.00406119f, 0.03577608f, -0.05436352f, 0.03181053f, 0.02163498f, 
    0.01704983f, 0.01733165f, -0.02512559f, 0.00074415f, 0.01967085f, -0.01037044f, 0.01720774f, 0.03694307f, 
    -0.03351371f, 0.02884925f, 0.00121405f, 0.02268258f, 0.03439743f, -0.02680049f, 0.04030037f, 0.01348442f, 
    0.04165057f, 0.02253059f, -0.05178630f, -0.03642469f, -0.05094676f, -0.02767018f, -0.05154366f, -0.04256671f, 
    0.00747560f, -0.02729667f, 0.03359668f, -0.00697141f, 0.03315334f, -0.01858816f, -0.01920996f, -0.02596362f, 
    0.00907479f, -0.04018131f, -0.01673168f, -0.02143994f, -0.04572546f, -0.02939421f, 0.00700864f, -0.01351541f, 
    -0.02885454f, -0.00002583f, 0.03386783f, -0.04742209f, 0.03601732f, -0.00280307f, -0.00444893f, 0.02335650f, 
    0.01069152f, -0.03047152f, -0.05440590f, -0.04905209f, -0.02269846f, -0.02716739f, -0.01172524f, -0.02263423f, 
    -0.00571398f, 0.02265508f, -0.01719886f, -0.04185444f, -0.03551080f, -0.02739332f, 0.03680712f, -0.03047672f, 
    0.02645457f, -0.02305940f, -0.02897266f, 0.03930038f, -0.00003943f, -0.02610687f, 0.01064575f, 0.03539794f, 
    0.03866102f, -0.04045853f, -0.01529592f, -0.01452038f, -0.02710659f, 0.00178214f, 0.01322220f, -0.03501222f, 
    0.00586412f, 0.03952779f, -0.04884525f, 0.04452533f, -0.02135950f, 0.00002366f, -0.02189045f, 0.00316731f, 
    -0.01745827f, 0.03285572f, -0.04746251f, -0.00694786f, -0.01532172f, 0.04299200f, -0.02807461f, -0.03831625f, 
    -0.05369514f, 0.03125350f, -0.05088280f, -0.01498698f, -0.01432171f, 0.00133589f, -0.04844453f, 0.00347319f, 
    -0.03270914f, -0.14498389f, -0.16670834f, 0.00668141f, 0.00282767f, -0.09183560f, 0.02268132f, 0.05548797f, 
    0.02588932f, 0.01025082f, -0.10074127f, -0.03134457f, 0.27427083f, 0.06091086f, 0.03902766f, -0.05351289f, 
    -0.12436193f, -0.05850165f, -0.02942656f, 0.01646190f, -0.08484698f, -0.07979965f, -0.03307213f, -0.12884498f, 
    -0.10005540f, 0.17695735f, 0.11545351f, -0.05226008f, -0.11124304f, 0.11808895f, -0.06558114f, -0.06029729f, 
    -0.04662665f, 0.05329426f, 0.12631115f, -0.10467143f, 0.32736948f, -0.12513648f, -0.11617193f, 0.16309874f, 
    -0.01556435f, -0.00304728f, -0.02290135f, 0.01252737f, 0.04408170f, 0.03650010f, 0.06973922f, -0.04771972f, 
    0.09933532f, 0.06593620f, -0.06176036f, -0.28441098f, -0.04201229f, -0.05518342f, 0.12841518f, -0.07913854f, 
    -0.14516428f, 0.03716088f, -0.09115534f, -0.02480827f, -0.29036704f, 0.15501975f, -0.25320280f, -0.21779817f, 
    -0.09937546f, 0.12545589f, -0.02891677f, -0.00458603f, -0.03282228f, -0.05265453f, -0.04668174f, 0.01086071f, 
    0.02063157f, 0.03601926f, -0.11252978f, -0.14804967f, 0.01253387f, 0.00365320f, 0.03441278f, 0.00697906f, 
    -0.02396424f, -0.03180125f, 0.01672278f, -0.00296084f, -0.27339178f, -0.04166493f, 0.02832346f, -0.10493509f, 
    -0.04940045f, 0.06542480f, 0.00475401f, 0.06030120f, 0.01866791f, 0.07061826f, -0.10498910f, -0.03842259f, 
    0.03534955f, -0.00729083f, -0.04346739f, -0.09401140f, -0.00011244f, 0.06744736f, 0.14178200f, 0.18008594f, 
    0.16647772f, -0.01280783f, -0.07288231f, 0.02751465f, -0.05431758f, 0.04840254f, -0.18426861f, -0.21527560f, 
    -0.00093857f, 0.00320916f, 0.07799826f, 0.11920071f, 0.00812908f, 0.05637746f, 0.08289972f, -0.02309127f, 
    0.30753264f, -0.18116187f, -0.01096305f, 0.24726002f, -0.00479127f, -0.05137891f, -0.13992818f, 0.04111417f, 
    -0.07223817f, 0.01966625f, 0.04831826f, 0.02118333f, 0.28436095f, 0.07817998f, 0.03508789f, 0.16028740f, 
    0.07524990f, -0.09734453f, 0.14125897f, 0.17117482f, -0.07472502f, 0.04946520f, -0.06136928f, 0.12018899f, 
    0.15472610f, 0.02893749f, -0.01785952f, 0.06237603f, -0.06451219f, 0.04167756f, -0.12652652f, 0.02425207f, 
    -0.02272829f, 0.02953368f, 0.06140560f, -0.05097403f, 0.09944658f, -0.15005341f, -0.03998636f, 0.14779209f, 
    -0.05621165f, 0.06533966f, -0.04011649f, 0.08183236f, -0.09685134f, -0.10036599f, 0.10588703f, 0.00281927f, 
    -0.18584129f, 0.09393084f, -0.06996400f, 0.07557710f, -0.05308570f, 0.05343911f, -0.08675957f, 0.00856435f, 
    -0.24331532f, -0.05363911f, -0.06457546f, -0.03594800f, -0.15907446f, -0.10888132f, -0.12112670f, -0.06769506f, 
    0.02815485f, 0.04940020f, -0.01531921f, 0.06814433f, -0.04025299f, -0.07138097f, 0.07101153f, -0.01893043f, 
    0.39470392f, 0.27396864f, -0.05269259f, 0.16869408f, 0.04616600f, -0.00748274f, 0.03313981f, -0.05391755f, 
    -0.03706422f, -0.06165022f, -0.02299821f, 0.11372671f, 0.39176688f, -0.01855389f, 0.03480477f, -0.10433913f, 
    -0.13636959f, 0.00215430f, -0.07620697f, -0.03301171f, 0.14114965f, 0.12638949f, 0.10551876f, 0.04363908f, 
    -0.07382975f, -0.11617260f, -0.20405088f, -0.05419745f, -0.00757833f, -0.05678476f, -0.00208463f, -0.03081875f, 
    0.06151595f, -0.10246450f, 0.00176498f, -0.01056104f, 0.02085535f, 0.14537865f, -0.11181348f, 0.16717374f, 
    0.06108462f, 0.03948507f, -0.00096867f, -0.02055959f, 0.08392359f, 0.10524435f, -0.09432950f, 0.03855955f, 
    0.30225232f, -0.11643094f, 0.00308254f, 0.12979773f, 0.08783828f, 0.06269757f, -0.01244542f, -0.01226409f, 
    -0.09854332f, -0.03410791f, -0.01970127f, 0.09980971f, -0.06257997f, 0.08301333f, -0.06294185f, -0.00338689f, 
    0.13187493f, 0.07910800f, -0.05204178f, 0.05945145f, -0.09387910f, -0.11175422f, -0.07636795f, -0.00998073f, 
    0.02282417f, 0.28438157f, 0.15499055f, -0.00830417f, -0.04520579f, 0.04313579f, -0.07399578f, -0.04876221f, 
    -0.06491984f, -0.00512295f, 0.03104147f, -0.06177676f, -0.11256563f, 0.12014599f, -0.04548198f, -0.10816144f, 
    0.10459244f, 0.03571279f, 0.06765755f, -0.05146923f, 0.08659046f, 0.02895234f, 0.01720416f, -0.02902555f, 
    -0.05320681f, -0.12585312f, -0.02174244f, 0.25602201f, 0.03077899f, -0.15316723f, 0.13153571f, -0.17150855f, 
    -0.01394210f, -0.00974928f, -0.01666753f, -0.01766036f, -0.05094045f, -0.06436311f, 0.01664536f, -0.00118663f, 
    -0.09288383f, 0.07352969f, -0.05742333f, 0.02485863f, 0.09160112f, -0.07836030f, 0.04688825f, 0.00171646f, 
    0.22850175f, 0.20493995f, -0.04619168f, -0.08363476f, -0.06587601f, 0.10585714f, -0.08352613f, 0.12881504f, 
    0.01271776f, 0.03560524f, 0.09411152f, 0.04696667f, 0.11766145f, 0.03071287f, -0.02781365f, 0.25336456f, 
    0.00047242f, -0.02271262f, 0.04847086f, -0.05549583f, 0.13914385f, 0.00637927f, -0.04344726f, -0.08534275f, 
    -0.09600781f, -0.03634300f, 0.04680770f, 0.01607556f, 0.01128299f, -0.03823049f, -0.01201349f, -0.02648034f, 
    0.29226834f, 0.03328631f, -0.00071590f, 0.15152811f, 0.46434790f, 0.12563007f, -0.32854313f, 0.21874845f, 
    0.11559044f, -0.05620918f, -0.06271169f, 0.01453645f, 0.05376660f, 0.02382462f, -0.03030594f, -0.02166502f, 
    -0.24742699f, 0.04073286f, -0.05218033f, 0.02223210f, 0.13424614f, 0.08391900f, -0.10205299f, -0.00203738f, 
    0.05916717f, -0.07818785f, 0.00930340f, 0.17209058f, 0.11202545f, 0.28455377f, -0.14906730f, -0.04401292f, 
    0.00000342f, -0.02912556f, 0.04249475f, 0.01052370f, 0.10607154f, -0.07749520f, -0.00529532f, 0.10603959f, 
    0.03806926f, -0.00354548f, 0.01305112f, 0.00486498f, -0.05333217f, 0.03117968f, -0.04184719f, -0.01434610f, 
    0.04236700f, -0.03090962f, 0.03905893f, 0.04932962f, -0.00082414f, -0.04162142f, -0.03241572f, -0.05555930f, 
    0.01572450f, -0.04423508f, 0.02052813f, -0.03157422f, -0.01915209f, 0.01274953f, 0.03399835f, 0.00303755f, 
    0.04493594f, -0.01794905f, -0.05311830f, -0.01283249f, 0.00789530f, -0.00222897f, 0.01447663f, 0.01961643f, 
    -0.05783035f, -0.01519703f, -0.04369343f, -0.05942570f, 0.00266443f, -0.01252630f, 0.00059063f, 0.01875727f, 
    0.03191029f, 0.02262238f, 0.02544785f, 0.03320874f, -0.05586186f, -0.01356315f, 0.04091098f, 0.00483152f, 
    -0.07334109f, 0.03619122f, -0.03998956f, 0.02685278f, 0.00013529f, -0.02557524f, 0.03725496f, -0.04092997f, 
    0.00613693f, -0.02989601f, -0.06300759f, 0.04661348f, -0.02292156f, 0.01867899f, -0.02848282f, 0.00834783f, 
    -0.02534256f, -0.00504528f, 0.01604211f, -0.05671230f, -0.05575654f, -0.00508710f, 0.03093812f, 0.03275077f, 
    0.01069716f, -0.01574911f, 0.02367996f, 0.05210050f, -0.05792321f, -0.05380912f, 0.02575893f, -0.03760373f, 
    -0.04697529f, 0.02700805f, -0.00435920f, -0.03529717f, -0.03498857f, 0.02018020f, -0.04207919f, 0.04307504f, 
    0.00264607f, -0.06924135f, 0.02879993f, 0.03534748f, -0.05747006f, 0.04094700f, -0.04946535f, 0.02444036f, 
    -0.03882702f, 0.00147006f, -0.02312962f, -0.00003953f, -0.03195595f, 0.02712910f, 0.01397639f, -0.04598793f, 
    -0.06623387f, -0.05360309f, 0.00689623f, 0.02074413f, -0.03655037f, -0.06956431f, -0.04246819f, -0.04330625f, 
    -0.00605177f, 0.03496649f, 0.01352570f, -0.02682191f, -0.04688998f, -0.01205483f, -0.04246861f, -0.03590037f, 
    0.01160140f, 0.01425981f, 0.05811760f, 0.02879808f, -0.06491022f, 0.04656094f, 0.02993758f, -0.03506920f, 
    0.00077287f, -0.02864080f, 0.02092901f, 0.00636577f, 0.03717324f, -0.01699346f, -0.03701269f, 0.01670332f, 
    -0.05291396f, 0.01438242f, -0.02248190f, -0.02154289f, -0.01708896f, -0.05056066f, 0.03500015f, 0.02493739f, 
    -0.00063381f, 0.01356218f, -0.03301639f, -0.02163740f, -0.01127138f, 0.02032580f, 0.00386213f, -0.01819582f, 
    0.03530543f, -0.00061154f, -0.02192380f, -0.00099269f, 0.05279347f, 0.04070759f, 0.00219067f, -0.01899973f, 
    -0.00937144f, 0.00811103f, -0.02147465f, -0.02550810f, -0.04989009f, 0.05553398f, -0.02336802f, 0.01078488f, 
    -0.01535001f, 0.06792048f, 0.02724782f, 0.03644985f, 0.03708065f, -0.03899759f, 0.00321240f, -0.01587496f, 
    0.04641575f, -0.01157763f, 0.03202879f, -0.00700982f, 0.00553870f, -0.06762214f, -0.04486907f, -0.03077075f, 
    0.00864647f, -0.05300203f, -0.03018965f, 0.04320219f, -0.05651648f, -0.03714679f, 0.01899080f, -0.02184973f, 
    -0.02808477f, 0.00481077f, -0.03631876f, 0.02633498f, -0.00387211f, -0.02834524f, 0.03804585f, 0.02749507f, 
    0.00818981f, -0.02902324f, -0.02643164f, -0.05420965f, 0.02792189f, -0.03121264f, 0.00156507f, -0.05685306f, 
    -0.01208506f, 0.03497576f, 0.00593510f, 0.03418146f, -0.01335293f, 0.01321411f, -0.00039194f, -0.04457195f, 
    0.00447312f, -0.03398022f, -0.04730262f, -0.02963024f, 0.00571234f, -0.00115019f, 0.02185811f, 0.01659707f, 
    -0.01865725f, -0.05489270f, 0.01808848f, -0.00476343f, 0.05712705f, -0.02704902f, -0.02360457f, 0.00395975f, 
    0.00731282f, 0.00951809f, -0.01663852f, 0.02557559f, 0.03324087f, -0.01079020f, 0.03103988f, -0.02266175f, 
    -0.01731845f, -0.02182906f, 0.05251589f, -0.01898563f, -0.03925669f, -0.02168688f, -0.00958362f, 0.00784383f, 
    0.00315110f, 0.03903938f, -0.03560473f, -0.04561269f, -0.01610156f, 0.02758319f, -0.02494504f, -0.02500226f, 
    -0.01939592f, -0.00273667f, 0.00608048f, -0.00830727f, -0.05809065f, -0.04094291f, -0.03831413f, -0.07165343f, 
    0.00676851f, 0.00081179f, -0.04503670f, -0.06915246f, 0.00421612f, -0.00047470f, -0.05199000f, -0.05007105f, 
    0.01104818f, -0.03728011f, -0.03262776f, -0.03884608f, 0.00419671f, -0.06351065f, -0.04786652f, 0.02281109f, 
    -0.01757146f, -0.02451368f, 0.00395077f, 0.01829431f, -0.05790164f, -0.05462400f, -0.02823845f, -0.00077950f, 
    0.04476968f, -0.01651927f, 0.04395678f, -0.01084027f, 0.01110666f, -0.04522449f, -0.06180296f, -0.05215068f, 
    -0.02624484f, 0.00211631f, 0.05047945f, 0.02466331f, -0.02995978f, 0.01368796f, 0.00433595f, -0.06087349f, 
    -0.02635406f, -0.06133380f, -0.03164874f, -0.05873633f, 0.03514347f, 0.00026525f, -0.03408872f, -0.05639844f, 
    -0.01002695f, 0.02459378f, -0.01450031f, 0.02126626f, -0.01055972f, 0.02013746f, 0.01748053f, -0.00034215f, 
    -0.03789239f, -0.05712124f, -0.04673058f, -0.06223051f, -0.03789569f, -0.04124569f, 0.01910460f, 0.01222442f, 
    -0.05305738f, 0.03887103f, 0.02637416f, -0.01762482f, 0.03176420f, -0.03280734f, -0.04088140f, -0.01936357f, 
    -0.06166739f, -0.04713869f, -0.00261462f, -0.03178518f, 0.02167677f, -0.01454670f, 0.03953534f, 0.02558896f, 
    0.01021760f, -0.02310565f, -0.00096189f, 0.00932537f, -0.03267916f, -0.03012093f, 0.03079108f, 0.06388409f, 
    0.02046045f, -0.05643740f, -0.04364686f, 0.02215733f, -0.04147099f, -0.00827217f, 0.02950625f, -0.02557188f, 
    0.00656789f, 0.01608122f, -0.02373389f, 0.02817721f, 0.04461328f, 0.02379520f, -0.06113251f, 0.03378785f, 
    -0.00009613f, -0.00688117f, -0.04143361f, -0.04042779f, -0.00607039f, -0.05205684f, -0.06011347f, 0.00143929f, 
    -0.04326519f, -0.06099670f, -0.00184826f, -0.00131858f, -0.01458229f, 0.03791874f, 0.02990053f, -0.03709168f, 
    0.14132272f, 0.02430157f, -0.04167875f, -0.12854688f, 0.05720747f, 0.14366770f, 0.10974526f, 0.00919396f, 
    0.03261258f, -0.10166721f, -0.08612474f, 0.02211170f, -0.24181598f, -0.07278489f, -0.05919800f, -0.11136137f, 
    -0.09487851f, 0.04532117f, -0.01215750f, -0.06925903f, -0.01382722f, 0.06283566f, -0.03167302f, -0.06816030f, 
    0.09551132f, 0.04676827f, -0.03869630f, -0.14666063f, 0.14019257f, 0.09717416f, -0.08239069f, -0.00741353f, 
    0.12001677f, 0.02624239f, -0.10744826f, -0.14671437f, 0.28591436f, 0.23868302f, -0.00821552f, 0.03083166f, 
    -0.11202708f, 0.10434628f, 0.04614020f, 0.02738726f, -0.06801852f, 0.02859774f, -0.03719806f, -0.02567031f, 
    0.35832259f, 0.12975845f, -0.03840698f, -0.18428552f, 0.08275516f, -0.01285871f, -0.03562012f, 0.13935195f, 
    0.02504249f, -0.02485949f, -0.02140790f, -0.00004364f, -0.41122845f, -0.40815312f, 0.17354599f, 0.35708717f, 
    -0.00402652f, -0.00762772f, -0.03669396f, -0.03292710f, 0.00253710f, 0.17161335f, 0.03148312f, 0.06916188f, 
    -0.03482628f, -0.07866491f, 0.15838778f, 0.03361016f, -0.06394450f, -0.02536527f, -0.04532404f, -0.07883640f, 
    0.10620722f, 0.01935861f, 0.07845066f, 0.02382723f, -0.14671601f, 0.04786125f, 0.07702927f, 0.00511452f, 
    0.01188905f, 0.14374818f, 0.01408866f, 0.04423354f, 0.01438074f, 0.03342659f, -0.05131415f, 0.03826052f, 
    -0.10848001f, 0.00208377f, -0.00004314f, 0.18874395f, -0.03620926f, 0.07547992f, -0.03289585f, -0.08527278f, 
    0.02506592f, -0.00927379f, -0.01498228f, -0.02126923f, -0.08534199f, -0.07123930f, -0.04410787f, -0.11195378f, 
    0.09148912f, -0.05035900f, 0.01670210f, 0.06226275f, -0.14253323f, -0.16243114f, 0.01368062f, -0.00521127f, 
    0.04268073f, 0.16156571f, 0.13350660f, 0.06942674f, -0.19833453f, 0.00696901f, -0.02062587f, 0.02928285f, 
    0.08540048f, 0.06123108f, 0.00588512f, 0.05026700f, 0.17798272f, -0.13596471f, -0.14581552f, -0.24783543f, 
    0.09500277f, 0.17477739f, -0.01065740f, 0.01651701f, 0.08954381f, 0.11234803f, -0.05028927f, 0.05909505f, 
    0.10100096f, -0.04889667f, 0.25095275f, -0.05663015f, -0.01705977f, 0.13050936f, 0.10283405f, -0.15420145f, 
    -0.02853952f, 0.06448243f, 0.12785247f, 0.05567867f, -0.05256379f, 0.16592419f, 0.28257051f, 0.00251597f, 
    0.03779248f, 0.00735016f, 0.06566345f, -0.11833322f, -0.00339109f, 0.03121155f, 0.03220345f, -0.07402134f, 
    0.10374743f, -0.04316920f, 0.05330900f, -0.02790336f, 0.06395414f, 0.04703397f, -0.00940091f, -0.04950805f, 
    -0.00579705f, -0.02812367f, 0.02446428f, -0.02708776f, -0.14233589f, -0.20589581f, -0.03633260f, 0.00447706f, 
    -0.07846001f, -0.06837752f, 0.02927702f, -0.01740110f, -0.03350806f, -0.10953995f, 0.07928770f, 0.01757131f, 
    0.14271192f, 0.13089375f, -0.14739832f, 0.05734264f, 0.05849724f, -0.01889774f, 0.11081280f, 0.13569567f, 
    0.04309988f, -0.12011955f, 0.11349258f, -0.02112880f, 0.35521802f, 0.19976068f, -0.04027645f, 0.27875033f, 
    -0.04981464f, -0.15372258f, 0.04528053f, 0.06038067f, -0.06856117f, -0.00327903f, 0.08767573f, -0.13382892f, 
    -0.13636181f, 0.01460079f, 0.00431484f, -0.00041870f, -0.09301126f, 0.06261094f, 0.07789015f, 0.03219996f, 
    -0.03357566f, 0.04759078f, -0.03599420f, -0.01520674f, -0.05001654f, -0.03189279f, 0.12549229f, 0.11939218f, 
    -0.11349353f, -0.05703315f, 0.09779531f, -0.07680403f, 0.03359945f, -0.01290729f, 0.05145203f, -0.03219765f, 
    0.17789473f, -0.08343539f, 0.10974225f, 0.15044759f, 0.05842855f, -0.06958328f, -0.10861953f, 0.00889596f, 
    0.03699257f, 0.00891787f, -0.06186205f, -0.01642832f, 0.07274237f, 0.04219016f, -0.08753610f, 0.20206127f, 
    0.00052470f, 0.12566096f, -0.07337973f, 0.07262607f, 0.08798270f, -0.01977612f, 0.01080684f, -0.00745616f, 
    -0.14249474f, -0.04735503f, -0.02596059f, -0.07775093f, 0.15437792f, 0.03506535f, -0.09099302f, 0.03280104f, 
    -0.00036257f, 0.09301760f, 0.02634401f, -0.04737751f, 0.08528697f, 0.03648138f, -0.01877494f, 0.02939523f, 
    0.17292133f, -0.15929468f, -0.01484992f, -0.06370242f, -0.01025868f, 0.04391037f, 0.07410877f, -0.02212964f, 
    0.00718236f, 0.05597370f, -0.14149843f, 0.05400997f, -0.00892096f, -0.07917385f, 0.10798222f, -0.02570916f, 
    0.02807177f, -0.03409850f, -0.07202961f, -0.07071319f, -0.05773105f, -0.23460039f, -0.13889351f, 0.12343096f, 
    0.04979302f, -0.13386580f, -0.06730588f, -0.06243689f, 0.09467074f, -0.13003299f, -0.04376083f, 0.01651687f, 
    -0.03811190f, -0.09553508f, -0.05688117f, -0.07620189f, 0.05331668f, 0.00936007f, -0.06983337f, 0.04932779f, 
    -0.00473147f, 0.09143495f, -0.01130718f, -0.00193551f, 0.50658768f, 0.28186673f, -0.11421643f, -0.07017548f, 
    -0.03787322f, -0.13930228f, 0.06500495f, 0.07659389f, -0.00207898f, -0.02157380f, 0.08294941f, 0.00820750f, 
    -0.06480954f, -0.07498524f, 0.03199351f, 0.05026764f, -0.06657553f, -0.02693465f, 0.08030692f, 0.00511808f, 
    -0.02637900f, 0.07728985f, -0.04725832f, 0.03422404f, 0.44829491f, 0.27932090f, 0.09240828f, -0.03324626f, 
    0.09581660f, -0.02720328f, -0.00266069f, -0.01910715f, -0.03331825f, -0.17286389f, -0.07849728f, 0.13912633f, 
    0.15697896f, 0.02434071f, -0.20537339f, -0.03823173f, -0.11834639f, 0.18879974f, 0.05063423f, 0.02287439f, 
    0.04222118f, -0.01643286f, -0.09446936f, 0.08956009f, -0.04179168f, 0.16927332f, 0.22123484f, -0.25741723f, 
    0.02092825f, 0.23829383f, 0.05510960f, 0.09833311f, 0.04234263f, -0.05214666f, 0.04720639f, 0.10402751f, 
    -0.16232650f, 0.09501122f, 0.08999030f, 0.11455446f, 0.00998416f, 0.00461048f, -0.01113382f, 0.01375034f, 
    0.08702087f, 0.12156159f, 0.08972702f, 0.12907422f, 0.26708072f, 0.03893306f, -0.09749377f, -0.04940734f, 
    0.08252129f, -0.01301478f, 0.04467317f, -0.02907506f, 0.05547384f, -0.10333094f, 0.02727734f, -0.02922367f, 
    0.01107905f, 0.12234233f, 0.01380002f, 0.10770813f, -0.00721349f, -0.00118285f, 0.14104693f, 0.10751832f, 
    -0.02725169f, 0.04923856f, 0.16401495f, 0.05983360f, -0.14913942f, -0.14787431f, -0.00570329f, -0.06455795f, 
    -0.02505550f, -0.00909122f, -0.06508539f, -0.03346786f, -0.07217593f, -0.02548690f, 0.06490591f, 0.10420404f, 
    -0.08022940f, -0.06165836f, 0.07702265f, 0.19750394f, -0.01069765f, 0.01132034f, 0.07514134f, 0.03048678f, 
    0.01314823f, 0.05292664f, -0.04011707f, 0.05242003f, 0.45992661f, 0.41154772f, 0.22254086f, 0.02145650f, 
    0.10171074f, 0.07698724f, 0.01151879f, 0.04820489f, -0.02969001f, 0.00416765f, 0.11457830f, 0.11305888f, 
    0.30362257f, 0.15383118f, -0.01128044f, 0.03418871f, 0.09495571f, 0.02786111f, 0.05825507f, 0.09771606f, 
    -0.09543513f, 0.06293500f, 0.07761201f, 0.05855687f, 0.32839569f, 0.08702134f, 0.07032524f, 0.19348586f, 
    0.10990898f, -0.02419961f, -0.01382990f, -0.01919471f, 0.03839390f, -0.03613647f, -0.01748596f, 0.09314841f, 
    0.16338000f, 0.02330052f, 0.19836020f, 0.11979703f, 0.09044279f, 0.00346794f, -0.01035570f, 0.01447534f, 
    -0.12399332f, 0.04161045f, -0.08917570f, -0.08148862f, 0.22921212f, 0.10568371f, 0.09468322f, 0.14949608f, 
    -0.00636664f, 0.07433758f, 0.01628798f, -0.01791856f, 0.17201953f, 0.13067243f, -0.03965946f, 0.06860418f, 
    -0.08413438f, -0.06668483f, -0.08311770f, -0.08275292f, 0.00338206f, -0.04741513f, -0.05930364f, 0.08024218f, 
    0.00295763f, -0.09695340f, 0.03506107f, -0.07001986f, -0.08584146f, 0.13963000f, 0.06078023f, 0.03466288f, 
    -0.12024035f, 0.03123876f, 0.10042329f, 0.01880597f, 0.02266139f, 0.07655938f, 0.13905457f, 0.00412159f, 
    -0.17996819f, 0.03527147f, -0.10433104f, 0.07502078f, 0.07238819f, -0.07426673f, -0.01681913f, 0.06774942f, 
    0.11435477f, 0.04003590f, -0.02972823f, 0.12122579f, -0.11115215f, -0.07415238f, -0.10991677f, -0.00285499f, 
    -0.08532208f, -0.04371774f, 0.01758849f, 0.10387921f, 0.02461460f, 0.04660391f, 0.04710975f, 0.03680858f, 
    -0.02403324f, 0.00337185f, 0.08272139f, 0.07964271f, 0.02073439f, -0.05588740f, 0.09263405f, 0.07774305f, 
    0.13625702f, -0.04408231f, 0.00724990f, -0.09538971f, 0.14383572f, 0.12371980f, 0.26398849f, 0.07993287f, 
    0.08642444f, -0.04320440f, -0.02136332f, 0.12676321f, 0.06904612f, 0.04423287f, 0.00649437f, -0.07014585f, 
    -0.20050246f, 0.03347771f, 0.07810310f, -0.03789884f, -0.02672321f, -0.01459037f, 0.01375529f, -0.06420870f, 
    0.04653269f, 0.14583723f, -0.14999536f, 0.06529789f, -0.04513020f, 0.00869579f, -0.00860668f, -0.00849843f, 
    0.01664046f, 0.12046215f, -0.02718362f, 0.03536617f, 0.00973100f, 0.10078885f, -0.06120846f, 0.15087691f, 
    0.10285456f, 0.04145966f, 0.17225206f, 0.17439936f, 0.05399252f, 0.01185556f, 0.04319456f, 0.08965754f, 
    -0.08647335f, 0.05883905f, 0.02728475f, -0.01959859f, -0.11434004f, 0.07836153f, 0.05126606f, -0.19911852f, 
    0.03909560f, -0.04871578f, -0.03015200f, 0.07157375f, -0.06328858f, 0.03358456f, 0.02702473f, 0.05914775f, 
    -0.24367960f, 0.08771496f, -0.06145330f, -0.03277519f, -0.03827778f, 0.04668398f, 0.06633551f, -0.01191679f, 
    0.09513300f, 0.02148981f, 0.01985372f, 0.03181515f, -0.01475681f, 0.11287045f, 0.24081618f, -0.11102859f, 
    -0.02456534f, -0.04549709f, 0.16964550f, 0.10619341f, 0.09187713f, -0.09111422f, 0.05021269f, -0.11756683f, 
    0.10570954f, 0.05348841f, 0.01633255f, 0.03094842f, -0.03453400f, 0.03968979f, 0.04592554f, 0.10016724f, 
    0.00819854f, 0.03275539f, 0.06591605f, -0.01159506f, 0.12191664f, -0.06993717f, 0.01498170f, 0.03747259f, 
    -0.06589203f, 0.18379220f, 0.03082728f, 0.08720813f, -0.01404591f, 0.06845889f, 0.08055186f, 0.03788888f, 
    0.13476487f, -0.02108064f, 0.10290302f, -0.01544087f, 0.07498184f, 0.09183552f, 0.03637687f, 0.09749003f, 
    0.04768407f, -0.05260632f, -0.01399916f, 0.00825753f, 0.15730195f, 0.27703002f, 0.07391494f, -0.10193332f, 
    -0.00473055f, 0.05553627f, 0.02302033f, 0.00573053f, 0.03256771f, 0.08130887f, 0.01137228f, 0.04021955f, 
    0.05377847f, 0.18039121f, 0.03913397f, 0.10762305f, 0.10955593f, 0.09184159f, 0.02614737f, 0.01584361f, 
    -0.00484289f, 0.02223377f, -0.03812266f, 0.01939528f, -0.20356551f, -0.06723572f, 0.00734310f, 0.01636327f, 
    -0.01392446f, 0.02285941f, 0.09903147f, -0.00855014f, -0.00396495f, 0.03984291f, -0.08217651f, -0.03890898f, 
    0.33609518f, 0.07230061f, -0.00806246f, 0.01815125f, 0.03693539f, 0.07228524f, 0.10172912f, 0.09838950f, 
    -0.03807667f, -0.07785949f, -0.10607649f, -0.05733658f, -0.28162596f, -0.14574027f, -0.03895072f, -0.11753436f, 
    -0.10658962f, 0.08503529f, -0.03478080f, 0.01713786f, 0.03466195f, 0.12608571f, -0.08051887f, -0.09953792f, 
    0.13192096f, 0.05849825f, 0.22861698f, 0.14352113f, 0.03225690f, 0.02542140f, 0.10306421f, -0.01951936f, 
    0.08010770f, 0.04256038f, 0.10438501f, 0.11330417f, 0.13580692f, 0.05196445f, -0.09951479f, 0.16605869f, 
    0.05724803f, 0.01342871f, 0.01343012f, -0.13742565f, -0.04676743f, 0.18589799f, 0.00825005f, 0.05014522f, 
    0.26587331f, 0.08238839f, -0.04429939f, -0.11673264f, 0.14793293f, 0.02452579f, -0.04759560f, 0.09275707f, 
    0.04640180f, -0.13619727f, -0.05049316f, -0.12206618f, -0.33339378f, 0.09171131f, 0.10167984f, 0.16425230f, 
    0.02340149f, 0.21273059f, 0.05285238f, 0.04111135f, -0.02318381f, 0.18159226f, 0.04211156f, 0.10958322f, 
    0.01846546f, -0.17632076f, -0.09006181f, -0.08257176f, 0.02676543f, 0.01046610f, 0.08420239f, -0.06997631f, 
    0.05832215f, -0.11693688f, -0.12836239f, 0.09801102f, -0.02282780f, 0.22279789f, 0.26071674f, 0.16472861f, 
    -0.01276046f, 0.00655022f, 0.07267983f, 0.11697431f, 0.17419986f, 0.08770999f, -0.04450027f, 0.05242720f, 
    0.17887071f, -0.07748240f, 0.06591713f, -0.14577831f, 0.07579786f, 0.05920590f, 0.01204470f, 0.08398815f, 
    0.11755678f, -0.02851615f, 0.15731217f, -0.09448612f, -0.23644739f, -0.29172552f, -0.00634277f, 0.10397687f, 
    0.01404771f, -0.01816718f, -0.00033621f, 0.00332067f, 0.12031413f, 0.12763999f, -0.03787000f, -0.04909843f, 
    -0.18404083f, -0.11378506f, 0.08144848f, -0.07298064f, -0.08779738f, -0.03579583f, 0.03340319f, -0.02126531f, 
    0.28263915f, 0.03707185f, 0.01579781f, 0.02462506f, -0.09918533f, -0.10316505f, -0.06878399f, -0.08718874f, 
    0.08079478f, -0.03081734f, 0.09725808f, -0.04727240f, 0.03091454f, 0.12587529f, 0.06242915f, -0.01008831f, 
    -0.19341119f, 0.10613441f, -0.12804809f, 0.03387411f, 0.01350194f, -0.02147654f, -0.03377780f, -0.03540346f, 
    0.15639503f, 0.01608530f, 0.17908727f, 0.01949583f, -0.08499574f, -0.15968400f, 0.06652213f, -0.01479767f, 
    0.14125322f, 0.00160789f, 0.05866606f, 0.02964714f, -0.06170353f, -0.06106953f, 0.07735050f, 0.04813547f, 
    0.07839686f, 0.12166394f, 0.23644356f, 0.08255715f, 0.02041541f, 0.10871340f, 0.06798308f, -0.00381882f, 
    0.10561944f, 0.10992455f, -0.00873239f, 0.14089049f, 0.04405803f, -0.03375367f, -0.05744369f, 0.00264788f, 
    0.05792823f, 0.06176725f, -0.03882181f, -0.00010562f, 0.01711520f, -0.04199571f, -0.11774798f, 0.00910111f, 
    0.09867825f, 0.20719901f, 0.01753245f, 0.00254988f, -0.00333378f, 0.06513794f, -0.05970329f, -0.04683887f, 
    -0.00840720f, 0.12651736f, 0.11175553f, -0.06324915f, 0.21472068f, 0.18002659f, 0.23054285f, 0.06938367f, 
    0.07528237f, 0.04708355f, 0.06562854f, -0.03507790f, 0.11354727f, 0.14867035f, -0.05660712f, 0.09140237f, 
    0.10301805f, 0.03219280f, -0.02089341f, -0.01345520f, 0.06302801f, 0.01765495f, -0.05316174f, 0.00125804f, 
    0.00256403f, 0.19363543f, -0.00415633f, 0.14826941f, -0.05602702f, 0.09879744f, -0.06088931f, 0.09330242f, 
    -0.01861822f, 0.07266510f, 0.07228096f, -0.06137400f, 0.09973473f, 0.10065500f, 0.04980932f, 0.09091329f, 
    -0.03530763f, -0.01730540f, -0.07704126f, 0.00423098f, 0.00139045f, 0.11905466f, 0.05830548f, 0.16996285f, 
    -0.00915779f, -0.10041857f, 0.12651674f, 0.02963362f, -0.05492627f, 0.03058977f, 0.06680479f, 0.13020737f, 
    0.08796980f, -0.03770168f, -0.03292116f, -0.03726844f, 0.00475057f, -0.04120941f, 0.10247644f, -0.10896953f, 
    -0.03338341f, 0.09879837f, -0.02536209f, -0.02300119f, 0.00745760f, 0.05378923f, 0.09890795f, -0.02930575f, 
    0.13063002f, -0.00911205f, 0.04095937f, 0.08524747f, 0.25632647f, 0.01828034f, 0.06057996f, 0.26316002f, 
    0.00778359f, 0.07393757f, 0.03686229f, 0.13054444f, 0.02731950f, -0.03271604f, 0.12385265f, 0.00992822f, 
    0.19728895f, 0.04090011f, 0.10579009f, 0.07480434f, -0.02113073f, -0.04485059f, 0.07292540f, 0.05118594f, 
    0.02227801f, 0.11892275f, 0.06481867f, -0.02909962f, 0.02253462f, -0.05441539f, -0.07478216f, 0.13876419f, 
    0.11001841f, 0.15420584f, -0.17799231f, -0.09115096f, 0.03867019f, 0.15796122f, 0.06045154f, 0.20305350f, 
    -0.04175689f, -0.16590562f, 0.01861337f, -0.01211274f, 0.16581623f, 0.07008025f, 0.03286560f, 0.02749393f, 
    0.02245899f, 0.09350386f, 0.10788798f, 0.04721539f, -0.06367062f, 0.01126606f, 0.00542454f, -0.11470338f, 
    0.11104541f, -0.15202944f, -0.04838152f, -0.19134106f, -0.03655133f, 0.04924062f, -0.01554404f, 0.09605359f, 
    -0.01422179f, -0.00529096f, 0.10891060f, -0.01552637f, 0.01796784f, 0.11147032f, 0.06793170f, -0.05679679f, 
    0.03105979f, 0.07352199f, 0.07177659f, 0.12484015f, 0.00922774f, -0.20341986f, -0.00632138f, 0.10974211f, 
    0.10894167f, 0.02927252f, 0.07148305f, 0.07481381f, 0.00673504f, -0.01521720f, 0.08665075f, -0.01649649f, 
    -0.13974935f, -0.01032295f, -0.20278373f, -0.00716002f, -0.00008888f, -0.00572098f, 0.13621663f, -0.03477990f, 
    0.03766308f, 0.00608087f, 0.08425830f, 0.01785496f, 0.14787990f, 0.09427091f, 0.13486479f, 0.03919402f, 
    0.04000249f, -0.00189351f, -0.04499315f, 0.07330897f, 0.00560781f, 0.02392340f, 0.23376137f, 0.18658772f, 
    -0.11819071f, -0.05102775f, 0.11454179f, 0.05398617f, 0.00243993f, 0.03500013f, -0.07689831f, 0.07783780f, 
    0.02818250f, 0.06028550f, 0.20404395f, 0.06191935f, 0.12468760f, 0.12284162f, 0.33299488f, 0.11007812f, 
    0.04920785f, 0.03269313f, 0.04134632f, 0.01007908f, 0.07928279f, -0.04424322f, 0.18877178f, 0.17691436f, 
    -0.03069333f, -0.07555360f, -0.06676627f, -0.22036345f, -0.00876158f, 0.14717197f, -0.00281260f, 0.06222538f, 
    0.01596766f, -0.08883242f, -0.03866126f, -0.07660156f, -0.10527763f, -0.12237461f, 0.26209274f, -0.14303616f, 
    -0.02975788f, 0.04158313f, 0.08469453f, 0.21650741f, 0.11996246f, -0.06090195f, -0.01590781f, -0.02830612f, 
    -0.07218152f, -0.12267211f, -0.19044386f, -0.02493021f, 0.06066369f, 0.03365082f, -0.04135843f, 0.15390864f, 
    0.00673098f, 0.05174578f, 0.02894234f, 0.05783095f, 0.15225154f, -0.16477184f, -0.02284920f, 0.37905756f, 
    0.05537632f, 0.14207497f, 0.08525816f, 0.07936141f, -0.03221473f, 0.13031526f, -0.18315722f, -0.12627926f, 
    -0.10954011f, 0.17320004f, -0.09966984f, -0.08506974f, 0.07856256f, 0.08390977f, 0.12189378f, 0.10563532f, 
    -0.05354999f, 0.07020819f, 0.11310631f, -0.03421680f, 0.33982128f, -0.00976567f, 0.15152171f, 0.15771770f, 
    -0.02705636f, -0.06934843f, 0.01472533f, 0.06147892f, 0.07890836f, 0.10633290f, 0.02662080f, 0.15793031f, 
    0.16776103f, -0.26100576f, -0.09950449f, 0.00374016f, 0.05350411f, 0.00892296f, 0.15343215f, -0.09077792f, 
    0.00744128f, -0.04574695f, 0.02194083f, -0.06394503f, -0.13013232f, 0.05576859f, -0.00121487f, 0.07354221f, 
    -0.09069140f, 0.04839035f, -0.06797624f, 0.06878214f, 0.11467491f, 0.08991542f, -0.10217167f, 0.08471152f, 
    0.30932203f, -0.21485883f, -0.14715949f, 0.09344845f, 0.03488258f, 0.10472848f, 0.07445953f, 0.01515342f, 
    0.09892863f, 0.06313231f, 0.11568475f, 0.01947564f, -0.23931311f, 0.01315921f, 0.05254498f, -0.05928817f, 
    0.00517500f, 0.02357249f, 0.04380190f, 0.05959758f, 0.12942375f, -0.05751373f, 0.00858018f, 0.14005785f, 
    -0.12261238f, 0.04845201f, -0.07301527f, 0.23886973f, -0.14381087f, -0.01558405f, 0.05713731f, 0.01077024f, 
    0.23300113f, 0.03383370f, -0.00512851f, -0.04844256f, 0.08403651f, 0.04650062f, -0.17574964f, 0.14645420f, 
    0.04391763f, -0.00020097f, 0.07419368f, 0.07378588f, -0.00422511f, 0.01451624f, 0.02138731f, 0.00852769f, 
    0.42058939f, -0.02665963f, 0.21094930f, 0.00467961f, -0.00664479f, 0.03591243f, -0.00973025f, 0.00175748f, 
    -0.07673914f, 0.02061623f, 0.02562354f, 0.16169009f, -0.03079617f, 0.00055105f, -0.03580791f, 0.00703598f, 
    0.12168049f, 0.01003185f, 0.09324419f, 0.10970955f, -0.05276543f, 0.11078887f, 0.01853147f, 0.03064076f, 
    -0.29621175f, 0.13341098f, -0.09255832f, -0.09044246f, 0.02637372f, 0.07287615f, -0.05187931f, 0.09406459f, 
    -0.07084553f, 0.02383927f, -0.02313712f, -0.00219113f, 0.38300657f, 0.10636924f, 0.13337047f, -0.02697566f, 
    0.09595028f, 0.03181837f, 0.03359511f, 0.16237307f, 0.03985503f, 0.10411447f, 0.02651126f, 0.00345671f, 
    -0.15311779f, 0.05361993f, -0.28412986f, 0.03177166f, 0.01517546f, -0.07253580f, -0.07760063f, 0.15671313f, 
    -0.09285492f, 0.11218195f, 0.01441692f, 0.00010403f, -0.19360940f, -0.06324488f, 0.07774998f, 0.24658445f, 
    -0.02564819f, 0.06168997f, 0.04309865f, 0.01614098f, 0.04477487f, -0.02196638f, 0.07831759f, 0.11873701f, 
    -0.19990972f, 0.23808162f, -0.19288844f, 0.08506407f, 0.17023012f, 0.01943212f, 0.13437569f, 0.05817423f, 
    0.01264669f, -0.08734565f, -0.08332551f, -0.00739492f, 0.12809202f, 0.11289608f, 0.18297450f, -0.20611826f, 
    -0.08029204f, -0.04646187f, -0.12004639f, -0.05004891f, 0.12520459f, 0.12879637f, 0.20293072f, -0.02676969f, 
    -0.01018292f, -0.18057720f, 0.04226080f, 0.10396156f, -0.04980369f, -0.00298955f, 0.03676512f, -0.03350221f, 
    0.03579298f, 0.01561562f, -0.11890335f, 0.08895612f, -0.19599228f, 0.03896125f, -0.09106274f, -0.02766453f, 
    0.10682736f, -0.01691260f, 0.00385629f, 0.08185513f, 0.02245269f, 0.04738089f, 0.00755523f, 0.01633963f, 
    0.07420345f, -0.05118963f, 0.20975396f, -0.04188514f, 0.10614420f, -0.01271794f, 0.06357249f, 0.04152597f, 
    0.08667153f, -0.04356300f, 0.00469946f, -0.05529242f, 0.15059994f, 0.14561369f, 0.00088553f, 0.19318400f, 
    0.12492846f, 0.00071960f, -0.00077205f, -0.12894453f, 0.02881055f, -0.01971495f, 0.02615151f, 0.11336309f, 
    0.11229955f, 0.18486965f, -0.01982100f, 0.08377314f, 0.15121025f, 0.15555161f, -0.01810056f, 0.01071433f, 
    -0.05741874f, 0.08537658f, -0.01404160f, 0.04572976f, -0.03481482f, -0.07512376f, -0.04867783f, 0.08028266f, 
    0.11516395f, 0.05778286f, 0.02125009f, -0.17773324f, -0.14230119f, 0.18046542f, -0.06219829f, 0.08721147f, 
    0.03617325f, -0.21358152f, 0.13936904f, 0.37013072f, -0.06105709f, -0.06108160f, -0.01375073f, -0.12047928f, 
    0.06979508f, -0.14019494f, 0.08714940f, 0.15805410f, -0.13103995f, -0.03718100f, -0.18041079f, -0.03147448f, 
    0.07665268f, 0.10788843f, 0.03659629f, 0.00484474f, 0.03860572f, 0.11377290f, -0.05496195f, -0.06968068f, 
    0.06182443f, -0.04294800f, -0.05447442f, 0.10340340f, 0.03865709f, 0.11523873f, 0.08828069f, 0.02611027f, 
    0.00255788f, 0.12203827f, -0.00134274f, 0.01427617f, 0.23348992f, 0.13487723f, 0.13853732f, 0.15023917f, 
    -0.02464213f, -0.00366061f, -0.07410290f, -0.01301903f, 0.04812992f, -0.06455904f, 0.05244600f, 0.13666567f, 
    -0.12812667f, -0.20975532f, -0.13467894f, 0.05071413f, 0.11530609f, 0.00633184f, -0.08545731f, 0.10042053f, 
    0.28195664f, -0.03792151f, -0.14842616f, 0.17888315f, 0.61508435f, 0.32999843f, 0.02508564f, -0.05333058f, 
    0.01078580f, -0.07134546f, 0.08078972f, -0.04230083f, 0.29525051f, 0.03690917f, 0.02204213f, 0.09299174f, 
    -0.00031295f, -0.04932274f, 0.08079164f, 0.02542971f, 0.11110143f, 0.07815530f, -0.08129579f, -0.04607612f, 
    -0.03419925f, -0.06454502f, 0.09142584f, -0.05350989f, 0.22676286f, 0.08274665f, -0.10609196f, 0.01737187f, 
    0.04939897f, -0.02642406f, 0.05556402f, 0.00273262f, 0.15629116f, 0.07402309f, 0.08193493f, 0.04983825f, 
    0.10941874f, 0.00799211f, -0.00444889f, -0.08232544f, 0.12897454f, 0.04471764f, -0.06805810f, 0.17382933f, 
    0.00541376f, 0.02216797f, -0.11622874f, -0.02172097f, -0.19428471f, 0.17909521f, 0.11474100f, -0.15823057f, 
    -0.20115077f, 0.13915500f, -0.01548973f, 0.00799569f, -0.15660961f, 0.02761673f, -0.01309801f, 0.00435304f, 
    0.05315804f, -0.12277585f, -0.02932187f, -0.04122885f, -0.09910180f, -0.10741672f, -0.04338646f, -0.09441325f, 
    -0.05404335f, -0.17539795f, -0.14744012f, 0.06530567f, 0.07478461f, 0.03375765f, 0.14040416f, 0.30568171f, 
    -0.08752489f, 0.02953246f, 0.00988747f, 0.04296450f, 0.11813442f, 0.01518115f, -0.00532173f, -0.11417402f, 
    0.26374814f, -0.00092726f, -0.03615776f, -0.14259110f, 0.09065069f, -0.00201146f, 0.02801599f, 0.02552103f, 
    0.06909873f, -0.01081465f, 0.09309971f, 0.00932495f, 0.07848792f, 0.03125743f, 0.01923323f, -0.11333096f, 
    -0.05677459f, -0.05832240f, -0.07849610f, 0.08912321f, 0.18139149f, 0.15803932f, 0.03137611f, 0.05082707f, 
    -0.12852766f, -0.02173415f, 0.18312709f, -0.18203624f, -0.20737466f, -0.04217553f, 0.06054989f, -0.07450088f, 
    0.14521062f, 0.01170199f, -0.04340607f, -0.04389899f, -0.04416271f, -0.10231049f, 0.07409463f, -0.13886407f, 
    0.13225369f, -0.03284984f, 0.08773132f, 0.05813538f, 0.04064277f, 0.05424450f, 0.04575067f, -0.05382999f, 
    -0.01756015f, -0.06939390f, -0.11404267f, -0.02320460f, -0.01165806f, -0.04827974f, 0.11058095f, 0.02861187f, 
    0.09307398f, 0.06808589f, 0.09109501f, 0.00144246f, 0.05672929f, -0.14858229f, -0.06003041f, -0.15120354f, 
    0.14386466f, -0.03289820f, 0.12790361f, 0.08686028f, 0.00758575f, -0.00054522f, -0.07982261f, 0.08317307f, 
    0.02199689f, 0.04658681f, 0.10428514f, 0.16941327f, -0.02912285f, 0.02343270f, -0.00915724f, -0.01213695f, 
    0.12032321f, 0.05050334f, 0.04264465f, 0.02367253f, 0.10213722f, -0.20631155f, -0.03723406f, 0.09008934f, 
    -0.05815192f, -0.07576992f, -0.06898749f, -0.00043624f, -0.00047292f, 0.01509642f, 0.01287469f, 0.07346509f, 
    -0.03713505f, 0.11891675f, -0.19089594f, 0.21302433f, -0.07120302f, 0.05912616f, -0.03462024f, 0.04420436f, 
    -0.06954619f, 0.06671001f, 0.11849844f, 0.10891033f, -0.06207032f, 0.10866240f, 0.04482957f, 0.09859035f, 
    -0.03290757f, -0.01335971f, 0.00065228f, 0.04873071f, -0.00335624f, 0.09854703f, 0.06080187f, 0.04119683f, 
    -0.04497696f, 0.02979505f, 0.26091766f, -0.00721146f, 0.01821813f, 0.00238928f, 0.01192665f, -0.05445338f, 
    -0.00553325f, 0.04271120f, -0.18988122f, 0.04574906f, 0.07117443f, 0.36398968f, -0.06018252f, -0.00747155f, 
    0.09391108f, 0.08227763f, -0.00112183f, 0.02472574f, 0.05239568f, -0.00086808f, 0.01592935f, 0.08443805f, 
    0.05825603f, 0.04050517f, -0.06718910f, -0.01489176f, 0.01089280f, -0.04270000f, 0.06502625f, 0.17679259f, 
    -0.02772663f, 0.00146762f, 0.11661332f, 0.01487415f, 0.00724648f, 0.10791698f, -0.08841618f, 0.26693207f, 
    0.03265999f, 0.00056674f, 0.00753450f, 0.06364116f, 0.09715581f, -0.03101416f, 0.09071097f, -0.05898200f, 
    0.16810735f, 0.21181904f, -0.19280314f, -0.07909597f, 0.10454313f, 0.06296695f, 0.09302534f, -0.05665174f, 
    -0.02745481f, -0.09416107f, -0.02320211f, -0.01964433f, 0.09572449f, -0.12035768f, 0.06711327f, 0.26061121f, 
    0.08169506f, 0.04907267f, 0.14239180f, -0.00032564f, 0.06547254f, 0.00711130f, 0.02288362f, 0.04002583f, 
    0.35820404f, -0.16075088f, -0.03245732f, 0.17367446f, 0.18586652f, 0.03089625f, -0.09243955f, 0.02290390f, 
    -0.01486388f, 0.04983620f, 0.02108453f, -0.02689489f, 0.05134853f, 0.06741118f, -0.26745629f, 0.08060855f, 
    0.15949143f, 0.08767564f, -0.12728751f, -0.02132494f, 0.03558917f, -0.14959472f, 0.05715986f, 0.08996547f, 
    -0.21767524f, 0.04461196f, 0.12975207f, -0.11334904f, -0.00556524f, -0.01683839f, 0.01290134f, 0.02179805f, 
    0.00768927f, 0.02242747f, 0.14409445f, -0.00175330f, -0.21327356f, -0.07302382f, -0.00390871f, -0.14091583f, 
    0.14207585f, 0.02970720f, 0.00232143f, -0.20398490f, 0.07829337f, 0.05194849f, -0.04193806f, 0.29931977f, 
    0.10808866f, -0.11956818f, 0.03041398f, 0.06410517f, 0.12644704f, 0.07636175f, 0.17766279f, 0.00147855f, 
    -0.03770287f, -0.03429404f, -0.03943168f, -0.03365556f, 0.02440179f, -0.22064446f, 0.15033364f, -0.03174633f, 
    -0.08897682f, -0.08584778f, -0.04485206f, 0.09189672f, -0.05327734f, -0.07735810f, 0.09665228f, 0.14137065f, 
    -0.17128383f, 0.12906584f, -0.16721193f, 0.00598359f, -0.15404636f, 0.14283942f, -0.10488585f, 0.04436705f, 
    -0.04924319f, -0.08365227f, -0.01824506f, 0.13602585f, 0.12843432f, -0.08776423f, 0.07788299f, 0.09904587f, 
    0.05670831f, -0.04850530f, -0.02389397f, 0.07756229f, 0.21588597f, -0.08124959f, -0.00727934f, 0.11193426f, 
    0.03093787f, -0.13335334f, 0.18543805f, 0.02960599f, 0.05317662f, 0.00079423f, -0.06837797f, 0.17989509f, 
    0.03597829f, -0.00314043f, 0.07215721f, 0.11061952f, 0.04766962f, 0.13659452f, 0.06776787f, 0.20895225f, 
    0.09912854f, 0.02395429f, 0.00808029f, -0.03564288f, 0.01460401f, 0.04886512f, 0.19206885f, 0.12329770f, 
    -0.20766735f, -0.17458023f, 0.02327338f, -0.29608628f, 0.10892276f, 0.04778361f, 0.05096031f, 0.11957573f, 
    0.00357135f, -0.06592867f, 0.02188262f, 0.14254399f, -0.23160405f, 0.04195406f, 0.17354873f, -0.15127443f, 
    -0.03903789f, 0.10184601f, -0.08695737f, 0.17808853f, 0.08481757f, -0.16632390f, 0.03524270f, -0.05199927f, 
    -0.04680400f, 0.03482559f, 0.01123918f, -0.00331181f, -0.01158037f, -0.01347813f, -0.01207439f, 0.02541897f, 
    -0.00284417f, 0.04474698f, -0.00594425f, -0.05524806f, 0.00825297f, -0.01606359f, -0.04079396f, 0.02100592f, 
    0.01907868f, 0.00263273f, -0.00581402f, -0.01995945f, -0.05306172f, 0.02031978f, -0.01652075f, -0.03254687f, 
    0.02785147f, 0.00820680f, -0.06357154f, 0.00768713f, 0.00011253f, 0.00235151f, 0.00299834f, 0.04021686f, 
    0.01419696f, -0.01132711f, 0.02916586f, -0.02635123f, 0.02754350f, -0.04209563f, 0.01183213f, 0.02840872f, 
    0.00825244f, 0.00596387f, 0.01759070f, 0.04451155f, -0.01933588f, -0.01737568f, 0.00433864f, 0.00752144f, 
    -0.00702878f, -0.01515309f, -0.03387265f, 0.04125100f, -0.02006377f, -0.02073830f, -0.01313388f, 0.00842146f, 
    0.03994391f, -0.02581309f, -0.06089887f, 0.02421777f, -0.05337289f, -0.00427551f, 0.01257693f, 0.01015786f, 
    -0.03752711f, 0.01537912f, 0.02199759f, 0.01253765f, 0.03025480f, -0.04574896f, -0.00852236f, 0.00933035f, 
    -0.00490568f, -0.02476402f, -0.04176744f, -0.02988952f, 0.01221610f, 0.00499925f, -0.05198763f, 0.01320194f, 
    -0.04550746f, 0.04717986f, 0.00833285f, -0.00228010f, 0.00077325f, -0.04795552f, 0.03190732f, 0.03975084f, 
    0.01057454f, 0.03598004f, 0.02641608f, -0.02641932f, -0.02713533f, 0.03150109f, 0.03101509f, 0.02354675f, 
    0.01977877f, -0.01839026f, 0.05305480f, 0.02294240f, -0.00648748f, -0.02151970f, 0.03333114f, 0.04111726f, 
    -0.03644376f, -0.00766984f, 0.04277571f, 0.03788468f, -0.00450709f, -0.01315607f, 0.00428197f, 0.03028947f, 
    -0.03510609f, 0.02318000f, -0.01054691f, 0.01051934f, 0.04307627f, -0.01155760f, -0.04977503f, -0.03751436f, 
    -0.03699200f, -0.02316578f, 0.01302340f, 0.01397163f, 0.04218414f, 0.01518958f, 0.01045768f, -0.01363632f, 
    -0.00883021f, 0.02024179f, -0.05028984f, -0.04449957f, 0.02320884f, 0.00005381f, -0.00987205f, -0.01721537f, 
    0.01769289f, -0.02793573f, -0.02714977f, 0.03624417f, 0.00976050f, -0.03774113f, 0.01638767f, -0.02156078f, 
    -0.00449115f, 0.03017717f, 0.03659879f, -0.00741166f, -0.04198438f, 0.02754365f, -0.02665091f, 0.01115085f, 
    -0.04110213f, 0.00761118f, 0.01223917f, -0.03032549f, 0.01116046f, 0.00510747f, -0.01627045f, 0.00799387f, 
    0.02766147f, 0.01930960f, 0.02407482f, 0.00140471f, 0.00315818f, -0.02437250f, 0.00693930f, -0.04933406f, 
    0.02156631f, -0.03823875f, -0.00642178f, -0.03027328f, -0.03986989f, -0.03489723f, 0.04311982f, -0.02549057f, 
    -0.03360864f, -0.02256738f, 0.03151584f, -0.03007572f, -0.02755105f, 0.02635089f, 0.00734445f, 0.00825214f, 
    -0.03536635f, -0.05450502f, 0.03917645f, -0.01924235f, 0.04594129f, -0.03096977f, 0.00314104f, 0.02590540f, 
    -0.03024913f, 0.01685294f, -0.00190712f, 0.03710244f, -0.03470966f, -0.04811772f, 0.02797387f, 0.03551791f, 
    -0.03511362f, -0.03517033f, 0.00230516f, -0.03261058f, 0.02925141f, -0.02619813f, 0.03950090f, -0.04370067f, 
    -0.00390311f, 0.04138569f, 0.01192800f, -0.03619527f, 0.03380330f, -0.04201185f, -0.02905599f, -0.00851417f, 
    -0.01185627f, -0.04431738f, -0.05114304f, -0.06018396f, 0.03353332f, 0.02679646f, 0.03053818f, 0.01305242f, 
    -0.04178375f, -0.01618277f, -0.01184648f, 0.00260535f, -0.00826644f, -0.00754900f, 0.03786169f, -0.00752626f, 
    0.01661598f, -0.05545980f, 0.01191743f, 0.02968074f, 0.03681078f, -0.04067030f, -0.02183849f, -0.01961441f, 
    0.00694829f, -0.03507323f, 0.00045284f, -0.04994087f, -0.03604288f, -0.01352275f, -0.01579459f, 0.01087318f, 
    -0.05086831f, -0.00956352f, 0.00797863f, -0.01301242f, 0.03200194f, 0.02397264f, -0.04391077f, -0.02733762f, 
    -0.02536408f, -0.00622639f, -0.00589278f, 0.00715807f, 0.01446720f, -0.01746803f, 0.00264004f, -0.05601076f, 
    -0.03803826f, 0.02416863f, -0.01525320f, -0.05513833f, -0.02672904f, 0.03010400f, -0.02318911f, 0.03469032f, 
    -0.04900516f, -0.05275654f, 0.00955789f, -0.00540086f, 0.01756948f, -0.03902120f, -0.00113620f, -0.00642998f, 
    0.01207844f, 0.02361945f, -0.01980749f, 0.00855887f, 0.00771086f, -0.01749462f, -0.02732992f, 0.00524695f, 
    0.00137554f, 0.04209922f, -0.03729190f, -0.05114983f, -0.03069310f, -0.01975253f, 0.02596022f, 0.02739217f, 
    -0.05637779f, 0.03176564f, -0.04860990f, -0.05717793f, 0.00366552f, -0.02538003f, 0.03314873f, 0.01322899f, 
    -0.01364590f, 0.00770095f, -0.03836288f, -0.01342562f, 0.01443036f, 0.04406193f, -0.03787780f, -0.01005373f, 
    0.03884016f, -0.05454189f, -0.01569629f, -0.03247566f, -0.01084285f, -0.03927437f, -0.03390295f, 0.03106035f, 
    -0.00865767f, 0.04517454f, -0.04646594f, -0.01697169f, 0.03289474f, 0.02185765f, -0.03820326f, 0.02933856f, 
    -0.00996972f, -0.02020559f, 0.03902293f, 0.00567266f, 0.00698461f, 0.00584341f, 0.02604112f, -0.04496831f, 
    -0.04384388f, -0.02981088f, 0.02155426f, -0.00239887f, 0.03731662f, -0.03101043f, 0.04521885f, 0.02040932f, 
    -0.05146597f, 0.02245934f, 0.04075349f, 0.00289757f, -0.05136616f, 0.03066644f, -0.03364725f, 0.00755191f, 
    -0.05307905f, 0.03495574f, -0.01865947f, -0.03025682f, -0.00624555f, -0.04548387f, 0.00041950f, -0.03981597f, 
    -0.05089393f, -0.03833640f, 0.03431159f, -0.00368104f, -0.03191836f, -0.05075986f, -0.04057629f, -0.01789929f, 
    0.03719568f, 0.03819406f, 0.00592282f, -0.02123224f, 0.03686270f, -0.00310551f, -0.05527818f, -0.01873646f, 
    -0.00927820f, 0.03980852f, 0.01978817f, 0.01517062f, 0.01589987f, -0.02895379f, -0.01547350f, -0.05822708f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03661302f, -0.04362049f, -0.00665859f, 0.06743803f, 0.02742131f, -0.01263589f, -0.08591666f, -0.04602817f, 
    0.02462694f, -0.01737443f, 0.08677456f, 0.15055186f, 0.00642696f, 0.01219953f, 0.01209577f, -0.03049703f, 
    0.11465699f, 0.01121481f, 0.01950209f, 0.03196862f, -0.02448911f, 0.04054452f, 0.01428440f, -0.03764506f, 
    -0.06787386f, -0.04443293f, 0.02972198f, -0.01445032f, 0.13009551f, 0.04965283f, 0.11207578f, 0.03119315f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.31799003f, -0.02020356f, -0.20508955f, 0.16071078f, 0.01894821f, 0.11923399f, 0.16013701f, 0.01530166f, 
    0.61897337f, 0.21839768f, -0.31499001f, -0.08100486f, -0.14532337f, -0.02746687f, 0.08558977f, -0.13399573f, 
    0.01431260f, -0.03408861f, -0.05588941f, 0.30279797f, 0.16438794f, -0.12712197f, -0.21161057f, -0.17234887f, 
    0.11718900f, -0.09596065f, -0.48904419f, 0.15063627f, -0.05258398f, 0.04938682f, 0.21904723f, 0.12948157f, 
    -0.02654735f, -0.32211119f, 0.08668935f, -0.34778389f, 0.28742519f, 0.09264833f, 0.59370238f, 0.14959687f, 
    0.10605857f, 0.28315392f, 0.14650990f, -0.03669016f, -0.08862498f, 0.26526144f, 0.01456610f, 0.11900814f, 
    0.11734855f, -0.15362592f, -0.10295965f, 0.04674833f, -0.05563232f, -0.09273638f, -0.36352021f, -0.04794636f, 
    -0.40162456f, -0.01366824f, -0.13316120f, 0.41134790f, -0.08603651f, 0.10573620f, -0.03665615f, -0.05868697f, 
    -0.05955607f, -0.12723455f, -0.07231653f, 0.11755444f, 0.04180456f, 0.09425852f, 0.05482548f, -0.17402706f, 
    -0.14536792f, -0.08583625f, -0.17119853f, -0.00872878f, 0.15273398f, -0.12908424f, -0.04382299f, -0.02930217f, 
    -0.13141188f, -0.17405321f, -0.14100164f, -0.03513037f, 0.09235264f, -0.13273385f, -0.13552368f, -0.06078309f, 
    -0.05114198f, -0.00302454f, -0.13976410f, 0.08425552f, -0.10188449f, 0.03857265f, -0.07350275f, 0.15678313f, 
    0.16395101f, -0.37199375f, -0.20807777f, -0.00237557f, 0.15815392f, 0.22818767f, -0.03506710f, 0.25433218f, 
    -0.47022733f, 0.13386364f, -0.48683253f, -0.06379289f, -0.09312245f, -0.18436876f, 0.11165444f, -0.05874527f, 
    0.29308748f, -0.25939748f, 0.15067530f, 0.38142234f, -0.05409788f, -0.12733884f, -0.22501424f, -0.15112300f, 
    -0.22770151f, 0.00594138f, 0.20236683f, 0.03565867f, 0.24286993f, 0.10714792f, 0.19213261f, -0.14791328f, 
    0.07546901f, -0.20924322f, 0.11827051f, -0.36136568f, -0.11266568f, -0.41585758f, 0.04167601f, -0.06447234f, 
    0.18344472f, 0.17289786f, 0.42688003f, 0.09911849f, -0.10745379f, 0.05943534f, 0.11601201f, -0.09934002f, 
    0.33145729f, -0.50558817f, 0.16684128f, 0.25695631f, -0.16727823f, 0.47698626f, 0.06852549f, 0.06750830f, 
    0.03001706f, -0.08844392f, 0.11592562f, -0.01468127f, 0.17714348f, -0.02508723f, 0.03876002f, -0.03204644f, 
    0.11001206f, 0.06983513f, -0.36303961f, -0.14179322f, -0.27487838f, 0.22204226f, -0.33960271f, -0.28184006f, 
    0.13094883f, -0.18410179f, 0.15653978f, -0.02379834f, -0.07425964f, 0.08992930f, -0.06636222f, 0.04446908f, 
    0.25027579f, -0.40528974f, -0.11505402f, 0.16095382f, 0.15531009f, 0.33326221f, 0.59461612f, 0.03156955f, 
    0.19467448f, -0.09287698f, -0.14483103f, -0.28013095f, 0.27662215f, 0.16250414f, 0.25543368f, -0.17471451f, 
    -0.13516158f, -0.17690046f, -0.13125230f, 0.10458036f, 0.07593846f, 0.09558935f, -0.05282586f, -0.05927934f, 
    0.01419194f, -0.11842968f, 0.09784421f, -0.04414563f, 0.08266989f, -0.04715373f, 0.12139276f, 0.04667028f, 
    -0.09597320f, 0.14655574f, -0.02692796f, -0.06696962f, -0.10917951f, 0.06124039f, -0.10246287f, 0.04475542f, 
    -0.07138095f, -0.02190749f, -0.12741527f, 0.07340999f, -0.07887285f, 0.01736580f, -0.14618810f, 0.00592549f, 
    0.39319208f, 0.13650806f, 0.30932927f, 0.40970242f, 0.45408544f, -0.20466985f, -0.39260927f, 0.15633911f, 
    -0.07544996f, 0.36460984f, -0.11790735f, 0.04066299f, -0.11076245f, 0.24024400f, -0.08311724f, -0.15728626f, 
    -0.10038785f, 0.45437974f, -0.01031653f, -0.05748998f, 0.12893412f, -0.15861426f, 0.48147386f, 0.03835778f, 
    -0.43279397f, -0.08340804f, 0.32151270f, -0.22089258f, 0.15099913f, 0.08525665f, -0.15136871f, 0.12012137f, 
    -0.03493993f, -0.01851250f, 0.12914127f, -0.15131721f, 0.15554248f, -0.03400140f, -0.02936474f, -0.09688313f, 
    -0.04189224f, -0.08013326f, -0.09391945f, -0.13558604f, 0.09598518f, 0.07243524f, -0.13999709f, -0.06892105f, 
    -0.09658963f, 0.12908544f, 0.01131569f, -0.12087050f, 0.08218551f, -0.00817085f, 0.07226186f, 0.03780252f, 
    0.01819140f, -0.02961395f, -0.10431422f, -0.15402439f, -0.14174350f, -0.07963086f, 0.06294033f, -0.14011531f, 
    -0.19819750f, 0.17899805f, -0.11595507f, 0.01331791f, 0.26863807f, 0.40781868f, -0.18415652f, -0.42497113f, 
    -0.35227907f, -0.03168611f, -0.36869335f, 0.22221874f, -0.10108684f, -0.23529890f, -0.02291949f, -0.17532784f, 
    0.16622898f, 0.36948222f, 0.10377394f, -0.22846109f, -0.02998523f, -0.39809343f, -0.19908926f, 0.13402529f, 
    -0.42700180f, 0.16145271f, 0.19385946f, 0.22451398f, 0.10959303f, 0.23894821f, -0.01695258f, -0.15259786f, 
    0.39503828f, -0.08346147f, 0.44703209f, 0.03601165f, -0.08008811f, -0.41352776f, -0.29002267f, 0.42812991f, 
    -0.00899451f, -0.01703494f, 0.18616740f, 0.13240133f, -0.12738952f, 0.01289455f, 0.12050767f, -0.13933146f, 
    0.00316483f, -0.08749210f, 0.01819425f, -0.07830208f, 0.05109289f, 0.28657594f, -0.13224806f, -0.16445264f, 
    0.23785183f, 0.16974774f, 0.49745113f, -0.16646856f, 0.22940677f, 0.22587235f, 0.10769320f, -0.04769815f, 
    0.08605892f, -0.00898869f, 0.12583731f, -0.13392621f, -0.01742968f, 0.06347828f, 0.14702182f, -0.13067402f, 
    0.11713953f, 0.13147381f, 0.11022340f, 0.08909818f, 0.04081246f, -0.11487833f, -0.10029093f, 0.12247097f, 
    -0.19056609f, -0.16568723f, -0.13009614f, -0.07928731f, 0.11467936f, -0.13818480f, -0.05408406f, 0.01069630f, 
    0.11027209f, 0.05932215f, 0.02760210f, -0.07531232f, -0.15338416f, -0.09229677f, -0.07233302f, -0.10713189f, 
    -0.17731807f, 0.15276609f, -0.12716074f, 0.42498425f, -0.07515925f, 0.40994588f, -0.24398640f, 0.00760842f, 
    0.09281489f, 0.04264580f, -0.36555523f, 0.20734979f, -0.10954029f, 0.10094117f, 0.14276153f, 0.09157568f, 
    0.03247893f, 0.14464879f, 0.08297178f, 0.03803414f, 0.00545511f, -0.03476015f, -0.03566776f, -0.17396437f, 
    0.02803524f, -0.13319413f, -0.24057786f, -0.16753131f, -0.01658740f, 0.09606185f, 0.02250821f, -0.11208294f, 
    -0.05673742f, -0.17607044f, -0.07362970f, -0.14144805f, 0.09874856f, -0.09548589f, -0.11528686f, 0.04293017f, 
    0.01889626f, -0.19600561f, 0.06059859f, 0.09273434f, -0.01647791f, -0.14654799f, -0.16421397f, 0.04357944f, 
    0.04423880f, -0.08204789f, 0.06080861f, -0.07125483f, -0.11677358f, 0.11568779f, -0.03592665f, -0.05959280f, 
    0.14095756f, -0.13923633f, -0.09738942f, -0.02677481f, -0.20930794f, 0.09752829f, 0.01928515f, -0.01664292f, 
    0.02416494f, 0.10929466f, -0.15456468f, 0.13335454f, -0.04697860f, 0.03177097f, 0.03419471f, -0.16335046f, 
    0.06078026f, 0.01355234f, -0.14174870f, -0.14521089f, 0.15950616f, -0.01029534f, -0.00191684f, 0.05690103f, 
    0.04669833f, 0.09021255f, -0.10193704f, -0.07544398f, 0.17580971f, -0.13734367f, -0.13765496f, 0.00529253f, 
    -0.17326240f, 0.11997652f, -0.05385048f, -0.15232480f, -0.17300287f, 0.03164246f, 0.13878351f, -0.14858577f, 
    -0.26102513f, 0.21363521f, 0.29609179f, 0.35055363f, -0.14508638f, -0.08504866f, 0.02490032f, 0.35848874f, 
    0.16086084f, 0.09418846f, -0.05997422f, 0.06124220f, -0.07131517f, 0.30177647f, 0.06688469f, -0.14999753f, 
    -0.01806225f, 0.02456889f, -0.15829068f, 0.15758573f, -0.12550534f, -0.29359233f, -0.06501196f, 0.00245192f, 
    0.18755195f, -0.12425563f, -0.09420854f, 0.28439605f, -0.31606674f, 0.16519110f, -0.32666361f, 0.02844477f, 
    -0.16716893f, -0.12877600f, 0.05688624f, -0.00491615f, 0.05919181f, 0.09605347f, -0.15014827f, 0.08965728f, 
    0.09125985f, 0.11568446f, -0.14062062f, 0.04629047f, -0.06934626f, -0.02110248f, 0.02819848f, 0.04754398f, 
    -0.16969241f, -0.03602308f, 0.16495289f, -0.14582010f, -0.13067462f, 0.03506015f, 0.13151880f, 0.12969188f, 
    -0.06281150f, 0.01754591f, -0.01901176f, -0.11035127f, -0.14612724f, -0.14594047f, -0.15792955f, -0.12579525f, 
    0.14724760f, -0.11821828f, -0.05267160f, 0.08199396f, 0.00695007f, 0.16193758f, 0.15529066f, -0.13743159f, 
    -0.14493850f, -0.03100836f, -0.06072661f, -0.09643436f, -0.13188699f, -0.10898750f, 0.15262572f, -0.13502786f, 
    -0.09445733f, -0.16044076f, -0.04945904f, -0.02417190f, 0.05606237f, -0.05618750f, -0.02471405f, 0.13171512f, 
    0.09330310f, 0.13400887f, 0.15208477f, -0.11953101f, -0.12395775f, -0.08221103f, 0.00754722f, -0.14648329f, 
    -0.01879303f, -0.14301623f, 0.04224583f, 0.03668273f, 0.14893125f, -0.12166240f, -0.14748546f, -0.20101778f, 
    0.12521954f, 0.30532786f, 0.38428479f, 0.21251218f, -0.10204931f, -0.19114028f, -0.10777471f, -0.02703447f, 
    0.24604630f, 0.14143284f, -0.17008060f, -0.00040452f, 0.03735371f, -0.11281888f, -0.23441350f, -0.02961283f, 
    -0.49697798f, -0.12947172f, -0.15151636f, 0.17124316f, -0.07326218f, 0.00725694f, -0.04337312f, 0.06417095f, 
    -0.12795679f, -0.07771830f, -0.01256303f, -0.00373581f, 0.01533720f, -0.05574087f, -0.08970621f, 0.07311835f, 
    -0.04775820f, -0.14791350f, -0.00218687f, -0.03637979f, 0.01618711f, -0.10265415f, -0.14969115f, 0.00724308f, 
    -0.01989120f, -0.00289033f, -0.11513177f, 0.05721089f, 0.07341226f, -0.03928196f, -0.08819616f, -0.10989087f, 
    -0.09133178f, -0.14443870f, -0.10321156f, -0.03150911f, -0.06954727f, 0.15557550f, -0.15341440f, 0.13944560f, 
    -0.04924468f, -0.15390874f, -0.08040060f, 0.03680060f, 0.09492108f, 0.10779695f, -0.06082979f, 0.06131251f, 
    0.07365426f, 0.06566316f, 0.07113650f, -0.14508276f, -0.06401554f, -0.05324981f, -0.17992292f, -0.09717228f, 
    -0.06385201f, -0.05286174f, 0.05354847f, 0.03423447f, -0.15329917f, 0.01188007f, -0.13535079f, -0.08265529f, 
    0.04454323f, 0.11351141f, -0.05956135f, 0.06403834f, -0.09321929f, -0.15069126f, -0.12943085f, 0.14575616f, 
    -0.22094852f, -0.46893489f, 0.05288572f, -0.21521612f, 0.23820597f, -0.33068621f, 0.26890075f, 0.15740407f, 
    0.41897947f, 0.37384957f, -0.41805917f, 0.15481244f, 0.08388575f, 0.18857044f, 0.14837201f, 0.00989888f, 
    -0.08098031f, 0.39951503f, 0.06401463f, 0.18824555f, -0.10908164f, -0.37805122f, -0.50818568f, -0.09173542f, 
    -0.09867497f, 0.05346729f, 0.06329207f, 0.14034638f, 0.15600751f, 0.08176646f, 0.24014303f, 0.11503594f, 
    0.07095028f, 0.43126649f, 0.00739689f, 0.37407064f, -0.29892570f, 0.39514092f, -0.10933676f, 0.33574408f, 
    -0.25897557f, -0.48021573f, -0.09210623f, 0.13736899f, -0.14871705f, -0.50317115f, -0.02729393f, -0.09226856f, 
    0.14668749f, 0.16164728f, 0.10278852f, 0.36101952f, 0.04064073f, 0.08721048f, 0.04842365f, 0.11757943f, 
    0.36002582f, -0.03324626f, 0.17131889f, 0.07553139f, -0.21957488f, -0.03193713f, 0.09906646f, 0.15301347f, 
    0.18258215f, 0.23750325f, 0.05388769f, 0.21525556f, 0.24355729f, -0.07165159f, 0.17068985f, 0.25329950f, 
    0.25977370f, 0.29117149f, 0.27659366f, -0.21673542f, -0.05992081f, -0.19841227f, -0.03588771f, 0.03711998f, 
    -0.07743996f, -0.14878292f, 0.08985923f, 0.17981327f, 0.09756808f, 0.34798071f, 0.60991150f, -0.16668610f, 
    -0.21299468f, 0.07328241f, -0.07662231f, 0.16203208f, 0.05427650f, -0.18771449f, -0.23361051f, 0.03158448f, 
    0.00478304f, 0.57148606f, 0.17298310f, -0.26823807f, 0.09372268f, 0.31435582f, -0.09437031f, -0.50444078f, 
    -0.08890690f, -0.19397962f, 0.29254970f, -0.07488991f, 0.07959651f, 0.53160834f, 0.02159328f, -0.05326822f, 
    0.13661066f, 0.31252715f, 0.09566888f, -0.45065811f, 0.03968128f, 0.20180511f, 0.02294075f, -0.00193555f, 
    0.57124990f, 0.05349584f, 0.09835237f, 0.04481486f, -0.17941619f, 0.08750898f, 0.12012464f, -0.16698129f, 
    0.08025195f, 0.16494794f, 0.02482380f, -0.04632610f, 0.06375216f, 0.24976030f, 0.18112810f, 0.43604496f, 
    0.10524470f, -0.08257895f, -0.60935020f, -0.14336489f, -0.01763856f, 0.48363593f, -0.04212044f, -0.02174264f, 
    -0.23126335f, 0.14933600f, -0.06770466f, 0.16699703f, -0.03484972f, -0.02166928f, 0.32080549f, -0.05895821f, 
    0.61385703f, 0.07405645f, 0.10273444f, -0.04640694f, 0.02183119f, 0.25857565f, -0.03249854f, -0.03050589f, 
    0.14727518f, 0.10173223f, 0.09124850f, -0.02157162f, 0.10980672f, -0.02355988f, -0.10688344f, -0.04483560f, 
    -0.13451867f, -0.05440328f, -0.07852287f, -0.01345512f, 0.02538512f, 0.06752171f, 0.05854237f, -0.11312288f, 
    -0.14402221f, 0.06210472f, -0.04712683f, 0.04314084f, -0.11461172f, -0.11601614f, -0.03110766f, -0.08283480f, 
    -0.17379129f, 0.00804695f, -0.07486244f, -0.08817334f, -0.10413447f, -0.13249296f, 0.13646045f, -0.14799739f, 
    0.08798637f, -0.00640769f, -0.15158001f, -0.16475064f, -0.13854142f, 0.00516720f, -0.12822984f, -0.05009982f, 
    0.09013902f, -0.06644241f, -0.06587576f, 0.01776859f, 0.02150550f, 0.08937086f, 0.14360188f, -0.10543291f, 
    0.03714241f, 0.02623527f, 0.16343872f, -0.11255355f, 0.07733773f, -0.13901260f, -0.14385550f, -0.00294665f, 
    -0.03576265f, 0.13701808f, 0.04974844f, 0.03163196f, -0.18926820f, 0.13138509f, -0.00022859f, -0.06892552f, 
    0.11740038f, 0.30288744f, -0.08759440f, 0.33329371f, 0.01032410f, 0.16965801f, 0.18719171f, -0.39424881f, 
    0.49178743f, -0.29870623f, 0.23271224f, 0.27220160f, 0.02254295f, -0.21148197f, -0.11300480f, -0.15436949f, 
    -0.02992811f, 0.20624764f, -0.11135481f, -0.23894966f, -0.10867993f, -0.24363059f, 0.21219073f, -0.04994688f, 
    -0.09204432f, 0.04838669f, -0.30519071f, 0.33953246f, 0.12797228f, -0.11577788f, 0.20682943f, -0.15543069f, 
    -0.23130317f, 0.29956225f, 0.27174103f, 0.60066164f, -0.29317236f, 0.35297102f, 0.19834015f, -0.25656906f, 
    0.25471017f, 0.28728536f, 0.13478383f, 0.17234525f, -0.07871485f, 0.00505909f, 0.17240599f, 0.02914744f, 
    -0.12440933f, 0.27137524f, -0.04799812f, 0.03424692f, 0.09899011f, 0.10997189f, 0.10728016f, -0.06665260f, 
    -0.04407401f, 0.15773542f, -0.35424784f, 0.30282688f, -0.11892264f, 0.05949727f, -0.19222201f, 0.17269503f, 
    0.19252492f, 0.04263156f, 0.25391749f, 0.29743740f, -0.02625803f, -0.18836534f, -0.37158534f, -0.10670607f, 
    -0.09342293f, -0.36327869f, 0.20527470f, 0.22946247f, 0.03567792f, -0.20874919f, -0.10306352f, -0.08924710f, 
    0.04825776f, 0.00954633f, -0.13832808f, 0.21474855f, -0.05559787f, 0.20009646f, 0.05678204f, -0.00772465f, 
    -0.05597425f, 0.11010526f, 0.11465918f, -0.10866343f, 0.22879757f, 0.03224206f, 0.33998710f, 0.13844976f, 
    -0.23240595f, 0.19192523f, 0.00070520f, -0.46677032f, -0.27617240f, 0.19738327f, 0.18759322f, -0.14480245f, 
    -0.39492989f, 0.07879245f, -0.17375983f, 0.19447286f, 0.08416125f, 0.35001153f, -0.17497936f, 0.11246061f, 
    0.34975213f, -0.28838471f, 0.02246804f, 0.10663994f, -0.01835729f, 0.35750952f, -0.29459247f, -0.13865621f, 
    0.14004380f, -0.03417924f, -0.00047545f, 0.14824036f, 0.09519403f, 0.29746950f, -0.12620635f, -0.01873365f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.02903461f, -0.05867500f, -0.07856841f, -0.09584580f, 0.06108129f, -0.12331893f, -0.04535735f, 0.09153660f, 
    -0.03624539f, 0.12513751f, 0.08609814f, -0.04345444f, -0.09231028f, -0.13937950f, -0.12860605f, -0.00581992f, 
    0.15398508f, 0.04137602f, 0.04104001f, -0.15158068f, 0.06955678f, -0.01383982f, 0.17532377f, 0.01880362f, 
    -0.02800195f, 0.09187260f, -0.13601273f, -0.07138534f, 0.18984896f, 0.04156598f, 0.01857654f, -0.06423211f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.12926099f, 0.25032416f, 0.04613820f, 0.15339155f, 0.11185411f, -0.28988060f, -0.14828473f, -0.12189633f, 
    -0.12346867f, -0.59438652f, 0.12471446f, 0.12566531f, -0.71073681f, -0.13912301f, -0.02344454f, 0.27912188f, 
    0.09575946f, -0.04847330f, -0.35591763f, 0.06948437f, -0.05315671f, 0.25856540f, -0.08097091f, 0.05152670f, 
    -0.50466919f, 0.27600294f, 0.14458615f, 0.05598935f, -0.24391432f, -0.29982945f, -0.19117975f, 0.08854702f, 
    -0.04002975f, -0.14638191f, -0.14159116f, 0.23979761f, 0.22552396f, 0.35442796f, -0.11627375f, -0.11459780f, 
    0.01791616f, -0.24331756f, 0.08282773f, 0.09688267f, -0.06093968f, -0.18351474f, 0.01014133f, -0.38403380f, 
    -0.08646745f, 0.14337038f, -0.34131232f, 0.03677928f, 0.11642754f, -0.16873431f, 0.10085755f, 0.14868030f, 
    0.20972072f, 0.17719044f, -0.05788297f, 0.02348056f, -0.46566200f, -0.43654564f, 0.13455439f, 0.16761206f, 
    -0.13847880f, -0.49987549f, -0.17158553f, -0.05804825f, -0.08676251f, 0.25770202f, 0.12304201f, 0.07881114f, 
    -0.04193532f, -0.38962749f, -0.01839779f, -0.05611344f, 0.27668163f, -0.03992028f, -0.08718979f, 0.06784224f, 
    -0.14117499f, 0.16003379f, -0.35365486f, -0.01213600f, -0.13915713f, -0.62439203f, 0.46249610f, 0.32852492f, 
    -0.17873469f, 0.13087702f, -0.01214724f, -0.05298127f, -0.07134743f, 0.12673455f, 0.14207566f, -0.12130307f, 
    0.37011975f, 0.18087697f, 0.08198374f, -0.17916158f, 0.00030698f, -0.37193206f, 0.01227683f, -0.89028597f, 
    0.00125355f, 0.06205973f, -0.40631878f, -0.03137500f, -0.00570228f, -0.09428496f, 0.04402731f, 0.08267953f, 
    0.09699098f, -0.07343129f, 0.20346355f, 0.05243793f, 0.08355869f, 0.30797970f, 0.27583349f, -0.15116693f, 
    -0.03375833f, -0.41158488f, 0.10840551f, 0.12774080f, 0.33713889f, 0.18921988f, -0.15216897f, 0.05897899f, 
    0.29581335f, 0.06309608f, -0.18835577f, 0.01523453f, -0.19043411f, 0.18764195f, 0.05226850f, 0.03991352f, 
    -0.11841365f, 0.18581285f, -0.28421330f, -0.05465401f, 0.42070583f, -0.08931137f, -0.01323967f, 0.13671632f, 
    0.13483731f, 0.02441015f, 0.08293863f, -0.17350146f, -0.12917653f, 0.26655304f, -0.41050279f, 0.02967764f, 
    -0.14351575f, 0.10875276f, 0.12984392f, -0.12163039f, 0.07444488f, 0.21919009f, -0.21980430f, -0.13185586f, 
    -0.62188923f, 0.11468557f, 0.09453638f, 0.14683785f, 0.18919800f, -0.03731069f, -0.08834720f, 0.14168614f, 
    0.07593043f, 0.22952096f, 0.08925919f, -0.15482621f, -0.32773039f, -0.11807676f, 0.00642059f, -0.20999038f, 
    -0.00522205f, 0.02167376f, 0.30186373f, 0.01800707f, -0.09988382f, 0.25043109f, -0.71012098f, -0.21108389f, 
    -0.00696829f, -0.34600085f, -0.12594758f, -0.12484925f, -0.31752017f, -0.36230513f, 0.00971914f, 0.27011257f, 
    -0.35703173f, -0.25964871f, 0.11681081f, 0.24079102f, -0.17470112f, -0.29726914f, 0.14406446f, 0.12621798f, 
    0.10543614f, 0.39230135f, 0.05288223f, 0.02534968f, 0.19002230f, -0.00964582f, -0.04206032f, -0.12249078f, 
    0.13713747f, -0.04084288f, -0.04016241f, 0.03755697f, 0.14464718f, 0.16767088f, 0.48081344f, -0.43119544f, 
    -0.37625402f, -0.14365448f, 0.07178874f, 0.13764156f, 0.17365454f, -0.22661333f, 0.25620839f, -0.38375732f, 
    -0.57381743f, 0.04052658f, -0.03113190f, -0.39624617f, -0.47218058f, 0.18304737f, -0.14224923f, -0.00013003f, 
    0.16072777f, 0.39623109f, -0.47592196f, -0.01081523f, -0.15741815f, -0.06199948f, 0.16474041f, 0.19099532f, 
    -0.09287530f, 0.08503972f, -0.21610944f, -0.07577230f, -0.15332827f, -0.24850488f, -0.14359230f, 0.15202057f, 
    0.48619911f, 0.22408023f, 0.14291452f, -0.11159021f, 0.27277800f, 0.22302642f, -0.46874800f, 0.12788077f, 
    -0.22959088f, -0.37325585f, -0.07247977f, -0.40198776f, 0.24106044f, 0.40953079f, 0.03819986f, 0.05950439f, 
    -0.13189067f, -0.18517286f, 0.18643802f, 0.14754182f, -0.22769250f, -0.13381393f, 0.09833667f, -0.51222658f, 
    -0.02728109f, -0.12949431f, -0.15665388f, 0.15646031f, -0.06350741f, -0.11969614f, -0.41393813f, -0.22040823f, 
    0.55333656f, -0.07860994f, -0.03632978f, -0.05633568f, 0.47216487f, -0.38699508f, 0.17736518f, -0.24781865f, 
    -0.30339053f, -0.02580905f, 0.03841132f, -0.23621055f, 0.02151642f, -0.56302232f, 0.00820801f, 0.36890766f, 
    0.06068887f, -0.28092894f, 0.15823896f, 0.14967635f, -0.22790496f, -0.00036454f, 0.12836121f, 0.15965104f, 
    -0.05405279f, -0.17857416f, 0.17391221f, 0.08735394f, 0.08183278f, 0.08128760f, -0.12634429f, 0.51104140f, 
    -0.15676084f, -0.18138283f, -0.02501109f, 0.05789567f, 0.04047931f, 0.09001689f, 0.00192823f, -0.68552256f, 
    -0.42814234f, 0.05333324f, -0.03851229f, -0.04181734f, 0.21328799f, 0.25959760f, 0.15106720f, -0.46845877f, 
    0.07999474f, -0.01241160f, -0.05862987f, -0.09649601f, -0.00929861f, -0.01405365f, 0.03800255f, -0.08161832f, 
    -0.08720727f, -0.00740617f, 0.17191975f, -0.08691982f, 0.09360965f, -0.66596085f, 0.14876685f, 0.20295572f, 
    -0.05092369f, -0.89455348f, 0.12995307f, 0.14839496f, 0.26103455f, 0.18405144f, 0.09526886f, 0.19848400f, 
    -0.47300312f, -0.21393982f, 0.14416657f, -0.34969223f, -0.05939010f, -0.13510905f, 0.00985086f, -0.11475749f, 
    0.09585772f, -0.10060165f, 0.19102688f, 0.13257718f, 0.31838906f, 0.05586766f, 0.05594870f, 0.28320494f, 
    -0.08579127f, -0.12301563f, -0.17578407f, -0.16661650f, -0.03441462f, 0.00035363f, 0.19944403f, -0.76712817f, 
    0.32557330f, 0.15182394f, -0.09389285f, 0.14435823f, -0.05085002f, 0.23059079f, 0.09833334f, 0.27579111f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.07542216f, 0.17456919f, 0.04439706f, 0.08663312f, -0.14154004f, 0.09098054f, -0.06414600f, -0.19995418f, 
    0.05822096f, 0.03108450f, 0.14001286f, -0.07464086f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
