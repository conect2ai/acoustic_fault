#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.01731114f, -0.43368894f, -0.32038245f, -0.63094634f, -0.23146863f, -0.52302700f, 0.41893119f, -0.04940916f, 
    0.59353667f, 0.75554150f, -0.89302373f, 0.45452613f, 0.48360875f, -0.20700179f, -0.20373817f, -0.28244159f, 
    -0.00852839f, -0.33289251f, 0.11408532f, -0.00966705f, 0.53546834f, 0.19305246f, -0.41408461f, -0.04055069f, 
    -0.30526620f, -0.45242774f, 0.35958707f, 0.33325133f, 0.20124364f, 0.14042933f, 0.16270834f, 0.53061479f, 
    0.06322573f, 0.58417451f, -0.38582769f, 0.32136822f, -0.73002261f, -0.35090441f, -0.06816670f, -0.24474196f, 
    0.20700437f, -0.43353423f, -0.04849349f, 0.51697677f, -0.01256021f, 0.60525829f, 0.66155559f, -0.91549844f, 
    -0.44660902f, -0.22967008f, 0.13480671f, 0.24203092f, 0.44635767f, 0.11231433f, 0.31716043f, -0.32526907f, 
    -0.05579161f, -0.43557662f, -0.59607965f, -0.24486354f, 0.03429881f, 0.65148747f, 0.53373885f, -0.73078591f, 
    0.31222147f, 0.41153514f, 0.21900085f, -0.01535432f, -0.24646157f, -0.00027238f, 0.21474470f, 0.55831462f, 
    -0.44800600f, 0.13152829f, 0.10208394f, -0.53304768f, -0.37432793f, 0.13568814f, 0.18253443f, -0.32820559f, 
    0.38805047f, 0.17366762f, -0.06072923f, -0.00776877f, -0.22048423f, -0.32568240f, -0.74745238f, -0.38239601f, 
    0.82942617f, -0.47265390f, 0.65335995f, 0.42504203f, 0.52330822f, -0.16212307f, -0.34747508f, 0.37071985f, 
    0.10236172f, -0.17766970f, -0.19086578f, -0.73704922f, 0.04910668f, 0.43262631f, 0.19845007f, -0.71117157f, 
    -0.67044312f, -0.38615993f, -0.34729171f, -0.24239486f, 0.67736685f, 0.62279558f, 0.17202480f, -0.26252633f, 
    0.67828315f, -0.65906090f, 0.02214332f, 0.19872525f, 0.53726637f, -0.43720669f, -0.48331752f, -0.02786253f, 
    -0.33986866f, -0.58307803f, 0.73277515f, 0.48964497f, -0.38170525f, -0.03984465f, -0.16070035f, -0.54579282f, 
    -0.91242194f, 0.41609204f, 0.21496405f, 0.23267046f, 0.46703729f, 0.63945991f, 0.11811447f, -0.43307027f, 
    0.63046354f, -0.22744030f, 0.07954644f, 0.06221243f, 0.07355947f, 0.06507381f, 0.59207982f, -0.16899118f, 
    0.21461196f, 0.13881582f, 0.59474164f, 0.42455852f, -0.67704827f, -0.28421786f, 0.05344119f, -0.11399072f, 
    -0.04396915f, 0.62946397f, -0.03719452f, -0.68226963f, -0.09187098f, 0.31800228f, -0.61899817f, -0.04155686f, 
    -0.42847881f, -0.38015819f, -1.11308837f, 0.33512074f, 0.53047198f, -0.48395127f, 0.07085232f, 1.02130949f, 
    -0.04628415f, -0.04269236f, 0.14135191f, 0.31605244f, -0.21797353f, 0.10691400f, -0.50791311f, -0.14986970f, 
    0.84813190f, -0.12205485f, 0.15987043f, -0.01474515f, -0.75669611f, 0.61888164f, 0.33145565f, -0.17530562f, 
    -0.01347770f, -0.29116082f, -0.17212525f, -0.42196360f, -0.16984916f, -0.44699082f, -0.37352908f, -0.42790890f, 
    0.95780963f, -0.65382260f, -0.41062728f, -0.21059872f, -0.32457933f, -0.14025334f, 0.01756894f, 0.12971446f, 
    0.56421250f, -0.14268647f, -0.54204291f, 0.66674763f, 0.44657701f, -0.40853074f, -0.13817219f, 0.22510503f, 
    -0.10483351f, -0.04841965f, 0.41300413f, 0.32999510f, 0.26978996f, 0.63609165f, -0.33181795f, -0.59572017f, 
    -0.51574856f, -0.48890039f, 0.27585888f, 0.07921275f, -0.25292820f, -0.63614994f, 0.48385844f, -0.31426910f, 
    0.50170571f, -0.02665511f, 1.17567658f, -1.04919362f, 0.14026141f, -0.18584952f, 0.17579353f, -0.42844847f, 
    0.05376926f, -0.24054191f, -0.77109438f, -0.73392677f, -0.21667184f, 0.22022769f, 0.35501307f, -0.14698419f, 
    -0.02724036f, -0.23915456f, -0.46727097f, -0.03042339f, -0.10580555f, 0.80502802f, -0.62722981f, 0.11372826f, 
    0.12537313f, 0.39064541f, -0.54922879f, 0.06481308f, 0.40773401f, -0.20339514f, 0.28152037f, 0.46232533f, 
    0.24314021f, 0.57590282f, 0.05965111f, 0.06879805f, -0.06796969f, -0.61901045f, -0.64758766f, -0.56724519f, 
    0.91091639f, 0.44993311f, 0.12187308f, -0.32007018f, -0.34775728f, -0.09176971f, 0.17192845f, 0.30633602f, 
    0.13188717f, 0.49130595f, 0.25718406f, 0.17858796f, 0.10886209f, -0.56782299f, -0.06485330f, 0.76578760f, 
    -0.07240579f, 0.38544080f, -0.58679330f, -0.40034026f, -0.24485146f, 0.49320611f, -0.28094119f, 0.33289781f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.21286504f, -0.17434862f, 0.16638927f, -0.12036425f, -0.13960171f, 0.14863111f, 0.31082910f, 0.18582767f, 
    0.04002358f, -0.11737795f, -0.15994731f, -0.56263536f, 0.09004163f, -0.12364978f, 0.04430119f, -0.23973723f, 
    0.27137685f, 0.06375214f, 0.09228194f, 0.18361382f, 0.11176703f, -0.04815967f, 0.12429041f, 0.04533335f, 
    -0.17120598f, -0.23263285f, 0.27464852f, 0.08826336f, 0.12398387f, -0.06094110f, -0.21366724f, 0.13082315f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.06513683f, -0.16868296f, 0.08966304f, 0.12954164f, 0.03033216f, -0.24646042f, 0.00752639f, 0.07878077f, 
    -0.19288845f, 0.12515689f, 0.10253508f, -0.01341804f, -0.44702080f, -0.07864732f, -0.00688202f, 0.14245780f, 
    0.07196043f, 0.06528263f, 0.34230584f, 0.18969335f, 0.10254681f, -0.20322350f, -0.14677700f, -0.01722729f, 
    -0.18566327f, -0.07903852f, -0.12916182f, 0.09505311f, 0.19383241f, 0.09505872f, 0.09643628f, -0.11850245f, 
    -0.17352259f, 0.07778881f, 0.23813152f, 0.04363455f, -0.07540789f, 0.03328140f, 0.18091089f, 0.22137444f, 
    -0.08326226f, -0.04848418f, -0.04913548f, -0.15225339f, -0.02601457f, 0.33969036f, 0.10072053f, 0.14181678f, 
    -0.10407073f, -0.02709957f, 0.00221013f, 0.02075044f, 0.03993107f, 0.08429882f, -0.00701314f, -0.01648681f, 
    0.09581439f, -0.00894771f, -0.07420769f, -0.04164088f, 0.01835614f, 0.04766524f, -0.15402101f, -0.13705280f, 
    -0.04048490f, -0.02245041f, -0.15552077f, -0.04938293f, -0.11535225f, 0.05879451f, 0.10373159f, 0.08510552f, 
    0.14738265f, 0.04979776f, 0.21542251f, -0.01527381f, 0.00279467f, -0.01770286f, 0.04144182f, -0.01866861f, 
    0.06400001f, 0.11717855f, 0.18635254f, 0.56556010f, -0.02458326f, -0.03066826f, -0.11749920f, -0.07959870f, 
    -0.05604093f, 0.35180569f, 0.27056268f, 0.17914222f, 0.06356739f, -0.15358940f, -0.10382283f, -0.12657176f, 
    -0.15030600f, -0.07824941f, -0.16701970f, 0.21969725f, 0.07243829f, 0.52114940f, -0.15403290f, -0.06444721f, 
    -0.08614304f, 0.15673746f, -0.02341489f, 0.06396122f, 0.24699822f, 0.33830258f, 0.20310859f, -0.06978686f, 
    -0.07606655f, -0.18366249f, -0.16191095f, 0.06048295f, 0.14065050f, -0.16197230f, 0.16264091f, 0.22430766f, 
    0.00029553f, -0.09523941f, 0.09205933f, -0.03668384f, -0.10064399f, 0.11781104f, -0.22060646f, 0.02741635f, 
    0.34258661f, -0.06976999f, -0.15089549f, 0.04009579f, -0.09050437f, -0.14742242f, -0.04739417f, -0.04991093f, 
    -0.19857791f, -0.05130548f, -0.03410912f, -0.02284985f, 0.19210678f, 0.22169799f, -0.07916049f, 0.30311865f, 
    0.32117161f, 0.16067110f, 0.19939697f, -0.14079116f, 0.01825850f, -0.17624812f, -0.00992598f, -0.13805144f, 
    0.00468056f, 0.19345793f, 0.12914954f, 0.20639646f, -0.15787034f, -0.00869536f, 0.11243531f, -0.09457409f, 
    0.10518889f, 0.14555988f, 0.22293717f, 0.03243319f, -0.22836305f, 0.08945327f, -0.10941432f, -0.12062152f, 
    0.03531134f, -0.00274379f, -0.14187552f, 0.13372065f, -0.09293728f, -0.01492642f, -0.04556837f, -0.21920206f, 
    0.21078792f, 0.23524722f, 0.04713608f, -0.09169909f, 0.30454898f, 0.12808505f, 0.26556075f, -0.12141342f, 
    0.04988490f, 0.12275856f, 0.02322469f, 0.03349684f, 0.08551560f, -0.10926246f, -0.06743827f, 0.36766493f, 
    0.15806757f, -0.12622854f, -0.18542728f, 0.24061699f, -0.19113578f, 0.05725061f, 0.10041640f, 0.12435287f, 
    -0.14586468f, 0.04406230f, -0.10484718f, 0.05499807f, 0.00453127f, 0.12624966f, 0.00849109f, -0.16332896f, 
    0.04292137f, -0.04637745f, -0.01860978f, -0.00255652f, 0.06124890f, 0.20587046f, 0.10364977f, 0.18122120f, 
    -0.00611824f, -0.26557040f, 0.29080111f, 0.06486150f, 0.05189153f, -0.16560902f, 0.01611788f, 0.05997716f, 
    -0.18276380f, 0.53203142f, -0.28781575f, -0.01870024f, 0.02822986f, -0.17888947f, 0.10211203f, -0.00377424f, 
    0.01855894f, 0.10628614f, -0.07354663f, 0.05234152f, 0.17407978f, 0.14948277f, -0.13282531f, -0.09262285f, 
    -0.04240186f, -0.18738396f, 0.21386404f, 0.17507918f, 0.07126959f, -0.15125051f, 0.12637340f, -0.18969348f, 
    0.23185167f, 0.04645409f, -0.05828179f, -0.07918289f, 0.01863056f, 0.04496867f, 0.06917366f, -0.01917596f, 
    -0.05982017f, 0.13682568f, 0.02903533f, 0.12537146f, 0.02741008f, -0.17231691f, -0.04187641f, 0.10120858f, 
    0.12949488f, -0.20322631f, -0.19368851f, -0.08247911f, -0.04638235f, 0.01726996f, -0.00639346f, -0.02727170f, 
    0.03007419f, 0.03171993f, -0.05680698f, 0.00911405f, -0.05138696f, 0.12388132f, 0.05069954f, 0.30061156f, 
    0.06444019f, 0.07263484f, 0.21624121f, -0.22082151f, -0.06547493f, -0.11651332f, -0.07556386f, -0.16137090f, 
    0.01488492f, -0.00286441f, 0.02709638f, -0.03761266f, -0.00428153f, -0.01824120f, -0.01804755f, -0.05713564f, 
    -0.03204248f, 0.03842414f, 0.04573194f, -0.03167504f, -0.01303834f, -0.02860128f, 0.00368789f, -0.02557452f, 
    0.02357745f, -0.05574333f, -0.02278546f, -0.05500665f, 0.04440003f, -0.04905444f, -0.06077114f, -0.02504927f, 
    -0.04823193f, -0.03496058f, -0.07117330f, -0.01634627f, 0.04356312f, 0.00699933f, 0.01616903f, 0.01938464f, 
    -0.03330258f, 0.00728070f, 0.03668541f, 0.01799233f, 0.02127305f, -0.05644995f, 0.03622185f, -0.03148928f, 
    -0.05660930f, 0.00966482f, -0.05621733f, -0.02963680f, 0.02715646f, 0.04073765f, -0.03597741f, -0.03022176f, 
    0.01735155f, -0.06149078f, -0.03845201f, -0.04858442f, 0.01859073f, -0.02598329f, 0.05060512f, -0.06413431f, 
    -0.03046069f, -0.05554801f, -0.06285057f, -0.01639698f, 0.03455623f, -0.01281230f, -0.05939327f, 0.01473006f, 
    -0.04550388f, -0.01579531f, -0.01049020f, 0.04526058f, -0.01453813f, 0.03586052f, 0.02601932f, 0.04165887f, 
    -0.04697798f, -0.01267540f, 0.02664274f, 0.01615533f, -0.02319034f, -0.05031900f, 0.00892678f, -0.01215133f, 
    -0.00274016f, -0.03075019f, 0.03565708f, -0.01444831f, -0.06046682f, -0.04200179f, 0.02253691f, -0.06073354f, 
    0.01531507f, -0.04926713f, -0.04898288f, -0.03325807f, -0.00395605f, 0.03100904f, 0.00731337f, 0.04062640f, 
    -0.04461808f, 0.03728188f, -0.01393625f, -0.00832296f, -0.03296136f, 0.03784029f, 0.02694359f, 0.01418936f, 
    0.05648969f, 0.00686243f, -0.05385564f, -0.03495500f, -0.04875384f, 0.00165287f, 0.03776327f, -0.04332816f, 
    0.01408354f, 0.01160118f, -0.06226110f, 0.01531039f, -0.00229274f, 0.02294696f, -0.02767563f, 0.02648221f, 
    -0.05824203f, 0.04348946f, 0.03710635f, -0.05901707f, -0.04749626f, -0.03523653f, -0.02404487f, -0.04330827f, 
    -0.02002768f, 0.02276714f, -0.04656653f, -0.00771472f, 0.03911860f, 0.00419101f, 0.04147683f, -0.06216922f, 
    -0.05214626f, -0.06556330f, -0.03624059f, -0.00276015f, -0.03044797f, -0.00049676f, -0.04870318f, 0.04650879f, 
    -0.03636361f, 0.00595790f, 0.04550109f, 0.04013005f, -0.06537011f, -0.04586781f, -0.03391561f, -0.03035702f, 
    0.03864056f, -0.01224001f, -0.00717473f, 0.00641578f, -0.02631578f, -0.02783831f, -0.05364620f, -0.02100611f, 
    -0.01826469f, -0.05747831f, -0.03350650f, -0.01250758f, 0.01635900f, 0.03461269f, -0.02710583f, -0.04650473f, 
    -0.02094303f, -0.01916681f, 0.00975890f, 0.02622751f, -0.05483490f, -0.03194355f, -0.02516006f, -0.02734155f, 
    0.01946198f, 0.01746901f, 0.00595394f, -0.00069461f, 0.02646034f, 0.03671424f, 0.04902294f, 0.03762617f, 
    -0.03049308f, 0.03811547f, 0.02586384f, -0.02569703f, -0.02040939f, -0.02746072f, -0.01141308f, -0.00325717f, 
    -0.01820522f, 0.00738729f, -0.02967071f, 0.01766174f, -0.02321964f, 0.06013820f, -0.02062579f, -0.04119027f, 
    0.00808648f, -0.00159370f, -0.03593588f, 0.00781878f, -0.02150539f, -0.03094760f, -0.00388106f, -0.05665163f, 
    -0.04065317f, -0.04324473f, 0.01704364f, 0.01604874f, 0.03109206f, 0.01056220f, -0.03156381f, -0.06179946f, 
    0.04535931f, -0.04268180f, -0.05148439f, -0.05927562f, 0.00409877f, -0.01128255f, -0.03643855f, 0.04639978f, 
    -0.05521389f, -0.01554947f, -0.04886416f, -0.00212027f, 0.04043287f, -0.01099377f, -0.02763276f, 0.01061866f, 
    0.04471566f, -0.00504247f, -0.05511395f, -0.01928670f, -0.06213767f, -0.00446049f, -0.04246125f, 0.01568096f, 
    -0.00649342f, -0.03222134f, 0.04745208f, 0.04731240f, -0.00682978f, -0.03242957f, -0.03269260f, 0.02790979f, 
    0.04092073f, -0.00739637f, -0.06071727f, -0.01158182f, -0.04596860f, 0.01219984f, -0.03930631f, 0.03626222f, 
    0.03814355f, -0.01538984f, 0.03280281f, 0.04295286f, 0.04149073f, -0.05159149f, -0.03981118f, -0.00603793f, 
    -0.01779971f, -0.04011749f, 0.04880422f, -0.02724213f, 0.05989975f, -0.02683584f, -0.00401103f, -0.05757409f, 
    -0.00859047f, -0.04545382f, -0.04284522f, 0.02789047f, -0.02422327f, 0.00470355f, 0.00866887f, -0.02452808f, 
    -0.02845156f, -0.02146853f, -0.00619112f, -0.05680652f, -0.03869633f, -0.03775492f, -0.06748122f, 0.03253746f, 
    0.18261550f, 0.36964709f, 0.06110180f, -0.14165860f, -0.06606612f, -0.07886440f, 0.07046906f, 0.11409420f, 
    0.09197325f, 0.10715788f, -0.17425624f, -0.22115199f, -0.01884045f, -0.03914283f, 0.05031507f, 0.10457262f, 
    -0.11920500f, -0.17919059f, -0.07474582f, -0.22601669f, 0.07882638f, 0.01804435f, 0.03901287f, -0.05006211f, 
    0.05994701f, -0.08407796f, -0.13576713f, -0.04123786f, 0.01534338f, -0.24763167f, 0.04650107f, 0.08294375f, 
    -0.09075525f, -0.10684131f, -0.02022336f, -0.16316134f, 0.08675145f, 0.11540427f, 0.13426253f, -0.14238265f, 
    0.03256387f, -0.10112814f, 0.03639284f, -0.01718433f, -0.00663273f, 0.20664804f, 0.08210289f, -0.40012297f, 
    -0.07739066f, 0.09819725f, 0.08775984f, -0.08219767f, 0.06578714f, -0.16677953f, 0.11805494f, 0.17326052f, 
    -0.00089078f, -0.08008570f, 0.15369785f, -0.10296912f, 0.18098469f, 0.09813090f, 0.19776115f, -0.14665155f, 
    -0.16261628f, -0.06836480f, 0.10800817f, 0.13847551f, 0.01236906f, 0.08360790f, 0.12728797f, 0.09755637f, 
    0.15958479f, 0.26174277f, 0.15203851f, -0.02119330f, 0.03081552f, -0.02428180f, -0.10985332f, 0.01828367f, 
    0.02421269f, 0.17219350f, 0.05247413f, 0.09870114f, -0.03682777f, 0.09904814f, -0.18755531f, 0.08462267f, 
    -0.08855490f, 0.07404698f, 0.01566832f, -0.40472522f, 0.12027575f, -0.02558931f, -0.02281491f, -0.00577719f, 
    0.04561355f, 0.25026351f, -0.07925653f, -0.07326261f, 0.17754246f, -0.04302407f, 0.06412837f, 0.01244523f, 
    -0.05946723f, -0.01724618f, -0.05503779f, -0.12292057f, 0.15007448f, -0.30659238f, -0.06272341f, -0.02130981f, 
    -0.01299071f, 0.02114472f, 0.06572910f, 0.09513212f, 0.00913328f, 0.17400874f, 0.15645523f, 0.24119376f, 
    -0.11668836f, 0.09511127f, 0.17190143f, -0.09166367f, -0.00446012f, -0.00901929f, 0.13084739f, 0.06343639f, 
    -0.37914053f, -0.00995925f, -0.00542139f, 0.08871346f, 0.00064558f, 0.14819220f, 0.05661089f, -0.27549434f, 
    -0.11268555f, -0.40037662f, -0.27187407f, 0.08132783f, 0.04575844f, -0.15574788f, 0.21663818f, 0.06779503f, 
    -0.15288147f, -0.31571883f, -0.12167650f, 0.03062714f, 0.14711209f, -0.08497719f, 0.09121898f, -0.07070743f, 
    -0.04914844f, 0.04400152f, 0.06633825f, -0.01422984f, -0.00572372f, -0.01751133f, 0.16009971f, -0.06715664f, 
    0.01428262f, -0.09198236f, -0.10714272f, -0.16571993f, 0.35153770f, -0.05582965f, -0.08158006f, -0.06860793f, 
    -0.10999694f, -0.05572967f, 0.09541135f, -0.15013856f, 0.01296143f, -0.05274635f, -0.14390256f, -0.09972555f, 
    0.00805321f, -0.13236815f, -0.09885785f, 0.11335073f, -0.19615504f, -0.06025956f, 0.10764103f, -0.02056503f, 
    -0.02612915f, -0.12647696f, -0.05223116f, -0.05449961f, -0.08836979f, 0.20689893f, 0.11731854f, 0.01739449f, 
    -0.16405492f, -0.04903019f, 0.09852283f, -0.03040235f, -0.01135447f, -0.05051868f, -0.02795324f, -0.01415746f, 
    0.40745354f, 0.07588121f, 0.03254431f, -0.03550027f, -0.15020449f, 0.07196721f, 0.02343683f, 0.02625218f, 
    0.16085689f, -0.10326304f, 0.02471871f, -0.24864759f, -0.10930839f, 0.03091374f, 0.02679100f, -0.00454473f, 
    0.24031240f, 0.31090647f, 0.03915631f, 0.19446100f, -0.00956616f, 0.08159377f, -0.02095380f, -0.06580658f, 
    0.05934482f, -0.26383555f, 0.20742619f, -0.55637485f, -0.08474889f, -0.05482161f, -0.01048077f, 0.06427865f, 
    -0.04701719f, 0.04301655f, 0.24932228f, -0.02213708f, -0.00477256f, 0.08357318f, -0.05573133f, 0.09866687f, 
    -0.12099894f, -0.07583917f, 0.00424791f, -0.07718910f, -0.32720393f, 0.43843460f, 0.19648284f, 0.07147095f, 
    -0.25600851f, -0.04300944f, 0.12961115f, -0.01442555f, -0.03201139f, 0.10434257f, -0.53903824f, 0.06785638f, 
    -0.06608750f, -0.11992319f, 0.11681934f, 0.12330955f, 0.05923828f, 0.25478673f, -0.04400950f, -0.03035120f, 
    -0.10797327f, -0.13604896f, 0.11479998f, -0.06764589f, 0.02874143f, 0.11098449f, -0.11692351f, 0.17214946f, 
    0.07131220f, 0.00983830f, -0.10807113f, -0.06325146f, -0.14398083f, -0.02492337f, -0.01707001f, 0.02146733f, 
    -0.06792595f, 0.18790600f, -0.01687231f, 0.02152592f, -0.11544579f, 0.01782125f, 0.10223708f, 0.07980329f, 
    -0.10673679f, 0.03455960f, 0.29787281f, 0.17933691f, 0.04437264f, -0.05908503f, -0.20031567f, 0.03802799f, 
    0.05747826f, 0.01500031f, -0.40200707f, 0.03096557f, -0.00183302f, -0.06159341f, 0.15105471f, 0.01652393f, 
    -0.09909599f, -0.03118176f, -0.36454278f, -0.11462223f, 0.02256908f, 0.01314593f, 0.06952462f, 0.10547051f, 
    0.04050468f, 0.00037188f, 0.01505426f, -0.10848325f, 0.12342450f, 0.19284748f, 0.08071037f, 0.00165823f, 
    -0.15719403f, -0.03008937f, 0.01500222f, 0.07244714f, 0.05130801f, 0.01399437f, 0.08126890f, -0.09739377f, 
    0.00247180f, 0.01851252f, 0.05350183f, 0.03456397f, 0.03773995f, -0.43810719f, 0.26689896f, 0.03319885f, 
    0.09183087f, -0.07093545f, -0.02942214f, 0.07803188f, 0.12482252f, -0.00352288f, -0.06174983f, -0.03113358f, 
    0.06139491f, 0.10351023f, 0.10060559f, 0.05669295f, 0.02693960f, 0.04628734f, 0.08337473f, -0.05332265f, 
    0.14115988f, -0.10015719f, -0.12087811f, 0.11297908f, -0.12511881f, 0.00453470f, 0.03223848f, 0.04306080f, 
    -0.03980180f, 0.14386348f, 0.14495930f, 0.07902604f, 0.00843812f, -0.06833727f, 0.06820834f, 0.05147857f, 
    0.08621581f, -0.00351983f, 0.22089683f, 0.17832099f, -0.12238614f, -0.15991026f, -0.12311801f, -0.04169547f, 
    0.20323186f, 0.07473739f, -0.56593192f, -0.19131456f, -0.12665141f, 0.00234028f, -0.05040944f, -0.00243986f, 
    0.07073607f, -0.00214896f, -0.03103497f, -0.17921098f, -0.32676134f, 0.00544852f, -0.17368841f, -0.07843512f, 
    0.02868243f, 0.05142301f, -0.12087587f, -0.08111063f, -0.27735010f, 0.27494657f, -0.17671967f, 0.07008085f, 
    -0.07983188f, 0.04914248f, 0.08972953f, 0.00229480f, -0.03598139f, -0.34856328f, 0.10488054f, 0.03482391f, 
    -0.07792483f, -0.10839745f, 0.06185646f, 0.06228718f, 0.00463166f, 0.13174127f, -0.12775205f, -0.13577786f, 
    0.14795773f, 0.12031937f, 0.01219363f, -0.03816126f, -0.01758762f, 0.07138550f, 0.03907534f, -0.22128995f, 
    0.15998593f, -0.22711377f, -0.05853964f, 0.10552449f, -0.01797899f, 0.07033732f, -0.04520930f, -0.15453435f, 
    -0.17662480f, -0.25567856f, 0.07490988f, 0.01580191f, 0.07038105f, -0.02009775f, -0.08740292f, -0.00474091f, 
    0.10266984f, 0.11448666f, 0.11010516f, 0.08141842f, -0.07878753f, -0.02957501f, 0.06811274f, 0.02530894f, 
    -0.03549237f, 0.10048685f, -0.24499010f, 0.17969842f, -0.53630465f, -0.16390082f, -0.04246219f, -0.05912647f, 
    -0.08708817f, 0.17020017f, 0.02601339f, -0.24084130f, 0.16855249f, -0.07015648f, 0.06531422f, -0.04395274f, 
    -0.09010687f, -0.03775490f, 0.20045881f, 0.08012754f, -0.15783514f, -0.13690761f, 0.01333856f, 0.01618790f, 
    -0.00350973f, -0.01172614f, 0.10145181f, -0.11829843f, -0.07593469f, -0.00246851f, -0.11820463f, 0.15430067f, 
    -0.05899053f, -0.03372556f, -0.06395548f, 0.07232846f, -0.05105493f, 0.03839240f, -0.32973534f, 0.03562506f, 
    -0.01359016f, -0.04022817f, 0.05609292f, -0.05022043f, 0.06144875f, 0.11823414f, -0.01406113f, -0.06003298f, 
    -0.05182938f, 0.16977185f, -0.16973612f, 0.00706805f, 0.09436917f, -0.01663815f, 0.01891333f, 0.04594753f, 
    0.08772984f, -0.00418323f, 0.07004116f, -0.01866758f, 0.25164673f, -0.20172375f, -0.15387666f, 0.03059384f, 
    0.10439529f, -0.07676467f, -0.36741552f, -0.35408634f, 0.00176131f, 0.16889000f, 0.00246989f, -0.03501664f, 
    -0.03425326f, -0.01746180f, 0.09540869f, -0.01174944f, 0.13793592f, -0.13245344f, 0.06687099f, 0.06566375f, 
    0.23687956f, -0.12834702f, 0.00801606f, -0.30729863f, -0.07513414f, 0.04919932f, 0.05836083f, 0.08771791f, 
    -0.02881968f, 0.07822211f, 0.03819957f, 0.00866492f, -0.09582791f, 0.03215593f, 0.14481844f, -0.09701061f, 
    0.04064384f, -0.04114441f, 0.00947457f, 0.08139936f, 0.03121068f, -0.01040065f, -0.13564514f, 0.07218564f, 
    -0.04288701f, 0.04689253f, -0.01000523f, 0.07380516f, -0.10587157f, 0.09275476f, -0.17816764f, -0.25379387f, 
    0.16839495f, 0.02588797f, 0.05503639f, -0.21361656f, 0.00932875f, -0.07136218f, 0.06758533f, -0.03020797f, 
    0.01691494f, 0.15150771f, 0.10262965f, 0.10023484f, 0.05014290f, -0.08872235f, 0.05205569f, 0.06035029f, 
    -0.24619034f, -0.45229098f, -0.12780049f, -0.02611900f, -0.08396410f, -0.05991617f, -0.05583693f, -0.10573751f, 
    -0.08733151f, 0.14437932f, 0.02929054f, -0.35968444f, -0.09057204f, 0.08633430f, -0.03887515f, 0.08355080f, 
    -0.16318294f, -0.01818237f, 0.09313942f, 0.00484009f, 0.01474929f, 0.10135827f, 0.12489205f, 0.10263557f, 
    -0.04995852f, 0.22385651f, 0.10998411f, -0.19103381f, -0.09804130f, 0.06509767f, -0.12604806f, -0.31782380f, 
    0.08731657f, 0.10301071f, 0.01725804f, 0.13742195f, -0.07455255f, -0.00758391f, 0.00996597f, 0.07626790f, 
    -0.01765773f, -0.09344500f, 0.14789759f, -0.14477757f, 0.04010489f, 0.15483394f, -0.04014590f, -0.21708174f, 
    0.00054180f, -0.16774176f, 0.07728202f, 0.02026947f, -0.02032669f, 0.21939887f, 0.04068625f, -0.21632689f, 
    -0.29330254f, -0.03203046f, -0.07976336f, -0.04400761f, 0.04288687f, 0.06715023f, -0.03037217f, 0.14704157f, 
    -0.12743258f, 0.06011364f, -0.08240461f, 0.01226521f, 0.04147207f, 0.14811014f, 0.14071810f, 0.24643271f, 
    0.11248296f, -0.21877001f, -0.05434061f, -0.07573111f, 0.09068353f, -0.01003591f, -0.03161263f, 0.14734487f, 
    -0.08705712f, -0.12425069f, -0.20209613f, 0.09093508f, 0.03050772f, -0.05251013f, -0.08511929f, -0.00958500f, 
    0.04422044f, 0.06017283f, -0.26850551f, -0.10243285f, -0.04322119f, -0.08517163f, -0.06209453f, -0.27890310f, 
    -0.09512029f, -0.02604094f, 0.04715203f, -0.08411317f, -0.07983466f, 0.16902527f, -0.12042136f, -0.02690362f, 
    -0.10148337f, -0.08816289f, -0.00152776f, -0.44342485f, -0.31240273f, -0.35948849f, 0.03818487f, -0.05736095f, 
    -0.03608312f, -0.04766165f, 0.02485893f, 0.14861704f, 0.05407329f, -0.00573469f, -0.18722531f, -0.24745397f, 
    0.03909802f, 0.03498309f, -0.17835498f, -0.11655229f, 0.03405484f, -0.13561040f, -0.30847800f, 0.10792143f, 
    0.33200240f, 0.12938850f, 0.03507831f, 0.12559634f, 0.13467346f, 0.24905065f, 0.12224973f, 0.37362301f, 
    -0.27014691f, -0.27395830f, -0.09651169f, -0.28684437f, -0.05030528f, 0.22295433f, -0.13451916f, 0.06270777f, 
    -0.12156861f, -0.22890295f, -0.04384301f, -0.05977982f, 0.07690708f, -0.02422314f, 0.19709821f, 0.17625035f, 
    0.22255224f, 0.06899860f, 0.02481198f, 0.18619417f, 0.13602062f, -0.01265109f, 0.04081813f, 0.07844912f, 
    -0.04334282f, -0.14714424f, 0.44208324f, -0.43124044f, -0.30627820f, 0.03430839f, 0.05049542f, -0.22808158f, 
    0.03388710f, 0.04634263f, 0.06840757f, 0.08359194f, -0.07143055f, 0.15957475f, 0.01219036f, 0.19508241f, 
    -0.03185682f, 0.01078700f, 0.01023934f, 0.04548732f, 0.11042149f, 0.04949187f, 0.09952685f, 0.06894299f, 
    0.10585480f, 0.01754637f, 0.05235580f, 0.04520746f, 0.08663559f, -0.04272099f, 0.01424087f, -0.01184780f, 
    0.06824461f, -0.04499317f, -0.05241250f, 0.00127174f, 0.02261052f, -0.03842025f, 0.04021731f, -0.02659381f, 
    -0.18879484f, 0.15009892f, 0.04874061f, 0.06352820f, 0.12279766f, 0.03404615f, -0.03310137f, -0.18480323f, 
    -0.14120474f, 0.14530154f, 0.16724002f, -0.02145995f, -0.10387066f, 0.04603680f, -0.08332873f, 0.10755575f, 
    -0.15410438f, -0.21307237f, 0.08298683f, -0.16946676f, -0.16673972f, -0.03165948f, -0.08130352f, 0.20371138f, 
    0.02096881f, 0.58708894f, -0.34314752f, 0.30031914f, 0.04571970f, -0.23893222f, 0.02386575f, -0.03465840f, 
    -0.03661251f, -0.16560152f, 0.00991463f, 0.21101825f, 0.28281772f, 0.03610529f, 0.04353586f, 0.11745454f, 
    -0.00391424f, 0.07762080f, -0.01544525f, 0.41446811f, 0.03689804f, -0.39185447f, 0.10519454f, -0.02807773f, 
    0.11010845f, 0.04964865f, 0.18435349f, 0.16069129f, -0.22227818f, -0.10282379f, 0.00624028f, -0.06282786f, 
    -0.01894663f, -0.22253682f, 0.10970398f, -0.10479584f, 0.11338987f, -0.12905836f, 0.09773979f, 0.32373586f, 
    -0.01252897f, -0.17558804f, -0.05446696f, 0.00674597f, -0.05859240f, -0.07055540f, -0.37280837f, -0.23841679f, 
    0.07676982f, -0.00991859f, -0.22890444f, -0.32513714f, -0.00289472f, -0.13776238f, -0.17346229f, 0.01953261f, 
    0.04212155f, -0.27749091f, 0.03964641f, -0.05896492f, 0.12115456f, 0.12532634f, 0.13017467f, 0.23488079f, 
    -0.09821191f, -0.11871837f, -0.35919616f, 0.07345671f, -0.01205069f, 0.02461194f, -0.04849823f, -0.06268857f, 
    0.13549113f, 0.31903887f, -0.04633483f, -0.23446880f, 0.13090985f, 0.02768422f, 0.14747562f, -0.01139512f, 
    0.03441530f, -0.02362608f, 0.24159293f, 0.08540781f, 0.11282638f, 0.24546416f, 0.13698272f, -0.15237013f, 
    0.12891057f, 0.08530952f, 0.04037014f, 0.06284166f, -0.08910558f, 0.25859681f, -0.16206589f, -0.03272781f, 
    -0.04248202f, -0.09193183f, -0.14704025f, -0.10734158f, -0.12089022f, 0.09101159f, 0.33893368f, 0.18698226f, 
    -0.19859244f, 0.06743693f, 0.03035420f, -0.18838626f, 0.06548444f, 0.05353734f, -0.32921943f, -0.12896357f, 
    0.02477895f, 0.01106029f, -0.02318626f, 0.23396187f, -0.04639378f, 0.14107955f, -0.24334714f, -0.34994921f, 
    -0.16543528f, 0.25896698f, 0.02843107f, 0.06240217f, 0.17416947f, 0.01377506f, 0.41271061f, -0.10587421f, 
    -0.00092318f, 0.30092752f, -0.11487886f, -0.12526689f, 0.07109728f, 0.26614526f, 0.08253682f, 0.15907246f, 
    -0.29430926f, -0.14687894f, 0.08734170f, 0.02913981f, 0.20578562f, -0.03866845f, 0.09268275f, 0.01406196f, 
    0.19401516f, -0.16375431f, -0.44239470f, -0.04064051f, 0.12617236f, -0.12037119f, -0.01347978f, 0.05047398f, 
    -0.12612982f, 0.16319424f, 0.14729479f, 0.13337660f, 0.12353478f, 0.00806969f, 0.03795131f, -0.08484615f, 
    0.05541892f, -0.00739340f, 0.11080208f, -0.18305402f, -0.28776786f, -0.11077836f, -0.03814427f, -0.04489192f, 
    -0.20894513f, -0.02608340f, -0.30632308f, -0.37685865f, -0.04140977f, -0.30628735f, 0.34272459f, 0.07612252f, 
    0.09638323f, 0.00972879f, 0.17232232f, -0.02927213f, 0.03099526f, -0.30576551f, -0.03335714f, -0.24589577f, 
    -0.02412294f, -0.04799378f, 0.05747902f, -0.13401262f, 0.13945381f, -0.19781756f, 0.04307230f, 0.32477745f, 
    -0.19158982f, -0.09728619f, 0.06251941f, 0.02018875f, 0.07318921f, 0.09690593f, 0.12031955f, -0.08297129f, 
    -0.17421648f, 0.36322513f, -0.07451494f, -0.23387341f, -0.23237622f, 0.06343331f, -0.12667647f, 0.04384241f, 
    -0.23826128f, 0.00840550f, 0.06627045f, 0.28111595f, 0.07044478f, 0.06912648f, 0.11046267f, 0.06316067f, 
    0.16616066f, -0.06755775f, 0.11874648f, 0.15148847f, 0.02814703f, 0.12556687f, -0.09300735f, -0.12245210f, 
    -0.12759113f, -0.05114801f, -0.22637105f, -0.18027718f, 0.16173792f, 0.06366736f, -0.07301666f, -0.00689648f, 
    0.10092090f, -0.11935805f, 0.25023821f, 0.13463689f, 0.21199177f, -0.02332476f, 0.17028286f, 0.01220683f, 
    0.27300021f, 0.07549173f, -0.07152623f, 0.01329431f, -0.12302605f, 0.06780295f, -0.11258915f, -0.00940615f, 
    -0.04056638f, 0.03616983f, -0.11349222f, -0.15958504f, 0.00071682f, 0.05947794f, 0.13906315f, 0.24050753f, 
    -0.07357638f, -0.07916858f, -0.10732625f, 0.01650097f, -0.27677265f, -0.02544121f, 0.17643686f, 0.19350244f, 
    0.18057008f, 0.11893335f, -0.03846855f, 0.14830282f, 0.03646217f, 0.32508376f, 0.07015384f, 0.21149543f, 
    0.18777572f, 0.07976762f, -0.06096815f, 0.00630993f, 0.00187877f, 0.12683824f, -0.23055474f, -0.06667487f, 
    -0.23924583f, 0.31096339f, -0.01596030f, -0.13780731f, 0.05848049f, -0.16738686f, 0.15952663f, 0.15212058f, 
    -0.08369406f, -0.07414480f, -0.05495237f, -0.33380961f, -0.10301451f, -0.13553582f, 0.35258365f, -0.18431993f, 
    -0.22089085f, 0.00292572f, -0.25240299f, -0.04439642f, 0.11047586f, -0.14114374f, -0.02950504f, 0.06922349f, 
    0.01258934f, -0.13288034f, -0.14777263f, 0.14827310f, 0.15130019f, 0.08831046f, -0.04143891f, 0.02461960f, 
    -0.10418772f, 0.12891066f, 0.14926770f, 0.10609604f, 0.24720936f, 0.17417625f, 0.05650882f, 0.01596713f, 
    0.01151884f, -0.02663661f, -0.07410679f, -0.07465925f, -0.10299610f, -0.33562103f, 0.02243572f, -0.00515947f, 
    -0.22134790f, 0.02946255f, -0.13598046f, 0.05333961f, -0.20614798f, 0.01268007f, 0.01306929f, -0.04327669f, 
    0.09552581f, -0.06030875f, -0.01159159f, -0.39511067f, 0.05641879f, -0.14770207f, -0.26843080f, -0.07647192f, 
    -0.08837186f, 0.02543304f, 0.07086224f, 0.09017803f, 0.08261736f, -0.00979001f, -0.04966917f, 0.23687276f, 
    -0.31194717f, -0.06888013f, 0.16780159f, -0.11192171f, -0.05348775f, -0.09700202f, 0.09282954f, -0.07510495f, 
    -0.00654393f, 0.24747205f, -0.29586819f, 0.07620389f, -0.07105606f, 0.09617472f, 0.01508843f, -0.06018319f, 
    -0.15878767f, -0.05728258f, -0.19968788f, 0.12587202f, 0.17023030f, -0.18191959f, -0.04044162f, -0.01582173f, 
    0.24466029f, 0.08815657f, -0.16439652f, -0.03399397f, 0.00887854f, 0.05355451f, 0.05977131f, 0.10634536f, 
    -0.09124419f, -0.00697697f, -0.06634039f, 0.06575420f, 0.17693824f, 0.12226652f, 0.13432671f, -0.16670761f, 
    -0.00670944f, 0.12356465f, 0.12745334f, 0.02034351f, -0.08226995f, -0.09838922f, -0.14088561f, 0.01205055f, 
    0.16725303f, 0.17841895f, 0.31343102f, -0.04667592f, -0.02288457f, 0.15553156f, -0.05047518f, -0.25272837f, 
    0.01090547f, -0.13297559f, -0.05543834f, 0.06380411f, 0.10139751f, -0.02646485f, 0.09995355f, 0.04988200f, 
    0.11154531f, -0.07032911f, 0.10970610f, 0.02220109f, 0.03920341f, 0.01002204f, 0.17322487f, -0.00897048f, 
    -0.20942178f, 0.05667962f, -0.08488952f, 0.14760266f, -0.19964665f, -0.13635778f, 0.15983936f, 0.13441828f, 
    -0.11185411f, 0.03918289f, 0.03606041f, 0.05759839f, -0.34855455f, -0.03196284f, -0.13215439f, -0.17164762f, 
    0.14339831f, 0.00262053f, -0.09878211f, 0.12231357f, 0.10691890f, -0.09093376f, -0.23529588f, -0.20299019f, 
    0.17103644f, 0.01716285f, -0.08176101f, 0.18265320f, 0.14587975f, 0.27660742f, -0.23420183f, 0.16671267f, 
    -0.02722681f, -0.09499083f, -0.09343433f, -0.11803345f, -0.00546410f, 0.06268540f, -0.06728310f, 0.12594435f, 
    -0.09560835f, -0.04740932f, 0.16261053f, 0.01813734f, 0.16352065f, -0.13692737f, 0.29578859f, -0.09133200f, 
    -0.10779777f, -0.15870905f, 0.03892981f, 0.25522366f, -0.14736103f, 0.00953106f, -0.03538170f, -0.11509883f, 
    0.04928952f, -0.06128772f, 0.00038425f, 0.21242911f, 0.12325507f, 0.07211345f, -0.19102898f, 0.00756623f, 
    0.06982913f, 0.00944548f, 0.01503711f, 0.00546891f, 0.19211608f, -0.12607098f, 0.07476939f, 0.09057058f, 
    -0.12057696f, 0.11050805f, 0.17145003f, -0.13614345f, -0.00872107f, -0.06045008f, 0.16155910f, 0.17048936f, 
    0.05590526f, 0.17084470f, 0.03395228f, 0.27428174f, 0.03460984f, -0.14674096f, -0.17167644f, -0.07677868f, 
    -0.10393429f, 0.00246925f, -0.38758776f, 0.12897331f, -0.27478972f, 0.04835593f, 0.05373060f, 0.02223650f, 
    -0.07932318f, -0.04479187f, 0.12436191f, -0.11871623f, 0.18704478f, 0.08081153f, -0.03501378f, -0.11639673f, 
    0.00952201f, 0.11856776f, 0.09254887f, 0.05887060f, -0.01142269f, 0.02675471f, 0.13325608f, -0.03348071f, 
    0.08955853f, -0.08736262f, 0.00220420f, -0.08468276f, -0.02062483f, 0.28065619f, 0.08736003f, 0.30941454f, 
    -0.01343466f, 0.10819551f, -0.08946643f, -0.07272069f, 0.05534141f, -0.36459464f, -0.06120114f, 0.07582989f, 
    0.16364460f, -0.05110277f, -0.02215852f, -0.23666684f, 0.10575167f, 0.04726974f, 0.03884900f, -0.07884178f, 
    -0.10245882f, 0.25815898f, 0.09139064f, 0.11352973f, 0.06670874f, -0.14078616f, 0.07641394f, 0.08563059f, 
    -0.07383383f, 0.15595850f, 0.04092552f, -0.23765643f, 0.04980188f, -0.19309184f, 0.01740964f, 0.21582387f, 
    0.02443906f, -0.03434855f, -0.20673010f, 0.21700668f, 0.10624516f, -0.05774266f, -0.03735063f, -0.13116734f, 
    -0.18011552f, -0.03775634f, 0.16558470f, -0.07683554f, 0.06839357f, 0.03943536f, 0.10514749f, -0.08720274f, 
    0.04312888f, 0.01032770f, -0.06879638f, -0.27082491f, 0.07351588f, 0.21608980f, -0.03955491f, 0.02167520f, 
    -0.28299713f, 0.04996752f, 0.07699444f, 0.00855510f, 0.05652074f, -0.06539048f, -0.01925773f, 0.08538413f, 
    0.04728189f, -0.00126440f, -0.06138253f, 0.12218488f, 0.00447887f, 0.13869020f, -0.05349628f, 0.22205338f, 
    0.07409424f, 0.00126599f, -0.14108388f, -0.08146091f, -0.00893439f, -0.11793544f, 0.01908994f, -0.06484997f, 
    0.10657982f, 0.13041697f, -0.03841693f, -0.19924717f, 0.12809032f, -0.08112728f, 0.04290895f, -0.14712721f, 
    0.06495453f, -0.01292774f, -0.18548465f, 0.01259012f, -0.04652153f, 0.13479258f, 0.14876525f, 0.15315261f, 
    -0.48409140f, 0.00086572f, -0.04740239f, -0.00981899f, -0.03041752f, -0.06195599f, 0.07727132f, 0.01026649f, 
    -0.00609472f, -0.06683519f, 0.17960863f, -0.04611123f, -0.00603933f, -0.02964416f, 0.04697454f, 0.04598519f, 
    -0.13259192f, 0.15188852f, 0.09750711f, 0.06622310f, 0.03005311f, 0.12892361f, 0.05909817f, 0.04078154f, 
    0.09345070f, 0.02521495f, -0.03347106f, 0.14408341f, 0.16357444f, 0.00655589f, -0.10174128f, -0.03683321f, 
    -0.17893471f, 0.08693547f, 0.03479584f, 0.04970604f, 0.05161725f, -0.68487680f, -0.02918218f, 0.15530027f, 
    -0.03409975f, 0.05556167f, 0.03285418f, -0.04492392f, -0.10590523f, 0.29025945f, -0.02494365f, -0.37543580f, 
    -0.11986241f, -0.00765795f, 0.01818892f, 0.10412419f, -0.02577207f, 0.01437939f, -0.00828694f, 0.04135301f, 
    0.09915494f, -0.06988963f, -0.16784099f, -0.00685983f, -0.00178449f, -0.00717323f, 0.03870957f, -0.33556995f, 
    -0.16656972f, -0.26706666f, -0.02279259f, 0.08964868f, 0.01363237f, 0.10962583f, 0.03194188f, -0.12801272f, 
    -0.30304381f, -0.04620471f, -0.22613747f, -0.07110855f, -0.02459661f, -0.05628263f, -0.04915695f, 0.03833044f, 
    -0.11962269f, 0.02447467f, -0.01902309f, -0.33325264f, 0.04105228f, -0.03901863f, -0.14001881f, -0.03272776f, 
    -0.02456495f, 0.07800439f, 0.29846418f, 0.19220328f, -0.04264198f, 0.04128256f, 0.21813411f, 0.07709093f, 
    -0.00612580f, -0.12749740f, 0.09205773f, 0.02793003f, 0.40550411f, -0.24023935f, -0.10502973f, -0.05175633f, 
    0.00789281f, 0.10504878f, -0.12391183f, 0.14278556f, 0.20783724f, 0.11789407f, -0.07289366f, 0.10584348f, 
    -0.03881646f, 0.08120399f, -0.00928443f, 0.06565302f, -0.14969556f, -0.33345893f, -0.45803899f, -0.06088520f, 
    0.16288178f, 0.15490972f, 0.09621727f, -0.13751131f, -0.08409140f, -0.05707572f, -0.22702380f, 0.27175921f, 
    0.16459559f, 0.03913167f, 0.28115314f, -0.00318405f, -0.00018314f, 0.05125195f, 0.00026334f, -0.21208794f, 
    -0.01980581f, -0.20781387f, -0.00461049f, 0.05340314f, -0.25217485f, 0.28445566f, 0.18829152f, 0.01902419f, 
    -0.03171316f, 0.00979857f, -0.23408855f, 0.00768175f, -0.00036588f, -0.00974347f, 0.07743546f, -0.12851234f, 
    -0.04624344f, -0.49981958f, 0.05975755f, -0.11459873f, -0.03075748f, 0.10500343f, -0.04875684f, 0.09796122f, 
    0.01822982f, 0.12579343f, -0.24227539f, 0.04377801f, -0.19713587f, 0.09952300f, -0.11437346f, 0.13841610f, 
    0.18427289f, 0.02228099f, -0.05438326f, 0.37078038f, 0.02784302f, 0.12876549f, -0.00742315f, 0.13483573f, 
    0.06061388f, -0.03811169f, -0.05785818f, 0.02970729f, 0.01027952f, -0.00901915f, -0.43397832f, -0.12609272f, 
    -0.07333748f, 0.09138117f, 0.06743608f, 0.06638007f, 0.22023848f, 0.02400046f, -0.41872379f, -0.36203280f, 
    -0.06057989f, 0.00005827f, 0.08212680f, -0.12250452f, -0.08662358f, 0.05226073f, 0.16081962f, 0.18462263f, 
    -0.15464257f, 0.05969137f, 0.15702133f, 0.00674819f, 0.01966299f, 0.03577242f, 0.17642523f, -0.23219304f, 
    0.20943129f, -0.08067729f, 0.06046522f, -0.03029338f, 0.02579421f, 0.20379190f, -0.00334489f, 0.11684972f, 
    -0.45872211f, -0.23045033f, 0.42807734f, 0.02894512f, -0.01812040f, -0.11204685f, 0.16630556f, 0.11939295f, 
    -0.20231433f, -0.14881587f, 0.00174381f, 0.07139583f, -0.05706176f, 0.07363299f, 0.17267144f, -0.00235743f, 
    -0.06347772f, 0.00804788f, 0.00619747f, -0.38933060f, -0.27359447f, 0.01094739f, 0.08336252f, 0.35356742f, 
    0.10528062f, -0.09056085f, 0.06571174f, 0.04568785f, 0.09874961f, -0.22422902f, -0.04518872f, 0.12870637f, 
    -0.02593828f, 0.20995750f, -0.06719002f, -0.10660764f, 0.00693070f, 0.10194270f, -0.11506547f, 0.03896516f, 
    0.02911796f, -0.03673153f, 0.10575057f, 0.02977755f, 0.01503689f, -0.50853240f, -0.59262007f, -0.17440732f, 
    0.10085473f, 0.19735332f, 0.19360906f, -0.04091729f, 0.04354617f, 0.15964471f, -0.08053035f, 0.17410602f, 
    0.01418277f, -0.17854367f, -0.05026812f, -0.12954737f, -0.02273493f, -0.03139059f, 0.22133124f, 0.29342252f, 
    -0.13572221f, -0.19654417f, -0.10219015f, 0.04354088f, -0.10851477f, -0.02910484f, 0.12629460f, -0.09485041f, 
    0.01312139f, -0.23574418f, -0.36346176f, 0.19289753f, -0.09046076f, -0.05901226f, 0.14970416f, 0.03494599f, 
    0.19563572f, -0.27692235f, -0.19711338f, -0.22950822f, 0.02592537f, 0.01052321f, -0.09043994f, 0.00265333f, 
    -0.14231780f, 0.01764638f, -0.25059605f, -0.08673978f, -0.04160018f, 0.18047157f, 0.01959369f, 0.14250959f, 
    -0.00171009f, 0.08680731f, -0.09302346f, -0.06908628f, 0.00026890f, 0.19029213f, 0.12882690f, 0.09408097f, 
    0.20435348f, 0.13006631f, 0.18536367f, 0.16474739f, -0.06989585f, -0.10170425f, 0.01851458f, -0.09175607f, 
    0.06898097f, -0.16143164f, -0.00592264f, -0.22832848f, 0.19115470f, -0.05371677f, 0.05988186f, -0.01053780f, 
    -0.09573520f, -0.09971962f, -0.04718273f, 0.25179008f, 0.17430077f, 0.12079076f, 0.10357188f, -0.21665548f, 
    -0.07083898f, 0.09878141f, 0.13239712f, -0.00996815f, 0.15294188f, 0.05319949f, 0.11534103f, -0.07262244f, 
    -0.17190592f, 0.16852123f, -0.05999642f, -0.03623578f, 0.22071780f, 0.14163244f, 0.12436640f, -0.04606206f, 
    -0.18145843f, -0.25767502f, -0.05248427f, -0.01833304f, -0.01831400f, 0.04905542f, 0.03052807f, 0.05500774f, 
    0.03540272f, -0.38665286f, -0.29980189f, -0.37775499f, 0.08954230f, 0.04088416f, 0.06828675f, -0.06864460f, 
    -0.03402922f, 0.07680015f, -0.26891494f, -0.06010951f, -0.10249824f, -0.02711236f, 0.04297360f, 0.02892927f, 
    -0.04978897f, 0.01314250f, 0.13453387f, -0.40173438f, -0.33221570f, -0.25372648f, -0.19443242f, -0.14493813f, 
    0.09066053f, 0.09124114f, -0.09743426f, 0.02958742f, -0.23961386f, -0.02935660f, 0.05079691f, 0.05517897f, 
    0.16975710f, 0.14928865f, 0.03466218f, 0.12207811f, -0.08412566f, 0.03879523f, -0.24102071f, -0.08580092f, 
    -0.01569609f, -0.07746270f, -0.07904766f, 0.04132905f, -0.02563284f, 0.05640277f, 0.00365312f, 0.35503870f, 
    0.23039876f, -0.03555726f, 0.03208009f, -0.15772934f, 0.04892848f, 0.13421516f, 0.19885951f, -0.14889784f, 
    0.04217124f, -0.17438748f, 0.01045191f, -0.24924065f, -0.02401076f, 0.24971251f, -0.06446723f, 0.06172670f, 
    -0.11005478f, -0.05234414f, -0.04908677f, 0.25890461f, 0.10553245f, 0.26949671f, 0.04519182f, 0.05323598f, 
    0.07625885f, -0.05702237f, -0.02393214f, -0.15588510f, 0.03317754f, 0.05878903f, -0.06037888f, -0.07676987f, 
    0.14342746f, -0.01873398f, -0.23878022f, -0.36154807f, 0.14416631f, -0.09743625f, -0.01664610f, 0.07957160f, 
    0.01403921f, -0.00026145f, 0.13779494f, -0.13689113f, -0.23836300f, 0.11198409f, -0.11162188f, 0.08390271f, 
    -0.04509352f, -0.01736417f, -0.01613319f, 0.07304017f, -0.00204399f, -0.06414695f, -0.03903799f, 0.01042766f, 
    -0.02543558f, 0.14958748f, -0.07304232f, -0.10316104f, 0.13933216f, -0.03367565f, 0.14969276f, 0.06824235f, 
    -0.17153461f, -0.09764720f, 0.00046792f, 0.04063989f, 0.04866617f, -0.01492966f, -0.10247486f, -0.14821373f, 
    0.02100368f, 0.03902881f, 0.14135279f, -0.04064844f, 0.04017255f, -0.03887035f, 0.13826394f, 0.08990586f, 
    0.07652952f, 0.14358062f, 0.04070915f, -0.07297759f, 0.03218938f, 0.02344987f, -0.02331556f, -0.07114581f, 
    -0.14833546f, -0.13909805f, -0.08029345f, -0.11335427f, 0.00065622f, 0.03311246f, 0.26994511f, 0.02155714f, 
    0.15873499f, -0.20152269f, -0.55923891f, -0.27011484f, -0.10300163f, -0.05728862f, -0.12433044f, -0.07837822f, 
    -0.11404887f, 0.14738855f, -0.03567956f, 0.47315449f, 0.42584196f, -0.11077934f, -0.04337858f, 0.10708387f, 
    0.00001663f, -0.05387668f, -0.10046271f, 0.09899251f, -0.27046618f, 0.04366219f, 0.04390709f, -0.06235332f, 
    0.14683801f, 0.13501282f, 0.09601295f, 0.21279438f, -0.03380518f, 0.11165987f, 0.13508606f, 0.05790261f, 
    0.09155507f, 0.15528189f, -0.06900990f, -0.00106230f, 0.01343250f, 0.04127917f, 0.48895460f, 0.29918310f, 
    -0.20334564f, -0.04842659f, -0.22275110f, -0.06297666f, -0.12239350f, -0.16458584f, -0.12398244f, 0.03755258f, 
    0.03950497f, 0.07480830f, -0.10633680f, 0.06392372f, 0.04236606f, 0.02522559f, 0.02443618f, -0.11427197f, 
    0.16294055f, -0.17422304f, 0.10444513f, 0.10018302f, 0.09194942f, 0.19256666f, 0.14289583f, 0.08646696f, 
    -0.23094822f, -0.11703087f, -0.49706578f, 0.15970996f, 0.07950533f, -0.19077644f, -0.19888294f, -0.00995611f, 
    0.06652556f, 0.33308676f, -0.30019322f, -0.41986755f, -0.01296909f, 0.18339507f, 0.06713943f, 0.12282580f, 
    -0.07084375f, 0.21039194f, 0.23948075f, 0.07813480f, 0.17153177f, -0.07351624f, 0.16769661f, -0.06560900f, 
    0.05201901f, 0.07106362f, 0.08781867f, 0.06899764f, 0.13352421f, 0.19698742f, -0.15899281f, -0.12744379f, 
    -0.26314980f, -0.00900402f, 0.07393866f, 0.00506386f, 0.12881091f, 0.06605875f, 0.06964549f, -0.09335704f, 
    -0.04301220f, -0.00413969f, -0.14933984f, -0.24115387f, 0.13442609f, -0.15547952f, -0.18878193f, -0.02956592f, 
    0.07628824f, 0.06887907f, 0.02467080f, 0.03332486f, 0.01426602f, 0.16232587f, 0.11587988f, -0.33905962f, 
    -0.17348874f, 0.19712433f, -0.00321385f, -0.04367841f, 0.09614749f, 0.03820632f, 0.11667446f, -0.00826049f, 
    -0.05788301f, 0.15444976f, -0.01116840f, -0.20904425f, 0.19920248f, 0.13222449f, -0.13223571f, 0.02752033f, 
    0.08893426f, -0.25644058f, -0.09810270f, 0.10550009f, -0.01081133f, 0.07370123f, 0.07584633f, 0.22499433f, 
    -0.09743736f, 0.10174542f, 0.17036583f, -0.07743676f, 0.09337573f, -0.12848093f, -0.21054643f, 0.17367177f, 
    -0.24798413f, 0.09668243f, 0.10430922f, 0.19898103f, 0.00353949f, -0.19044624f, -0.16683517f, -0.18348141f, 
    -0.00542501f, 0.13181002f, -0.00005489f, -0.00127093f, 0.03512013f, -0.02277607f, -0.14246018f, -0.08304010f, 
    -0.15426281f, 0.11728261f, 0.18234251f, 0.11659625f, 0.01656557f, 0.00034760f, 0.13279653f, -0.03268851f, 
    -0.25370058f, -0.03351576f, 0.22047904f, 0.08087045f, 0.05575746f, -0.34140959f, -0.22316748f, -0.16030903f, 
    -0.10119923f, 0.09614873f, 0.04489375f, -0.15018804f, 0.02843827f, 0.02165969f, -0.29849353f, -0.69392681f, 
    -0.52669573f, -0.07002030f, 0.28035483f, 0.04383656f, 0.17477790f, 0.06087772f, 0.09092946f, -0.31382433f, 
    -0.28995129f, 0.18885194f, -0.04100730f, -0.03764902f, -0.13894601f, 0.22464244f, -0.12785450f, 0.17148787f, 
    -0.06716833f, 0.03565300f, -0.22919518f, -0.11055735f, -0.08090917f, 0.02694907f, 0.10526446f, 0.13398722f, 
    0.12478854f, -0.08693744f, -0.09132221f, -0.01876227f, -0.06325055f, 0.22084232f, -0.17434916f, 0.01707567f, 
    0.07459668f, 0.12561046f, -0.19095516f, -0.31994778f, -0.27664950f, -0.02071816f, -0.13956930f, 0.19637097f, 
    -0.00390540f, 0.01821453f, 0.20273474f, 0.14003603f, 0.26937246f, 0.18951261f, 0.08635101f, -0.09351795f, 
    -0.02775870f, -0.02597035f, -0.09367840f, 0.22812247f, 0.00109554f, 0.17545055f, -0.29730967f, 0.00653385f, 
    -0.04771413f, 0.13955484f, 0.12508042f, 0.05885509f, 0.12875983f, -0.02164119f, -0.07782903f, 0.02065371f, 
    -0.14190775f, -0.01325952f, -0.17564069f, 0.20916969f, 0.05967782f, 0.19071659f, 0.18713512f, 0.17245050f, 
    0.08106742f, 0.00523936f, -0.02440557f, -0.03871632f, -0.12372760f, 0.09732175f, 0.10643663f, -0.01774916f, 
    0.28152254f, -0.01887948f, -0.07743646f, 0.03352281f, -0.05646955f, -0.02698990f, 0.04750623f, 0.15023549f, 
    -0.09929900f, 0.22267823f, -0.05111191f, -0.27692151f, -0.06566580f, -0.02503194f, -0.06750003f, 0.03090874f, 
    0.08063320f, -0.55777240f, -0.46111652f, -0.46696869f, 0.04285745f, -0.05008380f, 0.11061510f, 0.06456073f, 
    -0.06670829f, -0.01467002f, 0.01260489f, 0.01044528f, -0.20554577f, -0.16884618f, -0.10624408f, 0.09407607f, 
    0.08069978f, 0.04856974f, 0.01454876f, 0.13218455f, 0.04069667f, -0.04764336f, -0.08530549f, -0.05097346f, 
    -0.16643909f, -0.05428801f, 0.15410683f, 0.01704837f, 0.19102754f, 0.23237774f, 0.06058142f, -0.10863424f, 
    -0.09155567f, -0.15670505f, 0.12765437f, 0.03170716f, 0.05825252f, -0.21552797f, 0.06564932f, -0.01353066f, 
    -0.24719685f, 0.01699759f, -0.05444915f, -0.07876251f, -0.22505257f, -0.22942410f, 0.02514290f, 0.16188115f, 
    0.03830966f, -0.20755564f, -0.17119917f, -0.22568737f, -0.02010019f, -0.02110189f, -0.02590856f, 0.25744537f, 
    0.16681379f, 0.06064362f, -0.02458306f, -0.11839272f, -0.06964207f, -0.03571229f, 0.11830226f, 0.04101381f, 
    0.20250890f, 0.19325790f, 0.16612910f, -0.10097553f, -0.00901037f, 0.09946583f, 0.27207327f, 0.09994391f, 
    0.04772366f, 0.33782282f, -0.36495969f, -0.04682743f, -0.01293068f, -0.06669553f, 0.08631971f, 0.16748896f, 
    0.09419992f, 0.02207382f, -0.05499903f, -0.06140835f, 0.08971051f, 0.01177327f, -0.01035659f, -0.15688646f, 
    0.03033063f, -0.00518191f, -0.03396719f, -0.25542143f, -0.09961350f, -0.53479421f, 0.21569706f, 0.00010539f, 
    0.14090143f, 0.16779290f, 0.01797595f, -0.03336662f, 0.19121483f, 0.19445087f, 0.11656298f, -0.05613628f, 
    0.01825758f, 0.14100997f, 0.24351424f, -0.01829868f, -0.15257262f, 0.10362774f, -0.18579260f, -0.58318031f, 
    0.04971223f, -0.14312832f, 0.10235202f, -0.02783768f, 0.08088239f, -0.03067126f, 0.01340828f, 0.04738115f, 
    0.10823100f, -0.10093930f, 0.00813159f, -0.15551595f, 0.06516732f, 0.10785453f, 0.13437079f, -0.21217893f, 
    0.02409304f, -0.16872643f, 0.06020441f, 0.05002979f, 0.02756251f, 0.21597698f, 0.11507721f, 0.02045934f, 
    0.01608516f, 0.11933617f, 0.15337154f, 0.17082891f, 0.21956751f, -0.14218497f, 0.03857293f, -0.02244966f, 
    0.01078178f, -0.03010098f, 0.05128472f, 0.08718462f, 0.10638057f, 0.24532616f, -0.09797677f, 0.01447592f, 
    -0.09245586f, 0.18607335f, 0.33547610f, -0.53379053f, -0.01822443f, 0.01163605f, -0.09924232f, -0.10432045f, 
    0.04666212f, 0.04793127f, -0.02234595f, 0.02899656f, 0.15713570f, 0.03954561f, -0.02283152f, 0.06071880f, 
    -0.02684205f, 0.10323398f, -0.06657691f, 0.05762707f, -0.24515447f, -0.47309747f, -0.11045880f, 0.09353308f, 
    -0.17424873f, -0.18022434f, 0.09410720f, -0.04872531f, -0.00033688f, 0.11655695f, -0.15814988f, 0.16545677f, 
    0.01254526f, 0.21008955f, -0.08546505f, 0.01300330f, 0.26171193f, -0.12126847f, 0.27037606f, -0.14161989f, 
    -0.32485080f, -0.00396900f, 0.04620711f, 0.29883477f, 0.08694984f, -0.02276947f, -0.16977191f, 0.38222659f, 
    -0.12545417f, -0.40981397f, -0.16166741f, -0.11743904f, 0.19548318f, 0.13109633f, 0.17960650f, 0.11113076f, 
    -0.19566950f, -0.14930467f, -0.27707303f, -0.12266383f, 0.18743469f, -0.16985068f, -0.12824947f, 0.09391733f, 
    0.08565184f, 0.04229815f, 0.02069826f, 0.26258963f, -0.06379344f, 0.10649807f, 0.03830789f, -0.11241672f, 
    0.09492605f, 0.01631511f, -0.57363921f, -0.29484597f, 0.05037940f, 0.00227389f, 0.08529469f, 0.07344334f, 
    0.15611078f, 0.12465599f, -0.06152466f, -0.09295449f, -0.43067363f, -0.03057534f, -0.05274999f, -0.11294064f, 
    0.02871132f, -0.06824941f, 0.18309294f, -0.01148116f, -0.17949454f, 0.12554874f, 0.16320115f, -0.19852011f, 
    -0.04725951f, -0.04082612f, 0.13369611f, 0.00261269f, -0.04966838f, 0.02222771f, 0.08540855f, -0.07419405f, 
    -0.07381090f, 0.02577734f, -0.01541579f, 0.02608023f, -0.00172218f, 0.27578250f, -0.32356563f, 0.02815161f, 
    0.13155997f, -0.04577913f, 0.01930897f, -0.13093854f, -0.03252318f, -0.05454213f, -0.14753756f, -0.07354558f, 
    -0.01086803f, -0.12641360f, -0.06199432f, -0.23793902f, -0.01679507f, 0.17216936f, 0.01440350f, 0.07005940f, 
    0.31559619f, 0.18686996f, 0.02812495f, -0.05689542f, 0.11485180f, 0.03081649f, 0.29749751f, -0.03534506f, 
    0.03984489f, 0.02079197f, -0.03049751f, -0.87775874f, -0.16332701f, -0.21595749f, 0.11809523f, 0.08265378f, 
    -0.03636619f, -0.09897369f, 0.03338658f, -0.12442219f, -0.17790085f, -0.05194369f, -0.06691246f, 0.05215621f, 
    0.03308739f, -0.03912574f, 0.08158640f, -0.60976112f, -0.22326484f, 0.17618719f, -0.05257792f, -0.09123041f, 
    -0.04399659f, -0.00736443f, 0.00671835f, -0.16191851f, 0.24464612f, -0.01470889f, -0.87117726f, -0.18115680f, 
    -0.00300415f, 0.12580070f, 0.20174362f, 0.11781082f, -0.04281546f, -0.17137416f, -0.31018591f, -0.39038900f, 
    -0.08126561f, -0.18712546f, 0.13992114f, -0.00189121f, 0.01644178f, 0.08697017f, -0.21110317f, 0.10878349f, 
    -0.17623368f, 0.18442656f, -0.28296566f, 0.05760944f, 0.09323578f, -0.12142931f, 0.00721768f, -0.36056340f, 
    -0.19864526f, 0.17605440f, 0.02189049f, 0.05447542f, -0.14405313f, -0.13351499f, 0.11534454f, 0.16532233f, 
    0.20355259f, 0.26914835f, 0.13520712f, 0.11156011f, 0.09268603f, 0.14163423f, 0.00398425f, 0.05502103f, 
    0.04707422f, -0.26041883f, -0.43095294f, -0.20260556f, -0.03320729f, -0.10756773f, 0.10271643f, 0.05546683f, 
    0.06543327f, 0.05212562f, -0.21815027f, 0.02159236f, -0.15776679f, -0.11346742f, -0.14685465f, 0.04553576f, 
    -0.11220127f, -0.14736664f, 0.06554481f, 0.01105802f, 0.16272093f, 0.32035258f, 0.27605706f, 0.08575471f, 
    -0.01858432f, 0.07750826f, -0.07614455f, -0.00915748f, 0.26885387f, 0.18353461f, 0.24436730f, -0.05960339f, 
    -0.02410711f, -0.00447356f, 0.06420847f, 0.16999464f, 0.09734301f, -0.29104587f, 0.00658323f, -0.31573090f, 
    0.01851277f, 0.04452096f, 0.03110819f, -0.00213950f, -0.02499508f, -0.12327163f, -0.11666891f, 0.10128167f, 
    -0.01590852f, -0.04870244f, 0.09322369f, 0.12677047f, -0.02689705f, -0.04664366f, 0.06000784f, 0.08958244f, 
    -0.17472368f, -0.16122630f, -0.00002450f, 0.06784754f, -0.08224909f, 0.06831005f, -0.17391455f, 0.03036305f, 
    0.12749468f, 0.23793401f, 0.17186719f, 0.18142548f, 0.00783345f, -0.03702837f, -0.03168909f, 0.02222009f, 
    0.00642570f, 0.08913185f, 0.33505058f, 0.22629362f, -0.13968404f, 0.13147202f, -0.04016238f, -0.04483605f, 
    0.21516098f, -0.27868909f, -0.51018518f, -0.14127609f, -0.10420287f, 0.03861743f, -0.10611203f, 0.00634045f, 
    -0.01449329f, 0.08054595f, 0.08690921f, -0.12909269f, -0.16867013f, -0.06929466f, 0.10851531f, -0.02090299f, 
    -0.14491983f, 0.03094394f, -0.01026171f, -0.00649204f, -0.22928064f, 0.16262071f, -0.01194589f, 0.04529868f, 
    -0.12005632f, -0.00430491f, -0.06574099f, -0.04988616f, -0.15097570f, -0.19824886f, 0.27077439f, -0.07689310f, 
    -0.19978876f, -0.06773999f, 0.07036579f, 0.13688201f, 0.03421968f, 0.10731620f, 0.26517761f, 0.10976364f, 
    0.07264002f, -0.15875760f, -0.13782966f, -0.03447043f, 0.06258590f, -0.05085420f, 0.04716094f, -0.02922629f, 
    0.26494873f, -0.00558000f, -0.08366451f, 0.19830757f, 0.15395539f, 0.00466533f, 0.01161593f, -0.21453667f, 
    -0.39927176f, -0.28577754f, -0.11528730f, -0.01650623f, -0.01602394f, -0.07612859f, -0.02140195f, 0.01766668f, 
    0.03760262f, 0.05610492f, 0.18594754f, 0.08455147f, -0.02222389f, -0.13076866f, -0.04549004f, -0.00281482f, 
    0.02716975f, 0.10487752f, -0.43209147f, 0.17377548f, -0.52663475f, -0.25895077f, 0.06228900f, 0.05433892f, 
    -0.05250350f, 0.12084513f, -0.01928027f, -0.43606856f, 0.06899890f, -0.41555771f, -0.01725975f, 0.05644869f, 
    -0.05128136f, -0.19247651f, 0.05614337f, 0.10929235f, 0.05296722f, -0.24468060f, 0.16719495f, -0.02861653f, 
    -0.01370991f, -0.19426809f, -0.01146024f, -0.10647344f, 0.09272110f, -0.07074979f, -0.01102023f, 0.23381712f, 
    0.02579964f, -0.01539635f, -0.21613425f, 0.02234670f, 0.04648031f, 0.11293978f, -0.52659810f, -0.18821910f, 
    -0.22206123f, -0.03533442f, -0.13157710f, -0.04601765f, 0.01410763f, 0.16887310f, 0.01470143f, -0.01904136f, 
    0.00484337f, 0.10102055f, -0.20341648f, -0.12362012f, 0.12741661f, -0.01422022f, -0.13256308f, -0.22681189f, 
    0.40097293f, 0.12493871f, 0.19472192f, 0.22371584f, -0.07276210f, -0.03317106f, -0.03633499f, 0.02661476f, 
    0.10838071f, -0.25912648f, -0.58648324f, -0.08373937f, -0.18556221f, -0.07796797f, 0.00762771f, -0.18866628f, 
    0.10475361f, 0.16204681f, -0.12946193f, -0.00503269f, 0.09076221f, -0.05759361f, 0.10314075f, -0.11412965f, 
    0.13051154f, -0.07191999f, -0.06035205f, -0.43865868f, -0.23085836f, 0.10357544f, -0.07361793f, -0.03550738f, 
    -0.20475245f, -0.08839934f, -0.03748776f, 0.15708253f, -0.06129543f, 0.03942598f, 0.23641716f, -0.13722660f, 
    -0.01727452f, 0.12995936f, 0.00100221f, -0.04720841f, -0.01282471f, -0.22059023f, -0.02682443f, 0.26694646f, 
    0.05001744f, 0.05798292f, -0.03069882f, 0.01751818f, -0.01039422f, 0.02486540f, -0.28380185f, -0.10248211f, 
    0.11406925f, 0.16622701f, 0.01811226f, -0.13256264f, 0.09457734f, -0.07465240f, -0.03809304f, -0.33307129f, 
    0.30912128f, 0.24896316f, -0.05263318f, 0.08497554f, 0.17980626f, -0.01662432f, -0.03698012f, -0.10171278f, 
    -0.03329662f, -0.03448041f, -0.01016104f, -0.04526449f, 0.02235783f, -0.05140911f, -0.00826416f, -0.00940631f, 
    -0.04377455f, 0.03943887f, -0.03709322f, -0.03054658f, -0.02054338f, -0.05452232f, -0.03548864f, -0.01368417f, 
    0.05012196f, -0.06171766f, 0.04315794f, -0.00353585f, -0.01912430f, -0.01213471f, -0.04762276f, -0.04784652f, 
    -0.05829395f, -0.04827148f, -0.05649391f, 0.03543780f, -0.06607837f, 0.01954368f, 0.02039429f, -0.02880215f, 
    0.05065241f, 0.04882269f, -0.00223973f, -0.00648131f, -0.05680834f, -0.02734997f, -0.00608739f, 0.02820304f, 
    0.03971547f, -0.05603818f, 0.04468661f, 0.04451225f, 0.02164855f, -0.04795147f, -0.01059748f, -0.04906765f, 
    -0.02411051f, 0.01044827f, -0.04097945f, -0.00539689f, -0.04455478f, -0.04982986f, -0.01891464f, 0.02249363f, 
    0.05242985f, 0.03643663f, -0.02814387f, 0.00737663f, 0.01835518f, -0.06595939f, 0.01466559f, 0.03439082f, 
    0.04993429f, -0.00214116f, -0.04600673f, 0.05467074f, -0.05688300f, -0.02053291f, -0.02717892f, 0.01406193f, 
    0.00952084f, 0.04670763f, -0.05505557f, -0.03356796f, -0.04455187f, 0.04328585f, 0.01674570f, 0.02352723f, 
    0.01709663f, 0.05898316f, 0.00591432f, -0.03461802f, -0.04139224f, -0.01189017f, -0.00941185f, -0.03659163f, 
    -0.05195301f, -0.04298777f, 0.00083661f, -0.04439719f, 0.03232792f, -0.01375424f, 0.00708830f, 0.00659003f, 
    -0.05863390f, -0.02773706f, 0.01904379f, 0.00994810f, -0.04699507f, -0.01693800f, 0.02220848f, -0.00402174f, 
    -0.01322140f, -0.05459091f, -0.05412914f, -0.05817930f, 0.03628728f, 0.04469597f, -0.06174653f, -0.03271993f, 
    -0.00814288f, -0.05519515f, -0.05839081f, -0.04470231f, 0.02082428f, -0.04089940f, -0.04612970f, 0.03108029f, 
    -0.01570903f, -0.01079763f, -0.02558003f, -0.01321161f, 0.04558026f, 0.03368016f, -0.01435732f, -0.02889498f, 
    -0.04213403f, 0.05275441f, 0.02047721f, 0.00147759f, -0.03244659f, -0.05462601f, -0.00676271f, 0.04210708f, 
    0.04012636f, -0.04614160f, -0.03035477f, 0.00065932f, 0.04477399f, 0.04835432f, -0.00189892f, -0.03529385f, 
    -0.05581652f, 0.03409018f, -0.05221209f, -0.00742829f, -0.03677708f, -0.04802324f, 0.03993364f, -0.03929321f, 
    0.00946075f, 0.04305087f, 0.03022787f, 0.04584577f, -0.02896840f, -0.03971282f, 0.03091991f, -0.02577111f, 
    -0.00283307f, 0.00174798f, 0.01790946f, -0.03538518f, -0.01410878f, 0.00391197f, -0.05656659f, -0.00629193f, 
    0.02520093f, -0.06479033f, 0.01160887f, 0.04485771f, -0.06884894f, 0.00095084f, -0.04822470f, 0.03515781f, 
    -0.03067436f, -0.05345241f, -0.05081780f, 0.00962930f, 0.01784349f, -0.03916555f, 0.02418168f, -0.04708367f, 
    0.01407789f, -0.00232235f, 0.03657454f, -0.03342395f, -0.01926121f, -0.04220638f, 0.02569601f, 0.02847701f, 
    -0.02491531f, -0.03546048f, 0.01756126f, -0.01721611f, -0.01909995f, 0.01748293f, 0.02073256f, -0.05905890f, 
    -0.00225268f, -0.06749649f, 0.03788833f, -0.01454422f, 0.03882477f, 0.03406299f, -0.01074323f, -0.05981623f, 
    0.01901216f, -0.06295867f, 0.01352080f, 0.02396488f, -0.03337414f, -0.05013377f, -0.03216700f, 0.01014787f, 
    0.02603711f, 0.01810626f, -0.05141242f, 0.02188720f, -0.02734212f, -0.01242539f, 0.05176388f, 0.02535057f, 
    -0.02916736f, 0.02142742f, 0.03951178f, -0.01634698f, -0.01817092f, -0.04110826f, 0.05619673f, -0.04219076f, 
    -0.06445006f, 0.04580272f, 0.03679882f, -0.03279186f, -0.01050358f, -0.00112905f, -0.00640747f, -0.02618344f, 
    0.00961231f, -0.01002456f, 0.02944835f, -0.04458875f, 0.00442539f, -0.00746501f, 0.02870121f, 0.01041987f, 
    -0.02564080f, -0.00178267f, -0.03856521f, 0.02284001f, 0.03567395f, 0.00621390f, -0.05369433f, 0.05046895f, 
    -0.05815112f, -0.00246327f, 0.02458598f, -0.02582900f, 0.01891378f, -0.01984744f, 0.01671126f, 0.02972990f, 
    -0.00176698f, 0.02612643f, 0.01627659f, -0.01874365f, -0.00206559f, -0.04368753f, -0.02810713f, 0.00541871f, 
    -0.00053000f, 0.03645823f, 0.00990602f, 0.00108549f, 0.03759523f, 0.00037103f, 0.00041329f, -0.01057815f, 
    0.01952351f, 0.01985770f, 0.01185244f, 0.00429338f, -0.01804519f, 0.01763815f, 0.02956389f, -0.00913364f, 
    -0.01715009f, -0.01661794f, 0.01938401f, 0.02744811f, -0.06280665f, 0.04456349f, 0.02826744f, 0.01769486f, 
    -0.06137862f, -0.00993896f, 0.00050671f, -0.02466946f, -0.04240363f, -0.03813661f, 0.01689719f, -0.01980480f, 
    0.04467970f, 0.02650348f, -0.07053562f, 0.02083179f, -0.05800698f, -0.00884385f, 0.01806297f, 0.02046533f, 
    -0.06492240f, 0.02336110f, -0.05535570f, -0.05724963f, 0.01825690f, -0.05873929f, -0.00799617f, -0.04083824f, 
    -0.04313409f, -0.01013816f, -0.02891314f, -0.03109313f, 0.03452516f, -0.02004084f, 0.04578764f, -0.06226946f, 
    0.00428681f, -0.06202688f, -0.03576416f, 0.03247401f, 0.04536007f, -0.06649532f, 0.02618718f, -0.01154953f, 
    0.04354716f, 0.02199862f, 0.01335876f, -0.01943871f, 0.01853195f, 0.01266741f, -0.02439610f, 0.03584826f, 
    -0.00496388f, 0.00403486f, -0.01973066f, 0.00222426f, -0.02507764f, -0.00610379f, -0.04906073f, 0.04022899f, 
    0.02911539f, -0.03733571f, -0.04391264f, -0.02243689f, 0.02730922f, -0.04267197f, 0.01776519f, -0.06054057f, 
    -0.03540941f, -0.07033990f, 0.03436692f, -0.03541278f, -0.03683752f, 0.01568315f, -0.04030933f, 0.01430333f, 
    -0.04422703f, 0.04051160f, 0.04155171f, -0.03612123f, -0.02077357f, 0.02987226f, -0.04146298f, 0.02664892f, 
    -0.02196928f, -0.00819547f, -0.06057646f, -0.01075865f, 0.02660839f, -0.04929380f, 0.01987949f, -0.01870962f, 
    0.03471212f, 0.00911411f, 0.03297466f, -0.01720200f, 0.03303684f, -0.02308332f, 0.03479553f, 0.04729671f, 
    0.05133206f, 0.00403883f, -0.00289384f, 0.03456976f, -0.02428110f, -0.03496663f, -0.06822746f, -0.06348213f, 
    -0.06253862f, -0.01884120f, -0.04109020f, 0.01068596f, -0.02927337f, 0.03520697f, 0.00073002f, -0.01236723f, 
    -0.05990688f, -0.00708275f, 0.02972410f, -0.01206451f, 0.01537040f, -0.05611180f, 0.01371733f, 0.01746235f, 
    -0.00520892f, -0.04154626f, -0.06437365f, -0.05979536f, 0.00712771f, -0.06226153f, -0.02915384f, -0.01013448f, 
    -0.05406403f, -0.02616272f, -0.04809876f, 0.01128355f, -0.01436996f, 0.03216555f, -0.02317124f, 0.00410070f, 
    0.04128877f, -0.04741561f, 0.03902502f, -0.06882282f, -0.02364450f, -0.00170284f, 0.02916385f, -0.02746900f, 
    0.03576558f, -0.01062168f, -0.05805612f, -0.04135488f, -0.00773185f, -0.03232080f, -0.01761034f, 0.04178027f, 
    -0.05879684f, -0.06415983f, -0.05062808f, -0.01577020f, -0.06771060f, 0.04923430f, 0.01409306f, -0.01251218f, 
    0.02171361f, -0.03199411f, 0.04315495f, -0.02954826f, -0.01702778f, 0.02247607f, -0.01111367f, 0.01396738f, 
    -0.00016882f, 0.00981092f, -0.03119876f, 0.03920040f, 0.03789293f, -0.03574647f, -0.00927979f, 0.01443629f, 
    -0.05909748f, -0.03034333f, -0.02918927f, 0.03132488f, -0.02251068f, -0.02280201f, 0.03246469f, -0.06269265f, 
    -0.04970279f, 0.01793850f, -0.03217703f, 0.01736674f, 0.01936676f, 0.01876648f, -0.01015129f, 0.01378410f, 
    0.01067816f, -0.02712213f, 0.01079513f, -0.00474750f, -0.01311503f, -0.05054050f, 0.03340240f, -0.01971000f, 
    0.04474144f, 0.03371702f, -0.02191101f, -0.02000122f, -0.04604016f, -0.02870435f, -0.04794723f, -0.05773420f, 
    -0.02749717f, -0.06038549f, 0.00343741f, 0.03212523f, 0.02016401f, 0.01765465f, 0.04538909f, -0.01727700f, 
    -0.03881690f, -0.05942597f, -0.06493647f, -0.01560770f, -0.04249826f, 0.02753552f, 0.02799365f, -0.00926082f, 
    -0.04366979f, -0.02873529f, -0.05522437f, -0.05139882f, -0.00186209f, -0.02336704f, -0.04373443f, 0.00548730f, 
    -0.05370158f, -0.05437447f, 0.02794872f, 0.03337754f, -0.00401591f, 0.01034609f, -0.00840687f, -0.04863398f, 
    -0.00756476f, -0.06599446f, 0.04519751f, 0.01921397f, -0.02132108f, -0.02852862f, -0.03461352f, -0.06370168f, 
    -0.01566632f, -0.02151551f, -0.06211366f, -0.01261698f, 0.02046829f, -0.00410135f, 0.02332413f, -0.03277367f, 
    0.02542236f, -0.01086998f, -0.01296058f, 0.04582420f, 0.00996783f, -0.00534779f, 0.01951010f, -0.04681487f, 
    0.02482528f, -0.01795916f, 0.04346392f, -0.00042906f, 0.01786646f, 0.04678645f, -0.04193588f, -0.02199176f, 
    0.00864614f, 0.01188201f, -0.06909852f, 0.02348093f, 0.01403471f, -0.04558823f, 0.00888974f, 0.02687483f, 
    -0.15574296f, 0.15563028f, 0.24134412f, -0.02712554f, 0.02399210f, -0.06557426f, 0.05248391f, -0.05108925f, 
    -0.11768236f, 0.19262159f, -0.27083695f, -0.04768198f, 0.16576311f, 0.07926487f, 0.02066601f, 0.19343691f, 
    -0.20996889f, -0.08925486f, 0.02652432f, -0.01386868f, -0.17407198f, 0.03878660f, 0.11770242f, 0.02924386f, 
    0.12750873f, 0.07437272f, -0.07011160f, -0.09452961f, -0.23243794f, -0.13643023f, -0.28442588f, 0.03466234f, 
    0.09148798f, 0.00209165f, -0.03079700f, -0.06104098f, -0.01335003f, 0.11881385f, 0.21620944f, -0.02687052f, 
    -0.11699062f, 0.10890732f, -0.01938274f, -0.13277514f, 0.06307063f, -0.04969204f, -0.21068820f, -0.07224944f, 
    0.03286863f, 0.05938119f, 0.17342435f, -0.05717602f, -0.12850125f, 0.18801771f, 0.04741407f, 0.04946062f, 
    0.10357052f, -0.00865519f, 0.01028087f, -0.12394178f, 0.09876238f, -0.06324727f, 0.00663119f, -0.10589255f, 
    0.10390003f, 0.12869358f, -0.01312830f, -0.05494652f, 0.03543672f, 0.13275687f, 0.13743803f, 0.16800176f, 
    -0.00770246f, 0.20588081f, 0.04700400f, 0.13421893f, 0.11367820f, -0.05240546f, 0.08812455f, 0.07224457f, 
    -0.03759202f, -0.02815607f, 0.05326143f, 0.20783378f, -0.07967064f, -0.02352333f, 0.01350838f, 0.03200676f, 
    -0.01552036f, 0.08386166f, -0.26213011f, -0.19044575f, 0.02390359f, 0.03782987f, -0.06345160f, 0.07683803f, 
    -0.09284644f, -0.11302283f, 0.02263076f, -0.10164172f, 0.07736127f, -0.07191788f, -0.03645929f, 0.05385980f, 
    0.06835366f, -0.02273380f, -0.11118364f, -0.20866008f, -0.23979451f, -0.25164568f, -0.00566090f, -0.20698196f, 
    0.08643169f, -0.01531359f, 0.06419512f, -0.04696433f, 0.11238255f, 0.02083166f, -0.07888723f, -0.13890474f, 
    -0.08534199f, -0.11072512f, -0.09252054f, 0.14263381f, 0.15252426f, -0.17489678f, 0.04387985f, 0.06810121f, 
    -0.06311123f, -0.00356610f, 0.02554842f, 0.01469730f, 0.10268586f, 0.16054243f, -0.13132946f, 0.00601960f, 
    0.11158105f, 0.37122014f, -0.21434017f, -0.08270428f, 0.12012718f, -0.27814618f, 0.01649828f, -0.12223310f, 
    -0.37003726f, -0.19751185f, -0.24880835f, -0.03766889f, 0.01187096f, 0.14526474f, 0.04974904f, 0.04689453f, 
    0.23596300f, 0.19634245f, 0.13685785f, 0.19958493f, 0.07542445f, 0.05108064f, -0.04278167f, 0.13800910f, 
    -0.15604833f, -0.06731010f, -0.46896005f, -0.24529101f, -0.05791457f, 0.10555597f, -0.09997675f, 0.02143886f, 
    0.13635220f, 0.11756423f, -0.04121440f, 0.10548183f, -0.04111344f, 0.08647522f, 0.04528838f, 0.00248961f, 
    -0.01652648f, -0.03804154f, 0.15897563f, -0.01612026f, -0.12795708f, 0.18419388f, 0.10620021f, 0.13145207f, 
    0.00186209f, 0.07595198f, 0.22277346f, -0.05997567f, -0.19818032f, 0.21097586f, 0.18272744f, 0.11752508f, 
    0.14260653f, 0.29606518f, 0.05072213f, 0.02392105f, -0.09522762f, -0.03682433f, -0.04698158f, -0.00603273f, 
    0.06006151f, 0.03674472f, -0.18063961f, 0.07973064f, -0.00581847f, -0.06716263f, 0.10346492f, -0.17899324f, 
    -0.05735083f, 0.10691831f, 0.16741186f, -0.04818420f, -0.11867268f, -0.17482941f, 0.06310347f, 0.09273725f, 
    -0.10595663f, 0.25991929f, 0.05436179f, -0.14247447f, 0.01416216f, -0.04823796f, -0.00899621f, 0.08128490f, 
    0.01917078f, 0.01590150f, 0.14988956f, 0.03082530f, -0.02133506f, 0.12048376f, 0.21324161f, -0.13182853f, 
    0.02605353f, -0.32304522f, 0.07298875f, 0.10367236f, 0.01695263f, 0.04727172f, 0.14759637f, 0.11099891f, 
    -0.03359853f, 0.01296073f, -0.02180181f, 0.13979775f, -0.07234985f, 0.06886858f, 0.08073781f, 0.08747608f, 
    -0.07346848f, -0.15513341f, 0.08319749f, 0.01451253f, -0.08616431f, -0.22407933f, -0.19832879f, -0.09182575f, 
    -0.00615303f, -0.09058122f, -0.01795074f, -0.03054071f, 0.03876227f, 0.00280478f, 0.32633096f, -0.00392082f, 
    0.11908741f, 0.10069194f, -0.04654672f, 0.03820067f, 0.03480636f, 0.03647284f, -0.22833785f, -0.14841124f, 
    0.01556739f, -0.01492827f, -0.03149565f, -0.23435138f, 0.06379556f, -0.14040428f, -0.13636534f, 0.00185099f, 
    0.22006920f, -0.06655829f, 0.04098173f, 0.07812986f, -0.04014133f, -0.19036989f, -0.07948247f, 0.14277975f, 
    0.06766152f, 0.38224566f, 0.33198529f, -0.04281647f, -0.11841936f, -0.08316039f, 0.11973859f, -0.02704887f, 
    -0.14000708f, 0.16383606f, -0.15594840f, -0.06433053f, -0.09573962f, 0.14531167f, 0.00646687f, 0.15768534f, 
    0.02550433f, -0.16570905f, 0.12156958f, -0.12918083f, -0.06030129f, 0.03263996f, -0.03582750f, 0.05676672f, 
    -0.07701293f, 0.09467485f, -0.09341440f, 0.06793596f, -0.11949987f, -0.04349694f, 0.08924368f, 0.03641975f, 
    0.11073574f, -0.04198386f, -0.02583200f, 0.17025547f, 0.07554174f, 0.13857478f, 0.41929477f, -0.04249255f, 
    0.02728279f, 0.12295258f, -0.09090369f, 0.13128242f, 0.18359433f, 0.05796422f, -0.04647361f, -0.32629308f, 
    -0.06310946f, 0.03578718f, -0.04516692f, 0.04250798f, 0.09767295f, -0.07339279f, -0.06004640f, 0.11484656f, 
    0.16019133f, -0.01900204f, 0.03253337f, 0.05528259f, 0.03211249f, -0.01438476f, -0.01829613f, 0.05688733f, 
    -0.24092570f, -0.16532449f, 0.07228391f, 0.05882377f, 0.08657088f, -0.04468770f, 0.17283744f, 0.10276769f, 
    0.05303755f, 0.25622800f, 0.14035545f, 0.18942279f, 0.07082290f, 0.01638969f, -0.00999456f, 0.08259606f, 
    -0.05098371f, -0.05694285f, -0.05255619f, 0.27447465f, 0.01114338f, 0.06949116f, -0.09121920f, -0.02777560f, 
    -0.01149764f, -0.08265865f, 0.30761659f, -0.14605996f, -0.24968605f, 0.01702786f, -0.02689093f, 0.07245281f, 
    -0.02285158f, 0.01620594f, 0.06616016f, 0.14643019f, 0.11802483f, 0.09903009f, -0.09108267f, 0.16905899f, 
    0.02056628f, 0.02576878f, -0.10930351f, 0.06834672f, -0.02208450f, -0.20893259f, -0.00730552f, -0.07328540f, 
    -0.01129847f, 0.06602021f, -0.09645202f, -0.02152680f, -0.06241658f, -0.23690209f, -0.11076745f, -0.12632225f, 
    0.02410575f, -0.04516084f, -0.07365785f, -0.02827103f, 0.26962423f, 0.21533804f, 0.17239599f, -0.01406761f, 
    -0.06010984f, 0.09226731f, 0.08596824f, 0.16702875f, -0.14463949f, -0.08649182f, 0.00901564f, -0.00172868f, 
    0.06358867f, -0.09399086f, -0.08329377f, 0.10286336f, -0.05884744f, -0.26874083f, -0.05253992f, 0.24235095f, 
    -0.08678707f, -0.27744189f, -0.15267959f, -0.07288244f, 0.00798719f, -0.01676716f, -0.07025166f, -0.01703078f, 
    0.06279894f, 0.05332731f, 0.19882172f, 0.30530667f, 0.10748217f, 0.07630762f, -0.28160411f, 0.11243630f, 
    0.01279649f, -0.04331340f, -0.39569193f, -0.57973450f, -0.13246863f, 0.15709022f, -0.11589859f, -0.03647016f, 
    0.08478102f, 0.12777011f, 0.30883220f, -0.08996709f, -0.11451013f, -0.35861388f, 0.13542162f, -0.11343667f, 
    -0.10488913f, 0.04281374f, 0.08919475f, 0.13368510f, 0.01139829f, 0.07945123f, 0.22838320f, -0.03183608f, 
    -0.07570919f, 0.01865771f, 0.16647404f, -0.02273510f, -0.00070617f, 0.15732884f, 0.17980540f, 0.21525601f, 
    -0.10671689f, 0.16035493f, -0.03168901f, -0.00013803f, -0.18497698f, 0.00224806f, 0.03008272f, -0.21401767f, 
    -0.14781389f, 0.01411697f, -0.17389894f, -0.09984607f, -0.11721243f, 0.08108088f, 0.03019728f, -0.10446735f, 
    -0.17966190f, -0.42709976f, 0.06301224f, -0.01448829f, -0.13524351f, -0.02475674f, -0.06840190f, 0.09261420f, 
    0.18602636f, 0.29038128f, 0.19621082f, 0.06375827f, -0.09035817f, -0.07260735f, -0.04681874f, 0.06392656f, 
    0.05176336f, -0.09220181f, 0.63509691f, -0.70847470f, -0.29065621f, -0.34103611f, 0.23771486f, 0.12190379f, 
    0.00750709f, -0.03991047f, 0.22622202f, -0.24237490f, 0.10652124f, 0.17025942f, -0.00532565f, 0.04576993f, 
    0.13542834f, -0.04273634f, 0.04985633f, 0.15983225f, -0.04429801f, 0.06460547f, 0.08942948f, -0.18182507f, 
    -0.01977961f, 0.08012819f, 0.01967956f, 0.03770408f, 0.06989408f, -0.14304690f, -0.47013730f, -0.09856055f, 
    -0.05515815f, -0.08372483f, -0.06654976f, 0.06021853f, 0.03860135f, 0.07383512f, -0.33655569f, 0.01257498f, 
    0.00723103f, 0.01564404f, 0.03499535f, 0.11628165f, 0.06188007f, 0.03370646f, 0.01995700f, -0.14745350f, 
    -0.13888277f, 0.11132944f, -0.06849303f, -0.02297022f, -0.03871124f, -0.08520730f, 0.20228641f, -0.03539464f, 
    0.09547454f, 0.11501633f, -0.11784682f, -0.02259347f, -0.06310208f, -0.16517945f, -0.13902521f, -0.07655534f, 
    -0.07862075f, -0.10976444f, -0.11889246f, -0.01195869f, -0.09567704f, 0.01464287f, 0.10143460f, 0.13296282f, 
    0.13518760f, 0.03582693f, -0.31357411f, 0.11297495f, 0.01409744f, 0.20360290f, 0.16675028f, -0.14468473f, 
    0.05545017f, 0.08858664f, -0.01063235f, 0.00057943f, 0.02553533f, 0.05616271f, 0.06799865f, -0.05718968f, 
    0.00087216f, 0.00612697f, -0.06291054f, -0.07047156f, 0.13944739f, 0.18243483f, -0.00576423f, 0.01326125f, 
    0.06273747f, -0.04747345f, -0.06059331f, -0.03161607f, 0.06413609f, -0.07147644f, 0.29608285f, -0.10936397f, 
    -0.10488433f, -0.15238518f, 0.09838362f, 0.00615703f, 0.01829211f, 0.16227685f, -0.14778173f, 0.06731844f, 
    0.08630687f, -0.02523784f, -0.00399662f, -0.02974861f, 0.08905119f, 0.03876914f, 0.01320938f, -0.29960987f, 
    -0.16899623f, 0.01635721f, 0.09620569f, 0.14460512f, 0.16965468f, 0.09207653f, 0.33811054f, 0.19646117f, 
    0.19303486f, 0.19777966f, -0.07983112f, -0.02894592f, 0.07023423f, -0.08236030f, 0.26020840f, 0.00320571f, 
    0.07063262f, 0.08268959f, 0.04399347f, 0.08680999f, 0.23016256f, 0.05878437f, 0.09392353f, 0.09991060f, 
    0.10629024f, 0.14742297f, -0.02495813f, -0.15246634f, 0.02832669f, 0.22103487f, -0.05299982f, 0.09410199f, 
    0.08379326f, 0.05733180f, -0.25273541f, 0.07065516f, -0.03989512f, 0.03003306f, -0.10556328f, 0.04665873f, 
    -0.12277363f, -0.00990929f, -0.09997994f, 0.09773125f, -0.44553509f, -0.03896512f, 0.07004492f, 0.02366432f, 
    0.07528363f, -0.07919191f, -0.12847070f, -0.00714705f, 0.01615979f, -0.19353485f, -0.01615758f, 0.09683374f, 
    0.01294732f, -0.03017961f, 0.15620846f, 0.17650229f, 0.04824549f, 0.02347601f, 0.11872940f, -0.10481878f, 
    -0.02483300f, -0.09711803f, 0.03928116f, -0.04247503f, 0.09233692f, 0.06829681f, -0.08351375f, -0.11276780f, 
    0.14117144f, -0.06600016f, -0.12374631f, -0.22424461f, 0.06675369f, 0.00275206f, -0.03922510f, 0.25802609f, 
    0.21011740f, 0.13035122f, -0.01337222f, 0.21409141f, -0.10934431f, -0.27046707f, 0.19092466f, -0.11031169f, 
    -0.19691771f, -0.09725796f, 0.12082250f, 0.05264534f, 0.05905671f, 0.02648005f, -0.01652559f, 0.05771254f, 
    0.23756605f, 0.04108350f, 0.05646103f, -0.11115499f, 0.25729176f, -0.02298799f, -0.02748619f, -0.17949088f, 
    -0.08115092f, -0.08868635f, 0.16846810f, -0.08373825f, 0.07888665f, 0.25504035f, -0.04072834f, -0.11166430f, 
    -0.04309782f, -0.03303206f, 0.24179003f, 0.28263286f, 0.10275979f, 0.03619912f, 0.02477391f, 0.02528482f, 
    -0.00520305f, -0.06990377f, 0.01503124f, -0.10572442f, -0.03422923f, -0.03724559f, 0.07648149f, -0.04459522f, 
    0.03027070f, -0.00062640f, -0.01560674f, -0.03544711f, -0.03448696f, 0.26604673f, 0.03106338f, 0.23073623f, 
    0.02876825f, 0.09184922f, 0.05612634f, -0.13945331f, -0.28946659f, -0.05532417f, -0.00147550f, 0.17911457f, 
    0.03068159f, -0.07367252f, 0.03261921f, 0.08991494f, -0.02658625f, 0.12621205f, -0.16095288f, -0.01649949f, 
    0.03134536f, -0.05392303f, 0.12136522f, 0.04981705f, 0.01815131f, -0.01164281f, -0.08934087f, -0.22853461f, 
    -0.09727081f, -0.07418564f, -0.04728092f, -0.12702060f, 0.11731207f, 0.09981982f, 0.14872271f, 0.18543082f, 
    0.01183540f, 0.25832704f, 0.03210323f, -0.27709097f, 0.18297987f, 0.18218721f, 0.06265192f, -0.28275177f, 
    0.15915386f, -0.03907638f, -0.05453490f, -0.11441690f, 0.06489700f, 0.08876008f, -0.05842544f, -0.00316591f, 
    -0.17874590f, -0.14951995f, -0.22285128f, 0.00392832f, 0.17801894f, 0.03127629f, -0.08850108f, -0.03221208f, 
    0.04608605f, 0.04193546f, 0.05084709f, 0.00783669f, -0.17754187f, 0.08213253f, 0.02762650f, -0.05154951f, 
    0.14605284f, 0.04363692f, -0.07021867f, -0.03284298f, -0.12291071f, -0.08888314f, 0.04790194f, 0.15993053f, 
    0.06273428f, 0.09231214f, 0.05400375f, -0.12357544f, -0.24929915f, -0.34738469f, -0.17749149f, -0.19792014f, 
    0.07092859f, 0.12521338f, 0.14204551f, -0.04875124f, 0.05607927f, -0.10687391f, -0.10456698f, -0.07666417f, 
    -0.03968188f, 0.04848514f, -0.01427051f, 0.00032066f, 0.24304663f, -0.07202837f, 0.05862731f, 0.14373030f, 
    0.33103570f, 0.30446380f, 0.14401206f, -0.00281030f, -0.07006855f, 0.07926622f, 0.03422679f, 0.16039503f, 
    -0.05819691f, -0.10127083f, -0.03514525f, -0.05844958f, 0.02999386f, -0.13154738f, 0.07794892f, 0.04982732f, 
    -0.17805550f, -0.01842184f, -0.11896221f, -0.13157386f, 0.10029185f, -0.11615045f, -0.07859712f, -0.02203374f, 
    0.07790814f, -0.04378377f, -0.02446891f, 0.05038344f, 0.19047828f, -0.04790491f, 0.00066467f, -0.06079096f, 
    0.10711270f, 0.06475341f, 0.17909105f, -0.02904478f, 0.24713248f, 0.12604766f, -0.01710733f, 0.19108658f, 
    -0.18967268f, 0.04058336f, -0.10091612f, 0.15055577f, -0.14884004f, 0.03953769f, 0.04291051f, -0.22953257f, 
    -0.13358869f, -0.12200218f, -0.05765685f, 0.00127349f, 0.10697433f, -0.01836240f, 0.10037991f, 0.13866712f, 
    0.19474947f, -0.07732201f, -0.00087682f, -0.22182018f, 0.10971938f, 0.03207773f, 0.01134980f, 0.17981595f, 
    0.03192962f, -0.17738585f, 0.03706345f, -0.02123734f, 0.04161644f, 0.07938504f, 0.02414337f, -0.05997608f, 
    0.15135196f, 0.12922624f, 0.10077333f, -0.16143702f, -0.12117590f, -0.27053142f, -0.13299990f, -0.18634661f, 
    0.02849329f, 0.25472131f, 0.05789749f, -0.03205269f, -0.15005167f, -0.00715267f, -0.19016625f, 0.00163922f, 
    0.00168245f, -0.05182608f, -0.30192453f, -0.52413934f, -0.36490875f, 0.16092493f, 0.09927177f, 0.05701956f, 
    -0.04170496f, 0.04432642f, 0.01359534f, 0.18337122f, 0.29886693f, -0.06801948f, -0.24700767f, 0.05630344f, 
    -0.12002920f, 0.11047161f, -0.07577487f, 0.07904390f, -0.22264332f, -0.14846127f, 0.07798896f, 0.06928772f, 
    -0.02981012f, 0.15863748f, 0.05504095f, 0.11646728f, -0.19145176f, 0.26958132f, -0.11292002f, 0.08224811f, 
    0.01382404f, 0.36276665f, -0.06644794f, -0.03252754f, 0.06444427f, 0.05351038f, 0.05736896f, -0.12337846f, 
    -0.34021083f, 0.08480386f, -0.01528370f, 0.04456405f, 0.12465493f, 0.15000205f, 0.12134789f, -0.00236956f, 
    -0.00857871f, -0.23133674f, -0.13669860f, -0.17107868f, 0.07632496f, 0.05834053f, 0.09013806f, 0.09322961f, 
    -0.17186071f, 0.03239255f, -0.01580372f, -0.17599903f, 0.19352040f, 0.00041597f, 0.02116061f, -0.06473609f, 
    0.14269884f, 0.18634473f, -0.07902551f, -0.04876192f, -0.07530024f, -0.01790447f, -0.05132480f, -0.08453207f, 
    0.01654414f, -0.06309199f, -0.16830918f, -0.09556269f, 0.22990677f, -0.06921759f, 0.06995130f, 0.00629281f, 
    0.10816269f, 0.00087861f, 0.02998668f, -0.52461481f, -0.22783916f, -0.12762333f, 0.09111714f, -0.40354687f, 
    -0.07537529f, -0.14299864f, 0.02733674f, -0.00339344f, 0.06870057f, 0.18906888f, 0.05709070f, -0.27985278f, 
    0.00720233f, -0.03939088f, 0.07985129f, 0.02249454f, -0.06193217f, 0.23236491f, 0.16360112f, -0.21873213f, 
    -0.11532268f, 0.01689265f, -0.01799703f, -0.12838100f, 0.02727202f, 0.11112294f, -0.32497743f, -0.09173474f, 
    0.04009054f, 0.08204530f, -0.13791172f, -0.06992535f, 0.13140608f, -0.14156847f, 0.02719368f, 0.17154332f, 
    -0.02335790f, -0.01816052f, -0.21741171f, -0.06142551f, -0.04508393f, -0.00728837f, 0.01364159f, -0.03743613f, 
    0.46768558f, 0.13725317f, -0.10229145f, 0.01466476f, -0.16227318f, -0.00501487f, -0.02379511f, 0.00265121f, 
    -0.07477631f, -0.06946040f, -0.01260387f, -0.35978052f, 0.05711342f, -0.29845333f, 0.06778230f, 0.12533145f, 
    -0.14673375f, -0.00838856f, 0.21891594f, 0.05578475f, -0.18278126f, 0.06459258f, 0.02958140f, 0.03638472f, 
    0.00141706f, -0.02176236f, -0.10832161f, -0.39326006f, -0.39056647f, 0.31842846f, 0.10634310f, -0.08110724f, 
    -0.10373647f, -0.01362341f, -0.11613458f, 0.01227267f, 0.18818405f, 0.24407281f, -0.23763505f, -0.00435601f, 
    -0.13650768f, -0.01627941f, 0.07719302f, 0.17296229f, -0.01285722f, 0.19805230f, 0.06395336f, -0.24634884f, 
    -0.11960392f, 0.09188117f, 0.10435725f, 0.00582678f, 0.05019986f, -0.09074429f, 0.26772919f, 0.18896674f, 
    0.13043699f, 0.14843968f, -0.10894015f, 0.05077364f, -0.00255489f, -0.10824010f, -0.12681770f, -0.13560426f, 
    0.14746305f, 0.25701723f, -0.25392026f, 0.02764204f, -0.02772321f, -0.14234245f, 0.17828418f, -0.00862150f, 
    0.18490826f, 0.05007220f, 0.06262392f, -0.22150777f, -0.07768337f, -0.08955533f, 0.00847007f, 0.11950716f, 
    0.03539766f, 0.06934328f, -0.25281325f, -0.14551315f, -0.10764197f, -0.03295820f, -0.03226366f, -0.09949619f, 
    -0.15979883f, -0.10365587f, 0.10011043f, -0.16927604f, 0.12221681f, 0.17021118f, -0.03784157f, -0.08572369f, 
    -0.10020939f, -0.29774556f, -0.13746867f, -0.10127727f, 0.13126189f, -0.10721643f, 0.04220874f, -0.06516253f, 
    -0.16076425f, 0.07057486f, 0.10446845f, 0.08918619f, 0.07165434f, 0.17011030f, 0.07326484f, -0.05541990f, 
    -0.06530239f, -0.14476912f, -0.09748504f, 0.04713205f, 0.16060080f, 0.29010808f, 0.03858760f, -0.13331519f, 
    0.05037161f, 0.03140687f, 0.10807481f, 0.20056221f, 0.13446988f, 0.01179041f, -0.00131695f, 0.09767244f, 
    -0.10825591f, 0.02207626f, 0.18031286f, 0.10761780f, 0.10294960f, 0.12943691f, -0.12490720f, 0.09386986f, 
    -0.23257327f, -0.05007379f, 0.05152158f, -0.04984998f, -0.15256682f, 0.27799711f, 0.08063477f, -0.12296993f, 
    0.27666444f, -0.01438926f, 0.27908534f, 0.01600777f, -0.02328547f, 0.11808104f, 0.13513485f, 0.00470051f, 
    0.15757582f, 0.01548838f, 0.51214606f, 0.28465220f, 0.05140704f, 0.10169140f, 0.19537793f, -0.02757365f, 
    0.36626688f, 0.03183327f, -0.05803809f, -0.08942448f, -0.13677385f, -0.14348075f, -0.18952417f, -0.20293993f, 
    -0.09566476f, -0.01432489f, 0.01430002f, -0.27036896f, -0.16353171f, 0.61111110f, 0.06787542f, -0.02770045f, 
    -0.05618391f, 0.27916539f, 0.06037142f, -0.19256349f, 0.07696568f, -0.02715722f, -0.11904200f, 0.01871381f, 
    0.08482701f, -0.08001605f, 0.27248174f, 0.04990683f, 0.09597537f, 0.20380104f, 0.33579487f, 0.16200550f, 
    0.05797193f, -0.39375484f, 0.08397636f, 0.10058518f, -0.04135957f, 0.05797604f, 0.09251192f, 0.25677595f, 
    0.16212672f, 0.00519675f, -0.07820155f, -0.08837859f, 0.04472697f, 0.14508803f, 0.09520891f, 0.00613901f, 
    0.14740823f, -0.02107332f, 0.11215768f, 0.09959276f, -0.08303301f, 0.18075110f, 0.29857641f, 0.19155933f, 
    -0.02354702f, -0.10147643f, 0.06879833f, 0.04880701f, 0.11028599f, -0.14353189f, -0.00118018f, -0.05975910f, 
    -0.27846053f, 0.19804874f, 0.15627518f, 0.17053364f, 0.02674894f, 0.15199445f, 0.18169871f, 0.20769504f, 
    0.18454912f, 0.09410013f, 0.36631778f, -0.09360755f, -0.33877525f, 0.07599781f, 0.08954725f, 0.12012253f, 
    0.02063578f, 0.01548930f, -0.10478193f, 0.10659302f, -0.32389763f, -0.27907076f, 0.17752947f, 0.07100532f, 
    0.13399976f, -0.05830345f, 0.08029121f, 0.09928320f, 0.15805160f, -0.12876922f, 0.41242847f, 0.03114198f, 
    0.15799621f, 0.04359762f, 0.08326794f, 0.14523612f, 0.03928914f, -0.31620216f, -0.08688319f, 0.59232575f, 
    -0.13284257f, -0.19982180f, 0.11186530f, 0.30641425f, -0.17272411f, 0.27850100f, 0.02582487f, -0.15106724f, 
    -0.13931654f, 0.08374915f, -0.07237948f, -0.15369631f, -0.03959246f, -0.08741153f, 0.14494328f, -0.30789846f, 
    0.13069578f, -0.19091968f, -0.01010328f, 0.09971084f, 0.11442208f, 0.00367792f, 0.23775400f, 0.05474854f, 
    0.12602231f, 0.05161930f, 0.15963793f, 0.04994661f, -0.18352431f, 0.02823623f, 0.11238985f, -0.18911365f, 
    -0.03606066f, 0.62403655f, -0.39053276f, -0.06686198f, 0.39941511f, 0.11120827f, 0.08654351f, -0.09776998f, 
    -0.01020262f, 0.00673221f, -0.23478609f, 0.16841424f, 0.30835351f, -0.08527890f, -0.13875295f, 0.15977989f, 
    0.09102356f, -0.00929050f, 0.10590608f, -0.03124429f, -0.09574447f, 0.12876010f, 0.09424225f, -0.11387159f, 
    -0.14642459f, 0.03069722f, -0.07992163f, 0.19305219f, -0.16500013f, -0.01353985f, -0.15185165f, -0.08310600f, 
    -0.07521245f, -0.11235248f, -0.01657154f, 0.06343269f, 0.18876652f, -0.43304494f, -0.05524467f, 0.23596585f, 
    -0.17057915f, -0.21262668f, 0.14097542f, -0.09710527f, -0.04414145f, 0.00063787f, -0.21111807f, 0.00476817f, 
    -0.13112953f, -0.13436688f, -0.17842005f, -0.09984223f, -0.07035402f, 0.09522600f, 0.08112756f, 0.08325585f, 
    -0.20406273f, -0.16031985f, 0.06416830f, 0.02948100f, 0.07809012f, 0.12433566f, 0.13490605f, -0.06348006f, 
    0.07708608f, -0.13726145f, 0.18845673f, -0.04069724f, 0.00326716f, 0.05248450f, -0.22786832f, -0.14475565f, 
    0.10702104f, -0.27686447f, -0.10861041f, -0.09651820f, 0.01157159f, -0.14035690f, -0.06116161f, 0.02033609f, 
    -0.26030546f, -0.21933550f, -0.21543439f, -0.03960784f, 0.01761324f, 0.02320148f, -0.24399716f, 0.01238088f, 
    -0.09601779f, -0.08918791f, -0.24042138f, 0.07245377f, -0.07704539f, 0.03325342f, 0.16348703f, -0.02859537f, 
    -0.24476269f, 0.11278709f, 0.02613923f, 0.14061369f, 0.08696446f, -0.04031487f, -0.10846678f, 0.04242274f, 
    -0.13109069f, -0.04808661f, 0.09157012f, -0.09300634f, 0.07958754f, -0.12983648f, 0.04462884f, -0.03228678f, 
    0.01091205f, 0.13924281f, -0.14858370f, -0.06437672f, 0.21950221f, 0.00568795f, 0.05660207f, 0.02061459f, 
    0.00209877f, 0.08025802f, 0.01522050f, 0.06063795f, 0.09286472f, -0.05186623f, 0.13029782f, 0.25985080f, 
    0.11676534f, -0.02988235f, 0.09142994f, -0.11900236f, -0.13239931f, 0.09861543f, 0.07461952f, 0.10978964f, 
    0.06597495f, 0.21700075f, -0.05927260f, -0.00510660f, -0.11354673f, 0.05769944f, 0.08822272f, 0.00388441f, 
    0.01852502f, -0.08796773f, 0.25863782f, 0.30489838f, 0.05142144f, -0.08374943f, -0.00818045f, -0.12992802f, 
    -0.22389783f, 0.19176088f, -0.30915070f, -0.10550486f, 0.07934400f, 0.04649283f, -0.27113193f, -0.26395705f, 
    0.04616074f, -0.07849665f, -0.12651922f, 0.40998501f, 0.02442354f, -0.04504791f, 0.05471274f, -0.12538075f, 
    -0.20484534f, -0.10919919f, -0.17944793f, -0.01570482f, -0.11950900f, -0.10324001f, 0.13322212f, 0.05167840f, 
    0.14000753f, -0.12623997f, 0.18409784f, 0.11606745f, 0.10609721f, -0.07802959f, -0.20837620f, -0.22362712f, 
    -0.06006104f, -0.02713935f, -0.19344941f, 0.16960691f, -0.20282228f, -0.08343347f, 0.13167502f, -0.08466588f, 
    -0.16000189f, -0.01763699f, -0.06890310f, -0.01645783f, -0.02920412f, -0.10120017f, 0.19933827f, 0.14591035f, 
    0.19992971f, -0.21762125f, -0.13283873f, -0.14305489f, 0.03639771f, 0.10823988f, -0.04428707f, 0.13934964f, 
    -0.16628049f, 0.08898172f, 0.04249592f, 0.06423880f, -0.13146016f, 0.15624113f, 0.00729935f, -0.16213943f, 
    0.12725374f, -0.13491862f, 0.22956276f, -0.03106698f, -0.05986322f, -0.07371856f, 0.05164823f, 0.13833651f, 
    -0.32544628f, -0.19949715f, 0.26083699f, -0.12337362f, 0.01180739f, -0.06705844f, -0.16897944f, -0.18879563f, 
    0.03668518f, 0.14660496f, 0.07405229f, -0.05071842f, -0.03461473f, -0.05589687f, -0.03256255f, 0.07672868f, 
    -0.38341805f, 0.05290577f, 0.13858894f, -0.04994827f, 0.27427378f, 0.12512891f, 0.05953278f, 0.08681584f, 
    -0.07461476f, 0.06125800f, -0.02503310f, -0.21617439f, -0.38449746f, 0.18361464f, 0.02028052f, -0.11294694f, 
    -0.02146851f, 0.05876967f, -0.01700798f, 0.00937176f, -0.13402894f, 0.02462364f, -0.31623670f, 0.02609994f, 
    -0.02486029f, 0.00930006f, -0.08441752f, -0.18264110f, 0.13631642f, 0.04041403f, 0.12339570f, -0.04649117f, 
    -0.03770425f, 0.08476260f, -0.00867267f, -0.12142789f, 0.03088053f, 0.01253686f, 0.02847026f, 0.15126260f, 
    0.45418778f, 0.11560971f, -0.28816468f, -0.08442368f, -0.16199228f, -0.13768950f, -0.01975867f, -0.06458521f, 
    0.23561771f, 0.14293532f, 0.12568933f, -0.05997108f, 0.15885223f, 0.07661600f, -0.12824802f, 0.07136282f, 
    -0.10894173f, 0.12354613f, 0.04557502f, 0.01819535f, -0.02818496f, -0.05054836f, -0.08356766f, 0.03027025f, 
    0.04729054f, -0.16820313f, -0.08320174f, -0.19752577f, 0.13214000f, 0.01858527f, 0.11564271f, -0.10844602f, 
    -0.00381606f, 0.14832035f, 0.06997504f, 0.18973932f, 0.10458557f, -0.02715292f, 0.02010126f, 0.09965235f, 
    -0.01713474f, -0.24281363f, -0.04532297f, 0.06374142f, 0.20652366f, 0.15375838f, 0.21008541f, 0.15407071f, 
    0.08264423f, -0.04907214f, -0.13470605f, 0.05138527f, -0.04710943f, 0.03217319f, -0.16885464f, -0.07194383f, 
    0.06538435f, 0.30403507f, -0.28038117f, -0.07256364f, -0.05378788f, -0.16937524f, -0.04894872f, -0.25995609f, 
    0.27120382f, 0.33616906f, 0.07229993f, 0.13364185f, -0.11649413f, 0.08172101f, 0.02220334f, 0.13300727f, 
    -0.61487579f, 0.04522772f, -0.42127925f, 0.02731052f, -0.17896928f, -0.32664645f, 0.08355668f, 0.02723230f, 
    -0.24132329f, -0.28675225f, 0.06144234f, 0.05840869f, 0.05668331f, 0.11070356f, 0.09723863f, 0.07389303f, 
    -0.08979855f, 0.12247650f, -0.05083005f, 0.08071204f, 0.06909788f, -0.02623335f, 0.05727300f, 0.21403205f, 
    0.14409555f, 0.05284468f, -0.00754751f, 0.19292527f, -0.03445322f, 0.02192391f, 0.10710455f, -0.02490684f, 
    -0.01958160f, -0.03747525f, -0.01519561f, 0.12448880f, -0.42689165f, -0.10670409f, 0.31395337f, -0.03382356f, 
    0.00500342f, -0.12240929f, -0.12934110f, 0.13403979f, 0.10514201f, 0.38499627f, -0.00348773f, -0.32021528f, 
    0.06092323f, 0.02407759f, 0.19320132f, 0.18881400f, 0.20941044f, -0.14701453f, 0.01507606f, 0.08864550f, 
    -0.31344968f, 0.02646189f, 0.03492621f, -0.09891544f, -0.12936451f, -0.03678213f, -0.13194315f, -0.43276092f, 
    -0.19323909f, -0.06856817f, 0.06237577f, 0.11815879f, -0.04463062f, 0.00815175f, 0.01459973f, -0.20880938f, 
    -0.31348747f, 0.03367839f, -0.08406174f, -0.25181681f, -0.19242772f, -0.10350143f, 0.08203845f, -0.06379697f, 
    -0.03083033f, -0.45428151f, -0.60816801f, -0.16406576f, 0.09225456f, -0.06486524f, -0.31493348f, -0.00802874f, 
    -0.06108521f, -0.02112866f, 0.27128142f, -0.01966260f, 0.04613009f, -0.06150004f, -0.02722172f, -0.04760517f, 
    0.12418593f, 0.08403870f, 0.15679367f, -0.38447273f, -0.14259923f, 0.11132348f, -0.13013248f, -0.02480482f, 
    -0.18403421f, 0.02848943f, 0.13814449f, -0.01960050f, 0.40431502f, -0.04789896f, 0.14854130f, 0.00868585f, 
    0.22272889f, -0.08797313f, -0.01758622f, 0.03139579f, 0.02147954f, 0.06754292f, 0.20409077f, 0.51473665f, 
    -0.28833535f, -0.13243693f, 0.09869773f, 0.03560583f, 0.12483504f, -0.12154883f, -0.32793632f, 0.34999746f, 
    0.19378519f, -0.10620610f, -0.02445224f, -0.04036516f, -0.05338717f, 0.08056970f, 0.03084102f, -0.08313955f, 
    -0.33261785f, 0.11152802f, 0.28622288f, 0.00033030f, 0.00672493f, -0.12605663f, 0.04277490f, -0.13124923f, 
    0.21566556f, -0.08713188f, 0.16271192f, 0.05433442f, 0.09514589f, -0.07254866f, 0.13458903f, 0.21294855f, 
    0.01274377f, -0.19190344f, -0.10649218f, -0.00678058f, 0.05799244f, 0.14511500f, 0.02531287f, 0.04197647f, 
    0.03725389f, 0.01347720f, -0.25707424f, 0.21167547f, -0.13162898f, -0.11849220f, 0.19128403f, -0.16998951f, 
    -0.03738850f, 0.12916076f, -0.09214406f, 0.12901606f, 0.14331028f, -0.08367436f, -0.08206473f, 0.14112301f, 
    0.12456635f, 0.18422268f, 0.09830435f, 0.16183057f, -0.30812472f, -0.19220039f, -0.16558498f, -0.09031985f, 
    0.01311460f, -0.00028658f, 0.05179344f, 0.15199275f, 0.09914300f, -0.20444967f, -0.06901728f, 0.31951824f, 
    -0.04794122f, -0.13863808f, -0.17826492f, -0.01045690f, 0.18186431f, 0.12692790f, 0.06630392f, 0.12471665f, 
    0.21180336f, 0.00949517f, -0.02047488f, 0.02856128f, 0.00760822f, 0.06832761f, 0.24587409f, 0.01109035f, 
    0.08996252f, 0.12860076f, 0.05135863f, 0.12708582f, 0.06381848f, -0.16175729f, 0.03299332f, 0.35477564f, 
    -0.56249774f, -0.08211638f, 0.34742767f, 0.06376063f, -0.11159331f, -0.27382517f, -0.15871817f, 0.13936634f, 
    -0.18325980f, 0.00194030f, -0.17633614f, -0.10561205f, 0.03819036f, -0.38275525f, -0.07969174f, 0.17805518f, 
    0.04743599f, 0.18796906f, -0.24639183f, -0.00525227f, 0.17790297f, -0.00616756f, 0.16094542f, -0.14058936f, 
    -0.09577966f, 0.10927197f, 0.30743515f, -0.00947436f, 0.02114573f, 0.22044112f, -0.16310421f, 0.15685859f, 
    -0.24970807f, -0.02628016f, 0.09033223f, 0.12006328f, 0.13169819f, 0.04254343f, -0.01799367f, 0.04131193f, 
    0.15239821f, 0.14858198f, -0.12040477f, 0.04243096f, 0.01293308f, -0.50183356f, 0.02644560f, 0.13147339f, 
    -0.06633301f, 0.12408359f, -0.16311233f, 0.04796795f, 0.13900043f, 0.15003429f, -0.02844746f, 0.09246919f, 
    0.03004411f, 0.23251867f, -0.04684158f, -0.00166026f, -0.00937568f, 0.00007813f, 0.23161060f, 0.22368111f, 
    -0.00101708f, -0.11001109f, 0.13958505f, 0.05749186f, -0.06470747f, 0.11498254f, -0.00606557f, -0.09489995f, 
    -0.22537306f, 0.07859449f, 0.17310303f, -0.07477003f, -0.11665311f, -0.18144678f, 0.07228742f, -0.02129976f, 
    0.03825641f, 0.16649380f, -0.20553659f, 0.08196798f, 0.05981785f, -0.02155107f, 0.03914901f, -0.14105637f, 
    -0.03862427f, 0.05649595f, -0.11362011f, 0.13012843f, -0.07369474f, 0.00120870f, -0.01466255f, 0.10345561f, 
    0.05254709f, 0.02540371f, 0.00912991f, 0.01050293f, 0.14941372f, 0.11896239f, 0.01698837f, 0.05788718f, 
    -0.13162328f, 0.03744848f, -0.16948077f, 0.12497468f, 0.11371555f, 0.03159390f, 0.18945992f, -0.09596618f, 
    -0.06613290f, 0.01323700f, 0.16879462f, 0.06255154f, 0.04650646f, -0.35921687f, -0.02370928f, 0.10489930f, 
    0.11563033f, -0.02637811f, 0.15093593f, 0.06233455f, -0.00126957f, 0.06559122f, -0.33019966f, -0.01568063f, 
    0.17419575f, 0.02382395f, -0.00664984f, 0.04217962f, 0.14952780f, -0.03387656f, 0.07383468f, -0.24639776f, 
    -0.05577528f, -0.10576537f, 0.04702323f, 0.13196306f, 0.07163923f, 0.06958126f, -0.02244515f, -0.09060013f, 
    -0.12810655f, 0.08082314f, 0.12881231f, 0.05038819f, -0.15637861f, 0.00368903f, 0.13848463f, 0.05941681f, 
    0.01554306f, -0.05435449f, 0.12312372f, 0.37583551f, -0.08986077f, 0.01528917f, -0.22197793f, -0.10975447f, 
    0.10392009f, -0.05876050f, 0.17151682f, 0.19913639f, 0.01507670f, -0.08941223f, -0.11382996f, -0.08008379f, 
    0.04367995f, 0.13685492f, 0.05574298f, -0.33242992f, -0.35539332f, 0.23941331f, 0.02888667f, 0.00390767f, 
    0.05883941f, 0.08153760f, -0.02631421f, 0.00701589f, 0.23604321f, 0.36587042f, 0.07157601f, 0.13030426f, 
    -0.14926732f, -0.04360165f, 0.02118587f, 0.12164000f, 0.05529699f, -0.04970430f, 0.42976144f, 0.25346106f, 
    -0.21785960f, -0.26176280f, 0.11000694f, 0.02879955f, -0.00989412f, 0.01196454f, 0.08973490f, -0.29797837f, 
    -0.02147526f, 0.06655601f, 0.11155612f, 0.07826077f, 0.04540321f, -0.01206381f, -0.06711007f, -0.07839411f, 
    0.10832453f, -0.30061382f, 0.06873418f, 0.12056238f, 0.25129193f, -0.04682994f, 0.15824655f, -0.04450833f, 
    0.07676342f, 0.13110735f, -0.04261223f, 0.01030583f, -0.01720164f, -0.17082004f, 0.03157746f, 0.08020744f, 
    -0.02861147f, 0.21515305f, 0.05963362f, 0.12098600f, 0.07472533f, -0.05234133f, -0.05491579f, -0.02968257f, 
    -0.05126296f, 0.04557869f, -0.36340973f, 0.32273117f, -0.36440665f, -0.04363687f, 0.01546486f, 0.05813439f, 
    0.01229384f, -0.07439324f, 0.00312609f, -0.26898149f, 0.07949620f, 0.03488433f, 0.01849748f, -0.19181691f, 
    -0.16981934f, -0.12568119f, 0.13490906f, 0.04333582f, -0.12062346f, -0.31892979f, 0.08008419f, -0.03753978f, 
    0.01735801f, 0.07400516f, -0.00816312f, -0.02505735f, 0.03826370f, -0.22467250f, 0.12600748f, 0.23234798f, 
    -0.01038270f, 0.07773432f, -0.11880415f, 0.00088459f, 0.07154673f, -0.19856969f, -0.13608727f, 0.03270134f, 
    0.22450516f, -0.07769962f, -0.12290949f, -0.05876638f, -0.02372985f, 0.02222283f, -0.08829465f, -0.10251039f, 
    -0.10620437f, 0.17215896f, 0.03677276f, -0.18668632f, 0.08537248f, -0.04449095f, 0.05666538f, 0.05649162f, 
    0.00075114f, -0.05449392f, 0.28455195f, -0.06603560f, 0.09491727f, -0.33105084f, -0.03756332f, 0.13521105f, 
    0.08313762f, 0.20113941f, -0.48835906f, -0.52393883f, 0.09313985f, -0.11492196f, 0.09145885f, 0.04846123f, 
    -0.14654562f, 0.06550974f, 0.04138395f, -0.18099150f, -0.09628253f, 0.10320438f, 0.12659740f, -0.03008242f, 
    0.08941568f, 0.02537183f, 0.03005915f, -0.32758114f, -0.07022308f, 0.32904190f, 0.00172687f, -0.06133793f, 
    -0.07537443f, 0.05492807f, -0.01478900f, -0.02868396f, -0.05798368f, -0.10823181f, 0.09563869f, 0.05099083f, 
    -0.04096819f, -0.05089871f, 0.08559275f, -0.07993618f, -0.08715740f, -0.10716379f, -0.30209723f, -0.24136484f, 
    0.09062158f, 0.01933087f, -0.10404179f, -0.00827483f, -0.09561075f, 0.07920557f, -0.01889487f, -0.10027480f, 
    0.18145573f, -0.05020528f, -0.03553329f, -0.41625601f, 0.27977470f, -0.09054401f, 0.05151704f, 0.01098926f, 
    0.21064511f, -0.01669728f, -0.04940081f, 0.05487567f, -0.04634351f, -0.09114867f, -0.02268304f, -0.02231504f, 
    0.12668458f, -0.03856752f, 0.00180028f, 0.09798654f, 0.11795347f, 0.07263619f, -0.07399993f, 0.15000758f, 
    -0.27206552f, -0.16571763f, 0.19824518f, -0.03727052f, -0.12774302f, -0.16476849f, 0.12210223f, 0.06061428f, 
    0.34509647f, 0.08127726f, 0.21474211f, 0.00132415f, 0.14054804f, 0.00597478f, 0.03040457f, 0.10941666f, 
    -0.07606729f, 0.12628710f, 0.02698520f, 0.10504318f, 0.07288566f, 0.02703155f, -0.09666777f, -0.01499413f, 
    -0.05284505f, -0.00891726f, 0.09071451f, 0.02950391f, 0.22657607f, 0.04964055f, 0.21104565f, 0.04731524f, 
    -0.02458863f, -0.03761190f, -0.10058041f, -0.12644501f, -0.03823257f, 0.08657341f, 0.14011167f, -0.02627300f, 
    0.10965770f, 0.11010879f, 0.02182076f, -0.02260168f, -0.00472600f, -0.06507269f, 0.09877499f, -0.00531392f, 
    0.04674748f, -0.04492512f, 0.20880951f, 0.10449396f, 0.02395502f, 0.05431108f, -0.19459268f, -0.05655139f, 
    -0.00196408f, -0.10619247f, 0.16862947f, 0.02697994f, 0.20721395f, 0.01352702f, -0.14497973f, -0.06960923f, 
    0.21553595f, 0.12143279f, 0.11167664f, -0.09894082f, 0.08472407f, 0.10552858f, -0.01022984f, 0.10152046f, 
    0.02436738f, 0.23789246f, 0.20380832f, 0.16420048f, -0.04866801f, -0.07160529f, 0.03400292f, 0.16080900f, 
    -0.00724480f, 0.29423991f, 0.15183072f, 0.24424377f, 0.01015019f, -0.07526044f, -0.10325303f, -0.21175927f, 
    -0.09744817f, -0.18683565f, 0.04188233f, 0.15856764f, 0.18277010f, 0.21376313f, -0.05150621f, -0.14688411f, 
    0.02757352f, -0.10157742f, 0.14757159f, -0.12408103f, -0.02491632f, 0.26397017f, 0.02912642f, -0.08612682f, 
    -0.05370692f, -0.11774366f, -0.00653750f, -0.02853153f, 0.10389595f, 0.15253524f, -0.20745495f, 0.10477524f, 
    0.02423538f, 0.13185510f, -0.08225399f, -0.04291955f, 0.05867529f, 0.11745005f, -0.36463034f, -0.22457118f, 
    0.01787931f, 0.03483025f, -0.06082010f, 0.05506344f, -0.09626426f, 0.02037061f, -0.04939118f, -0.02540433f, 
    -0.17824300f, -0.16583785f, 0.09342433f, -0.06673477f, 0.12245291f, 0.02431324f, -0.17567065f, -0.13246824f, 
    0.24944983f, 0.15675171f, 0.02961793f, 0.04553912f, -0.00875796f, 0.14530462f, -0.12087549f, -0.00118259f, 
    0.06473142f, 0.10673106f, 0.16694488f, 0.02944851f, -0.11329748f, 0.12629670f, 0.12350449f, 0.07276098f, 
    0.25465113f, 0.24149080f, 0.11312855f, -0.05879318f, -0.06060547f, 0.02343768f, -0.09184586f, 0.10647198f, 
    0.09207616f, 0.04216259f, 0.06681869f, -0.00275564f, -0.02886998f, 0.10694385f, -0.04219932f, 0.07232688f, 
    0.01219872f, 0.10459261f, 0.09917258f, -0.03147092f, 0.23033078f, 0.12651870f, 0.15877470f, -0.11569026f, 
    0.05049201f, 0.14626732f, 0.02665577f, 0.11594039f, 0.00102546f, -0.08387055f, 0.02952821f, 0.08187059f, 
    0.11535209f, 0.01227851f, -0.00852390f, 0.03383070f, -0.03070141f, 0.24191999f, 0.16991067f, 0.06949743f, 
    -0.03856241f, -0.08584820f, 0.11972932f, -0.13446358f, -0.01226048f, -0.01745764f, 0.04506031f, -0.05998446f, 
    -0.24176814f, 0.01902368f, 0.14381966f, 0.12543325f, 0.07190613f, 0.15080941f, -0.08745697f, -0.15960145f, 
    0.14167206f, -0.11485880f, 0.05169771f, 0.21214151f, 0.16583712f, 0.07699942f, 0.08784840f, 0.02775603f, 
    -0.12058790f, 0.15839663f, -0.11994538f, 0.06645351f, 0.00986513f, 0.05942472f, -0.18270890f, 0.11343933f, 
    0.14851418f, 0.10981123f, -0.12967926f, -0.00256261f, 0.04963095f, 0.04855260f, 0.14673446f, 0.05933876f, 
    0.06363787f, -0.02807603f, 0.14460392f, 0.24299955f, 0.10073842f, -0.11881217f, 0.11655658f, 0.02861010f, 
    0.08768167f, -0.05354060f, -0.06182677f, 0.07330060f, -0.03155515f, 0.02193399f, 0.06091243f, 0.07087025f, 
    -0.04351970f, 0.06905116f, 0.08274364f, -0.02690936f, -0.00628259f, -0.21072009f, -0.10533541f, -0.09740829f, 
    0.07963070f, 0.14568560f, 0.07446457f, 0.02855520f, 0.05017572f, 0.09399629f, 0.01324997f, -0.05217892f, 
    -0.06422810f, -0.02056779f, 0.10495664f, 0.11835553f, 0.09027907f, 0.03426671f, -0.07318580f, 0.04609719f, 
    0.20288239f, -0.01780546f, 0.02543173f, 0.07509785f, -0.05825434f, -0.15298393f, 0.03366379f, 0.08885685f, 
    -0.15101199f, -0.32551253f, -0.31853783f, -0.07231934f, -0.06772710f, -0.01894948f, -0.07911192f, -0.14154477f, 
    0.06401309f, 0.40412611f, -0.07115778f, 0.04825455f, -0.07006885f, 0.07236016f, 0.10190441f, -0.03808065f, 
    0.06556359f, -0.02568178f, 0.15463734f, 0.00092932f, -0.01561297f, -0.02013207f, 0.01698663f, 0.07984785f, 
    -0.03262299f, 0.08758853f, -0.02691285f, -0.03831056f, 0.12130627f, -0.02484537f, -0.17486690f, -0.12127732f, 
    -0.27129859f, 0.07966200f, 0.04405199f, -0.00836111f, 0.46254927f, -0.24067686f, -0.59218740f, -0.01620152f, 
    0.14163229f, -0.13087741f, 0.06562822f, -0.01734760f, -0.03513199f, -0.03923218f, -0.09809962f, -0.16302468f, 
    -0.08264145f, 0.02785722f, 0.04360668f, -0.03879848f, 0.06832191f, 0.11284624f, -0.06443330f, -0.36453736f, 
    0.26128972f, -0.18310040f, 0.04216550f, -0.09929397f, 0.08232772f, -0.02270967f, -0.01197709f, 0.09851082f, 
    -0.03215803f, -0.10621432f, -0.16057594f, 0.09706765f, 0.10550852f, 0.05760965f, 0.08690529f, -0.19399473f, 
    0.21749866f, -0.19841851f, -0.18463355f, 0.03878663f, -0.04352895f, -0.03445838f, 0.00779779f, 0.06842577f, 
    0.10169832f, -0.10229173f, -0.07354157f, 0.19266255f, -0.13540214f, 0.01335252f, -0.18811631f, 0.04161038f, 
    0.04064533f, 0.02663672f, 0.08098499f, 0.00721660f, 0.04588902f, 0.14367750f, 0.10535745f, -0.00820805f, 
    -0.04585559f, -0.09188867f, 0.04294561f, -0.34050202f, 0.00266613f, 0.25951731f, -0.10801751f, -0.13729988f, 
    -0.01911722f, 0.01239843f, 0.16355443f, 0.15678509f, 0.13733493f, 0.23685054f, 0.11617801f, 0.00733190f, 
    0.00014225f, -0.05699205f, 0.03521968f, 0.16598700f, -0.04792552f, 0.51297706f, -0.38314903f, 0.12799396f, 
    0.07125833f, -0.03966063f, 0.05340265f, -0.10555429f, -0.00958071f, -0.05431859f, 0.14361337f, -0.43125641f, 
    -0.28787419f, 0.14190587f, 0.22021008f, 0.16174799f, 0.17978983f, -0.14877725f, 0.05675764f, 0.53775060f, 
    -0.07751536f, 0.07106391f, -0.02698937f, 0.21275321f, -0.03695514f, 0.02449867f, 0.13851279f, -0.13878077f, 
    0.10314925f, 0.02985541f, 0.01595257f, 0.02672043f, 0.05951404f, 0.03908903f, 0.05336455f, 0.06446581f, 
    0.04112309f, -0.40969250f, -0.44885504f, 0.11091562f, 0.06296690f, 0.03640676f, 0.20608820f, -0.01517829f, 
    -0.04177461f, -0.03621364f, 0.35104606f, 0.31419143f, -0.12775175f, -0.04654198f, 0.10522670f, 0.01831784f, 
    -0.06699915f, 0.08406215f, -0.02465115f, 0.11398679f, -0.03751558f, -0.10361067f, 0.03255761f, 0.07769721f, 
    -0.08797592f, -0.16655441f, 0.10810406f, 0.04781066f, -0.12831040f, -0.27647835f, -0.22881669f, -0.08801943f, 
    0.04018071f, -0.01665977f, -0.05087818f, 0.17924090f, 0.00175563f, -0.07248598f, -0.23100585f, -0.05569272f, 
    -0.08868470f, 0.05062335f, -0.04562083f, 0.05785852f, 0.00456424f, 0.02443096f, 0.03026270f, 0.01510705f, 
    0.22858366f, -0.00547884f, 0.06960133f, -0.01751677f, -0.00661588f, -0.10151217f, 0.09291369f, 0.02038372f, 
    -0.09164109f, 0.11835892f, -0.22642326f, -0.14728913f, 0.17945281f, -0.01611100f, -0.00472713f, 0.17638560f, 
    -0.15839046f, -0.42570251f, 0.23802507f, -0.05098226f, 0.06179694f, 0.01072187f, 0.05464936f, -0.02482430f, 
    0.00339454f, -0.07982761f, 0.18536800f, -0.21376623f, -0.05328256f, -0.08564661f, 0.24529400f, 0.23821847f, 
    -0.12614709f, 0.01131307f, 0.50045466f, -0.21316412f, -0.55790961f, 0.00334184f, -0.01930850f, 0.01913842f, 
    -0.07264907f, 0.05362217f, 0.04548378f, -0.09643709f, -0.12193302f, 0.28407627f, 0.01607909f, 0.15157692f, 
    -0.04211748f, -0.06314786f, -0.03670542f, 0.06325462f, -0.05740514f, -0.04819917f, -0.02075203f, -0.35958162f, 
    -0.15478343f, -0.15718275f, 0.06251129f, -0.01839020f, 0.05548441f, 0.36118522f, -0.45344612f, -0.65527755f, 
    0.05727265f, -0.10455255f, 0.14325649f, -0.02958271f, -0.07313214f, 0.10857206f, 0.05004802f, -0.03236272f, 
    0.10304398f, -0.20517069f, -0.08746762f, -0.09888109f, -0.02773556f, -0.02846815f, -0.04460849f, 0.24972691f, 
    -0.10845603f, 0.00450261f, 0.00300830f, -0.09973989f, -0.12526636f, 0.03142951f, 0.06652431f, 0.03585516f, 
    0.05920167f, 0.00799521f, -0.02523736f, 0.00386667f, 0.02405469f, -0.05094697f, -0.05669967f, -0.04673759f, 
    -0.00911264f, -0.05444369f, -0.03352078f, 0.04859083f, -0.01559145f, -0.04290371f, 0.02801748f, 0.00589660f, 
    -0.01413712f, -0.04482168f, -0.02713456f, 0.01680409f, 0.04034580f, 0.03056914f, -0.05726310f, 0.00867958f, 
    -0.04510722f, -0.04935656f, -0.03918999f, -0.03646463f, -0.00342860f, -0.04947986f, 0.01960026f, -0.01952836f, 
    0.02237918f, 0.02634816f, -0.03497341f, -0.04727881f, 0.06011144f, -0.00303175f, -0.00643885f, 0.04668957f, 
    0.02863609f, -0.03325307f, 0.04200874f, 0.03572656f, -0.05390371f, -0.01465610f, 0.01062690f, -0.02412855f, 
    -0.02682021f, -0.02313652f, 0.01224288f, 0.02360579f, 0.04056961f, 0.00490451f, 0.03018546f, 0.02429987f, 
    -0.05812653f, -0.06612721f, -0.00525092f, 0.00112535f, -0.06210368f, -0.00364494f, 0.04352202f, -0.06067865f, 
    -0.05493348f, -0.00334528f, -0.03773826f, -0.04918855f, -0.00479064f, -0.01450642f, -0.05188419f, 0.02215692f, 
    0.04192488f, -0.01043945f, 0.02453841f, -0.04539261f, 0.02888512f, 0.03507309f, 0.03512106f, 0.01389738f, 
    0.04172158f, 0.03816888f, 0.05155276f, 0.03036590f, 0.01502284f, -0.01296810f, -0.00845076f, -0.04065687f, 
    -0.03686984f, 0.01234393f, -0.00704444f, -0.05618658f, 0.03780526f, 0.03848022f, 0.04975155f, -0.05850228f, 
    0.00761705f, -0.04216739f, -0.05184163f, -0.03257328f, -0.02574374f, 0.03782678f, 0.00944062f, -0.06521462f, 
    -0.03548289f, -0.05424643f, 0.02996243f, -0.04251497f, 0.02649828f, -0.01654481f, -0.03780288f, 0.03696927f, 
    -0.04997385f, 0.04271528f, -0.04450270f, 0.01722863f, -0.06263821f, -0.02814763f, -0.02592446f, -0.00579741f, 
    -0.02940028f, -0.00311038f, -0.01403130f, -0.06085927f, -0.01027320f, -0.02440550f, 0.03908360f, 0.00630105f, 
    -0.02782571f, 0.02106440f, -0.03119106f, -0.00451319f, -0.05128749f, -0.04111441f, 0.04014320f, -0.05423434f, 
    -0.00708615f, -0.00410103f, 0.03283980f, -0.01542055f, 0.04489561f, -0.04692117f, 0.04384473f, -0.00292542f, 
    0.04646244f, -0.04107519f, 0.01582110f, 0.04254270f, -0.04326998f, 0.02275954f, -0.06306217f, 0.03381719f, 
    0.00138055f, -0.03129441f, 0.01533736f, 0.04162863f, -0.05069498f, -0.01029280f, 0.03988547f, 0.04466652f, 
    0.05733457f, -0.05420944f, 0.02379030f, 0.01766300f, -0.03781646f, -0.03865643f, -0.06643634f, 0.04667999f, 
    -0.04201005f, -0.00339635f, 0.01415674f, 0.02475528f, -0.00627603f, -0.01377368f, 0.00578229f, -0.05255793f, 
    -0.01717754f, 0.01165956f, 0.03933461f, -0.05457613f, 0.02123483f, 0.05080087f, -0.02928507f, -0.00593769f, 
    -0.04683375f, -0.03279907f, -0.05407193f, -0.00452186f, -0.04275145f, -0.01431128f, -0.00690247f, -0.04197043f, 
    -0.00114050f, -0.04866915f, 0.04693208f, -0.03338511f, -0.03201877f, 0.01842479f, 0.03844645f, 0.00381565f, 
    0.04470897f, -0.06129477f, -0.00572876f, -0.02192304f, -0.06426021f, -0.02181935f, 0.03067427f, 0.04614436f, 
    -0.05354307f, 0.02961940f, 0.01069588f, -0.03627057f, -0.05667689f, 0.01814198f, -0.03211079f, -0.06160891f, 
    -0.05054461f, 0.00118721f, -0.05444227f, 0.01638283f, 0.01438697f, -0.04534247f, -0.05908592f, 0.00474816f, 
    -0.00842049f, -0.00023315f, 0.03708320f, -0.05896989f, -0.00168403f, 0.05769985f, 0.02700493f, -0.05368040f, 
    -0.00713847f, 0.03428989f, 0.00056706f, -0.00456373f, -0.04474092f, 0.02503130f, 0.05197890f, -0.04237780f, 
    -0.05584333f, 0.00019045f, -0.02513015f, 0.02693549f, 0.04646619f, -0.04552196f, -0.00577223f, 0.02702222f, 
    -0.00020225f, -0.05772829f, -0.00964288f, -0.05230636f, -0.03248963f, 0.00177078f, 0.02209711f, -0.04001198f, 
    -0.05836406f, 0.03793424f, 0.03535343f, -0.00363499f, 0.00785607f, -0.05708969f, 0.03040561f, -0.01203721f, 
    -0.00009676f, -0.05893468f, 0.05072247f, -0.03770702f, 0.05616951f, 0.00380236f, 0.01585258f, 0.03925018f, 
    0.02568920f, 0.03110736f, 0.04353835f, 0.04246723f, 0.00224086f, -0.01640463f, -0.01717685f, 0.03244231f, 
    -0.02042909f, 0.00194557f, 0.01131366f, -0.01996333f, -0.03066884f, -0.04907754f, -0.06333485f, -0.00479142f, 
    -0.00600420f, 0.04343264f, -0.05636512f, 0.00026739f, 0.02867154f, 0.03106388f, -0.03755156f, 0.04552037f, 
    0.00836771f, -0.02399760f, 0.02105564f, 0.00735416f, -0.01401075f, 0.04481394f, 0.01400494f, -0.03721668f, 
    0.01420389f, 0.02195838f, -0.04831327f, -0.03970521f, 0.01482131f, 0.04414108f, 0.00930763f, -0.02872854f, 
    0.03655230f, -0.02164527f, -0.00109580f, 0.01841514f, -0.02957619f, -0.00839123f, 0.02643503f, 0.02945888f, 
    -0.01429512f, 0.04979345f, -0.05303742f, 0.04771518f, -0.03157061f, -0.06452493f, 0.04084322f, 0.04591529f, 
    0.03992810f, -0.02097960f, -0.02834215f, -0.05434362f, -0.01551078f, 0.04117044f, -0.06325116f, -0.01990130f, 
    -0.03390450f, -0.02983803f, 0.00112180f, -0.01874422f, -0.05101059f, 0.02038923f, 0.00626113f, -0.03229372f, 
    0.02920718f, -0.03474963f, -0.05127050f, -0.04238944f, -0.02909410f, 0.01075277f, -0.04978145f, 0.01682566f, 
    -0.06431668f, 0.02475359f, -0.05267685f, 0.04050393f, -0.03990568f, -0.03459534f, -0.01704927f, 0.00633882f, 
    0.01082939f, 0.02613798f, -0.02012889f, -0.00728773f, -0.04840841f, -0.06276919f, -0.03247243f, -0.00855473f, 
    0.03992861f, 0.03091186f, -0.06539344f, -0.03892796f, 0.05071153f, -0.04135120f, 0.00300464f, -0.01017484f, 
    0.01634049f, -0.00230412f, 0.03941124f, -0.02610976f, -0.03365223f, -0.03647035f, 0.00207637f, 0.02151876f, 
    0.02801678f, -0.05437029f, 0.04990703f, -0.01420906f, 0.01391132f, -0.03583493f, 0.00499365f, 0.04429146f, 
    -0.00651292f, -0.05821799f, 0.00481892f, 0.02684493f, 0.02097313f, 0.03078193f, 0.03313392f, -0.05896925f, 
    -0.03628924f, -0.04627540f, 0.02588023f, 0.03311642f, -0.04114940f, -0.06331368f, 0.02420491f, -0.05903147f, 
    -0.03411252f, 0.02900650f, -0.00543783f, 0.03300318f, 0.05001702f, -0.03843318f, 0.02679956f, -0.05573914f, 
    0.04561903f, 0.03128935f, -0.04793934f, 0.03692799f, 0.04497060f, 0.04987687f, 0.02247429f, 0.05183092f, 
    0.04811560f, -0.03051545f, -0.00405230f, -0.02478239f, -0.00946316f, 0.05180890f, -0.05632487f, 0.01773290f, 
    -0.02872276f, 0.00810344f, -0.04593220f, -0.03280081f, 0.02694012f, -0.02366570f, -0.00615246f, 0.00581833f, 
    -0.00032761f, -0.00097802f, -0.04174989f, -0.00695951f, -0.04200314f, 0.00615984f, 0.02052599f, -0.05346969f, 
    0.04273541f, -0.03331340f, 0.04028558f, -0.05779193f, 0.01121060f, -0.02792978f, 0.04511289f, 0.02109683f, 
    0.01667648f, 0.03619510f, -0.00531919f, -0.01824931f, -0.00849140f, 0.02023679f, 0.00061308f, 0.02492217f, 
    0.00712310f, 0.04697812f, -0.03101321f, -0.03751853f, 0.00772614f, 0.00797887f, -0.00792447f, -0.00070054f, 
    0.00129070f, -0.03440559f, -0.01043618f, -0.05191357f, -0.06484940f, 0.01028680f, 0.02658920f, 0.02639178f, 
    -0.06871317f, -0.02382814f, -0.03093402f, 0.01868220f, 0.03388540f, 0.04434346f, -0.02221876f, -0.01960159f, 
    -0.02445061f, 0.00526934f, 0.03408536f, -0.00658425f, -0.03296104f, -0.05498668f, 0.00945088f, -0.03958451f, 
    0.01568105f, -0.05809734f, 0.04639117f, -0.03872464f, 0.00637093f, -0.02638577f, -0.04460438f, 0.02458325f, 
    0.04432891f, -0.02347435f, -0.06975846f, 0.01016680f, -0.03052494f, 0.00924660f, 0.02635472f, -0.01072958f, 
    0.04680450f, 0.03591097f, 0.04918669f, -0.06525183f, -0.02575793f, -0.00884341f, -0.03970796f, -0.01150480f, 
    -0.02093961f, -0.02995071f, 0.01824368f, 0.00010594f, -0.03262478f, -0.00561070f, 0.04128513f, 0.00327269f, 
    0.02778169f, 0.01466726f, -0.05175544f, -0.04743197f, -0.03515095f, 0.03889939f, -0.02187407f, -0.05026271f, 
    -0.02280334f, -0.03703394f, -0.01037977f, 0.03143320f, -0.04727348f, -0.03336568f, -0.02698507f, 0.03406165f, 
    0.04935254f, 0.02738953f, -0.05502249f, -0.02439847f, 0.01817075f, -0.03357703f, -0.06138775f, -0.04680504f, 
    -0.00891724f, -0.04657869f, 0.00529332f, -0.02467957f, -0.00859788f, -0.00897724f, 0.04729033f, 0.02667603f, 
    0.02883242f, 0.01486975f, 0.02552644f, 0.01056379f, 0.00226885f, 0.02936144f, 0.04858274f, -0.04248418f, 
    -0.00836725f, -0.06781362f, 0.01050049f, -0.02547213f, 0.01224625f, -0.07037909f, -0.06539425f, -0.04245914f, 
    -0.01687565f, 0.11015557f, -0.04632423f, -0.08775781f, -0.05556178f, 0.05456703f, -0.01932462f, -0.03889649f, 
    -0.06717366f, 0.09781660f, -0.12331777f, -0.08527754f, -0.08428149f, 0.13289353f, -0.12263491f, 0.04407800f, 
    -0.00554852f, -0.10591406f, 0.12356476f, -0.16396455f, -0.03540958f, 0.15313321f, 0.11894783f, 0.03934942f, 
    -0.01422506f, -0.14676180f, -0.12294710f, 0.15561044f, 0.16883865f, 0.04858170f, -0.16389216f, -0.05763260f, 
    -0.24469778f, -0.00799146f, -0.05236982f, -0.02151734f, 0.27038288f, 0.05677517f, -0.17625849f, 0.05126612f, 
    -0.08787823f, -0.02383390f, 0.01570060f, -0.08653868f, -0.02024494f, -0.31606594f, 0.21725546f, -0.11890159f, 
    -0.01932168f, 0.15470713f, -0.13541946f, -0.00189536f, -0.01582311f, 0.05307133f, -0.28608921f, -0.12833560f, 
    0.28993127f, 0.15331657f, 0.16103323f, 0.02018672f, 0.09316382f, 0.02432474f, 0.12825796f, 0.34914052f, 
    0.05677382f, 0.09888841f, -0.15696159f, -0.07571423f, 0.17738190f, 0.03562682f, 0.14234258f, -0.01682910f, 
    0.22370109f, 0.17477550f, 0.14746682f, 0.05834627f, -0.02418180f, 0.02494613f, -0.05678483f, 0.03079033f, 
    -0.03486399f, 0.10833138f, 0.18116605f, -0.07636241f, -0.04222476f, 0.04511191f, 0.06102179f, -0.01326132f, 
    0.07544670f, 0.02471313f, 0.08750092f, -0.04288713f, 0.17318282f, 0.05868642f, 0.05422645f, 0.10880352f, 
    -0.15325446f, -0.08980403f, -0.00922774f, 0.09120762f, -0.07773627f, 0.37350467f, 0.02492692f, 0.12787507f, 
    -0.09179877f, 0.04813286f, 0.06224291f, 0.09320699f, 0.09446968f, 0.04739599f, -0.04595849f, 0.01573972f, 
    0.00514567f, 0.01335929f, 0.05735381f, -0.17000407f, 0.11400606f, 0.23792365f, 0.08407794f, 0.02745193f, 
    0.00676911f, -0.27440310f, -0.23539445f, 0.12596999f, 0.01200659f, 0.01609758f, 0.24953480f, -0.04195030f, 
    -0.07663759f, -0.22259095f, -0.11268098f, 0.01233327f, 0.08085532f, 0.10762831f, -0.06167793f, 0.43881959f, 
    0.12072386f, -0.00537970f, -0.05799596f, 0.15848915f, 0.10587485f, 0.10853069f, 0.17829825f, -0.21775334f, 
    -0.11462267f, -0.05192652f, -0.01968371f, -0.01544358f, 0.13459289f, 0.05937697f, 0.12228712f, -0.04940981f, 
    0.06682496f, -0.00447214f, -0.20571652f, -0.16389228f, -0.05666134f, 0.07112160f, 0.15183641f, -0.08173674f, 
    0.14887711f, -0.15935154f, 0.18631977f, 0.36688593f, 0.14711401f, 0.03924834f, -0.10736688f, -0.09360579f, 
    -0.01606437f, 0.00454270f, -0.17324501f, -0.02041176f, -0.04439777f, -0.01463719f, 0.08967417f, -0.04824890f, 
    -0.06848640f, -0.21545899f, 0.01750074f, -0.27037653f, -0.17460957f, -0.19750097f, 0.10602073f, 0.10675613f, 
    0.04388786f, -0.06830819f, 0.03014617f, -0.18372290f, -0.00637897f, 0.13668795f, 0.09028932f, -0.21074210f, 
    -0.08303373f, 0.16776511f, -0.11993067f, 0.08692992f, -0.02182297f, 0.02481997f, -0.00427424f, 0.09011818f, 
    0.21300489f, -0.06954952f, 0.02544975f, 0.00054661f, -0.07020323f, -0.08296999f, 0.01765189f, 0.13740511f, 
    0.01801486f, 0.22083671f, -0.24988121f, -0.09154940f, -0.07945406f, -0.02272997f, -0.17416525f, -0.00893721f, 
    0.23579626f, -0.12597884f, -0.01761113f, -0.08615778f, 0.11117366f, 0.00308132f, 0.03701259f, 0.11420592f, 
    -0.18580306f, 0.14567643f, -0.04681320f, -0.19148910f, 0.02853229f, 0.07069506f, 0.16313238f, 0.01589328f, 
    -0.27617335f, -0.21251535f, 0.14851266f, -0.06414085f, -0.11804471f, 0.01402394f, -0.08943570f, -0.06048644f, 
    0.06016028f, -0.10236575f, -0.00018543f, 0.00169122f, 0.02187755f, 0.10677134f, 0.07965607f, 0.06006155f, 
    0.14205049f, -0.15745701f, -0.00987269f, -0.02217235f, 0.23373857f, 0.04862245f, 0.14028198f, -0.29260781f, 
    -0.15313758f, -0.23006105f, 0.06545821f, -0.08711421f, -0.15514047f, 0.22893837f, -0.20932639f, -0.26401734f, 
    -0.22875684f, -0.09949053f, -0.05171828f, 0.14254980f, -0.10380644f, -0.07964487f, 0.02324177f, 0.01415508f, 
    0.24289155f, -0.05300343f, 0.13794646f, 0.04207432f, -0.03177950f, -0.23982514f, -0.20762664f, 0.05883778f, 
    -0.01508802f, -0.03106766f, 0.04867946f, 0.06460489f, 0.02696196f, -0.05629396f, -0.06654206f, 0.02232588f, 
    0.08802933f, 0.10699291f, 0.18080255f, 0.07172802f, 0.08370053f, -0.08387293f, 0.04603055f, 0.00555712f, 
    -0.27427101f, -0.12477626f, 0.21335831f, 0.04319492f, -0.17817344f, 0.03271370f, -0.06155358f, 0.16592637f, 
    0.17543364f, 0.09391378f, 0.03975056f, 0.17996904f, 0.15839180f, 0.02700960f, -0.07899623f, 0.00972891f, 
    0.05396663f, 0.13829848f, -0.03692709f, 0.03290490f, -0.07048576f, -0.05695875f, 0.09010787f, 0.09034356f, 
    -0.00297110f, -0.08275773f, -0.07349353f, 0.03954623f, 0.16327418f, -0.04862060f, 0.16950195f, 0.09984706f, 
    0.17688367f, -0.04624926f, -0.02073568f, -0.14494690f, -0.06934635f, 0.00812263f, 0.26748052f, -0.06835256f, 
    0.12983769f, 0.03762223f, -0.05582784f, -0.00091331f, 0.03947844f, -0.19612147f, 0.08094486f, 0.08825324f, 
    0.16385917f, 0.02694687f, 0.07133460f, -0.01008456f, -0.00701443f, -0.20941952f, -0.14000650f, 0.04495567f, 
    -0.06108071f, -0.04062299f, 0.04982715f, 0.07542359f, 0.16112170f, 0.01746506f, -0.13586749f, -0.05406969f, 
    -0.09973647f, 0.29804111f, 0.17912531f, -0.04777594f, -0.12819140f, -0.11852522f, 0.05707527f, -0.08715727f, 
    -0.18821433f, 0.17046148f, 0.23082170f, 0.26515672f, 0.00460136f, 0.12526019f, 0.16082670f, 0.10400788f, 
    -0.19915107f, 0.07615953f, 0.25436175f, 0.17007674f, -0.24556465f, 0.10041601f, -0.04890217f, -0.21433438f, 
    0.01951989f, -0.11116156f, 0.05505204f, 0.30053484f, 0.39087486f, 0.38855034f, -0.05789181f, 0.04263300f, 
    0.16224577f, 0.12866914f, 0.03664923f, 0.15849049f, 0.05955822f, 0.31233162f, 0.03065297f, 0.11817475f, 
    -0.13338622f, 0.06121231f, -0.20592114f, -0.11863449f, -0.17854728f, 0.01210647f, -0.02860962f, 0.16292788f, 
    -0.05031825f, 0.20966116f, -0.16671661f, 0.19555314f, -0.03676623f, -0.04492827f, 0.00397160f, -0.11595474f, 
    0.12201197f, 0.12765099f, 0.05027214f, -0.14204869f, -0.16793874f, -0.22373293f, 0.02920828f, -0.00637855f, 
    -0.22910090f, -0.06567138f, 0.04152915f, -0.03503335f, 0.14376892f, -0.02883951f, -0.32230556f, 0.03777922f, 
    0.30353642f, 0.09268506f, 0.19633181f, 0.02399164f, 0.03718575f, -0.00912590f, -0.10314532f, 0.09945016f, 
    -0.16364525f, 0.03775692f, 0.24630539f, 0.36578190f, -0.07943066f, 0.22375324f, 0.06450439f, -0.08179572f, 
    0.08895092f, 0.22296703f, -0.05401144f, 0.13607314f, -0.19657560f, -0.03216859f, 0.05232014f, 0.06220702f, 
    -0.06160316f, -0.10986394f, -0.00395479f, 0.00617862f, -0.14086092f, -0.20733987f, -0.02361916f, 0.07401302f, 
    -0.04967358f, 0.22042453f, -0.02823198f, 0.06166438f, 0.17074060f, 0.23770966f, 0.25378525f, -0.06509318f, 
    -0.02394769f, 0.19814344f, 0.05382552f, 0.13500041f, 0.12663713f, 0.02852259f, 0.08774798f, 0.10785249f, 
    -0.00994634f, -0.03235095f, 0.07717186f, 0.06394504f, -0.11381306f, 0.16257961f, 0.17188625f, 0.07368465f, 
    0.04086166f, -0.04715857f, 0.06811737f, -0.09319850f, 0.08786436f, -0.16952533f, -0.06547210f, -0.02859385f, 
    -0.10366547f, -0.20417468f, 0.03851158f, 0.11898672f, -0.06769597f, 0.06666894f, -0.15389107f, 0.07924639f, 
    0.21194881f, 0.20437755f, -0.00718410f, 0.05915859f, -0.00594272f, 0.07566617f, 0.07509273f, -0.14399961f, 
    -0.19532868f, -0.09312207f, 0.35435134f, 0.08963192f, 0.05725462f, -0.06673419f, 0.19933800f, 0.11094449f, 
    0.16574362f, 0.08622869f, 0.02746339f, -0.05960213f, 0.01680127f, -0.00865399f, 0.03765953f, -0.00062396f, 
    0.12555885f, -0.11494657f, 0.31423682f, 0.10813839f, 0.21478529f, -0.06323564f, -0.04008892f, -0.00014343f, 
    0.03374077f, 0.18342687f, -0.15496871f, 0.00882874f, 0.18172626f, -0.15980679f, -0.05927094f, 0.09691117f, 
    0.00468260f, -0.01809001f, 0.06411988f, -0.08911287f, -0.08073179f, -0.05712382f, -0.27033362f, -0.07214766f, 
    0.16022958f, -0.06649513f, -0.03535412f, 0.10713805f, 0.21773911f, 0.24250674f, 0.04648594f, -0.01239921f, 
    -0.32996550f, 0.11355169f, 0.17397064f, -0.01975158f, -0.06761871f, 0.02592233f, -0.00670974f, -0.08459234f, 
    0.23338915f, 0.06665266f, 0.09934827f, 0.00815707f, -0.02278808f, -0.03463199f, -0.00482606f, -0.03439857f, 
    0.04966586f, 0.27300683f, 0.16587992f, 0.07514095f, -0.14644611f, -0.04457991f, -0.01455437f, 0.10032953f, 
    0.15887083f, -0.05635599f, -0.37984243f, -0.15995929f, -0.01231565f, -0.06187134f, -0.05939346f, -0.07135130f, 
    -0.17638686f, -0.24070336f, -0.10635507f, -0.48005927f, -0.15099877f, 0.00420065f, -0.06149213f, 0.02052088f, 
    0.10390670f, -0.06192829f, -0.20634487f, 0.07364097f, 0.10448749f, 0.11004606f, -0.10463323f, 0.06675278f, 
    -0.02537110f, 0.03886243f, 0.04629504f, 0.03432441f, -0.15015224f, -0.14067240f, 0.21626721f, -0.13795185f, 
    0.02858885f, -0.17297940f, 0.05223817f, 0.10519494f, -0.00847923f, -0.33708882f, 0.28237143f, -0.04624257f, 
    -0.00851865f, -0.09199847f, 0.09124295f, 0.05248446f, 0.07979708f, -0.03489495f, 0.04048838f, 0.09864992f, 
    -0.03298633f, 0.20016810f, 0.15269439f, 0.04261551f, 0.19459236f, 0.27573869f, 0.16023873f, -0.05441423f, 
    -0.34036776f, 0.07877377f, -0.15130921f, 0.04327150f, -0.08501991f, 0.18423748f, 0.11235705f, 0.06323657f, 
    -0.04373201f, 0.26269585f, 0.24904560f, 0.08021439f, 0.26295024f, 0.09955665f, 0.10472459f, 0.12331589f, 
    0.00203296f, 0.08760492f, 0.04610679f, 0.05492060f, -0.04088347f, 0.13825709f, -0.00823673f, 0.12032393f, 
    0.17125076f, -0.08833259f, -0.25561604f, -0.09963538f, -0.33157417f, 0.01226701f, -0.01587527f, 0.12672485f, 
    -0.03430215f, -0.02681866f, 0.15624446f, -0.28366986f, -0.33609080f, -0.10347012f, -0.01331496f, -0.06129767f, 
    -0.14015324f, 0.13103214f, -0.11085294f, 0.08183786f, -0.00581313f, -0.22135682f, -0.04378389f, 0.15896840f, 
    0.01876473f, 0.11444482f, 0.24524626f, 0.23536935f, 0.12760630f, 0.01070660f, -0.07127331f, 0.38278654f, 
    -0.09008206f, -0.18499853f, 0.14583459f, 0.07025705f, -0.01848368f, -0.01439484f, 0.16200387f, -0.01802698f, 
    0.12479396f, 0.16506895f, -0.06809433f, -0.13924173f, 0.09755182f, 0.16161148f, 0.13592115f, -0.03293229f, 
    0.22450466f, -0.22761360f, -0.18531540f, 0.19206391f, -0.04937876f, -0.01249421f, 0.39473453f, -0.04756756f, 
    0.03014150f, -0.36941817f, -0.14486161f, -0.02095118f, 0.06301660f, -0.03863254f, -0.00691444f, 0.04380228f, 
    -0.18654472f, 0.16293666f, 0.05477531f, -0.08446241f, 0.00051484f, 0.05532967f, -0.07131957f, 0.08570341f, 
    0.03057073f, -0.06798281f, -0.26407832f, 0.08441547f, 0.02492427f, 0.09635492f, 0.04361787f, -0.03219867f, 
    0.06015949f, -0.09879516f, 0.08520842f, -0.18526985f, -0.17885333f, -0.16624470f, 0.13923821f, -0.02968301f, 
    0.04831407f, -0.06988668f, 0.05245932f, -0.04180240f, -0.26358551f, -0.42772645f, -0.21304138f, 0.03411291f, 
    -0.13553239f, 0.02306000f, 0.02283053f, -0.08597453f, 0.00227404f, 0.03974311f, 0.09542738f, 0.05577508f, 
    -0.24499086f, 0.22333267f, -0.23102605f, 0.02422054f, 0.01437140f, -0.09488749f, -0.09523080f, -0.17822686f, 
    -0.25646141f, -0.06837156f, 0.07125968f, 0.24507973f, 0.03272362f, 0.09497571f, 0.12021884f, 0.25840724f, 
    0.03773158f, 0.14242771f, 0.02394050f, -0.13449192f, 0.01998776f, -0.22634633f, -0.10861861f, -0.05998139f, 
    0.20112412f, -0.09612324f, 0.07327319f, -0.17270403f, 0.05199501f, -0.09758073f, 0.01506575f, 0.15363553f, 
    0.00377858f, -0.15776739f, 0.11276484f, -0.55642015f, -0.11005128f, -0.08122889f, 0.14921235f, -0.17712301f, 
    -0.22246620f, -0.30770105f, 0.13740797f, 0.05953574f, 0.30056810f, 0.10285106f, -0.00586383f, -0.06908964f, 
    -0.02946156f, -0.06400789f, -0.13979101f, -0.08930063f, -0.25827625f, -0.30885020f, 0.11549290f, 0.05860016f, 
    0.21389294f, 0.09835988f, 0.14754158f, 0.04645718f, -0.05395533f, 0.09087485f, 0.11359227f, 0.06627758f, 
    -0.11046591f, 0.00937021f, 0.00885549f, -0.06207927f, 0.05811262f, 0.07162729f, 0.11693229f, 0.11449578f, 
    -0.05675714f, 0.09110343f, -0.11052881f, 0.05561118f, -0.12441509f, -0.12706973f, -0.00447801f, -0.04614116f, 
    0.10796670f, -0.11710627f, 0.02320352f, 0.12596060f, -0.11877181f, 0.00097357f, -0.04610983f, 0.03505126f, 
    -0.05585278f, -0.40712970f, 0.12196509f, 0.16920425f, 0.03413801f, 0.10248767f, 0.14548932f, 0.02395932f, 
    -0.18089975f, -0.22169088f, -0.19448315f, 0.25059605f, 0.18630600f, 0.17814568f, 0.06435916f, -0.01546762f, 
    -0.11576394f, -0.29208642f, 0.05901771f, 0.01173943f, -0.07839046f, -0.10467382f, 0.00879108f, 0.03795589f, 
    0.24570511f, 0.24052393f, -0.11526445f, -0.10874423f, -0.09995390f, 0.05097605f, 0.17082259f, 0.06684222f, 
    0.08130515f, 0.10505717f, 0.10019144f, -0.05321014f, -0.15732990f, 0.05016420f, -0.06110871f, 0.03611943f, 
    0.02020264f, 0.01399341f, 0.07839979f, -0.04089228f, 0.13379741f, 0.02857380f, -0.09610675f, 0.22954796f, 
    0.07927836f, 0.02254523f, 0.06286288f, -0.15203550f, -0.22012937f, 0.06030101f, 0.02534031f, -0.09263869f, 
    0.06614941f, 0.04719355f, 0.02717233f, -0.07510035f, -0.12836666f, -0.07398364f, -0.04830120f, -0.03531346f, 
    -0.02575815f, 0.05503483f, 0.07891280f, -0.10430940f, -0.02257208f, -0.19361658f, -0.09544881f, -0.06448977f, 
    -0.12253734f, -0.06979328f, 0.02463583f, 0.14724992f, 0.11491694f, -0.03815913f, -0.19201469f, -0.16397420f, 
    -0.02676374f, -0.17828941f, -0.18086375f, 0.08341573f, 0.05490231f, 0.12981786f, -0.09285162f, -0.03582459f, 
    -0.11718719f, 0.02355279f, -0.04415954f, -0.09955072f, 0.10190974f, 0.07015810f, 0.16824336f, 0.16647738f, 
    0.10907570f, 0.03288158f, -0.09894185f, -0.05045696f, -0.08151378f, -0.04756571f, 0.03240217f, 0.04952062f, 
    0.00428862f, -0.00486208f, 0.00031799f, 0.29276779f, 0.27163434f, 0.05388515f, -0.08145110f, -0.14657724f, 
    -0.29590517f, 0.13887909f, 0.04660975f, 0.00504632f, -0.08795381f, -0.02374145f, 0.13030685f, -0.00260879f, 
    -0.03990018f, -0.01221666f, -0.03588823f, -0.14063606f, 0.12133412f, 0.23910215f, -0.00769358f, -0.40234518f, 
    0.03067303f, 0.09006855f, 0.03945006f, -0.04487487f, 0.13915116f, 0.15168732f, -0.11132090f, 0.25452396f, 
    -0.10226109f, 0.01676553f, 0.07411763f, 0.08166188f, -0.03656149f, 0.04787760f, -0.02059306f, -0.13580599f, 
    0.05506618f, -0.21048883f, 0.12063709f, 0.12021619f, 0.19199461f, -0.00969833f, -0.19905804f, -0.13442291f, 
    -0.13365279f, 0.10422838f, 0.02072820f, 0.02668053f, 0.08745677f, -0.15291372f, -0.03465178f, -0.00802218f, 
    -0.00873974f, -0.02615429f, -0.15423796f, -0.08580530f, -0.17390184f, -0.12866634f, -0.03558288f, 0.07483056f, 
    -0.01179617f, 0.21739304f, -0.01739692f, 0.06858718f, 0.17712440f, -0.15434559f, 0.15574676f, -0.04765040f, 
    -0.14705722f, 0.09764673f, 0.08199208f, -0.31518725f, -0.18097366f, -0.05305394f, 0.04147214f, -0.05848961f, 
    0.11832245f, 0.01413326f, 0.00401429f, -0.09688276f, 0.19169576f, 0.05887592f, 0.01303112f, 0.05621219f, 
    -0.00159011f, -0.22735645f, 0.07508220f, 0.14003107f, 0.23314050f, 0.13041480f, -0.08717234f, -0.18160789f, 
    -0.13395497f, -0.10199200f, -0.17320570f, 0.01779877f, 0.02226471f, 0.18050513f, -0.01412188f, -0.17583193f, 
    -0.12291740f, 0.01805233f, -0.09123408f, 0.14778791f, -0.00815148f, 0.02610128f, -0.13558437f, -0.05678629f, 
    -0.08248471f, -0.25002593f, 0.08932284f, 0.03258232f, 0.22716194f, -0.10983505f, -0.02740467f, -0.05114241f, 
    -0.06097206f, -0.10342614f, -0.29701063f, 0.36223280f, 0.21210074f, 0.04850101f, -0.02113589f, -0.15541656f, 
    -0.25537506f, -0.06347861f, -0.09498377f, -0.11933131f, 0.05117632f, 0.01684147f, -0.16167970f, 0.03835407f, 
    -0.11480996f, 0.24278793f, 0.18560487f, 0.10667036f, -0.17713240f, -0.01939022f, 0.00789077f, 0.00696578f, 
    -0.00622945f, 0.08697278f, 0.13653105f, -0.22647357f, -0.16204572f, -0.17271832f, 0.08844330f, 0.03656941f, 
    0.09529392f, -0.05461192f, 0.06174437f, 0.20131139f, -0.04960568f, -0.13745007f, 0.06446639f, -0.00680547f, 
    0.04117528f, 0.17265636f, -0.00723829f, 0.01622473f, -0.00922269f, 0.11859969f, 0.08725938f, -0.25081137f, 
    -0.06536092f, 0.02136044f, 0.04085854f, -0.03860451f, -0.14905743f, 0.17398912f, -0.15225925f, -0.12625635f, 
    -0.05389724f, 0.06787236f, 0.08094086f, 0.21057148f, -0.07517881f, 0.04530004f, -0.11143410f, -0.08822554f, 
    -0.06480247f, -0.07464276f, 0.04624422f, 0.08013219f, 0.11814523f, 0.00207393f, 0.04809570f, 0.01374438f, 
    -0.13681336f, 0.02966717f, -0.09049471f, -0.01028802f, -0.02839321f, 0.04357283f, 0.01980839f, -0.04619057f, 
    0.04213579f, 0.14965273f, -0.07058336f, 0.18813451f, 0.06420711f, 0.10256267f, 0.02885715f, -0.01118338f, 
    -0.06327210f, -0.03330047f, 0.03031371f, 0.08754121f, 0.08243761f, 0.04086623f, -0.03328440f, -0.06984141f, 
    0.08072343f, -0.11299182f, 0.09525076f, 0.20287041f, 0.17129660f, -0.00594955f, -0.01090638f, 0.07073124f, 
    -0.06820581f, 0.00292850f, -0.01308831f, -0.08010013f, -0.03631142f, -0.38384300f, 0.03399593f, -0.00565068f, 
    -0.08796316f, -0.04061388f, 0.07107250f, -0.00321962f, -0.04910888f, -0.10015418f, 0.19246855f, 0.26558435f, 
    -0.02854688f, 0.11395634f, 0.06961689f, 0.09239962f, 0.09669892f, 0.14259580f, -0.11787272f, -0.06290175f, 
    0.37373018f, -0.00688111f, 0.06536893f, 0.00647801f, 0.15885092f, 0.07329910f, 0.25733113f, 0.17363879f, 
    0.06935368f, 0.02603723f, 0.04621533f, -0.09990124f, 0.07314775f, 0.04439813f, 0.09529946f, -0.03884236f, 
    -0.05492287f, 0.10295295f, 0.14509301f, 0.11809216f, 0.07082401f, -0.12663749f, 0.03968837f, 0.12917365f, 
    -0.12169861f, -0.09946015f, -0.04215489f, -0.14349811f, 0.10765749f, 0.03430444f, 0.04448919f, 0.00472632f, 
    0.03730063f, -0.00513776f, 0.15184362f, 0.05300079f, -0.01463626f, 0.10234526f, -0.00067965f, 0.07768361f, 
    0.02788603f, 0.05587510f, -0.00921915f, -0.33360809f, 0.26196918f, 0.01734309f, -0.01620688f, -0.03392172f, 
    0.04015509f, 0.03319355f, -0.14927328f, -0.04662994f, 0.26286736f, 0.22013798f, 0.07638185f, 0.05926308f, 
    -0.08701949f, 0.01141010f, 0.22115614f, 0.05842214f, 0.09606158f, -0.11627981f, 0.00819097f, -0.06587356f, 
    0.03628042f, -0.27086872f, -0.12008683f, -0.14437062f, 0.03178663f, -0.11358824f, -0.05593519f, -0.34357229f, 
    -0.22009751f, 0.06413157f, -0.06521226f, 0.02290614f, 0.04492855f, 0.03779074f, 0.03470594f, 0.11628184f, 
    0.05985763f, 0.18775356f, 0.04010133f, 0.05089546f, -0.02734042f, 0.17339191f, -0.02883955f, 0.16271572f, 
    0.09852125f, 0.24834691f, -0.07867573f, 0.02332874f, 0.00414015f, -0.03336938f, 0.04517467f, 0.13356538f, 
    0.04289439f, -0.02352695f, 0.01473177f, -0.35789838f, -0.00978524f, -0.04498952f, 0.11096489f, 0.02324396f, 
    -0.14684358f, -0.09143250f, 0.01707434f, 0.18591903f, 0.07448997f, -0.08708276f, 0.21842495f, -0.05821738f, 
    0.02957598f, 0.01351669f, 0.00083832f, 0.04996642f, 0.05668994f, 0.02696128f, -0.02990143f, 0.02748069f, 
    0.10818206f, 0.06760613f, -0.07967921f, -0.07527095f, -0.16013685f, -0.06580184f, 0.11152057f, 0.01120367f, 
    -0.02433066f, 0.03042016f, -0.09097523f, -0.16824862f, -0.08945301f, -0.17048980f, 0.15124428f, -0.36710343f, 
    0.00013191f, -0.00202065f, -0.09504277f, 0.11959174f, -0.31459656f, 0.10336868f, 0.00049185f, 0.10085289f, 
    0.11686385f, 0.06886879f, 0.07694670f, -0.01471506f, 0.03758481f, 0.04859694f, -0.06247916f, 0.09776823f, 
    0.14478864f, -0.05311551f, 0.05915049f, 0.08521247f, -0.00191439f, -0.04279696f, -0.05758256f, 0.07428022f, 
    -0.29549319f, 0.08558682f, -0.12967977f, -0.00691462f, -0.02772791f, 0.14427488f, -0.01926979f, -0.02678741f, 
    -0.13589931f, -0.06847933f, 0.17151597f, -0.34659791f, 0.02278616f, 0.10098405f, 0.17301427f, 0.22534141f, 
    -0.11349057f, -0.17326640f, -0.01998234f, -0.24531491f, -0.24763717f, -0.13122086f, -0.07914336f, -0.00932167f, 
    -0.04351077f, 0.00115872f, 0.06235679f, -0.09051225f, 0.22387001f, 0.16033196f, 0.01888405f, -0.01168139f, 
    -0.12847894f, 0.01579239f, 0.18533911f, 0.01117324f, 0.26863655f, 0.03356193f, 0.02898924f, -0.06003468f, 
    0.07654369f, 0.05053088f, -0.00019814f, -0.07892287f, -0.04758782f, -0.03506856f, -0.28572094f, -0.30457121f, 
    -0.10316636f, -0.16477899f, -0.02535549f, -0.05409140f, -0.16974971f, -0.09134038f, 0.04529284f, 0.07941695f, 
    -0.01015613f, -0.05868156f, 0.01244845f, 0.03611733f, 0.05551632f, -0.12807885f, -0.09410677f, 0.01791057f, 
    0.16766411f, 0.27459916f, 0.05664780f, -0.03152013f, -0.00928061f, -0.03828912f, 0.08674249f, 0.19682723f, 
    -0.12045087f, 0.06819246f, 0.09315605f, -0.13591985f, -0.14300595f, -0.12282685f, -0.01084632f, 0.11323822f, 
    0.18637517f, 0.41512153f, -0.37182286f, -0.48512274f, 0.03350345f, 0.06254474f, -0.00905430f, 0.00034965f, 
    -0.02835501f, 0.17088674f, -0.24212940f, 0.00245040f, -0.22557589f, 0.15395193f, -0.00370284f, 0.02601415f, 
    0.03324792f, -0.06482175f, 0.07819664f, -0.07563988f, -0.18032734f, 0.04390564f, -0.36006477f, 0.13455456f, 
    -0.06054818f, 0.00891412f, 0.02767631f, 0.05344487f, -0.11723015f, 0.16270888f, 0.10790913f, -0.18735662f, 
    0.00862167f, 0.26099139f, 0.02578324f, -0.13374841f, 0.01239742f, -0.03417066f, -0.45364904f, -0.02230424f, 
    0.03351195f, -0.02978279f, -0.08873057f, 0.02236336f, -0.06457849f, -0.08366624f, 0.18799129f, 0.01377931f, 
    -0.19555396f, -0.16625810f, 0.02397039f, -0.35034344f, 0.07783721f, -0.09653767f, 0.16551107f, -0.57473153f, 
    0.06516413f, 0.09914891f, 0.06669468f, -0.03846173f, 0.09409832f, 0.03475253f, 0.09589101f, 0.13275471f, 
    -0.16841315f, 0.10011705f, 0.01406365f, 0.03687372f, -0.08933255f, 0.02895020f, -0.06370566f, 0.11573046f, 
    0.24492173f, 0.02240634f, 0.19814023f, -0.12953067f, -0.11462912f, -0.06619410f, -0.24331534f, -0.01963678f, 
    -0.07916854f, -0.00618844f, -0.20849781f, -0.09947747f, -0.00563324f, 0.12282776f, -0.20215793f, 0.04282776f, 
    0.16842839f, 0.14608893f, 0.02826252f, -0.17908344f, 0.19010894f, -0.08103981f, 0.08970970f, 0.03622378f, 
    -0.07888661f, -0.13264796f, -0.00924989f, 0.07311729f, -0.13165762f, -0.17568228f, -0.03463121f, 0.07640141f, 
    -0.10148452f, -0.00541285f, -0.04090876f, 0.05009483f, 0.04810444f, -0.11921269f, -0.02350906f, -0.06733947f, 
    -0.13706380f, 0.04212986f, 0.09981085f, 0.07115774f, -0.06588145f, -0.27356070f, -0.02255732f, -0.18744875f, 
    -0.61033809f, 0.16458271f, 0.04049916f, 0.26098189f, -0.03538258f, -0.04109059f, -0.13644528f, -0.32180247f, 
    -0.32724693f, -0.28417307f, -0.15879206f, 0.05242217f, 0.17664462f, 0.02594269f, 0.13461986f, -0.20499855f, 
    -0.26820019f, -0.20366365f, -0.41682357f, -0.11541941f, -0.14446416f, -0.07152366f, 0.04199146f, 0.03807155f, 
    0.09585112f, 0.32686871f, 0.02947818f, 0.08633957f, 0.12363438f, -0.10969012f, -0.06518612f, 0.07635325f, 
    0.05498720f, -0.05728292f, -1.48005581f, -0.50000352f, -0.05042277f, -0.03795064f, -0.16292647f, 0.04768258f, 
    0.04474410f, -0.08535690f, 0.13503826f, 0.19058350f, 0.16051348f, 0.30194181f, -0.04454876f, -0.13753664f, 
    -0.13225946f, 0.17236422f, 0.01437102f, -0.05538305f, -0.28243604f, 0.02907390f, -0.03835791f, 0.06059859f, 
    -0.17990491f, 0.01497676f, -0.03307130f, 0.08405301f, -0.00754438f, 0.15300535f, 0.29919758f, 0.16022533f, 
    0.12974754f, 0.27794451f, 0.05193727f, -0.04547987f, 0.15818581f, 0.05755543f, -0.28640792f, 0.01215979f, 
    0.39796788f, 0.03636644f, -0.11788911f, -0.02346525f, 0.17142852f, -0.05850892f, -0.01140868f, 0.07178855f, 
    -0.06587241f, -0.15025619f, 0.00604400f, -0.06173297f, -0.03664223f, 0.01492159f, -0.06066284f, 0.04176463f, 
    -0.05237893f, 0.26338229f, 0.09893171f, -0.07134403f, -0.00609836f, 0.05932477f, -0.08480476f, 0.04275931f, 
    0.09297672f, -0.18434092f, 0.14804754f, -0.17613655f, -0.16358835f, -0.10154513f, -0.09468885f, 0.02812291f, 
    -0.03184350f, -0.12081721f, 0.38658977f, 0.20292769f, 0.09756695f, 0.06497013f, 0.02553527f, 0.09449118f, 
    0.03867098f, -0.01919352f, -0.15905769f, 0.02628106f, -0.14669508f, 0.06852732f, -0.02137482f, -0.00319010f, 
    -0.15303351f, -0.02526791f, 0.03066343f, -0.13229033f, 0.21486638f, -0.02749975f, -0.34995502f, -0.21552034f, 
    -0.08090340f, -0.23607065f, 0.01713887f, 0.17347902f, 0.11194254f, 0.18129493f, 0.24980934f, 0.17299324f, 
    0.00878733f, 0.06067775f, 0.08212897f, 0.13913564f, 0.01294635f, -0.10158022f, 0.07914733f, 0.31236142f, 
    0.03716858f, -0.10423240f, -0.33627388f, -0.12020838f, 0.00084828f, -0.01053066f, 0.15135247f, 0.22069152f, 
    0.15132366f, -0.03402526f, -0.10354961f, -0.15236959f, -0.21804279f, -0.02311774f, 0.11434329f, 0.14715166f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.21120207f, -0.02672826f, -0.08313958f, 0.16476841f, 0.30564773f, 0.18777995f, 0.10271847f, -0.02639353f, 
    0.14559445f, 0.21920671f, -0.03951475f, -0.00900968f, -0.04797625f, -0.01816293f, 0.15716787f, 0.00061175f, 
    0.05476532f, -0.15396848f, 0.21419327f, 0.11024912f, 0.03057498f, 0.04633991f, 0.18019575f, -0.07572911f, 
    0.04692208f, 0.01804529f, 0.00447493f, 0.10849177f, 0.03519420f, -0.04914553f, 0.05790747f, -0.00624618f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.22566348f, 0.07205360f, -0.17502865f, -0.08258342f, 0.42083204f, 0.07187001f, 0.34909225f, -0.15347084f, 
    0.17104147f, 0.44045800f, -0.40749410f, -0.46645662f, 0.03742518f, 0.09743136f, 0.13166533f, -0.00529542f, 
    0.29705092f, -0.24402097f, -0.03936481f, -0.15709066f, 0.16322224f, -0.18998060f, 0.19324620f, -0.27231118f, 
    -0.02764612f, 0.08458702f, -0.15144061f, -0.10242578f, -0.39625415f, 0.30514783f, -0.00934172f, 0.11730385f, 
    -0.06717543f, 0.08702783f, 0.28639066f, 0.15970089f, -0.05503542f, 0.20689966f, -0.31339416f, 0.34440193f, 
    -0.04265987f, -0.35363024f, -0.35095578f, -0.05168942f, 0.11210560f, -0.09727243f, -0.26808855f, 0.21923004f, 
    -0.16079769f, -0.46456695f, 0.01463039f, -0.42429483f, -0.21684371f, -0.23902309f, 0.05946319f, 0.29940784f, 
    0.01825047f, 0.12034799f, 0.28688198f, 0.25044769f, 0.36628413f, -0.34388220f, 0.15827434f, -0.37823024f, 
    -0.16945018f, -0.04030939f, -0.08249812f, -0.03673600f, 0.07040919f, -0.01630299f, -0.07202811f, -0.05740707f, 
    -0.09838487f, -0.12814459f, -0.02333971f, 0.01409120f, 0.02840512f, 0.09378666f, -0.01356563f, -0.02770856f, 
    -0.05946586f, -0.09661402f, -0.11915270f, -0.13925269f, -0.13436058f, -0.13766253f, 0.06473505f, -0.20038351f, 
    -0.10278236f, 0.09775112f, -0.03721643f, 0.09727304f, 0.02829281f, 0.02104609f, 0.18859681f, -0.17502242f, 
    0.04917961f, 0.16728288f, 0.28708872f, 0.28568453f, 0.00870816f, -0.10286296f, -0.15771595f, 0.24205716f, 
    0.24631442f, -0.33523509f, -0.38473824f, -0.23310323f, 0.03947753f, 0.14229916f, -0.18131626f, -0.47745514f, 
    0.07794730f, -0.40483072f, 0.20792700f, -0.20050783f, 0.04141475f, -0.17171502f, 0.16832158f, 0.22476980f, 
    -0.04505598f, 0.07285301f, -0.23197187f, -0.02411699f, 0.37062210f, 0.19905867f, -0.07177927f, -0.45622906f, 
    -0.12821284f, 0.10516204f, 0.40182343f, 0.04392059f, -0.44069132f, 0.01835379f, 0.34282348f, 0.18567818f, 
    -0.25032243f, 0.22862551f, 0.20605864f, 0.16390300f, 0.00680771f, 0.00743857f, 0.12352345f, 0.26741636f, 
    -0.19708352f, 0.26771292f, -0.06433874f, -0.09302700f, -0.12872520f, 0.38086626f, 0.09027655f, 0.41893527f, 
    0.15640447f, -0.08539511f, 0.27089578f, 0.16726077f, 0.18401530f, -0.35077813f, 0.18197437f, 0.20415798f, 
    0.16040151f, -0.05116836f, 0.01119701f, -0.23418531f, -0.09377480f, -0.16203007f, 0.02812887f, 0.10556583f, 
    -0.17374018f, -0.19623570f, 0.33804855f, 0.03829041f, -0.14299190f, 0.08214378f, -0.34281802f, 0.18484347f, 
    -0.14062499f, -0.21836837f, 0.23824108f, -0.09409126f, 0.38189965f, 0.55246437f, 0.06774803f, 0.10403928f, 
    0.11560034f, 0.08345695f, -0.16565797f, 0.25884190f, -0.08498392f, 0.15835439f, 0.15676498f, -0.38251039f, 
    0.01192499f, 0.02735247f, 0.10937192f, 0.28464288f, 0.27471986f, 0.20154324f, -0.05461582f, 0.19699101f, 
    -0.15555483f, 0.11578205f, -0.18063912f, 0.29730955f, 0.07353546f, 0.14700718f, 0.17707159f, 0.07648445f, 
    -0.12473927f, -0.30410874f, 0.19348310f, 0.00812063f, -0.22835249f, 0.02570987f, -0.19249465f, 0.30270097f, 
    0.10724440f, -0.00553635f, -0.04844299f, -0.11662135f, 0.40458214f, -0.42328528f, 0.21035536f, 0.13783041f, 
    0.00079476f, -0.09924336f, 0.23634265f, 0.26920232f, 0.19863276f, -0.07092407f, 0.13210459f, -0.43237886f, 
    0.06835953f, 0.20562480f, 0.51050121f, -0.04448405f, 0.04523370f, 0.10001216f, 0.38478047f, 0.31758314f, 
    0.19415934f, 0.22917822f, 0.26847318f, 0.51396078f, -0.52800059f, -0.11950690f, -0.11529833f, -0.37384123f, 
    0.03361738f, 0.00917302f, 0.30622286f, 0.11699050f, 0.24655561f, -0.15272745f, 0.14581174f, 0.36715564f, 
    -0.04545624f, 0.03642963f, 0.07414404f, -0.05847972f, -0.20069799f, 0.02149090f, 0.06922272f, -0.04372033f, 
    -0.15598013f, 0.06016250f, -0.00874719f, -0.01394321f, -0.04189409f, 0.17453915f, 0.08905689f, -0.05916344f, 
    -0.09023169f, -0.17407900f, -0.14675109f, -0.09598304f, -0.10123149f, 0.03853566f, 0.08523639f, 0.04177427f, 
    0.02438586f, 0.08462189f, 0.08238249f, -0.21739626f, 0.11049745f, 0.02533648f, -0.06427932f, 0.07760995f, 
    0.19188422f, -0.08673397f, -0.03126497f, 0.26216617f, -0.04880287f, -0.13724762f, 0.02494645f, -0.40655011f, 
    0.02170485f, 0.18628950f, 0.55617052f, 0.59115654f, -0.02391880f, -0.16196330f, 0.10134785f, 0.55746520f, 
    -0.01446822f, -0.07444722f, 0.15691157f, 0.13550881f, 0.00039636f, 0.23998836f, -0.04613964f, -0.22643417f, 
    -0.13451597f, -0.06719936f, 0.12385854f, -0.07704692f, 0.05541472f, -0.29098964f, 0.13089509f, 0.22283572f, 
    0.05589173f, -0.14129029f, -0.08717063f, -0.21617530f, -0.25339267f, 0.09531917f, -0.19786237f, -0.12874897f, 
    -0.04514926f, 0.42369226f, 0.09514654f, 0.14602275f, -0.11303779f, -0.14766410f, -0.17199129f, -0.41988832f, 
    -0.13950890f, 0.12464567f, -0.26906919f, -0.54952604f, 0.14782397f, 0.30762741f, -0.01834357f, -0.07659830f, 
    0.08285479f, -0.15970632f, -0.03428711f, 0.09384664f, -0.35105169f, -0.06550808f, 0.24157916f, -0.04166652f, 
    0.04625565f, -0.13682678f, -0.00183092f, -0.16868772f, 0.18973285f, 0.17624161f, -0.32442263f, 0.02412175f, 
    0.28247872f, -0.23591794f, -0.07037631f, -0.56486648f, -0.09594002f, 0.14169830f, 0.03629053f, 0.10383704f, 
    -0.12734485f, 0.05809372f, -0.12377028f, 0.14953381f, 0.01368860f, -0.56576210f, 0.12234753f, -0.15479830f, 
    0.16434374f, 0.03591549f, -0.01737706f, 0.17138822f, 0.15826838f, 0.06393214f, -0.05897889f, 0.03109341f, 
    0.12911616f, -0.13938619f, -0.41786832f, 0.21551263f, -0.08582111f, 0.12658454f, 0.38630554f, -0.21534112f, 
    -0.10576192f, -0.09401553f, -0.43720227f, 0.01737661f, -0.13832493f, 0.04476527f, -0.01082509f, 0.15052493f, 
    -0.03630380f, -0.19138592f, -0.08127189f, -0.07388762f, 0.40794408f, 0.19209823f, 0.24969351f, -0.38304481f, 
    0.13145915f, 0.00030756f, -0.36008424f, 0.22853744f, -0.40466729f, 0.03053359f, -0.18440135f, -0.07656992f, 
    0.03915185f, -0.06110635f, 0.16105841f, -0.10881745f, -0.09902728f, 0.13233303f, -0.01798891f, -0.05555306f, 
    -0.05457852f, -0.15570091f, -0.09396235f, 0.16490799f, 0.06450025f, -0.11713585f, -0.11274181f, -0.08608203f, 
    -0.17060240f, -0.13998784f, -0.12888083f, 0.02805328f, -0.10184181f, -0.11037593f, 0.17524838f, -0.05773716f, 
    -0.03926192f, -0.07463437f, -0.16994938f, -0.16754754f, -0.03964202f, 0.11319155f, -0.04982628f, -0.13542436f, 
    -0.03534017f, -0.02711827f, 0.14303170f, -0.13082908f, 0.10583459f, -0.10801297f, -0.06925365f, 0.04873731f, 
    -0.11072028f, -0.15107968f, 0.14636344f, 0.10886047f, 0.07191852f, -0.01604638f, 0.05568362f, -0.05404288f, 
    0.13487199f, -0.03348099f, -0.03850158f, -0.06296042f, -0.11564806f, -0.04967462f, -0.18453234f, 0.09959818f, 
    -0.04482444f, -0.01420228f, 0.07421055f, 0.07730167f, -0.14772813f, 0.06318946f, -0.14503343f, -0.17101321f, 
    0.21162152f, -0.12750654f, 0.08402851f, -0.04186361f, 0.06252226f, -0.56720108f, 0.17712651f, -0.36991647f, 
    -0.48576811f, -0.20836705f, 0.13601273f, 0.28676131f, 0.05295342f, -0.09955557f, -0.14745732f, 0.20752148f, 
    -0.36505502f, 0.63024610f, 0.10189209f, 0.36880451f, -0.62773609f, -0.30839047f, 0.01860397f, 0.47164452f, 
    0.03590342f, -0.12190466f, 0.00050587f, 0.25991857f, -0.35877123f, 0.56120539f, -0.39534512f, -0.21478139f, 
    -0.50869447f, -0.08712787f, 0.12390608f, -0.26607054f, -0.41083637f, 0.38118497f, 0.06596176f, 0.14489399f, 
    0.34849206f, 0.02192866f, 0.28278354f, -0.11682904f, -0.15639313f, 0.02286463f, -0.11230828f, -0.12845428f, 
    -0.01667786f, 0.60604703f, -0.31500268f, 0.15059994f, 0.13592091f, -0.29767942f, -0.06136560f, 0.04142816f, 
    -0.00718373f, 0.03547823f, 0.16052182f, -0.12385227f, 0.28813782f, 0.24245279f, 0.23785004f, 0.35191172f, 
    -0.11640548f, 0.01817371f, 0.27547470f, 0.31580529f, -0.39275134f, -0.17741306f, 0.03760399f, -0.05130553f, 
    -0.27302548f, 0.00020289f, 0.08456483f, 0.51057106f, 0.01049320f, 0.04237641f, 0.20248075f, 0.30920416f, 
    0.16628121f, 0.08999927f, -0.05384783f, 0.30343249f, 0.00340895f, 0.52775264f, -0.01902103f, 0.32899418f, 
    0.12582663f, 0.01407556f, 0.23057066f, 0.08939337f, 0.14570121f, -0.25360659f, 0.29215282f, -0.08409088f, 
    0.35638210f, -0.03603810f, 0.14281256f, -0.32970563f, 0.18000773f, 0.05965494f, -0.27054733f, 0.26332048f, 
    0.19008560f, -0.08244587f, 0.11397167f, -0.46217555f, 0.10429607f, 0.08515514f, -0.24580355f, -0.19460432f, 
    -0.11789343f, -0.26549309f, 0.19432068f, -0.38744256f, 0.30503184f, -0.07136362f, 0.23047699f, -0.25759423f, 
    -0.11650945f, -0.13008514f, -0.35573715f, 0.24608643f, -0.05503360f, 0.09591261f, -0.04412984f, -0.22230107f, 
    0.25662869f, -0.07438365f, -0.07268509f, -0.13147046f, 0.28471228f, 0.32768038f, 0.03448326f, -0.17068478f, 
    0.00440833f, 0.71225172f, -0.36297309f, -0.39102906f, 0.00829828f, 0.11369537f, 0.25772157f, -0.16813351f, 
    0.29257762f, -0.24326350f, 0.11414804f, -0.07949846f, -0.16618174f, -0.04786545f, 0.08767133f, -0.00938451f, 
    -0.10384136f, -0.10487480f, 0.02874183f, -0.05047685f, -0.06811684f, -0.17240737f, 0.12422355f, 0.30125433f, 
    0.17348135f, 0.00147746f, 0.08594133f, -0.05180782f, 0.07877007f, -0.34236398f, -0.02491543f, -0.00326932f, 
    0.30712658f, -0.00095428f, 0.09136289f, -0.54269862f, -0.10847323f, -0.16573076f, -0.11141174f, -0.05641265f, 
    -0.27884319f, 0.44704258f, -0.06702086f, 0.27093637f, -0.04790246f, -0.73520392f, 0.29581404f, -0.15609349f, 
    0.07981101f, 0.09904256f, -0.07553638f, 0.18983790f, 0.14008391f, 0.33958840f, -0.18784277f, -0.34348556f, 
    0.02894613f, -0.05176716f, -0.13299809f, -0.19900689f, 0.07405489f, -0.11922018f, 0.00316684f, -0.00273001f, 
    -0.06063770f, -0.00215941f, 0.09310661f, -0.16692738f, 0.07288517f, -0.04803400f, -0.16942582f, -0.12146196f, 
    -0.04633435f, -0.13715558f, -0.03273851f, -0.14123110f, 0.05065919f, 0.07349970f, -0.00229992f, -0.14885205f, 
    0.04181055f, -0.16870028f, -0.03620848f, -0.00082205f, 0.05824928f, 0.00692400f, -0.11056115f, 0.12841541f, 
    -0.01157794f, -0.14890148f, -0.20913866f, -0.08843098f, 0.12145346f, 0.02326444f, -0.05924970f, -0.16472036f, 
    -0.08429873f, -0.11818816f, -0.01971678f, -0.13788028f, 0.11864338f, -0.10156769f, 0.13863961f, -0.20139726f, 
    0.06396998f, 0.02133303f, -0.05063483f, -0.07599225f, -0.02784490f, -0.08334655f, -0.08612817f, -0.11821251f, 
    -0.04420882f, 0.02874162f, -0.14159542f, -0.15311950f, -0.01968935f, 0.05390374f, -0.02742345f, 0.05936818f, 
    0.02364687f, -0.00804242f, 0.02410501f, 0.34759763f, 0.06462304f, -0.07747950f, -0.24715154f, -0.42684206f, 
    0.17425603f, -0.46065301f, 0.04230596f, 0.07629747f, 0.04052508f, 0.01786413f, -0.28403348f, -0.03461949f, 
    -0.01062562f, 0.53732342f, 0.05873990f, 0.36690864f, -0.32965022f, -0.30788475f, 0.22156772f, -0.09362772f, 
    0.11875001f, 0.07486951f, 0.28777179f, 0.16448233f, -0.10848974f, 0.14926384f, 0.21055083f, -0.18763478f, 
    -0.00151621f, 0.07310238f, 0.15764932f, -0.08644481f, 0.25677192f, 0.07153524f, -0.29407862f, -0.26259211f, 
    0.09226231f, -0.08910480f, 0.62787396f, -0.13364513f, 0.10538341f, 0.14965115f, 0.08981695f, 0.39686963f, 
    -0.33739644f, 0.34377977f, -0.03113494f, -0.11540724f, 0.28324628f, -0.28293055f, 0.22675402f, -0.36111593f, 
    0.02958824f, 0.14556468f, -0.13486190f, 0.23695646f, -0.09404379f, 0.07138067f, 0.08177862f, 0.42482427f, 
    -0.17914088f, 0.03266117f, 0.14347684f, 0.08299815f, 0.35900912f, 0.41609630f, 0.03370228f, 0.17067732f, 
    0.00498032f, 0.34072581f, -0.06658471f, -0.54796839f, -0.04441143f, 0.01869901f, 0.41023505f, 0.09587530f, 
    0.25907689f, -0.08386523f, -0.21865493f, -0.01728529f, -0.14620778f, -0.46257222f, 0.05512930f, -0.27021888f, 
    -0.00003918f, 0.08034501f, 0.00333292f, 0.04081393f, 0.01202435f, -0.36019135f, 0.18232839f, 0.76528740f, 
    0.14322120f, -0.01912220f, -0.05875849f, -0.05895457f, 0.31498343f, -0.00457426f, -0.12986353f, -0.29170689f, 
    0.20606482f, 0.04297076f, -0.34892014f, -0.27768552f, -0.03852919f, -0.06054610f, 0.15759839f, -0.31606251f, 
    -0.02796695f, -0.20495620f, 0.30552369f, 0.29695198f, -0.07566210f, -0.41168103f, 0.16681731f, -0.24554476f, 
    0.13374247f, -0.06703160f, -0.42390081f, 0.17628777f, 0.08772457f, 0.28164262f, -0.39419138f, -0.12526061f, 
    0.47841656f, -0.08131234f, -0.18865554f, 0.37766394f, 0.35518470f, -0.25799149f, 0.22260913f, -0.25143009f, 
    0.04025338f, -0.08750578f, -0.28949153f, 0.47192496f, 0.10398922f, -0.01778542f, 0.08133927f, 0.01516405f, 
    -0.01509039f, -0.16071172f, 0.45057023f, 0.03382695f, 0.09949281f, 0.48856694f, 0.25402933f, -0.17740783f, 
    0.06495401f, 0.16307729f, -0.32413840f, 0.21344070f, 0.19439948f, -0.04715528f, 0.19415881f, -0.45348874f, 
    -0.03933121f, 0.15097611f, 0.09501838f, -0.09889117f, 0.00253522f, 0.09972584f, -0.14438933f, -0.05255354f, 
    -0.15522863f, -0.06122713f, -0.09544344f, -0.15768354f, -0.03027126f, 0.15771420f, 0.09460988f, -0.14646928f, 
    -0.05533506f, -0.17426410f, 0.02074821f, -0.07973944f, -0.14925937f, -0.09557779f, 0.06235148f, -0.01863292f, 
    -0.16395697f, -0.06073336f, -0.09341072f, -0.11948765f, 0.04731468f, -0.15181449f, 0.05903165f, -0.11790717f, 
    0.10644539f, -0.06834736f, 0.50824702f, -0.41044250f, -0.10865740f, 0.09633908f, -0.00554805f, 0.52475828f, 
    -0.23835661f, 0.46307924f, 0.18729478f, -0.64864904f, 0.11895256f, 0.09652501f, 0.06879157f, -0.03644684f, 
    0.23583595f, 0.14964366f, 0.15032691f, -0.10146943f, -0.02453741f, -0.01961570f, -0.09410110f, 0.57182521f, 
    -0.16355270f, 0.04369292f, 0.26042476f, -0.08867616f, 0.05216067f, 0.29278532f, -0.03628400f, 0.00800578f, 
    0.26665187f, -0.06933266f, -0.32254940f, 0.25291297f, 0.41956928f, -0.02494385f, 0.23415880f, -0.24376859f, 
    0.18228677f, 0.08026679f, -0.33097199f, 0.35041288f, 0.03623768f, 0.01597410f, 0.29923671f, -0.06279128f, 
    0.13555591f, -0.37100011f, 0.10793930f, 0.17418139f, -0.12643957f, 0.49090168f, 0.03212517f, -0.20532857f, 
    0.02129177f, -0.12166378f, -0.02673214f, -0.12044646f, -0.17299852f, -0.32207772f, 0.23325895f, -0.10170119f, 
    0.38458937f, -0.09923020f, 0.11650176f, -0.10340136f, 0.08792539f, -0.02725107f, -0.49972108f, 0.24768701f, 
    0.26404652f, -0.01807199f, 0.17338909f, -0.25064105f, -0.08811083f, -0.08533037f, 0.00339468f, 0.19908366f, 
    -0.31534258f, -0.08574995f, 0.02869601f, -0.01527586f, 0.18835174f, -0.15558146f, 0.07940253f, -0.18883032f, 
    0.09681066f, 0.05196662f, -0.01798330f, 0.09238186f, 0.15610939f, -0.14682238f, -0.04309857f, -0.10168301f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00626775f, 0.10912400f, -0.17994224f, -0.11693861f, 0.00203592f, 0.00965461f, 0.31764415f, 0.28946364f, 
    -0.04848371f, -0.00601410f, 0.18806344f, -0.07458884f, 0.27449337f, -0.08822395f, 0.03824522f, -0.08202390f, 
    -0.36661944f, 0.12663577f, 0.14376384f, 0.03756035f, 0.22884874f, -0.09856766f, -0.05184574f, -0.15273872f, 
    0.16014032f, 0.13249978f, 0.30153629f, 0.45734334f, -0.06307068f, 0.00717492f, 0.24279746f, 0.15234180f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.20129359f, -0.00934144f, 0.03718410f, 0.01195024f, 0.21582946f, 0.57384276f, -0.32752773f, -0.54775214f, 
    -0.16414069f, -0.02627081f, -0.00400715f, -0.13847113f, 0.47804070f, 0.08649838f, 0.14420123f, -0.29206282f, 
    -0.08038761f, 0.00065151f, 0.34980577f, 0.14138091f, -0.22810851f, -0.11852599f, -0.11536542f, -0.39917523f, 
    -0.07854769f, -0.12283105f, -0.50533962f, 0.05608443f, -0.07487255f, 0.15462816f, -0.04395916f, 0.17295806f, 
    0.07546198f, -0.41472259f, -0.05478643f, -0.05704682f, -0.17162608f, 0.21037970f, -0.23268431f, 0.13915199f, 
    -0.06955089f, -0.03292558f, 0.39005101f, -0.31464982f, -0.10776574f, 0.12056597f, -0.06383562f, -0.58005929f, 
    -0.00754984f, -0.14530589f, 0.26174805f, 0.12695237f, -0.22573516f, 0.05513947f, -0.08944068f, -0.14561272f, 
    0.09950392f, 0.08940155f, 0.21888183f, 0.15448983f, -0.01536044f, 0.20042229f, 0.02734781f, 0.01279947f, 
    -0.22426412f, 0.23435511f, -0.05671586f, -0.00099446f, 0.31725311f, 0.25674108f, 0.48554909f, 0.27804330f, 
    -0.17443512f, 0.15229501f, -0.51609629f, -0.41409144f, -0.16270860f, -0.07691976f, 0.03026373f, -0.38916296f, 
    -0.51990467f, 0.50211430f, -0.13201888f, 0.21730895f, -0.36104819f, -0.12980057f, 0.01646400f, -0.12376134f, 
    -0.19270100f, -0.27847224f, -0.20925972f, 0.34157446f, 0.06395321f, -0.00805610f, 0.24074294f, -0.14198591f, 
    -0.19962576f, 0.40602154f, 0.00753961f, 0.01245959f, -0.00282912f, 0.29247886f, 0.25436816f, -0.16786134f, 
    0.05820036f, 0.22774185f, -0.07125475f, 0.05131529f, 0.03506475f, -0.17032306f, -0.16525969f, -0.12151533f, 
    -0.22649994f, 0.13547090f, 0.21226412f, -0.30589151f, -0.18549828f, -0.20501032f, -0.02741916f, -0.22562750f, 
    0.25819182f, -0.73249763f, 0.24564999f, 0.35312614f, -0.05741590f, -0.28136337f, -0.16531429f, 0.13446158f, 
    -0.04374103f, 0.13155565f, 0.04728261f, -0.52349681f, -0.18027943f, -0.17623442f, 0.25673318f, 0.37525535f, 
    0.10686075f, 0.29804373f, 0.26060334f, -0.03670403f, 0.04888420f, 0.03393470f, 0.06818000f, -0.51473570f, 
    -0.26736027f, 0.10975728f, -0.10370853f, 0.19120720f, -0.31454667f, 0.09167559f, 0.13854800f, -0.03774422f, 
    0.01382980f, 0.63040310f, -0.11985580f, 0.26996568f, -0.02470272f, -0.36186069f, 0.36473191f, 0.03623175f, 
    -0.10521807f, 0.08645435f, 0.03915526f, 0.26907298f, 0.08139528f, -0.39632919f, 0.20208596f, 0.24432500f, 
    0.16389312f, -0.00470244f, 0.40928233f, -0.01550206f, 0.04058961f, 0.01522125f, 0.09629488f, 0.14008100f, 
    0.12081595f, -0.07231382f, -0.08241357f, -0.15432152f, 0.20438167f, -0.01920461f, -0.14518905f, 0.28432360f, 
    0.08343439f, 0.20205452f, 0.06614325f, 0.13313943f, -0.01941931f, -0.30768457f, 0.00910492f, -0.07542967f, 
    0.38754117f, -0.33150142f, -0.03265144f, -0.77725089f, 0.12652844f, -0.23359171f, 0.07504176f, 0.09608310f, 
    -0.05229341f, 0.15752269f, -0.06957442f, -0.15225321f, 0.37303972f, -0.04602552f, 0.13359824f, -0.67149496f, 
    -0.30295306f, -0.07204368f, 0.02248028f, 0.08380698f, -0.31944612f, -0.02478784f, -0.17481099f, -0.15851796f, 
    0.15559411f, 0.54182410f, -0.02499140f, 0.00748327f, -0.16045089f, -0.24716440f, 0.29590929f, 0.04994742f, 
    0.20305917f, -0.30749622f, 0.16418456f, -0.54715776f, 0.11858021f, -0.31198129f, -0.18399101f, 0.17016548f, 
    0.07679668f, -0.14648396f, -0.02066512f, 0.28010944f, 0.00564005f, -0.02935905f, 0.08171608f, -0.01471598f, 
    0.07165524f, 0.02551792f, -0.37609899f, -0.03396770f, 0.06020783f, 0.05972963f, -0.16107684f, 0.13155566f, 
    -0.02069641f, 0.23320481f, 0.11458851f, -0.03168228f, -0.01104150f, -0.28226224f, -0.01167413f, 0.00329349f, 
    -0.02024922f, -0.16419411f, -0.14614342f, 0.08377869f, 0.00883768f, 0.02494128f, 0.06004789f, -0.12671515f, 
    0.05379014f, 0.04145743f, -0.00861756f, 0.15528239f, 0.07109156f, 0.16178590f, -0.01916181f, -0.05175580f, 
    -0.12141149f, -0.02868743f, 0.05317539f, -0.14926916f, 0.11539213f, 0.06124505f, -0.06370418f, 0.00175734f, 
    -0.17887729f, -0.14245728f, -0.11827915f, 0.02624454f, 0.04579641f, -0.15050296f, -0.14269927f, -0.15706301f, 
    -0.04014793f, 0.17298019f, -0.09770032f, -0.11422437f, 0.14849469f, 0.28617954f, -0.39560616f, -0.06609389f, 
    0.02326332f, 0.03931663f, 0.08038580f, 0.32841450f, 0.04996160f, -0.00326301f, -0.15128770f, 0.62920952f, 
    -0.16030453f, -0.09067809f, 0.30388227f, -0.31062010f, 0.50381923f, -0.15496418f, 0.16732071f, 0.13634780f, 
    0.60581070f, -0.48656768f, 0.02064335f, 0.24642244f, 0.11982179f, -0.26829615f, -0.15693666f, 0.53979075f, 
    -0.10192030f, 0.20853510f, -0.08589654f, -0.28046232f, 0.13045274f, 0.11659473f, 0.10423719f, -0.18353871f, 
    -0.11103865f, 0.19177258f, 0.13604638f, -0.06857976f, -0.14019324f, 0.06777215f, -0.06747336f, 0.17546636f, 
    0.06293449f, 0.42459545f, -0.02582991f, 0.21913259f, -0.51222545f, -0.04200808f, 0.09298709f, -0.21478052f, 
    0.29889771f, -0.08930628f, -0.40895894f, -0.11184736f, -0.07510765f, 0.09098399f, 0.10569085f, 0.28456432f, 
    -0.08507747f, -0.13472071f, -0.13612355f, -0.02774453f, -0.16423807f, -0.02542952f, -0.13927700f, -0.12707570f, 
    0.12142709f, -0.15518308f, 0.05680332f, -0.00434272f, -0.15980564f, 0.13151723f, 0.11621054f, -0.08765136f, 
    -0.15194313f, -0.06063568f, -0.04735873f, -0.18943901f, 0.09421892f, -0.14318840f, 0.00754081f, -0.07961388f, 
    0.11876666f, 0.04582081f, -0.08358247f, 0.09108605f, -0.15878016f, 0.01701152f, 0.03585362f, 0.09212776f, 
    0.14329739f, -0.23259081f, 0.00782801f, -0.22438949f, 0.28770187f, 0.22588752f, 0.06157458f, 0.39196837f, 
    0.17983937f, 0.16799290f, 0.13055417f, -0.32800370f, -0.29591879f, -0.14908023f, 0.12877856f, 0.19046728f, 
    0.05584714f, 0.32004496f, -0.09772173f, -0.00661655f, -0.07893398f, -0.11142407f, 0.08268993f, -0.09889629f, 
    -0.46113113f, -0.18964368f, 0.12764174f, 0.26604104f, 0.00885287f, 0.24515389f, 0.22885451f, -0.09956377f, 
    -0.10626145f, -0.60939151f, -0.19107910f, -0.24728434f, 0.03954128f, -0.11910618f, -0.04802713f, 0.39643008f, 
    -0.15773137f, 0.16013421f, 0.40556127f, -0.03124064f, 0.33426932f, -0.11517558f, 0.16218749f, 0.61302781f, 
    0.30502382f, -0.03537273f, -0.10766282f, -0.12380665f, 0.37294194f, -0.16081105f, 0.17699289f, 0.43647349f, 
    0.22902259f, -0.31859577f, 0.16711652f, 0.20045057f, -0.16738616f, -0.51124042f, 0.22858138f, -0.07937233f, 
    0.00794424f, 0.06495103f, 0.17436229f, 0.36084640f, 0.00567986f, 0.00742002f, 0.28387919f, -0.39556399f, 
    -0.00880859f, -0.15279879f, -0.17527500f, 0.11999133f, 0.05964857f, 0.11069413f, 0.03182093f, -0.71181267f, 
    -0.15792230f, -0.24429628f, 0.35179383f, -0.09869551f, 0.35352814f, -0.11513609f, 0.04286327f, -0.61200649f, 
    -0.09379051f, -0.08320215f, 0.50261378f, 0.09590270f, -0.15262578f, 0.04333339f, 0.07227718f, 0.38703096f, 
    -0.27072939f, 0.10667913f, 0.11786544f, 0.08225276f, 0.24381217f, -0.33621109f, -0.31169701f, 0.17267460f, 
    -0.08267470f, -0.09664367f, -0.14690894f, -0.10959239f, -0.14896384f, 0.08414388f, 0.14802125f, 0.21878718f, 
    -0.03734076f, 0.25609848f, -0.26731169f, -0.33667943f, 0.16436175f, 0.01836732f, 0.00638519f, -0.04233944f, 
    0.07269736f, 0.08996566f, -0.09589583f, -0.18858452f, -0.13323608f, 0.09803396f, -0.30700630f, -0.33126900f, 
    0.18278915f, 0.13537745f, 0.02407693f, 0.26008856f, -0.13007200f, -0.05744439f, 0.08052162f, 0.19173026f, 
    0.01870194f, -0.11076441f, -0.04811782f, 0.25518245f, -0.27230433f, 0.10256423f, -0.03142121f, -0.00047218f, 
    -0.25160453f, -0.27084947f, 0.27509019f, 0.17628422f, 0.41543379f, -0.02668576f, 0.19834664f, 0.21076886f, 
    -0.05941600f, -0.08856300f, 0.47948223f, -0.00699665f, -0.02435245f, 0.19061844f, -0.03184802f, 0.47654453f, 
    0.06626243f, -0.31275219f, -0.15371081f, -0.02011294f, -0.05524138f, 0.41219756f, -0.52554965f, -0.07620749f, 
    -0.03806870f, 0.14189093f, 0.20299041f, 0.14290039f, 0.41614091f, 0.09862611f, -0.00728475f, 0.59325689f, 
    0.02731821f, 0.09038737f, -0.01683471f, -0.14189604f, 0.37561619f, -0.10907812f, 0.08194516f, 0.15777858f, 
    0.44337741f, -0.35178503f, 0.23325109f, 0.17420797f, 0.13220984f, -0.13798711f, -0.07964189f, 0.14910358f, 
    0.29725590f, -0.22131696f, -0.11327628f, -0.28739756f, -0.11366022f, -0.05001347f, 0.07824023f, -0.04720067f, 
    -0.05901082f, 0.09133095f, 0.41216201f, 0.06059050f, 0.50049269f, -0.16313216f, -0.00750727f, -0.03782386f, 
    0.00817247f, -0.15493903f, 0.24115708f, 0.13180079f, 0.03231385f, 0.18627042f, 0.12640786f, 0.04020620f, 
    -0.07764554f, 0.24355081f, 0.29822659f, 0.08110210f, -0.12659790f, -0.17448916f, 0.31321633f, -0.11127090f, 
    -0.10255769f, 0.02595991f, -0.16823336f, -0.16755247f, -0.21358360f, -0.21251538f, -0.00022167f, -0.07573570f, 
    0.06266433f, 0.00920887f, 0.02265058f, 0.06892452f, -0.04035769f, -0.07327590f, -0.11065903f, 0.07308940f, 
    0.02071238f, -0.12116110f, 0.04243859f, 0.03564728f, 0.06206329f, -0.12831235f, 0.14622463f, -0.19006260f, 
    0.06582473f, -0.15788987f, -0.07389574f, 0.02324124f, 0.02246859f, 0.07393813f, -0.15566336f, -0.15848216f, 
    -0.23568659f, -0.07271286f, -0.14586881f, 0.26259741f, 0.07143087f, -0.05353329f, -0.00335146f, 0.27036169f, 
    0.15455568f, 0.33361340f, -0.02982549f, -0.00812827f, -0.15631421f, -0.04275313f, 0.07945629f, 0.24866986f, 
    -0.08538657f, 0.51139534f, -0.24726073f, -0.25211528f, 0.27094391f, 0.03474243f, -0.05050524f, 0.42392719f, 
    -0.03775389f, -0.55866355f, 0.08852010f, 0.26055801f, -0.16892512f, -0.45847166f, 0.20628816f, 0.20864461f, 
    -0.12799476f, 0.41666690f, 0.18897636f, 0.20696349f, 0.29170793f, 0.42311442f, -0.01670638f, -0.19766605f, 
    -0.08582308f, 0.03075577f, -0.34472278f, -0.26935056f, 0.27909666f, 0.02377929f, -0.16614388f, 0.40197247f, 
    -0.52962130f, 0.34914091f, 0.13525341f, -0.32022348f, 0.08035076f, 0.08659228f, 0.05091542f, 0.10138067f, 
    -0.10407173f, -0.74636847f, -0.06355584f, 0.12302960f, -0.02785209f, -0.11523554f, 0.05003765f, -0.06868267f, 
    0.04584261f, -0.11046749f, 0.16197784f, 0.07984651f, -0.10608906f, -0.18983281f, 0.02394322f, 0.04827983f, 
    0.14327985f, -0.08091206f, -0.06701496f, 0.00441318f, 0.12339003f, 0.03638719f, 0.04062103f, 0.14411232f, 
    0.00654046f, -0.13860881f, -0.15251923f, 0.04306384f, -0.14251605f, 0.10323855f, -0.05175487f, -0.06010576f, 
    0.15078408f, -0.05312889f, -0.13034214f, 0.00195045f, -0.09405954f, -0.05775059f, -0.16113928f, -0.14879754f, 
    0.22837514f, -0.38807136f, 0.09100153f, 0.35006124f, -0.39981583f, 0.12422650f, -0.17701796f, 0.04415028f, 
    -0.09667485f, -0.08099771f, 0.31440374f, -0.00470547f, -0.03025203f, -0.09840553f, 0.08282958f, 0.16179535f, 
    -0.17983425f, -0.25288865f, 0.22119117f, 0.05251028f, 0.14720568f, -0.01198693f, -0.13382822f, 0.02840319f, 
    0.07836762f, -0.42232591f, 0.37189183f, 0.31600413f, 0.02920102f, 0.04903793f, 0.31798726f, -0.00099261f, 
    -0.12341744f, -0.07059652f, -0.03820006f, 0.06845623f, 0.19382009f, 0.40372851f, 0.08445045f, -0.04193448f, 
    -0.12701988f, 0.09958801f, -0.17878182f, 0.09728724f, -0.25316182f, -0.01051551f, 0.18339542f, -0.31445292f, 
    -0.45812139f, -0.26842472f, 0.39884129f, 0.04334768f, 0.27354923f, 0.09353693f, 0.20854461f, -0.05793559f, 
    0.53611672f, 0.06062006f, 0.17342202f, -0.02309151f, -0.12819149f, 0.25342840f, -0.05817200f, 0.44732735f, 
    0.22760107f, -0.50378066f, -0.07001082f, 0.12849236f, 0.04155295f, 0.13778329f, -0.02386285f, -0.22334540f, 
    0.01061789f, 0.01367901f, 0.18374436f, -0.34473950f, 0.39010948f, 0.13380124f, 0.15089485f, 0.42540374f, 
    -0.46483886f, 0.14167577f, -0.11963168f, 0.03447115f, -0.17007528f, 0.03641270f, 0.13422717f, -0.03250738f, 
    -0.22056371f, -0.63250929f, 0.31376737f, 0.36010993f, 0.03163419f, 0.08057440f, 0.12623532f, -0.48515865f, 
    0.07141440f, 0.10678054f, -0.03356037f, -0.38630891f, 0.32746154f, -0.06155957f, 0.15930088f, 0.44810727f, 
    -0.07115752f, 0.32002521f, -0.01568285f, 0.06678894f, -0.21948303f, 0.09682058f, -0.02387375f, 0.16922371f, 
    0.07730693f, 0.16895792f, -0.20226438f, -0.04704269f, -0.14194475f, 0.02838592f, 0.01917873f, 0.05430422f, 
    0.25929332f, 0.07663582f, -0.27323416f, -0.13625190f, -0.00637685f, 0.26479924f, -0.11298952f, 0.04697388f, 
    0.17563944f, -0.65718341f, -0.19107866f, -0.19299021f, -0.39630169f, 0.11888772f, -0.13773629f, 0.07180430f, 
    0.05929852f, 0.08322217f, 0.47501543f, -0.07669438f, 0.56377286f, -0.14044429f, 0.14904013f, 0.13915232f, 
    -0.38366804f, -0.20843536f, 0.21677969f, 0.15041749f, -0.02689342f, -0.08668142f, -0.12730879f, 0.21175018f, 
    0.03768932f, -0.29023066f, 0.32435358f, 0.30868489f, -0.14751942f, -0.51767665f, 0.13360213f, 0.26953614f, 
    0.22647978f, -0.22564086f, -0.06150896f, 0.09008996f, -0.15674226f, -0.16526833f, -0.23164280f, 0.04834357f, 
    -0.13853787f, -0.05319473f, -0.10709187f, 0.04206690f, -0.00001716f, -0.10692221f, 0.01242811f, 0.15526664f, 
    0.11723283f, -0.03899027f, -0.21218365f, -0.07439263f, 0.28212026f, 0.11257786f, -0.00982064f, 0.15924402f, 
    -0.18061671f, -0.12315733f, 0.19387826f, 0.03498024f, 0.00845063f, -0.22935702f, 0.14137806f, 0.00911203f, 
    0.02264138f, 0.02541233f, 0.12994663f, 0.09913532f, -0.18696503f, 0.06688441f, -0.10255575f, -0.01805413f, 
    0.16577391f, -0.07273599f, -0.11398014f, -0.18070270f, -0.08130275f, -0.08370277f, -0.11773931f, 0.06369637f, 
    0.05561672f, -0.04012264f, -0.11295772f, 0.01912946f, -0.11640836f, 0.08017515f, -0.03494191f, -0.04632151f, 
    -0.20715669f, -0.17450117f, -0.17841379f, -0.06130644f, 0.02394610f, 0.00335882f, -0.26926219f, -0.16491787f, 
    0.16533683f, -0.13793387f, 0.01319967f, -0.38590637f, 0.22575530f, -0.36280432f, -0.00798519f, 0.30733943f, 
    0.15236941f, -0.01072277f, -0.07136254f, -0.05047750f, -0.13454494f, 0.09503438f, 0.15072349f, -0.01963635f, 
    -0.50620222f, 0.25027856f, -0.35317928f, 0.21615030f, 0.10595485f, -0.04738685f, 0.10985275f, 0.11451203f, 
    0.09649642f, 0.54976791f, -0.12516004f, 0.06555431f, 0.03573284f, 0.27287379f, -0.11302370f, -0.28690991f, 
    0.37619120f, -0.08806594f, 0.08909617f, 0.01817813f, -0.18170148f, -0.18873923f, 0.10500258f, 0.01827372f, 
    -0.09994254f, -0.00595989f, 0.41368154f, 0.08384439f, 0.22300903f, 0.12392031f, -0.11559851f, -0.05179084f, 
    -0.22170681f, -0.29960579f, 0.05149814f, 0.35187414f, 0.32427320f, -0.14404146f, 0.07694938f, -0.06686874f, 
    -0.09720849f, 0.43035823f, 0.29080632f, 0.26577857f, -0.15467225f, -0.09174112f, 0.06673555f, 0.12031464f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.08012717f, -0.09689864f, 0.15243015f, -0.11510541f, 0.20062281f, 0.14478615f, 0.21006882f, -0.07947209f, 
    -0.01679805f, 0.02116745f, -0.08355011f, 0.03786566f, 0.21186590f, 0.16910756f, 0.18697351f, -0.03751276f, 
    0.07336374f, 0.03365064f, 0.30671188f, -0.16140510f, 0.22485659f, -0.02899693f, -0.17480186f, 0.22252709f, 
    0.22720949f, 0.27771991f, -0.12847872f, 0.07844200f, -0.15022273f, -0.00762017f, 0.26480600f, 0.52362907f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.29754907f, 0.07261262f, -0.18752597f, -0.45116678f, -0.23822601f, 0.16666554f, -0.42921358f, -0.07632282f, 
    -0.08976857f, 0.24782191f, 0.07619407f, -0.14935388f, -0.12078703f, 0.10073604f, -0.08918329f, 0.54548734f, 
    -0.15781868f, 0.20521460f, -0.62027234f, -0.05067538f, 0.15986441f, 0.11457960f, 0.10376617f, -0.63118774f, 
    0.01030749f, -0.49349922f, 0.30682606f, -0.68162966f, -0.22166051f, 0.03818119f, 0.31229174f, -0.54688185f, 
    0.23691168f, 0.07335956f, -0.07825589f, -0.53974563f, 0.32089043f, 0.26368657f, 0.51601970f, 0.29730132f, 
    -0.09004688f, -0.47776964f, 0.09273329f, 0.04038918f, -0.05498420f, 0.03648342f, -0.27730507f, -0.30331433f, 
    -0.19413131f, -0.38570935f, 0.26258421f, -0.06922326f, -0.17825407f, -0.12120783f, -0.03432961f, -0.43241695f, 
    -0.03238714f, -0.50677693f, 0.17387722f, -0.34908408f, 0.04351380f, 0.04627223f, 0.44522899f, 0.22016443f, 
    -0.50330436f, 0.21125109f, -0.78600091f, -0.16800696f, 0.10082684f, 0.16981173f, 0.30836314f, -0.18335848f, 
    0.05188213f, 0.03816862f, 0.24913941f, -0.15071405f, -0.49844813f, 0.14141968f, 0.09067706f, -0.10040513f, 
    0.18314387f, 0.05695397f, 0.19886640f, 0.12129894f, -0.40703559f, -0.92535871f, 0.07686187f, 0.28249282f, 
    0.01737976f, 0.05628132f, -0.13499515f, 0.51556152f, 0.11304189f, 0.10927181f, -0.74930203f, 0.23184299f, 
    -0.31640214f, -0.45921680f, -0.60800964f, -0.30416319f, -0.24222566f, 0.11243349f, -0.53066272f, 0.11794861f, 
    0.15236467f, 0.16875865f, -0.38176936f, 0.10637542f, 0.05987371f, 0.35598043f, -0.63809067f, -0.26556683f, 
    0.16990238f, 0.20719987f, 0.07258839f, 0.11939180f, 0.08105194f, 0.06285396f, 0.11521095f, 0.19828786f, 
    -0.21806993f, 0.33905479f, -0.07084299f, 0.20126927f, 0.37174433f, -0.26732838f, -0.08657549f, 0.18847217f, 
    0.12371990f, -0.49250227f, 0.07699325f, 0.25617680f, 0.07424248f, 0.10095047f, -0.25021207f, -0.23383626f, 
    0.09065760f, 0.14033341f, 0.14155760f, -0.13342151f, 0.12001816f, 0.18064813f, -0.16018550f, -0.32210019f, 
    -0.23568369f, 0.04162818f, -0.26510942f, 0.09288132f, 0.26173148f, 0.13951088f, -0.12211414f, -0.13538532f, 
    -0.19433501f, -0.03208473f, 0.12372262f, 0.07072951f, -0.09813042f, -0.25541887f, -0.34431982f, -0.37128672f, 
    0.13674328f, 0.19121623f, 0.01749894f, -0.10329358f, 0.17356668f, -0.17300680f, 0.08534560f, -0.35398981f, 
    0.05421820f, 0.03012574f, -0.03531076f, -0.11338461f, 0.00765444f, 0.08265272f, -0.43444058f, -0.19198823f, 
    0.19544306f, -0.06206040f, -0.03748938f, -0.09376981f, 0.14795613f, -0.64218074f, 0.18041658f, 0.11621843f, 
    0.11984031f, -0.43907863f, 0.18723239f, 0.17057355f, -0.19458549f, -0.10814267f, 0.00224335f, -0.02175204f, 
    0.29986772f, 0.10381588f, -0.82290155f, 0.13420831f, -0.83826381f, -0.66394013f, 0.00482491f, 0.14139454f, 
    -0.00465783f, 0.24325122f, -0.39607415f, -0.17390537f, -0.94202036f, -1.03365839f, 0.25220701f, 0.09119873f, 
    0.25578445f, 0.05815827f, 0.02198433f, -0.17720520f, -1.36930668f, -0.12029339f, 0.12733798f, 0.27513337f, 
    0.25511056f, 0.16849309f, -0.17054898f, 0.35766321f, -0.07595735f, -0.08714949f, -0.77907008f, 0.21081075f, 
    0.12099182f, -0.42633629f, 0.36718294f, 0.37775376f, -0.30951107f, -0.56563771f, -0.16104577f, -0.01067370f, 
    -0.04832692f, -0.09663989f, 0.15064429f, -0.04749275f, 0.20159039f, -0.64585322f, -0.20168705f, -0.20434934f, 
    -0.35202739f, -0.16780601f, -0.39378059f, 0.14647746f, -0.27787387f, 0.53643531f, 0.14884645f, -0.51652759f, 
    -0.08777426f, 0.28114742f, 0.11597225f, -0.62454736f, 0.00985768f, -0.00134977f, 0.02307710f, -0.18529910f, 
    -0.29885924f, 0.15719891f, 0.24318869f, -0.55436045f, -0.03412980f, 0.05309569f, -0.25500077f, -0.15535797f, 
    -0.18028425f, -0.77747303f, -0.45839041f, 0.10536840f, 0.29802209f, -0.70499843f, 0.17892069f, -0.19457123f, 
    0.38897410f, -0.86025864f, 0.07085840f, -0.11915194f, -0.21453959f, -0.34804124f, -0.02820594f, 0.21914841f, 
    0.07269718f, 0.11305992f, -0.11886523f, -0.59719592f, -0.01354641f, 0.00212108f, 0.30382103f, 0.40647072f, 
    -0.00861781f, -0.26649138f, -0.09034532f, 0.21875960f, -0.17859156f, 0.21567778f, -0.32933587f, 0.00492690f, 
    -0.06304347f, 0.30478683f, -0.05072391f, -0.05144041f, -0.28122869f, -0.18104929f, 0.09038159f, -0.23417529f, 
    0.22891420f, 0.10449573f, -0.04550330f, -0.13942106f, 0.24476565f, 0.14249796f, -0.11381656f, -0.01825151f, 
    0.29570588f, -0.65711677f, -0.59444177f, -0.03217103f, -0.04740596f, -0.09802949f, -1.03154480f, 0.17113639f, 
    -0.67057139f, -0.09916088f, 0.43693137f, -0.14556287f, 0.30613270f, 0.09180314f, 0.18200353f, 0.16519557f, 
    0.01262430f, -0.83377320f, -0.38685226f, 0.01583082f, 0.02073628f, -0.03624962f, -0.34553289f, -0.18484020f, 
    -0.38139683f, -0.46073171f, 0.17390697f, -0.02132002f, 0.29631573f, 0.21778511f, 0.09571039f, 0.03320138f, 
    -0.93201500f, 0.45739725f, -0.22399303f, 0.20056036f, 0.06108661f, 0.07766218f, -0.04715167f, 0.04822654f, 
    0.34616527f, 0.31827018f, -0.02916491f, 0.00917143f, -0.39464685f, -0.46318939f, 0.06253458f, -0.04766529f, 
    -0.15329812f, -0.15136324f, -0.15485141f, 0.02105168f, 0.09108599f, 0.01355938f, 0.00330657f, 0.02671884f, 
    -0.29417890f, -0.11480497f, 0.13317810f, 0.12474113f, -0.08588026f, 0.22344290f, -0.13972558f, 0.22803609f, 
    -0.09829804f, 0.56224406f, -0.66375250f, 0.14150898f, -0.31300148f, 0.05706165f, -0.58362401f, -0.11528526f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.42343017f, 0.18457732f, -0.15449424f, -0.04868881f, -0.30142781f, -0.09938087f, 0.03539709f, -0.13123736f, 
    0.30119047f, 0.34296754f, 0.21636626f, -0.15867788f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
