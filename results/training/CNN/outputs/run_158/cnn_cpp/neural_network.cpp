#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.02016927f, -0.74625552f, 0.52159154f, 0.09850794f, -0.29199770f, 0.11995801f, 0.00065473f, -0.14759023f, 
    0.02977083f, 0.03917756f, -0.02941490f, -0.28355813f, 0.09763115f, -0.55820131f, -0.34644938f, -0.45208174f, 
    0.09448454f, 0.13878545f, -0.25556085f, -0.53009367f, -0.57044679f, 0.19619562f, -0.57169938f, 0.15256658f, 
    -0.13519581f, 0.03937826f, -0.27519566f, 0.40133816f, -0.08547479f, 0.14348461f, -0.46743754f, -0.76282030f, 
    -0.38754562f, 0.00201027f, 0.00745618f, -0.04794186f, -0.37749305f, -0.28355426f, -0.27911931f, 0.42045715f, 
    0.11914859f, 0.62288100f, -0.34647271f, -0.14051370f, -0.47876674f, 0.52454376f, 0.43480486f, 0.50319928f, 
    0.34818342f, -0.56577784f, 0.33422858f, 0.29007879f, -0.20906790f, 0.10127432f, -0.59393722f, 0.34079814f, 
    0.11108032f, -0.42616880f, -0.29809600f, -0.22449580f, -0.23955290f, 0.40019509f, -0.29412076f, 0.22641382f, 
    0.09938189f, 0.09996044f, -0.12682982f, -0.28319672f, 0.77826405f, 0.01863098f, 0.25265443f, -0.34625068f, 
    -0.04199178f, 0.54338574f, -0.54586613f, -0.48294282f, -0.50979042f, -0.17671388f, 0.16890498f, -0.34357432f, 
    -0.17049137f, -0.35139814f, -0.01000953f, -0.46186456f, -0.02825790f, 0.47081122f, 0.29729128f, 0.51050961f, 
    0.02452935f, 0.13972908f, 0.36613032f, 0.38497126f, -0.32697594f, 0.27325696f, -0.42549476f, -0.12763019f, 
    -0.24656117f, -0.29283187f, 0.20490938f, -0.41994643f, -0.34958044f, -0.49509752f, -0.37022746f, -0.19467051f, 
    0.24059528f, -0.09525546f, 0.09537564f, 0.03267674f, 0.73164201f, -0.57233256f, -0.51020747f, 0.30901068f, 
    -0.26983854f, -0.27309594f, 0.07328651f, -0.00164556f, 0.26681161f, 0.05702349f, 0.80394018f, -0.59535044f, 
    0.45301023f, 0.34028074f, -0.37593356f, 0.22146714f, 0.18962908f, 0.06253751f, 0.02097927f, -0.58607584f, 
    -0.61711574f, -0.23969358f, 0.42739961f, 0.25349846f, -0.25814015f, 0.26186475f, 0.16654812f, 0.54986596f, 
    0.21491295f, 0.42087308f, 0.23011202f, 0.36284539f, -0.17226703f, 0.38594913f, 0.52253115f, 0.27063632f, 
    -0.84768242f, 0.45375121f, 0.60761756f, 0.54818416f, 0.45431235f, 0.25168756f, -0.11127592f, -0.04297898f, 
    -0.14810334f, -0.51834100f, -0.50616765f, -0.43209979f, 0.34567964f, 0.33810014f, -0.10808560f, -0.03734770f, 
    -0.26959950f, -0.33272016f, 0.23478432f, -0.11248551f, -0.38696355f, -0.57374126f, -0.19359283f, 0.03830341f, 
    0.34210411f, 0.55965829f, -0.01423808f, 0.14571284f, -0.79003358f, -0.16802849f, -0.69939005f, 0.10306978f, 
    -0.17221680f, -0.07805079f, 0.21536356f, -0.03992022f, 0.73849463f, 0.29301342f, 0.33387676f, 0.26861265f, 
    0.34747335f, -0.22974820f, -0.41028431f, 0.27542374f, 0.08088213f, 0.20753141f, 0.35220942f, -0.20145826f, 
    0.37638369f, 0.06409360f, 0.23928186f, -0.59305972f, -0.34431145f, 0.30496746f, -0.12041659f, 0.24275999f, 
    0.67594522f, 0.60849321f, 0.12802966f, -0.57681799f, 0.16517510f, 0.23425035f, 0.22975132f, -0.48834273f, 
    -0.46351716f, -0.19657917f, 0.52873594f, 0.45121005f, 0.50790083f, 0.27497175f, 0.12631209f, 0.42226201f, 
    -0.09432650f, 0.32767612f, -0.17581651f, -0.15365687f, -0.57573998f, -0.52061808f, -0.09147494f, 0.20440881f, 
    0.58489680f, -0.28678146f, 0.41333637f, -0.20626231f, 0.41560033f, -0.05488589f, -0.36255246f, -0.09753762f, 
    -0.51382804f, -0.51536185f, 0.22739160f, 0.36125737f, 0.05586753f, -0.73229349f, 0.48136297f, -0.57745630f, 
    0.09405769f, -0.01092885f, -0.07244803f, -0.77391750f, 0.50899661f, -0.32693443f, 0.42404529f, -0.23026559f, 
    -0.46959829f, -0.07073259f, 0.19529991f, -0.26528031f, -0.50324500f, -0.10654175f, 0.45733207f, 0.05338272f, 
    -0.04411235f, -0.60972065f, 0.40265933f, 0.24697027f, -0.00868319f, 0.45918384f, 0.51909775f, 0.52871537f, 
    -0.36009687f, -0.27891707f, -0.13191032f, -0.35620219f, -0.11672115f, 0.00113105f, -0.44666687f, -0.29680407f, 
    0.15368855f, 0.07777880f, 0.71631545f, -0.50828767f, -0.00167489f, -0.13250509f, -0.20026284f, 0.68861669f, 
    -0.39131504f, -0.18491209f, -0.23061483f, 0.21862571f, 0.44005817f, -0.31040242f, -0.22699060f, -0.39802185f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00615920f, -0.29514313f, 0.21246241f, 0.06641074f, -0.20357080f, 0.01754218f, -0.03318543f, 0.09922449f, 
    0.12788510f, 0.18346871f, -0.00659780f, 0.12666534f, 0.06846006f, -0.17275044f, -0.13015917f, 0.04232701f, 
    -0.07021647f, -0.21467426f, -0.23167406f, -0.16254987f, 0.12984511f, -0.41339427f, -0.03012758f, 0.03931915f, 
    -0.04812608f, -0.29642028f, 0.23835003f, -0.02333516f, -0.08840945f, 0.07569256f, -0.25463736f, -0.21959276f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.04272198f, 0.01414071f, -0.03205494f, 0.02391614f, 0.02797792f, 0.04033918f, -0.04651259f, 0.03914260f, 
    0.02952122f, -0.04903766f, -0.04174692f, -0.04384421f, 0.03896518f, 0.01630150f, 0.03266160f, -0.03525327f, 
    -0.01289460f, 0.03184522f, -0.02969525f, -0.01448189f, -0.02527397f, -0.02289070f, -0.02196858f, 0.03519206f, 
    -0.04418024f, 0.01965403f, -0.03869704f, 0.04124262f, 0.01293947f, -0.04694176f, -0.05355630f, 0.02451501f, 
    -0.03854985f, 0.02629503f, -0.03612666f, -0.06147718f, 0.01845913f, 0.01807374f, 0.04681277f, -0.00490410f, 
    -0.03050051f, -0.06403401f, -0.01080966f, -0.04992167f, -0.01734285f, -0.04007582f, 0.03726314f, -0.06169139f, 
    -0.06412861f, -0.00041653f, 0.04112865f, -0.05826020f, -0.02637346f, -0.02788517f, 0.04927457f, 0.03315513f, 
    0.01146865f, 0.02561991f, 0.00473555f, -0.05643037f, -0.05457593f, 0.03308788f, -0.06415235f, -0.06416836f, 
    -0.05026092f, -0.01855866f, 0.03468735f, 0.02323630f, -0.05245161f, -0.01372276f, -0.05552733f, -0.05650706f, 
    -0.02331288f, -0.06138883f, -0.00731876f, -0.05480783f, 0.01736797f, 0.00353481f, 0.03228490f, -0.04238956f, 
    0.00773955f, 0.05234875f, 0.00149530f, 0.01906574f, 0.01453823f, -0.02800577f, 0.00782944f, 0.01016851f, 
    -0.05335892f, -0.04050916f, -0.00434175f, 0.02882948f, -0.04102036f, -0.03019218f, 0.03410513f, 0.01125150f, 
    0.04446433f, -0.02457686f, 0.03345931f, -0.02233309f, -0.01382286f, -0.05115001f, 0.03646856f, -0.05576268f, 
    -0.05057294f, 0.02039015f, -0.04756232f, -0.04092505f, -0.06135194f, -0.02511457f, -0.06157454f, 0.04568522f, 
    -0.05268807f, -0.06314545f, -0.00321570f, -0.02392850f, -0.02998387f, 0.03176131f, 0.00626528f, 0.03347296f, 
    0.00135335f, 0.03191914f, -0.00807217f, -0.04110394f, -0.01980125f, 0.05292669f, 0.04860330f, -0.04664297f, 
    -0.03486426f, 0.00664180f, -0.04421229f, -0.03095751f, 0.04908008f, 0.04884033f, -0.05577423f, 0.00729925f, 
    0.03995571f, -0.04143154f, -0.01763122f, -0.06124411f, -0.04328687f, 0.03299196f, -0.03554938f, -0.05161471f, 
    0.02298418f, -0.05830346f, 0.01136091f, -0.06030362f, 0.02177809f, 0.01190237f, 0.01627904f, -0.02252363f, 
    -0.02003886f, -0.02048062f, -0.03166528f, 0.04440431f, 0.03117491f, -0.00408409f, 0.00698621f, 0.03604767f, 
    -0.00365126f, -0.00210826f, -0.05344040f, -0.06158707f, 0.02274466f, 0.02213358f, 0.03710585f, -0.00695115f, 
    -0.04435738f, 0.00497856f, 0.02180848f, -0.06088533f, -0.02835079f, -0.03427928f, -0.02692974f, 0.04255829f, 
    -0.00039453f, -0.02368652f, 0.03021508f, -0.06444039f, -0.05233804f, 0.01246738f, -0.00841595f, -0.02508596f, 
    0.01613270f, 0.00488663f, 0.04777972f, 0.00063247f, 0.01781634f, 0.01670069f, -0.03103199f, -0.02823697f, 
    0.00726169f, -0.03605333f, -0.04016181f, 0.02936231f, -0.05040886f, -0.03632797f, 0.01202981f, 0.03346874f, 
    -0.00744912f, -0.01967250f, -0.04310858f, -0.01243451f, -0.04750951f, -0.05472731f, -0.05936237f, 0.00762028f, 
    0.02478962f, 0.02329849f, 0.00516121f, 0.01303964f, -0.05668568f, -0.05787328f, -0.02960427f, -0.05001726f, 
    0.04510538f, -0.03167369f, -0.05143153f, 0.04954721f, -0.03748434f, 0.00306661f, 0.01487645f, 0.02942451f, 
    0.00516946f, 0.00586841f, 0.02751747f, -0.00057648f, -0.00651115f, 0.02332348f, 0.02218472f, -0.04022711f, 
    0.03190170f, -0.00619345f, 0.05285981f, -0.06179010f, -0.02970804f, -0.01315204f, -0.04878413f, 0.04631115f, 
    -0.06048129f, -0.05600888f, 0.00644042f, -0.01457203f, -0.01924556f, -0.04715252f, -0.01961252f, -0.04341532f, 
    -0.01924059f, 0.00558559f, 0.01852321f, 0.04655307f, 0.02046981f, 0.01326592f, 0.05394891f, 0.03334493f, 
    -0.00286218f, -0.02100753f, -0.04514904f, 0.03360388f, -0.01607232f, -0.01575326f, -0.06125659f, -0.03440342f, 
    -0.01334281f, 0.01720999f, 0.04102529f, -0.01937807f, 0.05275179f, -0.00529418f, -0.05241675f, -0.06544398f, 
    -0.05917637f, -0.04837659f, 0.00868861f, -0.03684387f, -0.05692550f, 0.03475482f, 0.03240160f, 0.03974424f, 
    0.04371325f, 0.04332732f, -0.03975200f, -0.01495303f, -0.00909443f, -0.01166917f, -0.03259584f, 0.04374425f, 
    0.20190977f, -0.04378310f, -0.33321133f, -0.04500110f, -0.03889817f, 0.09816399f, -0.02659346f, -0.14067313f, 
    0.15192010f, -0.05546280f, -0.13834374f, -0.19215229f, 0.01685164f, 0.05679725f, -0.08764621f, 0.08229484f, 
    0.10844960f, 0.07717992f, -0.24735360f, 0.18288936f, -0.12180174f, 0.01660035f, -0.00898004f, 0.08466378f, 
    -0.02841890f, 0.04172901f, -0.03317731f, 0.00783788f, 0.10457714f, -0.07610944f, -0.11135619f, 0.01839926f, 
    0.13970771f, 0.04551812f, 0.08206139f, 0.16244502f, 0.08431502f, -0.02273953f, -0.08680037f, -0.04082467f, 
    0.10225872f, 0.04737665f, 0.10041211f, -0.19153975f, -0.04911792f, -0.16589600f, 0.16169742f, 0.11619881f, 
    0.00447629f, 0.04773241f, 0.14664148f, 0.08012874f, -0.00495148f, -0.06448124f, 0.00453634f, -0.20048372f, 
    0.11574609f, 0.03157482f, 0.06673534f, -0.02731585f, -0.02364306f, 0.10912295f, 0.11673038f, -0.15025522f, 
    0.21839425f, 0.12378316f, 0.02559771f, -0.04107850f, -0.02899112f, 0.02081553f, 0.00261601f, 0.10799145f, 
    -0.14424452f, -0.01131526f, 0.18741409f, 0.04356977f, -0.09868515f, 0.13665652f, -0.09533337f, 0.01433099f, 
    0.02474410f, -0.34380198f, -0.17268310f, -0.04847736f, 0.03452339f, 0.03213627f, 0.03647153f, 0.06900843f, 
    -0.05904676f, 0.04629482f, -0.08842577f, 0.12278304f, 0.04543614f, 0.06459427f, -0.06628643f, -0.00743783f, 
    0.07772952f, 0.03368855f, 0.08581406f, -0.39778417f, -0.02454566f, -0.19272986f, 0.11670749f, 0.18172984f, 
    0.04463056f, 0.05505570f, -0.04207862f, 0.05275988f, -0.02774986f, -0.22733198f, -0.22455864f, 0.09035496f, 
    -0.00784935f, -0.15365502f, 0.10165996f, 0.07072946f, -0.03717712f, -0.27272806f, -0.04355722f, 0.26521808f, 
    0.06088059f, 0.10141466f, -0.17675291f, -0.03697626f, -0.00224487f, -0.04975853f, -0.20769283f, -0.22547647f, 
    -0.22006688f, 0.07648929f, 0.04875167f, 0.00319311f, -0.10319380f, -0.01009845f, -0.08880288f, 0.18800996f, 
    0.12662861f, 0.01865284f, -0.14693139f, -0.05512124f, 0.04228020f, 0.01106898f, 0.05261166f, 0.10416612f, 
    0.15241759f, -0.28880325f, 0.12691832f, -0.04257846f, 0.00622554f, -0.04283499f, -0.03643000f, -0.06685569f, 
    -0.09879545f, -0.14633325f, -0.06886388f, -0.30658600f, 0.09365807f, -0.03163870f, 0.00978249f, 0.14832298f, 
    0.07108455f, -0.13137783f, -0.19437706f, -0.00217615f, -0.18373381f, -0.15620020f, -0.04559035f, 0.05005112f, 
    0.11810381f, 0.09091540f, 0.05867158f, -0.01777514f, 0.20035979f, -0.12483722f, -0.03532952f, 0.03621013f, 
    0.02171505f, -0.08040127f, -0.06675962f, -0.05524699f, -0.13610244f, 0.14972264f, 0.15901168f, 0.05484198f, 
    -0.09717339f, 0.04214444f, -0.13732862f, 0.20860493f, 0.06533344f, -0.06399752f, 0.09349188f, 0.11476675f, 
    -0.16531591f, 0.09981404f, -0.07003435f, 0.14798610f, 0.07392860f, -0.02369954f, 0.05896239f, -0.01936370f, 
    -0.03321300f, -0.08961793f, -0.01978335f, -0.04940111f, -0.03547475f, -0.03145875f, 0.14937314f, -0.03282933f, 
    -0.34934801f, 0.00319958f, 0.11043747f, 0.01875308f, 0.05031623f, 0.04337959f, -0.01934717f, -0.01300782f, 
    0.03395391f, 0.06552528f, -0.00396292f, -0.09042218f, 0.00362454f, 0.05277516f, -0.06079477f, -0.02242565f, 
    0.12365343f, 0.01120496f, 0.05267632f, 0.07318524f, -0.22984052f, 0.20945777f, -0.03535968f, 0.19884877f, 
    0.01020605f, 0.15167086f, 0.14764749f, 0.06691579f, 0.06868652f, -0.02537873f, 0.09676938f, 0.07543501f, 
    -0.05109528f, 0.08301905f, -0.02475451f, -0.20642114f, -0.01481663f, 0.13726796f, 0.04236928f, 0.01987462f, 
    0.01561106f, 0.18458219f, -0.01023967f, 0.00308897f, 0.13633946f, -0.07795375f, -0.14862433f, 0.06679087f, 
    -0.03858023f, -0.06348698f, 0.02952903f, 0.00564027f, 0.13183907f, 0.12267560f, 0.12287017f, 0.19520791f, 
    0.04999495f, -0.07422806f, -0.00118507f, -0.11745322f, 0.06167884f, 0.13339897f, -0.29903689f, -0.36462149f, 
    -0.41939741f, 0.04584272f, 0.02821634f, 0.10289571f, -0.05524548f, -0.18114461f, -0.04713599f, 0.29109415f, 
    -0.04228679f, -0.02578941f, 0.03922732f, 0.02896401f, -0.10718773f, -0.05093611f, 0.00876748f, 0.10971108f, 
    -0.00889831f, -0.07656996f, -0.08193900f, 0.00092965f, -0.05593087f, 0.05536498f, -0.04029111f, 0.12455644f, 
    0.09909596f, 0.13888484f, -0.07497729f, 0.03627650f, 0.04676025f, -0.03673410f, 0.21297753f, -0.10415669f, 
    0.24304210f, -0.08644609f, 0.26088274f, -0.07962541f, 0.04193963f, 0.08996812f, 0.10878465f, -0.03449358f, 
    -0.01179375f, 0.02598805f, 0.00745088f, 0.19654366f, -0.13241926f, -0.12443282f, -0.25133082f, -0.09473570f, 
    -0.03187701f, 0.02334640f, -0.00013609f, -0.04179990f, 0.31974497f, 0.07176101f, -0.13293254f, 0.14090163f, 
    0.03472359f, -0.14408007f, -0.13033642f, -0.00011812f, 0.06470653f, -0.11729583f, -0.26274130f, -0.11631320f, 
    0.13523109f, -0.04028706f, -0.00723599f, 0.07698923f, 0.01602394f, 0.04858457f, 0.09279415f, -0.10966008f, 
    -0.10440515f, 0.03252181f, -0.02423243f, -0.00856094f, -0.00627141f, -0.00912068f, 0.07083752f, 0.07706053f, 
    -0.19016200f, -0.30639312f, -0.05887365f, 0.03938437f, -0.03897734f, 0.05030204f, -0.01777401f, -0.14847034f, 
    0.06339664f, -0.06880273f, 0.11634316f, 0.00553989f, -0.11687731f, -0.04097611f, -0.02517681f, -0.08648026f, 
    0.01518376f, 0.08841778f, -0.05473367f, 0.12576908f, 0.04668980f, -0.02251693f, -0.08480044f, 0.02147641f, 
    0.02131418f, -0.01456772f, 0.17127305f, 0.04787066f, 0.03651173f, 0.07147628f, -0.02619441f, 0.01867836f, 
    0.03378621f, 0.05408498f, -0.16747127f, 0.13004062f, 0.00142542f, 0.05895844f, 0.04413642f, -0.00518640f, 
    0.00284936f, 0.06714644f, 0.15455358f, -0.03493067f, -0.06134521f, 0.05913502f, 0.05976371f, -0.11687541f, 
    0.04483147f, 0.02301043f, -0.07464292f, 0.02813981f, -0.00818424f, -0.31459880f, 0.11740211f, 0.05802041f, 
    0.04947675f, -0.15463503f, -0.13459691f, 0.08882055f, 0.02142369f, 0.06635751f, 0.11907122f, -0.08005930f, 
    0.18781815f, -0.08078417f, 0.01102574f, 0.04579911f, -0.03830536f, 0.17123756f, 0.07213978f, -0.18059431f, 
    -0.06502016f, 0.16509062f, 0.04544615f, -0.09287518f, 0.01625568f, 0.13079421f, -0.06072584f, 0.02435441f, 
    -0.23252749f, -0.03926554f, -0.11111128f, 0.17943487f, 0.05320033f, 0.00570163f, -0.06003574f, 0.04374287f, 
    0.10915963f, 0.08135572f, 0.14547230f, 0.12176200f, 0.05949520f, 0.04805874f, -0.02210994f, -0.09996878f, 
    0.09466003f, 0.03639179f, -0.04550001f, -0.05635773f, -0.09656882f, -0.16194837f, -0.07306966f, 0.04065046f, 
    0.17187750f, -0.03568558f, -0.04388090f, 0.14786783f, 0.05924469f, 0.11576059f, -0.02098385f, -0.12513719f, 
    0.03174863f, -0.02100004f, -0.05744693f, -0.03773263f, -0.08980773f, -0.07567263f, -0.15658468f, -0.11758967f, 
    0.10590702f, 0.11781168f, 0.06962676f, 0.00484664f, 0.06407531f, 0.02225523f, -0.06652218f, -0.24193999f, 
    0.03522196f, 0.09169055f, -0.01943040f, -0.02553788f, 0.08012541f, -0.02711499f, -0.13511716f, -0.01416199f, 
    -0.06532629f, 0.07818504f, -0.03027865f, 0.16709901f, -0.00525632f, 0.00462009f, 0.04322278f, 0.02485054f, 
    -0.07687598f, 0.07876400f, 0.06715527f, -0.04350944f, 0.00258480f, 0.04072617f, 0.09308560f, 0.06295692f, 
    -0.00496447f, -0.07983280f, 0.11274059f, 0.01336161f, -0.08225572f, -0.03338001f, -0.07577770f, 0.00247483f, 
    0.04151213f, -0.22675252f, 0.06700405f, 0.14486094f, 0.04140327f, 0.02728102f, 0.04520020f, -0.00683496f, 
    -0.00033375f, -0.15207589f, 0.07353780f, -0.26561761f, -0.07501020f, 0.16532871f, 0.14611129f, 0.02711181f, 
    -0.07047772f, -0.07918315f, 0.01537588f, 0.02581622f, 0.00134040f, 0.11158518f, 0.05037199f, -0.01432959f, 
    -0.17897055f, -0.03319205f, 0.05846331f, -0.09808381f, 0.14744410f, 0.03933860f, -0.08108703f, 0.04438779f, 
    0.05637032f, 0.07952261f, -0.00312587f, 0.00531258f, -0.00175894f, 0.15610306f, -0.09386788f, -0.04931008f, 
    -0.03436237f, -0.14421980f, 0.07291757f, -0.01928198f, 0.02294091f, 0.06417593f, 0.14519101f, 0.21409282f, 
    0.05773074f, -0.21766070f, 0.07560508f, 0.13917539f, -0.07620989f, 0.19379348f, -0.08469205f, -0.02920675f, 
    0.02843079f, 0.03719996f, -0.10109106f, -0.04925581f, -0.00861153f, -0.05532768f, 0.02384307f, 0.09343857f, 
    0.03763312f, -0.10624594f, 0.11402640f, 0.12023842f, 0.10938174f, -0.07906883f, 0.10268589f, 0.03850416f, 
    -0.15223838f, -0.05508881f, 0.03274658f, -0.08440095f, -0.03817132f, -0.06056636f, -0.22891669f, -0.01991751f, 
    0.03990589f, -0.16798782f, -0.02946370f, 0.01222407f, 0.05636927f, -0.04793403f, 0.02689345f, 0.01868526f, 
    -0.01048525f, 0.06493890f, -0.09920610f, -0.07676963f, 0.17106359f, 0.12796295f, -0.04318659f, 0.05536808f, 
    0.03095372f, -0.09316468f, 0.09341163f, 0.19844955f, 0.15257727f, 0.13900656f, -0.23615061f, 0.03024771f, 
    0.01789157f, -0.04714449f, -0.00287511f, -0.08240739f, -0.08338773f, -0.11589860f, 0.11528078f, -0.03198708f, 
    -0.10408592f, -0.08944935f, -0.12727574f, -0.07712705f, 0.01296148f, -0.00661808f, -0.15022516f, -0.18401243f, 
    -0.06641062f, 0.06208435f, -0.02852845f, 0.10024974f, 0.01307031f, 0.01691001f, -0.19476710f, 0.14993034f, 
    -0.13238358f, 0.00562991f, -0.01902197f, -0.04003904f, -0.06801363f, 0.20100518f, 0.09934955f, 0.07067494f, 
    0.11286006f, 0.06614321f, 0.20485587f, 0.10296649f, -0.03077270f, 0.02414588f, -0.07164942f, -0.06178642f, 
    0.02028335f, 0.07799368f, 0.03189141f, -0.17358218f, 0.07457831f, 0.07856934f, 0.04563969f, 0.05890196f, 
    -0.13368134f, 0.03465879f, -0.15170206f, 0.12822227f, 0.16441415f, 0.00895745f, 0.02195428f, -0.09658205f, 
    -0.08000705f, 0.06280737f, 0.03236673f, 0.09992211f, -0.00567768f, -0.09748608f, 0.10798269f, 0.04087997f, 
    -0.04552329f, -0.01053157f, 0.06886522f, 0.07928324f, -0.12827477f, -0.22083232f, 0.12414857f, 0.14239097f, 
    0.05902191f, 0.12887515f, 0.01578895f, 0.01411717f, 0.03268266f, 0.03237831f, -0.11838931f, -0.23931785f, 
    -0.13160962f, 0.06678674f, -0.05852136f, -0.18787079f, -0.04699077f, 0.11127519f, -0.00427121f, -0.26002267f, 
    -0.19210452f, 0.02079692f, -0.04881246f, -0.05721563f, -0.07632052f, 0.05610017f, -0.01463411f, 0.10886883f, 
    0.06177783f, -0.26573202f, -0.15229486f, -0.08169778f, -0.03850793f, 0.05490388f, 0.10696309f, 0.08156884f, 
    0.23405163f, 0.33645204f, 0.09553775f, -0.00432467f, -0.00252218f, -0.23092273f, -0.03660256f, 0.00106118f, 
    0.07333479f, 0.15271702f, 0.02922345f, -0.12072924f, 0.08046719f, -0.00545934f, -0.03769745f, 0.15617739f, 
    0.05168311f, -0.19890468f, -0.16051991f, -0.05432224f, -0.06296718f, -0.04670110f, 0.00152210f, -0.12578684f, 
    0.01297542f, -0.03330272f, 0.19091775f, -0.31180865f, -0.20533936f, 0.17739365f, -0.01643864f, 0.31036007f, 
    0.02678025f, 0.00147507f, -0.08856788f, -0.14328998f, 0.13773507f, 0.04696921f, -0.20953633f, -0.09016834f, 
    -0.10324188f, 0.08116108f, 0.08887553f, 0.19384696f, 0.14426333f, 0.05951809f, 0.08940272f, -0.26494980f, 
    -0.11252466f, -0.00807719f, -0.24035090f, 0.26412186f, 0.26693821f, 0.09767802f, -0.11866251f, 0.19713914f, 
    0.09035837f, -0.00322174f, -0.01104500f, 0.00085983f, 0.14262541f, 0.06501472f, 0.18262777f, 0.13682853f, 
    0.15503472f, -0.24602035f, 0.09899928f, 0.05784594f, -0.08363253f, 0.01772763f, -0.06102157f, -0.05659318f, 
    -0.19615801f, 0.12457438f, 0.10200536f, -0.05859097f, 0.10474689f, 0.01041929f, -0.04224424f, 0.01954639f, 
    -0.03776692f, -0.04651472f, -0.09787496f, 0.13218963f, 0.02582692f, 0.04335675f, -0.02726389f, 0.14825486f, 
    0.02757623f, -0.08858500f, 0.07985270f, -0.13089271f, -0.00345168f, 0.00112951f, -0.10624488f, 0.04761950f, 
    0.05549274f, 0.07372449f, 0.01439997f, -0.16963921f, -0.14545883f, 0.11277042f, -0.10080026f, 0.07822908f, 
    -0.02396564f, -0.07333845f, -0.00801383f, -0.06993520f, -0.23321956f, 0.01696052f, 0.03712019f, 0.04962024f, 
    0.11934236f, 0.04597631f, -0.00251385f, -0.02252370f, 0.15445413f, 0.13498403f, 0.08029214f, -0.00938155f, 
    0.00828561f, -0.17118813f, -0.23676816f, -0.06138709f, 0.09820525f, 0.06616847f, -0.16979107f, 0.01041652f, 
    0.06407475f, 0.05526372f, 0.02404789f, 0.05411298f, -0.08700863f, -0.10772601f, -0.09983562f, 0.19302955f, 
    -0.01208015f, -0.13468741f, 0.03005362f, -0.08473546f, -0.18618760f, -0.06673412f, -0.14511286f, 0.15440492f, 
    -0.02944762f, 0.02495949f, 0.02136498f, 0.01643647f, -0.00505354f, 0.03056041f, 0.05613772f, 0.01920844f, 
    0.02825577f, 0.00314918f, 0.00475796f, -0.00721809f, 0.04365490f, -0.02432835f, 0.00928421f, -0.05350908f, 
    0.04926241f, 0.00453277f, 0.05782690f, 0.01795392f, -0.02284446f, -0.05676007f, -0.02641732f, 0.02652279f, 
    -0.02907793f, 0.01446636f, -0.00803247f, -0.04436876f, -0.03855161f, -0.04657654f, 0.02699526f, 0.05669111f, 
    0.03069490f, -0.02407242f, 0.04782922f, 0.00846649f, 0.04629133f, -0.04055681f, -0.00995860f, -0.05555624f, 
    0.04404162f, -0.03632560f, 0.03991869f, 0.05880738f, 0.04153041f, -0.02591773f, -0.04047558f, -0.03073692f, 
    -0.02099487f, 0.03206649f, 0.02616196f, -0.01740708f, -0.03969780f, -0.04909750f, 0.01865061f, 0.02818032f, 
    -0.01321236f, -0.05818091f, 0.04813467f, -0.04917901f, 0.00429411f, -0.03509462f, 0.03182557f, -0.01195614f, 
    0.01503692f, 0.04357030f, 0.05159048f, -0.04924169f, -0.05670603f, -0.02613889f, -0.04105442f, 0.05616722f, 
    -0.05129888f, -0.03820285f, -0.04364806f, -0.01910687f, 0.01093902f, 0.05190614f, 0.05127788f, -0.05687902f, 
    -0.02459720f, 0.05215849f, -0.02503573f, -0.01789790f, -0.02435748f, 0.01198054f, 0.00470194f, -0.05862157f, 
    0.00176531f, 0.05638499f, 0.00007096f, -0.04460753f, -0.02595114f, -0.04797498f, -0.04286857f, 0.05695544f, 
    0.05569612f, -0.01777035f, -0.03034523f, -0.00856091f, -0.04097791f, 0.03727764f, -0.00044588f, -0.03651417f, 
    -0.02764649f, -0.05867925f, -0.05092775f, -0.02381831f, -0.00848085f, 0.00046143f, -0.04242349f, -0.03120408f, 
    -0.02323351f, -0.01754105f, -0.05578630f, -0.00265379f, -0.03510000f, -0.04305729f, -0.00884673f, 0.01736210f, 
    -0.03330930f, -0.00684209f, -0.02627444f, -0.05234527f, -0.00177263f, -0.03933349f, -0.04176509f, -0.05040747f, 
    -0.02860043f, -0.01525755f, 0.03950560f, -0.03307163f, -0.04113343f, -0.03705040f, -0.05268835f, 0.03443924f, 
    -0.05246568f, -0.05080497f, 0.00653353f, 0.00904306f, 0.00948593f, -0.02139937f, 0.05652171f, 0.04044874f, 
    -0.05137845f, -0.01684808f, -0.00773362f, -0.01641649f, -0.01461209f, -0.03636550f, 0.03337293f, -0.03890662f, 
    -0.05144914f, -0.02829024f, 0.00190655f, 0.03858909f, 0.05592842f, 0.05861586f, 0.01942462f, -0.02006814f, 
    0.00278933f, -0.05626593f, -0.02002953f, 0.03398541f, -0.04258610f, 0.02640621f, 0.00632196f, 0.03395021f, 
    -0.00435973f, -0.00847809f, -0.01532437f, 0.03066036f, 0.03616654f, -0.05733569f, 0.05660191f, 0.02631625f, 
    -0.01832167f, 0.02388688f, -0.03582767f, 0.01221364f, 0.00001011f, -0.01051783f, 0.05026023f, -0.03472102f, 
    0.05775291f, -0.02094290f, -0.03487471f, -0.02065210f, 0.03042634f, 0.03676758f, 0.05258624f, -0.00776329f, 
    -0.01920808f, 0.02858738f, 0.04216504f, 0.00081258f, -0.00083373f, 0.04310818f, 0.02144629f, -0.04928948f, 
    -0.02236858f, 0.00051428f, -0.04250840f, -0.03955862f, 0.00303679f, -0.04870239f, 0.04738582f, -0.05266370f, 
    0.05216606f, 0.05882810f, -0.03534355f, -0.05708480f, -0.04448772f, -0.01083439f, -0.05534353f, -0.02166195f, 
    0.05286343f, -0.05526592f, -0.03335897f, -0.04003826f, -0.05623697f, 0.01909447f, -0.03195202f, 0.04707560f, 
    -0.03461890f, -0.05285692f, -0.05538166f, -0.02265578f, 0.01861156f, -0.00265031f, -0.01174902f, 0.02379424f, 
    -0.05177644f, -0.05578147f, -0.04097543f, 0.05786229f, 0.03647862f, 0.03224939f, -0.02103064f, -0.00873972f, 
    0.00344383f, 0.04540970f, 0.00164144f, 0.02903108f, -0.03978418f, -0.01589872f, -0.04242703f, -0.05659591f, 
    -0.00514643f, 0.05757917f, 0.01434749f, -0.02046351f, 0.00963200f, 0.01485910f, -0.02554084f, -0.01852065f, 
    0.01494485f, -0.04619026f, -0.01467482f, -0.03009262f, 0.01632287f, 0.04378336f, -0.02440463f, -0.02811550f, 
    0.00856319f, 0.01676116f, -0.00255278f, -0.01377051f, 0.03477568f, 0.04933615f, 0.05488709f, 0.05356088f, 
    -0.03481575f, 0.03332626f, -0.04457219f, 0.02924927f, -0.05400085f, -0.04706031f, 0.01536099f, -0.05736133f, 
    0.04630195f, -0.01062606f, -0.05110327f, 0.01653037f, 0.01652775f, -0.02662976f, -0.03299250f, -0.01026659f, 
    -0.05624444f, -0.00132869f, -0.03621774f, -0.07822987f, -0.04903746f, 0.02311962f, -0.03148562f, 0.00060058f, 
    0.01307528f, -0.03430930f, 0.02691971f, -0.04772016f, -0.05578721f, 0.01239850f, 0.02258334f, -0.07745422f, 
    -0.03745910f, -0.06624713f, -0.06887042f, 0.01182967f, -0.01309142f, -0.04438443f, -0.05037116f, -0.01445873f, 
    0.02895220f, 0.01704119f, -0.00742624f, -0.06619321f, -0.00374970f, -0.04836976f, -0.01817687f, -0.00808221f, 
    0.02774035f, -0.08463654f, -0.08063219f, -0.02256240f, 0.04459759f, -0.04519973f, -0.01127510f, -0.06950949f, 
    -0.07155436f, -0.05552685f, -0.02425891f, 0.00329217f, -0.00877146f, -0.04794381f, -0.04298289f, -0.07728066f, 
    -0.01985500f, -0.01386896f, 0.00460363f, -0.04293439f, -0.07969355f, 0.00581022f, 0.00837326f, -0.05622263f, 
    -0.07354323f, -0.07621443f, 0.02204802f, -0.07230120f, -0.04508262f, 0.01271277f, -0.02376370f, -0.00907619f, 
    -0.06712828f, -0.00237540f, -0.05586677f, -0.06307533f, -0.07393863f, -0.05546344f, -0.05270224f, -0.00991309f, 
    -0.05162145f, 0.01914303f, -0.05908900f, -0.01743108f, -0.02593320f, 0.00069918f, 0.01040007f, -0.08650876f, 
    -0.06995062f, -0.03404108f, -0.04529648f, 0.02285712f, -0.03054050f, -0.06365279f, -0.00881758f, -0.03628409f, 
    -0.00064495f, 0.02898968f, 0.02554900f, -0.02205029f, -0.06116886f, -0.03866569f, -0.02216860f, -0.02917322f, 
    -0.05258154f, -0.01821430f, 0.01182748f, -0.07165851f, -0.03893867f, 0.01337352f, -0.03924162f, -0.07583933f, 
    0.00666104f, 0.00908751f, -0.08709396f, -0.02706783f, -0.04612316f, -0.06968243f, -0.02947550f, -0.07361480f, 
    0.02731978f, -0.07695244f, -0.07307054f, 0.00469849f, -0.05343899f, 0.01260720f, -0.00873988f, 0.02574962f, 
    -0.08653062f, -0.02275720f, -0.01540239f, -0.04633713f, 0.00671861f, -0.00121302f, -0.01661982f, -0.05416456f, 
    -0.01455506f, -0.06897747f, -0.07880413f, -0.01933314f, 0.01347328f, -0.02470795f, -0.08340330f, -0.03599975f, 
    -0.06837092f, -0.04497013f, -0.07959674f, -0.03855665f, -0.04994460f, -0.06656355f, 0.01187941f, -0.01541374f, 
    0.01298756f, -0.00284098f, 0.00354881f, -0.03994199f, -0.05322520f, -0.00801747f, 0.00913606f, -0.05991362f, 
    -0.03861747f, -0.01252852f, -0.05219002f, -0.01031574f, 0.00842851f, -0.02403456f, -0.06199557f, 0.00281660f, 
    0.00004708f, -0.00301927f, 0.01605118f, -0.04938260f, -0.06977022f, -0.08837935f, -0.07449025f, 0.01716872f, 
    -0.02166116f, -0.06493229f, -0.02381445f, -0.04963624f, -0.02558460f, 0.01277499f, -0.00341057f, -0.02017164f, 
    -0.01058929f, -0.04899646f, 0.01537097f, 0.00397931f, -0.02530747f, -0.08684734f, -0.06623444f, 0.01883123f, 
    -0.01612512f, -0.01566803f, -0.02050245f, -0.07360543f, 0.02099073f, -0.01336104f, -0.06811967f, -0.03850519f, 
    0.00638978f, -0.00576625f, -0.03457407f, 0.00856352f, -0.04543347f, -0.02845431f, -0.05682483f, -0.04537812f, 
    -0.08534289f, -0.05161525f, -0.06358512f, -0.01061254f, -0.08347587f, -0.04452641f, 0.00241506f, -0.08623690f, 
    -0.04434248f, 0.00492752f, -0.07350325f, 0.00715907f, -0.01403424f, -0.08250805f, -0.05700953f, -0.03489199f, 
    -0.01919976f, -0.07173239f, -0.04139614f, -0.05968769f, -0.03027208f, -0.08465903f, 0.01646003f, -0.05200537f, 
    -0.05203735f, -0.04062981f, -0.02426924f, -0.02283919f, 0.00006326f, -0.02858769f, -0.01223521f, -0.03636083f, 
    -0.05373966f, -0.02690475f, -0.01365817f, -0.05916732f, -0.06532831f, -0.02449396f, -0.06479175f, -0.05900269f, 
    -0.02110000f, -0.05435772f, -0.03719325f, -0.06545340f, -0.00402713f, -0.00033690f, -0.08360357f, -0.01717380f, 
    0.02445369f, -0.00897304f, -0.01518484f, -0.02763827f, -0.06714941f, -0.06295706f, 0.02759643f, -0.04586751f, 
    -0.07486928f, -0.06007468f, 0.00163693f, -0.04397699f, -0.03909062f, -0.04459156f, -0.03855492f, 0.00119450f, 
    -0.06787439f, -0.02908419f, -0.04537578f, -0.02919944f, 0.01501150f, -0.03664984f, -0.06845266f, 0.03463970f, 
    -0.00108076f, -0.04555059f, -0.05359823f, -0.03103500f, 0.02498826f, -0.03713560f, -0.03720351f, -0.04011128f, 
    -0.08591799f, -0.05780809f, -0.03423716f, -0.02087498f, -0.06352636f, -0.00672208f, 0.01999677f, -0.00429065f, 
    -0.05124658f, -0.01544940f, 0.04968552f, 0.00140444f, -0.00910988f, -0.02352099f, -0.04674521f, -0.07106166f, 
    -0.05334112f, -0.02829479f, 0.01379947f, -0.02602147f, 0.01875249f, 0.04821274f, -0.05207370f, 0.03086343f, 
    0.04922240f, -0.01823905f, 0.04782104f, -0.01599009f, -0.04692432f, -0.04163235f, 0.01755319f, 0.03581996f, 
    -0.04223987f, 0.01112346f, 0.00579554f, 0.02594379f, 0.05105154f, -0.04329965f, 0.04691964f, 0.01106649f, 
    -0.02734159f, -0.05784716f, 0.02780424f, -0.03035415f, 0.03916850f, 0.03235368f, 0.06490253f, -0.04082969f, 
    0.01625386f, -0.02207280f, -0.02213605f, -0.00303837f, -0.05957705f, -0.00476054f, -0.04130213f, 0.03518910f, 
    -0.03692170f, -0.01732221f, -0.03616570f, -0.01152518f, -0.00226730f, 0.01372240f, 0.00605971f, -0.03524705f, 
    -0.04012074f, 0.03168709f, 0.03837993f, -0.07211894f, 0.01056556f, 0.01664654f, -0.00512098f, -0.03874457f, 
    0.03716132f, 0.03311314f, 0.01126693f, 0.01132942f, 0.03071776f, -0.02061647f, -0.04132693f, 0.00751274f, 
    -0.00782377f, -0.05831643f, -0.02678183f, -0.00641382f, 0.04005281f, 0.01468295f, -0.02215686f, -0.04314143f, 
    0.04610617f, 0.04831804f, -0.05243155f, -0.01428527f, 0.00591251f, -0.05574042f, 0.01140981f, -0.00639830f, 
    0.03633896f, 0.00243578f, -0.04043431f, -0.05623043f, 0.04453878f, 0.04525943f, -0.01766118f, 0.05286221f, 
    0.03833462f, -0.04548957f, -0.01201708f, -0.04604213f, -0.03096476f, -0.02534981f, 0.04750331f, -0.05057848f, 
    0.01523593f, -0.00979900f, 0.00395162f, -0.03270562f, -0.01759537f, -0.03003623f, -0.04888590f, -0.05003064f, 
    0.01248582f, -0.01831030f, -0.00567073f, -0.04417214f, 0.01537730f, -0.01726685f, -0.06370816f, 0.03774077f, 
    -0.02143034f, 0.01000334f, -0.02219820f, 0.04576388f, -0.03917694f, -0.00478140f, -0.03973522f, 0.00857740f, 
    -0.01551458f, 0.04958337f, -0.00148563f, -0.00653412f, 0.05813481f, -0.00718931f, -0.02592592f, 0.00892753f, 
    0.01771674f, 0.04661883f, 0.04032100f, -0.02176911f, 0.00440277f, -0.05723648f, -0.02308681f, -0.03086892f, 
    -0.06226028f, 0.03275127f, -0.05908586f, -0.03032430f, -0.00544005f, 0.02943079f, 0.04527041f, 0.01944108f, 
    -0.03362498f, -0.01016351f, -0.04703621f, 0.04062171f, -0.03256038f, 0.01547115f, 0.01346440f, 0.00048752f, 
    -0.03320200f, 0.05354236f, 0.02195887f, 0.03705018f, 0.03900348f, -0.05840297f, 0.03942822f, 0.01037038f, 
    0.03767268f, -0.00471053f, -0.01544718f, 0.02914025f, 0.06175681f, -0.01650325f, 0.02335200f, -0.03477595f, 
    0.04634890f, -0.02832809f, -0.02042948f, 0.04066548f, -0.02714216f, 0.04771404f, -0.06108915f, -0.05419651f, 
    0.01903305f, -0.04321815f, -0.01465468f, -0.01676798f, -0.03507760f, -0.00377617f, 0.02423099f, -0.03306560f, 
    -0.01373141f, 0.05487571f, -0.00835778f, -0.05939044f, -0.00146228f, -0.07737546f, 0.00374403f, -0.05923579f, 
    -0.06256416f, -0.02405581f, -0.03671627f, -0.04416346f, -0.03017067f, -0.06282900f, -0.01155569f, 0.04061870f, 
    -0.02237052f, 0.00126472f, -0.01265374f, -0.00040380f, -0.01721467f, -0.04340141f, -0.04238145f, 0.03041480f, 
    -0.04114527f, -0.06337181f, -0.00976915f, 0.05341225f, -0.01261790f, -0.01612335f, 0.02557952f, -0.04365433f, 
    -0.05759215f, 0.01591042f, 0.02921985f, 0.01151124f, -0.04059502f, 0.02939988f, -0.04533888f, 0.00449004f, 
    -0.01612745f, -0.04610228f, -0.03198437f, -0.02235422f, -0.02983836f, -0.05742102f, -0.00987163f, 0.01654995f, 
    0.00810593f, -0.02580106f, 0.04649692f, 0.03493848f, 0.01681220f, 0.05199796f, -0.00648618f, -0.04183369f, 
    0.05100032f, -0.02337006f, -0.01375737f, 0.00154854f, 0.02287467f, -0.01642612f, 0.05258364f, 0.01539184f, 
    -0.05686769f, 0.01743630f, -0.03809765f, 0.04111672f, -0.05752755f, -0.01088530f, -0.05716965f, 0.03176033f, 
    -0.02166371f, 0.03649566f, -0.00956227f, 0.03673787f, -0.04802702f, 0.01202861f, -0.03996431f, -0.00641497f, 
    -0.00842809f, 0.03234996f, -0.04311945f, 0.05379267f, 0.01391923f, -0.00692091f, -0.01101630f, -0.06723356f, 
    0.02054177f, -0.03688692f, 0.00800570f, -0.01714575f, 0.03383411f, 0.01658468f, -0.00225447f, -0.04467446f, 
    0.01616054f, 0.01514821f, 0.02522478f, 0.00675573f, -0.03658286f, 0.01854977f, 0.02745915f, -0.04161004f, 
    -0.01794361f, 0.01439087f, 0.04504176f, 0.01787031f, 0.03829755f, 0.05170513f, 0.00825019f, 0.00059964f, 
    -0.04539394f, 0.00765688f, -0.00356679f, -0.02437282f, 0.04131331f, 0.04991592f, -0.03649395f, -0.05695587f, 
    0.03793607f, -0.01836753f, 0.04822459f, 0.03443063f, 0.01510513f, -0.00544508f, 0.02133807f, -0.00725197f, 
    0.01093527f, -0.03699389f, -0.03118053f, -0.05342326f, 0.01820938f, -0.04748496f, -0.05263794f, 0.03074976f, 
    -0.04883228f, 0.04953369f, -0.04413910f, 0.05182616f, 0.03782834f, -0.02481344f, -0.00367129f, 0.04328749f, 
    0.03638239f, 0.01197582f, 0.05174620f, -0.03443874f, -0.03440186f, -0.02174857f, -0.05266357f, -0.01758430f, 
    0.04269670f, 0.00956182f, -0.01017715f, -0.03795867f, -0.02427992f, -0.06081915f, -0.00246589f, -0.00749769f, 
    -0.04523883f, -0.03346124f, -0.06460290f, 0.01183019f, 0.02166645f, -0.05431837f, 0.03131171f, 0.01942186f, 
    -0.03529282f, -0.02183722f, -0.03574095f, -0.00438878f, 0.00452935f, 0.03451581f, 0.03518408f, 0.03549291f, 
    -0.00030411f, -0.06218449f, 0.04150870f, 0.01810749f, -0.03894002f, -0.05225715f, 0.01885244f, 0.00728388f, 
    0.02555449f, 0.04441965f, 0.00185931f, 0.01549579f, 0.00321475f, -0.01909587f, -0.03640008f, 0.01383605f, 
    0.00041294f, -0.04279915f, 0.01493572f, -0.04394034f, -0.00101532f, -0.04258256f, -0.02462389f, 0.00504167f, 
    -0.04245992f, -0.02110824f, 0.00122061f, -0.06101194f, 0.02783218f, 0.00644393f, -0.03746903f, 0.03143753f, 
    -0.03656166f, -0.02668326f, 0.04489636f, 0.01687306f, 0.00965731f, 0.00212746f, -0.01438964f, 0.01171260f, 
    -0.06274530f, -0.03072470f, -0.03850765f, 0.05143452f, 0.01222267f, -0.04569642f, 0.03456458f, 0.00809899f, 
    -0.00219622f, 0.03262733f, 0.03907085f, 0.03788162f, -0.03458346f, 0.00340029f, -0.00075474f, -0.04843507f, 
    0.00140226f, 0.04848583f, 0.01797105f, -0.00681611f, -0.05274615f, -0.00218588f, -0.02813783f, -0.04372759f, 
    -0.04161074f, -0.04778112f, -0.04079843f, -0.03784288f, -0.00329748f, 0.00558142f, -0.05749055f, -0.02223963f, 
    0.02788317f, -0.02082458f, -0.05745825f, 0.01562010f, 0.01296523f, -0.03916124f, -0.02809304f, -0.06510129f, 
    -0.00164918f, -0.03088910f, 0.03429298f, -0.05156092f, -0.03942807f, -0.03894519f, -0.00293509f, 0.04604239f, 
    -0.00336678f, -0.01152471f, 0.02768822f, -0.01151953f, 0.01682346f, -0.03648623f, -0.04814200f, 0.00310942f, 
    -0.05764857f, 0.04862991f, 0.00025190f, -0.03800810f, -0.06493103f, 0.01317375f, -0.05947194f, -0.04582490f, 
    -0.01418946f, 0.02219865f, 0.01205674f, 0.05631079f, 0.03710440f, 0.00967830f, 0.04684749f, 0.00715804f, 
    0.05306707f, -0.02131397f, -0.03544842f, -0.05703025f, -0.01293294f, 0.00360780f, 0.01741722f, -0.03043571f, 
    -0.05955040f, -0.02256469f, -0.03388176f, -0.01173697f, -0.01217997f, -0.00149029f, 0.01762741f, -0.00409295f, 
    -0.05926656f, 0.02072630f, -0.05346018f, -0.04579541f, -0.03544270f, 0.02916591f, 0.00709985f, -0.02647407f, 
    0.01810672f, 0.00054418f, 0.03911376f, -0.07225680f, -0.04065237f, -0.05082012f, 0.03670957f, -0.01468856f, 
    0.04861746f, -0.02556772f, -0.00413564f, 0.03201155f, -0.01335515f, 0.00727126f, -0.00768462f, -0.02461027f, 
    -0.05680417f, 0.02545260f, -0.04136421f, -0.04658641f, 0.00856102f, -0.01006777f, 0.04385502f, 0.01500858f, 
    -0.01531320f, -0.05650112f, -0.02576654f, -0.00056246f, -0.00534975f, 0.00945473f, -0.01795680f, 0.00051572f, 
    -0.00934492f, -0.04197421f, -0.00055986f, -0.05231388f, 0.01498605f, -0.04185480f, 0.02849883f, 0.02624731f, 
    -0.04802898f, -0.00153957f, -0.02919467f, -0.00691765f, 0.00663445f, -0.03041540f, 0.02365516f, 0.01107561f, 
    0.01392505f, -0.02609190f, 0.02918022f, -0.00914308f, -0.03335628f, 0.04429850f, -0.00356420f, -0.05109226f, 
    -0.05815455f, -0.00906287f, -0.03273221f, -0.00303262f, 0.00534586f, -0.01051224f, -0.00724841f, -0.04173726f, 
    0.04887173f, -0.05430814f, 0.00185876f, -0.01385993f, -0.04085340f, 0.03462024f, -0.00088949f, -0.01785997f, 
    -0.01563677f, 0.00013640f, 0.02149299f, -0.04711185f, -0.00369516f, 0.02342862f, 0.04210239f, -0.04820038f, 
    0.01452333f, -0.01593849f, -0.00973816f, -0.03343287f, -0.03290008f, 0.03475498f, -0.02374703f, -0.00070474f, 
    0.01740601f, -0.05141110f, -0.01662642f, -0.04204535f, 0.03885862f, 0.00005939f, -0.05445347f, 0.04611739f, 
    0.02142894f, -0.00901803f, -0.00351923f, -0.00837865f, -0.00688749f, 0.04110737f, -0.02176742f, -0.01505983f, 
    0.01203449f, -0.02259333f, -0.02834864f, 0.01647853f, -0.02834001f, -0.05080573f, 0.02155403f, -0.02738964f, 
    0.03372935f, -0.00909614f, -0.03281344f, 0.04647996f, -0.03740738f, -0.04082883f, -0.01828353f, 0.01174470f, 
    -0.04382492f, -0.00389828f, -0.01103339f, 0.04789191f, 0.03606080f, 0.00699603f, 0.01838765f, 0.01175296f, 
    0.00828846f, 0.00819999f, -0.04705819f, -0.05900607f, 0.03003410f, -0.00744478f, -0.04206829f, 0.00416993f, 
    -0.05042426f, -0.04582228f, 0.01056248f, -0.05241299f, 0.03091024f, 0.01148950f, 0.00893447f, 0.01795216f, 
    0.03626864f, 0.04270637f, 0.01582473f, -0.01229254f, -0.05538281f, -0.05103145f, 0.01449726f, -0.03774639f, 
    -0.02875731f, -0.01141137f, -0.05807480f, 0.00137626f, 0.05025899f, 0.03576776f, -0.00564400f, -0.03100121f, 
    -0.02694841f, -0.03390695f, -0.06229969f, -0.04778842f, 0.04696974f, -0.00042355f, -0.04451346f, 0.03742287f, 
    -0.00359388f, -0.05627492f, -0.06446267f, -0.02383849f, -0.04184900f, 0.04229268f, -0.03738365f, -0.04068060f, 
    0.01869082f, 0.01199152f, -0.04045958f, 0.02154658f, -0.05505317f, -0.01517577f, -0.03186364f, -0.04614454f, 
    0.01398771f, 0.04193371f, -0.02025015f, -0.05301040f, -0.06491773f, -0.04655520f, 0.03617910f, 0.00041130f, 
    0.02258508f, -0.06428166f, -0.00738323f, 0.01903220f, 0.03262475f, -0.02277717f, -0.04714464f, 0.00041258f, 
    0.04255392f, -0.04533873f, -0.04873789f, -0.05936862f, 0.03342400f, -0.05581451f, -0.00120496f, 0.01762601f, 
    0.02375966f, -0.04750733f, 0.02422085f, -0.04900078f, 0.03529990f, 0.04222198f, 0.04238761f, 0.03281690f, 
    -0.05763862f, -0.01768495f, -0.05501034f, -0.00641392f, 0.02624744f, -0.04561501f, 0.05167119f, 0.02455098f, 
    0.04895941f, 0.00157766f, 0.02155783f, -0.05272714f, -0.01393851f, 0.00955883f, -0.00110806f, -0.06574927f, 
    -0.01923201f, 0.00684523f, 0.03792099f, -0.03528667f, 0.01280720f, -0.06637653f, 0.04573742f, -0.06628317f, 
    0.02501850f, -0.02574712f, 0.03443707f, -0.03283251f, -0.00455518f, 0.00097481f, -0.05613883f, 0.03858359f, 
    0.00478520f, -0.05658909f, 0.00145437f, -0.03038219f, 0.04234020f, 0.01366739f, 0.01510710f, -0.03826516f, 
    0.03632649f, -0.02865054f, -0.00956400f, -0.05793782f, -0.04681452f, -0.01903677f, -0.04581697f, -0.06055239f, 
    0.06028525f, 0.02934024f, 0.00897501f, -0.03294401f, 0.05044044f, -0.03151496f, 0.02456753f, -0.02941617f, 
    0.02833649f, -0.04091190f, 0.01481684f, -0.00330767f, -0.03582904f, -0.00216796f, 0.01610522f, -0.04944421f, 
    -0.04366861f, 0.04927585f, 0.03843646f, 0.04075398f, 0.00668717f, 0.00002169f, -0.01342764f, -0.00624015f, 
    0.01564301f, 0.00333578f, -0.00511754f, -0.06083457f, -0.01834030f, -0.05379355f, -0.06449190f, -0.03212493f, 
    0.02124047f, 0.00448706f, 0.00924564f, -0.01885108f, -0.04478025f, -0.02563039f, -0.03875108f, 0.01567785f, 
    -0.01969142f, 0.03083098f, 0.03826700f, 0.02598509f, -0.03693883f, 0.04296633f, -0.01389490f, -0.01043744f, 
    0.04850404f, -0.05675102f, -0.03803170f, -0.06121217f, -0.02630280f, 0.03277532f, 0.03636391f, -0.05375197f, 
    -0.04459717f, -0.05503027f, 0.00931253f, -0.03415119f, 0.02336342f, -0.00714582f, 0.04198441f, 0.04811359f, 
    -0.00023807f, 0.02956237f, -0.01294928f, 0.02948681f, -0.03363782f, 0.02303590f, 0.04457087f, -0.06513844f, 
    0.04000695f, 0.03529951f, -0.00981586f, -0.01204084f, -0.02786238f, 0.01176892f, 0.04506959f, 0.02635998f, 
    -0.02334789f, 0.00479642f, -0.02485290f, -0.05648903f, -0.00837645f, -0.01988464f, 0.02670798f, 0.02988344f, 
    -0.00426626f, -0.03557073f, 0.03136429f, -0.04860102f, 0.03134091f, -0.02691862f, 0.01416906f, -0.04182431f, 
    0.02972199f, -0.03849458f, -0.00574030f, 0.02416220f, -0.00915840f, 0.00734650f, -0.02378765f, -0.02263814f, 
    -0.00193397f, -0.03566469f, -0.03070688f, -0.03496061f, -0.02778875f, -0.01349108f, 0.03133083f, 0.05276175f, 
    -0.02959692f, 0.00613432f, 0.01422209f, -0.02216310f, 0.01355221f, -0.02108137f, -0.04659170f, -0.03282246f, 
    -0.04667613f, -0.05867476f, 0.04705331f, 0.04342954f, 0.01814014f, -0.01762078f, -0.00032647f, -0.02337290f, 
    0.00566707f, 0.04005447f, -0.03373512f, 0.01624001f, -0.02131495f, -0.04440587f, -0.05336462f, -0.01540782f, 
    0.01673672f, 0.01347087f, -0.04013046f, 0.00791651f, -0.03201248f, -0.05351408f, 0.01479423f, 0.02615205f, 
    0.04121044f, -0.03706435f, -0.01321481f, 0.04247974f, 0.01936982f, 0.01523346f, -0.02250064f, 0.00764814f, 
    0.00077758f, 0.05193114f, -0.02820058f, 0.02003478f, 0.02245164f, 0.01243442f, -0.03944849f, -0.03758486f, 
    -0.06064726f, 0.00682476f, -0.03499006f, -0.06460105f, 0.03938600f, -0.02086448f, -0.02220062f, -0.01533893f, 
    0.00010395f, 0.03683888f, -0.05945917f, -0.04743511f, 0.00257042f, 0.01302355f, -0.00733985f, -0.03215349f, 
    0.00536453f, 0.00876096f, -0.03869650f, 0.00382747f, 0.03921880f, -0.03298313f, 0.02429708f, -0.00634153f, 
    -0.01050108f, 0.02592688f, 0.00145135f, 0.04136582f, -0.04133885f, -0.02612051f, -0.02906084f, -0.04130823f, 
    -0.05190707f, -0.00044459f, -0.02893621f, 0.02727346f, 0.03916004f, 0.04437769f, -0.05917343f, -0.02271581f, 
    0.03676943f, 0.03952977f, 0.01363853f, -0.06304633f, -0.01823613f, -0.03141027f, -0.00113425f, 0.03711491f, 
    0.01130675f, 0.00416737f, 0.03683501f, -0.05099428f, -0.01737733f, -0.01604464f, -0.02047714f, -0.03705258f, 
    -0.05209747f, 0.00876586f, -0.03320517f, -0.04469752f, -0.03004000f, -0.04065428f, 0.03833232f, 0.02186494f, 
    -0.04752206f, -0.02717346f, -0.04990928f, -0.04077225f, 0.01885174f, -0.00082168f, 0.04937764f, 0.02892133f, 
    -0.01131765f, -0.05064233f, 0.03535748f, 0.04847845f, 0.02161029f, 0.00638437f, -0.06032058f, -0.06543908f, 
    0.03993654f, -0.03710445f, -0.05023434f, -0.04679437f, -0.00318908f, 0.01752516f, -0.00563486f, -0.04197381f, 
    -0.01927710f, -0.04450835f, 0.00777754f, -0.04785797f, -0.05815228f, -0.05837377f, -0.05193270f, -0.01140005f, 
    0.00082826f, 0.04253896f, -0.05057025f, -0.01349687f, -0.05019335f, 0.02770993f, -0.01354578f, -0.04201863f, 
    0.05042555f, -0.00330885f, -0.06105553f, -0.04102770f, -0.05848140f, -0.02179706f, -0.03419640f, 0.03353604f, 
    -0.05725912f, -0.02974058f, -0.00163537f, 0.04176430f, -0.02788020f, 0.01904620f, -0.02151761f, -0.01323012f, 
    0.01807237f, 0.00279175f, 0.05002036f, 0.04218935f, 0.04446157f, -0.06386621f, 0.03606913f, 0.00640260f, 
    0.03338568f, 0.02939875f, -0.06521481f, -0.04278209f, -0.05099598f, -0.00058298f, -0.03139137f, 0.04293280f, 
    -0.01347738f, -0.02515552f, 0.02472170f, -0.00772300f, 0.02138495f, 0.03688516f, -0.03976039f, -0.04178278f, 
    0.02823938f, 0.05210030f, -0.05202888f, -0.04544961f, 0.00621820f, -0.05140555f, 0.01922976f, 0.02494608f, 
    -0.04414906f, 0.05114229f, -0.05022569f, -0.03626610f, -0.01128431f, 0.00559415f, -0.04640908f, 0.00871296f, 
    -0.00314842f, 0.00983604f, -0.01232740f, 0.02676332f, 0.04138743f, -0.03402178f, 0.00268316f, 0.00109783f, 
    0.00554460f, -0.02058064f, -0.03141384f, 0.00965205f, 0.04608217f, -0.00192419f, -0.03456805f, -0.06443723f, 
    0.00814570f, -0.00243321f, -0.01848767f, -0.01961459f, -0.04575504f, -0.05836264f, 0.04513863f, -0.03832445f, 
    0.02814158f, -0.02189631f, 0.04673029f, -0.03132496f, 0.03657409f, -0.03442997f, 0.01053587f, 0.05026983f, 
    0.03249661f, -0.05788163f, -0.04379457f, 0.04437931f, -0.03494963f, -0.02162100f, -0.04371314f, -0.02715104f, 
    -0.02596779f, 0.00911997f, 0.04785293f, -0.03393388f, -0.02017664f, -0.04323259f, 0.03865438f, -0.04492535f, 
    -0.05337462f, 0.03838079f, 0.03669796f, -0.00338661f, -0.01914449f, -0.03266155f, 0.03321302f, 0.01172042f, 
    -0.02811853f, 0.04180552f, -0.02247806f, 0.03563536f, -0.04543359f, -0.05803400f, 0.04561149f, 0.04033672f, 
    -0.28540882f, 0.15740828f, 0.14036298f, -0.08697531f, 0.05453647f, 0.14491703f, 0.06341415f, 0.05405983f, 
    -0.13460018f, 0.14133839f, 0.05648345f, -0.27750373f, -0.01908671f, 0.06614237f, -0.03780212f, -0.07732035f, 
    -0.01646904f, 0.17010505f, -0.02803870f, 0.13161512f, -0.28186354f, 0.03406773f, 0.12314530f, 0.00645126f, 
    0.06101270f, -0.04902857f, 0.02664580f, -0.01203354f, 0.26300022f, -0.04148543f, -0.01797442f, -0.06081811f, 
    0.06539507f, -0.01970316f, -0.10298748f, 0.08123028f, -0.03406970f, 0.14638351f, -0.01994621f, 0.09739442f, 
    0.06861555f, -0.07738708f, -0.04383728f, 0.04922296f, -0.16802225f, 0.10067854f, 0.17547984f, 0.15214004f, 
    0.01551631f, -0.00359582f, -0.05463900f, 0.07119469f, -0.01640787f, -0.02148389f, -0.01241352f, -0.01388897f, 
    -0.31503186f, -0.04837244f, 0.06262943f, 0.14909987f, 0.06568264f, 0.02170132f, -0.10156294f, 0.06314793f, 
    0.13097404f, 0.02492385f, 0.14762260f, 0.07779269f, 0.03558031f, 0.05811208f, 0.01741784f, 0.14303459f, 
    0.14373970f, -0.03324105f, -0.18677509f, 0.08591260f, 0.11253931f, 0.04567145f, -0.08425243f, -0.22378042f, 
    -0.19412997f, 0.02400265f, 0.02661511f, -0.02229415f, -0.09392674f, -0.13868384f, 0.05194167f, 0.02490312f, 
    0.08537948f, -0.19644809f, 0.03737453f, -0.01389337f, 0.06341295f, -0.00951615f, -0.07095795f, 0.00598650f, 
    -0.04593670f, 0.04198840f, 0.09212971f, 0.01463481f, 0.08190634f, -0.29278573f, 0.04286366f, 0.04326252f, 
    0.24051979f, -0.03519161f, 0.02701306f, -0.03105969f, -0.20735693f, -0.06151581f, -0.19117889f, 0.06408787f, 
    -0.00389678f, 0.05073925f, 0.15973231f, 0.03905569f, 0.03854001f, 0.08044620f, -0.32263446f, -0.23828585f, 
    -0.07797231f, 0.00901297f, -0.22733681f, -0.03076528f, -0.01374432f, 0.16664740f, -0.09273021f, -0.19905393f, 
    -0.15378702f, 0.03956274f, -0.08584372f, 0.02503117f, -0.02813127f, -0.02545404f, 0.04557535f, 0.16117217f, 
    -0.06324547f, 0.19791813f, 0.04281071f, 0.03028738f, 0.02352949f, 0.01104569f, 0.03383142f, 0.05275884f, 
    -0.56331587f, 0.00944969f, 0.08916212f, 0.00087096f, -0.13267276f, -0.19215390f, 0.06020680f, 0.08723044f, 
    0.05719284f, 0.11134131f, -0.01081370f, -0.31311524f, -0.04202127f, -0.10598553f, -0.01164044f, -0.02689044f, 
    0.15773505f, -0.07134999f, -0.01694901f, 0.10016818f, -0.07877835f, 0.06839314f, -0.20191626f, -0.06245897f, 
    0.01023399f, 0.01497893f, 0.00886807f, -0.15669844f, 0.09745352f, 0.00325619f, 0.06853417f, 0.05890277f, 
    -0.06179676f, -0.00468019f, 0.12026072f, -0.07559405f, 0.03438659f, 0.03397609f, 0.03662385f, 0.07831330f, 
    0.17937031f, -0.06422406f, 0.00942809f, -0.01257040f, 0.00827652f, 0.15379408f, 0.03783182f, -0.00206123f, 
    -0.15404454f, -0.04922057f, -0.05548449f, 0.04880880f, 0.08666931f, 0.23697001f, -0.01096189f, -0.05904649f, 
    0.14372170f, 0.07632446f, 0.02028747f, 0.04360947f, 0.03617680f, -0.05119056f, 0.01764491f, -0.13348299f, 
    -0.05441298f, 0.03325195f, -0.18935977f, 0.07965767f, -0.04111180f, 0.12257001f, -0.07682274f, -0.07158414f, 
    0.08003778f, 0.03027679f, 0.00666422f, 0.02600794f, -0.03291946f, 0.13905355f, -0.04883822f, 0.09248354f, 
    0.11001184f, -0.08030962f, -0.09700473f, 0.03522278f, 0.03573834f, 0.08768550f, 0.06798034f, -0.19002779f, 
    0.10390082f, -0.35961419f, 0.11558511f, -0.02417607f, 0.10081073f, 0.04403897f, 0.03856241f, 0.02993303f, 
    0.02215832f, 0.01498485f, 0.07665897f, -0.24706332f, -0.09370025f, -0.09723457f, 0.05623307f, 0.02733555f, 
    -0.05006953f, 0.02163902f, 0.03858447f, -0.03310687f, 0.02658140f, -0.13259853f, -0.13133042f, -0.08724326f, 
    0.09882405f, 0.22767071f, 0.07445803f, -0.04762667f, -0.01728691f, 0.27218246f, 0.16398126f, -0.19879684f, 
    0.05167247f, -0.15417881f, 0.12355880f, -0.00078562f, -0.04051396f, 0.08083046f, -0.07251120f, -0.12670720f, 
    -0.04097220f, -0.02201687f, 0.11567725f, 0.10116057f, -0.06376734f, -0.21169816f, 0.03454857f, 0.00567480f, 
    -0.08382981f, -0.14821397f, 0.23282066f, 0.03800487f, 0.09962368f, -0.07687765f, 0.18259507f, -0.21818192f, 
    0.05344277f, 0.06051440f, 0.00747435f, 0.02747384f, -0.03339451f, -0.03778815f, 0.03981449f, 0.03044659f, 
    0.01824130f, 0.00160309f, -0.04921246f, 0.01084356f, -0.02155130f, 0.03391900f, -0.04278046f, -0.06338327f, 
    -0.00770406f, 0.05820446f, -0.02907156f, 0.04425878f, -0.05113487f, -0.01569732f, 0.01205906f, -0.04257797f, 
    0.02261480f, -0.01934292f, 0.03599047f, 0.03354657f, -0.06192461f, 0.03040216f, 0.04716074f, -0.01449222f, 
    -0.01206333f, 0.02579321f, -0.06642261f, 0.05066042f, -0.05089743f, 0.01047084f, 0.04486417f, 0.04433739f, 
    0.04705370f, -0.02996764f, -0.06054635f, -0.00781704f, -0.04746497f, -0.00067368f, -0.00074748f, -0.04303173f, 
    -0.03992051f, -0.05810643f, 0.02379081f, 0.03621085f, 0.05672055f, -0.04831996f, 0.00973343f, -0.00025714f, 
    0.04810840f, -0.03676853f, 0.00465836f, -0.01702701f, 0.02143415f, -0.05572181f, -0.04146246f, 0.03722062f, 
    0.03343705f, -0.03282003f, 0.02364323f, -0.01321435f, -0.02574235f, -0.06203892f, -0.02082115f, -0.05909623f, 
    -0.06341300f, -0.05553427f, -0.00281042f, 0.01158232f, -0.05899584f, -0.00866146f, -0.05440169f, -0.01799128f, 
    0.00095626f, -0.02071795f, 0.05162517f, 0.00982747f, -0.01526833f, 0.04228480f, -0.03865314f, -0.02716091f, 
    -0.03285783f, 0.01250278f, -0.05822892f, 0.04952421f, 0.00782192f, 0.02029727f, 0.00694749f, 0.03631637f, 
    0.01235329f, -0.00567708f, -0.01589857f, -0.04497062f, -0.03032281f, 0.00240030f, -0.01881503f, 0.00515788f, 
    0.02728552f, -0.04197220f, 0.00801304f, 0.05043424f, 0.03892947f, 0.01785334f, -0.00865437f, 0.01942547f, 
    0.02192011f, 0.02709774f, 0.03157870f, 0.01600451f, -0.05548739f, 0.01910959f, 0.02110714f, 0.03947492f, 
    -0.06552997f, -0.01695531f, 0.01501725f, -0.03288823f, -0.00222229f, -0.05998467f, 0.00264343f, -0.02756190f, 
    -0.00666912f, -0.04647181f, 0.00527926f, -0.05132635f, 0.01882260f, 0.02425654f, 0.04891174f, 0.01221726f, 
    -0.03610485f, -0.03066059f, 0.03667469f, -0.01293662f, -0.05319918f, -0.04918692f, 0.00730751f, 0.03043304f, 
    0.00824275f, -0.00299131f, 0.03128884f, 0.01512521f, 0.01722488f, 0.05049639f, 0.04471049f, -0.03206887f, 
    -0.00153486f, -0.02238420f, -0.02240773f, 0.04884122f, -0.06058467f, 0.02048193f, -0.00042326f, 0.03510271f, 
    -0.03026294f, -0.00950864f, -0.04719923f, -0.02310387f, 0.00018124f, 0.02642275f, 0.02985530f, -0.02511201f, 
    0.01525690f, -0.00763610f, -0.03217835f, 0.02951269f, -0.03496684f, -0.01886118f, -0.06766388f, -0.02506872f, 
    0.03382805f, -0.04812582f, -0.02440390f, -0.03146868f, -0.02149223f, 0.03210193f, 0.01436797f, -0.05196257f, 
    0.05026434f, 0.01095291f, 0.00468124f, 0.04095137f, -0.04801918f, 0.00232528f, 0.03637570f, 0.04630591f, 
    -0.02672994f, 0.01566190f, 0.00099064f, 0.01666646f, 0.03328874f, 0.00521166f, 0.01445782f, -0.05551934f, 
    0.02819960f, 0.04299260f, -0.03154983f, 0.02440093f, -0.03798100f, 0.02610483f, 0.04680348f, -0.00614739f, 
    0.02574175f, -0.02343350f, -0.02980986f, 0.02968539f, 0.03075851f, -0.06375489f, -0.05680174f, 0.02183829f, 
    0.03440574f, -0.01611636f, 0.04700129f, -0.00351654f, -0.04866423f, -0.04481072f, 0.04638951f, 0.02276334f, 
    -0.01687982f, 0.02990669f, -0.01325714f, 0.00996657f, -0.05774032f, 0.02877398f, 0.00451078f, -0.06607828f, 
    -0.05538350f, -0.00364584f, -0.03437673f, 0.03219183f, -0.03719365f, 0.01960783f, -0.04034239f, -0.01169972f, 
    -0.02158860f, -0.04003051f, -0.00069834f, 0.05179631f, -0.01962869f, -0.00734578f, 0.04557437f, -0.00467252f, 
    -0.06324846f, -0.06479008f, -0.02580787f, 0.00916571f, -0.04871760f, -0.02300346f, -0.05048177f, 0.04086937f, 
    0.02437026f, 0.01163497f, -0.05259359f, 0.01949019f, -0.01777055f, 0.00505474f, 0.04854588f, -0.03198086f, 
    0.03389246f, 0.00481634f, -0.02807362f, -0.04981934f, 0.04267738f, 0.02388141f, -0.02937249f, 0.02795310f, 
    -0.01974867f, 0.04791018f, -0.05147839f, 0.00547247f, 0.02788718f, 0.00798755f, 0.05117794f, -0.06614179f, 
    -0.03198134f, -0.04350472f, -0.06971160f, -0.03231678f, -0.02301920f, -0.06540979f, 0.03168233f, -0.01553649f, 
    -0.18619737f, 0.03616939f, 0.20751020f, -0.14979197f, -0.11764316f, -0.16482763f, 0.05320799f, 0.03116439f, 
    0.07059211f, -0.17514566f, -0.21980514f, -0.06129503f, -0.01516867f, 0.06034547f, 0.10425308f, -0.04605098f, 
    -0.04571420f, -0.00157698f, -0.33524677f, 0.17635734f, -0.02887213f, 0.16808534f, 0.03402143f, -0.01295240f, 
    0.08757079f, -0.05178421f, 0.11247229f, -0.33699325f, 0.14727244f, -0.02794751f, 0.03742765f, 0.10461351f, 
    0.06082777f, -0.07759914f, 0.19215497f, 0.11782432f, 0.21037391f, 0.14217959f, -0.11491007f, 0.03551237f, 
    -0.05989464f, -0.08255605f, -0.09749288f, -0.09765501f, -0.03845837f, -0.38181913f, 0.33750832f, 0.01612719f, 
    0.05990327f, 0.17397752f, 0.01899756f, 0.06440192f, 0.07155531f, 0.16319911f, 0.16387755f, 0.08451011f, 
    -0.33373135f, -0.10856873f, -0.03039325f, 0.05036052f, -0.00976236f, 0.04209691f, 0.04885796f, -0.13767116f, 
    0.05475514f, -0.00204570f, 0.02055012f, 0.09030822f, -0.04381961f, 0.05171248f, 0.03651441f, 0.20114358f, 
    -0.06803712f, -0.05314286f, 0.10206063f, 0.03001666f, -0.04298400f, -0.00143811f, -0.10205602f, 0.12389228f, 
    0.02052933f, 0.06218471f, 0.08982112f, 0.12943298f, 0.04541697f, 0.00728159f, -0.04094717f, 0.04122762f, 
    0.07936121f, 0.03904441f, -0.04942309f, -0.03207842f, 0.04679796f, 0.09441418f, 0.03931142f, -0.02497452f, 
    -0.04700456f, 0.04132718f, 0.06996164f, 0.02751616f, 0.04564867f, -0.00467648f, 0.04773359f, 0.03619019f, 
    -0.04401232f, 0.02911528f, -0.03634186f, 0.04799427f, -0.18248312f, -0.16888766f, -0.09163592f, -0.13140424f, 
    0.07251518f, 0.08510540f, 0.05898416f, -0.08848121f, -0.11822554f, 0.02535029f, -0.31604868f, -0.13565102f, 
    -0.07791451f, 0.01910733f, 0.01596114f, -0.10890208f, -0.02503422f, -0.01650498f, 0.31945229f, -0.02824964f, 
    0.00966960f, -0.14242770f, -0.08468650f, 0.04984090f, -0.08575053f, 0.02231687f, 0.13309437f, -0.20294251f, 
    0.11942564f, -0.01329730f, 0.06314196f, 0.02007033f, -0.07039256f, 0.01370452f, 0.06783040f, 0.06665804f, 
    0.40476263f, 0.01840112f, -0.17855182f, -0.05810962f, -0.02819566f, 0.01433847f, -0.05145530f, 0.08502571f, 
    0.02075374f, 0.04850185f, -0.07477995f, -0.11824924f, -0.09021642f, -0.07487227f, -0.03462829f, -0.00339251f, 
    0.02282549f, 0.12578785f, 0.10502376f, 0.08266838f, 0.03665779f, 0.16595665f, -0.00116533f, 0.12602371f, 
    -0.18729819f, 0.06672140f, -0.08802537f, 0.40565056f, 0.07872210f, -0.03300181f, 0.12497732f, 0.22243749f, 
    0.09338384f, -0.20230027f, -0.06084802f, 0.04221296f, -0.41533813f, 0.02256896f, 0.07005069f, -0.05419196f, 
    0.01162017f, 0.07557885f, -0.09590489f, 0.03381666f, 0.13060901f, -0.02385725f, -0.15438770f, 0.01491715f, 
    0.00732718f, -0.16300644f, -0.12554698f, 0.09967656f, 0.04523674f, -0.15073885f, 0.14572598f, -0.19169338f, 
    -0.10988240f, 0.06373393f, 0.13634986f, -0.03862006f, 0.01679287f, 0.02262421f, 0.10766741f, 0.28952155f, 
    0.09959456f, 0.10879547f, -0.05323464f, -0.06697281f, 0.07505697f, 0.01760716f, 0.07804258f, -0.06230990f, 
    -0.05234989f, 0.07603548f, -0.10709457f, 0.01528736f, 0.06352898f, -0.01716937f, -0.02903182f, 0.02366410f, 
    -0.18580191f, -0.08165185f, -0.17154422f, 0.00503858f, 0.10865834f, 0.04858200f, 0.10161672f, -0.06972369f, 
    0.01670280f, -0.02166755f, 0.06535350f, 0.18862112f, 0.06014996f, 0.19433334f, -0.01025686f, 0.15075462f, 
    -0.11369795f, 0.00971293f, -0.02905935f, 0.05286040f, -0.08847214f, 0.07538337f, 0.00368059f, 0.00294326f, 
    -0.02693977f, -0.02264364f, 0.03845230f, 0.02131478f, 0.33046630f, -0.01073133f, -0.11200216f, -0.00809792f, 
    -0.02050170f, -0.06906892f, 0.09668563f, -0.02699696f, 0.08236783f, 0.03801396f, 0.19473416f, -0.11854774f, 
    0.02033611f, 0.12160958f, 0.03828710f, 0.01619445f, -0.02147955f, -0.01322039f, 0.25625935f, -0.26989710f, 
    -0.35690320f, 0.04693028f, -0.00368468f, 0.01088792f, 0.07784240f, -0.12784861f, -0.13234995f, 0.18392019f, 
    0.06560479f, -0.38232869f, 0.06840670f, -0.21742347f, -0.01308433f, -0.06199847f, -0.12981720f, 0.04043960f, 
    0.01630050f, -0.02987789f, 0.01743607f, 0.03948871f, -0.02781977f, -0.00409258f, -0.03715843f, -0.03097886f, 
    -0.00577109f, 0.06272963f, -0.04717955f, -0.04621365f, -0.00346727f, -0.00147534f, 0.05612694f, 0.05083179f, 
    -0.00941000f, 0.03331298f, -0.05097082f, -0.02838216f, 0.04909769f, -0.00593674f, 0.03355284f, 0.02451796f, 
    -0.02551088f, -0.02276580f, 0.04240334f, -0.02141824f, -0.02571095f, -0.06434830f, -0.04259568f, -0.05652020f, 
    0.01146446f, -0.00235612f, -0.01375571f, -0.03309554f, -0.04198483f, 0.00813682f, -0.00326578f, -0.03835559f, 
    -0.06688479f, -0.04736234f, -0.02743197f, -0.02689101f, -0.05517503f, -0.01240880f, -0.04947059f, -0.06295381f, 
    -0.00777956f, -0.05708960f, -0.06205979f, -0.02508246f, -0.05355165f, -0.02798153f, 0.05801675f, 0.03629097f, 
    0.00643304f, 0.04580597f, 0.05204622f, -0.03049404f, 0.02691471f, -0.03912540f, -0.04589023f, 0.03840578f, 
    0.02706973f, -0.05205796f, 0.02237698f, 0.00957951f, 0.02988332f, -0.03997060f, 0.00165814f, 0.02032012f, 
    -0.00724162f, 0.00483514f, 0.04416662f, -0.01458594f, 0.03135251f, 0.02248611f, -0.02296209f, -0.01866723f, 
    -0.05995929f, 0.04828562f, -0.03514884f, 0.03728918f, 0.03398714f, 0.00816615f, -0.04528447f, 0.02113640f, 
    -0.04241928f, -0.00369329f, 0.03465543f, -0.02689162f, 0.03643743f, 0.00095488f, -0.02914460f, -0.01728751f, 
    -0.02616354f, -0.02701649f, 0.01441046f, -0.06153786f, -0.05822710f, -0.05715081f, 0.01935679f, 0.00140609f, 
    -0.03487265f, -0.00540367f, 0.01125918f, 0.00947490f, 0.03650371f, 0.02101000f, -0.04628525f, -0.02231022f, 
    -0.03801575f, -0.03217657f, -0.04814849f, -0.02897369f, 0.02479493f, 0.03086076f, -0.05285532f, 0.04124653f, 
    -0.02666795f, 0.04363404f, 0.02247555f, -0.01825300f, -0.04956154f, -0.02253160f, -0.01429771f, 0.03288066f, 
    -0.06509231f, -0.00193801f, -0.02539396f, -0.04622973f, 0.04849397f, -0.03928696f, 0.02807656f, 0.03440167f, 
    0.04947690f, -0.00872531f, 0.04094883f, -0.06369794f, -0.06143640f, 0.01581228f, -0.02923162f, 0.03205364f, 
    -0.05807903f, 0.02033819f, -0.03653386f, -0.00182168f, -0.04645068f, 0.01039980f, 0.03359860f, 0.00381741f, 
    -0.01881028f, 0.03188777f, -0.04842744f, 0.02398301f, 0.03183293f, 0.03925206f, -0.03336089f, -0.02732287f, 
    0.04932396f, 0.01819928f, 0.01137862f, -0.02832506f, -0.05159384f, -0.06214125f, -0.00442956f, 0.03994505f, 
    -0.05743920f, -0.01824624f, -0.00062818f, 0.02256202f, 0.00926094f, 0.02550572f, 0.02115227f, 0.00545894f, 
    -0.02176385f, -0.03170547f, -0.05173945f, 0.03503219f, -0.03454259f, -0.03823656f, 0.00039104f, 0.00482504f, 
    -0.03685195f, 0.02161472f, 0.03413133f, 0.00784515f, -0.04590200f, 0.02431237f, 0.01521299f, 0.01188037f, 
    0.03104232f, -0.02785052f, 0.04644710f, -0.06069872f, -0.01374262f, 0.03178414f, 0.03357016f, 0.02961217f, 
    -0.04002481f, -0.00883427f, 0.02334734f, 0.02060044f, -0.05197614f, -0.01690978f, -0.03932312f, 0.02070907f, 
    0.00773506f, -0.01502397f, 0.03806571f, -0.00068438f, 0.02513414f, -0.04606313f, -0.03078952f, -0.00406548f, 
    0.05751527f, -0.04665238f, 0.01540075f, 0.04741456f, -0.04243168f, 0.03776003f, 0.04313060f, -0.06219441f, 
    -0.03489845f, 0.05986649f, -0.02732872f, -0.04986776f, -0.03836151f, 0.04185389f, 0.05802407f, -0.03171893f, 
    0.00138627f, -0.06328411f, -0.06235392f, 0.01726867f, 0.01332278f, -0.05513348f, -0.01461586f, 0.02201797f, 
    -0.02291980f, 0.02626727f, -0.05247040f, -0.00214728f, -0.00166586f, -0.05489035f, -0.02756363f, -0.00883761f, 
    0.04380209f, -0.02228210f, -0.01372860f, 0.04640758f, 0.02054975f, 0.02959053f, -0.01765862f, -0.05043340f, 
    -0.04138840f, -0.01188518f, 0.03393789f, -0.02877972f, -0.04326979f, -0.02688141f, -0.01766129f, -0.01320598f, 
    0.04959251f, 0.00896483f, 0.00232841f, -0.02456063f, -0.00902061f, -0.04767679f, -0.00337382f, -0.06638059f, 
    0.00855032f, 0.03098679f, 0.03703467f, -0.04363111f, -0.04023734f, 0.00534610f, -0.00266353f, 0.05352034f, 
    -0.03689494f, -0.01582293f, -0.00132080f, 0.02199200f, -0.03211563f, -0.00443475f, 0.04946461f, -0.01623909f, 
    0.27419704f, 0.11370200f, 0.20761754f, -0.02158285f, 0.00651246f, 0.02391623f, -0.08495156f, -0.06379967f, 
    0.12562156f, -0.15888733f, -0.20228514f, -0.21763833f, -0.15822656f, 0.02919759f, -0.03759140f, -0.07758553f, 
    0.11211000f, 0.06184210f, 0.08212338f, -0.00568085f, 0.22519946f, 0.04625992f, 0.01963056f, 0.01613033f, 
    0.05300218f, 0.02512154f, 0.01491953f, 0.16456234f, -0.19954407f, -0.00959138f, 0.03325429f, 0.08734275f, 
    0.11950617f, -0.02878656f, 0.08274212f, 0.16793002f, -0.14571834f, -0.10270921f, -0.03968297f, -0.03653506f, 
    -0.23457241f, -0.11217136f, 0.07428949f, -0.04959029f, -0.00039401f, 0.07290123f, 0.26989359f, 0.13073966f, 
    -0.09904541f, 0.06576236f, 0.08559208f, 0.06676035f, -0.07188192f, -0.08292682f, -0.10334875f, -0.36477107f, 
    -0.00576108f, 0.13458373f, 0.04636850f, -0.04266910f, 0.04859724f, 0.07401933f, 0.07053429f, 0.04124279f, 
    0.10332102f, 0.14920968f, -0.11001784f, 0.03885757f, 0.00718685f, -0.01189443f, -0.00032462f, -0.08878600f, 
    -0.20745237f, -0.09340946f, -0.22328174f, 0.08960722f, 0.11042918f, 0.10545657f, -0.00787387f, 0.08029984f, 
    0.01221204f, -0.02527553f, -0.08452422f, 0.01208979f, -0.07747457f, 0.03530753f, -0.01940422f, 0.02828192f, 
    -0.01122099f, 0.05371085f, -0.14292116f, 0.11195317f, 0.05434763f, -0.11774410f, 0.00260723f, -0.02786634f, 
    -0.04203324f, 0.01144521f, -0.02691560f, -0.43933803f, 0.06966009f, 0.02952475f, -0.06842653f, 0.03671625f, 
    -0.00833814f, 0.00479977f, 0.02911208f, -0.07928565f, -0.05941078f, 0.10257017f, 0.02684332f, -0.10577787f, 
    -0.04978738f, 0.00124429f, -0.09563541f, -0.02924511f, -0.09897023f, -0.01754072f, -0.02194273f, -0.41234356f, 
    -0.00010153f, -0.10655407f, 0.02589809f, -0.04207577f, 0.07217179f, 0.13846684f, -0.34494928f, 0.29668656f, 
    -0.27278164f, 0.13519269f, -0.04809126f, -0.02111725f, -0.00352233f, 0.03881390f, -0.03078021f, 0.11072543f, 
    0.11237693f, -0.15418044f, 0.06427898f, 0.05621026f, 0.03930840f, 0.03457132f, 0.06914937f, 0.00377263f, 
    0.14556199f, -0.08353247f, -0.03442077f, 0.06341729f, -0.13738120f, -0.06511422f, -0.01977121f, 0.00155022f, 
    -0.01570715f, 0.05418130f, -0.11843412f, 0.12735525f, -0.06673178f, 0.02050223f, -0.02047957f, 0.05421646f, 
    -0.17169751f, -0.10796317f, -0.08077088f, 0.02903005f, -0.09773414f, -0.04022213f, 0.08853766f, -0.03772432f, 
    0.02469958f, -0.00010874f, -0.05322783f, -0.41999233f, 0.23336405f, 0.14444730f, 0.05129145f, 0.07925748f, 
    -0.10314612f, 0.09436786f, -0.09181738f, 0.04687634f, 0.05220913f, -0.00800115f, -0.02348419f, 0.02326618f, 
    0.09501342f, -0.08174457f, 0.00099330f, 0.17983510f, -0.04843817f, -0.00849813f, 0.05084326f, -0.15566592f, 
    -0.02350553f, -0.02420323f, -0.01658049f, 0.11731300f, 0.03657946f, 0.03714175f, 0.01083721f, 0.08049486f, 
    0.01684146f, 0.09846456f, -0.00006558f, -0.10626998f, -0.06219946f, 0.07137734f, 0.08293393f, 0.15200309f, 
    -0.08246884f, -0.01754631f, -0.12624954f, 0.06374743f, 0.12121354f, 0.07858671f, -0.02120165f, 0.10456709f, 
    -0.03382340f, 0.13960446f, -0.27281496f, -0.03855648f, 0.09769481f, -0.01167248f, 0.03922968f, 0.13599229f, 
    0.03183872f, -0.18104766f, 0.00602116f, -0.07029525f, 0.10882729f, -0.09228577f, 0.06536032f, 0.14781165f, 
    -0.11410518f, -0.05917869f, -0.02166875f, -0.20554420f, -0.31471550f, 0.07593909f, 0.06122815f, 0.18389812f, 
    0.02481712f, -0.11980437f, 0.13485563f, -0.47914359f, -0.21665080f, -0.03697261f, 0.08828792f, 0.04433136f, 
    -0.10600942f, 0.01570825f, -0.03107917f, 0.08151469f, 0.03287948f, -0.13297217f, 0.05992364f, 0.03352529f, 
    -0.03745522f, -0.04856084f, -0.01284847f, 0.04741853f, 0.04649940f, -0.17074215f, -0.23283668f, 0.09289096f, 
    0.17865595f, -0.05025862f, -0.06277018f, 0.08271096f, 0.06439816f, -0.02720371f, -0.26848680f, -0.32246882f, 
    -0.11949543f, 0.10921503f, -0.10490235f, 0.09879912f, 0.03522386f, -0.02327435f, -0.00976038f, -0.03728535f, 
    -0.03481529f, -0.01533343f, -0.11717584f, 0.00752739f, 0.01239930f, 0.08764405f, -0.01911790f, -0.09840532f, 
    -0.03317067f, 0.13786304f, -0.09307344f, 0.01065461f, -0.07241246f, 0.09358915f, -0.01003134f, 0.07245530f, 
    -0.05525992f, -0.07402200f, -0.10870790f, -0.16091524f, -0.04681404f, 0.12708095f, 0.00858268f, 0.05249297f, 
    -0.07561903f, -0.05045941f, -0.06265791f, -0.02746675f, 0.20690487f, 0.00462564f, 0.11929341f, 0.02517082f, 
    0.00179852f, 0.09701283f, 0.11197033f, 0.04049057f, -0.15889025f, -0.11212650f, -0.04424291f, -0.04604266f, 
    -0.02011600f, 0.12737224f, 0.14961839f, -0.04998669f, 0.21932113f, 0.15722658f, 0.18349953f, -0.22654681f, 
    0.15830129f, -0.06560794f, -0.12226758f, 0.12160596f, -0.10664497f, 0.07502505f, 0.05572838f, 0.08686023f, 
    0.14638421f, -0.01147201f, -0.18617581f, 0.10888654f, 0.05144798f, -0.05896212f, -0.13426335f, -0.05338879f, 
    -0.07759454f, 0.00047281f, 0.04093958f, -0.01961010f, -0.01795998f, -0.10494149f, -0.07864086f, -0.03137271f, 
    -0.09392892f, -0.02597991f, -0.01566931f, 0.04390174f, -0.01267759f, -0.07446712f, 0.04884223f, -0.06105609f, 
    -0.05718576f, 0.16505195f, -0.13094085f, 0.19356443f, 0.09063359f, -0.07794069f, -0.02452876f, 0.05153822f, 
    -0.02493288f, 0.04751822f, 0.07848341f, 0.08767752f, -0.06840836f, 0.05111155f, -0.05069318f, 0.00214854f, 
    0.01912022f, -0.01760794f, -0.01939980f, 0.01772054f, -0.07050617f, -0.02659931f, 0.18396641f, -0.03630122f, 
    0.05052434f, -0.10008411f, 0.10481218f, -0.16917634f, -0.20199527f, 0.16840643f, 0.05915971f, 0.03893234f, 
    -0.11607768f, 0.07094836f, 0.02248994f, 0.00846990f, 0.01194493f, 0.09243906f, 0.10264196f, -0.14525245f, 
    -0.02854640f, 0.05311842f, -0.03230917f, -0.00101784f, -0.23152123f, 0.03258552f, 0.10381425f, -0.18700467f, 
    0.09362639f, -0.09602972f, 0.00088959f, 0.11017706f, -0.05754662f, 0.16217755f, 0.18669902f, 0.21801390f, 
    0.11371400f, -0.03968142f, 0.02350616f, -0.05705509f, -0.03964230f, 0.05224388f, -0.07155998f, 0.20515504f, 
    -0.01979780f, -0.03768934f, 0.03287604f, 0.05827251f, -0.06576993f, -0.02554133f, 0.04386088f, 0.03474586f, 
    0.19548769f, 0.06934702f, -0.03597907f, -0.01476561f, 0.10233575f, 0.20347436f, 0.08711658f, -0.06327965f, 
    0.10972723f, -0.03556387f, -0.09739374f, 0.40286466f, -0.04322482f, -0.02679280f, 0.06371723f, -0.07697295f, 
    0.11493264f, 0.07781097f, -0.12900420f, 0.17810670f, -0.04478957f, -0.06336095f, -0.13516279f, -0.03128638f, 
    0.03090244f, -0.07854348f, -0.27909470f, -0.05678315f, 0.03578106f, -0.15205534f, -0.08515295f, -0.04397674f, 
    0.02521162f, 0.03281765f, -0.12950277f, 0.10542221f, 0.20147066f, 0.02542691f, -0.03238513f, 0.03840296f, 
    0.01687107f, 0.07115251f, -0.14345402f, 0.09272171f, 0.00350600f, 0.09539991f, -0.04621651f, -0.08700926f, 
    0.11505551f, -0.11661343f, 0.08389213f, 0.09075588f, -0.04871536f, 0.07344647f, 0.11735006f, 0.01733726f, 
    -0.15811564f, -0.07164456f, -0.05125122f, 0.10581709f, 0.10918561f, -0.17902954f, 0.15241306f, 0.14259468f, 
    -0.03571850f, 0.24059080f, -0.16137610f, -0.00524039f, -0.00241191f, -0.03428433f, -0.00342659f, 0.04626325f, 
    0.17696591f, 0.04515423f, -0.19379371f, 0.09480529f, 0.00261678f, 0.00101960f, 0.02286099f, 0.07132651f, 
    0.05378605f, -0.36369634f, -0.15985079f, -0.15353037f, 0.05254953f, 0.05491618f, -0.01518317f, 0.02052232f, 
    0.11579299f, 0.07696895f, -0.10572579f, -0.02974412f, -0.38003176f, -0.00821777f, 0.08787115f, -0.07930390f, 
    -0.05773655f, -0.02498551f, -0.09231661f, -0.25323138f, -0.20151778f, -0.00182969f, -0.06444176f, -0.09852033f, 
    0.04123698f, 0.03163448f, 0.09215711f, -0.07817174f, 0.12183253f, -0.00983432f, 0.06143793f, -0.15066791f, 
    -0.01757128f, 0.04038351f, -0.03195116f, -0.08893558f, 0.06488447f, -0.12129761f, -0.08923282f, -0.08009855f, 
    0.17251912f, 0.02008672f, 0.02803590f, 0.08098563f, -0.10830186f, -0.00421284f, -0.10810020f, -0.15960413f, 
    -0.07944495f, 0.05252129f, -0.20435575f, 0.15163387f, 0.06563297f, -0.01547219f, -0.01475660f, -0.04917682f, 
    0.14164035f, 0.13113996f, -0.04944418f, -0.00133050f, -0.02779507f, -0.00248043f, 0.22386186f, -0.14742164f, 
    -0.06382058f, 0.15555240f, -0.10309023f, -0.10022933f, 0.07032527f, 0.05168984f, -0.08194153f, -0.07921088f, 
    0.22655271f, -0.06514499f, -0.00717989f, -0.06306939f, -0.02888241f, 0.14169462f, -0.03450778f, 0.12257177f, 
    0.06376292f, -0.13686013f, 0.21212333f, 0.18857034f, -0.01237926f, 0.10511965f, -0.00502176f, -0.14122266f, 
    -0.05473524f, 0.06173437f, 0.15760958f, 0.20008823f, 0.15496983f, -0.23491178f, 0.17647758f, 0.01221864f, 
    0.15099666f, 0.05180554f, 0.06622300f, 0.01382884f, 0.07109894f, -0.11441310f, 0.13981329f, 0.13391906f, 
    0.01870895f, -0.05120478f, -0.14442624f, -0.20426664f, 0.03075026f, 0.20678192f, -0.13331129f, 0.04336387f, 
    0.07931204f, 0.04969611f, 0.00086268f, 0.08896282f, 0.03435524f, 0.00953519f, -0.24541962f, 0.05198868f, 
    0.06534806f, -0.03138601f, -0.04597519f, -0.08380843f, -0.03772251f, -0.07334442f, 0.07048371f, 0.01132556f, 
    -0.03214587f, -0.03692323f, -0.01133995f, -0.04372659f, 0.00121443f, 0.00042630f, 0.08660899f, 0.09745494f, 
    0.09817346f, 0.17335851f, -0.24810661f, 0.08075705f, 0.08717027f, -0.02762007f, -0.07128011f, 0.18012917f, 
    -0.05232942f, -0.08077291f, -0.10969389f, 0.12548000f, -0.11294374f, 0.04360555f, 0.06894688f, 0.03379733f, 
    0.11814243f, -0.01683226f, 0.05762559f, 0.05484571f, 0.04945213f, 0.09618727f, -0.04171631f, -0.03376612f, 
    0.21833986f, -0.08100505f, 0.01697505f, -0.05494641f, 0.13720176f, 0.08294652f, -0.00374731f, -0.00184557f, 
    -0.02960069f, 0.01427587f, -0.08725942f, -0.07781246f, 0.17278920f, -0.05150777f, 0.12095341f, -0.01933692f, 
    -0.10455406f, -0.23645148f, -0.05319538f, 0.06663521f, -0.12361923f, 0.00910289f, -0.00694894f, -0.12262452f, 
    -0.04960547f, 0.06572581f, 0.08670080f, -0.05875504f, 0.04819204f, 0.06533622f, -0.11065558f, -0.02532628f, 
    0.05515095f, 0.05369502f, -0.03302013f, 0.00830561f, -0.09981839f, -0.12796898f, 0.00010866f, 0.27973455f, 
    -0.08552784f, -0.24302021f, 0.07893609f, 0.03853867f, -0.01874043f, 0.14741676f, 0.09555532f, -0.09837296f, 
    -0.02102785f, -0.13201612f, -0.00693236f, -0.02051864f, -0.02793309f, 0.04057208f, -0.14734069f, 0.05216813f, 
    0.05482053f, 0.01123970f, -0.27552009f, 0.10667507f, -0.00525819f, 0.02803895f, 0.08056319f, -0.19173604f, 
    -0.12472665f, -0.02500501f, -0.05254975f, 0.16775909f, -0.10732576f, 0.13929093f, -0.04497859f, 0.09100511f, 
    0.04377829f, 0.01575162f, -0.11813543f, -0.03345150f, 0.03182446f, -0.10522889f, 0.14356971f, 0.00119133f, 
    0.09970029f, 0.01221689f, 0.12564075f, 0.13333562f, 0.07261796f, 0.17650597f, -0.09810618f, -0.03900769f, 
    0.02933647f, 0.03516462f, 0.12193891f, 0.02352609f, 0.03826913f, 0.02082418f, -0.05890257f, -0.09085044f, 
    -0.00903697f, -0.01101225f, 0.03017572f, 0.14829317f, -0.13537185f, -0.13196672f, 0.31531030f, -0.14137480f, 
    -0.12444632f, -0.02707919f, -0.00041859f, 0.06203378f, 0.06157129f, -0.13736886f, -0.01809538f, -0.00206757f, 
    0.00828584f, 0.17599373f, 0.04081907f, -0.01514946f, 0.11204365f, -0.01626133f, -0.08980522f, -0.12279981f, 
    0.13965620f, 0.07883835f, -0.23233482f, 0.07367215f, 0.17116319f, -0.02551245f, 0.11162088f, -0.06876613f, 
    -0.20667599f, -0.17897972f, -0.19886260f, -0.24540539f, 0.04047869f, -0.05310472f, 0.02557001f, -0.10747104f, 
    -0.02740619f, -0.09985524f, 0.07778083f, 0.09670903f, -0.19922647f, -0.01237732f, 0.04994562f, 0.10078987f, 
    0.01676425f, -0.05578193f, 0.10454533f, -0.04400269f, -0.15511766f, 0.16164392f, 0.00522204f, 0.02094077f, 
    0.10026760f, -0.07695399f, -0.13972358f, -0.17193060f, 0.16874740f, 0.08893872f, -0.07301570f, -0.05282879f, 
    -0.10016859f, 0.11309916f, 0.00502925f, -0.05355887f, 0.07102872f, 0.19806740f, 0.19567345f, -0.17178454f, 
    0.10351820f, 0.08902530f, -0.05566621f, 0.02195368f, -0.00081134f, 0.03312820f, -0.27686208f, -0.12782860f, 
    -0.03971365f, -0.07313826f, -0.13200644f, 0.05955297f, -0.03748041f, 0.01007675f, -0.08782709f, -0.12376502f, 
    -0.08367864f, 0.17736210f, 0.01185227f, -0.23764369f, 0.01184120f, -0.10202598f, -0.08445142f, 0.09022181f, 
    0.05100847f, -0.05393665f, -0.02886373f, 0.04269718f, 0.02976883f, 0.03876671f, -0.01553683f, 0.05030996f, 
    -0.00296445f, 0.02372495f, 0.03689595f, -0.04085056f, -0.02478309f, -0.04077955f, 0.03326139f, -0.02325039f, 
    0.02317441f, -0.03688490f, -0.03235570f, -0.05670215f, -0.00097780f, 0.02155088f, -0.03336843f, 0.02639865f, 
    -0.00255223f, -0.04716127f, -0.01039328f, 0.03851000f, 0.01730606f, 0.00298461f, 0.03780781f, -0.02338200f, 
    0.00874819f, -0.02448263f, 0.04458382f, 0.01061930f, 0.00995036f, -0.04659339f, -0.00514825f, -0.03416689f, 
    0.01826487f, -0.05222616f, 0.02756663f, 0.00785265f, -0.01926325f, -0.03930899f, -0.00844210f, 0.03205156f, 
    -0.04775055f, 0.03495033f, -0.05962111f, -0.06515415f, 0.01852614f, -0.02906064f, -0.01448044f, 0.03534807f, 
    0.00773540f, -0.03170636f, 0.04284016f, -0.05167135f, -0.01819637f, 0.01679312f, 0.03680212f, 0.03196206f, 
    -0.04910715f, 0.04240052f, -0.04711862f, -0.01101579f, -0.00245787f, 0.01931616f, -0.06196487f, 0.03538143f, 
    -0.00275577f, 0.03564198f, 0.01257166f, -0.03268774f, 0.00152925f, -0.00682981f, 0.00661512f, 0.01388779f, 
    0.05066579f, 0.04963210f, 0.00987896f, -0.04371941f, 0.02922845f, 0.03775878f, -0.01444013f, -0.00009503f, 
    -0.04322881f, 0.02794315f, 0.00860165f, -0.03288774f, 0.01255355f, -0.02724000f, 0.01993652f, -0.03587220f, 
    0.00530608f, 0.01048743f, 0.02305793f, -0.04810103f, -0.04681144f, -0.05836931f, 0.04647540f, 0.03209941f, 
    0.01366536f, 0.02042371f, -0.06408387f, -0.03894675f, -0.02842386f, 0.02225759f, 0.00778113f, 0.01341148f, 
    0.03113212f, -0.02772022f, -0.05302336f, -0.02422124f, -0.04881736f, -0.05494544f, -0.04855588f, -0.06482336f, 
    -0.05159507f, 0.01327437f, -0.03373149f, 0.00966717f, -0.05588936f, 0.03349438f, -0.02592901f, -0.04480622f, 
    -0.04094712f, 0.00551431f, -0.03972752f, 0.01254333f, 0.05100271f, -0.01778566f, -0.05142377f, 0.05272685f, 
    -0.04840962f, 0.03021221f, 0.00096660f, 0.01670788f, -0.05119878f, -0.05978958f, -0.03082691f, 0.02934683f, 
    0.01490013f, 0.00726151f, 0.00744841f, -0.04564386f, 0.00555530f, 0.03662936f, 0.00879057f, 0.04627853f, 
    -0.01466526f, 0.04809336f, 0.00195679f, -0.01425168f, -0.02300127f, 0.02935292f, 0.01128667f, 0.02398809f, 
    0.06246870f, -0.00899409f, -0.06713606f, -0.03113492f, -0.01874147f, -0.04802612f, 0.03880161f, 0.04724815f, 
    -0.04830183f, 0.02012207f, 0.02484413f, -0.02576052f, 0.02059444f, 0.03994232f, -0.05015248f, -0.01475750f, 
    -0.02546123f, 0.03821322f, 0.04079362f, -0.04558627f, -0.03056956f, 0.02603288f, -0.03249741f, -0.02580528f, 
    -0.02252218f, -0.05488721f, 0.04361536f, 0.00204532f, -0.04413971f, 0.05048074f, -0.03118384f, -0.05662294f, 
    -0.05507714f, 0.04251247f, -0.03830893f, -0.03549810f, -0.05421402f, -0.02435918f, 0.02012626f, 0.01986163f, 
    0.03545017f, -0.00307791f, 0.03979957f, -0.06419414f, -0.00261632f, -0.00015570f, 0.02704031f, 0.04308163f, 
    0.01037751f, -0.02808825f, -0.05241713f, 0.02788216f, -0.06258055f, 0.01745187f, -0.04243680f, 0.04161065f, 
    0.02068035f, 0.01248844f, 0.00900385f, 0.03552141f, 0.01287078f, -0.06128929f, -0.01528926f, 0.01264430f, 
    -0.05996458f, 0.02875783f, -0.01924886f, 0.00520202f, 0.00381480f, -0.00480583f, -0.03505958f, 0.02243766f, 
    -0.05123588f, 0.03336980f, 0.01320366f, -0.05052825f, -0.03867185f, 0.03215703f, -0.06195787f, -0.05982250f, 
    -0.02926574f, -0.03943246f, -0.04564239f, -0.03552493f, 0.03803523f, -0.06338880f, -0.05557897f, -0.05979592f, 
    0.04427899f, -0.05901371f, -0.01662694f, -0.05866126f, -0.01000017f, -0.02938673f, -0.00707790f, -0.01327829f, 
    -0.06035896f, 0.02818896f, -0.00100201f, -0.02263184f, -0.04210764f, -0.02358302f, 0.02424267f, -0.03476495f, 
    0.01442969f, -0.05410069f, 0.04303728f, 0.04736695f, -0.03250715f, 0.03082087f, 0.00733555f, -0.00590859f, 
    0.01306297f, 0.00397944f, 0.06257069f, -0.02196118f, 0.02364211f, 0.02963242f, -0.02544517f, 0.00723734f, 
    0.00904581f, 0.01180121f, 0.00244677f, 0.01722677f, -0.02843721f, -0.01071019f, -0.05893113f, -0.03238152f, 
    -0.01826112f, -0.01792484f, -0.00180621f, 0.03616432f, -0.01905713f, -0.03956315f, -0.04180110f, -0.01350701f, 
    -0.05855952f, -0.03104005f, -0.05394527f, 0.04191026f, -0.03415386f, 0.03085989f, 0.00909868f, -0.04977682f, 
    -0.03337820f, -0.01060623f, 0.03358563f, 0.01476017f, 0.02119385f, -0.02801765f, -0.01749207f, -0.00533579f, 
    0.02983625f, -0.03491303f, 0.00985723f, -0.02997785f, -0.02862852f, -0.00279295f, -0.03725277f, 0.00873285f, 
    -0.06270443f, 0.04560242f, -0.05950266f, -0.05203600f, 0.03771509f, 0.05279921f, 0.04355013f, -0.00737752f, 
    0.04711226f, 0.00266683f, -0.04280797f, 0.03078255f, 0.03140023f, -0.01233343f, 0.02983047f, -0.01613838f, 
    -0.02860372f, -0.06455950f, -0.01544773f, 0.00650793f, 0.01174543f, 0.03438786f, 0.04736767f, 0.04375929f, 
    -0.03751846f, 0.00234251f, 0.00830330f, -0.04418363f, -0.05118314f, -0.03656732f, -0.03909495f, -0.06417046f, 
    0.03366572f, -0.01324519f, -0.04885694f, -0.04354923f, 0.01756331f, 0.00069173f, -0.05264710f, -0.02140179f, 
    0.01177625f, 0.03119163f, -0.00180251f, 0.02922241f, -0.04557016f, -0.04917365f, -0.00385984f, -0.02601223f, 
    -0.04844063f, 0.01550226f, -0.01359073f, 0.04283033f, 0.04276791f, 0.00764374f, -0.04889658f, -0.02089186f, 
    0.03643576f, 0.01022868f, 0.01876161f, 0.01220031f, 0.03670839f, -0.03299049f, 0.01525714f, 0.01684568f, 
    0.03656834f, 0.00104349f, 0.03730437f, -0.05178808f, 0.03370268f, -0.00073441f, 0.00622848f, -0.02791237f, 
    -0.02870952f, -0.06049807f, -0.02993802f, -0.00517801f, 0.02280612f, -0.00284735f, 0.05363625f, 0.02844408f, 
    0.04044736f, 0.03578972f, -0.05342273f, 0.00333463f, 0.05378520f, -0.03009734f, 0.05062618f, 0.01459234f, 
    -0.05383859f, -0.00553101f, 0.02855127f, -0.05416806f, -0.03928947f, 0.01886615f, 0.02320027f, 0.01934845f, 
    0.03040452f, -0.05307169f, -0.03359313f, 0.04279704f, 0.03495314f, 0.05293947f, 0.00532935f, -0.04513476f, 
    -0.05201996f, -0.02473299f, -0.06502461f, 0.02229053f, 0.01886714f, -0.00085515f, -0.01702091f, 0.03967391f, 
    -0.04171582f, 0.01914626f, 0.04973044f, -0.01699302f, 0.02557929f, 0.03874335f, -0.05201629f, 0.03245609f, 
    0.04100819f, 0.02813346f, 0.01418350f, -0.01570519f, -0.06207936f, -0.00480286f, -0.04223401f, 0.01193195f, 
    0.02637584f, 0.02805047f, -0.03981654f, -0.00006326f, -0.05439816f, -0.06536606f, -0.05245509f, -0.03324734f, 
    0.01922407f, -0.00933874f, -0.04253188f, -0.02480821f, -0.02123181f, 0.03483312f, -0.03864357f, -0.02771323f, 
    -0.02788975f, 0.00693610f, -0.01977296f, 0.04587640f, -0.00606864f, -0.03137534f, -0.01401796f, 0.04973541f, 
    -0.05094143f, -0.05255310f, -0.04367491f, -0.05797965f, -0.02191195f, 0.03484400f, -0.02353166f, -0.02494178f, 
    -0.03234196f, -0.03330180f, -0.05839222f, -0.04071066f, -0.00491071f, 0.02760782f, -0.06148490f, -0.01042065f, 
    -0.05050112f, -0.04676509f, 0.01460049f, -0.03849369f, -0.03495820f, -0.03697019f, 0.01244192f, -0.05824994f, 
    -0.06014706f, -0.01779972f, -0.05183270f, -0.00966142f, -0.00584990f, -0.03961185f, 0.02382812f, 0.04385833f, 
    -0.06050309f, 0.00457274f, -0.02656366f, -0.06176076f, -0.05646201f, 0.00863937f, 0.03558654f, -0.02352848f, 
    -0.05028275f, -0.03772051f, 0.02050684f, 0.05332109f, -0.02861580f, 0.02574887f, 0.03991036f, -0.05149262f, 
    0.03500804f, 0.03205803f, 0.00281106f, 0.03209199f, -0.01649689f, -0.04879588f, -0.05655060f, -0.03769616f, 
    0.01505688f, -0.03356564f, -0.01128630f, 0.04188720f, 0.01146920f, -0.06130013f, -0.01085987f, -0.05162755f, 
    -0.04033147f, -0.05500165f, 0.02124063f, -0.06445426f, 0.02338098f, 0.01224380f, 0.03275380f, -0.00235926f, 
    0.03902768f, 0.02510123f, -0.01328893f, 0.04187422f, -0.01601568f, 0.02731933f, -0.02683887f, -0.00589659f, 
    0.01710151f, 0.01061019f, 0.02261821f, 0.03583665f, 0.04212142f, 0.04629403f, 0.04968894f, 0.03360524f, 
    -0.05886564f, -0.04472704f, -0.04962593f, 0.01264661f, -0.02977601f, 0.02896264f, -0.05033220f, 0.01962155f, 
    -0.04211742f, -0.01544772f, 0.01004186f, 0.01756865f, 0.02752083f, -0.03989770f, -0.06546450f, -0.06055457f, 
    -0.04682150f, -0.06869193f, 0.13499658f, -0.00669375f, -0.00682128f, -0.16791399f, 0.02040517f, 0.19375485f, 
    0.12797856f, 0.09206517f, -0.05031361f, 0.10524873f, 0.01595978f, -0.04305089f, -0.12904008f, -0.09627935f, 
    0.06554058f, -0.01647391f, -0.09920859f, 0.06965102f, -0.03694553f, 0.00814046f, 0.05220265f, 0.06865853f, 
    -0.10382791f, 0.07626460f, -0.14962295f, 0.07126155f, -0.04746081f, 0.14128383f, -0.02198492f, 0.01752296f, 
    0.08405688f, -0.09854438f, 0.11932717f, -0.00529685f, 0.24059898f, 0.08265234f, 0.08905574f, 0.10927878f, 
    0.13772252f, 0.10213371f, 0.04417190f, 0.03900869f, -0.08003730f, -0.34161112f, -0.18043065f, -0.16521618f, 
    0.14835355f, 0.01884861f, 0.13341600f, -0.07928041f, 0.01833736f, 0.04278330f, 0.13528781f, -0.02169066f, 
    -0.02860398f, -0.03291001f, -0.07001655f, -0.09133563f, 0.09949265f, 0.08046877f, -0.07050633f, -0.19756500f, 
    -0.11473063f, 0.11331995f, 0.00779097f, -0.02280689f, -0.06188227f, 0.08848559f, 0.00874961f, 0.22724339f, 
    0.09212626f, 0.01429523f, 0.00789681f, -0.06495383f, 0.15006925f, 0.02734924f, -0.10121751f, 0.02358199f, 
    -0.06416392f, 0.16689666f, 0.15183620f, -0.02801026f, -0.09086525f, 0.02302764f, 0.01054756f, 0.04376324f, 
    -0.00200533f, 0.09476560f, -0.14744388f, -0.05658421f, 0.09644500f, 0.07837672f, 0.06805035f, 0.03403674f, 
    0.19182435f, -0.04164431f, -0.10033387f, -0.05889366f, 0.01760667f, 0.06052106f, 0.02433623f, 0.05932842f, 
    0.06847678f, -0.07455622f, 0.13562296f, 0.04893737f, -0.06408271f, 0.17382956f, -0.05076584f, -0.01454655f, 
    -0.04325484f, 0.05370907f, -0.01860357f, -0.03836362f, -0.03227556f, -0.00674394f, -0.03659355f, -0.07331165f, 
    -0.09138495f, 0.00153319f, 0.01264071f, 0.02182445f, 0.19792220f, -0.10863317f, -0.06791634f, 0.10768002f, 
    -0.09401824f, 0.06438816f, 0.04731363f, -0.03612123f, -0.06398650f, 0.08298213f, 0.00728057f, -0.34135392f, 
    -0.08137712f, -0.02451557f, 0.08288544f, 0.06581151f, -0.00651919f, 0.15547697f, -0.03530953f, 0.05974412f, 
    -0.20379514f, 0.01734941f, -0.18303016f, 0.05442650f, -0.00275266f, -0.17476848f, 0.05204659f, 0.03955912f, 
    0.07741867f, 0.17115946f, 0.06290489f, 0.08226884f, 0.03351859f, 0.05866507f, 0.12819561f, 0.16525981f, 
    0.03051579f, -0.16043495f, -0.05595858f, -0.05209333f, 0.01373302f, -0.12925100f, -0.08687156f, 0.00750977f, 
    0.12296229f, 0.10538604f, -0.09648150f, -0.02477308f, 0.17727911f, 0.16233456f, 0.00210357f, -0.09840970f, 
    -0.05587655f, 0.09366950f, -0.03083634f, -0.11497229f, -0.39801264f, -0.15546279f, -0.09107307f, -0.02011301f, 
    0.03314425f, 0.08075327f, 0.02860761f, 0.08175397f, 0.08840071f, -0.02650943f, -0.17311731f, 0.11151028f, 
    -0.13595060f, -0.04026883f, 0.14465287f, -0.05014932f, 0.16456398f, -0.07031304f, -0.23003137f, -0.02813322f, 
    -0.27028418f, 0.08937576f, 0.04776543f, -0.07742675f, 0.03018684f, 0.02726284f, 0.08093227f, 0.19716075f, 
    0.26909795f, -0.08569649f, -0.03284258f, 0.04735256f, -0.03816621f, 0.02752462f, 0.05329077f, 0.00030516f, 
    0.15895629f, -0.11531176f, -0.09536899f, 0.11511895f, 0.09336706f, -0.01602863f, -0.08134291f, 0.11026763f, 
    0.00019850f, 0.24121585f, -0.09596647f, 0.05164662f, 0.04400880f, 0.05571572f, 0.03118107f, -0.22672348f, 
    0.04518909f, -0.09764773f, -0.29190516f, -0.08340678f, 0.16088937f, 0.19455168f, 0.06603656f, 0.05456860f, 
    -0.01488889f, -0.23705612f, 0.01408799f, 0.25439113f, -0.08597620f, -0.12819694f, 0.00031142f, -0.08364403f, 
    0.02077211f, -0.02751513f, 0.00941664f, -0.09548191f, 0.06620959f, -0.00090561f, -0.00061891f, 0.10853860f, 
    -0.02046173f, -0.01010056f, 0.00353797f, 0.07463029f, 0.04075135f, -0.45085824f, -0.11021240f, 0.15343416f, 
    0.00067377f, -0.01667768f, 0.11156282f, -0.05518483f, 0.04126706f, 0.01913710f, -0.03723337f, 0.07193273f, 
    -0.01595080f, -0.17608453f, -0.14781080f, 0.05665778f, 0.05521826f, -0.03142381f, 0.06660834f, -0.13400169f, 
    0.04514467f, 0.03368536f, -0.12103181f, -0.00225866f, -0.06829038f, -0.15299748f, -0.00798033f, 0.02205195f, 
    0.31268662f, 0.00436722f, -0.19488561f, 0.07020630f, 0.01826952f, -0.06770042f, -0.02424652f, -0.04832309f, 
    -0.00039413f, -0.30573022f, 0.02094904f, -0.00647933f, -0.12974763f, -0.09897051f, 0.05706969f, -0.19535217f, 
    -0.01764412f, -0.03689421f, 0.14312491f, 0.04100074f, 0.02340921f, 0.05003022f, -0.07783163f, 0.18461424f, 
    -0.13356088f, 0.07281008f, 0.03486408f, 0.05446253f, 0.01579327f, -0.07051869f, -0.00961844f, 0.02396425f, 
    -0.10059270f, 0.20208721f, 0.14118144f, 0.04172846f, 0.00295925f, -0.10952742f, -0.01424221f, 0.11115904f, 
    -0.08084257f, 0.06140206f, -0.03298911f, 0.09934233f, 0.05779744f, 0.02703802f, 0.15827292f, -0.01985071f, 
    -0.08895304f, 0.00636822f, 0.05074762f, -0.11157143f, 0.02051967f, 0.02812136f, -0.24405137f, 0.18700978f, 
    -0.21349774f, -0.00493336f, 0.03143450f, -0.21481326f, 0.14164187f, 0.00738063f, -0.07962096f, -0.01609932f, 
    0.12304221f, 0.25098157f, -0.02992690f, -0.00988470f, 0.07505788f, 0.15952536f, -0.03874947f, 0.00085077f, 
    -0.02720683f, 0.14950739f, -0.14797549f, 0.06834251f, 0.10278476f, 0.18054934f, -0.04081007f, 0.08908329f, 
    0.01008164f, 0.01166409f, -0.11476441f, 0.14330181f, 0.10069178f, -0.05020018f, 0.18719788f, -0.07887838f, 
    0.10849425f, -0.08178612f, -0.09165614f, 0.09498346f, -0.06348709f, -0.06230020f, 0.03396030f, 0.02538520f, 
    -0.08187394f, -0.00684619f, 0.11120841f, 0.01338507f, 0.03419204f, 0.02869548f, -0.00075640f, -0.00426712f, 
    0.08035190f, -0.00150344f, 0.08201951f, 0.08912663f, 0.38382769f, 0.02021664f, 0.22208339f, -0.05858058f, 
    0.04424426f, -0.07467092f, 0.08852289f, -0.15738484f, 0.05092770f, -0.10462634f, 0.10686710f, -0.30320266f, 
    0.03290398f, 0.00223481f, -0.12385476f, -0.03291061f, -0.01799800f, 0.01073708f, -0.00666027f, 0.04293942f, 
    -0.03285414f, 0.00828869f, -0.03405686f, -0.04499004f, -0.09760088f, -0.17882003f, 0.02795303f, 0.08731049f, 
    0.03707325f, -0.14629444f, -0.11928389f, -0.13552482f, -0.07335944f, 0.05256395f, 0.12940529f, 0.01340201f, 
    -0.01901311f, 0.11553092f, -0.03011119f, 0.02061985f, 0.11388458f, -0.07049756f, 0.01658164f, 0.02564954f, 
    -0.03874163f, 0.22085890f, -0.06358966f, -0.01818124f, 0.05195755f, -0.17640384f, -0.04563368f, -0.02499645f, 
    0.06326184f, 0.10153374f, -0.04845946f, -0.11857058f, 0.00010792f, 0.12081172f, 0.05120406f, 0.09520105f, 
    -0.01066818f, -0.09249472f, -0.02455115f, -0.02354923f, -0.10509629f, 0.04001673f, 0.15864927f, 0.14359020f, 
    0.04643142f, -0.11760276f, -0.07048672f, 0.09711619f, 0.43063229f, 0.04198560f, -0.00884602f, -0.06672208f, 
    -0.04205192f, -0.06349923f, 0.05151893f, 0.02479080f, 0.00878210f, -0.23620042f, 0.00601339f, -0.09440028f, 
    0.08764539f, 0.07522216f, -0.01727909f, 0.11257536f, -0.03625618f, 0.12808986f, -0.11026740f, 0.03451955f, 
    -0.33409306f, -0.18433921f, -0.06207128f, -0.05716120f, -0.02227131f, -0.03349610f, -0.00535470f, 0.21714324f, 
    -0.15264396f, 0.12848723f, 0.00307390f, -0.19182847f, 0.04704887f, 0.06768584f, 0.01826332f, 0.05149109f, 
    -0.15785222f, -0.03226531f, 0.04911907f, 0.05448700f, -0.00082397f, -0.01080416f, 0.00586418f, -0.13192572f, 
    0.04431692f, -0.24065985f, -0.13725977f, -0.16162689f, 0.04329503f, 0.01836697f, -0.07343166f, 0.13591230f, 
    0.01863700f, -0.02715350f, -0.06076545f, -0.03149238f, -0.12961254f, -0.02421242f, -0.12104273f, 0.13339642f, 
    0.18958743f, 0.05391632f, -0.01421228f, -0.33629939f, -0.33700210f, -0.03918984f, -0.01723934f, 0.07078070f, 
    -0.00799937f, -0.09704167f, 0.08022221f, -0.06998874f, -0.15861475f, -0.09899269f, -0.02220527f, -0.02950113f, 
    0.01035094f, 0.08295213f, -0.17617644f, 0.00886611f, 0.06738029f, -0.12293902f, 0.07698151f, 0.00481686f, 
    -0.04099289f, -0.05618768f, -0.01531727f, -0.03224440f, 0.01094878f, -0.15073332f, -0.25721750f, -0.32559168f, 
    -0.03446222f, 0.13055393f, 0.02120041f, -0.04300594f, 0.03084887f, -0.05094938f, 0.08219335f, 0.30321878f, 
    -0.33430785f, 0.22523458f, 0.02199641f, 0.09066427f, -0.01779290f, -0.01934210f, 0.14740860f, 0.11330584f, 
    0.26400149f, -0.12556326f, 0.03670592f, -0.19030270f, -0.05595186f, -0.01734158f, -0.01606482f, -0.22156167f, 
    0.05189503f, 0.22028773f, 0.01365794f, -0.07709423f, 0.00720453f, 0.25132570f, 0.20024237f, -0.01195311f, 
    0.13931306f, 0.08460380f, 0.10358244f, -0.02627240f, 0.15385759f, 0.08439100f, 0.03481309f, -0.00488275f, 
    0.00972362f, 0.12703173f, 0.18215613f, 0.11756600f, -0.00775976f, 0.04585020f, 0.02788953f, -0.05147119f, 
    -0.08401880f, 0.00914655f, 0.06653431f, 0.02868538f, 0.02380996f, 0.05529097f, -0.03032475f, 0.00092314f, 
    -0.05411790f, 0.08946134f, -0.04288898f, -0.00122235f, -0.01471210f, -0.15658002f, -0.13262342f, -0.09867155f, 
    -0.00885633f, 0.14186196f, -0.04178701f, 0.10309841f, 0.10578377f, -0.10000812f, -0.02345242f, 0.16993605f, 
    -0.05648758f, -0.04355459f, 0.07778819f, 0.01337375f, 0.03248225f, 0.08234495f, -0.05025263f, 0.05407769f, 
    -0.06189946f, -0.08886335f, -0.09209613f, 0.27965710f, 0.01530196f, 0.16332746f, 0.01427398f, -0.19900277f, 
    0.13126257f, -0.00178284f, 0.08180105f, 0.11896271f, 0.03606128f, -0.15431696f, 0.05888025f, 0.11904364f, 
    -0.04427015f, -0.07058905f, 0.12309328f, 0.03060464f, 0.11523887f, 0.11462369f, 0.03247508f, -0.07704934f, 
    0.07275636f, 0.20559102f, 0.16143394f, -0.08369729f, -0.11651937f, -0.01750740f, -0.02275229f, 0.12156808f, 
    -0.12785885f, 0.07880007f, -0.08317445f, -0.00343842f, -0.07352157f, -0.02015058f, -0.03872189f, 0.07526211f, 
    0.02844270f, 0.11057013f, 0.03897896f, 0.01316336f, 0.11731492f, 0.05372608f, 0.03312437f, -0.10461687f, 
    -0.02880880f, -0.02969010f, 0.01217884f, 0.28420293f, 0.05039239f, 0.10282222f, 0.10478141f, 0.06175117f, 
    -0.09920286f, -0.06640936f, 0.08730867f, -0.05422318f, -0.04257869f, -0.01824480f, 0.00419273f, -0.05405325f, 
    -0.01401382f, -0.05994781f, 0.01577117f, -0.01182719f, 0.03756323f, -0.04951182f, 0.03973465f, -0.12930076f, 
    -0.03661903f, -0.01062689f, -0.01628343f, 0.02490027f, 0.09221960f, 0.08586777f, 0.15259112f, -0.03080560f, 
    -0.00036375f, 0.01241518f, -0.21130057f, 0.01651490f, 0.00933273f, 0.20771769f, 0.03807733f, -0.01259314f, 
    -0.20612563f, -0.27036953f, -0.13502036f, 0.08024190f, -0.12679839f, -0.10700522f, 0.07282018f, -0.03563219f, 
    -0.05274249f, 0.11246341f, -0.01793643f, -0.19221577f, -0.04551746f, -0.08216691f, 0.08011623f, -0.10127735f, 
    -0.11398162f, 0.22641791f, -0.02891294f, -0.14814979f, 0.02620378f, 0.01279430f, -0.15603331f, -0.00304199f, 
    0.03480455f, 0.08768332f, -0.06166939f, 0.12390145f, -0.29543474f, -0.00215341f, -0.24079552f, 0.11535119f, 
    0.09671924f, 0.04104770f, 0.13058053f, 0.10464149f, 0.02466082f, -0.04862554f, 0.08589198f, -0.12086364f, 
    0.04787508f, -0.04675683f, 0.12098361f, 0.00215057f, 0.19476835f, -0.27545688f, -0.06043516f, -0.03600303f, 
    -0.05986165f, 0.15119690f, 0.02532105f, 0.10021678f, -0.01094496f, 0.15585603f, -0.06451306f, 0.10020417f, 
    -0.02127903f, -0.16357525f, 0.02956370f, 0.12629931f, -0.03937345f, 0.11939764f, 0.01026009f, -0.00782733f, 
    0.05316971f, -0.03741843f, 0.06744149f, 0.03776064f, -0.12948030f, -0.03299242f, 0.01687582f, 0.09700356f, 
    -0.03127973f, 0.03273738f, 0.06030238f, 0.02119257f, -0.02018616f, -0.02053401f, 0.09064887f, 0.09557285f, 
    -0.05859385f, 0.16073236f, -0.12935416f, 0.17244317f, 0.09049752f, 0.14833939f, -0.00296048f, -0.06368031f, 
    0.07597667f, -0.03957309f, 0.18882532f, 0.23408477f, -0.09000061f, 0.02550756f, -0.19281718f, -0.04534746f, 
    -0.01160998f, 0.00412959f, 0.05412329f, 0.01006755f, 0.12613386f, -0.00269137f, 0.01905566f, 0.03213026f, 
    -0.04654853f, -0.00240379f, 0.07179014f, -0.04346590f, 0.14189407f, 0.01666372f, -0.05493579f, -0.09764840f, 
    0.15158127f, 0.21750826f, -0.03648386f, 0.06770214f, 0.14052597f, -0.08553703f, -0.26655927f, -0.02346069f, 
    0.04259572f, 0.01397470f, -0.27402666f, 0.11873493f, -0.08871181f, 0.11699867f, -0.04049038f, -0.18686460f, 
    0.04295785f, -0.15984245f, -0.10632707f, 0.05116417f, 0.00194449f, 0.10140251f, 0.03470448f, -0.03539030f, 
    -0.03845304f, 0.01928136f, -0.02735547f, 0.02999238f, -0.03364404f, 0.02277773f, 0.01247940f, 0.00872805f, 
    -0.01903062f, -0.05547804f, 0.00520689f, 0.00654111f, 0.03229788f, 0.04862401f, -0.03036946f, 0.02226471f, 
    -0.00168643f, -0.02447449f, 0.04541035f, 0.02853474f, 0.01475826f, 0.02918069f, -0.00392232f, -0.05902866f, 
    0.03298273f, -0.06298202f, -0.00608645f, -0.03495869f, 0.01139624f, -0.04410005f, -0.05261492f, 0.00630623f, 
    -0.00207108f, -0.02834237f, -0.01221025f, 0.04099644f, -0.01873402f, 0.04972690f, -0.05868161f, -0.01411974f, 
    -0.03629759f, 0.04047783f, 0.04225508f, 0.01633987f, 0.03831317f, -0.01450900f, -0.03220043f, -0.03081887f, 
    -0.05521309f, -0.05598621f, -0.03830270f, 0.01694788f, -0.01191435f, -0.02184392f, 0.03901458f, -0.01508346f, 
    0.00400329f, 0.01141453f, -0.06036802f, 0.01854920f, -0.05968963f, -0.02674114f, -0.06237965f, 0.03736363f, 
    -0.00023130f, -0.04700395f, 0.03626457f, -0.05538606f, 0.02029054f, -0.04639843f, 0.01821502f, 0.04389390f, 
    0.00702018f, -0.03790849f, -0.04125493f, -0.05680516f, -0.04248930f, -0.02006418f, -0.05880516f, -0.04360496f, 
    -0.00053894f, -0.04367344f, 0.00417295f, 0.03377325f, 0.03883014f, -0.05987385f, -0.04174577f, 0.01447231f, 
    -0.05820204f, -0.02602390f, -0.05665504f, 0.01845248f, -0.00285019f, -0.05405355f, -0.05914069f, 0.00991557f, 
    0.03343992f, 0.03017213f, 0.00137448f, -0.06688019f, 0.02289812f, 0.04207615f, 0.01058208f, 0.01958066f, 
    -0.01122820f, -0.00962519f, -0.01466805f, 0.02527382f, -0.03198547f, 0.03100057f, -0.00278145f, -0.00173801f, 
    -0.04362802f, -0.05752291f, 0.03289351f, 0.01249039f, 0.00390829f, -0.00522496f, 0.00535202f, 0.00489387f, 
    0.02630287f, 0.01764515f, -0.00980078f, 0.01027425f, 0.03495485f, -0.01311550f, -0.04279132f, 0.03327220f, 
    0.04159900f, -0.01984879f, -0.04012670f, -0.05921796f, -0.04782843f, 0.04337955f, 0.02800987f, 0.01881547f, 
    -0.02616563f, 0.03660126f, 0.03169676f, 0.00271178f, -0.00713415f, -0.00228742f, -0.00459760f, -0.04140204f, 
    -0.04008193f, 0.04177443f, -0.03507205f, -0.02758854f, 0.03010628f, -0.01400197f, 0.04388766f, -0.01894108f, 
    0.02830802f, 0.01924704f, 0.00771421f, 0.02995697f, 0.00987509f, -0.03932716f, 0.00365072f, -0.05069492f, 
    0.02662351f, -0.02998766f, -0.01813264f, 0.04220616f, 0.02311685f, -0.06621855f, -0.01853858f, -0.01369439f, 
    -0.00275857f, -0.01429178f, -0.00456159f, -0.02476144f, -0.02651078f, -0.03147824f, 0.00885569f, -0.02064233f, 
    -0.04813119f, -0.04799433f, 0.00152558f, -0.06495500f, 0.02194334f, -0.03996072f, 0.00049984f, -0.00730823f, 
    0.02273908f, -0.05059564f, -0.00182100f, 0.03196921f, 0.01469953f, -0.04533767f, 0.00329903f, -0.06517160f, 
    0.00672823f, -0.01239893f, -0.05866412f, -0.00071260f, -0.02928917f, -0.06094995f, -0.02209619f, 0.00770662f, 
    -0.02243388f, -0.01976386f, 0.00304407f, -0.02890618f, -0.00186753f, 0.03637472f, -0.00595388f, -0.00784639f, 
    0.03326027f, -0.01261117f, 0.03894910f, 0.02675611f, -0.03065964f, -0.01645709f, -0.04618823f, 0.03651273f, 
    -0.05173400f, -0.05234886f, -0.00635528f, 0.02490365f, -0.02699499f, -0.06905246f, -0.03572728f, 0.00252621f, 
    0.03655352f, -0.05179783f, -0.03721650f, -0.02804931f, 0.04890201f, -0.04437634f, -0.00683890f, -0.01492857f, 
    -0.04623356f, 0.02134614f, 0.03663732f, -0.01124045f, -0.02246285f, -0.02077237f, -0.04026072f, 0.04616291f, 
    -0.01209311f, 0.01320651f, 0.00318032f, -0.01605851f, -0.01673998f, -0.06695354f, 0.04577649f, -0.00821648f, 
    -0.01575288f, -0.04697254f, -0.06246692f, -0.01670009f, -0.04514514f, -0.03045458f, -0.06178707f, -0.02137602f, 
    -0.06400782f, 0.00606590f, -0.00183572f, -0.04022323f, -0.00708897f, 0.02972672f, -0.03961436f, -0.01761001f, 
    0.04729909f, -0.03206985f, -0.02514738f, -0.00391703f, -0.00266323f, -0.01808700f, 0.00095238f, 0.00516732f, 
    0.00714798f, 0.01653132f, -0.03745319f, -0.02357122f, -0.00644938f, -0.04774551f, 0.02383181f, -0.01766724f, 
    -0.06621306f, -0.01298191f, 0.02960877f, -0.04121652f, 0.03035594f, 0.03225668f, -0.00370037f, -0.00353228f, 
    -0.52473885f, -0.24010463f, 0.27258107f, 0.04175412f, 0.01207022f, 0.05727612f, 0.05872668f, -0.04718988f, 
    -0.17647086f, -0.10784904f, -0.05544695f, -0.23832446f, -0.05715533f, 0.08040939f, -0.11049969f, -0.07078469f, 
    -0.05583104f, 0.16929151f, 0.09513964f, -0.02493532f, -0.03595105f, 0.02281820f, -0.01744713f, 0.11627445f, 
    0.16266803f, 0.04647795f, 0.05118875f, -0.01379750f, -0.06597506f, 0.17403059f, -0.06485944f, -0.05977641f, 
    -0.03550406f, 0.07175373f, 0.12897485f, 0.12360270f, 0.04510815f, 0.00844239f, -0.12631527f, -0.03822941f, 
    -0.05275078f, 0.13975109f, 0.13122836f, -0.07045759f, 0.00951008f, -0.06009778f, 0.19410518f, 0.04209971f, 
    -0.07474717f, 0.08221050f, 0.01985220f, -0.01297539f, -0.03991918f, -0.09777740f, -0.09423346f, -0.06720423f, 
    -0.03746693f, 0.05014141f, 0.05455430f, 0.04775846f, -0.02269443f, 0.00585784f, -0.19001265f, -0.10690910f, 
    0.09935194f, -0.23795101f, 0.08825605f, 0.08862664f, 0.04403843f, -0.07589059f, 0.06925551f, -0.11666448f, 
    -0.03350743f, 0.13791505f, -0.27890229f, -0.05769927f, -0.02827124f, 0.02934391f, 0.03508907f, -0.01181937f, 
    0.08038654f, 0.31583500f, -0.05227743f, -0.14809403f, 0.11754786f, 0.17425060f, 0.08385074f, 0.07659129f, 
    -0.14781684f, -0.05486564f, -0.11534088f, -0.07878387f, -0.01874807f, -0.17658725f, -0.03762774f, 0.16337560f, 
    0.14050464f, 0.00736217f, 0.03217132f, 0.11475612f, -0.08009557f, -0.19102824f, 0.06356629f, 0.01446015f, 
    0.10189363f, 0.09937508f, 0.02612334f, 0.05343625f, -0.18433709f, -0.04602873f, -0.11192214f, -0.01641713f, 
    0.10367430f, -0.09886243f, 0.02080575f, 0.02472777f, 0.00481984f, -0.07489438f, -0.31382599f, -0.15801492f, 
    0.09374712f, -0.01696613f, -0.06809799f, -0.02855682f, -0.03630248f, 0.04656121f, -0.18920580f, -0.15600030f, 
    -0.27490106f, -0.00226487f, -0.02059733f, 0.00837216f, -0.06850584f, -0.02893117f, 0.11001310f, -0.20739919f, 
    0.06796471f, 0.13785961f, -0.02357780f, 0.09926727f, 0.01790478f, -0.03532508f, 0.02829126f, -0.07528581f, 
    0.00871684f, 0.30116528f, 0.33595538f, -0.03474691f, -0.00353304f, -0.16119783f, 0.04837208f, -0.05157867f, 
    -0.01862930f, 0.22753993f, 0.01899525f, -0.12362230f, 0.11811859f, -0.08263623f, 0.07906646f, 0.28639778f, 
    0.04399346f, -0.00753794f, -0.15987100f, 0.03011802f, 0.09140584f, 0.02609303f, -0.00567312f, -0.01537176f, 
    0.09908481f, -0.03146870f, 0.00972416f, -0.26297680f, -0.09331093f, 0.22875741f, -0.01074168f, 0.09064084f, 
    0.13638596f, 0.03201916f, 0.05595370f, -0.14146055f, 0.09587352f, 0.16221014f, 0.11492298f, -0.05767339f, 
    -0.04437772f, 0.08551311f, -0.05682339f, 0.16036919f, 0.02614323f, -0.05275152f, 0.08954813f, -0.00199141f, 
    -0.04758681f, -0.00168236f, 0.10476799f, 0.13242416f, 0.01004933f, -0.17245321f, -0.10551311f, 0.05091932f, 
    0.34643850f, 0.02191922f, 0.05798358f, -0.11465932f, -0.03081229f, 0.02012740f, 0.03819524f, 0.11225779f, 
    0.11282797f, -0.11336078f, 0.08310355f, -0.01695441f, 0.09548036f, 0.13338894f, 0.02048154f, -0.17842042f, 
    -0.17767461f, -0.03104503f, -0.15222952f, -0.05888440f, -0.05832230f, 0.06629718f, -0.05098623f, 0.13623142f, 
    0.17405182f, 0.09137781f, 0.05187141f, -0.26958948f, -0.01110349f, -0.04936915f, 0.03540732f, 0.09767282f, 
    0.15760161f, 0.01997786f, 0.06803355f, 0.15665720f, -0.20054480f, -0.08898830f, 0.17265509f, 0.16087280f, 
    -0.05468767f, -0.00293487f, -0.05350992f, 0.37355006f, -0.15079902f, -0.18797468f, 0.01415513f, -0.02836053f, 
    -0.02979001f, 0.07043772f, 0.02883730f, 0.03185504f, -0.29616627f, -0.10671034f, -0.13226932f, 0.05849457f, 
    0.01488957f, 0.03309999f, -0.07649731f, 0.10374518f, -0.02882664f, 0.11740299f, 0.01463773f, 0.02300150f, 
    -0.03409696f, 0.00611975f, 0.01978500f, 0.02529328f, 0.05327368f, 0.12451001f, -0.25474712f, 0.02737527f, 
    -0.19259679f, -0.06347338f, 0.16645530f, 0.10602628f, -0.24865833f, -0.11428157f, -0.09671395f, -0.08329687f, 
    -0.04685009f, -0.15400895f, -0.01399957f, -0.05654604f, -0.04062003f, 0.09875648f, -0.07268918f, 0.06341478f, 
    0.21931471f, -0.18025562f, -0.19125234f, 0.21348093f, -0.22171459f, 0.06338119f, 0.18265150f, -0.06645817f, 
    0.08381418f, 0.22748585f, 0.00505511f, 0.09995251f, 0.10648604f, -0.12698524f, -0.06118101f, 0.04905969f, 
    0.01491626f, -0.11720420f, 0.14777015f, 0.23957095f, 0.19842429f, 0.09659589f, 0.11629789f, -0.02090730f, 
    -0.12593579f, -0.08975665f, -0.03653620f, 0.13527894f, -0.08784054f, -0.14031759f, -0.17733230f, 0.00704907f, 
    -0.12572935f, 0.08755840f, -0.02323340f, 0.04192602f, 0.25666672f, 0.07912456f, 0.18673140f, 0.09948613f, 
    0.01379966f, 0.09306818f, -0.11269763f, -0.07667477f, 0.22817756f, 0.02580127f, 0.04745467f, -0.21255773f, 
    -0.16004902f, -0.03968675f, -0.02865491f, -0.03844829f, -0.03093580f, 0.04450930f, 0.24989042f, -0.04690291f, 
    0.00859960f, -0.03925250f, -0.12966275f, -0.07971200f, 0.03098875f, -0.08156136f, 0.06382955f, -0.10215528f, 
    -0.14392868f, -0.01902710f, -0.01811497f, 0.10721347f, -0.00060483f, -0.12112135f, -0.17970188f, 0.04295699f, 
    -0.24023117f, -0.09774355f, 0.07760612f, -0.15583871f, 0.04189700f, -0.03637996f, 0.02803824f, 0.05235019f, 
    0.00570903f, 0.10041469f, -0.06903888f, 0.11568690f, -0.06235126f, 0.11410959f, -0.02503341f, -0.00666687f, 
    -0.10043688f, 0.05181253f, 0.19659449f, -0.03018469f, -0.03048280f, -0.08113249f, -0.00455558f, -0.09272835f, 
    -0.12324983f, 0.10453320f, -0.18022656f, 0.18249407f, 0.07320523f, 0.17769140f, 0.07763505f, 0.03362652f, 
    -0.01754134f, -0.04691817f, 0.00476345f, -0.01780612f, 0.15407917f, 0.15947679f, -0.00264930f, -0.09718654f, 
    -0.19907373f, -0.03794459f, -0.10226560f, 0.00719598f, -0.06279398f, -0.12952507f, 0.20600852f, 0.20364816f, 
    0.00314615f, -0.20703731f, -0.02540462f, 0.04867513f, 0.12614837f, -0.01953025f, 0.09376404f, 0.24863094f, 
    0.23897502f, -0.00965791f, 0.00776860f, 0.12028769f, -0.09215560f, 0.05511656f, -0.12213273f, 0.00699443f, 
    -0.00775249f, 0.17158465f, -0.03580085f, -0.11236235f, -0.03202591f, -0.13028854f, 0.02519606f, 0.01247923f, 
    0.22133113f, -0.09816990f, 0.08045088f, -0.12518585f, 0.00571780f, 0.07707519f, 0.12617941f, -0.02128989f, 
    0.03227751f, 0.00839893f, 0.16536716f, 0.19933666f, 0.18945700f, 0.11295357f, 0.07901879f, -0.07674138f, 
    0.17906526f, -0.01098559f, -0.13460195f, -0.07718636f, -0.04694173f, -0.16368532f, 0.15964180f, -0.09202512f, 
    -0.03092029f, 0.15058541f, -0.05911188f, 0.29253352f, 0.04369348f, 0.17216171f, 0.02094284f, -0.02909315f, 
    0.03145732f, -0.11802287f, -0.04172667f, 0.05385168f, 0.09081824f, 0.01008879f, 0.05415458f, 0.00139674f, 
    0.08820669f, 0.00514078f, -0.05565019f, 0.03439791f, -0.07077631f, 0.37118369f, -0.01406120f, -0.04054404f, 
    0.12341180f, -0.02488388f, 0.10422866f, 0.14336699f, -0.01487703f, 0.07166234f, 0.07185462f, -0.09998777f, 
    -0.14074667f, 0.02640274f, -0.12464941f, 0.10373620f, -0.02047485f, 0.08455086f, -0.07685971f, -0.01765825f, 
    0.02063909f, 0.10133713f, -0.00642764f, 0.08868612f, 0.04743249f, 0.01184101f, 0.04137462f, 0.01160164f, 
    -0.16257699f, -0.01812092f, -0.05249323f, -0.02674699f, -0.04537338f, -0.09310861f, -0.07001175f, -0.06578996f, 
    -0.13064080f, 0.09259714f, 0.06574900f, 0.21080121f, -0.04287498f, 0.08389903f, 0.15365256f, -0.10463639f, 
    0.03304019f, 0.14686933f, -0.18271230f, -0.07585312f, 0.09751391f, -0.03607443f, 0.00606638f, -0.04812530f, 
    -0.04134830f, 0.03306748f, -0.04888025f, 0.15389918f, 0.04690885f, -0.09997050f, 0.02471548f, -0.00055324f, 
    0.12534109f, 0.03767919f, 0.15270452f, -0.04573640f, -0.01196432f, -0.11243881f, -0.17235094f, 0.06267519f, 
    0.03392451f, -0.12269723f, 0.04043249f, -0.11252506f, 0.01899793f, -0.18196400f, -0.14274587f, -0.02662773f, 
    -0.25363013f, -0.05830761f, -0.08002930f, 0.00323844f, -0.02544790f, -0.05178505f, 0.06763151f, 0.29662076f, 
    0.17789459f, 0.08916000f, 0.05282106f, -0.00448610f, -0.11026236f, 0.01572624f, 0.03231496f, 0.17966576f, 
    0.11684029f, -0.04070727f, -0.10667650f, 0.03870579f, -0.06980082f, -0.03474315f, 0.01656700f, 0.04082969f, 
    0.00725140f, 0.01611895f, -0.05499733f, -0.04726773f, -0.13210505f, 0.01707766f, -0.12591271f, -0.06072439f, 
    0.11875770f, 0.29640892f, -0.03184611f, 0.00908155f, 0.07698673f, 0.01507692f, -0.00698991f, 0.11394533f, 
    0.03667307f, 0.03566463f, 0.00091487f, -0.02377290f, -0.03910299f, -0.04856415f, -0.04131709f, 0.05885208f, 
    -0.10598093f, 0.10951491f, 0.04323838f, 0.20412217f, 0.11571831f, 0.04255070f, 0.03784370f, 0.02983572f, 
    0.02160063f, 0.07996979f, 0.01434663f, -0.03776849f, 0.10694540f, 0.17494079f, 0.14566402f, 0.06605531f, 
    -0.00255174f, -0.00269499f, -0.12379229f, 0.04404382f, 0.06269284f, -0.14578110f, -0.44923276f, -0.03813142f, 
    0.11433090f, 0.09883501f, 0.10785820f, -0.08581360f, -0.07471860f, -0.07693893f, 0.09411873f, 0.05535944f, 
    0.18272585f, 0.00381663f, -0.04282504f, 0.07217477f, 0.06587377f, 0.00190755f, -0.06730521f, -0.20224346f, 
    -0.17425971f, 0.14663842f, 0.14279680f, -0.01452144f, -0.01412538f, -0.00369050f, 0.06279488f, -0.06636968f, 
    0.20915234f, -0.02364525f, -0.12518673f, 0.08976439f, 0.03886502f, 0.05501945f, -0.05206736f, 0.00558190f, 
    -0.04752054f, 0.17356175f, 0.08792296f, 0.07615040f, 0.00400946f, -0.03858291f, -0.05501278f, -0.00564038f, 
    0.07168076f, 0.09247752f, 0.19313553f, -0.09498120f, 0.05150978f, 0.10159519f, 0.03801125f, -0.04676621f, 
    0.08850730f, -0.13151531f, -0.04938407f, -0.10576984f, -0.03201414f, -0.02247440f, 0.00892950f, 0.06240327f, 
    -0.04762244f, -0.02302363f, -0.03352842f, 0.06468354f, 0.15892981f, 0.15390640f, -0.18172921f, -0.13524809f, 
    -0.17293906f, -0.03219127f, -0.03860919f, 0.04223023f, 0.00868100f, 0.29313990f, -0.06634456f, -0.04983579f, 
    -0.06544250f, 0.08576109f, -0.18750025f, -0.09105911f, 0.09040784f, 0.02481485f, 0.02563646f, 0.11713997f, 
    0.04945013f, -0.01494438f, -0.16698545f, -0.27410635f, 0.02903149f, 0.10795324f, 0.04096872f, -0.30202153f, 
    -0.16762942f, 0.05560619f, 0.06500764f, 0.04744440f, 0.11639376f, 0.00191067f, 0.02993171f, 0.03343448f, 
    -0.15506001f, 0.02159811f, -0.09547744f, 0.05794626f, -0.01208397f, 0.09292046f, -0.14341609f, -0.03263806f, 
    0.00891585f, -0.10784620f, 0.09879577f, -0.00377740f, -0.16775820f, 0.09570602f, 0.07425387f, -0.06659387f, 
    -0.01666331f, 0.05507595f, 0.00837731f, 0.00758303f, -0.08816869f, -0.20679189f, 0.05233437f, -0.09634219f, 
    0.01015305f, 0.05498051f, -0.08450229f, -0.14698787f, 0.25045606f, 0.06977966f, 0.04814186f, -0.11103836f, 
    -0.02854533f, 0.13272022f, 0.00236238f, -0.00519921f, -0.29007611f, -0.20416331f, -0.11216866f, 0.07421646f, 
    0.04968200f, 0.05660360f, -0.00170912f, -0.01893804f, -0.03198981f, -0.17073192f, -0.04736509f, -0.02066910f, 
    -0.16678622f, 0.11689091f, 0.03356300f, -0.12274487f, 0.08639821f, -0.07016772f, 0.24484046f, -0.25408033f, 
    -0.09146155f, -0.04994859f, -0.14673206f, 0.05099507f, -0.10250501f, 0.00584004f, 0.00500623f, 0.18015555f, 
    0.13125230f, -0.00837701f, 0.04067065f, -0.05966447f, 0.07186335f, -0.07313979f, 0.15640101f, -0.02195831f, 
    0.19138308f, -0.06637415f, 0.10023938f, 0.07232802f, 0.09642915f, -0.13611302f, 0.07152365f, 0.04847803f, 
    0.02369645f, 0.24758653f, -0.30134523f, -0.16576403f, 0.03629689f, 0.04180456f, 0.07780167f, -0.12041409f, 
    -0.04184841f, -0.00445715f, 0.02575417f, 0.00124703f, 0.02035815f, 0.13348819f, 0.03227691f, -0.02513277f, 
    -0.06859442f, -0.11950158f, 0.06070528f, 0.37775311f, -0.02908186f, 0.07323015f, -0.04452960f, -0.06289691f, 
    0.01761429f, -0.02010110f, 0.00918708f, -0.08999258f, 0.17487997f, 0.10129125f, 0.05941176f, 0.06219131f, 
    0.00088318f, 0.06272231f, -0.06571241f, -0.05189139f, -0.02722531f, -0.03090395f, -0.21203586f, 0.06993905f, 
    0.21350248f, -0.01851208f, 0.05904926f, 0.04947583f, -0.10982119f, 0.02847405f, -0.21669234f, -0.00151487f, 
    0.20045608f, -0.05720972f, -0.00827962f, 0.03615960f, -0.06364655f, -0.00680149f, -0.02098205f, -0.12223179f, 
    0.11289652f, -0.11160658f, 0.04407564f, 0.13887335f, 0.01242610f, -0.00847946f, -0.03114875f, -0.05972430f, 
    -0.05935002f, 0.00162564f, -0.06046151f, 0.04671913f, 0.00763399f, -0.01156930f, -0.03455603f, 0.05158808f, 
    0.04491458f, 0.05200107f, -0.05505354f, -0.04380943f, -0.02919744f, -0.02787118f, 0.01591794f, -0.01133388f, 
    -0.04858285f, 0.01630194f, -0.02597828f, 0.02152104f, 0.03173160f, -0.01568764f, 0.03157067f, 0.01120666f, 
    0.02511155f, 0.00730606f, 0.02748375f, -0.03783497f, 0.04628836f, -0.00775076f, 0.02175028f, 0.00295641f, 
    -0.04620444f, -0.05347448f, -0.01180759f, -0.05107425f, 0.01604088f, 0.02472468f, 0.00131395f, -0.01219926f, 
    -0.03313261f, -0.05841707f, 0.01404388f, 0.03650739f, 0.04059916f, -0.01731517f, 0.00382565f, -0.04383370f, 
    0.01873672f, -0.00020908f, -0.02010272f, 0.02250395f, 0.01127806f, 0.00243274f, 0.03808336f, 0.01571582f, 
    -0.05175429f, -0.05704598f, -0.03534292f, 0.03185501f, -0.01681543f, 0.02407810f, -0.03636697f, -0.00794705f, 
    -0.04853974f, -0.04089642f, -0.03451738f, -0.02182212f, 0.04252192f, -0.04274684f, 0.04059149f, -0.03985327f, 
    0.02699878f, -0.03201925f, -0.04060902f, -0.05296141f, -0.05973329f, 0.00955171f, 0.01646047f, -0.00571156f, 
    -0.04933000f, 0.03638546f, -0.00145144f, -0.05497753f, -0.01768325f, -0.04859848f, -0.03766512f, -0.03452552f, 
    0.03127316f, 0.00777601f, 0.05076869f, 0.03523793f, 0.03870401f, -0.05420196f, -0.05927014f, 0.05513618f, 
    -0.03837634f, -0.02247754f, -0.01583454f, -0.06344473f, 0.01133975f, 0.04021668f, 0.02539628f, -0.04907790f, 
    0.01119285f, -0.04428116f, 0.00651694f, -0.02832192f, 0.02743478f, -0.03584420f, -0.05089588f, -0.01566745f, 
    -0.01493783f, -0.01572798f, -0.04916874f, -0.06270290f, -0.02195820f, -0.04833362f, -0.04507468f, -0.00285996f, 
    -0.04689141f, -0.03347507f, -0.01293528f, 0.03627223f, -0.06103222f, -0.01212153f, -0.05514250f, 0.02416344f, 
    0.03320448f, -0.04920482f, 0.03246287f, 0.01809391f, 0.04240277f, -0.02361795f, -0.02464022f, -0.03675510f, 
    -0.02582917f, -0.05429076f, -0.06141993f, -0.06447323f, 0.00606547f, -0.06228937f, -0.05884629f, 0.01919041f, 
    -0.03128057f, 0.04375828f, 0.01259668f, 0.02361297f, 0.05256608f, 0.03661970f, -0.00209770f, -0.06300791f, 
    0.02736601f, -0.02622961f, 0.01414838f, 0.04021250f, -0.02265688f, -0.03264073f, 0.03836684f, -0.04465269f, 
    0.03411298f, -0.02773065f, 0.01351575f, -0.02277201f, -0.00893477f, 0.02241118f, -0.00460233f, -0.06178822f, 
    -0.01893918f, -0.02479502f, -0.03406984f, 0.04444130f, 0.03891014f, 0.04163213f, 0.04384621f, 0.00412316f, 
    -0.02339064f, 0.00279980f, -0.06354756f, 0.02937205f, -0.02324839f, 0.02126257f, 0.01867610f, 0.05935578f, 
    0.05237177f, 0.00142625f, 0.00229102f, 0.00395642f, 0.00479318f, -0.01022485f, 0.01933013f, -0.02495786f, 
    -0.03514036f, 0.01417955f, -0.01193654f, 0.04546082f, -0.00670422f, -0.02338533f, -0.02421222f, -0.06205867f, 
    0.02197654f, 0.00224973f, -0.03483816f, 0.03307330f, 0.00147661f, -0.04764178f, 0.04672671f, 0.03818912f, 
    -0.05504636f, 0.03626982f, -0.04814204f, 0.04147791f, 0.01981862f, -0.06013666f, 0.00780399f, -0.01830903f, 
    0.01748173f, 0.00990915f, 0.01097236f, -0.00813887f, -0.02091684f, 0.03525363f, -0.05448889f, 0.04904125f, 
    -0.05832447f, 0.01635717f, -0.01544678f, 0.00959383f, -0.03725485f, 0.04824024f, -0.04494467f, 0.02835521f, 
    0.04672195f, -0.02332078f, -0.06121812f, -0.02026935f, 0.00518733f, -0.02454555f, -0.05102859f, 0.03080176f, 
    -0.04390920f, 0.03995968f, -0.02450856f, 0.04607684f, -0.05398697f, 0.00215659f, 0.05099937f, -0.04873500f, 
    0.01197476f, -0.02239798f, -0.00133989f, 0.04500206f, -0.05206174f, 0.00716568f, 0.04886879f, -0.03312607f, 
    0.04222909f, 0.01888873f, -0.04423806f, -0.02967559f, -0.00349055f, -0.03057194f, 0.03992322f, -0.02230188f, 
    -0.04777181f, -0.04163282f, -0.02389381f, -0.01126632f, 0.05040402f, 0.03198157f, 0.01654408f, -0.03978297f, 
    -0.05455803f, 0.03484172f, -0.00686801f, 0.04999484f, -0.02129188f, -0.00540498f, 0.01986272f, 0.04853841f, 
    0.02479414f, 0.02395185f, 0.02378088f, -0.00317082f, 0.03899593f, -0.00173536f, -0.04113372f, -0.03819179f, 
    -0.04481033f, -0.04762553f, 0.04293445f, -0.05560928f, 0.00760611f, -0.03331355f, -0.00258194f, -0.06801124f, 
    0.01875344f, 0.00493171f, -0.02399560f, -0.01198956f, -0.05843828f, -0.03453834f, -0.04099809f, 0.05977587f, 
    0.05243078f, 0.02603075f, -0.04427675f, -0.03770009f, -0.00490311f, 0.03557207f, 0.00162172f, -0.02579612f, 
    -0.01924920f, -0.01016177f, 0.04082625f, -0.00934048f, 0.01265851f, 0.00798131f, -0.03867293f, 0.02206449f, 
    0.00042895f, -0.05553610f, -0.01705304f, -0.03067173f, 0.00853630f, 0.02348891f, -0.03518205f, -0.02300270f, 
    -0.03658845f, -0.01135245f, -0.01273752f, -0.04454201f, 0.03464045f, -0.01979626f, -0.01561151f, 0.00098630f, 
    -0.00639031f, 0.02665327f, -0.04705584f, -0.02382765f, -0.06610668f, -0.05715841f, 0.01991778f, 0.03362280f, 
    0.03929093f, -0.05219523f, -0.06221159f, 0.03954957f, -0.01649129f, 0.02711118f, 0.01864530f, -0.01830998f, 
    -0.05794071f, 0.03144471f, -0.01583958f, 0.02918768f, -0.06255030f, -0.04622982f, -0.06012620f, 0.00004401f, 
    -0.01460148f, -0.00843274f, -0.05802369f, 0.01291826f, -0.03614126f, -0.03518336f, -0.05177780f, -0.05367164f, 
    -0.03962173f, 0.05070690f, -0.00729812f, -0.00968371f, 0.00834236f, 0.02707817f, -0.05159850f, 0.02549135f, 
    0.03119433f, -0.01987836f, -0.01401986f, -0.00709547f, 0.01941164f, -0.02709301f, -0.05998198f, 0.03139556f, 
    0.01997370f, -0.03210221f, -0.00441093f, 0.01540883f, 0.00476820f, 0.00866714f, -0.02784030f, -0.01681432f, 
    0.01184137f, -0.00418232f, -0.02496086f, -0.04546736f, 0.01242748f, 0.02432264f, -0.03722876f, -0.01589713f, 
    -0.02299537f, 0.02402519f, -0.01406991f, -0.00450959f, 0.00612833f, 0.00953764f, 0.02316547f, -0.00471983f, 
    0.03640123f, 0.02931780f, 0.00020169f, -0.01892045f, -0.02179540f, -0.02936442f, 0.02054122f, -0.00558617f, 
    0.00546262f, -0.00154041f, -0.03811107f, 0.02506627f, -0.01026240f, -0.00267941f, 0.03419415f, 0.01964607f, 
    0.01636325f, 0.04430324f, 0.05291889f, 0.01813747f, -0.06095051f, 0.02194479f, -0.06261656f, -0.04242020f, 
    -0.04480879f, 0.02627650f, -0.01622845f, -0.05113020f, 0.01791801f, 0.01396040f, 0.05079393f, -0.04843062f, 
    -0.07336453f, 0.00556046f, 0.00507246f, -0.03868368f, -0.04125760f, -0.03505580f, 0.03940578f, 0.02190410f, 
    0.02133035f, -0.02120918f, 0.03772685f, 0.05049748f, -0.03537400f, 0.01354989f, -0.03187406f, 0.04517406f, 
    0.03235854f, 0.04221412f, -0.05105346f, 0.04066003f, 0.03585238f, -0.04026629f, 0.05263017f, 0.01083707f, 
    -0.04464507f, 0.02205641f, 0.03249854f, 0.01816800f, 0.04313516f, 0.00878922f, -0.01826692f, -0.06434922f, 
    -0.04272046f, -0.02232946f, 0.01487293f, -0.00893506f, -0.05695654f, -0.01514109f, 0.03064429f, -0.03137397f, 
    0.02154651f, -0.03835096f, -0.04659684f, -0.03478494f, -0.06319597f, -0.01960833f, 0.00523962f, -0.02249111f, 
    -0.03145755f, -0.06191749f, -0.04015269f, -0.01887385f, 0.00568739f, -0.05080546f, -0.04732135f, -0.05670637f, 
    -0.05727297f, 0.02138321f, -0.00817572f, -0.04492994f, 0.02564909f, 0.03178301f, -0.01880379f, -0.03406491f, 
    0.04902158f, -0.04728496f, 0.04200956f, -0.01468909f, -0.01446933f, -0.02851550f, -0.03869516f, -0.02585588f, 
    -0.02097291f, 0.01733647f, 0.04335067f, -0.00888730f, -0.04750305f, 0.00316338f, 0.01832310f, 0.01758238f, 
    -0.01928815f, 0.00666930f, -0.01807583f, 0.05280752f, 0.04313697f, -0.02941240f, 0.03948637f, -0.05572455f, 
    0.01896936f, 0.02939644f, -0.03275563f, -0.03751750f, 0.04209153f, -0.06368948f, -0.00674260f, -0.05547212f, 
    -0.03654307f, -0.02476450f, 0.00763113f, -0.05362670f, -0.04612878f, -0.06257500f, -0.00444422f, -0.03955039f, 
    0.03904257f, 0.03994283f, 0.01981430f, -0.01661404f, -0.04161578f, -0.04392517f, -0.01921047f, -0.04844907f, 
    -0.01952668f, -0.05035054f, -0.01058527f, 0.05156687f, -0.02565744f, 0.02768352f, 0.04351264f, -0.04750037f, 
    -0.03501724f, 0.04826143f, 0.02635284f, -0.00561744f, 0.03178534f, 0.02477367f, -0.06009306f, -0.01400357f, 
    0.02927770f, -0.03288950f, 0.02260567f, -0.05042748f, 0.03880097f, 0.01385705f, -0.01726549f, 0.01527230f, 
    0.10934600f, 0.32026377f, 0.26893905f, 0.01818643f, -0.04090149f, 0.02224564f, -0.05902286f, -0.01887665f, 
    0.03842558f, 0.01922080f, -0.11662404f, -0.19689777f, -0.07844324f, -0.00758677f, -0.04489333f, -0.01899913f, 
    -0.14342171f, -0.15742856f, 0.14800784f, 0.32060173f, 0.07309850f, -0.13113968f, 0.04970424f, 0.05438842f, 
    -0.01918902f, 0.06578812f, -0.02875923f, -0.19107446f, -0.18171164f, -0.12543529f, 0.04721630f, 0.13638240f, 
    0.11980490f, -0.18744902f, 0.04173777f, -0.01125781f, 0.15133414f, 0.03608119f, 0.09980286f, -0.04072724f, 
    0.05879445f, -0.15563256f, 0.05229270f, 0.04908622f, 0.01426508f, 0.02512015f, 0.14964357f, 0.07121091f, 
    0.01465529f, -0.10087483f, -0.04229384f, -0.02098770f, 0.03041256f, -0.10341450f, -0.02509001f, -0.16713707f, 
    -0.09382303f, 0.06674366f, -0.00452999f, -0.05487863f, 0.02814064f, -0.05950085f, -0.05413013f, 0.12585789f, 
    -0.03198156f, 0.09666633f, 0.00288421f, -0.05226505f, -0.12102256f, 0.13912147f, -0.03207001f, 0.07011867f, 
    0.03156629f, -0.07042821f, -0.15173095f, 0.15076114f, -0.01208187f, 0.12915227f, 0.04057886f, -0.12253680f, 
    -0.10901581f, 0.27097145f, 0.17184502f, -0.01798508f, 0.00852962f, 0.11327866f, 0.02303707f, 0.03341709f, 
    0.05778253f, 0.00566893f, -0.02549915f, -0.08813258f, -0.00985119f, 0.00144506f, 0.02923386f, 0.09276326f, 
    0.00922010f, 0.00976534f, -0.07832604f, 0.05754871f, 0.21547788f, 0.00261908f, 0.00460256f, 0.02532087f, 
    -0.01605243f, 0.00286471f, 0.11307924f, 0.04484072f, -0.02842640f, 0.14296217f, 0.20534094f, -0.02432998f, 
    -0.07437792f, 0.04071227f, 0.09696244f, -0.00211582f, -0.11071050f, 0.04709169f, -0.21731132f, -0.22476791f, 
    -0.00124197f, -0.00508490f, -0.07609403f, 0.14091779f, 0.03879559f, 0.09199137f, 0.04655726f, 0.13522327f, 
    -0.01474643f, 0.00739901f, -0.06640492f, -0.07788592f, 0.04808215f, -0.01778743f, 0.09230578f, 0.04616355f, 
    -0.10614135f, -0.06682052f, -0.00664554f, 0.02327467f, -0.00920831f, 0.08911886f, -0.07668047f, 0.18099785f, 
    -0.04037756f, 0.01785517f, 0.05401231f, 0.13214190f, -0.01718229f, -0.13582273f, 0.03892222f, -0.02283585f, 
    0.03522348f, 0.39459816f, 0.20474936f, -0.01443403f, -0.09106737f, -0.08263507f, -0.04847400f, 0.05061195f, 
    0.14703229f, -0.00974123f, 0.04486528f, -0.15524937f, -0.07049259f, 0.03148191f, -0.03844755f, 0.06051558f, 
    0.02389808f, -0.08599081f, -0.13099712f, -0.06089126f, -0.06092970f, -0.05180798f, 0.07011296f, -0.00821828f, 
    0.02969992f, -0.06300895f, -0.18698931f, 0.06672281f, 0.00535727f, -0.07099224f, 0.08613639f, 0.13626380f, 
    0.04672907f, -0.12746312f, 0.08516312f, -0.01895443f, 0.11634632f, 0.13366041f, -0.12336942f, -0.04591322f, 
    -0.14449140f, -0.03869364f, -0.12558874f, -0.10680472f, -0.06399287f, 0.13949269f, -0.04791811f, -0.05504498f, 
    -0.00170935f, -0.00651849f, 0.10860284f, -0.03863630f, -0.01336677f, 0.06942212f, 0.10415554f, 0.11573282f, 
    0.05827294f, 0.05436641f, -0.09152605f, 0.08924430f, -0.10817245f, 0.01020520f, 0.04336960f, 0.08731189f, 
    -0.12043659f, -0.20201528f, -0.14417531f, 0.10521960f, 0.06888846f, 0.04446880f, 0.14611092f, -0.10462630f, 
    0.10239490f, -0.04340806f, -0.27199921f, -0.17690274f, 0.04465389f, 0.07068452f, 0.15173776f, -0.20609675f, 
    -0.11270791f, -0.06728585f, -0.01735875f, -0.10084885f, -0.22259004f, -0.09214291f, -0.04360817f, 0.14875518f, 
    0.02416627f, 0.04478308f, -0.05874813f, -0.12452015f, -0.03199271f, -0.06560551f, 0.05507696f, 0.05895269f, 
    -0.03006479f, 0.01018335f, -0.09659053f, -0.04331456f, 0.01193981f, -0.00576116f, 0.01128550f, -0.18225838f, 
    0.03644780f, 0.06218573f, -0.12409082f, 0.07230804f, -0.13468565f, -0.15276799f, 0.02480444f, -0.13226269f, 
    -0.00919525f, 0.05818941f, -0.04084439f, -0.22653960f, -0.12378269f, -0.08423597f, -0.05488141f, 0.11177181f, 
    -0.13959219f, 0.05531099f, 0.18201920f, 0.11400405f, 0.12911347f, -0.02108460f, -0.03728476f, -0.07575744f, 
    0.04072794f, 0.05637708f, 0.11938987f, -0.07325193f, 0.01676228f, -0.01447538f, 0.01841106f, -0.13067915f, 
    -0.05516662f, -0.05640641f, 0.01947640f, 0.02893960f, -0.04848564f, 0.04764512f, -0.03702507f, -0.01551029f, 
    0.05468530f, -0.00940483f, 0.02822421f, 0.01275504f, 0.00206200f, 0.00691143f, 0.00999583f, 0.03795714f, 
    -0.03759754f, 0.00633445f, -0.00847443f, 0.05527457f, -0.02136536f, 0.01682126f, -0.03239931f, 0.01629204f, 
    -0.04587969f, 0.01064079f, 0.03733217f, 0.04376352f, -0.01269360f, 0.01018345f, -0.02551883f, 0.00079185f, 
    0.04905687f, -0.01908553f, 0.02912491f, 0.01535861f, -0.01795465f, -0.01456682f, -0.05657659f, -0.02128008f, 
    -0.04935327f, 0.03250206f, -0.03714684f, 0.01210330f, -0.01805695f, -0.03665799f, 0.03229190f, -0.00726970f, 
    0.04598952f, 0.03791354f, -0.01327131f, 0.02365521f, 0.01551960f, -0.05201411f, -0.05807417f, -0.04341099f, 
    0.04836512f, -0.00278308f, -0.05859810f, 0.01567080f, -0.05476619f, -0.04829605f, -0.03423782f, -0.03175174f, 
    0.02552384f, 0.01301226f, 0.04359018f, -0.00813734f, -0.02433467f, -0.05751700f, 0.02691624f, 0.00385900f, 
    -0.00794032f, -0.03552163f, 0.00580949f, -0.01464994f, -0.00435761f, 0.03136148f, 0.02857746f, -0.03417861f, 
    0.00296292f, 0.01038329f, 0.02633833f, -0.03489247f, -0.05413720f, -0.03316423f, 0.00486628f, -0.00636349f, 
    -0.01030339f, 0.02086237f, -0.02567410f, 0.05223360f, -0.00419346f, -0.05242446f, -0.01503507f, -0.02476079f, 
    -0.02413444f, 0.04741256f, -0.01308329f, 0.01066308f, -0.01559313f, 0.04950310f, 0.00229171f, 0.03416365f, 
    -0.02236938f, -0.04004385f, -0.04945625f, 0.03353024f, -0.02629342f, -0.04290160f, -0.04668616f, -0.00620602f, 
    0.02919843f, 0.03313011f, 0.02729757f, -0.00544755f, -0.00343884f, 0.00279017f, -0.03035754f, -0.02607923f, 
    0.03813197f, 0.00484872f, -0.00365472f, -0.02921341f, 0.04052918f, -0.04115385f, -0.03129888f, 0.03465442f, 
    -0.00097906f, -0.04050184f, -0.03713211f, -0.04621993f, 0.04368512f, -0.00847010f, 0.03534313f, 0.04360227f, 
    -0.00876177f, 0.00742248f, -0.05772436f, -0.03647841f, -0.03064496f, -0.00316753f, -0.01859320f, 0.01758834f, 
    0.04574318f, 0.03615361f, -0.00322239f, -0.04644250f, 0.03425385f, 0.03181424f, -0.04941619f, -0.00241846f, 
    0.02636937f, 0.00112564f, 0.04629881f, -0.03846943f, -0.04697970f, -0.00665660f, -0.02453981f, 0.02584653f, 
    0.00296737f, 0.02213850f, 0.04844315f, -0.01708381f, -0.02102616f, -0.04763081f, -0.02237838f, -0.01061502f, 
    -0.01232319f, -0.00476255f, 0.05602371f, -0.05885300f, -0.00662047f, -0.04871574f, -0.00485571f, -0.05523638f, 
    0.04729954f, -0.01737420f, -0.01934911f, -0.04375796f, 0.04057328f, 0.01281289f, -0.00911747f, -0.01602403f, 
    -0.01761758f, -0.00071659f, -0.04544706f, 0.00644534f, 0.03917615f, -0.01115586f, -0.05389150f, 0.03189472f, 
    -0.04506021f, -0.03826815f, -0.00661832f, -0.00558559f, -0.01078101f, -0.04573263f, 0.00224562f, -0.00901038f, 
    0.00573590f, -0.02563445f, 0.05146556f, -0.04116549f, 0.02742784f, -0.02902329f, -0.02288526f, 0.01688891f, 
    -0.03080485f, 0.04450851f, -0.03745386f, -0.04099684f, -0.05144736f, -0.05197490f, -0.05119425f, 0.00067816f, 
    -0.01117109f, -0.04076032f, -0.00367286f, 0.04626648f, 0.00570286f, -0.04546023f, -0.00405087f, 0.03931672f, 
    -0.04893596f, 0.04277715f, -0.04834658f, -0.03614773f, 0.05440222f, 0.00875225f, -0.02702308f, -0.05760145f, 
    -0.01083223f, -0.05794469f, 0.01672908f, -0.05453897f, -0.03008211f, 0.04609974f, -0.00329385f, -0.01930220f, 
    -0.03343026f, -0.02649480f, -0.00765142f, -0.01213659f, -0.03026126f, 0.01829067f, 0.01801039f, 0.01377196f, 
    -0.03831760f, -0.04869824f, 0.04144044f, -0.03144116f, -0.01993162f, -0.01623767f, 0.04053237f, 0.03435669f, 
    0.01165987f, -0.01191420f, -0.00063546f, -0.00630565f, -0.02820816f, -0.04647461f, 0.03228102f, -0.00649982f, 
    0.03496490f, -0.01783280f, -0.02848927f, 0.02545985f, 0.00735791f, -0.04310199f, 0.05358163f, 0.03969482f, 
    -0.03510391f, -0.00117689f, -0.03139253f, 0.02320074f, -0.00041595f, 0.04248315f, 0.01486498f, -0.02654216f, 
    -0.02604675f, -0.05437638f, -0.03282465f, -0.01260228f, 0.04034516f, -0.04707559f, 0.00958567f, -0.05216316f, 
    0.00926442f, -0.21250369f, -0.25021785f, -0.11635239f, -0.08786574f, 0.02437918f, -0.09670962f, -0.01657249f, 
    -0.08647597f, 0.03709649f, -0.12927963f, 0.08639273f, 0.04696666f, 0.10298702f, -0.09868874f, 0.09594922f, 
    -0.06368434f, 0.21034133f, -0.10475919f, 0.06289218f, 0.06586394f, -0.00802746f, -0.00591495f, -0.07040249f, 
    -0.02162796f, 0.00302813f, 0.07381658f, 0.00511340f, 0.15150872f, 0.13799571f, -0.09192470f, 0.06806937f, 
    -0.26205292f, 0.08175554f, 0.04564686f, 0.12233633f, -0.17313996f, -0.19823939f, -0.17298187f, 0.15315673f, 
    0.12293904f, 0.13774700f, -0.08778582f, -0.03067693f, -0.04526177f, -0.06348104f, 0.06965830f, 0.28874606f, 
    0.00206745f, 0.14936893f, 0.07002890f, 0.07163619f, -0.07540054f, 0.10578802f, -0.04340363f, 0.14585106f, 
    0.09022090f, -0.03113766f, 0.08499217f, 0.00431589f, -0.01727155f, 0.01915105f, 0.22333775f, -0.22393879f, 
    -0.05948754f, -0.02766247f, -0.00531952f, 0.10526868f, 0.10530140f, 0.01702193f, 0.01707773f, -0.04073369f, 
    0.07703946f, 0.03475286f, 0.15981783f, -0.20402527f, 0.04008069f, -0.21973737f, 0.07861168f, 0.13933611f, 
    -0.00867557f, -0.09307880f, 0.03917942f, 0.06648388f, 0.20491052f, 0.11557706f, 0.07707898f, 0.08975939f, 
    -0.13299920f, -0.11635177f, 0.06249464f, -0.06696143f, 0.01989771f, -0.01937453f, -0.01264417f, -0.01769031f, 
    -0.02843238f, 0.03243519f, 0.07798427f, -0.03176660f, -0.06481785f, 0.02346811f, -0.07736082f, 0.20523325f, 
    -0.08415098f, 0.12014333f, 0.10928202f, 0.08473643f, -0.05038822f, -0.12882538f, -0.07801363f, 0.07655618f, 
    0.06086620f, 0.00052471f, -0.07612044f, 0.11278667f, 0.01375018f, -0.02342000f, -0.05177146f, 0.00296466f, 
    -0.03265210f, -0.03413076f, 0.00408639f, 0.05880154f, -0.09183420f, -0.04036363f, -0.20096232f, -0.04299326f, 
    0.05969334f, 0.04678743f, -0.00041691f, -0.02277492f, -0.00928484f, -0.04903599f, 0.00968258f, -0.03989200f, 
    0.04768548f, -0.01715534f, 0.04737768f, 0.04126411f, 0.12168920f, 0.09396318f, 0.04281253f, 0.05975778f, 
    0.20463623f, -0.08466741f, 0.04259121f, 0.19397305f, 0.17810781f, 0.05064955f, 0.08822534f, -0.09463170f, 
    -0.08774240f, -0.16902061f, 0.02513797f, -0.13281409f, -0.01142651f, 0.05954344f, 0.14134228f, -0.11603954f, 
    -0.02651566f, 0.12136969f, -0.00706920f, 0.03172135f, -0.09941761f, -0.08839013f, 0.07349540f, -0.10483464f, 
    0.05730968f, 0.07932149f, -0.02107481f, -0.01561617f, -0.05270940f, 0.06052118f, -0.02384803f, -0.11706435f, 
    0.03571149f, 0.02090845f, -0.00531707f, -0.04164129f, -0.03631181f, 0.21345325f, 0.15744545f, 0.15639621f, 
    -0.01168301f, 0.06185997f, 0.04260532f, 0.01414969f, -0.01828890f, -0.12957937f, -0.12264230f, 0.04517987f, 
    0.22129883f, 0.02724642f, -0.10711437f, -0.02482818f, 0.02727860f, -0.18883026f, -0.04474266f, -0.11406267f, 
    -0.08504560f, 0.15086050f, 0.03591546f, 0.08426332f, 0.02941345f, -0.02420935f, -0.00329011f, -0.12066191f, 
    -0.07950919f, -0.00023825f, 0.32334509f, 0.13978936f, 0.10330489f, 0.00964636f, -0.06720893f, -0.22315845f, 
    0.04694643f, 0.07538085f, -0.01781892f, -0.04854853f, 0.00318199f, -0.13110745f, 0.05489738f, -0.00282639f, 
    -0.10193338f, 0.25113297f, 0.13249527f, 0.00338894f, -0.04624534f, -0.07991078f, -0.02822772f, 0.20564909f, 
    -0.02670502f, 0.19352943f, -0.04233081f, 0.21543999f, 0.09885231f, -0.01445932f, -0.03357249f, 0.00919301f, 
    -0.02646261f, 0.02964773f, 0.08577266f, 0.14197759f, 0.11947486f, 0.00086377f, 0.02523011f, -0.14493296f, 
    0.07594477f, 0.03254495f, 0.02130373f, 0.01375855f, 0.10538069f, -0.02436741f, 0.06335968f, 0.01209501f, 
    -0.02602193f, 0.01567158f, 0.06697298f, -0.01037113f, 0.04630220f, 0.15263870f, 0.15669364f, 0.22811006f, 
    0.07161042f, 0.04506473f, -0.06588799f, 0.15157069f, -0.11108078f, -0.02089713f, -0.24998337f, -0.14552926f, 
    -0.11247818f, 0.09933557f, -0.23399706f, -0.12448423f, -0.23558612f, -0.09953095f, -0.08512828f, 0.02547629f, 
    0.03126109f, 0.09691742f, -0.11856075f, 0.05187951f, 0.06964064f, 0.12694584f, 0.05258361f, -0.01205219f, 
    -0.05559011f, -0.02338676f, 0.01796596f, -0.04483730f, -0.03342108f, -0.02046131f, -0.02790917f, -0.00460948f, 
    -0.04802053f, 0.04141584f, -0.03520134f, 0.02177636f, -0.03766324f, -0.05265952f, -0.05031176f, 0.01576375f, 
    0.01432831f, -0.04144146f, -0.05759197f, 0.03475011f, -0.03968644f, 0.01842180f, -0.06663717f, -0.00686012f, 
    -0.04257139f, -0.00230340f, -0.03745788f, 0.02814102f, -0.06421637f, -0.03730423f, -0.05164909f, -0.04329748f, 
    0.04130797f, 0.01116300f, 0.05311125f, -0.00047635f, -0.02713248f, -0.02069639f, 0.01944850f, -0.06672052f, 
    -0.05511899f, -0.02627273f, -0.05789905f, 0.00345988f, -0.00239160f, -0.04627537f, -0.02103469f, -0.05191761f, 
    -0.02229509f, 0.00355624f, -0.03925093f, -0.03640174f, -0.00436328f, -0.01494351f, 0.00690669f, 0.03948305f, 
    0.04533904f, 0.02470943f, -0.05634891f, 0.04515456f, -0.05135677f, -0.00010484f, 0.01438418f, -0.06352878f, 
    0.03039663f, 0.01251734f, -0.00456896f, -0.02072077f, -0.06549843f, -0.02739148f, 0.02204984f, 0.01010278f, 
    -0.02040778f, 0.01440860f, -0.04518569f, 0.01527564f, 0.00237636f, -0.04945251f, 0.04810387f, -0.00642234f, 
    0.02698442f, -0.05111669f, -0.01369335f, 0.04036324f, -0.01481134f, -0.00673642f, 0.02988247f, 0.01537662f, 
    0.04418158f, -0.04172333f, 0.03494035f, 0.04037480f, 0.00509471f, 0.02395618f, -0.01413736f, -0.06778087f, 
    -0.02202857f, 0.01891561f, -0.05045105f, 0.02754236f, -0.05553674f, 0.03963318f, 0.02220788f, 0.03814001f, 
    -0.00471538f, -0.02293108f, -0.04444299f, 0.03589955f, -0.04591065f, -0.03102465f, 0.00403090f, -0.01672228f, 
    -0.06856157f, 0.04779156f, -0.04158031f, -0.04883889f, -0.06044590f, -0.00469526f, -0.00973319f, -0.05677551f, 
    -0.01068525f, -0.02426778f, 0.02388259f, -0.03203710f, 0.00159791f, 0.05035191f, -0.02759571f, 0.02957809f, 
    0.04368222f, -0.03680706f, -0.02085941f, 0.01362772f, -0.03291219f, -0.00622284f, -0.05107628f, 0.03992734f, 
    0.02492711f, 0.03681190f, -0.04623779f, 0.02280431f, -0.03093766f, 0.03828217f, -0.06333055f, 0.01803791f, 
    -0.05616568f, -0.00726277f, -0.04537179f, -0.05060744f, 0.02416402f, 0.02116791f, -0.04806254f, -0.02151832f, 
    -0.05903089f, 0.01067719f, 0.02629716f, -0.05152316f, 0.04293351f, -0.05753602f, -0.02862745f, -0.05980675f, 
    -0.05455836f, 0.01217146f, -0.01342832f, 0.02199130f, -0.05057340f, -0.06285749f, -0.04940804f, 0.03792649f, 
    0.05460740f, -0.00866845f, 0.00243151f, -0.03187272f, 0.00246350f, 0.02234257f, 0.01617881f, -0.04253183f, 
    0.02231691f, 0.01001528f, 0.02368414f, 0.03325846f, -0.00184845f, -0.04505552f, -0.00961783f, 0.04791713f, 
    -0.06404158f, 0.01061779f, -0.00343513f, -0.06332897f, -0.01981258f, 0.03930078f, -0.03664675f, -0.02340127f, 
    -0.00635609f, -0.00754182f, -0.00516667f, -0.02753518f, 0.01382293f, -0.03267522f, -0.01270286f, 0.01334177f, 
    -0.01737669f, -0.02460326f, -0.06460766f, -0.05443211f, 0.03137602f, -0.01033747f, -0.01765482f, 0.05090421f, 
    0.04669244f, 0.00853747f, 0.04740684f, -0.00071382f, -0.00815063f, 0.03759589f, -0.03415016f, 0.02923718f, 
    0.00910840f, 0.01811582f, -0.01731689f, 0.01275736f, -0.02754793f, -0.04873214f, -0.05917022f, -0.04424699f, 
    0.05095194f, -0.05891174f, -0.04191210f, -0.06595020f, 0.00259243f, 0.04018436f, 0.04763956f, 0.01467700f, 
    -0.01778449f, -0.05653635f, -0.02480309f, 0.03443315f, -0.04162958f, 0.00369911f, 0.04016235f, -0.04022542f, 
    -0.02946602f, -0.04418079f, -0.01617041f, 0.01425981f, -0.00575872f, 0.04299099f, -0.05189053f, -0.00407503f, 
    -0.06699132f, -0.02030060f, -0.03057270f, -0.02171567f, 0.00059732f, 0.04744985f, -0.02974520f, 0.02011817f, 
    0.01244350f, 0.00366580f, -0.02588945f, -0.01551984f, -0.02923923f, -0.06431434f, -0.03805861f, 0.01724816f, 
    -0.06791653f, -0.00173409f, -0.00899451f, -0.05805725f, 0.00492200f, -0.03744863f, 0.03306256f, 0.03577333f, 
    0.00097006f, 0.01662466f, 0.02600539f, -0.04474451f, 0.04725766f, 0.05866112f, -0.00680802f, 0.04240457f, 
    -0.02296960f, 0.05062825f, -0.02814182f, 0.01409549f, 0.01342085f, -0.05318191f, -0.04980069f, -0.05830355f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.02254671f, 0.11291733f, 0.06315129f, 0.16710699f, 0.05085531f, 0.02711097f, -0.01553146f, 0.04559471f, 
    0.04660615f, 0.05309423f, 0.06498778f, -0.06310735f, 0.03769840f, -0.02267911f, 0.06154316f, 0.02633114f, 
    0.00566876f, -0.05713340f, -0.06574469f, 0.02634159f, 0.08057436f, 0.11624502f, -0.06008111f, 0.14496566f, 
    -0.04403393f, 0.00587795f, 0.03583172f, 0.01449847f, 0.04281886f, -0.05048911f, 0.12534475f, -0.06212477f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.17221145f, -0.03898231f, -0.01981313f, 0.11359169f, 0.03138981f, 0.01405260f, 0.06667870f, 0.00457356f, 
    -0.04425043f, 0.11858800f, 0.02534437f, 0.14967529f, -0.05236454f, -0.11535963f, 0.00970457f, -0.03909196f, 
    -0.10140888f, 0.11329553f, -0.04181552f, 0.01023587f, 0.08048543f, -0.09377342f, 0.08518054f, -0.13667916f, 
    0.00795450f, 0.07766368f, 0.03188746f, -0.16254355f, -0.09796687f, 0.02174604f, -0.13601592f, -0.00155413f, 
    -0.13298504f, -0.01422474f, 0.02200353f, 0.19746427f, -0.06362098f, -0.02313163f, 0.06460675f, 0.00985661f, 
    -0.09692077f, -0.17412741f, -0.25373498f, -0.02942053f, -0.19907746f, 0.13253818f, -0.22311699f, -0.10789255f, 
    -0.04487406f, -0.03261204f, -0.07352007f, 0.23294546f, 0.36734074f, 0.29021201f, 0.09264971f, 0.31353375f, 
    0.24690032f, 0.23843782f, 0.15446760f, -0.11919221f, -0.03392424f, -0.13616498f, 0.09532204f, -0.05939232f, 
    -0.13898014f, 0.06093720f, -0.12683468f, 0.33034745f, 0.07603566f, -0.06009500f, 0.15075670f, -0.15699148f, 
    0.07916198f, -0.05239708f, 0.31063125f, 0.09725735f, 0.31542283f, -0.10951634f, -0.04100633f, -0.15002483f, 
    0.12213004f, 0.03689552f, -0.13275887f, 0.14283159f, 0.47479102f, 0.09847761f, -0.10950338f, -0.11079420f, 
    -0.22495945f, -0.03939582f, 0.16612913f, -0.06166418f, 0.21282554f, 0.06225741f, 0.01043327f, -0.01174397f, 
    -0.05439546f, 0.31709394f, -0.14626345f, -0.02450443f, 0.09523824f, 0.06565581f, -0.03956018f, -0.16193889f, 
    -0.05413330f, -0.01240099f, 0.03507507f, 0.06322705f, -0.02901012f, -0.08546165f, 0.26208231f, 0.41300994f, 
    -0.09608978f, -0.00316869f, -0.05363268f, 0.13118118f, -0.23466052f, -0.22949618f, -0.14349547f, 0.08665131f, 
    -0.13217908f, -0.07107566f, 0.08155197f, 0.09263491f, 0.26283184f, 0.04455518f, -0.00343809f, 0.01963468f, 
    -0.07290112f, -0.29720435f, 0.24162835f, 0.34176061f, -0.12343096f, -0.07580366f, 0.07018004f, 0.00120256f, 
    0.08402872f, -0.06366368f, -0.09150360f, 0.07909196f, -0.07650200f, -0.15706724f, 0.15590107f, 0.30506706f, 
    0.49131703f, -0.06638151f, -0.10088003f, -0.45552161f, 0.24368095f, 0.09812144f, 0.09129775f, 0.23276284f, 
    -0.02484438f, 0.01432553f, 0.04779891f, -0.12832193f, -0.01520323f, -0.07443833f, -0.03968587f, 0.14687614f, 
    -0.12102900f, -0.21504132f, -0.05912281f, -0.01977716f, 0.02840786f, -0.16267100f, 0.00694416f, 0.04620783f, 
    0.05306521f, 0.00605502f, 0.16820358f, -0.09141149f, 0.16603641f, -0.08578406f, 0.39795417f, -0.05276392f, 
    -0.13832919f, -0.15757665f, -0.06953176f, 0.45315561f, 0.46793348f, 0.06922848f, -0.02365644f, -0.08289462f, 
    -0.26483616f, 0.18112536f, -0.09788209f, 0.09126458f, 0.30634567f, 0.13366850f, -0.12259068f, 0.10919932f, 
    -0.07689235f, -0.02067983f, -0.09170265f, 0.05033604f, 0.10945261f, -0.14045177f, -0.16264838f, -0.09904107f, 
    0.03375031f, -0.03778747f, 0.11443334f, 0.05184140f, -0.14205533f, -0.05509472f, -0.03498274f, 0.11409843f, 
    -0.01998812f, -0.07151169f, -0.07707537f, 0.06444664f, -0.14885442f, 0.00692013f, -0.01056723f, -0.03146541f, 
    -0.12725434f, -0.08681477f, -0.02933825f, 0.10915338f, -0.02903156f, 0.17166702f, -0.16937152f, 0.14935993f, 
    0.07101063f, 0.08512904f, 0.31998572f, 0.13311127f, -0.15495683f, -0.09347541f, 0.15337652f, -0.01703339f, 
    0.12253518f, -0.11053895f, 0.27045920f, -0.17354925f, -0.01035293f, -0.14415647f, 0.02229814f, 0.02573824f, 
    0.37915623f, 0.14523815f, -0.04788573f, -0.40476835f, -0.30074736f, -0.12507667f, 0.11627994f, 0.33191296f, 
    0.22749697f, -0.29727840f, 0.04795109f, -0.10345376f, 0.20249890f, 0.13757589f, 0.22493495f, 0.03988566f, 
    -0.05473185f, -0.44289294f, -0.26973474f, 0.15331843f, -0.07797299f, 0.16160330f, -0.01861504f, -0.00866773f, 
    -0.00478489f, 0.08083739f, -0.11035480f, -0.00113622f, 0.23290804f, -0.05721346f, 0.17892744f, 0.08005711f, 
    -0.28768057f, -0.06484094f, -0.10217091f, 0.16145709f, 0.42083582f, -0.01836437f, 0.15363790f, 0.19475493f, 
    0.30916229f, 0.29044110f, -0.17136335f, 0.07985792f, 0.33129218f, 0.14732812f, -0.09312971f, 0.15586494f, 
    -0.08623940f, -0.17212993f, 0.22902973f, 0.13817424f, 0.00487222f, -0.11786374f, 0.14384121f, -0.13916792f, 
    -0.03641133f, 0.16125631f, 0.04568622f, -0.09381185f, -0.19158502f, 0.04396976f, 0.06191155f, 0.33733788f, 
    -0.23170415f, -0.14168750f, -0.08517169f, 0.36027658f, -0.53616345f, 0.16872501f, -0.12494755f, 0.10140221f, 
    0.16805963f, 0.10328533f, 0.09223370f, -0.08790515f, 0.02745462f, -0.02177281f, -0.06424087f, -0.04229348f, 
    0.13110521f, 0.24702208f, 0.32239527f, -0.07487278f, 0.13348050f, 0.06834575f, 0.00760636f, -0.12027088f, 
    -0.15803857f, -0.17153920f, -0.31987381f, -0.10161144f, -0.15231188f, 0.13849160f, -0.00631806f, -0.06510376f, 
    -0.08470889f, 0.11127058f, -0.14097905f, 0.22305878f, -0.12453783f, 0.02435344f, -0.17335226f, -0.13930546f, 
    0.41661337f, 0.17067246f, 0.17434399f, -0.12947543f, -0.09505230f, -0.11379794f, -0.12436209f, 0.12195819f, 
    -0.04804557f, 0.40221104f, -0.01639692f, -0.00042528f, -0.00612691f, -0.04469396f, -0.00629107f, 0.03304637f, 
    -0.06986087f, -0.15172014f, -0.29356992f, 0.05159923f, -0.05991902f, -0.00671852f, -0.11570501f, 0.19015050f, 
    0.22011575f, 0.02675655f, 0.00684627f, -0.32485130f, 0.62696713f, 0.20635778f, 0.09568605f, -0.26374292f, 
    0.06505004f, -0.14692023f, 0.14073966f, -0.11036180f, -0.34405261f, -0.07345264f, 0.33305636f, -0.12775034f, 
    -0.06154949f, -0.15870284f, -0.04824428f, 0.00283113f, -0.15683071f, -0.08280303f, 0.12683493f, -0.11470171f, 
    0.01053637f, 0.08177263f, -0.03215587f, -0.05298526f, -0.07293530f, 0.14257854f, 0.02360267f, -0.12859096f, 
    0.07604129f, -0.10410978f, -0.02966904f, -0.06355476f, -0.00392451f, -0.13951688f, -0.09935351f, -0.11418983f, 
    0.01955059f, 0.07544883f, -0.06639740f, -0.18182036f, -0.01975015f, 0.14170051f, -0.05243490f, -0.01476978f, 
    -0.14643957f, -0.29962826f, 0.35401574f, -0.58380198f, 0.00305748f, 0.15199150f, -0.17155264f, -0.07153560f, 
    0.16359146f, 0.14208381f, -0.28751838f, 0.10861480f, -0.12323292f, 0.03390018f, -0.00230417f, 0.18267451f, 
    -0.05795125f, -0.01353700f, -0.06056789f, 0.01501668f, 0.01379688f, 0.09296462f, -0.05867619f, -0.01760914f, 
    0.35155380f, 0.02308927f, 0.01779831f, 0.02996595f, 0.20937966f, -0.07423476f, 0.12723234f, 0.05045331f, 
    -0.05588099f, 0.32196161f, -0.04277055f, 0.13484026f, 0.05061689f, 0.04872833f, -0.12457186f, 0.02219589f, 
    -0.11265228f, -0.15353528f, 0.19281706f, 0.03088773f, 0.20082116f, 0.17717397f, -0.42885739f, -0.38129017f, 
    -0.05006062f, -0.13749167f, 0.13872367f, 0.14178675f, -0.38900489f, 0.27090126f, -0.06999144f, 0.01215298f, 
    -0.21062367f, -0.04763449f, -0.15754294f, -0.03341785f, -0.16218287f, -0.11122990f, 0.32050824f, -0.03831528f, 
    0.14473590f, -0.26399964f, 0.34950125f, 0.08962061f, -0.07134300f, -0.16147792f, -0.02908925f, -0.11575544f, 
    -0.01961504f, 0.09833221f, 0.14189139f, 0.00765617f, -0.09446479f, -0.13155897f, -0.02921424f, 0.13914806f, 
    -0.26733413f, -0.16279791f, 0.06736442f, 0.35601696f, -0.19824158f, 0.21227323f, 0.02698376f, 0.30943549f, 
    0.14471810f, 0.12796400f, -0.12216401f, -0.00883300f, 0.28074905f, -0.17474465f, -0.09730978f, 0.11412846f, 
    -0.10863817f, -0.26933557f, -0.10646976f, 0.12766950f, -0.02451280f, 0.10919334f, 0.00665707f, 0.03652854f, 
    0.03783608f, 0.09769525f, 0.21858577f, -0.05074386f, 0.35259113f, -0.09602403f, 0.28645498f, 0.16507362f, 
    0.31671408f, -0.03007317f, 0.12024559f, -0.24998291f, -0.04863155f, -0.08544721f, -0.07344752f, 0.37370846f, 
    -0.05708816f, 0.04498187f, 0.04816595f, 0.17192993f, 0.00704214f, 0.00828822f, 0.04173421f, -0.07674841f, 
    0.09992053f, 0.35004115f, -0.03780637f, -0.03481110f, 0.09222484f, 0.06936642f, 0.03363635f, 0.16663396f, 
    0.16353486f, -0.10416576f, 0.10260523f, 0.06984957f, -0.12939268f, 0.02466811f, 0.45024508f, -0.04322235f, 
    0.18076470f, -0.12068255f, 0.13314198f, -0.28587705f, 0.35797992f, -0.06340246f, 0.00783824f, 0.02315499f, 
    0.30820012f, -0.18979506f, -0.06984116f, 0.12462422f, 0.19677939f, -0.05509872f, 0.14746843f, -0.13115107f, 
    0.10684902f, 0.00592799f, -0.06744755f, 0.24617338f, -0.08586933f, 0.12056942f, -0.08385848f, -0.06117892f, 
    0.11616736f, 0.09630864f, 0.21297710f, 0.15351740f, 0.27808860f, 0.07870147f, 0.44904536f, 0.30095449f, 
    0.04352846f, 0.11227407f, 0.03950714f, 0.19322057f, -0.08397815f, -0.06989405f, -0.12716728f, -0.41956526f, 
    0.04789818f, -0.29689059f, 0.01026027f, 0.09255170f, 0.29334682f, -0.05248945f, -0.08500605f, -0.14139356f, 
    0.00223745f, -0.00761888f, 0.23341712f, -0.14587714f, -0.15668738f, -0.03168436f, 0.07887255f, -0.07625016f, 
    0.04524279f, -0.08622307f, -0.22390613f, -0.11396494f, -0.20319352f, 0.11798264f, -0.32103607f, 0.18157654f, 
    -0.10020196f, -0.15483139f, 0.06366421f, 0.20412637f, -0.41162384f, -0.12501974f, -0.12409437f, 0.04215668f, 
    0.40448016f, 0.13698582f, -0.07592651f, -0.01273726f, 0.16824925f, -0.14559163f, 0.07772315f, 0.07065526f, 
    0.11347895f, -0.00726590f, 0.18230976f, -0.08457633f, -0.15097113f, -0.10287745f, -0.01906931f, -0.13856928f, 
    0.16495270f, -0.00171321f, 0.45383140f, -0.04559903f, -0.26441938f, -0.01057034f, 0.37095982f, -0.03737266f, 
    0.14888570f, 0.07438518f, -0.12136681f, 0.08713988f, -0.32052904f, -0.06002330f, 0.07506386f, 0.12683836f, 
    0.00438530f, 0.40197575f, -0.06670856f, -0.11021126f, 0.31169841f, -0.09333719f, 0.14502843f, -0.06186877f, 
    -0.01853745f, 0.09314121f, -0.08255819f, 0.48341680f, 0.09255431f, 0.13571431f, -0.12392265f, 0.06467244f, 
    0.05672321f, 0.02438125f, 0.03010192f, 0.12849635f, 0.28075391f, -0.12826937f, 0.41262659f, -0.22565062f, 
    -0.19884445f, -0.05132579f, 0.12583980f, 0.21401034f, -0.03146774f, -0.10098935f, -0.03629797f, 0.48704249f, 
    -0.01502120f, -0.17007318f, -0.03393887f, 0.05649997f, 0.22080773f, -0.17091581f, -0.18557842f, 0.02797627f, 
    0.05304674f, -0.03039192f, 0.13556419f, 0.22472383f, -0.07252391f, -0.11628189f, -0.14685769f, 0.06504443f, 
    -0.05275369f, 0.02870242f, 0.09763793f, 0.00247360f, -0.09277367f, 0.05551724f, 0.46247208f, 0.13556230f, 
    -0.19874230f, 0.11712767f, 0.15964296f, 0.34243494f, -0.20680064f, -0.04915740f, 0.12248915f, 0.29492018f, 
    0.12993415f, -0.16699739f, -0.14661297f, -0.13120595f, 0.39005712f, -0.08319647f, -0.13812512f, 0.09475178f, 
    0.07949646f, 0.09409863f, -0.12080687f, 0.12196915f, -0.10008317f, -0.13608630f, -0.02337445f, 0.00859903f, 
    -0.13326418f, 0.07314461f, -0.18320701f, -0.08379660f, -0.05328052f, 0.16877942f, 0.59219766f, 0.15892440f, 
    -0.12439208f, 0.02511668f, 0.16868728f, 0.05279813f, 0.32441765f, -0.16454172f, -0.01166406f, 0.02429465f, 
    0.23725887f, -0.11014275f, 0.06100097f, 0.03243643f, 0.34356394f, -0.15282643f, 0.16920598f, 0.16610111f, 
    0.14994122f, 0.01920642f, 0.00718399f, -0.15615152f, -0.15189950f, -0.10765202f, -0.08229075f, 0.12980506f, 
    0.12791321f, 0.16910224f, 0.13508438f, 0.14078276f, 0.20239598f, -0.02144513f, -0.57419223f, 0.05613424f, 
    0.04205066f, -0.15477906f, -0.09107884f, 0.03251143f, -0.54676700f, 0.29423127f, 0.06831003f, -0.05627780f, 
    0.13683082f, 0.16223744f, -0.02218884f, -0.07536323f, -0.28837064f, -0.02569539f, 0.27148402f, 0.11218429f, 
    -0.06786852f, 0.23372321f, 0.17564891f, 0.17659920f, 0.13322842f, 0.13339885f, 0.06356783f, -0.08553541f, 
    0.01967559f, 0.07051456f, 0.31856257f, 0.08182407f, -0.17634593f, -0.06344736f, 0.01915728f, -0.18616170f, 
    -0.05610294f, -0.17873977f, -0.02801023f, -0.11664969f, -0.25970170f, -0.18352748f, 0.05295094f, 0.46676329f, 
    0.25109467f, -0.04984435f, -0.02752271f, -0.04336772f, 0.10883992f, -0.15174268f, 0.19465993f, 0.02462209f, 
    0.00675870f, -0.08250001f, 0.45431146f, -0.00355695f, -0.08003221f, 0.02114967f, -0.02984035f, -0.11791074f, 
    0.01718204f, 0.06384552f, 0.15077484f, -0.11244638f, -0.05767668f, -0.10526013f, 0.37010047f, 0.40682375f, 
    0.14692262f, -0.00354589f, -0.12827428f, -0.10824656f, 0.12893447f, 0.09745430f, 0.10888270f, -0.14786209f, 
    0.23204610f, 0.09728193f, 0.05178861f, 0.03053954f, 0.26388216f, -0.08416116f, -0.22842003f, 0.16179556f, 
    0.14362738f, 0.27035975f, -0.02151208f, -0.08736961f, -0.08417990f, -0.13593751f, 0.01457678f, -0.13629723f, 
    0.05866488f, 0.16134702f, 0.31580308f, 0.12511079f, 0.33699054f, 0.05962342f, 0.10027299f, 0.22065628f, 
    0.11588906f, 0.03112645f, 0.01684273f, 0.02760770f, 0.01405643f, -0.16455980f, 0.08790078f, -0.35705203f, 
    -0.09343859f, 0.11216546f, 0.03222344f, 0.01886278f, 0.31328657f, 0.05882168f, -0.02267477f, -0.03190135f, 
    0.05076995f, -0.19950847f, 0.08367296f, -0.10644659f, -0.11501881f, -0.14624399f, 0.04371848f, 0.14341407f, 
    -0.02103641f, 0.05462235f, 0.06402115f, 0.12104560f, 0.22577935f, -0.11631915f, 0.02150319f, 0.19677179f, 
    0.38481241f, 0.14794828f, -0.13033147f, -0.11429773f, 0.49380812f, 0.13497627f, -0.16216321f, -0.10259839f, 
    -0.16210382f, 0.40839344f, -0.09469926f, 0.03893439f, 0.10202186f, -0.13281558f, -0.11522412f, 0.01844065f, 
    0.04070962f, -0.13499106f, 0.37236089f, 0.22532569f, -0.13590969f, -0.09392878f, 0.00380093f, 0.00161981f, 
    -0.14935705f, 0.06360923f, 0.19279742f, -0.05689270f, -0.28137293f, -0.13080446f, 0.42032546f, -0.00672954f, 
    0.25167048f, 0.14885898f, -0.14692162f, -0.10150262f, 0.28947559f, 0.14721833f, -0.16412663f, 0.31383458f, 
    -0.15321369f, -0.17209016f, 0.07289409f, -0.04404430f, 0.26272610f, -0.10809764f, -0.03925893f, -0.05889993f, 
    0.01110416f, 0.10448311f, -0.07402294f, -0.21217576f, 0.10818969f, 0.10506614f, 0.09396949f, 0.15709794f, 
    -0.07236113f, 0.06129527f, -0.31677693f, -0.14107473f, -0.13546391f, 0.10000167f, -0.08193216f, 0.41291296f, 
    0.30701393f, 0.03982599f, 0.13877018f, -0.09963830f, 0.26221395f, 0.26545775f, 0.02676472f, -0.18493465f, 
    0.07691351f, 0.44865268f, -0.14285760f, -0.05729836f, -0.35983557f, 0.08291806f, 0.10413390f, 0.16211399f, 
    -0.11215922f, -0.03483203f, 0.06970480f, -0.18970849f, 0.13318060f, 0.11047827f, -0.00793152f, -0.06297579f, 
    -0.04584967f, 0.15553732f, 0.34799030f, 0.07929113f, 0.31821960f, 0.08056273f, 0.26913372f, -0.16919900f, 
    0.46527553f, 0.14538977f, -0.16460405f, -0.05403068f, 0.07963652f, -0.10130605f, -0.02097316f, -0.07061354f, 
    -0.02093270f, -0.32190827f, -0.10545337f, 0.01234653f, 0.23896676f, 0.15381981f, 0.17313758f, 0.05788159f, 
    0.12637691f, -0.17593415f, -0.08836406f, -0.00286998f, 0.14559713f, -0.05131320f, 0.05876562f, -0.04382100f, 
    -0.14856009f, 0.12774044f, -0.13803457f, 0.07443178f, 0.18255301f, -0.10481857f, 0.16678180f, 0.32163385f, 
    0.07953044f, -0.12952395f, -0.14970767f, 0.36508140f, -0.22438586f, 0.21931374f, 0.17589121f, -0.23589452f, 
    0.04173933f, 0.11946175f, -0.11491645f, 0.03125612f, 0.29293957f, 0.00896232f, -0.24864917f, 0.06638095f, 
    -0.10946105f, 0.14849128f, -0.35495588f, 0.35210991f, 0.14578487f, -0.08406880f, -0.12354660f, 0.15556173f, 
    0.16513629f, -0.09615858f, -0.21052253f, 0.09240314f, 0.28069332f, 0.02028658f, 0.09506869f, 0.20809942f, 
    -0.18823716f, -0.11577713f, 0.04729131f, -0.13025182f, -0.03896378f, -0.01802302f, -0.15248562f, 0.41070476f, 
    0.17028728f, -0.32181713f, 0.00117019f, -0.09574053f, -0.11746166f, -0.05951247f, 0.32972318f, 0.12306614f, 
    -0.04951702f, -0.07396917f, -0.05731380f, 0.08953265f, 0.04540387f, 0.11317099f, 0.15566400f, -0.07520117f, 
    0.00734004f, 0.10756554f, -0.17275093f, -0.05108617f, -0.11713844f, 0.14352481f, 0.11126243f, -0.08687630f, 
    -0.13952632f, 0.16268969f, -0.11421143f, 0.11914946f, -0.04384641f, -0.01902100f, 0.09944487f, -0.03747058f, 
    -0.12190734f, -0.16806477f, 0.10686578f, 0.16733466f, -0.14140898f, -0.04734678f, 0.07745185f, 0.17436156f, 
    0.16146584f, 0.50338221f, -0.23585597f, -0.07207567f, 0.01620346f, -0.10442384f, -0.06913698f, 0.10157172f, 
    -0.17001122f, -0.14739028f, 0.41505593f, 0.11314251f, 0.37117952f, -0.14320333f, -0.04417509f, -0.32050180f, 
    0.00787787f, -0.05339646f, -0.05121631f, -0.23370135f, -0.39733806f, -0.07516976f, -0.18028152f, 0.07804450f, 
    -0.18928020f, -0.08752157f, 0.12737563f, -0.10608495f, -0.32266128f, -0.15499033f, 0.12562846f, 0.17076539f, 
    0.04936135f, -0.39521396f, 0.32716206f, 0.22362587f, -0.14807315f, 0.07087808f, 0.11529849f, 0.03362042f, 
    0.11617644f, 0.03912485f, 0.01949909f, -0.02915650f, 0.14805423f, 0.02885438f, -0.28005353f, -0.01785804f, 
    0.02526537f, 0.01001011f, -0.15724601f, -0.15901683f, -0.25954488f, 0.39215305f, 0.00789102f, 0.47846305f, 
    0.01284191f, 0.07879309f, 0.06904416f, 0.15818857f, -0.08656199f, -0.05940649f, 0.31545222f, -0.07305592f, 
    -0.14922698f, -0.21225934f, -0.14985581f, 0.07519195f, 0.11471367f, 0.09804723f, 0.15322913f, -0.04866882f, 
    0.11913016f, 0.15983042f, 0.09495413f, -0.08281598f, -0.10463107f, -0.00314629f, -0.04487142f, 0.01210889f, 
    -0.19825643f, -0.00424370f, -0.15368743f, 0.04277010f, -0.19695945f, -0.06374367f, -0.14885414f, -0.06360637f, 
    -0.10129736f, -0.01824597f, -0.14149061f, -0.12531820f, 0.05119148f, -0.13720801f, -0.00146805f, -0.16950074f, 
    -0.09435285f, 0.16774178f, -0.51265866f, -0.00547890f, 0.07441077f, 0.05009074f, 0.13475285f, -0.07422019f, 
    -0.01558835f, 0.07686523f, -0.18246530f, 0.01439959f, 0.36672369f, -0.04497402f, 0.41454455f, 0.47464854f, 
    0.11475622f, -0.11204419f, 0.14083567f, -0.34300962f, 0.20485938f, -0.00697077f, 0.05095251f, -0.18528415f, 
    0.10453047f, -0.10773211f, 0.08171555f, 0.16379587f, -0.22037782f, -0.06363142f, -0.06041700f, 0.14731532f, 
    -0.10937987f, -0.29993823f, 0.09822636f, -0.14556779f, -0.01587257f, -0.16567625f, 0.11805267f, -0.07236768f, 
    -0.07047001f, -0.17476034f, 0.01560653f, 0.04570287f, 0.21249995f, 0.16254459f, 0.26686007f, 0.28778759f, 
    -0.14769258f, -0.00108521f, 0.07555053f, 0.36872193f, -0.16248262f, -0.06877749f, 0.13010238f, 0.11076126f, 
    0.16001791f, 0.32855216f, -0.09016550f, 0.09022020f, 0.40979916f, 0.09554048f, -0.07647996f, -0.13106783f, 
    0.03904269f, -0.05668726f, 0.11805119f, 0.24821398f, 0.02914971f, 0.16152854f, 0.09570846f, 0.05562743f, 
    -0.06909952f, 0.16767441f, 0.39445272f, -0.02848929f, -0.18760559f, -0.07148845f, 0.40819079f, 0.01048831f, 
    -0.14498889f, 0.06703674f, -0.05159585f, 0.19340871f, -0.32150176f, -0.09139358f, 0.13419928f, 0.22932889f, 
    -0.16869633f, -0.10251127f, 0.09960973f, 0.16229612f, 0.03125153f, -0.14582312f, 0.11393956f, 0.15358578f, 
    0.13297109f, -0.24406523f, -0.00761814f, -0.50551862f, 0.09554781f, -0.00055525f, 0.02721103f, 0.06004203f, 
    -0.16766152f, -0.00956437f, 0.09112173f, 0.08230803f, 0.27902639f, 0.07115681f, -0.23710899f, -0.05537372f, 
    0.22643624f, -0.08632430f, 0.02713100f, 0.31448755f, -0.11853300f, 0.20128818f, 0.07562747f, -0.10484184f, 
    -0.26248509f, 0.10557470f, 0.12808666f, 0.02232842f, 0.21865422f, 0.13234664f, 0.13339467f, -0.10900716f, 
    0.15642165f, 0.10712573f, 0.20893173f, 0.07339223f, -0.03064253f, -0.13597278f, -0.07200498f, 0.16160513f, 
    0.14824888f, -0.14137225f, 0.17415464f, 0.14820740f, 0.30913982f, 0.10690010f, 0.03186800f, 0.30264422f, 
    -0.01494812f, 0.09522215f, 0.05037906f, 0.33350685f, -0.71859902f, 0.14800972f, -0.08312811f, -0.38675901f, 
    -0.21395542f, -0.27229160f, -0.10550939f, 0.10938443f, 0.18671072f, -0.16008206f, 0.01528854f, 0.12290006f, 
    -0.05442048f, 0.03493850f, 0.07509571f, 0.49980447f, 0.12320946f, -0.01366817f, 0.06325073f, -0.09402445f, 
    -0.13141012f, -0.09953342f, -0.41695774f, -0.14333031f, 0.22982900f, -0.11124806f, -0.30454531f, -0.08408158f, 
    -0.38158351f, 0.06450821f, -0.15132309f, 0.31505182f, 0.08095220f, 0.10385964f, -0.01527224f, 0.04094977f, 
    0.34470889f, -0.42861304f, 0.04381415f, -0.03139823f, -0.04893790f, -0.13361639f, 0.21709579f, -0.00978293f, 
    -0.07651935f, 0.12903938f, 0.17650190f, 0.14615296f, 0.09632129f, 0.13737650f, 0.01427769f, -0.16853745f, 
    0.13762665f, 0.16464303f, -0.20477203f, -0.03066965f, 0.08171264f, 0.06982969f, 0.53373033f, 0.25506449f, 
    -0.05198295f, 0.15504812f, 0.01820194f, 0.11583307f, 0.38991222f, -0.10107629f, 0.15620020f, 0.13234554f, 
    0.30348623f, -0.27953053f, 0.13791113f, -0.15855235f, 0.31747174f, 0.17557049f, -0.12538424f, 0.11590757f, 
    -0.15156348f, -0.08201516f, 0.22568713f, -0.35610363f, 0.12791373f, -0.07630355f, -0.15419847f, -0.06912011f, 
    0.17066097f, 0.10920683f, 0.20542370f, -0.09437354f, 0.35559589f, 0.09475346f, -0.16442373f, 0.24113342f, 
    0.36671692f, -0.11488211f, -0.00849580f, -0.03247441f, 0.02660940f, -0.06609716f, 0.11959931f, -0.20655286f, 
    -0.17964277f, 0.41604435f, -0.00986309f, -0.09266683f, 0.07736571f, 0.13687962f, -0.05551725f, -0.08069763f, 
    0.13792996f, 0.11612072f, -0.33839965f, -0.02853763f, -0.03176256f, -0.13638167f, -0.08045532f, -0.10709816f, 
    -0.12556764f, 0.15063103f, 0.03505739f, -0.16023913f, 0.13652100f, -0.14760087f, -0.31282845f, -0.36963019f, 
    -0.22769755f, -0.10931626f, 0.06805994f, 0.09392653f, 0.14249206f, 0.05025333f, 0.14194226f, 0.55292261f, 
    0.12325758f, -0.07879817f, -0.00038389f, -0.05326329f, 0.17636517f, 0.00911478f, 0.30736443f, 0.15303153f, 
    -0.10376614f, 0.14151029f, 0.34840858f, -0.01885362f, 0.17330571f, 0.01003235f, -0.07584918f, -0.07914029f, 
    0.14505632f, -0.01712030f, 0.22047406f, -0.04196008f, 0.27462828f, 0.09041790f, 0.32072753f, -0.05038264f, 
    0.34376889f, 0.07837720f, 0.00486958f, 0.01825036f, 0.26219866f, -0.04825637f, -0.09575706f, -0.20284900f, 
    -0.23263024f, -0.16418451f, 0.06142442f, -0.10070302f, 0.33756673f, -0.08420222f, -0.15710317f, -0.02195075f, 
    0.00787502f, -0.24744025f, 0.01498621f, 0.02976339f, 0.13106416f, -0.15726583f, 0.09660827f, -0.12118854f, 
    0.09284562f, 0.14461964f, -0.07149621f, -0.05169297f, 0.08273927f, 0.04529066f, 0.29269654f, 0.33469898f, 
    -0.20216179f, 0.01208419f, 0.00629235f, 0.29303804f, 0.08552837f, -0.05453406f, 0.00037467f, 0.10362298f, 
    0.31856373f, 0.14076608f, -0.01976520f, 0.10452441f, 0.31515071f, 0.14415431f, -0.14425762f, -0.03860085f, 
    -0.02201496f, -0.13437589f, 0.02858935f, 0.04720993f, -0.11511634f, 0.12969993f, 0.11757826f, -0.17163111f, 
    -0.12064642f, -0.09888148f, 0.16692871f, -0.02085369f, -0.04099952f, -0.13363890f, 0.10010328f, 0.07533630f, 
    -0.11566843f, -0.04537964f, 0.08948309f, -0.06954942f, 0.20158176f, -0.23007099f, 0.02292923f, 0.27552027f, 
    0.10115872f, -0.04315818f, 0.06762995f, 0.10225337f, 0.36180025f, -0.15245524f, -0.04014074f, 0.04142188f, 
    -0.02297088f, -0.06636481f, 0.28509530f, -0.24963841f, -0.15290548f, -0.12794290f, -0.10451164f, -0.03742937f, 
    -0.09205262f, -0.14568803f, -0.15364313f, 0.07367814f, 0.15953749f, -0.09302417f, -0.39686751f, 0.05907444f, 
    0.21871172f, -0.05614065f, -0.06369836f, 0.04351599f, -0.39970431f, 0.24095640f, 0.05439879f, -0.17727733f, 
    0.14340830f, 0.39876556f, 0.15798604f, 0.10045961f, -0.09350121f, 0.10761567f, 0.20481697f, 0.01430034f, 
    -0.14094105f, -0.07513130f, -0.02485020f, 0.22473542f, 0.12832619f, -0.08749370f, 0.10824341f, 0.09591942f, 
    -0.08958846f, -0.04464898f, -0.03375418f, 0.13148364f, -0.10138689f, -0.14916563f, -0.46002111f, 0.04121871f, 
    -0.22400436f, 0.04802258f, 0.03234330f, 0.23161851f, 0.10266002f, 0.12457774f, -0.07875655f, 0.00407529f, 
    0.09311523f, 0.33212009f, 0.03144251f, -0.09796708f, -0.28096852f, 0.15049770f, 0.28999615f, -0.03233657f, 
    -0.12429276f, -0.08819892f, -0.23419581f, 0.08387073f, -0.06138735f, -0.14793248f, 0.17634372f, -0.11694282f, 
    0.01864714f, 0.17396170f, -0.07646848f, 0.06316490f, 0.31146365f, 0.04746655f, 0.08693944f, 0.19580890f, 
    0.14212184f, -0.03192323f, 0.02518599f, -0.04653882f, 0.08303411f, -0.09737343f, -0.09044626f, 0.10826128f, 
    0.03098206f, -0.09107251f, -0.05955326f, -0.14065348f, -0.25272521f, -0.11083660f, -0.15838724f, -0.14736688f, 
    0.02549259f, 0.07800778f, 0.12429605f, -0.10291839f, -0.01598662f, 0.11382365f, 0.14121768f, -0.16789483f, 
    0.12832759f, 0.04104113f, -0.25984657f, -0.07799234f, -0.27234340f, 0.16899684f, -0.44769341f, 0.00972228f, 
    0.26391280f, -0.04730939f, -0.01417777f, -0.21262215f, -0.19776505f, 0.29409879f, -0.03309936f, 0.33145028f, 
    0.09218166f, 0.19345346f, -0.14357854f, 0.10154646f, -0.19430535f, -0.05369207f, 0.35140797f, -0.14493234f, 
    0.00595602f, -0.01029383f, 0.06675909f, 0.36027765f, 0.09871207f, -0.08700792f, -0.15380284f, -0.09447858f, 
    0.00281504f, -0.10001849f, -0.15953654f, -0.15753995f, 0.14706659f, -0.09594113f, 0.09554936f, 0.24571726f, 
    0.21221992f, -0.12797360f, 0.06679852f, -0.41062090f, 0.37220925f, 0.12897740f, -0.11945427f, -0.04014591f, 
    0.05769262f, -0.29443786f, -0.16514722f, -0.02318322f, 0.02701561f, -0.01741244f, 0.14133525f, 0.16614772f, 
    0.11157440f, -0.08586255f, -0.45552325f, -0.26844296f, 0.00508586f, 0.11363885f, -0.15377392f, 0.18204145f, 
    -0.11334281f, 0.02191801f, -0.00468943f, -0.02399612f, 0.39191973f, -0.11619294f, -0.08534313f, 0.05820864f, 
    0.12358843f, -0.14581360f, 0.15031610f, -0.14703648f, 0.45596930f, 0.04332284f, 0.08011431f, 0.36515722f, 
    0.05540788f, -0.00078350f, 0.01586735f, -0.10171824f, 0.04525727f, 0.14403592f, -0.08315539f, 0.14202143f, 
    -0.02892587f, -0.10550982f, -0.11470409f, -0.00703457f, 0.13295035f, -0.08094909f, 0.00626225f, -0.02418201f, 
    -0.10881332f, -0.05771416f, 0.04739613f, -0.01666316f, -0.12846334f, 0.08114813f, -0.13555725f, -0.01336708f, 
    0.10371774f, 0.04432740f, -0.09532348f, 0.02998344f, -0.14865968f, -0.02452782f, 0.07623374f, -0.07911121f, 
    -0.18905406f, -0.02184551f, -0.01633117f, 0.02888966f, 0.09317948f, -0.06538405f, -0.05873696f, 0.08301212f, 
    0.01115033f, -0.04076715f, -0.05131262f, -0.51790661f, -0.10781383f, 0.13675024f, -0.02586208f, -0.01421493f, 
    -0.02539213f, 0.13975002f, -0.15735675f, -0.17166048f, -0.06038324f, 0.06557533f, -0.07820401f, 0.30126685f, 
    -0.12587731f, -0.04510636f, 0.03645258f, 0.08479507f, 0.18379062f, 0.12299524f, 0.06351945f, 0.19682631f, 
    -0.13251548f, -0.11788113f, 0.13310362f, -0.03554631f, 0.07254517f, 0.07897236f, 0.06412094f, -0.11309550f, 
    -0.12060708f, 0.44370446f, 0.25081560f, 0.18869168f, 0.11905467f, -0.14408538f, 0.12135988f, -0.10721544f, 
    0.15950854f, 0.11931977f, 0.00303012f, 0.10310128f, 0.13181910f, 0.13198043f, 0.00655290f, 0.04027840f, 
    0.22101176f, -0.15368330f, -0.06538161f, -0.12500221f, 0.70015341f, -0.11453328f, 0.10354876f, -0.44698286f, 
    0.22130489f, -0.32291460f, 0.10588497f, -0.05863506f, 0.09649603f, 0.08897436f, 0.18657584f, 0.12173790f, 
    -0.16026074f, 0.62522709f, -0.24932455f, 0.03197992f, 0.13846964f, -0.00972972f, -0.02905017f, 0.17041117f, 
    0.13659614f, -0.10619487f, 0.28499106f, -0.09956320f, 0.11100669f, -0.10675725f, 0.52932930f, -0.11749999f, 
    0.22038826f, 0.12337223f, 0.03077997f, 0.02793145f, 0.09206211f, -0.23931250f, -0.10137133f, -0.05110501f, 
    0.01659776f, -0.07076021f, 0.10407435f, 0.12031042f, -0.22191772f, -0.03855642f, 0.02742516f, 0.05168640f, 
    0.10757010f, 0.01207063f, 0.34469321f, 0.25192261f, 0.14331415f, 0.07331652f, -0.04336409f, -0.02876544f, 
    0.12086344f, -0.11939672f, 0.08264507f, -0.15545723f, -0.26622579f, 0.11727415f, 0.49746913f, 0.26063880f, 
    0.21282993f, -0.16639023f, -0.00260458f, 0.19823416f, -0.01264830f, -0.07233197f, 0.05853835f, 0.05173521f, 
    -0.01269102f, -0.08047108f, -0.01643267f, -0.06020483f, 0.33604872f, -0.13204734f, -0.09644290f, 0.11040676f, 
    -0.04935088f, 0.29831710f, -0.15632148f, -0.05575987f, 0.09485982f, -0.06391643f, 0.04647345f, 0.04881801f, 
    0.06821329f, -0.02635979f, -0.01979993f, -0.12788899f, 0.40653747f, -0.00795810f, -0.56116462f, -0.16989030f, 
    -0.03364752f, 0.07307444f, -0.11663764f, -0.05488255f, -0.22728008f, 0.28536260f, 0.12321471f, -0.01488533f, 
    0.07663154f, -0.12210426f, 0.11695556f, 0.07149299f, -0.22735114f, 0.07984234f, 0.21881869f, -0.10488743f, 
    -0.13297744f, 0.32957071f, -0.26602808f, 0.04227763f, 0.15500757f, 0.01731028f, -0.09705222f, -0.12446492f, 
    -0.01085109f, -0.10623355f, -0.13176335f, 0.09634182f, 0.23461236f, 0.09647436f, 0.01156358f, 0.02034323f, 
    0.28190914f, 0.13994271f, -0.07005386f, 0.17188221f, 0.46455756f, 0.26512113f, 0.00267593f, -0.40826043f, 
    -0.28276503f, 0.19604257f, -0.14008443f, 0.00502360f, -0.34332031f, -0.08925885f, 0.17942990f, 0.01673254f, 
    0.02935459f, -0.11511873f, -0.09949412f, 0.11544394f, -0.14322138f, -0.06959093f, -0.01550616f, 0.11617652f, 
    -0.08123520f, 0.15180188f, -0.08231754f, -0.16132542f, -0.12207846f, -0.16551471f, -0.16546562f, -0.09927586f, 
    -0.08990295f, 0.11171047f, -0.06316536f, -0.10058466f, 0.07640182f, 0.04527114f, -0.03021291f, -0.00129534f, 
    -0.03705811f, 0.04659178f, 0.06865385f, -0.09740717f, 0.06914688f, -0.01627039f, -0.13708293f, -0.00798702f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03721377f, 0.15192653f, -0.00171209f, 0.03018412f, 0.12827122f, -0.02674305f, 0.06238307f, 0.01700011f, 
    0.19575721f, 0.26884377f, -0.04271830f, 0.08146457f, 0.03824877f, -0.14112826f, 0.20309295f, 0.23534897f, 
    -0.02916371f, -0.05397796f, 0.26150009f, 0.03172947f, 0.01701173f, 0.05212360f, 0.00962403f, -0.17470858f, 
    0.12234721f, 0.24791153f, -0.18740875f, -0.02535071f, 0.06811760f, 0.00894853f, 0.22166798f, 0.09551355f, 
    -0.07689215f, -0.00091257f, -0.01859704f, 0.15075675f, 0.29150051f, -0.15391402f, 0.09060632f, 0.08428295f, 
    0.03975296f, 0.17016870f, 0.03969373f, 0.09658478f, -0.07672429f, 0.03510910f, 0.21728130f, 0.00978779f, 
    0.00721983f, -0.01488816f, 0.15217252f, 0.20521973f, -0.04779628f, 0.20120335f, 0.18095005f, 0.05611769f, 
    -0.15844770f, 0.12618864f, 0.16146842f, 0.10600679f, 0.04438528f, 0.27842399f, 0.10632364f, 0.00542571f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.12406905f, -0.03312429f, -0.08035892f, -0.12857476f, 0.01652628f, -0.02291925f, -0.11936031f, -0.05497232f, 
    0.05716212f, -0.01842565f, -0.03972640f, 0.10321043f, -0.05627175f, 0.08868689f, -0.05415335f, 0.07236600f, 
    -0.03836471f, -0.00136946f, 0.11322971f, 0.11271035f, -0.01284395f, -0.07347941f, -0.10934451f, -0.08413103f, 
    0.02195378f, 0.08025862f, -0.11961505f, -0.08981209f, -0.11317485f, 0.00133090f, -0.06198524f, -0.10334077f, 
    0.09717253f, -0.01930360f, 0.00364421f, 0.01304057f, -0.06704124f, -0.05597587f, -0.04043524f, 0.01449095f, 
    -0.04565188f, -0.09795006f, 0.05372297f, 0.06041018f, -0.13356756f, -0.00643898f, -0.09806241f, 0.06725162f, 
    -0.06631021f, 0.10886697f, -0.03780998f, -0.06525791f, -0.04311846f, 0.08270562f, 0.03480048f, -0.10189913f, 
    -0.03429304f, 0.05912501f, -0.09463127f, 0.05827023f, 0.05542191f, 0.03113714f, -0.10509106f, 0.06322300f, 
    0.00670145f, 0.11254160f, 0.12652394f, 0.05610445f, -0.18189572f, 0.18712379f, 0.10179190f, -0.01461987f, 
    0.30058551f, 0.23382530f, -0.40331700f, -0.42205870f, 0.00876784f, -0.06691285f, 0.26267898f, 0.22950226f, 
    0.08012426f, -0.25849524f, -0.11847765f, -0.07004088f, 0.01484455f, 0.35014027f, 0.07861371f, -0.17853469f, 
    0.25616127f, -0.01342054f, -0.38003701f, -0.01522586f, -0.05389919f, -0.24802253f, -0.25926080f, -0.02933677f, 
    0.16434772f, 0.35609251f, 0.00748244f, 0.66621488f, 0.28598088f, -0.04816449f, -0.02054834f, 0.16347405f, 
    -0.17530984f, 0.31301942f, 0.22877012f, 0.17924207f, -0.12227190f, 0.06898076f, 0.27016029f, -0.27568617f, 
    0.18229283f, -0.23966205f, 0.13554895f, 0.07731762f, 0.17689461f, 0.10633439f, -0.02592714f, 0.24720423f, 
    -0.14019987f, 0.17956761f, -0.16081400f, 0.00792079f, -0.27737662f, 0.18643658f, 0.05695135f, -0.01659963f, 
    0.11225004f, -0.04933599f, 0.02554848f, -0.04014680f, -0.10163045f, 0.07273631f, 0.06127496f, -0.01847950f, 
    0.10353453f, -0.10769104f, -0.02159975f, 0.03093028f, 0.07882130f, 0.00068526f, -0.10276713f, -0.03822908f, 
    -0.01725098f, -0.02527823f, -0.12028105f, -0.05893915f, 0.01219275f, -0.01317484f, 0.07346693f, -0.12202413f, 
    -0.13258368f, -0.10169087f, 0.07773511f, 0.05953949f, -0.08682779f, 0.08527241f, -0.16070299f, -0.03454598f, 
    0.01956974f, 0.12629895f, 0.00740637f, -0.02222682f, 0.00466738f, 0.04691641f, -0.04661790f, -0.08598915f, 
    0.13812485f, -0.07977308f, 0.05495201f, -0.02047744f, -0.02953653f, 0.03037728f, -0.11584463f, 0.07825687f, 
    0.00603083f, -0.11351255f, 0.02599063f, -0.00127921f, 0.12052965f, 0.01685577f, -0.12614080f, -0.13134281f, 
    0.07197726f, 0.05490366f, 0.05862904f, 0.02306744f, -0.12626778f, -0.07367533f, -0.01506327f, -0.02516726f, 
    0.09403667f, -0.08169104f, -0.03140100f, 0.33393532f, 0.21939977f, -0.03633602f, -0.03636520f, 0.09030610f, 
    -0.05329712f, 0.02555791f, -0.12468015f, -0.19989003f, -0.09691543f, 0.07134391f, -0.15882090f, 0.11536275f, 
    0.22919032f, -0.11688927f, 0.32736421f, -0.02842987f, -0.23601098f, 0.07755943f, 0.24841602f, 0.15969688f, 
    -0.09156325f, -0.15693079f, 0.37627712f, 0.24727456f, 0.14066155f, 0.04853821f, -0.00092773f, 0.14661193f, 
    0.35930464f, 0.11761281f, 0.01741483f, -0.18326209f, 0.07634450f, -0.08390282f, 0.35673967f, 0.05015860f, 
    0.02919802f, 0.07782253f, 0.41946518f, 0.11022165f, 0.39885283f, 0.33940834f, -0.18411702f, 0.24571630f, 
    0.29388049f, 0.11171280f, 0.10161013f, -0.22537181f, 0.23585105f, -0.19928451f, 0.18858753f, 0.06868514f, 
    0.13318713f, 0.24408372f, 0.14537771f, -0.23637603f, 0.16307805f, -0.02379814f, -0.07701328f, -0.04361029f, 
    0.01865207f, 0.20393136f, 0.20834355f, 0.03717250f, 0.37835002f, 0.22216858f, 0.00018460f, -0.11362036f, 
    0.21312647f, 0.30447733f, -0.34528503f, -0.15030946f, 0.01696602f, -0.40473586f, -0.16232879f, 0.27607661f, 
    0.13180000f, -0.28341985f, 0.17646971f, -0.24501348f, 0.12777856f, 0.10263353f, 0.16562058f, -0.09476185f, 
    -0.01456759f, -0.06591638f, 0.33157620f, -0.20249934f, 0.40134633f, 0.27206010f, 0.19859147f, -0.04729350f, 
    0.32736397f, -0.12996925f, -0.03929567f, -0.88686413f, 0.22421533f, -0.08659659f, -0.48695558f, 0.15256956f, 
    0.05817781f, -0.10488448f, 0.03291921f, 0.23905702f, 0.05798081f, -0.00470347f, -0.18496183f, 0.17496406f, 
    0.25096545f, 0.24470459f, 0.15217897f, 0.15992606f, -0.22716944f, -0.02902398f, 0.24358356f, -0.02880281f, 
    0.06199348f, -0.21132018f, 0.01650237f, -0.61934006f, 0.39254823f, -0.13916552f, 0.05104477f, -0.02342593f, 
    -0.09552320f, -0.17064995f, 0.22674426f, -0.13144019f, -0.08937752f, 0.18510284f, -0.01440997f, 0.04487430f, 
    -0.17058045f, -0.08866247f, 0.02270260f, 0.34062520f, 0.02870794f, 0.02357451f, 0.12424195f, -0.06046150f, 
    -0.02328715f, 0.27882040f, 0.48905793f, 0.07899670f, -0.11497207f, 0.09468497f, 0.13740809f, 0.49011409f, 
    0.00077284f, 0.06668539f, -0.13101137f, 0.19854729f, -0.02007623f, 0.20434123f, -0.08623659f, 0.37076464f, 
    -0.10081112f, 0.08997269f, 0.07032564f, -0.09467869f, -0.07304645f, -0.12892212f, 0.57274973f, -0.05700888f, 
    -0.07473645f, 0.21582152f, 0.27036881f, 0.14008991f, 0.38940278f, -0.12048565f, 0.18119563f, 0.39332157f, 
    -0.11501722f, 0.20612232f, -0.17027712f, -0.18797919f, -0.04556371f, -0.15315256f, 0.22864345f, 0.20297521f, 
    0.02885003f, 0.24746786f, 0.15703779f, 0.40964612f, 0.14005253f, -0.05560064f, 0.17325898f, 0.09639194f, 
    -0.04202461f, -0.26233333f, 0.11657588f, 0.07722479f, -0.01314547f, 0.10635873f, -0.07062792f, 0.09017600f, 
    -0.33662823f, 0.05892191f, 0.18543886f, -0.04079118f, -0.12514861f, 0.29216126f, -0.13661714f, 0.05772623f, 
    0.01759946f, 0.24189150f, 0.46773750f, 0.12101173f, 0.17863104f, 0.11014602f, 0.11173489f, 0.08137832f, 
    0.04102826f, 0.06813214f, 0.27295095f, 0.50352353f, 0.11217441f, -0.01817849f, -0.17796881f, 0.39821512f, 
    0.18733364f, -0.14583120f, -0.08311971f, 0.32617128f, -0.14448634f, 0.07816518f, 0.57872140f, 0.10461978f, 
    0.39835677f, 0.15686189f, 0.41833821f, -0.11827404f, 0.18276756f, 0.44417107f, -0.26845142f, 0.56489676f, 
    0.12373822f, -0.03905093f, -0.06744314f, -0.15652852f, -0.00266191f, -0.22513421f, -0.03753556f, 0.00785955f, 
    0.05597690f, -0.06005828f, 0.21265252f, 0.67863011f, 0.25977099f, 0.05182203f, 0.02595444f, -0.04212483f, 
    -0.09742350f, -0.15338877f, -0.09063599f, 0.23253974f, 0.00766703f, -0.30224991f, 0.06451806f, 0.00902497f, 
    0.05171449f, -0.14744329f, -0.03305640f, 0.29060575f, -0.12019964f, -0.17291027f, 0.07478747f, -0.09712054f, 
    0.09380325f, -0.00038700f, 0.19133666f, -0.09951942f, -0.30192396f, 0.01048821f, -0.04033925f, 0.18664221f, 
    0.28728989f, -0.14688626f, -0.14653270f, 0.22198503f, -0.03381120f, -0.32463953f, 0.07588733f, -0.03502706f, 
    0.13213706f, 0.47555128f, 0.06365432f, 0.29647365f, 0.14620656f, -0.01121583f, 0.76060474f, 0.00854292f, 
    -0.22261724f, -0.02492676f, 0.26501772f, 0.07363848f, -0.04416775f, -0.03368140f, 0.00232703f, -0.24403688f, 
    0.04028377f, -0.20202316f, 0.18127805f, 0.11311945f, 0.30472884f, -0.03382070f, 0.17342860f, 0.30701512f, 
    -0.00426660f, 0.32271141f, -0.08440927f, 0.07378689f, -0.33022290f, 0.33832547f, 0.11573762f, 0.04248083f, 
    0.06088430f, -0.25436932f, 0.08782198f, 0.45424929f, -0.19929597f, 0.14812472f, -0.11613515f, -0.05528510f, 
    -0.13510528f, 0.09209292f, -0.32170865f, -0.40308562f, 0.09139305f, 0.16445655f, 0.14351048f, 0.01208363f, 
    0.17503475f, -0.12782323f, 0.42673895f, -0.01683015f, 0.23364706f, 0.11740331f, 0.19814773f, -0.10769343f, 
    0.07451771f, -0.01720690f, 0.18420731f, 0.53852355f, 0.12010396f, -0.14861841f, 0.02256827f, 0.28546774f, 
    0.44813713f, 0.02427686f, -0.06117722f, 0.60643554f, -0.07240467f, -0.13155226f, 0.54963374f, 0.27833366f, 
    0.37333792f, 0.40750962f, 0.58086491f, -0.25433022f, -0.07107036f, 0.47299331f, -0.06245579f, 0.30395308f, 
    0.05863448f, -0.11751293f, 0.13344267f, -0.14606142f, 0.23366517f, -0.16980761f, -0.15119787f, 0.21607605f, 
    0.08405921f, 0.27584508f, -0.12299721f, 0.42268762f, 0.14148302f, 0.02231591f, 0.07412452f, 0.01738873f, 
    -0.02362787f, 0.17147195f, 0.02170555f, 0.07316456f, -0.09778497f, -0.25378981f, 0.02145310f, -0.02599127f, 
    -0.02549102f, 0.20228370f, 0.31281382f, 0.41263163f, -0.02019175f, -0.25628099f, 0.01022370f, 0.00887067f, 
    -0.11696965f, 0.08005483f, 0.29467407f, 0.08149689f, -0.39323691f, 0.15017448f, -0.04743451f, 0.22397587f, 
    0.02882687f, -0.08260830f, 0.03431103f, 0.11682770f, -0.22591896f, -0.34807599f, 0.21895909f, -0.15839532f, 
    0.17612782f, 0.28306106f, -0.04791636f, -0.24711223f, -0.13580972f, 0.05088907f, 0.80253965f, -0.05861853f, 
    -0.34638059f, -0.21820721f, 0.17627306f, 0.53386885f, 0.33466685f, -0.27225140f, 0.07152437f, -0.17757009f, 
    0.18879043f, -0.09296662f, 0.04297153f, 0.02913273f, 0.17485674f, -0.04181171f, 0.17978257f, -0.04070059f, 
    -0.07437563f, 0.08177436f, 0.17499855f, 0.18899478f, 0.04142345f, 0.27469817f, 0.31120661f, 0.00934499f, 
    -0.00876650f, 0.11445543f, 0.09525459f, 0.16643210f, -0.12871231f, 0.37940046f, 0.01310281f, -0.05737424f, 
    -0.09803949f, -0.16074945f, 0.02917303f, 0.18422577f, -0.00725019f, 0.22148176f, 0.20199856f, 0.11848019f, 
    -0.15054490f, -0.04654047f, -0.25924277f, 0.07174437f, 0.06978201f, -0.26566607f, -0.13304073f, -0.09232394f, 
    0.15328208f, -0.06253078f, -0.04956616f, 0.07109126f, 0.22067633f, 0.16654344f, 0.33649218f, 0.23772165f, 
    -0.05037354f, -0.16657594f, -0.04545211f, 0.03314088f, -0.04109581f, -0.05215091f, -0.59920382f, 0.16397996f, 
    -0.55727124f, 0.48509359f, -0.06846701f, -0.18565555f, -0.14566773f, 0.21014768f, 0.21674681f, 0.03392529f, 
    -0.09449682f, 0.02961355f, 0.27280235f, 0.03459294f, 0.04525822f, 0.25987887f, -0.14111315f, 0.20191638f, 
    -0.06676501f, 0.18574746f, 0.01253053f, -0.24953872f, -0.18100131f, 0.03033221f, 0.16729991f, 0.14908792f, 
    0.01474749f, 0.19445471f, -0.02885686f, 0.22816700f, 0.11338832f, 0.02099459f, -0.04721534f, 0.01051233f, 
    0.28536832f, 0.26589561f, -0.07211861f, -0.05629791f, 0.07680400f, 0.09920435f, -0.02613589f, 0.23431379f, 
    0.17542100f, -0.35200477f, -0.16987616f, -0.09617797f, 0.10781091f, 0.01156242f, -0.01820774f, -0.08524031f, 
    0.26812750f, -0.12413892f, -0.14524436f, -0.23234019f, 0.27989393f, -0.02577101f, 0.29033053f, -0.23457246f, 
    0.10820737f, 0.02739048f, 0.02005961f, -0.30121094f, 0.30769250f, 0.13774416f, -0.32295212f, 0.21003975f, 
    -0.11338604f, 0.31032324f, 0.03083610f, 0.12787130f, -0.17639372f, 0.14381154f, 0.22730795f, -0.28514498f, 
    0.13318491f, 0.03386268f, 0.22066255f, 0.26078832f, -0.02397731f, 0.34576127f, -0.02594990f, 0.16376533f, 
    0.10299870f, 0.34744999f, -0.15745227f, -0.81332499f, -0.23714334f, 0.01253066f, -0.02659199f, -0.11330924f, 
    0.05852544f, -0.06390478f, -0.02123643f, 0.00956927f, 0.18886198f, -0.18997237f, -0.01696287f, 0.15990934f, 
    0.15856962f, 0.25217193f, 0.21227613f, -0.07433591f, -0.06741958f, 0.33601490f, -0.11943135f, 0.13022712f, 
    0.10294729f, 0.26642191f, 0.05103669f, 0.16959341f, 0.27552411f, 0.28603402f, 0.53998506f, 0.35950378f, 
    -0.25617698f, 0.12426722f, 0.33355871f, -0.17548613f, -0.06376862f, 0.38922346f, -0.30834538f, -0.00998446f, 
    -0.08638684f, -0.09101786f, 0.00815125f, -0.02394999f, -0.02889792f, 0.06469414f, 0.08119383f, 0.07559539f, 
    0.63836735f, -0.26763427f, -0.06109974f, -0.01167652f, 0.23978752f, -0.24311261f, -0.07946862f, 0.05735167f, 
    0.37085846f, 0.40944555f, -0.16812484f, -0.14535953f, -0.40331724f, -0.13912548f, 0.06139111f, -0.20801230f, 
    0.08642111f, -0.09401461f, 0.11307522f, 0.18114814f, 0.46712527f, -0.21687551f, -0.17319630f, 0.08237424f, 
    0.02744141f, -0.07603282f, -0.04840695f, -0.04950085f, 0.02929763f, 0.07775950f, -0.09747503f, -0.00110569f, 
    0.09261704f, -0.08043285f, 0.04670890f, 0.01093449f, -0.07012106f, 0.06915454f, -0.11879941f, 0.05339452f, 
    -0.09594660f, -0.05739644f, 0.01963440f, -0.05698849f, -0.07318532f, -0.09319722f, -0.02564238f, 0.05358073f, 
    -0.05049544f, -0.06004671f, -0.04484630f, 0.00361107f, -0.03178379f, 0.03567584f, -0.10424935f, -0.04876696f, 
    0.09955128f, -0.13129939f, -0.02212647f, 0.03800895f, -0.12940001f, -0.00818250f, 0.06312655f, -0.06207696f, 
    0.02899918f, -0.06208602f, -0.08792780f, -0.00240867f, -0.10640366f, 0.09143569f, 0.07614397f, 0.10461040f, 
    0.05461525f, 0.12117158f, -0.09283370f, -0.05826559f, 0.01275753f, -0.06027937f, 0.04436808f, 0.05376350f, 
    0.03511885f, -0.11607562f, -0.09175805f, -0.08758813f, 0.06505413f, -0.05541300f, -0.02352856f, 0.05902200f, 
    -0.07055752f, -0.04825731f, -0.04850755f, -0.01150811f, 0.08599121f, -0.03106483f, 0.06823196f, 0.04591053f, 
    -0.15236376f, -0.05167800f, 0.07659729f, -0.00205087f, 0.01776297f, -0.11835054f, 0.07016577f, -0.04572428f, 
    -0.01819794f, -0.01719491f, -0.03269885f, -0.15645686f, -0.19296832f, -0.06810211f, -0.05438968f, -0.02898007f, 
    -0.12379521f, -0.12213529f, -0.05872079f, -0.05294077f, -0.11313287f, 0.01718135f, 0.05117493f, -0.13127986f, 
    0.00981333f, 0.02063936f, -0.07738703f, -0.06525575f, -0.01252392f, 0.12314558f, -0.08900620f, -0.07338524f, 
    -0.09486229f, -0.17389667f, -0.06672157f, -0.03253696f, 0.08515574f, -0.05888040f, 0.05620006f, 0.02103881f, 
    -0.06425384f, 0.09211076f, -0.10723133f, 0.00221649f, 0.09286921f, 0.00512511f, 0.01923597f, -0.10234955f, 
    -0.04195562f, -0.05512136f, -0.02737618f, 0.03386871f, -0.12745640f, 0.10384227f, 0.08322500f, -0.12567241f, 
    -0.03516659f, 0.06872006f, 0.14335160f, -0.21994820f, -0.06505787f, -0.02595331f, 0.05620049f, -0.17733242f, 
    -0.06451254f, -0.17628500f, 0.42997026f, 0.46579042f, -0.00872345f, -0.05847542f, 0.09206995f, -0.17023711f, 
    -0.29361972f, 0.23088010f, -0.04408431f, 0.19375382f, -0.10824555f, -0.30289257f, -0.14842378f, 0.07503200f, 
    0.07059292f, -0.09210452f, 0.25153488f, 0.21885274f, -0.00835410f, -0.18344852f, 0.28457761f, -0.04114329f, 
    -0.01228504f, 0.00119089f, 0.04969747f, -0.38401878f, -0.05529440f, -0.10536350f, 0.23703614f, -0.18462427f, 
    -0.42571184f, -0.23209408f, -0.12262073f, 0.15078174f, 0.06678592f, -0.03793443f, -0.08387679f, 0.07723869f, 
    0.03125758f, -0.18022896f, 0.12507977f, 0.04519898f, 0.09630192f, -0.01508238f, 0.08043224f, -0.02624155f, 
    0.00605744f, -0.21613386f, 0.24732928f, 0.24106291f, -0.09757878f, 0.06313267f, 0.27783337f, 0.01863270f, 
    0.03621365f, 0.14539681f, 0.17509259f, -0.48272085f, 0.04711295f, -0.16105908f, 0.11902415f, 0.02283934f, 
    -0.17963161f, -0.05726761f, -0.06951734f, 0.35712790f, 0.09129249f, -0.21208486f, 0.32708126f, 0.00012107f, 
    -0.04970023f, 0.10645905f, 0.25703353f, -0.19947934f, -0.19725491f, 0.02602946f, -0.14242910f, -0.00745686f, 
    0.15756436f, -0.01278505f, -0.01067791f, -0.06680582f, 0.01832961f, 0.14497486f, -0.11288545f, 0.04207283f, 
    -0.16490324f, 0.10818753f, -0.07566153f, -0.22149387f, 0.09599748f, -0.02946834f, -0.10872564f, -0.14399435f, 
    -0.04713786f, 0.02535068f, 0.30437097f, 0.21406116f, 0.00279322f, -0.19339299f, -0.12474441f, 0.15335609f, 
    -0.16380055f, -0.19700536f, -0.00542059f, 0.24009387f, -0.14041862f, -0.03858074f, 0.32057577f, -0.26036459f, 
    -0.09181632f, -0.31606877f, 0.30403081f, 0.06038071f, 0.11451628f, 0.19210124f, 0.35304788f, 0.06510503f, 
    0.10475577f, 0.10324839f, 0.05359780f, -0.02748832f, -0.06648664f, -0.14140247f, 0.06351256f, -0.04673440f, 
    -0.07481673f, 0.04115325f, -0.07176938f, -0.03458498f, -0.09859681f, 0.11335650f, 0.08607977f, -0.06970412f, 
    -0.08437130f, -0.08441134f, 0.04977328f, 0.05620336f, 0.08803296f, -0.03258796f, 0.07814349f, 0.05221564f, 
    0.03095579f, 0.01920130f, 0.01169568f, -0.06539902f, 0.07214005f, -0.13284837f, -0.09775842f, -0.06997312f, 
    -0.05673615f, 0.01373166f, -0.09415933f, -0.11751881f, -0.09974479f, -0.02631435f, -0.02268775f, 0.08152732f, 
    -0.05154438f, -0.11155225f, 0.01662008f, 0.05229356f, -0.14614692f, -0.02883725f, -0.04390284f, 0.04900399f, 
    -0.06674908f, 0.10691758f, -0.06794394f, 0.03479482f, -0.05052245f, -0.05461694f, -0.05456299f, -0.09452175f, 
    -0.00970505f, 0.08948934f, -0.11093029f, -0.11919703f, -0.01744262f, 0.00673189f, -0.10657068f, 0.12244958f, 
    -0.04935773f, 0.17883198f, 0.33524618f, -0.27136505f, -0.18309370f, 0.69505382f, -0.08191771f, -0.14464709f, 
    0.15991579f, 0.04126814f, -0.11352427f, -0.18618421f, -0.03992791f, -0.08312491f, 0.34924635f, 0.16468287f, 
    0.13312936f, -0.27849790f, -0.00932066f, -0.35224405f, 0.09737000f, 0.16044523f, -0.01960029f, -0.15646347f, 
    -0.00648316f, -0.09656633f, -0.10488171f, 0.20230290f, 0.18228017f, -0.00300006f, -0.10324186f, 0.20081510f, 
    0.17449299f, -0.23712713f, -0.12688424f, 0.46553317f, 0.13542670f, 0.10588030f, -0.37688774f, 0.07041015f, 
    -0.15479998f, 0.44073209f, 0.09896508f, 0.07618445f, -0.22779529f, 0.15072502f, 0.37456584f, 0.24362308f, 
    -0.03674542f, -0.14647067f, 0.05631713f, 0.16793191f, 0.24698694f, 0.09080697f, -0.01483922f, 0.14710522f, 
    0.02037219f, -0.01561620f, -0.05127240f, -0.12918092f, -0.15629789f, 0.26603177f, 0.32795727f, 0.05836035f, 
    -0.11652607f, 0.04436228f, -0.01422312f, 0.28403816f, 0.17777188f, 0.20493264f, -0.01762526f, 0.10820299f, 
    -0.08941901f, 0.24026833f, 0.01404550f, -0.09549720f, 0.11400225f, 0.26636687f, -0.04637188f, 0.15054114f, 
    0.09387348f, -0.13896926f, 0.21199803f, -0.02050984f, 0.33527485f, 0.12360551f, 0.19208796f, -0.03538645f, 
    -0.09016799f, -0.09355219f, 0.34267586f, 0.19048518f, 0.26328275f, 0.47154480f, 0.10648438f, 0.04589979f, 
    0.24057131f, -0.24595274f, -0.09671661f, -0.32078573f, 0.21330522f, -0.11123843f, -0.40161183f, 0.15510412f, 
    0.45891836f, 0.12804696f, 0.23719619f, -0.30803534f, 0.00339952f, 0.28220347f, -0.26606879f, 0.28458372f, 
    0.04862140f, 0.04468051f, 0.13907623f, -0.01116176f, -0.42912537f, 0.03954288f, -0.00912555f, -0.03068128f, 
    0.00873816f, -0.16735779f, 0.12827395f, -0.09555966f, 0.52066040f, -0.23317780f, 0.12320186f, -0.03632343f, 
    -0.08258972f, 0.06636191f, -0.10267449f, -0.11219361f, 0.19053020f, -0.55734539f, 0.03162347f, 0.16776836f, 
    -0.69799048f, -0.19336204f, 0.24887997f, 0.70298618f, 0.07261667f, 0.23485684f, 0.12428401f, -0.12663774f, 
    -0.10086958f, 0.41130814f, 0.00324244f, 0.17552084f, 0.04139170f, -0.35757878f, -0.28168458f, -0.03930283f, 
    0.04720794f, 0.09653391f, 0.09832756f, 0.03245560f, -0.08962190f, 0.20440893f, 0.31918293f, 0.30039018f, 
    -0.29874507f, 0.03298486f, 0.07888683f, 0.17229716f, 0.10357692f, -0.02244948f, -0.15774389f, -0.39269251f, 
    -0.20083688f, 0.03120484f, 0.00643549f, -0.10588638f, 0.04638691f, -0.09423517f, 0.01502994f, 0.15435779f, 
    -0.38272908f, -0.50679183f, 0.18971622f, -0.01293956f, -0.11436414f, 0.26495895f, 0.30201939f, -0.19480686f, 
    -0.06734054f, 0.16051130f, 0.24339847f, 0.28500581f, 0.16790818f, 0.11879960f, 0.19203891f, -0.18792114f, 
    -0.10555885f, -0.14344229f, 0.06773487f, 0.00106554f, -0.06958994f, -0.03677124f, -0.00218202f, 0.11299288f, 
    -0.03469447f, 0.10817149f, 0.04197782f, -0.05606018f, -0.08918218f, -0.00116058f, -0.07050067f, -0.11688925f, 
    -0.04669669f, -0.04804619f, -0.05455175f, 0.10999221f, 0.06853306f, 0.07600620f, 0.02314150f, 0.02850856f, 
    -0.03482684f, -0.12311343f, 0.02953400f, -0.00220041f, -0.03376382f, -0.11878506f, -0.10013473f, 0.11082083f, 
    -0.10704224f, -0.03642835f, -0.01220149f, 0.07314097f, 0.08640141f, 0.09536186f, -0.01171059f, -0.14037046f, 
    -0.09860562f, -0.10832927f, 0.08583336f, -0.08320136f, -0.11823969f, 0.11477585f, -0.08807307f, -0.10626604f, 
    0.07461743f, 0.10946399f, -0.11226241f, -0.01377835f, 0.06075136f, 0.00261857f, -0.04178026f, 0.00670077f, 
    0.02215290f, 0.00549033f, 0.05300102f, -0.12682441f, 0.03622831f, -0.02675575f, -0.08231300f, -0.11407545f, 
    -0.09469247f, 0.06599092f, 0.25524008f, -0.36715639f, -0.27378985f, 0.64345604f, 0.06758322f, -0.08597806f, 
    0.23017287f, -0.26246420f, -0.13925970f, -0.05905494f, 0.00265793f, -0.15440780f, 0.21247137f, -0.05943741f, 
    0.19907428f, 0.12474928f, 0.26331401f, -0.31256339f, 0.07865169f, 0.27871346f, 0.00096361f, -0.04913040f, 
    0.01410563f, -0.00419254f, -0.09028130f, 0.16247641f, 0.23802659f, -0.01474634f, -0.13516939f, 0.25874248f, 
    -0.04315944f, 0.04936203f, 0.04767419f, 0.61323720f, 0.01966451f, -0.01283441f, 0.45419577f, 0.11161362f, 
    -0.09968280f, 0.19681789f, -0.01006515f, -0.01620699f, 0.05143772f, 0.15526028f, 0.27453735f, 0.24826767f, 
    -0.11080176f, -0.03239515f, -0.01402418f, 0.16924666f, 0.26389474f, -0.10310686f, -0.00952041f, 0.23499767f, 
    0.02588362f, -0.28895584f, 0.27648672f, 0.52493095f, -0.19188879f, 0.22559753f, 0.30274248f, 0.09108219f, 
    -0.10047676f, 0.22338897f, 0.13718443f, -0.37874660f, 0.12409952f, -0.06129856f, 0.07819417f, 0.25231361f, 
    -0.14671662f, -0.19789501f, -0.01215943f, 0.37057272f, -0.05207415f, -0.10573220f, 0.39882737f, 0.05103644f, 
    0.05872037f, 0.23586908f, -0.29258829f, 0.03799968f, 0.21503216f, 0.07442287f, -0.32628408f, 0.04417290f, 
    0.17041646f, 0.32562724f, -0.22271082f, -0.23683153f, -0.03071208f, 0.08647934f, 0.09253319f, 0.01933729f, 
    -0.39251700f, 0.25846249f, 0.11010604f, 0.32610396f, 0.12522686f, -0.08298817f, -0.04335136f, -0.35447866f, 
    -0.13340896f, 0.02605108f, -0.26801389f, 0.04202666f, -0.26280755f, -0.08764873f, 0.43951437f, -0.14671348f, 
    -0.31124833f, 0.07826038f, 0.15076961f, 0.20766710f, -0.13899979f, 0.44599253f, 0.10491633f, 0.10079372f, 
    -0.04313448f, -0.01848770f, 0.09651924f, 0.28859720f, -0.20089582f, 0.19865488f, 0.18847311f, 0.00175368f, 
    0.02721586f, 0.19399647f, 0.08789507f, -0.26753995f, -0.11077416f, 0.00787297f, 0.10234676f, 0.02602453f, 
    0.01365462f, 0.13749011f, 0.29339984f, 0.22967611f, -0.10647926f, 0.21772745f, 0.18652713f, 0.12353993f, 
    -0.09896299f, 0.12325036f, -0.01206647f, 0.28385958f, -0.24910411f, 0.18640032f, 0.32047865f, 0.18012762f, 
    0.04995103f, -0.04887616f, 0.02176194f, -0.22043455f, -0.38644925f, 0.28998691f, -0.07698026f, 0.00716856f, 
    -0.00322683f, 0.19609992f, 0.06601428f, -0.30628160f, 0.08685984f, -0.06311642f, -0.04263683f, -0.02407799f, 
    0.00546898f, -0.11405002f, 0.24359834f, 0.49596155f, 0.20768675f, -0.47495458f, 0.08284079f, -0.06386703f, 
    -0.03428736f, -0.16215950f, -0.17083985f, 0.15401205f, -0.27196440f, 0.04376998f, 0.10192426f, -0.18687065f, 
    0.11891386f, 0.33480588f, 0.09726603f, -0.30958679f, 0.26584977f, -0.01397186f, -0.04374898f, 0.05572093f, 
    -0.07775886f, 0.06237474f, 0.08286308f, -0.05427657f, -0.02254686f, -0.03196007f, 0.02840324f, 0.05074943f, 
    -0.10678452f, -0.13771774f, 0.01867998f, -0.13627923f, -0.09458648f, -0.12768243f, -0.00430324f, -0.11941716f, 
    -0.05247906f, 0.04794615f, -0.10945812f, 0.02952458f, 0.01950988f, 0.00238388f, -0.10953567f, 0.06474625f, 
    -0.05424468f, -0.03427647f, -0.09944466f, -0.00798214f, -0.03976915f, 0.07063094f, 0.02694237f, -0.06430916f, 
    0.04682947f, -0.08376545f, 0.06359360f, -0.12042761f, -0.10960133f, 0.11340089f, -0.08936546f, -0.02978845f, 
    0.00016883f, 0.05571999f, 0.04196168f, -0.10191543f, 0.07633164f, -0.01064730f, 0.07977245f, 0.02281218f, 
    -0.02165319f, -0.08470906f, -0.01167281f, 0.08512069f, -0.02430294f, -0.07091153f, -0.11698881f, 0.04139075f, 
    -0.08979084f, 0.07412192f, 0.06670788f, -0.09138597f, -0.00957585f, -0.06698284f, -0.13038209f, 0.09763739f, 
    -0.11127354f, 0.12949783f, -0.17491105f, 0.02844441f, 0.29694423f, -0.25030112f, -0.05824639f, 0.21767922f, 
    -0.19910689f, 0.32464775f, 0.16225284f, 0.31871691f, -0.00619340f, 0.29908818f, 0.10397683f, 0.04860207f, 
    0.04999631f, -0.15620491f, -0.11159743f, 0.29785454f, 0.22586045f, -0.28122094f, -0.14504448f, -0.22763751f, 
    0.25620204f, 0.02880739f, 0.22279471f, -0.20891942f, 0.18228716f, 0.08168051f, 0.63511086f, -0.08702438f, 
    0.07726862f, 0.02635462f, -0.02464085f, -0.19135921f, 0.28414151f, -0.09490386f, -0.05590268f, 0.07549009f, 
    -0.14679007f, 0.12098069f, 0.06834403f, -0.09532492f, -0.08953298f, 0.23001501f, -0.15122642f, 0.05304516f, 
    -0.00703531f, -0.28539068f, 0.42416543f, 0.17640212f, -0.06134314f, 0.46693119f, 0.12559247f, -0.13962735f, 
    0.04260293f, 0.36023352f, -0.04581784f, -0.27721348f, 0.08248909f, 0.05701668f, -0.01688490f, -0.08396707f, 
    -0.00782096f, -0.08304924f, 0.21058300f, -0.27914825f, 0.21776751f, -0.04203368f, -0.08613430f, 0.24056894f, 
    -0.31731018f, -0.03789022f, -0.28985503f, -0.05767398f, 0.02046546f, -0.21626695f, 0.18191786f, 0.11424389f, 
    -0.01020689f, -0.14018054f, 0.37321311f, -0.13353971f, -0.06391142f, 0.12246849f, -0.03849803f, -0.35156545f, 
    0.20001984f, -0.14640063f, 0.10204238f, 0.04252363f, 0.05206184f, 0.17660919f, -0.34311372f, 0.24507760f, 
    0.23932913f, -0.06407958f, 0.05320271f, 0.24468553f, 0.16741318f, 0.01649839f, -0.12577373f, -0.15704843f, 
    -0.08851337f, 0.28230438f, 0.58142602f, 0.19469406f, -0.10345839f, 0.12452547f, -0.19897413f, 0.39836070f, 
    -0.19924691f, -0.09184916f, 0.12793171f, -0.13515003f, 0.09999812f, 0.01732461f, 0.25963864f, -0.22776635f, 
    -0.09627871f, -0.32354352f, -0.00047276f, -0.21026389f, -0.00130237f, 0.18821304f, 0.00213192f, 0.07664987f, 
    -0.03225695f, 0.30864617f, -0.16973387f, -0.34039024f, -0.09037247f, 0.08129926f, 0.07715219f, -0.24551858f, 
    0.28208223f, 0.09855320f, 0.42484581f, 0.24644086f, -0.07050974f, 0.26464954f, -0.05755326f, 0.18146251f, 
    -0.25013682f, -0.04818257f, -0.18870769f, 0.08840740f, 0.03066778f, -0.23940325f, 0.03801535f, 0.13267910f, 
    -0.04875042f, -0.17585343f, 0.09683996f, -0.30217847f, 0.15057956f, -0.06299237f, 0.46751758f, -0.15148284f, 
    0.17717476f, -0.14207123f, -0.01045798f, -0.55426061f, 0.06996547f, 0.06802105f, 0.10861079f, 0.06132980f, 
    -0.52841347f, 0.07075084f, -0.27011555f, 0.06821980f, 0.19597924f, -0.05733255f, -0.11757889f, -0.22474831f, 
    0.36178875f, -0.37563068f, 0.22093025f, 0.23402886f, 0.07636201f, 0.16989644f, 0.01153215f, 0.00031525f, 
    0.09392471f, 0.48031798f, -0.07877782f, -0.32193410f, -0.05013011f, 0.02362838f, 0.07819038f, -0.06613246f, 
    0.06294413f, 0.16209354f, -0.01493989f, -0.05065579f, -0.21191368f, 0.01171716f, 0.11111931f, 0.05774217f, 
    -0.16890298f, 0.16793850f, 0.27546987f, -0.05157184f, -0.06793936f, 0.50529528f, 0.03272394f, 0.11340421f, 
    -0.03795941f, 0.18019703f, -0.17827214f, 0.37317911f, 0.29911235f, 0.09216934f, 0.33973119f, 0.00089365f, 
    0.16083048f, 0.34247786f, -0.21634665f, -0.23993582f, -0.27900299f, 0.09205003f, -0.19945601f, 0.12024555f, 
    -0.04492508f, 0.23481092f, -0.05782726f, 0.45542079f, 0.21115376f, -0.00805424f, -0.28501838f, -0.04973023f, 
    -0.08197188f, 0.00038338f, -0.10018067f, 0.13478275f, -0.01301766f, -0.41499197f, 0.43150419f, 0.00129914f, 
    -0.08949490f, -0.16060910f, -0.04608794f, 0.01955347f, -0.00847648f, 0.24293438f, 0.00880607f, -0.02116425f, 
    0.02756796f, 0.44608980f, -0.00039433f, 0.01954794f, -0.06238056f, 0.17195712f, -0.22189480f, -0.04199738f, 
    0.04665937f, 0.03343886f, -0.20582639f, -0.25534269f, -0.04372155f, -0.46581641f, -0.00501913f, 0.04283193f, 
    -0.21102875f, 0.28523675f, 0.55235922f, -0.14186545f, -0.08953638f, 0.29262006f, 0.07336447f, 0.18033572f, 
    -0.14939691f, 0.09349134f, -0.15849653f, 0.41873294f, 0.40538171f, -0.01921873f, 0.11879875f, -0.08307442f, 
    0.21920122f, 0.22039935f, 0.33659613f, 0.07118096f, -0.15117756f, -0.09053633f, 0.12583418f, -0.20803334f, 
    0.00548792f, -0.24727710f, -0.05108447f, 0.11716747f, 0.13939780f, -0.00360748f, 0.02854761f, 0.14788817f, 
    0.00681409f, -0.17350285f, -0.02833729f, 0.09547780f, -0.03208087f, 0.13026839f, -0.15517041f, -0.01077165f, 
    0.03531680f, -0.03978745f, 0.25156981f, 0.02279782f, 0.03968754f, 0.06718185f, -0.11988903f, -0.24407902f, 
    0.02858297f, -0.14271863f, 0.04643170f, 0.14788595f, 0.12641181f, 0.04203599f, -0.19875573f, -0.09206718f, 
    -0.01072983f, 0.11063399f, -0.01300636f, -0.05361230f, 0.04526930f, -0.22884355f, -0.05209881f, 0.32667673f, 
    -0.07458545f, -0.35696685f, 0.00445862f, 0.49712744f, 0.10676900f, 0.09565743f, 0.06418858f, -0.09767015f, 
    0.04073545f, 0.57929409f, 0.16783924f, 0.02678965f, 0.11089928f, 0.09124254f, -0.11897342f, 0.39901784f, 
    0.01602379f, 0.32191947f, -0.14028084f, 0.25352991f, -0.06557066f, 0.06431097f, 0.03964942f, 0.24624132f, 
    -0.17466772f, 0.25319645f, -0.05531314f, 0.55269605f, -0.03083869f, -0.05677599f, 0.43273434f, -0.33342075f, 
    -0.27268654f, -0.15952756f, 0.02456157f, 0.10030271f, 0.19102424f, 0.04972128f, 0.11452442f, 0.16683976f, 
    -0.20962647f, 0.13436756f, -0.11430345f, -0.11682602f, -0.14345619f, 0.17293434f, 0.10941733f, 0.29668257f, 
    -0.02768849f, -0.14494886f, 0.20766416f, 0.63374275f, -0.02940143f, 0.14904739f, 0.09534211f, 0.05599016f, 
    0.00854623f, -0.10523595f, 0.08000248f, 0.03925250f, 0.07858553f, 0.00628172f, 0.11232744f, -0.00787694f, 
    0.08929974f, -0.03239745f, -0.09862610f, 0.02758871f, 0.00309828f, -0.00883862f, -0.05761910f, 0.02118241f, 
    -0.12331735f, 0.07318121f, -0.10926018f, -0.03281056f, -0.11069995f, 0.09969062f, -0.02099599f, -0.03173360f, 
    0.00124952f, -0.02570677f, 0.03276714f, -0.10895851f, -0.00387767f, -0.10725077f, -0.10960335f, -0.02130144f, 
    0.06125318f, -0.03441623f, 0.08931668f, 0.05759024f, -0.10714868f, 0.04316452f, -0.05017113f, 0.10801594f, 
    0.01276264f, -0.00521588f, -0.02066732f, 0.01136219f, 0.08143643f, -0.11761971f, -0.10613747f, -0.06256063f, 
    0.06200474f, 0.02413629f, 0.03256889f, 0.02705100f, 0.04430721f, -0.06781911f, 0.07026024f, 0.04658640f, 
    -0.07059070f, -0.00244458f, -0.12450521f, -0.05526166f, -0.06389780f, -0.06130882f, -0.01953037f, 0.08005758f, 
    -0.02746665f, 0.22015576f, 0.03016757f, -0.11043049f, 0.13725513f, 0.03171901f, 0.00809045f, 0.12342879f, 
    0.20162022f, 0.03956087f, 0.32878664f, 0.14394307f, -0.07932725f, -0.05806247f, -0.28074419f, 0.16139475f, 
    -0.10493598f, 0.32116818f, 0.13347819f, 0.27753815f, 0.09736305f, 0.22726622f, 0.32135287f, 0.43593895f, 
    -0.21984009f, 0.06629048f, 0.31763059f, -0.27061200f, -0.07274625f, 0.33940625f, -0.03308638f, -0.00042587f, 
    -0.00588463f, 0.18774171f, -0.02220331f, -0.68868977f, 0.02255618f, -0.01356614f, -0.03249448f, -0.00716196f, 
    0.27392754f, -0.34199262f, -0.35184446f, 0.24730420f, 0.53396869f, -0.46947393f, 0.06112435f, 0.10837628f, 
    0.33944222f, 0.40392366f, -0.24450794f, 0.12988850f, -0.37953758f, 0.06728430f, 0.12815411f, -0.08984338f, 
    -0.10980496f, 0.10841016f, 0.13619821f, -0.13127969f, 0.41489676f, -0.24854071f, -0.08518693f, -0.04490894f, 
    0.09729499f, 0.25833595f, 0.03499762f, -0.12539333f, -0.32386142f, 0.73541009f, 0.10421803f, -0.33773500f, 
    0.33344531f, 0.25291988f, 0.28548086f, -0.47514099f, -0.06505688f, -0.01337782f, 0.02294916f, 0.27974555f, 
    -0.34051064f, -0.47299230f, 0.07199083f, 0.12975962f, 0.18150677f, 0.12454258f, 0.03685666f, -0.09467159f, 
    0.15178792f, -0.21396931f, 0.01636599f, 0.03792927f, 0.12880176f, -0.04255321f, 0.14034472f, -0.30017835f, 
    0.33180475f, -0.46054479f, -0.02341642f, -0.03533916f, -0.05571448f, 0.01163822f, -0.45931071f, 0.27370939f, 
    0.28996214f, 0.22119996f, 0.19038072f, -0.05936291f, -0.13035123f, 0.21014303f, -0.08630957f, -0.09030316f, 
    0.22260199f, -0.05893883f, 0.00858293f, 0.22622156f, -0.05826071f, -0.19572224f, -0.46683893f, -0.06215623f, 
    -0.10041497f, -0.20373133f, -0.20232874f, 0.02187374f, 0.07617373f, 0.01012560f, 0.21345402f, 0.05744143f, 
    -0.01686022f, -0.03686193f, -0.04393275f, -0.11438850f, 0.05910876f, -0.06863002f, 0.09106615f, 0.08189857f, 
    0.07581593f, 0.10945253f, 0.04401378f, 0.01325653f, -0.09262845f, -0.09895091f, -0.06859023f, -0.08794262f, 
    -0.00549257f, 0.00666657f, 0.08027900f, -0.05692028f, -0.03226338f, 0.05301350f, -0.11362886f, -0.08676478f, 
    -0.05643998f, -0.12119760f, -0.09366806f, -0.03466810f, 0.03942744f, -0.10036482f, -0.06021063f, -0.08751098f, 
    0.04296649f, -0.10434847f, 0.07285537f, 0.03945368f, 0.02905723f, -0.10770401f, -0.01469076f, -0.02136847f, 
    -0.02141110f, -0.09071153f, 0.08288386f, 0.04232103f, -0.04792305f, 0.02775672f, -0.06501131f, 0.08231359f, 
    0.07751651f, 0.00136545f, -0.08772843f, -0.03775842f, 0.06399680f, -0.08565638f, -0.10803264f, 0.05615605f, 
    0.03610136f, -0.06682529f, 0.10906013f, -0.08402588f, -0.06498152f, -0.11594944f, 0.07667696f, -0.03098606f, 
    -0.07886150f, 0.18537153f, -0.17297238f, 0.41300556f, 0.02832290f, -0.15732378f, 0.10311686f, 0.20288400f, 
    -0.25128952f, 0.61805594f, 0.01486695f, -0.03653486f, 0.04605669f, 0.22693029f, 0.14906029f, 0.23408948f, 
    0.07315832f, 0.06441250f, 0.04551874f, 0.33283350f, 0.22665496f, 0.06554918f, 0.44746178f, 0.12487518f, 
    0.03109605f, 0.08487566f, 0.05620126f, -0.29182476f, -0.33373615f, 0.22923496f, -0.12801082f, -0.14295016f, 
    0.11770130f, 0.09964452f, 0.08039703f, -0.04895194f, 0.18097568f, 0.06322885f, -0.24972445f, 0.19761901f, 
    0.24104819f, 0.12211064f, 0.27875695f, -0.06700522f, -0.02199525f, -0.25918204f, 0.13239148f, -0.27123350f, 
    0.12665182f, -0.17799811f, 0.12326938f, 0.07390805f, -0.25256374f, 0.31069735f, -0.10517813f, -0.19217157f, 
    0.10880733f, 0.33598283f, -0.15299900f, -0.17464188f, 0.25371560f, -0.03102992f, -0.19937010f, -0.01997725f, 
    0.07521275f, -0.11234846f, -0.14239782f, 0.01234095f, -0.09264464f, 0.07643326f, -0.11733034f, -0.02371754f, 
    0.01382953f, 0.10631217f, 0.02535119f, -0.04275209f, 0.08462486f, 0.05854596f, 0.02738553f, 0.00212984f, 
    -0.02277531f, 0.01844260f, 0.03808070f, -0.02311516f, -0.07527482f, -0.01080163f, -0.05455403f, -0.05476945f, 
    0.01351834f, -0.12417326f, -0.15343894f, -0.05640379f, 0.03765034f, 0.08151050f, 0.04097076f, -0.03925757f, 
    0.07031687f, 0.07853144f, -0.11115180f, 0.08331866f, 0.04412478f, 0.07783100f, -0.08329833f, -0.06149302f, 
    -0.00105241f, -0.11583189f, -0.12512855f, 0.09231839f, 0.09211112f, -0.13096881f, -0.01478196f, 0.09140192f, 
    -0.10699459f, 0.02518457f, -0.05531674f, -0.07198400f, 0.04611731f, -0.04845371f, -0.13871457f, 0.00631300f, 
    -0.01549686f, -0.04568696f, 0.07373252f, -0.06725869f, 0.09507552f, -0.08039576f, -0.06818668f, 0.08047789f, 
    0.11878425f, 0.15113609f, 0.13682978f, -0.16965131f, -0.07110083f, 0.47667658f, 0.10863595f, -0.00580213f, 
    -0.02864799f, -0.15328313f, -0.03304653f, 0.18499726f, 0.00596587f, -0.10127793f, 0.24050340f, -0.08967644f, 
    0.06833328f, -0.05189360f, -0.06333382f, -0.10794765f, 0.20337908f, -0.16184708f, -0.33017728f, -0.50383180f, 
    0.23809098f, -0.06170959f, 0.00207161f, 0.38449860f, 0.49708399f, -0.05643117f, 0.34055835f, 0.13544314f, 
    0.22251204f, -0.31648913f, -0.05687677f, 0.36721373f, 0.14206782f, -0.16414599f, -0.19116448f, 0.10116565f, 
    -0.36481372f, 0.43196473f, 0.30628023f, -0.13263112f, -0.34506437f, 0.58815718f, 0.00555280f, 0.42173117f, 
    -0.00893359f, -0.26421130f, 0.13498320f, -0.00327614f, 0.07471073f, -0.00558553f, -0.15491699f, 0.19412956f, 
    -0.07654288f, -0.26358610f, 0.17526288f, 0.04320694f, -0.01010912f, 0.25769326f, 0.50604361f, -0.09915490f, 
    -0.01453932f, 0.05511518f, -0.10507294f, -0.01627947f, 0.10641871f, -0.33727047f, -0.07679499f, -0.00675781f, 
    -0.19701572f, 0.40150794f, -0.22279963f, -0.14788698f, 0.04097537f, 0.06718136f, 0.30376223f, 0.09751468f, 
    0.08195282f, -0.14550763f, -0.07756995f, 0.20349690f, 0.16518684f, -0.03758147f, 0.01215045f, -0.17362753f, 
    0.34218821f, 0.25069401f, -0.22781095f, -0.24181211f, -0.18446939f, -0.01082424f, -0.10536838f, 0.03193421f, 
    -0.16052519f, 0.17423496f, 0.09114703f, 0.46524492f, 0.32158816f, -0.08514167f, -0.25082311f, 0.09166875f, 
    0.13676210f, 0.15838628f, 0.16636711f, 0.13090466f, -0.25018665f, -0.07502572f, 0.24850088f, -0.33217302f, 
    -0.09261861f, -0.23238729f, 0.22892286f, 0.25394037f, 0.00912734f, 0.22023785f, -0.05649795f, 0.08713427f, 
    -0.04216684f, 0.30197558f, -0.14549354f, -0.24021269f, -0.16174211f, 0.29610085f, -0.03965336f, 0.01928161f, 
    0.02605232f, 0.20929390f, -0.21246646f, -0.04379058f, 0.40172571f, -0.47447479f, -0.11716031f, 0.31138325f, 
    0.10918476f, 0.10799196f, 0.09581018f, 0.01544351f, -0.03804169f, 0.42822647f, -0.17646942f, 0.19940707f, 
    0.07999557f, 0.18722747f, -0.36559555f, 0.31491232f, 0.23350063f, -0.22873019f, -0.08241668f, -0.33161974f, 
    0.15324956f, 0.18712062f, 0.25234357f, -0.28253043f, 0.20368694f, 0.28186595f, 0.29044643f, -0.04615826f, 
    -0.10545535f, -0.12772995f, -0.13653430f, -0.20997085f, 0.17166500f, 0.07812601f, -0.48089519f, -0.01864226f, 
    -0.09699086f, -0.06683786f, -0.21142729f, -0.24720246f, -0.17344479f, 0.15626448f, -0.04470631f, -0.10860027f, 
    0.08043783f, 0.04169471f, 0.25418317f, 0.08239529f, -0.10184801f, 0.39205223f, 0.07076219f, -0.02104506f, 
    0.10041319f, 0.16070358f, -0.10803831f, -0.36147648f, 0.10734356f, 0.00165690f, -0.30485451f, 0.04296480f, 
    -0.02073996f, 0.04999936f, 0.22332512f, -0.38237256f, -0.14704983f, -0.13359684f, -0.00492989f, 0.03553320f, 
    -0.16641784f, -0.08882856f, 0.04953548f, 0.54122055f, -0.09800684f, -0.35485172f, 0.19433624f, 0.08714848f, 
    0.01840373f, 0.01747303f, 0.01123173f, -0.12145131f, -0.22415046f, 0.13053355f, -0.15717474f, -0.10023950f, 
    0.19759038f, 0.15340714f, -0.30720994f, 0.00601850f, -0.14138699f, -0.07404417f, -0.01785707f, 0.13913783f, 
    -0.31914237f, 0.22237937f, -0.06567736f, 0.21113972f, 0.22655684f, -0.13581245f, 0.07279544f, -0.33053935f, 
    -0.28151202f, 0.03365785f, 0.17190737f, 0.36529917f, -0.06260180f, -0.32251757f, 0.22604960f, 0.02807511f, 
    -0.26253784f, -0.11956818f, 0.04326243f, 0.27006191f, 0.14529090f, 0.11994694f, 0.05448356f, 0.05934620f, 
    0.08767858f, -0.21334147f, 0.21165578f, 0.29013762f, -0.23139100f, 0.36030543f, 0.33564821f, 0.02566381f, 
    0.10129471f, -0.13455200f, 0.04448123f, 0.10673591f, -0.10453806f, -0.05767637f, 0.00552972f, -0.05996128f, 
    0.01630454f, 0.00159810f, -0.10272551f, -0.01248683f, 0.02427810f, 0.03532048f, 0.03485457f, -0.05998482f, 
    -0.09825224f, -0.06787413f, -0.05924514f, -0.03522963f, -0.00453454f, -0.07312024f, 0.06090137f, -0.03200611f, 
    -0.09619672f, -0.05626152f, 0.04379410f, 0.00239864f, -0.14031591f, 0.01601589f, -0.02772172f, 0.01137535f, 
    -0.10264199f, -0.03712337f, -0.03978412f, -0.02175155f, 0.05169517f, -0.11084352f, 0.04667673f, -0.01324671f, 
    -0.07487868f, -0.01078415f, -0.13130328f, -0.06319536f, -0.08894471f, 0.00193730f, -0.14042515f, -0.02581455f, 
    -0.03647346f, -0.00137001f, 0.05807673f, -0.12261824f, 0.05916141f, -0.09455962f, 0.02893400f, -0.04166500f, 
    0.08487831f, -0.07095410f, -0.13022254f, -0.09807706f, -0.10146564f, 0.05749999f, 0.05666557f, -0.04712452f, 
    -0.12813358f, 0.17500260f, -0.06801613f, -0.05433421f, -0.10242130f, -0.06693075f, -0.08212164f, 0.20102187f, 
    0.56773454f, 0.12070365f, 0.02887587f, -0.27022377f, -0.11259914f, 0.22627407f, 0.09605282f, 0.09062930f, 
    0.05260386f, 0.00033177f, -0.05176339f, 0.23196614f, -0.09164864f, 0.38458839f, 0.33394891f, 0.30512065f, 
    0.00838079f, 0.30381173f, -0.14553206f, -0.35577616f, -0.34408060f, 0.03723672f, -0.24632342f, -0.00818621f, 
    -0.17416137f, 0.40616325f, -0.08219616f, -0.03238860f, 0.22387522f, -0.09824507f, -0.21489741f, 0.06712859f, 
    0.06256121f, 0.01927925f, -0.15318710f, 0.38018671f, 0.27286646f, -0.53461832f, 0.41082478f, -0.26640156f, 
    0.20567827f, 0.27618271f, -0.17360641f, 0.08415259f, 0.05226897f, 0.03744792f, 0.01399367f, 0.35588542f, 
    0.04449051f, 0.53140825f, 0.05622024f, -0.28494689f, 0.01250366f, 0.03110549f, -0.22005689f, 0.09692041f, 
    -0.10218650f, 0.10825533f, 0.04614092f, 0.01204530f, -0.06809854f, -0.04030736f, -0.05343518f, -0.12839308f, 
    -0.01711980f, 0.05876443f, -0.02081329f, 0.09698496f, 0.00574757f, 0.01607240f, -0.13426922f, 0.05362274f, 
    -0.04998253f, 0.01109085f, 0.00289852f, -0.06444666f, -0.03279562f, -0.07128629f, -0.06370459f, -0.00311873f, 
    -0.09645648f, 0.03283693f, -0.11462101f, -0.14287999f, -0.03798113f, 0.10066945f, 0.01941690f, -0.02538804f, 
    -0.01349215f, -0.04011182f, 0.11116552f, -0.01678090f, -0.02286514f, -0.00461379f, 0.07484872f, 0.00965878f, 
    0.01911760f, -0.04746792f, 0.01573912f, -0.02604071f, -0.02453321f, -0.14082740f, 0.03453792f, 0.03424802f, 
    -0.00502242f, 0.07678828f, -0.14165065f, 0.01072235f, 0.06278167f, -0.12881577f, 0.02183133f, -0.13495500f, 
    -0.12284659f, 0.00810191f, 0.09650756f, -0.02533611f, 0.08855056f, 0.00280071f, -0.06759986f, -0.05574872f, 
    0.06397359f, -0.00320610f, -0.28429797f, -0.09606652f, -0.57925570f, -0.05737859f, 0.00740028f, 0.09681339f, 
    0.18613648f, 0.32499599f, 0.42512128f, -0.45070013f, 0.06342723f, 0.54595381f, -0.20707178f, 0.21960448f, 
    -0.26201665f, -0.05737394f, -0.14571728f, 0.63049799f, 0.19786392f, -0.11043426f, 0.29168460f, 0.19070058f, 
    0.14145976f, 0.16876426f, 0.23472019f, 0.23339872f, -0.23201135f, -0.33014831f, -0.15199389f, -0.12179082f, 
    0.27526560f, -0.24110961f, -0.08208625f, 0.21912749f, -0.12504013f, 0.12761045f, 0.03364579f, 0.43154189f, 
    0.06472849f, 0.09390949f, 0.06830265f, 0.03625710f, 0.15967351f, 0.14174381f, 0.09735218f, -0.16941810f, 
    0.42192340f, 0.12108020f, 0.16417782f, 0.04829710f, -0.18775228f, -0.00938128f, -0.38101995f, -0.26330602f, 
    0.10521175f, 0.01893244f, 0.02673656f, 0.11647552f, -0.05252878f, -0.05436512f, -0.50768113f, 0.01483173f, 
    0.04300357f, 0.20730041f, 0.13858512f, 0.20928445f, 0.15651622f, 0.10922446f, -0.05143086f, 0.00187642f, 
    0.53101957f, 0.09475762f, 0.00985289f, -0.51438498f, -0.08396937f, 0.28222117f, -0.02236587f, 0.20242099f, 
    0.20064035f, -0.00096527f, 0.23968637f, 0.11278952f, 0.05364421f, 0.41989425f, 0.51771939f, 0.15401004f, 
    -0.15662037f, 0.30649412f, 0.15108745f, -0.05795357f, -0.02961114f, 0.28333959f, -0.49870291f, 0.06778693f, 
    0.05013322f, 0.04183732f, -0.00958024f, -0.08550687f, 0.18361630f, -0.06078701f, -0.43708467f, 0.17839108f, 
    0.24370919f, -0.15673567f, 0.01109987f, 0.23344207f, 0.21849774f, -0.40875918f, 0.25436920f, -0.02324110f, 
    0.32992855f, 0.23574050f, -0.20130125f, -0.09182945f, -0.04749309f, -0.06536499f, 0.08307803f, 0.08135775f, 
    0.11349257f, -0.00572162f, -0.13079867f, -0.15217970f, 0.16997942f, 0.02053828f, -0.32882640f, 0.13812751f, 
    -0.02852042f, 0.08623204f, -0.09433539f, -0.10238001f, 0.01705175f, -0.09299177f, 0.06218339f, -0.04636145f, 
    -0.11436669f, 0.04373237f, -0.12578221f, 0.05644873f, 0.03073430f, 0.01307089f, -0.07463235f, 0.06552611f, 
    -0.11565764f, -0.02408422f, -0.05135281f, 0.04206283f, -0.11273126f, 0.07093336f, -0.13339172f, 0.00245820f, 
    0.01496038f, 0.08550218f, 0.06297754f, -0.02411839f, 0.05807855f, 0.00507273f, -0.08634427f, 0.01590091f, 
    -0.08771501f, 0.11691266f, 0.07674232f, -0.04926978f, 0.08097854f, -0.11319868f, -0.12422404f, -0.12504993f, 
    -0.02746731f, -0.11311334f, -0.09468311f, -0.05754786f, 0.03969985f, -0.05296656f, -0.04373193f, -0.04411884f, 
    0.08672894f, -0.01622488f, 0.06157855f, 0.01682151f, 0.10152708f, -0.01998216f, -0.14629889f, -0.13280605f, 
    -0.01861866f, 0.11174314f, -0.11019922f, 0.03400091f, 0.03144882f, -0.14318711f, -0.12034860f, -0.01454724f, 
    -0.01745300f, 0.07628475f, -0.09332114f, -0.17053747f, -0.13296923f, 0.02934726f, -0.06654841f, -0.07639164f, 
    0.21255878f, 0.22577006f, 0.31862244f, -0.09069002f, -0.05451717f, -0.07863998f, 0.21210700f, 0.19985743f, 
    -0.03653432f, -0.14397591f, 0.14904073f, 0.18512668f, 0.08267187f, 0.28962326f, 0.30981109f, 0.03769304f, 
    0.05384110f, 0.24162713f, -0.03916037f, -0.20573713f, -0.35851344f, 0.02046107f, -0.12193627f, -0.13198817f, 
    0.08130231f, 0.20078152f, -0.01824296f, 0.13998342f, 0.09651127f, -0.07958937f, 0.04739341f, -0.01489703f, 
    0.06556261f, -0.10194492f, 0.21533172f, 0.38266072f, 0.06222833f, -0.33199191f, 0.07536262f, -0.16539548f, 
    0.25517988f, 0.02112634f, 0.01028495f, 0.25122532f, -0.14004757f, 0.06623289f, -0.02503873f, -0.32749787f, 
    0.04916941f, 0.08007700f, 0.14437054f, 0.18014529f, 0.05596932f, 0.01696332f, -0.11479716f, 0.10437296f, 
    -0.07990548f, -0.13264841f, -0.00549527f, -0.26699641f, 0.30221242f, -0.32186952f, -0.09030361f, 0.26252326f, 
    0.16312635f, -0.24139079f, -0.08454105f, 0.03420384f, 0.11847367f, -0.04529157f, -0.12341579f, -0.03999214f, 
    0.38440365f, 0.12746708f, -0.03577843f, -0.22769926f, -0.39297432f, 0.15001477f, -0.17163594f, 0.04942100f, 
    0.13318743f, -0.03415962f, 0.06122054f, 0.10855941f, 0.15937795f, -0.05856141f, -0.15549302f, 0.23234363f, 
    -0.12943256f, 0.29682568f, -0.14552480f, 0.01194132f, 0.25565222f, -0.13818765f, 0.26012111f, 0.10071822f, 
    -0.47746435f, -0.07773273f, -0.18372881f, 0.20870514f, 0.26301849f, 0.19999236f, 0.11728169f, 0.16218829f, 
    0.07079084f, 0.32345685f, 0.02649807f, -0.05976432f, 0.54616261f, 0.10249958f, 0.28660080f, 0.51748604f, 
    -0.05866906f, -0.20716321f, 0.03176007f, -0.20568994f, -0.35237560f, 0.19246922f, -0.19899157f, -0.03727043f, 
    0.01970512f, 0.00734849f, -0.06350694f, 0.06285708f, 0.07394840f, -0.07259048f, -0.07099149f, 0.06736634f, 
    0.10743408f, -0.05913091f, -0.01264609f, -0.02478725f, 0.05240272f, -0.00326461f, -0.04175422f, -0.04526631f, 
    -0.13025841f, 0.01214476f, -0.13509080f, 0.00823108f, 0.10736682f, 0.00234015f, -0.06124775f, 0.02300508f, 
    -0.11361477f, -0.13639347f, -0.07469316f, 0.01982743f, 0.04640721f, 0.06917497f, 0.08429200f, -0.05732578f, 
    0.08414377f, 0.00680097f, 0.08870548f, -0.11315712f, -0.04540985f, 0.02998310f, -0.01524103f, -0.12777971f, 
    -0.00825497f, 0.08945987f, 0.03238019f, -0.08990985f, -0.10223252f, 0.07980561f, 0.01941021f, 0.08386200f, 
    -0.10398106f, 0.12360807f, -0.03436227f, -0.13608576f, -0.07978237f, -0.13147894f, 0.00897310f, 0.03054680f, 
    0.08535801f, 0.06301698f, -0.02095339f, 0.09994666f, -0.03731259f, -0.09846561f, -0.08281080f, 0.09357397f, 
    0.04152412f, 0.10906047f, 0.24582909f, -0.44569510f, 0.34651884f, -0.13959706f, 0.01593466f, 0.11100280f, 
    -0.01659830f, -0.28191814f, -0.27822390f, 0.41293931f, 0.10672911f, -0.00735231f, 0.15139636f, 0.04256411f, 
    0.12448556f, 0.16729167f, -0.03592515f, -0.13630222f, -0.02178611f, -0.13275433f, -0.32941914f, -0.16386864f, 
    0.09343322f, 0.07303973f, -0.03007104f, -0.11702625f, 0.29201949f, 0.08785352f, 0.21875548f, 0.15210408f, 
    -0.22621958f, -0.08310723f, 0.09359286f, -0.01690236f, 0.19541636f, -0.05807536f, -0.16113216f, -0.21420254f, 
    -0.41550663f, -0.02433301f, -0.12268984f, -0.01034829f, -0.17433214f, 0.38395077f, 0.10837158f, -0.06491265f, 
    -0.18002291f, 0.21108915f, 0.13147177f, 0.24775298f, 0.14021523f, 0.14769065f, 0.25937653f, 0.32327661f, 
    0.07729821f, -0.32126603f, 0.25465915f, 0.02796981f, -0.26441562f, 0.14925167f, 0.20931911f, -0.12582722f, 
    0.01539391f, -0.10299108f, 0.27447662f, -0.10510138f, 0.04447214f, 0.25638440f, 0.02854786f, 0.07355668f, 
    0.11854549f, -0.36430392f, -0.06417914f, -0.18149593f, -0.00286589f, 0.00536760f, -0.07034782f, -0.08819200f, 
    0.28910401f, 0.05244865f, 0.15218846f, -0.25281867f, -0.05529313f, 0.25157064f, 0.09835317f, 0.11897653f, 
    -0.11224287f, -0.08944887f, 0.13829547f, 0.35605204f, 0.18906519f, 0.02421589f, -0.23904926f, 0.33934134f, 
    0.00304856f, 0.19319777f, 0.03987697f, 0.23687404f, -0.00664706f, 0.07679729f, 0.28718325f, 0.18876053f, 
    -0.06157631f, 0.10416760f, -0.05457355f, 0.07120760f, 0.32174692f, 0.31599170f, 0.14050448f, 0.40839779f, 
    0.12824343f, 0.11934217f, -0.21741267f, -0.21686900f, 0.29532537f, -0.23782754f, 0.05315790f, 0.46600619f, 
    -0.02315393f, -0.11918470f, 0.23107740f, 0.28537124f, 0.03291934f, 0.09105036f, 0.08012889f, 0.02002473f, 
    -0.09005615f, -0.01912799f, 0.06666828f, 0.11407202f, 0.05412387f, -0.01619868f, 0.09338239f, -0.06349494f, 
    -0.09798575f, 0.01546172f, -0.06422682f, -0.00262100f, 0.04649700f, -0.03596026f, 0.08800302f, 0.08222256f, 
    -0.11393586f, -0.02531863f, -0.00513419f, 0.00244186f, -0.07966983f, -0.05395915f, -0.13649637f, 0.02470254f, 
    -0.12539524f, -0.02930334f, 0.01380134f, 0.03051636f, -0.11179662f, 0.06500100f, 0.02438484f, 0.09726265f, 
    0.07644720f, 0.01748456f, 0.11267814f, -0.02822084f, 0.06819783f, 0.06645277f, -0.03445690f, -0.12283862f, 
    0.11052527f, -0.04568355f, -0.02811458f, -0.09289769f, -0.03340659f, 0.05446172f, -0.00216817f, -0.11537484f, 
    0.01208895f, 0.00476640f, -0.03889531f, -0.04548150f, 0.08910589f, -0.15141873f, 0.02680275f, -0.10355058f, 
    0.08789846f, -0.04799086f, -0.12396304f, 0.11428180f, 0.10469374f, -0.01741746f, -0.14999790f, 0.10035239f, 
    0.11384335f, 0.21778046f, -0.02728710f, 0.15990531f, 0.28168321f, 0.19590218f, 0.03135463f, -0.08782153f, 
    0.49612480f, -0.10556778f, 0.36783594f, 0.35141507f, -0.12234762f, 0.18200447f, -0.36800098f, 0.07371522f, 
    0.23731185f, 0.34020126f, -0.11092833f, 0.12384272f, 0.16091348f, 0.13607284f, 0.12688623f, 0.53951168f, 
    -0.19523419f, -0.02381849f, 0.22033441f, 0.07010286f, 0.21878086f, 0.21842855f, 0.39820552f, -0.05471436f, 
    0.08947410f, 0.13548400f, -0.06260754f, -0.56033760f, -0.07663406f, -0.00392453f, 0.57390815f, 0.15658598f, 
    0.02788336f, -0.03461908f, -0.45373023f, -0.23636664f, 0.24891542f, -0.11157869f, -0.03314706f, 0.04121516f, 
    0.38225546f, 0.17462274f, -0.02337690f, -0.10423424f, 0.10533459f, -0.06418671f, 0.12624055f, 0.34409490f, 
    0.10702643f, 0.09678442f, -0.00367698f, 0.10539798f, 0.24947348f, -0.29007336f, 0.05915125f, -0.09856314f, 
    0.02692264f, -0.05404937f, 0.07285824f, -0.06614081f, 0.00505365f, 0.03048779f, -0.08680113f, 0.10396182f, 
    -0.02383969f, 0.02204590f, 0.07411020f, -0.04994389f, 0.00934599f, 0.11224748f, 0.01692225f, -0.15256944f, 
    -0.05169789f, 0.00576995f, 0.01758378f, 0.07614185f, 0.04575403f, -0.06501719f, -0.17803583f, 0.04512235f, 
    -0.14422071f, -0.13387199f, -0.09707370f, -0.02320050f, 0.07578485f, 0.05950405f, -0.07794829f, -0.06177253f, 
    0.03179430f, 0.01319238f, -0.02401426f, -0.06049269f, -0.01882969f, 0.08664414f, 0.10460472f, -0.09404391f, 
    -0.03996177f, 0.02830320f, -0.05881932f, -0.12491693f, -0.13060528f, -0.08194875f, -0.07349733f, -0.08417281f, 
    -0.03639666f, 0.01221177f, 0.01894064f, 0.00012128f, 0.10834923f, 0.06133538f, -0.02525214f, -0.01440484f, 
    -0.10731726f, 0.01193644f, -0.10881280f, 0.08832654f, 0.10538829f, -0.04973700f, 0.08912660f, -0.11101484f, 
    0.02403045f, 0.20093086f, 0.13380086f, 0.20992313f, 0.09040915f, -0.09376766f, 0.00889260f, 0.19879107f, 
    0.14725406f, -0.09407814f, -0.17846583f, -0.18551306f, 0.03138256f, -0.61593688f, 0.29689017f, 0.06866773f, 
    0.10315210f, 0.01450155f, -0.13902804f, -0.10306145f, 0.18322216f, 0.43182451f, 0.11160450f, -0.09030224f, 
    -0.04238569f, 0.33931616f, -0.29237977f, -0.22858934f, -0.25634781f, 0.13894859f, -0.25948593f, 0.02621857f, 
    -0.29588723f, 0.23482895f, -0.10676262f, 0.58806825f, 0.10869057f, 0.07115225f, -0.46908447f, -0.05082679f, 
    0.41405025f, -0.15193141f, -0.14374690f, 0.03110397f, 0.06810463f, -0.30360430f, 0.35612735f, 0.14298907f, 
    -0.17478690f, 0.09390295f, -0.17503856f, 0.00341810f, -0.40842405f, 0.02091992f, -0.05567069f, -0.04368493f, 
    0.02489175f, -0.20434409f, 0.00401882f, 0.36531845f, 0.13365678f, 0.15587611f, -0.12283493f, -0.08099011f, 
    -0.11920241f, -0.03153942f, 0.09056687f, 0.29427543f, 0.05075995f, -0.39765072f, 0.08315421f, 0.24572960f, 
    -0.07885347f, 0.00772641f, -0.23516420f, -0.30479333f, 0.07438915f, -0.01730206f, 0.06336997f, 0.15188515f, 
    0.26415071f, 0.19152257f, -0.02601522f, 0.19872051f, 0.45376232f, 0.02666066f, 0.25723264f, -0.02737476f, 
    0.11006085f, 0.33753490f, 0.17146119f, 0.18989711f, 0.10964119f, 0.21838790f, -0.23615058f, 0.21886057f, 
    -0.24524651f, -0.10531849f, 0.02348532f, 0.61167437f, 0.14134298f, 0.00157879f, -0.31458253f, -0.10079592f, 
    0.68728143f, -0.10970868f, -0.00179478f, -0.31439552f, -0.03310088f, 0.02885447f, -0.02205503f, 0.14447729f, 
    -0.16186589f, 0.01676925f, -0.03833471f, -0.04753546f, -0.32998782f, -0.03301429f, -0.02220810f, -0.28351173f, 
    0.07736897f, -0.24660257f, -0.05540493f, 0.48631349f, 0.28887123f, -0.14522851f, -0.12054440f, 0.03972040f, 
    0.10455176f, -0.06821358f, 0.03415999f, 0.05385123f, -0.07438537f, -0.12187546f, 0.01867706f, 0.08756970f, 
    -0.06467898f, 0.06428511f, -0.04535041f, 0.07136238f, 0.07135336f, -0.00612055f, 0.07347094f, -0.01333784f, 
    0.01070523f, 0.00951852f, -0.07270778f, -0.02729804f, 0.02986836f, -0.05588828f, 0.07748199f, 0.07502396f, 
    0.04263103f, 0.01039609f, -0.09968740f, 0.00067267f, 0.02405033f, -0.06370301f, -0.00718157f, -0.00275659f, 
    -0.03176319f, 0.05383681f, -0.10805054f, -0.08177792f, -0.10755008f, 0.08302245f, -0.04532412f, -0.10756186f, 
    0.04442503f, -0.10726446f, 0.09799040f, -0.06874409f, -0.08352293f, -0.01929281f, -0.13207558f, 0.01476937f, 
    -0.12199341f, -0.03821744f, 0.07702634f, 0.00549692f, 0.10533066f, -0.10864069f, -0.05421993f, -0.06833144f, 
    0.07940288f, -0.08822528f, 0.04028702f, -0.04863935f, -0.03473351f, 0.07502855f, -0.10707945f, -0.06528547f, 
    0.11471375f, -0.01984930f, 0.04349957f, 0.06885220f, 0.09487399f, -0.06526738f, -0.10747412f, -0.05775335f, 
    0.05039100f, 0.03157302f, -0.01539492f, -0.09004587f, -0.01526715f, 0.07185771f, 0.01891285f, -0.02333780f, 
    0.03762785f, 0.05783000f, 0.00128348f, -0.05603831f, 0.10901180f, -0.12137112f, 0.00857623f, -0.13614383f, 
    -0.02651413f, 0.11088697f, -0.13082294f, -0.01300201f, 0.02758179f, -0.02056160f, 0.01688703f, -0.06629073f, 
    -0.12821601f, -0.06240867f, 0.12301405f, -0.01035144f, -0.14792122f, -0.00014960f, 0.05233112f, -0.07102332f, 
    -0.02102221f, -0.08975250f, -0.04384563f, 0.02539595f, 0.04919735f, 0.07868796f, 0.03240483f, -0.06695008f, 
    -0.04839876f, 0.08819394f, 0.04224987f, 0.04475625f, -0.05108975f, -0.02079870f, 0.01628467f, -0.10690204f, 
    -0.05544303f, 0.09655774f, -0.09414093f, -0.07214253f, -0.03992209f, -0.11995210f, -0.10278130f, -0.06559030f, 
    -0.04909129f, -0.06375469f, 0.03689644f, 0.21818759f, -0.08266177f, 0.05524394f, -0.10239667f, -0.09271198f, 
    0.08650373f, 0.01533330f, -0.08961064f, -0.07863680f, -0.02326262f, 0.07676654f, -0.11327021f, -0.05043328f, 
    -0.00943604f, -0.06480459f, -0.01259630f, 0.00634430f, -0.06085333f, 0.03051393f, 0.08218143f, -0.08859715f, 
    -0.14781231f, -0.15607065f, 0.00775706f, -0.05387801f, 0.07312952f, -0.05976761f, -0.04782395f, -0.12612490f, 
    0.01711076f, 0.00978839f, 0.01817985f, -0.02807307f, -0.09769341f, 0.05168413f, 0.10926110f, 0.03582010f, 
    0.07612623f, 0.04471529f, 0.01347543f, -0.00011826f, -0.09067682f, -0.03426798f, -0.04367289f, 0.02908909f, 
    -0.07442399f, 0.04426615f, -0.12189669f, -0.08265976f, 0.01512772f, -0.09361593f, 0.08498251f, -0.14505373f, 
    -0.01914382f, 0.03572144f, -0.14948544f, -0.01425574f, -0.04683132f, -0.11801112f, -0.05595195f, 0.09542701f, 
    0.10612339f, 0.08775714f, 0.09520144f, 0.04267181f, 0.02029627f, -0.09142005f, 0.01225841f, -0.01846919f, 
    0.11623400f, -0.02716928f, -0.05072475f, -0.14547764f, -0.08045267f, -0.01215686f, 0.02463949f, -0.06792329f, 
    0.01393543f, -0.03561949f, -0.14250039f, -0.04102128f, 0.09665535f, -0.09108038f, 0.06407090f, -0.02366563f, 
    0.04136575f, -0.01311278f, -0.09571097f, -0.09821721f, -0.09724016f, -0.11727895f, -0.00168738f, -0.06748090f, 
    0.00655785f, 0.03864149f, -0.03593081f, -0.08041940f, 0.04877962f, 0.05268052f, -0.10032590f, -0.11020000f, 
    0.01159311f, -0.01472635f, -0.11798764f, -0.12253670f, -0.10371765f, 0.00217609f, -0.11553706f, 0.01116156f, 
    -0.04706800f, -0.12347743f, -0.05830342f, -0.06773321f, -0.04868487f, 0.02139853f, 0.05736828f, 0.00048254f, 
    -0.06827839f, -0.01268248f, -0.11295249f, 0.06270028f, 0.03777361f, 0.06384808f, 0.06701867f, 0.12099349f, 
    0.01440010f, 0.25894329f, -0.07118921f, -0.22857457f, 0.12199482f, -0.10302213f, -0.06616761f, -0.03107815f, 
    -0.15449171f, -0.03694920f, 0.11890698f, 0.50709295f, 0.04271984f, 0.11983596f, -0.00606749f, -0.00041912f, 
    0.02937846f, -0.06769138f, -0.21855159f, -0.03579518f, -0.08038877f, -0.20308113f, -0.42104411f, 0.05075742f, 
    0.19759077f, -0.00812904f, -0.05269011f, -0.06902618f, 0.21730123f, -0.16082223f, 0.70442092f, -0.17606135f, 
    0.05920303f, 0.08108358f, 0.02569564f, -0.48914364f, 0.22847083f, 0.11905255f, 0.21145061f, -0.09954357f, 
    -0.48971909f, 0.05403173f, 0.01912072f, 0.15364163f, 0.00223872f, 0.07089154f, 0.13541053f, -0.26978236f, 
    -0.24909994f, -0.22551709f, 0.30336353f, 0.21232472f, 0.25364569f, 0.39409649f, 0.04461505f, 0.11077332f, 
    -0.04808677f, 0.21618362f, 0.14976361f, -0.28068638f, -0.13446914f, 0.27183044f, 0.39625672f, 0.08299527f, 
    -0.11469271f, 0.02395796f, -0.08377152f, 0.02280607f, 0.04931651f, 0.02479547f, -0.11300353f, 0.04817328f, 
    0.00442937f, -0.00581810f, 0.10009047f, -0.08649942f, -0.04771455f, -0.00761430f, -0.09709773f, -0.06597383f, 
    0.09679985f, 0.01823858f, -0.13388765f, -0.09604138f, 0.00056520f, -0.04292063f, 0.08306657f, -0.12616201f, 
    0.10326817f, 0.04620139f, -0.03904139f, -0.13251501f, -0.07719603f, 0.07810573f, -0.05006814f, -0.05980868f, 
    0.07755926f, -0.09246124f, 0.10292465f, 0.04468435f, -0.05673585f, 0.07254560f, -0.08990037f, -0.12418532f, 
    -0.08789223f, -0.04208616f, 0.00153880f, -0.02193091f, -0.00291109f, 0.00696785f, 0.07193772f, 0.06715440f, 
    0.01325563f, -0.11267614f, -0.06180845f, -0.01027746f, -0.00412712f, -0.10769337f, 0.05507538f, -0.06253334f, 
    -0.00139744f, 0.12353410f, -0.04858469f, -0.08369812f, 0.04807585f, 0.09419634f, 0.08874298f, -0.10341833f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.08509497f, 0.22590591f, -0.13637294f, 0.04543983f, 0.18553916f, 0.20958757f, -0.00915695f, -0.02609160f, 
    0.03088946f, 0.05639087f, 0.10557341f, 0.09406070f, 0.08399136f, 0.07453034f, -0.13738024f, -0.09743397f, 
    0.27486613f, -0.05848766f, 0.12421062f, 0.00387452f, 0.10478200f, 0.01496158f, 0.04557151f, 0.31508598f, 
    0.20630233f, -0.13066544f, 0.13429396f, 0.27003267f, 0.05904897f, 0.25769973f, 0.05615953f, 0.02843636f, 
    -0.07895152f, 0.01197539f, 0.15497871f, -0.10941353f, 0.30482578f, 0.07990374f, 0.10905101f, 0.25310647f, 
    -0.00674376f, 0.05775327f, -0.14088930f, -0.01546443f, -0.10156744f, -0.27027950f, 0.05464549f, -0.12818365f, 
    0.17229629f, -0.15909673f, -0.03193486f, -0.04007142f, -0.01976662f, -0.04747960f, 0.00618586f, -0.11191721f, 
    0.07479015f, -0.00968381f, -0.12326575f, 0.08550688f, -0.05796419f, 0.01288150f, 0.13197628f, 0.07110795f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.06596706f, 0.10965943f, -0.01960488f, -0.02653774f, 0.26059651f, -0.19861352f, -0.51826835f, -0.09612913f, 
    -0.66254020f, 0.17881237f, -0.33574620f, 0.10915630f, 0.09839001f, 0.07686111f, -0.16462637f, -0.32319063f, 
    0.04433058f, 0.11734986f, -0.12256136f, -0.18444550f, -0.36517763f, 0.06191155f, -0.16215357f, -0.01462661f, 
    0.33900437f, -0.01099685f, -0.08021528f, -0.01401576f, 0.01597240f, 0.01902784f, -0.19677897f, -0.18419939f, 
    -0.10298750f, 0.32002994f, -0.28305686f, -0.03744248f, 0.14657448f, -0.11365286f, -0.43548515f, 0.16667433f, 
    0.04967038f, 0.02765290f, 0.06477246f, 0.39168924f, -0.11724115f, -0.64694810f, 0.31215480f, -0.09765395f, 
    0.31251988f, 0.06511742f, 0.09348558f, -0.07329052f, -0.20739722f, 0.08329348f, -0.03318529f, 0.12632115f, 
    0.19127783f, -0.13269702f, -0.10088980f, 0.10526597f, -0.14353777f, -0.04446777f, -0.01931223f, 0.10727020f, 
    0.05331373f, -0.06714402f, -0.00410822f, -0.05038187f, -0.11348294f, 0.07238501f, 0.03454627f, -0.43763569f, 
    -0.07287683f, -0.34016028f, -0.05102870f, -0.21314943f, 0.31020537f, 0.03977789f, -0.13434654f, -0.09629078f, 
    -0.20139652f, 0.04969406f, 0.00996940f, -0.04686994f, -0.36899906f, -0.03217905f, 0.17447971f, -0.03435422f, 
    -0.00722651f, -0.02997051f, -0.51812953f, -0.21246952f, 0.23176660f, 0.08050046f, -0.44074768f, 0.13506737f, 
    0.10938957f, 0.27057788f, -0.04942973f, 0.08999147f, -0.10637750f, -0.00119828f, -0.22201604f, -0.31506363f, 
    -0.11258832f, -0.15401493f, 0.05566658f, 0.32522428f, 0.06321262f, -0.01802580f, 0.36396262f, -0.01615979f, 
    -0.06521881f, 0.09510551f, -0.02904035f, -0.10808212f, 0.24767180f, -0.02322263f, 0.27387780f, 0.01433699f, 
    0.31376511f, 0.18262523f, 0.10897069f, -0.09378777f, -0.12893841f, 0.07254791f, -0.53711230f, 0.07495511f, 
    -0.00072492f, 0.26183721f, 0.08572503f, 0.28533834f, -0.25907442f, 0.01710351f, 0.16587171f, 0.53108567f, 
    0.34173819f, 0.34225455f, -0.30298913f, -0.01609677f, -0.36869720f, -0.05034825f, -0.10153916f, -0.02459903f, 
    -0.02774470f, 0.02715791f, 0.01467138f, -0.39810812f, -0.39730018f, 0.05392353f, 0.27564496f, -0.22471292f, 
    -0.34797448f, 0.05069392f, -0.22690447f, 0.15009530f, -0.44128352f, -0.53499252f, -0.53790963f, 0.06997404f, 
    0.09746264f, -0.45397910f, -0.40545669f, 0.00443465f, -0.65443003f, 0.07622764f, 0.12526856f, -0.08427621f, 
    -0.54058528f, 0.03634180f, 0.04266107f, -0.07115339f, 0.07623565f, -0.36087930f, -0.15320715f, -0.03046186f, 
    -0.19971287f, 0.37212372f, -0.11027434f, 0.04319055f, 0.28123948f, -0.03165062f, -0.00607050f, 0.11159281f, 
    -0.56111413f, -0.34299380f, 0.05864790f, 0.06428945f, 0.04701366f, -0.02175360f, 0.04904919f, -0.04100690f, 
    0.09196869f, 0.17480047f, -0.07006791f, -0.30002484f, 0.06285596f, -0.64206386f, -0.25124168f, -0.22762227f, 
    0.02667910f, -0.44210812f, 0.18875210f, 0.24079877f, -0.23726282f, -0.00801434f, 0.02174256f, -0.08581497f, 
    -0.21403231f, 0.00624460f, 0.18085343f, 0.07002558f, -0.40816540f, 0.01374645f, 0.00595157f, 0.10392447f, 
    -0.35329622f, 0.08006857f, 0.16322900f, -0.28423449f, 0.19807465f, -0.06664351f, 0.21152797f, -0.78254163f, 
    0.00733099f, -0.33197692f, 0.29469535f, 0.09955899f, 0.04640610f, 0.06416398f, 0.22745563f, 0.21398644f, 
    0.15995471f, -0.25811860f, 0.09535326f, -0.43070179f, 0.07932224f, 0.06758020f, -0.42627072f, 0.04340463f, 
    -0.09074222f, -0.37323388f, 0.00538630f, 0.02152151f, -0.40126780f, -0.09557325f, 0.10870206f, 0.07320951f, 
    -0.42131731f, 0.18475696f, -0.11390823f, 0.01506976f, -0.01822635f, 0.00777637f, 0.22643226f, 0.02302787f, 
    -0.12503722f, 0.05391838f, 0.09961257f, -0.06740332f, -0.19375493f, 0.06261567f, -0.22454773f, 0.15674669f, 
    -0.08078187f, 0.10403606f, 0.17974471f, 0.13466787f, -0.25275245f, 0.03480231f, -0.03861244f, -0.09968221f, 
    -0.05807881f, 0.05369654f, -0.03363163f, -0.23895051f, 0.09245314f, -0.06151225f, -0.09016966f, 0.17114973f, 
    0.21803296f, -0.06504197f, 0.04847775f, -0.11038529f, 0.06021220f, 0.22108370f, -0.01672750f, 0.05028154f, 
    0.05938740f, -0.01118408f, -0.37919354f, 0.00209480f, 0.11625405f, -0.03334309f, -0.04743396f, 0.17467804f, 
    0.02367947f, 0.04592691f, -0.11776814f, 0.20363496f, -0.00205971f, -0.23328136f, -0.19808236f, 0.04120694f, 
    -0.05006009f, 0.01668855f, 0.02116724f, -0.02992760f, -0.08335172f, 0.00751105f, 0.09387187f, 0.03778354f, 
    -0.40892532f, -0.46775684f, -0.05352979f, -0.04632109f, 0.06684261f, 0.12708937f, 0.24389669f, -0.04895446f, 
    -0.11925425f, 0.01757516f, -0.13129783f, -0.11930206f, -0.39330959f, 0.05041673f, 0.16511254f, -0.08236526f, 
    0.08581997f, -0.09519678f, -0.28557247f, -0.28366214f, 0.19134653f, 0.08984069f, -0.10945041f, -0.55704492f, 
    0.04238772f, 0.10409571f, -0.08210364f, -0.10287340f, 0.17383757f, -0.02889436f, 0.01231490f, 0.13409044f, 
    0.17480198f, 0.09937733f, -0.12206649f, 0.17850484f, -0.22149356f, 0.23725902f, 0.29591516f, 0.11260593f, 
    0.03251387f, -0.12064391f, -0.08474967f, -0.00042421f, 0.16608751f, -0.03191402f, -0.15110436f, 0.19885817f, 
    -0.00897802f, 0.04923116f, 0.01315650f, 0.07585625f, -0.03186191f, 0.66662371f, 0.06661271f, -0.08701718f, 
    0.23134488f, -0.12051538f, -0.03773608f, -0.18008417f, -0.11580180f, -0.10259410f, -0.36796561f, 0.08669980f, 
    0.18872096f, 0.33748615f, -0.07294638f, -0.03216487f, -0.05197624f, -0.10511163f, -0.36892056f, -0.04761889f, 
    -0.11824953f, 0.24279137f, 0.04080782f, -0.50242049f, -0.45075539f, -0.06552327f, -0.15164021f, 0.12488169f, 
    -0.09022117f, 0.02425328f, 0.23961094f, -0.08879532f, -0.72684336f, 0.04898556f, -0.06986952f, 0.11570555f, 
    0.09215943f, 0.10240723f, 0.20382424f, -0.45304134f, 0.10871911f, 0.00946932f, 0.22964759f, 0.35867134f, 
    -0.12623544f, -0.03671199f, -0.17339072f, 0.02217809f, -0.71225429f, 0.11438633f, -0.25327906f, 0.23187812f, 
    0.01909600f, -0.49950865f, -0.04010521f, 0.01818076f, -0.13497645f, 0.03210630f, 0.18422437f, 0.20256692f, 
    -0.16700824f, 0.35064197f, -0.08403184f, 0.02362926f, 0.03393253f, -0.15914911f, -0.35300910f, -0.04524546f, 
    -0.03594089f, 0.03716726f, 0.04930142f, 0.23574264f, -0.02318848f, -0.05794035f, -0.52701902f, 0.03814979f, 
    0.15791698f, -0.00093418f, -0.10126311f, 0.02341136f, -0.03814324f, 0.01246343f, -0.00691405f, -0.07863540f, 
    -0.09863125f, -0.16879635f, 0.03904252f, -0.01622786f, -0.19457929f, -0.29910234f, 0.05693605f, -0.15734744f, 
    -0.12979387f, 0.18840721f, -0.02439116f, -0.03861282f, 0.22896113f, 0.06210174f, 0.03876299f, 0.17278902f, 
    -0.49992952f, -0.07788907f, -0.32004538f, -0.04809456f, 0.05710635f, 0.07848734f, -0.51307106f, -0.41376358f, 
    0.10528166f, 0.11041770f, 0.11956447f, -0.55073082f, 0.18773474f, 0.15881288f, 0.27375180f, 0.07871254f, 
    0.01032180f, 0.19842175f, 0.16439247f, -0.06797148f, 0.13093533f, -0.08988649f, -0.19820906f, -0.08614188f, 
    0.19798526f, -0.43719846f, 0.01953168f, -0.06453557f, 0.01188670f, 0.39130074f, -0.03732838f, -0.02403658f, 
    0.12294772f, -0.18760432f, 0.02723231f, -0.52653122f, -0.28180587f, 0.05087199f, 0.17414817f, -0.00248281f, 
    -0.29853785f, -0.10735882f, 0.01238872f, 0.02425855f, -0.00632026f, 0.04541608f, -0.05541570f, -0.01036328f, 
    0.02940495f, -0.39928687f, -0.08245590f, 0.28043091f, 0.12297027f, 0.06290780f, 0.27545422f, 0.03424177f, 
    0.33009660f, 0.05622043f, -0.30327263f, -0.28403744f, 0.36092007f, -0.08361605f, -0.06153777f, -0.19540857f, 
    -0.12191743f, -0.09642331f, -0.31260601f, 0.24393170f, -0.13705543f, 0.05058263f, -0.02555185f, -0.70457351f, 
    -0.35105133f, -0.01241257f, -0.16019587f, -0.02975090f, -0.41889486f, -0.47112229f, -0.15518373f, 0.04567057f, 
    0.04495342f, 0.17070095f, -0.20570700f, 0.06746609f, 0.05222413f, 0.08289577f, -0.05894070f, -0.39222369f, 
    -0.24105099f, -0.58628327f, -0.10978098f, -0.24954729f, -0.03777106f, -0.03708765f, 0.04919016f, 0.06978190f, 
    -0.21627675f, -0.15037444f, 0.01275450f, -0.28091711f, 0.06002015f, 0.03299251f, 0.30659890f, 0.02391008f, 
    -0.25715095f, 0.31148109f, 0.11080255f, 0.04372980f, 0.05813199f, 0.04114572f, -0.41299355f, -0.02953967f, 
    0.01651620f, -0.67705292f, 0.02773244f, -0.08211163f, -0.08247098f, 0.15344074f, 0.04258664f, -0.05414869f, 
    -0.45920750f, 0.28639761f, -0.08077648f, -0.31456783f, 0.03778969f, -0.06907948f, -0.00197445f, 0.38290051f, 
    0.18298608f, -0.01030228f, -0.18564050f, -0.11512914f, 0.31626117f, -0.00467679f, 0.09907488f, 0.17727622f, 
    0.14173970f, -0.02096445f, -0.05826357f, -0.04874253f, -0.07560491f, -0.24200958f, 0.05449381f, 0.20039290f, 
    0.02449923f, 0.26244316f, -0.12013620f, -0.10378464f, -0.35755923f, 0.00181524f, 0.04247481f, -0.46667725f, 
    -0.16427007f, 0.14718349f, -0.11525898f, -0.34201366f, 0.00858406f, 0.10542040f, -0.49127203f, 0.08020708f, 
    -0.16385680f, 0.00902247f, -0.07627300f, 0.17175901f, 0.01367550f, 0.04217348f, 0.27713671f, 0.07255148f, 
    -0.34904256f, -0.24127626f, -0.07123201f, 0.10835401f, 0.02839803f, -0.07821057f, 0.20363875f, 0.03440142f, 
    0.03102209f, 0.14919321f, 0.05305586f, 0.21266435f, 0.22010520f, 0.07483652f, 0.16824163f, -0.42529428f, 
    0.28649586f, -0.14919193f, 0.14049597f, 0.01527793f, -0.16212265f, -0.08923704f, -0.04810690f, -0.08146058f, 
    0.04516120f, 0.02982587f, 0.31890061f, 0.22074322f, -0.53400987f, 0.10651785f, 0.13205434f, -0.57317722f, 
    0.09103980f, -0.02518150f, -0.06253094f, 0.31163520f, -0.08170731f, -0.13399571f, -0.14078604f, -0.51839679f, 
    -0.00479853f, -0.26095703f, 0.24250747f, 0.02853555f, -0.00015208f, 0.05413628f, 0.24575242f, -0.05921251f, 
    -0.28141823f, -0.12622130f, -0.07439860f, -0.36800191f, -0.12390652f, -0.11669499f, 0.01564273f, 0.03313843f, 
    -0.03553126f, -0.32433191f, -0.05319038f, -0.19347306f, 0.05135313f, 0.03698718f, -0.28859976f, -0.06163669f, 
    -0.19747294f, -0.28336322f, -0.08534306f, -0.01256612f, -0.03809276f, -0.03912356f, -0.11348612f, -0.01805205f, 
    -0.04083099f, -0.15181673f, 0.04942451f, 0.14719774f, 0.13174100f, -0.17776141f, 0.03078028f, -0.36014599f, 
    -0.03319500f, -0.72971189f, 0.18644951f, 0.09503674f, -0.06920239f, -0.03781631f, -0.09736971f, -0.39919928f, 
    -0.03283406f, 0.04383327f, -0.00300531f, 0.23007546f, 0.21161483f, 0.10585746f, -0.17105336f, 0.04966587f, 
    -0.27606347f, 0.08608154f, 0.26159108f, 0.24260199f, -0.23967765f, -0.12820980f, 0.03226708f, -0.10482094f, 
    0.05332431f, -0.22088751f, -0.49189636f, 0.08547897f, -0.00326211f, -0.07596923f, 0.15764868f, 0.10368283f, 
    0.40883964f, -0.17774291f, 0.08111730f, -0.35265970f, -0.00811411f, -0.32655746f, -0.10437401f, 0.09781089f, 
    -0.51624238f, 0.18113168f, -0.10135780f, 0.21373773f, -0.00987346f, -0.07403152f, -0.07928257f, 0.08581512f, 
    -0.18623044f, 0.19694276f, 0.05190124f, -0.07353223f, 0.04138397f, 0.08039845f, 0.10382357f, 0.11541314f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.02344644f, -0.05362620f, -0.13519029f, 0.13756566f, 0.17349501f, 0.18459950f, 0.01408606f, -0.18361580f, 
    -0.07536857f, 0.02391089f, 0.23067339f, 0.06804533f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
