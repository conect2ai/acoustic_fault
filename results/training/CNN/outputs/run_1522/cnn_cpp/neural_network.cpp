#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.59813142f, -0.15338062f, -0.04234634f, 1.27053225f, -0.55685991f, -0.53356105f, -0.21586840f, -0.05410573f, 
    -0.34204507f, 0.43126607f, 0.55589134f, -0.07227016f, -0.42283314f, -0.74787480f, -0.62687677f, -0.09314492f, 
    0.45740491f, 0.02450613f, 1.05824912f, -0.68495655f, 0.03597163f, -0.08884411f, 0.02412460f, 0.24374495f, 
    -0.18756364f, 0.02585501f, 0.39897367f, -0.09923828f, 0.96738756f, -1.01623344f, 0.44002023f, 0.11920428f, 
    -0.21642128f, 0.26424909f, 0.17950451f, 0.16202049f, -0.49737898f, -0.67998010f, 0.04639657f, -0.51297534f, 
    -0.38170007f, -0.46188745f, 0.06608666f, 0.13417518f, 0.03734975f, 0.43290815f, 0.77768719f, 0.01998267f, 
    0.06702818f, 0.32755262f, 0.10879868f, -0.35449833f, -0.13009746f, -0.22605228f, -0.05746681f, -0.20633200f, 
    0.66719168f, -0.26406276f, 0.61513203f, -1.03332675f, 0.18386710f, 0.02941873f, -0.07098984f, 0.07339775f, 
    0.41698611f, 0.44662246f, -0.55459327f, 0.15985569f, 0.29491580f, 0.37773117f, 0.30524629f, 0.25826952f, 
    0.08251590f, -0.27413395f, -0.42724991f, -0.48293805f, -0.07988514f, -0.56457555f, 0.43812913f, 0.50523728f, 
    0.73865169f, 0.31612530f, -0.41943476f, -0.54509312f, 0.65680116f, 0.41901115f, 0.63524383f, -0.33565816f, 
    -0.09429542f, -0.40368384f, -0.01430825f, 1.24218249f, -0.23101991f, -0.65451193f, 0.03308617f, 0.16840398f, 
    -0.09469571f, -0.05586760f, 0.31064200f, -0.48682278f, -0.67113811f, -0.49774170f, -0.18513139f, 0.26351145f, 
    0.49383527f, 0.28260246f, -0.14488122f, 0.14909196f, -0.89462817f, -0.30530617f, 0.19580513f, -0.10359471f, 
    0.49368164f, -0.05249796f, -0.50233662f, -0.13174891f, -0.56740290f, 0.74916631f, -0.76630008f, 0.81642491f, 
    -0.06667847f, -0.00846085f, -0.06111322f, 0.38262802f, -0.12458263f, -0.16321765f, -0.27211869f, -0.33751386f, 
    -0.36659506f, -0.27337950f, -0.65941423f, -0.58847934f, -0.25793514f, -0.32656649f, -0.20014592f, -0.84213620f, 
    -0.74391896f, -0.21053556f, 0.81529039f, 0.11023387f, -0.30143198f, -0.08827276f, 0.03969238f, 0.53798807f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16411456f, 0.07760239f, 0.47090742f, 0.16378108f, 0.20986155f, 0.06834964f, -0.05343711f, 0.61148489f, 
    -0.20303747f, 0.33111516f, 0.28824294f, 0.62268585f, 0.25409302f, 0.39539671f, 0.11615929f, -0.16677868f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.00443502f, -0.00482850f, -0.07336992f, 0.01232322f, -0.00369170f, 0.01922708f, 0.02779340f, 0.06731928f, 
    -0.07627243f, 0.01870703f, -0.04985345f, -0.07335947f, -0.03176599f, -0.04889144f, -0.07104744f, -0.00272640f, 
    0.04745201f, -0.08087971f, 0.01325720f, -0.07677444f, -0.01658715f, -0.03125581f, 0.01131302f, 0.03992039f, 
    0.00835611f, -0.05126642f, 0.04726313f, -0.04291319f, -0.05477390f, 0.01597823f, -0.01755985f, 0.06073471f, 
    0.06189806f, 0.06530599f, -0.09220754f, 0.04039551f, 0.00534767f, -0.01792223f, 0.03896442f, -0.00562903f, 
    -0.02255019f, -0.07153510f, -0.03657530f, -0.07464042f, -0.04955203f, -0.07266708f, -0.02218393f, -0.09048133f, 
    -0.07546373f, -0.04559797f, 0.02801066f, 0.01539593f, -0.03896892f, 0.06703374f, -0.03848342f, -0.04656688f, 
    0.01438380f, -0.07825132f, -0.01574939f, -0.06220583f, 0.01247690f, -0.05006961f, 0.06708790f, 0.03041833f, 
    -0.01337268f, -0.05953281f, 0.06449055f, -0.01739599f, 0.00607113f, 0.03821502f, -0.01025570f, 0.00394002f, 
    0.03900263f, -0.02688091f, 0.01518402f, 0.07645257f, -0.06191707f, -0.05577070f, 0.02455243f, -0.02134092f, 
    -0.05695266f, 0.01708039f, -0.08077115f, -0.05140780f, 0.04727046f, 0.02043965f, -0.03100548f, 0.01678996f, 
    0.06367263f, 0.04030235f, 0.05422840f, -0.06835821f, -0.01587094f, -0.06766444f, -0.05449443f, -0.04553050f, 
    -0.01054288f, -0.06380282f, -0.01297758f, -0.05767487f, -0.04968364f, -0.07625695f, 0.03992843f, -0.05462081f, 
    -0.00496797f, -0.00856281f, 0.00983508f, -0.08317215f, 0.05588683f, 0.03507346f, 0.02447134f, 0.06192366f, 
    -0.06346114f, -0.06706427f, 0.04953357f, -0.09711360f, -0.07727212f, 0.01464634f, 0.04760449f, 0.01349804f, 
    0.02309875f, -0.04373311f, -0.03878867f, 0.02336671f, -0.08841619f, 0.00587845f, 0.06376404f, -0.08735316f, 
    0.02537891f, -0.00502694f, -0.05789019f, -0.07996924f, 0.06550407f, -0.03683554f, 0.00856622f, -0.01524413f, 
    0.00470089f, 0.02216851f, 0.06190206f, -0.07480261f, -0.00097791f, -0.03129410f, -0.00836524f, 0.02495403f, 
    -0.30624846f, -0.10161637f, -0.11194047f, -0.14632978f, 0.01923149f, -0.06620914f, 0.20057200f, 0.03626002f, 
    0.17122120f, 0.03589443f, -0.13562404f, 0.02476494f, -0.13430527f, 0.02883920f, -0.08263611f, 0.21480936f, 
    0.01493024f, 0.02942824f, -0.06209652f, -0.04992009f, 0.10099415f, 0.17668168f, 0.05516929f, 0.11792079f, 
    -0.02414347f, -0.04538452f, 0.03866991f, 0.18454976f, -0.05221379f, -0.21996674f, -0.05317814f, 0.13763802f, 
    -0.12469713f, 0.13012138f, 0.04653967f, 0.17704982f, -0.17872056f, -0.02759569f, 0.05733751f, -0.06013959f, 
    -0.09535640f, 0.09855901f, -0.02979929f, 0.02983721f, 0.12051849f, -0.38997170f, -0.37460935f, -0.01989055f, 
    -0.05660053f, 0.00055999f, -0.06236286f, -0.04117011f, -0.10842153f, 0.07212811f, -0.62047613f, -0.58208662f, 
    0.11546768f, -0.06306092f, -0.09557336f, -0.05404796f, 0.12267736f, -0.08081595f, 0.07972994f, 0.01767501f, 
    -0.15223747f, -0.00959121f, 0.12226261f, 0.01886692f, 0.17005883f, 0.25896946f, 0.16873194f, -0.00939728f, 
    -0.00022843f, 0.15515694f, 0.04411732f, -0.36008772f, -0.19078901f, -0.21907799f, 0.12583379f, 0.01681853f, 
    -0.01270979f, 0.19205280f, 0.29300839f, 0.32203084f, -0.15041925f, -0.18816450f, -0.12096573f, 0.09852262f, 
    0.04517280f, 0.26109076f, -0.12128425f, -0.21625756f, -0.27600145f, -0.02414199f, -0.03634246f, 0.07632593f, 
    0.05313803f, -0.17237364f, 0.07696074f, 0.06873903f, 0.27693483f, 0.48890755f, 0.03338134f, -0.12927926f, 
    0.12577635f, 0.08743965f, 0.16754784f, 0.09987260f, 0.30878466f, 0.22932951f, 0.13435756f, -0.03427940f, 
    -0.19244632f, 0.12770168f, 0.07609267f, 0.01270305f, 0.07920539f, -0.16259615f, -0.14221543f, -0.04615370f, 
    0.13246584f, 0.02789909f, 0.09756284f, 0.26997390f, 0.07697105f, 0.14422312f, -0.06203617f, -0.29572317f, 
    0.18461107f, -0.33006069f, 0.06867130f, 0.18674780f, 0.08657646f, 0.05771651f, 0.10772580f, -0.48522443f, 
    0.03928649f, 0.14390704f, -0.04550629f, -0.26171604f, -0.34702456f, -0.03753491f, -0.03422823f, -0.01079917f, 
    -0.08385625f, 0.13725170f, 0.36203343f, 0.09130386f, -0.17637604f, -0.13038246f, 0.00022084f, 0.03704440f, 
    -0.04440637f, 0.09805214f, -0.15557010f, 0.32789931f, -0.03191700f, -0.10780746f, 0.13486086f, 0.03330959f, 
    -0.06304558f, 0.09352770f, 0.59775054f, 0.17744730f, 0.10861760f, -0.04499352f, -0.02788697f, 0.40702701f, 
    -0.00841989f, -0.01026212f, 0.03428375f, -0.47061220f, -0.12688372f, -0.16733462f, 0.04194001f, -0.05261889f, 
    0.23786382f, 0.12761894f, -0.05625840f, -0.14595644f, -0.12489775f, 0.33708990f, -0.08038315f, -0.21013287f, 
    -0.08551998f, 0.06092558f, 0.21170999f, 0.08543701f, -0.16664822f, 0.00885519f, 0.15859044f, 0.13685371f, 
    -0.05524379f, -0.16507436f, -0.08415094f, 0.04384735f, -0.01210051f, -0.07437985f, -0.28014821f, 0.07641796f, 
    0.22671054f, -0.18171661f, 0.40166807f, -0.18343565f, 0.19767240f, 0.06491849f, -0.07894354f, 0.31649062f, 
    0.16223243f, 0.07955042f, 0.07702107f, -0.13937746f, -0.01328165f, 0.06192721f, 0.14791788f, 0.16618997f, 
    -0.04207096f, -0.15474164f, 0.01375320f, 0.16268627f, 0.09884193f, 0.03741527f, -0.02290682f, -0.08610944f, 
    0.11637025f, -0.05961699f, -0.24099866f, -0.09974448f, -0.01458239f, -0.06659798f, -0.11999013f, -0.01828948f, 
    -0.18718944f, 0.06039002f, -0.08957427f, 0.18585986f, -0.04591250f, -0.01025655f, -0.06205980f, 0.23326099f, 
    0.06443812f, -0.15209393f, -0.09996389f, -0.32437336f, 0.00814926f, -0.31301147f, -0.12332119f, 0.04035566f, 
    -0.08470961f, 0.06957235f, 0.31298587f, -0.06579104f, -0.21774824f, -0.07126444f, 0.19633640f, 0.11607584f, 
    0.08126120f, -0.20890346f, 0.02833360f, -0.11380994f, 0.09881631f, 0.25587901f, 0.36082360f, 0.12276705f, 
    -0.16771612f, 0.27730516f, 0.19474165f, -0.19731626f, 0.04126240f, 0.12246570f, -0.07548178f, 0.04078392f, 
    -0.26553425f, -0.26332986f, -0.08166133f, -0.07118253f, -0.01184035f, 0.03160405f, -0.04543682f, -0.01265469f, 
    0.18983054f, 0.17337812f, -0.27771518f, -0.01251265f, -0.22812986f, -0.08688615f, -0.01711598f, -0.07626674f, 
    -0.06974451f, -0.07508115f, -0.02503718f, 0.06360999f, -0.05770368f, -0.03956445f, 0.06356008f, 0.08222901f, 
    -0.07862704f, -0.05923995f, -0.06765355f, -0.05537486f, 0.02942373f, -0.03613198f, -0.08510958f, -0.05182484f, 
    0.00538504f, -0.09343789f, -0.08529780f, -0.00298062f, -0.00218767f, -0.00442870f, 0.04909401f, 0.01934866f, 
    -0.03423740f, 0.01661539f, -0.05385794f, -0.00734779f, -0.04983151f, -0.06662323f, -0.03238948f, 0.06725820f, 
    -0.06786957f, -0.01009123f, -0.03118424f, -0.02221867f, 0.03887670f, -0.08209258f, 0.00632423f, 0.00514471f, 
    0.00534988f, 0.07762744f, 0.06272654f, 0.02094885f, 0.00801915f, 0.03228254f, -0.09248196f, 0.00296366f, 
    -0.01720916f, -0.06936115f, 0.03581462f, -0.00109596f, -0.06589491f, 0.05920414f, -0.05732561f, 0.02064734f, 
    -0.07418949f, -0.02061444f, -0.05280150f, -0.01496822f, -0.00300751f, 0.03515956f, 0.02687292f, 0.03747000f, 
    0.05819819f, 0.04802606f, 0.00210951f, -0.05148869f, 0.06822766f, -0.04077203f, 0.01242446f, 0.03340932f, 
    0.05040257f, 0.00382666f, -0.00704456f, -0.08641636f, 0.02341864f, 0.03334874f, -0.03438904f, -0.09676155f, 
    -0.07521245f, -0.04180217f, -0.00338849f, 0.00841785f, -0.03888592f, -0.05647640f, -0.05368842f, -0.00327317f, 
    -0.01025851f, -0.06818736f, 0.06271839f, -0.02602315f, 0.06135726f, -0.06231622f, 0.00274834f, -0.02075608f, 
    0.05451601f, 0.05409226f, -0.03461713f, 0.03660556f, 0.02415602f, 0.05104881f, -0.01669941f, -0.01371027f, 
    0.01579411f, -0.04722551f, 0.02196903f, -0.04857195f, -0.05556602f, -0.00159638f, -0.05878748f, 0.06333469f, 
    -0.04517978f, 0.04751296f, -0.07210693f, 0.03514631f, -0.01575463f, -0.09068360f, -0.05430203f, -0.07460397f, 
    0.07605072f, -0.00417272f, 0.04349649f, 0.02459543f, 0.00382282f, -0.06541450f, -0.02884774f, 0.05622944f, 
    -0.00666537f, 0.02896586f, 0.07561879f, -0.02801120f, -0.02549592f, -0.01054143f, 0.00633614f, -0.04748626f, 
    -0.00525652f, 0.04492877f, 0.03862955f, -0.03097850f, 0.05262717f, -0.04075612f, -0.06790424f, 0.04006717f, 
    -0.33683953f, 0.46307415f, -0.25055227f, 0.04271248f, -0.01560582f, 0.18523417f, 0.11195314f, 0.06805424f, 
    0.03419681f, -0.00960882f, 0.05631963f, 0.14870922f, -0.02887096f, -0.06692670f, -0.19275652f, -0.06452028f, 
    -0.13131723f, 0.06558047f, -0.08536310f, -0.11253063f, 0.22070357f, 0.13150457f, 0.17178071f, -0.04028890f, 
    0.09870360f, 0.06206021f, -0.22529453f, 0.05283457f, 0.07804976f, 0.25906196f, 0.10372953f, 0.07359782f, 
    0.05354197f, -0.06222203f, 0.03811856f, -0.05747876f, -0.10438678f, -0.18825476f, -0.00302571f, 0.06778975f, 
    -0.04109019f, 0.01990020f, -0.05522668f, -0.13032539f, 0.05802386f, 0.10470507f, 0.10799813f, 0.27628377f, 
    -0.14076915f, 0.17793272f, -0.13608666f, 0.13485482f, 0.24150383f, -0.00868774f, -0.07160801f, 0.09412469f, 
    -0.48395851f, -0.03478104f, 0.00719555f, 0.12635066f, 0.11531571f, 0.04902802f, 0.09696651f, 0.03488989f, 
    0.06172717f, -0.00885827f, 0.02432328f, -0.00678315f, 0.07265628f, -0.09020600f, -0.05559320f, -0.25786656f, 
    -0.16222541f, -0.36519596f, -0.02804076f, -0.08128984f, 0.04219545f, -0.25045744f, -0.04478627f, -0.02970002f, 
    -0.30549240f, -0.39362606f, -0.18543127f, 0.15204036f, -0.03099058f, 0.29435274f, 0.14113384f, 0.03759498f, 
    0.08960304f, 0.11514619f, 0.19359009f, 0.05079262f, 0.06520712f, 0.08573189f, 0.00343462f, -0.03957293f, 
    0.01021243f, -0.00169567f, -0.18603265f, 0.19807775f, -0.20022246f, -0.14218383f, 0.12134428f, -0.00275723f, 
    0.04226686f, -0.04829741f, 0.03265567f, -0.04974429f, -0.19959597f, -0.22775988f, -0.29152861f, 0.03603270f, 
    0.15196587f, 0.17936447f, 0.11899626f, 0.04722258f, 0.32005033f, 0.01788350f, 0.24468076f, -0.10275917f, 
    -0.02579984f, -0.07958739f, 0.08224528f, 0.03929589f, -0.20540515f, -0.06903769f, 0.07084116f, 0.09889615f, 
    0.16972342f, 0.28222951f, -0.05620757f, 0.13060197f, 0.04786827f, -0.05829234f, 0.14336661f, 0.04480815f, 
    0.16396715f, -0.27894026f, -0.09595763f, -0.00360310f, 0.14882092f, -0.13769469f, 0.20099291f, -0.12096377f, 
    -0.02851845f, -0.03401000f, 0.02818056f, -0.13823697f, 0.01679768f, 0.14461680f, 0.01387167f, -0.04816033f, 
    -0.10464634f, -0.12247487f, -0.08645110f, 0.39890721f, -0.09289668f, -0.12126587f, -0.00355834f, 0.08833133f, 
    0.08263075f, 0.14759740f, 0.20767213f, 0.12432833f, -0.12102801f, 0.03021995f, 0.07554398f, -0.05077315f, 
    0.14601946f, 0.08905739f, -0.07649767f, -0.48734915f, -0.44639423f, -0.32070273f, -0.22863360f, 0.06417824f, 
    0.07640488f, 0.06356466f, 0.16775498f, -0.00936986f, 0.15526970f, -0.14045359f, -0.03732812f, 0.04424696f, 
    -0.05358192f, -0.05597753f, -0.12478992f, 0.03810878f, 0.07691536f, -0.11128937f, 0.15233089f, -0.25001714f, 
    -0.20708512f, -0.19975853f, -0.35329002f, -0.08511615f, 0.00206501f, 0.05864425f, -0.07250432f, -0.47078890f, 
    -0.02070396f, -0.11738480f, -0.11857734f, 0.07211699f, 0.06828832f, -0.11060813f, 0.07989055f, 0.22050831f, 
    0.19417715f, -0.08735491f, 0.03959486f, 0.27429122f, 0.03835962f, 0.01079591f, 0.12296551f, 0.23644710f, 
    0.06314930f, -0.30806470f, 0.18264076f, -0.19864854f, -0.16109805f, 0.02133072f, 0.18582314f, 0.15048243f, 
    -0.07842315f, -0.24093464f, -0.12257516f, 0.00677199f, 0.01502650f, -0.04561231f, -0.06559003f, -0.10019363f, 
    -0.03014732f, 0.15308180f, 0.48824424f, -0.04779517f, -0.12330534f, 0.10708353f, 0.07143013f, 0.17621812f, 
    -0.11017177f, 0.00772777f, 0.02488728f, 0.27868304f, -0.20762476f, -0.24587050f, 0.09483295f, 0.13216439f, 
    0.12893113f, 0.08457602f, -0.05624255f, -0.06299007f, 0.19429426f, 0.11081238f, -0.08972419f, 0.03745868f, 
    -0.11547051f, -0.05652666f, 0.11620188f, 0.00637635f, 0.02698684f, 0.63433433f, 0.16511716f, -0.01289122f, 
    -0.14610241f, -0.13320562f, 0.20070744f, 0.02246982f, 0.04130204f, 0.00123834f, 0.09641635f, -0.03206626f, 
    0.11633322f, -0.22796993f, -0.22503172f, 0.03032532f, 0.00214862f, 0.06304589f, 0.09763516f, -0.30694425f, 
    -0.33668318f, -0.28578660f, -0.19437404f, -0.05713381f, -0.07618634f, 0.18986823f, -0.23815385f, -0.16515514f, 
    -0.42075810f, -0.04318522f, 0.09090003f, -0.06552023f, 0.06269193f, 0.02383409f, 0.16036162f, -0.16012554f, 
    -0.09038364f, 0.44324461f, 0.11125987f, 0.01630229f, -0.03388614f, 0.10390330f, 0.09186514f, -0.01654294f, 
    -0.10063463f, 0.01386585f, 0.09756997f, 0.06762883f, -0.30508471f, 0.04005724f, -0.09232307f, 0.04087368f, 
    0.22318450f, 0.12188844f, -0.00402423f, 0.40035135f, 0.30532625f, -0.50545067f, -0.17532840f, -0.15053886f, 
    0.21545979f, 0.07894973f, 0.23239297f, 0.01964759f, 0.11688358f, -0.09509108f, 0.31156605f, 0.20590557f, 
    0.05505199f, -0.09509312f, 0.02398662f, 0.04980083f, 0.01998578f, 0.47066650f, -0.13488083f, 0.00809898f, 
    0.19435984f, -0.11250553f, -0.27828047f, 0.23253267f, -0.20237654f, 0.11406234f, -0.27331474f, -0.48922288f, 
    0.13156863f, 0.03709490f, -0.22998336f, 0.09696893f, 0.20012692f, -0.22168635f, 0.00924054f, -0.14965187f, 
    -0.34968662f, -0.21754931f, 0.10702910f, -0.06862353f, 0.00483506f, -0.06386776f, 0.08392580f, -0.02206429f, 
    0.21556640f, 0.22014917f, 0.32456678f, -0.07568748f, -0.05074817f, -0.08485891f, -0.06979242f, -0.10049090f, 
    -0.16557531f, -0.25664058f, -0.14349836f, -0.45787269f, -0.09889764f, 0.08362713f, -0.05889176f, 0.03359968f, 
    0.11140918f, 0.05361738f, 0.17379743f, -0.20011345f, -0.40406319f, 0.00331195f, 0.19398314f, 0.20971638f, 
    0.02257572f, 0.07287708f, 0.11393901f, 0.03641161f, -0.07620049f, -0.07850140f, 0.13987269f, 0.01387448f, 
    0.17293008f, -0.02445700f, 0.04352907f, -0.06581070f, -0.32392368f, 0.01210741f, 0.19288984f, 0.01827538f, 
    0.03293831f, -0.08956980f, 0.03335958f, 0.16018301f, 0.02440589f, 0.18740842f, -0.18223089f, -0.26212502f, 
    -0.01513188f, 0.04823211f, 0.02818769f, 0.03337567f, -0.14561564f, 0.17330499f, 0.14073867f, 0.13548157f, 
    0.20900385f, -0.01547084f, -0.02379368f, 0.06567203f, 0.15261079f, -0.04187667f, -0.00502996f, -0.02014071f, 
    -0.44201019f, 0.11536019f, -0.01766484f, -0.10062834f, -0.21170206f, 0.09769385f, 0.13211331f, 0.03692084f, 
    0.15444651f, 0.33790746f, -0.18382534f, -0.07469749f, -0.07118253f, -0.00885198f, -0.04618673f, 0.07261857f, 
    0.16511594f, 0.07061189f, -0.03287953f, 0.20667903f, -0.04566834f, -0.27435064f, -0.15688670f, 0.13590840f, 
    -0.00599148f, -0.17165953f, -0.33850566f, -0.01684486f, -0.22052217f, 0.08611836f, 0.06755240f, -0.11350588f, 
    0.13760622f, 0.13299894f, -0.16197792f, -0.12646909f, -0.07269412f, -0.60062778f, 0.05409607f, -0.10560941f, 
    -0.12895702f, 0.01704992f, 0.01863509f, -0.23955207f, 0.35156932f, 0.14455250f, 0.03130341f, 0.12853605f, 
    -0.05205435f, 0.15486312f, 0.17576577f, -0.03966448f, -0.06412895f, -0.06774401f, -0.35579914f, -0.06517718f, 
    0.25553465f, 0.01265904f, 0.03730666f, 0.14015937f, -0.11580791f, 0.04727580f, 0.05734659f, 0.28975120f, 
    0.21030273f, -0.27625245f, 0.02675225f, -0.01103490f, 0.07530528f, -0.01615408f, 0.05460433f, 0.06742018f, 
    -0.11674941f, -0.05698776f, 0.14425863f, 0.05571546f, 0.00106641f, -0.09900454f, 0.02614165f, 0.01226731f, 
    0.33563375f, 0.47345147f, 0.12262877f, -0.05803497f, -0.05204283f, 0.15398692f, -0.13206704f, -0.03682512f, 
    -0.02438501f, 0.38682863f, -0.23755933f, -0.44612184f, 0.07956792f, 0.04065329f, 0.01771296f, 0.08175134f, 
    -0.04024535f, -0.00007972f, -0.09753505f, -0.10159045f, -0.08854388f, -0.17281093f, -0.33201987f, -0.04639761f, 
    0.10757592f, 0.17529693f, -0.09388499f, 0.25141034f, 0.02786253f, -0.08643194f, 0.00870585f, -0.01004611f, 
    0.02687245f, -0.00596723f, 0.05051281f, 0.01742829f, 0.26088244f, 0.22606082f, -0.26178083f, 0.16266711f, 
    0.06654859f, 0.15086454f, -0.09630141f, 0.07026716f, 0.08438838f, -0.32683414f, -0.08223601f, 0.00941126f, 
    -0.10641943f, 0.07392491f, -0.03373933f, 0.08450819f, 0.13427000f, 0.07464383f, 0.22855535f, 0.18103288f, 
    0.18176232f, 0.03854482f, 0.15294124f, 0.11506139f, 0.03641491f, -0.08444820f, -0.04791669f, -0.11179970f, 
    0.15706225f, -0.46427706f, 0.13407350f, -0.09057980f, 0.19203483f, 0.02396910f, -0.03641482f, 0.01643646f, 
    0.11891923f, -0.46199328f, 0.50288939f, -0.11683198f, 0.10967115f, -0.18786995f, 0.11355482f, -0.03122267f, 
    0.08760903f, -0.09501234f, 0.24147534f, 0.14020053f, 0.11060347f, 0.11123929f, -0.16785325f, -0.11498737f, 
    -0.12038850f, -0.12826574f, -0.02142543f, 0.06767783f, -0.36134654f, -0.11748099f, -0.05117740f, 0.39458784f, 
    -0.14846267f, 0.04625215f, -0.10353944f, -0.09807031f, -0.01645587f, 0.13709217f, -0.00437510f, 0.25898305f, 
    0.19129525f, 0.06300409f, 0.01730690f, 0.35076895f, 0.05773343f, 0.09316885f, 0.34212795f, -0.02700366f, 
    -0.02359951f, -0.06490921f, 0.06096428f, -0.02468888f, 0.08571786f, -0.28207284f, 0.04309872f, -0.25950077f, 
    -0.03256838f, -0.05239253f, -0.04539855f, -0.03908999f, 0.03192759f, 0.09611315f, -0.18354182f, 0.41381475f, 
    0.58052558f, -0.13089909f, 0.22555211f, -0.40649644f, 0.15686971f, -0.12560795f, -0.05182713f, -0.27806368f, 
    0.07000779f, -0.25588569f, -0.14494936f, 0.02557425f, -0.11332362f, 0.07076111f, -0.08588142f, -0.01044200f, 
    -0.10699763f, 0.06284765f, 0.30589575f, 0.18360497f, 0.14080283f, -0.09058950f, 0.12533507f, -0.42584714f, 
    -0.08473926f, -0.08426806f, 0.05214552f, 0.01484845f, 0.03847556f, -0.05570685f, 0.16859609f, 0.00841214f, 
    -0.00924716f, 0.15605603f, -0.02713721f, 0.23989747f, -0.24760237f, -0.04311789f, 0.09497754f, -0.04694153f, 
    -0.16039985f, -0.00453641f, 0.04006531f, -0.14289851f, 0.28744385f, 0.34151259f, 0.00666715f, 0.05940914f, 
    -0.17720895f, -0.02759604f, 0.19122443f, 0.11145162f, -0.07767507f, -0.00330451f, 0.19361961f, 0.10037537f, 
    0.09362415f, 0.11447919f, -0.10397258f, 0.06831758f, 0.25257167f, -0.00799879f, -0.05234420f, 0.11674339f, 
    0.04403656f, 0.05975742f, 0.11249190f, 0.26267287f, -0.12128425f, -0.09611439f, -0.00950653f, -0.11221481f, 
    0.32058248f, -0.00850199f, -0.06787996f, 0.00620455f, 0.00732877f, 0.06237411f, 0.03143297f, 0.24244705f, 
    -0.20452507f, 0.30654988f, -0.09659547f, 0.01575767f, -0.22942212f, 0.03952067f, 0.03147241f, -0.17978621f, 
    0.48813727f, 0.01144954f, 0.34852630f, -0.04647778f, 0.11211054f, -0.03220855f, 0.00972756f, 0.09677678f, 
    -0.07549752f, -0.18108505f, -0.00407735f, 0.21680175f, -0.01347544f, 0.06511565f, -0.04065555f, 0.05694348f, 
    0.11644612f, -0.00452049f, -0.11475588f, -0.21053994f, -0.52198994f, 0.10947280f, 0.08136773f, -0.05606809f, 
    -0.02431328f, 0.02147992f, 0.17034490f, -0.09822771f, -0.08318686f, 0.08000252f, -0.03470745f, -0.04624940f, 
    -0.03859894f, -0.13474537f, 0.33390656f, 0.05112733f, 0.10707039f, 0.01624095f, 0.37593535f, 0.05732609f, 
    -0.01049229f, -0.08602176f, 0.12469442f, 0.08424813f, 0.04939117f, -0.37759256f, -0.15949009f, -0.09250595f, 
    -0.01298257f, 0.06695043f, -0.00340735f, -0.06045197f, 0.06102543f, -0.06623425f, 0.10580686f, -0.11439308f, 
    -0.10454926f, -0.09356198f, -0.10275682f, 0.24567196f, 0.03826703f, 0.06100180f, -0.11979783f, -0.22570236f, 
    -0.11843348f, -0.21720721f, 0.02739340f, -0.10572068f, -0.21699415f, -0.14819475f, 0.15297407f, 0.20321210f, 
    0.31734219f, 0.03410854f, 0.52482855f, 0.15215343f, 0.01934698f, 0.17541805f, 0.07590094f, 0.08558628f, 
    0.13266866f, -0.19017737f, 0.36305061f, 0.04856586f, 0.22376941f, -0.01167402f, -0.13506067f, -0.08839367f, 
    -0.16340889f, 0.05685244f, -0.19243544f, 0.00024912f, 0.06116215f, 0.11658160f, -0.09475806f, 0.00876510f, 
    0.06176676f, -0.05888267f, 0.01871469f, -0.05615269f, 0.03412478f, 0.08853509f, 0.00387510f, 0.00077957f, 
    -0.04667838f, 0.09426540f, -0.04376070f, -0.08922151f, 0.20094968f, -0.02282141f, -0.07280990f, 0.00283640f, 
    0.14572027f, -0.15934692f, -0.12112541f, 0.01390115f, -0.02447721f, -0.28053614f, -0.21785794f, -0.30112007f, 
    0.29049128f, -0.24423750f, -0.01144317f, 0.15822463f, 0.08357339f, -0.25204971f, 0.23125435f, -0.11027914f, 
    0.27669960f, 0.07596549f, 0.06615797f, 0.04771494f, 0.06518387f, -0.10002870f, 0.03737146f, -0.00613756f, 
    0.10915003f, 0.36333758f, 0.15006955f, 0.04367230f, -0.00772011f, -0.13629895f, 0.18148573f, 0.00628263f, 
    0.16222562f, 0.22317731f, 0.31539112f, 0.14742491f, 0.16358078f, 0.15391997f, 0.04529272f, 0.03028594f, 
    -0.13056386f, -0.65253371f, -0.24025546f, -0.07210736f, -0.04823307f, -0.22749415f, -0.10530806f, -0.01914237f, 
    -0.21376036f, 0.13120817f, 0.54399073f, -0.25666794f, -0.14066583f, -0.04048529f, 0.21098711f, -0.04226223f, 
    0.09498242f, 0.14489980f, 0.05459791f, -0.47009400f, -0.21095157f, 0.08031484f, -0.18369585f, 0.04090432f, 
    0.12390310f, 0.22124405f, -0.04035974f, 0.08231106f, 0.12185454f, -0.01479867f, 0.13508070f, 0.00578787f, 
    0.05862508f, 0.00129473f, 0.12486847f, 0.08808249f, -0.11352495f, -0.29619381f, -0.15180051f, -0.24244009f, 
    -0.14340201f, -0.15270187f, 0.04100497f, 0.03389854f, 0.08160806f, -0.16860996f, -0.02578654f, -0.11617886f, 
    -0.12330444f, -0.09805889f, -0.35932630f, -0.08946817f, 0.00539573f, 0.11676678f, 0.05879833f, -0.37286112f, 
    -0.21665531f, 0.14656855f, 0.02268275f, 0.15431628f, -0.03137274f, 0.04979524f, 0.07838041f, 0.17964299f, 
    -0.56335294f, -0.42774168f, -0.18145727f, -0.07352660f, 0.01792521f, 0.00913854f, -0.17547306f, -0.08911917f, 
    0.10349210f, 0.02834846f, 0.09794280f, 0.12562475f, -0.01095368f, -0.12328658f, -0.32044575f, 0.18838978f, 
    0.07232346f, 0.02648525f, -0.38683406f, -0.18996882f, -0.15013954f, -0.00431712f, 0.01190207f, -0.03166338f, 
    0.03267429f, 0.15655977f, 0.06846929f, 0.11300602f, 0.09957016f, 0.03973416f, -0.04679945f, 0.03677892f, 
    -0.03001418f, 0.13417779f, 0.16653794f, 0.05000388f, -0.07462500f, 0.28093749f, 0.13467672f, 0.06224693f, 
    -0.07167628f, 0.04413703f, 0.16709055f, -0.17010437f, -0.09219811f, 0.01135133f, -0.08950718f, -0.13911730f, 
    -0.17272392f, -0.11739606f, -0.01349091f, -0.13447796f, 0.17045633f, 0.17549965f, -0.11037687f, 0.01294592f, 
    0.13498016f, -0.05098075f, 0.10037341f, -0.13174130f, 0.12823389f, 0.19781488f, -0.06256107f, -0.28423360f, 
    0.31578866f, 0.42149395f, -0.05405830f, -0.08709478f, 0.02679703f, -0.11323748f, 0.10372812f, 0.09078547f, 
    0.02547034f, 0.20121098f, -0.12501363f, -0.11152153f, 0.02079606f, -0.06164380f, 0.21986160f, 0.02769121f, 
    0.01888205f, 0.08985781f, -0.00130944f, -0.29579017f, -0.03277905f, 0.06549262f, -0.21280465f, -0.02068147f, 
    0.05656902f, 0.15607627f, 0.10436756f, -0.36975300f, -0.05054556f, 0.00062315f, -0.00614221f, -0.23193391f, 
    -0.07496204f, -0.08398048f, 0.00925708f, -0.23054396f, -0.48160112f, -0.92246646f, -0.11622041f, -0.03618053f, 
    0.22450352f, 0.10558596f, 0.20362315f, -0.04489012f, 0.18677104f, 0.33345604f, 0.29693109f, -0.07118515f, 
    0.11977220f, 0.05246846f, -0.13988563f, -0.01407319f, -0.01610237f, 0.51447195f, -0.24723808f, -0.29658931f, 
    0.15363023f, -0.14876591f, -0.25408515f, -0.00111094f, 0.04100231f, 0.08426938f, -0.24042690f, -0.75110042f, 
    0.02119975f, -0.18144616f, -0.00094484f, -0.04731651f, 0.13724287f, 0.10999815f, -0.11373949f, -0.42346507f, 
    -0.20820640f, 0.16877396f, -0.00590476f, 0.19687019f, 0.07491630f, 0.07101410f, 0.00413825f, 0.13561103f, 
    0.32188633f, 0.28690067f, 0.11733141f, 0.01026472f, 0.02659210f, -0.07741483f, 0.12855896f, 0.13660850f, 
    0.07470936f, 0.22893018f, -0.54229879f, 0.06550568f, -0.06430879f, -0.15198740f, -0.07853247f, 0.18640932f, 
    -0.17250039f, -0.07192049f, -0.22661705f, -0.61930251f, -0.33911604f, 0.02383475f, -0.17182812f, 0.19870535f, 
    0.05981634f, -0.06257995f, 0.05867459f, 0.22559229f, -0.06578720f, 0.09853724f, -0.13288517f, 0.08777365f, 
    -0.04377927f, -0.01174300f, 0.06364778f, -0.05154711f, -0.04564888f, -0.05455359f, 0.29737869f, -0.09827328f, 
    0.04426660f, 0.00905928f, 0.08625810f, 0.03514734f, 0.04218658f, -0.06230039f, -0.71727103f, -0.24726678f, 
    -0.37538293f, 0.10385267f, 0.19795051f, 0.03287182f, -0.01069617f, 0.01517572f, 0.17592251f, 0.14064205f, 
    0.16679740f, 0.00382855f, 0.18897137f, 0.05491354f, 0.16264442f, -0.03060910f, -0.15757690f, 0.36169025f, 
    0.20161712f, -0.00329408f, -0.23472798f, -0.03841224f, 0.10858265f, -0.09001228f, 0.01445447f, 0.06148587f, 
    -0.13734640f, -0.16500475f, -0.28227726f, -0.14007466f, -0.17267862f, 0.00759822f, 0.06728230f, 0.07098169f, 
    -0.00498765f, 0.13486919f, -0.43489203f, -0.33242044f, 0.08919054f, 0.17069499f, 0.01561936f, 0.11928643f, 
    0.09160840f, 0.02936904f, 0.33955386f, 0.45286107f, -0.14049359f, 0.11578988f, -0.05980468f, 0.08746122f, 
    0.10717025f, -0.02338512f, 0.04581054f, 0.07792615f, -0.15251476f, -0.04077047f, -0.01496973f, 0.02072679f, 
    -0.05059193f, 0.01356157f, -0.03835181f, -0.01869125f, -0.33168444f, -0.13319696f, -0.08388592f, -0.05956340f, 
    -0.00547758f, -0.02859152f, -0.08134212f, 0.03383162f, 0.07422128f, -0.17079048f, -0.04585358f, 0.06506473f, 
    0.08363993f, -0.04242515f, -0.03432766f, -0.01842873f, 0.08774730f, 0.16995981f, 0.02257204f, -0.81171954f, 
    -0.20562771f, 0.17262271f, 0.05497248f, -0.12713677f, 0.09080049f, -0.09134928f, 0.08031101f, 0.23226166f, 
    0.07288414f, -0.04009197f, 0.04777445f, 0.24521160f, -0.03668562f, 0.06583318f, 0.09345940f, 0.13062787f, 
    -0.20608231f, -0.37039506f, -0.61517632f, -0.24358504f, -0.12650959f, -0.18173508f, -0.02594843f, 0.02870050f, 
    -0.04100614f, -0.09529646f, -0.08429234f, 0.19339910f, -0.12489282f, -0.04583527f, 0.08653938f, -0.02209850f, 
    0.09400196f, 0.04753979f, 0.29275113f, -0.30952784f, 0.11912253f, 0.13831311f, 0.12305708f, 0.19031729f, 
    0.05550134f, 0.16377063f, -0.06308857f, -0.25827023f, 0.17447495f, 0.18460071f, 0.00619228f, 0.07692774f, 
    -0.01411020f, 0.09417648f, -0.03499371f, 0.05519489f, 0.05559229f, 0.02915142f, 0.07774290f, -0.06195698f, 
    0.14241284f, 0.04319595f, -0.22337125f, -0.02789108f, 0.09380309f, 0.41733441f, 0.06791574f, -0.11581664f, 
    0.05636390f, -0.06434251f, 0.18090257f, 0.15205011f, -0.18196449f, -0.01336091f, -0.17013532f, -0.08292063f, 
    -0.35179475f, -0.01190011f, 0.06248713f, -0.01195315f, 0.06891834f, 0.00281846f, 0.05232083f, -0.47597528f, 
    0.03538875f, 0.56377292f, 0.09812692f, 0.04554779f, 0.02917525f, 0.04189441f, -0.03461227f, -0.03228170f, 
    -0.20521663f, -0.59004217f, 0.03550838f, -0.18121952f, 0.07734600f, -0.05041248f, 0.12232281f, -0.19212480f, 
    0.07985260f, -0.32811430f, 0.18915360f, 0.22261822f, -0.07937810f, 0.07315227f, 0.17068012f, -0.07172845f, 
    0.10181477f, 0.18901852f, 0.03610479f, -0.19294986f, 0.28253987f, 0.18505555f, -0.00702315f, 0.22039722f, 
    0.11602909f, -0.11164359f, 0.12011244f, 0.46222132f, 0.37783948f, -0.08673311f, -0.10803881f, 0.10980484f, 
    0.19542219f, 0.07999117f, 0.19574575f, -0.12366772f, -0.00328693f, -0.00452036f, -0.23430385f, 0.10076354f, 
    -0.08928692f, 0.09887489f, 0.03339260f, -0.14223072f, -0.04467662f, 0.07326023f, 0.05570004f, 0.07788032f, 
    0.08422031f, -0.15520684f, 0.10595986f, 0.06138641f, -0.33625361f, -0.13176540f, -0.30744749f, -0.13136122f, 
    0.12835670f, -0.04975017f, -0.03310293f, -0.03927774f, 0.04660920f, -0.05500022f, -0.07736397f, 0.03551709f, 
    0.24565728f, 0.02767019f, 0.13271372f, 0.08447579f, 0.10999787f, 0.18282549f, 0.09898877f, 0.07004920f, 
    -0.06308626f, -0.05831137f, 0.06339783f, 0.09625512f, -0.08858109f, 0.17742848f, 0.02949581f, -0.02345773f, 
    0.15463538f, 0.29758871f, -0.13243930f, -0.08806283f, -0.04954766f, -0.31027851f, -0.03458290f, 0.03972603f, 
    -0.10904174f, -0.06875047f, -0.03238950f, 0.40548930f, -0.08155372f, 0.02543654f, 0.04991848f, 0.04775284f, 
    0.06354946f, 0.08847916f, -0.00058518f, 0.34948927f, -0.59663743f, -0.32867387f, 0.10815898f, -0.10246412f, 
    -0.02705336f, 0.03017465f, 0.00667878f, -0.09160542f, 0.10186174f, 0.07623719f, -0.70531559f, 0.18792376f, 
    -0.17705356f, -0.14142781f, 0.01638227f, 0.02481661f, -0.10088677f, 0.22883007f, -0.04545156f, 0.25197020f, 
    -0.04522921f, -0.02011877f, -0.09684417f, 0.04807887f, 0.02238458f, -0.10285709f, -0.08001948f, 0.23115556f, 
    0.06291423f, 0.00323540f, -0.05145327f, -0.06158619f, 0.04864866f, 0.05762354f, 0.11448514f, 0.31108621f, 
    -0.57667559f, -0.42798609f, -0.40966591f, 0.15968730f, -0.18984018f, 0.02803472f, 0.00502248f, -0.05463742f, 
    0.39163470f, -0.05278954f, 0.20958444f, 0.01625747f, 0.16594194f, -0.05318807f, -0.13618517f, -0.14030851f, 
    -0.11027338f, -0.36061630f, 0.01322792f, -0.14863020f, -0.11300773f, 0.14414166f, 0.15131615f, 0.15752856f, 
    0.11644885f, 0.14411367f, -0.02544460f, -0.08239852f, -0.01732452f, -0.04419208f, 0.03287682f, 0.16459352f, 
    -0.15975161f, -0.12887526f, 0.19714241f, -0.36155730f, 0.08194492f, 0.20002562f, -0.02169891f, 0.12455958f, 
    -0.07546064f, 0.08883479f, 0.17449979f, 0.27368268f, 0.09532975f, -0.12011294f, 0.02184453f, -0.17435773f, 
    -0.07332643f, 0.06147492f, 0.07545633f, 0.15821870f, 0.02360624f, -0.52877265f, -0.22412668f, -0.02443463f, 
    0.06725034f, -0.00917016f, 0.00335555f, -0.16745019f, 0.03660588f, -0.38784242f, 0.15096633f, 0.65074116f, 
    0.05323010f, 0.07461934f, 0.29092991f, 0.14361711f, 0.09251228f, 0.16558971f, 0.00708426f, -0.21504851f, 
    -0.05305861f, 0.16846906f, -0.02796054f, -0.09125211f, -0.10663806f, 0.13420096f, 0.20293666f, 0.22489777f, 
    -0.11688208f, -0.00774472f, 0.19967763f, -0.19040905f, -0.08399063f, 0.03741386f, 0.16809292f, 0.16091993f, 
    0.24245487f, -0.05716496f, -0.12860411f, -0.05217062f, 0.12337940f, 0.10670887f, -0.03727562f, -0.12474020f, 
    -0.20632547f, -0.16513558f, -0.26829731f, 0.01491995f, 0.15948887f, 0.00472161f, 0.24806961f, -0.13351455f, 
    0.11266340f, 0.11967672f, 0.15236852f, 0.02629940f, 0.03970031f, -0.26029700f, -0.01739868f, -0.17365845f, 
    0.05590338f, -0.01761017f, -0.02108447f, 0.04983988f, 0.14226271f, -0.06815165f, -0.09017431f, 0.04267349f, 
    -0.04357917f, -0.02304813f, -0.13071766f, -0.23460750f, -0.11284094f, 0.06201657f, 0.14412582f, 0.17073981f, 
    0.04260099f, 0.20381576f, 0.02391438f, -0.17412092f, 0.16453165f, 0.03350735f, 0.28573909f, -0.00031697f, 
    -0.00449134f, 0.01971780f, 0.07813516f, -0.05809970f, -0.09918202f, -0.08389377f, -0.16562639f, -0.04663797f, 
    -0.02595196f, -0.16363658f, 0.00832588f, 0.06136952f, -0.27514106f, 0.17880802f, 0.03800400f, 0.00325521f, 
    0.30556175f, -0.20758165f, -0.05979247f, -0.01549909f, -0.03133642f, -0.06790201f, -0.02999361f, -0.07218737f, 
    0.16124965f, 0.17991121f, 0.33867240f, 0.05815549f, 0.29741290f, 0.01056702f, 0.02649298f, 0.05748185f, 
    -0.14267738f, -0.32459798f, -0.28349572f, 0.18113144f, -0.07761090f, 0.05260980f, 0.00298194f, -0.18741086f, 
    0.10586196f, 0.10605714f, -0.02309038f, -0.08244988f, 0.09736313f, 0.15324228f, -0.01652819f, 0.00626206f, 
    -0.00991327f, -0.10934652f, -0.08087188f, 0.02853435f, 0.21457416f, -0.04262410f, 0.08871087f, 0.07427718f, 
    -0.15937750f, -0.06794804f, 0.02501092f, -0.12364272f, -0.00323324f, -0.07514340f, 0.04190766f, 0.06889687f, 
    -0.09686346f, -0.19326501f, 0.10213120f, -0.09013480f, 0.05252437f, 0.21528828f, 0.24397223f, -0.40545389f, 
    0.12944174f, 0.13534899f, 0.20575207f, -0.14178979f, 0.17327477f, -0.01212396f, -0.14724694f, 0.06708778f, 
    0.12169636f, -0.01863274f, -0.17527375f, -0.05859094f, 0.07931981f, -0.03192093f, -0.17213534f, 0.06239329f, 
    0.01238806f, -0.12193999f, 0.22426836f, -0.13584191f, 0.33975244f, 0.14439255f, 0.19460331f, 0.04134149f, 
    -0.32600406f, 0.08650584f, 0.02258552f, 0.04143107f, 0.02839930f, -0.15320143f, 0.02145989f, 0.11038432f, 
    0.23328373f, 0.07563066f, -0.19765909f, 0.37349299f, -0.18783890f, -0.10997599f, -0.03089757f, 0.06226888f, 
    0.02016696f, 0.15983994f, 0.10178405f, 0.14613828f, 0.05075829f, 0.32478318f, 0.05691813f, -0.01162382f, 
    -0.07004903f, 0.01288481f, -0.13194852f, -0.07595190f, 0.28663510f, -0.15094338f, -0.25570756f, -0.16829406f, 
    -0.06002680f, -0.11820106f, 0.03957454f, -0.00564896f, 0.20165753f, -0.08814380f, -0.14082271f, -0.16949195f, 
    0.04447140f, 0.09823858f, 0.08428537f, 0.00067285f, 0.07858849f, 0.12943810f, 0.21634680f, -0.02285387f, 
    0.09013934f, 0.15119326f, -0.05789766f, -0.31411970f, -0.09065385f, -0.14099438f, 0.23733936f, 0.00591609f, 
    -0.38080251f, -0.20083229f, 0.18031755f, -0.10019828f, -0.12371513f, 0.07301284f, -0.06782578f, -0.09159087f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.09342290f, 0.30891046f, 0.13290384f, -0.04017290f, -0.09939048f, 0.16130343f, 0.08106050f, -0.19320059f, 
    0.17304975f, 0.01904038f, 0.18346873f, -0.09364796f, 0.20577604f, 0.18068166f, -0.08615793f, -0.06009152f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15160426f, -0.04780242f, -0.14323455f, 0.03533706f, 0.20272130f, 0.18243542f, 0.13059336f, -0.22322339f, 
    -0.10722560f, -0.19469279f, 0.05711281f, -0.13951540f, -0.17719895f, -0.05456686f, -0.09876069f, -0.23329359f, 
    -0.04351997f, -0.05311103f, -0.08115217f, -0.22444367f, -0.12228928f, 0.58826429f, -0.17946172f, -0.38258806f, 
    0.48559576f, 0.39718771f, 0.18730623f, -0.35098249f, -0.47063345f, 0.15369110f, 0.55014217f, -0.25771964f, 
    -0.21293953f, -0.11105739f, 0.43095922f, -0.15931234f, 0.10397618f, -0.27181622f, -0.42586854f, 0.41467622f, 
    -0.24346524f, 0.07039201f, -0.34780207f, 0.00612806f, 0.11707624f, 0.03499989f, -0.18453836f, -0.38841629f, 
    -0.08234984f, 0.17709012f, 0.09504608f, 0.10248813f, -0.10784159f, -0.73471957f, -0.22280850f, 0.32928848f, 
    -0.04685565f, 0.08090482f, -0.79229796f, -0.05664482f, 0.09457041f, 0.22021408f, -0.25322831f, -0.34748545f, 
    0.23874645f, 0.32513535f, -0.37519297f, 0.16182345f, 0.02286533f, 0.21392171f, 0.11482963f, -0.25752902f, 
    -0.17285605f, 0.35249200f, 0.34588450f, -0.34684154f, -0.06606215f, -0.04948919f, 0.24993040f, -0.12802385f, 
    0.11104636f, 0.09551797f, -0.02288048f, 0.16775599f, -0.09241418f, 0.06091313f, -0.09464014f, -0.23652405f, 
    -0.26032612f, 0.31236178f, 0.13306648f, 0.41635278f, 0.11323939f, 0.00965769f, 0.31646040f, -0.31592938f, 
    -0.14036462f, 0.18311475f, -0.34735897f, 0.18279944f, 0.31979018f, -0.21228187f, 0.45622885f, -0.34487909f, 
    0.16077743f, 0.11672299f, 0.22267489f, -0.19148868f, 0.36129645f, 0.01376596f, -0.24339956f, -0.03622401f, 
    0.16012432f, 0.09784011f, 0.08920688f, -0.14628477f, 0.22161317f, -0.04407255f, 0.02702911f, 0.37195021f, 
    -0.12434174f, -0.15407822f, -0.19940951f, -0.28117004f, 0.50062710f, -0.23181298f, -0.45388931f, 0.15160863f, 
    0.04396052f, -0.24677694f, -0.06086925f, 0.07915249f, 0.04406898f, 0.31799012f, -0.02544615f, 0.17350660f, 
    -0.42723659f, 0.10500901f, 0.34993240f, -0.26339772f, 0.17363453f, 0.41505164f, 0.22806826f, -0.16711800f, 
    -0.01028832f, 0.26496974f, 0.42309484f, -0.00733129f, -0.15621801f, -0.31473666f, 0.50581896f, -0.21681340f, 
    0.24743502f, -0.37010485f, 0.05663581f, 0.29656121f, 0.28025135f, -0.15174767f, -0.36326215f, -0.10343350f, 
    -0.21832392f, -0.10500605f, -0.00837119f, -0.02984604f, 0.23559155f, -0.40518162f, 0.16340533f, -0.33913592f, 
    0.25840542f, 0.27876332f, -0.04610882f, -0.13241588f, 0.20273092f, 0.12677042f, -0.25359637f, 0.23979366f, 
    0.11741126f, 0.32440078f, 0.16985171f, 0.16516842f, 0.14294842f, -0.74910146f, 0.22601295f, -0.38574499f, 
    0.36233225f, -0.26130143f, -0.22661535f, 0.48660409f, 0.09404471f, 0.13531519f, -0.36728364f, 0.22923644f, 
    0.03862079f, 0.11738953f, -0.11813427f, -0.18211098f, -0.16899091f, -0.04309946f, 0.36337915f, 0.07507406f, 
    0.23340468f, -0.29854378f, 0.26420549f, -0.13809168f, -0.41734096f, 0.05797066f, 0.09090953f, 0.39640912f, 
    -0.14003116f, 0.25152898f, -0.01938521f, -0.03510408f, 0.19825532f, -0.20453319f, 0.18175919f, -0.10967007f, 
    0.35247904f, 0.20688492f, -0.40655029f, -0.30339190f, -0.01317188f, -0.03991481f, -0.47315758f, 0.03786662f, 
    -0.21502450f, -0.02185450f, -0.17794102f, 0.02131775f, -0.14899246f, -0.43208894f, 0.26871175f, -0.59957713f, 
    0.30276495f, -0.11175814f, 0.44330844f, 0.34366521f, 0.04866427f, 0.43257779f, -0.04433710f, 0.06714062f, 
    -0.23924008f, -0.05921844f, -0.12764582f, -0.17984739f, -0.16672429f, 0.01948547f, 0.06178191f, -0.22675273f, 
    -0.16823828f, 0.24349713f, -0.17980379f, -0.03659892f, 0.05264676f, 0.03903928f, -0.11063132f, -0.16975725f, 
    0.02578102f, -0.32481349f, -0.16893274f, 0.19822320f, -0.28723407f, -0.28565943f, -0.13104402f, 0.11414735f, 
    -0.09175668f, -0.03979418f, -0.21043956f, 0.03205820f, -0.05365304f, -0.26281363f, 0.01592941f, -0.02993269f, 
    0.24563655f, 0.17003940f, 0.12528354f, -0.18504436f, -0.47936812f, 0.51187027f, -0.34820539f, 0.45312735f, 
    -0.07945430f, -0.12580448f, 0.10127044f, -0.07407574f, -0.38251415f, -0.39924011f, 0.42319673f, 0.21411394f, 
    0.21998462f, 0.39575326f, -0.38960934f, 0.09473634f, -0.14984176f, 0.15989445f, 0.31784064f, -0.22100334f, 
    0.40067890f, 0.00900388f, 0.24211895f, -0.40147421f, 0.46413270f, -0.68524009f, -0.51285458f, 0.12965620f, 
    -0.11114961f, -0.19910160f, -0.05389735f, 0.11207190f, 0.16135725f, -0.14106217f, -0.04817027f, -0.23124567f, 
    -0.04158089f, -0.02469596f, -0.05223525f, -0.11408249f, -0.06037065f, -0.19871676f, -0.00905910f, 0.02365795f, 
    -0.17376193f, 0.24580050f, 0.08375365f, -0.05943621f, 0.36256385f, 0.56223160f, 0.09119657f, -0.24436872f, 
    0.08875293f, -0.16821069f, 0.10116892f, -0.44956201f, 0.03586752f, -0.00531437f, 0.21577795f, -0.00502825f, 
    0.07674251f, -0.43584323f, -0.43918204f, 0.07588204f, 0.26120034f, 0.02518740f, 0.11567879f, 0.36607197f, 
    0.35339078f, 0.29818296f, -0.25998759f, 0.16355661f, -0.62277699f, 0.12263609f, -0.48089263f, 0.49001551f, 
    -0.16238678f, -0.05124197f, 0.30616507f, -0.25030529f, -0.30807161f, 0.01327046f, 0.62954986f, 0.25596738f, 
    0.31446916f, 0.01712481f, 0.03766553f, -0.58388281f, 0.39028034f, -0.60660923f, -0.41489848f, -0.12003181f, 
    0.14107642f, 0.21004933f, 0.38866967f, 0.23184457f, -0.27614459f, -0.51625305f, -0.21901669f, -0.03496519f, 
    -0.21801901f, 0.12905934f, 0.44371307f, 0.42783028f, 0.12420048f, 0.12797435f, -0.17171989f, -0.21183269f, 
    -0.11311713f, 0.07464038f, 0.42713115f, 0.02861870f, 0.04880914f, -0.46908283f, 0.05206430f, -0.56906402f, 
    0.27342969f, 0.22305791f, -0.11839502f, 0.46335939f, -0.19566962f, -0.11539036f, -0.12220040f, 0.00270098f, 
    -0.01128635f, -0.20970756f, 0.08244845f, -0.06782937f, -0.11040649f, -0.23290980f, -0.07081115f, 0.05841690f, 
    -0.09253740f, -0.09252316f, -0.14131016f, 0.12390119f, -0.05907050f, -0.22666949f, 0.15137860f, -0.08523935f, 
    0.15569638f, 0.38576758f, 0.07547829f, 0.05727476f, 0.37000698f, 0.28366947f, -0.00238890f, -0.21891300f, 
    0.18189579f, 0.04691574f, -0.10072535f, -0.16554816f, -0.02971341f, -0.14403385f, -0.47294605f, 0.42448413f, 
    -0.02713607f, 0.10790312f, -0.03554290f, -0.19154464f, -0.32996920f, -0.07744826f, 0.36796433f, 0.12920810f, 
    0.13945466f, -0.11095668f, 0.56921989f, -0.17693719f, 0.14829469f, -0.06407416f, -0.37639841f, 0.48380232f, 
    -0.24946147f, 0.35620320f, 0.01318793f, 0.08040187f, -0.20030428f, -0.35702819f, 0.41795763f, -0.27346519f, 
    0.10979443f, -0.32621616f, 0.49115258f, 0.06715052f, -0.07589830f, 0.10225397f, -0.22534482f, 0.20729114f, 
    -0.10947879f, 0.06283712f, 0.35780627f, 0.14216807f, 0.01497634f, 0.48800194f, -0.11252043f, -0.03387266f, 
    -0.21331233f, -0.02155254f, 0.46961135f, 0.41108677f, 0.11248419f, -0.18477343f, -0.05250302f, -0.14014769f, 
    0.10306675f, -0.29622057f, 0.01649845f, -0.19135369f, 0.34487721f, -0.25128978f, 0.23134622f, 0.06012202f, 
    -0.14265692f, 0.22233225f, 0.08839861f, -0.50099528f, -0.02977617f, 0.36280370f, -0.21660250f, -0.18969548f, 
    0.05891857f, -0.35652256f, -0.19174612f, 0.00105839f, -0.21965417f, -0.25384822f, 0.26428777f, -0.33585602f, 
    0.24181916f, -0.04226564f, 0.37801331f, -0.69737345f, 0.14622732f, 0.20218346f, 0.28787658f, 0.06059390f, 
    -0.07240406f, 0.29405001f, -0.25652477f, 0.02507614f, 0.52339524f, -0.20989907f, 0.36200196f, 0.01866082f, 
    0.46210021f, -0.26776132f, 0.02926047f, 0.46531323f, -0.23673604f, -0.04322616f, -0.46595818f, 0.11490504f, 
    0.07895080f, 0.06642944f, -0.29831898f, 0.09968349f, 0.00537199f, -0.28227672f, 0.06240850f, 0.03686519f, 
    0.29394400f, 0.13481921f, 0.24683034f, 0.06215796f, -0.27639139f, 0.46151593f, 0.22700207f, 0.10086448f, 
    -0.08908266f, 0.00384329f, -0.16421467f, 0.09003991f, 0.02149292f, 0.21502365f, -0.10818537f, -0.09918679f, 
    -0.03424183f, 0.08167636f, -0.04748306f, 0.08498444f, 0.02792486f, -0.26049238f, -0.18959650f, 0.00677211f, 
    -0.14856672f, 0.09454243f, 0.12357759f, 0.20419355f, -0.30670810f, 0.56352752f, -0.08905153f, -0.19201800f, 
    -0.33513209f, 0.34977263f, 0.14705709f, 0.32439595f, -0.00407076f, -0.04622900f, 0.17889221f, -0.06060381f, 
    0.16687134f, 0.28772709f, 0.12831250f, -0.09061731f, -0.21157752f, 0.48307309f, -0.33522180f, -0.04065529f, 
    0.22713427f, 0.23178571f, 0.14693835f, -0.45451391f, 0.33944127f, -0.39303172f, -0.03415941f, -0.01667710f, 
    -0.16486497f, 0.39268735f, 0.09349538f, 0.20000683f, 0.19299915f, -0.09164672f, -0.54491770f, 0.33221063f, 
    0.08965297f, -0.36737910f, -0.00583301f, -0.04884123f, 0.11700469f, -0.33416629f, -0.18244322f, 0.27594888f, 
    -0.08498135f, 0.29219633f, 0.24402678f, -0.03922233f, 0.48896530f, -0.29318109f, 0.35706919f, 0.26475134f, 
    0.13432637f, -0.01156242f, -0.51633388f, -0.25710261f, -0.13109580f, -0.17065263f, -0.25341240f, 0.44308305f, 
    -0.18890935f, -0.03436872f, 0.14905192f, -0.06128800f, 0.37733302f, 0.21675760f, -0.82685417f, -0.08147404f, 
    -1.11842871f, 0.04919993f, -0.29725379f, -0.22265182f, -0.03328416f, -0.13607579f, -0.16179831f, -0.01985087f, 
    0.23418531f, 0.03699386f, -0.23113210f, -0.11237053f, -0.58311743f, 0.07744282f, 0.43876204f, -0.30632219f, 
    0.26641658f, 0.02780548f, 0.53719491f, -0.36608994f, 0.09530686f, 0.00971704f, 0.56149042f, -0.25700483f, 
    -0.18556085f, 0.18047775f, -0.12968801f, -0.15085530f, -0.18726033f, 0.69728243f, 0.25286478f, 0.27310908f, 
    0.01465076f, -0.08034372f, -0.28005415f, 0.19383964f, -0.42119840f, -0.06282490f, 0.33752581f, 0.28501281f, 
    0.08961055f, -0.09037576f, -0.11832862f, -0.06461746f, -0.08460950f, 0.28596792f, 0.07721835f, 0.06297048f, 
    -0.05324552f, -0.15478936f, -0.18244252f, 0.22469467f, 0.01615892f, -0.23823406f, 0.23738037f, 0.17172399f, 
    0.14550439f, 0.32524973f, 0.16211298f, 0.23284012f, -0.16299458f, -0.21086794f, -0.39450061f, -0.29847386f, 
    0.41088542f, 0.28776217f, 0.06064007f, -0.24383266f, 0.00014830f, 0.13448383f, -0.21230474f, 0.19903970f, 
    -0.01940392f, -0.10926427f, 0.10174440f, 0.08678786f, -0.15454060f, -0.00703522f, -0.38104188f, 0.29812726f, 
    -0.13979140f, 0.46868223f, 0.36573198f, 0.29380506f, -0.12366124f, 0.42997813f, -0.09172542f, 0.18129480f, 
    -0.02100680f, -0.05294236f, -0.17688708f, 0.06853637f, -0.00662788f, 0.15445158f, 0.46030122f, -0.29709226f, 
    -0.22132489f, 0.38862935f, -0.22268650f, 0.30585355f, 0.23410031f, 0.17770818f, -0.05771928f, 0.15340979f, 
    0.20944968f, 0.53545302f, -0.46355921f, -0.04961700f, -0.16436873f, -0.26122653f, 0.07901218f, -0.16424014f, 
    0.34073603f, -0.40369067f, 0.65044606f, 0.05293867f, -0.32556769f, -0.03795722f, -0.27462217f, 0.40812716f, 
    0.08369099f, -0.16752611f, 0.01272057f, -0.15942492f, -0.00267123f, -0.18887433f, 0.04503882f, -0.16106223f, 
    -0.18206516f, -0.08236958f, 0.08294789f, 0.01121968f, -0.16250081f, 0.02096969f, -0.08828242f, 0.19289744f, 
    0.15320012f, 0.26933011f, 0.27799284f, -0.20843112f, 0.07275246f, 0.41405305f, 0.31952196f, -0.29825163f, 
    0.05721787f, 0.24524000f, 0.02030336f, -0.20637751f, 0.07718306f, 0.02515966f, 0.20322560f, -0.34972653f, 
    0.09911860f, 0.53279573f, -0.31859264f, -0.20471594f, 0.51910663f, 0.54175287f, -0.03141431f, -0.26673189f, 
    0.52426165f, -0.18378855f, -0.16597106f, -0.06973211f, -0.12389965f, -0.68072814f, -0.43284789f, 0.43795317f, 
    0.07983306f, -0.20343547f, -0.07573891f, 0.12279361f, 0.17775671f, 0.26209286f, 0.32289797f, -0.08003896f, 
    0.06878076f, 0.31016475f, 0.09221093f, 0.53927821f, -0.25376400f, 0.42725793f, 0.11518437f, -0.26806948f, 
    -0.00516098f, -0.24756002f, -0.17153837f, 0.15025462f, -0.07151248f, 0.18462498f, 0.00990715f, -0.10344963f, 
    0.00752135f, -0.13545710f, 0.08971683f, -0.09755419f, 0.03670086f, -0.01435142f, -0.03668552f, 0.02360973f, 
    0.13053851f, 0.22530295f, 0.09915312f, 0.19625995f, -0.53951460f, -0.36280519f, 0.54253513f, 0.07984126f, 
    0.29212195f, -0.17319539f, 0.49872255f, 0.36535719f, -0.32875076f, 0.08774044f, 0.50083536f, -0.07892186f, 
    -0.09343179f, -0.01903563f, -0.14280860f, -0.13899362f, -0.14636417f, 0.54487926f, 0.41233677f, -0.12376908f, 
    -0.43287322f, 0.00736941f, 0.39801624f, 0.24877064f, 0.10841862f, 0.18829623f, 0.40622574f, -0.20460629f, 
    -0.20666483f, 0.16114390f, 0.14597481f, -0.17657197f, 0.23338169f, -0.42671737f, -0.76958203f, 0.05355497f, 
    -0.25381514f, -0.12429494f, -0.50551200f, 0.28951013f, 0.23744991f, 0.00267093f, 0.15815663f, 0.01962555f, 
    -0.17859939f, 0.00060831f, -0.06457508f, -0.05804684f, 0.03455845f, 0.42984605f, 0.08107077f, -0.05019556f, 
    0.41437897f, 0.52376509f, -0.46215615f, 0.09769802f, -0.59762007f, 0.30547100f, 0.21853633f, -0.05714798f, 
    -0.08114576f, -0.07379393f, 0.32563910f, 0.01135422f, 0.18522005f, 0.73246700f, 0.11633898f, 0.05212798f, 
    0.06599215f, 0.02638690f, -0.79050648f, 0.36737666f, 0.16193379f, -0.07904004f, -0.15331711f, -0.17561218f, 
    -0.23305067f, -0.16698973f, 0.01934248f, 0.21078771f, 0.01619495f, 0.71704853f, 0.10653134f, 0.27809238f, 
    -0.25345886f, 0.34753513f, 0.15257268f, -0.10403651f, -0.08265464f, -0.07916109f, 0.51049566f, -0.26387832f, 
    0.24967194f, -0.24363661f, -0.22949627f, 0.21304527f, -0.04994640f, -0.17938513f, 0.04457381f, 0.01733693f, 
    -0.14887187f, 0.06510547f, -0.26081148f, 0.02858658f, -0.18341458f, 0.11468110f, -0.27002761f, -0.06693614f, 
    0.22248352f, 0.17677052f, -0.09170733f, -0.24395947f, -0.00247980f, 0.73242468f, 0.17521770f, 0.17529137f, 
    0.15732504f, 0.20064060f, -0.28658649f, 0.02573533f, -0.50336820f, -0.22317624f, -0.57040894f, 0.26036078f, 
    -0.05505319f, -0.17905098f, -0.23364009f, 0.12662145f, 0.10546218f, -0.59936935f, 0.08126139f, -0.55025905f, 
    0.32296541f, -0.00445780f, -0.22690129f, 0.54116476f, 0.22728510f, 0.21520717f, 0.22715999f, 0.16803463f, 
    -0.03462368f, 0.31615388f, -0.15073307f, 0.24454711f, -0.41126239f, 0.21890461f, -0.16004588f, -0.22621804f, 
    0.16571760f, 0.20051564f, 0.48684725f, -0.41320455f, -0.22465411f, -0.33541733f, 0.51774722f, 0.01473916f, 
    0.16732977f, 0.07406181f, 0.16792279f, 0.23404564f, 0.09108113f, 0.08466776f, -0.01378494f, -0.38289800f, 
    0.44311967f, 0.21312976f, 0.15046513f, -0.26473397f, 0.22155398f, -0.11918484f, -0.05029578f, -0.00684067f, 
    -0.07462306f, 0.10917404f, -0.01218412f, -0.23143944f, -0.31522316f, -0.49259880f, 0.29221436f, 0.20612685f, 
    0.08775297f, -0.24374528f, 0.06713889f, -0.05350611f, -0.32238087f, 0.23374207f, 0.37576056f, 0.27788186f, 
    0.21899867f, 0.12017816f, -0.00534130f, -0.23325348f, 0.34766385f, 0.05256794f, 0.26758695f, 0.22680308f, 
    0.00860138f, -0.11394613f, -0.15310384f, 0.02508890f, 0.29362878f, -0.21964085f, -0.45333141f, 0.57706112f, 
    0.22264445f, 0.18213023f, -0.37616649f, 0.18007560f, 0.34521797f, 0.38560486f, 0.56181443f, -0.31067979f, 
    0.00256347f, 0.21548599f, 0.18653828f, -0.20750840f, 0.30542049f, -0.26643685f, -0.13247739f, 0.00079894f, 
    -0.08819984f, 0.33609304f, -0.59892774f, -0.04846913f, 0.16746160f, -0.29222792f, -0.06219254f, 0.05969203f, 
    0.46938986f, 0.07720752f, -0.20215698f, -0.41758138f, -0.25038394f, -0.09777378f, -0.19065228f, 0.29588082f, 
    0.15608394f, 0.13839571f, -0.07531232f, 0.02906040f, -0.05663448f, -0.01858484f, 0.35928154f, 0.31662548f, 
    -0.01209682f, 0.00786211f, 0.32582337f, 0.16654597f, -0.24858280f, -0.14398804f, -0.37289736f, 0.08135466f, 
    0.17383936f, -0.04204814f, -0.21723741f, -0.05695620f, 0.10118224f, -0.49251565f, 0.18143767f, -0.14341360f, 
    0.10517299f, 0.06537414f, -0.11324432f, 0.28047675f, -0.17516729f, 0.40615860f, -0.01755776f, 0.34455207f, 
    0.10869372f, 0.19873057f, 0.08567668f, 0.10662659f, 0.53684789f, 0.18957844f, 0.28792554f, -0.26795247f, 
    0.37765381f, -0.28919718f, -0.68264794f, -0.30683216f, -0.26213205f, 0.28164715f, -0.23521431f, 0.07540935f, 
    0.17862326f, 0.02492979f, 0.35386270f, -0.02869997f, -0.19453992f, 0.03154366f, 0.39379025f, 0.58922923f, 
    -0.32810035f, 0.14714752f, 0.23730229f, 0.32819787f, -0.22551525f, 0.16053748f, -0.33799294f, 0.00679171f, 
    0.03549582f, 0.03595725f, 0.29904214f, 0.22528449f, 0.06864672f, 0.67333215f, 0.42192340f, -0.08350448f, 
    -0.10307975f, -0.09795895f, -0.19890404f, 0.60290736f, 0.25199211f, -0.36533502f, 0.15042034f, -0.33018726f, 
    0.24147373f, -0.16544490f, -0.35679981f, -0.13646172f, 0.35072559f, -0.19515295f, 0.17478400f, 0.27792183f, 
    0.19368160f, -0.05566675f, -0.00757468f, 0.27872884f, -0.62362880f, 0.25944898f, -0.45002404f, 0.50015950f, 
    0.04919156f, -0.35408184f, -0.21331276f, 0.11675438f, -0.08008725f, -0.25389943f, -0.01583469f, 0.41377139f, 
    0.23705469f, -0.23046345f, -0.04035777f, 0.55413729f, -0.25395307f, -0.45842129f, -0.21979396f, 0.31556597f, 
    0.08857088f, -0.07775972f, 0.21936794f, -0.06610963f, -0.05902145f, 0.51953876f, -0.29869598f, 0.01969611f, 
    0.42381874f, 0.55108559f, -0.30060565f, 0.26250696f, -0.33538216f, 0.13187218f, 0.00457699f, -0.21471213f, 
    0.14905114f, -0.28232285f, 0.18396591f, 0.07224116f, -0.44335106f, -0.05389803f, 0.36818069f, 0.46978799f, 
    0.13962893f, 0.07884849f, 0.47052228f, 0.06895103f, -0.01126895f, -0.09831096f, 0.18384875f, 0.18099308f, 
    0.17127967f, 0.03472993f, 0.10071131f, -0.14579037f, -0.16794017f, 0.10292771f, -0.30103776f, -0.31054240f, 
    -0.03415436f, -0.19078599f, 0.22568551f, 0.14976467f, -0.09917495f, 0.00108273f, -0.21658739f, -0.03710409f, 
    0.21661347f, 0.24503051f, -0.35509437f, -0.13836962f, 0.08904399f, 0.69067752f, -0.20189491f, -0.00027327f, 
    0.03895209f, 0.01636923f, 0.41433728f, -0.15592426f, -0.26886958f, -0.41860586f, 0.29992998f, 0.16846973f, 
    -0.22828615f, 0.11130399f, -0.09591026f, -0.08894533f, -0.21090788f, 0.07425115f, -0.00494592f, -0.10404936f, 
    -0.15199892f, 0.00910846f, -0.23106019f, -0.05513291f, -0.11269108f, -0.02764332f, 0.06288803f, -0.24480233f, 
    -0.23361954f, 0.25076649f, 0.01842787f, -0.18305393f, -0.79654682f, -0.21448064f, 0.13486604f, 0.21048704f, 
    0.01615247f, -0.14488535f, 0.70995623f, -0.07241875f, 0.23152408f, -0.55644840f, 0.20916061f, -0.13719644f, 
    -0.06384860f, 0.16388729f, 0.19524318f, 0.24317981f, -0.09689007f, -0.14497854f, 0.09972255f, 0.21380055f, 
    -0.14230019f, 0.17245615f, 0.10736871f, 0.27086931f, 0.14393876f, -0.22398253f, -0.69147408f, 0.39727905f, 
    -0.02616237f, 0.23111802f, 0.00030968f, -0.19465479f, 0.08319864f, -0.33171546f, -0.18708308f, 0.13270076f, 
    -0.36847231f, -0.03742817f, 0.41389805f, 0.15665293f, 0.29786527f, -0.12824439f, -0.13421510f, 0.13112776f, 
    -0.04794190f, -0.01316107f, -0.08828473f, -0.14043033f, -0.23297670f, 0.42271155f, 0.33411443f, 0.42773405f, 
    -0.28262976f, 0.10027836f, -0.05453373f, 0.13214131f, 0.02166335f, 0.15367080f, 0.39353237f, -0.18955740f, 
    -0.20674363f, 0.18230061f, 0.03372261f, 0.02285026f, 0.23256597f, -0.09305383f, -0.23326550f, -0.30937278f, 
    0.34390628f, -0.00525157f, -0.22199954f, -0.08065927f, -0.22235343f, 0.27150881f, -0.13699654f, 0.05561749f, 
    -0.22622591f, -0.19529265f, 0.53181601f, -0.19231850f, -0.28612775f, -0.20545754f, -0.03544214f, 0.02122383f, 
    0.30018705f, -0.25928593f, 0.59551263f, -0.12373915f, 0.49666429f, -0.47384062f, -0.25680998f, -0.11017522f, 
    0.02162983f, 0.15498231f, 0.32709941f, -0.14547013f, 0.26956293f, 0.67706698f, 0.32234403f, -0.13079289f, 
    -0.09045424f, 0.08504804f, -0.01244287f, -0.26480776f, 0.30703750f, -0.43771255f, 0.18425831f, 0.02533060f, 
    -0.19585365f, 0.13251829f, 0.33872765f, -0.04989082f, -0.34226349f, 0.30346432f, 0.02643858f, -0.34769344f, 
    -0.00847694f, -0.08599789f, 0.63405079f, -0.25433317f, 0.06306115f, -0.28013760f, 0.44672352f, -0.03385339f, 
    0.20331666f, -0.14096674f, 0.33335301f, 0.23458365f, 0.24749596f, 0.37205726f, 0.15083624f, 0.13362259f, 
    -0.04095623f, -0.21775489f, -0.16353309f, 0.62405676f, 0.00190396f, 0.13094684f, -0.00755852f, 0.05716014f, 
    -0.02697835f, 0.24527185f, -0.14553776f, 0.07852376f, -0.21381627f, -0.45149168f, -0.28985420f, 0.10426062f, 
    0.02766042f, 0.18441930f, 0.10121152f, -0.36318955f, -0.07440371f, -0.03479400f, 0.44594604f, -0.10375797f, 
    0.14064644f, -0.18100104f, 0.32290298f, -0.22055705f, 0.10567024f, -0.34842017f, 0.15431365f, -0.48100543f, 
    0.03308629f, 0.33125749f, 0.22458041f, 0.47814655f, -0.14856479f, 0.36556628f, -0.20185323f, -0.04134801f, 
    -0.07218061f, 0.48499504f, -0.51967591f, -0.03828074f, -0.10438295f, -0.11785620f, 0.39133406f, -0.28246623f, 
    0.38905758f, -0.21414602f, 0.20481984f, -0.21503654f, 0.11368794f, -0.33500507f, -0.06382497f, 0.00476746f, 
    -0.23074402f, -0.20745791f, 0.23540409f, 0.15086631f, 0.37185121f, 0.00337073f, -0.06096163f, 0.04332108f, 
    0.28488371f, 0.48160961f, -0.34550425f, -0.15645629f, -0.33757493f, 0.22291136f, 0.20279297f, -0.27818605f, 
    0.24651751f, -0.21715461f, -0.21492447f, 0.20946759f, 0.36224258f, -0.27938738f, 0.04021519f, 0.33474186f, 
    0.39315280f, 0.13502464f, -0.24651755f, -0.11242232f, -0.63191390f, 0.34485134f, 0.06529254f, 0.18403549f, 
    -0.03910266f, 0.26528689f, -0.20065136f, -0.02254238f, 0.19464396f, 0.12175747f, 0.08187360f, 0.19889835f, 
    0.07194049f, 0.39965397f, -0.13741304f, 0.20165876f, -0.40892848f, -0.31269163f, -0.38270289f, -0.18013747f, 
    0.15919618f, -0.06948204f, 0.26411012f, 0.12858345f, 0.20954226f, 0.00779797f, -0.10254578f, 0.42598212f, 
    0.14329425f, -0.32474965f, -0.39686358f, 0.27434874f, -0.12275649f, -0.04484443f, -0.18208513f, 0.00767635f, 
    0.21518774f, -0.35917962f, 0.31248620f, -0.11613864f, -0.02684365f, 0.46011150f, 0.03013103f, 0.45017701f, 
    0.10654808f, 0.16381112f, -0.15450336f, 0.11290819f, 0.00346169f, 0.08623720f, 0.15076745f, -0.31087837f, 
    -0.12129813f, 0.09049772f, -0.19840221f, -0.17888904f, -0.08192867f, -0.30138585f, 0.49381918f, 0.10434175f, 
    0.21067627f, -0.17365122f, -0.27876118f, -0.46196216f, 0.20489033f, -0.17892477f, 0.44645730f, 0.09148135f, 
    0.19813746f, 0.20917359f, 0.03084880f, 0.13367246f, -0.31230277f, -0.37778437f, -0.14979099f, 0.19759247f, 
    -0.37399349f, 0.39738986f, -0.27728677f, 0.04921144f, 0.11690988f, 0.29267731f, -0.05419395f, -0.24397905f, 
    -0.09538153f, 0.19619088f, -0.00214156f, -0.18559954f, 0.00434090f, -0.17185608f, -0.40356478f, 0.22149619f, 
    -0.31780666f, 0.00148538f, 0.39628318f, -0.30393124f, -0.13657087f, 0.50517422f, -0.12536700f, 0.24125813f, 
    -0.08179586f, 0.51251721f, -0.03804047f, 0.15105943f, 0.12007684f, -0.17922436f, -0.40712866f, 0.10575733f, 
    -0.18787828f, -0.26286867f, 0.37475723f, -0.17867933f, -0.03372598f, -0.05005885f, -0.30175501f, 0.31544730f, 
    0.23304830f, -0.30172449f, 0.52712417f, 0.11867222f, 0.31467250f, 0.72609544f, 0.21843906f, -0.04892078f, 
    0.17730528f, -0.04055583f, -0.06728098f, -0.55205816f, -0.06722955f, -0.08920610f, -0.51959592f, -0.22000822f, 
    0.00193546f, -0.15862422f, 0.35107026f, -0.25456047f, -0.23858462f, 0.31122360f, -0.24375802f, -0.31379738f, 
    0.22088099f, -0.19379595f, 0.70685011f, -0.16722460f, 0.28003308f, -0.32342792f, 0.25693482f, 0.10053241f, 
    0.20043275f, -0.03384983f, 0.41619906f, -0.22084461f, 0.01128408f, 0.36209795f, 0.02794205f, 0.03747158f, 
    -0.02421518f, -0.39966589f, -0.29109272f, -0.50042289f, 0.29855412f, -0.33194685f, 0.12986328f, -0.06150368f, 
    -0.13613388f, 0.16150101f, -0.15855701f, -0.19033177f, 0.10657724f, 0.04509323f, 0.44195238f, 0.48382282f, 
    -0.25413832f, 0.33164698f, -0.22901213f, 0.53090632f, -0.44747931f, 0.20839246f, 0.17201073f, -0.09392941f, 
    -0.10856338f, 0.17367657f, 0.08557862f, -0.12115795f, -0.01624436f, 0.48191568f, 0.40026730f, -0.22989486f, 
    0.10822465f, -0.09646402f, 0.26833898f, -0.06449061f, 0.18875624f, 0.09129506f, 0.29821345f, -0.31249619f, 
    -0.02920917f, -0.27496812f, 0.42805091f, 0.10902201f, 0.15896469f, -0.24906367f, -0.12571000f, -0.37863332f, 
    0.13731478f, 0.11279383f, 0.19009615f, 0.54444605f, -0.10136401f, 0.12553674f, 0.04379043f, -0.07996689f, 
    -0.07905938f, -0.01179335f, -0.20966715f, -0.13218638f, -0.41074148f, -0.43141973f, 0.29124838f, 0.04827576f, 
    0.04445596f, 0.52846998f, 0.37729219f, 0.44747618f, -0.45129764f, -0.35280108f, 0.11160640f, -0.23022354f, 
    -0.03149987f, 0.13360420f, -0.31407428f, 0.17838234f, -0.26820910f, 0.51774913f, 0.18611483f, 0.06243964f, 
    0.14889856f, -0.02062111f, 0.26755705f, 0.10005248f, -0.13339600f, -0.38321435f, 0.27089053f, 0.02954350f, 
    -0.09508518f, 0.06018772f, 0.10786518f, 0.18909732f, -0.00338354f, -0.00712896f, -0.06945319f, -0.07641278f, 
    0.07693227f, 0.48545501f, -0.04702959f, 0.50292856f, -0.34360337f, 0.52315170f, -0.21605049f, -0.15333033f, 
    0.22504339f, 0.26429600f, -0.48042235f, 0.18738893f, 0.08862762f, 0.30118141f, 0.43794170f, 0.04865836f, 
    0.07071909f, -0.12250460f, -0.07056555f, -0.31304526f, -0.53361565f, 0.00691379f, 0.31399518f, 0.30095077f, 
    0.05726492f, -0.12462246f, 0.23756951f, -0.04755014f, 0.38624030f, 0.05663390f, 0.31391510f, 0.24298142f, 
    -0.08402493f, -0.19257128f, -0.02282334f, 0.47202983f, 0.24889000f, -0.24777474f, -0.14640114f, 0.23879699f, 
    0.09838194f, -0.29977822f, -0.02393117f, 0.09482238f, 0.05738111f, -0.05363819f, -0.17110217f, 0.18706349f, 
    -0.04215609f, -0.22446056f, -0.09922460f, 0.03295524f, -0.04319236f, -0.13584155f, -0.08178040f, -0.05057770f, 
    -0.05314182f, -0.29824758f, -0.28164697f, 0.15516865f, -0.07045623f, -0.17985041f, 0.30370340f, -0.14608772f, 
    0.27732319f, 0.46811661f, 0.11279258f, -0.20650198f, -0.06147926f, 0.43158683f, -0.08417249f, -0.03110197f, 
    -0.07328782f, 0.10294620f, -0.10998234f, -0.16241384f, 0.05175268f, 0.14755566f, 0.58686513f, 0.23244123f, 
    -0.23097970f, -0.05181671f, 0.06687669f, 0.10258652f, 0.30937964f, 0.02041534f, -0.37791148f, 0.06541417f, 
    0.05001206f, 0.00188972f, 0.13790667f, 0.21253671f, 0.31461322f, 0.43366963f, -0.27613696f, -0.05282769f, 
    -0.25931433f, 0.34924302f, -0.23042460f, 0.09290273f, 0.34524521f, -0.25064781f, 0.09738320f, 0.05754507f, 
    0.24598493f, 0.18292454f, 0.22220162f, 0.23259123f, -0.27017072f, 0.16252436f, 0.45790127f, -0.02644119f, 
    -0.02505008f, -0.08856478f, -0.16862382f, -0.27126402f, 0.28183475f, -0.17158991f, 0.03377953f, 0.01397520f, 
    -0.01230229f, -0.15494829f, 0.22502163f, -0.07714918f, 0.10351134f, 0.77767915f, 0.05667067f, 0.13001090f, 
    -0.04119095f, 0.22272834f, -0.51093364f, 0.28661919f, 0.16530059f, 0.05656241f, -0.37470704f, 0.14383477f, 
    -0.14408137f, 0.26413438f, -0.12361251f, 0.19055602f, 0.00058094f, 0.17356674f, -0.37624350f, -0.14422737f, 
    0.36321312f, 0.20884754f, -0.37592167f, -0.28402159f, -0.12945250f, 0.05773185f, -0.01730382f, 0.40989092f, 
    -0.04031277f, -0.07787572f, -0.33991441f, 0.14424242f, -0.02086002f, 0.05098955f, -0.08572917f, 0.02016207f, 
    -0.11360545f, -0.21717666f, -0.05626668f, -0.16310062f, -0.03498276f, -0.00061043f, 0.05621827f, 0.07458460f, 
    0.13175017f, -0.02500510f, -0.16270468f, 0.11436129f, 0.03403136f, 0.11534978f, -0.11786368f, 0.10553968f, 
    0.01142114f, -0.22958857f, -0.22329718f, -0.08614238f, -0.26360944f, -0.21815133f, 0.14100173f, -0.20355931f, 
    -0.09702315f, 0.32467934f, -0.21635967f, 0.11097459f, -0.11834929f, 0.24242978f, -0.06575540f, 0.18070626f, 
    0.05451377f, -0.25043118f, -0.03491308f, -0.13427524f, 0.39984879f, -0.27394196f, -0.02387425f, 0.17502330f, 
    0.12030722f, -0.31972069f, -0.11862778f, -0.20941332f, 0.08566895f, -0.05559971f, -0.32467279f, -0.31455430f, 
    0.37085059f, 0.48238948f, -0.16077475f, 0.03964784f, 0.18239881f, 0.14903283f, 0.41141540f, 0.32440192f, 
    -0.00870916f, -0.16353080f, 0.33287373f, -0.04784231f, 0.02441106f, -0.52858937f, 0.13419910f, -0.03820079f, 
    0.10128351f, -0.04559490f, 0.12223101f, 0.54309845f, -0.08211563f, -0.28884026f, 0.07054969f, -0.14872999f, 
    -0.11375140f, 0.52034825f, -0.18893068f, 0.09439225f, -0.02585988f, -0.21473087f, -0.40214482f, 0.22003059f, 
    -0.09379073f, 0.04741384f, -0.01786292f, -0.38828209f, -0.00779597f, 0.10068434f, -0.43764883f, 0.43162146f, 
    -0.08569053f, 0.03447738f, 0.20985731f, 0.23712203f, -0.55743963f, 0.20946929f, 0.15391028f, 0.38790494f, 
    0.26601702f, -0.24954601f, 0.55252469f, 0.10082474f, -0.25193366f, -0.04201826f, 0.23576348f, 0.04089710f, 
    0.04164240f, 0.10565057f, -0.17875707f, 0.16156234f, -0.24235442f, 0.42729351f, -0.18665382f, 0.18061379f, 
    -0.19217031f, 0.08574792f, -0.08944881f, 0.06592055f, 0.12860246f, 0.30715573f, -0.36667565f, 0.16711366f, 
    -0.18110397f, -0.16752121f, 0.07897753f, 0.02133746f, 0.04968768f, -0.02701136f, -0.17279600f, -0.43902266f, 
    0.44677323f, 0.35742238f, 0.18427359f, 0.12759775f, 0.08712468f, 0.18441384f, -0.48892808f, 0.11692645f, 
    0.16505930f, -0.15720586f, 0.29273450f, -0.17267674f, -0.23267253f, 0.39150009f, 0.02683433f, -0.07090538f, 
    -0.22467606f, 0.53918600f, 0.33074901f, 0.47614238f, 0.09705687f, 0.06963646f, 0.11672246f, -0.36012828f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06820029f, 0.44312063f, -0.28445384f, -0.31346536f, 0.39559942f, 0.10123573f, -0.14607674f, 0.27201745f, 
    -0.11773860f, 0.18797904f, 0.08594368f, -0.20440954f, -0.02849934f, 0.10536014f, 0.04227693f, 0.00713083f, 
    0.07032683f, 0.31666750f, 0.37667543f, -0.21945095f, -0.16652642f, -0.48191056f, 0.15504798f, 0.21356125f, 
    -0.31717488f, -0.02087468f, 0.18883978f, 0.33275065f, -0.05579259f, 0.49202159f, 0.21045876f, -0.02134672f, 
    -0.02403997f, -0.06325938f, -0.18455373f, -0.16025077f, -0.06017479f, 0.33223310f, -0.25121531f, 0.41692951f, 
    0.11940304f, -0.01293268f, 0.15459035f, 0.08818390f, 0.32061589f, 0.14015332f, 0.45032522f, -0.16596329f, 
    0.27816230f, 0.42525810f, 0.04038797f, 0.05552979f, 0.29278943f, 0.06344274f, -0.40026197f, -0.12901103f, 
    0.10541175f, 0.24705122f, 0.10672211f, -0.03855579f, 0.23329858f, 0.52524728f, 0.38270268f, 0.36300436f, 
    -0.34942189f, 0.31845117f, 0.24852405f, 0.42789897f, 0.06906266f, 0.09345365f, 0.30556503f, 0.05970570f, 
    -0.15044697f, -0.41671187f, -0.37825125f, 0.14092702f, -0.17278147f, 0.15918045f, -0.03390446f, 0.04788864f, 
    0.21697436f, 0.19466159f, -0.10328102f, 0.28402039f, 0.24416406f, 0.24462950f, 0.46542931f, 0.04257597f, 
    0.34800953f, 0.11186030f, 0.50248915f, 0.00927381f, -0.09226056f, 0.37614283f, 0.37924552f, -0.44692075f, 
    -0.14267904f, -0.29032511f, -0.08339853f, 0.75802141f, 0.58833551f, 0.18393128f, -0.06351617f, 0.23862331f, 
    0.12724768f, -0.00563730f, 0.21556339f, 0.36350262f, 0.14642131f, 0.28851676f, -0.32553235f, -0.02246015f, 
    0.30769396f, 0.26746032f, -0.19225889f, 0.11801493f, 0.00463838f, -0.05107241f, 0.11507930f, -0.03881266f, 
    0.37896487f, -0.33876279f, -0.32893023f, 0.43495959f, 0.05365027f, 0.06812083f, 0.34073883f, 0.26782131f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.08104374f, -0.54613554f, 0.04051822f, 0.07144419f, -0.91891289f, -0.03651092f, -0.57814145f, -0.02179564f, 
    0.07761726f, -0.22446550f, -0.16865897f, 0.12262191f, 0.05509495f, -0.47554308f, -0.09390346f, 0.08091298f, 
    -0.02636358f, 0.28464663f, -0.55125171f, -0.04200270f, -0.05000544f, 0.18518490f, -0.14048477f, 0.23015361f, 
    0.27862296f, -0.04973279f, -0.26897478f, 0.08624784f, -0.45740739f, -0.00554052f, -0.01668507f, -0.38446277f, 
    0.13159606f, 0.04814178f, -0.04078488f, 0.06127242f, -0.31263927f, 0.31770688f, -0.13869488f, -0.18950427f, 
    -0.86264479f, 0.08321386f, 0.18376845f, -0.14431845f, 0.25715017f, -0.04240684f, -0.00187635f, -0.00866690f, 
    -0.39573053f, -0.59401011f, 0.08350350f, 0.02200828f, 0.10179509f, -0.08424596f, 0.02567216f, -0.05931814f, 
    -0.08931121f, -0.06768649f, 0.04078386f, 0.01831512f, 0.04136774f, -0.53507996f, -0.53476030f, -0.01583177f, 
    0.01932194f, -0.91224515f, -0.20356651f, 0.11429747f, 0.15958633f, -0.23576532f, 0.16599989f, 0.01893377f, 
    0.25464121f, 0.43380997f, 0.04951172f, 0.18682101f, -0.12830856f, -0.15459622f, 0.00544760f, 0.00910770f, 
    0.11264332f, 0.11687718f, 0.15272343f, 0.03289601f, -0.06442918f, -0.39446807f, -0.39674109f, 0.22061063f, 
    -0.26035953f, 0.15119652f, -0.86450320f, -0.11185273f, 0.12164518f, -0.03118631f, 0.33187360f, 0.19925182f, 
    -0.58980930f, 0.07919239f, 0.14518264f, 0.35024342f, -1.19353104f, -0.16635306f, -0.21678947f, 0.10574333f, 
    -0.34722367f, 0.19364250f, 0.10989308f, 0.05137981f, 0.13674857f, -0.20577709f, 0.22830163f, -0.02412325f, 
    -0.15053041f, 0.00343042f, 0.01746571f, -0.23787984f, 0.08733957f, -0.29280460f, -0.00187863f, 0.00650825f, 
    -0.08559154f, -0.02127160f, 0.31792760f, 0.12839513f, 0.20875280f, 0.15830852f, -0.30456638f, 0.10144038f, 
    -0.01262304f, 0.05879866f, -0.04426716f, -0.13830405f, 0.05101390f, 0.17520350f, -0.13542670f, 0.04158969f, 
    0.01339061f, -0.05110764f, -0.01423967f, -0.21594328f, -0.18962947f, -0.08012709f, -0.01043578f, 0.03696581f, 
    -0.08006863f, 0.12778780f, -0.42309451f, -0.00983384f, -0.15334897f, -0.74129784f, 0.09090399f, 0.18678579f, 
    0.07916743f, 0.01625707f, -0.09904110f, 0.06667262f, -0.11229436f, 0.18050869f, 0.13885048f, 0.11063833f, 
    -0.25024650f, -0.04790047f, -0.02401561f, 0.21005055f, -0.05405473f, -0.06665552f, -0.32659209f, 0.84222138f, 
    0.21109457f, -0.30801532f, -0.17476670f, -0.02108870f, 0.19719069f, 0.03406424f, -0.20797314f, -0.03793941f, 
    0.03873652f, -1.24511552f, 0.06696954f, 0.06216866f, 0.24497469f, 0.10446799f, -0.07714066f, -0.20366676f, 
    -0.01233569f, 0.21291362f, 0.03293602f, -0.19223218f, -0.07329720f, 0.10347144f, -0.00971933f, 0.04412845f, 
    -0.26974604f, -0.11815731f, -0.79582644f, 0.07106093f, -0.10810241f, 0.09532004f, 0.23721066f, 0.04609106f, 
    -1.02153647f, -0.62481123f, -0.07813850f, 0.09898625f, -0.03336979f, -0.14193596f, 0.04576998f, 0.27365527f, 
    0.12727596f, 0.11128681f, 0.05879525f, -0.06840510f, 0.28805462f, 0.04279339f, 0.22048356f, -0.03256316f, 
    0.13347451f, 0.24410386f, -0.28565764f, 0.05281894f, -0.35128406f, 0.08633772f, 0.12213004f, -0.02403866f, 
    -0.38734230f, -0.07218502f, -0.03204076f, 0.40894964f, 0.60458505f, 0.17299527f, 0.01794315f, 0.11834015f, 
    0.01342972f, 0.19624968f, 0.33134395f, -0.10748488f, 0.06916536f, -0.38065818f, -0.09367410f, 0.02491605f, 
    0.20819916f, 0.05397724f, -0.05323496f, -0.00869035f, -0.00736584f, -0.48638937f, -0.02882194f, -0.02068176f, 
    -0.07615551f, -0.10128644f, 0.19936857f, -0.05598380f, 0.18903004f, -0.16258459f, 0.17865750f, 0.26476419f, 
    0.08467787f, -0.17087699f, 0.30715033f, 0.27797481f, 0.13289173f, -0.05254336f, 0.15581831f, 0.07145043f, 
    0.12647694f, 0.16430002f, 0.03725033f, -0.04061249f, 0.15958847f, -0.08098361f, 0.19940437f, -0.07145233f, 
    0.06133853f, -0.09849822f, 0.52307868f, 0.01800471f, 0.00370389f, -0.06062223f, 0.22551298f, 0.12616141f, 
    0.01872324f, 0.06305433f, 0.06991728f, 0.33810714f, 0.44741967f, 0.02672843f, 0.22833994f, -0.08112504f, 
    0.06894641f, 0.01744111f, 0.03895855f, -0.74462569f, 0.13171792f, 0.12804580f, -0.22635055f, -0.46532780f, 
    0.11463973f, -1.01603472f, -0.20750819f, 0.01454813f, -0.07601073f, -0.21789363f, 0.54759276f, -0.04420086f, 
    -0.05259584f, 0.27504390f, -0.44801304f, -0.04448323f, -0.20915233f, 0.00739001f, 0.11129005f, -0.92682981f, 
    -0.44413286f, -0.54129702f, 0.04364749f, -0.18311913f, -0.09366244f, 0.17027517f, 0.09832325f, -0.14697342f, 
    -0.03649891f, 0.31887180f, 0.15486798f, 0.24198964f, -0.15095426f, -0.70174730f, -0.16462275f, -0.47656122f, 
    -0.34459037f, -0.13204023f, -0.74411511f, -0.08336108f, 0.03081190f, 0.14999977f, 0.03246547f, 0.40149134f, 
    0.03600152f, 0.20190132f, -0.27936146f, -0.24001852f, 0.56571400f, 0.00723095f, 0.16370672f, -0.12559891f, 
    -0.01259734f, -0.08440095f, 0.37999871f, -0.40805730f, -0.93275040f, -0.15576628f, -0.40468183f, -0.03736111f, 
    -0.11024132f, 0.28127497f, 0.21984471f, 0.26060832f, -0.24633665f, 0.36803427f, -0.24675465f, -0.62531710f, 
    0.05437789f, -0.12385269f, -0.48337725f, 0.19508997f, -0.34587011f, -0.13867415f, -0.04843175f, -0.06938108f, 
    -0.25521752f, 0.10874687f, -0.09354693f, 0.02951132f, -0.27050456f, -0.08857830f, 0.02172920f, 0.03777945f, 
    0.22510338f, -0.13558596f, -0.18617640f, 0.21145841f, -0.02784962f, 0.08968751f, 0.30225614f, -0.19568381f, 
    -0.08095697f, 0.11605215f, -0.23780254f, 0.14121635f, 0.10896595f, -0.39219189f, -0.23866343f, -1.23409867f, 
    0.06236731f, -0.95836723f, -0.08809219f, -0.71298927f, 0.13708451f, 0.03136655f, -0.55012059f, -0.04738221f, 
    -0.02776835f, 0.29358542f, 0.06429856f, 0.02171978f, 0.24455035f, 0.41066888f, 0.16194387f, -0.40409827f, 
    -0.37843502f, -0.04784561f, 0.04146810f, 0.05864305f, -0.38447750f, -0.39609340f, -0.15636328f, -0.39681721f, 
    -0.00762609f, 0.09702674f, -0.00010424f, -0.26484084f, -0.02303127f, 0.08656238f, 0.09726492f, -0.15852575f, 
    -0.09694149f, 0.08531776f, 0.05668792f, 0.07217479f, 0.08801847f, -0.15887211f, 0.08279298f, -0.10373830f, 
    -0.16763991f, 0.16131040f, -0.08662660f, -0.01337948f, -0.02818579f, -0.22022232f, 0.03311308f, 0.16048779f, 
    -0.77916414f, -0.01576699f, -0.02292095f, 0.23880722f, -0.80491012f, 0.12639786f, -0.11543148f, 0.15372020f, 
    -0.01100340f, -0.22588353f, 0.39098507f, 0.09479134f, 0.02269255f, 0.15388912f, 0.04331766f, -0.77306879f, 
    0.34560925f, 0.24748644f, -0.02400915f, 0.07130961f, 0.03704094f, 0.14848097f, 0.04498433f, 0.01944832f, 
    -0.00987557f, -0.13298886f, 0.02526611f, 0.22401173f, -0.46389157f, -0.14278279f, -0.06772631f, -0.53810227f, 
    0.25262129f, -0.25793618f, 0.04697416f, 0.06617547f, 0.23890597f, 0.15055799f, -0.27469894f, -0.12135071f, 
    0.12529570f, 0.70047659f, 0.37782726f, 0.29589611f, -0.65026504f, -0.11087652f, -0.64641494f, 0.06997403f, 
    -0.26274490f, -0.70845461f, 0.10175885f, 0.05530610f, -0.02187262f, 0.27993071f, -0.25332707f, -0.03820367f, 
    0.12681124f, -0.08768269f, -0.37755334f, -0.15336202f, -0.19124059f, 0.33306924f, -0.02696617f, -0.03572795f, 
    -0.04012345f, 0.05057632f, -0.12893696f, 0.33260071f, 0.10234177f, -0.25927213f, -0.18087982f, -0.21878195f, 
    0.07476886f, -0.11631281f, 0.10244776f, 0.20390515f, -0.14643715f, 0.00173033f, 0.17362835f, -0.11678371f, 
    0.06913845f, 0.04938715f, 0.14993289f, 0.19082588f, 0.00028344f, 0.16730948f, 0.10521966f, 0.05930934f, 
    0.07862263f, -0.90764666f, 0.03834389f, 0.08073447f, -0.27181682f, 0.20222348f, -0.02135731f, 0.01823346f, 
    0.34807807f, 0.04196253f, 0.05630794f, 0.05912684f, 0.00737211f, -0.16010185f, -0.10675711f, 0.08069291f, 
    0.10686600f, -0.00498208f, -0.01530020f, 0.03821972f, -0.07398178f, -0.29268771f, -0.00328428f, -0.05714029f, 
    -0.27838945f, -0.13987651f, 0.07251998f, 0.09785429f, -0.01530492f, 0.13821939f, -0.00236041f, -0.07302141f, 
    -0.02828060f, 0.07801197f, 0.11030702f, 0.07965977f, -0.02721182f, -0.02315165f, 0.04035162f, 0.12873042f, 
    0.26736951f, -0.23733027f, 0.05561328f, 0.21543586f, 0.07352677f, -0.32554752f, 0.03554469f, -0.17059766f, 
    0.00558958f, 0.12952629f, 0.07534360f, 0.08505628f, 0.16840330f, -0.30603763f, 0.07081638f, 0.07780625f, 
    0.11923166f, -0.16184388f, 0.19567604f, -0.01745957f, 0.02857968f, -0.12333634f, -0.09168978f, -0.23633949f, 
    0.13844433f, -0.10758504f, -0.10317814f, -0.14837854f, -0.17973551f, -0.04590746f, -0.62684757f, -0.05777054f, 
    -0.25516921f, 0.26391679f, -0.07447802f, 0.11259909f, 0.02776064f, 0.11137775f, -0.12670559f, -0.07555284f, 
    -0.19841008f, 0.10290270f, 0.09919934f, -0.65971982f, -1.68113399f, -0.31598186f, -0.00634750f, 0.06945880f, 
    -0.06251649f, 0.24129434f, 0.12095723f, -0.09764130f, 0.16577628f, 0.08079202f, 0.02922461f, -0.05743407f, 
    0.16445847f, -0.00425116f, 0.00354911f, -0.05888537f, 0.05756253f, 0.16957135f, 0.02671468f, -0.12984787f, 
    -0.27152601f, 0.09176527f, -0.00648361f, -0.04298113f, -0.04232932f, 0.01191221f, 0.19092508f, 0.06074929f, 
    0.04861872f, 0.03097675f, 0.10168703f, 0.12648001f, 0.09734761f, 0.00211906f, 0.11229603f, -0.06174053f, 
    0.02839257f, 0.27047655f, -0.10969090f, -0.03602346f, 0.09129870f, -0.21270747f, 0.00281299f, 0.06640662f, 
    0.07736849f, 0.06608991f, 0.01159146f, 0.06826790f, 0.07261024f, -0.29033530f, 0.07700685f, -0.16342139f, 
    -0.52068228f, -0.05594737f, -0.13185088f, 0.08228745f, 0.15053754f, -0.02202477f, 0.08541945f, -0.30061778f, 
    -0.06503741f, 0.03951480f, 0.02713430f, 0.00473370f, -0.29688576f, -0.52685714f, -0.03200478f, 0.27629736f, 
    0.23999077f, 0.20499347f, 0.02827672f, -0.36550739f, -0.20874338f, 0.04000714f, -0.00047076f, -0.05778823f, 
    0.04936038f, -0.32330680f, 0.12060001f, -0.00739590f, 0.22436711f, 0.28941363f, -0.00714464f, -0.01391404f, 
    -0.01329593f, 0.10622621f, 0.00487203f, -0.25779963f, -0.14475182f, 0.10551281f, -0.16624649f, 0.20704803f, 
    -0.09314321f, 0.11622547f, -0.12104008f, -0.02400793f, 0.01824387f, 0.10039008f, 0.03699498f, 0.26611528f, 
    -0.28908542f, -0.17538404f, -0.27445874f, 0.14950065f, -0.02408975f, 0.13934584f, -0.01103618f, 0.19970746f, 
    -0.21981092f, -0.10923702f, 0.22845927f, -0.19507176f, -0.33374426f, 0.08670980f, 0.01079839f, 0.13500878f, 
    -0.20339859f, -0.21205187f, 0.24845012f, 0.00276589f, -0.03929098f, -0.09890397f, 0.03677653f, 0.08179253f, 
    0.38718686f, -0.24392693f, 0.01744667f, -0.82020527f, -0.12626421f, -0.21654350f, 0.08160882f, 0.14241201f, 
    0.13226168f, -0.41154990f, 0.02426525f, 0.21365479f, -0.17337433f, 0.34242177f, 0.15010960f, 0.06948601f, 
    -0.07011165f, 0.16539477f, -0.07547367f, 0.07207400f, -0.11790018f, -0.25173587f, -0.00070578f, -0.00986178f, 
    -0.04120433f, -0.19757175f, -0.15528758f, -0.53429329f, 0.15073055f, -0.15181291f, -0.89452487f, -0.06898975f, 
    -0.05427970f, -0.58688802f, -0.58140939f, -0.17648245f, -0.26146984f, -0.04895994f, 0.24962875f, 0.25034714f, 
    -0.34473169f, 0.20970853f, 0.11259383f, 0.17526880f, -0.64371520f, 0.16623825f, -0.21865305f, -0.06495126f, 
    -0.00736274f, -0.71941739f, 0.57653749f, 0.04073641f, 0.04514917f, 0.18856630f, 0.71166962f, -0.10374691f, 
    -0.35198033f, 0.03477348f, 0.18585229f, 0.01201957f, -0.04951761f, -0.01747975f, -0.41516870f, -0.19249405f, 
    -0.05109831f, -0.33094671f, 0.00836048f, 0.01846676f, 0.13476630f, 0.32297257f, 0.22486962f, -0.13380986f, 
    -0.34067354f, -1.28074431f, -0.15994233f, 0.08341638f, -0.53780890f, 0.09473093f, -0.68694758f, -0.07770974f, 
    0.08824076f, 0.29984733f, -0.74888307f, 0.03355388f, -0.80327266f, -0.22384831f, 0.14376351f, -0.67604500f, 
    0.04033621f, -0.69518960f, -0.00322760f, -1.23071444f, 0.23531166f, -0.08768106f, 0.10465224f, -0.27764770f, 
    0.34930721f, 0.37603730f, -0.25102413f, -0.78769875f, -0.25358719f, -0.08796916f, -0.91412485f, 0.25488913f, 
    -0.31882524f, -0.13579759f, -0.65558755f, -0.20351139f, -0.14234124f, -0.57869166f, 0.08107925f, -0.15775397f, 
    0.28285402f, 0.17213781f, -0.20215662f, -0.06480552f, 0.47247705f, 0.26541832f, -0.03922597f, 0.03842510f, 
    0.02038237f, -0.54980636f, 0.25980985f, -0.24194452f, 0.05394923f, -1.24497163f, 0.00092513f, -0.55645365f, 
    0.58793509f, -0.27189007f, -0.28158203f, 0.14871493f, -0.52643800f, 0.04046275f, 0.26022589f, -1.04112589f, 
    -0.01742876f, -0.17401111f, -0.26974991f, -0.41884825f, -0.84976637f, -0.95116824f, 0.29054743f, 0.04813204f, 
    -0.27038562f, 0.14863442f, 0.19906972f, 0.17923908f, 0.00886151f, 0.11263743f, 0.00876860f, -0.07957258f, 
    0.38487947f, 0.10662709f, -0.34799111f, 0.09998458f, -0.73842967f, -0.48973945f, -0.07019320f, -0.66145951f, 
    0.01369905f, 0.17359743f, -0.27324072f, -0.08558553f, -0.23860997f, 0.03357898f, 0.21799023f, -0.14943993f, 
    0.02904905f, -0.19382854f, 0.16429414f, 0.09042320f, -0.43159801f, 0.16466674f, 0.13406049f, -0.03186507f, 
    0.04127282f, -0.07376953f, -0.52516156f, 0.07168515f, 0.04534002f, 0.28736624f, -0.73367923f, -0.07511837f, 
    0.16921063f, 0.08188239f, 0.00480628f, -0.89047015f, -0.09709016f, -0.10798336f, -0.00372315f, 0.14342600f, 
    0.37428308f, 0.25538439f, 0.03518733f, 0.51900566f, -0.46399000f, -0.66514993f, -0.03435765f, -0.20784467f, 
    -0.62149471f, -0.86349887f, 0.09201305f, 0.05399614f, 0.10761994f, 0.08730042f, -0.72441447f, 0.02928414f, 
    0.01966598f, 0.18236636f, 0.27842751f, -0.06209351f, -1.08406770f, -0.00724111f, -0.24940217f, 0.56093508f, 
    0.00322238f, -0.04214737f, 0.05164036f, -0.13445005f, 0.18785997f, -0.60715628f, 0.06489035f, 0.06850156f, 
    -0.07909900f, -0.00428810f, -0.25842604f, -0.60494322f, 0.32181323f, 0.26903576f, -0.28450847f, -0.38618392f, 
    0.44007444f, -0.18146889f, 0.40939569f, -0.41640306f, -0.02011766f, -0.79520983f, -0.07775740f, -0.41242912f, 
    -0.53994876f, -0.29590252f, -0.07605717f, 0.19155981f, -0.55665481f, -0.07899868f, -0.32148680f, 0.12185523f, 
    -0.45547950f, 0.23580994f, -0.44504064f, 0.21961172f, 0.57356411f, -0.55452931f, -0.09269179f, 0.05794461f, 
    -0.50576568f, -0.02707763f, 0.07304516f, -0.53579998f, -0.35978642f, -0.27947414f, -0.32527906f, 0.00504867f, 
    0.05868132f, 0.12705587f, -0.14641021f, -0.57268178f, 0.24312671f, -0.35876760f, -0.03841826f, 0.03019506f, 
    0.31168616f, -0.04261000f, 0.04984307f, -0.10546568f, 0.09819113f, 0.14322384f, 0.04780985f, 0.01998210f, 
    -0.68473577f, 0.25272849f, 0.08533773f, -0.06666730f, -0.60150242f, 0.23350981f, 0.30949217f, -0.02911947f, 
    -0.02003348f, 0.32191783f, -0.22631520f, 0.12438430f, 0.30749929f, 0.07928249f, 0.05880303f, 0.02673644f, 
    -0.07214892f, -0.35165524f, 0.02004061f, -0.31384197f, -0.30765945f, -0.18929344f, -0.19836566f, -0.02443456f, 
    -0.02229909f, 0.19949406f, -0.22910312f, 0.08344948f, 0.11434979f, -0.65226942f, -1.04298198f, -0.20827937f, 
    -0.69311935f, 0.02474841f, 0.11385144f, -0.46919510f, -0.78050083f, 0.20156337f, 0.00418191f, -0.14325145f, 
    -1.09100425f, -0.16093673f, -0.06579397f, 0.40779313f, 0.23625031f, -0.34161955f, -0.38711077f, -0.81952578f, 
    -0.02953692f, 0.00029924f, 0.03473873f, 0.05335022f, -0.00746297f, 0.14937334f, -0.73195511f, 0.02739425f, 
    0.08434956f, -0.30264336f, 0.05017314f, -0.04500245f, -0.52609521f, 0.20044588f, -0.39817569f, 0.20801941f, 
    0.15335178f, 0.49507603f, 0.04634342f, 0.31532329f, -0.05676433f, 0.20205513f, 0.10251346f, -0.75792009f, 
    -0.13207144f, 0.23538084f, -0.66111213f, -0.70652264f, -0.44417909f, -0.29242256f, -0.62259233f, 0.24646492f, 
    -0.60858804f, -0.30687600f, 0.33048651f, -0.18273030f, 0.00356475f, 0.48701736f, -0.02667226f, -0.39596024f, 
    -0.25138777f, -0.07502320f, 0.05617232f, -0.09333950f, -0.76319647f, 0.21370117f, 0.14661576f, 0.08590800f, 
    -0.10621582f, 0.04621416f, -0.35629836f, 0.05103141f, -0.34410664f, -0.36377162f, -0.37218425f, 0.16116823f, 
    -0.37428072f, -0.13844855f, -0.43449810f, -0.65817398f, 0.07384048f, 0.15320297f, 0.02167256f, -0.16412716f, 
    0.11603284f, -0.06258173f, -1.17793715f, 0.24179858f, -0.03722045f, -0.13459787f, -0.15814990f, 0.02073042f, 
    -0.20872700f, 0.11377276f, 0.20607875f, 0.04956127f, 0.18144237f, 0.14273685f, -0.08277867f, -0.00760696f, 
    0.14899270f, 0.15198606f, -0.39682060f, -0.12340763f, -0.23278148f, 0.15967235f, 0.18681556f, 0.29924080f, 
    0.08550603f, -0.24898247f, -0.09010236f, -0.26010728f, -0.05381677f, -0.11329823f, 0.14817359f, 0.01199270f, 
    -0.21720448f, 0.13043013f, 0.10555383f, 0.32878229f, 0.07578971f, 0.28982252f, 0.32737195f, 0.06766914f, 
    0.06905469f, -0.39151990f, 0.07835099f, -0.02986951f, 0.00851168f, -0.76756036f, -0.40172237f, 0.07777456f, 
    0.28128934f, -0.08387624f, 0.27051154f, 0.02547403f, 0.39457098f, -0.04419329f, -0.28673443f, -0.17595530f, 
    0.28685376f, 0.05573731f, 0.03514242f, -0.40946445f, -0.11439350f, 0.17398669f, 0.24804991f, -0.53997421f, 
    -0.49471030f, -0.22227140f, -0.20400944f, 0.18286447f, -0.10125354f, 0.03953424f, 0.58827776f, 0.01372956f, 
    -0.07709593f, 0.34368217f, -0.10832430f, -0.06719805f, -0.09199278f, -0.27734938f, -0.23098540f, -0.10543474f, 
    -0.04106390f, -0.56934226f, 0.00328716f, 0.19269088f, 0.17031577f, -0.11559109f, -0.04315080f, 0.08282214f, 
    0.18083513f, 0.14258517f, 0.44285363f, 0.09271943f, 0.22466591f, 0.15871426f, 0.12890016f, -0.35550913f, 
    -0.33591688f, -1.08507681f, -0.38304082f, -0.61428267f, -0.02645295f, -0.06988452f, 0.03334238f, -0.24799792f, 
    0.23499554f, 0.14891148f, -0.27108267f, 0.18215694f, -0.72978908f, -0.06905412f, -0.36709949f, 0.04750708f, 
    0.00030921f, 0.16928634f, 0.27137703f, -0.15962268f, -0.35400519f, 0.24140613f, 0.04564421f, -0.68453729f, 
    -0.07015814f, -0.17707664f, 0.07306222f, 0.55406868f, -0.34074560f, -0.63701272f, -0.37252691f, 0.21206541f, 
    -0.04225372f, -0.12184031f, 0.10544344f, -0.06627372f, 0.11664364f, 0.30445486f, -0.08796248f, -0.06832638f, 
    -0.06403403f, 0.15241866f, -0.16001360f, -0.03703532f, 0.03601434f, 0.18957621f, -0.07424491f, -0.06708971f, 
    0.05509445f, -0.26888660f, -0.31458455f, 0.49755812f, -0.48500031f, 0.42370591f, 0.16557524f, -0.43222520f, 
    -0.02856446f, 0.30525625f, -0.87518936f, -0.33252934f, -0.07785619f, 0.15266193f, -0.06041465f, -0.24354617f, 
    -0.66463536f, -0.07431861f, 0.11037881f, 0.23486257f, 0.06053819f, 0.00852194f, 0.23619691f, 0.00308803f, 
    -0.00560858f, -0.25550669f, -0.09818418f, 0.05083105f, -0.04532452f, -0.12435396f, -0.32625639f, 0.07222807f, 
    0.17385142f, -0.06930687f, -0.15855621f, -0.07810919f, -0.03946624f, -0.14670415f, -0.57129884f, -0.05761173f, 
    -0.11895227f, 0.27553084f, -0.10873560f, -0.66953599f, -0.07920961f, -0.23498462f, -0.31139520f, -0.47612661f, 
    0.37445933f, -0.62014288f, -0.14253984f, 0.23858215f, 0.05085854f, -0.16564646f, 0.00662937f, 0.05863426f, 
    0.12771301f, -0.22418979f, 0.05235728f, -0.01028811f, 0.30546916f, -0.03054774f, 0.13070999f, 0.26950848f, 
    -0.52211261f, -0.23318639f, -0.07202516f, -0.88915843f, 0.44430137f, 0.29598841f, 0.07107209f, 0.42951658f, 
    -0.64145291f, -0.29024312f, 0.06551193f, -0.61578953f, 0.20677826f, -0.33704016f, -0.42655748f, -0.31115496f, 
    -0.21770111f, -0.93234217f, 0.06474503f, -0.04262506f, 0.00409157f, -0.29433480f, 0.00794565f, 0.08153696f, 
    -0.81137478f, -0.17479393f, -0.06616868f, 0.22274846f, 0.04807943f, -0.09265038f, 0.17118907f, -0.09777018f, 
    0.36924919f, 0.09441613f, 0.25951248f, 0.21485384f, 0.21358788f, -0.72452545f, -0.20781431f, -0.25483406f, 
    0.38420141f, 0.02914135f, -0.28978941f, -0.46133485f, -0.77176082f, 0.21244873f, -0.72000027f, -0.12022119f, 
    0.10994596f, 0.17261769f, -0.32584530f, -0.05343647f, 0.12969112f, -0.02845225f, -0.62626475f, -0.05817970f, 
    0.25848457f, -0.86786580f, -0.24226068f, 0.05576002f, -0.67405111f, 0.14394349f, -0.04942992f, -0.14669788f, 
    -0.08659877f, 0.27411354f, -0.16436525f, -0.16497669f, 0.11695237f, -0.90021712f, 0.08818106f, -0.02994872f, 
    -0.05294283f, 0.21132496f, 0.44532347f, 0.25368938f, -0.26693869f, -0.13621782f, -0.36239409f, 0.04115514f, 
    -0.30244079f, 0.29407746f, -0.06863762f, -0.00120125f, -0.25652468f, 0.08424777f, -0.47028804f, -0.03219937f, 
    0.05037889f, 0.31557879f, -0.24495177f, -0.05451962f, 0.13549571f, 0.32381889f, 0.08576926f, 0.17312521f, 
    0.23193631f, 0.07151999f, 0.08319900f, -0.41194049f, -0.10347184f, 0.17772816f, -0.23262039f, -0.59994644f, 
    -0.25595784f, -0.42661697f, 0.04153086f, -0.72629571f, 0.22264960f, 0.30688968f, 0.20387606f, -0.00316178f, 
    -0.61715794f, 0.11113287f, -0.08676182f, 0.02038199f, -0.33384228f, -0.48180142f, -0.45302999f, -0.01475396f, 
    0.11523857f, 0.24585310f, -0.28185546f, 0.04940897f, -0.25344875f, -0.57051092f, 0.03881864f, 0.04255951f, 
    0.23488148f, 0.02502687f, 0.06045235f, 0.31027699f, -0.45272624f, 0.19564669f, 0.05728870f, -0.35387945f, 
    0.04458221f, -0.15997076f, -0.07723019f, -0.19316468f, -0.73359805f, 0.03772032f, 0.02123239f, 0.26648974f, 
    -0.70655203f, -0.59392661f, 0.27113211f, -0.26738858f, 0.00959661f, 0.21846998f, -0.06855025f, -1.08598793f, 
    -0.13215886f, -0.19356471f, -0.27655685f, -0.01868681f, 0.75407612f, 0.21056667f, 0.14286797f, 0.16587289f, 
    0.18567462f, -0.15686616f, -0.14158204f, 0.19945846f, -0.30293074f, 0.46429208f, 0.27125224f, 0.19314615f, 
    -0.13015704f, 0.00864089f, -0.25606796f, -0.23915574f, 0.41394159f, 0.20048235f, 0.32098794f, -0.04197826f, 
    0.01338103f, 0.19124855f, 0.19882071f, 0.10693919f, -0.25778064f, 0.23162471f, 0.08251188f, 0.02579840f, 
    -0.79351044f, -0.09749839f, 0.06797098f, 0.03195435f, 0.03933208f, 0.02053381f, -0.06778627f, -0.05466402f, 
    -0.09136631f, -0.19397524f, -0.15363641f, -0.25327951f, -0.01768876f, -0.34061399f, -0.15675147f, -0.18169779f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.26924029f, 0.31579369f, 0.03629278f, -0.06781201f, -0.13798523f, -0.00614308f, -0.09149143f, -0.10554782f, 
    0.00622152f, 0.18108742f, 0.08852648f, -0.13647421f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
