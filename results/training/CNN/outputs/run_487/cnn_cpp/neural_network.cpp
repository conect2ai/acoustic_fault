#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.17241915f, -0.46404043f, -0.59691274f, -0.64550245f, 0.59122610f, 0.64428765f, -0.14437905f, -0.04832006f, 
    -0.17121860f, -0.89799780f, -0.52554721f, 0.27264893f, 0.50092578f, 0.05286767f, -0.58425009f, 0.08255979f, 
    -0.26300791f, -0.09103048f, 0.09415850f, 0.21140482f, 0.29437181f, -0.24861819f, -0.21780108f, -0.30590925f, 
    -0.23109394f, 0.80245566f, 1.32655215f, 0.81257629f, -0.32426408f, -0.91808701f, -0.87419629f, 0.98508418f, 
    -0.35079572f, -0.46306449f, 0.07030006f, 0.15840414f, 0.43318936f, -0.32915667f, 0.15051016f, 0.04744415f, 
    -0.17280020f, -0.43018141f, 0.06565976f, 0.07170483f, -0.39455652f, -0.01357117f, 0.33611232f, 0.09111570f, 
    0.17745604f, 0.35190406f, 0.39800161f, 0.58083856f, 0.90733647f, 0.54634362f, 0.78823084f, -1.03077281f, 
    0.09057309f, 0.05611364f, -0.81455606f, -0.57219511f, 0.28044364f, -0.00141881f, 0.00376222f, 0.55555612f, 
    -0.00787511f, -0.25573277f, 0.30451071f, 0.13967094f, -0.03148261f, -0.24315585f, -0.09571923f, -0.11396458f, 
    0.03695766f, 0.17929356f, 0.07272911f, -1.07974970f, -0.92777812f, -0.64720577f, -0.09165306f, -0.11033656f, 
    0.48478168f, 1.07342637f, 0.55263656f, 0.10159786f, 0.41656008f, -0.05000111f, -0.00788199f, 0.43611971f, 
    -0.39176002f, 0.21699971f, -0.02140355f, 0.33576113f, 0.37715876f, 0.22923806f, 0.05390516f, 0.10980364f, 
    -0.17578746f, -0.01992702f, 0.11560751f, 0.27218911f, 0.58238584f, 0.79191869f, 0.80328232f, 0.32312304f, 
    -0.01858671f, -0.15970676f, -0.75751138f, -0.61667013f, -0.82943845f, 0.15381040f, 0.28801903f, 0.67319953f, 
    0.02349635f, -0.22003093f, 0.06318187f, -0.33018470f, -0.40202811f, -0.14976056f, 0.00546047f, 0.25426015f, 
    0.53482550f, 0.14880084f, -0.40534052f, -0.20799455f, -0.15582578f, -0.78876299f, -0.42038691f, -0.25349927f, 
    -0.36527222f, 0.24611440f, -0.08718874f, 0.45235053f, 0.39638764f, 0.51505458f, 0.75117868f, -0.42336679f, 
    0.07886470f, -0.15277794f, -0.26777986f, -0.63189256f, 0.19983083f, -0.17955968f, 0.55295491f, -0.10061466f, 
    -0.01154936f, -0.14096698f, -0.29698625f, -0.68687433f, -0.26881269f, -0.45352572f, -1.10463440f, 0.16479208f, 
    0.53240442f, 0.56032872f, 0.01680765f, -0.79411912f, 0.48253521f, 0.25785157f, -0.35695323f, -0.63772875f, 
    0.43851864f, 0.10007528f, 0.36369139f, 0.36722168f, 0.31723860f, 0.44792411f, 0.27022138f, 0.23584569f, 
    0.13877909f, 0.53124219f, -0.33161959f, -0.46058279f, -0.28740120f, -0.01298336f, 0.12702523f, -1.10106277f, 
    0.20697989f, -0.49835664f, -0.19591254f, -0.04672446f, 0.67379862f, 1.07186699f, -0.29424372f, -0.02143626f, 
    0.06626549f, -0.24676415f, -0.31755847f, 0.13443883f, -0.07307352f, 0.42636523f, -0.39938343f, -0.11831854f, 
    -0.36478087f, -0.19149305f, -0.25198519f, 0.57389706f, -0.07737762f, 0.45941547f, 0.34357065f, -0.03238731f, 
    0.99744976f, 0.60152161f, 1.04299796f, 0.82798582f, 0.07374786f, 0.76350582f, -0.33315298f, -0.07742317f, 
    0.12416392f, -0.04923845f, 0.13618436f, 0.10198829f, -0.01802346f, 0.39528903f, -0.23073277f, 0.11040596f, 
    0.00499886f, 0.13626583f, -0.11391883f, -0.14238231f, -0.40661946f, 0.20126048f, 0.28297010f, -0.21249285f, 
    -0.12447599f, -0.47319460f, 0.33589709f, 0.39786696f, -0.39100921f, -0.78688103f, -0.70726109f, 0.45772988f, 
    -0.11098858f, -0.43085495f, 0.46227121f, 0.48777351f, 0.32687297f, -0.38617325f, 0.05371011f, 0.01322610f, 
    0.41948411f, 0.36605981f, 0.23881727f, 0.37257436f, 0.23186199f, 0.20909193f, 0.21471909f, 0.51728612f, 
    -0.34120882f, 0.42865634f, -0.14615467f, -0.76843828f, -0.77935207f, -0.50169122f, -0.04340245f, -0.33346018f, 
    -0.59242207f, 0.15789364f, 0.79136354f, -0.14423183f, -0.43231472f, -0.41553393f, 0.03853453f, -0.31660965f, 
    -0.68101525f, 0.35539520f, 0.20628044f, 0.02397630f, 0.04712597f, 0.01427017f, 0.33863863f, 0.33509225f, 
    0.04353873f, 0.41511166f, -0.04850620f, -0.25762507f, -1.43384731f, 0.86502999f, 0.82104051f, -0.74330080f, 
    0.05376507f, 0.11511513f, 1.03508043f, -0.41173083f, -0.20025186f, 0.04312703f, -0.46380556f, -0.15623473f, 
    0.12387464f, -0.40376461f, -0.09364676f, 0.33119011f, 0.05411701f, -0.06808800f, -0.13687849f, -0.17067787f, 
    0.19834416f, 0.30102769f, -0.08879504f, -0.00836685f, 0.16343178f, 1.08876753f, 0.66270375f, -0.37616658f, 
    1.19880593f, 1.11457264f, 0.03659600f, -0.88780987f, -0.00797869f, -0.34723866f, 0.18630867f, 0.43718606f, 
    0.14241810f, 0.08105608f, -0.39758509f, 0.01954792f, 0.08507998f, 0.32862294f, -0.03070514f, -0.23869476f, 
    0.04368974f, -0.10892647f, 0.04216493f, -0.00629514f, -0.13021195f, -0.66929018f, -0.12732372f, -0.35854405f, 
    0.88430703f, -0.69798881f, 0.69582522f, -0.54133505f, -0.53870136f, -0.79727876f, -0.00440601f, 0.23241974f, 
    0.26278403f, 0.07907626f, 0.17673041f, 0.28472295f, -0.46105361f, -0.38826010f, -0.04020528f, -0.21314581f, 
    0.09678750f, 0.10847342f, -0.08713602f, 0.25013074f, 0.33446100f, -0.25858670f, 1.13432419f, 0.54819596f, 
    -1.12118495f, -0.74709791f, -0.87350780f, -0.04032310f, 0.22860144f, -0.11202499f, 0.33077419f, -0.36008281f, 
    -0.28908807f, 0.08467558f, 0.18942857f, 0.38381988f, -0.03351931f, 0.06490011f, -0.03664940f, -0.00904098f, 
    0.15473372f, 0.39330330f, -0.10479292f, 0.18150237f, -0.28203580f, -0.08020946f, -0.09988658f, 1.01435816f, 
    -0.62160784f, -0.17144692f, 1.03427649f, 1.08431387f, 0.32302433f, 0.32766029f, -0.08607884f, 0.57102138f, 
    0.41677436f, -0.36321288f, -0.06315544f, -0.25173068f, -0.11620723f, 0.27695331f, -0.37368324f, -0.20572998f, 
    -0.40510499f, 0.02260259f, -0.26025680f, 0.15487610f, 0.26567188f, -0.12153085f, -0.31196228f, -0.04638991f, 
    -0.66353709f, 0.41084266f, 0.90949547f, -0.41306791f, 1.02410614f, -0.92609829f, 0.17226925f, -0.73043185f, 
    -0.64932275f, -0.09525402f, 0.35017267f, 0.68630975f, 0.61927831f, -0.12189249f, -0.06228582f, 0.44085315f, 
    0.22322762f, 0.24620245f, 0.25250459f, -0.02717031f, 0.19656740f, -0.14167841f, 0.11068281f, -0.20478088f, 
    -0.03199886f, 0.97437769f, -0.32585442f, 1.16676474f, 0.70238149f, 0.00223144f, 0.62972558f, -0.19164240f, 
    0.25899360f, 0.04557801f, -0.38374940f, -0.33268985f, -0.18257120f, 0.09359939f, 0.05187967f, 0.13692817f, 
    0.60561931f, 0.05802482f, 0.45030293f, 0.08315308f, -0.04895480f, -0.23488066f, -0.05168528f, -0.18411678f, 
    -0.02296422f, -0.33360204f, 0.40855077f, -0.16962145f, 0.42234755f, -0.62057018f, 0.62473327f, 0.24975976f, 
    -0.82937849f, -0.30304548f, -0.81420302f, -0.94277757f, 0.22625671f, 0.44917190f, 0.12668914f, 0.60978228f, 
    -0.05267500f, 0.05624057f, 0.20000993f, -0.21383320f, 0.05718654f, 0.47615463f, 0.06720987f, 0.46961477f, 
    0.00242242f, 0.38914230f, 0.24167879f, -1.59110403f, 0.30104956f, 0.65801281f, 0.31919613f, -1.18137562f, 
    0.76260048f, 0.61772984f, -0.06950953f, 0.64510089f, 0.64846599f, 0.18274203f, -0.28756350f, 0.34442064f, 
    -0.04956004f, -0.23525520f, 0.12819035f, -0.19507053f, -0.18633664f, -0.41087103f, -0.12857811f, -0.21699457f, 
    0.01597160f, 0.14650351f, 0.19811399f, 0.04661278f, -0.58348006f, -0.53083867f, 0.00035008f, -0.81912333f, 
    -0.27541891f, -0.52278203f, -0.39121395f, -0.53367364f, -0.52370113f, 0.05614047f, 0.12385078f, -0.45227662f, 
    0.37232679f, -0.41905421f, 0.04644209f, -0.10841350f, -0.41945156f, -0.32789499f, 0.02090404f, 0.00452046f, 
    0.01852580f, 0.18379170f, -0.04176975f, 0.19557482f, 0.04533882f, 0.59696496f, -0.22927319f, 1.02307916f, 
    0.65373170f, 0.36055964f, 0.10545980f, 0.24960352f, 0.06442094f, 0.44511378f, 0.38230380f, 0.34135994f, 
    0.41807371f, -0.12192378f, 0.20606035f, -0.52637130f, 0.31516889f, 0.01949761f, -0.07460649f, 0.12163077f, 
    -0.29120824f, -0.17152430f, -0.32207939f, -0.06938539f, 0.60350776f, -0.16439183f, -1.54322183f, 1.17053640f, 
    -0.33612877f, -0.98881418f, -0.41393283f, 0.46022093f, -0.29803148f, -0.43955505f, 0.08655082f, -0.50580466f, 
    -0.09366617f, -0.30715251f, -0.16779868f, 0.48945293f, -0.11400484f, -0.32473171f, 0.08582676f, -0.11943635f, 
    -0.19029257f, -0.34812430f, 0.16727750f, 0.10510585f, 0.33103129f, 0.28059778f, 0.23753282f, 0.38855699f, 
    -1.18862343f, -0.66422969f, -0.05240237f, -0.21678200f, -0.81318659f, 0.96889758f, -0.00177984f, -0.45262253f, 
    0.46139774f, 0.66720414f, 0.05295792f, -0.05355084f, -0.14996377f, 0.10416664f, -0.28992847f, -0.02423625f, 
    0.16753787f, -0.04667623f, -0.12490076f, 0.09158986f, -0.13426709f, 0.39215836f, 0.13937294f, 0.01996842f, 
    -0.98131317f, -1.55908394f, -0.74678510f, -0.01087891f, 0.14303248f, -0.93216336f, 0.70673943f, 0.68297529f, 
    -0.21926242f, -0.06537472f, 0.27842197f, -0.13149743f, -0.00771489f, 0.11910260f, 0.26445073f, -0.14727350f, 
    -0.08686163f, -0.36979493f, -0.18788525f, -0.11414833f, -0.06027129f, -0.00103006f, -0.03666056f, 0.23636983f, 
    -0.00798153f, 0.42672700f, 0.28573456f, -0.96157652f, 0.15137266f, 0.73539931f, 0.35770297f, -1.04393196f, 
    -0.05704373f, -0.86151326f, 0.17192759f, 0.42857939f, 0.31428733f, 0.01541123f, 0.17368065f, 0.05900949f, 
    0.02614647f, -0.42317629f, -0.32149225f, 0.16115905f, -0.12625721f, -0.11563743f, 0.07022177f, -0.09447018f, 
    -0.06542177f, 0.10721869f, 1.37203157f, 0.82040602f, 0.16493337f, 0.94507682f, 0.73769945f, -0.84860575f, 
    -0.63012868f, -0.00796414f, 0.66574615f, -0.21562548f, -0.43582091f, -0.37898114f, 0.34057635f, -0.16350660f, 
    -0.41461918f, 0.01089360f, -0.02192656f, 0.17353196f, 0.27149886f, 0.30624291f, 0.50416994f, -0.14098972f, 
    0.01779245f, -0.23317243f, 0.05720810f, 1.02108109f, 0.34697437f, 0.44159752f, 0.78181195f, 0.32837087f, 
    0.74728310f, 0.50419182f, -0.28531370f, 0.29528201f, 0.57997578f, -0.71652603f, -0.32096455f, -0.49362904f, 
    0.21676472f, -0.38833943f, -0.31628498f, 0.06186160f, 0.16686969f, -0.29927191f, 0.06906325f, -0.13473777f, 
    -0.15235569f, -0.38684398f, -0.04388576f, 0.33040649f, 0.72972167f, 0.36362490f, 0.41029730f, 0.44032162f, 
    0.76438355f, 0.84014452f, -0.51669306f, 0.41463190f, 0.45725268f, 0.53287971f, 0.24349862f, 0.12632662f, 
    -0.38059139f, 0.29376099f, -0.18474008f, 0.34433478f, 0.08386476f, -0.06181411f, 0.28394878f, -0.10055915f, 
    0.50001013f, 0.30398947f, 0.16517583f, 0.19439894f, 0.57039499f, -0.79965764f, 0.49770582f, -0.88253653f, 
    -0.94628280f, -0.22336029f, -0.38927710f, 0.95342702f, 0.38772297f, 0.03260414f, 0.71333569f, -0.24524537f, 
    -0.05545117f, 0.17456928f, -0.45791763f, -0.22281241f, 0.21957110f, 0.40008944f, 0.14887325f, 0.30465496f, 
    -0.22910878f, -0.14904639f, 0.06585704f, -0.02264011f, -0.35510993f, 0.19958451f, -0.11155125f, -0.05008698f, 
    -1.12056947f, 1.26280665f, 0.80279928f, 0.76702690f, 0.75327438f, 0.39338908f, 0.36689001f, -0.32706583f, 
    -0.14154322f, 0.20570269f, -0.51609677f, -0.10717207f, -0.21935467f, 0.06106318f, -0.15097398f, 0.26476493f, 
    -0.25494406f, -0.13296664f, 0.03906669f, -0.41832659f, 0.11018566f, 0.14208138f, -0.33220318f, 0.80090290f, 
    0.05004287f, -0.75092936f, -0.65457094f, -0.68737668f, -0.56374353f, 0.12359237f, 0.49979031f, 0.14895901f, 
    -0.45615754f, 0.08966275f, -0.13542300f, -0.37219235f, -0.35991836f, -0.20981304f, 0.42512000f, 0.04109093f, 
    -0.17964239f, -0.52806181f, 0.02552966f, -0.35980389f, -0.17808364f, 0.07156268f, 0.23159321f, -0.54801267f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01527908f, 0.41231897f, 0.04696847f, 0.34893325f, 0.32555681f, -0.02905348f, 0.43092036f, 0.00923583f, 
    0.28994584f, 0.09378716f, 0.02201451f, 0.20808677f, -0.02200217f, 0.18608941f, 0.16061132f, 0.27053896f, 
    0.24098785f, 0.34146759f, 0.27358225f, -0.06400956f, 0.29666778f, 0.35413578f, 0.32386127f, 0.19118498f, 
    0.27754468f, 0.31803486f, 0.05463959f, 0.20359057f, 0.17293712f, 0.24760431f, 0.19047700f, -0.08553346f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.44365272f, -0.24616277f, 0.26362908f, -0.24562494f, -0.00278768f, 0.01432797f, 0.07208905f, -0.02044509f, 
    0.01977940f, 0.07654735f, -0.11377504f, 0.02845101f, -0.27184877f, 0.22648349f, 0.01154453f, -0.05516301f, 
    -0.09402785f, 0.09773686f, -0.12918352f, -0.04588652f, -0.17602326f, 0.01140209f, -0.02419830f, -0.08492982f, 
    0.11230721f, 0.23977704f, -0.27854961f, 0.01946236f, -0.25794062f, -0.15898491f, -0.04785456f, -0.13000028f, 
    -0.00762697f, -0.06959014f, -0.03131556f, -0.07328703f, 0.14292684f, 0.25531682f, -0.00529546f, -0.39565042f, 
    0.15810530f, 0.03060016f, -0.08377353f, 0.21505137f, 0.01971677f, -0.03424712f, -0.07030524f, 0.06179199f, 
    0.03513664f, 0.20002154f, 0.13284980f, 0.00247321f, 0.01133323f, -0.00784515f, 0.07102641f, -0.04979949f, 
    -0.07246736f, -0.06727570f, -0.06524104f, 0.02431065f, 0.10154763f, 0.16608219f, -0.05608686f, -0.15108636f, 
    -0.00739041f, 0.11390404f, 0.20160821f, 0.13856652f, -0.04669427f, -0.12520216f, -0.05529904f, 0.05106836f, 
    -0.35846817f, 0.09475433f, -0.03825912f, 0.09724511f, 0.06639636f, -0.02821726f, 0.06625331f, -0.00968174f, 
    0.05518033f, -0.03082511f, 0.14901724f, -0.05801992f, 0.42077452f, 0.01721633f, 0.30802011f, -0.19776185f, 
    0.00817290f, -0.05999936f, -0.04561973f, 0.04626941f, 0.07965142f, -0.04114599f, -0.05016765f, 0.10407753f, 
    0.17055155f, -0.11454754f, -0.25323072f, 0.13079967f, -0.28489956f, -0.03807194f, 0.02206060f, 0.11910970f, 
    0.04844340f, 0.10145348f, -0.16799514f, -0.02605419f, 0.02116090f, 0.03054106f, 0.14057502f, -0.12382059f, 
    0.12935311f, 0.08624844f, 0.07527742f, 0.08959453f, 0.08911861f, -0.09476354f, 0.06746212f, 0.06873949f, 
    0.13534975f, 0.02248143f, -0.01572582f, -0.08330742f, 0.03939839f, 0.11313673f, 0.16026470f, -0.02765175f, 
    -0.01190135f, 0.08594742f, 0.13167270f, 0.04294551f, -0.21442276f, 0.08670369f, 0.01995108f, 0.42446101f, 
    -0.09140068f, 0.08947427f, 0.10793559f, -0.02902873f, -0.02599287f, 0.03247390f, -0.01085918f, -0.14273573f, 
    -0.21477343f, -0.14939156f, 0.29098451f, -0.20466590f, -0.17601377f, -0.02622357f, 0.09324337f, -0.03529337f, 
    0.08956212f, 0.07144638f, -0.09512773f, -0.02005807f, -0.19770306f, 0.04568722f, -0.25525555f, 0.08569501f, 
    -0.03097085f, -0.10269894f, 0.05629499f, -0.15639794f, 0.06021574f, 0.02349407f, -0.05893672f, -0.01404882f, 
    -0.21456143f, -0.06913638f, 0.03107973f, -0.35168785f, -0.12331938f, -0.06217318f, -0.14162338f, -0.04247921f, 
    -0.08202411f, -0.05186552f, -0.02464456f, 0.18641320f, 0.09898528f, -0.12237048f, -0.05501420f, 0.42185834f, 
    -0.08096057f, -0.03172058f, 0.01115378f, -0.12467524f, -0.28455490f, 0.02730940f, 0.03037109f, -0.00400279f, 
    -0.38407516f, -0.16336131f, 0.03544998f, -0.00048213f, -0.07424697f, -0.03503836f, -0.06372960f, -0.03871588f, 
    0.06515612f, -0.08569583f, -0.05251030f, -0.09240355f, 0.21897323f, -0.16909514f, -0.15873097f, 0.20826988f, 
    -0.14710525f, -0.03966996f, 0.16527000f, -0.02319263f, -0.04963361f, -0.03673756f, -0.14072263f, -0.04610607f, 
    -0.03095664f, 0.18250898f, 0.17741777f, -0.32459193f, -0.05210277f, 0.11197730f, 0.03366216f, -0.10385415f, 
    0.04197340f, -0.10017987f, -0.11618220f, -0.02722063f, 0.83993804f, 0.13144866f, -0.01534365f, 0.07956954f, 
    -0.07886172f, 0.13220881f, -0.00242688f, -0.06297646f, -0.05265753f, -0.00454778f, 0.20584305f, -0.03459082f, 
    -0.31352368f, -0.31685978f, 0.05317857f, 0.04353005f, -0.00913346f, -0.06177893f, -0.06286732f, 0.07431839f, 
    -0.08477822f, -0.07078752f, 0.03563628f, -0.03723652f, 0.13378541f, -0.18786685f, -0.19198708f, 0.24787363f, 
    -0.07675522f, -0.07988780f, 0.07861894f, 0.01668501f, 0.03136279f, 0.06390074f, -0.01706770f, -0.13589074f, 
    0.20512269f, 0.08812224f, -0.03485198f, -0.25642958f, 0.18608034f, -0.04253986f, -0.02755833f, 0.05902890f, 
    -0.00572171f, -0.14695968f, -0.10493319f, -0.02108131f, -0.47838232f, -0.24554262f, 0.07255089f, 0.14254861f, 
    -0.05881177f, -0.21645030f, 0.04297563f, -0.07706339f, -0.03264443f, 0.00892656f, -0.04666061f, -0.07978539f, 
    -0.50516546f, 0.38909686f, -0.29317391f, -0.09963821f, 0.04220182f, -0.08120215f, -0.12557323f, -0.01565864f, 
    0.01675352f, -0.04484662f, -0.07324760f, -0.00973924f, 0.35611293f, -0.33045548f, 0.32683066f, -0.08005164f, 
    -0.16133249f, -0.12963708f, -0.10106605f, 0.08249969f, -0.05996088f, -0.04414747f, 0.04859541f, 0.00122296f, 
    0.13281885f, 0.11123417f, -0.00860301f, 0.26012659f, -0.09322497f, 0.03507724f, -0.02736226f, 0.01976699f, 
    0.05298712f, -0.00124814f, 0.07994401f, 0.08187739f, 0.03219318f, -0.12555996f, -0.00885954f, 0.27179646f, 
    -0.14060977f, -0.12093328f, 0.02743870f, 0.05500929f, -0.04271881f, 0.19426011f, -0.21055447f, 0.11958174f, 
    0.18635401f, -0.28430992f, 0.16524933f, 0.08177951f, -0.04090775f, 0.01316680f, -0.11097153f, -0.10359342f, 
    -0.07768650f, 0.05069431f, 0.23638566f, -0.15698771f, 0.34017161f, 0.24888487f, -0.00546464f, -0.53927708f, 
    0.12431027f, -0.00816801f, 0.00143473f, 0.03161644f, -0.10455276f, -0.06630693f, -0.10025720f, 0.07312826f, 
    -0.08428964f, 0.34939378f, -0.03342210f, 0.06132598f, -0.00099107f, 0.13574231f, -0.08262565f, -0.08799972f, 
    0.03233560f, -0.08974496f, -0.01379049f, -0.09464008f, -0.28462657f, 0.05970791f, 0.12078428f, -0.14846659f, 
    -0.06662271f, 0.14655849f, -0.22837599f, -0.18186533f, -0.15334585f, 0.06175489f, 0.08562847f, -0.11554272f, 
    0.07389969f, -0.24883986f, 0.02383002f, -0.34656051f, -0.03072353f, 0.01841204f, -0.05957230f, -0.01443420f, 
    -0.10008591f, 0.06326465f, -0.05225295f, -0.09766134f, 0.06180784f, 0.26111367f, -0.19540039f, -0.19599664f, 
    -0.15450208f, 0.03162860f, 0.09868594f, 0.07257569f, 0.15084013f, 0.00592439f, -0.15194690f, 0.10463256f, 
    -0.20350860f, 0.09256467f, 0.00581214f, 0.23863891f, 0.06964695f, 0.07554643f, 0.01341556f, 0.07616263f, 
    0.03047476f, 0.01309695f, 0.10062497f, -0.00057711f, 0.37727034f, 0.01391724f, -0.17030194f, 0.05137368f, 
    0.00829337f, 0.03850415f, -0.01501326f, -0.09665213f, 0.16124813f, 0.00275725f, 0.02265507f, 0.06801564f, 
    -0.02700228f, -0.01801896f, -0.04695905f, 0.03280295f, -0.15756460f, -0.01178124f, 0.00396949f, -0.06507208f, 
    -0.03883231f, 0.05646823f, 0.08709307f, -0.07816605f, -0.05930294f, -0.05327959f, 0.00689221f, -0.08676601f, 
    0.22726204f, 0.04721215f, -0.10590132f, 0.01321115f, 0.13853475f, -0.04405222f, -0.10753875f, -0.12805936f, 
    -0.33169842f, 0.03674621f, -0.05247735f, -0.03470908f, 0.01273246f, 0.10798123f, -0.25998759f, -0.08895379f, 
    -0.14805247f, -0.08520152f, 0.05143774f, 0.16797628f, -0.21210414f, 0.00675667f, -0.19135062f, -0.10601452f, 
    0.10971791f, -0.01774469f, -0.10726681f, -0.11059365f, 0.01959074f, 0.19484404f, -0.17139283f, 0.00236720f, 
    0.14750934f, 0.18073344f, 0.19044867f, 0.10926260f, -0.01550309f, -0.15055953f, 0.01733637f, 0.01976423f, 
    -0.01588388f, -0.04152022f, 0.14407571f, 0.09750301f, -0.35420668f, 0.09600683f, -0.63606685f, -0.11040385f, 
    -0.03714193f, -0.05604529f, -0.06706912f, 0.05536845f, 0.19624892f, 0.05794703f, 0.06727120f, 0.03948633f, 
    -0.15049757f, -0.18664421f, 0.06534299f, -0.36937311f, -0.14322880f, -0.03376753f, 0.05309364f, -0.00847002f, 
    0.15689950f, -0.07481232f, -0.05322662f, 0.17341205f, -0.74328446f, 0.09481733f, -0.27035680f, 0.30869001f, 
    -0.28297472f, -0.09077244f, 0.00509980f, 0.03237978f, 0.12971981f, -0.08149993f, 0.00298960f, -0.02411391f, 
    0.26354808f, 0.02360348f, 0.16306749f, 0.07392488f, -0.13217962f, 0.00999436f, -0.03853312f, 0.01442002f, 
    0.04099606f, -0.12708688f, -0.09034279f, -0.01988747f, -0.21229260f, 0.03192416f, -0.35032815f, 0.17785849f, 
    0.11940111f, -0.04763394f, -0.03353395f, -0.02366748f, 0.03427985f, -0.01697906f, -0.21521093f, 0.06333800f, 
    0.40626544f, -0.34910426f, 0.11008170f, -0.30201784f, 0.03672619f, -0.07261330f, -0.01565960f, 0.10775549f, 
    -0.14298025f, 0.05759606f, 0.06071226f, -0.01613265f, 0.44550619f, -0.13480914f, 0.22516865f, 0.14966014f, 
    -0.04049242f, 0.09976512f, -0.02190892f, 0.05310838f, 0.08820571f, 0.06940451f, -0.10378808f, -0.07553769f, 
    -0.18551393f, 0.07348313f, -0.17084424f, -0.27311468f, -0.02825842f, 0.01659972f, 0.01658815f, 0.01417025f, 
    0.09315300f, 0.07371239f, -0.01578795f, 0.08889287f, 0.12555474f, 0.10646337f, -0.00964408f, 0.00590945f, 
    -0.07164404f, 0.04526529f, -0.00925731f, -0.07294276f, 0.19402592f, -0.10847592f, -0.07011063f, 0.11000229f, 
    -0.00535549f, -0.05343071f, 0.02213742f, -0.16789530f, 0.07578788f, -0.04209390f, 0.01546255f, 0.04661956f, 
    -0.06031568f, 0.26883897f, 0.06637557f, -0.02406446f, -0.99274886f, -0.02752715f, 0.02423374f, 0.00813344f, 
    -0.02219818f, -0.00265537f, 0.16175103f, -0.05724955f, -0.07991455f, -0.13096285f, 0.00752034f, -0.01259075f, 
    0.16496362f, -0.06952971f, -0.12754421f, -0.04945078f, 0.02440264f, 0.00481720f, 0.01554596f, 0.06639270f, 
    -0.04351806f, -0.02273060f, -0.13991751f, -0.06201786f, 0.14213111f, 0.03548555f, 0.20983370f, 0.17847975f, 
    -0.22296132f, -0.02450944f, -0.09474868f, -0.04726127f, 0.05063492f, -0.13476399f, -0.05173085f, 0.00775752f, 
    -0.70169795f, -0.11226642f, -0.03624583f, -0.42051756f, -0.08028867f, -0.07365242f, 0.08118720f, -0.02498702f, 
    0.06708734f, 0.03385878f, -0.05018000f, -0.10145318f, 0.49801141f, -0.34494212f, -0.32768524f, 0.08984280f, 
    -0.04157057f, 0.13676219f, -0.04494886f, 0.05788768f, 0.02425374f, -0.08795200f, 0.07239774f, 0.06288911f, 
    0.49073669f, -0.11406882f, -0.02283035f, 0.15949790f, -0.09283510f, 0.05760416f, -0.03379595f, 0.00225398f, 
    0.03175973f, -0.05495488f, -0.05754334f, 0.02934894f, 0.04757369f, -0.17516579f, 0.14210978f, -0.16557311f, 
    -0.04262749f, -0.06300582f, -0.01275535f, 0.06660011f, 0.08691869f, 0.04873530f, -0.24590334f, 0.11980577f, 
    0.27511600f, -0.27834389f, -0.22143193f, 0.35581279f, -0.06044140f, -0.13330890f, 0.01751550f, 0.13319448f, 
    0.00664773f, -0.11911078f, -0.25762057f, 0.03492503f, 0.37161389f, 0.06126347f, 0.10388692f, 0.00832588f, 
    -0.15644753f, 0.11836797f, 0.05205757f, 0.05511681f, -0.01433297f, -0.00536050f, 0.11871298f, -0.14801937f, 
    0.24053329f, 0.05778753f, 0.11008780f, 0.12332323f, -0.14898725f, -0.12748425f, -0.02026962f, 0.06796131f, 
    0.01615484f, 0.02246193f, -0.02122284f, 0.10261466f, 0.09365445f, -0.01610090f, -0.03473817f, -0.44506487f, 
    -0.02157447f, -0.08126036f, 0.04427826f, 0.06616518f, 0.08822384f, -0.09448562f, 0.07789502f, -0.08953612f, 
    0.16028789f, -0.22802024f, -0.11725752f, 0.23981290f, 0.26189923f, -0.04394792f, -0.13647977f, 0.19818538f, 
    -0.06731902f, 0.24091864f, 0.05935570f, 0.05685313f, 0.28225625f, -0.07488476f, -0.10654857f, -0.23978359f, 
    -0.12754342f, -0.04977116f, 0.08069167f, 0.09633729f, -0.10739049f, 0.03003040f, -0.22805695f, 0.09536225f, 
    -0.55427402f, -0.14243916f, 0.24114156f, -0.22540636f, 0.00986376f, -0.10197975f, 0.00222944f, -0.05208850f, 
    -0.01849316f, 0.13131905f, -0.15549797f, -0.01873586f, 0.01414727f, 0.20834142f, -0.12720847f, -0.26723054f, 
    -0.00005015f, 0.09085641f, 0.03647177f, -0.14846180f, -0.03380989f, 0.03210374f, -0.02324032f, -0.13679072f, 
    0.24824782f, 0.17151259f, -0.42047665f, 0.11749008f, 0.24233264f, 0.01046368f, -0.00074478f, -0.08114379f, 
    0.04251251f, 0.07506017f, -0.09235001f, 0.09508324f, 0.26499501f, 0.04857536f, 0.23354678f, 0.32731602f, 
    -0.16883740f, -0.15059030f, -0.12860863f, 0.21288046f, 0.05521020f, -0.02961755f, -0.07452019f, -0.05868441f, 
    -0.21980840f, 0.06801733f, 0.04205900f, -0.17362955f, -0.01441527f, -0.02358130f, 0.15878408f, -0.12058592f, 
    0.05296856f, 0.10810257f, -0.07768713f, -0.04814639f, 0.35435578f, 0.11827009f, -0.17107393f, 0.08281431f, 
    -0.06268465f, -0.03717909f, 0.08292583f, 0.08978578f, -0.03806470f, 0.13163902f, -0.05244498f, -0.08054423f, 
    0.31299412f, 0.08758260f, -0.30174658f, 0.07312028f, -0.08026630f, -0.01393489f, -0.00934519f, -0.08535028f, 
    -0.12524310f, -0.02761680f, -0.09592339f, -0.14011584f, 0.41915575f, 0.04513507f, 0.08445143f, 0.02046410f, 
    0.04738545f, -0.02269608f, -0.15124054f, 0.21479945f, 0.07848740f, -0.08864500f, 0.03900595f, -0.03341684f, 
    0.04832711f, 0.10503626f, -0.11527748f, 0.05600034f, 0.14488657f, 0.08646592f, 0.02545157f, 0.01163201f, 
    -0.12443884f, 0.09536089f, -0.07874445f, -0.02262873f, -0.00352715f, -0.03996197f, 0.05032535f, -0.04515929f, 
    -0.07396389f, 0.06472944f, -0.06250986f, 0.00725514f, -0.09836172f, -0.18906504f, 0.02005099f, 0.01315292f, 
    -0.51891589f, -0.13493262f, -0.13709417f, 0.28069469f, -0.01280581f, 0.05153741f, -0.02675166f, 0.02362492f, 
    0.07125533f, 0.08821330f, 0.01125228f, 0.00798930f, -0.17462136f, -0.24555676f, -0.20182683f, -0.07078480f, 
    -0.24340484f, 0.08966676f, -0.11310073f, -0.04664334f, 0.09000239f, 0.09428596f, -0.04038031f, -0.13973880f, 
    0.21264334f, -0.26495066f, -0.02397912f, 0.14594783f, 0.10897876f, -0.06700788f, 0.07858381f, -0.07869425f, 
    -0.11821969f, 0.10549454f, -0.01615443f, -0.01324460f, -0.06917593f, -0.06184054f, -0.13417956f, -0.42411745f, 
    -0.12408833f, 0.01022854f, -0.06436527f, 0.07834551f, -0.08414511f, -0.04644856f, -0.05958262f, -0.05341913f, 
    -0.24912535f, 0.06848635f, -0.19577357f, -0.04446143f, -0.14439191f, -0.10434344f, 0.16660462f, 0.03010850f, 
    -0.09916248f, -0.06433673f, -0.08818607f, 0.02397858f, -0.17444901f, 0.09613239f, 0.00382881f, -0.20126230f, 
    0.08874313f, 0.15367243f, -0.08191978f, -0.03375966f, 0.00245429f, -0.04438683f, 0.09775201f, -0.01408341f, 
    0.40110114f, -0.22695681f, -0.24626289f, 0.12984431f, 0.18897282f, -0.02028937f, -0.02839123f, -0.10817490f, 
    -0.11610250f, -0.16305463f, 0.00178669f, -0.13190562f, -0.51066875f, 0.08946740f, -0.08881969f, -0.05262270f, 
    0.01052584f, 0.02948878f, -0.06462900f, -0.06518821f, -0.14209782f, -0.11580500f, -0.02002687f, -0.10706738f, 
    -0.61236882f, 0.20685753f, -0.11258526f, -0.16067205f, 0.13376623f, -0.01348506f, 0.13430479f, -0.05205559f, 
    0.00332161f, -0.08648702f, -0.02153826f, -0.19388606f, 0.55108380f, 0.18701304f, 0.10169169f, -0.16373521f, 
    -0.03923890f, 0.06156919f, -0.11054314f, 0.14087901f, -0.10750660f, 0.10054128f, 0.02312412f, -0.11377256f, 
    -0.00619256f, -0.23242263f, -0.14971897f, -0.39773208f, 0.01974578f, -0.03198966f, -0.16367745f, -0.13415070f, 
    0.05207076f, 0.05458802f, 0.00034942f, -0.02474990f, 0.03309910f, 0.06203511f, -0.07933028f, 0.08615550f, 
    -0.15167305f, -0.01683204f, 0.02459217f, 0.01367288f, -0.07177402f, -0.01555235f, -0.01849977f, -0.07155776f, 
    -0.07179946f, 0.27842787f, -0.32280108f, -0.35748169f, 0.06591836f, 0.04949259f, -0.04470810f, -0.13248615f, 
    -0.02563408f, -0.05045866f, 0.03386011f, 0.08676434f, 0.58100247f, -0.12496103f, 0.33579108f, 0.04859153f, 
    -0.08555639f, 0.02785544f, -0.09090427f, -0.08632445f, -0.07153246f, -0.04154753f, 0.10468882f, -0.02596274f, 
    0.57658374f, -0.05595716f, -0.13659379f, 0.20150603f, -0.21749398f, 0.07337689f, -0.19467755f, 0.05058908f, 
    0.03862143f, 0.04050743f, 0.14877738f, -0.09222841f, -0.19275874f, 0.02210479f, 0.01672240f, -0.14036860f, 
    0.13234767f, -0.07096744f, 0.07659633f, -0.06799613f, 0.04019756f, 0.15805738f, 0.00869509f, -0.08088697f, 
    -0.20581551f, 0.09798297f, -0.34961784f, -0.02567612f, 0.07276440f, 0.06702686f, -0.01905649f, -0.00673498f, 
    0.05897886f, -0.03961484f, -0.02368083f, -0.13730617f, 0.06097877f, -0.11188558f, 0.06894352f, -0.09629808f, 
    0.08780089f, -0.03016422f, 0.07612240f, 0.03556019f, -0.10544734f, 0.14179583f, 0.04362224f, 0.00667686f, 
    0.09388585f, 0.05512152f, 0.03100836f, 0.03409244f, 0.04019680f, -0.05156208f, 0.05771643f, 0.08401670f, 
    0.01748113f, -0.05061453f, 0.03096201f, -0.03801831f, 0.15295000f, 0.24453998f, 0.00035122f, 0.30339703f, 
    0.12684894f, -0.05434642f, 0.01364796f, 0.04845745f, -0.02797109f, 0.05783761f, -0.03246561f, 0.01155105f, 
    -0.04581120f, -0.24858871f, -0.02678991f, -0.04838345f, 0.05275238f, 0.00709029f, -0.07599194f, 0.03376577f, 
    0.06370153f, -0.08405098f, -0.06944763f, 0.10451308f, -0.08899149f, -0.17893645f, -0.15299818f, 0.27592418f, 
    -0.21802798f, -0.06572774f, 0.21706133f, 0.13137878f, 0.13044295f, -0.04354222f, 0.00638644f, -0.09457200f, 
    0.02253889f, -0.01598262f, -0.06471877f, 0.05554336f, 0.03858899f, 0.03325266f, 0.08078925f, 0.07604954f, 
    0.07333146f, 0.05159845f, -0.03422914f, -0.09805062f, -0.47913092f, 0.20822324f, -0.10833550f, 0.00185311f, 
    -0.05204190f, 0.00901713f, -0.06549068f, -0.05195273f, -0.12804177f, 0.03172321f, 0.07931733f, 0.07241929f, 
    -0.72730881f, -0.42583728f, 0.17416844f, 0.12749216f, -0.02282170f, 0.12839387f, 0.09933545f, -0.07175621f, 
    -0.16429639f, -0.15228881f, -0.10339627f, -0.10206155f, -0.00640904f, -0.19114064f, -0.12895432f, -0.19788194f, 
    -0.15633361f, -0.12508062f, 0.07229939f, -0.07074823f, -0.10967903f, 0.00861407f, -0.04653305f, -0.06979652f, 
    0.03735549f, -0.20733264f, -0.19207662f, 0.32822156f, 0.04071940f, 0.00822622f, -0.02613361f, -0.04098119f, 
    -0.03672136f, 0.01269110f, 0.04247158f, -0.10017580f, -0.21026972f, 0.10298552f, 0.09446826f, -0.02091842f, 
    -0.08954711f, -0.12634006f, -0.06415629f, 0.10644886f, -0.06933775f, 0.05779215f, -0.00679930f, 0.07651799f, 
    -0.43650079f, 0.19451986f, 0.12286071f, -0.04810211f, 0.18068491f, -0.19255039f, 0.08360585f, 0.07279503f, 
    0.00872654f, -0.11880152f, -0.07698009f, -0.00763743f, -0.04908272f, 0.24186550f, 0.04293407f, -0.02872068f, 
    0.01508730f, -0.03902043f, 0.00297529f, 0.04638393f, -0.07716840f, 0.04217466f, 0.12709522f, -0.03229552f, 
    -0.11349254f, -0.52544564f, -0.30392030f, 0.24869330f, -0.01367512f, -0.03529610f, 0.04334019f, -0.01084296f, 
    0.08133981f, -0.12861337f, -0.07987095f, 0.08189090f, -0.28136286f, 0.22154729f, -0.00590707f, -0.09150365f, 
    0.02537622f, -0.02379309f, -0.14093736f, 0.11404453f, 0.05822064f, -0.15959704f, -0.10010329f, 0.05260120f, 
    0.16124049f, 0.09306969f, 0.10103212f, -0.06814624f, -0.10254853f, -0.01616398f, 0.03906265f, -0.02840391f, 
    -0.09169696f, 0.14141695f, -0.02886920f, -0.01711780f, 0.33859375f, 0.02410129f, 0.09510069f, -0.14756972f, 
    0.06234590f, 0.17388350f, -0.05261160f, 0.19007997f, -0.19678026f, 0.10526375f, 0.02764135f, -0.09961896f, 
    0.88984877f, -0.35556850f, 0.21498494f, 0.13576998f, -0.06743827f, -0.10632826f, -0.01688106f, 0.01366086f, 
    -0.08897671f, 0.07077066f, -0.11582492f, 0.01156055f, 0.28864539f, 0.27108112f, 0.00112170f, -0.06271206f, 
    0.05337215f, -0.05566174f, 0.01770752f, 0.03648531f, 0.01349362f, -0.02172549f, 0.11207585f, 0.00275068f, 
    0.05017721f, -0.20788920f, -0.00870401f, 0.06381787f, -0.16282073f, -0.01483735f, 0.06738041f, 0.11056025f, 
    -0.04428807f, 0.17720921f, -0.03965793f, 0.08004921f, -0.19070809f, -0.20944728f, -0.00761019f, -0.09024360f, 
    0.06225843f, 0.15097462f, -0.11398186f, -0.22145359f, 0.07633095f, 0.06948795f, 0.13568570f, -0.05212133f, 
    -0.40353224f, 0.15995505f, 0.32468081f, 0.29229385f, 0.13551170f, 0.01746053f, 0.14095630f, 0.06231996f, 
    -0.08640949f, 0.11158849f, -0.22328132f, -0.06511390f, 0.01615661f, -0.56906563f, -0.07795875f, 0.28506762f, 
    -0.13118464f, -0.08010922f, 0.16986150f, 0.00190128f, -0.01158784f, -0.05107363f, -0.11703008f, -0.06663376f, 
    0.07305030f, 0.02661517f, 0.12453871f, 0.12240176f, 0.13655832f, -0.02446407f, -0.01312518f, 0.09400997f, 
    -0.02682237f, -0.19504467f, 0.05638905f, -0.20511375f, -0.56396556f, 0.28628770f, -0.03911374f, -0.39921606f, 
    0.14921744f, 0.01745597f, -0.06647810f, 0.07885717f, 0.04386380f, -0.11365709f, -0.04180888f, 0.04218739f, 
    0.17807804f, 0.08626124f, 0.10374310f, 0.04799616f, -0.02815574f, -0.12993392f, -0.01188712f, 0.05555951f, 
    0.05811390f, 0.02978069f, 0.16119502f, 0.00458238f, -0.53722602f, -0.33546403f, -0.25879833f, -0.05181991f, 
    -0.07018127f, 0.09340642f, 0.04575231f, 0.01294904f, -0.11954840f, 0.17843989f, -0.17660946f, -0.05120822f, 
    0.51545537f, 0.33518019f, 0.22446735f, -0.08950306f, 0.08124251f, -0.11712298f, -0.03417135f, -0.03083808f, 
    -0.00138300f, 0.02374686f, -0.06822918f, -0.08210204f, -0.03191523f, -0.09280743f, -0.01245301f, 0.12349502f, 
    -0.07400357f, -0.04221389f, -0.14846756f, 0.07980705f, 0.00774181f, 0.22765940f, -0.04161946f, 0.01611759f, 
    0.15220620f, 0.03623399f, 0.05634648f, 0.14071883f, -0.15608022f, -0.16422111f, 0.05022798f, -0.05629217f, 
    -0.02333081f, -0.00801498f, 0.01508227f, 0.07015382f, 0.22061688f, 0.16102020f, -0.15614627f, 0.20273137f, 
    0.02689024f, 0.16387185f, -0.03470789f, -0.00318945f, 0.03064466f, -0.02532255f, -0.01812705f, -0.10526095f, 
    0.19924603f, -0.26149595f, -0.21880014f, 0.02403018f, 0.07410327f, -0.02672383f, 0.05392538f, -0.17056590f, 
    -0.01436336f, 0.06091394f, -0.12050121f, 0.02371828f, -0.53599793f, -0.54621094f, -0.37896302f, 0.05759661f, 
    -0.06368310f, -0.11586235f, -0.07175956f, 0.02073652f, 0.09359123f, -0.06636350f, 0.09168068f, 0.11147568f, 
    -0.51156062f, -0.17612167f, -0.39621636f, 0.09859526f, -0.02146985f, 0.03266226f, -0.01774987f, -0.21874925f, 
    -0.11913136f, -0.12946323f, -0.11655640f, -0.03722966f, -0.48332411f, 0.12888366f, -0.11812267f, -0.21712743f, 
    -0.06322248f, 0.13581707f, -0.04429331f, 0.08133175f, 0.01385128f, 0.11391272f, -0.03406049f, 0.15954457f, 
    0.02903262f, 0.08279151f, -0.01862077f, -0.01636608f, 0.08307516f, -0.08966950f, 0.24772526f, -0.04102807f, 
    0.07943730f, 0.04441714f, 0.25453985f, -0.04802041f, 0.13175274f, -0.26996619f, 0.08420921f, -0.01713195f, 
    -0.11518104f, -0.02632008f, -0.02818531f, 0.10461196f, -0.03618881f, 0.06368967f, -0.01403876f, -0.06726421f, 
    -0.05898406f, 0.16730727f, -0.31725338f, -0.10249486f, 0.06897968f, -0.01656638f, 0.06704640f, 0.14246559f, 
    0.08624697f, -0.06573157f, -0.07211591f, -0.01298182f, -0.58248597f, -0.19624138f, 0.30569515f, -0.14617310f, 
    0.03937740f, 0.04090618f, 0.01774741f, -0.12957664f, 0.12908404f, -0.05488269f, -0.08682165f, -0.12989771f, 
    -0.24732098f, -0.12803523f, 0.32733431f, 0.24939221f, 0.02071530f, 0.02953258f, -0.13678011f, -0.05377575f, 
    -0.02979155f, 0.05967014f, -0.17365597f, -0.09261971f, -0.69575477f, -0.00022904f, -0.00999906f, 0.15042992f, 
    -0.01573903f, -0.14176232f, 0.08110870f, -0.06280743f, -0.00372356f, 0.01855430f, 0.05896423f, -0.05617986f, 
    -0.59300286f, -0.30489242f, 0.18570943f, 0.11538248f, -0.01041009f, 0.01399737f, -0.12846375f, -0.06950959f, 
    0.18371215f, -0.07897553f, -0.01398259f, 0.04947286f, -0.21409403f, 0.22056377f, 0.07953104f, 0.32246256f, 
    -0.05852884f, 0.10097103f, 0.08757692f, 0.18238790f, -0.01893483f, 0.12127452f, 0.17460093f, 0.07335301f, 
    -0.25541779f, -0.05507087f, -0.00348680f, -0.10826080f, 0.08349857f, -0.10738180f, 0.20439725f, -0.05534576f, 
    -0.10877506f, 0.13543777f, -0.16950965f, -0.05403858f, -0.29758498f, -0.02402306f, -0.19523232f, -0.22400339f, 
    0.08206149f, 0.06173813f, 0.12712270f, -0.06648121f, -0.05913740f, -0.02044942f, -0.07381578f, -0.01681245f, 
    -0.12802766f, 0.10171302f, 0.13869098f, -0.11175333f, -0.00425832f, -0.04124283f, -0.04539912f, 0.22286247f, 
    0.05943789f, -0.09798904f, 0.09014002f, 0.07885121f, 0.08779164f, -0.03021394f, 0.15758359f, 0.06526867f, 
    -0.16837235f, -0.12333900f, 0.12515908f, 0.03122857f, -0.17154431f, 0.02935887f, -0.01181616f, 0.00620825f, 
    0.08982933f, -0.03806706f, -0.21169955f, 0.31722951f, 0.09367795f, 0.08309545f, -0.03352661f, 0.08196677f, 
    -0.10556325f, 0.10806692f, 0.07134993f, 0.04599639f, -0.39259982f, -0.01337411f, 0.02981392f, -0.45692998f, 
    0.04088651f, 0.17054467f, -0.27219284f, -0.05165339f, -0.04461866f, -0.00197014f, -0.10730514f, 0.16205393f, 
    -0.04391393f, 0.18548949f, -0.34293500f, -0.19674227f, 0.00537424f, 0.14239995f, -0.06967239f, 0.23081651f, 
    -0.17610167f, 0.01236999f, -0.00761365f, 0.11149464f, -0.36702597f, -0.28525472f, 0.28298393f, -0.44442996f, 
    -0.06522613f, 0.12782183f, -0.06876178f, 0.10156517f, -0.08911438f, -0.17910282f, 0.00533309f, 0.11298691f, 
    0.05323028f, 0.13332406f, 0.09609570f, 0.14554511f, -0.11032674f, 0.00740466f, 0.18132940f, -0.01651453f, 
    -0.00623018f, 0.06484481f, 0.07482965f, -0.05379267f, 0.07070018f, 0.17537746f, -0.08295474f, 0.05181434f, 
    0.03078590f, 0.04343227f, 0.12939064f, 0.05293258f, -0.09786204f, 0.02588423f, 0.01085123f, 0.05425809f, 
    -0.44228432f, 0.25209409f, 0.04716312f, 0.22151700f, -0.08698234f, -0.08703290f, -0.05703186f, -0.07118709f, 
    0.17559412f, 0.03526497f, -0.08194659f, 0.03960018f, -0.04262882f, 0.24277170f, 0.10870289f, -0.34157971f, 
    0.13878550f, -0.02495579f, 0.11702633f, 0.06646705f, 0.02189682f, 0.04150357f, 0.06195967f, -0.07981242f, 
    -0.19562078f, -0.04653360f, 0.25090066f, -0.05004664f, -0.01309658f, -0.01605744f, -0.15991591f, -0.18136530f, 
    -0.11725230f, -0.07198054f, 0.04973290f, -0.15642273f, -0.02157105f, 0.09326990f, -0.19379775f, -0.06838030f, 
    0.20866573f, 0.01325501f, -0.11083669f, 0.14336407f, 0.07157785f, -0.00760086f, -0.16061206f, -0.06842025f, 
    0.21698681f, -0.03769970f, 0.14267841f, 0.08856295f, 0.02140340f, -0.05789176f, 0.16856213f, 0.14076407f, 
    0.02212216f, -0.10775124f, 0.02553926f, 0.09299428f, -0.19722798f, 0.16794232f, -0.00502633f, -0.16143064f, 
    0.06568106f, -0.09982468f, 0.06573215f, 0.21966946f, -0.01185977f, 0.07246628f, 0.04303483f, -0.15220860f, 
    0.66733700f, 0.08490925f, -0.05790133f, -0.24362494f, 0.10568222f, 0.03400255f, 0.21916798f, 0.06911906f, 
    0.14367032f, -0.03190086f, 0.00435046f, 0.01175042f, -0.58901399f, 0.13992774f, 0.04355815f, -0.05605803f, 
    -0.04434771f, -0.03732929f, 0.06903085f, 0.13238341f, 0.01149381f, -0.05966195f, -0.07054280f, -0.07153940f, 
    -0.62111998f, 0.03551375f, -0.14497218f, 0.08901003f, 0.07698530f, -0.01821281f, 0.08687477f, 0.09492082f, 
    -0.09622176f, -0.18062745f, -0.02193662f, 0.08140876f, -0.22151642f, 0.00141192f, -0.19794244f, 0.20879816f, 
    0.00097235f, -0.11338770f, 0.03264664f, -0.03509013f, -0.07966009f, -0.15107141f, 0.10708734f, -0.03779406f, 
    0.27665541f, -0.08982856f, 0.15941933f, 0.23092842f, -0.06779682f, 0.04918753f, 0.05453061f, -0.03961417f, 
    0.10488840f, 0.04229128f, 0.02188447f, -0.07875367f, -0.04450919f, 0.32978833f, 0.02012974f, 0.02375411f, 
    0.07282318f, -0.02121818f, 0.02629052f, 0.03512592f, -0.07744724f, -0.01152513f, -0.00000325f, 0.18495895f, 
    -0.08960788f, -0.12070928f, -0.20616946f, 0.08824934f, -0.06583034f, -0.15026917f, -0.07151222f, -0.10410486f, 
    0.12101305f, 0.02564141f, -0.15970634f, -0.07240932f, -0.12478945f, -0.14700001f, 0.23137654f, 0.26916873f, 
    -0.02792161f, 0.01549852f, 0.13059077f, -0.09730941f, 0.00947322f, 0.02278783f, -0.01501395f, 0.04580830f, 
    0.27705541f, -0.39160523f, -0.29349205f, -0.13756053f, -0.14759274f, 0.06343941f, 0.02459571f, -0.06939491f, 
    0.03464352f, -0.03165261f, 0.04904877f, -0.08704684f, 0.12111701f, -0.02633838f, 0.13927321f, -0.00601696f, 
    -0.00005948f, -0.04499555f, 0.14472295f, -0.03336727f, -0.01930195f, 0.21575406f, 0.13222466f, 0.16357601f, 
    0.22152185f, -0.05395111f, 0.02762985f, 0.09021808f, 0.30264094f, 0.15354864f, -0.16444124f, -0.13118827f, 
    0.04448035f, 0.02984322f, 0.16043426f, 0.05828839f, 0.03782615f, -0.05821347f, -0.04253442f, 0.11181004f, 
    -0.15392067f, -0.04795193f, 0.00700695f, 0.17151883f, -0.08448800f, 0.05150547f, 0.06880771f, -0.08335643f, 
    0.16758622f, -0.08933993f, 0.05421036f, 0.15988754f, -0.29682350f, -0.04128454f, 0.11662299f, 0.08966587f, 
    -0.14530130f, -0.14453699f, 0.20381680f, 0.17439002f, -0.62268198f, 0.14826527f, -0.14637841f, -0.13971749f, 
    0.18003115f, 0.20631970f, 0.04439284f, -0.16902660f, 0.10889558f, -0.17224666f, 0.07259415f, -0.01142324f, 
    0.22955024f, 0.03795117f, 0.02933681f, 0.23924074f, -0.10304539f, -0.05979819f, -0.04550113f, 0.18112822f, 
    -0.23659553f, 0.14726074f, -0.09856579f, -0.00860138f, 0.29082397f, 0.13842861f, -0.05568505f, -0.09179446f, 
    0.08159519f, -0.02566321f, -0.10843450f, -0.24090415f, 0.00427996f, -0.22866417f, 0.02101004f, -0.18100862f, 
    0.11444004f, -0.26372254f, -0.04539406f, -0.04933812f, 0.07720458f, 0.04563572f, 0.03465382f, 0.06224781f, 
    0.20743032f, 0.14068919f, 0.12690200f, 0.16799387f, -0.56475890f, 0.12597597f, 0.15268570f, -0.21894649f, 
    -0.13054815f, 0.09672856f, 0.18251114f, 0.15352575f, 0.11016154f, -0.08534606f, 0.09678616f, -0.40333259f, 
    -0.11647083f, 0.00942927f, 0.03298679f, 0.25755569f, -0.05855707f, 0.10549165f, 0.14853841f, -0.12750708f, 
    -0.00079379f, -0.06496672f, 0.04528163f, 0.14497381f, -0.15454796f, -0.15670557f, -0.07478690f, -0.09872206f, 
    -0.15578835f, -0.04810798f, -0.00332316f, -0.01829997f, 0.15718736f, 0.05627224f, -0.11021379f, 0.23193742f, 
    0.06507199f, -0.12532775f, -0.05729114f, 0.04038895f, 0.20495838f, 0.24572317f, 0.01860064f, -0.00597803f, 
    0.03556202f, -0.07414513f, -0.17826818f, -0.28988099f, -0.33556876f, 0.10232308f, -0.21670395f, -0.06934965f, 
    0.11945719f, -0.12794156f, 0.11441734f, -0.02879799f, 0.02266745f, -0.10298473f, 0.04702491f, 0.00309385f, 
    -0.03612141f, -0.32706869f, 0.29344326f, 0.15656112f, 0.05442757f, 0.01884724f, 0.05738205f, -0.06217205f, 
    0.03077729f, 0.00108595f, 0.06261555f, 0.00964166f, -0.18510447f, -0.29493675f, 0.24222524f, -0.04138321f, 
    0.07483911f, 0.04533337f, 0.05866096f, 0.18144310f, -0.21443829f, 0.12078816f, 0.10668587f, -0.07811143f, 
    0.13771182f, 0.01289577f, -0.15590636f, 0.03061247f, -0.06514446f, -0.11311674f, -0.05134713f, -0.11411376f, 
    -0.05765615f, 0.05785340f, 0.08682469f, 0.00366178f, -0.02497188f, 0.09210268f, 0.04222314f, -0.37975320f, 
    0.02755965f, -0.12700248f, -0.16855018f, 0.11118578f, 0.17442353f, -0.11976983f, -0.14082214f, -0.15744683f, 
    0.17359675f, 0.02070572f, -0.04149940f, -0.25094438f, 0.10206877f, -0.09322926f, 0.11527056f, 0.03620901f, 
    -0.11084424f, 0.04785713f, 0.23150328f, 0.19209322f, 0.07846203f, 0.03853033f, 0.11457045f, 0.29676852f, 
    -0.05881523f, -0.02820329f, -0.11854890f, 0.05678762f, -0.13981031f, 0.08568058f, 0.05475291f, 0.06682543f, 
    -0.02633742f, -0.02945984f, 0.21892364f, 0.29946232f, -0.14602911f, -0.10170877f, 0.10526663f, 0.06980120f, 
    0.07682852f, -0.06867401f, -0.03416907f, 0.43943676f, -0.32111448f, -0.28659058f, -0.12004728f, -0.03674541f, 
    -0.01636607f, -0.22908746f, 0.06182718f, -0.19434913f, 0.05252770f, -0.12847866f, -0.19191696f, -0.01663216f, 
    -0.27881771f, -0.05845671f, -0.02625564f, 0.40457255f, 0.32395914f, -0.06636793f, 0.07795326f, 0.00627880f, 
    -0.16413887f, 0.20489322f, 0.10352800f, -0.00071890f, -0.00679585f, 0.12907739f, 0.11821283f, 0.09767961f, 
    0.11542192f, 0.08590437f, -0.02058519f, -0.13107038f, 0.09824161f, -0.05999450f, -0.15983623f, 0.02521570f, 
    -0.29722652f, -0.31755641f, 0.27705318f, 0.49433494f, -0.05077697f, -0.03939360f, -0.01697692f, 0.05753301f, 
    0.04499035f, 0.05415533f, 0.09934308f, -0.07477653f, -0.66928166f, -0.10962789f, 0.09804483f, -0.09154803f, 
    0.06710194f, -0.00664606f, -0.09602191f, 0.10178196f, 0.02564011f, -0.18324322f, -0.11022010f, -0.03975377f, 
    -0.79229462f, -0.13583019f, -0.20540439f, -0.41431534f, 0.20386216f, 0.05797780f, 0.10024595f, 0.02220819f, 
    -0.16979556f, 0.23448996f, -0.13121036f, 0.04838387f, -0.21582203f, -0.00432963f, 0.12008278f, 0.07995446f, 
    -0.00754793f, 0.11159129f, -0.13605480f, -0.15873034f, -0.19856422f, -0.13372487f, -0.00135784f, 0.00358453f, 
    0.15086137f, -0.08950017f, 0.03593868f, -0.23620889f, 0.01840706f, -0.11495930f, -0.10286037f, -0.07264639f, 
    -0.00905102f, 0.02127682f, 0.04408247f, 0.09456086f, 0.15234964f, -0.04217906f, 0.09489662f, -0.00705200f, 
    0.11454747f, -0.02167588f, -0.14807005f, -0.06077651f, 0.01578804f, -0.18592604f, -0.00367057f, -0.12114944f, 
    0.04812030f, 0.11515129f, 0.02369863f, -0.05096574f, 0.08640442f, 0.10533141f, 0.02929874f, 0.12404964f, 
    0.21167952f, 0.11203986f, -0.05505249f, 0.19565207f, -0.11238182f, -0.28158906f, -0.31883496f, -0.13677235f, 
    -0.00684330f, 0.14399119f, -0.18774475f, -0.15360469f, 0.10275126f, -0.07685784f, -0.03363773f, 0.12146945f, 
    -0.30260372f, 0.51789922f, 0.46439272f, -0.38819337f, 0.02227073f, -0.00740328f, 0.12270718f, -0.29206869f, 
    0.14573902f, -0.03757520f, -0.06906004f, -0.07409375f, 0.02215316f, -0.40322250f, -0.15394180f, 0.05059412f, 
    0.13355997f, -0.07619365f, -0.04176712f, -0.10259532f, 0.06017556f, -0.02508526f, -0.28829271f, 0.08050359f, 
    0.06613014f, -0.28476238f, -0.31287497f, -0.05211759f, -0.14917681f, 0.06608157f, 0.31291837f, 0.06662980f, 
    0.15873541f, -0.03027300f, -0.00069780f, 0.09021048f, -0.26978213f, -0.02423573f, 0.03832213f, 0.16015238f, 
    0.18626970f, 0.03955109f, 0.00573528f, 0.08610617f, -0.03369324f, 0.00105509f, 0.02125577f, 0.01152388f, 
    0.27123597f, 0.17743050f, 0.23395759f, -0.49772581f, 0.00104232f, -0.15423252f, 0.08379669f, 0.05220838f, 
    0.06528519f, 0.06748762f, -0.19087546f, 0.16944808f, -0.05947590f, -0.54776597f, -0.29210913f, -0.24833582f, 
    -0.03451949f, -0.00933995f, -0.09791131f, -0.04732277f, -0.02438344f, 0.16912603f, -0.08249997f, 0.27108055f, 
    0.02160756f, 0.31525555f, -0.07334168f, -0.17728370f, 0.00248705f, 0.11554240f, -0.07858203f, 0.10062850f, 
    0.08615717f, -0.27878523f, 0.04174455f, -0.04201829f, -0.25306654f, -0.47017705f, -0.06972338f, -0.15042821f, 
    0.08221307f, -0.15032311f, -0.08354977f, -0.03278945f, -0.02952035f, 0.09836782f, 0.04334123f, 0.30996177f, 
    0.27804357f, -0.17076501f, 0.16984661f, 0.15629224f, -0.10413659f, -0.04845658f, 0.01093325f, 0.01771004f, 
    -0.00402206f, -0.02262208f, -0.11302564f, -0.36260200f, 0.18417615f, -0.36712182f, -0.02412482f, 0.28449830f, 
    -0.04321411f, -0.01428733f, 0.00504160f, -0.03482881f, -0.22096187f, 0.11672876f, -0.04107456f, 0.22143866f, 
    -0.03677594f, 0.23414989f, 0.06573244f, -0.03219807f, -0.16318753f, -0.01186943f, -0.04288496f, -0.03547918f, 
    0.12631269f, 0.07769538f, -0.15027946f, -0.10310165f, -0.02538423f, -0.04685652f, -0.01745932f, 0.14471501f, 
    0.02396823f, 0.02272752f, 0.01654948f, -0.04498842f, -0.15511319f, -0.06099508f, -0.12272362f, -0.42704853f, 
    -0.31801480f, 0.08109427f, -0.09222051f, -0.44418731f, -0.22328980f, -0.13915628f, 0.00234991f, -0.29365355f, 
    -0.12196202f, 0.05375075f, -0.01178918f, -0.03505811f, 0.24505869f, -0.57309091f, 0.22432984f, -0.13228108f, 
    0.17747754f, 0.06521199f, 0.07188830f, -0.03680743f, -0.07598543f, 0.00293214f, -0.04876017f, -0.01458204f, 
    -0.13740456f, 0.00819560f, -0.14669044f, -0.05575621f, -0.07961357f, 0.09659868f, 0.09749991f, -0.01067517f, 
    0.08981854f, 0.08186897f, -0.05363129f, 0.08846115f, 0.28612557f, 0.22854176f, 0.10921366f, 0.14481796f, 
    -0.13156475f, 0.15228710f, 0.05434439f, -0.06313825f, 0.23057930f, -0.07668579f, -0.00566753f, -0.02695942f, 
    -0.05151412f, -0.14730987f, -0.04036968f, 0.38808987f, 0.10120089f, 0.09524645f, 0.05369182f, 0.00986131f, 
    0.14058360f, -0.11081745f, -0.05487800f, 0.03092519f, 0.24294063f, -0.22558862f, 0.18056844f, -0.21952011f, 
    -0.29423657f, -0.02379852f, 0.02535759f, 0.09366548f, -0.06020932f, -0.02821193f, 0.12275386f, 0.01735453f, 
    0.12034351f, 0.01163346f, 0.14701280f, 0.07102729f, -0.02184496f, 0.11346366f, 0.02947555f, -0.11905756f, 
    -0.04801875f, -0.13916242f, -0.10628214f, -0.05362508f, -0.08440685f, 0.05832901f, 0.08421283f, 0.01209345f, 
    -0.03695275f, 0.07233000f, 0.01858716f, 0.05652122f, -0.09597173f, 0.08150978f, -0.05008088f, -0.11954187f, 
    -0.02065638f, -0.06410698f, -0.15540917f, -0.05525925f, -0.10247341f, 0.03866920f, -0.17930005f, -0.11404324f, 
    0.07374755f, -0.09348875f, 0.00391093f, -0.20058581f, 0.56466019f, -0.37479526f, 0.23821388f, 0.12649384f, 
    -0.11939014f, 0.00396404f, -0.01624369f, -0.02010535f, -0.12968642f, 0.07155786f, 0.08730951f, 0.04549843f, 
    -0.13934024f, 0.09791534f, -0.15732235f, -0.50570685f, -0.14759400f, 0.11320433f, -0.12385264f, -0.07667476f, 
    -0.00341246f, -0.19963288f, -0.00048266f, 0.13320686f, 0.18374614f, 0.11434515f, 0.17500180f, -0.03189728f, 
    -0.15179837f, -0.05779592f, -0.04143913f, 0.08199956f, -0.02973949f, 0.13758047f, 0.14346333f, 0.03953392f, 
    0.17906988f, -0.07200987f, 0.15807702f, 0.22492735f, -0.06685563f, 0.01876521f, -0.10971841f, 0.00757197f, 
    -0.22315107f, 0.06484791f, -0.02685467f, 0.02022237f, 0.24127916f, 0.06129236f, -0.01165788f, -0.33949196f, 
    -0.02840616f, -0.00387718f, -0.01825077f, 0.08054628f, -0.06156976f, 0.13685741f, 0.07818948f, 0.04977982f, 
    0.11066084f, -0.14468212f, 0.04604176f, -0.20605998f, -0.05418745f, 0.00844332f, 0.14014551f, -0.21639858f, 
    0.05701964f, -0.25224239f, 0.17380142f, -0.00553618f, 0.29781857f, 0.00143796f, -0.15635768f, -0.11332086f, 
    -0.13278653f, -0.00897828f, -0.01347625f, 0.07857120f, 0.05175713f, -0.02022942f, 0.00447903f, -0.14574076f, 
    -0.30941549f, 0.58025366f, 0.20572542f, -0.56081378f, 0.00125170f, 0.22883075f, 0.20560612f, -0.11058000f, 
    -0.13609333f, -0.05522462f, 0.05738103f, -0.05294774f, -0.26010585f, 0.06189374f, 0.17591025f, -0.09705153f, 
    -0.14472534f, -0.12566125f, 0.01630412f, 0.12745394f, 0.08644456f, -0.07919040f, 0.03277642f, 0.14835344f, 
    -0.26605204f, 0.23427492f, 0.29788718f, -0.17446016f, -0.18898319f, -0.06716482f, -0.00093174f, 0.06906074f, 
    -0.08117942f, -0.05601349f, 0.08791719f, -0.15966788f, -0.54972881f, -0.18040787f, -0.19065619f, 0.15529960f, 
    0.12937556f, 0.01403994f, 0.14467035f, -0.05441763f, -0.00037012f, 0.00821216f, 0.00606530f, 0.02611104f, 
    -0.05536477f, -0.33607727f, 0.08277244f, 0.15740196f, -0.01564560f, 0.13827674f, 0.01034898f, 0.24425678f, 
    0.00242614f, -0.15506187f, -0.13119166f, 0.08278591f, -0.34148496f, -0.02320602f, -0.24846818f, 0.27120495f, 
    0.13848524f, 0.08209670f, -0.13131745f, 0.05678254f, 0.20102677f, 0.08404771f, 0.19662160f, 0.08634251f, 
    0.28663662f, 0.22951061f, 0.10168533f, 0.11932471f, 0.02171082f, -0.00800915f, 0.04589910f, -0.01471333f, 
    -0.00204331f, 0.00261243f, -0.09594706f, -0.00939866f, 0.15356255f, -0.48839027f, -0.03814315f, -0.11352412f, 
    -0.01204746f, -0.02355064f, 0.01782600f, -0.03510445f, -0.15077078f, -0.19866882f, -0.00697631f, -0.04349168f, 
    0.11694899f, -0.46311370f, 0.06341319f, 0.18298693f, -0.03428740f, -0.07620239f, 0.04061106f, -0.06192891f, 
    0.01242958f, -0.03063388f, 0.01577660f, -0.12551743f, -0.07462067f, -0.03496863f, 0.11202151f, 0.01738800f, 
    0.15194422f, 0.10671692f, 0.14932369f, -0.02300263f, -0.18967824f, 0.15007845f, 0.05293990f, -0.02448335f, 
    -0.18807368f, -0.18123154f, -0.21619242f, 0.07034036f, 0.04491405f, -0.12055688f, -0.08015416f, -0.08252821f, 
    -0.10115124f, -0.02285829f, -0.03588282f, -0.13675182f, -0.06223298f, 0.02944477f, 0.09186016f, 0.02564295f, 
    0.17545681f, -0.01258805f, -0.00976978f, -0.06726968f, -0.00302638f, -0.02884593f, -0.02063679f, -0.00283545f, 
    0.26095662f, -0.39338425f, 0.03097969f, -0.05374915f, -0.03642535f, -0.10414089f, 0.01389078f, -0.01507885f, 
    -0.02864126f, 0.03249946f, -0.17270571f, -0.05400870f, -0.03187232f, 0.02765772f, 0.02494439f, 0.14624262f, 
    -0.03339138f, -0.04251540f, -0.01426239f, 0.08992197f, -0.03966422f, 0.03794571f, 0.03876576f, 0.10189733f, 
    -0.08967992f, 0.03438422f, -0.07497298f, -0.29303569f, -0.01288675f, 0.05589591f, 0.05002415f, -0.07428023f, 
    -0.14127687f, 0.04528563f, -0.03037190f, -0.08953609f, 0.24723069f, 0.09842208f, 0.27892759f, 0.04425336f, 
    0.20833562f, 0.09954985f, -0.10082196f, 0.04343933f, -0.12007780f, -0.10686775f, 0.02481701f, -0.07192554f, 
    0.28298864f, 0.24327415f, 0.21644734f, 0.26093397f, 0.15416619f, 0.09442702f, 0.03503374f, 0.02505651f, 
    -0.10991722f, 0.10535963f, -0.00685697f, -0.07293147f, 0.32731581f, -0.16594182f, 0.09295933f, -0.02111190f, 
    0.02674661f, -0.00268963f, -0.03313598f, 0.08459310f, -0.03357550f, 0.12251543f, 0.02188968f, 0.03497551f, 
    -0.37202260f, 0.29752880f, -0.10841798f, -0.05658593f, 0.05424192f, 0.00540819f, 0.02336799f, 0.01750158f, 
    -0.04560979f, 0.09773356f, 0.07570248f, -0.10799082f, 0.16933374f, 0.01479831f, 0.03078841f, 0.22141801f, 
    -0.09069892f, -0.22578400f, 0.10046709f, -0.08570272f, -0.01557872f, 0.05133795f, -0.13259780f, -0.01038764f, 
    0.03013695f, 0.14265898f, -0.15312718f, 0.01223904f, -0.12568456f, -0.02549022f, -0.06909312f, 0.00938880f, 
    -0.07782397f, 0.05065146f, 0.01294403f, -0.09215841f, -0.25194147f, 0.02580571f, -0.21620214f, -0.15411359f, 
    -0.06783991f, 0.02209558f, -0.07914665f, -0.18402855f, -0.14137657f, -0.09325077f, -0.12835249f, -0.19106233f, 
    0.33940482f, -0.48449469f, 0.13790314f, 0.30468097f, -0.04035912f, -0.14113770f, -0.03136619f, -0.04248733f, 
    0.02375334f, -0.03804681f, 0.00784593f, -0.09333710f, -0.03791868f, 0.03390096f, -0.02398050f, -0.22574756f, 
    -0.11274359f, -0.02364675f, 0.06092868f, -0.03260420f, -0.08197787f, -0.00780868f, -0.07607485f, -0.14087272f, 
    -0.20635577f, -0.13132279f, -0.14619455f, 0.25922951f, -0.07352619f, -0.15477586f, -0.14295131f, -0.04117099f, 
    -0.08181524f, -0.06494959f, -0.05294651f, 0.01891259f, 0.11905435f, 0.12395582f, 0.03135054f, 0.12462031f, 
    0.18254583f, -0.04050764f, 0.00393155f, -0.02437827f, 0.02737711f, -0.00967650f, -0.07128088f, -0.15056249f, 
    0.13437140f, 0.17853652f, 0.13714804f, 0.26409569f, 0.07572316f, -0.00608887f, 0.00082474f, -0.05245828f, 
    -0.02705297f, -0.10755241f, -0.06400106f, -0.13698344f, -0.26869568f, 0.07968712f, -0.07515644f, -0.19748181f, 
    -0.04732441f, -0.02409973f, -0.03749099f, -0.02139696f, -0.08474427f, -0.07291773f, -0.02608456f, -0.12378256f, 
    0.04945946f, 0.15954737f, 0.09284160f, 0.33973980f, 0.13664201f, -0.06804793f, -0.01744892f, -0.01934749f, 
    -0.05957388f, 0.01050381f, 0.05894820f, 0.01960925f, 0.21489105f, 0.23861565f, 0.26043722f, 0.00565368f, 
    -0.27821741f, -0.05356588f, 0.04312695f, -0.12425753f, -0.01511188f, 0.10635917f, -0.18907283f, -0.07002208f, 
    0.19863972f, -0.02317390f, 0.20296562f, -0.08409467f, 0.02562537f, 0.06027097f, -0.07819198f, -0.06456272f, 
    -0.01994642f, 0.07112692f, -0.02304179f, -0.01919630f, -0.56154883f, -0.01371776f, -0.07848867f, 0.04058944f, 
    -0.08435558f, -0.15704621f, -0.19902174f, -0.08400698f, -0.09561095f, -0.03729810f, -0.06512889f, -0.00752867f, 
    -0.06156989f, 0.19504873f, -0.03397443f, -0.24741714f, 0.01155715f, 0.00031538f, -0.06286376f, -0.05985198f, 
    -0.06983994f, -0.07648997f, -0.02520580f, -0.01712221f, -0.04139049f, 0.07502728f, -0.19258974f, -0.12235492f, 
    -0.11150346f, -0.12576775f, -0.00870819f, -0.10098292f, 0.04599367f, 0.03668332f, -0.08843291f, -0.01799683f, 
    -0.11264119f, 0.22480382f, -0.03747509f, -0.19155970f, 0.02421336f, -0.00416789f, -0.12047058f, -0.08851598f, 
    -0.13917269f, 0.05772322f, -0.02996166f, -0.06332688f, 0.02465174f, 0.16527641f, 0.23433645f, 0.19583204f, 
    0.16891429f, 0.00927165f, 0.02716337f, -0.04694229f, 0.01290677f, -0.05851953f, -0.02134600f, -0.04467162f, 
    -0.04488367f, -0.00150102f, 0.09504079f, -0.22972247f, -0.22183412f, -0.13978299f, -0.10116839f, 0.04685321f, 
    -0.03093169f, -0.02522764f, -0.01340729f, -0.08271457f, 0.10451564f, 0.16711216f, 0.03405471f, 0.10843834f, 
    0.03107842f, 0.12195107f, -0.01509265f, -0.01897808f, 0.05863440f, 0.01593490f, -0.03229576f, -0.19404325f, 
    -0.24566996f, 0.04453079f, 0.08641621f, -0.02458199f, -0.05235231f, -0.07101518f, -0.12330127f, 0.15096217f, 
    0.00521405f, -0.17724921f, 0.02244517f, -0.30032641f, 0.42687142f, -0.03956504f, -0.47329345f, -0.04981047f, 
    0.10404088f, -0.04005416f, 0.05596334f, -0.04963577f, 0.00146190f, 0.05284004f, 0.04250859f, 0.12728950f, 
    -0.02047615f, -0.32272547f, -0.01647327f, 0.05659185f, 0.21546841f, 0.05074850f, -0.03151281f, -0.02919240f, 
    0.13596065f, -0.05201504f, 0.10208356f, 0.05194512f, -0.07601584f, -0.07197338f, 0.26819399f, 0.11288026f, 
    -0.29442951f, 0.00063806f, 0.02292594f, -0.10080355f, 0.00520286f, -0.04380779f, 0.02312195f, -0.11069437f, 
    0.10986185f, -0.13540615f, -0.31602865f, -0.07273871f, 0.04466004f, -0.05867502f, 0.06394231f, 0.06268078f, 
    0.10894179f, 0.11700408f, -0.08423446f, 0.01177319f, -0.05141129f, -0.04852255f, 0.15038376f, 0.20762318f, 
    -0.19230241f, -0.00531047f, -0.11526469f, -0.19500834f, 0.01324598f, -0.08332008f, -0.04027851f, -0.03287735f, 
    0.18709046f, -0.32479545f, 0.00389025f, -0.12306824f, -0.06602985f, -0.01509687f, -0.01415924f, -0.24643567f, 
    -0.03976634f, 0.12945601f, 0.12970191f, 0.15329908f, 0.14472218f, 0.04381490f, -0.11637992f, 0.05878839f, 
    -0.03101722f, -0.05302409f, -0.01084531f, -0.04133245f, -0.03614533f, 0.02283403f, -0.15254073f, -0.16219072f, 
    0.10658253f, 0.10564148f, 0.16418099f, 0.20759916f, 0.02668594f, 0.03434632f, -0.06855744f, -0.06802506f, 
    0.04356082f, 0.01317687f, 0.13327473f, -0.15768993f, 0.21191886f, 0.06142849f, -0.04967064f, -0.05998221f, 
    -0.12662168f, 0.04900952f, 0.07097619f, -0.06643236f, 0.02978423f, -0.04245457f, 0.04225350f, 0.13628054f, 
    -0.46539211f, -0.06056290f, 0.18164918f, -0.15792497f, -0.05310720f, 0.03610932f, -0.06359860f, 0.14799093f, 
    0.01790947f, -0.18464157f, -0.06597682f, 0.01680575f, -0.13166195f, -0.13211504f, 0.11117083f, -0.30774802f, 
    -0.11531407f, -0.24479106f, 0.05727341f, -0.02071664f, 0.01814121f, -0.11782021f, 0.00347698f, 0.24050871f, 
    0.10707045f, 0.05454411f, -0.14239915f, 0.07486345f, 0.05027443f, -0.06799895f, -0.03128900f, -0.10284415f, 
    0.16272193f, -0.02231881f, 0.11231049f, 0.02437276f, -0.25189763f, -0.09491674f, 0.04014502f, -0.34216037f, 
    -0.18350233f, -0.10969557f, 0.03919388f, -0.09186096f, 0.00665119f, 0.18187776f, -0.00476849f, -0.08506498f, 
    -0.01373987f, 0.23348458f, -0.28820616f, -0.06420755f, -0.00370082f, -0.06633934f, -0.28960046f, 0.02935345f, 
    0.08401570f, -0.00252033f, 0.14341243f, -0.08498336f, 0.06720743f, 0.02108289f, 0.10731924f, 0.25676554f, 
    0.01109787f, -0.18017687f, -0.04826006f, 0.03434042f, -0.03223454f, 0.00339793f, -0.08874094f, -0.19195899f, 
    -0.10096806f, -0.03172079f, -0.12740028f, -0.02567813f, -0.11942255f, 0.00732466f, -0.05847985f, -0.04601689f, 
    -0.03018513f, 0.03668502f, 0.01274788f, 0.07482395f, 0.02012991f, 0.15056440f, 0.10112044f, 0.17526376f, 
    0.02802896f, 0.04074243f, -0.03591311f, -0.11225776f, 0.04777518f, 0.09744174f, 0.13565014f, -0.01323807f, 
    -0.09277302f, 0.12987812f, -0.37300727f, -0.18935229f, -0.02196633f, 0.00198512f, -0.00984451f, -0.07531100f, 
    0.15916665f, 0.11025715f, 0.02690537f, 0.05705472f, 0.11241409f, -0.30664033f, 0.12661174f, -0.00111261f, 
    -0.06145166f, -0.02291217f, 0.01303218f, -0.03864950f, 0.05812179f, -0.14160399f, 0.03641981f, 0.11334331f, 
    -0.26159370f, 0.01674751f, -0.05602697f, -0.39350897f, -0.03578017f, -0.02158072f, 0.14029741f, -0.12652162f, 
    0.04593875f, -0.04982325f, -0.05015722f, -0.29724747f, 0.15140718f, -0.05989658f, 0.12084449f, 0.10235068f, 
    0.08414204f, -0.01448667f, -0.08690429f, -0.15956225f, -0.10430617f, -0.16499083f, 0.02571916f, 0.14762294f, 
    -0.13733226f, 0.04055554f, -0.05401464f, -0.51752532f, 0.05128853f, -0.09519440f, 0.07226240f, -0.09983323f, 
    0.13305251f, -0.02848571f, 0.04408078f, -0.11021022f, -0.15019239f, 0.31507647f, -0.09632538f, -0.11582416f, 
    0.08872034f, -0.02424010f, 0.08246358f, -0.15980636f, 0.04590823f, 0.05318860f, 0.06414989f, 0.08469416f, 
    -0.23235372f, -0.04921730f, 0.35256562f, -0.03033746f, 0.05056900f, 0.02390289f, -0.02261420f, -0.10586571f, 
    0.00321615f, 0.09467413f, -0.03764863f, -0.00376571f, -0.23634501f, 0.11331654f, -0.21716473f, -0.03437972f, 
    -0.08421726f, 0.03790936f, -0.18605593f, 0.06189088f, 0.05397258f, 0.04772088f, -0.10462319f, 0.08336287f, 
    -0.13669458f, -0.51288903f, -0.04556348f, 0.17930709f, 0.08013330f, -0.07001152f, -0.02576959f, 0.02666557f, 
    -0.00127716f, 0.07026969f, 0.23664029f, -0.04714241f, 0.41142333f, 0.04812699f, 0.13241971f, 0.11980468f, 
    0.11836988f, 0.04745883f, -0.11369564f, -0.14369231f, 0.03970458f, -0.14613470f, 0.11595564f, -0.08293017f, 
    0.16976114f, 0.10606375f, 0.10289365f, 0.12667309f, -0.04253763f, 0.06937169f, 0.01115210f, -0.13048768f, 
    0.02773709f, -0.02557474f, 0.07835761f, 0.04300351f, 0.01885634f, 0.32978255f, -0.02099396f, 0.24583720f, 
    -0.11904406f, -0.09850536f, -0.08746276f, -0.06205316f, -0.02331104f, -0.09851310f, -0.03852215f, -0.01371892f, 
    0.36861682f, -0.28560221f, 0.01329743f, 0.01933840f, -0.26263696f, -0.15542996f, -0.01049922f, -0.13454486f, 
    -0.04607357f, -0.08290254f, -0.17786992f, 0.01976939f, -0.19729568f, 0.28376603f, -0.11230978f, -0.34478709f, 
    0.03562743f, -0.04554833f, -0.05295062f, 0.10175193f, 0.07623184f, -0.10774689f, -0.17985645f, 0.07385731f, 
    -0.25181118f, 0.20340802f, -0.09399778f, 0.27377665f, 0.04557315f, -0.00644758f, -0.10031075f, -0.04721683f, 
    0.06506652f, 0.07124557f, 0.03549968f, 0.00482034f, 0.10927569f, -0.17129780f, 0.27593938f, 0.05205536f, 
    0.07126947f, 0.10275004f, 0.02065931f, -0.07711944f, -0.14220898f, 0.06332357f, -0.04119979f, 0.05977941f, 
    -0.14026502f, -0.13053690f, -0.17564107f, -0.40330058f, 0.05955258f, 0.02884631f, 0.02014438f, 0.09554081f, 
    0.01242289f, -0.01450655f, 0.02733253f, -0.07947280f, 0.15698440f, -0.24995510f, 0.15332845f, 0.12855038f, 
    0.10238217f, -0.09583456f, -0.01059785f, 0.04000885f, -0.12172993f, 0.00129177f, -0.14693740f, -0.04566356f, 
    -0.13293687f, 0.08252180f, 0.11722635f, -0.41308558f, 0.00473194f, -0.01194819f, 0.07688507f, -0.10717371f, 
    -0.14081661f, 0.18307126f, 0.06436915f, 0.02302813f, 0.22583611f, -0.40395695f, 0.01320169f, 0.09516180f, 
    0.00262785f, 0.09654545f, 0.22022395f, 0.04557845f, -0.09245212f, 0.09515203f, 0.09986086f, -0.01839818f, 
    0.21447454f, 0.10229208f, -0.29154864f, 0.08071924f, 0.02572073f, -0.04538874f, 0.00854530f, 0.07511993f, 
    0.22181123f, -0.12051519f, -0.09214626f, -0.12450527f, 0.11588523f, -0.30489814f, 0.04323508f, 0.14815655f, 
    0.05830899f, -0.00066861f, -0.14881663f, -0.08686453f, 0.11704317f, -0.10911713f, 0.16483012f, 0.15843144f, 
    0.02519630f, 0.01742075f, 0.00757207f, -0.42505437f, 0.02585442f, 0.10946805f, 0.05234852f, 0.13837470f, 
    -0.01835540f, -0.04846466f, 0.05180564f, -0.13763422f, -0.17746155f, -0.48161396f, 0.06898691f, 0.04565453f, 
    0.24880135f, 0.09662944f, -0.08999738f, 0.06414592f, -0.10165010f, 0.03996480f, 0.08055031f, -0.11218917f, 
    0.04777562f, -0.08881083f, 0.04514542f, 0.12251355f, 0.11714399f, -0.06686860f, -0.11728094f, 0.10707447f, 
    -0.11924402f, -0.01287727f, -0.11816782f, 0.09764679f, 0.83489853f, 0.27805403f, -0.15895858f, 0.16489154f, 
    0.11273468f, -0.05176240f, 0.09597696f, 0.05735202f, -0.15816763f, 0.00356408f, 0.09137768f, 0.06245689f, 
    -0.41665578f, 0.55037451f, -0.07892449f, -0.59921551f, 0.08490299f, -0.02314386f, -0.12294844f, 0.00792334f, 
    -0.10996982f, 0.02834769f, 0.02482669f, -0.24970433f, -0.38563085f, 0.11997846f, -0.13340549f, -0.03134112f, 
    0.14462744f, 0.05037534f, 0.00395369f, 0.00138513f, 0.01145921f, 0.07485609f, -0.01991990f, -0.05727502f, 
    -0.35674363f, 0.29064384f, 0.38750637f, -0.04560502f, 0.18355107f, -0.00787921f, -0.08135865f, 0.07021582f, 
    0.19578786f, -0.07486179f, -0.13358434f, 0.00482265f, -0.40917292f, 0.35927263f, -0.31365153f, -0.17304525f, 
    0.28391671f, -0.10271920f, 0.04068916f, -0.16990919f, 0.03324720f, -0.01291917f, 0.02692628f, 0.07977465f, 
    0.02784264f, -0.17976186f, 0.16981165f, -0.43248948f, -0.01235032f, 0.05433289f, -0.07757889f, 0.01162568f, 
    -0.08551479f, 0.08920757f, 0.05813568f, -0.26919937f, 0.30193403f, 0.06287193f, -0.18860824f, -0.27004787f, 
    0.04953763f, -0.14962184f, 0.11188646f, 0.05557712f, 0.06861724f, -0.02281318f, -0.06302849f, 0.01629398f, 
    0.20455346f, 0.07422054f, -0.44414768f, -0.10239825f, 0.03132297f, -0.01495133f, 0.13359956f, 0.17038000f, 
    -0.09336985f, -0.15909007f, 0.02321601f, -0.00677652f, -0.12470901f, 0.05645024f, -0.27160788f, 0.02581995f, 
    0.00509958f, 0.00404634f, 0.03183701f, -0.04192868f, 0.12431295f, 0.25201115f, 0.01965930f, -0.04646786f, 
    -0.08134316f, -0.07601555f, -0.13591041f, -0.01215400f, -0.13646336f, 0.11965214f, 0.08838245f, -0.04724504f, 
    -0.00941046f, 0.04066560f, 0.00900791f, -0.00471635f, 0.00981513f, 0.05684770f, 0.01969207f, -0.33976597f, 
    0.19972929f, -0.04491738f, 0.07463058f, -0.17068258f, -0.06115637f, 0.00450080f, 0.03622431f, 0.03389234f, 
    -0.41701895f, -0.56865841f, -0.01773075f, 0.06902463f, -0.07007079f, 0.00553972f, -0.07454846f, -0.05170650f, 
    -0.14355262f, -0.18959397f, 0.11310489f, 0.12044715f, -0.51607293f, -0.11134651f, -0.23410861f, 0.34404659f, 
    0.02856660f, -0.02200310f, -0.05339904f, -0.11870304f, -0.07407165f, 0.19245180f, -0.05057640f, 0.10250671f, 
    0.14385761f, -0.35706753f, -0.11535078f, 0.13280138f, -0.08728764f, 0.00366248f, -0.14240742f, 0.10026009f, 
    0.02238162f, 0.02859247f, 0.04265707f, -0.15746684f, -0.21381108f, 0.18216899f, 0.03039917f, -0.23677371f, 
    0.01686443f, 0.13872230f, 0.10611439f, -0.00178518f, 0.02620790f, 0.03773149f, 0.13659751f, 0.10179367f, 
    -0.52676201f, -0.16292562f, 0.13322254f, -0.00639566f, -0.09278885f, 0.02048124f, 0.08882386f, -0.08917445f, 
    -0.00147075f, 0.05197293f, -0.12684774f, -0.06151970f, -0.28881288f, 0.24827588f, -0.07800163f, -0.11603510f, 
    0.03379545f, -0.03425347f, -0.00622185f, -0.02555352f, 0.05800887f, 0.08532882f, -0.02870730f, 0.03288078f, 
    0.14623518f, 0.24455452f, -0.22442840f, -0.22496197f, 0.02672692f, 0.04988604f, 0.06992182f, -0.07706968f, 
    -0.12422004f, -0.02083956f, 0.02682519f, -0.14537728f, 0.32603621f, -0.60380214f, 0.04440063f, 0.00821888f, 
    -0.01952887f, -0.01106414f, -0.10151678f, 0.25842175f, -0.22172433f, 0.13018452f, -0.02122560f, -0.07655282f, 
    -0.45760223f, 0.23543009f, -0.09616809f, 0.40715757f, 0.13925068f, 0.12081663f, 0.00905358f, 0.04396836f, 
    -0.13329190f, 0.01592707f, 0.09804637f, 0.03037991f, -0.03754439f, 0.30776006f, -0.00413279f, 0.25317833f, 
    -0.02592651f, 0.01938256f, -0.03862077f, 0.19373652f, -0.04879035f, -0.29333457f, 0.19008066f, 0.01290908f, 
    0.23112524f, 0.18135934f, 0.09868032f, 0.02828606f, -0.14819029f, -0.06754774f, 0.02328230f, 0.12747110f, 
    -0.16356495f, -0.17622243f, 0.04604680f, 0.03465521f, -0.77999848f, -0.19158570f, 0.09313921f, 0.09962479f, 
    0.06605536f, -0.00198307f, 0.02747139f, 0.09236287f, 0.12904300f, 0.07280735f, -0.14278339f, 0.01229944f, 
    -0.30810949f, 0.17390560f, -0.11302657f, -0.36490324f, -0.02500909f, 0.08035208f, -0.11595326f, 0.02987757f, 
    0.02050908f, 0.10966299f, 0.07243554f, -0.03121756f, 0.24540934f, 0.19509141f, -0.10022011f, 0.07015333f, 
    -0.13371810f, -0.08629707f, 0.03788585f, 0.08847316f, -0.03832237f, 0.06162367f, 0.02850299f, -0.01007168f, 
    -0.04997478f, 0.10155907f, 0.12912494f, -0.01274662f, 0.07136209f, 0.07300737f, -0.08838462f, 0.04930993f, 
    0.05833693f, 0.02826416f, 0.06394622f, 0.04503186f, 0.02798991f, 0.16342929f, -0.13830674f, -0.20899367f, 
    -0.03671667f, -0.18565926f, -0.09418598f, -0.08371765f, -0.07816909f, -0.06963137f, -0.14250712f, -0.10551223f, 
    -0.06015548f, 0.16433755f, -0.04362005f, -0.10630018f, -0.03689411f, 0.09926076f, -0.04564646f, 0.05250698f, 
    -0.03195820f, 0.11010743f, 0.10658161f, 0.24160272f, 0.17185113f, 0.14160269f, -0.20192966f, 0.01159945f, 
    -0.22497629f, -0.19737796f, -0.00639022f, -0.15650778f, 0.06794628f, 0.13985080f, -0.03885705f, -0.13442181f, 
    -0.92226160f, -0.53199810f, -0.08311064f, -0.26521370f, 0.11878903f, -0.09808264f, -0.09853607f, -0.15960474f, 
    -0.02950810f, -0.00353250f, 0.05925234f, -0.09425762f, -0.12781575f, 0.09370391f, 0.06112723f, 0.18235326f, 
    0.09193503f, 0.00351325f, 0.10847729f, -0.04179575f, 0.00934731f, 0.16909356f, 0.08890910f, 0.19765173f, 
    -0.01125245f, -0.19879659f, 0.05298229f, 0.05585521f, -0.00100039f, -0.06068576f, 0.08570205f, -0.10038076f, 
    0.06657039f, -0.05563524f, 0.13821568f, 0.04304917f, -0.03610108f, 0.04168561f, 0.08776804f, 0.17144611f, 
    0.08667035f, -0.03836637f, 0.11540924f, -0.04933589f, 0.14959772f, 0.04581158f, 0.13463154f, -0.05747321f, 
    -0.45040265f, -0.09587403f, -0.28594324f, -0.39755672f, 0.15028380f, 0.00495778f, -0.07113166f, -0.02332849f, 
    -0.05779750f, -0.06332736f, 0.06582617f, -0.00351720f, 0.45483407f, 0.07287405f, 0.02462705f, 0.22406220f, 
    -0.00869002f, -0.02161847f, 0.15144536f, -0.09844122f, 0.00546065f, 0.09873107f, 0.00153928f, 0.04830850f, 
    -0.34617493f, -0.14603733f, 0.08875383f, 0.02793083f, 0.00357473f, 0.10269144f, -0.00118250f, -0.09150977f, 
    0.03540136f, -0.14616068f, 0.11114361f, 0.01323436f, -0.07221346f, -0.38949591f, -0.22053413f, 0.03363914f, 
    -0.03157387f, -0.20707005f, 0.02434242f, 0.10888511f, -0.05209468f, -0.05747456f, -0.14107226f, 0.05474411f, 
    0.28289142f, 0.22547655f, -0.29687703f, -0.24337755f, 0.00165819f, -0.04497761f, -0.05401937f, 0.16260549f, 
    0.07041977f, 0.01488690f, 0.15483488f, 0.10956123f, -0.80423796f, -0.31941891f, 0.02007020f, 0.05622333f, 
    0.13148461f, -0.02188582f, -0.12671699f, -0.10115008f, -0.01971666f, 0.07890200f, 0.10949553f, 0.08290971f, 
    0.31264186f, 0.06498541f, 0.09900958f, -0.13073742f, 0.16218866f, 0.11832763f, 0.05903729f, 0.08195706f, 
    0.09028748f, 0.26257682f, 0.04273640f, 0.17746457f, 0.01052815f, 0.08567060f, -0.19128171f, 0.04956508f, 
    -0.25551754f, -0.03863918f, 0.03298236f, -0.08401658f, -0.07664750f, -0.07932861f, 0.09631322f, -0.02051004f, 
    0.07120370f, 0.12883803f, -0.06924624f, 0.04771152f, 0.06674732f, 0.10176046f, -0.05828102f, -0.03918002f, 
    -0.03418278f, 0.16936827f, -0.15248795f, -0.01725128f, -0.36167371f, -0.31828177f, -0.04111208f, -0.13346516f, 
    0.16071226f, 0.05885445f, -0.21691582f, -0.07237624f, 0.04384388f, -0.06381059f, 0.10622171f, 0.02997223f, 
    -0.25466460f, -0.06783033f, -0.26522544f, 0.03013392f, 0.06088367f, 0.11516465f, 0.00719239f, -0.02236698f, 
    0.03703554f, 0.23906356f, 0.02094588f, -0.08358710f, 0.10463805f, -0.10766352f, -0.02475331f, -0.06207364f, 
    -0.14192101f, 0.18615618f, 0.13505684f, -0.09935433f, 0.07930493f, -0.06312327f, 0.04726732f, -0.00032640f, 
    0.26331541f, -0.00306713f, -0.04448065f, 0.00065700f, 0.05548474f, 0.02269938f, 0.01990189f, 0.07589412f, 
    0.01274516f, 0.00338310f, -0.08446229f, 0.03320049f, 0.35339606f, -0.20005262f, 0.17473710f, -0.01428392f, 
    0.13761744f, 0.09462015f, 0.09385062f, 0.15920062f, 0.03551158f, -0.00715288f, -0.08675274f, 0.08592469f, 
    -0.60430920f, -0.52655405f, 0.12586425f, -0.16156569f, 0.05724852f, -0.10846261f, -0.09735917f, 0.06873652f, 
    0.02522301f, -0.00875692f, 0.13270466f, 0.23794664f, -0.53888905f, -0.15448739f, -0.20049091f, -0.28157946f, 
    0.06254264f, 0.24200517f, -0.00280733f, -0.04268504f, 0.08599153f, -0.14110914f, -0.04709956f, -0.05159129f, 
    -0.45343298f, -0.28408122f, -0.13983177f, -0.06971458f, 0.23209856f, 0.04877430f, 0.11010448f, 0.12701055f, 
    0.16829084f, 0.16759622f, 0.00208835f, 0.27358717f, 0.07572105f, 0.00894000f, 0.01596661f, 0.02833232f, 
    -0.14143997f, -0.01663152f, -0.01284425f, -0.08682157f, 0.00119355f, 0.01234736f, 0.01880195f, -0.08900283f, 
    0.37958688f, 0.02722588f, -0.10370851f, 0.13049437f, -0.03399129f, -0.17981498f, -0.10322753f, 0.07713360f, 
    -0.00506418f, -0.13953108f, -0.16890486f, 0.09302481f, -0.25806853f, -0.02807388f, 0.17849688f, -0.17163146f, 
    -0.10932032f, 0.07694722f, 0.10522595f, -0.13826910f, -0.01286084f, -0.33018088f, -0.18803401f, -0.04601767f, 
    0.06786475f, -0.14166756f, 0.08714842f, 0.23869738f, -0.16813937f, -0.05172490f, 0.00863313f, -0.13285449f, 
    -0.15526587f, -0.02916326f, 0.00044924f, 0.20413347f, 0.75826168f, -0.04085142f, -0.04414230f, 0.22048314f, 
    -0.05607421f, -0.12246177f, -0.02247151f, -0.03946581f, 0.06127434f, 0.09320246f, 0.13767973f, 0.06967536f, 
    0.20152584f, 0.01934646f, -0.30290762f, -0.09382696f, 0.02547597f, -0.15062070f, -0.01469511f, 0.01179276f, 
    -0.02536609f, 0.03044886f, -0.12310066f, 0.06144878f, 0.02906335f, 0.00817154f, 0.06657928f, -0.02935813f, 
    -0.08923650f, 0.02039412f, -0.00040964f, 0.01308819f, -0.10548281f, -0.05658081f, 0.00350305f, -0.16045140f, 
    0.53857690f, 0.06383795f, -0.11216190f, 0.10853726f, 0.14544038f, -0.04754141f, 0.06987872f, -0.02522605f, 
    0.17264830f, -0.06591710f, 0.11013867f, 0.01026811f, -0.30464953f, 0.17998318f, -0.23003340f, -0.28968406f, 
    -0.19630793f, 0.07624116f, -0.00933650f, 0.05213582f, 0.01447027f, 0.05299128f, 0.05350634f, 0.00354062f, 
    -0.31716266f, 0.30668506f, 0.10872005f, -0.01706561f, -0.13083282f, 0.06225703f, -0.08687021f, 0.04280999f, 
    -0.08127999f, -0.00318118f, -0.06359196f, -0.02360854f, -0.08355884f, -0.29913881f, 0.10551952f, 0.21049494f, 
    0.03002052f, 0.18998404f, 0.00652508f, 0.03334525f, -0.23467432f, 0.07036117f, 0.12479521f, 0.27044991f, 
    0.45325005f, -0.35693347f, -0.11232103f, -0.20320190f, -0.01038743f, -0.06696246f, -0.09045205f, 0.02167633f, 
    0.01937332f, -0.01062667f, -0.07274158f, -0.00050998f, 0.31740203f, 0.07464143f, 0.13573146f, 0.11223880f, 
    0.06760886f, 0.02592337f, -0.02063438f, 0.00220142f, -0.13764961f, 0.07625048f, -0.02076279f, -0.13286488f, 
    0.26061603f, 0.25881141f, -0.16774851f, -0.12735926f, 0.03720633f, -0.31461385f, -0.07014762f, -0.09553482f, 
    0.00264372f, 0.02193181f, 0.03611451f, -0.05892028f, -0.35036543f, 0.06959990f, 0.09754530f, -0.14849506f, 
    -0.09710675f, 0.04146454f, -0.13333175f, 0.00495722f, 0.12416931f, 0.09817777f, -0.06293325f, -0.21359633f, 
    0.12722367f, -0.12814644f, -0.22441964f, 0.57772243f, 0.02172634f, -0.00222800f, 0.04374055f, 0.01811595f, 
    0.05706898f, -0.00850710f, -0.05644261f, 0.00718596f, 0.06841584f, -0.27861384f, -0.16412804f, 0.06042728f, 
    0.01111070f, 0.05815663f, 0.06287829f, -0.15172482f, 0.06209678f, -0.22853976f, 0.13190193f, 0.06824535f, 
    -0.12815601f, 0.12146207f, -0.13368915f, 0.06078381f, -0.01786242f, 0.10447650f, -0.03852818f, -0.10718273f, 
    0.04238822f, 0.02688753f, -0.04364048f, -0.07884025f, -0.32392800f, -0.12633894f, -0.01160220f, -0.18832372f, 
    0.07905394f, -0.01050320f, 0.00051021f, -0.02060496f, 0.06806699f, 0.11871295f, 0.09801428f, 0.21101354f, 
    -0.07291426f, 0.00161610f, -0.25220194f, 0.34311062f, -0.07041640f, 0.07661501f, 0.04910823f, 0.10379545f, 
    0.00295333f, -0.08230811f, 0.01434093f, -0.09024044f, 0.01363998f, -0.27403304f, 0.10186488f, -0.10381188f, 
    0.00504755f, -0.00926579f, -0.09667561f, 0.00612633f, 0.00424512f, -0.13459732f, -0.00164028f, -0.08205136f, 
    0.04404662f, -0.43190891f, -0.01150908f, 0.33900455f, -0.06428767f, -0.08479363f, 0.05504278f, 0.12614113f, 
    -0.13307071f, -0.02822956f, -0.06886186f, -0.11397071f, -0.53534746f, -0.13994609f, 0.05681986f, -0.12463665f, 
    -0.04562031f, 0.14914083f, 0.00142475f, 0.04220529f, -0.02783959f, 0.07051028f, -0.18122084f, 0.10408783f, 
    0.00416250f, 0.11925608f, -0.05557521f, -0.11536454f, -0.13766393f, -0.01198789f, -0.00652084f, 0.03488208f, 
    0.16578510f, -0.04559599f, 0.09323742f, 0.06828475f, 0.01722532f, -0.10999727f, -0.30277577f, -0.22658598f, 
    0.08137675f, 0.09506392f, 0.00649341f, 0.08656716f, -0.05906795f, 0.03888671f, -0.05489348f, 0.01350769f, 
    -0.19664724f, -0.20920736f, -0.09079195f, 0.07253858f, -0.25338045f, 0.15883882f, -0.13699292f, 0.02963399f, 
    0.10523254f, -0.06963639f, 0.11603278f, 0.22494076f, 0.00419959f, 0.21110322f, -0.11097606f, -0.01315640f, 
    0.26772270f, 0.02649297f, 0.16163242f, -0.05617294f, -0.10489354f, -0.09541355f, 0.00869853f, -0.08573321f, 
    -0.29444155f, 0.34644860f, 0.04603057f, -0.19127411f, -0.06393871f, -0.05465253f, -0.06898406f, 0.01194886f, 
    0.05378287f, 0.03638563f, 0.07046995f, -0.05826016f, 0.11917264f, -0.00445659f, -0.19130710f, 0.19900796f, 
    0.21991925f, -0.08926470f, 0.00698438f, 0.01140198f, -0.13993517f, 0.17413980f, -0.01401423f, -0.06386659f, 
    0.02525683f, 0.55522746f, -0.24143466f, -0.25615260f, 0.13686390f, 0.13519849f, -0.12922452f, 0.14589982f, 
    0.09200242f, 0.02983598f, 0.02495448f, -0.03671686f, -0.06378173f, -0.38619834f, -0.17428726f, -0.32438260f, 
    0.11153606f, -0.03844365f, 0.12767477f, -0.01129104f, -0.05323824f, 0.06658828f, -0.13347164f, -0.09583357f, 
    0.18322526f, -0.37967104f, -0.18994021f, -0.13967186f, 0.04084745f, 0.07190171f, -0.09023592f, 0.09741364f, 
    -0.22075796f, 0.00784712f, -0.06421886f, -0.17931309f, -0.02031724f, 0.11642419f, -0.09457196f, 0.11147863f, 
    -0.11142587f, -0.03582448f, 0.04388322f, -0.12181446f, -0.05544701f, -0.01436828f, 0.01887587f, -0.10879381f, 
    -0.04097575f, -0.22278950f, 0.11349314f, -0.17137389f, -0.00742775f, -0.14034571f, 0.02617530f, -0.04026945f, 
    -0.02547748f, 0.12707339f, 0.10094789f, 0.14123742f, -0.15396339f, 0.08794236f, 0.09071394f, -0.20681252f, 
    0.11680016f, -0.04423495f, 0.01147636f, -0.10528571f, -0.13124931f, 0.13838370f, 0.10151920f, -0.13954115f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05754263f, 0.02602778f, -0.10002643f, -0.00315608f, 0.03437160f, -0.03076791f, 0.05211895f, -0.11208039f, 
    -0.03569617f, 0.03021928f, 0.15977347f, -0.01595872f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
