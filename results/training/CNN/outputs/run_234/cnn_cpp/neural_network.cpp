#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.87504220f, 0.98429447f, 0.66100276f, 0.14491911f, 1.33647799f, -0.75564814f, -0.71736431f, -0.98499328f, 
    0.24141593f, -0.12044687f, -0.33952647f, -0.42535225f, 0.64788562f, 0.45491087f, 0.44173607f, -0.20020957f, 
    -0.06963909f, 0.19647537f, 0.23398536f, 0.57829297f, 0.20012186f, 0.01334002f, -0.20807104f, -0.08572884f, 
    -0.16607217f, -1.47604954f, -0.57038426f, -0.42729098f, -0.26849213f, -0.20992015f, -1.10067058f, -0.26136428f, 
    -0.55581039f, -1.04777682f, -0.39385617f, -0.20364253f, 0.77970189f, 0.34983432f, 0.24693640f, -0.29659241f, 
    0.37867826f, -0.20071617f, 0.28630498f, 0.30601707f, -0.14098963f, -0.17366154f, -0.23422410f, -0.14095677f, 
    0.10352464f, -0.07828235f, -1.11035633f, -0.51190394f, -1.62711287f, -0.67642194f, -0.09978263f, -0.12158086f, 
    0.28971079f, 0.50081551f, 0.50252497f, 0.76554239f, 0.28579444f, -0.24700700f, -0.05686194f, -0.31312659f, 
    0.44247654f, -0.18280059f, 0.16074574f, 0.06464161f, 0.44352004f, -0.09849557f, -0.51439786f, -0.06658448f, 
    -0.44020939f, -0.14596498f, 0.06449644f, -1.78613925f, 0.15259151f, -0.85339409f, 0.87853312f, -1.10496628f, 
    0.84244812f, 0.34842715f, -0.55134273f, 0.04116758f, -0.55423391f, -0.03382842f, 0.17435257f, -0.33111009f, 
    0.15342523f, 0.48496372f, -0.08740362f, -0.26727042f, -0.36389041f, -0.34340274f, -0.18532383f, 0.08488545f, 
    0.06554056f, 0.21104309f, -0.11381113f, -0.11090428f, -1.28860903f, -0.78925186f, -0.02876861f, 0.31276888f, 
    -0.87561166f, 0.67729557f, 1.62341702f, 0.22812484f, -0.30431193f, 0.50258613f, -0.65960073f, -0.58873469f, 
    -0.05703320f, -0.51427841f, -0.26893303f, -0.02267355f, -0.15195309f, -0.13603099f, -0.14444107f, -0.15605611f, 
    0.14685647f, -0.18620549f, -0.02568660f, -0.08304700f, 0.07777043f, -0.66246116f, 0.59580928f, 1.34812438f, 
    0.73982799f, 0.34997633f, -0.07604504f, 0.18457891f, -1.26179874f, -0.83125472f, -0.53790689f, 0.25260335f, 
    0.36112747f, 0.63258177f, 0.51396078f, 0.20513059f, 0.33418286f, -0.24154882f, -0.19917609f, 0.26655018f, 
    0.18568525f, 0.02885716f, 0.38357094f, 0.17644785f, 0.01678656f, 0.13806741f, -0.84056360f, 1.58727717f, 
    0.53925544f, 0.33219022f, 0.65664840f, 0.45517555f, 0.78952187f, 0.96125561f, 0.24710357f, 0.64390469f, 
    -0.62741303f, 0.11856707f, -0.29142523f, -0.60561883f, -0.35487783f, 0.29710206f, -0.12971199f, -0.32601452f, 
    0.09085622f, 0.14072290f, 0.10304599f, 0.18228196f, 0.08280624f, 0.43723670f, -0.03574566f, 0.84208900f, 
    -0.14557786f, 1.22899294f, -0.62080157f, -0.10640576f, 1.15630496f, -1.34495091f, 0.12137636f, -0.83273429f, 
    0.41845724f, 0.29170614f, -0.23309807f, -0.62558496f, -0.24126859f, -0.44688785f, -0.14908861f, -0.17769103f, 
    -0.22444767f, -0.49910378f, -0.37423000f, 0.30529770f, 0.09396189f, 0.08320737f, -0.10964982f, -0.11770698f, 
    1.49607170f, 0.43287599f, -1.25073028f, -0.78752720f, -0.43077773f, -0.31904465f, -0.68014771f, -0.67341554f, 
    -0.69295961f, -0.64682984f, -0.31014514f, 0.03418296f, 0.55769604f, 0.28977719f, 0.20853949f, -0.00304113f, 
    -0.10956998f, -0.62805849f, -0.09620429f, 0.18880400f, 0.01317486f, 0.18601656f, 0.51822728f, -0.21206233f, 
    0.32151484f, 1.37845707f, 0.16311108f, 0.16361085f, 1.39483547f, 1.20623410f, 1.13730395f, 0.19937284f, 
    -1.28998590f, -0.14621574f, 0.01321730f, 0.02166832f, 0.46383089f, 0.00288375f, 0.29333913f, -0.45222566f, 
    -0.04007061f, -0.01767263f, 0.49130788f, -0.00921720f, 0.11345741f, 0.09303555f, -0.11839700f, 0.13202806f, 
    0.00130245f, 0.33029959f, 1.45241225f, 0.91766328f, 0.89233673f, 0.24921234f, 0.26498213f, 0.82893115f, 
    0.00883420f, 0.35826078f, 0.45401028f, 0.27591589f, 0.10214899f, 0.72853225f, -0.40823358f, 0.19543080f, 
    0.29165006f, 0.43143186f, -0.10189554f, -0.23468518f, -0.02250589f, 0.14030913f, 0.09734357f, 0.61961937f, 
    0.12736744f, -0.15265049f, 0.60957742f, 1.04351676f, 0.74008644f, 0.95764416f, -0.67973888f, -0.74745280f, 
    -0.22351640f, 0.71999156f, 0.15414971f, 0.02659617f, 0.85514468f, -0.38295367f, 0.50310838f, 0.29125899f, 
    -0.17406724f, -0.67363340f, -0.34617490f, -0.33661535f, -0.44909513f, -0.13314244f, -0.29929960f, -0.39468122f, 
    0.02889412f, -0.06150387f, -0.12020566f, -0.40770265f, 0.46553239f, -0.38296181f, -1.34854078f, -1.43092573f, 
    0.09439979f, 0.72619194f, -0.53304994f, 0.16900684f, 0.24303396f, 0.30441537f, -0.53785646f, -0.27283627f, 
    0.18397824f, -0.21931855f, -0.69549662f, -0.01223764f, 0.11651971f, 0.37692884f, 0.02209815f, -0.10535204f, 
    0.19146660f, -0.02606643f, 0.34940937f, 0.60144770f, 0.10075820f, 1.47326159f, 1.08345437f, 0.61975801f, 
    1.12885785f, -0.23671497f, -0.71364141f, -0.29979694f, 0.02139496f, -0.11487667f, 0.36556885f, 0.37997052f, 
    -0.27318773f, -0.19913217f, 0.10736193f, -0.46436116f, 0.02459712f, -0.17393309f, 0.37712014f, -0.66349375f, 
    0.03134016f, -0.07868854f, 0.16646321f, 0.05957674f, 0.24442653f, -0.25750512f, 1.29698563f, -1.19053078f, 
    -0.40561813f, -1.06992173f, -0.61802280f, 0.92154366f, 0.74388868f, 0.56347388f, 0.18204831f, -0.24415638f, 
    0.11435114f, 0.15121235f, -0.74609697f, 0.01622796f, -0.11216073f, -0.07221913f, 0.12657906f, -0.01195304f, 
    0.42071179f, 0.35594758f, -0.11790794f, -0.07300523f, 0.06540523f, -0.01280682f, 0.05627858f, -0.65135014f, 
    -1.54392529f, -1.16908777f, 0.11305237f, -0.15335852f, -0.81243861f, 1.10652280f, 0.53825808f, -0.85717356f, 
    0.62099642f, 0.83871257f, 0.41820213f, 0.31523833f, 0.15646291f, 0.55713493f, -0.32977211f, 0.26955312f, 
    0.48650947f, -0.09585267f, -0.06727526f, 0.23724481f, 0.04144093f, 0.05362291f, -0.09477650f, 0.11325538f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.19082278f, 0.36566469f, 0.03657502f, 0.36901197f, -0.03821409f, 0.01492969f, 0.08876532f, 0.48960096f, 
    0.39913082f, 0.18015845f, 0.44438827f, 0.02014982f, 0.26985347f, 0.31076846f, 0.31495816f, 0.61871487f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.23523729f, 0.10148516f, 0.17695428f, -0.28786147f, -0.29654682f, 0.00699232f, -0.08246765f, 0.03893976f, 
    -0.06164881f, -0.12448396f, -0.10818235f, 0.00084806f, -0.54945892f, -0.36637461f, -0.07939380f, 0.27651337f, 
    -0.06211879f, -0.10620695f, 0.07060840f, 0.23715071f, 0.22678754f, 0.07009386f, -0.18081562f, -0.16321291f, 
    0.24601783f, 0.09269474f, -0.23898610f, -0.20095411f, 0.08925606f, -0.10666579f, -0.02545644f, 0.06047510f, 
    -0.00697081f, 0.08500671f, -0.04618517f, -0.00985503f, 0.71428692f, 0.12773187f, -0.30847844f, -0.19546576f, 
    -0.05756127f, 0.04826881f, -0.22380917f, -0.06971718f, 0.14328870f, 0.06558583f, -0.02614943f, -0.05964406f, 
    0.63755149f, 0.66197485f, 0.27988207f, -0.19130944f, 0.18810536f, 0.14049597f, -0.02744091f, 0.05947150f, 
    0.08587676f, -0.01617407f, -0.00360520f, -0.13877930f, -0.21861330f, 0.22975683f, 0.01789436f, -0.03566316f, 
    -0.16022024f, 0.12323324f, -0.01883122f, 0.02456526f, -0.00213863f, -0.05028740f, -0.01379490f, 0.01430359f, 
    0.12327883f, 0.09076835f, 0.27592158f, 0.07774987f, -0.11590371f, -0.12411218f, 0.11213798f, -0.36181751f, 
    -0.02685607f, -0.18776511f, -0.10565997f, -0.07912095f, -0.47180811f, -0.28097045f, 0.41291371f, -0.21642490f, 
    -0.03961379f, -0.14673159f, 0.17446810f, -0.02320845f, -0.14461458f, -0.01659910f, -0.15151431f, 0.03203682f, 
    -0.21637812f, -0.22871611f, 0.37918085f, -0.38008323f, -0.29630020f, -0.00892415f, 0.10817471f, 0.20379910f, 
    -0.16329123f, -0.02422589f, -0.02025570f, 0.12166504f, 0.09648287f, -0.38569602f, 0.12825280f, 0.65836036f, 
    -0.25475144f, -0.16058801f, -0.00692740f, 0.13593958f, -0.09952477f, 0.25793192f, 0.01542431f, -0.01563494f, 
    0.26781499f, -0.38389128f, -0.16525187f, -0.03491196f, 0.06684261f, 0.02887244f, -0.00677601f, 0.12975439f, 
    0.04826871f, 0.15138216f, 0.13799591f, -0.00112534f, -0.33555809f, 0.17608376f, 0.04273701f, -0.06243630f, 
    0.08559211f, -0.06454409f, -0.02703116f, -0.16018480f, -0.03509955f, 0.13181216f, 0.07628945f, -0.07262960f, 
    0.18845402f, -0.24888453f, 0.07514210f, -0.65303510f, 0.13997149f, 0.06643041f, 0.19008902f, 0.15280060f, 
    0.06074857f, 0.12767263f, -0.17789397f, 0.04892792f, 0.12355737f, 0.10651723f, -0.29931286f, 0.26243657f, 
    -0.33778343f, -0.12907964f, -0.14816140f, 0.11841126f, -0.04587764f, 0.05277672f, -0.01485192f, -0.21817505f, 
    0.15877989f, -0.08694797f, 0.19882268f, -0.75109476f, 0.07310074f, 0.10600598f, 0.05867979f, -0.05570241f, 
    -0.26137114f, -0.01230862f, 0.13350810f, 0.12631045f, -0.77805364f, 0.06746016f, -0.04007494f, 0.11094470f, 
    0.07262582f, -0.27043629f, -0.20026849f, 0.05445461f, -0.00835516f, -0.17587262f, -0.12623020f, 0.13248630f, 
    0.16262341f, -0.30161515f, -0.16823371f, 0.28217626f, -0.04743721f, -0.28704578f, 0.21162538f, -0.05834115f, 
    -0.09129442f, -0.05078023f, -0.18186975f, 0.05411176f, -0.00230742f, -0.10742785f, -0.02111318f, -0.10888130f, 
    -0.11119270f, 0.00343870f, -0.10264900f, -0.10585924f, -0.02196939f, 0.18345541f, -0.05920184f, 0.11526169f, 
    0.30531856f, 0.19314167f, -0.03187410f, -0.00786582f, 0.28133196f, 0.13382633f, -0.19946185f, 0.05578098f, 
    -0.00255652f, -0.06451481f, 0.05530524f, -0.06948384f, -0.72073114f, -0.01831977f, -0.39544848f, 0.09387680f, 
    -0.02566332f, -0.02699648f, -0.14276275f, 0.02413015f, -0.14570212f, -0.03599862f, -0.30456549f, -0.05783042f, 
    -0.40762031f, -0.14773074f, -0.18379970f, 0.05203779f, -0.08358137f, -0.09409675f, -0.02238904f, -0.15237918f, 
    0.11128847f, 0.07526671f, -0.09463269f, -0.10297856f, -0.36506474f, -0.08267296f, -0.07848185f, -0.15971981f, 
    -0.11015872f, 0.10303162f, 0.11408619f, -0.12207045f, 0.24147736f, 0.17458574f, 0.04464264f, 0.04557849f, 
    0.02194789f, 0.37033707f, 0.04608179f, 0.09571582f, 0.06576436f, 0.19103420f, -0.06435521f, -0.18890302f, 
    0.13210553f, 0.01884607f, 0.21633241f, 0.14019825f, 0.21143866f, 0.35218376f, -0.00234274f, -0.15541384f, 
    -0.04323557f, 0.02010424f, -0.05849710f, 0.15449111f, -0.04282597f, -0.25312600f, -0.00453601f, -0.18033251f, 
    0.17875758f, -0.51563692f, -0.01242182f, -0.58160537f, -0.04941058f, -0.20258556f, -0.05285423f, 0.07148550f, 
    -0.24562785f, 0.07310393f, -0.08008035f, -0.17420089f, 0.29059660f, -0.16519892f, 0.16295582f, -0.00606871f, 
    -0.20061307f, -0.09029724f, -0.16322862f, 0.02506051f, 0.07654261f, -0.03012755f, 0.00097383f, -0.09158099f, 
    0.40776926f, 0.04824207f, 0.34828746f, 0.24142459f, -0.21942435f, -0.08897413f, -0.09210714f, 0.01526245f, 
    -0.20071979f, -0.09213416f, -0.02698602f, 0.05859641f, 0.29342073f, 0.42988831f, -0.05807770f, -0.03694858f, 
    -0.06499986f, -0.19198363f, 0.04832591f, -0.32613224f, -0.00445358f, -0.28339171f, -0.08617985f, -0.28138959f, 
    -0.02152672f, -0.42758989f, 0.37794957f, -0.55018932f, 0.15187195f, -0.07056777f, 0.03423972f, -0.01614009f, 
    0.26166621f, -0.23823373f, 0.14725544f, 0.05170376f, 0.23284829f, -0.15501465f, 0.20455779f, 0.34095579f, 
    -0.08778123f, -0.11016678f, 0.28261122f, 0.04167262f, 0.13705757f, -0.07091429f, -0.01205408f, 0.21158662f, 
    0.55040520f, -0.72240537f, -0.15193038f, -0.21077879f, 0.12671322f, -0.00305805f, -0.09092454f, 0.22980410f, 
    0.04516151f, 0.20929019f, 0.01669533f, 0.03847266f, 0.60854846f, -0.14237213f, -0.39419115f, 0.19340122f, 
    -0.02514290f, 0.11472944f, -0.03928385f, 0.05817380f, 0.03320049f, -0.22413240f, 0.29679841f, 0.13027100f, 
    -0.30257225f, 0.01875394f, -0.17839429f, -0.24285465f, 0.26202515f, 0.21264088f, 0.18147141f, -0.21994038f, 
    0.00235043f, 0.04431817f, 0.05385720f, -0.01417561f, 0.35375103f, -0.04458069f, -0.36697388f, -0.40772134f, 
    -0.01263574f, -0.13865720f, -0.26846242f, -0.06031679f, -0.11377671f, -0.07630136f, -0.12664731f, -0.21843892f, 
    0.25727651f, 0.11789247f, 0.08294527f, 0.47821832f, -0.10204147f, -0.17123826f, -0.09934774f, 0.19540805f, 
    0.11188491f, 0.12686874f, 0.08106873f, 0.03455698f, 0.42566454f, 0.12395236f, -0.20957252f, -0.33586499f, 
    -0.17042874f, -0.18753386f, -0.14446916f, -0.02348564f, -0.08293115f, -0.09749708f, 0.02396471f, -0.05873029f, 
    0.75339007f, -0.11280593f, 0.24038045f, 0.04543744f, -0.06817012f, -0.21246982f, 0.09759143f, 0.20285980f, 
    0.34071732f, 0.30614203f, 0.06181120f, -0.05442345f, 0.48659906f, -0.00377711f, -0.22097661f, -0.25980911f, 
    -0.11697788f, 0.07360990f, -0.11282583f, 0.03385993f, -0.09875540f, -0.05487419f, -0.03185036f, -0.09510639f, 
    0.46336392f, -0.25038755f, -0.27038977f, 0.18818024f, -0.12552446f, 0.16189896f, 0.05979000f, -0.03499410f, 
    -0.30865029f, 0.14202839f, 0.05701570f, -0.06398952f, -0.34737113f, 0.27146050f, 0.13679340f, -0.19601355f, 
    -0.04841199f, 0.09401737f, -0.04420220f, -0.12391162f, -0.01004972f, 0.06632102f, -0.10514022f, -0.06215677f, 
    -0.70066142f, -0.10021462f, -0.24843356f, -0.82221431f, -0.00974055f, -0.02744682f, 0.25395882f, -0.09603819f, 
    -0.11327541f, 0.12698787f, -0.02655732f, -0.10709719f, 0.30571967f, -0.32594225f, 0.11552885f, -0.15173708f, 
    0.23282254f, -0.08045059f, -0.09251810f, -0.07009878f, -0.19059113f, 0.25887984f, -0.11601984f, -0.02859774f, 
    0.08269705f, 0.09767552f, -0.01566187f, -0.15718456f, 0.09917972f, -0.03608834f, 0.01303941f, 0.01322073f, 
    -0.05690610f, -0.02706286f, 0.14656830f, -0.16968693f, 0.02155557f, 0.29891047f, 0.01453361f, -0.42093509f, 
    -0.42533386f, 0.21175642f, 0.14472857f, 0.12925017f, -0.17551705f, 0.03939346f, -0.06107495f, 0.18306360f, 
    -0.55821800f, -0.04392258f, 0.15703765f, 0.20482729f, -0.07756953f, -0.11885301f, -0.03159728f, -0.20021012f, 
    -0.14852744f, -0.09106428f, -0.07914028f, 0.13948171f, -0.36239433f, 0.22051755f, -0.16271357f, -0.16512680f, 
    -0.11927564f, 0.02833038f, -0.01092314f, 0.18224342f, -0.24902050f, 0.07662525f, 0.02816613f, -0.18893473f, 
    -0.60225558f, 0.02794582f, 0.14549644f, 0.11929294f, 0.02161335f, -0.33338839f, 0.06112889f, 0.10003959f, 
    -0.16735116f, -0.01981938f, 0.09176727f, -0.03689902f, 0.97809970f, 0.00535718f, 0.14166901f, 0.16366747f, 
    -0.21860388f, 0.02201599f, -0.11991961f, 0.09057014f, -0.11764913f, -0.09796455f, -0.08880335f, 0.03715842f, 
    0.25647488f, -0.18992345f, -0.08185037f, 0.14398873f, 0.04512047f, 0.18404557f, 0.16254510f, -0.37892008f, 
    -0.10344620f, -0.07979295f, 0.09237280f, 0.05563113f, -0.40369919f, 0.56977296f, 0.39344898f, 0.06745363f, 
    0.06781460f, -0.02019334f, -0.00488002f, 0.06448788f, 0.07515822f, -0.07736335f, -0.19141555f, 0.16141026f, 
    -0.09525384f, 0.16140898f, -0.06125248f, -0.44384232f, -0.48861346f, -0.12479661f, -0.02128489f, -0.06531367f, 
    -0.11318743f, -0.33339152f, -0.03778850f, 0.09888802f, 0.10306732f, 0.42823562f, -0.25849003f, -0.08124524f, 
    0.22382112f, -0.03222461f, -0.00174163f, 0.24124126f, -0.00462578f, -0.05401025f, 0.07981420f, 0.10723757f, 
    -0.14854930f, -0.14803821f, 0.08377934f, -0.39450648f, -0.00742683f, -0.21075962f, 0.13068578f, 0.11125905f, 
    0.01795216f, -0.04215823f, 0.11484827f, -0.24862336f, -0.21003333f, 0.08647437f, 0.40777114f, 0.40776494f, 
    0.14330298f, 0.12079124f, 0.04195072f, 0.25552773f, -0.10675294f, -0.17064328f, -0.18177424f, -0.28931662f, 
    -0.72330540f, 0.06830555f, -0.30794534f, -0.35393068f, -0.06341010f, -0.36676320f, -0.18929212f, 0.23398967f, 
    -0.04408922f, 0.01518805f, 0.03691154f, 0.00175262f, 0.06811577f, -0.21052955f, -0.39892972f, 0.41006193f, 
    0.12783863f, 0.13768397f, 0.12224618f, -0.04987937f, 0.07701071f, 0.11063220f, 0.00721443f, -0.06689785f, 
    0.61752301f, -0.16627103f, 0.39903262f, -0.12674341f, 0.01039973f, 0.20401794f, -0.07789855f, 0.31845787f, 
    0.16268101f, 0.05222347f, -0.03776070f, -0.01306739f, 0.28505728f, -0.17097566f, -0.19585998f, 0.39856279f, 
    0.05070076f, 0.05626706f, -0.15726323f, -0.03820163f, 0.15024792f, -0.18873349f, -0.04082193f, 0.09053200f, 
    -0.90945566f, -0.83050770f, -0.37426263f, -0.07994706f, -0.28630742f, -0.25139263f, -0.00216186f, -0.08680867f, 
    -0.07392652f, -0.00067741f, -0.09095589f, -0.12858945f, -0.64998174f, 0.50187588f, 0.08882811f, 0.08563859f, 
    -0.19179046f, 0.06548214f, -0.01568774f, 0.06147381f, -0.18042819f, 0.48624235f, 0.07286789f, 0.15991470f, 
    0.03056394f, 0.11970709f, -0.02574357f, -0.01866031f, -0.15347707f, -0.22713529f, 0.16074543f, 0.11839124f, 
    -0.15450898f, 0.11202548f, -0.13024005f, 0.05854500f, 0.00011295f, -1.16213489f, -0.56138760f, 0.23352426f, 
    -0.00844855f, 0.09155633f, -0.13756545f, 0.10019244f, 0.06041188f, -0.01769150f, 0.08938262f, -0.05702111f, 
    -0.03734883f, -0.31318855f, -0.20679192f, 0.16363646f, -0.23869757f, 0.14084615f, 0.08349125f, 0.19373561f, 
    -0.07188474f, -0.02512052f, 0.12413446f, 0.09939244f, 0.23653241f, -0.20569545f, 0.12436942f, -0.06279534f, 
    -0.12827364f, -0.03123971f, 0.03733379f, -0.04189402f, 0.04506028f, 0.08202767f, -0.18806157f, 0.12391342f, 
    -0.21024771f, -0.10438318f, -0.11407197f, 0.36785454f, 0.01663355f, 0.17391801f, -0.16206051f, -0.02507875f, 
    0.20762834f, -0.02904445f, -0.19326389f, -0.01491154f, 0.06258671f, -0.06714769f, 0.44994929f, 0.27312133f, 
    0.15788367f, -0.05917562f, 0.08805481f, 0.31135184f, 0.09843114f, 0.07243548f, -0.06102914f, 0.10484076f, 
    0.22106852f, -0.05696965f, -0.21085967f, 0.37707621f, -0.00794430f, 0.06052498f, 0.12323513f, 0.22898202f, 
    -0.04197397f, -0.03290717f, 0.12660748f, 0.07379712f, -0.10658424f, -0.25908488f, -0.03861378f, -0.62839007f, 
    0.14058091f, 0.04222252f, 0.13848870f, 0.13339809f, -0.04274480f, -0.22245504f, 0.00550327f, 0.14091048f, 
    -1.13014185f, -0.20876676f, -0.07946738f, 0.15214348f, -0.09068333f, -0.12820216f, -0.11226060f, 0.06151309f, 
    -0.27855501f, 0.07783636f, -0.02427667f, 0.09032670f, -0.85847884f, 0.31646994f, 0.07908300f, -0.19940540f, 
    -0.07327418f, -0.19674675f, -0.21263710f, 0.15809675f, 0.07763603f, -0.03129196f, -0.09104431f, 0.07379466f, 
    0.27211243f, 0.07072005f, -0.13142496f, 0.21452552f, -0.02201659f, 0.07604402f, 0.20309207f, 0.22134322f, 
    -0.11643723f, 0.11026185f, 0.02544697f, -0.09891046f, -0.07216045f, 0.10042630f, -0.00355421f, -0.08899494f, 
    0.32000649f, 0.16379578f, -0.33669585f, -0.14033338f, -0.01137514f, 0.08300382f, -0.07687194f, 0.12246461f, 
    0.22819960f, -0.11798255f, -0.06883421f, 0.27419558f, -0.17756748f, -0.03420706f, 0.05320419f, 0.12944779f, 
    0.00959203f, -0.05128196f, 0.14460601f, 0.01740432f, 0.16904171f, 0.18792883f, -0.11139967f, -0.17026120f, 
    -0.04729361f, -0.01491399f, -0.00838295f, 0.07336723f, -0.18206780f, -0.18400180f, -0.00644517f, -0.01919941f, 
    -0.26337233f, -0.12316962f, -0.14018071f, -0.04905790f, -0.20348573f, -0.26152784f, -0.20184794f, -0.05185723f, 
    0.22751333f, 0.04218139f, -0.08636102f, 0.00211019f, -0.34381148f, -0.24760343f, 0.28570423f, -0.31123096f, 
    -0.00977319f, 0.05481985f, 0.08737445f, 0.27598181f, -0.04331239f, 0.05304081f, 0.30668691f, 0.12605174f, 
    0.09171455f, -0.31954893f, -0.39836973f, 0.27453515f, 0.09279620f, -0.19271480f, -0.06027839f, 0.15973234f, 
    -0.22265686f, 0.16318536f, -0.08197049f, 0.00010631f, -0.04880657f, -0.13030502f, 0.27477267f, 0.05710926f, 
    -0.34615374f, 0.19463404f, 0.07436136f, -0.01776385f, 0.05327157f, 0.06778063f, 0.01583935f, -0.21635300f, 
    -0.61525261f, 0.40628862f, 0.45798683f, 0.12906197f, -0.02272797f, 0.07128752f, 0.05223386f, -0.38237929f, 
    0.08028188f, -0.11790308f, 0.18128431f, -0.10364640f, -0.63498372f, 0.28251770f, 0.19791272f, -0.12825134f, 
    0.13929307f, 0.04972995f, 0.08037896f, -0.00445430f, 0.13037109f, 0.04236775f, -0.23435920f, -0.13499899f, 
    0.32105151f, -0.03726430f, 0.10635269f, -0.29606703f, -0.04506744f, -0.07091765f, 0.00520504f, -0.03275045f, 
    -0.19866997f, 0.15668412f, 0.23823921f, -0.02368218f, 0.14614888f, -0.00288003f, -0.40615302f, 0.04230199f, 
    0.10447755f, 0.00155061f, -0.00954727f, 0.01940393f, -0.02340553f, 0.01469613f, 0.45010471f, 0.22783762f, 
    -0.61060548f, -0.00352349f, -0.32031801f, -0.09829623f, 0.21032499f, 0.14134552f, -0.10777172f, -0.37000468f, 
    0.11039519f, 0.11164884f, -0.16910209f, 0.18690114f, -1.20572603f, 0.05551226f, 0.45491174f, -0.16371919f, 
    -0.03993457f, 0.14509135f, 0.10706089f, 0.00356634f, -0.13416034f, 0.25613144f, -0.05292476f, -0.09804101f, 
    -0.31249806f, 0.10650279f, -0.39119050f, -0.10007752f, 0.06869727f, 0.01386199f, 0.06185365f, -0.03820341f, 
    0.10346663f, -0.39883870f, -0.07883116f, -0.14591525f, 0.27660948f, -0.15511163f, 0.10260402f, 0.24125533f, 
    -0.06192952f, 0.13198613f, 0.02950063f, 0.00637229f, -0.27081826f, 0.18566523f, 0.07278275f, 0.19071710f, 
    -0.33979222f, 0.03083537f, 0.44807109f, -0.19142428f, -0.21042614f, -0.13802950f, -0.12170549f, -0.17088468f, 
    0.12040377f, 0.16946734f, -0.06606289f, -0.10324453f, -0.29523474f, -0.14072630f, 0.10216064f, 0.54127240f, 
    -0.06521170f, -0.14961030f, -0.10188991f, 0.24438290f, 0.20033574f, -0.13809662f, -0.07447416f, -0.15678731f, 
    -0.01832900f, 0.19031790f, 0.20176420f, 0.39227861f, -0.00660649f, -0.18114109f, 0.09171493f, -0.09368016f, 
    0.00989976f, -0.04451029f, 0.06620503f, 0.06690573f, -0.08587929f, -0.25279298f, 0.19948904f, 0.01912464f, 
    0.18638048f, 0.11103841f, 0.23677650f, -0.11280476f, 0.16992508f, -0.18136287f, 0.14069322f, 0.25939047f, 
    0.04581860f, 0.15061162f, 0.10676919f, 0.13993177f, 0.06720731f, 0.27864829f, 0.18288629f, 0.03393854f, 
    -0.07965231f, -0.00905400f, -0.09282245f, 0.01642835f, 0.58799016f, -0.32655221f, -0.17541580f, -0.01014995f, 
    0.10483846f, -0.40690729f, -0.17890866f, 0.01937627f, -0.05335379f, -0.29769090f, -0.19452073f, -0.20132416f, 
    0.14510651f, -0.31146100f, -0.30622646f, -0.32180908f, 0.10347064f, 0.14552073f, 0.00030313f, 0.07949829f, 
    0.23059952f, -0.31718844f, 0.30203491f, -0.28774452f, 0.18712899f, 0.14157578f, 0.01923472f, 0.16038626f, 
    0.03367759f, -0.06059227f, -0.11027143f, -0.04746716f, -0.11532573f, -0.11448313f, 0.10726847f, -0.00233208f, 
    -0.20230435f, 0.11865067f, -0.13834997f, 0.13198367f, -0.15602913f, -0.08853021f, -0.06485791f, -0.04618279f, 
    0.11284608f, 0.10574034f, -0.09683963f, 0.12333842f, -0.92418385f, -0.30940449f, -0.07089000f, -0.23052263f, 
    0.21616115f, -0.10807861f, -0.00818736f, 0.14522694f, 0.05552276f, -0.02342176f, 0.12836762f, -0.04325097f, 
    -0.14212187f, 0.66041702f, 0.41172650f, -0.29081726f, -0.07136553f, 0.07156465f, 0.05003143f, 0.14559279f, 
    -0.12834476f, -0.16804297f, 0.03250465f, 0.05797473f, -0.20611304f, -0.06126663f, -0.11410604f, -0.14224154f, 
    -0.05775812f, 0.16652489f, -0.11905409f, -0.27830547f, -0.00147372f, -0.15767954f, -0.00497344f, -0.35149407f, 
    -0.87786239f, -0.38760439f, -0.04728788f, -0.22562765f, 0.06538773f, 0.05838950f, 0.08891486f, 0.10673116f, 
    0.03593113f, -0.04194297f, 0.07062924f, 0.14280142f, 0.80389172f, 0.00475356f, 0.36752567f, 0.14313291f, 
    -0.14851381f, -0.08766256f, -0.11764868f, -0.17166880f, -0.00436273f, -0.00755263f, 0.23607151f, -0.15178727f, 
    0.41112933f, -0.86971903f, -0.09179276f, -0.18556987f, 0.09920630f, 0.21034847f, 0.06845611f, -0.08276010f, 
    -0.06257560f, -0.00059552f, 0.25423053f, 0.47113949f, 0.38626876f, -0.16573232f, 0.14996064f, -0.27000695f, 
    0.10168279f, 0.00122789f, 0.03301359f, -0.03332520f, 0.03910876f, -0.23943892f, -0.06832447f, -0.44880956f, 
    0.01631496f, 0.10145709f, -0.15189011f, 0.08379065f, -0.08467600f, -0.10972989f, 0.15032591f, 0.15929987f, 
    -0.06728692f, -0.09846792f, -0.05603974f, -0.01817529f, -0.34572586f, 0.31396529f, -0.29491714f, 0.32522783f, 
    -0.05338711f, 0.30392024f, 0.22607137f, 0.05999055f, -0.16407657f, 0.14741288f, 0.07110012f, 0.26787573f, 
    0.05488149f, -0.25243473f, -0.62403136f, 0.09978760f, 0.18750970f, 0.00418333f, -0.30662802f, -0.18298037f, 
    0.15016760f, -0.15635446f, 0.01819192f, 0.06429756f, 0.11018332f, -0.03053936f, 0.12860329f, -0.58353668f, 
    -0.28257778f, 0.15243280f, -0.03777804f, 0.00349790f, 0.01994545f, -0.09070616f, -0.04322995f, -0.02881688f, 
    -0.65359300f, 0.54081756f, 0.10557900f, 0.10300888f, -0.11450443f, -0.05613147f, -0.16246846f, 0.28908244f, 
    0.05481160f, 0.01010854f, 0.15623195f, -0.30213651f, -0.62425798f, 0.14037859f, 0.05306327f, 0.55448222f, 
    0.17123173f, 0.17268343f, -0.16176559f, -0.06098321f, 0.00372552f, -0.00226872f, 0.00311661f, 0.20894122f, 
    -0.20847580f, 0.09855673f, -0.06961745f, -0.03601795f, -0.24851120f, 0.04855177f, 0.05648482f, -0.32538721f, 
    -0.19548923f, 0.10621952f, -0.10726132f, 0.07516050f, -0.22756344f, 0.37006301f, 0.04911160f, -0.52235681f, 
    -0.05707918f, 0.16065830f, -0.02112894f, 0.06712342f, -0.05630528f, 0.26562354f, 0.06711183f, 0.11706879f, 
    0.03647771f, 0.00805300f, -0.49119195f, 0.18385507f, 0.18707067f, -0.10087927f, 0.03279956f, 0.02499082f, 
    0.01785024f, -0.08968870f, -0.12237797f, 0.06126988f, -0.17332557f, 0.01445680f, -0.03340730f, -0.21315737f, 
    -0.08512635f, -0.07394266f, 0.20263222f, 0.10042424f, 0.03146562f, 0.09463587f, -0.06660138f, -0.18248056f, 
    -0.53928959f, -0.00673218f, 0.03872623f, -0.05352775f, -0.11767109f, -0.06107295f, -0.04081006f, -0.04973452f, 
    -0.25716993f, -0.04928721f, 0.07495201f, -0.20508681f, 0.27632940f, -0.20976123f, 0.39536464f, 0.14761694f, 
    0.28682229f, 0.13013653f, -0.00856220f, -0.23693894f, 0.01243346f, -0.06852730f, -0.17111063f, -0.14856791f, 
    -0.12600225f, 0.02500606f, 0.18990518f, 0.18073317f, 0.19802591f, -0.02718187f, 0.13540198f, -0.05995143f, 
    0.01786367f, -0.01275820f, -0.01639906f, -0.03398850f, 0.13280825f, 0.00234493f, 0.12236844f, 0.35400003f, 
    0.13154617f, -0.12330998f, 0.21845444f, 0.00559391f, -0.19403888f, 0.20004447f, 0.04930978f, 0.01892665f, 
    0.10726597f, 0.30760089f, 0.24841838f, 0.21250941f, 0.37145013f, 0.05969004f, 0.01899577f, -0.01664042f, 
    -0.09191456f, 0.07554996f, 0.05284252f, 0.05697631f, 0.36555886f, -0.54589099f, -0.08434477f, 0.23343004f, 
    0.00147805f, -0.26467711f, 0.06196531f, -0.18623668f, -0.01326137f, 0.11725587f, -0.06472147f, -0.10324539f, 
    -0.38609770f, 0.30997577f, 0.13532418f, -0.15257916f, 0.03385942f, -0.02794504f, 0.01176716f, -0.27638590f, 
    -0.00929097f, -0.11317162f, -0.02195262f, 0.10362594f, -0.09160510f, -0.13485245f, -0.58858740f, -0.27552164f, 
    0.14014287f, -0.28649923f, 0.05036214f, -0.10522208f, -0.27306509f, 0.04555690f, -0.07745462f, 0.02666722f, 
    -0.25738925f, 0.20174804f, -0.10083243f, 0.27963367f, -0.16819310f, 0.01761448f, -0.06217355f, -0.14052728f, 
    -0.12875985f, 0.00574214f, 0.02446562f, -0.02047953f, -1.04323196f, 0.67883432f, -0.24211621f, -0.26679364f, 
    -0.19094779f, -0.06375825f, -0.04595499f, -0.15711124f, -0.17993625f, 0.04117590f, -0.12568150f, -0.25614473f, 
    -0.19418789f, 0.17596874f, -0.04946484f, -0.29131815f, 0.11589745f, 0.09855153f, 0.00235230f, -0.04368652f, 
    -0.19152240f, 0.00447417f, -0.06792036f, 0.02369893f, -0.17040366f, -0.47891968f, -0.09827524f, -0.29428199f, 
    -0.13694657f, 0.09080491f, 0.01790504f, 0.09176312f, -0.12425162f, -0.14943090f, -0.07206202f, 0.00920078f, 
    0.34466437f, 0.50361079f, 0.04846172f, 0.44523424f, 0.00983830f, 0.12645049f, 0.01074997f, 0.02005878f, 
    -0.40947422f, 0.03725219f, -0.11612538f, 0.02343591f, -0.07781434f, -0.00866681f, -0.02301926f, -0.36389399f, 
    -0.21001241f, 0.01712578f, -0.11156642f, -0.12641768f, -0.03311567f, -0.03720719f, -0.03685646f, -0.10750729f, 
    -0.23022102f, 0.16140881f, -0.03937092f, 0.08619478f, -0.03677169f, -0.12182597f, 0.02422068f, 0.00422427f, 
    0.09670927f, 0.06836884f, -0.12562144f, 0.04047162f, 0.41431412f, 0.05348493f, 0.40478304f, -0.07389331f, 
    0.00506428f, -0.08259193f, -0.15583262f, -0.12333046f, -0.07662074f, 0.12849961f, -0.20356312f, 0.01229672f, 
    -0.25790286f, -0.38338917f, -0.22536039f, -0.00494403f, 0.15890312f, -0.08110617f, -0.14685184f, -0.06080050f, 
    0.15707864f, 0.20557849f, 0.18802029f, -0.37657085f, -0.30374718f, -0.22839722f, -0.03659987f, -0.40441325f, 
    0.03176557f, -0.03346147f, 0.22367565f, -0.37061852f, 0.01131348f, -0.23223107f, 0.20221387f, 0.11909285f, 
    -0.50342017f, 0.06170121f, 0.42521474f, 0.24529009f, -0.02832847f, 0.16279493f, -0.16678025f, -0.18506877f, 
    0.01477407f, 0.02732095f, -0.07810360f, -0.25917110f, -0.16520832f, -0.54367787f, 0.06694070f, -0.42994305f, 
    -0.11947442f, -0.30278459f, -0.32761452f, -0.23940912f, 0.03072276f, 0.11524969f, -0.26726994f, -0.03789134f, 
    0.11589122f, -0.26407993f, 0.29610929f, -0.03311281f, -0.12401359f, 0.00912371f, 0.13764198f, -0.01797792f, 
    0.00445472f, -0.42066652f, -0.20605023f, -0.37058711f, 0.20351893f, -0.31136858f, -0.39631298f, 0.05186584f, 
    0.14037736f, -0.11730418f, 0.10464612f, -0.10018142f, 0.22102471f, 0.14308052f, 0.30452642f, 0.17020990f, 
    0.46995553f, 0.17189406f, -0.02886680f, 0.31040078f, 0.08818688f, -0.28802025f, -0.06905939f, -0.13292663f, 
    -0.04046340f, -0.02041329f, -0.28013664f, -0.08305383f, 0.06881068f, 0.32782564f, -0.06940805f, -0.09668598f, 
    -0.14431925f, -0.08256178f, -0.10823794f, -0.10718936f, 0.24704093f, -0.11422259f, -0.29841292f, -0.07872148f, 
    -0.19789575f, 0.42833877f, -0.52276015f, -0.53587806f, -0.28198603f, 0.11563883f, -0.24522486f, 0.04112708f, 
    0.25395715f, 0.24804406f, -0.07632100f, -0.14348209f, -0.00337317f, -0.14158030f, 0.01742425f, 0.27526277f, 
    -0.13553406f, 0.03911652f, 0.05059837f, -0.20302735f, 0.11082861f, -0.22819124f, 0.07911492f, -0.07922646f, 
    0.26768979f, 0.02595332f, 0.03828473f, 0.39550975f, 0.11772639f, 0.20419864f, -0.12892525f, -0.04613159f, 
    -0.02033529f, 0.01081572f, -0.11854671f, -0.03248429f, 0.67265135f, -0.07514770f, -0.42626610f, 0.03927114f, 
    0.06321072f, -0.06625766f, 0.05128173f, -0.06179469f, -0.07810083f, 0.05026799f, -0.07823017f, 0.23599485f, 
    -0.42428291f, 0.28918633f, 0.21052763f, 0.07600296f, -0.26029485f, 0.20294176f, 0.06298358f, 0.19391355f, 
    0.18764646f, -0.39868447f, 0.09042025f, -0.03413392f, -0.06561663f, -0.59970766f, -0.08267932f, 0.34436807f, 
    0.34422269f, -0.06359844f, 0.00313759f, 0.04564431f, 0.11094534f, -0.12187382f, 0.22411399f, -0.01924087f, 
    0.30911955f, 0.47543120f, -0.17590226f, 0.04292316f, -0.31547570f, -0.11370754f, -0.25177100f, -0.14781842f, 
    0.12167638f, -0.09149382f, 0.21767740f, 0.03624437f, 0.03292833f, 0.04235879f, 0.10048331f, -0.05785983f, 
    -0.13643570f, 0.07451858f, -0.11256958f, -0.08590696f, 0.17964095f, 0.17272285f, 0.09141627f, 0.10504366f, 
    -0.13907169f, -0.27215266f, -0.10253301f, -0.45774871f, -0.17962708f, 0.17926319f, 0.06239795f, -0.09109649f, 
    -0.03628594f, -0.02049603f, 0.02265407f, 0.03444162f, 0.18777648f, -0.32564589f, -0.37123719f, 0.04655389f, 
    0.04503397f, -0.02964492f, -0.09539060f, 0.06201666f, -0.07358576f, -0.04426232f, -0.13786690f, -0.00516483f, 
    0.07085885f, -1.27973318f, 0.02799065f, -0.15523537f, -0.21840978f, -0.16217613f, 0.11476340f, 0.07103769f, 
    -0.24474120f, 0.06307420f, 0.09154083f, -0.10032383f, -0.69652867f, -0.03198834f, -0.07517371f, 0.55010033f, 
    -0.08257886f, 0.14629534f, 0.13365257f, 0.12056651f, 0.18297344f, -0.18878151f, 0.07703249f, -0.09261329f, 
    0.23156697f, 0.00681045f, -0.12428086f, -0.20950836f, 0.27941972f, 0.10839948f, -0.15117908f, -0.06808843f, 
    0.00219694f, 0.24285164f, 0.07228995f, 0.32551378f, -0.05219904f, 0.19412816f, -0.11930466f, -0.56207377f, 
    0.10362063f, -0.03676859f, 0.08487403f, 0.18043570f, -0.11524615f, -0.00968133f, -0.36581486f, -0.00336282f, 
    0.17581104f, -0.74203318f, 0.12112031f, -0.00131864f, 0.12492551f, 0.07334485f, -0.00581193f, -0.00019458f, 
    -0.06367110f, -0.17211939f, 0.05307915f, 0.00095282f, 0.75561666f, -0.20617141f, -0.12728235f, -0.51231414f, 
    -0.19063225f, 0.13902889f, 0.00921812f, 0.01221349f, -0.01118194f, -0.00789832f, 0.18877120f, 0.16101068f, 
    -0.66057068f, 0.22142114f, 0.23416802f, 0.09747656f, 0.04400004f, 0.29764536f, -0.04607437f, -0.21026386f, 
    -0.15640074f, -0.14588326f, -0.14641219f, 0.17824069f, -0.66300881f, 0.99717683f, -0.59373611f, -0.53118604f, 
    0.21651518f, -0.23424859f, -0.05050474f, 0.12728798f, -0.04408434f, 0.15504926f, -0.10861769f, -0.17359929f, 
    -0.06416177f, 0.28704667f, 0.19530180f, -0.28023422f, 0.30098599f, 0.24458860f, 0.15425073f, -0.26620975f, 
    -0.14723380f, 0.03819679f, -0.02487310f, -0.13424788f, 0.39201841f, -0.16295786f, 0.36097455f, 0.05028114f, 
    -0.01266802f, 0.26823834f, 0.15508522f, 0.09878394f, 0.01120029f, 0.25726548f, 0.01773988f, 0.04198857f, 
    -0.21413335f, 0.12750521f, 0.25068292f, 0.37608820f, -0.09589835f, 0.12362169f, -0.35612226f, 0.00426695f, 
    -0.13544065f, 0.21860056f, 0.07020220f, 0.24597026f, -0.38530055f, 0.19634159f, 0.33957919f, -0.07537686f, 
    -0.07222331f, -0.00635350f, 0.05927879f, -0.08994520f, 0.08309025f, -0.12297153f, -0.26080754f, -0.02665936f, 
    0.42775041f, 0.03605685f, -0.13738568f, 0.36636806f, 0.09031324f, 0.11026472f, 0.04179039f, 0.30623347f, 
    -0.17191999f, -0.24542497f, 0.00448851f, -0.01319262f, -0.23625427f, -0.47191814f, -0.14737809f, 0.09941208f, 
    0.04951891f, -0.02213381f, -0.06496964f, -0.23369879f, 0.07304334f, 0.25450194f, -0.12232777f, -0.17462981f, 
    -0.32011452f, -0.17470729f, 0.07948888f, -0.13178860f, 0.24493743f, -0.01489062f, -0.08279128f, 0.31410974f, 
    0.17917895f, 0.34366682f, -0.04870924f, 0.00967067f, 0.58741468f, 0.16145886f, -0.28882477f, -0.27622503f, 
    0.07893327f, 0.17562224f, 0.29193890f, -0.16969587f, -0.04399485f, 0.04024879f, 0.23806420f, 0.14352170f, 
    0.37342513f, 0.05666276f, 0.01671966f, -0.17957816f, -0.07165165f, 0.00727405f, -0.02537140f, -0.00220129f, 
    -0.04213710f, 0.01786246f, -0.41790643f, 0.11473162f, 0.41679084f, -0.14448623f, 0.04162893f, 0.22235286f, 
    -0.05704771f, -0.11146209f, 0.05868739f, -0.11682568f, 0.01750437f, -0.01465847f, -0.24558868f, 0.00071591f, 
    0.50914687f, 0.40581629f, -0.33606213f, -0.00904496f, -0.44144595f, -0.41634607f, -0.08894694f, -0.03519809f, 
    -0.09642395f, -0.23746988f, -0.06992650f, -0.17693049f, -0.41088080f, 0.26053914f, -0.21523798f, -0.07099835f, 
    0.08404329f, -0.12279160f, -0.00782819f, 0.02046538f, 0.15891856f, -0.10387151f, 0.09039979f, 0.19978666f, 
    -0.86799204f, -0.11840180f, -0.44800758f, -0.34377217f, 0.02840311f, 0.13667788f, -0.26633599f, 0.07868642f, 
    0.17972830f, 0.16177039f, -0.14141433f, 0.08750882f, -0.66388625f, 0.00884465f, 0.52735335f, 0.13309981f, 
    0.29308856f, -0.03951766f, 0.09246229f, 0.11686806f, -0.01825036f, -0.01318057f, -0.25438848f, -0.08987314f, 
    -0.20294811f, -0.06255214f, 0.17296824f, -0.00954533f, 0.48221609f, 0.20719992f, 0.09444447f, -0.12628664f, 
    -0.00052464f, 0.06928525f, -0.10427823f, 0.03673791f, -0.07750925f, -0.61823201f, -0.28473154f, -0.36891305f, 
    0.05818789f, -0.01939378f, 0.07070918f, 0.05872047f, 0.13991079f, 0.08359718f, 0.28638548f, 0.03200926f, 
    -0.81740475f, -0.73680937f, -0.10829317f, -0.22642127f, 0.12557803f, 0.00062795f, 0.19448826f, -0.04715255f, 
    0.34209603f, 0.13347848f, -0.03359976f, 0.40856585f, -0.85160184f, -0.58848763f, -0.05628685f, 0.21754937f, 
    0.00844942f, 0.06067863f, 0.11693157f, -0.16191450f, 0.21716012f, -0.26561484f, -0.20035222f, -0.23410638f, 
    -0.27761337f, -0.04090002f, 0.00833870f, 0.22837041f, -0.28577363f, 0.09697134f, 0.06474704f, -0.14125966f, 
    0.28651407f, 0.18960203f, 0.18033719f, -0.18523359f, -1.02270377f, -0.06526057f, -0.07710017f, -0.11848957f, 
    0.27001595f, 0.01300436f, 0.10316165f, -0.17862023f, -0.09335215f, -0.07499804f, 0.04551892f, 0.16974895f, 
    -0.04711596f, -0.04766696f, 0.24586798f, -0.10608419f, -0.20042017f, 0.11760794f, 0.09242091f, -0.09885740f, 
    0.12777932f, 0.00335556f, 0.05006316f, -0.21839622f, 0.00650443f, -0.06267358f, -0.16478218f, -0.04879989f, 
    -0.06217923f, 0.25720006f, 0.04001853f, 0.03979906f, -0.02088367f, 0.03695076f, 0.13603219f, 0.22177264f, 
    0.31285676f, 0.25778022f, -0.44668439f, 0.31380597f, 0.05677527f, -0.07641978f, -0.03187840f, 0.09870811f, 
    0.29416659f, -0.16074912f, -0.02621053f, -0.05466980f, -0.36583969f, 0.31430310f, -0.39335582f, -0.01066161f, 
    -0.37122491f, 0.05100242f, 0.07488271f, 0.06416312f, 0.07372808f, -0.08911024f, -0.15125448f, -0.31523567f, 
    0.17603052f, 0.06126104f, 0.03643840f, 0.00387303f, -0.35243228f, -0.13966517f, -0.01210370f, -0.12979041f, 
    0.02551564f, 0.11751774f, 0.11147020f, -0.30291235f, 0.21445115f, -0.27471784f, 0.05421057f, 0.16939017f, 
    0.17126632f, -0.01122679f, 0.05884312f, -0.21172105f, 0.03878587f, -0.03019072f, 0.22319436f, 0.17239201f, 
    -0.44787347f, -0.38367060f, -0.04157849f, -0.00045692f, -0.20714563f, 0.32120514f, -0.04768388f, 0.14378980f, 
    0.01216726f, 0.07539400f, -0.04311803f, -0.12409639f, 0.32924685f, -0.27404326f, 0.14817609f, 0.35656485f, 
    0.06615406f, -0.19532952f, -0.07541370f, 0.05780753f, 0.03329295f, -0.17311627f, 0.12603243f, 0.07545624f, 
    -0.96615213f, 0.09532956f, -0.22176686f, -0.28579932f, 0.24450073f, 0.12442365f, 0.04595924f, 0.18881589f, 
    -0.14087585f, -0.14024422f, 0.03931440f, -0.30393422f, 0.61251563f, -0.58175719f, 0.17468102f, -0.15469493f, 
    -0.39158982f, -0.26781750f, -0.00667546f, -0.04008881f, 0.10781384f, 0.20936507f, 0.25086913f, -0.02941893f, 
    0.04798775f, 0.36257741f, -0.53835469f, 0.29000941f, 0.13316552f, 0.01123076f, -0.00464917f, -0.05660479f, 
    0.03176111f, 0.13617454f, -0.01049183f, -0.02557092f, 0.23260041f, -0.62698960f, 0.04049183f, 0.04847156f, 
    0.11449211f, 0.08942809f, 0.07495245f, -0.10879533f, 0.03211284f, 0.04172865f, -0.04461209f, 0.03706363f, 
    0.42012995f, -0.52091449f, -0.11295158f, -0.31384081f, -0.00669936f, -0.06190939f, -0.04922815f, 0.12623268f, 
    -0.03810400f, 0.03376548f, -0.16408277f, 0.15748265f, 0.07697089f, 0.08351697f, -0.04016713f, -0.06737955f, 
    0.10856047f, -0.06363489f, -0.23515728f, 0.23116319f, 0.10293526f, 0.13139021f, 0.19979668f, 0.04870498f, 
    0.23944376f, 0.24701922f, -0.36761343f, 0.25184095f, 0.09110838f, -0.23631072f, -0.01144881f, -0.24315342f, 
    -0.11613250f, 0.03629984f, -0.12955666f, -0.01474076f, 0.57290483f, 0.21041323f, 0.07248954f, -0.61632097f, 
    0.14892350f, -0.11375923f, -0.07092604f, 0.14703596f, 0.11081569f, 0.17200789f, 0.09948909f, 0.06640135f, 
    -0.61985034f, -0.52916920f, -0.12413278f, -0.06309815f, 0.04951384f, -0.08634675f, 0.13308758f, -0.09438384f, 
    -0.18984161f, -0.00003277f, -0.07366391f, -0.29389495f, -0.19195476f, 0.49591058f, -0.03939943f, 0.06147354f, 
    0.07160473f, 0.10564888f, 0.24387951f, -0.19450347f, -0.13724191f, -0.08115322f, 0.03286150f, -0.17613086f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.16643293f, 0.00417863f, -0.13075268f, 0.09650950f, 0.03410418f, -0.07020582f, -0.01738016f, -0.16510621f, 
    -0.07431941f, 0.09136689f, 0.32235089f, 0.03716053f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
