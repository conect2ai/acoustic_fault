#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.67277205f, 0.78755051f, 0.50913405f, 0.25895441f, 0.65822554f, -0.42635724f, -0.84240371f, -1.07550824f, 
    -0.32910514f, -0.66609031f, 0.48125103f, 0.13653547f, -0.02090308f, 0.33142769f, -0.17527090f, 0.36820284f, 
    -0.06357524f, -0.03320939f, 0.07673753f, 0.43158844f, -0.07458314f, -0.22620156f, -0.04235443f, 0.24775201f, 
    -0.10173468f, 0.50350493f, 0.82554835f, 1.02673852f, 0.39528257f, -0.05546832f, -0.99093252f, 0.75585675f, 
    -0.70957565f, -0.65931386f, -0.37233564f, 0.23281156f, -0.07016530f, -0.41483742f, -0.02043439f, -0.01753415f, 
    -0.28414235f, -0.47237363f, 0.24138245f, -0.25280902f, -0.25904718f, -0.40618131f, 0.45735261f, 0.15372986f, 
    -0.00664838f, -0.18508735f, -0.76030314f, 0.44169092f, -0.18731195f, -0.12457769f, -1.34266543f, 0.97074986f, 
    0.62165749f, -0.69011194f, 0.37162951f, 0.23950103f, 0.11315155f, -0.21635272f, 0.23702179f, -0.21043514f, 
    0.02180907f, 0.30355406f, 0.04486939f, 0.27110839f, 0.12038180f, 0.22477591f, -0.21091734f, -0.53414190f, 
    0.10505070f, 0.27775300f, -0.18222825f, 1.23789072f, 0.28213400f, 0.01355699f, 0.83950037f, 0.35670620f, 
    -0.35392779f, -0.06282145f, -0.34847036f, 0.48206052f, 0.53868407f, -0.13246380f, -0.27008641f, 0.36159000f, 
    -0.44950402f, -0.33076960f, -0.28049806f, -0.37980500f, -0.11894372f, -0.22237709f, -0.38761231f, 0.48946369f, 
    0.11741005f, 0.08751445f, -0.14088117f, -0.17295387f, 1.03610599f, 0.69627643f, -0.46926489f, -0.24671689f, 
    -0.61135542f, 0.43381619f, 0.16223231f, -0.73792964f, -0.06416771f, 0.08471785f, 0.13981952f, -0.15338823f, 
    0.27297619f, 0.75331283f, -0.15667498f, 0.45534676f, 0.45874095f, 0.11557647f, -0.20585361f, -0.26547444f, 
    -0.05667415f, -0.00291647f, 0.33406639f, -0.09217293f, 0.48369327f, 0.23865847f, 0.43522906f, 0.75818861f, 
    1.09442222f, 0.37806052f, 0.72772837f, 0.17915726f, -0.49713370f, 0.48981947f, -0.30467600f, -0.38349995f, 
    -0.00155620f, -0.64130551f, 0.31033903f, -0.26588723f, 0.29292578f, -0.05542110f, 0.12843971f, -0.19218579f, 
    0.02562867f, -0.02496855f, 0.35679445f, -0.09823712f, 0.11925532f, 0.28426325f, 0.28036100f, -0.05592285f, 
    0.43633917f, -0.50132179f, 0.14806736f, 0.39917323f, -0.74393880f, 1.07916117f, 0.96624464f, -0.55805993f, 
    -0.54936802f, -0.31702295f, -0.15287626f, -0.38159254f, 0.01418649f, -0.35763359f, 0.07440516f, -0.56687289f, 
    -0.23054893f, -0.22596979f, -0.28215209f, -0.09839614f, -0.15910088f, -0.12370765f, 0.03677030f, 1.30267441f, 
    -0.17940760f, 0.37684417f, 0.62062639f, 0.72129089f, -0.37467027f, 0.78032243f, -0.10660233f, 0.21082900f, 
    0.43891186f, -0.25921109f, -0.26727402f, -0.24959022f, 0.19372946f, -0.07470517f, -0.35690659f, -0.11138190f, 
    -0.14365183f, 0.28374720f, 0.07505790f, -0.11138712f, 0.16091013f, -0.10373275f, -0.01033286f, 0.07128628f, 
    -0.34233850f, -0.72530597f, -0.05611663f, 0.26918441f, -0.16257647f, -0.54513371f, -0.69867903f, -0.56848776f, 
    -0.99131316f, 0.12151571f, -0.46609923f, 0.30364451f, 0.32605359f, -0.10323104f, -0.25421059f, -0.90177387f, 
    -0.29626113f, -0.14629430f, 0.19237106f, -0.57935727f, 0.31264251f, 0.34398007f, -0.32824287f, 0.07165647f, 
    0.34813407f, 1.46951151f, 0.44875610f, 0.05422134f, 0.97713357f, -0.27718118f, 0.46173188f, -0.01888184f, 
    -0.04246143f, 0.28267658f, -0.23566388f, -0.11971654f, 0.20541444f, 0.29222313f, -0.06387714f, -0.02360693f, 
    0.26660743f, -0.28342116f, -0.20228839f, -0.10049430f, 0.31374240f, -0.47771928f, 0.16439530f, 0.23274063f, 
    -0.04425085f, 0.22520855f, 0.80634099f, -0.95158529f, -0.68136245f, 0.38493186f, -0.31041864f, -0.90433657f, 
    0.21203895f, 0.20104791f, -0.16740038f, -0.33239567f, 0.13147321f, -0.01703054f, 0.55592138f, -0.16973092f, 
    -0.26185390f, -0.23769836f, 0.08772897f, -0.28230435f, -0.03999174f, -0.80063045f, -0.23055637f, -0.16542155f, 
    0.00178544f, 0.12786292f, 0.11667716f, 1.22006726f, 0.57609600f, 0.61175817f, -0.95469689f, -0.02424406f, 
    -0.41421708f, 0.48124105f, -0.07755537f, -0.09469180f, 0.37516868f, -0.01058328f, -0.24791093f, -0.21076089f, 
    -0.06017331f, 0.36834952f, -0.06061203f, 0.07163894f, 0.19344403f, 0.25808069f, 0.48123205f, -0.28190321f, 
    -0.09073456f, 0.05058235f, -0.11413261f, 0.55249703f, 0.82273519f, 0.68127686f, 0.93876827f, 0.66439342f, 
    0.04419055f, 0.50018030f, -0.38355258f, 0.05095923f, -0.15787525f, -0.25735241f, -0.33968258f, 0.26921913f, 
    0.19193938f, 0.12009307f, -0.50884002f, 0.33692101f, 0.16385846f, 0.28331703f, 0.32682002f, -0.10535355f, 
    -0.14969826f, -0.40583640f, -0.04882203f, -0.43167549f, 0.27365902f, 1.30000722f, 0.85589087f, -0.87615150f, 
    0.69725221f, 0.49738538f, 0.86557871f, 0.24846089f, 0.18296498f, 0.60184836f, 0.32344681f, 0.07549976f, 
    -0.51413566f, -0.09350226f, -0.36914685f, 0.19001210f, 0.06025636f, -0.22306401f, -0.20831358f, -0.19846255f, 
    0.24503402f, -0.12167304f, -0.29136756f, 0.00485202f, -0.28138202f, -0.15565872f, -1.08335900f, -0.35419127f, 
    -0.55168581f, 0.22418731f, -0.75001615f, 0.60532653f, 1.05300152f, -0.35361412f, 0.11098802f, 0.39909503f, 
    -0.14983109f, -0.21420881f, 0.12960202f, 0.07650226f, 0.39039916f, -0.20248739f, -0.39550567f, -0.15416302f, 
    -0.24713416f, -0.41007528f, 0.23371845f, 0.21783568f, 0.29135799f, 0.40826902f, 0.19509362f, -0.92813629f, 
    -0.25377515f, -0.73584205f, -0.94596350f, -0.66026127f, 0.19890140f, -0.38692385f, -0.32302183f, 0.18674371f, 
    0.04415414f, -0.11118379f, -0.16954203f, 0.05480421f, 0.14528434f, 0.28509194f, 0.16566743f, 0.29524180f, 
    0.28217202f, 0.10540612f, 0.22522743f, -0.44681194f, -0.35137138f, 0.12595531f, -0.30622387f, -0.06894760f, 
    -0.77031380f, -0.37948623f, -0.72806895f, -0.50520581f, -0.29216504f, -0.03795015f, 0.07152593f, 0.55727172f, 
    0.68417960f, 0.66870284f, -0.13916945f, 0.02325148f, -0.28948718f, -0.14821939f, -0.44434205f, 0.47343820f, 
    0.11886184f, -0.00998265f, 0.08638092f, 0.08186097f, 0.09419888f, -0.20485522f, -0.30645901f, -0.25930032f, 
    -0.15135105f, -0.10903563f, 0.56486225f, 0.47022533f, 0.91142017f, 0.48424241f, 0.55761415f, 0.82732999f, 
    0.72654271f, -0.08989297f, 0.36738861f, 0.01723206f, 0.05148756f, 0.54329509f, -0.12168644f, 0.18919052f, 
    -0.04532335f, -0.44296217f, 0.20230581f, 0.27734345f, -0.11088099f, 0.37871048f, -0.06479833f, -0.00590101f, 
    0.49461478f, -0.48952895f, 0.76634163f, 0.34458750f, 0.98142153f, 1.09586799f, 0.71768385f, 0.79747564f, 
    -0.11038179f, -0.22799107f, -0.69848001f, 0.04616310f, 0.40461221f, 0.46995381f, -0.08066265f, -0.04742122f, 
    0.02033534f, 0.15207890f, 0.17609058f, 0.35860744f, -0.19094768f, -0.13945091f, 0.31355104f, 0.26498613f, 
    0.17881252f, 0.00679214f, -0.00003530f, -1.34446371f, 1.05978847f, 1.30643821f, -1.07440972f, 0.32551005f, 
    0.45127070f, 0.11566693f, 0.37445354f, 0.20260480f, -0.88006926f, -0.36326236f, 0.10565322f, -0.10682175f, 
    0.00390152f, -0.14747994f, 0.22610460f, 0.02612253f, 0.12232325f, 0.07081698f, 0.17998716f, -0.09397157f, 
    0.12269440f, 0.10640893f, 0.10142557f, 0.05839752f, -1.25612807f, -1.42200780f, -0.00232554f, 0.62336481f, 
    0.17419852f, 0.85044074f, 0.17593852f, 0.63235456f, 0.15526384f, -0.86028463f, 0.20115446f, -0.14959812f, 
    -0.18977544f, 0.45267427f, 0.19689295f, 0.11342632f, 0.18955903f, -0.37201723f, -0.23265442f, 0.02863438f, 
    -0.12905702f, -0.00245797f, 0.18571171f, 0.02579145f, 0.02782443f, 1.01365983f, -0.03206844f, -0.81122267f, 
    1.17251801f, -0.63177389f, -0.56222236f, 0.49002144f, 0.87773097f, 0.12738676f, 0.56320471f, -0.38610724f, 
    0.11141189f, 0.36714250f, -0.43378016f, -0.00127256f, -0.46775544f, -0.16636829f, -0.02421398f, -0.15421978f, 
    0.09872007f, 0.39587018f, 0.04423250f, -0.15461564f, 0.26893356f, 0.05564406f, 1.09137118f, 0.71978003f, 
    1.01003218f, -0.55303693f, -1.16153538f, -0.34905422f, -0.74568385f, 0.46212462f, -0.20952396f, 0.53172666f, 
    0.10456318f, 0.34364808f, -0.24402159f, -0.10258768f, -0.08975939f, -0.33737212f, -0.04530357f, -0.15325622f, 
    -0.08024084f, -0.16298768f, 0.08435261f, 0.16631453f, -0.06897496f, -0.08178117f, 0.06614731f, -0.84784240f, 
    0.21790850f, 0.89998335f, 0.42534307f, -0.83180720f, -0.99582541f, 0.51893973f, 0.10853512f, -0.46011052f, 
    -0.21567447f, -0.10288794f, 0.28500363f, -0.02500286f, 0.06939463f, 0.09189690f, 0.27372032f, -0.04487625f, 
    -0.18055645f, 0.08177637f, 0.18327928f, -0.11679517f, 0.22753724f, 0.49907655f, 0.02558015f, 0.28973567f, 
    0.38748810f, 1.17395103f, -0.59206909f, -0.81269771f, -0.53942907f, 1.03745568f, -0.71418989f, -0.62164557f, 
    -0.95289934f, -0.27806345f, 0.48770398f, 0.43284774f, 0.34884879f, 0.25924426f, -0.12365502f, -0.03181788f, 
    -0.39318180f, 0.16092148f, 0.14351957f, -0.13805318f, 0.29164931f, 0.21648403f, 0.09895329f, -0.02542111f, 
    0.22796549f, -0.12796533f, 0.06302337f, -0.63543016f, -0.22758570f, -0.53877276f, 0.16766481f, 0.30135217f, 
    -0.69681674f, -0.57426018f, -0.74314713f, -0.54692620f, 0.28529266f, -0.67904073f, -0.10341050f, -0.26844683f, 
    -0.06176424f, 0.33265695f, 0.09671233f, -0.30490008f, -0.04330181f, 0.20746955f, -0.09085337f, 0.23693228f, 
    0.23426344f, 0.42103466f, -1.64554286f, 0.89240205f, 0.28121200f, -0.87023705f, -0.80611998f, 0.46939120f, 
    0.24294795f, -0.36781698f, 0.58541316f, 0.27209601f, -0.01097400f, 0.09567326f, -0.12441591f, 0.25258654f, 
    0.21247874f, -0.16277413f, 0.03986913f, -0.18768641f, -0.07049832f, -0.55555892f, 0.33865106f, 0.33784911f, 
    0.25916246f, 0.25854957f, 0.10595853f, 0.61951780f, 0.91529435f, 0.38541934f, 0.23808578f, -0.03394043f, 
    -0.84005302f, 0.26590374f, -0.79754519f, 0.05771956f, 0.41335821f, 0.45867369f, 0.31859952f, 0.47468317f, 
    0.15119755f, 0.14067633f, -0.26994994f, -0.18720849f, 0.22135319f, 0.34678823f, -0.35009593f, 0.00752508f, 
    -0.15808013f, -0.14863363f, 0.12150134f, 0.31984192f, -0.82320476f, -0.37044391f, -0.72521299f, -0.33896443f, 
    0.09341223f, 0.24427912f, 1.19092667f, 0.65371168f, 0.06930078f, 0.10290089f, -0.16279304f, 0.30743441f, 
    0.31345800f, -0.44998920f, 0.13171692f, -0.00851122f, 0.03784116f, 0.11627521f, 0.26648894f, 0.02428385f, 
    0.08200305f, 0.14998730f, 0.16670334f, -0.24256983f, -0.12752847f, -0.80969560f, -0.32001358f, -0.15937145f, 
    -0.65633214f, -0.65151882f, 0.09483290f, 0.72307014f, 0.21869795f, -0.16657585f, 0.73784184f, -0.62962222f, 
    0.00033224f, 0.01833513f, -0.42725444f, -0.41757321f, -0.20730405f, 0.09021556f, -0.18986586f, 0.13112222f, 
    0.23891668f, -0.03452675f, -0.21324578f, -0.27889916f, -0.33882937f, 0.61976057f, 1.24946249f, 0.75344497f, 
    -0.76970190f, -1.13866079f, -0.43768635f, -0.22617798f, 0.51920903f, 0.51855767f, 0.33504668f, 0.15899083f, 
    0.01671815f, 0.36590722f, 0.30873165f, -0.28362903f, -0.49792406f, 0.32895800f, -0.19488646f, 0.00779482f, 
    0.05286903f, -0.32709676f, -0.32758167f, -0.11860699f, 0.11224791f, -0.46782470f, -0.63138109f, 0.81666422f, 
    -0.21358375f, -0.84975386f, -1.11110198f, -0.65132827f, 0.53751206f, -0.38435832f, -0.48190701f, 0.49485219f, 
    0.03068741f, -0.30000451f, -0.33647287f, -0.33557078f, 0.03538686f, -0.31146738f, -0.10558408f, 0.22131482f, 
    -0.10355190f, 0.18530911f, 0.23890567f, 0.11904858f, -0.04411640f, -0.13819815f, -0.10105387f, 0.35313222f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.23184158f, -0.02072710f, 0.07672149f, 0.35106200f, 0.13495718f, 0.29035246f, -0.08988357f, 0.31802455f, 
    0.33422935f, 0.20532377f, 0.12369754f, 0.34973320f, 0.16822781f, 0.23041005f, -0.00698735f, 0.22245519f, 
    0.17758702f, 0.03396489f, 0.22759074f, 0.07350297f, 0.41492584f, 0.17781568f, 0.31279173f, 0.33429518f, 
    0.28355610f, 0.27592891f, 0.24067801f, 0.01338123f, 0.09779653f, -0.06272975f, 0.15946457f, 0.11088610f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.23603378f, 0.06986319f, 0.09405403f, -0.05794781f, -0.13248441f, -0.08298083f, 0.05110053f, 0.05647227f, 
    0.12514271f, -0.02331241f, -0.05291234f, 0.02134618f, 0.20101368f, 0.22429444f, 0.06359375f, 0.13847293f, 
    -0.17550561f, -0.07035203f, -0.03153189f, 0.04110841f, -0.01599023f, 0.09424668f, 0.09796448f, -0.19791217f, 
    0.73514861f, 0.06257728f, 0.00764196f, -0.23910061f, -0.04906761f, 0.06071641f, -0.06837498f, -0.02000411f, 
    0.00266950f, 0.02495759f, 0.03288658f, 0.02357993f, 0.09171873f, 0.02152226f, -0.13230295f, 0.30204216f, 
    0.02433538f, 0.09453458f, -0.03743287f, 0.06259149f, -0.01257531f, 0.05924192f, 0.02968499f, -0.07200359f, 
    -0.18978898f, 0.10415858f, 0.12653762f, -0.21226364f, 0.05590016f, -0.12717879f, -0.01275835f, 0.09347772f, 
    -0.03477185f, 0.06449679f, -0.04265637f, 0.08308308f, 0.01779013f, 0.03095942f, -0.00595605f, 0.32347316f, 
    -0.09402009f, -0.07389823f, 0.09115018f, -0.02903173f, -0.06917752f, 0.06978968f, -0.04624488f, -0.06527536f, 
    0.29340363f, 0.19732647f, 0.18354440f, 0.06618518f, -0.09656494f, -0.01478277f, 0.05250122f, -0.11801914f, 
    -0.01611840f, -0.11901356f, 0.17519027f, -0.11395200f, 0.27930370f, -0.11925396f, -0.01122070f, 0.23865215f, 
    -0.16831172f, -0.11242147f, -0.02141679f, 0.12414759f, -0.13215640f, -0.01681902f, -0.01346608f, -0.04595858f, 
    -0.41336834f, -0.22354203f, -0.11689863f, 0.16674536f, -0.18839470f, 0.07568470f, 0.00418706f, -0.08943403f, 
    -0.22094038f, -0.02744320f, -0.17938617f, 0.06774258f, 0.29582277f, -0.08642366f, -0.33002776f, 0.19296889f, 
    -0.15659946f, -0.11969270f, -0.38959029f, 0.17579892f, -0.01021027f, -0.19572429f, -0.02412417f, -0.03786474f, 
    -0.14723498f, -0.13694558f, 0.14780740f, 0.14592718f, -0.01417424f, -0.07275235f, -0.06224522f, -0.14411598f, 
    0.03254450f, 0.13028501f, 0.17812128f, -0.04961830f, 0.09625040f, 0.14625846f, 0.09813774f, -0.48562440f, 
    -0.16982709f, -0.16417494f, 0.06150175f, 0.17117344f, -0.06498121f, -0.12604883f, -0.03663763f, -0.00754811f, 
    0.03518196f, 0.06018074f, -0.14934377f, 0.10318244f, -0.04404913f, 0.06053694f, -0.05440325f, 0.03773182f, 
    0.01851414f, -0.03903591f, -0.24071954f, 0.05699843f, 0.11702081f, -0.15971847f, 0.21695289f, 0.21280493f, 
    -0.31792235f, 0.07297897f, 0.13831432f, 0.08354714f, -0.07917581f, 0.06265505f, 0.03988674f, -0.03153359f, 
    0.50658011f, 0.20192130f, 0.17471203f, -0.15505296f, 0.05325866f, -0.04584510f, -0.07079896f, 0.12416069f, 
    0.00043168f, -0.08686420f, 0.02546553f, 0.13901398f, 0.25274223f, -0.12668541f, -0.17065158f, -0.25702578f, 
    -0.01912668f, -0.01449580f, -0.02463041f, 0.06134280f, -0.00432110f, 0.06762737f, -0.08599009f, 0.02533746f, 
    0.11942864f, 0.15714329f, -0.14771906f, -0.20171481f, 0.04232092f, 0.02871452f, 0.14489587f, 0.06136892f, 
    -0.03429851f, -0.11177824f, -0.05003065f, -0.02773456f, -0.12974253f, 0.05749212f, -0.11668878f, 0.09453522f, 
    -0.13001446f, -0.03142240f, 0.06737510f, -0.25397882f, 0.08452245f, 0.00312946f, 0.04565346f, -0.00463958f, 
    0.13669650f, 0.07542063f, -0.14856176f, 0.04209160f, -0.18023625f, -0.05941009f, 0.09720224f, -0.03882397f, 
    -0.04163605f, 0.11695963f, 0.01201617f, -0.07216335f, -0.61915016f, 0.17101724f, 0.20033586f, -0.08159649f, 
    0.00144204f, 0.06125825f, -0.02252354f, -0.12812784f, 0.06221931f, -0.04071630f, 0.05552933f, 0.04053172f, 
    -0.47287434f, -0.07082861f, -0.12051808f, 0.04349823f, 0.10798465f, 0.19009939f, -0.12270961f, 0.01133979f, 
    0.01623647f, -0.13116680f, 0.00916567f, -0.23727061f, -0.27839896f, -0.05225829f, -0.15029119f, 0.15193440f, 
    -0.07311083f, 0.07180748f, -0.20024608f, -0.12003528f, 0.08014906f, -0.03655675f, 0.07923295f, 0.07587029f, 
    -0.28818777f, 0.20183706f, -0.01671815f, 0.00122686f, -0.06138276f, -0.21256070f, -0.07088475f, -0.09792183f, 
    -0.06938320f, -0.11866861f, 0.03984522f, 0.01746086f, -0.29117304f, 0.10745800f, -0.04273511f, 0.39551193f, 
    -0.05268637f, 0.11694381f, -0.08909624f, -0.00959061f, 0.00646070f, -0.01565199f, -0.10280787f, 0.12697478f, 
    -0.23570776f, 0.05148238f, 0.22641115f, -0.28175652f, -0.23290563f, 0.03042293f, 0.19483088f, -0.17552412f, 
    -0.07231603f, -0.15121442f, 0.02120590f, 0.12124944f, -0.34322503f, 0.00217811f, 0.12330662f, -0.12349163f, 
    -0.08237061f, -0.00430780f, -0.06324392f, 0.18140209f, -0.21580942f, 0.00406838f, 0.03309910f, -0.02318345f, 
    0.53166068f, -0.13060497f, -0.09898809f, -0.09783494f, -0.05694946f, 0.07767545f, 0.03796919f, -0.07419577f, 
    0.17119534f, -0.00287492f, -0.07477704f, 0.02280623f, -0.11855247f, -0.03290031f, 0.00818507f, 0.04851139f, 
    -0.11577862f, 0.00624329f, 0.00426047f, 0.00329607f, 0.10320846f, 0.13380256f, -0.01271327f, -0.06982696f, 
    0.09057711f, 0.09482654f, 0.02300533f, -0.31693622f, 0.06510183f, -0.04601528f, 0.15563270f, 0.03482348f, 
    -0.02488579f, -0.04093423f, 0.01490553f, 0.08281263f, 0.21970922f, 0.15533799f, 0.06614716f, -0.27854970f, 
    0.06349037f, -0.00424727f, -0.04853296f, 0.13618053f, 0.14458707f, -0.14695537f, -0.03337126f, -0.01168416f, 
    -0.33018604f, 0.14682753f, 0.08512706f, -0.72582453f, -0.02951615f, 0.02477596f, -0.11776670f, 0.05762451f, 
    -0.03535172f, 0.01298697f, 0.02923606f, -0.06277106f, 0.07078017f, -0.19740200f, 0.09294231f, -0.56737316f, 
    0.14580788f, -0.13698545f, 0.04271347f, -0.04612925f, 0.00720346f, 0.06738914f, 0.07843244f, 0.16532329f, 
    -0.13463180f, -0.24458405f, -0.17137758f, -0.17602110f, 0.16834979f, 0.04570063f, -0.02120572f, -0.12657997f, 
    0.01431171f, 0.15879260f, 0.01423244f, 0.07404173f, 0.10510486f, 0.06814998f, -0.07533451f, -0.03581788f, 
    -0.16297355f, 0.02679446f, 0.12970553f, -0.06860047f, 0.12924662f, -0.08105560f, 0.00502576f, 0.03564154f, 
    -0.68087077f, -0.42693418f, 0.17143689f, 0.00014338f, 0.10491523f, -0.01781007f, 0.12796159f, -0.07935297f, 
    -0.07103680f, -0.05547714f, -0.10440142f, 0.11730076f, 0.22781274f, -0.01112540f, 0.13288099f, 0.23281868f, 
    -0.12275606f, 0.00289747f, 0.11402590f, -0.00016359f, 0.07340705f, -0.03232338f, -0.22224218f, -0.09874242f, 
    0.31186578f, -0.14791642f, 0.00780632f, -0.23295927f, -0.02494827f, -0.13017562f, 0.10624094f, 0.04764682f, 
    -0.07553414f, -0.13586667f, -0.01884851f, -0.06923472f, 0.33224499f, -0.06997846f, 0.13911507f, 0.09374089f, 
    -0.12497627f, 0.04115970f, 0.05099287f, 0.06632843f, 0.01574516f, 0.09895558f, 0.18906227f, 0.02234310f, 
    -0.62922710f, -0.11354975f, 0.04689911f, 0.05567358f, -0.05013267f, -0.18214317f, 0.01781238f, 0.05075372f, 
    0.02588251f, -0.11923543f, -0.04994071f, -0.19712606f, 0.48535845f, -0.10659114f, 0.10637031f, 0.29369286f, 
    -0.13623247f, 0.01774318f, 0.00068423f, 0.06993577f, 0.09045145f, 0.03124038f, -0.17524217f, -0.00473630f, 
    -0.09321848f, -0.03164159f, -0.23725930f, -0.05344877f, -0.00643438f, 0.04720211f, -0.05092024f, 0.14155306f, 
    0.11277311f, 0.01028935f, 0.07224660f, -0.23029400f, 0.19731265f, -0.11400036f, 0.24408561f, 0.25237420f, 
    0.01905614f, -0.03352175f, 0.09792902f, -0.02492377f, -0.09497572f, 0.16817276f, -0.00212362f, 0.07259975f, 
    0.13350467f, -0.59908980f, -0.28468040f, 0.06662721f, -0.06115545f, -0.04562524f, -0.16225238f, 0.20108230f, 
    -0.04739049f, -0.17459475f, -0.20499124f, -0.09736745f, 0.32630536f, 0.10345218f, -0.07371008f, -0.04415454f, 
    0.06183617f, -0.09416675f, -0.05728852f, -0.04952560f, -0.13479589f, 0.00925821f, -0.07122187f, 0.13097435f, 
    0.22938362f, 0.03789561f, 0.06120755f, 0.15145370f, -0.08351272f, -0.01107992f, -0.04575082f, -0.08080032f, 
    0.09023465f, -0.17777832f, 0.01228438f, -0.07447995f, 0.04864334f, -0.19905357f, 0.16573803f, 0.07778913f, 
    0.02067638f, -0.08833481f, -0.20625371f, -0.02738781f, -0.04367822f, 0.08310784f, -0.21986175f, 0.10321731f, 
    -0.22985381f, 0.03490447f, -0.29999030f, -0.04473064f, 0.00714031f, -0.06684853f, -0.03989787f, 0.00984134f, 
    0.05194922f, -0.03313097f, -0.12720634f, 0.05972812f, -0.19249944f, 0.07349611f, 0.11719234f, -0.03236919f, 
    0.01005667f, 0.08207992f, 0.22521879f, -0.05363687f, 0.08906291f, 0.14556056f, 0.06320849f, 0.02550603f, 
    -0.05800255f, -0.04138004f, -0.07307860f, -0.25879472f, 0.12230764f, -0.19694692f, -0.10181883f, 0.09532253f, 
    0.14239427f, 0.07555559f, -0.07899410f, 0.01577652f, 0.21413466f, 0.34641498f, 0.02361844f, 0.37924990f, 
    -0.02924061f, 0.11879926f, -0.06678586f, 0.09073374f, -0.07874665f, 0.09277396f, 0.07747892f, 0.12704806f, 
    -0.01171919f, 0.03239908f, 0.31749308f, 0.23771849f, -0.21417183f, -0.06449611f, 0.03313930f, -0.01156355f, 
    -0.06312806f, -0.11373496f, 0.13762982f, -0.04214308f, -0.09874215f, 0.08121525f, -0.38104722f, -0.22575252f, 
    -0.11449617f, 0.18709287f, 0.00058285f, -0.04484739f, 0.17656663f, 0.19640005f, -0.08241996f, 0.07144281f, 
    0.09183431f, 0.42095909f, -0.29544795f, 0.15818258f, -0.05627412f, 0.06083066f, 0.04724035f, 0.00599706f, 
    -0.08332772f, 0.05548147f, -0.09285325f, 0.13542911f, 0.48559210f, -0.19191401f, -0.03331682f, 0.14879026f, 
    0.02439427f, 0.04700966f, -0.11154982f, 0.01361493f, 0.01697634f, -0.02868656f, -0.05667017f, 0.09311596f, 
    -0.04775844f, 0.04920451f, -0.15330856f, -0.07293811f, -0.07404435f, -0.08295904f, 0.08774700f, 0.04851823f, 
    -0.03155456f, 0.03299300f, 0.02763278f, -0.04534234f, -0.50966424f, 0.15711692f, -0.34400690f, -0.18283366f, 
    -0.01171592f, 0.01872938f, -0.04766657f, -0.02118872f, 0.05667141f, 0.02390895f, 0.02332013f, -0.07546186f, 
    0.12159800f, -0.09755941f, -0.10352326f, -0.42573890f, 0.03371925f, -0.00732506f, -0.01290431f, -0.00490515f, 
    0.04403792f, 0.21602690f, 0.04332354f, -0.04758911f, -0.21053287f, 0.07111592f, -0.48520875f, -0.24011806f, 
    -0.01907917f, 0.01653937f, 0.00687638f, -0.05854154f, 0.18708698f, 0.12282926f, 0.02333679f, 0.00725245f, 
    -0.88244724f, 0.10548469f, -0.07329474f, -0.14809138f, 0.07276241f, -0.00451227f, -0.10541230f, 0.20123072f, 
    0.03929643f, -0.04072290f, -0.07116108f, -0.05313136f, 0.21996266f, 0.07376345f, -0.04837075f, -0.00015650f, 
    -0.16675846f, -0.14381532f, 0.04130770f, 0.03577623f, 0.08631556f, 0.01454038f, -0.00527404f, 0.02287485f, 
    0.29055268f, 0.08659862f, -0.16905533f, -0.26330584f, 0.19333567f, -0.06221958f, -0.03327859f, 0.04005508f, 
    0.03900728f, -0.01117272f, 0.00946717f, 0.05682995f, -0.26725766f, -0.01808509f, -0.02167744f, -0.11783931f, 
    0.06969014f, -0.23948310f, 0.05991364f, 0.05776650f, -0.08929437f, 0.16318916f, -0.00798455f, -0.18944395f, 
    0.39994809f, -0.03680395f, 0.27516955f, -0.46542555f, 0.00315479f, -0.27921283f, 0.02567220f, -0.03008149f, 
    -0.21298978f, -0.20871015f, 0.08171351f, 0.03053775f, 0.19463854f, -0.29027885f, 0.21643038f, -0.40467328f, 
    -0.03454641f, -0.01027454f, -0.06612130f, 0.18703395f, -0.15834165f, 0.01511783f, -0.01036672f, -0.14232066f, 
    0.21580067f, 0.14874521f, -0.43682745f, 0.12658346f, -0.02400598f, 0.09284227f, 0.04807097f, -0.08649071f, 
    -0.18215649f, -0.11640179f, 0.01859363f, -0.16943251f, 0.14797187f, 0.04810396f, -0.12944870f, -0.08007336f, 
    0.10732936f, 0.12344307f, -0.06415780f, -0.06093356f, 0.07464454f, 0.04712429f, -0.18196134f, -0.03789684f, 
    0.34317905f, 0.19560009f, 0.12475019f, -0.21207729f, 0.02207456f, -0.07496970f, -0.02267809f, 0.11747745f, 
    -0.09347519f, 0.08044241f, 0.11557849f, -0.12045975f, -0.08878937f, 0.04269605f, -0.05246435f, -0.13143480f, 
    0.03180727f, 0.01920267f, -0.04951812f, -0.05985454f, -0.00220308f, 0.08673674f, 0.08667377f, -0.02285634f, 
    -0.00966071f, -0.13897616f, -0.11169948f, -0.17340517f, 0.03836156f, -0.13848004f, -0.04547891f, -0.08630145f, 
    -0.08536066f, 0.12289166f, -0.08106247f, -0.07535254f, 0.00952664f, -0.17207612f, -0.08360230f, 0.03025291f, 
    0.15208311f, 0.06440101f, -0.04340137f, -0.11932471f, 0.08487725f, 0.00757293f, 0.00924421f, 0.00530440f, 
    -0.52828252f, 0.35626957f, -0.33533004f, 0.04471413f, 0.14035343f, 0.01459851f, 0.06775224f, 0.03040047f, 
    0.04531464f, 0.02176912f, 0.07797039f, -0.05437370f, -0.28599712f, 0.24309330f, 0.17319144f, -0.20333414f, 
    0.11390091f, 0.07377087f, 0.05124504f, 0.12902620f, -0.19807746f, 0.04371645f, 0.00022852f, 0.07605451f, 
    0.25243932f, -0.26794988f, -0.31385890f, -0.14582083f, -0.16317312f, -0.08272252f, 0.00175873f, -0.00837074f, 
    0.13381886f, 0.17069100f, -0.24115361f, 0.00736596f, 0.00722094f, 0.11096474f, -0.01148080f, -0.11846583f, 
    -0.01980644f, 0.01156004f, -0.06735307f, 0.06979385f, -0.15069243f, 0.03753165f, 0.03413912f, -0.08283640f, 
    0.64043730f, -0.09553685f, -0.27287704f, -0.04526396f, -0.15761267f, -0.06048866f, -0.04642785f, 0.08928719f, 
    -0.12416199f, 0.16723482f, -0.00303059f, -0.17464586f, -0.16905957f, -0.04470667f, 0.01693131f, -0.22843812f, 
    0.13139141f, -0.03995103f, 0.03219296f, 0.01798711f, -0.15351948f, -0.12289912f, -0.00176670f, 0.13410725f, 
    -0.31168064f, -0.05189262f, 0.00676324f, -0.01201982f, 0.09074529f, 0.14495613f, 0.04737998f, -0.01080462f, 
    -0.18645853f, 0.13145034f, -0.13980649f, -0.04016158f, 0.44895318f, -0.10817940f, -0.05811036f, -0.21808837f, 
    0.07777217f, -0.16202384f, 0.05661567f, 0.04216661f, -0.01848086f, 0.03520833f, 0.04065655f, 0.02707571f, 
    0.41697207f, 0.06153931f, 0.13586687f, 0.17311992f, -0.02369093f, -0.22951452f, -0.15528767f, 0.07318716f, 
    -0.02348453f, 0.01301097f, 0.01477965f, -0.06957438f, -0.17275621f, -0.04912999f, -0.03826037f, 0.09327381f, 
    0.01201905f, -0.16265304f, -0.03075949f, 0.02848479f, -0.06998719f, 0.00866314f, -0.02745521f, -0.10347140f, 
    0.16712573f, 0.01738097f, 0.01759546f, 0.30127081f, -0.16850637f, -0.02629222f, 0.07851750f, 0.05492738f, 
    -0.02157639f, 0.08353706f, -0.09101147f, -0.07028599f, 0.09954200f, -0.04823399f, 0.00111133f, -0.05388088f, 
    0.04339141f, -0.05846832f, 0.01677882f, -0.14178599f, -0.02486863f, 0.08212217f, 0.03529652f, -0.03780948f, 
    0.04822671f, -0.02859970f, 0.10227387f, 0.07427605f, 0.08953008f, 0.17166093f, -0.04002659f, -0.06074705f, 
    0.03314081f, 0.03779659f, -0.02853658f, 0.05975015f, 0.39212471f, -0.17970893f, -0.37213320f, 0.14711899f, 
    -0.08480994f, -0.03751706f, 0.08508369f, -0.04923954f, -0.09240790f, -0.01999171f, -0.12547813f, -0.05383444f, 
    0.24017556f, -0.21911334f, -0.05378432f, -0.00838259f, -0.23103926f, -0.03529257f, -0.26676258f, -0.02507837f, 
    0.15921980f, -0.05818450f, -0.07234420f, -0.19150917f, 0.44994295f, 0.01535395f, -0.06413151f, 0.33437446f, 
    -0.05051758f, -0.11035638f, 0.16291258f, 0.11741931f, -0.06564664f, -0.00132789f, 0.05324348f, 0.04744634f, 
    -0.44780788f, 0.05460881f, 0.18981977f, -0.21542519f, -0.10390624f, 0.00003066f, 0.20809889f, 0.06521952f, 
    -0.05223988f, -0.14182082f, 0.07644808f, 0.12007927f, 0.27928358f, 0.11600623f, -0.52911472f, -0.21146795f, 
    -0.11917532f, 0.10238654f, -0.09945688f, 0.11049107f, -0.11203191f, -0.02331263f, -0.02917640f, -0.06662668f, 
    -0.51916075f, -0.15762818f, 0.10374454f, -0.47620726f, 0.17897666f, -0.10702873f, 0.14310561f, 0.06774304f, 
    -0.05462017f, 0.06043619f, -0.13401435f, -0.11303273f, -0.38411108f, -0.17730571f, -0.34397644f, -0.44111168f, 
    0.00408917f, -0.14345807f, -0.18013117f, -0.08987030f, 0.04269448f, 0.02511055f, 0.05697412f, -0.03470161f, 
    0.40316439f, 0.13753884f, -0.05957356f, -0.14616367f, -0.04030689f, 0.02300098f, -0.03110330f, -0.05392542f, 
    -0.14972660f, -0.07922756f, -0.06470138f, -0.08520993f, 0.06633703f, 0.13501194f, -0.06982123f, -0.07144295f, 
    0.07007295f, 0.13564205f, -0.02469989f, -0.15059128f, 0.00774446f, 0.07906789f, 0.09499315f, -0.23079601f, 
    0.25238672f, 0.17122513f, 0.12989861f, 0.23689665f, -0.23519181f, -0.14735471f, -0.06820133f, 0.06754987f, 
    0.07357325f, -0.08449385f, -0.08980620f, -0.05646973f, 0.31121531f, 0.10529494f, 0.03716834f, 0.17747736f, 
    -0.03956272f, -0.13357466f, 0.18548980f, -0.03464701f, 0.04498569f, 0.15742284f, 0.00346503f, -0.08115032f, 
    -0.17535803f, 0.22425705f, -0.17824014f, -0.07222914f, 0.03060240f, -0.14295459f, 0.28968900f, -0.00874120f, 
    -0.11080691f, -0.02663918f, 0.08819206f, -0.05196033f, -0.44516850f, -0.21748507f, 0.03399063f, 0.22294258f, 
    0.08877751f, -0.07334068f, 0.06668410f, -0.04517558f, 0.03299602f, -0.04272159f, 0.05022926f, -0.04724064f, 
    0.45194542f, 0.23304003f, 0.06095687f, 0.23960175f, 0.32590845f, 0.14456536f, 0.00467232f, 0.10857898f, 
    -0.15370160f, 0.01851606f, -0.09440353f, -0.34213713f, -0.70401537f, 0.16045265f, -0.10367426f, 0.17080012f, 
    0.03120313f, 0.16316551f, -0.18025544f, 0.04688451f, -0.02681701f, 0.10861351f, 0.16047563f, -0.04516809f, 
    -0.03796680f, 0.15392359f, -0.12689443f, -0.20555913f, 0.01890651f, 0.00578493f, 0.03750585f, -0.01374435f, 
    -0.11530970f, -0.12445174f, -0.01894692f, -0.02810494f, 0.32484919f, -0.10597660f, -0.31368902f, -0.13839100f, 
    0.09467526f, -0.00708075f, -0.07269976f, -0.12049936f, -0.00509174f, 0.04829791f, 0.05029188f, -0.01600224f, 
    0.05927108f, -0.23049207f, -0.04366582f, -0.06100668f, -0.13829245f, -0.03885974f, -0.03193920f, 0.01894380f, 
    -0.01105146f, 0.04824968f, 0.03402912f, 0.01834432f, 0.00561019f, -0.37938318f, -0.30156806f, 0.16669208f, 
    -0.00635849f, -0.10683911f, 0.06296684f, 0.12431367f, 0.03341054f, -0.03749255f, 0.05470287f, -0.09923852f, 
    -0.27874720f, -0.07480047f, 0.15159731f, -0.02320697f, -0.00824936f, 0.03727549f, 0.06558277f, -0.12239262f, 
    -0.03918369f, 0.16264911f, 0.08400030f, 0.11963633f, -0.76608628f, -0.36973199f, -0.17704093f, -0.07861804f, 
    0.00612233f, 0.05234592f, -0.03848619f, -0.01476102f, 0.02308762f, -0.02727766f, 0.17205243f, 0.01268420f, 
    0.17437033f, 0.24176598f, 0.16670477f, 0.19122458f, 0.00986306f, -0.03869307f, -0.03214554f, 0.03021855f, 
    0.02229778f, 0.12907809f, 0.07780834f, 0.19934084f, 0.32176122f, -0.35939547f, -0.27724925f, -0.02131154f, 
    -0.05127908f, -0.07865021f, -0.14958605f, 0.16113071f, 0.10021637f, -0.10669059f, -0.17221865f, -0.10262725f, 
    0.19420891f, -0.01139263f, 0.31178758f, 0.14105041f, 0.07312360f, -0.03847488f, 0.02626495f, 0.06310176f, 
    0.13121809f, 0.14957777f, -0.03790202f, 0.07803601f, -0.47378838f, -0.06201458f, -0.11270853f, -0.14324796f, 
    -0.00081171f, 0.03318745f, 0.08024686f, 0.10899363f, 0.16469881f, -0.05597873f, -0.02677843f, 0.12133414f, 
    0.17159544f, -0.49921626f, -0.35790762f, 0.42429653f, -0.14628312f, -0.09629828f, 0.11793885f, 0.05758275f, 
    0.04565950f, 0.04482802f, -0.01661827f, 0.11093210f, -0.19654474f, 0.05966228f, -0.27052087f, -0.10109882f, 
    -0.13201225f, 0.06729097f, 0.07501099f, 0.00744439f, 0.02994621f, -0.10722326f, 0.09574669f, -0.07047330f, 
    -0.08848118f, 0.18600422f, -0.09122882f, -0.11093179f, 0.02945966f, -0.17123573f, 0.12621811f, -0.08447796f, 
    -0.04864671f, -0.12830742f, -0.04112117f, -0.08209550f, -0.09112006f, 0.05858772f, -0.07624727f, -0.13093732f, 
    -0.17848065f, -0.08553494f, -0.06276438f, 0.08556711f, 0.09654014f, -0.02822197f, 0.06187832f, 0.14384487f, 
    -0.14753023f, 0.03644146f, -0.00116917f, -0.14092320f, -0.11256652f, -0.10483603f, -0.03698670f, 0.01473757f, 
    -0.00132894f, 0.05768674f, 0.05041026f, -0.07497411f, -0.65482622f, -0.23709257f, -0.00286160f, -0.31985325f, 
    -0.10183850f, -0.03616312f, 0.02612776f, -0.11924859f, 0.09338289f, -0.09391500f, 0.00320963f, -0.00647060f, 
    -0.43235981f, -0.47057313f, -0.06527526f, 0.44036990f, -0.02687321f, 0.02420828f, 0.04255172f, -0.05698142f, 
    -0.07506707f, -0.08410142f, -0.12533832f, 0.02741435f, 0.24911226f, 0.01961943f, 0.17594333f, -0.03592573f, 
    0.07879476f, -0.05304027f, -0.01855950f, 0.07827080f, 0.06926613f, 0.01677085f, 0.05123271f, -0.05690177f, 
    0.31676364f, 0.05805107f, -0.00649087f, 0.13446589f, 0.01052948f, -0.16648538f, -0.04257598f, -0.00943790f, 
    -0.11010171f, -0.04208718f, 0.12111138f, -0.05090385f, 0.28706500f, -0.26251486f, -0.08404388f, -0.02287044f, 
    -0.05595386f, 0.00490287f, 0.06402895f, -0.01192546f, -0.24415126f, -0.03943198f, -0.07977092f, -0.06790515f, 
    -0.04936378f, -0.26982021f, -0.24780335f, 0.09253386f, -0.08688630f, 0.08904790f, 0.00921244f, 0.03917600f, 
    0.01640266f, 0.12664017f, -0.02467863f, -0.06872945f, -0.34303829f, 0.33864164f, 0.18202098f, -0.01976157f, 
    0.17221291f, -0.01207270f, -0.11375639f, 0.08973197f, -0.00845545f, -0.20202488f, -0.22605404f, 0.03851094f, 
    0.40015802f, 0.11379693f, 0.07993826f, 0.27484092f, -0.13981675f, -0.07270023f, -0.03610528f, 0.04357615f, 
    -0.14626130f, 0.04749889f, -0.15349637f, 0.01030036f, 0.27393818f, 0.04797676f, 0.24306396f, 0.10076487f, 
    -0.07365074f, 0.05976947f, 0.08144058f, 0.01457649f, -0.10779927f, 0.08477414f, 0.05937903f, 0.11825747f, 
    0.07818119f, 0.29516798f, 0.20101959f, -0.28003830f, -0.13792804f, 0.07203196f, -0.05430422f, 0.07698273f, 
    0.06020906f, -0.01819962f, -0.08796924f, 0.04600449f, -0.38176236f, -0.11957275f, -0.16076288f, 0.10405319f, 
    -0.06903514f, -0.03369640f, 0.16430114f, 0.03769459f, -0.06144714f, 0.01099266f, -0.06439267f, 0.05156233f, 
    -0.23652068f, -0.09149826f, -0.11612174f, -0.22680676f, -0.16779973f, -0.17071570f, 0.02559191f, -0.01718650f, 
    -0.10858861f, -0.11608668f, -0.02892157f, -0.00793960f, -0.23145401f, 0.09562877f, 0.07515895f, -0.18152347f, 
    0.08729038f, -0.05296262f, 0.06582083f, 0.01429693f, -0.02465904f, -0.09663396f, -0.06856124f, 0.06939589f, 
    -0.14111698f, -0.24291864f, 0.01324975f, 0.15125479f, -0.09698097f, 0.03864080f, -0.09107740f, 0.12821065f, 
    -0.05819451f, 0.17924726f, -0.07479271f, 0.04211321f, 0.11150925f, -0.09733545f, 0.13350815f, 0.05798297f, 
    -0.11097339f, 0.01816500f, -0.00278811f, -0.03930847f, 0.10319869f, 0.05776297f, -0.10734265f, 0.05294790f, 
    -0.46176094f, 0.16185331f, 0.36223945f, 0.13649702f, -0.07748535f, 0.12814523f, -0.09461717f, -0.13192834f, 
    0.08219203f, 0.02329434f, -0.04574093f, -0.22826190f, -0.41777167f, -0.07940565f, 0.40088201f, 0.08316465f, 
    -0.09307636f, 0.09571906f, -0.01712657f, 0.00085072f, 0.08800677f, -0.07886740f, -0.09659281f, -0.04200294f, 
    -0.18009892f, 0.06139733f, -0.05643275f, 0.13815787f, 0.18833086f, -0.05464225f, 0.05759253f, 0.00361341f, 
    -0.09971785f, 0.14468744f, -0.09465124f, -0.04442118f, 0.07319055f, -0.11660718f, 0.12623619f, 0.15730290f, 
    -0.17185134f, 0.01492981f, 0.07268889f, -0.08980605f, -0.01107195f, -0.06532577f, 0.08205065f, 0.00680906f, 
    0.03044260f, -0.09687305f, -0.00732657f, 0.00668361f, -0.05565471f, 0.07751864f, 0.06031676f, 0.00651482f, 
    0.01346838f, 0.08225445f, 0.02674235f, -0.03609565f, 0.12900138f, 0.28764278f, 0.09295898f, -0.12721524f, 
    -0.04622401f, 0.02866843f, -0.07600951f, 0.12787676f, 0.08578496f, -0.11584670f, -0.02076847f, 0.18280467f, 
    0.26890674f, -0.25529552f, -0.03110184f, -0.11125230f, 0.00785890f, 0.18141498f, -0.00022160f, -0.05709944f, 
    0.01172860f, 0.07191509f, 0.03900151f, 0.13049397f, 0.08263755f, 0.25516149f, -0.03602001f, -0.03949527f, 
    0.04737861f, 0.03319195f, -0.00282809f, 0.11548498f, 0.09009454f, 0.03191602f, 0.06917293f, -0.00001850f, 
    -0.17097865f, -0.06086010f, 0.31172657f, -0.08900942f, 0.06480826f, -0.06145909f, -0.17616047f, -0.03861526f, 
    0.07658571f, -0.01106432f, 0.06649932f, 0.08679961f, -0.05522012f, 0.29214594f, 0.00449519f, -0.01392511f, 
    -0.12228952f, -0.13169818f, -0.01981973f, 0.07652179f, 0.02248319f, 0.01419461f, 0.13895123f, 0.02192366f, 
    -0.16940187f, 0.12097672f, -0.22743258f, -0.13164908f, -0.07219735f, 0.05704922f, -0.07020505f, -0.01844801f, 
    -0.10160590f, -0.01138713f, 0.01112651f, -0.03450529f, -0.20884210f, -0.25068045f, 0.14503023f, -0.23290978f, 
    -0.06992479f, 0.16272771f, 0.03983201f, 0.00369185f, 0.05296513f, -0.15651667f, -0.01150752f, -0.07114895f, 
    0.00162843f, 0.18198285f, 0.14906985f, -0.14953259f, -0.01154395f, 0.06750349f, -0.04366206f, 0.24325091f, 
    0.05409251f, -0.07675903f, 0.08900288f, -0.11684042f, 0.31290609f, -0.11475555f, -0.21735826f, 0.13787712f, 
    0.03737373f, -0.04220425f, 0.05282980f, 0.10623613f, -0.07023852f, -0.12225345f, 0.04834662f, 0.01155553f, 
    -0.64073026f, -0.20085332f, -0.04946714f, -0.14874840f, 0.13301896f, 0.01707162f, -0.07549991f, 0.07615357f, 
    -0.06527607f, -0.20797941f, -0.07688382f, -0.07751173f, 0.34596831f, 0.03030645f, 0.20842382f, 0.21590005f, 
    -0.03954498f, -0.09455516f, 0.15911932f, 0.15389815f, 0.02124704f, -0.01815576f, 0.05174341f, 0.08071151f, 
    0.09411639f, -0.09610191f, 0.11135318f, 0.33815080f, -0.00029496f, 0.09885647f, 0.02488706f, 0.09303313f, 
    0.03728014f, 0.17227629f, 0.14166492f, 0.01288567f, -0.32697773f, -0.11539378f, -0.23414375f, 0.01791585f, 
    -0.06246423f, -0.14344576f, 0.12402255f, 0.16990696f, -0.01497992f, -0.03654405f, 0.02072570f, -0.07944664f, 
    -0.19672777f, 0.02664234f, 0.06522417f, 0.02525765f, 0.02363309f, 0.01085617f, -0.11239893f, 0.02987060f, 
    0.09090485f, -0.16449915f, -0.03718388f, 0.05280380f, 0.50082392f, 0.51450276f, -0.33203077f, -0.54095799f, 
    -0.15117842f, -0.08018094f, 0.03510047f, -0.03307290f, -0.07282981f, -0.09728729f, -0.00224964f, 0.01061152f, 
    -0.53145659f, 0.02425455f, -0.10230094f, -0.44537464f, 0.02238105f, 0.03301740f, 0.00377446f, 0.08761071f, 
    0.02761054f, -0.21352850f, 0.06524197f, -0.02040981f, -0.07614475f, -0.00809191f, 0.25624853f, 0.07129133f, 
    -0.04967995f, 0.01056146f, -0.12640311f, -0.26931813f, -0.06989484f, 0.01222037f, -0.05675765f, -0.09215866f, 
    -0.06405261f, -0.62101543f, 0.19695874f, -0.21893786f, -0.11127767f, 0.19729815f, -0.07736928f, -0.09760928f, 
    0.16019742f, 0.10901607f, 0.08533413f, 0.02473334f, -0.13354717f, -0.29052484f, 0.14098527f, 0.00930797f, 
    -0.01347966f, -0.00693755f, 0.00297600f, 0.01202686f, -0.04673612f, -0.07342566f, -0.08677736f, -0.08345382f, 
    -0.34714195f, -0.05077475f, -0.14465852f, 0.04693849f, 0.04412521f, -0.03199055f, -0.00428786f, -0.06164168f, 
    -0.06830399f, -0.08511499f, -0.04865302f, -0.12641743f, 0.17031176f, 0.01542167f, 0.14606498f, -0.05295207f, 
    0.12765887f, -0.04994364f, 0.03917959f, 0.12589335f, -0.05604585f, 0.06809311f, 0.02941089f, 0.19347714f, 
    0.56962597f, 0.03499198f, 0.08077293f, -0.22958665f, 0.06216699f, -0.04154277f, 0.18218119f, -0.04551545f, 
    0.14528191f, -0.03373249f, -0.11651006f, -0.06256711f, -0.52676439f, -0.40846756f, 0.04922893f, 0.04270003f, 
    -0.28980157f, 0.18949805f, -0.07575309f, -0.05583334f, 0.13605362f, -0.03555635f, -0.04982003f, -0.01430342f, 
    -0.50292480f, 0.11456318f, 0.07849814f, 0.17684276f, -0.10648779f, 0.10269888f, 0.12206472f, -0.19993499f, 
    0.03082926f, 0.08782554f, -0.03300374f, 0.06207595f, -0.50306541f, -0.23699729f, 0.16322194f, 0.21319196f, 
    -0.02180299f, -0.04129896f, -0.08767459f, -0.03683910f, -0.11741000f, 0.02790062f, 0.23299614f, 0.12107346f, 
    -0.06972537f, -0.21757135f, 0.08786815f, -0.05968665f, -0.21857865f, 0.23953550f, 0.08399463f, -0.10121487f, 
    -0.03613897f, 0.17052603f, -0.03536766f, 0.05206914f, -0.15617116f, 0.16750599f, 0.00431157f, 0.32385176f, 
    -0.07988748f, -0.02508662f, 0.22060828f, -0.07025580f, -0.06548874f, -0.03500184f, 0.06747752f, 0.11954239f, 
    0.03991387f, -0.11522590f, -0.06663927f, 0.15006053f, -0.20327298f, -0.10994913f, 0.08370215f, 0.03462160f, 
    -0.01347942f, 0.07040601f, 0.06276990f, 0.45452353f, -0.06464860f, -0.08594464f, -0.11363206f, 0.19150296f, 
    -0.13914220f, -0.17592201f, -0.13600859f, 0.04262844f, -0.14918984f, 0.13341171f, -0.05842923f, -0.02993267f, 
    -0.15266831f, 0.14246087f, -0.07106257f, -0.09652654f, 0.02680076f, -0.12598844f, -0.07051456f, -0.18252465f, 
    0.10187996f, -0.11717763f, 0.17817411f, -0.20219365f, 0.00979045f, -0.17070723f, 0.11511896f, -0.19560531f, 
    0.02040386f, -0.34408054f, -0.11864870f, 0.14422111f, 0.20261346f, -0.05860132f, -0.01350744f, -0.03842410f, 
    0.01696458f, 0.19753069f, -0.12016106f, -0.01563772f, -0.29626733f, 0.07621512f, 0.04735791f, -0.16329530f, 
    0.15818603f, -0.06274112f, 0.01051732f, 0.18029574f, -0.12577373f, 0.09810907f, 0.05188171f, 0.03183870f, 
    0.01934982f, 0.07400706f, -0.01514110f, -0.10314214f, 0.02911895f, 0.20716129f, -0.21265157f, 0.01600866f, 
    0.18090802f, -0.08581952f, 0.16172431f, 0.28341743f, 0.11368742f, 0.02598394f, -0.00226070f, -0.21994914f, 
    -0.10748456f, -0.10951091f, -0.28924707f, -0.03661369f, -0.21075411f, -0.08210400f, 0.17036055f, -0.16327621f, 
    0.04640274f, -0.01741340f, -0.04686911f, -0.10766322f, 0.17283389f, 0.00028899f, 0.11114547f, -0.13357200f, 
    -0.06569626f, 0.01690516f, -0.05446207f, 0.29128626f, 0.00829053f, 0.09887660f, 0.09782097f, 0.15859768f, 
    -0.12506312f, 0.03768242f, 0.24456559f, -0.12624341f, 0.11843155f, 0.09873199f, -0.04371116f, 0.00325531f, 
    -0.02004964f, 0.08613259f, 0.21687445f, -0.14459464f, -0.05419561f, -0.01937366f, -0.20400657f, 0.08281014f, 
    -0.20211363f, 0.07891401f, 0.19496495f, 0.01542846f, 0.01225124f, 0.25029162f, 0.06814206f, -0.20422971f, 
    -0.02470986f, -0.34136868f, -0.03408651f, 0.00603570f, 0.16695285f, -0.05039341f, 0.08254902f, -0.14293958f, 
    -0.15176360f, 0.09485286f, 0.05133716f, -0.16857119f, -0.04466382f, 0.10873637f, 0.20140335f, -0.03918341f, 
    0.03368283f, 0.06418366f, 0.16589954f, 0.19616351f, 0.12569317f, -0.00050640f, 0.03610333f, -0.05941503f, 
    -0.05719584f, 0.06696734f, 0.09274264f, 0.20856364f, 0.27065438f, 0.22711898f, 0.10625526f, -0.36999050f, 
    0.02277167f, -0.12583962f, -0.16319174f, -0.09907409f, -0.08104757f, -0.02504943f, -0.24322802f, -0.00664011f, 
    -0.66994184f, -0.12578773f, -0.20120256f, -0.17810737f, -0.05967190f, 0.06840456f, 0.19746011f, 0.12441543f, 
    -0.02988272f, 0.02584171f, 0.07984295f, -0.19795828f, -0.33121753f, -0.23434730f, 0.00950080f, 0.04117262f, 
    0.16109484f, -0.00155463f, -0.21498142f, -0.17032927f, 0.03697591f, 0.12057141f, 0.12400752f, -0.01931641f, 
    0.18516667f, 0.06905184f, -0.23199479f, -0.06672161f, 0.10102239f, 0.07763374f, -0.19528148f, -0.18948416f, 
    -0.09735435f, -0.11152283f, -0.13892458f, -0.01298959f, -0.20366058f, 0.22163558f, 0.41342187f, -0.31846610f, 
    0.15115274f, 0.03927739f, 0.06143222f, 0.11534353f, 0.13637666f, -0.00400642f, 0.01086842f, -0.06866280f, 
    0.11693694f, -0.00279231f, 0.27498037f, 0.19734287f, -0.04749454f, 0.07577215f, 0.01149288f, 0.03294802f, 
    0.04601631f, 0.08229982f, 0.03069867f, 0.12479882f, -0.16548015f, -0.37871480f, 0.49937838f, 0.30589962f, 
    0.04198783f, -0.11486084f, -0.00470109f, -0.07689401f, 0.05969373f, 0.11902200f, 0.11896068f, -0.02138543f, 
    -0.82811427f, -0.19687587f, 0.00368608f, -0.25338078f, 0.08425905f, 0.11946815f, 0.33678877f, 0.01020928f, 
    0.00678990f, 0.09114075f, -0.11928222f, 0.10247447f, 0.18416822f, 0.06531440f, 0.02979659f, -0.36372387f, 
    -0.19279197f, -0.00117079f, -0.09625624f, 0.11189394f, -0.03036797f, -0.13627753f, 0.00870346f, -0.18360336f, 
    0.20116992f, 0.16519009f, 0.00024265f, 0.08589300f, -0.07744984f, -0.05520607f, -0.06194893f, 0.08895860f, 
    0.04444936f, -0.05130257f, -0.01616939f, -0.07742693f, 0.15384208f, -0.00363192f, -0.06460097f, 0.02849959f, 
    -0.07680742f, 0.03163824f, 0.07008946f, 0.09380473f, 0.22401862f, -0.03805304f, 0.05583334f, 0.25895631f, 
    -0.46173471f, -0.04545177f, 0.11712825f, 0.34357819f, -0.17515662f, 0.07372143f, -0.03000307f, 0.05943792f, 
    0.00171900f, -0.03281437f, 0.13288924f, -0.06715867f, 0.09331942f, -0.13063896f, 0.16503902f, 0.14310534f, 
    0.10745980f, 0.12215021f, 0.07370378f, 0.06886145f, 0.08687377f, -0.17488199f, -0.02685072f, -0.10242929f, 
    -0.58176363f, -0.48917425f, -0.02767435f, 0.20073619f, -0.04170774f, 0.02316038f, 0.07630931f, -0.02194316f, 
    0.05167996f, -0.07003641f, 0.05826490f, 0.13220260f, -0.00579515f, 0.10622481f, 0.13086218f, 0.15848058f, 
    -0.01259042f, 0.00045967f, 0.11113030f, -0.01207346f, -0.12026794f, -0.39454991f, 0.07005461f, 0.05296951f, 
    -0.37640619f, 0.07689625f, -0.15267725f, -0.14937577f, 0.07550105f, 0.09214874f, 0.02663937f, -0.14618421f, 
    0.03660816f, 0.00260643f, 0.01366382f, 0.04536232f, 0.01498014f, -0.16135719f, -0.39906996f, -0.07549659f, 
    0.03213556f, 0.19207826f, -0.07761067f, -0.01586096f, -0.06393141f, -0.18525217f, -0.01658522f, 0.10401960f, 
    0.21427676f, -0.09757513f, -0.14844735f, 0.13703705f, 0.03063357f, -0.14804247f, -0.17625667f, -0.17504917f, 
    0.14322692f, -0.07580329f, -0.20581083f, 0.03983117f, 0.07782915f, -0.22962871f, -0.16387376f, 0.03165343f, 
    0.02275509f, 0.02468216f, -0.11089449f, 0.07906193f, 0.09507359f, -0.13740814f, -0.06064918f, -0.06981372f, 
    0.21764669f, 0.13005638f, 0.06768232f, -0.36512274f, 0.01336893f, 0.10203641f, 0.01767326f, -0.00748688f, 
    0.00807157f, -0.04404328f, 0.01474669f, -0.20147854f, -0.01582932f, 0.16163717f, 0.09868284f, -0.37788287f, 
    0.34940284f, -0.10868719f, 0.06768128f, 0.11839757f, -0.11760215f, -0.05492372f, 0.03508046f, 0.17598425f, 
    0.32825708f, -0.02996625f, 0.09086103f, 0.29752570f, -0.17261066f, 0.18487565f, 0.01806217f, 0.06111939f, 
    -0.05066357f, 0.02371069f, -0.05864177f, -0.00345928f, -0.22475041f, 0.23641653f, 0.00171482f, -0.04533922f, 
    -0.18638852f, 0.18006940f, 0.00865527f, 0.05078493f, -0.34368446f, 0.00105958f, 0.22997953f, 0.13280106f, 
    0.03787627f, 0.13896054f, -0.01853409f, 0.26776803f, 0.07951654f, 0.11730476f, -0.05070640f, 0.05817452f, 
    0.03532629f, 0.10760165f, -0.01793706f, -0.20943168f, 0.01472709f, -0.03686455f, -0.06087648f, -0.26439175f, 
    0.08157703f, 0.05642710f, 0.19114941f, 0.02533394f, -0.07666501f, -0.02607726f, 0.16544493f, -0.09124858f, 
    -0.48480675f, 0.11924424f, -0.21224809f, 0.16708550f, -0.12264822f, -0.11866839f, 0.03054014f, 0.02641094f, 
    0.02337580f, 0.28668898f, 0.10611981f, 0.02172442f, 0.31162131f, 0.13825212f, 0.22303246f, -0.23210199f, 
    -0.19406348f, 0.07052876f, -0.11312740f, 0.04237111f, -0.11479804f, -0.04766874f, 0.04616358f, 0.26525816f, 
    0.07059490f, -0.12480102f, -0.08891498f, -0.30430570f, 0.07083847f, 0.01539148f, 0.03718101f, -0.17190278f, 
    0.04814898f, -0.06425726f, -0.04119818f, 0.13877314f, -0.34300426f, 0.09580259f, 0.18704411f, -0.07903749f, 
    -0.11751740f, 0.01960292f, -0.11662631f, -0.00059775f, 0.00831963f, -0.00834637f, 0.08698018f, -0.16632263f, 
    0.25067392f, -0.22884507f, 0.02114162f, -0.23603861f, 0.03165434f, -0.04385785f, 0.10373271f, -0.13806958f, 
    0.12031775f, 0.21258357f, 0.21383414f, 0.02257662f, -0.23760405f, 0.25236627f, 0.17436114f, 0.35801581f, 
    -0.15174930f, 0.02120203f, 0.05671500f, 0.03762522f, 0.08267703f, -0.15195246f, 0.00305399f, -0.20965616f, 
    -0.01827966f, 0.23865518f, 0.01303244f, -0.13060831f, -0.11646067f, 0.00903646f, 0.01327800f, 0.00744289f, 
    0.09232558f, 0.02077835f, -0.05340927f, -0.18236950f, -0.57894093f, 0.19724835f, 0.01460994f, -0.00627256f, 
    -0.13181096f, 0.07780342f, 0.11130556f, 0.17881922f, 0.19829316f, -0.04286734f, 0.06067769f, 0.05608936f, 
    0.41189319f, -0.08889784f, 0.19368763f, -0.01928931f, 0.00278269f, 0.13269542f, 0.05007988f, -0.29378635f, 
    -0.09409163f, 0.03228283f, 0.00702935f, 0.11096980f, -0.02716938f, -0.05167209f, -0.28208467f, -0.03407408f, 
    -0.14843465f, 0.05173271f, -0.12948178f, 0.10483049f, 0.00819524f, 0.01332819f, -0.15210482f, 0.09264950f, 
    -0.51250237f, -0.26481104f, -0.06490702f, -0.22774389f, 0.05471190f, -0.06795282f, 0.04110596f, -0.04593519f, 
    -0.12702660f, 0.02453762f, 0.15865296f, 0.09051337f, 0.29436430f, -0.22450751f, -0.06330007f, 0.01656803f, 
    -0.26991084f, -0.20520231f, -0.05094021f, 0.04840728f, -0.04378090f, 0.10416011f, -0.07718294f, 0.03095932f, 
    0.24228106f, 0.12122772f, -0.11215881f, -0.46543548f, -0.19862632f, 0.01850019f, 0.08594538f, 0.04338545f, 
    0.00782215f, 0.01209745f, -0.01584747f, -0.18842575f, 0.13308933f, -0.14573370f, -0.35875350f, 0.29196644f, 
    -0.02649027f, 0.00773484f, 0.03832544f, -0.14955074f, 0.06061001f, -0.08891983f, -0.24365309f, 0.06408937f, 
    0.21060540f, -0.51188427f, -0.01691143f, -0.11047585f, -0.12468234f, 0.02839578f, -0.08846608f, -0.16206299f, 
    0.05802331f, 0.06342459f, -0.06339169f, -0.05829071f, -0.16614242f, 0.00269941f, 0.34961072f, -0.29678416f, 
    -0.00349206f, -0.16459757f, 0.04803070f, -0.17562898f, -0.18478702f, 0.10639758f, 0.02591398f, 0.01325696f, 
    -0.58772945f, 0.21033312f, -0.12733588f, 0.42151028f, 0.15588358f, 0.04262287f, -0.13229257f, 0.12004615f, 
    0.01119911f, 0.04727797f, -0.11519401f, -0.04450310f, 0.08730433f, -0.33954176f, 0.13305514f, -0.11160483f, 
    0.03184496f, -0.04885359f, 0.19109879f, -0.01277352f, -0.09549730f, 0.09413725f, -0.03349766f, -0.54175967f, 
    0.25807148f, -0.20632611f, -0.27914274f, 0.33562726f, 0.04682647f, 0.12532632f, -0.07176306f, 0.04669831f, 
    -0.12885742f, -0.08576678f, -0.09070054f, -0.00490683f, 0.06032003f, -0.30928388f, -0.16550922f, 0.00135458f, 
    0.01581686f, -0.12787214f, 0.01842899f, 0.03291866f, 0.00876854f, -0.12302850f, -0.05168836f, 0.05555073f, 
    0.21670419f, 0.02350220f, -0.06261308f, 0.19948111f, -0.05719304f, -0.00191996f, -0.08234344f, -0.06143910f, 
    -0.30391860f, 0.17344727f, 0.06819358f, -0.15717988f, -0.04357518f, 0.32597873f, 0.18318060f, 0.00890149f, 
    0.18399429f, 0.04653586f, -0.07326443f, 0.02739126f, 0.02727819f, 0.16329411f, -0.26749212f, -0.00973416f, 
    -0.24041958f, -0.44330344f, -0.19927567f, -0.00126979f, 0.00795974f, -0.00363785f, 0.08614233f, 0.12746480f, 
    0.12296167f, -0.01062785f, -0.10963747f, 0.06680731f, 0.03057834f, -0.17928153f, -0.45480838f, 0.07849269f, 
    -0.19112813f, -0.08672854f, 0.04016310f, -0.22598541f, 0.11767156f, 0.01086959f, -0.03562871f, 0.24196167f, 
    -0.32747984f, -0.15810515f, -0.29310694f, 0.36614546f, 0.19064121f, 0.01047997f, 0.20611773f, 0.22634013f, 
    0.08196526f, 0.04069518f, 0.09749288f, 0.09693819f, -0.25952715f, 0.01400670f, -0.42603183f, 0.11368188f, 
    -0.07646828f, 0.04576317f, 0.05496734f, -0.19038759f, 0.01787019f, -0.01090697f, 0.02934799f, -0.04551411f, 
    -0.20930615f, -0.13929237f, 0.00052901f, 0.15620323f, -0.14933780f, -0.20355654f, -0.13767284f, -0.11041084f, 
    -0.07750955f, -0.02371052f, 0.06973042f, -0.10933648f, 0.19155599f, -0.54189247f, 0.10467555f, 0.04071942f, 
    -0.18918756f, 0.01780637f, -0.03582580f, -0.00769087f, -0.17908464f, -0.00256555f, -0.01747765f, 0.09426475f, 
    -0.04627857f, 0.16639781f, -0.12089219f, 0.18068689f, 0.06960820f, -0.13064836f, 0.03547292f, 0.09353239f, 
    -0.05431058f, 0.06317478f, 0.03726268f, -0.04907356f, -0.32361239f, 0.05632123f, -0.15321209f, -0.25716600f, 
    -0.01768802f, 0.07644439f, -0.22144429f, -0.12014930f, -0.15232782f, -0.19274877f, -0.05388554f, -0.11512993f, 
    -0.44059286f, 0.06864630f, -0.08986958f, 0.01877092f, -0.07923056f, 0.03991529f, -0.09720139f, 0.05844716f, 
    -0.01236770f, 0.15688162f, 0.00880548f, 0.09187001f, -0.30773282f, 0.08545527f, -0.01462238f, -0.10637282f, 
    0.01174005f, -0.04378486f, 0.03234059f, -0.15450361f, -0.13358283f, -0.07531781f, -0.04091817f, -0.03861998f, 
    0.59074134f, 0.13209517f, -0.16436563f, 0.02101185f, -0.06351065f, 0.00351813f, -0.09023604f, 0.02071383f, 
    -0.07798498f, 0.03485801f, 0.07358018f, -0.02211458f, -0.03582233f, -0.10825319f, -0.31520033f, -0.09688552f, 
    -0.13941579f, -0.01278250f, -0.03380129f, -0.08285161f, -0.06281788f, -0.10466919f, -0.12747131f, -0.22211248f, 
    0.26851088f, 0.01056165f, 0.12504372f, 0.05587387f, -0.06258497f, -0.13733754f, -0.06583859f, -0.03473949f, 
    -0.06665874f, 0.00250250f, -0.17724033f, -0.01730777f, -0.19870190f, 0.14726856f, -0.08027986f, -0.10088407f, 
    -0.08413243f, 0.12607746f, 0.01926810f, -0.09497977f, -0.09765860f, -0.08819909f, 0.09975960f, -0.15925801f, 
    0.28259596f, 0.28965750f, 0.15842821f, -0.14633366f, -0.22583805f, 0.11832731f, 0.03986410f, -0.06303415f, 
    -0.09809574f, 0.00880165f, -0.06807515f, -0.08929709f, -0.19166827f, -0.39867193f, -0.09102337f, -0.00115112f, 
    -0.15090233f, -0.09818316f, 0.02683883f, 0.02987377f, -0.09300716f, -0.07244951f, -0.04106406f, -0.03320789f, 
    -0.21747880f, 0.06803934f, 0.01969122f, -0.07091501f, -0.05912698f, -0.08513588f, 0.02807739f, 0.03280114f, 
    -0.08187151f, 0.04801812f, -0.00636439f, -0.04650943f, -0.34034315f, 0.17962457f, 0.16054824f, -0.11597081f, 
    -0.07439250f, 0.07746343f, 0.01029114f, -0.03145757f, 0.01155696f, -0.03152276f, -0.03462901f, -0.03686529f, 
    0.08273904f, 0.20576403f, 0.26693967f, 0.16015740f, 0.17312582f, 0.13303751f, 0.05226479f, 0.05986046f, 
    -0.14226921f, 0.05943911f, 0.00841255f, 0.06837990f, 0.13781272f, 0.27585053f, 0.08230415f, 0.23747885f, 
    0.18751051f, 0.09126829f, 0.03696587f, 0.05053844f, -0.10185714f, -0.13240479f, -0.08809102f, -0.06411385f, 
    -0.01262247f, 0.06723297f, 0.16501403f, 0.24297519f, 0.14096756f, 0.07759774f, 0.04550305f, -0.24173942f, 
    -0.04986408f, -0.01530503f, -0.06489632f, 0.00891870f, 0.12987497f, -0.00214738f, -0.02380941f, -0.15836613f, 
    0.08180752f, 0.03623132f, 0.00681075f, -0.06096124f, -0.02002575f, -0.01764384f, -0.07874258f, -0.06974296f, 
    -0.34759486f, 0.01062348f, -0.24310631f, -0.37905741f, 0.02460582f, -0.01625659f, -0.01231350f, -0.13692246f, 
    0.03149572f, 0.03565019f, -0.10406333f, -0.06322423f, 0.23459145f, 0.11529719f, 0.24423997f, 0.24810849f, 
    0.09069929f, -0.02454934f, -0.00333913f, -0.09449371f, -0.05076192f, -0.11866318f, -0.04006239f, -0.03015436f, 
    0.03969869f, 0.01420157f, 0.16475436f, 0.07106910f, 0.05380660f, -0.02453136f, -0.02054381f, -0.04340526f, 
    -0.04587571f, 0.03280974f, -0.00196591f, -0.10027710f, -0.05153783f, 0.26392955f, -0.03049243f, -0.40066555f, 
    -0.15772073f, 0.03976724f, 0.00186524f, -0.07123937f, -0.01411262f, 0.02330017f, 0.07873612f, -0.09787972f, 
    -0.24561955f, -0.19684675f, -0.27380174f, -0.20795199f, 0.03869054f, -0.09188079f, -0.02246637f, -0.05827106f, 
    -0.18249722f, -0.05484616f, -0.04318643f, -0.02334651f, 0.37901255f, -0.31394356f, 0.08047922f, 0.05318230f, 
    0.09642560f, -0.19789374f, -0.08326937f, -0.20017035f, -0.05155928f, 0.01746375f, 0.03711459f, -0.15072910f, 
    -0.19711384f, 0.13745864f, 0.00986422f, 0.24940950f, -0.04537759f, -0.21297380f, -0.09397060f, 0.06916451f, 
    -0.00097273f, 0.09149233f, -0.10072831f, 0.06526030f, 0.07037927f, 0.12614396f, 0.10305173f, 0.44226807f, 
    -0.01137583f, -0.16572130f, -0.07104731f, 0.08790854f, 0.00866767f, -0.02009468f, -0.08287212f, -0.09946088f, 
    0.23150745f, 0.15129201f, 0.02367893f, 0.29883540f, 0.26986739f, -0.01331795f, 0.13218459f, -0.01609263f, 
    -0.06993298f, -0.00822325f, 0.02737906f, -0.02622673f, -0.07740318f, -0.20668606f, -0.14275572f, -0.16529134f, 
    0.01096134f, -0.02686108f, -0.07661848f, 0.10136376f, -0.06857140f, 0.01008799f, -0.06626420f, -0.14197996f, 
    0.05680200f, 0.06478883f, 0.19781160f, 0.01041312f, 0.12631835f, 0.17866412f, 0.04674749f, -0.02905162f, 
    -0.00172116f, 0.09809310f, -0.00982907f, -0.02477675f, 0.17402588f, 0.13346718f, 0.19257089f, 0.14922151f, 
    0.12527612f, 0.06227584f, 0.12116514f, -0.06841803f, 0.01908195f, -0.03971960f, -0.05535939f, -0.10991054f, 
    -0.01814887f, -0.00346641f, -0.11118530f, 0.18999499f, 0.10729405f, -0.07393001f, -0.17243303f, 0.00498988f, 
    0.10539461f, 0.03643182f, -0.06253431f, -0.15314852f, 0.11380468f, 0.32055217f, -0.29324624f, 0.26741633f, 
    0.04058091f, 0.08632287f, -0.00709212f, 0.04874073f, -0.08342188f, 0.01609832f, -0.01195140f, 0.07054551f, 
    -0.39623380f, -0.41248190f, -0.36803159f, -0.18045247f, 0.06652406f, -0.17101561f, -0.02599511f, 0.02976730f, 
    0.07781188f, 0.11104636f, 0.01409769f, 0.05329633f, -0.09170158f, -0.23289920f, -0.51642734f, 0.15779741f, 
    0.15917911f, 0.03608729f, 0.03854115f, -0.10665214f, -0.00598850f, 0.01142763f, -0.04363908f, 0.00288514f, 
    0.05893669f, 0.03152496f, -0.09307269f, -0.00922133f, -0.13347140f, -0.08741838f, 0.05550110f, 0.07884494f, 
    0.01645639f, -0.09144831f, -0.03142204f, 0.12430763f, 0.07064258f, -0.13846281f, 0.11481416f, 0.09893898f, 
    0.06015009f, -0.04669490f, -0.00795171f, 0.11207324f, 0.09491842f, -0.13368697f, -0.01692712f, -0.19388968f, 
    0.02642851f, 0.04412436f, -0.25750455f, 0.04269712f, 0.05989510f, 0.11058046f, -0.00135588f, -0.00089753f, 
    0.01585977f, -0.16039385f, 0.19507021f, 0.14169356f, 0.10461857f, -0.16130069f, 0.19033936f, 0.20286910f, 
    -0.07130999f, -0.08655410f, -0.05988752f, -0.04245226f, 0.07972823f, -0.09927048f, -0.00400431f, -0.00979406f, 
    -0.07967779f, -0.02532777f, 0.01268680f, -0.17519581f, 0.04446745f, 0.01753693f, -0.04356857f, -0.02121503f, 
    -0.09055637f, -0.00579724f, -0.03126336f, -0.03882639f, 0.15607017f, 0.02558068f, -0.06938893f, 0.24102663f, 
    0.17240028f, 0.00154312f, -0.07813766f, -0.06190344f, -0.00080124f, 0.01361327f, -0.00563102f, -0.02624917f, 
    -0.14362176f, -0.25334328f, -0.05048418f, -0.33556131f, -0.04578965f, -0.05149454f, 0.09202679f, 0.11248139f, 
    0.01316687f, -0.13583578f, 0.00510643f, -0.04943651f, 0.04832855f, -0.17360416f, 0.10277234f, 0.08478125f, 
    0.12804984f, 0.06323265f, 0.03125518f, -0.06541530f, 0.01110216f, 0.14290330f, 0.00636386f, -0.04041976f, 
    -0.20869787f, 0.03511536f, -0.13411926f, -0.28512830f, -0.07855504f, -0.08326893f, 0.13414086f, 0.12082683f, 
    0.12493711f, -0.39442402f, 0.11319230f, 0.11394884f, 0.05052060f, -0.03576672f, -0.36534324f, 0.07294770f, 
    0.08349007f, 0.07422274f, -0.08515867f, -0.15786894f, 0.00405753f, 0.01266831f, -0.04763003f, -0.02751223f, 
    0.02816489f, 0.04931574f, 0.13100569f, 0.16520979f, 0.18519141f, -0.07377834f, -0.01721271f, -0.03999116f, 
    -0.09732989f, -0.00798138f, 0.21875596f, 0.07218636f, 0.21990620f, 0.06291732f, 0.00299742f, 0.16073218f, 
    0.14332278f, -0.01706084f, -0.12015776f, -0.07574141f, -0.04893108f, 0.02647202f, -0.11197818f, -0.17894626f, 
    0.11191922f, -0.19264580f, 0.14555910f, 0.10372943f, -0.04787969f, 0.14999269f, 0.03688363f, -0.15801010f, 
    -0.11178389f, 0.06816394f, -0.01185336f, -0.11052582f, -0.34653014f, -0.06840811f, 0.09009568f, -0.32037115f, 
    -0.01593286f, -0.06515361f, -0.02560624f, -0.29437271f, 0.03020455f, 0.01189052f, -0.00799088f, -0.15784366f, 
    -0.30741957f, -0.06258477f, 0.18775269f, 0.20912661f, -0.15434965f, 0.00743824f, -0.27357724f, -0.06413186f, 
    0.04468984f, -0.14897871f, -0.00267930f, 0.04565807f, 0.37688273f, 0.02230102f, -0.06000288f, 0.09204425f, 
    -0.01965450f, -0.02827557f, 0.00882334f, -0.10560660f, -0.09993229f, -0.09919544f, 0.01538510f, -0.12020572f, 
    -0.06570204f, 0.03957623f, 0.05067623f, 0.23972899f, 0.07809668f, 0.00330649f, -0.07881791f, -0.00692728f, 
    0.16259849f, -0.01178695f, -0.02369050f, 0.12667316f, 0.18766949f, 0.05675678f, -0.00959950f, -0.16830276f, 
    0.01321515f, -0.21211040f, -0.08246019f, -0.04340467f, -0.10158434f, 0.06514350f, 0.07592107f, -0.06750987f, 
    -0.29476169f, -0.19430476f, 0.34321368f, -0.12517828f, -0.09738605f, -0.09277354f, 0.08274046f, -0.27687168f, 
    -0.07953975f, 0.01545383f, -0.10134435f, 0.08390483f, 0.19926001f, 0.15972647f, -0.04899845f, 0.05194734f, 
    -0.07823622f, -0.11307400f, -0.04965170f, 0.14913310f, 0.16471675f, 0.04587981f, -0.16937374f, 0.04662913f, 
    0.29195893f, 0.02830446f, -0.42836055f, -0.24273764f, -0.00112511f, -0.06421906f, -0.05781130f, -0.09943221f, 
    0.10733268f, 0.05183617f, -0.15270172f, 0.02165823f, 0.20828539f, -0.25925761f, -0.03834373f, -0.20273584f, 
    -0.01506457f, -0.00092266f, 0.14562543f, -0.21492614f, 0.03855835f, 0.08424655f, 0.03551031f, 0.15771374f, 
    0.17482033f, 0.41078639f, -0.35309571f, -0.18045932f, -0.07822104f, -0.05963221f, -0.13254759f, 0.02924275f, 
    0.07521658f, -0.14171429f, 0.18462794f, 0.06244439f, -0.02785966f, -0.04316220f, -0.28015730f, -0.50665367f, 
    -0.09875544f, 0.09883577f, 0.11585724f, -0.13648294f, -0.02708309f, -0.07193238f, -0.03625231f, -0.14205058f, 
    0.14173426f, 0.06025097f, 0.00193800f, -0.01056036f, 0.06043931f, -0.14302880f, 0.18550013f, -0.02748621f, 
    0.09154738f, -0.03701872f, 0.08066805f, 0.02816581f, 0.27421257f, -0.04782613f, -0.40838546f, 0.03760724f, 
    0.12487686f, 0.02469758f, 0.00960157f, -0.09005013f, -0.09051222f, 0.05032099f, 0.29911157f, 0.13906288f, 
    -0.03531287f, 0.03125221f, 0.15311226f, 0.09132306f, -0.28041172f, -0.20367469f, 0.02130136f, 0.03037872f, 
    -0.01159455f, 0.01602809f, 0.00362316f, -0.00804617f, 0.07704846f, 0.03524873f, 0.08960463f, 0.11125994f, 
    -0.03180885f, 0.06922485f, -0.07132550f, -0.09184354f, -0.02009735f, -0.08456066f, 0.04845463f, -0.10174809f, 
    0.07042602f, 0.42362615f, -0.31606182f, 0.08590107f, 0.06636903f, -0.03141183f, -0.26594606f, -0.11582995f, 
    0.08847564f, 0.13419560f, -0.09002337f, -0.06382669f, -0.03481919f, 0.18456391f, 0.04115176f, -0.16347760f, 
    -0.17091849f, 0.18890613f, -0.28980121f, 0.02596901f, 0.01506878f, -0.13639145f, -0.00961285f, -0.15736608f, 
    -0.11466580f, 0.02246379f, -0.20820270f, -0.29591396f, -0.03541281f, -0.02856342f, -0.08388976f, 0.04450755f, 
    -0.00620494f, -0.07556096f, -0.03473182f, -0.20265990f, -0.09533525f, -0.21445221f, -0.00850918f, -0.17940785f, 
    -0.06973019f, -0.09545416f, -0.15594196f, 0.01957215f, 0.00399818f, -0.05748532f, 0.17269064f, 0.04919525f, 
    -0.59835333f, -0.03029112f, -0.00864783f, -0.13303187f, 0.00134318f, 0.08260847f, 0.09268798f, 0.06312433f, 
    0.15681942f, 0.08647390f, 0.07047775f, 0.01879248f, -0.31404319f, 0.14182112f, 0.04775123f, -0.32680631f, 
    -0.03065587f, 0.03921273f, -0.01127761f, -0.12470133f, 0.05511037f, 0.09100604f, -0.07470249f, 0.12752004f, 
    -0.50818783f, 0.32611156f, 0.36228135f, 0.10230946f, 0.11343902f, 0.07421028f, -0.07192811f, 0.07523342f, 
    -0.10142064f, -0.17839183f, 0.03806663f, -0.12325183f, -0.24610883f, 0.24750942f, -0.15618224f, -0.20860817f, 
    0.14096287f, 0.02327554f, -0.01864831f, -0.11010882f, -0.14371215f, -0.10990921f, -0.07201474f, -0.15647179f, 
    0.33892974f, 0.07100058f, 0.16374910f, -0.15506709f, -0.14295018f, -0.16901408f, -0.02003556f, 0.22682197f, 
    0.08150244f, 0.12132513f, 0.06501210f, 0.12312040f, -0.44170308f, 0.13687249f, -0.11760381f, 0.00686278f, 
    0.03599555f, -0.04180152f, 0.06118576f, -0.11025973f, -0.16557789f, -0.06669739f, -0.10386499f, 0.07326315f, 
    -0.29524255f, 0.04713920f, -0.27200305f, -0.12785149f, -0.01932441f, 0.03632903f, 0.22556396f, -0.11358134f, 
    -0.02081440f, 0.04279015f, -0.12878746f, 0.13105412f, -0.25582865f, 0.13335013f, -0.17798996f, -0.14788951f, 
    0.06150590f, -0.02434986f, 0.11697064f, -0.08294785f, 0.09950747f, -0.27012655f, 0.11610536f, -0.06333129f, 
    -0.30236459f, 0.07275095f, -0.24506952f, 0.21979995f, 0.06241211f, -0.15062526f, -0.09587684f, 0.17770751f, 
    -0.15995197f, 0.08415760f, -0.02412432f, 0.05713631f, 0.26360157f, -0.03967991f, -0.06049559f, 0.31586722f, 
    0.11930240f, 0.02222822f, -0.21176666f, 0.00349663f, -0.02858638f, -0.04417284f, -0.00847531f, -0.06271895f, 
    0.00240424f, -0.01005501f, 0.03804946f, -0.11050030f, -0.03746686f, -0.10068645f, 0.06431718f, 0.16143744f, 
    0.02611486f, 0.11373912f, -0.01891408f, -0.00141742f, -0.49799407f, 0.34879851f, 0.04222463f, -0.17094782f, 
    -0.02951550f, 0.07673553f, -0.06778374f, -0.03037150f, 0.07768783f, 0.09008838f, 0.25189266f, 0.01844859f, 
    -0.29486248f, -0.18185756f, 0.08228028f, 0.02788505f, 0.12284647f, 0.01598562f, -0.10780768f, -0.15408050f, 
    0.20546064f, 0.20626473f, -0.11412813f, 0.11441100f, -0.32843047f, -0.39655569f, -0.01151539f, -0.11920330f, 
    0.00682412f, 0.03428365f, 0.12361396f, 0.11040992f, -0.04559208f, -0.32042900f, 0.05103654f, -0.12587900f, 
    -0.00709169f, -0.25006473f, -0.06534407f, -0.10214121f, -0.00293894f, 0.06690060f, 0.12718479f, 0.10507008f, 
    -0.09814668f, -0.05295210f, -0.00324329f, -0.01695377f, 0.20434600f, -0.09010386f, -0.04276003f, 0.05129663f, 
    0.32594100f, 0.26114628f, -0.02388208f, -0.17203996f, -0.20845409f, -0.10068402f, -0.13196720f, 0.13301021f, 
    -0.13507599f, 0.33789566f, -0.35180238f, -0.55512071f, 0.21329339f, -0.04314074f, -0.03868600f, 0.00800568f, 
    -0.20000987f, 0.07863260f, -0.05666731f, -0.33131817f, 0.08317263f, -0.42585275f, 0.01908836f, -0.08575342f, 
    0.07728092f, 0.01023027f, 0.06316537f, 0.15640986f, -0.22287674f, -0.08277753f, 0.12555590f, -0.03339877f, 
    0.69248784f, 0.02532681f, -0.34847832f, 0.42194572f, 0.11386438f, -0.07428122f, -0.05306561f, 0.18166718f, 
    -0.00435837f, -0.02794073f, 0.04961414f, 0.06122168f, -0.64804262f, 0.07122831f, -0.11701442f, 0.06336598f, 
    0.15128718f, 0.00876466f, 0.30938855f, -0.16113132f, 0.07738732f, 0.09674258f, 0.07649305f, 0.07213296f, 
    0.58600014f, -0.12446863f, 0.37676069f, 0.05162580f, 0.05286904f, 0.04937511f, 0.22894320f, -0.23619887f, 
    -0.12194891f, 0.02815419f, -0.02976126f, 0.03604531f, 0.01433171f, -0.00895163f, 0.21459147f, -0.03202286f, 
    0.02065957f, -0.03810985f, -0.13010094f, -0.09184360f, -0.01011205f, -0.02858594f, -0.09595176f, 0.07267245f, 
    -0.17243934f, 0.16533566f, 0.44677570f, -0.42996287f, -0.01254231f, -0.04289411f, -0.13613580f, -0.08717149f, 
    -0.10448683f, -0.02366564f, 0.03780735f, -0.02656642f, -0.43496996f, 0.05458647f, 0.03157848f, 0.16201967f, 
    0.06705210f, 0.04862191f, -0.08357055f, -0.03788823f, -0.20267960f, -0.03801693f, 0.05956237f, 0.07460986f, 
    -0.36084089f, -0.47334948f, 0.11578138f, 0.01084277f, 0.11456776f, -0.02516354f, -0.07911991f, -0.04110011f, 
    -0.04922655f, -0.14378448f, 0.20215751f, 0.07815409f, -0.21632460f, -0.00195243f, 0.18444376f, -0.21230808f, 
    -0.05442574f, -0.17146514f, 0.00785388f, 0.04924576f, -0.11378522f, 0.03622941f, -0.08216792f, -0.05134129f, 
    0.31202656f, -0.29693234f, 0.02521028f, 0.34503704f, 0.17263785f, 0.09855400f, -0.08534092f, 0.01960691f, 
    -0.07795709f, -0.07931033f, -0.05474280f, -0.15574040f, 0.21490872f, -0.17921151f, 0.14688517f, -0.23678514f, 
    0.10120730f, 0.01381391f, 0.02409446f, -0.05019381f, -0.01317819f, 0.19094233f, 0.00328980f, 0.04370293f, 
    0.07373936f, 0.18920632f, 0.23056972f, 0.18905944f, -0.05815779f, 0.14143434f, -0.05811206f, 0.24254426f, 
    0.11768557f, 0.09028643f, 0.09106243f, -0.05871443f, -0.14516908f, 0.41703430f, 0.22581629f, -0.06591918f, 
    0.16704760f, -0.06512714f, -0.03320687f, 0.16731551f, 0.03736815f, -0.00014649f, -0.06638732f, 0.14806254f, 
    0.24453585f, 0.21540147f, -0.00443718f, -0.09230579f, 0.03830779f, -0.06035774f, 0.09166217f, 0.16197301f, 
    0.02722352f, 0.11472135f, 0.13173702f, 0.22704664f, -0.36909166f, 0.09436605f, 0.02096693f, -0.33577406f, 
    0.04680579f, 0.06556746f, 0.05226447f, -0.08346702f, -0.05975060f, -0.09866557f, -0.18421078f, 0.00469428f, 
    0.03489465f, 0.07447440f, -0.09045675f, 0.17027630f, -0.03823828f, -0.10728759f, 0.02678060f, -0.14751576f, 
    0.13613103f, 0.00652041f, 0.19683300f, 0.10465050f, -0.40487650f, -0.43984720f, 0.03054339f, 0.03330572f, 
    0.10633294f, -0.00454443f, 0.17378376f, 0.08241037f, 0.06646267f, -0.02582504f, -0.00001472f, 0.05907444f, 
    -0.45288664f, -0.26256037f, 0.13933018f, 0.24902804f, 0.16799794f, 0.00392064f, 0.02174807f, -0.05209273f, 
    0.08902200f, -0.14971448f, 0.19816230f, 0.09435776f, -0.49409384f, -0.17735814f, -0.03643515f, -0.30047897f, 
    0.11729369f, 0.07610489f, -0.02143396f, 0.16091380f, 0.06922601f, 0.00480137f, 0.09412906f, 0.11362484f, 
    -0.08191063f, -0.22935548f, 0.06897204f, -0.35334289f, 0.08204362f, 0.08778297f, 0.01238001f, -0.03706046f, 
    -0.06094167f, -0.02190957f, -0.22142707f, -0.20217022f, -0.20292415f, -0.42151400f, -0.09421409f, -0.10672802f, 
    -0.03372994f, 0.05397104f, 0.08353492f, -0.10080285f, 0.12801024f, 0.13598283f, -0.10714458f, -0.17404395f, 
    0.45668149f, 0.22306594f, -0.01847081f, 0.01369693f, 0.05708482f, 0.16344643f, 0.09784406f, 0.04193264f, 
    0.04773548f, -0.08983232f, 0.02039705f, -0.23061396f, -0.71751213f, -0.68400037f, 0.05019874f, -0.31773955f, 
    0.11816084f, -0.01495789f, 0.13687479f, -0.12722260f, 0.16682296f, 0.23186737f, 0.02555437f, 0.24217218f, 
    -0.24678753f, 0.06654109f, 0.16361290f, -0.04193285f, 0.12190662f, 0.08721494f, 0.03491073f, -0.06779410f, 
    -0.06062743f, -0.17869449f, -0.09547874f, 0.00398068f, -0.38287818f, -0.21929243f, 0.30110964f, 0.18164462f, 
    -0.03735512f, 0.08063176f, -0.00495965f, -0.03849512f, 0.13065401f, 0.16320379f, -0.01821282f, 0.12905778f, 
    -0.80371815f, -0.56160957f, -0.17472118f, -0.39825571f, 0.15275845f, 0.00947028f, -0.12273186f, -0.17232862f, 
    -0.01036631f, -0.12136456f, 0.12581854f, -0.06150354f, -0.34948492f, -0.38642636f, -0.25366580f, -0.00658549f, 
    0.04981300f, 0.04520654f, 0.05811671f, -0.14656952f, 0.15035333f, -0.10523123f, -0.17847024f, 0.02293911f, 
    0.33192340f, 0.20772746f, -0.11737623f, 0.14788392f, -0.21455878f, -0.07817868f, 0.09700029f, 0.00843735f, 
    0.08565499f, 0.06959512f, 0.03996843f, -0.08739378f, 0.22998844f, 0.11641459f, 0.07234623f, -0.08271015f, 
    -0.02017642f, 0.02015541f, 0.04306578f, -0.20305867f, -0.11260555f, 0.16650048f, -0.04156210f, -0.12878221f, 
    0.20547220f, 0.12560688f, 0.06916252f, -0.04251837f, -0.00660142f, -0.14187020f, -0.11718491f, -0.05130281f, 
    -0.14399765f, -0.06765451f, -0.09420058f, 0.02092509f, -0.17085487f, -0.02650037f, -0.26848757f, -0.07967938f, 
    0.05963989f, -0.02288579f, -0.18278132f, -0.03497090f, 0.02956573f, -0.00473534f, 0.03963582f, 0.13448232f, 
    -0.38504109f, -0.12495276f, -0.28447366f, -0.35286662f, 0.13150609f, -0.12387958f, -0.09890894f, -0.00580918f, 
    -0.04620130f, -0.03709080f, 0.18797009f, 0.13665584f, -0.65623641f, 0.16690275f, -0.09008516f, -0.35127336f, 
    0.07218996f, 0.17611869f, -0.12597740f, 0.05858267f, 0.14669247f, 0.09817685f, -0.05470297f, 0.11839637f, 
    0.28919795f, 0.11879012f, 0.08615902f, 0.03492906f, -0.06004422f, 0.00528381f, 0.14883128f, 0.08881076f, 
    0.07596663f, -0.05032771f, -0.06160544f, -0.01397293f, -0.33972460f, -0.25506505f, -0.24013104f, -0.03361075f, 
    0.06940501f, 0.11078320f, 0.10445968f, 0.12327413f, 0.13875140f, -0.00433512f, -0.02911029f, 0.18661079f, 
    -0.56120139f, 0.18801747f, 0.21781257f, 0.29931441f, 0.20100397f, 0.05673075f, 0.00035959f, -0.06894629f, 
    0.00260235f, -0.04611611f, -0.20747839f, 0.10232169f, -0.20220599f, 0.08754376f, 0.04000434f, 0.02899562f, 
    0.11186489f, 0.08210088f, 0.14646523f, 0.01650679f, 0.10619143f, 0.14510193f, 0.19363290f, 0.17516842f, 
    -0.15289636f, -0.15549546f, -0.15850416f, -0.12045075f, 0.16681531f, 0.03489329f, -0.00273433f, 0.15125673f, 
    0.05904612f, 0.16511787f, 0.12565516f, 0.03005729f, 0.01761650f, 0.06776747f, 0.04773998f, 0.03299627f, 
    0.04134340f, 0.13618903f, -0.01238502f, -0.00286599f, 0.12788856f, -0.03075379f, -0.02022432f, -0.05089885f, 
    -0.18354362f, 0.04131127f, -0.25934747f, 0.09978309f, -0.12023566f, -0.03507257f, -0.00256056f, -0.01262413f, 
    0.02182548f, 0.15246657f, 0.03199263f, -0.06281282f, -0.12085489f, -0.14035563f, -0.00670144f, -0.07810665f, 
    0.15660298f, 0.10148382f, -0.18216485f, 0.04423000f, -0.04668894f, 0.14223303f, 0.07935555f, 0.02366295f, 
    0.37218577f, 0.03542310f, 0.06392952f, -0.02920931f, -0.20739447f, -0.15177521f, 0.04586905f, 0.19137911f, 
    0.05798794f, 0.07387636f, -0.02673746f, 0.07706811f, 0.13160254f, 0.14246109f, -0.04372626f, -0.05831664f, 
    -0.26823995f, 0.03133723f, -0.21438059f, 0.05828746f, 0.16330901f, -0.02049888f, -0.08692126f, -0.03354927f, 
    -0.29902661f, -0.27798647f, 0.12606278f, 0.02462867f, -0.07677171f, 0.00697580f, 0.00059502f, -0.05104837f, 
    -0.09518728f, -0.33187217f, 0.09689369f, -0.11370333f, -0.20544723f, -0.15853816f, 0.10133196f, 0.10645436f, 
    0.04112300f, 0.01934071f, 0.03438833f, 0.00661000f, 0.02196172f, -0.11151101f, -0.09474913f, -0.07274891f, 
    0.11072018f, -0.27779138f, -0.04716301f, 0.24089535f, -0.02089120f, 0.00557730f, 0.10965132f, 0.08618303f, 
    0.01291847f, -0.21286672f, -0.12633836f, -0.05141058f, 0.65492719f, 0.05167928f, -0.37521043f, 0.00094410f, 
    0.06859250f, 0.01952727f, -0.13792802f, -0.01403393f, 0.07548736f, 0.00721409f, 0.26632380f, -0.12699495f, 
    0.11343007f, -0.35890272f, -0.07974656f, 0.06727375f, -0.14873441f, 0.06873771f, -0.13568708f, 0.11033134f, 
    -0.06954475f, -0.11539190f, -0.13897964f, -0.03812991f, 0.22886398f, 0.29485211f, -0.22168195f, -0.35005456f, 
    0.19617961f, 0.00791074f, -0.09764774f, 0.09098988f, 0.12813444f, -0.02164440f, 0.07886426f, 0.02730381f, 
    0.43649530f, -0.27483723f, -0.15783112f, -0.00694318f, 0.09162828f, 0.02101457f, -0.00759359f, 0.13455005f, 
    -0.05048373f, 0.06813793f, -0.15498482f, 0.04557122f, 0.13885701f, -0.24848823f, 0.03442596f, -0.27928823f, 
    -0.03750609f, 0.04260232f, 0.06968291f, -0.05545468f, -0.04677033f, -0.00991435f, -0.05368140f, -0.00198010f, 
    -0.21540520f, -0.15297639f, -0.04392538f, -0.15316306f, 0.03105689f, 0.15729418f, -0.08567464f, 0.14935623f, 
    0.02961149f, -0.07112232f, 0.09176478f, 0.05155789f, -0.16776790f, 0.03329571f, -0.30559650f, -0.23138453f, 
    0.16369233f, -0.05554699f, 0.08974510f, -0.02931970f, 0.01508689f, 0.02783709f, -0.00494835f, 0.10292773f, 
    -0.11753923f, 0.11767533f, -0.07998127f, -0.00910435f, 0.10040759f, -0.15011057f, -0.06082455f, -0.05626240f, 
    0.13555269f, -0.03186309f, 0.02616770f, -0.02699794f, 0.01316433f, -0.23399433f, 0.12522496f, -0.20361488f, 
    0.20834111f, 0.01317032f, -0.19045144f, -0.00652628f, 0.04755386f, -0.03679623f, -0.07734393f, 0.13796151f, 
    -0.37324145f, 0.28268072f, -0.15443060f, -0.03337720f, 0.32973120f, -0.05650761f, 0.09153000f, 0.02466382f, 
    0.03489214f, 0.29581946f, 0.07279324f, 0.05335578f, 0.23793821f, 0.24835819f, -0.16979541f, 0.13283695f, 
    -0.01105633f, -0.09954364f, 0.09262814f, -0.00926129f, -0.08884879f, 0.09850872f, 0.03415668f, 0.04803225f, 
    0.10868356f, -0.16941702f, -0.05781739f, -0.23259912f, -0.04294812f, 0.05542224f, -0.13353734f, -0.08875655f, 
    -0.08577827f, 0.02392566f, 0.06253379f, -0.01219101f, -0.13122153f, -0.52043265f, -0.06151237f, 0.01699667f, 
    0.07294427f, 0.01876924f, 0.08155563f, 0.07514298f, 0.06786491f, 0.04946587f, 0.15766206f, -0.02491508f, 
    -0.13325562f, -0.22413456f, -0.01713183f, 0.21523964f, 0.03585429f, 0.06571249f, -0.11751860f, 0.08902203f, 
    0.02666225f, -0.02723110f, 0.07912908f, 0.02799947f, 0.36544836f, -0.11950856f, -0.05826162f, 0.10944457f, 
    -0.11845814f, 0.09176398f, -0.07567037f, -0.15879215f, -0.00170051f, -0.06012508f, -0.07076315f, -0.01264898f, 
    -0.02348667f, 0.17239352f, -0.09444344f, -0.07542588f, -0.24129219f, 0.15629634f, 0.07512257f, -0.08410452f, 
    0.05718870f, 0.12379110f, -0.00526632f, -0.14563698f, -0.41202638f, -0.41581917f, -0.14459334f, -0.17750275f, 
    0.01869450f, -0.15653601f, -0.02713667f, -0.02247354f, 0.01380969f, -0.01138511f, -0.05270572f, -0.03500359f, 
    0.39464724f, -0.41142568f, -0.16972052f, -0.06597802f, 0.02748730f, -0.01947574f, 0.09206528f, -0.01692771f, 
    -0.00872516f, -0.03574218f, -0.13147807f, -0.10284151f, -0.53104132f, 0.02659048f, 0.20473891f, 0.37108329f, 
    -0.08199693f, 0.05600363f, -0.07450621f, 0.13383612f, -0.16487759f, -0.04201694f, 0.08776937f, -0.12382969f, 
    0.01892371f, 0.01652784f, 0.21156272f, -0.20806132f, 0.03287461f, -0.06659266f, -0.14922857f, -0.09681375f, 
    -0.06066730f, -0.05963749f, 0.14121956f, 0.17910330f, -0.76173723f, 0.22487299f, -0.17962959f, 0.21280454f, 
    0.21604861f, 0.03888597f, 0.04108338f, 0.04701040f, 0.24193457f, -0.03665493f, 0.03361673f, 0.00263543f, 
    0.49531123f, 0.05658492f, 0.06514826f, -0.18683441f, -0.05290863f, -0.11164562f, -0.10376115f, 0.08605891f, 
    0.06044790f, 0.07940907f, 0.19213569f, 0.00188820f, 0.28500438f, 0.16862442f, 0.14066073f, 0.05300060f, 
    -0.06818179f, -0.02408576f, -0.03513882f, 0.07831734f, -0.16362861f, 0.05415670f, 0.10959756f, -0.09424333f, 
    0.35215968f, -0.44302356f, -0.21107486f, 0.16386561f, 0.15766266f, -0.08563729f, -0.12856428f, -0.12797259f, 
    0.18184605f, 0.02344226f, -0.02624379f, 0.11980285f, 0.06420870f, -0.12228693f, -0.16183835f, 0.12497541f, 
    -0.27243608f, 0.01540600f, 0.00749418f, -0.15910089f, -0.10250701f, 0.07500716f, -0.03982874f, 0.00646737f, 
    -0.28723389f, -0.13521208f, 0.06562217f, 0.04315057f, -0.08731286f, 0.21916214f, -0.20766261f, -0.02135731f, 
    -0.04238977f, 0.05730800f, 0.11343837f, 0.06825011f, 0.44703129f, 0.06981574f, -0.21183726f, -0.06566535f, 
    0.16186927f, -0.10534234f, -0.01667002f, 0.19168423f, 0.00236648f, 0.01649534f, -0.11495951f, 0.01403205f, 
    -0.18440625f, 0.05473172f, 0.02452067f, 0.12208679f, -0.00460742f, 0.05530480f, -0.18241458f, -0.05113646f, 
    -0.10947977f, 0.04140002f, -0.03366094f, -0.14440081f, -0.26581019f, 0.09958915f, -0.06159970f, 0.04601225f, 
    -0.21914825f, -0.00805847f, 0.10224681f, 0.06567277f, 0.03261080f, -0.04975074f, -0.13599443f, -0.21578830f, 
    -0.21284974f, 0.19473982f, -0.09677429f, -0.01339590f, -0.00525849f, 0.19087207f, -0.01952635f, -0.18175457f, 
    0.06151446f, 0.07180617f, 0.05050656f, 0.00145462f, 0.20196801f, -0.15210350f, -0.16121244f, 0.08247555f, 
    -0.15589830f, -0.16738498f, -0.21430449f, -0.12919885f, -0.07059096f, 0.13679591f, -0.01719478f, -0.01632928f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13530980f, 0.04136165f, -0.03795640f, -0.00840780f, -0.04121941f, -0.01841025f, -0.01342602f, -0.05533773f, 
    -0.00871637f, 0.01940582f, 0.15199156f, 0.05700284f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
