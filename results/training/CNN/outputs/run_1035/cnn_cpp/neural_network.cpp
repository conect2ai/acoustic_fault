#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.70583904f, -0.32688692f, -0.19337043f, -0.22524028f, 0.26355925f, -0.25641975f, -0.21001139f, -0.54480422f, 
    0.08570004f, 0.27013600f, -0.12505691f, -0.07054475f, 0.01654810f, -0.42428556f, 0.11834443f, 0.18785615f, 
    0.17623773f, -0.10106236f, -0.16616574f, 0.01788851f, 0.17202729f, -0.07374519f, -0.21635102f, -0.27995533f, 
    -0.32087252f, -0.68486208f, -0.35002565f, 0.20752369f, 0.51741314f, -0.05850351f, -0.52324444f, -0.48549014f, 
    -0.05406535f, 0.77157938f, 0.24203275f, -0.33920908f, -0.09495822f, 0.32585946f, 0.09453014f, 0.13564114f, 
    0.13397333f, 0.25314164f, -0.07480423f, -0.39327633f, -0.27656999f, -0.13213111f, -0.00122432f, -0.01587586f, 
    -0.05211719f, 0.22092909f, -0.65007281f, -0.57745165f, -0.03783368f, 0.04703737f, 0.02162371f, -0.12074405f, 
    -0.26974562f, -0.67833990f, -0.64231777f, -0.36191434f, 0.01786314f, -0.01492795f, -0.05527015f, -0.38527066f, 
    -0.43074015f, -0.21100146f, 0.04631501f, -0.10854407f, 0.05941875f, 0.02636948f, -0.16658543f, -0.15145460f, 
    -0.10057765f, 0.15020740f, -0.29602608f, 0.53261411f, 0.61381775f, -0.41974533f, -0.53453225f, 0.14463721f, 
    -0.30595568f, 0.07953561f, -0.27480045f, -0.29541534f, -0.11555966f, 0.01205379f, 0.09940907f, 0.12734944f, 
    -0.05631828f, 0.00038322f, -0.20244518f, 0.10201213f, -0.22843510f, -0.32210991f, -0.15554675f, 0.10990603f, 
    -0.20185137f, -0.39190128f, -0.32616946f, -0.29087383f, 0.42164189f, -0.02800622f, 0.02572214f, -0.16981718f, 
    0.11330319f, -0.10821065f, 0.10772148f, -0.17207700f, -0.02092653f, 0.41623166f, -0.02431326f, 0.38731682f, 
    -0.12070612f, -0.36987320f, 0.00582062f, 0.10396226f, -0.23590605f, 0.06029385f, 0.15896928f, -0.10534580f, 
    -0.01039589f, 0.11639959f, 0.25410143f, -0.27112973f, -0.19909917f, -0.96311158f, 0.63935739f, 0.45510495f, 
    -0.63994420f, 0.27063084f, -0.23966096f, -0.04894394f, 0.37191153f, -0.06146626f, 0.08805756f, -0.02681862f, 
    -0.30563003f, -0.21960762f, -0.36170030f, 0.15189877f, 0.29555362f, -0.02037410f, -0.05266320f, -0.14565386f, 
    -0.12353964f, -0.07806937f, -0.19361690f, -0.11723617f, -0.15597838f, -0.59477657f, 0.05260607f, -0.03152904f, 
    -0.10635645f, -0.19535275f, 0.53070301f, 0.23849370f, -0.06722127f, -0.45539817f, -0.48315337f, 0.46358100f, 
    -0.27565882f, 0.21462502f, 0.20724249f, -0.40483624f, -0.18094639f, 0.19269763f, 0.19249824f, 0.01350975f, 
    -0.07421366f, -0.01548635f, -0.23749395f, -0.19666393f, 0.05633266f, 0.27334753f, 0.15655473f, -0.13777731f, 
    0.75977129f, 0.52458739f, -0.53893435f, -0.02462093f, -0.55058789f, -0.32084018f, 0.35572878f, 0.05363424f, 
    -0.06231229f, -0.16498488f, 0.15699536f, 0.18564002f, 0.24986701f, -0.44121286f, 0.22344312f, 0.11746119f, 
    0.05195852f, 0.13934661f, -0.36958817f, 0.08077992f, 0.04114369f, -0.37009743f, 0.19500478f, -0.01933079f, 
    -0.79783738f, -0.53126007f, -0.54184288f, 0.02018235f, 0.48064184f, 0.00509585f, -0.04207352f, -0.12826261f, 
    0.00478385f, 0.22996721f, 0.35303566f, 0.04985117f, 0.04933349f, 0.16782156f, 0.37557653f, -0.00034596f, 
    -0.00163277f, -0.17863445f, 0.03413528f, -0.15584795f, -0.19872397f, -0.07062823f, 0.03842398f, 0.27715760f, 
    -0.04128821f, -0.62558126f, -0.24585766f, -0.24653938f, -0.38683236f, 0.43529531f, 0.14355063f, -0.24604420f, 
    -0.41885009f, -0.10617834f, 0.62095785f, 0.14747413f, -0.10464513f, -0.07379135f, 0.04037223f, -0.42062649f, 
    -0.18177183f, 0.07968564f, -0.35695562f, -0.08082492f, -0.46878138f, -0.23579094f, -0.28347802f, -0.15828849f, 
    -0.11926904f, -0.35106862f, -0.14765215f, 0.26924735f, 0.04924390f, -0.08364736f, -0.09662876f, 0.09375745f, 
    0.38225111f, 0.27872482f, -0.12726721f, -0.08003473f, -0.38361263f, -0.04641246f, -0.05888224f, -0.33652326f, 
    -0.01774999f, 0.24485625f, -0.21874872f, 0.10136875f, -0.25920030f, -0.19452673f, 0.11678036f, 0.27396563f, 
    0.22800896f, -0.11058787f, 0.29764760f, 0.02055868f, 0.45192328f, 0.21975131f, -0.48153242f, -0.63124454f, 
    0.02395414f, -0.32859781f, -0.02413335f, -0.17156635f, -0.24513683f, 0.27542350f, 0.32301939f, 0.02544614f, 
    0.15802519f, 0.33139449f, -0.16785908f, 0.21767692f, -0.02127840f, -0.13430989f, -0.14381503f, -0.05445578f, 
    0.26819220f, 0.03861947f, -0.32251722f, -0.31749955f, 0.52053207f, 0.50466627f, 0.07519569f, -0.23190567f, 
    -0.15898284f, -0.23405819f, 0.41896132f, 0.19769971f, -0.38817590f, -0.50742507f, -0.19118550f, 0.27438268f, 
    0.07124919f, -0.01562569f, -0.12318441f, -0.08655859f, -0.21869172f, 0.21236606f, 0.03494472f, -0.01130624f, 
    0.23053943f, -0.11307750f, -0.01153597f, 0.03909526f, -0.40133354f, -0.98343146f, -0.42613593f, -0.16668446f, 
    -0.67265236f, -0.58173496f, 0.56621945f, 0.41421714f, 0.10219941f, 0.11416689f, 0.66866791f, 0.02344518f, 
    0.27429864f, -0.02382659f, -0.13097502f, 0.19636221f, -0.33147115f, -0.25245926f, -0.23668835f, -0.02078799f, 
    -0.06037601f, 0.22515339f, 0.03043265f, 0.08567058f, 0.02883390f, 0.27786088f, 0.21974789f, -0.04105165f, 
    -0.49998039f, -0.25156856f, 0.44122514f, 0.01952470f, -0.07589847f, -0.00219717f, 0.02946866f, -0.34361711f, 
    -0.25028899f, 0.28496924f, 0.21495043f, -0.13201268f, -0.08863159f, -0.35907936f, -0.03277863f, 0.19595370f, 
    -0.29970655f, 0.26151606f, 0.08290014f, -0.00377012f, 0.02861008f, 0.02663907f, 0.30023837f, -0.05601327f, 
    -0.02366229f, -0.08089423f, -0.19057961f, -0.18554726f, 0.01801818f, 0.04337973f, 0.42505383f, -0.31090975f, 
    -0.35566777f, 0.44007865f, -0.14980468f, 0.58280063f, -0.41322681f, -0.28476673f, 0.05640024f, -0.15349787f, 
    -0.24096180f, -0.09297060f, -0.20014498f, 0.08548591f, -0.01482426f, -0.09613290f, 0.23965220f, 0.39658380f, 
    -0.71302450f, 0.04639668f, 0.54987121f, -0.66994518f, -0.22328375f, -0.06117647f, 0.27766430f, -0.31157419f, 
    0.95449126f, -0.40861958f, 0.26364788f, -0.22125861f, 0.04250014f, -0.33358812f, -0.15603679f, 0.00722431f, 
    -0.04136794f, 0.16044372f, 0.21101895f, 0.02456167f, -0.02466409f, 0.13624750f, -0.02992737f, -0.11968786f, 
    0.08514407f, 0.42260435f, 0.43670282f, 0.08264288f, 0.00822996f, -0.05750031f, 0.01440052f, 0.00185679f, 
    0.21656565f, -0.41804302f, -0.54462653f, -0.48938453f, -0.12820110f, -0.10407031f, -0.09876125f, 0.12347481f, 
    0.18709679f, 0.25435171f, 0.39828962f, -0.19110581f, 0.17112581f, -0.15603925f, -0.20511682f, -0.40044984f, 
    0.01615603f, 0.09435970f, -0.57930833f, -0.14524043f, 0.28177735f, 0.29611188f, 0.04250737f, 0.19895042f, 
    0.11281375f, 0.03803338f, 0.13047796f, -0.26220372f, -0.27585596f, 0.10475076f, -0.29587162f, 0.51363140f, 
    -0.19347513f, -0.09637064f, 0.03304284f, 0.00089300f, -0.01086679f, 0.21637203f, 0.16387050f, -0.16459909f, 
    -0.21741775f, 0.24773708f, 0.19900174f, 0.19769982f, 0.54728758f, -0.32125163f, -0.40044895f, -0.27740735f, 
    -0.33563969f, -0.19207098f, 0.84392273f, -0.35525441f, 0.22525533f, -0.18630008f, -0.03465266f, -0.08657357f, 
    0.10801018f, 0.24721038f, 0.20331863f, -0.09284006f, -0.47316095f, 0.24310024f, 0.02238832f, 0.07010881f, 
    -0.00786265f, 0.02258971f, 0.11053728f, -0.05523572f, -0.44540983f, -0.46675023f, -0.38157973f, -0.19477557f, 
    -0.10623027f, -0.51051968f, -0.45471770f, -0.34765577f, -0.36512280f, -0.17723395f, 0.21851297f, -0.07136923f, 
    0.12854232f, -0.28099597f, -0.23779562f, 0.08423921f, 0.10581157f, 0.10599028f, 0.12150200f, 0.19578888f, 
    0.06872237f, 0.25093502f, -0.15522699f, 0.00592163f, 0.44802648f, -0.31636336f, -0.56286275f, -0.09096491f, 
    0.27196494f, 0.27402192f, -0.08469941f, -0.13350016f, 0.12377463f, 0.33120739f, 0.43123841f, 0.20645344f, 
    0.17613053f, -0.12665232f, 0.43148845f, -0.34875306f, -0.47293702f, -0.01112813f, -0.16608068f, 0.27002519f, 
    0.07685379f, 0.49926716f, -0.42585149f, -0.17723662f, 0.34642977f, -0.12626059f, 0.60265243f, 0.00624510f, 
    -0.18369365f, 0.22300042f, -0.42473295f, 0.35179526f, 0.41526625f, -0.03043541f, -0.49849114f, -0.13377739f, 
    0.31610277f, 0.12550947f, -0.14765492f, -0.27610743f, 0.18173507f, 0.00267139f, -0.31185916f, -0.04357997f, 
    -0.14549713f, 0.29084653f, -0.05104784f, -0.13309920f, -0.06151282f, 0.24587087f, -0.09943808f, 0.16943176f, 
    -0.60740566f, -0.66017962f, -0.77205211f, -0.80785114f, 0.28007737f, 0.26140252f, 0.45632038f, 0.31632522f, 
    0.14370334f, -0.00241147f, -0.18773599f, -0.21360016f, -0.30432349f, -0.17788427f, 0.19589777f, -0.05023053f, 
    0.07626043f, -0.09671207f, -0.14577644f, -0.37625632f, -0.20756997f, -0.17617390f, -0.08953883f, -0.27023166f, 
    0.80362761f, -1.04494095f, -0.15615393f, 0.33819157f, 0.60857975f, -0.16002034f, 0.03903211f, -0.31320792f, 
    -0.58142132f, -0.57717627f, 0.20002742f, -0.29523918f, 0.38904145f, -0.38717359f, -0.14960271f, 0.16786933f, 
    0.15639533f, -0.23165286f, 0.18442683f, 0.03463405f, 0.05418454f, -0.05506949f, -0.03195946f, 0.09409472f, 
    -0.13313343f, -0.15441874f, -0.22692128f, 0.08812243f, 0.66076821f, 0.32014087f, -0.41759834f, -0.15830635f, 
    -0.51469147f, -0.06872732f, 0.32552344f, -0.44460180f, 0.33929047f, -0.26347080f, 0.29803640f, -0.29566148f, 
    0.06362914f, 0.27367708f, -0.05300482f, -0.11502766f, 0.07828723f, -0.05757553f, 0.11727604f, -0.18938939f, 
    -0.13694175f, 0.25683683f, -0.36172011f, -0.19456832f, -0.24613562f, 0.27386391f, -0.14447740f, 0.04471720f, 
    -0.59679550f, -0.84343404f, -0.07930507f, -0.44351217f, 0.48449498f, 0.45579371f, -0.10454146f, 0.16825181f, 
    -0.16356611f, -0.48904282f, -0.19926021f, 0.30177927f, -0.29640293f, -0.40939727f, -0.16426267f, -0.02662988f, 
    -0.08285961f, 0.32194063f, -0.15831631f, -0.05669937f, -0.19763201f, 0.07963917f, 0.33161855f, 0.55160427f, 
    0.38914603f, 0.41025910f, 0.08732931f, -0.34976414f, -0.63769305f, -0.15900302f, -0.19787695f, 0.11537930f, 
    0.01536615f, -0.03651476f, -0.11776624f, -0.15042295f, -0.15139709f, -0.13417757f, -0.24355753f, -0.00494359f, 
    -0.00923126f, 0.23274314f, -0.03656767f, 0.11875241f, 0.68545246f, 0.01619181f, -0.37701368f, 0.14957264f, 
    -0.14650699f, 0.31682786f, 0.24991736f, -0.02332252f, -0.08893362f, -0.35170904f, -0.40487066f, 0.34008348f, 
    -0.00021836f, -0.06875323f, -0.06652525f, -0.19674502f, -0.02102128f, -0.06308053f, -0.07217191f, -0.07136914f, 
    0.32917973f, 0.06977396f, 0.11110064f, -0.08566477f, -0.03033261f, 0.49788859f, 0.47624579f, 0.48121944f, 
    0.23700449f, 0.29438743f, -0.06451541f, -0.15356693f, 0.11920814f, -0.14418817f, -0.23777184f, 0.11793709f, 
    0.07725466f, -0.06224355f, 0.05963263f, -0.05321250f, -0.12468985f, -0.21552847f, 0.19204418f, 0.16004606f, 
    -0.06924988f, -0.04453504f, 0.07863539f, -0.15776658f, 0.07626010f, -0.10917267f, 0.17292997f, 0.22882874f, 
    -0.13271526f, -0.34295687f, 0.10707924f, -0.00641785f, -0.06720483f, 0.05117773f, 0.55243647f, -0.28164020f, 
    0.34331447f, -0.37162989f, 0.04039590f, -0.17590547f, 0.21552928f, 0.13411367f, 0.02326943f, 0.06874555f, 
    -0.18675168f, 0.30206174f, 0.09775398f, 0.14024220f, -0.19965672f, -0.28693646f, 0.34475255f, -0.49798021f, 
    -0.03369459f, -0.09678810f, -0.31650206f, 0.47302154f, -0.11437466f, -0.17153458f, 0.14712411f, 0.31966072f, 
    0.37595105f, -0.35911632f, 0.12022364f, 0.06407302f, 0.17042261f, -0.22393382f, 0.10260572f, -0.12594640f, 
    -0.17884527f, 0.14682667f, -0.22374684f, 0.07106625f, 0.47369102f, 0.18577383f, 0.10804392f, -0.29008129f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.21638571f, 0.28860086f, -0.21949732f, -0.14477710f, 0.22843944f, 0.19974452f, 0.07745057f, 0.26532793f, 
    0.00985046f, 0.04614516f, -0.12565872f, -0.02896481f, 0.19306426f, 0.25200811f, 0.17425384f, 0.25300530f, 
    0.00697425f, -0.08024567f, 0.06939193f, 0.31764692f, 0.18179186f, 0.13113332f, 0.20850518f, 0.18539974f, 
    -0.04699047f, 0.06982786f, 0.08831082f, 0.13687786f, 0.10668102f, -0.19805978f, 0.00703957f, 0.21469820f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.16246150f, -0.00097905f, 0.04375987f, 0.09752470f, -0.12133495f, -0.03646776f, -0.04746151f, -0.09932380f, 
    0.08594031f, 0.00362537f, 0.14547104f, 0.06989862f, -0.33206776f, -0.19631603f, -0.19200626f, 0.01385962f, 
    0.08791129f, 0.05600153f, 0.02271369f, 0.07332881f, 0.00485078f, 0.02573377f, 0.11201009f, 0.20313032f, 
    0.19317363f, -0.01276329f, 0.18737222f, 0.06317195f, -0.13245320f, -0.00551573f, 0.00484557f, -0.17160468f, 
    -0.01660120f, -0.01637074f, -0.01063824f, 0.08434173f, 0.26125899f, -0.11829986f, -0.15874429f, -0.16734789f, 
    0.10355809f, 0.02196871f, -0.00116056f, 0.17017621f, 0.06640513f, 0.08604073f, 0.12208322f, 0.06648308f, 
    0.24524581f, 0.02359388f, -0.08444324f, 0.12328359f, 0.04774644f, 0.00422926f, -0.02627173f, 0.01621894f, 
    -0.01900288f, 0.06009816f, 0.09016749f, -0.06205574f, -0.28621510f, -0.03015888f, -0.06299735f, -0.02267738f, 
    0.09473222f, -0.04671197f, 0.03583502f, 0.17438272f, 0.11635936f, -0.01161631f, 0.23779267f, 0.00401299f, 
    0.07345088f, -0.03410804f, -0.01469941f, 0.02960972f, -0.05763930f, 0.07803678f, -0.13832361f, 0.21141948f, 
    0.00926067f, -0.00526797f, -0.10572087f, 0.00214947f, 0.25762555f, -0.21101104f, 0.15425183f, -0.20612168f, 
    0.14275649f, 0.13241254f, 0.08435829f, 0.05093023f, 0.00191629f, 0.05828530f, 0.00601660f, -0.00462699f, 
    -0.41211894f, 0.07841537f, -0.01448684f, 0.14135864f, -0.05581126f, -0.09131961f, 0.04898936f, 0.18890607f, 
    0.12489673f, 0.00557051f, 0.02646547f, 0.00248542f, -0.08093075f, 0.05950338f, -0.07180130f, 0.08996460f, 
    -0.04521513f, -0.09119944f, -0.02412534f, 0.09836388f, 0.06998965f, 0.07038942f, -0.05298997f, 0.00476101f, 
    -0.03033138f, -0.03030308f, -0.02562512f, -0.02721675f, -0.06514753f, -0.00159950f, -0.00258140f, 0.07230202f, 
    0.01614370f, -0.04722642f, -0.08256353f, -0.16880411f, 0.04233347f, -0.07841060f, 0.11934751f, -0.14980355f, 
    0.00804183f, 0.17155589f, -0.08530699f, -0.09074131f, 0.10414045f, 0.02084521f, 0.10746718f, 0.04450138f, 
    0.39070708f, -0.00185103f, -0.21191521f, -0.09696002f, 0.17198768f, 0.07948098f, -0.01392795f, -0.17090283f, 
    -0.00937873f, 0.04112348f, 0.00919061f, 0.04330790f, -0.25040612f, 0.32135966f, 0.06153673f, 0.06523030f, 
    -0.06022749f, -0.10019642f, -0.01966603f, 0.07004555f, -0.03002388f, 0.08882532f, -0.02030812f, 0.04639419f, 
    0.00528984f, 0.00968231f, -0.10896509f, 0.01874688f, 0.04107413f, 0.18459480f, -0.00613761f, 0.05784450f, 
    -0.02879182f, 0.02587313f, -0.11054666f, -0.02627642f, 0.07099876f, 0.01181967f, 0.14200208f, -0.18159524f, 
    -0.02103937f, -0.04911780f, 0.01352961f, -0.10199696f, -0.03991811f, 0.09132484f, -0.08443819f, -0.07746454f, 
    -0.33646965f, -0.23253147f, 0.21779574f, 0.13704538f, -0.08542945f, -0.09480181f, 0.01046232f, -0.26107424f, 
    -0.05169197f, 0.10342035f, 0.07795759f, -0.01244089f, 0.20430940f, 0.11210794f, -0.12249452f, -0.26577893f, 
    0.16728427f, -0.00705445f, -0.08717877f, -0.01367482f, 0.10232063f, 0.06431838f, 0.00666906f, 0.06231887f, 
    -0.00835017f, -0.19102232f, 0.11796861f, 0.08878528f, 0.09129818f, 0.01302660f, 0.03234651f, -0.05129438f, 
    -0.02035779f, -0.06227924f, -0.06190985f, 0.03731162f, 0.22685033f, -0.18749119f, 0.17414907f, -0.13128586f, 
    -0.07548779f, 0.16995971f, -0.07922869f, 0.09789980f, 0.09169693f, -0.01327885f, 0.05417882f, -0.00866799f, 
    0.01493235f, 0.10702682f, 0.25985736f, 0.17864461f, -0.18221942f, -0.05610874f, -0.11741398f, -0.26945534f, 
    -0.04260132f, -0.01784190f, -0.11409871f, -0.03442861f, -0.11983534f, -0.00287842f, 0.08226705f, 0.24002329f, 
    -0.02436337f, -0.00857414f, 0.05817509f, -0.02970289f, 0.12679777f, 0.02465991f, -0.02433713f, 0.15281188f, 
    0.23135747f, 0.17851968f, -0.16834970f, -0.03082873f, 0.00869485f, -0.02586903f, 0.10204075f, -0.05423299f, 
    -0.04548232f, 0.08466379f, 0.03565511f, 0.07992321f, -0.04684912f, 0.11292695f, 0.01653917f, -0.03460097f, 
    -0.03135132f, 0.01089712f, -0.06702924f, -0.00518287f, 0.09327212f, 0.05591987f, 0.07686433f, 0.04496617f, 
    0.23858835f, -0.34843826f, 0.27335137f, -0.23194149f, -0.04708926f, 0.03682998f, 0.05346436f, 0.00883291f, 
    -0.02749506f, 0.01458067f, -0.01487198f, 0.03614969f, -0.18480170f, -0.08408890f, -0.05820188f, 0.24452817f, 
    0.04368714f, 0.19163303f, 0.11240718f, 0.03977615f, -0.01205625f, -0.07455575f, -0.04410715f, -0.01029653f, 
    -0.20581342f, -0.02331772f, 0.12514514f, 0.12526537f, -0.10828660f, -0.19021131f, -0.03294626f, -0.16150063f, 
    0.02930195f, 0.03983479f, -0.16484781f, -0.02742657f, 0.00138975f, -0.30850479f, 0.13411894f, 0.07046510f, 
    0.11618174f, -0.00120708f, -0.00613670f, 0.01383131f, -0.01072809f, 0.08386261f, -0.04727136f, -0.00471885f, 
    0.33053258f, -0.00349423f, -0.10585560f, -0.03477070f, 0.06051099f, 0.03525829f, 0.06387121f, -0.00105462f, 
    0.00426765f, -0.04135562f, 0.02184325f, -0.07583208f, 0.31939891f, 0.12894510f, 0.12193048f, 0.15060841f, 
    0.09022034f, 0.06137943f, 0.03371762f, -0.00117294f, -0.03861142f, -0.00440877f, -0.00189482f, 0.05401066f, 
    0.16125794f, -0.04361052f, 0.11787158f, 0.10292344f, -0.00338439f, 0.02655424f, -0.02076371f, -0.02723492f, 
    0.06062512f, -0.02596964f, -0.04515781f, -0.16959450f, -0.21794677f, 0.00482792f, 0.05331490f, 0.03163023f, 
    0.03617439f, 0.10129343f, -0.11627124f, 0.14720239f, -0.00363158f, 0.01258787f, -0.06836254f, -0.18969922f, 
    -0.02740474f, -0.02429822f, 0.20853315f, -0.09504828f, 0.06247877f, -0.02101640f, 0.01582585f, 0.21591781f, 
    -0.05115313f, -0.05835903f, 0.01540294f, -0.05524297f, 0.53678906f, -0.33818176f, 0.16955699f, 0.17170896f, 
    0.24065699f, -0.10414816f, -0.02971329f, 0.03998118f, 0.12833810f, -0.11704420f, -0.02919762f, 0.06676880f, 
    -0.05914812f, 0.12907057f, 0.03728609f, -0.18005970f, 0.07519833f, 0.05418869f, -0.03076985f, -0.04645931f, 
    0.08263512f, 0.02278028f, 0.16325340f, -0.01851307f, -0.06232686f, 0.09780651f, 0.04946538f, -0.02662895f, 
    -0.06841740f, 0.05935231f, 0.10561216f, -0.13129631f, -0.07682487f, -0.07648335f, -0.10581380f, -0.27286988f, 
    -0.12355767f, -0.00600312f, 0.05906076f, -0.01943800f, 0.00851770f, -0.01488132f, 0.01212445f, 0.01579270f, 
    0.06766804f, 0.05778423f, -0.00825220f, 0.18772784f, -0.15047391f, 0.22773504f, 0.05128666f, 0.04341659f, 
    -0.06451516f, 0.00411289f, 0.06597874f, 0.03258674f, 0.02736242f, -0.19248860f, -0.17863685f, -0.24419805f, 
    -0.08288698f, 0.07681599f, 0.30863443f, -0.02070627f, 0.01025906f, 0.01538509f, -0.01099935f, 0.00760676f, 
    0.05335364f, -0.02873097f, 0.14200662f, 0.00219294f, -0.14392534f, 0.24999438f, -0.21973102f, 0.29050437f, 
    0.20598739f, -0.06337327f, -0.10868069f, 0.12096942f, -0.12033871f, 0.16654877f, 0.04997803f, 0.06074980f, 
    0.10877232f, -0.01601655f, -0.01702855f, -0.26375949f, -0.01529493f, -0.02649897f, 0.01025448f, -0.00174038f, 
    0.07898580f, -0.12289411f, -0.16001928f, -0.08965757f, -0.20917068f, -0.01946492f, 0.09246574f, -0.18705340f, 
    0.05207837f, -0.04407509f, 0.09543255f, 0.05345109f, -0.09569892f, -0.07555836f, 0.00813054f, -0.15025488f, 
    -0.11523860f, 0.12730727f, 0.01010375f, 0.05337546f, 0.07904727f, -0.05372651f, -0.02770097f, -0.06153226f, 
    0.04812970f, 0.02075533f, 0.02317124f, 0.21909881f, -0.10230251f, 0.08010264f, -0.08953730f, 0.06591049f, 
    -0.11625541f, -0.00029725f, 0.20996784f, 0.01420160f, -0.10408682f, 0.04992839f, 0.08426388f, -0.14743647f, 
    -0.21251960f, 0.06406280f, -0.16617242f, 0.13795352f, -0.17858206f, 0.13987669f, 0.04400482f, 0.12795039f, 
    0.01400078f, 0.00802416f, -0.00919205f, -0.06258006f, -0.39723644f, -0.38763562f, -0.23060986f, -0.08614156f, 
    0.06702324f, 0.08836635f, 0.06803177f, 0.02120417f, 0.26106274f, 0.03050917f, 0.08992538f, -0.12553701f, 
    -0.01042001f, -0.08618330f, -0.00641965f, -0.11836582f, -0.08270486f, 0.08400884f, -0.00856508f, -0.00560053f, 
    0.02642278f, 0.05083871f, 0.11464290f, 0.03132415f, -0.00022693f, 0.01368073f, -0.04932368f, 0.25302428f, 
    -0.03486459f, 0.07347236f, -0.00654054f, -0.00066840f, 0.02798193f, -0.04522981f, 0.07583763f, 0.10230564f, 
    -0.14098166f, 0.11146088f, 0.04046346f, 0.12754835f, 0.17241907f, -0.07737998f, 0.12718356f, 0.15550056f, 
    -0.07111987f, -0.01355676f, 0.10572466f, 0.07999127f, -0.18323794f, 0.03224944f, -0.06450497f, 0.27470636f, 
    -0.10879087f, -0.00070751f, -0.03886774f, 0.06326307f, -0.15022379f, -0.16618554f, 0.09061579f, -0.05790947f, 
    0.13056792f, 0.08846062f, -0.04715221f, -0.00758094f, 0.04467981f, -0.10477053f, -0.06068325f, 0.00741884f, 
    0.05772351f, 0.09148815f, -0.03818497f, 0.01782670f, -0.08159377f, 0.09877939f, -0.03396651f, 0.04886319f, 
    0.14539726f, -0.06623973f, -0.11462164f, 0.14253597f, 0.00927288f, -0.01328472f, -0.02300426f, -0.05504046f, 
    0.03702607f, -0.05392127f, -0.01701804f, -0.00033484f, 0.19154948f, 0.14744064f, 0.16283409f, 0.29742756f, 
    -0.04272152f, 0.02645890f, 0.05576318f, 0.08940917f, 0.21294503f, -0.13945013f, -0.14062855f, -0.05115717f, 
    0.04272204f, 0.06067060f, 0.09101158f, 0.07519025f, 0.02121058f, 0.04855483f, 0.19405353f, 0.01441054f, 
    -0.24999382f, 0.03205026f, 0.09017077f, 0.03695738f, 0.05467136f, 0.18954003f, -0.06032201f, 0.01883538f, 
    0.09196331f, -0.10083327f, 0.03720750f, 0.07000870f, 0.00542958f, -0.23905315f, -0.14776245f, -0.12847647f, 
    0.06671825f, -0.03003341f, 0.03860460f, 0.21026415f, -0.13492446f, -0.22734158f, 0.04497306f, -0.10474241f, 
    0.25580907f, 0.10452449f, 0.20705554f, -0.09694082f, 0.16790447f, 0.15512009f, -0.09433267f, -0.00229406f, 
    0.00952081f, 0.03363593f, 0.03664083f, -0.02581344f, 0.37548053f, -0.09022822f, 0.29376203f, -0.02874810f, 
    0.06979906f, -0.13861386f, -0.02050024f, -0.10910295f, 0.10904908f, 0.04233394f, 0.01892802f, -0.12095829f, 
    0.22900192f, 0.10216162f, -0.04772483f, -0.09394266f, 0.13305670f, 0.14617139f, 0.12612447f, -0.07228975f, 
    0.04953446f, 0.09257087f, 0.18408372f, -0.02558435f, -0.08345369f, 0.24433008f, -0.19703545f, -0.12659459f, 
    -0.06610608f, -0.01463178f, -0.00848937f, 0.01419364f, 0.04997108f, 0.00537481f, -0.02089588f, 0.09605180f, 
    -0.37750512f, -0.03898338f, 0.07550232f, 0.07859244f, -0.11648923f, 0.02976386f, -0.03144366f, -0.10789815f, 
    0.03204776f, 0.05977262f, 0.09011838f, 0.04447960f, -0.17059447f, 0.08543922f, 0.04193418f, 0.01293834f, 
    0.03677215f, 0.01990722f, 0.02994811f, 0.02225842f, -0.06015014f, 0.01880500f, -0.05604704f, -0.07405902f, 
    -0.09218591f, 0.00557380f, -0.04780370f, -0.04568557f, 0.04882694f, 0.03046766f, 0.14870046f, 0.10610689f, 
    0.02874592f, -0.03733824f, 0.14407599f, 0.34054896f, 0.06970930f, -0.05830918f, 0.04878183f, -0.01740289f, 
    0.09163398f, -0.10538927f, 0.06915315f, -0.17921640f, 0.13527542f, 0.21042386f, 0.10838534f, 0.22905225f, 
    0.16470595f, 0.18562192f, 0.10735786f, -0.07284479f, -0.02747001f, 0.09023444f, 0.05879369f, 0.02836949f, 
    0.00710917f, -0.04468064f, 0.12706348f, 0.10136995f, 0.24017280f, 0.01058136f, 0.31472424f, -0.06129611f, 
    -0.02005386f, -0.08637968f, -0.05204720f, -0.01768344f, 0.10649406f, 0.02497302f, -0.11207254f, -0.04469612f, 
    0.04689473f, 0.17449297f, 0.08046483f, 0.09932139f, 0.14542735f, 0.15851088f, -0.01695787f, 0.00871712f, 
    0.06361628f, 0.04139304f, 0.02511653f, 0.07427895f, 0.08837205f, 0.30081898f, 0.06941684f, 0.27127367f, 
    -0.05546305f, -0.09760078f, 0.00992923f, -0.01689811f, 0.13995633f, 0.09851666f, 0.18245295f, 0.14072683f, 
    -0.32639015f, -0.11393813f, -0.53963208f, -0.07373285f, -0.01387709f, 0.06014172f, 0.13065672f, 0.05654860f, 
    0.09666876f, -0.14265957f, 0.04331557f, 0.12958458f, -0.01295878f, 0.11887010f, -0.07077446f, 0.10492606f, 
    -0.20414194f, 0.14759934f, 0.14665779f, 0.04586546f, 0.14524828f, 0.02129998f, 0.16812688f, 0.21327396f, 
    -0.19679096f, 0.13036969f, -0.08441277f, -0.14347352f, 0.14728777f, 0.04570517f, -0.11049896f, 0.10541646f, 
    -0.20737341f, 0.11616849f, -0.07194084f, 0.01795933f, -0.22932296f, 0.42953363f, -0.63437617f, -0.02426628f, 
    -0.07893194f, 0.15770623f, -0.03306283f, -0.14449355f, -0.09971573f, 0.09617291f, -0.05256141f, -0.19031821f, 
    0.09184202f, 0.57158971f, 0.13128239f, -0.08988495f, -0.00911500f, 0.01691147f, -0.11393847f, -0.02897668f, 
    0.06003559f, -0.12448355f, -0.20324697f, -0.16472137f, -0.22352970f, 0.09456260f, 0.16378382f, -0.05972780f, 
    0.10697938f, -0.02675188f, -0.03483552f, -0.01445006f, 0.19165696f, 0.14991809f, 0.08071334f, 0.20317149f, 
    0.03584665f, 0.07138906f, -0.17258613f, 0.01173204f, 0.20769784f, -0.15661475f, -0.21796279f, 0.13067259f, 
    -0.09968036f, -0.18171789f, 0.04476472f, -0.09887449f, 0.44295564f, 0.33348218f, 0.05681891f, 0.33230081f, 
    -0.02628431f, 0.00380509f, 0.04056668f, 0.07574011f, 0.12818274f, -0.03462978f, 0.08816645f, -0.00656452f, 
    -0.31227082f, -0.05278585f, -0.11051919f, 0.35169354f, 0.12057752f, 0.20565575f, 0.25336203f, 0.04711958f, 
    0.09620662f, -0.06726690f, -0.08410780f, -0.08655218f, -0.13334829f, 0.04108954f, 0.04039107f, 0.06122907f, 
    -0.04382803f, -0.14237322f, 0.06142120f, -0.14827944f, 0.05595350f, -0.04678742f, -0.10280938f, 0.03634198f, 
    -0.15911663f, 0.10526416f, 0.09534103f, -0.21424471f, 0.11714846f, -0.00753245f, -0.18891241f, -0.01656170f, 
    -0.18545975f, -0.26100224f, -0.02165611f, -0.12236574f, -0.03223817f, 0.17542228f, 0.15506952f, 0.18460652f, 
    0.02465801f, -0.10286369f, -0.21276563f, 0.04390965f, -0.16767305f, -0.01046543f, 0.00839243f, -0.10195889f, 
    0.07575375f, -0.10040957f, 0.21696058f, 0.11996534f, 0.05372580f, 0.02124752f, 0.11103413f, 0.01262805f, 
    -0.05889773f, -0.14236327f, 0.10653035f, 0.02041669f, -0.24479097f, -0.03713782f, 0.11385661f, 0.30654773f, 
    -0.09080339f, 0.00117469f, 0.17893448f, 0.28602219f, -0.11252090f, 0.11016512f, 0.17054178f, -0.00272855f, 
    0.25263554f, -0.01727167f, 0.10402551f, -0.03599726f, 0.03662194f, -0.01973221f, 0.00693522f, -0.19318296f, 
    -0.25476381f, -0.01539288f, -0.21352251f, -0.04542272f, 0.25120714f, 0.43002748f, -0.05065035f, -0.17209606f, 
    -0.05787966f, -0.15111643f, 0.04231182f, 0.07842068f, -0.02439480f, 0.06424597f, 0.07696205f, -0.23221724f, 
    0.13395596f, 0.08510242f, 0.14059032f, -0.07814587f, 0.15123831f, 0.00486753f, 0.02112282f, 0.02801191f, 
    -0.05541593f, -0.06957659f, -0.05827031f, -0.03049890f, 0.01364680f, -0.09217265f, 0.36242199f, -0.03807763f, 
    -0.01443891f, 0.19819336f, 0.05697603f, -0.00786055f, -0.04109555f, 0.17366427f, -0.01679879f, -0.05887464f, 
    -0.07964910f, -0.03297013f, -0.10782143f, 0.12850437f, 0.07727754f, 0.09900914f, -0.02226116f, -0.28450316f, 
    0.00269629f, 0.01612597f, 0.03092458f, -0.15857498f, -0.09654714f, -0.21399662f, -0.20701142f, 0.01206319f, 
    0.14190181f, 0.02613617f, 0.09411634f, 0.30778500f, 0.00137327f, -0.00116364f, 0.16502978f, 0.21456057f, 
    0.12390111f, 0.04518990f, 0.37781125f, 0.06517641f, 0.41713697f, -0.00105625f, -0.09668531f, 0.11773715f, 
    -0.02858556f, 0.08401036f, -0.15110566f, 0.04493420f, 0.32181025f, -0.27900410f, 0.22711004f, 0.20359457f, 
    0.09977399f, 0.06178181f, 0.15014006f, 0.13313653f, -0.01955602f, -0.02089698f, 0.02285660f, -0.20836245f, 
    0.13489811f, 0.11011538f, 0.10548545f, 0.07633116f, 0.14913960f, 0.09778374f, -0.04432483f, -0.15446056f, 
    -0.03484324f, 0.04746972f, -0.16205657f, -0.01967508f, -0.02645492f, 0.11449763f, 0.10939419f, 0.09719621f, 
    0.14623538f, 0.01406479f, -0.20371598f, 0.00081601f, -0.18576053f, -0.09422079f, -0.00074358f, 0.06198484f, 
    -0.28607848f, -0.00378971f, 0.32681099f, 0.16068810f, 0.05198336f, 0.03325547f, 0.07311555f, -0.13272418f, 
    -0.08791335f, -0.06252691f, 0.07196541f, -0.12525487f, -0.11452975f, -0.33092374f, -0.20324998f, 0.14365137f, 
    0.40873933f, 0.32988951f, 0.29699504f, -0.16499422f, 0.08254055f, -0.07693866f, -0.12062276f, 0.07362045f, 
    0.04559981f, 0.13899586f, -0.19367494f, -0.12229297f, -0.19409570f, -0.08514757f, -0.04376374f, -0.06320029f, 
    0.02804157f, -0.20646521f, 0.18834227f, -0.08954697f, 0.16437012f, 0.00439125f, 0.07991815f, -0.21099824f, 
    0.14064236f, -0.00765510f, -0.05405057f, -0.09886509f, 0.17088403f, 0.00100102f, -0.05347134f, -0.11544070f, 
    -0.01784677f, -0.03365232f, -0.29036415f, -0.02621537f, -0.12905042f, 0.09559006f, 0.05159001f, -0.03358682f, 
    -0.00484031f, -0.00949448f, 0.09378432f, -0.08917159f, -0.27823618f, 0.13573660f, 0.15295747f, -0.04402988f, 
    -0.01441981f, 0.22239946f, -0.05355044f, 0.06467804f, -0.10198619f, 0.11372335f, 0.19628790f, 0.05203230f, 
    -0.16773993f, -0.41382959f, -0.25897184f, 0.18142040f, -0.07949130f, -0.02100746f, -0.05694824f, -0.10623669f, 
    0.00948058f, -0.01096444f, -0.06274150f, 0.00796860f, 0.08497963f, -0.21050726f, -0.01241135f, 0.08603337f, 
    0.10961326f, -0.04219556f, 0.05785765f, 0.10324293f, 0.02690501f, -0.00944021f, 0.09407306f, 0.10535212f, 
    0.08626204f, 0.18686110f, -0.00937064f, 0.09862593f, -0.00140392f, -0.00313603f, 0.02206875f, 0.03150513f, 
    -0.08552211f, 0.03242853f, 0.17683524f, 0.03098321f, 0.22493781f, -0.10036729f, 0.04406248f, -0.10295104f, 
    0.00881948f, 0.10163621f, 0.08131802f, 0.04243489f, 0.00030957f, -0.02412724f, 0.09097917f, 0.05419315f, 
    -0.09055965f, 0.24599108f, 0.15949084f, -0.01721882f, 0.03644485f, -0.04191352f, -0.05943298f, 0.20145020f, 
    -0.13216738f, 0.09630937f, -0.00687408f, -0.00150000f, 0.31398496f, -0.12130003f, 0.14642161f, -0.38675261f, 
    -0.13100356f, 0.12445533f, 0.18906838f, 0.05136496f, -0.07927983f, 0.11470550f, -0.06936666f, 0.00296472f, 
    -0.22387487f, 0.12147517f, -0.06653355f, -0.00084690f, 0.01274270f, 0.06232600f, -0.08464866f, 0.04870161f, 
    -0.06820234f, 0.19551530f, 0.08971898f, 0.01570203f, -0.02875570f, 0.16730358f, -0.17486548f, -0.15988196f, 
    -0.03110782f, -0.03974106f, -0.12511212f, 0.17055289f, 0.02908741f, 0.08143678f, 0.02849293f, -0.05913771f, 
    0.03460583f, -0.17221463f, 0.02057563f, -0.17750454f, -0.14907053f, -0.06983424f, 0.08217812f, 0.00504266f, 
    0.02555562f, -0.07010704f, 0.01785151f, 0.03253938f, 0.04404068f, -0.23607290f, 0.09819211f, -0.03726570f, 
    -0.00066183f, -0.03905546f, 0.03859687f, -0.10627660f, -0.03562433f, -0.11381873f, 0.06146678f, 0.15555477f, 
    0.20586924f, 0.05816915f, 0.24066502f, -0.05126907f, 0.00423438f, 0.00766039f, -0.00469918f, 0.04056036f, 
    -0.01655508f, 0.05441294f, 0.07789557f, 0.13003820f, 0.22048844f, 0.14694992f, 0.20313439f, -0.07794388f, 
    -0.06479967f, -0.21356912f, 0.08632534f, -0.04945546f, -0.22078085f, 0.06973045f, -0.03898720f, 0.04066290f, 
    -0.14711773f, 0.09888311f, 0.11241761f, 0.09162654f, 0.10594431f, 0.13046615f, 0.03249748f, 0.15603562f, 
    0.01483489f, -0.04448110f, -0.01363843f, -0.11854745f, 0.08397310f, 0.04547540f, 0.43335348f, 0.02249166f, 
    -0.02081236f, -0.09203385f, -0.04266661f, 0.11658779f, 0.00938966f, 0.01071103f, -0.00476095f, 0.08176603f, 
    0.23250620f, 0.25822684f, 0.44666591f, 0.25406876f, -0.11307637f, 0.17833401f, 0.12910286f, -0.34705856f, 
    0.04457145f, -0.02361379f, -0.05253481f, 0.02594096f, 0.10641199f, 0.03281364f, 0.12463371f, -0.18181314f, 
    -0.08351102f, -0.04110435f, 0.12275121f, -0.07375374f, -0.07285375f, 0.06261917f, 0.01501863f, 0.13707247f, 
    -0.01725501f, 0.14610542f, 0.00884730f, 0.01231009f, 0.05387739f, 0.03782116f, -0.00407447f, -0.06456024f, 
    -0.06880665f, 0.09193038f, 0.00942789f, 0.01428847f, 0.47273371f, 0.05556190f, 0.29608837f, -0.05982085f, 
    0.00649536f, 0.09515005f, 0.19015858f, 0.06794675f, 0.07946886f, 0.06502968f, -0.08078146f, 0.12974630f, 
    -0.25789556f, -0.11590751f, -0.03329142f, 0.07472014f, -0.10428175f, -0.02730417f, -0.13566247f, -0.14846434f, 
    -0.02081450f, -0.05465583f, -0.03955579f, -0.05964685f, -0.20065036f, 0.24700466f, 0.01039199f, -0.02748389f, 
    -0.01556250f, 0.10917923f, -0.08555993f, 0.01356501f, 0.07900753f, 0.03404149f, 0.02347498f, -0.10145123f, 
    0.10275375f, 0.24832928f, 0.04386437f, 0.06244203f, -0.08298551f, -0.02515112f, 0.07472822f, -0.07996311f, 
    0.01075094f, 0.17417002f, -0.09651040f, 0.03544947f, -0.29860079f, 0.10754088f, -0.11844029f, -0.04202881f, 
    -0.06995776f, -0.01876631f, 0.00512462f, 0.07217608f, 0.04206599f, 0.14473008f, -0.02800602f, -0.06598689f, 
    -0.46723592f, -0.13256100f, 0.06530872f, 0.43142501f, -0.08143390f, 0.00914036f, 0.08318965f, 0.26428407f, 
    0.03728960f, 0.04645833f, 0.03502353f, 0.01810526f, -0.24232492f, 0.15796089f, -0.13669798f, 0.27444768f, 
    -0.10288294f, 0.03977440f, 0.02721478f, 0.06794408f, -0.07277001f, 0.05697118f, 0.10464575f, 0.03973827f, 
    -0.54969174f, -0.29061559f, 0.21716824f, 0.28501806f, -0.09438013f, 0.03804937f, -0.13610569f, 0.02982248f, 
    -0.04067158f, 0.04485955f, -0.04039889f, 0.03249581f, 0.04446345f, -0.04963506f, -0.24897052f, -0.12341231f, 
    0.02472008f, -0.02821573f, -0.03823836f, 0.02929685f, 0.00385706f, 0.07910667f, -0.06686312f, -0.06327175f, 
    0.05834490f, 0.16087937f, 0.06640408f, -0.05946211f, 0.05816924f, -0.03771095f, 0.10529675f, 0.09507223f, 
    0.02493322f, -0.05016509f, -0.01001566f, 0.02321454f, 0.24538471f, 0.07345516f, -0.06372667f, -0.11299777f, 
    -0.07141708f, 0.02375104f, -0.00721988f, 0.08636476f, -0.05804722f, 0.01004111f, -0.02310644f, -0.09016458f, 
    0.15196680f, 0.04351150f, 0.12103334f, 0.06619266f, -0.12811786f, 0.06017517f, -0.06043488f, -0.10693454f, 
    0.05419444f, -0.09365585f, -0.01478046f, -0.18277735f, 0.00469001f, 0.07330953f, 0.05514490f, -0.11943106f, 
    0.05101774f, 0.04147109f, -0.07129847f, 0.14420666f, -0.10074849f, 0.10210804f, 0.05105310f, -0.17064224f, 
    0.06029455f, 0.15784431f, 0.02718200f, 0.12689912f, 0.03125475f, 0.03078165f, 0.05991574f, -0.10208415f, 
    0.10078350f, 0.04793165f, 0.19477144f, 0.25662681f, 0.05754324f, 0.23523992f, 0.04730194f, -0.08996096f, 
    -0.07517491f, -0.06118895f, -0.04431624f, -0.16808590f, 0.06774047f, -0.06121748f, -0.00578496f, 0.12594248f, 
    0.10731924f, 0.11828268f, 0.06678389f, 0.06871272f, 0.08866024f, 0.03401618f, -0.02852445f, 0.07234758f, 
    0.03452154f, 0.06312283f, 0.08350838f, 0.12845612f, 0.03649851f, 0.41184819f, 0.13765097f, 0.03031075f, 
    -0.00966877f, 0.03860436f, -0.01903458f, -0.07146946f, 0.14252457f, 0.14254229f, 0.19737266f, 0.16611829f, 
    -0.29483828f, -0.27857000f, -0.29880777f, -0.20627153f, 0.05991910f, -0.10327668f, 0.00827941f, -0.17421149f, 
    -0.05061170f, -0.11476646f, 0.00884213f, 0.01267570f, 0.09890456f, 0.01593137f, -0.12977223f, 0.20063709f, 
    -0.07342137f, 0.03900789f, 0.04635378f, -0.12022178f, 0.12178384f, -0.03942210f, 0.13602220f, 0.28022814f, 
    -0.19064865f, -0.16258882f, -0.16147436f, -0.12666187f, 0.04528253f, 0.12776953f, 0.07317946f, -0.00366910f, 
    -0.11164857f, 0.19392061f, -0.02013221f, -0.18121578f, -0.27537802f, 0.11027542f, -0.45728830f, 0.03858929f, 
    -0.05659491f, -0.02897121f, -0.08103598f, -0.24291751f, 0.06372702f, -0.22090492f, -0.02524927f, -0.15578271f, 
    0.21725948f, 0.27894345f, 0.03287458f, 0.20575818f, 0.03349217f, -0.07060888f, -0.07487945f, 0.05943307f, 
    -0.00837554f, -0.02913664f, -0.05104575f, 0.00009907f, -0.02816131f, 0.09978274f, 0.14597756f, 0.16057135f, 
    0.10323951f, 0.13129480f, 0.04015478f, -0.09995661f, 0.15133512f, 0.17032294f, 0.06003697f, 0.28519186f, 
    0.10764525f, -0.00257130f, -0.05206604f, 0.24855028f, 0.18306500f, -0.00285591f, -0.11455598f, -0.01602222f, 
    -0.02098790f, -0.05356314f, 0.04132574f, -0.20712626f, 0.19199909f, 0.40024063f, 0.00090481f, 0.27043581f, 
    0.06678157f, 0.02867390f, -0.00799472f, -0.03129379f, 0.14782321f, -0.08929027f, 0.09092544f, 0.11212109f, 
    -0.18220599f, 0.05462155f, -0.24742267f, 0.12676583f, 0.12991582f, 0.02774734f, 0.12598747f, -0.12869927f, 
    0.14399995f, -0.02980893f, -0.05082363f, -0.04615941f, 0.05566377f, 0.25291812f, 0.06939323f, 0.16090158f, 
    -0.00865618f, -0.23803408f, -0.04887016f, -0.20118925f, 0.05014265f, -0.10047320f, -0.10914484f, 0.03158667f, 
    0.05349922f, -0.07618798f, 0.04498691f, -0.14249510f, 0.10105170f, -0.06361684f, -0.06170906f, 0.09861037f, 
    -0.03229094f, -0.20197284f, -0.17053753f, -0.20056590f, 0.15530641f, 0.12363896f, -0.02862358f, 0.14753476f, 
    -0.03275720f, -0.01745872f, -0.15936549f, 0.14625432f, -0.09865228f, -0.07626214f, -0.15006649f, -0.22962603f, 
    -0.11917145f, -0.04516358f, 0.07755820f, -0.06922048f, -0.05432032f, -0.05414829f, 0.07369705f, -0.11520467f, 
    0.09386107f, -0.08728095f, 0.04273267f, -0.07256841f, -0.02922889f, 0.14579184f, 0.08590650f, 0.28535426f, 
    0.01014585f, 0.06043623f, -0.01736993f, 0.22695237f, 0.14204989f, 0.15748617f, 0.01825915f, -0.06846182f, 
    0.01134875f, -0.26069307f, 0.03707480f, -0.02676841f, -0.09591816f, 0.02689681f, -0.02193553f, -0.07336193f, 
    -0.24909940f, -0.02516959f, -0.25584769f, -0.14626791f, -0.13266648f, 0.01639790f, -0.07437366f, -0.15435334f, 
    -0.05934027f, 0.02858988f, 0.05124800f, 0.06128218f, 0.05752267f, 0.06263331f, 0.01951292f, -0.02892588f, 
    0.06363270f, 0.18515971f, 0.23132040f, 0.11927315f, -0.01982058f, 0.00506079f, 0.03164607f, 0.10078307f, 
    -0.00052724f, -0.03314291f, 0.04493174f, -0.04700750f, 0.03776186f, -0.10484683f, 0.12774608f, 0.04462511f, 
    -0.11272041f, 0.03484438f, -0.10171237f, -0.03761174f, 0.03451066f, 0.18725878f, -0.34064379f, 0.03417352f, 
    -0.05490522f, -0.20273079f, -0.11230138f, -0.16973801f, 0.06825908f, -0.00766971f, -0.04357696f, -0.11796716f, 
    -0.09509580f, 0.10619146f, -0.08225391f, -0.07441906f, -0.04717662f, -0.06105705f, 0.10212171f, 0.07803135f, 
    0.16387202f, 0.01943136f, 0.14951326f, 0.08998425f, -0.04717131f, 0.06626553f, 0.11087529f, 0.15709999f, 
    0.30344018f, -0.07220462f, 0.31469595f, -0.08892205f, 0.19231863f, 0.02280609f, -0.13124412f, 0.14181787f, 
    -0.02669661f, 0.02310405f, 0.00491874f, 0.05278582f, 0.09688821f, -0.25957596f, 0.18916745f, 0.15258938f, 
    0.09692904f, 0.03779632f, 0.02380880f, -0.04358128f, -0.10569042f, -0.02707794f, -0.04438396f, -0.13712925f, 
    0.21899247f, 0.13951871f, 0.05905363f, 0.14015594f, 0.10721700f, -0.03420962f, 0.14344651f, 0.00638393f, 
    -0.04619741f, 0.08860988f, -0.01503681f, -0.06752010f, -0.11794481f, 0.01965281f, 0.33522156f, 0.12868945f, 
    0.19949155f, 0.06957076f, -0.12440235f, -0.06154264f, -0.12705302f, -0.10910877f, -0.01145913f, 0.01489048f, 
    -0.10952992f, -0.22147241f, 0.03477300f, 0.04991280f, 0.20434716f, 0.08423659f, -0.04512139f, -0.06997403f, 
    0.01801947f, -0.05866672f, -0.05264397f, -0.09197930f, -0.26431111f, -0.31750235f, -0.17072843f, 0.21176186f, 
    0.21076331f, 0.18686244f, 0.18066750f, -0.15642624f, 0.15769239f, 0.03566226f, 0.00805777f, 0.14404701f, 
    -0.07533437f, -0.10726527f, -0.17929186f, -0.23259412f, -0.07554862f, 0.00132184f, -0.12508084f, -0.00606459f, 
    -0.00757425f, -0.18394896f, -0.00566741f, -0.10295284f, -0.00700658f, 0.04165403f, 0.01468315f, 0.10981246f, 
    0.00880710f, -0.05823383f, -0.04893913f, -0.08924238f, 0.06037655f, -0.23801459f, -0.08966298f, -0.05890350f, 
    0.08306018f, -0.02697766f, -0.04440811f, 0.07412949f, 0.01977726f, -0.15757225f, 0.13462195f, -0.10880978f, 
    0.06857469f, -0.01370670f, 0.02204611f, 0.00440427f, -0.03769844f, 0.00836928f, -0.16803351f, -0.18209940f, 
    0.14482450f, -0.04566349f, 0.03417916f, 0.05691576f, 0.04701084f, 0.18218920f, 0.02231225f, 0.05770075f, 
    -0.17364906f, -0.01502766f, 0.07054874f, 0.27784565f, -0.17948781f, -0.07448626f, -0.01545841f, -0.07436620f, 
    -0.02195303f, -0.03881992f, -0.02261057f, 0.08163832f, -0.09109049f, -0.09997618f, 0.16022275f, 0.13398571f, 
    0.06955180f, -0.00311848f, -0.04864143f, 0.10476981f, -0.07255483f, 0.05076233f, 0.00614276f, -0.02705326f, 
    0.00302141f, 0.12708168f, 0.01433102f, 0.15484850f, -0.04494124f, 0.09433715f, -0.05584513f, -0.04957105f, 
    -0.03302377f, 0.14066890f, 0.06313127f, 0.03929116f, 0.35912269f, -0.14602019f, 0.00650827f, -0.17267330f, 
    0.09577502f, 0.01891814f, 0.00821842f, 0.09588369f, -0.08518650f, 0.03249105f, -0.03232462f, -0.00295616f, 
    0.02488848f, 0.14793871f, 0.13852654f, 0.02435987f, -0.07974538f, -0.01057964f, 0.04168231f, -0.10068060f, 
    0.02321162f, 0.10480368f, -0.08409470f, -0.00133241f, 0.26593855f, -0.15620121f, 0.34374288f, -0.25117806f, 
    -0.00306568f, -0.00023422f, 0.17739530f, 0.03175909f, 0.09293057f, 0.00720067f, 0.28385228f, 0.01984691f, 
    -0.14763908f, -0.14217076f, -0.16590747f, -0.03008375f, 0.00612245f, 0.03355454f, 0.02930995f, 0.07645679f, 
    0.07423068f, 0.05133522f, 0.05644640f, -0.06004890f, 0.00739681f, -0.03814948f, -0.22945079f, -0.00759049f, 
    0.03043994f, -0.07959859f, -0.01883419f, 0.04016995f, -0.04862872f, -0.04957060f, -0.00966225f, -0.01395874f, 
    0.00317313f, 0.05458019f, 0.13395236f, -0.00649994f, -0.14563420f, 0.04804979f, -0.05552901f, -0.02704216f, 
    -0.03999227f, 0.05890589f, 0.02270488f, -0.00463468f, -0.16722336f, -0.09726495f, 0.06000630f, -0.02809099f, 
    0.09798130f, 0.01496938f, -0.14123274f, 0.10151445f, -0.08489904f, 0.02568620f, -0.07738567f, 0.07725879f, 
    0.20321000f, 0.18800351f, 0.44110078f, 0.10715006f, -0.04689547f, 0.02642813f, -0.07974198f, -0.04529558f, 
    -0.03910880f, 0.05002668f, -0.00180247f, 0.12674458f, -0.15469985f, -0.03887437f, -0.19703916f, 0.11706153f, 
    0.08712716f, -0.01663629f, 0.12376701f, 0.08495159f, -0.01614027f, 0.05492233f, 0.01754446f, 0.04711719f, 
    0.05470449f, -0.02892676f, 0.05929655f, 0.20170183f, 0.08500893f, -0.01052221f, -0.02839920f, 0.02889172f, 
    -0.00183557f, 0.09165132f, -0.09362733f, 0.00813810f, -0.04348756f, -0.04420650f, 0.08487359f, 0.09059855f, 
    -0.06769558f, 0.02041285f, 0.12233220f, 0.05623650f, 0.10631742f, 0.11309378f, 0.09193452f, 0.03508982f, 
    0.44550616f, -0.35195479f, 0.18420577f, 0.07863479f, 0.00843487f, 0.01716852f, -0.04338325f, -0.07688031f, 
    -0.08287191f, -0.03044391f, -0.09844827f, -0.09841326f, 0.30409902f, 0.16323292f, 0.25781462f, 0.02524888f, 
    -0.09780549f, -0.03430990f, 0.10675007f, 0.06398452f, 0.07812257f, 0.10312638f, -0.11367840f, -0.02669165f, 
    -0.10651635f, 0.10805530f, 0.01905961f, -0.11965572f, 0.14013150f, 0.07042750f, 0.05072067f, 0.02331712f, 
    0.10526653f, -0.01652954f, 0.06990681f, 0.11310298f, 0.06714099f, -0.21057439f, 0.04842824f, 0.01741109f, 
    -0.01926116f, 0.13737835f, 0.02618150f, 0.10216706f, -0.01870785f, -0.11072838f, 0.06488379f, 0.11536072f, 
    -0.04139381f, -0.00534077f, -0.08265556f, 0.15007837f, -0.05326695f, -0.13537766f, -0.02339044f, -0.15700915f, 
    -0.04549347f, -0.05971079f, -0.10559276f, -0.09258364f, -0.01591106f, -0.00783507f, -0.04493972f, -0.15300071f, 
    -0.01174078f, -0.02846831f, 0.01523049f, -0.12302645f, 0.08158109f, 0.07286096f, 0.03205967f, 0.13138886f, 
    0.01391525f, 0.09493341f, 0.02947982f, 0.22433488f, -0.12546235f, -0.06656885f, 0.15422156f, -0.01336314f, 
    0.05713197f, 0.01100576f, 0.11772266f, 0.09484944f, -0.03758084f, -0.00614836f, -0.02370926f, 0.15100744f, 
    0.01456951f, 0.06089007f, -0.03485535f, 0.01431998f, 0.00312696f, 0.03017733f, -0.00805537f, -0.05325210f, 
    -0.13911040f, 0.25575361f, 0.01621209f, 0.19088137f, -0.04994110f, -0.00859765f, 0.06484445f, -0.01388198f, 
    0.01681144f, -0.04243974f, -0.04562911f, 0.00702966f, 0.05034228f, 0.28392750f, -0.07942336f, -0.00389904f, 
    -0.14330739f, -0.07404158f, 0.01483696f, -0.12293208f, -0.05004273f, 0.01149213f, -0.08174961f, -0.04060653f, 
    -0.00183646f, -0.05705205f, -0.13422275f, 0.32028157f, -0.04397374f, -0.05142864f, 0.11947574f, 0.12478679f, 
    0.01026150f, 0.05818206f, -0.03475150f, 0.07698791f, -0.13032290f, 0.19557402f, 0.05638427f, -0.17023543f, 
    -0.03493949f, -0.06518018f, -0.02622886f, 0.00429269f, -0.00119276f, 0.02314968f, -0.00762539f, 0.03017356f, 
    0.27810198f, 0.14337069f, 0.15844379f, 0.01607058f, -0.01277780f, -0.04770144f, -0.05634221f, -0.02634782f, 
    -0.09142935f, 0.01754929f, -0.03143324f, 0.09392972f, 0.24518508f, 0.15674311f, 0.06909154f, -0.03631697f, 
    -0.08219438f, -0.02973396f, -0.07362095f, -0.02883638f, 0.02266381f, 0.00676876f, -0.01136862f, 0.05080831f, 
    0.02870912f, 0.00852530f, 0.12983885f, -0.00348012f, 0.10783635f, 0.13459928f, 0.06905897f, 0.14424871f, 
    -0.00417895f, 0.00346406f, 0.03624265f, -0.21172394f, 0.01622756f, 0.01755998f, -0.04067208f, -0.05378725f, 
    0.05535612f, 0.07598396f, -0.05077968f, 0.15319259f, -0.07095075f, 0.04732260f, 0.00673139f, 0.12061252f, 
    -0.03514835f, 0.02272425f, 0.04171807f, 0.02461812f, -0.03756262f, 0.02311099f, 0.03054131f, -0.00829722f, 
    -0.02616299f, -0.01800903f, 0.01193992f, 0.00150385f, -0.01147000f, -0.00217135f, 0.02363372f, -0.03023781f, 
    0.01211450f, -0.04600157f, -0.02160751f, 0.02673726f, -0.03214378f, -0.02828539f, -0.00251991f, -0.00301562f, 
    0.00664722f, 0.01191495f, -0.03826817f, -0.04208267f, 0.00134441f, -0.02201878f, -0.00429234f, 0.01847954f, 
    -0.03119216f, -0.02735426f, -0.02757118f, -0.02118242f, -0.02464181f, -0.05195080f, 0.02427636f, 0.03984568f, 
    0.03044512f, -0.03371832f, -0.00732436f, -0.00139142f, -0.03471226f, -0.03533075f, 0.04135979f, -0.03999288f, 
    0.03696389f, 0.01606687f, -0.04248259f, -0.04618144f, -0.00743118f, -0.05613936f, 0.02351492f, 0.03224852f, 
    0.03972407f, -0.04273694f, 0.01150627f, -0.04727619f, 0.02713976f, 0.02214224f, -0.04300727f, -0.00548812f, 
    0.01189933f, 0.02660496f, -0.04300708f, 0.01489707f, -0.00411286f, 0.03976995f, -0.01037575f, -0.04636153f, 
    0.01268063f, -0.00221249f, 0.00568883f, -0.02939305f, -0.04290949f, -0.00868125f, 0.00529516f, 0.01373037f, 
    -0.05242644f, -0.03398291f, -0.02203446f, -0.00485860f, -0.00470946f, -0.04303302f, 0.03784212f, 0.02531730f, 
    0.04260968f, -0.02559830f, 0.00298747f, 0.04210033f, -0.04825561f, 0.02558259f, -0.02244199f, -0.00948336f, 
    0.03215708f, 0.01024705f, 0.00855791f, -0.00953888f, -0.03973366f, 0.04461062f, -0.03931877f, 0.01333727f, 
    -0.04858770f, 0.01655743f, 0.00028405f, -0.02208011f, 0.03426755f, -0.05378260f, 0.01939836f, 0.00683444f, 
    -0.02252557f, -0.01380813f, 0.01090319f, 0.03742350f, 0.00395527f, -0.04901931f, -0.02873323f, -0.02527143f, 
    0.02823806f, 0.03603861f, 0.03481535f, 0.03279493f, 0.01444696f, -0.01315950f, 0.01031458f, 0.00641657f, 
    -0.05631555f, -0.04891811f, -0.04934489f, 0.04877818f, 0.00850631f, -0.00832676f, 0.00014280f, -0.02830649f, 
    0.04354614f, 0.00970562f, 0.01725003f, 0.04528783f, -0.04194514f, 0.00798794f, 0.03199139f, 0.00407148f, 
    -0.02126590f, 0.02480908f, -0.00526576f, 0.04217177f, -0.03972765f, 0.02865200f, -0.01824394f, -0.03644909f, 
    -0.00677061f, -0.01685027f, -0.00565218f, -0.01296576f, -0.04591381f, -0.00728756f, 0.01733593f, 0.00206215f, 
    -0.00895848f, 0.01290176f, 0.02313034f, -0.00227797f, -0.02072362f, 0.00870022f, -0.00152442f, -0.01732699f, 
    0.01781412f, -0.01064801f, -0.00328513f, 0.00790634f, -0.02613058f, -0.04657852f, -0.02118040f, -0.03609717f, 
    -0.05409816f, 0.01770121f, -0.00736264f, -0.02131450f, -0.04310951f, -0.05300573f, -0.00652637f, 0.05087973f, 
    0.04372742f, 0.00478909f, 0.03688692f, -0.04423593f, 0.01539233f, -0.01535677f, 0.01920014f, -0.02836376f, 
    -0.03719504f, -0.00725192f, -0.01097991f, -0.00788877f, -0.02581839f, -0.02335338f, -0.02165375f, -0.05033984f, 
    0.04530758f, -0.02155516f, 0.03147323f, 0.03670211f, 0.03829058f, -0.05249285f, -0.04478794f, -0.01963913f, 
    0.01875860f, -0.04866228f, -0.01951454f, -0.00865800f, -0.03401071f, 0.03886012f, -0.04988744f, 0.01499393f, 
    0.04306836f, 0.02440191f, -0.04066264f, -0.00889242f, -0.03253543f, -0.00169429f, 0.01552215f, -0.04913179f, 
    -0.04849717f, -0.01151128f, -0.03497852f, 0.01705145f, -0.03011462f, -0.02952449f, 0.00793679f, 0.00937525f, 
    -0.03975265f, -0.03381507f, -0.04358148f, -0.04197304f, 0.04220135f, 0.03044950f, -0.03320394f, -0.04187038f, 
    -0.01732216f, 0.01341345f, -0.02419667f, -0.03128412f, 0.00897980f, 0.00229039f, -0.01181198f, -0.04106831f, 
    -0.05034502f, -0.01816048f, 0.03767734f, -0.02872686f, -0.00658637f, -0.03540532f, 0.00449791f, -0.02763312f, 
    0.00981184f, -0.03479869f, -0.00968329f, 0.01276715f, -0.00038424f, 0.03944280f, -0.01484899f, 0.03694270f, 
    -0.03718970f, -0.00175170f, -0.05570338f, -0.01990573f, -0.05082684f, -0.02223600f, -0.03598620f, 0.03965698f, 
    -0.01534672f, -0.05358879f, -0.00791772f, -0.02970397f, -0.03698157f, -0.01342881f, 0.02706089f, -0.03861479f, 
    0.04433458f, -0.03461299f, 0.04135046f, -0.04192668f, -0.01283430f, 0.00753245f, -0.00127787f, 0.00923889f, 
    -0.04614818f, -0.00405245f, -0.02750633f, -0.04316271f, 0.03065167f, 0.00830628f, -0.04816033f, 0.02808933f, 
    -0.04973714f, -0.05274054f, -0.03268791f, 0.02885287f, 0.03234746f, -0.04278756f, -0.02483696f, 0.00920169f, 
    0.03845840f, 0.01513664f, 0.02523170f, -0.05143843f, -0.05257139f, 0.01436692f, -0.04003100f, 0.04524601f, 
    -0.04566095f, -0.05141408f, -0.03424849f, 0.03607085f, -0.02329295f, -0.00253893f, 0.02804168f, 0.03818133f, 
    0.02916069f, -0.04861832f, -0.04487490f, -0.01319217f, 0.00916326f, 0.00811234f, -0.03883788f, -0.02632132f, 
    -0.01142857f, 0.00178513f, 0.02478655f, 0.02843634f, -0.01126870f, -0.01420274f, 0.01284210f, -0.02800716f, 
    0.04276804f, 0.00489219f, -0.04192870f, 0.00058014f, 0.00373128f, -0.03455117f, -0.03588066f, 0.02474172f, 
    0.00120570f, -0.03067954f, -0.02133474f, 0.01707968f, -0.04251217f, -0.04481124f, -0.02979228f, 0.02629948f, 
    0.02411473f, -0.03773433f, -0.02325893f, 0.04143879f, 0.03284770f, 0.00097337f, -0.01691233f, -0.00723578f, 
    0.04473088f, -0.04312771f, 0.04075511f, 0.03940795f, -0.03816829f, 0.04683330f, -0.01686605f, -0.04039124f, 
    -0.00696984f, 0.04370052f, -0.00254058f, -0.00060078f, -0.04025643f, 0.00885976f, -0.05374951f, 0.04288664f, 
    0.03933352f, -0.04272326f, 0.01189526f, -0.00487800f, -0.04425937f, -0.00193990f, 0.04112665f, -0.00202500f, 
    -0.04130131f, -0.03810882f, -0.04077590f, -0.03448229f, 0.03712251f, -0.02273241f, -0.04776675f, -0.05794382f, 
    -0.01189160f, 0.00610988f, -0.00888595f, 0.02709231f, 0.00636439f, -0.01033459f, -0.00047288f, -0.05119938f, 
    0.01516367f, -0.03770458f, -0.02947655f, -0.00972607f, -0.05898929f, -0.00229803f, -0.03270220f, -0.01930540f, 
    0.01462485f, -0.01703547f, -0.01942977f, 0.03918093f, -0.00896600f, -0.05125350f, 0.01493384f, 0.01468458f, 
    -0.02994784f, 0.01317558f, -0.04098723f, 0.01822131f, -0.01363990f, 0.02042216f, 0.03821604f, 0.03479752f, 
    -0.00724622f, -0.00135093f, 0.00152497f, -0.04483024f, 0.00178339f, -0.01742053f, -0.03692216f, -0.01254138f, 
    0.02634611f, -0.03650999f, -0.03952921f, 0.01888021f, -0.00765247f, 0.03434483f, 0.00993623f, 0.04466140f, 
    0.02662152f, 0.03840590f, 0.03477351f, 0.04788800f, 0.00703385f, -0.02270860f, 0.04246626f, -0.01207088f, 
    -0.04280497f, 0.02014836f, 0.03116571f, -0.05015865f, 0.02932415f, 0.02140422f, 0.02316130f, -0.03812319f, 
    -0.01517827f, -0.02310083f, -0.02594870f, -0.03550560f, -0.05116479f, 0.00224421f, 0.03983638f, 0.00506325f, 
    0.01026679f, 0.03319926f, -0.04981033f, -0.04055727f, 0.02208973f, -0.04007737f, 0.00624947f, -0.02975300f, 
    -0.04291277f, -0.03331679f, 0.00381235f, -0.04238065f, -0.04679417f, 0.00952947f, -0.02822436f, 0.00156688f, 
    -0.04700317f, 0.03048765f, -0.04754105f, -0.03313493f, 0.03398196f, -0.02013735f, 0.02463445f, -0.04779902f, 
    0.00563967f, -0.00519455f, -0.02171126f, -0.03356033f, 0.03540343f, -0.00295026f, -0.04302126f, 0.03349783f, 
    0.04085049f, 0.02141120f, 0.04403187f, -0.01341399f, 0.00698136f, -0.00949864f, -0.04573698f, -0.03888078f, 
    -0.03022703f, -0.00272989f, 0.03284971f, 0.03773230f, -0.01996854f, 0.03607330f, -0.05648322f, 0.00867799f, 
    0.01804337f, -0.02627943f, 0.02752393f, 0.02200516f, -0.02595406f, -0.01360597f, 0.02092033f, 0.02642594f, 
    -0.02691903f, 0.01145245f, -0.00644437f, 0.02220180f, -0.05129543f, 0.04642489f, -0.02356829f, -0.04762817f, 
    -0.00795035f, -0.02245583f, 0.03314061f, -0.00047340f, -0.01214285f, -0.02781152f, -0.02355550f, -0.03436798f, 
    -0.01429133f, 0.01340313f, -0.01223392f, -0.02598142f, 0.05078971f, 0.00356729f, -0.02572321f, -0.00907936f, 
    0.00157293f, -0.04951751f, -0.03325179f, -0.02720962f, 0.03690603f, -0.05120928f, 0.00434954f, -0.00055404f, 
    0.03390919f, 0.00783092f, -0.02516844f, 0.00860081f, 0.01779604f, -0.00887678f, 0.02472743f, -0.00549883f, 
    -0.03961319f, -0.04603537f, -0.02793457f, -0.00099084f, -0.04712317f, -0.04992113f, -0.03370918f, 0.00915715f, 
    -0.02491246f, -0.04477302f, -0.01622944f, -0.04951550f, 0.04622605f, 0.01956947f, -0.00026803f, -0.04771550f, 
    -0.05916626f, 0.02782072f, -0.05261312f, -0.02144125f, 0.00093426f, 0.01326367f, -0.00326599f, -0.04396132f, 
    -0.02844501f, -0.05279070f, -0.05779975f, 0.02149805f, -0.00255461f, -0.00162833f, 0.01569527f, -0.03553736f, 
    0.02142345f, 0.03355855f, -0.00309611f, 0.02429325f, 0.03493677f, -0.00674871f, -0.01723843f, 0.02300496f, 
    0.00801579f, -0.02332005f, -0.02383046f, -0.00515691f, -0.02550673f, 0.00462359f, -0.04520223f, -0.04669246f, 
    0.02434827f, 0.02029870f, -0.00133371f, 0.04311443f, -0.01921108f, 0.01354520f, 0.01187766f, -0.02496880f, 
    -0.03053477f, -0.05049241f, 0.04711467f, 0.04021837f, -0.04809111f, -0.02594226f, 0.01774220f, -0.01384134f, 
    -0.05038379f, 0.02848011f, -0.02071734f, 0.00594853f, 0.03060289f, -0.01879167f, -0.03012990f, 0.03916908f, 
    -0.04024733f, -0.00631209f, -0.04934957f, -0.06073498f, -0.04653100f, 0.02722438f, -0.02970602f, -0.03285218f, 
    0.02908720f, 0.04324462f, -0.01156343f, 0.03739069f, -0.00841164f, 0.04069438f, -0.02197365f, -0.02214745f, 
    0.04024541f, 0.04601916f, -0.04909578f, -0.01775716f, -0.00001932f, -0.00600549f, 0.03244475f, 0.01086023f, 
    0.00142903f, -0.00108359f, -0.01193663f, 0.00348617f, 0.03874334f, -0.05440972f, -0.01228674f, 0.02380911f, 
    0.02604028f, 0.01808353f, -0.00546612f, 0.01144744f, -0.01825369f, 0.00752108f, -0.02712860f, 0.03670274f, 
    0.00775346f, -0.00676643f, -0.03556274f, -0.05366779f, -0.02154857f, 0.00204059f, 0.01700756f, -0.05474755f, 
    0.04280498f, 0.01500219f, -0.04913575f, 0.01161509f, -0.05126483f, -0.02417776f, -0.02442737f, 0.00002099f, 
    -0.04166617f, -0.05213569f, 0.00943132f, 0.04147871f, 0.00507585f, -0.02429417f, -0.01028722f, 0.01307173f, 
    0.02803968f, -0.04465404f, 0.02811800f, -0.02242161f, -0.00593991f, -0.01236039f, -0.02372845f, -0.04989710f, 
    -0.04513602f, 0.04395295f, -0.04500945f, -0.03975586f, -0.02029707f, -0.03958393f, -0.02750691f, 0.03628577f, 
    0.03137606f, 0.04315883f, -0.03707812f, 0.03567424f, -0.05100564f, -0.02714114f, -0.03801730f, -0.04359825f, 
    -0.03585872f, -0.03827433f, -0.04144634f, -0.04384916f, -0.03852429f, 0.00587850f, -0.00863892f, -0.02002028f, 
    0.04002251f, -0.00885921f, 0.03342251f, -0.03489492f, 0.01358772f, 0.01537343f, 0.01365745f, -0.01057988f, 
    0.02727707f, -0.04952566f, -0.00047604f, 0.01526901f, 0.02160324f, -0.01997528f, 0.01574563f, -0.00448106f, 
    0.03907134f, -0.05184831f, -0.03939077f, 0.02181919f, 0.00353892f, -0.02361262f, -0.05356021f, 0.01378142f, 
    0.02959083f, -0.01513318f, -0.00601237f, -0.05627479f, -0.00640712f, 0.01121727f, 0.04381100f, 0.03734062f, 
    0.02706206f, -0.00051424f, -0.03365272f, 0.00682779f, 0.00547341f, -0.01026957f, 0.01376032f, -0.04017730f, 
    0.09985226f, 0.22283117f, 0.23866178f, 0.10924216f, 0.07768345f, 0.11167126f, -0.13518918f, -0.00474702f, 
    -0.00300106f, -0.04676721f, 0.01225027f, -0.01957225f, -0.06926417f, -0.17272957f, 0.14800011f, 0.03939962f, 
    0.06402899f, -0.03756325f, 0.08858989f, -0.05506970f, 0.04415843f, -0.16402671f, -0.06200766f, -0.05499930f, 
    0.38225138f, 0.27355516f, 0.18369929f, -0.07569615f, 0.18988889f, 0.03743136f, 0.05649024f, -0.05586163f, 
    0.07183906f, -0.06431796f, 0.02596348f, 0.03393277f, 0.19525309f, 0.06058706f, -0.15262516f, -0.02968707f, 
    0.03639147f, 0.05203782f, 0.01750856f, -0.01092542f, 0.00622132f, -0.11925834f, -0.04721089f, -0.08174423f, 
    0.00487585f, 0.03532359f, 0.02522313f, -0.06137509f, 0.06636701f, -0.10292912f, 0.00854745f, 0.10405056f, 
    0.00401754f, 0.04688025f, -0.01921757f, -0.04927042f, -0.39589453f, 0.10240653f, 0.02671246f, 0.09769642f, 
    -0.04577335f, -0.09462952f, -0.07673200f, 0.03842381f, 0.01085693f, -0.17432562f, -0.14958520f, -0.08213785f, 
    0.05757840f, 0.10634696f, -0.06268331f, -0.07027387f, -0.12862611f, 0.04395286f, -0.09894989f, 0.01012445f, 
    0.08444902f, -0.12914786f, 0.05419561f, 0.04171748f, -0.10335410f, 0.05669703f, -0.13200541f, 0.36798364f, 
    0.17393023f, -0.03689711f, -0.19655693f, -0.08035335f, 0.05944303f, 0.04545952f, -0.04546566f, -0.02041867f, 
    0.00947553f, 0.18754458f, 0.02474586f, -0.10480439f, -0.08179742f, -0.00539248f, 0.06192517f, 0.12827446f, 
    0.18932170f, -0.19237544f, -0.14588231f, -0.05879607f, 0.11065250f, 0.19824547f, 0.18419659f, 0.03244228f, 
    -0.00426118f, 0.08746196f, 0.07004276f, 0.05254627f, 0.03378820f, -0.06271815f, -0.07740132f, -0.12486782f, 
    0.07015903f, 0.17442599f, -0.03023785f, 0.24555667f, 0.06895811f, -0.01920745f, -0.00210010f, 0.05371230f, 
    0.02962490f, 0.00038955f, -0.05122270f, 0.08198263f, -0.02126903f, 0.01646622f, -0.04657051f, 0.00820252f, 
    0.08256333f, 0.10908069f, 0.00663117f, 0.08415367f, -0.01838748f, 0.07118664f, 0.16393615f, -0.16186255f, 
    0.01458088f, -0.00041073f, -0.46859381f, 0.12158469f, 0.04303553f, 0.10809043f, -0.02587685f, -0.11843908f, 
    0.03560701f, 0.03570713f, 0.02109282f, -0.04582040f, -0.21828467f, -0.05727335f, -0.10556329f, -0.10949232f, 
    0.00351091f, 0.08250816f, -0.01128986f, 0.16006437f, 0.24452710f, -0.04967209f, 0.03641336f, -0.20483960f, 
    0.10344189f, 0.03687264f, -0.18751614f, -0.03389223f, -0.02719921f, 0.10492762f, 0.04962207f, -0.20321211f, 
    -0.02101210f, -0.04286010f, 0.09514911f, 0.12100017f, 0.08251586f, 0.02452215f, -0.16761287f, 0.01133734f, 
    -0.01112283f, 0.14771506f, 0.03854492f, -0.24510159f, -0.00031719f, -0.00422022f, -0.00509691f, 0.08949512f, 
    -0.32801628f, 0.01216085f, -0.01788532f, 0.11442535f, 0.05629580f, -0.09589913f, 0.04061048f, 0.10357985f, 
    -0.04541460f, 0.01604758f, 0.05312265f, 0.06071434f, -0.01044210f, 0.13974027f, -0.27591276f, 0.19561245f, 
    0.11694925f, 0.05582248f, -0.18243422f, 0.04769098f, -0.01680669f, 0.01461530f, 0.11883383f, -0.06222238f, 
    0.07608762f, -0.14092192f, 0.08684874f, 0.15212284f, -0.03048608f, 0.00773606f, 0.00933187f, 0.01693457f, 
    0.06428168f, 0.00294635f, -0.08458524f, 0.01512504f, -0.08346665f, -0.03558320f, -0.09266507f, 0.17093956f, 
    0.12090989f, -0.01396247f, -0.11491060f, -0.01738590f, 0.00555739f, 0.03321666f, -0.04126634f, -0.13283861f, 
    0.26684374f, 0.23984025f, 0.21921618f, 0.11353341f, 0.01924515f, 0.13452020f, 0.04050081f, -0.02690963f, 
    0.05068140f, -0.00166460f, -0.01249215f, 0.03871594f, 0.14458993f, -0.02490900f, 0.01193012f, 0.00682639f, 
    0.01221712f, 0.02694846f, 0.08351748f, 0.06822257f, 0.01962877f, -0.03706847f, 0.02648537f, 0.05730527f, 
    0.13872775f, 0.01771219f, -0.18273471f, -0.04961622f, 0.15210584f, 0.12138696f, -0.04165972f, 0.00858692f, 
    0.00505213f, -0.09680916f, -0.01049079f, 0.01381372f, 0.11299364f, -0.12324525f, -0.07065786f, -0.06520811f, 
    0.05752178f, 0.03678168f, -0.00681956f, 0.01237458f, 0.04495713f, -0.25206888f, -0.12590794f, -0.05311297f, 
    0.46395057f, -0.08763943f, 0.28825110f, -0.30401775f, 0.08575328f, 0.02604841f, 0.00249918f, -0.09699394f, 
    0.02583470f, -0.00554401f, -0.03027509f, 0.03928836f, 0.04316186f, -0.10358594f, 0.29858896f, -0.04644399f, 
    0.06951395f, -0.01493115f, 0.00885624f, -0.04424193f, 0.02575865f, 0.01585064f, -0.02490475f, 0.06433878f, 
    0.22966535f, 0.23239987f, 0.21470562f, -0.15317303f, 0.06243126f, 0.02341823f, 0.05520154f, -0.11881682f, 
    0.08825993f, -0.03845029f, 0.02813761f, -0.05389209f, -0.01449688f, -0.25983518f, 0.23964038f, 0.16584039f, 
    -0.05905664f, 0.01522493f, 0.07274622f, 0.07422030f, 0.00408144f, -0.04659553f, -0.02335977f, 0.09591130f, 
    0.08142013f, -0.05632293f, -0.12832271f, 0.07599025f, -0.02253519f, 0.08082826f, -0.03506139f, -0.01608593f, 
    0.02066251f, 0.07850752f, 0.08205256f, -0.07935990f, 0.01561543f, 0.07153136f, -0.00044003f, 0.27513638f, 
    0.09717828f, 0.00188795f, 0.03238707f, -0.08637276f, 0.01079045f, -0.01665061f, 0.06291775f, 0.01790154f, 
    -0.00779302f, 0.09093794f, 0.01634495f, 0.03696794f, 0.04683815f, 0.00107634f, 0.03580805f, -0.06706927f, 
    -0.09247148f, -0.03801724f, -0.00758444f, 0.14488892f, -0.17795143f, 0.04231216f, 0.10152554f, 0.00643507f, 
    -0.08252780f, -0.02797596f, 0.00882538f, -0.00513678f, 0.03730415f, 0.13650855f, 0.00938171f, 0.00588822f, 
    -0.21351831f, -0.13877301f, 0.06484567f, 0.05162315f, -0.07591737f, -0.03123218f, -0.10227156f, 0.17017193f, 
    -0.02457803f, -0.01040954f, -0.02784475f, -0.12450095f, 0.22639488f, -0.32548192f, 0.14112787f, 0.26078638f, 
    0.12096103f, 0.10582006f, -0.04080398f, -0.08238954f, -0.00657879f, 0.00377250f, 0.06571936f, 0.02970854f, 
    -0.21932709f, -0.12939680f, 0.04028319f, -0.10742472f, 0.11445525f, 0.01355077f, -0.00334976f, -0.15734594f, 
    0.03566740f, -0.04495708f, -0.00565651f, -0.08365718f, 0.05959892f, -0.17145877f, -0.00200653f, 0.01759730f, 
    0.14801605f, -0.01985197f, -0.03424896f, -0.03667261f, -0.04399708f, -0.05565868f, -0.03272817f, -0.10945772f, 
    0.01298448f, 0.04955787f, -0.09691325f, -0.03315664f, -0.03019381f, -0.10030458f, -0.05040675f, 0.13441601f, 
    0.03311988f, 0.04567612f, 0.03838343f, 0.09254038f, 0.02536696f, 0.07578958f, 0.08270558f, -0.00620276f, 
    0.02586749f, -0.02289866f, 0.05942290f, 0.03218926f, 0.07565039f, -0.08277386f, -0.04940783f, -0.11400596f, 
    -0.01018096f, -0.01814638f, 0.19783954f, -0.06056539f, -0.08134463f, 0.13456666f, 0.00711102f, 0.16554379f, 
    0.03233948f, 0.06398298f, 0.08044143f, 0.03616491f, 0.12455377f, -0.10898586f, -0.22198530f, -0.08463933f, 
    0.10855303f, 0.16374497f, -0.04789088f, 0.10715596f, -0.08568531f, 0.16162993f, -0.00662731f, 0.01663972f, 
    0.01566568f, 0.12244912f, -0.01332330f, -0.17053747f, -0.07295686f, 0.03595113f, -0.05541831f, 0.11472877f, 
    0.07063089f, -0.00046641f, -0.15785399f, -0.01457793f, -0.16538265f, 0.07983138f, 0.03294748f, -0.13409077f, 
    0.01444556f, -0.06318400f, -0.00619229f, 0.10830013f, 0.03455414f, -0.02396056f, -0.04612391f, -0.06679023f, 
    -0.05885702f, -0.05231623f, -0.07713219f, -0.09496400f, -0.09131855f, -0.23035242f, -0.19887538f, 0.02199683f, 
    0.08894114f, -0.07408711f, -0.02398455f, 0.13636024f, -0.05491481f, -0.17267565f, 0.08502550f, 0.09675476f, 
    -0.05890139f, -0.01491393f, 0.08261782f, -0.11656489f, 0.07779197f, -0.07142805f, 0.11759420f, -0.01154137f, 
    -0.03844665f, -0.06431172f, -0.15966879f, 0.07846950f, 0.02843404f, -0.09804820f, -0.00801043f, 0.04053139f, 
    -0.01566686f, -0.13544773f, -0.11929788f, -0.16268522f, -0.05697440f, 0.00851060f, 0.12932271f, 0.12933172f, 
    -0.08861639f, -0.00881324f, 0.00660770f, 0.05635404f, 0.15946157f, 0.06600422f, 0.10779221f, -0.00083986f, 
    -0.11954200f, 0.07185949f, 0.17060478f, -0.06811322f, -0.10953190f, 0.18484962f, 0.08740802f, 0.04843798f, 
    -0.02204988f, 0.03826633f, 0.12246962f, 0.11308520f, 0.07399064f, 0.08775600f, 0.20669575f, 0.18488733f, 
    -0.00573600f, 0.01041424f, -0.01998695f, -0.05101510f, 0.01592403f, -0.05806126f, 0.00595450f, 0.06809060f, 
    -0.27835360f, 0.30902126f, 0.20191777f, 0.33378035f, 0.12836573f, -0.11150844f, 0.12587360f, -0.00603509f, 
    -0.11348292f, 0.00792614f, 0.06210368f, 0.18115245f, -0.26123050f, 0.09596471f, -0.23302059f, -0.07338499f, 
    -0.03879083f, 0.07470123f, -0.05492318f, -0.00257621f, -0.08296248f, -0.18173461f, 0.21159098f, -0.07990040f, 
    0.14031337f, 0.07411580f, 0.02089168f, 0.12072285f, -0.04096986f, 0.06356324f, -0.00430053f, -0.16355503f, 
    0.03571583f, 0.16205631f, 0.04294912f, -0.01825693f, 0.18932182f, 0.09631160f, 0.14003234f, -0.01788002f, 
    0.13930811f, 0.02345251f, -0.05236981f, 0.13108003f, 0.14145733f, 0.08570010f, 0.01930114f, -0.01747227f, 
    -0.15855063f, -0.11796406f, 0.10970753f, 0.17088459f, 0.05856090f, 0.09458773f, 0.10564921f, 0.11740674f, 
    -0.05756697f, 0.03212532f, -0.00526403f, 0.05812759f, 0.12337621f, 0.07869189f, -0.18689625f, -0.06433555f, 
    -0.13954279f, 0.11436469f, 0.13299760f, 0.15772311f, 0.07057834f, 0.08711939f, 0.14263763f, -0.16222049f, 
    -0.15880185f, 0.23626627f, -0.02971969f, -0.04045502f, 0.11993548f, 0.10846131f, -0.07807295f, -0.05598703f, 
    0.04921596f, 0.07190476f, -0.07156220f, 0.04895825f, -0.08691043f, -0.01205632f, -0.02239260f, -0.04807791f, 
    -0.01569358f, -0.02840611f, -0.02136217f, 0.22761215f, 0.00153591f, -0.09340946f, -0.06476597f, -0.07070971f, 
    0.04355968f, 0.02035736f, 0.31900430f, 0.14615078f, 0.11129597f, 0.13855498f, 0.01029689f, -0.01977142f, 
    0.14413731f, -0.04556062f, -0.01462838f, 0.03551912f, 0.15626012f, -0.14349136f, 0.22011858f, 0.22349180f, 
    -0.07493727f, 0.15477996f, 0.04095989f, 0.02219935f, 0.03894580f, 0.01115667f, 0.12327957f, 0.03868903f, 
    -0.19768263f, -0.01638361f, 0.13534027f, 0.04165051f, 0.07591992f, 0.02982011f, 0.10853730f, -0.13535520f, 
    0.05253168f, -0.00148677f, 0.02207349f, -0.06849426f, 0.09614940f, 0.14147894f, -0.23624063f, -0.03049204f, 
    -0.16594630f, 0.02539101f, 0.02793331f, -0.01581267f, 0.07170379f, 0.15431643f, -0.14005630f, 0.05763166f, 
    -0.20297906f, 0.07856432f, 0.07289519f, 0.02086488f, -0.08926363f, -0.10048262f, -0.08830505f, -0.04426071f, 
    0.06210722f, 0.11117620f, 0.12495533f, -0.01435699f, -0.32559863f, -0.14581533f, -0.08397222f, -0.25413051f, 
    -0.04478816f, -0.16024026f, -0.02866000f, -0.05309495f, -0.12133207f, -0.14569885f, -0.14924878f, -0.14037502f, 
    -0.11711098f, 0.14819621f, -0.13314198f, -0.01747932f, -0.07356561f, -0.01829842f, 0.06383416f, -0.03221572f, 
    0.03636564f, -0.06761540f, 0.14681286f, 0.35450238f, 0.08424915f, -0.02269297f, -0.02605396f, -0.17019510f, 
    0.00872750f, 0.02958104f, 0.07428667f, -0.02180045f, 0.10417216f, 0.19440508f, 0.12135584f, 0.05981464f, 
    -0.12428039f, -0.07483487f, -0.06573474f, 0.16034365f, -0.13903508f, 0.00802974f, -0.09252633f, -0.16074960f, 
    -0.03433492f, -0.00187396f, 0.10824586f, 0.13895208f, -0.17669335f, 0.21620654f, -0.18894292f, 0.18654332f, 
    -0.16454031f, 0.02772664f, -0.02099381f, -0.16082573f, 0.01170973f, 0.03010267f, 0.14932960f, -0.06715541f, 
    -0.12188378f, -0.20682648f, 0.09867539f, 0.11445912f, -0.10607265f, 0.02503598f, -0.11760150f, 0.05434083f, 
    -0.00609877f, 0.07685023f, 0.02766311f, 0.09899616f, 0.01112308f, 0.17193046f, 0.14658482f, -0.08308817f, 
    0.14389209f, 0.10064120f, 0.06142607f, 0.08871167f, 0.09897918f, 0.10936778f, 0.07579369f, 0.05452286f, 
    0.10070784f, -0.06288941f, 0.05731485f, -0.15277012f, 0.02763046f, -0.06896427f, 0.11230651f, -0.08590770f, 
    -0.01639777f, 0.05487680f, -0.03311229f, 0.03255897f, 0.07239883f, -0.05268864f, -0.11741397f, 0.05259400f, 
    -0.01262900f, -0.01095974f, -0.05793462f, -0.12543763f, 0.02661697f, 0.00396980f, 0.10337370f, 0.18686603f, 
    -0.20378377f, -0.08873788f, 0.15027377f, 0.02219779f, -0.03960453f, 0.25491697f, 0.18991660f, -0.07673291f, 
    -0.07081404f, 0.04809326f, 0.04946674f, -0.02527679f, 0.02247422f, 0.15055925f, -0.11555362f, -0.05714893f, 
    0.05646509f, -0.07264253f, 0.12934971f, -0.18317455f, 0.16765912f, -0.06596705f, -0.05807781f, -0.02237562f, 
    0.08093690f, -0.08014321f, -0.12901761f, 0.35764638f, 0.05717783f, -0.11477606f, -0.12361561f, -0.01900667f, 
    0.02997481f, 0.02466068f, 0.07455106f, 0.06909584f, 0.03006241f, -0.01479931f, -0.07974471f, 0.12519416f, 
    0.02739156f, 0.01814593f, -0.07411445f, -0.01958975f, 0.06844417f, 0.07429518f, -0.06699798f, 0.09647542f, 
    0.12362403f, -0.04217520f, 0.09172982f, 0.09667926f, 0.03790529f, 0.05135072f, 0.06398372f, 0.06139062f, 
    -0.01572820f, -0.09657773f, -0.10591050f, -0.18691608f, -0.02773622f, 0.12775172f, 0.08663491f, 0.15681919f, 
    0.05780473f, 0.00379044f, -0.03107272f, -0.00722593f, -0.07776668f, -0.05175303f, 0.08550038f, -0.03478363f, 
    0.05728854f, 0.16983543f, -0.04828893f, -0.00769407f, 0.03321664f, -0.03284866f, 0.04328633f, 0.00891704f, 
    0.04241187f, -0.02664956f, 0.01334493f, 0.04043558f, 0.51986134f, 0.35060272f, 0.19150281f, 0.01404378f, 
    -0.16718899f, -0.21143326f, -0.13159263f, 0.05899452f, -0.05432828f, 0.00543537f, 0.11368941f, 0.10736950f, 
    -0.04879345f, 0.03021249f, 0.07316852f, -0.03671849f, -0.00592327f, 0.07592493f, 0.02434651f, 0.10044126f, 
    0.01393007f, -0.03344223f, 0.01386222f, -0.06016688f, 0.10683889f, -0.06652837f, 0.19112122f, 0.09868208f, 
    -0.10679686f, 0.12816186f, -0.06574000f, 0.03554375f, 0.04787252f, -0.21846864f, 0.01298520f, 0.06413857f, 
    -0.19688109f, 0.08068686f, 0.13561155f, 0.19373524f, -0.09014507f, -0.09688915f, 0.15954673f, -0.01022648f, 
    0.05994998f, 0.01409862f, 0.03131106f, 0.02362239f, 0.22480829f, 0.26720327f, -0.17162491f, 0.05606664f, 
    0.05078933f, 0.10433333f, -0.02781226f, 0.05136928f, 0.06511424f, -0.09281998f, -0.05540932f, -0.02603215f, 
    0.03274002f, -0.05252397f, 0.07732173f, -0.05703807f, 0.05514034f, 0.16335984f, -0.11519168f, -0.01472962f, 
    0.02679692f, 0.00435167f, -0.02042000f, -0.03519518f, -0.18712047f, 0.01662751f, 0.03785929f, -0.18555535f, 
    -0.00261652f, 0.00903197f, 0.08850601f, 0.10597435f, 0.01260206f, 0.13580979f, 0.01159481f, -0.05194125f, 
    -0.12925926f, -0.09618523f, 0.19629225f, 0.18102428f, -0.18811260f, -0.13496041f, -0.06358920f, -0.02227867f, 
    0.07363650f, -0.01468994f, -0.01912573f, -0.00454166f, 0.05131026f, 0.12413884f, -0.03154811f, -0.04733902f, 
    0.06197321f, -0.01003444f, -0.15763582f, -0.01888495f, 0.02066738f, 0.08647098f, -0.27890810f, 0.10317070f, 
    0.17476171f, -0.01919666f, 0.19488688f, -0.08613020f, 0.01566950f, 0.07162670f, -0.11020071f, 0.03678188f, 
    -0.08657973f, 0.13793279f, -0.03288380f, 0.07257465f, -0.21625295f, 0.08540159f, 0.22656898f, 0.09036820f, 
    0.00130871f, -0.18165427f, 0.04759201f, -0.01957237f, -0.03192207f, -0.00828426f, -0.02607954f, 0.07509539f, 
    0.02174023f, -0.25465572f, 0.30836925f, -0.02172983f, 0.03699476f, 0.01966905f, -0.06777798f, 0.18958816f, 
    -0.00568746f, -0.05780691f, 0.06185301f, 0.00951382f, -0.30746773f, -0.27307874f, 0.05582169f, 0.30438083f, 
    0.06168270f, 0.20634215f, 0.02140534f, 0.07749171f, -0.06010270f, -0.03491521f, -0.00610650f, 0.03671410f, 
    -0.12511644f, -0.09371325f, 0.13038352f, 0.22091752f, -0.13089478f, -0.06066815f, 0.01664082f, 0.09062792f, 
    -0.09926248f, 0.02472055f, 0.06187493f, 0.05860845f, -0.09594126f, -0.15172631f, 0.27312678f, 0.06289333f, 
    0.02401338f, 0.01881196f, -0.03357656f, -0.01601803f, 0.04317727f, -0.09460417f, -0.00528211f, -0.05230691f, 
    0.13934223f, 0.02413416f, 0.15708533f, -0.08390917f, 0.09407908f, 0.02834969f, 0.05460892f, -0.00147910f, 
    0.04982320f, 0.02217864f, -0.07080392f, -0.03607259f, 0.08334323f, -0.08074349f, -0.02769526f, 0.07408231f, 
    -0.04298281f, 0.06078613f, 0.08531205f, -0.02965615f, 0.10073857f, 0.05481477f, 0.02320288f, -0.01408808f, 
    0.01475399f, 0.12380874f, -0.00360563f, -0.03130335f, 0.02797912f, -0.03123346f, 0.05873474f, 0.02752942f, 
    -0.05613526f, 0.07520921f, 0.06439542f, -0.05376814f, 0.14000851f, 0.22382651f, -0.06125177f, -0.00123185f, 
    -0.06516107f, 0.03316088f, 0.03285382f, 0.09036770f, 0.12251873f, -0.09558178f, -0.09088333f, -0.04885908f, 
    0.13005905f, -0.06037624f, -0.20371240f, -0.09203818f, 0.05511459f, 0.06984811f, 0.04242599f, -0.01050171f, 
    0.05481156f, 0.00639102f, -0.08590798f, -0.06353933f, 0.25377890f, 0.25651729f, -0.20356405f, -0.05834256f, 
    -0.09315862f, -0.00953175f, 0.14235468f, 0.16426246f, 0.07229416f, 0.18005982f, -0.04041936f, 0.07750400f, 
    -0.02583573f, 0.02529158f, -0.20206486f, -0.08604290f, 0.02601209f, -0.03907318f, 0.07311301f, 0.01498098f, 
    -0.05762753f, -0.00544523f, -0.04789727f, -0.07568736f, -0.14609067f, -0.02321521f, -0.08007201f, -0.06792070f, 
    -0.08233236f, -0.08685594f, 0.08384567f, 0.01446599f, 0.01035758f, 0.11851973f, -0.06419880f, 0.20069249f, 
    -0.00702595f, -0.16953017f, 0.10808940f, -0.07367014f, -0.00500977f, 0.03758907f, 0.07324404f, 0.01977039f, 
    0.15352492f, 0.01329672f, -0.05438887f, -0.06853881f, 0.05537437f, 0.03169110f, -0.06473703f, 0.08867972f, 
    0.03733331f, 0.01689667f, 0.02026401f, 0.02559856f, 0.07406460f, 0.27172929f, 0.14365983f, 0.08149507f, 
    0.13365841f, -0.47356954f, -0.29333413f, 0.07233734f, 0.19911061f, 0.01242379f, 0.18758446f, 0.21392782f, 
    0.18186744f, -0.01126120f, 0.03284523f, 0.04905390f, -0.30432326f, 0.14390543f, -0.14925286f, -0.03438209f, 
    -0.07804275f, 0.00981218f, 0.03990437f, 0.12058550f, 0.04537630f, -0.06480715f, -0.00012863f, 0.02225870f, 
    0.12844233f, -0.04288822f, 0.26039973f, -0.06217955f, -0.00415257f, 0.03780318f, 0.03862184f, -0.08343255f, 
    -0.07669652f, 0.00383191f, 0.04570232f, 0.09528922f, 0.17762749f, -0.23294224f, 0.17069153f, 0.02152194f, 
    -0.00270212f, 0.03247640f, 0.03073745f, 0.00726885f, -0.07173096f, 0.09544438f, 0.20652774f, 0.04090061f, 
    -0.07043183f, -0.07835834f, 0.09249420f, -0.17875436f, -0.03125821f, -0.01170674f, 0.02266927f, 0.06420928f, 
    -0.03910375f, 0.10686987f, 0.07864060f, -0.01954864f, 0.20506328f, 0.07878038f, -0.07367459f, -0.23215136f, 
    0.01151974f, -0.13121712f, -0.06018959f, 0.02815327f, 0.21480304f, 0.06870813f, -0.04366449f, 0.04487019f, 
    -0.28564632f, -0.25653291f, 0.21308099f, -0.09765059f, -0.00226985f, 0.02712766f, 0.08240956f, 0.01771371f, 
    0.07420006f, 0.02379659f, 0.01253271f, 0.10465410f, -0.01476073f, 0.03660924f, 0.42851314f, 0.23511508f, 
    0.11367868f, 0.06491742f, -0.08216954f, -0.16169941f, -0.02383892f, 0.06197890f, 0.08813885f, 0.25798890f, 
    -0.09897786f, -0.05246258f, 0.03091905f, -0.03142986f, 0.19330931f, -0.13444142f, 0.08881544f, -0.01980363f, 
    0.06679338f, 0.07013068f, 0.00959341f, 0.05021680f, -0.10603385f, 0.07621347f, -0.14442067f, -0.21531281f, 
    0.14215453f, 0.03520897f, 0.11366551f, 0.12839705f, 0.02418211f, 0.15034004f, -0.02431461f, -0.07029425f, 
    0.00547529f, 0.03910219f, -0.35939330f, -0.19958544f, 0.12714592f, 0.09347248f, -0.16112798f, 0.19000669f, 
    0.05635422f, 0.04359933f, -0.07725164f, 0.00713923f, -0.43011516f, -0.28202823f, 0.04937254f, -0.04433544f, 
    0.10364220f, -0.02344126f, 0.20410557f, -0.18095110f, 0.04631147f, -0.05447190f, -0.03204601f, 0.09034574f, 
    -0.05945012f, 0.13880751f, -0.07934900f, 0.03675679f, -0.07554782f, -0.00963170f, 0.03261233f, 0.07362742f, 
    0.01742655f, -0.04082819f, -0.00238799f, 0.02059141f, 0.14119068f, 0.18527624f, -0.23575626f, 0.12447842f, 
    0.02236514f, -0.03144072f, 0.09199076f, 0.03434842f, -0.01990388f, -0.11951622f, 0.36333475f, 0.06329855f, 
    0.01269829f, -0.13009080f, -0.24490032f, -0.31534296f, 0.12435966f, -0.09743555f, 0.11939256f, 0.13488096f, 
    0.04745515f, 0.02587419f, -0.02248817f, 0.00727537f, 0.10860845f, 0.04332613f, 0.25875658f, 0.09718312f, 
    0.08677419f, -0.02425096f, -0.06564263f, -0.03023390f, 0.01600713f, -0.09013551f, 0.20057894f, -0.03703206f, 
    -0.05355121f, -0.26791000f, 0.27546740f, -0.04604274f, 0.01053746f, -0.09226114f, 0.02445260f, 0.08704530f, 
    -0.02606510f, -0.09891316f, 0.17669921f, 0.03590442f, 0.13069636f, 0.20021045f, 0.16425045f, 0.13760829f, 
    -0.03126835f, 0.07195614f, 0.03325826f, -0.02880390f, 0.01277097f, 0.13408053f, 0.12098162f, 0.05506017f, 
    -0.12327990f, -0.06791385f, -0.42981932f, 0.07151239f, 0.12859127f, -0.13052855f, 0.08957756f, -0.13026647f, 
    0.04904253f, 0.05359193f, 0.04226170f, -0.05424888f, 0.07029113f, -0.06835463f, -0.29580894f, -0.19690792f, 
    0.07079854f, 0.07592673f, 0.09475939f, 0.10853210f, 0.06323745f, -0.07084006f, -0.05932277f, 0.08388498f, 
    0.08640382f, -0.20834526f, -0.18412238f, -0.31168368f, 0.17440222f, -0.08608412f, -0.07733354f, 0.15763585f, 
    0.06668875f, 0.00276104f, -0.06273735f, -0.00150777f, -0.11693732f, 0.07768905f, 0.18304886f, 0.10149090f, 
    0.02116805f, 0.00000396f, 0.00532254f, 0.01597153f, 0.00871032f, 0.03015285f, 0.10272539f, -0.04702387f, 
    -0.37519783f, -0.11623124f, 0.25269282f, -0.14163905f, 0.05344652f, -0.02423643f, -0.01299137f, -0.01331863f, 
    0.03075171f, 0.03936252f, 0.02201830f, 0.10434175f, -0.32161567f, -0.20413126f, -0.16527604f, -0.15276970f, 
    0.05006153f, -0.02957496f, -0.00735940f, 0.02728977f, -0.03999062f, -0.02705384f, -0.00910815f, 0.04902067f, 
    -0.11635960f, -0.06226487f, -0.07155152f, -0.03069100f, 0.07969428f, 0.01953498f, 0.09283450f, -0.02064214f, 
    0.00156146f, 0.03105622f, -0.05749678f, -0.07178020f, 0.16423209f, -0.04099042f, -0.02872298f, 0.14501183f, 
    0.06692418f, -0.03545668f, -0.05115849f, 0.03819819f, 0.00351798f, -0.01924191f, -0.00569833f, 0.10461812f, 
    -0.02255538f, 0.03731807f, 0.02810472f, 0.01478947f, 0.03739657f, -0.03236454f, 0.01011033f, 0.02314396f, 
    0.00597560f, 0.01205533f, 0.00349522f, 0.02266591f, 0.00109246f, 0.00006809f, 0.02245741f, -0.04071361f, 
    0.04006844f, -0.01143087f, -0.02257725f, -0.02847632f, -0.02619142f, -0.04838401f, 0.00958087f, 0.00873906f, 
    -0.05232817f, -0.02855733f, -0.04767326f, -0.03286387f, -0.00747556f, 0.00887060f, 0.01465492f, 0.03837695f, 
    -0.00601249f, 0.02328561f, 0.00528175f, 0.00969948f, -0.01275667f, -0.01702789f, -0.00726656f, -0.00849012f, 
    0.02365812f, 0.04346659f, -0.01697419f, 0.04212292f, -0.05572688f, -0.03556228f, -0.03855066f, 0.00748217f, 
    -0.03743031f, -0.05120616f, -0.03436881f, -0.03275252f, -0.04790995f, -0.04969995f, -0.01106020f, -0.05581745f, 
    -0.03253736f, 0.03313300f, -0.04162567f, -0.01337593f, -0.03498361f, -0.00093450f, -0.05059827f, 0.04436712f, 
    0.00948123f, 0.02315458f, -0.04124980f, 0.00146969f, -0.00844399f, -0.01035702f, -0.02384012f, 0.02471723f, 
    -0.00543413f, -0.04704453f, -0.01338778f, 0.02360432f, 0.02352432f, 0.03870504f, 0.01754156f, 0.02260973f, 
    -0.00489776f, 0.02983078f, 0.03846264f, -0.03142525f, 0.03274287f, 0.03992940f, -0.00352033f, 0.03857840f, 
    0.02801008f, -0.04428369f, 0.00689405f, -0.01079376f, -0.01987951f, -0.03968287f, -0.05616730f, -0.05469002f, 
    0.04682666f, -0.04051030f, 0.01256180f, 0.04061258f, 0.00401977f, 0.00404728f, 0.02010552f, -0.05575880f, 
    -0.02215335f, -0.03175265f, -0.02190814f, 0.02082247f, 0.04336148f, -0.01197489f, -0.04181195f, -0.02076515f, 
    -0.00865315f, -0.01594846f, -0.05411800f, -0.05041445f, -0.05082517f, 0.00431489f, -0.03039761f, -0.05632600f, 
    -0.02715772f, 0.03049847f, -0.04879990f, 0.03062508f, 0.00281207f, -0.04343324f, -0.02337916f, -0.00531520f, 
    0.03653076f, -0.02593930f, 0.00149404f, -0.02590178f, -0.02377688f, 0.00912999f, -0.04251477f, -0.04093237f, 
    -0.00738048f, -0.00548426f, -0.03316045f, 0.03087760f, -0.00951858f, -0.02887280f, -0.01751558f, -0.03907705f, 
    0.03974153f, 0.02185924f, -0.02083636f, 0.02952489f, -0.04202178f, 0.01479900f, -0.01662573f, -0.04666398f, 
    0.00217184f, 0.03724378f, -0.05338545f, -0.05083934f, -0.05229224f, 0.02404981f, -0.01215640f, 0.04459744f, 
    -0.05482215f, 0.00155864f, -0.04423851f, -0.04239301f, -0.03984256f, 0.02775889f, 0.02284187f, 0.01277125f, 
    -0.04072329f, -0.03052000f, -0.02273145f, -0.01579879f, -0.04095770f, -0.04619676f, 0.02644705f, 0.02424351f, 
    0.01355363f, -0.00348527f, -0.03364363f, 0.03971040f, 0.04206257f, -0.00888911f, -0.01907222f, -0.01137235f, 
    0.01844988f, -0.04930809f, -0.05070114f, 0.01173411f, 0.00527978f, -0.05358723f, -0.00266107f, -0.00711502f, 
    -0.02613228f, 0.00902522f, -0.03310177f, -0.00441234f, 0.03422713f, 0.01611023f, -0.04718592f, 0.00197603f, 
    0.04217601f, 0.01394769f, -0.02924630f, -0.03916151f, -0.05459152f, 0.01702131f, -0.03046599f, 0.03593305f, 
    0.03347355f, -0.02645846f, -0.01434631f, -0.03872523f, 0.02138116f, -0.01600954f, 0.01360495f, -0.01067518f, 
    0.00221349f, -0.01262004f, 0.02824852f, -0.01706675f, -0.00537586f, -0.02486778f, 0.01055819f, -0.04987199f, 
    -0.02550796f, 0.01052057f, 0.00106913f, 0.00164933f, 0.00692578f, 0.02999681f, -0.01784063f, 0.00822564f, 
    -0.04036101f, -0.04759782f, 0.03164931f, 0.01447459f, -0.03605951f, -0.03106453f, -0.05058496f, 0.03569242f, 
    -0.01942024f, 0.00928036f, 0.00088529f, -0.05550486f, 0.00421966f, -0.00056977f, -0.02364544f, 0.00152643f, 
    -0.02109128f, 0.02583335f, -0.05465539f, -0.04462907f, -0.04889432f, -0.01109660f, 0.02990910f, 0.01508065f, 
    -0.05237406f, 0.02183998f, -0.03918913f, 0.02718177f, 0.02666788f, 0.02415988f, -0.01623771f, -0.02194175f, 
    0.02809577f, 0.04122173f, 0.01990918f, 0.01374619f, -0.03666104f, 0.02053258f, -0.01419129f, 0.03140073f, 
    -0.00824906f, 0.04022014f, -0.04520569f, 0.01646997f, -0.02396243f, -0.03088536f, -0.00053028f, 0.03226225f, 
    0.02606182f, 0.00147473f, -0.02555321f, 0.02533834f, 0.03902317f, -0.02154860f, -0.00768905f, 0.04279681f, 
    0.04246340f, -0.02426807f, 0.04048549f, -0.05478328f, 0.01839070f, -0.05645723f, 0.01522884f, -0.01561209f, 
    -0.03523715f, 0.02421551f, -0.00315118f, -0.01648740f, 0.03172407f, -0.01445565f, 0.03591461f, -0.00344224f, 
    -0.01503347f, 0.01891632f, 0.02380146f, -0.05324168f, 0.01052497f, -0.02559668f, 0.01366229f, -0.00158770f, 
    -0.05475069f, 0.04082422f, -0.02406266f, 0.00319672f, -0.02705643f, 0.03243507f, 0.00391667f, 0.01818329f, 
    -0.02661519f, -0.03144469f, -0.02730683f, -0.01120536f, -0.03218879f, 0.01669502f, -0.03007691f, -0.05013564f, 
    0.03443667f, -0.02240615f, -0.05547601f, -0.02695563f, -0.03850933f, -0.02160709f, 0.00738403f, 0.04438325f, 
    -0.05634852f, -0.03135907f, 0.02456027f, -0.04133877f, -0.02080926f, -0.01835872f, 0.02220706f, 0.02533989f, 
    -0.04603954f, 0.04171660f, 0.01805771f, -0.04747484f, -0.04088909f, -0.04176141f, -0.04479284f, -0.00568137f, 
    -0.02803396f, -0.01161870f, -0.00939304f, -0.05203202f, -0.04882350f, 0.02932798f, -0.05306011f, 0.03355637f, 
    -0.04258280f, 0.00577697f, -0.00664213f, -0.00479186f, 0.00820579f, -0.01672450f, -0.05636572f, 0.01368086f, 
    -0.03192595f, -0.02625224f, 0.03805334f, -0.04945645f, -0.02896415f, -0.00471839f, 0.00837709f, 0.03117228f, 
    -0.03660965f, -0.02710554f, 0.02843871f, 0.04174334f, 0.03521974f, 0.02857926f, 0.03206905f, -0.00526015f, 
    -0.12714538f, -0.06434902f, -0.23694743f, -0.35223487f, -0.02521756f, 0.05698801f, 0.05079471f, -0.09320296f, 
    0.00848195f, 0.03061777f, 0.15034516f, 0.09530282f, -0.11696732f, 0.27222788f, 0.07825773f, -0.20380905f, 
    0.08919755f, -0.02620314f, -0.00883908f, 0.01187092f, 0.11070956f, 0.06394477f, 0.11994094f, 0.14770640f, 
    -0.20226051f, -0.43410334f, -0.25435978f, 0.03847045f, -0.10502067f, -0.08960343f, -0.07129588f, -0.07766630f, 
    0.03768357f, -0.01137857f, 0.04278588f, 0.03409150f, 0.11517812f, 0.06510162f, 0.02279990f, -0.08830513f, 
    -0.02921341f, 0.08529814f, 0.15987265f, 0.17724839f, 0.03570269f, 0.02605327f, 0.13203175f, 0.05455592f, 
    0.17987314f, 0.13457261f, 0.12278453f, 0.05760235f, -0.01317321f, 0.04699558f, 0.01359140f, -0.10905018f, 
    0.01205831f, 0.04073175f, 0.01449160f, -0.13604580f, -0.17229301f, -0.03963397f, 0.09780975f, -0.13524729f, 
    0.00090026f, 0.15817022f, 0.24047165f, 0.12288516f, 0.18307678f, -0.00305108f, 0.13932128f, -0.07062586f, 
    0.09580909f, 0.08363319f, 0.08823781f, -0.05395668f, 0.12352848f, 0.00034542f, 0.08003291f, 0.11167452f, 
    0.08668821f, 0.15017560f, 0.00902438f, 0.09127863f, 0.11786113f, 0.29020438f, -0.08406840f, -0.09610339f, 
    0.14770783f, 0.13747816f, 0.37538522f, 0.08644897f, 0.15769206f, 0.01738591f, 0.00976871f, 0.02102130f, 
    -0.10733656f, -0.00981570f, -0.12413538f, -0.13902761f, -0.15127532f, -0.01076899f, -0.13965267f, -0.02884415f, 
    -0.01085210f, -0.02498079f, -0.07331843f, -0.11099040f, 0.03647108f, -0.17325281f, -0.29633224f, -0.17696449f, 
    -0.04418481f, 0.12118574f, 0.01609223f, 0.12742850f, -0.06524712f, 0.12745720f, 0.03357967f, -0.07721241f, 
    -0.01604951f, 0.00807651f, 0.13236293f, 0.12830304f, -0.08879830f, -0.01257753f, -0.09940442f, -0.10696882f, 
    -0.04335744f, -0.06655382f, -0.07155564f, -0.08416218f, 0.00496401f, 0.06851498f, 0.07392272f, -0.13245712f, 
    0.07431523f, 0.07279123f, 0.16405180f, 0.11157838f, -0.05534328f, -0.02438468f, 0.02404197f, -0.13300014f, 
    0.26981014f, 0.24792601f, 0.26455489f, 0.22733527f, 0.14802226f, 0.18028711f, 0.26870805f, 0.07413532f, 
    0.09402575f, -0.03168043f, -0.03834771f, 0.06903773f, -0.25758120f, -0.08841427f, -0.49052307f, -0.49906200f, 
    -0.18284036f, -0.19761485f, 0.02337337f, 0.00909542f, 0.06043510f, 0.15870948f, 0.10832964f, 0.10224918f, 
    -0.12848803f, -0.09910041f, -0.00597369f, -0.06719773f, 0.20761807f, -0.04783303f, 0.13363333f, 0.02795431f, 
    -0.02080915f, -0.10413602f, -0.10918790f, 0.01280122f, -0.19699009f, 0.00855879f, 0.04984619f, -0.05315838f, 
    -0.00583016f, 0.00202210f, 0.09218504f, 0.15201823f, 0.12752438f, 0.15651956f, 0.08395407f, -0.10435095f, 
    -0.40654695f, -0.38775638f, -0.12107162f, -0.17108020f, -0.01052171f, -0.04881556f, 0.07660644f, -0.09626801f, 
    -0.00001844f, -0.03390658f, -0.03645711f, 0.01759664f, 0.17306462f, 0.04026631f, 0.13872015f, 0.14787084f, 
    -0.01002196f, -0.03923254f, 0.19248609f, 0.25842345f, 0.11570297f, 0.01743421f, 0.02618485f, 0.08320256f, 
    -0.05575258f, -0.02365454f, 0.00574853f, 0.00138525f, 0.02895297f, -0.00260911f, 0.04903141f, -0.09506737f, 
    -0.02517721f, -0.13093103f, -0.02154150f, 0.07618649f, 0.09238464f, 0.14535058f, 0.01703858f, -0.05338848f, 
    0.02271347f, 0.06111453f, 0.10631816f, 0.22235966f, 0.16430299f, 0.08438500f, 0.10281009f, 0.07455431f, 
    -0.31298336f, -0.19171485f, -0.19966120f, -0.34013817f, -0.02858628f, -0.07592080f, -0.13484454f, -0.16173342f, 
    -0.13737540f, -0.09636042f, -0.06467705f, -0.08251487f, 0.20047314f, 0.18247201f, 0.18877937f, 0.04848544f, 
    -0.02405342f, 0.03773071f, -0.08563977f, -0.17095478f, 0.10663050f, -0.05929570f, 0.04849575f, 0.19427747f, 
    0.29681042f, 0.17878756f, 0.19020544f, 0.16098513f, -0.04627745f, -0.06327995f, 0.09605113f, 0.00816057f, 
    0.09205541f, 0.05556574f, 0.04731897f, 0.06071547f, -0.19632162f, -0.48887655f, -0.24412753f, -0.30457956f, 
    -0.04399308f, 0.02703383f, 0.06773545f, 0.09495587f, 0.07205753f, 0.00794713f, 0.13711078f, -0.11157638f, 
    -0.15537193f, -0.29807562f, -0.01828825f, -0.42021579f, 0.27845946f, 0.01944739f, 0.18362492f, 0.21137269f, 
    -0.11825392f, 0.01632548f, -0.08314401f, -0.02814638f, -0.02614016f, 0.00531437f, 0.03527990f, 0.09957487f, 
    0.17498079f, 0.30312675f, 0.16746107f, 0.06126271f, -0.08136595f, -0.03655610f, -0.02341208f, -0.02271175f, 
    -0.26080483f, -0.39148203f, -0.04519395f, 0.11798420f, -0.16488379f, -0.05478393f, -0.05305228f, 0.10957325f, 
    -0.01817290f, 0.14207153f, 0.01719688f, 0.08484324f, 0.13880920f, -0.01852730f, 0.46983394f, 0.23656934f, 
    0.04628980f, -0.00235338f, -0.10792531f, -0.08025129f, -0.02506006f, -0.07013193f, -0.04917037f, 0.07164258f, 
    0.21636666f, 0.08020527f, 0.36345243f, 0.17013867f, -0.04378590f, 0.04277698f, 0.03268348f, -0.02940959f, 
    -0.07614947f, 0.04671138f, -0.04411836f, -0.01695804f, 0.31524682f, 0.15111922f, 0.08849493f, 0.16169670f, 
    -0.02786815f, -0.02024565f, 0.01296399f, -0.07328994f, -0.03071173f, -0.06071648f, -0.08651768f, -0.12374164f, 
    0.06197916f, -0.00090302f, 0.00948255f, 0.01492790f, 0.08861248f, 0.06777529f, 0.03080296f, -0.02382087f, 
    -0.08916352f, -0.06312384f, -0.04165110f, -0.09305158f, 0.00042530f, -0.02072937f, 0.12156839f, -0.19433951f, 
    0.04424325f, 0.13871634f, -0.03537143f, -0.02512938f, 0.00669472f, -0.02074035f, 0.03002755f, -0.06956759f, 
    0.04641164f, 0.15790848f, 0.17418464f, -0.00634582f, 0.04803230f, 0.02094849f, 0.12125374f, 0.01704658f, 
    0.07593305f, 0.05940336f, 0.00038978f, -0.03762595f, 0.01897412f, 0.14648145f, 0.04473178f, 0.04661128f, 
    -0.07977949f, -0.15571548f, -0.04858303f, 0.02201841f, 0.11884174f, 0.03328236f, 0.10724016f, 0.01418318f, 
    0.00408623f, 0.10692361f, 0.29098311f, 0.17369227f, 0.05784255f, 0.07578726f, -0.04730179f, 0.26466951f, 
    0.03085518f, -0.05922723f, 0.02891354f, 0.06749681f, -0.06791754f, 0.26589045f, 0.08096209f, -0.00534993f, 
    -0.02789469f, 0.02947362f, 0.10129064f, 0.09664091f, 0.10661906f, 0.06867296f, 0.04057464f, 0.06273456f, 
    0.02722045f, -0.09294567f, -0.01257468f, -0.11515287f, 0.01966465f, 0.05709753f, -0.09352097f, -0.04043270f, 
    0.04162842f, -0.00084107f, 0.00881883f, -0.03636914f, -0.14018503f, 0.08186715f, 0.02357393f, 0.04691938f, 
    -0.03096759f, 0.08220886f, 0.00570060f, 0.04721529f, 0.11507657f, 0.02150080f, 0.12027491f, 0.03171859f, 
    -0.04006977f, 0.07013594f, 0.13005087f, -0.04071396f, 0.16146252f, 0.09773292f, 0.00704695f, 0.02590748f, 
    -0.06286059f, -0.01474515f, -0.04669634f, 0.01999763f, -0.19238509f, 0.32743436f, -0.27414238f, 0.03295633f, 
    0.01902094f, -0.11611407f, -0.03909846f, -0.17262869f, -0.05512294f, 0.09707665f, -0.08166058f, 0.04486959f, 
    0.09804682f, -0.12188831f, 0.10615063f, 0.05032321f, 0.08362895f, -0.03725358f, -0.08039478f, -0.14661691f, 
    -0.12181067f, 0.07169565f, 0.14893620f, -0.02016055f, 0.09450062f, -0.07688538f, 0.17531216f, 0.11287419f, 
    -0.01013078f, 0.03245834f, -0.14899957f, -0.10434016f, -0.01338121f, 0.09358100f, -0.03010615f, 0.10937966f, 
    -0.00352906f, 0.05407384f, -0.06726035f, 0.05008192f, -0.00826581f, 0.03554445f, 0.01288495f, 0.02539741f, 
    -0.03535584f, -0.01622449f, -0.04772989f, -0.01925387f, -0.02590448f, 0.26281247f, -0.16778642f, -0.05109153f, 
    0.00218493f, 0.08075316f, 0.17088896f, 0.19790779f, -0.05336876f, 0.02629440f, 0.07368356f, -0.11370176f, 
    -0.00267947f, 0.11033545f, -0.03413110f, 0.08291059f, -0.04060157f, 0.06077672f, 0.08571504f, 0.04193160f, 
    0.08377890f, 0.06752136f, 0.01277468f, -0.03473857f, 0.07203025f, -0.10780786f, -0.27413285f, -0.36512837f, 
    -0.08370743f, -0.12798570f, -0.15821771f, -0.14011399f, 0.01755162f, -0.00449157f, 0.07708462f, 0.18760382f, 
    0.10475548f, 0.05264857f, 0.12029457f, -0.03101253f, 0.18270953f, -0.10755837f, 0.01003109f, 0.06995334f, 
    0.03731921f, 0.01284895f, -0.03727195f, -0.01221162f, -0.17213720f, 0.22153637f, -0.04500056f, -0.06624847f, 
    0.04038370f, -0.00576904f, -0.01706666f, 0.19422808f, -0.07767652f, 0.15662858f, 0.07482941f, -0.02463457f, 
    -0.10744650f, -0.36402386f, -0.13419293f, -0.16606031f, -0.01751612f, 0.07872767f, -0.01335981f, 0.00096924f, 
    0.10050709f, 0.01619248f, -0.01300207f, 0.04768946f, 0.19803859f, 0.00139131f, 0.08632419f, 0.23251374f, 
    -0.02478973f, 0.04333733f, 0.06059821f, 0.14059602f, -0.00345182f, 0.08034476f, 0.10958289f, 0.12025076f, 
    0.02055423f, -0.01691172f, -0.07474913f, -0.06901333f, 0.03829784f, -0.03331058f, -0.07023394f, -0.07083238f, 
    -0.17983721f, 0.03695783f, 0.00554875f, 0.07754971f, -0.04066278f, 0.33201009f, -0.26503116f, -0.10956542f, 
    0.00204592f, -0.22799665f, 0.10564160f, 0.00214050f, -0.04623922f, 0.03001244f, 0.01124693f, 0.02358061f, 
    0.02324593f, 0.09450755f, 0.06456421f, -0.15167324f, 0.07671165f, -0.03354966f, 0.01333319f, 0.05038697f, 
    0.02241891f, -0.00044844f, 0.03014905f, 0.01821975f, 0.01603029f, -0.02338161f, 0.04479391f, -0.08120695f, 
    0.03415786f, -0.00676239f, -0.15947881f, -0.09150840f, -0.12671152f, 0.04670665f, -0.19007665f, 0.15964217f, 
    0.14627081f, 0.03632024f, 0.11410138f, 0.11226535f, 0.00480430f, 0.01811155f, -0.02292687f, 0.01229863f, 
    -0.00224062f, 0.06246875f, 0.01033687f, -0.02857971f, 0.14313687f, -0.11697175f, 0.01212254f, -0.22139736f, 
    -0.00798030f, -0.09764522f, -0.00555345f, 0.10469683f, 0.00265642f, -0.00155233f, 0.09388161f, 0.02764173f, 
    -0.13591759f, 0.04759064f, 0.14460719f, -0.26161954f, 0.15155071f, -0.08344256f, 0.14580627f, 0.11833770f, 
    -0.07188105f, 0.03052466f, 0.04279201f, -0.03923691f, -0.00108693f, -0.21268114f, -0.27726930f, -0.06946474f, 
    0.06136705f, -0.10341343f, 0.01429085f, 0.07095787f, 0.07425927f, 0.04727378f, 0.05276782f, -0.03524815f, 
    0.18414226f, -0.06534567f, 0.08559132f, 0.16050155f, -0.06700005f, 0.11253478f, -0.11133433f, 0.12353574f, 
    -0.12439794f, -0.04088666f, 0.01238033f, -0.07831787f, -0.03844501f, 0.11517298f, 0.24929385f, -0.01473381f, 
    -0.01491321f, 0.00748643f, -0.02533228f, -0.06824452f, 0.01278953f, -0.05692639f, 0.03865577f, -0.01369045f, 
    0.15997151f, 0.00324682f, 0.22391462f, 0.12748612f, -0.03701032f, -0.06095150f, 0.03402353f, 0.06737947f, 
    0.08502391f, 0.00989404f, 0.02987172f, -0.04599811f, 0.10188265f, 0.00255263f, -0.09150696f, 0.03968443f, 
    0.03291499f, 0.00435910f, 0.00485767f, -0.01185203f, 0.07555626f, 0.09682377f, 0.03752210f, 0.02670447f, 
    0.03672987f, -0.02181752f, -0.03512287f, -0.01362835f, -0.03681348f, 0.00997764f, -0.02494312f, -0.02908518f, 
    0.10842600f, -0.01710759f, -0.03944292f, -0.09426267f, 0.12219522f, 0.06600963f, 0.08482254f, 0.05849551f, 
    -0.00012409f, -0.12011065f, 0.03430689f, 0.05656798f, 0.06991889f, -0.11696514f, 0.03358591f, -0.02471938f, 
    0.08566101f, 0.23501401f, -0.06702724f, 0.00107274f, 0.06036062f, -0.02465243f, 0.11045213f, 0.05894646f, 
    0.04134995f, -0.00329022f, -0.05907250f, 0.02615776f, -0.36304283f, 0.43680114f, 0.12223621f, 0.00800687f, 
    -0.00073727f, -0.02277417f, 0.00153320f, 0.00721084f, 0.04088590f, 0.01381981f, 0.10952380f, 0.02931470f, 
    0.15574993f, -0.02344063f, -0.14032705f, 0.08736168f, 0.02939261f, -0.01739536f, 0.02047820f, 0.16386414f, 
    0.00549427f, -0.04327633f, -0.02061846f, 0.08793546f, -0.03344456f, 0.14813535f, -0.01943817f, -0.04513957f, 
    -0.05783380f, 0.04452342f, 0.00853136f, 0.06197940f, 0.01046913f, -0.07842889f, 0.05975775f, 0.24363174f, 
    0.17056528f, -0.10935606f, 0.02040110f, 0.00270966f, -0.03107782f, 0.07427978f, 0.02297400f, -0.06442974f, 
    -0.01669245f, 0.04434991f, 0.01526253f, -0.06519600f, -0.16134696f, -0.09241289f, 0.01038994f, -0.03530902f, 
    -0.01892550f, 0.08372921f, 0.03076632f, 0.14402947f, -0.01330748f, 0.05637899f, 0.10781462f, 0.14725402f, 
    0.03579776f, 0.06119386f, -0.07169911f, 0.23159693f, 0.10474331f, -0.05574739f, -0.00234597f, -0.21927395f, 
    -0.04406159f, -0.07244093f, 0.01687047f, 0.04254135f, 0.01712444f, 0.00662618f, 0.35126412f, -0.01769649f, 
    0.01860539f, -0.15793483f, 0.15240476f, -0.02574677f, 0.04502789f, -0.00230089f, 0.02287144f, 0.01014244f, 
    -0.22096527f, 0.05528204f, 0.16995585f, 0.35099146f, 0.15442641f, -0.10439771f, 0.01507971f, -0.12226604f, 
    -0.04358455f, 0.05290027f, 0.07735242f, -0.07734326f, 0.11823338f, 0.09468976f, -0.00873172f, 0.22957632f, 
    0.02466818f, 0.04169036f, -0.10872248f, -0.05758822f, -0.03335921f, -0.06261225f, -0.01403018f, 0.12457255f, 
    0.04226183f, -0.12379260f, 0.01442690f, 0.04152170f, -0.11900623f, 0.15058737f, 0.05998093f, -0.02304594f, 
    -0.06458756f, -0.01537711f, 0.04173476f, -0.09585854f, 0.06038625f, 0.16188595f, -0.08889228f, -0.20857047f, 
    -0.02725516f, -0.02195872f, 0.00886943f, 0.12442901f, -0.08275487f, 0.06628787f, -0.12867655f, 0.05994701f, 
    0.29365927f, -0.10131345f, 0.16976064f, -0.04964394f, -0.03443511f, 0.09321454f, 0.03942991f, 0.09678697f, 
    0.09022401f, 0.07913209f, 0.09369113f, 0.19172688f, 0.14232448f, 0.33788091f, 0.06764387f, -0.14983644f, 
    -0.04233225f, -0.05810447f, -0.12910973f, 0.01206886f, -0.20069835f, -0.03933630f, -0.06304727f, -0.01848032f, 
    0.16108553f, 0.03298447f, -0.13244365f, 0.09238762f, 0.11984762f, 0.04197106f, 0.06665803f, 0.09063940f, 
    -0.01770237f, -0.11291396f, -0.16031906f, -0.13706985f, 0.06094876f, -0.03949076f, 0.00413227f, -0.07303938f, 
    0.03200648f, 0.15132381f, 0.05591931f, 0.09425696f, -0.01841218f, -0.03885336f, 0.09192969f, 0.07821814f, 
    0.22837889f, 0.02610394f, 0.10321254f, -0.20367590f, -0.02048264f, 0.09886713f, -0.02694240f, 0.12029819f, 
    0.04042441f, -0.10862002f, -0.02020051f, -0.01983989f, 0.32564455f, -0.07571933f, 0.15288922f, -0.10246202f, 
    -0.07110185f, -0.09618598f, 0.03692146f, 0.09485232f, 0.15992445f, 0.30249113f, -0.08754444f, 0.03621573f, 
    -0.16266741f, -0.18723087f, 0.02087415f, -0.04977522f, 0.11013592f, -0.06923725f, 0.02198787f, 0.04683593f, 
    0.05227746f, -0.05811343f, 0.02123895f, -0.06032879f, 0.08518391f, -0.11002663f, 0.23718782f, -0.14152363f, 
    -0.01959590f, 0.06722347f, 0.12800910f, -0.02424214f, 0.01097598f, -0.01118976f, -0.03464711f, 0.10246155f, 
    0.05372394f, 0.26254871f, 0.07254853f, -0.01037742f, -0.04005284f, -0.00895460f, -0.02859626f, -0.07556210f, 
    -0.07859802f, -0.04390888f, -0.06754270f, -0.13494845f, -0.22593319f, -0.07814001f, 0.19209820f, 0.13986401f, 
    0.11409139f, -0.06004516f, -0.18247275f, -0.12951607f, 0.08000599f, -0.02482401f, -0.06844475f, 0.12651820f, 
    0.30762327f, -0.11988458f, -0.04768771f, 0.08229931f, -0.16864030f, -0.07286311f, -0.00023918f, 0.00766560f, 
    0.09762143f, 0.04100189f, 0.00447613f, 0.03536136f, 0.26893443f, 0.18052144f, 0.15199517f, 0.01681302f, 
    0.12019905f, -0.00646887f, 0.03746734f, -0.01365685f, 0.02865416f, 0.10876510f, 0.07866061f, 0.12076814f, 
    -0.10568654f, -0.11498228f, -0.32103515f, 0.10937655f, -0.15263973f, -0.04692010f, -0.00727417f, 0.23585933f, 
    -0.11633821f, -0.01652828f, 0.02329017f, -0.01390116f, -0.36868840f, 0.21437445f, -0.18315399f, 0.03338498f, 
    0.21354975f, -0.05946252f, -0.00688963f, -0.01143611f, -0.03200114f, -0.01478164f, -0.06465663f, 0.00190960f, 
    0.07510814f, 0.02662785f, -0.08460592f, 0.14424202f, -0.09726001f, 0.05080187f, -0.08783540f, 0.09626092f, 
    -0.03604161f, -0.03329425f, -0.04157792f, 0.06587231f, -0.01562829f, -0.13129979f, 0.15910371f, 0.15777627f, 
    0.03244992f, 0.01876601f, 0.01170981f, -0.07869149f, -0.07968272f, -0.11141131f, 0.02186879f, -0.01202859f, 
    0.22595982f, -0.07657593f, -0.18354130f, 0.06267081f, -0.10504878f, -0.01757158f, -0.00586408f, 0.10342468f, 
    -0.05961421f, -0.08573244f, -0.11489832f, 0.08965860f, 0.22253653f, -0.06221591f, -0.06383556f, -0.00870150f, 
    -0.13310678f, 0.02917379f, 0.00513206f, 0.00036624f, 0.08415692f, 0.07060282f, 0.10789281f, -0.05660962f, 
    0.00068970f, -0.15125346f, -0.05622000f, -0.05481891f, 0.02287679f, 0.06707875f, 0.02852799f, 0.03789495f, 
    -0.00141544f, 0.02430917f, -0.14430480f, -0.23710662f, -0.15417422f, 0.10947552f, 0.11125672f, 0.25739604f, 
    0.05463199f, 0.02284106f, -0.00335780f, -0.06126630f, -0.09438881f, -0.04089444f, 0.04723910f, -0.11034025f, 
    0.01486515f, 0.01869319f, 0.00645533f, -0.00635140f, -0.01135148f, -0.02587974f, -0.03794948f, 0.03915045f, 
    -0.00861346f, 0.02613670f, -0.01161784f, 0.01051068f, -0.03265541f, -0.02233096f, -0.00681349f, -0.01331997f, 
    0.04463350f, -0.02521851f, -0.01211220f, -0.05200780f, 0.03203271f, -0.04480447f, 0.04280266f, -0.03813110f, 
    0.02356993f, -0.01943343f, 0.02597870f, -0.04106729f, 0.01050762f, -0.02026251f, -0.03630875f, -0.04757874f, 
    0.04582252f, -0.03508317f, 0.04239681f, 0.01024993f, -0.04783243f, -0.03433259f, 0.03111445f, 0.03847487f, 
    -0.02406714f, 0.02336666f, -0.00239581f, -0.01122912f, -0.04780184f, -0.03641338f, -0.02686268f, -0.01847213f, 
    -0.00957910f, -0.00070097f, -0.02107145f, 0.03623815f, 0.01048343f, -0.05393375f, -0.02309292f, -0.04957585f, 
    -0.03198145f, 0.04078778f, -0.00973331f, 0.01446118f, 0.01148464f, 0.02847480f, 0.00507955f, -0.03243067f, 
    0.01928862f, -0.03708733f, 0.03099907f, -0.00064124f, -0.01527568f, -0.04619359f, 0.01291523f, -0.01766725f, 
    0.02162764f, -0.02393663f, 0.04238975f, 0.00301112f, 0.00714624f, 0.01503282f, 0.03858297f, 0.00825800f, 
    -0.00280640f, 0.03442651f, -0.05556520f, -0.01579841f, 0.02268619f, -0.00967809f, 0.01826735f, 0.02651670f, 
    0.02022386f, 0.03393321f, 0.03765858f, -0.01575468f, -0.03192712f, 0.00708682f, -0.03518746f, -0.02576620f, 
    -0.03535242f, -0.02634659f, -0.04141127f, -0.05270220f, 0.01529309f, -0.02391496f, -0.02063951f, -0.04628795f, 
    -0.03378075f, -0.00106929f, -0.02193977f, -0.02448503f, 0.04437073f, -0.00671201f, 0.01310900f, 0.02091229f, 
    -0.02912518f, -0.01799700f, 0.01552122f, -0.05160510f, -0.04467976f, 0.04387765f, -0.04018785f, -0.04296611f, 
    -0.02567690f, 0.04516293f, -0.04287617f, 0.03129080f, 0.03853413f, 0.02058179f, 0.00832403f, -0.03310426f, 
    -0.02322574f, 0.00481061f, -0.00914669f, -0.04701312f, -0.04697930f, -0.03413244f, -0.04432461f, -0.02228481f, 
    0.02207244f, 0.04103966f, 0.01110506f, -0.05150196f, -0.04951453f, -0.02606077f, 0.00058927f, 0.02204895f, 
    -0.04880789f, -0.01495913f, 0.00675283f, -0.01970998f, -0.05601358f, -0.01113291f, 0.03058368f, -0.01781662f, 
    0.04052632f, 0.00806461f, -0.03230366f, -0.05044599f, -0.03715301f, -0.01577915f, -0.05019203f, -0.02832434f, 
    0.03703674f, -0.02800806f, -0.05302488f, 0.04161236f, -0.04087079f, -0.02043110f, -0.05220168f, 0.03354909f, 
    -0.05038325f, -0.00170193f, -0.02066504f, 0.02404525f, -0.05038764f, -0.04607398f, 0.01198935f, -0.02670370f, 
    -0.02597144f, 0.03052902f, -0.01431335f, -0.00059928f, -0.01020201f, -0.02482118f, 0.02148254f, 0.02713987f, 
    -0.04026721f, -0.03067757f, -0.04868022f, 0.04104175f, 0.00509867f, -0.04138206f, -0.01798298f, -0.02529996f, 
    -0.00968005f, 0.02128691f, -0.02842967f, 0.03095550f, 0.01313901f, -0.01977255f, 0.02967680f, -0.01507916f, 
    -0.02651752f, -0.00925660f, -0.05632313f, 0.02871964f, 0.04087220f, -0.02402509f, -0.02889800f, -0.00859952f, 
    -0.00502054f, 0.01781691f, -0.00253813f, 0.02157794f, -0.02506744f, -0.03058393f, 0.01184068f, 0.01784339f, 
    0.01672583f, 0.03999148f, 0.00716658f, 0.01400541f, 0.01697790f, -0.02641142f, 0.00451837f, -0.05405347f, 
    0.01241078f, -0.03662333f, -0.02909882f, 0.03644349f, -0.02404088f, -0.04586253f, 0.01662444f, -0.03855458f, 
    -0.00246565f, -0.01018812f, 0.03566048f, -0.04041168f, 0.00891584f, -0.02690385f, 0.02440050f, 0.01964070f, 
    -0.05032795f, -0.04643076f, 0.00531039f, 0.04553911f, -0.03078309f, -0.04102282f, -0.01273418f, -0.05584176f, 
    -0.03730429f, 0.03037876f, 0.04465219f, -0.00203336f, 0.01433817f, 0.01049754f, -0.05066913f, 0.00036499f, 
    0.02129797f, 0.01536925f, -0.05413924f, 0.01125184f, 0.02258024f, 0.00683565f, -0.04732604f, -0.00070193f, 
    0.02826469f, 0.01874705f, -0.04021462f, -0.04485346f, 0.00720687f, 0.00687251f, -0.02946949f, -0.04975090f, 
    0.02407116f, -0.04744804f, -0.03305330f, -0.04365668f, -0.01564911f, -0.05050031f, 0.04194868f, 0.01014132f, 
    -0.01448054f, -0.05177955f, 0.04508875f, 0.01000936f, 0.02681076f, -0.03577226f, -0.03939468f, -0.02428480f, 
    0.00089998f, 0.03125220f, -0.00566664f, 0.00830816f, 0.00635229f, 0.02838773f, -0.01359780f, -0.02383280f, 
    0.00396522f, 0.02192459f, 0.03840747f, -0.00292564f, 0.03880818f, 0.01513733f, 0.02525074f, -0.05181212f, 
    0.00283136f, 0.03596880f, -0.03518735f, -0.04648707f, -0.01137538f, 0.00060378f, -0.03470661f, -0.02050092f, 
    -0.03078153f, 0.01805011f, -0.01543847f, -0.00991610f, -0.02005300f, 0.02633531f, 0.00828958f, -0.03529461f, 
    -0.01050501f, 0.01445579f, -0.03794882f, 0.03469507f, 0.04102521f, -0.00220178f, 0.04431037f, -0.03303450f, 
    -0.01892007f, -0.04045177f, -0.03181923f, -0.00332970f, -0.02584027f, -0.02418648f, -0.04685478f, -0.00318857f, 
    -0.01802236f, -0.01296728f, -0.00343345f, 0.04245115f, 0.01448188f, 0.03589264f, -0.02896910f, -0.02241378f, 
    0.04183351f, -0.04089192f, 0.00436980f, 0.00712246f, 0.02818672f, 0.01703664f, 0.03520271f, 0.00609167f, 
    0.01551104f, -0.05073486f, -0.05239338f, 0.02922314f, -0.02654914f, -0.00513593f, 0.00351569f, -0.01912545f, 
    0.03623343f, 0.02384735f, -0.02103595f, 0.01396137f, 0.01306850f, 0.04316230f, -0.01501973f, 0.02793106f, 
    0.00305084f, 0.04037077f, 0.04089741f, 0.03826261f, -0.03474326f, -0.03130036f, -0.01228757f, -0.02581200f, 
    -0.05638752f, 0.03582515f, -0.03743822f, -0.03677432f, 0.00605657f, -0.01824805f, -0.02383531f, -0.04989812f, 
    -0.00138881f, -0.00326877f, -0.02042253f, 0.01368369f, -0.02251403f, -0.01594491f, 0.02399343f, 0.00184424f, 
    0.04139292f, -0.03651006f, 0.01357678f, 0.03961920f, 0.04098569f, -0.03226249f, 0.01967468f, -0.01314527f, 
    -0.02304356f, 0.02329231f, -0.00671294f, 0.04425609f, 0.02205361f, -0.04977908f, -0.00485250f, -0.00147409f, 
    0.00355429f, -0.03801979f, 0.02732875f, 0.03584718f, 0.01887961f, 0.03463415f, -0.03023855f, 0.00313894f, 
    0.04502889f, 0.04291921f, -0.03809765f, -0.04193586f, 0.03262945f, -0.04138584f, -0.05373870f, 0.00799933f, 
    0.00981254f, -0.01092861f, -0.04596196f, -0.03078108f, -0.01508636f, -0.03173164f, 0.02634493f, -0.03106082f, 
    -0.05262939f, -0.04261374f, -0.04608119f, 0.03644659f, 0.02008995f, -0.00705926f, 0.02104036f, -0.02725843f, 
    0.04307291f, -0.05071303f, 0.02912016f, -0.03451952f, -0.02043779f, 0.02505011f, 0.01562377f, 0.03203104f, 
    0.02720856f, 0.01147150f, -0.01837883f, -0.04998766f, -0.01991291f, -0.05337106f, 0.02385116f, 0.02465991f, 
    -0.01646084f, 0.01878219f, 0.00097798f, 0.02564091f, 0.02935258f, 0.01871100f, 0.03082849f, -0.02467440f, 
    -0.02915253f, 0.01107445f, -0.00981099f, 0.01971230f, -0.02951439f, -0.00783624f, -0.03011442f, 0.01483977f, 
    -0.03956810f, -0.01921062f, -0.00256446f, 0.00319844f, -0.00050396f, 0.02051939f, -0.04052893f, -0.03673013f, 
    -0.03733195f, -0.02345448f, -0.01295780f, 0.01952086f, 0.00427988f, -0.05435156f, -0.01126093f, -0.00127635f, 
    -0.04487548f, 0.00952765f, -0.00882142f, 0.02999943f, -0.01973932f, -0.03637547f, 0.00146403f, 0.01108774f, 
    -0.01514959f, -0.01373617f, 0.03875929f, 0.00539923f, 0.00429858f, -0.03757120f, 0.02049855f, 0.03019508f, 
    0.01810221f, -0.01685363f, -0.02401501f, 0.01118092f, 0.02864110f, -0.04550301f, -0.00396953f, -0.02358653f, 
    0.00859339f, -0.00237292f, 0.03594334f, -0.04146235f, -0.05661508f, -0.02033722f, -0.02053891f, -0.03605734f, 
    0.03077132f, -0.04585215f, -0.00691671f, 0.03176749f, -0.04570420f, -0.04815993f, 0.02324145f, -0.01123095f, 
    -0.02987729f, -0.05229907f, -0.05306968f, -0.04644084f, 0.04288799f, -0.01074616f, -0.03893349f, 0.01491992f, 
    -0.03904460f, -0.00477110f, -0.01164494f, -0.05921912f, 0.04152183f, 0.00541324f, 0.01993293f, -0.00406169f, 
    0.03187756f, -0.02357392f, 0.03352749f, 0.00691423f, 0.03175453f, 0.01907595f, -0.02502499f, 0.04360117f, 
    -0.03508026f, 0.01646963f, 0.04465634f, -0.05036383f, 0.02412864f, -0.00375322f, -0.02712221f, 0.01246124f, 
    -0.03805615f, 0.03191024f, 0.02198123f, -0.00345422f, 0.02914456f, 0.04069865f, 0.01604730f, -0.02344891f, 
    -0.02557693f, -0.02171386f, -0.00609764f, -0.04887154f, -0.03559741f, 0.04124969f, 0.00291836f, 0.02492791f, 
    -0.00319974f, -0.05315020f, 0.01718603f, -0.03491638f, -0.05176981f, -0.05413873f, 0.01692430f, 0.02318993f, 
    0.00030910f, -0.01162077f, -0.02113981f, -0.03064262f, 0.03726121f, -0.02688877f, 0.04304211f, 0.04188346f, 
    0.02389652f, -0.03552803f, -0.03779216f, 0.01650106f, -0.05374347f, -0.00378376f, -0.05712837f, 0.02879292f, 
    -0.03438983f, -0.03516008f, -0.02951810f, 0.02552315f, 0.01935298f, 0.04652037f, 0.03666091f, 0.04274814f, 
    0.01524689f, -0.00668259f, 0.01224404f, -0.05273947f, -0.00963278f, 0.01110637f, -0.00190049f, -0.00373458f, 
    -0.01030232f, -0.03553152f, -0.03753898f, 0.04571971f, -0.03224355f, -0.03164115f, 0.03514467f, -0.01619903f, 
    0.01641822f, -0.04087302f, 0.01536119f, 0.02306710f, 0.02676060f, -0.00151967f, 0.01192376f, 0.01122010f, 
    0.02967068f, -0.00787446f, -0.01210017f, -0.00919548f, -0.04903165f, -0.02054334f, -0.04969266f, 0.02875348f, 
    -0.01366954f, 0.00606041f, -0.05561825f, -0.04715689f, 0.00787446f, 0.02971777f, 0.00282038f, -0.01455638f, 
    -0.00772608f, -0.02194479f, -0.05358183f, -0.02772594f, 0.04286505f, -0.03574350f, -0.05390105f, 0.02436054f, 
    0.00647157f, -0.05657556f, -0.01535408f, -0.01255924f, -0.02197813f, 0.00634082f, 0.02188412f, 0.04392364f, 
    0.02501628f, -0.02727945f, -0.03798113f, 0.04041553f, 0.01689672f, -0.00912244f, -0.04141612f, 0.00581845f, 
    0.03329022f, -0.04764381f, -0.00973987f, 0.02386482f, -0.01283096f, 0.00654043f, 0.03278800f, 0.02474668f, 
    -0.05405531f, -0.03824833f, -0.00513228f, -0.00307405f, -0.02287472f, -0.04486745f, -0.02369941f, 0.01905448f, 
    0.00262212f, -0.03699482f, -0.01592877f, 0.03671478f, -0.01038980f, -0.04411383f, -0.03258488f, -0.02985041f, 
    -0.03819400f, -0.02985924f, -0.01632641f, -0.01593493f, -0.04502311f, 0.00685212f, -0.01174703f, -0.03589968f, 
    0.00226637f, 0.01467552f, -0.01717291f, -0.04243536f, -0.02198165f, -0.04096030f, 0.02574722f, -0.04251853f, 
    -0.04859836f, -0.01578968f, 0.02718547f, 0.03523280f, -0.04907920f, 0.03568686f, 0.03336698f, -0.05570978f, 
    -0.03310504f, -0.03965852f, -0.04032354f, 0.02210445f, -0.01669470f, -0.04677003f, -0.04171160f, 0.02662820f, 
    -0.01751043f, 0.02142846f, -0.03440235f, -0.00610939f, -0.02948749f, -0.01612756f, 0.04644426f, 0.00751712f, 
    -0.04629807f, -0.04502453f, 0.01738277f, 0.01807900f, 0.04414596f, 0.03829645f, -0.01841033f, -0.04024340f, 
    0.00505062f, -0.00545434f, -0.03577282f, -0.02073808f, -0.03240595f, -0.01484210f, -0.02184748f, 0.02128730f, 
    -0.02652531f, -0.00338243f, -0.04727475f, 0.03214740f, 0.04024883f, -0.05513250f, -0.00857191f, 0.01390951f, 
    -0.01988121f, 0.01119217f, 0.03644921f, -0.04196198f, 0.03721097f, -0.01486996f, -0.05048295f, 0.04452130f, 
    -0.19935746f, -0.26629135f, 0.05913252f, 0.05025329f, -0.04352349f, -0.11319847f, -0.16998726f, 0.10545433f, 
    -0.05248316f, 0.02113830f, 0.02711121f, 0.12793399f, 0.04595919f, -0.16671978f, -0.17911279f, 0.46848762f, 
    -0.12838705f, 0.01925801f, -0.15251492f, -0.07422870f, 0.02688034f, -0.00903479f, -0.12980014f, 0.05188138f, 
    -0.32556885f, -0.08282961f, 0.22674042f, 0.05851886f, 0.13076904f, 0.07555889f, -0.04721290f, 0.00603484f, 
    -0.04900389f, 0.07121452f, 0.12227113f, 0.08945742f, 0.19960043f, 0.09733398f, 0.11427329f, -0.11539816f, 
    0.00882261f, -0.04087159f, 0.09155143f, 0.01225955f, 0.04865129f, -0.07729409f, 0.05937823f, 0.02928883f, 
    0.03010950f, -0.13734546f, -0.22410670f, -0.20015258f, 0.02295347f, 0.02254129f, -0.03319842f, 0.02096001f, 
    0.10735697f, -0.00725097f, -0.01238788f, 0.02515032f, -0.07214530f, 0.04718174f, -0.06575027f, 0.21548104f, 
    0.02958429f, -0.18250607f, 0.01383090f, 0.03016211f, 0.17440277f, -0.07340011f, -0.03024301f, 0.06199574f, 
    -0.01739682f, -0.45007849f, 0.08202671f, -0.30205852f, 0.04060860f, 0.16537873f, -0.02440558f, 0.10444502f, 
    -0.04183974f, 0.09025840f, 0.06911807f, 0.02397924f, 0.00974083f, 0.13873206f, -0.45638615f, -0.00905562f, 
    0.10424931f, 0.07676531f, -0.03062802f, -0.13679990f, -0.01242784f, 0.13541645f, -0.07201476f, -0.07020439f, 
    -0.09737626f, 0.00127253f, 0.18107386f, 0.05875038f, -0.06593511f, -0.12150614f, -0.07476730f, 0.06194445f, 
    -0.01069882f, -0.02991315f, -0.02666999f, -0.03107875f, -0.31244472f, -0.05505496f, 0.25776115f, 0.04747205f, 
    -0.00702064f, -0.14067215f, 0.03793421f, 0.12090719f, 0.14176595f, 0.07111491f, -0.03780079f, 0.21806590f, 
    0.12393972f, -0.01657933f, -0.07388010f, 0.01175984f, 0.17854926f, -0.00382678f, 0.02582349f, 0.04289949f, 
    0.07732566f, -0.08618728f, -0.02941881f, -0.00027191f, 0.08627015f, 0.15199612f, -0.06867549f, 0.02152510f, 
    0.01045113f, -0.02265262f, 0.07780036f, -0.07119209f, 0.12987179f, 0.03509402f, 0.08199539f, -0.08640804f, 
    0.05629280f, -0.03208915f, -0.28355324f, -0.12837328f, 0.14448506f, -0.04089146f, 0.14104281f, 0.02896382f, 
    0.04483430f, -0.10196472f, -0.03106725f, -0.04387751f, 0.05741853f, 0.14949062f, 0.37747365f, 0.18630624f, 
    -0.06104511f, -0.07780522f, -0.14703315f, -0.07195814f, 0.17432825f, 0.04681550f, 0.05769972f, 0.12181638f, 
    -0.01287713f, -0.03286219f, 0.08794923f, -0.15265544f, 0.01237444f, 0.11526183f, -0.03230622f, 0.00425272f, 
    -0.02888098f, -0.06894291f, 0.02620352f, 0.04581736f, -0.00672612f, 0.19165994f, 0.02794955f, 0.03001517f, 
    -0.02877495f, 0.03237205f, -0.09226233f, -0.04572993f, 0.00392315f, 0.06855121f, 0.03931557f, 0.00477034f, 
    -0.30409876f, -0.04448665f, -0.10648882f, 0.23124367f, 0.12781118f, -0.12400512f, -0.00331925f, -0.08737488f, 
    0.02248074f, 0.00895301f, 0.00527350f, 0.08822267f, -0.03085301f, 0.01488356f, -0.16713169f, 0.01826494f, 
    0.06595220f, 0.08114330f, 0.10360693f, -0.06275664f, -0.00922654f, -0.08381116f, 0.06040222f, 0.09267037f, 
    0.08990271f, -0.11624400f, -0.12552942f, 0.12572734f, 0.00892907f, 0.06091580f, -0.08199605f, -0.08304180f, 
    -0.08596092f, 0.12616226f, -0.09157617f, -0.06132679f, 0.15626058f, 0.24956436f, -0.13551669f, -0.06864384f, 
    0.02325201f, -0.08832061f, 0.03263351f, 0.04343094f, 0.17842869f, 0.02814464f, 0.03692919f, -0.03504404f, 
    -0.24800849f, -0.10944524f, 0.19499220f, 0.20090060f, 0.04403988f, 0.17002657f, 0.05901565f, -0.01595228f, 
    -0.00011839f, -0.02537710f, 0.03143824f, 0.04354834f, 0.08067256f, -0.09146001f, 0.03360726f, 0.23886082f, 
    0.03581519f, 0.07275853f, 0.05261618f, 0.09876321f, -0.08519105f, 0.06808432f, 0.01944725f, -0.05072245f, 
    0.09173342f, -0.01232427f, 0.06510680f, -0.22790341f, 0.11974397f, 0.03460679f, -0.06041723f, -0.08177664f, 
    0.11014664f, -0.03140223f, -0.14533933f, 0.03169249f, -0.09015365f, 0.09657083f, 0.14552881f, 0.02606481f, 
    -0.04424936f, 0.00626970f, 0.05101105f, 0.10460197f, 0.10700481f, -0.10426597f, 0.05038005f, 0.00820994f, 
    -0.10204190f, 0.03878566f, 0.20413829f, -0.05222174f, 0.21792142f, 0.09970123f, -0.13118820f, -0.08521841f, 
    0.01203295f, 0.01998696f, 0.04836632f, -0.02771033f, -0.13607150f, -0.52309078f, 0.06575697f, 0.29934633f, 
    0.02114806f, 0.09796425f, 0.09815898f, 0.21858573f, 0.10096537f, -0.00817245f, 0.08696549f, 0.04485227f, 
    -0.15707101f, -0.01092363f, 0.17019312f, 0.04867032f, 0.03142069f, 0.07845948f, 0.11833420f, -0.13038801f, 
    0.00692099f, 0.03442085f, 0.08462889f, 0.00675161f, 0.02345164f, 0.11898280f, 0.14316310f, 0.13616949f, 
    0.02223910f, 0.03381397f, -0.00445465f, -0.02655129f, 0.04127051f, -0.03848714f, 0.01762521f, -0.08196077f, 
    0.06416728f, 0.10350090f, 0.09023609f, -0.00605600f, 0.13044192f, -0.03955880f, -0.03482630f, -0.03171657f, 
    0.01814689f, -0.01643437f, 0.08386737f, -0.06981005f, -0.21247528f, -0.28638765f, -0.12589990f, 0.05300356f, 
    0.01468258f, 0.05325338f, 0.06258357f, 0.01125611f, 0.01456476f, -0.05025471f, -0.03763658f, -0.03418793f, 
    -0.02912084f, -0.00392991f, -0.19669837f, -0.04527861f, 0.05208436f, -0.06022172f, 0.05231244f, -0.02904235f, 
    0.04299641f, 0.01868348f, 0.02821386f, 0.20768961f, 0.06231008f, -0.04000244f, 0.02474666f, 0.08643793f, 
    0.09604850f, -0.08134992f, -0.01151850f, -0.04684496f, 0.07320107f, 0.06220020f, -0.01383983f, 0.01383173f, 
    -0.00967813f, -0.00897923f, -0.15793748f, 0.20959413f, -0.05530040f, -0.04856786f, 0.01727562f, -0.11272828f, 
    0.12168722f, 0.14052689f, -0.08602276f, 0.07814126f, -0.12164193f, 0.43019602f, -0.20285816f, 0.04493101f, 
    -0.10887059f, 0.01515628f, 0.17310819f, -0.05330493f, -0.07465309f, 0.16763936f, 0.05777328f, 0.08420210f, 
    0.00261761f, -0.01788937f, -0.05935450f, 0.23459679f, -0.12986715f, -0.11266316f, 0.06709973f, 0.18607895f, 
    -0.02847857f, 0.02453705f, -0.07332801f, 0.04869025f, 0.07577126f, -0.05895024f, -0.02636385f, 0.03900892f, 
    0.04412922f, 0.01334844f, 0.00790968f, -0.01084075f, 0.00606120f, 0.07588929f, 0.00923603f, 0.23724738f, 
    0.00144314f, -0.17215551f, 0.15912494f, -0.20371270f, -0.04708929f, -0.03561488f, 0.05324662f, -0.07650591f, 
    -0.00821559f, -0.14294091f, -0.00043187f, -0.02607554f, 0.28026694f, -0.23514128f, -0.07221261f, 0.10478052f, 
    0.16801040f, 0.01216266f, -0.06327721f, -0.04960614f, -0.07640679f, 0.21985459f, 0.14612347f, 0.25432217f, 
    0.11444139f, -0.08798783f, -0.14814922f, 0.06322376f, 0.02538879f, 0.06357989f, 0.14307533f, -0.14299026f, 
    0.03264917f, -0.02862016f, -0.04142009f, -0.08594314f, -0.00931513f, -0.47393659f, 0.35600129f, -0.07109094f, 
    -0.04300264f, -0.09175949f, 0.08661025f, -0.05306423f, 0.03182001f, -0.12599637f, 0.12218448f, 0.00609780f, 
    0.14089970f, 0.00018585f, 0.05643965f, 0.28741127f, -0.04992194f, -0.03479040f, 0.07760055f, 0.07373528f, 
    -0.00644761f, 0.20085165f, 0.16759036f, 0.01147272f, 0.32665095f, 0.01325423f, -0.01018176f, 0.26237851f, 
    0.04232964f, 0.00647323f, -0.06473365f, -0.05050210f, 0.15102258f, 0.11626910f, 0.14733475f, 0.05162892f, 
    0.09498597f, -0.14723867f, 0.13756970f, 0.00958680f, -0.03340771f, 0.20689413f, 0.07215649f, -0.01803365f, 
    -0.14832835f, 0.03446828f, -0.01334009f, -0.17976440f, 0.07893114f, -0.02282910f, 0.07045025f, -0.02644573f, 
    0.04506847f, -0.03472375f, -0.17797111f, -0.05853762f, 0.06558999f, 0.13498791f, 0.00209477f, 0.14872907f, 
    0.03397219f, -0.15473150f, -0.05441281f, -0.32177633f, 0.09995739f, -0.13048510f, -0.06799664f, -0.03285858f, 
    -0.07012100f, 0.00161254f, 0.13284242f, 0.02272172f, 0.53159148f, 0.50568938f, 0.40981680f, 0.34059104f, 
    0.09442452f, 0.04224151f, -0.11362403f, 0.03831805f, -0.07174369f, -0.05983930f, -0.09654594f, 0.00026780f, 
    0.11708011f, -0.07402705f, 0.00464895f, 0.17205989f, 0.05961287f, -0.02063190f, 0.17962067f, 0.00941627f, 
    -0.00281056f, -0.02850643f, -0.16217394f, -0.15953580f, 0.22083159f, 0.04908678f, 0.02907714f, 0.03907244f, 
    -0.00610941f, 0.08996850f, 0.05019574f, -0.04313291f, -0.03552816f, -0.22619414f, -0.10805037f, -0.12015605f, 
    0.11789634f, 0.14567617f, 0.05263302f, 0.02679919f, -0.08030114f, 0.10565501f, -0.07521953f, -0.04898263f, 
    0.05483442f, 0.04708451f, -0.03370000f, -0.14154905f, 0.26504785f, 0.10884300f, 0.08680496f, -0.17911576f, 
    0.07436322f, 0.00221332f, -0.05311834f, -0.09184308f, 0.09720670f, 0.12919015f, -0.16033073f, -0.06411096f, 
    -0.27943498f, -0.14195646f, -0.00114735f, -0.17474152f, -0.00344339f, -0.01087934f, 0.00124943f, 0.14939699f, 
    0.03478483f, -0.12521580f, 0.08706360f, -0.18576258f, -0.05230941f, -0.17679664f, 0.06569130f, 0.14398168f, 
    -0.03781944f, 0.23905849f, 0.01921780f, -0.10064369f, -0.08351775f, -0.05899731f, -0.09197965f, 0.17226478f, 
    0.01925015f, 0.14578287f, 0.05253559f, 0.14907961f, -0.05500570f, 0.04665978f, 0.00701382f, 0.00090295f, 
    0.03887853f, 0.02421265f, -0.07979455f, -0.12602079f, -0.29863742f, 0.10782366f, -0.20334870f, 0.07694519f, 
    -0.03435263f, -0.17693487f, -0.09358620f, -0.09813818f, 0.04416011f, 0.06873704f, -0.19212379f, -0.06835081f, 
    0.15217495f, -0.08300766f, 0.07752601f, -0.32870001f, -0.10509860f, -0.18128325f, -0.11417505f, -0.02692658f, 
    -0.16641222f, -0.10003024f, 0.07189944f, 0.03263285f, 0.08581609f, 0.33570874f, 0.31246901f, 0.30713075f, 
    0.04422296f, 0.03133665f, 0.04351935f, -0.19398797f, 0.05746901f, 0.10233067f, -0.08109894f, 0.18475227f, 
    -0.03363846f, 0.04695687f, -0.16031958f, 0.26684359f, -0.08758274f, 0.04230071f, 0.03184014f, -0.05722214f, 
    0.05319175f, -0.09438768f, 0.10738430f, 0.03295346f, -0.34425157f, 0.07976294f, -0.20391577f, -0.01946046f, 
    0.12401181f, 0.04897299f, -0.03226533f, -0.06185894f, -0.07590418f, -0.02836675f, -0.13422143f, 0.14514035f, 
    0.02981801f, 0.11038957f, 0.12715800f, 0.16019978f, -0.03606306f, -0.11984856f, -0.00072084f, 0.17413513f, 
    0.00960486f, -0.06693662f, -0.00096700f, 0.02743525f, -0.09873125f, -0.28719285f, -0.00413530f, 0.11649813f, 
    0.10562153f, -0.05329984f, 0.08630071f, -0.05941141f, -0.09803183f, -0.12062280f, 0.07549065f, -0.05471639f, 
    0.08270189f, -0.17186239f, -0.35027850f, -0.20270617f, 0.07550644f, 0.04583139f, -0.03751904f, 0.00203152f, 
    -0.13417000f, -0.17439619f, -0.22722022f, 0.11240674f, -0.41861585f, -0.38775933f, -0.21807517f, -0.10827611f, 
    -0.09615014f, -0.12351472f, -0.02075415f, -0.02512856f, -0.06224335f, -0.01968101f, 0.09263550f, 0.08252849f, 
    -0.08656511f, -0.08794370f, -0.03910777f, 0.03386555f, -0.04756239f, -0.03842135f, 0.02756871f, 0.00485458f, 
    -0.07256433f, 0.15005121f, -0.26887062f, -0.26511073f, -0.15386558f, 0.12231345f, -0.08170953f, 0.21512033f, 
    -0.07569227f, -0.01488503f, 0.02455037f, 0.13028592f, -0.14895518f, -0.12606627f, -0.13899587f, 0.01921875f, 
    0.25153822f, 0.11673386f, 0.03212799f, -0.02501825f, 0.09111410f, 0.07037146f, 0.27766457f, 0.00177957f, 
    0.02465230f, 0.03375268f, -0.07023631f, -0.09907835f, 0.06313326f, 0.01246179f, 0.08087444f, -0.26085326f, 
    0.16024496f, 0.04879916f, 0.03125938f, 0.17594001f, 0.17053260f, 0.17998803f, 0.08075695f, 0.01219713f, 
    0.26623631f, 0.17997405f, -0.05825260f, 0.03194489f, -0.11641610f, -0.06402183f, 0.03118578f, 0.05262564f, 
    -0.01192144f, -0.03570480f, -0.05009686f, -0.03502471f, -0.17810357f, -0.15676390f, -0.01525387f, 0.12027554f, 
    0.01135235f, 0.01991164f, -0.07319504f, 0.09978139f, -0.03588695f, 0.14281546f, 0.00235302f, 0.01985152f, 
    0.01321996f, 0.08321556f, 0.09311205f, 0.16493447f, -0.04721092f, 0.05060066f, -0.01031229f, -0.07748707f, 
    -0.11554136f, -0.00609851f, -0.01789958f, 0.00248113f, 0.01051880f, 0.01628602f, 0.08339529f, -0.12778778f, 
    0.09443274f, 0.17361455f, 0.08954788f, 0.13200974f, -0.00253642f, 0.19795638f, 0.05551573f, -0.13109158f, 
    0.19289996f, 0.24735940f, -0.03874340f, 0.14528337f, 0.01862083f, -0.08378270f, -0.04623849f, -0.02414372f, 
    0.01044727f, 0.02479362f, -0.11263623f, 0.06887966f, -0.01712328f, -0.08109360f, 0.36162031f, -0.09239277f, 
    0.01411207f, -0.01908088f, 0.13930348f, 0.13591816f, -0.00639585f, -0.02422490f, 0.11282875f, 0.05366234f, 
    0.15023415f, -0.02871012f, -0.03272584f, -0.10963809f, 0.07827488f, 0.11219574f, 0.05426406f, 0.02429595f, 
    0.08321728f, 0.01726935f, 0.11402901f, 0.02082131f, 0.18969220f, -0.00417164f, -0.14628103f, -0.06212391f, 
    0.04014045f, 0.03686593f, -0.03111576f, -0.01256314f, -0.07050729f, -0.01389037f, 0.06799495f, -0.11156026f, 
    -0.10485235f, 0.09192505f, -0.00415306f, -0.03365234f, -0.13086997f, 0.01280795f, -0.05466134f, -0.06607359f, 
    -0.09299207f, 0.13499112f, 0.06128624f, 0.00043330f, -0.04581821f, -0.05490507f, 0.00305430f, -0.19573280f, 
    -0.05193901f, 0.01885316f, -0.07020241f, 0.14247242f, -0.02592516f, 0.03486670f, 0.00938323f, 0.00173452f, 
    0.04060506f, 0.12099999f, 0.25163311f, 0.04932345f, -0.08864503f, 0.05777235f, -0.00306125f, -0.00331414f, 
    -0.04346291f, 0.10400842f, 0.02492983f, 0.14644063f, -0.29832965f, -0.33034420f, -0.36245668f, -0.14014432f, 
    0.06665166f, 0.08420156f, 0.07667200f, 0.03047787f, -0.05398194f, 0.07585683f, 0.01118958f, 0.01037557f, 
    0.08176805f, 0.06102051f, -0.02576178f, 0.20451067f, 0.11052453f, -0.09210691f, 0.05148951f, 0.00108682f, 
    0.00293176f, 0.03993982f, -0.08787759f, 0.01552412f, -0.13920631f, -0.03104205f, -0.04633513f, -0.02533793f, 
    0.10572458f, -0.01730754f, 0.15742919f, 0.09666813f, -0.04655449f, 0.14351650f, 0.03472215f, -0.02535564f, 
    0.26478472f, -0.23294652f, 0.00414835f, -0.16490847f, -0.04125760f, 0.20553058f, -0.08412972f, 0.01545488f, 
    -0.02842851f, -0.04887240f, -0.09319800f, -0.10017645f, 0.08712911f, -0.02648201f, 0.22877814f, -0.02626930f, 
    -0.05702449f, -0.19078231f, 0.07495338f, 0.00976318f, 0.07551724f, 0.21351248f, -0.09806017f, 0.01355766f, 
    -0.05239559f, 0.04895921f, -0.02519286f, -0.09086415f, -0.00573337f, 0.00676165f, 0.09184839f, 0.05773675f, 
    0.10119971f, -0.06746387f, 0.05645597f, 0.13461484f, 0.01223866f, -0.05461505f, 0.02269348f, 0.09473307f, 
    -0.02933004f, 0.07514137f, -0.00085173f, -0.01950824f, -0.03215519f, -0.11269704f, 0.08842454f, 0.15245500f, 
    0.24634165f, 0.14912353f, -0.13524283f, -0.08606955f, -0.00709618f, -0.15201950f, -0.08133250f, -0.05579681f, 
    -0.01693680f, -0.05876556f, -0.06023344f, -0.08537218f, -0.00812733f, 0.00987371f, -0.00329865f, -0.13601618f, 
    0.05137429f, -0.06157909f, -0.03754322f, -0.10400674f, 0.05782673f, -0.05762765f, 0.11490537f, 0.13306189f, 
    0.03779894f, 0.02725076f, 0.01716236f, 0.14752617f, -0.20130186f, -0.12001759f, 0.16466387f, 0.03124269f, 
    0.00325334f, 0.05547731f, 0.10213811f, 0.00560458f, 0.18395500f, -0.12788552f, -0.17002772f, -0.01814445f, 
    0.07657990f, 0.10496628f, 0.02669345f, 0.00210003f, 0.00085987f, 0.06346019f, 0.08307853f, -0.04832231f, 
    0.02256592f, 0.22729629f, -0.19205542f, -0.07585406f, -0.12560205f, -0.00838568f, 0.15931949f, -0.07737359f, 
    -0.09099166f, 0.00963040f, -0.02555617f, -0.00628653f, 0.20318033f, 0.43625864f, -0.07891832f, -0.25424814f, 
    0.05400312f, -0.12436687f, -0.02104125f, -0.11010236f, -0.01720165f, 0.07165695f, -0.02188907f, -0.02716362f, 
    0.18105397f, -0.02129239f, -0.11805113f, -0.02221866f, -0.02599872f, 0.02058825f, 0.03898131f, 0.16910249f, 
    0.03770253f, -0.03106480f, 0.01211895f, 0.09466096f, 0.10389273f, 0.01331148f, -0.02980578f, -0.13474308f, 
    -0.05533101f, -0.06145656f, 0.01715681f, -0.07894982f, -0.05472369f, 0.03080042f, 0.00552371f, 0.08491050f, 
    0.10171064f, 0.01944765f, -0.04511701f, 0.02812677f, -0.05606078f, -0.07478023f, -0.02404987f, 0.05616112f, 
    -0.05154676f, -0.00613909f, -0.08153342f, 0.10050801f, 0.23115863f, 0.16662849f, 0.08971566f, -0.10088276f, 
    0.01766912f, 0.01263739f, -0.09163220f, -0.05184763f, -0.09864404f, -0.01010181f, 0.09122167f, -0.01114809f, 
    0.07975421f, -0.12466939f, 0.07966413f, 0.04270323f, 0.04585677f, 0.05424429f, 0.01062524f, 0.05606509f, 
    -0.05553113f, 0.04314166f, -0.06347380f, -0.16735436f, -0.00226246f, -0.06351020f, 0.03270971f, -0.10538076f, 
    0.06122737f, 0.12532453f, -0.03017263f, 0.02529875f, -0.15058853f, 0.02876936f, 0.05264938f, -0.02159323f, 
    0.01833926f, -0.04053785f, -0.00534718f, 0.00368045f, 0.04030100f, -0.03060477f, 0.04444054f, -0.02163003f, 
    0.04141846f, -0.00544443f, -0.04266281f, -0.02988645f, 0.02474041f, 0.02647834f, 0.02784788f, -0.03832913f, 
    0.03093540f, -0.01599378f, -0.04240921f, -0.02359099f, -0.05813767f, 0.02481015f, -0.01056357f, -0.00853883f, 
    0.01796914f, 0.01922627f, 0.04612634f, -0.02813103f, 0.03131364f, -0.05098372f, -0.03349099f, -0.04792230f, 
    -0.05077756f, -0.02705790f, 0.01308049f, -0.01990783f, -0.03018892f, -0.00488954f, 0.04280176f, -0.01878706f, 
    -0.03635393f, -0.04674714f, 0.02785385f, -0.04936857f, -0.04509365f, -0.03642642f, 0.02946780f, 0.00716604f, 
    -0.02709180f, -0.04634696f, -0.03682833f, 0.03425678f, -0.02163702f, -0.00661712f, -0.03273701f, 0.03786229f, 
    -0.03792579f, -0.03745975f, -0.00530785f, -0.05826137f, 0.00623493f, -0.05639083f, -0.01071094f, -0.00872117f, 
    -0.04783989f, -0.01077215f, -0.05840850f, -0.00210030f, -0.03902774f, -0.00688532f, 0.02283806f, -0.05022162f, 
    -0.01601374f, 0.04184618f, -0.02040192f, -0.03710926f, -0.03482178f, 0.00532248f, 0.01191428f, -0.01489940f, 
    -0.00852361f, -0.00681281f, 0.01471497f, -0.00177604f, -0.00459863f, -0.02651082f, -0.03686004f, -0.01567109f, 
    0.02050341f, 0.02310785f, 0.00767963f, -0.05186779f, -0.01958759f, -0.00795972f, 0.01631240f, -0.03883017f, 
    0.03094253f, -0.03907767f, -0.02734163f, 0.02569553f, 0.03900148f, 0.02803032f, 0.03745712f, -0.04476665f, 
    -0.03415759f, 0.04235345f, -0.05765468f, -0.05152944f, -0.00480254f, 0.00231820f, 0.01967885f, -0.02302962f, 
    -0.05078680f, -0.02214924f, 0.04702826f, 0.04918876f, -0.02895389f, -0.03844536f, 0.03354141f, 0.01337108f, 
    -0.02268665f, 0.02655232f, 0.02625691f, -0.03639473f, 0.00216285f, 0.01495453f, -0.00700385f, -0.02443795f, 
    0.02024253f, -0.01750649f, -0.02632761f, 0.00338091f, 0.02028949f, 0.00566975f, -0.00902927f, -0.02827985f, 
    -0.00124576f, 0.01125502f, -0.03542192f, -0.04057181f, -0.05778888f, 0.00913050f, -0.02297211f, -0.04018947f, 
    0.02049161f, -0.02700402f, 0.02376440f, -0.04339595f, 0.03894683f, -0.04484136f, -0.02878871f, 0.02837813f, 
    0.00932520f, -0.01034420f, -0.03507748f, 0.01619945f, -0.03059199f, -0.00186407f, 0.01678237f, -0.00955908f, 
    -0.04363833f, -0.03164589f, 0.00864646f, 0.00364105f, 0.02441602f, -0.00754944f, -0.01873893f, -0.02418649f, 
    -0.04032745f, -0.05863542f, 0.01755513f, -0.00838617f, 0.00452209f, -0.01598519f, 0.01355191f, -0.03367303f, 
    -0.04398439f, -0.01702552f, 0.03362467f, -0.01866776f, -0.02702356f, -0.04252483f, -0.04617189f, -0.01894623f, 
    0.00864686f, 0.04184705f, -0.04566321f, -0.00270147f, 0.03367721f, 0.03788166f, 0.01634769f, 0.01719310f, 
    -0.01750758f, 0.02521151f, -0.04019282f, -0.04320910f, -0.02349637f, -0.03491556f, 0.03566942f, -0.02307956f, 
    -0.01106637f, -0.00216396f, 0.01743209f, -0.04378285f, -0.01671103f, -0.01853370f, 0.03424503f, -0.00323332f, 
    0.04016165f, 0.03535958f, -0.00780611f, 0.01863209f, -0.01599871f, -0.02620262f, -0.04113988f, -0.01094908f, 
    -0.03552825f, -0.04242712f, -0.05207215f, 0.00449816f, -0.05290921f, -0.04453685f, 0.03970670f, 0.02796396f, 
    0.03830994f, -0.04637150f, -0.03911408f, -0.00317680f, -0.02198558f, 0.01066596f, -0.01747428f, 0.01037812f, 
    -0.00233974f, -0.01034375f, -0.05360373f, -0.04083068f, 0.04274447f, -0.05825414f, -0.02074577f, -0.02145207f, 
    -0.00942743f, 0.00838587f, 0.00230580f, -0.02714515f, -0.02065830f, 0.03720461f, -0.03592726f, -0.02604842f, 
    0.00163738f, -0.04596818f, 0.01662902f, -0.01084623f, -0.01803775f, -0.03191269f, 0.02699885f, -0.04155340f, 
    -0.00047489f, -0.02267950f, 0.01592369f, -0.05343758f, -0.01599260f, 0.02400410f, -0.01588891f, 0.03787082f, 
    0.04137943f, 0.01127589f, 0.02719543f, -0.00934505f, 0.02975659f, -0.00426725f, -0.00919116f, -0.01902519f, 
    -0.04691672f, -0.05112818f, -0.05178374f, -0.03703571f, -0.02544665f, 0.01261527f, -0.05455447f, 0.02133551f, 
    -0.03626576f, 0.02618931f, -0.04417710f, 0.00213997f, -0.00881913f, -0.03814358f, -0.02050132f, 0.01215578f, 
    0.01421327f, -0.02226925f, 0.02379243f, -0.00271995f, -0.01967894f, -0.05849420f, -0.02221981f, -0.00774844f, 
    0.03956127f, 0.03173480f, -0.04785223f, -0.04968329f, -0.01740972f, 0.00426744f, -0.02730651f, 0.01639488f, 
    0.01084303f, 0.01141810f, -0.05853750f, 0.02204577f, 0.03093218f, -0.02814795f, -0.03892149f, 0.03414282f, 
    0.00413289f, 0.00126901f, -0.03218339f, -0.00264235f, -0.04243771f, -0.01589965f, -0.04166781f, 0.01771654f, 
    -0.01452753f, -0.02217706f, 0.00789742f, -0.00749389f, -0.01012583f, -0.02863927f, 0.03416589f, 0.01930330f, 
    0.02529314f, 0.03805004f, 0.02859101f, -0.00916368f, -0.01380228f, -0.01665378f, 0.00994611f, 0.00271616f, 
    -0.00975816f, -0.05385395f, 0.02402744f, -0.00955513f, -0.01861237f, -0.01172180f, -0.03846533f, -0.00273219f, 
    -0.02897735f, -0.04371750f, -0.05655523f, -0.00120910f, -0.03259885f, 0.01649266f, -0.05311104f, 0.02625350f, 
    -0.01367834f, 0.00645564f, 0.02681942f, -0.05089473f, -0.00121887f, -0.04232544f, -0.03451677f, -0.02633698f, 
    0.03240123f, -0.05433930f, 0.02610268f, -0.01859648f, -0.00315646f, -0.05241430f, 0.02628592f, -0.04098808f, 
    0.00139616f, -0.01362227f, -0.03581620f, 0.04274556f, 0.00133706f, -0.01753016f, -0.04786132f, -0.02486639f, 
    0.01454038f, -0.00177184f, 0.04219269f, 0.01957420f, -0.03965637f, -0.00024076f, 0.01701554f, 0.03648932f, 
    0.13528529f, 0.06151763f, 0.15144779f, 0.15829815f, 0.28307307f, 0.03550797f, -0.09350099f, 0.14393900f, 
    0.02042986f, -0.01339495f, -0.18409599f, -0.11708117f, -0.04343584f, 0.20415293f, 0.01796630f, 0.11223425f, 
    0.12925419f, 0.16747077f, 0.11311384f, -0.03549869f, 0.16305020f, 0.07057101f, -0.01873657f, -0.02513446f, 
    0.16126032f, 0.12349619f, 0.18590090f, -0.02117291f, 0.03228671f, 0.03511347f, 0.14564037f, 0.27750406f, 
    0.08033860f, -0.02471684f, 0.04353355f, 0.08034885f, 0.05169370f, -0.01168599f, -0.04569342f, 0.03018185f, 
    -0.02329804f, 0.00396015f, 0.10076469f, 0.14441729f, 0.10663123f, -0.13111962f, -0.18153003f, -0.13159885f, 
    0.00172429f, -0.03288067f, 0.32168084f, -0.11042597f, -0.03590764f, -0.06424585f, 0.01186873f, -0.08421816f, 
    0.08138534f, 0.01299504f, -0.05336095f, -0.05995897f, -0.22096609f, -0.00482809f, 0.16322479f, 0.24067253f, 
    0.06170044f, -0.04384965f, -0.02098737f, 0.07308836f, -0.08045834f, 0.04853407f, -0.22012465f, -0.24424104f, 
    0.22483584f, -0.07867140f, 0.05173443f, 0.00303755f, 0.05515594f, -0.10326643f, 0.10748470f, -0.04778121f, 
    0.20088197f, -0.19417979f, 0.06031327f, 0.04917792f, -0.25108567f, 0.16256487f, -0.13776031f, 0.18585646f, 
    0.00194239f, -0.07330728f, 0.14427690f, 0.00014001f, 0.17038193f, -0.05861770f, 0.04678105f, 0.11406256f, 
    0.20210202f, -0.31073862f, -0.01994310f, -0.15773085f, -0.02143307f, 0.07690989f, 0.08438219f, -0.13396171f, 
    0.07439481f, -0.00973852f, -0.00898812f, -0.11807548f, 0.34409529f, -0.09180047f, 0.08440124f, 0.10124020f, 
    0.02053159f, 0.17272043f, 0.03503966f, 0.17176634f, -0.01758423f, -0.04302114f, -0.13520442f, -0.22878832f, 
    0.01428640f, 0.09028622f, 0.13486947f, 0.11013725f, -0.14572410f, -0.03314190f, 0.06310882f, -0.05972608f, 
    -0.01058429f, 0.11854189f, -0.08174233f, 0.16095732f, -0.15808542f, -0.09721170f, -0.08149808f, -0.23770665f, 
    0.02874913f, -0.05437846f, 0.11452313f, 0.15110628f, -0.07927617f, 0.07384465f, -0.03967574f, -0.08842736f, 
    -0.00931021f, 0.10421869f, 0.05899390f, 0.04186811f, -0.09158660f, -0.09649332f, -0.05247756f, 0.06027471f, 
    0.00696467f, -0.03717845f, 0.10659319f, 0.07653288f, 0.10865892f, -0.32469812f, -0.24107124f, -0.33440900f, 
    -0.06692546f, 0.08212060f, -0.01730448f, 0.29161966f, 0.07263257f, 0.16571042f, 0.08612799f, -0.03936225f, 
    0.03311451f, -0.02500938f, -0.04919124f, 0.01157827f, 0.04782663f, -0.00740566f, 0.34430268f, 0.01064461f, 
    0.05424086f, 0.01876805f, 0.02504282f, 0.16308427f, -0.07099187f, -0.16126032f, -0.24616463f, 0.01499691f, 
    0.03944677f, 0.14523958f, 0.30556646f, 0.16221163f, 0.11793687f, 0.07539164f, 0.10884648f, 0.12012704f, 
    -0.25107402f, 0.13239196f, -0.34054384f, -0.07305801f, -0.02407577f, 0.08602611f, -0.05044459f, 0.25126559f, 
    -0.03297861f, 0.00213590f, -0.24560204f, 0.04193486f, 0.09789699f, -0.09475350f, -0.19163711f, 0.05740385f, 
    0.05361008f, -0.11354628f, 0.00707842f, 0.03188390f, -0.01864547f, -0.09689048f, -0.02963830f, -0.00763258f, 
    0.02976639f, 0.03669862f, -0.06462622f, -0.04383840f, -0.06758502f, 0.06364366f, 0.00824063f, -0.02079610f, 
    0.21311870f, -0.05693999f, 0.11727038f, 0.02008655f, -0.33938444f, 0.14475444f, -0.22858258f, 0.21341760f, 
    0.03571858f, 0.00705133f, 0.20262395f, -0.11440109f, 0.07649478f, 0.15340614f, 0.03463482f, 0.08437689f, 
    0.05061404f, 0.08142605f, -0.05750066f, 0.05994227f, 0.08765075f, 0.06490009f, 0.18316805f, 0.16547400f, 
    -0.03455300f, 0.01261335f, -0.04251764f, -0.00337338f, 0.13106810f, 0.13261856f, 0.08941151f, -0.11281584f, 
    -0.08916109f, -0.13768128f, -0.12606147f, -0.12960052f, 0.07160303f, -0.19532950f, 0.21239580f, 0.01415004f, 
    0.30584714f, -0.14025737f, 0.15117043f, -0.10236713f, -0.05317295f, 0.00344368f, -0.11534093f, 0.04505611f, 
    0.14386474f, -0.02305497f, 0.00048603f, 0.00432749f, 0.30612901f, -0.04942957f, -0.04418642f, -0.12714136f, 
    -0.00079628f, 0.09421626f, 0.02984505f, -0.10358614f, 0.13680635f, -0.08152761f, -0.11557898f, -0.12943390f, 
    0.07546896f, 0.01778651f, -0.23911536f, -0.24848984f, -0.01022743f, -0.00234966f, 0.28245571f, -0.08960533f, 
    -0.03176400f, -0.04807922f, 0.01739124f, 0.02850708f, -0.11373407f, 0.08635943f, 0.01932700f, -0.34485820f, 
    0.16591521f, 0.10163313f, -0.02151738f, -0.11710401f, -0.05684457f, -0.03978496f, -0.10733112f, 0.04468301f, 
    0.05775401f, 0.06521439f, 0.06751528f, -0.17697357f, -0.02945716f, 0.15828212f, 0.12917279f, 0.34226817f, 
    0.02816125f, -0.04910362f, 0.18678276f, 0.13654099f, 0.15390033f, -0.09589242f, 0.25017157f, 0.19945222f, 
    -0.22975954f, -0.12282405f, 0.03050795f, -0.06156015f, 0.00653452f, -0.00250798f, 0.02126659f, -0.04252956f, 
    0.20794468f, 0.07531405f, 0.08865099f, -0.00803939f, -0.06780700f, -0.16675772f, -0.12363563f, 0.03461854f, 
    -0.01301381f, 0.07074156f, -0.01039628f, 0.11121731f, -0.04678893f, 0.04695384f, 0.02489330f, 0.06807055f, 
    -0.11844007f, -0.13740432f, -0.11140902f, -0.05828527f, -0.05739339f, -0.01323243f, -0.02391175f, -0.07904531f, 
    -0.10581455f, -0.06321962f, -0.10149018f, -0.05731056f, 0.13433042f, -0.03201751f, 0.17119583f, -0.00720495f, 
    -0.08268095f, 0.20329462f, -0.05318468f, 0.15664175f, -0.01713818f, -0.04830721f, 0.00887272f, 0.08227456f, 
    -0.09529575f, -0.09972931f, 0.08181006f, -0.02819558f, 0.03233534f, 0.11781613f, 0.12313581f, 0.18814303f, 
    0.18263617f, -0.10731784f, -0.14897002f, -0.04037214f, 0.08618711f, 0.05463059f, 0.12351914f, -0.05186679f, 
    -0.01861688f, -0.00732843f, -0.10684137f, 0.04873066f, 0.55442560f, 0.06944233f, -0.12868248f, -0.10317320f, 
    -0.04860876f, -0.06770103f, 0.03161392f, -0.05407613f, -0.02721976f, 0.12087421f, 0.00438717f, -0.07735652f, 
    -0.16117035f, 0.06754985f, -0.03866809f, 0.06570882f, 0.04516624f, 0.01990656f, 0.02459056f, 0.19798508f, 
    -0.09743331f, -0.09541471f, -0.05324381f, 0.03782682f, -0.13791895f, 0.23765317f, 0.27415133f, 0.23296338f, 
    -0.16199172f, -0.15156023f, -0.01806619f, -0.12100734f, -0.00249159f, 0.12408829f, 0.04372450f, 0.00524231f, 
    -0.10059107f, -0.07346302f, 0.06264564f, -0.05992198f, -0.00266049f, -0.01641840f, 0.00094642f, -0.03218148f, 
    0.10966039f, 0.01351632f, -0.07762478f, 0.05901454f, 0.41168633f, 0.00093946f, -0.16736223f, 0.03966048f, 
    -0.06167234f, -0.00754113f, 0.02587726f, -0.17936866f, -0.02768214f, 0.02778046f, 0.03212212f, 0.22411899f, 
    -0.05892791f, 0.06545188f, 0.04762754f, -0.07949553f, 0.02766547f, -0.01276361f, 0.13812873f, -0.02039083f, 
    0.01901414f, 0.01941037f, -0.06064557f, -0.08793306f, -0.04824796f, 0.14379081f, -0.12007671f, 0.10655841f, 
    -0.10417449f, -0.07991137f, -0.18956356f, -0.00182541f, 0.04604114f, -0.05848074f, 0.05062556f, -0.06485401f, 
    0.45409283f, -0.17601849f, -0.05216091f, -0.08760731f, 0.09344377f, -0.03331880f, -0.02410269f, -0.07084057f, 
    0.03021800f, 0.03501138f, 0.02201490f, 0.07775182f, 0.14158775f, -0.13483794f, 0.03657265f, 0.07425986f, 
    -0.06568965f, -0.02522405f, -0.02012832f, -0.05442356f, 0.09499123f, 0.03426512f, 0.25045419f, 0.13571252f, 
    0.12668154f, 0.07693972f, -0.03461615f, 0.03985075f, 0.12639993f, 0.10600903f, 0.01199133f, 0.02799047f, 
    0.02735526f, 0.09011523f, 0.04540780f, -0.11994337f, -0.06485704f, 0.10346328f, -0.01394608f, 0.22805312f, 
    0.07936541f, -0.02020593f, -0.04564856f, 0.02536958f, 0.12993686f, 0.03614542f, 0.01935101f, -0.06526820f, 
    -0.19999824f, 0.19966073f, 0.00324569f, 0.19655779f, -0.09755976f, 0.00430661f, 0.02202909f, 0.06690393f, 
    0.05288800f, 0.06038747f, 0.02024894f, 0.04268449f, 0.47782195f, -0.21682222f, -0.00435016f, 0.31953633f, 
    0.02208846f, 0.05965054f, 0.01254179f, -0.05512588f, 0.09723811f, -0.10868932f, 0.13216375f, 0.15798624f, 
    -0.04658008f, -0.00269205f, 0.16749719f, -0.06672598f, -0.02820060f, -0.13182120f, 0.10179709f, -0.05840608f, 
    0.06810876f, 0.03757084f, -0.03124981f, -0.07988825f, -0.04614342f, 0.21782255f, -0.14644916f, 0.18356045f, 
    0.05547764f, -0.00221356f, -0.00342754f, -0.01546096f, -0.09200422f, -0.14993808f, 0.01713074f, -0.04980855f, 
    0.31777203f, -0.06017098f, -0.20759475f, -0.03745144f, 0.06883019f, 0.10864340f, -0.11065990f, 0.11823932f, 
    0.12803346f, 0.01450074f, 0.13879642f, -0.03330304f, 0.00102052f, 0.05999905f, 0.12234370f, 0.33825541f, 
    -0.03109840f, 0.09608563f, -0.02167340f, 0.06825089f, -0.02813992f, -0.07979551f, -0.03135353f, -0.03867074f, 
    0.13116962f, 0.15240246f, -0.11436340f, -0.06111715f, -0.00021959f, 0.06865713f, -0.05816213f, 0.05614302f, 
    -0.10539130f, 0.08330773f, 0.00433145f, -0.02934862f, -0.21741380f, 0.14454524f, -0.23775165f, 0.09923406f, 
    0.04986084f, -0.06427509f, -0.01123651f, 0.05974805f, -0.15543248f, -0.03495843f, 0.11014940f, 0.01377386f, 
    0.05091320f, -0.12176823f, -0.12619646f, -0.06069653f, 0.12328415f, -0.06418820f, 0.01279292f, 0.07693549f, 
    0.05354606f, 0.04804119f, 0.01490964f, 0.01026612f, 0.23193398f, 0.05137077f, -0.14728592f, -0.20505196f, 
    0.06544394f, 0.00314438f, 0.02562793f, 0.00584663f, -0.08490755f, 0.04035857f, -0.13851972f, -0.00391531f, 
    -0.28480837f, 0.01840840f, 0.20030777f, -0.05500804f, -0.00057635f, 0.06831244f, -0.04085275f, 0.10199627f, 
    0.00095901f, -0.04371420f, 0.07035797f, -0.00582129f, -0.17609563f, -0.14797780f, -0.01783169f, 0.25698125f, 
    -0.03612566f, -0.00213030f, 0.23541665f, 0.00393504f, -0.11343365f, -0.01732621f, 0.02379717f, 0.15371855f, 
    0.00636798f, 0.28022566f, 0.28937051f, 0.18555588f, 0.22612417f, -0.00468412f, 0.04461521f, -0.17347644f, 
    0.03958070f, -0.01557922f, 0.03813539f, -0.10704979f, 0.24848036f, -0.05304667f, 0.05098615f, -0.26206571f, 
    0.00464359f, -0.22772381f, -0.03799820f, -0.08389588f, 0.03572050f, 0.02147242f, -0.02889338f, -0.01402406f, 
    0.18260697f, -0.05930289f, 0.07374302f, 0.02410483f, 0.20480536f, 0.01350412f, 0.07717165f, 0.11171613f, 
    -0.17895915f, -0.07464337f, 0.07431215f, -0.00052238f, 0.08303386f, 0.19986698f, -0.07600790f, -0.05651614f, 
    0.01724935f, -0.04351096f, -0.01176763f, -0.04767988f, -0.02787109f, -0.00086306f, 0.06069444f, -0.07485169f, 
    -0.18037105f, 0.11655682f, 0.14837545f, 0.03116719f, 0.05467597f, 0.10581857f, 0.02597346f, -0.04727668f, 
    0.02080498f, 0.03320150f, -0.00528193f, -0.05657855f, -0.16278785f, -0.01293464f, 0.00237154f, -0.03783886f, 
    -0.06090079f, 0.00559451f, 0.03823543f, 0.06312380f, 0.12540711f, 0.07107554f, 0.02635928f, 0.04232425f, 
    -0.03460733f, 0.05372120f, 0.00124078f, -0.01829966f, 0.09710548f, 0.05832236f, 0.00178009f, 0.09204269f, 
    0.03033472f, 0.04290408f, -0.06532118f, 0.01011515f, 0.23995921f, -0.06593356f, -0.19054493f, -0.10395391f, 
    0.03177161f, -0.15439972f, -0.00872987f, -0.04075613f, 0.10698923f, -0.02720578f, -0.02451741f, 0.07192297f, 
    -0.02201710f, -0.03851644f, 0.04063863f, -0.01441492f, -0.00178784f, -0.01835415f, 0.02344210f, 0.02290923f, 
    -0.00207880f, 0.01858176f, 0.03655578f, -0.02420719f, -0.02922229f, -0.01150961f, -0.04797646f, -0.03923964f, 
    -0.04695783f, -0.02005602f, 0.03655094f, -0.01755145f, -0.04248120f, -0.00051276f, -0.00963666f, -0.00182928f, 
    -0.02900236f, -0.03569916f, 0.03925150f, -0.00587696f, -0.05858120f, 0.04247406f, -0.03682809f, 0.00368092f, 
    0.01501487f, -0.02899696f, -0.00487373f, -0.00443481f, -0.04524105f, -0.01243313f, -0.05618059f, -0.00462937f, 
    0.01318216f, 0.03263311f, -0.03876173f, 0.02440932f, 0.02332488f, -0.01369423f, -0.01413989f, -0.05734070f, 
    -0.02777763f, -0.05785804f, 0.01918779f, -0.02840921f, 0.04353624f, 0.01117951f, -0.04254880f, -0.00313575f, 
    -0.04098848f, -0.00437574f, -0.03265599f, -0.00130340f, 0.01950671f, 0.01882749f, -0.00364133f, 0.03850036f, 
    -0.01518836f, 0.00438856f, 0.01118236f, -0.03814292f, 0.03755410f, -0.01610868f, -0.05810998f, -0.02868662f, 
    -0.05285193f, -0.02326461f, -0.00038960f, 0.02408700f, -0.02983976f, -0.04487768f, 0.01839379f, -0.03330559f, 
    0.00870573f, -0.04499939f, 0.03306280f, 0.01450256f, 0.04196192f, 0.01749240f, 0.01027177f, -0.05447074f, 
    -0.01888522f, -0.04947824f, 0.00300348f, 0.03279191f, 0.00267492f, -0.04408233f, -0.03981734f, 0.02564218f, 
    -0.02943772f, 0.03242265f, 0.03033929f, -0.03663776f, 0.01099266f, 0.02499734f, -0.02319131f, 0.03351306f, 
    -0.04694905f, 0.03540380f, -0.04302242f, 0.02669455f, 0.03148076f, -0.02511322f, -0.02737443f, 0.03713847f, 
    -0.00067486f, 0.02925848f, -0.03575569f, 0.04019776f, 0.02938128f, -0.03191731f, 0.00812744f, -0.02346542f, 
    -0.02322640f, -0.05411971f, -0.01728307f, 0.03644562f, -0.00644015f, -0.01892947f, -0.01535970f, -0.05534835f, 
    -0.00537348f, -0.00542231f, -0.04845362f, -0.03097356f, -0.04995112f, -0.05362399f, -0.05518016f, -0.01370711f, 
    0.03703874f, -0.03967578f, 0.01111311f, -0.04859342f, 0.00578053f, -0.05123378f, -0.02742406f, 0.02176699f, 
    -0.04953814f, -0.01181549f, -0.00448806f, -0.04187832f, -0.00383412f, 0.03175646f, -0.04942835f, -0.05668626f, 
    0.00612303f, 0.03567700f, 0.02335553f, -0.02764202f, -0.01330933f, -0.00876087f, -0.00146790f, 0.00563385f, 
    0.01381728f, -0.00610822f, 0.00795919f, -0.00503027f, 0.01748329f, 0.01603506f, -0.00801912f, -0.05037894f, 
    -0.04246537f, -0.01126848f, -0.05277799f, -0.02468052f, -0.00645595f, 0.01905867f, 0.00757868f, 0.03210430f, 
    -0.00162337f, 0.02015972f, 0.03019394f, 0.01209698f, -0.03373059f, -0.04519496f, -0.02937793f, -0.00865330f, 
    -0.01947209f, -0.04370699f, -0.01110593f, 0.00374488f, -0.01935261f, -0.03934356f, 0.03141675f, -0.05129908f, 
    0.04184734f, 0.00670257f, -0.03085368f, -0.02391862f, -0.02789899f, -0.05261954f, 0.03598149f, -0.04799984f, 
    -0.04260283f, -0.03049057f, 0.00482823f, 0.00251070f, -0.00159082f, -0.00716906f, -0.04105240f, -0.01632429f, 
    0.01440177f, 0.00251716f, -0.03689550f, -0.03739889f, 0.00398457f, -0.00070101f, -0.05297035f, 0.01555083f, 
    -0.05526640f, -0.03231391f, 0.02698485f, -0.02607458f, -0.02893108f, 0.01371163f, -0.03936175f, -0.00139717f, 
    -0.01993280f, -0.04731481f, 0.00776828f, -0.04523096f, -0.02175876f, 0.00867134f, -0.04619381f, 0.03390926f, 
    -0.05482130f, 0.04112060f, 0.04168327f, -0.03197779f, -0.00362599f, 0.02226157f, -0.02007072f, 0.02697733f, 
    -0.02122763f, -0.05701941f, 0.01484174f, 0.01169345f, 0.00026183f, -0.04405172f, -0.01052057f, -0.02995865f, 
    0.00796774f, 0.02417904f, -0.00608865f, -0.03900344f, 0.00718050f, -0.04179549f, -0.05021578f, 0.04092328f, 
    0.00825574f, -0.00100221f, 0.01049021f, -0.01594043f, -0.03357941f, -0.03445182f, -0.02747682f, -0.02377491f, 
    0.01481659f, -0.05742449f, -0.00303872f, 0.00876753f, -0.00098933f, 0.03618037f, -0.00944114f, 0.00883710f, 
    -0.04831845f, -0.02097760f, -0.05058549f, 0.00813032f, 0.02270626f, -0.00596044f, -0.00298195f, 0.03000664f, 
    -0.03680453f, -0.05505892f, -0.02272723f, -0.01075546f, -0.03008563f, 0.02781100f, -0.03123302f, -0.01821026f, 
    -0.00148648f, -0.02094855f, 0.01407076f, -0.03238983f, -0.00651824f, -0.00697472f, 0.02801421f, -0.03954765f, 
    -0.03631248f, -0.00508300f, -0.05753047f, -0.00541151f, 0.01117656f, 0.03428396f, 0.03352582f, 0.03225395f, 
    0.03853061f, 0.03001445f, -0.02350104f, -0.01080509f, 0.00983061f, -0.04304164f, 0.01190058f, 0.02232995f, 
    0.03647797f, -0.00854247f, 0.01719395f, -0.01125526f, -0.02770299f, -0.02469942f, -0.01718573f, -0.02869381f, 
    0.03874107f, -0.00735517f, -0.04120627f, 0.04182749f, -0.03507855f, 0.00662876f, -0.01348684f, 0.04210606f, 
    0.03912968f, 0.00907984f, -0.00008388f, -0.03063188f, 0.02100494f, -0.03508935f, -0.01124986f, -0.04598294f, 
    -0.01691158f, 0.04105347f, 0.02830684f, 0.00995567f, 0.00518943f, 0.03439181f, -0.00766791f, -0.05267803f, 
    -0.03913509f, -0.02277089f, 0.01285380f, -0.03586891f, -0.02556120f, 0.02763678f, -0.04218454f, -0.02739523f, 
    -0.01174406f, -0.04296340f, 0.03675427f, 0.03141671f, -0.01111391f, -0.01042826f, -0.05515488f, -0.04766915f, 
    0.03285189f, -0.03102791f, 0.03378786f, -0.01938246f, 0.01908105f, -0.04693839f, 0.02005326f, 0.03402439f, 
    0.01661314f, -0.01482316f, 0.01397838f, -0.03427478f, 0.00822200f, 0.03956786f, 0.02252928f, -0.00765731f, 
    -0.05676233f, 0.03060701f, -0.05176632f, -0.05177193f, 0.03664991f, -0.00814047f, -0.04752948f, -0.01443067f, 
    -0.19006088f, -0.13783363f, -0.08183949f, 0.07038841f, -0.06099864f, 0.00586726f, 0.16303532f, -0.06860290f, 
    0.03602624f, 0.08337865f, -0.04458971f, -0.02070506f, 0.29374900f, 0.01659047f, -0.30256221f, 0.10463103f, 
    0.06504919f, 0.06789212f, 0.05768266f, -0.07115839f, 0.07804191f, 0.09097404f, 0.10645192f, 0.02837826f, 
    0.01883747f, -0.16712940f, -0.02744041f, -0.11215080f, -0.15638709f, -0.06192770f, -0.00126381f, 0.06974073f, 
    -0.01973064f, 0.00884012f, -0.09224644f, -0.00392215f, -0.28188753f, -0.00015413f, 0.10290682f, -0.30475813f, 
    0.02814881f, -0.02604237f, -0.14247639f, -0.04591051f, 0.09115988f, 0.16223833f, 0.07033179f, 0.15279068f, 
    0.09501713f, -0.08975444f, 0.21376796f, 0.03693453f, -0.03382406f, 0.15951173f, 0.05359067f, -0.05886551f, 
    0.03703349f, 0.05338529f, -0.01017702f, 0.00231036f, -0.09645323f, -0.03149502f, -0.09270349f, 0.02362163f, 
    0.04188753f, 0.01452580f, -0.01589188f, -0.08100188f, 0.00111679f, 0.14386399f, 0.16460001f, 0.17997219f, 
    0.00406393f, -0.13785386f, 0.10970574f, 0.10068092f, 0.10824920f, 0.03737806f, 0.13919826f, 0.04460226f, 
    0.03294751f, 0.16659078f, 0.05461842f, -0.16424042f, -0.00535028f, 0.01036898f, 0.20053287f, -0.01458795f, 
    0.15722571f, -0.03804813f, 0.12521090f, 0.09893759f, 0.05363430f, -0.24613805f, 0.13117673f, 0.01643699f, 
    0.33820292f, -0.28627455f, 0.21249859f, 0.32508257f, 0.01824711f, -0.09545551f, -0.01705873f, 0.00073172f, 
    0.07196970f, 0.05252266f, -0.02017335f, 0.04942339f, 0.11164588f, -0.19505911f, -0.05426496f, 0.13930391f, 
    0.00283826f, 0.00244438f, -0.08093443f, -0.13330305f, 0.13340871f, 0.13631953f, 0.07995600f, 0.16169405f, 
    -0.14336140f, -0.01056464f, -0.10585678f, -0.15406217f, 0.05065468f, 0.05205651f, -0.08076032f, 0.02762128f, 
    -0.01932638f, 0.02336228f, -0.05078434f, -0.19636010f, -0.14916016f, 0.20640340f, 0.05535612f, -0.01032670f, 
    -0.07635832f, -0.11819848f, -0.05760360f, -0.02932085f, 0.20055471f, 0.08708769f, -0.11886036f, -0.00380867f, 
    0.03188749f, 0.05744367f, 0.03012702f, -0.16210675f, -0.03467599f, 0.04118425f, 0.05077735f, 0.11707009f, 
    -0.02853886f, 0.02727110f, -0.02064503f, 0.09605289f, 0.03467646f, 0.24833423f, 0.10529912f, 0.17788787f, 
    0.01264348f, 0.02190623f, -0.04726024f, -0.07841454f, -0.01421414f, -0.08652974f, -0.11553407f, 0.09282499f, 
    0.04769605f, -0.05680916f, -0.08693969f, -0.04716602f, 0.05540899f, 0.04822991f, 0.07173128f, 0.00170150f, 
    0.03526372f, 0.02968812f, -0.11417267f, -0.11796144f, 0.00798625f, 0.04963205f, -0.09576058f, -0.26097730f, 
    0.06893060f, 0.05897766f, 0.02244959f, 0.06233406f, -0.03557662f, -0.07710657f, 0.00265093f, -0.10224962f, 
    -0.11088521f, 0.09761367f, -0.12302450f, -0.15775047f, -0.00584998f, 0.00099460f, 0.05377425f, 0.10319941f, 
    0.03331294f, -0.01186974f, 0.12069640f, 0.00030410f, -0.09239434f, 0.14187753f, 0.02967783f, -0.19274934f, 
    0.12427948f, -0.09468803f, 0.06766205f, 0.13270545f, 0.05111610f, 0.03557906f, -0.09152519f, -0.00996942f, 
    0.00402874f, -0.07581369f, -0.01736969f, -0.04483145f, 0.15342040f, 0.03684232f, 0.06526535f, 0.08448205f, 
    0.02153238f, -0.05288336f, 0.01782656f, 0.06372563f, -0.21124633f, -0.15966944f, 0.13580541f, -0.17629680f, 
    0.01825299f, 0.04652810f, 0.04518478f, -0.03204681f, 0.04200171f, 0.00015539f, 0.06635116f, 0.05065840f, 
    0.06210609f, 0.06734183f, -0.00252026f, 0.02656406f, -0.13056631f, -0.13820724f, -0.10234157f, 0.06555441f, 
    0.03986625f, -0.04510189f, -0.04667318f, -0.05492154f, 0.27180171f, -0.06724218f, -0.09261551f, 0.12778036f, 
    0.06786955f, 0.04392739f, 0.10203498f, 0.05177490f, 0.14101194f, 0.12219843f, -0.13385330f, 0.13835457f, 
    -0.04207507f, -0.04342389f, 0.11869276f, -0.19815426f, -0.06112516f, -0.06770474f, -0.01715967f, 0.16560854f, 
    -0.15525411f, 0.04465067f, 0.01116551f, 0.12079154f, -0.03462030f, 0.19791813f, 0.34233406f, -0.03987386f, 
    -0.08360311f, -0.05696684f, 0.15788524f, 0.02192965f, -0.08164162f, 0.18433148f, 0.07341024f, 0.13811699f, 
    0.17601572f, -0.49284908f, 0.23689964f, -0.17557205f, -0.12532118f, -0.10421512f, 0.09317287f, 0.09032077f, 
    -0.03466013f, -0.07321324f, 0.00866183f, -0.03882266f, 0.03990658f, -0.03042208f, -0.04142869f, -0.03863519f, 
    0.12818804f, 0.13920557f, -0.10079425f, 0.06123604f, 0.07343756f, -0.05062144f, 0.02943518f, -0.01123133f, 
    0.06067568f, -0.13331334f, -0.04929697f, 0.01566318f, -0.02465781f, -0.22825243f, -0.04196368f, 0.09173238f, 
    0.02067493f, -0.02031492f, -0.05993115f, 0.06724397f, 0.07707611f, 0.07397301f, 0.12511830f, -0.08275046f, 
    0.05740403f, 0.07024733f, 0.00090498f, -0.01770309f, -0.08219768f, -0.03877212f, 0.02795830f, -0.04218088f, 
    -0.02660216f, -0.20435297f, -0.03449281f, -0.06260875f, 0.07772052f, -0.04245193f, 0.08081014f, 0.05456061f, 
    0.04938662f, -0.05173071f, -0.07566439f, 0.10354608f, 0.05470374f, 0.13107121f, 0.24893752f, -0.06585971f, 
    -0.05856248f, 0.07521216f, 0.10444235f, 0.13331912f, 0.01677422f, -0.06328282f, 0.06516577f, 0.03285437f, 
    -0.02321824f, -0.01602259f, 0.01228673f, -0.08094912f, 0.10318164f, 0.07493160f, 0.12061650f, 0.13830440f, 
    -0.03497483f, 0.13582236f, -0.03897357f, -0.04719784f, -0.00633881f, -0.01658613f, -0.03251373f, 0.25066933f, 
    0.09906287f, 0.05399507f, 0.10895523f, 0.02925135f, 0.14133397f, -0.21232781f, -0.09588649f, -0.09660464f, 
    -0.02330515f, 0.01872330f, 0.02401872f, 0.00481828f, -0.05028947f, 0.02655722f, 0.03505829f, -0.02076086f, 
    0.00895921f, -0.01422976f, 0.01077102f, 0.00135822f, -0.02375980f, 0.04468179f, -0.04327438f, 0.01741104f, 
    0.02442883f, 0.02791162f, 0.02306768f, 0.04049473f, -0.04226834f, -0.03022563f, 0.00412851f, 0.04322740f, 
    -0.03062263f, -0.00566068f, 0.01378249f, 0.00531645f, 0.01396080f, -0.04338451f, 0.01848991f, 0.02482448f, 
    0.01797829f, 0.02427609f, -0.01275732f, 0.02621290f, 0.00168824f, -0.03141335f, 0.00744414f, -0.03220112f, 
    0.00004030f, -0.01013319f, -0.02087932f, -0.05417629f, -0.04459453f, 0.02136959f, -0.00825200f, -0.04836265f, 
    -0.03508982f, -0.04878813f, -0.00536844f, -0.02515775f, -0.00864837f, 0.02864487f, -0.00549412f, 0.04206738f, 
    0.03662022f, 0.02326303f, 0.01749372f, 0.02907495f, 0.00246184f, -0.02497219f, -0.01582991f, -0.00691934f, 
    -0.04579666f, -0.03355791f, -0.01778220f, 0.00658336f, -0.04287250f, -0.02685232f, 0.04142036f, -0.01646613f, 
    0.00693987f, 0.02077799f, 0.00427593f, -0.05269915f, 0.01657549f, -0.05641250f, 0.00694143f, -0.02623461f, 
    -0.03479466f, -0.04456071f, -0.01108987f, 0.00029945f, 0.04356916f, -0.04454610f, -0.04126034f, -0.03159445f, 
    -0.01980476f, -0.04585793f, 0.04382604f, -0.03840356f, 0.01573300f, 0.03868673f, -0.00863855f, -0.00030592f, 
    -0.03349465f, -0.03863743f, -0.02142022f, -0.01464152f, 0.02692671f, -0.02605372f, 0.03844056f, -0.03064170f, 
    0.01638049f, 0.02926625f, -0.04787419f, 0.03124907f, 0.00101413f, -0.01388909f, -0.01863930f, 0.02280446f, 
    -0.01870565f, -0.01403213f, 0.03785862f, -0.03399053f, -0.05135952f, -0.04823706f, 0.03075860f, -0.05256096f, 
    0.03163490f, -0.05126802f, 0.01850164f, -0.01395364f, -0.00430916f, 0.03577978f, -0.03026163f, -0.02091203f, 
    -0.05372861f, -0.04692743f, 0.03817845f, -0.01897688f, 0.00846079f, -0.00945007f, 0.04277715f, -0.04281898f, 
    0.00432925f, -0.01667777f, 0.00169227f, -0.00073649f, -0.02041248f, 0.02002711f, -0.00120864f, -0.01187300f, 
    0.00529949f, -0.03509740f, -0.01442871f, -0.03524769f, 0.01939957f, 0.03235072f, -0.05275683f, -0.02882554f, 
    -0.04415794f, -0.02933560f, -0.04109951f, 0.00575942f, -0.02879982f, -0.02214209f, -0.02822568f, -0.01482251f, 
    -0.01328888f, -0.00119803f, 0.01853471f, -0.01022273f, -0.05243038f, 0.00092533f, -0.02668032f, 0.00442404f, 
    0.00156574f, -0.04548794f, -0.05427211f, 0.03121856f, -0.00877654f, -0.01912170f, -0.04795539f, -0.05660844f, 
    0.00561298f, -0.04076136f, -0.01150677f, 0.04479715f, 0.02063244f, -0.04523693f, 0.01092946f, -0.04512558f, 
    -0.03041321f, -0.04866271f, 0.00102759f, -0.04996676f, 0.02312934f, -0.02453930f, -0.04433978f, -0.00284583f, 
    0.01862499f, -0.04027588f, -0.05282884f, 0.01534216f, -0.03596956f, -0.00167507f, -0.01621939f, -0.03590243f, 
    0.04370161f, -0.02177855f, -0.01801722f, -0.04497426f, 0.02382831f, -0.01337462f, -0.01719293f, 0.00133764f, 
    -0.00437405f, 0.01336686f, -0.00618201f, -0.04425339f, -0.04901830f, -0.01423371f, 0.00764503f, -0.05216694f, 
    -0.05199605f, 0.00137995f, 0.03982211f, -0.03405787f, -0.05397828f, -0.04036396f, -0.01025109f, -0.03142702f, 
    -0.00633887f, 0.02982562f, 0.03177653f, -0.00724226f, 0.03987749f, 0.02799342f, -0.00726371f, 0.01852842f, 
    -0.04129875f, 0.01754109f, 0.02529305f, -0.02874951f, -0.00726890f, -0.04551533f, -0.05534782f, -0.01382084f, 
    -0.02135947f, -0.05584820f, 0.02963573f, -0.03137186f, -0.05068205f, -0.00246396f, -0.00595272f, 0.00591454f, 
    -0.03991402f, -0.01286222f, -0.00597993f, -0.04190138f, 0.04205746f, 0.03073459f, -0.03815665f, -0.03510528f, 
    -0.00694881f, 0.00909714f, -0.04465286f, 0.04164781f, -0.00577806f, 0.01680506f, 0.00451496f, -0.02248258f, 
    0.00968056f, 0.04274699f, -0.01160288f, -0.04207468f, 0.00174621f, -0.02304740f, -0.01254626f, 0.04008166f, 
    0.03933682f, -0.03426794f, 0.03036482f, 0.04032429f, 0.00426863f, 0.02098681f, 0.02506318f, -0.02665894f, 
    -0.03501530f, -0.05069856f, 0.01969335f, -0.00052187f, -0.04522159f, 0.01698725f, 0.03158914f, -0.01671328f, 
    -0.00424677f, -0.04378159f, -0.00583780f, -0.02240300f, 0.03810573f, -0.01141144f, 0.02599113f, -0.00815753f, 
    0.03869628f, -0.00853942f, -0.03167777f, 0.02822058f, 0.03916404f, 0.00543852f, 0.04009094f, 0.04499837f, 
    -0.04320798f, 0.01344304f, -0.00033575f, 0.00930639f, -0.03898406f, 0.00060601f, -0.05240004f, 0.02656541f, 
    -0.00198960f, 0.04382253f, 0.00233352f, 0.01139548f, -0.02317734f, -0.00675945f, 0.03564841f, -0.03952751f, 
    -0.04497087f, -0.05064933f, 0.03971125f, -0.01821731f, -0.01498472f, -0.02091517f, 0.03174043f, 0.02889663f, 
    -0.05054197f, -0.02655153f, 0.01276859f, 0.01575718f, -0.04225884f, -0.00069699f, 0.02615447f, 0.00794050f, 
    -0.04443864f, 0.00599046f, -0.03010596f, 0.01609909f, -0.01999637f, -0.05475776f, 0.02473134f, -0.00498749f, 
    0.03537928f, 0.00217526f, 0.04477925f, -0.00563094f, -0.00882653f, 0.02308914f, 0.03452578f, 0.00152555f, 
    -0.02999408f, 0.03343265f, 0.00871451f, -0.03306175f, 0.04284096f, 0.02182195f, -0.01460562f, -0.03358788f, 
    -0.01776587f, 0.00325603f, 0.02209123f, 0.02661155f, -0.00171969f, -0.00382835f, -0.02859248f, 0.00601484f, 
    -0.02135878f, 0.03619552f, -0.01782759f, -0.01616356f, -0.03163142f, -0.02255051f, 0.01828599f, -0.02742172f, 
    0.02796872f, -0.00358354f, -0.02622828f, -0.05432837f, -0.01502840f, 0.00168810f, 0.02884190f, -0.00939311f, 
    0.31483108f, 0.34099424f, 0.08998686f, 0.14933488f, 0.05195244f, 0.11357291f, 0.05283366f, -0.05657179f, 
    -0.07078248f, -0.04373116f, -0.11543800f, -0.05155615f, -0.31339446f, 0.29484582f, 0.19176394f, -0.21100175f, 
    -0.02802987f, 0.05813507f, 0.17337443f, 0.10580136f, -0.05378817f, 0.04891490f, -0.02279195f, -0.02011690f, 
    0.34709936f, 0.24267747f, 0.02420221f, 0.13073534f, 0.02447268f, 0.03880388f, 0.03993585f, 0.04605516f, 
    0.02645102f, -0.06081509f, 0.01318729f, -0.00346014f, 0.12880184f, -0.04033986f, -0.26693761f, 0.18723173f, 
    -0.04771967f, 0.05824345f, 0.05090684f, 0.03743489f, -0.02901838f, -0.04292681f, -0.19042122f, 0.01130997f, 
    -0.09530429f, -0.09074692f, -0.00098538f, -0.11043876f, -0.06460406f, -0.17069091f, -0.07711583f, -0.05033337f, 
    -0.19546191f, -0.04979260f, -0.05683587f, -0.12144123f, 0.08018010f, -0.05594030f, 0.06002783f, 0.02982192f, 
    0.00517283f, 0.07115889f, 0.00125039f, -0.03234709f, -0.12111837f, -0.03759724f, -0.02993041f, -0.00959371f, 
    0.03483918f, 0.19676186f, -0.22969885f, 0.15669630f, -0.02379537f, -0.07112826f, 0.02278664f, -0.14657450f, 
    0.02881172f, -0.12211611f, 0.03530466f, -0.03509810f, -0.15605602f, -0.27742422f, 0.23338653f, 0.00853546f, 
    -0.15426376f, 0.02159219f, 0.07939850f, -0.04809706f, -0.01472673f, 0.04198400f, -0.03346435f, 0.03717426f, 
    0.04594573f, 0.20234826f, -0.11619423f, -0.02091445f, -0.03999452f, 0.07459979f, 0.04146824f, -0.06542505f, 
    0.03810242f, 0.13532963f, 0.13644299f, 0.01997986f, 0.34774512f, 0.28606883f, 0.03891025f, 0.11576850f, 
    -0.01393745f, 0.08786107f, -0.04121919f, -0.03538406f, -0.01499002f, -0.00828714f, -0.14707308f, -0.30573502f, 
    -0.02261310f, -0.07359572f, 0.07131060f, -0.01387849f, -0.18297148f, 0.06163616f, 0.11195400f, -0.00823364f, 
    -0.08119453f, 0.02471881f, 0.06614529f, 0.05392544f, 0.07166485f, -0.25312990f, 0.07097875f, -0.00168977f, 
    0.03952329f, -0.02827559f, -0.01382170f, 0.08212641f, -0.13515471f, 0.00350186f, -0.00266937f, 0.02827923f, 
    -0.17669921f, -0.18441615f, -0.10937805f, -0.16549177f, 0.00392457f, -0.03615823f, -0.00089739f, -0.04446163f, 
    -0.05031032f, -0.01767017f, 0.06171040f, 0.06830497f, 0.38369974f, 0.19529791f, -0.04690381f, -0.10229121f, 
    0.03467262f, 0.10316864f, 0.08126928f, 0.15382534f, -0.05177765f, 0.07587352f, 0.04104331f, 0.00426392f, 
    0.06039143f, -0.00559288f, -0.03706695f, 0.17918140f, 0.06733168f, -0.08589883f, 0.15120399f, 0.02860242f, 
    -0.06401092f, -0.07674827f, -0.00492930f, -0.00248291f, 0.14360243f, 0.05453029f, 0.15031070f, 0.17773859f, 
    0.02238194f, 0.02529768f, 0.07740697f, 0.02615863f, -0.01652583f, -0.05735134f, 0.10256140f, 0.08110274f, 
    0.25918922f, 0.11188975f, 0.25213382f, 0.12507217f, -0.14393711f, 0.09556865f, 0.01008074f, 0.03668233f, 
    0.03256004f, 0.01017790f, 0.00527757f, -0.04675876f, 0.16096923f, -0.08351530f, 0.02001089f, -0.09243748f, 
    0.02165400f, -0.01749357f, -0.00337170f, -0.07109678f, -0.01222253f, -0.00919045f, -0.07075237f, 0.00073326f, 
    -0.25024760f, -0.09758776f, 0.04347111f, -0.14970770f, 0.02326917f, -0.02147607f, -0.00990395f, 0.01914191f, 
    0.09475509f, 0.02302212f, -0.00136270f, -0.09923624f, -0.11405084f, -0.09702051f, 0.10904016f, 0.08580887f, 
    -0.03694141f, 0.11143225f, 0.05298381f, -0.08623676f, -0.11619230f, -0.07996120f, -0.13276491f, 0.06457819f, 
    0.21514405f, 0.22433911f, 0.13615221f, 0.16212903f, -0.03660091f, 0.01871991f, -0.02603120f, -0.07485995f, 
    0.00999678f, -0.04379023f, 0.03391574f, 0.01457507f, -0.27770904f, 0.16096602f, 0.00880974f, -0.15720508f, 
    -0.13816373f, -0.02813425f, -0.19875078f, -0.08746862f, 0.03711073f, 0.05227504f, -0.08828877f, -0.06691796f, 
    0.02479843f, -0.08214739f, -0.04241895f, 0.00589006f, -0.16880354f, -0.09573432f, -0.04761356f, 0.02879132f, 
    -0.09053473f, -0.10348607f, 0.09440178f, -0.04670743f, 0.33749563f, 0.11762959f, 0.00312902f, 0.20907642f, 
    0.11801522f, 0.09287962f, -0.09630686f, -0.08033471f, 0.00054214f, 0.06898306f, -0.07030631f, -0.03617310f, 
    0.01737890f, -0.00839727f, -0.15317905f, 0.20165771f, -0.17041977f, -0.01009306f, -0.02452922f, 0.08622155f, 
    -0.02067727f, -0.00790699f, 0.03759524f, 0.07024319f, -0.27266484f, 0.17374484f, -0.13871801f, -0.11747495f, 
    0.18088765f, -0.10811867f, 0.01071458f, -0.17363082f, -0.04834587f, 0.07884223f, -0.04796830f, 0.01780387f, 
    0.23403226f, 0.29358920f, 0.20975535f, 0.12271225f, -0.04244572f, 0.12766840f, 0.00355758f, 0.17419137f, 
    0.03474251f, 0.01911505f, 0.04226781f, 0.09853666f, -0.27603260f, -0.45414388f, 0.02390008f, -0.05857955f, 
    -0.10649797f, -0.04127885f, -0.04365463f, 0.01045921f, -0.00811324f, -0.01013968f, -0.03950472f, 0.02309434f, 
    -0.00890961f, -0.15031621f, -0.26888791f, -0.14290769f, -0.06993764f, -0.00459463f, 0.00016337f, 0.00958708f, 
    -0.12612632f, -0.00417343f, -0.06672847f, -0.00954333f, -0.16285749f, -0.34310654f, -0.39868534f, -0.21052366f, 
    -0.05685162f, -0.03138822f, -0.05339608f, 0.00751787f, -0.03194151f, 0.08954370f, 0.10345939f, 0.01992664f, 
    0.01698171f, -0.03569651f, -0.06415537f, 0.08917774f, -0.03201753f, -0.01954937f, 0.06768049f, -0.05668790f, 
    -0.01883128f, 0.09711342f, -0.10017940f, -0.21241382f, -0.12011859f, 0.07486524f, 0.02309679f, -0.05604718f, 
    -0.13721012f, 0.06332586f, 0.02622065f, 0.02904696f, -0.23154810f, 0.01741442f, -0.01739884f, 0.06544565f, 
    -0.18097393f, -0.23639931f, 0.10734139f, 0.16937959f, -0.03589684f, -0.15165600f, -0.05535491f, 0.00129475f, 
    0.04958473f, -0.02990928f, -0.02913372f, -0.05238717f, 0.06908729f, -0.23840070f, -0.30629155f, 0.27063674f, 
    0.25541374f, 0.10383233f, 0.02835483f, 0.02993723f, 0.17062829f, 0.26065156f, 0.08170114f, 0.20277950f, 
    -0.03069632f, -0.07186019f, 0.19205333f, -0.01860323f, -0.15726309f, -0.01918433f, 0.11318596f, -0.20390828f, 
    -0.00329631f, 0.04515873f, 0.05410649f, -0.00945007f, 0.16785663f, -0.29846373f, -0.04145527f, -0.29401550f, 
    0.13785702f, 0.08009168f, -0.04543104f, 0.11520144f, 0.02710595f, 0.04716902f, -0.04225666f, 0.03721956f, 
    0.23807985f, -0.05979485f, 0.11589053f, 0.02073510f, -0.05849540f, 0.13047759f, -0.07646635f, 0.08150901f, 
    0.11849952f, 0.06160736f, 0.03078076f, 0.00867249f, -0.11040711f, 0.05238396f, 0.00192045f, 0.12875269f, 
    0.10930770f, -0.08642788f, 0.05651888f, 0.24155700f, 0.11531203f, 0.16050537f, 0.08211564f, -0.22854726f, 
    0.19696365f, -0.36465731f, 0.15638895f, 0.00860586f, 0.12819418f, -0.08998726f, -0.13685739f, 0.31471080f, 
    0.20971976f, 0.06176114f, -0.05649772f, -0.03032394f, 0.04509387f, -0.07304138f, 0.00645100f, -0.12262951f, 
    0.12687093f, 0.09804203f, 0.14386190f, 0.17199902f, -0.05466142f, -0.02833426f, 0.15259519f, -0.03075454f, 
    -0.13197412f, -0.19590080f, 0.16065256f, -0.01262857f, -0.09865659f, -0.06007422f, 0.03088338f, 0.14699270f, 
    0.11314883f, -0.03208606f, 0.03113132f, -0.04292114f, -0.03430857f, -0.20415589f, 0.08843321f, -0.02722164f, 
    0.00504824f, -0.03889507f, 0.06014196f, 0.15606411f, 0.02428835f, 0.03429433f, 0.02292115f, -0.02415170f, 
    -0.11974581f, -0.11846700f, 0.01282129f, -0.06015167f, -0.09373455f, -0.00682293f, -0.12736829f, -0.01080953f, 
    -0.04355155f, 0.06200757f, -0.05279125f, -0.02624337f, -0.04804631f, -0.01477561f, -0.02782359f, -0.29472181f, 
    -0.10681977f, 0.01402230f, -0.05585179f, 0.00958026f, 0.17395554f, 0.06708926f, -0.00898269f, -0.00284110f, 
    0.20053743f, -0.06213693f, 0.06479533f, -0.20472009f, 0.06594130f, 0.06562573f, 0.05455678f, 0.06092348f, 
    -0.01943369f, 0.00929595f, -0.04125022f, 0.07729524f, -0.51960641f, -0.06677071f, 0.17545775f, 0.15446551f, 
    0.00046205f, 0.03507582f, -0.07551885f, -0.00426318f, 0.04227945f, 0.13870309f, -0.04825441f, 0.08015365f, 
    -0.03075466f, 0.00916583f, -0.12070236f, -0.04769979f, 0.07528525f, 0.12382465f, 0.09032167f, 0.09493164f, 
    0.05493059f, 0.03465587f, -0.08858288f, 0.10058574f, -0.05757002f, 0.10116319f, -0.00750353f, -0.19599715f, 
    0.05246193f, 0.06413756f, 0.22650051f, -0.01429947f, 0.00234879f, 0.22398078f, 0.03974466f, 0.01080045f, 
    -0.40917695f, -0.14318158f, -0.21571460f, 0.08029651f, 0.22364572f, -0.10103577f, 0.03227004f, -0.02221839f, 
    -0.05685529f, 0.00678568f, -0.09505469f, 0.01940313f, -0.12975590f, -0.05839324f, -0.02057633f, -0.27808285f, 
    0.07205803f, -0.11164313f, 0.15378462f, -0.06025565f, 0.01941184f, -0.08345397f, -0.12014874f, 0.05964221f, 
    -0.01542711f, -0.07415527f, -0.03758574f, 0.05234798f, 0.07940894f, -0.01560609f, 0.10583556f, -0.03895662f, 
    0.12930606f, -0.04443737f, 0.01706900f, 0.11682518f, 0.28525409f, -0.06323827f, -0.02533645f, 0.06148233f, 
    0.05532029f, 0.16768219f, 0.04525298f, 0.11257767f, 0.20957026f, -0.06372233f, 0.17665014f, -0.05331707f, 
    -0.15153760f, -0.09413762f, 0.05051991f, 0.08860704f, 0.04830724f, 0.02907572f, 0.00005743f, -0.02915898f, 
    -0.02596879f, 0.01500649f, -0.04709346f, 0.01133463f, 0.18303269f, -0.00695125f, 0.03574343f, 0.20058396f, 
    0.07326040f, 0.02079830f, 0.09924341f, 0.03736511f, 0.19583990f, -0.07047943f, 0.30584252f, 0.08677021f, 
    0.19946861f, 0.09145108f, 0.01368399f, -0.12525986f, 0.05261404f, -0.08234788f, 0.04643813f, -0.03999576f, 
    0.09816174f, -0.04633470f, 0.04899753f, 0.14236179f, 0.09467479f, 0.20425728f, 0.16540027f, 0.03210367f, 
    -0.05441416f, 0.10725698f, 0.05620793f, 0.00304040f, 0.07340308f, 0.05459141f, 0.06872936f, 0.01652340f, 
    0.02927041f, -0.07654168f, -0.03708635f, -0.18178511f, -0.05953083f, 0.03553363f, 0.13040411f, -0.16899848f, 
    -0.01309740f, -0.07449706f, -0.09794211f, 0.03719277f, -0.04581300f, -0.15666063f, -0.18750858f, 0.10775681f, 
    0.08921713f, 0.26751998f, 0.05417370f, 0.00177478f, -0.01702364f, -0.08301957f, -0.03039361f, 0.02489433f, 
    -0.21507649f, -0.18968791f, -0.02877020f, -0.04882467f, -0.12335402f, -0.12186620f, 0.11409818f, -0.04242551f, 
    0.11223527f, 0.03046277f, -0.03070461f, 0.00933621f, -0.06625482f, -0.07695955f, 0.17738247f, -0.02704184f, 
    -0.04741875f, -0.00466425f, 0.04285584f, -0.04450213f, -0.03075380f, -0.01165512f, -0.03131236f, 0.01048465f, 
    0.14672928f, -0.05829628f, 0.05791772f, -0.11795000f, 0.02294336f, -0.06558286f, -0.02923943f, -0.03921763f, 
    -0.05272698f, -0.06550174f, -0.02453879f, 0.11704264f, 0.02472304f, 0.03866057f, 0.00685973f, -0.01785270f, 
    -0.02568423f, -0.02404322f, -0.05637517f, -0.00242103f, -0.18222931f, -0.12408637f, -0.06527227f, -0.09275496f, 
    -0.00290980f, -0.07364184f, 0.04723533f, 0.00038129f, 0.07037817f, -0.02542554f, 0.18670684f, 0.02919741f, 
    -0.02124224f, 0.01142252f, 0.00443743f, 0.09165723f, -0.08626922f, -0.12428724f, 0.05923160f, 0.06710131f, 
    0.10230745f, -0.05319732f, -0.01040919f, 0.06651607f, -0.02518405f, 0.11073281f, 0.12774049f, 0.07998797f, 
    0.04095339f, -0.00235908f, 0.04389275f, -0.04917807f, 0.01762436f, -0.03590368f, -0.00832462f, 0.01822363f, 
    0.00035430f, 0.00055470f, -0.00658255f, -0.01180375f, 0.01907815f, -0.04257488f, 0.04251616f, -0.01024866f, 
    -0.03503996f, 0.00011796f, -0.00022690f, -0.04389606f, 0.02674239f, 0.03990576f, -0.02631671f, 0.00600037f, 
    -0.00043879f, -0.00841014f, 0.03885888f, -0.02168119f, -0.03505239f, -0.05241364f, -0.02887006f, 0.04347833f, 
    -0.04565860f, -0.01805254f, 0.04513254f, -0.01989808f, 0.01402988f, 0.00593270f, 0.03699093f, -0.04732206f, 
    -0.01592855f, -0.05104237f, -0.01690488f, 0.02452339f, -0.01834947f, 0.01449919f, 0.01387619f, 0.03260444f, 
    -0.04717015f, 0.04096424f, -0.01613477f, -0.00375159f, 0.04497777f, -0.02875732f, 0.04202661f, 0.00600627f, 
    -0.01313531f, -0.02953965f, -0.04033305f, 0.04026211f, -0.05059773f, -0.01074373f, 0.01502901f, 0.01883247f, 
    -0.03526757f, -0.01077048f, 0.01294534f, -0.00694383f, -0.05448667f, -0.00829046f, 0.00093291f, -0.00062927f, 
    -0.02868190f, 0.00828518f, -0.00847544f, -0.01281310f, 0.00325792f, -0.04774003f, -0.00687417f, 0.01598578f, 
    0.00798941f, -0.00102770f, -0.03347011f, 0.03856201f, -0.02735211f, -0.00777924f, -0.04244761f, 0.03131384f, 
    -0.00000832f, -0.02383914f, 0.05077406f, -0.02158799f, -0.03251289f, -0.01971547f, 0.04106732f, -0.05322352f, 
    0.00361293f, 0.05037596f, 0.01024699f, 0.01079133f, 0.00447837f, 0.01832346f, 0.00776332f, 0.04555976f, 
    -0.03765979f, -0.04650054f, 0.01409834f, 0.00498347f, 0.03557409f, 0.01346672f, 0.00745479f, 0.02634302f, 
    -0.05484220f, 0.01849094f, 0.02995312f, 0.02506487f, -0.05587536f, 0.01051937f, -0.01796129f, 0.00871816f, 
    0.04422344f, -0.04346523f, -0.03927880f, -0.03387251f, 0.01419286f, 0.01329066f, -0.03077196f, 0.01297535f, 
    0.02320541f, -0.04801377f, -0.03528709f, -0.00552314f, -0.02588123f, 0.02644606f, -0.00841188f, -0.00795146f, 
    -0.01185558f, -0.00174393f, 0.00279979f, 0.02428410f, -0.03248490f, -0.03511102f, -0.02114533f, -0.02462770f, 
    0.01482042f, -0.03580160f, -0.04382790f, 0.02245420f, -0.03829858f, -0.01493977f, 0.01685612f, 0.03965901f, 
    -0.00808399f, 0.01758088f, 0.01216453f, -0.04505174f, 0.01195278f, -0.03629880f, 0.03989347f, -0.04635332f, 
    -0.04585466f, -0.01874686f, -0.00806449f, 0.01443956f, -0.05442093f, -0.01989339f, -0.01378951f, 0.03094072f, 
    -0.04243008f, -0.02859444f, -0.02492145f, 0.02691411f, 0.02696686f, -0.02348947f, -0.05007620f, 0.04443992f, 
    0.01053585f, -0.04892382f, 0.00406185f, -0.05085740f, 0.01915624f, -0.03142072f, -0.02053373f, 0.00489394f, 
    -0.00006681f, -0.00740916f, 0.03322609f, -0.02939823f, -0.01923603f, -0.02261761f, 0.02790590f, -0.02832536f, 
    -0.01990815f, -0.01055621f, 0.01373224f, 0.04198907f, -0.00035226f, 0.02909946f, -0.05051403f, 0.04006354f, 
    -0.03749679f, 0.01608911f, 0.01557235f, 0.00227421f, -0.02712942f, -0.02592782f, -0.01824760f, -0.04019164f, 
    -0.02292540f, 0.02166460f, -0.00881827f, -0.04694599f, -0.03835341f, -0.00440552f, -0.00712393f, -0.00687270f, 
    0.00152960f, -0.00524098f, 0.03215047f, -0.02386586f, -0.02870799f, 0.00683290f, -0.04754388f, 0.04227209f, 
    -0.04690518f, -0.02829883f, -0.01993723f, -0.03096844f, -0.00784777f, -0.05153767f, -0.04852084f, 0.00616638f, 
    0.02622184f, -0.02039797f, 0.03497400f, -0.01376369f, -0.04016502f, -0.01206432f, -0.03035468f, -0.04252291f, 
    0.03622333f, 0.02325431f, -0.03374320f, -0.04236900f, 0.02602403f, -0.01274782f, -0.02548209f, -0.04534688f, 
    -0.04415871f, -0.01849030f, -0.05099432f, -0.04250365f, -0.01272844f, -0.02123933f, -0.02523085f, -0.04139790f, 
    -0.04323247f, 0.03576353f, 0.03727608f, -0.03564410f, 0.03459049f, 0.03178870f, -0.05081079f, -0.02774424f, 
    0.02179787f, 0.00246393f, 0.01299864f, 0.01368815f, -0.05106151f, 0.03204460f, 0.00272842f, 0.02144242f, 
    -0.04592197f, 0.01400550f, -0.04860473f, -0.01327388f, -0.02597425f, 0.01011028f, 0.00640862f, 0.03399560f, 
    -0.02119702f, -0.02366782f, 0.00843151f, 0.02469925f, 0.00436670f, -0.03708121f, 0.01443291f, -0.05358817f, 
    0.01833719f, -0.05358787f, 0.01621543f, -0.04203095f, -0.03506301f, -0.03142720f, 0.00801232f, 0.01450749f, 
    -0.00886593f, 0.00756857f, -0.01563697f, -0.03902892f, -0.02391529f, -0.04475561f, -0.01888684f, 0.03510809f, 
    -0.03880408f, -0.04964710f, 0.02201451f, -0.02985491f, -0.01593459f, -0.03913676f, -0.03852255f, 0.02745938f, 
    0.04344583f, -0.04219692f, -0.04301745f, 0.02314754f, 0.01234464f, -0.02350970f, 0.02066648f, 0.00670151f, 
    -0.03232977f, -0.03596600f, -0.02864322f, 0.03605759f, -0.01288702f, 0.02119836f, -0.04278569f, -0.00040485f, 
    0.00445840f, -0.04933205f, -0.04803132f, 0.03197956f, 0.03523944f, -0.01061619f, -0.04949491f, 0.01485007f, 
    -0.01786569f, 0.02643293f, -0.04413176f, 0.03964586f, -0.00352787f, -0.02492005f, 0.02347438f, 0.00256818f, 
    0.00318012f, -0.00454730f, 0.00271181f, 0.03638791f, 0.00452849f, -0.04149506f, 0.04433715f, -0.00192718f, 
    0.01887816f, 0.03614210f, 0.01279826f, -0.02436697f, -0.02156958f, 0.02880008f, 0.03244743f, -0.01066534f, 
    0.02470631f, -0.04455635f, 0.03250911f, 0.01399824f, -0.04567569f, 0.02283205f, -0.02243832f, -0.04123323f, 
    0.02468713f, 0.04298425f, 0.02884374f, -0.02425258f, -0.02913296f, 0.03617954f, 0.01785184f, 0.00468051f, 
    0.04232527f, 0.01339256f, -0.01035437f, -0.00427039f, -0.04378429f, -0.01248860f, -0.01227322f, -0.02024580f, 
    0.00519385f, -0.03644311f, 0.01141568f, -0.02011752f, -0.03707565f, 0.02675314f, -0.01667185f, -0.01108216f, 
    0.03402450f, 0.03980087f, 0.01253116f, 0.04271543f, -0.05117638f, 0.01338401f, 0.00159561f, -0.05255095f, 
    -0.05656061f, 0.02097277f, -0.00337340f, 0.02397625f, -0.02945300f, -0.04789467f, -0.04978105f, -0.01167659f, 
    -0.05394860f, 0.01333141f, -0.01028574f, 0.04032999f, 0.02078193f, -0.01709677f, -0.01949772f, -0.01768024f, 
    0.00914041f, -0.04692861f, 0.01377746f, -0.00971921f, 0.03226459f, -0.04506167f, -0.01925861f, -0.01064761f, 
    -0.02787429f, -0.05388207f, -0.03133301f, 0.01050191f, 0.00095858f, -0.02508785f, -0.00082615f, -0.04505372f, 
    -0.01657900f, -0.01328667f, -0.00569447f, -0.01404366f, 0.03499696f, -0.00976263f, -0.01552903f, -0.03230597f, 
    0.04456005f, 0.02544078f, 0.00268555f, -0.02224362f, 0.04073635f, 0.01514767f, 0.02384744f, 0.03661845f, 
    0.01105789f, -0.03519351f, -0.05029075f, -0.00073216f, -0.02532981f, 0.03385391f, 0.02526143f, -0.00989802f, 
    0.02506742f, -0.02004488f, 0.04040773f, 0.04268404f, -0.03901913f, 0.02070613f, 0.01405483f, 0.00080830f, 
    -0.05050553f, -0.05214584f, -0.02708090f, -0.03697189f, 0.01394241f, -0.00054010f, 0.03410282f, 0.02723264f, 
    -0.04635787f, -0.04003726f, -0.03361255f, -0.01930548f, -0.05395908f, -0.00566119f, 0.00053361f, 0.01904075f, 
    -0.01620361f, -0.00227466f, 0.03880946f, -0.04582245f, -0.01590277f, -0.05360669f, 0.00784180f, 0.01862202f, 
    0.00045317f, 0.01577364f, -0.02112039f, -0.00303036f, -0.03980253f, -0.00948797f, -0.00969349f, 0.02060540f, 
    -0.05548543f, -0.03555784f, 0.01825655f, 0.02122631f, -0.02859626f, 0.03256816f, -0.05529402f, 0.03563571f, 
    -0.02961107f, -0.01351069f, 0.02218009f, -0.03793726f, 0.04002976f, 0.01202917f, -0.01013390f, -0.03573279f, 
    0.04020901f, -0.02101982f, 0.03767663f, -0.02749068f, -0.00193360f, -0.03360277f, 0.02692969f, -0.03530225f, 
    -0.02817697f, -0.01831441f, 0.01066277f, -0.03171198f, -0.03268676f, -0.01892891f, -0.01416348f, -0.01295611f, 
    -0.02461633f, 0.03243894f, 0.03739931f, 0.00673288f, -0.02686794f, -0.05174864f, 0.03301001f, -0.00682655f, 
    0.00027911f, 0.03749114f, -0.02365788f, -0.03301419f, -0.04549610f, -0.03943312f, 0.00056959f, -0.03205786f, 
    0.02621359f, 0.01463270f, 0.00104564f, -0.01844336f, 0.04408297f, -0.03895580f, 0.01407035f, -0.04532107f, 
    0.04133255f, 0.03539085f, -0.03755456f, -0.04755415f, -0.02586060f, -0.03694024f, -0.00303578f, 0.04450517f, 
    -0.04420270f, 0.04055412f, 0.00534463f, -0.00916377f, -0.04847097f, -0.00311122f, 0.02755182f, -0.03385327f, 
    -0.04690656f, 0.01394188f, 0.03811702f, -0.03513962f, 0.00069713f, -0.01183729f, -0.00346194f, 0.01514449f, 
    0.02122338f, -0.03204305f, 0.02655965f, -0.04652782f, -0.00198743f, -0.05429604f, -0.02371728f, -0.04977851f, 
    -0.04054284f, 0.03482994f, -0.03038866f, 0.03608632f, -0.05669870f, 0.00429525f, -0.00991031f, 0.04481074f, 
    0.00832700f, 0.02493307f, -0.04125334f, -0.01512967f, -0.02026008f, -0.00606874f, -0.02791302f, 0.03775495f, 
    -0.01835287f, -0.00477701f, -0.00061275f, 0.00890040f, 0.03241710f, -0.04213888f, -0.00744145f, 0.02156395f, 
    -0.00028141f, -0.00803692f, -0.04345043f, -0.01071211f, 0.04238010f, -0.03177486f, -0.04398403f, 0.03838193f, 
    0.01094638f, -0.03236582f, -0.00459971f, -0.03425280f, -0.04042743f, -0.01312219f, -0.04178138f, -0.00345940f, 
    -0.00406287f, 0.00749215f, -0.04015415f, -0.00558236f, -0.00019094f, -0.04417178f, -0.02235646f, -0.03332395f, 
    -0.03034363f, -0.01229819f, -0.02215786f, -0.01399980f, -0.02027868f, -0.04455035f, -0.04618293f, 0.00817683f, 
    -0.00030505f, 0.00168365f, -0.05433761f, -0.03461766f, -0.04222409f, -0.04422078f, -0.01025232f, 0.00890162f, 
    -0.00016023f, 0.00044471f, -0.01878602f, 0.02903298f, 0.01715255f, 0.03979817f, -0.04097803f, -0.03219325f, 
    -0.00828679f, 0.02429983f, 0.03897228f, -0.01393461f, 0.00326993f, -0.01147803f, 0.03975413f, -0.05072187f, 
    -0.05345930f, 0.03916418f, -0.05502730f, 0.01095427f, 0.01264780f, -0.03483729f, 0.03924840f, -0.03395939f, 
    -0.02283796f, 0.01033627f, 0.00386636f, -0.04001756f, 0.00356966f, -0.03512367f, 0.03585922f, -0.00721071f, 
    -0.02424313f, 0.00019497f, 0.00116760f, 0.01659502f, -0.02779689f, -0.04881415f, 0.02314124f, -0.03306892f, 
    -0.01742233f, -0.02313027f, -0.05195580f, 0.00489261f, 0.04314282f, -0.01228433f, -0.03187643f, -0.05413973f, 
    -0.05090972f, 0.02900978f, 0.02235203f, 0.03312692f, -0.02222332f, -0.03631031f, 0.02688172f, 0.01709595f, 
    -0.04192462f, -0.05454486f, 0.02330176f, -0.02256778f, -0.03794433f, 0.02599135f, -0.00114653f, -0.05068886f, 
    -0.03630521f, -0.05220114f, -0.03347987f, 0.02213674f, -0.01785886f, 0.03837603f, -0.05281667f, -0.02888602f, 
    -0.02421013f, 0.00722755f, -0.02188475f, -0.02867049f, -0.01661524f, -0.02279823f, 0.02491353f, 0.00867355f, 
    0.01322435f, 0.00510229f, -0.05439140f, -0.05224561f, 0.00332266f, 0.02975735f, -0.02992232f, -0.05544332f, 
    0.01608253f, -0.05533131f, 0.03368509f, 0.02859327f, 0.02234519f, -0.04848144f, 0.02875489f, -0.04970066f, 
    0.03713141f, -0.01556280f, 0.00186697f, 0.00941534f, -0.03848793f, 0.00870828f, -0.03942739f, 0.02787500f, 
    0.01636136f, 0.00782604f, -0.01333990f, -0.01175315f, -0.04282512f, -0.01407003f, 0.03710312f, 0.02370732f, 
    0.02738323f, 0.01897120f, -0.01538049f, -0.01992312f, 0.02522254f, -0.02397879f, -0.00500658f, 0.04048537f, 
    -0.16331941f, -0.17549799f, 0.16515088f, 0.14522158f, 0.12681217f, -0.11712862f, -0.08376171f, 0.20376498f, 
    0.06447197f, -0.04395070f, -0.09578342f, -0.06096736f, -0.02489387f, -0.25460622f, -0.05268012f, 0.26411116f, 
    0.09942944f, 0.10518347f, -0.02437782f, -0.14662878f, 0.08188926f, 0.12389807f, 0.07158490f, 0.04968769f, 
    -0.13494666f, -0.13221703f, 0.16630682f, -0.05330816f, -0.03097622f, 0.04897476f, 0.16051835f, 0.17711638f, 
    -0.01381355f, -0.00753905f, 0.02015240f, -0.07643017f, 0.01645917f, -0.17382839f, 0.19441757f, -0.10896540f, 
    0.14055645f, 0.00960985f, -0.02310592f, 0.04249053f, -0.02162708f, -0.12937236f, -0.03005539f, -0.02523354f, 
    0.14959742f, 0.04057498f, 0.11447766f, 0.10004682f, -0.08341884f, -0.00387489f, -0.01659588f, 0.01629403f, 
    0.05312975f, -0.01415896f, 0.06680492f, -0.03673643f, -0.03141057f, 0.08992603f, 0.16440858f, -0.12762736f, 
    0.10155818f, -0.06515472f, 0.03846276f, 0.11160060f, -0.02502681f, 0.04512540f, -0.12262508f, -0.10491765f, 
    0.08833022f, 0.07706599f, 0.22636110f, 0.04594626f, 0.04961849f, -0.07844122f, -0.13403283f, -0.08214781f, 
    -0.00393614f, -0.02251946f, -0.01975620f, 0.01244122f, 0.10071890f, -0.20893717f, 0.27755350f, -0.00384274f, 
    0.09054413f, -0.10883770f, 0.06545886f, 0.11467546f, -0.02194319f, 0.02626713f, 0.11395062f, 0.04580069f, 
    0.00060602f, -0.23309815f, -0.02874547f, -0.00737919f, -0.00685698f, -0.01596498f, 0.01625106f, 0.01650184f, 
    -0.01564544f, 0.04568043f, -0.05021013f, 0.03381692f, 0.05475596f, 0.02171194f, 0.01269369f, 0.09381457f, 
    -0.01239698f, -0.06386693f, -0.08129194f, 0.07028677f, 0.02469467f, -0.06046439f, 0.02911692f, -0.00349285f, 
    -0.03309261f, -0.06793693f, -0.08361367f, -0.01781933f, -0.09849376f, -0.01584617f, -0.04418345f, -0.05978373f, 
    -0.02440100f, -0.04468363f, -0.06511515f, 0.05613573f, -0.24373645f, -0.05608622f, 0.03621856f, -0.06742661f, 
    -0.02745131f, -0.06045510f, 0.16677977f, 0.01041237f, 0.00138252f, 0.08594827f, -0.07015803f, -0.07312425f, 
    0.33860675f, 0.12889469f, -0.00825769f, -0.11333558f, -0.08599471f, -0.07034343f, -0.09570245f, 0.05514544f, 
    -0.04775404f, -0.03381801f, 0.09731894f, -0.00425292f, -0.00330672f, -0.03426124f, -0.01545084f, -0.12365525f, 
    -0.05753000f, 0.07069100f, -0.06757370f, 0.11501117f, 0.06539356f, 0.10498337f, -0.11200962f, -0.04264066f, 
    0.05371732f, 0.03217348f, -0.03458930f, 0.03475688f, -0.03574068f, 0.29030713f, 0.08576726f, 0.03324824f, 
    -0.02917826f, 0.07053415f, -0.05874873f, 0.01443993f, -0.07709016f, -0.05351353f, 0.00536974f, -0.13749568f, 
    0.03573602f, 0.16197136f, 0.11908158f, 0.04685457f, 0.05424494f, -0.04733524f, 0.10775016f, 0.14314009f, 
    -0.08180643f, 0.22181663f, -0.01935740f, 0.02367947f, -0.00961353f, 0.05030912f, 0.07596873f, 0.06695818f, 
    -0.03853621f, 0.04906458f, -0.09501036f, 0.02548853f, 0.29043150f, 0.13830541f, -0.17541738f, -0.25044060f, 
    -0.01879367f, -0.00597084f, -0.09106228f, 0.01486506f, -0.03622713f, 0.10671373f, 0.05294777f, -0.07206133f, 
    -0.06875216f, 0.06271987f, -0.10697770f, -0.00946604f, 0.07332694f, -0.06115981f, -0.03277056f, -0.00712460f, 
    0.05400893f, -0.06376301f, 0.09130983f, 0.04206132f, -0.05047009f, -0.08461963f, 0.20079215f, 0.04267960f, 
    0.08811831f, 0.08879547f, 0.10974946f, -0.04894165f, -0.00518766f, 0.09174395f, -0.21970041f, 0.08199093f, 
    -0.07127383f, -0.05414207f, 0.00659299f, 0.17933314f, 0.05525018f, 0.16589585f, 0.00182235f, 0.09588982f, 
    -0.02809077f, -0.00917222f, -0.02353056f, -0.06385690f, 0.02104969f, 0.04999778f, -0.25133401f, 0.06825009f, 
    -0.04317966f, -0.02476630f, 0.07630087f, 0.01175372f, 0.00899606f, -0.05194824f, 0.02385589f, -0.01069536f, 
    0.07420272f, 0.21238042f, -0.01843303f, -0.08797645f, 0.04054242f, -0.01304000f, 0.05781248f, 0.01839493f, 
    0.09342623f, 0.05335536f, -0.18122546f, 0.00745323f, 0.18743454f, 0.19717659f, 0.17215867f, -0.20690989f, 
    -0.04365332f, -0.05476514f, 0.06006623f, -0.00709213f, 0.06641324f, 0.06705122f, 0.01595716f, 0.02943559f, 
    -0.12775032f, 0.17869741f, 0.06848627f, -0.08055089f, -0.21772592f, 0.10876701f, 0.19685158f, 0.08922186f, 
    -0.02653172f, -0.11318773f, -0.04729836f, 0.06828038f, -0.15588252f, 0.14882971f, 0.00071947f, -0.00316876f, 
    0.02530761f, -0.05667698f, -0.11319077f, 0.03558421f, 0.02179072f, -0.02439263f, 0.06603425f, 0.02511773f, 
    -0.23736376f, 0.05972585f, 0.14172858f, 0.18793647f, -0.15145646f, 0.01138418f, -0.02171567f, 0.05485848f, 
    -0.00184965f, -0.12824091f, 0.07093910f, 0.02663662f, 0.22598496f, 0.19259471f, -0.24502198f, 0.07210737f, 
    -0.09293246f, -0.08296852f, 0.07879093f, -0.03576605f, 0.01965926f, 0.03978500f, -0.10352596f, -0.17310081f, 
    0.38086700f, 0.17808017f, -0.27403650f, 0.01969032f, -0.06783111f, -0.14263554f, -0.02491052f, 0.06932356f, 
    0.05629352f, -0.04317526f, -0.03874499f, -0.07433302f, 0.15600125f, 0.20661974f, 0.17001230f, -0.06390744f, 
    -0.11285739f, -0.08245087f, -0.10247547f, 0.04109450f, -0.04522664f, -0.04458848f, -0.02391749f, -0.06848346f, 
    -0.00837005f, -0.01278353f, 0.07018426f, -0.01503059f, 0.04889607f, 0.07708344f, -0.07216741f, -0.08058129f, 
    -0.00310408f, 0.08692646f, -0.14475860f, 0.12594937f, -0.05572532f, -0.07446409f, -0.03938974f, 0.07303227f, 
    -0.06076543f, -0.02476513f, 0.05491194f, -0.04533428f, 0.00991208f, -0.05283226f, 0.07643738f, -0.03820547f, 
    0.14359546f, -0.10803256f, -0.32219291f, 0.01698745f, -0.05549179f, -0.01266700f, 0.05392916f, -0.13948967f, 
    -0.03205663f, -0.05918811f, 0.01669571f, 0.07266340f, -0.13572021f, 0.13898221f, -0.22563916f, -0.27354616f, 
    -0.12667848f, 0.01380430f, 0.05551484f, 0.17302151f, -0.14607246f, 0.06398504f, -0.09827977f, 0.08660164f, 
    -0.13819402f, -0.06204608f, -0.15600561f, 0.19597888f, 0.02969270f, 0.00603545f, 0.06813475f, -0.13229866f, 
    -0.16535778f, -0.01910119f, -0.05469196f, -0.01985194f, 0.18072772f, -0.21279949f, -0.01016601f, 0.25522286f, 
    -0.00140455f, -0.05697435f, -0.00326942f, 0.10638024f, -0.15631835f, 0.06608784f, 0.09026746f, 0.16338874f, 
    -0.05077625f, 0.07850431f, -0.18352184f, 0.05042008f, 0.04542599f, 0.04234672f, 0.06282350f, 0.07080564f, 
    -0.13588575f, 0.03869158f, 0.06706162f, -0.03667974f, 0.44581220f, -0.13143389f, -0.05480639f, -0.07582574f, 
    0.03955050f, 0.05829216f, 0.06750207f, -0.00501227f, 0.00308387f, 0.06718968f, 0.11425547f, 0.15345933f, 
    0.02010382f, -0.04324919f, -0.28490150f, -0.01542745f, -0.08565403f, 0.01148906f, 0.08719596f, 0.20162669f, 
    -0.09571361f, 0.02812598f, -0.16409025f, 0.02608178f, 0.41081867f, -0.32226786f, 0.25535461f, -0.47506750f, 
    -0.24397641f, 0.18751283f, -0.06387548f, -0.04510322f, 0.00424688f, 0.02379051f, 0.01257800f, -0.06893083f, 
    -0.21975456f, 0.12519142f, -0.18944076f, -0.11011124f, -0.00748764f, -0.02222687f, 0.07824399f, 0.06308062f, 
    0.06827679f, 0.13558012f, 0.07844049f, 0.07071177f, 0.08124306f, 0.01656439f, -0.10107746f, 0.00521706f, 
    -0.07816990f, -0.06922774f, -0.03243746f, 0.06453203f, 0.11246316f, 0.06041821f, 0.04342610f, 0.08798338f, 
    0.13536602f, -0.06479774f, -0.01889016f, -0.14164951f, 0.04543608f, 0.05524388f, 0.04103218f, 0.07713597f, 
    -0.00304708f, 0.04742378f, 0.04666030f, -0.11613391f, 0.10127216f, -0.28110543f, 0.14124677f, -0.00045439f, 
    0.14469244f, 0.04211029f, -0.18732172f, -0.12719113f, 0.15899143f, -0.02155720f, 0.02692955f, 0.11634765f, 
    -0.00188025f, -0.03456520f, 0.20853505f, 0.03877399f, 0.07309686f, -0.01933193f, 0.04582265f, -0.11777824f, 
    0.03759383f, 0.01598530f, 0.01672381f, 0.12107393f, 0.27188721f, 0.24031289f, 0.44983935f, 0.45405659f, 
    0.12287198f, -0.03534504f, 0.10725591f, -0.06905331f, -0.05908570f, 0.00188164f, 0.00992073f, 0.08746345f, 
    -0.15723820f, 0.08268416f, 0.06842875f, 0.13314663f, 0.08341491f, -0.04542800f, -0.04107619f, -0.05225761f, 
    0.00687568f, -0.02047590f, -0.09227766f, -0.08922292f, 0.09284651f, 0.16651168f, 0.17953102f, 0.05944988f, 
    0.05307403f, -0.05716031f, -0.02748866f, -0.06507303f, -0.00200904f, 0.12521195f, 0.01784380f, -0.09552664f, 
    0.50489533f, -0.21264234f, 0.12913877f, 0.09564996f, -0.01637174f, 0.14319888f, -0.05987645f, -0.16391174f, 
    0.02876681f, 0.01917718f, 0.04547118f, -0.01855769f, 0.08257776f, -0.02335761f, 0.24539304f, -0.00458020f, 
    -0.10265402f, 0.04938668f, -0.00936647f, -0.17334217f, 0.05827855f, 0.09392351f, -0.05401355f, 0.09847365f, 
    -0.05910831f, 0.14525956f, 0.05407608f, -0.02229017f, 0.10201457f, 0.00209366f, -0.05269487f, 0.03105316f, 
    -0.06485830f, 0.02309718f, -0.03438024f, -0.07584562f, 0.36217615f, 0.00267897f, -0.00426339f, 0.12862895f, 
    -0.09301736f, 0.10476584f, 0.00353737f, 0.03197284f, 0.08997898f, -0.19368498f, 0.10011809f, 0.03653208f, 
    -0.05080339f, -0.09335195f, -0.09268747f, 0.04860234f, 0.00655893f, -0.07664509f, -0.01341028f, -0.19444224f, 
    -0.04746364f, -0.04623514f, -0.04767767f, -0.08471236f, -0.21032119f, 0.12735803f, 0.01158543f, 0.00780928f, 
    -0.01144374f, 0.06837013f, -0.03856656f, -0.03540787f, 0.07197291f, 0.00506131f, -0.00340824f, -0.03038856f, 
    -0.10208668f, 0.14184026f, 0.04281266f, 0.12119116f, -0.00910171f, -0.10441442f, 0.05022815f, -0.11925402f, 
    -0.12391783f, 0.04014789f, 0.14961702f, -0.03046129f, -0.09016294f, 0.23860309f, -0.03314685f, 0.37279716f, 
    -0.01461964f, 0.14741865f, 0.01919514f, -0.02907200f, 0.07409658f, 0.09696925f, 0.02973710f, 0.12712471f, 
    -0.36319104f, 0.34924620f, -0.13476720f, 0.46143550f, 0.01741248f, -0.02849723f, 0.08027359f, -0.19042870f, 
    -0.01028866f, 0.01127955f, 0.06829498f, -0.02916122f, 0.00365784f, 0.19212671f, -0.23084579f, 0.08238175f, 
    -0.16986816f, -0.06890113f, 0.16623488f, 0.03992312f, -0.04576090f, 0.01500763f, -0.07258137f, 0.08656280f, 
    -0.23681793f, -0.03165143f, -0.04675785f, 0.03775801f, 0.10753963f, 0.01509433f, 0.00375935f, 0.04883866f, 
    0.01048196f, 0.02601423f, -0.05735105f, 0.00362571f, -0.02425937f, -0.10402349f, -0.16216898f, -0.02212684f, 
    0.03076550f, -0.01101548f, 0.02480872f, 0.01275883f, -0.00501753f, 0.04954095f, 0.01484465f, -0.04270849f, 
    0.02831782f, 0.31603667f, 0.02358077f, -0.12178518f, 0.06216019f, 0.02624874f, 0.01592403f, -0.03763448f, 
    -0.09469204f, -0.03368181f, -0.10134716f, -0.03337922f, -0.03405987f, -0.11030204f, -0.06197747f, -0.03351110f, 
    0.03297138f, -0.02522874f, -0.11941405f, 0.01141066f, -0.03895063f, 0.02584274f, -0.00186337f, 0.11737721f, 
    0.15009764f, 0.03792360f, 0.12339485f, 0.19552881f, -0.12009219f, 0.11250347f, -0.09928177f, -0.00563976f, 
    0.04124177f, -0.10603957f, -0.05986172f, -0.34149855f, 0.18017814f, 0.00144228f, -0.14976154f, -0.16381255f, 
    0.11244257f, 0.03360362f, -0.15555552f, 0.22853932f, -0.01893021f, 0.06288623f, -0.09883293f, -0.01485760f, 
    -0.08936181f, -0.25411844f, -0.06287522f, 0.18411176f, 0.03794783f, -0.09165283f, -0.03631243f, -0.02868054f, 
    -0.04872442f, -0.10285614f, -0.11532986f, 0.14581805f, -0.14277399f, 0.13807619f, -0.43574724f, 0.23189959f, 
    -0.08403294f, 0.01095634f, 0.06100085f, 0.01708188f, 0.05816239f, 0.18544556f, -0.07278133f, 0.19610363f, 
    -0.26160267f, -0.14635275f, -0.01335503f, 0.14753449f, -0.05877128f, -0.03587321f, 0.09006748f, -0.00861617f, 
    -0.06766945f, 0.01300064f, 0.01275941f, 0.09642493f, 0.05018285f, -0.04580667f, 0.19427159f, -0.12169619f, 
    0.04259764f, -0.00029594f, 0.01527469f, 0.09165460f, 0.00711486f, 0.03112764f, -0.01038517f, 0.10966804f, 
    0.19844602f, -0.04093899f, -0.04248133f, -0.04086430f, 0.02306573f, 0.19083884f, 0.01314548f, 0.06405598f, 
    0.20821323f, 0.06359568f, 0.02981707f, -0.01420366f, 0.20783167f, -0.12961961f, -0.09966471f, 0.07739522f, 
    0.13909729f, -0.14576775f, 0.00865158f, 0.11000779f, 0.04778919f, 0.15960011f, 0.12556811f, 0.06748830f, 
    0.17441441f, -0.43976304f, -0.02312391f, 0.07370380f, 0.19379875f, 0.02760115f, -0.02127329f, 0.08105489f, 
    0.14475857f, 0.15738766f, -0.08275383f, -0.02620285f, 0.23944208f, -0.03824804f, 0.22481988f, -0.24780639f, 
    0.06285933f, -0.00560262f, 0.18117981f, 0.01615276f, 0.09714194f, 0.04961555f, 0.11201261f, -0.01453922f, 
    -0.36513361f, -0.24746656f, 0.10615120f, 0.11585906f, -0.06868552f, -0.09026732f, 0.03027443f, 0.15891564f, 
    -0.06554553f, -0.04453438f, 0.05061190f, -0.03010461f, -0.07515374f, -0.21517789f, 0.08580059f, 0.13329010f, 
    0.02606990f, -0.10976007f, -0.07633760f, -0.03063272f, 0.06325256f, 0.04068105f, 0.06308303f, 0.14821738f, 
    0.00369887f, -0.17015935f, 0.07393238f, -0.03835414f, -0.06580910f, 0.05258757f, -0.06060921f, -0.03880892f, 
    -0.01762763f, -0.05837081f, -0.03262862f, -0.14883333f, -0.01323745f, 0.12486360f, -0.01858526f, -0.25573245f, 
    0.06807469f, 0.06202680f, -0.04845705f, 0.00680054f, 0.16263434f, 0.08491618f, -0.12257741f, -0.00403773f, 
    0.25015628f, 0.02524595f, 0.36959457f, -0.09896788f, 0.04407769f, 0.00839380f, -0.01211906f, 0.01527862f, 
    0.03309125f, -0.00815719f, 0.07803158f, 0.19253427f, 0.01852952f, 0.30086327f, 0.45147178f, 0.31539962f, 
    -0.02388009f, -0.12803483f, -0.15877001f, -0.04465127f, -0.10785029f, 0.09296499f, 0.02602733f, 0.06155458f, 
    0.08744414f, 0.00621187f, 0.09490872f, 0.07796516f, 0.06228599f, -0.03750533f, 0.02115467f, -0.01235825f, 
    -0.04334490f, 0.02428359f, -0.12933825f, 0.05676116f, -0.01487455f, 0.03089679f, -0.00495811f, -0.18223104f, 
    0.01479883f, 0.07703645f, 0.10911813f, 0.00278193f, 0.11360352f, 0.15399908f, 0.07862550f, -0.06935716f, 
    0.00869232f, -0.19763695f, -0.15885894f, 0.00725899f, 0.16123363f, -0.08259311f, -0.04696878f, -0.10524724f, 
    -0.07681274f, 0.04460736f, -0.21906199f, -0.01130470f, 0.09732772f, -0.05921897f, 0.18564478f, -0.11784542f, 
    -0.03389359f, -0.10239542f, 0.12582897f, -0.12342560f, 0.13357380f, 0.05824849f, -0.14277594f, 0.12850189f, 
    -0.13979767f, 0.02905539f, -0.06474905f, 0.09794825f, 0.06109568f, -0.05135473f, 0.03861492f, 0.01089875f, 
    -0.03657350f, -0.04820974f, 0.05502019f, -0.01921423f, 0.29272151f, -0.02293583f, -0.09243027f, 0.03772530f, 
    -0.04664298f, 0.02151009f, 0.11779839f, 0.08044915f, 0.13516973f, -0.12998301f, 0.18490000f, 0.06097685f, 
    -0.27740675f, -0.15137139f, -0.07199733f, 0.08624824f, -0.00095307f, 0.01477415f, 0.00554811f, -0.08300887f, 
    -0.08801400f, -0.05906488f, -0.10761783f, -0.03507793f, -0.02631563f, 0.00784898f, 0.04863944f, 0.19994541f, 
    0.10720142f, -0.02593745f, -0.04675962f, -0.00111686f, 0.06718627f, -0.07028615f, -0.04291086f, 0.08254235f, 
    0.24218525f, 0.01647437f, 0.16453171f, -0.01469749f, 0.10182360f, -0.06711006f, 0.05036985f, -0.05314531f, 
    0.08208643f, -0.06396255f, 0.01518528f, 0.10182907f, 0.01364810f, 0.41878307f, 0.29104176f, 0.26981369f, 
    -0.05505450f, 0.04851002f, 0.08566254f, -0.04774431f, 0.00125734f, 0.11735053f, 0.08907363f, 0.11808638f, 
    -0.33033881f, 0.16149956f, -0.31777889f, 0.07324871f, -0.05677008f, 0.02728812f, -0.01333747f, -0.10774197f, 
    0.04393137f, -0.08377200f, 0.03756719f, -0.04818442f, -0.20915842f, -0.06195844f, -0.30736780f, 0.09434456f, 
    0.00005050f, 0.02338708f, -0.00778529f, 0.02081012f, 0.01049653f, -0.00737261f, -0.04309341f, 0.14678191f, 
    -0.17615168f, -0.18838233f, -0.10099275f, 0.00625200f, -0.08084270f, -0.07102820f, 0.06274977f, 0.10193306f, 
    -0.00437351f, -0.01459366f, -0.07519726f, 0.01147067f, -0.10284433f, 0.06715899f, 0.20737198f, 0.16438845f, 
    0.09342197f, -0.01817839f, 0.01043238f, -0.01254944f, -0.11935215f, -0.05052343f, 0.11064315f, 0.00587914f, 
    0.37180740f, 0.09087851f, 0.02879521f, -0.08085318f, 0.07223447f, -0.13396640f, -0.07631648f, -0.03759022f, 
    -0.05542388f, -0.08974500f, -0.03180120f, 0.16938597f, -0.00101413f, 0.02979810f, 0.08355068f, 0.02976688f, 
    -0.09101483f, -0.00349315f, -0.06847003f, 0.03413965f, -0.01021822f, -0.10456889f, -0.01272766f, -0.00572702f, 
    0.05208104f, -0.04801373f, -0.04558187f, 0.04134030f, 0.14828026f, 0.08584804f, 0.02953611f, 0.02693574f, 
    0.02281128f, 0.03036233f, -0.12098050f, -0.14473896f, -0.01409736f, -0.04780056f, -0.00396976f, 0.18289505f, 
    0.09612511f, -0.03226635f, -0.08494757f, 0.17180099f, 0.00600837f, -0.05358004f, 0.05305173f, 0.06067061f, 
    0.10192339f, 0.18923773f, 0.28694084f, -0.01738630f, 0.05886854f, 0.05960447f, 0.09909059f, 0.10124204f, 
    0.03204070f, 0.05376629f, 0.11598247f, -0.03175870f, 0.24630615f, -0.27712360f, 0.27436090f, 0.04125131f, 
    0.08703505f, 0.00953639f, 0.02153936f, -0.03059809f, 0.03332351f, -0.03314149f, 0.10950723f, 0.02568826f, 
    0.29351988f, 0.15554434f, 0.24591742f, -0.07701711f, 0.13308693f, 0.05540163f, 0.10006858f, 0.13720645f, 
    0.02353049f, -0.06952769f, 0.02932374f, -0.02902161f, -0.04165126f, 0.06903476f, 0.11088791f, 0.07973031f, 
    0.04321789f, -0.00694205f, -0.08639546f, -0.09721145f, 0.05445681f, 0.04389921f, 0.18794234f, 0.05241142f, 
    -0.09778107f, -0.03115273f, -0.03890732f, 0.08483461f, 0.00954145f, -0.02283763f, -0.07051875f, 0.01438129f, 
    -0.01256978f, -0.00176678f, 0.03616538f, 0.06233657f, -0.26849544f, 0.14220113f, 0.04593609f, 0.03446476f, 
    -0.08894602f, 0.11388710f, 0.06590261f, 0.00465004f, 0.12856540f, -0.04845314f, 0.03745298f, 0.05007784f, 
    -0.11622260f, 0.45752582f, 0.20325580f, -0.11997511f, 0.01343684f, 0.02530376f, -0.06806011f, 0.10402295f, 
    -0.10431793f, -0.07356558f, 0.04092573f, -0.10482130f, -0.08711865f, 0.08200072f, -0.14557536f, 0.19278848f, 
    0.10605847f, 0.01096584f, -0.15239799f, 0.05912863f, -0.11548197f, -0.08791485f, 0.00548174f, 0.01268324f, 
    0.50758535f, 0.14055850f, 0.01147585f, 0.04722103f, 0.07573368f, 0.01403859f, -0.05439423f, -0.06339847f, 
    0.14575681f, 0.00162023f, -0.10112698f, -0.04073315f, -0.00651093f, 0.14205517f, 0.10676992f, 0.01587074f, 
    0.04185895f, -0.01439810f, -0.02798948f, -0.05964097f, 0.11805730f, 0.00956873f, 0.11827639f, 0.02355682f, 
    -0.03441646f, 0.13135356f, -0.39316422f, -0.03353780f, 0.11286749f, -0.14697793f, -0.13685320f, -0.06569611f, 
    -0.04716883f, -0.08725115f, -0.04803719f, -0.05089623f, -0.14459361f, 0.07550880f, 0.00429311f, 0.24871089f, 
    -0.11790220f, 0.04445666f, 0.05091993f, -0.04123787f, 0.06485032f, 0.12419763f, 0.19316623f, -0.05769487f, 
    -0.03608291f, 0.09163182f, -0.39863309f, 0.16495481f, -0.01300372f, 0.04952294f, 0.02530350f, 0.12424888f, 
    0.02235676f, 0.02841305f, -0.03815714f, -0.12063698f, -0.09406993f, -0.09013136f, -0.25002915f, -0.13285607f, 
    0.01688466f, 0.12777956f, 0.02642000f, -0.08794340f, 0.21755876f, -0.04075651f, -0.03722923f, -0.01602444f, 
    0.04559390f, 0.05393166f, -0.04410252f, -0.13504131f, -0.04479214f, 0.21602561f, -0.00846912f, -0.09467793f, 
    -0.00891650f, -0.01706960f, -0.08518156f, -0.22187570f, 0.08295498f, 0.25718182f, 0.00271166f, 0.00219408f, 
    0.05686913f, -0.00801031f, -0.01373529f, 0.04840781f, -0.11060146f, 0.03435159f, -0.05488713f, -0.08420803f, 
    -0.07777039f, -0.00745640f, 0.07772755f, -0.02564239f, 0.02318138f, 0.03830796f, 0.08343227f, 0.12622716f, 
    0.01925533f, -0.12120368f, 0.12551379f, -0.04324964f, 0.01949348f, 0.18421072f, -0.12616080f, -0.01846403f, 
    0.06070907f, 0.05579053f, -0.06087657f, 0.23337707f, -0.01520797f, 0.09015578f, 0.22103862f, -0.06742226f, 
    0.11257379f, -0.16828768f, -0.12631293f, -0.07437290f, 0.07419344f, 0.02792751f, 0.02514160f, -0.05664325f, 
    -0.13838688f, 0.00786291f, -0.18156652f, 0.04022374f, -0.08315194f, 0.11056958f, 0.05154166f, -0.06240986f, 
    0.11126902f, -0.10202724f, -0.05697024f, -0.10046090f, -0.03253738f, 0.11414585f, -0.14758690f, -0.00492057f, 
    0.24335685f, 0.18007012f, 0.17403553f, -0.02314581f, 0.14674832f, 0.12919010f, 0.06735404f, 0.13617294f, 
    -0.00698925f, -0.06279221f, -0.01007086f, 0.00422937f, 0.11860784f, -0.04508633f, -0.22853595f, -0.06471846f, 
    -0.04907505f, 0.05587096f, 0.14581542f, -0.02705108f, -0.00593133f, 0.08199248f, -0.14363363f, 0.02878030f, 
    -0.24093723f, 0.11473361f, -0.22212708f, -0.12192564f, 0.04388664f, -0.00456377f, 0.05420173f, 0.05583579f, 
    -0.04312185f, 0.17874175f, -0.07146852f, -0.07448170f, -0.02737145f, -0.18991058f, -0.14734246f, -0.22583981f, 
    0.02220565f, 0.02379305f, 0.14103469f, 0.15877961f, 0.05213498f, 0.06242217f, 0.10848123f, 0.09102610f, 
    0.38279188f, -0.07874008f, 0.51427513f, -0.19845340f, 0.10879115f, -0.02341134f, 0.18949504f, 0.06701323f, 
    -0.07336905f, 0.04453280f, -0.15647615f, 0.03780687f, 0.24675293f, -0.09897978f, 0.38278705f, -0.01082461f, 
    0.04635896f, -0.07259043f, 0.02659967f, 0.12794843f, -0.02258187f, -0.02170744f, 0.01923638f, -0.18786402f, 
    0.16281560f, 0.20712541f, 0.22085737f, 0.06950788f, 0.14063366f, 0.12600361f, 0.01240261f, -0.12523466f, 
    0.03043311f, -0.01213010f, -0.01754350f, -0.07088620f, 0.28568771f, 0.08437193f, -0.09749326f, -0.08424621f, 
    0.03487324f, -0.05699700f, -0.01179857f, -0.09105013f, -0.05867184f, 0.02014461f, -0.05060402f, -0.09622702f, 
    -0.02351406f, -0.04745004f, -0.14080016f, 0.09549613f, -0.10152265f, -0.08598044f, 0.12471660f, -0.01547936f, 
    0.08472803f, 0.00797042f, 0.04709944f, -0.24931027f, 0.03684989f, 0.11503463f, 0.12353741f, -0.09841456f, 
    0.03896855f, -0.03390019f, -0.00982393f, 0.06112361f, -0.02939487f, -0.04089056f, -0.01362294f, 0.05845374f, 
    -0.01013869f, -0.08802883f, -0.01024031f, -0.21099496f, 0.02163314f, 0.00989139f, -0.11931630f, -0.02013011f, 
    0.07399677f, -0.14335947f, 0.10831724f, 0.10314211f, -0.03705414f, -0.18411466f, 0.11353862f, -0.11354850f, 
    0.07747050f, 0.03985295f, 0.02400846f, -0.11451050f, 0.12296033f, -0.06920008f, -0.07516760f, -0.19924764f, 
    -0.24591768f, -0.23569851f, -0.05167911f, 0.04501681f, -0.04226686f, -0.05071425f, -0.00610407f, 0.04760681f, 
    0.09344125f, 0.04746374f, 0.08034343f, 0.15237150f, 0.15278929f, -0.13590609f, -0.01589758f, 0.37932515f, 
    -0.07939177f, 0.07336270f, -0.07893086f, -0.11044230f, -0.00809069f, 0.06791290f, -0.00008106f, 0.06774991f, 
    -0.35454383f, -0.25217080f, 0.03507900f, 0.08486425f, -0.04428638f, 0.05102656f, -0.07802157f, 0.04004708f, 
    0.03033555f, 0.09335518f, -0.00750774f, -0.01260639f, -0.01308120f, -0.04344394f, 0.40114337f, 0.06894442f, 
    0.14052233f, -0.05332184f, 0.01348980f, 0.00584380f, 0.11088981f, 0.09075984f, 0.15579398f, 0.17739715f, 
    -0.02500819f, -0.06527734f, -0.21151556f, -0.05794421f, -0.03208641f, 0.09844246f, -0.03554776f, 0.07943327f, 
    0.12508722f, 0.02919640f, 0.10199118f, 0.12485278f, 0.23724523f, -0.11460256f, -0.12166010f, 0.00388006f, 
    0.04671983f, -0.08248120f, 0.03732346f, -0.01647986f, 0.17750295f, 0.07701258f, 0.12088484f, 0.23606896f, 
    -0.03188128f, 0.10833595f, 0.28258109f, -0.08191879f, -0.01029182f, 0.16554976f, 0.00718851f, 0.10930414f, 
    -0.13025497f, 0.18298261f, 0.08101667f, -0.16946867f, 0.32410881f, -0.05240075f, -0.05063899f, -0.22281855f, 
    0.04106099f, 0.02462318f, 0.01273195f, -0.05956783f, -0.10943575f, 0.08280231f, 0.10805939f, -0.09177696f, 
    0.04627646f, -0.12572603f, -0.02814496f, 0.28554973f, -0.03145444f, -0.00671353f, -0.07188842f, 0.23537919f, 
    -0.10852490f, -0.01228857f, -0.05541753f, -0.05614938f, -0.15869676f, -0.09896147f, -0.02463409f, 0.08200864f, 
    0.04421315f, -0.18964143f, -0.09627326f, -0.02051175f, 0.13301449f, 0.12308410f, 0.12255055f, 0.23348251f, 
    0.10798298f, -0.06131824f, -0.09485493f, -0.17007391f, 0.12044407f, -0.04696843f, -0.16910283f, -0.02835502f, 
    -0.10020548f, -0.30189997f, -0.05598464f, -0.14910711f, -0.04044857f, 0.22449212f, 0.17464298f, 0.36251101f, 
    0.01175763f, 0.04640118f, 0.03252421f, -0.12216382f, 0.09999297f, -0.08244786f, -0.02717038f, 0.02582564f, 
    0.15234151f, 0.20387034f, 0.01928410f, 0.04603839f, 0.05428641f, -0.01647496f, 0.03801746f, 0.12099677f, 
    -0.04027542f, -0.05686472f, -0.01371582f, -0.11053697f, 0.30590844f, 0.14159492f, 0.22895950f, 0.26685098f, 
    0.02889110f, -0.18897615f, -0.06627580f, -0.06230504f, 0.05530146f, -0.02835420f, -0.12073495f, 0.00696579f, 
    -0.04259827f, 0.11685434f, 0.34521052f, -0.01129029f, 0.00071404f, 0.09645891f, -0.12851484f, 0.05064993f, 
    -0.16333078f, -0.06553794f, -0.13447788f, -0.14985619f, -0.02418031f, 0.23336294f, 0.33251643f, 0.06344499f, 
    0.00029793f, -0.04704612f, -0.10374494f, -0.02504750f, -0.08711215f, -0.01410111f, -0.03260467f, -0.03262619f, 
    0.14331089f, 0.09277837f, 0.19915766f, 0.29476267f, 0.08958869f, -0.04338244f, 0.14150202f, -0.07906728f, 
    -0.11215713f, -0.09237286f, -0.01158451f, -0.03048062f, 0.06245128f, 0.24325873f, -0.02784993f, -0.08989491f, 
    -0.13100645f, 0.04369522f, 0.10781603f, 0.09090525f, -0.01602049f, 0.05069298f, 0.02717597f, -0.05405400f, 
    0.03035866f, 0.07956189f, -0.08439545f, 0.01479844f, 0.13022614f, 0.01961089f, -0.08962309f, -0.08662339f, 
    -0.32675463f, 0.20955878f, -0.10300435f, -0.04536983f, 0.17431183f, 0.11824724f, 0.08327947f, 0.03151642f, 
    0.06860431f, -0.05039355f, 0.04653202f, 0.07697684f, 0.03212043f, 0.06384656f, -0.03317126f, -0.03295125f, 
    -0.23931457f, -0.21792334f, 0.07929470f, 0.19620696f, -0.06956458f, 0.00961098f, -0.05954362f, 0.07507674f, 
    -0.09062975f, -0.06736913f, -0.08006471f, -0.14785871f, -0.08429740f, -0.01578713f, -0.29525575f, 0.00568678f, 
    0.10196944f, 0.10209966f, 0.05389130f, 0.17415503f, -0.07097644f, 0.21713550f, -0.24353239f, -0.11043370f, 
    -0.17217927f, 0.19324112f, -0.03857395f, -0.17270052f, 0.10297026f, 0.07284042f, 0.01791797f, -0.08696186f, 
    -0.04352018f, 0.15777551f, -0.13371003f, -0.00639042f, -0.28892604f, 0.08985670f, 0.11277520f, 0.09056615f, 
    0.01443249f, -0.04099956f, 0.10963158f, 0.24003156f, 0.11653621f, 0.06089365f, 0.07858835f, 0.13040246f, 
    -0.19117880f, 0.16018298f, 0.39199403f, 0.22920188f, 0.11977831f, 0.04897465f, 0.08728484f, 0.12388878f, 
    0.01737693f, -0.09779447f, 0.06498611f, 0.04612828f, -0.00688906f, -0.11974213f, 0.11919588f, 0.36308986f, 
    -0.04166053f, -0.07467055f, -0.07587746f, 0.12371346f, 0.05399426f, -0.04219643f, 0.03684667f, -0.04387540f, 
    -0.15351385f, -0.09996588f, 0.10743399f, 0.34744510f, -0.06297956f, -0.04436007f, 0.02508754f, -0.03356735f, 
    -0.04943497f, 0.04652926f, 0.02115319f, -0.13898118f, 0.14003806f, 0.33971748f, -0.13931662f, -0.05987589f, 
    0.06589159f, 0.01688601f, -0.13264097f, -0.06492021f, -0.04707064f, 0.10434976f, -0.06226571f, 0.01132865f, 
    -0.01352572f, 0.11604054f, 0.08490258f, -0.08380859f, 0.09904943f, -0.17218147f, -0.02586561f, -0.05333659f, 
    -0.03238185f, -0.07801774f, -0.13014317f, -0.03924329f, -0.03914560f, -0.01036228f, -0.02198708f, -0.25529402f, 
    -0.12254021f, -0.12515616f, -0.14259897f, 0.08809202f, 0.04970796f, -0.05069248f, -0.10626088f, -0.04218431f, 
    0.00315433f, 0.11472799f, 0.10531161f, -0.12511274f, -0.09008957f, 0.05036534f, -0.06201551f, 0.14268994f, 
    -0.03050242f, -0.16228051f, 0.04238280f, -0.06541580f, 0.22326151f, 0.00380302f, -0.09931610f, -0.02062391f, 
    0.04188478f, 0.05203586f, -0.09421140f, 0.13142452f, 0.13425134f, -0.11940065f, -0.10339692f, -0.17890348f, 
    -0.00603186f, -0.12840863f, -0.03850018f, -0.04550292f, 0.05903830f, -0.14052078f, -0.07521482f, 0.11257400f, 
    -0.03209415f, -0.07966631f, -0.07418303f, -0.03705529f, 0.37732747f, -0.16760805f, -0.08996689f, 0.00730529f, 
    0.13333553f, 0.07821423f, -0.05355847f, 0.04546490f, -0.04942543f, 0.04192775f, -0.07355268f, 0.00144829f, 
    -0.30391884f, -0.01754222f, -0.05981653f, -0.07119378f, 0.05715636f, 0.06435917f, 0.05207415f, -0.11856066f, 
    0.00509237f, 0.02283997f, -0.05574357f, -0.03089983f, 0.02127619f, -0.13735113f, 0.04847110f, 0.09070760f, 
    0.08141634f, 0.02117553f, -0.00918188f, 0.02285095f, -0.12301411f, -0.06277555f, -0.09536576f, -0.04814275f, 
    -0.16184597f, 0.05668969f, -0.21626550f, 0.00706604f, -0.03842526f, 0.02475751f, -0.07393882f, 0.13934530f, 
    0.06580397f, 0.00625520f, -0.04240818f, 0.16299979f, 0.44809031f, 0.08853696f, 0.16273418f, -0.01431331f, 
    0.01679519f, -0.03488297f, 0.03651654f, 0.04588762f, 0.03658451f, -0.00388353f, -0.09154830f, -0.06639484f, 
    0.05107829f, -0.12968376f, 0.06813605f, -0.02871644f, 0.00636145f, 0.11491952f, 0.01420438f, 0.11784745f, 
    -0.01185400f, 0.07098312f, -0.06242897f, 0.04279036f, 0.30962020f, -0.14368163f, 0.17487705f, -0.00898960f, 
    -0.03527882f, 0.07613163f, -0.08003450f, 0.12106431f, -0.09227064f, 0.10796410f, 0.15315424f, 0.02360864f, 
    -0.11508523f, -0.01288874f, -0.11234409f, -0.32393301f, -0.00642193f, 0.00899453f, 0.02231637f, 0.07432577f, 
    -0.09139986f, -0.00816694f, -0.04686040f, 0.00755068f, -0.18460998f, 0.00774008f, 0.06399562f, -0.11139887f, 
    0.02142070f, -0.15195817f, 0.06920487f, 0.03670165f, -0.01631922f, -0.09277769f, 0.05880526f, 0.03901129f, 
    0.08780552f, -0.05902161f, 0.06069437f, -0.06239767f, 0.01954663f, -0.12937494f, -0.15078850f, -0.04448698f, 
    0.04494756f, -0.04427966f, -0.04229890f, 0.30620891f, -0.08127201f, -0.14616887f, 0.02512021f, 0.09689070f, 
    0.07132914f, 0.03741205f, 0.03181372f, 0.08530424f, 0.05431553f, 0.00930062f, 0.03107088f, 0.05613011f, 
    -0.14861009f, -0.09007084f, 0.24903215f, 0.04145109f, -0.07273835f, 0.03221239f, -0.08543471f, 0.06032134f, 
    -0.06945121f, -0.14802267f, -0.05642059f, -0.09096993f, -0.05563590f, -0.10133723f, 0.29947931f, 0.40403628f, 
    0.04987427f, 0.08370595f, 0.06406584f, 0.05694350f, 0.09814394f, 0.08043824f, 0.12903117f, 0.07634402f, 
    0.06154796f, 0.09803038f, 0.15361385f, 0.06427993f, -0.12285557f, 0.12503460f, 0.00026262f, 0.01770530f, 
    0.01297981f, 0.14138661f, 0.18679172f, 0.10506640f, 0.05277544f, 0.00928117f, 0.10166935f, 0.18356280f, 
    0.13358034f, 0.04395426f, 0.09596261f, -0.07231385f, 0.16565567f, 0.14659940f, 0.13468893f, 0.14849545f, 
    0.35555214f, 0.11107124f, -0.00606173f, 0.07757662f, 0.23526804f, 0.01191659f, -0.00442465f, 0.06558519f, 
    -0.05233385f, 0.00017507f, 0.04605923f, 0.15468028f, -0.20982085f, -0.22920865f, 0.12874709f, 0.14017439f, 
    -0.17996919f, 0.09657881f, -0.03827746f, -0.08333828f, -0.03256255f, -0.00074147f, 0.00382161f, -0.11964069f, 
    0.05395885f, 0.35428712f, -0.14941598f, -0.00131473f, -0.09061661f, 0.04432150f, -0.10434103f, -0.06892425f, 
    -0.05329758f, 0.11267912f, 0.02242500f, -0.05163458f, 0.24785306f, 0.03416879f, 0.08707083f, 0.13395135f, 
    0.01589770f, 0.09840062f, -0.04897606f, 0.11476196f, 0.12022548f, -0.00415390f, 0.02751618f, 0.03184621f, 
    -0.07901026f, -0.16561502f, -0.08820760f, 0.05261560f, 0.25756347f, 0.11602055f, 0.05606671f, 0.10399202f, 
    -0.00115750f, 0.10549697f, 0.01201733f, 0.11499429f, -0.02208106f, -0.11170378f, -0.17447729f, -0.18070661f, 
    -0.14891407f, -0.06658337f, 0.04185450f, 0.04830033f, -0.04669560f, 0.03472178f, 0.32102117f, -0.17619927f, 
    -0.54316449f, -0.00385008f, -0.03519389f, 0.12809364f, 0.01108451f, -0.03395589f, -0.04651401f, -0.04739904f, 
    0.14689535f, -0.00520938f, -0.05105113f, -0.01264180f, -0.00641312f, 0.13153149f, 0.03338046f, 0.22660807f, 
    0.00114549f, 0.08194659f, 0.07252736f, 0.08501467f, 0.07145142f, -0.07659477f, 0.01068347f, 0.05426824f, 
    -0.17936812f, 0.50718957f, -0.11602967f, 0.46180239f, 0.04926778f, 0.09612776f, -0.08408836f, -0.16188283f, 
    0.00998925f, -0.04245192f, 0.03684629f, -0.03685305f, 0.36017016f, 0.26188985f, 0.12819988f, 0.15012269f, 
    -0.15817785f, -0.05985779f, 0.05567752f, 0.04540096f, 0.05033533f, 0.02132637f, 0.05546338f, 0.16193752f, 
    -0.00956581f, 0.02089933f, -0.13457301f, -0.13219409f, 0.15422830f, 0.04090620f, 0.18012227f, -0.01506485f, 
    0.04433006f, 0.04755748f, 0.16234624f, 0.00083545f, 0.10699803f, 0.33809000f, -0.31920719f, 0.00751724f, 
    -0.14485259f, -0.03804517f, 0.05922297f, 0.01567035f, -0.05453470f, -0.01806336f, -0.05735270f, 0.11111844f, 
    -0.11068922f, 0.20868659f, 0.03960297f, 0.07391128f, -0.06497473f, -0.07918247f, -0.17644802f, -0.09882311f, 
    -0.03535625f, -0.04509985f, -0.04203210f, 0.03440873f, -0.59246844f, -0.21020149f, -0.03178891f, -0.17311931f, 
    -0.09051470f, -0.25289094f, -0.27677831f, -0.23114301f, -0.13951088f, -0.16194335f, -0.25792667f, 0.05096937f, 
    -0.19101983f, 0.11836150f, -0.21851626f, -0.04122119f, -0.02507940f, 0.03823309f, -0.09693004f, 0.03855653f, 
    -0.02352549f, -0.10604249f, -0.00953644f, 0.19872467f, 0.11502603f, -0.15517497f, -0.07371881f, -0.02339969f, 
    0.07538553f, -0.04069868f, 0.00897780f, -0.03622605f, 0.08220810f, 0.21133582f, 0.14542340f, 0.21677302f, 
    -0.13292871f, -0.09103335f, 0.27476472f, 0.07935316f, 0.09076258f, -0.10910415f, -0.10950948f, 0.09875008f, 
    0.01387006f, -0.01893104f, -0.02583800f, -0.05685224f, 0.01804785f, -0.31088635f, -0.15126507f, 0.11601524f, 
    0.23643337f, 0.10868581f, 0.11197410f, 0.02817984f, 0.11185200f, 0.14693470f, -0.00611846f, 0.13955870f, 
    0.06307902f, 0.01877775f, 0.05348266f, -0.16294260f, -0.11117225f, -0.03846338f, 0.03375324f, -0.12479194f, 
    0.11035618f, 0.03523314f, 0.04566557f, 0.03719701f, 0.14467466f, -0.29952511f, -0.14144100f, -0.26062402f, 
    0.12507738f, 0.09958672f, -0.09412957f, 0.18254066f, -0.00934746f, -0.02691098f, -0.17978936f, -0.10327271f, 
    0.24287671f, -0.01457732f, 0.16028813f, 0.11327449f, -0.12631635f, 0.09697238f, -0.06078612f, 0.07487800f, 
    0.05158551f, 0.17284210f, -0.00493189f, 0.01407361f, -0.30920777f, 0.20301905f, 0.19553994f, -0.01255308f, 
    0.08092787f, -0.02385403f, 0.02501639f, 0.22476467f, -0.02587983f, 0.09059589f, -0.12831774f, -0.31531379f, 
    0.23409288f, -0.19379626f, -0.04327373f, 0.13168626f, -0.06867064f, -0.05552588f, -0.08692303f, 0.18653561f, 
    0.27146927f, -0.06076013f, -0.03583196f, 0.12672262f, 0.07807806f, -0.16638166f, 0.08431582f, -0.08219501f, 
    0.23176213f, 0.02583001f, 0.06526981f, 0.27071071f, 0.00710338f, 0.11687671f, 0.07208668f, 0.00803654f, 
    -0.19103017f, -0.21539636f, 0.04366167f, -0.15751930f, -0.10149076f, 0.02020275f, 0.10397363f, 0.08817973f, 
    0.13251439f, 0.01227678f, -0.01933971f, 0.03411790f, 0.07368331f, -0.03701128f, 0.14614867f, -0.05947347f, 
    -0.00788991f, 0.05912907f, 0.18026702f, 0.27495074f, -0.06546454f, -0.10170405f, -0.06652892f, -0.17025924f, 
    -0.15893267f, -0.02448488f, 0.05648308f, -0.10504103f, -0.13936031f, -0.08936736f, -0.06597651f, -0.05862905f, 
    -0.00946160f, 0.09671643f, -0.16359827f, 0.08047560f, -0.11127266f, -0.17733406f, -0.06991021f, -0.42662761f, 
    -0.01446561f, -0.00951041f, 0.10878029f, 0.11672422f, 0.03737701f, 0.07335041f, 0.06124003f, -0.05457148f, 
    0.28283799f, -0.12304610f, 0.01570446f, -0.23232886f, -0.00854216f, 0.19291000f, -0.10192264f, 0.03230644f, 
    -0.05582017f, 0.01928435f, 0.07523648f, -0.03845189f, -0.40218756f, -0.20115419f, 0.02527606f, 0.02468168f, 
    -0.06375212f, 0.22938003f, -0.03913426f, 0.17757209f, 0.10479432f, 0.20913349f, 0.10680482f, 0.05714928f, 
    0.01004906f, -0.05506961f, -0.19998950f, 0.03831873f, 0.02434329f, 0.23901166f, 0.10064787f, -0.03395303f, 
    -0.01425269f, 0.13181490f, 0.01409439f, 0.17926094f, -0.02934824f, -0.12965432f, -0.07575218f, -0.18728848f, 
    0.10324118f, 0.10283610f, 0.30502298f, 0.04855982f, 0.14977294f, 0.18666480f, 0.09320023f, 0.11437105f, 
    -0.30937988f, -0.03437445f, -0.15540083f, -0.03111011f, 0.17405829f, -0.15882015f, 0.04324840f, 0.15822499f, 
    -0.09843527f, 0.11820674f, -0.14857975f, 0.02241205f, -0.11884138f, -0.17274624f, -0.16211542f, -0.29092729f, 
    0.08251821f, -0.04944925f, -0.01659335f, -0.00396342f, -0.01077178f, -0.09276256f, -0.04468782f, -0.00541605f, 
    -0.03877535f, -0.02535677f, -0.08888173f, 0.13321358f, 0.04728279f, -0.05104192f, -0.01493609f, -0.03764147f, 
    0.22209647f, -0.13058171f, 0.09499574f, 0.04092053f, 0.15267271f, -0.15817454f, 0.13805778f, 0.16693255f, 
    0.16579430f, 0.07864651f, -0.05367395f, 0.11790338f, 0.10909026f, 0.07528438f, 0.05300930f, 0.06272005f, 
    0.05015671f, 0.03895590f, 0.03658732f, 0.02887410f, 0.01962915f, 0.12316422f, 0.03316078f, 0.12413511f, 
    -0.03641723f, 0.05228756f, -0.00447509f, 0.07491813f, 0.19319075f, -0.14078930f, -0.12024642f, 0.18525240f, 
    -0.05095805f, -0.03287532f, 0.14982875f, 0.03114428f, 0.15925789f, -0.21266882f, 0.45237398f, 0.02210394f, 
    0.07597272f, 0.03817470f, -0.01587116f, -0.01036359f, 0.02320693f, -0.02614864f, 0.01395338f, 0.00315458f, 
    0.21974498f, -0.00916027f, -0.00848398f, 0.13201480f, 0.32088155f, 0.20386994f, 0.07905693f, -0.12526599f, 
    -0.04816582f, 0.07087147f, -0.02144160f, 0.03318738f, 0.02697246f, -0.06275215f, 0.01385934f, -0.07421965f, 
    0.11568867f, 0.00732080f, -0.26497793f, -0.19171491f, -0.18576378f, 0.00328755f, 0.11150877f, -0.15408373f, 
    0.03552821f, -0.01721055f, -0.04896447f, 0.06654184f, 0.00618538f, 0.11516519f, -0.21158841f, -0.12453634f, 
    0.06289057f, 0.10974181f, 0.08244494f, 0.03714283f, 0.11314883f, 0.01085765f, -0.05093483f, 0.08030652f, 
    -0.05119749f, 0.01666516f, -0.16926397f, -0.17640634f, -0.09807386f, -0.05564084f, 0.03710179f, -0.04643790f, 
    0.13865124f, -0.06016069f, 0.02503630f, 0.13868254f, -0.01817043f, -0.09622144f, 0.01327848f, 0.04379614f, 
    -0.14233649f, -0.09847283f, 0.10817046f, -0.04632771f, 0.02734467f, -0.00856466f, -0.08144181f, -0.01163948f, 
    0.13057564f, 0.09835059f, -0.20215289f, 0.02320193f, -0.12647723f, -0.10645489f, -0.04818654f, -0.04940546f, 
    -0.02614450f, 0.06056676f, 0.08383202f, 0.07158192f, 0.05986278f, 0.11610597f, 0.09655733f, -0.09628814f, 
    -0.10046807f, -0.12898955f, -0.17474487f, -0.14090726f, -0.16371728f, -0.09721047f, -0.05958462f, -0.15349360f, 
    -0.10542766f, -0.11615566f, -0.08032668f, -0.00143483f, 0.19670588f, -0.02793537f, -0.00148669f, -0.01459250f, 
    0.01843833f, 0.11364107f, -0.11682701f, 0.19791903f, -0.15553926f, -0.13763647f, 0.02011730f, 0.11883955f, 
    0.02922155f, -0.09304190f, 0.05291869f, -0.02698734f, 0.01981538f, 0.22344092f, 0.16403767f, 0.07019293f, 
    -0.04278801f, 0.02018094f, -0.02108000f, -0.00208709f, -0.01171601f, 0.02712629f, 0.04452754f, -0.04847956f, 
    0.03846616f, 0.04787391f, -0.02356697f, -0.00432338f, -0.02248900f, -0.02356071f, 0.02175533f, -0.00751620f, 
    -0.02389614f, 0.01664832f, -0.02518024f, 0.01379044f, -0.01816011f, -0.00726256f, 0.01276297f, 0.03057084f, 
    0.02387028f, -0.01759598f, -0.00181812f, -0.03858405f, -0.03573330f, 0.00432217f, -0.02169593f, 0.04496994f, 
    0.00660503f, -0.02485937f, 0.00876778f, 0.02426377f, 0.04952336f, -0.03373564f, -0.05744241f, 0.02138487f, 
    -0.03976082f, 0.03462029f, 0.03186006f, 0.01672007f, -0.05747908f, 0.01724834f, -0.03483386f, 0.04816770f, 
    -0.02199410f, 0.01186029f, -0.05185445f, -0.03237778f, -0.04017005f, -0.02876865f, 0.01625369f, 0.00524940f, 
    -0.03347455f, 0.04103117f, 0.01534401f, 0.03557609f, -0.03530289f, -0.01424502f, 0.02900028f, -0.02716572f, 
    -0.03093856f, -0.03183210f, -0.01780103f, 0.02627265f, -0.04763961f, 0.02039542f, -0.04489466f, -0.04776017f, 
    0.02843980f, -0.03211882f, -0.00912533f, 0.04294842f, 0.02776345f, -0.05466396f, -0.00649910f, -0.04332177f, 
    0.04757840f, 0.00612668f, 0.01647121f, -0.05539574f, 0.02971720f, -0.02088296f, 0.02164030f, -0.00240335f, 
    0.02714006f, 0.04199991f, -0.04520550f, -0.01508591f, 0.03917374f, -0.03195120f, -0.03139476f, -0.04912151f, 
    -0.03354529f, 0.01128806f, -0.05083457f, 0.01533486f, 0.01506373f, -0.02959771f, -0.00420634f, 0.01999262f, 
    -0.01896347f, 0.04854118f, 0.03751184f, 0.03574026f, 0.03080548f, -0.00878455f, 0.01050152f, -0.05460094f, 
    -0.00167845f, -0.03567910f, -0.03702832f, 0.01218577f, 0.01515182f, -0.02911673f, -0.03251075f, -0.05255375f, 
    0.02924327f, -0.03069569f, -0.02612090f, -0.03149912f, 0.01197486f, -0.04294879f, 0.03597777f, 0.02547514f, 
    -0.03076773f, 0.03814168f, 0.01653316f, 0.01132161f, 0.01432168f, 0.04462143f, -0.05203657f, -0.00018648f, 
    -0.02062288f, -0.04736077f, 0.03598567f, -0.01605668f, 0.03156566f, 0.03821742f, -0.05394434f, -0.00929260f, 
    0.02596431f, -0.00223825f, 0.03300225f, -0.01517696f, -0.00192595f, -0.02521296f, -0.02938551f, -0.00604381f, 
    0.02524128f, 0.00533063f, -0.00792174f, -0.02682687f, 0.03484048f, -0.04215732f, 0.03180729f, -0.02393575f, 
    -0.00940455f, 0.00193026f, 0.04120193f, 0.04559450f, 0.00967664f, -0.01837474f, 0.01436781f, -0.01085927f, 
    -0.03858472f, -0.03311677f, -0.01502694f, -0.01139784f, -0.03210898f, 0.03253091f, 0.03335380f, -0.01734781f, 
    -0.01137218f, -0.01988972f, -0.01049397f, 0.00334415f, -0.05708583f, -0.04403440f, 0.04059412f, 0.00078826f, 
    -0.03874013f, -0.00259028f, 0.03112402f, -0.03267515f, 0.03464344f, 0.04839875f, 0.01429186f, -0.05398400f, 
    0.04177462f, 0.00870376f, -0.02829580f, 0.04108047f, 0.03934029f, -0.04385916f, 0.02344370f, -0.01034228f, 
    0.04339779f, 0.02361441f, -0.04833145f, -0.04068983f, 0.05045702f, 0.04314295f, -0.00747686f, -0.03841562f, 
    -0.01307157f, -0.03150722f, 0.00845517f, 0.00592219f, -0.04467345f, -0.00745948f, 0.00909056f, 0.02228102f, 
    0.00340972f, 0.02232818f, 0.00719792f, 0.04390243f, 0.02040093f, 0.00350390f, 0.05027936f, -0.00283856f, 
    0.03862712f, -0.00517869f, -0.01640167f, 0.02255349f, -0.03023576f, 0.00085368f, -0.01065871f, 0.02678849f, 
    0.00673909f, 0.03559664f, 0.02426386f, -0.03139437f, -0.00232781f, -0.02098641f, 0.03762935f, 0.01283143f, 
    -0.05985678f, 0.02966839f, -0.01114030f, -0.04614141f, -0.04342744f, -0.04944405f, 0.02561659f, -0.02333852f, 
    0.00031712f, -0.03520210f, -0.00794551f, 0.03243478f, -0.03872823f, -0.01782891f, -0.01357445f, -0.00302934f, 
    0.00099886f, -0.05250488f, -0.01672807f, 0.00861401f, 0.00017148f, 0.03563027f, -0.04069643f, -0.00633317f, 
    0.03379508f, -0.03613429f, -0.02146910f, -0.05503095f, -0.02348247f, -0.03661796f, -0.05428308f, -0.04178818f, 
    0.04299441f, 0.02359975f, -0.02926868f, 0.01338214f, -0.04424701f, -0.01429784f, -0.01952336f, -0.00761236f, 
    0.00956161f, 0.01312132f, 0.01017560f, -0.00737839f, -0.02862982f, 0.00680504f, -0.04825395f, -0.05321147f, 
    -0.04102747f, 0.03312914f, -0.04995020f, -0.04004344f, -0.04233409f, -0.05047799f, -0.02104695f, 0.03029682f, 
    -0.04446390f, 0.03340008f, 0.04068248f, -0.04076114f, -0.04080961f, 0.01628163f, -0.04394076f, -0.01714330f, 
    -0.01730029f, -0.05098470f, 0.04276044f, -0.01710393f, 0.02033329f, 0.03087668f, -0.03093071f, -0.05835235f, 
    -0.03793570f, -0.01722093f, -0.05737557f, 0.02583840f, 0.04168284f, -0.03246981f, 0.03903155f, 0.01944060f, 
    -0.01728226f, 0.03908833f, -0.01534033f, -0.03189289f, -0.01910402f, -0.01747590f, -0.03663983f, -0.02008232f, 
    0.03042068f, 0.03246153f, 0.02562416f, -0.01448238f, -0.05093642f, 0.02026848f, 0.03932727f, 0.01323314f, 
    0.04226892f, 0.03713989f, 0.03566673f, -0.01570478f, -0.02670977f, -0.01739372f, 0.02262774f, 0.03396096f, 
    -0.05200531f, -0.03112330f, 0.00120803f, 0.01246016f, 0.02010207f, -0.04339180f, -0.03792953f, -0.02948421f, 
    0.01710541f, 0.00301695f, -0.00230915f, 0.02466526f, 0.01347361f, -0.02359402f, -0.01135967f, 0.00124609f, 
    -0.03555691f, -0.05393725f, -0.05790665f, -0.03658791f, -0.00589287f, 0.01860738f, -0.03718427f, -0.05355645f, 
    0.02950421f, 0.02860621f, -0.05393657f, -0.04331997f, -0.00848218f, 0.02667974f, -0.04423683f, -0.05083534f, 
    0.00778438f, -0.00173753f, 0.00885987f, -0.00558113f, -0.02428128f, 0.01835573f, -0.03764444f, 0.01267429f, 
    0.16118503f, 0.14525127f, -0.06127580f, -0.16114178f, 0.02641315f, 0.17642559f, -0.00094339f, 0.12655541f, 
    -0.12835947f, 0.00277746f, 0.11481284f, -0.04664847f, 0.06617700f, 0.13552412f, 0.39283454f, -0.09011493f, 
    0.02778763f, 0.06616532f, 0.12464599f, 0.07813698f, -0.03797869f, -0.11231456f, -0.06575748f, 0.04461031f, 
    0.18337335f, -0.00562625f, -0.30677941f, -0.23667423f, 0.21056290f, 0.04550059f, -0.07802495f, -0.20338865f, 
    0.01238271f, 0.00932034f, 0.07759254f, -0.13922164f, 0.06661846f, -0.02514338f, -0.25248587f, 0.04861581f, 
    -0.01770252f, -0.03436218f, 0.05491348f, -0.11704454f, -0.10204028f, -0.06367458f, -0.07704037f, -0.01719482f, 
    -0.19251132f, 0.10678284f, 0.01252003f, -0.02048059f, -0.02056601f, -0.05618854f, 0.07405175f, 0.03695100f, 
    -0.09351498f, -0.00523828f, 0.09530605f, 0.04731865f, 0.00975804f, 0.06050739f, 0.09923857f, -0.01767872f, 
    -0.10786764f, 0.13640611f, 0.09983119f, 0.04795709f, 0.05591716f, -0.11039649f, 0.01614372f, -0.07439903f, 
    -0.03611898f, 0.13812676f, -0.12699564f, 0.16086946f, 0.01094176f, 0.01716060f, 0.06289852f, 0.07617714f, 
    -0.07977834f, -0.18856053f, 0.08202884f, 0.03745868f, -0.09740659f, 0.03531264f, -0.01428594f, 0.09832150f, 
    -0.01466472f, 0.05799462f, 0.05250781f, 0.13444802f, -0.07442366f, 0.25548714f, -0.14552785f, 0.05465970f, 
    -0.16071865f, 0.30622935f, 0.01878171f, -0.16842481f, -0.01981434f, 0.04991774f, -0.02511813f, -0.00049340f, 
    0.01126628f, -0.07847786f, -0.11785614f, 0.00991501f, -0.06723417f, 0.21885325f, -0.00202307f, -0.17852464f, 
    0.02134717f, 0.16349307f, 0.12423840f, 0.05081639f, -0.04766719f, 0.00307357f, -0.03111470f, -0.10645635f, 
    0.01227322f, -0.05331004f, 0.07785460f, -0.09159926f, -0.08671954f, -0.09913632f, 0.00032028f, -0.08334050f, 
    0.02828496f, 0.00459813f, 0.05626845f, 0.20320085f, 0.17785333f, -0.22001375f, 0.07190010f, 0.02585519f, 
    -0.04174577f, -0.07089254f, 0.05698361f, -0.11994921f, -0.09848357f, -0.11000920f, 0.02996509f, 0.05050604f, 
    -0.26914772f, -0.31954765f, 0.07487003f, 0.06212313f, -0.03842366f, 0.10646034f, 0.04696206f, -0.02229678f, 
    0.01953932f, 0.00260486f, -0.03964524f, -0.07753552f, -0.04089553f, -0.01431672f, 0.15223512f, -0.04598170f, 
    0.03889433f, 0.09580495f, 0.18774134f, -0.01433787f, 0.08631133f, 0.06498250f, 0.02358299f, -0.11897988f, 
    -0.07247112f, -0.00319531f, -0.00914153f, -0.04333542f, -0.06621119f, 0.03204776f, -0.00244731f, 0.10560958f, 
    -0.00087333f, -0.03136787f, 0.11143801f, 0.04939492f, 0.17807178f, -0.12662446f, 0.14349903f, 0.13950604f, 
    0.06172145f, -0.07897475f, -0.04699329f, 0.09796857f, 0.02120633f, -0.04239583f, 0.00667659f, 0.06415286f, 
    0.06441490f, 0.37518695f, 0.26089886f, 0.08991407f, 0.02567564f, -0.00199364f, 0.16634755f, 0.12552899f, 
    -0.05344372f, -0.03830913f, 0.11333210f, 0.08883001f, -0.36916965f, -0.20527758f, 0.05703215f, 0.03628681f, 
    0.00462754f, 0.11621645f, -0.03071137f, 0.00710141f, -0.09392251f, -0.17753844f, 0.05157257f, -0.10247038f, 
    0.00906704f, 0.08619675f, 0.10433079f, 0.08793675f, -0.02208754f, -0.01084679f, -0.00563284f, 0.01804497f, 
    0.03830931f, 0.06081356f, 0.05846223f, 0.01860618f, 0.14988522f, 0.08367311f, 0.19301146f, -0.01560600f, 
    -0.00180831f, 0.02888933f, 0.02473707f, 0.05076543f, 0.01086892f, 0.01794015f, 0.09115413f, 0.00645718f, 
    0.04923416f, 0.00605283f, -0.10180516f, -0.10092295f, 0.08637967f, 0.14788175f, 0.13311116f, 0.08682448f, 
    -0.07365944f, 0.01647984f, 0.08126536f, -0.01837427f, -0.09755882f, 0.07485177f, 0.20999424f, -0.04805784f, 
    -0.08406417f, 0.08685483f, 0.01496100f, 0.07181244f, 0.07647902f, 0.07701410f, 0.24076968f, -0.12034713f, 
    -0.12172616f, -0.07533582f, 0.07611047f, 0.14798620f, -0.00134284f, 0.08069464f, -0.07553484f, -0.05971313f, 
    -0.02399410f, -0.08554596f, 0.11694223f, -0.05690679f, 0.09840716f, -0.03328838f, -0.16813394f, -0.00652094f, 
    0.09475666f, 0.07716118f, -0.08546086f, 0.09456477f, 0.01379835f, 0.00333072f, -0.01964718f, -0.03208605f, 
    0.09019069f, -0.21049391f, -0.22454792f, 0.28999737f, 0.06950150f, 0.07245746f, -0.20708402f, 0.18818925f, 
    -0.03072383f, 0.03384206f, 0.09664860f, 0.01618455f, 0.16869424f, 0.12757199f, 0.18541431f, 0.13088796f, 
    -0.02465316f, 0.01146378f, 0.13810141f, -0.07648269f, -0.05982696f, -0.01000477f, 0.06157009f, -0.11266426f, 
    0.12629379f, 0.15174413f, -0.06870754f, -0.27006370f, 0.20607872f, 0.15284185f, -0.01284395f, -0.06122851f, 
    0.05933283f, 0.09912131f, 0.12755072f, 0.00783374f, -0.00147984f, -0.01077926f, -0.13052480f, 0.02376359f, 
    -0.04200729f, -0.00442480f, -0.01199328f, 0.02160398f, 0.03861470f, 0.03270646f, -0.04929568f, 0.14347741f, 
    -0.52902621f, 0.06415305f, 0.19367132f, 0.04904848f, -0.05996152f, -0.00125512f, -0.04359772f, -0.08449945f, 
    0.02689055f, 0.04682617f, 0.06143690f, 0.09259231f, -0.22049458f, -0.25033471f, -0.14002693f, -0.01717973f, 
    -0.03441784f, 0.04758932f, 0.06626756f, -0.00809748f, -0.03735847f, 0.01036526f, -0.03339813f, -0.11407407f, 
    -0.02307413f, 0.09260742f, -0.02076008f, 0.05611557f, -0.03252842f, -0.00060083f, 0.03494418f, -0.01622336f, 
    0.06371965f, -0.04413632f, 0.13235794f, 0.13620314f, -0.08198503f, 0.18862706f, 0.06854357f, -0.09087863f, 
    0.01914437f, 0.04842052f, 0.01285630f, -0.11887662f, -0.03599039f, 0.21343577f, 0.01245979f, 0.15974888f, 
    -0.03081143f, 0.04084002f, -0.03166499f, 0.01923729f, -0.02824150f, -0.03229606f, -0.05105915f, -0.00912736f, 
    0.02335786f, 0.02586673f, 0.03048941f, 0.00664916f, 0.03373434f, -0.05039887f, -0.03221387f, -0.00163509f, 
    0.01374632f, -0.01576759f, -0.00726622f, 0.04784841f, 0.01622906f, 0.03557292f, -0.00074998f, 0.00122940f, 
    -0.00243236f, 0.00350838f, -0.00062338f, -0.00170591f, -0.03385509f, -0.02680051f, 0.03505060f, -0.02853691f, 
    -0.05485104f, 0.01008894f, -0.04717916f, -0.01601878f, -0.03703476f, -0.05369773f, 0.04346989f, 0.01995750f, 
    0.01796196f, 0.02195662f, 0.02573104f, 0.03319930f, -0.01923280f, 0.00216927f, 0.03027399f, -0.03934737f, 
    -0.00099997f, 0.00916146f, -0.02325568f, 0.00226926f, 0.00262999f, 0.00873739f, -0.04206727f, 0.02714546f, 
    -0.02704376f, 0.00716864f, -0.04606402f, 0.03919845f, 0.01925040f, -0.03814790f, -0.00047735f, 0.02964959f, 
    -0.05484189f, 0.03766269f, -0.04945326f, -0.05756754f, -0.05580007f, -0.01316803f, -0.03051746f, 0.01649660f, 
    -0.01455372f, -0.01300453f, -0.05652563f, -0.04102747f, 0.02109555f, -0.05015518f, 0.03054280f, -0.01922181f, 
    -0.02811260f, -0.00827710f, 0.01781297f, 0.03916202f, 0.01013299f, 0.02057839f, -0.04344417f, -0.02822962f, 
    0.00532956f, 0.02966018f, -0.02562229f, -0.00906313f, -0.03321058f, 0.00118336f, 0.01884623f, -0.04344169f, 
    -0.05177306f, 0.03130776f, -0.03052368f, 0.03075327f, 0.02965082f, 0.03541072f, -0.02107614f, 0.01843983f, 
    -0.02949289f, -0.04439120f, -0.04153413f, 0.01372512f, 0.00613226f, 0.00079266f, 0.01127377f, 0.00264824f, 
    0.01219848f, 0.01761500f, -0.03467790f, 0.01765241f, 0.03401265f, 0.02265517f, -0.00043715f, 0.01664297f, 
    -0.04089462f, 0.00708894f, 0.02478716f, 0.03054487f, 0.03199403f, -0.02533675f, 0.03356563f, -0.01602802f, 
    -0.05200682f, -0.02782062f, -0.02727422f, -0.03520969f, -0.05532780f, 0.02882088f, 0.03134740f, -0.01328316f, 
    -0.03247361f, -0.04598426f, 0.01674703f, -0.03157683f, -0.01300969f, -0.04615960f, -0.01682582f, -0.01026091f, 
    -0.03841994f, 0.03647866f, -0.04431151f, 0.00268245f, 0.00802029f, -0.04631945f, -0.01578326f, -0.05248207f, 
    -0.04513898f, -0.02079779f, 0.03553712f, -0.04335226f, 0.00935965f, -0.01825312f, 0.01390116f, -0.03568079f, 
    -0.00332529f, 0.01954041f, -0.02481878f, -0.04381806f, 0.01956262f, -0.01823929f, -0.00235204f, -0.00905738f, 
    -0.05117255f, 0.00017375f, 0.02873389f, -0.00023652f, 0.04337013f, -0.02998069f, -0.03051179f, -0.00214308f, 
    0.03577248f, 0.03989160f, 0.03427390f, 0.00625581f, -0.03468525f, -0.02996182f, 0.00052307f, -0.00129442f, 
    0.02781057f, 0.00294519f, 0.04087384f, -0.04490514f, 0.01837201f, -0.05019720f, 0.03201922f, 0.04011417f, 
    0.01547879f, -0.01843266f, -0.04879905f, -0.00710437f, -0.04815790f, -0.01638369f, 0.03616106f, 0.01841063f, 
    -0.03705318f, 0.03239560f, 0.04346710f, 0.00160979f, 0.03689068f, -0.02234207f, -0.03640386f, -0.02895653f, 
    0.01634299f, 0.02992353f, -0.05068680f, 0.00511444f, -0.04027310f, 0.00830966f, -0.01476529f, -0.00375534f, 
    -0.00374971f, 0.03255421f, -0.01172172f, -0.01735792f, -0.02549550f, -0.02367833f, -0.05079456f, 0.01557296f, 
    0.00615052f, -0.03010480f, 0.02110568f, -0.03517044f, -0.05626100f, 0.02678485f, -0.03646164f, -0.04444588f, 
    0.03460340f, 0.00587386f, 0.01729244f, -0.00325807f, 0.03163599f, -0.05441230f, -0.01001613f, -0.01107975f, 
    -0.01220928f, -0.02616033f, 0.02655478f, -0.04812248f, -0.02157303f, 0.01286767f, -0.02411957f, 0.03506906f, 
    -0.02278383f, -0.01095252f, -0.01178968f, -0.03883761f, -0.01679703f, -0.03066324f, -0.04271404f, 0.00765424f, 
    -0.05435605f, -0.04218866f, 0.01137507f, -0.02224736f, 0.04208220f, -0.02238259f, -0.04588233f, -0.04951445f, 
    -0.02379755f, 0.00298463f, 0.00768561f, 0.01354292f, 0.02597703f, 0.02077109f, 0.01131319f, 0.03100799f, 
    -0.01629635f, -0.05603830f, 0.01297693f, 0.01280983f, -0.01204992f, -0.01282299f, -0.01733572f, -0.03521607f, 
    -0.00408594f, 0.00154151f, 0.03979455f, -0.00080646f, -0.04962403f, 0.01121728f, 0.02126674f, -0.02052447f, 
    0.00241949f, 0.04166935f, -0.02065493f, 0.01972544f, -0.02058828f, 0.00217357f, -0.00537244f, -0.04700448f, 
    0.00439379f, 0.01809379f, -0.05393717f, 0.00541960f, -0.01279710f, -0.05755652f, -0.04834139f, 0.03029965f, 
    -0.04723940f, 0.01604629f, -0.04621067f, 0.02060945f, 0.03091910f, 0.02274900f, 0.00593788f, -0.02658699f, 
    0.01244085f, 0.02895923f, -0.04376257f, 0.02418089f, -0.01140272f, 0.03259357f, -0.03117732f, 0.03749392f, 
    0.01176032f, 0.00295025f, -0.00168614f, -0.01396296f, 0.04402604f, -0.01082218f, -0.03519079f, -0.00908927f, 
    -0.00132475f, -0.04936868f, 0.02737765f, 0.01284458f, 0.00007570f, -0.03655780f, -0.00252103f, -0.01297856f, 
    0.00993192f, -0.03529908f, -0.02995021f, -0.00700927f, 0.01727785f, 0.04417953f, 0.01971497f, 0.00445715f, 
    -0.02054294f, -0.05507258f, -0.04061277f, 0.02509256f, -0.02449592f, -0.05075758f, -0.00512759f, -0.02664777f, 
    0.04511738f, -0.05182670f, 0.02095268f, 0.04163689f, -0.03573711f, 0.03721051f, 0.02451791f, -0.05740403f, 
    0.01823166f, 0.03916803f, 0.02720251f, -0.01956341f, 0.03486908f, -0.02092160f, -0.04808678f, -0.00480002f, 
    0.00961593f, 0.03613066f, -0.05358782f, -0.00916126f, 0.00047786f, 0.01620834f, 0.04123059f, 0.02716435f, 
    -0.05100303f, -0.05044566f, 0.02076408f, -0.02741793f, -0.00556744f, 0.02755261f, -0.05801639f, -0.01883408f, 
    -0.17932476f, -0.11996851f, 0.03769698f, -0.02884125f, -0.14618592f, -0.01610984f, -0.01083586f, 0.00896596f, 
    0.02528421f, -0.02205533f, 0.17000967f, 0.06481247f, 0.11534689f, -0.06696126f, -0.03805128f, 0.27723086f, 
    0.07917138f, -0.13655227f, -0.07671490f, 0.08663461f, 0.06669836f, -0.03620878f, 0.00004160f, 0.17231864f, 
    -0.26406461f, -0.11816959f, 0.10130597f, 0.01651108f, 0.04349104f, 0.05117121f, -0.14443277f, -0.22491442f, 
    -0.02722515f, 0.07779003f, 0.13952127f, 0.03754148f, 0.13143648f, 0.10659302f, 0.01934069f, -0.07889459f, 
    0.06773458f, 0.07071919f, 0.19915082f, 0.06128649f, 0.05861162f, 0.00151228f, 0.02321012f, -0.10588323f, 
    0.08528361f, -0.05838045f, -0.14011306f, -0.03504635f, 0.01883446f, -0.02887847f, 0.04540027f, -0.00226240f, 
    0.04000314f, 0.11404272f, 0.01009395f, 0.04281595f, 0.07280913f, 0.05202320f, -0.00772993f, 0.13932957f, 
    -0.01112790f, -0.04580195f, 0.08173116f, 0.10444099f, 0.10216375f, -0.09198743f, 0.07153694f, -0.03239151f, 
    -0.14727023f, -0.21362925f, 0.20039658f, -0.02301017f, -0.01015276f, 0.12691410f, 0.01192322f, 0.15378115f, 
    0.04773540f, 0.00228065f, 0.04572549f, -0.01543375f, 0.06686139f, 0.32035601f, -0.45331094f, -0.00374140f, 
    0.12971324f, 0.08831356f, 0.14892040f, 0.05186478f, -0.09037661f, 0.21056662f, -0.08572371f, -0.07719033f, 
    -0.35719746f, 0.08715884f, 0.08361728f, -0.10989871f, -0.05387800f, -0.13298629f, -0.11954027f, 0.11967257f, 
    -0.02974657f, -0.07000352f, 0.05182908f, 0.00855344f, -0.32791671f, 0.03622040f, 0.21961729f, -0.14116865f, 
    0.01540055f, -0.00017647f, 0.13617611f, 0.10778683f, -0.05486153f, 0.02170676f, -0.03407282f, 0.03079107f, 
    -0.05036173f, -0.05321378f, -0.02754476f, -0.08143178f, 0.07986139f, -0.01114713f, -0.01275693f, 0.02129392f, 
    0.07617547f, -0.04328155f, -0.01318804f, 0.06774052f, 0.12221687f, 0.10526802f, 0.00782208f, 0.02086570f, 
    -0.08433082f, 0.02524309f, 0.04273874f, -0.04384331f, -0.06831383f, -0.07837107f, 0.17273042f, -0.07030368f, 
    -0.07692497f, -0.09551846f, -0.02363513f, 0.10493562f, 0.08152863f, 0.19883296f, 0.05274745f, 0.01275521f, 
    0.10640762f, -0.03406168f, -0.06382784f, -0.02217894f, -0.28300413f, 0.13041413f, 0.24589150f, 0.08163046f, 
    -0.06073622f, -0.15933147f, 0.05393828f, -0.10732810f, 0.09107672f, 0.10961007f, 0.18926163f, 0.12109974f, 
    -0.09469442f, -0.08869170f, 0.13196290f, -0.08268994f, 0.02301462f, -0.01371216f, 0.01767995f, 0.07624936f, 
    0.07613054f, -0.00260949f, 0.09544271f, 0.16584495f, -0.01002853f, 0.10274057f, 0.29381153f, 0.17861754f, 
    -0.09200740f, -0.05311241f, -0.08017828f, 0.11683276f, 0.03965840f, 0.07746972f, 0.11883032f, 0.00203548f, 
    -0.22253393f, -0.04148381f, 0.14516921f, 0.29299927f, 0.21837553f, -0.13689609f, 0.17895813f, -0.05136176f, 
    -0.03644161f, 0.03019563f, 0.13338561f, 0.04593864f, -0.21962023f, 0.03416427f, 0.09693328f, 0.14426471f, 
    -0.07946959f, 0.09487323f, 0.15090653f, 0.04448344f, -0.07310864f, -0.23311234f, 0.02366952f, 0.04671396f, 
    -0.03676771f, 0.01427476f, 0.04260585f, 0.01063086f, 0.10013236f, 0.02474265f, -0.10923445f, -0.10241157f, 
    0.02477970f, 0.03794836f, -0.08325677f, 0.06274993f, 0.23625167f, 0.13016590f, 0.01356807f, -0.17872159f, 
    0.01237513f, -0.07167912f, -0.01172011f, 0.30615494f, 0.15035422f, -0.08998619f, 0.21214099f, -0.06555332f, 
    -0.27903506f, -0.23794465f, 0.11864720f, 0.08992998f, 0.02532664f, -0.04025775f, 0.04155985f, 0.01293972f, 
    0.06303142f, 0.00841259f, 0.00685987f, 0.08470581f, 0.02476101f, -0.17628306f, 0.11180049f, 0.09225496f, 
    -0.04121182f, 0.00149784f, -0.08553170f, 0.01158356f, 0.09892461f, 0.06629699f, 0.07054913f, 0.02158471f, 
    -0.03489506f, 0.02223023f, 0.10028003f, 0.05358598f, 0.10610628f, 0.10251249f, -0.00238353f, -0.07484698f, 
    0.12490906f, -0.08717686f, 0.02825924f, -0.01080277f, -0.18219973f, -0.06950739f, 0.04048041f, 0.02140614f, 
    -0.01425769f, 0.02349007f, 0.00815785f, 0.18000962f, -0.03498049f, -0.03955913f, 0.04686789f, 0.01222049f, 
    0.03356976f, -0.04850503f, 0.13783860f, 0.10319542f, 0.21531881f, 0.04397412f, -0.22235017f, 0.06837619f, 
    -0.00673863f, 0.01315625f, 0.07890447f, -0.04000537f, 0.10212836f, -0.43183494f, 0.06120436f, 0.32776037f, 
    -0.03963732f, 0.09319181f, 0.10909364f, 0.05538533f, 0.01863734f, 0.01911891f, 0.08028609f, -0.09902424f, 
    -0.05528439f, -0.04724453f, -0.02037283f, 0.10166761f, 0.07007761f, 0.10580991f, 0.04457896f, -0.12354479f, 
    0.07040514f, 0.17404070f, 0.10107927f, -0.07496598f, -0.30317262f, 0.05063413f, 0.14300060f, -0.13963248f, 
    -0.03021709f, 0.08489714f, -0.07689589f, 0.03998547f, 0.01796352f, 0.00601868f, -0.03587219f, 0.06651364f, 
    -0.26033106f, -0.01101071f, 0.34610930f, -0.02405316f, -0.00186538f, 0.09292717f, -0.00810524f, -0.04888025f, 
    0.06381351f, 0.03124932f, 0.04932608f, 0.07023308f, -0.06649708f, -0.20187770f, -0.09826456f, 0.01641728f, 
    0.10828659f, 0.07800242f, 0.09146800f, -0.00252731f, -0.02251596f, -0.03270160f, -0.10783260f, -0.07781272f, 
    -0.00703707f, -0.03238019f, -0.06075236f, -0.00175634f, 0.00764620f, -0.11075682f, 0.16642040f, 0.03113365f, 
    0.17275035f, -0.13221692f, 0.13415965f, 0.16152328f, 0.05004189f, 0.07082596f, 0.03001430f, -0.11106112f, 
    0.13074997f, -0.06783463f, -0.03605006f, -0.04571482f, 0.09584300f, 0.18782726f, 0.01735558f, 0.19424771f, 
    0.04891859f, 0.15091440f, 0.16911544f, -0.05630177f, 0.09107486f, 0.02280757f, 0.04261182f, 0.10082228f, 
    0.01639130f, 0.00568372f, 0.12988843f, -0.02042661f, -0.03934875f, -0.15149513f, 0.34599543f, 0.01224251f, 
    0.07073902f, 0.02196481f, 0.07461189f, -0.02542637f, 0.00089335f, -0.22285278f, -0.02339905f, 0.03185631f, 
    0.29487419f, 0.12357914f, -0.07318945f, -0.15622960f, 0.09673078f, 0.03074204f, 0.04203654f, -0.01286187f, 
    0.06044827f, 0.04696550f, 0.01914105f, -0.02594387f, -0.00549488f, -0.06233236f, -0.07560335f, -0.00994705f, 
    0.00036835f, 0.04381075f, -0.11429263f, -0.12316605f, -0.09762138f, -0.03848798f, 0.07081489f, 0.02468863f, 
    -0.04263285f, 0.12030131f, -0.11962518f, 0.14529084f, 0.00669076f, 0.00163237f, 0.09842973f, 0.08424754f, 
    -0.09107159f, -0.01748397f, 0.06609007f, 0.06704719f, -0.16069470f, 0.11363427f, 0.10418499f, -0.11526799f, 
    -0.02264831f, 0.11068904f, 0.04545666f, 0.04344724f, 0.08302302f, -0.07372081f, -0.02305592f, -0.02218378f, 
    -0.03289689f, 0.38099179f, -0.01283970f, 0.06357432f, -0.00653291f, 0.01519498f, -0.05193564f, -0.12804094f, 
    -0.10890235f, 0.00135991f, 0.10829573f, -0.02090954f, 0.03832467f, -0.22922514f, 0.34051234f, 0.04123700f, 
    0.02893956f, 0.00355067f, 0.00709606f, 0.13564554f, -0.08687606f, 0.13056262f, 0.01249728f, 0.00685436f, 
    -0.12995058f, 0.28928846f, -0.02949687f, 0.11085796f, 0.06685270f, 0.09829272f, 0.03456303f, 0.09119111f, 
    -0.02418008f, -0.03516677f, -0.15564910f, 0.01818889f, -0.13383967f, 0.30211741f, -0.04842506f, -0.02837585f, 
    0.00025981f, 0.07271589f, 0.12484003f, -0.01972735f, 0.00063564f, -0.03024113f, 0.00523511f, -0.02066156f, 
    0.02779830f, -0.00919773f, -0.07873107f, -0.09397627f, -0.04365935f, -0.10560359f, -0.00969260f, -0.06412799f, 
    0.00569416f, -0.10670841f, 0.02126720f, 0.13607480f, -0.06411555f, -0.07283826f, 0.09138966f, 0.12901179f, 
    -0.00298617f, -0.01601245f, 0.15499423f, -0.10974228f, -0.06337331f, 0.03673502f, -0.06887146f, -0.05585376f, 
    0.15288234f, -0.23163828f, -0.01986944f, -0.08127639f, 0.04541885f, 0.02198928f, 0.00205438f, -0.03408453f, 
    -0.06587033f, -0.03721449f, -0.01067150f, -0.09971248f, -0.19431862f, 0.12145711f, -0.12833595f, -0.10096303f, 
    0.07705203f, 0.12755165f, 0.19246928f, 0.05228927f, 0.06350198f, 0.08878531f, -0.10265785f, -0.21066697f, 
    0.14823242f, 0.03134324f, -0.09590014f, -0.01100580f, -0.08468608f, 0.19662978f, -0.10153122f, -0.00035735f, 
    -0.05512264f, 0.03914930f, 0.01682745f, -0.02614900f, 0.24956408f, -0.17805777f, 0.11287846f, 0.13005486f, 
    0.04710109f, 0.04258039f, -0.07187594f, 0.02294033f, -0.04445487f, -0.10451802f, 0.12277532f, 0.05390593f, 
    0.23524611f, 0.24804093f, 0.25374109f, -0.10667716f, 0.00245745f, 0.01034288f, 0.17258053f, 0.13742094f, 
    -0.00603302f, -0.05507320f, 0.09994400f, 0.00524195f, 0.08134771f, 0.02623354f, 0.06702093f, -0.20834272f, 
    0.00042585f, 0.02199182f, -0.10519677f, 0.17607054f, 0.02487515f, 0.07366648f, 0.12266754f, -0.12529670f, 
    -0.09765395f, -0.06766821f, 0.05017713f, 0.02721573f, 0.03471960f, 0.00158088f, 0.04895602f, -0.00341657f, 
    -0.02313077f, -0.05090062f, -0.03150826f, 0.04619391f, 0.06359464f, -0.16612099f, 0.36820775f, -0.10780086f, 
    -0.02960654f, 0.02323722f, -0.06162335f, -0.05151988f, 0.04917094f, 0.14126642f, -0.25881237f, 0.06607172f, 
    0.32681951f, 0.20735796f, 0.12160883f, 0.02009770f, 0.12640099f, 0.29948705f, 0.06102376f, 0.16419959f, 
    -0.00366260f, -0.02120952f, 0.04393057f, 0.04881760f, -0.21392275f, -0.01976878f, -0.05207324f, 0.16136776f, 
    -0.01803539f, 0.07816029f, 0.03107128f, 0.16231982f, 0.02501503f, 0.13217525f, 0.08235968f, -0.00723863f, 
    -0.09320405f, 0.06395930f, -0.26812851f, 0.06091348f, 0.03367122f, 0.00337472f, -0.02061535f, 0.00404701f, 
    -0.02433235f, 0.04042988f, -0.01815036f, 0.04577130f, 0.20057563f, 0.01270266f, -0.12778707f, -0.21050212f, 
    0.08535428f, 0.00780985f, -0.02300681f, 0.13768691f, -0.06132166f, 0.04798714f, 0.07322285f, 0.06671483f, 
    0.18452571f, 0.01893253f, 0.00283614f, 0.18554164f, -0.12986901f, 0.13533704f, -0.08828783f, 0.25584015f, 
    0.00956710f, 0.01868164f, -0.05486666f, 0.00804397f, 0.06578625f, 0.36298940f, 0.31551325f, 0.16772386f, 
    0.03199466f, -0.03545669f, 0.03155830f, 0.06004449f, 0.03704579f, 0.02028371f, 0.05799694f, -0.10954381f, 
    0.14418623f, 0.30301380f, 0.02504204f, 0.00661469f, 0.08588371f, 0.12667951f, -0.03881394f, -0.09923155f, 
    0.01152293f, 0.00427660f, 0.04625919f, -0.05338251f, 0.17758124f, 0.02485936f, -0.27256578f, 0.08270565f, 
    -0.04567916f, 0.03771061f, 0.01389937f, -0.03326837f, 0.05380155f, -0.03181740f, -0.01512686f, 0.10689224f, 
    0.02982242f, -0.06995021f, -0.26116997f, 0.13876830f, -0.05407311f, -0.00878988f, -0.00302642f, 0.10012267f, 
    -0.01962852f, 0.01506316f, 0.05226177f, -0.07099481f, 0.09631979f, 0.04356740f, 0.05553748f, -0.06405266f, 
    -0.05274121f, -0.01359253f, -0.01160002f, 0.05183178f, -0.03048609f, 0.07824134f, -0.02856877f, 0.00456183f, 
    -0.06042042f, -0.00954983f, -0.03072350f, -0.02989019f, -0.07235197f, 0.03782253f, -0.13262679f, -0.01996101f, 
    0.01482130f, -0.04845540f, 0.07729471f, 0.10212655f, -0.20074300f, 0.08158815f, 0.08301895f, 0.03851940f, 
    0.04458509f, 0.10868888f, 0.06085032f, -0.20384738f, 0.00341877f, 0.08694060f, 0.06629319f, -0.11654925f, 
    -0.00015936f, 0.26293439f, 0.09890324f, 0.08236882f, -0.06513119f, 0.06077365f, -0.02217613f, -0.02937337f, 
    0.00084945f, 0.02559636f, 0.01493606f, 0.07365812f, -0.20141816f, 0.33852100f, 0.23770729f, 0.07544959f, 
    -0.07050979f, 0.01698437f, 0.03998697f, -0.05039614f, -0.00173971f, -0.07092707f, 0.10518372f, -0.01498679f, 
    0.30967560f, -0.01236533f, 0.05554381f, 0.02825767f, 0.02469004f, 0.02489073f, -0.02982552f, 0.07357897f, 
    0.01197781f, -0.01572220f, -0.00792891f, -0.02221408f, -0.05050465f, 0.21009561f, -0.06251317f, -0.13774551f, 
    0.02381021f, 0.03706494f, -0.02543931f, 0.03997641f, 0.04074541f, 0.03170153f, 0.03976651f, 0.00812748f, 
    -0.01882681f, -0.15274847f, 0.02988864f, -0.13212173f, -0.01997245f, -0.01888711f, 0.04263080f, -0.06196750f, 
    0.00604753f, 0.00362558f, -0.01741373f, -0.07391897f, -0.23586304f, 0.06262888f, 0.00981579f, 0.07661524f, 
    -0.07727104f, 0.02669244f, -0.01271416f, 0.00855156f, 0.02423491f, -0.06638601f, 0.10628227f, 0.13173789f, 
    -0.02538685f, 0.09402298f, -0.00908813f, 0.11983145f, 0.05083476f, 0.06843344f, 0.12174913f, -0.08172431f, 
    -0.05904134f, -0.12497357f, 0.08206642f, -0.01102962f, -0.17984492f, -0.01861909f, -0.14669439f, 0.17148593f, 
    0.02413519f, -0.10796820f, 0.04616673f, -0.03819817f, 0.05671989f, -0.12070537f, -0.12187494f, 0.03434566f, 
    0.13803495f, 0.15731563f, 0.14698701f, 0.27076736f, -0.05168277f, 0.03194797f, -0.09272852f, -0.12519653f, 
    0.00607466f, 0.00087947f, 0.03219385f, -0.01033700f, 0.13843086f, 0.15373179f, 0.05005003f, 0.10805252f, 
    -0.02020869f, 0.14254940f, -0.09319817f, -0.01472191f, 0.01965793f, 0.05331780f, 0.01715711f, -0.01001045f, 
    -0.10548738f, -0.10167050f, -0.03793360f, 0.07372113f, -0.00354836f, 0.01728085f, 0.04444167f, -0.02861536f, 
    -0.07312613f, -0.02779788f, -0.03081544f, -0.06212799f, 0.12368532f, 0.06889858f, -0.02522633f, 0.05306866f, 
    -0.05317299f, -0.04186785f, 0.10739104f, 0.03308083f, -0.05937823f, -0.03212999f, 0.02468374f, -0.03728684f, 
    -0.06000739f, -0.03419896f, -0.22221600f, -0.07036226f, 0.03383443f, -0.01077055f, 0.01316864f, 0.03290375f, 
    -0.00843347f, -0.03382800f, 0.00922474f, -0.02757693f, 0.27009821f, 0.25717729f, -0.06748816f, -0.21162122f, 
    -0.11798367f, -0.06455122f, -0.11892143f, 0.01404956f, -0.03704741f, 0.02061611f, 0.02847240f, -0.02646535f, 
    0.04568284f, 0.01578343f, -0.03814632f, -0.06327767f, 0.05154187f, -0.07859937f, 0.13418120f, 0.06746701f, 
    -0.01105823f, -0.05849492f, 0.00092230f, -0.11316062f, 0.22278813f, -0.05692568f, 0.07960231f, 0.06724642f, 
    -0.06164604f, 0.03755170f, -0.00983510f, 0.10758524f, -0.05917607f, -0.10634100f, -0.03849272f, -0.02532016f, 
    -0.15258150f, 0.30533603f, 0.14655763f, -0.04759439f, -0.13489467f, 0.00119570f, 0.04503033f, 0.13072440f, 
    -0.00962210f, -0.00461934f, 0.09457058f, -0.03315014f, 0.00200017f, 0.04707507f, -0.22273318f, -0.03198058f, 
    0.09800962f, -0.06523354f, -0.01228598f, 0.12109613f, 0.01152195f, 0.01329855f, 0.03503636f, -0.01356918f, 
    -0.05136204f, -0.22133142f, -0.01323385f, 0.01232234f, 0.02874384f, 0.02770959f, 0.02953593f, 0.09835042f, 
    0.03563430f, -0.11879514f, 0.00780891f, -0.05738445f, -0.14950807f, -0.05123882f, 0.16514584f, -0.11941089f, 
    -0.05414169f, 0.00034917f, 0.01674513f, -0.07089130f, 0.03317525f, 0.07167035f, -0.03804212f, 0.03566490f, 
    0.14512396f, 0.24558175f, 0.20572525f, 0.07683263f, -0.09987661f, 0.04500487f, -0.00737632f, 0.03049728f, 
    -0.04097296f, -0.02893832f, -0.03768051f, -0.04732697f, -0.16963789f, -0.02595263f, 0.07245173f, 0.03466237f, 
    -0.07001098f, -0.00937908f, -0.04145296f, -0.01311128f, 0.14077727f, 0.08309019f, -0.13551089f, 0.08665604f, 
    0.19100143f, -0.20135856f, -0.06805151f, -0.06139714f, -0.02873445f, 0.02952533f, -0.08754356f, 0.01258111f, 
    -0.11557849f, 0.01640769f, 0.01881027f, 0.04443938f, 0.09754053f, 0.08870303f, 0.12516545f, -0.06291509f, 
    0.09045576f, -0.10314552f, -0.00650862f, 0.03508310f, 0.02397535f, 0.07192452f, 0.06326655f, 0.05511760f, 
    0.22185719f, -0.31856996f, 0.14692535f, -0.14867464f, -0.05873003f, -0.01549880f, -0.00618747f, 0.21219385f, 
    -0.06107875f, -0.07161519f, -0.02794799f, 0.02153123f, -0.21876918f, -0.10769859f, 0.09903353f, -0.01787986f, 
    0.15217756f, 0.10870799f, 0.05743913f, -0.07648391f, -0.06569181f, -0.10586426f, 0.01072224f, -0.11035669f, 
    0.16812810f, 0.15133289f, 0.11208463f, 0.11490346f, -0.04969299f, -0.01562173f, -0.13021865f, 0.13641472f, 
    -0.07514201f, -0.08391431f, 0.02699072f, 0.00185987f, -0.24091992f, -0.31105095f, 0.20682912f, 0.02256452f, 
    -0.03191274f, -0.02039802f, -0.01339605f, -0.01901026f, -0.03152878f, -0.07630441f, -0.03154463f, -0.03355050f, 
    -0.04932788f, -0.32998344f, -0.12471405f, -0.10111717f, 0.01284578f, 0.05523602f, 0.03600448f, -0.02843836f, 
    -0.02413686f, -0.10214297f, -0.08876319f, -0.07107307f, -0.06276294f, -0.20481212f, -0.16487174f, 0.00230050f, 
    -0.04030651f, 0.00875500f, 0.00657410f, -0.05262379f, 0.01313359f, -0.01518981f, 0.03070428f, -0.07746991f, 
    -0.01717335f, -0.01322281f, -0.02077598f, -0.06123231f, 0.02419942f, -0.01172819f, 0.05255485f, 0.02277270f, 
    0.00598956f, 0.03805995f, -0.04142670f, -0.09607977f, -0.19030307f, 0.19682577f, 0.14653605f, 0.04629119f, 
    -0.07578699f, 0.11942928f, 0.03332116f, -0.08476535f, 0.01020679f, 0.01034452f, -0.07946195f, -0.07640762f, 
    -0.00501865f, -0.05889126f, 0.03302591f, 0.03257808f, 0.02682143f, 0.00191493f, 0.04413090f, -0.04925543f, 
    -0.01493707f, -0.03588809f, -0.04127361f, 0.02924909f, 0.03806244f, -0.03742610f, 0.02107471f, -0.02494881f, 
    0.03814152f, 0.02887654f, -0.00288592f, 0.01491741f, -0.04082581f, -0.03363896f, -0.03878783f, -0.00993122f, 
    -0.00261374f, -0.00991952f, 0.01599925f, 0.02496820f, -0.04708234f, -0.02169040f, -0.00325014f, 0.03286979f, 
    -0.05746523f, -0.02629996f, -0.01588203f, 0.04189500f, -0.03184320f, 0.02913021f, 0.01863464f, 0.02301952f, 
    0.00603037f, -0.02325465f, 0.00834844f, -0.01093911f, 0.00495246f, -0.00655111f, 0.02873736f, 0.02997628f, 
    -0.01692485f, -0.02614453f, -0.02660218f, -0.00683548f, 0.01204617f, -0.06002160f, -0.02365830f, 0.03795226f, 
    0.01746253f, 0.00420522f, -0.04884539f, -0.01997745f, -0.03867553f, -0.01173564f, -0.00090234f, 0.03803355f, 
    0.02393292f, 0.03706605f, -0.04836131f, -0.01152791f, 0.02118359f, -0.05430052f, -0.03965878f, -0.02618629f, 
    0.02904062f, 0.00015477f, -0.03999429f, -0.05290257f, -0.04414526f, -0.04362576f, -0.00017778f, -0.05060648f, 
    0.01631462f, 0.02587078f, 0.02261013f, 0.00397063f, -0.02949771f, 0.01736056f, 0.01823997f, 0.04131631f, 
    0.03432891f, -0.02495926f, 0.01730646f, -0.02798962f, 0.02193469f, -0.04086459f, -0.03889053f, -0.05577186f, 
    -0.01572948f, -0.03698607f, 0.03007155f, 0.01168266f, -0.00379162f, 0.03666749f, -0.05623166f, 0.00853265f, 
    -0.00288530f, -0.04149241f, -0.03669488f, 0.00356518f, 0.03402580f, 0.00107402f, -0.03512904f, 0.01500389f, 
    -0.00697820f, -0.00778951f, 0.01347214f, 0.00742370f, -0.00376548f, 0.03489297f, 0.00430656f, 0.00823750f, 
    -0.01141212f, 0.03710218f, -0.00515489f, -0.00219307f, -0.03141532f, 0.03522525f, -0.02267288f, -0.04802268f, 
    -0.00865905f, -0.00744005f, 0.03585982f, -0.04462814f, -0.00836214f, -0.01354191f, 0.03935829f, 0.01292167f, 
    -0.01392150f, 0.03637583f, 0.02863888f, -0.04790617f, 0.02564459f, 0.03890604f, -0.01708528f, -0.03319567f, 
    0.01999623f, 0.00316626f, 0.02006452f, -0.03407436f, -0.04536772f, -0.03006733f, -0.03619820f, -0.05117328f, 
    -0.00778411f, -0.03108695f, 0.02014665f, 0.00302226f, 0.03084756f, -0.05586902f, -0.00666049f, 0.04005265f, 
    0.02126860f, 0.03812862f, 0.00287975f, -0.05903792f, 0.00954410f, 0.00265092f, -0.02229585f, -0.00212700f, 
    0.04642619f, 0.00738342f, -0.01351937f, 0.03138846f, 0.03958764f, -0.02550938f, -0.02512040f, -0.01464776f, 
    0.01764057f, -0.03606378f, -0.00373910f, 0.01993349f, -0.01108674f, 0.02001568f, -0.05523736f, 0.00083605f, 
    -0.04413920f, -0.00081308f, -0.03907473f, 0.02987009f, -0.00295033f, -0.00034327f, 0.03588600f, 0.02394545f, 
    0.01369662f, 0.03737314f, -0.01757712f, -0.05740972f, 0.03575275f, -0.00840028f, -0.03541321f, -0.02804868f, 
    -0.00425185f, -0.00748304f, 0.02658568f, 0.01701259f, -0.04667482f, -0.02175913f, 0.02607360f, 0.00104490f, 
    -0.01295729f, -0.01367531f, -0.02989457f, -0.01991871f, 0.02718930f, -0.01849816f, -0.00278320f, -0.04841790f, 
    -0.05703971f, 0.01673910f, 0.00568287f, 0.03300776f, -0.06053703f, 0.04104767f, -0.03107209f, -0.05876731f, 
    0.02145138f, 0.00852091f, -0.03091493f, -0.01628200f, -0.03798106f, -0.04740184f, -0.01518599f, 0.03382766f, 
    -0.02232363f, 0.00807966f, -0.00173618f, 0.01574086f, 0.02889539f, -0.00354882f, -0.00478621f, 0.01738783f, 
    -0.05219784f, 0.00582793f, 0.02526738f, -0.03599020f, 0.02487088f, 0.03210324f, -0.03679731f, -0.02788943f, 
    -0.02166060f, 0.03073145f, -0.03241856f, 0.03795417f, 0.04140446f, -0.00850084f, 0.04164519f, 0.03785319f, 
    -0.00422857f, -0.03268649f, -0.03264687f, -0.04182177f, 0.02086203f, -0.03983008f, 0.02489832f, -0.04003032f, 
    0.00423789f, -0.00056059f, 0.01923140f, -0.05082887f, -0.05840623f, -0.05029471f, -0.03001003f, -0.04451647f, 
    -0.03795912f, 0.01642185f, -0.04302418f, -0.02874335f, -0.02776707f, -0.05148462f, -0.01663476f, 0.04048443f, 
    0.02243747f, -0.04975403f, -0.00954093f, -0.03941812f, -0.00472282f, -0.05622051f, 0.04165459f, -0.03666819f, 
    0.03798024f, 0.01673516f, -0.03977010f, 0.02660347f, -0.02154895f, -0.04535610f, -0.04580202f, -0.00380055f, 
    0.01513506f, 0.04341606f, 0.00377676f, 0.02429281f, -0.02037225f, 0.03736221f, 0.01146269f, 0.01299123f, 
    -0.04344478f, 0.00110442f, -0.04530133f, 0.01527295f, 0.02996543f, -0.01217880f, -0.02615685f, 0.02929835f, 
    -0.04763119f, -0.02460947f, -0.04793817f, -0.02443651f, 0.03000863f, -0.05612719f, -0.03975479f, -0.03228143f, 
    -0.03632415f, -0.04998372f, -0.00703139f, -0.00363429f, 0.00376852f, -0.03853851f, -0.01853496f, 0.02797867f, 
    0.03297564f, 0.01814495f, 0.01475049f, -0.05787491f, 0.00965187f, 0.02611708f, -0.01551845f, 0.03507676f, 
    -0.00612347f, -0.04760175f, -0.01565806f, 0.03481405f, -0.02328750f, -0.04807317f, -0.03093970f, -0.02415015f, 
    0.02285179f, -0.01031850f, -0.04736589f, -0.04782804f, -0.03186834f, 0.00736488f, -0.01909128f, 0.03467012f, 
    -0.00503513f, -0.01168800f, -0.04182355f, -0.01068945f, 0.03292611f, -0.01397322f, -0.00888245f, 0.02910409f, 
    -0.01167435f, -0.04933961f, -0.00076274f, 0.02642932f, -0.03617780f, 0.00537153f, -0.00890440f, -0.03735838f, 
    0.01527673f, 0.01551018f, -0.01324668f, 0.01867758f, -0.04818903f, -0.01876541f, 0.01710000f, 0.01015436f, 
    -0.01993604f, -0.00580323f, -0.04887277f, 0.02702301f, -0.02885324f, -0.01697821f, 0.00366989f, -0.00396311f, 
    0.00944773f, -0.00660895f, -0.02146178f, 0.04838812f, -0.04302287f, -0.02261040f, -0.04387707f, 0.03017049f, 
    0.03858516f, 0.01628751f, 0.01092748f, -0.05004368f, 0.03478722f, 0.02639076f, 0.03321843f, 0.02987893f, 
    -0.01089257f, 0.02042523f, 0.01585609f, -0.01612435f, -0.01768208f, 0.03690184f, -0.02127365f, -0.05175924f, 
    0.00592643f, 0.03482125f, 0.02979880f, -0.05012365f, -0.01994635f, -0.01489930f, -0.01126419f, 0.02492398f, 
    0.00321468f, -0.02878525f, -0.03788236f, 0.01052476f, -0.00281310f, -0.05748368f, -0.01640375f, 0.01669295f, 
    0.01615014f, 0.03810249f, 0.01904072f, 0.02929662f, -0.03599017f, -0.01182561f, -0.00420805f, -0.04128275f, 
    -0.00394784f, -0.01853215f, 0.02382813f, -0.02667562f, 0.02977877f, 0.00357896f, -0.01864352f, 0.02828793f, 
    -0.02699169f, -0.03796359f, 0.01374698f, -0.03141474f, 0.01141389f, 0.03313013f, -0.00102749f, 0.01177660f, 
    0.02707557f, -0.02904082f, 0.00759152f, -0.01348290f, -0.02322081f, -0.04872927f, 0.00363494f, -0.04194595f, 
    -0.04306529f, -0.02116893f, -0.00282684f, -0.04111348f, -0.01357883f, 0.02672077f, -0.04218576f, -0.04861448f, 
    -0.01369219f, 0.03202196f, -0.04041868f, -0.04341776f, 0.02319256f, -0.02187166f, -0.00820221f, 0.04447008f, 
    0.02322470f, -0.03504549f, -0.00638305f, -0.00772402f, 0.01741841f, 0.02209203f, -0.03658748f, -0.03881264f, 
    -0.03029169f, -0.03815600f, -0.02794242f, -0.03450532f, -0.03789981f, -0.05012808f, -0.02835093f, -0.02962975f, 
    -0.03876085f, -0.02671362f, -0.02253519f, -0.00026437f, -0.04996724f, 0.01401724f, -0.03873206f, -0.00360209f, 
    0.00686982f, -0.00673988f, -0.02080808f, -0.01949571f, -0.03248116f, -0.02903722f, 0.03147611f, 0.01157957f, 
    0.01824807f, -0.00296836f, -0.05447992f, 0.00548406f, -0.04504997f, -0.04209979f, 0.00039890f, 0.02643213f, 
    0.02998617f, -0.04790487f, -0.00344552f, 0.04269464f, 0.01534167f, 0.01609107f, 0.01211176f, -0.01215207f, 
    -0.03786796f, -0.04475274f, -0.04577957f, 0.02150641f, -0.04610409f, 0.01456257f, 0.02882857f, -0.05004026f, 
    -0.03857857f, 0.00394208f, 0.01125154f, 0.00420909f, -0.01413518f, -0.04848735f, 0.03125407f, 0.02677069f, 
    -0.02865687f, -0.01174837f, 0.02782080f, 0.02490572f, -0.04393005f, 0.02766475f, 0.01823604f, -0.03581813f, 
    0.01019146f, -0.05358381f, -0.00342325f, -0.00308943f, 0.01606750f, 0.02657412f, 0.04400963f, -0.04098917f, 
    0.04219307f, 0.04787909f, 0.03933689f, -0.01501863f, -0.02149149f, 0.01144783f, -0.02464805f, -0.01113044f, 
    0.01819904f, -0.04553096f, -0.03607499f, 0.03775145f, -0.01631659f, 0.04150308f, -0.05389835f, -0.05483887f, 
    0.02453913f, 0.01634933f, -0.00919539f, -0.02307894f, -0.00731276f, -0.05803957f, 0.02405136f, -0.02210990f, 
    -0.01732111f, -0.03061741f, -0.04973025f, 0.03129032f, -0.02023738f, -0.04633946f, -0.02992887f, -0.03830781f, 
    0.02856656f, 0.01035509f, -0.02142182f, -0.03957093f, -0.01215661f, -0.00360315f, -0.02886510f, -0.03183862f, 
    0.01307853f, 0.02113762f, 0.04504500f, 0.02856651f, -0.01527220f, 0.02714533f, 0.04222576f, -0.05058160f, 
    0.04406107f, -0.02673519f, -0.00559754f, -0.02318014f, -0.00129918f, -0.00622371f, 0.03309263f, -0.02065876f, 
    -0.01481217f, -0.00761986f, -0.01774872f, -0.05044503f, -0.00430853f, -0.00224154f, 0.02363351f, -0.00253303f, 
    -0.01076095f, 0.02016598f, 0.01601385f, -0.00402775f, 0.00408700f, -0.03442614f, 0.01350603f, -0.01283422f, 
    -0.04639344f, 0.01139169f, 0.02373752f, -0.05280312f, 0.04553059f, -0.00016768f, -0.04998149f, -0.03416450f, 
    -0.05070334f, 0.01166401f, -0.05682637f, -0.04013975f, -0.03549175f, 0.01667243f, 0.02461179f, 0.01069170f, 
    0.01546963f, -0.03751687f, -0.00008014f, -0.04737160f, -0.04410528f, 0.00673053f, 0.03139315f, 0.01657612f, 
    -0.04662909f, -0.05229840f, -0.02961111f, 0.02968866f, -0.00598520f, 0.03227740f, -0.02058111f, 0.00251010f, 
    -0.04128559f, 0.02938600f, -0.03538341f, 0.03602645f, -0.04047892f, 0.00535790f, 0.03577221f, 0.03389307f, 
    -0.04669805f, 0.02018614f, -0.03183744f, 0.02970934f, 0.02488162f, 0.01455162f, 0.00287854f, -0.01965770f, 
    -0.05257997f, -0.04333499f, 0.00908729f, -0.03955359f, -0.03036470f, -0.01680109f, -0.01260238f, -0.03803810f, 
    0.02867637f, 0.01045073f, -0.02398757f, 0.03730771f, -0.00203829f, 0.01875865f, -0.01666205f, -0.00674688f, 
    0.00983494f, -0.01992870f, 0.03139187f, 0.04405163f, 0.00716413f, -0.02526522f, -0.01599270f, 0.03068492f, 
    0.02689165f, 0.01501043f, -0.02145639f, 0.02562968f, -0.03473821f, -0.01186751f, -0.02509804f, -0.04202130f, 
    0.01255090f, -0.01149964f, -0.02759068f, 0.02590605f, -0.02699901f, 0.01060624f, -0.02928621f, 0.02147692f, 
    0.03002497f, -0.04835577f, -0.02586344f, 0.03931108f, -0.00543460f, 0.02019295f, -0.03671685f, 0.01993888f, 
    -0.00210643f, -0.02468996f, -0.04358530f, 0.01115627f, 0.04595482f, -0.00266360f, -0.04147792f, -0.02933085f, 
    -0.05077471f, 0.04211292f, -0.01308102f, -0.01319022f, -0.01110940f, 0.03095108f, -0.01827043f, -0.04210372f, 
    -0.02297770f, 0.01407573f, -0.00838450f, 0.01650065f, -0.00351252f, -0.04803665f, -0.05684343f, -0.01700726f, 
    -0.01511026f, -0.03513238f, 0.01480156f, -0.02862697f, 0.02621493f, -0.04574315f, -0.04014436f, -0.00301798f, 
    -0.01054086f, 0.01580620f, 0.02641759f, -0.03842913f, 0.01023404f, 0.05087748f, -0.01184617f, -0.05280455f, 
    -0.00909763f, -0.03837339f, 0.03077998f, 0.01118375f, 0.01015206f, 0.00198982f, -0.03809884f, -0.04438601f, 
    0.21344459f, 0.25384590f, 0.33667466f, 0.07718729f, 0.08570849f, 0.06862547f, 0.16338453f, 0.03646810f, 
    0.03100458f, -0.05714588f, -0.02950151f, -0.00897342f, 0.10046525f, -0.24050063f, 0.14176247f, -0.06379133f, 
    0.06677622f, -0.18661804f, 0.01009825f, 0.12292051f, 0.06670903f, 0.02792607f, 0.03292361f, -0.06371278f, 
    0.30650353f, 0.38091940f, 0.34200397f, 0.18269470f, -0.00679900f, 0.12858768f, 0.07895752f, 0.18856481f, 
    -0.04485430f, 0.00387282f, -0.08316845f, 0.08402994f, 0.04884454f, 0.08819564f, 0.12837003f, 0.18261541f, 
    -0.03106880f, -0.01287511f, 0.01469462f, -0.01954710f, 0.07123368f, -0.03528590f, -0.01324476f, -0.01470404f, 
    0.01348286f, -0.00289950f, -0.04953742f, 0.03459869f, 0.04586422f, 0.02674319f, -0.12630843f, -0.01475063f, 
    0.05079933f, 0.07819922f, 0.01110901f, -0.05306039f, -0.25920111f, 0.14563017f, 0.06036836f, -0.01137612f, 
    -0.05141210f, 0.01057357f, -0.03372566f, 0.00589390f, 0.03670176f, 0.07385703f, 0.01424897f, -0.03493789f, 
    0.07402012f, 0.29298830f, 0.07627613f, -0.05447066f, -0.01267074f, -0.08307303f, -0.10152100f, -0.03805995f, 
    -0.07772691f, -0.07364367f, -0.08444515f, 0.03437027f, -0.09252959f, 0.06984378f, -0.00645070f, 0.04242806f, 
    0.09575802f, -0.09982947f, -0.13839468f, -0.11349201f, -0.08924025f, 0.07530612f, 0.04687403f, -0.03963549f, 
    0.13702421f, -0.06538662f, 0.00429276f, -0.06753199f, 0.17601095f, 0.02502457f, 0.13237262f, -0.03320169f, 
    -0.03734375f, 0.04339791f, -0.01396539f, -0.01376042f, 0.12586832f, -0.11084085f, 0.10809088f, -0.01250433f, 
    -0.04620368f, -0.01644550f, -0.00461439f, -0.00398862f, -0.00789561f, -0.02005424f, 0.07312129f, -0.04469657f, 
    0.06333337f, 0.20264025f, -0.06601915f, 0.09748363f, 0.04576218f, 0.04591238f, 0.05650404f, 0.04939390f, 
    0.04586978f, 0.01678874f, -0.01003333f, 0.00090421f, -0.12031689f, 0.12431262f, -0.09081507f, -0.05552884f, 
    -0.00394543f, 0.14580239f, 0.11719002f, 0.22377130f, 0.01313490f, 0.06948970f, 0.14330150f, -0.07418255f, 
    0.08197793f, 0.19864590f, -0.23135239f, 0.16980882f, -0.02379627f, 0.08052468f, 0.03830146f, -0.01744699f, 
    -0.01970645f, 0.09947225f, 0.10101606f, -0.06996918f, -0.16823091f, -0.29391721f, -0.43624291f, -0.23933728f, 
    0.11556938f, 0.03610471f, -0.10129672f, 0.00472009f, 0.04746207f, 0.00072990f, 0.02294514f, -0.01104517f, 
    0.15309304f, 0.07542960f, 0.06901937f, 0.07542866f, 0.10403107f, 0.06621195f, -0.03510843f, -0.01610468f, 
    0.05564849f, -0.01771614f, -0.10288739f, 0.02387919f, -0.19497837f, 0.23638256f, -0.08946682f, -0.05104090f, 
    0.11334041f, -0.00610994f, 0.01662517f, -0.04993902f, -0.08883874f, 0.14675806f, 0.06904758f, 0.00252918f, 
    0.08742417f, -0.43661571f, -0.12553965f, -0.07443924f, -0.02951938f, 0.05689947f, 0.02205119f, 0.03034084f, 
    -0.03244702f, 0.02657487f, 0.00651366f, 0.00089907f, 0.25433016f, 0.06919990f, 0.02030279f, 0.28310645f, 
    -0.02400891f, -0.00409641f, -0.07128199f, 0.11068688f, 0.00058286f, 0.13855526f, 0.08337268f, 0.07253931f, 
    0.08851732f, -0.01127501f, -0.05497052f, -0.11033651f, -0.00169656f, -0.01864058f, 0.04757170f, -0.03036422f, 
    -0.15217720f, 0.00444679f, -0.11560675f, 0.05287174f, -0.04915275f, 0.16097234f, -0.22965376f, 0.05341758f, 
    0.11479289f, -0.08516837f, 0.00779388f, 0.04649026f, -0.06760385f, -0.02430312f, -0.08964092f, 0.04511560f, 
    0.33795381f, 0.29588234f, 0.18763630f, -0.00950925f, 0.19682896f, 0.03640893f, 0.05848093f, 0.01869121f, 
    0.06857649f, -0.00623846f, -0.07676291f, -0.02303654f, 0.10964883f, -0.12022179f, -0.06313451f, -0.15162635f, 
    -0.01196878f, -0.04310215f, 0.03250169f, -0.06688716f, -0.14359933f, -0.03810677f, -0.10709745f, 0.11180080f, 
    -0.01543967f, 0.14328580f, -0.11124116f, 0.07054883f, -0.00022173f, 0.03702467f, 0.08192914f, 0.00895577f, 
    0.03360328f, -0.03153088f, 0.05238376f, -0.07861369f, 0.20574021f, -0.31969547f, -0.19635376f, -0.19670466f, 
    0.03095682f, -0.00890679f, 0.00254659f, 0.01141073f, 0.03157875f, -0.02798343f, 0.05380032f, 0.03720078f, 
    0.11361193f, 0.35469922f, 0.25257736f, -0.22785853f, 0.08857919f, 0.02112983f, 0.21063899f, -0.11045183f, 
    -0.04402190f, 0.04905175f, -0.09522616f, 0.03041643f, 0.19177637f, 0.07633264f, -0.07888134f, -0.24598522f, 
    -0.07292546f, -0.24821149f, -0.01023081f, -0.03242540f, 0.00216706f, 0.00383622f, -0.05577229f, 0.03961554f, 
    0.24356784f, 0.12922442f, 0.19975539f, 0.21292038f, -0.04272284f, 0.10526437f, -0.04031503f, -0.00130693f, 
    -0.08614220f, -0.07633328f, -0.04524396f, -0.11844169f, 0.10827710f, 0.08059381f, 0.07897237f, 0.01538179f, 
    0.02863341f, -0.05397354f, -0.02902194f, 0.05743467f, -0.01614243f, 0.00898788f, 0.03786775f, 0.05021670f, 
    0.29649445f, -0.01700141f, 0.00138659f, 0.17483582f, -0.08422811f, 0.05642619f, -0.00428828f, 0.03968368f, 
    -0.00971158f, 0.05933239f, 0.01404292f, -0.11330914f, 0.15836680f, 0.08971228f, 0.06216443f, 0.03345242f, 
    0.08948052f, -0.01079091f, -0.05617197f, -0.01516489f, 0.05302911f, 0.00294418f, 0.09050766f, 0.04375394f, 
    0.10821016f, -0.12563802f, 0.02949105f, 0.04066427f, 0.02326566f, 0.01758851f, -0.10018064f, -0.06743215f, 
    0.03877596f, -0.03690088f, -0.07259822f, -0.08242937f, 0.08202483f, -0.07380260f, 0.12672177f, -0.05044531f, 
    -0.06600367f, -0.11639021f, 0.00294452f, 0.02664075f, 0.04476322f, -0.00936432f, 0.05105041f, -0.12112092f, 
    -0.00552871f, -0.21784602f, -0.11820610f, -0.31814662f, 0.25637925f, -0.02977520f, -0.30469853f, 0.05526206f, 
    -0.11527527f, -0.05628197f, -0.16142146f, 0.05669339f, -0.35500717f, 0.34192416f, 0.12950423f, -0.21161456f, 
    -0.14238410f, 0.21121864f, -0.17221129f, -0.25449902f, -0.00538772f, -0.03814370f, -0.03963046f, -0.02555930f, 
    -0.41296643f, -0.54239863f, -0.14375345f, -0.03524503f, 0.16000043f, 0.02588624f, 0.10741012f, 0.22880742f, 
    -0.01588573f, 0.01137597f, -0.03465404f, -0.04681225f, 0.15444644f, 0.14185387f, 0.14414671f, 0.20165318f, 
    -0.03655905f, -0.12861040f, -0.03491604f, 0.04421046f, 0.03690024f, -0.15455468f, 0.10118552f, -0.02031777f, 
    0.13345560f, 0.11781332f, 0.12214683f, 0.08179924f, 0.07376437f, 0.06304400f, 0.01607528f, 0.01395889f, 
    0.16533093f, 0.00478876f, 0.10866171f, 0.05152236f, -0.10786769f, -0.06815574f, 0.02646230f, 0.07857002f, 
    -0.06661368f, -0.05338418f, -0.02436243f, -0.08120988f, -0.06663857f, -0.03637303f, -0.24896812f, 0.08050319f, 
    0.14107946f, 0.11214687f, 0.05596099f, -0.07335565f, 0.00698791f, -0.09792560f, -0.03066617f, -0.11862722f, 
    0.12453508f, 0.09789269f, 0.11097758f, 0.12249713f, -0.01050914f, 0.15921167f, 0.10393585f, 0.16367865f, 
    -0.00860569f, 0.03883873f, 0.04030962f, -0.11047600f, 0.13516761f, -0.02944972f, 0.03771695f, 0.03495897f, 
    0.10200687f, -0.06020906f, -0.11870066f, -0.10759465f, -0.02556476f, 0.00150088f, 0.04631200f, -0.02621643f, 
    -0.02245388f, -0.05483626f, -0.00232507f, -0.09210972f, 0.30785713f, -0.15195699f, -0.19926652f, 0.13597938f, 
    -0.08654810f, -0.03411382f, -0.08085036f, -0.04375543f, 0.01240699f, -0.04036662f, 0.12009711f, 0.04838983f, 
    0.08074932f, 0.00621862f, 0.15461572f, 0.24697407f, -0.03309982f, -0.03583388f, 0.01887673f, -0.01621401f, 
    0.00217468f, 0.05152379f, -0.05166827f, 0.06553886f, -0.13212392f, -0.04057160f, -0.11945812f, -0.12393393f, 
    0.09137258f, 0.10509434f, 0.10634535f, 0.15370554f, 0.12305775f, -0.05440225f, -0.14268123f, -0.05416432f, 
    0.16104215f, 0.17079946f, 0.11495847f, 0.19026296f, 0.05762700f, -0.07410979f, 0.11558313f, 0.02889236f, 
    0.06786027f, -0.02433433f, 0.01844055f, 0.01575835f, 0.38280115f, -0.23720022f, -0.58435154f, -0.82899779f, 
    -0.14967783f, -0.06439096f, -0.08127652f, 0.16084565f, 0.08065308f, 0.08932079f, 0.04596869f, -0.08332774f, 
    0.06111680f, 0.10543422f, 0.02904136f, 0.05234927f, -0.02084799f, -0.05733256f, 0.07274228f, -0.04240327f, 
    -0.02485249f, -0.02593838f, -0.06355876f, 0.05008828f, -0.18782672f, -0.39347529f, -0.28859124f, 0.04621911f, 
    0.01527146f, 0.13827407f, 0.20444793f, -0.11585018f, 0.11903903f, -0.01707683f, -0.02739417f, 0.07288726f, 
    -0.12675512f, 0.06633563f, -0.48528984f, -0.31465754f, -0.14412047f, 0.18009894f, -0.01062864f, 0.07774793f, 
    -0.00243099f, 0.04537478f, -0.17338020f, 0.00469960f, 0.23798439f, 0.15513939f, -0.05996243f, 0.27679843f, 
    -0.05645406f, -0.12762250f, 0.02933818f, 0.13595296f, 0.09500072f, 0.17088202f, -0.02782029f, -0.02241174f, 
    0.10714217f, 0.03126516f, 0.06171805f, 0.10323922f, -0.14668863f, 0.12639020f, 0.03096089f, -0.06964558f, 
    0.04409769f, -0.00632871f, 0.01312357f, -0.02443092f, -0.33846265f, 0.19057070f, -0.29051787f, 0.25685683f, 
    0.01751995f, 0.01259503f, 0.34705356f, -0.08396246f, 0.28094885f, 0.24791555f, -0.15527692f, 0.04577009f, 
    -0.04809728f, -0.13809781f, -0.28735340f, -0.31981885f, -0.01311626f, 0.00781446f, -0.03969434f, -0.04880432f, 
    -0.04801271f, -0.05271684f, 0.01490568f, 0.04481923f, 0.08926506f, 0.23358978f, 0.08110537f, -0.03760230f, 
    -0.07024495f, -0.03436675f, 0.03281328f, -0.01027234f, -0.07123357f, -0.07790079f, 0.08744624f, 0.01895626f, 
    0.22923246f, -0.01125771f, 0.05738115f, 0.09106132f, 0.03350894f, -0.05377791f, 0.00373222f, 0.05003262f, 
    0.16806264f, 0.08157596f, -0.06011468f, -0.05805095f, -0.12057067f, -0.61431664f, -0.24900259f, -0.27874792f, 
    -0.11161509f, -0.08548830f, 0.08448846f, -0.15635416f, 0.03085082f, -0.08506957f, -0.02167192f, 0.02973323f, 
    -0.13785858f, 0.16520534f, -0.12166016f, -0.12618366f, 0.14459865f, 0.00328486f, 0.12059745f, -0.03375786f, 
    -0.04428283f, -0.05540515f, -0.15666640f, -0.03158883f, -0.15326434f, 0.14507324f, 0.22586332f, -0.05728073f, 
    -0.04336040f, 0.10115959f, -0.02565465f, -0.03075395f, -0.03835897f, -0.05472938f, 0.04227908f, 0.06088967f, 
    -0.49492830f, -0.34249344f, 0.08800247f, -0.15505853f, -0.07520868f, 0.03684267f, 0.12320209f, 0.18152282f, 
    -0.04062704f, -0.06015602f, -0.08557010f, -0.02386066f, 0.41079789f, 0.09431490f, 0.26129204f, 0.40317464f, 
    -0.02121408f, -0.05363978f, 0.06547724f, -0.01772176f, -0.00923667f, 0.06617220f, -0.02537432f, -0.01469111f, 
    0.48495823f, 0.19062138f, 0.20797196f, 0.25743151f, 0.08768551f, -0.00371139f, -0.01674866f, 0.08960270f, 
    -0.03331923f, -0.05724750f, -0.06485440f, 0.02243679f, 0.11490232f, 0.12857611f, 0.15587649f, 0.20957963f, 
    -0.02585390f, -0.07662346f, 0.05127422f, 0.00526607f, 0.04447325f, 0.01704351f, 0.01522968f, 0.07084679f, 
    0.01835879f, 0.09823588f, 0.03246689f, 0.09069744f, 0.08279900f, 0.05665338f, -0.04972285f, -0.00802784f, 
    -0.10084692f, 0.05328274f, -0.11152256f, 0.04768783f, 0.01597065f, 0.02627664f, 0.17843679f, 0.04822683f, 
    -0.02874994f, 0.04697912f, 0.03461303f, 0.03120831f, -0.00046151f, -0.09419869f, 0.06911531f, -0.03984453f, 
    -0.29558131f, -0.06803013f, 0.22708750f, -0.02604335f, -0.11126401f, -0.06809308f, -0.02918968f, 0.08978560f, 
    0.04299949f, 0.03596442f, 0.17719355f, -0.04387066f, -0.17046478f, -0.16816315f, 0.10198509f, 0.34210756f, 
    0.09419418f, -0.03326818f, -0.08919713f, 0.11926185f, 0.03089722f, -0.02099355f, 0.12423377f, 0.17875491f, 
    -0.15173836f, -0.07491750f, 0.02502357f, -0.09658032f, 0.02161988f, 0.00521699f, -0.07638210f, -0.20744148f, 
    0.08042846f, 0.05435342f, 0.07890251f, 0.01390471f, 0.09997796f, -0.12090310f, -0.08430352f, -0.22760704f, 
    0.10735143f, 0.13535443f, 0.14201222f, 0.05949465f, 0.00330613f, -0.04572349f, -0.02165631f, -0.07637008f, 
    0.19451720f, 0.10925369f, -0.06658728f, 0.07143861f, 0.00569404f, 0.02660105f, 0.00271222f, 0.04585151f, 
    0.08295524f, 0.10724647f, 0.04736682f, 0.04983188f, -0.21255305f, 0.15656810f, 0.20831138f, -0.02772344f, 
    0.01518552f, -0.01041227f, 0.10418238f, 0.21934226f, 0.09530729f, -0.09209026f, -0.00024627f, -0.25410843f, 
    0.04790118f, -0.17099835f, 0.17018881f, -0.01264950f, 0.04287493f, 0.06308328f, -0.16423844f, 0.13796641f, 
    0.01322743f, -0.03418346f, 0.04717800f, -0.00499431f, 0.15821478f, 0.06786315f, -0.13868517f, -0.05666623f, 
    0.24833113f, 0.01512511f, 0.20782389f, 0.05700711f, -0.11427860f, 0.23158289f, -0.07452291f, -0.03142884f, 
    -0.33422774f, 0.02498787f, 0.12924674f, -0.05290960f, -0.08951288f, -0.04941622f, -0.06532009f, 0.12429413f, 
    -0.04427548f, -0.04870703f, 0.03043427f, -0.07576307f, -0.32741439f, 0.09656053f, 0.18780559f, -0.06992565f, 
    0.01395573f, 0.01874770f, 0.10812257f, 0.15210760f, -0.07036379f, -0.04340582f, -0.07931525f, -0.01906478f, 
    -0.09823571f, -0.06586123f, 0.03640955f, -0.04081016f, -0.15215427f, -0.11074471f, -0.10782372f, -0.04913747f, 
    -0.01467698f, -0.04170375f, -0.02823592f, 0.08676912f, 0.04006695f, 0.01731626f, -0.01529210f, -0.23593122f, 
    -0.16359690f, -0.00156847f, 0.14754173f, 0.00907535f, -0.06488045f, -0.07623348f, 0.07732970f, -0.00490597f, 
    0.21820892f, -0.14720377f, 0.07253943f, -0.12441280f, -0.00912947f, 0.15065199f, 0.12285127f, -0.00854632f, 
    0.00642714f, -0.09559465f, -0.08268382f, -0.05805279f, -0.43071753f, 0.08288316f, 0.15301622f, -0.08357461f, 
    -0.04371769f, -0.07340044f, -0.03438682f, -0.07316049f, 0.11055762f, 0.17238010f, 0.07244610f, 0.06624799f, 
    0.01386457f, -0.07548661f, -0.00976307f, -0.01206111f, -0.01119679f, 0.11454201f, 0.06738877f, 0.19006273f, 
    0.00942161f, -0.04900181f, 0.03278866f, 0.12904307f, -0.01851233f, -0.07807860f, 0.25406003f, 0.10250577f, 
    -0.07984028f, 0.00048241f, -0.02331448f, 0.08320890f, -0.00827660f, 0.10410795f, 0.07831287f, 0.06728923f, 
    -0.24765202f, 0.02560770f, 0.18211193f, 0.20691748f, 0.20288633f, -0.11083357f, 0.20822801f, -0.01725874f, 
    -0.03700241f, 0.00351658f, -0.02209073f, 0.08196671f, -0.12366198f, -0.11111905f, 0.05474290f, -0.17063956f, 
    0.02904141f, -0.01660854f, 0.05398982f, -0.03902490f, -0.12298848f, -0.08503081f, 0.08735700f, 0.01254872f, 
    -0.12015298f, -0.11081344f, 0.02815697f, 0.13854213f, 0.06156560f, -0.03597454f, -0.07140026f, -0.07536146f, 
    0.06737711f, -0.01561184f, 0.00500521f, 0.07359017f, 0.28105271f, 0.02552576f, 0.24889514f, -0.15256336f, 
    0.11163110f, 0.00505319f, -0.06882092f, 0.22989887f, 0.14717083f, 0.09259606f, 0.11751126f, 0.00664497f, 
    -0.11932068f, -0.03802235f, 0.12856150f, 0.03428118f, 0.05602368f, 0.09936078f, 0.06049819f, 0.04534186f, 
    -0.01104781f, 0.01781380f, -0.04038369f, 0.00363335f, -0.04954202f, -0.05558928f, 0.09215511f, 0.21358401f, 
    -0.06883883f, -0.02693545f, -0.04188776f, 0.09350350f, 0.17831847f, 0.03338727f, 0.27535659f, 0.03308200f, 
    0.19067016f, 0.05088662f, 0.04273285f, 0.02395602f, 0.08593153f, 0.04599152f, 0.01736602f, -0.03908579f, 
    0.10395011f, -0.03391118f, -0.07151129f, 0.15426347f, 0.08904320f, 0.01748931f, -0.00902999f, -0.14871320f, 
    -0.03637719f, -0.01371316f, -0.09665465f, 0.18192087f, 0.01639862f, -0.08095390f, 0.06960748f, -0.07850075f, 
    -0.07567594f, -0.12720041f, -0.13241406f, -0.06063873f, -0.01254337f, 0.01144101f, -0.15941706f, 0.26589420f, 
    0.02021873f, 0.02147112f, -0.06577265f, 0.03689812f, -0.12838510f, -0.22161596f, -0.03727887f, 0.30549458f, 
    0.02794983f, 0.14698514f, 0.08154231f, 0.07213653f, 0.05018722f, -0.01935255f, 0.02568784f, -0.11418249f, 
    -0.16975415f, -0.05568052f, -0.02110112f, 0.02849929f, -0.08094293f, 0.05322686f, 0.01680252f, -0.09384644f, 
    0.12982571f, 0.07978708f, 0.10118251f, 0.00730178f, -0.16023143f, 0.01571923f, 0.03524407f, 0.00631080f, 
    -0.06507955f, -0.04694096f, -0.06655931f, 0.00186327f, 0.01988296f, -0.03090704f, -0.04854929f, 0.07488586f, 
    -0.03811304f, -0.07227666f, 0.09866668f, 0.06330409f, -0.09577492f, -0.00567536f, -0.05949679f, -0.04627105f, 
    0.04665596f, -0.01588508f, 0.07426798f, 0.09719820f, 0.10049839f, -0.11997908f, -0.03978689f, -0.02203314f, 
    0.01942856f, 0.05531128f, -0.06796754f, -0.00736470f, -0.15547587f, -0.14055738f, -0.17322983f, -0.17908753f, 
    -0.00332749f, -0.06755695f, -0.10370893f, -0.03383343f, -0.06821629f, -0.10642491f, 0.16325869f, -0.04736296f, 
    0.12299699f, -0.09628564f, 0.12241971f, 0.17440718f, -0.12050169f, 0.07073607f, 0.09545731f, -0.01854160f, 
    0.12221309f, -0.01832266f, 0.03246448f, -0.04168604f, -0.01607495f, 0.23814496f, 0.12913413f, 0.07814658f, 
    0.01509287f, 0.04307992f, 0.01152734f, 0.03461459f, -0.04341928f, -0.01158238f, -0.03058458f, -0.04851481f, 
    -0.03604449f, -0.02172997f, 0.03825172f, 0.01469603f, -0.00144027f, 0.02165763f, -0.00739037f, -0.00883000f, 
    0.02969473f, 0.00003519f, 0.00411766f, 0.02708025f, -0.00567513f, -0.00343992f, 0.01262279f, 0.02342900f, 
    -0.03671454f, 0.00309670f, -0.02195708f, -0.01544867f, -0.01643365f, 0.02355054f, 0.01865564f, -0.03514199f, 
    0.04281221f, -0.00616393f, 0.01104495f, -0.00300499f, -0.02816294f, -0.01435104f, 0.01639527f, 0.02535377f, 
    -0.01232504f, -0.04806703f, -0.04253369f, 0.01323526f, -0.05336638f, -0.02858622f, 0.00856098f, 0.00673936f, 
    0.02585448f, -0.04932090f, -0.00327002f, 0.04066738f, 0.00853490f, -0.00050838f, -0.01680780f, -0.02234970f, 
    0.01285937f, -0.01189642f, -0.04305421f, 0.03399454f, -0.02823839f, -0.03343003f, -0.04611036f, 0.00235124f, 
    -0.05675370f, 0.02226070f, -0.05531228f, -0.03775315f, 0.03014419f, -0.02499264f, -0.01592036f, -0.02860667f, 
    -0.05000240f, -0.02731310f, -0.05532536f, -0.00868443f, -0.00827002f, -0.02456573f, -0.03723734f, -0.00285231f, 
    -0.01017290f, 0.03915759f, -0.01235542f, 0.03057249f, 0.01972242f, -0.02029969f, -0.03613354f, -0.03004465f, 
    -0.01841431f, 0.02452578f, 0.02386299f, -0.01977720f, 0.01752514f, -0.01040482f, -0.04758055f, -0.04564361f, 
    0.01017780f, -0.02919763f, -0.00535746f, 0.00775630f, 0.01700063f, -0.03773742f, -0.00232320f, -0.03073293f, 
    0.03416904f, -0.04965450f, 0.01237330f, 0.02688226f, -0.02337168f, -0.00753176f, 0.02201304f, -0.01802599f, 
    0.04580905f, -0.00023938f, -0.01931698f, -0.02848000f, -0.04131930f, 0.03557654f, -0.02903751f, 0.03780254f, 
    0.00968455f, 0.00310307f, -0.03670162f, 0.01241071f, -0.05272856f, -0.01645275f, -0.02983037f, 0.03752292f, 
    -0.04639303f, -0.01120051f, -0.04528733f, -0.03629851f, 0.04495896f, 0.02350417f, -0.02322337f, -0.02677403f, 
    -0.01614909f, -0.01190802f, -0.03015416f, 0.00587893f, 0.00439876f, -0.02530978f, 0.00461925f, 0.00903340f, 
    -0.03679911f, -0.04919165f, 0.02186943f, 0.02944362f, -0.01216085f, 0.03053982f, 0.01100132f, -0.02634699f, 
    0.01299108f, -0.04901792f, -0.02226927f, 0.03927237f, 0.02988544f, 0.00446709f, -0.03672774f, 0.02089171f, 
    -0.05014356f, 0.02524947f, -0.02361856f, 0.01694752f, -0.01839690f, 0.01662881f, -0.03225538f, -0.00651651f, 
    -0.03576785f, -0.00417504f, 0.01304642f, 0.04146114f, 0.01457536f, 0.01788824f, -0.02076813f, -0.04800259f, 
    -0.00096908f, 0.01977027f, -0.02769548f, 0.03155600f, -0.02762642f, -0.04698557f, 0.01342873f, -0.00318509f, 
    0.00621775f, -0.02293186f, -0.01243802f, -0.04237568f, 0.00694492f, -0.03377087f, -0.01272668f, 0.01700089f, 
    0.02273073f, 0.03466950f, 0.01845919f, 0.00286005f, 0.02287995f, -0.03167840f, 0.03260003f, 0.03384815f, 
    0.04224716f, 0.00768215f, 0.01041235f, -0.04344290f, 0.03862951f, 0.03128703f, 0.04195698f, 0.00333861f, 
    -0.05230387f, 0.03215900f, -0.03592927f, 0.00888703f, -0.03910850f, 0.01932517f, 0.00534843f, -0.05403996f, 
    0.01708140f, 0.04267092f, -0.00026660f, -0.05650669f, -0.02542044f, -0.00727771f, -0.04605972f, -0.02065483f, 
    -0.02084108f, -0.02818855f, -0.00678383f, 0.01301877f, -0.05306141f, 0.03482454f, 0.00790841f, -0.00378286f, 
    -0.00826854f, -0.05165236f, 0.04077822f, 0.04406773f, 0.02766605f, 0.04329005f, 0.02262042f, -0.05153279f, 
    0.02584173f, 0.00093248f, -0.05315563f, -0.05054366f, -0.01478032f, 0.00745408f, -0.01804541f, 0.00865886f, 
    -0.03139758f, -0.05069288f, -0.02658925f, -0.02260940f, -0.03325619f, -0.03078719f, 0.00690837f, -0.03771013f, 
    -0.03200079f, -0.00849655f, 0.00967135f, -0.03033029f, -0.05053873f, 0.03846369f, 0.02382575f, 0.02984565f, 
    0.01143902f, -0.01867650f, 0.04422393f, -0.03095556f, -0.05280633f, -0.03944133f, -0.02612722f, -0.00071755f, 
    -0.01996288f, -0.02320874f, -0.02359422f, -0.05569117f, -0.01761627f, 0.02470669f, 0.01805601f, 0.01599905f, 
    0.02144002f, -0.04468527f, 0.03551063f, 0.00028717f, -0.05058517f, -0.03703652f, -0.03467077f, 0.03039371f, 
    -0.02780674f, 0.03332288f, -0.01264045f, 0.02078796f, -0.01332579f, -0.05658287f, 0.03669630f, 0.00858321f, 
    0.02453897f, -0.02671173f, 0.00343581f, -0.05639291f, 0.02160640f, 0.01927044f, 0.02522457f, -0.02369202f, 
    -0.05576913f, -0.02848249f, 0.03291295f, -0.01541538f, -0.03769507f, -0.05480368f, 0.00167161f, -0.03388872f, 
    -0.03379122f, -0.03639995f, 0.03982835f, -0.04900698f, 0.01796652f, -0.02206824f, -0.04508565f, 0.01351243f, 
    -0.02525055f, 0.00029885f, 0.02949000f, 0.02822540f, -0.00577987f, -0.01592268f, -0.03624419f, -0.02760387f, 
    -0.00821945f, -0.04376561f, -0.00344995f, 0.00622950f, -0.02063378f, -0.01449690f, -0.02175016f, -0.02196600f, 
    0.00338364f, -0.02388539f, 0.04172042f, -0.03926114f, -0.02443626f, 0.00586318f, -0.03143879f, 0.03336554f, 
    -0.03744232f, -0.00725093f, 0.01842989f, 0.00671110f, -0.01313455f, -0.02975720f, 0.02926902f, 0.04274413f, 
    -0.01771941f, 0.00228357f, -0.00583453f, -0.00962375f, 0.00741744f, 0.04129693f, -0.04529741f, 0.01777581f, 
    -0.03958210f, 0.03213171f, -0.00928189f, -0.04753356f, 0.00605190f, -0.01738115f, 0.00920194f, 0.01916412f, 
    -0.05032269f, -0.01417483f, -0.05485799f, -0.01962422f, -0.00342017f, 0.00199700f, -0.00644867f, 0.03511003f, 
    0.03135847f, -0.00184688f, 0.01541141f, -0.03685309f, 0.00880132f, -0.02581111f, 0.03058231f, 0.03757422f, 
    0.03339231f, 0.03105558f, 0.00721953f, -0.04230665f, 0.03308761f, -0.04541449f, 0.02204347f, -0.03119463f, 
    -0.05091312f, -0.01782561f, 0.01763726f, 0.03457931f, 0.00142447f, 0.03846794f, -0.01298358f, 0.02740103f, 
    0.03769242f, -0.04169022f, -0.02963887f, -0.01843903f, -0.00253768f, 0.00404601f, 0.04481732f, -0.04835477f, 
    0.03734264f, 0.00600764f, -0.04538480f, 0.01703556f, 0.00717728f, 0.02751410f, -0.04196294f, 0.00560333f, 
    0.02339893f, 0.02764488f, 0.02193904f, 0.01873069f, 0.03009246f, -0.03156539f, -0.04530579f, 0.02049961f, 
    -0.05340285f, 0.03656319f, -0.01379402f, -0.00925477f, 0.01332133f, -0.02719498f, 0.03932337f, -0.05949230f, 
    0.02728441f, 0.00065469f, 0.03304920f, -0.05427622f, 0.00292802f, -0.01223447f, 0.04295565f, -0.04808042f, 
    0.02837880f, 0.00146218f, 0.03244853f, 0.00922585f, 0.04580434f, -0.04017026f, 0.02036349f, 0.03872472f, 
    0.01453438f, -0.00240147f, 0.01250529f, -0.00989760f, -0.01724983f, -0.02203429f, 0.01210210f, -0.03086682f, 
    -0.04051255f, -0.01516531f, 0.04419980f, -0.02352871f, -0.04700847f, -0.03808219f, -0.03687610f, 0.01010289f, 
    0.04718771f, 0.01548832f, -0.03845445f, -0.03276826f, 0.04116835f, -0.02858392f, -0.04156098f, -0.02976733f, 
    -0.01974684f, -0.04088729f, 0.04211127f, -0.04378026f, -0.03930753f, 0.01446984f, -0.02363193f, 0.03194534f, 
    -0.04660785f, -0.04822005f, -0.03375766f, -0.01369582f, -0.00508089f, -0.04294785f, 0.01489712f, -0.05022776f, 
    -0.06114708f, -0.02823971f, -0.01939746f, -0.01330029f, -0.01676952f, -0.02781686f, -0.04930114f, 0.04219185f, 
    0.01542924f, -0.01259177f, -0.04355151f, -0.04725987f, 0.02314016f, -0.04984338f, -0.03286177f, 0.00016945f, 
    -0.04527292f, -0.05507769f, -0.01843634f, -0.04940084f, 0.02070693f, -0.00779388f, 0.01558697f, -0.05047963f, 
    0.05168023f, 0.04669268f, 0.02145103f, -0.01359147f, -0.00706423f, 0.00718261f, 0.01704672f, 0.00626693f, 
    -0.00858741f, -0.03197104f, -0.02873385f, -0.03603616f, -0.00902003f, 0.02538256f, -0.05476052f, -0.03929985f, 
    0.00028333f, -0.04740212f, -0.03344573f, 0.02228156f, 0.00708960f, -0.00069822f, 0.02729903f, 0.01316397f, 
    -0.04967111f, 0.01850233f, -0.03977296f, -0.03263919f, -0.02109219f, -0.04134112f, 0.00260643f, -0.00514711f, 
    0.01132996f, -0.01905099f, 0.02712243f, -0.00086796f, -0.01623000f, -0.03477399f, -0.05132158f, 0.00310991f, 
    -0.04974681f, 0.02728515f, 0.00237835f, 0.03990707f, -0.04395178f, 0.00831618f, -0.00694777f, -0.02725766f, 
    -0.01581372f, -0.03107203f, 0.02711530f, -0.01736622f, -0.04093585f, 0.02372001f, 0.04201195f, 0.00915026f, 
    -0.03001664f, 0.03773203f, 0.02989776f, 0.03320117f, -0.03764396f, -0.00767640f, -0.01686421f, -0.04951334f, 
    -0.00078607f, 0.04666230f, -0.05524928f, -0.00255834f, 0.01112668f, 0.00346942f, 0.01418980f, -0.01488750f, 
    -0.04174552f, -0.02586754f, 0.03718314f, -0.03455292f, -0.00859168f, -0.00086936f, -0.01829940f, 0.00579603f, 
    -0.02116573f, -0.00953513f, -0.03505924f, -0.03232608f, -0.00799526f, 0.01194862f, -0.04566382f, -0.03775870f, 
    0.03855183f, 0.02517567f, -0.05001394f, -0.01389541f, 0.00945101f, 0.03507626f, -0.02674711f, 0.01303416f, 
    -0.03858541f, -0.01027370f, 0.02397512f, -0.03515915f, -0.00312751f, 0.03994192f, 0.02614977f, 0.01784398f, 
    -0.01331192f, -0.01729867f, 0.02565929f, -0.01177103f, -0.03746186f, -0.00121285f, -0.01268641f, -0.02225722f, 
    0.00836908f, 0.02404231f, 0.01235442f, 0.03230562f, -0.03486890f, -0.05453597f, 0.00593884f, -0.04833461f, 
    -0.01118354f, -0.01514438f, 0.02792566f, -0.01215538f, -0.03059319f, 0.03731604f, -0.00734566f, 0.03482473f, 
    -0.03561178f, -0.01965311f, -0.00047235f, -0.00271246f, -0.03514073f, 0.00312983f, -0.00397060f, -0.02010549f, 
    -0.04287114f, -0.02047659f, -0.02246020f, 0.00737263f, 0.03583902f, 0.02389056f, -0.02011556f, 0.00259263f, 
    0.00497676f, -0.02164201f, -0.05600679f, 0.00287257f, -0.03093893f, 0.01473341f, 0.03736978f, -0.03269588f, 
    -0.02888073f, 0.01991547f, 0.03569471f, -0.00502024f, -0.05198994f, 0.01828125f, -0.03080237f, -0.01265698f, 
    0.02261507f, -0.04982079f, -0.01725712f, 0.02956070f, 0.03057327f, -0.03275240f, 0.00779348f, -0.03010963f, 
    -0.02695177f, -0.00071328f, 0.04352152f, 0.02585368f, 0.01206918f, 0.02510551f, -0.01328735f, 0.01754623f, 
    -0.03648267f, 0.03678957f, -0.04034379f, -0.00870845f, -0.04773832f, -0.01507686f, 0.02493945f, -0.02683704f, 
    -0.03938214f, -0.02950324f, 0.01605701f, -0.01620845f, -0.04385825f, 0.03426858f, -0.01903218f, -0.00760150f, 
    0.01361391f, -0.05089707f, -0.03422207f, 0.03264663f, 0.02809558f, -0.01110397f, 0.01101107f, -0.01162281f, 
    0.01658377f, 0.01336748f, -0.00166366f, 0.04374738f, -0.04359330f, -0.05316411f, -0.04623413f, 0.01083953f, 
    -0.00155868f, -0.01590293f, 0.02465774f, -0.01581299f, -0.02065996f, 0.00668162f, -0.04287657f, -0.01742837f, 
    -0.02329873f, 0.01710398f, -0.02693480f, -0.01062277f, 0.00080034f, 0.01847707f, -0.02099700f, -0.04832491f, 
    -0.00579359f, -0.00468879f, -0.03424190f, -0.04264995f, 0.02713546f, -0.02562164f, 0.01712287f, 0.03373709f, 
    -0.04388328f, -0.04025777f, -0.02032707f, 0.00939653f, 0.03445929f, -0.03581462f, -0.02967552f, -0.03497366f, 
    -0.04199019f, -0.01750925f, 0.03038069f, -0.01661837f, 0.04288528f, -0.02814193f, 0.01237803f, -0.01878964f, 
    -0.04506942f, -0.04960750f, -0.01881475f, -0.02745030f, -0.03255109f, 0.01283524f, -0.04175776f, 0.01665548f, 
    0.25299418f, 0.21080361f, 0.10369854f, -0.04831134f, 0.14217882f, 0.05388701f, 0.03422374f, 0.07347932f, 
    -0.04836828f, -0.07336105f, 0.02407705f, -0.13859756f, -0.15995143f, 0.06480401f, 0.21404535f, -0.23779263f, 
    0.10165373f, 0.06729254f, 0.01563243f, 0.14759704f, 0.06786865f, -0.02064580f, -0.00090624f, 0.07522086f, 
    0.20990886f, 0.16190095f, -0.13053097f, -0.11040690f, 0.07059202f, 0.04914441f, 0.06101451f, -0.05834278f, 
    -0.04210982f, -0.06829612f, 0.01426563f, -0.07827847f, 0.03584966f, -0.14071287f, -0.14484906f, 0.02538743f, 
    0.04029856f, 0.08863498f, -0.01069138f, 0.03215441f, -0.19960627f, -0.04573167f, -0.11118708f, -0.03558799f, 
    0.08792817f, 0.21070245f, 0.05075045f, 0.20022303f, -0.05539547f, -0.01577771f, 0.03645007f, 0.03070779f, 
    -0.07824662f, 0.05958088f, -0.03077656f, -0.03438402f, 0.03843110f, 0.12746216f, 0.27158079f, -0.19126292f, 
    -0.01086980f, 0.14472847f, 0.12594782f, 0.15325055f, -0.11567269f, 0.00305930f, -0.10133939f, -0.19766948f, 
    0.14673521f, 0.19812347f, -0.10268056f, 0.19405994f, 0.02848824f, -0.07977836f, -0.08110305f, -0.05427146f, 
    0.02479013f, -0.02196589f, -0.08830918f, 0.12206693f, 0.04179896f, -0.12267437f, 0.41418687f, -0.02324948f, 
    0.01167733f, 0.08371578f, 0.10363710f, 0.15672520f, -0.04275113f, 0.09077679f, 0.06558231f, 0.14070717f, 
    -0.26495817f, 0.03528168f, -0.13283990f, -0.23165809f, -0.08347079f, 0.05626521f, 0.04237705f, -0.00368232f, 
    0.01891931f, -0.04324079f, 0.04582520f, 0.04850090f, -0.01297805f, 0.22695155f, -0.01293381f, -0.05743866f, 
    0.07693619f, 0.11394488f, 0.04941747f, 0.00833190f, -0.19258653f, -0.17485946f, -0.04351167f, -0.15563883f, 
    -0.06354706f, -0.05779217f, 0.03083070f, 0.01092856f, -0.17165513f, -0.10592992f, -0.08041053f, -0.10793287f, 
    0.04084209f, 0.03009781f, -0.00465800f, 0.11068887f, -0.02813188f, -0.36896908f, -0.07626511f, -0.22107175f, 
    0.00516045f, 0.02948575f, -0.00079410f, 0.03341361f, -0.08256201f, 0.01919676f, -0.11241817f, -0.02218259f, 
    0.15546770f, -0.15402406f, 0.30193219f, 0.02055672f, -0.03784569f, 0.09662776f, -0.04156517f, -0.04873963f, 
    -0.10788052f, -0.02563769f, 0.07004559f, -0.01094284f, -0.26818690f, -0.09265630f, -0.09781606f, -0.12925097f, 
    0.01428204f, 0.04706060f, 0.10366219f, 0.07165232f, -0.02770261f, 0.13940386f, 0.03129549f, -0.03988107f, 
    0.02639186f, 0.00541895f, -0.22418866f, 0.10762747f, 0.06057058f, 0.03522008f, 0.05220465f, 0.02594986f, 
    -0.04746081f, 0.03365035f, 0.04955197f, 0.04776699f, 0.02897361f, -0.21625364f, 0.04420441f, -0.00946389f, 
    0.10114778f, 0.05359264f, 0.10572815f, 0.02611133f, 0.07797220f, 0.11534898f, 0.19945447f, 0.10647381f, 
    0.27273446f, -0.01966219f, 0.16691688f, -0.12093125f, 0.02025604f, 0.11937216f, 0.01900315f, 0.02921263f, 
    -0.02168090f, -0.04677260f, -0.00227248f, 0.00481626f, 0.04917159f, -0.15541914f, 0.18175460f, -0.09092649f, 
    -0.07390483f, -0.08618409f, -0.03479465f, -0.07472117f, 0.06533740f, 0.17479178f, 0.05174132f, -0.04008942f, 
    -0.06753563f, 0.11357298f, 0.07718999f, 0.03225770f, -0.01987447f, -0.12887469f, -0.00892647f, 0.02237911f, 
    0.22906309f, -0.07104270f, 0.00892713f, 0.05505686f, 0.21370213f, -0.18288568f, 0.23988563f, 0.04832670f, 
    -0.04493690f, 0.06595574f, 0.06076093f, 0.05752309f, 0.11551960f, 0.00773960f, 0.02832831f, 0.15586039f, 
    0.22043894f, 0.10353963f, -0.06268203f, -0.10496213f, 0.09201051f, 0.08410869f, 0.02880722f, -0.02821384f, 
    -0.04532405f, -0.06593600f, 0.00894405f, -0.00549119f, -0.12901421f, 0.09245184f, 0.06284379f, 0.04528775f, 
    -0.01601828f, -0.05938784f, -0.00926919f, 0.02096307f, 0.06381127f, -0.13352816f, 0.28297701f, 0.03691049f, 
    0.04165281f, 0.10068934f, -0.01803723f, 0.22201277f, -0.04682909f, -0.05494981f, 0.09557368f, 0.04429430f, 
    0.04329078f, 0.03326466f, -0.00810003f, -0.03591244f, 0.33040914f, 0.12187027f, -0.03828481f, -0.02786874f, 
    0.06019152f, 0.08539603f, -0.07939696f, -0.03844742f, -0.02884933f, -0.04060689f, 0.02599908f, -0.09215615f, 
    -0.01066129f, 0.19497228f, -0.42155513f, 0.25962928f, -0.21383348f, 0.02372569f, 0.00277667f, 0.00577650f, 
    -0.08431803f, -0.00555168f, 0.02152585f, 0.00180182f, 0.09960604f, 0.42541122f, 0.01089910f, -0.04466919f, 
    -0.03897930f, -0.11124012f, 0.03001885f, -0.04634848f, -0.00660535f, 0.06210541f, 0.01053943f, 0.04184141f, 
    0.12041394f, 0.12590922f, -0.14554939f, -0.10863411f, 0.08150081f, 0.08063544f, 0.03380830f, -0.02081140f, 
    0.13682610f, 0.04042768f, 0.05287885f, 0.11328693f, 0.07195559f, 0.06329938f, -0.08491610f, 0.14626890f, 
    -0.05433298f, -0.09655377f, -0.01199460f, -0.04230714f, -0.01372310f, 0.02308488f, -0.01851370f, 0.03755832f, 
    0.04799289f, 0.12411406f, -0.01870402f, 0.19678320f, -0.02651780f, -0.01761535f, 0.00310318f, 0.01492836f, 
    -0.03835499f, -0.03168038f, 0.05938358f, -0.03333087f, 0.14456333f, 0.07205783f, 0.16318928f, 0.10543676f, 
    0.01213093f, -0.03164588f, -0.03576444f, -0.04857251f, -0.12868945f, -0.00025859f, -0.00621029f, -0.11259878f, 
    0.03503178f, -0.01661373f, 0.04432261f, -0.00161015f, -0.02509903f, 0.07022005f, -0.03013167f, 0.02623584f, 
    0.00018097f, -0.04460444f, -0.08459452f, -0.06191565f, -0.14205095f, 0.04652328f, 0.07834464f, 0.03742053f, 
    0.06250786f, 0.09149319f, 0.00504805f, -0.13612854f, -0.11512799f, 0.16096811f, 0.07273208f, 0.07669464f, 
    -0.01427572f, 0.08225399f, 0.25051230f, 0.07740972f, 0.07138660f, 0.00076033f, -0.18828373f, 0.16505009f, 
    -0.05670987f, -0.06865189f, 0.03714746f, -0.12780543f, -0.21162985f, -0.09909875f, 0.10984875f, 0.11962048f, 
    0.13877197f, 0.10473498f, 0.00134672f, -0.07614749f, 0.12621674f, -0.09051082f, -0.02207706f, 0.07243503f, 
    0.14391960f, 0.08034766f, 0.12194407f, -0.08028318f, 0.02156171f, 0.05280473f, 0.02590996f, -0.16624743f, 
    0.07491833f, 0.00418053f, 0.02872640f, -0.04778025f, 0.19580112f, -0.12012190f, -0.20545413f, -0.08696236f, 
    0.10603624f, 0.06060639f, 0.01021180f, 0.06410181f, -0.01892018f, -0.17902225f, -0.19664909f, -0.22379804f, 
    0.04947440f, 0.05599990f, 0.01549446f, -0.00030534f, 0.02053022f, -0.08018459f, 0.04173204f, 0.08220099f, 
    0.04100038f, -0.02241796f, -0.01365995f, -0.02785812f, -0.21790148f, 0.14574230f, 0.13267612f, -0.00752215f, 
    -0.01366146f, 0.00549523f, 0.02528547f, 0.08496404f, -0.05552877f, -0.12352175f, -0.25170729f, -0.25269145f, 
    0.06358145f, -0.01160217f, 0.11623318f, -0.01048271f, -0.04465516f, -0.04272591f, -0.09286810f, 0.02757504f, 
    0.13831876f, -0.06173490f, 0.02962979f, 0.06194976f, -0.00947025f, -0.03641252f, 0.02716737f, 0.06459814f, 
    0.17865975f, 0.06491569f, 0.14319466f, 0.05221746f, -0.01605856f, 0.09683423f, -0.02904013f, 0.06178226f, 
    -0.19101132f, 0.11759175f, -0.13850409f, -0.11745013f, -0.14060442f, 0.02361209f, -0.01049030f, 0.05108953f, 
    0.01279112f, -0.04177418f, -0.07170025f, -0.08807367f, -0.06075262f, 0.17501989f, 0.03377146f, -0.04054295f, 
    0.00869187f, 0.01538431f, 0.09189022f, 0.09849769f, -0.07750302f, -0.12733375f, -0.24763890f, -0.20797612f, 
    -0.01286149f, -0.05663756f, 0.10367694f, 0.10675140f, -0.13704573f, -0.16351011f, -0.01189779f, -0.01059809f, 
    0.08103587f, -0.04895264f, 0.00829363f, 0.14768083f, -0.07944030f, -0.20335709f, 0.01175981f, -0.04762763f, 
    0.00618572f, -0.00114240f, 0.09403126f, 0.00047650f, -0.22256404f, -0.07964707f, -0.05516975f, -0.04603709f, 
    0.15628006f, -0.07225826f, 0.05977805f, 0.03747471f, 0.06778609f, 0.04006156f, -0.00045765f, -0.03282975f, 
    -0.03429881f, -0.05355111f, -0.01796268f, -0.02516676f, -0.28880656f, -0.06076480f, -0.03586205f, -0.18819115f, 
    -0.11495178f, 0.07035112f, 0.07711804f, 0.16747530f, 0.06383032f, 0.18569693f, 0.07371690f, -0.08486070f, 
    -0.00963438f, -0.08773620f, -0.05992826f, 0.00798917f, -0.01784879f, 0.15145487f, 0.13574769f, 0.09582919f, 
    0.01258449f, 0.04041019f, 0.05761439f, 0.11279740f, 0.13249676f, -0.16564663f, 0.10409217f, 0.12665842f, 
    0.00323638f, 0.10353596f, 0.20025188f, 0.01539867f, 0.09968556f, 0.02673209f, 0.07136688f, 0.10143480f, 
    -0.25678709f, 0.20975287f, 0.02469528f, 0.15043631f, 0.04544390f, -0.08005478f, 0.15797117f, 0.04586261f, 
    -0.10069077f, 0.00023641f, -0.00034251f, 0.05973036f, -0.09410995f, 0.01061202f, -0.09566048f, -0.11992768f, 
    -0.00468363f, -0.02791036f, -0.06425321f, -0.05823570f, -0.00252368f, -0.07018068f, 0.01450878f, -0.06692495f, 
    -0.08198360f, -0.04287010f, 0.01864692f, 0.10154298f, -0.10537679f, -0.08888543f, -0.04974800f, -0.05890225f, 
    0.15825421f, 0.00068134f, 0.06509390f, -0.02432419f, 0.06119680f, -0.07354181f, 0.11917499f, -0.01146973f, 
    0.09686840f, 0.10144483f, 0.07756839f, 0.10673175f, 0.14335299f, 0.16758771f, 0.01400329f, -0.04724378f, 
    0.03840528f, 0.08067954f, 0.17168500f, 0.23092541f, 0.03763390f, 0.27429879f, 0.10945185f, 0.12718400f, 
    -0.07216781f, 0.03619984f, 0.04505594f, 0.06711411f, 0.01355700f, 0.11632575f, 0.05874615f, 0.01626458f, 
    -0.12240992f, -0.00857485f, -0.02986181f, 0.07104912f, 0.15671760f, -0.08932997f, 0.32296550f, 0.02376481f, 
    0.19253361f, 0.05945324f, 0.00545439f, 0.03009625f, 0.03099470f, 0.07208858f, -0.06233039f, -0.07081650f, 
    0.12619397f, -0.01696514f, -0.07310720f, 0.12108485f, 0.24321510f, -0.02595949f, -0.02909740f, -0.09618763f, 
    0.02036679f, 0.00991340f, -0.09929763f, -0.00416453f, 0.00224102f, -0.19770733f, -0.11124688f, -0.17661874f, 
    0.19425713f, -0.11635100f, -0.06502990f, -0.07243944f, -0.03485073f, 0.15181279f, -0.10022841f, 0.11331438f, 
    0.00734381f, -0.04399283f, -0.08820866f, 0.00404898f, -0.05858970f, 0.10951534f, 0.19085614f, 0.11210854f, 
    0.08829954f, 0.22844693f, 0.01659157f, -0.07471962f, -0.03091875f, 0.00214234f, -0.03503286f, 0.02747069f, 
    -0.02378833f, 0.15375368f, 0.01137612f, -0.04203874f, 0.00418258f, 0.14336728f, 0.16203041f, -0.03814100f, 
    0.06624793f, 0.00756783f, 0.05225518f, 0.03398056f, 0.04777196f, -0.06431049f, 0.07970569f, 0.08155506f, 
    -0.13793333f, -0.02812221f, -0.06110319f, -0.01588253f, -0.01151326f, 0.00291148f, -0.09889919f, 0.07597440f, 
    0.09290474f, 0.08120862f, -0.04321123f, -0.00794347f, -0.05931090f, -0.05749730f, -0.07776058f, -0.05327361f, 
    -0.03223094f, 0.02179520f, 0.04201305f, 0.04098928f, 0.00020913f, -0.03340779f, -0.02631336f, 0.11932605f, 
    -0.01833838f, -0.06381787f, -0.07089691f, -0.08990970f, -0.14120682f, -0.04527371f, -0.11136334f, -0.11278496f, 
    -0.02963591f, -0.02863773f, -0.04152637f, 0.04955539f, 0.04648427f, -0.01000510f, 0.10407637f, 0.01994907f, 
    -0.03630286f, 0.08036362f, 0.07778927f, 0.21192493f, -0.14046736f, 0.05074083f, 0.03038984f, -0.00841389f, 
    -0.06035104f, -0.00564497f, 0.06717984f, -0.04270014f, 0.01234082f, 0.29974633f, 0.13882640f, 0.09323580f, 
    0.05136352f, -0.16892523f, -0.14678431f, -0.02706295f, -0.09955647f, 0.01808231f, 0.17858849f, -0.15121004f, 
    -0.00328094f, 0.03758643f, 0.04470643f, -0.04916609f, 0.41775593f, -0.03091701f, -0.18678655f, 0.00904311f, 
    0.10458695f, 0.08558507f, 0.06400024f, 0.06041999f, -0.01927825f, 0.17708099f, 0.02450039f, 0.12832744f, 
    -0.19751093f, -0.14797901f, -0.13680625f, 0.12027314f, -0.05989529f, 0.00704019f, -0.02494561f, -0.17125411f, 
    -0.02149281f, -0.04216580f, -0.02791089f, -0.03600964f, -0.05350451f, -0.04715565f, 0.12945847f, 0.12244857f, 
    0.02558431f, 0.04350664f, 0.06416377f, 0.05897582f, -0.02914277f, 0.17611034f, 0.04018020f, -0.04496527f, 
    -0.02754517f, 0.02767963f, 0.07461406f, -0.06790188f, -0.03558008f, -0.00165122f, -0.05436056f, -0.05983528f, 
    -0.13770521f, 0.07621876f, 0.07524824f, 0.12096187f, 0.49609950f, -0.09543073f, -0.06407003f, -0.08301947f, 
    0.00267797f, 0.03532294f, 0.06613508f, 0.02330651f, 0.05755977f, 0.05221206f, 0.10127623f, -0.00553533f, 
    -0.03898187f, 0.07010644f, 0.17156191f, -0.00807774f, -0.05990333f, 0.06714305f, 0.09765806f, 0.12603846f, 
    -0.00197681f, 0.07672638f, 0.01342311f, -0.04488497f, 0.15967220f, -0.01071657f, 0.01943287f, -0.12535787f, 
    -0.04136078f, 0.08898160f, 0.07186416f, 0.04446733f, -0.06507466f, 0.08306365f, 0.07843270f, 0.01720195f, 
    0.05559212f, -0.09031872f, -0.17119223f, -0.21997258f, -0.11784621f, 0.02386579f, 0.00449893f, 0.08990356f, 
    0.05133804f, 0.04349729f, 0.00768781f, 0.00259794f, -0.02784693f, -0.04206314f, -0.14448991f, -0.15573403f, 
    0.03174222f, -0.07158279f, -0.02134677f, 0.07124332f, -0.01640501f, 0.04011191f, 0.05765008f, -0.07284424f, 
    -0.02926824f, -0.02828922f, 0.05093487f, -0.03837876f, -0.04249625f, -0.03555714f, -0.05369430f, -0.02733061f, 
    -0.02813516f, 0.09576088f, 0.01871819f, 0.02011225f, -0.06156759f, -0.14108451f, 0.05934660f, 0.09355294f, 
    0.00824829f, 0.04478852f, -0.07688713f, 0.01019829f, 0.02002823f, -0.07196362f, 0.05706552f, 0.01567248f, 
    -0.14026135f, 0.18146914f, 0.16387953f, 0.03160905f, -0.15404305f, 0.00706027f, -0.03942325f, 0.05925078f, 
    -0.08544906f, 0.04907412f, -0.04170045f, 0.05676576f, 0.10503357f, -0.13644873f, 0.07404258f, 0.25724912f, 
    -0.01804508f, 0.01194628f, 0.09853541f, 0.01701992f, 0.02871741f, 0.02983860f, 0.15944529f, 0.02665625f, 
    -0.12962511f, -0.03755642f, 0.17013176f, 0.02975565f, 0.01740393f, -0.05620190f, 0.05369085f, 0.07293612f, 
    -0.07690617f, 0.06527195f, 0.02999695f, 0.08696003f, -0.03626169f, 0.05336318f, 0.24996336f, 0.19300424f, 
    -0.07916786f, -0.11165438f, 0.02730239f, 0.02853287f, 0.05279417f, 0.01857542f, 0.00351497f, 0.01635491f, 
    0.23281494f, -0.01831045f, 0.14433628f, 0.28801993f, 0.16567676f, 0.10253753f, 0.03006703f, -0.08865774f, 
    0.03132599f, -0.03329788f, -0.03393325f, 0.00310909f, -0.15406986f, 0.08394007f, 0.15312678f, 0.07865500f, 
    -0.06836537f, -0.05763324f, 0.05141199f, -0.06097180f, -0.11879958f, -0.14706025f, -0.02515566f, 0.02214481f, 
    0.03283999f, 0.13041422f, -0.01433085f, -0.07909811f, -0.00453531f, -0.00019642f, -0.00461445f, 0.07278164f, 
    0.06415673f, 0.08786328f, 0.10645078f, 0.08036106f, 0.17554195f, 0.08550222f, -0.06604118f, 0.07774283f, 
    0.00912041f, 0.05505928f, 0.03108417f, 0.15401857f, -0.04501151f, -0.04229686f, 0.17990854f, -0.00696783f, 
    -0.21790318f, -0.30540633f, -0.16214716f, 0.06698478f, -0.06184206f, -0.14332052f, -0.05967834f, 0.03270847f, 
    0.01603045f, -0.01447426f, -0.05204326f, 0.01972701f, 0.11581389f, -0.00006372f, -0.12355557f, -0.15961051f, 
    0.06758542f, -0.01825913f, 0.04894937f, 0.04327903f, 0.03342265f, 0.14265142f, 0.08471680f, -0.01438384f, 
    -0.20468926f, 0.07069537f, 0.16750665f, 0.03035300f, -0.10639694f, 0.03459005f, 0.00641165f, 0.01897687f, 
    -0.09274113f, -0.01113425f, 0.15803789f, 0.01268504f, -0.25041771f, -0.00023138f, 0.03333265f, 0.22184514f, 
    0.03486298f, 0.08823293f, 0.12885299f, 0.06340591f, 0.06007245f, 0.04731931f, 0.04142036f, -0.05569237f, 
    -0.08667675f, 0.11073727f, 0.18167892f, 0.28205043f, 0.11268121f, 0.04580620f, 0.04852418f, -0.05174699f, 
    0.07630177f, -0.01733510f, 0.10898963f, -0.04113409f, 0.23312011f, 0.05864385f, -0.02502003f, 0.06251784f, 
    -0.08530033f, -0.04111013f, 0.03066270f, -0.11789670f, -0.03550447f, -0.00984832f, 0.03637049f, -0.03388887f, 
    -0.14245340f, -0.20581770f, 0.02945465f, 0.19686368f, 0.08221711f, 0.03975488f, 0.14631860f, 0.11972240f, 
    -0.00810619f, 0.03493112f, 0.01244090f, 0.03211421f, -0.17331651f, 0.12167085f, -0.13362761f, -0.28547624f, 
    -0.00298449f, -0.00089122f, -0.03684449f, 0.04675171f, -0.02369229f, 0.01568481f, -0.04061786f, 0.10131563f, 
    -0.33003122f, 0.09687222f, 0.22866842f, -0.17455773f, -0.01260990f, -0.04643574f, -0.03895039f, -0.13764960f, 
    -0.00517852f, 0.02060181f, 0.01595780f, 0.05997130f, -0.01284862f, 0.05646988f, 0.02601887f, -0.19656016f, 
    -0.04074200f, -0.13043703f, -0.07834553f, 0.01379650f, 0.03467098f, -0.01691245f, -0.07880852f, -0.02237841f, 
    -0.06076178f, 0.08116582f, 0.12789910f, -0.04048489f, -0.00820833f, -0.04521668f, 0.16562109f, 0.06335239f, 
    0.02601849f, 0.03702390f, 0.09384202f, -0.06092792f, 0.20488779f, -0.01670892f, -0.14511262f, -0.18416157f, 
    -0.01222498f, -0.00511731f, 0.04255480f, 0.08547403f, -0.00610884f, 0.07780048f, 0.01921149f, 0.13295598f, 
    -0.15932521f, 0.16424158f, 0.20077640f, 0.12325982f, -0.06226454f, 0.03101116f, -0.03983596f, -0.04735946f, 
    0.02472512f, 0.01220890f, 0.07888250f, 0.01100424f, -0.15372361f, 0.11807080f, 0.04886208f, 0.15172495f, 
    0.10161175f, -0.03546239f, 0.04528825f, -0.12792705f, 0.16828640f, -0.08790677f, 0.16262680f, -0.03382121f, 
    0.15639591f, -0.00523493f, 0.20519704f, 0.09817863f, -0.01651560f, -0.01968144f, -0.02523175f, 0.10100318f, 
    0.13845584f, 0.04148316f, 0.09078097f, -0.01295080f, 0.00134729f, 0.23514165f, -0.01737517f, -0.17230025f, 
    0.05233941f, 0.11722586f, 0.01091963f, 0.07682247f, 0.16542424f, -0.09338926f, 0.01354836f, -0.05045853f, 
    0.06944048f, -0.07982379f, 0.14683074f, -0.17602055f, -0.03991746f, -0.04700862f, -0.01108735f, -0.02478429f, 
    0.07925387f, 0.09671023f, 0.05539092f, -0.04199198f, -0.43909425f, -0.01124138f, -0.03221655f, 0.20394878f, 
    -0.07816188f, -0.07879330f, -0.02744491f, -0.02894372f, 0.03335859f, -0.13145453f, 0.08333985f, -0.01458228f, 
    -0.09036026f, -0.02659495f, 0.19709475f, -0.00265505f, 0.06542947f, 0.17589936f, 0.13267626f, -0.02488717f, 
    0.10536363f, -0.03116446f, 0.13629824f, -0.06803044f, -0.34470215f, 0.31797147f, -0.40859941f, 0.19699089f, 
    0.16373692f, -0.05050766f, 0.11722013f, -0.09048139f, 0.07740627f, -0.03167600f, -0.06484410f, -0.05841384f, 
    0.05139340f, 0.05732976f, 0.07063342f, 0.31893966f, 0.04455170f, -0.04056293f, -0.13110945f, -0.11090168f, 
    -0.03489665f, -0.04502444f, -0.00640265f, -0.09597024f, -0.02007617f, 0.04987057f, 0.03843417f, 0.06634799f, 
    -0.01504335f, 0.08746659f, -0.01491456f, -0.06265824f, -0.01632330f, 0.05297032f, -0.10360076f, -0.02739898f, 
    -0.09832697f, 0.18343526f, 0.08561631f, 0.19211029f, -0.12858020f, 0.00764131f, 0.02530608f, -0.05127265f, 
    0.05887478f, -0.06202607f, -0.08387224f, -0.03815622f, -0.08045441f, 0.22150286f, -0.05905601f, 0.07954326f, 
    -0.09434906f, -0.02197901f, 0.11541618f, 0.10838604f, -0.15824185f, 0.02752283f, 0.10481737f, -0.03442612f, 
    0.03230206f, 0.01429773f, -0.18355028f, -0.06802592f, -0.04074824f, 0.07291311f, 0.08489720f, 0.04889005f, 
    0.03988046f, -0.02846810f, -0.08575813f, 0.04531191f, 0.05725981f, 0.22117275f, -0.13602634f, -0.24755152f, 
    -0.11104549f, -0.14429532f, -0.03748817f, 0.04849503f, 0.09574383f, 0.07484844f, 0.05310450f, 0.02924992f, 
    0.04721780f, -0.08849008f, -0.07767460f, -0.14444433f, 0.09077596f, 0.07527903f, 0.10044909f, 0.04379556f, 
    0.04899698f, -0.08293048f, 0.01091753f, 0.15458691f, 0.10910046f, -0.08626508f, 0.07368011f, 0.12556432f, 
    -0.01988412f, 0.09354009f, -0.03762556f, 0.14233646f, -0.03537258f, -0.09922781f, -0.03466396f, 0.08698945f, 
    -0.50066173f, 0.12228674f, 0.06111072f, 0.16694050f, -0.00715934f, -0.08278550f, 0.21927887f, 0.11154328f, 
    0.03010063f, -0.00903596f, 0.05174556f, 0.02178228f, 0.01244600f, 0.11257009f, -0.26089057f, 0.03692965f, 
    0.09493379f, 0.00698404f, 0.06821856f, 0.15831983f, 0.00023524f, -0.25719973f, -0.01635500f, -0.00539450f, 
    -0.04801570f, -0.32621008f, 0.03252298f, 0.13042274f, 0.03204042f, 0.09265704f, -0.02347639f, -0.04206898f, 
    0.12120807f, -0.06863661f, 0.09294286f, -0.01846916f, -0.31159833f, -0.00451404f, 0.06782021f, -0.20548840f, 
    0.06982014f, -0.06168718f, 0.07168525f, 0.06908624f, 0.00934126f, 0.15971559f, 0.01173978f, -0.08509538f, 
    0.03214515f, 0.09595748f, 0.30158648f, 0.15700068f, -0.11467817f, -0.00034153f, 0.07213062f, -0.00944302f, 
    -0.01935252f, -0.04817589f, 0.06178411f, -0.02866488f, 0.21786182f, -0.03139920f, 0.11872514f, 0.10608766f, 
    -0.02396429f, 0.02535921f, -0.09110057f, -0.07844442f, 0.10545412f, 0.00570426f, -0.09313358f, 0.16204499f, 
    0.43663126f, -0.21262075f, 0.04035563f, -0.15915176f, -0.01918510f, 0.15996107f, -0.15269266f, -0.04382316f, 
    -0.00390707f, 0.05312430f, 0.01377306f, 0.16213891f, -0.01726079f, -0.14028515f, 0.00722040f, -0.22529833f, 
    -0.00918788f, -0.09688764f, -0.12918426f, 0.04146541f, -0.02220359f, -0.06966286f, 0.04669426f, -0.09206898f, 
    0.26748434f, -0.47072104f, 0.32129458f, -0.32212967f, 0.04447848f, -0.01691115f, -0.00410552f, 0.23900314f, 
    0.02279144f, -0.03800131f, -0.05645732f, 0.02060553f, -0.17780697f, -0.37057108f, 0.13890094f, 0.10410146f, 
    0.26781577f, 0.22055598f, 0.05695136f, -0.01553798f, -0.05282782f, -0.01757337f, -0.02769706f, -0.16124731f, 
    0.15303524f, 0.06468151f, 0.16552003f, 0.18150476f, -0.12078242f, 0.05035516f, 0.03141083f, 0.12852322f, 
    0.01869854f, 0.13845471f, -0.01845575f, -0.02809763f, -0.17231067f, -0.21390799f, 0.51433808f, -0.04335838f, 
    -0.13026524f, -0.00288436f, -0.10351290f, -0.03427031f, 0.03677245f, -0.07270631f, -0.05578934f, 0.11840964f, 
    0.03651212f, -0.29029647f, 0.14950252f, -0.09186798f, -0.09813976f, 0.01857860f, -0.03181056f, -0.00106269f, 
    -0.00671081f, 0.04579918f, 0.02954208f, 0.03013185f, 0.13097952f, -0.06389241f, -0.06470960f, 0.10807849f, 
    0.02518127f, 0.01766877f, 0.09753067f, -0.02220127f, 0.03023211f, 0.06177032f, -0.02595972f, -0.07490329f, 
    -0.08166499f, -0.10595500f, -0.00922448f, -0.10788136f, 0.14096612f, -0.13453469f, 0.17044276f, -0.00814815f, 
    -0.03313715f, 0.09866347f, 0.13623598f, 0.12176050f, -0.17126921f, 0.15411873f, 0.14277749f, 0.00823122f, 
    0.02524583f, 0.03837525f, 0.08608189f, -0.06264807f, 0.07164448f, 0.07387832f, 0.00008148f, -0.02615147f, 
    0.00664974f, 0.02949053f, -0.04280319f, 0.04182858f, -0.04829508f, 0.00649695f, -0.01712158f, -0.01918836f, 
    0.03187542f, 0.02222937f, 0.01182730f, 0.00848035f, -0.02348754f, 0.04132441f, -0.00830833f, -0.04022986f, 
    -0.00879130f, -0.03103203f, 0.02811515f, -0.00581263f, 0.01965623f, -0.02794599f, -0.03951381f, -0.00266234f, 
    -0.02768975f, 0.04399278f, 0.03530506f, -0.05222268f, -0.04823880f, -0.01440973f, -0.01339971f, -0.04995314f, 
    -0.04801414f, 0.00585554f, -0.01273926f, -0.04956665f, 0.02067269f, -0.04467218f, -0.00127572f, -0.00475184f, 
    -0.03592056f, -0.04251295f, -0.00300668f, -0.02246042f, 0.02845025f, 0.02434611f, -0.02095540f, -0.01896014f, 
    0.00361618f, 0.01198088f, -0.04409052f, -0.05343652f, 0.00564681f, 0.02405844f, 0.03134744f, -0.05215229f, 
    0.00525640f, 0.03757498f, 0.01725962f, -0.04309450f, -0.04086871f, -0.04000884f, -0.05564346f, 0.02294365f, 
    -0.05126193f, 0.01158227f, 0.00599165f, 0.02445792f, -0.01259586f, 0.03199555f, -0.03288252f, 0.02360480f, 
    0.01412373f, -0.01676769f, -0.02013584f, -0.03619770f, 0.00027910f, -0.00789209f, -0.04365515f, -0.03722418f, 
    0.00511097f, -0.02503191f, -0.05202737f, 0.02567955f, 0.01653626f, -0.00369023f, -0.05216788f, -0.01372415f, 
    -0.02087042f, 0.04384215f, -0.02243158f, -0.00329299f, -0.00629377f, -0.01238067f, -0.03958170f, 0.01354548f, 
    -0.00394749f, -0.03482637f, -0.04477471f, -0.04545061f, 0.04155471f, 0.04099998f, -0.01599121f, 0.03167814f, 
    0.00305091f, 0.01192847f, 0.00545651f, 0.01718068f, -0.05058120f, -0.01632597f, 0.00603729f, -0.04218644f, 
    0.01380515f, -0.02753648f, 0.03628512f, 0.02983253f, -0.00002550f, 0.02853495f, 0.01136906f, -0.04585768f, 
    -0.05212657f, 0.01521117f, 0.01353709f, -0.04463341f, 0.02303316f, -0.03349662f, 0.03550407f, -0.02855784f, 
    0.00205846f, -0.02698358f, 0.02103278f, 0.01632013f, -0.03907838f, 0.00047869f, -0.00078263f, -0.04616210f, 
    0.00651171f, -0.01890042f, 0.01556882f, 0.01677490f, 0.02905801f, -0.03219334f, -0.05504167f, -0.05504630f, 
    0.01725315f, -0.01462093f, -0.02368282f, -0.04323259f, 0.02652984f, -0.01955654f, 0.01306493f, 0.00051860f, 
    0.00896303f, -0.02240887f, -0.00010935f, 0.01733386f, 0.00126126f, -0.03714155f, -0.01748014f, 0.00703023f, 
    -0.04857575f, 0.01846395f, -0.01373823f, 0.03266772f, -0.05355088f, -0.02095729f, -0.01947332f, 0.00016373f, 
    0.00599392f, 0.03469252f, -0.02445191f, 0.00723556f, 0.00110953f, 0.00186336f, -0.04121334f, -0.04343630f, 
    0.02628663f, -0.05154056f, 0.04345791f, -0.00708135f, 0.00715069f, 0.02448666f, -0.04339636f, -0.00912991f, 
    0.04550333f, 0.00815945f, 0.02121160f, -0.02235278f, -0.03671332f, -0.02211897f, 0.04061170f, 0.00989448f, 
    -0.04651939f, -0.01828797f, -0.02155456f, -0.04689532f, -0.05012577f, -0.02145702f, -0.02805003f, -0.00975358f, 
    0.01720335f, 0.00289230f, -0.02977173f, -0.02976937f, -0.05016777f, 0.01354994f, 0.01358036f, 0.01180125f, 
    -0.02190209f, -0.00906022f, 0.00983198f, -0.02428167f, -0.03392331f, -0.00049362f, -0.00857337f, -0.03968616f, 
    -0.03802188f, -0.03956445f, -0.02641805f, -0.00073027f, -0.05073071f, -0.02725149f, 0.02601676f, -0.04842044f, 
    0.03844584f, -0.05631661f, -0.03759151f, 0.01631088f, -0.01811058f, -0.04890642f, -0.03788272f, -0.02995965f, 
    -0.02365713f, 0.03084567f, 0.01776072f, -0.02235426f, -0.00426107f, 0.03810494f, 0.02507723f, 0.01697684f, 
    0.02310640f, -0.03648502f, -0.00123423f, 0.03294365f, -0.05774429f, -0.02333386f, -0.02859385f, -0.03394280f, 
    -0.05090088f, -0.00908930f, -0.05774600f, 0.04047130f, -0.00597769f, -0.05330253f, -0.02337083f, -0.02001852f, 
    0.00029950f, -0.03241419f, -0.01478008f, -0.04838503f, -0.02549242f, -0.00442868f, -0.01580499f, 0.00861015f, 
    -0.03968088f, -0.02351910f, 0.02725698f, -0.05136084f, -0.03728904f, 0.01909157f, -0.03610510f, -0.01660877f, 
    0.00027375f, 0.01639245f, 0.02669074f, -0.05250808f, 0.00521544f, -0.02797625f, -0.00064573f, 0.04390348f, 
    -0.02174927f, 0.01479673f, -0.05272611f, -0.00997034f, -0.02765248f, -0.04007510f, -0.04187205f, -0.00815599f, 
    -0.01618494f, -0.00309040f, -0.04769549f, -0.00383929f, -0.02001598f, -0.05005717f, 0.04305339f, -0.01197783f, 
    -0.03042147f, -0.04552969f, -0.01995338f, 0.00552992f, 0.01310398f, -0.03501618f, -0.01410701f, -0.03621599f, 
    0.00371536f, -0.03111364f, -0.04250328f, 0.01180013f, -0.03203977f, 0.02189840f, 0.01508810f, -0.02442794f, 
    -0.03732159f, -0.04538790f, -0.03395355f, -0.02594027f, -0.03334995f, -0.02811916f, -0.02500187f, -0.01665761f, 
    0.00669472f, -0.01253526f, -0.01123859f, 0.02200833f, 0.00942525f, 0.03000577f, 0.01479657f, 0.04122264f, 
    0.03721360f, -0.02252151f, -0.03119312f, 0.02548567f, -0.04689427f, 0.03998957f, 0.03737202f, -0.00161064f, 
    0.03528791f, 0.01755004f, -0.01724869f, -0.01726321f, -0.04761297f, -0.02821908f, -0.04040037f, 0.03069623f, 
    0.00778714f, -0.02632400f, 0.04014106f, -0.01190663f, -0.04605142f, -0.03688496f, 0.03051940f, -0.03624015f, 
    0.03585457f, 0.03747700f, -0.04138058f, -0.00889998f, -0.02921976f, -0.04126736f, -0.05188347f, 0.00643260f, 
    -0.03523073f, -0.00579185f, 0.00622286f, -0.00237701f, -0.04270065f, 0.02783472f, -0.00767982f, 0.02883461f, 
    -0.03112636f, -0.01912358f, 0.00243178f, 0.00524396f, 0.01316728f, -0.02673229f, 0.01213957f, -0.01978716f, 
    -0.02182556f, -0.00085887f, 0.03615746f, -0.05111533f, 0.03617382f, -0.05620158f, -0.05720241f, -0.02991734f, 
    -0.14645502f, -0.26385161f, -0.06016583f, -0.02755932f, -0.03644185f, -0.02365419f, 0.21233033f, 0.10843944f, 
    0.09795585f, 0.07056185f, 0.07368708f, 0.02229058f, 0.41918021f, -0.08552276f, -0.23725328f, 0.31515068f, 
    0.03693929f, -0.00856184f, -0.04440244f, 0.01298293f, 0.05156399f, 0.21611768f, 0.07055769f, 0.09017519f, 
    -0.36600813f, -0.19938642f, 0.01421269f, 0.08919702f, -0.06633372f, 0.10720541f, 0.08918018f, 0.22195974f, 
    -0.03759777f, 0.02618891f, 0.06897076f, 0.01316617f, -0.29029155f, -0.04000243f, 0.41449124f, -0.07530691f, 
    0.03730581f, -0.02068722f, 0.03532259f, 0.00185246f, 0.06420758f, 0.10904659f, 0.15346932f, 0.05862088f, 
    0.01755790f, 0.02924301f, 0.01109491f, 0.06122467f, 0.00977532f, 0.08297635f, -0.01941998f, -0.04599342f, 
    -0.00550741f, -0.00949821f, 0.03648308f, 0.11926629f, 0.29996225f, -0.05351086f, -0.03628088f, -0.10721932f, 
    -0.01320098f, 0.08480002f, 0.06835790f, 0.02600970f, 0.20538847f, 0.14177482f, 0.22155933f, 0.14972314f, 
    -0.13840738f, -0.05516057f, 0.20142862f, -0.00211078f, 0.21033545f, 0.06580107f, 0.04610274f, 0.09812361f, 
    -0.09260169f, 0.17395122f, -0.04267212f, -0.05698406f, 0.08751976f, 0.08428464f, 0.01970488f, -0.11170260f, 
    -0.00846394f, -0.04596260f, 0.11392480f, 0.12934287f, -0.05523875f, -0.07399593f, 0.04411531f, -0.03676667f, 
    0.15609299f, -0.26230490f, 0.06684895f, 0.13069887f, -0.01646942f, -0.16960734f, -0.13710512f, -0.06928503f, 
    -0.12492628f, 0.11346899f, 0.03801582f, 0.03347941f, -0.09363396f, -0.24936914f, 0.02459640f, 0.04905376f, 
    0.00120839f, -0.14574532f, -0.06463233f, -0.04320676f, 0.13530000f, 0.14076462f, 0.17007317f, 0.24580768f, 
    -0.12442652f, -0.08732443f, -0.04954096f, -0.14707871f, 0.08244717f, 0.04320421f, 0.03998034f, -0.03144680f, 
    -0.06082586f, -0.05673949f, 0.01754403f, -0.09817169f, -0.03523633f, 0.21205363f, -0.03312670f, 0.04011792f, 
    -0.03674604f, 0.00181852f, 0.12674999f, -0.00586027f, 0.13942820f, 0.03012180f, -0.03635038f, 0.08390308f, 
    0.00045593f, 0.18012151f, 0.17004567f, -0.09035543f, 0.00727142f, 0.04860729f, 0.04801667f, 0.21736671f, 
    0.03809766f, 0.04315734f, 0.00403924f, 0.04454717f, 0.06764933f, 0.00884439f, 0.16538236f, 0.18082966f, 
    -0.00048135f, -0.15349385f, -0.15041581f, -0.22402349f, 0.03871331f, -0.07263033f, -0.03156748f, 0.17423756f, 
    -0.01150571f, 0.05698099f, 0.15269586f, -0.03731024f, 0.07346835f, -0.00504582f, -0.01940004f, 0.05153335f, 
    0.06370149f, 0.07430217f, -0.06388204f, -0.09981598f, -0.20488916f, 0.17483844f, 0.16964136f, -0.08185811f, 
    -0.01202932f, -0.03321772f, -0.05495112f, 0.15759580f, -0.00659293f, -0.00962505f, 0.03289737f, -0.08983035f, 
    0.02175693f, -0.11012530f, -0.00821043f, 0.05973991f, 0.09851012f, 0.13302325f, 0.00682065f, -0.06887628f, 
    0.05936085f, -0.01619831f, -0.00279992f, 0.03004342f, 0.00373341f, 0.09347307f, 0.17302057f, -0.11719055f, 
    0.03042578f, -0.03908242f, 0.14151160f, 0.14192377f, 0.01592895f, -0.00044797f, 0.03569822f, 0.08747710f, 
    0.00688380f, 0.04717241f, -0.09620781f, -0.02274158f, 0.16439368f, 0.05434635f, -0.03379082f, -0.01610235f, 
    -0.01098190f, -0.00405663f, -0.00202832f, 0.03462606f, 0.17829680f, 0.13544610f, 0.04345649f, -0.07993726f, 
    0.05307555f, 0.01935995f, 0.09675237f, 0.15567653f, -0.03664213f, -0.03434180f, 0.04931445f, 0.03618507f, 
    -0.26606840f, -0.23506792f, -0.16000490f, 0.00706680f, 0.01584768f, -0.10909537f, -0.06801111f, 0.15338638f, 
    -0.02752385f, 0.02356155f, -0.04920562f, -0.04863561f, 0.15907350f, -0.08164781f, -0.03610476f, 0.03574484f, 
    0.12441295f, -0.01014623f, -0.01640112f, -0.07169911f, -0.03045668f, 0.07477115f, -0.11938766f, 0.00771829f, 
    -0.07574282f, 0.13999614f, 0.23295726f, -0.04557338f, 0.02422665f, 0.00757828f, 0.02392047f, 0.08992678f, 
    0.02879919f, 0.07663874f, -0.09341866f, -0.03781789f, -0.21646068f, 0.17116210f, 0.26195270f, -0.00349405f, 
    -0.08084254f, -0.10124722f, 0.14909257f, 0.20596458f, -0.01942451f, 0.17836274f, 0.19816858f, 0.08892903f, 
    -0.29568315f, 0.02534013f, 0.21276605f, 0.05557122f, 0.03379766f, -0.04483135f, 0.13719012f, 0.16446199f, 
    0.06164746f, 0.03962432f, 0.06163426f, -0.00241441f, 0.03372964f, -0.14863445f, -0.24533181f, 0.13783811f, 
    0.03455233f, 0.09255851f, 0.06151934f, 0.09261591f, 0.01274574f, 0.00992841f, 0.04915889f, -0.01819285f, 
    -0.16010380f, -0.29815602f, -0.05080972f, 0.31149590f, 0.01510651f, -0.03336265f, -0.03663247f, 0.10519465f, 
    -0.00513465f, 0.02090890f, 0.10393097f, -0.02468424f, -0.07474402f, 0.25901267f, -0.11481991f, -0.19038095f, 
    0.06419809f, -0.02393552f, 0.03646220f, -0.02760774f, -0.01062231f, -0.02257242f, 0.02508236f, -0.06808980f, 
    -0.13586120f, -0.00622898f, 0.14718576f, -0.02158423f, -0.02244979f, -0.00550577f, -0.00497347f, 0.07093691f, 
    0.05101456f, -0.06461766f, -0.01342251f, 0.00013331f, 0.03415225f, 0.07000326f, 0.06085488f, -0.14953229f, 
    -0.05788714f, 0.04626499f, -0.02096540f, 0.04299625f, -0.01271855f, -0.04532579f, -0.04607522f, 0.03600917f, 
    -0.01164262f, -0.01473204f, -0.00474509f, -0.02340548f, -0.00809484f, 0.03722613f, 0.04400008f, 0.04828040f, 
    0.10615832f, 0.02144077f, -0.07403573f, 0.01510267f, 0.21020648f, -0.02126057f, -0.10663261f, 0.08755585f, 
    0.08101898f, -0.09497683f, -0.05689975f, -0.02083579f, 0.15489811f, -0.17191231f, 0.00809151f, 0.01806754f, 
    0.16373152f, 0.09160054f, -0.17028311f, 0.07187238f, 0.17035097f, 0.12137658f, -0.08444476f, 0.01098615f, 
    -0.04626944f, 0.01063704f, -0.20379002f, 0.01465007f, -0.02910288f, 0.50821608f, 0.05011150f, -0.07299945f, 
    -0.13540503f, 0.12619980f, 0.03759027f, -0.15533410f, -0.00355134f, 0.00290491f, -0.06378574f, -0.10418395f, 
    0.16383648f, 0.10247990f, -0.07172209f, -0.04908160f, 0.16254497f, 0.00418379f, 0.09015771f, 0.26652074f, 
    0.01005528f, 0.04553997f, -0.08682699f, 0.03656897f, -0.05017832f, 0.10231488f, 0.03930292f, 0.16383986f, 
    0.00714048f, -0.05283672f, -0.00498636f, -0.00813031f, -0.07987549f, -0.04838120f, -0.11005860f, 0.02394865f, 
    -0.06081657f, 0.07226159f, 0.19086014f, -0.18953666f, 0.02247652f, 0.00014763f, 0.10363323f, -0.04393232f, 
    0.13810457f, -0.08601653f, 0.01344314f, -0.01815757f, 0.18988547f, -0.07527294f, -0.01388016f, 0.16452545f, 
    0.01137304f, -0.05338570f, -0.08814919f, -0.09070532f, -0.10908799f, 0.09152970f, -0.12912087f, 0.05974281f, 
    0.18069130f, -0.14700215f, -0.09757056f, 0.02414793f, 0.00624569f, -0.12293926f, 0.14810528f, -0.10703357f, 
    0.11242426f, -0.01265926f, 0.11084884f, 0.08531140f, -0.21460384f, 0.04061566f, 0.02086011f, 0.28420311f, 
    -0.10161145f, -0.07070187f, -0.07028863f, -0.06832477f, 0.16744761f, -0.16130036f, 0.07776524f, 0.10979234f, 
    0.41812021f, -0.07993338f, -0.08771913f, -0.05502439f, -0.03986295f, 0.16763224f, 0.05917193f, -0.08849438f, 
    0.02657024f, 0.03387800f, 0.01033918f, -0.00037142f, 0.42337310f, -0.00153214f, -0.00188237f, 0.17711566f, 
    -0.03556802f, 0.18669918f, -0.05071194f, -0.03986870f, -0.02458565f, 0.00596215f, 0.02421222f, -0.04825528f, 
    0.13815320f, 0.05045080f, 0.16775909f, 0.26500168f, -0.02931467f, 0.01550558f, 0.06961858f, 0.03294053f, 
    -0.04980417f, 0.08040741f, -0.02101795f, 0.03517739f, -0.08691190f, -0.10012895f, -0.03453443f, 0.06356837f, 
    0.10286128f, -0.09497147f, -0.10681066f, 0.07809906f, 0.02004534f, 0.01560571f, -0.09487329f, 0.07392842f, 
    -0.13108906f, 0.01833683f, 0.13766508f, 0.09554671f, 0.00338210f, -0.17623731f, 0.04061493f, 0.04996105f, 
    -0.02639098f, -0.00120471f, 0.08755135f, 0.04461850f, 0.64691788f, 0.07720931f, 0.11425526f, 0.07269483f, 
    -0.03414472f, 0.11642696f, 0.00408671f, 0.27660638f, -0.04083245f, 0.03679613f, -0.00377145f, -0.06430887f, 
    0.00060470f, -0.03939011f, 0.01133958f, 0.09573315f, 0.02163017f, -0.06935405f, 0.17349803f, -0.09188116f, 
    -0.03103200f, 0.00182266f, -0.00493905f, 0.07761752f, 0.02621933f, -0.15408647f, -0.18578449f, 0.12107191f, 
    0.03843001f, 0.11165995f, 0.09647979f, -0.09910616f, 0.14627323f, -0.06983436f, -0.00714793f, 0.15983717f, 
    0.11250172f, 0.40966052f, -0.36784807f, -0.08619048f, -0.09643596f, 0.09326271f, -0.08634409f, 0.22692467f, 
    0.04815702f, -0.01339439f, -0.17133775f, 0.02992774f, 0.01800862f, -0.03409092f, -0.00614159f, 0.27237999f, 
    -0.02855097f, -0.03439866f, -0.03302584f, -0.10430626f, 0.13764042f, 0.01779512f, -0.11780825f, -0.04208271f, 
    0.01074609f, 0.11450842f, -0.01245717f, 0.02973033f, -0.18170789f, 0.01705470f, 0.02788731f, 0.12334622f, 
    0.14068505f, -0.01243731f, 0.14378721f, -0.15253507f, -0.35127196f, 0.04061461f, -0.20771636f, 0.34993121f, 
    0.02792372f, 0.09103458f, 0.20976177f, -0.24437065f, -0.00544297f, 0.09082197f, -0.00197623f, 0.03880569f, 
    0.04670844f, 0.08965041f, -0.10408350f, -0.01381238f, -0.02279365f, 0.10043480f, 0.09838675f, 0.08742701f, 
    -0.05590575f, 0.04215400f, -0.00426313f, 0.06087065f, 0.02993080f, 0.23031212f, 0.02888196f, -0.15228568f, 
    -0.07742789f, -0.04777961f, -0.04914691f, 0.00574484f, -0.00855951f, -0.09074465f, 0.00795263f, -0.06442355f, 
    0.15046644f, -0.19545619f, 0.15982629f, -0.01764345f, -0.00644123f, -0.06804927f, -0.19591442f, 0.03449214f, 
    0.02159086f, -0.07646623f, 0.02796495f, 0.01697996f, 0.21250975f, 0.09311586f, 0.15177353f, 0.26070991f, 
    0.11943966f, 0.05695593f, 0.11567863f, -0.19948749f, 0.09334803f, 0.01321362f, -0.10372757f, -0.01113144f, 
    -0.06355336f, 0.19113038f, -0.28465173f, 0.20604903f, 0.02330275f, 0.09616718f, 0.14817202f, -0.04582763f, 
    0.00369947f, -0.09418785f, 0.01466312f, 0.00043759f, -0.10945457f, 0.26601678f, 0.09129044f, -0.24232166f, 
    0.08192694f, -0.00930519f, -0.14552502f, -0.06623616f, -0.04043785f, -0.05328443f, -0.05933107f, 0.16146781f, 
    0.19386099f, 0.17931487f, 0.07118063f, -0.19334768f, 0.07459182f, 0.05320092f, 0.08216170f, 0.35375765f, 
    -0.02164354f, -0.06785294f, 0.00220554f, 0.10185406f, 0.17978138f, 0.05369156f, 0.13619062f, 0.24264804f, 
    -0.10005521f, -0.09835977f, 0.09250073f, -0.01970102f, -0.01803101f, 0.00828649f, 0.02100023f, -0.00894496f, 
    0.16062766f, 0.07123064f, 0.03307569f, -0.03204237f, 0.05367691f, 0.01409143f, -0.01273784f, -0.02903894f, 
    -0.02740407f, -0.02562176f, -0.03225084f, 0.03580936f, -0.24404986f, -0.02489473f, 0.02487185f, 0.08198159f, 
    -0.08935828f, -0.11341048f, -0.03948410f, -0.02726207f, 0.00664350f, 0.01276545f, 0.11876297f, 0.00903337f, 
    -0.17096767f, 0.11212070f, -0.00950957f, 0.02120971f, 0.07116953f, 0.04349636f, 0.00151381f, 0.06055688f, 
    -0.14802106f, 0.20201913f, -0.06194026f, 0.02285074f, 0.07832609f, 0.00211268f, -0.05690994f, 0.14398314f, 
    -0.11110833f, -0.02222868f, 0.06094624f, 0.00604001f, -0.09802780f, 0.00165550f, 0.05814501f, 0.15545861f, 
    0.08979229f, -0.11214286f, -0.07285618f, -0.00094423f, 0.04749492f, -0.19435263f, 0.10887883f, -0.01223373f, 
    0.01473493f, 0.03657190f, 0.00680370f, 0.05860169f, 0.17404860f, -0.21884255f, -0.10789759f, -0.18558563f, 
    0.11800725f, -0.03232350f, -0.06344016f, 0.02855140f, 0.00291614f, 0.05985717f, -0.00546136f, -0.01220954f, 
    -0.03532355f, 0.07935662f, -0.01732405f, 0.14560089f, -0.07779814f, -0.03765925f, 0.11359988f, -0.02002107f, 
    0.07361962f, 0.02556495f, -0.02712434f, 0.01814760f, -0.17189504f, -0.04990803f, 0.28493372f, 0.12008012f, 
    0.05354655f, 0.07565792f, -0.24534027f, -0.11497626f, -0.06897850f, 0.08719209f, 0.01802194f, 0.02604811f, 
    -0.17079490f, 0.01170408f, -0.09994688f, 0.19747210f, -0.12861811f, 0.06001122f, 0.03543886f, -0.01379806f, 
    -0.09164445f, -0.00803367f, -0.03819352f, 0.03836861f, 0.32430404f, 0.03565555f, 0.08638542f, -0.20273565f, 
    0.01260130f, -0.01891367f, 0.02498825f, -0.04993352f, -0.04049367f, 0.04883393f, 0.02041318f, 0.02874421f, 
    -0.00700149f, 0.28692991f, 0.01839631f, -0.03108544f, -0.02520628f, -0.08905195f, -0.01051361f, -0.14458524f, 
    0.02658675f, 0.09213255f, -0.09779723f, -0.07097365f, 0.26513648f, -0.31731343f, 0.66141164f, -0.10379410f, 
    -0.01385694f, -0.01755701f, -0.06737075f, 0.07606933f, 0.07261622f, -0.16690271f, 0.29004961f, -0.07148100f, 
    0.02930699f, -0.17443384f, -0.27225229f, 0.11084025f, 0.13151079f, 0.05766981f, 0.16217749f, 0.03269186f, 
    0.11087841f, -0.01001552f, -0.09607250f, 0.04047028f, -0.04360545f, 0.04859739f, -0.30342403f, 0.08067544f, 
    0.05626845f, -0.02436074f, 0.04260723f, -0.03948741f, 0.06023315f, -0.03418115f, 0.06623666f, 0.06576159f, 
    0.02498770f, 0.04346772f, -0.04880150f, -0.04268317f, 0.00347932f, 0.02567173f, -0.08676533f, -0.02546479f, 
    -0.04613259f, 0.00414348f, 0.03094174f, -0.04182807f, -0.24504913f, -0.07558235f, 0.20227966f, 0.20545912f, 
    0.02569377f, 0.01442680f, -0.13401324f, -0.04047772f, 0.02748753f, 0.11903939f, -0.19135502f, 0.05713871f, 
    0.10421265f, 0.07260421f, 0.14564222f, 0.01170417f, 0.01085822f, -0.05995838f, -0.07987707f, 0.01357606f, 
    -0.09813855f, -0.04948607f, -0.01925921f, -0.01250699f, -0.13732694f, 0.02444445f, -0.18620780f, 0.30262506f, 
    0.10210744f, 0.14434186f, 0.22992016f, 0.10500867f, 0.02161704f, 0.00991119f, -0.03140443f, -0.04871383f, 
    0.12052117f, -0.01960620f, -0.01799796f, 0.09704249f, -0.01797851f, 0.20855272f, -0.09456290f, -0.11942852f, 
    -0.07385793f, 0.05656770f, -0.07262516f, -0.12721914f, 0.18524103f, -0.02648100f, 0.05844669f, 0.11841831f, 
    0.03837300f, 0.11503147f, 0.05252388f, -0.08928886f, 0.06923038f, 0.03619697f, 0.14264034f, -0.01417977f, 
    0.72315216f, -0.13628981f, 0.15365534f, -0.15305701f, 0.13478987f, 0.04211774f, 0.01516937f, 0.08380601f, 
    0.02083895f, -0.04936362f, 0.06900953f, -0.12648469f, 0.25046927f, 0.18767376f, 0.23613279f, -0.08214851f, 
    -0.04716004f, -0.03532128f, -0.07915410f, 0.07042951f, 0.11386850f, 0.17076395f, -0.07498842f, -0.12095965f, 
    -0.09354889f, 0.01598465f, -0.04203917f, -0.10021523f, 0.13484849f, 0.00244364f, 0.07225945f, 0.02605562f, 
    0.04671504f, -0.04005613f, -0.01357290f, 0.03083016f, -0.11845879f, -0.37436411f, 0.20964839f, 0.02159841f, 
    0.00712041f, 0.15041965f, -0.04879664f, -0.07528306f, 0.06515528f, -0.00766520f, -0.16849793f, 0.16379473f, 
    0.30462766f, 0.09004728f, -0.01802787f, 0.23486595f, 0.09094400f, 0.15169260f, -0.05517592f, 0.12044840f, 
    0.01097412f, 0.01225609f, -0.01107174f, -0.02023643f, -0.08461581f, -0.07154629f, -0.44065395f, -0.03919865f, 
    0.01880790f, -0.00247887f, 0.14614508f, 0.02501471f, 0.06579582f, 0.17478515f, 0.06318764f, 0.05969399f, 
    -0.35659263f, 0.07069966f, -0.21248835f, 0.00721201f, -0.03042471f, -0.14460167f, 0.10108652f, -0.02606391f, 
    -0.07663777f, 0.04361442f, 0.04236127f, 0.07846543f, 0.05816419f, -0.00750702f, 0.07139399f, 0.12726052f, 
    0.05603530f, 0.09614547f, 0.05483158f, -0.03173431f, 0.00823779f, 0.13437413f, -0.01193626f, 0.08944581f, 
    0.06262711f, 0.55585855f, 0.06599397f, 0.32953483f, -0.11768575f, 0.09186891f, -0.03725690f, -0.02418033f, 
    0.02456952f, -0.07098186f, -0.08318255f, 0.06500584f, 0.24725722f, 0.55044919f, 0.26542357f, 0.02541806f, 
    -0.06296381f, -0.09404241f, -0.13914596f, -0.00055838f, -0.02843078f, 0.07939978f, -0.02459059f, -0.06323978f, 
    0.11240997f, 0.11509383f, -0.14256151f, 0.21280907f, 0.03803256f, -0.03230175f, 0.10191009f, 0.00682457f, 
    0.03524353f, 0.00373853f, 0.05521019f, 0.05241647f, 0.16554226f, 0.21857730f, -0.22984059f, -0.11455207f, 
    0.01157806f, 0.02436404f, 0.05463275f, 0.02839497f, -0.03862526f, -0.07184646f, 0.05216991f, 0.06095215f, 
    0.17670225f, 0.07575873f, -0.31586900f, 0.00373416f, -0.02635307f, -0.02095323f, -0.04338947f, 0.05806076f, 
    -0.00088089f, -0.06897025f, -0.02208799f, -0.05092300f, 0.06022267f, 0.22868620f, 0.27025571f, -0.06176021f, 
    -0.04416069f, -0.02336969f, -0.11416032f, 0.05419289f, -0.00200063f, 0.00425074f, 0.06742123f, 0.12836257f, 
    -0.03756510f, -0.04934971f, 0.10730970f, -0.11180400f, 0.01332308f, 0.09657221f, -0.13056526f, 0.16227351f, 
    -0.07843444f, -0.01920545f, -0.10084251f, -0.03684577f, -0.06078948f, -0.08770543f, -0.13710178f, -0.02857066f, 
    -0.01672197f, 0.16689239f, 0.01822861f, -0.08257536f, 0.07035548f, -0.04874288f, 0.00356059f, 0.02998037f, 
    -0.01791404f, -0.01962644f, 0.16740690f, 0.13255137f, 0.14822304f, -0.08472544f, -0.10874523f, 0.21443972f, 
    -0.03610627f, -0.05609547f, -0.15042305f, 0.00105407f, -0.36101425f, -0.07586024f, 0.06890541f, 0.15781486f, 
    -0.08759887f, 0.07172695f, -0.05775040f, -0.06272050f, -0.06204122f, 0.02390537f, -0.15956096f, -0.00973129f, 
    -0.19428998f, -0.01784777f, 0.19812387f, 0.07811826f, 0.13815837f, 0.13846105f, 0.07945553f, 0.11786085f, 
    0.03385832f, 0.06710535f, 0.03919749f, -0.02442075f, 0.25188079f, -0.07407455f, 0.10672590f, 0.15834840f, 
    0.04830006f, 0.06540292f, 0.05675882f, 0.05290705f, -0.07035888f, -0.30612701f, -0.17045881f, -0.13339858f, 
    0.06551311f, 0.05855796f, -0.19067766f, -0.09965009f, -0.06459896f, -0.04115588f, 0.02217897f, -0.01765017f, 
    0.04142930f, -0.03248680f, 0.03967548f, -0.02361251f, 0.10037629f, 0.03598142f, 0.14781234f, -0.02223222f, 
    0.00209787f, -0.05523293f, 0.02975812f, -0.00911525f, -0.04500003f, -0.13417920f, -0.24518809f, -0.15458502f, 
    0.02101566f, -0.03827181f, 0.08215567f, -0.06662571f, 0.00893312f, -0.01449823f, -0.05552524f, -0.11450935f, 
    0.02386243f, -0.07836960f, 0.01857955f, 0.07700896f, 0.06371745f, -0.09410809f, -0.03742393f, -0.07356332f, 
    -0.08293181f, -0.03072566f, 0.09101140f, -0.11785350f, 0.00210626f, 0.17618634f, -0.05960298f, 0.00648501f, 
    -0.26098701f, 0.03918914f, -0.16244082f, -0.18270594f, 0.06476324f, 0.06043072f, 0.00270281f, -0.02799378f, 
    -0.03249977f, -0.00101188f, -0.04491000f, 0.02045780f, -0.14087182f, 0.14093909f, 0.05444951f, -0.02181560f, 
    0.04334550f, -0.11324756f, -0.02205036f, 0.15558808f, -0.04804780f, -0.12156880f, -0.22943644f, -0.11180912f, 
    0.09927953f, -0.03199984f, 0.03001948f, 0.10841079f, 0.00084883f, -0.06647845f, 0.04322560f, -0.06405272f, 
    0.11654665f, -0.10545730f, 0.01588358f, 0.18636884f, 0.01605451f, -0.14366436f, 0.00601225f, -0.08454798f, 
    0.02355069f, -0.06808440f, 0.22354190f, 0.06760482f, -0.06626982f, -0.09927808f, -0.02159178f, -0.01632517f, 
    0.21972308f, -0.12016644f, 0.01915722f, 0.03239074f, 0.04620900f, -0.01999247f, -0.00908206f, 0.00252278f, 
    -0.04327474f, -0.14672874f, 0.06999508f, -0.04635398f, 0.06137054f, 0.03480096f, 0.04274570f, -0.13858277f, 
    -0.02622563f, 0.01981124f, 0.01644122f, 0.14499502f, 0.01997367f, 0.11586431f, 0.02649067f, -0.00755942f, 
    0.10824051f, 0.04681331f, 0.07484102f, 0.09158863f, 0.00946228f, 0.08631209f, 0.01932453f, 0.05563251f, 
    0.04979295f, 0.01450796f, 0.10808130f, 0.09324262f, -0.06118176f, 0.06995322f, 0.16944703f, 0.23566775f, 
    0.02199288f, 0.14610475f, 0.10442507f, 0.00737462f, 0.15172598f, 0.03045105f, 0.13137914f, 0.18943375f, 
    0.10533515f, -0.02809254f, -0.02377586f, 0.19279367f, 0.00865851f, 0.04207599f, 0.09811702f, -0.02647960f, 
    0.01411248f, 0.07229009f, -0.11128942f, 0.09332290f, 0.31716758f, -0.08962341f, -0.01665783f, 0.00028136f, 
    -0.13667704f, 0.08506984f, -0.02735506f, -0.05032117f, 0.00847601f, 0.02421801f, 0.03304598f, -0.08013253f, 
    -0.10411504f, 0.01655841f, -0.02781678f, 0.04601859f, 0.02329686f, -0.00881601f, -0.06206468f, -0.11953744f, 
    -0.03034886f, 0.12562703f, 0.08486450f, -0.01813288f, 0.13700959f, 0.14529470f, -0.00666057f, 0.00453153f, 
    0.07896293f, -0.02979016f, 0.10572808f, 0.04589486f, 0.16338325f, 0.05696720f, -0.14280154f, 0.01378995f, 
    -0.15367582f, -0.01417952f, 0.11784533f, 0.19409586f, 0.09032112f, 0.22643828f, 0.16692089f, 0.08552900f, 
    0.02471560f, 0.03650622f, 0.03449148f, 0.04309381f, -0.28905162f, 0.11418004f, -0.01781798f, -0.10198631f, 
    -0.08757393f, -0.00250581f, -0.12793568f, -0.00237597f, -0.10216918f, 0.04710336f, 0.14686449f, -0.01316442f, 
    0.11336995f, 0.04355802f, -0.13841549f, 0.07024687f, 0.05166652f, 0.01217971f, -0.07308087f, -0.00503181f, 
    0.22755422f, 0.06479090f, -0.13639511f, -0.03433483f, 0.24377801f, 0.11766525f, -0.08270407f, -0.04055114f, 
    -0.06719122f, -0.09306222f, -0.10067987f, -0.04044817f, 0.02738607f, -0.09232720f, -0.10811489f, -0.10918016f, 
    -0.32909393f, 0.43243021f, -0.11388174f, 0.18133704f, 0.06134322f, 0.18863258f, 0.01825786f, 0.06873607f, 
    0.01370403f, -0.07123839f, -0.05387428f, 0.10354684f, -0.21410054f, -0.00953919f, -0.04825867f, 0.15485741f, 
    -0.09029359f, 0.04051235f, 0.09356591f, 0.09071609f, -0.04540376f, -0.00882702f, 0.09285608f, 0.09406449f, 
    -0.14927882f, 0.13931789f, 0.17330183f, 0.14581959f, -0.00964887f, 0.25127482f, 0.17424205f, 0.02886816f, 
    -0.03249375f, -0.04091423f, 0.03099584f, 0.06203753f, 0.16630097f, 0.11521210f, -0.12405589f, 0.20645213f, 
    -0.10968734f, -0.08101065f, -0.05614702f, 0.02162024f, -0.04555021f, -0.03595193f, -0.12498504f, -0.00758862f, 
    0.41703367f, 0.20438208f, -0.07993386f, 0.15136078f, 0.00197192f, -0.15516956f, -0.10851255f, -0.00423784f, 
    -0.01920732f, -0.00666397f, 0.03208487f, -0.09229771f, -0.01509944f, -0.19084935f, -0.13007981f, 0.00961145f, 
    -0.09902240f, -0.13415179f, -0.08428057f, -0.12279173f, -0.03718193f, 0.00366860f, -0.01881998f, -0.06000774f, 
    0.02044434f, -0.01855391f, -0.15350780f, 0.05189529f, 0.00752203f, 0.05613522f, 0.01208940f, 0.02306151f, 
    0.08475344f, 0.10237380f, 0.09423085f, 0.19862421f, 0.01389084f, -0.01558139f, 0.06304706f, -0.05020419f, 
    -0.04120642f, -0.03363102f, 0.03985039f, -0.00452675f, 0.03380252f, 0.14630589f, 0.08674443f, 0.12408862f, 
    0.00958490f, 0.03758327f, 0.05039261f, 0.04660027f, 0.12183301f, 0.11628540f, -0.10382026f, 0.17470329f, 
    -0.02209402f, -0.05298119f, -0.07772847f, -0.00516572f, 0.02861595f, 0.04033057f, 0.07242686f, 0.11979363f, 
    -0.06882199f, 0.07520423f, 0.02358249f, -0.02386118f, 0.05437829f, 0.07622935f, -0.09943169f, 0.04443942f, 
    0.18038073f, 0.13298236f, 0.12946549f, -0.18378961f, 0.20625229f, 0.05265822f, 0.10826199f, 0.19787838f, 
    -0.02662644f, -0.03188512f, 0.00682895f, -0.03981847f, 0.03494729f, -0.04123347f, -0.11911271f, -0.00924784f, 
    -0.09979017f, -0.07642990f, -0.03868358f, -0.08606780f, 0.04181075f, -0.07271724f, 0.02282052f, 0.11532626f, 
    0.09537870f, -0.07152413f, 0.00499273f, -0.03868635f, -0.01279568f, -0.01075474f, 0.02984420f, 0.07413771f, 
    0.16551812f, -0.07389883f, 0.01318930f, -0.00393612f, -0.29393747f, 0.14712501f, -0.05799539f, 0.10094678f, 
    0.01549726f, 0.04152296f, 0.03436043f, -0.06879734f, -0.00366503f, 0.03653439f, -0.06373487f, 0.09759763f, 
    0.21873873f, -0.15643454f, -0.18497561f, -0.01090902f, 0.09750403f, -0.10723073f, -0.04911632f, 0.08693075f, 
    0.05066384f, 0.02544676f, 0.00699414f, 0.00192618f, -0.23160847f, 0.01698248f, -0.14480218f, 0.10041727f, 
    0.00337491f, -0.00077071f, -0.15872130f, -0.02573278f, -0.01621936f, -0.07495009f, -0.02056334f, 0.02669032f, 
    0.34216544f, -0.00502892f, 0.27601483f, 0.06535949f, 0.02313327f, 0.01917517f, 0.10994133f, 0.01242531f, 
    0.00448850f, 0.03866772f, 0.05709170f, 0.02436127f, 0.24411331f, -0.08843055f, 0.24933858f, 0.14101323f, 
    -0.11258393f, -0.01684803f, -0.08118671f, -0.03102484f, 0.07897408f, 0.02280737f, 0.12600106f, 0.15903597f, 
    0.09762973f, -0.02193590f, -0.05210005f, -0.00809244f, 0.04623421f, 0.07226849f, 0.01421721f, 0.06414721f, 
    0.05001637f, 0.01055438f, -0.01574952f, -0.02665261f, 0.11188725f, 0.13452865f, -0.06609173f, -0.10356305f, 
    0.04765686f, -0.01768974f, 0.15193865f, -0.05472967f, 0.26329628f, 0.08718377f, -0.04907510f, 0.05860870f, 
    0.01120944f, -0.07908850f, -0.24129495f, -0.07920642f, 0.09054307f, -0.09274425f, 0.03406680f, 0.01157392f, 
    0.06041005f, 0.05378925f, 0.07171210f, 0.01074874f, 0.11040960f, 0.00770506f, 0.18623769f, -0.04540460f, 
    0.01624925f, 0.05976408f, -0.17205271f, -0.02406065f, 0.06233112f, 0.06315418f, -0.08282885f, 0.01057854f, 
    0.11199190f, 0.14402434f, -0.08704919f, -0.06849992f, -0.03644813f, 0.05622088f, 0.06745131f, -0.04427715f, 
    0.01932592f, -0.02549092f, -0.03484803f, 0.00496330f, -0.00656176f, 0.11425072f, -0.22637480f, -0.21622060f, 
    0.15054485f, 0.03250903f, 0.04391141f, -0.06652898f, -0.06113354f, -0.00691480f, -0.01556198f, -0.00102627f, 
    -0.24549010f, 0.18927997f, -0.37476188f, -0.07820220f, -0.05196170f, 0.08150233f, -0.09171870f, 0.06481159f, 
    0.04166066f, 0.11680076f, 0.00962893f, 0.06093699f, -0.03983107f, -0.12140057f, -0.14461988f, -0.02899190f, 
    0.09328970f, 0.02316262f, -0.00176088f, -0.09249627f, 0.04769778f, 0.09075983f, 0.07296177f, 0.09621231f, 
    0.02292505f, -0.01899770f, -0.06406424f, 0.10639080f, -0.05364466f, -0.04383221f, 0.01327321f, -0.04105969f, 
    -0.09286902f, -0.02692168f, -0.00733483f, 0.03172994f, 0.02023937f, 0.21564659f, -0.09709649f, 0.14903773f, 
    0.00703426f, -0.01048218f, 0.02295949f, -0.13349572f, 0.05291795f, 0.02570500f, -0.07484698f, -0.00604501f, 
    0.12601615f, 0.13436784f, -0.02455641f, -0.15587735f, 0.15700996f, 0.12547868f, 0.10233150f, 0.09393214f, 
    0.00733335f, 0.07908543f, 0.07470405f, 0.05381301f, 0.05450142f, 0.06692904f, 0.08078285f, 0.16897446f, 
    0.01139479f, -0.00871058f, 0.08134002f, 0.04029751f, -0.13430673f, -0.13610646f, -0.05707072f, -0.03862596f, 
    0.08613365f, -0.00964921f, -0.06607049f, -0.19615164f, 0.05994940f, -0.05744692f, -0.04379868f, 0.10409308f, 
    0.01094534f, 0.02298426f, -0.08371682f, 0.04315790f, 0.20555235f, 0.09812490f, 0.02326589f, -0.06353697f, 
    -0.00013135f, 0.06100616f, 0.04319106f, -0.03729561f, 0.03322893f, 0.05777015f, 0.05047660f, 0.16485256f, 
    -0.00008947f, -0.04468406f, -0.13885595f, -0.21210003f, 0.04171173f, -0.05432837f, 0.13706921f, -0.07606306f, 
    0.00212950f, 0.07893633f, -0.07942840f, 0.00529645f, -0.10861577f, -0.15591428f, -0.09235889f, -0.14112514f, 
    0.12050163f, -0.04837199f, -0.07411171f, 0.21577092f, 0.07800571f, -0.08216885f, 0.01836810f, 0.08607288f, 
    0.01962562f, 0.12244133f, 0.14892419f, -0.36025131f, 0.04013153f, -0.01852260f, -0.09742495f, -0.06101295f, 
    -0.02990810f, -0.12145367f, -0.02168048f, -0.04218042f, 0.30323869f, -0.04941134f, -0.01736987f, 0.24585439f, 
    0.09209528f, -0.02155835f, 0.14919445f, 0.01188366f, -0.02489452f, 0.08673330f, 0.13063161f, -0.11369621f, 
    0.13719727f, 0.05944251f, -0.17234392f, 0.09406102f, 0.08956869f, -0.08657882f, 0.00613556f, 0.07574305f, 
    0.06837275f, -0.00976044f, -0.00610651f, -0.04201855f, -0.08283903f, -0.02751806f, -0.05973514f, 0.05100325f, 
    0.06683225f, 0.05066014f, -0.02639892f, 0.00975219f, 0.03247064f, -0.06283307f, 0.06913872f, 0.05780927f, 
    0.04927416f, -0.00242674f, -0.02726825f, -0.00725702f, 0.10030249f, 0.04366931f, -0.16548248f, -0.06766003f, 
    -0.08254512f, 0.08176100f, -0.10161284f, 0.05235360f, -0.08672596f, -0.10444110f, 0.09641694f, 0.23074819f, 
    -0.01090787f, -0.05570666f, 0.05999913f, -0.02881130f, 0.02393352f, -0.08369792f, -0.03693538f, -0.10411907f, 
    0.08877017f, 0.15612400f, 0.26488057f, 0.34728250f, 0.14146692f, 0.08338813f, -0.08301948f, 0.03989411f, 
    0.08815299f, 0.01766736f, -0.10417913f, 0.00631439f, 0.01322760f, 0.17669767f, 0.20698324f, 0.20864446f, 
    -0.13227564f, -0.02999276f, -0.03965654f, -0.07212608f, 0.09836350f, 0.00321998f, -0.11553093f, 0.06932568f, 
    0.01662416f, 0.24515475f, 0.46364391f, 0.18800738f, 0.02611197f, 0.08127398f, 0.00768889f, 0.28533188f, 
    0.00431354f, 0.01920773f, -0.11054905f, -0.04859436f, 0.07393798f, 0.14735028f, 0.11140774f, -0.02541212f, 
    -0.07654486f, -0.07186759f, -0.13931921f, -0.08959268f, 0.00708629f, -0.08340456f, -0.08150949f, 0.07148630f, 
    -0.13668077f, -0.32411373f, -0.17598909f, -0.24718238f, -0.00543313f, 0.00724322f, -0.02882296f, 0.06018312f, 
    0.14706250f, -0.04165353f, -0.03973658f, -0.05791067f, -0.08902658f, 0.02053743f, -0.05941992f, 0.09728538f, 
    0.03276118f, -0.07983361f, -0.11362778f, -0.04802766f, -0.11702646f, 0.03658938f, 0.05909204f, 0.10846978f, 
    0.06561644f, -0.09589859f, -0.04317326f, -0.05525853f, 0.07639250f, -0.01180166f, -0.01608205f, 0.08742623f, 
    -0.02288324f, -0.02506357f, -0.02473925f, 0.02019688f, -0.36951566f, -0.09789521f, -0.11798496f, 0.20589258f, 
    0.02229117f, -0.14907071f, -0.19874579f, -0.14526989f, 0.12938026f, -0.16885093f, 0.09125672f, -0.02789096f, 
    0.27882972f, 0.14688860f, 0.28679082f, 0.26910317f, 0.06482256f, 0.03481398f, 0.07429647f, -0.04927933f, 
    -0.05793812f, 0.01509024f, 0.06771898f, 0.00789320f, 0.05462084f, 0.08637205f, 0.19870961f, 0.17928582f, 
    0.01367965f, 0.00785934f, -0.01213822f, -0.15313363f, 0.01840339f, -0.07150587f, 0.00347084f, 0.03442901f, 
    0.08680642f, -0.04539598f, -0.26878971f, 0.06591714f, 0.17186734f, 0.08684921f, 0.06274301f, 0.05346679f, 
    0.12883069f, 0.01218977f, -0.02732650f, 0.06014682f, 0.07236223f, 0.24490565f, -0.02101311f, 0.24467774f, 
    0.04627824f, 0.04889790f, -0.03001123f, -0.03510562f, 0.07762543f, 0.14673676f, 0.08788448f, 0.02842600f, 
    0.00963817f, -0.11688707f, -0.36236131f, -0.06583429f, 0.08685033f, -0.10334461f, -0.01692156f, -0.03036894f, 
    0.02366268f, 0.00087753f, -0.01168847f, -0.00509678f, 0.33408397f, 0.23960300f, 0.09467717f, 0.16381261f, 
    0.09590124f, 0.04292465f, -0.03494896f, 0.12003120f, 0.00155932f, 0.03461091f, 0.00510754f, 0.03019111f, 
    0.30191839f, 0.10464185f, 0.01334574f, -0.01591123f, 0.04065730f, -0.00006887f, 0.04014088f, 0.11978835f, 
    0.00502246f, -0.05973613f, -0.04686926f, -0.09927961f, 0.14168058f, 0.32284677f, -0.05758264f, 0.15352064f, 
    0.04462514f, 0.06651620f, 0.01883450f, -0.00510314f, -0.10148256f, -0.07107284f, -0.03926063f, 0.05989383f, 
    0.19763495f, 0.04183216f, -0.11508104f, -0.02703685f, 0.16360271f, 0.00519339f, 0.16000551f, 0.21118429f, 
    0.02894782f, -0.01598329f, -0.06699964f, -0.10174751f, 0.21739376f, -0.01618365f, -0.26630861f, 0.04339852f, 
    -0.07347134f, -0.03990830f, 0.02125333f, 0.10318346f, 0.10968146f, 0.09641114f, -0.00333130f, 0.00846295f, 
    -0.12498370f, -0.15599570f, -0.12272119f, -0.10812459f, -0.00599624f, 0.09727186f, 0.07551951f, 0.01029735f, 
    -0.05160386f, 0.00940504f, -0.04611295f, 0.02426806f, -0.13747129f, 0.13621104f, -0.12778355f, 0.23251241f, 
    0.04350707f, -0.03587586f, 0.03926047f, -0.10657802f, 0.03517269f, 0.09728457f, -0.05930259f, 0.08019009f, 
    0.22155473f, 0.40769431f, 0.37504569f, 0.31329021f, 0.16886464f, 0.16499069f, 0.02802846f, 0.07341406f, 
    0.05235914f, -0.03762734f, -0.04798597f, 0.00420169f, -0.24927381f, -0.12682782f, -0.10119269f, -0.12737113f, 
    0.04961222f, -0.08389693f, -0.05438271f, -0.02217798f, 0.02001750f, 0.09253924f, -0.09835482f, 0.10139862f, 
    -0.05805238f, -0.36855799f, -0.23496088f, -0.22409986f, 0.17788489f, -0.08636388f, -0.04835056f, -0.03263115f, 
    -0.00331835f, 0.04340337f, -0.08111932f, -0.05349606f, 0.40780595f, 0.24070421f, 0.16869591f, 0.15179761f, 
    0.04084281f, 0.02385596f, 0.02812486f, -0.03633601f, 0.00001046f, 0.02438297f, -0.05831457f, 0.09685129f, 
    0.13222009f, 0.38767302f, 0.22383380f, -0.09505960f, 0.06531258f, 0.05626405f, 0.02195211f, 0.10398033f, 
    -0.03997920f, 0.00289547f, -0.01586719f, 0.03980565f, -0.09554009f, -0.12565845f, 0.22716205f, 0.03265455f, 
    0.02270130f, -0.06860084f, -0.05651858f, 0.10154765f, 0.02477674f, -0.06925438f, 0.03054553f, 0.03661153f, 
    0.36207342f, 0.48434597f, 0.39305288f, 0.16181681f, -0.04119891f, 0.06038781f, 0.05404554f, 0.10507729f, 
    -0.13744071f, -0.08198987f, -0.07216296f, -0.06722987f, -0.12543869f, 0.06864444f, 0.00025462f, -0.10588155f, 
    0.04857003f, -0.03767957f, 0.07609837f, 0.00813921f, -0.01283311f, -0.08567142f, 0.07756573f, -0.11543606f, 
    0.14336133f, -0.18603587f, -0.37127274f, -0.26132086f, -0.04828012f, -0.02562875f, 0.01501401f, 0.02897887f, 
    0.04938681f, -0.06009312f, -0.06493016f, -0.05542126f, -0.46566927f, -0.39857858f, -0.26044628f, -0.08902870f, 
    0.04720318f, -0.05479927f, -0.01403572f, -0.09198989f, 0.09220171f, -0.00273026f, 0.09216450f, 0.13703135f, 
    -0.15121345f, -0.23110135f, -0.32477048f, -0.19315763f, 0.10395154f, 0.04981065f, 0.02635779f, 0.05802591f, 
    0.19717433f, 0.06346038f, -0.01262949f, 0.15616508f, -0.04571644f, -0.03665170f, 0.19073974f, 0.23313586f, 
    -0.10663845f, 0.03991447f, -0.01099021f, 0.03197800f, 0.17282914f, -0.09208009f, 0.03891184f, 0.02536033f, 
    0.04787932f, -0.06017024f, -0.09281439f, 0.04430287f, 0.06769519f, -0.09691998f, 0.12767190f, 0.03088977f, 
    0.04200589f, 0.03972318f, -0.00873572f, -0.03620160f, 0.17251748f, 0.05438427f, 0.01509989f, -0.13775258f, 
    0.14806852f, 0.00693238f, 0.02247335f, 0.05140611f, 0.01081549f, 0.10252295f, 0.05569645f, 0.01689503f, 
    -0.21158043f, -0.07598831f, -0.01507615f, 0.18899560f, -0.04243711f, -0.03020171f, 0.00658687f, 0.02573000f, 
    0.03634710f, 0.02267841f, -0.03178399f, 0.11314208f, -0.10136880f, -0.06896173f, 0.26927000f, 0.16378072f, 
    0.03694464f, 0.07347110f, 0.05300974f, 0.08193258f, -0.06982003f, 0.01572939f, -0.04848067f, -0.14270106f, 
    -0.16358413f, 0.15710156f, 0.10024183f, 0.10143530f, -0.11458199f, 0.01561660f, -0.02104055f, -0.11851364f, 
    -0.04821876f, 0.07395657f, -0.02173502f, 0.13425940f, 0.53552663f, -0.05065425f, 0.15996033f, -0.18822208f, 
    0.04947663f, -0.03259838f, 0.02126849f, -0.01088760f, -0.06993529f, -0.05079531f, -0.09879814f, -0.10327065f, 
    -0.01328084f, 0.26573613f, 0.26152608f, 0.02896095f, -0.12779821f, -0.01693717f, 0.01683963f, -0.14731821f, 
    0.03624390f, 0.08458897f, -0.00568092f, -0.05576029f, 0.19710290f, -0.03049405f, 0.31694350f, -0.06861968f, 
    -0.06048742f, -0.00909586f, 0.15494849f, 0.07507163f, 0.01491145f, 0.06365939f, 0.21004015f, -0.00652793f, 
    -0.05497665f, -0.15260009f, -0.33504820f, -0.08235594f, 0.06279078f, -0.00262574f, 0.05654648f, -0.02374641f, 
    0.01676789f, 0.06865394f, 0.04030012f, -0.07378232f, -0.04068440f, 0.00117655f, -0.23071362f, -0.06521867f, 
    0.17630626f, -0.02285132f, 0.07032520f, 0.02666338f, -0.04689376f, -0.09237031f, -0.07857777f, -0.10931157f, 
    -0.04394105f, -0.00213454f, 0.09693003f, 0.06249193f, -0.08659048f, 0.02958528f, -0.07001009f, -0.07540981f, 
    -0.06782243f, -0.03054618f, 0.03213922f, 0.07272778f, -0.17601082f, -0.16602039f, 0.03845919f, 0.18480109f, 
    0.05042953f, 0.03398080f, 0.00838193f, 0.06832314f, -0.15300028f, -0.02756598f, -0.08680554f, 0.02729765f, 
    -0.00276754f, 0.14502819f, 0.37483680f, 0.13391250f, -0.16915263f, 0.05067404f, -0.12205128f, 0.06846696f, 
    -0.09207886f, -0.04161738f, 0.01237214f, 0.02960934f, -0.04315672f, -0.24375576f, -0.24103597f, 0.01796082f, 
    0.05966335f, 0.02660941f, 0.18278012f, 0.11679733f, -0.01562534f, 0.11235569f, 0.06115342f, 0.00966908f, 
    0.06956445f, -0.06101130f, 0.16645730f, 0.17985694f, 0.01808297f, -0.06310257f, 0.04689217f, 0.12409273f, 
    -0.04552137f, 0.06959255f, 0.03136839f, 0.06279749f, -0.07142062f, -0.08726191f, 0.14463277f, 0.24996522f, 
    -0.02023213f, 0.00406268f, 0.07485546f, 0.15360360f, 0.14787155f, 0.02743976f, 0.18024313f, 0.04016797f, 
    0.51907933f, -0.09911036f, 0.11107129f, 0.07830168f, 0.05186330f, 0.04946725f, 0.04256913f, 0.01831883f, 
    -0.03346705f, -0.11067015f, -0.05263867f, -0.03883285f, 0.20372143f, 0.11000407f, 0.27295408f, 0.12056249f, 
    -0.18117562f, -0.07224430f, 0.00175029f, -0.01595417f, 0.02154576f, 0.06638495f, -0.11561173f, -0.12632442f, 
    -0.09569310f, 0.25922918f, -0.04749534f, -0.14296052f, 0.06906542f, -0.03425625f, -0.00504047f, 0.06442709f, 
    0.11167566f, 0.02894207f, 0.12682702f, 0.01248955f, -0.07675698f, -0.13426377f, 0.07404924f, 0.03583751f, 
    -0.00061856f, 0.12727547f, -0.00276567f, 0.05154094f, -0.02614892f, -0.03641086f, -0.00175369f, 0.12818609f, 
    -0.01662312f, -0.07969581f, -0.07929506f, 0.11415850f, 0.04595764f, -0.05873260f, -0.03855598f, 0.09259863f, 
    -0.11134148f, 0.02700435f, -0.01893746f, -0.01397024f, -0.09704553f, 0.02854292f, -0.26501024f, -0.27750012f, 
    -0.03871221f, -0.06630838f, -0.01507085f, -0.09060408f, 0.04951519f, 0.05236079f, 0.13823496f, 0.02814184f, 
    -0.29142925f, 0.05100519f, 0.06068449f, 0.18161060f, -0.08890980f, 0.01611027f, 0.09063193f, -0.00176424f, 
    0.08655121f, -0.03974604f, 0.05244556f, -0.02527079f, -0.03071311f, -0.11703391f, -0.03621449f, 0.18966137f, 
    0.06197953f, 0.04791105f, 0.01827932f, 0.00988212f, 0.00437157f, -0.01611939f, -0.00235996f, -0.15194586f, 
    -0.15536439f, 0.37876171f, -0.08689237f, 0.27547312f, -0.09995965f, 0.06597624f, -0.03473397f, 0.04114446f, 
    -0.01799922f, -0.00639623f, 0.05445438f, 0.01136405f, 0.15179420f, 0.35397652f, -0.03506692f, -0.01943582f, 
    -0.17391396f, -0.09331048f, -0.06550133f, -0.19553331f, -0.05541531f, 0.08060965f, 0.01585377f, -0.01641162f, 
    0.07422003f, -0.04379759f, -0.12504393f, 0.27964056f, 0.00882515f, 0.08206282f, 0.16990590f, 0.10393552f, 
    -0.01325729f, 0.08680702f, 0.18924582f, 0.10718186f, -0.04037658f, 0.34304464f, -0.25670823f, -0.28456348f, 
    -0.08818905f, -0.02395150f, -0.07462660f, -0.01244020f, -0.01534782f, -0.06512233f, -0.10220613f, 0.08946836f, 
    0.03002662f, 0.21153320f, 0.12221107f, -0.02406985f, -0.11201499f, -0.04745077f, -0.01775888f, -0.03160103f, 
    -0.11309974f, -0.00645462f, -0.04004058f, 0.11490656f, 0.01499258f, 0.18288657f, 0.07901847f, -0.19718261f, 
    -0.13191868f, -0.08891513f, -0.12960044f, -0.06458669f, -0.03607563f, -0.01245210f, 0.00456265f, 0.01080958f, 
    -0.05763222f, -0.02378266f, 0.06466392f, -0.08617609f, -0.03311577f, 0.05226975f, 0.03890128f, 0.09742389f, 
    0.04270410f, -0.01925872f, 0.01051122f, -0.04046904f, 0.20927607f, -0.03190186f, -0.18196759f, -0.16244866f, 
    -0.00473581f, 0.06256344f, -0.00310086f, 0.04578017f, -0.06227724f, 0.13027653f, 0.05603592f, 0.14082429f, 
    0.01893378f, -0.02746492f, -0.02289703f, -0.01817075f, 0.01390147f, -0.03291068f, -0.05748321f, -0.04158236f, 
    0.01558333f, -0.03588321f, -0.05041748f, 0.02111955f, -0.01671264f, -0.00233769f, 0.01081567f, -0.05581483f, 
    0.00858926f, -0.03884826f, 0.03166645f, -0.05254732f, 0.03527199f, 0.03810595f, 0.01682758f, 0.00954024f, 
    -0.00879807f, -0.00869270f, 0.00919498f, 0.04429281f, -0.01451573f, -0.00744765f, 0.04073355f, 0.03976186f, 
    -0.05232960f, -0.01299120f, -0.02696434f, 0.03375822f, 0.00658974f, -0.03781474f, -0.05148373f, 0.02315882f, 
    0.04021382f, 0.03593698f, 0.02518439f, -0.04182994f, 0.04071924f, -0.01358573f, -0.05847563f, -0.01536634f, 
    -0.04901947f, -0.04777562f, 0.01405041f, 0.03585408f, -0.01371176f, 0.03663445f, 0.01263862f, -0.02458717f, 
    -0.04708236f, 0.03135595f, 0.00304619f, -0.02168564f, -0.02519130f, -0.03118974f, -0.02730025f, -0.02236240f, 
    0.01093872f, 0.03503729f, 0.03984284f, -0.03614068f, 0.02296303f, -0.00566940f, -0.01322404f, -0.02965624f, 
    -0.04424298f, -0.04427828f, 0.02252484f, -0.03726866f, 0.01264543f, -0.01588618f, -0.05377552f, -0.00920163f, 
    -0.02494674f, -0.01384763f, -0.00774615f, 0.03939665f, -0.04708558f, -0.05001158f, 0.02766424f, -0.02118352f, 
    0.04157577f, 0.01953704f, -0.03965473f, 0.03855449f, 0.03051894f, 0.01108147f, -0.01801844f, 0.01975439f, 
    0.03566243f, -0.04942818f, -0.03858195f, 0.04082353f, -0.05265369f, 0.00031589f, 0.02118621f, -0.05158623f, 
    0.01481129f, -0.01975850f, 0.04139163f, -0.05326563f, 0.01427563f, -0.03566568f, 0.01718049f, -0.02598122f, 
    0.03898523f, -0.04112914f, -0.04310685f, -0.00825209f, -0.04699176f, 0.01072491f, -0.03622288f, 0.01897503f, 
    0.01354705f, 0.04067328f, -0.04247549f, -0.01287661f, -0.03979109f, -0.02399465f, -0.00172362f, -0.01452180f, 
    -0.01272576f, -0.01457251f, -0.05729257f, -0.03759013f, -0.05601693f, -0.05685377f, -0.00575095f, -0.04213710f, 
    0.02749242f, 0.03852100f, -0.00221245f, 0.02050614f, -0.04776985f, 0.04336730f, -0.05372791f, -0.00947628f, 
    0.02885137f, -0.03479758f, -0.02962814f, 0.03201028f, -0.00751183f, 0.01458542f, -0.01628641f, -0.01805534f, 
    -0.02100070f, -0.04133394f, -0.02662141f, -0.03030787f, -0.01206772f, 0.00410987f, -0.01367409f, -0.02277797f, 
    0.00533208f, -0.04874611f, 0.03212988f, 0.01563051f, 0.03368406f, 0.01483859f, -0.02356393f, -0.05060213f, 
    -0.00384622f, 0.01545833f, -0.05494140f, -0.05659442f, 0.00325152f, 0.03287965f, 0.00307190f, 0.01338044f, 
    -0.05233171f, -0.05395331f, -0.00286176f, -0.01537814f, 0.02135776f, 0.03388121f, 0.02383424f, -0.03979483f, 
    0.04469165f, -0.04045548f, 0.01187192f, 0.02681227f, 0.04153148f, -0.03529243f, -0.03580768f, 0.03950475f, 
    0.03072227f, -0.02741675f, 0.01571022f, 0.01673196f, 0.01492552f, 0.00512624f, -0.02229785f, 0.01162336f, 
    -0.02551325f, -0.04519851f, 0.01908307f, -0.02333333f, 0.00508982f, 0.01103760f, 0.00623693f, -0.01821593f, 
    -0.00731479f, 0.03877475f, 0.00478510f, 0.03712651f, -0.05530524f, 0.03126132f, 0.02575673f, 0.03658258f, 
    0.04095973f, -0.05121758f, 0.00234847f, 0.04121194f, -0.03681494f, -0.03063718f, -0.00251563f, -0.03652627f, 
    -0.00334828f, -0.04808343f, -0.03729520f, 0.03962530f, 0.02462526f, -0.02454718f, -0.02858816f, -0.01665714f, 
    -0.05216867f, -0.03571983f, -0.04393167f, 0.02205737f, -0.01642482f, 0.03041067f, 0.00772596f, -0.01534247f, 
    -0.00075563f, -0.00535054f, -0.05152419f, -0.01545658f, -0.01787844f, -0.05081128f, -0.01955302f, 0.00179396f, 
    -0.01622237f, 0.03752283f, -0.01509100f, -0.03145533f, -0.02894347f, -0.02271317f, 0.03538684f, 0.02477320f, 
    -0.02749691f, -0.04224345f, 0.03569783f, 0.04300550f, -0.05062104f, -0.05430402f, -0.05498812f, -0.00732247f, 
    -0.01129709f, 0.00344330f, -0.02773785f, -0.02385554f, 0.02181448f, 0.04834919f, 0.02274077f, 0.04134253f, 
    -0.00419911f, 0.00029292f, 0.01097932f, 0.01789110f, -0.05413936f, 0.01739304f, -0.00836238f, -0.00881225f, 
    0.02253415f, -0.01830561f, -0.04100648f, 0.04223111f, 0.02722348f, -0.03541791f, -0.02299873f, -0.00679848f, 
    0.00422593f, -0.01020150f, -0.05614598f, -0.04304041f, -0.04908891f, 0.02757311f, -0.00599645f, -0.02226546f, 
    0.00759665f, -0.04368950f, -0.01454530f, -0.02807775f, -0.02855335f, -0.01727996f, -0.03308884f, 0.01641699f, 
    -0.02626222f, 0.00548435f, 0.01785319f, -0.03459288f, -0.05187777f, 0.03142765f, -0.03715450f, -0.04991985f, 
    -0.02615584f, -0.01847907f, -0.02245372f, 0.02451588f, 0.04134101f, 0.02748111f, -0.00695033f, 0.00701367f, 
    0.00437740f, -0.01203815f, 0.03458218f, -0.00078153f, 0.03628407f, 0.00595960f, -0.04824588f, -0.02717111f, 
    -0.02779736f, -0.01156499f, 0.01714123f, 0.02780949f, 0.03459713f, -0.00270624f, 0.00712204f, -0.03164686f, 
    -0.02700409f, -0.00738875f, -0.05636007f, 0.02531094f, -0.00156262f, -0.02779902f, -0.00300209f, -0.04239185f, 
    0.00903532f, 0.02965679f, -0.02479286f, -0.02435078f, -0.01375039f, 0.04445444f, 0.01697148f, -0.05470383f, 
    -0.04278067f, -0.01598562f, -0.04412689f, -0.04961941f, -0.03307123f, 0.01845917f, 0.01218759f, 0.02005270f, 
    -0.00237714f, -0.00244589f, 0.02760154f, 0.03227891f, -0.00246713f, -0.00318535f, -0.03081755f, -0.05414257f, 
    -0.02704761f, -0.02369043f, 0.03188130f, -0.01375009f, -0.03783571f, -0.00032666f, -0.05944881f, 0.01463557f, 
    -0.02460197f, -0.05218885f, -0.03257749f, 0.01438028f, 0.03890780f, 0.00156203f, -0.05601240f, -0.05147149f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07454830f, 0.06477764f, -0.06901898f, -0.01586542f, -0.08085418f, 0.03247736f, -0.02298518f, 0.04211848f, 
    -0.01953134f, 0.13033488f, -0.00334821f, 0.12307203f, 0.03757282f, 0.05847452f, -0.04920032f, 0.06374957f, 
    0.00585294f, -0.01967785f, 0.13028957f, -0.02521137f, -0.09498176f, -0.00062099f, 0.07554263f, -0.11373027f, 
    0.02413067f, 0.08465202f, -0.05350114f, -0.11320639f, 0.26524624f, -0.04995260f, -0.03895773f, 0.08138331f, 
    -0.04764809f, 0.13276105f, -0.08122706f, 0.04237602f, 0.15290761f, 0.17453268f, -0.03808020f, -0.00778942f, 
    0.03578490f, 0.13958524f, 0.01455851f, -0.05152692f, 0.00180258f, -0.04448044f, -0.06224549f, 0.08077754f, 
    0.14384486f, -0.01465962f, 0.02704407f, 0.06431080f, 0.15123299f, 0.01847297f, -0.00257320f, 0.00495549f, 
    0.01253408f, 0.07007516f, -0.04696007f, 0.06207844f, 0.03507446f, 0.05394946f, 0.01220289f, -0.02142863f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.15816692f, -0.06164083f, 0.23341726f, -0.14156291f, 0.09638205f, -0.39617485f, 0.07194841f, 0.00631829f, 
    0.17265552f, -0.38922265f, -0.28729767f, 0.06517638f, 0.08935812f, -0.08429445f, 0.01279696f, 0.19946328f, 
    0.00155206f, -0.07291549f, -0.42406404f, 0.06344658f, 0.19276744f, -0.10059397f, -0.03586600f, 0.04650484f, 
    -0.01105081f, -0.05419932f, 0.09668402f, 0.21852067f, -0.28996739f, -0.02322326f, 0.00428660f, -0.35624930f, 
    0.01453566f, -0.50856185f, 0.25027779f, -0.53056806f, -0.20853637f, -0.20390172f, 0.11055235f, 0.16321714f, 
    0.07381634f, -0.40122741f, 0.18047589f, 0.20556238f, -0.06469087f, 0.08415107f, 0.13115767f, -0.09309908f, 
    -0.29378620f, 0.09600779f, -0.04137640f, 0.26416427f, -0.09782701f, -0.38017079f, -0.11024670f, -0.01513569f, 
    -0.31960616f, 0.22584271f, 0.01332106f, -0.24675702f, 0.16091838f, 0.09949507f, -0.32613990f, -0.09975538f, 
    0.11949268f, -0.23729526f, -0.80577433f, -0.00310769f, -0.41409448f, 0.09311721f, -0.10942414f, -0.09751775f, 
    0.07274198f, -0.19618231f, -0.06600902f, -0.07790812f, -0.05414316f, 0.39151943f, -0.08107868f, 0.20247382f, 
    -0.09515284f, -0.02323893f, -0.13496181f, 0.33243269f, 0.11129168f, -0.04984762f, 0.28165439f, -0.28124288f, 
    -0.09754960f, -0.03337180f, -0.04206659f, 0.29047120f, 0.11575037f, 0.00304309f, -0.08552724f, 0.15971194f, 
    -0.02186611f, 0.15437531f, -0.28062585f, -0.42960519f, -0.18389839f, 0.17942752f, -0.04058686f, -0.16438770f, 
    -0.08780678f, -0.26318404f, 0.03573757f, 0.07114427f, -0.04342967f, -0.08495888f, 0.03235161f, 0.24779405f, 
    0.01230892f, 0.06518205f, -0.08712563f, 0.19079596f, 0.16044009f, -0.21611871f, 0.10179260f, 0.04035382f, 
    -0.19128396f, 0.20057985f, 0.07944899f, 0.20207383f, 0.05322266f, 0.08338758f, 0.01504343f, -0.03429118f, 
    -0.10320514f, -0.16279584f, -0.42078161f, -0.04852990f, -0.17608918f, -0.24923484f, -0.01250876f, -0.03364278f, 
    -0.16484691f, 0.17016298f, -0.00036009f, 0.17575423f, -0.00589190f, -0.59606129f, -0.15683579f, 0.02503055f, 
    0.06898079f, 0.00384245f, 0.16551250f, 0.30796564f, -0.26668429f, 0.06203292f, -0.14547357f, 0.12922792f, 
    -0.07437787f, 0.26468268f, 0.06191549f, -0.58515638f, 0.11450192f, 0.06391691f, -0.09472886f, 0.24471132f, 
    0.03191770f, 0.33632192f, -0.20762394f, 0.33975491f, 0.32104230f, 0.09020931f, 0.06657717f, -0.10227031f, 
    -0.00049963f, -0.10252962f, -0.04523176f, -0.13557537f, -0.05980750f, -0.03728246f, -0.23207274f, -0.02162260f, 
    -0.09566446f, 0.10932856f, -0.06862578f, -0.05439108f, -0.14742531f, -0.00411311f, -0.55294347f, 0.07850077f, 
    0.18520974f, 0.19191998f, 0.06935724f, -0.05487880f, 0.18680567f, -0.01667757f, -0.11214563f, 0.12826793f, 
    -0.53232980f, -0.11244892f, 0.16800810f, -0.18060623f, 0.03978800f, 0.27644685f, -0.07513694f, -0.10036108f, 
    -0.23586778f, -0.27290523f, -0.21153192f, -0.00227392f, -0.00430823f, -0.28783122f, 0.10894597f, 0.00130158f, 
    0.09427428f, -0.11030631f, -0.03980139f, 0.10825266f, 0.11085260f, -0.05890989f, -0.21680869f, 0.28453323f, 
    -0.04539289f, -0.38705662f, 0.08435211f, 0.06112478f, -0.26661333f, -0.05634003f, 0.11161000f, -0.21507837f, 
    0.33008137f, 0.11262276f, -0.16416320f, 0.06173565f, 0.25933999f, -0.37650916f, 0.07992075f, -0.14713973f, 
    -0.03448725f, -0.07323940f, -0.07467922f, -0.21746272f, 0.11460923f, 0.02106052f, 0.16562203f, -0.23767014f, 
    -0.35203364f, 0.06727777f, -0.10594368f, 0.06961363f, -0.28259927f, 0.07893635f, -0.67264301f, 0.03891173f, 
    0.02232528f, 0.15941133f, 0.26150075f, 0.16812445f, -0.12052611f, 0.15545192f, 0.37832096f, 0.02664395f, 
    0.17796582f, -0.07951592f, 0.21446259f, -0.14192672f, 0.30111387f, -0.09453293f, -0.02557454f, -0.00851643f, 
    0.18787986f, 0.03309858f, 0.30847394f, -0.36149442f, 0.08336311f, -0.28216919f, -0.02550267f, -0.11797597f, 
    0.02472631f, 0.08577935f, 0.15157023f, 0.18511304f, -0.31654036f, -0.09276701f, -0.38916048f, 0.10353188f, 
    -0.08425278f, 0.05285657f, -0.02161655f, -0.00356883f, -0.14157219f, 0.02518767f, -0.00812936f, -0.17053579f, 
    0.02780712f, -0.12077523f, 0.18213998f, 0.19922130f, -0.14807309f, -0.40391400f, -0.06693073f, -0.13986287f, 
    -0.09024274f, 0.04290918f, 0.01002930f, 0.13364635f, -0.09167396f, -0.07700329f, 0.04613462f, 0.02687502f, 
    -0.17504862f, -0.00863093f, -0.08120763f, -0.34760129f, -0.12326523f, -0.06478250f, 0.20543292f, 0.05826334f, 
    -0.10975846f, -0.01130399f, 0.10600082f, -0.09162454f, -0.04512397f, 0.14011699f, -0.11329310f, 0.08454797f, 
    -0.02515874f, 0.29224664f, 0.19991918f, -0.27459258f, -0.12500361f, -0.28613254f, 0.00279893f, -0.11264491f, 
    0.23133966f, 0.31321827f, -0.25207207f, -0.18263279f, 0.05259372f, -0.04502909f, 0.01055410f, -0.27199295f, 
    0.09721230f, -0.08060268f, 0.26810935f, -0.44058338f, -0.18624297f, 0.07712949f, 0.04146812f, -0.19588482f, 
    0.06512117f, -0.23978113f, -0.01347047f, -0.13448116f, 0.09038360f, 0.07188289f, -0.10321030f, 0.04636467f, 
    -0.46424392f, -0.22844711f, 0.27328360f, -0.15203778f, 0.10484065f, 0.14700080f, 0.02788959f, 0.00590243f, 
    0.10497405f, 0.19502859f, 0.15467291f, -0.04797380f, 0.10682953f, 0.07606407f, 0.14879134f, -0.13943514f, 
    0.24274801f, 0.10035623f, 0.10353704f, 0.06397595f, 0.21928512f, -0.24437000f, 0.16227546f, -0.09490303f, 
    -0.12548687f, -0.16761550f, -0.06414486f, 0.22082639f, 0.06886668f, 0.10823938f, -0.11867075f, -0.00910346f, 
    0.20003170f, -0.21830854f, 0.27364421f, 0.15148765f, -0.24070020f, -0.00998511f, 0.08486161f, 0.08545630f, 
    -0.17186664f, 0.16747008f, -0.04055462f, 0.21833402f, -0.11136307f, 0.11389583f, 0.03921906f, -0.10826330f, 
    0.08839511f, -0.00159134f, 0.20206040f, -0.08654596f, -0.09783721f, 0.09065008f, -0.41104695f, -0.16688895f, 
    -0.01453863f, -0.08122230f, -0.12668401f, -0.19550966f, 0.25204343f, -0.12706274f, -0.03867794f, -0.24835068f, 
    0.32962522f, 0.30950013f, -0.62950838f, 0.13049260f, 0.01946292f, 0.02120960f, -0.03181082f, 0.00415314f, 
    0.06831098f, 0.31413409f, -0.29355559f, -0.39618239f, -0.12463620f, -0.03848975f, -0.10477930f, -0.32957998f, 
    0.26169285f, -0.05651999f, 0.07309366f, -0.09177072f, -0.10009781f, 0.15380736f, -0.23522586f, 0.00601424f, 
    0.10356579f, -0.31059092f, -0.50415844f, -0.13749419f, -0.01915793f, -0.70821100f, -0.20818567f, -0.05220364f, 
    -0.19097881f, 0.05149060f, 0.02219984f, 0.05005767f, -0.25113389f, -0.06156752f, 0.00017235f, -0.11511217f, 
    -0.06095109f, 0.15423946f, 0.10539421f, -0.13601930f, -0.10416083f, 0.10904319f, 0.20995057f, -0.62704426f, 
    -0.06318271f, 0.04961028f, -0.04869358f, -0.27359390f, 0.07526167f, 0.07087949f, 0.25498933f, 0.34671503f, 
    -0.02404414f, -0.05537245f, 0.01218797f, -0.26230428f, -0.06173715f, -0.00460528f, 0.06212711f, 0.15695049f, 
    -0.11325692f, -0.31620422f, 0.46438155f, 0.28447199f, -0.26251984f, -0.19292197f, -0.10430770f, -0.26411581f, 
    -0.03235084f, -0.17284290f, -0.31670129f, -0.13056311f, 0.06315219f, -0.06859294f, 0.24309918f, 0.11771560f, 
    -0.28341466f, 0.09985877f, -0.01813489f, -0.45309132f, -0.21263538f, 0.13907474f, 0.06704433f, -0.12550765f, 
    0.12372451f, 0.19067410f, -0.17886664f, 0.04290906f, 0.06034458f, -0.43395108f, 0.10108048f, 0.04620020f, 
    -0.24460454f, 0.29805800f, -0.47567469f, -0.29800224f, -0.28761351f, 0.16154721f, -0.05889731f, -0.08073697f, 
    0.03125505f, 0.18607564f, -0.25802842f, 0.18161516f, 0.02961496f, 0.04577019f, -0.27150297f, -0.72319597f, 
    0.05031801f, 0.04644467f, -0.40178245f, -0.57044536f, 0.20207566f, 0.05601484f, 0.15784270f, 0.19823450f, 
    0.05152744f, 0.12037019f, 0.02470687f, -0.17657597f, 0.15386786f, -0.09731042f, -0.07697428f, -0.13195831f, 
    -0.15460494f, -0.09360480f, -0.23708175f, -0.32183060f, 0.31713718f, 0.15379070f, 0.09750046f, 0.07852491f, 
    -0.00064536f, 0.09436682f, -0.06598782f, -0.23632854f, -0.02195803f, -0.03905628f, -0.11565331f, -0.20272420f, 
    -0.00889206f, -0.04835683f, 0.11054309f, 0.14121547f, 0.09367558f, 0.28362048f, -0.02478782f, -0.02224530f, 
    -0.06576465f, 0.12507604f, 0.20696878f, -0.37013683f, -0.27002987f, -0.50928944f, 0.29919857f, 0.08462783f, 
    -0.11117893f, -0.13440856f, 0.10052179f, -0.27400193f, 0.25327960f, -0.15306896f, -0.01517120f, -0.00158364f, 
    -0.11589851f, -0.41412413f, 0.27936453f, 0.21165149f, -0.07414858f, 0.12642036f, 0.29325235f, 0.36695847f, 
    0.09929834f, -0.02201165f, 0.13073142f, 0.02431955f, -0.15335499f, 0.08587883f, 0.10362570f, -0.04611243f, 
    -0.09640405f, 0.30750576f, -0.05123229f, -0.27362221f, 0.06435306f, -0.07212558f, 0.07046086f, -0.12722141f, 
    -0.53929168f, 0.18321082f, -0.26691163f, 0.00793246f, -0.57109076f, -0.09243834f, 0.02953819f, -0.21126024f, 
    0.04210107f, 0.13752775f, -0.28797385f, 0.32008064f, -0.02634841f, 0.05058382f, -0.06482097f, -0.09620026f, 
    0.07290013f, 0.10836467f, 0.06445184f, -0.47496301f, -0.21311755f, -0.15834582f, 0.59848964f, -0.04798988f, 
    0.13708977f, 0.08429164f, -0.47953817f, -0.36467814f, 0.05892415f, 0.12521519f, -0.29548329f, -0.07533262f, 
    -0.39704639f, 0.01147115f, -0.09852607f, 0.32852003f, -0.36552501f, -0.04671064f, -0.02827812f, 0.05527008f, 
    -0.21383190f, 0.28128859f, 0.24751897f, -0.26461565f, 0.02951415f, -0.20663682f, -0.29374290f, 0.02534014f, 
    -0.09078290f, 0.10493506f, -0.05421202f, 0.02576754f, -0.32542565f, -0.04823326f, -0.04141042f, -0.24367274f, 
    -0.02359587f, -0.56778300f, -0.11052097f, 0.22599907f, -0.22894897f, 0.00222752f, -0.08512579f, 0.01299550f, 
    0.04014762f, -0.22209683f, -0.51220691f, 0.10437807f, 0.12266460f, -0.19585897f, -0.05340605f, 0.32517827f, 
    -0.05489739f, 0.22628102f, 0.21920481f, 0.13976200f, -0.10812514f, -0.00805157f, -0.59857166f, -0.35632804f, 
    0.22451003f, -0.03737935f, 0.10843772f, 0.24708454f, 0.21082018f, 0.08984689f, 0.07387644f, 0.01338053f, 
    -0.12877624f, 0.23460855f, -0.09065741f, 0.35724694f, -0.32396126f, -0.19717009f, 0.24813923f, 0.04244913f, 
    0.21603818f, -0.11345728f, -0.18854065f, 0.19023904f, -0.26205999f, 0.27797797f, 0.10404722f, -0.12520409f, 
    -0.42830572f, -0.02760004f, -0.10458045f, -0.29264748f, -0.07249590f, 0.13407388f, 0.02134680f, 0.22554724f, 
    0.05167354f, 0.03983407f, -0.37561813f, -0.23942396f, 0.29701108f, -0.03166643f, -0.41623515f, -0.19781440f, 
    0.00451941f, 0.25547993f, 0.10927763f, -0.22333394f, 0.06327612f, -0.12700495f, -0.07766000f, 0.21687546f, 
    0.03820498f, -0.03514073f, 0.27238613f, 0.17309797f, -0.11501438f, -0.00425352f, -0.07719887f, -0.15150511f, 
    0.05891022f, -0.09323287f, 0.22479245f, 0.01003169f, 0.01883300f, -0.05705311f, 0.10216985f, -0.40459785f, 
    0.09073333f, 0.03391222f, -0.09450745f, 0.26468772f, -0.11812125f, 0.06173842f, -0.15711938f, -0.13116260f, 
    0.19984387f, -0.64545202f, 0.41617480f, -0.18842201f, -0.22357631f, -0.27238217f, 0.26584086f, -0.07280520f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12542860f, 0.08282074f, -0.01773212f, 0.00748043f, -0.14096707f, 0.00059784f, 0.14654107f, -0.08705593f, 
    0.11152768f, 0.05103590f, -0.00849566f, -0.08611570f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
