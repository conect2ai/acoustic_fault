#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.14661986f, -0.47166777f, -0.22888325f, 0.15815823f, -0.44277376f, 0.73944265f, -0.14440063f, -0.25651336f, 
    -0.22671896f, 1.01261950f, -0.86033249f, -0.15010619f, 0.05456213f, -0.16641441f, -0.02096256f, 0.05058422f, 
    0.04952168f, -0.09714228f, -0.04127843f, -0.00275982f, 0.00696972f, -0.58141530f, -0.35237479f, -0.19390804f, 
    0.38896558f, -0.28516150f, 0.37828746f, -0.28947142f, 0.26033440f, -0.44125247f, 0.26772732f, -0.45544749f, 
    -0.55713665f, -0.21453996f, -0.09593721f, -0.26262158f, 0.28713298f, 0.11313740f, 0.03618885f, -0.33715409f, 
    -0.34726900f, 0.48207900f, -0.13569079f, 0.07066453f, 0.17260824f, 0.09016590f, -0.02485079f, 0.70223701f, 
    0.52005243f, 0.10986575f, 0.67218065f, 0.01154556f, 0.12008042f, 0.02886769f, 0.63041991f, 0.31112331f, 
    0.36582631f, 0.14478958f, -0.44060147f, -0.42240429f, 0.11501244f, 0.06742806f, 0.13332637f, 0.47960693f, 
    -0.59234786f, -0.12256425f, 0.00450554f, 0.45818424f, 0.27961588f, -0.28450665f, -0.09971951f, -0.41600925f, 
    0.23632324f, -0.47606632f, 0.18626271f, -0.16119260f, 0.03266965f, -0.15065145f, -0.04963141f, 0.33362153f, 
    0.41610825f, -0.43473998f, -0.28979859f, 0.00923988f, -0.43874311f, -0.38523960f, 0.08462287f, -0.24432775f, 
    0.14496306f, -0.01025997f, 0.41326559f, 0.45399529f, 0.09195446f, -0.15300211f, 0.17570181f, 0.59793180f, 
    -0.13663021f, -0.22247662f, -0.27538323f, -0.55913347f, -0.43408245f, -0.16126582f, 0.38101244f, 0.02731896f, 
    -0.39862001f, 0.13052401f, 0.04955219f, 0.23386417f, 0.07667331f, -0.44481984f, -0.74194932f, -0.04672926f, 
    0.71847081f, 0.11184686f, 0.10666065f, 0.20690574f, 0.01860564f, -0.21656913f, 0.07765076f, -0.16808024f, 
    -0.19766593f, -0.31240305f, -0.50953341f, 0.37654528f, 0.33196387f, 0.35821381f, -0.09746532f, 0.13106394f, 
    0.21411923f, 0.36872670f, -0.02862821f, 0.01360614f, -0.08526202f, -0.40788791f, -0.37220567f, 0.40090987f, 
    -0.16864240f, 0.30279595f, 0.16698445f, -0.07297149f, -0.06784956f, -0.14184336f, 0.59860682f, -0.39843822f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.34087911f, -0.18762243f, -0.10439687f, 0.10915410f, 0.36527765f, 0.17402224f, 0.16621426f, 0.03521494f, 
    0.13390614f, -0.43195108f, 0.13229913f, -0.28707954f, 0.11942980f, -0.12653372f, 0.09842031f, -0.16418310f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.31235987f, -0.14590870f, 0.17659712f, 0.12381060f, 0.00705963f, 0.06753326f, -0.10162826f, -0.13125844f, 
    0.08622402f, -0.23293039f, -0.33523500f, -0.59768480f, 0.08402133f, 0.12302306f, 0.18507314f, -0.02951626f, 
    -0.01840336f, -0.01359124f, 0.00660310f, -0.16890998f, 0.02936807f, -0.08515407f, -0.11402246f, -0.16776446f, 
    0.04848752f, -0.04606982f, -0.18168420f, -0.09875145f, 0.19859180f, -0.14007649f, -0.21897645f, -0.01903359f, 
    -0.21970575f, 0.18028621f, -0.04277084f, 0.12469763f, 0.46202251f, 0.12624487f, 0.20659655f, 0.26737866f, 
    0.07672541f, 0.08588158f, 0.03656833f, 0.09298307f, 0.01894107f, 0.01118884f, 0.11958365f, -0.25122404f, 
    0.04822436f, 0.00740435f, 0.07934882f, -0.01764540f, 0.01647202f, -0.03745020f, 0.41840783f, 0.16488437f, 
    -0.00061145f, 0.03008819f, -0.22594787f, 0.03015370f, -0.11120886f, 0.11175397f, 0.12338512f, -0.00344603f, 
    0.08790299f, -0.13467324f, 0.03321977f, -0.08167649f, -0.02886319f, -0.02877011f, -0.11701587f, 0.01716878f, 
    0.00405384f, -0.08990314f, -0.09118582f, -0.11826411f, -0.04794210f, -0.00468854f, 0.05783600f, 0.11757723f, 
    -0.06141414f, -0.02307248f, 0.30725104f, -0.03249615f, -0.19328897f, -0.08336527f, -0.19310284f, -0.18016498f, 
    -0.04394320f, 0.05444704f, 0.24806993f, 0.23646800f, 0.01418516f, -0.03183877f, -0.03147002f, -0.02971163f, 
    0.03783783f, -0.05445062f, 0.11223057f, -0.22372474f, 0.32661629f, -0.06739689f, -0.34299132f, 0.03294926f, 
    -0.04618488f, -0.06111597f, -0.05561829f, 0.05958167f, -0.54646164f, -0.25011826f, -0.11082456f, -0.06028750f, 
    0.09476066f, -0.02255156f, 0.09108159f, 0.14675160f, 0.04646972f, -0.25696200f, -0.30554882f, -0.10119457f, 
    -0.02533461f, -0.03407339f, -0.11015108f, 0.12513895f, 0.01532051f, -0.07233084f, -0.04990360f, 0.22178106f, 
    0.04684512f, -0.01401797f, -0.01610662f, 0.02917610f, 0.08167267f, 0.01260663f, 0.16237551f, -0.31320709f, 
    -0.04748015f, -0.09839258f, -0.06384818f, 0.14657463f, -0.06734301f, -0.04871015f, -0.08688805f, 0.06311892f, 
    -0.08049116f, 0.16639861f, -0.27841601f, -0.11294996f, -0.11286679f, -0.21513677f, -0.07578231f, 0.04434244f, 
    0.01180918f, 0.16388582f, -0.03438118f, -0.24748111f, 0.14410794f, 0.01575421f, -0.09506988f, 0.09076048f, 
    0.13696247f, -0.14254566f, 0.10838134f, 0.29177111f, -0.01022282f, 0.16294910f, 0.11997345f, 0.15625894f, 
    0.04115901f, 0.26921895f, -0.00212439f, 0.04860828f, 0.03823763f, -0.16492128f, -0.10457589f, 0.03649663f, 
    -0.16829056f, 0.10013165f, -0.14574233f, -0.06084101f, -0.02382664f, 0.09969955f, 0.01513090f, 0.01969902f, 
    -0.00523142f, 0.01933243f, 0.07136037f, -0.16989696f, 0.09567443f, 0.07209012f, -0.05513627f, 0.22738129f, 
    -0.02796095f, 0.13126291f, 0.02277852f, -0.09569435f, -0.09198662f, 0.10262492f, -0.27168000f, -0.05499961f, 
    0.17646414f, -0.01016962f, -0.07160626f, 0.27652040f, -0.11324564f, -0.06166252f, 0.07604548f, -0.03109828f, 
    -0.21580744f, 0.19770044f, -0.18025565f, 0.12566324f, 0.09047928f, -0.11059329f, -0.21288013f, -0.14828220f, 
    0.29413798f, -0.08133458f, -0.06220448f, -0.02724241f, 0.20697206f, 0.01945291f, 0.16172941f, 0.15799527f, 
    0.14827223f, 0.02686354f, 0.25774553f, 0.10158377f, 0.08818047f, 0.00190669f, -0.01938215f, -0.01158061f, 
    0.04841748f, -0.05201004f, -0.09491957f, 0.00447657f, 0.18158372f, 0.06689065f, -0.12285516f, -0.20769903f, 
    -0.05615516f, -0.02902709f, -0.01997834f, 0.06561954f, 0.37862444f, 0.02842637f, 0.06093672f, 0.06479862f, 
    -0.13751350f, 0.02265201f, 0.07843447f, 0.00450484f, 0.07341853f, -0.25639266f, -0.16046485f, -0.02365665f, 
    0.10789030f, 0.00618800f, -0.02172704f, -0.11936457f, -0.02617775f, 0.10736710f, 0.04996980f, -0.02639649f, 
    0.08206362f, 0.06652209f, 0.17130612f, 0.24131429f, 0.26547152f, 0.29387650f, -0.11873916f, -0.16119719f, 
    -0.09769100f, -0.01019816f, -0.10281406f, 0.00196530f, -0.22228622f, -0.44420534f, -0.25782675f, 0.25402290f, 
    0.32222119f, 0.23155770f, 0.10227922f, -0.07984933f, 0.02430152f, 0.01949928f, -0.21884319f, 0.23948501f, 
    -0.53173381f, -0.37017927f, -0.19483474f, -0.00312046f, -0.05808484f, 0.01579229f, -0.03725314f, -0.09615175f, 
    -0.00281097f, 0.03239404f, 0.33432296f, -0.51051748f, -0.05336686f, -0.09748802f, 0.24949715f, -0.00884979f, 
    0.02694426f, 0.01637220f, -0.28415608f, -0.64472276f, -0.25008497f, -0.02330482f, 0.11725117f, -0.32780293f, 
    0.01252845f, 0.05266180f, 0.09318936f, 0.00956882f, -0.19900976f, -0.14613757f, -0.10204928f, -0.04927520f, 
    -0.09689698f, 0.07608311f, 0.13052082f, 0.10239217f, 0.24497256f, 0.14978074f, 0.05976898f, 0.01791156f, 
    0.00959027f, 0.09782153f, 0.07952020f, 0.11328536f, 0.14566813f, -0.01805950f, 0.18835901f, -0.08767533f, 
    -0.15583138f, -0.19256334f, 0.05482779f, -0.08729009f, 0.04714380f, -0.05871252f, 0.10396720f, -0.00330514f, 
    -0.14879826f, 0.09868823f, 0.08246927f, -0.20661354f, 0.03891155f, -0.14429101f, 0.02986009f, -0.28878191f, 
    0.13071643f, 0.08412413f, -0.05335850f, 0.09617232f, 0.06061133f, 0.09247234f, -0.04740462f, 0.11937579f, 
    0.12027226f, -0.12455771f, -0.19782318f, 0.05024130f, 0.06290723f, 0.07632188f, 0.05260499f, 0.02958370f, 
    -0.05524406f, -0.13032708f, -0.25429067f, -0.61720848f, -0.02414918f, -0.44650996f, -0.08669291f, 0.06548716f, 
    -0.15209416f, 0.08154879f, -0.09203105f, 0.16742192f, 0.03432478f, -0.09278512f, -0.02608707f, 0.08817700f, 
    0.06313635f, 0.00904399f, 0.06706031f, -0.09683078f, 0.10703557f, 0.31090331f, -0.03773360f, 0.07491974f, 
    -0.02682229f, -0.07808700f, -0.05308866f, -0.00483083f, -0.59320545f, 0.17733112f, 0.27145377f, -0.09573840f, 
    0.00061356f, -0.01559549f, 0.10572504f, -0.00938851f, 0.01665359f, -0.27048329f, -0.52763164f, -0.31500694f, 
    0.10664459f, 0.02650405f, -0.02096029f, 0.06603123f, -0.09032102f, -0.13668098f, 0.03001426f, 0.19303285f, 
    0.08203077f, 0.04262976f, 0.00821271f, -0.05714924f, -0.12746544f, 0.15491477f, 0.21302082f, -0.05269242f, 
    0.04043811f, -0.10984011f, -0.01466029f, -0.20039918f, 0.24780235f, 0.08000341f, 0.01753072f, 0.06898952f, 
    -0.15855725f, -0.25629693f, -0.05457565f, -0.04706930f, 0.02067905f, 0.06043221f, 0.01965389f, -0.03228696f, 
    0.16954808f, -0.20284326f, 0.21766096f, 0.36335483f, -0.02578831f, 0.05723415f, 0.03688581f, -0.00361808f, 
    0.01786090f, -0.06361310f, -0.01593162f, -0.14256921f, 0.09674765f, 0.24121813f, -0.00758089f, 0.03980205f, 
    0.01063142f, -0.08098195f, -0.11062933f, 0.11497086f, 0.11801387f, 0.12084780f, 0.15226322f, 0.01365837f, 
    0.07892905f, 0.11443022f, 0.15475498f, 0.24156231f, 0.17752102f, 0.04580706f, -0.00841729f, 0.05770408f, 
    0.05140926f, -0.03849927f, -0.02250687f, -0.14605531f, -0.10121451f, 0.04986220f, -0.01328571f, -0.23221096f, 
    0.06753313f, 0.05897021f, 0.06831713f, 0.12347247f, -0.04172089f, -0.15015791f, 0.41386437f, 0.35249123f, 
    0.10125304f, 0.02903147f, 0.07027096f, -0.09509843f, -0.03605333f, -0.04344660f, -0.02742009f, -0.01927492f, 
    -0.24304511f, 0.04255160f, -0.05481274f, -0.07839902f, 0.20865366f, 0.07200414f, 0.19111566f, 0.12128100f, 
    -0.06184956f, 0.00118244f, 0.26718584f, 0.06144743f, -0.07289035f, -0.03475366f, -0.30700403f, 0.02072096f, 
    -0.26938730f, 0.03730363f, 0.03024792f, 0.16746512f, 0.05517170f, -0.01556367f, 0.14535490f, 0.17793290f, 
    -0.16601422f, 0.03557513f, 0.05654240f, 0.23116380f, 0.35658783f, -0.04941984f, 0.11178846f, 0.08986937f, 
    0.04165430f, 0.10990905f, -0.10494544f, 0.05660261f, -0.19559476f, -0.21954036f, 0.15919149f, 0.08543264f, 
    0.09662627f, 0.03569693f, 0.03792559f, -0.04867953f, -0.01317375f, -0.12730457f, 0.20291764f, -0.03375495f, 
    0.08862653f, 0.08017200f, 0.02613653f, -0.01025866f, 0.06605978f, 0.05738268f, -0.17002505f, -0.10444048f, 
    0.16067846f, 0.15622962f, -0.05643920f, -0.11069684f, -0.09265056f, -0.11275537f, -0.05471911f, 0.16753830f, 
    -0.05213153f, 0.04375796f, 0.00180521f, -0.01832913f, 0.20810869f, 0.04299965f, 0.04400547f, 0.18832368f, 
    0.10403637f, 0.04005511f, -0.02998496f, -0.15292613f, 0.12683518f, 0.19296640f, 0.07848831f, 0.04052249f, 
    -0.05146919f, 0.05756742f, 0.02903866f, -0.07790142f, -0.06511284f, -0.01715639f, 0.06469499f, 0.00451377f, 
    -0.07363188f, -0.00114945f, 0.01673689f, 0.06539052f, 0.02065005f, -0.01188132f, 0.02423659f, -0.07273613f, 
    0.06828365f, 0.04830984f, 0.00430423f, -0.03730537f, -0.05179003f, -0.04425229f, 0.00923485f, 0.03902578f, 
    0.03017110f, 0.02739276f, 0.07046438f, 0.01456816f, 0.01528635f, 0.01604137f, 0.04431618f, -0.01255062f, 
    -0.05142663f, -0.08184110f, 0.02103296f, -0.01308407f, -0.07367868f, -0.00774454f, 0.04463056f, 0.07524999f, 
    -0.08610817f, -0.03261123f, -0.03292520f, -0.01972631f, -0.04509744f, -0.07602013f, -0.01130735f, -0.00337143f, 
    -0.04902825f, 0.06654924f, -0.02992645f, -0.01793761f, 0.03045614f, -0.03244460f, -0.06084186f, 0.01605604f, 
    0.03579136f, -0.06859208f, -0.01159319f, -0.04041296f, -0.04339780f, -0.00917412f, -0.05347764f, 0.03472387f, 
    -0.08966821f, -0.06553492f, 0.06587396f, 0.00844305f, -0.03090743f, 0.04055880f, -0.02766792f, -0.03749716f, 
    -0.00545976f, -0.03534571f, -0.00351356f, -0.05887010f, -0.04807726f, 0.04996524f, -0.02319783f, 0.01613171f, 
    -0.02769328f, -0.04337730f, -0.01555899f, 0.00327461f, -0.03558668f, -0.06944120f, 0.05410479f, -0.08852389f, 
    -0.00341908f, -0.08441035f, -0.04816388f, 0.04678530f, -0.07907265f, -0.03199701f, -0.02516164f, -0.07883894f, 
    0.01416937f, -0.04894615f, -0.03407395f, -0.06219598f, 0.05492176f, 0.03488337f, 0.03262333f, 0.00494506f, 
    -0.06032230f, -0.01772793f, -0.00825451f, -0.01662972f, -0.01017078f, 0.05503190f, -0.01201840f, -0.02650881f, 
    -0.06807039f, -0.04624415f, -0.05276537f, 0.00265113f, -0.04071907f, -0.02662757f, -0.01525685f, -0.04187722f, 
    -0.02616764f, 0.05224746f, 0.03545624f, 0.02247680f, 0.02528048f, 0.07341426f, -0.00880976f, -0.02375836f, 
    0.03828492f, 0.01897015f, 0.04715193f, -0.03743178f, 0.01129203f, 0.02558287f, 0.02126888f, 0.07543309f, 
    -0.03853404f, -0.07260925f, 0.02240997f, 0.06724615f, -0.02394158f, -0.08592583f, -0.05391867f, -0.00662368f, 
    0.47203022f, 0.06408753f, -0.00355079f, 0.06776105f, 0.07959763f, 0.05919191f, 0.13162315f, -0.04048287f, 
    -0.20390458f, 0.15909098f, 0.35168365f, -0.34818387f, -0.06889164f, 0.07471025f, 0.01534737f, 0.00831404f, 
    0.04471838f, 0.00892506f, 0.09119330f, 0.15029183f, 0.18152241f, -0.01117576f, -0.08605426f, -0.04814798f, 
    -0.03803153f, -0.06418594f, 0.09042513f, -0.10325570f, 0.32252207f, -0.10877273f, 0.01854186f, 0.04885774f, 
    0.09043710f, -0.01884510f, -0.03325439f, 0.14918207f, -0.16832866f, 0.02972139f, 0.16956207f, 0.06380832f, 
    0.05539272f, -0.06029831f, 0.07105849f, 0.06725319f, 0.06527796f, 0.00961163f, -0.38746563f, -0.61591786f, 
    -0.09020045f, -0.02092374f, -0.09766620f, 0.02652292f, -0.08078677f, 0.06153521f, -0.35086551f, -0.11580512f, 
    -0.17944589f, -0.17938530f, -0.04195312f, 0.00658397f, -0.00231239f, 0.08509769f, 0.03530983f, 0.36435854f, 
    -0.00597999f, 0.14901797f, 0.13507703f, -0.07151642f, 0.00129638f, -0.04014152f, -0.03458234f, 0.00373549f, 
    0.08588257f, 0.14809839f, 0.03075361f, 0.08284265f, 0.00271978f, 0.03474193f, 0.03717422f, -0.09223159f, 
    0.06931964f, 0.03675191f, 0.14639921f, 0.16848090f, -0.08428557f, -0.00254760f, -0.02063475f, 0.13577239f, 
    0.04245037f, -0.23127994f, -0.05968568f, 0.14472811f, -0.29217914f, 0.02571080f, -0.21896853f, -0.04619353f, 
    -0.01598804f, 0.04884963f, 0.07057402f, 0.44857574f, 0.21475014f, 0.18472575f, -0.06886698f, 0.07294446f, 
    0.08920673f, -0.06435408f, -0.02589966f, 0.05601428f, 0.05058185f, 0.01315392f, -0.40794706f, 0.07879761f, 
    -0.02298483f, 0.17166728f, 0.18060842f, 0.07349809f, 0.09496906f, 0.02467001f, 0.15538426f, -0.06437124f, 
    0.06495243f, 0.01819118f, -0.02648592f, -0.00239504f, 0.05011778f, 0.07924019f, 0.19206531f, 0.04462578f, 
    0.02080327f, 0.10763881f, -0.13794316f, 0.02792995f, 0.06037899f, -0.15114686f, 0.00745529f, -0.19383700f, 
    -0.25013706f, 0.18493491f, 0.02332869f, 0.22674738f, 0.05974144f, -0.04688304f, -0.05602602f, 0.13132201f, 
    -0.13063380f, -0.23608749f, -0.47164530f, -0.19825931f, -0.02002715f, 0.06020134f, -0.15292300f, 0.07654478f, 
    -0.18750164f, 0.24763417f, 0.07837705f, -0.34483859f, 0.12360235f, 0.44741058f, 0.16514041f, -0.07107133f, 
    0.11372724f, 0.06372553f, 0.03677151f, -0.40227622f, 0.19648784f, 0.04689652f, -0.30404538f, -0.05092314f, 
    0.12728709f, 0.11773293f, -0.02341528f, 0.01686118f, 0.01280735f, -0.38116056f, 0.08820333f, 0.02131908f, 
    -0.15581307f, -0.04842328f, -0.07135811f, 0.00425819f, -0.04446643f, 0.02652157f, -0.10436650f, -0.13426270f, 
    0.01768862f, 0.17130528f, 0.01794153f, 0.00767040f, 0.04110462f, 0.20030470f, 0.32462174f, -0.04820617f, 
    -0.07168658f, -0.06240592f, -0.02508608f, -0.03058043f, -0.12599291f, -0.08771007f, 0.03091998f, -0.14880411f, 
    -0.13806793f, 0.08366554f, -0.02964254f, 0.19983420f, 0.05870211f, -0.04735335f, 0.07409983f, -0.24761374f, 
    -0.02877784f, 0.08363366f, -0.11420958f, 0.21930888f, -0.06631141f, -0.11631310f, -0.15646718f, -0.05138265f, 
    -0.07602331f, 0.13454984f, -0.23902571f, 0.13094208f, 0.20162937f, 0.06218839f, 0.09709605f, 0.11043981f, 
    -0.03578091f, -0.15281352f, 0.13813262f, 0.01562997f, 0.04276573f, -0.08406703f, 0.02032317f, 0.07604735f, 
    0.04377651f, -0.21097305f, 0.05077727f, 0.29043555f, 0.10200344f, -0.19539626f, 0.15446134f, 0.07351599f, 
    0.01230398f, 0.00978173f, 0.03407349f, 0.03944365f, 0.12316044f, 0.02557923f, -0.13552952f, -0.00695076f, 
    -0.11185973f, 0.14653514f, 0.04474804f, -0.08510375f, -0.31301141f, -0.04553090f, -0.26755661f, -0.21069176f, 
    0.09805939f, -0.10209950f, -0.04064023f, 0.07693940f, -0.05462710f, -0.11236217f, -0.06271838f, 0.27223104f, 
    0.09602029f, -0.01637894f, 0.09371214f, -0.03414728f, -0.10642350f, -0.03187057f, -0.01620264f, 0.17695494f, 
    0.00229257f, -0.08155212f, -0.04509898f, -0.00039843f, -0.02240482f, 0.13781875f, 0.18798962f, -0.08858143f, 
    -0.00481582f, -0.06693666f, 0.13451350f, 0.28263652f, 0.05635744f, 0.01740481f, -0.03119058f, 0.05440884f, 
    -0.09588962f, 0.02661705f, -0.05988109f, -0.08960438f, 0.04220736f, -0.09980197f, -0.09157800f, -0.00500348f, 
    0.04066426f, -0.09872686f, -0.04870975f, -0.08940799f, 0.06655657f, -0.05914324f, 0.00131926f, -0.08674571f, 
    0.02766164f, -0.02418426f, 0.02919656f, -0.02668324f, -0.06488619f, -0.07126024f, 0.03102707f, 0.06294576f, 
    0.04822541f, -0.06961653f, -0.06970494f, 0.02535509f, -0.01370437f, -0.03102759f, -0.07079831f, -0.05333446f, 
    0.03146724f, -0.01459180f, 0.06506960f, 0.06817267f, 0.00603929f, -0.03860419f, -0.04119107f, -0.01286142f, 
    -0.08978248f, 0.00500863f, 0.03953173f, -0.07440104f, -0.07808524f, -0.01083064f, 0.04309836f, -0.09157304f, 
    -0.07454853f, -0.09076472f, 0.03184624f, -0.09636654f, -0.05939965f, 0.04080625f, 0.04692368f, -0.06251151f, 
    -0.04128403f, 0.05535611f, 0.05077444f, 0.01946381f, -0.04891222f, -0.07523188f, -0.05401921f, 0.03747816f, 
    -0.09825394f, 0.06054575f, -0.03551045f, -0.05026485f, -0.08720963f, -0.08256276f, -0.01612060f, -0.03811692f, 
    -0.04795182f, 0.03635512f, -0.05444743f, -0.07080807f, -0.01301882f, -0.08312500f, -0.05941398f, 0.05470352f, 
    -0.02338295f, 0.06736232f, -0.06475915f, -0.03026402f, 0.00164490f, -0.03839430f, -0.08015530f, -0.06280378f, 
    0.02700354f, 0.00940009f, -0.02103624f, -0.05783151f, -0.08880159f, -0.02909171f, 0.06380422f, -0.03587960f, 
    -0.05866552f, -0.01367186f, -0.09240235f, 0.05759416f, 0.04494762f, 0.02146079f, -0.07427859f, 0.04379316f, 
    0.00764351f, 0.03615020f, -0.01378053f, -0.07841049f, 0.06179115f, -0.01105110f, 0.03405932f, 0.01031377f, 
    -0.06109286f, -0.07761160f, 0.06128639f, 0.02388637f, -0.07884716f, 0.00364857f, -0.02255114f, -0.07176645f, 
    -0.06752951f, -0.02769601f, 0.04875852f, 0.02568844f, 0.00442917f, -0.02208742f, -0.05021680f, 0.03440095f, 
    0.01761768f, 0.04078821f, -0.09020801f, -0.06123519f, -0.01998911f, -0.01045401f, 0.00357271f, 0.03049375f, 
    0.03297573f, 0.05451182f, -0.00266567f, -0.00800244f, 0.00206239f, -0.00216841f, -0.04281155f, 0.03658670f, 
    -0.24435923f, 0.51877338f, -0.37642896f, 0.13177787f, -0.02090698f, 0.11089703f, -0.13427860f, -0.08796395f, 
    0.08492566f, -0.00179289f, -0.43199620f, 0.35783470f, -0.08331747f, 0.06679021f, 0.41987824f, -0.01702118f, 
    -0.11882214f, -0.04886921f, -0.28175312f, -0.01521108f, 0.17643498f, -0.01811581f, -0.04023335f, -0.13109210f, 
    0.16242044f, 0.07486034f, -0.04719795f, 0.03798090f, -0.08445536f, 0.14584276f, -0.05129883f, -0.04151099f, 
    0.11744791f, 0.05045434f, -0.07288723f, -0.10058866f, -0.20297399f, -0.00869702f, -0.00258134f, -0.04592147f, 
    0.03046441f, -0.00049903f, 0.02475382f, -0.02013836f, 0.03405280f, -0.15257987f, 0.08264410f, 0.21689165f, 
    -0.00141893f, -0.00505273f, -0.16260274f, 0.03919611f, -0.00361875f, -0.03458101f, 0.14572036f, 0.21822689f, 
    -0.06664439f, -0.06461424f, 0.10411568f, -0.21086054f, 0.19973013f, 0.16631976f, 0.06396795f, 0.06101650f, 
    -0.23421781f, -0.20272636f, 0.08362229f, -0.06839982f, 0.18640690f, -0.08307416f, 0.01953681f, 0.20931229f, 
    -0.14934352f, -0.02448556f, 0.19207972f, -0.00002253f, 0.02320698f, 0.04566003f, -0.13053870f, -0.00881557f, 
    -0.05626135f, -0.03731390f, 0.33760470f, -0.22915138f, -0.09931450f, -0.18247803f, 0.07189772f, 0.12051684f, 
    0.13852574f, 0.11945268f, -0.06772699f, -0.02609389f, 0.05257729f, 0.02311243f, -0.31902778f, -0.06712828f, 
    -0.03295819f, -0.01935376f, 0.14061700f, 0.18375839f, -0.13511701f, 0.00945598f, 0.06746044f, 0.07365590f, 
    -0.15480211f, -0.01415985f, 0.05099970f, -0.11080973f, -0.22575942f, -0.21911567f, -0.02317762f, -0.00130386f, 
    0.01951471f, 0.07251323f, 0.00980484f, 0.11324495f, 0.05909202f, -0.21147341f, -0.17926309f, 0.02253091f, 
    -0.16117822f, -0.01615027f, -0.20061351f, 0.04931756f, 0.11884835f, 0.01869469f, -0.20707810f, -0.04174784f, 
    -0.05945537f, 0.03233499f, 0.08828507f, -0.28691563f, 0.00925957f, -0.17241015f, 0.09705827f, 0.16223167f, 
    0.18445446f, 0.63680917f, 0.19274281f, 0.17348045f, -0.09867543f, 0.05754352f, 0.08625639f, -0.11636826f, 
    -0.27375355f, -0.02953643f, -0.23242496f, 0.04126748f, -0.21312332f, -0.07273416f, -0.13046637f, 0.02491767f, 
    -0.16598710f, 0.25113451f, -0.17664045f, -0.05068926f, 0.04031053f, 0.16598360f, 0.08222014f, 0.17178115f, 
    -0.06266648f, -0.19412263f, 0.22210470f, 0.10395912f, 0.13494219f, -0.01669981f, 0.13280098f, 0.07402516f, 
    -0.01421551f, -0.11087513f, 0.09314860f, 0.10064771f, 0.27449459f, 0.18773504f, 0.05713567f, 0.12279443f, 
    0.16465694f, -0.03579877f, -0.13827296f, -0.01777082f, 0.30816987f, -0.00583451f, -0.17159963f, -0.03449458f, 
    0.06901389f, -0.07666285f, -0.06211321f, 0.10628062f, 0.09939378f, -0.33110830f, -0.12142715f, -0.17338878f, 
    0.13298506f, 0.00067500f, -0.27917111f, -0.09727575f, 0.01907477f, -0.04310527f, -0.14534657f, -0.35768715f, 
    -0.04240926f, 0.04120122f, -0.11179771f, -0.03354397f, 0.05815871f, -0.13338847f, 0.05814176f, 0.07121837f, 
    -0.03754713f, -0.27132416f, 0.05700038f, 0.02768071f, -0.02704904f, -0.00895696f, 0.09179083f, -0.29360828f, 
    0.12011165f, -0.11100718f, 0.05603936f, 0.08116236f, 0.02820840f, -0.09663734f, 0.17467149f, 0.00839140f, 
    0.08442150f, -0.01595504f, -0.26037732f, 0.37012130f, 0.04579049f, 0.12203314f, -0.08716145f, 0.22793841f, 
    -0.07914987f, 0.06436400f, 0.08486453f, -0.19558387f, 0.02299094f, -0.02860562f, -0.01131826f, -0.01063508f, 
    0.10004508f, 0.09155200f, 0.01614578f, -0.17331490f, -0.13084900f, 0.20416705f, 0.06890710f, 0.09187937f, 
    0.02917279f, 0.27290982f, -0.13801709f, 0.13772036f, -0.06538425f, 0.15982656f, -0.10469908f, -0.26332849f, 
    0.04566151f, 0.11297025f, -0.12711214f, 0.11597878f, 0.04023790f, 0.14062905f, 0.10772892f, 0.40879723f, 
    0.02213856f, -0.16169569f, 0.18256441f, 0.04287120f, 0.03114036f, 0.12551707f, -0.27690226f, 0.07690913f, 
    0.08409335f, 0.08132476f, 0.02083309f, 0.07132261f, -0.12002526f, -0.08816635f, -0.18974893f, -0.16068202f, 
    -0.02540144f, 0.08881231f, 0.21578139f, 0.34530622f, 0.25768626f, 0.05356431f, 0.03251718f, -0.00575462f, 
    0.04336540f, -0.24998210f, 0.11733648f, -0.14298476f, -0.03129236f, -0.06537192f, -0.09170203f, -0.06322215f, 
    -0.05218985f, 0.30978373f, -0.35832924f, 0.05095424f, 0.08866683f, -0.08600048f, -0.07650058f, -0.28527454f, 
    -0.05145441f, 0.12278007f, -0.20399146f, -0.23028164f, -0.12323916f, -0.05984834f, -0.05241509f, 0.15066354f, 
    0.00842569f, 0.12167039f, 0.01727597f, -0.05686070f, 0.10595173f, 0.13859731f, -0.00569180f, -0.06798462f, 
    0.12297063f, 0.13720754f, 0.00903862f, -0.02248019f, 0.08676873f, 0.11484635f, 0.37929013f, 0.09744039f, 
    0.13143089f, 0.07563458f, 0.17389032f, 0.11242718f, 0.08661722f, -0.10507178f, 0.03105402f, 0.20076655f, 
    0.06409267f, -0.04514373f, -0.02096316f, 0.04981374f, 0.04660397f, 0.07683008f, -0.18099611f, 0.04417522f, 
    0.00833754f, 0.13015774f, 0.04751218f, 0.11461278f, 0.15221812f, 0.13557623f, 0.24717365f, 0.08999715f, 
    -0.04690043f, -0.05028372f, 0.08896018f, -0.02532024f, 0.00815155f, -0.05938905f, -0.08360481f, -0.21150060f, 
    0.33155698f, -0.22820137f, -0.07206793f, 0.02161207f, 0.09045868f, 0.12984920f, 0.16993900f, 0.02692497f, 
    0.02998787f, -0.39833441f, -0.16533400f, 0.09819597f, -0.10730681f, 0.09121626f, -0.01689706f, 0.06344877f, 
    0.05128451f, 0.15859145f, -0.34795889f, -0.01030835f, 0.07593684f, -0.04879451f, -0.10648745f, -0.04623022f, 
    -0.15682888f, -0.10460678f, -0.03588939f, -0.46237618f, -0.12602398f, 0.27964821f, -0.13714011f, 0.04565421f, 
    -0.27821988f, -0.07665765f, 0.07217600f, 0.07478248f, -0.19721754f, 0.00751846f, 0.02178136f, -0.06977681f, 
    0.18322940f, 0.10938133f, 0.05815526f, 0.05051552f, 0.04143276f, -0.12438540f, 0.01832971f, -0.05945104f, 
    -0.01702046f, -0.10730103f, -0.15680070f, 0.08840935f, 0.17732179f, 0.15129608f, -0.00974969f, -0.09374531f, 
    -0.15708688f, -0.07415529f, -0.11849190f, -0.06004143f, 0.15885986f, -0.08986611f, -0.10295001f, 0.06390674f, 
    -0.07100029f, 0.08772699f, -0.09360775f, 0.14308487f, 0.06945435f, 0.01796463f, -0.04833648f, -0.09475925f, 
    -0.28961051f, 0.17276976f, 0.23312074f, -0.05074406f, 0.10838436f, -0.12821966f, 0.07745407f, -0.02622899f, 
    0.03429478f, 0.04891914f, -0.57773232f, -0.54112041f, -0.11417534f, 0.15512918f, -0.08989350f, 0.05773610f, 
    -0.03407845f, -0.07730196f, -0.16428986f, 0.29169223f, 0.19499804f, 0.07678194f, 0.11419262f, -0.04843260f, 
    -0.05724448f, -0.09436820f, -0.06093245f, -0.07343286f, 0.12761129f, 0.11333691f, 0.06946828f, 0.01410938f, 
    0.00645219f, 0.03477251f, -0.05657839f, 0.04812256f, -0.13854061f, -0.13967419f, -0.31493717f, 0.02292749f, 
    -0.10640848f, 0.07426861f, -0.13850102f, 0.05628535f, -0.00088158f, -0.03449927f, 0.39709023f, 0.13847202f, 
    -0.30525357f, 0.14425610f, -0.00370066f, 0.02435958f, 0.04446025f, -0.01621081f, -0.05923770f, -0.60381639f, 
    0.04254665f, 0.09283070f, 0.04416412f, 0.13606250f, 0.02441411f, -0.00627842f, 0.14978231f, -0.35119054f, 
    -0.18784516f, -0.03666629f, -0.01589874f, -0.10436057f, 0.11172887f, -0.00257445f, -0.09007924f, 0.07977401f, 
    -0.13398689f, 0.10529143f, -0.19521476f, 0.02695789f, -0.05993832f, 0.02683099f, 0.14240427f, -0.06447865f, 
    0.07849371f, 0.15495676f, 0.40198916f, 0.12484782f, 0.00079254f, 0.08454251f, -0.04640522f, 0.13679661f, 
    0.14943704f, -0.00544095f, 0.12356532f, -0.05559605f, -0.28574374f, 0.02364449f, -0.20351785f, -0.17141940f, 
    0.03828701f, -0.06638534f, 0.05026820f, 0.29799312f, 0.16588858f, 0.11365999f, -0.11510274f, 0.01321669f, 
    -0.10969772f, -0.01955737f, -0.03789654f, -0.01737386f, -0.09477894f, 0.02688993f, -0.03230333f, 0.02550032f, 
    -0.07603232f, -0.08113468f, -0.00966549f, 0.08580101f, -0.05033724f, 0.16852982f, 0.15935531f, 0.11781097f, 
    -0.09532373f, -0.04277347f, -0.00475277f, 0.08061814f, 0.05676657f, -0.06732614f, -0.20997214f, -0.02206124f, 
    -0.01989344f, -0.10252339f, 0.01991293f, -0.08793163f, 0.07873953f, -0.00837368f, -0.06863503f, 0.11741553f, 
    0.42072141f, 0.25791362f, -0.32031098f, -0.09022371f, -0.04497731f, 0.17456928f, -0.00730363f, -0.10775379f, 
    -0.24472944f, -0.15078153f, -0.08398116f, -0.01335349f, -0.16423672f, -0.09143131f, -0.07730027f, -0.07710577f, 
    -0.18768193f, 0.01953971f, -0.30824900f, 0.35550109f, -0.10215878f, -0.14306931f, 0.09829856f, -0.08536204f, 
    -0.12871151f, 0.07327406f, 0.03777421f, -0.01589646f, -0.02100263f, 0.12868284f, 0.02424544f, 0.01832166f, 
    -0.03789996f, 0.04192268f, -0.00494516f, -0.05039207f, 0.16898452f, -0.12068154f, -0.19690771f, 0.00922354f, 
    -0.02878073f, 0.07753561f, 0.02348665f, -0.05098407f, -0.09761790f, -0.24680027f, -0.01438400f, -0.00626604f, 
    0.04314522f, 0.18106495f, -0.01434673f, 0.13563612f, -0.00426020f, 0.03242355f, 0.27406153f, 0.40496829f, 
    -0.22083217f, -0.07973973f, -0.12089118f, -0.04407227f, 0.01742269f, -0.00768275f, 0.11737122f, -0.03412453f, 
    0.10905409f, 0.08887710f, 0.01983177f, 0.02316991f, 0.08317725f, 0.07745185f, 0.14905989f, 0.29183239f, 
    -0.17514503f, -0.01876985f, 0.00799628f, -0.12642969f, 0.04943212f, 0.05411405f, -0.05782105f, -0.13407214f, 
    -0.33936307f, 0.09053360f, 0.33021203f, -0.00324067f, 0.09241940f, 0.05765242f, 0.13218340f, 0.19658428f, 
    0.12944362f, 0.13401148f, -0.30602869f, 0.03283342f, 0.17017831f, -0.17180087f, -0.00080880f, 0.01003919f, 
    0.07909998f, 0.06811536f, 0.24197415f, -0.06524976f, 0.11468171f, 0.22985266f, -0.01598919f, 0.14430486f, 
    -0.09826051f, 0.04372393f, -0.09867657f, 0.11266477f, -0.14672214f, -0.17503549f, -0.16871266f, 0.00768009f, 
    -0.07227835f, -0.01954161f, -0.13137484f, 0.01487317f, -0.10210290f, -0.34672403f, -0.21588790f, -0.03352308f, 
    -0.00348012f, -0.16698129f, -0.00292630f, 0.09076109f, -0.02350166f, 0.09763724f, 0.21471103f, 0.08605844f, 
    0.05351520f, -0.08665679f, -0.00506845f, -0.02476760f, 0.08949868f, 0.05454169f, -0.09502353f, -0.09376417f, 
    -0.00780566f, -0.07738995f, -0.11196357f, 0.02937801f, -0.07878599f, -0.02470611f, 0.02250746f, 0.07984759f, 
    0.17536223f, 0.05258069f, -0.02078238f, 0.13883740f, -0.15105110f, 0.13860893f, 0.22880055f, -0.06694830f, 
    -0.03953616f, 0.04761881f, 0.02984137f, 0.02302369f, -0.06976470f, 0.02492327f, 0.07646718f, -0.07709416f, 
    -0.02953437f, 0.04616660f, 0.01313001f, -0.06337391f, 0.06459513f, 0.05989807f, 0.04924471f, 0.00291164f, 
    -0.02905897f, -0.08600401f, 0.06984890f, 0.07225156f, -0.03109549f, 0.07780358f, -0.01161050f, -0.05226246f, 
    0.01998386f, 0.05966852f, 0.00428971f, -0.01512824f, -0.05304119f, -0.05091794f, -0.00147516f, -0.03505115f, 
    0.06448764f, -0.08139181f, -0.07571419f, -0.05295929f, 0.05769586f, -0.01367311f, 0.04335470f, -0.05253921f, 
    0.00748817f, -0.08052316f, -0.00960407f, 0.03524245f, -0.07227037f, 0.00643470f, -0.03901146f, -0.05207936f, 
    -0.08406360f, -0.04173060f, 0.01309421f, -0.03372470f, 0.07483757f, -0.03798239f, 0.02608086f, -0.03570659f, 
    -0.00511517f, -0.07441906f, -0.00867900f, -0.08695846f, 0.05356202f, 0.05712353f, 0.04347409f, -0.04444799f, 
    0.07416936f, 0.03973768f, 0.04465883f, -0.04030156f, -0.07774623f, -0.03778636f, 0.07377125f, -0.02535355f, 
    -0.08965203f, 0.06482307f, -0.02283181f, -0.06280234f, 0.04281102f, -0.02286200f, -0.05320028f, -0.02297519f, 
    -0.00847780f, -0.00444010f, -0.04979414f, 0.00119243f, 0.01582988f, -0.08399527f, -0.07671530f, -0.01757026f, 
    -0.03198335f, -0.05427055f, -0.06096271f, -0.05667588f, -0.03638772f, -0.01416157f, 0.05468348f, 0.06100929f, 
    -0.08548644f, 0.05520186f, -0.01096149f, -0.01676720f, 0.05793528f, -0.05067671f, -0.02122075f, -0.04356078f, 
    -0.08028516f, -0.04542580f, -0.07883079f, 0.05450156f, -0.02320442f, -0.01597101f, -0.08523060f, 0.07930972f, 
    0.06983834f, 0.02194675f, -0.07479104f, -0.06549738f, -0.04556398f, -0.06869315f, -0.02333962f, -0.04221173f, 
    -0.05218874f, -0.07658760f, 0.01496093f, -0.05908823f, -0.07081014f, 0.04720975f, -0.06865475f, -0.04926862f, 
    -0.02849708f, -0.01031914f, 0.03873488f, -0.05784413f, -0.03892967f, 0.03481004f, 0.05390448f, 0.03328534f, 
    0.00852141f, -0.04153642f, -0.02403747f, -0.02535010f, 0.02667657f, 0.07629448f, -0.05524277f, -0.08231098f, 
    -0.01538526f, -0.00976328f, 0.06571177f, -0.04133680f, -0.05508532f, -0.01836404f, -0.08178145f, 0.03881653f, 
    0.04741066f, 0.00448237f, 0.06456644f, -0.00646217f, -0.00172148f, 0.01940832f, 0.01572049f, -0.04467598f, 
    0.02147468f, 0.06907387f, 0.01683200f, -0.07091707f, 0.01117058f, -0.09242629f, 0.02204604f, -0.03172752f, 
    -0.03539406f, 0.00102249f, -0.00185641f, -0.01681013f, 0.02433709f, -0.03144630f, 0.05344094f, -0.00712576f, 
    -0.07329890f, -0.06949148f, -0.09045411f, -0.01948968f, -0.02569241f, 0.00776829f, 0.00444529f, 0.00795089f, 
    -0.04762511f, -0.01522695f, 0.02240133f, -0.03743897f, -0.00355769f, -0.08856943f, 0.01329436f, 0.04642920f, 
    0.00727582f, -0.05574084f, -0.04646349f, 0.04820300f, -0.01711778f, -0.05013383f, -0.08556717f, 0.06516364f, 
    0.01112383f, -0.04357440f, -0.01239546f, -0.05501924f, 0.03567040f, 0.01697023f, 0.06516668f, 0.02715984f, 
    0.03158862f, -0.00176998f, -0.04080797f, 0.03753310f, -0.07889208f, -0.05160220f, -0.02351082f, -0.02957278f, 
    0.04478690f, 0.03378540f, -0.00320407f, 0.03849953f, -0.03917125f, -0.02002534f, -0.07274488f, 0.06970864f, 
    -0.05948135f, 0.05047606f, -0.06228985f, -0.00653317f, -0.01936444f, -0.00095526f, 0.04618210f, -0.04853387f, 
    0.00258056f, -0.02648169f, 0.05258369f, -0.00138903f, -0.00186925f, 0.05799426f, -0.03944259f, 0.03120703f, 
    -0.02489594f, 0.00409754f, -0.08777388f, 0.02922401f, -0.03212407f, -0.02829541f, -0.08348370f, 0.04148980f, 
    -0.04321663f, 0.00481193f, -0.09126470f, 0.03084261f, 0.04965870f, -0.05549644f, -0.07483015f, -0.09363626f, 
    -0.08154822f, -0.07283713f, -0.01293613f, -0.04565224f, -0.01682819f, -0.06072678f, -0.07346413f, -0.01941709f, 
    0.01619531f, -0.02639228f, -0.05190967f, 0.00567291f, 0.06853035f, -0.04937695f, 0.00209794f, 0.04097530f, 
    -0.09137972f, -0.05042877f, 0.05485774f, -0.09189903f, -0.00892375f, -0.05759406f, 0.01791806f, 0.02742696f, 
    0.03502517f, -0.02210533f, 0.05482341f, -0.04081194f, 0.04593457f, 0.00646348f, 0.02715436f, -0.08062605f, 
    0.08887774f, 0.00549411f, 0.02425751f, 0.10520958f, 0.04226520f, 0.30976003f, -0.12804778f, 0.23097712f, 
    -0.12355600f, -0.10022841f, 0.23905429f, 0.22707997f, -0.00644844f, 0.03281736f, -0.06516351f, 0.12989913f, 
    -0.12963989f, 0.22861825f, 0.13872190f, -0.13234998f, 0.10192794f, -0.08433753f, 0.09634575f, 0.08038301f, 
    0.03004976f, -0.00025243f, -0.20876318f, 0.21106368f, 0.07490558f, 0.11565536f, -0.00429619f, -0.03553035f, 
    0.02158208f, 0.08674872f, 0.05028651f, 0.15226270f, -0.11483548f, 0.25286153f, -0.04005409f, 0.00938947f, 
    0.09545951f, -0.18241349f, 0.06230408f, 0.13071088f, -0.15982711f, 0.05376163f, 0.02477579f, -0.13337353f, 
    -0.02549265f, -0.01260498f, 0.15129979f, 0.10657309f, 0.18554422f, -0.13230158f, -0.11062016f, -0.45730618f, 
    -0.02225717f, -0.10125642f, -0.01525543f, 0.10259286f, 0.08195516f, 0.05650241f, -0.13861635f, 0.12261294f, 
    0.02424948f, -0.07323294f, 0.03340355f, 0.02435205f, 0.13588144f, -0.02351498f, 0.01221678f, 0.24090397f, 
    -0.22612838f, 0.19392930f, -0.04087241f, -0.14321086f, -0.03382192f, -0.02721708f, 0.05553435f, -0.00254094f, 
    -0.11760195f, 0.42279673f, 0.16543384f, 0.07245960f, -0.12481283f, -0.06669626f, 0.00164303f, 0.20214848f, 
    -0.12054530f, -0.17708993f, 0.10077588f, -0.19874358f, -0.41287512f, 0.14349855f, -0.17199464f, 0.03634240f, 
    0.06072945f, -0.13100550f, 0.09246468f, -0.10015503f, -0.05581024f, -0.06851658f, 0.02868083f, -0.01422766f, 
    -0.01034055f, 0.00412948f, -0.10179944f, -0.29975003f, 0.05043035f, 0.10118476f, 0.35181832f, 0.01371614f, 
    0.10782269f, 0.00313093f, -0.06649271f, 0.10148452f, 0.06126827f, 0.01659045f, -0.04924474f, -0.00858568f, 
    0.10186329f, -0.03210167f, 0.04527043f, 0.09171822f, -0.06746313f, -0.51180303f, 0.12269155f, 0.13667960f, 
    0.02230663f, 0.05346946f, 0.17774972f, -0.09350089f, 0.11708594f, 0.11856414f, 0.13359630f, 0.19196171f, 
    -0.01151152f, -0.10846089f, -0.05699725f, -0.23694484f, -0.00150486f, 0.14030439f, 0.15611002f, 0.27032506f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.17228100f, -0.02171716f, 0.15698451f, 0.00792129f, 0.01398421f, -0.00140419f, 0.03479863f, -0.07614889f, 
    0.02647642f, 0.11013678f, 0.08381634f, 0.07819472f, 0.04485763f, 0.00998353f, -0.01180646f, 0.08577710f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08456863f, 0.27901313f, 0.57150930f, -0.02584546f, -0.20563087f, 0.34262583f, 0.18817581f, 0.05798735f, 
    -0.42100555f, -0.09626458f, 0.08648463f, -0.38987702f, -0.41638222f, 0.08643038f, 0.17130108f, -0.12203197f, 
    0.01812603f, -0.20165630f, -0.12815551f, 0.20822300f, -0.11212552f, 0.27986780f, 0.07006694f, 0.16040206f, 
    0.18010753f, 0.34734586f, -0.37498915f, 0.47307721f, 0.35010839f, -0.23087823f, -0.06510544f, -0.19243827f, 
    0.00058864f, -0.12266462f, 0.11095963f, 0.02805754f, 0.18088146f, -0.02968698f, -0.03529534f, -0.19704609f, 
    -0.08267752f, 0.02607062f, 0.28952187f, 0.13620797f, -0.09070466f, -0.00634789f, -0.15940268f, -0.14403728f, 
    0.47173852f, 0.17166354f, 0.28505385f, -0.11197825f, -0.08347622f, 0.29737869f, -0.15379749f, 0.22804137f, 
    0.14616291f, -0.09572150f, 0.23543039f, -0.46829376f, -0.52923763f, 0.05117767f, -0.06628368f, 0.20466395f, 
    -0.21255097f, -0.28628600f, -0.22549942f, 0.20938975f, -0.17213385f, 0.05250618f, -0.75832903f, -0.21612494f, 
    0.10238913f, -0.01372200f, -0.02102605f, 0.38985020f, 0.23385905f, 0.03054528f, -0.10696231f, -0.04105387f, 
    0.11771844f, -0.24927054f, 0.47053510f, -0.00803227f, -0.03585842f, 0.07291947f, -0.36232200f, -0.11928666f, 
    0.43572631f, 0.25433764f, -0.47095576f, 0.25692430f, -0.21151690f, 0.07203269f, 0.00245503f, 0.24907582f, 
    -0.13865653f, -0.18080585f, -0.15533496f, 0.35152313f, 0.04913047f, -0.15325974f, -0.36449090f, 0.11166503f, 
    0.45357013f, -0.14651701f, -0.02377807f, 0.39003342f, 0.01211968f, 0.23405255f, 0.18990454f, -0.04147876f, 
    0.03590872f, 0.04273247f, 0.10910504f, -0.28122962f, 0.03282434f, -0.18756606f, -0.20891805f, -0.14500740f, 
    -0.14741136f, 0.40266398f, 0.21631283f, -0.33974308f, 0.17114320f, 0.18536317f, -0.09877329f, 0.30184120f, 
    -0.05948751f, 0.17080580f, -0.02925407f, -0.09978280f, -0.11287721f, 0.21678054f, -0.02037740f, -0.10842837f, 
    -0.33562610f, 0.09080065f, -0.05572020f, -0.15176557f, 0.18960944f, 0.05541280f, -0.22371173f, 0.22490801f, 
    -0.06473234f, -0.07434005f, -0.14870821f, -0.00114199f, 0.09942392f, -0.23561411f, -0.12380444f, -0.24829012f, 
    -0.30777860f, -0.28657785f, 0.08939629f, -0.24434261f, 0.07227000f, -0.21495649f, 0.19359022f, -0.12269458f, 
    -0.27187362f, -0.01185479f, 0.08173655f, 0.25661933f, 0.04152143f, 0.20531969f, 0.25143668f, -0.04048182f, 
    -0.08300525f, -0.07837053f, -0.15094559f, 0.41047090f, -0.10016102f, -0.16331598f, -0.16917703f, -0.16217735f, 
    -0.16922434f, -0.02391001f, -0.10432150f, -0.15146910f, -0.10633308f, 0.42181367f, -0.11310820f, -0.06635011f, 
    0.11857693f, 0.04047933f, -0.41241714f, -0.02088637f, -0.39229318f, -0.08785060f, -0.12443069f, 0.25067812f, 
    -0.02004158f, 0.36916959f, 0.57583696f, -0.27442807f, -0.20116889f, 0.07763848f, 0.13152666f, -0.24463549f, 
    -0.48609224f, -0.09390721f, -0.47943845f, 0.11359137f, 0.26692414f, -0.15241323f, -0.25078997f, 0.34378263f, 
    0.22475623f, 0.00135595f, -0.10724375f, -0.06877521f, 0.12107614f, -0.03759323f, 0.13365449f, -0.15846770f, 
    -0.30960557f, 0.23957366f, 0.25532901f, -0.53156847f, -0.40166870f, 0.08216304f, 0.00517459f, 0.20765325f, 
    0.50238836f, 0.10190511f, 0.26226488f, -0.38040504f, 0.13617001f, 0.33481944f, -0.03326890f, -0.20295331f, 
    -0.41595411f, 0.41816661f, 0.34741518f, -0.14100900f, -0.30683434f, 0.05650200f, -0.10830995f, -0.15386569f, 
    -0.49953872f, -0.24246742f, 0.19653034f, -0.10926177f, -0.24170554f, 0.13222711f, -0.24913464f, -0.10745993f, 
    0.34798762f, 0.35552797f, -0.63587004f, -0.24472198f, -0.05889093f, -0.04950286f, 0.14430445f, 0.28839239f, 
    -0.03817767f, -0.29291719f, 0.21304734f, -0.11664704f, 0.18118365f, 0.31831634f, 0.35753232f, -0.09132886f, 
    0.11185917f, 0.03703727f, -0.33125335f, 0.40344924f, 0.27531925f, -0.00081405f, 0.14452426f, 0.09969803f, 
    -0.16694441f, 0.20116302f, 0.24002951f, -0.20471448f, -0.17822129f, -0.14924911f, -0.20250174f, -0.08516759f, 
    0.15416321f, 0.00243369f, 0.02267033f, 0.13730964f, -0.20648456f, 0.00295353f, -0.07414708f, -0.15970945f, 
    -0.02496471f, -0.32241198f, 0.35661307f, 0.15408680f, -0.21312952f, -0.02681864f, 0.31850433f, -0.04910076f, 
    -0.19096078f, -0.32253331f, -0.25206423f, -0.25195524f, -0.21313947f, 0.23126823f, -0.13101293f, 0.40687898f, 
    0.57259768f, -0.05336680f, 0.01197817f, -0.18433513f, -0.02837602f, 0.05387096f, -0.49179068f, 0.18618073f, 
    0.40138635f, 0.45553371f, 0.23249471f, 0.01098298f, 0.06897245f, 0.02847454f, -0.03498791f, -0.07304043f, 
    -0.21947947f, -0.07779536f, -0.08485618f, 0.07213989f, -0.14634290f, -0.20170349f, -0.11219639f, 0.07410705f, 
    -0.08011478f, -0.11310846f, -0.10118613f, -0.19580519f, -0.22285476f, 0.09378004f, -0.20233449f, -0.13885286f, 
    0.21018688f, -0.04916633f, 0.19369982f, 0.12642163f, 0.18523434f, -0.23538448f, -0.12907739f, -0.08981066f, 
    0.27961844f, 0.03842692f, 0.07728434f, -0.04646070f, -0.30730695f, 0.08267915f, 0.07650687f, 0.27205423f, 
    -0.24393418f, 0.09207956f, 0.13910891f, 0.23538293f, -0.04034710f, 0.12820856f, -0.05801005f, 0.20617577f, 
    0.36253315f, -0.13086672f, -0.32543734f, 0.31557342f, 0.32829183f, 0.19538775f, 0.14129412f, -0.16632049f, 
    0.05568252f, -0.42142510f, -0.21259259f, 0.20583859f, 0.12772660f, -0.35820994f, -0.34301445f, 0.03368321f, 
    0.14740412f, 0.34729227f, -0.09551571f, 0.24124837f, 0.36121055f, -0.18498670f, 0.20643665f, 0.12968764f, 
    -0.36593550f, 0.22121090f, 0.31809956f, -0.25615031f, 0.06379233f, 0.08792538f, -0.35501572f, 0.22380741f, 
    0.13248949f, 0.37123874f, 0.33390382f, 0.02151021f, -0.22314942f, 0.12614574f, 0.04161194f, 0.21526541f, 
    0.35859731f, 0.15936403f, -0.10180519f, -0.03931771f, -0.20340444f, 0.27838209f, 0.10453935f, -0.20748243f, 
    0.27383435f, -0.16300188f, -0.12292908f, 0.46871191f, 0.19166969f, 0.08415395f, 0.25380346f, -0.20391309f, 
    0.12821503f, 0.06357304f, -0.21404104f, -0.18919322f, 0.20259227f, 0.29712775f, 0.19972861f, 0.18189298f, 
    -0.20090465f, 0.18285388f, -0.12893040f, -0.14389686f, 0.18939957f, -0.16621616f, 0.05003709f, 0.29537958f, 
    -0.21369375f, -0.04193389f, -0.63145888f, -0.08483319f, -0.18470231f, 0.38396606f, 0.20466365f, -0.17639598f, 
    -0.24887905f, 0.17713322f, 0.26455179f, 0.32331336f, -0.55214882f, -0.13156590f, 0.17840320f, -0.10193166f, 
    0.54815763f, -0.06087781f, 0.02300210f, 0.23117830f, 0.10507323f, 0.01582006f, 0.29196388f, -0.22035956f, 
    0.02092877f, 0.07078854f, -0.27548712f, -0.32806286f, -0.02175438f, -0.21697661f, 0.12349096f, 0.19469367f, 
    0.31481314f, -0.14994909f, -0.21048786f, -0.01723851f, 0.12124823f, 0.14878087f, 0.00847163f, -0.00560882f, 
    -0.00738716f, 0.48971805f, 0.00804049f, -0.26043242f, 0.02568219f, 0.13713785f, -0.00924494f, -0.04980307f, 
    0.07981147f, -0.08524457f, -0.24716051f, -0.09276035f, 0.11654961f, -0.11473516f, -0.21051334f, 0.24158260f, 
    0.00872217f, -0.07860804f, -0.08797264f, -0.21212742f, 0.20577148f, 0.06469110f, -0.16584545f, -0.09313777f, 
    0.32520732f, -0.06461588f, 0.07772242f, 0.20415518f, -0.19534935f, -0.19179416f, 0.27987349f, 0.23334150f, 
    0.28257120f, -0.24943118f, -0.06459242f, -0.29704371f, -0.22347930f, 0.02914713f, -0.01871120f, 0.07452621f, 
    -0.06153993f, 0.52448255f, 0.33495483f, 0.25357908f, 0.02983587f, -0.07592268f, 0.13351980f, -0.12182534f, 
    -0.42148766f, -0.15351978f, -0.01541266f, -0.20376310f, -0.02155251f, 0.10976412f, -0.21039790f, -0.16324735f, 
    -0.25705776f, 0.39018127f, 0.47208670f, -0.33394316f, 0.19102013f, 0.25916246f, -0.20830576f, 0.23025277f, 
    0.17299148f, -0.19765864f, -0.22472186f, 0.16880116f, 0.11326584f, -0.05220801f, -0.01163045f, 0.10984343f, 
    -0.32566714f, -0.28172815f, -0.04266565f, -0.10362302f, -0.07187232f, -0.16472666f, 0.08080675f, -0.04480438f, 
    -0.18258615f, 0.16410889f, 0.45819238f, -0.03268073f, -0.08677354f, 0.16324408f, -0.16753909f, 0.30246967f, 
    0.07864051f, 0.42547858f, 0.53990358f, 0.07542823f, 0.17526948f, -0.20111139f, 0.20616890f, -0.11314306f, 
    -0.34902069f, 0.21638297f, -0.01849532f, 0.56321102f, -0.41434965f, 0.19846934f, -0.06240934f, -0.13496827f, 
    -0.02299615f, 0.03555868f, -0.31765541f, 0.04006109f, -0.09970436f, -0.22248483f, -0.18510693f, 0.07737038f, 
    -0.43274751f, 0.43182790f, 0.11179945f, 0.25010961f, -0.02749156f, -0.04994770f, -0.21179444f, 0.23885423f, 
    0.33069274f, -0.21648218f, -0.43227905f, -0.05224795f, 0.00781397f, -0.09133327f, -0.18239763f, 0.11565252f, 
    0.19398415f, 0.18721516f, 0.16064613f, 0.08651793f, 0.19300659f, -0.14081001f, -0.15790974f, 0.18213238f, 
    0.01053694f, 0.06704699f, 0.23914596f, -0.18069689f, 0.17667705f, 0.20917550f, 0.04375918f, -0.09780588f, 
    -0.47853515f, 0.48819247f, 0.36289233f, -0.13957426f, -0.25101513f, -0.13933049f, 0.01267472f, -0.17410982f, 
    0.42279276f, 0.16025090f, -0.06405226f, 0.12245011f, -0.15082270f, 0.20268247f, -0.31840554f, -0.19212189f, 
    -0.14663978f, 0.21120301f, 0.03386824f, -0.20699567f, -0.07332023f, -0.18712914f, 0.24025206f, -0.11910933f, 
    -0.13790588f, 0.05398343f, 0.11254090f, -0.01793536f, -0.01799747f, 0.11998743f, -0.05686284f, -0.03552228f, 
    -0.20814656f, -0.05652989f, -0.23589244f, -0.24879888f, -0.06104866f, -0.12527058f, -0.11365023f, -0.22834791f, 
    -0.32570085f, 0.31272236f, -0.55268377f, -0.13107477f, -0.01116952f, 0.30467218f, 0.12039717f, -0.08196332f, 
    -0.02753374f, -0.22865109f, -0.19968258f, -0.13539192f, 0.02042147f, 0.01190273f, 0.13944666f, 0.23155473f, 
    0.23689099f, -0.30174702f, -0.24541526f, 0.01652686f, 0.15239920f, 0.10826374f, 0.13979143f, 0.16693859f, 
    0.34737170f, -0.46753412f, 0.13340533f, -0.16033761f, -0.10909872f, -0.18503956f, 0.03267393f, 0.30168682f, 
    -0.15687457f, 0.15384383f, 0.22306232f, -0.07996266f, 0.00451529f, 0.41410813f, 0.38911414f, 0.16363102f, 
    -0.29667550f, -0.22245063f, -0.16321898f, -0.26373431f, 0.15988098f, -0.16845009f, -0.04185799f, 0.03178496f, 
    0.50765133f, -0.21010140f, 0.06193125f, -0.24713613f, -0.10303874f, -0.09442189f, -0.29134750f, -0.21785225f, 
    0.16863251f, 0.14447655f, 0.53165728f, 0.27111104f, -0.29362515f, -0.17759754f, -0.23175283f, 0.08207294f, 
    0.55322206f, -0.41908598f, 0.13610177f, -0.26386499f, -0.05417981f, -0.15037782f, -0.11430539f, 0.23495503f, 
    0.37156421f, 0.14107612f, 0.32584971f, 0.28468093f, -0.15809406f, -0.11113061f, 0.08028007f, 0.30283228f, 
    0.58068097f, -0.29648611f, 0.39179990f, -0.13901387f, 0.19343854f, 0.11471149f, 0.16519597f, 0.06523074f, 
    0.41248468f, -0.00287160f, 0.03442917f, -0.53346741f, -0.07553005f, -0.09499498f, -0.25847709f, -0.16581236f, 
    -0.01231981f, -0.13520049f, 0.33045086f, -0.10849752f, -0.12732905f, 0.40521580f, 0.06927145f, 0.15937307f, 
    0.39904547f, 0.05013560f, -0.28209412f, 0.14012781f, -0.33376408f, -0.01914319f, -0.06607091f, 0.15133531f, 
    -0.03868886f, -0.36508510f, 0.23557605f, 0.31101200f, -0.15540576f, -0.09849521f, 0.41277763f, 0.02748311f, 
    -0.15732183f, -0.18616538f, -0.19565035f, 0.05953204f, 0.17015868f, 0.13431004f, 0.04209589f, -0.02326223f, 
    -0.21384633f, -0.16915287f, -0.13704118f, -0.04869989f, -0.18658856f, -0.01588515f, 0.21347328f, -0.14412445f, 
    -0.00795435f, -0.20847782f, -0.21909286f, 0.14652105f, -0.09617810f, -0.02824005f, -0.04801521f, -0.18804638f, 
    -0.08665590f, -0.16223449f, 0.10066827f, -0.17624637f, 0.07298294f, -0.19346617f, 0.18434301f, 0.22505796f, 
    0.10113981f, -0.16235538f, -0.05833297f, -0.20322639f, -0.20524681f, -0.23893663f, 0.10823837f, 0.13387051f, 
    0.03724192f, -0.52546722f, 0.08378704f, 0.12468047f, -0.16538434f, -0.22854903f, 0.33194664f, 0.07526923f, 
    0.18155964f, -0.02112278f, 0.20229600f, 0.19804718f, -0.22201703f, 0.18380210f, -0.13740839f, 0.27376708f, 
    0.37743303f, 0.17363372f, -0.44535953f, 0.21864977f, -0.05198796f, 0.04615906f, 0.09507751f, 0.16336149f, 
    0.33004224f, -0.16306888f, -0.02817334f, 0.31625900f, -0.29274529f, -0.13893327f, 0.05055374f, -0.17285720f, 
    -0.10098466f, -0.21595311f, -0.29670408f, 0.40464231f, -0.03077284f, 0.26099840f, 0.39975277f, -0.12618275f, 
    -0.23318370f, 0.08499482f, -0.30801851f, -0.00218216f, -0.05538698f, 0.11311075f, 0.15713000f, -0.02430361f, 
    0.56020659f, -0.20323192f, -0.09901736f, -0.00979907f, 0.00191277f, -0.21292445f, -0.36386934f, -0.07048459f, 
    -0.18900995f, 0.35219997f, 0.36388201f, -0.06524134f, -0.20666318f, 0.23472285f, -0.23564705f, 0.05718227f, 
    -0.08247252f, -0.35781133f, 0.46887082f, -0.09799499f, -0.20523432f, 0.08270685f, 0.38490075f, -0.07403490f, 
    -0.53223860f, -0.22543561f, 0.06681596f, -0.23808438f, -0.50820118f, 0.21274276f, -0.00501686f, 0.30601195f, 
    -0.42224571f, -0.20455781f, -0.49132845f, 0.12331236f, 0.21793403f, 0.00868510f, -0.33611217f, 0.01691110f, 
    0.14450069f, 0.16523497f, -0.03202615f, 0.07545900f, 0.07857519f, 0.07771888f, -0.07582790f, 0.30712321f, 
    0.15439688f, -0.12721159f, 0.27979398f, 0.26208964f, 0.12632725f, -0.20489168f, -0.11225746f, 0.04035025f, 
    0.03823405f, -0.24050839f, -0.21799155f, -0.19635786f, -0.40140447f, 0.22578189f, 0.00699290f, 0.36671770f, 
    0.42287394f, -0.10455588f, -0.24534740f, 0.20827475f, 0.14497921f, 0.13119036f, 0.02291560f, -0.08859154f, 
    0.20806497f, 0.20327444f, -0.23477288f, -0.53310430f, -0.19515434f, -0.20221150f, -0.07700574f, 0.18021098f, 
    0.37146261f, 0.24593690f, 0.52539855f, 0.05262811f, 0.08273581f, 0.14426383f, 0.44469553f, 0.04806834f, 
    -0.26888761f, -0.00608425f, -0.28642738f, 0.43033499f, 0.20861432f, 0.09568307f, 0.24363106f, -0.27700064f, 
    0.36537465f, -0.28972474f, -0.12537058f, 0.30790576f, 0.05906053f, -0.19721192f, 0.09705092f, -0.07278904f, 
    0.19660379f, -0.22017434f, 0.04631441f, 0.06017018f, 0.01445615f, -0.25252455f, -0.13858275f, 0.25276598f, 
    0.32985729f, -0.28859651f, 0.01009253f, -0.15444367f, 0.09110698f, 0.40790263f, -0.05014784f, -0.00170310f, 
    0.21543166f, -0.00620708f, -0.23671180f, 0.01868768f, 0.11886982f, -0.20512938f, -0.22224900f, 0.27785310f, 
    -0.51734090f, 0.09582260f, 0.04322942f, -0.24658625f, -0.24535933f, 0.04875144f, -0.37132880f, -0.14146763f, 
    -0.78105485f, 0.29845703f, -0.36465192f, 0.10643013f, -0.59493518f, 0.16696417f, 0.12409690f, 0.20828167f, 
    0.28137109f, 0.02868145f, 0.30866015f, -0.30247942f, 0.17583154f, 0.36024690f, -0.16885422f, 0.04912191f, 
    -0.49071303f, 0.31816256f, -0.10588462f, -0.15755819f, -0.44725206f, -0.21077673f, -0.07955045f, 0.25844410f, 
    -0.63523072f, 0.39075568f, 0.26934153f, 0.01650851f, -0.02974311f, -0.25959313f, -0.38428122f, -0.00647178f, 
    -0.22471726f, 0.13397062f, 0.33198664f, 0.40841043f, 0.18539923f, 0.08191693f, -0.08155805f, -0.29796159f, 
    0.37467375f, 0.40469429f, 0.30144897f, -0.14173381f, 0.06508677f, 0.40595210f, -0.00593065f, -0.23067346f, 
    0.30264735f, -0.10290755f, 0.03670188f, 0.27167416f, -0.11639502f, -0.10454810f, -0.24557038f, -0.05306958f, 
    0.08391312f, 0.04780135f, 0.11445856f, -0.03946266f, 0.17088062f, -0.07139573f, -0.04702941f, -0.06305256f, 
    0.00252083f, -0.15236712f, 0.05036744f, -0.13212135f, -0.17074236f, -0.07328311f, 0.00009581f, -0.11466512f, 
    0.33733180f, 0.03556652f, 0.28678620f, -0.19547632f, -0.04155723f, 0.08346074f, 0.23981811f, -0.06000165f, 
    -0.48439667f, 0.15547854f, 0.21710791f, -0.12618685f, -0.12946104f, 0.02089013f, 0.05079183f, 0.14182293f, 
    0.09270739f, -0.18484542f, -0.00911481f, 0.12281918f, 0.01281791f, -0.11858244f, 0.08771700f, -0.03755253f, 
    -0.27737060f, 0.24566685f, -0.02431265f, -0.04070104f, 0.06787784f, 0.05626924f, 0.18562315f, 0.00392714f, 
    -0.00653963f, -0.03059256f, 0.37245309f, -0.12907758f, -0.05449501f, 0.38393134f, 0.45406103f, -0.08143078f, 
    -0.23665032f, -0.04343655f, 0.00030715f, -0.05129275f, -0.18567763f, -0.19121689f, -0.11125511f, 0.24974331f, 
    0.09976761f, 0.34362626f, -0.08991864f, -0.03647951f, -0.02583425f, -0.70818216f, 0.15238434f, 0.22941346f, 
    0.32543480f, -0.82400084f, 0.07346561f, -0.04759705f, 0.15349920f, -0.00992982f, 0.23412237f, -0.32064289f, 
    0.37403685f, -0.45973170f, -0.11660770f, 0.26388034f, -0.17617154f, 0.05490097f, 0.11811323f, 0.04950803f, 
    0.19208549f, -0.28492168f, -0.26332432f, 0.37438452f, 0.09290433f, 0.06937350f, -0.02191556f, 0.17258309f, 
    0.18818440f, -0.15737578f, 0.48822808f, 0.09021364f, 0.24790409f, -0.11088313f, 0.06462632f, 0.17247057f, 
    -0.08946252f, -0.23260984f, -0.00355859f, 0.07530353f, -0.50548261f, 0.12478481f, -0.17040524f, 0.18637484f, 
    -0.24018174f, 0.01766112f, -0.23039928f, -0.24696958f, -0.17212838f, -0.14540163f, 0.01764610f, 0.01648900f, 
    -0.12172845f, 0.17843139f, -0.10583010f, 0.08678150f, 0.14911702f, 0.24759039f, 0.17801949f, -0.10214260f, 
    -0.21825632f, -0.11583999f, -0.00694072f, -0.05870360f, -0.01685241f, -0.13840047f, -0.09240031f, -0.19890285f, 
    -0.19581142f, -0.22469211f, -0.07748228f, -0.07265201f, -0.15412903f, 0.03307828f, -0.06160340f, 0.02303749f, 
    0.01376903f, -0.30787387f, -0.24889907f, 0.10684707f, 0.04731199f, 0.25355411f, -0.37852412f, -0.11759546f, 
    -0.03102265f, 0.49978969f, -0.16427732f, 0.21170941f, -0.28484535f, -0.08107713f, -0.13842255f, 0.06505623f, 
    -0.60211867f, 0.24136974f, 0.13967842f, -0.16140968f, 0.01831818f, -0.04043376f, -0.41836724f, -0.02395469f, 
    -0.05762592f, 0.33599666f, -0.50030607f, 0.37323788f, -0.69642133f, 0.14566424f, -0.23564503f, 0.04474374f, 
    0.40719402f, 0.09878210f, 0.00350148f, 0.24615531f, 0.23150918f, -0.31885561f, -0.00538285f, 0.02098668f, 
    -0.17541416f, 0.21624123f, -0.02102549f, -0.28883818f, -0.39087445f, -0.09517848f, -0.17763196f, 0.18121324f, 
    0.28530800f, 0.23330294f, 0.08441460f, 0.08038317f, 0.06796156f, -0.28297791f, -0.20591459f, 0.04154955f, 
    -0.04102775f, 0.39533249f, -0.17488915f, -0.29735830f, -0.10665873f, -0.24569908f, 0.24129303f, 0.09124639f, 
    0.02646043f, -0.37965232f, 0.39398342f, 0.28703907f, -0.06150382f, -0.17375529f, -0.28895393f, -0.14528187f, 
    -0.38274509f, 0.26751748f, -0.10725930f, -0.04281595f, -0.49891126f, 0.19902302f, 0.00144789f, 0.20563757f, 
    0.10163394f, 0.06672429f, -0.19188276f, 0.13572724f, -0.23504031f, -1.05104518f, 0.14485149f, -0.17998484f, 
    0.12357210f, -0.52019918f, 0.16246447f, -0.21269551f, 0.19818398f, 0.09754008f, 0.19749480f, -0.47666299f, 
    -0.05427928f, -0.05618425f, -0.14913417f, -0.12145161f, -0.15643719f, -0.34984505f, -0.24502485f, -0.20659021f, 
    0.17577510f, 0.13649213f, 0.00366932f, 0.22678833f, 0.31667891f, 0.04834906f, 0.07237694f, 0.29532492f, 
    -0.04014084f, 0.00326954f, 0.45495564f, 0.18386139f, 0.19850293f, -0.05290442f, -0.12656792f, 0.10228444f, 
    -0.06836385f, -0.23382562f, 0.02305539f, -0.50634754f, -0.10196320f, -0.24500462f, 0.03051569f, 0.24012844f, 
    -0.12005119f, -0.23464771f, -0.11200920f, 0.08048878f, -0.13221258f, -0.19193907f, -0.14244339f, 0.04181327f, 
    -0.25627980f, 0.40869591f, -0.07093551f, -0.09135237f, -0.11866827f, 0.18192428f, 0.21515772f, 0.39734581f, 
    -0.24294366f, -0.33398154f, -0.15399490f, -0.08522990f, 0.14014919f, 0.17229518f, 0.22761658f, 0.05961758f, 
    0.26954567f, 0.23909575f, -0.30013111f, 0.30214301f, 0.33053678f, 0.18643779f, -0.08275727f, 0.10739666f, 
    0.14111024f, -0.21415216f, -0.08063979f, -0.14321074f, 0.14772582f, -0.12677862f, -0.20855655f, -0.18292597f, 
    -0.04479150f, 0.11598476f, -0.07543737f, -0.19407158f, -0.08625436f, 0.05672085f, 0.13941279f, 0.11114676f, 
    0.21352859f, -0.24385482f, 0.53592092f, 0.22474968f, 0.16595006f, 0.17441580f, -0.28663793f, 0.06737608f, 
    0.27819866f, -0.10033229f, 0.09081973f, -0.34744066f, -0.54969144f, -0.10790200f, 0.09170759f, -0.17790678f, 
    -0.14296728f, 0.08741945f, -0.20781174f, -0.18586093f, -0.07125208f, -0.19404086f, -0.18334302f, -0.12625495f, 
    0.02084079f, 0.02725112f, -0.22293004f, 0.17301667f, -0.09133023f, 0.09141639f, -0.13286537f, -0.03106081f, 
    -0.31203464f, -0.15647039f, 0.20220490f, 0.21178676f, -0.21367903f, 0.15224476f, 0.01078734f, 0.17651282f, 
    -0.51524144f, -0.12329892f, 0.24983954f, 0.07308097f, -0.11372969f, -0.06028463f, 0.23848927f, -0.16870990f, 
    -0.16583580f, -0.04049486f, -0.19093102f, -0.23041058f, -0.13610610f, -0.01890236f, -0.07998681f, 0.07780135f, 
    -0.13604730f, -0.13080806f, -0.09604686f, -0.19315514f, -0.03685060f, -0.02360755f, -0.07282332f, 0.21956265f, 
    -0.35483408f, 0.04745614f, 0.47162867f, 0.22594197f, -0.17934754f, 0.13996612f, 0.17704289f, 0.05918157f, 
    -0.41809899f, -0.30568361f, 0.10739187f, -0.13496017f, -0.34763551f, -0.09182832f, -0.13926053f, -0.05536265f, 
    0.34979966f, -0.00732686f, 0.00814228f, 0.21790868f, -0.04339563f, -0.04640149f, -0.59805572f, -0.20350777f, 
    0.21739742f, -0.14078268f, -0.06405680f, -0.15047455f, 0.09180318f, -0.13483530f, 0.08945923f, -0.14056292f, 
    0.09986369f, -0.05932377f, 0.20367360f, -0.02719462f, -0.01540098f, 0.45028189f, 0.44106147f, -0.16165677f, 
    0.00218023f, -0.13733366f, -0.21644606f, 0.34401801f, 0.15747945f, 0.04278487f, -0.09812951f, -0.05441621f, 
    -0.04943081f, -0.42810673f, -0.19956715f, 0.31144744f, -0.11386502f, -0.00639558f, -0.05461062f, 0.21906483f, 
    0.40606546f, -0.08605416f, -0.18750289f, 0.43852180f, 0.01937930f, 0.01602663f, -0.01036282f, 0.00134632f, 
    0.15074371f, -0.54323190f, 0.31817994f, 0.29662839f, 0.21083933f, 0.25767526f, 0.08839250f, -0.12590303f, 
    0.04585810f, -0.35880500f, -0.21674144f, 0.14206983f, -0.14405392f, -0.19630691f, 0.07651763f, -0.00387764f, 
    0.51722717f, -0.05909364f, -0.04929294f, -0.10818116f, -0.22453976f, 0.14314140f, 0.45015109f, -0.10716708f, 
    0.45368585f, -0.17691675f, -0.15334734f, 0.15153630f, -0.02708655f, 0.04880339f, 0.21015379f, 0.03121491f, 
    -0.22026466f, 0.28125170f, -0.43181503f, -0.01774853f, 0.11579427f, 0.39496380f, 0.09508520f, 0.18593009f, 
    -0.07417919f, 0.10096157f, 0.21534194f, 0.14796376f, -0.13740695f, -0.18746872f, -0.05257681f, 0.18810783f, 
    0.04418671f, -0.09442648f, -0.03948003f, -0.07426401f, 0.08185312f, 0.05037938f, -0.13289106f, -0.19962651f, 
    -0.04761500f, 0.12985353f, -0.23491816f, -0.15013120f, 0.16466758f, -0.17356572f, 0.19873226f, -0.19051443f, 
    0.00292805f, -0.07836222f, -0.29808775f, 0.01993130f, -0.22501956f, 0.06601637f, 0.03391914f, 0.04083042f, 
    -0.27193844f, 0.03821497f, 0.03407595f, -0.51745898f, -0.11827666f, -0.07866461f, 0.13754569f, 0.29786709f, 
    -0.38263330f, 0.03782097f, -0.07104048f, 0.14928007f, -0.02905408f, -0.21697037f, -0.48661456f, -0.20661007f, 
    0.33960453f, 0.37811184f, -0.01707293f, 0.22248679f, 0.23768960f, 0.01799377f, -0.13986242f, -0.11388954f, 
    0.43911251f, 0.10713131f, -0.18446591f, -0.14085239f, 0.15358947f, 0.29014719f, 0.00819920f, -0.20861115f, 
    0.16428845f, 0.05328615f, 0.21876495f, 0.37357923f, -0.06524356f, -0.00713899f, -0.12752356f, -0.35738394f, 
    0.12890325f, -0.09229770f, -0.19434366f, 0.25349724f, -0.18892308f, -0.12899566f, -0.03919001f, -0.07818444f, 
    0.27757838f, -0.16037066f, -0.00240759f, 0.13873467f, -0.04452686f, -0.20062061f, -0.00062117f, -0.11059434f, 
    -0.25099316f, 0.01963192f, 0.02062836f, 0.27135995f, 0.04591971f, 0.07647890f, 0.17909969f, 0.14625372f, 
    0.34973103f, -0.32030275f, -0.43701795f, 0.16975309f, 0.11646063f, 0.15072630f, -0.08118232f, 0.17384848f, 
    -0.26886898f, 0.19716211f, -0.59020448f, 0.23321562f, 0.16849847f, 0.20639989f, -0.23692955f, -0.14758185f, 
    -0.11055839f, 0.01477419f, -0.35799363f, 0.35927603f, 0.22342020f, 0.04811112f, 0.05951797f, 0.16123787f, 
    0.19630636f, -0.03076807f, 0.09697223f, -0.02959007f, -0.01047367f, -0.14305912f, -0.37707028f, -0.18079264f, 
    0.12462109f, 0.19431901f, -0.07307453f, -0.19664198f, 0.15133828f, -0.20274511f, 0.14617987f, 0.13651104f, 
    0.28514618f, 0.03562880f, -0.12493285f, -0.11268188f, -0.04481117f, 0.06254600f, -0.16734515f, -0.13945483f, 
    0.40370637f, 0.35280886f, 0.13721545f, 0.26994011f, 0.18843915f, 0.19414750f, -0.18823482f, -0.20628490f, 
    -0.28758898f, 0.06235194f, -0.24098316f, 0.29874834f, -0.00904099f, -0.28356510f, -0.28641936f, -0.07352345f, 
    0.37112036f, -0.24404952f, -0.06537400f, -0.28478608f, 0.02663906f, -0.15214573f, 0.23862080f, 0.36889204f, 
    0.20811303f, 0.12049862f, -0.43469012f, -0.00443351f, 0.02549945f, 0.09134217f, -0.35978246f, 0.07413249f, 
    -0.07231414f, 0.11538646f, 0.00733080f, 0.31250843f, -0.06211949f, -0.18290471f, -0.12389112f, 0.16807699f, 
    -0.25903997f, -0.46173880f, -0.13952042f, 0.24732339f, -0.04544199f, -0.21550442f, 0.25866380f, -0.01381425f, 
    -0.03505094f, 0.19342564f, 0.09932767f, 0.08007769f, -0.14609037f, -0.20152001f, 0.00055490f, 0.19714102f, 
    -0.16705553f, -0.42277578f, 0.06688548f, 0.25744522f, -0.06172070f, 0.17972107f, -0.38226554f, -0.23076093f, 
    -0.12995757f, -0.22477481f, 0.09386320f, -0.38647407f, 0.16473280f, -0.16996509f, -0.23721746f, -0.23861143f, 
    -0.59717137f, -0.29079652f, -0.10950096f, 0.21111372f, 0.17368504f, 0.13634622f, -0.22066654f, -0.18452772f, 
    0.18444033f, 0.20387994f, -0.42849809f, 0.42658615f, -0.44325864f, -0.11331630f, -0.21657914f, 0.04459352f, 
    -0.38079590f, 0.10160495f, -0.36616418f, 0.15266719f, 0.10171518f, -0.21759748f, -0.10802820f, 0.03204153f, 
    0.15321156f, 0.36164638f, -0.33343598f, -0.13327569f, 0.41172937f, 0.17146285f, 0.11841853f, 0.05728735f, 
    -0.14809385f, -0.46312022f, 0.03976836f, 0.29933795f, -0.04451820f, 0.01521804f, 0.33251432f, -0.07545958f, 
    -0.39944017f, -0.16327554f, -0.31692824f, 0.37924755f, 0.01039795f, 0.08511113f, 0.02782746f, 0.14968914f, 
    -0.02030858f, -0.24019517f, -0.20566793f, -0.12671891f, 0.09801647f, 0.05771570f, -0.23766547f, 0.21200705f, 
    0.05963090f, -0.19456185f, -0.21603113f, 0.17875022f, -0.07617661f, 0.19397712f, -0.09265327f, 0.00794363f, 
    0.16992307f, -0.21826023f, -0.21421558f, -0.15600577f, -0.01446411f, -0.15475062f, 0.11223388f, 0.14154208f, 
    -0.14816436f, -0.23694700f, 0.20000893f, -0.17895916f, -0.12239969f, 0.21699068f, -0.21318364f, -0.23076323f, 
    0.13563131f, -0.04315729f, 0.12353539f, -0.16955657f, -0.23453757f, -0.00639366f, -0.18307330f, -0.21010530f, 
    0.15303627f, -0.16408637f, -0.24455267f, -0.05069657f, -0.17825839f, 0.02399755f, 0.01094841f, -0.01461575f, 
    -0.24161251f, 0.10486049f, -0.36172202f, 0.33156526f, -0.02382144f, -0.09067383f, -0.11203404f, 0.04475889f, 
    -0.34886983f, -0.26456055f, 0.31852725f, 0.17949136f, 0.37108177f, -0.23544168f, -0.00063547f, -0.13136242f, 
    0.55058074f, -0.16271871f, 0.10843681f, -0.26360792f, 0.04611638f, 0.40932798f, 0.20235786f, 0.24187621f, 
    0.19107763f, 0.14125606f, 0.09221361f, 0.01861010f, 0.27002424f, -0.23978323f, -0.11292675f, -0.19303091f, 
    0.29991576f, 0.29638031f, -0.04253003f, -0.30676937f, -0.20954409f, 0.29669547f, 0.16360983f, 0.15651605f, 
    -0.37913296f, -0.19264014f, 0.24755761f, 0.25584188f, -0.11657318f, 0.22811341f, 0.03947420f, 0.25263703f, 
    0.35354781f, -0.40785867f, 0.24829288f, 0.17897339f, 0.09138472f, -0.25461137f, -0.20351440f, 0.18378845f, 
    -0.05422955f, 0.03147850f, 0.02709524f, 0.03071954f, 0.16590336f, -0.17343533f, -0.08454163f, 0.27156720f, 
    0.28785160f, 0.07075066f, -0.37894613f, 0.12764561f, -0.11969568f, -0.29671338f, -0.20776814f, -0.20054251f, 
    -0.32680464f, 0.13167566f, 0.18345106f, -0.05354027f, -0.24547286f, 0.19781145f, 0.07275189f, 0.16761702f, 
    0.00995920f, 0.02001240f, -0.22320282f, -0.22237453f, 0.14241064f, 0.07855616f, -0.40265146f, 0.20648837f, 
    0.50923932f, -0.19413733f, 0.19450042f, 0.44357255f, 0.33004966f, -0.04096461f, 0.24759504f, 0.10100486f, 
    0.26220292f, -0.06902383f, -0.05686285f, 0.17204712f, 0.20871729f, -0.60942906f, 0.18193443f, -0.24887598f, 
    -0.02441235f, -1.00324273f, 0.08829163f, 0.10210686f, 0.24250527f, 0.06912819f, 0.17335108f, -0.32172993f, 
    -0.42139280f, -0.24446438f, 0.53070170f, 0.17592826f, 0.04319041f, -0.04234033f, 0.23114552f, -0.20913644f, 
    -0.42833242f, -0.28278187f, 0.14343503f, -0.47570524f, -0.44026849f, -0.09936472f, -0.02360770f, 0.26789230f, 
    -0.11602069f, -0.34545407f, 0.62012392f, 0.30988580f, -0.10820161f, 0.16026391f, -0.18131407f, 0.12087661f, 
    -0.11857334f, -0.40591690f, 0.13581312f, -0.38469926f, -0.52956581f, 0.04235676f, -0.23501387f, -0.05992548f, 
    0.32940966f, 0.11587826f, 0.18288583f, 0.07589847f, -0.13185127f, -0.10080762f, 0.35882396f, 0.00322794f, 
    0.11336643f, 0.03686664f, -0.07981355f, -0.22055066f, -0.23004287f, 0.20333260f, -0.13347508f, -0.12971443f, 
    0.15598351f, -0.29193872f, -0.06360752f, 0.24577625f, -0.14647673f, -0.00683850f, -0.30143237f, 0.19654822f, 
    0.14432277f, 0.10540780f, -0.15014282f, 0.52445036f, 0.06804297f, -0.17107759f, -0.07545146f, -0.12061760f, 
    -0.20549788f, 0.20992036f, -0.39496091f, -0.03451400f, 0.04394900f, 0.19882882f, 0.06482819f, -0.19789766f, 
    0.31652808f, 0.38108787f, -0.23955144f, 0.02823445f, 0.27358294f, -0.11017268f, 0.15563464f, 0.13675791f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.34461874f, -0.10728641f, 0.46573511f, 0.17924497f, -0.09180088f, -0.37178931f, 0.09382466f, 0.43342623f, 
    0.23712286f, -0.27327645f, 0.11571216f, -0.02325346f, -0.21348904f, -0.05235533f, 0.27254972f, 0.07475347f, 
    0.06845019f, -0.03075773f, 0.03830134f, -0.27932250f, 0.06276089f, -0.25109056f, -0.30994785f, 0.48600453f, 
    0.41618523f, 0.07839869f, 0.26308429f, -0.00849806f, -0.38047129f, 0.47308651f, -0.18089919f, -0.02342240f, 
    -0.12779668f, -0.29665637f, 0.27588618f, -0.12100997f, 0.26397082f, -0.27112815f, 0.25022656f, -0.20796037f, 
    -0.17157093f, -0.09454777f, -0.45326540f, 0.00782208f, 0.41982278f, 0.16196553f, 0.02842719f, -0.37594560f, 
    0.20592052f, 0.19845253f, -0.17273803f, 0.14641103f, -0.32160273f, -0.18116374f, 0.52690786f, 0.45846695f, 
    0.16589911f, 0.04344198f, -0.45203385f, -0.14201957f, -0.06086748f, -0.10126036f, -0.33186415f, 0.28137869f, 
    -0.10969071f, -0.31332415f, -0.17918339f, 0.43808907f, 0.05209652f, -0.19298431f, -0.05356499f, -0.09270716f, 
    0.04484256f, -0.24531659f, -0.16347149f, 0.25951192f, -0.18694812f, 0.30183131f, 0.34609234f, 0.36734706f, 
    -0.47019041f, 0.30662286f, 0.35978258f, 0.18931811f, 0.16471702f, -0.01669455f, 0.07590155f, -0.22530714f, 
    0.60307515f, -0.22163671f, 0.17384320f, 0.32103965f, -0.29126805f, 0.06222517f, 0.11654855f, -0.10039879f, 
    -0.09455247f, -0.16020525f, 0.19173068f, 0.13761981f, 0.11638411f, 0.06854940f, -0.34927663f, 0.09921863f, 
    0.22564755f, 0.05229370f, -0.11967127f, 0.41421252f, 0.39695734f, -0.12441574f, -0.26061356f, 0.12321510f, 
    0.28249446f, 0.04153763f, 0.16590202f, 0.08181044f, -0.30917832f, -0.15258949f, -0.08093461f, 0.23449178f, 
    0.43930092f, -0.06499173f, -0.12173320f, 0.28740215f, 0.07941108f, -0.19416182f, 0.29367477f, -0.17982230f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04329786f, 0.06453709f, -0.00840093f, 0.04315941f, -0.00487126f, -0.10123385f, -0.01905555f, -0.13613707f, 
    -0.03943057f, -0.07873452f, -0.01537067f, -0.07747683f, -0.00599285f, -0.10047767f, -0.07742455f, -0.04518984f, 
    -0.00308406f, -0.01312209f, -0.08776721f, 0.04441439f, -0.03831244f, 0.03855053f, -0.10274539f, -0.12231790f, 
    0.01459938f, -0.05036522f, -0.01543063f, 0.01200997f, -0.05266195f, -0.13129504f, 0.06812733f, -0.09602147f, 
    -0.00509085f, -0.04781327f, -0.02543669f, 0.01471373f, -0.03480658f, -0.00236632f, 0.03538413f, -0.04255899f, 
    -0.02883438f, -0.07292620f, 0.03532145f, 0.02494566f, -0.06710097f, -0.08628925f, -0.10458747f, 0.03788580f, 
    -0.03133964f, -0.01283818f, 0.01166552f, -0.12958631f, -0.08835009f, -0.03106499f, -0.05837851f, -0.11702266f, 
    0.04681683f, 0.00464329f, 0.04234310f, -0.02981292f, -0.04004822f, -0.09913117f, -0.08377228f, -0.00713730f, 
    0.01936929f, 0.04626413f, 0.01297174f, -0.12079362f, -0.02621987f, 0.05665813f, -0.04032047f, -0.01858064f, 
    -0.09183651f, 0.00143019f, 0.00119871f, 0.01773396f, 0.01450378f, 0.01889658f, -0.03038041f, 0.01644020f, 
    -0.02961717f, 0.05717732f, 0.02235653f, 0.03898952f, -0.05337552f, -0.06359451f, -0.02801831f, -0.06196506f, 
    0.01744033f, 0.00060439f, 0.04489128f, 0.00346794f, -0.02081764f, 0.06158771f, -0.05835674f, -0.13291594f, 
    -0.05644125f, -0.02970612f, -0.03854813f, 0.02501006f, -0.06520538f, -0.09938716f, -0.09613038f, -0.06283987f, 
    -0.08102407f, -0.04625526f, -0.00950545f, 0.02599835f, -0.08498081f, -0.06474668f, -0.03464640f, 0.02479938f, 
    -0.00739764f, -0.00543337f, -0.02604833f, -0.03831513f, -0.04029929f, 0.08851062f, 0.01136419f, 0.02277802f, 
    -0.02345655f, -0.03265918f, -0.00251704f, -0.04009271f, -0.10292924f, -0.01217699f, -0.01349198f, -0.09387055f, 
    0.01852027f, -0.11203972f, -0.08960527f, 0.05255041f, 0.03737360f, 0.06571691f, -0.01853492f, 0.01823889f, 
    -0.00170361f, -0.07293992f, 0.02109142f, -0.01636854f, -0.12382121f, -0.04104475f, 0.01835415f, -0.00189443f, 
    -0.07743490f, 0.00033218f, 0.00736624f, -0.06194030f, 0.04434180f, -0.09411673f, -0.00736277f, -0.08576863f, 
    -0.02443771f, -0.05812464f, -0.04070329f, -0.09872534f, 0.00254874f, -0.00010608f, -0.05927181f, -0.03625744f, 
    -0.01159929f, -0.06360475f, 0.02917318f, -0.08313123f, -0.01664014f, -0.06818049f, -0.07046493f, -0.00156787f, 
    -0.08385029f, -0.03319190f, 0.02245047f, 0.05484382f, -0.11282295f, -0.04163632f, -0.00433611f, -0.07926871f, 
    0.05115185f, -0.04010916f, 0.07651732f, -0.08124729f, -0.08176012f, -0.09227283f, 0.06901234f, -0.05396747f, 
    -0.08144556f, -0.02010913f, -0.03820060f, 0.00817720f, -0.07568301f, -0.06212761f, -0.07949921f, -0.03977803f, 
    -0.08754192f, 0.01739326f, 0.05121334f, -0.09328945f, 0.01551137f, -0.05935458f, 0.06303164f, -0.00240329f, 
    0.00503157f, -0.02641052f, 0.08757719f, -0.02122872f, -0.03072244f, 0.01292158f, -0.02906496f, 0.00685133f, 
    0.06868099f, -0.08243082f, -0.04606372f, 0.01804638f, 0.00188751f, 0.08465110f, -0.06035199f, -0.03251481f, 
    -0.02068098f, 0.05026998f, 0.04498808f, 0.00486576f, -0.04990467f, 0.05640555f, -0.07966822f, 0.00801290f, 
    0.00060622f, 0.06555518f, -0.03216798f, 0.05018367f, 0.06140357f, 0.01857010f, -0.01305490f, -0.06367975f, 
    -0.10722374f, -0.04319015f, 0.05835491f, 0.00425401f, 0.05363775f, 0.00433082f, -0.04736412f, 0.02874107f, 
    -0.02980408f, 0.08555099f, -0.02363396f, 0.02603287f, 0.01531721f, -0.02825598f, 0.01846325f, -0.01314265f, 
    -0.04482074f, -0.10102638f, 0.00957303f, -0.01270758f, -0.06549264f, -0.05442161f, 0.00275354f, -0.10383490f, 
    -0.03051531f, 0.02781263f, -0.03516574f, -0.07376501f, -0.05718006f, -0.04286142f, -0.07025201f, -0.09151347f, 
    -0.02931850f, -0.07423008f, 0.00085772f, -0.01409506f, -0.06430384f, 0.05055236f, 0.00099165f, 0.00989717f, 
    0.01672803f, -0.02599062f, 0.00999639f, 0.05215074f, 0.03118830f, -0.07123377f, -0.04982996f, 0.01332972f, 
    0.07143165f, 0.06284232f, -0.05771399f, -0.02087543f, 0.02142350f, -0.04703404f, 0.06474023f, 0.03781570f, 
    -0.02744144f, 0.05614354f, 0.04110380f, -0.03994456f, -0.08958170f, 0.05711219f, -0.01269346f, -0.00846425f, 
    0.00415309f, -0.06948203f, 0.04546478f, -0.08598935f, -0.09395840f, -0.10063598f, -0.08084704f, -0.03330689f, 
    -0.02353515f, 0.00798148f, 0.01313847f, 0.04766937f, -0.02815315f, 0.06251693f, -0.03903318f, 0.03022970f, 
    -0.06196296f, -0.10220811f, -0.11395339f, -0.02861459f, -0.01249725f, -0.00794183f, 0.04811024f, 0.02643605f, 
    -0.02266440f, 0.03642629f, 0.06408155f, -0.10050514f, -0.07854487f, -0.02229625f, -0.06418528f, -0.07709452f, 
    -0.03177675f, 0.01736324f, -0.03693945f, 0.06566062f, 0.09176303f, -0.03146914f, 0.03213416f, -0.11805770f, 
    -0.01094798f, -0.03014205f, -0.03006864f, 0.06948040f, 0.04243899f, -0.02736231f, -0.07358797f, -0.03485070f, 
    0.00072439f, -0.05591546f, 0.00512588f, 0.02396937f, -0.01072592f, -0.01301030f, -0.04956726f, 0.02550138f, 
    -0.05107195f, -0.00760409f, -0.01377491f, 0.04562616f, 0.00822880f, -0.06210568f, -0.00526412f, 0.07428563f, 
    -0.05206424f, -0.00593958f, -0.08410011f, -0.09175280f, -0.02952612f, 0.05205384f, 0.04697708f, -0.05956909f, 
    -0.07189865f, -0.05689062f, -0.08773439f, 0.04150904f, 0.09403668f, -0.00855868f, 0.01040351f, -0.08277228f, 
    0.03471436f, -0.04260442f, 0.09706503f, 0.00137426f, -0.04850231f, -0.06129544f, -0.04427364f, -0.10095417f, 
    0.27499017f, -0.07134864f, 0.03086010f, -0.06583035f, 0.03576301f, 0.06219623f, -0.08030285f, 0.16372177f, 
    0.11068989f, -0.00476732f, 0.03215860f, -0.03471300f, -0.11312880f, 0.22291510f, 0.20022625f, 0.07279378f, 
    -0.06213204f, -0.07505608f, -0.01190399f, -0.16502231f, 0.04734505f, -0.10259818f, -0.21901894f, 0.23291822f, 
    0.08094371f, -0.06037309f, 0.08007456f, -0.10315487f, 0.03802302f, 0.14527707f, 0.04587030f, -0.05359257f, 
    0.23928310f, -0.36552918f, 0.17926644f, 0.11095671f, 0.31298396f, 0.06376830f, 0.17544481f, 0.12349144f, 
    -0.11496950f, 0.04999318f, -0.23278131f, -0.05344934f, 0.09855530f, -0.15097938f, -0.26348162f, -0.08243456f, 
    -0.07952797f, 0.01992126f, 0.03267687f, 0.02711932f, 0.08343883f, 0.06918769f, 0.30041343f, -0.02156299f, 
    -0.07623343f, -0.05498283f, -0.06190816f, -0.16421649f, 0.05399302f, -0.20618205f, -0.14304978f, 0.02948430f, 
    0.02795757f, -0.20676057f, 0.08198507f, 0.20762675f, 0.13084924f, -0.08018228f, -0.08586791f, -0.01738352f, 
    -0.20262845f, 0.01553595f, -0.08722212f, 0.10703536f, -0.13794097f, 0.27291298f, 0.34467301f, 0.28451353f, 
    -0.18783592f, 0.19921748f, 0.01891932f, 0.14063132f, -0.00831971f, -0.01881234f, -0.17752467f, -0.04793689f, 
    0.21331142f, -0.01844782f, 0.10426401f, 0.02352250f, -0.30575994f, -0.13730678f, -0.16961554f, -0.20001505f, 
    0.12835743f, 0.07462562f, 0.13205898f, 0.07527454f, -0.01156582f, -0.08235984f, -0.17039883f, 0.08243848f, 
    0.06932618f, -0.04335360f, 0.05908268f, 0.14072411f, 0.19526753f, 0.67003787f, -0.07379884f, 0.18181223f, 
    0.08718485f, -0.00616129f, -0.03963127f, -0.05080267f, 0.05479946f, -0.36726028f, 0.13050915f, 0.19333276f, 
    0.41925985f, -0.29044625f, -0.13921884f, 0.17047864f, -0.08995631f, -0.07067960f, -0.07016422f, 0.03957427f, 
    0.50232345f, -0.26398018f, 0.06349845f, 0.28346202f, -0.32392111f, -0.17700484f, -0.74345905f, 0.36523390f, 
    0.25658906f, -0.01090602f, -0.14149824f, 0.11309730f, -0.57277948f, 0.38129950f, 0.73957747f, 0.01455952f, 
    -0.07305614f, 0.08080741f, -0.02785117f, 0.36087891f, 0.04370937f, 0.04671565f, -0.38431865f, -0.09962142f, 
    0.38359976f, -0.12387258f, 0.12578940f, 0.24103218f, -0.00635455f, 0.16596055f, 0.05456970f, -0.08424345f, 
    0.04189571f, 0.24080881f, 0.11038802f, -0.03753696f, 0.15880695f, -0.01645919f, 0.55166787f, 0.16267693f, 
    0.02861577f, 0.00971168f, -0.28460017f, 0.02966135f, 0.50116390f, 0.28166944f, 0.09805398f, 0.00038574f, 
    -0.20998965f, -0.07382031f, -0.06682441f, -0.00687480f, -0.41447416f, -0.24563642f, 0.28230512f, 0.32614863f, 
    -0.23162001f, 0.01179015f, -0.09603252f, 0.01433344f, -0.10805067f, 0.01007432f, -0.74537230f, 0.32539907f, 
    -0.13765909f, 0.18307637f, 0.04050062f, 0.24521384f, 0.02883249f, 0.12085406f, -0.15655546f, -0.41152954f, 
    0.12146669f, -0.05557700f, -0.00939955f, -0.09170072f, -0.90126657f, 0.11974679f, 0.18237664f, 0.01382492f, 
    -0.32932451f, -0.08229341f, 0.12547936f, 0.06693813f, -0.10194473f, 0.02709613f, -0.13626449f, 0.03666234f, 
    0.16771989f, -0.07679740f, 0.02744875f, -0.06248264f, -0.18066870f, -0.69328892f, -0.32006094f, -0.17970450f, 
    0.09425425f, -0.02908907f, -0.07225727f, -0.00710113f, 0.11586418f, -0.17426205f, -0.67766327f, -0.17303525f, 
    0.18675308f, 0.19136567f, -0.61829388f, 0.03314431f, -0.10243491f, 0.57180399f, -0.21238185f, -0.27619326f, 
    -0.30440244f, 0.06165081f, 0.06482071f, 0.07589100f, -0.47388047f, 0.19039126f, 0.25520629f, 0.05426832f, 
    0.18434367f, -0.04070996f, -0.05494200f, 0.13849632f, -0.16429375f, -0.07079259f, -0.11644801f, -0.09225842f, 
    -0.02672284f, 0.25137872f, 0.10613620f, -0.14383206f, -0.02835769f, -0.56563240f, -0.02486894f, -0.11565965f, 
    -0.21516535f, 0.01923055f, 0.15747456f, -0.49908838f, -0.04369061f, 0.03460803f, -0.31796986f, -0.55119634f, 
    0.38145071f, 0.03767107f, 0.31795293f, -0.10916831f, 0.01205137f, 0.01523962f, -0.05334206f, 0.14329369f, 
    -0.44452721f, 0.01159539f, 0.03894687f, -0.10006460f, 0.20242308f, 0.19035326f, -0.02363753f, 0.13601187f, 
    0.00510143f, -0.47010517f, -0.04991980f, 0.26603252f, -0.14237688f, -0.02090478f, -0.00307619f, -0.01855279f, 
    -0.00384028f, -0.66394758f, -0.09565220f, 0.03224550f, -0.13698542f, 0.28498459f, 0.45682746f, -0.63642919f, 
    0.42762509f, 0.06048701f, 0.01674653f, 0.15083954f, -0.03227289f, 0.47503272f, -0.00051527f, 0.05600110f, 
    0.00292794f, 0.04393501f, 0.18356043f, 0.22112639f, 0.18952125f, 0.14494085f, 0.23211484f, -0.50402462f, 
    -0.18610662f, -0.21927746f, 0.08205441f, 0.13314632f, 0.22045296f, 0.05480646f, -0.22714703f, 0.33200714f, 
    0.12775029f, -0.05535813f, -0.06449631f, -0.24673229f, 0.10177173f, 0.14919922f, 0.14472534f, 0.10121615f, 
    -0.15936191f, -0.04710238f, 0.17941789f, -0.23047543f, 0.23357247f, -0.04631383f, 0.06381223f, 0.03587120f, 
    0.27375141f, 0.06270082f, 0.24148126f, 0.05020408f, 0.13715342f, 0.40149269f, 0.34567165f, 0.21994118f, 
    -0.38319647f, 0.02553191f, -0.01520714f, -0.29670715f, -0.05092600f, 0.17375302f, 0.04864836f, -0.06354909f, 
    0.01366182f, -0.18501353f, -0.11961062f, -0.17408559f, 0.14956751f, 0.01506894f, -0.41336581f, -0.19452576f, 
    0.60569221f, 0.05847890f, -0.07171081f, 0.07386689f, -0.03611830f, 0.21402635f, -0.43165269f, 0.25688741f, 
    0.10103863f, -0.20587558f, -0.06020769f, 0.11880369f, 0.08032718f, 0.20735210f, 0.18912770f, -0.14628798f, 
    0.17492147f, -0.33471155f, 0.05115174f, 0.11487261f, -0.10864334f, 0.16537307f, -0.21658896f, 0.23127866f, 
    0.10762008f, 0.07246304f, -0.02908726f, 0.09143057f, 0.06105221f, 0.33952558f, 0.12879725f, 0.35342512f, 
    -0.06244269f, -0.01978019f, 0.17222723f, -0.08083194f, 0.06380945f, -0.03835817f, -0.54078835f, -0.01925429f, 
    0.18696715f, -0.35442221f, 0.10428952f, -0.12628719f, 0.00239750f, -0.04161809f, 0.01478183f, -0.07329415f, 
    -0.02220247f, 0.10839602f, 0.28133819f, -0.85490674f, 0.14564690f, 0.00848283f, 0.16308305f, -0.01961329f, 
    0.04820660f, 0.11032275f, -0.05544314f, -0.03762044f, 0.04334856f, -0.04481832f, -0.27627197f, 0.12253387f, 
    -0.15473539f, 0.07209618f, -0.01380550f, 0.05561228f, -0.41984043f, -0.06624753f, 0.16975920f, 0.31738520f, 
    -0.02751287f, 0.15417518f, -0.00288093f, -0.91037375f, -0.08786275f, -0.01188485f, 0.40313441f, 0.30424908f, 
    -0.63515824f, -0.31492609f, -0.01415332f, 0.10185513f, -0.05783400f, 0.12689626f, 0.01411453f, -0.36160970f, 
    0.13801393f, 0.00587798f, 0.08613902f, 0.12423057f, 0.11190628f, 0.04089823f, 0.11490140f, 0.15098429f, 
    0.03774935f, 0.12951133f, 0.18720357f, 0.25734299f, -0.18334809f, 0.00823191f, 0.07756846f, 0.00192705f, 
    0.07322423f, 0.04083491f, 0.08498494f, -0.03968817f, -0.46105143f, -0.35939044f, -0.13141544f, -0.67657304f, 
    0.06985114f, 0.01037416f, 0.30003145f, -0.12677020f, -0.23537855f, -0.12422805f, -0.09200758f, -0.02232164f, 
    0.01632954f, -0.29260689f, 0.25869316f, 0.00034173f, 0.02660683f, 0.17773990f, 0.00915376f, 0.08689179f, 
    -0.15526663f, 0.05695732f, 0.01792874f, 0.01912791f, 0.11263485f, -0.47177434f, 0.05374938f, 0.02797804f, 
    0.16948923f, -0.36215764f, -0.09693985f, 0.13134655f, 0.08317158f, -0.44333467f, -0.09855202f, -0.05126958f, 
    -0.20700309f, 0.14992233f, -0.01467809f, 0.16274434f, 0.09700406f, 0.00568768f, 0.20004508f, -0.12945293f, 
    -0.04158771f, 0.02297221f, 0.00863959f, -0.02652613f, -0.22746107f, 0.05488859f, 0.15698627f, -0.06890026f, 
    0.03792138f, -0.04182593f, 0.02150339f, 0.46186808f, 0.00340074f, 0.05911508f, -0.08471905f, -0.08235095f, 
    -0.10821845f, -0.03137612f, 0.00960439f, -0.00862903f, 0.03498747f, 0.14666362f, -0.09902577f, 0.08788266f, 
    -0.17902827f, -0.11620281f, -0.07906959f, 0.32271814f, -0.10945237f, 0.15946509f, 0.03899556f, 0.13849369f, 
    0.07420900f, -0.02009988f, 0.44770917f, -0.15668246f, 0.29927158f, 0.25527957f, 0.23552905f, 0.09695701f, 
    -0.22919999f, -0.04053249f, 0.01716498f, 0.02845856f, 0.14082356f, 0.09339035f, 0.05421934f, -0.23026587f, 
    0.01872963f, 0.03232126f, 0.37080482f, -0.00209143f, -0.03204552f, 0.29079181f, -0.27141145f, 0.00372416f, 
    -0.36867872f, 0.30847830f, -0.04792028f, -0.02850663f, -0.12389316f, -0.00844780f, -0.15378746f, 0.08786442f, 
    -0.06555828f, 0.05998359f, -0.07073644f, 0.10605218f, 0.08124650f, 0.11337701f, 0.06762784f, -0.18849260f, 
    -0.31927645f, -0.01198249f, -0.02542021f, 0.04055727f, 0.02734605f, -0.00804786f, 0.20310499f, 0.00997782f, 
    -0.42028418f, -0.02923730f, -0.37709206f, 0.04808562f, 0.19540891f, 0.22337745f, 0.15275532f, 0.31595585f, 
    0.01420626f, 0.03666638f, 0.06097010f, -0.01529384f, 0.13893048f, 0.00526613f, 0.06800838f, 0.12716098f, 
    0.07794639f, 0.14221331f, -0.00895804f, 0.20638877f, -0.08822881f, -0.51979381f, 0.14481731f, -0.23703925f, 
    -0.02186086f, 0.09899623f, -0.06534972f, -0.07011974f, -0.41042504f, 0.27619943f, 0.13321644f, -0.01875114f, 
    0.04524749f, 0.07675640f, -0.47040686f, -0.34950656f, -0.28603294f, 0.04509953f, 0.07261330f, 0.11181322f, 
    -0.06415787f, -0.08991322f, 0.02308059f, -0.10068266f, 0.02622353f, -0.09495017f, -0.04567032f, -0.07884905f, 
    0.04668258f, 0.01087795f, 0.00157553f, -0.08372153f, -0.06703062f, 0.03486174f, 0.03715895f, -0.01605317f, 
    -0.05453318f, 0.08581989f, -0.06059533f, -0.05397115f, 0.03706091f, -0.04068438f, 0.02055451f, 0.04541931f, 
    -0.05949387f, -0.07836747f, -0.00268149f, 0.05111891f, -0.05981133f, -0.07461306f, -0.03285623f, 0.08159020f, 
    -0.08533822f, -0.02581006f, -0.03010866f, -0.00346270f, -0.05042581f, -0.10706130f, -0.11262133f, 0.05280877f, 
    -0.01444715f, 0.03741793f, -0.08043896f, -0.09241018f, -0.07423458f, 0.00428941f, 0.06866689f, 0.02089301f, 
    -0.01582240f, 0.07742354f, 0.02745964f, -0.10769232f, 0.01272780f, -0.02269131f, -0.04869047f, -0.05446828f, 
    -0.04196283f, -0.11049808f, 0.02640610f, 0.04701878f, 0.08035946f, -0.08759113f, 0.06677192f, 0.03003048f, 
    0.04920262f, -0.04013192f, -0.08400612f, 0.01775852f, -0.09493720f, 0.04987004f, 0.06345534f, -0.06868678f, 
    -0.04372226f, 0.02329189f, -0.05023651f, 0.05679177f, 0.01022410f, -0.06613655f, -0.03900001f, -0.03196349f, 
    0.06602668f, 0.03947029f, 0.04036519f, 0.00990020f, -0.02274860f, 0.06838834f, 0.03987354f, 0.08234221f, 
    -0.05496234f, 0.02594503f, -0.10495670f, -0.10159817f, -0.10630523f, -0.06627394f, -0.05509556f, -0.05761858f, 
    -0.05885783f, 0.04171277f, -0.00928772f, -0.01417627f, -0.08674301f, -0.07183593f, 0.04170511f, -0.07386845f, 
    -0.09956698f, -0.01967121f, 0.00146328f, -0.09234305f, -0.05216939f, 0.06215513f, -0.11463216f, 0.05014227f, 
    0.04968850f, -0.01131637f, 0.04835359f, -0.04468351f, -0.01172075f, -0.10913127f, -0.06769112f, -0.07291861f, 
    -0.05233358f, -0.08796956f, -0.06570306f, 0.02204705f, -0.02261568f, 0.04194474f, -0.06556701f, -0.03624711f, 
    0.10861268f, -0.00484171f, 0.08221149f, -0.00793133f, -0.05985389f, 0.02740631f, -0.16519299f, 0.03219288f, 
    -0.01933912f, 0.02218379f, 0.08126563f, -0.12976894f, -0.46874830f, 0.27089572f, 0.26410422f, -0.16654266f, 
    -0.08161587f, 0.04628703f, 0.17933960f, 0.19108479f, 0.08806543f, -0.05974433f, -0.03730227f, 0.08411154f, 
    -0.08340347f, -0.02214297f, 0.09806077f, -0.10057477f, 0.04840613f, 0.15341653f, 0.00688438f, 0.06849434f, 
    0.02773533f, -0.59246844f, -0.05626541f, 0.12099846f, 0.15248799f, 0.21374531f, 0.03315099f, 0.17857932f, 
    -0.04101786f, -0.26548105f, 0.58348668f, -0.18890293f, 0.20253862f, 0.11549837f, 0.12519306f, -0.06336413f, 
    0.12276696f, 0.08220645f, 0.00549571f, 0.04503369f, 0.10553406f, 0.20203233f, 0.31320259f, 0.00519198f, 
    -0.12765563f, 0.09283856f, 0.26877636f, 0.04389240f, 0.12549825f, 0.10438757f, -0.38746333f, 0.13631319f, 
    0.06160419f, -0.02113020f, 0.08102757f, 0.04923823f, 0.13242602f, 0.05253027f, 0.02704844f, 0.05054234f, 
    0.20370209f, 0.03988744f, -0.05276455f, 0.07604048f, -0.29980314f, 0.15720935f, 0.09422888f, 0.19208521f, 
    -0.03206065f, -0.04266846f, -0.08081574f, 0.01677976f, 0.00760393f, 0.00305749f, 0.00940786f, -0.06544483f, 
    0.00151958f, 0.01066019f, -0.12816215f, -0.01348413f, -0.09484098f, -0.02264941f, 0.26074439f, 0.01325563f, 
    -0.00613601f, 0.07502635f, -0.03781303f, 0.13376713f, 0.14701875f, 0.14103930f, 0.09602520f, -0.12894261f, 
    -0.05966595f, 0.05282113f, 0.04284141f, -0.04271717f, -0.04345693f, -0.13373113f, -0.14781463f, -0.04794372f, 
    0.12631479f, 0.03269960f, -0.07948563f, -0.02422101f, 0.15323137f, 0.12155071f, -0.12252089f, -0.00336113f, 
    0.27947921f, 0.09429335f, 0.02582534f, -0.29600376f, -0.04401153f, 0.14769129f, 0.04950788f, -0.08254465f, 
    -0.25993013f, -0.00302876f, -0.11809918f, 0.01949478f, -0.07438324f, 0.10057648f, -0.01139121f, 0.10382585f, 
    0.06215729f, 0.06848677f, -0.17757782f, 0.00260875f, 0.04940068f, 0.31725931f, -0.24370308f, 0.22288163f, 
    0.01046500f, 0.08422361f, -0.04841290f, 0.11847511f, -0.05955590f, 0.14309567f, 0.09675592f, 0.01151638f, 
    -0.32390368f, 0.10879767f, 0.19552758f, -0.24183656f, 0.40370074f, 0.06060214f, -0.03347297f, 0.22551131f, 
    0.06607464f, -0.58308244f, -0.06214908f, -0.13739343f, -0.16553864f, 0.23231749f, -0.33280507f, 0.19612995f, 
    -0.04633686f, -0.11203738f, 0.38065904f, 0.05411329f, -0.04036220f, 0.01024285f, -0.07631330f, 0.33459914f, 
    0.13240416f, -0.03798426f, -0.01545264f, -0.05912159f, 0.15007699f, 0.18999061f, -0.01003286f, -0.47948751f, 
    0.12862222f, 0.06456013f, 0.48360384f, -0.04249820f, 0.22204830f, 0.25422263f, -0.15081455f, 0.01932295f, 
    -0.17113173f, -0.02491336f, -0.04872256f, 0.05732210f, 0.11799753f, 0.17956322f, -0.07824711f, 0.17349881f, 
    -0.24341480f, 0.03899817f, -0.00102102f, -0.05063163f, -0.40509719f, 0.21124230f, 0.22662252f, -0.16330431f, 
    0.01409013f, -0.01742564f, 0.06048908f, 0.09137486f, -0.10575417f, 0.08095361f, -0.22326867f, 0.03856285f, 
    -0.37737384f, -0.01469332f, -0.22351046f, 0.18339716f, 0.02745799f, -0.04025210f, -0.22009933f, 0.17658873f, 
    -0.14730260f, -0.04432664f, 0.40902099f, -0.18551508f, -0.09099311f, 0.12686870f, 0.23189054f, 0.00965132f, 
    0.12230416f, 0.08292478f, 0.31310248f, 0.00255917f, -0.15932450f, 0.03395563f, -0.12324275f, 0.06220603f, 
    -0.35016382f, 0.13152529f, 0.08074154f, 0.03922211f, -0.01519137f, 0.16703759f, -0.07536856f, 0.09175948f, 
    0.06683250f, -0.09317469f, 0.01118046f, -0.27963921f, -0.31914726f, 0.17992803f, -0.17026994f, 0.13637546f, 
    0.05656644f, -0.02737204f, -0.10805587f, -0.03612037f, 0.05320476f, -0.00842399f, -0.00173841f, 0.00558819f, 
    -0.11270640f, 0.01729743f, -0.02185504f, -0.02665620f, -0.04012342f, -0.04964254f, -0.04397853f, 0.02310567f, 
    -0.02889695f, 0.01049613f, -0.07997878f, -0.04645616f, 0.03030184f, -0.06501727f, -0.00494233f, -0.10386657f, 
    0.05536341f, -0.02751362f, -0.10119630f, -0.04963934f, -0.06796513f, -0.11158680f, 0.00653489f, 0.02055473f, 
    -0.07193625f, 0.03210540f, -0.00506353f, -0.11655118f, -0.07982294f, -0.11111502f, 0.02606441f, 0.03621202f, 
    0.07334961f, 0.01510688f, -0.05614610f, -0.08178563f, -0.04907595f, -0.07437829f, 0.02361678f, 0.05591338f, 
    -0.07413447f, 0.00408744f, -0.00445268f, 0.01508010f, -0.12872337f, 0.00066553f, 0.00553254f, 0.04883124f, 
    -0.10329761f, 0.05110402f, 0.03212388f, -0.01809987f, -0.10608256f, 0.00335914f, 0.03973221f, -0.09619429f, 
    0.01077572f, -0.09456836f, 0.05755613f, -0.04726292f, -0.10338905f, -0.08354958f, -0.01374336f, 0.02778855f, 
    -0.01282185f, 0.05180032f, -0.00452590f, -0.00194127f, 0.08425477f, -0.10714212f, 0.03906407f, -0.05112449f, 
    0.01572867f, -0.01702935f, -0.00392142f, 0.05748831f, -0.08721820f, -0.01176067f, -0.02158052f, 0.07106292f, 
    -0.13205841f, 0.04080329f, 0.04746277f, -0.03666111f, 0.01411580f, -0.02462765f, 0.04774769f, -0.07687785f, 
    0.00260212f, -0.03351478f, -0.09338164f, -0.01199325f, -0.10420481f, -0.06850447f, 0.00178317f, -0.01634854f, 
    -0.00271253f, -0.08456089f, 0.03212970f, -0.01414134f, -0.01660456f, 0.07175200f, 0.00824217f, -0.06758307f, 
    -0.04160688f, 0.03737310f, -0.00969883f, -0.00900010f, 0.02474692f, -0.02982276f, -0.14496323f, 0.03029010f, 
    -0.08691417f, -0.03321942f, -0.01673670f, 0.02143639f, -0.03941323f, -0.12097859f, 0.02372446f, -0.06766105f, 
    -0.05604903f, -0.07496616f, 0.07021716f, -0.04056646f, 0.04607861f, 0.05819687f, -0.03229364f, -0.04749968f, 
    0.08594796f, 0.08707017f, 0.05313390f, -0.02697264f, -0.01290521f, 0.04066762f, -0.09297373f, 0.05051849f, 
    0.03972016f, -0.08219527f, -0.09522021f, -0.05186656f, -0.00420730f, 0.06317034f, 0.05986455f, -0.09192441f, 
    -0.05544129f, -0.09060461f, -0.08697221f, -0.07481351f, -0.08784164f, 0.00946576f, 0.02423157f, -0.01173421f, 
    0.05713116f, 0.04582049f, 0.00918506f, -0.06329656f, 0.06984721f, -0.07974157f, -0.06001533f, -0.00618241f, 
    -0.02470799f, 0.07375880f, 0.06115957f, -0.06255233f, -0.07595477f, -0.03585794f, 0.02895530f, -0.08208345f, 
    -0.04385640f, 0.07769984f, -0.05179239f, 0.04646329f, 0.02239621f, 0.01079922f, 0.03767616f, 0.00653692f, 
    -0.01189870f, -0.08219866f, -0.05501505f, -0.02431678f, 0.00431292f, 0.04195336f, -0.08385906f, -0.07775404f, 
    -0.04299364f, -0.07201563f, -0.04894288f, -0.09883000f, -0.05361036f, -0.03402420f, -0.04457257f, -0.08428791f, 
    -0.08748155f, 0.06175248f, 0.02799430f, -0.01493496f, 0.04743827f, 0.05075926f, -0.09496867f, -0.04156984f, 
    0.06193272f, -0.06510559f, -0.02976819f, -0.05963393f, 0.07647482f, -0.05200123f, -0.06118435f, -0.05453539f, 
    -0.01947285f, 0.03945522f, 0.06566544f, 0.00979775f, -0.04110505f, -0.02345922f, -0.07822970f, 0.06380928f, 
    -0.00228599f, -0.05438648f, 0.02808275f, 0.02943414f, -0.10275272f, 0.02165359f, -0.10025291f, -0.06715930f, 
    0.04973361f, 0.07349763f, 0.06077429f, -0.04052586f, 0.04239772f, -0.05851881f, 0.07534901f, -0.06011092f, 
    -0.05446061f, -0.01858701f, 0.05858760f, 0.02011440f, 0.04845005f, 0.05091292f, -0.04497519f, 0.06471270f, 
    -0.09004506f, -0.00141327f, -0.02187440f, 0.02439929f, 0.02366251f, 0.01101359f, 0.01342436f, 0.02001532f, 
    -0.11859238f, -0.10523778f, -0.06857324f, -0.08436643f, -0.01096719f, -0.06396687f, -0.08748972f, -0.12168223f, 
    -0.09001282f, 0.03181651f, -0.03716083f, 0.04984383f, 0.06413638f, -0.08716531f, -0.05787384f, -0.07115633f, 
    0.02286576f, -0.02824037f, -0.02404546f, 0.03202031f, -0.07412736f, -0.03235975f, 0.01729981f, -0.00330091f, 
    0.00664407f, -0.08954925f, -0.01451842f, -0.10811815f, -0.01075490f, -0.12320787f, 0.00769556f, -0.09479703f, 
    -0.08074755f, 0.11788512f, -0.00599660f, -0.05192708f, -0.07346378f, -0.01625643f, -0.02655515f, 0.07351124f, 
    0.08176152f, -0.04957748f, -0.05504669f, -0.03399964f, -0.04671494f, -0.05635667f, -0.00677303f, -0.10347588f, 
    0.00649156f, -0.04269486f, -0.00576885f, 0.00798568f, 0.01779369f, -0.10502984f, -0.05848802f, -0.01505437f, 
    -0.04995199f, 0.01670017f, -0.07993739f, 0.01835557f, -0.12960950f, -0.10652146f, 0.01433986f, -0.08306064f, 
    0.04759051f, -0.09934539f, -0.07715429f, -0.08767486f, -0.04395165f, 0.01092929f, -0.00135015f, -0.00108344f, 
    -0.01926961f, 0.03915531f, -0.05784362f, 0.06177861f, 0.05463489f, -0.01505023f, 0.07380667f, -0.00664594f, 
    -0.03116144f, -0.01640107f, -0.04622023f, 0.02000539f, -0.09786788f, 0.00778117f, -0.09399881f, -0.03537235f, 
    0.01245560f, -0.00216242f, 0.01826607f, -0.03227400f, 0.00271388f, -0.06249681f, 0.04374864f, -0.05211847f, 
    -0.01690999f, 0.03989982f, 0.01280006f, 0.04551781f, -0.04159764f, -0.08170266f, -0.03703513f, 0.04880724f, 
    -0.12994072f, 0.04641285f, -0.07095449f, -0.04587165f, -0.05730878f, -0.06289776f, 0.03575615f, 0.02370340f, 
    -0.04504237f, -0.03601152f, -0.01035685f, 0.01416553f, -0.00596387f, 0.01179960f, -0.09778743f, -0.06588576f, 
    -0.01449789f, 0.04542324f, 0.02364442f, -0.08483643f, 0.06017483f, -0.01670286f, -0.06086993f, 0.02883252f, 
    -0.01549099f, -0.02635433f, -0.03885107f, 0.07475439f, -0.01489859f, -0.03177759f, -0.02143733f, 0.00829728f, 
    -0.03105281f, 0.03313535f, -0.07451858f, 0.04742824f, 0.05168807f, -0.02239721f, 0.07657410f, 0.03570364f, 
    -0.01359937f, -0.00513731f, 0.06935064f, -0.03520333f, 0.00600081f, -0.09822232f, -0.09683219f, -0.07657027f, 
    -0.04124829f, 0.00514890f, -0.07682317f, 0.00590905f, -0.02184245f, -0.07437082f, -0.08191507f, -0.03113845f, 
    0.01158345f, 0.05922565f, -0.09401463f, -0.03850170f, -0.04640982f, -0.02143919f, -0.04995122f, -0.07773332f, 
    -0.07428446f, 0.01211192f, 0.01955466f, -0.08914173f, 0.07284360f, 0.06067293f, 0.02664415f, -0.06313594f, 
    -0.07062087f, -0.02518341f, 0.01470180f, 0.03391474f, 0.06367364f, 0.02608139f, -0.01073472f, -0.02707087f, 
    0.02070547f, -0.02525652f, 0.02993422f, -0.09441418f, -0.01726070f, 0.04458866f, 0.03318627f, 0.07156861f, 
    -0.07944991f, -0.04255278f, 0.01258958f, 0.05643549f, -0.05019058f, -0.02966860f, -0.02140368f, 0.01203971f, 
    -0.05419066f, -0.02101345f, -0.05263650f, -0.05868380f, 0.07997924f, -0.03698651f, 0.01548804f, -0.05774253f, 
    0.06650259f, -0.08901642f, 0.01240884f, -0.05240502f, 0.03666354f, 0.07309360f, 0.04120452f, -0.00076326f, 
    0.04790195f, 0.08275736f, -0.00066192f, 0.00150983f, 0.05693787f, 0.06471288f, 0.03535365f, -0.07413585f, 
    0.04671327f, -0.04593276f, -0.05302512f, -0.00849415f, -0.00275392f, 0.04640943f, -0.02237464f, 0.05365664f, 
    0.07195991f, 0.01292308f, 0.03024443f, -0.06048797f, -0.02932351f, -0.01229831f, -0.06530020f, 0.03988907f, 
    -0.09662065f, 0.01570307f, -0.02171664f, -0.07586522f, 0.01914220f, -0.11526841f, -0.00358845f, -0.04182518f, 
    -0.06012125f, -0.00514203f, 0.02704167f, -0.04524839f, 0.05405975f, -0.00154085f, -0.08325452f, -0.04766767f, 
    -0.02278120f, 0.00579084f, -0.12310933f, 0.04480533f, -0.09504871f, 0.07377982f, -0.07636643f, -0.11767149f, 
    -0.11134647f, 0.08062718f, 0.02751407f, -0.00615954f, 0.00720807f, -0.08919869f, -0.13837154f, -0.05188021f, 
    0.04478784f, -0.02644750f, -0.20111291f, -0.03766733f, -0.03408976f, 0.06839304f, -0.08502993f, 0.01341655f, 
    -0.12449988f, 0.04523207f, -0.09256141f, 0.01241293f, 0.00700308f, -0.09384968f, 0.00303041f, 0.03100492f, 
    0.04583656f, -0.03526351f, 0.00249301f, -0.07046273f, -0.07277749f, 0.04338403f, -0.06462667f, -0.05459699f, 
    0.07742082f, -0.12256992f, -0.06764083f, 0.04107244f, 0.10849869f, 0.03899585f, -0.06826211f, -0.19125456f, 
    -0.04166101f, 0.00671780f, -0.05890370f, -0.02387599f, 0.07330894f, -0.18561554f, -0.09431203f, -0.12328589f, 
    -0.07714894f, -0.14376731f, 0.01331014f, -0.05395128f, 0.06021385f, -0.04761682f, -0.06689703f, -0.03216839f, 
    -0.02553847f, -0.10727194f, -0.06495826f, 0.05713324f, -0.11643874f, -0.05386701f, -0.05413510f, 0.01723350f, 
    -0.09376619f, -0.07363644f, 0.06520537f, -0.19764641f, -0.05345457f, -0.02213543f, -0.00292982f, -0.18199025f, 
    -0.00589815f, -0.00320139f, 0.07699844f, -0.20686470f, -0.05896026f, -0.05108899f, -0.20098683f, -0.02943687f, 
    -0.19356671f, -0.02403110f, -0.11220569f, -0.09137853f, -0.06855618f, -0.01183559f, -0.17720297f, 0.04380313f, 
    -0.11250427f, -0.04638904f, -0.15279944f, -0.04623780f, -0.08081067f, -0.04700717f, 0.02807075f, -0.00121293f, 
    -0.03877791f, -0.08332616f, -0.10533341f, -0.02840608f, -0.07615530f, -0.01944162f, -0.04476692f, -0.04245444f, 
    -0.12576994f, 0.03142289f, -0.06707426f, 0.02874265f, -0.01667557f, -0.04989319f, 0.02880086f, -0.05370000f, 
    0.06129621f, -0.00807446f, 0.06434660f, -0.06704511f, -0.13872245f, 0.00369527f, -0.17113487f, 0.04110441f, 
    -0.18697067f, 0.12340856f, 0.02020940f, 0.01079248f, -0.03936833f, 0.15216365f, -0.15314718f, 0.23924340f, 
    0.07411763f, 0.13708587f, -0.03816937f, 0.18204981f, 0.64211100f, -0.07351734f, -0.17033412f, 0.31078193f, 
    0.30394551f, -0.03874838f, 0.01856482f, -0.22125037f, 0.00314666f, 0.01372495f, 0.08061374f, 0.23677160f, 
    0.13259014f, 0.05262863f, 0.11879271f, 0.04653926f, -0.03463455f, 0.02838938f, -0.06649613f, 0.02901559f, 
    -0.07358796f, 0.65582842f, 0.17929210f, -0.18315682f, 0.07890151f, -0.03902225f, -0.23339799f, -0.26075864f, 
    0.10873135f, 0.47511357f, -0.15899776f, 0.24239947f, -0.13984697f, 0.05323845f, 0.08469573f, 0.01480258f, 
    0.00138037f, -0.01080237f, -0.03955424f, 0.23213626f, -0.42141438f, 0.02830840f, -0.05894372f, -0.23106042f, 
    0.08909094f, -0.03025690f, -0.13773648f, -0.02240936f, 0.02983270f, 0.16614048f, 0.20036601f, 0.06860432f, 
    -0.00583123f, -0.08785013f, 0.06463950f, 0.08559648f, 0.05128923f, 0.07213267f, -0.12610137f, -0.00570139f, 
    -0.40560931f, -0.06109869f, 0.08135168f, 0.00804743f, 0.08226743f, 0.06432939f, -0.00869519f, -0.34437338f, 
    -0.25871551f, 0.30418658f, 0.11954682f, -0.06723168f, 0.27015623f, 0.08988306f, -0.42592996f, 0.07937288f, 
    0.01555300f, -0.07374139f, -0.02755872f, -0.07363525f, 0.10900871f, 0.03907903f, -0.11503182f, 0.07518663f, 
    0.00137879f, -0.11467446f, 0.06790287f, 0.05719971f, -0.18726902f, -0.10448176f, 0.02647673f, -0.06650335f, 
    0.11361734f, -0.11141755f, 0.04203691f, -0.00139702f, 0.16869342f, -0.00168281f, 0.08673239f, 0.12777525f, 
    0.03354804f, 0.09397638f, 0.03552222f, 0.04450662f, -0.10065583f, 0.07534691f, -0.01197815f, 0.13803929f, 
    -0.15266833f, -0.06709562f, -0.20648967f, 0.00980026f, -0.30458522f, -0.08731303f, 0.01253452f, 0.14170738f, 
    -0.04527934f, -0.06248644f, -0.00687872f, -0.05484705f, 0.04700333f, -0.06365824f, 0.03001409f, -0.10705031f, 
    0.01502457f, 0.05629055f, -0.04191179f, -0.06111732f, -0.05405476f, 0.04157698f, -0.00211134f, 0.00225751f, 
    0.00694839f, 0.07251465f, -0.07008636f, 0.01628404f, 0.06377782f, -0.05348644f, -0.14234547f, -0.08796076f, 
    -0.06078382f, -0.00912987f, -0.00029889f, -0.01917566f, -0.10252970f, 0.00896167f, -0.03816755f, 0.04311141f, 
    0.01379666f, 0.05833437f, 0.00327919f, -0.11043188f, 0.03453866f, -0.09484719f, -0.02628818f, -0.00713136f, 
    0.04077652f, -0.00569772f, 0.02620964f, -0.10248012f, 0.03630132f, -0.03523054f, -0.05262689f, -0.00531462f, 
    -0.00715893f, -0.06735040f, -0.05571365f, -0.05249508f, -0.00394911f, -0.08903416f, -0.00106214f, -0.05220088f, 
    -0.10471427f, 0.05202848f, -0.03458442f, -0.07513352f, 0.03824484f, -0.04965075f, 0.04160913f, 0.06346581f, 
    0.00889318f, -0.00066106f, 0.01036036f, -0.03629529f, -0.09664498f, -0.03428011f, -0.02521156f, -0.06327887f, 
    -0.04865691f, 0.04144317f, -0.04145225f, 0.00339158f, 0.03829046f, -0.09495673f, 0.05585747f, -0.01450606f, 
    0.00590761f, -0.03343066f, 0.02872333f, 0.03480429f, -0.06688183f, -0.05492584f, -0.01140636f, 0.03493335f, 
    0.02983124f, 0.05279713f, -0.03810569f, -0.10045301f, -0.10027210f, 0.03856869f, 0.06710605f, 0.04042075f, 
    -0.03002113f, -0.07790092f, -0.07148807f, 0.00823552f, -0.08230900f, -0.01952763f, 0.01028796f, 0.02550949f, 
    -0.08075432f, -0.09546991f, -0.05572509f, 0.04927311f, -0.07275466f, -0.01377219f, 0.05309901f, -0.01462740f, 
    -0.06133302f, -0.07031911f, 0.00353805f, -0.01772549f, -0.07363296f, 0.02779213f, 0.05669228f, -0.02992645f, 
    -0.01984336f, -0.00133594f, 0.04946558f, -0.02978854f, 0.02622428f, 0.01231103f, -0.06946146f, -0.07920809f, 
    0.60536522f, -0.17526257f, 0.05169380f, 0.22161068f, -0.25161010f, -0.20655391f, -0.18499473f, 0.15287003f, 
    0.06390779f, 0.01396584f, -0.07483456f, -0.04006539f, -0.32707438f, 0.33720264f, 0.41818923f, 0.08794918f, 
    -0.17307167f, 0.06185050f, 0.23971021f, 0.06030321f, 0.06624913f, 0.08753613f, -0.07918610f, -0.07668895f, 
    0.12726790f, -0.05009791f, 0.02407799f, -0.23779713f, 0.20109659f, 0.13641119f, -0.02436250f, 0.00427374f, 
    0.15970242f, 0.15808697f, -0.05472637f, -0.49519619f, 0.06589521f, -0.20650657f, 0.28277752f, 0.21210532f, 
    0.06799732f, -0.10149462f, -0.03998086f, 0.11661332f, 0.01521904f, 0.04328024f, 0.15180947f, -0.12536055f, 
    -0.03905867f, 0.04450444f, 0.03968010f, -0.07810076f, -0.12121891f, -0.11369275f, 0.12400818f, 0.68604249f, 
    -0.09829015f, 0.22292288f, 0.13738735f, -0.18008927f, -0.03850663f, 0.06998266f, 0.20837912f, 0.23118153f, 
    -0.20079200f, 0.04783995f, 0.00503117f, 0.21547244f, 0.10651105f, 0.15639466f, -0.06149424f, -0.06894568f, 
    0.32665628f, -0.01908470f, 0.01949871f, 0.02504383f, -0.33909151f, 0.22073942f, 0.19160818f, 0.27852792f, 
    -0.17277341f, -0.24602048f, 0.24730113f, 0.17706195f, -0.24038205f, 0.07347537f, 0.15622716f, 0.00452077f, 
    0.29305303f, 0.07842523f, 0.30541545f, 0.22646870f, -0.12912665f, -0.23009337f, 0.19340214f, -0.13964127f, 
    -0.00686273f, 0.01530923f, 0.16241302f, -0.14921914f, 0.08024782f, 0.02684600f, 0.00820370f, -0.05294649f, 
    0.15198979f, -0.08956870f, -0.00994534f, 0.00751004f, 0.01640039f, -0.33843437f, -0.19556989f, -0.14202997f, 
    -0.06400861f, -0.04610009f, 0.02263801f, -0.00318764f, -0.05960430f, 0.15709071f, 0.04945054f, 0.12885275f, 
    0.14027040f, -0.24499950f, 0.32985440f, 0.28191057f, 0.37346476f, -0.01940912f, -0.01259051f, -0.21626344f, 
    -0.07972322f, -0.24688964f, 0.16395578f, 0.09469917f, -0.11320825f, 0.34556904f, 0.17643438f, 0.08884684f, 
    -0.08737683f, 0.02191627f, 0.03385894f, 0.04169163f, -0.25126615f, 0.04381375f, 0.02100705f, 0.13937268f, 
    -0.06755504f, -0.00180439f, 0.20430081f, 0.02347672f, 0.02449610f, 0.21477507f, -0.29467520f, 0.15474482f, 
    0.28881595f, -0.38084304f, -0.00943774f, -0.03648131f, -0.21718206f, 0.00303010f, -0.00606246f, 0.07367338f, 
    -0.10578912f, -0.15393464f, 0.32744786f, 0.21742816f, 0.21518494f, -0.15595289f, 0.11805411f, -0.06862395f, 
    -0.06875204f, 0.02973704f, 0.19003373f, -0.33512825f, 0.31220764f, 0.15906753f, -0.00657692f, 0.20057924f, 
    -0.16687813f, -0.02079193f, -0.00601597f, 0.26513281f, -0.28908205f, -0.23560260f, 0.14187330f, 0.33032009f, 
    0.07751328f, 0.20657419f, -0.14746493f, -0.47647530f, 0.00992113f, 0.01091757f, 0.04670276f, 0.09162159f, 
    -0.22890104f, -0.04609159f, 0.01909704f, 0.11500069f, -0.11228398f, 0.15480898f, -0.32821903f, -0.11819679f, 
    0.31865326f, -0.03372894f, -0.06162287f, 0.01805029f, 0.36167380f, 0.09924918f, -0.07303374f, 0.32184759f, 
    0.23738316f, 0.23808090f, 0.05057634f, 0.24419791f, -0.09314031f, -0.04143276f, 0.20381296f, -0.00995127f, 
    0.05849941f, 0.02713892f, 0.12159798f, -0.11577529f, -0.14703111f, 0.08864208f, 0.09624584f, -0.45865920f, 
    -0.06663638f, -0.02384952f, -0.04887860f, 0.06308404f, -0.19355446f, -0.04102733f, 0.00364606f, -0.15704148f, 
    0.11352848f, -0.16209690f, 0.22375309f, 0.01960364f, 0.22461344f, -0.16058144f, 0.25926661f, -0.34343299f, 
    0.02990505f, 0.03222015f, 0.04936184f, -0.04509487f, -0.15492554f, -0.35436377f, 0.07237741f, 0.12269508f, 
    0.09470791f, -0.05458412f, -0.40018180f, 0.22232877f, 0.34946048f, -0.33157805f, 0.04336537f, -0.13437350f, 
    -0.02539764f, 0.01565770f, 0.02245928f, -0.03355151f, 0.03884582f, -0.01868504f, -0.07749373f, 0.03124679f, 
    -0.06998713f, -0.01572452f, 0.06090641f, 0.07270630f, -0.03513613f, -0.06464363f, -0.05919884f, -0.04059049f, 
    0.05159716f, 0.05574789f, -0.04937388f, -0.03087286f, 0.06158377f, 0.02473028f, -0.00145645f, 0.03576020f, 
    0.01998973f, -0.07113953f, -0.03653392f, 0.01752642f, -0.05207473f, -0.07677178f, -0.01827703f, -0.02607070f, 
    -0.03028378f, -0.02695032f, 0.02298475f, -0.13921630f, -0.01510859f, -0.03902032f, 0.02845652f, 0.01925598f, 
    0.05859799f, -0.02773426f, -0.06399503f, -0.01436120f, 0.06580798f, 0.07849191f, 0.04788192f, 0.00802116f, 
    -0.13382119f, 0.01527900f, 0.00851964f, -0.03349898f, -0.01539466f, 0.03870571f, -0.01936847f, -0.02336222f, 
    0.04409240f, 0.01768718f, -0.10016544f, -0.01139984f, -0.09796692f, -0.05609970f, 0.11054172f, -0.06104020f, 
    -0.04109641f, 0.03145222f, -0.06538940f, -0.00046598f, -0.01879118f, -0.04174561f, -0.00953594f, -0.08053261f, 
    -0.04190752f, -0.00242768f, -0.01165864f, 0.05416914f, 0.00424943f, -0.11092581f, -0.09458939f, 0.02197294f, 
    -0.00950965f, 0.00926042f, -0.09291071f, -0.05305963f, -0.07125889f, 0.04406333f, -0.02312285f, 0.02618345f, 
    0.02013661f, 0.07898080f, 0.01757026f, -0.06212521f, 0.04162089f, -0.02782373f, -0.00825804f, 0.01952352f, 
    -0.08261628f, 0.06591154f, 0.05392937f, -0.07820673f, -0.01304375f, -0.08842789f, -0.11341404f, -0.02228770f, 
    -0.06778038f, -0.05460010f, -0.05999301f, 0.05559275f, -0.10654403f, 0.01072114f, 0.01973381f, -0.07282923f, 
    -0.10911390f, -0.04421973f, -0.05893677f, 0.03373212f, 0.01537244f, 0.00602882f, 0.05851156f, -0.04440625f, 
    -0.02271292f, 0.01988381f, -0.08620488f, -0.07275473f, 0.04776314f, -0.11422756f, -0.02751091f, -0.02627953f, 
    -0.19933030f, 0.10718572f, -0.03166064f, 0.06311671f, -0.01331634f, 0.05732226f, -0.11233414f, -0.14396413f, 
    -0.12487622f, -0.04527442f, -0.08170948f, 0.04246555f, -0.04607797f, 0.14687650f, -0.09686469f, -0.04553906f, 
    0.17967455f, 0.07797738f, -0.03318995f, 0.06997915f, 0.08025280f, -0.01073387f, 0.06139043f, -0.01027588f, 
    -0.35882509f, 0.14068760f, -0.06585067f, 0.01066721f, 0.13627200f, -0.00612750f, -0.01766763f, 0.23373459f, 
    0.06417576f, 0.26105466f, -0.03176149f, -0.00957410f, -0.30165890f, 0.07016670f, -0.16372515f, 0.11327706f, 
    -0.01712878f, 0.22537579f, 0.50781739f, -0.02564980f, 0.16340777f, 0.35567820f, 0.03026728f, 0.38740954f, 
    0.01822495f, 0.06760600f, 0.02262843f, 0.13335668f, 0.26920214f, 0.21485126f, -0.08732962f, -0.03068442f, 
    -0.11441234f, 0.06264547f, 0.22602189f, 0.01973705f, 0.16808170f, 0.35328957f, -0.11475927f, 0.02300764f, 
    -0.08601604f, 0.08272943f, -0.00553066f, 0.04095812f, -0.10671859f, 0.37585101f, 0.12444986f, 0.28283089f, 
    0.07965872f, 0.05589402f, -0.01540505f, -0.14117345f, -0.01763511f, 0.10227135f, -0.10631026f, -0.11553110f, 
    0.12867925f, -0.15341094f, -0.04109027f, -0.15322457f, 0.16720425f, 0.03890755f, 0.00888358f, 0.06304577f, 
    -0.24123538f, 0.05780470f, -0.02556814f, 0.02255513f, 0.07768431f, 0.02330439f, 0.07977793f, 0.22068246f, 
    0.03330243f, -0.08537038f, 0.08772061f, -0.34460005f, 0.12080036f, 0.12026983f, 0.17971338f, -0.12372308f, 
    -0.05366521f, 0.05221660f, 0.07133927f, -0.11241069f, -0.10121056f, -0.11732543f, 0.01796929f, -0.13835561f, 
    -0.10447638f, 0.19295162f, 0.04039602f, -0.06845126f, -0.05967573f, 0.00243605f, 0.05554045f, 0.11506523f, 
    -0.07549539f, 0.06284727f, -0.10704432f, -0.07974839f, -0.09976344f, 0.23625256f, -0.08069713f, -0.01881160f, 
    -0.19685954f, 0.08347654f, 0.09482521f, 0.08305974f, 0.02442051f, -0.61372846f, -0.04602962f, -0.11292725f, 
    -0.11913430f, 0.00456338f, 0.05586484f, -0.26418194f, 0.60896063f, 0.09633416f, -0.04940407f, -0.46100140f, 
    0.03466421f, -0.05302280f, 0.20265676f, 0.03695973f, 0.01448296f, 0.04026875f, -0.35232738f, 0.07556083f, 
    -0.38108537f, 0.01937117f, 0.06510717f, 0.11592210f, 0.17201380f, 0.20412867f, -0.02063937f, 0.14582485f, 
    -0.20869388f, -0.10549639f, 0.06559533f, 0.07670102f, -0.15457773f, 0.17208816f, -0.10279491f, -0.10073194f, 
    0.07998254f, -0.67712426f, 0.26571968f, -0.23126861f, 0.18341970f, 0.21624312f, 0.23274678f, -0.32272872f, 
    0.16274554f, 0.06005562f, 0.06193651f, 0.19063197f, 0.11647297f, 0.34838715f, 0.20230575f, -0.08524883f, 
    -0.01056042f, 0.02365208f, 0.10601950f, -0.06195039f, 0.16364765f, 0.08920206f, -0.03411449f, -0.26191291f, 
    -0.00044943f, -0.27739745f, -0.04824004f, 0.10105208f, 0.17509548f, -0.22485088f, -0.25960666f, 0.27307951f, 
    -0.04264417f, 0.04680966f, -0.04760109f, 0.01930507f, -0.16068634f, 0.11629519f, -0.16318941f, -0.09045159f, 
    -0.22739075f, 0.03574897f, 0.06385577f, -0.14648710f, 0.14616914f, -0.07385584f, 0.33770016f, -0.00447840f, 
    0.11916616f, 0.04762406f, 0.00740810f, 0.02984294f, 0.08485848f, 0.25707898f, 0.22940549f, 0.26354840f, 
    -0.12665921f, 0.05218260f, 0.09728250f, -0.28106564f, 0.04962465f, -0.01654123f, -0.15524925f, -0.15162385f, 
    0.05519726f, -0.11961212f, -0.09742364f, 0.07862797f, 0.22737832f, 0.21571082f, -0.24637139f, -0.26303306f, 
    0.35261780f, -0.02013817f, -0.03001653f, -0.07766054f, -0.07468308f, 0.25081700f, -0.34907448f, 0.16795439f, 
    0.02341160f, -0.07949400f, -0.32638520f, 0.06103891f, 0.13450485f, 0.17073359f, 0.14502795f, -0.13401239f, 
    0.36279523f, -0.09583271f, -0.18009615f, 0.11338709f, -0.10131446f, -0.01741725f, -0.35273063f, 0.09504168f, 
    0.26755723f, 0.00076880f, -0.03574027f, 0.24096884f, 0.77782172f, 0.07087278f, 0.26458448f, 0.08882088f, 
    0.19280161f, -0.02814993f, 0.20232508f, -0.27918184f, 0.04716468f, -0.18903667f, -0.00207012f, -0.23615614f, 
    0.03385193f, 0.09122140f, 0.14982630f, 0.18415992f, -0.15698478f, 0.00647301f, -0.02061445f, -0.29979566f, 
    -0.07156812f, 1.04242265f, -0.09859395f, -0.19065446f, -0.09296814f, -0.28239027f, 0.05506328f, 0.06623174f, 
    0.01317120f, 0.41299224f, -0.29579499f, 0.35725477f, -0.26367736f, -0.45184824f, -0.23943011f, 0.26479918f, 
    -0.13604893f, 0.02972002f, 0.06598605f, -0.42375612f, -0.08536054f, -0.01463344f, -0.50900275f, 0.36973363f, 
    0.10053053f, -0.08133301f, 0.09988227f, 0.02503968f, -0.55079848f, 0.18369386f, 0.28176039f, 0.11900612f, 
    0.23552711f, 0.13540117f, -0.05591515f, 0.11443296f, -0.05797577f, 0.22043069f, -0.03506463f, -0.26856890f, 
    0.24059993f, 0.04205321f, -0.01270363f, 0.10351295f, 0.21556048f, -0.36720753f, -0.10454916f, -0.25665218f, 
    -0.01875986f, -0.16629805f, -0.03178222f, -0.11137100f, -0.02112702f, -0.07752980f, -0.04060028f, -0.02915984f, 
    -0.04688400f, -0.05533469f, -0.00958966f, -0.25766018f, 0.22253999f, -0.24784359f, 0.00121676f, -0.24690016f, 
    0.15177846f, 0.02749853f, 0.21992078f, -0.14880468f, 0.05578768f, -0.12017538f, -0.05233966f, 0.01349902f, 
    -0.05523827f, -0.10410615f, -0.24844430f, 0.06699677f, -0.16866083f, -0.34761354f, -0.04349766f, -0.05497793f, 
    -0.11392751f, -0.01565847f, -0.02329503f, 0.03939561f, 0.00357673f, 0.14247371f, 0.32598075f, -0.43472275f, 
    -0.31650972f, 0.00060252f, 0.03340967f, 0.42315146f, 0.02821298f, -0.08803850f, -0.08183965f, 0.09940052f, 
    0.01137132f, 0.17313902f, 0.07131080f, -0.04741905f, 0.41390562f, 0.23577170f, -0.08541598f, 0.28876191f, 
    0.22986566f, 0.02325626f, 0.01020565f, 0.08435864f, 0.33778843f, -0.08370242f, 0.00400069f, 0.33314073f, 
    0.01258817f, 0.00534413f, -0.42025548f, 0.10465223f, -0.06404541f, -0.07020525f, -0.04343149f, 0.19829907f, 
    0.22303858f, 0.08891658f, 0.24594580f, -0.23078868f, 0.06425643f, 0.14129701f, 0.06404403f, -0.14380482f, 
    -0.04296109f, 0.29804075f, 0.21262135f, -0.43303013f, 0.09534384f, 0.03438923f, 0.05768520f, 0.14160459f, 
    0.13432010f, 0.22955455f, -0.27144521f, 0.08431955f, 0.18758498f, -0.05995606f, -0.20432265f, 0.19029970f, 
    -0.07430902f, -0.05878808f, -0.04037963f, -0.07905680f, -0.25043768f, 0.09915087f, 0.12318692f, -0.15268955f, 
    0.14218862f, -0.09402274f, -0.02705689f, -0.06172203f, 0.06234255f, 0.00147938f, 0.42080373f, -0.01491113f, 
    -0.45638275f, -0.11430243f, 0.08148736f, 0.20823623f, 0.00094699f, -0.03704572f, -0.16424406f, -0.17556021f, 
    -0.32321879f, 0.04667939f, 0.04579117f, 0.15551916f, 0.24258919f, 0.03950056f, 0.16808616f, 0.09559482f, 
    -0.10994390f, 0.24134158f, 0.09330147f, 0.07159450f, 0.05124207f, -0.04477190f, -0.16098170f, -0.05391462f, 
    0.27041674f, 0.03590527f, -0.01541950f, 0.06402200f, -0.19056611f, -0.07069809f, -0.29006916f, -0.13386206f, 
    0.01682858f, -0.11145142f, 0.03750363f, 0.11763123f, 0.05601411f, 0.04108164f, 0.00461434f, 0.10895829f, 
    0.19726785f, 0.09161624f, 0.04152840f, 0.09293477f, 0.10895375f, 0.68787938f, 0.22633417f, 0.05316334f, 
    -0.12642923f, 0.11021833f, -0.02118306f, 0.03141268f, 0.09635901f, -0.02186580f, 0.14863244f, 0.18495752f, 
    0.12090271f, 0.03759363f, -0.15273640f, -0.00426003f, -0.07875605f, -0.18525545f, 0.16395397f, 0.14513615f, 
    -0.09637854f, -0.01853527f, -0.09572339f, 0.19607539f, -0.09281287f, 0.22999418f, -0.19929193f, 0.21566390f, 
    -0.06516647f, 0.04056179f, -0.15982045f, -0.04960193f, -0.41234654f, 0.26132569f, 0.29589993f, 0.13534945f, 
    -0.01454103f, -0.02383777f, 0.01890302f, 0.51930958f, 0.07233822f, 0.18820131f, -0.45417744f, 0.03067896f, 
    0.07542505f, -0.17158183f, -0.03715262f, -0.07701296f, 0.13760363f, 0.08758388f, -0.07783947f, 0.02161774f, 
    -0.36072364f, -0.39564025f, 0.21295436f, -0.45001921f, 0.08211651f, 0.15169325f, 0.21701321f, 0.14608830f, 
    -0.04653602f, -0.20370148f, 0.08740882f, -0.33553353f, 0.38568318f, 0.27960184f, 0.35600272f, -0.04726472f, 
    -0.14283985f, -0.02812956f, -0.01882163f, 0.09798298f, -0.01101919f, -0.25305253f, 0.52418071f, 0.21012093f, 
    -0.06950925f, 0.23285240f, 0.25659779f, -0.32987854f, -0.01010257f, 0.16528554f, -0.00377493f, 0.27428013f, 
    -0.31739888f, -0.06728751f, 0.04750198f, 0.16209820f, 0.08126374f, -0.05480371f, 0.04577254f, -0.09997629f, 
    0.38163996f, 0.01100700f, -0.08082579f, 0.09715357f, -0.22499108f, 0.09787212f, 0.20477404f, 0.15289387f, 
    0.18051268f, 0.12154548f, 0.05400206f, 0.11553936f, 0.02787459f, 0.04538007f, 0.26215541f, 0.04116599f, 
    -0.30998531f, -0.04326658f, -0.33766475f, -0.03100727f, -0.27878392f, -0.04684214f, -0.09034762f, -0.06267126f, 
    -0.06291337f, -0.01453873f, 0.13065186f, 0.06531045f, 0.05656761f, -0.11256236f, -0.28440067f, -0.15255463f, 
    0.04876669f, 0.06813008f, -0.25498089f, 0.13712163f, -0.03865915f, 0.10057659f, -0.09645273f, -0.09376575f, 
    -0.27612546f, 0.07091217f, -0.06786811f, -0.01330934f, -0.45081550f, 0.25241169f, 0.09584722f, 0.09920970f, 
    0.22887564f, -0.18015070f, 0.34230477f, -0.02656084f, 0.05970621f, 0.00514051f, 0.10164616f, -0.09651154f, 
    -0.11498596f, -0.04440302f, -0.09131359f, 0.07416293f, 0.16933407f, 0.14365222f, 0.13651355f, -0.00336551f, 
    0.11895305f, -0.08044778f, 0.04541691f, 0.02433792f, -0.09381075f, 0.09988844f, 0.06523333f, -0.03194730f, 
    -0.13248990f, 0.07117090f, -0.09528439f, -0.31254348f, -0.07374799f, -0.09445745f, -0.38535395f, 0.04954743f, 
    0.03693957f, -0.26666275f, 0.06498373f, 0.36750033f, -0.05391840f, 0.05483156f, -0.02746178f, -0.15857451f, 
    -0.22918350f, -0.43706372f, 0.18000731f, -0.19162095f, 0.16331938f, 0.16338243f, 0.01698192f, 0.04683387f, 
    -0.02679848f, 0.30566311f, -0.01843650f, -0.14959913f, 0.11331731f, -0.01490360f, -0.32424867f, -0.17997548f, 
    -0.20869978f, 0.04074981f, 0.05452203f, -0.02977184f, 0.04007139f, 0.30085573f, 0.19180760f, 0.05291446f, 
    0.32926840f, -0.02403622f, 0.07298736f, -0.34829134f, 0.00024824f, -0.06386050f, -0.23012535f, -0.12607913f, 
    -0.57480121f, -0.32834631f, 0.02216206f, -0.05954454f, -0.05556342f, 0.02204877f, -0.13575976f, -0.12190846f, 
    -0.10427838f, 0.01383206f, 0.02840941f, 0.29679382f, 0.39982530f, 0.00066796f, -0.08218365f, 0.22887112f, 
    0.10056707f, -0.05364624f, -0.10303287f, 0.31009391f, -0.10824323f, 0.05075239f, 0.03445746f, -0.03348095f, 
    0.23442435f, -0.00032652f, -0.11513632f, -0.13895026f, -0.21803042f, 0.01612614f, 0.08140474f, -0.33574983f, 
    0.22387843f, -0.00099309f, 0.35816333f, -0.05157179f, -0.08754838f, -0.00339867f, -0.14611055f, 0.29472044f, 
    -0.06353820f, -0.21606553f, 0.10976163f, 0.26352483f, 0.13927612f, 0.56836504f, 0.09599938f, -0.07308722f, 
    0.05753727f, 0.03689297f, -0.06784395f, -0.02610861f, 0.15491767f, -0.27175727f, 0.18370819f, 0.04481455f, 
    0.18221259f, -0.30750594f, 0.04588175f, 0.02668295f, 0.03862235f, -0.41435134f, 0.16836868f, 0.03273251f, 
    0.01893300f, 0.02102907f, -0.07061256f, 0.05941946f, 0.04755018f, 0.08284817f, -0.03741688f, 0.00847730f, 
    -0.00510530f, -0.02914532f, -0.10904386f, -0.07391536f, -0.02677706f, -0.02230040f, 0.01783521f, 0.02897877f, 
    -0.02807236f, 0.02650273f, 0.02066920f, 0.05834072f, -0.00025898f, -0.06948810f, -0.06342706f, -0.09653272f, 
    0.00880373f, -0.10070830f, -0.03245270f, 0.05936059f, -0.04975267f, -0.00583681f, -0.05649473f, -0.05519618f, 
    0.08480431f, 0.06028924f, 0.03588291f, 0.04647617f, -0.09733211f, -0.02899513f, -0.06564811f, -0.07056686f, 
    0.00989403f, -0.10120486f, -0.00238702f, -0.06410658f, 0.05375496f, -0.04365274f, -0.01944561f, 0.06644754f, 
    -0.11180370f, -0.05804283f, -0.05891305f, 0.03735604f, -0.01257379f, -0.02242629f, 0.06968854f, -0.11608835f, 
    -0.09291419f, -0.07812744f, -0.10073138f, 0.07065739f, -0.02260368f, -0.09687904f, 0.00728722f, -0.10598463f, 
    0.02263155f, -0.09874272f, 0.00964230f, -0.10333066f, 0.03011415f, 0.01672033f, 0.00878284f, -0.01294212f, 
    0.00356679f, 0.03496363f, -0.07738067f, 0.04631822f, -0.04406146f, -0.02819687f, 0.05235913f, -0.01673179f, 
    0.00734262f, -0.09769324f, -0.01865198f, -0.01151721f, 0.02150783f, 0.06315474f, -0.04747477f, -0.01849653f, 
    -0.05322547f, 0.00166047f, -0.01334032f, -0.10795050f, -0.08641690f, -0.08371677f, -0.05995743f, 0.02912362f, 
    0.04294520f, -0.05496114f, -0.08781321f, 0.03529244f, -0.03797553f, 0.01547021f, -0.09624994f, -0.01149656f, 
    0.04091182f, 0.04340559f, -0.02246537f, -0.03741370f, -0.04341302f, -0.08532010f, 0.06705533f, -0.08509067f, 
    0.01511453f, 0.04313815f, 0.06601764f, 0.03087390f, -0.06873795f, -0.11005121f, -0.03136911f, 0.01612735f, 
    0.00766136f, 0.01842413f, -0.09707234f, -0.00662188f, 0.06575932f, 0.03252479f, 0.07175266f, 0.00806557f, 
    0.20957902f, 0.22584355f, 0.05046229f, -0.15597066f, -0.09327307f, -0.17306282f, -0.27319720f, -0.03388043f, 
    -0.15568016f, -0.06321780f, 0.17997620f, -0.38358048f, -0.02591876f, -0.01652981f, -0.42218402f, 0.20076896f, 
    0.54728210f, -0.05222323f, 0.22832961f, -0.23752870f, 0.00839687f, -0.06945691f, 0.01461018f, -0.05338854f, 
    -0.27049485f, -0.09429807f, 0.04980821f, -0.53090322f, 0.13819939f, 0.04580204f, 0.01349801f, 0.08587055f, 
    -0.04983315f, -0.30750075f, -0.29670289f, 0.38310078f, -0.31620094f, -0.04225913f, -0.16170052f, -0.15528034f, 
    -0.03260513f, -0.27092639f, -0.33255869f, 0.09217897f, -0.53039163f, -0.06848652f, 0.20500663f, -0.03430727f, 
    0.26088443f, -0.04212725f, 0.06089055f, 0.06350686f, 0.06208862f, 0.32121581f, -0.28270504f, -0.02659832f, 
    -0.36041358f, -0.02911491f, 0.09691643f, 0.17458284f, 0.12475311f, 0.08509389f, -0.06247910f, -0.59551573f, 
    -0.03175439f, -0.07401928f, -0.08819281f, 0.01233743f, 0.10165752f, 0.40303895f, -0.17335884f, 0.07025028f, 
    0.18752225f, 0.05858810f, -0.03637376f, -0.73805308f, 0.01447941f, 0.09192874f, 0.17751583f, 0.06749072f, 
    -0.04975465f, -0.08150437f, 0.02441921f, -0.27714041f, 0.46990192f, 0.05091386f, -0.10248797f, -0.03684565f, 
    0.05276753f, 0.06380393f, 0.22756325f, 0.03536247f, 0.19976121f, 0.09744100f, -0.03492550f, 0.05691563f, 
    -0.49230492f, -0.06010937f, -0.43649805f, -0.23151867f, -0.04024369f, 0.09297025f, 0.12206817f, -0.04316962f, 
    0.06257258f, -0.01838861f, -0.27110353f, -0.54412127f, 0.13006063f, -0.34235853f, 0.04416443f, -0.11189181f, 
    0.29986408f, 0.02452067f, -0.01660450f, 0.03783486f, -0.19327459f, 0.05368019f, -0.19930492f, 0.12966116f, 
    -0.07515050f, -0.10242455f, -0.16408405f, 0.14436994f, 0.01715913f, 0.13979839f, -0.05059934f, -0.09989959f, 
    -0.03511371f, -0.09735667f, -0.04931486f, -0.03226614f, -0.07130430f, 0.02476677f, -0.00129062f, 0.01569200f, 
    -0.06604514f, -0.08224051f, -0.06230855f, -0.00067799f, 0.04923342f, -0.08713803f, -0.06913614f, -0.08730232f, 
    -0.02480590f, 0.06884266f, -0.06943925f, 0.04224811f, -0.04009549f, 0.04660824f, -0.02101301f, -0.05677769f, 
    0.07772862f, 0.02641250f, 0.03467728f, 0.05121778f, -0.09373107f, -0.08433139f, -0.06344621f, -0.03029398f, 
    -0.03176537f, 0.03704512f, -0.01986962f, -0.10521718f, -0.08283387f, -0.11346078f, -0.04302436f, 0.05439828f, 
    0.06959421f, 0.00663552f, -0.07109789f, 0.02846503f, 0.00649642f, 0.00654176f, -0.01383562f, 0.01174780f, 
    0.01096220f, 0.02830748f, -0.03389272f, -0.07831959f, -0.00698341f, -0.02321954f, -0.04268403f, -0.06872741f, 
    -0.03552435f, 0.05700259f, -0.00213795f, 0.00309308f, -0.07385447f, 0.00926179f, -0.04580081f, -0.07569245f, 
    -0.03904540f, -0.07585064f, 0.01352165f, 0.03661284f, 0.03481003f, -0.08390494f, -0.02845493f, -0.06569156f, 
    -0.01865636f, 0.05842477f, -0.02380929f, -0.08869702f, 0.08485192f, 0.06663471f, 0.02457017f, 0.02703957f, 
    -0.02840854f, -0.03679782f, -0.04530097f, -0.08020199f, 0.03401092f, -0.07902329f, 0.04800867f, -0.06010940f, 
    -0.05154938f, 0.05042631f, -0.08331589f, -0.04714346f, -0.09864190f, 0.05516778f, 0.00295906f, 0.05382286f, 
    -0.09605893f, 0.02511945f, 0.04626539f, 0.04955859f, -0.03925428f, -0.08848466f, 0.04669072f, -0.02934858f, 
    -0.03100125f, 0.03838577f, 0.03801728f, 0.04456647f, -0.03167187f, -0.01953044f, 0.07669187f, -0.03136048f, 
    0.07538705f, -0.07369263f, -0.05798154f, 0.04113276f, 0.02128364f, 0.01037983f, -0.09263046f, 0.03443179f, 
    -0.07207116f, 0.02593704f, -0.03309469f, 0.05404181f, -0.06236865f, 0.01473126f, 0.06292908f, -0.11290933f, 
    -0.06310671f, -0.00558575f, -0.10603549f, 0.07380135f, -0.01433946f, 0.25055811f, 0.03026393f, 0.34839338f, 
    -0.00109967f, -0.09156300f, -0.11553618f, 0.07776359f, 0.07602452f, 0.28239521f, 0.05999395f, 0.24547954f, 
    -0.09044967f, 0.06371824f, 0.11533434f, 0.16200511f, -0.02170699f, 0.15537368f, -0.18688686f, 0.26011127f, 
    0.21944997f, -0.26813504f, -0.00042798f, -0.13730010f, -0.00791910f, 0.12058480f, -0.02635172f, -0.24812374f, 
    -0.23785169f, -0.27403626f, 0.19418523f, 0.12208875f, 0.10933205f, 0.05031097f, 0.06380276f, -0.06851979f, 
    0.14891487f, -0.03145598f, -0.44302103f, -0.28262886f, 0.25209928f, 0.04639379f, -0.23769017f, 0.00733186f, 
    -0.55472451f, -0.01600470f, 0.00372173f, 0.03972656f, -0.24644616f, -0.07039960f, 0.42629126f, 0.12039519f, 
    0.09011738f, 0.29340079f, 0.12100564f, -0.43532330f, -0.12965792f, 0.00431491f, 0.14961933f, 0.06618072f, 
    -0.03253628f, -0.18134372f, 0.01052730f, 0.10565693f, 0.11042751f, -0.10067915f, 0.34492102f, -0.25341874f, 
    0.13825341f, -0.07185096f, -0.08703999f, 0.00557156f, 0.12882413f, 0.27999118f, 0.36100999f, 0.22317846f, 
    0.17289889f, 0.40452084f, 0.07775623f, 0.30074713f, 0.00007743f, 0.08526463f, 0.11834724f, -0.07757355f, 
    -0.06107564f, -0.06824611f, -0.37511036f, -0.16951595f, -0.22860563f, -0.15149330f, -0.23522326f, -0.53856862f, 
    0.00150347f, 0.04823890f, 0.08352421f, 0.28139076f, -0.25824872f, -0.34535483f, -0.05998672f, -0.06430217f, 
    0.15994038f, -0.00527705f, 0.21948288f, -0.01660004f, 0.17929476f, -0.06999285f, 0.03075085f, 0.17060488f, 
    0.01348144f, -0.02940356f, -0.03507933f, 0.05805452f, -0.57110304f, -0.31937215f, -0.13717923f, 0.09485900f, 
    0.26515061f, -0.11457057f, 0.26044834f, -0.03697309f, 0.07659306f, -0.13228670f, 0.10410766f, 0.08022939f, 
    0.12364508f, 0.00825161f, 0.09053443f, -0.05059162f, 0.02502765f, 0.09866071f, 0.20275205f, -0.06699595f, 
    0.01570668f, -0.06312771f, 0.25056255f, -0.01275189f, -0.09615525f, 0.00675079f, -0.19507374f, 0.19382624f, 
    -0.20900361f, 0.08135706f, 0.13011296f, -0.70025009f, -0.07786462f, 0.04498206f, -0.01535115f, 0.15910017f, 
    -0.04423873f, -0.17934535f, -0.10547959f, 0.13428655f, 0.04281766f, -0.05051301f, 0.02815438f, -0.01899425f, 
    0.25087911f, -0.53268105f, 0.16412927f, 0.12809986f, 0.12089140f, -0.12471250f, 0.04644384f, -0.08293112f, 
    -0.06502423f, -0.03954049f, -0.20650589f, -0.09909378f, -0.13084163f, -0.24695177f, -0.23799242f, -0.09018910f, 
    0.23928796f, -0.06533923f, -0.02980763f, 0.12306619f, -0.01637909f, 0.27945358f, 0.08686615f, 0.09818087f, 
    0.13842039f, 0.11570739f, -0.15409735f, 0.00087569f, 0.04769616f, -0.21599582f, 0.21115264f, -0.14008293f, 
    -0.66737491f, -0.56831431f, -0.05090570f, 0.00130435f, -0.01385437f, -0.05110297f, -0.18443035f, 0.14192759f, 
    -0.00842085f, -0.06634378f, -0.03017050f, 0.17521583f, 0.34829840f, 0.15372226f, -0.00828586f, 0.37311715f, 
    -0.25819752f, -0.21742019f, 0.20216730f, 0.12635264f, -0.21310243f, 0.09297846f, 0.11139512f, -0.05084535f, 
    0.47732738f, 0.06736437f, 0.39498302f, -0.01225582f, -0.28148577f, 0.26771536f, 0.14575240f, -0.28209370f, 
    0.05139044f, -0.09003863f, 0.15266821f, -0.07073639f, -0.24919368f, 0.06928230f, 0.06205644f, 0.15438160f, 
    -0.11348744f, -0.45099837f, 0.01616991f, 0.00387618f, 0.25526619f, 0.66804761f, 0.25943819f, 0.02140963f, 
    0.45947525f, 0.02898426f, -0.01148367f, 0.05504320f, 0.30038705f, -0.58417612f, -0.13676055f, 0.07527566f, 
    0.22916833f, -0.62093925f, -0.01422013f, 0.35973787f, 0.37009898f, 0.08645235f, 0.12858923f, -0.11452718f, 
    -0.04014662f, -0.00595152f, 0.01084873f, -0.06025983f, -0.00776688f, -0.07423146f, 0.06674146f, -0.07235518f, 
    0.07981919f, 0.03648314f, -0.07001472f, 0.03297383f, 0.07404257f, -0.06771828f, -0.06509221f, 0.02854690f, 
    0.04644727f, 0.00551411f, 0.03936677f, 0.02939363f, -0.05634179f, -0.07535918f, -0.03223593f, -0.07520454f, 
    0.07194527f, 0.00715052f, 0.04921912f, 0.08724687f, -0.05903005f, 0.06853859f, 0.07486043f, -0.01918027f, 
    0.02170036f, 0.08753725f, -0.00096412f, 0.02017612f, -0.03452125f, -0.00147419f, -0.05432545f, -0.01175509f, 
    0.04994557f, 0.02133362f, 0.05995306f, -0.03813078f, 0.03348996f, -0.01009188f, 0.02656545f, -0.05616190f, 
    0.02543477f, -0.02173180f, -0.00909640f, -0.08746018f, -0.01743257f, -0.00093030f, 0.03791346f, 0.04469450f, 
    -0.08819696f, 0.00189333f, 0.06396993f, -0.07387710f, 0.01046063f, -0.08182764f, -0.05950304f, 0.08651688f, 
    -0.08718338f, 0.05567838f, 0.07226136f, 0.03164675f, -0.00428374f, 0.05796537f, 0.00483616f, -0.06760945f, 
    0.00652810f, 0.00282511f, -0.02957808f, -0.01211813f, 0.03045592f, -0.08159499f, 0.01411009f, 0.07517910f, 
    -0.09001420f, -0.08953214f, -0.00954741f, -0.01324308f, -0.07361558f, -0.06931365f, -0.09406156f, 0.00268305f, 
    0.04375403f, 0.08672968f, -0.10058822f, 0.03812823f, -0.08292741f, -0.02731724f, 0.00012736f, 0.03674505f, 
    -0.02547647f, 0.00447522f, 0.03452612f, -0.00601848f, -0.06389309f, 0.04504436f, 0.03729829f, -0.07526497f, 
    0.00830093f, -0.08299714f, -0.04259287f, -0.08090257f, 0.04136950f, 0.03364417f, -0.01662937f, 0.06421322f, 
    -0.04492095f, 0.00582071f, -0.02523048f, 0.02974714f, -0.07189756f, 0.04679286f, -0.04979568f, 0.03642580f, 
    -0.03767752f, -0.00132664f, 0.02098344f, -0.05936745f, 0.00357941f, 0.02314494f, -0.07619428f, -0.09423861f, 
    0.00878481f, -0.08656549f, -0.10854214f, -0.11436842f, 0.00330795f, -0.05715758f, 0.05761878f, -0.10332286f, 
    -0.03764341f, 0.01304311f, 0.01620400f, -0.00798901f, 0.06575696f, 0.04821204f, -0.05876673f, -0.01342442f, 
    -0.01296548f, -0.01974598f, -0.02042385f, 0.04727771f, 0.04386887f, -0.07436144f, -0.10754133f, -0.00925249f, 
    0.03731413f, -0.00441737f, -0.05053021f, -0.02968132f, -0.12405305f, -0.00360479f, 0.03043343f, 0.01301831f, 
    0.07556715f, -0.04752176f, 0.01054252f, 0.06608155f, -0.08947351f, -0.10551012f, 0.04753127f, -0.09236670f, 
    0.02380316f, 0.02885443f, 0.03783999f, -0.06375682f, -0.07524358f, -0.00150795f, -0.05073137f, -0.09316204f, 
    -0.01744598f, 0.01369899f, -0.07810371f, -0.07358807f, 0.05901534f, 0.04769947f, -0.04557593f, 0.01652738f, 
    0.02435425f, 0.06803737f, -0.04621611f, -0.00640412f, -0.07426008f, 0.01525288f, -0.06203611f, 0.02859096f, 
    -0.04424452f, -0.03164354f, 0.08014377f, -0.07148696f, -0.09675836f, 0.00633235f, -0.08269916f, -0.07538303f, 
    -0.03923417f, 0.07237895f, -0.01324379f, -0.04716476f, -0.04964288f, -0.01497568f, -0.04549756f, -0.06022004f, 
    -0.04045370f, -0.07593088f, -0.05984781f, 0.00223705f, -0.06939456f, 0.03438239f, -0.04873680f, 0.04018987f, 
    -0.06795593f, -0.00895516f, 0.07869868f, -0.06289482f, -0.05391333f, 0.07180017f, 0.00107852f, 0.04441211f, 
    0.01964693f, 0.03375864f, -0.09652343f, -0.12064173f, 0.04043932f, -0.07893357f, 0.00786749f, -0.11045184f, 
    -0.07155430f, -0.03604786f, -0.07630305f, -0.08535782f, -0.08909983f, -0.03167066f, -0.08982892f, 0.03475783f, 
    -0.09489240f, 0.01223213f, 0.01082638f, 0.05794304f, 0.04917650f, -0.01013239f, 0.01824499f, 0.05484642f, 
    -0.08394153f, -0.04688279f, -0.00466997f, -0.07952605f, 0.08041781f, 0.06591378f, -0.03704438f, -0.05842035f, 
    0.15031825f, 0.16053446f, 0.11160754f, -0.01302572f, 0.12710901f, -0.19620967f, -0.25621009f, -0.06200455f, 
    0.03239666f, -0.06547622f, 0.17187946f, -0.02079119f, -0.48056895f, 0.07685657f, 0.33704519f, -0.29577523f, 
    0.33802253f, -0.00564402f, 0.01392474f, -0.11519311f, -0.05363987f, -0.09609800f, 0.00178031f, 0.03052187f, 
    -0.03960215f, 0.07401598f, 0.00457449f, 0.47676501f, -0.00278748f, 0.13751990f, 0.06942943f, 0.11012100f, 
    0.07817787f, -0.35647899f, 0.06538083f, 0.48083749f, 0.04305425f, 0.03305116f, 0.18985513f, 0.06444966f, 
    0.09314214f, -0.02157582f, 0.10078226f, -0.00585677f, -0.03454940f, -0.01054131f, 0.09936462f, -0.27199858f, 
    0.12111314f, 0.04591909f, 0.01520807f, 0.02284544f, 0.21054971f, 0.25529054f, -0.06718287f, -0.03435272f, 
    -0.27188814f, -0.12542826f, 0.02782841f, 0.15065467f, -0.01449062f, 0.06936216f, -0.82283562f, 0.13629827f, 
    -0.09708671f, 0.10892630f, 0.08739372f, 0.07462209f, 0.08103498f, 0.24366242f, -0.04911065f, 0.10080645f, 
    -0.01151872f, 0.02537173f, -0.07956433f, -0.08171973f, -0.47649992f, 0.03882909f, 0.01206196f, 0.11899996f, 
    0.03767310f, -0.22901760f, 0.01688084f, -0.22645895f, 0.06930387f, -0.01358359f, -0.20149140f, 0.06404608f, 
    0.22978723f, -0.00671865f, 0.28464064f, 0.08211055f, 0.17339694f, 0.03535172f, 0.14633684f, 0.07683854f, 
    0.17993869f, 0.11378104f, -0.28506836f, -0.23899990f, 0.12528060f, 0.07168110f, 0.01675442f, -0.04603193f, 
    0.03758394f, 0.02201681f, -0.21627879f, -0.04002227f, 0.04023265f, 0.17045416f, -0.13350782f, -0.16283965f, 
    0.25131553f, 0.06028325f, -0.07002628f, 0.04041601f, 0.03318693f, 0.09341779f, 0.31585336f, 0.08172843f, 
    0.09554698f, -0.05149522f, 0.01713097f, 0.02960140f, 0.02749022f, 0.07147024f, 0.07793616f, 0.03491144f, 
    -0.01357081f, 0.02176902f, 0.04169966f, -0.05877380f, -0.00265716f, -0.02136889f, 0.07072333f, 0.04792773f, 
    -0.06993238f, -0.04548237f, -0.07693160f, -0.05985194f, -0.02145339f, 0.01392066f, -0.02890447f, 0.03122181f, 
    0.05802729f, -0.02180345f, 0.00265501f, -0.02419531f, 0.02969855f, -0.10675061f, 0.03989507f, -0.04179074f, 
    0.04696931f, -0.05533101f, -0.01687158f, 0.00119025f, -0.04155557f, 0.06277788f, -0.02697616f, -0.09816678f, 
    -0.07661290f, 0.06943412f, 0.03518296f, -0.04664364f, -0.06315244f, 0.05400242f, 0.00656388f, 0.06189886f, 
    0.05867817f, 0.05661770f, 0.03934538f, -0.05382213f, -0.09175295f, -0.01656646f, 0.05881533f, -0.05247275f, 
    -0.02687121f, 0.04071034f, -0.01946602f, 0.02165219f, -0.09817599f, 0.05534537f, 0.07744335f, 0.02083619f, 
    -0.05271500f, -0.02451541f, 0.01375869f, 0.01359853f, -0.09288532f, -0.05766601f, 0.00178355f, -0.07454551f, 
    -0.08610100f, -0.08810738f, 0.03908133f, 0.00626370f, -0.06046942f, -0.01272277f, 0.06799024f, 0.02895502f, 
    0.06535221f, 0.00952138f, -0.02746530f, 0.01456542f, -0.00090149f, -0.01582997f, -0.03496521f, 0.06825757f, 
    -0.01059248f, 0.02144722f, -0.04916562f, -0.07599710f, 0.05441955f, 0.05791451f, 0.03775223f, 0.08237156f, 
    -0.07069173f, -0.07969592f, -0.05789836f, -0.00095307f, 0.05184511f, -0.03138891f, 0.04324621f, -0.00100854f, 
    0.02733197f, 0.04508173f, -0.06115279f, -0.02522879f, 0.02251202f, 0.03988778f, -0.02899609f, -0.03344427f, 
    0.01467780f, 0.06453666f, -0.02364628f, 0.03419616f, 0.02197920f, -0.03872854f, -0.03232242f, 0.04581368f, 
    -0.09801465f, -0.02879044f, -0.05296179f, -0.00879299f, -0.07373521f, 0.05794217f, 0.06419187f, -0.06936826f, 
    -0.05389640f, 0.00038671f, 0.01046054f, 0.02440335f, -0.06529445f, -0.00006893f, -0.00719813f, -0.07511400f, 
    0.46595329f, -0.23238730f, 0.07096867f, 0.13723306f, -0.22143571f, 0.04700609f, -0.02553360f, -0.04688010f, 
    0.04592782f, 0.05041279f, 0.11813015f, 0.10899772f, 0.45982978f, 0.19316621f, 0.07633786f, 0.14605281f, 
    -0.01655708f, -0.01512568f, 0.45129099f, -0.40096888f, -0.07515987f, 0.14274214f, -0.13192904f, -0.16923550f, 
    0.13618919f, -0.42220047f, -0.06100607f, -0.10085452f, 0.02378559f, -0.05349265f, 0.04988072f, 0.05068681f, 
    0.14702438f, 0.39369756f, 0.20462489f, -0.05559787f, -0.04990077f, -0.38069227f, 0.15153030f, 0.04608872f, 
    -0.08131804f, 0.24792601f, 0.11565790f, 0.18983972f, -0.07946629f, -0.02541891f, 0.04729283f, 0.30964375f, 
    0.05462402f, 0.06839897f, 0.07659174f, 0.02958645f, -0.30007020f, -0.11885557f, -0.07771860f, 0.67426443f, 
    -0.01663238f, 0.24405254f, -0.03942756f, -0.18050776f, -0.03666563f, 0.10821514f, 0.59649873f, 0.22465257f, 
    0.05591309f, -0.03024836f, 0.00059136f, 0.04766797f, -0.06245704f, 0.22694884f, -0.19590619f, -0.02429569f, 
    0.38963011f, -0.08404918f, 0.05177887f, -0.08170804f, 0.33151403f, 0.12509839f, 0.04519214f, 0.22906806f, 
    0.15066980f, -0.34000412f, 0.28767931f, 0.02389697f, -0.18002465f, -0.00473982f, 0.37258029f, 0.07706419f, 
    0.28134674f, 0.03375690f, 0.57822174f, 0.09318503f, -0.08975267f, -0.18339191f, 0.20022701f, -0.42943770f, 
    -0.05459641f, 0.03434851f, -0.02707924f, -0.23903659f, -0.33204186f, -0.03170957f, 0.08844709f, 0.00025865f, 
    -0.05036769f, -0.61186844f, 0.12581560f, -0.02611645f, -0.02000613f, -0.35083887f, 0.04881808f, -0.48103434f, 
    0.15368435f, -0.01739335f, 0.05291180f, 0.06856211f, -0.16643429f, -0.44289008f, 0.19490021f, 0.02073116f, 
    -0.04723704f, -0.38444567f, -0.13341106f, 0.53343832f, 0.58980870f, -0.17720306f, -0.08183101f, -0.14653678f, 
    -0.05725650f, -0.04303564f, -0.04205482f, -0.05602321f, -0.09025908f, 0.06821040f, 0.02591614f, -0.09283447f, 
    0.01017304f, 0.08334411f, -0.06600922f, -0.08144688f, -0.00034164f, 0.07938661f, 0.04529553f, 0.04173222f, 
    0.03524229f, 0.05719626f, 0.01804129f, -0.07714830f, -0.01933146f, -0.06871624f, -0.03428828f, -0.00965880f, 
    0.01415944f, -0.04850303f, -0.07392391f, 0.03503671f, 0.00681789f, -0.03425236f, 0.08788243f, -0.07680359f, 
    -0.06963486f, 0.06754853f, 0.00036285f, 0.05160559f, -0.03728378f, -0.01336073f, 0.04349911f, 0.05956770f, 
    -0.03670093f, 0.02153200f, -0.05594040f, -0.06836250f, -0.02802646f, -0.00647872f, 0.06487373f, 0.02601385f, 
    0.08585549f, -0.03270278f, -0.08643916f, 0.05702712f, -0.01464914f, 0.04161385f, -0.08797728f, -0.04028498f, 
    0.03067816f, -0.05612115f, -0.02562528f, -0.02630868f, -0.05967052f, -0.10052367f, 0.02445964f, -0.08344902f, 
    -0.08489352f, 0.03905165f, 0.07522290f, 0.06898410f, -0.07278942f, -0.04378259f, 0.08171604f, -0.00218584f, 
    0.00553921f, -0.01229038f, 0.07993916f, -0.01259742f, -0.03837615f, -0.09385195f, 0.07422104f, 0.00243021f, 
    -0.01904809f, 0.00330593f, 0.05302461f, -0.03927091f, -0.01105530f, -0.00553968f, 0.06516631f, -0.01080025f, 
    0.01178537f, -0.00449844f, -0.06381543f, -0.06164985f, 0.01494269f, 0.00873450f, -0.03281718f, 0.06619060f, 
    -0.03980689f, -0.02334785f, 0.03759862f, -0.07333766f, 0.05905100f, 0.02522864f, 0.05117727f, 0.00395206f, 
    0.00705198f, 0.02586807f, 0.02721939f, -0.02957342f, 0.03366246f, 0.05166331f, -0.08159140f, 0.05010303f, 
    0.04534084f, -0.02739629f, -0.03108553f, -0.08164085f, -0.05116844f, -0.04238763f, 0.01755216f, 0.04609623f, 
    -0.02099599f, 0.06105975f, -0.07391714f, 0.00352757f, -0.00754546f, -0.05280129f, 0.07100049f, -0.06393554f, 
    0.14179239f, 0.11636249f, -0.00729902f, 0.04619030f, 0.08911561f, 0.24714789f, -0.14017798f, 0.03845447f, 
    0.12666987f, -0.05898265f, 0.12964281f, 0.04966394f, 0.60326016f, 0.17907113f, -0.09030939f, 0.14741084f, 
    0.06162105f, 0.06834521f, 0.04529994f, -0.28748822f, 0.03580339f, 0.11350583f, -0.09179688f, 0.00088826f, 
    -0.16973339f, -0.13389370f, 0.22357948f, 0.17877707f, 0.26559404f, 0.03666483f, 0.05122101f, 0.01292618f, 
    0.12220533f, 0.46819076f, -0.02256227f, 0.23874860f, 0.05507616f, 0.02698326f, -0.06113045f, 0.16241324f, 
    -0.07461408f, -0.07879534f, -0.12910530f, 0.14272468f, -0.43784642f, -0.23853882f, -0.28651011f, 0.27748546f, 
    0.18069100f, 0.09370550f, -0.03161731f, 0.14263979f, -0.11028020f, 0.45909491f, -0.17174199f, -0.16402450f, 
    0.09850138f, 0.15461965f, 0.24937646f, 0.16303723f, 0.12187199f, -0.02573413f, 0.52702332f, -0.01321981f, 
    -0.49793488f, -0.05291284f, -0.01933107f, 0.05550238f, 0.04311594f, 0.26598781f, -0.49310634f, 0.04982736f, 
    -0.21337821f, -0.08690725f, -0.03296728f, 0.10595218f, 0.36734787f, 0.05986959f, 0.06546867f, 0.09418917f, 
    -0.40379843f, -0.14073405f, 0.02527496f, 0.06485242f, 0.09660330f, -0.01473386f, -0.24334599f, -0.04907784f, 
    0.10371899f, -0.01724929f, 0.18119320f, -0.15440059f, 0.14277865f, 0.03308368f, 0.03798485f, 0.01972671f, 
    0.12386118f, 0.03005954f, 0.21293779f, -0.16329351f, -0.11068306f, 0.01626837f, 0.14952564f, 0.12028539f, 
    -0.06874484f, -0.21013410f, 0.10179347f, 0.00455528f, 0.13140291f, 0.37409273f, 0.08319221f, -0.01939722f, 
    0.35682797f, -0.04778445f, -0.06663749f, -0.00410459f, 0.04120154f, -0.07184680f, 0.08801001f, 0.07634646f, 
    -0.02123208f, -0.40111703f, -0.42225841f, 0.06771786f, -0.06178369f, 0.06260869f, 0.07943703f, 0.11648393f, 
    0.05080490f, -0.03509071f, 0.06284515f, -0.01366247f, -0.16471614f, -0.20462818f, 0.10862524f, 0.00196087f, 
    -0.00876012f, -0.07259762f, -0.13011090f, -0.30058926f, -0.00137725f, 0.19842130f, 0.14258467f, -0.18105240f, 
    -0.12022177f, -0.01849624f, 0.05668422f, 0.18655191f, 0.04872479f, -0.04066911f, 0.02329769f, 0.16029021f, 
    0.10695640f, -0.02488889f, -0.08054654f, -0.35869139f, -0.12681939f, 0.13827667f, -0.00102569f, 0.02193969f, 
    -0.01153172f, -0.17881757f, -0.00317924f, -0.14211948f, 0.01467059f, 0.08578420f, 0.09610060f, 0.09428122f, 
    -0.06285372f, -0.08348049f, 0.08971877f, -0.22538123f, 0.00736773f, 0.08071697f, 0.05373061f, -0.45381618f, 
    0.00843943f, 0.06470278f, -0.05769990f, 0.07381193f, 0.07430692f, -0.09980303f, 0.18663493f, 0.26734310f, 
    0.08576761f, 0.04360059f, 0.14909431f, -0.09172779f, -0.03387417f, -0.06814946f, -0.17000610f, -0.06305209f, 
    0.28652397f, -0.13865764f, -0.08325953f, -0.15025491f, 0.11114510f, -0.23157036f, -0.03690347f, 0.04452100f, 
    0.21863508f, 0.05716942f, 0.08704194f, 0.04575033f, -0.45994279f, 0.07413967f, 0.14818612f, 0.18799990f, 
    -0.02466822f, 0.19518790f, 0.05856637f, 0.09122926f, 0.01602500f, 0.05202130f, 0.08572330f, -0.08636619f, 
    -0.03084791f, 0.00303069f, -0.08092042f, 0.15819830f, -0.28496030f, 0.17582521f, 0.03895769f, -0.14991651f, 
    0.00822347f, 0.08094026f, -0.01724633f, 0.39542231f, 0.04185535f, 0.05635390f, 0.09461983f, -0.00238730f, 
    0.06006205f, -0.00979149f, 0.28710780f, 0.03708723f, 0.05129913f, -0.56921130f, -0.29664645f, 0.29700747f, 
    -0.01496569f, -0.03841124f, 0.02870461f, 0.06072404f, 0.11023436f, -0.12971428f, -0.20726213f, 0.00708284f, 
    0.19024289f, 0.11018771f, -0.01911408f, -0.04988360f, 0.01944218f, -0.04774465f, 0.09506790f, 0.07180139f, 
    0.11058763f, 0.15593506f, -0.17817038f, 0.10791565f, 0.05723632f, 0.09888101f, -0.29830116f, -0.10477368f, 
    0.28761297f, 0.06543753f, 0.14364757f, 0.43781918f, -0.08827479f, 0.36003354f, 0.34996390f, 0.26116198f, 
    0.09864709f, 0.08032016f, -0.40944219f, -0.12991497f, 0.03018796f, -0.06778453f, -0.35106954f, -0.05850144f, 
    0.16905396f, -0.21714143f, 0.24162838f, 0.58265543f, 0.13936640f, 0.04526737f, 0.00398010f, -0.46082863f, 
    -0.04875781f, 0.22728111f, 0.09955973f, -0.31293443f, 0.16320762f, 0.05259770f, 0.21307482f, 0.15941480f, 
    0.05946996f, 0.31298444f, 0.02759194f, 0.34907752f, 0.01807941f, -0.07188162f, -0.83064771f, 0.23622930f, 
    -0.31601295f, 0.08312156f, -0.00746290f, -0.11169959f, 0.00537131f, 0.41722235f, -0.02405152f, 0.01549534f, 
    0.15858713f, -0.28680670f, 0.17810142f, -0.30649880f, -0.14654352f, 0.12526602f, -0.42646453f, 0.44520652f, 
    -0.44508857f, -0.05109961f, 0.00587102f, 0.12618788f, -0.05604669f, 0.32446581f, -0.40600070f, -0.15560809f, 
    -0.28045744f, -0.03634460f, 0.08070169f, 0.33560774f, -0.44657490f, 0.01185819f, -0.10611768f, 0.07663453f, 
    -0.02901497f, -0.16689290f, -0.11977550f, 0.23875241f, 0.15140866f, 0.02702591f, -0.63678020f, 0.02113623f, 
    0.07924062f, -0.05652804f, -0.00554115f, -0.34729925f, 0.27811557f, -0.32167497f, -0.17094371f, 0.12374242f, 
    0.22271247f, -0.03397549f, 0.32139683f, -0.09426679f, 0.00043998f, -0.31664941f, -0.00154254f, 0.34022671f, 
    -0.11655765f, -0.18368317f, -0.11080491f, 0.22971904f, 0.06752834f, -0.54682004f, 0.03250256f, -0.04022895f, 
    0.02431285f, -0.04527647f, 0.00862257f, 0.00321851f, -0.12602371f, -0.16973738f, 0.23712073f, -0.07433586f, 
    0.05878755f, -0.39617571f, 0.04823385f, -0.09168056f, -0.41232878f, -0.71655917f, 0.00410033f, 0.14360674f, 
    0.15843152f, 0.11820769f, -0.03650990f, -0.10245913f, 0.23520364f, 0.15294996f, -0.04270805f, 0.13225825f, 
    0.30797824f, -0.00835938f, 0.04472950f, -0.02406547f, 0.18530579f, 0.00802757f, 0.04967932f, 0.25080839f, 
    -0.01897899f, 0.02162543f, -0.18791425f, -0.07464124f, -0.02878792f, 0.09207011f, 0.04096030f, 0.21480522f, 
    -0.15099695f, -0.07646754f, 0.08769161f, 0.02256181f, 0.09844863f, 0.14423089f, -0.03477938f, -0.04628441f, 
    0.26787978f, -0.49423736f, -0.03364235f, -0.08100340f, 0.29880315f, -0.15475252f, 0.17282060f, 0.20181297f, 
    0.03432288f, 0.18553934f, -0.31360668f, 0.15898189f, -0.23866199f, -0.23136027f, -0.21829841f, -0.28033730f, 
    0.04696364f, 0.00069729f, 0.03099833f, -0.03499050f, -0.09600193f, 0.04269410f, 0.05400576f, -0.25327158f, 
    -0.03841608f, 0.05862497f, 0.06358873f, 0.11737227f, -0.08432385f, -0.18646756f, 0.19730730f, 0.08409232f, 
    -0.32114485f, -0.18374707f, -0.00383985f, 0.12495567f, 0.00730683f, -0.17783941f, -0.03048953f, 0.06450190f, 
    -0.19244544f, -0.08730097f, 0.05300297f, 0.11458054f, 0.18118510f, 0.05740422f, 0.14027993f, 0.17330787f, 
    -0.19003946f, 0.13072994f, 0.11544321f, 0.16089292f, -0.20643681f, -0.03575249f, -0.18014230f, 0.06906854f, 
    0.31439734f, 0.01754401f, 0.09934918f, 0.15489185f, -0.15387893f, -0.07883512f, -0.16392469f, -0.23617005f, 
    0.14232169f, -0.05630612f, -0.00387773f, 0.01966537f, -0.14076120f, -0.00492985f, 0.03599304f, 0.37483224f, 
    0.20445913f, -0.14604193f, 0.09640793f, 0.07944530f, 0.06430927f, 0.67566437f, 0.15527748f, 0.29155537f, 
    0.17308696f, -0.01773096f, -0.08830948f, 0.04931000f, 0.15113099f, -0.35058296f, 0.13889854f, 0.13553172f, 
    0.09346338f, -0.20869283f, -0.07316078f, 0.12141320f, 0.09123249f, -0.05818149f, 0.07869066f, 0.05308984f, 
    0.05647075f, 0.04320832f, 0.02600403f, 0.24913535f, -0.06847364f, -0.26952395f, 0.03352059f, 0.04942651f, 
    0.02120996f, -0.05564385f, 0.01094129f, 0.08485597f, -0.39518833f, 0.10467417f, 0.59754670f, -0.20569655f, 
    -0.15309313f, 0.07947426f, -0.25394398f, 0.31574979f, -0.05186449f, 0.13723817f, 0.02954943f, 0.00572657f, 
    0.18228665f, 0.06148928f, -0.06699006f, 0.13716070f, 0.06605393f, 0.04339417f, -0.06398913f, 0.13865194f, 
    -0.00335129f, -0.10721037f, -0.12552078f, 0.09139320f, 0.21359742f, 0.08667608f, 0.23290814f, 0.32210350f, 
    0.03922265f, 0.11585537f, 0.10073909f, -0.21716429f, 0.28846261f, -0.03275938f, 0.30861133f, -0.16097289f, 
    -0.08130524f, -0.01710994f, -0.01270412f, -0.04604945f, 0.13196325f, -0.35735330f, 0.23165125f, -0.25425309f, 
    -0.22094558f, -0.02291513f, -0.01039367f, 0.06833945f, 0.09498835f, 0.08621790f, -0.37541297f, 0.14579360f, 
    -0.09112300f, 0.16864808f, 0.04011083f, -0.04622754f, -0.01992940f, -0.07302497f, 0.03471816f, -0.01577886f, 
    -0.11779954f, 0.02760593f, 0.04937312f, -0.08221373f, -0.24776085f, 0.23302054f, 0.30843416f, -0.17672330f, 
    0.02807123f, 0.17989397f, 0.08304422f, -0.11791946f, -0.08172862f, 0.03216965f, 0.17449193f, 0.01316064f, 
    -0.08075124f, -0.06458125f, -0.10718219f, 0.10855558f, -0.05902951f, -0.14576346f, -0.30407408f, 0.14846657f, 
    -0.00998218f, 0.06058114f, -0.17057639f, 0.17071798f, 0.10594301f, 0.02723328f, -0.00223060f, 0.08022418f, 
    0.00191070f, 0.06143067f, -0.12172814f, 0.24022946f, -0.10372292f, -0.36308661f, -0.12354615f, 0.04389132f, 
    -0.43218401f, 0.03242736f, -0.01758228f, 0.02114475f, -0.14770438f, 0.10170359f, -0.13790114f, -0.06825024f, 
    0.15011360f, 0.07513469f, 0.14236327f, -0.43149450f, -0.37623700f, 0.09230168f, -0.04280619f, 0.10518463f, 
    0.01742125f, -0.03086874f, 0.12015665f, 0.20884375f, 0.01686587f, -0.11114765f, -0.26727596f, 0.35814330f, 
    0.20528319f, -0.05139400f, 0.03941967f, -0.12844642f, -0.33419016f, 0.21374063f, 0.41207501f, -0.01845765f, 
    -0.05611144f, -0.00481538f, -0.27129433f, 0.19709615f, 0.07522815f, -0.03611283f, -0.28455395f, 0.28664005f, 
    0.18422228f, -0.03991219f, 0.23048255f, 0.04588579f, -0.05473471f, 0.11843645f, -0.03840942f, -0.04773171f, 
    -0.09022742f, -0.58485854f, 0.24557273f, -0.16636315f, 0.27184135f, 0.11888637f, 0.24673530f, 0.23143010f, 
    -0.10712741f, 0.01231067f, -0.26901308f, -0.12446535f, 0.52118421f, 0.06384560f, -0.07084064f, -0.42815691f, 
    0.00756462f, 0.02139427f, 0.06215355f, 0.10092171f, -0.10987110f, -0.00652825f, 0.56653947f, -0.03485930f, 
    0.03098782f, -0.18591538f, -0.05859184f, -0.06069464f, 0.05643121f, 0.05074751f, -0.25350982f, -0.03989365f, 
    -0.30575833f, -0.08278867f, 0.00256723f, 0.28440815f, 0.15173094f, -0.12378591f, -0.33127454f, -0.11446272f, 
    -0.17704903f, 0.01896306f, 0.05906294f, -0.02418319f, -0.28600162f, 0.06992623f, 0.20314473f, -0.03709554f, 
    -0.13327964f, 0.17134884f, 0.01779693f, 0.00931902f, -0.01466171f, 0.03242505f, -0.12168969f, 0.02228217f, 
    0.16463514f, 0.03548389f, -0.15094338f, 0.07303652f, -0.29595640f, -0.24375397f, -0.34023163f, -0.00358235f, 
    0.08035677f, 0.08813569f, 0.22882840f, 0.08718762f, 0.15469398f, 0.02509285f, -0.34385687f, 0.11844718f, 
    0.07373572f, 0.22167762f, -0.20247889f, 0.22112384f, 0.03191761f, 0.43166229f, -0.19221424f, 0.17905462f, 
    -0.08609357f, -0.06739540f, -0.07048754f, 0.04907671f, -0.04871534f, 0.20661020f, 0.09288361f, 0.16270456f, 
    0.25572377f, 0.03591881f, -0.15752567f, -0.01926021f, -0.26066253f, -0.13098264f, 0.09737130f, 0.13572310f, 
    -0.08699515f, 0.03223554f, -0.05572092f, -0.03525967f, -0.06574842f, -0.03110575f, 0.02060315f, -0.10761415f, 
    -0.04716623f, 0.00769570f, -0.05393599f, 0.03407112f, 0.03051906f, 0.03030762f, -0.08016503f, -0.06927703f, 
    0.03657960f, 0.05124122f, 0.01114045f, -0.00091023f, 0.07012065f, -0.05140977f, -0.00258120f, -0.07290723f, 
    -0.03629382f, -0.07412057f, -0.00418862f, -0.06864434f, -0.10788693f, -0.00632340f, -0.02031548f, -0.11699440f, 
    -0.03786031f, 0.05539197f, 0.08806448f, 0.01482816f, -0.05450720f, -0.00594232f, 0.07769912f, 0.06181100f, 
    0.02326847f, -0.06745761f, -0.07263142f, 0.01364805f, -0.01364240f, -0.09426512f, -0.06559203f, -0.02489994f, 
    -0.10432354f, 0.00324213f, 0.06297464f, -0.07343141f, -0.03058939f, 0.02109959f, -0.08281847f, -0.00289098f, 
    -0.00153959f, 0.00170603f, -0.09083065f, 0.02381118f, -0.02173422f, -0.06674211f, 0.07091942f, 0.05050881f, 
    -0.05006792f, -0.09773329f, 0.02953434f, -0.09164900f, -0.01276266f, -0.05112213f, -0.06768393f, -0.06746826f, 
    -0.03601695f, -0.04783274f, -0.01180737f, 0.04074384f, 0.04863250f, 0.00686179f, -0.07344929f, -0.01965074f, 
    0.01381590f, -0.04054200f, 0.05292727f, -0.05739833f, -0.04374826f, -0.08729399f, -0.03471705f, 0.06687630f, 
    0.05821835f, 0.00529190f, -0.05158373f, -0.02105718f, -0.00495044f, -0.03704431f, -0.00134498f, -0.03980635f, 
    -0.09636079f, -0.01146649f, 0.03177913f, 0.01304906f, -0.01393839f, 0.02210067f, -0.00382480f, -0.09066311f, 
    -0.01910551f, -0.07317466f, -0.07190496f, 0.05357202f, -0.03703991f, -0.03954440f, -0.06239896f, -0.09609582f, 
    0.06137696f, -0.03399348f, 0.03623657f, -0.04377961f, 0.05215934f, 0.00498640f, -0.10844117f, -0.11306822f, 
    -0.05403333f, 0.01133559f, -0.05218675f, -0.06515808f, 0.05436977f, 0.03335033f, 0.05057804f, -0.10083544f, 
    -0.31311443f, 0.08739676f, -0.09958012f, -0.03255096f, -0.09902046f, 0.27939081f, 0.13258946f, 0.13128069f, 
    0.07692300f, 0.01302273f, -0.07258178f, 0.01536227f, -0.37138245f, 0.16497707f, -0.01169487f, 0.14751244f, 
    0.08024430f, -0.07219506f, 0.20472616f, 0.01714196f, 0.02920214f, 0.06228311f, 0.00573683f, 0.24850568f, 
    0.01518532f, -0.26875219f, 0.13113104f, -0.07703099f, 0.13264123f, -0.02621158f, -0.01567094f, 0.01345728f, 
    -0.43452173f, -0.75056171f, 0.36279011f, -0.16417144f, 0.20820892f, 0.20161833f, -0.00960607f, -0.09349219f, 
    -0.03945965f, -0.02516871f, 0.41821221f, -0.21626437f, 0.03157557f, 0.26242730f, -0.09657212f, 0.00608004f, 
    -0.12979297f, 0.04926098f, 0.03994999f, 0.18051280f, -0.10820764f, 0.12780063f, 0.06982502f, 0.14458595f, 
    0.25703606f, 0.15247303f, 0.17794359f, -0.44635779f, 0.18017936f, 0.12963109f, -0.12373755f, 0.13226652f, 
    -0.77696306f, -0.32189107f, 0.03381962f, -0.04961549f, -0.01288229f, -0.00194782f, -0.60638863f, 0.22746912f, 
    0.01173384f, -0.07494229f, 0.03885219f, 0.07205927f, -0.08486285f, -0.02792735f, 0.10360286f, 0.08886293f, 
    -0.54441798f, 0.16856109f, 0.08375645f, 0.36712098f, 0.08835997f, 0.04377188f, -0.03453602f, -0.03112766f, 
    -0.19073100f, 0.00493535f, -0.32623968f, -0.02985052f, 0.06378073f, 0.23568058f, 0.25094000f, 0.06980876f, 
    -0.02784077f, 0.00268562f, 0.11820111f, 0.07764637f, -0.15822516f, -0.13808739f, 0.25463435f, 0.01677586f, 
    0.06491964f, -0.13465314f, 0.21753740f, 0.07343777f, 0.15909767f, -0.26673159f, 0.16145653f, 0.11311872f, 
    0.19432299f, -0.05646986f, -0.00593875f, -0.00402805f, -0.24983433f, -0.14721987f, -0.00809330f, 0.05971849f, 
    0.14537038f, -0.24189158f, -0.42208508f, 0.02292272f, 0.07461575f, -0.33305421f, 0.06206089f, 0.00557180f, 
    0.11369633f, -0.06813872f, 0.14617769f, 0.00025953f, -0.07453205f, -0.03580704f, -0.33463719f, 0.17447823f, 
    0.12839416f, -0.03388039f, -0.05226297f, 0.01401904f, -0.27366027f, 0.12855433f, 0.26659572f, -0.06130683f, 
    0.00338207f, 0.03157200f, 0.26006156f, -0.05312093f, -0.04417595f, 0.07983209f, -0.29929891f, 0.08247134f, 
    0.13936490f, -0.14870365f, 0.10916226f, 0.10225836f, -0.07555234f, 0.08386696f, 0.06833830f, 0.14985868f, 
    0.04698840f, -0.16510905f, 0.35290891f, -0.15388158f, 0.03639753f, 0.01263291f, 0.15290244f, -0.06333489f, 
    -0.07533493f, 0.03908142f, -0.05463273f, -0.12843347f, 0.44008651f, 0.41493121f, 0.10391670f, -0.11258934f, 
    0.26221126f, 0.04163422f, 0.02668481f, 0.30123380f, -0.46232775f, -0.03386751f, 0.31401232f, 0.36843741f, 
    0.02526478f, -0.00475258f, -0.12133995f, -0.05679874f, 0.05392816f, 0.04548114f, -0.40350282f, 0.22250572f, 
    0.09555547f, -0.13519703f, 0.01696858f, 0.17813373f, 0.12037154f, 0.05083869f, 0.07870865f, -0.00742156f, 
    0.35892016f, -0.01801552f, -0.06667604f, 0.06551792f, -0.32681823f, -0.02586442f, 0.00868331f, 0.18682915f, 
    0.16663247f, 0.16318347f, 0.04068369f, 0.04732463f, 0.01962988f, -0.01074050f, -0.03763270f, 0.00169553f, 
    0.22719891f, 0.08525328f, 0.16529764f, -0.22118254f, 0.04434631f, -0.16159780f, -0.02894935f, -0.00351650f, 
    0.06199252f, -0.00889751f, 0.02054411f, -0.20157252f, -0.01371835f, -0.15529260f, -0.17889223f, -0.13135450f, 
    0.02633440f, 0.03824795f, -0.31527853f, 0.02377504f, 0.10988181f, -0.42203280f, -0.20023672f, -0.25700915f, 
    0.05197820f, -0.06638025f, 0.07506312f, 0.00483082f, -0.14714435f, 0.02686233f, 0.19449951f, 0.21694516f, 
    -0.00094042f, 0.11486808f, 0.00625792f, 0.21767972f, 0.10445405f, 0.00950438f, 0.00944170f, -0.00007935f, 
    -0.36702165f, 0.18315372f, -0.26634389f, -0.11871015f, 0.25367692f, 0.56412941f, 0.26358318f, -0.19205341f, 
    -0.02534403f, -0.07816418f, 0.08453228f, 0.21278289f, 0.77634752f, -0.28564480f, -0.22927612f, 0.45845941f, 
    0.24684228f, 0.03790163f, 0.19019291f, -0.39305893f, 0.08615821f, 0.08744676f, 0.06079716f, 0.20654966f, 
    -0.03951811f, -0.25492486f, 0.03228847f, 0.18347949f, 0.10665041f, -0.03592135f, -0.08470174f, -0.11051341f, 
    -0.38536513f, 0.49829265f, -0.17912060f, 0.60696608f, 0.08361247f, -0.19397095f, -0.04993691f, -0.01283473f, 
    0.01214074f, 0.07182077f, -0.13680245f, -0.11596862f, -0.47878462f, -0.47357979f, -0.21408366f, 0.52462345f, 
    0.10467845f, -0.01297238f, -0.01458695f, -0.07750048f, -0.30358660f, 0.30678552f, -0.22126739f, -0.36198363f, 
    0.20309433f, 0.27750379f, 0.16923545f, 0.11863647f, 0.05876273f, 0.04621923f, 1.00056374f, 0.10878354f, 
    -0.64530993f, -0.16131198f, -0.06324691f, -0.10734386f, -0.03018103f, 0.15674508f, -0.23552224f, 0.18730785f, 
    -0.29507202f, -0.04305090f, -0.05843861f, 0.23210917f, 1.09132004f, -0.03251846f, 0.01263720f, 0.10315849f, 
    -0.32840291f, 0.10222739f, 0.02117674f, 0.25808275f, 0.19363086f, 0.05839569f, -0.07375336f, -0.02183617f, 
    -0.06845526f, 0.07772606f, -0.03155503f, -0.09132273f, 0.12022392f, 0.21292609f, 0.22382255f, -0.04859110f, 
    -0.04177143f, -0.00590322f, 0.09546684f, 0.10190152f, -0.31720766f, -0.00162249f, 0.29814872f, 0.23855659f, 
    -0.00324820f, -0.30441567f, 0.16996574f, 0.03634716f, 0.10148916f, 0.22659138f, 0.49441794f, 0.22201361f, 
    0.34342670f, 0.00461064f, -0.00317962f, 0.05636124f, -0.23644176f, -0.21460463f, -0.04469767f, 0.07566751f, 
    -0.19027026f, -0.56379539f, 0.08074740f, -0.06745122f, -0.07352969f, 0.01337414f, 0.21630293f, 0.09404323f, 
    -0.32754955f, 0.12857184f, 0.04830145f, -0.05138244f, 0.18649070f, 0.12901072f, 0.26618326f, 0.03261156f, 
    -0.04804757f, -0.09501008f, -0.06555847f, -0.18366759f, 0.03219225f, -0.01977598f, -0.24565524f, -0.06860881f, 
    -0.07074665f, 0.05134721f, -0.03036599f, 0.03205600f, -0.06376402f, 0.04126931f, 0.04621003f, 0.20763381f, 
    0.11517920f, -0.12767237f, -0.04789787f, -0.09068716f, -0.14727676f, 0.09896560f, 0.01550537f, 0.09879699f, 
    -0.26247555f, -0.46893111f, 0.26132670f, -0.05398278f, 0.05355059f, 0.12963973f, 0.00137443f, -0.05439848f, 
    0.03038247f, -0.20496443f, 0.05532571f, -0.52068847f, 0.33341962f, 0.12024573f, 0.12267384f, -0.11019067f, 
    0.10423755f, -0.01289461f, 0.07212438f, 0.22589384f, -0.08303949f, 0.00891061f, 0.28621712f, -0.07072783f, 
    0.19071972f, 0.09167408f, -0.16824757f, -0.20990066f, 0.04241384f, -0.06751878f, 0.23379402f, -0.13860899f, 
    0.17156982f, -0.26148579f, -0.01297181f, -0.03332646f, 0.15052342f, -0.26517412f, -0.00389492f, 0.05796418f, 
    0.02014007f, 0.03604363f, -0.03943088f, 0.12404328f, 0.18217136f, 0.01836932f, -0.03018624f, 0.27307805f, 
    0.05483667f, 0.21282129f, 0.04468378f, 0.20035899f, 0.00521505f, -0.09020524f, 0.35457203f, 0.04808560f, 
    0.11156101f, -0.00563276f, -0.16343571f, 0.03125980f, -0.17660105f, 0.27259892f, 0.18080612f, -0.06850879f, 
    0.01457120f, -0.05697659f, -0.05208074f, 0.33773431f, 0.08991648f, 0.00337059f, -0.07525227f, 0.14816928f, 
    0.10013166f, 0.08942354f, 0.12358201f, 0.12102652f, 0.08652441f, 0.03545386f, 0.21622632f, 0.04427636f, 
    0.14515106f, 0.04020786f, 0.08368168f, 0.00635811f, 0.11636215f, -0.22828846f, -0.23550618f, 0.11736299f, 
    0.13071239f, 0.10570005f, 0.12227213f, -0.22923951f, 0.11984975f, -0.12300246f, 0.17881738f, -0.08276216f, 
    0.13527292f, 0.14666753f, 0.05795368f, 0.05222125f, 0.19631574f, -0.24160606f, -0.23420337f, 0.01349293f, 
    -0.06112094f, -0.01181607f, 0.18185514f, 0.14829205f, -0.69251078f, -0.03437727f, 0.41072169f, -0.25750589f, 
    0.28146353f, -0.00170782f, -0.16115125f, 0.28319061f, 0.05691404f, 0.01489672f, -0.14340271f, 0.04855378f, 
    0.08948532f, 0.15093629f, 0.03564576f, 0.34597608f, 0.02463966f, 0.04457177f, 0.08150592f, 0.09250681f, 
    -0.17329040f, 0.07197057f, 0.03238475f, -0.01134201f, 0.01038985f, 0.06455172f, 0.33553463f, 0.06714334f, 
    -0.03415929f, 0.01452768f, -0.18407239f, -0.17837712f, 0.54363996f, 0.33029088f, 0.33342433f, 0.07655276f, 
    0.09869725f, -0.04847267f, -0.04069284f, -0.06295995f, -0.12901610f, -0.12351070f, 0.27054718f, 0.08743869f, 
    0.02801131f, -0.22734942f, -0.14503130f, 0.05325087f, -0.17004982f, 0.07953446f, -0.63648808f, 0.14940484f, 
    -0.10006996f, 0.12530099f, -0.00114377f, 0.12796888f, 0.00968616f, 0.07979788f, -0.08371538f, 0.10415991f, 
    0.04203770f, -0.03046824f, 0.04165886f, 0.01745495f, -0.47095740f, -0.10807563f, 0.07398166f, 0.02587354f, 
    0.07117272f, -0.17937961f, -0.18225423f, -0.13856559f, 0.16392872f, -0.04235063f, -0.33766904f, 0.03926790f, 
    0.24165843f, 0.08609345f, 0.01425533f, -0.02617467f, 0.23635545f, -0.05442848f, -0.10328548f, 0.15352699f, 
    -0.00454183f, -0.04677283f, -0.12424841f, 0.00207191f, 0.18694729f, -0.01334111f, -0.19713332f, 0.10350201f, 
    0.01187880f, 0.23241140f, -0.81999135f, 0.21626922f, -0.03720125f, -0.18881817f, -0.15121219f, -0.25319612f, 
    0.00742098f, 0.02714866f, -0.01854725f, 0.01289726f, -0.35788652f, 0.43283808f, 0.09139349f, 0.03404203f, 
    0.02678997f, -0.06555834f, 0.15071270f, -0.20336775f, -0.53503257f, 0.10776364f, 0.09431308f, -0.07787023f, 
    0.37635440f, 0.07574157f, 0.08092376f, 0.23359030f, 0.01031670f, -0.08421642f, -0.23068799f, -0.05272827f, 
    0.02083482f, 0.04353375f, 0.18744555f, 0.28254321f, -0.00052588f, 0.10047544f, 0.13729188f, -0.00614022f, 
    0.34388444f, -0.01011306f, 0.08289649f, -0.06514608f, -0.07244124f, 0.15599449f, -0.04466682f, -0.12252240f, 
    0.02848887f, 0.06620774f, 0.12502146f, 0.43421510f, -0.00378116f, 0.03276221f, 0.00617472f, 0.05198718f, 
    0.03159957f, 0.20030887f, -0.00245967f, 0.40234280f, -0.09170854f, -0.09574243f, 0.07959922f, 0.08381511f, 
    0.08115814f, 0.03197661f, 0.14529169f, 0.20257989f, -0.25458747f, -0.01538433f, 0.13304776f, 0.10444186f, 
    0.11869472f, 0.02763525f, 0.06379139f, 0.17141847f, 0.08395985f, 0.35263637f, -0.32564905f, 0.10422783f, 
    -0.09570112f, 0.06431503f, 0.02117394f, 0.12848136f, -0.03342270f, 0.17092708f, -0.16987866f, 0.11368346f, 
    -0.17041610f, 0.19641955f, -0.01366660f, 0.14932492f, -0.05575069f, 0.39046168f, -0.38103035f, 0.08213288f, 
    -0.03873690f, -0.02525885f, -0.08548530f, -0.02115646f, 0.05076398f, 0.02333787f, -0.01322799f, 0.09888578f, 
    -0.35796404f, -0.24535483f, 0.09423026f, -0.07029176f, 0.06349063f, -0.05790353f, -0.17378551f, 0.03887607f, 
    0.19784628f, -0.00314323f, 0.31856322f, -0.10544979f, 0.28256550f, -0.06392603f, 0.05354280f, 0.16451471f, 
    0.08491039f, -0.06651723f, -0.06725474f, -0.24603643f, 0.04921453f, -0.09722619f, 0.03833657f, 0.09916408f, 
    -0.04654296f, -0.05742956f, -0.11139315f, 0.03982409f, -0.01108397f, -0.31950670f, 0.11132656f, -0.31384951f, 
    0.11544920f, 0.00073591f, -0.05760632f, -0.00497629f, -0.21500587f, 0.16991363f, 0.32759279f, 0.00099321f, 
    -0.05292504f, -0.14960711f, -0.46954384f, 0.09084365f, -0.16448848f, -0.02871794f, 0.08884893f, 0.02397088f, 
    -0.07950057f, -0.01546302f, -0.05639340f, -0.04467528f, -0.02574375f, -0.01939646f, 0.01221394f, 0.07090130f, 
    0.04005312f, -0.07259669f, 0.01671518f, -0.00152910f, 0.00350052f, -0.06704166f, 0.00705250f, -0.07299144f, 
    -0.02267572f, 0.02317317f, 0.01181250f, 0.07096574f, -0.06496426f, 0.07841600f, -0.07391720f, -0.07719067f, 
    0.05246792f, 0.04654342f, -0.01238224f, 0.06461518f, 0.03471845f, -0.03708251f, -0.03954940f, 0.04138847f, 
    -0.06945251f, -0.04346272f, 0.07439001f, -0.06978463f, -0.01483462f, 0.03377032f, 0.00838868f, -0.00789704f, 
    -0.01543101f, -0.09600932f, 0.00235214f, 0.07309765f, -0.01939738f, -0.01996252f, -0.00295677f, -0.02178176f, 
    -0.01563968f, -0.04404083f, -0.01582508f, -0.00521837f, 0.04355687f, -0.07968999f, -0.06831765f, 0.04234150f, 
    0.01654453f, -0.05766324f, -0.00649570f, -0.01085406f, -0.01493232f, -0.05223956f, 0.05324714f, -0.07051231f, 
    0.05014236f, 0.01659851f, 0.00675341f, 0.04173774f, 0.02210126f, -0.00704403f, 0.00408412f, -0.05577940f, 
    -0.08254331f, 0.02325200f, 0.06174663f, 0.02659216f, -0.05769262f, -0.09391413f, -0.08770632f, -0.03807396f, 
    -0.07167006f, -0.09142096f, -0.01711807f, 0.08360651f, -0.04339657f, -0.06758305f, 0.00633166f, 0.07389671f, 
    -0.07207449f, -0.03940838f, 0.06203738f, 0.00440356f, -0.03080622f, 0.04655776f, -0.01358865f, 0.01646748f, 
    -0.07797272f, 0.03297471f, 0.02175381f, 0.01206012f, -0.08102023f, -0.02875676f, 0.02177111f, 0.03479077f, 
    -0.06359221f, -0.06490059f, -0.06508137f, 0.00940952f, -0.08686761f, 0.06582244f, 0.07799049f, -0.05348203f, 
    -0.07417198f, -0.00042087f, 0.00292947f, 0.00494682f, 0.07630332f, -0.06216246f, 0.00970836f, 0.07796391f, 
    0.08620331f, -0.04224597f, -0.02730383f, 0.07630659f, 0.02647113f, 0.01096295f, -0.00171351f, 0.01317102f, 
    -0.03005096f, -0.05381877f, -0.07774853f, -0.00952664f, -0.03397327f, 0.06077127f, -0.08864630f, 0.02505449f, 
    -0.02134498f, -0.01189689f, 0.05837658f, 0.04181664f, 0.01063414f, -0.00958828f, 0.02595068f, -0.00980009f, 
    -0.07392401f, 0.03859871f, 0.07791829f, -0.01269624f, -0.06962599f, 0.01458869f, -0.05623754f, -0.09262979f, 
    0.07886442f, -0.03857025f, -0.09046668f, 0.03913900f, -0.06736391f, -0.02920721f, 0.04137108f, 0.01650007f, 
    0.06252658f, 0.05202188f, -0.03849382f, -0.00601034f, -0.02571082f, -0.01294134f, 0.02124575f, -0.06858334f, 
    -0.02009943f, 0.04756742f, 0.04316388f, 0.03740836f, 0.03142713f, -0.08452660f, 0.05683033f, 0.06367401f, 
    -0.01517169f, -0.01539299f, -0.01533102f, 0.06039721f, -0.06490608f, -0.01296289f, -0.08222432f, 0.02935827f, 
    -0.00921043f, 0.05328358f, -0.04338567f, -0.06238159f, -0.03435500f, -0.03548371f, -0.02426524f, -0.05772987f, 
    -0.08093040f, 0.04733131f, 0.02946395f, -0.04088205f, 0.00597809f, 0.00595202f, 0.05512087f, 0.06764966f, 
    -0.08921003f, 0.05345468f, 0.06011504f, 0.06431134f, -0.04458388f, -0.05977328f, -0.01303009f, -0.02399102f, 
    -0.08675613f, 0.05106845f, -0.09131528f, 0.04033308f, 0.07641116f, -0.08341548f, 0.07029937f, -0.08310290f, 
    0.07753742f, -0.02830648f, -0.07654621f, 0.01784875f, 0.06475159f, 0.04982446f, -0.05079701f, -0.00722576f, 
    -0.08786482f, 0.05803169f, 0.03466729f, -0.01271710f, -0.07613603f, 0.00543736f, 0.07744271f, -0.07088200f, 
    -0.08443774f, 0.06112086f, 0.03075342f, -0.01588981f, -0.05075489f, -0.04450863f, 0.05553606f, -0.08549352f, 
    -0.01192409f, -0.08403272f, 0.02887052f, 0.03208192f, -0.00735393f, 0.02071506f, -0.02904074f, -0.04480784f, 
    -0.04131837f, 0.04061304f, -0.05879421f, 0.01148602f, -0.07256199f, 0.07632508f, 0.06897458f, -0.01625394f, 
    -0.02421031f, -0.00580898f, 0.02699781f, -0.05789859f, 0.03325285f, -0.02334201f, -0.00194167f, -0.00714292f, 
    -0.03783160f, -0.04676575f, 0.04175983f, -0.02542357f, -0.03918859f, 0.02065343f, -0.09874396f, -0.00038337f, 
    -0.06586795f, -0.08381415f, 0.08428591f, -0.06755180f, 0.06793716f, -0.05518580f, 0.00975818f, -0.10705819f, 
    -0.08728946f, -0.02827387f, -0.09342957f, 0.04468562f, -0.10955552f, 0.03118646f, -0.08041365f, 0.01357973f, 
    -0.05169258f, 0.02789937f, -0.01120755f, 0.05614675f, -0.09270214f, -0.06201192f, 0.03378453f, -0.03245448f, 
    0.00440921f, -0.03942338f, 0.06794420f, -0.01762948f, -0.08847745f, -0.06903636f, -0.02397592f, -0.08141381f, 
    -0.00075606f, 0.03160391f, 0.03518310f, -0.02339909f, 0.00248499f, -0.04684241f, 0.03719550f, 0.02356348f, 
    -0.10602304f, 0.00404772f, 0.01735101f, -0.05815081f, 0.02223427f, 0.00337372f, 0.08806567f, -0.02154259f, 
    -0.01585784f, -0.07831681f, -0.00885905f, -0.01048839f, -0.10024770f, -0.04721260f, 0.08004207f, -0.04064968f, 
    -0.02401874f, -0.00837074f, 0.05109846f, 0.05361069f, -0.02364276f, 0.05702557f, -0.09183630f, -0.02187888f, 
    -0.05948731f, 0.04283545f, -0.04056571f, 0.02967335f, 0.02747187f, 0.01170688f, -0.02450802f, -0.03135048f, 
    0.04687527f, -0.06918059f, -0.06518229f, -0.04967720f, -0.03139324f, -0.04876317f, 0.00016295f, -0.07864301f, 
    0.00294909f, 0.03851489f, -0.09120756f, 0.05826368f, -0.08320466f, 0.03201092f, -0.06873141f, 0.01665904f, 
    -0.07113948f, 0.03569529f, -0.09097607f, 0.02556264f, -0.08692256f, -0.04459259f, -0.08282045f, -0.00049769f, 
    0.00799679f, 0.03352381f, -0.07262971f, 0.05564146f, -0.05115582f, -0.07522363f, -0.09295419f, 0.04423520f, 
    -0.04565166f, -0.05342426f, 0.06799322f, 0.07477278f, 0.02230628f, 0.01866828f, 0.03277464f, 0.01254823f, 
    -0.13407609f, 0.03623871f, -0.05630178f, -0.28713226f, -0.44401157f, -0.03168356f, -0.05981725f, 0.10252105f, 
    0.04546380f, 0.04328883f, -0.14442202f, -0.13151576f, 0.18701141f, -0.03457792f, 0.01563032f, -0.22910753f, 
    0.11441792f, -0.03877285f, -0.19551069f, 0.13472362f, -0.07564234f, -0.04311626f, 0.10289222f, 0.22596280f, 
    -0.39844576f, -0.04686128f, 0.01196722f, 0.05008385f, 0.23398922f, 0.07956441f, 0.00957613f, 0.10441960f, 
    0.12153714f, -0.14522271f, -0.05733689f, 0.10965320f, 0.06188620f, 0.09720653f, -0.14630109f, 0.24004444f, 
    -0.01967679f, 0.00997795f, 0.15440820f, -0.03030859f, 0.02188509f, 0.11484624f, 0.32177830f, -0.21882324f, 
    0.24808528f, 0.03969661f, 0.03780855f, -0.03155072f, 0.00867913f, -0.21780440f, 0.05383674f, -0.16167457f, 
    -0.35275874f, 0.01263058f, -0.06104566f, 0.18569320f, 0.18643405f, -0.08539693f, -0.00929568f, 0.33674112f, 
    -0.12007556f, -0.14752305f, -0.05000511f, 0.17011164f, 0.10742871f, -0.33413824f, -0.00722898f, 0.15947750f, 
    -0.19291675f, 0.05412459f, -0.02266430f, -0.96611720f, -0.02497767f, 0.11014595f, 0.33939677f, -0.38214716f, 
    0.13006264f, 0.00955529f, 0.10765710f, -0.28751114f, -0.06595318f, -0.01155961f, -0.21784708f, -0.08467431f, 
    -0.05582978f, 0.00734316f, -0.33184546f, 0.04642173f, -0.06047760f, 0.09906515f, -0.23582850f, 0.14074551f, 
    -0.23608805f, -0.08594221f, 0.41227666f, 0.02429531f, -0.11721276f, -0.04531448f, 0.03527262f, -0.08276881f, 
    0.03695865f, 0.06764023f, 0.03161347f, -0.21623819f, -0.23134539f, 0.32850519f, -0.24534503f, 0.11824522f, 
    -0.21718800f, 0.00483332f, 0.00125679f, -0.04781986f, 0.08097506f, 0.07573614f, -0.10354266f, 0.27580577f, 
    0.11279269f, -0.04469491f, 0.15081280f, -0.15095569f, -0.31966150f, -0.03571124f, -0.04962979f, -0.02997878f, 
    0.00549005f, 0.06109718f, 0.05030562f, -0.09070121f, -0.03156462f, 0.00971861f, -0.06345804f, -0.05200182f, 
    -0.02008028f, 0.01278253f, 0.02779576f, -0.05255641f, 0.02262374f, -0.06730121f, 0.03226785f, 0.07339671f, 
    0.01822967f, -0.04711492f, 0.07089464f, 0.04298095f, 0.04853005f, 0.03245702f, 0.01792695f, 0.06400570f, 
    -0.05677851f, 0.06880194f, 0.03290212f, -0.08688694f, -0.03543366f, 0.06558523f, 0.04359459f, 0.05945256f, 
    -0.08634640f, -0.02753399f, 0.04813891f, 0.07145880f, -0.08027033f, -0.00082715f, 0.02249081f, -0.02422560f, 
    0.01412181f, -0.09516293f, 0.06049944f, -0.00715874f, -0.06173564f, 0.04151261f, -0.01820397f, -0.02282097f, 
    0.03202870f, -0.08599495f, -0.01313644f, 0.03041689f, -0.05920318f, 0.07455757f, -0.00680483f, -0.08084758f, 
    0.05530597f, -0.04192158f, -0.05920639f, -0.00573253f, -0.02333243f, -0.02434727f, 0.04079220f, 0.05833768f, 
    -0.06813148f, -0.02976855f, 0.03997575f, 0.00110949f, -0.01515121f, -0.02977872f, 0.02126951f, -0.04272459f, 
    0.06307059f, 0.06309911f, 0.03790810f, 0.02936460f, 0.01041649f, -0.07286888f, 0.03076385f, 0.00202563f, 
    -0.08514926f, -0.08839545f, 0.01509240f, 0.00597169f, 0.00426610f, -0.01670360f, 0.04398594f, -0.04888077f, 
    0.01317909f, 0.08253226f, -0.02147253f, 0.00898370f, -0.07502640f, 0.02105931f, 0.06792522f, -0.01807326f, 
    0.02560111f, -0.02090059f, 0.04384570f, -0.02868308f, 0.06089947f, -0.09200022f, -0.08483808f, -0.08242182f, 
    -0.04063819f, -0.07627259f, -0.07345234f, -0.08314179f, -0.02269020f, 0.05748649f, 0.00937348f, -0.06321879f, 
    -0.10020762f, 0.06071328f, -0.02533760f, 0.02001869f, -0.07052249f, 0.07558499f, -0.04045588f, -0.10036476f, 
    -0.00761184f, -0.07884622f, 0.06459261f, -0.10094719f, -0.05928721f, 0.03267781f, -0.07494057f, 0.03119428f, 
    0.02881403f, -0.04400383f, -0.01676409f, -0.02195151f, 0.02231715f, 0.01810222f, 0.05012281f, -0.04723827f, 
    0.01808903f, 0.00077218f, 0.00986983f, -0.03147697f, 0.01878367f, 0.03192328f, 0.00218724f, 0.01794828f, 
    0.04949334f, -0.01609247f, -0.05305923f, -0.03633624f, -0.05741240f, -0.08585197f, 0.06654146f, -0.07717505f, 
    0.04426550f, 0.02864408f, -0.10368448f, -0.00550269f, 0.03655951f, -0.08308525f, 0.03605048f, -0.04603767f, 
    0.00069654f, -0.01346670f, 0.01934645f, -0.08207073f, -0.08520386f, 0.03699858f, 0.00847560f, 0.07356618f, 
    -0.02980504f, 0.03318823f, -0.06895409f, 0.03208307f, 0.01622425f, -0.10126801f, -0.07110432f, -0.04726988f, 
    -0.00799667f, -0.02327449f, -0.02717192f, 0.00424980f, -0.06754150f, -0.09543537f, -0.00989573f, 0.04244975f, 
    -0.02323792f, -0.00842351f, 0.03380668f, -0.01335015f, 0.03176244f, -0.09218313f, -0.07682362f, 0.02736408f, 
    -0.08080750f, 0.00376607f, -0.02352456f, -0.05044857f, -0.06416569f, -0.10990159f, 0.00762030f, -0.01176482f, 
    0.07631695f, -0.06710441f, 0.01417650f, -0.05089003f, -0.02996619f, -0.01411245f, -0.05606932f, -0.04205085f, 
    -0.08237633f, -0.11448019f, 0.00184310f, -0.00503486f, 0.05032755f, 0.03572635f, -0.07753807f, 0.07241812f, 
    -0.02441367f, -0.08525018f, -0.02577188f, 0.00382791f, 0.01885158f, -0.12069600f, -0.03141656f, -0.06374102f, 
    0.06624880f, 0.07805245f, 0.00605118f, 0.05754364f, -0.10423210f, 0.05015595f, 0.05383204f, 0.06681890f, 
    -0.02955377f, 0.01065471f, -0.05902845f, -0.00624528f, -0.05934415f, -0.01763851f, 0.03620104f, -0.02182239f, 
    -0.09612836f, 0.06587279f, -0.08770784f, 0.07171047f, -0.05777679f, -0.08765045f, -0.02811950f, -0.10973008f, 
    0.03911652f, 0.02445190f, -0.03725983f, 0.04992885f, -0.09940028f, -0.01201268f, 0.03467830f, -0.04682375f, 
    -0.04745836f, -0.08270956f, 0.05193314f, 0.05287651f, -0.02599142f, 0.05647910f, 0.04310173f, -0.10524208f, 
    0.03951085f, -0.00709558f, -0.09185114f, -0.10100307f, 0.03414876f, 0.01671344f, -0.02317317f, -0.08207332f, 
    0.02767905f, 0.06762216f, -0.04795810f, -0.00118196f, -0.03318698f, 0.05720694f, 0.02571359f, -0.04504276f, 
    -0.01552583f, -0.03240493f, 0.02415750f, -0.06707483f, -0.07627138f, -0.06706461f, 0.08461545f, 0.06837121f, 
    -0.03234716f, -0.08027139f, 0.03756595f, 0.05129501f, -0.00050065f, -0.01438851f, 0.05296513f, 0.03464621f, 
    0.04503113f, 0.02618613f, 0.00276640f, -0.03555617f, -0.02254603f, -0.03879805f, 0.07011346f, 0.01162256f, 
    -0.06331217f, -0.02128387f, -0.06616556f, 0.02371576f, -0.10253382f, -0.09182170f, -0.03086618f, 0.08602089f, 
    -0.01834222f, -0.01561050f, 0.01353530f, -0.02784636f, 0.07537208f, -0.04203121f, 0.01369416f, 0.05420994f, 
    -0.09068926f, -0.00417866f, -0.03336526f, -0.00174728f, 0.05957238f, -0.04810668f, -0.02605642f, -0.09988183f, 
    -0.02319705f, 0.04677354f, -0.02510745f, 0.00735634f, 0.04013174f, -0.07717543f, 0.02412698f, -0.05462695f, 
    -0.06368137f, 0.06380753f, -0.07147077f, 0.01448079f, -0.09601428f, 0.07779304f, 0.01072565f, -0.03091590f, 
    0.00379939f, -0.02902445f, -0.07177533f, -0.09101398f, -0.08342680f, -0.03196261f, -0.04038682f, -0.02917414f, 
    -0.08508172f, 0.00166190f, 0.00508523f, -0.06140039f, 0.00315685f, -0.04474863f, 0.03290803f, 0.03954466f, 
    0.03735070f, -0.10584147f, 0.05697834f, -0.03671351f, -0.10106689f, -0.04193556f, -0.01581994f, 0.04860645f, 
    -0.07806037f, -0.07676624f, -0.05066580f, -0.05358911f, -0.01760685f, -0.05910584f, -0.05036609f, 0.01177162f, 
    0.06505068f, -0.01888848f, 0.04325163f, -0.04230141f, 0.04989482f, -0.08453754f, -0.07099541f, 0.05600472f, 
    -0.00735480f, 0.05962600f, 0.11449932f, 0.17347972f, 0.01399620f, -0.25723565f, -0.14014199f, 0.36530128f, 
    0.27026719f, -0.07486836f, -0.10518334f, 0.03730785f, 0.01504322f, 0.00710243f, 0.19661663f, 0.10462195f, 
    0.01619595f, 0.08156637f, -0.12347580f, 0.08250277f, -0.01346053f, 0.05153250f, -0.21158160f, 0.16227637f, 
    0.25808886f, 0.11321882f, 0.26493758f, -0.05442064f, -0.04621039f, 0.25148925f, -0.03403214f, -0.03169798f, 
    -0.03806870f, -0.24989089f, 0.28817809f, -0.55110341f, 0.10260008f, 0.10471740f, 0.04814296f, -0.07014664f, 
    -0.01302782f, 0.31526273f, -0.36655119f, -0.00045767f, 0.42995623f, 0.06632284f, 0.04381724f, -0.47972122f, 
    0.00910551f, -0.04576299f, 0.02014948f, 0.04329202f, -0.27392778f, -0.18289064f, 0.34564307f, 0.00653819f, 
    0.04630627f, -0.14442202f, -0.14569494f, -0.15375620f, -0.04332939f, 0.09227280f, 0.00526471f, -0.04353394f, 
    -0.26745322f, -0.03120909f, -0.02937769f, 0.23886932f, 0.11143559f, -0.17188632f, -0.25458434f, -0.13382231f, 
    -0.21320362f, -0.00018960f, 0.07685273f, -0.10376413f, -0.28297743f, 0.08367933f, 0.12917823f, 0.02177174f, 
    -0.33125901f, 0.31559950f, 0.15228198f, -0.01428309f, 0.05277374f, -0.08205948f, -0.21181433f, -0.06210253f, 
    0.17986837f, -0.03650173f, -0.13252379f, 0.01517751f, -0.26055092f, -0.22307611f, -0.39244476f, -0.10804457f, 
    0.18722554f, 0.01739558f, 0.09041169f, 0.03569565f, 0.12961523f, -0.07955906f, -0.15784995f, -0.02603015f, 
    0.14230417f, 0.18690018f, -0.06377903f, 0.23457707f, 0.01634094f, 0.38598588f, -0.18091320f, 0.05711611f, 
    -0.27546951f, -0.09709165f, -0.08034787f, -0.05903226f, 0.05581092f, 0.07604325f, 0.21941438f, 0.19065550f, 
    0.23709951f, 0.05288530f, -0.04605501f, 0.12250678f, -0.20968093f, -0.28381646f, 0.03149620f, 0.20836909f, 
    0.01810006f, -0.05534620f, 0.08667979f, -0.05341075f, -0.06199285f, -0.22558933f, 0.30023456f, 0.03453946f, 
    -0.08546492f, 0.02817245f, 0.07505853f, -0.30766344f, -0.00286220f, 0.21654128f, 0.05520985f, -0.05888313f, 
    -0.36017936f, 0.01903514f, 0.16280131f, -0.00597382f, -0.01182162f, 0.00193619f, 0.07421616f, 0.11618745f, 
    -0.02157552f, -0.14099374f, -0.03105028f, -0.38447288f, 0.09425572f, 0.01204423f, -0.05224911f, 0.04973543f, 
    0.03031088f, -0.67702192f, -0.05631177f, -0.25248379f, -0.00372774f, -0.07909507f, 0.07557813f, 0.02946898f, 
    -0.02316102f, -0.16561782f, -0.00206548f, -0.01459498f, -0.16303132f, -0.01768111f, -0.05077177f, -0.50189692f, 
    0.03172247f, 0.06350573f, -0.01710007f, 0.06880277f, 0.10757591f, -0.00355401f, 0.19383597f, 0.22144300f, 
    -0.02440075f, 0.17748618f, 0.24773797f, -0.12622219f, 0.03459981f, -0.09223162f, 0.04901164f, 0.01880904f, 
    0.12086198f, -0.18106288f, 0.03081772f, -0.15836520f, 0.09102838f, -0.23949964f, 0.01093729f, 0.14892861f, 
    0.22948170f, -0.02854165f, -0.03662190f, 0.00485244f, -0.64526194f, 0.26227638f, 0.14164169f, 0.28863183f, 
    0.04868685f, 0.10000467f, 0.11213291f, 0.21218161f, -0.13312678f, 0.04471724f, 0.12375832f, -0.03707230f, 
    0.07709977f, -0.06978593f, 0.05633801f, 0.19547604f, -0.20833081f, 0.13165542f, 0.09739799f, -0.19193697f, 
    0.04906918f, 0.08958681f, 0.00309681f, 0.30459878f, -0.02094729f, 0.10234904f, 0.18492652f, 0.18169844f, 
    0.04674414f, -0.06335601f, 0.32634836f, -0.08376379f, 0.12674850f, -0.49694440f, -0.20652176f, 0.12445233f, 
    0.11117811f, -0.01402718f, 0.04160273f, -0.06663784f, 0.10869384f, -0.30849504f, -0.32220027f, 0.11117653f, 
    0.23594093f, -0.14782161f, 0.13889383f, 0.00140695f, 0.18564087f, -0.08192643f, 0.11687278f, 0.01362771f, 
    -0.02117795f, -0.00296880f, -0.04622316f, -0.00232902f, 0.04180330f, 0.01050726f, -0.04755170f, 0.04579118f, 
    0.00614941f, -0.00819769f, -0.02095697f, -0.07469368f, 0.01369273f, 0.02459936f, -0.07812779f, -0.01329266f, 
    0.07346296f, 0.01659498f, -0.01765374f, -0.09219444f, -0.03426469f, -0.10614948f, 0.03713039f, 0.01470212f, 
    -0.08756199f, -0.07235587f, -0.07884652f, -0.00061749f, -0.04043566f, 0.02493197f, -0.05423374f, 0.01224679f, 
    0.05924968f, -0.01306679f, -0.04657628f, 0.03299571f, 0.07586703f, -0.07122718f, -0.00020836f, -0.08549780f, 
    -0.03477593f, -0.04967931f, -0.02380577f, 0.02044619f, -0.04738340f, 0.06557570f, -0.05267035f, -0.01618308f, 
    -0.03792014f, 0.03192784f, -0.01832783f, -0.07765579f, 0.02214034f, -0.00908273f, -0.06130492f, 0.02651627f, 
    0.02366735f, -0.02406909f, -0.08238152f, -0.03572364f, -0.03285175f, 0.02681673f, -0.06368940f, -0.05131312f, 
    -0.02635866f, -0.01800962f, 0.00747658f, 0.04399344f, -0.05965633f, 0.07625013f, -0.03330581f, -0.00140039f, 
    0.03754308f, -0.02720113f, 0.05976011f, -0.01024315f, -0.01323893f, -0.01962260f, -0.10461293f, -0.07821032f, 
    -0.08012351f, 0.01461979f, -0.10602784f, 0.01791707f, 0.05309060f, 0.02058110f, 0.05762156f, 0.04578940f, 
    -0.10512715f, -0.00170250f, -0.10751253f, 0.01072393f, -0.06301088f, 0.03571211f, 0.04847953f, -0.03590040f, 
    -0.07357543f, -0.07545659f, 0.04400015f, -0.08151893f, 0.02945228f, 0.00168369f, -0.10596223f, -0.02393480f, 
    -0.09401820f, -0.03853916f, -0.05842422f, -0.03747938f, -0.06894466f, 0.00521525f, 0.01855835f, 0.02235601f, 
    -0.07909127f, -0.07348116f, 0.06269123f, 0.01500774f, 0.04008167f, -0.07381593f, -0.08052388f, -0.01777516f, 
    0.02532286f, -0.02904043f, 0.04892362f, -0.02983206f, 0.04938928f, -0.07568883f, 0.03020588f, -0.00911072f, 
    -0.08770119f, 0.03636774f, -0.07132421f, 0.04216564f, 0.03994400f, -0.05417758f, -0.10089453f, -0.02636618f, 
    -0.09297338f, 0.03542821f, 0.02518390f, 0.05995800f, 0.07182148f, -0.05160335f, 0.06702419f, 0.06697924f, 
    -0.03090597f, -0.06588618f, 0.04593516f, -0.01632978f, -0.04956497f, 0.06616703f, -0.02312966f, 0.07244329f, 
    -0.03818195f, 0.04166571f, -0.08383401f, -0.02798187f, -0.01526172f, -0.08475892f, 0.02453171f, 0.06083626f, 
    -0.03732797f, 0.07654247f, -0.02610508f, -0.07706262f, 0.01956828f, -0.03104475f, 0.06982926f, 0.04180006f, 
    0.03687665f, -0.03922150f, -0.03863169f, -0.07818368f, 0.05385055f, -0.02800587f, -0.00028333f, 0.06542080f, 
    -0.05616045f, 0.04671442f, -0.04068059f, -0.00753525f, -0.03504557f, -0.07561953f, -0.03798584f, 0.05453375f, 
    -0.06009444f, 0.04625894f, 0.00290933f, 0.00590404f, -0.03961701f, 0.08574405f, 0.05107462f, 0.03643696f, 
    -0.02154535f, 0.04096626f, -0.03032852f, -0.08857458f, -0.05346505f, -0.03899947f, -0.08025835f, -0.02746418f, 
    -0.09941300f, 0.07054548f, 0.02933725f, -0.06219441f, -0.05522455f, 0.04820283f, 0.03926783f, -0.00174972f, 
    0.04359492f, -0.02191393f, 0.02787698f, -0.03842608f, 0.05209839f, 0.06362452f, 0.01146184f, -0.01301693f, 
    0.00919762f, -0.05884771f, 0.05105521f, -0.08835866f, 0.06899358f, -0.05983441f, 0.03453564f, -0.07075376f, 
    -0.02081073f, -0.07290114f, -0.01799716f, 0.00545242f, 0.00118713f, -0.08191926f, -0.03391391f, 0.00674794f, 
    -0.01575533f, -0.06850741f, -0.05982026f, -0.07771099f, 0.03285267f, -0.02127354f, 0.07061633f, 0.04976162f, 
    0.03604607f, 0.03276484f, -0.08247401f, -0.07942320f, -0.03494024f, -0.01080733f, 0.04310221f, 0.04133132f, 
    0.01463825f, 0.01334662f, 0.07489254f, -0.00227508f, 0.00599890f, -0.04639545f, -0.00798036f, -0.06621856f, 
    0.38039932f, -0.11240881f, 0.29260087f, 0.10577583f, 0.22151664f, -0.42324254f, 0.28995857f, -0.04532661f, 
    -0.08801027f, -0.12426557f, 0.22521397f, -0.19093579f, -0.38441244f, 0.10024592f, 0.28888476f, -0.39972737f, 
    -0.12897785f, -0.08560277f, 0.21847613f, -0.01878030f, 0.03646765f, 0.02533730f, -0.20001251f, 0.01328089f, 
    0.27879575f, 0.02020625f, -0.00937099f, -0.06783672f, -0.12290691f, -0.04720663f, -0.03480514f, -0.14646649f, 
    -0.01593155f, 0.00337614f, 0.13340984f, 0.23688050f, 0.11592479f, -0.17194822f, 0.38852906f, 0.12505729f, 
    -0.07671175f, -0.40604305f, 0.06134531f, -0.12275500f, 0.41947922f, 0.28022906f, 0.14609304f, -0.26703611f, 
    0.02299471f, 0.06735311f, 0.08555298f, 0.15578309f, -0.02915090f, -0.12576281f, 0.18786365f, 0.50308841f, 
    -0.13063103f, 0.20583740f, -0.18042274f, 0.05582666f, 0.04317545f, -0.03201693f, -0.16393661f, -0.04113981f, 
    0.34184644f, 0.07057914f, -0.05475395f, 0.10328469f, -0.10168633f, 0.11339252f, -0.16709341f, 0.04701889f, 
    0.50084651f, -0.00127677f, -0.06439770f, -0.03121101f, 0.06461881f, 0.05800841f, -0.04511015f, 0.33777207f, 
    -0.39130700f, -0.30618915f, 0.20260076f, -0.03663765f, -0.28451750f, -0.07184532f, 0.41231498f, -0.06552135f, 
    0.47000903f, -0.07174128f, 0.37425908f, 0.16337681f, -0.12332861f, 0.10167158f, 0.40046605f, -0.11187295f, 
    0.07427970f, 0.02727813f, -0.04460408f, 0.19808476f, 0.23673786f, -0.04949215f, -0.20623322f, -0.07466547f, 
    0.06556763f, 0.03006914f, -0.30780533f, 0.10320238f, 0.03218077f, -0.23546802f, -0.20734979f, -0.41425690f, 
    0.23225600f, 0.05917014f, 0.08141911f, 0.00832381f, -0.19019391f, -0.00231643f, 0.04917975f, 0.15577862f, 
    0.21908067f, 0.08026374f, 0.03327600f, 0.37048456f, 0.47239485f, -0.17880568f, 0.19390117f, -0.27910128f, 
    0.48088336f, -0.10289490f, 0.13099276f, 0.11082885f, -0.25357836f, -0.75699222f, -0.34854129f, 0.06193896f, 
    -0.00961986f, 0.04828969f, -0.00849551f, -0.01332927f, -0.36038667f, -0.05960304f, 0.16209340f, -0.31180605f, 
    0.12041964f, -0.04087489f, 0.27986392f, -0.07031922f, 0.03517200f, 0.00786657f, -0.05600490f, -0.24022669f, 
    0.00136746f, 0.10713080f, 0.06974440f, 0.18271300f, 0.12334284f, -0.00125777f, -0.05775576f, -0.03238694f, 
    0.04326576f, -0.01395333f, -0.12733260f, 0.23293075f, -0.00991239f, 0.14474672f, 0.07817136f, 0.19501047f, 
    -0.12751445f, -0.17390153f, 0.16183120f, 0.18805619f, 0.00659547f, -0.00766872f, 0.22407387f, -0.26439890f, 
    0.08183046f, 0.04589640f, -0.02266103f, -0.02572347f, 0.08660376f, 0.00297826f, -0.03370995f, 0.29367274f, 
    -0.17538846f, -0.01974193f, -0.11117020f, 0.08315711f, 0.13430437f, 0.15568386f, -0.71780580f, 0.07042484f, 
    0.02006675f, 0.26225778f, 0.00557977f, 0.06956184f, -0.01080900f, 0.35156628f, -0.01873173f, -0.00508653f, 
    0.24372794f, -0.02723719f, -0.08679879f, -0.14975977f, -0.62217718f, 0.02065123f, 0.06182154f, -0.13892607f, 
    -0.08180223f, -0.02719958f, 0.08772674f, -0.28377375f, -0.08316337f, 0.03990527f, 0.03622790f, -0.07601959f, 
    0.13602257f, 0.05929399f, 0.33500710f, 0.08696623f, 0.22513369f, -0.06791791f, 0.09484443f, 0.17602342f, 
    -0.02652719f, 0.03178981f, -0.01180790f, -0.26411358f, 0.18129258f, 0.02651562f, -0.15027869f, -0.15147813f, 
    0.03517024f, 0.03117795f, -0.25629523f, 0.08215077f, -0.02638946f, -0.46411934f, -0.50760072f, -0.12942100f, 
    0.08276775f, -0.02213974f, 0.04182989f, -0.05904920f, -0.02328700f, 0.40255556f, 0.30735523f, -0.03374365f, 
    0.04892816f, 0.10775325f, -0.00480532f, 0.26752803f, 0.12755333f, -0.10190251f, -0.08562934f, -0.06838703f, 
    -0.01279445f, -0.13768272f, -0.03640958f, 0.03406199f, -0.00143855f, -0.05499816f, -0.09082924f, -0.01665585f, 
    0.02475744f, 0.05800002f, -0.12949412f, 0.08503145f, 0.00682484f, -0.09689799f, 0.08256255f, -0.05751318f, 
    -0.11120376f, 0.02590562f, -0.06904387f, 0.07435286f, -0.06801543f, 0.01697505f, -0.07870681f, -0.01098199f, 
    0.00693853f, -0.11521731f, 0.01978148f, -0.08326860f, -0.12668361f, -0.02756109f, 0.00644904f, -0.02358047f, 
    0.03436304f, 0.00269844f, 0.02289095f, -0.00146123f, -0.05747369f, 0.01704816f, 0.00973923f, 0.04566716f, 
    -0.06506975f, -0.07060187f, -0.04709506f, 0.00869929f, -0.06225286f, 0.03522385f, -0.03234921f, 0.00373469f, 
    0.00355528f, 0.05007225f, -0.02316955f, -0.07056640f, -0.06781289f, -0.06752852f, -0.09213687f, -0.06580476f, 
    -0.04864598f, -0.02044242f, -0.12354687f, 0.04657109f, 0.01372049f, -0.00481794f, 0.01677216f, -0.06671712f, 
    -0.09731726f, -0.07840050f, -0.08545073f, -0.02543373f, -0.06528105f, -0.00161776f, 0.03709193f, 0.01238035f, 
    -0.00806335f, -0.01679640f, 0.01230584f, -0.02868029f, 0.08301034f, -0.00924271f, 0.01352107f, 0.04528001f, 
    -0.02075800f, -0.07136582f, 0.02499552f, -0.11560569f, -0.09045051f, -0.02177178f, 0.05121157f, -0.05507478f, 
    -0.00414633f, 0.06691361f, 0.05572381f, -0.06463861f, 0.04097734f, -0.03985735f, -0.09124283f, -0.05859280f, 
    -0.03707505f, 0.01574485f, -0.07841815f, -0.02260616f, -0.04855022f, -0.01613167f, -0.00609070f, -0.03389520f, 
    -0.07855865f, -0.03791397f, -0.01661497f, -0.06998721f, -0.08071241f, 0.02282651f, 0.09474482f, -0.00109039f, 
    -0.13371830f, 0.03857153f, 0.03452758f, -0.04303370f, -0.06160460f, -0.07814983f, -0.04500689f, -0.03240333f, 
    0.03630993f, -0.13397034f, 0.05169718f, -0.06330734f, 0.06349470f, 0.00940322f, 0.00954435f, -0.12287667f, 
    -0.04451981f, -0.41968760f, 0.07804121f, 0.15065819f, -0.15681548f, 0.37755969f, -0.09558606f, 0.11970571f, 
    0.09289312f, -0.07902987f, -0.12277395f, 0.23029670f, -0.44604692f, 0.28541332f, 0.17806390f, 0.38194120f, 
    -0.08147974f, 0.05148439f, 0.10352974f, -0.22360386f, 0.04145852f, 0.00594329f, -0.57469696f, 0.06936140f, 
    0.28323206f, -0.33683658f, 0.13563773f, 0.23934965f, -0.11598301f, -0.00634205f, 0.02907786f, -0.06741150f, 
    -0.06735925f, -0.29048765f, 0.40213412f, -0.34964803f, 0.23069310f, -0.02353597f, 0.17924783f, -0.08806708f, 
    0.00513026f, 0.20904964f, 0.12774131f, -0.04804121f, 0.15657644f, 0.02978451f, -0.37746921f, 0.01520488f, 
    -0.17796125f, -0.01144335f, 0.08762866f, 0.19474930f, -0.34545979f, -0.07285787f, 0.21252726f, 0.51109046f, 
    0.24915062f, 0.02000206f, -0.11455473f, -0.78405368f, -0.00619526f, -0.15870194f, -0.04198226f, 0.30588037f, 
    -0.13739368f, -0.22933359f, 0.07560635f, 0.01816017f, -0.07210314f, 0.25756025f, -0.12087618f, -0.17510268f, 
    0.10631771f, -0.01972649f, 0.05449246f, 0.14013563f, -0.24157658f, -0.03926454f, -0.05487169f, 0.01538658f, 
    0.18548419f, 0.24255517f, 0.04084750f, 0.35959959f, -0.23993655f, 0.05764458f, -0.16259727f, 0.03386046f, 
    0.14405958f, -0.06568094f, 0.05364045f, -0.19547723f, -0.43459713f, -0.32328603f, -0.09700067f, -0.36950400f, 
    0.24779487f, 0.11558596f, 0.36128822f, -0.14925998f, -0.10454174f, -0.08136946f, -0.21557812f, 0.02747242f, 
    -0.03931772f, -0.30618483f, 0.19410732f, 0.13844086f, 0.25648347f, 0.29322568f, -0.10513211f, -0.12249143f, 
    -0.20863184f, -0.06490125f, 0.02850244f, 0.08307564f, 0.07103857f, -0.48029724f, 0.39503708f, 0.00608957f, 
    0.16911004f, -0.06277192f, -0.06407502f, 0.16075182f, 0.08086640f, -0.46326545f, -0.04568743f, 0.08192872f, 
    -0.48616430f, 0.58346051f, -0.10459846f, -0.14940436f, 0.60620505f, 0.39819694f, 0.44294980f, 0.03476480f, 
    0.10401341f, 0.01407939f, 0.21400882f, -0.01847021f, 0.15065303f, -0.18242113f, -0.06937290f, 0.17577459f, 
    0.30884802f, -0.02967795f, -0.42742139f, 0.15476805f, -0.08478830f, -0.02519006f, 0.19888002f, 0.35578218f, 
    0.08473505f, 0.04480479f, 0.04733549f, 0.15433374f, 0.05210496f, 0.13309893f, -0.00657761f, -0.24202348f, 
    -0.30279800f, -0.00824224f, 0.14123321f, -0.97317404f, 0.07764906f, 0.07000732f, 0.05111665f, 0.13305648f, 
    -0.01934405f, 0.00351027f, -0.39375511f, -0.27521461f, -0.01471021f, -0.04037224f, -0.27525428f, 0.25210482f, 
    -0.04374054f, 0.07645680f, -0.03641508f, 0.01006462f, -0.04498162f, 0.36186644f, 0.03174703f, -0.29485694f, 
    0.29293492f, -0.22587387f, 0.19143619f, -0.17887734f, -0.11648518f, 0.05526524f, 0.41013065f, -0.00670746f, 
    -0.33763477f, -0.28340667f, 0.03024939f, 0.00805885f, 0.06965365f, -0.03418941f, -0.23412207f, 0.15139645f, 
    -0.40019292f, 0.08794891f, -0.01442285f, 0.29680383f, 0.16503869f, -0.10423575f, -0.00352661f, 0.10848101f, 
    -0.26155224f, 0.06134931f, -0.01906047f, 0.31260982f, 0.61801928f, -0.04857449f, -0.12349264f, -0.06800635f, 
    0.06952382f, 0.03181026f, -0.33807313f, 0.12518683f, -0.11773022f, 0.43089023f, -0.05192917f, -0.03076692f, 
    0.13414310f, -0.03411755f, 0.08166815f, 0.49368122f, -0.08369088f, -0.07015055f, 0.15945049f, 0.36087483f, 
    0.03761914f, 0.15140982f, 0.18289375f, 0.04130368f, 0.13842170f, 0.38983077f, 0.21629995f, 0.35836744f, 
    -0.04802915f, 0.02949311f, 0.03345427f, -0.05869693f, -0.00222978f, 0.14467664f, -0.42229182f, 0.06227051f, 
    -0.12166962f, -0.12963215f, -0.09108722f, -0.08111358f, -0.23122820f, -0.20658715f, 0.42835847f, 0.16932145f, 
    -0.17462233f, 0.30336016f, -0.00338815f, -0.04665741f, 0.26956606f, -0.10762706f, -0.04969713f, 0.10236095f, 
    0.11697783f, 0.09868842f, 0.19884241f, 0.08866312f, -0.44621184f, -0.11676009f, 0.07616399f, -0.22856469f, 
    0.16512512f, -0.02639771f, -0.08628692f, 0.35658270f, 0.07865881f, 0.02904707f, 0.05407120f, 0.17142814f, 
    -0.05268305f, 0.15869613f, 0.12924816f, 0.17851949f, 0.07337989f, 0.17695062f, -0.03710341f, 0.05761902f, 
    -0.02995452f, -0.57131594f, -0.01901828f, 0.17852505f, 0.14486548f, 0.08276007f, 0.06255223f, -0.04384312f, 
    -0.05884594f, 0.09242156f, -0.10238071f, -0.05294766f, 0.00924926f, -0.02855841f, 0.01755612f, -0.18421875f, 
    0.03245070f, -0.06867196f, -0.03164253f, -0.05992191f, 0.17660764f, 0.16394910f, 0.00331191f, -0.54419065f, 
    0.02050288f, -0.03734413f, -0.02122424f, 0.15161616f, -0.00987768f, 0.22051075f, -0.37632677f, -0.00156678f, 
    -0.15679835f, 0.12549478f, 0.02298668f, 0.12161124f, -0.08172417f, -0.11897998f, -0.21790564f, -0.10304534f, 
    -0.20333363f, -0.02965879f, 0.07086350f, 0.13960795f, -0.11131824f, 0.07390693f, 0.18475871f, -0.18519655f, 
    -0.19171117f, 0.04782316f, -0.00318994f, -0.06304740f, 0.26981056f, -0.05831872f, -0.12523684f, -0.04003876f, 
    -0.06498008f, -0.05397983f, 0.06986544f, -0.02332220f, 0.12419765f, 0.04757464f, -0.03111217f, 0.07752512f, 
    0.17436895f, -0.04168947f, -0.15034740f, 0.15573630f, 0.08213291f, 0.01900630f, 0.12863123f, 0.14369060f, 
    0.09857155f, 0.12456312f, -0.16952832f, 0.24260919f, 0.01452160f, 0.57763505f, 0.13425350f, 0.04727254f, 
    -0.08346444f, 0.08219163f, -0.06553883f, 0.00111601f, -0.06787020f, 0.19488879f, -0.01031921f, 0.02634783f, 
    0.08818115f, 0.07977247f, -0.23340647f, -0.14540435f, -0.33269542f, 0.03340343f, 0.02127431f, 0.21847051f, 
    -0.28916648f, 0.16172169f, -0.14917308f, -0.00798725f, 0.13288404f, 0.16532345f, -0.10054427f, -0.17309587f, 
    0.10201220f, 0.16967678f, 0.10721461f, 0.30267861f, 0.34067228f, -0.17322506f, -0.04145822f, 0.16252166f, 
    0.32646954f, 0.00853948f, 0.02061548f, -0.22292143f, 0.05329466f, -0.08084271f, 0.14130162f, -0.22719046f, 
    -0.13927931f, 0.10191447f, 0.18550660f, 0.31835541f, 0.10078191f, -0.02532656f, -0.04062716f, -0.07260055f, 
    -0.01449598f, 0.40289131f, -0.05396310f, 0.13759784f, 0.03304022f, -0.01867110f, -0.11514704f, 0.01111199f, 
    -0.01079156f, 0.21906780f, 0.04823632f, 0.21725368f, -0.15510605f, -0.02645023f, -0.18724664f, 0.29053494f, 
    0.07203746f, 0.04109982f, -0.01250720f, -0.08606090f, 0.13890819f, 0.19965625f, -0.42873445f, 0.04962263f, 
    0.16416241f, -0.09264172f, 0.05047929f, 0.24254675f, 0.05712860f, 0.21643731f, -0.18406177f, 0.17765678f, 
    -0.12746161f, 0.16841376f, 0.08277798f, -0.18149985f, -0.02377485f, 0.20378533f, -0.12700459f, 0.09777880f, 
    -0.11588569f, 0.03373708f, 0.00043795f, 0.11347379f, -0.04671107f, -0.04144134f, -0.14367819f, -0.09879296f, 
    0.06377864f, -0.17583518f, -0.09982772f, 0.02486926f, 0.17627998f, -0.03245658f, -0.31591478f, -0.06038461f, 
    -0.22477251f, 0.05242714f, -0.19176094f, -0.08649781f, 0.29995245f, 0.02586440f, 0.01615206f, 0.10781653f, 
    0.14107567f, 0.01142651f, -0.02156915f, -0.11942714f, 0.01302175f, -0.04038785f, 0.16046897f, 0.22116914f, 
    -0.07971057f, -0.07767312f, 0.00581529f, 0.02133355f, 0.00029944f, -0.29275045f, 0.20304559f, -0.03789129f, 
    0.02336997f, 0.03358984f, 0.00752246f, 0.00115240f, -0.09172360f, 0.14880659f, 0.02713207f, -0.25747949f, 
    -0.26280650f, -0.28190076f, -0.14931536f, -0.02727144f, -0.37411344f, 0.03112624f, -0.07456860f, 0.10471678f, 
    0.02649618f, -0.08420290f, -0.05631343f, -0.10938215f, -0.06030648f, 0.07145157f, -0.00141303f, 0.01909832f, 
    -0.02926327f, 0.04374336f, -0.09900109f, 0.02327082f, -0.04217384f, 0.01626830f, 0.00663464f, -0.02240073f, 
    -0.07176801f, 0.00766236f, -0.04007763f, 0.05404961f, -0.05362629f, 0.03617296f, -0.02857275f, -0.10906739f, 
    0.00361734f, -0.05476591f, 0.00971695f, -0.05354559f, -0.00182460f, -0.08682829f, 0.01529981f, 0.02494418f, 
    0.03154247f, -0.02966174f, -0.01033839f, 0.03390176f, 0.03860043f, -0.01050292f, -0.07183310f, -0.10301972f, 
    -0.00802239f, -0.03122292f, -0.06339983f, -0.09983584f, 0.03188807f, 0.00638341f, -0.11542260f, -0.04641894f, 
    0.04013679f, -0.05347162f, 0.05403980f, -0.06847799f, -0.02653797f, -0.05950219f, -0.05662698f, -0.06204903f, 
    -0.00500159f, 0.00703964f, -0.08135255f, -0.03375856f, -0.11721750f, 0.00240592f, -0.05647074f, -0.08368164f, 
    -0.02944713f, -0.07438684f, -0.03877921f, -0.10726261f, -0.03182859f, 0.04990625f, 0.07250644f, 0.05204381f, 
    -0.07088798f, 0.02272199f, 0.00658891f, -0.00982636f, 0.00083233f, 0.02963602f, 0.05351980f, -0.09064551f, 
    -0.00495437f, -0.06083516f, -0.10418591f, -0.03166368f, 0.04604512f, 0.03455830f, -0.06746121f, 0.06341393f, 
    -0.10263446f, 0.03120716f, 0.00773717f, -0.03279670f, 0.02884383f, -0.08379518f, -0.05977573f, -0.07240661f, 
    -0.06150085f, -0.01085539f, -0.05632088f, -0.03642863f, 0.02600010f, -0.04729939f, 0.03574568f, 0.08812769f, 
    0.05208878f, -0.04011791f, -0.03179597f, -0.06059505f, -0.06771112f, -0.01105611f, 0.03322854f, -0.04171802f, 
    0.04471179f, 0.03755296f, 0.03175532f, 0.05672525f, -0.07493526f, 0.03290843f, 0.00059276f, 0.02938196f, 
    -0.07237673f, -0.07455635f, 0.08185048f, -0.04209675f, 0.01488859f, -0.04234590f, 0.05342524f, -0.03898731f, 
    -0.00752156f, 0.05729100f, -0.07258581f, -0.05579011f, 0.09498671f, 0.17592981f, -0.18183334f, -0.00189468f, 
    0.03882648f, 0.00795023f, 0.00746730f, 0.20199263f, 0.43013343f, 0.38175532f, 0.07062271f, 0.43836641f, 
    0.11482323f, 0.07431091f, -0.36145478f, -0.01844602f, 0.03918232f, -0.00326005f, -0.21187730f, 0.06101813f, 
    -0.02209102f, -0.13592851f, 0.13346145f, 0.17988639f, 0.16400370f, 0.01116782f, -0.04373813f, -0.39157212f, 
    0.09641802f, 0.44260660f, 0.08461470f, -0.34242335f, 0.13275592f, 0.04791728f, 0.05188860f, 0.10307246f, 
    -0.03162025f, 0.18620719f, -0.15725955f, 0.09168885f, -0.08289450f, 0.08904224f, -0.54609615f, 0.14312688f, 
    -0.40366903f, -0.06391587f, 0.06794884f, -0.09560338f, -0.08010282f, 0.30749494f, -0.05712383f, 0.00691419f, 
    0.09813560f, -0.04248541f, 0.30022642f, -0.19376668f, -0.08315359f, 0.00916126f, 0.41937149f, 0.19195291f, 
    -0.46980384f, -0.13597514f, 0.00236450f, -0.01504467f, 0.01019228f, 0.17614272f, -0.19675677f, -0.17926945f, 
    -0.37214833f, -0.00815720f, -0.03334622f, 0.16621903f, 0.16047092f, 0.04594184f, 0.05692663f, 0.06809666f, 
    -0.07242692f, -0.08263537f, -0.09669805f, 0.13399476f, 0.11797886f, 0.01819223f, -0.41464576f, -0.02862043f, 
    -0.02762330f, 0.02996075f, -0.13322735f, -0.12389371f, 0.07462712f, -0.17538893f, -0.23351915f, -0.01042697f, 
    0.06717288f, 0.02769433f, 0.28787324f, -0.01825681f, -0.03437508f, -0.11548525f, 0.03635804f, 0.18905266f, 
    0.05492587f, -0.08879221f, 0.12567298f, 0.12655289f, 0.03639622f, -0.56741816f, 0.20238878f, 0.09733930f, 
    -0.02712450f, -0.03839230f, -0.00160340f, 0.02925722f, -0.03788574f, -0.10937858f, 0.17070462f, -0.08922410f, 
    0.02951984f, -0.35359502f, -0.24220563f, -0.05602099f, -0.43082595f, -0.39759764f, 0.06574216f, 0.13809966f, 
    0.02368028f, -0.03041012f, -0.04529207f, -0.07388510f, -0.10352176f, -0.03902183f, -0.00243007f, -0.03658737f, 
    0.04048193f, 0.00854594f, -0.13161184f, -0.01133533f, -0.11772462f, -0.10684896f, -0.09608711f, 0.02668083f, 
    -0.12227965f, -0.05910027f, 0.01535150f, -0.00926956f, -0.04075593f, 0.00239322f, -0.02836822f, 0.04087457f, 
    -0.09408315f, 0.00169670f, 0.04412330f, -0.02313127f, -0.03481198f, -0.06399079f, 0.07832535f, 0.00765001f, 
    0.00698283f, 0.02030874f, -0.08995975f, -0.08808336f, 0.00941462f, -0.02904539f, -0.04425444f, -0.08890096f, 
    -0.02885979f, -0.03165707f, 0.05513824f, -0.01774139f, 0.07170819f, -0.08418322f, 0.04153700f, -0.09596575f, 
    -0.08959693f, 0.07729049f, -0.02177995f, -0.09329543f, -0.06623701f, -0.04335726f, -0.07155404f, 0.04240922f, 
    0.02568160f, -0.07246075f, -0.11705001f, 0.07037840f, 0.02824167f, -0.06079507f, -0.09077676f, 0.03437471f, 
    -0.06404855f, 0.02622376f, 0.06817521f, 0.04450649f, 0.04562622f, -0.12784514f, -0.04968530f, 0.02886434f, 
    0.05153815f, -0.00187998f, 0.01154506f, -0.14089561f, -0.01643979f, -0.00150842f, -0.08285695f, -0.01379145f, 
    0.03578188f, -0.12550966f, 0.02450243f, -0.10884097f, -0.07000139f, -0.06308079f, -0.01166847f, -0.00133709f, 
    0.03451878f, -0.07834095f, 0.00338916f, 0.07113455f, -0.00976295f, 0.04581062f, -0.04165607f, 0.05990437f, 
    0.04668973f, 0.02758020f, -0.07950545f, 0.01340961f, 0.02536673f, -0.09398141f, -0.00368848f, -0.07466794f, 
    -0.00881724f, -0.01467335f, -0.07733072f, -0.06952354f, -0.09584586f, -0.04415207f, -0.10317197f, -0.05140426f, 
    0.03921747f, 0.01831957f, -0.00493550f, 0.02001703f, 0.00333970f, 0.03093155f, 0.02731977f, 0.06373044f, 
    -0.05821951f, 0.02316749f, -0.01480282f, -0.04671765f, 0.04877308f, -0.06092612f, -0.02037932f, -0.08433567f, 
    -0.11379479f, 0.00936065f, 0.05783208f, -0.18126042f, -0.02468375f, -0.02787538f, -0.07493822f, 0.10520047f, 
    0.12114759f, 0.01104299f, 0.05777132f, -0.00429012f, -0.06427626f, 0.15892258f, 0.03133857f, -0.03525413f, 
    -0.01170778f, 0.08791148f, 0.09902133f, -0.09607329f, -0.06677092f, 0.05831267f, -0.16443051f, 0.29465491f, 
    -0.05369800f, -0.19501841f, 0.02619255f, 0.01935268f, -0.01059186f, 0.06107189f, 0.08652607f, 0.14296566f, 
    -0.14818436f, -0.51125920f, 0.20666739f, -0.34347525f, 0.09839860f, 0.06633839f, -0.00776294f, -0.06273854f, 
    0.06266236f, -0.13238657f, -0.23681712f, -0.02851816f, 0.20430657f, 0.08711322f, 0.07731744f, -0.15169275f, 
    0.25635651f, 0.02825581f, -0.05584116f, 0.16568616f, -0.26487571f, 0.19669475f, 0.26818070f, 0.03640459f, 
    0.11282637f, 0.08321948f, -0.04404129f, -0.09088764f, 0.17326148f, -0.06675390f, -0.08593162f, 0.10984293f, 
    -0.74595505f, -0.35024634f, 0.07485216f, 0.15339944f, 0.11520671f, 0.03081257f, -0.22131634f, 0.16646142f, 
    -0.17967854f, -0.08283285f, -0.03722699f, 0.13480137f, -0.12230652f, 0.16706210f, -0.01260176f, 0.15594089f, 
    -0.40439811f, 0.08431763f, 0.05196734f, 0.12508474f, 0.03466744f, 0.09115402f, -0.09401470f, 0.01279097f, 
    0.20726685f, -0.04587429f, -0.04858597f, -0.06670205f, -0.13487442f, 0.20680395f, 0.07237112f, -0.15424530f, 
    0.00153868f, -0.05494278f, 0.18685479f, 0.06925803f, -0.20586862f, -0.05381777f, -0.06549546f, -0.04316802f, 
    0.08251175f, -0.08685821f, -0.05605656f, 0.15621029f, 0.25357190f, 0.64018810f, -0.08182436f, 0.12872636f, 
    0.28168654f, -0.05706449f, 0.07162136f, -0.06039548f, 0.04277959f, -0.09203302f, -0.03113213f, 0.22933984f, 
    0.22869572f, -0.33097550f, 0.03687536f, -0.02042860f, -0.05576232f, -0.12979615f, 0.04517863f, 0.03569376f, 
    0.02163676f, -0.01195796f, -0.03731712f, 0.01786477f, -0.06557082f, 0.08600228f, -0.05999816f, 0.01456121f, 
    -0.09166283f, -0.04032568f, -0.03829337f, -0.04636358f, 0.06102935f, -0.01113562f, 0.02313118f, 0.01876586f, 
    -0.03988957f, 0.01448300f, -0.08851367f, 0.02895291f, -0.00494376f, -0.06388230f, 0.04884369f, -0.09485456f, 
    0.01407554f, -0.03020787f, 0.02454355f, 0.03033050f, 0.06260104f, -0.00862566f, 0.04352823f, 0.02582697f, 
    -0.04100695f, 0.06639907f, -0.03919728f, 0.06693223f, 0.00737003f, -0.07374270f, -0.06200908f, 0.00330068f, 
    -0.03052375f, -0.08031926f, 0.05241532f, 0.06983887f, 0.00595585f, -0.06514763f, 0.03912061f, 0.04166767f, 
    -0.03152620f, -0.03201470f, -0.08146467f, 0.01003537f, -0.09569537f, 0.05371273f, 0.03407894f, -0.05031326f, 
    -0.02028373f, -0.09025700f, -0.07490074f, -0.05603062f, 0.03262651f, 0.07881221f, -0.05256305f, -0.06036214f, 
    0.00689194f, -0.09696715f, -0.07963578f, -0.03178328f, -0.06694771f, -0.07969019f, -0.06500749f, 0.02080712f, 
    0.03729527f, -0.07216017f, -0.03848160f, -0.04179292f, -0.08039922f, -0.02464165f, 0.01919986f, -0.05966109f, 
    -0.08840968f, -0.09845328f, 0.05595876f, 0.02467403f, -0.01637926f, -0.05434971f, -0.02894105f, 0.02680737f, 
    0.02272061f, 0.00758396f, 0.00515590f, -0.06532045f, -0.10519805f, 0.02566552f, -0.06858303f, -0.03002191f, 
    -0.03650551f, 0.02831561f, -0.09280896f, -0.09949698f, -0.04840295f, -0.00611020f, 0.05942125f, 0.00628592f, 
    -0.00640415f, -0.02039770f, -0.10417353f, -0.05076394f, 0.03820362f, 0.05000464f, 0.02043104f, -0.03901871f, 
    -0.08889627f, -0.02221508f, -0.01187133f, -0.01634928f, -0.03659166f, 0.06562652f, -0.07090836f, 0.01962315f, 
    -0.08353409f, 0.03172189f, 0.00363518f, 0.07597041f, -0.02682082f, -0.06999899f, -0.07268170f, -0.08276246f, 
    0.01387413f, 0.03272589f, -0.06040194f, -0.05725433f, 0.01115366f, -0.01564905f, 0.05720988f, 0.02449054f, 
    -0.07320760f, 0.02687006f, -0.09406624f, -0.02079207f, 0.08012713f, -0.08735386f, -0.03645264f, 0.04507721f, 
    -0.03275036f, -0.02189288f, -0.04107665f, -0.08466596f, -0.01047812f, 0.05661624f, 0.06059593f, 0.06514573f, 
    -0.09235623f, -0.08614305f, -0.05108020f, 0.04653275f, -0.09504696f, 0.01208715f, 0.05318103f, 0.07272246f, 
    -0.03709959f, 0.07366610f, 0.06599234f, -0.02964462f, -0.08306409f, 0.02317790f, -0.07072312f, -0.07801405f, 
    0.05387038f, 0.03912504f, 0.06769431f, 0.06538741f, -0.03020449f, -0.07999966f, 0.05526131f, -0.00127105f, 
    0.01186395f, 0.08219077f, -0.02766429f, -0.04001219f, 0.04418475f, 0.03828428f, -0.05079399f, 0.06001304f, 
    0.04450363f, -0.04317158f, 0.03138523f, -0.08339659f, -0.05177096f, 0.01735555f, 0.07965703f, -0.00312932f, 
    -0.08592212f, 0.02201551f, -0.07057495f, 0.07586505f, 0.00033446f, 0.01814317f, -0.02373154f, -0.03297294f, 
    -0.04930556f, -0.05875787f, 0.06567828f, -0.04305706f, -0.07595502f, -0.02610679f, 0.05454730f, -0.02307644f, 
    -0.08058558f, -0.02737722f, -0.05005632f, -0.08324648f, -0.03080788f, 0.03026737f, -0.01343401f, 0.04991545f, 
    -0.05500244f, 0.05276752f, -0.02377868f, -0.09474031f, 0.05330012f, -0.01596027f, -0.06256240f, -0.03885761f, 
    -0.05315059f, 0.08701903f, -0.01322997f, -0.04325632f, 0.02977438f, -0.07895198f, 0.07113521f, 0.01203212f, 
    0.03500370f, 0.04183793f, 0.01241573f, -0.00257046f, -0.05145499f, 0.04952354f, 0.03654696f, -0.01795246f, 
    -0.03850447f, -0.02485723f, 0.07582066f, 0.01652945f, 0.01495509f, 0.03168701f, -0.08673187f, -0.01305512f, 
    0.00265362f, -0.00823009f, 0.00088876f, -0.09155566f, 0.02651221f, -0.03745433f, -0.00463626f, 0.05672593f, 
    0.05377194f, 0.32952657f, -0.03396123f, 0.17907794f, 0.31316930f, -0.14919966f, -0.20057015f, 0.00973015f, 
    0.04568702f, -0.01335617f, 0.05257808f, 0.17428918f, -0.10888518f, -0.11013037f, 0.25552204f, -0.00749575f, 
    0.42350653f, -0.01535310f, -0.09921929f, 0.22925881f, 0.07804798f, -0.08895638f, 0.06962835f, 0.08036374f, 
    0.22344030f, 0.07352231f, 0.14194848f, 0.07368530f, 0.03759314f, 0.17958212f, -0.09242552f, 0.02022088f, 
    -0.06780377f, -0.02593128f, 0.02424812f, 0.18055055f, 0.06178050f, 0.04325617f, 0.18063147f, 0.12469056f, 
    0.01745419f, 0.11003879f, 0.04800669f, -0.03414002f, -0.06598841f, 0.07130679f, 0.15736519f, -0.08516801f, 
    -0.14575586f, -0.00181911f, 0.03811167f, -0.04869159f, -0.06161816f, 0.05240146f, -0.09902137f, -0.46141016f, 
    0.08205933f, -0.11920683f, 0.06117431f, 0.09607980f, -0.04552797f, 0.27257264f, -0.28383604f, 0.09152790f, 
    -0.06955346f, 0.22514586f, -0.00712983f, 0.06707211f, -0.13791788f, -0.01329302f, -0.34172133f, -0.13269399f, 
    -0.18749966f, 0.01261939f, -0.08358792f, -0.07415649f, -0.07518511f, 0.04720506f, 0.13571647f, -0.24570002f, 
    -0.42249730f, 0.02512464f, 0.01076891f, -0.19211246f, 0.29840112f, -0.10346171f, -0.17392687f, -0.08319339f, 
    -0.09988049f, -0.01269210f, -0.22926639f, -0.11945935f, 0.16730112f, 0.04965552f, -0.02327326f, 0.15950415f, 
    0.13581164f, -0.03253827f, -0.11531171f, 0.17895307f, 0.02898154f, -0.12718430f, -0.03271426f, 0.08643623f, 
    0.06839428f, 0.24500872f, -0.17519405f, 0.16021113f, -0.03033935f, 0.10352300f, 0.14011033f, -0.00251449f, 
    -0.11937024f, 0.12054648f, -0.00846329f, -0.05735517f, -0.21966255f, 0.33419430f, 0.00666996f, -0.05661380f, 
    -0.05634867f, -0.04396926f, -0.45062113f, -0.16292901f, -0.39600652f, -0.01043479f, 0.13539469f, 0.25324613f, 
    -0.32116756f, 0.04122109f, 0.13398115f, 0.07162349f, -0.06116143f, 0.09927272f, 0.17223963f, 0.24363795f, 
    -0.07351410f, 0.04268270f, -0.16689084f, -0.08392534f, -0.16101053f, 0.08861722f, 0.09970522f, 0.09889126f, 
    -0.13884996f, -0.00540823f, -0.12546821f, 0.39205274f, -0.07144476f, 0.19262630f, -0.07841825f, 0.33701658f, 
    0.18478489f, -0.11728981f, 0.08267733f, -0.15529874f, 0.13960303f, 0.11453455f, -0.08458220f, -0.02318339f, 
    -0.06586900f, -0.61617690f, 0.24528266f, -0.18959239f, 0.14505559f, 0.15306780f, 0.09486212f, 0.04763860f, 
    0.09239275f, -0.13259289f, -0.00988458f, -0.32098135f, 0.44433102f, 0.19146383f, 0.16280594f, -0.18626317f, 
    -0.17756748f, -0.02697528f, -0.00544796f, -0.02236510f, -0.15769549f, -0.18120584f, 0.42156419f, -0.14285602f, 
    0.09014228f, 0.12454454f, -0.04188964f, -0.06237339f, 0.03987005f, 0.03611673f, 0.10574979f, -0.05626619f, 
    -0.09234961f, -0.14203927f, -0.06863960f, 0.05324055f, 0.13839424f, -0.15796593f, 0.00431997f, -0.09363625f, 
    0.00389886f, 0.05057057f, 0.04984992f, 0.07950423f, 0.04593398f, 0.18931048f, 0.31721190f, 0.08083504f, 
    0.08595529f, 0.35444245f, 0.09349353f, 0.17725977f, 0.02344155f, 0.06695649f, 0.20038123f, -0.03201869f, 
    -0.21136665f, -0.08535491f, -0.54644543f, 0.16074149f, -0.26529753f, -0.13954182f, -0.22256425f, -0.16753376f, 
    -0.00968816f, -0.02994528f, -0.04874149f, 0.30406928f, -0.05913727f, 0.08087486f, -0.06750353f, -0.02859975f, 
    0.24706988f, 0.16337287f, 0.02859237f, 0.09613682f, 0.10855302f, 0.34917903f, 0.08657034f, 0.19735561f, 
    -0.21409830f, -0.00202085f, -0.00627429f, -0.07432152f, -0.08928327f, 0.00509750f, -0.22831139f, 0.12833256f, 
    0.09773107f, 0.02781776f, 0.07281442f, -0.34076977f, -0.03881203f, -0.04359086f, -0.02296150f, 0.07644996f, 
    -0.11050764f, -0.01609451f, -0.02606376f, -0.08976583f, -0.08288384f, -0.05954634f, 0.06156839f, 0.01622666f, 
    -0.06805818f, 0.02195676f, -0.09956577f, 0.03756281f, -0.06613407f, -0.01068914f, -0.06982245f, 0.00317185f, 
    -0.00098599f, 0.01122757f, -0.02988338f, 0.03013780f, -0.01715416f, -0.09665988f, 0.01208789f, -0.05498789f, 
    -0.04640916f, -0.03785548f, -0.06652648f, 0.00375536f, -0.01690337f, 0.05057936f, -0.00453676f, 0.03577164f, 
    0.00972976f, -0.07360057f, -0.03343584f, 0.00323253f, 0.06788921f, 0.04407253f, -0.02386198f, 0.03793546f, 
    -0.08030776f, -0.04688599f, -0.07083340f, -0.06947251f, -0.06976795f, -0.02564187f, -0.04988507f, -0.04021296f, 
    -0.03269020f, -0.02048758f, -0.00172891f, 0.02400232f, 0.02117043f, -0.02827361f, 0.06205513f, 0.01524231f, 
    -0.09039496f, 0.00523056f, 0.01295187f, 0.04832921f, -0.08476431f, -0.08058227f, -0.03253426f, -0.07126523f, 
    0.06084258f, -0.01454470f, -0.03032704f, -0.09774129f, 0.03720389f, 0.01740416f, 0.03019990f, -0.02076204f, 
    -0.10684832f, 0.00518874f, 0.00893020f, 0.01826759f, 0.01467740f, -0.07042416f, -0.08199361f, -0.04588765f, 
    -0.08054672f, -0.02236742f, -0.04893762f, 0.07928904f, -0.06659341f, 0.01633791f, 0.05992874f, 0.06435294f, 
    -0.00740599f, 0.08597118f, -0.03226343f, -0.04642125f, -0.10533248f, -0.06377122f, 0.03850840f, 0.00808825f, 
    -0.04545467f, 0.00551313f, 0.02172362f, 0.04754273f, 0.01831831f, -0.00631472f, -0.11036393f, -0.11036539f, 
    -0.10147136f, -0.09557286f, 0.00711065f, -0.06906309f, 0.02064444f, 0.01031841f, -0.06512140f, -0.01170956f, 
    0.00221116f, -0.03409959f, -0.08774281f, -0.00672426f, -0.08292130f, 0.03667819f, 0.02150332f, 0.01410774f, 
    -0.11618716f, -0.08333398f, -0.08157758f, 0.04939006f, 0.04253260f, 0.01970939f, 0.04004283f, -0.07608110f, 
    0.03835940f, 0.30769679f, 0.02633372f, 0.00898270f, 0.43514067f, -0.25378692f, -0.21501265f, 0.11735818f, 
    0.17910634f, -0.00396626f, 0.20226197f, 0.04169269f, -0.26697025f, -0.05019503f, 0.16061953f, -0.11866773f, 
    0.29160136f, 0.07845617f, -0.02183184f, 0.14532682f, 0.01442451f, -0.02688154f, 0.11942682f, 0.18051560f, 
    0.03945823f, 0.01264620f, 0.08665905f, 0.18782711f, 0.12451321f, 0.16327512f, 0.05287421f, 0.01925142f, 
    -0.07429687f, -0.50506669f, 0.04020692f, 0.04612366f, 0.20479347f, -0.00956757f, 0.20730649f, 0.01061218f, 
    0.00403898f, 0.14170092f, -0.37266603f, -0.01221888f, -0.07861280f, -0.05939949f, -0.01592227f, -0.34015492f, 
    0.09179181f, 0.00081176f, -0.00003812f, 0.00845613f, 0.04498301f, -0.01628916f, -0.00550213f, -0.43459386f, 
    0.05621288f, -0.13622913f, -0.16188683f, 0.07357717f, 0.01693950f, 0.14871415f, -0.56017458f, -0.01289422f, 
    -0.09035603f, 0.04495968f, 0.04867952f, 0.08015103f, 0.03556981f, -0.16553712f, -0.15765852f, -0.09556074f, 
    -0.11195832f, 0.03473048f, 0.04386593f, 0.06635956f, -0.43746060f, 0.08780395f, 0.21594842f, -0.23614928f, 
    -0.12818542f, 0.15561956f, 0.03276030f, -0.11318639f, 0.32208696f, -0.10307179f, -0.23590460f, -0.08185330f, 
    0.05846000f, 0.08364858f, 0.07590998f, 0.06462138f, 0.10285095f, 0.03437641f, -0.05168301f, 0.14297040f, 
    0.09981259f, 0.04318695f, -0.07268089f, 0.02172027f, 0.04197549f, -0.06590582f, 0.05289112f, 0.16056141f, 
    0.09088454f, 0.23117760f, -0.22723052f, 0.22337833f, 0.00381491f, 0.63766646f, -0.10171807f, 0.15271664f, 
    0.03507878f, -0.00766869f, 0.03393444f, -0.00223376f, -0.15336050f, 0.08736642f, 0.06392090f, 0.04442684f, 
    -0.02725790f, 0.00660886f, -0.17561126f, -0.03310109f, -0.24170269f, 0.09276549f, 0.14612339f, 0.15797313f, 
    -0.09585578f, 0.22218765f, -0.07345839f, 0.05172901f, 0.42336854f, 0.08768154f, 0.20885704f, -0.22034167f, 
    -0.02198949f, 0.03648575f, 0.10603450f, 0.11015702f, 0.31162441f, -0.41928709f, -0.25944468f, -0.02582623f, 
    0.25277263f, 0.00959691f, -0.18137741f, -0.04516043f, 0.03916599f, -0.14833406f, 0.06189909f, 0.18518028f, 
    0.11661730f, 0.17308146f, 0.08323449f, -0.09522644f, -0.10537564f, 0.08126187f, -0.04982152f, -0.16169538f, 
    -0.12020700f, 0.16389872f, -0.16359147f, -0.10343312f, 0.03678975f, 0.03317236f, -0.24251163f, -0.07362923f, 
    -0.01422783f, 0.06923504f, 0.14482801f, -0.03341168f, -0.09989908f, -0.15079242f, 0.07518371f, 0.11547564f, 
    -0.03568960f, 0.04245575f, 0.07646297f, -0.00783219f, 0.09770378f, 0.07591810f, -0.20321086f, -0.18448277f, 
    0.06277374f, -0.18866625f, 0.09034218f, 0.04526372f, -0.12842084f, 0.07316627f, 0.02660844f, -0.01113637f, 
    -0.09970260f, 0.05015229f, -0.06049892f, -0.14325993f, 0.00530679f, 0.02259903f, -0.00562936f, 0.12705395f, 
    0.15486690f, -0.08024459f, 0.08736476f, 0.00320522f, 0.14660347f, -0.24637219f, -0.13462670f, -0.02016028f, 
    -0.03932246f, 0.14209737f, -0.19436532f, -0.00141604f, 0.25784382f, 0.00640606f, 0.05974571f, -0.01465075f, 
    -0.23103704f, 0.07615825f, -0.18188660f, 0.05987542f, 0.23862977f, 0.19178362f, 0.19171353f, 0.10374181f, 
    0.05103736f, 0.02407574f, -0.09063988f, 0.15807749f, 0.06713625f, -0.11008909f, 0.02347140f, 0.14946921f, 
    -0.10869244f, 0.10354529f, -0.08035047f, 0.19671790f, -0.02194555f, 0.17915566f, 0.12839220f, 0.01677768f, 
    0.23911017f, 0.05164603f, 0.07044508f, 0.04407312f, 0.05647971f, 0.06562078f, -0.01483347f, -0.07228372f, 
    -0.19433552f, 0.10419784f, -0.09678133f, -0.27225551f, -0.00663499f, -0.01359210f, 0.17143932f, 0.17123041f, 
    0.08880353f, 0.15116706f, 0.07440452f, 0.13417637f, 0.11882289f, -0.05002328f, -0.06086168f, -0.05006202f, 
    -0.06360180f, -0.09466853f, 0.07490118f, 0.03066112f, -0.51475120f, -0.11551601f, 0.27273053f, -0.32890362f, 
    0.22095615f, 0.05989434f, -0.08050047f, 0.19498275f, 0.00243792f, 0.03976656f, -0.18903156f, 0.00731463f, 
    0.01391219f, 0.19905873f, 0.01799796f, 0.30968976f, 0.01825249f, 0.09534898f, 0.01255527f, 0.18895589f, 
    -0.14594920f, -0.42225763f, -0.02147810f, 0.77346790f, 0.00474361f, -0.00328380f, 0.21502668f, 0.18184237f, 
    -0.04737646f, -0.08621324f, 0.46848553f, -0.14579400f, 0.34332564f, 0.21602026f, 0.21286842f, -0.00108250f, 
    -0.04548206f, 0.03512516f, 0.05317902f, 0.06804360f, 0.22369131f, 0.12402581f, 0.00711027f, -0.24569900f, 
    -0.12800537f, -0.21370625f, 0.01898814f, 0.34445119f, -0.02016907f, 0.17087986f, -0.51710081f, -0.07436769f, 
    0.38493681f, 0.23882981f, -0.08309651f, 0.16070466f, -0.09287487f, 0.08811427f, -0.55067688f, 0.22705318f, 
    0.23006293f, 0.01407702f, -0.02903037f, 0.04255329f, -0.27640253f, -0.01839467f, -0.14599101f, -0.00752356f, 
    -0.91175258f, -0.21423054f, -0.21152066f, -0.12418170f, -0.04164664f, -0.07386131f, -0.00260342f, 0.04982610f, 
    0.10633341f, -0.01866305f, -0.02683486f, -0.05274364f, 0.19363996f, 0.13260499f, 0.19328995f, 0.27176887f, 
    -0.02738261f, -0.02022943f, -0.08322096f, -0.10250676f, 0.37923560f, -0.15205273f, -0.10862950f, -0.02877242f, 
    -0.00949077f, 0.25413507f, -0.55325186f, 0.02754773f, -0.01101311f, 0.13922735f, 0.05605079f, -0.22257665f, 
    0.09866367f, -0.04398797f, -0.05732144f, 0.07194383f, -0.39561257f, 0.39126307f, 0.12057611f, -0.08120240f, 
    -0.09739129f, 0.09184484f, -0.78858608f, -0.13958913f, -0.24443173f, 0.11443651f, 0.10614030f, 0.02936708f, 
    -0.23878071f, 0.19137618f, -0.07508173f, 0.12534611f, 0.23778670f, 0.14480782f, 0.08481154f, -0.33287364f, 
    0.00383522f, -0.04636235f, 0.14468895f, -0.00007235f, -0.09085971f, -0.26403123f, -0.08848957f, -0.15708868f, 
    0.16517162f, -0.03000998f, 0.14291896f, 0.07187837f, 0.04391726f, 0.22946501f, -0.05277707f, -0.10106387f, 
    -0.22102678f, 0.09509625f, -0.02948789f, 0.16734132f, 0.05199129f, -0.06049363f, 0.04555634f, 0.11072060f, 
    -0.13886100f, -0.38623562f, -0.06320834f, 0.72097158f, -0.08740184f, 0.04824896f, -0.02075819f, 0.00877458f, 
    -0.04999271f, -0.14449652f, 0.63799971f, -0.09193759f, -0.13232991f, 0.01938113f, 0.18787169f, 0.20616801f, 
    -0.02282641f, -0.00985534f, -0.03857868f, 0.17767143f, 0.10054395f, 0.28029338f, -0.30178675f, -0.31831256f, 
    0.04331619f, 0.13050918f, 0.09613703f, 0.13664004f, -0.01157474f, 0.19942829f, -0.08725931f, -0.09853126f, 
    -0.34760109f, 0.14534919f, -0.05034911f, -0.03227767f, -0.05001732f, 0.13801263f, -0.13578078f, 0.21250586f, 
    0.12735911f, 0.07505979f, 0.04154184f, 0.17338377f, 0.23821911f, -0.04648630f, -0.20214973f, 0.17363107f, 
    -0.35357875f, -0.07193139f, -0.05466763f, 0.00070611f, 0.02808491f, 0.02226435f, 0.14069816f, 0.03685223f, 
    -0.14188457f, 0.06599520f, -0.10026575f, 0.00032958f, 0.33247444f, 0.12070900f, 0.42588773f, 0.22802368f, 
    -0.01677831f, 0.00254045f, -0.03855409f, -0.13493694f, 0.00338568f, -0.08432648f, 0.17487037f, -0.02666461f, 
    -0.16061594f, -0.04642498f, 0.02662508f, 0.10395618f, 0.06397797f, 0.02378933f, 0.28238335f, -0.19020696f, 
    0.27212796f, 0.04393369f, 0.08732674f, -0.01391380f, -0.11625730f, 0.00555814f, 0.21090239f, 0.03160052f, 
    -0.21548431f, 0.06067741f, -0.25248283f, -0.18049887f, 0.01007023f, 0.07762270f, 0.11858410f, -0.02912390f, 
    -0.08081541f, -0.01943154f, -0.02762413f, -0.07925566f, -0.06029609f, 0.01883763f, -0.06553641f, -0.09921354f, 
    0.00149947f, -0.10614800f, -0.04244284f, 0.07181560f, 0.05373581f, -0.00772678f, -0.00748078f, 0.06669099f, 
    0.04706974f, -0.00691563f, -0.00237284f, -0.07683855f, 0.05674157f, 0.08122130f, 0.02806575f, 0.05232011f, 
    -0.00181962f, -0.09723092f, 0.03081221f, -0.03170783f, -0.00757921f, -0.00429291f, -0.07367121f, -0.06704586f, 
    0.05446538f, -0.03954602f, -0.06670965f, 0.00689066f, -0.08128225f, -0.02900218f, 0.07152849f, -0.10910253f, 
    -0.02486355f, 0.00308272f, -0.01297227f, -0.09441190f, 0.00043342f, -0.07614304f, 0.00951712f, 0.01981260f, 
    -0.08500738f, 0.05913734f, 0.02800855f, -0.00161011f, -0.04555592f, -0.10874082f, 0.01028992f, 0.04087086f, 
    -0.03939426f, 0.06492217f, -0.01621578f, -0.04075205f, -0.09074618f, 0.01827519f, -0.07842135f, 0.02408540f, 
    -0.05381233f, 0.05093237f, -0.05106618f, -0.04553720f, -0.10592377f, -0.01789443f, 0.01563134f, -0.05438161f, 
    0.07509205f, -0.00523606f, 0.03638985f, -0.08468190f, -0.00560926f, 0.02289972f, -0.09498511f, -0.03824500f, 
    -0.05068807f, 0.00925013f, -0.07662055f, 0.00555342f, -0.07707819f, -0.07080604f, -0.01694517f, -0.05252071f, 
    0.04184173f, 0.03214063f, 0.05148910f, 0.05218147f, 0.03895231f, 0.08360749f, 0.07531954f, -0.03522103f, 
    -0.04201490f, 0.01710763f, 0.05671837f, -0.06128500f, -0.07612332f, -0.06300025f, -0.10637215f, 0.04806686f, 
    -0.06746089f, -0.11376552f, -0.01755993f, 0.00899727f, -0.01723922f, -0.04603545f, -0.08810120f, 0.00763679f, 
    -0.03047917f, 0.01216088f, -0.00389219f, 0.01434145f, 0.02336959f, 0.01044859f, -0.07295080f, 0.01622866f, 
    -0.06251226f, 0.00523453f, -0.06535590f, -0.03933822f, -0.03147751f, -0.04338253f, 0.02905507f, 0.00927460f, 
    0.00457357f, -0.03953424f, 0.11244345f, 0.02075689f, 0.03317317f, 0.21021284f, 0.14682594f, -0.10578742f, 
    -0.23758429f, -0.12380020f, 0.01525606f, 0.03177938f, 0.30714989f, -0.04153936f, -0.33523136f, 0.29704675f, 
    -0.03291753f, -0.02147568f, 0.60562629f, -0.53836060f, -0.05689573f, 0.14954503f, -0.26147431f, 0.19841218f, 
    -0.09423754f, -0.18424283f, -0.08070393f, 0.05188863f, 0.18906549f, 0.06877370f, 0.05798812f, 0.25306910f, 
    -0.22684683f, -0.49854457f, 0.19192281f, 0.04791616f, 0.02776686f, 0.12128896f, -0.16792136f, -0.15332405f, 
    -0.08956171f, 0.04194224f, 0.19250913f, -0.23944658f, -0.25058514f, -0.08991506f, 0.21917771f, -0.04076886f, 
    0.24723569f, -0.05688100f, 0.03123127f, 0.36889160f, -0.20314495f, 0.15096696f, -0.04180455f, 0.26229441f, 
    0.18137175f, 0.49768186f, 0.12622495f, -0.10671704f, 0.15808733f, -0.08258801f, 0.32021084f, -0.05393111f, 
    -0.62903112f, -0.38822162f, 0.07951266f, 0.01993671f, 0.03327737f, -0.09176020f, 0.06935952f, 0.31910816f, 
    0.27234688f, 0.06437576f, -0.00690607f, -0.01983481f, 0.22487251f, 0.22204788f, 0.09913243f, 0.19950068f, 
    0.13182712f, 0.04374059f, 0.10029148f, 0.22594969f, 0.13989000f, 0.01932078f, 0.33708572f, 0.03517437f, 
    0.01424795f, -0.00939200f, 0.07859786f, -0.02886274f, -0.15329285f, 0.36978763f, 0.40839332f, -0.00521510f, 
    -0.19319803f, -0.03034220f, 0.12014378f, -0.16322720f, -0.27845597f, 0.12285127f, 0.10860572f, -0.11678985f, 
    0.02407319f, -0.38116503f, 0.10546764f, 0.04092787f, 0.19375309f, -0.41436589f, 0.10651004f, 0.05340065f, 
    0.30891162f, -0.10447948f, 0.04297480f, 0.07376444f, -0.08659511f, -0.26512957f, -0.24552596f, 0.21086343f, 
    0.16287202f, -0.31793523f, 0.55001384f, 0.28156158f, 0.40374348f, 0.09445628f, 0.05359704f, -0.18724827f, 
    0.01186442f, 0.03000589f, 0.01688715f, -0.07362247f, 0.07803379f, -0.02127400f, 0.09357537f, -0.10390519f, 
    0.01236900f, 0.08203563f, -0.10392825f, 0.02297188f, 0.02067137f, 0.04003572f, -0.09517577f, -0.10075972f, 
    -0.08753273f, -0.07426722f, -0.03310118f, 0.06009473f, 0.02844816f, -0.05356405f, -0.05440558f, 0.03714095f, 
    -0.04705611f, -0.03741557f, -0.14403509f, -0.11168978f, -0.04732458f, -0.11801235f, 0.06130320f, 0.04607166f, 
    -0.00298226f, -0.00995552f, -0.01925620f, 0.03990685f, -0.02180764f, -0.08834331f, 0.02892017f, -0.00375408f, 
    0.05275917f, 0.02078479f, -0.11531450f, -0.05199184f, 0.06538501f, -0.07376379f, -0.03712230f, -0.09219725f, 
    0.05503727f, 0.07009243f, -0.03843113f, -0.04889790f, -0.11176310f, -0.01565275f, -0.06385364f, -0.11552944f, 
    -0.07006889f, -0.00218925f, -0.03000326f, -0.05961413f, 0.01748580f, 0.02426124f, -0.06821095f, -0.08792229f, 
    0.02334348f, 0.02711141f, -0.05650447f, 0.00971344f, 0.06235237f, -0.03452528f, -0.09539018f, -0.00256847f, 
    -0.07643464f, 0.07966054f, 0.04474507f, -0.02566406f, 0.08393625f, 0.02074284f, -0.10245419f, -0.13258672f, 
    -0.08545493f, -0.05725648f, -0.03810627f, -0.09213974f, 0.01530388f, -0.04096112f, -0.05210256f, 0.03366713f, 
    -0.04751683f, -0.06338508f, 0.01944723f, 0.00313605f, 0.01749233f, 0.02660191f, 0.01348564f, -0.07580584f, 
    0.02851584f, 0.05869460f, -0.06987935f, -0.05446255f, -0.05265324f, -0.02160895f, 0.00457444f, -0.00103270f, 
    -0.07736987f, -0.08168532f, -0.03114793f, 0.00868571f, -0.04948698f, -0.04361657f, -0.10848135f, 0.04335751f, 
    0.00702933f, 0.04220791f, 0.02015070f, -0.05422032f, 0.03980977f, -0.08628912f, -0.10418790f, -0.07246193f, 
    -0.04652936f, -0.11608056f, -0.00344455f, -0.09011393f, -0.04132018f, 0.01869185f, -0.01943246f, -0.07831645f, 
    0.22959213f, -0.14837363f, 0.02800425f, 0.18025403f, -0.27209443f, -0.32851541f, -0.26575261f, 0.23006998f, 
    0.06359762f, 0.03121659f, -0.02986550f, -0.14065798f, 0.40228587f, 0.08615911f, -0.06588957f, -0.13726439f, 
    -0.11785144f, -0.07704384f, 0.14956328f, 0.06280524f, -0.01969562f, 0.03533154f, 0.04324320f, -0.41284540f, 
    0.15045656f, 0.10302384f, 0.12803473f, -0.17919749f, 0.11747556f, -0.00152162f, -0.07488223f, -0.02529780f, 
    0.08971111f, 0.09282576f, -0.02048557f, -0.14873940f, -0.22628234f, 0.23671076f, -0.00017302f, -0.07720175f, 
    0.04446477f, -0.03070452f, 0.34813598f, 0.18558584f, -0.15909792f, 0.02556376f, -0.34997228f, -0.10150122f, 
    -0.09016782f, -0.03401913f, -0.07779808f, -0.03948379f, 0.07752523f, 0.13198140f, -0.69045025f, 0.01699871f, 
    0.01853675f, 0.02571297f, -0.04167497f, 0.11973665f, 0.06776465f, 0.09221175f, -0.14581770f, -0.21990374f, 
    -0.05651213f, 0.30250704f, -0.03606858f, 0.23788153f, 0.04726540f, 0.39876807f, 0.01409577f, -0.28586024f, 
    -0.07525306f, 0.02221439f, 0.08269852f, -0.23287317f, 0.03166893f, -0.20809859f, -0.13220893f, -0.66262019f, 
    -0.11710420f, 0.06452916f, 0.19804896f, -0.11940501f, -0.10410783f, -0.07921077f, -0.35086536f, 0.04805892f, 
    0.03497732f, 0.05763521f, 0.10322323f, 0.15589036f, 0.23357520f, -0.40138993f, -0.07210167f, 0.18179916f, 
    0.15120076f, 0.06742501f, 0.22241959f, -0.26575699f, 0.04227672f, -0.02577219f, -0.13233902f, -0.09180502f, 
    0.08043721f, 0.14148627f, -0.00569536f, -0.06900698f, -0.26620159f, 0.04256812f, -0.43139884f, -0.02175035f, 
    -0.24863747f, -0.05604421f, -0.08829489f, 0.03763695f, 0.09250873f, 0.30097404f, 0.42928800f, -0.20090914f, 
    -0.25962427f, 0.15429430f, -0.11702164f, 0.12053608f, 0.10723910f, -0.00837573f, -0.59157443f, 0.01164377f, 
    -0.05637813f, 0.01537393f, 0.02081108f, 0.04917170f, -0.03945928f, 0.07647197f, -0.07767532f, 0.02340521f, 
    -0.01629686f, -0.05029668f, -0.06682485f, -0.04745666f, 0.05747138f, -0.01461254f, -0.03275326f, -0.09245209f, 
    0.07192376f, -0.03730427f, 0.07819962f, 0.07830590f, 0.04992539f, -0.02370174f, 0.00719544f, 0.01411551f, 
    0.03644855f, 0.02947852f, 0.00993962f, 0.05869303f, -0.03400302f, -0.02405737f, -0.04136431f, 0.00420090f, 
    -0.04109906f, 0.06914705f, -0.09424523f, 0.08154448f, 0.03756574f, 0.05768717f, 0.07702428f, 0.05820746f, 
    0.03717139f, -0.07411513f, 0.02645120f, -0.06635790f, 0.02228183f, -0.06030804f, -0.03804517f, 0.05768348f, 
    -0.07782623f, -0.01084778f, -0.03362770f, 0.05964369f, -0.05177723f, -0.04970822f, -0.00155266f, -0.00276722f, 
    -0.05095863f, -0.03747629f, -0.07353364f, -0.02518069f, 0.01895838f, 0.02569143f, -0.02837568f, -0.03101931f, 
    -0.03549353f, -0.03167751f, -0.04471780f, 0.01892556f, -0.07466268f, 0.01753590f, 0.00277152f, -0.06551132f, 
    0.05661024f, 0.05864828f, -0.07813530f, 0.07310550f, -0.04823473f, -0.08467062f, -0.02792178f, 0.01296586f, 
    -0.06999695f, 0.03669296f, -0.06389215f, -0.06033827f, -0.04137035f, -0.07265157f, 0.04186374f, -0.05013617f, 
    0.07138364f, 0.03347758f, -0.04800469f, -0.04114223f, -0.02768874f, -0.08496780f, -0.05554038f, -0.02539008f, 
    -0.02176865f, 0.00294174f, 0.04230803f, -0.03152476f, -0.04618531f, -0.00858644f, 0.06033870f, -0.08270808f, 
    0.01192153f, 0.03104699f, 0.01526508f, -0.09494738f, 0.02556278f, -0.07833856f, -0.08153752f, -0.08249606f, 
    -0.08012781f, 0.00313369f, -0.06490447f, -0.02895399f, 0.00235743f, -0.02723731f, 0.00564107f, -0.01034429f, 
    -0.04675690f, -0.03211179f, -0.06076884f, 0.01179280f, -0.00627822f, 0.05700484f, -0.06823170f, -0.09095273f, 
    0.18040693f, -0.08809811f, 0.13217348f, 0.06337548f, 0.15936534f, 0.15127920f, 0.24308836f, 0.01998438f, 
    -0.02652886f, 0.01356310f, 0.03278963f, -0.23209882f, -0.01156164f, -0.18447213f, -0.12172604f, -0.01583842f, 
    0.02376021f, -0.02817908f, 0.32781339f, -0.10537206f, 0.03243768f, 0.05156392f, -0.09626786f, 0.05432350f, 
    0.03581977f, 0.14202079f, 0.05404056f, -0.09392106f, 0.04550365f, 0.02626042f, 0.07559686f, 0.05899818f, 
    -0.09436873f, -0.08776670f, -0.19435157f, 0.50527531f, -0.03491654f, 0.01050493f, 0.06060588f, -0.00936062f, 
    -0.03459955f, -0.18285854f, 0.40136284f, -0.02978412f, -0.18300974f, -0.13147672f, 0.13034134f, 0.08427806f, 
    -0.16868033f, 0.01500379f, 0.06667521f, 0.16651323f, 0.10868551f, 0.02395092f, -0.28385502f, -0.23405504f, 
    0.02231999f, 0.19836740f, -0.03420242f, 0.09575412f, 0.01497375f, 0.00079378f, 0.31798083f, -0.25896347f, 
    0.08498012f, 0.20334429f, -0.03259574f, 0.10071806f, -0.05457063f, -0.07611230f, -0.12079199f, 0.01188663f, 
    0.00058453f, 0.05046460f, 0.02375268f, -0.06969747f, 0.69443655f, 0.06907737f, 0.08836728f, 0.14724812f, 
    -0.42020375f, 0.01398178f, 0.15179618f, -0.14817303f, -0.02911003f, -0.01247142f, 0.33303073f, 0.07014029f, 
    0.04984640f, 0.08046373f, 0.07273743f, 0.13805881f, -0.05521278f, 0.07787963f, 0.39705926f, 0.07821021f, 
    0.05202443f, -0.02179503f, -0.10220822f, 0.11427972f, 0.09615526f, 0.09414173f, 0.07734114f, 0.03005937f, 
    -0.03887259f, -0.00546071f, 0.01296647f, 0.00048279f, 0.03202353f, -0.18608586f, 0.26667553f, -0.08435187f, 
    0.28736734f, 0.06374910f, 0.08083379f, -0.04485123f, 0.00279100f, 0.01280751f, 0.17906916f, -0.08374519f, 
    0.12889032f, 0.11181305f, -0.17393732f, -0.00658892f, 0.41262871f, -0.04264976f, 0.15714675f, 0.02259184f, 
    -0.24655087f, 0.13408308f, 0.02401046f, 0.16581945f, 0.28027803f, 0.41924286f, 0.08737922f, 0.01577723f, 
    0.09945364f, 0.09710926f, -0.16471469f, 0.06332690f, -0.29708874f, 0.14757362f, 0.07315759f, 0.25354004f, 
    -0.10741911f, -0.04656845f, -0.13559797f, 0.08906318f, -0.08564477f, 0.04521998f, -0.18283425f, 0.26695037f, 
    -0.02058222f, -0.17152637f, 0.07735938f, 0.01408775f, 0.02401523f, 0.14664975f, -0.08561926f, -0.21036477f, 
    -0.29931623f, -0.69705248f, 0.11767929f, -0.72945768f, 0.27795973f, 0.18612505f, -0.03700696f, 0.19203644f, 
    0.07138068f, -0.10094690f, 0.01769976f, -0.18014163f, 0.22942767f, 0.12743713f, 0.03562612f, 0.24911918f, 
    -0.24215648f, 0.10049613f, 0.07541004f, -0.07998227f, -0.34556830f, 0.16683874f, 0.34410232f, 0.15647738f, 
    0.36342132f, -0.01660636f, 0.22238497f, -0.44626474f, 0.01026417f, 0.31726658f, -0.03182533f, 0.01471663f, 
    -0.66727191f, -0.17256945f, 0.03315741f, 0.14684004f, 0.01466273f, -0.04902352f, -0.52223575f, 0.00628422f, 
    0.02775762f, -0.07833652f, -0.06071928f, 0.40555894f, -0.51210243f, 0.10896171f, 0.02997187f, 0.28579935f, 
    -0.28225881f, 0.24798080f, -0.01492681f, 0.37938970f, -0.00458149f, -0.02536724f, -0.01621481f, -0.02168649f, 
    0.06325237f, 0.03414164f, -0.21638407f, 0.03251565f, -0.29983929f, -0.10814670f, 0.00394739f, -0.13120803f, 
    0.00810051f, 0.11311497f, 0.37669280f, 0.00530921f, -0.04285349f, -0.17664512f, -0.08449350f, 0.19305964f, 
    0.14497378f, 0.00257193f, 0.07920591f, 0.26157039f, 0.01368702f, 0.55519891f, 0.10949714f, 0.02938659f, 
    -0.10629603f, 0.04088380f, -0.04368087f, 0.06580754f, -0.16489699f, 0.11894358f, -0.12131903f, 0.04878756f, 
    0.11666863f, -0.17424844f, -0.47971293f, -0.13116761f, 0.03862664f, -0.43011799f, 0.10138242f, 0.08565426f, 
    -0.06071488f, -0.18420424f, 0.08988733f, 0.12387317f, -0.45493183f, -0.27890074f, 0.14867564f, 0.14986399f, 
    -0.31614238f, 0.02323633f, -0.20207632f, -0.80623978f, 0.15821168f, 0.10815904f, -0.47286627f, -0.30182642f, 
    -0.13392308f, -0.07442481f, -0.20949182f, 0.25119865f, 0.07215291f, 0.19233255f, -0.01756484f, 0.17670970f, 
    0.03758922f, -0.07810589f, -0.22556157f, -1.26254904f, 0.08391216f, -0.03281724f, 0.04344955f, 0.13694212f, 
    0.03284011f, 0.34530327f, 0.04757900f, 0.24700479f, -0.23470673f, -0.01248549f, -0.22496147f, 0.13887173f, 
    0.02539351f, -0.38143602f, 0.13136539f, -0.15503426f, 0.34124982f, 0.38113183f, 0.32614639f, -0.46019068f, 
    0.01440205f, -0.03434498f, 0.00243012f, 0.15859737f, 0.07866124f, -0.02702999f, 0.22349180f, -0.04345497f, 
    0.15179351f, 0.14587198f, 0.19001476f, 0.00233304f, 0.03420095f, 0.08652738f, -0.01034803f, -1.04103100f, 
    0.06328797f, 0.07595865f, 0.06440374f, 0.12882055f, 0.07220835f, -0.09758898f, 0.09488011f, 0.15772800f, 
    0.09285393f, -0.08415487f, -0.01968282f, -0.16937812f, 0.00705273f, 0.26209331f, 0.26245177f, -0.05892674f, 
    0.12523653f, 0.24805883f, 0.15190630f, -0.06754494f, 0.09607507f, -0.08639016f, 0.30656886f, -0.08760454f, 
    -0.24276353f, 0.04622173f, 0.15371166f, 0.13236327f, -0.20233139f, 0.25577152f, -0.23264495f, 0.06875599f, 
    -0.32163477f, 0.06370987f, -0.01798143f, 0.09768564f, -0.05629159f, 0.03316491f, -0.05601165f, -0.20972519f, 
    0.09205375f, 0.06273095f, 0.21426822f, -0.12723343f, 0.17834431f, -0.81272078f, -0.32722962f, -0.20253570f, 
    -0.38923851f, -0.05120818f, 0.05665140f, -0.05121502f, -0.08143125f, 0.00685727f, -0.22206289f, 0.24571599f, 
    0.34255373f, 0.11018529f, -0.02991424f, -0.13106900f, 0.02443898f, 0.08533808f, 0.07508500f, -0.17516761f, 
    0.27583122f, -0.05166879f, 0.00527691f, 0.03111808f, 0.06783650f, -0.66210926f, -0.22271128f, -0.02906900f, 
    0.05509418f, 0.04501596f, 0.24415793f, -0.56410050f, 0.13997802f, 0.01300198f, -0.54312259f, -0.10091989f, 
    -0.44456401f, -0.06145481f, -0.02292102f, 0.14790785f, -0.08492866f, 0.06218642f, -0.03869475f, -0.71421701f, 
    -0.29498911f, 0.09696364f, 0.06978024f, -0.61004007f, 0.18134837f, 0.10598981f, 0.07187366f, 0.02140446f, 
    0.19862992f, -0.63666141f, 0.05607467f, 0.23765557f, -0.57361579f, 0.01536282f, -0.12840815f, 0.09901715f, 
    -0.01270646f, -0.33827776f, -0.01062330f, 0.15687890f, -0.07546686f, 0.13435820f, -0.16635929f, -0.33592549f, 
    0.01181647f, -0.04708860f, -0.00820537f, 0.06948061f, 0.15003383f, 0.66820699f, -0.48015836f, 0.19981456f, 
    -0.23004641f, -0.12662227f, 0.28905818f, 0.04494592f, 0.08872847f, -0.01447249f, 0.03957792f, -0.48748690f, 
    -0.05094864f, 0.23320407f, 0.00917199f, 0.28371999f, 0.11942358f, 0.61766863f, 0.08485901f, -0.39643475f, 
    0.18469964f, 0.06901135f, 0.05394768f, -0.68845093f, -0.08060174f, 0.05838070f, -0.00710234f, 0.18669528f, 
    -0.05402446f, -0.34892899f, 0.05813846f, -0.28677168f, -0.36304450f, -0.04577739f, 0.04044041f, 0.06251909f, 
    -0.02668578f, -0.00083358f, 0.25184673f, 0.02466713f, 0.07503688f, -0.41894767f, -0.19358602f, 0.09506841f, 
    0.02269077f, 0.04552015f, -0.48356724f, -0.10050790f, 0.15431044f, 0.06758391f, -0.07893641f, -0.36668640f, 
    -0.15313527f, 0.12019041f, -0.05137533f, -0.85403329f, 0.11333936f, 0.17079651f, 0.04082993f, -0.07708397f, 
    -0.13842231f, -0.04083959f, 0.07007615f, -0.04899475f, 0.04402635f, 0.11981767f, 0.04747714f, -0.34381831f, 
    -0.21641657f, 0.00251044f, -0.06315688f, 0.32047257f, 0.18706691f, 0.18979463f, -0.42039222f, 0.14678480f, 
    -0.16927077f, -0.09594537f, -0.03754755f, 0.03109114f, -0.14352646f, 0.19814149f, 0.02228871f, 0.10740841f, 
    -0.07275105f, -0.00575144f, -0.07575888f, -0.04174860f, 0.02474319f, 0.26266399f, 0.01649408f, 0.31432244f, 
    -0.10571750f, 0.05456629f, 0.28499436f, 0.25983885f, -0.02870894f, 0.10291226f, -0.00487922f, 0.28035179f, 
    0.15152103f, -0.19535796f, 0.07604357f, -0.24204589f, 0.12929492f, 0.14547729f, -0.00217909f, 0.00079075f, 
    -0.08159194f, -0.38922647f, -0.06966206f, -0.18102603f, 0.06453666f, 0.02394112f, 0.01310759f, 0.14017190f, 
    0.02837390f, -0.02377185f, 0.07156420f, -0.22437401f, -0.08828982f, -0.03433048f, 0.13225357f, 0.08289669f, 
    -0.00188641f, 0.07807751f, 0.08041604f, 0.01344229f, 0.08269288f, -0.03792073f, 0.26247358f, 0.03192279f, 
    0.01578737f, 0.35468939f, 0.25059551f, -0.24660198f, 0.14218587f, -0.05795108f, 0.42850679f, 0.13456355f, 
    0.15368925f, -0.10364614f, -0.05584046f, -0.01255251f, 0.00491202f, -0.02116526f, -0.06654198f, 0.07962795f, 
    0.16537508f, 0.06394332f, -0.00600648f, -0.01123683f, 0.05615680f, 0.11793486f, 0.23370434f, 0.12225596f, 
    0.02486656f, 0.09712858f, 0.09950287f, 0.11548126f, -0.04393548f, 0.00306329f, 0.34461409f, -0.02812228f, 
    -0.19018510f, 0.07456733f, -0.28039804f, 0.07216666f, -0.28165853f, 0.04336145f, 0.07875492f, -0.01778505f, 
    -0.12344837f, 0.00567070f, 0.01803474f, 0.33208737f, -0.16595577f, 0.00740738f, 0.07984012f, -0.01883566f, 
    0.16895640f, 0.13510568f, 0.44669333f, 0.07283103f, 0.04075176f, -0.61630100f, 0.00993634f, 0.33972436f, 
    -0.01046930f, 0.07073528f, 0.04031291f, -0.01416989f, -0.13951060f, -0.01218519f, -0.28478643f, 0.18845963f, 
    0.12838444f, -0.14189127f, 0.35146436f, -0.21654631f, -0.03223000f, 0.00649129f, -0.04387363f, 0.00085101f, 
    -0.29461309f, 0.00535094f, 0.22570549f, -0.05871167f, 0.10932954f, -0.14125468f, 0.17402814f, 0.12882920f, 
    -0.03647892f, -0.03371105f, 0.03546165f, -0.13774970f, 0.15334164f, -0.20813459f, -0.40482867f, -0.09252207f, 
    0.13848051f, -0.01213728f, 0.01716888f, -0.13215399f, 0.01690059f, 0.00656595f, -0.08551407f, 0.25949657f, 
    -0.12762240f, 0.01192750f, -0.00208690f, 0.15915415f, -0.00006587f, 0.00006466f, -0.00900124f, 0.00011631f, 
    -0.21394092f, -0.61739719f, 0.03683754f, 0.36880645f, -0.00374517f, 0.06084513f, -0.16348456f, -0.13269427f, 
    -0.01676756f, -0.16570722f, -0.07301717f, -0.07906130f, 0.12469068f, 0.16563986f, 0.05854031f, -0.13964722f, 
    0.08617989f, 0.03713739f, 0.06076952f, 0.18925235f, 0.00961137f, 0.26528049f, 0.04496806f, -0.47772467f, 
    0.18622634f, -0.02120258f, -0.17360589f, 0.12029845f, 0.12350259f, -0.11899328f, 0.01431952f, -0.28912848f, 
    0.16006590f, -0.15721305f, 0.01455141f, 0.11218202f, -0.01880328f, -0.26512417f, -0.17572603f, 0.16735269f, 
    -0.23428349f, 0.00392406f, -0.03531034f, -0.03294803f, 0.44329777f, -0.03901945f, -0.07915343f, 0.07389466f, 
    -0.20999029f, 0.22952746f, -0.04937411f, -0.04923091f, 0.19002137f, 0.08678871f, 0.06787489f, 0.06182978f, 
    0.17540015f, 0.06801546f, -0.04900931f, 0.08066403f, -0.02158478f, 0.34733176f, 0.16918384f, 0.05107733f, 
    -0.05818876f, -0.06651478f, -0.05888320f, -0.05272577f, 0.11740253f, 0.09374463f, -0.11354692f, 0.05636444f, 
    0.00510398f, 0.14385635f, -0.10092422f, 0.03691290f, 0.21461713f, 0.13366529f, 0.10342693f, -0.00734783f, 
    0.27612212f, -0.05327859f, 0.03651245f, 0.05078829f, 0.04528265f, -0.03402815f, -0.02796687f, 0.07427053f, 
    0.12440071f, 0.17233247f, -0.26186848f, -0.11411119f, 0.02580998f, 0.01238815f, 0.08843160f, -0.11638638f, 
    -0.02405003f, 0.08694794f, 0.03626569f, -0.15351859f, -0.06408370f, -0.34223372f, 0.07457024f, -0.07095967f, 
    -0.18364990f, -0.04693065f, 0.24273139f, -0.46477509f, -0.33537757f, -0.03080300f, -0.33060607f, -0.51988643f, 
    0.28731734f, -0.05007877f, 0.21471773f, 0.00705469f, -0.01300153f, 0.01283814f, 0.15473810f, -0.12816781f, 
    -0.37571359f, 0.13437042f, -0.07715927f, 0.06295285f, -0.03371955f, 0.04070332f, -0.05747329f, 0.13835901f, 
    0.02427885f, -0.32235196f, -0.17500864f, 0.33353123f, -0.25382310f, -0.07042785f, -0.04228060f, -0.00056290f, 
    -0.04549743f, 0.05659292f, 0.43139645f, 0.03871537f, -0.15922073f, 0.13988061f, 0.18201779f, -0.09726715f, 
    0.06899748f, -0.01312365f, 0.06979706f, 0.02192379f, 0.24148336f, 0.39294195f, -0.12617970f, 0.02819112f, 
    -0.11730270f, -0.02729010f, 0.08274885f, 0.06838701f, 0.15436549f, 0.28825811f, -0.01274276f, -0.58435678f, 
    0.16641484f, 0.09761806f, -0.05213892f, -0.11451153f, 0.08958349f, 0.30026394f, -0.01107055f, 0.19190192f, 
    0.25445193f, -0.04926950f, -0.03515864f, -0.21006884f, 0.24587809f, 0.17607142f, -0.00702318f, 0.08651986f, 
    -0.04858408f, -0.26470193f, 0.11085534f, -0.35567930f, 0.16422136f, 0.04806892f, 0.24538301f, 0.02697565f, 
    -0.00502030f, 0.02298996f, 0.23082331f, 0.16545534f, 0.02958745f, 0.21426399f, 0.17451696f, 0.17005867f, 
    0.07764189f, -0.04831252f, -0.16813417f, -0.05111689f, 0.17726260f, 0.20537566f, 0.16164409f, -0.06707614f, 
    -0.11533773f, 0.10871873f, 0.22210932f, -0.18119651f, 0.02865921f, -0.12577091f, -0.11265070f, 0.04979728f, 
    0.27719823f, 0.00011407f, 0.00820931f, -0.02113305f, 0.08688027f, 0.06086253f, -0.15609993f, 0.06491649f, 
    -0.05518921f, 0.02342592f, -0.18476497f, 0.08193929f, 0.18060607f, 0.11166706f, -0.05164552f, 0.07655054f, 
    0.26340553f, -0.15521562f, 0.14358257f, 0.22775571f, -0.11942323f, -0.24670112f, 0.36667559f, 0.01853088f, 
    -0.08050897f, 0.00288470f, -0.01124471f, -0.22451544f, 0.24556164f, 0.18598227f, -0.30110666f, 0.01073821f, 
    -0.18346232f, 0.06564020f, 0.40504125f, -0.14893292f, -0.01930822f, 0.21090567f, -0.30035236f, 0.25071689f, 
    -0.07170712f, -0.29482043f, -0.05123331f, 0.07845713f, -0.02892330f, 0.12326270f, 0.07220675f, 0.06312194f, 
    -0.33231294f, -0.14628285f, 0.26879478f, -0.06483597f, -0.13557802f, -0.00421665f, -0.12322366f, -0.10104042f, 
    0.08708266f, -0.10117709f, 0.06628232f, -0.14545588f, -0.00849210f, 0.14030491f, 0.11601396f, -0.33390114f, 
    0.24987838f, 0.01772518f, -0.01041851f, 0.34786883f, -0.07722639f, 0.21212161f, 0.34280577f, 0.43883041f, 
    0.23374954f, 0.34590185f, 0.18289430f, -0.53456539f, 0.22535031f, -0.03528218f, 0.27666518f, -0.33424616f, 
    -0.82728177f, -0.38680565f, -0.05503078f, 0.06070955f, 0.05992647f, 0.03884875f, -0.34633571f, 0.30555040f, 
    0.15265128f, -0.02707450f, 0.05026591f, -0.00333524f, -0.29180786f, 0.26204774f, 0.04061107f, 0.16429548f, 
    -0.09345783f, 0.01497518f, 0.19555697f, 0.13981393f, -0.07335468f, -0.03826991f, 0.44011074f, -0.00830595f, 
    0.17814018f, -0.04987382f, 0.50126690f, 0.17172238f, -0.26500732f, 0.37241322f, 0.21668091f, 0.05025735f, 
    -0.09784575f, -0.00801785f, 0.21022654f, -0.10035587f, -0.16966520f, 0.19896454f, -0.01833130f, 0.01205944f, 
    0.12232824f, -0.28763491f, 0.32536462f, 0.07500030f, 0.33993673f, -0.50030583f, -0.10735604f, -0.07554348f, 
    0.21039411f, 0.04275106f, -0.04352641f, 0.04232820f, -0.22724456f, -0.41199857f, -0.35538870f, 0.16906928f, 
    0.25062466f, -0.22159740f, -0.00202672f, 0.60497189f, 0.53827763f, -0.15905140f, 0.14662983f, -0.11769695f, 
    -0.09756188f, 0.28160146f, -0.00469570f, 0.08828194f, 0.46043336f, 0.23528102f, 0.04438431f, 0.28210568f, 
    0.34145749f, 0.02222296f, -0.02764702f, 0.03740435f, 0.14477637f, -0.07495645f, 0.17816930f, 0.15776777f, 
    -0.15757509f, 0.01496744f, -0.38516113f, 0.41921124f, -0.01458839f, 0.03565325f, -0.10564300f, 0.29087228f, 
    0.35827917f, 0.04937980f, 0.27317026f, -0.22211088f, -0.02706141f, 0.23887457f, -0.04262320f, -0.17599238f, 
    -0.19327775f, -0.33809531f, 0.33755541f, -0.40096337f, 0.18465321f, 0.19417304f, 0.10328499f, 0.13888276f, 
    -0.01657761f, 0.32797951f, -0.29272911f, -0.08079259f, 0.48683903f, 0.17169440f, -0.05895200f, -0.07114308f, 
    -0.13494807f, -0.03608393f, -0.07402861f, -0.00407689f, -0.19442214f, -0.11139617f, 0.37046763f, -0.11012994f, 
    0.19666837f, -0.17042473f, -0.01970197f, -0.02760123f, -0.02809545f, 0.11741411f, 0.35395926f, -0.15443408f, 
    -0.27752721f, -0.09585594f, -0.08122250f, 0.17657422f, 0.08158864f, -0.19091830f, -0.26046681f, -0.14966726f, 
    -0.08342645f, 0.03073274f, 0.03970975f, 0.18441333f, 0.28088221f, 0.02231868f, 0.16734128f, 0.12751089f, 
    -0.44610977f, 0.39716578f, 0.13709980f, 0.11448631f, 0.10369220f, -0.04801029f, -0.00570684f, 0.04357285f, 
    0.05141614f, 0.00531650f, -0.16125704f, 0.07200575f, -0.17946908f, -0.10559875f, -0.30861109f, -0.07307286f, 
    0.12393428f, -0.08277903f, 0.10475087f, 0.18304174f, 0.02395219f, -0.08546786f, -0.01798820f, 0.17456852f, 
    0.11608496f, 0.23407128f, 0.03378426f, 0.28023130f, 0.13054653f, 0.63522023f, 0.05314378f, 0.26489404f, 
    -0.17523293f, 0.00719666f, 0.03181342f, -0.00447268f, 0.01517751f, 0.08514281f, 0.05259918f, 0.17450613f, 
    0.13347156f, 0.10403018f, -0.24040127f, -0.04833025f, -0.18020052f, -0.23923618f, 0.17626388f, 0.16029043f, 
    0.23650588f, 0.01466384f, -0.07084610f, 0.22105576f, -0.17604834f, -0.03979733f, -0.11875971f, 0.08581256f, 
    0.05714846f, 0.04900275f, -0.03925193f, 0.08118339f, 0.11550131f, 0.38274118f, 0.21128137f, 0.07812527f, 
    0.07144879f, 0.07789103f, 0.11334116f, 0.10512965f, 0.03541010f, 0.16906956f, -0.00313517f, -0.14635107f, 
    -0.10603535f, -0.03462694f, 0.15714639f, -0.03369576f, 0.22647007f, 0.11160065f, -0.07379042f, 0.08751025f, 
    0.12887371f, 0.46038714f, -0.27678743f, -0.13584730f, -0.05256891f, -0.01688707f, 0.15197180f, 0.02913462f, 
    0.05124740f, 0.06276745f, 0.14067815f, 0.15715815f, -0.35688210f, -0.12409852f, -0.02808245f, 0.18513924f, 
    0.00606456f, -0.08707009f, 0.07331565f, -0.09230320f, 0.08589301f, 0.13790254f, -0.17934869f, 0.00496754f, 
    -0.05845690f, 0.09589577f, 0.36235324f, 0.04384833f, 0.05354702f, 0.08943692f, 0.19467117f, 0.08929290f, 
    -0.10878697f, -0.01940374f, 0.03895400f, 0.09270006f, 0.01638000f, 0.17776372f, -0.19675466f, -0.10179843f, 
    -0.06765185f, -0.01644017f, 0.04557510f, -0.09149397f, -0.15415138f, 0.21355525f, 0.16187656f, -0.13657638f, 
    -0.18319188f, -0.05377677f, 0.18585381f, 0.07227316f, 0.03160325f, -0.06461196f, -0.17525563f, -0.00594235f, 
    -0.23507881f, 0.07702260f, 0.12116360f, 0.13360360f, 0.00638448f, -0.18404582f, -0.02044775f, -0.07533548f, 
    0.01856008f, 0.04278503f, 0.17700042f, -0.10840183f, -0.14880928f, 0.05942124f, 0.11658075f, 0.06537444f, 
    0.13436428f, -0.03752968f, 0.22011577f, 0.09888460f, -0.10688437f, -0.40243307f, -0.09531311f, 0.12404605f, 
    -0.12660466f, 0.10283981f, 0.00687187f, 0.01061902f, 0.05995772f, -0.04773045f, 0.10951985f, -0.03931267f, 
    0.15225199f, -0.15007502f, -0.17376995f, -0.00872296f, -0.16024286f, 0.12040327f, -0.14907707f, 0.04750848f, 
    -0.08317634f, -0.01705770f, 0.00898573f, -0.08373599f, 0.07907634f, -0.04875493f, 0.00022172f, -0.04466770f, 
    -0.05244247f, -0.07963452f, -0.01285406f, 0.01428335f, 0.05056009f, 0.07655881f, 0.04947022f, -0.05985349f, 
    0.01732766f, 0.05686353f, -0.04723134f, 0.00750563f, 0.02483914f, -0.01434838f, -0.01001791f, 0.03044681f, 
    -0.03350030f, -0.08984570f, -0.07085691f, 0.07596540f, -0.02314216f, -0.00051993f, -0.05404834f, -0.07823889f, 
    0.08498100f, 0.02863412f, 0.03563304f, 0.06945544f, 0.02828425f, 0.01146304f, -0.07755641f, -0.07755051f, 
    -0.02969998f, 0.07538027f, 0.02022302f, 0.01584742f, 0.01833715f, 0.04482749f, -0.03226750f, -0.02511862f, 
    0.02678376f, -0.06998891f, 0.08390175f, 0.04198524f, -0.05686226f, -0.01178008f, -0.02986666f, -0.00028096f, 
    -0.00848528f, -0.08145895f, 0.06721877f, 0.04156318f, 0.05187858f, 0.04876978f, 0.02261476f, 0.07421546f, 
    -0.05448809f, -0.06059047f, 0.02972662f, -0.05095645f, -0.07139863f, 0.01636599f, 0.05620333f, -0.08263365f, 
    -0.08573838f, 0.00396193f, 0.06721476f, -0.00751041f, 0.06277104f, -0.04525037f, -0.06905638f, 0.04328129f, 
    -0.07086647f, -0.04366369f, -0.06880164f, 0.04197516f, -0.09506236f, 0.05601242f, 0.01782578f, -0.06907658f, 
    0.07435785f, 0.00032091f, 0.08575817f, 0.00993505f, -0.03253374f, -0.09479222f, 0.01983204f, 0.05928589f, 
    -0.09545426f, -0.00207307f, 0.03764888f, 0.02521247f, -0.05837706f, 0.02054413f, -0.00090077f, -0.01276227f, 
    0.00080489f, 0.00258257f, 0.00296966f, -0.04050628f, -0.06540158f, 0.04051031f, 0.01817050f, -0.06504631f, 
    0.06876198f, -0.04171381f, 0.05231585f, -0.06899543f, -0.05031054f, -0.08488388f, -0.05298929f, -0.02291013f, 
    0.08360224f, 0.05704067f, 0.01512084f, -0.04209169f, -0.07961830f, 0.01488488f, -0.00560930f, 0.00023740f, 
    -0.05762444f, -0.06042259f, -0.06063817f, -0.09232730f, 0.05777632f, -0.02458764f, 0.06936814f, 0.06139306f, 
    -0.01691110f, -0.02624104f, -0.01050371f, 0.02131930f, -0.00881253f, -0.06436024f, -0.00329251f, -0.00323050f, 
    0.01378912f, 0.03217118f, -0.08833279f, -0.01000697f, 0.03340443f, -0.01098795f, -0.05444971f, -0.05823691f, 
    -0.04098807f, -0.05309193f, -0.06556825f, 0.06429239f, -0.02500549f, -0.08950607f, 0.00159886f, -0.06239267f, 
    0.03512618f, 0.03480547f, -0.03180610f, -0.09348990f, -0.06118241f, -0.03702001f, -0.00102363f, 0.05416542f, 
    -0.05530879f, 0.01093375f, 0.01771689f, 0.03180128f, 0.04049755f, 0.01933200f, -0.00778841f, -0.07095793f, 
    0.00922160f, -0.04122969f, -0.04380346f, -0.00117376f, 0.06206147f, -0.06275061f, 0.00345281f, -0.01196560f, 
    -0.00233233f, 0.02030471f, 0.07215101f, -0.07290936f, -0.04965870f, 0.00616501f, -0.03051558f, 0.05376829f, 
    0.06186098f, 0.02576917f, 0.02476160f, 0.04157848f, 0.04590404f, -0.07512575f, -0.04360788f, -0.05187549f, 
    0.00741497f, -0.04500612f, 0.02672043f, -0.00323527f, 0.05742895f, -0.05452509f, -0.05573101f, -0.01914482f, 
    -0.04826893f, -0.09928475f, -0.07318123f, 0.02715744f, -0.08716697f, 0.08585791f, -0.03402324f, 0.06667338f, 
    -0.01449383f, -0.08353562f, -0.06559157f, 0.01822889f, -0.03767408f, -0.03539684f, 0.00930290f, 0.06336899f, 
    -0.09673283f, -0.01364324f, 0.00254292f, -0.01029022f, -0.04280128f, -0.04708244f, -0.06260867f, 0.05095522f, 
    -0.08170894f, -0.08759753f, -0.04090340f, -0.10361985f, 0.07468471f, 0.02035041f, 0.04549489f, -0.04296116f, 
    0.04852317f, -0.02030185f, -0.00073462f, -0.03224752f, 0.05469268f, 0.01423500f, -0.03191184f, 0.01159876f, 
    0.05481172f, -0.05922699f, -0.06076898f, -0.06592492f, -0.05529122f, 0.02567017f, -0.07224149f, 0.05784732f, 
    0.08789995f, -0.08608191f, -0.09951799f, 0.22787714f, -0.35781679f, -0.18454821f, 0.13536303f, 0.09024893f, 
    -0.05638751f, -0.06374202f, -0.24858963f, -0.46312815f, 0.20275940f, 0.31952178f, 0.27224195f, -0.39809588f, 
    -0.59606510f, 0.01221901f, 0.44945648f, 0.30107433f, 0.07841352f, 0.14712514f, -0.04711685f, -0.06673208f, 
    0.02717568f, -0.03430275f, 0.09006017f, -0.64069313f, 0.22037983f, 0.14070627f, 0.04507897f, 0.02401544f, 
    0.05688345f, -1.26903331f, -0.08486009f, -0.04757035f, 0.09979946f, 0.26822653f, 0.18607111f, 0.23232332f, 
    0.02300267f, -0.69386303f, 0.57666355f, -0.15124600f, 0.13451426f, 0.17463981f, 0.01044402f, -0.58313668f, 
    -0.01259125f, 0.07010754f, 0.02948503f, -0.03191730f, 0.12651704f, -0.08148354f, 0.27473012f, 0.41565138f, 
    -0.11556353f, 0.25787279f, 0.25903878f, -0.06159117f, 0.12622260f, 0.16036622f, -0.62050372f, 0.11503219f, 
    -0.02524428f, 0.15316807f, 0.07295435f, 0.09180976f, 0.02036694f, 0.07643119f, -0.08893330f, 0.04585999f, 
    0.48062468f, -0.06053711f, -0.03976749f, -0.04776542f, -0.35148054f, 0.14514880f, 0.25981048f, 0.23898213f, 
    0.05463177f, 0.00345139f, -0.06940016f, 0.18770362f, -0.39154169f, -0.07962856f, 0.23883724f, 0.07761728f, 
    -0.37610203f, 0.04519235f, -0.24228504f, -0.00583898f, -0.12795927f, -0.16246441f, 0.21526533f, 0.17513122f, 
    -0.01448656f, 0.05448094f, 0.06935421f, -0.02774417f, 0.02232132f, -0.01073098f, 0.06413651f, -0.16360196f, 
    0.08526523f, -0.02311561f, 0.02085675f, 0.07364385f, -0.10054532f, -0.23001431f, -0.69771749f, 0.05403674f, 
    -0.18167569f, 0.07551038f, 0.03998196f, -0.04139791f, 0.08144212f, 0.16048963f, 0.14369398f, -0.01238142f, 
    0.12944047f, 0.05860907f, -0.05582321f, -0.01126486f, 0.28720465f, 0.12265376f, -0.12824184f, -0.03536820f, 
    -0.06885508f, -0.11038407f, -0.18419467f, 0.06009740f, 0.11483359f, 0.36402124f, 0.26357335f, -0.09380720f, 
    0.02066125f, -0.10799242f, -0.03505759f, 0.07417345f, 0.94680363f, -0.00128913f, -0.15182610f, 0.19935293f, 
    0.30527684f, -0.07657302f, 0.66609371f, -0.46142468f, -0.01256133f, 0.20030813f, -0.13290437f, 0.22897294f, 
    0.03792914f, -0.19654422f, 0.02300946f, -0.03731357f, 0.10295223f, -0.06764307f, -0.01681342f, 0.13232701f, 
    -0.42627734f, 0.46462846f, 0.18766093f, -0.20087275f, 0.10360604f, -0.08326802f, -0.06741770f, -0.08312586f, 
    0.08691147f, 0.10154834f, 0.39203373f, -0.09072499f, -0.16052334f, -0.06562863f, 0.07074620f, 0.33172730f, 
    0.19829985f, 0.09633461f, -0.03838827f, 0.09806114f, -0.25237280f, 0.20370963f, 0.02792965f, 0.22316970f, 
    0.14520304f, 0.59265983f, 0.17156494f, -0.31170112f, 0.18527144f, 0.16230036f, 0.89884025f, 0.14229149f, 
    -0.74595237f, -0.36703870f, 0.01801206f, -0.04517410f, -0.04224605f, 0.06234774f, -0.03062174f, 0.36552256f, 
    0.13370310f, -0.03930087f, -0.02731442f, 0.23393799f, 1.08434963f, 0.09309259f, -0.06421625f, 0.38248318f, 
    0.04163762f, 0.19729196f, 0.04943338f, 0.31373847f, 0.18388750f, 0.02903097f, 0.22507620f, -0.00070264f, 
    -0.15643871f, -0.02066463f, 0.11922804f, -0.05458381f, 0.03099117f, 0.44465303f, 0.37433034f, -0.02522575f, 
    -0.07839257f, -0.02107574f, 0.11381720f, -0.03244239f, -0.33379450f, -0.05848980f, 0.15921512f, 0.07641018f, 
    0.05881612f, -0.45737523f, 0.38155630f, 0.05888375f, 0.19764222f, 0.57225287f, 0.30020648f, 0.01658102f, 
    0.56355494f, -0.04999949f, -0.00690810f, -0.00039479f, -0.21893887f, -0.27975461f, -0.05186066f, 0.21221350f, 
    -0.03656845f, -0.18169950f, 0.51056886f, 0.40797088f, 0.57994241f, -0.21472059f, 0.12323320f, -0.15750596f, 
    0.04451386f, -0.15355988f, 0.09585395f, -0.00020422f, -0.05861743f, 0.15887854f, 0.27493086f, 0.02563745f, 
    -0.03932680f, -0.09594289f, 0.06743070f, 0.03176288f, 0.32069686f, 0.06063439f, -0.22244832f, 0.34459469f, 
    -0.02567078f, -0.02536276f, 0.58329612f, -0.44708359f, -0.06824768f, 0.22014433f, -0.29722881f, 0.04811822f, 
    0.11667305f, -0.35666001f, -0.10562554f, -0.15306078f, -0.05341656f, -0.05443916f, -0.01342020f, 0.11356475f, 
    -0.31869584f, -0.29296660f, 0.19001326f, 0.14135960f, 0.07240324f, -0.05416388f, -0.04326381f, -0.16851322f, 
    0.09118471f, 0.08024793f, 0.04162819f, -0.17447974f, -0.12645191f, -0.02772399f, -0.07786442f, 0.09427133f, 
    0.01202147f, -0.08057208f, 0.03833373f, 0.24062741f, -0.09881409f, 0.04459966f, 0.07435858f, 0.40548122f, 
    0.10825700f, 0.46467736f, 0.05436035f, -0.57044804f, 0.14954846f, 0.02276166f, 0.56279463f, -0.04350615f, 
    -0.26467630f, -0.28510454f, 0.02070648f, 0.03654303f, -0.04860521f, 0.18657438f, 0.14890496f, 0.07595135f, 
    0.35946640f, 0.07771093f, 0.04706677f, 0.06379004f, 0.63241410f, 0.17575115f, 0.12917066f, 0.31284466f, 
    -0.09782724f, 0.14380339f, 0.31370708f, 0.29419839f, 0.03656030f, 0.04171261f, 0.41381285f, 0.05242880f, 
    0.15319505f, 0.08684071f, 0.36240619f, 0.06552481f, -0.26937759f, 0.28178900f, 0.14498563f, -0.40977320f, 
    -0.04011706f, -0.00386625f, 0.18503796f, 0.04537113f, -0.32090604f, 0.01676992f, 0.04487719f, -0.07220175f, 
    0.01241349f, -0.35447964f, 0.33023083f, -0.07938211f, 0.18992729f, -0.13835837f, 0.09473379f, -0.07025604f, 
    0.18031934f, 0.10505610f, -0.02327072f, 0.01093476f, -0.35247087f, -0.65478379f, -0.08263198f, 0.14388613f, 
    0.11346340f, -0.46585628f, -0.03509389f, 0.57575339f, 0.68190920f, -0.18609811f, 0.08765674f, -0.18196596f, 
    0.23145454f, -0.14867741f, 0.13798036f, -0.00964585f, -0.15854599f, 0.03496994f, -0.17886576f, -0.02275016f, 
    0.14013535f, 0.01242341f, 0.08135900f, 0.05110263f, -0.12898627f, 0.41166383f, 0.09680182f, 0.18265262f, 
    -0.05300405f, 0.01187847f, 0.01452150f, -0.08578466f, -0.07455066f, 0.05813249f, -0.25277755f, -0.04467416f, 
    -0.05714546f, -0.18963622f, 0.09453113f, 0.18246342f, 0.15010965f, 0.07986796f, 0.04979791f, 0.14581682f, 
    0.22267145f, 0.44341868f, 0.14781158f, -0.48335344f, 0.03160615f, 0.00270052f, 0.12531416f, 0.01120026f, 
    0.02369017f, 0.11249139f, -0.08133424f, 0.43611929f, -0.07000209f, 0.02839520f, -0.09716398f, 0.12992276f, 
    0.35796499f, 0.05915169f, -0.02214989f, 0.13262136f, -0.26400244f, 0.20600432f, -0.01749060f, 0.41831875f, 
    0.08535308f, 0.06039390f, 0.05571377f, -0.18669268f, 0.06231535f, -0.02117644f, -0.08425228f, 0.28440079f, 
    -0.80618012f, -0.02876400f, 0.05731865f, 0.13914509f, 0.12349115f, 0.19657651f, -0.06448706f, -0.09509736f, 
    0.19989610f, 0.07055920f, -0.00660980f, 0.10887774f, -0.47644582f, 0.10151388f, 0.09365873f, 0.13052902f, 
    -0.46620876f, -0.07014994f, 0.17826641f, 0.13279170f, -0.09503473f, -0.00856384f, -0.03283525f, -0.04633563f, 
    0.27393132f, -0.04769731f, 0.36485082f, -0.02749522f, -0.02130098f, -0.12660161f, -0.13870093f, 0.02741163f, 
    0.09501360f, 0.00524497f, 0.18681006f, -0.22962099f, -0.12166358f, -0.04232955f, 0.10241259f, 0.01191307f, 
    0.00556207f, -0.25259733f, 0.19701082f, 0.04723278f, 0.21295364f, 0.04724211f, -0.19104885f, -0.09729172f, 
    0.05100938f, 0.00260880f, 0.06204060f, -0.06079215f, 0.19241680f, -0.11296730f, 0.11221343f, 0.04533344f, 
    0.08103324f, -0.24452226f, -0.27473226f, 0.38671148f, 0.22401175f, -0.04377244f, -0.04005864f, -0.07767919f, 
    -0.11609870f, 0.04866248f, 0.06040274f, -0.18263175f, 0.07586492f, -0.53746390f, 0.10867003f, -0.03833773f, 
    -0.15446351f, -0.00693018f, 0.09421066f, -0.54821706f, 0.01324756f, 0.08523764f, -0.27197883f, -0.52671331f, 
    0.24691606f, -0.06997657f, 0.02117905f, -0.06153855f, -0.07206005f, -0.01265830f, -0.13231309f, 0.27864158f, 
    -0.45957819f, -0.01525693f, 0.07255722f, -0.12280726f, 0.21848421f, 0.04429565f, -0.05644367f, 0.19724983f, 
    -0.12968789f, -0.64372790f, -0.13191468f, 0.05530036f, 0.02437830f, 0.14159936f, -0.26074672f, -0.04029791f, 
    -0.05717312f, -0.80600286f, -0.11159170f, -0.15968645f, 0.25857851f, 0.32652500f, 0.42054671f, -0.73339713f, 
    0.25424784f, 0.02470071f, 0.04615040f, 0.13259955f, 0.02047250f, 0.33989352f, 0.22551683f, -0.23018923f, 
    0.03795499f, 0.06426557f, 0.01655330f, 0.03116876f, 0.28348479f, -0.11752335f, 0.02688274f, -0.84733158f, 
    -0.28575477f, -0.21688005f, -0.01142456f, 0.22178079f, 0.07334299f, -0.37952676f, -0.00827418f, 0.34833449f, 
    -0.11145939f, 0.01686774f, 0.05616428f, -0.01322870f, 0.02840873f, 0.14411837f, 0.12114526f, -0.05617305f, 
    -0.07482506f, 0.09386864f, 0.07377121f, -0.09424600f, 0.11002278f, 0.02075279f, 0.03849849f, -0.01494264f, 
    0.20208070f, 0.00094431f, 0.02861606f, 0.11681639f, -0.02718873f, 0.26667228f, 0.16333835f, 0.15825847f, 
    -0.27679834f, -0.01875228f, -0.03510810f, -0.23803900f, 0.07975892f, 0.17385721f, -0.12850310f, 0.06127707f, 
    0.03835359f, 0.01041057f, -0.10741523f, 0.09746635f, 0.09082751f, -0.10539740f, 0.03107795f, -0.05411936f, 
    0.31808022f, 0.01749226f, 0.08046964f, -0.05490759f, -0.04845363f, 0.19768539f, -0.17143658f, 0.29602447f, 
    0.21562575f, -0.03576358f, 0.04084991f, -0.01754015f, -0.13617930f, 0.08987818f, 0.20977932f, -0.26040092f, 
    0.04228426f, -0.09092087f, 0.05407079f, -0.06521677f, 0.03555659f, 0.03953613f, 0.08674096f, -0.02400305f, 
    0.03986039f, -0.05138726f, 0.03745886f, -0.04053645f, 0.07700934f, -0.09857292f, 0.07142191f, -0.02435772f, 
    -0.04869271f, -0.03830213f, -0.06348056f, -0.09747253f, -0.02176945f, -0.07098890f, 0.04540365f, -0.02045398f, 
    -0.00396942f, -0.03066038f, -0.06777716f, 0.01849236f, 0.04695762f, -0.07807413f, 0.04770301f, -0.04747865f, 
    -0.02659567f, 0.01465978f, 0.05545297f, 0.00376171f, 0.01796920f, 0.04152048f, -0.02445233f, -0.03425046f, 
    -0.07966865f, -0.03785961f, -0.05850238f, 0.04499995f, 0.06314184f, -0.05974595f, -0.04547020f, -0.04303981f, 
    -0.02829280f, 0.07546736f, -0.05602657f, 0.06548687f, 0.03410694f, -0.08268367f, -0.08665330f, -0.00181621f, 
    -0.04780030f, -0.08364919f, 0.06770059f, -0.09948418f, -0.08528832f, 0.04072662f, -0.07365435f, 0.00700507f, 
    0.06134015f, -0.08332220f, 0.00990043f, 0.02856835f, -0.05830446f, -0.04550089f, 0.03489671f, 0.00657587f, 
    0.07149459f, 0.00795828f, 0.06681505f, 0.08791757f, 0.03438228f, -0.05970568f, -0.04725061f, -0.01071611f, 
    -0.00679483f, -0.03019361f, -0.04893809f, -0.05829925f, -0.01577223f, -0.01629892f, 0.07268585f, -0.01788672f, 
    0.04562627f, -0.07593200f, -0.04815086f, 0.05558622f, 0.06194367f, -0.03537329f, -0.04695317f, -0.08113992f, 
    -0.01755791f, -0.03674127f, 0.01172124f, -0.08936571f, -0.00915042f, 0.00466820f, -0.08530591f, -0.06342799f, 
    -0.04098275f, -0.03243132f, 0.02812178f, -0.08236229f, -0.04196976f, 0.00969752f, -0.02563025f, -0.09577790f, 
    0.07980905f, 0.07306809f, -0.06028210f, -0.06501819f, -0.03878821f, 0.00920382f, -0.09317910f, -0.00080091f, 
    -0.09536192f, 0.06371168f, -0.04799317f, -0.03285079f, 0.04544978f, 0.05457176f, 0.03118244f, -0.07524257f, 
    0.00794488f, -0.04418359f, 0.06106988f, 0.03719811f, -0.06465305f, -0.05915058f, 0.08731094f, 0.00185757f, 
    -0.06641654f, -0.03140284f, 0.03372033f, 0.03140060f, -0.01663308f, 0.08259428f, -0.03397582f, -0.04466534f, 
    -0.08089530f, -0.03129748f, -0.05639215f, -0.07225764f, 0.02377360f, 0.03494780f, 0.04074332f, -0.01459624f, 
    -0.05582816f, 0.05251259f, 0.05901958f, -0.04064966f, 0.00236685f, -0.06967384f, -0.00592136f, -0.03489483f, 
    0.01421728f, 0.02787229f, -0.06291469f, 0.00885523f, 0.08839116f, 0.07912095f, -0.02604537f, -0.04107463f, 
    0.07937539f, -0.07825548f, 0.08439622f, 0.00277217f, 0.02525448f, -0.05336663f, -0.08477370f, 0.06842257f, 
    -0.04382727f, 0.06676995f, 0.05314826f, -0.07934055f, -0.05294880f, 0.03066150f, 0.05453444f, -0.01257722f, 
    0.04364704f, -0.02193728f, -0.00704688f, -0.07197772f, 0.04226794f, -0.00929983f, 0.08188316f, 0.01109123f, 
    0.02413395f, 0.00490354f, -0.04607857f, 0.02351387f, 0.08476667f, -0.01465765f, -0.05582111f, 0.08569710f, 
    -0.02288716f, -0.02770532f, -0.07700197f, 0.08793647f, -0.01941116f, -0.07240603f, -0.07411282f, -0.03562580f, 
    -0.03789989f, -0.00805218f, -0.08791534f, 0.06806018f, 0.04173411f, 0.06680650f, -0.02388527f, 0.06138761f, 
    0.02537549f, -0.02727903f, -0.03092730f, -0.08606131f, 0.05206442f, -0.03326562f, 0.04469325f, 0.07593220f, 
    -0.07502227f, -0.01603859f, 0.08595608f, -0.07657134f, -0.08518893f, -0.02552454f, -0.01342319f, -0.00580236f, 
    0.02132954f, 0.00254011f, 0.02269867f, -0.06259590f, -0.07708368f, -0.00740289f, -0.00106398f, -0.08531891f, 
    -0.02295534f, -0.02695176f, -0.06197995f, 0.08020242f, -0.05609011f, 0.08564141f, 0.07161009f, -0.06521574f, 
    -0.01155568f, 0.01857213f, -0.03498946f, 0.07241182f, 0.07263219f, 0.06279911f, -0.00702450f, -0.04846596f, 
    -0.38006130f, 0.30006811f, -0.00040440f, 0.05141227f, 0.32745269f, -0.00012386f, 0.27856824f, -0.04441269f, 
    0.00046867f, -0.05583178f, -0.06397120f, 0.00678556f, -0.09307919f, -0.14456882f, -0.01976747f, -0.29125500f, 
    0.14386384f, 0.02957146f, -0.04494465f, 0.28570023f, 0.05339685f, 0.05150643f, 0.07162015f, 0.09959065f, 
    0.03566098f, -0.00464564f, 0.07119443f, 0.03674928f, -0.10367933f, 0.11008874f, -0.02361289f, -0.11430027f, 
    -0.55684060f, 0.34559771f, 0.00546039f, -0.62261236f, -0.05795389f, 0.14609028f, -0.13656902f, 0.05908738f, 
    0.11533079f, 0.03610647f, 0.14741270f, -0.29637766f, 0.23959212f, 0.10264252f, 0.06037077f, 0.09562911f, 
    -0.05529075f, -0.00792067f, 0.08338485f, 0.04008410f, -0.00214176f, -0.00627173f, 0.07035568f, -0.26299784f, 
    0.37660483f, 0.09223904f, 0.14271225f, -0.33401811f, -0.07952259f, 0.29271805f, -0.17144132f, -0.14288239f, 
    0.08895022f, 0.16106798f, -0.01963158f, -0.20259415f, -0.21430260f, -0.10027467f, -0.61404914f, 0.19997546f, 
    -0.13532770f, -0.01194180f, -0.07029580f, 0.20874301f, 0.03806496f, -0.13177055f, -0.03496563f, -0.27532265f, 
    -0.48157209f, 0.14838059f, -0.07126969f, -0.03695840f, 0.34394911f, -0.08551935f, 0.27441326f, -0.06086721f, 
    -0.11531999f, 0.01326207f, -0.33136168f, 0.07958170f, -0.01430783f, 0.33015916f, 0.28090686f, 0.07324122f, 
    0.07250415f, 0.07228806f, 0.06726773f, 0.24265644f, 0.04055681f, -0.07461604f, 0.02039643f, 0.19672182f, 
    0.13628638f, 0.18631652f, 0.19875149f, 0.26145643f, 0.13185406f, -0.37304023f, 0.07408301f, 0.17429660f, 
    -0.13323340f, -0.03071310f, -0.03432878f, 0.00655258f, -0.34465379f, 0.21770790f, -0.26365295f, -0.02188317f, 
    -0.07721908f, 0.23419300f, -0.78052562f, -0.32895976f, -0.05231993f, -0.27846056f, 0.27935714f, 0.22701091f, 
    0.57326573f, -0.32022494f, 0.06103752f, 0.24010292f, -0.33198473f, 0.04745860f, -0.50389445f, 0.14178288f, 
    0.20036250f, 0.00377818f, 0.07517213f, 0.24078147f, 0.08271296f, 0.32094565f, 0.43012464f, 0.11940963f, 
    -0.01149619f, 0.05428486f, 0.31156707f, 0.00879004f, 0.06323607f, 0.07051483f, -0.28697786f, -0.15462799f, 
    0.18373761f, -0.16115770f, 0.08365205f, 0.08956158f, 0.03222650f, 0.09319798f, -0.00778206f, -0.00301181f, 
    0.18848529f, 0.69284534f, 0.16283582f, -0.25743878f, -0.10092770f, -0.21334712f, 0.31333500f, -0.01198479f, 
    -0.08124123f, 0.11579146f, -0.23750210f, 0.36553448f, 0.02592115f, -0.02304596f, 0.05246352f, 0.18127222f, 
    0.05677283f, -0.05410926f, 0.04845701f, 0.07123258f, -0.25616056f, -0.11951967f, 0.00372164f, 0.64790344f, 
    -0.13399187f, 0.11496234f, 0.04707904f, -0.04549233f, -0.10398258f, 0.10971653f, 0.21304464f, 0.41943881f, 
    -0.05093513f, 0.09900098f, -0.06482454f, 0.23426272f, 0.05021983f, 0.36655402f, 0.02121598f, -0.10619017f, 
    0.43216038f, 0.03013946f, 0.05505225f, -0.05338555f, -0.24301296f, 0.06395963f, 0.06445723f, 0.13973540f, 
    0.15180612f, -0.29360521f, 0.13548093f, 0.05780847f, -0.12357651f, 0.04472684f, 0.09483765f, 0.07380790f, 
    0.07087573f, 0.07039072f, 0.31701860f, -0.07621916f, 0.11864676f, -0.36393303f, 0.11842309f, -0.04586506f, 
    -0.04143529f, -0.05742037f, 0.16218309f, -0.30225757f, -0.03175186f, -0.21455659f, -0.24794060f, -0.13163503f, 
    -0.01779462f, -0.18740639f, -0.35623115f, -0.10862106f, -0.04225654f, -0.23402810f, -0.05074224f, -0.34313637f, 
    -0.09631065f, -0.05197452f, -0.08075648f, -0.07623264f, -0.31101000f, 0.16245426f, 0.41988173f, -0.05749948f, 
    -0.04420240f, -0.12860420f, 0.10740505f, 0.24982156f, 0.27021244f, 0.02313157f, -0.16305320f, -0.16252688f, 
    0.21009286f, -0.02036723f, -0.07164148f, 0.12326109f, -0.30794963f, -0.12079978f, -0.31353250f, 0.04464630f, 
    0.05194245f, 0.00550936f, -0.09789683f, 0.10354930f, -0.43802348f, 0.37046450f, 0.38441437f, 0.04864559f, 
    -0.04861678f, -0.01644141f, 0.11079220f, 0.34646979f, -0.00832611f, 0.08254216f, -0.22264026f, -0.10471456f, 
    0.05387647f, -0.01682648f, 0.04863644f, 0.25356880f, 0.15001479f, 0.03430972f, -0.03319016f, 0.20254217f, 
    -0.13305598f, -0.16957314f, -0.06470328f, 0.00860502f, -0.03200314f, 0.16348594f, 0.30835128f, 0.14966166f, 
    -0.10319317f, -0.04634513f, 0.44709247f, -0.04185628f, 0.20643355f, 0.32482266f, 0.19416502f, -0.20723793f, 
    0.02117341f, 0.01970425f, -0.03385762f, 0.14056037f, 0.02297534f, -0.08555628f, 0.31100056f, 0.18266048f, 
    -0.00638831f, 0.15260741f, 0.30756089f, -0.06893709f, 0.12682293f, 0.15634120f, -0.53541148f, 0.25662795f, 
    -0.07718667f, 0.06982139f, 0.07489064f, 0.16656309f, 0.03044578f, 0.25001493f, -0.01650802f, 0.13746214f, 
    0.21552651f, -0.01490189f, -0.08757883f, -0.06123351f, -0.57884538f, 0.17750901f, 0.13850315f, 0.07849478f, 
    0.02332547f, -0.14874357f, -0.00199162f, 0.07043132f, -0.06691642f, -0.08819921f, 0.00922978f, 0.02349261f, 
    -0.22700264f, -0.03367561f, -0.09503815f, 0.02850291f, 0.01913681f, -0.15415511f, -0.11440381f, 0.17782451f, 
    -0.06657398f, -0.03948452f, 0.18436222f, -0.24017097f, -0.01755828f, -0.02956112f, -0.18921763f, -0.10808695f, 
    0.07297835f, 0.09566429f, -0.19961405f, 0.08024076f, 0.05110095f, -0.33694753f, -0.25024199f, -0.17114604f, 
    -0.24189143f, -0.08719137f, 0.04844705f, -0.00639154f, -0.21834986f, 0.20845835f, 0.25325564f, 0.10627767f, 
    0.14680101f, -0.11095363f, 0.13259761f, 0.01792668f, -0.10643761f, 0.02661545f, -0.09661466f, -0.01716710f, 
    -0.08926774f, 0.35326529f, 0.06038042f, -0.18641217f, 0.43925035f, -0.06277444f, 0.05763172f, 0.00124817f, 
    0.02401960f, 0.03579834f, 0.09861420f, -0.13437381f, -0.29934901f, -0.13197939f, 0.09074732f, -0.09441634f, 
    0.22985499f, -0.06152955f, -0.05602647f, 0.00456577f, -0.02281914f, -0.10306764f, 0.05214823f, 0.21567768f, 
    0.00926399f, -0.05449254f, 0.02973128f, 0.11916869f, 0.01218611f, 0.08189733f, 0.08790118f, -0.00260085f, 
    0.01848864f, -0.83575141f, 0.00844986f, 0.08535260f, 0.25111657f, -0.11526317f, 0.04629923f, 0.13498731f, 
    0.01410453f, -0.04786913f, -0.37386742f, 0.03373877f, -0.05404871f, 0.00020895f, -0.05156294f, -0.38354406f, 
    0.17770816f, -0.05767636f, 0.01152673f, -0.01818308f, -0.11057641f, 0.23077792f, 0.06253737f, -0.36400157f, 
    0.06605636f, -0.21616636f, -0.04948933f, 0.18540947f, -0.09848421f, -0.02904097f, -0.43168956f, -0.05658645f, 
    -0.16542457f, -0.16701624f, 0.07198803f, 0.12444759f, -0.00702684f, -0.24006601f, -0.22804917f, -0.02600739f, 
    -0.22665243f, 0.00510321f, -0.03643570f, 0.18495604f, -0.13000309f, 0.05072196f, 0.14779671f, -0.06762016f, 
    -0.35402143f, 0.08901785f, -0.07705005f, -0.00112976f, 0.10764935f, -0.05205718f, -0.15241885f, 0.04772605f, 
    0.28981835f, -0.00587264f, -0.03969692f, 0.09332159f, 0.02317755f, 0.14248635f, -0.01010060f, -0.13312335f, 
    0.04391424f, -0.02068792f, 0.03834897f, 0.17540167f, -0.08634493f, -0.13184248f, 0.05845398f, 0.25981462f, 
    0.05864867f, -0.03751779f, -0.13855392f, 0.19817071f, 0.16728976f, 0.74701077f, 0.06792053f, 0.10105086f, 
    0.25515819f, 0.07169382f, 0.03238841f, -0.06554156f, -0.07725159f, 0.06482731f, -0.19369382f, -0.00901509f, 
    0.08246903f, -0.23653097f, -0.26363164f, -0.12379824f, -0.25247461f, 0.02135551f, 0.11910674f, 0.15352632f, 
    0.17447683f, 0.01426592f, 0.23198761f, -0.05577407f, 0.00892670f, -0.19758761f, 0.34450135f, 0.01924100f, 
    -0.04595351f, 0.15014322f, -0.01470075f, -0.34082410f, -0.62330991f, -0.09357385f, -0.02315749f, -0.09070995f, 
    -0.30693510f, 0.05185672f, -0.04476436f, 0.01444358f, 0.03539409f, 0.13044038f, -0.03989587f, 0.39116213f, 
    0.23896520f, -0.02680476f, -0.11719158f, -0.50501966f, -0.08985625f, 0.08475500f, -0.00196338f, -0.09251568f, 
    -0.07465288f, -0.52741051f, 0.01317560f, -0.55939400f, 0.09295408f, 0.03159487f, 0.09502087f, 0.06903103f, 
    -0.02286187f, -0.20317699f, -0.10033662f, -0.24554421f, 0.23913334f, 0.01529048f, 0.17006120f, -0.54949951f, 
    0.02213803f, -0.01154460f, -0.03180819f, 0.11288793f, 0.03061123f, -0.11668462f, 0.50115174f, 0.15584478f, 
    0.12708297f, 0.15809558f, -0.04024495f, -0.34707376f, 0.10821420f, -0.18016805f, -0.42662668f, -0.22105107f, 
    0.23162486f, -0.29436266f, 0.08771644f, -0.10497191f, 0.00084518f, -0.46434078f, -0.00152360f, 0.11429000f, 
    0.16569275f, 0.03026310f, -0.04720888f, 0.11800212f, -0.94685632f, 0.22151411f, 0.33582377f, 0.16429842f, 
    0.18080315f, 0.13720892f, 0.07943958f, 0.18448764f, -0.10546183f, 0.06154736f, 0.30048320f, 0.07803141f, 
    0.24884103f, -0.01635270f, 0.12062139f, 0.32531580f, -0.53173864f, 0.19225779f, 0.14644551f, -0.19389205f, 
    -0.12682483f, -0.04855832f, 0.14766501f, 0.46955040f, -0.03741241f, 0.16635844f, 0.03261025f, 0.04911768f, 
    0.18635641f, 0.07587571f, 0.33067819f, 0.20193534f, 0.09999313f, -0.18840481f, -0.15949906f, 0.19274713f, 
    -0.00720469f, -0.02207922f, -0.07196495f, 0.02702626f, 0.14213516f, -0.39558762f, -0.43847588f, 0.15575433f, 
    0.25722101f, 0.05989278f, 0.29635936f, 0.14626774f, 0.39092565f, -0.07201895f, 0.15655543f, -0.00999943f, 
    0.01980038f, -0.04590283f, 0.03512832f, -0.05552543f, -0.08505087f, -0.01802014f, -0.00340125f, -0.10810219f, 
    -0.11171428f, 0.03069470f, -0.00904324f, 0.07938468f, 0.02044363f, -0.07742035f, 0.03142551f, -0.07746410f, 
    -0.01060146f, 0.07092235f, -0.03680958f, -0.09381983f, -0.03344381f, -0.11335684f, -0.03179426f, -0.04901717f, 
    -0.03346250f, -0.06037385f, -0.10118765f, 0.03382931f, -0.01349555f, -0.09145796f, -0.03407042f, -0.04190586f, 
    0.02739603f, 0.03380587f, -0.06229740f, -0.08673341f, -0.07249333f, 0.04739522f, -0.00988464f, 0.06316558f, 
    0.08627480f, 0.07303642f, 0.03378313f, 0.02848292f, -0.00961248f, -0.09427708f, -0.06835130f, -0.07741462f, 
    0.03205477f, -0.01445483f, -0.04754017f, -0.02316511f, -0.04286883f, 0.02616579f, 0.03701124f, -0.06835381f, 
    0.04833789f, -0.09553712f, -0.02276443f, 0.04522611f, 0.02335451f, 0.04161321f, 0.07710826f, 0.05457085f, 
    0.02027161f, 0.01343923f, 0.01432327f, -0.05754843f, -0.03324404f, 0.05678251f, -0.07855350f, 0.02530064f, 
    -0.00396288f, 0.01897437f, -0.07256113f, 0.04900171f, 0.05194902f, -0.04544575f, -0.11243635f, -0.02906370f, 
    0.02525554f, -0.07432983f, -0.01424355f, -0.06760412f, 0.06719816f, 0.05540285f, 0.04806985f, -0.08099806f, 
    -0.04797836f, 0.06801396f, 0.05241768f, -0.08581492f, -0.10910928f, -0.09686308f, 0.04961193f, 0.02445538f, 
    0.01535497f, 0.04109202f, 0.02962924f, 0.04439213f, -0.00244309f, -0.03588828f, 0.01052738f, 0.01499585f, 
    -0.06413676f, -0.10416193f, -0.05904853f, -0.07112381f, -0.00084925f, 0.05077004f, -0.09126020f, -0.06144031f, 
    -0.03154982f, -0.07563662f, 0.07648555f, 0.01518549f, -0.00928239f, 0.04110315f, -0.03601734f, -0.07058680f, 
    0.05425217f, 0.01559587f, 0.05936103f, -0.05936700f, -0.07603668f, -0.05247942f, -0.04572138f, 0.03895843f, 
    -0.02596478f, -0.07074151f, -0.02210964f, -0.11806029f, 0.06218453f, -0.00220867f, -0.01035466f, -0.12469179f, 
    0.01196231f, -0.00991465f, 0.03831553f, -0.02087953f, 0.00297167f, -0.07656184f, -0.04069611f, -0.04181053f, 
    0.00318896f, -0.06235690f, -0.06778415f, -0.07878804f, -0.06677263f, -0.08429504f, -0.01821301f, 0.01041987f, 
    0.05719487f, 0.04043905f, -0.04550208f, -0.05350336f, -0.07982852f, -0.03727696f, -0.07417719f, -0.02114851f, 
    -0.10773300f, 0.01548104f, -0.06042632f, -0.06794625f, 0.03549034f, -0.01302361f, -0.01202422f, -0.12058737f, 
    -0.07415891f, 0.03756566f, 0.00066577f, -0.06364485f, -0.04419294f, 0.06379957f, -0.12920704f, 0.02960476f, 
    0.05345919f, -0.02480041f, -0.05444308f, -0.02669247f, -0.09727476f, 0.02587976f, -0.04177864f, -0.03869811f, 
    0.07892621f, -0.05615412f, -0.01804847f, -0.06706795f, -0.01710132f, -0.14196180f, 0.01506546f, -0.10046288f, 
    -0.05854751f, -0.07952614f, 0.05274539f, -0.10339347f, 0.03066234f, -0.09760013f, -0.05475222f, 0.03504635f, 
    -0.09599682f, 0.00991891f, -0.02782895f, -0.08195233f, -0.06438272f, -0.00667389f, 0.03893426f, -0.10041668f, 
    -0.06521899f, -0.01215704f, -0.07233429f, 0.04276061f, -0.06103872f, 0.07005488f, 0.07620350f, -0.08625235f, 
    -0.09561944f, -0.05939119f, -0.03722635f, -0.02679282f, -0.09168847f, 0.02472572f, 0.00979959f, 0.00174168f, 
    -0.02008620f, -0.05954315f, -0.02044132f, 0.01213067f, -0.05222606f, 0.04197020f, -0.08851776f, -0.07497370f, 
    -0.10161828f, 0.06857798f, -0.02519175f, -0.04638094f, 0.04267058f, 0.09235024f, 0.04461533f, 0.04961835f, 
    0.04216499f, 0.01639577f, -0.03090599f, 0.06836836f, -0.08969670f, 0.04460901f, -0.01820428f, -0.04723913f, 
    -0.01193900f, 0.00750981f, -0.04948336f, -0.09233323f, -0.06642930f, 0.02383373f, 0.06593107f, -0.10280184f, 
    0.40332723f, -0.25393257f, 0.25911972f, 0.19622920f, -0.02331896f, -0.61360139f, 0.04595386f, 0.14445823f, 
    0.12600794f, -0.00390160f, 0.14120011f, -0.08708290f, -0.30004573f, -0.07968854f, 0.24848852f, -0.36947146f, 
    -0.12422231f, 0.00020901f, 0.21516062f, -0.26290175f, 0.04227926f, -0.08433129f, -0.21731946f, 0.09315771f, 
    0.11606385f, -0.05248791f, -0.00965459f, 0.16863330f, -0.20955573f, 0.03358530f, -0.00694790f, -0.01446430f, 
    0.06102717f, 0.00558120f, 0.19712508f, -0.10836925f, 0.17286575f, -0.17400624f, 0.17928238f, 0.01933655f, 
    0.03417207f, 0.01765672f, -0.16453180f, 0.00205111f, 0.26409110f, 0.08211655f, 0.21438301f, -0.33894664f, 
    0.08846872f, -0.02548214f, -0.04676986f, 0.13639013f, -0.15879303f, -0.14442903f, 0.36703956f, 0.64388871f, 
    0.03443760f, -0.04475195f, -0.18235315f, -0.07159070f, -0.03746922f, -0.10571489f, -0.46644905f, 0.04719469f, 
    0.02709910f, -0.07350501f, -0.00221678f, 0.08304779f, -0.06994654f, 0.04022334f, 0.05008819f, 0.25117746f, 
    0.18854709f, 0.04864579f, 0.02951170f, -0.07252249f, -1.06598830f, 0.06250792f, -0.14754480f, 0.08792093f, 
    -0.03347319f, -0.05584680f, 0.12043023f, -0.08052722f, -0.24761948f, -0.07448173f, 0.17848592f, -0.08257031f, 
    0.56869179f, -0.03056078f, 0.53393799f, 0.14235726f, -0.21505877f, -0.04736410f, 0.32423264f, -0.13131794f, 
    0.09298696f, -0.05002061f, 0.08506193f, -0.06578699f, 0.10487208f, 0.03614381f, -0.31839478f, 0.16971593f, 
    -0.02474001f, -0.09674841f, -0.21267007f, 0.05820936f, 0.14853145f, -0.16024289f, -0.40420258f, -0.21524245f, 
    0.32409206f, -0.08283906f, 0.03307895f, -0.01233238f, -0.01125298f, -0.06476449f, 0.15836865f, 0.14328563f, 
    0.20887192f, 0.04928713f, 0.10258295f, 0.43974507f, 0.38444424f, -0.07594710f, 0.12604122f, -0.25616363f, 
    -0.04183913f, -0.05912472f, -0.00264748f, 0.15086921f, -0.17917879f, 0.19899100f, 0.28849968f, 0.04582353f, 
    -0.03292829f, 0.08636321f, -0.00762131f, 0.00789747f, -0.11959301f, 0.02662181f, 0.03455025f, 0.06193639f, 
    -0.13479841f, -0.02816892f, 0.31762066f, 0.10319266f, 0.07412194f, 0.18281677f, -0.04389657f, -0.00609223f, 
    0.13002990f, -0.17339846f, -0.03265066f, -0.19551498f, -0.09401274f, 0.01642383f, 0.04148233f, -0.03144050f, 
    0.03516693f, -0.45580631f, 0.15435238f, 0.27584106f, 0.07209223f, 0.01786291f, 0.00697784f, 0.03638706f, 
    0.01937162f, -0.09334213f, 0.39437628f, -0.25603274f, 0.23997799f, 0.06304934f, 0.11228296f, -0.08468501f, 
    -0.31718069f, 0.03103270f, 0.06117010f, 0.01179024f, 0.10995767f, -0.21392012f, 0.17528884f, 0.35705206f, 
    0.02545410f, 0.21278428f, 0.12425090f, -0.19360600f, -0.07878503f, 0.06184709f, 0.18698181f, 0.03338748f, 
    0.27104384f, -0.00005150f, -0.00833609f, -0.09210873f, -0.16543132f, 0.09423174f, 0.13335720f, -0.00016105f, 
    0.34762511f, -0.05280009f, 0.05517859f, -0.07595283f, 0.16565908f, 0.06168022f, 0.19446242f, 0.34722021f, 
    0.00820727f, 0.06689611f, 0.10418461f, 0.21270663f, -0.08336783f, 0.00547356f, 0.28354982f, 0.00481201f, 
    -0.20582353f, 0.01039930f, -0.12322832f, 0.05710619f, -0.21165526f, -0.00667596f, 0.04961719f, -0.02968618f, 
    0.04555014f, -0.02268884f, -0.07480802f, 0.33300564f, 0.03725751f, -0.05428323f, 0.07302505f, -0.09304575f, 
    0.11410709f, -0.00272641f, 0.18355003f, 0.00390510f, 0.09736614f, -0.53575116f, 0.15647587f, 0.01486469f, 
    -0.09152784f, -0.05509187f, 0.05099317f, 0.05083818f, -0.05774007f, -0.29418230f, -0.01929551f, 0.09098470f, 
    0.11141355f, 0.07349234f, -0.05914307f, 0.06752338f, 0.27231818f, -0.03996587f, 0.08832951f, 0.00280828f, 
    -0.02586621f, 0.02125198f, -0.05236689f, -0.06569624f, -0.07118203f, -0.01902507f, -0.03525857f, -0.00576691f, 
    -0.02718243f, 0.01488363f, -0.07809875f, -0.08963886f, 0.01734977f, -0.08166669f, -0.08675987f, -0.01033493f, 
    -0.08356445f, 0.07604284f, -0.04144442f, -0.07230072f, 0.06576861f, 0.02588752f, -0.01369051f, -0.00108898f, 
    0.01927882f, -0.14488669f, -0.06040297f, 0.08220457f, -0.11377078f, 0.00971461f, -0.03683866f, -0.03280724f, 
    -0.00952815f, 0.05648429f, 0.06266458f, -0.04108302f, -0.05780983f, -0.06835238f, -0.00445579f, -0.02247983f, 
    0.03547246f, -0.05540676f, -0.02989981f, -0.01934212f, 0.02170184f, 0.01370983f, 0.00566164f, 0.03412506f, 
    -0.00897752f, -0.08486825f, 0.03325249f, 0.04876479f, -0.10615736f, -0.05342136f, -0.06772083f, -0.02570761f, 
    0.04922553f, -0.00663754f, 0.06810471f, -0.08745520f, 0.01292676f, 0.01559297f, -0.08567557f, -0.01086596f, 
    -0.02785029f, 0.01977964f, -0.03342024f, -0.11150413f, -0.04382255f, 0.08794415f, 0.03311659f, -0.02305117f, 
    -0.09948278f, 0.00132772f, 0.00052966f, -0.04083909f, -0.02604013f, -0.06905944f, -0.10455506f, -0.03543397f, 
    -0.07834534f, -0.05802784f, -0.09147482f, 0.03951789f, -0.09664077f, 0.03443263f, -0.07073648f, 0.05836884f, 
    0.03493103f, 0.05083024f, -0.05702110f, 0.00239030f, -0.00100522f, -0.08993296f, 0.01366424f, -0.01269149f, 
    -0.00022973f, 0.03520827f, -0.08419628f, -0.03559284f, 0.00356308f, -0.12487785f, 0.02801062f, 0.01139884f, 
    -0.06806347f, -0.01240230f, 0.03609188f, -0.04636773f, -0.04523157f, 0.04896606f, 0.01232283f, 0.01146163f, 
    -0.00482534f, -0.03194942f, 0.07617558f, 0.00418460f, 0.01389132f, 0.03353921f, 0.01130516f, 0.00656217f, 
    -0.07333378f, -0.08000123f, 0.03218908f, -0.08549070f, -0.01232760f, -0.01130263f, -0.08868234f, 0.01586642f, 
    -0.38100556f, 0.20384912f, 0.13120750f, -0.11576701f, 0.31007081f, -0.16761336f, 0.17588149f, 0.22325034f, 
    0.08854815f, -0.04662631f, -0.05544371f, -0.31274587f, 0.06508864f, -0.02578253f, -0.07665619f, -0.32085326f, 
    -0.01166441f, -0.04557657f, -0.09752519f, 0.31104597f, 0.05700020f, 0.12263489f, -0.05026573f, 0.31598952f, 
    -0.02170246f, 0.13973075f, 0.14040564f, -0.11343936f, -0.02876684f, 0.13616948f, -0.00394666f, -0.00825673f, 
    -0.18727233f, -0.86282921f, -0.05757165f, 0.19216445f, 0.21235585f, 0.21199892f, -0.04783490f, 0.13539183f, 
    0.05285393f, -0.14778396f, 0.04155299f, -0.18607035f, 0.29539254f, 0.06817750f, 0.12645052f, -0.22351119f, 
    -0.11797217f, 0.07668811f, -0.07917818f, -0.01497021f, -0.01389970f, 0.05542622f, 0.25848854f, -0.51803696f, 
    0.10584319f, -0.06300779f, 0.03821845f, 0.13353722f, 0.06076978f, 0.02058549f, -0.22971630f, -0.28360164f, 
    0.04782742f, -0.04652201f, 0.01842282f, 0.08352104f, -0.00215253f, -0.35069558f, -0.30348963f, 0.01031441f, 
    -0.15693225f, 0.04135634f, -0.05534399f, 0.04073082f, 0.02566950f, 0.01670412f, 0.19734716f, -0.15045170f, 
    -0.48160249f, 0.37855318f, 0.08879496f, 0.02440432f, 0.25894579f, 0.01462947f, -0.03023236f, 0.05504796f, 
    -0.11402065f, -0.07617114f, -0.15718776f, 0.11274436f, -0.11534509f, 0.16126733f, -0.08819856f, -0.01385568f, 
    0.13544101f, -0.05395348f, -0.03978314f, 0.33289135f, -0.01336957f, -0.09192279f, -0.06159024f, 0.16414399f, 
    0.03701622f, 0.25393882f, -0.06390189f, 0.23958494f, 0.08143111f, 0.22877327f, 0.08027979f, 0.12589099f, 
    -0.04494243f, -0.03712173f, -0.01106386f, 0.02717191f, -0.06857883f, 0.18113188f, -0.12760857f, 0.08073036f, 
    -0.00508545f, 0.16187933f, -0.44283038f, -0.31106046f, -0.23024347f, -0.04800243f, 0.15547237f, 0.20466392f, 
    -0.07030345f, 0.01899606f, -0.09773937f, -0.06715559f, -0.03566141f, 0.02288220f, 0.01843025f, -0.02457470f, 
    -0.06690264f, 0.07046974f, -0.01488404f, -0.05603455f, -0.05305678f, 0.00265997f, 0.00408495f, 0.04111240f, 
    -0.08400687f, -0.01511973f, -0.05260080f, 0.03261580f, 0.01357974f, -0.09399114f, 0.03017791f, 0.02770263f, 
    -0.01916206f, -0.01411064f, 0.00612150f, 0.03859173f, -0.09960470f, -0.09695109f, 0.02865175f, 0.04347105f, 
    -0.08276071f, -0.03621949f, -0.08043150f, -0.03844113f, 0.00327287f, -0.00866554f, -0.06673656f, 0.00139060f, 
    -0.00647085f, -0.03067155f, 0.00061034f, 0.02634423f, -0.03203427f, 0.01073087f, -0.06250800f, -0.04866942f, 
    0.02758859f, 0.03839288f, -0.03727853f, -0.00951996f, 0.00225829f, 0.01763685f, -0.01639889f, -0.03748900f, 
    -0.04725328f, 0.03526221f, -0.10322987f, -0.07741308f, 0.04070404f, 0.02869289f, -0.02305394f, 0.00117295f, 
    0.02415258f, -0.03350250f, -0.05197090f, 0.06170711f, 0.00510322f, -0.04229214f, -0.06792115f, -0.11059295f, 
    0.03327211f, -0.04026009f, 0.08057154f, -0.05499582f, -0.06821407f, -0.08992875f, -0.04309337f, -0.01695461f, 
    -0.00931639f, -0.03717199f, 0.03050357f, -0.06274544f, 0.07930738f, -0.00690713f, -0.02658736f, 0.06320449f, 
    -0.07829420f, 0.00512722f, -0.02234316f, -0.11430066f, -0.08133703f, -0.00892386f, -0.02142512f, -0.03993337f, 
    -0.11189681f, 0.02134345f, 0.04266810f, -0.07753677f, -0.08527208f, -0.10374822f, -0.00965636f, 0.04691873f, 
    -0.03937846f, -0.06515352f, 0.04017007f, -0.10747578f, -0.04520775f, -0.01525401f, -0.01324381f, -0.07810280f, 
    -0.08234753f, 0.07935940f, 0.01406522f, -0.02821356f, -0.01486458f, 0.05838766f, -0.04765620f, -0.05697135f, 
    -0.00481639f, 0.06497209f, -0.05456832f, 0.04054971f, -0.05280434f, 0.00715162f, -0.06692916f, -0.02107696f, 
    0.03472756f, -0.03133788f, -0.08095646f, -0.10205258f, 0.00075922f, -0.09103392f, 0.02523860f, -0.02902290f, 
    -0.00527366f, 0.02081179f, -0.00234320f, 0.05336700f, -0.09182348f, 0.02681185f, -0.00024253f, 0.04378555f, 
    -0.06978625f, 0.06882931f, 0.02628253f, -0.12101411f, 0.02076267f, -0.03456621f, 0.00958559f, 0.01475884f, 
    0.03436723f, -0.05711833f, -0.00504361f, -0.04250308f, -0.04321848f, -0.04904768f, -0.02128775f, -0.05660424f, 
    0.01595877f, -0.01381331f, 0.04671022f, -0.09120252f, 0.05130839f, -0.01310513f, -0.10871287f, -0.05082142f, 
    0.01552949f, -0.03683398f, -0.04051507f, 0.05682133f, -0.07025450f, -0.08101114f, -0.08360461f, 0.04771072f, 
    -0.02920859f, 0.06966674f, -0.07216114f, -0.06426606f, 0.01248627f, -0.15804245f, -0.00409670f, -0.01283821f, 
    -0.09761321f, 0.04390156f, -0.08577773f, -0.13011967f, -0.03413053f, -0.07036135f, 0.03609053f, 0.02887008f, 
    0.00527021f, 0.01502478f, -0.03083732f, -0.05719710f, 0.04367120f, -0.11489397f, -0.06074590f, -0.06372568f, 
    0.03696028f, -0.03845947f, 0.08174001f, -0.01865683f, -0.06052216f, 0.02111194f, -0.11153626f, -0.09249159f, 
    -0.04056020f, -0.09759161f, -0.04443844f, -0.03956071f, 0.04793852f, 0.01755104f, 0.01233872f, -0.02605549f, 
    -0.00297292f, -0.03764530f, -0.10516150f, -0.00637517f, -0.04745298f, 0.03707378f, 0.00552970f, -0.05085647f, 
    -0.07378621f, -0.01396830f, -0.04358281f, 0.02162750f, -0.12111311f, -0.00426063f, -0.09880985f, -0.08007418f, 
    -0.06677707f, 0.02342827f, -0.10166130f, -0.06625418f, 0.02871579f, 0.00589555f, -0.03561612f, -0.10750946f, 
    -0.13326088f, -0.01845228f, 0.03567478f, -0.08761933f, 0.01214644f, -0.11842874f, -0.06651500f, 0.01762472f, 
    -0.04414507f, -0.08051008f, -0.10081877f, 0.04360877f, 0.02083748f, 0.02781075f, -0.08419117f, -0.02321794f, 
    -0.06494334f, 0.05425749f, 0.02826623f, 0.01370796f, -0.04493326f, 0.04320484f, -0.07258872f, 0.03258730f, 
    0.01193754f, 0.04596072f, -0.03328070f, 0.06227544f, -0.05746021f, -0.00220542f, 0.01862330f, -0.00248569f, 
    -0.07647701f, -0.01520176f, 0.06448022f, -0.02435244f, 0.01647974f, -0.06750217f, -0.07807011f, -0.04410673f, 
    0.03780964f, 0.07383808f, -0.08291325f, -0.00808606f, -0.06925121f, 0.05003253f, 0.01490719f, 0.07248976f, 
    -0.03520351f, -0.03516032f, -0.03507115f, -0.07728075f, 0.04063398f, -0.00610622f, -0.05719046f, 0.00323504f, 
    -0.08463802f, 0.01844748f, -0.04430575f, 0.04970689f, -0.08182142f, 0.01453886f, 0.02123871f, -0.04760004f, 
    0.03789113f, 0.04654541f, -0.05013931f, 0.00082761f, -0.08575596f, 0.01613823f, -0.01884734f, -0.08958109f, 
    0.07833102f, -0.00683385f, 0.07350041f, -0.00794355f, 0.01517904f, -0.07528576f, 0.07573229f, 0.05335735f, 
    -0.06279533f, -0.03388600f, -0.07363695f, -0.05859306f, -0.06204705f, 0.01321256f, -0.08726929f, 0.04077777f, 
    0.00407578f, 0.00331059f, -0.03504448f, 0.02812259f, -0.03664355f, -0.08057340f, 0.03960105f, 0.06037979f, 
    0.07859156f, 0.07031455f, 0.03568320f, -0.01713162f, -0.05789565f, 0.06338386f, 0.02248164f, -0.03504018f, 
    -0.07677591f, 0.04608077f, -0.02409446f, 0.02303522f, -0.03425579f, -0.03595202f, 0.06243322f, -0.08501174f, 
    -0.04138248f, 0.06565199f, -0.04416949f, -0.06838638f, 0.03591964f, -0.06117319f, -0.03909652f, -0.04132296f, 
    -0.09050106f, -0.06035634f, 0.03176855f, -0.06420539f, -0.01944902f, 0.00149034f, -0.01701192f, -0.02172032f, 
    0.07566418f, 0.02780058f, -0.05026061f, -0.03559939f, -0.07335898f, 0.06776192f, -0.07964695f, -0.01842545f, 
    -0.08690509f, -0.05702792f, -0.06830851f, 0.00964404f, -0.02125359f, -0.04556773f, -0.06333569f, -0.01232757f, 
    -0.26582721f, 0.14861669f, 0.02075640f, -0.17375910f, 0.33935782f, 0.11991692f, 0.49338770f, -0.06457496f, 
    0.10378313f, -0.08358319f, 0.05341892f, 0.06626090f, 0.11403361f, -0.29172751f, -0.25756693f, 0.19447996f, 
    -0.06745151f, -0.06163165f, -0.17163648f, -0.21252255f, 0.08676767f, 0.05117638f, 0.06112862f, 0.39670253f, 
    0.17073457f, 0.09196827f, 0.08792809f, -0.09264870f, -0.11724142f, 0.00201847f, 0.03539826f, -0.06688701f, 
    -0.00441314f, -0.32583702f, 0.13009815f, -0.03892813f, 0.06225537f, 0.14622425f, -0.02212734f, -0.22790062f, 
    0.07539031f, 0.17233220f, 0.22277376f, -0.04934219f, -0.09585581f, -0.34080204f, -0.26007482f, -0.01850628f, 
    0.10664693f, 0.02962196f, 0.02006149f, 0.11849885f, 0.03538109f, -0.11239626f, -0.07995908f, -0.33134827f, 
    0.21596661f, -0.03595862f, -0.24164908f, 0.03437195f, 0.07625952f, -0.20690563f, 0.61586446f, -0.20092085f, 
    0.14530127f, -0.17274129f, 0.02486994f, -0.12455262f, 0.01715846f, -0.17211668f, -0.07828800f, 0.13787705f, 
    -0.23634128f, -0.04132665f, 0.05366849f, 0.01274206f, 0.70826387f, 0.03147901f, -0.01668778f, 0.17344785f, 
    -0.01302725f, 0.20952287f, -0.05924166f, 0.13383041f, 0.10556392f, -0.00115482f, 0.05326480f, -0.05443780f, 
    0.06224953f, 0.02469616f, 0.03937192f, 0.11579981f, -0.08176211f, 0.34802994f, 0.05623945f, -0.17061771f, 
    0.04616176f, 0.01743528f, -0.09473177f, 0.24801917f, -0.08942134f, 0.05133877f, 0.15160279f, 0.24870165f, 
    0.02156539f, 0.10129750f, 0.25634429f, 0.17592672f, 0.02879543f, -0.08764579f, 0.35537180f, 0.11120770f, 
    0.22624630f, -0.01938921f, 0.06405707f, 0.03567175f, 0.07578973f, -0.30315858f, -0.08171238f, 0.13656440f, 
    0.10455170f, 0.19287641f, 0.02144189f, -0.15973006f, 0.09949999f, -0.05756823f, 0.13940041f, 0.07372330f, 
    0.12887430f, -0.03466580f, -0.05207739f, 0.16365397f, -0.22947471f, -0.09686904f, -0.33645383f, 0.07767621f, 
    0.00437638f, -0.03064316f, -0.11784329f, 0.02697582f, -0.14946777f, 0.36909175f, 0.50684720f, 0.15619671f, 
    -0.01169990f, -0.08680769f, -0.20130016f, 0.34191748f, 0.00843286f, -0.05800529f, -0.11049461f, 0.02350646f, 
    0.02978655f, -0.08211733f, -0.01315957f, 0.02509740f, 0.15150540f, 0.10430183f, -0.04967829f, 0.07511531f, 
    0.03073960f, 0.09912982f, 0.00582486f, -0.71516806f, 0.04997857f, 0.07821757f, 0.25222084f, 0.16950874f, 
    -0.02238151f, -0.00689372f, 0.08075809f, 0.02153656f, 0.30992255f, 0.14166120f, 0.32032463f, -0.09287187f, 
    0.08795700f, -0.01257991f, 0.06088784f, -0.07088785f, -0.19400571f, -0.17247726f, 0.43179107f, 0.25549781f, 
    -0.04777991f, 0.12902680f, 0.21198437f, -0.10697814f, -0.06494438f, 0.05585099f, -0.23345156f, 0.33242217f, 
    -0.45049691f, -0.06889384f, 0.01900526f, 0.14209393f, 0.01930454f, 0.01305483f, -0.04526870f, 0.02247803f, 
    0.12291792f, 0.01888431f, -0.05712342f, 0.05062772f, -0.55418551f, 0.24840671f, 0.30896106f, -0.03205304f, 
    0.10957307f, -0.09081116f, 0.10308053f, 0.15371045f, 0.03713290f, -0.07044839f, 0.01522704f, -0.04877094f, 
    -0.12260623f, -0.06542999f, -0.28121123f, 0.09254461f, 0.03061621f, -0.07771850f, -0.18106945f, 0.03221179f, 
    -0.01970393f, 0.06719857f, 0.27323776f, -0.08628688f, -0.11958802f, 0.00563893f, -0.15938720f, -0.08962451f, 
    0.12982236f, 0.08481372f, -0.11138821f, -0.01467787f, -0.09045034f, 0.02335366f, -0.12156437f, -0.00722301f, 
    -0.34897777f, -0.09956733f, -0.02506167f, -0.02548992f, -0.19357313f, 0.30288735f, -0.11419097f, 0.03301293f, 
    0.20108965f, -0.13811657f, 0.11070374f, -0.08033917f, -0.15933269f, 0.14562255f, -0.10498547f, 0.00065919f, 
    -0.07148619f, 0.26508453f, -0.00972883f, -0.12494278f, 0.13410927f, 0.10004807f, 0.15321335f, 0.08768409f, 
    0.09948906f, 0.07735362f, 0.11730754f, 0.15946966f, 0.77133143f, -0.32312799f, -0.35001016f, 0.24482602f, 
    0.31589234f, -0.03265388f, 0.24675247f, -0.08620057f, 0.01806642f, -0.06734350f, 0.10866980f, 0.17850901f, 
    0.13186771f, -0.00360738f, 0.13562007f, -0.22562048f, 0.10317057f, 0.12369447f, -0.02754702f, -0.14236239f, 
    -0.08981273f, 0.49182922f, -0.32901344f, 0.14224842f, -0.05850241f, -0.02771201f, -0.20316830f, -0.14772050f, 
    0.06714704f, 0.20894183f, -0.01643163f, 0.30853453f, -0.52162266f, -0.27173665f, -0.07447376f, 0.13417237f, 
    0.07111132f, -0.07657749f, -0.09027062f, -0.02577530f, -0.08391359f, 0.04593417f, -0.47249484f, -0.25441051f, 
    0.03394691f, 0.02296000f, -0.07980994f, 0.20227829f, -0.02276950f, 0.15931767f, 0.67034757f, -0.05660383f, 
    0.16183673f, 0.08656074f, -0.04192532f, 0.02715602f, -0.02251823f, 0.09294455f, -0.36228007f, 0.05278612f, 
    -0.26898313f, -0.01471696f, -0.04393140f, -0.09278894f, 0.61316055f, -0.12001947f, 0.09521094f, -0.15684661f, 
    -0.29153907f, 0.14753875f, -0.02820433f, -0.04331998f, 0.22725657f, 0.02159500f, -0.39371398f, 0.02738238f, 
    -0.14152284f, 0.08117826f, 0.04602924f, 0.02272033f, 0.15994947f, 0.18847822f, 0.04765234f, -0.00329458f, 
    0.00023580f, -0.01517521f, -0.13709396f, 0.05279682f, -0.09306768f, -0.05492952f, 0.23932824f, 0.11885081f, 
    0.17600526f, 0.06190387f, 0.10543283f, 0.03827059f, 0.07160918f, 0.16260716f, 0.29684061f, 0.12711197f, 
    0.27080637f, 0.05897920f, -0.07044056f, 0.03857667f, -0.03516770f, -0.00620565f, 0.10502717f, -0.05900336f, 
    -0.30662343f, 0.02981445f, -0.46158558f, 0.01096378f, -0.32852781f, -0.08203450f, -0.05057665f, 0.07221559f, 
    0.05127320f, 0.02308710f, -0.06596363f, -0.04009881f, 0.06910171f, -0.01624216f, -0.00646222f, 0.01925731f, 
    0.04924834f, -0.07796598f, -0.01050461f, -0.07561803f, -0.06093637f, 0.01064926f, 0.04909884f, -0.04126035f, 
    0.03396963f, -0.06073313f, 0.02915326f, -0.04003149f, -0.07501779f, 0.03544556f, -0.09624082f, -0.08711984f, 
    -0.08503246f, 0.04951749f, 0.02397398f, -0.06824666f, -0.09302489f, -0.05566495f, 0.00233847f, -0.11061878f, 
    -0.05035038f, -0.04522651f, -0.02108093f, -0.10947784f, -0.11349995f, -0.06762041f, -0.11057150f, 0.04801895f, 
    0.04519382f, 0.02744913f, -0.07374875f, 0.03484360f, -0.03865959f, -0.08026943f, 0.02685173f, -0.05103784f, 
    -0.00357914f, -0.02211161f, 0.07982805f, -0.11189838f, -0.07707756f, -0.02683580f, 0.01081854f, 0.02856117f, 
    -0.07084135f, 0.00585237f, 0.02000051f, 0.00577474f, -0.02597599f, 0.00673200f, 0.05214274f, -0.08496206f, 
    -0.06037003f, 0.00286585f, -0.04405149f, -0.10348317f, -0.10972690f, -0.07238760f, -0.06559721f, -0.00079644f, 
    -0.07046739f, -0.03813919f, 0.07469504f, -0.06687202f, 0.05067598f, -0.08416105f, -0.07819176f, -0.10021672f, 
    -0.01372347f, 0.06185925f, 0.00676024f, -0.04867531f, -0.04331814f, 0.01744757f, -0.06607586f, -0.00366723f, 
    -0.02704617f, 0.05602116f, -0.05586483f, 0.00231893f, -0.03619618f, -0.05947267f, -0.06523494f, -0.01865235f, 
    -0.10981872f, 0.00461383f, -0.06952599f, -0.05391772f, 0.02545824f, -0.10900326f, -0.07506151f, -0.09815720f, 
    -0.01995266f, -0.07948302f, -0.05109204f, 0.05944282f, 0.01028975f, 0.01184056f, -0.06986672f, -0.03420388f, 
    0.02773012f, 0.04648187f, -0.03900552f, -0.01872157f, -0.08507175f, 0.02394048f, -0.09428387f, 0.00896259f, 
    -0.05671750f, -0.04352038f, 0.05715603f, -0.02735497f, -0.04798197f, 0.04311351f, 0.00109128f, 0.00220479f, 
    -0.04789038f, 0.16502950f, 0.30911773f, -0.17528310f, 0.19802272f, -0.42516857f, 0.08524934f, -0.04397570f, 
    0.09753430f, -0.02284690f, 0.16805939f, -0.07136519f, -0.46916986f, -0.19524208f, 0.06037813f, -0.36517909f, 
    0.09702107f, 0.03558148f, -0.20171534f, -0.00502044f, 0.00015058f, -0.26322520f, -0.07826297f, 0.17941032f, 
    0.01270704f, 0.07945471f, 0.01742011f, 0.38308194f, -0.06054404f, 0.13076928f, -0.02088978f, 0.02020258f, 
    -0.11905768f, -0.40225121f, 0.17148067f, 0.00426441f, 0.08663122f, -0.01811822f, 0.09725226f, 0.00864302f, 
    -0.11162987f, 0.12350013f, -0.31316417f, -0.15368898f, 0.50212705f, 0.13896789f, 0.27001634f, -0.31355619f, 
    0.34204781f, -0.03595457f, 0.08850863f, -0.02048341f, -0.18218870f, -0.11853090f, 0.31847942f, -0.19501464f, 
    0.10451663f, -0.29831937f, -0.34712636f, 0.08781652f, 0.08067860f, -0.23231897f, -0.65849084f, -0.01795894f, 
    -0.07561145f, -0.21087845f, 0.05923377f, 0.15180618f, 0.09287403f, -0.26965886f, -0.13225169f, 0.14885056f, 
    -0.33623135f, 0.04076193f, -0.08690797f, 0.07582040f, -0.41302419f, -0.13233545f, -0.14968397f, -0.00966628f, 
    -0.14756577f, 0.16359365f, -0.04964448f, -0.03480601f, 0.16671667f, -0.09353517f, -0.12604889f, -0.03957949f, 
    0.49972460f, 0.01345960f, 0.07260403f, -0.06808744f, 0.02614632f, 0.07504475f, -0.00574738f, 0.12870517f, 
    0.03511295f, 0.07108244f, -0.01462936f, 0.14168872f, 0.17350022f, -0.05890548f, -0.13600124f, 0.12141541f, 
    -0.02940009f, 0.11797523f, -0.46806604f, 0.22946885f, 0.10072507f, 0.56999451f, -0.25558838f, -0.01040225f, 
    0.22066016f, 0.06330677f, -0.05644431f, -0.08135484f, -0.08520223f, 0.11017998f, -0.00477563f, 0.09523825f, 
    0.10887142f, 0.12839273f, 0.10969831f, -0.14821027f, -0.20460282f, 0.03952061f, 0.11331023f, 0.01193438f, 
    -0.10267954f, -0.09009521f, 0.02233267f, -0.08584869f, -0.03012382f, -0.03222850f, -0.02350907f, 0.02050124f, 
    -0.04948894f, 0.06474217f, -0.05407197f, -0.01325949f, 0.05266863f, 0.04216515f, -0.08143326f, 0.01728019f, 
    -0.01713270f, -0.04991963f, 0.04015449f, -0.05346984f, -0.06053475f, 0.04900253f, -0.00942743f, -0.09963074f, 
    -0.06628905f, -0.00009280f, -0.02527910f, 0.05728317f, -0.00601032f, -0.04966862f, -0.03181635f, -0.03127138f, 
    0.03869711f, -0.00410626f, 0.04914115f, -0.07409645f, -0.06177208f, -0.10675139f, 0.01146102f, -0.04717927f, 
    -0.06236007f, 0.05253090f, -0.03885238f, 0.04650281f, -0.06887748f, -0.00774015f, -0.08640930f, -0.01425486f, 
    -0.09508161f, -0.03992626f, -0.06189490f, -0.07500470f, 0.01187100f, -0.09020764f, -0.02674659f, -0.02183668f, 
    0.01974613f, 0.04606792f, 0.01822566f, 0.03825617f, -0.00983172f, 0.02475844f, 0.06685203f, -0.02024824f, 
    0.04469130f, -0.12502444f, 0.03065340f, -0.10181969f, -0.05738233f, -0.06365521f, 0.00347218f, -0.01666749f, 
    -0.05410938f, 0.03839537f, -0.04438244f, -0.00609220f, 0.02606503f, 0.04022512f, -0.00079593f, 0.04691207f, 
    0.06899819f, -0.12152439f, -0.03651091f, 0.01010955f, 0.07531390f, 0.06973653f, 0.06581859f, 0.07856987f, 
    0.01082382f, -0.07933237f, -0.06216330f, -0.05457834f, -0.10758423f, 0.01022845f, 0.01846924f, -0.02080278f, 
    0.05436765f, -0.07135198f, -0.05569443f, 0.01985092f, -0.12557103f, -0.11611923f, 0.03091121f, 0.01747172f, 
    -0.08519837f, -0.07180104f, 0.03818957f, -0.08209473f, -0.03700298f, -0.05368441f, 0.01206370f, -0.06586052f, 
    -0.06242185f, -0.01278201f, -0.07537734f, -0.05556908f, -0.03643999f, -0.11478137f, -0.03241870f, 0.01397042f, 
    0.03836818f, -0.08200739f, 0.03180214f, -0.08493756f, 0.03824438f, -0.01885346f, 0.05621784f, -0.09119970f, 
    -0.12901968f, 0.03179675f, 0.00443770f, 0.19834527f, 0.13508402f, -0.09246806f, 0.14783768f, -0.00962930f, 
    -0.08269093f, 0.00044791f, 0.10219809f, 0.02691587f, -0.33911580f, 0.02178682f, 0.33652484f, -0.17762034f, 
    -0.04441636f, 0.07923624f, -0.41023976f, 0.30809262f, 0.01524596f, 0.08355168f, 0.00822898f, 0.06429006f, 
    0.14953592f, -0.00441249f, 0.06726573f, 0.15258870f, 0.00185939f, 0.05423392f, -0.03742933f, 0.11532709f, 
    -0.06655217f, -0.16724902f, -0.13851888f, 0.10610313f, 0.06085089f, 0.11849400f, 0.17966691f, 0.09649211f, 
    -0.00098898f, 0.20074771f, 0.21325415f, -0.13837415f, 0.22700191f, 0.12912713f, 0.32746351f, 0.08429527f, 
    -0.08607645f, -0.01904185f, 0.02042371f, -0.11076942f, 0.19998661f, -0.16560334f, 0.05000225f, -0.24615633f, 
    -0.04677295f, -0.03915011f, -0.08611752f, 0.07395033f, 0.10200985f, 0.06433970f, -0.38793266f, 0.00827741f, 
    -0.12555136f, 0.05618213f, 0.05509233f, -0.12424079f, 0.06685651f, -0.04366784f, -0.00579997f, 0.00762839f, 
    -0.09571397f, -0.05353557f, 0.08325925f, -0.04956390f, -0.19010377f, 0.16215128f, 0.08017512f, -0.24961174f, 
    0.01472888f, 0.13796681f, -0.04596722f, -0.24568307f, 0.01392227f, 0.03442946f, 0.02967345f, 0.01282396f, 
    0.04567354f, 0.01739496f, 0.01690306f, 0.07052777f, -0.02289800f, -0.03494370f, -0.17939231f, 0.05171529f, 
    0.07526932f, -0.00675903f, -0.10310184f, 0.12084980f, 0.06496501f, 0.10942250f, 0.04879335f, 0.23104490f, 
    0.07718749f, 0.11566071f, 0.05300970f, 0.18377469f, -0.09386072f, -0.63434553f, -0.03443375f, -0.02739145f, 
    -0.31440219f, 0.12023080f, 0.06394421f, -0.00818361f, -0.15759225f, 0.08667447f, -0.04671093f, -0.05675016f, 
    0.07871256f, 0.13406143f, -0.04167862f, -0.31518295f, -0.25331011f, -0.00487662f, 0.19413218f, 0.13969527f, 
    -0.03298059f, 0.00922766f, -0.02230135f, -0.00863409f, 0.05464449f, -0.02176906f, -0.05153705f, 0.07291090f, 
    0.03273264f, -0.04794162f, -0.09533972f, -0.06732165f, -0.01962048f, -0.09109280f, -0.05196451f, -0.02428758f, 
    0.02466640f, 0.05120261f, -0.05575772f, -0.04579961f, -0.01664098f, -0.03518351f, -0.07829683f, 0.01094546f, 
    -0.03395824f, -0.06157648f, -0.06709623f, -0.05574719f, -0.09686843f, 0.03418899f, -0.07749206f, -0.00021487f, 
    -0.10214484f, 0.01961139f, 0.06455820f, 0.05528570f, -0.05558151f, -0.00744291f, -0.06392914f, 0.02592484f, 
    -0.07194447f, -0.06790973f, 0.04109406f, -0.01628929f, -0.02263973f, 0.02364647f, 0.01068554f, -0.06193447f, 
    -0.07664301f, 0.04993445f, 0.00909823f, 0.04297593f, 0.01557161f, -0.02051092f, 0.06294540f, 0.05671107f, 
    -0.09177077f, -0.08661479f, -0.09161220f, -0.00480113f, -0.07278091f, -0.11239863f, 0.08029106f, 0.04348433f, 
    -0.05075623f, -0.04197313f, -0.02157255f, -0.08850268f, 0.07612215f, -0.04914881f, 0.00261011f, -0.05756573f, 
    -0.09322184f, 0.07973751f, 0.05757730f, 0.00490899f, -0.04654770f, 0.06154945f, 0.06267685f, 0.04033792f, 
    -0.05136237f, 0.04171389f, 0.02750968f, -0.06146988f, 0.05363806f, 0.04599314f, -0.04736286f, -0.04696601f, 
    -0.05992327f, -0.06549639f, 0.05683285f, -0.09735950f, -0.08598419f, 0.02415405f, -0.03249802f, -0.02406922f, 
    -0.04113189f, -0.04440325f, 0.07828706f, 0.04337654f, -0.01712358f, -0.03281743f, 0.05571019f, -0.05372127f, 
    0.05417442f, 0.02226855f, 0.01603001f, -0.05699298f, -0.03551135f, 0.00326991f, -0.04039720f, -0.06745479f, 
    0.01754696f, -0.01716083f, 0.01671137f, 0.00793899f, -0.12405597f, -0.04865898f, -0.01647211f, 0.00404120f, 
    -0.05405861f, -0.09823932f, -0.07200612f, -0.02608318f, -0.03709101f, 0.00666002f, 0.05363216f, 0.03858944f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09625487f, -0.01224381f, -0.07881257f, 0.21888269f, 0.23752201f, 0.12849383f, 0.11597459f, -0.18839435f, 
    -0.09086692f, -0.12023054f, -0.16875386f, -0.13472509f, -0.10109024f, -0.06473134f, 0.02332723f, -0.04578505f, 
    0.28643471f, -0.07799535f, 0.20781787f, 0.10196181f, 0.00833867f, -0.09764226f, 0.10702169f, -0.04125099f, 
    0.29833400f, -0.07705756f, -0.01194454f, -0.06111012f, 0.04322346f, -0.02074316f, 0.09473709f, 0.24880590f, 
    -0.01460171f, 0.00220934f, 0.04115286f, -0.04543458f, 0.10457946f, -0.05839649f, -0.11606298f, 0.02063390f, 
    -0.06506698f, 0.17460117f, 0.05233422f, 0.41855592f, 0.04095833f, -0.01747885f, 0.01626063f, -0.10035580f, 
    0.15288101f, 0.08698412f, -0.02689143f, -0.06321876f, -0.03229155f, -0.03433630f, -0.01156259f, -0.07306352f, 
    0.01045450f, 0.01168058f, 0.47705802f, 0.13461216f, -0.01021041f, 0.03088599f, 0.22960098f, 0.17359695f, 
    -0.03424581f, 0.08430493f, 0.10082236f, 0.15049483f, -0.21237646f, -0.10671692f, -0.01939593f, -0.07883313f, 
    0.18691343f, -0.00770543f, 0.04501818f, 0.16961940f, 0.09324057f, -0.05396055f, 0.27723888f, -0.07405629f, 
    -0.05889937f, -0.28462011f, -0.10528443f, 0.12669589f, 0.00332093f, -0.15660611f, -0.02252690f, 0.01579521f, 
    0.04951398f, 0.22953826f, -0.19139440f, -0.05314611f, 0.24330087f, -0.00199366f, 0.25215051f, 0.20475602f, 
    -0.07703115f, -0.02860615f, -0.00966112f, -0.14420378f, 0.00059048f, 0.12840369f, -0.00325278f, 0.28652531f, 
    -0.09052952f, -0.06412594f, 0.09899791f, 0.02904026f, -0.11158100f, 0.22324416f, 0.30043513f, 0.01373275f, 
    -0.02469075f, 0.43974102f, -0.07826560f, -0.07205750f, 0.09969568f, -0.10117985f, 0.01315858f, -0.00034296f, 
    0.06799237f, 0.00770372f, -0.04488296f, 0.03696306f, 0.41307545f, 0.02113070f, 0.08228352f, -0.02525149f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.00417512f, 0.00182033f, 0.02472398f, -0.52447522f, -0.30334616f, -0.39570019f, -0.17036533f, 0.14740723f, 
    -0.04895394f, -0.36444253f, -0.21348995f, -0.08887821f, 0.03074577f, 0.02174433f, 0.02058267f, 0.03427858f, 
    0.08710256f, -0.08324989f, -0.08378629f, -0.06671038f, 0.01403074f, -0.00670620f, -0.19635502f, 0.45587409f, 
    0.03473687f, -0.51643604f, 0.10533964f, 0.04386988f, -0.40351519f, -0.06588796f, -0.61852556f, -0.12162983f, 
    0.00523590f, -0.06617401f, 0.02402052f, 0.04661334f, 0.12055786f, -0.05186831f, 0.13631797f, -0.25467956f, 
    0.10157324f, -0.01515539f, -0.35841921f, -0.25849670f, -0.02115251f, -0.05527208f, -0.33543947f, 0.18009952f, 
    -0.33650544f, -0.08222321f, 0.14187740f, 0.01002266f, -0.07634142f, 0.05758398f, -0.09267052f, 0.00864369f, 
    -0.07188677f, -0.02963334f, -0.19248281f, -0.03584848f, 0.05210220f, -0.04583426f, 0.64220673f, -0.16144270f, 
    -0.02937549f, -0.12218922f, 0.11804299f, 0.06979138f, 0.20242460f, -0.06611762f, 0.12957518f, -0.03445522f, 
    -0.32668889f, -0.06380152f, -0.05827036f, 0.11913831f, -0.39164647f, 0.02948034f, 0.06145349f, 0.13825989f, 
    0.03511667f, 0.12962237f, -0.05419282f, -0.36813810f, 0.02713872f, -0.11931060f, -0.04466369f, 0.09410720f, 
    0.04263865f, -0.52042443f, -0.02203636f, -0.47449684f, -0.10566437f, -0.20005324f, 0.38554886f, 0.02525117f, 
    -0.01676674f, 0.04293348f, 0.06264652f, -0.25588357f, 0.00219465f, -0.21209025f, 0.03025497f, -0.71190280f, 
    -0.10362945f, 0.00369130f, 0.15772587f, -0.18879901f, -0.36949298f, -0.04021953f, 0.44039875f, -0.00910004f, 
    -0.10932542f, 0.45406538f, -0.31492844f, 0.03008269f, -0.08451983f, 0.08000597f, 0.03819435f, -0.00891507f, 
    0.00580309f, -0.43601596f, 0.12877932f, -0.03846789f, -0.15912952f, -0.11650796f, 0.00735252f, 0.08697870f, 
    -0.05540660f, -0.03418260f, 0.02208412f, 0.02759769f, 0.19702975f, 0.33336186f, -0.03105114f, -0.10502225f, 
    0.04983428f, -0.04893283f, -0.02475248f, -0.07074239f, -0.06803080f, 0.01888634f, -0.01675567f, 0.05997831f, 
    0.05382159f, -0.03519939f, -0.03721503f, -0.25166330f, -0.05633598f, 0.07048042f, 0.09182865f, 0.26088536f, 
    -0.01969541f, -0.15779665f, 0.07648992f, -0.03124458f, 0.28240609f, -0.01771027f, -0.31237444f, 0.20068523f, 
    -0.00757990f, 0.02003161f, 0.13641603f, 0.00045178f, -0.00366159f, 0.06623425f, -0.02485368f, -0.18420203f, 
    0.26941064f, -0.00884668f, 0.02808015f, 0.18821378f, 0.00912355f, -0.20770907f, 0.15831444f, -0.76990747f, 
    -0.34250167f, 0.28942171f, 0.08795848f, -0.04724501f, 0.02035454f, 0.05589354f, 0.01337552f, 0.01239851f, 
    -0.04438161f, 0.01452660f, 0.14265966f, -0.22065587f, -0.06485230f, -0.06205914f, -0.08637448f, 0.10216520f, 
    -0.08240061f, 0.06972551f, 0.01585951f, 0.06753651f, 0.11051260f, -0.01585374f, 0.02814646f, -0.02398173f, 
    0.01455618f, -0.05032318f, -0.00992197f, 0.08214927f, -0.15140641f, -0.04416586f, 0.10937759f, -0.05247819f, 
    0.09410676f, -0.60798132f, 0.01243150f, -0.52936733f, 0.01951638f, -0.07756207f, 0.05854521f, -0.30057532f, 
    -0.00494576f, 0.20520696f, -0.04430778f, -0.35438913f, 0.13493311f, 0.08046270f, -0.09315370f, 0.03314245f, 
    -0.03059171f, -0.04409630f, -0.03390853f, -0.30782956f, -0.94863594f, -0.53825217f, 0.21680757f, 0.31327966f, 
    0.01295670f, 0.07249359f, -0.01045874f, 0.12521967f, 0.13949104f, 0.08672603f, -0.37618303f, -0.07888564f, 
    -0.03640975f, 0.23653744f, -0.27803022f, -0.07472380f, -0.09783423f, -0.00431654f, -0.01643702f, 0.01964105f, 
    -0.26754043f, 0.10819050f, -0.37167200f, 0.04895261f, 0.23388377f, -0.01057707f, 0.05926733f, 0.06515328f, 
    -0.01079936f, 0.05800581f, 0.06104273f, 0.09012900f, 0.02154265f, -0.31526813f, 0.44291618f, -0.64302915f, 
    0.08835699f, -0.02391496f, -0.03710750f, -0.05116190f, -0.09562942f, -0.01629144f, -0.06320939f, -0.11600853f, 
    -0.13889956f, 0.04876602f, 0.22832090f, 0.33658150f, -0.03919293f, -0.16071679f, -0.19957750f, 0.19925982f, 
    -0.20501669f, 0.12562549f, -0.04478654f, -0.06631743f, -0.59164286f, -0.08785669f, 0.18200234f, 0.11540314f, 
    -0.04251716f, -0.09880412f, -0.03726832f, 0.06296859f, 0.50612849f, -0.04277764f, -0.29075223f, 0.01126692f, 
    -0.48999885f, -0.03560890f, -0.10001501f, -0.09669159f, -0.02132927f, 0.11933663f, 0.17581034f, -0.51154721f, 
    -0.05479857f, -0.16902974f, -0.16881314f, 0.08081177f, -0.09422909f, -0.01203020f, 0.09961484f, 0.01250360f, 
    0.03264267f, 0.00080585f, 0.01299564f, 0.02593319f, -0.01183176f, 0.03597623f, 0.15645386f, 0.12340453f, 
    -0.03618866f, 0.31803140f, -0.67409319f, -0.22017956f, 0.11034763f, -0.00599076f, -0.50492471f, 0.00609741f, 
    0.12015937f, -0.07423341f, -0.07251202f, -0.33071479f, -0.04728158f, -0.01022321f, -0.12710114f, -0.04309438f, 
    -0.53092593f, -0.32840699f, -0.01579527f, 0.04285577f, 0.02535669f, 0.06278867f, 0.03304704f, -0.06822320f, 
    -0.09465301f, -0.07110538f, 0.09863320f, -0.04126232f, -0.29456154f, -0.13219187f, 0.15246837f, -0.12647043f, 
    -0.11260009f, -0.06884611f, 0.05358771f, 0.19050917f, 0.20730194f, 0.37494203f, 0.19008091f, -0.26290500f, 
    -0.04774940f, -0.03554125f, -0.68334180f, 0.24822606f, 0.11733643f, -0.48692879f, 0.14019665f, -0.07731304f, 
    -0.07091400f, 0.16421269f, 0.18313108f, -0.04187115f, -0.48477685f, 0.02172274f, -0.00625378f, -0.06876248f, 
    -0.19824243f, -0.03037174f, -0.11374877f, 0.05020740f, -0.37213349f, -0.09885278f, -0.10476176f, 0.07643488f, 
    0.05283306f, 0.04185588f, 0.06889950f, -0.04387346f, -0.06922757f, -0.82564837f, 0.19913276f, -0.08769439f, 
    -0.02590119f, -0.26106504f, 0.16113856f, 0.00000806f, -0.04701933f, -0.01966714f, 0.05547810f, -0.09166383f, 
    0.12263788f, -0.06203577f, -0.06397253f, -0.01368353f, 0.01785370f, -0.40275162f, -0.72684711f, 0.31479445f, 
    0.07646427f, -0.22966605f, 0.08933363f, 0.05459384f, -0.42210233f, -0.00079137f, 0.12960234f, 0.13878097f, 
    0.00698812f, -0.01504959f, -0.31262308f, 0.07476950f, 0.21960384f, -0.06942961f, 0.06914271f, -0.01863796f, 
    0.04112401f, 0.10534392f, -0.12805638f, 0.00294806f, -0.02319459f, 0.02148127f, -0.25393555f, 0.17867692f, 
    -0.10479351f, -0.62406951f, -0.02575031f, -0.08929018f, -0.06179602f, 0.02788637f, -0.47924721f, 0.07497952f, 
    0.03237779f, -0.01684041f, 0.07909378f, -0.03838766f, -0.03060818f, 0.03311681f, -0.60048544f, -0.03631231f, 
    -0.08678354f, 0.04486777f, 0.10833515f, -0.03000683f, 0.03348470f, -0.07237022f, 0.10197668f, 0.02001713f, 
    -0.03450373f, -0.00256180f, -0.00295832f, 0.03142782f, 0.07323620f, 0.03824260f, 0.00985529f, -0.02631952f, 
    -0.58153695f, -0.18312056f, -0.03787966f, 0.11168514f, -0.02175231f, 0.42278340f, -0.07740179f, 0.01669164f, 
    0.06664237f, 0.24593151f, -0.53494757f, 0.10393950f, -0.06076805f, -0.69105506f, 0.16738266f, 0.12094788f, 
    0.12173419f, -0.00460550f, -0.03784480f, -0.44584644f, 0.13565800f, 0.20008379f, 0.02521812f, -0.35388857f, 
    0.01910444f, -0.04017713f, -0.06877017f, 0.02396739f, -0.15622747f, -0.03516973f, 0.06942848f, 0.01429187f, 
    -0.00460073f, -0.25977331f, -0.01998596f, -0.09545008f, -0.01665873f, 0.00245712f, -0.01604541f, 0.07169927f, 
    0.07294789f, -0.02511574f, 0.10033832f, 0.06835737f, -0.50505590f, -0.11953629f, -0.12825555f, 0.02737724f, 
    -0.00741733f, 0.01321694f, -0.02912010f, 0.01778220f, -0.41117445f, -0.43341690f, -0.08629263f, 0.11833986f, 
    -0.05724228f, 0.00124998f, 0.09533356f, 0.02900951f, -0.03195854f, -0.11454494f, 0.06363954f, -0.04151559f, 
    0.01539512f, -0.01029365f, -0.74574333f, 0.18205115f, -0.08651278f, 0.12723921f, 0.05707792f, -0.76634496f, 
    0.02354703f, -0.10993176f, 0.13415980f, 0.04850381f, -0.44309512f, 0.01152812f, 0.04054387f, 0.11908983f, 
    0.01591199f, -0.06118007f, 0.09928463f, -0.05332057f, -0.59867364f, -0.05669558f, -0.01734705f, -0.28008279f, 
    -0.00886001f, 0.07137634f, -0.03703945f, 0.10567124f, -0.04196041f, 0.12666966f, -0.04206244f, 0.08291908f, 
    0.08385549f, -0.10977078f, 0.05765060f, 0.02214697f, -0.06262571f, -0.11897208f, -0.09645607f, -0.06634390f, 
    0.02641185f, -0.07838614f, 0.04379836f, -0.46685341f, 0.05883874f, -0.04755015f, -0.12828936f, 0.06344958f, 
    0.05369007f, 0.11403251f, 0.06986113f, 0.16608389f, 0.06453067f, -0.07280493f, -0.04438374f, -0.04885026f, 
    -0.03582598f, 0.01475014f, 0.05056453f, 0.12160636f, 0.13786508f, 0.04083555f, 0.10665137f, 0.02336724f, 
    0.17030014f, 0.24944611f, -0.03255617f, -0.04619393f, -0.05788650f, 0.06127961f, 0.02869984f, 0.16874695f, 
    0.07544513f, -0.78370678f, 0.02231624f, -0.13749415f, 0.21219109f, 0.10113209f, -0.34487376f, 0.13945696f, 
    -0.11445095f, -0.02418861f, -0.09619286f, -0.06217026f, -0.01795319f, 0.01008067f, -0.11693890f, -0.55556232f, 
    0.06450327f, -0.02483713f, 0.01830076f, -0.60428506f, -0.16755421f, 0.14710395f, -0.83358306f, 0.04901890f, 
    -0.07636713f, -0.53804028f, 0.06679810f, -0.06115634f, 0.22918926f, 0.01981443f, 0.03724862f, -0.00798757f, 
    0.09510689f, -0.38554773f, 0.00870533f, -0.03732304f, 0.06639840f, -0.09828244f, 0.06308171f, 0.07497942f, 
    -0.08306202f, 0.00118234f, -0.02491910f, 0.03854218f, 0.16789244f, 0.09277301f, 0.22007406f, 0.01854563f, 
    0.05662052f, 0.02412437f, 0.10354223f, 0.00513920f, -0.09805987f, -0.01353731f, 0.06785180f, -0.03384484f, 
    0.00619521f, -0.06493559f, -0.01986258f, 0.00689813f, 0.00494458f, 0.08345944f, -0.33345717f, -0.45863557f, 
    0.01134121f, 0.26894882f, 0.08644976f, 0.00125865f, -0.41123679f, -0.05512676f, 0.18591709f, -0.24861626f, 
    0.04888852f, -0.03470054f, -0.03336627f, 0.06759754f, -0.35992762f, -0.05186297f, -0.08300150f, 0.07192479f, 
    0.11124106f, 0.07738426f, -0.04250053f, 0.12427354f, 0.04817692f, 0.11721282f, 0.11361728f, -0.06974151f, 
    -0.06777283f, 0.03558703f, -0.09704498f, -0.06001662f, 0.06221367f, -0.11075407f, -0.05247062f, -0.08668909f, 
    -0.00200471f, -0.03418406f, 0.00228118f, 0.11020864f, -0.05277200f, 0.03405269f, -0.29598954f, -0.39496908f, 
    0.05393290f, 0.17618659f, 0.15858956f, 0.05420765f, 0.00784869f, 0.06261016f, 0.07029103f, -0.04258045f, 
    0.07544767f, 0.02894238f, 0.01744437f, 0.05608939f, 0.12777597f, -0.09151728f, 0.08184148f, -0.01801468f, 
    0.00727955f, 0.04576840f, 0.00356385f, -0.53719181f, -0.11943918f, -0.17945154f, 0.04110631f, -0.28225639f, 
    0.17987776f, -0.34362766f, 0.08414467f, 0.02473296f, -0.21842554f, 0.15600637f, -0.57002217f, 0.06731661f, 
    0.01874823f, -0.07268036f, -0.00229345f, 0.23621854f, -0.29014835f, -0.56391770f, 0.12624525f, -0.19194686f, 
    0.02853724f, 0.00860082f, -0.01594175f, 0.01910983f, 0.12098309f, 0.11674840f, 0.04795302f, -0.04609901f, 
    -0.06059344f, -0.20680010f, -0.08691779f, -0.05153224f, 0.05546865f, 0.04619682f, -0.01842555f, -0.06482104f, 
    0.03458628f, 0.27041245f, -0.07284179f, -0.03782333f, -0.00481979f, -0.01063485f, -0.02358701f, 0.02654483f, 
    -0.03997396f, 0.02365131f, 0.09684582f, -0.10198638f, 0.11979393f, 0.15693864f, -0.43279293f, -0.30384764f, 
    0.07036426f, 0.06090839f, -0.25559816f, -0.08249141f, -0.03450185f, -0.02202851f, 0.00175251f, -0.10560604f, 
    -0.63629264f, -0.05593899f, 0.13019453f, 0.04711684f, -0.06572336f, -0.10618202f, 0.09603030f, -0.12221146f, 
    -0.86265051f, -0.15202731f, -0.78509009f, 0.06462227f, 0.23429832f, -0.04941161f, 0.03960633f, 0.02771136f, 
    -0.05476128f, 0.07470357f, 0.06979007f, -0.06158784f, 0.40620840f, 0.03028146f, -0.04427096f, 0.16377200f, 
    -0.56870568f, -0.30680081f, -0.17382050f, -0.71833944f, 0.00084043f, -0.00580384f, 0.15795608f, -0.33836839f, 
    0.06049538f, -0.08367420f, 0.08085500f, -0.03079330f, 0.06858201f, 0.07004995f, -0.17507283f, 0.05486317f, 
    -0.10175475f, -0.01119877f, -0.82897305f, 0.13397947f, -0.01037196f, 0.03656928f, 0.30989927f, 0.07807399f, 
    -0.00168209f, -0.82563502f, -0.16566400f, -0.40350232f, -0.11615021f, -0.02464661f, -0.16296743f, 0.02768813f, 
    -0.03256973f, -0.06824462f, -0.03283173f, -0.40351716f, -0.30833843f, -0.08099206f, -0.43235016f, 0.07203285f, 
    0.02670836f, 0.06950550f, -0.10402592f, 0.21202378f, -0.03537045f, 0.10351269f, 0.01558766f, 0.15587480f, 
    -1.05537796f, 0.03709109f, -0.02129544f, 0.01419420f, 0.06415409f, 0.15036242f, 0.24070507f, -0.90081853f, 
    -0.14253196f, -0.03782275f, 0.00083481f, 0.14734176f, 0.15479432f, 0.26498020f, 0.03461206f, 0.05493841f, 
    -0.00277583f, 0.06006855f, -0.37415490f, 0.35493991f, 0.02486448f, -0.43581989f, 0.05341722f, 0.04481149f, 
    0.02214800f, 0.16743284f, 0.22674441f, -0.05157280f, -0.30801749f, 0.00656762f, 0.01777285f, 0.05286342f, 
    0.19155274f, -0.25664365f, -0.45672107f, 0.03304529f, -0.17505336f, -0.03847548f, -0.03440822f, -0.04552145f, 
    -0.01414298f, -0.02479141f, 0.05852750f, -0.32580060f, -0.63237506f, 0.08664825f, -0.26338455f, 0.11750913f, 
    0.07846478f, 0.07482292f, 0.02065165f, -0.05612781f, 0.06438293f, -0.01642544f, -0.07588242f, -0.05667883f, 
    0.24833566f, -0.08835633f, -0.50612551f, -0.37765574f, -0.03411070f, 0.02785734f, 0.17355274f, -0.75754488f, 
    -0.37255928f, -0.23849839f, -0.47475922f, -0.03390170f, 0.13553864f, 0.05050936f, -0.10863090f, -0.31233832f, 
    0.03245952f, -0.09281100f, 0.06327944f, 0.05823681f, -0.53761804f, -0.09014384f, 0.15197091f, -0.07289410f, 
    -0.47851521f, -0.48794380f, -0.00451314f, -0.73365116f, 0.00873744f, 0.35081846f, -0.24887480f, 0.51679742f, 
    -0.18583767f, -0.23190184f, 0.18336661f, 0.02039594f, 0.02044561f, 0.01614482f, -0.11969003f, 0.06841469f, 
    -0.04326627f, -0.08777647f, -0.62479442f, -0.13962661f, 0.02868146f, -0.00124162f, -0.51170433f, 0.12182071f, 
    -0.05255842f, -0.15568160f, -0.26733953f, 0.12146047f, 0.06463630f, 0.02617844f, -0.27554893f, 0.02805534f, 
    0.12324373f, -0.06035649f, 0.05265210f, 0.16705549f, -0.27284554f, -0.06040325f, 0.09434849f, -0.02588138f, 
    0.14386398f, 0.23202829f, -0.09900095f, 0.06038829f, -0.07129217f, 0.05086685f, -0.04020585f, 0.13633360f, 
    -0.32538772f, -0.00009284f, 0.22652638f, -0.16474743f, 0.04651451f, 0.13571224f, 0.11251368f, -0.44281042f, 
    0.09479593f, -0.07821089f, -0.04860874f, 0.06731986f, 0.16476679f, 0.00797303f, -0.16212757f, -0.04324576f, 
    -0.05884377f, -0.03485338f, 0.26841021f, -0.31486657f, 0.07438355f, 0.00300799f, -0.37488729f, -0.00925325f, 
    -0.00947423f, -0.36461765f, 0.00575957f, -0.00548712f, 0.08441850f, -0.06541774f, 0.00230731f, 0.04795971f, 
    -0.26919442f, -0.31520510f, 0.22160378f, 0.00560633f, -0.18489331f, -0.04233588f, 0.00250314f, 0.05629973f, 
    0.04964329f, -0.11985992f, -0.07194477f, 0.22902817f, 0.53653783f, -0.11526735f, -0.41826048f, 0.18213883f, 
    0.07144219f, 0.11305798f, 0.00877486f, -0.11861881f, -0.03048465f, 0.01872159f, -0.07927381f, -0.02675271f, 
    -0.63696462f, -0.08457313f, 0.22850928f, -0.15910433f, 0.05566371f, -0.05200606f, -0.10114624f, -0.30887148f, 
    -0.15971920f, 0.16299003f, -0.77111995f, 0.09344711f, -0.15292132f, 0.05179315f, 0.03788923f, -0.15801013f, 
    0.02288075f, 0.05434793f, 0.10820516f, -0.08337608f, -0.03732371f, -0.03562716f, -0.71010393f, 0.01174501f, 
    -0.20520520f, 0.13488822f, 0.28024200f, 0.15862842f, -0.01724966f, -0.71591747f, -0.19852242f, -0.24182644f, 
    -0.32202902f, 0.20407610f, 0.13111439f, 0.04521135f, 0.00535844f, 0.04089451f, 0.06714259f, 0.03488049f, 
    -0.06037234f, -0.02725990f, -0.00728152f, 0.03305426f, 0.01614383f, -0.07806092f, 0.14890754f, 0.18498042f, 
    -0.03388938f, -0.61957860f, -0.98246771f, 0.08596780f, -0.20370650f, 0.04247913f, -0.62488741f, -0.00322772f, 
    -0.36372146f, -0.01834919f, -0.01485174f, 0.20493205f, 0.02063444f, 0.04003316f, 0.08639011f, 0.00872699f, 
    0.35413745f, -0.14413150f, 0.01765129f, 0.07460517f, -0.00210577f, -0.25932896f, -0.02809319f, 0.09205321f, 
    -0.35433438f, -0.13777104f, -0.61018950f, 0.06714149f, -0.17092656f, -0.06176012f, -0.43200412f, -0.08578118f, 
    0.27112526f, 0.06800584f, 0.05116974f, 0.23583178f, -0.16507219f, 0.01277597f, -0.31612849f, 0.00290101f, 
    -0.04487492f, 0.06246784f, -0.27213100f, 0.28894299f, 0.17352025f, -0.16749766f, 0.04772819f, 0.04071121f, 
    0.00405938f, 0.12433723f, -0.00476525f, -0.04397841f, 0.02026253f, 0.08552195f, 0.00777491f, 0.01525163f, 
    0.10469981f, 0.13218981f, -0.94259071f, 0.06776692f, -0.05742430f, 0.00474646f, 0.22676092f, 0.05509740f, 
    -0.07007029f, 0.01699538f, -0.00045790f, 0.19100642f, -0.57152069f, 0.12694067f, -0.03614150f, -0.40205494f, 
    -0.01632525f, 0.01164762f, -0.23391555f, -0.06213995f, 0.06804188f, 0.01586724f, -0.05198868f, -0.06289309f, 
    -0.13693117f, 0.00324141f, -0.01058859f, -0.15114143f, -0.02910455f, -0.24783547f, 0.10518916f, 0.12268606f, 
    -0.10750182f, -0.12816957f, 0.07660387f, 0.03393891f, 0.04766158f, -0.01599756f, -0.09479581f, 0.38894105f, 
    0.05633847f, -0.06874646f, 0.05076678f, 0.05352955f, -0.15134890f, -0.01878354f, 0.14129156f, 0.00031710f, 
    -0.35274595f, 0.15186575f, -0.44637513f, 0.02371102f, 0.06588464f, -0.15512404f, 0.01549063f, -0.11484057f, 
    0.13142897f, -0.20426378f, -0.17086338f, -0.02985806f, 0.03832013f, 0.04571113f, -0.03581160f, 0.06061627f, 
    0.03234662f, -0.08304210f, -0.06660584f, 0.00899939f, 0.04499162f, -0.07518693f, 0.04728439f, 0.01199081f, 
    -0.02027567f, -0.19069052f, -0.04594108f, -0.15192063f, -0.68496901f, -0.09705339f, -0.23789823f, -0.11877966f, 
    0.20011127f, -0.10123941f, 0.05629580f, -0.35826740f, -0.06328034f, -0.10790937f, -0.09065212f, -0.35993370f, 
    -0.41935587f, -0.10623975f, 0.05891629f, 0.14695197f, -0.03730159f, 0.13502778f, 0.06643947f, 0.12952508f, 
    -0.07036082f, -0.22958086f, -0.07471926f, -0.06746692f, 0.21944925f, -0.02608835f, 0.15530597f, -0.12701894f, 
    -0.20337795f, 0.02790024f, 0.01564144f, -0.14608666f, 0.20720090f, 0.07216843f, 0.03690027f, 0.17165715f, 
    -0.03629967f, 0.00771476f, -0.31017688f, -0.27790147f, -0.15062994f, 0.14910108f, 0.07924157f, -0.08103329f, 
    0.03383124f, 0.20955490f, -0.11723220f, -0.08729783f, 0.03197722f, 0.02518140f, 0.00685205f, 0.04619762f, 
    0.05087728f, -0.11850995f, -0.21986598f, -0.03052169f, 0.35093397f, -0.11053043f, -0.49728006f, -0.09385991f, 
    0.03682890f, 0.03016183f, 0.03214906f, -0.00600199f, 0.02963791f, -0.52917296f, -0.30597067f, 0.00615701f, 
    0.00388467f, -0.22081323f, -0.76181400f, -0.02131904f, -0.02703057f, 0.00632757f, 0.08047169f, -0.03126568f, 
    0.04353689f, 0.02395521f, -0.12298018f, -0.15154758f, -0.08390571f, -0.80930847f, -0.16239323f, -0.01898105f, 
    0.05146956f, -0.04414372f, -0.31872115f, 0.04932840f, -0.24876253f, 0.07139585f, 0.10465704f, -0.25837433f, 
    -0.02502268f, 0.02922091f, -0.56151223f, 0.04503011f, -0.11674815f, 0.02696994f, -0.84979045f, 0.12716639f, 
    -0.65015948f, -0.12383436f, 0.08234321f, 0.21970110f, -0.09114023f, -0.22486784f, 0.00483723f, -0.26643935f, 
    0.26324758f, 0.08977791f, -0.52014959f, 0.05524598f, 0.04007279f, 0.01252103f, -1.34066021f, -0.07518466f, 
    0.04066135f, 0.06885166f, 0.24829343f, -0.07295895f, 0.06336676f, 0.06270640f, 0.21202978f, -0.36144766f, 
    -0.07984775f, -0.30527878f, 0.21210530f, 0.12294343f, -0.31309536f, 0.05900895f, -0.53799880f, -0.00031188f, 
    -0.14212318f, -0.05536536f, 0.00925941f, 0.13980097f, 0.32186559f, -0.00998271f, 0.16056871f, 0.25564378f, 
    -0.04983432f, -0.22122136f, -0.04509703f, -0.16884163f, 0.08695389f, -0.42260641f, -0.08250856f, -0.01942627f, 
    -0.04309122f, 0.01352022f, -0.34779462f, -0.00401401f, 0.18147467f, -0.56276411f, -0.23082280f, 0.25853932f, 
    -0.41285792f, -0.02206427f, 0.05593865f, -0.30155113f, -0.50902712f, -0.25034231f, -0.70252991f, -0.18057260f, 
    -0.06417586f, -0.07053818f, 0.43130833f, -0.45796323f, -0.38211977f, 0.08629335f, 0.22839543f, -0.02194601f, 
    -0.02257792f, 0.08391307f, 0.06164199f, -0.04390776f, 0.32009450f, 0.02986668f, -0.03997086f, -0.00849434f, 
    0.34012774f, -0.07987860f, 0.28997573f, 0.04966684f, 0.25934231f, -0.05114159f, 0.18932787f, 0.00790173f, 
    0.03532686f, 0.06435757f, -0.01023544f, -0.30232909f, -0.82188129f, 0.00460263f, -0.22463061f, 0.27559155f, 
    -0.03610590f, 0.10763329f, 0.11757573f, 0.05806009f, -0.03083450f, -0.07759468f, -0.02092040f, -0.05487940f, 
    -0.16393937f, -0.05251775f, -0.05298049f, -0.43229225f, -0.00383437f, 0.03326513f, 0.16451761f, -0.25664842f, 
    -0.36338651f, 0.26645231f, 0.08785941f, 0.05954077f, -0.15687931f, -0.03239545f, -0.06477552f, -0.58966649f, 
    -0.01113932f, -0.06999139f, -0.25848204f, -0.08437910f, -0.48537639f, 0.03940375f, -0.23341857f, 0.13353088f, 
    -0.73549652f, -0.58034438f, 0.04811854f, -0.06726013f, -0.08365614f, 0.02565811f, -0.01962786f, -0.86144930f, 
    0.17600536f, -0.02983966f, -0.41253707f, -0.05424333f, -0.07698932f, 0.01571744f, 0.05116320f, 0.04262817f, 
    -0.00715434f, 0.00559729f, -0.24402329f, 0.06154798f, 0.06779312f, -0.05423717f, -0.08122505f, -0.10068686f, 
    -0.06479191f, -0.11406348f, -0.41526854f, -0.18664251f, -0.25175464f, 0.01968494f, -0.52454704f, -0.04661075f, 
    0.05131293f, -0.06658197f, -0.08641328f, -0.24613315f, 0.19758482f, 0.05199771f, -0.32592157f, -0.67492634f, 
    -0.00018105f, 0.08339942f, 0.04514875f, 0.03236733f, -0.05021828f, -0.37777573f, -0.04070170f, -0.07952018f, 
    0.15140988f, 0.29575577f, -0.26800478f, 0.15153407f, 0.09184667f, 0.04272057f, 0.16252106f, -0.14833823f, 
    -0.14392772f, -0.01590425f, 0.00880364f, 0.23098919f, -0.01404428f, -0.12931590f, -0.19279125f, 0.18173762f, 
    -0.07501722f, -0.01247738f, 0.38973865f, -0.05355518f, 0.21683504f, -0.32282728f, 0.20433131f, -0.01350456f, 
    0.04674063f, 0.01290748f, 0.16821568f, -0.03715279f, 0.16129521f, 0.04512106f, 0.00732612f, 0.05697414f, 
    -0.11166600f, 0.25419915f, -0.44710714f, -0.06642251f, -0.05993416f, -0.02109304f, 0.07910571f, 0.02822909f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.27063495f, 0.17111173f, -0.11147983f, 0.00613725f, -0.11730281f, -0.13584414f, -0.13307531f, -0.08867228f, 
    -0.01722217f, 0.10062725f, 0.31143761f, -0.12645324f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
