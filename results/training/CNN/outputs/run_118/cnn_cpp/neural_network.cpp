#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.61826742f, -0.88849670f, -0.82585150f, -0.36042035f, -0.11455781f, -0.05107235f, -0.02678097f, 0.32995212f, 
    0.32790202f, -0.05928627f, -0.71695602f, -0.19902141f, 0.68786663f, -0.08124905f, 0.48314798f, -0.09923028f, 
    -0.28234681f, -0.23264411f, -0.82990986f, 0.00342250f, -0.49508050f, 0.61119586f, -0.50504076f, 0.12264670f, 
    0.07183968f, 0.11520084f, -0.05614983f, -1.11505449f, -0.18449286f, -0.75003904f, -0.02957744f, 0.79485464f, 
    0.68917352f, 0.05298249f, -0.20750801f, -0.19447677f, 0.44995472f, 0.72877544f, 0.47120506f, -0.93181437f, 
    -0.69311339f, -0.53035182f, -0.12457924f, 0.09348953f, 0.01147932f, 0.63740164f, -0.08616970f, 0.83978552f, 
    0.67676753f, -0.72535706f, 0.22174738f, 0.08493443f, -0.17823246f, -0.22830448f, 0.35352659f, 0.61125284f, 
    0.65953451f, -0.17362219f, -0.46736571f, 0.69208735f, 0.12161349f, 0.21363260f, 0.03943684f, -0.98578411f, 
    0.84906220f, -0.27157375f, -0.37903273f, 0.19107854f, -0.36165392f, -0.15196793f, -0.03796890f, 0.21876641f, 
    0.62606239f, -0.50939184f, -0.43751481f, -0.20930532f, -0.53873742f, -0.45979089f, -0.36853060f, 0.13231531f, 
    -0.30741793f, 1.02610683f, 0.69306934f, 0.25648350f, 0.39563280f, 0.34681740f, -0.08021054f, 0.09007334f, 
    0.04378014f, -0.12307483f, 0.27801082f, 0.52076256f, 0.32884681f, 0.11052242f, -0.10184319f, -0.27820721f, 
    0.45343527f, 0.39835405f, 0.67314875f, -0.74295557f, -0.32670057f, 0.25359830f, 0.19606687f, 0.86779463f, 
    -0.50247246f, 0.12347551f, 0.13698848f, -0.23318848f, 0.25531140f, -0.55065811f, 0.10736385f, -0.95488918f, 
    -0.25957811f, 0.15332043f, 0.04930786f, 0.21636818f, 0.43665910f, -0.27833772f, -0.16747697f, -0.59905279f, 
    -0.06293765f, -0.51916140f, -0.16879845f, -0.82033515f, -0.19442947f, 0.07098856f, -0.70402604f, -0.36047900f, 
    0.35624105f, -0.08483623f, -0.58827531f, -0.37826011f, 0.53755391f, 0.35414803f, 0.09325491f, -0.72996169f, 
    -0.54742527f, -0.19365767f, -0.33811235f, -0.34834638f, 0.09339719f, -0.02699740f, -0.31299064f, 0.02552496f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.21705344f, -0.25259182f, -0.15179189f, 0.11804529f, 0.12284920f, 0.08353399f, 0.10897669f, 0.12405069f, 
    0.15365136f, 0.31044367f, -0.47117791f, -0.30965829f, 0.07665136f, 0.02921396f, 0.18914151f, -0.24059881f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03978092f, -0.05010697f, -0.11992057f, 0.04280986f, 0.02073363f, -0.06271897f, -0.08247903f, -0.13238224f, 
    -0.14449315f, -0.05126003f, -0.04194837f, -0.09041584f, 0.00348192f, 0.02374611f, 0.01436040f, -0.02154142f, 
    -0.08865594f, 0.05946111f, -0.02291150f, -0.01280386f, -0.12045047f, -0.02001971f, -0.03741430f, 0.05221230f, 
    -0.12829864f, -0.12916298f, -0.04090014f, 0.02471594f, -0.05120204f, -0.03878605f, -0.10408024f, -0.06370875f, 
    -0.09078936f, -0.02117508f, -0.12684873f, -0.11596775f, 0.03246763f, -0.02749883f, -0.07120264f, -0.03539808f, 
    -0.13185929f, -0.00307341f, 0.01635562f, -0.01637063f, -0.03744293f, -0.01529732f, -0.05606683f, -0.07744171f, 
    -0.01819141f, -0.01619411f, -0.06679278f, 0.00219045f, -0.01995267f, 0.02662298f, 0.06446752f, -0.01255072f, 
    -0.00862600f, -0.06108439f, -0.10443458f, -0.03085240f, -0.01893823f, 0.05085999f, 0.02519222f, 0.02554159f, 
    -0.11122385f, -0.06627611f, -0.01477987f, -0.00849802f, 0.02403570f, -0.02819338f, -0.06029356f, -0.02589002f, 
    -0.01173871f, -0.06079394f, -0.07019358f, -0.10488077f, 0.00585772f, 0.01491419f, -0.00169361f, 0.02051369f, 
    -0.07517785f, -0.01760691f, -0.07526629f, 0.06103273f, -0.00282755f, 0.03202885f, -0.07965877f, -0.03396669f, 
    0.01231738f, 0.06099289f, 0.06471004f, 0.01191835f, -0.07050260f, -0.11509757f, 0.05646844f, 0.00929641f, 
    0.03329133f, 0.01056092f, 0.03333710f, -0.05440246f, -0.02910866f, -0.09779561f, -0.09310203f, 0.03744341f, 
    -0.03732101f, 0.00500741f, -0.03432316f, 0.02549345f, -0.00013931f, -0.10765029f, -0.05991891f, -0.06634464f, 
    -0.09854544f, -0.09149672f, -0.00198177f, -0.11909439f, 0.03120366f, -0.15303442f, -0.04321755f, -0.01611194f, 
    -0.09587835f, -0.11129244f, -0.14225101f, -0.05296179f, 0.01359036f, 0.02376771f, -0.02807240f, 0.04938675f, 
    -0.11526459f, -0.09470968f, 0.02808471f, -0.04184433f, -0.15525909f, -0.05939241f, -0.01935650f, -0.17561521f, 
    -0.16074666f, -0.14018029f, -0.00764741f, -0.04130553f, -0.08702662f, -0.11674167f, 0.00450373f, 0.01799398f, 
    0.05199764f, -0.04609641f, 0.52360570f, -0.02232537f, -0.02034011f, -0.09861252f, -0.12973756f, -0.12417935f, 
    -0.06800989f, 0.18593700f, -0.33024964f, 0.04830864f, -0.07991321f, 0.06011362f, 0.09845425f, -0.13634498f, 
    -0.09703819f, 0.13292375f, -0.43590039f, -0.11311758f, 0.22418310f, 0.04040405f, 0.04726015f, 0.05063651f, 
    0.02771111f, 0.13343294f, -0.03454776f, -0.48364145f, -0.16127804f, 0.19313279f, 0.03357924f, -0.04987700f, 
    0.10921185f, -0.05552167f, 0.13334846f, 0.04798192f, -0.22383702f, 0.22453947f, -0.26411596f, 0.11149359f, 
    0.01519660f, -0.07252440f, 0.04087261f, 0.09719542f, -0.12899548f, 0.02647290f, -0.08004200f, -0.32398063f, 
    0.07901295f, 0.17526901f, -0.07336902f, 0.00458319f, 0.12265145f, -0.01860912f, -0.35950726f, 0.27603218f, 
    0.06282958f, 0.14137653f, 0.08750068f, -0.02082105f, 0.06326821f, -0.00393827f, 0.11513343f, -0.46387362f, 
    0.19867505f, 0.06722935f, 0.20448628f, 0.06337795f, 0.00263795f, 0.02630701f, -0.05788546f, 0.06530977f, 
    0.20645943f, 0.01504678f, -0.17472063f, 0.10760900f, 0.10323852f, -0.01122832f, 0.06326514f, -0.00849647f, 
    0.09273525f, 0.44171688f, 0.17971830f, 0.10313969f, -0.08173018f, -0.07158912f, -0.15145124f, 0.13446935f, 
    0.02308879f, 0.00055153f, 0.15491891f, 0.09536561f, -0.13721456f, -0.11608488f, -0.21889138f, -0.02756406f, 
    0.00681139f, -0.17695457f, 0.06912465f, -0.31574661f, -0.12653424f, -0.27679923f, 0.02155723f, -0.03289938f, 
    -0.07607740f, -0.06425425f, -0.01477971f, -0.07437905f, 0.16396043f, -0.16212410f, -0.19439736f, 0.08115544f, 
    -0.04838962f, 0.14371106f, 0.11883032f, -0.07175042f, 0.01257068f, -0.16550437f, 0.13750170f, -0.03588183f, 
    -0.11089394f, -0.04529083f, 0.05811689f, 0.02084376f, 0.02554732f, 0.09375963f, 0.11725700f, -0.08631737f, 
    -0.00846307f, 0.00717806f, -0.08855907f, -0.04533665f, -0.05078071f, 0.08259536f, -0.14063431f, 0.24078865f, 
    -0.30006152f, -0.03050436f, 0.17878082f, -0.05256950f, -0.11069666f, 0.03977981f, -0.03252225f, 0.19315243f, 
    -0.24476671f, -0.18901442f, -0.04110124f, 0.04962860f, -0.10003407f, 0.00069469f, -0.08097284f, -0.03511971f, 
    0.08953672f, 0.32732296f, 0.00067739f, -0.29210377f, 0.08983212f, -0.23888735f, -0.11488121f, 0.04328572f, 
    -0.02312578f, -0.06139180f, -0.68043083f, -0.00698774f, 0.16631900f, 0.09712790f, 0.08503914f, 0.12598413f, 
    -0.09979417f, -0.00327463f, 0.20197962f, 0.09888994f, -0.31796646f, 0.02410359f, -0.07168349f, -0.03926791f, 
    -0.14013317f, 0.07100729f, 0.10011083f, 0.05206038f, 0.00925057f, -0.10825359f, 0.10646778f, 0.10013462f, 
    0.10784969f, 0.22251526f, -0.08417529f, 0.14681379f, 0.03809211f, -0.01932204f, 0.07966255f, 0.19620146f, 
    -0.12422793f, -0.21965757f, -0.06885003f, -0.03313884f, 0.05124014f, -0.11949283f, 0.01372460f, 0.25134915f, 
    -0.12876496f, -0.16685669f, -0.02262765f, -0.04110643f, -0.06148839f, 0.18573186f, 0.20296779f, 0.07546420f, 
    -0.43717274f, -0.02076548f, 0.08121018f, 0.03222613f, 0.06890227f, 0.05935736f, -0.18981676f, 0.11783276f, 
    -0.04058690f, 0.09667501f, -0.08224051f, -0.05177426f, 0.21408233f, 0.13061385f, -0.13234913f, -0.01710560f, 
    -0.16369236f, -0.04504199f, 0.19103369f, 0.01585537f, -0.03073410f, -0.08570393f, -0.10993111f, 0.11771102f, 
    0.03049523f, 0.16649806f, -0.12164206f, 0.15314303f, 0.05064825f, 0.01067638f, 0.01019866f, -0.12135227f, 
    -0.09424581f, 0.13059379f, -0.01533326f, -0.19525124f, -0.14874539f, 0.03446297f, 0.04553667f, 0.06085559f, 
    0.08670030f, -0.17197163f, -0.00583682f, -0.08514057f, 0.03275418f, 0.02703771f, 0.26897386f, 0.16861808f, 
    0.08669512f, -0.17812707f, -0.17920883f, -0.01485815f, 0.13661346f, -0.11702535f, 0.26109540f, -0.03654940f, 
    0.05400537f, -0.09960962f, 0.09627417f, -0.03138374f, 0.12724745f, -0.13475387f, 0.30158937f, -0.16667204f, 
    0.13796730f, -0.07142875f, 0.07354663f, 0.09169199f, 0.02802031f, -0.00334875f, -0.21775961f, -0.23997687f, 
    -0.00431554f, 0.01228465f, 0.00725763f, -0.06924501f, 0.03197164f, 0.12866688f, 0.03549457f, -0.00923778f, 
    0.22411406f, 0.17832160f, 0.06325001f, -0.16848150f, -0.11480029f, 0.24871635f, 0.14896184f, 0.03831736f, 
    -0.09668875f, 0.12130841f, -0.03298035f, -0.06823413f, 0.21946348f, 0.16560107f, -0.04056031f, 0.10313815f, 
    0.00612607f, 0.07964589f, 0.35897762f, 0.31660175f, 0.02199305f, 0.01180212f, -0.00420259f, 0.08240274f, 
    -0.09649935f, 0.05085298f, -0.16938455f, 0.25239471f, 0.14373305f, 0.13387313f, -0.06694115f, 0.18262404f, 
    -0.03578382f, 0.08120742f, 0.04271444f, 0.02155975f, -0.03987839f, -0.37966636f, 0.21897352f, -0.14963377f, 
    0.05628392f, 0.15479435f, -0.10640348f, -0.11085854f, -0.04522835f, -0.24871990f, -0.00512692f, 0.26147082f, 
    0.04908941f, -0.00893696f, 0.02808980f, -0.10319949f, -0.03796913f, -0.03414094f, 0.08508521f, -0.17967226f, 
    0.13383798f, -0.00612682f, -0.10661928f, -0.02018993f, -0.08780432f, 0.03981989f, 0.16152674f, 0.10658165f, 
    0.12486167f, -0.11974967f, -0.00942524f, -0.01099221f, 0.05874909f, -0.13153827f, -0.15508348f, -0.16570945f, 
    0.33459726f, 0.01234873f, 0.06918335f, 0.07645194f, -0.13548870f, 0.14128062f, -0.22672470f, -0.12475345f, 
    -0.27279720f, -0.12241772f, -0.19105411f, 0.04323893f, 0.02372326f, -0.15883568f, -0.13340436f, -0.01417681f, 
    -0.00647276f, 0.13708121f, -0.11787274f, -0.14134449f, 0.13401759f, 0.15077105f, 0.05075444f, -0.05002785f, 
    0.20010029f, -0.00075193f, -0.02959254f, 0.04959891f, 0.29171124f, 0.01087609f, -0.10372175f, 0.05199334f, 
    0.03197372f, 0.11421841f, -0.04430133f, -0.06495606f, 0.14954650f, -0.06756261f, 0.03885388f, -0.06868877f, 
    -0.13320428f, 0.06212885f, -0.16092062f, -0.16387568f, 0.05718212f, -0.00756327f, 0.16144761f, -0.23407412f, 
    -0.00331854f, -0.05460744f, 0.19755213f, -0.07080116f, 0.07682062f, -0.04523438f, 0.09255409f, 0.21541920f, 
    -0.02928179f, -0.14996609f, -0.18496710f, 0.04780571f, -0.16180389f, -0.05979998f, -0.11356314f, 0.17291313f, 
    0.18702717f, 0.08637438f, -0.04865191f, -0.01739152f, 0.08272248f, 0.09413731f, 0.12588260f, -0.09898148f, 
    0.13632211f, 0.25243065f, -0.10426937f, 0.05102656f, 0.07534841f, -0.04483813f, -0.01356775f, 0.05009052f, 
    0.04004036f, 0.24178641f, 0.09161764f, 0.23118164f, -0.06545694f, 0.06890046f, 0.25048387f, -0.28240266f, 
    -0.02136497f, 0.00659533f, 0.13056886f, -0.09727275f, 0.02083038f, -0.32526466f, 0.13189942f, 0.12786771f, 
    0.07863285f, 0.08915009f, -0.00679694f, -0.13840447f, 0.10016998f, 0.16866125f, -0.20368780f, -0.07046981f, 
    -0.02933170f, -0.22722109f, 0.06073621f, 0.07905305f, 0.16856517f, -0.01203035f, -0.18770659f, 0.06835984f, 
    -0.07615963f, -0.07737876f, 0.16525775f, -0.12707217f, 0.09403611f, 0.17743753f, -0.24616937f, -0.00480261f, 
    0.02544897f, 0.01698548f, 0.06333642f, 0.02313184f, -0.12028448f, -0.34156060f, 0.34957346f, -0.17175902f, 
    -0.17806143f, -0.00604271f, 0.06295496f, 0.13892774f, -0.02512051f, -0.08093917f, -0.17427920f, -0.06206723f, 
    0.08225366f, -0.05263728f, -0.31404698f, 0.04486367f, -0.13224019f, -0.03113246f, -0.11417747f, -0.20578852f, 
    -0.04094108f, 0.11837439f, -0.01043223f, -0.06702072f, -0.06750840f, -0.10431701f, 0.02048098f, -0.01333017f, 
    -0.02142829f, 0.29116365f, 0.01119218f, 0.07878662f, 0.16050678f, 0.14813589f, 0.13069823f, -0.05296051f, 
    -0.00079453f, -0.04436644f, 0.47798729f, -0.24288855f, 0.16380307f, 0.27531868f, -0.03705098f, 0.22734085f, 
    -0.02842543f, 0.36241832f, -0.17352717f, 0.07582203f, 0.13206770f, 0.12527293f, 0.02960442f, -0.04770939f, 
    0.05794016f, -0.17334034f, 0.16206464f, 0.15042025f, -0.03736797f, 0.17022313f, -0.03944707f, 0.08099730f, 
    -0.02905243f, 0.01027566f, 0.11038776f, -0.02231500f, -0.14749074f, 0.22930047f, 0.18389162f, 0.10523187f, 
    0.23129947f, 0.03606422f, -0.02121036f, -0.01925466f, 0.00308005f, 0.08521833f, -0.14866687f, 0.28598908f, 
    0.00033941f, -0.15920676f, -0.12340982f, 0.09500086f, -0.01806254f, -0.13931444f, 0.07570443f, -0.23740138f, 
    0.27153540f, -0.03487989f, -0.12392238f, 0.20212793f, -0.14314522f, -0.13954350f, 0.08918913f, 0.00777907f, 
    0.17197047f, -0.23301081f, 0.02559148f, 0.00819037f, 0.00847079f, 0.09423956f, -0.12312162f, -0.28139868f, 
    0.13690859f, 0.00533255f, -0.01252726f, 0.11363512f, 0.07841741f, -0.05095140f, -0.08924588f, -0.04539211f, 
    -0.18986571f, -0.00904119f, 0.25817162f, 0.14902671f, 0.05582400f, -0.07476376f, 0.05829565f, 0.08755519f, 
    -0.17045365f, -0.00357513f, -0.05530608f, 0.36423185f, 0.07086887f, -0.23663267f, 0.00679266f, -0.14142203f, 
    0.08751229f, 0.05097946f, -0.08301508f, 0.10713269f, -0.15034597f, 0.10567018f, 0.20447804f, -0.01507198f, 
    0.07895102f, -0.24771482f, -0.17103350f, 0.14779426f, -0.22188596f, -0.09883751f, 0.09725025f, 0.08598182f, 
    0.07849384f, 0.21651886f, 0.03273168f, -0.03446449f, -0.06235880f, -0.18025233f, -0.41694149f, 0.19929950f, 
    0.13991998f, -0.03003869f, 0.09640100f, 0.19231528f, 0.04286207f, 0.00510451f, -0.05126400f, 0.43588212f, 
    0.07977723f, -0.09515056f, -0.15028746f, 0.16988365f, 0.16201013f, -0.03965719f, -0.09424769f, 0.18063222f, 
    -0.00667720f, 0.11703874f, 0.18794046f, 0.12639032f, 0.05058832f, -0.10977105f, -0.10929406f, -0.01585818f, 
    0.08795886f, 0.05669429f, 0.23054694f, 0.06737190f, -0.10625069f, -0.14546548f, 0.34533587f, 0.04682867f, 
    -0.03389436f, -0.06547934f, -0.24983948f, 0.18443960f, 0.06803696f, -0.11514460f, 0.01323121f, -0.17225152f, 
    -0.10465316f, 0.02783365f, -0.05028109f, 0.39667636f, -0.16253085f, -0.05114046f, -0.07803770f, 0.00449035f, 
    -0.06494007f, 0.05403743f, -0.08078361f, -0.04000708f, 0.35820079f, 0.15887904f, -0.06601103f, -0.01591684f, 
    0.01307154f, 0.12084987f, -0.12202246f, 0.07073218f, -0.16331787f, -0.20235021f, 0.02476532f, 0.22080466f, 
    -0.13618726f, 0.14726157f, 0.00378402f, 0.15431704f, 0.06107542f, 0.20319062f, 0.38969404f, -0.10520197f, 
    -0.02022071f, 0.03271067f, -0.18609557f, -0.08330963f, -0.00130795f, -0.03584345f, 0.01546677f, -0.26983964f, 
    -0.19892097f, -0.10924175f, -0.20310514f, -0.08656754f, 0.16086684f, 0.17151500f, -0.01690356f, 0.04756661f, 
    -0.13468127f, 0.34995988f, -0.13848470f, 0.01243570f, 0.12502083f, 0.00895054f, -0.17261361f, 0.11091196f, 
    0.02524548f, 0.40818173f, -0.07552266f, -0.61965859f, 0.30755210f, 0.15542407f, 0.03024128f, 0.02425043f, 
    -0.04460310f, -0.00000353f, -0.08632177f, 0.05482668f, -0.29617658f, 0.04135785f, 0.14187026f, -0.05255808f, 
    -0.00547737f, -0.11495148f, 0.01485121f, 0.35490459f, 0.24578351f, -0.32606360f, 0.14794482f, 0.12501281f, 
    0.07728634f, 0.15849550f, -0.08355467f, -0.09973323f, 0.03334544f, 0.20147501f, 0.10732596f, 0.13108487f, 
    -0.18179750f, 0.00755191f, -0.11824621f, 0.09870180f, 0.12657267f, -0.02989951f, 0.10955819f, 0.21415792f, 
    -0.16842884f, 0.08363114f, 0.00181164f, 0.09109322f, 0.23003362f, 0.04546245f, -0.11527847f, 0.16256508f, 
    0.11331368f, 0.09180564f, -0.25189382f, 0.00008329f, 0.07339860f, -0.00944011f, 0.07790814f, 0.32542363f, 
    -0.00296101f, -0.42056495f, -0.00197426f, -0.12650022f, -0.09438173f, -0.28803489f, -0.01513911f, -0.14938822f, 
    0.03059036f, -0.29629296f, 0.09308912f, 0.00153739f, -0.04888834f, -0.00787168f, -0.07137307f, 0.08681170f, 
    0.23176406f, 0.29228666f, 0.23129740f, 0.12514487f, -0.00127826f, 0.06911294f, 0.16235988f, 0.00214625f, 
    0.10249361f, -0.01214642f, 0.01382923f, -0.11403484f, 0.02685572f, -0.14533114f, -0.16667093f, -0.01311162f, 
    -0.07194715f, -0.05849802f, -0.26021782f, 0.07897921f, -0.21882054f, 0.15109773f, -0.05956055f, 0.12768903f, 
    0.04208488f, -0.31233647f, -0.11901997f, 0.06697544f, -0.16943169f, -0.31667280f, -0.29499289f, -0.08350390f, 
    -0.03073011f, 0.09914543f, 0.10949484f, -0.02783088f, -0.06348016f, -0.14062327f, -0.06484466f, 0.06571193f, 
    -0.03890483f, -0.12419296f, -0.14493467f, 0.38703179f, -0.05063429f, -0.14985816f, -0.58951628f, -0.08659744f, 
    -0.19045538f, 0.01626215f, 0.08026898f, 0.00483385f, -0.09219296f, -0.00731438f, 0.14722793f, -0.17690535f, 
    0.17857279f, -0.02275973f, -0.00017973f, -0.07018296f, 0.16011079f, 0.07034324f, 0.13661337f, -0.04404290f, 
    -0.08884440f, -0.08260289f, -0.03030206f, -0.23554502f, -0.10914055f, -0.13856809f, 0.01927908f, 0.05985627f, 
    0.03637571f, 0.03412374f, -0.04352220f, -0.19502701f, -0.03200904f, 0.01368860f, -0.11551134f, -0.03541283f, 
    0.16651361f, -0.08244868f, 0.08053926f, -0.04071670f, 0.12925060f, 0.23205768f, 0.25618458f, 0.10904406f, 
    0.06055979f, 0.05630974f, -0.09293239f, -0.20951028f, 0.05713723f, 0.08494857f, 0.00249135f, 0.09513968f, 
    -0.04823641f, 0.01767236f, 0.29550058f, 0.05690930f, 0.45164913f, -0.27512196f, 0.04230453f, 0.06604046f, 
    -0.07825807f, 0.09341181f, 0.05611878f, 0.19619738f, 0.16970627f, -0.52649188f, -0.22956662f, -0.10519559f, 
    0.13602422f, 0.15781456f, 0.30193779f, 0.13553286f, 0.00310330f, 0.12029757f, -0.05116468f, -0.16874631f, 
    -0.26903915f, 0.13015535f, -0.11006346f, 0.12400880f, 0.17610614f, 0.15518658f, -0.15469471f, 0.03719576f, 
    -0.09543566f, 0.31109256f, 0.09316568f, -0.05584349f, -0.20642126f, 0.10800890f, 0.00836802f, -0.05889812f, 
    0.19505048f, -0.06285291f, 0.02180247f, -0.15011284f, -0.02323038f, -0.13936192f, -0.08758751f, 0.05578864f, 
    -0.08554266f, -0.11931324f, -0.10483571f, -0.11967911f, 0.05332969f, 0.10274751f, -0.08937441f, 0.14097951f, 
    -0.11907264f, 0.13772318f, -0.50484627f, -0.25509268f, 0.11297125f, -0.06233437f, -0.09238856f, -0.12909424f, 
    -0.12857234f, -0.33886877f, -0.00722029f, -0.00042572f, 0.10665088f, -0.09724970f, -0.07740325f, -0.12841158f, 
    0.05788720f, -0.18107630f, 0.09796122f, 0.01226256f, 0.04549979f, 0.07156077f, -0.25916851f, -0.16900970f, 
    -0.17447157f, 0.07593353f, 0.21508981f, 0.26945847f, 0.06874526f, 0.06315050f, -0.00902361f, 0.18370524f, 
    0.08095118f, 0.04805858f, 0.09590315f, -0.11013607f, 0.12656188f, -0.11088803f, 0.11002750f, 0.11435688f, 
    -0.16185743f, 0.00573206f, 0.14909740f, -0.11341124f, 0.07863617f, 0.03751317f, -0.08870421f, 0.08992473f, 
    0.00897869f, -0.11842859f, -0.33592838f, -0.15893736f, -0.17144942f, -0.02717951f, -0.00549801f, 0.02396554f, 
    0.00981506f, 0.06728842f, 0.04134812f, 0.00002169f, -0.18171839f, -0.19200528f, -0.15560225f, 0.09244381f, 
    0.07977384f, 0.19654939f, 0.23307806f, 0.10982737f, 0.06181982f, -0.07629809f, -0.09973650f, -0.09038492f, 
    0.09276282f, -0.13170068f, -0.09235382f, -0.12055396f, 0.06660693f, -0.06859262f, -0.08688381f, 0.14101852f, 
    -0.10470746f, -0.04108180f, -0.04960692f, 0.21150777f, 0.16917272f, 0.02891102f, -0.12132688f, 0.15229508f, 
    -0.19223019f, 0.14120640f, -0.06043004f, 0.12569748f, 0.21123813f, 0.32157496f, 0.02597202f, 0.17933103f, 
    0.03906668f, 0.15713286f, -0.28081918f, -0.24149944f, -0.02972717f, -0.55297500f, -0.25432533f, 0.04786572f, 
    0.21572012f, 0.09201820f, -0.00045794f, -0.01045203f, -0.10162912f, 0.15351701f, -0.40353873f, -0.03286560f, 
    -0.08169776f, 0.03174978f, 0.02390412f, 0.10061812f, 0.06534934f, 0.10020786f, 0.12909043f, 0.00778991f, 
    0.07846309f, -0.22551157f, 0.04606749f, -0.01454007f, -0.00215663f, -0.07795233f, -0.03987258f, -0.09080501f, 
    -0.10096610f, -0.05556106f, 0.30554724f, 0.08343395f, 0.13295166f, 0.10828715f, 0.08111281f, -0.13598981f, 
    -0.07883315f, -0.41793427f, -0.30175534f, -0.24303523f, 0.21298331f, -0.06738041f, 0.03196621f, 0.00528207f, 
    0.11882811f, -0.05384240f, -0.04817263f, 0.06383205f, -0.04646097f, -0.04122410f, -0.23898529f, 0.06277891f, 
    0.03088734f, -0.07723188f, 0.18554026f, 0.21437804f, 0.02007650f, -0.19365701f, -0.12924264f, -0.12862957f, 
    0.16511130f, -0.07313451f, 0.12815876f, -0.03604440f, 0.27744529f, 0.21539865f, 0.12921448f, 0.10848609f, 
    -0.10839255f, 0.03934551f, 0.02660024f, -0.16984703f, 0.03089830f, -0.11909161f, -0.28291905f, 0.18191259f, 
    0.21117812f, -0.03995382f, 0.01491695f, -0.00462783f, -0.08222435f, -0.09628031f, 0.00146165f, 0.36119333f, 
    0.10409450f, -0.16462107f, -0.17830175f, 0.07757937f, 0.04316100f, -0.05137731f, 0.01347179f, -0.37360403f, 
    -0.09687148f, -0.11447661f, -0.18505120f, -0.04401761f, -0.12816261f, -0.18297738f, 0.06447276f, -0.05246664f, 
    -0.32466757f, 0.46244457f, -0.10269853f, 0.01882059f, 0.10180094f, 0.06495614f, -0.19512480f, -0.01746776f, 
    -0.02554940f, 0.01970136f, 0.31999451f, -0.19940479f, -0.00179744f, -0.15655796f, -0.14821085f, -0.02805094f, 
    0.05922298f, -0.06076434f, -0.69856864f, 0.22288461f, 0.11680573f, 0.04246132f, -0.15059969f, 0.08472605f, 
    0.16450313f, -0.01465097f, -0.15424068f, -0.24726567f, -0.07072746f, 0.01121738f, 0.07552990f, -0.10281675f, 
    -0.11955763f, -0.03691000f, 0.06532647f, -0.17988534f, 0.03076205f, -0.28258869f, -0.38787702f, 0.11194596f, 
    0.00412056f, -0.02990506f, 0.06521603f, -0.15027010f, 0.08539291f, -0.02923097f, 0.21558459f, 0.36854848f, 
    0.10001283f, -0.04946812f, -0.00969746f, -0.00499301f, 0.08183146f, 0.26629215f, 0.18914287f, 0.24907400f, 
    0.22914265f, 0.17551123f, 0.01493721f, -0.16924259f, 0.17716831f, -0.03585746f, -0.11374740f, -0.51852578f, 
    -0.06134524f, -0.12436122f, -0.02573092f, 0.04068551f, -0.14074141f, 0.12947194f, 0.05179702f, 0.12526546f, 
    0.19263908f, 0.16175207f, -0.22176184f, 0.12790541f, 0.01016524f, 0.17434315f, 0.04253940f, -0.05518682f, 
    0.01991158f, 0.17075294f, 0.04456431f, 0.01445997f, 0.09085665f, -0.05999651f, -0.23206754f, -0.12043959f, 
    0.09035093f, 0.06375808f, 0.23682679f, 0.12889621f, 0.07978639f, 0.07637055f, -0.03208286f, -0.03006550f, 
    -0.14691661f, 0.17126842f, 0.21015981f, -0.22426744f, -0.38810235f, -0.32347038f, -0.02501712f, 0.10301061f, 
    0.07175166f, 0.14366505f, -0.14082001f, 0.04444975f, 0.00980037f, 0.20629513f, 0.23562092f, 0.06205901f, 
    -0.00902181f, 0.10645492f, 0.03462156f, 0.08453419f, 0.20725703f, -0.10666409f, 0.04997719f, -0.29652113f, 
    0.05552962f, -0.02775564f, 0.03369037f, 0.15937100f, 0.09541421f, 0.04235720f, -0.07431860f, -0.25919601f, 
    -0.01765884f, -0.08210247f, -0.06390471f, 0.01691996f, -0.06747140f, 0.02160043f, 0.07256725f, -0.24840473f, 
    0.06942511f, 0.33669707f, -0.02131546f, 0.03925072f, 0.00680627f, 0.01136372f, 0.13709393f, -0.02835766f, 
    -0.34288126f, -0.06893866f, -0.06409598f, 0.23776004f, 0.06388198f, 0.00219390f, -0.03747532f, 0.07129829f, 
    -0.02691060f, -0.02587241f, -0.10422278f, -0.32131779f, 0.07351866f, 0.09756269f, 0.14949098f, -0.15251319f, 
    -0.06909707f, -0.01448557f, -0.52536720f, 0.14212783f, 0.05604681f, 0.05708532f, 0.15168183f, 0.13885042f, 
    0.02001023f, -0.09040678f, -0.14641696f, -0.37638143f, 0.02046465f, -0.16309378f, -0.03268312f, 0.17231928f, 
    0.14908141f, 0.12941797f, -0.03624861f, -0.12917060f, 0.23973662f, 0.26737672f, 0.13633445f, -0.04877269f, 
    -0.05646498f, 0.06740855f, -0.11651202f, 0.02136383f, 0.22098470f, -0.37393761f, 0.03431402f, -0.11283692f, 
    -0.11291590f, 0.08527220f, 0.24789400f, 0.09394445f, -0.18456455f, -0.05673696f, -0.21893944f, 0.11677115f, 
    0.12327790f, -0.05236237f, 0.21732503f, 0.04357463f, 0.04033406f, 0.09783902f, -0.11597934f, -0.04418620f, 
    -0.06532647f, 0.29778564f, -0.17338400f, -0.14265086f, 0.01158579f, 0.07680822f, 0.16960916f, 0.03951216f, 
    0.01801844f, -0.19751108f, -0.22072811f, -0.23494332f, 0.06331301f, 0.00983461f, -0.12657535f, 0.16461110f, 
    0.05578000f, -0.17900611f, 0.26749751f, 0.11045387f, -0.00472530f, 0.05418424f, -0.03031130f, -0.01684573f, 
    -0.04746128f, 0.08367090f, -0.00192104f, -0.02323672f, -0.18310992f, 0.06694692f, 0.02526196f, 0.11167530f, 
    -0.01064355f, -0.13509832f, -0.02123463f, -0.41913190f, -0.23278609f, -0.14299273f, -0.03085434f, 0.11627692f, 
    0.02099340f, -0.00021483f, -0.01210415f, -0.10621349f, 0.11580162f, -0.01099786f, -0.04369456f, 0.08026978f, 
    -0.29242265f, 0.20148240f, 0.32419690f, -0.16651434f, 0.13861661f, 0.21012302f, 0.06566986f, -0.06161635f, 
    -0.05673689f, 0.17919892f, -0.08311465f, -0.03206880f, 0.01132004f, 0.22173578f, 0.40039521f, -0.12453978f, 
    -0.25710952f, 0.08666926f, 0.00872264f, -0.11128329f, 0.05724643f, 0.04250921f, 0.00022001f, -0.58255094f, 
    -0.31642610f, -0.20099042f, 0.13663293f, 0.06292954f, -0.08199715f, 0.19917513f, 0.13310508f, -0.10961732f, 
    0.33431658f, -0.01486992f, 0.03807841f, -0.07053731f, -0.11476038f, -0.06219081f, 0.04381592f, 0.01566412f, 
    -0.04788037f, -0.10414605f, 0.15815799f, 0.17555301f, -0.10909343f, 0.04898852f, -0.13044687f, 0.01586791f, 
    0.12417480f, -0.13487995f, -0.09557166f, 0.25517306f, -0.15728523f, 0.34509975f, 0.04884992f, -0.09780538f, 
    -0.04146240f, 0.21236615f, -0.05087787f, 0.39584252f, 0.11530455f, -0.12875761f, 0.07204487f, 0.06509703f, 
    -0.06900933f, 0.07765769f, 0.03257363f, -0.00311545f, 0.02067848f, -0.00963916f, -0.31055239f, 0.17154843f, 
    -0.05799001f, 0.14934751f, -0.03801160f, -0.02863452f, -0.08188857f, -0.36478937f, 0.16962528f, 0.13065472f, 
    -0.01097410f, 0.08247734f, 0.26393414f, -0.03780552f, -0.08519563f, 0.00471469f, 0.07419408f, 0.00687556f, 
    -0.27136800f, 0.00962124f, 0.15340240f, 0.02483562f, 0.04999929f, -0.04433762f, 0.13688327f, -0.29149428f, 
    0.06092566f, -0.43192431f, 0.15201487f, -0.06278767f, 0.19152376f, 0.01340152f, 0.03845304f, 0.04773831f, 
    -0.39728260f, -0.21273914f, -0.02007889f, 0.17869282f, 0.15975374f, 0.06868035f, -0.10710642f, -0.01986393f, 
    -0.26835808f, 0.19625023f, -0.28922081f, 0.21121888f, -0.11820023f, -0.13083152f, 0.11099847f, 0.03543595f, 
    0.12755500f, 0.20394096f, -0.06295251f, -0.04030821f, 0.09945196f, 0.05665543f, -0.04594401f, -0.18191546f, 
    -0.09343041f, -0.20923902f, 0.23322299f, 0.08979609f, -0.40667880f, -0.16674659f, -0.12782787f, 0.04676019f, 
    -0.06570686f, 0.00677067f, 0.01447133f, -0.04791904f, 0.18543433f, -0.29208183f, -0.27994516f, 0.13418533f, 
    -0.08628216f, 0.10881226f, 0.05247980f, -0.13194324f, -0.12175623f, -0.17099550f, -0.26280117f, -0.03558479f, 
    0.03077375f, -0.00771153f, -0.05063858f, 0.04853000f, 0.11172485f, 0.13082448f, 0.03545958f, -0.10380153f, 
    -0.06061720f, 0.00615359f, -0.03253879f, -0.01745931f, -0.00453403f, -0.02977251f, -0.01461230f, 0.21115036f, 
    0.18528222f, -0.09222642f, -0.02566305f, -0.16126859f, 0.24195315f, -0.06437179f, -0.08527214f, 0.11279457f, 
    0.18220280f, 0.41104564f, 0.24910037f, 0.20708971f, 0.03421659f, 0.10835049f, 0.04756742f, 0.09210581f, 
    -0.00303229f, -0.28814918f, 0.17699884f, 0.11229580f, 0.04646987f, -0.09766512f, -0.30850318f, 0.12908596f, 
    -0.20224902f, 0.08849571f, -0.12893668f, -0.05857726f, -0.04665150f, 0.16520581f, -0.09480822f, 0.12655535f, 
    -0.14466938f, -0.13030235f, 0.03949124f, -0.22521397f, -0.21277101f, -0.32232884f, 0.10279803f, 0.11551771f, 
    0.04888666f, 0.00519988f, 0.09013162f, 0.18051253f, -0.29908308f, -0.09147528f, 0.41655982f, -0.07972798f, 
    0.12597528f, -0.10002541f, 0.10650843f, 0.00865264f, 0.03308985f, 0.00169768f, 0.03794206f, 0.09580652f, 
    0.13086563f, -0.11689798f, -0.03202514f, 0.05845218f, 0.20125170f, 0.11341891f, -0.30475992f, -0.12690519f, 
    0.33570448f, 0.16723901f, -0.22841401f, -0.12734608f, 0.11185538f, 0.10134080f, 0.03967364f, -0.19512470f, 
    0.15224357f, 0.04319085f, 0.20895188f, 0.10444683f, 0.05598917f, 0.01659282f, 0.01256224f, -0.19030243f, 
    -0.17384058f, -0.14697555f, 0.13873680f, -0.02102931f, -0.00073726f, 0.18418308f, -0.07124357f, -0.00315827f, 
    0.01768540f, 0.12368456f, 0.00141201f, 0.21610999f, 0.03987865f, -0.08701035f, 0.04009758f, 0.15783364f, 
    -0.00797689f, -0.04484155f, 0.04936297f, 0.03382456f, 0.07658960f, -0.14382397f, 0.05418361f, 0.06580739f, 
    0.05675152f, -0.09281601f, 0.10764100f, -0.01446669f, -0.39760840f, -0.35502920f, -0.05164137f, -0.02634318f, 
    0.14306843f, 0.07169348f, -0.06541527f, -0.12675095f, -0.38162652f, -0.40333053f, -0.24677768f, -0.15320234f, 
    0.00562513f, -0.18118650f, 0.02081829f, 0.14433722f, -0.02660313f, -0.14886573f, -0.05171825f, 0.12673864f, 
    0.02830794f, 0.19475311f, -0.03216258f, 0.15978609f, -0.02982084f, 0.19156161f, 0.14697726f, -0.37674928f, 
    -0.09296537f, 0.05188181f, -0.16541258f, -0.01783070f, -0.18260227f, 0.01990791f, 0.13227884f, -0.38754085f, 
    -0.16212621f, 0.06098904f, 0.26831281f, -0.18920398f, 0.00153649f, 0.17574102f, -0.29677790f, -0.05562305f, 
    0.05700203f, 0.32242873f, -0.09470554f, -0.01654566f, 0.09905417f, 0.06978665f, 0.00651034f, -0.04047324f, 
    -0.01000636f, -0.06615908f, -0.17950213f, -0.32897687f, -0.02310913f, -0.04219968f, -0.06976041f, 0.04210929f, 
    0.05190029f, 0.01406480f, 0.26318446f, 0.03272845f, -0.28124571f, -0.24720149f, 0.09469281f, -0.00702419f, 
    0.04157631f, -0.04247695f, 0.25839478f, 0.01911417f, -0.09109934f, -0.09204047f, -0.23619334f, 0.03233426f, 
    -0.06116841f, 0.10240934f, 0.07049550f, 0.01757929f, 0.20172711f, 0.01203750f, 0.09552829f, 0.27479509f, 
    -0.00885136f, 0.11271112f, -0.04912258f, -0.16740599f, 0.04882395f, -0.18314748f, -0.05912713f, 0.38177264f, 
    0.12908950f, 0.26735300f, 0.04339805f, -0.00064422f, -0.19929075f, -0.10486966f, -0.28420639f, -0.02986758f, 
    0.39123338f, 0.14014414f, -0.00622172f, 0.06942777f, -0.01122655f, 0.00580821f, 0.12723233f, 0.31738919f, 
    -0.06467298f, -0.00311316f, -0.00715458f, -0.02221916f, -0.04533016f, -0.09981861f, 0.09417260f, 0.03282421f, 
    0.39267376f, 0.27070725f, -0.23250309f, 0.11101784f, -0.09946147f, -0.10037085f, 0.00697799f, -0.12166826f, 
    -0.06513973f, -0.35496792f, 0.18265381f, -0.06358621f, -0.23935054f, -0.09943350f, -0.28857610f, -0.05345814f, 
    -0.02326200f, -0.06444655f, -0.04711897f, -0.19196855f, -0.02510254f, 0.22874314f, -0.02719493f, -0.09281482f, 
    0.03230716f, 0.16690707f, -0.08231759f, -0.01132855f, -0.13005246f, -0.09911115f, -0.08267550f, -0.03592739f, 
    0.07792096f, -0.26371709f, 0.13002704f, -0.01926020f, 0.22742961f, 0.24741325f, 0.09459171f, -0.01447857f, 
    -0.06233169f, -0.20581630f, 0.15419677f, 0.00579566f, -0.07947220f, -0.27494895f, -0.09774301f, -0.00569059f, 
    0.05882463f, -0.05980934f, 0.01953090f, -0.02440077f, -0.17122465f, 0.07246141f, -0.08492509f, 0.10644451f, 
    -0.02244144f, -0.05265620f, -0.13931979f, 0.07094464f, -0.17542200f, 0.10209348f, -0.13840820f, -0.20360413f, 
    0.21518134f, 0.05845856f, 0.03323651f, -0.12331551f, -0.04291073f, -0.11942126f, -0.18652394f, 0.09574868f, 
    0.00407887f, -0.03701867f, 0.31051192f, 0.13974707f, -0.04180616f, 0.07030700f, -0.23908946f, 0.01507113f, 
    -0.14176780f, 0.46668965f, 0.21135417f, -0.02154055f, 0.01085376f, 0.04343341f, -0.02238987f, 0.16923802f, 
    -0.02934797f, 0.10829175f, -0.10524043f, 0.19416445f, 0.14208911f, -0.04602223f, 0.15732159f, 0.03282157f, 
    -0.07379091f, -0.01589803f, -0.17342605f, 0.31437212f, -0.06619169f, 0.04917073f, 0.22409107f, 0.06567665f, 
    -0.23704885f, -0.11349173f, -0.02815285f, 0.10695264f, -0.24561697f, -0.09265056f, -0.11542448f, -0.31263262f, 
    -0.33212471f, -0.03365802f, -0.11643206f, 0.14285447f, -0.02493460f, 0.22759420f, 0.15151908f, -0.08252613f, 
    -0.05951297f, -0.09731871f, -0.00833302f, 0.06127056f, -0.08619726f, 0.02676106f, 0.03129840f, -0.01806672f, 
    -0.16096424f, -0.05209127f, -0.00600565f, 0.01968319f, -0.09151413f, -0.02238265f, 0.08860361f, -0.21800232f, 
    -0.17450045f, 0.06400570f, -0.07602967f, -0.15398715f, 0.08530433f, -0.02663439f, 0.19245951f, -0.14035434f, 
    0.02133812f, 0.03912484f, -0.01999979f, -0.12390073f, -0.05722381f, -0.01686930f, -0.16272709f, -0.05909377f, 
    -0.05561848f, -0.17956734f, 0.19657205f, -0.02337474f, -0.14335068f, -0.17596264f, -0.15852311f, 0.07057192f, 
    0.10172326f, 0.14906725f, 0.13837762f, 0.13494872f, 0.12538168f, 0.07371143f, -0.07097141f, -0.09101425f, 
    0.08515977f, 0.10023054f, 0.04259350f, 0.20166220f, 0.45770109f, 0.15306117f, 0.21045426f, 0.06279156f, 
    0.06129614f, -0.10998079f, -0.04702920f, -0.15915915f, 0.28790167f, 0.02721482f, 0.01538579f, -0.42884678f, 
    -0.20271729f, -0.14709848f, -0.14367886f, -0.00167824f, 0.03258473f, 0.46050307f, 0.00392647f, -0.01788769f, 
    0.10432685f, 0.04210571f, 0.19844295f, -0.01617492f, -0.06464533f, -0.16218705f, -0.18988045f, -0.11303607f, 
    0.05341910f, 0.03317794f, -0.18388508f, 0.06396417f, 0.16696160f, -0.19198845f, 0.01788530f, 0.12230479f, 
    0.11653898f, 0.22101060f, 0.28256953f, 0.19733833f, -0.04235745f, 0.14444715f, -0.13300547f, 0.22528556f, 
    -0.07091842f, -0.07058668f, 0.18869112f, -0.03793976f, 0.04341989f, -0.01888715f, 0.02595590f, 0.00947128f, 
    0.03095878f, 0.34488940f, 0.06360632f, 0.09310643f, 0.11035211f, 0.25374806f, -0.00274037f, -0.01866143f, 
    0.20584963f, -0.10321866f, 0.00375730f, 0.00773025f, -0.09562623f, -0.04111343f, -0.01095932f, 0.21110180f, 
    -0.10471985f, -0.03489557f, 0.04942302f, 0.05691728f, 0.08044016f, -0.02350112f, -0.05073802f, 0.21456549f, 
    0.15673803f, 0.15801428f, 0.11495553f, 0.23955272f, 0.00776057f, -0.17123033f, -0.20250171f, 0.11253034f, 
    0.03979585f, -0.09736760f, -0.11045269f, 0.16507374f, -0.13507421f, -0.12555817f, -0.16472454f, 0.11195720f, 
    0.06445466f, 0.16249521f, -0.07359066f, -0.19407929f, -0.02238259f, -0.19491941f, -0.44118270f, -0.08437888f, 
    -0.15156959f, 0.03726744f, 0.18069866f, -0.03495112f, 0.05859580f, -0.11830034f, -0.28046146f, 0.08758412f, 
    -0.15996997f, -0.14192593f, 0.10498393f, -0.00937218f, -0.08065952f, 0.21391556f, -0.03546563f, 0.05213960f, 
    0.16629449f, 0.11933509f, -0.08165731f, 0.09081689f, -0.12049831f, 0.07994240f, -0.20410238f, -0.04348225f, 
    0.14161187f, -0.43568537f, -0.12478985f, 0.03074430f, -0.00007899f, 0.09052400f, 0.15017478f, 0.14566933f, 
    0.10988321f, -0.06508659f, -0.65526026f, -0.03961520f, -0.09996832f, 0.19226515f, -0.24331477f, -0.07367624f, 
    -0.19453363f, -0.03775599f, 0.22776373f, -0.12779182f, 0.44564328f, 0.23535161f, 0.05355751f, -0.03274564f, 
    -0.11927496f, 0.08292732f, 0.12491225f, 0.13773111f, 0.10207956f, 0.03350030f, -0.17786695f, 0.05882718f, 
    0.23356214f, 0.03375752f, -0.00719251f, 0.05124054f, -0.15045816f, 0.12156721f, 0.08156210f, 0.07079217f, 
    0.01611149f, -0.04152617f, 0.13938163f, 0.24120656f, -0.23645726f, -0.08564684f, 0.14060016f, 0.08319836f, 
    0.13522348f, -0.07966104f, -0.03274380f, -0.23124106f, -0.11892929f, -0.29028484f, 0.16366471f, -0.10165107f, 
    -0.16541801f, 0.11963106f, 0.09014951f, -0.09388673f, 0.04554890f, -0.11143182f, 0.07247429f, 0.07041828f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.08881481f, 0.07391760f, 0.10197543f, 0.12302440f, -0.18543580f, 0.00416476f, 0.12823202f, 0.27731895f, 
    0.05677631f, 0.11283630f, 0.19228826f, 0.11299428f, 0.23703563f, 0.12300871f, -0.28835440f, -0.05671584f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.14025612f, -0.26418161f, -0.50549018f, 0.15834437f, 0.33941546f, 0.35492694f, -0.09450832f, 0.50359088f, 
    0.25880322f, 0.35895771f, -0.18357256f, -0.18154095f, -0.36894009f, 0.45264757f, -0.48239207f, -0.24593733f, 
    -0.07206499f, 0.39613301f, -0.10274210f, -0.08780327f, 0.40026399f, -0.06395973f, -0.14957088f, 0.09647782f, 
    -0.18688259f, -0.12889135f, 0.26708323f, 0.02097152f, -0.06487808f, -0.28862795f, 0.54198551f, 0.04268059f, 
    -0.13701709f, -0.06330902f, -0.09880833f, 0.28363150f, -0.48869440f, -0.19792959f, 0.53418368f, 0.12711227f, 
    -0.44634610f, -0.13251077f, 0.23779649f, -0.04422342f, 0.09551113f, 0.02392279f, 0.13746926f, -0.01047181f, 
    -0.04122147f, -0.14464542f, -0.05039361f, -0.02395234f, -0.11040556f, -0.04590115f, 0.03614858f, -0.22384310f, 
    -0.23465443f, -0.05383345f, -0.01337469f, -0.14725542f, 0.06071809f, -0.19639432f, -0.10816011f, -0.07592919f, 
    -0.15793470f, -0.30014253f, -0.01487625f, -0.17228721f, 0.18504608f, 0.11693033f, 0.24186726f, 0.27471498f, 
    0.11906002f, 0.13048820f, -0.36770821f, 0.33392856f, -0.28587916f, 0.06771912f, -0.12591852f, 0.08291599f, 
    0.03436498f, -0.20477745f, -0.11376508f, 0.28516221f, 0.37952328f, -0.38052109f, 0.12124874f, 0.49405083f, 
    0.41144407f, 0.30431595f, -0.56414402f, 0.04966294f, -0.11939128f, -0.16557641f, -0.12731582f, 0.32909232f, 
    -0.12916169f, 0.49292552f, 0.10266887f, -0.58813190f, 0.10992431f, 0.16775547f, -0.37840244f, -0.09250577f, 
    0.64997357f, 0.40722406f, -0.28306407f, 0.22112259f, -0.11197449f, -0.07008155f, -0.20773618f, 0.15110116f, 
    -0.06206134f, -0.18176751f, -0.23436020f, -0.04285979f, -0.08195473f, 0.02314324f, -0.16449949f, -0.14867640f, 
    -0.00616305f, 0.13384831f, -0.14892583f, -0.15289257f, 0.19093111f, -0.04914510f, -0.21680133f, -0.04880283f, 
    -0.20867194f, 0.08827196f, -0.07538041f, 0.11173253f, -0.30721009f, 0.14375818f, 0.43047050f, -0.52766424f, 
    -0.55354416f, 0.30759639f, 0.10116637f, -0.20279171f, 0.25397483f, -0.13162081f, 0.48993829f, -0.08888759f, 
    -0.03581048f, 0.25058135f, -0.22686942f, 0.13095182f, 0.10240333f, 0.24993952f, 0.29599491f, -0.05062290f, 
    0.09214067f, -0.01703514f, 0.01564647f, 0.15615234f, -0.14819726f, 0.13628599f, -0.36609307f, -0.26431969f, 
    -0.24810779f, 0.27477473f, -0.19466093f, -0.24003188f, 0.06257859f, 0.37089065f, 0.41000974f, -0.05301368f, 
    -0.13556345f, -0.18711115f, -0.12484065f, 0.03800739f, -0.49818447f, -0.00449164f, 0.29157522f, -0.00839238f, 
    -0.10816216f, 0.32860374f, -0.05629419f, -0.03676780f, 0.05189075f, 0.16255760f, 0.11858024f, 0.33012030f, 
    -0.27959517f, -0.70165426f, 0.31717476f, -0.16150656f, -0.75636268f, 0.37014833f, 0.33335710f, 0.16595607f, 
    -0.18106018f, 0.49891943f, 0.21413933f, 0.16382161f, -0.11361509f, -0.37061161f, 0.34701881f, -0.43898913f, 
    -0.04686149f, 0.27915546f, -0.36483356f, 0.31153595f, 0.17579705f, 0.05450505f, 0.26763284f, 0.03388020f, 
    0.23532474f, -0.14513928f, 0.05532600f, 0.26631689f, -0.31250113f, 0.06506882f, -0.27536190f, 0.19371949f, 
    0.14581117f, -0.22614554f, 0.27529994f, -0.18315493f, 0.48295152f, 0.28601709f, 0.01686618f, 0.10448412f, 
    0.13151057f, 0.37117121f, 0.37981588f, -0.25220877f, -0.11467308f, -0.04353928f, 0.08912624f, -0.18950672f, 
    0.33365738f, 0.08107466f, 0.26671943f, 0.20602082f, -0.43102872f, 0.49923182f, -0.14549156f, 0.36163551f, 
    -0.23312716f, 0.14151417f, -0.24326576f, -0.34071830f, 0.21034804f, 0.29065686f, 0.16113745f, 0.30527499f, 
    0.13277417f, -0.19276373f, 0.03991469f, 0.01333221f, -0.29247901f, -0.08424257f, -0.00770938f, 0.30113533f, 
    -0.03581728f, 0.08535238f, -0.44537812f, -0.00383147f, 0.13966219f, 0.41216272f, -0.01508818f, -0.52402878f, 
    0.01865193f, 0.29020834f, 0.05327130f, 0.17993966f, -0.42457595f, 0.49529469f, -0.30742407f, -0.07598285f, 
    0.15970585f, 0.06873242f, -0.03522073f, -0.18668696f, -0.07060208f, 0.16079414f, 0.16237055f, 0.01423240f, 
    0.20733202f, -0.37140426f, 0.00761113f, -0.18590863f, 0.40818447f, -0.48157766f, 0.24884707f, 0.18914649f, 
    0.12796374f, 0.06636893f, 0.17922071f, -0.07406917f, 0.12026699f, -0.02317107f, -0.03302063f, -0.27388054f, 
    0.24586137f, -0.21492802f, -0.02996761f, -0.19817150f, 0.00493536f, 0.32903230f, 0.23279960f, -0.29876727f, 
    0.06228247f, 0.03887442f, 0.22190799f, -0.04310612f, 0.01873930f, -0.13714331f, -0.06105000f, -0.07520702f, 
    0.07965626f, -0.19574390f, -0.19025166f, -0.17970453f, -0.23014368f, 0.12095814f, -0.13602008f, -0.16915852f, 
    -0.15770398f, -0.31605843f, -0.21164174f, -0.02869441f, -0.34784228f, 0.46765685f, -0.26837659f, 0.09127374f, 
    0.16754355f, 0.32270971f, 0.11914361f, 0.05119460f, 0.16810083f, 0.28939354f, -0.31508541f, 0.18355308f, 
    0.12238573f, 0.88457584f, 0.18156391f, -0.21598978f, -0.07180808f, 0.21484447f, 0.18958178f, 0.07139458f, 
    -0.64129090f, -0.06084647f, -0.12480725f, -0.55668092f, -0.51731527f, -0.17590718f, 0.36299253f, 0.31135714f, 
    -0.13067643f, 0.30790898f, 0.43695855f, -0.02193312f, 0.12117044f, -0.30094692f, 0.17688157f, -0.07200626f, 
    -0.08142968f, 0.43366173f, 0.23585369f, 0.37402412f, 0.26854217f, -0.06890861f, 0.29421589f, -0.15702039f, 
    -0.07749501f, -0.03918086f, -0.34713703f, 0.09979020f, 0.18908027f, 0.06556936f, -0.01811157f, 0.45142359f, 
    0.35759348f, -0.21238804f, -0.50755298f, 0.45975846f, 0.16918339f, 0.10149150f, 0.03810520f, 0.37088284f, 
    0.01127432f, -0.02652510f, 0.35404301f, -0.14456950f, 0.20780061f, -0.15691949f, -0.26557124f, 0.34087259f, 
    0.02722564f, 0.45528212f, 0.16604978f, -0.50875390f, 0.19252452f, 0.47091818f, 0.19855826f, -0.06804487f, 
    -0.17001535f, -0.31507108f, -0.46341690f, 0.29878125f, -0.14073752f, -0.21648054f, -0.46299002f, 0.59669656f, 
    0.35438362f, -0.09830473f, -0.06265780f, 0.36973161f, -0.17859438f, 0.35555527f, 0.19115902f, 0.48610219f, 
    -0.15516128f, -0.41379946f, -0.27457055f, 0.25675398f, -0.08327144f, -0.03105465f, 0.05625850f, 0.17141134f, 
    -0.10318031f, 0.30624002f, 0.10304018f, 0.47475427f, 0.08603121f, -0.34851134f, -0.26032639f, 0.04107492f, 
    0.16955671f, -0.27344829f, 0.12892070f, 0.19218977f, -0.09965222f, -0.07355110f, -0.23760411f, -0.27145737f, 
    0.09044924f, -0.24458367f, -0.02623932f, 0.13407327f, -0.03750553f, -0.21819013f, -0.14552683f, -0.06714425f, 
    0.15428719f, 0.51148760f, 0.04398128f, 0.26786858f, -0.38730019f, 0.19606760f, -0.40218163f, 0.31363240f, 
    -0.53673655f, -0.09875578f, -0.20475230f, -0.13100119f, -0.20859449f, 0.35737497f, 0.17666858f, 0.41332349f, 
    -0.23873417f, 0.08868351f, -0.03052169f, -0.19094408f, -0.19835097f, 0.26361388f, -0.24515922f, -0.51264906f, 
    0.55449611f, -0.06815591f, 0.22575775f, 0.76021600f, 0.28524444f, -0.31407437f, -0.33436108f, -0.00151019f, 
    -0.05959606f, -0.07937151f, 0.22854714f, 0.18166864f, 0.06507086f, -0.40341488f, 0.10858846f, 0.04203631f, 
    -0.15105258f, 0.42516202f, 0.30410779f, 0.32418543f, -0.21242736f, 0.34596634f, -0.10991887f, 0.22446084f, 
    -0.15336011f, -0.07692508f, -0.08479858f, 0.19405393f, 0.16436510f, -0.21369159f, -0.07062456f, -0.03928265f, 
    -0.09997740f, 0.54462630f, -0.47057348f, -0.07029197f, 0.32495996f, 0.37109569f, 0.26021916f, -0.18530299f, 
    0.08657859f, 0.37546659f, 0.11384846f, -0.00527833f, 0.07171097f, 0.05466762f, -0.10959911f, 0.02934740f, 
    0.39897138f, 0.39379930f, -0.58213156f, 0.41271669f, 0.12780264f, -0.30396995f, 0.14891210f, -0.26364687f, 
    -0.06046159f, -0.11988688f, 0.04449235f, 0.12992634f, 0.09932458f, 0.20679085f, -0.24415873f, -0.02296833f, 
    -0.09455173f, 0.20256922f, 0.23491856f, -0.35652098f, 0.26143232f, 0.46410930f, -0.43256056f, 0.00131177f, 
    0.17732444f, 0.06254243f, -0.06978632f, 0.22755560f, -0.19568487f, -0.16262148f, -0.06633841f, -0.19469547f, 
    0.23932847f, -0.09489612f, 0.06013937f, 0.01352589f, -0.02173220f, 0.26817125f, -0.00312676f, -0.09110057f, 
    -0.17555518f, 0.09795056f, -0.42133504f, -0.22678731f, 0.49226797f, 0.41245657f, -0.22238472f, 0.36690232f, 
    -0.05687996f, -0.34593108f, -0.03762919f, -0.00403981f, 0.04179946f, 0.08237568f, -0.00652496f, 0.27527708f, 
    0.17785679f, 0.59277469f, 0.39801577f, -0.11957744f, 0.19993000f, 0.03201686f, 0.12102773f, -0.62074757f, 
    -0.15224573f, 0.50701487f, -0.27959290f, -0.00806266f, 0.03456820f, -0.21488962f, -0.35896057f, -0.48519355f, 
    -0.15255137f, 0.61869425f, 0.16183966f, 0.12545067f, -0.14838718f, 0.03333960f, -0.03726155f, -0.33953115f, 
    0.28871027f, -0.38790244f, -0.15556717f, 0.23750971f, 0.30552483f, -0.16290416f, -0.00982991f, -0.01065316f, 
    -0.06117978f, -0.33136338f, 0.04634061f, 0.33471906f, 0.08851378f, -0.17601414f, 0.19289337f, 0.06681266f, 
    -0.25247270f, 0.11384440f, -0.16597271f, 0.35558021f, 0.17859675f, 0.09432219f, -0.42202795f, -0.06526854f, 
    -0.18459171f, -0.15816075f, -0.35981122f, -0.01698599f, -0.03217811f, 0.32070455f, 0.03586205f, -0.15147741f, 
    0.32431093f, -0.00685247f, -0.05047159f, 0.03914123f, 0.09391075f, 0.28727305f, -0.03262026f, 0.34578472f, 
    0.04986580f, -0.13261415f, -0.36314711f, 0.11559057f, 0.25055152f, 0.02852069f, -0.42317435f, 0.56649339f, 
    0.24823040f, 0.12726521f, 0.37976298f, -0.12904011f, 0.28921083f, 0.30622867f, -0.10407831f, -0.19139697f, 
    -0.17143376f, -0.27148500f, -0.29412529f, 0.24098842f, -0.07677642f, 0.38185415f, -0.21259438f, 0.31912932f, 
    -0.19555542f, -0.06174294f, 0.49333283f, 0.41986269f, 0.00442150f, 0.08608638f, 0.12117764f, -0.40192485f, 
    -0.10212470f, 0.11463501f, -0.44822231f, 0.14826839f, 0.24353300f, -0.14783385f, -0.46453503f, -0.20486180f, 
    0.31536579f, -0.05605964f, -0.56463689f, 0.18489195f, -0.18839653f, 0.12656865f, 0.76356649f, 0.25294331f, 
    0.16763055f, -0.34179735f, -0.08508272f, 0.25426617f, -0.28142339f, 0.12072710f, 0.24175230f, 0.00985119f, 
    -0.02965608f, -0.24201219f, -0.16721782f, -0.22450691f, 0.42992401f, -0.01023492f, 0.30701250f, 0.20164216f, 
    0.10005152f, 0.08788054f, -0.18012387f, -0.24441721f, 0.06955208f, -0.23948430f, -0.11028560f, 0.01236510f, 
    -0.11094812f, 0.27931067f, -0.03752903f, -0.10804796f, -0.23173444f, -0.12775221f, 0.20190606f, -0.16450749f, 
    0.11528131f, 0.55702120f, 0.12448611f, -0.20579062f, 0.36833262f, 0.09108520f, -0.11354803f, -0.01445614f, 
    -0.17385158f, 0.21994394f, 0.34615311f, 0.12308904f, -0.18702729f, 0.30721685f, -0.02513375f, -0.31758812f, 
    0.07312132f, -0.54162997f, 0.33555737f, 0.33939993f, -0.06350584f, 0.29568237f, 0.28971910f, -0.41897184f, 
    -0.18649305f, 0.23075835f, 0.33787271f, 0.09465307f, -0.09380189f, 0.10120162f, 0.28772807f, -0.05359125f, 
    -0.08012757f, -0.11971966f, -0.32629305f, 0.13923074f, 0.50062370f, 0.13140821f, 0.07860798f, 0.27667519f, 
    0.52493799f, 0.24347867f, -0.32551637f, 0.44222462f, -0.26812068f, -0.04507184f, -0.38100997f, 0.18739350f, 
    0.05381417f, 0.33296016f, 0.04491922f, 0.01027761f, 0.32446462f, 0.16212277f, 0.55269331f, -0.30280152f, 
    -0.37634951f, -0.09068403f, 0.46251005f, -0.34788358f, 0.34496549f, -0.21197943f, -0.08199287f, -0.04396742f, 
    0.10975986f, 0.30380329f, 0.36068639f, 0.01581316f, -0.25178811f, 0.00912005f, 0.06408910f, -0.33651745f, 
    0.09739456f, 0.35007241f, 0.09788915f, -0.10663529f, -0.01248551f, 0.35171491f, 0.16999261f, -0.12959953f, 
    -0.07424565f, 0.41767249f, 0.22488055f, 0.00313987f, -0.07464141f, 0.41010270f, -0.11970384f, 0.15596271f, 
    -0.05753944f, -0.32820863f, 0.46491781f, -0.26508331f, -0.61754924f, -0.05009658f, 0.00476742f, -0.05303745f, 
    -0.10675179f, -0.03364420f, 0.09320943f, 0.30574438f, -0.11584911f, -0.25317410f, 0.23744388f, 0.34674364f, 
    -0.09245410f, 0.22503789f, 0.16153599f, -0.18659696f, 0.09155578f, 0.41586789f, -0.15933900f, 0.26889959f, 
    -0.15634103f, 0.11197574f, 0.17037676f, -0.06343341f, 0.04687477f, -0.05073012f, -0.05149580f, -0.14794487f, 
    0.14616700f, 0.05505656f, 0.10416093f, 0.06878387f, 0.14279416f, 0.26691201f, 0.10142291f, 0.22104599f, 
    -0.12983814f, -0.10126602f, 0.26910546f, 0.11767436f, -0.40350926f, 0.22494367f, 0.28930974f, -0.15376230f, 
    -0.29433662f, 0.15447889f, 0.52745974f, -0.12476675f, 0.09951214f, 0.16761129f, -0.08482702f, 0.04079531f, 
    -0.17116237f, -0.38064328f, 0.30721626f, -0.04217269f, -0.27887058f, 0.15690531f, 0.62171465f, -0.25291106f, 
    -0.44644734f, -0.22631890f, 0.34156579f, 0.35504439f, -0.39582098f, 0.12917669f, -0.05309909f, 0.08948028f, 
    -0.19624600f, -0.23369879f, -0.35323158f, 0.16702199f, 0.06055896f, 0.15775564f, -0.03137136f, 0.10091101f, 
    -0.07772458f, -0.06250849f, -0.01494214f, 0.39373791f, 0.18955450f, 0.04825151f, -0.63343966f, 0.23332852f, 
    0.03998179f, 0.22333814f, 0.05633844f, 0.20863058f, 0.14323469f, -0.00050882f, -0.22827266f, 0.33685279f, 
    -0.22010046f, 0.07781685f, 0.31984323f, 0.42991856f, -0.20546287f, -0.58518714f, -0.75025237f, -0.24488109f, 
    -0.09859637f, 0.32526132f, 0.19705643f, -0.13812579f, 0.20360076f, -0.17421176f, -0.14171188f, 0.48980266f, 
    0.23372424f, -0.14570457f, 0.41109931f, -0.24901192f, 0.33930066f, -0.25806224f, 0.04672618f, -0.28177240f, 
    -0.04860014f, 0.49609363f, -0.10982775f, -0.05808132f, -0.01707792f, 0.21979479f, -0.07469138f, -0.37033257f, 
    -0.45346951f, -0.31530738f, -0.06209512f, 0.13057248f, 0.23106788f, 0.06462142f, 0.23549742f, 0.28574347f, 
    0.12322208f, 0.14910354f, 0.15167785f, -0.21269062f, -0.02448864f, 0.26755705f, 0.20764005f, 0.14796355f, 
    0.13292657f, 0.28580782f, 0.54176998f, -0.23835671f, -0.20374098f, 0.33720300f, -0.13319173f, -0.21639824f, 
    -0.05007450f, 0.00746081f, 0.15018734f, -0.36333942f, -0.08018354f, 0.41934904f, 0.46651277f, 0.21111958f, 
    0.17794874f, -0.35462707f, 0.37050840f, 0.06041681f, -0.52152580f, -0.27431157f, -0.22479908f, 0.09095398f, 
    0.11436845f, -0.14228734f, 0.44475815f, -0.16251414f, -0.31789857f, -0.27654698f, 0.16968918f, 0.68835807f, 
    0.37233621f, 0.37639469f, 0.13872832f, 0.07950737f, 0.09128490f, 0.10915650f, -0.35438368f, -0.28182185f, 
    0.14486770f, 0.07794529f, -0.30577999f, -0.03852441f, 0.40082696f, -0.03471843f, -0.11166440f, 0.22334749f, 
    0.05116996f, 0.38002136f, 0.06686146f, 0.16877379f, -0.15212823f, 0.33654729f, -0.15862460f, -0.32223344f, 
    -0.09720089f, 0.14302196f, 0.12938009f, 0.42553517f, -0.42306548f, -0.24709150f, -0.52615625f, 0.44976339f, 
    0.27267557f, 0.03931985f, -0.13315400f, 0.11211191f, -0.33107176f, 0.06237200f, -0.05265297f, 0.52821738f, 
    0.20755680f, 0.19431922f, 0.31732807f, -0.24433288f, 0.16731827f, 0.03752353f, 0.49358654f, -0.01087889f, 
    -0.05676023f, 0.29589260f, -0.30759230f, -0.10864538f, -0.30491927f, 0.25736585f, -0.31272513f, 0.13180809f, 
    0.02610380f, -0.20239560f, -0.33776855f, -0.04617775f, 0.22901195f, 0.44775465f, 0.07837547f, 0.39488363f, 
    -0.24103813f, -0.01302393f, 0.00349991f, -0.44577327f, -0.19864820f, 0.07302590f, 0.06405217f, 0.23133627f, 
    -0.01407538f, 0.08210167f, -0.15938438f, -0.02068769f, 0.10519073f, -0.12280875f, 0.30916208f, 0.05554747f, 
    -0.45771655f, 0.08974357f, 0.60852885f, -0.59942830f, 0.25191694f, 0.39810565f, -0.09174725f, 0.04435522f, 
    0.07417507f, 0.14003134f, -0.10262018f, 0.20775174f, 0.18066059f, 0.28455457f, -0.40932819f, 0.28501025f, 
    0.54681647f, -0.03401261f, -0.30844495f, 0.05178118f, 0.11331056f, 0.09023745f, -0.43811303f, 0.19475308f, 
    0.15433742f, -0.27419621f, 0.30741814f, 0.27203229f, -0.26959869f, 0.30618882f, -0.17875728f, -0.63057822f, 
    -0.73059177f, -0.30967185f, -0.10362668f, 0.54341340f, 0.46125379f, 0.03269687f, -0.14250989f, -0.07258979f, 
    -0.21263033f, 0.55832863f, 0.14506087f, -0.33500844f, -0.08010165f, 0.38844627f, -0.22817783f, -0.37093887f, 
    0.37968251f, -0.51645982f, -0.07284240f, 0.27633703f, 0.18544181f, -0.38445464f, 0.07066153f, 0.41191587f, 
    -0.06190829f, 0.50796372f, 0.16208959f, -0.33208233f, -0.30515608f, 0.15661146f, 0.34665444f, -0.01710469f, 
    0.47911635f, 0.03529171f, -0.30816832f, 0.24221423f, -0.17976996f, -0.36149654f, -0.24496838f, 0.08730578f, 
    -0.18603812f, -0.20919690f, 0.29807821f, 0.37084004f, 0.30441076f, -0.34844857f, 0.06008166f, -0.13913557f, 
    0.00819017f, 0.39951745f, -0.43773124f, 0.30368119f, -0.16469462f, -0.15378380f, 0.18215530f, 0.12382320f, 
    0.18640757f, -0.08654980f, -0.06583244f, -0.15866587f, 0.15409203f, 0.28414187f, 0.26261994f, 0.17019336f, 
    -0.25518623f, -0.47835004f, -0.12825726f, -0.05145825f, 0.17646399f, -0.27138308f, 0.22283496f, 0.27205056f, 
    -0.21715812f, 0.05036414f, -0.10961954f, 0.19863895f, 0.17968753f, -0.18531261f, -0.04592238f, 0.57902795f, 
    -0.25305220f, 0.10248909f, 0.09179774f, -0.17269580f, 0.36598185f, 0.40055147f, -0.42692563f, 0.11413494f, 
    0.12091652f, 0.27319148f, 0.44744313f, 0.17367531f, -0.24057977f, -0.21892740f, -0.04089347f, -0.19486769f, 
    -0.16987193f, 0.49183851f, 0.18560131f, 0.05664996f, 0.07738399f, 0.11918198f, 0.33402944f, 0.04076573f, 
    0.03903093f, -0.13241318f, 0.27298218f, 0.47705808f, -0.31850126f, -0.21402380f, -0.07421656f, 0.37252489f, 
    0.22718933f, 0.68453056f, 0.27204385f, 0.05458034f, 0.09058335f, 0.35196409f, -0.14558077f, 0.00639261f, 
    -0.15837905f, 0.08316686f, 0.28079596f, 0.26919568f, -0.23121735f, -0.14325519f, 0.43622568f, -0.37021342f, 
    -0.60482758f, 0.00462491f, 0.12493521f, 0.25039396f, 0.31124052f, -0.19387662f, 0.43069342f, 0.09403961f, 
    -0.23173523f, -0.11964190f, -0.22493856f, -0.17064686f, -0.01759378f, -0.14302330f, -0.15129328f, 0.18069541f, 
    0.18461491f, -0.09962754f, 0.08975681f, 0.19919774f, -0.09036715f, -0.18058926f, -0.14877053f, -0.14158848f, 
    -0.06991798f, -0.32586235f, 0.27898201f, 0.26921105f, -0.18798307f, 0.10577871f, -0.01826635f, 0.14168216f, 
    0.35770437f, 0.19933353f, -0.27385971f, 0.54279357f, -0.00989536f, -0.27326295f, 0.07342406f, -0.00468655f, 
    -0.21781713f, 0.21993031f, 0.07265450f, -0.18127680f, 0.35321385f, 0.30337894f, 0.21285176f, 0.07690879f, 
    -0.18823409f, 0.08254499f, 0.17611606f, -0.49645936f, -0.23316108f, 0.40382993f, -0.37011871f, 0.09631583f, 
    0.20617211f, -0.09309235f, 0.13809383f, -0.27350712f, -0.00823162f, 0.39447743f, -0.08158725f, -0.21715125f, 
    0.11338910f, -0.30493724f, 0.53874999f, -0.33333391f, 0.31258953f, -0.02429422f, 0.38617915f, 0.37048441f, 
    -0.17734610f, 0.58087158f, -0.15013671f, -0.17046665f, 0.02086062f, 0.04584125f, -0.02627348f, 0.22266410f, 
    -0.28310883f, -0.46760470f, 0.08282728f, -0.05366388f, 0.57650870f, 0.06666595f, 0.17312025f, -0.12226325f, 
    0.01131108f, 0.17432816f, -0.25515217f, -0.11943734f, 0.32413274f, -0.01801552f, -0.16726300f, 0.32522330f, 
    -0.23948410f, 0.24190108f, -0.16109173f, -0.45569238f, 0.26165146f, 0.51098400f, -0.31728083f, 0.34554774f, 
    -0.15388040f, -0.69382435f, -0.19938236f, 0.32066992f, 0.08518591f, -0.17063649f, -0.13041776f, 0.13469355f, 
    0.11139116f, -0.15180726f, 0.43440843f, 0.25588894f, -0.12082836f, 0.11849407f, 0.58752334f, -0.21479470f, 
    0.23031919f, 0.46489328f, 0.40572622f, 0.12686747f, 0.02175232f, -0.18008222f, 0.42412260f, -0.44625005f, 
    -0.27642739f, 0.16744450f, 0.51363933f, -0.20967798f, -0.02779292f, -0.07450985f, 0.22806130f, -0.01042432f, 
    -0.16364028f, 0.12500462f, 0.12374993f, -0.11903251f, -0.02954483f, 0.28963462f, 0.13998416f, -0.33209118f, 
    -0.21037656f, -0.03180891f, 0.45871544f, 0.39287719f, 0.13664803f, 0.04511670f, -0.02276457f, -0.19112271f, 
    -0.08224300f, 0.61087513f, 0.30225563f, -0.47568145f, 0.28913364f, 0.07128949f, -0.06353030f, -0.03088314f, 
    0.01561451f, 0.48892146f, -0.32279155f, 0.16662094f, 0.15188555f, -0.22890306f, -0.46387863f, -0.51257581f, 
    0.22195239f, 0.32937285f, 0.04793384f, -0.17418765f, -0.04039958f, 0.22361898f, -0.11705050f, -0.12202214f, 
    -0.03638506f, -0.24404351f, 0.21211137f, -0.23018768f, 0.29055843f, -0.02425013f, -0.15671714f, 0.06407379f, 
    0.01797209f, 0.06369034f, -0.39355111f, 0.40172541f, -0.14677405f, -0.12757097f, -0.53528798f, 0.06322294f, 
    0.22387198f, -0.28878871f, 0.14271829f, 0.21228430f, -0.16929026f, -0.04273690f, 0.43591312f, 0.46774891f, 
    -0.06698260f, -0.23855329f, -0.05406466f, 0.00691123f, -0.21875310f, 0.00620437f, -0.14615858f, 0.05214916f, 
    0.16982639f, -0.09018761f, -0.01313529f, -0.04022862f, 0.05524550f, -0.13985761f, 0.08809628f, -0.25956541f, 
    -0.11401760f, 0.07759962f, 0.11416091f, 0.04015119f, -0.10218804f, -0.15875725f, -0.04497846f, 0.07214636f, 
    0.05908179f, -0.09780081f, -0.01531399f, -0.13953242f, -0.20018230f, -0.03549983f, 0.06356855f, -0.11975071f, 
    -0.04865007f, -0.28692397f, 0.09628206f, 0.18483113f, 0.20727532f, -0.16897841f, 0.59673053f, 0.10748165f, 
    -0.60265523f, -0.31735331f, 0.19905636f, -0.02443987f, -0.06750041f, -0.33248317f, -0.04525495f, 0.09233152f, 
    0.11635238f, 0.00815028f, -0.14523768f, -0.24597161f, 0.40789482f, 0.21318445f, -0.14020616f, -0.04683896f, 
    0.10340822f, -0.13534316f, -0.27776670f, 0.35557750f, 0.08787399f, 0.00666271f, -0.00362899f, 0.32243359f, 
    0.20909445f, -0.37906414f, 0.09099285f, 0.13399418f, -0.05863890f, 0.33660522f, 0.36935797f, -0.12735327f, 
    -0.33112416f, -0.34448880f, 0.18290389f, 0.27319002f, 0.05970152f, -0.16742620f, -0.08131170f, 0.15906420f, 
    0.15502171f, -0.31862387f, 0.30438700f, 0.29436600f, 0.22763379f, -0.41711786f, 0.07643072f, 0.03853834f, 
    0.13605732f, 0.47340766f, 0.11781031f, -0.12798369f, 0.02139484f, 0.19654834f, 0.03191456f, 0.06894921f, 
    0.12115209f, -0.04994499f, 0.05044023f, 0.17518288f, 0.01935620f, -0.27794266f, 0.02726287f, -0.12043844f, 
    -0.01579699f, -0.19069196f, -0.13880038f, -0.20900001f, 0.04428497f, -0.15406983f, -0.21803977f, -0.04481990f, 
    0.06975090f, 0.55915505f, 0.26906833f, -0.12382793f, -0.06464798f, 0.30219510f, -0.16299903f, 0.01135087f, 
    0.58578056f, -0.09302354f, -0.19271159f, -0.79837191f, 0.00526614f, 0.02986282f, -0.31371775f, 0.18466744f, 
    -0.18258609f, 0.15058713f, -0.07646042f, 0.13624190f, 0.14389712f, -0.09617416f, -0.27574286f, 0.32584926f, 
    0.21867111f, -0.25184664f, -0.35397404f, 0.13935345f, 0.34699047f, -0.28172424f, 0.00394284f, 0.05948763f, 
    -0.17788175f, 0.31687778f, 0.03301445f, -0.33257923f, -0.14744313f, 0.36037865f, 0.58716291f, -0.26552463f, 
    -0.59722716f, -0.14396790f, 0.46562275f, 0.09960957f, 0.02634226f, 0.30292028f, -0.02598680f, -0.01053769f, 
    -0.03550845f, 0.08458838f, -0.06345921f, -0.02443060f, -0.16021037f, -0.23134449f, 0.03308957f, -0.08995542f, 
    0.08934966f, -0.22611818f, -0.11493391f, -0.20818980f, -0.19294694f, -0.12307534f, 0.18452357f, -0.11816740f, 
    -0.15854223f, -0.26830682f, 0.25058252f, 0.02636381f, 0.30803841f, -0.10372886f, 0.34706181f, -0.16008131f, 
    -0.27279037f, -0.66845620f, -0.03129075f, -0.13897383f, -0.16995101f, -0.30238268f, 0.49685195f, 0.27640402f, 
    -0.23682670f, 0.48498940f, -0.37416059f, -0.06870373f, 0.23407657f, 0.24930039f, 0.04961764f, 0.25148255f, 
    -0.27042603f, -0.23318404f, -0.16832928f, -0.45849341f, 0.18365769f, 0.33779576f, -0.12433194f, 0.02110895f, 
    0.00761981f, -0.27533937f, 0.10108688f, 0.30989754f, 0.17916158f, -0.03605896f, 0.06440686f, 0.07969560f, 
    -0.19596265f, -0.39480188f, 0.00619220f, -0.31020561f, -0.72136050f, 0.30226263f, 0.29263303f, 0.29733303f, 
    0.03655264f, 0.20310128f, -0.21131147f, 0.34920958f, 0.00482873f, -0.07604709f, -0.56728935f, -0.06957436f, 
    0.17966793f, -0.30254516f, 0.15423112f, 0.18975477f, -0.25782844f, 0.04238222f, 0.51680917f, 0.36835915f, 
    -0.12749039f, 0.22043048f, 0.45630729f, 0.35340774f, 0.27958694f, -0.28968170f, 0.53664416f, -0.29554939f, 
    -0.54347718f, 0.32624078f, 0.59948784f, -0.41085902f, 0.03954468f, -0.18739751f, 0.14761972f, -0.16423564f, 
    -0.15528537f, -0.07673795f, -0.24498414f, 0.21258271f, 0.35752255f, -0.13255730f, 0.19559814f, 0.24436165f, 
    0.01703882f, -0.35832578f, 0.35868481f, -0.16155249f, -0.30688992f, -0.11677248f, 0.45724520f, -0.30035511f, 
    -0.03877642f, -0.11701260f, 0.40966165f, 0.02629459f, -0.18527485f, -0.15747324f, -0.34243834f, 0.22534448f, 
    0.58064938f, 0.11382330f, -0.26888314f, -0.09904289f, -0.21204391f, 0.53631634f, -0.45562035f, 0.39729375f, 
    -0.15432450f, 0.51401454f, 0.32675996f, 0.24751009f, 0.39230907f, -0.36965084f, 0.38475123f, -0.30974808f, 
    -0.61581308f, 0.37497741f, -0.36179036f, 0.39557263f, -0.14982705f, -0.32895917f, -0.17099608f, -0.22200589f, 
    -0.19860794f, -0.49477908f, 0.07667142f, 0.34271729f, -0.44274446f, 0.26590991f, 0.08073149f, -0.02871501f, 
    0.49115703f, -0.10968003f, -0.26008800f, 0.35117495f, 0.16274774f, -0.39227739f, 0.08472612f, 0.33158642f, 
    -0.09372845f, -0.82640225f, 0.43220401f, -0.06870174f, -0.15323760f, 0.07637458f, -0.02921462f, 0.28637752f, 
    -0.13259351f, 0.19866696f, 0.01636974f, 0.00608606f, -0.44811583f, -0.40078688f, 0.48987302f, 0.30701414f, 
    -0.12422846f, -0.59003901f, -0.14485797f, 0.16798073f, -0.11181733f, -0.01100458f, 0.18998595f, -0.08094802f, 
    -0.08552965f, -0.09974083f, 0.48429447f, -0.22270580f, 0.54559612f, -0.08863497f, 0.07299631f, 0.10747894f, 
    -0.10171219f, -0.31667915f, 0.35750899f, 0.26217541f, -0.37001994f, -0.21841893f, 0.36945423f, 0.18833074f, 
    0.16915724f, 0.32199171f, -0.14341299f, 0.45367277f, -0.12481429f, -0.31590348f, -0.06244225f, 0.08497389f, 
    -0.18619242f, -0.02534912f, 0.49243891f, 0.50916606f, -0.04961722f, -0.45540607f, -0.04458788f, 0.14153285f, 
    0.05122468f, 0.67453808f, -0.09337629f, 0.19313376f, 0.12329109f, 0.19217683f, 0.15331581f, -0.14923130f, 
    0.09900828f, 0.42779836f, 0.06274941f, -0.20590942f, 0.24908516f, 0.29912189f, -0.20322815f, -0.00431764f, 
    0.44387645f, -0.03983212f, 0.32080033f, 0.08920906f, -0.09549182f, -0.15711878f, 0.01991440f, -0.29742676f, 
    0.19148168f, 0.11944778f, 0.07924139f, -0.26783645f, -0.23280878f, -0.02648410f, -0.04812358f, 0.19582410f, 
    0.12113468f, -0.20349179f, -0.04910882f, -0.11809644f, -0.16298962f, -0.19741954f, 0.03829269f, -0.11265310f, 
    -0.05708939f, -0.03821390f, -0.06698170f, -0.16149957f, -0.18397698f, -0.01545340f, -0.13930319f, 0.06100999f, 
    -0.10344583f, -0.18026000f, 0.04849611f, 0.10684430f, -0.17351112f, 0.11343640f, -0.07895068f, 0.07650998f, 
    0.10321722f, 0.29749107f, -0.14626653f, -0.20101857f, 0.04169262f, 0.25071850f, 0.50298262f, -0.26567608f, 
    -0.47339365f, -0.35699639f, 0.35354942f, 0.26373664f, 0.16041012f, -0.36047542f, 0.55001837f, 0.10264990f, 
    0.06195651f, -0.12997125f, 0.36094522f, -0.09418195f, -0.43206120f, 0.37002075f, 0.17774506f, -0.07372160f, 
    0.26756018f, 0.22697501f, 0.54002482f, -0.18608862f, 0.05748146f, 0.14852746f, -0.42136857f, -0.29563931f, 
    -0.13756783f, 0.04322363f, -0.02644888f, 0.06186574f, -0.11161859f, -0.22415026f, -0.15871793f, 0.09332222f, 
    -0.20122860f, -0.09615712f, 0.16639562f, -0.05656544f, -0.10031846f, -0.21459270f, 0.02415598f, -0.19124816f, 
    0.15292454f, 0.27710813f, -0.10931059f, -0.18850917f, 0.16141334f, 0.41379032f, 0.11120653f, 0.12666859f, 
    -0.23820321f, -0.43051535f, 0.28189060f, -0.46911952f, 0.48905569f, -0.17607287f, 0.02031741f, 0.02954629f, 
    0.05983603f, -0.40352371f, 0.18956672f, -0.01810565f, 0.22143000f, -0.12564461f, 0.39174685f, 0.13329466f, 
    -0.27884561f, -0.48382986f, 0.10562800f, -0.39271790f, -0.29180211f, -0.22773311f, 0.65276992f, 0.07859302f, 
    0.01021479f, 0.11836776f, -0.28471440f, 0.28984711f, -0.10232276f, 0.42036042f, 0.08040787f, 0.11821008f, 
    -0.13338743f, -0.36758259f, 0.17489161f, -0.12834376f, 0.22894254f, 0.28752807f, -0.40122837f, -0.09562327f, 
    0.16128647f, 0.02521699f, -0.74612719f, -0.02885167f, 0.42331773f, 0.41137522f, -0.24949525f, 0.17762683f, 
    -0.23206972f, -0.09093764f, -0.25585288f, 0.02849565f, -0.75732851f, 0.39502484f, 0.11390355f, 0.25361204f, 
    -0.12112387f, 0.60198653f, 0.26357725f, -0.03015518f, 0.28571928f, -0.13373087f, -0.31962293f, 0.14844929f, 
    0.52162641f, 0.21368870f, -0.15203385f, -0.02702057f, -0.14266157f, 0.54966968f, -0.05683198f, 0.04313839f, 
    -0.06429136f, -0.11285397f, -0.04402879f, -0.31950015f, 0.22275601f, 0.30049458f, -0.00119213f, 0.28465787f, 
    0.59688675f, -0.31340012f, -0.34633344f, 0.33944452f, -0.16534734f, 0.28251517f, -0.52948707f, 0.25195205f, 
    -0.02939853f, -0.13034801f, -0.17748119f, -0.10591593f, -0.16747822f, -0.10416247f, -0.20421092f, 0.12593408f, 
    0.19463022f, 0.20003846f, -0.17106141f, 0.02718523f, -0.04879213f, -0.03567652f, -0.18180290f, -0.24943648f, 
    -0.07440650f, 0.31682345f, 0.31646612f, 0.03524850f, 0.05809711f, -0.22050238f, 0.11190750f, 0.06853966f, 
    0.12053553f, -0.04434376f, 0.02572634f, -0.28023306f, 0.06851078f, -0.42893595f, 0.50667554f, 0.10232667f, 
    0.19955321f, -0.14259502f, 0.14477381f, 0.09606634f, 0.14955743f, 0.39092097f, -0.09723511f, -0.74551553f, 
    0.03605419f, 0.32764417f, -0.46375924f, 0.44855693f, -0.27801326f, 0.26294807f, -0.19418412f, -0.30527100f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.47816962f, 0.33392766f, 0.22186416f, 0.04963607f, 0.12283592f, -0.19274439f, -0.14017665f, -0.19666789f, 
    0.48407191f, 0.31630397f, 0.13547197f, 0.00039846f, -0.21438411f, 0.21639192f, -0.00001408f, 0.24961664f, 
    -0.27192435f, 0.60513955f, 0.21204036f, 0.12770633f, 0.64615291f, 0.07591492f, 0.06686781f, 0.20412932f, 
    0.08306007f, 0.26709902f, 0.37696052f, 0.09064028f, -0.23695302f, -0.15330283f, -0.40086088f, -0.32435623f, 
    0.17480771f, -0.37157905f, -0.14560442f, 0.10706954f, 0.02691044f, 0.43605763f, 0.27746445f, -0.18030536f, 
    0.37407964f, 0.11331347f, -0.06712282f, 0.13646185f, -0.13991517f, -0.13000064f, -0.45987070f, -0.27848285f, 
    -0.06114727f, 0.34765419f, 0.34642062f, -0.22559431f, -0.79414040f, 0.19097909f, 0.20851120f, -0.19840918f, 
    0.17804423f, 0.32839337f, -0.33509013f, 0.02387532f, 0.43884227f, 0.45887819f, 0.32055461f, 0.06470317f, 
    0.25794715f, -0.19499230f, 0.35216358f, -0.23569827f, 0.12104487f, 0.32467091f, -0.08003371f, 0.10232932f, 
    0.27845332f, 0.57727158f, 0.11709687f, 0.08019784f, 0.26535913f, -0.05476339f, 0.01150584f, -0.20544340f, 
    -0.19387402f, 0.52494854f, 0.06073716f, 0.05154230f, -0.14214917f, 0.32228258f, 0.02440120f, 0.14197709f, 
    0.04806930f, -0.06287205f, -0.07301146f, 0.06061140f, 0.32645884f, -0.14056517f, -0.16803136f, 0.10715921f, 
    -0.49485266f, 0.30231667f, 0.36738575f, 0.21020314f, -0.26657650f, 0.13478968f, -0.24960247f, -0.41982090f, 
    -0.03718233f, 0.26623690f, 0.11645605f, 0.13729252f, 0.25258401f, 0.60875863f, 0.48938844f, -0.18684946f, 
    -0.27322704f, -0.12033276f, -0.02703733f, 0.04634449f, 0.43562195f, -0.16080001f, -0.16363312f, 0.40103897f, 
    -0.12827680f, 0.33949280f, -0.36804008f, 0.00490639f, 0.02744863f, -0.11154525f, 0.43745136f, -0.22361602f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.11632735f, -0.10509288f, 0.23363867f, -0.08423434f, 0.06812896f, 0.08181846f, -0.00936950f, -0.01298848f, 
    0.29057381f, -0.03738523f, 0.15590154f, 0.06142899f, 0.02978035f, -0.19841097f, -0.00267858f, 0.17407483f, 
    -0.32636997f, 0.25531569f, -0.49839896f, -0.05101825f, -0.02621438f, 0.48277226f, -0.12668543f, 0.12931372f, 
    -0.17093930f, -0.10576559f, 0.05248401f, -0.06956863f, -0.03559589f, 0.62144935f, -0.15884945f, -0.20359568f, 
    -0.19582145f, -0.18285206f, -0.21489809f, -0.06719809f, -0.19538604f, 0.07030871f, 0.03238744f, 0.08605870f, 
    -0.25108883f, -0.39122534f, -1.29889655f, 0.14404315f, -0.04861530f, -0.34261575f, 0.13109230f, -0.05838321f, 
    0.05701532f, -0.02797743f, -0.12116691f, -0.02641255f, -0.02294632f, 0.04676139f, 0.08656552f, -0.02111441f, 
    -1.45635033f, -0.26212493f, 0.07841729f, -0.07916234f, 0.18790427f, -0.49468058f, -0.21721826f, -0.12280687f, 
    0.13222468f, 0.09495235f, 0.10988121f, -0.33639419f, 0.44269437f, 0.19695000f, -0.05507579f, 0.10656127f, 
    0.23446558f, -0.10512131f, -0.17686175f, -0.32462728f, 0.19393256f, 0.01453503f, -0.03363599f, -0.06813811f, 
    0.07751561f, -0.02306153f, -0.05185308f, -0.16535842f, 0.05740353f, -0.07440607f, -0.73225689f, -0.05171167f, 
    -0.77424854f, 0.01951308f, -0.08011547f, 0.32024425f, 0.07889181f, 0.11491617f, -0.04776596f, -0.00077080f, 
    -0.11130954f, 0.04197273f, 0.03408609f, -0.02830526f, 0.37166139f, 0.06622940f, 0.17257321f, -0.95613366f, 
    0.05724990f, 0.28559020f, 0.08336381f, 0.09505381f, 0.13903338f, 0.47821200f, 0.13934815f, 0.10827311f, 
    -0.27502811f, -0.37844050f, -0.01156518f, -0.06617752f, 0.28552058f, -0.36045229f, -0.07458274f, 0.08869023f, 
    0.56373703f, -0.06810458f, -0.75160182f, -0.41872308f, 0.11387175f, 0.02663934f, 0.15262592f, -0.68681198f, 
    -0.35720482f, -0.22458018f, 0.28436759f, -0.03402432f, 0.08302911f, 0.11248000f, -0.33765891f, -0.11393215f, 
    0.20093948f, 0.07069224f, -0.04501327f, -1.44906950f, 0.28460467f, -0.19015767f, -0.06141254f, -0.18447667f, 
    -0.01470819f, -0.12137493f, -0.00654433f, -0.05163119f, 0.00950971f, -0.33856693f, 0.09931906f, 0.00892254f, 
    -0.43994683f, 0.02129477f, 0.20349745f, 0.00447812f, 0.45969403f, -0.13830456f, 0.19480914f, -0.19004837f, 
    -0.01397089f, -0.10717327f, 0.08129305f, -0.42587629f, 0.10308162f, 0.09642738f, 0.21449368f, -0.08563216f, 
    -0.37125391f, 0.00110862f, 0.27650040f, 0.06035458f, 0.03557928f, -0.20157607f, 0.17921504f, -0.03771872f, 
    -0.01173704f, 0.02442770f, -0.93392551f, 0.10393731f, -0.03300967f, 0.10864863f, 0.38579249f, 0.09575301f, 
    -0.27791107f, -0.40434858f, 0.06026590f, 0.01294408f, 0.04189752f, 0.23689644f, -0.12863813f, 0.43833485f, 
    0.21087849f, -0.20996591f, -0.27165636f, -0.08432382f, 0.67517757f, -0.25624174f, 0.41507131f, 0.14324655f, 
    -0.01988587f, -0.16066079f, 0.14054266f, 0.09550599f, 0.25778300f, 0.01257974f, 0.18579867f, -0.15589000f, 
    -0.33907858f, -0.28352463f, -0.33634785f, -0.23281470f, 0.13755530f, 0.05994873f, -0.31984010f, -0.16303395f, 
    0.51227605f, -0.06472760f, 0.06337679f, 0.24298355f, -0.10665826f, 0.14812911f, 0.00084317f, 0.01479308f, 
    0.37129837f, -0.03512070f, 0.04434935f, 0.03357171f, -0.12077256f, -0.18788056f, -0.32477498f, 0.34165391f, 
    0.04918447f, -0.44329157f, 0.19899410f, 0.33575079f, 0.08900145f, -0.01236328f, -0.04622656f, 0.40533763f, 
    0.16512594f, -0.29723439f, 0.02819126f, -0.01176781f, 0.14516677f, 0.22731209f, -0.10432774f, -0.37666678f, 
    -0.18086912f, -0.01064262f, -0.69339043f, -0.21067159f, -0.28901538f, -0.00703088f, -0.10447829f, -0.01698761f, 
    0.00183985f, -0.12285933f, -0.30970353f, 0.06368759f, 0.11109717f, -0.22347803f, 0.35274705f, -0.01125865f, 
    -0.40672925f, 0.16500847f, 0.22941497f, -0.45920894f, -0.11001160f, -0.36013314f, 0.13771696f, 0.14020230f, 
    0.41288510f, -0.06683388f, 0.25183988f, -0.05269756f, 0.06533457f, -0.36201108f, -0.05442291f, -0.01650290f, 
    -0.34247798f, -1.17498243f, 0.03772525f, -0.03888992f, -0.40328708f, 0.51483744f, -0.10655022f, -0.27711794f, 
    0.11540662f, 0.02629714f, 0.02354519f, 0.02922419f, 0.01920933f, 0.20666970f, -0.01174297f, 0.13869131f, 
    -0.03872270f, 0.17582244f, -0.41791102f, -0.43210295f, -0.04712315f, 0.11277880f, 0.19958755f, 0.28469372f, 
    -0.08496600f, -0.12851019f, 0.12506391f, -0.71725887f, 0.10952434f, -0.06303975f, 0.22675984f, 0.12349140f, 
    0.39675978f, -0.10738161f, -0.02126361f, 0.03187757f, 0.14480780f, -0.76996499f, 0.05688675f, -0.74590868f, 
    -0.04183719f, -0.10550655f, -1.00342190f, 0.28185818f, -0.03797714f, 0.44735292f, 0.38982105f, 0.00193305f, 
    0.01494911f, -0.81891084f, -0.41026670f, -0.63081855f, -0.14718036f, 0.04718455f, 0.20166180f, -0.04408855f, 
    0.04947628f, -0.11504728f, -0.51360637f, -0.96704471f, -0.03883375f, 0.24442466f, 0.12537321f, 0.03264176f, 
    -1.59569132f, 0.05536402f, -0.05020003f, -0.11503108f, 0.27169761f, 0.12763187f, -0.37254122f, -0.10699778f, 
    0.55849558f, -0.07424393f, -0.04309096f, -0.06370316f, 0.25532138f, -0.22963229f, -0.31444013f, -0.74584657f, 
    -0.24360302f, -0.48178267f, -0.08255634f, 0.07649619f, 0.10118322f, -0.43150839f, -0.45977926f, -0.07436972f, 
    -0.44651246f, 0.41657594f, -0.06656452f, -0.00200393f, 0.12070955f, 0.15734954f, -0.02808663f, -0.25623038f, 
    -0.32052964f, -0.02025390f, -0.21656977f, -0.03375557f, 0.34101257f, -0.02078206f, -0.42076543f, 0.55844557f, 
    0.22669005f, -0.42208421f, -0.42352805f, -0.06935713f, 0.05748211f, 0.13722861f, -0.14493510f, 0.00793178f, 
    -0.42331451f, -0.07644232f, -0.06078130f, 0.15277067f, -0.33420995f, 0.11081877f, -0.02521166f, 0.00458604f, 
    0.16080911f, -0.17676583f, -0.28419259f, 0.03597854f, 0.15446106f, 0.46327645f, -0.38583854f, 0.14327085f, 
    0.14855413f, 0.18248560f, -0.12008889f, -0.08088884f, 0.27365354f, -0.20547846f, -0.01659279f, 0.08663400f, 
    -0.11529247f, 0.27595896f, 0.04244752f, 0.07543477f, -0.16708300f, -0.41670308f, -0.04769678f, 0.18707314f, 
    0.17639473f, 0.06211737f, 0.01243711f, 0.03356493f, 0.00491409f, -0.38271320f, 0.03703938f, 0.16222839f, 
    -0.20842285f, -0.08440220f, -0.03463297f, 0.15034468f, 0.12231310f, -0.12622620f, -0.98967242f, 0.20499904f, 
    -0.74768299f, -0.29903454f, -0.10994272f, 0.01706992f, -0.08898043f, 0.01498373f, -0.03428600f, 0.04554756f, 
    -0.10631490f, 0.17882496f, 0.11637907f, 0.21722271f, -0.66152579f, -0.28824192f, -0.50086176f, -0.15781426f, 
    -0.01302528f, 0.13629651f, -0.34651548f, 0.10742588f, -0.75535929f, 0.06989988f, -0.07983622f, 0.20807843f, 
    0.09953100f, -0.41943181f, 0.27378240f, -0.19890323f, -0.14168064f, -0.58172864f, -0.01783006f, 0.03887553f, 
    -0.13387753f, -0.07964569f, 0.05395022f, -0.66843134f, -0.00960948f, -0.04008427f, 0.03816716f, -0.06677368f, 
    0.16690215f, 0.00304540f, -0.82993317f, -0.04219387f, -0.44442636f, 0.17346281f, 0.21702150f, -0.04896867f, 
    -0.25262877f, -0.18418477f, 0.19769990f, -0.46621168f, 0.02838195f, -0.59143716f, 0.00599115f, 0.00229106f, 
    -0.03268603f, -0.13037144f, 0.00864593f, 0.02224233f, -0.71446860f, 0.39165011f, -0.02695727f, -0.10880577f, 
    -0.50699002f, 0.12774917f, 0.52502942f, 0.10926487f, 0.23716052f, -0.17857122f, -0.34730247f, 0.00632418f, 
    -0.18199083f, 0.11649691f, -0.11048570f, 0.07279292f, -0.10243323f, -0.22317953f, -0.42748141f, -0.11010496f, 
    0.10399622f, -0.03108571f, -0.04447678f, -0.04581947f, -0.15263210f, 0.22160105f, -0.36272636f, -0.00695561f, 
    0.16233952f, 0.30496326f, -0.33906704f, -0.05943199f, 0.03947484f, -0.19533715f, -0.06183211f, 0.05270220f, 
    -0.09952433f, -0.03335967f, -0.13366522f, -0.06846340f, 0.03764184f, -0.09282415f, -0.44078085f, 0.19613473f, 
    -0.08126105f, 0.05893075f, -0.10029194f, 0.11769480f, 0.04558481f, 0.24706706f, 0.00702129f, 0.05635276f, 
    0.13943774f, 0.04927197f, -0.52762991f, 0.14416499f, -0.00962594f, -0.12521185f, -0.20657717f, -0.15490602f, 
    0.18234335f, -0.20908687f, 0.02037693f, -0.08691864f, -0.06115017f, -0.00555778f, -0.23714089f, 0.06234138f, 
    -0.12000180f, 0.21342012f, 0.26921153f, -0.07131426f, -0.07228898f, -0.47705016f, -0.07415213f, 0.04174669f, 
    -0.26324666f, 0.01998907f, 0.16302247f, -0.04081316f, 0.31655216f, 0.40267795f, -0.34156993f, -0.43745339f, 
    0.18428271f, 0.11997424f, -0.23713824f, -0.26582840f, 0.01613323f, -0.03254708f, -0.31616798f, -0.10666443f, 
    0.22716637f, 0.50772589f, 0.11006186f, 0.08246630f, -0.05444113f, 0.02460290f, -0.12770060f, 0.15345396f, 
    0.29491583f, -0.01182188f, -0.05303759f, -0.04021750f, 0.12357819f, 0.02903092f, -0.28189641f, -0.00332736f, 
    -0.42912987f, 0.17908505f, 0.08774756f, -0.02797907f, -0.12391982f, 0.22883429f, -0.58518428f, 0.10351316f, 
    -0.06891212f, 0.02163496f, -0.16583012f, -0.24918436f, -0.01666134f, -0.61333930f, 0.30901206f, -0.58083850f, 
    -0.40074059f, 0.01655643f, -0.02063089f, 0.08744738f, 0.23162760f, -0.33430308f, -0.08254152f, 0.53309369f, 
    -0.21873343f, 0.21633516f, -0.70849985f, -0.15352522f, -0.08777799f, -0.01453684f, 0.12160289f, 0.47137707f, 
    -0.13962072f, -0.02826531f, 0.37146056f, -0.05005463f, -0.15041682f, -0.42401516f, 0.12703252f, 0.00862504f, 
    0.10498206f, -0.06679687f, -0.22760539f, -0.04258224f, -0.17807205f, 0.20076068f, -0.10546220f, -0.25053322f, 
    -0.44920063f, -0.04689552f, -0.22754289f, 0.05579645f, 0.10604820f, -1.03733981f, 0.14071171f, -0.33840907f, 
    0.13355044f, 0.01112307f, 0.14166701f, 0.06731615f, -0.51487273f, -0.15793206f, 0.00834268f, 0.18835582f, 
    0.12564254f, -0.00111092f, -0.35382012f, -0.38624910f, 0.14578941f, -0.20951028f, 0.00927908f, -0.16080724f, 
    0.13273199f, 0.32047310f, 0.49149081f, 0.04339493f, -0.10872806f, -0.04073189f, 0.30881849f, -0.30906290f, 
    -0.02034611f, 0.08895832f, 0.10021958f, 0.03596200f, -0.10772703f, 0.19846170f, 0.16512249f, -0.18415883f, 
    0.04677009f, 0.32546896f, -0.55773342f, 0.12710814f, 0.05546847f, 0.37457377f, 0.01969347f, -0.23517886f, 
    -0.38506195f, -0.07379188f, 0.14865012f, -0.53633749f, -0.71632880f, -0.59825838f, -0.37618306f, -0.06271949f, 
    -0.13001016f, -0.08466830f, 0.14181089f, 0.25991964f, 0.15096605f, 0.00526562f, -0.05117968f, -0.13888055f, 
    0.04446563f, 0.04130562f, -0.33996174f, 0.74333233f, 0.03517779f, 0.13030382f, 0.53569812f, 0.00026037f, 
    0.07911117f, -0.05013837f, -0.03963242f, 0.04563838f, -0.33839819f, 0.03233379f, 0.01822191f, -0.00480060f, 
    -0.78506911f, -0.26054382f, 0.04724984f, -0.04473093f, 0.26958215f, -0.37510118f, 0.37697691f, 0.13621455f, 
    0.08009411f, 0.22612153f, 0.03085884f, -0.29269803f, 0.00826441f, 0.25337017f, 0.28200579f, 0.02495516f, 
    0.16126822f, -0.04597096f, -0.04595700f, -0.07618597f, -0.00918941f, 0.23200747f, 0.00796022f, -0.03170677f, 
    0.17444387f, 0.01401122f, 0.44797435f, -0.31225193f, -0.56993175f, -0.12497229f, 0.00307399f, -0.40120396f, 
    0.16736995f, -0.07083430f, 0.02621711f, 0.04008806f, -0.03696560f, -0.44569159f, -0.34886408f, -0.09692524f, 
    0.08266574f, 0.13339680f, 0.06294534f, -0.36438683f, -0.32583788f, 0.03965069f, 0.30911162f, 0.08369420f, 
    0.31368184f, -0.15803885f, 0.33444598f, 0.06210505f, 0.21004136f, -0.01694080f, -0.09149642f, -0.19849226f, 
    0.21136388f, -0.59987688f, -0.09898924f, 0.05960217f, -0.05600785f, -0.52472591f, 0.22568336f, -0.35913920f, 
    -0.67780912f, 0.22797585f, -0.13064809f, 0.02076404f, -0.49349201f, -0.23153490f, 0.00983077f, 0.15022202f, 
    0.11896995f, 0.02796066f, -0.31275403f, -0.12467226f, -0.03487299f, 0.12925343f, 0.13099581f, -0.10956793f, 
    0.09593230f, 0.10540729f, 0.03825558f, 0.15071613f, 0.06867368f, 0.27938637f, 0.18692866f, 0.11011992f, 
    -0.28385049f, -0.11715193f, -0.07417081f, 0.23370704f, 0.14357033f, -0.35295305f, 0.04724287f, -0.20975418f, 
    0.09073807f, 0.17626265f, 0.26152870f, -0.12407043f, -0.87917292f, -0.26727733f, -0.56606299f, -0.40100557f, 
    -0.02095355f, 0.11946134f, 0.03636156f, 0.07761528f, -0.10551792f, 0.03679639f, -0.43592212f, 0.25323212f, 
    0.14269932f, -0.16662189f, 0.18451577f, -0.63364649f, 0.12499838f, 0.02196561f, -0.87018973f, 0.05316012f, 
    -1.04574943f, -0.04202198f, -0.00649681f, -0.04947157f, 0.03009714f, 0.09734497f, 0.04849151f, -0.05020779f, 
    -0.36392143f, -0.49296415f, 0.24175625f, 0.03896251f, -0.73684013f, 0.08352452f, -0.28658953f, -1.02751243f, 
    0.09838998f, -0.17880543f, -0.03973467f, -0.45417184f, -0.23867160f, -0.58729708f, 0.09151624f, -0.40384221f, 
    -0.06768340f, -0.03176012f, 0.03704035f, 0.02535210f, 0.07079269f, 0.17233746f, -0.06881043f, 0.12470336f, 
    -0.37042281f, 0.16083390f, -0.21509233f, 0.06600839f, -0.01596660f, -0.11077056f, 0.00477498f, -0.22538565f, 
    -0.75922209f, 0.28172329f, -0.46583119f, -0.03306396f, -0.12002939f, 0.13296096f, -0.39025432f, 0.06422902f, 
    -0.21539152f, -0.45301574f, -0.18606892f, 0.42479721f, 0.10696923f, -0.10831346f, -0.07569264f, -0.10746896f, 
    -0.70887482f, -0.09719311f, 0.19548945f, -0.04161911f, -0.56389832f, 0.58332306f, 0.15093027f, 0.03723289f, 
    0.07552351f, 0.01700133f, -0.05457545f, 0.01142387f, 0.30649355f, 0.21780106f, 0.18867151f, 0.15413654f, 
    0.02273235f, -0.18203562f, 0.02757708f, 0.02063694f, 0.36238277f, -0.15307991f, -0.20740403f, 0.00064002f, 
    -0.18212271f, -0.15119413f, 0.23795354f, 0.06942983f, 0.03305997f, 0.00469321f, 0.07436736f, -0.00387839f, 
    -0.03402377f, -0.42996877f, 0.13436861f, 0.10395717f, 0.25779167f, -0.33463624f, -0.60291243f, 0.00327103f, 
    0.00250857f, 0.05350041f, 0.22081488f, -0.43597782f, -0.59102225f, -0.21461354f, -0.33974528f, 0.01607352f, 
    -0.55797189f, -0.01214973f, -0.11331696f, -0.19646867f, -0.83439893f, 0.03729716f, -0.69336909f, 0.13286157f, 
    0.06168180f, -0.27686560f, 0.07661883f, -0.10089748f, 0.07706077f, 0.04293030f, 0.06051981f, -0.24908109f, 
    0.28775826f, -0.25698942f, -0.04612315f, 0.10066451f, 0.12834120f, 0.07527115f, -0.33005598f, -0.17366090f, 
    0.17581514f, 0.00262131f, -0.04583390f, 0.12472256f, 0.05647075f, 0.02046927f, 0.14907552f, 0.03985725f, 
    -1.05573666f, 0.07888680f, -0.27785435f, 0.07183143f, 0.39739200f, -0.28571552f, 0.10197009f, 0.19014430f, 
    0.05153305f, 0.01925845f, -0.41194305f, 0.20371535f, -0.03179393f, 0.15003046f, -0.02308282f, -0.04494760f, 
    0.14693180f, 0.00585971f, 0.04417953f, 0.03866678f, 0.12419870f, -0.56620604f, 0.04757590f, -0.23912030f, 
    0.31124181f, -0.56245232f, 0.26226252f, 0.02304442f, -0.07781681f, -0.11787738f, 0.18433028f, -0.98916453f, 
    0.03457874f, -0.09374578f, 0.17775701f, 0.04263934f, -0.04845748f, 0.17780165f, 0.08696320f, 0.00635067f, 
    0.10982932f, 0.00774952f, -0.29612201f, -0.15332194f, 0.36018693f, -0.37648588f, 0.00816142f, -0.54159153f, 
    0.31083593f, -0.57932651f, 0.10786554f, 0.02359195f, -0.32496727f, -0.39698082f, 0.28283837f, -0.33011338f, 
    0.21742919f, -0.58591783f, -0.15853278f, 0.02212855f, -0.81614029f, -0.56360191f, 0.26490933f, 0.47766474f, 
    0.13478811f, 0.12377472f, 0.16161804f, -0.63429838f, 0.47958627f, -0.07905042f, 0.20103168f, -0.14044271f, 
    0.03349721f, -0.55498880f, -0.04810295f, -0.39579013f, 0.02623211f, 0.21001334f, 0.04998851f, 0.01864564f, 
    -0.00745119f, 0.20706688f, -0.40616408f, 0.09743886f, 0.12469507f, -0.09728574f, -0.40399581f, -0.26496702f, 
    0.12631071f, -0.09845859f, 0.06492063f, 0.00126948f, -1.09830678f, 0.10845523f, 0.18907003f, -0.35494506f, 
    0.18430924f, -0.45587161f, 0.01144529f, -0.26530987f, -0.75896984f, -0.63039541f, -0.58568817f, 0.43190193f, 
    -0.44620332f, 0.09964546f, 0.29303890f, 0.22412425f, 0.09350276f, -0.04263075f, -0.22384495f, 0.00796202f, 
    -0.71426183f, -0.29591006f, 0.11611616f, -0.21403557f, 0.20242186f, -0.11477336f, 0.19389775f, -0.17283052f, 
    -0.75450581f, -0.07419276f, 0.06885988f, -0.14819726f, -0.08816113f, -0.29319328f, 0.41758442f, -0.09612370f, 
    -1.02619553f, -0.25471997f, -0.31268820f, -0.01129179f, 0.23294552f, -0.18692352f, -0.26424512f, -0.53377151f, 
    0.28810549f, -0.17201437f, -0.13830814f, 0.39339820f, -0.49594438f, -0.03063117f, -0.28899902f, 0.09667428f, 
    0.46476048f, -0.08053903f, -0.03609366f, -0.01673335f, -0.42351478f, -0.44631210f, -0.06754807f, -0.60916603f, 
    0.00747633f, -0.26782665f, -0.09147878f, 0.27088115f, -0.43012962f, 0.09467113f, 0.00918699f, 0.51038098f, 
    -0.49731842f, 0.17767383f, 0.00479129f, 0.01271583f, -0.12992649f, -0.39123559f, 0.29286397f, -0.08294020f, 
    0.01092745f, 0.00297199f, 0.15858734f, 0.37234709f, 0.09139277f, -0.15889439f, 0.30542895f, 0.12253693f, 
    -0.26459461f, 0.02529934f, -0.11853682f, -0.06667515f, -0.27790958f, 0.38097605f, 0.06239419f, -0.17432699f, 
    0.05353826f, 0.14653656f, -0.77343225f, -0.10629012f, -0.10179520f, -0.61732841f, 0.00911393f, -0.52010626f, 
    0.07048879f, -0.04025520f, 0.01290270f, -0.09360011f, 0.34746397f, 0.19649097f, -0.43026176f, -0.15132304f, 
    -0.22171797f, -0.36583254f, -0.04468808f, -0.36517006f, -0.04513087f, 0.11481237f, -0.21532123f, -0.33994314f, 
    0.07348942f, 0.06963442f, 0.35508004f, -0.03255763f, 0.04541293f, -0.02745491f, -0.02318572f, -0.66804123f, 
    -0.42741865f, 0.17008425f, 0.09609263f, 0.12513067f, 0.06385191f, -0.01571457f, -0.12386579f, 0.27096125f, 
    0.04494644f, -0.01503960f, 0.03006377f, -0.24111736f, 0.11242444f, 0.25991893f, 0.31052971f, -0.20426323f, 
    0.03359944f, -0.12852260f, 0.04679517f, -0.22871149f, -0.01503876f, -0.09593578f, -0.52662563f, 0.12418670f, 
    0.09875254f, 0.29887730f, 0.01716575f, 0.46007064f, 0.23004353f, -0.02655246f, 0.25805986f, 0.14508127f, 
    0.00213174f, 0.03393121f, -0.05543868f, -0.11581618f, -0.06941206f, -0.05749595f, -0.31253749f, -0.04790948f, 
    0.51234215f, -0.26859382f, 0.21613671f, 0.03777631f, -0.03740173f, 0.17349179f, 0.38588038f, 0.12320196f, 
    0.02047971f, 0.16336887f, -0.26872021f, 0.13117018f, -0.41002604f, 0.24366382f, -0.49898177f, -0.24405108f, 
    -0.25443578f, 0.08777311f, 0.00609454f, -0.06790245f, 0.13342969f, -0.12680468f, -0.12988594f, 0.13460824f, 
    -0.08579129f, -0.06849163f, -0.05638898f, 0.16326334f, -0.21938331f, -0.04550778f, 0.18362787f, 0.05377486f, 
    0.08428764f, -0.29579496f, -0.14397259f, 0.06294409f, 0.07016248f, 0.23483549f, 0.41817579f, 0.02574325f, 
    -0.30018240f, -0.09130105f, -0.37948024f, -0.62491959f, -0.01868646f, 0.13883170f, 0.16364613f, -0.02222149f, 
    -0.16854276f, 0.04837445f, 0.07260790f, -0.05873295f, 0.25517598f, -0.54896039f, -0.13691097f, 0.21214813f, 
    0.18874498f, 0.37139869f, 0.16252021f, 0.02514014f, -0.02945742f, 0.28496948f, -0.03420306f, -0.01772756f, 
    0.15896344f, -0.05484254f, -0.04780706f, -0.08385915f, -0.71205276f, 0.14654149f, -0.05019476f, 0.06254482f, 
    0.18062060f, -0.19164249f, 0.12498499f, -0.13235645f, 0.01832668f, -0.16592199f, -0.57804996f, 0.08763447f, 
    -0.88173753f, 0.02417368f, 0.03381453f, 0.01700766f, -0.09480853f, -0.16951188f, -0.18369772f, 0.01177328f, 
    -0.15750517f, -0.03377018f, -0.77777910f, -0.03975631f, 0.04132300f, 0.34241334f, -0.01828274f, 0.41950816f, 
    -0.12623325f, -0.08482601f, -0.36687186f, 0.25529528f, -0.31665057f, 0.09762155f, 0.33335045f, 0.17842992f, 
    -0.08628482f, 0.15802662f, -0.13390802f, 0.31445608f, -0.33492404f, -0.03914991f, 0.23324373f, -0.29176730f, 
    -0.23759751f, 0.07458428f, 0.07642508f, -0.08525626f, -0.80134708f, -0.29851750f, -0.35477936f, -0.11314651f, 
    0.18905358f, 0.01770251f, 0.02324960f, -0.35766914f, 0.12564847f, -0.26870689f, 0.05796113f, 0.04861381f, 
    -0.04472094f, 0.26184231f, -0.92785537f, -0.08551218f, -0.41847903f, -0.16371617f, -0.10210625f, 0.06499561f, 
    -0.98000067f, -0.48153561f, 0.46201110f, -0.43951446f, 0.21534020f, 0.46409330f, -0.08794617f, 0.20881577f, 
    0.12884001f, -0.10403237f, 0.02853636f, 0.06199805f, -0.88022900f, -0.19265413f, -0.02067117f, -0.52466393f, 
    -0.52081835f, -0.11735506f, -0.36711347f, 0.25833088f, 0.18969058f, 0.00497444f, 0.07244813f, -0.38845235f, 
    0.36512890f, 0.24016845f, -0.71010208f, -0.08663578f, 0.16848096f, 0.24305797f, -0.02154881f, 0.02052513f, 
    -0.78248131f, 0.17776227f, 0.18589750f, 0.09981316f, -0.29062417f, -0.32931438f, -0.19080330f, 0.21564534f, 
    0.01616936f, -0.10334018f, 0.27243167f, -0.02470531f, -0.10954734f, -0.28212726f, -0.09485283f, 0.21878612f, 
    0.03465850f, -0.10131986f, 0.18204196f, 0.01842072f, -0.61652994f, -0.59687185f, 0.11548623f, 0.12007643f, 
    0.06814090f, -0.06468272f, 0.00133166f, 0.24561298f, -0.86827606f, -0.39714599f, 0.14664263f, -0.09736405f, 
    0.29208344f, 0.24741961f, 0.10284421f, -0.14555779f, -0.11544380f, 0.17636381f, -0.38145542f, 0.28047374f, 
    -0.08706136f, -0.48817086f, 0.12102580f, -0.06245913f, -0.19624990f, -0.31050625f, -0.15926516f, 0.07547381f, 
    0.48550999f, 0.20020081f, -0.31770930f, 0.02766265f, 0.18573929f, 0.18058851f, 0.31647941f, -0.62994838f, 
    0.09774448f, 0.12282557f, -0.17199580f, 0.06417695f, 0.31399038f, -0.22009204f, -0.00799257f, 0.11035537f, 
    0.06527469f, 0.16111633f, -0.52502334f, -0.20121959f, -0.42165914f, -0.06566929f, -0.04909125f, 0.05794542f, 
    -0.44227862f, 0.00492178f, 0.12791254f, 0.17037196f, -0.39197901f, -0.16720158f, -0.13222933f, -0.11080842f, 
    -0.43218252f, -0.04425757f, 0.00302619f, 0.15738863f, 0.16554804f, -0.02499005f, -0.00047706f, -0.06043721f, 
    -0.39353368f, 0.16970925f, -0.25923651f, -0.03831938f, -0.19844685f, 0.23284100f, -0.15748270f, -0.44156659f, 
    -0.15299316f, 0.30676618f, -0.73139209f, 0.16646361f, -0.26840687f, -0.27215007f, -0.20542732f, -0.06997076f, 
    0.03486736f, 0.10309716f, 0.07695313f, -0.06450672f, -0.07392149f, -0.42329425f, -0.02476550f, 0.06607454f, 
    -0.34853330f, 0.05662941f, 0.27157581f, 0.12296987f, 0.22568186f, -0.05364218f, -0.06426232f, -0.34542683f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.18847392f, -0.07621977f, -0.22427696f, -0.31523758f, 0.25842524f, 0.09675985f, 0.09374908f, -0.48738688f, 
    -0.20196372f, -0.06450720f, 0.37638217f, 0.12684321f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
