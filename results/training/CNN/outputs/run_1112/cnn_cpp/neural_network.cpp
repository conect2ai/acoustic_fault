#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.43675610f, -1.12880325f, -0.38509756f, 0.29768738f, 0.51215398f, 0.38908714f, 0.35235602f, 0.00454623f, 
    -0.19227944f, 0.14683698f, 0.11499180f, -0.09954061f, 0.07888105f, -0.25999418f, 0.17338324f, 0.15486914f, 
    -0.25809643f, 0.02700589f, -0.17046273f, -0.04989418f, -0.13636488f, -0.13997604f, -0.15270080f, 0.06991638f, 
    -0.28149435f, 0.36709988f, 0.58718580f, 0.31140304f, -0.36528212f, 0.03386980f, 0.09032254f, -0.23929712f, 
    -0.05258174f, -0.10078876f, -0.26012486f, -0.25066614f, 0.02205782f, 0.03000967f, 0.16539493f, 0.02895859f, 
    0.09663770f, -0.06055896f, -0.23050831f, -0.02478299f, 0.05701470f, -0.12108311f, 0.23440540f, -0.27263471f, 
    0.17053367f, 0.28230199f, 0.30382326f, 0.94267225f, 0.00051541f, -0.23697621f, 0.21153969f, -0.31553829f, 
    -0.56493181f, 0.06837091f, 0.54432571f, -0.17353238f, 0.11847033f, -0.32651162f, -0.07379047f, 0.02224964f, 
    -0.24675488f, -0.06989218f, 0.23715247f, 0.18609479f, -0.15588237f, -0.16065878f, 0.10966749f, 0.11648319f, 
    -0.17077242f, 0.07947437f, -0.00809220f, -0.22540368f, 0.46638727f, -0.58992070f, -0.16209988f, -0.05689873f, 
    0.08010845f, 0.13716885f, 0.49709350f, -0.20166239f, -0.29815039f, 0.26504079f, -0.20087838f, 0.17807044f, 
    -0.04146123f, -0.18961571f, -0.12723063f, -0.33241281f, -0.16243094f, 0.07053348f, 0.20835961f, 0.12760940f, 
    -0.08506037f, 0.09539668f, 0.18015479f, 0.40884909f, 0.46369928f, -0.19669028f, -0.14189513f, 0.03894336f, 
    -0.26007843f, 0.54323930f, -0.33327675f, -0.13867889f, 0.02408946f, 0.26510116f, 0.14554298f, -0.08624812f, 
    0.03612393f, -0.31185395f, 0.36794505f, 0.08187634f, -0.07805812f, -0.11944755f, 0.00627291f, -0.17854480f, 
    0.07144912f, 0.05839956f, 0.20351483f, 0.11329368f, 0.42117551f, -0.42031279f, 0.52963895f, 0.66949755f, 
    -0.72763026f, -0.29591280f, -0.06756113f, -0.17618327f, -0.36160281f, -0.21919511f, -0.59085178f, 0.07064858f, 
    -0.06046161f, 0.10311957f, -0.42996278f, 0.17820163f, 0.07336571f, -0.21320128f, -0.17910111f, 0.20146936f, 
    -0.41115236f, -0.06868111f, 0.13124102f, 0.07321865f, -0.20141530f, 0.17490244f, 0.47621581f, 0.26691988f, 
    0.31195450f, 0.13994816f, 0.14247379f, 0.08251091f, 0.38689026f, 0.16971107f, 0.09098280f, 0.21026477f, 
    -0.15581180f, 0.06906459f, 0.34618199f, -0.20764020f, -0.28101468f, -0.10830710f, 0.18918498f, -0.25693104f, 
    -0.07152888f, 0.00969511f, -0.19557501f, 0.11089738f, 0.01082881f, -0.24703124f, 0.20994240f, 0.20702274f, 
    -0.49037749f, 0.11557111f, 0.65572834f, 0.26153100f, -0.71387851f, -0.35523468f, -0.01025173f, -0.00876585f, 
    -0.00189017f, 0.32132721f, -0.41922423f, 0.16035189f, 0.07780520f, -0.00610949f, 0.06574735f, -0.21263027f, 
    0.25942093f, -0.03244458f, -0.18993369f, -0.22652990f, 0.00851716f, -0.02322254f, 0.29005370f, 0.23848200f, 
    0.54471117f, 0.03203785f, 0.17402732f, 0.34350613f, 0.19861904f, -0.26095426f, -0.09052857f, 0.05580629f, 
    -0.15362701f, -0.10251124f, -0.21919113f, 0.03088305f, 0.08034911f, 0.14760774f, -0.20926109f, 0.00403680f, 
    -0.01866514f, 0.18030654f, 0.19134003f, -0.18695675f, -0.14732364f, -0.24241240f, -0.24793273f, -0.35017100f, 
    -0.34018958f, -0.15351172f, -0.42085001f, -0.71211851f, -0.32472283f, 0.12938394f, -0.31364429f, 0.09003910f, 
    0.30087668f, 0.04424784f, -0.27381888f, -0.26516631f, -0.10568976f, 0.02924911f, -0.08677464f, -0.02856341f, 
    0.14013678f, 0.07201293f, -0.09888659f, 0.05503507f, 0.03125229f, 0.12842178f, 0.36299416f, -0.05683850f, 
    -0.01588277f, 0.47210065f, -0.16966100f, 0.63740200f, -0.50781107f, -0.23585613f, -0.57620984f, -0.37800467f, 
    -0.26640570f, 0.05164600f, 0.50707036f, 0.30392191f, 0.23229761f, -0.12245458f, 0.13902465f, 0.12197918f, 
    -0.01649272f, 0.00373415f, 0.06771884f, 0.19232526f, 0.11100868f, -0.13757896f, 0.00552625f, 0.10986804f, 
    -0.02153566f, -0.16593462f, -0.22109643f, 0.21078874f, 0.29933682f, 0.14064027f, 0.22898890f, 0.27242067f, 
    0.25814402f, -0.47668049f, -0.51386666f, -0.22860198f, -0.59375030f, -0.24123593f, 0.12487677f, -0.23950525f, 
    -0.20962499f, -0.20567980f, 0.26637048f, 0.20735629f, 0.21568123f, 0.00929855f, -0.20598876f, -0.16722389f, 
    0.10692529f, -0.04083982f, 0.12239068f, -0.01314590f, 0.29116154f, 0.61167777f, 0.45168310f, -0.04565964f, 
    -0.21011895f, -0.01244173f, -0.30453455f, -0.34348550f, -0.12922245f, 0.13312779f, 0.02080981f, 0.14068015f, 
    -0.07805889f, 0.32536423f, -0.34188837f, 0.04728412f, 0.12373634f, -0.25175917f, 0.23862046f, 0.05430420f, 
    0.27865890f, 0.07125462f, 0.05180127f, 0.01932374f, -0.20664704f, -0.31449157f, -0.46214083f, -0.56634986f, 
    -0.00602950f, -0.32587540f, -0.42326331f, -0.06659488f, -0.43589094f, -0.27557981f, -0.43755707f, 0.09500485f, 
    0.27355152f, 0.03550398f, -0.20057297f, -0.20402436f, -0.13210215f, -0.14909546f, 0.21906036f, -0.15595420f, 
    -0.06310686f, -0.19719447f, 0.13479482f, 0.00933829f, -0.24799021f, -0.18960087f, -1.10819459f, 0.18406826f, 
    -0.35767668f, 0.12827814f, 0.74063981f, -0.17124088f, -0.48207277f, 0.40162894f, 0.37361410f, 0.56171435f, 
    0.00846711f, -0.04767890f, 0.29371583f, -0.26459157f, 0.07322083f, 0.03138388f, 0.05870732f, -0.06370079f, 
    -0.20507547f, 0.14882770f, 0.04143712f, -0.11197948f, 0.13373928f, 0.04547364f, -0.10354211f, -0.81907886f, 
    0.40383527f, 0.35953480f, 0.44109061f, -0.11341767f, -0.57262355f, -0.50249934f, -0.07463830f, 0.23898508f, 
    0.34186015f, 0.00911827f, 0.19769433f, -0.04433266f, 0.08068454f, -0.11333490f, 0.03117316f, 0.00507365f, 
    0.13450022f, 0.02274738f, -0.13586123f, 0.15909454f, -0.21446964f, -0.03627077f, 0.15603089f, -0.00659122f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.30918562f, 0.04207131f, 0.17381313f, 0.30012646f, 0.20277624f, 0.13491632f, -0.27254367f, 0.04812074f, 
    0.06869941f, -0.23820502f, 0.23359787f, -0.09001238f, 0.32541925f, -0.23705010f, 0.20404108f, -0.00660124f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.17026521f, 0.17679183f, -0.00336871f, 0.00319344f, 0.07206929f, -0.02773565f, -0.09225206f, -0.22742079f, 
    -0.02777228f, 0.08390589f, -0.02509240f, 0.14093812f, -0.23316601f, 0.02763351f, -0.25103968f, 0.07309737f, 
    0.14629579f, 0.03793237f, -0.06473125f, -0.01359627f, -0.14590682f, -0.02472129f, -0.10153924f, -0.24735978f, 
    0.01591426f, -0.01075445f, -0.40516952f, 0.30221823f, -0.02491666f, 0.00140843f, 0.10186949f, -0.06558537f, 
    -0.01074620f, -0.13813037f, -0.04841784f, 0.03179218f, 0.00008255f, -0.01418836f, 0.10323557f, 0.09306321f, 
    0.02814640f, -0.01354398f, -0.14077897f, 0.07810299f, -0.12660283f, -0.20709361f, -0.09793509f, -0.25497344f, 
    0.03407322f, -0.15623526f, 0.01138966f, 0.21448751f, 0.07777189f, 0.06718896f, -0.09551304f, -0.26474479f, 
    -0.19499981f, -0.26508263f, -0.09027364f, 0.01002788f, 0.23943153f, 0.23977317f, -0.01648518f, 0.22325182f, 
    0.09098601f, 0.11471415f, 0.13098599f, 0.06625984f, 0.15326270f, 0.08841573f, -0.04834935f, -0.03998579f, 
    -0.03980655f, -0.33270410f, -0.13497543f, 0.04733950f, 0.30831891f, -0.04623428f, 0.05645808f, 0.03838378f, 
    0.04694794f, -0.17187598f, 0.06756449f, 0.10439673f, 0.06167660f, -0.19435950f, 0.51438218f, -0.03109125f, 
    0.07941370f, -0.12720558f, -0.14075778f, 0.03383338f, -0.06409634f, 0.05185442f, 0.09075048f, -0.05967310f, 
    -0.01120031f, -0.25861752f, 0.09187860f, -0.02314577f, 0.12384345f, 0.05416687f, 0.15528554f, -0.07200570f, 
    0.13272078f, -0.04161770f, 0.12285700f, 0.26901099f, 0.22215703f, -0.05592111f, 0.00041165f, 0.04931243f, 
    0.00845243f, -0.05706305f, -0.02432869f, -0.01780264f, -0.13391556f, -0.14533509f, -0.01847136f, -0.08277035f, 
    -0.02832604f, 0.06445787f, 0.04244438f, -0.05406198f, -0.17282361f, 0.05735966f, 0.09045224f, -0.05386432f, 
    0.00267894f, -0.08988682f, 0.11791948f, -0.00194449f, 0.36869720f, 0.12289047f, -0.00436835f, 0.25904062f, 
    0.09122564f, 0.25493097f, 0.09360385f, 0.03678361f, -0.03405671f, 0.09835625f, -0.00902154f, -0.17298257f, 
    -0.22017589f, 0.06042454f, -0.44252968f, 0.02178740f, 0.04573978f, 0.09073862f, 0.08692243f, -0.16261593f, 
    -0.14364932f, 0.02796106f, -0.21123432f, -0.04931107f, 0.33085021f, 0.07515347f, 0.09294485f, 0.07434031f, 
    0.14213352f, -0.14738923f, 0.06819164f, 0.12009563f, 0.09219248f, 0.12497806f, 0.14003329f, -0.01057809f, 
    -0.04442249f, 0.28174901f, 0.07107265f, -0.35645479f, 0.00033039f, -0.04809739f, -0.09519385f, 0.01074612f, 
    0.11374553f, 0.00444990f, -0.01043596f, -0.07026464f, -0.00685887f, 0.35063201f, 0.01736925f, -0.05201843f, 
    -0.10994645f, 0.18609060f, 0.07102361f, -0.02471827f, 0.00776297f, 0.03106143f, 0.03184756f, 0.09955472f, 
    0.25795168f, 0.26512036f, -0.16084667f, 0.01472330f, -0.06915440f, 0.02181744f, 0.10314946f, -0.12969327f, 
    0.00195155f, 0.10163815f, 0.08693434f, 0.06874529f, 0.04957629f, -0.18230461f, -0.12444051f, 0.07930154f, 
    0.03595852f, 0.05773481f, 0.05389897f, -0.03763044f, 0.03482134f, 0.11296646f, 0.13627972f, -0.05037430f, 
    -0.56865317f, -0.14663966f, -0.18680204f, 0.21122220f, -0.02848411f, -0.02299186f, 0.11186088f, 0.06967431f, 
    0.09058385f, 0.05525024f, 0.02583252f, 0.06459309f, 0.08305441f, 0.01868455f, 0.12883447f, -0.06522392f, 
    -0.06352894f, -0.12551779f, 0.02571222f, -0.04195201f, -0.10136049f, -0.02933367f, 0.08391545f, -0.06702343f, 
    0.07957293f, 0.00722279f, -0.09875900f, 0.14856057f, 0.05102953f, 0.13552766f, 0.07765575f, 0.10377245f, 
    -0.19923659f, 0.01898344f, 0.08348429f, -0.12300357f, 0.22514571f, -0.11119325f, -0.23956136f, 0.02614503f, 
    0.02461955f, 0.10395795f, 0.11769640f, 0.08836516f, -0.00378122f, -0.00618263f, 0.07278659f, -0.06781925f, 
    -0.23130590f, -0.27391398f, 0.03748227f, -0.03699345f, 0.04132530f, 0.02432161f, 0.12820747f, 0.03239401f, 
    -0.06680762f, 0.06431227f, -0.00941963f, -0.08132166f, -0.34425443f, 0.18109868f, 0.24597266f, -0.34153739f, 
    0.08608869f, 0.20475450f, -0.00567992f, 0.00431419f, -0.01649946f, 0.07474691f, 0.03263596f, 0.08443792f, 
    -0.36109602f, 0.08253295f, 0.00502065f, -0.19459349f, 0.05127264f, 0.02679286f, -0.14139731f, 0.05261334f, 
    -0.02074878f, -0.12412553f, -0.14403833f, 0.05927245f, 0.19677779f, 0.16359709f, 0.02494592f, -0.03054468f, 
    -0.05185662f, 0.01592379f, -0.00998197f, 0.00120542f, 0.03408030f, 0.04088686f, -0.00709313f, -0.09595218f, 
    0.02537838f, 0.05424828f, 0.07358374f, -0.04604906f, 0.02486166f, 0.07533435f, 0.07322260f, -0.02610403f, 
    -0.09447251f, 0.01843154f, -0.09095435f, 0.09017190f, -0.21068586f, -0.20970981f, -0.36618420f, 0.05921150f, 
    0.06455292f, 0.13729911f, -0.08065673f, 0.06346748f, -0.02995051f, 0.07447471f, -0.01694977f, 0.03274148f, 
    -0.04082123f, -0.08589176f, 0.00785762f, -0.01492027f, -0.11466982f, -0.04996753f, 0.16670968f, -0.12444165f, 
    -0.01437591f, -0.01400831f, -0.04090131f, 0.00818869f, 0.19189577f, 0.06948461f, -0.10384807f, -0.09689282f, 
    0.04156702f, 0.09386282f, 0.06754539f, 0.10581658f, -0.17104252f, -0.10475747f, -0.04463777f, -0.08639314f, 
    0.17691934f, 0.36619326f, 0.25263971f, -0.29505494f, 0.02553537f, 0.39759293f, 0.04814092f, 0.08805638f, 
    -0.00052612f, 0.02089242f, 0.09363831f, -0.12756371f, -0.06301125f, 0.17747280f, 0.16447487f, -0.35964268f, 
    -0.06969471f, 0.18391444f, -0.11303541f, -0.02606758f, 0.14237389f, -0.11560927f, 0.09656350f, 0.03764004f, 
    -0.09775049f, 0.01859564f, 0.34573445f, 0.29649216f, 0.04588018f, 0.05996848f, -0.17027257f, 0.00310181f, 
    0.02565929f, -0.00136993f, 0.06015994f, 0.12621668f, -0.16630429f, -0.14781392f, -0.01509358f, -0.10859821f, 
    0.10074252f, 0.10200886f, -0.03265464f, -0.01895479f, 0.02780710f, 0.04116025f, -0.10636891f, -0.06140557f, 
    0.19245510f, -0.05400521f, -0.37879500f, -0.07035034f, -0.02197649f, -0.17257258f, -0.15318458f, -0.10068131f, 
    -0.05138787f, -0.02182238f, -0.10949498f, 0.09619274f, 0.04504521f, 0.00882042f, 0.22823949f, 0.02731779f, 
    0.02753182f, 0.21147870f, 0.01883569f, 0.01235004f, -0.06028019f, 0.09495182f, 0.06329332f, 0.13968177f, 
    0.07290137f, 0.12996165f, -0.03165159f, 0.05033325f, 0.16602264f, 0.11622301f, 0.12405375f, 0.15434931f, 
    0.09939522f, 0.09646790f, 0.03281149f, 0.15132064f, -0.06953702f, -0.05507297f, 0.02727153f, -0.02915867f, 
    0.11752729f, 0.00823304f, 0.18525204f, 0.05335213f, 0.04965539f, 0.11465481f, 0.07011429f, 0.10193488f, 
    -0.05505088f, -0.05832755f, 0.14606062f, -0.06176717f, -0.10755668f, -0.15247434f, -0.10296050f, -0.09069572f, 
    0.02068108f, 0.09466492f, 0.00081829f, -0.05713815f, 0.03486288f, -0.01676910f, -0.17451671f, 0.09595622f, 
    0.02849462f, 0.10292213f, 0.12764187f, 0.20944026f, -0.01362746f, -0.16900179f, 0.04153078f, 0.01108074f, 
    0.15030019f, -0.05871083f, 0.07399209f, -0.06589288f, 0.13974468f, 0.05507983f, 0.04550048f, 0.01141569f, 
    0.06371703f, 0.01767427f, 0.11185380f, -0.10520846f, -0.21218170f, -0.14947562f, 0.23970081f, 0.02415378f, 
    -0.20189519f, -0.03983058f, -0.11915588f, -0.06176899f, -0.05244983f, -0.09362852f, 0.02987022f, 0.01845998f, 
    -0.11295217f, 0.09164681f, -0.03398574f, -0.09124060f, 0.05708202f, -0.01330510f, 0.12957039f, 0.11299298f, 
    -0.03647481f, 0.13722023f, 0.10747726f, 0.03320884f, 0.21571635f, -0.10307001f, 0.04241504f, -0.02527370f, 
    0.14577320f, 0.03129995f, 0.05499635f, -0.09365050f, 0.12573697f, -0.09691803f, -0.00645304f, -0.03811301f, 
    0.16450518f, 0.09065701f, -0.05373316f, 0.06475151f, 0.19244444f, 0.15553337f, 0.16958521f, 0.13889141f, 
    -0.05198662f, -0.03116492f, 0.01426431f, 0.10888159f, -0.23555753f, -0.03412215f, 0.20253563f, 0.13952132f, 
    -0.20906581f, -0.00205295f, 0.01157289f, -0.05058552f, 0.11029755f, 0.05022587f, -0.08625778f, 0.00010233f, 
    -0.45390153f, 0.12686475f, 0.18178828f, 0.30875930f, -0.15249942f, 0.00477250f, -0.05545538f, -0.08546204f, 
    0.09064059f, -0.00056471f, 0.03260177f, 0.20496649f, -0.44245553f, -0.14748101f, -0.29318750f, 0.13362013f, 
    0.14643709f, 0.01650723f, 0.13709246f, -0.03750400f, 0.01986917f, -0.07031944f, -0.00098844f, 0.09886602f, 
    -0.04801132f, -0.15226802f, 0.32809669f, 0.11523786f, 0.01153901f, -0.00282013f, -0.06200713f, 0.11582486f, 
    0.16697244f, 0.09930646f, 0.12624885f, 0.11232534f, -0.26081076f, -0.18318884f, -0.12402491f, 0.00285245f, 
    0.12754115f, 0.13613197f, -0.04154904f, -0.00026291f, -0.00141743f, 0.04534502f, -0.04603366f, -0.12385851f, 
    0.08552638f, -0.01347716f, -0.45736635f, -0.26866579f, 0.02281591f, 0.01088946f, -0.02570401f, -0.09156762f, 
    -0.13532095f, -0.03060865f, 0.09013538f, 0.19180186f, -0.01786140f, 0.15560664f, 0.13218375f, 0.00423129f, 
    -0.06440590f, 0.09169730f, -0.12573999f, 0.00798497f, -0.05208532f, -0.01820100f, -0.13190551f, 0.02142040f, 
    -0.05785841f, 0.00599656f, 0.05561581f, 0.00487557f, 0.02528063f, -0.18304488f, -0.08777718f, 0.00375520f, 
    -0.01907694f, 0.05312715f, 0.04551051f, 0.14672557f, -0.06798330f, -0.03233659f, 0.04534288f, 0.07331369f, 
    0.16675925f, -0.28535932f, 0.18089519f, 0.00096604f, 0.06729926f, -0.04454776f, 0.00824982f, 0.04779948f, 
    -0.17086524f, -0.05094849f, -0.02037338f, -0.20609304f, -0.11108924f, -0.03455172f, 0.00328520f, -0.12572032f, 
    -0.04360826f, 0.00940314f, -0.05000615f, 0.11977713f, 0.01140639f, -0.19655474f, -0.19729987f, 0.19768070f, 
    -0.01868565f, 0.08586051f, -0.01743877f, 0.11801485f, -0.07456362f, -0.02877854f, 0.00423835f, -0.01717017f, 
    0.03265569f, -0.17703432f, -0.07156365f, -0.16701803f, 0.01976792f, 0.06612111f, 0.01585338f, 0.05285011f, 
    0.00523825f, 0.16558723f, -0.02944946f, -0.14515550f, -0.15801811f, -0.12094425f, 0.14576899f, 0.04052190f, 
    -0.09692614f, 0.07407496f, -0.10036186f, -0.05976245f, 0.03021712f, -0.05396499f, -0.04118130f, 0.08175374f, 
    0.07561800f, 0.09963022f, -0.10179701f, 0.02958532f, 0.06307469f, 0.04638179f, 0.16849735f, 0.18192813f, 
    0.16309440f, -0.04713995f, 0.02244908f, -0.06167473f, 0.00463923f, -0.01359588f, 0.21928865f, 0.03761361f, 
    0.05739679f, 0.06398936f, 0.01693653f, -0.15473251f, 0.03226986f, -0.09936506f, 0.06450073f, 0.01193917f, 
    -0.03130334f, -0.11306576f, -0.00746121f, 0.07295902f, 0.04089430f, 0.26506513f, 0.05433241f, 0.01246243f, 
    -0.07568982f, 0.05688910f, -0.04751049f, -0.05834047f, -0.25810406f, -0.03523615f, 0.24526446f, 0.11866030f, 
    -0.17388727f, 0.06405762f, -0.00088793f, -0.08553939f, 0.10160252f, 0.08993134f, 0.07758848f, -0.03729607f, 
    -0.19978148f, -0.13236396f, -0.05198864f, 0.18763013f, -0.20168290f, -0.19896877f, -0.03571011f, -0.01175594f, 
    0.13286877f, -0.02760577f, 0.05787006f, -0.00967162f, -0.11615885f, -0.28559944f, -0.21585733f, 0.25096643f, 
    0.19045612f, 0.16499019f, 0.16598617f, 0.13415900f, 0.03997492f, 0.00099366f, -0.14313275f, 0.00700456f, 
    0.06130787f, -0.22041617f, 0.07188714f, 0.28428775f, 0.04782979f, -0.07406095f, 0.01920920f, 0.05908722f, 
    -0.00155360f, 0.14041851f, 0.09532238f, 0.06350002f, 0.46458277f, 0.07609371f, 0.05805945f, -0.11285678f, 
    -0.12467649f, -0.04423822f, 0.02380571f, 0.03525320f, -0.10277840f, 0.04880262f, -0.02751370f, -0.02996055f, 
    0.48958072f, -0.13286772f, 0.07427721f, -0.08484714f, -0.16927220f, -0.14696899f, 0.00441982f, 0.00550356f, 
    -0.03860923f, -0.08840161f, -0.09066091f, -0.18307376f, -0.03004353f, 0.01166335f, 0.07384168f, -0.12905715f, 
    0.17452997f, 0.02498042f, -0.07182178f, 0.24563268f, -0.12823470f, -0.10587841f, -0.20784602f, 0.02455349f, 
    0.19906063f, 0.06567714f, 0.17821854f, 0.05953370f, 0.20390870f, 0.03368630f, 0.07195752f, 0.04666700f, 
    -0.15339194f, -0.14774229f, -0.18908860f, -0.26510933f, -0.20503275f, -0.02288770f, 0.03738799f, 0.04763214f, 
    -0.03247882f, 0.07350280f, -0.04216023f, -0.12325242f, 0.04219902f, 0.12536339f, 0.12272902f, -0.06714924f, 
    0.21906367f, 0.11070284f, 0.13417855f, -0.08339078f, -0.01932710f, 0.01170102f, -0.03434461f, 0.08777846f, 
    0.07624201f, 0.18915921f, -0.02734838f, -0.10449692f, 0.15878277f, -0.09065344f, -0.09168009f, -0.03532277f, 
    -0.02786963f, -0.14333226f, -0.04883068f, 0.18840252f, -0.01045970f, -0.09512713f, 0.01730009f, -0.27858707f, 
    0.28291222f, 0.03525735f, 0.04225725f, -0.00390326f, 0.17340755f, 0.02890016f, 0.22004239f, -0.00269185f, 
    0.10715437f, 0.10161116f, 0.12522887f, 0.31348473f, 0.00888831f, -0.13993634f, 0.13183370f, 0.05230009f, 
    -0.18472879f, -0.15934481f, -0.18651485f, -0.03581150f, -0.05762266f, -0.25315291f, -0.10985307f, -0.08624528f, 
    -0.14096639f, 0.09778108f, 0.06739803f, 0.06112072f, 0.15533337f, 0.14625303f, -0.04793455f, -0.08016293f, 
    0.11456326f, 0.17219234f, 0.16635457f, 0.18086275f, 0.37880620f, -0.17793958f, -0.00539806f, 0.11134853f, 
    -0.13620801f, -0.06085421f, -0.00551326f, 0.09817228f, -0.02082779f, 0.05222636f, -0.05232324f, -0.00763933f, 
    0.24528947f, 0.10071781f, 0.12094480f, 0.05089388f, 0.03162782f, 0.17980765f, -0.00202780f, -0.08459212f, 
    -0.09396693f, -0.12003915f, 0.01243708f, -0.03765922f, -0.08788165f, -0.16179515f, 0.17162232f, 0.10571653f, 
    -0.07039121f, -0.07501727f, -0.05908093f, 0.05232514f, 0.06104973f, 0.18498456f, 0.04530646f, -0.09929593f, 
    -0.11154141f, 0.02958570f, -0.03673065f, 0.15865798f, 0.03763535f, 0.12539157f, -0.15373030f, 0.04257818f, 
    -0.02131752f, 0.13200773f, -0.06957125f, -0.11534284f, -0.19889754f, -0.04536133f, -0.25658268f, 0.11421797f, 
    0.16356353f, 0.00236551f, 0.08090881f, -0.18193996f, -0.05851303f, -0.05934638f, 0.06973808f, -0.10256732f, 
    0.29272640f, 0.01951153f, 0.37931922f, 0.19244254f, -0.12393806f, 0.07688767f, -0.04079545f, 0.02264856f, 
    0.06138372f, 0.20349912f, 0.09627170f, -0.07477341f, -0.27782732f, -0.02749203f, 0.11661521f, -0.19489251f, 
    0.05627071f, 0.08470938f, 0.03864320f, 0.01283031f, -0.04055488f, -0.03127342f, -0.08867888f, -0.08991761f, 
    -0.47058493f, 0.07462933f, 0.11250276f, -0.18537617f, 0.03969047f, -0.01859277f, 0.09107080f, -0.01246827f, 
    0.00505663f, 0.06374896f, -0.02248520f, 0.05473195f, -0.04352698f, 0.06665048f, -0.00413642f, -0.03270712f, 
    0.03453702f, -0.07429107f, 0.22733550f, -0.03317177f, -0.08845650f, 0.02972953f, 0.09427387f, -0.12085695f, 
    0.00962503f, 0.00024677f, 0.18647161f, -0.07067639f, 0.18676981f, -0.05005630f, 0.07998757f, 0.18173164f, 
    0.06636275f, 0.05542506f, 0.01630046f, -0.00506115f, -0.04144339f, -0.15185019f, -0.04369819f, 0.07839774f, 
    0.15151747f, -0.03134272f, -0.15760781f, -0.11447400f, 0.16505681f, 0.00262406f, 0.01822300f, 0.04788827f, 
    -0.27671188f, 0.12259659f, 0.03481653f, 0.03083627f, 0.05174404f, 0.02533559f, 0.04798532f, -0.08149870f, 
    -0.01167283f, -0.14136717f, -0.11666121f, -0.00376540f, -0.39651212f, 0.05652796f, -0.51295078f, 0.16720481f, 
    -0.13266665f, 0.06886166f, 0.14172104f, 0.07500331f, 0.05152078f, 0.08058463f, 0.07229434f, -0.05388381f, 
    -0.02346991f, -0.06089465f, -0.18954888f, 0.00697397f, 0.11629986f, 0.03143017f, 0.06967946f, 0.05413321f, 
    -0.12250642f, -0.20310353f, 0.02067493f, 0.17206717f, -0.15825546f, 0.02274924f, 0.08969479f, 0.01344342f, 
    -0.17289609f, 0.04890730f, -0.04638489f, -0.05961701f, 0.08988085f, -0.02768648f, -0.03900287f, -0.07615435f, 
    0.10981654f, 0.34953958f, -0.08994038f, -0.01691975f, 0.04262429f, 0.14015976f, -0.07487585f, -0.02573518f, 
    0.11912501f, 0.10735293f, 0.02678083f, 0.20740072f, -0.35578749f, -0.50290960f, -0.07781625f, -0.20461695f, 
    0.23360038f, 0.02725338f, 0.06732841f, -0.04300611f, 0.00027307f, -0.01637554f, -0.06995209f, 0.01061997f, 
    0.02482369f, -0.20122698f, -0.13677631f, -0.13863316f, 0.16076909f, 0.22841114f, -0.11161442f, 0.11837510f, 
    0.07268523f, -0.13358797f, 0.11799628f, 0.12595545f, -0.35846645f, -0.22050601f, 0.07212683f, 0.01671896f, 
    -0.06005668f, 0.10093267f, 0.01541562f, -0.08264228f, 0.06400836f, 0.09451836f, 0.01134076f, -0.02245655f, 
    0.37084717f, 0.17022040f, -0.19495369f, 0.31328079f, -0.02445669f, -0.06468417f, 0.04772486f, -0.00442837f, 
    0.13250692f, 0.09068917f, 0.09031628f, 0.11071867f, 0.13203926f, -0.18180051f, -0.29713058f, 0.12391552f, 
    -0.08377245f, 0.10481735f, -0.01449441f, -0.02958255f, 0.11262459f, -0.01027374f, 0.20711268f, 0.00727924f, 
    0.27375099f, -0.22089194f, -0.17860593f, -0.19164640f, -0.08812557f, -0.08614064f, 0.11438801f, 0.06658152f, 
    0.12669928f, 0.03668474f, 0.09836678f, -0.01339363f, 0.06259456f, 0.05198059f, 0.00764818f, 0.00019970f, 
    -0.04323876f, -0.01434768f, -0.04041962f, 0.01531487f, -0.05182890f, -0.04895386f, 0.06586954f, 0.10000579f, 
    -0.02406753f, -0.13107228f, 0.37225321f, -0.04191293f, 0.08792239f, 0.06298083f, -0.04071349f, 0.02640649f, 
    0.03390479f, -0.04448348f, 0.14061606f, 0.07517478f, -0.05175164f, 0.22140330f, -0.11831026f, -0.05193609f, 
    0.13915542f, 0.07336705f, 0.22976686f, -0.04808388f, -0.05451885f, 0.16792275f, -0.05752317f, 0.04967936f, 
    0.08877107f, -0.10780182f, 0.04732282f, -0.06499045f, 0.05622115f, 0.17299411f, 0.10233846f, 0.06863458f, 
    0.09046378f, 0.02186655f, -0.02637434f, -0.13263904f, -0.28131515f, 0.12212647f, -0.24641706f, 0.00083374f, 
    0.06033596f, 0.05193824f, -0.00195034f, 0.01796538f, -0.09819290f, -0.01000441f, -0.04965478f, -0.09975996f, 
    0.05175141f, 0.21159419f, 0.01606333f, 0.26205233f, -0.04070529f, 0.07576786f, 0.02334221f, 0.02289704f, 
    0.01475436f, 0.12249896f, 0.05383991f, 0.11181889f, 0.16216609f, 0.11411585f, -0.10624006f, -0.16453837f, 
    -0.06482983f, 0.05506521f, -0.00805877f, -0.24521641f, 0.10690188f, -0.02613420f, 0.07711974f, -0.03927687f, 
    0.00834791f, -0.02709560f, 0.03287485f, 0.02363246f, 0.02251439f, -0.00914252f, 0.01359120f, 0.05080409f, 
    0.04224901f, 0.03656439f, -0.00698379f, 0.02423574f, 0.16435698f, 0.03962991f, -0.15391885f, -0.17272297f, 
    0.38196447f, 0.10348594f, 0.26206893f, 0.00568984f, -0.08421817f, -0.01767198f, 0.02251565f, -0.03131047f, 
    -0.01718629f, -0.22221397f, -0.04132164f, -0.10044608f, 0.16133137f, 0.04799598f, -0.21006317f, 0.08782711f, 
    -0.18891701f, -0.01868863f, 0.03314903f, -0.04989197f, -0.11744263f, 0.11161098f, -0.16642258f, -0.18279673f, 
    -0.11404142f, -0.03069096f, -0.12366684f, 0.01171845f, -0.11796673f, -0.03714829f, 0.03943152f, 0.02297947f, 
    -0.01363635f, -0.12432589f, -0.03784671f, -0.05774057f, -0.06333549f, -0.18990213f, -0.05181324f, 0.12763891f, 
    -0.04047219f, -0.04898630f, 0.05824829f, -0.00682267f, 0.13551243f, 0.13880350f, -0.06311973f, -0.25505024f, 
    0.15863837f, 0.10981615f, 0.09921185f, -0.05809643f, -0.10865481f, -0.22148372f, -0.07269877f, -0.00846226f, 
    0.24223097f, -0.15875983f, 0.01511045f, 0.05784639f, 0.07602739f, -0.02386340f, 0.05207646f, 0.03436900f, 
    -0.03812824f, 0.08633868f, 0.10515276f, -0.09000912f, 0.15679459f, -0.05250529f, 0.18094569f, -0.11899310f, 
    0.02549575f, -0.16139612f, 0.09955428f, 0.09036223f, -0.04797186f, -0.06216860f, 0.10083789f, -0.00176347f, 
    0.15253486f, 0.03690708f, 0.22938120f, 0.08702423f, -0.03146932f, -0.17202398f, -0.13112660f, -0.07777753f, 
    0.10928261f, 0.10539149f, -0.03882236f, 0.19705318f, -0.15632363f, 0.09664612f, -0.05193177f, 0.10583466f, 
    0.08699512f, 0.14794107f, -0.05563472f, -0.05968340f, -0.03574235f, -0.01014516f, -0.14687236f, -0.16859058f, 
    0.14013195f, -0.14667518f, 0.04703599f, 0.00920648f, -0.15485922f, 0.03448702f, -0.12319025f, 0.05252718f, 
    0.11083852f, -0.08221075f, 0.04218090f, 0.09228721f, 0.04764917f, 0.16289258f, -0.02756825f, 0.01641141f, 
    -0.04315149f, 0.13591343f, -0.09073129f, 0.00090951f, -0.03929948f, -0.05903170f, -0.04677748f, -0.12681146f, 
    -0.14286700f, -0.03701097f, -0.18065979f, 0.02924559f, -0.05581383f, 0.04300609f, -0.02784522f, 0.10714224f, 
    -0.06172081f, -0.12996185f, -0.08533194f, 0.13338256f, 0.14977242f, 0.29282436f, -0.09914047f, -0.00952787f, 
    0.26099622f, -0.07091600f, -0.04284081f, 0.06518108f, 0.12578084f, -0.00654624f, 0.14316426f, 0.00192083f, 
    -0.07305059f, -0.11525877f, -0.06725483f, 0.11283741f, -0.12222532f, 0.07164826f, -0.01754596f, -0.09861136f, 
    0.00270570f, -0.10630112f, 0.03298891f, 0.03961880f, -0.07187225f, -0.10816932f, 0.42055014f, 0.12167429f, 
    0.00169186f, 0.15883435f, -0.04653588f, -0.04780094f, -0.08544872f, -0.11173665f, 0.02000465f, -0.01206569f, 
    -0.21700002f, -0.01184568f, 0.06823437f, 0.01734563f, 0.01503885f, -0.03332837f, -0.08269103f, -0.13939932f, 
    0.01421971f, -0.08145627f, 0.09778940f, 0.04852069f, 0.02619170f, 0.01536383f, 0.16845706f, -0.09484588f, 
    -0.05024334f, 0.10400449f, -0.04854313f, 0.00148651f, -0.03989783f, -0.13191450f, 0.01779324f, -0.11388257f, 
    0.30889857f, 0.03195554f, -0.10018914f, 0.07824298f, -0.05289530f, 0.04257023f, 0.09817144f, 0.19284904f, 
    0.06410464f, 0.00991157f, 0.21279810f, 0.04876995f, -0.05235773f, 0.25779322f, -0.04712742f, -0.03740932f, 
    0.09991361f, -0.03566623f, -0.05644162f, 0.00396819f, 0.03041164f, -0.00812617f, 0.02065944f, -0.06412868f, 
    -0.19369963f, -0.09928313f, -0.02618346f, 0.14952911f, 0.06105682f, -0.03162684f, -0.09182039f, 0.03991528f, 
    0.03366245f, -0.06281244f, -0.10112910f, -0.09589428f, 0.17129374f, 0.10408134f, 0.15185247f, -0.03510023f, 
    0.11820755f, 0.08955203f, 0.06643359f, -0.06491421f, 0.00320581f, -0.04092626f, 0.02993307f, -0.03005785f, 
    -0.19962129f, 0.11727330f, 0.21011782f, 0.13172668f, -0.14083689f, -0.19954039f, -0.05442102f, 0.22308536f, 
    0.02206795f, -0.04484990f, 0.05991665f, 0.04382260f, 0.01451665f, -0.11353871f, 0.06822835f, 0.09290462f, 
    0.07275056f, 0.20950434f, -0.18017162f, 0.17424437f, -0.06462302f, -0.07659701f, 0.02030773f, -0.09378886f, 
    0.32057852f, -0.06372216f, -0.08558851f, 0.11542492f, -0.07379913f, 0.03345982f, -0.02751927f, -0.03505150f, 
    -0.03653912f, -0.01784614f, 0.03167652f, 0.08421348f, -0.22395758f, -0.15455432f, -0.18345897f, -0.04068443f, 
    0.04881104f, 0.01008184f, -0.09075589f, 0.01054769f, 0.01134352f, 0.03108647f, 0.08606773f, 0.03357009f, 
    -0.36204717f, -0.46578085f, -0.31234387f, 0.24519335f, -0.07495137f, -0.03667934f, 0.12578565f, 0.03636114f, 
    0.01299572f, -0.05525632f, 0.06306203f, 0.06968635f, 0.11562005f, 0.02645808f, 0.19516645f, -0.00986747f, 
    0.05197386f, 0.02827806f, 0.01307103f, -0.07181991f, -0.08485535f, -0.03846733f, 0.02106692f, 0.04592437f, 
    -0.03986424f, 0.09431662f, -0.02496877f, 0.10106877f, -0.12555224f, 0.24096073f, -0.03907741f, 0.01919312f, 
    -0.12961811f, -0.06433522f, 0.04741102f, -0.00817058f, 0.32133460f, 0.16794722f, 0.10540236f, 0.19376387f, 
    -0.07112766f, 0.09360050f, 0.20865647f, 0.21661240f, -0.01077900f, 0.03449190f, -0.00368132f, 0.00719312f, 
    -0.39047572f, -0.60731936f, -0.21186455f, -0.26144624f, 0.03474226f, 0.01122010f, 0.02805353f, 0.10276568f, 
    -0.08642921f, 0.02695147f, 0.09588233f, -0.09834954f, -0.28066555f, 0.22896725f, 0.41258889f, 0.09103435f, 
    0.08957584f, 0.04099115f, 0.00878199f, 0.09805031f, -0.10826924f, -0.04342058f, -0.00960867f, -0.02085493f, 
    -0.17533633f, -0.00118048f, -0.05181017f, -0.13927904f, 0.00961874f, -0.03013811f, -0.12534927f, -0.05136565f, 
    0.02545233f, 0.07615314f, 0.24485929f, 0.11388244f, 0.42654255f, 0.43019077f, 0.34693354f, 0.32751349f, 
    -0.22388604f, 0.09119803f, 0.14932229f, 0.05278585f, -0.08923931f, -0.05994049f, 0.06924532f, -0.05259037f, 
    -0.11517234f, 0.21114801f, 0.17935997f, -0.01480133f, 0.00652759f, 0.03369728f, 0.08049452f, -0.03687887f, 
    -0.09746595f, 0.03955770f, -0.00331655f, 0.09752779f, 0.25309134f, -0.06326634f, -0.14992823f, 0.22251001f, 
    0.01863577f, -0.11985523f, -0.08776457f, 0.08798183f, -0.02452833f, 0.07034421f, 0.00486348f, 0.03955929f, 
    -0.19950418f, 0.00346357f, -0.11119056f, -0.08067939f, 0.16563000f, 0.00040861f, 0.05278540f, 0.04125220f, 
    -0.04595894f, 0.12509356f, 0.07253432f, 0.08642337f, 0.22290073f, 0.17701747f, 0.06458477f, 0.15347883f, 
    -0.05639483f, -0.08155142f, -0.06419698f, 0.19377933f, 0.08746292f, -0.02015901f, 0.10499670f, 0.06111171f, 
    -0.18553676f, 0.26566771f, -0.01592331f, -0.22381537f, -0.02763058f, 0.21486132f, 0.01360927f, 0.00871038f, 
    -0.03089497f, 0.11364572f, -0.10639527f, 0.10911747f, -0.17874311f, 0.22804080f, 0.09326528f, -0.15088783f, 
    0.03876704f, 0.14830548f, -0.03573470f, -0.03956383f, -0.00432842f, -0.14992878f, 0.04196247f, 0.12119214f, 
    -0.15240659f, -0.36065501f, 0.17483400f, 0.20095350f, 0.05621314f, -0.01358483f, -0.01916083f, 0.00865278f, 
    -0.00826207f, 0.07100479f, 0.15098803f, 0.13865450f, -0.01177349f, 0.02397465f, -0.10711413f, -0.04966340f, 
    -0.00008287f, 0.21610290f, 0.06752628f, 0.17034690f, 0.00449756f, -0.02694384f, -0.13141495f, -0.05919890f, 
    0.31901380f, -0.14448227f, -0.40277898f, -0.15908346f, 0.00385370f, -0.02099323f, 0.00033711f, 0.05738411f, 
    -0.09925257f, -0.14911678f, 0.05667032f, 0.00664064f, -0.05814737f, 0.20203419f, 0.14922525f, -0.18530537f, 
    -0.10894955f, 0.01538741f, -0.11228947f, 0.12950356f, -0.01453100f, 0.03418623f, -0.18518519f, -0.15598181f, 
    -0.05872121f, -0.01069874f, -0.03569458f, 0.01469432f, 0.11246224f, -0.09330665f, -0.04382182f, 0.08963769f, 
    0.12268455f, -0.02350616f, -0.06221373f, 0.14424551f, -0.21432330f, 0.15783447f, -0.02613633f, -0.04509522f, 
    0.13691446f, -0.07811564f, 0.16390237f, -0.01761073f, 0.03956655f, -0.07800939f, 0.08377270f, 0.07834021f, 
    -0.15658483f, -0.06496483f, -0.05348735f, 0.07142410f, -0.02527377f, 0.03429804f, 0.11627679f, -0.03360586f, 
    0.02623646f, -0.14202304f, 0.05683340f, 0.06939756f, 0.11872718f, -0.24202281f, 0.04254606f, 0.18879256f, 
    0.06067932f, 0.21440423f, -0.00898205f, 0.12632565f, 0.00359209f, -0.03883242f, -0.02182028f, -0.10274126f, 
    0.10488822f, -0.20222025f, -0.01296940f, -0.14749970f, 0.11257335f, 0.13039212f, 0.01175498f, 0.06496046f, 
    -0.05978584f, -0.00900090f, -0.04468000f, -0.06669364f, -0.21852617f, -0.23593955f, 0.32605612f, -0.03119643f, 
    -0.05949830f, 0.01081582f, -0.13769409f, -0.11766139f, 0.04095137f, -0.20099078f, -0.01823894f, -0.12412910f, 
    0.04235143f, 0.18094045f, -0.00315628f, 0.01399352f, 0.19153425f, -0.00374285f, 0.10028278f, 0.17375162f, 
    0.12550975f, 0.03438446f, 0.14575358f, -0.07550664f, 0.01012051f, 0.04371374f, 0.03054779f, -0.03857934f, 
    0.00713974f, 0.01800560f, -0.05639908f, -0.14238945f, 0.00223182f, -0.09314383f, 0.00090603f, -0.07165287f, 
    0.08090460f, -0.03715538f, -0.03050738f, 0.17249517f, 0.09508613f, 0.21289562f, 0.23951536f, 0.12719595f, 
    -0.03370783f, 0.03518606f, 0.12871101f, -0.04096035f, -0.14650674f, 0.09142300f, 0.21860863f, -0.05460619f, 
    -0.04361598f, 0.11998735f, 0.03131590f, -0.08172023f, 0.05786557f, -0.03520337f, 0.05877575f, -0.09081712f, 
    -0.50836796f, -0.01413666f, 0.10872083f, 0.48637298f, -0.03240980f, -0.05350285f, 0.05307516f, 0.11960547f, 
    0.19604288f, 0.08339789f, 0.08564195f, 0.04717930f, -0.25394487f, -0.14477229f, -0.12686740f, 0.21530978f, 
    0.07486218f, 0.07406928f, 0.03284072f, 0.03845460f, 0.08385518f, 0.01049278f, 0.03157160f, -0.09707728f, 
    0.11979447f, -0.10692781f, 0.14953478f, 0.24932466f, -0.04850196f, -0.00339560f, -0.04448033f, 0.15718332f, 
    0.05076744f, 0.06243394f, 0.16830131f, 0.12388195f, -0.13545470f, 0.21249266f, 0.03776183f, -0.13971084f, 
    -0.03345247f, -0.05902669f, -0.00262368f, -0.12024108f, -0.18007182f, -0.07780424f, -0.16603784f, -0.22053897f, 
    0.04745607f, 0.20392250f, -0.01721952f, 0.02037949f, -0.16285744f, -0.04549992f, 0.19089095f, -0.16796333f, 
    -0.02001477f, 0.00204089f, 0.10260225f, -0.07165073f, -0.17564234f, 0.12983423f, 0.09215650f, -0.06825298f, 
    0.08731157f, -0.15417071f, -0.01592189f, 0.00249363f, -0.07300112f, -0.11021537f, -0.07805359f, -0.05779913f, 
    0.11462160f, -0.18102802f, 0.11261399f, -0.22030579f, 0.09933057f, -0.06484527f, -0.02931977f, -0.01637505f, 
    -0.03123757f, -0.08940056f, 0.06515603f, -0.40671438f, 0.01855234f, 0.06512079f, 0.04522782f, 0.20615788f, 
    -0.00158969f, 0.02647285f, 0.12561649f, 0.00571410f, 0.06203455f, 0.06230248f, 0.00089013f, 0.13787130f, 
    -0.04357642f, 0.05272225f, -0.06891853f, -0.02374307f, -0.00386752f, -0.17730300f, 0.08094664f, 0.02691674f, 
    0.04964000f, -0.00911662f, -0.01895920f, 0.00463592f, 0.02462286f, -0.21470244f, -0.18664274f, 0.09992576f, 
    -0.02646817f, -0.10545468f, -0.04999042f, 0.07958387f, -0.10233644f, -0.02158220f, -0.08669738f, -0.13584997f, 
    0.05450226f, -0.16653039f, -0.04008915f, 0.00692537f, 0.15921110f, 0.01655733f, 0.24001716f, 0.09401251f, 
    0.15367773f, 0.08219125f, 0.07478341f, 0.33344331f, -0.01969314f, -0.08675243f, 0.10232706f, -0.14402118f, 
    -0.07416601f, -0.28923738f, 0.04714907f, 0.07798918f, -0.20005718f, -0.13572390f, -0.16060260f, -0.03094875f, 
    0.08363201f, 0.37771609f, 0.00370230f, 0.10228982f, 0.05020288f, 0.14652616f, 0.00028231f, -0.23953111f, 
    0.06560504f, 0.17468096f, 0.07370584f, 0.17369956f, 0.30381849f, -0.08194736f, 0.26427305f, 0.14129578f, 
    0.12116298f, -0.02363838f, 0.02526549f, 0.08855644f, -0.14931588f, -0.03044041f, -0.04011873f, -0.21559145f, 
    0.16524737f, 0.06875096f, -0.17657842f, 0.06940464f, 0.15926188f, 0.04309558f, 0.10455438f, -0.07242694f, 
    0.02577325f, -0.13764329f, -0.11588907f, -0.07458989f, -0.33370474f, -0.19900288f, 0.10785223f, 0.10610556f, 
    -0.02798965f, -0.03309332f, 0.06358079f, 0.23570639f, 0.03844783f, 0.09264176f, 0.08097632f, 0.16349836f, 
    0.35278881f, 0.18065172f, -0.11942583f, 0.04622145f, -0.02285270f, -0.17430362f, -0.32673553f, -0.12930842f, 
    0.14250240f, 0.06077272f, 0.02696058f, -0.08313046f, 0.03221777f, -0.17119098f, -0.52702343f, 0.23533338f, 
    -0.01093622f, 0.14367737f, 0.16438670f, -0.17858419f, 0.11927142f, 0.00385169f, -0.03770720f, -0.09457260f, 
    -0.05642397f, 0.25670165f, 0.14470732f, 0.19769387f, 0.00208828f, 0.08239878f, -0.10290332f, -0.08450077f, 
    -0.09975512f, -0.01440537f, -0.10222950f, 0.02675428f, -0.21624772f, -0.28366223f, 0.07375374f, -0.07609619f, 
    0.01996443f, -0.05980362f, -0.09329830f, -0.00128669f, 0.02025432f, 0.09948584f, 0.01935913f, -0.04965331f, 
    -0.32926741f, -0.39377901f, -0.13034561f, 0.20679121f, -0.18583153f, -0.01347935f, -0.03077881f, -0.01996055f, 
    0.08163677f, 0.02191485f, -0.12847760f, -0.00847572f, 0.16249377f, 0.00630814f, 0.10946268f, 0.02777953f, 
    0.04947234f, 0.14888798f, 0.16469215f, -0.01000013f, -0.05324754f, -0.11279211f, 0.12075640f, -0.07059334f, 
    -0.09007369f, 0.17738482f, 0.02925499f, 0.00334941f, 0.04170863f, 0.17236808f, -0.07891510f, -0.16110238f, 
    -0.27217326f, 0.09537411f, 0.07290795f, -0.04453442f, 0.52535325f, -0.17948106f, 0.30168220f, 0.19409791f, 
    0.04277797f, 0.21444088f, 0.06060797f, 0.14474760f, 0.08875130f, 0.05835135f, -0.09440155f, 0.02958652f, 
    -0.22406790f, -0.49547544f, -0.01763052f, -0.24066697f, 0.03988729f, 0.00818023f, -0.13380174f, 0.01182879f, 
    -0.04536275f, 0.01671993f, 0.11406412f, -0.22832549f, -0.26555002f, 0.17545736f, -0.07005734f, 0.14845501f, 
    0.04994878f, -0.03017656f, 0.01357091f, 0.26489490f, -0.16681345f, 0.07617451f, 0.04566301f, -0.06725913f, 
    -0.14388569f, 0.05452444f, 0.01208347f, -0.01196318f, -0.05929616f, -0.08647386f, -0.23062994f, -0.06055343f, 
    0.09613854f, 0.06185710f, 0.15395215f, 0.22908559f, 0.21917149f, 0.43215311f, 0.14802271f, 0.34632927f, 
    -0.31613627f, 0.03738525f, 0.10145196f, 0.16540553f, 0.01498472f, 0.06922303f, 0.05259299f, -0.06267015f, 
    -0.06981483f, 0.36613715f, 0.21246968f, 0.02807485f, -0.07417032f, 0.01066285f, 0.06971919f, -0.11501694f, 
    0.06542616f, 0.01683339f, 0.11321487f, 0.22071230f, 0.08745377f, -0.19242117f, -0.05947569f, 0.21147230f, 
    -0.00210963f, -0.01834484f, 0.10425860f, 0.13200364f, -0.02888692f, 0.03101677f, -0.02783756f, 0.00446724f, 
    -0.05767992f, 0.21026808f, -0.02779802f, -0.16629751f, 0.26470259f, 0.04425438f, 0.03113190f, -0.05828579f, 
    0.03805855f, 0.07255221f, -0.01690784f, 0.21551538f, -0.09418561f, -0.01451126f, 0.00875061f, 0.36772603f, 
    -0.05970013f, 0.01776494f, 0.04383868f, 0.37558198f, 0.08664165f, 0.09626876f, -0.00656869f, 0.04532776f, 
    -0.05648715f, 0.15957767f, -0.00978816f, -0.10469677f, -0.00921877f, 0.03418799f, -0.05455450f, -0.08767183f, 
    -0.13959540f, -0.00117212f, -0.20293888f, 0.07067006f, -0.01071622f, 0.19545223f, -0.13593824f, -0.12691794f, 
    0.03819091f, 0.08186927f, -0.10766941f, 0.00367114f, -0.04128473f, -0.07444818f, 0.03705112f, 0.05696030f, 
    -0.18040919f, -0.11822214f, 0.35486004f, 0.13027707f, 0.04396118f, 0.01563064f, -0.08896554f, 0.13049385f, 
    0.02083380f, -0.02183875f, 0.12550065f, 0.01393237f, 0.12805259f, 0.15571703f, -0.03574768f, -0.07688469f, 
    -0.03405099f, 0.02352119f, 0.09402625f, -0.12579060f, 0.08477859f, -0.00281196f, -0.13273145f, -0.10364682f, 
    0.25901973f, 0.23800185f, -0.10915794f, -0.10297616f, 0.06905709f, 0.08861337f, 0.06104944f, -0.15232702f, 
    -0.03851899f, -0.04503416f, -0.03474805f, -0.02926362f, 0.00082601f, 0.12690985f, -0.13991296f, -0.11290178f, 
    0.02738912f, -0.01262449f, 0.11013941f, 0.17477940f, 0.13696922f, -0.06071225f, 0.01273319f, 0.11377150f, 
    0.11370681f, -0.09673043f, 0.09676308f, -0.21945518f, 0.08929353f, -0.10731157f, 0.05003145f, 0.08182734f, 
    0.17024255f, 0.00756383f, -0.02703008f, -0.04980468f, -0.15466727f, 0.15845425f, 0.05931971f, 0.03865675f, 
    0.00998661f, -0.09357697f, -0.02493593f, -0.03502870f, 0.03934797f, -0.00918524f, -0.04274499f, 0.02057287f, 
    0.14860904f, 0.34245923f, 0.07596326f, 0.10752000f, 0.03047480f, -0.09712531f, 0.07039805f, -0.05585865f, 
    -0.01640200f, -0.07205975f, -0.10005193f, -0.01726067f, 0.22740974f, -0.37764212f, -0.19193359f, 0.08173505f, 
    -0.14670928f, -0.07354126f, -0.01192206f, 0.01783453f, -0.01458020f, 0.02929945f, 0.05298525f, -0.02084951f, 
    0.13712656f, 0.04859876f, 0.01639572f, 0.02267632f, 0.01989481f, -0.04185219f, 0.19221500f, 0.00705605f, 
    -0.03239759f, 0.05285439f, 0.02636444f, 0.09708751f, -0.19758345f, -0.31162068f, -0.05259868f, -0.14268054f, 
    0.20437151f, -0.08925224f, -0.01935963f, -0.03064546f, 0.14198834f, 0.06247035f, 0.01381629f, 0.06463197f, 
    0.13666223f, 0.09367646f, -0.11074372f, -0.00195000f, 0.03229828f, -0.05325788f, 0.13488291f, -0.02746400f, 
    0.22679427f, 0.10589984f, 0.04781954f, 0.13277264f, 0.08260960f, 0.04894455f, 0.35959497f, -0.19613045f, 
    0.09614085f, 0.10446102f, 0.12203325f, 0.04952534f, 0.06323880f, 0.00991344f, -0.01391773f, 0.01579770f, 
    0.28907001f, -0.07656016f, 0.00337002f, 0.04180662f, 0.00385613f, 0.13220909f, -0.05392946f, 0.09938508f, 
    0.02962162f, -0.07286097f, 0.04444154f, -0.04822566f, -0.15711117f, 0.01530174f, 0.14632222f, -0.01008081f, 
    -0.00211066f, 0.06541300f, 0.07473267f, -0.07068037f, 0.04817552f, 0.09437612f, 0.00676248f, 0.02618589f, 
    0.32626724f, -0.15185589f, -0.07757875f, 0.18843751f, 0.05325784f, -0.20777397f, -0.19497927f, -0.13703109f, 
    0.02523118f, 0.02544825f, 0.05359857f, -0.02805109f, 0.05002586f, -0.27981651f, -0.33016449f, 0.22129469f, 
    -0.08786089f, 0.02295553f, -0.02997908f, -0.07897783f, -0.05930102f, 0.10293701f, -0.03678471f, 0.02731612f, 
    -0.21664679f, 0.37277943f, 0.35874406f, 0.02170109f, 0.05494136f, 0.08994348f, -0.04909663f, 0.09514289f, 
    0.26178452f, 0.07280935f, -0.04807601f, 0.06448255f, -0.16089694f, -0.21949236f, 0.17540468f, 0.03193488f, 
    -0.09674720f, -0.10548246f, -0.03454335f, -0.08489299f, 0.09626885f, -0.02412102f, -0.06859764f, 0.00256164f, 
    -0.13218370f, 0.19700703f, -0.02848957f, -0.29586309f, -0.22546940f, -0.05201218f, -0.19432163f, -0.14680693f, 
    0.00707135f, 0.10938835f, -0.03782835f, 0.11669170f, 0.09874239f, 0.04831805f, 0.08704465f, 0.17978288f, 
    -0.09661853f, 0.10168734f, 0.18440543f, -0.02641710f, 0.24149987f, 0.05369531f, 0.17098832f, 0.12250333f, 
    -0.07180499f, 0.20613098f, 0.00900579f, 0.08084191f, -0.11950929f, -0.02280614f, -0.00088788f, 0.00695075f, 
    -0.06396172f, 0.07536636f, 0.06472979f, 0.23536323f, 0.12760451f, -0.32145181f, 0.20005755f, -0.10503599f, 
    0.19602980f, 0.01677039f, 0.03358238f, 0.06603458f, 0.11503282f, 0.04851813f, -0.02567769f, 0.20121031f, 
    -0.09917679f, -0.07670591f, -0.01734051f, -0.12373967f, -0.21071701f, -0.25642547f, -0.01372468f, -0.16307250f, 
    0.02203509f, -0.02967152f, -0.03584241f, 0.01237181f, -0.24447106f, 0.04092111f, -0.47220799f, 0.14779271f, 
    -0.12875453f, 0.07306731f, 0.07077119f, -0.02124558f, -0.09315642f, -0.04528573f, -0.01568155f, 0.06995837f, 
    -0.20508161f, -0.07327861f, -0.16145028f, -0.03707156f, -0.18992595f, 0.00298555f, 0.02289021f, -0.01836127f, 
    0.02212900f, 0.01382185f, -0.08522865f, -0.25515589f, -0.19579802f, 0.04642348f, -0.10071693f, 0.05767817f, 
    -0.15784431f, 0.18022029f, 0.02034054f, -0.02994114f, 0.06249949f, -0.00118657f, -0.03437220f, 0.10247992f, 
    0.24515770f, 0.21960446f, -0.15197064f, 0.13518834f, -0.04986149f, 0.03577595f, 0.23128209f, 0.11019468f, 
    0.18834677f, -0.02950461f, -0.01623712f, -0.01004226f, -0.35558820f, -0.13282247f, 0.23518375f, -0.16883509f, 
    0.07821301f, 0.00004541f, -0.04868531f, -0.08747537f, 0.04933190f, -0.13414508f, 0.00660835f, 0.11204831f, 
    0.08365527f, -0.12568313f, 0.18006727f, -0.07799614f, 0.02954448f, -0.00850598f, -0.08114978f, 0.12042163f, 
    -0.02294568f, 0.05759012f, -0.06011615f, -0.08599631f, -0.31653905f, -0.21123143f, -0.05507984f, 0.10849787f, 
    0.04227082f, 0.26576105f, 0.08645645f, -0.12690160f, -0.04172868f, 0.05757215f, -0.00832569f, 0.04588994f, 
    0.08523141f, -0.09282472f, 0.06417623f, 0.24576019f, -0.24910261f, -0.02785198f, -0.01734012f, -0.06079616f, 
    0.09614284f, -0.00226820f, 0.02000985f, -0.06573933f, 0.08937550f, -0.19583015f, -0.16708498f, -0.03984326f, 
    -0.01607892f, 0.14459312f, 0.11985653f, 0.11215519f, 0.03950496f, 0.05636036f, -0.02225455f, -0.19118506f, 
    -0.06314920f, 0.00947383f, -0.00842076f, 0.02792549f, 0.04004180f, 0.01780639f, -0.05652817f, -0.03595131f, 
    0.01055650f, 0.03008726f, 0.00815743f, -0.07235475f, -0.03281742f, -0.04716604f, 0.03815943f, 0.01351644f, 
    -0.06656478f, 0.02516629f, 0.04823416f, 0.01334282f, -0.01437302f, 0.04174246f, 0.04941780f, -0.01412182f, 
    -0.01259637f, 0.01823536f, -0.03203370f, -0.04941612f, -0.07091331f, 0.03262563f, -0.07298723f, -0.06193401f, 
    0.05440947f, 0.01826769f, 0.05434768f, -0.02097750f, 0.02238984f, -0.02494910f, -0.02068930f, -0.00064324f, 
    0.01384265f, 0.02541106f, -0.02077516f, 0.03661374f, 0.03096916f, -0.05476752f, -0.03966202f, -0.05667618f, 
    -0.07390288f, 0.04279030f, -0.00389889f, 0.05087115f, -0.08532857f, -0.05691724f, 0.04089496f, -0.04933910f, 
    -0.03188253f, 0.00234022f, -0.07434699f, 0.04140278f, -0.08665760f, 0.00744068f, 0.04779099f, -0.08272764f, 
    -0.02554834f, -0.03951068f, -0.01968762f, -0.04122208f, 0.02584155f, 0.04979964f, -0.07001521f, -0.00062911f, 
    0.05832854f, 0.02455562f, 0.02730782f, -0.03382925f, -0.07407384f, -0.04873104f, -0.08794524f, -0.09081066f, 
    -0.05231440f, 0.04857792f, 0.03650328f, 0.04177774f, -0.07659207f, 0.01009219f, -0.04040933f, 0.01662705f, 
    -0.04828011f, -0.03723652f, 0.05543201f, -0.04752026f, 0.05531530f, -0.07526799f, -0.03013343f, -0.03605314f, 
    -0.02594944f, 0.00373860f, -0.08647731f, -0.08150561f, 0.01118100f, 0.00465912f, -0.07511538f, 0.00364049f, 
    -0.04313126f, -0.04483678f, 0.00810656f, 0.06524079f, -0.09182835f, -0.08689312f, 0.01795810f, -0.02384675f, 
    -0.08826426f, -0.06485939f, 0.05621558f, -0.07102963f, 0.03684044f, -0.07340920f, -0.02072543f, 0.01258256f, 
    0.03409336f, 0.01682152f, -0.04454811f, 0.01657201f, -0.07642356f, 0.03231991f, -0.03747027f, -0.00726448f, 
    0.05413723f, 0.04484686f, 0.01349488f, 0.00670993f, 0.04233491f, 0.00852911f, -0.05463561f, -0.07589747f, 
    -0.08023120f, -0.02317386f, -0.06982967f, -0.08329798f, -0.05598075f, -0.01579257f, -0.01508140f, -0.03149977f, 
    -0.03657793f, 0.06195417f, -0.01920888f, 0.04467919f, -0.03763456f, 0.01977248f, -0.05374760f, -0.03573161f, 
    -0.03217609f, -0.08043185f, -0.01736838f, -0.00368582f, -0.01737383f, 0.04804826f, 0.03499464f, -0.03633384f, 
    -0.06173444f, 0.04766766f, -0.07541154f, 0.04292794f, 0.02419796f, 0.00319037f, -0.02174333f, -0.04396696f, 
    0.04659662f, -0.03597911f, -0.05958962f, -0.01964443f, -0.02570896f, 0.02168222f, -0.01188263f, -0.04231533f, 
    -0.00002140f, -0.00214547f, -0.07820168f, -0.06781396f, -0.04006882f, -0.05404956f, -0.08634657f, -0.05600752f, 
    0.03959941f, -0.02149034f, 0.03999733f, -0.03940424f, -0.04560208f, -0.06471821f, 0.04891224f, -0.06510859f, 
    -0.15116744f, 0.25993901f, 0.22158214f, -0.12439919f, 0.02444766f, 0.02316961f, -0.14916496f, 0.13180465f, 
    0.06157499f, 0.15005937f, 0.06748839f, 0.11423036f, -0.35123152f, -0.06233941f, -0.11072811f, 0.11125774f, 
    -0.03649890f, 0.06441686f, 0.08549557f, -0.04839422f, -0.00983109f, 0.04357655f, -0.08433309f, 0.00076862f, 
    -0.16563831f, 0.47752196f, -0.53625840f, -0.00308759f, -0.19013292f, -0.06368069f, 0.03066648f, -0.09803911f, 
    0.00177562f, 0.00015519f, 0.05461608f, 0.04752699f, 0.09134983f, 0.01790758f, 0.14083590f, 0.15552659f, 
    -0.09955925f, -0.04433015f, 0.10088161f, -0.00103089f, 0.20951374f, -0.02157152f, 0.10118180f, 0.03898682f, 
    0.18822201f, 0.06753356f, 0.03994190f, 0.07032792f, 0.04990115f, -0.21996638f, 0.04035625f, -0.07601032f, 
    0.03955717f, 0.08183329f, 0.25087941f, 0.09055830f, 0.05256473f, -0.17205828f, 0.01755871f, -0.10075334f, 
    0.09361967f, -0.03031527f, 0.17364837f, -0.02806807f, 0.01100470f, 0.06855429f, 0.00413049f, 0.17810819f, 
    -0.09264188f, -0.09241002f, -0.04430311f, 0.00098518f, -0.12431877f, -0.15855710f, 0.04392480f, -0.10906078f, 
    -0.06936640f, -0.02436469f, 0.02817005f, 0.14963605f, -0.12281822f, -0.03400910f, -0.16129628f, -0.03796993f, 
    0.03466617f, 0.09435693f, 0.10642302f, 0.02012717f, -0.10762110f, 0.11626877f, -0.01043049f, 0.11827812f, 
    -0.20967552f, -0.10671226f, -0.12391458f, -0.01894847f, -0.08743118f, 0.02718113f, 0.13038681f, -0.08796015f, 
    0.06602479f, 0.04289050f, -0.07913114f, 0.05404164f, -0.14326426f, -0.09065229f, -0.02576203f, -0.12441494f, 
    0.02798942f, 0.06653020f, 0.02593126f, 0.00608475f, 0.00232899f, -0.04842372f, -0.11013266f, 0.18361656f, 
    0.10580117f, 0.29155236f, -0.31003317f, -0.01419279f, -0.11282314f, 0.04993171f, 0.20748949f, 0.11507136f, 
    0.04781754f, 0.02125456f, 0.02885972f, -0.08159699f, -0.01983042f, -0.30658108f, 0.21922693f, -0.03362694f, 
    0.08384465f, 0.10506093f, -0.02619599f, -0.13042682f, 0.04762368f, -0.10641377f, 0.07816607f, -0.10549370f, 
    0.05089783f, 0.05904094f, -0.28958616f, 0.16025719f, -0.01092194f, 0.21416780f, 0.06192726f, 0.05873138f, 
    -0.05793263f, 0.12467031f, -0.04492987f, -0.05348220f, -0.23376611f, -0.21296486f, 0.00816990f, -0.02265063f, 
    0.00386762f, 0.08245211f, 0.14561605f, -0.07821304f, -0.04406215f, 0.07176589f, -0.01462061f, 0.13153611f, 
    0.25828749f, 0.12769054f, 0.34602401f, 0.16378497f, -0.24458845f, -0.07629731f, -0.03414069f, -0.04250512f, 
    -0.02341812f, 0.07455148f, 0.05069854f, 0.08654959f, -0.19222385f, -0.09811461f, -0.16516593f, 0.04543824f, 
    -0.18111686f, 0.28805232f, 0.19895646f, 0.05754760f, 0.11700411f, 0.04522016f, -0.12132456f, -0.07895102f, 
    0.03419184f, 0.23693523f, -0.14973125f, -0.11851890f, 0.00055509f, -0.06865630f, 0.17588815f, 0.06577475f, 
    0.04451824f, 0.14537732f, 0.09049630f, 0.05119224f, 0.01818333f, 0.02287585f, 0.27862659f, -0.17311564f, 
    0.05576694f, -0.16925982f, -0.19724929f, 0.17770489f, -0.12619802f, -0.00813127f, -0.01635513f, -0.04368564f, 
    -0.00906833f, -0.18082453f, 0.59728867f, -0.09910320f, -0.12939414f, -0.03605092f, -0.14499038f, 0.24563722f, 
    -0.00629516f, -0.03004116f, -0.08651531f, -0.02234055f, 0.04658210f, 0.03388621f, -0.08634844f, 0.06786297f, 
    0.14356330f, 0.02944033f, 0.00960157f, 0.13492242f, 0.04641632f, 0.25459734f, 0.12194859f, -0.08843999f, 
    -0.38022599f, 0.03824301f, 0.02804316f, 0.05273793f, -0.08102724f, -0.05145177f, -0.11653748f, -0.00927697f, 
    -0.03869953f, 0.01058848f, -0.08267780f, 0.13581388f, 0.10307436f, 0.02830294f, 0.19050018f, 0.01900500f, 
    0.19354619f, 0.04219328f, -0.08111063f, 0.02930395f, 0.01747571f, -0.03734086f, 0.05843261f, 0.02973960f, 
    0.05664910f, 0.11793069f, 0.09570740f, -0.04823403f, -0.19577433f, -0.16822459f, -0.21229298f, -0.14668189f, 
    -0.07203831f, 0.00051637f, -0.00230366f, -0.11284161f, 0.22666842f, 0.05737767f, 0.09115938f, 0.23658061f, 
    0.03628999f, -0.09594164f, 0.11210454f, 0.04845916f, 0.01472524f, -0.10867924f, 0.21144556f, 0.04664243f, 
    -0.16413587f, 0.10090926f, 0.02033510f, 0.09233499f, -0.02633721f, -0.03594924f, 0.01780931f, -0.05277837f, 
    0.05543020f, 0.09351677f, 0.09442092f, -0.09382578f, 0.15473151f, -0.12680720f, -0.07128973f, 0.10455780f, 
    0.04739495f, 0.06299002f, -0.08606093f, 0.11950664f, -0.02939937f, 0.00336333f, 0.02100363f, 0.07950906f, 
    0.34578118f, -0.02832610f, -0.04158427f, 0.31025606f, 0.07718807f, 0.13740034f, -0.07642747f, 0.12534933f, 
    -0.02054303f, -0.02683491f, 0.06867155f, 0.02490258f, -0.17718346f, 0.19673002f, 0.25093922f, 0.01232966f, 
    0.06382120f, -0.02828561f, -0.04679665f, 0.05074046f, -0.14504816f, 0.13880433f, -0.01558692f, 0.00699857f, 
    -0.06743162f, -0.12949736f, 0.29719523f, -0.17759709f, 0.07611525f, -0.04228371f, -0.19443971f, 0.10217525f, 
    -0.00385350f, -0.04955706f, -0.08951208f, -0.05058140f, -0.00909136f, -0.05219962f, -0.12497194f, 0.04194743f, 
    0.04290596f, 0.05666608f, 0.02844091f, 0.01289513f, -0.05993336f, -0.04690055f, 0.11158723f, -0.05725991f, 
    0.40196514f, -0.13555492f, -0.33062387f, -0.33958587f, 0.12605354f, -0.04397067f, 0.16778465f, 0.04878555f, 
    0.10317250f, 0.02119221f, 0.04134683f, 0.10579771f, 0.75223345f, 0.05195686f, -0.03591739f, -0.10049405f, 
    0.19268706f, -0.08788682f, -0.12458554f, 0.06751392f, -0.03996501f, -0.08053257f, -0.04930125f, 0.10702231f, 
    0.30844396f, -0.42685926f, 0.31286943f, 0.30248386f, -0.05991138f, 0.06396969f, -0.09136944f, 0.02434583f, 
    0.06928280f, 0.07444093f, 0.05388727f, 0.08650349f, -0.20735155f, 0.20670372f, 0.01927616f, -0.04357476f, 
    0.01619430f, -0.19502722f, -0.22546282f, 0.10272259f, -0.00262484f, 0.13867262f, -0.13191938f, -0.15683965f, 
    0.08767527f, -0.05373510f, -0.10117200f, 0.23269099f, -0.06508175f, -0.05088948f, 0.02529071f, -0.19571298f, 
    0.02802198f, -0.12575535f, -0.02860529f, 0.00958680f, 0.02485919f, 0.30670616f, 0.06424938f, -0.08997029f, 
    0.00993496f, 0.06424474f, -0.04418338f, -0.12235678f, -0.17785263f, -0.07618321f, -0.10619429f, -0.06425247f, 
    0.17165822f, 0.06775340f, 0.16091460f, -0.08562727f, 0.08200492f, 0.02030657f, -0.13081607f, -0.08460481f, 
    0.03836125f, -0.05464488f, -0.19165693f, -0.13913435f, -0.03525293f, 0.26898825f, 0.13348921f, 0.24373215f, 
    -0.00069552f, 0.03763073f, -0.00055759f, 0.04481743f, 0.10366184f, -0.09262726f, 0.00116235f, -0.05068415f, 
    -0.00626893f, -0.10941300f, 0.04807255f, 0.05758208f, -0.09675679f, -0.15287557f, -0.05606702f, 0.04797287f, 
    0.19318524f, 0.02067204f, 0.10768681f, 0.13579141f, -0.16927283f, -0.12358348f, 0.05766974f, 0.24545461f, 
    -0.02806824f, -0.04117208f, -0.05024130f, -0.05926530f, -0.06834082f, -0.12042087f, 0.09765496f, -0.20776996f, 
    0.18309315f, -0.11877119f, -0.00431740f, 0.06692163f, 0.07823323f, 0.04000022f, -0.01658724f, -0.02861411f, 
    0.10784624f, 0.05233754f, 0.29554680f, 0.23450302f, -0.05190400f, -0.10044014f, 0.19666581f, 0.01711483f, 
    -0.13982671f, -0.04301614f, 0.05789586f, 0.03667134f, -0.01515290f, -0.12541638f, -0.02194584f, 0.09951618f, 
    -0.21445958f, 0.36085445f, -0.02521295f, 0.07762482f, 0.08625115f, 0.04939302f, -0.08865362f, -0.28800499f, 
    0.06311038f, 0.09805240f, 0.07733829f, 0.11066887f, 0.32244757f, 0.01426595f, 0.14846806f, 0.08105432f, 
    0.06609865f, 0.05717288f, -0.01694408f, 0.21071169f, 0.00498062f, -0.08549900f, -0.01772016f, -0.11806660f, 
    -0.08550109f, 0.12621772f, -0.12601238f, -0.00358272f, 0.17348911f, -0.09097751f, -0.04903841f, 0.05159444f, 
    0.10268317f, -0.10557209f, -0.12409604f, 0.04827362f, -0.30285570f, -0.05902658f, 0.20648423f, 0.00107481f, 
    -0.13645169f, -0.14185545f, -0.07845078f, 0.20993969f, 0.22151610f, 0.01001320f, 0.08181659f, 0.03660167f, 
    0.03217251f, 0.20894878f, -0.29499999f, 0.26397473f, -0.07698277f, -0.06918969f, -0.30431515f, -0.28487349f, 
    0.14554922f, 0.01195065f, -0.09312457f, -0.05046058f, -0.13962290f, -0.00160078f, -0.32108858f, 0.27682132f, 
    0.08834649f, 0.16988237f, 0.04221116f, -0.20258646f, -0.01906363f, -0.11919830f, -0.06660604f, 0.03856241f, 
    0.35391086f, 0.05230043f, 0.09801352f, -0.08016307f, -0.06151040f, 0.01912037f, -0.01579931f, -0.12807423f, 
    0.15405194f, 0.00581855f, 0.04495868f, 0.01347597f, -0.10153408f, 0.07476138f, -0.19634545f, 0.15909009f, 
    -0.03987543f, -0.12488310f, 0.09892754f, -0.17972901f, -0.04504885f, -0.08178616f, 0.10694509f, 0.08527774f, 
    -0.08108504f, 0.58355153f, -0.37862507f, 0.41725093f, -0.06237534f, -0.13379516f, 0.19126600f, -0.26664484f, 
    0.05067760f, -0.04710092f, 0.02436677f, 0.01961063f, -0.08900321f, 0.01785482f, -0.12998991f, 0.10767139f, 
    0.06865744f, -0.02550278f, 0.09331891f, 0.00072193f, 0.01383288f, -0.00064620f, 0.18677574f, 0.14525412f, 
    0.29063320f, -0.18296829f, 0.03163568f, -0.04898096f, 0.09665000f, -0.05650301f, -0.08541141f, -0.10838732f, 
    0.11532643f, 0.06367694f, 0.17345445f, -0.17840908f, 0.01136466f, 0.05149968f, -0.30274820f, -0.04330356f, 
    -0.21272761f, 0.08978190f, 0.05011669f, 0.13819075f, -0.06891829f, 0.11169055f, -0.04993831f, 0.05150431f, 
    -0.00101382f, 0.11984029f, -0.01205469f, 0.28711289f, 0.05188558f, -0.08786004f, 0.02118415f, -0.15050521f, 
    0.03540361f, -0.11862060f, 0.00317831f, 0.11363680f, 0.06521703f, 0.05054370f, 0.15713120f, -0.23829001f, 
    0.14092650f, -0.12335712f, 0.15897618f, -0.22493486f, 0.00192346f, 0.04865639f, -0.10165282f, -0.10510436f, 
    -0.03682437f, -0.05651846f, -0.00370201f, 0.19429407f, 0.06251722f, 0.00112368f, 0.25133118f, -0.04573693f, 
    0.04999841f, -0.08899939f, -0.12440726f, 0.23177919f, -0.00877095f, -0.06105554f, -0.28189757f, -0.22814497f, 
    0.34449673f, 0.01831792f, 0.33458641f, 0.04702362f, -0.24325949f, -0.07113181f, -0.12367418f, 0.10965314f, 
    -0.35837638f, -0.03985679f, 0.00939853f, -0.24311562f, -0.01325741f, -0.03536351f, 0.09427046f, -0.17565955f, 
    0.08428445f, -0.00201494f, -0.15036105f, 0.15359053f, 0.08723239f, -0.08908470f, -0.11257506f, -0.04790836f, 
    0.14075172f, 0.09541122f, 0.06823147f, 0.09134722f, 0.01335663f, -0.04038794f, 0.02240092f, -0.00418826f, 
    -0.03739964f, 0.16676174f, -0.29423419f, 0.06030954f, -0.02543587f, 0.11167872f, 0.06729747f, -0.07487685f, 
    -0.07858027f, -0.02777166f, -0.03861090f, 0.03322967f, 0.26471436f, 0.19265127f, -0.16005109f, -0.27133885f, 
    0.18880002f, -0.05416618f, 0.20811333f, 0.19955699f, -0.06720336f, -0.01530944f, -0.05309138f, 0.04919503f, 
    0.20742108f, 0.25466880f, 0.37539807f, 0.11406607f, -0.06271533f, -0.05706403f, -0.07711519f, -0.27873644f, 
    0.16899036f, -0.00411404f, 0.12039144f, 0.12760366f, -0.28042707f, 0.07604568f, 0.16417606f, -0.01068679f, 
    -0.04723932f, 0.05061363f, 0.09494217f, -0.05096064f, 0.00795216f, -0.06724104f, 0.08027942f, -0.10695112f, 
    0.13155152f, -0.13696243f, -0.28375465f, -0.25474408f, 0.00622756f, -0.04510158f, 0.03592819f, 0.06981526f, 
    -0.12488049f, -0.11438253f, 0.01417522f, 0.14659809f, 0.17122956f, 0.20635718f, -0.08632913f, 0.09127778f, 
    0.05991823f, -0.11688427f, -0.10315201f, -0.02172000f, -0.05486686f, 0.05072668f, -0.02804672f, 0.14054796f, 
    0.42240781f, 0.09617629f, 0.08368202f, 0.19455889f, 0.08598765f, 0.01451251f, -0.09733052f, 0.10640035f, 
    -0.01100488f, -0.02223574f, 0.01250035f, 0.02247910f, 0.10185457f, 0.13061570f, -0.12870973f, 0.19486044f, 
    0.08009828f, 0.01236956f, -0.27084070f, -0.08263584f, 0.02889154f, -0.04505691f, -0.03770662f, 0.04631047f, 
    0.04802300f, 0.03996655f, 0.05076214f, 0.01887929f, -0.14378141f, 0.00349153f, -0.15566406f, -0.07927521f, 
    0.09407544f, -0.08186497f, 0.00313767f, 0.05935025f, -0.05736746f, 0.51491851f, -0.04761569f, 0.11032119f, 
    0.05433677f, 0.11843359f, 0.03679157f, 0.05942633f, -0.14717792f, -0.06306610f, -0.04337015f, -0.11138026f, 
    0.21743284f, -0.14219913f, -0.06736189f, 0.12603776f, 0.08276074f, 0.03870824f, 0.01541703f, 0.06099794f, 
    0.16894630f, 0.07795099f, 0.13697165f, 0.07972842f, 0.18672283f, -0.07665471f, 0.59456390f, -0.06014964f, 
    0.03694234f, -0.16139752f, -0.21795683f, -0.17446510f, -0.00053548f, -0.06276948f, -0.06352840f, 0.09891591f, 
    0.04499452f, 0.00916975f, 0.17414065f, 0.03320028f, -0.07349519f, -0.13576636f, 0.05469028f, 0.01324284f, 
    0.19182073f, 0.27571532f, 0.14705196f, -0.02511973f, 0.33158803f, 0.14009739f, -0.01488790f, -0.05272370f, 
    0.26984915f, -0.04812102f, 0.01531024f, 0.07953909f, -0.07429571f, 0.04996563f, -0.02989851f, 0.01326075f, 
    0.06371644f, -0.18946445f, 0.07102915f, 0.03411575f, -0.07179440f, -0.08879323f, -0.07237888f, 0.08264516f, 
    -0.06846465f, -0.13569708f, 0.04829038f, -0.17940263f, 0.34112528f, 0.54707652f, 0.06630778f, 0.04874567f, 
    -0.04560480f, 0.00123211f, 0.01064913f, 0.13395487f, 0.04919575f, -0.01640849f, 0.03322049f, 0.01266334f, 
    -0.08270609f, 0.01863096f, -0.05987045f, 0.11852577f, -0.00777316f, -0.20254599f, -0.04306050f, -0.08326013f, 
    0.06444462f, -0.01895479f, -0.01185705f, -0.02086196f, 0.42271233f, 0.28650126f, 0.06507044f, 0.00017566f, 
    0.21463382f, 0.02999019f, 0.11478621f, 0.12077184f, -0.02151732f, -0.15860365f, 0.00745545f, 0.00043437f, 
    -0.11697206f, 0.01866970f, 0.08956116f, -0.10153073f, -0.01495602f, 0.00892037f, 0.03433952f, 0.10504602f, 
    -0.14184372f, -0.09115390f, -0.06681880f, -0.00033283f, -0.21018003f, 0.11630256f, 0.26714754f, -0.07086315f, 
    0.01516757f, -0.02054886f, -0.01832791f, -0.06075498f, -0.06925739f, -0.00607341f, -0.08406000f, -0.00300300f, 
    0.05207265f, 0.13122261f, 0.03039136f, -0.35855380f, 0.01367985f, 0.05149553f, -0.09708218f, -0.08568977f, 
    0.14135380f, -0.02687244f, -0.12814602f, -0.05303464f, -0.22062297f, 0.03264490f, 0.04858452f, -0.03931760f, 
    -0.15414234f, -0.12408201f, 0.09720343f, 0.04730897f, -0.00349815f, -0.02205071f, -0.00962738f, 0.02755236f, 
    0.05175260f, 0.16626860f, 0.18255281f, 0.09173714f, -0.16375585f, -0.05011142f, -0.03870311f, -0.03376666f, 
    0.02854872f, -0.01266060f, 0.04215639f, -0.06072400f, 0.07297204f, 0.21793070f, -0.17709360f, 0.19832087f, 
    -0.01097490f, 0.08835464f, 0.15571076f, -0.06759145f, 0.21942422f, 0.17489377f, 0.03642499f, -0.00011995f, 
    -0.15831110f, 0.10236460f, 0.01486376f, -0.03716621f, -0.12130830f, -0.07120265f, -0.00817827f, 0.08609968f, 
    0.34048030f, 0.17221193f, 0.07509771f, 0.21973784f, -0.03477302f, 0.12585565f, 0.34656000f, 0.18200642f, 
    0.13889019f, 0.08960447f, 0.02051177f, 0.09831880f, 0.00585358f, -0.00980681f, -0.19539049f, -0.00340012f, 
    0.15915057f, 0.09525722f, 0.06935088f, 0.13508724f, -0.08258224f, -0.20252931f, -0.04873431f, -0.07621964f, 
    0.12683938f, 0.03690276f, -0.04324750f, 0.01545157f, 0.26331913f, -0.04416822f, 0.02953226f, 0.44368294f, 
    -0.00644403f, 0.00717891f, 0.01213590f, -0.09518838f, 0.03389978f, 0.02983790f, 0.04318408f, 0.14467947f, 
    -0.01223851f, -0.03987372f, -0.16444245f, 0.14316791f, -0.11463567f, -0.08098295f, 0.01772937f, -0.09852028f, 
    -0.11446753f, -0.11700151f, 0.05595956f, -0.20412186f, -0.07542434f, -0.15157332f, -0.19916730f, 0.04999309f, 
    0.18861176f, 0.15849036f, 0.10916678f, 0.07355741f, 0.09549361f, 0.12038723f, -0.02273769f, 0.24446733f, 
    0.13731124f, 0.00776509f, -0.23483336f, 0.12361867f, 0.06130467f, -0.05126946f, 0.02791145f, -0.08806738f, 
    -0.06533631f, -0.13952607f, -0.00816570f, -0.00405455f, -0.12716165f, 0.20265143f, 0.41257137f, -0.05030636f, 
    0.11829798f, -0.01806096f, 0.07858001f, 0.08190346f, -0.15369448f, -0.16569488f, 0.01393111f, 0.10457320f, 
    -0.26892453f, -0.00261302f, 0.03646202f, -0.03437984f, -0.09648370f, -0.11937436f, -0.01802658f, 0.05556975f, 
    -0.04843824f, 0.17901686f, -0.00730980f, -0.00309807f, -0.06198273f, -0.02321497f, -0.02061465f, 0.17326845f, 
    0.12572287f, 0.07028055f, 0.14403240f, -0.00051010f, 0.04195267f, -0.01938665f, 0.02490268f, -0.10010131f, 
    0.29278341f, -0.19745328f, -0.24490440f, -0.17190929f, -0.01320184f, -0.10995923f, -0.00924754f, -0.16245638f, 
    0.12467944f, -0.00878689f, 0.06610471f, 0.11510953f, 0.37916455f, -0.02509910f, -0.02521341f, 0.05438077f, 
    0.01063664f, 0.08508693f, 0.13823886f, 0.00267441f, -0.07502291f, 0.03743580f, 0.03120602f, -0.09677567f, 
    0.11360160f, 0.16822979f, 0.07109843f, 0.03880272f, 0.13798672f, 0.01719368f, 0.19877602f, -0.06550036f, 
    0.06867597f, 0.09285277f, -0.06639678f, -0.03160771f, 0.17390512f, 0.04559943f, 0.02827868f, 0.02289262f, 
    -0.11440230f, -0.24668212f, -0.00902340f, -0.16893102f, -0.04115199f, -0.11959148f, 0.08094390f, 0.13563988f, 
    -0.00301088f, 0.17700203f, 0.36464623f, 0.22245950f, -0.02965810f, -0.04623815f, -0.11562145f, -0.14503525f, 
    -0.06708860f, 0.12938233f, -0.08166768f, -0.14267950f, -0.01357933f, 0.03178639f, -0.13941157f, -0.00922510f, 
    0.20247248f, 0.16419220f, 0.12821820f, -0.06151979f, 0.20667619f, 0.20659649f, 0.23464510f, 0.12258264f, 
    -0.06393696f, -0.05520239f, -0.03439173f, -0.12444799f, -0.07470145f, 0.08322698f, -0.01317818f, -0.13795292f, 
    0.13555042f, 0.21800214f, -0.02482510f, 0.01882897f, 0.08819039f, 0.05318461f, 0.02300493f, 0.00433203f, 
    -0.06852636f, 0.26889220f, 0.01994510f, 0.22208163f, -0.05564314f, -0.01999453f, -0.01950125f, 0.10701064f, 
    0.18446572f, 0.01662269f, 0.01628949f, 0.13748753f, -0.13498017f, -0.06198933f, -0.08549890f, -0.08180690f, 
    -0.00956453f, -0.07542066f, -0.07071542f, -0.03415869f, 0.09289891f, 0.40450829f, 0.11314722f, -0.07174210f, 
    0.10985214f, -0.15617798f, -0.13256779f, -0.26733428f, -0.03694772f, -0.02667529f, -0.04082286f, -0.11128481f, 
    0.01569648f, 0.02061983f, 0.01027192f, 0.08427655f, -0.03633691f, 0.00034820f, 0.03178531f, 0.03383901f, 
    0.08008000f, -0.08477588f, -0.01267188f, -0.06909633f, 0.10934652f, 0.21751237f, -0.21859182f, -0.00857170f, 
    0.22980702f, 0.05215834f, 0.26322266f, 0.09236988f, -0.05853925f, 0.12266497f, -0.01960000f, -0.04156449f, 
    -0.13007927f, -0.06607237f, 0.10225777f, -0.13901193f, 0.09097086f, 0.03837487f, -0.09624668f, -0.03568520f, 
    -0.02768340f, 0.01202938f, -0.00124336f, 0.05229642f, 0.00992497f, 0.19288099f, -0.05876953f, -0.05628421f, 
    -0.01115655f, -0.01805817f, -0.08781470f, 0.05973256f, -0.03629084f, 0.02770723f, 0.07272523f, 0.08482396f, 
    -0.09387002f, 0.17161356f, -0.05000434f, -0.04927189f, -0.06825785f, -0.17498218f, 0.01884233f, -0.07813833f, 
    0.12523189f, -0.02486954f, -0.03790500f, 0.13702811f, 0.21951896f, 0.23253714f, -0.22355080f, -0.11500868f, 
    0.25893635f, 0.02178467f, 0.11456422f, 0.16115786f, -0.02827667f, -0.00841727f, -0.00057960f, 0.00746776f, 
    -0.17661546f, -0.12505268f, -0.04260344f, 0.09861966f, 0.26394027f, 0.04341666f, -0.08237737f, -0.20902099f, 
    0.08079296f, 0.05094739f, -0.00881637f, 0.21553950f, -0.05574906f, 0.21393453f, 0.34700993f, -0.31533259f, 
    0.08105820f, -0.07643136f, -0.05128933f, 0.07093462f, 0.07246002f, 0.00353291f, -0.00644587f, -0.05858665f, 
    -0.05846803f, -0.03481338f, -0.00527589f, 0.04170703f, -0.05365584f, -0.04890871f, -0.05821748f, 0.05255736f, 
    -0.02012010f, -0.03778865f, 0.02180768f, -0.04571643f, 0.02555627f, 0.02775503f, -0.00987031f, -0.01140847f, 
    -0.02547809f, 0.01180451f, -0.02175212f, -0.07802999f, -0.04555322f, -0.00303990f, -0.00389042f, 0.01328967f, 
    -0.03776528f, 0.01722449f, -0.06478456f, -0.04664527f, 0.04526762f, 0.00562483f, -0.06546751f, 0.01546868f, 
    0.05144003f, -0.05973000f, -0.01525139f, -0.05795925f, -0.02196644f, -0.04357984f, 0.05870956f, -0.04604035f, 
    0.04610241f, -0.02392415f, -0.01401223f, 0.04834436f, -0.03719029f, 0.05099588f, -0.07438369f, 0.04334177f, 
    -0.00615889f, -0.02243344f, -0.05213065f, -0.04694722f, -0.08351323f, 0.00061800f, -0.00823593f, -0.03649667f, 
    -0.03162784f, 0.01642128f, -0.08116513f, -0.02379047f, 0.05273594f, -0.06287035f, -0.05156269f, -0.00562711f, 
    0.05664857f, 0.02588669f, 0.02874096f, -0.00174348f, 0.05035820f, 0.05470720f, 0.02205008f, 0.05730424f, 
    0.05388708f, 0.02961764f, -0.03486114f, -0.06743621f, 0.05282415f, -0.02499516f, -0.03175584f, 0.01720157f, 
    0.00128313f, -0.02607197f, -0.04828047f, 0.04152085f, -0.06657530f, 0.01263807f, 0.01103074f, -0.01368919f, 
    -0.07070259f, -0.04989224f, -0.06517562f, -0.02884858f, -0.01333660f, -0.05749109f, -0.08040090f, 0.02143881f, 
    -0.05397577f, -0.01054607f, 0.05484154f, -0.02130398f, -0.02901372f, -0.00103390f, -0.03418557f, 0.02937279f, 
    -0.02618731f, 0.01661164f, 0.06111618f, -0.03219185f, -0.04453351f, -0.05813305f, -0.04829292f, -0.07328351f, 
    -0.01520123f, 0.04795908f, -0.06733117f, -0.03973375f, -0.00073598f, -0.00675361f, 0.05661612f, -0.06026752f, 
    0.02485590f, -0.05951970f, -0.03009605f, 0.05820954f, -0.00252669f, -0.07579470f, 0.00598722f, 0.01875498f, 
    -0.05056043f, -0.04323496f, -0.00025333f, 0.05994432f, 0.04863213f, 0.00962958f, 0.03591937f, 0.04720730f, 
    -0.08012121f, 0.02656456f, 0.04232655f, 0.02063188f, 0.05755641f, -0.02955588f, -0.06062071f, -0.06652768f, 
    -0.05905838f, 0.04737475f, 0.04642233f, 0.02803307f, -0.00252202f, 0.00095839f, 0.00198039f, 0.01377296f, 
    -0.02491020f, -0.01135308f, -0.01288985f, 0.02126760f, 0.06781468f, -0.04832173f, 0.05417479f, -0.00926371f, 
    0.03886797f, -0.03620911f, -0.02570211f, -0.03609897f, 0.03768215f, -0.03181478f, -0.07185815f, -0.06781950f, 
    -0.04942561f, 0.05694158f, 0.04364334f, -0.08178122f, -0.07717095f, 0.00091235f, -0.02458333f, 0.02105550f, 
    -0.02328240f, -0.03482928f, 0.00513858f, 0.00101454f, -0.04200463f, 0.02069436f, -0.07799775f, 0.02282905f, 
    0.04009946f, 0.03480970f, 0.00595473f, 0.06427892f, -0.04308888f, -0.07375427f, 0.02425941f, -0.04475760f, 
    -0.32604438f, 0.01026460f, 0.05027068f, 0.10557244f, 0.14676021f, 0.10500209f, 0.12465990f, 0.00372724f, 
    -0.01651613f, -0.02112236f, 0.15616284f, 0.06317127f, 0.17441604f, 0.01588539f, 0.11545023f, 0.00366784f, 
    0.05161284f, 0.00023966f, -0.12718007f, -0.11877325f, -0.02617443f, 0.00679629f, -0.07253405f, 0.15344001f, 
    0.39275184f, 0.00766190f, 0.24301499f, 0.11228380f, 0.05188823f, -0.02582075f, -0.24159339f, -0.00052223f, 
    -0.13449928f, 0.05227121f, -0.03728642f, 0.03096875f, -0.07687870f, -0.08743472f, 0.04782388f, 0.02318567f, 
    0.03198677f, 0.23011112f, 0.07579057f, 0.01457419f, 0.07201440f, 0.06919091f, 0.09996537f, 0.21436509f, 
    -0.05616117f, 0.06944532f, -0.06134479f, 0.03151968f, -0.13083878f, -0.15081227f, -0.10209034f, -0.06595264f, 
    0.14261311f, 0.10489758f, -0.04329490f, 0.10967526f, -0.22057381f, 0.06319996f, 0.14397076f, -0.12527038f, 
    -0.05002226f, 0.09711003f, 0.05928706f, 0.07098608f, 0.04548764f, 0.05582121f, 0.08713987f, 0.23871599f, 
    0.28547853f, 0.25785923f, 0.13659003f, 0.05342196f, -0.16609715f, -0.05585292f, -0.17838830f, -0.15847693f, 
    -0.20745379f, -0.05137970f, -0.00731257f, -0.00708445f, 0.37861264f, 0.23934019f, -0.07595788f, 0.22069649f, 
    0.01995301f, -0.18408106f, -0.10916723f, -0.05499137f, 0.12633766f, -0.07515804f, 0.03287108f, 0.08219974f, 
    0.22943288f, 0.10277233f, 0.08092561f, 0.11783306f, 0.12105316f, 0.07546183f, -0.00438216f, 0.03293278f, 
    -0.05989956f, 0.04210870f, -0.13034973f, -0.24099433f, -0.23120232f, 0.01766087f, -0.04244157f, 0.04580507f, 
    0.13814174f, 0.02528543f, 0.06522778f, 0.02001991f, 0.04133686f, -0.06651555f, 0.05931697f, 0.06989925f, 
    -0.10293546f, -0.20827816f, 0.02814880f, -0.03057309f, 0.14799623f, -0.15563212f, 0.16292556f, 0.22104050f, 
    -0.04462874f, 0.08565603f, -0.09584244f, -0.13218494f, 0.08772352f, 0.24729164f, 0.11083651f, -0.04998546f, 
    -0.09297509f, -0.03309622f, 0.07185449f, -0.10796974f, -0.06483082f, -0.09961615f, 0.07751803f, 0.12949932f, 
    0.14512138f, 0.04897111f, 0.19213663f, 0.00735831f, -0.06550977f, -0.07207102f, -0.04213105f, -0.12461251f, 
    -0.03575602f, 0.03223308f, 0.05141788f, 0.06676196f, -0.12794471f, 0.11379655f, -0.05378104f, 0.09049890f, 
    0.00610212f, 0.02091552f, -0.10200477f, -0.09887981f, 0.03996031f, 0.13267756f, -0.05386942f, 0.04523489f, 
    -0.38740036f, -0.15692310f, -0.01167515f, 0.07932021f, 0.10092197f, -0.17189540f, -0.06024788f, -0.03957787f, 
    0.08484633f, -0.01767817f, 0.19683753f, 0.07605704f, -0.03239651f, -0.02974882f, 0.07273402f, -0.07924721f, 
    0.18944907f, -0.35491636f, 0.05210410f, 0.04741254f, 0.03891899f, 0.04627387f, -0.09478025f, -0.10781404f, 
    0.35221016f, -0.05158385f, 0.19845508f, 0.28521800f, 0.11757348f, -0.02619947f, 0.18763201f, 0.12370319f, 
    0.03935128f, 0.08423722f, -0.02614174f, 0.06033307f, -0.26505220f, -0.06621022f, -0.22203946f, -0.01057018f, 
    0.12642166f, -0.13226680f, -0.22504637f, 0.13805029f, -0.16054942f, -0.23245656f, -0.11230307f, -0.04967000f, 
    -0.29480323f, -0.24859409f, 0.05074519f, 0.23551618f, 0.11696646f, -0.03043354f, -0.05031013f, 0.02407314f, 
    0.12880412f, -0.15428823f, -0.04780711f, -0.06483122f, -0.03955152f, 0.21446957f, -0.16209538f, 0.02651423f, 
    0.07974549f, -0.00273910f, 0.00382257f, 0.05957808f, -0.06218098f, -0.07838472f, -0.00080286f, -0.04743262f, 
    -0.02800555f, -0.32809007f, -0.17455359f, -0.22395357f, 0.05346454f, 0.19348538f, -0.06711259f, -0.06688000f, 
    0.01029237f, -0.08693677f, -0.09057096f, 0.14951825f, 0.11156888f, 0.31216678f, -0.12987344f, 0.16344517f, 
    0.13372026f, 0.02446434f, -0.01455831f, 0.18315329f, 0.04869843f, 0.03991445f, 0.10776582f, 0.14989084f, 
    -0.27034405f, -0.51420045f, -0.25326431f, 0.11681007f, 0.09225200f, 0.05563461f, 0.01091147f, -0.08840394f, 
    0.00062822f, -0.06984030f, -0.02870765f, 0.05889389f, -0.21007393f, 0.11778730f, 0.27690247f, -0.14283220f, 
    0.07627730f, -0.02074361f, -0.04847654f, -0.09022921f, -0.01997141f, -0.10795975f, -0.09420081f, -0.21937710f, 
    -0.19545494f, -0.11817879f, 0.04811515f, -0.04211602f, 0.02482118f, -0.05700012f, 0.07551891f, -0.00028601f, 
    -0.10763085f, -0.08959347f, 0.06923128f, 0.12864819f, 0.09573559f, 0.18323258f, 0.17358817f, 0.10509580f, 
    0.08716621f, 0.07723501f, 0.18875018f, 0.08069520f, -0.08253037f, -0.03296588f, -0.03247259f, -0.16179079f, 
    0.01493960f, 0.09541028f, 0.11853367f, -0.09739141f, -0.03797804f, 0.22627966f, -0.11151764f, -0.05175385f, 
    0.16010167f, 0.01078183f, 0.11243913f, 0.20964687f, 0.12054522f, 0.24511702f, -0.16286327f, -0.15109262f, 
    -0.00307075f, -0.08039677f, -0.01497100f, -0.01977790f, 0.01662259f, 0.03835351f, -0.02198675f, -0.02983306f, 
    -0.21450578f, 0.05271521f, -0.11380725f, -0.05258488f, 0.09628581f, -0.03702788f, -0.05666554f, 0.15951668f, 
    0.00767788f, -0.17202710f, -0.11220253f, 0.01153208f, 0.27660638f, 0.28303653f, 0.20600899f, -0.05498761f, 
    0.09852670f, -0.02073401f, 0.12868175f, 0.01850963f, 0.12213662f, 0.00271486f, 0.11371356f, 0.06461720f, 
    -0.35748112f, -0.04835631f, -0.05775860f, 0.42960945f, 0.00258912f, -0.09419920f, -0.11316179f, 0.06663376f, 
    0.13886906f, 0.09545437f, 0.00384832f, 0.02857414f, -0.28366679f, 0.00174689f, 0.21895687f, 0.04168524f, 
    0.01277784f, 0.13101229f, -0.02974798f, 0.15846007f, 0.12191238f, -0.02004836f, 0.05665459f, -0.20714320f, 
    -0.22040978f, 0.40073070f, -0.01121888f, -0.13488878f, 0.08398236f, 0.02089240f, -0.14820768f, -0.08252038f, 
    0.04633948f, -0.06814966f, -0.06727808f, -0.09391475f, -0.18138273f, -0.16765101f, 0.21443199f, 0.09769001f, 
    0.00331854f, -0.04842418f, 0.05752297f, -0.02723846f, 0.03466572f, 0.08760203f, 0.13614365f, 0.05955752f, 
    -0.13830264f, 0.10353983f, -0.01179555f, 0.20667954f, -0.03258197f, -0.05875844f, -0.06177185f, -0.17296025f, 
    -0.07917520f, 0.06414306f, -0.14210977f, 0.09452001f, 0.16143446f, -0.14034590f, 0.14634803f, 0.07549239f, 
    0.01156581f, 0.13855343f, 0.18374081f, 0.00534399f, 0.27492741f, 0.03595085f, 0.17356871f, 0.13336408f, 
    -0.25737941f, 0.19877268f, -0.12307346f, 0.19194032f, -0.15170668f, 0.01869821f, -0.02611299f, -0.11989840f, 
    -0.03499065f, 0.17528372f, 0.12789036f, 0.22334340f, 0.26210576f, -0.14065908f, 0.27842018f, -0.01438768f, 
    0.03481256f, 0.06516457f, 0.01591307f, 0.12814148f, -0.04791102f, 0.03971588f, -0.07598042f, 0.15062265f, 
    -0.01992259f, 0.00758307f, 0.16793168f, -0.01515611f, -0.10116993f, -0.07627790f, -0.07546380f, -0.05875577f, 
    -0.07658712f, -0.09548932f, 0.02560713f, -0.06283022f, 0.23152179f, 0.17473756f, -0.06897658f, 0.08811695f, 
    0.02516310f, -0.04813637f, 0.02971885f, -0.09123302f, 0.05143109f, 0.04998817f, 0.11971641f, 0.09821679f, 
    -0.11343430f, 0.06558798f, -0.05869481f, -0.02010621f, -0.21194364f, -0.01826460f, -0.17753306f, -0.08168904f, 
    -0.18463348f, -0.11761317f, -0.13662367f, -0.28175390f, -0.04605111f, 0.03706525f, -0.07060377f, 0.11488798f, 
    0.01448674f, 0.21315627f, 0.03078053f, 0.05709122f, 0.00109748f, 0.09250412f, 0.08213383f, 0.07991266f, 
    -0.06731299f, -0.00561626f, -0.05029811f, 0.01891772f, 0.02342235f, -0.08482150f, 0.03989058f, 0.13959451f, 
    0.03832343f, -0.06973964f, -0.08433742f, -0.04573826f, -0.19513133f, 0.05102060f, 0.16269042f, 0.07102061f, 
    -0.02857735f, 0.01700501f, 0.00288982f, -0.05801583f, -0.08097060f, -0.12237450f, -0.01686317f, 0.05256339f, 
    -0.20171712f, 0.19682790f, 0.21574764f, -0.05303393f, -0.12251479f, 0.00393868f, 0.05230150f, 0.02670261f, 
    -0.12830214f, 0.10768443f, 0.03409899f, 0.16048123f, -0.03720684f, -0.02431816f, -0.15202287f, 0.19697315f, 
    0.14570223f, 0.11492927f, 0.03941758f, 0.15514125f, -0.02461613f, 0.05896812f, -0.00815357f, -0.02393077f, 
    -0.10191687f, -0.03019101f, 0.09668421f, -0.19774425f, -0.07543834f, -0.02021389f, -0.09585853f, -0.19767414f, 
    0.11079598f, -0.02859143f, 0.05169325f, 0.15820666f, 0.13252483f, 0.07471766f, 0.09594724f, -0.22170673f, 
    0.02355081f, -0.00252753f, 0.06797434f, 0.08827308f, -0.04313064f, 0.02278686f, 0.02307333f, -0.05176508f, 
    0.26611447f, -0.01484731f, -0.00468093f, 0.11413674f, -0.00535545f, -0.01266371f, 0.09553391f, -0.12302503f, 
    0.03933242f, 0.02550437f, 0.00630295f, 0.12462018f, -0.27428827f, 0.03662798f, -0.20318165f, 0.11286446f, 
    0.15517779f, -0.00968917f, -0.06547622f, 0.07435384f, -0.05252720f, 0.02965093f, 0.05907132f, 0.00205407f, 
    -0.25862738f, -0.09966067f, -0.36629647f, 0.42987341f, 0.15132822f, -0.08215716f, -0.00574316f, -0.03975414f, 
    0.09752911f, 0.03353994f, -0.04443521f, -0.05307350f, -0.04151267f, 0.09109441f, 0.00360702f, -0.04786072f, 
    0.17137669f, 0.07096343f, 0.03781472f, -0.07978591f, -0.13790923f, -0.02014211f, 0.09073965f, -0.03666745f, 
    0.15334944f, -0.20888962f, -0.08904798f, -0.13793242f, -0.10752475f, 0.09059655f, -0.07387681f, -0.08317953f, 
    -0.10074913f, -0.09540233f, 0.00862823f, -0.09915165f, 0.03805179f, 0.19427429f, -0.22411202f, 0.01010047f, 
    -0.10198960f, 0.15671359f, 0.03891408f, 0.11243172f, -0.02278939f, -0.01206220f, -0.04855341f, -0.06354292f, 
    -0.33169255f, -0.37561068f, -0.19176976f, 0.08182641f, 0.18508999f, 0.09547871f, -0.00014370f, -0.02924295f, 
    0.00114976f, 0.01830852f, 0.07178897f, 0.11987100f, 0.08652619f, -0.11262980f, 0.45992756f, -0.19266880f, 
    0.22616877f, -0.07232746f, -0.09455033f, -0.01628403f, 0.05481557f, -0.07480417f, -0.06647440f, -0.09981135f, 
    -0.13470216f, -0.15528497f, 0.01089159f, -0.11685203f, 0.05074086f, -0.01839038f, 0.01203442f, 0.06872005f, 
    -0.01246024f, 0.08458173f, 0.07377750f, 0.08815168f, 0.20906484f, 0.13061823f, 0.08391972f, -0.05848426f, 
    0.10613259f, -0.08611319f, 0.26723364f, -0.03490007f, -0.03346271f, -0.07784699f, 0.02558125f, -0.08290111f, 
    -0.11263926f, -0.01493124f, 0.20944618f, -0.03173886f, -0.03990870f, -0.16443190f, -0.05846692f, -0.08111354f, 
    -0.03849315f, 0.08987547f, 0.08438922f, 0.03986226f, 0.09972062f, 0.19319220f, -0.32389966f, -0.04098174f, 
    0.07553238f, 0.06102391f, 0.02813210f, 0.15128721f, 0.08770884f, 0.05230403f, 0.11046777f, -0.11297541f, 
    -0.14001907f, 0.17553900f, -0.22811234f, 0.06417861f, 0.10192225f, -0.03775595f, 0.00422898f, -0.05427563f, 
    0.04547630f, -0.06107267f, -0.05299933f, -0.02599463f, 0.34952351f, 0.17482400f, -0.00154341f, -0.14917476f, 
    0.10787681f, -0.07852285f, 0.09621041f, 0.16332574f, 0.06500800f, -0.07552294f, 0.09119908f, 0.05754005f, 
    -0.22290316f, 0.18313676f, 0.16860871f, 0.08125741f, 0.02321432f, 0.01475430f, -0.04764188f, 0.00543344f, 
    0.15378070f, 0.00693035f, -0.00531443f, 0.05755621f, -0.18951580f, 0.11306657f, 0.21532096f, -0.04582657f, 
    0.00363768f, -0.03308618f, -0.08151929f, 0.14501013f, 0.11092635f, -0.11625145f, -0.02137934f, 0.09903284f, 
    0.00168352f, 0.06263208f, -0.02924585f, 0.05636879f, -0.03921361f, -0.00469952f, -0.02059095f, 0.02580014f, 
    0.04295063f, -0.01148621f, -0.01647713f, -0.07336312f, -0.03406667f, -0.06740844f, 0.03384992f, 0.04596408f, 
    -0.01108083f, 0.05747545f, 0.02765418f, 0.03253353f, 0.01548302f, -0.07344213f, -0.02193069f, -0.03948430f, 
    -0.03310496f, -0.05932352f, 0.02307437f, 0.02591331f, -0.01435192f, -0.00055400f, -0.03555823f, 0.05571236f, 
    0.04890018f, -0.05343607f, -0.05194958f, -0.00628851f, -0.05845972f, -0.03743016f, 0.03085089f, 0.03396661f, 
    -0.06859958f, -0.02672919f, -0.03530335f, 0.03561714f, -0.06754164f, -0.05469956f, 0.01648797f, -0.03129467f, 
    -0.07583623f, -0.00797346f, -0.01900936f, -0.02780835f, -0.05253394f, 0.02466285f, 0.01347533f, -0.05880984f, 
    -0.00563363f, -0.05761936f, -0.05688195f, -0.03925156f, -0.02652139f, -0.03026434f, 0.04950271f, -0.07039609f, 
    -0.00984821f, -0.05030249f, -0.06544446f, 0.04040921f, -0.01884074f, -0.00746340f, -0.07109483f, -0.01887765f, 
    -0.04167080f, 0.05845213f, 0.02448142f, 0.06116034f, -0.02004343f, -0.05906732f, 0.00467501f, 0.04074477f, 
    -0.07103800f, -0.00178882f, 0.02284334f, 0.01354301f, 0.03778411f, 0.01790444f, 0.03586399f, -0.06394037f, 
    0.05358221f, -0.02060606f, -0.03628779f, 0.05758360f, 0.04307933f, -0.01564586f, -0.05390988f, 0.04333256f, 
    0.03734968f, -0.01547698f, -0.05249730f, -0.01133843f, 0.01278230f, 0.03679556f, 0.01209668f, -0.07023942f, 
    0.05843883f, -0.05866991f, -0.06380247f, 0.00949823f, 0.02497068f, -0.03972103f, 0.03435588f, 0.06533936f, 
    0.01391229f, -0.00707340f, 0.01556799f, -0.05532612f, 0.02798522f, -0.05896929f, -0.01962174f, -0.05037016f, 
    -0.04711449f, 0.05085354f, 0.02609626f, -0.05018806f, -0.05354840f, -0.04184405f, -0.07456109f, 0.02217326f, 
    -0.04656612f, -0.06982786f, -0.07082107f, -0.02952797f, -0.05888947f, -0.02321454f, -0.02654655f, -0.03540104f, 
    0.05915648f, -0.01894904f, 0.00346958f, -0.01227847f, -0.04794401f, -0.05646131f, -0.07657129f, 0.02501554f, 
    -0.05096952f, -0.05660851f, 0.01478158f, 0.03617110f, 0.02215635f, 0.01887529f, -0.07275919f, -0.04287617f, 
    -0.02798438f, -0.03750267f, -0.02530853f, -0.06326007f, -0.04954308f, -0.05227854f, -0.02660444f, 0.01979322f, 
    -0.05168608f, -0.06118096f, 0.06507799f, -0.05679056f, -0.06461846f, 0.02337549f, 0.00532139f, -0.03504781f, 
    0.04779277f, 0.03270014f, 0.02507020f, -0.00795934f, -0.01362092f, 0.02487425f, 0.00831027f, 0.04357679f, 
    0.03218264f, -0.01967627f, 0.04446443f, -0.07558223f, -0.02969817f, -0.04821339f, -0.04767256f, -0.01582644f, 
    -0.00858620f, 0.00091519f, 0.02326254f, 0.00987108f, -0.04717622f, -0.04640908f, 0.01053002f, 0.06173527f, 
    -0.00334312f, -0.05531466f, -0.00104645f, 0.05236536f, -0.07016191f, 0.00393697f, -0.03686824f, 0.02416765f, 
    -0.05853148f, -0.01180217f, 0.01623537f, -0.06578113f, -0.01014216f, -0.05856221f, -0.02647694f, -0.00404756f, 
    0.06489845f, -0.01305852f, 0.03787554f, 0.01243500f, 0.05584370f, -0.04711456f, -0.00271196f, 0.05038413f, 
    -0.07646061f, 0.04166367f, -0.00402007f, 0.03512252f, -0.01535907f, -0.07890103f, -0.06627580f, -0.05652163f, 
    -0.07288497f, 0.05910121f, -0.01218108f, 0.03194354f, 0.05753013f, -0.06532317f, 0.04203333f, -0.07124755f, 
    -0.05365545f, 0.05415915f, -0.07603955f, 0.04183113f, -0.07205380f, 0.03453666f, -0.00366034f, -0.01334697f, 
    -0.01754028f, 0.02566966f, 0.01848181f, -0.06271154f, 0.05816517f, -0.06126743f, -0.00074599f, -0.06202889f, 
    0.05676656f, -0.08124832f, -0.01314419f, 0.00364466f, 0.05240855f, -0.03975488f, 0.06776029f, -0.06364258f, 
    0.02878296f, -0.03633815f, 0.04699179f, 0.05291925f, 0.02963910f, -0.01353452f, -0.01631192f, -0.03451279f, 
    0.00153499f, -0.05580029f, -0.02140915f, 0.03482722f, 0.00189997f, 0.00643288f, 0.03266840f, -0.03616248f, 
    0.01065683f, -0.00395505f, -0.06844956f, 0.04104681f, -0.06466248f, -0.02724796f, -0.08197058f, 0.00662025f, 
    -0.03582105f, 0.00260399f, -0.07226018f, -0.03595753f, -0.05434110f, -0.01899397f, -0.06561395f, 0.00837344f, 
    -0.03842972f, -0.07964557f, 0.01080163f, 0.03659548f, 0.03449211f, 0.03855037f, -0.01179696f, -0.00079358f, 
    0.05372642f, -0.05263337f, 0.05952435f, -0.05922181f, -0.04709965f, -0.02215257f, -0.05704205f, -0.03390422f, 
    0.03622387f, -0.07070675f, -0.03383679f, 0.05881894f, 0.01450820f, 0.00876098f, 0.02651730f, -0.06351703f, 
    -0.07432904f, -0.03683165f, -0.03732835f, -0.00840602f, 0.03368589f, -0.04746783f, -0.07568906f, 0.01773989f, 
    0.04774788f, 0.05123093f, -0.03808111f, 0.00031561f, -0.05737641f, -0.05018027f, 0.05453052f, 0.04230972f, 
    0.02811317f, 0.04517612f, 0.02744085f, -0.06213134f, 0.05696438f, -0.00713728f, 0.05560834f, -0.02143107f, 
    0.03027437f, -0.00947176f, -0.00435615f, -0.06645337f, -0.01991261f, 0.02070024f, -0.05376767f, 0.00009784f, 
    0.02183146f, -0.02772744f, 0.04978480f, -0.01937333f, -0.01186241f, 0.06556616f, 0.05214194f, -0.01158224f, 
    -0.07587342f, -0.01296621f, -0.08227747f, -0.04311584f, -0.00376126f, -0.01968340f, 0.00150550f, -0.05396421f, 
    -0.05262820f, -0.03715863f, -0.02423168f, -0.04513638f, -0.05005313f, 0.00720231f, 0.05286628f, -0.00028575f, 
    -0.00508386f, 0.04858576f, 0.00869928f, -0.07000874f, 0.01213848f, -0.06492061f, 0.02707545f, -0.02086302f, 
    -0.07887325f, -0.04351290f, 0.06242184f, -0.06913570f, -0.00067021f, -0.00427280f, -0.02401126f, 0.04078781f, 
    0.32365125f, -0.23589253f, 0.05753225f, -0.16164470f, 0.06975883f, -0.02021111f, 0.12655710f, 0.11711713f, 
    0.26872978f, 0.10057493f, 0.03561046f, 0.03882728f, -0.37900266f, 0.02696925f, -0.04811323f, -0.00159255f, 
    0.17395926f, -0.02381321f, -0.14334294f, 0.06535583f, -0.01467989f, -0.07017379f, 0.09032761f, 0.08789625f, 
    -0.19731361f, 0.20683272f, 0.12651604f, 0.08846292f, 0.19688188f, -0.00612596f, -0.15620407f, -0.05549610f, 
    0.06354895f, 0.07842191f, 0.07820717f, 0.15921852f, 0.00683202f, 0.19777848f, -0.23655024f, 0.09369738f, 
    -0.04024177f, 0.10970515f, 0.04852464f, -0.07426843f, -0.09830187f, -0.02798584f, 0.00740880f, -0.06614771f, 
    -0.12513283f, -0.21887901f, -0.09461499f, -0.21626262f, -0.18339282f, -0.03620883f, -0.08159393f, 0.01739210f, 
    0.12223914f, -0.04006371f, -0.03977530f, 0.17686132f, -0.04853706f, 0.32474235f, -0.17568462f, -0.05577024f, 
    0.11642440f, -0.04902501f, 0.02065689f, 0.17222643f, -0.08904312f, -0.06634160f, -0.01737086f, 0.11048076f, 
    -0.16795665f, 0.04138690f, -0.22897023f, 0.37253791f, -0.00606285f, -0.01508843f, -0.03357097f, -0.11324114f, 
    0.07609102f, -0.11295851f, -0.01277575f, 0.28132164f, 0.15767927f, -0.19044580f, 0.24458463f, -0.04150210f, 
    0.09912383f, -0.03762593f, -0.04352239f, -0.24102107f, 0.15059504f, -0.06929143f, 0.02148084f, 0.15530144f, 
    -0.17096001f, -0.06826542f, -0.06460156f, 0.03467859f, -0.04445127f, -0.11011028f, -0.05532079f, -0.04424144f, 
    -0.01617546f, -0.02131771f, -0.08553957f, -0.30846682f, 0.06731600f, -0.07731342f, -0.05724538f, -0.12627329f, 
    0.31287166f, 0.15228407f, 0.27108821f, 0.01372553f, 0.02386107f, 0.08587611f, -0.02744968f, 0.17752315f, 
    0.10242558f, -0.14263566f, -0.10691492f, -0.02939644f, 0.01760038f, -0.10936049f, -0.04249844f, 0.15444472f, 
    -0.04868949f, -0.06291392f, 0.07202481f, -0.04123308f, -0.07197605f, 0.49507183f, 0.02093187f, -0.37996528f, 
    -0.08148990f, -0.13113035f, -0.23812172f, -0.06112906f, 0.04331890f, 0.07328257f, 0.01220420f, 0.03748901f, 
    -0.31904083f, -0.15451668f, -0.09196381f, -0.06045705f, 0.02055070f, -0.05724338f, -0.12245283f, 0.01280645f, 
    -0.02924751f, 0.04679482f, -0.01126994f, -0.06462990f, 0.23384941f, 0.24895103f, 0.01176820f, -0.20136827f, 
    0.17823960f, 0.19485544f, 0.26310360f, -0.06992872f, 0.02263458f, -0.10783879f, -0.03257563f, 0.11152623f, 
    0.03615673f, -0.20723967f, 0.03780823f, 0.34783858f, -0.10196423f, -0.30231845f, 0.11256082f, 0.19500369f, 
    0.12460171f, -0.02777131f, -0.01561044f, 0.05188759f, 0.16555943f, -0.15195450f, 0.37999615f, 0.29360119f, 
    -0.07491834f, -0.00473734f, -0.19023848f, 0.25513837f, 0.12346383f, 0.13546738f, -0.04363577f, -0.06294783f, 
    -0.03436007f, -0.05570317f, -0.05649836f, -0.06682295f, -0.01444307f, -0.07353611f, 0.00122703f, 0.06442994f, 
    -0.03817005f, 0.01886110f, -0.05575990f, 0.03197968f, 0.04438591f, -0.01728708f, 0.03389058f, 0.02276381f, 
    -0.07051309f, -0.00832553f, -0.06772044f, -0.00620403f, 0.03408388f, 0.00675017f, 0.04355018f, -0.00403222f, 
    -0.04962544f, -0.03796854f, -0.04607696f, -0.07730615f, -0.05735081f, 0.03031132f, -0.05616825f, -0.00822298f, 
    0.00287776f, -0.02504729f, -0.00312373f, 0.01175102f, 0.03567599f, -0.04048301f, 0.02099761f, -0.06181183f, 
    0.03035691f, 0.03218165f, -0.07295377f, -0.03120248f, 0.01802906f, 0.00005680f, -0.05410921f, 0.05278997f, 
    -0.05203455f, 0.05382085f, 0.01798260f, 0.00285108f, -0.04985228f, 0.01920706f, 0.02809089f, -0.01937389f, 
    0.02634798f, -0.00110069f, 0.06001530f, -0.06242172f, 0.01590157f, 0.06091074f, -0.03260068f, 0.00656649f, 
    -0.06735169f, 0.02291569f, 0.04961205f, 0.02670249f, 0.06316840f, -0.06471051f, -0.05120824f, -0.04523281f, 
    -0.03502929f, -0.02909502f, 0.00952748f, 0.05693692f, 0.06189787f, -0.06460296f, 0.00868987f, -0.02444108f, 
    -0.04802084f, -0.05596910f, 0.02551804f, -0.04273278f, -0.02272522f, -0.00013441f, -0.03481868f, 0.02955740f, 
    -0.03566914f, 0.01141136f, 0.00274159f, 0.00712500f, -0.00983470f, -0.04368770f, -0.01988391f, 0.03571942f, 
    0.00818011f, 0.02768700f, 0.00763440f, 0.00411082f, 0.05936599f, -0.04929500f, 0.01057988f, 0.05797514f, 
    -0.01552718f, -0.05684024f, -0.04072661f, -0.06798293f, -0.03729196f, 0.06425718f, 0.02905319f, -0.06288690f, 
    0.00756487f, 0.01448616f, -0.01500856f, 0.01106209f, -0.01371649f, -0.00903550f, 0.00098460f, 0.01680125f, 
    0.04272313f, 0.02253521f, -0.04681751f, -0.01309779f, -0.03156629f, 0.04357978f, -0.05278543f, -0.04955328f, 
    -0.00162626f, -0.04557709f, -0.00854279f, 0.05060219f, 0.05219254f, -0.04883750f, 0.03141394f, 0.02703654f, 
    0.04631844f, -0.03797338f, 0.02782802f, 0.04804968f, -0.01241543f, -0.02309093f, 0.04138379f, -0.06945521f, 
    -0.00056356f, -0.04926321f, -0.05638294f, 0.01505981f, 0.00931920f, 0.03574111f, -0.03462756f, 0.05021863f, 
    -0.03870888f, -0.07743337f, -0.05414755f, 0.00368923f, 0.03630380f, 0.05329146f, 0.04491498f, -0.06475957f, 
    -0.02497198f, -0.02330435f, 0.01313369f, -0.05307385f, -0.02883072f, 0.05126227f, -0.03570069f, -0.06397568f, 
    -0.00945835f, -0.02923116f, -0.06315024f, 0.01398844f, 0.06115507f, -0.07356438f, -0.01205821f, 0.00433551f, 
    -0.04253059f, -0.05066769f, -0.06589631f, -0.03200917f, -0.07665195f, 0.01806723f, -0.00657775f, 0.00954859f, 
    -0.02823247f, -0.03773350f, -0.02891279f, 0.02134265f, -0.02999515f, -0.01083788f, 0.05591721f, -0.01175327f, 
    -0.17195527f, 0.42746928f, 0.00857731f, -0.04286015f, 0.09503336f, 0.09209875f, 0.03143957f, 0.05552382f, 
    -0.06238626f, 0.06066925f, 0.01171994f, 0.02088233f, 0.37538105f, -0.03772914f, 0.07392703f, -0.01457276f, 
    -0.13849954f, -0.18695611f, -0.02098571f, -0.19907315f, 0.02058724f, 0.00765787f, -0.07003145f, 0.02774760f, 
    0.21314368f, 0.01129317f, 0.40810376f, -0.12289215f, -0.11888096f, -0.08869215f, -0.25922835f, -0.08749536f, 
    0.00920038f, 0.16722177f, 0.01193601f, -0.05244245f, -0.01672270f, -0.09486717f, 0.00459835f, -0.05416075f, 
    0.14720489f, 0.10998431f, 0.13665225f, -0.13517991f, 0.15362392f, 0.14037839f, 0.17423134f, 0.11024588f, 
    -0.07629123f, 0.16546752f, -0.15387438f, 0.00117978f, -0.10052958f, 0.00029038f, -0.06542274f, 0.01934117f, 
    0.10037871f, 0.11057547f, -0.04757098f, 0.03194992f, 0.00377987f, -0.19967028f, 0.18601391f, -0.04224368f, 
    0.06192581f, 0.17500414f, -0.07883336f, -0.03513677f, -0.01654762f, -0.03001992f, 0.05532740f, 0.19863074f, 
    0.25204629f, 0.15849073f, 0.19204220f, 0.02703905f, -0.19396205f, -0.07575510f, -0.16827248f, -0.05314383f, 
    -0.05599117f, 0.02390498f, -0.14878309f, -0.14373814f, 0.04289526f, 0.48875427f, -0.25083795f, 0.11182823f, 
    -0.12361673f, -0.04675065f, 0.01103306f, -0.10011090f, -0.05159204f, 0.03646975f, -0.03086513f, 0.08299934f, 
    0.04425893f, 0.07861304f, 0.00303179f, 0.08076813f, -0.10565107f, 0.02549989f, 0.03818795f, -0.01652315f, 
    0.02180079f, -0.08165836f, -0.02780033f, -0.16237482f, -0.17459525f, 0.23037302f, -0.04958655f, 0.18242748f, 
    -0.06731045f, 0.14478229f, 0.03418811f, 0.12334184f, 0.02318668f, -0.09182940f, 0.00743349f, -0.04891570f, 
    -0.06704981f, -0.13880712f, -0.01245967f, 0.00028446f, 0.01671029f, 0.07368352f, 0.00713554f, 0.13312182f, 
    0.07157262f, 0.06189874f, -0.02341642f, -0.08520908f, -0.03539985f, -0.09297970f, -0.03102311f, -0.08271004f, 
    -0.06314550f, -0.08741334f, -0.05236314f, -0.11953929f, -0.05782190f, -0.04383158f, 0.00538076f, 0.15522876f, 
    0.21339743f, 0.00627322f, 0.21527460f, -0.06388047f, 0.02875637f, 0.04506772f, -0.10198576f, -0.06601493f, 
    -0.03755072f, -0.05190341f, 0.00273318f, 0.07859526f, -0.19705361f, -0.02961286f, -0.06584409f, 0.07572263f, 
    0.02598969f, 0.17080455f, 0.03834551f, -0.11808297f, -0.06336451f, 0.09516644f, -0.07612634f, 0.11187239f, 
    -0.34390894f, -0.17348434f, 0.02882438f, -0.01703828f, 0.05864410f, -0.04111690f, 0.01429242f, 0.00334588f, 
    -0.08482521f, 0.12699665f, 0.06642079f, 0.17841411f, -0.14261110f, -0.02872033f, 0.12301128f, -0.24292968f, 
    0.18888320f, 0.00940163f, 0.07887809f, 0.03965192f, 0.01228653f, -0.04498744f, 0.03083627f, -0.04352666f, 
    -0.09974854f, 0.20752740f, -0.03081715f, -0.18819581f, 0.10462798f, 0.09056688f, 0.03790176f, 0.01798097f, 
    0.01023362f, 0.02460215f, 0.00991365f, -0.13216762f, -0.15646110f, -0.19944385f, -0.04731266f, -0.10574948f, 
    -0.00775132f, -0.17948614f, 0.02242321f, -0.07631535f, 0.03751359f, 0.01235936f, 0.14293613f, 0.16833539f, 
    -0.43848908f, 0.19135125f, -0.05415894f, -0.06621567f, -0.04600164f, -0.06157641f, -0.05291077f, -0.22123823f, 
    -0.08858566f, 0.04031447f, -0.12691376f, 0.06966355f, 0.02361180f, 0.00904084f, 0.07964609f, 0.12852277f, 
    0.13838346f, 0.02335823f, 0.25798911f, 0.07377068f, 0.21742518f, 0.03587672f, 0.12118289f, 0.12476029f, 
    -0.08158028f, -0.03843007f, -0.05839242f, 0.02828455f, -0.04181018f, 0.09807169f, 0.03381639f, -0.04068915f, 
    0.04025329f, 0.18683684f, 0.32388574f, 0.15010737f, 0.12231429f, 0.04472632f, 0.13325872f, 0.10238754f, 
    -0.08835814f, 0.18165842f, -0.04469246f, 0.07217958f, 0.05192214f, 0.06035570f, -0.16700818f, 0.08281344f, 
    0.01115603f, -0.14136741f, -0.06262015f, -0.14590549f, -0.00937708f, 0.02670945f, -0.07100862f, 0.02450449f, 
    -0.15074120f, -0.08150204f, 0.13630964f, 0.13316652f, 0.12149026f, 0.22018918f, -0.04663339f, -0.22572000f, 
    -0.00672170f, -0.00945950f, -0.09734448f, -0.24047971f, 0.18053399f, -0.01252517f, -0.02732206f, 0.11971150f, 
    -0.11795714f, 0.02791017f, -0.16373272f, -0.17497091f, -0.16769587f, -0.08742680f, -0.19574389f, 0.01589550f, 
    -0.12903403f, -0.02435572f, -0.05815952f, -0.20451707f, 0.06423524f, 0.20926405f, 0.05480147f, 0.22549351f, 
    0.18383652f, 0.16262054f, 0.33716458f, 0.17808063f, 0.08419666f, 0.12953044f, 0.10981160f, 0.02509902f, 
    -0.08540361f, -0.16168018f, 0.02286754f, -0.03699537f, -0.07009756f, -0.07631424f, 0.08043424f, 0.09248833f, 
    -0.05074374f, 0.05986916f, -0.16359401f, -0.13307695f, -0.13010229f, 0.01046397f, -0.10505377f, -0.18412650f, 
    -0.01455084f, -0.18762159f, -0.10484687f, -0.16012798f, -0.00949153f, -0.05548083f, 0.05710840f, 0.13616367f, 
    -0.18473759f, 0.03331440f, 0.01047444f, -0.22492862f, -0.29972923f, -0.19586937f, -0.00102343f, -0.04917937f, 
    0.00608423f, 0.02640320f, 0.15023749f, 0.03858808f, 0.25328231f, 0.15512511f, -0.04251488f, 0.16327916f, 
    0.08866736f, 0.15245865f, 0.02460258f, 0.04099055f, -0.06432748f, -0.05385903f, -0.14467804f, -0.03314403f, 
    -0.14780547f, -0.22957046f, -0.06972575f, -0.15097232f, -0.01977996f, 0.06562284f, 0.04753191f, -0.10366883f, 
    0.00990484f, -0.07333729f, 0.08034475f, 0.06928863f, -0.11931991f, -0.04697515f, 0.25952527f, -0.21089585f, 
    -0.04994185f, 0.05208153f, -0.03296575f, 0.26587442f, 0.10818354f, 0.10449742f, 0.06436811f, 0.07969326f, 
    0.16614778f, 0.00194568f, 0.19456263f, 0.19457386f, 0.01864934f, -0.04752782f, 0.04353219f, -0.01744378f, 
    -0.04658521f, -0.02882489f, 0.09434001f, 0.04028706f, 0.37800595f, 0.25714710f, -0.00681080f, 0.04124163f, 
    -0.10122324f, -0.04521880f, 0.00535174f, -0.14551578f, -0.05085464f, -0.09333134f, 0.00084988f, 0.07769333f, 
    0.36267179f, 0.26036704f, 0.00883182f, 0.04633091f, 0.00252483f, -0.08981191f, -0.03525744f, -0.00509075f, 
    -0.02621240f, -0.07269061f, -0.02391999f, -0.03045937f, -0.14030640f, 0.13427188f, 0.04289135f, -0.12142407f, 
    -0.00999185f, -0.07635624f, 0.11302707f, 0.11243565f, -0.06084494f, 0.07928543f, 0.00653979f, 0.07726189f, 
    0.26974094f, 0.04572123f, 0.04194147f, -0.05846946f, 0.01147527f, 0.01243859f, 0.02942998f, 0.06488130f, 
    0.06941213f, 0.06577765f, 0.03160065f, -0.26874489f, -0.23545624f, 0.13973138f, -0.08955456f, -0.11656073f, 
    -0.15257449f, 0.05179962f, 0.03715130f, -0.09136786f, 0.01839654f, -0.04966107f, 0.00812127f, 0.00276550f, 
    0.18875133f, 0.18604316f, 0.17625865f, 0.12359031f, 0.02758856f, -0.02379024f, -0.09526627f, 0.02961903f, 
    0.08805894f, 0.09648801f, -0.05833958f, 0.02472935f, -0.14559442f, 0.09448950f, 0.06541330f, -0.11276866f, 
    -0.02214391f, 0.03562684f, 0.12913969f, 0.06918547f, -0.10024959f, 0.00692589f, 0.01221822f, -0.06411007f, 
    0.14212824f, 0.03670381f, 0.03717207f, 0.07171629f, 0.05041055f, 0.00148191f, 0.11846964f, 0.13409615f, 
    0.17530887f, -0.03622374f, 0.03271002f, 0.14170800f, -0.30707017f, -0.17708430f, -0.08124014f, -0.20814423f, 
    0.02854912f, -0.22166894f, 0.04970511f, 0.08011124f, 0.03829962f, -0.05029100f, 0.05775103f, 0.03892504f, 
    -0.20690407f, -0.07178715f, 0.02249487f, -0.15488183f, -0.01473188f, 0.18382666f, -0.05524220f, -0.14160487f, 
    0.05789346f, 0.10047541f, -0.08158333f, 0.01281245f, 0.55652034f, -0.22042494f, -0.12503023f, -0.04946646f, 
    0.01804325f, 0.11420444f, -0.09140617f, -0.04415601f, -0.01938578f, 0.05036008f, 0.05223953f, -0.03250321f, 
    0.24123348f, 0.22214019f, -0.09105383f, 0.08195090f, -0.09534655f, -0.02531162f, -0.06061034f, -0.17909847f, 
    0.08558953f, -0.18382294f, -0.01958132f, 0.02711328f, -0.05631183f, 0.01358788f, 0.11569783f, -0.14844282f, 
    0.06211336f, -0.01736302f, -0.00420841f, 0.21501812f, -0.00623717f, -0.03166251f, -0.04211418f, -0.07573183f, 
    -0.05175662f, 0.20867483f, 0.17915317f, 0.10329343f, -0.14460927f, 0.06482746f, -0.17571877f, -0.08336097f, 
    -0.05752375f, -0.12766945f, 0.01741598f, -0.08426154f, -0.37511158f, 0.00000756f, -0.01793140f, -0.00380489f, 
    -0.08597656f, -0.08302645f, 0.02420252f, -0.05699136f, 0.00223987f, -0.20134950f, -0.06832543f, -0.06661015f, 
    0.24326648f, -0.25667748f, 0.29176190f, 0.35784873f, -0.08176630f, 0.00007262f, 0.08687288f, 0.14326955f, 
    -0.00276872f, 0.11903167f, 0.13975909f, -0.06554537f, 0.13940425f, -0.13461372f, 0.17555554f, -0.25568637f, 
    0.08481220f, -0.18828084f, -0.22245440f, -0.04738151f, -0.00564375f, -0.02808448f, 0.00766152f, 0.00526684f, 
    -0.31642798f, -0.31221303f, 0.57889676f, 0.10369071f, 0.12502478f, -0.07748472f, -0.04110696f, -0.13303156f, 
    -0.03934096f, -0.04371697f, 0.01391163f, 0.00094462f, -0.02402226f, 0.18927088f, 0.06133813f, -0.10144183f, 
    0.19240195f, 0.07476819f, 0.07778522f, 0.01219100f, -0.11328812f, -0.07075596f, 0.03056941f, 0.04135508f, 
    -0.12459719f, 0.01679553f, -0.09890628f, -0.33558682f, -0.12845849f, 0.14866079f, 0.00529624f, 0.01093074f, 
    -0.06049338f, 0.00850811f, 0.02992207f, -0.05836236f, 0.09937179f, 0.11516061f, 0.16724560f, 0.10743458f, 
    0.03337612f, 0.04458596f, -0.17421643f, 0.19257689f, 0.04303166f, 0.08085329f, 0.02028334f, 0.14563991f, 
    -0.25389192f, -0.17623851f, -0.04136742f, -0.14676191f, -0.12913202f, 0.10444376f, -0.16035193f, -0.07418864f, 
    -0.15664165f, 0.06702533f, 0.02270995f, -0.08728215f, -0.21261299f, 0.44896740f, -0.17628525f, 0.06303103f, 
    -0.01591890f, -0.02882205f, 0.06112626f, -0.15544252f, 0.05965417f, -0.08654833f, 0.02789961f, -0.02080184f, 
    0.01933121f, 0.15724076f, -0.05009400f, -0.12776840f, -0.10191930f, 0.00755288f, -0.14461774f, -0.07083248f, 
    -0.19870369f, -0.04350351f, 0.17477033f, 0.00222398f, -0.09545244f, 0.39729857f, 0.21086851f, 0.27305013f, 
    -0.04072731f, -0.05301907f, 0.30022955f, 0.01111807f, 0.04031624f, -0.09541875f, 0.01804559f, -0.17491627f, 
    -0.04438123f, 0.08630329f, 0.22660211f, 0.01958537f, 0.10238911f, 0.11902796f, -0.08069833f, -0.01925784f, 
    0.10076627f, 0.07306269f, -0.09547240f, 0.06763009f, -0.23113675f, 0.04513015f, -0.12797885f, -0.15612586f, 
    -0.01831602f, -0.26756376f, -0.11951803f, -0.03703303f, -0.02598942f, -0.05673371f, -0.06768321f, 0.21775556f, 
    0.01896123f, 0.01017612f, 0.24231982f, -0.18131246f, 0.20820399f, -0.18802069f, -0.23069067f, 0.26500872f, 
    0.19526361f, 0.00698182f, -0.06552844f, 0.17498349f, -0.09012070f, 0.25607944f, 0.06816328f, 0.00340256f, 
    -0.11176345f, 0.09428602f, -0.01364036f, 0.11575918f, -0.00065199f, -0.09535605f, -0.00076910f, 0.06427262f, 
    -0.40840265f, -0.17425366f, -0.35032350f, 0.34701532f, 0.15151551f, -0.10752899f, -0.02150171f, -0.13291407f, 
    0.03537937f, 0.13418058f, -0.09257133f, 0.13907863f, -0.01731981f, -0.16850820f, 0.01585844f, -0.05574786f, 
    0.17468812f, -0.03792664f, -0.11741360f, 0.08489835f, 0.04703168f, -0.01224632f, -0.00713317f, -0.07159737f, 
    -0.12065949f, 0.16280092f, 0.22864448f, 0.17654333f, 0.01466066f, -0.05417493f, -0.05125586f, 0.03069480f, 
    0.02512475f, 0.11256826f, 0.23077177f, 0.11295916f, 0.03379343f, -0.01106524f, 0.00659716f, -0.01886755f, 
    0.07600335f, 0.04635065f, 0.04270238f, 0.02265640f, -0.03084691f, -0.05495667f, -0.07220829f, -0.02915598f, 
    0.04565926f, 0.10141119f, -0.46765065f, -0.26325357f, -0.02699702f, 0.00528306f, 0.01005112f, -0.06583258f, 
    -0.00614804f, -0.03112031f, -0.06430194f, 0.00922463f, 0.00541763f, 0.02743237f, 0.17240468f, -0.06740418f, 
    0.01743738f, -0.07146376f, 0.01713551f, 0.25196677f, 0.00474796f, -0.10870244f, -0.05602143f, 0.04217000f, 
    0.18446371f, -0.00094202f, 0.06956816f, 0.00592038f, 0.17010686f, -0.14509265f, 0.14019826f, -0.01195133f, 
    -0.05492157f, -0.08519176f, 0.08909354f, -0.11375386f, -0.01841900f, -0.19649963f, -0.12449475f, -0.19231129f, 
    -0.03540522f, 0.00160963f, -0.02721640f, -0.23733082f, 0.07069464f, 0.03440422f, -0.02922869f, 0.10003065f, 
    -0.12742765f, -0.02460243f, -0.10368095f, -0.08241728f, 0.00088947f, -0.07196223f, 0.03346499f, -0.00676236f, 
    0.03863418f, 0.08371727f, -0.10115460f, 0.06278685f, -0.06207988f, -0.23820496f, -0.13884729f, -0.03082341f, 
    0.09861099f, -0.05060064f, 0.14425078f, 0.25218892f, -0.07003722f, -0.00628031f, -0.02931283f, 0.04675338f, 
    -0.05919550f, -0.14148028f, -0.04097054f, 0.05671054f, 0.01903807f, 0.04108668f, 0.23084001f, 0.11245105f, 
    0.09934109f, 0.09108529f, -0.11617996f, 0.09736072f, -0.20379864f, -0.11387439f, -0.01807050f, -0.13803881f, 
    -0.02455427f, -0.11718208f, -0.18906175f, -0.07245610f, -0.03294756f, -0.02300677f, -0.04307299f, 0.02123626f, 
    0.16832173f, 0.30073485f, -0.06888245f, 0.07061589f, -0.07327385f, 0.00582057f, 0.09826498f, 0.04428430f, 
    0.23555249f, 0.03470846f, 0.02519188f, 0.06448060f, -0.06815165f, -0.39595449f, 0.08559185f, 0.13698147f, 
    0.06444793f, 0.10054025f, 0.14125191f, -0.04372776f, 0.04573360f, 0.00774886f, -0.03263744f, -0.11846294f, 
    0.29697904f, -0.02691055f, -0.19392568f, -0.02803884f, 0.02854093f, 0.19620322f, 0.13471428f, -0.03758475f, 
    -0.00367049f, -0.09270065f, 0.02203968f, -0.10249376f, -0.24839023f, -0.33071959f, 0.05697610f, -0.04905117f, 
    -0.06068334f, 0.08248156f, -0.10622922f, -0.07250925f, 0.01658667f, 0.11188048f, -0.04866695f, 0.06858741f, 
    0.05490128f, 0.10450058f, 0.20520039f, 0.18198180f, 0.07925026f, -0.05706157f, -0.07270661f, 0.09457146f, 
    0.07411201f, -0.02342304f, 0.16025315f, 0.01658812f, -0.23866971f, -0.14491419f, -0.30322576f, 0.08104800f, 
    -0.03164807f, 0.11461174f, 0.07128587f, 0.01244481f, 0.08423668f, -0.00201718f, -0.13972975f, -0.03232884f, 
    0.33747241f, -0.07587618f, 0.13564740f, 0.30899084f, -0.04566008f, 0.05062422f, 0.05850322f, -0.04879710f, 
    0.15064897f, -0.03939226f, -0.01067519f, -0.05760870f, 0.18737718f, -0.20209746f, 0.02395672f, -0.00783436f, 
    -0.12491536f, -0.21299323f, -0.21121533f, -0.14457500f, -0.00057491f, 0.05176400f, -0.06508990f, -0.02856574f, 
    -0.21326649f, 0.04155891f, 0.25849903f, 0.12175267f, 0.10958919f, -0.12587337f, 0.16486442f, -0.06640469f, 
    -0.08349808f, 0.02563324f, -0.12690806f, -0.07458055f, -0.09506900f, -0.23232615f, 0.12987901f, -0.07081076f, 
    -0.05200376f, 0.12341186f, 0.28528252f, -0.00502631f, -0.11733289f, 0.07590160f, -0.06329929f, 0.26565865f, 
    -0.00404315f, 0.10768200f, 0.02592165f, -0.07625332f, 0.06276075f, 0.22371413f, -0.04692103f, -0.05276508f, 
    -0.07471073f, 0.08542816f, 0.01520477f, -0.03265985f, 0.04398225f, -0.18619014f, 0.17091930f, 0.06583890f, 
    -0.02008102f, 0.13593428f, 0.06369609f, 0.11119295f, 0.01553112f, 0.15723203f, 0.06590780f, 0.00269243f, 
    0.00151692f, 0.10975823f, 0.13829710f, -0.09225921f, -0.27252573f, -0.07353324f, -0.19381711f, -0.02890363f, 
    -0.15528791f, 0.05350353f, -0.03749603f, -0.21212138f, -0.36828306f, 0.47481483f, -0.36180514f, -0.01370245f, 
    0.03152563f, -0.00376226f, 0.04384814f, -0.01597507f, 0.03427443f, -0.03358304f, 0.02059979f, -0.13988538f, 
    0.15211250f, 0.34747207f, 0.09026860f, -0.26264468f, -0.12348058f, 0.01511006f, -0.23762840f, -0.20530277f, 
    -0.14027765f, -0.15647468f, 0.12099162f, 0.02229001f, -0.13813773f, 0.26562223f, 0.08631968f, 0.25605202f, 
    -0.20327477f, 0.11023603f, 0.09460623f, 0.13889013f, 0.05807847f, 0.06517306f, -0.03131472f, -0.24306005f, 
    -0.51438868f, -0.12379491f, 0.18187337f, -0.17900515f, 0.19446351f, 0.01318434f, 0.03817406f, -0.04707323f, 
    0.05213783f, 0.00606117f, -0.05946976f, 0.09109938f, 0.01953222f, -0.33765021f, -0.26856050f, -0.01423875f, 
    0.10241847f, -0.11952202f, 0.12159158f, -0.02953924f, 0.09828634f, -0.03441827f, -0.08115686f, 0.08421402f, 
    0.06834029f, 0.01612674f, 0.10550857f, -0.07791785f, 0.24277203f, -0.24550118f, -0.13285969f, 0.07768880f, 
    -0.09192268f, 0.04895978f, 0.00548819f, 0.20494296f, -0.18593010f, 0.02074976f, 0.16351876f, 0.23154493f, 
    -0.17408305f, -0.00098986f, -0.09828954f, 0.19073585f, 0.18077303f, 0.02710908f, -0.03866151f, 0.03208707f, 
    -0.30713701f, 0.05067571f, -0.42095602f, 0.07290617f, -0.08397420f, 0.01571321f, 0.03322820f, -0.23660816f, 
    -0.00565277f, 0.23658836f, 0.02978306f, 0.22115165f, -0.30691487f, -0.07002537f, -0.17964774f, -0.16588682f, 
    0.30768892f, -0.01329500f, -0.00864827f, 0.12594551f, -0.02085142f, 0.05306637f, 0.14618467f, 0.06739358f, 
    -0.17186296f, 0.01992584f, 0.05381532f, -0.12575950f, -0.06560059f, 0.01182661f, -0.22279614f, 0.04030537f, 
    -0.01353715f, 0.05730460f, -0.10037528f, 0.00754846f, -0.08685486f, -0.04501937f, -0.26741695f, 0.16787271f, 
    -0.00237050f, 0.06402740f, 0.07359848f, 0.00949237f, 0.02276522f, 0.03949708f, -0.01712520f, -0.03769677f, 
    0.22958948f, 0.41579938f, -0.81479597f, -0.11613285f, -0.05071486f, -0.06053519f, -0.02476124f, -0.14640932f, 
    -0.11458094f, -0.10945016f, 0.01100094f, 0.04917242f, 0.03672025f, 0.05871313f, 0.23409572f, 0.14221710f, 
    -0.25531325f, 0.08787490f, -0.09403567f, 0.07770567f, 0.07155710f, -0.06185459f, 0.03334093f, 0.04901799f, 
    0.13476808f, 0.09775570f, 0.09823912f, 0.08615597f, 0.09451132f, -0.17575221f, -0.02207991f, 0.03464288f, 
    0.02171818f, 0.05519698f, 0.15764202f, 0.10308319f, -0.03793455f, -0.01996232f, 0.05388256f, 0.09603184f, 
    0.05532179f, -0.02970032f, 0.14070919f, -0.00914596f, 0.02047603f, 0.06392694f, 0.03095578f, 0.15785788f, 
    0.02331751f, 0.06113187f, -0.06750506f, -0.17861269f, -0.06810416f, -0.15519764f, 0.03942700f, -0.06938820f, 
    0.00557382f, -0.04726024f, 0.05509048f, 0.16165586f, 0.25203705f, -0.42251390f, 0.09590515f, 0.20128515f, 
    0.02907426f, 0.02137870f, 0.07575573f, 0.16772278f, -0.03894266f, 0.05117917f, -0.00377961f, 0.05734576f, 
    0.15695049f, -0.11336137f, -0.15397112f, 0.01026234f, -0.02973254f, 0.02685211f, 0.05043103f, 0.01435680f, 
    -0.02546869f, 0.10777833f, -0.06267171f, 0.02443576f, -0.11259159f, -0.24661852f, 0.14713992f, -0.00470573f, 
    -0.02415966f, -0.01601860f, -0.15258552f, -0.13203420f, -0.01316035f, 0.03776588f, 0.05356935f, 0.08732501f, 
    0.00853369f, 0.05251582f, -0.12616728f, -0.08342838f, 0.02523166f, -0.10494696f, 0.35117641f, 0.12677297f, 
    0.00992090f, -0.03556181f, -0.10639008f, -0.18740278f, 0.13167566f, -0.10363494f, 0.27086511f, 0.13590813f, 
    0.07649901f, 0.08022234f, 0.05922626f, -0.12323569f, 0.00462703f, -0.04003209f, 0.07658136f, -0.05545245f, 
    0.16425443f, 0.04605407f, -0.19369058f, 0.14955595f, -0.06786577f, 0.21700767f, 0.17653355f, -0.08491299f, 
    0.02476190f, 0.16425490f, -0.03826875f, -0.13204752f, -0.02672874f, -0.07857894f, 0.27536517f, 0.26985875f, 
    -0.06299265f, 0.00923870f, 0.04264692f, -0.02780034f, 0.06441584f, 0.03224734f, 0.00025190f, -0.01075331f, 
    -0.09180734f, 0.01913590f, 0.17552829f, 0.01383125f, -0.21500118f, -0.12333476f, -0.13000676f, 0.03272734f, 
    -0.00283386f, 0.03848461f, 0.01759882f, 0.05702002f, -0.16260092f, -0.10722999f, -0.27635598f, 0.22065611f, 
    -0.10990481f, 0.08826498f, 0.10702177f, -0.03537253f, 0.07585645f, 0.14357705f, -0.08674820f, 0.07659355f, 
    0.06231380f, -0.07664359f, -0.03491719f, -0.06106434f, 0.07113543f, 0.05294770f, 0.01564969f, -0.01273333f, 
    -0.06909780f, -0.01907461f, -0.01134788f, -0.02530752f, -0.03995398f, 0.02717253f, -0.08217417f, 0.01616447f, 
    -0.00840011f, 0.02163549f, -0.05424118f, -0.08805607f, 0.05401823f, 0.03641410f, -0.04826992f, -0.03784818f, 
    0.01237830f, -0.00814610f, -0.02648743f, -0.08666709f, 0.04070479f, -0.05699599f, -0.05210594f, -0.07500429f, 
    -0.01391729f, 0.05466275f, 0.02517393f, -0.06050738f, -0.07104926f, -0.02746279f, -0.08889909f, -0.06049709f, 
    0.02197384f, -0.02480315f, -0.07242946f, -0.08111536f, 0.06937942f, 0.00566766f, 0.00768087f, -0.05246991f, 
    0.02375757f, 0.02128546f, 0.04121805f, -0.01836346f, -0.00569982f, -0.07630028f, 0.01079014f, 0.01097618f, 
    0.05966808f, -0.03861447f, -0.05244128f, -0.03275526f, -0.03379941f, -0.07361049f, -0.03562382f, 0.00384439f, 
    -0.00487211f, 0.01610181f, -0.00917993f, -0.05766168f, -0.03682426f, 0.00075437f, -0.06695811f, 0.04725591f, 
    -0.01151334f, 0.02255148f, -0.02545027f, -0.01033932f, 0.02174621f, -0.00290638f, 0.00770128f, -0.07769877f, 
    -0.03813287f, 0.04618291f, -0.03201043f, 0.00181590f, 0.03371196f, 0.05770675f, 0.01032764f, -0.02755990f, 
    0.04488342f, 0.05229167f, -0.00825723f, 0.00307061f, -0.03741439f, 0.04760064f, 0.02270092f, -0.08226144f, 
    -0.06741811f, -0.04977952f, -0.08273350f, -0.04177782f, -0.04772298f, -0.08231776f, -0.03500705f, -0.04780240f, 
    -0.07188965f, 0.03600123f, 0.03348377f, -0.07846846f, 0.00178708f, -0.04593163f, -0.04656212f, -0.01811529f, 
    0.01439141f, -0.05382152f, 0.04670865f, -0.06339911f, 0.08690029f, -0.06955212f, 0.02832843f, 0.04783890f, 
    0.00746253f, -0.00831249f, 0.00996527f, -0.01714116f, -0.01234423f, -0.06619721f, -0.01363508f, -0.01356153f, 
    0.00436544f, 0.02369462f, 0.05683162f, -0.05827068f, 0.02031023f, 0.00589329f, -0.06653515f, -0.08437265f, 
    0.00361921f, -0.08559870f, -0.02312148f, 0.02110238f, -0.06767638f, -0.05112231f, 0.05348507f, 0.01678387f, 
    -0.09473947f, 0.00735004f, -0.02576319f, 0.01191498f, -0.06711573f, -0.02742061f, -0.04012806f, -0.00701086f, 
    -0.04955854f, 0.04107863f, -0.03702782f, 0.03594294f, 0.01117795f, 0.01434609f, 0.05002399f, -0.05907332f, 
    -0.00354566f, -0.07212382f, 0.05370890f, -0.03201315f, 0.04776245f, 0.01974886f, -0.02972369f, -0.04576037f, 
    0.03455674f, -0.09192010f, 0.04053138f, -0.00476914f, -0.03190085f, -0.06601489f, -0.06934329f, -0.04566988f, 
    0.05656859f, 0.01960508f, -0.06115771f, 0.02233094f, -0.01752387f, -0.04301524f, -0.03371182f, -0.02969091f, 
    -0.02222953f, -0.00237227f, -0.00076605f, -0.07583227f, 0.03363446f, 0.02052400f, 0.02303835f, -0.07040119f, 
    -0.19674130f, 0.29263955f, -0.03859700f, -0.04679835f, 0.09494583f, 0.05554619f, 0.11863823f, 0.03405810f, 
    0.00400265f, -0.10103673f, -0.07897110f, 0.00924202f, -0.14726585f, -0.10055739f, 0.06065703f, 0.11194152f, 
    0.05876191f, -0.06326748f, -0.09149118f, -0.09244954f, 0.03396386f, -0.03082350f, 0.03605139f, 0.11442325f, 
    -0.06021832f, 0.10337674f, -0.02173443f, 0.16275044f, 0.01148100f, 0.05653337f, -0.06110059f, -0.06344382f, 
    -0.00678117f, 0.10159992f, -0.03602728f, 0.05219633f, 0.07387764f, -0.11369240f, 0.19229567f, 0.14273638f, 
    0.04413528f, 0.00123162f, 0.16210665f, 0.01254945f, 0.16472596f, 0.04445149f, 0.16408852f, 0.06923956f, 
    -0.24892206f, 0.04850170f, -0.14338316f, 0.07677650f, -0.08588327f, 0.06414321f, -0.06871527f, -0.12203962f, 
    -0.08834801f, 0.00028538f, 0.19896175f, 0.12289179f, 0.17134571f, -0.18742344f, 0.07382660f, -0.06582730f, 
    -0.03245799f, 0.06460917f, 0.15726134f, 0.24564412f, 0.07545374f, 0.12360788f, 0.04081946f, 0.13305551f, 
    -0.20947382f, -0.12824683f, -0.07508555f, -0.07225496f, -0.10693479f, -0.03526474f, 0.01779375f, -0.00203937f, 
    -0.10567009f, 0.01218120f, 0.09585822f, 0.02853522f, 0.21908082f, 0.30249456f, -0.04697811f, 0.05418363f, 
    0.14994988f, -0.01826481f, -0.03381269f, -0.12928103f, 0.07397194f, 0.07738422f, 0.04440674f, 0.04529604f, 
    -0.05354539f, 0.14497599f, -0.01317402f, -0.01838477f, -0.12600598f, -0.00788411f, -0.13003165f, 0.03873229f, 
    -0.08985820f, 0.03859776f, -0.14503329f, -0.26854718f, -0.03331507f, 0.18247175f, -0.02725348f, 0.12098381f, 
    0.05952196f, 0.18688723f, 0.11225632f, 0.09074733f, 0.03326176f, 0.16277653f, 0.08680840f, 0.10237446f, 
    -0.13687542f, -0.16958646f, 0.06037727f, 0.11337028f, -0.02537805f, -0.10579547f, 0.09110890f, 0.01713465f, 
    -0.09590859f, -0.20237704f, -0.20384449f, -0.10287592f, -0.09191168f, 0.26811001f, 0.08654014f, 0.00399076f, 
    -0.08325621f, -0.07200664f, -0.05661532f, -0.13318127f, -0.07888024f, 0.04433071f, -0.02260700f, 0.10483212f, 
    -0.17064647f, 0.09538490f, 0.20367354f, -0.10096466f, -0.13607502f, -0.23599061f, 0.05449698f, -0.13207489f, 
    -0.09482294f, 0.11860881f, -0.00343001f, 0.08524115f, -0.02275169f, -0.04988366f, -0.24573974f, 0.03483345f, 
    0.07458387f, 0.05670903f, -0.01102765f, -0.00935311f, 0.06847886f, 0.13228358f, -0.02888290f, 0.01411098f, 
    -0.31474257f, -0.19066003f, 0.07233313f, -0.12689187f, -0.01914173f, 0.02362727f, 0.14036407f, -0.10441685f, 
    0.08730287f, -0.14248523f, 0.02304857f, 0.04251446f, 0.11914921f, 0.02965987f, 0.33100739f, -0.09176423f, 
    0.09904157f, -0.03884039f, -0.02160319f, 0.20378378f, 0.05114086f, 0.03857417f, 0.03721880f, -0.07430253f, 
    -0.07224824f, -0.00191068f, 0.00727528f, 0.00780707f, -0.04075236f, 0.00024084f, -0.04896600f, -0.03171269f, 
    -0.05748466f, -0.06595506f, 0.01235225f, -0.01335977f, 0.00839755f, -0.06059616f, -0.00818511f, 0.03148204f, 
    0.00603243f, 0.06311266f, -0.00492172f, -0.00242911f, -0.07234453f, 0.04310970f, -0.07438564f, -0.03660559f, 
    -0.05371942f, -0.00669024f, -0.00026688f, 0.05831789f, 0.00460188f, -0.01690755f, 0.00887995f, -0.06064082f, 
    -0.03151475f, -0.02792483f, -0.07174990f, -0.03437735f, -0.06258253f, 0.00701329f, -0.07156535f, -0.03666051f, 
    0.05066185f, 0.06281412f, -0.03699479f, -0.04630246f, -0.02753713f, 0.00258751f, -0.02594250f, -0.01224776f, 
    -0.01238509f, 0.04236238f, 0.03102187f, 0.05676245f, 0.04955776f, -0.06368679f, -0.02607585f, -0.07186279f, 
    0.01644398f, -0.00964728f, -0.05898215f, -0.02306448f, -0.04210058f, 0.02426642f, 0.03846256f, -0.00972536f, 
    0.02497283f, -0.07914970f, 0.02935399f, -0.00203078f, -0.06725904f, 0.00246832f, 0.03380723f, -0.04199213f, 
    -0.06194699f, -0.07363065f, 0.03505288f, 0.05464323f, -0.01522041f, 0.04550224f, 0.02453901f, -0.07478256f, 
    -0.00871888f, 0.05525332f, -0.04624650f, 0.04170277f, -0.05014812f, 0.02975071f, 0.02428780f, 0.02883068f, 
    -0.02794871f, -0.03790154f, 0.02767584f, 0.03510447f, -0.03639377f, 0.05305178f, -0.02636865f, -0.01549844f, 
    -0.00780530f, 0.01975021f, 0.05658121f, -0.02408965f, -0.05406652f, 0.00157930f, 0.03919843f, -0.00671811f, 
    -0.05494903f, -0.01716041f, -0.01166942f, -0.06456885f, -0.03505328f, -0.06183641f, -0.06306382f, 0.02685424f, 
    0.03965432f, 0.02770969f, 0.02318744f, 0.01078494f, 0.03492887f, 0.03632553f, -0.06383160f, -0.03890464f, 
    -0.00379324f, 0.05399400f, 0.00147108f, -0.00191040f, 0.05210074f, -0.00264087f, -0.07709000f, 0.04323889f, 
    -0.07791097f, -0.00486568f, -0.00215907f, 0.00108923f, 0.04075146f, -0.00626746f, -0.04806034f, 0.04542346f, 
    0.00965651f, 0.02048871f, -0.07688220f, 0.03250873f, -0.03700479f, 0.04124332f, 0.01827761f, -0.06880744f, 
    -0.01747446f, 0.04819799f, -0.01131077f, 0.03760316f, -0.02070974f, 0.00736749f, -0.00451895f, 0.03040850f, 
    0.01005138f, -0.03457369f, 0.04236778f, -0.00161733f, 0.00531527f, 0.05453390f, -0.00569856f, -0.00114827f, 
    -0.02760325f, 0.03595490f, 0.02231534f, -0.06018739f, -0.03451345f, -0.06978581f, -0.01621501f, 0.03987443f, 
    -0.03972302f, -0.01138575f, -0.06574113f, -0.04626437f, -0.05129445f, 0.02914850f, 0.03521010f, -0.05046257f, 
    0.03787349f, 0.02235422f, -0.02059922f, 0.05447705f, -0.05735261f, -0.04937917f, -0.04400082f, -0.01561424f, 
    0.01277647f, 0.06172728f, -0.03022200f, 0.04036349f, -0.04545761f, 0.06401418f, -0.05836952f, -0.05868604f, 
    0.26310059f, -0.31307760f, 0.15413901f, 0.06882902f, 0.01718807f, -0.08066409f, -0.07531101f, -0.01162777f, 
    0.01328299f, -0.08963827f, -0.07796577f, 0.09750593f, -0.31922501f, -0.01733003f, -0.12546991f, 0.13859247f, 
    0.00494412f, -0.00717199f, -0.04145439f, 0.11348412f, 0.06161213f, 0.02335881f, 0.04501669f, 0.07298887f, 
    -0.16615750f, 0.02552993f, -0.19430424f, 0.26790279f, -0.02421003f, 0.08103726f, -0.02311056f, -0.13183795f, 
    0.11495300f, -0.16852753f, 0.02085109f, 0.01578459f, 0.16033596f, 0.14800656f, -0.07620823f, 0.07808033f, 
    -0.14069846f, 0.12574401f, 0.06910372f, -0.03962630f, -0.00913377f, -0.05716924f, -0.03924263f, 0.10769890f, 
    0.01472521f, -0.12221328f, -0.04895136f, -0.02540106f, -0.22224367f, 0.12212564f, -0.04158413f, -0.02204003f, 
    0.04692129f, 0.01450590f, -0.04813641f, 0.15703164f, -0.07476922f, 0.44963998f, -0.03250016f, 0.09497934f, 
    0.09612988f, 0.15006077f, 0.05699366f, 0.15820904f, -0.01221228f, 0.05311856f, -0.00818125f, 0.02926216f, 
    -0.16094212f, -0.12511462f, -0.17427562f, 0.11137493f, -0.01223707f, -0.01791755f, 0.01669154f, -0.07274747f, 
    0.13885666f, -0.15077710f, 0.00367348f, 0.06170178f, 0.11303629f, -0.15893671f, 0.49774975f, 0.11101876f, 
    0.08237582f, 0.01684229f, -0.01476003f, 0.02640983f, 0.08803631f, -0.11564078f, -0.10555387f, 0.01364817f, 
    -0.14974634f, -0.04918792f, -0.05416773f, -0.08075705f, 0.06488768f, 0.09355874f, -0.09458273f, 0.08599203f, 
    -0.08692786f, -0.08901963f, 0.12371014f, -0.08282687f, 0.06400404f, 0.00718612f, 0.20655942f, 0.01802428f, 
    0.02635220f, 0.07801617f, 0.14549008f, 0.07055415f, 0.06524388f, 0.02521848f, -0.05573147f, -0.04013035f, 
    -0.11651162f, -0.05063485f, 0.02916178f, 0.03746981f, 0.04193777f, -0.13891494f, 0.05467836f, 0.02509550f, 
    -0.04592986f, -0.01710826f, 0.14829803f, 0.12296323f, -0.04045114f, 0.33307347f, 0.07346763f, -0.01518421f, 
    0.05913236f, -0.01853292f, -0.03844601f, 0.13689122f, 0.06080120f, -0.07918899f, -0.05745849f, -0.07837326f, 
    -0.21903250f, 0.07962420f, -0.14667359f, -0.01638964f, -0.00543414f, -0.09487975f, 0.03573701f, -0.02771579f, 
    0.01552730f, 0.09158488f, -0.10444926f, -0.03645340f, 0.28469366f, 0.29203826f, 0.24722002f, -0.05962529f, 
    0.12445786f, -0.01300668f, 0.13231425f, 0.14965144f, 0.02169163f, -0.09306848f, 0.04163108f, -0.04384352f, 
    -0.27724338f, -0.02760231f, 0.01550490f, 0.15822975f, -0.07088520f, -0.04374780f, -0.14369814f, 0.09602827f, 
    0.15492080f, -0.06805246f, -0.10065895f, 0.03298025f, -0.09424301f, 0.06497646f, 0.03626453f, 0.07383613f, 
    0.05067421f, 0.05817943f, -0.14235753f, 0.20847026f, 0.06383937f, 0.02528053f, 0.01508174f, 0.05180041f, 
    0.12942319f, -0.19372910f, 0.41174108f, 0.10017028f, -0.11201584f, -0.02972911f, 0.01363947f, 0.03603415f, 
    0.11744074f, 0.11081330f, 0.04342654f, 0.05871430f, -0.00885016f, -0.02035772f, -0.16225597f, 0.06273109f, 
    0.07649537f, 0.12372118f, 0.06089391f, 0.05618602f, 0.01012452f, -0.00048980f, -0.07856965f, 0.08361680f, 
    0.07228131f, 0.41456860f, -0.29090610f, 0.02963831f, 0.13995768f, 0.02072479f, 0.05805588f, -0.03518919f, 
    -0.01322263f, -0.06535238f, 0.00383840f, 0.01972502f, -0.06561211f, 0.23005652f, -0.09329998f, 0.03512203f, 
    -0.07768487f, -0.10164745f, 0.02884429f, 0.06712128f, 0.12784106f, -0.01969806f, -0.07715254f, -0.02434253f, 
    0.22238779f, -0.00496687f, 0.04345677f, -0.12649077f, 0.11023335f, -0.15038748f, -0.00507807f, -0.03346473f, 
    0.14164504f, -0.01156756f, 0.09152643f, -0.02213727f, -0.18975891f, 0.17663161f, -0.20634289f, -0.01218032f, 
    0.10595859f, -0.09564979f, 0.11439350f, 0.00866319f, 0.06323071f, -0.06969143f, -0.09990359f, -0.00270951f, 
    0.05569930f, 0.07981991f, 0.06305031f, 0.29793251f, 0.06047602f, -0.11515047f, 0.09629001f, -0.11282067f, 
    0.09023190f, -0.07011394f, -0.04346071f, 0.12016674f, -0.07657588f, -0.17009299f, 0.06878828f, 0.03019717f, 
    0.05538172f, 0.18090105f, 0.05141153f, -0.00977755f, -0.02788392f, -0.04378404f, -0.04520838f, 0.04434945f, 
    0.08845422f, -0.06640472f, -0.07796767f, 0.09329060f, 0.00054343f, 0.04887829f, 0.10650086f, 0.01418888f, 
    0.05120871f, -0.03680248f, 0.03082904f, -0.05738735f, -0.28600618f, -0.17088440f, -0.06748046f, -0.22218421f, 
    0.03063753f, 0.03185539f, 0.14716640f, -0.09705316f, -0.01728519f, -0.00110372f, 0.03388873f, 0.12041376f, 
    0.10905533f, 0.12566748f, -0.17843427f, -0.07753517f, -0.05117616f, 0.00054494f, 0.02240262f, 0.03330425f, 
    0.09643498f, 0.07483939f, -0.03798154f, -0.01643365f, 0.03108001f, -0.05109039f, 0.05644893f, -0.18884061f, 
    0.25889212f, 0.10497694f, 0.05673145f, -0.06053207f, 0.13883108f, -0.00590912f, 0.05283060f, 0.01152095f, 
    0.14802346f, -0.05710698f, -0.21263601f, 0.13098004f, 0.03936192f, 0.10416783f, 0.05130472f, 0.06333256f, 
    0.03952401f, 0.00692231f, 0.04679813f, -0.14052224f, -0.12840252f, 0.10483132f, 0.15543079f, -0.14091706f, 
    0.10160722f, 0.08426718f, 0.11561771f, -0.05264774f, 0.00503056f, -0.07019091f, -0.04896690f, -0.08524194f, 
    -0.06559540f, 0.13817827f, 0.29963157f, 0.55347371f, -0.17803191f, -0.19273432f, -0.04622609f, 0.01522186f, 
    -0.03535948f, -0.05771643f, -0.02227401f, 0.03439263f, -0.40999585f, -0.18994196f, 0.01928005f, 0.27541304f, 
    -0.16793796f, 0.21494487f, 0.07945239f, 0.12948200f, -0.04848685f, 0.04609584f, -0.09377188f, 0.06034695f, 
    0.12408492f, 0.16007586f, -0.04383519f, -0.13468060f, 0.03201185f, -0.05105076f, 0.15604560f, 0.06349768f, 
    0.08955956f, 0.03626952f, 0.03843150f, 0.07097274f, 0.26172790f, 0.08417517f, 0.20869462f, -0.08744958f, 
    -0.11531635f, -0.06272826f, -0.05539523f, -0.05044899f, -0.07674342f, -0.01053022f, 0.12378721f, 0.02318670f, 
    0.07618114f, -0.03631544f, 0.65710783f, -0.04195035f, 0.04596142f, -0.10781483f, -0.07991406f, 0.16939361f, 
    -0.02552309f, -0.02892714f, 0.09819936f, 0.05175739f, 0.04530188f, -0.01353854f, -0.12351701f, -0.00953887f, 
    0.03673928f, 0.04402991f, 0.10910592f, -0.07387870f, -0.01694991f, 0.16558105f, -0.02853085f, -0.01929808f, 
    -0.07004864f, 0.00463891f, -0.02399802f, 0.04624130f, 0.02894767f, 0.13745387f, 0.03134616f, 0.08621803f, 
    0.03807279f, -0.00565636f, -0.13656774f, -0.00157481f, -0.12726833f, -0.01847122f, -0.06727724f, -0.11681079f, 
    0.15854250f, 0.02937781f, -0.12262229f, -0.00169285f, -0.12547557f, 0.07077426f, 0.16553980f, -0.04147338f, 
    0.21662153f, 0.19989964f, 0.10343173f, 0.08366701f, -0.13599259f, 0.05404580f, -0.00751711f, 0.00879027f, 
    0.03350292f, 0.06745642f, -0.01421334f, 0.04659521f, 0.10395411f, 0.40609878f, -0.06812065f, 0.00760017f, 
    -0.06982680f, -0.04542991f, -0.00210295f, -0.08075583f, 0.06204354f, -0.00249401f, 0.04715839f, 0.07271175f, 
    -0.10818979f, 0.09988601f, -0.02862387f, 0.03385872f, -0.10429730f, -0.01011079f, -0.11365823f, -0.03891546f, 
    0.06559619f, -0.04813250f, 0.07106280f, -0.11808440f, 0.08825050f, -0.00618657f, -0.13129030f, -0.02202057f, 
    0.04876406f, 0.12772277f, 0.00028228f, 0.02160064f, -0.06507818f, -0.03901500f, -0.04970133f, -0.06716358f, 
    0.00880302f, -0.19770095f, 0.00636546f, -0.04541915f, 0.18622020f, 0.13316171f, 0.00004749f, 0.26349962f, 
    -0.10613254f, 0.09209541f, -0.01264771f, -0.01666478f, -0.04277591f, 0.06361943f, -0.04694561f, -0.08962352f, 
    -0.11534002f, -0.10890625f, -0.05662205f, -0.01577125f, -0.11102725f, 0.11698579f, -0.05972841f, -0.00419778f, 
    -0.01050324f, -0.08881061f, 0.23833151f, -0.05045814f, 0.04416157f, -0.11954761f, -0.04936089f, 0.02934219f, 
    -0.07844112f, -0.12400954f, 0.01452462f, -0.00618607f, 0.07908446f, 0.07778381f, -0.09032443f, -0.12424740f, 
    0.08696702f, 0.07025148f, 0.06607305f, -0.14051795f, -0.10183862f, -0.01946726f, -0.04678720f, -0.00732978f, 
    0.07725331f, -0.18876506f, -0.22242279f, -0.07963036f, 0.16306686f, 0.09750225f, 0.13882184f, 0.07360174f, 
    0.04354462f, 0.07418983f, 0.10036393f, 0.19922157f, 0.24869941f, -0.07564839f, 0.18997099f, -0.08229282f, 
    0.07441241f, -0.13005944f, -0.00805624f, 0.12356401f, 0.05213087f, -0.04022460f, 0.02414225f, 0.01288573f, 
    -0.08061739f, 0.29817665f, -0.14894548f, -0.01788610f, 0.09870637f, 0.08988361f, 0.03302144f, -0.06870242f, 
    0.04484252f, 0.11571163f, 0.02813653f, 0.21187375f, 0.19089453f, 0.23287691f, 0.24730811f, -0.20517009f, 
    0.05808127f, -0.09715533f, -0.07626810f, 0.15070753f, -0.31687397f, -0.24582401f, -0.19580473f, -0.34716055f, 
    0.07379190f, -0.27466744f, 0.35637394f, -0.08336534f, -0.26377624f, 0.10813843f, -0.18034068f, 0.19619295f, 
    0.03290034f, -0.07623513f, -0.01816881f, -0.19745059f, 0.02081254f, -0.02641048f, -0.10149360f, -0.01071944f, 
    0.11335719f, -0.03184028f, -0.14417876f, 0.12611324f, -0.12929037f, -0.12183560f, -0.06453021f, -0.44870463f, 
    -0.25437495f, 0.10482170f, 0.00806674f, 0.02645709f, -0.13593763f, -0.08334243f, -0.08617052f, -0.14908358f, 
    -0.26648447f, -0.15649971f, -0.34697229f, -0.21945041f, 0.16126038f, 0.07588075f, 0.25727558f, 0.22752769f, 
    0.00922768f, 0.22250016f, -0.04012977f, 0.05721796f, 0.08782278f, -0.04003339f, 0.02569681f, 0.06293151f, 
    0.08177258f, -0.04071213f, -0.08468339f, -0.05429812f, 0.01246896f, -0.02935576f, -0.16676389f, 0.27937329f, 
    -0.08692034f, -0.11305354f, 0.06860990f, -0.11898416f, 0.04994900f, -0.07973596f, 0.01151102f, 0.10190482f, 
    -0.09386712f, -0.08413907f, 0.03980054f, 0.22890884f, -0.19529809f, 0.02958888f, 0.17393999f, -0.15900919f, 
    0.14053825f, 0.05694231f, 0.05257912f, 0.15156122f, 0.00719154f, 0.03894239f, 0.06405152f, 0.12420335f, 
    0.07864530f, 0.14616446f, 0.12819445f, 0.22431059f, 0.20714293f, -0.04754659f, -0.09402611f, -0.06200686f, 
    0.14329384f, 0.04315775f, -0.02881482f, 0.20508122f, -0.06053272f, -0.03059914f, -0.13448556f, -0.14676617f, 
    0.07883791f, 0.09072059f, 0.16882518f, 0.20622358f, -0.23141481f, 0.18016696f, -0.10480954f, -0.17963333f, 
    0.04371603f, -0.09470440f, 0.18615060f, 0.05587397f, 0.22649911f, 0.12856223f, 0.17699249f, 0.22150885f, 
    -0.02525564f, 0.17852563f, 0.19648965f, 0.20361587f, -0.22754671f, 0.19153073f, -0.09469707f, -0.06428407f, 
    -0.02504848f, 0.05485561f, -0.02211520f, -0.22425891f, -0.00561573f, 0.06258304f, -0.03997521f, -0.05834466f, 
    -0.12295338f, -0.17974398f, -0.11741261f, 0.00131169f, 0.07606801f, -0.02850850f, -0.02577611f, 0.26748019f, 
    0.14695475f, -0.07331775f, 0.17700885f, 0.30345184f, -0.00269990f, 0.07450546f, 0.15228485f, 0.00592184f, 
    0.32450393f, -0.01351426f, -0.16368824f, -0.59846282f, 0.27270967f, -0.00365384f, -0.06516371f, -0.02688536f, 
    0.18385805f, 0.08263493f, -0.12054090f, -0.09238838f, 0.27256405f, 0.25227588f, -0.14212191f, -0.15335919f, 
    -0.07730762f, 0.00897441f, -0.06376600f, -0.18227622f, 0.03382733f, 0.00071844f, -0.15813676f, 0.05910559f, 
    -0.04817636f, -0.02178234f, 0.05019395f, -0.01354139f, 0.00409838f, -0.06028872f, -0.02882681f, -0.07940256f, 
    -0.01620368f, -0.08316775f, 0.03959696f, -0.01587774f, 0.05359505f, -0.06362961f, 0.02501487f, -0.01903872f, 
    -0.05150813f, -0.01972568f, 0.06081101f, 0.02966255f, 0.02828188f, -0.08539706f, -0.01270513f, 0.00540514f, 
    0.02464966f, -0.06681886f, -0.04173157f, 0.01587411f, -0.06422442f, -0.02026427f, -0.04256454f, 0.01697147f, 
    -0.04589482f, 0.04103507f, 0.04946040f, 0.03485895f, -0.06165217f, 0.04406219f, 0.04289251f, 0.00446250f, 
    -0.00931085f, -0.03314110f, 0.05092687f, -0.05565694f, 0.02856713f, -0.03355851f, 0.04513778f, -0.05702863f, 
    0.04455395f, -0.02221970f, 0.01437112f, 0.04592220f, -0.03731680f, -0.07820679f, -0.05321962f, -0.05366530f, 
    -0.03339114f, -0.05141465f, -0.05327088f, -0.03545815f, -0.04113404f, 0.01055745f, -0.03024771f, 0.05009161f, 
    -0.04594446f, -0.07254580f, -0.07119697f, -0.03054385f, 0.05657544f, -0.03788886f, 0.06267835f, -0.05089812f, 
    0.00138596f, 0.03535490f, -0.05941981f, 0.04308354f, -0.02916266f, -0.00441697f, -0.06487930f, 0.01857542f, 
    -0.08269308f, -0.04374349f, 0.04385857f, 0.01112269f, -0.00466976f, 0.03634221f, -0.05938875f, -0.04370296f, 
    0.01073115f, 0.03253677f, 0.04340125f, -0.00619280f, -0.03498195f, -0.08724934f, 0.04501035f, -0.04972970f, 
    0.01186034f, -0.04870697f, -0.01361381f, -0.06395639f, -0.07670268f, -0.02643873f, -0.03610936f, -0.00805602f, 
    -0.07555206f, 0.00661350f, -0.03518455f, 0.01509829f, -0.07025732f, -0.01301790f, -0.07505563f, -0.00938524f, 
    0.03783855f, 0.00052547f, -0.06571859f, 0.05465571f, -0.05985470f, -0.07752098f, -0.04079304f, 0.01410389f, 
    -0.07892200f, -0.01855576f, 0.02143073f, 0.00033549f, -0.05427344f, 0.00212257f, -0.06265976f, -0.01182404f, 
    0.04998090f, 0.04377258f, -0.05808517f, -0.03456667f, 0.00940184f, -0.04836023f, -0.04221228f, -0.03753853f, 
    -0.00120181f, -0.05598645f, -0.07518794f, -0.05261308f, 0.02235958f, -0.08288134f, 0.04094432f, 0.03571753f, 
    -0.07915897f, 0.00366277f, -0.03688917f, 0.04516923f, -0.05498350f, 0.02959327f, -0.07766035f, 0.05484266f, 
    -0.03225638f, 0.00344108f, -0.04358282f, 0.02571024f, 0.04917872f, -0.04434810f, 0.01679754f, -0.05700655f, 
    0.05718089f, 0.01684910f, -0.03205627f, 0.03414176f, 0.00105093f, 0.00292558f, -0.01684704f, -0.02900013f, 
    0.01665505f, -0.00609027f, -0.01193264f, -0.01155001f, -0.04468100f, 0.02666969f, -0.06317345f, -0.02344507f, 
    0.01574151f, -0.05644802f, 0.03432029f, 0.02876537f, 0.00048664f, -0.06755992f, -0.01695456f, 0.02519759f, 
    0.01948929f, 0.05054505f, -0.07039190f, 0.02499547f, 0.03366040f, -0.03651281f, -0.04558280f, 0.03345161f, 
    0.10541815f, -0.13335657f, -0.10950930f, -0.08426387f, 0.04602502f, 0.07990976f, 0.11696107f, 0.14185557f, 
    0.10285491f, 0.05232984f, -0.05075552f, -0.07224680f, -0.14099498f, 0.09025737f, 0.04742457f, -0.03468850f, 
    -0.01223202f, -0.16087228f, -0.09840727f, -0.08789479f, 0.03872527f, -0.07317987f, 0.11076645f, 0.06107762f, 
    -0.15673105f, 0.15448822f, 0.41848877f, 0.01154789f, 0.10291316f, -0.07804228f, -0.09914722f, -0.00145327f, 
    0.02582577f, 0.03581888f, 0.10914323f, 0.03127177f, 0.04130711f, -0.15446423f, -0.06968211f, 0.08097279f, 
    -0.05189611f, 0.12170878f, 0.02572589f, -0.20321241f, 0.04078678f, 0.01988436f, 0.05967716f, 0.14020362f, 
    -0.15396468f, -0.07816136f, -0.04902377f, 0.01189963f, -0.07108050f, 0.05981678f, 0.02837249f, -0.03510140f, 
    0.16355623f, 0.04437801f, -0.04336571f, -0.01995821f, -0.11415429f, 0.03988481f, 0.01996032f, 0.10093158f, 
    -0.04113452f, -0.07675490f, -0.17022631f, 0.08303625f, -0.04976868f, 0.19772050f, 0.06761605f, 0.13718070f, 
    0.09240608f, 0.20360620f, -0.02230115f, 0.05492939f, -0.13654083f, 0.06387921f, -0.05626871f, -0.03544226f, 
    -0.01062289f, 0.04700311f, -0.07390285f, 0.13778612f, 0.22805320f, 0.19031902f, -0.19092964f, 0.01295887f, 
    0.00340977f, -0.20078751f, -0.03819896f, -0.34561548f, 0.15645325f, -0.08740195f, 0.02917217f, 0.10171184f, 
    0.07646907f, 0.10110084f, -0.06307365f, 0.06525876f, 0.03246823f, 0.05672972f, 0.01896788f, 0.02631790f, 
    -0.03935309f, -0.03852628f, 0.01817322f, 0.01424282f, 0.09338513f, 0.02408783f, -0.03119715f, 0.12155047f, 
    0.22040303f, 0.06075942f, 0.12267032f, -0.14547002f, -0.07106417f, -0.00993547f, -0.00089051f, 0.07912453f, 
    -0.17611901f, -0.14209528f, 0.00709056f, -0.11283270f, 0.23016553f, 0.04854960f, -0.04903486f, 0.03951964f, 
    -0.32219100f, -0.04151250f, -0.09013823f, -0.01738123f, -0.01601081f, 0.06644501f, -0.03538032f, -0.24592070f, 
    -0.07233151f, -0.28358105f, 0.00353255f, -0.15213312f, 0.04710393f, -0.01519962f, -0.01245519f, 0.11353772f, 
    0.02372670f, -0.06978222f, 0.07364321f, -0.13662395f, -0.01553588f, -0.13051233f, -0.16861863f, 0.08542736f, 
    0.01194645f, 0.04681737f, -0.08727122f, 0.12031404f, -0.02952672f, 0.05602422f, -0.08961368f, 0.08912023f, 
    0.02893090f, -0.01310141f, 0.05205930f, -0.00505917f, 0.07734162f, 0.06759000f, 0.03605573f, 0.11946403f, 
    0.08962493f, -0.30355400f, -0.27754405f, -0.15998676f, 0.04662853f, -0.15785776f, 0.08630627f, -0.15466082f, 
    0.06825083f, 0.08344631f, 0.04233077f, 0.18400502f, 0.26592919f, -0.09607144f, -0.03150716f, -0.00300198f, 
    0.13471925f, -0.29069647f, -0.01481199f, -0.05231858f, 0.02417006f, -0.09083924f, 0.05672457f, -0.01606886f, 
    0.01793044f, 0.24975143f, 0.16637927f, -0.05415077f, -0.06998160f, -0.01306679f, 0.08555267f, 0.09380513f, 
    0.06398948f, 0.19883363f, -0.05129425f, 0.05292482f, 0.23589316f, 0.02595014f, 0.13440163f, -0.02014349f, 
    0.03582446f, -0.23451000f, -0.11628608f, -0.09128623f, -0.01228281f, -0.01138029f, -0.03861012f, -0.04059493f, 
    -0.03063266f, -0.06281833f, 0.47397986f, -0.31759530f, -0.07974052f, -0.14591837f, -0.08111818f, 0.06387381f, 
    -0.02654809f, 0.04578738f, 0.01686698f, 0.12527591f, 0.00098569f, -0.01903004f, 0.15658788f, -0.02823699f, 
    0.04165726f, -0.00152047f, 0.10141302f, -0.16710426f, -0.01659271f, 0.12652174f, -0.03507840f, 0.04167616f, 
    0.12104390f, 0.20544766f, 0.02894457f, 0.13086534f, 0.23335013f, 0.05035533f, 0.03809861f, 0.05752896f, 
    -0.07442938f, 0.16380742f, -0.12468277f, -0.12348979f, -0.02537890f, -0.42367473f, 0.17733069f, 0.01317113f, 
    0.06088155f, 0.11723630f, 0.03785665f, -0.08847973f, -0.17738611f, -0.11014856f, 0.01511603f, 0.06267139f, 
    0.15975210f, 0.16534740f, 0.16835847f, 0.00189337f, -0.11235725f, -0.08307169f, -0.07606473f, -0.01249146f, 
    -0.03723291f, 0.14145818f, 0.01929260f, -0.00138599f, -0.24909791f, 0.38977954f, -0.46399027f, -0.04285961f, 
    -0.20333257f, -0.02983778f, 0.13540204f, 0.05799326f, -0.08526520f, 0.04957501f, -0.00394598f, 0.00082350f, 
    -0.05739480f, 0.12160031f, -0.12206828f, -0.08046451f, -0.05981126f, 0.08946909f, -0.02635548f, -0.17450872f, 
    0.20732686f, 0.13760351f, 0.11124564f, 0.03092931f, -0.09910735f, 0.10439336f, 0.02008957f, 0.17366125f, 
    -0.28249821f, 0.13261767f, -0.01177466f, 0.08673954f, -0.16288836f, -0.23147550f, -0.07837810f, -0.15835729f, 
    -0.02605478f, -0.10042270f, -0.06531901f, 0.14543617f, -0.00088676f, 0.42789954f, 0.02879439f, 0.25271267f, 
    0.07159651f, 0.11446455f, 0.01693979f, -0.08614913f, 0.00777475f, -0.43316132f, 0.08271030f, -0.11809386f, 
    -0.09029787f, -0.06092322f, 0.00373740f, -0.07205400f, -0.08640926f, 0.01604154f, -0.10034670f, -0.01066459f, 
    0.21091431f, 0.01380044f, 0.10910196f, -0.00919440f, 0.12598410f, 0.19025402f, -0.09060753f, -0.03104532f, 
    0.05391592f, -0.15805711f, 0.15384459f, 0.10015360f, -0.33960834f, -0.13247551f, -0.04829973f, 0.11623660f, 
    -0.14930427f, 0.18535791f, -0.04738789f, -0.03566775f, 0.02207484f, 0.05754513f, -0.11697619f, 0.00744191f, 
    -0.04466539f, 0.17456108f, 0.00008440f, 0.18872330f, 0.02444270f, 0.13717136f, 0.00244053f, 0.20155472f, 
    -0.02436671f, 0.15516864f, 0.01409215f, 0.19488026f, -0.12148848f, -0.06562629f, 0.00212429f, 0.02969860f, 
    0.02893348f, 0.16115336f, 0.11679012f, 0.09749752f, 0.00219379f, -0.07159876f, 0.03266839f, 0.06874522f, 
    0.03878791f, 0.10683076f, -0.39082161f, 0.13893852f, 0.02741945f, -0.00674923f, -0.08749957f, -0.18665729f, 
    0.00206031f, -0.07068531f, 0.00056032f, 0.01775285f, 0.37471899f, 0.12747566f, -0.05507860f, 0.11163647f, 
    -0.04903497f, -0.18612669f, -0.03309670f, 0.03042890f, 0.00891954f, -0.03736721f, 0.17075999f, -0.00557726f, 
    0.34794629f, 0.21610360f, 0.15414210f, 0.22671035f, -0.03072092f, -0.00730071f, 0.00061106f, -0.01049397f, 
    -0.12190544f, -0.12000103f, 0.03287471f, 0.04728438f, 0.05299239f, -0.21988754f, 0.16545086f, 0.08417942f, 
    0.04742626f, 0.29934812f, 0.10039251f, 0.09103067f, -0.01689808f, 0.13431603f, -0.11394483f, 0.10240099f, 
    -0.05679837f, 0.05601430f, -0.08421258f, 0.18351690f, 0.22594507f, 0.09995800f, 0.04356318f, 0.08367159f, 
    0.17071053f, 0.06490345f, 0.02783333f, -0.07954512f, -0.19076015f, -0.12470014f, 0.20861618f, 0.02295140f, 
    -0.18643157f, -0.01315303f, 0.14863983f, 0.02364786f, -0.04667518f, 0.19009084f, 0.04930837f, 0.12871979f, 
    0.25241065f, 0.13775527f, 0.12719865f, 0.02666142f, -0.13415514f, -0.00434805f, -0.10057505f, -0.03251262f, 
    -0.00728961f, 0.02906188f, -0.00612031f, -0.02811334f, 0.37527314f, 0.17336164f, 0.25214851f, 0.07780632f, 
    0.08874898f, -0.00950270f, -0.21514091f, -0.08800701f, -0.00880054f, 0.02666543f, 0.02215362f, -0.13610293f, 
    0.13979621f, 0.04118146f, 0.10508188f, 0.03390510f, -0.03367018f, -0.09748816f, -0.10108960f, 0.00544942f, 
    0.07114166f, -0.07756642f, -0.04046066f, 0.01059938f, -0.12147816f, -0.25672084f, -0.11687336f, -0.25476959f, 
    0.15474841f, -0.03887612f, -0.03930887f, 0.19338962f, -0.13311772f, -0.09064844f, 0.04107931f, 0.00833570f, 
    -0.37550718f, -0.41312140f, 0.20290723f, -0.20345290f, 0.02881390f, -0.09171189f, 0.02758123f, 0.16944064f, 
    -0.11773306f, 0.09635065f, 0.02539620f, -0.03897769f, 0.45760679f, 0.29984263f, -0.04826257f, 0.13074654f, 
    -0.00603210f, 0.07509674f, 0.11085977f, 0.01542940f, -0.16358210f, -0.05382536f, -0.04704857f, -0.05145323f, 
    0.11180340f, 0.23363698f, 0.15155640f, -0.04813466f, 0.01973214f, -0.14013474f, 0.01953793f, -0.17384590f, 
    -0.15367500f, 0.06005654f, 0.06171502f, 0.12717381f, -0.03780901f, -0.16327542f, -0.29167986f, 0.02385023f, 
    -0.07266979f, -0.20660633f, -0.09714025f, 0.04071317f, -0.01436902f, 0.10508261f, 0.08815359f, -0.02051466f, 
    -0.29933700f, -0.06391446f, 0.08469456f, -0.29564616f, 0.10719716f, 0.18912244f, -0.03210234f, -0.15846831f, 
    0.10794277f, 0.00188181f, 0.08937925f, 0.06967294f, 0.06432628f, 0.22487019f, 0.22537772f, -0.12065524f, 
    0.20408423f, -0.18889199f, 0.09735475f, -0.07991765f, -0.10695750f, -0.07852416f, 0.10552642f, 0.02511919f, 
    -0.05589719f, -0.11271592f, 0.29949185f, 0.28075695f, -0.07977964f, -0.10105827f, -0.12685116f, 0.03743812f, 
    0.03197531f, 0.02515765f, 0.14832474f, 0.10533451f, -0.11999916f, -0.09262402f, 0.34770194f, 0.03774444f, 
    -0.02356908f, -0.08819888f, -0.09500238f, 0.11084802f, -0.03604332f, -0.01479405f, -0.00487748f, -0.05964487f, 
    0.03019657f, -0.01185693f, 0.13327593f, 0.01285688f, 0.07568242f, -0.10609424f, -0.11357711f, 0.14454351f, 
    -0.11243194f, -0.15682089f, -0.11044057f, 0.12224023f, 0.02995934f, -0.17014836f, 0.25710839f, -0.08305175f, 
    0.08566716f, 0.17743777f, 0.08548254f, 0.15688621f, -0.02899048f, 0.03734991f, -0.16848527f, 0.07107875f, 
    -0.13507932f, 0.13454796f, -0.03192635f, 0.05766260f, 0.09423529f, 0.10831819f, -0.03252955f, 0.13085559f, 
    -0.07355314f, -0.07048002f, 0.06138053f, 0.16537002f, 0.01109100f, -0.21258834f, 0.03747881f, -0.15386662f, 
    0.18966790f, -0.19795676f, 0.10813143f, 0.01366082f, -0.06800944f, 0.11024383f, 0.10662463f, 0.03857996f, 
    -0.05466236f, 0.06757439f, 0.04556194f, -0.19239871f, -0.29223251f, 0.03742557f, -0.07053916f, -0.05858251f, 
    -0.12809928f, 0.08774959f, -0.01810118f, 0.05030047f, 0.04184682f, 0.16143911f, -0.27123499f, 0.15393926f, 
    0.09525236f, -0.04143085f, -0.13883846f, 0.03569444f, 0.02319785f, -0.19605516f, 0.01615104f, -0.09590258f, 
    -0.10129046f, 0.00342228f, -0.02659809f, -0.21176656f, -0.09868784f, -0.10046574f, -0.15694538f, -0.05009945f, 
    0.00980102f, -0.05635509f, -0.04397907f, -0.20675041f, -0.12365619f, -0.16881849f, 0.14382361f, -0.01558570f, 
    -0.15433925f, 0.12992850f, -0.03025683f, 0.02268859f, -0.20018415f, -0.20283495f, -0.07005016f, -0.03292603f, 
    0.05988964f, 0.25289693f, -0.07296747f, 0.08813367f, 0.24941535f, 0.03006397f, 0.08539920f, 0.07395863f, 
    0.05617102f, 0.02409935f, 0.06410469f, 0.06673448f, -0.01016369f, 0.01382910f, 0.12641171f, -0.13582034f, 
    0.02716638f, -0.11825926f, -0.07672544f, -0.17764479f, 0.04020702f, -0.05639987f, -0.05012947f, 0.00955439f, 
    0.22972108f, 0.01035492f, 0.33533770f, 0.10461213f, 0.14583717f, 0.11627030f, -0.03788114f, 0.22726499f, 
    -0.02775727f, 0.03199600f, 0.05270748f, 0.06589702f, -0.26754129f, -0.12430637f, 0.12272763f, -0.00218390f, 
    -0.15624838f, 0.06633410f, -0.06190599f, -0.09282007f, 0.12080090f, 0.04890760f, -0.00075067f, -0.01411032f, 
    -0.17208913f, -0.00852873f, -0.06852175f, 0.41274163f, -0.07878413f, 0.07885440f, -0.07911590f, -0.00337521f, 
    0.06100887f, 0.00300562f, 0.20126122f, 0.16075981f, 0.23241822f, -0.19561031f, -0.13138041f, 0.01788891f, 
    0.29449862f, -0.04501199f, 0.12519936f, 0.14162207f, -0.04684524f, -0.01050259f, -0.07232528f, -0.08223201f, 
    -0.42972952f, 0.38153151f, -0.08730504f, 0.00510917f, 0.02039595f, 0.15889345f, -0.07194741f, 0.06099495f, 
    0.04860697f, 0.09028264f, 0.19395122f, -0.00587773f, 0.01085622f, -0.25236687f, 0.22042738f, -0.04978411f, 
    -0.17544767f, -0.01065385f, 0.03307946f, -0.15235741f, 0.00067088f, -0.01259469f, -0.02031133f, -0.02416553f, 
    0.06414263f, -0.03495510f, 0.00191689f, -0.05158298f, -0.25364575f, 0.00080007f, -0.06983826f, 0.09312697f, 
    -0.17621359f, 0.12345070f, -0.06430411f, 0.07744484f, 0.10492390f, -0.32277951f, 0.27864981f, 0.06062328f, 
    0.11151940f, 0.01472420f, 0.04551224f, 0.08803472f, 0.18842986f, 0.00599341f, 0.10522565f, 0.05055718f, 
    -0.15592811f, 0.20533234f, -0.04645965f, 0.19192457f, -0.02618368f, -0.15700468f, 0.03898812f, -0.12465364f, 
    -0.06684989f, -0.03888433f, 0.02711019f, -0.07473172f, 0.04010749f, -0.32741934f, 0.29338986f, -0.08387952f, 
    0.06743494f, 0.08617992f, 0.12377211f, 0.01285096f, 0.10783580f, 0.17138857f, 0.12957565f, 0.27516338f, 
    -0.05763375f, 0.02840783f, 0.10744198f, -0.22781932f, -0.14615835f, -0.10950637f, -0.05956975f, -0.02439293f, 
    -0.23715952f, 0.01354488f, -0.07717217f, -0.09521303f, 0.26752499f, 0.14799665f, -0.33849159f, 0.03534166f, 
    -0.07522427f, -0.09919058f, 0.13265550f, 0.13874096f, -0.08132702f, 0.08272577f, 0.04521156f, -0.04940978f, 
    0.01476215f, 0.09667636f, 0.01721739f, 0.03949377f, 0.02905691f, 0.06924442f, 0.07893959f, 0.14429428f, 
    0.00498595f, 0.08225463f, 0.01007910f, -0.03645635f, -0.06915678f, -0.10716330f, -0.07498588f, 0.03201659f, 
    -0.19410503f, 0.02099863f, -0.13485083f, 0.10046844f, 0.00436401f, -0.02141134f, -0.00183964f, -0.01155414f, 
    0.08740700f, 0.10309566f, -0.01510868f, 0.13940808f, 0.02834029f, 0.00535487f, 0.26433593f, 0.23792045f, 
    0.17842048f, 0.06568370f, -0.10786112f, 0.02480411f, -0.02421983f, -0.18658903f, 0.16060263f, 0.17500387f, 
    -0.04923690f, 0.05844573f, 0.04959077f, -0.14299594f, -0.08644792f, -0.03443683f, -0.02479921f, 0.09097337f, 
    0.13746291f, 0.02357251f, 0.26062530f, -0.02039192f, -0.00056406f, 0.08872149f, -0.05103556f, -0.06983329f, 
    -0.16487999f, 0.01581641f, 0.04129060f, 0.06028825f, -0.29973987f, -0.30597237f, -0.21591590f, 0.13265614f, 
    -0.13330935f, 0.09102987f, -0.05708135f, -0.07907686f, 0.04540484f, 0.19649886f, 0.02861378f, 0.01199905f, 
    -0.06093981f, -0.02842831f, 0.03265363f, -0.28690982f, 0.01233096f, -0.02064359f, -0.06048126f, -0.09165690f, 
    0.01199003f, -0.00702183f, 0.06404648f, 0.02235369f, 0.12358036f, 0.09109204f, -0.10414786f, -0.17395517f, 
    0.16923366f, 0.04226322f, 0.13459118f, 0.14525503f, -0.05863291f, 0.02661610f, 0.00838538f, -0.01416606f, 
    0.44443324f, -0.26687777f, 0.13770406f, 0.25348094f, -0.05108152f, -0.07105829f, -0.00326187f, -0.08854269f, 
    0.06510475f, 0.01983562f, -0.10156576f, 0.13177486f, -0.14391328f, -0.09928280f, -0.22610500f, 0.16441451f, 
    -0.06214034f, 0.05557420f, -0.01701991f, 0.03546908f, 0.07702271f, 0.05310970f, -0.08453510f, -0.08235022f, 
    -0.00850498f, -0.17592070f, -0.08067652f, 0.31109777f, -0.06521068f, -0.00670249f, 0.00508317f, -0.10076105f, 
    0.10048591f, -0.01525236f, -0.08352789f, 0.03975692f, 0.12237224f, 0.16851936f, 0.06865617f, 0.01762616f, 
    -0.05290782f, 0.12311629f, 0.15902451f, -0.03768585f, -0.12550175f, -0.04241991f, -0.06591222f, -0.00435439f, 
    0.02760691f, -0.02170452f, -0.10415164f, 0.07759366f, -0.07510050f, 0.19981132f, -0.02174486f, 0.03551488f, 
    -0.04899823f, -0.07231181f, 0.05605284f, 0.16048019f, 0.07362077f, 0.22417782f, -0.02962811f, 0.14674613f, 
    0.10474123f, -0.00109406f, 0.19723403f, 0.19129758f, -0.04738969f, 0.05706159f, 0.07605472f, 0.05886218f, 
    -0.01385693f, -0.19202457f, 0.03544507f, 0.13019259f, -0.14427835f, -0.04860668f, -0.10701696f, -0.12884867f, 
    0.15314697f, -0.16436265f, 0.07692173f, -0.09090912f, -0.23254161f, 0.08286580f, 0.39808589f, 0.03204145f, 
    0.11377687f, 0.09769838f, -0.09327091f, -0.06114934f, -0.02112035f, -0.07788720f, -0.14144592f, 0.03959967f, 
    0.02410029f, -0.03856462f, 0.16003253f, -0.20582557f, -0.03857649f, 0.01694874f, -0.16934671f, -0.03751033f, 
    -0.04485113f, -0.12823559f, 0.23323265f, 0.06940522f, -0.00108088f, 0.12189365f, 0.24230640f, 0.03970705f, 
    0.03934418f, 0.23139399f, 0.19515193f, 0.09558071f, 0.08869596f, -0.04849763f, 0.07100131f, -0.15904362f, 
    -0.17388877f, -0.11190139f, 0.05471198f, -0.13588360f, 0.12288533f, 0.05898230f, -0.06848571f, 0.05968940f, 
    0.05440662f, -0.05216646f, 0.07083528f, 0.08623799f, 0.10848910f, 0.06275082f, -0.16591889f, 0.01690788f, 
    0.03220447f, 0.06531969f, -0.09140535f, 0.03067264f, 0.06704270f, 0.00679460f, -0.01854183f, -0.05739355f, 
    -0.31909168f, 0.06572032f, -0.07422309f, 0.01338791f, 0.01001460f, -0.12341461f, 0.11475237f, 0.03022659f, 
    0.07797949f, 0.05152189f, 0.01267316f, 0.07555749f, 0.21899851f, 0.22880489f, 0.21288508f, 0.04721355f, 
    0.03268225f, 0.08735023f, 0.03635632f, 0.13743050f, 0.23170461f, -0.01174129f, 0.06678123f, -0.02762721f, 
    -0.44359422f, 0.12208921f, -0.02977144f, 0.16418643f, -0.21392998f, 0.02661925f, -0.22326542f, 0.06591219f, 
    0.09829855f, 0.02079722f, -0.00394130f, 0.11753719f, -0.58343172f, -0.08198228f, 0.28889886f, 0.01663124f, 
    0.15387304f, 0.14275348f, -0.11521232f, 0.15363754f, -0.05729805f, 0.02483669f, 0.09258778f, -0.03874988f, 
    -0.18933371f, -0.03631511f, -0.19220157f, -0.14177801f, -0.00013830f, -0.04497962f, -0.21938343f, -0.03202248f, 
    0.12746632f, -0.05595573f, -0.10264304f, 0.03431859f, -0.18952796f, -0.00677272f, -0.13206021f, 0.19448146f, 
    -0.02142297f, 0.16521695f, 0.11767741f, 0.21314628f, 0.09194846f, 0.03703249f, 0.03583838f, 0.03931385f, 
    0.27294844f, 0.13440296f, -0.18258780f, 0.05968954f, -0.06121993f, 0.00202193f, -0.09599448f, 0.14510354f, 
    -0.09929036f, -0.09801507f, 0.02620440f, 0.09171928f, 0.17973781f, -0.15908670f, 0.17899393f, 0.14195192f, 
    -0.09751301f, 0.09340104f, -0.00405485f, 0.10662330f, 0.06923642f, 0.10455451f, 0.00613979f, 0.07770748f, 
    -0.12448715f, 0.10191142f, -0.17294613f, 0.24235825f, 0.16605887f, 0.02951792f, 0.05587573f, 0.00185263f, 
    0.14969805f, 0.09132338f, 0.09068600f, 0.21827391f, -0.04914765f, 0.01726850f, 0.11989851f, 0.06298714f, 
    0.19278172f, -0.08172540f, 0.22016306f, 0.06581053f, -0.11915579f, 0.04097041f, 0.12687725f, 0.04554313f, 
    -0.06982410f, -0.04292640f, -0.04812970f, -0.11206254f, -0.08571808f, -0.10360756f, 0.08829688f, -0.02903692f, 
    0.01883055f, -0.07146818f, 0.00825399f, 0.08315182f, 0.35650018f, -0.04819065f, 0.27584118f, 0.15548350f, 
    0.16655634f, 0.18697931f, 0.07256769f, -0.05957298f, -0.00372084f, 0.01341806f, 0.01211164f, 0.09472003f, 
    -0.11823465f, -0.13849367f, -0.05793127f, -0.07399851f, -0.08151834f, -0.07351625f, -0.08727447f, -0.13977231f, 
    -0.18277283f, 0.02000434f, -0.20473984f, -0.33042648f, 0.03762211f, -0.15002558f, 0.18464860f, 0.06422513f, 
    -0.06202455f, 0.07652994f, -0.10389801f, -0.00897898f, -0.10765898f, -0.12058605f, -0.03483702f, 0.16652958f, 
    0.00448307f, -0.15592146f, -0.02509245f, -0.00548837f, 0.04829246f, -0.05337080f, 0.19859196f, 0.21741211f, 
    -0.13257651f, 0.10104112f, -0.05850329f, -0.12483227f, 0.02092842f, 0.17202426f, 0.27508542f, 0.11165889f, 
    0.01544394f, 0.10349905f, 0.12835139f, -0.09547137f, 0.04281765f, -0.16017301f, -0.09510933f, -0.05408915f, 
    -0.09726939f, 0.15006520f, 0.01715687f, 0.14575019f, 0.03144439f, 0.14081888f, 0.22252949f, 0.10452157f, 
    -0.13189030f, 0.11002784f, 0.02316115f, -0.08094199f, 0.01467038f, -0.04856526f, 0.18752813f, 0.17636679f, 
    -0.10185213f, 0.09215868f, -0.10283800f, -0.09008960f, 0.03225128f, 0.06567314f, 0.01139885f, -0.00142231f, 
    -0.20380712f, -0.10300500f, 0.16031593f, -0.13690788f, -0.12516208f, 0.05654721f, 0.09138139f, -0.04141370f, 
    0.14729868f, 0.02853150f, 0.16131562f, 0.06720486f, 0.15053479f, -0.00892500f, 0.08101386f, 0.01809825f, 
    0.07833748f, 0.07813684f, 0.19706236f, 0.12618473f, 0.00984150f, 0.08756003f, 0.04405426f, 0.05909918f, 
    -0.18926822f, 0.22903204f, -0.21376492f, -0.12740596f, 0.04613220f, 0.00238408f, -0.05389558f, -0.00969421f, 
    -0.06924680f, 0.05133962f, 0.09110434f, -0.02927212f, -0.01387690f, 0.01904176f, 0.12711839f, -0.12648083f, 
    -0.05230835f, -0.01616441f, 0.01027546f, 0.11024345f, -0.03093850f, 0.02883379f, 0.04620525f, 0.02535237f, 
    -0.15283182f, -0.34251529f, 0.49402478f, -0.08392135f, -0.09137403f, 0.04606263f, -0.04393579f, 0.08996623f, 
    -0.02927279f, 0.05730428f, 0.04494034f, 0.00305083f, 0.13598709f, -0.06882711f, -0.01795949f, 0.13217030f, 
    0.18103227f, -0.01073083f, -0.02969873f, -0.08109628f, 0.08898257f, 0.04205779f, 0.08784011f, -0.10654701f, 
    -0.19739845f, 0.05004331f, -0.00743362f, 0.13489404f, 0.04048912f, 0.11984922f, -0.04624662f, -0.01055447f, 
    -0.13403261f, 0.01961834f, -0.02352423f, 0.03379474f, 0.17402118f, -0.10682386f, 0.11621603f, 0.07290360f, 
    0.06768565f, 0.20926268f, -0.11059664f, -0.04184557f, -0.08552022f, -0.03278520f, -0.06575207f, -0.02269240f, 
    -0.08207058f, 0.00737714f, 0.08039004f, -0.04471571f, -0.06181845f, 0.04489557f, -0.00548196f, 0.11551302f, 
    -0.01949343f, 0.07956372f, 0.10509828f, 0.05904472f, 0.17211866f, 0.08864445f, -0.17290139f, 0.18621999f, 
    -0.01407118f, -0.04864738f, -0.02373619f, 0.01519330f, 0.09694267f, 0.08005407f, 0.03781583f, 0.00957916f, 
    -0.12342335f, 0.02619573f, 0.02724076f, 0.03165177f, -0.06890044f, -0.10483266f, 0.00872207f, -0.07461865f, 
    0.07718796f, 0.14412448f, -0.03713777f, 0.08774384f, 0.26626691f, 0.05417650f, -0.20778196f, 0.04731296f, 
    0.06491777f, -0.08458006f, -0.18453164f, 0.07205093f, -0.10320795f, -0.00863029f, -0.09719730f, -0.09097491f, 
    0.22381590f, 0.02534978f, -0.06453940f, 0.20752588f, -0.01108384f, 0.13498382f, -0.13064456f, 0.00645371f, 
    -0.05767302f, -0.11678730f, -0.00235508f, -0.00266317f, -0.12175628f, 0.05726932f, 0.13380226f, 0.15186426f, 
    -0.05765981f, -0.09236637f, -0.02526492f, 0.04739843f, -0.13643821f, 0.08073845f, -0.04354917f, 0.07048523f, 
    -0.10784417f, -0.03408785f, 0.30844879f, -0.16818532f, 0.01363911f, -0.03708537f, 0.01811516f, 0.09703762f, 
    -0.02122541f, 0.01305538f, 0.08976828f, 0.01162209f, 0.06205766f, -0.06915556f, -0.29848823f, -0.01317522f, 
    0.15732373f, 0.01793593f, 0.09191713f, -0.00709151f, -0.10206971f, 0.00227572f, -0.06211183f, 0.03415117f, 
    0.49463493f, 0.01459370f, -0.18120889f, -0.43649161f, 0.32279789f, 0.14034407f, 0.05684624f, 0.05147231f, 
    -0.00495745f, 0.01664753f, -0.03266709f, 0.06107649f, 0.61049950f, 0.19661909f, 0.04565423f, -0.14558110f, 
    0.02070542f, 0.02372605f, -0.04947275f, -0.05438004f, 0.06578788f, 0.05508298f, -0.00783591f, -0.04619758f, 
    -0.18838976f, 0.08434144f, 0.25881347f, 0.17726372f, -0.00390513f, -0.11064310f, 0.03468235f, 0.17238368f, 
    0.02223984f, 0.25708738f, 0.34108725f, 0.14284076f, 0.08546539f, 0.12356079f, 0.28857321f, -0.12382238f, 
    -0.00654872f, -0.02309216f, -0.04771472f, 0.14927730f, -0.18813887f, -0.03913639f, -0.14807515f, 0.01036791f, 
    0.05954991f, -0.23255204f, 0.43369859f, -0.02506816f, -0.01451502f, -0.08606005f, -0.18538794f, 0.10501160f, 
    -0.03453834f, -0.10223544f, -0.01599531f, 0.04188723f, -0.01910993f, 0.19836873f, 0.02037352f, -0.10151350f, 
    0.22668973f, 0.03852498f, -0.01950719f, 0.18578339f, 0.06013813f, 0.13840477f, -0.06991059f, -0.09079791f, 
    -0.26994464f, 0.02177608f, -0.03153743f, -0.07537445f, -0.01096496f, 0.01515214f, 0.01171919f, 0.09877338f, 
    -0.14007732f, -0.00728070f, -0.17660804f, -0.09588508f, -0.12010498f, -0.16151837f, -0.24266626f, -0.25873637f, 
    0.28093094f, 0.00572354f, -0.04859202f, -0.03643749f, 0.11541666f, 0.08907362f, 0.11462974f, 0.11576480f, 
    -0.11611457f, 0.02683260f, -0.01472682f, -0.11248790f, -0.09343680f, -0.07432766f, -0.15152214f, -0.18749328f, 
    -0.23137443f, 0.02742397f, -0.12032369f, 0.02030811f, 0.28485832f, -0.00252968f, -0.10111283f, -0.02692631f, 
    -0.07471300f, 0.04893717f, 0.15038000f, -0.00461799f, 0.01084438f, -0.21676457f, 0.00358916f, -0.05584754f, 
    -0.13288511f, 0.04141303f, 0.09337196f, 0.03329843f, 0.02876604f, 0.10561120f, -0.02867831f, 0.01625407f, 
    0.12481020f, 0.15128326f, -0.02338143f, -0.12481739f, -0.14100499f, -0.17675868f, -0.07855368f, -0.19075169f, 
    0.02730386f, -0.16370553f, -0.13802963f, 0.09378490f, 0.04133921f, -0.17076348f, -0.01845845f, -0.15140869f, 
    0.38898274f, 0.20989786f, -0.20701875f, 0.24388187f, 0.08964390f, 0.02717341f, -0.08159938f, 0.08863746f, 
    0.07732224f, 0.12507735f, 0.25636908f, -0.05791541f, -0.24023606f, 0.03897315f, 0.07851581f, -0.01943207f, 
    -0.05861173f, -0.00924078f, 0.04940775f, -0.01363974f, -0.13433294f, -0.11470763f, -0.07439461f, 0.06338938f, 
    0.19044282f, -0.09902837f, 0.35231209f, -0.01884599f, 0.09501816f, 0.15164737f, -0.15115620f, 0.07128125f, 
    -0.12433926f, -0.18516780f, 0.08018414f, -0.00796782f, -0.29643399f, -0.27915248f, -0.14601353f, -0.29425874f, 
    -0.07231945f, 0.01562285f, 0.12717231f, -0.00724781f, -0.04853649f, 0.01010402f, 0.00531391f, -0.04621935f, 
    0.07537465f, -0.00319992f, -0.07579666f, 0.16707015f, 0.11279747f, -0.07300685f, 0.01438132f, 0.12402961f, 
    0.19403361f, 0.03240502f, 0.17461443f, 0.07058931f, 0.37292466f, -0.04508589f, -0.20133604f, 0.02468915f, 
    0.17730549f, -0.06288292f, -0.01454212f, 0.09618036f, 0.08362950f, -0.10047855f, 0.04184034f, -0.02564462f, 
    0.10195910f, -0.00962629f, -0.04401318f, -0.17633061f, -0.01163220f, -0.05798575f, 0.01103327f, 0.04227195f, 
    0.13626441f, 0.03888633f, 0.04486987f, 0.11755191f, -0.35376373f, 0.17131209f, -0.08946218f, 0.03652643f, 
    -0.04752399f, -0.15555564f, -0.06735438f, 0.12936296f, -0.07578306f, -0.03524164f, 0.03596498f, 0.00776686f, 
    0.09127899f, 0.01231144f, 0.22774792f, -0.04356323f, -0.01203988f, 0.02694901f, -0.08237816f, -0.04290208f, 
    0.11455551f, -0.08922218f, 0.06630833f, -0.08267278f, 0.19671685f, 0.33059046f, -0.22823317f, 0.19799536f, 
    -0.04870348f, 0.02737627f, -0.04559708f, 0.08600424f, 0.01478213f, 0.15469797f, -0.06054151f, -0.07562046f, 
    -0.21368390f, -0.12025803f, 0.00190938f, -0.03782262f, -0.13861611f, -0.07715642f, -0.13808967f, 0.03347301f, 
    0.06623441f, -0.10031079f, -0.18938176f, 0.11120170f, -0.08237537f, 0.41596016f, 0.04732694f, 0.23868057f, 
    0.14223431f, -0.02755651f, -0.11542439f, 0.00198031f, 0.09025719f, -0.03056937f, -0.01848519f, -0.03997677f, 
    -0.16715409f, 0.02638544f, -0.20239243f, 0.03400064f, 0.07117292f, -0.14251855f, -0.07191675f, -0.11573258f, 
    0.17974348f, -0.01445597f, -0.07255587f, 0.16372178f, 0.35294697f, -0.36067113f, 0.31023169f, 0.23014635f, 
    -0.06041368f, -0.06609745f, -0.03382310f, 0.05894738f, 0.00168059f, -0.02612221f, 0.10977396f, 0.08275099f, 
    -0.05529908f, -0.08821771f, 0.10219608f, 0.17712516f, 0.02395146f, -0.13138258f, 0.01110868f, -0.07201419f, 
    0.18599701f, 0.16217548f, 0.00887473f, 0.01180361f, 0.20164019f, -0.24853623f, 0.01470017f, -0.03898166f, 
    0.28243351f, 0.01740317f, 0.03266001f, -0.06378125f, 0.06242710f, -0.00674068f, 0.00764328f, 0.23581547f, 
    0.34116760f, 0.05415137f, -0.20511553f, 0.32811818f, 0.02066294f, 0.13171107f, 0.05352983f, 0.03162874f, 
    0.02098457f, -0.04055284f, 0.15265283f, -0.01505057f, -0.02510104f, 0.44423419f, 0.46369126f, -0.04594027f, 
    0.02462137f, -0.00314382f, 0.05955086f, 0.15052134f, -0.00979675f, 0.05102699f, 0.07337831f, -0.13198979f, 
    -0.25550890f, -0.18778469f, -0.01067676f, 0.03869627f, -0.20105587f, -0.05158204f, -0.12400930f, -0.06434456f, 
    0.01200926f, -0.12990253f, -0.09259797f, -0.09095050f, 0.09554812f, 0.06004772f, 0.05037633f, -0.06020850f, 
    0.15057395f, -0.02302281f, 0.05128800f, 0.03542561f, 0.00434546f, 0.04581084f, 0.18955007f, 0.08866030f, 
    0.53426987f, -0.13835683f, -0.20974176f, -0.23815975f, 0.07236589f, -0.07774544f, 0.10421977f, 0.00683492f, 
    0.17217550f, -0.05357808f, 0.01955851f, -0.06027055f, 0.71673328f, -0.06454221f, 0.00047331f, 0.28502131f, 
    -0.07036968f, 0.05479723f, -0.13294391f, -0.02452774f, -0.11497135f, 0.07472809f, -0.09310513f, -0.06482092f, 
    -0.00343278f, 0.00547103f, -0.03147022f, 0.03056210f, 0.03366626f, 0.03106062f, -0.04652050f, -0.02665900f, 
    -0.03251996f, -0.01192924f, 0.02916216f, 0.06537199f, -0.04226479f, -0.01683575f, 0.05081600f, -0.02591203f, 
    -0.01895311f, -0.06726845f, 0.04264687f, -0.06248954f, -0.07012948f, 0.05092855f, 0.03847419f, -0.06237425f, 
    -0.07792023f, 0.00529929f, -0.05315292f, 0.01093724f, -0.04271761f, -0.05757064f, -0.02764652f, 0.00393551f, 
    0.04368141f, -0.05217792f, -0.03076062f, 0.00143009f, -0.03401963f, -0.02149925f, -0.06183377f, -0.01103660f, 
    -0.07850538f, 0.01117708f, -0.05641836f, 0.00361864f, 0.05689474f, -0.07325491f, -0.01576175f, -0.00869012f, 
    -0.06361140f, -0.00421818f, -0.05349234f, -0.06113264f, 0.04109346f, 0.00368222f, 0.01489859f, 0.00725596f, 
    -0.05150675f, 0.02214870f, 0.01276176f, -0.02536174f, 0.00268725f, -0.05985167f, 0.05016046f, 0.00523716f, 
    -0.04774446f, 0.05128850f, -0.02646120f, -0.00864961f, -0.07877202f, -0.04100313f, 0.06005936f, -0.00526985f, 
    0.01643028f, -0.01339733f, 0.04509640f, -0.07263599f, -0.01512932f, -0.00157737f, 0.06325870f, -0.01083909f, 
    0.05215007f, 0.05122028f, -0.03811156f, -0.00033335f, 0.03299829f, 0.05077282f, -0.01521517f, -0.03421280f, 
    -0.06979143f, -0.05392640f, 0.03442100f, -0.03207143f, 0.04978959f, -0.04293384f, -0.01227463f, 0.06006484f, 
    -0.00126905f, -0.05769149f, 0.05799344f, 0.00129005f, -0.02163108f, 0.00078467f, 0.05366691f, -0.02030072f, 
    -0.05977218f, -0.00869329f, 0.04713311f, -0.02587868f, -0.02613227f, 0.03883950f, 0.04566197f, -0.01758238f, 
    -0.07616617f, -0.01040505f, -0.06948280f, -0.02273664f, -0.00180595f, 0.02903482f, 0.04475398f, -0.02138313f, 
    -0.02668607f, -0.07357965f, 0.03017541f, 0.04851936f, -0.00673234f, 0.00850697f, 0.05565088f, -0.07017000f, 
    0.04905865f, 0.06073071f, 0.06079131f, -0.07630717f, -0.03273559f, -0.05214361f, -0.01713547f, 0.03918090f, 
    0.05463988f, -0.04432035f, 0.02366205f, 0.02680352f, -0.05117348f, 0.05212858f, -0.08019026f, -0.06522106f, 
    0.01219741f, 0.00754408f, 0.00008436f, 0.03015064f, -0.00965061f, -0.04723294f, -0.01766735f, 0.06139909f, 
    0.03305100f, -0.04291439f, -0.00408395f, -0.03340819f, -0.06544211f, -0.05689328f, -0.01010375f, -0.00056797f, 
    -0.06967096f, 0.01513353f, 0.06667271f, -0.04700859f, -0.03121092f, -0.07421276f, 0.00712403f, -0.03720650f, 
    -0.04702763f, -0.01085817f, 0.04799794f, 0.04506074f, 0.03775774f, 0.06028085f, -0.04833962f, 0.01375495f, 
    -0.02863207f, -0.00662431f, -0.02305420f, -0.02495541f, 0.00327413f, -0.04174805f, -0.03478372f, 0.00775977f, 
    -0.07779212f, -0.02478230f, -0.00756493f, 0.02181737f, -0.05035778f, -0.03528115f, -0.04945676f, -0.00762520f, 
    0.21400738f, 0.04987188f, 0.21156625f, 0.07314872f, 0.08860739f, -0.05153203f, 0.01666242f, 0.04846232f, 
    0.11179657f, 0.08058254f, -0.10782013f, 0.02482118f, 0.20389247f, -0.12555771f, -0.11762799f, 0.03320103f, 
    -0.23185454f, -0.06938785f, -0.08480498f, -0.12288305f, 0.01760357f, 0.03445053f, -0.04277550f, 0.17734909f, 
    0.02810578f, 0.20539524f, 0.16251795f, 0.01737214f, 0.00508970f, -0.10359854f, -0.01690118f, -0.07390685f, 
    -0.01659251f, 0.00012078f, -0.01281849f, 0.02892561f, -0.13829014f, -0.02703848f, 0.03519868f, 0.02409684f, 
    -0.01106545f, 0.08525797f, 0.28881046f, 0.02667760f, 0.00303764f, 0.14738943f, -0.03484295f, 0.26706031f, 
    0.18800573f, -0.03282857f, -0.15471725f, -0.00032378f, 0.08718883f, 0.09718445f, 0.11665773f, -0.02094363f, 
    0.14108239f, 0.13406403f, 0.09793431f, 0.02053347f, 0.00049163f, -0.01074748f, -0.09377205f, -0.14419842f, 
    -0.02624574f, 0.04304425f, -0.04467884f, 0.15663184f, -0.08858857f, 0.09309319f, -0.03982684f, 0.02256673f, 
    0.11780616f, 0.04677600f, 0.14561278f, 0.20448202f, -0.25638855f, -0.01281975f, -0.02608370f, -0.18393105f, 
    -0.10097973f, -0.08472872f, -0.14605193f, -0.04375321f, -0.18764047f, 0.27841470f, -0.07887536f, -0.18339811f, 
    0.07325944f, 0.10537382f, -0.04111976f, -0.26864898f, 0.09194393f, -0.04622636f, -0.04901044f, 0.09774489f, 
    -0.05886497f, 0.17030162f, -0.02207682f, -0.14862889f, -0.05544856f, -0.02488012f, -0.20932391f, -0.01359051f, 
    -0.20505346f, -0.16503930f, -0.09564456f, -0.17066051f, -0.07243501f, 0.26901251f, 0.07163798f, 0.09125112f, 
    0.09915549f, 0.18984652f, 0.25496009f, 0.12684755f, -0.05503889f, 0.09080330f, -0.02387197f, -0.14617141f, 
    -0.34436589f, -0.36327085f, 0.06851464f, -0.34806567f, 0.01460000f, -0.06496027f, 0.03626262f, 0.20350841f, 
    0.06340223f, -0.03777873f, -0.03876869f, -0.07439021f, -0.12623180f, -0.07833302f, -0.22736047f, -0.17268495f, 
    -0.09850121f, -0.06407169f, -0.03843392f, -0.10216434f, -0.04018724f, -0.11236009f, 0.00204487f, 0.09358786f, 
    0.11392513f, 0.08710713f, -0.00758058f, -0.02724903f, -0.14541911f, -0.11653769f, -0.03256306f, 0.09454226f, 
    0.02911085f, -0.00938209f, -0.00798157f, 0.08460972f, 0.16914161f, 0.22419998f, -0.01289419f, 0.01338197f, 
    -0.01077618f, 0.26330543f, 0.04641895f, -0.05149727f, 0.05497428f, -0.07406496f, -0.06544970f, -0.03419086f, 
    -0.45245516f, 0.01173721f, 0.03310015f, 0.21277137f, -0.05708775f, -0.04224529f, 0.06882372f, -0.16659962f, 
    0.04825149f, 0.04573738f, 0.15110379f, 0.28083307f, -0.52290338f, -0.09478587f, 0.13172920f, -0.21303576f, 
    0.08747387f, 0.10635928f, 0.06181414f, 0.23293003f, -0.05243050f, 0.00351868f, 0.05782950f, -0.00963208f, 
    -0.27576986f, 0.07277146f, -0.07299615f, 0.08581178f, 0.18395118f, -0.00219659f, -0.12901264f, 0.01602527f, 
    -0.05723562f, 0.04585494f, 0.16519330f, 0.19380286f, 0.17621970f, -0.03184615f, 0.06032347f, -0.12330463f, 
    -0.19364934f, -0.04099309f, -0.00760998f, 0.04803572f, 0.02976491f, -0.05065800f, -0.07681935f, -0.05435996f, 
    0.37862286f, -0.38947225f, 0.13959616f, -0.11807561f, -0.21383089f, -0.01587648f, -0.12927657f, 0.03175730f, 
    -0.06123396f, -0.07365622f, 0.01259412f, -0.04689376f, 0.20045559f, 0.16217025f, -0.02279092f, 0.04261271f, 
    0.05697403f, 0.10126563f, -0.03925461f, 0.28899693f, 0.24675877f, 0.05350500f, -0.01940595f, -0.00028915f, 
    -0.15504348f, 0.13360614f, 0.10187946f, -0.02611022f, -0.04063034f, 0.05708291f, -0.02212355f, 0.02599268f, 
    0.07971385f, 0.05666387f, -0.05877968f, -0.00461354f, 0.02215736f, -0.00063938f, 0.33142185f, 0.17213917f, 
    0.11610997f, 0.16214922f, 0.12435738f, -0.02769531f, 0.04990814f, -0.01439018f, 0.04587282f, 0.13462631f, 
    0.17536935f, 0.00286770f, -0.03655169f, -0.18547761f, -0.10711288f, -0.15118173f, -0.00827735f, 0.04432593f, 
    0.04753282f, 0.11603218f, 0.18550202f, 0.01732634f, 0.32720217f, -0.11491765f, 0.00810687f, 0.42711797f, 
    -0.11974234f, -0.10095984f, 0.00611397f, 0.20674385f, -0.03765955f, -0.02442253f, 0.07020396f, -0.11888175f, 
    0.19088180f, -0.00580941f, 0.09099267f, 0.04237979f, -0.02870489f, -0.04502506f, 0.10654054f, 0.02706188f, 
    0.24799237f, 0.33088502f, 0.07209512f, 0.01810480f, 0.03011818f, -0.09019790f, 0.09999524f, 0.06550109f, 
    0.06306509f, -0.04076673f, -0.08950655f, 0.11065915f, 0.00871695f, -0.01415182f, -0.02687794f, 0.02339745f, 
    0.20555870f, 0.14459376f, -0.00561673f, 0.26484513f, 0.13098159f, 0.00864726f, 0.08289489f, 0.13795635f, 
    0.05244119f, 0.07113451f, 0.19449708f, -0.01812910f, 0.16475795f, 0.17733496f, 0.39545962f, 0.27807513f, 
    -0.14864628f, 0.10294400f, 0.01825385f, 0.09163389f, -0.07875769f, -0.00379591f, -0.06179598f, -0.07001765f, 
    0.07900857f, 0.02883635f, 0.14767952f, 0.00861218f, -0.05775868f, 0.03931276f, 0.07029162f, -0.08750142f, 
    0.08157127f, -0.04494740f, 0.01767988f, -0.02651278f, -0.14772430f, -0.10274044f, 0.09527583f, 0.27184457f, 
    0.06447532f, -0.00091546f, -0.01256748f, 0.17810260f, 0.03191209f, 0.14276084f, 0.16585098f, -0.09727515f, 
    0.15751529f, -0.18649454f, -0.20359987f, -0.21753007f, 0.12069039f, 0.03951842f, -0.05687067f, -0.11013515f, 
    0.07438342f, 0.08247829f, 0.00109201f, 0.06160305f, 0.24211898f, 0.09169375f, -0.05125032f, 0.12326955f, 
    0.19254202f, 0.06356750f, 0.13363107f, -0.09370153f, -0.14935613f, 0.08842940f, -0.12367440f, 0.00992031f, 
    0.26713696f, -0.14743218f, 0.01724050f, 0.33415502f, -0.08581345f, -0.04811551f, -0.09602188f, -0.05308814f, 
    0.07584294f, 0.08787608f, -0.00862760f, 0.05393880f, -0.07156225f, -0.07590947f, -0.06793187f, -0.08008847f, 
    0.15922497f, 0.07741702f, -0.13446675f, 0.04057533f, -0.04948601f, -0.09091008f, -0.06651826f, -0.24277411f, 
    -0.14563099f, -0.27982494f, -0.15053943f, 0.14500004f, 0.05070257f, -0.02411761f, 0.05893407f, -0.00234865f, 
    -0.01457725f, -0.14975628f, -0.03734648f, 0.09870385f, -0.02221962f, 0.02443645f, 0.13873760f, 0.05625749f, 
    -0.03038076f, -0.00046703f, -0.10227180f, -0.00178300f, -0.15746933f, -0.20480432f, -0.06849363f, -0.19210705f, 
    0.08580178f, -0.07146287f, 0.09574810f, 0.07867584f, 0.13132143f, 0.10402352f, -0.01045629f, -0.08859934f, 
    -0.21505743f, -0.17242983f, -0.00640256f, -0.12833135f, 0.18711981f, 0.09947164f, 0.02798012f, 0.09863814f, 
    0.04424524f, -0.02059172f, -0.00691990f, 0.10013993f, -0.03864004f, 0.08680570f, -0.05476059f, -0.06043974f, 
    -0.30772373f, -0.23799315f, -0.20502667f, -0.20335971f, 0.14561175f, 0.07488282f, -0.12575348f, 0.23528051f, 
    0.04723246f, 0.03993937f, 0.09679607f, 0.04541418f, -0.19213970f, 0.10096627f, 0.22246079f, -0.02108304f, 
    -0.03387851f, -0.04090711f, 0.00968755f, 0.09309287f, -0.11761545f, -0.04642969f, 0.05353983f, -0.07543717f, 
    -0.12920906f, -0.17001498f, 0.06531689f, -0.05310684f, 0.15630420f, 0.10458204f, 0.05596815f, -0.06582355f, 
    0.02496698f, 0.08917175f, 0.24139252f, 0.29948840f, 0.16829999f, 0.10947865f, 0.09915118f, 0.16360582f, 
    -0.15491870f, -0.02929167f, -0.00047088f, -0.02744429f, -0.11052540f, -0.23522979f, -0.02204902f, -0.13258889f, 
    -0.14315398f, 0.18112801f, 0.19343947f, -0.00156390f, 0.05900675f, 0.08203926f, -0.08977748f, -0.06070713f, 
    0.13825241f, 0.04360461f, 0.03955849f, 0.12490635f, 0.10491090f, -0.08918896f, -0.26371393f, 0.11472692f, 
    0.16114797f, 0.10054366f, -0.03897743f, 0.02449504f, -0.01246431f, 0.12132830f, 0.03605225f, -0.04462994f, 
    -0.03179915f, 0.05979437f, -0.10217786f, -0.06600878f, 0.31811085f, 0.07313365f, 0.04603036f, 0.01464260f, 
    -0.01682069f, -0.14638340f, -0.11047795f, 0.08362141f, 0.17394091f, -0.00679805f, 0.17662400f, -0.00174546f, 
    -0.00169937f, -0.09964406f, 0.03031277f, 0.20103434f, 0.07414173f, -0.02231088f, -0.01517719f, 0.09213840f, 
    -0.02366230f, 0.19707298f, -0.14470038f, 0.14966957f, -0.00621693f, -0.04001242f, -0.00748008f, 0.08021868f, 
    0.03433422f, 0.13982908f, -0.03279065f, -0.03807152f, -0.05132847f, 0.16358745f, -0.21987391f, 0.04334056f, 
    0.00610263f, 0.02849911f, -0.01312622f, 0.01850597f, -0.02243023f, 0.01954251f, -0.00065432f, 0.01983618f, 
    -0.17858241f, -0.28188342f, 0.00373248f, 0.25533727f, 0.03560207f, -0.10904531f, 0.08380398f, 0.06881448f, 
    -0.05502615f, -0.05207782f, 0.11562862f, 0.14698951f, 0.36913586f, 0.04362534f, -0.03610511f, -0.01822729f, 
    0.05762743f, 0.09243312f, 0.06043452f, 0.14950810f, -0.04152256f, 0.02369737f, -0.09092129f, 0.03870050f, 
    0.48011985f, -0.07274515f, -0.18264252f, 0.06725737f, 0.01757330f, -0.03410202f, 0.09703121f, -0.00100431f, 
    0.06563791f, -0.12407966f, -0.01639739f, -0.02882291f, 0.03500617f, -0.09658998f, -0.06054057f, -0.33514836f, 
    0.00828800f, 0.03766301f, -0.44699311f, 0.30614692f, 0.07761579f, -0.19781549f, -0.26268676f, -0.15298195f, 
    0.12840424f, -0.12546331f, -0.08215507f, 0.01275034f, 0.06290250f, -0.04573291f, -0.10061028f, -0.10207809f, 
    -0.01156254f, -0.14229845f, -0.12503745f, 0.05741918f, -0.18002681f, 0.42747310f, -0.17551804f, -0.08312058f, 
    0.02947894f, -0.09207632f, 0.08914374f, -0.15173194f, 0.05227632f, -0.03910023f, 0.06714056f, -0.03467951f, 
    0.16977854f, -0.04999401f, 0.01594218f, 0.07354816f, 0.10380276f, 0.06666850f, 0.02166878f, 0.11878148f, 
    0.00764380f, -0.05782113f, -0.07026072f, -0.09428686f, 0.23263757f, -0.25832561f, 0.44054326f, 0.01267363f, 
    -0.08012640f, -0.08626375f, -0.18678609f, 0.14297026f, 0.00824774f, -0.08182500f, -0.02051698f, -0.10851365f, 
    0.35406852f, -0.04947447f, 0.16351356f, -0.03526247f, 0.00557915f, -0.05310035f, 0.09498867f, 0.06774182f, 
    0.09510182f, 0.19662254f, 0.01237217f, -0.02844670f, 0.05700417f, -0.14157504f, 0.21721958f, -0.11971459f, 
    0.11892766f, -0.06287675f, -0.21375991f, -0.00683153f, 0.09154303f, -0.13576064f, 0.03682666f, -0.07449894f, 
    0.00043080f, -0.12175930f, 0.15007514f, 0.03342282f, -0.03335902f, -0.07586686f, -0.08241471f, 0.09129561f, 
    0.21054874f, 0.08420501f, 0.23773359f, -0.02114671f, 0.40209964f, 0.18427584f, -0.10356922f, 0.16751355f, 
    -0.12696916f, 0.06729836f, 0.10385817f, 0.05281200f, 0.04380819f, 0.09189726f, 0.01194840f, -0.16430022f, 
    0.15262686f, 0.17561871f, 0.01905508f, 0.22312471f, -0.02626976f, 0.08777434f, 0.14511372f, -0.01779622f, 
    0.07487312f, 0.02734062f, -0.06834774f, -0.08046785f, 0.18865535f, 0.16150387f, 0.18924734f, -0.10218432f, 
    -0.11183472f, -0.09477577f, -0.01812366f, -0.02714971f, 0.04107265f, -0.01927705f, 0.15719749f, -0.10625312f, 
    -0.44296706f, 0.03392434f, 0.11910970f, 0.18506895f, 0.05150096f, 0.01812439f, -0.10286444f, 0.06952492f, 
    0.09068906f, 0.07505091f, 0.13858503f, 0.00505381f, -0.18595083f, 0.06455304f, -0.01401888f, 0.10146698f, 
    0.05059282f, -0.02359795f, -0.06084682f, -0.05013173f, 0.01017035f, 0.17047037f, -0.16509046f, -0.08475603f, 
    -0.20212851f, 0.10342088f, -0.10548881f, -0.01404069f, 0.07826030f, 0.01293629f, -0.09665436f, 0.04785764f, 
    -0.03076783f, 0.05141067f, 0.17575195f, 0.13145761f, 0.04260846f, 0.24089608f, 0.10474534f, -0.20236202f, 
    0.03532701f, 0.00593785f, -0.10948056f, 0.00240881f, -0.19972503f, -0.12639470f, 0.03179855f, -0.10341357f, 
    0.13966540f, -0.13658008f, -0.03983258f, 0.00119644f, -0.11283617f, -0.02433488f, -0.17896901f, -0.03919339f, 
    0.06370522f, 0.00670377f, 0.05955490f, -0.13274197f, 0.01907361f, 0.32113394f, 0.01746168f, 0.07633682f, 
    0.06491797f, -0.19755639f, -0.15636295f, 0.06268487f, -0.04707177f, -0.00471345f, -0.00609284f, -0.18991995f, 
    0.01398581f, 0.00462160f, 0.21754284f, -0.13665526f, -0.04824240f, -0.16519205f, -0.12570916f, -0.06092720f, 
    0.08571577f, -0.14760691f, -0.13494235f, -0.14498201f, -0.00620237f, 0.28950378f, 0.18797845f, 0.17060542f, 
    0.03426950f, 0.17795837f, -0.02807344f, 0.01503373f, 0.10119522f, -0.04904538f, 0.05117390f, -0.00151013f, 
    -0.02956672f, 0.04159256f, -0.04107697f, -0.15405904f, 0.06328518f, -0.15700382f, -0.11777657f, 0.02530882f, 
    -0.00416429f, 0.01122956f, 0.07257527f, 0.14045177f, 0.15940714f, -0.30444700f, 0.03482522f, 0.17979468f, 
    0.04247342f, -0.23825236f, 0.00346297f, 0.24001840f, -0.15618341f, 0.07311327f, 0.03544724f, -0.07080936f, 
    0.08995845f, -0.23308197f, -0.04964923f, 0.10476350f, 0.18340223f, -0.04020153f, 0.26979274f, 0.06774329f, 
    0.23086537f, 0.23415437f, 0.00596824f, 0.31738475f, 0.18036078f, -0.12020408f, 0.02685422f, -0.03494529f, 
    0.15173972f, -0.33556187f, -0.14489177f, 0.05421990f, -0.05387421f, -0.21441638f, -0.07704706f, 0.07860880f, 
    0.37781745f, 0.15809879f, -0.00557283f, 0.26861998f, 0.00654906f, 0.15984124f, -0.01293576f, -0.02351154f, 
    -0.00392259f, 0.08790951f, 0.12519789f, 0.04584979f, 0.30885282f, 0.09093112f, 0.20705731f, 0.27201483f, 
    0.06676935f, 0.03082270f, -0.01167308f, 0.17617118f, -0.14169046f, 0.13630891f, -0.09673193f, -0.22797735f, 
    0.05654340f, -0.05844213f, -0.11576491f, 0.00507885f, 0.04581386f, 0.23373763f, -0.03895470f, -0.19563486f, 
    0.04293836f, -0.10674661f, 0.05553913f, -0.19786116f, -0.00009549f, -0.05420624f, 0.09780499f, 0.11660340f, 
    -0.01629469f, -0.13611950f, 0.04569416f, 0.21370493f, -0.02579188f, 0.09300667f, 0.08886784f, -0.02512692f, 
    0.32581571f, -0.06671745f, -0.09190763f, -0.27700385f, 0.36926395f, -0.09333584f, -0.12879422f, 0.04298083f, 
    0.02564185f, 0.12840933f, -0.01607926f, -0.00253505f, 0.28302619f, 0.10556573f, -0.23570123f, 0.15633082f, 
    -0.01587890f, 0.01241881f, 0.01013538f, -0.13227531f, 0.07042345f, 0.10696951f, -0.10119317f, 0.04427994f, 
    0.03693986f, 0.02569805f, -0.02748564f, 0.04507897f, -0.07289415f, -0.07174927f, 0.04094077f, 0.01064812f, 
    -0.04188020f, -0.01174049f, -0.03540230f, -0.07475410f, -0.01739419f, 0.00469637f, 0.06374874f, 0.02414481f, 
    -0.04825034f, 0.02899423f, 0.03355026f, -0.06085484f, 0.03790360f, -0.06450481f, 0.00303214f, -0.10267094f, 
    -0.05602409f, 0.04311249f, -0.00487632f, 0.06650774f, -0.03713881f, -0.06314364f, 0.03681372f, 0.02503158f, 
    -0.10517171f, -0.08029481f, 0.03240598f, -0.01334537f, -0.05258595f, -0.02778357f, -0.07383598f, 0.01294986f, 
    -0.08810578f, -0.05345655f, -0.02892566f, -0.05236719f, -0.02647161f, -0.05523797f, 0.02562022f, -0.02080063f, 
    -0.07417581f, -0.03653857f, -0.01734609f, -0.08864328f, -0.02327192f, 0.03603842f, 0.02035146f, 0.01312898f, 
    -0.04991495f, 0.03397716f, 0.02405681f, 0.03422434f, 0.00009490f, -0.02675353f, 0.02993066f, -0.07309785f, 
    0.02383964f, 0.01749428f, 0.06046849f, -0.03520191f, -0.03611988f, -0.08610385f, -0.01965142f, 0.04514079f, 
    0.02348404f, -0.00047211f, -0.04869399f, -0.01512812f, -0.04069404f, -0.08387534f, -0.07444926f, -0.05312326f, 
    -0.08206856f, -0.07413948f, -0.03490921f, -0.00977076f, -0.00042359f, -0.02526062f, -0.00747335f, 0.03061527f, 
    -0.04736642f, 0.01555209f, -0.10551613f, 0.05226750f, 0.00906515f, 0.02228291f, -0.06293375f, -0.08367180f, 
    -0.07953697f, 0.04443737f, -0.02657688f, 0.00172140f, 0.01707027f, -0.02739919f, 0.00685159f, -0.00249812f, 
    -0.04845520f, 0.00303491f, -0.10261746f, -0.02770114f, -0.06437888f, 0.02005312f, 0.04119574f, -0.07405835f, 
    -0.04244118f, 0.01094745f, 0.02727604f, 0.03120665f, -0.04263189f, -0.00372573f, -0.01733710f, -0.06375810f, 
    0.02737805f, -0.03960773f, -0.02208426f, -0.06602739f, -0.03701157f, -0.01093481f, 0.02159388f, -0.09204298f, 
    -0.04047216f, -0.06483604f, -0.04396601f, -0.04887797f, -0.05935312f, 0.00043184f, -0.05851562f, -0.01565554f, 
    -0.05804771f, -0.00553830f, 0.03836782f, -0.03766127f, -0.03308885f, 0.01260572f, 0.05502048f, -0.01289344f, 
    -0.01705252f, -0.00776950f, -0.01483416f, 0.06048757f, -0.04186621f, -0.05528072f, -0.02919327f, 0.02431711f, 
    -0.03802967f, 0.00722491f, -0.02960072f, -0.09094730f, -0.07986866f, 0.00176823f, 0.04354244f, -0.02440737f, 
    0.00523749f, -0.01354173f, 0.03382374f, -0.02358781f, -0.00407252f, -0.03022939f, 0.04197991f, 0.02335680f, 
    0.07938825f, 0.06220338f, 0.02061958f, -0.02017951f, 0.01245006f, -0.00268101f, -0.06741675f, 0.00757239f, 
    -0.08564924f, 0.00996931f, 0.02503564f, -0.08139685f, -0.06937878f, -0.08630324f, 0.00890106f, 0.05614248f, 
    0.01755837f, -0.01854396f, 0.01410870f, -0.11285251f, -0.01631027f, 0.02624848f, -0.08316219f, -0.00252196f, 
    0.28196585f, -0.12312274f, 0.00434493f, -0.28526229f, -0.08108760f, -0.00506105f, -0.10176551f, -0.13662626f, 
    -0.01304784f, -0.05961064f, -0.14307126f, -0.17213060f, -0.25937375f, 0.24714027f, 0.02115662f, -0.00680309f, 
    -0.09140848f, -0.13759419f, 0.03471534f, -0.11187743f, 0.02398978f, 0.08033718f, 0.00748945f, 0.04460170f, 
    -0.22832023f, 0.12343931f, 0.22343299f, 0.11313485f, -0.02835415f, -0.04957346f, -0.01938701f, -0.09111409f, 
    0.15750119f, -0.07919885f, 0.14710656f, -0.03061965f, 0.12034683f, 0.18264137f, -0.35122800f, 0.28770500f, 
    0.09226606f, 0.14274833f, 0.20639774f, -0.18327561f, 0.16843119f, 0.14612849f, 0.20724295f, 0.26654682f, 
    0.00653674f, -0.02627492f, 0.15613352f, -0.27623722f, -0.12524612f, 0.18057491f, -0.04873548f, 0.00701445f, 
    0.25466269f, 0.24532120f, 0.01180116f, 0.23662238f, 0.05760169f, 0.13377471f, 0.18469472f, 0.18379180f, 
    -0.03287876f, 0.14509790f, -0.12572080f, 0.18813521f, -0.11203725f, -0.01974504f, -0.14477114f, -0.00359601f, 
    0.10729969f, 0.13396963f, -0.01284433f, 0.09148639f, 0.08349179f, 0.00610469f, -0.04111858f, -0.17459711f, 
    0.24642290f, 0.02496202f, 0.08592441f, 0.12202592f, 0.07977352f, -0.09090663f, 0.08413549f, 0.27853745f, 
    0.04540529f, -0.06505322f, -0.04920394f, -0.13424259f, 0.04781257f, -0.09844647f, 0.03269335f, 0.11933383f, 
    0.03759092f, 0.00098734f, -0.03211300f, 0.08313689f, -0.06120585f, -0.08041274f, 0.00885498f, -0.11545731f, 
    0.07856120f, -0.10817422f, 0.18254074f, 0.15774894f, 0.15351862f, 0.15824014f, -0.15997882f, 0.07593953f, 
    0.10018659f, -0.02831048f, 0.19689822f, -0.07058614f, 0.02320888f, 0.11554949f, -0.04834821f, 0.08213160f, 
    -0.11459514f, 0.13457836f, -0.09907561f, -0.03065141f, 0.13429403f, 0.00162820f, -0.09596843f, -0.17489387f, 
    -0.18216944f, -0.13911439f, -0.06269781f, 0.05936731f, -0.09276264f, 0.26502860f, 0.21509306f, -0.11477262f, 
    0.06697027f, -0.00224036f, 0.07414223f, 0.24282318f, -0.05021829f, 0.03229587f, 0.02170905f, 0.09311177f, 
    -0.11129402f, 0.05171629f, -0.14449960f, -0.03460741f, -0.00622038f, -0.15752819f, -0.09898952f, 0.17944911f, 
    0.15322387f, 0.14152934f, -0.11071508f, -0.01675426f, -0.08811901f, 0.08301790f, -0.07433540f, 0.04234487f, 
    0.14341740f, -0.01730776f, 0.15962096f, 0.19479065f, -0.12036277f, -0.13998954f, -0.00992864f, -0.01685055f, 
    0.63421565f, -0.21059974f, -0.28877211f, -0.06759481f, 0.11991893f, -0.24160546f, -0.02452963f, -0.22021450f, 
    0.10153633f, 0.05860107f, -0.07371084f, 0.09777764f, 0.41493809f, 0.08296615f, -0.11767902f, 0.05351769f, 
    -0.03406255f, -0.07134922f, -0.00877126f, -0.12026767f, -0.09045342f, -0.06138184f, -0.00580445f, 0.02398189f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15193199f, -0.25665632f, 0.22200471f, 0.22238235f, 0.04504686f, 0.18906385f, -0.02712650f, 0.04316122f, 
    -0.08685357f, 0.27170241f, 0.05956460f, 0.02600498f, 0.23270634f, 0.22910865f, -0.01955873f, 0.15623838f, 
    0.09038639f, 0.03650127f, -0.02954281f, -0.15884121f, 0.10242165f, 0.05963402f, 0.05117308f, 0.31258991f, 
    0.02453701f, 0.02376882f, -0.14430842f, -0.01767783f, -0.07826957f, 0.04905810f, 0.00205745f, 0.19702122f, 
    -0.01261299f, 0.01740969f, 0.15513502f, 0.12327065f, 0.15163372f, 0.07299859f, 0.02245654f, 0.08895929f, 
    -0.07262899f, 0.07368030f, 0.15084100f, 0.16942513f, -0.10290822f, 0.00752249f, 0.06758761f, 0.17279877f, 
    0.01048219f, 0.29516461f, 0.19921137f, 0.03614279f, 0.08706073f, 0.00898973f, 0.13070157f, 0.09051228f, 
    -0.05808407f, 0.15851893f, 0.20817149f, -0.10263170f, 0.08120780f, -0.01010115f, -0.00737180f, -0.03565047f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.13895324f, 0.01445468f, 0.17485218f, -0.05125756f, 0.18502045f, -0.07597101f, -0.25313780f, -0.16355161f, 
    0.21722016f, -0.02039548f, 0.32648793f, 0.28331107f, 0.01364374f, -0.00062780f, -0.07543729f, 0.17261356f, 
    -0.20640843f, 0.11565358f, 0.26580355f, -0.14386187f, 0.00859190f, 0.02423535f, -0.05398753f, -0.02118851f, 
    -0.16193457f, 0.06468689f, 0.07808356f, 0.10000826f, -0.01711636f, -0.39238030f, 0.09651749f, -0.10109270f, 
    0.13369693f, 0.14243832f, -0.20065919f, 0.18577465f, 0.13697407f, 0.18819402f, 0.08008758f, 0.08584282f, 
    -0.08557534f, 0.10149939f, -0.01810440f, -0.10626870f, -0.01894304f, -0.03110652f, -0.17483252f, -0.04286770f, 
    0.17447363f, 0.11441454f, 0.25401285f, -0.08151957f, 0.08849866f, -0.06217298f, -0.14418490f, -0.19564299f, 
    -0.00790888f, -0.18630528f, 0.05593437f, 0.16138805f, -0.04334216f, -0.01904514f, 0.07348672f, 0.00554703f, 
    0.08843201f, -0.25476781f, 0.20819752f, 0.32314971f, -0.14606372f, 0.08027748f, -0.02608855f, 0.02660029f, 
    -0.15320452f, 0.26408666f, 0.09937777f, -0.12307322f, 0.12294604f, 0.36226094f, -0.03641978f, 0.36024854f, 
    0.18664436f, 0.15047689f, -0.11782610f, -0.02371567f, 0.30755964f, -0.19390853f, 0.09477542f, 0.00042348f, 
    -0.10214794f, -0.00265974f, -0.23228696f, -0.02565645f, -0.02746665f, 0.23434050f, -0.09292606f, -0.09879199f, 
    -0.02032744f, -0.22428821f, -0.10719002f, 0.14698695f, -0.16824909f, 0.41406205f, 0.04411795f, -0.18095456f, 
    -0.01149735f, 0.19679065f, 0.16896276f, -0.05418495f, -0.03114099f, 0.03469844f, -0.26888150f, 0.05903234f, 
    -0.10807569f, 0.07912827f, -0.07283944f, -0.00275179f, 0.16563407f, -0.07093260f, 0.12959784f, 0.36913311f, 
    0.05707508f, -0.10868750f, 0.12252767f, -0.15960020f, -0.11722152f, 0.02045480f, 0.07681813f, 0.23220599f, 
    0.07727427f, -0.03601184f, 0.08472405f, -0.00740526f, 0.18236938f, 0.02047520f, 0.02627322f, -0.13741040f, 
    0.11115942f, -0.00138950f, 0.06127362f, 0.17534047f, 0.04279326f, -0.09271064f, -0.09860525f, -0.32898951f, 
    0.34910250f, -0.06680416f, -0.33933410f, -0.23719518f, 0.11119386f, -0.05341529f, -0.12743562f, 0.07875456f, 
    -0.22239538f, 0.04362429f, -0.22473828f, 0.03769806f, -0.11638043f, -0.33004162f, 0.12167229f, -0.00855183f, 
    -0.17069948f, -0.07832513f, 0.15926817f, -0.05676896f, 0.15505612f, -0.05078940f, -0.10291435f, 0.13636534f, 
    -0.03775514f, -0.08665448f, -0.26311240f, 0.00952742f, 0.20091878f, -0.09938662f, 0.07432221f, -0.06981286f, 
    0.01509779f, 0.00574508f, 0.23029979f, -0.07719590f, 0.01131965f, 0.16485126f, 0.25743732f, 0.13662207f, 
    -0.05200906f, -0.24084114f, 0.02314441f, 0.15953299f, 0.00082743f, 0.17458272f, 0.10761685f, 0.06085593f, 
    -0.25895497f, -0.10402270f, 0.12639153f, 0.07287357f, 0.09072341f, 0.15286998f, 0.01665425f, -0.12558003f, 
    -0.08782604f, 0.01384499f, -0.15378663f, 0.07000145f, 0.03368488f, 0.21169913f, -0.01969729f, -0.10298029f, 
    0.05510680f, -0.04117907f, -0.16300972f, 0.03216458f, 0.08680753f, 0.08583549f, -0.00448509f, 0.06943032f, 
    0.02698263f, 0.22104651f, -0.10328883f, -0.07688750f, -0.10250735f, -0.10645163f, -0.08287518f, 0.22160372f, 
    0.09639142f, 0.02907359f, 0.13372387f, -0.10322192f, 0.43479407f, 0.08948009f, 0.03319414f, -0.06138626f, 
    -0.00543272f, 0.08570461f, -0.11733785f, 0.01444332f, -0.28715688f, 0.10005368f, 0.12164278f, 0.34326905f, 
    0.12092541f, 0.15749949f, 0.22174214f, -0.02855377f, 0.09238134f, -0.15901589f, 0.05413494f, -0.15701896f, 
    -0.06263527f, 0.15181793f, 0.10801099f, 0.08405645f, -0.17845492f, -0.12168971f, 0.01944070f, 0.17225884f, 
    -0.08146824f, -0.11253098f, 0.13378541f, -0.07718865f, -0.02986971f, -0.05378649f, 0.13936888f, -0.22979601f, 
    -0.24226493f, -0.24087483f, 0.07644492f, -0.39733854f, 0.11304410f, 0.01945647f, -0.04668371f, 0.37880814f, 
    -0.17120765f, 0.00019142f, 0.31196281f, 0.14382133f, 0.21114364f, 0.02011571f, 0.00679349f, 0.03009980f, 
    -0.46034640f, -0.07878194f, -0.33439776f, 0.05880807f, 0.11925659f, 0.02834548f, 0.10389104f, 0.22252442f, 
    0.08834512f, 0.20377649f, -0.80133921f, 0.19755414f, -0.02596228f, 0.26647437f, 0.11494738f, -0.07635414f, 
    0.02798195f, -0.25308985f, 0.19748367f, 0.09392160f, 0.19671033f, 0.11042035f, 0.06229765f, 0.37048686f, 
    0.04925470f, -0.14580528f, 0.02755479f, 0.00115328f, 0.13108967f, 0.06969264f, -0.12122909f, 0.02015671f, 
    -0.12993309f, 0.10297590f, 0.01801859f, -0.08491574f, -0.03530515f, 0.00683938f, -0.05308154f, 0.27553448f, 
    0.41842699f, 0.03164499f, -0.04269380f, 0.03346289f, 0.04630595f, -0.02240927f, 0.00139156f, 0.11534410f, 
    0.10318452f, 0.10413662f, 0.20165427f, 0.18562426f, 0.12091421f, -0.27458298f, 0.04909580f, 0.09706590f, 
    -0.06703570f, 0.38293490f, -0.05165954f, 0.21867855f, 0.15178151f, 0.07332452f, 0.02556260f, -0.19799225f, 
    0.02929758f, 0.04425497f, 0.07977627f, 0.11075184f, 0.03233128f, -0.29783651f, 0.01536405f, -0.17161492f, 
    -0.10961494f, -0.02945180f, -0.15163484f, 0.18324393f, -0.28235883f, 0.24917719f, 0.08817014f, -0.24198796f, 
    0.05304715f, 0.00441892f, 0.02042842f, -0.16624366f, 0.43438768f, 0.08447322f, 0.00279325f, -0.32563767f, 
    -0.15010168f, -0.30191350f, -0.13243704f, 0.06715921f, 0.06040860f, 0.04510029f, -0.19993921f, 0.25203076f, 
    -0.10897982f, -0.28916138f, 0.20678012f, 0.26693976f, 0.12505591f, 0.39963052f, -0.08186114f, 0.28157496f, 
    0.20065358f, 0.25137055f, 0.01408022f, 0.09162273f, -0.06569346f, 0.03620097f, -0.02589755f, 0.10830970f, 
    0.41715577f, 0.00076774f, 0.15994602f, 0.38340011f, -0.30131084f, 0.09586351f, -0.05087675f, 0.05936613f, 
    -0.05136099f, 0.09035933f, 0.34294730f, 0.06595574f, -0.12976700f, 0.08266822f, 0.10059822f, -0.25973848f, 
    0.16683561f, 0.24134634f, 0.23987712f, 0.00029616f, 0.08432364f, -0.06852342f, -0.10936170f, -0.09606794f, 
    0.03772579f, -0.00927873f, 0.26572403f, 0.06526533f, 0.23763445f, -0.09609459f, -0.01234497f, 0.09879891f, 
    0.03817311f, 0.23367171f, -0.07051712f, -0.10605236f, 0.16528372f, 0.06116731f, 0.00020771f, 0.13513513f, 
    -0.25264508f, 0.10798965f, 0.07488557f, 0.23482713f, -0.20521370f, 0.13009512f, -0.11154009f, -0.17455840f, 
    -0.08555923f, -0.02588238f, -0.09495501f, 0.32670233f, -0.22437245f, -0.13972387f, -0.05877657f, 0.08287520f, 
    -0.13038206f, -0.03780488f, 0.25357634f, 0.13899761f, 0.11276442f, 0.18792449f, -0.02137369f, -0.10138370f, 
    0.00523078f, 0.15609103f, -0.03646057f, 0.23262359f, 0.13387680f, 0.08116016f, 0.13501853f, 0.15947554f, 
    -0.06147540f, 0.09210299f, 0.20317687f, -0.28233492f, -0.04434157f, 0.10376787f, 0.03471594f, 0.24397735f, 
    -0.06896701f, 0.11228259f, -0.01064280f, 0.09686736f, -0.11064634f, -0.05680766f, 0.02986308f, -0.09561875f, 
    -0.00803610f, -0.00067047f, 0.26162454f, -0.02306522f, 0.49040687f, 0.05071976f, -0.04571329f, -0.03138416f, 
    -0.06625851f, -0.02345704f, -0.11925140f, -0.02420825f, -0.25866663f, 0.01776366f, 0.15592630f, 0.03019085f, 
    0.10085864f, 0.38409343f, 0.10942884f, 0.08257902f, 0.02937095f, -0.21633659f, 0.09058963f, -0.28256556f, 
    0.04285004f, 0.18706834f, -0.12000622f, -0.05619877f, -0.10787269f, -0.14209621f, -0.02537877f, 0.02224991f, 
    -0.01911844f, -0.11080805f, 0.16662753f, 0.33169997f, 0.14199018f, 0.33323810f, -0.00090552f, 0.13939609f, 
    0.04434479f, 0.18950740f, 0.15754965f, 0.07185194f, -0.00216947f, 0.06292410f, 0.09257100f, 0.20053327f, 
    0.02290196f, 0.40701154f, -0.11803915f, -0.29901579f, -0.09337126f, -0.03684256f, -0.09788453f, -0.05039293f, 
    0.11203034f, -0.17763346f, -0.00892958f, 0.07716879f, -0.05305884f, 0.05412764f, -0.10306332f, -0.11277735f, 
    -0.04341250f, -0.14715454f, 0.36044392f, 0.11293505f, 0.39972523f, 0.00801018f, -0.06976952f, -0.24505258f, 
    0.00687361f, 0.06637506f, 0.15025865f, 0.10636608f, -0.05604003f, -0.00548642f, -0.10350823f, 0.28817150f, 
    -0.44051272f, 0.12301146f, -0.14798918f, 0.11201552f, -0.08110667f, -0.17321835f, 0.00369191f, -0.00888037f, 
    -0.11288080f, 0.08146827f, -0.08694475f, 0.14597425f, -0.09010078f, -0.03821602f, 0.10339074f, -0.03251684f, 
    -0.03133027f, -0.10826105f, -0.06428354f, 0.02910850f, -0.10386766f, -0.12924089f, -0.02717065f, 0.09318352f, 
    0.06748853f, -0.09059788f, 0.09681395f, -0.04768724f, 0.00007012f, -0.03582034f, 0.03584765f, 0.04094831f, 
    -0.08263390f, -0.10419795f, -0.00726129f, -0.04485787f, -0.03746076f, -0.09690410f, -0.05108108f, -0.10133789f, 
    -0.13404132f, -0.05981119f, 0.00055451f, -0.00813870f, -0.06755471f, -0.10595918f, 0.11678283f, -0.03461108f, 
    -0.11791675f, -0.01932291f, -0.01911274f, -0.02124276f, -0.07171044f, 0.00019516f, 0.00976618f, -0.01701275f, 
    0.12400310f, -0.05326255f, 0.01944069f, -0.01776613f, -0.03468880f, -0.08607671f, -0.04352346f, -0.08740907f, 
    0.00425996f, -0.02922803f, 0.06802345f, -0.09727859f, -0.06419957f, -0.04413734f, -0.11730595f, -0.06397761f, 
    0.11504416f, 0.02202809f, -0.06045543f, -0.00089866f, 0.00931214f, -0.11454041f, 0.05860390f, -0.09711151f, 
    -0.18465768f, -0.30344239f, 0.10300258f, 0.15981947f, -0.01804935f, -0.00599412f, 0.00965447f, 0.03474159f, 
    -0.14148928f, 0.26275095f, 0.11555564f, -0.32246673f, 0.20502006f, 0.09745633f, -0.06067482f, -0.07343752f, 
    0.36411607f, 0.26305151f, -0.06621511f, 0.03280203f, 0.28710073f, -0.08979201f, 0.04067209f, 0.18143861f, 
    0.00370429f, -0.02326833f, -0.00455904f, 0.03287325f, -0.08879999f, 0.30879503f, -0.03488778f, -0.07543278f, 
    -0.19840002f, 0.00762996f, -0.04853252f, -0.01706672f, -0.29724929f, 0.10664728f, 0.13803403f, -0.02440935f, 
    -0.07863501f, 0.15152216f, 0.12308797f, 0.01720783f, -0.18130247f, 0.03050197f, 0.15840057f, -0.18479291f, 
    0.01423280f, 0.20057546f, 0.06494202f, -0.02415602f, 0.09080274f, -0.03268781f, 0.36249939f, 0.48561567f, 
    0.04057332f, -0.19504410f, 0.16663545f, -0.29998723f, 0.06549673f, 0.31995997f, -0.08521742f, 0.14104141f, 
    -0.07054669f, -0.38532832f, 0.20991024f, 0.15825766f, 0.07772802f, -0.05298359f, -0.12498157f, -0.16043703f, 
    0.05555572f, 0.08182903f, -0.08692519f, 0.31251490f, -0.02429490f, -0.04149672f, -0.04192259f, 0.02886727f, 
    -0.23277724f, 0.28797933f, -0.12735453f, -0.12714127f, -0.00531672f, 0.17520489f, 0.08111414f, 0.21948114f, 
    0.11505624f, 0.12796411f, -0.15310261f, 0.12823452f, -0.04050714f, -0.21421754f, -0.04438332f, 0.16389398f, 
    0.17420609f, 0.12457691f, 0.39094549f, 0.03052884f, 0.22484261f, 0.16366313f, -0.06041060f, 0.06541458f, 
    0.03681613f, 0.03123791f, 0.04670157f, -0.04640053f, -0.13486597f, 0.03406415f, -0.15216231f, 0.15607706f, 
    0.04829999f, 0.03266552f, 0.00021086f, 0.18553986f, -0.06151300f, -0.08194958f, 0.12224736f, -0.36599198f, 
    -0.00370048f, 0.13237189f, 0.06356258f, -0.10363762f, 0.02068764f, -0.09889212f, -0.04907118f, 0.10406616f, 
    -0.31148583f, 0.02312021f, -0.11499410f, -0.17136322f, 0.02748096f, -0.00382374f, 0.20815101f, -0.16951449f, 
    -0.29150116f, -0.17919819f, 0.07621511f, -0.40562111f, 0.11050957f, -0.08856028f, -0.12422990f, -0.01124388f, 
    0.21960136f, -0.02018103f, 0.09422822f, -0.01289149f, 0.03559627f, 0.10947091f, 0.01276659f, -0.01873082f, 
    -0.41613793f, -0.12730943f, -0.29831183f, -0.08317917f, 0.10542250f, -0.08998891f, 0.06744365f, 0.09189722f, 
    -0.22338073f, 0.08313119f, -0.35969818f, 0.07186464f, 0.07944245f, -0.00989307f, 0.12616588f, -0.18034337f, 
    0.03911420f, -0.11029713f, 0.04158571f, 0.23205213f, 0.20730554f, 0.10481537f, 0.04661735f, 0.28280553f, 
    0.12957072f, 0.01675939f, 0.09006032f, -0.00720298f, 0.01895446f, 0.13606954f, 0.00873921f, 0.23113172f, 
    -0.10238616f, 0.03263364f, 0.17275444f, -0.24533209f, -0.05538825f, 0.09875223f, 0.09633387f, 0.18403506f, 
    0.17212309f, -0.01260696f, 0.25752437f, 0.12440637f, 0.25648442f, 0.05426555f, 0.00010475f, -0.00738040f, 
    -0.16737124f, 0.10573022f, 0.32889417f, -0.22337657f, 0.21396410f, -0.21994661f, -0.03283649f, 0.18432246f, 
    -0.24125373f, -0.05259797f, 0.27916154f, -0.04030169f, -0.11385939f, 0.13058689f, 0.03039834f, 0.24712667f, 
    -0.19934487f, -0.17744958f, 0.11252300f, -0.04005660f, -0.07166023f, -0.19353737f, -0.10660380f, -0.00952479f, 
    0.00646868f, 0.13205016f, -0.33743006f, 0.18193440f, -0.18246059f, 0.20145504f, 0.03698269f, -0.07045091f, 
    -0.10085499f, -0.10781118f, -0.01157830f, 0.05123749f, 0.07140685f, 0.03741208f, -0.12491994f, 0.00388692f, 
    0.17084818f, -0.10628465f, 0.14531577f, -0.13151614f, -0.08623593f, -0.23263188f, 0.06517467f, -0.00426693f, 
    -0.08514775f, 0.00918171f, 0.05148797f, 0.06444657f, -0.11544087f, 0.24257258f, 0.08722708f, -0.02063086f, 
    0.00068803f, 0.07100710f, 0.09202148f, -0.20384468f, 0.26966736f, 0.06036573f, 0.18019095f, -0.05565178f, 
    0.21926644f, -0.10913836f, 0.34270597f, 0.03368239f, -0.04298500f, -0.08062954f, 0.08856956f, -0.27313182f, 
    -0.06214792f, 0.32118312f, 0.19041519f, 0.21381587f, 0.00764437f, 0.16367191f, -0.05849618f, -0.11327778f, 
    0.31653905f, -0.19877455f, 0.25445357f, 0.06806692f, -0.02507484f, 0.11471336f, -0.00554104f, -0.01285850f, 
    0.06866232f, 0.19048500f, 0.30931965f, -0.16220739f, 0.34669122f, -0.06096504f, -0.09298281f, -0.14521341f, 
    -0.00651135f, 0.08158083f, -0.00258545f, -0.04420889f, 0.12813237f, 0.00853351f, 0.06127621f, 0.03316432f, 
    -0.01570740f, -0.15443200f, -0.20458096f, 0.15643710f, -0.32564867f, 0.02291663f, -0.20891364f, -0.05705339f, 
    -0.07245550f, 0.15308243f, 0.10060202f, 0.20029801f, 0.04735291f, 0.09278691f, 0.13376851f, 0.12876619f, 
    0.26865703f, -0.04481709f, 0.09945602f, 0.07954776f, -0.18072398f, -0.20051086f, -0.04575394f, 0.16190290f, 
    0.05919442f, 0.02961189f, -0.21831116f, -0.03128455f, -0.02806338f, -0.09033803f, 0.14981887f, 0.03645871f, 
    -0.05730569f, 0.12607501f, 0.39213014f, 0.21663617f, 0.16497388f, -0.03310664f, 0.02096593f, 0.08709493f, 
    0.10705949f, -0.01727601f, 0.14628941f, 0.05335101f, 0.02098105f, 0.06443804f, -0.00326491f, -0.11165719f, 
    0.06881779f, 0.00547032f, -0.19910771f, 0.06567029f, -0.24307989f, 0.22784120f, 0.03447300f, 0.17483310f, 
    -0.05989033f, 0.29284853f, -0.06766132f, 0.07317148f, -0.18524113f, 0.02293545f, 0.12499020f, -0.10415862f, 
    0.33876348f, -0.03173980f, -0.00428081f, 0.17199215f, 0.28791043f, 0.00999111f, -0.22191715f, 0.22611280f, 
    0.02153646f, 0.00899204f, 0.01235159f, -0.09596660f, 0.12229149f, -0.06033762f, 0.06089557f, 0.12017034f, 
    -0.20306911f, 0.09332484f, -0.14126174f, -0.27589330f, -0.14504357f, -0.15335782f, 0.16803594f, -0.28757542f, 
    -0.18773867f, -0.02964297f, 0.06275284f, -0.15242743f, 0.06891399f, 0.00851086f, -0.02927266f, -0.24242778f, 
    -0.05458665f, -0.15214458f, 0.14821564f, 0.06529205f, -0.19364035f, -0.03725760f, -0.02374616f, 0.17309673f, 
    0.09891327f, -0.25732833f, 0.21417034f, -0.01689114f, 0.06551528f, 0.10826378f, 0.07005109f, -0.09297043f, 
    -0.30784476f, 0.13588391f, -0.16005322f, 0.00269352f, -0.06042688f, 0.12550221f, 0.02338423f, 0.25476542f, 
    0.07475525f, 0.15837054f, 0.10427442f, 0.02507120f, -0.01972055f, -0.08242287f, 0.06922213f, -0.33219418f, 
    0.10090522f, -0.28383940f, -0.00568861f, -0.33202723f, -0.14133008f, -0.03155120f, -0.28826445f, 0.15439422f, 
    -0.07714705f, -0.19042039f, 0.21219075f, -0.19112857f, 0.11872663f, -0.03427471f, 0.04972050f, 0.30282083f, 
    -0.22702058f, 0.01753244f, -0.08364674f, -0.23487513f, 0.17346193f, -0.10261457f, 0.16959977f, -0.68486595f, 
    -0.17857566f, -0.11716965f, 0.02151768f, -0.52421403f, 0.11690143f, -0.07874042f, -0.06076052f, 0.10781880f, 
    0.09399817f, 0.24758969f, 0.50693130f, 0.03503297f, 0.23021062f, 0.12756965f, 0.01057285f, 0.05363604f, 
    -0.70532149f, 0.00181827f, -0.10761015f, -0.06361102f, -0.07544625f, -0.00160824f, 0.09800485f, 0.00837971f, 
    -0.11265673f, -0.02105662f, -0.75140435f, -0.10775987f, 0.23255903f, 0.07648052f, -0.04533806f, -0.11307056f, 
    -0.10022353f, 0.10170268f, 0.06016777f, 0.16946414f, 0.13684122f, 0.03037976f, 0.06190251f, -0.03179261f, 
    0.17643233f, 0.07655491f, -0.18227924f, 0.05344816f, 0.04123634f, 0.03288191f, -0.14906707f, 0.19875264f, 
    0.11255789f, -0.07167846f, 0.16694734f, -0.27557707f, -0.30200982f, -0.09964947f, 0.12768522f, 0.48202315f, 
    0.17145264f, -0.05320454f, 0.07357937f, 0.15433380f, -0.09903605f, 0.18467709f, 0.11857808f, 0.01686306f, 
    -0.24736348f, 0.16171184f, 0.34763065f, -0.14285320f, 0.18373814f, 0.00400368f, 0.06994674f, 0.02530318f, 
    0.00190559f, 0.36216009f, 0.10331963f, -0.09553815f, 0.10437617f, 0.12037219f, 0.10995524f, 0.09211210f, 
    0.21579444f, -0.03163528f, -0.05639314f, -0.03310076f, -0.07880478f, 0.10906041f, 0.00983782f, -0.07163017f, 
    -0.01463732f, 0.05505886f, 0.09906831f, 0.12000550f, -0.30304387f, 0.17085399f, -0.11985568f, -0.22649832f, 
    0.04252763f, 0.17537159f, 0.01003152f, -0.01080932f, 0.13771383f, -0.09825042f, 0.05128969f, -0.15004891f, 
    -0.21548513f, 0.02943625f, -0.10231601f, -0.00183075f, -0.10466021f, -0.10057093f, 0.33008069f, 0.27880758f, 
    0.06854077f, -0.23649895f, 0.14282750f, 0.09137139f, 0.13628912f, 0.47233286f, -0.03689728f, 0.26959443f, 
    0.46478465f, 0.05018567f, 0.04589636f, -0.16549717f, 0.09471064f, -0.11809580f, -0.27154383f, 0.29723060f, 
    0.16322310f, 0.07360332f, 0.18084249f, -0.04134766f, -0.08854645f, -0.29212093f, -0.07224289f, 0.21958797f, 
    0.02787415f, -0.01670702f, 0.46611270f, 0.05868425f, -0.16695601f, 0.11788484f, -0.04161264f, -0.38365313f, 
    0.31542811f, -0.11385587f, 0.24107796f, 0.03860053f, 0.04404269f, 0.09044828f, -0.03267031f, -0.36536300f, 
    -0.05860708f, -0.07454739f, -0.28815553f, 0.18560098f, -0.37059966f, 0.10935684f, -0.11366300f, -0.22017127f, 
    -0.10426578f, 0.18012871f, -0.15051278f, -0.18004693f, 0.33152634f, 0.02261403f, -0.51974964f, -0.37687105f, 
    0.03817929f, -0.09036902f, -0.17247781f, 0.22857477f, 0.06970376f, -0.19467007f, -0.29439339f, 0.28817931f, 
    0.00403287f, -0.16605869f, 0.01692232f, 0.30794728f, -0.04289232f, 0.31979170f, 0.08133596f, -0.06136104f, 
    -0.08423254f, 0.01970351f, 0.22415186f, 0.24123549f, 0.10612106f, 0.15246852f, -0.16125885f, -0.11686939f, 
    0.00435875f, 0.02112653f, 0.17027584f, -0.01475949f, 0.20948130f, 0.19978961f, 0.07140242f, 0.33332083f, 
    -0.23059186f, -0.04534125f, 0.24610576f, -0.25411138f, 0.12692173f, -0.03692181f, 0.00233911f, -0.04692254f, 
    -0.17277749f, 0.12946226f, 0.11190038f, 0.04300620f, -0.03041691f, -0.06836133f, 0.09622284f, -0.08538037f, 
    0.10063850f, 0.05592227f, 0.02169083f, 0.10710179f, 0.26277921f, 0.29271162f, -0.05291325f, 0.17444113f, 
    0.11888722f, -0.00299308f, 0.08731432f, -0.13154224f, -0.32394907f, -0.07752334f, -0.04217691f, 0.04761878f, 
    0.09924573f, 0.16921085f, 0.28000215f, -0.08752192f, 0.23963940f, -0.12480646f, -0.15250072f, -0.16837566f, 
    0.03790407f, 0.19141741f, 0.16824964f, -0.07772066f, -0.06061129f, 0.05386558f, -0.01995706f, -0.03572601f, 
    0.09369687f, -0.20937255f, 0.08426189f, -0.11348388f, 0.18500862f, 0.17739685f, 0.01884388f, -0.15160345f, 
    -0.17520270f, 0.12046517f, 0.26660857f, -0.11098254f, 0.05792247f, -0.05469041f, -0.07288402f, 0.14201200f, 
    -0.12230158f, 0.04360954f, 0.57482588f, -0.04626251f, 0.00648999f, 0.01418336f, 0.00839913f, 0.14513201f, 
    0.04563700f, -0.08857037f, 0.03759664f, -0.01173353f, -0.05329567f, 0.02601512f, -0.07479991f, -0.05904631f, 
    -0.10483893f, -0.04577129f, -0.33195111f, 0.22367845f, 0.00655216f, 0.14520907f, -0.07772423f, -0.05731410f, 
    0.07147780f, -0.20373416f, 0.17538355f, -0.10395864f, -0.06347879f, -0.12286276f, -0.03165910f, 0.00516482f, 
    0.16207066f, -0.16629100f, -0.03128189f, -0.09601275f, -0.10472102f, -0.27346259f, 0.04874370f, -0.04172225f, 
    0.10798179f, 0.14651604f, -0.00122577f, 0.14793894f, -0.07096429f, 0.14921115f, 0.13023333f, -0.03029085f, 
    0.08424016f, -0.07399843f, 0.18984869f, -0.04992003f, -0.24516059f, 0.15983519f, -0.09954523f, 0.03539660f, 
    -0.01585175f, -0.05395026f, -0.17054988f, -0.05283851f, -0.06370953f, -0.15295713f, 0.06267262f, -0.08360574f, 
    -0.05514908f, -0.18272115f, -0.07309160f, -0.21567962f, 0.18933463f, -0.00798935f, 0.05417543f, -0.13772818f, 
    -0.02172198f, -0.05093618f, 0.10395554f, -0.11967419f, 0.08726537f, -0.14658566f, -0.12002155f, -0.19174071f, 
    0.01247114f, -0.14323358f, -0.01787359f, 0.14321072f, -0.18491288f, 0.04505206f, 0.03917824f, -0.14515351f, 
    -0.12322161f, -0.07547680f, 0.11467656f, 0.10109258f, -0.17038211f, -0.05692616f, 0.00281111f, -0.03132347f, 
    -0.04699989f, 0.12575246f, -0.16558385f, -0.10452260f, 0.21812423f, 0.09031388f, -0.01754231f, -0.11716248f, 
    0.10455093f, -0.09349272f, 0.03139500f, 0.05991821f, 0.00624819f, -0.09373478f, -0.05812037f, 0.16720608f, 
    -0.00688921f, -0.00815408f, -0.09700108f, -0.13678104f, 0.09266413f, -0.13547792f, 0.05043235f, 0.00698873f, 
    -0.04785892f, 0.03744670f, 0.00890370f, -0.06579429f, 0.07522882f, 0.09946829f, -0.04144464f, -0.01966529f, 
    -0.04695875f, 0.05475236f, -0.10399753f, -0.02715657f, -0.07743558f, -0.00091938f, 0.08544020f, 0.01610313f, 
    -0.12654944f, -0.10541876f, -0.07299443f, 0.04212502f, -0.09965271f, -0.08219499f, 0.06992748f, 0.03655118f, 
    -0.05361714f, -0.00264718f, -0.03314606f, 0.03828069f, -0.08973335f, 0.03640428f, -0.11188295f, 0.03356200f, 
    -0.03778234f, -0.05781409f, -0.10076656f, 0.01100104f, -0.05952083f, 0.07087365f, -0.04509766f, -0.09320387f, 
    -0.06423521f, -0.13672814f, 0.02165141f, 0.05213280f, 0.07221310f, 0.00091669f, -0.08447132f, -0.09783210f, 
    -0.07492568f, 0.08738909f, 0.03756247f, 0.02973055f, -0.10264274f, 0.05524962f, -0.08196406f, -0.09026314f, 
    0.28215978f, -0.04929017f, -0.02318135f, -0.12202289f, 0.16660365f, 0.18381578f, -0.09343433f, -0.00604133f, 
    -0.01335354f, -0.14036606f, 0.34342879f, 0.25150102f, 0.07751970f, -0.26505187f, -0.06460128f, -0.01750472f, 
    0.33676961f, 0.12306817f, 0.04400683f, -0.12751509f, 0.18724062f, 0.04921236f, -0.02976319f, -0.16250786f, 
    0.18739419f, -0.16645063f, -0.00757676f, 0.08150472f, 0.08496635f, -0.03283630f, 0.10462180f, -0.13246436f, 
    -0.09018410f, -0.01353140f, -0.09688281f, 0.07425225f, -0.23059942f, -0.01890276f, 0.03096886f, -0.18223327f, 
    0.02586394f, 0.11140407f, -0.26608667f, -0.05995345f, 0.51862937f, -0.11351671f, -0.10346852f, 0.01567598f, 
    0.07266045f, -0.11707344f, -0.02552035f, -0.12669602f, 0.05163368f, 0.30505958f, 0.23788661f, 0.33967939f, 
    -0.05988487f, -0.55092263f, 0.15026805f, 0.12379368f, 0.02215659f, 0.34428549f, 0.06264780f, 0.20283599f, 
    0.17947373f, -0.12896265f, 0.14721479f, 0.02154172f, 0.05334815f, -0.09485678f, 0.05292093f, -0.14871120f, 
    0.13931710f, 0.09568927f, -0.01810156f, 0.15295708f, -0.06555976f, -0.25522700f, -0.07516333f, -0.17248008f, 
    0.09220754f, 0.08433742f, -0.16022313f, 0.12197312f, -0.01977366f, -0.14501078f, 0.09999244f, 0.08907036f, 
    -0.11615062f, 0.14673474f, -0.08583222f, -0.00793572f, 0.04822463f, -0.19472530f, -0.11636354f, -0.16033700f, 
    0.10267780f, -0.21622978f, -0.27326232f, -0.12328019f, 0.04316635f, 0.26934496f, -0.04873352f, 0.12703268f, 
    -0.04573049f, 0.12065336f, -0.27821174f, -0.11208994f, 0.18874627f, 0.06318830f, 0.11124641f, -0.11638771f, 
    0.36597291f, -0.03888942f, 0.24089395f, -0.03993885f, 0.43408963f, 0.12518255f, -0.05043403f, 0.21589850f, 
    0.08169969f, -0.32436788f, 0.16878782f, 0.01132301f, 0.13455671f, 0.19970840f, -0.00080174f, 0.01913454f, 
    -0.02622309f, -0.04268676f, -0.09258240f, -0.18040366f, -0.12179693f, 0.08423849f, 0.19937405f, 0.08004608f, 
    -0.01421681f, -0.10137741f, -0.30624497f, -0.02801910f, -0.11748885f, -0.09871403f, -0.05056499f, -0.29171383f, 
    0.42518637f, -0.17485583f, 0.04457762f, 0.24796741f, 0.12653451f, 0.35768384f, 0.07225393f, 0.03328766f, 
    0.25680849f, 0.02315669f, 0.04196072f, -0.09814574f, -0.07869807f, 0.47797313f, 0.05112614f, 0.06280918f, 
    0.21056552f, -0.16478172f, 0.35640329f, -0.29445276f, 0.24444754f, -0.24306165f, 0.10712852f, 0.03475741f, 
    -0.06994686f, 0.23831460f, -0.06063730f, 0.28926331f, 0.10454393f, 0.04143581f, 0.09820119f, 0.05486954f, 
    0.12240603f, -0.07327251f, -0.08974897f, 0.01538458f, -0.03746879f, 0.26877272f, 0.14342277f, 0.24626468f, 
    0.08012620f, 0.28408167f, 0.07776956f, 0.08373345f, 0.06056767f, -0.09241503f, -0.09882438f, 0.19178128f, 
    -0.11684556f, -0.20111732f, 0.20448646f, 0.16518100f, 0.07954062f, -0.02506582f, -0.09853113f, 0.09367902f, 
    0.07784784f, -0.05452490f, -0.22277017f, 0.09471767f, -0.12765962f, 0.20466937f, 0.05221174f, 0.00585153f, 
    0.13981654f, -0.11144813f, -0.14457014f, 0.00406597f, -0.01873368f, 0.06204571f, -0.09576504f, 0.22254016f, 
    0.09622966f, 0.26454896f, -0.24876246f, 0.08448124f, -0.10170989f, -0.17290510f, -0.09678327f, 0.32383850f, 
    0.18641086f, -0.06079032f, 0.20191060f, -0.02413511f, 0.04810854f, 0.06832603f, 0.10603026f, 0.06277867f, 
    0.05901344f, -0.08888591f, -0.28045976f, 0.17762336f, -0.00165487f, 0.07884000f, 0.08570728f, 0.18074372f, 
    0.11046205f, 0.23246312f, 0.28666270f, -0.03228399f, -0.02089521f, 0.07087865f, 0.08910303f, -0.22132643f, 
    0.03608519f, 0.21112236f, 0.02438646f, -0.09454405f, -0.11575089f, -0.10324805f, -0.10868325f, 0.01576103f, 
    0.13832772f, 0.15937017f, 0.07899132f, -0.09741367f, -0.06153119f, 0.24912092f, -0.07639360f, 0.14612503f, 
    0.31708965f, -0.01569202f, 0.05016986f, 0.26121879f, -0.13101517f, 0.09778452f, 0.03532454f, 0.00100117f, 
    0.15652029f, 0.27145398f, -0.15995875f, -0.28192067f, 0.05627066f, -0.10298350f, 0.06465773f, -0.25223249f, 
    0.28676453f, -0.04349018f, 0.13395181f, -0.00159683f, 0.10724451f, -0.10005081f, -0.08668615f, -0.02945405f, 
    0.03608697f, -0.19232154f, 0.20980376f, -0.13798757f, 0.39179495f, -0.27801508f, -0.05415013f, -0.06577250f, 
    0.10506009f, 0.12113811f, -0.05791773f, 0.07584991f, 0.11242941f, -0.06940626f, 0.00101643f, 0.08302031f, 
    -0.52612519f, 0.09497857f, -0.04535101f, 0.21809331f, -0.11912397f, 0.09697144f, -0.00583679f, -0.07846651f, 
    0.12160119f, -0.04533078f, -0.04082933f, 0.34533903f, 0.00799273f, -0.06423534f, -0.02395572f, 0.21376206f, 
    0.02438617f, -0.07243296f, -0.07951472f, -0.05942035f, -0.08636249f, -0.05980739f, 0.08871266f, -0.10893728f, 
    -0.10571995f, -0.02090496f, -0.04130549f, -0.03089224f, -0.08693553f, 0.06576221f, 0.01103277f, 0.06370652f, 
    0.09868748f, 0.01595402f, -0.14617091f, 0.02922329f, -0.05415745f, -0.09771922f, 0.09640487f, -0.12893525f, 
    0.00752238f, 0.01969605f, -0.15216550f, 0.09567022f, 0.10344373f, -0.09029640f, 0.09476304f, 0.00657400f, 
    0.05447205f, -0.11963934f, -0.07004356f, -0.00177172f, 0.06812492f, -0.13436249f, 0.09855980f, -0.12944549f, 
    0.01930824f, -0.12966663f, -0.08447690f, 0.02402157f, 0.07412823f, -0.10296648f, -0.02857985f, -0.15513098f, 
    0.07862861f, 0.03469909f, -0.07396255f, 0.06905007f, 0.12927887f, 0.01600917f, 0.09549341f, 0.04412464f, 
    0.08795190f, -0.07349966f, -0.09946688f, -0.04198074f, 0.01264459f, 0.05113655f, -0.09400104f, -0.02458179f, 
    0.04899731f, -0.15142757f, 0.14799234f, 0.15561119f, 0.31221440f, 0.04100093f, -0.16966237f, 0.21189609f, 
    0.01908612f, 0.11749663f, 0.11869359f, 0.18260105f, 0.02457933f, 0.07055698f, 0.03869444f, 0.11042210f, 
    0.21692497f, 0.01562806f, -0.45595899f, -0.11512522f, -0.07601533f, -0.19933598f, -0.04602993f, 0.02667972f, 
    0.00000074f, -0.16659738f, -0.20277858f, -0.06166405f, -0.05386844f, -0.35647303f, -0.02463060f, 0.01148355f, 
    -0.33861193f, -0.06483253f, -0.00596681f, 0.18989338f, 0.07306858f, 0.08371489f, -0.05794656f, -0.31290621f, 
    -0.02852983f, -0.06583811f, 0.02199476f, 0.00956221f, 0.28560808f, -0.00421541f, -0.09291872f, 0.24666882f, 
    -0.23665388f, 0.18917632f, 0.23739730f, 0.09392849f, 0.07987200f, 0.20092256f, 0.08107287f, 0.00817150f, 
    -0.10951229f, -0.23048608f, 0.16293974f, 0.31786895f, -0.06618419f, 0.15551522f, 0.12084515f, -0.28093955f, 
    0.02436293f, -0.12455752f, 0.08201611f, -0.06711711f, 0.03236652f, -0.05822944f, 0.06246608f, 0.11389910f, 
    0.02894802f, 0.02549688f, -0.25725654f, 0.02377613f, 0.01434634f, -0.04505752f, -0.06252369f, -0.29115978f, 
    0.18549050f, 0.04042701f, -0.07313795f, 0.13816440f, 0.21366072f, 0.18229088f, -0.12811793f, 0.08421462f, 
    -0.04242876f, -0.04557647f, -0.00779255f, 0.06247063f, 0.12010672f, 0.25435379f, 0.04908781f, 0.17725764f, 
    0.14837949f, -0.13136908f, 0.18568623f, -0.31081876f, 0.20727818f, -0.07695306f, -0.09999086f, 0.15066841f, 
    0.00300424f, -0.02345342f, -0.17874877f, 0.11702124f, -0.00718212f, 0.10676898f, 0.09764617f, 0.11188792f, 
    0.22808337f, -0.17271030f, 0.09412055f, 0.15179153f, -0.02162851f, 0.01270723f, -0.15202299f, 0.17937618f, 
    0.03190492f, 0.04140423f, 0.18201582f, -0.14589725f, 0.02784189f, 0.01521317f, -0.08378459f, 0.23197404f, 
    -0.06668980f, -0.12014060f, 0.05625253f, 0.17878661f, -0.14383800f, -0.24724542f, -0.03698294f, -0.00823067f, 
    -0.11342653f, 0.16192137f, -0.41302752f, -0.00032230f, 0.11019959f, 0.16065335f, -0.10220153f, 0.16821510f, 
    0.03699627f, -0.22709849f, -0.07000837f, 0.11486255f, 0.15521751f, 0.15630527f, 0.06140444f, 0.32977989f, 
    -0.12622501f, 0.37411755f, -0.16157500f, -0.05454384f, -0.09231295f, 0.05692051f, -0.11141310f, 0.29824883f, 
    0.22642259f, -0.08285466f, -0.02504872f, -0.13572811f, -0.13804948f, 0.14957821f, 0.07482103f, 0.12791850f, 
    -0.12416768f, 0.18006034f, -0.05467573f, 0.03081716f, -0.08595087f, 0.07370081f, 0.13398880f, -0.10414454f, 
    0.20048437f, 0.10477547f, 0.40001556f, -0.06028830f, 0.28412095f, -0.03916951f, 0.04366075f, -0.04261936f, 
    0.05526342f, 0.17421417f, 0.15878680f, -0.16043031f, -0.08338108f, -0.19356893f, 0.00786293f, -0.19447406f, 
    0.43429506f, -0.07447041f, 0.15240455f, -0.06246860f, -0.01731745f, -0.16932480f, -0.14646517f, 0.07122250f, 
    0.15916182f, 0.06925943f, -0.09634717f, 0.36412928f, -0.11931977f, 0.15596442f, 0.05287122f, -0.04182599f, 
    -0.19421542f, 0.05597733f, 0.06560760f, 0.11949124f, 0.01215435f, 0.22196731f, -0.05202750f, -0.05468984f, 
    0.13987994f, 0.35039210f, 0.13782348f, -0.07258259f, 0.04280559f, -0.13377289f, -0.08681678f, 0.00680419f, 
    0.20806263f, 0.02071288f, 0.01937332f, -0.08348084f, -0.02616819f, 0.24337481f, 0.04339766f, 0.15950575f, 
    -0.02821474f, 0.23747621f, -0.11903927f, -0.21860816f, 0.34052983f, 0.00278990f, -0.11500524f, -0.15725319f, 
    0.09581664f, -0.16191772f, -0.06562573f, 0.28606042f, 0.06875354f, -0.02654593f, -0.02007872f, -0.11482901f, 
    -0.07887554f, -0.13586502f, 0.13138208f, 0.03143864f, 0.09202165f, 0.12479100f, -0.03619234f, 0.11119219f, 
    -0.12147640f, 0.01547457f, -0.04176126f, 0.24187371f, -0.27297822f, 0.02994275f, -0.13500865f, 0.12553166f, 
    -0.20119023f, 0.10464297f, -0.13179299f, -0.04852803f, -0.13090055f, 0.48973814f, 0.00702916f, 0.45027277f, 
    0.28917849f, -0.26351848f, 0.08625688f, -0.13685243f, 0.26713705f, 0.10337596f, 0.03231074f, -0.14376949f, 
    -0.21380988f, 0.32780862f, -0.40620300f, 0.10023627f, -0.11963352f, 0.20051695f, -0.11264488f, 0.16007465f, 
    0.07199572f, -0.26668823f, -0.29574755f, 0.17206131f, -0.11847426f, 0.23859948f, 0.04098780f, 0.10164359f, 
    -0.12863450f, -0.11319092f, -0.01242815f, 0.16935989f, -0.17358996f, 0.06716730f, -0.04155611f, 0.20500532f, 
    0.03049480f, 0.15019003f, 0.29734185f, 0.00255179f, 0.33368862f, 0.23917629f, 0.07943113f, 0.17158486f, 
    -0.12402631f, -0.02074911f, 0.12912816f, -0.29464638f, -0.35766590f, -0.07281741f, -0.09659299f, -0.06204638f, 
    0.10200940f, -0.16938573f, -0.02837658f, -0.06938762f, -0.01374230f, -0.13676588f, -0.02801854f, 0.08112122f, 
    -0.04577270f, -0.00634797f, -0.12539980f, 0.10237970f, -0.12960832f, 0.05287798f, -0.12954260f, -0.15485819f, 
    0.11674608f, -0.12984157f, 0.01379377f, 0.01247644f, 0.06527612f, -0.13144757f, -0.03334052f, -0.10030298f, 
    0.00756532f, -0.13720149f, -0.12479077f, 0.01551670f, -0.11237876f, -0.07523491f, -0.00038797f, 0.01206212f, 
    0.02566542f, 0.06853522f, -0.07730496f, -0.12815420f, -0.01588313f, -0.01087616f, -0.09772232f, -0.07664066f, 
    0.09119721f, -0.12038902f, -0.17687230f, -0.06719936f, -0.00183209f, 0.11349127f, -0.02074061f, 0.06244264f, 
    -0.03895917f, 0.03733591f, 0.09183783f, -0.09582774f, 0.02334994f, -0.05555315f, 0.02044662f, -0.06042659f, 
    0.08138269f, 0.00022407f, -0.02467918f, 0.03390440f, 0.03411947f, 0.01129349f, 0.10986876f, -0.11260414f, 
    -0.19256738f, -0.29652393f, 0.19583604f, 0.08119413f, 0.19607194f, -0.08602792f, -0.05728709f, -0.00689337f, 
    -0.10309322f, 0.30899632f, -0.08168507f, 0.02970930f, 0.11664120f, 0.02331431f, 0.00933855f, -0.15833305f, 
    -0.29192623f, 0.46816391f, 0.12629063f, -0.01481438f, 0.16283450f, 0.12719984f, 0.03217527f, 0.11297676f, 
    0.25974646f, -0.06443649f, 0.12526639f, 0.05311538f, -0.05821855f, 0.24314243f, -0.09973064f, 0.16448098f, 
    0.13316460f, 0.17644499f, 0.35597143f, -0.09970436f, 0.25376049f, -0.04146789f, -0.07123430f, -0.11240950f, 
    -0.07489136f, 0.23227572f, 0.10882241f, -0.08532055f, -0.21316119f, -0.10562391f, 0.02982133f, -0.06322636f, 
    0.13256097f, 0.11429671f, -0.17542914f, 0.29791436f, 0.03330470f, -0.35888875f, -0.20592482f, -0.05884074f, 
    -0.08918394f, 0.35613617f, 0.01734095f, -0.06042164f, -0.03549099f, -0.15577805f, -0.08587382f, 0.15988384f, 
    -0.23713973f, 0.10387668f, -0.02767709f, 0.14655285f, 0.18160781f, 0.10363620f, -0.04317546f, -0.20163585f, 
    -0.05248357f, 0.25248387f, -0.05479708f, -0.06469775f, 0.07506974f, -0.40571871f, 0.06390128f, -0.10637450f, 
    0.05250959f, -0.24786763f, -0.03475669f, -0.29687074f, -0.16808201f, -0.15067489f, 0.01142660f, 0.17141405f, 
    -0.35405466f, -0.00234408f, 0.03056333f, 0.00269848f, -0.09679616f, -0.06954414f, -0.02234917f, -0.05287074f, 
    -0.07543532f, -0.03037090f, -0.09767488f, 0.13432138f, -0.23129432f, -0.18706295f, -0.09762155f, 0.00321502f, 
    0.03673158f, -0.04093627f, -0.03516951f, 0.11290044f, -0.18302512f, -0.11943738f, 0.05184916f, 0.14043197f, 
    0.15760908f, 0.48148537f, 0.31839216f, -0.31168580f, 0.21599475f, 0.13566476f, 0.25576088f, 0.05276843f, 
    -0.10092733f, -0.08214013f, 0.01689621f, 0.02192112f, -0.00349987f, 0.09658960f, 0.05719560f, -0.07229548f, 
    -0.01342240f, -0.21204253f, 0.01341814f, 0.04974120f, 0.20265102f, 0.25265503f, -0.03092698f, -0.08338431f, 
    -0.11865016f, 0.07471643f, 0.45376337f, 0.03801160f, 0.27222544f, 0.24594589f, 0.11276017f, 0.14928491f, 
    0.31700033f, 0.28513220f, -0.20497213f, -0.05826012f, -0.02636056f, -0.04178461f, 0.02552483f, -0.02124754f, 
    0.08023006f, -0.11464749f, -0.23589680f, 0.01056883f, -0.00903913f, -0.17209265f, -0.09332287f, 0.17212650f, 
    -0.26557052f, -0.01492476f, 0.20640185f, 0.25639594f, 0.00301117f, -0.21025649f, -0.09793778f, -0.12809159f, 
    0.06252974f, -0.11772309f, -0.06258945f, 0.11228294f, 0.38015196f, -0.09340619f, -0.17413503f, 0.15530995f, 
    -0.28451043f, 0.15472163f, 0.19885643f, -0.24768940f, -0.29398707f, 0.12212602f, 0.38631678f, 0.03108996f, 
    0.07257477f, -0.27229246f, 0.19967768f, 0.08123032f, -0.14222106f, 0.41348407f, 0.09037860f, 0.11766533f, 
    0.52136070f, -0.07425598f, 0.09618059f, 0.03999334f, -0.29879358f, -0.45928529f, -0.09912471f, 0.17104097f, 
    0.10071310f, -0.03902169f, -0.34138453f, 0.03896923f, -0.13556586f, -0.05399878f, 0.05322153f, 0.12067948f, 
    0.12320665f, -0.07247678f, 0.25711748f, 0.24221607f, 0.18571067f, -0.00766430f, 0.11454874f, -0.06134352f, 
    0.22737291f, 0.03867593f, 0.21010140f, 0.09550321f, 0.01151476f, 0.26228353f, -0.08538222f, 0.04296731f, 
    0.21780114f, -0.25853416f, -0.00107716f, -0.15003341f, -0.42248663f, 0.21937603f, 0.03785595f, -0.13935441f, 
    -0.06922986f, 0.15068518f, -0.21836688f, 0.11219995f, 0.33217138f, -0.02948351f, -0.24509694f, -0.13579254f, 
    0.31333429f, -0.24464324f, -0.13927862f, 0.24954617f, 0.28897846f, -0.04973039f, -0.18250003f, 0.22979513f, 
    0.02314821f, 0.09727286f, 0.17431171f, 0.10297570f, 0.09858385f, 0.21084747f, -0.08674812f, 0.00323645f, 
    0.01379391f, -0.10273724f, 0.27654368f, 0.04103309f, -0.15692465f, 0.08002250f, -0.06336612f, -0.11651578f, 
    -0.23404692f, 0.04841139f, 0.21588002f, -0.06568950f, 0.13409239f, 0.30120197f, -0.02253269f, 0.44622713f, 
    -0.38695741f, 0.16785862f, 0.44982398f, -0.12778653f, -0.12598903f, 0.03530612f, -0.00573720f, 0.18928497f, 
    0.05393441f, 0.02567461f, 0.11206337f, 0.04980302f, -0.04158499f, 0.16652240f, -0.07412963f, 0.12443651f, 
    -0.00517239f, 0.06838921f, 0.00197043f, 0.27959573f, -0.29989848f, 0.15664460f, 0.10047171f, 0.11496145f, 
    0.09527230f, 0.01103696f, 0.21008290f, -0.25036362f, -0.38474667f, 0.00228239f, -0.06921943f, -0.05140514f, 
    0.06327531f, 0.18172152f, 0.12380119f, -0.09853425f, 0.09778146f, -0.12572177f, 0.19403294f, -0.27713266f, 
    -0.02405743f, 0.01157095f, 0.09242357f, -0.00316434f, 0.06572565f, -0.03461476f, 0.03979659f, -0.22896785f, 
    0.01500954f, 0.06614659f, 0.07966827f, -0.12128600f, -0.13149944f, -0.11314465f, 0.05800559f, -0.11251112f, 
    0.05046434f, -0.09973536f, -0.06679455f, -0.06460558f, -0.11154272f, -0.06136347f, -0.03600514f, 0.09109177f, 
    -0.04450424f, 0.04456897f, -0.06032446f, -0.12161808f, -0.00552460f, -0.09505792f, 0.06206352f, -0.06362835f, 
    -0.03205650f, -0.06464472f, -0.13092534f, -0.02674887f, 0.01315914f, 0.04038275f, 0.05424979f, 0.04275402f, 
    -0.14587672f, 0.00539188f, 0.04728130f, -0.10904711f, -0.10419044f, -0.12179989f, 0.05412853f, -0.17304687f, 
    -0.11414436f, 0.03693932f, -0.09083015f, -0.05071654f, 0.07428017f, -0.08932935f, -0.07337978f, -0.12133154f, 
    -0.00493754f, 0.09150603f, -0.13543011f, 0.02906488f, 0.03439218f, 0.06357412f, -0.00244757f, -0.05787437f, 
    0.01581152f, 0.07943188f, -0.02419368f, -0.06645776f, -0.12174576f, -0.07739273f, 0.06332946f, -0.05935203f, 
    -0.13665055f, -0.16411170f, 0.07591137f, -0.11425909f, 0.40306926f, -0.08813935f, -0.07140079f, -0.18713154f, 
    -0.01503526f, 0.18490225f, 0.36335412f, 0.08002208f, 0.08460713f, -0.01108723f, 0.01397210f, 0.01542783f, 
    -0.04946091f, 0.19579676f, -0.06999444f, 0.04526198f, -0.00942671f, 0.13226369f, -0.06738569f, 0.08137284f, 
    0.05822351f, -0.09408458f, 0.07111081f, -0.09769645f, -0.05211224f, -0.45004305f, -0.06048892f, 0.22357745f, 
    -0.13062873f, 0.16104098f, 0.04357755f, 0.15017839f, 0.00270228f, -0.05201699f, -0.08929030f, -0.16987635f, 
    0.11854137f, -0.18112136f, 0.00901149f, -0.04432242f, 0.29002783f, -0.09052392f, -0.13123152f, 0.34845126f, 
    0.07735960f, -0.00985923f, 0.19860448f, -0.15124750f, -0.15598911f, 0.14489162f, 0.23751922f, -0.16541307f, 
    -0.07912126f, -0.11843508f, 0.23721111f, 0.12647174f, 0.14743483f, 0.27594593f, 0.10218535f, -0.19960029f, 
    -0.10546210f, 0.01385757f, -0.04938163f, -0.16269319f, -0.15874097f, -0.13744922f, -0.09744092f, 0.00988610f, 
    -0.08121810f, -0.23486982f, -0.22816278f, 0.12092976f, -0.16475469f, 0.24880911f, 0.04432733f, -0.15758257f, 
    0.40898016f, -0.08715533f, -0.15356295f, -0.17872758f, 0.23311493f, 0.25112370f, 0.01998537f, 0.18619835f, 
    -0.13727257f, 0.25885817f, 0.02199080f, -0.06893268f, 0.06229366f, -0.11044392f, 0.00719792f, 0.25188187f, 
    0.07224225f, -0.09271248f, -0.06376731f, 0.02051245f, 0.02559808f, -0.29540753f, 0.04662176f, 0.22011337f, 
    -0.08073949f, -0.10796423f, -0.35309404f, 0.03881773f, 0.20904373f, -0.00530574f, -0.10756496f, -0.08222585f, 
    0.08346580f, 0.18446892f, 0.26596099f, 0.06681108f, -0.03333254f, 0.31886595f, 0.29624790f, 0.15100335f, 
    0.11551936f, 0.08538155f, 0.15760699f, -0.12425651f, -0.25411832f, 0.03378852f, -0.10419608f, 0.04601848f, 
    0.12912522f, 0.01437983f, 0.08012544f, -0.02043913f, -0.34319228f, -0.20085984f, -0.14587723f, 0.25206545f, 
    0.19431138f, 0.15570866f, -0.28463846f, 0.03159185f, -0.21954516f, 0.26082468f, -0.04846725f, 0.23198180f, 
    -0.13093051f, 0.13471761f, -0.06461985f, 0.13995400f, 0.25529665f, 0.17415984f, -0.08607221f, -0.05639215f, 
    0.22476400f, 0.27184054f, 0.07213255f, 0.00064489f, 0.10123178f, 0.04572337f, -0.05304196f, 0.00059073f, 
    -0.02008171f, -0.08257661f, -0.18946709f, -0.14723757f, -0.12202289f, -0.01769220f, 0.08370231f, 0.02361071f, 
    -0.04119056f, 0.23684730f, 0.13273467f, -0.09969428f, -0.06686337f, 0.01108493f, -0.22498932f, -0.09537977f, 
    0.07600317f, 0.06147053f, 0.05448560f, 0.23334579f, 0.05036473f, -0.05477170f, 0.06018459f, 0.06047803f, 
    -0.06496905f, 0.09887073f, 0.06044684f, 0.00837248f, 0.03153267f, -0.19592185f, 0.11528030f, 0.02092369f, 
    0.06915009f, -0.02732679f, -0.05516616f, 0.03608266f, -0.00070208f, -0.17237779f, 0.02210462f, -0.05346176f, 
    0.00695777f, -0.03890123f, -0.13470055f, -0.03891417f, 0.01623293f, 0.02347356f, 0.00278849f, -0.08370896f, 
    -0.07338963f, 0.02614001f, 0.00386164f, -0.06461518f, 0.02564865f, -0.08577819f, 0.05309675f, -0.15261276f, 
    0.05591898f, -0.04194620f, -0.10479506f, -0.12878095f, 0.04316847f, -0.07362671f, -0.09498353f, -0.13900357f, 
    0.01591893f, -0.06061878f, 0.12011886f, -0.05198941f, -0.01346693f, -0.12307011f, 0.11597253f, -0.12112419f, 
    0.10705916f, -0.05727465f, -0.06614942f, -0.14928555f, -0.00336715f, 0.04384964f, -0.05531583f, 0.05242292f, 
    -0.05492835f, 0.08615497f, 0.03033395f, -0.04251337f, -0.00333054f, -0.08917867f, -0.02952724f, 0.05774539f, 
    0.09680372f, 0.02925984f, -0.00044003f, -0.02730657f, -0.01925486f, -0.06982353f, 0.04629352f, -0.05079819f, 
    0.32171685f, 0.18307151f, 0.09704713f, -0.02121375f, -0.17493176f, -0.13953917f, -0.06228343f, 0.02414623f, 
    0.24566746f, -0.06156398f, -0.20759718f, 0.32555670f, -0.17015886f, -0.03335154f, -0.09571514f, 0.22771941f, 
    -0.18628599f, -0.28881261f, 0.34513634f, 0.03612409f, -0.06104248f, 0.06887750f, -0.11139737f, -0.02998121f, 
    0.21156642f, 0.15705207f, 0.24010576f, -0.06448157f, 0.09032732f, -0.19366133f, -0.02543080f, 0.09064939f, 
    0.26232579f, -0.05595222f, 0.02903199f, 0.12694244f, 0.26802808f, 0.08565073f, -0.11729567f, 0.12681614f, 
    -0.09477033f, 0.08554889f, -0.12193318f, -0.15249790f, -0.01349672f, -0.08698555f, -0.16792886f, 0.13426813f, 
    0.20015597f, -0.17468967f, 0.13871016f, 0.12509856f, 0.18908538f, -0.07258239f, -0.28757516f, -0.14067864f, 
    -0.07133336f, 0.17590083f, 0.16915865f, 0.13474758f, -0.11958603f, 0.01498694f, 0.05840686f, -0.03606843f, 
    -0.21381538f, -0.02358529f, 0.18512177f, 0.02246927f, 0.28686559f, 0.07931348f, -0.06567488f, -0.14345475f, 
    0.13819747f, -0.08289371f, -0.11411821f, 0.14745584f, 0.03687219f, 0.24612607f, -0.04082908f, -0.09893131f, 
    0.12958787f, 0.04830537f, -0.35195607f, -0.28477955f, 0.05411504f, 0.00344187f, -0.06382017f, 0.18617691f, 
    -0.15122281f, 0.22050831f, -0.21284831f, -0.01395518f, -0.10075486f, -0.45238760f, 0.04096915f, 0.30923158f, 
    0.07944016f, -0.10053062f, 0.11430945f, 0.00088927f, 0.49746203f, -0.10535607f, 0.05338756f, 0.00224323f, 
    0.12959039f, -0.11015461f, -0.26415217f, -0.00480081f, -0.03399910f, 0.08477239f, -0.16180962f, 0.33334643f, 
    0.07544018f, 0.12126195f, 0.22858007f, 0.16789262f, 0.09468116f, 0.02807354f, 0.03478036f, -0.31787452f, 
    0.09200373f, 0.12775852f, 0.20537035f, 0.06348913f, -0.11614831f, -0.21929985f, 0.02234171f, -0.11375075f, 
    -0.01413378f, -0.02124910f, 0.21954185f, 0.19222495f, 0.22820424f, -0.05741437f, -0.06745874f, 0.08223930f, 
    0.06082635f, 0.35214475f, 0.03060408f, 0.04766071f, 0.04170969f, -0.11964519f, 0.02671199f, -0.20235153f, 
    -0.00155781f, 0.22421180f, -0.54920876f, 0.08796885f, -0.09349094f, -0.13145146f, -0.07287087f, 0.08347631f, 
    0.09833835f, -0.10779858f, 0.02907246f, -0.08077221f, 0.08609350f, -0.30314431f, -0.00032619f, 0.18866187f, 
    -0.24543117f, 0.19883128f, 0.00641144f, 0.11157999f, 0.25756910f, -0.04387093f, 0.07470645f, 0.03494743f, 
    0.01968008f, 0.10878035f, -0.01222454f, 0.13224038f, -0.12096277f, 0.08841491f, -0.07949950f, 0.15190510f, 
    0.10651711f, 0.21348365f, -0.00053726f, 0.13474776f, 0.24920532f, -0.03950303f, -0.08089669f, 0.06037660f, 
    0.08497505f, 0.14078271f, 0.07778417f, 0.13533755f, 0.37273630f, -0.15551740f, -0.05775750f, -0.20442955f, 
    -0.24592304f, 0.03309283f, 0.09542301f, -0.08553271f, 0.29303634f, -0.05720527f, -0.02269447f, 0.05569588f, 
    -0.19793072f, 0.11174025f, -0.07642604f, -0.30275857f, 0.07127722f, -0.00559622f, -0.01989193f, -0.13727790f, 
    0.14635928f, -0.26778266f, -0.11701291f, 0.02432209f, -0.08957470f, -0.06370597f, 0.04155015f, 0.13437107f, 
    -0.21661107f, -0.15333538f, -0.25961950f, -0.05678775f, 0.11041464f, -0.31661189f, -0.02094659f, 0.23762871f, 
    -0.03230305f, 0.09615377f, 0.00707660f, 0.12971827f, 0.12930557f, 0.01164351f, 0.07079392f, -0.03325740f, 
    0.02888154f, -0.28689605f, -0.12703757f, 0.18463078f, 0.00244950f, 0.03406416f, -0.08080655f, 0.31359553f, 
    0.17384893f, 0.09699780f, 0.06721168f, -0.05620925f, 0.15677713f, 0.18094553f, 0.16722293f, -0.14771141f, 
    -0.07568881f, 0.09788357f, 0.23064683f, -0.15310839f, 0.20978466f, 0.04067528f, -0.06164416f, -0.40331072f, 
    -0.00424490f, 0.05043960f, 0.23295501f, 0.16254053f, 0.05408403f, 0.15508255f, 0.05787517f, 0.24421808f, 
    -0.07955956f, 0.47405478f, 0.18236296f, -0.05255027f, 0.07000406f, 0.18671788f, -0.03051825f, 0.09525495f, 
    -0.19133911f, 0.09908175f, -0.18097499f, -0.10297849f, -0.10342660f, 0.01793353f, 0.04829976f, -0.05954766f, 
    0.07302933f, -0.21192011f, -0.00094468f, 0.08500905f, -0.06473532f, 0.05393619f, -0.06196810f, -0.00049373f, 
    0.02957569f, 0.16600592f, -0.00194932f, 0.31651267f, -0.22323759f, 0.24092503f, 0.06047171f, -0.08842278f, 
    -0.05555862f, 0.02329211f, 0.31668854f, -0.15461259f, -0.26408756f, -0.05743274f, -0.08183996f, 0.00644880f, 
    -0.42727274f, 0.10700362f, 0.04263750f, 0.11112618f, 0.08663071f, -0.27616385f, 0.22186720f, -0.02860613f, 
    0.08249092f, 0.13691778f, -0.03217378f, 0.02131857f, 0.25107491f, 0.14157066f, 0.10348446f, -0.22835903f, 
    -0.05718964f, -0.27390584f, 0.04778009f, 0.03207471f, 0.37652180f, -0.28056327f, 0.06894324f, -0.17791229f, 
    0.07828971f, 0.19453534f, -0.12563488f, -0.20143004f, -0.05075694f, -0.50341898f, 0.10267592f, -0.34705281f, 
    0.02894339f, 0.17077981f, -0.06620339f, 0.08560305f, 0.04067537f, 0.08562706f, 0.09990276f, 0.20781034f, 
    0.02619967f, -0.12173133f, 0.04820435f, 0.02299322f, -0.10661222f, -0.29713833f, 0.09548193f, -0.02670686f, 
    -0.02335935f, 0.12953815f, 0.12644833f, -0.04502168f, 0.07919547f, -0.10306851f, -0.10521184f, -0.03037649f, 
    0.12679465f, -0.05770458f, -0.06275516f, 0.17610906f, -0.20992807f, 0.12412708f, -0.01439385f, -0.04595599f, 
    0.41140303f, 0.25690591f, 0.09718940f, 0.15269394f, 0.11271338f, -0.10998796f, -0.06488875f, -0.12491606f, 
    0.05805910f, 0.25079331f, 0.19925298f, 0.10115402f, 0.19060662f, 0.06864115f, 0.01439938f, -0.31322426f, 
    -0.18467474f, 0.22139826f, 0.06488574f, -0.06553402f, -0.12285046f, 0.21279390f, 0.17339233f, 0.01925326f, 
    0.07181961f, 0.14113702f, -0.08805155f, -0.00369385f, -0.17863002f, 0.03125844f, 0.05567905f, -0.10261156f, 
    0.15801612f, -0.12347052f, 0.35583735f, -0.13554132f, 0.02570657f, 0.26063612f, 0.05015133f, 0.03420122f, 
    0.06998350f, 0.00748431f, 0.17477849f, -0.01290725f, -0.07701579f, 0.27310854f, -0.02830806f, -0.00476337f, 
    0.20562431f, -0.13602178f, 0.13814913f, -0.19103567f, 0.17433360f, -0.32853392f, 0.08812990f, 0.08633025f, 
    -0.01390296f, 0.03357832f, 0.01054140f, 0.22343835f, -0.14698641f, 0.11123254f, 0.06003582f, 0.08175529f, 
    0.21779001f, 0.24042203f, -0.04249921f, 0.10125464f, -0.05761541f, 0.12000751f, -0.00330114f, -0.08203496f, 
    -0.09164025f, 0.26533976f, -0.16129781f, -0.00455579f, -0.16011664f, -0.33648047f, -0.03800253f, -0.03159318f, 
    -0.02003931f, 0.18644352f, 0.11808321f, -0.05816719f, 0.09377670f, 0.11500047f, 0.04846992f, 0.02784610f, 
    -0.16992728f, -0.01899366f, -0.03970237f, 0.14872934f, 0.01124587f, 0.32961044f, -0.09414814f, 0.33762568f, 
    0.26424104f, -0.26670289f, -0.24326244f, -0.12226667f, -0.17599346f, 0.08358367f, -0.00805480f, -0.02850439f, 
    -0.11971259f, 0.14290759f, -0.02203898f, -0.03629924f, 0.08831719f, -0.20572682f, 0.05435565f, 0.21154422f, 
    0.05771276f, -0.04977393f, -0.14116871f, 0.22057025f, -0.17076400f, 0.00931103f, 0.11177983f, -0.00685525f, 
    -0.03664933f, -0.14635211f, -0.02302676f, 0.02809948f, 0.22627182f, 0.12430394f, -0.13421421f, 0.13913128f, 
    -0.17432012f, 0.25226536f, 0.18649040f, -0.15645733f, -0.05573041f, 0.21330857f, 0.41428065f, -0.17983171f, 
    0.10337990f, 0.05728951f, 0.08988351f, -0.00967329f, 0.06935630f, 0.19799671f, -0.11837333f, -0.32913727f, 
    0.08176631f, 0.00415410f, -0.17981729f, -0.12458397f, 0.15028256f, 0.12700263f, 0.07699908f, -0.05185851f, 
    -0.06114452f, -0.01124271f, -0.05049677f, -0.14685042f, 0.05466256f, -0.03039827f, 0.10196999f, -0.05866468f, 
    -0.09794782f, 0.03290136f, -0.04001056f, 0.00243121f, 0.00775584f, -0.02126744f, -0.08710876f, -0.12150435f, 
    0.04862295f, -0.05399792f, 0.03185609f, -0.02682959f, 0.06869301f, -0.02328246f, -0.09759863f, -0.07284392f, 
    -0.00082191f, -0.13060647f, 0.04720408f, -0.05101237f, 0.06403224f, -0.03828880f, 0.05177322f, 0.05903428f, 
    -0.11825684f, -0.09467825f, -0.05001225f, -0.06687891f, -0.01501039f, 0.07435882f, -0.00594139f, -0.05356638f, 
    0.01638591f, 0.05934157f, -0.17575930f, 0.05067921f, -0.05177756f, -0.08923936f, 0.02570080f, -0.01860997f, 
    -0.05393998f, -0.12843433f, -0.00950475f, -0.00013552f, -0.04630470f, 0.07817807f, 0.02229977f, 0.00311499f, 
    -0.15118852f, -0.09433116f, 0.02667101f, 0.00489747f, -0.20937942f, 0.01216560f, -0.00431689f, -0.06103169f, 
    -0.01127987f, -0.27963361f, 0.03208702f, 0.12985706f, 0.24494447f, 0.32375816f, 0.11657437f, 0.13870677f, 
    0.10144975f, -0.06309392f, 0.04419084f, -0.08285882f, 0.33670017f, 0.19721881f, -0.12290004f, 0.07437786f, 
    -0.10509053f, 0.22977117f, -0.23023912f, -0.11732419f, 0.07290582f, -0.06004882f, 0.07746486f, 0.21971762f, 
    0.12753105f, -0.07767971f, 0.11879135f, -0.22042729f, 0.17258243f, 0.03653491f, -0.05735015f, 0.10862199f, 
    0.01428018f, -0.12786783f, -0.04942410f, 0.00090565f, -0.05249304f, 0.00633058f, 0.06505837f, 0.20573299f, 
    0.09085741f, -0.08652636f, 0.03402844f, -0.13587421f, -0.00663464f, 0.13120969f, 0.36857274f, 0.11779059f, 
    0.02689238f, 0.07525026f, 0.12413923f, -0.22178219f, -0.44229338f, 0.11079323f, 0.08066969f, 0.36157748f, 
    -0.04830835f, -0.07854487f, 0.04566995f, 0.17819642f, 0.02910563f, 0.31161359f, -0.23730512f, 0.06937148f, 
    0.02351794f, -0.09053019f, 0.37885556f, 0.27038482f, 0.10169481f, 0.38638484f, 0.07204647f, 0.14165038f, 
    0.19611242f, 0.43341842f, -0.16454035f, -0.15826133f, 0.20343681f, -0.13426295f, 0.06900034f, -0.05436476f, 
    -0.10987887f, 0.16320007f, -0.13834718f, 0.00778663f, 0.06016181f, -0.16414689f, 0.01475156f, -0.00907925f, 
    -0.03719169f, -0.18795733f, -0.01336648f, -0.03225985f, 0.00529593f, 0.15975843f, 0.10823659f, 0.17879754f, 
    0.00714703f, -0.11413963f, -0.08322623f, -0.12562472f, 0.16000861f, -0.07557062f, 0.04081291f, 0.16567954f, 
    -0.09645189f, 0.14569934f, 0.25534680f, -0.09281091f, 0.02217858f, 0.18335614f, 0.07908190f, 0.22154041f, 
    0.05774939f, -0.34696811f, 0.09640934f, 0.09154163f, -0.27367774f, 0.00775082f, 0.01251981f, 0.13946845f, 
    -0.13215759f, -0.05734999f, 0.19862351f, 0.22381026f, -0.05754339f, 0.10116229f, 0.05414426f, 0.17805541f, 
    -0.12541728f, 0.42065141f, -0.14846836f, -0.02793450f, 0.08729193f, 0.19368912f, 0.05201612f, 0.19658758f, 
    -0.23588756f, 0.19658317f, 0.18416919f, 0.12926783f, -0.08009747f, 0.02704910f, -0.10764743f, 0.11637708f, 
    0.30702281f, -0.10525758f, 0.09232707f, 0.03896907f, -0.09666675f, 0.27446890f, -0.02427138f, -0.01535983f, 
    -0.06087655f, 0.06685128f, 0.15077743f, 0.02589345f, 0.08908546f, 0.16780747f, 0.02629683f, -0.01067541f, 
    -0.11485603f, 0.16642265f, 0.31426260f, -0.04506394f, -0.34476298f, 0.08463164f, -0.08604995f, -0.06714274f, 
    -0.08843092f, 0.16913383f, -0.12243236f, 0.21134092f, 0.01752701f, -0.29204503f, 0.04544531f, -0.00264462f, 
    0.07742820f, 0.35303906f, -0.06973848f, -0.03612821f, 0.13825242f, -0.09353526f, -0.09694631f, -0.06346399f, 
    -0.00422902f, -0.10579392f, 0.10619599f, 0.18706791f, 0.11537808f, 0.13638632f, -0.15728173f, -0.10677063f, 
    0.14197417f, 0.00188319f, 0.30867392f, 0.13516361f, 0.06881773f, -0.02157660f, 0.04471705f, 0.14730306f, 
    -0.27530149f, 0.22137237f, 0.15549080f, -0.18576561f, 0.04244673f, -0.07640152f, 0.05690760f, 0.03229667f, 
    0.00589543f, 0.02534301f, -0.07707898f, -0.00143028f, -0.11985461f, 0.01809229f, -0.12863974f, 0.11173351f, 
    -0.05599021f, 0.09370124f, 0.15248279f, 0.06131427f, 0.52888387f, 0.19358721f, 0.01967573f, -0.02137930f, 
    0.04500171f, -0.05516528f, 0.04607170f, -0.10417859f, -0.16715893f, 0.04243952f, 0.07831620f, 0.23645717f, 
    0.10620395f, 0.15132050f, -0.00644888f, 0.17029211f, -0.05434216f, -0.38637954f, -0.43243235f, -0.15582274f, 
    0.05477365f, 0.30195040f, 0.06214655f, 0.16782330f, -0.04087653f, -0.15423286f, 0.08092903f, 0.03438005f, 
    0.01388667f, -0.12954620f, -0.03713329f, -0.07413494f, 0.03364965f, 0.01331948f, -0.14803255f, -0.04340813f, 
    0.05301875f, -0.08473670f, 0.09201208f, -0.14112850f, -0.00169851f, 0.05312994f, -0.10443470f, -0.10622980f, 
    0.02379165f, -0.10887224f, 0.03043329f, -0.14751263f, 0.03452875f, -0.02298063f, -0.00782503f, -0.07798897f, 
    -0.04249005f, -0.05344832f, -0.13688543f, 0.09332487f, 0.07924877f, -0.03118584f, -0.05532534f, 0.06872152f, 
    0.10659502f, -0.05560935f, 0.01387999f, 0.09573238f, 0.06160010f, 0.02786011f, 0.06607330f, -0.07683448f, 
    0.01533984f, 0.03455076f, 0.01000154f, -0.04847573f, 0.04196068f, -0.10724267f, -0.00652702f, -0.11986877f, 
    -0.04584034f, -0.03567098f, -0.10394393f, -0.05467007f, 0.07770769f, 0.07589110f, -0.01974220f, -0.02717630f, 
    -0.01148246f, -0.02195683f, -0.10882641f, -0.03178080f, 0.07995778f, 0.04398870f, -0.05062427f, 0.00322771f, 
    -0.12431113f, -0.07280977f, -0.02396949f, 0.04386607f, -0.06141222f, -0.13383834f, -0.01769920f, -0.08644924f, 
    0.03951553f, 0.01464418f, 0.09047636f, 0.01730478f, 0.08494341f, 0.01837762f, 0.02068748f, 0.07671686f, 
    -0.04959814f, -0.10579500f, -0.04024105f, -0.05303444f, -0.08612321f, 0.10721297f, 0.03903605f, -0.10497183f, 
    -0.07097125f, -0.10550945f, 0.00511508f, 0.00554848f, 0.07608561f, 0.04776489f, 0.00649008f, 0.03921561f, 
    -0.11084303f, -0.06556785f, -0.06308513f, -0.02575448f, 0.01509653f, -0.07845490f, -0.07753430f, -0.08069182f, 
    0.10255288f, -0.02408057f, -0.07512090f, -0.03947176f, 0.07942756f, 0.12375081f, -0.05258942f, -0.08224198f, 
    -0.02098272f, -0.09710140f, -0.00686598f, 0.01251608f, -0.07516534f, -0.02006568f, -0.10121991f, -0.04504256f, 
    0.04856481f, -0.11806379f, 0.03281893f, -0.03928500f, 0.04987330f, -0.05180836f, 0.04892433f, 0.03267984f, 
    -0.11681031f, 0.02830257f, -0.17946061f, 0.15065028f, 0.17787090f, -0.01185751f, 0.03479536f, 0.19278811f, 
    0.10687412f, 0.18673545f, -0.18468298f, -0.02955309f, 0.19758870f, -0.02287093f, -0.03239585f, -0.03063679f, 
    0.04682495f, -0.17016092f, -0.13650939f, 0.03648230f, -0.26944193f, -0.18669373f, -0.11772406f, -0.00690370f, 
    -0.07530285f, -0.28413939f, 0.00185250f, 0.05273809f, -0.08006791f, -0.04012763f, 0.04074826f, -0.06800963f, 
    -0.09594728f, 0.04257350f, 0.01772796f, 0.16367829f, -0.17471327f, 0.05646255f, 0.00017556f, 0.00292874f, 
    0.12365885f, -0.07257038f, 0.01479162f, 0.11816802f, -0.04442913f, 0.03976667f, -0.00121757f, 0.05036886f, 
    0.08213357f, -0.11830014f, 0.22046718f, -0.01863067f, 0.10268774f, 0.10165305f, -0.10307053f, -0.09269740f, 
    0.11322220f, -0.22243106f, 0.11240981f, 0.11593643f, 0.17779362f, 0.10834927f, 0.02381114f, -0.37164652f, 
    0.18084753f, 0.06081787f, 0.14232267f, 0.09022237f, 0.31371734f, 0.01347929f, -0.15045428f, 0.12332545f, 
    0.09049016f, 0.19036503f, 0.10494613f, 0.02928984f, -0.11252873f, -0.17941743f, -0.10022687f, -0.09810036f, 
    0.06149506f, 0.27274072f, -0.38369304f, -0.00752095f, -0.20032944f, -0.11965094f, 0.07727972f, 0.02277593f, 
    -0.01293456f, -0.12129031f, -0.10925972f, 0.06943785f, -0.05980275f, -0.15867648f, -0.00767957f, -0.02312596f, 
    -0.35580993f, -0.15824033f, 0.05814355f, 0.12421536f, 0.05676368f, 0.02992421f, 0.00135320f, -0.17105527f, 
    -0.00342894f, 0.03931058f, -0.13133515f, 0.12088286f, 0.20091288f, -0.09445407f, -0.23230705f, 0.08918928f, 
    0.10687832f, 0.17162418f, -0.00753727f, 0.10484838f, 0.07171740f, -0.14467026f, 0.20810874f, -0.00744889f, 
    -0.03987762f, -0.19841354f, 0.14317894f, 0.12532882f, 0.28717217f, 0.11313432f, -0.07057029f, -0.18810502f, 
    -0.11715122f, -0.01860610f, 0.09779931f, -0.04684706f, -0.06189112f, -0.00601784f, -0.01320425f, 0.07074144f, 
    -0.08716361f, 0.02960297f, 0.07586806f, -0.00784016f, 0.04775529f, -0.10180323f, 0.03319737f, -0.12041704f, 
    -0.11134323f, -0.06548269f, -0.11966182f, 0.03408481f, -0.06511465f, 0.03347953f, -0.07579716f, -0.10763096f, 
    0.01372310f, -0.10739680f, -0.01169367f, 0.12357791f, -0.09150331f, -0.10323803f, -0.10359372f, 0.07290708f, 
    -0.09236901f, -0.12155851f, -0.14738607f, -0.01504018f, -0.08190507f, -0.03465353f, -0.05544515f, -0.02018063f, 
    0.02685860f, -0.05192112f, -0.06326468f, -0.08225008f, -0.12991692f, 0.08272803f, -0.12040634f, -0.11839192f, 
    0.06010532f, 0.04542952f, -0.04608097f, -0.08336984f, 0.00537920f, 0.03147987f, -0.00295876f, -0.05949754f, 
    -0.00526541f, -0.12687148f, -0.06566200f, 0.06880037f, -0.11164308f, 0.08238009f, 0.07958561f, -0.00851131f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12576684f, 0.05782690f, -0.00662750f, 0.19395559f, 0.19216384f, -0.09532977f, 0.09501497f, 0.09237352f, 
    0.11990746f, -0.09581195f, 0.25082394f, 0.10802730f, 0.19002660f, 0.12502630f, -0.14642517f, -0.04430333f, 
    -0.01955146f, 0.09239979f, 0.12854093f, 0.00592489f, 0.26252350f, -0.00843355f, 0.09257399f, -0.10802927f, 
    0.01348083f, 0.00677339f, 0.17534523f, 0.19502816f, 0.01592413f, -0.13388303f, 0.14416976f, 0.04565646f, 
    0.15451936f, 0.13471307f, 0.00749496f, -0.12926045f, -0.00181465f, 0.24717049f, 0.14026582f, -0.06592210f, 
    0.12719202f, -0.15143843f, 0.05422289f, 0.12537736f, 0.04187315f, -0.06663409f, 0.00657736f, 0.12221232f, 
    0.11845092f, 0.12440359f, 0.22744529f, 0.02187399f, 0.13092835f, 0.13230583f, -0.00887750f, 0.02927786f, 
    0.16425921f, 0.19369945f, -0.06471158f, -0.13427949f, 0.04237543f, -0.05223682f, 0.15615684f, -0.07184985f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.20037597f, -0.56632715f, -0.22210824f, -0.47350132f, -0.24611820f, 0.10015380f, 0.23872362f, -0.30627817f, 
    -0.20403999f, -0.03244981f, -0.24343848f, -0.10473120f, -0.20306775f, -0.14256527f, 0.20259906f, 0.14407600f, 
    -0.02567357f, -0.38256460f, -0.09756829f, 0.37209299f, -0.43939391f, 0.05870318f, -0.36782664f, 0.04166646f, 
    0.09437884f, -0.13466859f, 0.20765786f, -0.25878188f, 0.10853114f, 0.01903729f, -0.23517556f, -0.02408905f, 
    -0.06022478f, 0.11847303f, -0.38310814f, 0.05142543f, -0.09430093f, -0.22300529f, -0.44098681f, 0.27820238f, 
    0.03643063f, 0.01507449f, -0.53578544f, 0.08129390f, 0.16510415f, -0.05806446f, 0.13058318f, -0.47260672f, 
    -0.09711841f, -0.09559124f, -0.08698767f, 0.08010588f, 0.17285109f, -0.14881524f, 0.04181943f, -0.38196626f, 
    -0.65466648f, 0.03810626f, -0.38440472f, -0.07842988f, 0.08832286f, 0.03966561f, 0.03090328f, -0.00807734f, 
    -0.10920768f, -0.41999590f, -0.19678888f, 0.20412011f, 0.28937808f, -0.39266211f, 0.21041326f, 0.21830060f, 
    0.19751619f, -0.03686667f, -0.26764283f, 0.25025880f, 0.12062402f, 0.12894653f, 0.16011921f, -0.00358643f, 
    -0.00697754f, 0.25596523f, -0.23415309f, -0.50934464f, -0.01005800f, 0.14778881f, -0.20842774f, 0.02498974f, 
    -0.62660062f, -0.28165600f, 0.15127456f, 0.18582584f, 0.17043979f, 0.03014168f, -0.28286678f, 0.09954619f, 
    0.02850004f, -0.01689897f, -0.21795639f, -0.01076370f, 0.20689514f, -0.14404742f, -0.17596589f, -0.13953581f, 
    -0.15772358f, -0.03410811f, 0.20569849f, -0.10146054f, -0.06407959f, -0.08598951f, 0.14724019f, 0.18283013f, 
    0.04464143f, 0.14818063f, -0.16753563f, 0.15117727f, 0.18378410f, -0.24142078f, 0.07615146f, 0.08920346f, 
    -0.36837679f, 0.10613314f, 0.33627313f, 0.03246042f, -0.06121973f, 0.04822176f, -0.19923313f, -0.00964324f, 
    -0.33683270f, 0.11795337f, 0.01812970f, 0.03988202f, -0.45557266f, -0.05690136f, 0.02442132f, 0.09936949f, 
    0.27160311f, -0.13368820f, 0.07498498f, 0.13746117f, -0.09486230f, -0.46179584f, 0.08452316f, -0.14785579f, 
    0.05711810f, -0.36728266f, 0.01387568f, -0.48563027f, -0.14464369f, -0.39331231f, -0.05302584f, 0.06781310f, 
    0.00161332f, -0.51997817f, 0.11038760f, 0.03998470f, 0.25110006f, -0.09501507f, 0.30644485f, -0.08506853f, 
    -0.18631072f, -0.13840170f, -0.02182935f, 0.07765967f, 0.04188192f, -0.05255229f, 0.25524840f, -0.66234046f, 
    -0.14035368f, -0.13130654f, -0.03901301f, 0.17535570f, 0.04442832f, 0.05411967f, -0.64941663f, 0.07849704f, 
    0.13107012f, -0.15501843f, 0.20232499f, -0.43198824f, 0.11791020f, 0.04923954f, 0.10030539f, 0.03278691f, 
    0.28724527f, 0.18763596f, -0.01804192f, -0.03472346f, -0.05187805f, 0.09231284f, 0.21126287f, -0.10100245f, 
    -0.03673524f, -0.07196324f, 0.13802107f, -0.12174817f, -0.02405118f, 0.15725751f, 0.08799554f, -0.29751661f, 
    -0.18463030f, 0.01613972f, -0.12464719f, 0.04399896f, -0.18787304f, -0.23910825f, -0.02071606f, 0.00537827f, 
    -0.78327024f, -0.10221840f, -0.03003792f, -0.03303045f, -0.30352610f, -0.27175766f, -0.29344109f, 0.09236296f, 
    0.28173110f, 0.11760835f, 0.07430314f, 0.17507738f, 0.10462090f, -0.06524774f, 0.12286212f, 0.07418171f, 
    0.02429604f, 0.17178287f, -0.03261312f, 0.00218353f, -0.23803861f, -0.26554596f, 0.14526998f, 0.11076400f, 
    -0.38582611f, -0.11858809f, 0.13109583f, 0.22424583f, -0.01227957f, -0.07993945f, 0.00017186f, -0.02914341f, 
    -0.16972053f, -0.12920961f, -0.49919009f, -0.45038894f, -0.23620526f, 0.25643957f, -0.00652232f, 0.18490419f, 
    0.13567737f, -0.33140653f, -0.42764410f, 0.10748732f, -0.06197179f, -0.41754636f, -0.01395323f, -0.05042864f, 
    0.02400754f, 0.08297148f, -0.03445655f, -0.21155186f, 0.24286591f, 0.22481540f, 0.02280482f, -0.14287551f, 
    0.18218735f, -0.11985959f, -0.02194372f, -0.02759887f, 0.11284197f, -0.12510452f, 0.11148751f, 0.13043605f, 
    0.19642779f, 0.09838651f, 0.00749277f, 0.24296856f, -0.06915726f, -0.21467380f, 0.08532546f, 0.03444672f, 
    0.11836682f, 0.16952091f, -0.12287845f, -0.30199140f, 0.13233615f, -0.12574033f, 0.28258276f, -0.00859884f, 
    -0.31032014f, 0.07224534f, -0.38203412f, 0.03980321f, -0.02972097f, 0.03210801f, -0.19318326f, 0.12156105f, 
    -0.43205133f, -0.02940125f, -0.21773256f, -0.37933597f, 0.00951129f, -0.09692712f, -0.04088982f, -0.19410557f, 
    0.18655297f, -0.04140356f, -0.00498733f, 0.10608106f, -0.37221095f, -0.33568132f, -0.05695237f, -0.43077818f, 
    0.00309562f, 0.06216454f, 0.14222220f, -0.05506010f, -0.03805336f, 0.07253993f, 0.31039158f, -0.04843685f, 
    -0.31075791f, 0.31758618f, -0.25691837f, -0.03328226f, -0.14326078f, -0.02968079f, -0.13510120f, -0.07323577f, 
    -0.00675049f, -0.01328698f, 0.29871330f, 0.15450472f, -0.21213245f, -0.06230145f, -0.10419933f, 0.18707570f, 
    -0.07139841f, -0.27915710f, 0.05898419f, -0.09835848f, -0.05455377f, -0.01210883f, -0.07282523f, -0.03048900f, 
    -0.36488542f, -0.04679276f, 0.13392097f, -0.00759600f, -0.12816678f, -0.08996043f, -0.35886109f, 0.13829565f, 
    0.24517582f, 0.12959668f, 0.09750485f, -0.10301629f, 0.19841851f, -0.09649993f, -0.43877593f, 0.20732641f, 
    0.16111508f, 0.00713388f, -0.32620263f, -0.09608236f, 0.19629969f, 0.07009637f, -0.11045402f, -0.23772810f, 
    0.03952073f, -0.20699149f, 0.13606305f, 0.15326613f, -0.10211515f, -0.11478107f, -0.03837443f, -0.01450171f, 
    -0.23731609f, 0.25693309f, -0.08621231f, -0.05813151f, -0.02526502f, 0.01537577f, -0.14723477f, -0.07053640f, 
    -0.07031689f, 0.17255118f, -0.16437228f, 0.00397943f, 0.13443547f, -0.08833085f, -0.66477191f, 0.04544418f, 
    0.10725216f, -0.10886163f, -0.02905575f, -0.04221400f, 0.02478074f, 0.20268524f, -0.29563037f, -0.25190851f, 
    0.04435898f, -0.36523432f, 0.07261749f, -0.43308118f, 0.11891196f, 0.11018977f, -0.16996235f, -0.05816142f, 
    -0.03755777f, -0.40658274f, -0.36563972f, 0.05879470f, -0.60989124f, 0.03113960f, 0.28599280f, -0.37452671f, 
    -0.17648689f, -0.66771424f, 0.26113099f, 0.05254554f, -0.39127091f, 0.12417364f, 0.21747762f, -0.44118309f, 
    0.19885957f, 0.04961845f, 0.12953757f, -0.37769184f, -0.38192266f, -0.16780059f, -0.63035238f, -0.03750564f, 
    -0.11445249f, 0.01396364f, 0.28047380f, -0.42089123f, -0.11713154f, 0.28792900f, -0.13088641f, -0.04148072f, 
    -0.05551252f, 0.09644386f, 0.02628369f, -0.02048069f, 0.09412565f, 0.06278315f, 0.02712856f, -0.06655775f, 
    -0.04447963f, 0.31099656f, 0.00369605f, -0.05744612f, 0.09883016f, 0.31285775f, -0.27426940f, -0.28713557f, 
    -0.14909185f, -0.07817786f, 0.16674557f, -0.22831973f, 0.17522947f, 0.12720843f, 0.17127049f, -0.12101007f, 
    -0.08519129f, 0.30681777f, 0.18940178f, 0.11573728f, -0.09926206f, 0.07125597f, 0.08626258f, 0.04084582f, 
    0.32788309f, -0.20409019f, 0.07791640f, -0.39635623f, -0.07645929f, -0.02009082f, -0.38846079f, 0.04842827f, 
    -0.29582551f, -0.25636402f, -0.13570118f, -0.04388954f, 0.10830764f, -0.34221318f, 0.09184774f, -0.13538808f, 
    -0.38798916f, 0.02100498f, -0.03418312f, -0.00678105f, -0.20046507f, 0.05283989f, -0.73028463f, -0.24229565f, 
    -0.34383681f, -0.25290385f, -0.16571267f, -0.23355013f, -0.12706549f, -0.27799004f, -0.00785247f, 0.11847910f, 
    0.15981530f, -0.16183622f, -0.02576783f, -0.03451214f, 0.06780408f, -0.05467894f, -0.44273132f, -0.06209441f, 
    -0.49554297f, 0.19611534f, 0.14075443f, 0.16072275f, -0.03641234f, -0.28756264f, -0.17154838f, 0.21673669f, 
    0.00755386f, 0.08263037f, 0.23363222f, -0.59652501f, 0.03411995f, -0.16969705f, -0.40774146f, 0.14982641f, 
    -0.22188693f, 0.27256116f, -0.07128310f, -0.23287572f, 0.15886767f, -0.11527244f, -0.03246701f, -0.07596727f, 
    0.04080211f, 0.17745991f, 0.19452670f, 0.12823869f, -0.25841710f, 0.09312864f, -0.52522033f, 0.01344930f, 
    0.08162999f, -0.43676466f, 0.35159051f, -0.04800550f, -0.44385195f, 0.30322960f, -0.17640103f, -0.17452601f, 
    -0.18008928f, 0.08559002f, -0.38911030f, 0.22647406f, -0.25092968f, 0.05050406f, -0.47404641f, -0.05739371f, 
    -0.55155987f, -0.11649683f, -0.25842640f, -0.23044695f, 0.27162915f, -0.03935526f, -0.06172088f, 0.12336177f, 
    0.10797411f, -0.16350067f, -0.03522263f, -0.05153353f, 0.05858606f, 0.15733586f, -0.37727803f, -0.00572555f, 
    0.30058357f, -0.14992936f, -0.12976937f, -0.14973618f, -0.08883078f, 0.15028296f, 0.10400420f, 0.20094486f, 
    0.15021418f, 0.08477441f, -0.02741437f, 0.14650810f, -0.24133912f, 0.19540511f, 0.14422588f, 0.01181015f, 
    -0.18736471f, -0.04260546f, 0.10223210f, 0.17110606f, 0.09703331f, 0.14907843f, 0.05034765f, 0.06736557f, 
    0.11221895f, -0.01720619f, -0.40748334f, -0.30706164f, -0.06036685f, 0.09150673f, -0.08260880f, -0.28529221f, 
    -0.40799901f, 0.02169700f, -0.43290403f, 0.08044171f, 0.11413786f, 0.05697091f, 0.07394408f, -0.37484804f, 
    0.29356736f, -0.10751818f, 0.17196697f, -0.38199112f, -0.14119910f, -0.00250209f, -0.16344734f, -0.31143230f, 
    -0.08833245f, -0.36896309f, 0.12594707f, 0.14231497f, -0.03825063f, -0.01645517f, 0.04995839f, -0.14181975f, 
    -0.02431598f, 0.15587215f, 0.18204045f, -0.11155709f, 0.00347573f, -0.43509126f, 0.15257528f, -0.02092529f, 
    0.40930149f, 0.12418934f, -0.02338760f, 0.08525842f, -0.07565359f, -0.20274965f, 0.05471878f, 0.11950394f, 
    -0.25936553f, -0.03367591f, -0.33724782f, 0.09089725f, -0.32932943f, -0.06272181f, -0.44349912f, 0.01907153f, 
    -0.62015313f, -0.17775004f, -0.56192595f, -0.17388007f, 0.25405318f, -0.31696028f, -0.23674706f, 0.03524476f, 
    -0.50540352f, 0.10981466f, -0.42450088f, 0.10414235f, -0.12103841f, 0.02655763f, 0.02796853f, -0.14849682f, 
    0.25606704f, 0.11923428f, 0.23852319f, -0.04097681f, -0.18293273f, -0.18533450f, -0.25282475f, -0.03890206f, 
    0.13563871f, -0.01539797f, -0.21659535f, 0.14082801f, 0.18269479f, 0.08463540f, 0.22018665f, 0.27948201f, 
    -0.03939152f, -0.16727702f, -0.14981753f, -0.26746574f, -0.10178340f, 0.10705877f, -0.04298789f, 0.05473704f, 
    0.27527919f, -0.07460485f, 0.19487877f, -0.10609470f, -0.09242463f, -0.06718431f, -0.11843836f, 0.10541911f, 
    -0.10402321f, -0.17605190f, 0.28170887f, 0.08088811f, -0.25577480f, -0.05921729f, -0.36830759f, 0.06107569f, 
    -0.38933337f, -0.11010826f, 0.10542966f, 0.02709453f, 0.05037515f, 0.07871482f, -0.09951691f, -0.13957240f, 
    -0.40293312f, -0.22895679f, -0.09030816f, -0.07309620f, -0.06916616f, -0.22824550f, -0.15670854f, 0.01355869f, 
    -0.03855774f, 0.18393596f, 0.01641510f, 0.18598476f, -0.42606866f, -0.05543819f, 0.16499342f, 0.01227193f, 
    0.12587501f, -0.01317810f, -0.31092760f, -0.00231788f, -0.14770883f, 0.26104382f, -0.00891335f, 0.01962858f, 
    -0.20188071f, -0.06028948f, 0.22315176f, 0.14777291f, -0.21639660f, -0.07974066f, -0.32680568f, 0.25397912f, 
    0.25337708f, 0.25333256f, 0.03231730f, 0.37821448f, -0.08309335f, 0.10565241f, -0.00375286f, -0.13538206f, 
    -0.22338279f, -0.15153770f, -0.18295135f, 0.02213633f, -0.04637621f, 0.16700052f, 0.34070835f, -0.15114784f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.03004570f, 0.00486351f, 0.08122609f, -0.17231695f, -0.12408426f, 0.07086166f, 0.03551116f, -0.13405313f, 
    0.02887786f, 0.06174843f, -0.16860102f, 0.01583825f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
