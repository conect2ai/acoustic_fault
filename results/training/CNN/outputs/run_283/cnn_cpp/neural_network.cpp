#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.52378994f, 0.33244351f, 0.40306354f, 0.81530958f, -0.22860235f, -0.09789985f, 0.18853046f, -0.13915756f, 
    0.46372461f, 0.48026949f, -0.02908988f, -0.10035830f, 0.21914890f, 0.35437542f, -0.21593350f, -0.22397281f, 
    0.08001263f, 0.13028093f, -0.05234794f, -0.49605811f, 0.18091382f, -0.17918742f, -0.42734641f, -0.09597212f, 
    0.08556142f, -0.30666035f, -0.55566978f, -0.51435357f, -0.20766521f, 0.04065773f, 0.67220372f, 0.88674766f, 
    -0.23361045f, 0.20477910f, 0.11784722f, -0.02317272f, 0.17850958f, -0.01586418f, -0.03778968f, -0.19685966f, 
    -0.14907138f, 0.03166217f, 0.08439382f, -0.06437033f, 0.09138830f, -0.05118693f, -0.04912804f, -0.12579705f, 
    -0.00655820f, 0.15176852f, -0.01532369f, 0.63073450f, 0.55685616f, -0.54689270f, -0.71782583f, -0.47573686f, 
    -0.06174430f, -0.28589886f, -0.46301323f, 0.05528392f, 0.07502491f, 0.24445835f, -0.44150349f, 0.18737590f, 
    0.16525479f, 0.26184160f, 0.20298807f, -0.12504181f, -0.12067103f, 0.11506792f, -0.00956765f, 0.08339877f, 
    0.09539329f, -0.24434978f, -0.16563874f, 0.53559947f, 0.23930286f, 0.71919757f, 0.63706487f, 0.15583719f, 
    -0.11952580f, 0.05060023f, -0.35951710f, -0.55874425f, -0.03469659f, 0.40343308f, 0.39959905f, -0.18885171f, 
    0.01436418f, 0.11032697f, -0.31449887f, 0.14081034f, -0.01117476f, 0.13217926f, -0.16190292f, 0.28633335f, 
    0.20489317f, 0.20095395f, 0.08963470f, 0.10381106f, -0.66557020f, 0.88483858f, 0.37084693f, -0.35568887f, 
    0.25023121f, -0.83684695f, 0.59812707f, -0.22361964f, -0.57555121f, 0.11033581f, 0.05384229f, -0.01059511f, 
    0.21330620f, -0.25630915f, -0.06747127f, 0.16047399f, -0.12644266f, 0.06223983f, -0.01915157f, -0.17491877f, 
    0.20572060f, 0.04652438f, -0.12727053f, 0.11616602f, 0.21702421f, -0.07016197f, -0.34737709f, 0.04622414f, 
    -0.45970041f, -0.54005539f, -0.35242257f, 0.32588735f, 0.43277496f, 0.04412314f, 0.16946046f, -0.11851123f, 
    -0.32653299f, -0.36749691f, 0.04395084f, 0.22556369f, -0.09899218f, -0.28358349f, -0.20357780f, -0.30851665f, 
    -0.01343292f, 0.22640109f, 0.30090284f, -0.24586716f, 0.04628355f, -0.18978435f, 0.20946550f, 0.15229845f, 
    0.45180568f, 0.97806793f, 0.18933959f, 0.34494248f, 0.15575227f, -0.07986584f, 0.33024573f, -0.07935235f, 
    -0.19897020f, 0.21046230f, 0.09968390f, 0.36558369f, -0.00563441f, -0.04094867f, 0.30983093f, -0.33455941f, 
    0.14102973f, -0.02494674f, 0.04413617f, -0.01731788f, 0.15710951f, -0.28996333f, 0.08892911f, 0.27455208f, 
    0.37961099f, -0.02397287f, 0.24069934f, 0.59073466f, -0.00083024f, -0.05084995f, 0.37799862f, 0.06854612f, 
    0.58832008f, -0.04395234f, -0.40184316f, -0.32806778f, -0.06642634f, -0.09429915f, 0.01076219f, -0.17325780f, 
    -0.10415366f, 0.03635335f, -0.06975498f, 0.47957268f, 0.06852295f, 0.15886025f, 0.23496705f, 0.02081651f, 
    0.87058598f, 0.32208166f, 0.51417774f, 0.06856516f, 0.62911969f, 0.01085671f, -0.00478485f, -0.24384449f, 
    -0.59749740f, 0.09694394f, 0.11412101f, 0.23369867f, 0.20897639f, 0.07560559f, -0.13931620f, 0.02871613f, 
    -0.23676981f, 0.26291445f, 0.06130630f, -0.32724953f, -0.27227929f, -0.04972667f, -0.01560593f, -0.17689501f, 
    -0.03487038f, -0.43369758f, -0.76447302f, -0.36118376f, 0.27694818f, -0.37586871f, -0.62527794f, -0.00389964f, 
    0.07815257f, -0.46824983f, 0.33742738f, 0.23618212f, 0.33082679f, -0.03461079f, 0.09949327f, 0.14213626f, 
    -0.06994432f, -0.19990566f, 0.06569964f, 0.12872468f, 0.20137888f, -0.03100608f, 0.19294983f, 0.04011840f, 
    0.20632114f, -0.06539819f, -0.35156718f, 0.29797494f, 0.07847594f, -0.53765696f, -0.19163257f, -0.37699968f, 
    -0.47624782f, 0.27560523f, 0.18404004f, -0.44587478f, 0.13783577f, 0.11826193f, -0.10921904f, 0.24824777f, 
    -0.25459775f, -0.50450373f, 0.11213776f, -0.26265770f, -0.37162980f, -0.07312342f, 0.30080265f, -0.17831087f, 
    -0.09623349f, -0.03089602f, -0.33656174f, 0.01416402f, 0.31318310f, -0.60529405f, 0.10140169f, -0.33306345f, 
    0.05778540f, -0.90276700f, -0.26474676f, 0.04061881f, -0.41802338f, 0.20559533f, 0.27906373f, 0.39764872f, 
    -0.06807858f, -0.19248641f, 0.15354434f, 0.23095922f, 0.20913664f, 0.03973738f, 0.10687883f, -0.15989569f, 
    0.00148552f, 0.16745539f, 0.21443240f, -0.00851655f, -0.40752882f, -0.69664770f, -0.30591789f, 0.74440920f, 
    -0.07698873f, -0.05323100f, -0.16662392f, 0.11282419f, -0.12211642f, -0.43075302f, -0.00211202f, 0.14496179f, 
    -0.30234709f, 0.21061520f, 0.16861708f, 0.20968159f, 0.24206047f, 0.05244103f, -0.44768468f, 0.25656769f, 
    -0.16563727f, 0.01930334f, -0.11290711f, 0.05701851f, -0.20419252f, -0.62839949f, 0.48557460f, 0.20336235f, 
    0.24849012f, 0.53911316f, -0.20237140f, 0.56730711f, 0.67451125f, -0.31004217f, 0.47615686f, -0.18724382f, 
    -0.21755593f, 0.24003345f, -0.24749453f, -0.30975899f, 0.01433974f, 0.01638657f, -0.23723958f, 0.04860632f, 
    0.04506692f, 0.01266244f, -0.13126779f, 0.03751453f, -0.05394498f, 0.02343235f, -0.01636374f, -0.08484670f, 
    -0.66005963f, -0.51120955f, -0.20545647f, -0.10505214f, -0.19737944f, 0.46364126f, 0.19612175f, 0.05603025f, 
    -0.41981196f, 0.05444147f, -0.39072397f, -0.14513935f, -0.60015786f, 0.11855877f, 0.16783199f, 0.28220645f, 
    0.11654796f, -0.01291447f, 0.04403239f, 0.32660359f, -0.03054319f, 0.12858807f, 0.17345454f, -0.81887543f, 
    0.21455321f, -0.42668596f, -0.44542244f, -0.03296887f, 0.21922737f, 0.78166217f, 0.26356214f, 0.10384835f, 
    0.52625859f, -0.00036296f, -0.05219211f, 0.35906091f, -0.23140056f, 0.25192282f, 0.18580648f, 0.11539558f, 
    0.07945997f, 0.12739645f, -0.32028720f, -0.02384768f, 0.00411110f, 0.13231088f, -0.07434092f, -0.04394967f, 
    0.07154941f, 0.56737185f, 0.32991719f, 0.51572609f, 0.23205316f, -0.22802489f, -0.69176322f, -0.58662450f, 
    -0.71737385f, -0.25650623f, 0.01186461f, 0.33955100f, 0.11536831f, 0.37657416f, -0.27898785f, 0.16580141f, 
    0.16599350f, 0.30093867f, -0.13350219f, 0.11542587f, -0.10481459f, -0.14049059f, -0.23626532f, 0.04465493f, 
    0.05460482f, -0.29341701f, -0.72729033f, -0.60310620f, -0.05486917f, 0.29439026f, -0.70971322f, 0.62345058f, 
    0.32978219f, -0.81813592f, -0.06614441f, 0.21803348f, 0.07268799f, 0.10386542f, 0.00176138f, 0.20967424f, 
    -0.36982384f, 0.09546234f, -0.08555526f, -0.15158173f, -0.19080630f, -0.01287684f, -0.11862684f, -0.02296206f, 
    -0.05274541f, -0.07039305f, 0.44419101f, -0.51140380f, -0.51463461f, -0.29050520f, -0.52887231f, -0.08868083f, 
    0.72278923f, -0.01452658f, -0.21345423f, 0.08806191f, 0.27257097f, 0.02113047f, -0.15276888f, -0.24267918f, 
    0.32784671f, -0.17441902f, 0.06104256f, 0.07893948f, 0.24450797f, 0.29456672f, 0.17272107f, 0.15075737f, 
    -0.08598749f, -0.04235655f, 0.23619820f, -0.18953201f, -0.21396600f, -0.12671009f, 0.02527297f, -0.52254915f, 
    -0.03004830f, -0.21326718f, 0.17051819f, -0.47659653f, -0.07868288f, -0.21105237f, 0.03076412f, -0.34337294f, 
    0.02497463f, -0.02691624f, -0.23534584f, -0.27777657f, -0.22220804f, 0.25692159f, -0.43474391f, -0.34591445f, 
    -0.08335492f, -0.00380832f, 0.12140913f, 0.27618632f, 0.76864100f, -0.15818012f, -0.83971328f, 0.80906987f, 
    0.20875531f, -0.22819875f, 0.48524839f, 0.45664141f, 0.42183051f, -0.17039119f, -0.19830674f, -0.21897271f, 
    -0.11039936f, -0.27080363f, 0.18219285f, 0.20021488f, -0.23226468f, -0.13717318f, 0.05518162f, 0.18969586f, 
    0.10793515f, -0.02632855f, 0.02236775f, 0.18823646f, -0.06537100f, 0.60125250f, -0.14980862f, -0.61014849f, 
    -0.58398348f, -0.34911501f, 0.16018926f, -0.25383684f, 0.04155577f, 0.09127692f, 0.13956706f, 0.12988229f, 
    -0.15965709f, -0.12842584f, 0.06983897f, 0.18506803f, -0.12998486f, -0.01665259f, -0.11994074f, -0.30531633f, 
    -0.06112012f, 0.06740333f, 0.09289189f, 0.28190139f, 0.46379286f, -0.17810208f, -0.71225291f, -0.33063790f, 
    0.25051135f, 0.07804711f, -0.32864916f, 0.25623226f, 0.46521327f, 0.32716444f, 0.14553286f, -0.05929051f, 
    -0.32941172f, 0.10657284f, -0.24358679f, -0.27531725f, -0.32054579f, -0.44698957f, 0.29888794f, -0.05030390f, 
    0.41068470f, -0.42893603f, 0.38199219f, -0.21105689f, 0.01334545f, -0.16612983f, -0.03745599f, -0.11576221f, 
    0.20320985f, -0.17918891f, -0.68286735f, 0.13987829f, 0.37742871f, -0.51901603f, -0.47400036f, 0.11409974f, 
    -0.56369299f, -0.32651794f, -0.24427709f, 0.01177308f, 0.09044792f, -0.25877976f, 0.11446010f, 0.01211657f, 
    -0.55033505f, -0.02484382f, 0.24802445f, -0.14066969f, 0.05188321f, 0.17755133f, 0.03214481f, -0.20584254f, 
    -0.48585364f, -0.49785250f, -0.35170159f, 0.32640600f, 0.59649092f, 0.03762006f, 0.46041027f, 0.62133783f, 
    -0.02447392f, 0.26887089f, 0.09601179f, -0.46484274f, 0.02852516f, -0.53273207f, -0.00654226f, -0.04960216f, 
    -0.02921588f, -0.12156618f, -0.03967050f, -0.13991630f, -0.07730169f, -0.14693613f, 0.09198856f, 0.21837984f, 
    -0.22371577f, 0.97469324f, 0.27938464f, -0.54359007f, 0.37712753f, -0.04926284f, -0.34169969f, -0.57542527f, 
    0.19182855f, -0.35338986f, -0.17690392f, -0.14044601f, 0.35566869f, -0.00436579f, 0.13080002f, 0.16728483f, 
    0.02863724f, 0.01394656f, -0.37553763f, -0.31748787f, 0.37522146f, -0.14559868f, 0.08324241f, -0.06268352f, 
    0.06631255f, -0.12920170f, 0.14074178f, -0.61703283f, 0.04672375f, 0.01302473f, -0.12634300f, -0.19909407f, 
    -0.81264418f, -0.39941862f, 0.35371786f, -0.09631272f, -0.04036710f, -0.07835498f, 0.52873051f, 0.05529470f, 
    -0.27013597f, -0.00823401f, -0.23924945f, 0.39419332f, 0.09990077f, -0.04604880f, 0.33048421f, 0.28141823f, 
    0.05364309f, -0.16967030f, -0.17346931f, 0.67788202f, 0.08456796f, 0.29632190f, -0.52397078f, -0.67357999f, 
    -0.01441416f, -0.40596187f, 0.48822173f, 0.37456197f, 0.55630404f, -0.23359825f, 0.15951630f, -0.05755341f, 
    -0.20802388f, -0.19666058f, -0.15262924f, -0.17560908f, 0.19513273f, -0.22072497f, 0.36955690f, 0.35586956f, 
    0.10852810f, 0.20997967f, -0.06049891f, 0.19931118f, 0.24229383f, -0.59076422f, 0.51763970f, 0.50347722f, 
    -0.24099681f, -0.19990492f, -0.05495283f, 0.34244573f, -0.09563430f, -0.60055363f, -0.10510419f, -0.31167600f, 
    -0.22508101f, -0.20112564f, -0.39468205f, -0.17962179f, -0.25021490f, -0.22534572f, -0.02940240f, -0.21904644f, 
    -0.31893355f, 0.03863706f, -0.02808511f, 0.29338175f, -0.03151518f, 0.71132755f, 0.81852049f, -0.04497591f, 
    0.03342088f, -0.82601100f, 0.21315740f, -0.07480739f, -0.32620215f, -0.10070173f, 0.25002566f, 0.44258288f, 
    0.52087635f, 0.08039342f, 0.13071853f, 0.14944759f, 0.18628009f, -0.07712120f, 0.02380434f, 0.02846160f, 
    0.25955385f, -0.25989214f, -0.03756063f, 0.00901678f, -0.15148550f, 0.12165891f, -0.15285923f, -0.85227913f, 
    -0.49741226f, -0.24300292f, -0.22492205f, 0.47891542f, -0.09655483f, 0.56225687f, 0.56790262f, -0.08909309f, 
    0.11990237f, -0.06156975f, -0.30888686f, 0.17293380f, 0.16678534f, 0.05994749f, -0.01824377f, -0.03901706f, 
    0.13247620f, 0.10698746f, -0.31112802f, -0.12490535f, 0.09524526f, -0.20946349f, -0.03823369f, 0.02147634f, 
    0.52602875f, 0.75898969f, 0.22858196f, 0.07515125f, -0.05397663f, 0.22266819f, 0.08647092f, 0.11810272f, 
    -0.57502705f, -0.05974631f, -0.18489090f, -0.05410410f, -0.12615989f, 0.34159446f, -0.00654140f, -0.11550152f, 
    0.06009027f, 0.17020844f, -0.22506572f, -0.05426187f, 0.09964311f, 0.31654930f, 0.19338056f, 0.27702099f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28525952f, 0.07670958f, 0.12555721f, 0.19163045f, 0.09224485f, -0.06402558f, 0.22389835f, 0.05253734f, 
    -0.00244079f, 0.16341090f, 0.03701237f, 0.12667407f, 0.25474989f, 0.14592236f, -0.02606655f, 0.10602989f, 
    0.24202596f, 0.04981503f, 0.27244705f, -0.11162981f, 0.11819301f, 0.32229304f, -0.07225981f, 0.13534331f, 
    0.26266897f, 0.14157501f, 0.39578864f, 0.28494793f, 0.10783326f, -0.11597932f, 0.10381328f, 0.22534822f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00510044f, -0.01446480f, 0.00558213f, 0.04162725f, 0.01210907f, -0.05247625f, 0.02368872f, -0.02465702f, 
    -0.01577339f, 0.00349696f, 0.00641816f, -0.02284635f, -0.03378347f, 0.03321716f, 0.02067680f, 0.01168569f, 
    -0.04807411f, 0.03466059f, 0.04404915f, 0.02957542f, 0.00880345f, -0.01490530f, -0.00536358f, -0.03413886f, 
    0.02784931f, -0.05625455f, -0.02324508f, -0.00944317f, 0.00173655f, -0.02651870f, 0.05198294f, 0.01188377f, 
    -0.03748308f, 0.01593513f, 0.04004980f, 0.00327153f, 0.00565826f, -0.00951648f, -0.00628507f, 0.04963382f, 
    -0.03585287f, 0.01890331f, -0.05284803f, 0.01197407f, -0.02524106f, 0.03274719f, -0.03516588f, -0.00261903f, 
    -0.02825693f, 0.00050509f, -0.01540603f, -0.05138930f, 0.01501716f, 0.02100765f, 0.03772679f, -0.00975087f, 
    0.03421826f, 0.02690548f, -0.00734906f, 0.01781116f, -0.02658255f, 0.03334668f, -0.05124553f, 0.01164581f, 
    0.00963370f, -0.03244228f, -0.01545260f, -0.01890261f, -0.03494270f, -0.00023879f, 0.01153521f, -0.03486524f, 
    -0.00640367f, -0.01533351f, -0.00344073f, -0.00295259f, 0.01851151f, 0.02200357f, -0.02563925f, -0.01727026f, 
    -0.04709769f, 0.03380072f, -0.02304124f, -0.03042694f, 0.01318583f, 0.02824919f, -0.05254724f, 0.00086911f, 
    0.00857402f, 0.03073947f, -0.00863339f, 0.02196624f, -0.00849865f, -0.02833630f, -0.03933384f, 0.01707430f, 
    0.03775723f, -0.03908338f, -0.04462652f, -0.00576364f, 0.04769725f, -0.00038322f, -0.01000915f, 0.02281301f, 
    0.01485487f, -0.04044414f, 0.03729229f, -0.03999197f, 0.01767256f, -0.04908024f, -0.03985605f, -0.04304907f, 
    -0.00067137f, 0.04558997f, -0.03266881f, -0.02662146f, -0.00627219f, 0.02915793f, -0.02969261f, 0.02135916f, 
    0.02814327f, 0.01544567f, 0.00800181f, 0.01855189f, -0.01736528f, -0.01453853f, -0.02315667f, 0.02020342f, 
    -0.04143361f, -0.04238372f, -0.00530041f, -0.02539602f, 0.02476398f, -0.01014238f, 0.04554620f, -0.00631638f, 
    -0.03878393f, 0.01176677f, -0.02838578f, 0.01867828f, -0.00932201f, 0.00661817f, 0.03326266f, 0.03104544f, 
    -0.05150561f, -0.00431695f, -0.02710343f, 0.02479642f, -0.02415655f, -0.01859448f, 0.00666771f, -0.00395141f, 
    0.00990718f, -0.03223982f, 0.00946968f, -0.04466722f, -0.03194714f, -0.01206030f, 0.03257806f, 0.04196436f, 
    -0.04282284f, 0.02540281f, -0.05087263f, -0.03490539f, -0.00956920f, 0.03667241f, -0.02927116f, -0.04450282f, 
    -0.04107489f, 0.03480278f, 0.02278191f, -0.02801142f, 0.02124195f, -0.01359685f, 0.02285923f, 0.05146670f, 
    -0.04120338f, 0.00005302f, 0.03131564f, 0.02975330f, 0.00433344f, -0.05229906f, 0.03220443f, -0.04172479f, 
    0.01840227f, 0.03728838f, -0.01401218f, -0.00420055f, -0.04398878f, 0.02928481f, 0.00008992f, -0.04953650f, 
    0.01839510f, -0.03320766f, -0.00825912f, 0.00370185f, 0.00249216f, -0.00927201f, 0.03400916f, 0.01064500f, 
    0.01400064f, 0.02091238f, 0.01930409f, -0.01427730f, 0.01225137f, -0.02558240f, -0.05289199f, 0.03408120f, 
    0.00476900f, 0.03583097f, -0.00603626f, -0.03604608f, -0.02016021f, -0.02378104f, -0.03176980f, -0.02776241f, 
    0.01744830f, 0.02340743f, -0.02222714f, 0.03908473f, 0.02232558f, -0.04504891f, -0.02603673f, -0.03549155f, 
    -0.02060802f, -0.04987736f, 0.03114428f, 0.01340023f, -0.01754433f, -0.03268557f, -0.03427844f, 0.04538818f, 
    0.00970100f, 0.00928076f, -0.03420421f, -0.02763825f, 0.02730322f, -0.01174273f, 0.03464609f, 0.02897259f, 
    -0.03394772f, 0.00079033f, -0.00418123f, 0.02083235f, 0.00878323f, -0.04919889f, -0.03596045f, 0.00427776f, 
    0.01478807f, 0.04786645f, 0.00607430f, -0.00437779f, 0.02164870f, -0.02634048f, 0.03703611f, 0.01296803f, 
    0.03833584f, -0.04213236f, 0.05151046f, 0.03652025f, 0.04791180f, -0.03479226f, 0.00899094f, -0.01261006f, 
    -0.01034382f, 0.04426794f, -0.01522458f, 0.01687775f, -0.03480347f, 0.00082369f, -0.01094676f, -0.01049311f, 
    0.04757046f, -0.03319229f, -0.05421370f, -0.03605167f, -0.02576092f, -0.04645005f, 0.00686313f, 0.02040306f, 
    -0.03120128f, -0.04863302f, -0.03878924f, -0.02308447f, 0.04049540f, 0.04226529f, -0.00885084f, -0.01600456f, 
    0.02586783f, 0.04090827f, -0.02699839f, 0.04462065f, 0.01295183f, -0.00063719f, -0.05571983f, 0.01043022f, 
    -0.04168660f, -0.03110372f, 0.00453746f, 0.04091183f, -0.04441809f, -0.03714324f, -0.02718856f, 0.00632667f, 
    -0.03432837f, -0.01984978f, 0.03609221f, 0.03157442f, 0.01687284f, -0.03020767f, -0.05000686f, -0.02746232f, 
    -0.01046845f, -0.00018008f, -0.01366380f, -0.02926595f, -0.04654948f, -0.00428106f, -0.00006717f, 0.02371388f, 
    -0.00852010f, 0.00601220f, 0.02626441f, -0.01857345f, -0.03616424f, -0.03429618f, 0.01435201f, -0.02221754f, 
    0.00164135f, -0.03759368f, 0.04675246f, -0.04057301f, -0.03156367f, 0.00477108f, 0.02697563f, -0.01969113f, 
    0.03885176f, -0.03832607f, -0.00078378f, -0.03933029f, -0.00071156f, -0.03063070f, 0.02236534f, -0.03225178f, 
    0.04838900f, 0.01735121f, -0.01592126f, 0.04386001f, 0.04709103f, -0.05294063f, 0.00196641f, 0.04362480f, 
    -0.04332979f, -0.00536330f, -0.04019815f, 0.04031672f, -0.04634267f, 0.00094964f, -0.03312191f, -0.01491215f, 
    -0.01969558f, -0.01488511f, -0.01899231f, -0.05067765f, 0.02702539f, 0.03464647f, -0.02304023f, -0.05578494f, 
    -0.04340687f, 0.00034722f, -0.02017940f, -0.04165555f, 0.04512814f, 0.02520772f, -0.00227184f, 0.00570142f, 
    -0.02388939f, -0.01315331f, 0.02815371f, -0.03950139f, -0.00436689f, 0.04609308f, 0.02198469f, -0.03210708f, 
    0.00101333f, 0.00964018f, 0.02061061f, -0.02125067f, 0.01803276f, -0.03158036f, -0.05722932f, 0.01534846f, 
    0.01117943f, -0.03965432f, -0.04779924f, 0.03706369f, 0.03395386f, -0.00396979f, -0.01880830f, -0.01157952f, 
    -0.02019045f, -0.04456919f, -0.06184948f, 0.01025497f, -0.02210180f, -0.04048920f, 0.02824305f, 0.01466524f, 
    0.03716436f, -0.03150946f, 0.02110708f, -0.04413988f, 0.03889814f, 0.01945516f, -0.01022385f, -0.01010311f, 
    0.03427250f, 0.01745374f, -0.01533400f, 0.04283400f, -0.00846090f, 0.01951929f, 0.00502498f, -0.01469508f, 
    0.01342052f, -0.00597584f, -0.02866406f, -0.04399349f, -0.00560109f, 0.01934110f, -0.01258157f, 0.02724257f, 
    -0.00327242f, 0.02171388f, -0.00302492f, -0.01037989f, 0.03830690f, -0.05182852f, 0.00953303f, 0.01223069f, 
    -0.00131294f, -0.02217431f, 0.01933315f, 0.03190860f, 0.01697210f, 0.04091264f, -0.04470192f, 0.00506245f, 
    -0.03418930f, 0.01990578f, -0.02636576f, 0.01946534f, -0.02984849f, 0.03114746f, 0.02452103f, -0.00817014f, 
    0.01014966f, -0.03958789f, 0.02260968f, 0.02728324f, 0.03769389f, -0.00745825f, -0.01880064f, -0.01601711f, 
    0.00384284f, 0.00683671f, 0.00539181f, 0.01679555f, -0.00269431f, -0.03152763f, -0.02126134f, 0.02372553f, 
    -0.02238810f, -0.04525866f, 0.01141807f, -0.01617940f, -0.04791621f, -0.02171892f, 0.05035830f, 0.02821306f, 
    0.01559890f, 0.04671288f, -0.00579062f, -0.05070181f, 0.04212432f, -0.05417653f, 0.01530156f, -0.02137965f, 
    0.00718418f, -0.00770387f, -0.02553917f, -0.00510319f, -0.01914158f, -0.01952142f, -0.01418562f, -0.04166901f, 
    -0.02038626f, -0.01918795f, -0.01245686f, -0.05417810f, -0.05885508f, -0.00132682f, -0.01176025f, -0.04393634f, 
    0.03816968f, 0.02831924f, -0.03436268f, -0.04463267f, 0.00695529f, -0.00486630f, -0.01398733f, 0.01098401f, 
    0.04564445f, -0.01251297f, 0.02228054f, -0.03291746f, -0.05432669f, -0.01499742f, -0.01346314f, -0.03148182f, 
    -0.05361034f, -0.00813301f, -0.05808558f, 0.01050259f, 0.02993032f, 0.01792525f, -0.05334544f, -0.00292478f, 
    -0.05030477f, -0.05859158f, -0.01296232f, 0.00932528f, -0.05503425f, -0.04037026f, -0.02212803f, -0.03859269f, 
    0.01985607f, 0.01928327f, -0.05642529f, -0.02934251f, -0.01924469f, -0.02547753f, -0.02881170f, -0.02119557f, 
    0.01167467f, -0.03569628f, 0.02454655f, -0.00252346f, -0.01258556f, 0.00895009f, 0.03466295f, -0.01167214f, 
    -0.05461202f, 0.01661590f, -0.02557851f, -0.02216921f, 0.00878599f, 0.02914897f, -0.04794408f, 0.00044604f, 
    -0.02685800f, -0.00709830f, -0.04313600f, -0.00020941f, 0.00827282f, 0.02391703f, 0.02862811f, -0.02959537f, 
    0.01589160f, 0.04047685f, 0.01956102f, 0.03201221f, 0.00117312f, 0.03367664f, -0.04120905f, 0.02099668f, 
    0.02129850f, 0.03930688f, -0.04524633f, -0.05444999f, 0.03093365f, -0.02297920f, 0.03395724f, 0.00261240f, 
    -0.04122384f, -0.00013097f, 0.00219624f, -0.03223131f, 0.00654790f, -0.03298245f, -0.02109578f, 0.02476031f, 
    0.00428272f, -0.02055122f, 0.01432300f, -0.04760728f, -0.04082448f, -0.02356079f, 0.01069991f, -0.04207154f, 
    0.00151043f, -0.04369302f, 0.00161600f, 0.02237034f, -0.03090477f, -0.03387765f, -0.01228298f, 0.03176242f, 
    0.03623965f, -0.02347382f, -0.02410324f, -0.03130313f, 0.03566208f, -0.00438706f, -0.01287904f, 0.04395253f, 
    -0.01632929f, -0.05362656f, -0.03632336f, 0.03738568f, 0.03086534f, -0.04631310f, 0.01917556f, -0.03448974f, 
    -0.04176857f, -0.04609327f, 0.03891886f, 0.00824323f, -0.02301667f, -0.05354294f, 0.04872737f, -0.01077606f, 
    -0.01978909f, -0.03977235f, -0.01915485f, 0.00482491f, -0.01474005f, -0.02096895f, 0.04265213f, 0.00878491f, 
    0.01689697f, -0.04629104f, -0.05667789f, 0.03061434f, -0.04540686f, -0.05491235f, -0.00234554f, -0.02806163f, 
    0.01197756f, -0.04816969f, 0.03503643f, 0.00324429f, 0.00235341f, -0.01848571f, -0.04514120f, -0.01636191f, 
    -0.00490870f, 0.02551574f, -0.02903140f, -0.03479810f, 0.00882580f, -0.01017437f, -0.00142739f, 0.03046269f, 
    -0.03024524f, -0.00611080f, 0.03739055f, -0.02529380f, 0.00932568f, 0.01436745f, -0.01020692f, -0.00313087f, 
    0.02645251f, 0.02783544f, 0.03691727f, 0.00317943f, -0.02847827f, -0.01977329f, -0.01812460f, 0.02659003f, 
    -0.00449759f, -0.03971827f, 0.03916273f, -0.03516738f, -0.00141440f, 0.00801493f, 0.03305247f, -0.05557447f, 
    -0.05749182f, 0.02325380f, -0.00598947f, -0.00419049f, -0.02044304f, -0.00005881f, -0.04122221f, 0.00902716f, 
    -0.01620559f, -0.05492791f, 0.00643994f, -0.03982068f, -0.00628737f, 0.01242596f, 0.01540503f, -0.03188158f, 
    -0.02890429f, 0.02321169f, -0.02756915f, 0.02057941f, -0.01013501f, -0.01162357f, -0.04226075f, -0.05416077f, 
    -0.00176413f, -0.00636553f, -0.03118220f, 0.01099444f, -0.03667851f, -0.00524466f, -0.00255104f, -0.02751208f, 
    -0.01290403f, 0.00070863f, 0.02422438f, 0.01348123f, 0.01374390f, 0.02685519f, 0.02285393f, 0.02203511f, 
    0.01596414f, -0.04361621f, -0.04987311f, 0.02377404f, -0.05577637f, -0.00323633f, 0.01242875f, -0.01145501f, 
    0.00549448f, 0.03126357f, 0.04846893f, 0.03994643f, 0.02447054f, -0.05261461f, -0.02295726f, 0.03696049f, 
    -0.03479688f, 0.01401238f, -0.00829470f, 0.04012859f, 0.01124208f, 0.01429769f, 0.02845969f, -0.01648113f, 
    -0.02599520f, -0.05853903f, -0.04183098f, 0.01908647f, -0.01016577f, -0.00733372f, -0.04777861f, -0.03857089f, 
    0.02444833f, -0.03598299f, 0.01307924f, 0.04368354f, 0.01525989f, -0.04352795f, -0.00737140f, 0.00738946f, 
    0.00803505f, 0.01223473f, -0.02462946f, -0.04987823f, 0.00233368f, 0.01716313f, 0.03835431f, 0.02293101f, 
    0.00298664f, 0.01605599f, 0.02118171f, 0.02946023f, -0.05567252f, -0.04361211f, 0.03722278f, 0.04028253f, 
    -0.01935430f, -0.00413096f, -0.02730585f, -0.04785299f, 0.04238358f, -0.03385279f, 0.01023991f, 0.03431382f, 
    0.01210001f, -0.04014769f, 0.01796079f, -0.04079735f, 0.02031663f, 0.03449506f, -0.01979052f, 0.02482049f, 
    -0.05014906f, -0.00097460f, -0.03790382f, -0.01790318f, -0.04561637f, 0.03506091f, -0.00044443f, -0.00237090f, 
    0.03242995f, -0.01314040f, 0.03281992f, 0.00305450f, -0.02387883f, 0.01746237f, -0.01318250f, -0.04770346f, 
    -0.01526349f, 0.00696838f, 0.00224380f, 0.00213743f, 0.00159397f, -0.03451087f, 0.01106171f, 0.00073103f, 
    0.02807152f, 0.03878112f, 0.01370094f, -0.05172157f, -0.03109684f, 0.01305127f, -0.00949552f, -0.04406017f, 
    -0.02488354f, 0.03085238f, -0.03307581f, -0.05838848f, 0.04453290f, -0.02024246f, 0.03377720f, 0.02213383f, 
    0.02602798f, 0.02357855f, -0.04077442f, -0.00374715f, -0.03452030f, 0.02141911f, -0.05130680f, 0.01548226f, 
    0.03277987f, 0.02695481f, -0.04522537f, 0.00933753f, 0.00349309f, 0.02516651f, 0.01630104f, -0.01628815f, 
    0.01284113f, 0.05066906f, 0.02693332f, 0.01762903f, 0.02369849f, -0.04784413f, -0.00580608f, 0.01367180f, 
    0.00756257f, -0.01486371f, 0.03840403f, -0.02831022f, -0.03403680f, -0.00644918f, -0.05771614f, -0.00366109f, 
    -0.02136526f, -0.01098215f, -0.00209574f, 0.03475508f, 0.03441174f, 0.04342975f, 0.04176957f, -0.01171194f, 
    0.01973001f, 0.01522344f, 0.02307617f, 0.04066932f, -0.00541358f, -0.01734281f, 0.00023141f, 0.00183711f, 
    0.02442525f, -0.04549666f, -0.01977646f, -0.02632585f, -0.04695610f, -0.04683190f, 0.03684578f, -0.01443847f, 
    -0.00392977f, -0.03589257f, 0.03734083f, -0.02110504f, 0.02936934f, -0.00787788f, -0.00511084f, -0.05169855f, 
    -0.01595269f, -0.03672945f, -0.03498906f, 0.00513202f, -0.05563840f, -0.02243332f, -0.05127111f, 0.00485108f, 
    0.03624826f, -0.01217138f, 0.00230663f, -0.04010564f, 0.03542364f, 0.03584373f, -0.02138361f, -0.03432863f, 
    -0.04887715f, -0.05147926f, -0.02518477f, 0.01255172f, -0.04750402f, 0.01157480f, 0.04466094f, 0.02259993f, 
    -0.04749860f, -0.02709934f, 0.01397260f, 0.00816308f, 0.03957746f, 0.02645756f, 0.01715964f, 0.02546616f, 
    0.02364136f, 0.01795251f, 0.02596735f, 0.03789153f, -0.00090104f, -0.02862384f, -0.02086147f, 0.00221142f, 
    -0.04687344f, 0.04183486f, -0.03277182f, -0.03585654f, 0.01474685f, -0.01343242f, -0.02354392f, -0.04790436f, 
    -0.05332679f, -0.03667760f, -0.03960811f, 0.02949093f, 0.02031508f, -0.00750649f, 0.02064911f, -0.00265239f, 
    -0.03738166f, 0.00286495f, -0.02045492f, -0.03097847f, 0.00459221f, 0.04092370f, 0.00021033f, -0.01692912f, 
    -0.01085593f, 0.02845364f, 0.01741424f, -0.03187512f, -0.00473660f, -0.00746870f, -0.01155476f, 0.01495553f, 
    0.04430972f, 0.02993663f, -0.01139158f, 0.00070065f, -0.00450543f, -0.03250928f, -0.00531105f, 0.03180582f, 
    0.03458939f, -0.02290431f, -0.00866724f, 0.03393527f, 0.03235579f, -0.05257951f, -0.05478189f, 0.04698234f, 
    0.03402168f, 0.00279864f, -0.01563207f, -0.05572019f, -0.02478458f, 0.02262927f, 0.02296604f, 0.02200915f, 
    0.01446634f, -0.03652285f, 0.02780270f, -0.05137797f, -0.02593428f, -0.03683829f, -0.01621504f, -0.05489846f, 
    0.02429632f, -0.03208252f, -0.00333870f, -0.02004043f, -0.00261067f, -0.02018528f, -0.00645030f, -0.01575582f, 
    -0.04544268f, 0.02746166f, -0.02337832f, -0.04568851f, 0.00266830f, 0.01832076f, 0.02026869f, 0.00554856f, 
    -0.01431446f, -0.00825404f, -0.03739826f, 0.04161744f, -0.04664791f, -0.04391488f, -0.01245247f, 0.00498934f, 
    0.03932406f, -0.01340699f, -0.02108680f, 0.00256092f, -0.00944144f, 0.03960960f, 0.02021507f, 0.02942219f, 
    0.03131864f, 0.01918888f, -0.05395097f, -0.00241711f, 0.02663505f, -0.02458749f, -0.00586083f, 0.02547974f, 
    -0.03184870f, -0.04181296f, 0.00321830f, -0.02339572f, -0.04940520f, 0.02718840f, -0.01480188f, 0.01517731f, 
    0.00968077f, -0.03213178f, 0.02263754f, 0.02301198f, -0.05424326f, -0.02803454f, -0.03524541f, -0.00281332f, 
    -0.05887168f, -0.02128658f, -0.02789863f, 0.00901868f, 0.01296091f, -0.02715642f, 0.01378943f, -0.01492585f, 
    0.03684707f, 0.00871854f, 0.02496565f, -0.05818435f, 0.01648159f, -0.03010410f, -0.06001073f, 0.00852041f, 
    0.01589521f, -0.01354655f, -0.05094663f, 0.01944718f, -0.03841687f, 0.00152986f, 0.03813147f, -0.04228491f, 
    0.01066181f, -0.02976834f, 0.00620690f, -0.02325670f, -0.05213841f, -0.05308999f, -0.01184348f, -0.02611761f, 
    0.02708115f, -0.00216297f, -0.05487785f, 0.02350953f, 0.01455772f, 0.02563363f, -0.03163457f, 0.02500657f, 
    0.00955607f, 0.01296149f, -0.02017130f, 0.00666111f, -0.04980043f, -0.05734006f, -0.01740469f, -0.05515404f, 
    -0.04835545f, -0.01678867f, 0.00762272f, 0.03675511f, -0.00818986f, -0.03041905f, -0.04013307f, 0.02852741f, 
    0.00929162f, -0.02971439f, 0.03144862f, -0.01019742f, -0.00095459f, 0.03043062f, -0.03144046f, -0.00676201f, 
    0.01065651f, -0.03844339f, 0.03402026f, -0.01414123f, 0.02066020f, -0.01528298f, -0.01399423f, -0.01627467f, 
    0.02604070f, 0.04431267f, -0.05058447f, -0.01869194f, -0.03898625f, 0.00566080f, 0.00194535f, -0.03919924f, 
    0.01580235f, -0.02608508f, -0.00214989f, 0.00994368f, 0.01114239f, 0.01250672f, 0.04105781f, -0.04178926f, 
    0.04298791f, -0.03411092f, 0.09252155f, 0.26941463f, -0.06012582f, 0.10721777f, 0.00705600f, 0.04037333f, 
    -0.03830782f, 0.01767137f, 0.10448259f, -0.05357312f, 0.20536171f, 0.01721194f, 0.15197814f, -0.11947259f, 
    -0.13419397f, 0.00012663f, -0.10081813f, 0.20023836f, 0.04666900f, -0.02537376f, -0.00453976f, 0.19572376f, 
    -0.37548715f, 0.10854593f, -0.16236821f, -0.12842491f, 0.11079893f, 0.02440438f, 0.25000057f, -0.06122557f, 
    0.01591668f, 0.00378700f, -0.02936245f, 0.05501468f, -0.11695682f, 0.16656519f, 0.12764308f, 0.24665558f, 
    0.10839661f, 0.08342163f, 0.07823054f, 0.01247186f, 0.00227037f, 0.10508183f, 0.08311167f, 0.01944294f, 
    0.05844645f, 0.10588271f, -0.15214434f, -0.17990571f, 0.10628595f, -0.01854623f, 0.01680041f, -0.07167224f, 
    0.00099520f, 0.11180051f, -0.00275654f, 0.10927184f, 0.08148652f, 0.02935264f, 0.01776324f, 0.14810213f, 
    0.14776909f, -0.14261442f, 0.17824915f, -0.03485394f, 0.01259385f, 0.03521220f, 0.05340364f, -0.03862899f, 
    0.13075353f, 0.05054897f, 0.01639783f, 0.29301035f, -0.06093642f, -0.01677444f, -0.13742192f, -0.15828609f, 
    0.14431232f, 0.10444029f, -0.00304860f, -0.12377975f, 0.13299531f, 0.16733581f, 0.31461117f, 0.27839828f, 
    -0.00013361f, 0.00850379f, 0.07579975f, -0.05463277f, 0.14708905f, 0.06327608f, 0.05119007f, 0.09496331f, 
    0.04109809f, 0.28588402f, 0.10045961f, 0.20572145f, 0.05986265f, 0.00691946f, -0.11995422f, 0.03530569f, 
    -0.09236778f, 0.04199324f, -0.03996899f, -0.07367592f, 0.33508179f, -0.07907294f, 0.13066895f, 0.00384921f, 
    -0.09955110f, 0.01433453f, 0.07865445f, -0.03260508f, 0.00794312f, 0.11229671f, -0.01360567f, 0.10029984f, 
    -0.01456142f, -0.00347548f, -0.09482879f, -0.19551033f, 0.12945868f, 0.04145226f, 0.07074434f, 0.09528218f, 
    0.02235469f, -0.03812804f, 0.00011327f, 0.10464983f, -0.17276987f, -0.04987019f, 0.04277459f, -0.09676808f, 
    -0.00134527f, 0.04472571f, 0.04284802f, -0.04951723f, 0.06146137f, -0.08061377f, 0.13948539f, 0.05081462f, 
    0.01409242f, -0.16329694f, -0.03341715f, -0.02373027f, 0.03171438f, 0.01260126f, 0.07113851f, 0.04137389f, 
    -0.00328199f, 0.07159603f, 0.02055248f, 0.04323279f, 0.37852043f, 0.14768977f, 0.05337081f, 0.24253117f, 
    0.03717834f, -0.01552122f, 0.00723913f, -0.00562959f, 0.03206396f, 0.05800603f, 0.08574622f, 0.10854282f, 
    -0.26092806f, 0.01779563f, -0.09325505f, -0.10894972f, 0.07693217f, -0.03155973f, -0.06426265f, 0.08464801f, 
    0.25474027f, -0.10271438f, 0.07312763f, 0.10227830f, 0.18305382f, 0.10082899f, 0.10443078f, 0.11529482f, 
    -0.02634394f, -0.00369243f, 0.05150138f, 0.09545033f, 0.08139527f, -0.00648228f, 0.07439174f, 0.09391633f, 
    -0.07883804f, 0.18059185f, 0.06500520f, -0.00438331f, 0.00417955f, 0.04608765f, -0.13235286f, -0.17979808f, 
    0.05911157f, -0.03547231f, 0.02673252f, -0.08354021f, 0.59933376f, 0.00480834f, -0.05995861f, -0.13745305f, 
    -0.06892077f, 0.07132015f, -0.10638778f, 0.11260199f, 0.05522303f, 0.02077939f, -0.04881334f, -0.04943085f, 
    0.27729395f, 0.14859205f, -0.06258088f, -0.13750635f, 0.05307846f, 0.06907081f, 0.08136569f, 0.03325021f, 
    0.01760335f, 0.05912771f, 0.16887282f, 0.00498073f, -0.09746405f, -0.07460411f, -0.14459427f, -0.11806652f, 
    -0.02065145f, 0.06902173f, -0.10400200f, -0.06144679f, -0.03744991f, 0.00624600f, -0.05544001f, 0.08405498f, 
    0.37021473f, -0.11127552f, -0.00812056f, 0.11276703f, -0.02506560f, 0.08470731f, -0.01240225f, 0.17330389f, 
    0.05466325f, 0.13398275f, 0.08417196f, 0.02892991f, -0.19205102f, -0.01150271f, 0.09152001f, -0.06252644f, 
    0.05806413f, 0.10357054f, 0.08245904f, -0.05236937f, 0.03640456f, -0.12067527f, 0.02853113f, 0.15184794f, 
    0.36019245f, -0.11783879f, -0.00507627f, 0.22804978f, 0.00290741f, -0.06008082f, 0.27490339f, 0.17761882f, 
    0.11811510f, -0.09853019f, 0.04052537f, 0.02360638f, -0.26785290f, -0.06148585f, -0.02415247f, -0.30369613f, 
    0.14133298f, 0.06696962f, 0.13075154f, -0.03025996f, 0.01019281f, 0.16610037f, 0.02872009f, -0.03863844f, 
    0.34082115f, -0.06626012f, 0.07711020f, 0.14080741f, -0.08024132f, 0.05230738f, -0.09868030f, -0.00798593f, 
    0.11290679f, -0.00764164f, 0.01432432f, 0.14073119f, -0.14635843f, -0.10278033f, -0.14952160f, -0.00785372f, 
    0.00485640f, 0.10401838f, 0.01199995f, -0.05472543f, -0.00876914f, 0.21371949f, -0.06851061f, 0.06421281f, 
    -0.37807909f, -0.07948096f, 0.22650099f, -0.12992293f, 0.01638643f, 0.08844930f, -0.01177914f, 0.05461947f, 
    -0.03891437f, 0.16185774f, 0.11280932f, 0.08936508f, -0.19827615f, -0.15944979f, 0.08647521f, 0.26740974f, 
    0.01394803f, 0.06521658f, 0.06834437f, -0.01820363f, 0.01311198f, 0.02866198f, 0.05127131f, 0.07629492f, 
    -0.11545996f, -0.08200759f, -0.03023591f, 0.01246689f, 0.11039512f, -0.04824712f, 0.05694109f, 0.01351374f, 
    0.07732287f, 0.11879764f, -0.03381082f, 0.03994403f, -0.00362866f, 0.11236984f, -0.08706136f, -0.10864811f, 
    -0.13819697f, 0.02772683f, 0.05796849f, -0.02975701f, -0.16394079f, 0.01696724f, -0.07789729f, 0.01462450f, 
    -0.20639907f, 0.22230455f, 0.26471049f, 0.04096118f, -0.06909169f, 0.03467603f, 0.07950957f, 0.06049673f, 
    0.04053850f, 0.06116048f, -0.05155506f, 0.08771719f, -0.18468845f, 0.29062521f, 0.09947724f, 0.18447132f, 
    0.01730250f, -0.08621461f, -0.06043811f, -0.01040471f, 0.06192395f, 0.06098043f, 0.02287242f, 0.13201174f, 
    -0.03154035f, 0.03773176f, -0.04638528f, 0.03450662f, 0.00072239f, 0.01296524f, -0.01048438f, -0.02649387f, 
    -0.03069017f, -0.05156020f, 0.03637683f, -0.01688959f, -0.03840030f, -0.02370422f, -0.03943665f, -0.05175016f, 
    -0.00576620f, -0.01972078f, -0.03710986f, -0.05653270f, 0.01327511f, -0.00003354f, -0.00359039f, 0.02230081f, 
    0.04060773f, -0.01326066f, -0.05318531f, -0.04953960f, -0.01973026f, -0.02722254f, 0.02316476f, -0.05319095f, 
    0.02448298f, -0.03990057f, -0.03975687f, -0.01062058f, -0.02486456f, -0.03010834f, -0.02829677f, -0.02295828f, 
    0.02199851f, -0.00811156f, -0.05527202f, -0.04032310f, 0.00581430f, 0.03075628f, -0.00084726f, -0.04468913f, 
    -0.02512815f, 0.02213568f, 0.01667364f, 0.04643102f, 0.01142296f, -0.03877243f, 0.02458281f, 0.00282092f, 
    0.01706713f, 0.03350540f, -0.04185725f, 0.00502375f, -0.01927041f, -0.04989599f, 0.01457620f, 0.02965000f, 
    -0.05032936f, 0.02095540f, 0.01598717f, -0.03043601f, -0.03520007f, -0.02662928f, -0.00626059f, -0.02543222f, 
    -0.03894452f, -0.04617125f, 0.03064712f, 0.03333262f, -0.00811676f, 0.02756783f, 0.02292207f, -0.00252773f, 
    -0.01425883f, -0.01422202f, -0.01013300f, -0.04849085f, 0.03221531f, -0.03301000f, -0.01431767f, -0.04471240f, 
    0.02793722f, -0.03187772f, 0.03715213f, 0.02446263f, 0.03529416f, -0.05552490f, -0.00681486f, 0.01730368f, 
    -0.04407667f, 0.00454108f, 0.01366956f, 0.02773718f, -0.01223867f, -0.04805211f, -0.03388029f, -0.03131923f, 
    -0.00872846f, -0.00682862f, -0.01199507f, -0.01959947f, -0.01870153f, -0.00919902f, -0.03214443f, 0.03223762f, 
    -0.02432496f, 0.01287869f, -0.00240617f, -0.03641969f, -0.02001317f, 0.00611170f, -0.04972854f, -0.04440886f, 
    -0.01230653f, -0.03322830f, -0.00720029f, 0.03418580f, -0.03724389f, -0.01454892f, 0.03181909f, -0.05200856f, 
    0.00452938f, 0.03775211f, -0.04279019f, -0.03542313f, -0.05260358f, -0.01516357f, -0.02441065f, 0.01262211f, 
    0.00571813f, -0.02209537f, 0.00504923f, -0.04626493f, 0.00110383f, 0.04270248f, -0.01915472f, 0.03350776f, 
    0.04077776f, -0.01248441f, 0.02700827f, 0.01874403f, -0.04928809f, 0.01022732f, 0.01135168f, -0.00961791f, 
    -0.04759140f, -0.05110341f, -0.02238923f, 0.00550578f, 0.02938976f, 0.00007748f, 0.02224946f, -0.02712283f, 
    -0.04418805f, 0.04229507f, 0.00954317f, 0.03406392f, 0.02370200f, -0.04232354f, 0.02977235f, 0.03453730f, 
    0.01843190f, -0.02041613f, -0.05159336f, -0.02777526f, -0.04192675f, 0.00062402f, -0.01452614f, 0.03486650f, 
    0.04437216f, -0.02129870f, -0.03607487f, -0.03651438f, -0.02851742f, 0.00379855f, 0.00499043f, -0.00006240f, 
    0.04609372f, 0.01951871f, 0.00314509f, 0.03544796f, 0.01292545f, -0.00760216f, -0.04906020f, -0.02428838f, 
    0.01649663f, -0.00638531f, -0.05040591f, 0.04048255f, -0.02226700f, -0.04490050f, 0.02275977f, 0.01536292f, 
    0.00652251f, -0.02620444f, -0.01642424f, -0.00859470f, -0.00285031f, 0.01519783f, 0.02085817f, -0.00146007f, 
    0.03833190f, 0.03853637f, 0.01022345f, -0.05319514f, -0.04294709f, -0.05044347f, -0.00991672f, -0.01580789f, 
    0.01347434f, 0.04558275f, -0.00487601f, 0.01749153f, 0.03409347f, 0.02112955f, 0.01869479f, -0.01826026f, 
    0.03466805f, 0.04494009f, 0.03455114f, -0.01220622f, 0.00552821f, 0.03507355f, -0.04126340f, 0.00883992f, 
    -0.04636759f, -0.01824051f, 0.02802049f, 0.03142836f, 0.02825540f, -0.05266647f, -0.02628915f, 0.01247717f, 
    0.03966719f, -0.02519233f, -0.03451300f, 0.01584296f, 0.04423610f, 0.03816040f, -0.02855565f, -0.04268956f, 
    0.03017403f, -0.06039457f, -0.03755025f, 0.02547743f, -0.00635616f, -0.02526193f, 0.02573501f, -0.02856904f, 
    0.03184982f, -0.00637883f, 0.00133832f, -0.03515457f, 0.03383293f, -0.02271651f, -0.02028549f, -0.00060521f, 
    -0.00639581f, -0.03685331f, -0.03381205f, -0.00962712f, 0.01261162f, 0.02988598f, -0.05140767f, 0.04034343f, 
    -0.02082204f, -0.01928598f, -0.00216139f, 0.02487008f, -0.02339804f, -0.03593776f, 0.00810925f, -0.04106920f, 
    -0.05465088f, -0.02672699f, 0.03633747f, -0.03439761f, -0.01127741f, -0.03710696f, -0.00946736f, -0.04403341f, 
    0.01404016f, 0.03603403f, 0.04487017f, 0.04903338f, 0.04589159f, -0.05586811f, -0.04431465f, 0.02781582f, 
    0.03032136f, 0.02720255f, -0.05545751f, 0.00904270f, -0.00644495f, 0.01901585f, -0.00742701f, -0.02734275f, 
    0.04274616f, 0.01761239f, -0.04065949f, 0.00251953f, 0.00181302f, -0.01957692f, 0.02992104f, 0.01679194f, 
    0.03006759f, 0.00029732f, 0.01005070f, 0.00172313f, 0.02336882f, -0.02324559f, -0.05374268f, 0.02129363f, 
    -0.03724322f, 0.00122620f, -0.02019462f, 0.02205391f, -0.04999949f, 0.02590265f, -0.00005307f, -0.01164489f, 
    -0.05093475f, -0.01183179f, 0.03652673f, 0.01571087f, 0.03839272f, -0.00424902f, -0.02889827f, -0.02135236f, 
    -0.04652037f, 0.01371912f, 0.03464481f, 0.04008064f, 0.00537205f, 0.01502971f, -0.05341658f, 0.04426088f, 
    -0.03828399f, -0.03209756f, 0.04377993f, -0.00938331f, 0.04282957f, 0.00399853f, 0.01302459f, -0.00048414f, 
    0.02106211f, -0.04292112f, -0.04686639f, 0.00413802f, -0.00106323f, -0.02035514f, -0.02008237f, 0.04306683f, 
    -0.04712044f, 0.02615573f, 0.02076274f, -0.02350482f, 0.01833136f, 0.00690292f, -0.03392507f, -0.00823805f, 
    -0.04143881f, -0.03180628f, -0.03130171f, -0.01992151f, -0.03169025f, -0.01218495f, -0.05252948f, -0.04010491f, 
    0.03450469f, 0.01069778f, -0.01850959f, -0.00815539f, -0.01571460f, 0.04563419f, -0.00316953f, 0.03612166f, 
    -0.01823561f, 0.03329705f, -0.02660669f, 0.02425430f, -0.01653458f, -0.00700792f, -0.00082102f, 0.00996156f, 
    -0.01792453f, 0.00988073f, -0.03500928f, 0.02138745f, 0.00628253f, -0.00512950f, 0.04390834f, -0.03720400f, 
    -0.02218214f, 0.01954352f, 0.00539137f, -0.04336494f, -0.01611558f, 0.03128777f, 0.00419654f, -0.00976164f, 
    0.00894628f, -0.04928345f, 0.01827833f, 0.03641836f, 0.03479238f, 0.00120749f, 0.02053051f, 0.02126165f, 
    -0.00166769f, -0.03852507f, 0.00618681f, 0.02005822f, 0.01108936f, -0.02759726f, 0.04393002f, 0.03278914f, 
    0.00149313f, 0.01608228f, -0.02231197f, 0.02412451f, 0.03793305f, -0.04662855f, 0.00786548f, 0.00347528f, 
    0.01128235f, 0.03309860f, 0.01388351f, -0.05772303f, 0.00638539f, 0.01940264f, -0.04505479f, -0.04237353f, 
    -0.03979989f, -0.02470927f, -0.03063758f, 0.00982050f, 0.00257634f, 0.02224804f, 0.01222012f, 0.00057097f, 
    -0.01381571f, -0.03105200f, -0.02975155f, -0.01466810f, -0.06295212f, 0.03888300f, 0.00160532f, 0.03324762f, 
    0.01162592f, -0.01475065f, 0.02862534f, -0.00687732f, -0.00222004f, 0.02161733f, -0.04038534f, -0.03828007f, 
    -0.00473564f, 0.04706380f, 0.00948481f, 0.04276732f, -0.01252034f, 0.01146536f, 0.03434850f, -0.05302653f, 
    -0.01702289f, 0.00034774f, -0.06328490f, -0.04216696f, -0.03552689f, -0.04175985f, 0.01864570f, -0.02050284f, 
    0.03523053f, -0.02129110f, 0.00488542f, 0.01722245f, -0.04423417f, 0.02524819f, 0.01878570f, 0.01837301f, 
    0.02104354f, -0.03814897f, -0.00757633f, -0.01717885f, -0.03650322f, -0.01747942f, -0.00638435f, -0.01182258f, 
    -0.01755506f, 0.00786892f, -0.01856823f, 0.00089980f, -0.01771338f, 0.03451081f, 0.02602194f, -0.03340434f, 
    -0.04677355f, -0.06184256f, 0.01469296f, 0.01545966f, -0.02797894f, 0.00064173f, -0.00117834f, -0.00379297f, 
    -0.02318373f, 0.04018486f, -0.02393517f, 0.01154202f, -0.04051311f, -0.03693913f, 0.01810522f, 0.01024538f, 
    -0.01533041f, 0.02552211f, -0.06261381f, 0.01483837f, -0.02008438f, -0.00608581f, 0.03052293f, -0.04790062f, 
    0.04758912f, 0.02247626f, 0.02665170f, -0.01977974f, -0.04370529f, -0.00580067f, -0.05299975f, 0.03606166f, 
    0.00777111f, 0.00457074f, 0.02284625f, 0.02996002f, -0.02395446f, -0.01229863f, -0.03684759f, 0.02900053f, 
    0.01754190f, -0.02686394f, -0.02537990f, 0.01313077f, -0.04677426f, 0.02281782f, 0.03753568f, -0.02165499f, 
    -0.05560609f, -0.03784226f, -0.01930289f, -0.00782496f, -0.05518414f, 0.02099879f, 0.02892422f, 0.03418548f, 
    -0.05505285f, -0.00234879f, 0.03403907f, -0.03796105f, -0.00999575f, -0.04769799f, -0.01162880f, 0.01389685f, 
    0.03596702f, -0.03070188f, 0.04190905f, 0.01465528f, 0.00826657f, -0.04416027f, -0.00652706f, -0.05555805f, 
    -0.01194965f, 0.03619481f, -0.03392760f, -0.00696123f, -0.02817302f, -0.03298333f, 0.02088548f, -0.01448710f, 
    -0.04446045f, 0.04159665f, 0.03366565f, 0.00032450f, -0.01916784f, -0.02313727f, 0.03151973f, 0.04021978f, 
    -0.04256059f, -0.04888526f, -0.04597621f, 0.04668354f, 0.04138790f, 0.03349987f, 0.03849320f, 0.03199675f, 
    -0.05333118f, -0.05362412f, -0.01649683f, -0.02205525f, -0.04293863f, 0.05232491f, -0.02603936f, 0.01625139f, 
    0.03120224f, -0.04265244f, 0.02782626f, -0.01189063f, 0.04263860f, -0.03726656f, 0.02170956f, -0.02790226f, 
    0.03386517f, -0.03149221f, 0.02550275f, 0.03782522f, -0.02025710f, -0.06043179f, -0.00206876f, -0.04361513f, 
    0.01284842f, -0.02317624f, -0.05703992f, -0.03941436f, 0.00545424f, -0.00672794f, -0.02735403f, -0.04731268f, 
    0.00259780f, 0.02747512f, 0.01066159f, 0.02689515f, 0.00896201f, -0.03432980f, -0.02764849f, 0.01114936f, 
    -0.03263216f, -0.02371936f, -0.01313913f, -0.01723538f, 0.02541764f, -0.01715445f, 0.02365205f, -0.04160002f, 
    0.02226377f, -0.02850837f, -0.00020517f, -0.03452713f, -0.02393770f, 0.04503656f, -0.02461409f, 0.00079292f, 
    0.00342752f, 0.00201073f, 0.00705169f, -0.04334873f, -0.02322555f, 0.02570219f, -0.03716851f, 0.03670123f, 
    -0.03331019f, -0.05625687f, 0.01905044f, -0.02686171f, -0.03146302f, 0.03195215f, -0.01126531f, 0.01557519f, 
    -0.05170117f, 0.00182908f, -0.03171081f, -0.00756097f, -0.05440673f, 0.00524831f, -0.00583008f, 0.02615430f, 
    -0.00835253f, 0.00136314f, 0.03260467f, 0.01018686f, -0.03368712f, -0.00280872f, 0.01683627f, 0.02078066f, 
    0.00017330f, -0.05416477f, 0.03500554f, -0.03343108f, 0.03813712f, -0.02051493f, -0.00522382f, -0.00737957f, 
    0.03718501f, -0.00542589f, -0.04004168f, -0.03350497f, 0.00422146f, -0.04729166f, -0.04796769f, 0.00962491f, 
    -0.04016910f, 0.03231707f, 0.03256877f, 0.00304404f, 0.03270471f, -0.00255707f, 0.01224821f, -0.00443474f, 
    0.00974299f, -0.03647882f, -0.01959608f, -0.01274190f, 0.03082318f, -0.00210891f, -0.00341451f, -0.02781730f, 
    -0.02136641f, 0.03444066f, -0.05250872f, -0.01928731f, -0.00858842f, 0.01252404f, -0.05717234f, 0.01956507f, 
    -0.06054138f, -0.01173617f, 0.02845950f, 0.00475673f, -0.01690970f, -0.00170645f, -0.04329201f, 0.00166929f, 
    0.03191554f, -0.03964061f, 0.01699560f, 0.01266869f, -0.03038612f, -0.04412711f, -0.03301258f, -0.02128328f, 
    -0.00833007f, 0.00939857f, -0.03016741f, 0.02688632f, 0.02271789f, -0.02149105f, 0.01143858f, 0.01589194f, 
    -0.01622511f, 0.03697467f, -0.05012937f, 0.04827018f, -0.03501259f, -0.03508250f, 0.01305016f, 0.02968578f, 
    -0.04668003f, -0.04186924f, -0.04985500f, 0.02821394f, 0.02521504f, 0.02143435f, -0.01925695f, 0.02325057f, 
    -0.09547900f, 0.13210644f, 0.08397155f, 0.28828424f, -0.06325189f, -0.03383525f, 0.03803787f, -0.08840948f, 
    0.10849032f, 0.07850774f, -0.01632811f, 0.08695329f, -0.23760839f, 0.04728325f, -0.17199914f, -0.16606313f, 
    0.15097238f, 0.09060072f, 0.02795411f, -0.00906827f, 0.01553520f, 0.13404635f, 0.12211800f, 0.00281058f, 
    -0.42135835f, -0.07595930f, 0.17591782f, -0.06108944f, -0.00446766f, 0.11013790f, 0.12578593f, 0.00706705f, 
    -0.03894074f, 0.14473414f, 0.00870753f, -0.00527991f, -0.08726694f, 0.19248575f, 0.19875211f, -0.02071059f, 
    -0.17480221f, -0.12884900f, -0.00336969f, 0.05022546f, -0.11312982f, -0.04192206f, -0.01800494f, -0.01611089f, 
    -0.25469676f, 0.04326650f, 0.33168921f, -0.14506760f, -0.00517183f, -0.03281024f, 0.13407837f, -0.07450299f, 
    0.05150157f, 0.09630097f, -0.15193547f, -0.02002853f, -0.23001219f, -0.24832149f, 0.06307320f, 0.11429501f, 
    -0.08701640f, 0.11014473f, -0.02877119f, -0.07758667f, 0.04885451f, -0.07678620f, 0.00889408f, 0.15749919f, 
    -0.00248605f, 0.32736498f, -0.01393490f, 0.11148940f, -0.05646020f, -0.05320669f, 0.06113343f, 0.09864892f, 
    -0.06003315f, -0.02433340f, -0.02092768f, -0.01688422f, 0.19354440f, 0.12567103f, 0.37824011f, 0.09331183f, 
    -0.11093335f, -0.05221771f, 0.07219034f, 0.06896797f, 0.03807126f, 0.08686005f, 0.08553194f, 0.09720496f, 
    0.16532102f, 0.25049952f, 0.40430471f, -0.26297653f, -0.28660664f, -0.03687771f, -0.00189340f, 0.25304937f, 
    0.09731370f, 0.14063592f, -0.06585126f, 0.03946214f, -0.40234399f, -0.11272354f, -0.30622238f, 0.25615919f, 
    -0.08681956f, 0.06141298f, 0.00233162f, 0.05612841f, 0.04487272f, 0.03445231f, -0.06462152f, -0.05731031f, 
    -0.22933432f, -0.10998983f, -0.14283070f, 0.01208512f, 0.03900394f, 0.13796836f, 0.12638302f, -0.08423133f, 
    0.01190577f, 0.01689718f, 0.11686656f, -0.05336624f, -0.02618262f, -0.13965909f, 0.19675632f, 0.30313888f, 
    -0.10419464f, 0.18691376f, 0.08944059f, -0.07283035f, 0.16321234f, 0.02524202f, -0.15094641f, 0.09860022f, 
    -0.10353885f, 0.13886361f, -0.05031597f, 0.24122350f, 0.19098662f, 0.11679960f, -0.12999357f, 0.05817774f, 
    0.12166405f, -0.10590635f, 0.04417347f, -0.02100732f, 0.08383886f, 0.08059105f, -0.00734156f, 0.07056811f, 
    -0.05338145f, -0.03854247f, 0.04934086f, 0.06806967f, 0.04585648f, -0.07860950f, -0.04634235f, 0.00682243f, 
    -0.01057077f, -0.15400720f, 0.21355113f, -0.23040211f, -0.02612836f, -0.02476478f, 0.12204492f, -0.03494515f, 
    -0.14719178f, -0.01745901f, 0.09420484f, -0.06750507f, 0.08173227f, -0.05935162f, -0.01726158f, -0.27538183f, 
    0.12304079f, 0.14331372f, 0.02534616f, -0.10470922f, 0.13695569f, 0.06288653f, -0.05641952f, 0.16110149f, 
    -0.07912873f, 0.24359062f, 0.35903129f, -0.15050364f, -0.19161190f, -0.04833391f, 0.02429603f, 0.04420037f, 
    0.17470768f, -0.00534448f, -0.06456068f, 0.19222456f, -0.64024168f, -0.00646298f, -0.03841308f, 0.05331549f, 
    -0.07326763f, -0.05755796f, -0.06534180f, 0.01008918f, 0.01143290f, -0.11704279f, 0.06805124f, 0.09644873f, 
    -0.30545768f, -0.17094558f, 0.17168270f, -0.02995341f, 0.05126377f, 0.02286193f, 0.12146029f, -0.04419573f, 
    0.10231688f, -0.01118318f, 0.05790082f, -0.02729543f, -0.09846038f, 0.15879831f, 0.12016975f, -0.02002296f, 
    -0.10948835f, 0.03693743f, 0.02881079f, 0.14206903f, -0.03442349f, 0.08368785f, -0.10648704f, -0.03034841f, 
    0.03107314f, 0.16973175f, -0.13445872f, 0.11733899f, 0.02509023f, 0.20377564f, -0.04198717f, -0.03831236f, 
    0.05102397f, 0.01064713f, 0.04944795f, -0.00142164f, 0.10803911f, -0.32524633f, -0.09491842f, -0.17153141f, 
    0.09196144f, 0.13220800f, 0.14638753f, -0.07910220f, -0.05110036f, 0.04476987f, 0.09650868f, -0.09775099f, 
    -0.00139230f, 0.17822260f, 0.03141138f, 0.06656098f, 0.11191145f, -0.02791203f, -0.00749577f, -0.11663665f, 
    -0.07113822f, 0.12088630f, 0.03277854f, 0.12590624f, 0.05394548f, -0.01640546f, 0.18519332f, -0.35140237f, 
    -0.02521777f, 0.10149308f, 0.01841982f, -0.01168500f, 0.13844489f, -0.09238894f, 0.11233524f, 0.08273655f, 
    -0.22552961f, 0.09766852f, -0.09272581f, -0.00547892f, 0.07331859f, 0.14123100f, -0.16971014f, 0.13703732f, 
    -0.10699359f, 0.06244306f, 0.02443034f, 0.15686153f, 0.37728849f, -0.03174205f, 0.23070210f, 0.21313317f, 
    -0.15162680f, -0.04129136f, -0.16918623f, -0.07766838f, -0.11267480f, -0.10431434f, 0.12884805f, 0.04939796f, 
    -0.01132201f, -0.14695412f, 0.14784050f, 0.05722450f, 0.24451704f, 0.08440983f, 0.22839648f, -0.05809512f, 
    0.00312129f, -0.01699431f, -0.14000860f, 0.03822334f, 0.10598696f, -0.19397368f, -0.00275350f, 0.12504670f, 
    -0.01009104f, -0.02650963f, 0.01781692f, -0.05461068f, 0.07253117f, 0.02352729f, 0.05819541f, -0.09193230f, 
    0.29507983f, -0.02108122f, -0.01684540f, 0.13874605f, 0.01587929f, 0.05838871f, 0.08689857f, 0.03081619f, 
    0.04592502f, -0.01016728f, -0.03813046f, 0.07107584f, -0.45640609f, 0.05002407f, 0.13033375f, 0.12980674f, 
    -0.18431957f, 0.11370809f, -0.04230030f, 0.13375108f, 0.09259751f, -0.10769401f, -0.04294012f, 0.01516326f, 
    0.10678761f, -0.04372599f, -0.18321286f, -0.11971294f, 0.08023242f, 0.06012498f, 0.00537524f, -0.11485603f, 
    0.11065096f, -0.09390057f, -0.00236950f, 0.18394585f, 0.05788744f, 0.34310743f, 0.10105269f, 0.15177822f, 
    -0.12960790f, -0.14983162f, 0.10045666f, 0.11357170f, -0.05878421f, 0.07993793f, 0.04963033f, -0.10170870f, 
    0.00639860f, 0.02875181f, 0.04456953f, -0.04521349f, 0.02336886f, 0.02016800f, -0.01572127f, 0.01188724f, 
    0.04263202f, -0.03815319f, 0.03558628f, -0.05200144f, -0.01349917f, 0.02951189f, -0.04514115f, -0.05284652f, 
    -0.03582878f, -0.03115400f, -0.00132836f, -0.03786676f, -0.03446955f, -0.04875898f, -0.04577419f, -0.04169045f, 
    0.00934307f, -0.04552289f, -0.03436597f, -0.03532280f, 0.00933621f, -0.04646725f, 0.00324690f, -0.03213411f, 
    -0.00107648f, -0.04662390f, -0.01665034f, 0.02076909f, -0.05676061f, 0.02689580f, -0.01569575f, 0.01880960f, 
    0.00682688f, -0.05428046f, 0.04704136f, 0.01697409f, 0.03444542f, 0.03125860f, -0.05327856f, 0.02852601f, 
    0.00961506f, -0.02691453f, -0.00916134f, -0.04241037f, 0.03554047f, 0.02922601f, 0.01329749f, -0.01058303f, 
    0.04990446f, -0.05387028f, -0.04874815f, 0.00656378f, 0.02065316f, -0.03271579f, 0.03923858f, -0.00089046f, 
    -0.01399987f, -0.03549533f, -0.01164082f, 0.01510120f, -0.03384162f, 0.02799460f, -0.00240522f, 0.02429406f, 
    -0.03071316f, 0.04009853f, 0.00499351f, -0.03340161f, -0.03420533f, 0.03692810f, -0.02930545f, 0.01679492f, 
    -0.05739843f, -0.05282384f, -0.01956807f, -0.02361106f, -0.03273950f, -0.05195581f, 0.03390244f, 0.04114037f, 
    -0.04434573f, 0.04018937f, -0.02911525f, 0.00914198f, -0.04928507f, -0.00161147f, -0.05236550f, 0.03736856f, 
    -0.04235800f, 0.02566848f, -0.01722821f, -0.05050999f, 0.02548558f, -0.04583286f, -0.01942901f, -0.00157483f, 
    -0.04511683f, -0.02205910f, -0.04533485f, -0.00190604f, -0.02541485f, -0.00301102f, 0.04241632f, -0.02245837f, 
    0.01288000f, 0.01257811f, -0.03148348f, 0.01474139f, -0.01477674f, 0.03013559f, -0.03830733f, -0.04944553f, 
    -0.04106761f, 0.03170813f, -0.04701494f, -0.01029692f, -0.00703023f, -0.04524724f, -0.04117210f, 0.00668416f, 
    0.00424592f, -0.05074022f, -0.05959942f, 0.03074678f, -0.01215242f, -0.04947582f, -0.00228988f, 0.03127101f, 
    0.03546706f, -0.02813931f, -0.02942772f, -0.01885560f, -0.04281066f, -0.01265627f, 0.00258324f, 0.00061073f, 
    0.02198474f, 0.02244255f, -0.04653863f, 0.00073891f, -0.01540865f, 0.02331072f, -0.00583879f, 0.03059424f, 
    0.02541249f, 0.01737878f, -0.04936567f, 0.00672764f, 0.04083476f, -0.01294027f, -0.02767051f, 0.02184463f, 
    -0.00287485f, -0.03932054f, -0.00089881f, 0.00104499f, 0.04062698f, 0.02011431f, -0.03159261f, -0.05176079f, 
    -0.03914105f, -0.01960781f, -0.03408497f, -0.04921128f, 0.00153753f, 0.03732884f, 0.03254950f, 0.02032373f, 
    0.00119716f, 0.02101043f, -0.03862615f, -0.01321225f, 0.03543962f, -0.01516323f, 0.00335208f, -0.03325061f, 
    -0.04647863f, 0.02682012f, -0.00037606f, -0.05058398f, -0.04833310f, 0.00682381f, -0.00789591f, -0.05192242f, 
    0.04478573f, 0.04359002f, 0.03161871f, -0.01071407f, -0.01511528f, -0.05926894f, 0.01511936f, -0.03369435f, 
    -0.01063866f, 0.04828868f, 0.03469707f, -0.05072374f, -0.05365763f, -0.01107033f, -0.02073506f, 0.00014146f, 
    -0.04790596f, 0.01211573f, -0.02400626f, -0.01893277f, -0.02633326f, 0.00662113f, -0.02892535f, 0.03921965f, 
    -0.04571269f, -0.04835713f, 0.01886791f, 0.04577609f, 0.04383000f, -0.01911579f, 0.01914993f, 0.03594676f, 
    0.00225075f, 0.01360238f, -0.03250004f, -0.02687273f, -0.03151589f, 0.01119432f, -0.00851526f, -0.04189722f, 
    -0.05407825f, -0.04744369f, -0.03426744f, -0.00192941f, 0.00387120f, 0.01692270f, -0.04093686f, 0.00431628f, 
    -0.02131072f, -0.00304957f, -0.05496148f, 0.03566080f, 0.04491001f, -0.04968325f, 0.01281131f, -0.01430187f, 
    -0.05545577f, 0.00410637f, 0.03578102f, -0.04675866f, 0.02212721f, 0.03910424f, 0.02201967f, 0.01737331f, 
    -0.01670669f, 0.04204454f, 0.03897412f, -0.00549733f, 0.03674131f, -0.01128453f, 0.03877827f, 0.01561328f, 
    -0.03858732f, 0.00895589f, -0.01123113f, 0.02721996f, 0.03505552f, -0.03427332f, -0.02361722f, -0.00862190f, 
    0.00353705f, -0.02818636f, -0.03912785f, 0.01314380f, -0.04207177f, 0.04366152f, -0.03414121f, 0.01971935f, 
    -0.00890330f, 0.00939975f, -0.04332992f, -0.05302062f, -0.02804642f, 0.00542908f, 0.02381535f, 0.03656743f, 
    0.03389340f, 0.02943863f, -0.05575141f, -0.00764221f, 0.03492843f, -0.00830064f, -0.04027784f, 0.03254738f, 
    0.02943550f, -0.00259843f, 0.00008969f, 0.02927759f, 0.00794563f, 0.00856010f, -0.04776018f, 0.01256965f, 
    -0.01173174f, -0.00929467f, 0.00762585f, -0.04781925f, 0.03978479f, 0.01939067f, 0.03057484f, 0.03691850f, 
    -0.04429292f, -0.04914574f, 0.01067300f, -0.04962969f, -0.00185887f, 0.01189834f, -0.00365119f, 0.03067536f, 
    -0.03634005f, 0.02693432f, 0.04099646f, -0.01520877f, 0.00679518f, -0.03185507f, -0.05647450f, 0.02478184f, 
    -0.00197178f, -0.02615979f, -0.04445574f, -0.01322045f, 0.00656104f, -0.01211502f, 0.01898689f, -0.04870418f, 
    0.02692095f, 0.00640314f, -0.00332168f, -0.04796672f, 0.00520751f, 0.01904315f, -0.02676236f, -0.01770202f, 
    0.00431777f, -0.02364851f, 0.02792880f, -0.00100497f, -0.02930580f, -0.02290429f, 0.00504843f, -0.01605597f, 
    0.00590557f, 0.00529875f, -0.01573367f, -0.01304314f, -0.02522954f, -0.05584204f, -0.01888449f, -0.04329630f, 
    -0.00080277f, -0.03651032f, -0.00912053f, 0.02262043f, -0.02641756f, 0.02588232f, -0.05621914f, -0.03283647f, 
    -0.02668225f, -0.03668710f, 0.02056240f, 0.03103405f, 0.02401124f, -0.02014386f, 0.04056440f, -0.02883356f, 
    -0.00426526f, 0.04291216f, 0.02110490f, -0.05025228f, -0.03238738f, -0.00344480f, -0.01627196f, -0.05019638f, 
    0.16063607f, 0.03887802f, -0.01358159f, 0.08441982f, -0.02032788f, 0.01870074f, -0.08036742f, 0.00654581f, 
    -0.07300175f, -0.25728536f, 0.00131583f, -0.04755474f, -0.09998962f, -0.04393521f, -0.19171514f, -0.05144441f, 
    0.14689295f, -0.07437220f, -0.05825694f, 0.05235376f, 0.08861288f, -0.03342870f, -0.07527008f, 0.05810821f, 
    -0.30087322f, 0.17222980f, -0.17797145f, -0.19875474f, 0.08296012f, -0.01143556f, 0.07949373f, 0.12026959f, 
    0.00712391f, 0.04893944f, 0.03402758f, 0.00628493f, -0.10873161f, -0.13097501f, 0.19507116f, 0.21353894f, 
    -0.01249161f, 0.04339674f, 0.02415535f, 0.09622544f, -0.16981891f, 0.09034014f, 0.07738976f, -0.02440379f, 
    -0.09462763f, 0.07275044f, -0.08405073f, -0.16525258f, 0.08805903f, 0.04451939f, -0.08225512f, 0.06567786f, 
    -0.01818624f, -0.01642716f, 0.02825433f, 0.12050326f, 0.08961332f, -0.08831592f, -0.04419888f, 0.02365737f, 
    0.21885882f, -0.19424255f, 0.07733425f, 0.12433767f, 0.07547695f, 0.02726849f, -0.20167881f, -0.28854412f, 
    0.12308923f, -0.00610006f, 0.13205111f, 0.14215997f, 0.05149729f, -0.02183968f, 0.07915229f, -0.08227589f, 
    0.01430526f, -0.07427062f, -0.07683922f, -0.00823073f, 0.14907356f, 0.10944534f, -0.01289641f, 0.09356107f, 
    -0.14285359f, 0.15226980f, -0.00688930f, 0.13793817f, 0.21132621f, 0.02710812f, 0.03188945f, -0.00919322f, 
    0.01976558f, -0.04505264f, 0.17020455f, 0.29482880f, 0.04083756f, -0.01771969f, 0.02698394f, 0.03413630f, 
    -0.00584163f, -0.18519430f, -0.03287389f, -0.01127586f, -0.03045056f, -0.07361838f, 0.06977768f, 0.11103654f, 
    -0.10825898f, -0.17154860f, -0.01391394f, 0.02170721f, -0.09577391f, -0.07891800f, 0.09689616f, 0.15523148f, 
    -0.01173870f, -0.05634098f, -0.06314708f, 0.22177182f, 0.14400469f, -0.26318854f, 0.07893807f, 0.21291545f, 
    -0.02273984f, 0.03948979f, -0.02076637f, -0.08106379f, -0.06140480f, -0.05546466f, 0.01524314f, 0.01787520f, 
    -0.02463605f, -0.04300923f, 0.06588471f, 0.06006428f, 0.05749004f, -0.05195605f, 0.00357700f, 0.10358592f, 
    -0.22667825f, 0.07300544f, -0.10911040f, -0.01122004f, 0.05294800f, 0.01270036f, 0.00438632f, -0.02797159f, 
    0.03671965f, 0.08295026f, 0.13523991f, 0.08001550f, 0.17844780f, 0.05970096f, 0.20565811f, 0.10393871f, 
    -0.02399819f, 0.00672632f, -0.04825490f, -0.00082927f, -0.07186038f, 0.11441623f, 0.01086932f, -0.07336651f, 
    0.05408185f, -0.19036880f, 0.15538169f, -0.31340075f, 0.19177377f, 0.24015151f, -0.05689030f, 0.17029330f, 
    0.17107238f, 0.02661161f, -0.14928399f, 0.06552105f, -0.22768874f, 0.07604136f, -0.04063383f, -0.12302992f, 
    0.03494091f, -0.00166802f, -0.06340425f, 0.00107933f, 0.22296639f, 0.01072189f, 0.12399181f, 0.00794541f, 
    0.01303679f, -0.23502903f, -0.00463716f, 0.13058668f, 0.03150310f, 0.11817504f, 0.03622524f, -0.04920778f, 
    -0.05182039f, -0.13619578f, 0.10135479f, 0.10446205f, 0.21752916f, -0.11731381f, 0.17069629f, 0.00754409f, 
    0.00434168f, -0.03917303f, -0.06405418f, 0.10364805f, -0.02939346f, 0.10195420f, 0.06127708f, -0.07918105f, 
    0.26678267f, -0.09467479f, -0.24984476f, 0.09298734f, -0.06662446f, -0.08400271f, -0.07201340f, 0.13482535f, 
    0.01398263f, 0.06243601f, -0.04299584f, 0.00920273f, 0.07950994f, 0.12728094f, -0.00791913f, 0.05042395f, 
    -0.11754445f, 0.06085830f, 0.10547547f, 0.19326003f, -0.17614716f, -0.05940448f, -0.03186701f, -0.06242307f, 
    0.42300302f, 0.00683452f, 0.10034572f, -0.12050965f, -0.05216379f, 0.01531830f, -0.08271995f, -0.10819451f, 
    -0.08013915f, 0.12542421f, -0.14324152f, 0.03702705f, 0.15474299f, -0.21377036f, -0.03203842f, -0.10948868f, 
    0.11394459f, -0.05609854f, -0.03234200f, 0.06659376f, 0.09520403f, -0.06137862f, -0.08021767f, 0.03306381f, 
    -0.12630112f, 0.09050350f, -0.11841530f, 0.17832427f, 0.14142139f, -0.01660842f, -0.08111978f, 0.05231377f, 
    0.05140175f, -0.13012767f, 0.04845233f, -0.07993929f, -0.02806748f, -0.04248013f, 0.02249319f, -0.12374716f, 
    0.05362672f, -0.00694077f, 0.15114388f, -0.07940637f, -0.05665960f, 0.15337044f, -0.03176786f, -0.06994536f, 
    0.17822580f, 0.15521905f, -0.01301121f, -0.04829240f, 0.03336021f, 0.18564528f, -0.04118400f, -0.07183337f, 
    0.01257748f, 0.00667749f, -0.07251856f, -0.03451325f, 0.21301354f, -0.06930190f, 0.03069489f, 0.03218533f, 
    -0.06613694f, -0.05090159f, 0.08893422f, -0.00864320f, -0.15629536f, 0.07127226f, -0.16726603f, 0.06893834f, 
    -0.09027084f, -0.15688542f, 0.14165594f, 0.20272805f, -0.06414353f, 0.02062240f, -0.02244497f, 0.07067659f, 
    0.02586287f, -0.05973306f, 0.09624398f, 0.05105539f, 0.24221355f, -0.10320789f, 0.02466632f, -0.07028105f, 
    0.07218145f, -0.07740913f, 0.05501484f, -0.02708242f, 0.09242434f, 0.00558602f, -0.07614507f, 0.11718079f, 
    -0.12270883f, -0.08705719f, -0.10851157f, 0.24095368f, -0.14432524f, 0.06542997f, 0.00316840f, 0.05771299f, 
    0.01393533f, 0.01244860f, -0.06631362f, -0.07379926f, 0.21235372f, 0.08053216f, -0.16136247f, -0.12061438f, 
    -0.09101946f, -0.06355002f, 0.14949597f, -0.04848533f, -0.20594010f, -0.04063308f, -0.02759993f, 0.08442211f, 
    -0.27784151f, 0.13216344f, -0.11536964f, 0.01720374f, 0.07002316f, 0.05292783f, 0.01780024f, -0.10043874f, 
    0.08000429f, 0.16617410f, -0.07614567f, 0.10293769f, -0.00660062f, -0.02995084f, 0.03323419f, 0.25553775f, 
    -0.05511519f, 0.05793887f, 0.05498039f, 0.03090173f, 0.10560987f, -0.01635270f, 0.03642355f, 0.05083452f, 
    0.10623346f, 0.11106659f, 0.08783034f, -0.01635391f, 0.08627108f, 0.00285941f, -0.01054846f, 0.01768249f, 
    0.07329896f, 0.00945134f, 0.10010099f, 0.09586965f, -0.32436824f, -0.15463729f, -0.24843104f, -0.06951948f, 
    0.11992157f, 0.11886255f, 0.00634548f, -0.06620140f, 0.09892455f, 0.02105926f, 0.05070789f, -0.04790375f, 
    0.00805896f, -0.10628425f, 0.05864329f, -0.01541781f, 0.11183023f, 0.03566182f, -0.05841397f, 0.12550028f, 
    0.02220036f, 0.14522843f, -0.00208512f, 0.09692250f, 0.17998001f, 0.04291961f, 0.05813670f, -0.14011979f, 
    0.02437592f, -0.01314100f, 0.00433821f, 0.04501582f, -0.14628634f, -0.06736646f, -0.02491748f, 0.02166378f, 
    0.05036431f, -0.11690496f, 0.16724490f, 0.12089337f, 0.10373116f, -0.12998268f, -0.00778290f, 0.05313120f, 
    0.00569082f, -0.02076663f, 0.01988142f, 0.05031802f, -0.20141888f, -0.13835713f, -0.00445121f, -0.14805746f, 
    0.08803879f, 0.02121117f, -0.00261227f, -0.04148729f, 0.03828181f, 0.05114062f, -0.02349023f, 0.01965838f, 
    0.04400412f, 0.03994738f, 0.26264274f, -0.00030978f, 0.12938949f, -0.12139548f, 0.08827109f, 0.07605672f, 
    -0.11277281f, -0.06917977f, 0.00587549f, -0.03660615f, 0.01975019f, 0.02556361f, 0.24952385f, -0.14484504f, 
    -0.01955229f, 0.00968484f, -0.05679282f, 0.07923334f, -0.07108746f, -0.08408146f, 0.10295363f, -0.11786465f, 
    0.13980100f, 0.16618617f, 0.13882300f, -0.03772817f, -0.06025936f, 0.09002321f, 0.07502215f, 0.08044103f, 
    -0.03647419f, -0.02916508f, 0.00372937f, 0.10941330f, -0.31905538f, -0.06292912f, -0.04534683f, 0.06362446f, 
    0.00041217f, -0.05538337f, 0.06851338f, 0.02455419f, 0.12638390f, -0.01661871f, 0.09048603f, -0.03569748f, 
    -0.07738522f, -0.23973234f, -0.00276656f, 0.27549475f, 0.04285939f, -0.08354884f, -0.00841038f, 0.03403851f, 
    0.04271656f, 0.04894053f, 0.13082519f, 0.00701169f, 0.04368048f, 0.16791049f, 0.08902860f, 0.12709838f, 
    -0.12135832f, 0.05048521f, -0.07846002f, -0.06103463f, 0.04678655f, -0.07365182f, -0.07492603f, 0.08749157f, 
    -0.22047620f, 0.12231173f, 0.02683812f, -0.09670632f, -0.02760310f, 0.03808723f, -0.02049619f, -0.08067401f, 
    0.19421864f, 0.06984420f, -0.00478511f, 0.01603560f, 0.02506878f, -0.08611441f, 0.16650772f, -0.05933386f, 
    -0.06175910f, 0.00878444f, 0.13023502f, 0.03253041f, -0.00266062f, 0.00174996f, 0.03687926f, -0.03482263f, 
    0.08512587f, -0.09140662f, 0.03607241f, -0.12563360f, 0.07321982f, 0.07783245f, 0.06500969f, 0.09540144f, 
    0.00765681f, -0.00489331f, -0.09578853f, 0.00008964f, -0.35091707f, -0.16978593f, -0.09998669f, -0.10116550f, 
    0.04133737f, 0.05955176f, 0.06987615f, -0.03151242f, 0.05941964f, 0.10942011f, 0.01290326f, 0.04515813f, 
    0.04404779f, -0.03378901f, 0.06404613f, -0.05715882f, -0.01988225f, -0.01650753f, 0.03211276f, 0.14158322f, 
    0.03855076f, -0.07747692f, 0.10424240f, 0.19061056f, -0.55845666f, -0.02047915f, 0.01368886f, -0.00215774f, 
    0.04567371f, -0.05196711f, 0.11351474f, 0.14596969f, 0.01490338f, 0.03799636f, 0.18426082f, 0.10104305f, 
    -0.17598997f, 0.00110217f, -0.12527592f, 0.10555127f, 0.05987436f, 0.04596692f, -0.03781158f, 0.07987035f, 
    0.07532543f, 0.06259161f, -0.01255873f, 0.02549838f, -0.04864277f, 0.13655280f, 0.12042660f, 0.01456440f, 
    0.00946301f, 0.10855963f, 0.25818971f, 0.08539214f, -0.15908131f, 0.01038694f, 0.04383685f, -0.10777285f, 
    -0.09570295f, 0.25369576f, 0.09088116f, -0.10051551f, -0.01312180f, -0.07451565f, -0.10028796f, -0.16485539f, 
    0.03307709f, -0.01146867f, -0.02997024f, -0.03146416f, 0.11479221f, 0.10920946f, -0.20148002f, 0.08107203f, 
    0.06195417f, 0.06593709f, 0.04637793f, 0.03347619f, 0.03203516f, 0.03650587f, 0.00091280f, -0.03763021f, 
    -0.05930895f, -0.09477758f, -0.13916561f, -0.05052697f, 0.12180231f, -0.02337282f, -0.14613484f, -0.08746463f, 
    -0.02682801f, 0.04453389f, 0.00218634f, 0.12172156f, 0.10524645f, 0.01958251f, 0.03442108f, 0.16069658f, 
    -0.10550115f, 0.07312892f, 0.08761521f, 0.08417317f, 0.03721287f, 0.01977611f, -0.00785252f, 0.04049978f, 
    -0.19787338f, -0.01841994f, -0.03102935f, -0.11971790f, 0.00517422f, 0.00684560f, 0.08090391f, -0.06754451f, 
    -0.03612834f, 0.04901011f, 0.00649822f, -0.06824002f, 0.19331677f, 0.19225316f, 0.17153069f, 0.05262544f, 
    -0.08675158f, -0.02578874f, -0.06362677f, 0.05652819f, -0.10990910f, -0.03689356f, 0.04159572f, 0.01996928f, 
    0.11842430f, -0.17724435f, -0.01918256f, 0.12500316f, 0.09615586f, -0.04606414f, 0.08354014f, 0.08389933f, 
    0.01462133f, 0.00296055f, -0.02340390f, -0.00584497f, 0.32358229f, 0.03848999f, -0.06299196f, 0.03970890f, 
    -0.06660505f, 0.02791640f, -0.01890513f, -0.05839850f, 0.04153239f, -0.04429725f, 0.03260335f, -0.00071284f, 
    0.26714626f, -0.11335161f, 0.05590706f, 0.02349398f, 0.09996056f, -0.01455983f, 0.08070134f, 0.10848686f, 
    -0.03534551f, -0.06117093f, -0.00636256f, 0.02324361f, 0.22571214f, 0.31364501f, -0.06789503f, 0.16330172f, 
    0.06655038f, 0.03536057f, 0.00213890f, 0.00697505f, 0.03734302f, -0.06143139f, 0.06044718f, -0.00107375f, 
    -0.30248648f, -0.08643273f, -0.19564694f, -0.16934600f, 0.19800688f, -0.05032240f, 0.03622752f, -0.14433879f, 
    0.02398835f, 0.03862348f, 0.01535932f, 0.02446298f, 0.24113086f, -0.03041119f, 0.07152168f, 0.18338299f, 
    0.15327607f, 0.01197771f, 0.00383250f, 0.05362310f, 0.04140913f, 0.09259114f, 0.03173700f, -0.06358626f, 
    -0.09982503f, -0.23390035f, -0.37728596f, 0.15673265f, -0.01632347f, -0.08650511f, 0.11389767f, -0.13090280f, 
    -0.07748774f, -0.02033064f, 0.08736585f, -0.01193971f, 0.08408063f, 0.41155675f, -0.03304355f, -0.13392569f, 
    -0.05928955f, -0.03336778f, 0.17226695f, 0.04455506f, 0.00819854f, -0.02365495f, 0.03885685f, 0.05760349f, 
    -0.23401293f, 0.28685227f, 0.03315913f, -0.02061572f, 0.07384753f, -0.03982602f, -0.06140703f, -0.10353114f, 
    0.02426927f, -0.05744425f, 0.04528557f, 0.06291881f, -0.18375520f, -0.22729754f, -0.09160460f, 0.21859688f, 
    -0.15164770f, -0.00547987f, -0.06224104f, -0.08828207f, -0.12190249f, 0.00168653f, -0.05717858f, 0.08642419f, 
    -0.46130383f, 0.17521600f, 0.25289387f, 0.13429454f, 0.07519442f, 0.03356110f, -0.01933799f, -0.06799767f, 
    0.07213186f, 0.02969352f, -0.05870700f, 0.07539207f, 0.14297846f, -0.13926874f, 0.09056978f, -0.04848741f, 
    -0.01793575f, 0.12839574f, 0.03545146f, 0.09290068f, 0.01245214f, 0.05611011f, -0.20018801f, 0.15728143f, 
    -0.10320179f, -0.15325199f, -0.29601961f, 0.25789702f, -0.08001973f, -0.07701236f, -0.00531702f, -0.01065490f, 
    -0.00619271f, -0.00952239f, -0.07558074f, 0.10661012f, -0.15136217f, -0.17187059f, -0.04978706f, 0.09871096f, 
    -0.05339642f, 0.06131493f, -0.10260139f, -0.08209609f, 0.14379263f, 0.02794535f, 0.13169202f, -0.06916184f, 
    0.00903121f, -0.46654797f, 0.14882050f, 0.07132459f, 0.05809585f, -0.03259559f, -0.08661076f, 0.04049142f, 
    0.07179199f, -0.01001448f, 0.11764968f, -0.07553700f, 0.07332131f, 0.01072581f, 0.15740789f, 0.10513684f, 
    -0.01199056f, -0.04715404f, -0.08122511f, -0.00272496f, 0.07808659f, -0.05432946f, 0.00477861f, 0.09600845f, 
    0.01419146f, 0.29791608f, -0.04957378f, -0.03004126f, 0.07427501f, -0.01604149f, 0.06905175f, -0.05714527f, 
    -0.06995414f, -0.01458028f, -0.01669617f, -0.03355873f, 0.35465452f, -0.01940520f, 0.00548969f, 0.01117413f, 
    0.02748379f, -0.00583730f, 0.09049983f, 0.11890107f, 0.18506999f, 0.08116884f, 0.01032122f, 0.07150056f, 
    0.06707139f, -0.07813457f, 0.02346690f, 0.22480819f, 0.14578821f, -0.05986835f, -0.05956831f, 0.02049891f, 
    -0.01329503f, 0.04407495f, 0.08095194f, -0.03416618f, -0.28386158f, 0.05571019f, 0.17859758f, -0.07544343f, 
    -0.02573900f, -0.09007425f, -0.19415598f, -0.03308703f, 0.12643301f, 0.00368303f, -0.07471607f, -0.01930700f, 
    0.13334402f, -0.03770403f, 0.22216967f, -0.20868777f, 0.06955310f, 0.13760310f, 0.19008926f, -0.02167558f, 
    -0.02416863f, 0.17713517f, 0.06781337f, -0.04699956f, 0.07410400f, 0.32500362f, 0.18790296f, -0.20414138f, 
    0.04122909f, -0.04548579f, -0.11169981f, -0.05328956f, 0.16746731f, -0.03332215f, -0.05099714f, 0.09642332f, 
    0.15195581f, -0.02750861f, 0.07357155f, 0.24768718f, -0.09741491f, -0.06324363f, 0.04437247f, 0.01737081f, 
    0.03462510f, 0.03656535f, 0.03870701f, 0.04090632f, -0.29767627f, 0.15749100f, 0.24982879f, 0.15854935f, 
    -0.02557911f, 0.01802265f, -0.10781021f, 0.00248798f, 0.04992938f, 0.01985266f, -0.17283161f, 0.11859649f, 
    -0.01758096f, 0.03371055f, 0.15469794f, -0.11843421f, -0.17276981f, -0.07394515f, 0.10789308f, -0.02722798f, 
    -0.01566706f, -0.00928653f, -0.03692092f, 0.07406633f, 0.23114936f, 0.01277549f, 0.20419510f, 0.13391094f, 
    0.02507591f, 0.05443814f, 0.00328492f, 0.07144348f, 0.11607184f, 0.04149358f, -0.06311167f, -0.00368135f, 
    0.26620960f, -0.01734207f, -0.04249186f, -0.05330973f, -0.09509148f, -0.00069218f, -0.01081672f, -0.15261035f, 
    0.05412448f, 0.05586440f, 0.12784176f, -0.03219113f, 0.03439586f, -0.07799135f, -0.02700754f, -0.17593458f, 
    -0.02203656f, 0.13108201f, 0.02951563f, -0.04724979f, -0.02736586f, -0.03039689f, -0.05711057f, -0.13676983f, 
    0.15494128f, 0.38003516f, 0.15910412f, -0.02755514f, 0.04899462f, -0.05843177f, 0.13049372f, 0.09161881f, 
    0.02411913f, 0.01322538f, -0.06897964f, -0.14186078f, 0.18729530f, 0.17444824f, 0.08286035f, -0.00333889f, 
    0.12783216f, -0.03434719f, -0.07967440f, 0.00935271f, 0.05721476f, -0.06251859f, 0.03006464f, -0.11799488f, 
    -0.01079865f, 0.25575820f, 0.04026844f, -0.05266666f, 0.03473445f, 0.12125058f, -0.07207046f, 0.03885216f, 
    0.10446222f, 0.11803790f, 0.04450207f, -0.04332870f, 0.47720867f, -0.10523544f, 0.05630577f, 0.05069357f, 
    -0.03089190f, 0.10583632f, 0.00307397f, 0.04782347f, 0.01889495f, -0.09947720f, -0.03596998f, 0.02873096f, 
    0.16001140f, 0.19127664f, 0.05785037f, 0.15563472f, -0.08350109f, 0.05395814f, 0.00569837f, 0.04000603f, 
    -0.03853488f, -0.08927932f, -0.07849126f, -0.05474023f, 0.01363540f, -0.20581959f, -0.16776197f, -0.16984093f, 
    0.16145222f, -0.03262242f, 0.03248992f, -0.07711190f, 0.07499788f, 0.10649616f, -0.15087549f, 0.05094644f, 
    0.11898977f, 0.15025468f, 0.01348193f, 0.25215173f, -0.11193922f, 0.09798402f, -0.03202097f, -0.06303340f, 
    0.04210986f, -0.02908633f, 0.04489426f, -0.04258743f, -0.51136363f, -0.16567434f, -0.11009160f, -0.09098386f, 
    -0.07472050f, 0.05607717f, 0.04139741f, 0.15141280f, 0.06794684f, 0.04929037f, 0.10258320f, 0.09261275f, 
    0.29352501f, 0.13961037f, 0.03579341f, -0.01066107f, 0.02599006f, 0.14099987f, 0.04312701f, -0.08550007f, 
    0.11171727f, -0.05165033f, -0.07094448f, -0.02554764f, -0.27301830f, 0.05643425f, -0.08434597f, 0.00219632f, 
    -0.08320948f, -0.10429959f, 0.05259477f, -0.09369110f, 0.07681318f, -0.07320718f, 0.05957626f, -0.03654256f, 
    -0.01080078f, 0.02106383f, 0.01766004f, -0.01744085f, 0.01361117f, 0.00492251f, -0.04864107f, -0.02275524f, 
    0.03933347f, 0.03496973f, -0.01766069f, -0.04607260f, -0.04728034f, -0.03395187f, 0.03141705f, -0.01414633f, 
    0.00360663f, -0.00586912f, 0.00692034f, -0.03424849f, -0.00075418f, -0.04514503f, 0.02915914f, -0.02657868f, 
    -0.01445411f, 0.01195131f, -0.00599569f, 0.02682801f, -0.01109423f, 0.02554020f, -0.05979874f, -0.04345119f, 
    0.03901975f, -0.04256218f, -0.05729504f, 0.02574862f, -0.02490665f, 0.03666515f, 0.03898388f, -0.00525287f, 
    -0.05351650f, 0.03880382f, -0.04426464f, -0.00089113f, -0.02566787f, 0.01419813f, -0.00897160f, -0.05007231f, 
    -0.00756520f, 0.03663705f, 0.03070636f, 0.03312779f, -0.03070270f, 0.00363328f, -0.02632015f, 0.00723057f, 
    -0.01072224f, 0.02427696f, -0.02423801f, 0.02998954f, -0.02449651f, -0.04381084f, -0.04104725f, -0.05394212f, 
    -0.04410286f, 0.03863560f, -0.01549152f, 0.01787511f, 0.03052203f, -0.00023843f, -0.02015582f, 0.03744587f, 
    -0.02895929f, -0.01623116f, 0.02536540f, -0.01778946f, 0.00738864f, -0.01911636f, -0.02077151f, 0.03040328f, 
    0.02961100f, 0.03369954f, 0.03781787f, 0.01898923f, -0.04080167f, 0.00699971f, -0.04424797f, -0.04580483f, 
    -0.05076418f, -0.03221697f, -0.01795334f, 0.02362704f, -0.05848724f, -0.00083944f, 0.02871157f, 0.03490506f, 
    -0.02656117f, 0.02092427f, 0.03911150f, -0.04296489f, -0.05092517f, -0.02219126f, -0.01738306f, -0.05446406f, 
    -0.00089154f, -0.03206362f, -0.04709961f, -0.04630049f, -0.03763524f, 0.01084531f, 0.02515946f, 0.00159996f, 
    -0.04180445f, -0.04305996f, 0.01073804f, 0.00243124f, 0.02152965f, 0.01138613f, -0.00012459f, -0.04741598f, 
    0.02051184f, 0.00625608f, 0.00480253f, 0.01452581f, 0.01216012f, -0.01139594f, -0.01211947f, -0.05389534f, 
    0.01283040f, -0.05566634f, 0.01095679f, -0.00799918f, -0.04336347f, 0.03423178f, -0.03633052f, 0.00789574f, 
    -0.05798673f, -0.00426972f, 0.02714457f, 0.02752253f, -0.00240722f, -0.05261239f, -0.04694521f, -0.00052605f, 
    0.02455307f, 0.01839182f, 0.00592543f, 0.00864366f, 0.03075588f, 0.00587940f, -0.02125702f, -0.04651915f, 
    -0.04611420f, 0.02563609f, -0.04702157f, 0.01098175f, 0.01292831f, 0.02189089f, -0.04414279f, 0.02666930f, 
    0.01119998f, -0.02282057f, -0.03034418f, 0.03748361f, 0.00646693f, 0.03205021f, 0.02973740f, -0.04717170f, 
    0.01120242f, 0.04479909f, -0.01882773f, -0.04685727f, 0.01612504f, 0.02816749f, 0.02283689f, -0.00199876f, 
    -0.00385161f, 0.01331258f, 0.03653276f, -0.03629852f, -0.06086056f, -0.00721080f, 0.00329386f, 0.02541214f, 
    -0.00961962f, 0.01197539f, 0.00797273f, -0.01552506f, -0.05435462f, -0.01980473f, -0.01916766f, -0.02829245f, 
    0.03108778f, -0.00297546f, -0.02524530f, -0.04237089f, -0.00511379f, 0.02620551f, 0.00509136f, 0.03133450f, 
    0.01796992f, -0.02911559f, -0.01732543f, -0.00998650f, -0.02853488f, -0.04716483f, 0.01529151f, -0.02900895f, 
    0.01771271f, -0.00306769f, -0.04138513f, 0.03462895f, 0.04407946f, 0.03746207f, 0.04158856f, -0.04791288f, 
    0.00324657f, -0.03231727f, -0.03817073f, -0.00321902f, 0.02021329f, -0.05144381f, -0.02835592f, -0.02845412f, 
    -0.00969483f, 0.01136564f, 0.02590545f, -0.00456620f, -0.03715208f, 0.02631118f, 0.02412317f, 0.01732299f, 
    -0.03182791f, 0.00386096f, 0.00464885f, -0.02486405f, 0.02221931f, 0.02292737f, -0.01556938f, 0.00087808f, 
    -0.03498603f, 0.03936505f, 0.01838303f, -0.03803056f, -0.02962662f, -0.02357122f, -0.04174621f, -0.02872128f, 
    0.03527991f, -0.03585584f, 0.00653148f, -0.03088676f, -0.03496844f, -0.04513963f, -0.00402840f, -0.03652669f, 
    -0.05770594f, -0.04255575f, -0.03636057f, -0.02774305f, -0.04798189f, 0.03803364f, 0.02494880f, -0.03726054f, 
    -0.00011753f, -0.01854594f, -0.02290136f, 0.02233157f, -0.05267628f, -0.04018567f, 0.00133903f, -0.03748634f, 
    0.03497411f, -0.03667518f, 0.04028424f, -0.03047695f, 0.00826056f, -0.00329706f, -0.03129270f, -0.03769209f, 
    0.03111884f, -0.02053202f, 0.04155722f, 0.00385238f, -0.04908689f, 0.00195164f, -0.03275783f, -0.05397157f, 
    0.00702367f, 0.00505885f, 0.03559054f, 0.02355496f, 0.02368370f, 0.02526857f, 0.00963612f, 0.00827304f, 
    0.01944685f, 0.04071373f, -0.03325412f, -0.00875859f, -0.01934290f, -0.04165765f, -0.05598576f, -0.01027282f, 
    -0.03907885f, -0.04222021f, -0.04628109f, -0.04850350f, -0.04950538f, -0.00378732f, 0.03771888f, -0.01414790f, 
    -0.03073919f, -0.02537810f, 0.03511315f, -0.04792475f, 0.00994347f, -0.04600083f, -0.01367603f, -0.00120092f, 
    0.01023972f, -0.01126799f, -0.03427994f, 0.01068633f, -0.03647091f, 0.02641239f, -0.04816439f, -0.00619262f, 
    0.01971448f, -0.01596449f, 0.00963331f, 0.03203939f, -0.04640586f, -0.01032057f, -0.02410309f, -0.01595979f, 
    -0.02868241f, -0.00807640f, -0.03377255f, 0.01109859f, 0.03246560f, -0.04192860f, -0.00533244f, -0.00376074f, 
    -0.02288892f, -0.04776417f, -0.02464991f, 0.01287876f, 0.01263035f, -0.00568927f, -0.02696672f, 0.01390109f, 
    0.02059139f, 0.03214081f, -0.03220504f, 0.01800347f, -0.01326550f, -0.04907954f, 0.05075703f, -0.03419390f, 
    -0.04668422f, 0.02549087f, 0.03458592f, -0.01177876f, 0.03291862f, -0.00668147f, 0.02918355f, 0.01862570f, 
    0.02000666f, -0.01894534f, -0.02528043f, 0.02311334f, -0.04345074f, 0.02983331f, -0.01287701f, -0.01575166f, 
    -0.01894366f, 0.03556040f, -0.02694018f, 0.02903959f, -0.00724310f, -0.05050515f, -0.03847386f, -0.05205030f, 
    -0.17614549f, -0.24980946f, -0.03521394f, 0.01201134f, 0.08122437f, 0.04256086f, 0.12964225f, -0.02522719f, 
    -0.01857756f, 0.05339195f, 0.06018656f, 0.05902044f, -0.06446780f, 0.28181556f, 0.19451578f, 0.18205224f, 
    -0.09198012f, -0.14499415f, 0.10919078f, 0.03009044f, -0.06751893f, -0.01191797f, -0.05414427f, 0.02658704f, 
    0.13266239f, -0.02331870f, 0.18806694f, -0.10322587f, -0.09896461f, -0.09423085f, 0.05896769f, -0.07055165f, 
    0.11607298f, -0.04155475f, -0.00225831f, 0.03095151f, -0.37717360f, -0.15369947f, -0.08113393f, 0.13032514f, 
    0.14352758f, 0.01928491f, -0.07591818f, 0.01418940f, 0.22280627f, 0.02169472f, -0.01062483f, 0.04060314f, 
    -0.22735730f, 0.14442691f, 0.00520878f, 0.24679753f, -0.00048875f, 0.03446881f, -0.01063440f, 0.01745145f, 
    0.07676230f, 0.04915300f, 0.00774989f, -0.02535539f, 0.12530893f, 0.01772323f, 0.20597830f, -0.05557834f, 
    -0.10355975f, 0.08500593f, -0.04140844f, 0.13323699f, -0.10907526f, 0.12858236f, -0.00374347f, 0.04879843f, 
    -0.08581005f, 0.00655719f, -0.30383071f, 0.17162354f, 0.12479053f, 0.00123045f, -0.08342934f, 0.09896442f, 
    0.06309146f, 0.00259234f, 0.04041168f, 0.04023020f, 0.03316105f, -0.22484101f, -0.25205258f, 0.33215004f, 
    0.07728016f, 0.01155547f, -0.04202828f, -0.03622346f, 0.00268031f, 0.06152116f, 0.06401139f, -0.02118490f, 
    -0.26218289f, -0.39407864f, -0.19569607f, 0.11741734f, 0.23588333f, 0.12622693f, -0.14355835f, -0.02751674f, 
    -0.00420704f, -0.04045039f, 0.07876312f, -0.05210611f, -0.03005140f, 0.03175031f, 0.21091413f, -0.16748290f, 
    0.17339489f, 0.00021082f, -0.04742950f, 0.11085863f, -0.05182124f, 0.01209085f, 0.01794216f, 0.04772393f, 
    0.32109094f, 0.24804026f, 0.06865618f, -0.32072848f, -0.03067172f, -0.01428110f, -0.01142881f, -0.03326183f, 
    0.04930090f, 0.06535265f, -0.03554502f, 0.14088830f, 0.27595770f, 0.12557958f, -0.19811583f, -0.18042754f, 
    0.06045860f, 0.08741391f, 0.05776302f, 0.07355744f, 0.19763440f, 0.05988413f, 0.10756383f, -0.05080908f, 
    0.01553429f, -0.13765854f, 0.15653931f, -0.04694045f, -0.00556293f, -0.06436086f, 0.09215984f, 0.05754932f, 
    -0.10197255f, -0.00895209f, -0.13935895f, -0.07669748f, 0.03859258f, 0.10427716f, 0.00540438f, 0.02307414f, 
    0.08839607f, -0.02169874f, -0.04929394f, 0.04405289f, 0.02609648f, 0.01594794f, -0.03207895f, -0.01758600f, 
    -0.02772705f, 0.04682066f, -0.09491622f, 0.37975404f, -0.13138413f, -0.00929984f, 0.08935836f, 0.05671138f, 
    -0.13193649f, 0.08384125f, 0.12514807f, -0.00304840f, 0.17626181f, 0.11126892f, 0.14800628f, 0.28397167f, 
    -0.15131721f, -0.14141354f, -0.00523400f, -0.06105130f, 0.01158363f, -0.11360780f, -0.02752825f, -0.05198741f, 
    -0.14555600f, -0.01687424f, 0.07769870f, 0.19327667f, 0.01974608f, 0.05120600f, -0.01422222f, 0.03222427f, 
    0.04227066f, 0.05430826f, -0.10979532f, -0.12093910f, -0.04106058f, 0.16789684f, 0.06203308f, -0.03428113f, 
    0.08306169f, 0.02370697f, 0.06940559f, -0.10381211f, 0.04987166f, -0.05663058f, -0.14553912f, 0.18492575f, 
    -0.14152446f, 0.34370533f, 0.11868216f, -0.12528484f, -0.11152039f, 0.09620419f, -0.04137589f, 0.00487551f, 
    0.04705096f, -0.03529031f, 0.05787327f, 0.03181236f, 0.14490613f, -0.25332323f, 0.11089483f, -0.14899659f, 
    0.22860779f, -0.03815002f, -0.01491474f, -0.04827610f, 0.24638872f, -0.06512516f, 0.05617954f, 0.23043738f, 
    0.03023393f, -0.10614277f, -0.18192083f, 0.12984955f, 0.08094949f, -0.06799746f, 0.14772886f, 0.05718662f, 
    -0.04369665f, -0.08559240f, 0.12748808f, 0.03365352f, -0.20698202f, 0.22620687f, 0.15564178f, 0.06999840f, 
    -0.16133207f, 0.03285332f, 0.04868720f, 0.06217342f, 0.00704982f, -0.04052695f, -0.01580457f, 0.05915282f, 
    0.11034553f, 0.05379028f, 0.25734740f, -0.15961534f, -0.09640174f, -0.03357989f, 0.08939867f, 0.15689175f, 
    -0.03503075f, 0.04136488f, 0.11422364f, -0.04248480f, 0.04964571f, 0.20091549f, -0.12119822f, 0.10823692f, 
    0.07482854f, -0.07991292f, -0.11077138f, 0.12270191f, 0.00810128f, -0.12047064f, 0.06329227f, -0.02889937f, 
    0.08074584f, -0.00399847f, 0.05223778f, 0.26093426f, -0.11930183f, -0.15461046f, 0.03390128f, 0.09786984f, 
    0.07631017f, 0.01144048f, 0.10456845f, 0.06393152f, 0.02191497f, -0.09429836f, -0.22144932f, 0.07147622f, 
    -0.01095407f, 0.14362960f, 0.06828513f, 0.01003742f, 0.23947395f, 0.09826672f, -0.01922910f, -0.03558614f, 
    0.19744374f, 0.19926398f, 0.01426649f, -0.02512376f, -0.14718638f, 0.07032067f, -0.09693410f, 0.04280182f, 
    0.10887639f, -0.08313504f, -0.01551997f, -0.03751641f, -0.15231693f, -0.22367091f, 0.01342221f, -0.07854544f, 
    0.05115511f, 0.08277916f, -0.07014474f, 0.08265358f, 0.01826919f, 0.06345133f, -0.06901687f, 0.12476008f, 
    -0.07885941f, 0.27847731f, 0.23628944f, -0.14673822f, 0.02648986f, 0.04649770f, 0.00386968f, -0.03493636f, 
    0.06017736f, 0.00429685f, 0.24159546f, 0.14321244f, -0.07776321f, -0.22045711f, -0.08825365f, -0.10524844f, 
    0.15362363f, 0.06611091f, -0.07245075f, -0.06559144f, 0.10980730f, -0.01605690f, 0.14476097f, -0.03420750f, 
    0.02635033f, 0.03409996f, 0.27458245f, 0.31761065f, -0.16551478f, 0.03463868f, -0.02100769f, 0.07193694f, 
    0.03132439f, -0.12451598f, 0.10895658f, -0.03752997f, -0.09241962f, -0.01278809f, -0.02580862f, -0.22047697f, 
    0.13891491f, 0.06274795f, -0.05682186f, -0.05508176f, -0.01394189f, -0.10894269f, 0.05636659f, 0.02112593f, 
    0.02385921f, -0.03431765f, -0.00297836f, -0.00836648f, -0.00177157f, 0.01201061f, 0.04057577f, 0.01309039f, 
    -0.03027530f, 0.01549239f, -0.04563133f, -0.02951336f, 0.00995076f, 0.03350690f, -0.03264391f, -0.03719325f, 
    -0.00672933f, -0.01169682f, -0.03820115f, 0.01768739f, 0.02460684f, 0.01500102f, -0.05740812f, 0.00799086f, 
    0.04188084f, 0.01621472f, 0.04071902f, -0.04856537f, 0.01404836f, -0.02484018f, 0.03720767f, 0.03217810f, 
    0.03755304f, -0.01885889f, 0.02361276f, -0.05361428f, -0.02494425f, 0.03194739f, -0.05701016f, 0.00060905f, 
    0.02852658f, 0.03956552f, 0.02976498f, -0.01969174f, 0.03673584f, -0.05346106f, -0.04681440f, 0.00945684f, 
    -0.04973984f, -0.04239867f, -0.04327212f, 0.03125172f, -0.04283428f, -0.04765856f, -0.00468695f, 0.00617233f, 
    -0.03997354f, -0.02567306f, 0.01550503f, -0.05322568f, 0.02067300f, -0.00956693f, -0.02141630f, -0.00046530f, 
    -0.04603675f, -0.03321846f, 0.01635475f, -0.00225152f, 0.00639409f, 0.01125441f, 0.01946122f, -0.00909484f, 
    -0.04267883f, 0.01050618f, -0.05731091f, -0.04359254f, -0.05523498f, -0.03818968f, -0.00616024f, 0.00400077f, 
    0.00284204f, -0.00409401f, -0.03227537f, -0.01682493f, -0.03839078f, -0.03050483f, -0.00216746f, 0.01044185f, 
    0.03865645f, 0.03435661f, 0.03443902f, 0.00066917f, 0.00334946f, -0.00315399f, 0.01186956f, -0.02891392f, 
    0.00993964f, -0.02243367f, 0.00195783f, -0.01669955f, -0.05500892f, -0.03495354f, -0.01783056f, 0.01867659f, 
    -0.05233690f, 0.02886424f, -0.04127938f, 0.00079978f, -0.03540606f, 0.00794716f, -0.05038173f, 0.01055704f, 
    -0.03697578f, -0.03633144f, -0.01518028f, 0.00620420f, -0.02720973f, -0.04660289f, 0.03228090f, -0.02750763f, 
    0.00338436f, -0.02179095f, -0.04663784f, 0.02241411f, 0.02312217f, -0.02322297f, -0.05598385f, 0.03859022f, 
    0.00396020f, -0.04363973f, 0.01997765f, 0.01198283f, 0.04131792f, 0.02165858f, -0.03060485f, 0.04207588f, 
    -0.04242811f, 0.02186406f, -0.00955471f, 0.02920331f, -0.04327317f, -0.02719446f, -0.05254538f, -0.01478713f, 
    -0.01091847f, -0.03813379f, -0.04221153f, -0.03937488f, 0.03303835f, 0.00797537f, -0.01224211f, 0.02731725f, 
    -0.02632617f, 0.02651237f, -0.02175766f, 0.03682630f, -0.00068908f, 0.00553237f, 0.00127070f, 0.00492838f, 
    0.01571883f, -0.04033239f, 0.00576192f, -0.03910194f, -0.05270186f, -0.05375361f, -0.04972617f, 0.01096550f, 
    0.01091397f, -0.03003358f, -0.01969958f, -0.02081995f, 0.01663180f, 0.03529164f, 0.02514696f, 0.02543054f, 
    -0.04504376f, -0.00649547f, -0.03853864f, 0.02134528f, 0.03310074f, 0.01254020f, 0.04025612f, -0.03067715f, 
    0.00427711f, 0.01452402f, -0.01034938f, -0.05645947f, 0.03352332f, -0.04488352f, 0.04172139f, -0.00149910f, 
    0.03883968f, -0.01166846f, 0.00685506f, 0.02493974f, 0.02722200f, 0.00081736f, -0.01796576f, -0.01753012f, 
    -0.04195569f, 0.02358694f, -0.03995693f, -0.05173815f, -0.02554754f, -0.02742993f, 0.00197645f, 0.01045051f, 
    0.02186735f, -0.02249587f, 0.00377449f, 0.00603185f, 0.03947046f, -0.04587729f, 0.02434368f, -0.00925353f, 
    -0.02471132f, 0.03061384f, -0.02904706f, -0.01887541f, -0.03779390f, -0.03761410f, -0.05711380f, 0.00937236f, 
    -0.01951411f, -0.02199158f, 0.03029530f, -0.02401715f, 0.04188706f, 0.03258289f, 0.00712446f, -0.03457942f, 
    -0.01876787f, -0.02994114f, -0.04457553f, -0.01444019f, 0.02241449f, 0.03738786f, 0.03792066f, 0.00575057f, 
    -0.05568363f, -0.02170498f, 0.01968659f, -0.00013975f, 0.03029727f, 0.03432598f, -0.04513323f, -0.02671276f, 
    -0.02155713f, -0.01981481f, -0.05358168f, -0.03343332f, 0.02117958f, -0.04651967f, -0.02435530f, -0.01240749f, 
    0.02873684f, -0.03907457f, -0.03075469f, -0.02172774f, -0.01924840f, -0.01655251f, -0.05300867f, -0.04892638f, 
    -0.01325374f, 0.03907625f, 0.01248902f, -0.04788966f, 0.01228883f, 0.04426727f, -0.02575968f, -0.01535301f, 
    0.00889297f, -0.03411729f, -0.00167432f, -0.02943499f, -0.02218035f, -0.01509066f, 0.02619936f, -0.03144871f, 
    -0.00920204f, -0.03875274f, -0.01533175f, 0.01817503f, -0.03309422f, 0.00128609f, 0.01529384f, -0.05717157f, 
    0.02356832f, 0.02017413f, -0.01321315f, -0.03892148f, -0.00246895f, -0.01044673f, -0.02906255f, 0.02683697f, 
    -0.04022316f, -0.02745503f, -0.05691864f, -0.01591657f, 0.01899339f, 0.01338488f, -0.02393509f, -0.03064232f, 
    -0.02558898f, -0.01343967f, -0.03109541f, -0.03840626f, 0.04052274f, -0.01218064f, 0.04097928f, -0.00832124f, 
    0.03750729f, -0.01471050f, -0.03074586f, 0.02569335f, -0.00176803f, -0.04407479f, -0.00439363f, 0.04021185f, 
    0.04579748f, -0.04411038f, -0.01835492f, -0.05448044f, -0.01730857f, 0.04271767f, -0.02424813f, -0.01444070f, 
    -0.05460005f, -0.00901430f, 0.03939590f, -0.00504851f, 0.03356788f, -0.01081736f, 0.01497665f, 0.01711783f, 
    -0.00745595f, -0.01308891f, 0.03928465f, 0.03812413f, -0.05428023f, -0.03590818f, -0.02361103f, 0.03821378f, 
    -0.01531427f, -0.03712649f, -0.04194871f, -0.00980526f, 0.00990734f, 0.03690922f, -0.03805940f, -0.03536986f, 
    0.00309916f, -0.01825505f, 0.03292423f, -0.03314877f, 0.00202103f, 0.01088676f, -0.04438929f, -0.05045030f, 
    0.03421602f, 0.03904507f, -0.03695248f, -0.04439222f, -0.03607006f, 0.00724908f, -0.05731881f, -0.03677016f, 
    0.04016160f, -0.03558644f, -0.01589098f, -0.02603991f, 0.00486260f, 0.00238556f, 0.03707956f, 0.00170038f, 
    0.02831873f, -0.05321271f, -0.00483829f, -0.03650939f, -0.05642580f, 0.01997655f, 0.01291050f, -0.04774271f, 
    -0.13729964f, 0.27376115f, 0.22296315f, -0.16192435f, 0.03328865f, 0.09524515f, 0.09714577f, 0.00007892f, 
    0.14357236f, 0.21505250f, -0.10686984f, 0.02138084f, -0.00061147f, -0.12392869f, -0.05209590f, 0.10450371f, 
    -0.10810980f, 0.16955185f, -0.06603434f, -0.01461979f, 0.00470642f, 0.08904702f, 0.14264891f, -0.01972056f, 
    0.14282398f, -0.26907802f, -0.03282255f, 0.25863576f, 0.04123038f, 0.15649013f, 0.05043094f, 0.00343966f, 
    -0.12616807f, -0.11075104f, -0.02866497f, -0.07599146f, -0.03981560f, 0.14412770f, 0.02249054f, -0.15562589f, 
    0.09484347f, -0.05622444f, -0.02134700f, -0.04523035f, 0.03914864f, -0.09674628f, -0.02542415f, -0.00682639f, 
    0.28989717f, -0.25856221f, 0.11379178f, 0.09775688f, 0.23196933f, 0.04360387f, 0.10523028f, -0.01650492f, 
    -0.01824004f, -0.02944384f, -0.09560508f, -0.04737960f, 0.08567610f, 0.13700837f, 0.04524992f, 0.12453803f, 
    -0.01397758f, 0.06883968f, 0.00132557f, -0.18928716f, -0.04414313f, -0.10211232f, 0.25319123f, 0.36127833f, 
    -0.02594533f, 0.14949694f, 0.05099769f, -0.23988152f, -0.06220367f, 0.09597409f, 0.09570172f, 0.03806773f, 
    -0.03048377f, 0.01112332f, 0.01948949f, -0.10772251f, -0.29695836f, 0.08442803f, 0.13850583f, -0.23919347f, 
    0.00239567f, -0.01767296f, 0.00492084f, -0.13962927f, -0.10885520f, -0.14712933f, -0.06083256f, 0.10655767f, 
    -0.11477447f, 0.21475159f, 0.09272269f, -0.05378467f, -0.06174506f, 0.04688938f, 0.03960435f, 0.05415003f, 
    0.03028050f, 0.09220356f, -0.01579804f, 0.04575450f, 0.30762982f, 0.17645791f, -0.00697424f, -0.01732874f, 
    -0.13447963f, 0.15781757f, -0.06272040f, -0.13346101f, 0.02867516f, 0.02164720f, -0.08525688f, -0.14033897f, 
    0.04695339f, 0.00803113f, -0.15394458f, 0.12648973f, 0.01604416f, 0.17640273f, 0.01736764f, -0.06772883f, 
    0.01460281f, 0.12076060f, 0.07143654f, 0.12587869f, -0.08096737f, -0.04063752f, -0.00792534f, 0.22538273f, 
    0.03199026f, 0.01667064f, -0.08678088f, -0.02519482f, -0.04741704f, 0.01903509f, -0.14314823f, -0.05020572f, 
    0.44298941f, 0.03541195f, 0.22691064f, -0.01757202f, -0.06880518f, 0.03008480f, 0.04597249f, 0.04491311f, 
    0.06098035f, -0.05896012f, 0.00254019f, -0.13676050f, 0.02416154f, -0.24419957f, -0.12747633f, 0.06359990f, 
    0.01839068f, -0.00893569f, 0.13404205f, -0.06481092f, -0.04532788f, -0.09053614f, 0.02701314f, 0.12369731f, 
    -0.05216265f, -0.09799338f, 0.03430501f, 0.32286131f, -0.04635140f, -0.08214910f, 0.08214574f, 0.02840655f, 
    -0.15332797f, 0.09084421f, 0.08612761f, 0.13904406f, -0.00473915f, -0.12549180f, -0.10535296f, 0.01413738f, 
    0.02701528f, 0.09386713f, -0.01464163f, 0.09670631f, -0.10292514f, 0.02356613f, -0.07198530f, 0.04814290f, 
    -0.11176972f, 0.20070216f, -0.00999420f, -0.11464025f, 0.09489158f, 0.10746820f, 0.01996540f, 0.02854016f, 
    -0.00438971f, 0.09223600f, -0.13769293f, -0.13829471f, 0.35745007f, -0.13425569f, 0.02789560f, -0.00694259f, 
    -0.04054861f, 0.00007712f, 0.04868129f, 0.10929148f, 0.10889065f, -0.02107484f, -0.05201119f, 0.07137170f, 
    0.04554038f, -0.05972188f, 0.05325951f, 0.03304010f, 0.07449666f, 0.06237230f, 0.02201787f, -0.00766333f, 
    -0.01266732f, -0.01170886f, 0.14345810f, -0.06172213f, 0.15877604f, 0.04136354f, 0.15898150f, -0.07408775f, 
    -0.00359424f, -0.09260532f, -0.01838249f, -0.02546707f, 0.18080883f, 0.01443815f, 0.09547640f, 0.17318305f, 
    -0.05724829f, -0.09925646f, 0.04907893f, -0.15832973f, 0.04176088f, 0.01971862f, 0.11348581f, 0.11740705f, 
    -0.00711865f, -0.09261802f, 0.12896039f, -0.06965285f, -0.10712884f, 0.07793321f, -0.24877043f, 0.22385025f, 
    -0.09136833f, 0.14040865f, -0.02099386f, 0.01774162f, -0.05574149f, 0.05528699f, 0.11557617f, 0.01200454f, 
    0.22657040f, -0.23090427f, 0.06102179f, -0.08423124f, -0.02269350f, 0.00328559f, 0.12731653f, -0.02992128f, 
    -0.04536200f, 0.21839571f, 0.09035900f, 0.24578659f, 0.22216794f, 0.10059965f, -0.06610797f, 0.12278926f, 
    -0.12855817f, 0.08591610f, -0.01616668f, 0.06456775f, 0.03286964f, 0.05195431f, 0.07881498f, 0.14143813f, 
    0.04343301f, -0.41270146f, 0.04288363f, 0.01299654f, 0.08225814f, -0.01874537f, 0.08071156f, 0.17894842f, 
    -0.07657980f, 0.15752126f, 0.10432569f, 0.19422501f, -0.16983086f, 0.16220559f, 0.02096438f, 0.04301202f, 
    -0.08307606f, 0.08452583f, -0.07725950f, 0.05041962f, 0.04261220f, -0.12047707f, 0.24189463f, -0.17769358f, 
    -0.04051658f, 0.12477665f, -0.20920987f, -0.11741310f, -0.03727402f, -0.00556155f, 0.14095677f, -0.23109646f, 
    -0.08725641f, 0.11893314f, -0.13433081f, 0.06010257f, -0.26635504f, 0.18652405f, -0.01549226f, 0.11251775f, 
    0.00481327f, 0.04968318f, 0.13816543f, 0.03474149f, 0.01113637f, 0.07999060f, 0.16533537f, -0.12857260f, 
    0.37373948f, -0.12716340f, 0.16318874f, -0.24533734f, 0.19738060f, -0.10391488f, 0.01755663f, 0.16729313f, 
    -0.00180496f, 0.06127369f, 0.15334383f, 0.19714804f, -0.38209808f, -0.01341469f, 0.17421576f, 0.20286515f, 
    -0.07335566f, 0.09966832f, -0.01247914f, 0.14154938f, 0.08553102f, -0.12446646f, -0.09513742f, -0.12583449f, 
    0.05979693f, -0.00574569f, -0.10071635f, -0.04069633f, -0.10604878f, -0.10633083f, -0.00081570f, 0.14302363f, 
    0.05601211f, -0.03366008f, 0.13464591f, 0.04929374f, 0.01253339f, 0.00601612f, 0.08329540f, -0.10587675f, 
    0.10674306f, -0.13992366f, 0.04162875f, -0.04671158f, -0.12065285f, 0.13294415f, 0.01802503f, 0.00086920f, 
    -0.30608568f, 0.03364518f, 0.07507121f, -0.10913257f, -0.02540711f, 0.06433138f, 0.05955330f, -0.04750945f, 
    0.02352845f, -0.12304713f, 0.10078051f, -0.05256464f, -0.56214267f, 0.22538084f, 0.19450584f, 0.31508583f, 
    0.28956923f, -0.08315698f, -0.01864195f, -0.03780779f, 0.07392496f, 0.10032337f, -0.01252308f, -0.05647194f, 
    0.02429994f, -0.29947126f, 0.26750121f, -0.11522590f, -0.06235460f, -0.04262747f, -0.00321526f, -0.06003673f, 
    0.03804240f, 0.01447293f, 0.02341657f, 0.03557176f, -0.52066272f, -0.00758474f, 0.23666288f, 0.01581999f, 
    0.03791868f, 0.07754171f, -0.03591552f, 0.06214092f, 0.13349661f, -0.06847113f, 0.00379930f, 0.04662033f, 
    0.02646301f, -0.13209777f, 0.14665672f, 0.01407733f, 0.03185891f, -0.12286744f, 0.00304062f, -0.15501587f, 
    0.10940763f, 0.00167704f, -0.00640280f, 0.14190440f, 0.09696814f, -0.00817793f, 0.11476860f, 0.01231164f, 
    0.03250752f, 0.24836966f, 0.13581184f, 0.30145937f, -0.00342759f, 0.09430487f, 0.03916611f, -0.12340138f, 
    -0.13884994f, 0.32063672f, -0.12118159f, -0.02177323f, 0.26901627f, 0.12206358f, 0.00225770f, 0.05766231f, 
    -0.05996789f, -0.11384525f, -0.06178561f, -0.03257623f, 0.24609125f, -0.07868574f, -0.17087026f, 0.16026233f, 
    -0.03929153f, -0.00741966f, 0.01182870f, -0.03520346f, 0.15259960f, 0.12538806f, -0.07545623f, 0.08383169f, 
    -0.31454891f, -0.19646533f, 0.17103557f, -0.16878814f, 0.09958555f, -0.02773689f, -0.09274675f, -0.01404492f, 
    -0.11152563f, -0.13476066f, 0.01705349f, -0.09807281f, -0.00286985f, -0.21629860f, 0.12877764f, 0.03426514f, 
    0.02137763f, 0.07134292f, -0.08179480f, 0.20082676f, -0.09638107f, 0.11872263f, -0.00693108f, 0.04712634f, 
    0.21859385f, -0.00548403f, 0.04616154f, 0.02066947f, 0.04187043f, -0.11923866f, 0.00569011f, -0.01981525f, 
    -0.10589554f, 0.04779999f, -0.09736360f, 0.03599534f, -0.21569234f, 0.16403168f, -0.01727622f, -0.09151287f, 
    -0.04083237f, 0.08153614f, 0.06500091f, -0.03212865f, 0.08393192f, 0.09755976f, 0.14166895f, -0.04308978f, 
    -0.00445359f, -0.15755521f, -0.00996448f, -0.16544273f, -0.15044175f, 0.01121819f, 0.06959401f, 0.06327882f, 
    -0.03712941f, 0.01803758f, -0.13647531f, 0.01688164f, 0.41855943f, 0.07166413f, -0.02282228f, 0.02056071f, 
    -0.06773738f, -0.06796078f, -0.06285844f, -0.02661330f, -0.01079957f, 0.01932021f, 0.03445649f, 0.07492173f, 
    0.12583894f, -0.12720375f, 0.10244551f, 0.52248406f, 0.10178141f, 0.19922936f, 0.02018198f, 0.26685137f, 
    -0.17773284f, 0.04748029f, 0.15842775f, 0.10233976f, 0.02099599f, 0.03212884f, 0.07664831f, 0.26128426f, 
    0.09497191f, -0.08442464f, 0.16118275f, -0.02314553f, 0.06777307f, -0.00584956f, 0.05528545f, 0.07363475f, 
    -0.49379438f, 0.00254374f, 0.21980645f, 0.02570874f, -0.17742865f, -0.01161045f, -0.12236024f, -0.07543189f, 
    -0.08491157f, 0.06934312f, 0.01286402f, 0.01630512f, 0.11251797f, -0.17707483f, -0.01785905f, -0.02938934f, 
    0.04396338f, 0.04948007f, -0.09460913f, 0.03744296f, -0.05699686f, 0.07739931f, -0.05233782f, -0.02559039f, 
    -0.09412584f, 0.19502521f, 0.19442257f, 0.11528103f, -0.17257752f, 0.02258809f, -0.05839397f, 0.02226030f, 
    0.05408465f, 0.07534747f, 0.01543284f, -0.07898080f, 0.14802992f, 0.02087890f, 0.10571924f, -0.03204481f, 
    0.29207373f, 0.08816164f, 0.01490906f, 0.10589235f, 0.04399308f, -0.11282576f, 0.10837325f, 0.09654111f, 
    0.32279482f, 0.17772610f, -0.17223178f, -0.14063315f, 0.15336987f, -0.06619364f, -0.12332292f, -0.01003842f, 
    0.02392752f, -0.08136672f, -0.03541011f, 0.10077844f, -0.22556619f, 0.01333205f, -0.02876247f, 0.33306742f, 
    -0.09204519f, -0.01690647f, 0.08603469f, 0.11983050f, 0.03442747f, 0.01846764f, 0.03779740f, -0.07009894f, 
    0.15656851f, 0.11625233f, 0.11529738f, 0.09599604f, 0.17920794f, 0.04639363f, 0.06451633f, -0.07106572f, 
    -0.12628740f, 0.07413232f, 0.05875444f, 0.01215816f, 0.00395190f, 0.24361137f, -0.03547200f, 0.25726345f, 
    0.08379418f, 0.06343471f, -0.01701594f, 0.10759645f, 0.00587491f, 0.02915684f, -0.00009406f, 0.01015083f, 
    0.11298306f, 0.09903383f, -0.18399176f, -0.00821397f, 0.04598897f, 0.03648273f, -0.06566291f, 0.08936707f, 
    -0.04719809f, -0.14830722f, 0.03780142f, -0.02775634f, -0.29260388f, -0.03229191f, -0.01824378f, 0.20247401f, 
    -0.13457359f, 0.12135632f, 0.06642868f, -0.24201970f, -0.07111964f, 0.02172254f, 0.09510932f, 0.00931122f, 
    -0.01323331f, -0.04066928f, -0.16867648f, 0.12257954f, -0.12052112f, -0.04218328f, -0.00869212f, 0.05537908f, 
    0.06535557f, -0.09055794f, -0.03252401f, -0.01547243f, 0.20512201f, -0.33568728f, 0.08284735f, -0.14937854f, 
    -0.05238176f, -0.06759404f, -0.04989338f, 0.01952670f, 0.00343838f, 0.02991451f, -0.03531385f, 0.09031989f, 
    0.07718102f, 0.35966209f, 0.11569232f, -0.19222566f, -0.06660239f, 0.04035531f, -0.06069465f, -0.00755565f, 
    -0.06642762f, -0.00835021f, 0.06737632f, 0.09962222f, -0.35654095f, 0.02616632f, 0.16435350f, -0.18470697f, 
    -0.04413206f, 0.18724242f, 0.09201156f, -0.09112258f, -0.09283206f, -0.09679915f, 0.07723529f, -0.07948040f, 
    -0.25387678f, 0.18935747f, -0.04116949f, 0.45717978f, 0.00711615f, 0.08444263f, 0.16143325f, 0.11698549f, 
    0.06766185f, -0.17185290f, 0.03091080f, -0.00087260f, 0.04265180f, 0.09221315f, 0.04612466f, -0.03660311f, 
    0.06619950f, 0.11625034f, 0.01999515f, -0.00881898f, -0.05507098f, -0.04125081f, 0.11201254f, -0.02692280f, 
    0.02856284f, 0.00391045f, 0.05858030f, 0.03905194f, -0.04530927f, -0.02331226f, -0.14202423f, 0.05242260f, 
    -0.04014176f, -0.08915684f, 0.02279503f, 0.00582110f, 0.45795760f, 0.01101038f, 0.16866480f, -0.04386760f, 
    0.01515923f, -0.06723537f, -0.02555754f, 0.09672254f, 0.08842685f, 0.02296603f, -0.00441974f, 0.02398469f, 
    0.02490328f, 0.11973243f, -0.10142279f, 0.06332877f, -0.03467111f, -0.04217989f, 0.06446800f, -0.05836266f, 
    0.08280414f, -0.01167975f, 0.03905224f, 0.00348261f, 0.22753026f, 0.11663061f, -0.03309815f, 0.04073761f, 
    -0.02304518f, 0.02926623f, 0.04062713f, 0.00235605f, -0.00433177f, 0.13111268f, 0.12573317f, 0.09259439f, 
    0.18686008f, 0.05885179f, -0.26988932f, -0.32503399f, -0.11069364f, 0.14149731f, -0.03973665f, 0.10129897f, 
    0.08528876f, 0.00677387f, 0.22980952f, 0.01530404f, 0.17270035f, 0.11279385f, -0.06392685f, 0.11696452f, 
    0.01731336f, -0.04294740f, 0.01494427f, 0.00352071f, 0.07504223f, 0.08337053f, -0.01194328f, -0.16772182f, 
    0.04793316f, -0.12849888f, -0.10053457f, 0.00110134f, -0.16015711f, 0.08017711f, -0.11411641f, -0.11912992f, 
    0.18514085f, 0.10418833f, 0.04819599f, -0.01627863f, 0.17032595f, 0.09223101f, -0.03663417f, 0.12738037f, 
    0.10427479f, 0.06957549f, 0.11934761f, 0.03235972f, 0.12816037f, 0.07271501f, -0.08272935f, 0.09174264f, 
    0.15622613f, 0.08681350f, -0.13444476f, -0.04078666f, -0.01200286f, -0.10907482f, 0.05280671f, -0.01060459f, 
    0.05634985f, 0.08836123f, -0.03123452f, -0.13891357f, 0.26573685f, 0.03573219f, 0.02845351f, 0.00199573f, 
    0.07503055f, 0.03647683f, 0.03974057f, 0.00883759f, -0.02453833f, 0.11569626f, 0.10844965f, 0.18704401f, 
    0.05606729f, -0.01396262f, 0.16833538f, -0.06165871f, 0.04930771f, 0.02565677f, 0.05668461f, 0.17504941f, 
    0.05196309f, -0.13256678f, 0.03679752f, -0.12156240f, -0.06615395f, -0.16209981f, 0.11964590f, -0.18410452f, 
    0.16023722f, -0.08090217f, 0.13867153f, 0.07609069f, -0.06898265f, 0.11989273f, 0.10373154f, 0.03580806f, 
    0.01470942f, 0.09370241f, -0.16081308f, 0.24165067f, 0.00779998f, 0.09158498f, -0.02338813f, 0.08697470f, 
    -0.03345677f, 0.06169766f, 0.03652487f, 0.23987435f, 0.19083567f, 0.14818045f, -0.07350978f, -0.04855278f, 
    0.08141270f, 0.11982122f, -0.02452906f, -0.03076858f, 0.01052633f, 0.01957956f, 0.04877288f, 0.09561443f, 
    -0.01493525f, 0.18852553f, -0.00961269f, -0.13071832f, 0.10262455f, 0.05500788f, -0.16479771f, -0.04519327f, 
    0.31375143f, 0.00300707f, 0.00092608f, 0.01139481f, 0.25539255f, 0.10815643f, 0.01810751f, 0.02848433f, 
    0.04287269f, 0.05728088f, -0.07332589f, 0.10847186f, 0.06517242f, 0.10425933f, 0.21014847f, -0.06194422f, 
    0.07584753f, 0.05105729f, -0.15122823f, -0.12776865f, 0.10643379f, 0.02067698f, -0.05748716f, -0.02199461f, 
    0.06108778f, 0.01487982f, 0.03860867f, -0.05012039f, 0.55952436f, -0.00166445f, -0.12125617f, 0.08512794f, 
    -0.00168673f, 0.10142375f, 0.00406462f, -0.02384360f, 0.01621316f, 0.07994352f, 0.04100332f, -0.23274069f, 
    0.42082396f, -0.06364287f, -0.02136237f, 0.02231205f, 0.13559781f, 0.03226351f, 0.08593735f, 0.02858790f, 
    0.05381273f, 0.06250592f, 0.01925388f, 0.13754632f, -0.14455245f, 0.15794384f, -0.13077807f, 0.20456544f, 
    -0.02303711f, 0.10555913f, -0.07505257f, -0.07033554f, -0.08089282f, -0.05163344f, -0.08599027f, 0.04097364f, 
    -0.08438607f, -0.18902095f, 0.02556520f, 0.21235266f, -0.01529102f, 0.04501311f, 0.02470285f, 0.11373200f, 
    0.02711454f, 0.16768175f, -0.14920267f, 0.15882008f, 0.10101066f, -0.00699752f, 0.29176679f, 0.01448774f, 
    0.09342681f, -0.03388972f, 0.05851268f, -0.04217054f, 0.02632700f, 0.03422152f, 0.11582924f, 0.11394150f, 
    -0.00835006f, 0.03193443f, -0.04410996f, 0.24204400f, 0.01965315f, -0.01417517f, 0.02320200f, 0.01718924f, 
    0.07749802f, -0.16357879f, -0.11447119f, -0.10140458f, -0.11488470f, -0.14308456f, 0.13270549f, -0.03935509f, 
    0.14847364f, 0.03529802f, 0.10401953f, -0.04264566f, -0.08206191f, 0.10089542f, -0.06533366f, 0.02415540f, 
    0.28397366f, 0.10432900f, 0.02714608f, 0.10088534f, 0.05721823f, 0.10918267f, -0.05248980f, -0.02593998f, 
    0.09075154f, -0.08481804f, -0.03802357f, -0.02668374f, -0.29367858f, -0.15887713f, -0.06794139f, -0.06371316f, 
    0.23951438f, 0.02630794f, 0.10934713f, 0.05345980f, -0.00707059f, 0.14616176f, -0.14573090f, 0.19208622f, 
    -0.07271034f, 0.02565628f, 0.07175818f, -0.06295409f, 0.10546463f, 0.02459960f, -0.01070458f, 0.09211824f, 
    -0.01133249f, 0.18882214f, 0.20901223f, -0.02657204f, 0.12126525f, 0.16849987f, 0.16626289f, 0.04044640f, 
    0.02446960f, -0.02948999f, 0.02056805f, -0.00478381f, 0.00559043f, -0.04402988f, 0.02661468f, 0.07046819f, 
    -0.30202726f, -0.02412977f, -0.12647413f, 0.23058188f, -0.05716286f, 0.09970974f, -0.02400796f, -0.07686008f, 
    0.03278099f, 0.02499792f, -0.19008096f, -0.10464951f, 0.27626073f, -0.06890263f, 0.10123781f, -0.22096299f, 
    0.08662403f, -0.22369325f, 0.06270332f, -0.14629579f, -0.11965691f, 0.12413114f, -0.05564665f, 0.09537499f, 
    0.23786020f, 0.12057411f, 0.24242172f, 0.00693593f, 0.09922163f, 0.03507106f, 0.01403267f, 0.14195612f, 
    -0.06099398f, 0.07667316f, -0.05993830f, -0.07415676f, -0.04425823f, -0.08565535f, -0.06337566f, 0.09213297f, 
    -0.11836062f, 0.17061213f, 0.02247350f, -0.01621384f, 0.12378041f, -0.04138434f, -0.05405755f, 0.26569206f, 
    0.20565818f, -0.01829585f, 0.28137493f, -0.18250300f, 0.10635293f, 0.12898852f, -0.14709257f, 0.12404303f, 
    0.05613176f, -0.04645082f, 0.11783727f, 0.15396006f, 0.06926874f, -0.24471799f, -0.09394509f, 0.05777076f, 
    -0.04302585f, -0.09136239f, -0.02035344f, 0.04885750f, 0.07039300f, -0.10382797f, -0.04967416f, -0.02056205f, 
    0.33499432f, -0.01085550f, 0.08519179f, 0.19613147f, -0.03367831f, -0.11464996f, 0.02584606f, 0.04957162f, 
    0.06612906f, 0.15835044f, -0.05465078f, 0.14365177f, 0.31812778f, 0.13979439f, 0.20979825f, -0.14120542f, 
    0.15275332f, 0.02503350f, -0.04287912f, -0.00106584f, 0.10905286f, 0.10425450f, 0.14664337f, 0.12442112f, 
    0.10504320f, 0.19881147f, -0.22399725f, 0.16477954f, -0.05297930f, 0.03072239f, -0.00601695f, 0.13410054f, 
    0.07020825f, 0.00052983f, 0.17811970f, 0.20937034f, -0.03221946f, -0.02750471f, -0.13755405f, -0.06333798f, 
    0.01553424f, 0.01362216f, 0.05157235f, 0.11942749f, -0.07189993f, 0.12590678f, 0.07944925f, -0.13293226f, 
    0.00216960f, -0.06691083f, 0.23405604f, -0.40094069f, 0.09568998f, 0.01768761f, -0.08874207f, -0.00706377f, 
    0.05856189f, 0.06703063f, 0.20313726f, 0.14639795f, 0.04514549f, 0.12059284f, -0.14198843f, -0.08759213f, 
    0.18432625f, 0.04822012f, 0.02164850f, 0.18491496f, 0.01441966f, 0.12685567f, 0.00901556f, 0.12510906f, 
    -0.09287676f, 0.14426655f, -0.11852206f, 0.03156611f, 0.08864754f, 0.03338333f, -0.02140818f, -0.16045868f, 
    0.08537178f, -0.02064760f, 0.09565596f, 0.14285615f, -0.04786446f, 0.04570709f, -0.09848467f, -0.15834402f, 
    0.22611108f, 0.09675921f, 0.20344454f, 0.08837236f, 0.09989869f, 0.10457218f, 0.13123845f, 0.12693724f, 
    0.21320394f, -0.14261922f, 0.22935174f, -0.10034741f, 0.06069421f, 0.03469037f, -0.05650217f, 0.09283878f, 
    0.16421969f, 0.09668703f, 0.03225543f, 0.05075440f, 0.06911338f, 0.19005461f, 0.00196998f, 0.00975612f, 
    0.11037006f, 0.07237207f, 0.00266672f, -0.05721326f, -0.01542669f, 0.09767439f, 0.12847328f, 0.15088813f, 
    -0.12394846f, 0.13178609f, 0.08518509f, -0.24930899f, 0.03897755f, -0.03384572f, 0.05054020f, 0.11867335f, 
    0.01367133f, 0.17282341f, -0.07826912f, 0.29466206f, -0.05407169f, 0.07985532f, -0.24845497f, -0.30354062f, 
    0.04811225f, 0.17428669f, 0.11418217f, 0.05128635f, 0.08804467f, 0.06934061f, 0.14767821f, 0.08497860f, 
    0.00882346f, 0.19598612f, -0.15255706f, 0.32371929f, -0.07102243f, 0.09429337f, -0.04205732f, 0.00183203f, 
    0.19207837f, -0.16798985f, -0.02611345f, -0.15405600f, -0.25715128f, -0.14116305f, -0.08991129f, 0.18601018f, 
    -0.09616549f, -0.01927534f, 0.16967975f, 0.04736707f, -0.14950921f, 0.14165194f, 0.12747933f, -0.16574453f, 
    0.25717047f, 0.02984937f, 0.07727958f, -0.04668431f, 0.11814479f, 0.08124596f, -0.00896842f, 0.08848541f, 
    0.06271095f, 0.02363085f, 0.22238418f, 0.21064802f, -0.22778645f, -0.00173682f, -0.19971220f, -0.06933357f, 
    0.22005101f, 0.15975983f, 0.25725174f, 0.09099585f, -0.01777362f, 0.07284523f, 0.15999556f, -0.01604994f, 
    -0.13967656f, 0.06502759f, -0.06085393f, 0.20140524f, 0.20721099f, 0.14505774f, -0.01969455f, 0.12432203f, 
    0.11279506f, 0.03177102f, 0.04701133f, 0.06958114f, -0.06794980f, 0.01304077f, -0.09150795f, 0.02755740f, 
    0.11799567f, 0.21959738f, 0.04052435f, -0.00578239f, -0.03869258f, -0.05473519f, 0.06662176f, 0.00031853f, 
    -0.30796164f, -0.09300627f, 0.03202154f, 0.00183880f, 0.13103332f, -0.07268041f, 0.03407769f, 0.15848848f, 
    0.12284903f, 0.00633153f, -0.07024800f, 0.12291206f, -0.06780692f, 0.18945640f, 0.01183995f, 0.21357141f, 
    0.14442089f, -0.12912847f, 0.10779963f, 0.07559229f, 0.21760806f, 0.14187305f, 0.02269500f, 0.12857777f, 
    -0.11107276f, -0.13523944f, -0.25097448f, -0.25600708f, -0.09387267f, 0.19363898f, -0.28290480f, 0.02811879f, 
    0.02608741f, -0.01956459f, 0.00525227f, -0.07009344f, -0.00260632f, -0.05732926f, -0.03956341f, 0.30284581f, 
    0.00846201f, 0.05980394f, 0.09296972f, -0.02604356f, 0.12927566f, 0.09380312f, -0.05093806f, 0.16631712f, 
    -0.08416838f, -0.07625460f, -0.13575009f, -0.17183027f, 0.00029939f, -0.12566893f, 0.18734065f, 0.13830554f, 
    0.11745932f, -0.01719683f, 0.02806357f, -0.03547708f, -0.33442143f, 0.04957072f, 0.06700367f, 0.09162758f, 
    0.25968257f, 0.00428713f, 0.02221843f, -0.10757300f, 0.20588635f, 0.10217788f, -0.10837249f, 0.21011575f, 
    0.20217304f, 0.00702854f, -0.11361480f, 0.07516331f, 0.20019405f, -0.01269378f, 0.00957104f, 0.11807261f, 
    0.13002646f, 0.11193623f, 0.34041324f, 0.00543163f, -0.06296711f, 0.17129838f, 0.19510035f, 0.20714088f, 
    -0.00339396f, 0.09478737f, 0.07339074f, 0.11941667f, 0.01570790f, 0.04538013f, 0.15067369f, 0.04911671f, 
    -0.28475729f, 0.15658982f, 0.15154688f, -0.17966941f, 0.15558165f, 0.09403414f, -0.09031766f, -0.04283693f, 
    -0.06308778f, 0.06036070f, -0.06197378f, -0.03592580f, 0.40922162f, -0.05805325f, -0.04694173f, 0.11290699f, 
    0.27235696f, -0.14253820f, -0.07588336f, -0.26859120f, 0.19279668f, -0.02196453f, 0.09544446f, 0.15783031f, 
    -0.19903816f, -0.26562822f, -0.02157461f, -0.04904547f, 0.06019281f, -0.01084940f, 0.18824421f, 0.02437367f, 
    -0.03725881f, 0.13787013f, -0.05533545f, -0.02425382f, 0.28367004f, 0.05986311f, 0.18884628f, 0.01988743f, 
    0.05617846f, 0.29874411f, 0.04052353f, 0.07553688f, 0.12080032f, 0.12944399f, 0.06792204f, 0.20561561f, 
    0.00033558f, -0.05003997f, -0.00718112f, -0.01513797f, -0.00694090f, -0.04392420f, -0.03657167f, -0.03892158f, 
    0.00765034f, 0.01434208f, -0.00952078f, 0.02949784f, -0.00828444f, -0.01869371f, 0.02887317f, -0.04510890f, 
    0.00265812f, -0.00901816f, -0.04286931f, -0.00604926f, 0.02584039f, -0.04808362f, -0.04107765f, -0.04229781f, 
    0.00484428f, -0.02421568f, -0.01841694f, -0.03747956f, 0.01943621f, 0.01515805f, 0.02472909f, 0.02454918f, 
    0.02633848f, 0.01567912f, -0.00003985f, -0.03044259f, -0.01227997f, -0.00481936f, 0.01429941f, 0.02832454f, 
    0.03412401f, -0.01201016f, 0.00004405f, 0.02603675f, 0.00423640f, -0.05240015f, -0.04238104f, -0.02140693f, 
    0.00683911f, 0.03087505f, 0.02691162f, -0.05556507f, 0.02810988f, 0.00315882f, 0.00082257f, 0.01418893f, 
    -0.00992285f, -0.01914411f, -0.00064464f, -0.03576186f, -0.03367740f, -0.04524380f, -0.03703445f, -0.04257017f, 
    -0.04512576f, 0.02881415f, 0.04041512f, 0.00913810f, 0.01992177f, 0.00472925f, -0.05043153f, -0.04176110f, 
    -0.01661905f, 0.01006282f, -0.00844100f, 0.02296392f, -0.04085865f, 0.02795272f, -0.01359459f, -0.05687213f, 
    0.00326208f, 0.00464482f, -0.05659090f, -0.04063705f, -0.03736681f, 0.00051878f, -0.01642230f, 0.03468052f, 
    0.00669696f, -0.00566257f, 0.04080751f, 0.02497514f, -0.04931930f, 0.01745175f, -0.02069099f, 0.02255813f, 
    -0.05409113f, 0.03153060f, -0.02560901f, -0.03550226f, -0.03620691f, -0.02557983f, -0.00972173f, 0.03773604f, 
    0.01679388f, -0.01263409f, -0.00453944f, -0.00151760f, -0.05709564f, -0.00587920f, 0.02491336f, 0.02557286f, 
    -0.05374396f, -0.01526089f, 0.03004071f, -0.03178519f, 0.01877772f, -0.00929575f, -0.00561612f, 0.02963624f, 
    0.01776686f, -0.05566209f, -0.05192669f, -0.01876660f, -0.04709635f, 0.01693907f, -0.03414114f, -0.03642637f, 
    -0.01194173f, -0.04086808f, -0.02987099f, 0.03259180f, -0.00492347f, 0.02828818f, 0.02646353f, 0.04213822f, 
    -0.05353163f, -0.04581253f, -0.04806782f, -0.05167004f, 0.02959753f, -0.03291440f, 0.01892347f, -0.03253607f, 
    0.01826059f, 0.00033375f, 0.01065899f, -0.03750880f, -0.01328379f, -0.01256676f, -0.00190099f, 0.00277555f, 
    -0.03669067f, -0.04668942f, -0.00177646f, 0.01237846f, 0.01154171f, -0.02702971f, 0.02171510f, -0.03876016f, 
    -0.00545381f, 0.03148488f, -0.01076275f, -0.02870943f, 0.00932293f, 0.03466063f, -0.05178039f, -0.03403740f, 
    0.04018360f, -0.02702419f, 0.00352745f, 0.02016794f, 0.00229155f, 0.01954439f, 0.00370716f, -0.02506420f, 
    -0.03869959f, -0.01796039f, -0.02225236f, -0.00122546f, -0.04665045f, -0.02369249f, -0.01873612f, -0.00887813f, 
    -0.01158862f, -0.03949349f, -0.02851616f, -0.01397906f, 0.00024499f, -0.01748056f, -0.00034793f, -0.03692757f, 
    -0.01718446f, -0.00994694f, -0.04118110f, 0.02138988f, -0.04081051f, -0.03430962f, -0.00455489f, -0.01338695f, 
    0.01394358f, -0.04089363f, -0.03973191f, 0.03741583f, 0.03556891f, -0.05024625f, 0.02849905f, -0.01264924f, 
    -0.03375757f, -0.05361990f, 0.00658737f, -0.00380220f, -0.01881645f, -0.04531365f, -0.05442327f, -0.00126896f, 
    0.00335394f, -0.03794798f, -0.04985095f, -0.01060987f, -0.02302011f, -0.00645533f, 0.04183720f, 0.02306374f, 
    -0.05782998f, -0.00208417f, 0.03487566f, 0.00614662f, -0.04219913f, -0.00101034f, -0.02240648f, -0.00120053f, 
    0.03964335f, -0.04961825f, -0.01995146f, 0.04216684f, 0.03244073f, -0.05272286f, 0.04746311f, 0.01220634f, 
    -0.01957089f, -0.05128152f, 0.04105847f, -0.05747279f, -0.02508724f, -0.02193624f, -0.01722224f, 0.01911871f, 
    0.04061478f, 0.00179273f, 0.01652141f, -0.00225230f, 0.04295665f, -0.01562481f, 0.00868073f, -0.02853725f, 
    -0.02137820f, -0.04657449f, 0.00127251f, 0.01070230f, -0.01664482f, 0.03800995f, -0.04422686f, -0.01055964f, 
    -0.00632084f, -0.04832317f, 0.01222157f, -0.00148269f, -0.01439573f, 0.04144431f, 0.02860122f, -0.02781283f, 
    -0.02650427f, 0.00312643f, 0.00105642f, -0.04925421f, 0.01030042f, 0.00065723f, -0.02742843f, 0.02831892f, 
    -0.01490943f, -0.01360577f, -0.00070614f, 0.02427941f, -0.01175849f, 0.03779481f, 0.03715108f, 0.04144285f, 
    -0.05888692f, 0.01275333f, 0.02152963f, 0.03458665f, 0.03779588f, -0.01676583f, 0.02580532f, 0.03966889f, 
    -0.01448166f, -0.03813067f, 0.02350957f, 0.00840286f, -0.04690278f, -0.00151792f, -0.04628011f, -0.03242964f, 
    -0.03721578f, 0.02402712f, -0.01887427f, -0.05511781f, -0.04670841f, -0.05654797f, 0.02942435f, -0.05373766f, 
    -0.05722751f, -0.05789451f, 0.03240244f, 0.02614170f, 0.01087938f, 0.03593643f, 0.02564357f, 0.00709456f, 
    0.01754759f, -0.01579008f, -0.02543168f, 0.01742869f, -0.00503931f, 0.02051040f, 0.03250588f, -0.05084681f, 
    0.04187410f, 0.01472077f, -0.05735920f, -0.00835163f, -0.02970653f, -0.05660377f, -0.01772480f, -0.00741607f, 
    0.02726852f, -0.03562161f, 0.01116849f, 0.02281096f, -0.05580899f, -0.00332450f, -0.02384903f, -0.00843152f, 
    0.02820704f, -0.02501993f, -0.03378517f, -0.03439173f, -0.00772954f, 0.00514047f, -0.04004355f, 0.03712418f, 
    -0.00895033f, 0.02981156f, -0.01333838f, 0.01715610f, 0.04536419f, 0.01977617f, -0.04099027f, 0.01578839f, 
    0.04611832f, -0.02721146f, -0.03124694f, -0.05250792f, 0.01838523f, -0.02644930f, 0.02670933f, -0.05315177f, 
    -0.04510994f, -0.05171380f, 0.00772348f, 0.02543311f, 0.04012258f, 0.04339176f, 0.00646157f, 0.01128126f, 
    0.01980140f, 0.03417438f, 0.00411988f, -0.03494509f, -0.00142936f, -0.05558380f, 0.03299387f, 0.01853200f, 
    0.20943119f, 0.01728862f, -0.03674761f, 0.37948769f, -0.00387017f, 0.01636230f, -0.03378746f, -0.00210874f, 
    0.04821514f, -0.04371386f, 0.10359284f, 0.07037900f, -0.07804576f, -0.07184640f, -0.10009594f, -0.23283289f, 
    0.04578058f, -0.04477726f, 0.11156650f, 0.07187883f, -0.00998369f, -0.00490109f, -0.02321372f, 0.06877488f, 
    -0.35947570f, 0.17276229f, -0.04923599f, -0.25532517f, 0.00356146f, 0.05202796f, 0.20339432f, -0.03503160f, 
    0.02690560f, 0.19768904f, 0.10363591f, -0.03294144f, 0.09378603f, -0.00307979f, 0.31079376f, 0.34817034f, 
    -0.07855772f, 0.06860150f, -0.03170225f, 0.03976364f, -0.03441599f, 0.13115580f, -0.02248159f, -0.02349706f, 
    -0.34872112f, 0.33465010f, 0.09192878f, -0.06782057f, -0.06138870f, -0.06588154f, -0.00002752f, -0.01796911f, 
    -0.01102226f, 0.10338777f, -0.02740007f, 0.00847435f, -0.21620318f, -0.11744913f, -0.06626394f, -0.10869107f, 
    0.06953337f, -0.00846124f, 0.05181473f, 0.06956062f, 0.01846112f, 0.01963422f, -0.01834571f, -0.03590595f, 
    0.14060138f, 0.07714120f, 0.18575998f, 0.32935193f, -0.01696901f, -0.02115078f, 0.04812428f, 0.02230444f, 
    -0.01024977f, 0.05263579f, -0.13045359f, 0.00485759f, 0.26672181f, 0.08918967f, 0.22105899f, 0.23831683f, 
    -0.13722026f, -0.00452897f, 0.06438024f, 0.09099468f, 0.13205042f, 0.11912905f, 0.13060895f, 0.08506272f, 
    0.29522151f, 0.22403300f, 0.38452107f, 0.19124946f, -0.04331483f, -0.01645005f, 0.04316816f, 0.14687237f, 
    0.07398167f, 0.04348181f, 0.03367748f, 0.09551243f, -0.21197526f, -0.08436546f, -0.19296253f, 0.14164393f, 
    -0.01011760f, -0.02674422f, -0.04355912f, 0.06746405f, 0.01950142f, -0.09618398f, -0.06368671f, 0.00762096f, 
    -0.20571242f, -0.00758239f, -0.10362904f, 0.00639253f, 0.07474058f, 0.04963859f, 0.06508512f, 0.03058415f, 
    0.03059679f, 0.02677424f, 0.07350074f, 0.02610374f, -0.06055684f, -0.13272515f, 0.01488415f, 0.08303993f, 
    -0.00213076f, 0.14086045f, 0.03233574f, -0.07841814f, 0.13449913f, -0.07089938f, -0.09843008f, 0.20635466f, 
    -0.30060825f, 0.02238513f, -0.03871302f, -0.03221867f, 0.20752279f, 0.04215651f, -0.16526474f, -0.00292019f, 
    0.08089007f, -0.03211560f, 0.07040992f, 0.09550921f, -0.09068128f, 0.31409669f, 0.13159105f, 0.10684822f, 
    -0.02411497f, 0.06010500f, -0.04728669f, 0.10241931f, 0.07124858f, 0.11522774f, 0.01480525f, -0.04022013f, 
    -0.14540726f, -0.10484245f, -0.00255196f, -0.29473308f, 0.03913732f, 0.06725300f, 0.07271757f, -0.02968946f, 
    0.10704982f, 0.00057119f, -0.05625747f, -0.02422050f, -0.05627998f, 0.15076487f, -0.05264553f, -0.26030436f, 
    0.00729907f, 0.09159579f, 0.16966866f, -0.00144780f, 0.10090757f, 0.07388731f, 0.00153212f, 0.03287834f, 
    0.24261856f, 0.06387303f, 0.26773503f, 0.20562458f, -0.03945930f, 0.05180161f, 0.01478633f, 0.04656737f, 
    0.04568478f, -0.03294495f, 0.06201937f, 0.16302787f, -0.34467047f, 0.09712889f, 0.05631505f, -0.05976617f, 
    0.16659768f, -0.06275327f, -0.05038805f, 0.09817506f, -0.06405835f, 0.03518616f, 0.06151288f, 0.14043695f, 
    -0.09530714f, -0.08029833f, 0.09165560f, -0.04017018f, -0.00536496f, -0.02927526f, 0.02810750f, 0.02915483f, 
    0.09013493f, 0.07282937f, 0.02210484f, -0.03886651f, -0.11971556f, 0.01260021f, -0.07400157f, -0.00840363f, 
    -0.14368980f, 0.06957665f, -0.01381559f, 0.16924775f, -0.00397423f, 0.07088199f, -0.05624655f, -0.03375022f, 
    0.25778559f, 0.12999992f, 0.03658387f, 0.10568566f, -0.00104408f, 0.14705905f, -0.08137088f, -0.09003267f, 
    -0.00322203f, 0.12709066f, -0.05789211f, 0.03087387f, 0.19914697f, -0.29116240f, -0.08258650f, -0.28046346f, 
    0.14956851f, -0.06765333f, 0.11988764f, -0.06743955f, -0.03462824f, 0.03388535f, 0.00808901f, -0.00001330f, 
    -0.15966196f, 0.22680539f, -0.13484427f, -0.06640607f, -0.03136770f, 0.09213416f, -0.00367245f, 0.13471229f, 
    0.06674314f, 0.04791254f, 0.04278193f, 0.07820243f, 0.04800640f, -0.23106998f, 0.08613316f, -0.21167631f, 
    0.06983123f, -0.06291710f, 0.12882191f, -0.10492770f, 0.05411443f, 0.05381855f, 0.02936934f, 0.09896017f, 
    -0.16649444f, 0.24731915f, -0.02646211f, -0.03342197f, 0.03589102f, 0.15322535f, -0.01534104f, 0.06297920f, 
    0.00196607f, 0.07380069f, -0.00601845f, 0.12057778f, 0.44834638f, 0.00754551f, 0.13454229f, 0.16083895f, 
    -0.04811438f, -0.07368848f, -0.03249002f, 0.00107507f, -0.14871797f, 0.03881987f, -0.03343210f, 0.03911244f, 
    -0.14403656f, -0.14773914f, 0.18126935f, 0.12546989f, 0.12111028f, 0.09254728f, 0.06670716f, 0.06493481f, 
    -0.01659873f, -0.05624132f, 0.01400968f, 0.10913046f, 0.07620975f, -0.12958427f, -0.06542411f, 0.01004322f, 
    0.04659029f, 0.01439329f, -0.04851869f, -0.05104183f, 0.03695393f, -0.02416485f, -0.07724532f, 0.01837867f, 
    -0.08773572f, 0.02699465f, -0.14411408f, 0.17952433f, -0.05771634f, 0.03054657f, 0.04624192f, 0.04562807f, 
    0.06676994f, 0.10893808f, -0.01043298f, 0.03423565f, 0.05253968f, -0.07143954f, -0.01510632f, -0.01391100f, 
    -0.04658075f, 0.03175512f, 0.08726523f, 0.02141292f, -0.02744546f, -0.03937900f, 0.01325595f, 0.03589869f, 
    -0.22175869f, -0.04677329f, -0.14354667f, -0.20208833f, 0.05922554f, 0.07263844f, 0.04486220f, -0.11129381f, 
    0.01946238f, 0.03370761f, 0.00135243f, 0.14983951f, 0.06879041f, 0.26449192f, 0.09797189f, 0.26670507f, 
    -0.08607153f, -0.03528200f, -0.03072748f, 0.02836677f, 0.08054619f, 0.12569053f, 0.04832974f, -0.05942504f, 
    -0.04221173f, -0.01181800f, -0.02272109f, 0.00531509f, 0.04008720f, 0.03734140f, -0.03438729f, 0.01690164f, 
    -0.04784151f, -0.02735431f, 0.02672705f, -0.00033459f, -0.03530214f, -0.04488274f, -0.01083158f, 0.03642255f, 
    -0.03927702f, 0.00423149f, -0.04988458f, 0.04482311f, -0.02694364f, 0.01409795f, -0.04685261f, -0.03632392f, 
    0.02488790f, -0.05365048f, 0.03202713f, 0.02148870f, -0.00082379f, 0.04484119f, 0.01186725f, -0.01606558f, 
    -0.02174281f, -0.04681608f, 0.01564212f, 0.03594041f, -0.00767821f, -0.01122360f, -0.00771783f, 0.03047897f, 
    -0.03843042f, -0.03765325f, 0.03456134f, -0.04060811f, 0.03811320f, -0.04097377f, -0.04028697f, -0.02817428f, 
    0.01140741f, -0.00792851f, 0.03438683f, 0.00615268f, -0.04251061f, -0.02591301f, -0.01367056f, 0.02187375f, 
    -0.01730565f, -0.00246826f, 0.00227770f, 0.01154123f, -0.02363668f, 0.02042201f, 0.00975278f, 0.02461346f, 
    0.03586523f, -0.03089098f, 0.00878439f, -0.01553422f, 0.03079546f, -0.02982117f, -0.04302927f, 0.01183956f, 
    -0.01219814f, 0.01994780f, 0.02866729f, -0.02335844f, -0.01225912f, -0.04894942f, 0.02985714f, -0.04322184f, 
    -0.03193020f, -0.03288935f, -0.01065031f, 0.01052189f, -0.01879803f, -0.00112588f, -0.05019599f, 0.02630557f, 
    -0.00796753f, 0.00349819f, -0.03908785f, -0.00538796f, 0.00972970f, -0.03778874f, 0.00330180f, 0.03916892f, 
    -0.03365728f, 0.00502180f, -0.02010199f, -0.03242461f, 0.03103121f, 0.02823441f, 0.05575937f, -0.01066485f, 
    -0.02391061f, -0.02290168f, 0.02311063f, -0.01593858f, 0.02783241f, 0.01124764f, -0.02888021f, -0.03130432f, 
    -0.00949043f, -0.04045377f, 0.03897364f, -0.00689921f, 0.04537294f, -0.01957273f, -0.05613695f, 0.01110146f, 
    -0.04084570f, 0.02848705f, -0.02179796f, -0.04823393f, 0.00475649f, -0.02441256f, 0.03361029f, 0.03977510f, 
    -0.01299904f, -0.04579889f, 0.02744000f, -0.00452308f, -0.03973420f, 0.01229755f, 0.02038932f, 0.02839884f, 
    -0.00515432f, 0.00635797f, -0.00583228f, 0.03313350f, 0.02374166f, 0.01915860f, 0.00874837f, 0.01175436f, 
    0.01439546f, -0.03745742f, -0.05610398f, -0.04705498f, 0.00552143f, 0.00036194f, -0.02715855f, 0.03618549f, 
    -0.05125745f, -0.02626870f, -0.04513076f, 0.01810227f, -0.00678220f, 0.05002061f, -0.02987354f, -0.04183238f, 
    0.01960500f, -0.01371775f, -0.00493721f, -0.03577407f, -0.05733544f, -0.00417353f, -0.04419252f, 0.00294628f, 
    -0.02551197f, 0.00769131f, -0.04451507f, -0.02837428f, 0.03913040f, 0.03616307f, -0.04919143f, -0.00262504f, 
    0.02126219f, -0.02763163f, 0.03553635f, -0.03557490f, -0.02555336f, -0.04896379f, -0.00927887f, -0.04238667f, 
    -0.04022814f, -0.04929814f, -0.04502980f, 0.03773976f, 0.03543702f, 0.02637123f, 0.02885868f, -0.03053982f, 
    -0.05053645f, -0.03250852f, -0.03950247f, 0.03085002f, -0.03373323f, -0.03599945f, -0.00489379f, 0.01923355f, 
    -0.04257040f, 0.03861246f, -0.02378668f, -0.04912091f, -0.04446474f, 0.01910914f, 0.02561183f, -0.01845550f, 
    -0.05521860f, -0.00219684f, 0.03949959f, -0.04529118f, 0.00357170f, -0.04320201f, 0.03664419f, -0.04819777f, 
    -0.04412680f, -0.04631078f, -0.00324550f, 0.00973670f, 0.05205333f, -0.01664778f, 0.03371499f, -0.00512053f, 
    -0.05342442f, -0.04399674f, -0.01867769f, 0.03004725f, -0.00339011f, 0.02223639f, -0.04371638f, 0.03562192f, 
    0.03397335f, 0.03650445f, 0.00550415f, 0.01301841f, -0.00116569f, -0.03899697f, 0.01281537f, -0.04027101f, 
    0.02810630f, -0.02824657f, 0.03609148f, 0.04138839f, -0.00072665f, -0.04550704f, -0.04224390f, -0.00853794f, 
    -0.04751946f, 0.00192441f, 0.03491053f, -0.00191492f, 0.02997170f, 0.03276276f, -0.04161263f, -0.00584070f, 
    0.04177215f, -0.03362669f, -0.02975973f, 0.03691958f, 0.02688965f, 0.01745591f, 0.00283056f, 0.01538610f, 
    -0.02955350f, -0.01721884f, -0.03200833f, 0.02729420f, -0.01077893f, 0.04011323f, -0.00048303f, 0.00643808f, 
    -0.02966155f, 0.03312100f, -0.04946380f, 0.01205865f, 0.03011358f, -0.05277055f, 0.03650000f, 0.03663301f, 
    -0.01042937f, -0.05194078f, 0.00896891f, -0.02283320f, -0.00596476f, 0.01492857f, 0.01675677f, 0.02973270f, 
    0.01918156f, 0.04411128f, 0.02950213f, 0.04799223f, 0.03458260f, 0.00009773f, -0.02030581f, -0.01204822f, 
    0.00502892f, 0.01711553f, -0.03473135f, -0.02878123f, 0.03343311f, 0.02715832f, -0.02281674f, 0.02467388f, 
    -0.03030912f, -0.03332913f, -0.00093012f, -0.02967266f, 0.01107232f, -0.02950198f, 0.01545892f, 0.03872678f, 
    0.03341034f, 0.04289524f, -0.02826781f, 0.00272820f, -0.02631724f, 0.03296366f, 0.00278123f, 0.04330900f, 
    -0.03845625f, 0.00095092f, 0.00645209f, 0.01588393f, 0.01843108f, -0.03426832f, 0.04659662f, 0.01831171f, 
    -0.04298707f, -0.03085692f, -0.02698387f, 0.04199763f, -0.03083161f, -0.00471786f, 0.01089466f, -0.01946013f, 
    -0.03542684f, -0.04570609f, 0.00664036f, -0.03363699f, -0.01157185f, 0.01250443f, -0.04841409f, -0.04869775f, 
    0.00123374f, 0.02381681f, -0.01053717f, -0.03450835f, 0.00265327f, 0.00791699f, 0.04033903f, -0.01098775f, 
    0.04200480f, 0.03957980f, 0.02068427f, -0.00610288f, 0.02234202f, -0.02483536f, 0.01476436f, -0.00878838f, 
    0.02841517f, -0.03439511f, 0.02451619f, 0.02255738f, -0.00310682f, -0.05045325f, 0.01456144f, 0.00970510f, 
    0.03407843f, -0.01371049f, -0.01432499f, -0.00684533f, -0.03770922f, 0.03562078f, -0.00650957f, -0.04167392f, 
    -0.03344088f, 0.00766951f, -0.04482702f, -0.03921855f, 0.04207714f, -0.03563144f, -0.04424872f, 0.03213393f, 
    0.17800893f, 0.06700870f, -0.07374763f, -0.18334283f, 0.03342595f, 0.01467864f, 0.03194392f, 0.08697498f, 
    0.08323141f, -0.05483769f, 0.04915639f, 0.08723108f, 0.00616977f, 0.08621678f, -0.20656382f, 0.07573476f, 
    -0.01096231f, -0.07075092f, 0.07476959f, -0.10897242f, -0.05555363f, -0.08893359f, -0.03417995f, -0.01648015f, 
    0.08463634f, 0.12177531f, -0.00557813f, 0.15280223f, -0.06587077f, -0.08558622f, 0.11093838f, 0.00927672f, 
    0.04400392f, 0.05955986f, -0.00917152f, -0.02119183f, -0.04689994f, -0.31206074f, 0.29594409f, 0.12487944f, 
    -0.03950346f, -0.07683163f, -0.04628526f, -0.05000718f, 0.01350885f, 0.03243201f, -0.01327893f, -0.11712176f, 
    -0.41286647f, 0.34176487f, -0.05376139f, 0.25654575f, 0.09725179f, -0.00064256f, 0.00171213f, 0.01641788f, 
    0.03781841f, -0.00109738f, -0.02449427f, 0.05855957f, 0.08361123f, -0.01701536f, 0.07573818f, -0.00557877f, 
    0.12403876f, 0.03177394f, 0.03016091f, -0.01617183f, -0.01393113f, -0.05140203f, 0.03052319f, -0.01570826f, 
    0.04318210f, 0.04349861f, 0.18794717f, -0.06863347f, -0.04211557f, -0.10409900f, 0.08444091f, 0.13189101f, 
    0.04882719f, -0.01785024f, -0.08294210f, 0.13941799f, -0.09653950f, -0.11050157f, -0.15971878f, -0.10488684f, 
    -0.05576603f, 0.11264100f, -0.05073569f, 0.15590502f, 0.01543154f, -0.00203990f, -0.00759092f, 0.01145265f, 
    -0.17913903f, -0.24584851f, 0.16624577f, 0.20226875f, 0.02784647f, 0.07606155f, 0.12336580f, -0.04919185f, 
    0.06601627f, -0.11058772f, 0.11048965f, 0.14571603f, -0.03125427f, 0.20171709f, -0.03925022f, 0.08666825f, 
    0.00283543f, -0.06748854f, 0.04401731f, 0.09350886f, -0.03087220f, 0.00945797f, -0.06242048f, -0.03473701f, 
    0.10395546f, 0.14294054f, -0.07354735f, 0.14195959f, 0.09728896f, -0.02370487f, 0.00249125f, 0.05364231f, 
    -0.05262620f, 0.11608944f, 0.00862718f, 0.19323510f, 0.25941202f, 0.03299996f, -0.19621521f, 0.22486091f, 
    0.10831568f, 0.10128152f, 0.04955173f, 0.00043798f, 0.08577210f, 0.07341943f, -0.15712367f, 0.04661109f, 
    0.09281194f, 0.11593356f, 0.03836043f, -0.26889849f, -0.00604122f, -0.18041761f, 0.07570682f, 0.10917786f, 
    -0.06459630f, -0.01883322f, 0.09950534f, 0.03792862f, -0.48800987f, 0.04739409f, 0.06954953f, -0.13557363f, 
    0.01959668f, 0.08476887f, 0.08537091f, 0.06554910f, 0.01831742f, 0.15118018f, -0.03574944f, -0.04804758f, 
    0.15706955f, -0.08763574f, 0.02839417f, 0.21022646f, -0.03677949f, 0.04685361f, 0.18410167f, -0.01845509f, 
    -0.02229243f, 0.01956923f, -0.01432351f, -0.05065919f, -0.47898656f, 0.18394898f, 0.06171542f, -0.02770309f, 
    -0.09088793f, -0.02798919f, 0.06514420f, -0.07648926f, -0.05134159f, 0.04288146f, 0.00715107f, -0.07287399f, 
    0.17375936f, -0.35871091f, 0.09211285f, 0.35577351f, -0.05977055f, 0.11552872f, 0.05988080f, 0.08817678f, 
    -0.00457304f, -0.04409234f, 0.07193334f, 0.09654737f, -0.23116070f, 0.03337631f, 0.18098097f, 0.10525277f, 
    0.13529493f, -0.01005364f, 0.10529090f, -0.00773322f, 0.00550468f, -0.05006107f, 0.01174701f, 0.06935230f, 
    0.15518901f, -0.06507199f, 0.06690067f, 0.14905703f, -0.11462422f, -0.01585954f, -0.04134226f, 0.14626281f, 
    -0.02080578f, 0.04737195f, -0.09628265f, -0.03262853f, 0.28453818f, -0.00365954f, 0.06570981f, 0.06769756f, 
    0.01844098f, 0.07128453f, 0.13841744f, 0.06774858f, 0.18852559f, -0.06895404f, 0.01673191f, 0.05815312f, 
    0.37452024f, -0.27302772f, 0.11591805f, -0.32196552f, 0.04039619f, -0.07186688f, -0.05105307f, -0.08698517f, 
    -0.02868144f, -0.01344558f, -0.13071258f, -0.05036042f, 0.17662942f, -0.10626470f, -0.20396276f, -0.01068660f, 
    0.09293531f, -0.04480099f, 0.03189284f, 0.18582839f, 0.10688164f, 0.07046002f, -0.16464330f, -0.02963397f, 
    -0.16992646f, 0.07121608f, 0.09640529f, -0.24055357f, -0.12263129f, 0.13244988f, -0.03671299f, 0.14329138f, 
    -0.03252492f, 0.12804212f, 0.09832747f, -0.09702183f, 0.48450041f, 0.07720611f, -0.16551900f, 0.31926945f, 
    0.01725455f, -0.14277652f, -0.02162784f, 0.01619504f, 0.01953332f, 0.02502182f, -0.04771830f, 0.07432078f, 
    -0.10040502f, -0.06251584f, -0.00633256f, -0.09009088f, 0.04150335f, -0.06287807f, 0.17311192f, 0.04919668f, 
    -0.02182799f, 0.09441231f, 0.00110441f, 0.07242953f, 0.34830871f, 0.00505573f, 0.03156553f, 0.27907717f, 
    0.03062911f, -0.00849916f, 0.08807777f, 0.04144485f, 0.10932645f, -0.01833895f, -0.02135971f, 0.05202020f, 
    0.24649809f, 0.10098220f, -0.16224712f, 0.26186636f, -0.08034818f, 0.02198699f, -0.01252735f, 0.02262125f, 
    0.06985778f, -0.17407481f, 0.00649104f, 0.04700780f, -0.32434255f, -0.00120749f, -0.09070826f, -0.08077341f, 
    -0.02802369f, -0.00249882f, 0.00814545f, 0.04011611f, 0.05860915f, 0.07204184f, 0.02544119f, -0.09338237f, 
    -0.10164515f, 0.07251556f, 0.11113308f, -0.13943245f, 0.01727070f, 0.05382751f, 0.02895661f, 0.07813072f, 
    -0.00526212f, 0.06222636f, -0.03718032f, -0.01308130f, -0.02764730f, -0.38320714f, -0.09382798f, 0.15977107f, 
    0.04614962f, -0.08918574f, -0.00506152f, 0.07910847f, 0.08030043f, -0.04739262f, 0.02238791f, -0.09713454f, 
    -0.13434048f, -0.08909891f, -0.23981889f, 0.01436862f, 0.02923013f, -0.06616852f, -0.02527937f, -0.16339141f, 
    0.03777610f, 0.09990595f, 0.02631062f, 0.02420843f, 0.01337819f, 0.03684236f, 0.05511033f, -0.07986246f, 
    0.03980803f, -0.05962669f, 0.10573031f, 0.05209224f, 0.15664411f, 0.01215569f, 0.12778080f, -0.12853509f, 
    -0.00879897f, 0.04134904f, -0.02211568f, -0.03127991f, -0.02737008f, 0.01668178f, -0.03860144f, 0.01272666f, 
    -0.01820850f, -0.05211693f, -0.02592226f, -0.05035886f, -0.01377768f, 0.03174932f, -0.02844548f, -0.00605776f, 
    -0.00683568f, -0.02725503f, 0.03532189f, 0.01268749f, -0.03247515f, 0.04027137f, 0.01259758f, 0.01245781f, 
    0.02072240f, -0.00162270f, -0.02048343f, 0.00483835f, -0.05428383f, 0.03614632f, -0.01513575f, 0.02820200f, 
    0.03686751f, -0.02626177f, -0.04463731f, -0.01021865f, -0.04287654f, -0.05015581f, 0.01678409f, 0.01064954f, 
    -0.01763875f, 0.01367211f, -0.05278370f, 0.02509294f, -0.03730958f, 0.00572473f, -0.04665902f, -0.03331964f, 
    0.00072302f, 0.03740502f, -0.00357894f, -0.04275426f, 0.00279060f, -0.02217602f, -0.00839951f, 0.02483245f, 
    -0.00512877f, -0.01433610f, 0.02422456f, -0.01893598f, 0.01137222f, -0.02908160f, -0.00123914f, -0.02536693f, 
    -0.05237408f, 0.04882303f, 0.03167996f, -0.01101801f, 0.01384127f, -0.03366853f, -0.01563163f, 0.02965887f, 
    -0.01228437f, 0.02133074f, -0.03685182f, -0.03947861f, -0.01324675f, -0.03611941f, -0.01953124f, -0.01491478f, 
    0.00811812f, 0.03519590f, -0.01775050f, 0.01211853f, -0.04702110f, 0.01910610f, -0.01366485f, -0.05976486f, 
    -0.02418546f, 0.04017304f, 0.04741612f, 0.00312414f, 0.03340415f, -0.01453880f, 0.03795636f, -0.05176190f, 
    -0.03111704f, -0.04174159f, 0.04024895f, 0.04578410f, -0.04136996f, -0.01584046f, 0.04017910f, -0.03502116f, 
    0.04333357f, -0.04185075f, 0.02628853f, -0.00187766f, 0.02671236f, -0.02968581f, -0.05371350f, 0.00168476f, 
    -0.00965780f, 0.04169283f, -0.00868122f, 0.02680705f, 0.00121625f, 0.00819417f, -0.00621637f, 0.00571702f, 
    0.03821268f, 0.00505050f, 0.04117502f, -0.05197735f, -0.02692993f, 0.00332766f, 0.03750928f, 0.02787363f, 
    -0.04757564f, -0.04612143f, -0.00673327f, -0.04397332f, -0.04052694f, -0.01642653f, 0.01736803f, 0.00657891f, 
    -0.04361106f, 0.04060819f, 0.00857151f, 0.03680123f, -0.02840562f, -0.03389148f, -0.03017846f, -0.03550008f, 
    -0.04037866f, 0.02206385f, 0.03386743f, -0.04890263f, -0.04108288f, 0.00913635f, -0.02684907f, 0.00307854f, 
    0.00106187f, 0.03904466f, -0.02612159f, -0.02280102f, 0.02184560f, 0.00454696f, 0.03697991f, -0.03875510f, 
    -0.00558312f, 0.04486873f, 0.02669506f, 0.01726884f, 0.02442319f, 0.00333249f, -0.03157447f, -0.00608243f, 
    -0.01673545f, -0.02828506f, -0.01677926f, -0.04562390f, -0.02275336f, -0.02125540f, 0.00626222f, 0.03876724f, 
    0.01924969f, -0.01549135f, -0.00867166f, -0.00814354f, 0.04218583f, 0.02315236f, 0.01267836f, -0.03786113f, 
    -0.05188004f, -0.01806698f, -0.05172919f, -0.04577154f, -0.02691739f, 0.04657847f, -0.05114089f, -0.04916347f, 
    0.03827723f, 0.00368004f, -0.03701591f, -0.02775060f, -0.02356202f, 0.04939134f, -0.01869032f, -0.03731982f, 
    -0.02912578f, 0.04253155f, 0.02640264f, 0.03871435f, -0.04973588f, 0.00776249f, 0.02189815f, -0.01314849f, 
    -0.03882834f, -0.03115164f, -0.00104057f, 0.00455940f, 0.03005436f, -0.00840213f, -0.01278786f, 0.01418672f, 
    -0.02229229f, -0.03739020f, 0.01858531f, 0.01522878f, 0.00255151f, -0.01582037f, 0.01991406f, 0.01023923f, 
    0.03840216f, 0.02391028f, 0.03186728f, -0.01987079f, -0.05474304f, 0.04197090f, 0.00883162f, 0.04998142f, 
    -0.02809079f, 0.01729836f, -0.00801817f, 0.01995868f, 0.01977023f, 0.01676775f, 0.03134685f, -0.02953916f, 
    -0.00134332f, 0.03421051f, -0.03060880f, -0.05622764f, -0.01373564f, 0.03048125f, -0.04919099f, -0.04325733f, 
    0.00884716f, -0.04399182f, -0.02808362f, 0.03837878f, -0.04182081f, -0.04125462f, -0.04956457f, -0.05559583f, 
    0.01308252f, -0.03216263f, -0.04414456f, 0.04062510f, 0.00557118f, 0.04409203f, -0.03385289f, 0.04560950f, 
    0.02944499f, -0.03126646f, 0.04447192f, 0.02851362f, -0.02581803f, -0.03591091f, -0.04243771f, -0.04497507f, 
    0.02625919f, -0.02405634f, -0.03097407f, -0.04746135f, -0.03377387f, -0.03105744f, 0.04348338f, -0.01199002f, 
    0.02518045f, -0.03801381f, 0.03364076f, 0.02919652f, -0.04471546f, -0.05506559f, 0.02481984f, 0.03419537f, 
    -0.01254073f, 0.03488597f, 0.01358653f, -0.02640486f, -0.00072691f, -0.04637580f, -0.02625805f, -0.03737093f, 
    -0.02027170f, -0.03502836f, 0.02755280f, -0.04974976f, 0.03931950f, 0.00126612f, -0.05571170f, 0.01638603f, 
    0.02673271f, -0.01066640f, -0.04641327f, 0.01344562f, -0.02765826f, -0.03620336f, 0.04478113f, -0.04862905f, 
    -0.01961442f, -0.03185011f, 0.00059482f, 0.01443881f, 0.02702184f, -0.02963487f, 0.03207355f, -0.03438608f, 
    0.02029700f, 0.02460778f, 0.01630854f, -0.01659499f, -0.02517753f, 0.03922690f, 0.04107896f, -0.02394108f, 
    -0.02390450f, -0.00918559f, -0.01656422f, -0.03431013f, 0.01975687f, 0.01094871f, 0.03964636f, -0.00782688f, 
    0.00167979f, 0.04320461f, 0.00989898f, 0.00837491f, 0.01220373f, 0.04921971f, -0.04023862f, -0.02509107f, 
    -0.03115424f, -0.02414121f, -0.02221426f, -0.01109906f, -0.02848160f, 0.00509046f, 0.03976022f, -0.05391727f, 
    0.04714552f, -0.04423258f, -0.02130818f, 0.00850420f, -0.04763960f, 0.04247871f, -0.03084265f, 0.03758132f, 
    -0.04590783f, -0.01120992f, -0.04764862f, -0.03775355f, 0.04227105f, 0.03640483f, 0.03250078f, 0.02551041f, 
    -0.04456547f, 0.03117904f, -0.04827223f, -0.00299033f, 0.00000537f, -0.05217774f, 0.03991919f, -0.01661805f, 
    -0.01588684f, 0.03439245f, 0.01820112f, 0.02145852f, -0.01650201f, 0.01077140f, -0.05491279f, -0.01572534f, 
    -0.05269767f, -0.03808401f, 0.08455796f, 0.01560557f, -0.10425967f, 0.00362922f, 0.07777763f, 0.12376073f, 
    0.05800593f, 0.16687807f, -0.06393478f, 0.02572829f, 0.45505533f, -0.22812614f, -0.10516223f, 0.00891568f, 
    -0.19010404f, 0.04046790f, -0.07867486f, 0.08440398f, -0.14462726f, 0.00390622f, 0.00997220f, 0.07102079f, 
    0.02083430f, 0.07024203f, 0.01868983f, 0.24380706f, -0.01722492f, 0.06752371f, 0.03441236f, -0.05540682f, 
    0.00757439f, -0.15678880f, -0.04105063f, -0.06277803f, -0.14635274f, 0.03394937f, 0.00479816f, -0.05914718f, 
    0.09739242f, 0.00234058f, 0.00719482f, -0.12172620f, 0.10851636f, 0.00421321f, 0.05935087f, -0.06588360f, 
    0.00740157f, 0.13108368f, -0.12919898f, -0.12427671f, 0.04220081f, 0.13674498f, 0.13638194f, 0.10189986f, 
    0.02415890f, 0.01168338f, -0.02511924f, -0.08566277f, 0.16347156f, 0.11925492f, 0.00177656f, 0.12016446f, 
    -0.08579673f, -0.14033571f, -0.01451673f, -0.12208976f, -0.07107253f, -0.02341325f, 0.10645530f, 0.21891133f, 
    -0.02601428f, -0.07312805f, -0.11516131f, -0.15957601f, -0.22812659f, -0.01049251f, -0.07692107f, -0.01497767f, 
    0.05272138f, 0.18548404f, 0.15933141f, 0.06457052f, -0.21273702f, -0.08184290f, -0.03300809f, -0.08583584f, 
    0.09374060f, 0.03364999f, 0.07840846f, -0.07209539f, -0.05799538f, 0.01624047f, -0.06536261f, 0.09502296f, 
    -0.18012519f, -0.03923551f, -0.16769962f, -0.05916126f, -0.03657543f, 0.11673445f, -0.01518482f, 0.03704926f, 
    0.12219283f, 0.10451474f, -0.02263631f, -0.04076107f, 0.20000066f, 0.27266327f, -0.12491676f, -0.01866620f, 
    -0.01307034f, 0.07370144f, 0.03544749f, -0.15272270f, -0.00952680f, 0.08761285f, -0.12736261f, -0.01372539f, 
    0.07432395f, 0.12366121f, -0.00268712f, -0.09504023f, -0.06174682f, 0.15044886f, 0.05901227f, -0.02171229f, 
    0.12704878f, -0.00229320f, 0.01630583f, 0.05561017f, 0.25052074f, -0.20660250f, 0.01076694f, 0.07578715f, 
    0.12512848f, 0.02072784f, 0.06824721f, 0.07706724f, 0.03510592f, 0.02654584f, -0.01897052f, -0.13785303f, 
    0.35077164f, 0.07915447f, 0.06002283f, 0.21914460f, 0.09952287f, 0.00797890f, 0.03611706f, 0.04140113f, 
    -0.11477770f, -0.04635834f, 0.10831565f, 0.06445713f, -0.23062579f, -0.03675386f, -0.21901897f, -0.04360161f, 
    0.09741104f, 0.03215409f, 0.05598683f, 0.06956714f, 0.01342514f, 0.02882583f, 0.02273050f, 0.07740735f, 
    -0.16054416f, 0.09016642f, -0.09952661f, -0.04229237f, -0.19689870f, -0.16114424f, -0.01900024f, -0.07413457f, 
    0.08495419f, 0.08365814f, 0.02245109f, 0.03374110f, 0.19604026f, 0.03243731f, -0.10785223f, -0.08122042f, 
    -0.02394415f, 0.04806985f, -0.07692525f, 0.16973615f, -0.11257172f, -0.01070818f, -0.01860395f, -0.04323215f, 
    0.20007588f, 0.16864553f, -0.03689136f, -0.04939737f, 0.11569515f, 0.15642366f, 0.03238093f, 0.00219406f, 
    0.11397213f, -0.01959127f, -0.11897360f, -0.17661779f, 0.48873404f, 0.06488374f, -0.06861070f, 0.16186039f, 
    -0.04026861f, 0.04921245f, 0.06135037f, 0.01765437f, 0.01164530f, -0.16716504f, -0.06199539f, -0.09992725f, 
    0.22568841f, -0.19865263f, 0.02274988f, -0.05085727f, 0.18023476f, 0.08450931f, 0.03387252f, -0.02957922f, 
    -0.10276620f, -0.12850875f, 0.00040991f, 0.03080986f, 0.00903293f, -0.06380440f, -0.07665458f, 0.04042388f, 
    -0.09013449f, -0.16915655f, -0.09251311f, -0.04925129f, 0.17759891f, 0.07912647f, -0.03094767f, 0.22686200f, 
    -0.20888920f, -0.40667057f, 0.01928130f, 0.21564138f, 0.04320671f, 0.05041249f, 0.13763893f, 0.21476936f, 
    0.02217142f, -0.01723558f, 0.03385412f, 0.08164306f, 0.07374135f, -0.09169799f, 0.19188718f, -0.00097414f, 
    -0.07603519f, 0.08297004f, -0.02004303f, -0.00692130f, 0.03663764f, -0.02030219f, 0.12340830f, 0.13586333f, 
    -0.04593765f, -0.17279403f, 0.04169084f, 0.01237380f, -0.20821615f, -0.00649219f, 0.02035798f, 0.02563231f, 
    -0.04778428f, 0.10677225f, -0.02810145f, 0.11094453f, 0.01441809f, -0.18336514f, -0.05403374f, -0.10944720f, 
    -0.02700954f, -0.01801348f, -0.08518167f, 0.00766223f, -0.06815495f, 0.00424594f, 0.04474677f, 0.06772190f, 
    0.15252538f, -0.27127182f, -0.03222170f, 0.16981193f, 0.04319978f, -0.10965704f, -0.01347983f, 0.08165786f, 
    -0.03689229f, 0.08183680f, 0.08077329f, 0.12141897f, -0.03649868f, -0.07437912f, 0.04462766f, -0.01182135f, 
    0.13849427f, 0.04400025f, -0.01376854f, 0.09927574f, 0.15906896f, 0.03096698f, 0.06926685f, 0.01618079f, 
    0.04908711f, 0.18860459f, 0.05896406f, -0.16465846f, 0.04832490f, 0.10369265f, 0.03686639f, -0.14759985f, 
    -0.07596945f, 0.16318548f, -0.04380871f, -0.01577987f, -0.31014979f, 0.19083269f, 0.11687200f, 0.08926838f, 
    0.01247400f, 0.07977977f, 0.02194163f, 0.10196067f, 0.00504634f, 0.04440936f, 0.02242360f, -0.04564340f, 
    -0.03874354f, -0.06008112f, 0.10492183f, -0.03298366f, 0.13307153f, 0.00712757f, 0.06621056f, 0.10895697f, 
    0.10194271f, 0.18937811f, 0.00673433f, 0.11110725f, -0.08492985f, -0.33931747f, 0.12080105f, 0.11622938f, 
    0.03656560f, -0.06599265f, -0.02752426f, 0.07342210f, 0.13948338f, 0.05594431f, -0.17371513f, 0.03036211f, 
    0.43488184f, -0.16961461f, 0.11651208f, -0.09661081f, -0.08914419f, -0.06259651f, -0.06847771f, 0.13452880f, 
    -0.07949595f, 0.06914218f, 0.09918752f, 0.03450932f, -0.29466918f, 0.00083721f, -0.02040038f, -0.22178711f, 
    0.06546571f, -0.06030316f, -0.00926778f, -0.01471846f, -0.09087593f, -0.02814939f, -0.03341028f, 0.05141649f, 
    -0.02779271f, 0.02861688f, -0.10755692f, -0.17674240f, 0.05763033f, -0.07906307f, 0.17310031f, 0.03680117f, 
    0.08481261f, 0.06478471f, -0.04609672f, 0.04374333f, -0.18588623f, 0.21071737f, 0.00288202f, 0.13564430f, 
    0.03516598f, -0.05336447f, 0.17518918f, -0.10184325f, -0.05111755f, -0.02500966f, 0.06443485f, -0.13949493f, 
    0.32906431f, -0.06807918f, 0.24401009f, 0.15554316f, -0.10005374f, 0.05964677f, -0.12465696f, 0.09705976f, 
    0.02011153f, -0.01678367f, 0.07548265f, -0.06685062f, 0.06273220f, -0.13163230f, -0.09720083f, -0.05609969f, 
    0.00146845f, -0.03726269f, -0.04335610f, 0.00673611f, 0.10377058f, -0.08290721f, -0.09092195f, 0.00409883f, 
    -0.04002399f, -0.00995923f, 0.26342916f, 0.27935413f, -0.02303737f, -0.00701446f, 0.05382295f, 0.05523543f, 
    -0.04408849f, 0.01803557f, -0.07619993f, -0.01333137f, 0.02552682f, -0.01146993f, 0.07270624f, -0.09408984f, 
    -0.13281454f, 0.15732230f, -0.06308468f, 0.10951700f, 0.03780506f, 0.06669506f, 0.01358671f, 0.21791591f, 
    -0.11427163f, 0.06088326f, -0.02804462f, -0.07258049f, 0.07953621f, 0.01782028f, 0.12492324f, 0.13172787f, 
    -0.05716006f, -0.00567890f, -0.01488537f, 0.11287315f, -0.13068876f, -0.18958013f, -0.25424549f, -0.00944366f, 
    0.05808249f, 0.04851754f, -0.12259781f, 0.02118011f, -0.14790823f, -0.00740351f, 0.06857748f, -0.04550781f, 
    -0.11253170f, -0.29029360f, 0.01658458f, -0.09061902f, 0.04382405f, 0.03296188f, 0.09890430f, 0.05704468f, 
    0.02984970f, -0.00754257f, 0.02058088f, 0.10737716f, -0.25859851f, 0.16159758f, 0.04877988f, 0.02678489f, 
    0.09638157f, -0.00408919f, -0.12359079f, -0.01705510f, 0.00472869f, -0.01616026f, -0.01526364f, -0.05876884f, 
    0.06436762f, 0.16251482f, 0.03324346f, 0.08542226f, -0.06787530f, 0.03628618f, -0.00932177f, -0.11742757f, 
    -0.00645837f, 0.01996891f, 0.01176834f, 0.04077445f, 0.30363148f, 0.06905010f, -0.04874909f, 0.11051255f, 
    0.01238448f, 0.06686670f, 0.01019353f, 0.02415026f, 0.06947726f, 0.10251463f, -0.10781537f, -0.08352326f, 
    0.05423098f, 0.02297790f, 0.11815890f, 0.04591985f, 0.00464087f, 0.04006713f, 0.08378406f, 0.04901462f, 
    0.03036227f, 0.00161233f, -0.05221614f, -0.06050526f, -0.26979592f, -0.06954624f, 0.03045310f, -0.12902978f, 
    -0.03141656f, 0.00744236f, 0.02851303f, 0.05466333f, 0.02560782f, 0.03308973f, -0.03405990f, -0.08627398f, 
    0.24986842f, -0.05683393f, 0.04475268f, 0.16558662f, -0.03332317f, 0.01379484f, 0.07230472f, 0.03767701f, 
    -0.24545506f, 0.19298416f, -0.00706745f, -0.11745897f, -0.00373291f, -0.01816157f, 0.01734529f, 0.02946776f, 
    0.09514026f, -0.00084254f, 0.00977554f, -0.04162726f, -0.00088963f, -0.00144439f, -0.13564911f, 0.02648187f, 
    -0.00438137f, -0.08387024f, 0.11710107f, 0.20501296f, -0.04227306f, -0.01075925f, 0.10850127f, 0.15170422f, 
    0.00674576f, 0.14186719f, -0.04399770f, 0.06609280f, -0.52854913f, -0.00208143f, 0.05823357f, 0.12091303f, 
    0.10558631f, 0.01690676f, 0.10014506f, -0.03054162f, -0.00815385f, -0.05635371f, -0.02225563f, 0.16534555f, 
    -0.21724416f, 0.01614204f, 0.13482177f, 0.06831955f, -0.07530989f, 0.03257219f, -0.07551356f, -0.00008825f, 
    0.01626810f, -0.04563303f, -0.08129580f, 0.02206475f, 0.17573769f, -0.00932633f, 0.11331077f, 0.10415354f, 
    0.04056931f, -0.05725178f, 0.07296813f, 0.04654747f, 0.09469245f, 0.06367899f, 0.16572876f, 0.04779712f, 
    -0.15945499f, 0.05798365f, -0.00166977f, -0.14205341f, 0.13714769f, -0.07137357f, 0.13534676f, -0.10285119f, 
    0.02386526f, -0.09699807f, 0.12643507f, -0.06870562f, 0.07696246f, 0.03371340f, -0.02742513f, 0.06633052f, 
    -0.04426395f, -0.03922448f, 0.03223287f, 0.08401567f, -0.09308457f, 0.05282526f, 0.03887823f, -0.10718772f, 
    -0.18858783f, 0.13022545f, 0.08456489f, -0.15562990f, 0.00294171f, 0.05022918f, -0.05150186f, -0.00941665f, 
    -0.13223071f, 0.24090330f, 0.13040876f, 0.02003021f, 0.30215260f, 0.15926439f, -0.02981619f, 0.24439685f, 
    -0.09787598f, 0.00661848f, -0.12329648f, 0.05905496f, 0.06240778f, -0.15810457f, 0.04862541f, 0.06268863f, 
    -0.16156007f, -0.00443560f, -0.03211299f, -0.04647106f, 0.10615950f, -0.05212003f, 0.11361632f, 0.13278417f, 
    -0.09711017f, 0.14985651f, 0.07823179f, -0.05836627f, 0.19571871f, 0.09844220f, 0.07102674f, 0.11042745f, 
    -0.00734074f, -0.02730612f, 0.04140290f, 0.01869178f, 0.05288168f, -0.11433938f, 0.13052064f, -0.15214984f, 
    0.30316529f, 0.17885265f, -0.21553309f, 0.04965290f, -0.03175550f, -0.05385126f, -0.03093520f, -0.03271015f, 
    0.00990747f, -0.08359941f, -0.11832627f, -0.01807261f, 0.08142170f, 0.08364557f, -0.03805183f, -0.20201445f, 
    0.02558286f, -0.03974342f, -0.05576896f, 0.09290764f, 0.00828344f, 0.04234192f, 0.00464888f, 0.04060453f, 
    0.20998754f, 0.24220473f, 0.15277916f, -0.05193902f, 0.00226335f, 0.06440216f, -0.01113131f, 0.04426125f, 
    -0.04660518f, -0.07155213f, 0.15017511f, 0.03322570f, -0.15985985f, -0.21209924f, 0.12668391f, 0.12257759f, 
    0.04246073f, 0.05044833f, -0.02566532f, 0.13065559f, 0.21241397f, 0.01996352f, 0.12942399f, 0.05591812f, 
    0.30030325f, -0.08872233f, -0.15106890f, 0.05209807f, 0.13016413f, 0.01584947f, -0.05991790f, 0.02433971f, 
    0.08163531f, -0.10339388f, 0.05290191f, -0.04766526f, 0.02923381f, -0.08586697f, -0.02762998f, -0.24655473f, 
    0.02684715f, 0.06158404f, 0.09280372f, -0.00756364f, -0.08145890f, -0.03891732f, -0.00748465f, -0.07550408f, 
    0.03734064f, 0.00724313f, -0.05459937f, -0.04868767f, 0.03750131f, 0.02157402f, -0.04026165f, -0.04899375f, 
    0.03690804f, 0.02757718f, 0.00230403f, -0.02322280f, 0.01490967f, -0.00604187f, -0.04345007f, -0.01540308f, 
    -0.00748285f, -0.03084726f, -0.03533192f, 0.00376992f, -0.00906724f, 0.00951158f, -0.01258379f, 0.01977071f, 
    -0.01536640f, -0.04851196f, -0.00907686f, -0.00426480f, -0.03532647f, -0.03682540f, -0.03304106f, -0.03008114f, 
    -0.02806556f, -0.00654676f, 0.03277595f, 0.01471281f, 0.02604363f, 0.01340707f, -0.03483006f, 0.00873307f, 
    -0.01491664f, -0.00283622f, -0.00970943f, -0.03571267f, 0.02989336f, -0.02563546f, -0.02002003f, 0.01140814f, 
    -0.03651924f, -0.04879943f, 0.01013593f, -0.01586991f, 0.01388923f, 0.01995438f, 0.01653535f, 0.03884380f, 
    -0.03478983f, 0.02247382f, -0.04746373f, 0.03473420f, 0.03708350f, 0.02268314f, -0.05095101f, -0.00882626f, 
    -0.04872630f, -0.03398164f, -0.03183435f, 0.03615114f, 0.01698272f, -0.05131424f, -0.03839131f, 0.04072604f, 
    -0.02255421f, 0.00009628f, -0.01189963f, 0.02635057f, 0.02532836f, 0.03497084f, 0.01302204f, -0.05488295f, 
    0.02206354f, -0.00485667f, -0.00896451f, 0.02185521f, -0.02719734f, -0.01034477f, -0.01188982f, 0.04765344f, 
    0.02711369f, 0.02591623f, 0.00707161f, 0.01867916f, -0.01632760f, 0.01506710f, 0.01762021f, 0.03295023f, 
    -0.00656754f, -0.03564136f, 0.03440065f, -0.04278758f, -0.00663907f, 0.02652581f, -0.01108983f, -0.03147613f, 
    0.02019868f, -0.03957601f, -0.01649816f, 0.03076810f, -0.00485297f, 0.04174488f, 0.01164389f, 0.00437101f, 
    -0.05550985f, 0.03927985f, 0.02697269f, 0.00133989f, 0.01039735f, -0.02439312f, -0.03490694f, -0.04893063f, 
    0.02619788f, -0.00132828f, -0.00785000f, -0.05527549f, -0.01866553f, 0.03532759f, 0.01322217f, 0.00995230f, 
    0.01420913f, -0.05908875f, 0.04131879f, -0.01353769f, 0.01060633f, -0.04171328f, 0.02367783f, 0.03529341f, 
    -0.02758980f, -0.02449721f, 0.01319096f, -0.01360155f, -0.01365990f, 0.00548260f, 0.02177614f, 0.00340693f, 
    -0.02902000f, -0.03191239f, 0.03870274f, -0.02645017f, -0.01619906f, -0.05128156f, -0.05372649f, 0.00300025f, 
    0.03729979f, 0.03243954f, 0.00244663f, -0.04198090f, -0.04718672f, 0.01505989f, 0.03841683f, 0.03576219f, 
    -0.05234054f, 0.02357558f, -0.04972171f, -0.00997236f, 0.02969728f, -0.03924500f, 0.02397246f, 0.02435148f, 
    -0.03679261f, -0.05102589f, -0.05160106f, 0.00064886f, 0.01635516f, -0.05002972f, 0.03307199f, 0.01067190f, 
    -0.01681268f, -0.05185454f, 0.00636933f, -0.04866918f, 0.02621335f, -0.00992823f, -0.04102494f, -0.00352699f, 
    -0.02327048f, -0.03869089f, -0.01532241f, -0.02147264f, -0.00910473f, -0.02665648f, -0.01732420f, -0.04679246f, 
    -0.01560841f, -0.00754697f, -0.04265030f, 0.02937345f, -0.00388126f, 0.01909938f, -0.00699715f, -0.03766583f, 
    -0.01527721f, -0.03549502f, 0.00258819f, -0.04112120f, -0.02589213f, -0.01080263f, -0.04542109f, -0.00363686f, 
    -0.03066592f, 0.01341239f, -0.01320946f, -0.00905439f, -0.05371303f, 0.03512866f, 0.03939955f, -0.04247728f, 
    0.03425437f, 0.02229745f, 0.03427874f, -0.01931239f, -0.00488785f, 0.02415941f, -0.02860302f, -0.03814251f, 
    -0.00964008f, -0.01302526f, 0.03676167f, -0.03902134f, 0.00364838f, -0.04429061f, -0.02446070f, 0.03046228f, 
    0.00229323f, -0.04222496f, -0.03131152f, 0.03283897f, -0.01048726f, -0.00685479f, 0.00607621f, 0.00675098f, 
    -0.03689069f, -0.05680558f, 0.03581784f, 0.04055408f, -0.00831628f, -0.03394575f, -0.03672897f, 0.01968829f, 
    0.01096807f, 0.02230993f, 0.02476749f, -0.02551545f, -0.03891896f, 0.00827599f, -0.01615532f, -0.01196046f, 
    -0.04553627f, -0.00635334f, 0.03113115f, 0.03615898f, -0.05204186f, -0.04496354f, -0.05239587f, -0.00337916f, 
    0.01743388f, -0.03695923f, -0.03774192f, -0.01887009f, -0.01096847f, 0.01516128f, 0.01031910f, -0.00100997f, 
    -0.00512380f, -0.00204156f, 0.02615245f, -0.04553618f, -0.00608951f, 0.02265373f, 0.02653099f, -0.05774761f, 
    -0.01044415f, 0.03461218f, 0.01149292f, -0.02496498f, -0.03709746f, -0.02844177f, -0.03552217f, 0.01040854f, 
    -0.02433775f, 0.00589058f, -0.05449757f, -0.02067432f, -0.05778896f, 0.01954383f, -0.04139316f, 0.03829823f, 
    -0.03343417f, -0.01988364f, -0.04433415f, -0.01303123f, 0.01982445f, 0.02236270f, -0.03586138f, 0.03816143f, 
    0.03618218f, -0.03381348f, -0.03765656f, 0.01685171f, -0.02374173f, -0.00072817f, 0.02355666f, -0.03865883f, 
    0.01520447f, 0.03045638f, -0.00215040f, -0.03789188f, -0.05992669f, -0.02265896f, -0.02237590f, -0.02395685f, 
    -0.03842739f, 0.03460126f, 0.01815043f, -0.05734130f, -0.00971421f, -0.01293596f, 0.01181780f, -0.04894472f, 
    -0.00131639f, 0.00605143f, 0.01604212f, -0.03372156f, -0.01050107f, -0.01458126f, -0.00017116f, -0.05591782f, 
    -0.00926662f, -0.04755456f, 0.02433779f, -0.05758005f, -0.01898481f, 0.00466915f, 0.01006747f, -0.05933974f, 
    -0.00096858f, -0.00428334f, 0.01931082f, 0.02610276f, -0.01504436f, -0.04037715f, 0.03633743f, 0.00172388f, 
    -0.05376855f, -0.00574824f, -0.04315931f, 0.00204037f, 0.02818340f, 0.02538456f, 0.01580627f, -0.04717916f, 
    -0.04192125f, -0.00863236f, -0.05304777f, -0.04523558f, -0.03930106f, 0.02919337f, 0.01377495f, -0.02719178f, 
    0.04030946f, 0.02490101f, -0.02410055f, -0.01625574f, 0.01516006f, -0.02611564f, 0.00803200f, -0.05324370f, 
    -0.00366028f, 0.02447766f, 0.00375553f, -0.00416167f, 0.01184506f, -0.05643911f, 0.03472276f, -0.00093945f, 
    0.01273362f, -0.02189938f, 0.00035674f, 0.00557836f, -0.04948735f, -0.01435174f, -0.01859126f, -0.01339214f, 
    0.03477521f, 0.01436177f, -0.04470252f, -0.04550682f, 0.01737783f, 0.01718404f, 0.01118945f, 0.01616415f, 
    -0.01135509f, 0.02758771f, 0.04547669f, -0.03318091f, 0.03998641f, 0.04000328f, -0.01845255f, 0.01856794f, 
    -0.04772094f, -0.05525735f, -0.01854170f, 0.01122431f, 0.00875390f, 0.02623342f, 0.01498364f, -0.05426664f, 
    0.01204109f, 0.01821791f, -0.01377336f, -0.00511052f, -0.04006029f, 0.04577951f, 0.00500031f, -0.05666973f, 
    0.00068378f, -0.02900090f, -0.02053457f, -0.01213603f, -0.02493266f, -0.04314076f, 0.01727559f, -0.00600977f, 
    -0.02621641f, 0.04129896f, -0.00481636f, 0.01223121f, 0.03982890f, -0.00998470f, -0.02481911f, -0.00422954f, 
    -0.03424330f, 0.01634647f, -0.02277795f, -0.05517241f, 0.00812528f, -0.01818591f, 0.00789300f, -0.03488275f, 
    -0.02124721f, 0.01408829f, -0.04949299f, -0.01657431f, 0.04601383f, 0.04457390f, 0.04380335f, 0.00931216f, 
    0.00995671f, 0.05102761f, 0.04042372f, -0.01290828f, -0.05019610f, -0.01478347f, 0.03383099f, -0.01593626f, 
    -0.01718781f, 0.03638951f, 0.01513105f, -0.00321759f, -0.05383334f, -0.02216236f, -0.01769887f, 0.00455044f, 
    -0.04929129f, -0.00944380f, -0.03047279f, -0.01473871f, 0.02927090f, 0.02637920f, 0.00005526f, 0.03365750f, 
    -0.00190826f, 0.00865885f, 0.04965767f, -0.04999143f, -0.05208247f, -0.00177796f, -0.02245148f, 0.01262813f, 
    0.02170049f, -0.04923688f, -0.02932884f, -0.04392481f, -0.00188286f, 0.03046981f, 0.02540102f, -0.03180734f, 
    0.03431468f, -0.00519246f, -0.01213089f, -0.05799219f, 0.01536898f, 0.02489741f, 0.03549591f, -0.02205286f, 
    0.01032810f, 0.03326197f, 0.00340408f, -0.04685533f, 0.03982411f, -0.03018705f, 0.03339867f, 0.03444994f, 
    -0.01238955f, -0.05797855f, 0.01472800f, -0.03355374f, -0.01395003f, -0.00351504f, 0.03890816f, 0.03207666f, 
    -0.00279227f, 0.03848673f, 0.03287378f, -0.01397570f, 0.04220411f, -0.01578713f, 0.00875843f, -0.05656453f, 
    0.03024566f, -0.00412281f, -0.00347227f, 0.04413624f, -0.01257497f, -0.02950137f, 0.03108937f, 0.00093698f, 
    0.00766357f, 0.02067347f, 0.05281230f, 0.00533005f, -0.01293093f, -0.02278163f, -0.03690193f, -0.05470458f, 
    -0.00742509f, -0.03872324f, -0.00424791f, -0.04691271f, 0.04396412f, -0.04964442f, -0.04976340f, 0.02925588f, 
    -0.00223858f, -0.02578703f, -0.03107992f, -0.02366888f, 0.01241883f, 0.02327571f, -0.00174030f, -0.04940252f, 
    0.03521072f, 0.03936193f, 0.00840878f, -0.03741284f, 0.03781357f, 0.00373197f, 0.00152105f, 0.02462693f, 
    0.00831871f, 0.04359573f, -0.00639846f, -0.04694764f, -0.03703979f, -0.04003137f, -0.02051058f, 0.02045909f, 
    -0.02184992f, -0.05211942f, -0.05450835f, -0.04116702f, -0.01351379f, 0.04221427f, -0.04733128f, -0.00424021f, 
    0.02618276f, 0.02186966f, 0.02951448f, -0.02461144f, 0.00768051f, -0.04107141f, -0.04782383f, 0.02246087f, 
    -0.01744282f, -0.03438865f, 0.01203674f, -0.01240794f, -0.02092083f, -0.01459139f, 0.02726250f, 0.02422756f, 
    -0.01811811f, -0.04522605f, 0.00723541f, -0.05477668f, -0.04880806f, -0.01596837f, -0.02165728f, -0.02085709f, 
    -0.04274831f, -0.05058333f, -0.00833785f, 0.04318543f, 0.00092938f, 0.02107858f, -0.02112227f, -0.01349899f, 
    -0.02730748f, 0.02795098f, -0.00101155f, -0.03475012f, 0.03305127f, 0.00300372f, -0.04726209f, 0.03890977f, 
    0.02238534f, 0.00846047f, 0.03769227f, -0.05495247f, 0.00917801f, -0.03080360f, -0.01804167f, 0.02849854f, 
    0.01037737f, 0.01920046f, 0.00076827f, 0.03925528f, 0.01134160f, 0.02792896f, 0.00029945f, -0.02834797f, 
    0.01723003f, 0.01844641f, -0.00344268f, -0.05689889f, 0.02433214f, -0.00662243f, -0.02783220f, -0.04376258f, 
    0.00709285f, 0.03113584f, -0.05096552f, 0.00520770f, 0.00905139f, 0.00132902f, 0.00896962f, -0.02867668f, 
    0.03267348f, 0.01892121f, -0.02434635f, -0.01497464f, 0.02986937f, -0.03100931f, 0.01795034f, 0.04412895f, 
    0.02518226f, -0.02632023f, -0.00642264f, 0.01902952f, -0.00572128f, -0.01296246f, 0.01681585f, 0.04609497f, 
    -0.04695281f, -0.01115530f, -0.01989450f, 0.00013988f, -0.05262727f, 0.00722950f, -0.04866887f, -0.03130190f, 
    -0.04189602f, -0.04310965f, 0.01859742f, -0.01624196f, -0.02094565f, -0.05556954f, 0.00791493f, 0.02397542f, 
    -0.02593672f, 0.04104539f, -0.00666486f, -0.00152222f, 0.01967073f, 0.00860416f, -0.01604148f, 0.02122505f, 
    0.00272765f, -0.01382494f, -0.03604478f, 0.03911142f, 0.02130963f, -0.00534595f, 0.03875236f, -0.03382816f, 
    -0.04045056f, 0.00587528f, -0.02101778f, 0.02059122f, -0.01927708f, -0.05058429f, -0.05099110f, -0.02467154f, 
    -0.03416129f, 0.01854900f, -0.04930355f, -0.03414708f, 0.02304312f, 0.04038375f, 0.00342139f, -0.02502693f, 
    -0.01303836f, 0.02866963f, -0.04362178f, 0.00909527f, -0.04666019f, 0.02025850f, -0.02699410f, -0.02359165f, 
    0.03251448f, -0.01900813f, -0.04018564f, 0.02307614f, 0.04334181f, 0.00460224f, 0.05437827f, 0.01361391f, 
    0.02126267f, -0.03711881f, 0.03694274f, 0.01596944f, 0.00059337f, -0.05379144f, -0.02780840f, 0.03657707f, 
    -0.03954152f, 0.00565731f, 0.03557522f, -0.01096228f, 0.00170649f, -0.05499320f, -0.02325805f, -0.04697613f, 
    0.02651013f, -0.05317506f, -0.02617162f, -0.05183066f, 0.00272953f, 0.01359413f, -0.02149436f, 0.02413145f, 
    0.00599491f, -0.00584572f, -0.05088542f, -0.00609808f, 0.01616266f, -0.03137988f, 0.04195372f, 0.02239066f, 
    -0.04297704f, 0.00605863f, -0.02726709f, -0.00801137f, 0.03615050f, 0.00591336f, 0.02299298f, -0.03678457f, 
    -0.05154610f, 0.01230631f, 0.03839233f, 0.00150696f, -0.02503173f, -0.04329387f, 0.02929920f, 0.01425467f, 
    -0.00357827f, -0.01288765f, -0.00926578f, 0.02054861f, -0.04940248f, -0.02385616f, 0.04021614f, -0.02628550f, 
    0.03815282f, 0.00610793f, -0.05450561f, 0.02755658f, -0.00156668f, -0.03082848f, 0.01191152f, -0.04515975f, 
    -0.03965601f, 0.02412537f, 0.02442676f, 0.04338655f, -0.04264403f, -0.03681546f, -0.03773964f, 0.04034154f, 
    -0.03116864f, -0.04046851f, 0.00010903f, -0.03374357f, -0.04644085f, -0.01682181f, -0.02660474f, 0.04382415f, 
    -0.01829644f, 0.02034978f, 0.01459617f, -0.05054150f, -0.05339148f, 0.02575785f, -0.00702095f, 0.03472925f, 
    0.00778975f, -0.02693660f, -0.05402100f, -0.04054280f, -0.01820110f, -0.01560452f, -0.03488602f, -0.04962758f, 
    -0.04773521f, 0.01246874f, -0.01369745f, -0.03893661f, -0.01063299f, 0.03961392f, 0.04737978f, -0.02631929f, 
    -0.01317462f, -0.00771449f, 0.04503502f, 0.00214746f, 0.00039767f, 0.03559502f, -0.02029494f, 0.01631547f, 
    -0.04663028f, -0.04873996f, -0.00688575f, -0.05063878f, 0.03442809f, 0.01179044f, 0.04237526f, 0.03645657f, 
    0.02242537f, -0.01206541f, -0.05083215f, 0.04423261f, -0.01355931f, -0.00566834f, -0.02903555f, -0.00769553f, 
    -0.04244505f, 0.01225443f, -0.01438143f, -0.00062385f, -0.02756627f, -0.04857197f, -0.01962816f, 0.04562422f, 
    -0.01252608f, 0.00165973f, 0.04328179f, 0.00649354f, 0.04739296f, -0.02012728f, 0.02994869f, 0.00850272f, 
    -0.02998627f, 0.04177710f, -0.01180037f, -0.03778034f, -0.04822481f, 0.00387432f, -0.02064565f, -0.00630029f, 
    0.03832476f, 0.03200467f, -0.01660217f, -0.02270223f, 0.01919719f, -0.00678665f, -0.03175306f, -0.03164286f, 
    -0.00417143f, -0.03162796f, -0.03733233f, -0.04463898f, -0.03422264f, 0.02139069f, -0.01764399f, 0.00850067f, 
    -0.05151361f, -0.01997442f, 0.03510659f, 0.01063036f, -0.05057734f, -0.03497544f, 0.00797996f, 0.02349540f, 
    0.00179244f, -0.05504867f, -0.00176111f, 0.04417247f, -0.01381601f, 0.01744076f, -0.03439117f, -0.02616175f, 
    -0.04184969f, 0.04361581f, -0.01488012f, -0.01431794f, -0.03430795f, -0.03361646f, 0.03761404f, -0.00848951f, 
    -0.03300885f, 0.02048799f, 0.01187440f, -0.01281204f, -0.04574261f, 0.02457873f, 0.02794469f, -0.05411280f, 
    0.01001438f, 0.02659350f, -0.03096662f, 0.01722750f, -0.01653356f, -0.02384780f, -0.01021002f, 0.04984857f, 
    0.03216262f, -0.04820842f, -0.04365984f, -0.01222876f, -0.05389526f, -0.03801781f, -0.01959922f, -0.03945175f, 
    0.03816969f, 0.02694661f, -0.01017037f, -0.05626376f, 0.02726093f, -0.01911552f, -0.04477184f, -0.03633601f, 
    0.01256261f, -0.04444757f, -0.00749831f, -0.01635624f, -0.04194338f, -0.03443522f, -0.01637754f, 0.00854631f, 
    0.03510203f, 0.03107031f, -0.01203954f, -0.02229552f, 0.04347629f, 0.02404685f, -0.03439632f, -0.04572198f, 
    0.01573046f, 0.00208911f, 0.01237283f, 0.03987603f, 0.00031150f, 0.04125678f, -0.04052201f, 0.02059497f, 
    -0.00668642f, -0.02459933f, -0.04890027f, 0.01366861f, 0.01379819f, -0.01402575f, 0.00956592f, 0.02314205f, 
    0.02424859f, 0.03363733f, -0.04388297f, -0.02227062f, -0.01257553f, -0.01243477f, -0.03044337f, -0.02035882f, 
    -0.04128507f, 0.02721339f, -0.02303752f, -0.04109843f, 0.04355499f, -0.05609307f, 0.03812398f, -0.03367247f, 
    -0.02935817f, -0.04587258f, -0.02040356f, -0.03220541f, -0.03111229f, -0.03308585f, -0.03700225f, 0.01277194f, 
    -0.04988019f, -0.04798340f, 0.01512941f, -0.04796299f, 0.04458463f, 0.00509006f, -0.03485339f, -0.00019367f, 
    0.03128538f, -0.01245159f, -0.04006133f, -0.00546237f, -0.00485970f, 0.02869144f, -0.02225594f, -0.04173006f, 
    -0.03252719f, 0.03105665f, -0.04417001f, 0.02143367f, -0.01116989f, 0.03287509f, -0.00869057f, 0.02280443f, 
    -0.04839779f, -0.01073964f, -0.03421033f, -0.04666068f, -0.03243771f, -0.00634971f, 0.02594845f, 0.02139632f, 
    -0.03506493f, -0.02980331f, 0.02891779f, 0.02026218f, -0.05641766f, -0.02572365f, -0.00068707f, 0.03926245f, 
    -0.04516252f, -0.04773631f, -0.03135983f, 0.01349267f, -0.04265093f, -0.03849690f, -0.02621695f, -0.05179935f, 
    0.02474698f, 0.02218349f, 0.03703214f, -0.01712737f, -0.00825606f, -0.01502894f, -0.03672036f, -0.02990330f, 
    0.02780323f, -0.03941325f, 0.01080187f, -0.01280734f, -0.00565323f, -0.02462484f, 0.01890030f, 0.02745820f, 
    -0.03091757f, -0.02535608f, -0.05224388f, 0.01388648f, 0.04371557f, 0.03214819f, 0.03625255f, -0.03332732f, 
    0.01402272f, 0.01235258f, -0.04702172f, 0.01785406f, 0.00605593f, -0.02124124f, 0.01995460f, -0.04402800f, 
    -0.02486042f, -0.04905704f, 0.03968528f, -0.05474910f, 0.02924112f, -0.04507111f, -0.03644029f, -0.02451900f, 
    -0.05204660f, 0.04269234f, 0.03380391f, 0.01443367f, -0.05558783f, -0.01877165f, -0.02260455f, -0.00190557f, 
    0.03787133f, 0.03840300f, -0.03412545f, 0.00335992f, -0.01701527f, -0.03508915f, 0.01903269f, 0.00624762f, 
    0.03045931f, -0.03112607f, -0.03344724f, 0.02965252f, -0.02833300f, -0.04155643f, -0.04172549f, -0.03039008f, 
    -0.05519480f, 0.00903224f, 0.01931414f, -0.03810792f, 0.01967903f, -0.00833813f, -0.00034204f, 0.00093753f, 
    0.01582960f, -0.01052661f, 0.04107901f, -0.00378372f, 0.00213035f, 0.01729746f, 0.02094140f, 0.02120839f, 
    0.01459440f, 0.03016685f, -0.03807071f, -0.00806765f, -0.04858734f, -0.00649689f, -0.03880309f, 0.00252249f, 
    0.03864121f, 0.00654891f, 0.01362221f, 0.04015777f, 0.00210691f, 0.03860501f, 0.01549503f, -0.00741729f, 
    -0.02004833f, 0.01225991f, -0.02873424f, 0.01703717f, -0.05783417f, -0.02731873f, -0.03753672f, 0.03989853f, 
    0.03710637f, 0.00046442f, -0.04643998f, -0.01868677f, 0.01639156f, -0.03975868f, -0.03965759f, 0.03995687f, 
    -0.01817692f, -0.04034959f, -0.05644431f, 0.03467994f, -0.00567136f, 0.00081960f, -0.01165441f, -0.00123519f, 
    0.04365973f, -0.03389813f, -0.04438449f, -0.04288911f, -0.02178264f, 0.02493860f, 0.04847748f, 0.00493814f, 
    -0.04322014f, 0.01819758f, 0.01697828f, -0.05188653f, -0.02770708f, 0.01430097f, -0.01408728f, 0.01801791f, 
    -0.05202183f, 0.02943877f, -0.05169768f, -0.03370553f, -0.03180495f, 0.01645679f, -0.01520270f, -0.01203538f, 
    -0.03958395f, -0.01276351f, -0.02064292f, 0.02100288f, -0.04884849f, 0.03114142f, 0.01626578f, -0.05640438f, 
    0.00291397f, -0.04638870f, 0.00224985f, -0.03593592f, 0.04670329f, 0.03108198f, 0.02603819f, 0.00118639f, 
    -0.03383854f, 0.03126218f, -0.00752544f, 0.02982827f, 0.01448486f, -0.04027792f, -0.02807339f, -0.03741426f, 
    0.02354454f, 0.01056549f, 0.00536508f, 0.00270269f, 0.03664146f, 0.00190065f, -0.04643826f, -0.03025012f, 
    0.01429057f, 0.00034667f, -0.01464036f, -0.00163568f, 0.00048224f, -0.02332968f, -0.05024196f, -0.01431885f, 
    -0.03029197f, -0.01211136f, 0.02464235f, -0.03773358f, -0.03823728f, 0.00962903f, -0.01481479f, 0.04065793f, 
    -0.05044675f, -0.04933558f, -0.03040103f, 0.03721555f, -0.03059550f, -0.04990621f, -0.03311785f, 0.01518330f, 
    -0.02427352f, 0.02898034f, 0.03648133f, -0.04234344f, -0.00496346f, 0.02661605f, -0.03965985f, 0.00462581f, 
    -0.04277352f, 0.03853006f, -0.03455962f, 0.02728976f, -0.00076513f, -0.00684417f, -0.05176327f, 0.04456702f, 
    0.01163921f, -0.05739715f, -0.03431523f, 0.01750273f, 0.03272973f, 0.03132783f, -0.00497972f, -0.00636566f, 
    -0.01935084f, -0.03269510f, -0.00772505f, -0.02000695f, -0.05465849f, -0.05643043f, -0.03817504f, -0.01092710f, 
    -0.02511957f, -0.00954811f, 0.02503465f, 0.01685606f, 0.02814057f, -0.02183781f, 0.03390675f, 0.01002386f, 
    -0.03093603f, -0.00147398f, -0.00789406f, -0.05207532f, 0.00225531f, -0.04517688f, -0.04237988f, -0.01346691f, 
    -0.00528387f, -0.02878965f, 0.00313978f, -0.03849506f, -0.02313738f, -0.00534709f, -0.03350640f, -0.01399620f, 
    -0.04920859f, -0.01091708f, 0.02711855f, -0.05273400f, -0.02677775f, -0.03973338f, 0.01431209f, -0.00235921f, 
    0.02591903f, 0.03999681f, 0.03144060f, -0.01877040f, -0.05562429f, -0.02852247f, -0.04522147f, 0.02141708f, 
    0.01855592f, -0.00800163f, -0.03678156f, -0.00416528f, -0.01809899f, 0.02732548f, -0.01716809f, -0.05595290f, 
    0.01942689f, 0.03429731f, -0.00032968f, 0.02005142f, -0.04620877f, 0.00113632f, -0.00172564f, -0.02163742f, 
    0.01030042f, -0.04839510f, 0.03808261f, -0.05183634f, -0.05819247f, 0.03008160f, -0.05362040f, -0.05267569f, 
    -0.01454600f, 0.01218198f, -0.05377248f, -0.00178492f, -0.00574023f, -0.01528394f, 0.03064393f, -0.00024695f, 
    -0.02474159f, -0.02154781f, -0.03874299f, -0.02057019f, 0.00057213f, -0.03372625f, -0.03535731f, 0.01753421f, 
    -0.01703875f, -0.02845231f, -0.04645422f, -0.03213174f, -0.04266256f, 0.03880968f, 0.01951787f, -0.04213024f, 
    0.04192422f, -0.01742133f, 0.02263745f, 0.01984513f, -0.00440289f, 0.02157435f, 0.01145273f, 0.01356397f, 
    0.00388401f, 0.00164933f, -0.02927780f, 0.02946730f, -0.01202892f, 0.01823571f, -0.01000115f, -0.00348774f, 
    -0.04055744f, 0.03087970f, -0.05511418f, 0.01545584f, -0.00808908f, -0.02957027f, 0.02653801f, 0.04273565f, 
    -0.05136535f, -0.04226208f, -0.02452879f, 0.02277177f, -0.05446233f, 0.00688816f, 0.03384338f, 0.03878663f, 
    -0.05819805f, -0.03902592f, 0.00980980f, -0.00548194f, -0.00505289f, -0.04581261f, -0.04569739f, -0.04891784f, 
    -0.05421878f, -0.04804984f, 0.02987642f, -0.01955781f, -0.03465292f, 0.01494294f, 0.01807859f, -0.02920313f, 
    0.00875508f, -0.00917135f, -0.00012974f, -0.05540783f, 0.03224402f, -0.00280648f, 0.04061882f, -0.01524063f, 
    0.00449818f, -0.04591931f, -0.02760736f, -0.05394584f, -0.04756201f, 0.04024758f, 0.02717027f, -0.04446858f, 
    -0.04281805f, 0.03202050f, 0.02511813f, -0.02347143f, -0.02184352f, 0.03543962f, 0.01931770f, -0.01042940f, 
    -0.04553215f, 0.03326093f, -0.04218759f, -0.05057983f, -0.02747735f, -0.03640941f, -0.03952691f, 0.03906913f, 
    0.02393328f, 0.00763530f, 0.01097989f, 0.03703468f, 0.00586543f, 0.01274391f, 0.02677142f, 0.01291460f, 
    0.02426884f, 0.01218124f, 0.01174703f, -0.01925047f, -0.00114862f, -0.05490572f, 0.03234635f, -0.00340235f, 
    0.03263755f, 0.01184695f, 0.04001566f, 0.02522922f, -0.03790988f, 0.01711274f, -0.05277406f, -0.01675458f, 
    0.03644617f, -0.05734190f, 0.01857569f, -0.04324842f, -0.01932671f, -0.02832036f, -0.04705191f, 0.03654760f, 
    -0.04633665f, -0.02661713f, 0.01906149f, -0.00239308f, 0.00129587f, -0.03801252f, -0.05394242f, 0.01165866f, 
    -0.03139270f, 0.00121579f, -0.05170292f, 0.00498217f, 0.03854408f, 0.02505353f, 0.01716493f, -0.00536402f, 
    0.03587772f, 0.03813363f, 0.00987136f, 0.01969024f, -0.02201634f, 0.02442910f, -0.01185431f, 0.03660384f, 
    -0.04972022f, -0.04532659f, 0.00728973f, 0.01825502f, 0.00655951f, 0.02566136f, 0.03581713f, -0.04158112f, 
    -0.01269373f, 0.00995649f, -0.00331071f, 0.02787677f, -0.02290965f, 0.03665565f, -0.02908338f, -0.01750331f, 
    -0.03181069f, 0.03431213f, 0.03381440f, -0.05080029f, -0.02277896f, 0.03067613f, -0.02073601f, -0.03075024f, 
    -0.04435683f, 0.00021899f, 0.00605298f, -0.04117091f, -0.02360979f, -0.01731953f, -0.03841998f, -0.04914008f, 
    -0.00735321f, -0.03589474f, -0.01568651f, 0.00159367f, 0.01305879f, -0.00009692f, 0.01289115f, -0.04289636f, 
    0.02427234f, 0.02461891f, 0.00285637f, 0.00369405f, 0.00881508f, -0.05388580f, -0.02482297f, 0.01767469f, 
    0.03911367f, 0.01620220f, -0.03390276f, -0.01627330f, -0.01099991f, -0.02580084f, 0.03587138f, -0.01767877f, 
    -0.03383451f, -0.04179596f, -0.01073491f, -0.02263106f, -0.04924991f, 0.04888924f, 0.00505360f, 0.02153741f, 
    0.01782406f, -0.03065708f, 0.00215163f, -0.02588864f, -0.01977301f, -0.03875744f, 0.04015189f, 0.02515202f, 
    0.01995275f, -0.03186867f, -0.00415897f, -0.02948079f, 0.01576114f, 0.01627764f, -0.03285157f, 0.00241370f, 
    -0.00374212f, -0.03725821f, 0.00306630f, 0.00082593f, 0.02458106f, 0.04674251f, 0.01158679f, 0.02237434f, 
    -0.03338502f, 0.01736829f, -0.04751904f, -0.04879481f, -0.02193284f, -0.01271999f, 0.01032963f, 0.00809385f, 
    -0.01645536f, -0.01938744f, 0.02761600f, -0.02795704f, 0.03724393f, 0.00790545f, 0.00421012f, -0.04660300f, 
    0.04757147f, 0.03643260f, 0.04597128f, -0.03620356f, 0.04771757f, 0.03887647f, -0.01652758f, -0.02522129f, 
    0.01982617f, 0.01342464f, -0.01414128f, -0.02490734f, 0.00252464f, 0.01293442f, -0.02453379f, 0.03687177f, 
    0.05544324f, -0.03659908f, 0.03473875f, -0.00732407f, -0.03708833f, -0.00245395f, -0.04390661f, -0.00144069f, 
    -0.01513277f, 0.01795649f, -0.02852063f, 0.04223964f, 0.03505568f, 0.04136866f, -0.04899605f, -0.00171494f, 
    0.02347721f, -0.03644518f, 0.01724649f, -0.06817634f, -0.05567617f, 0.01272791f, 0.02608102f, -0.02470376f, 
    -0.03309353f, -0.03066391f, -0.05059988f, -0.04956738f, -0.00969038f, 0.01047583f, -0.03746400f, -0.03272427f, 
    0.02021953f, 0.02254828f, 0.01212819f, 0.02037517f, -0.00166709f, -0.05257185f, -0.01980860f, -0.02937804f, 
    0.03726484f, 0.03240472f, -0.01519571f, 0.00969136f, 0.01481448f, -0.01280997f, 0.02384763f, -0.01566570f, 
    0.01287593f, 0.01702674f, 0.01448074f, -0.03936360f, -0.02665184f, -0.01057502f, -0.05283513f, -0.00333252f, 
    0.00490539f, 0.04605791f, 0.04448077f, 0.02857877f, -0.04943693f, 0.02329510f, 0.00416201f, 0.00392520f, 
    -0.02750751f, -0.02762831f, -0.02169908f, 0.01368621f, -0.03011465f, 0.00007532f, -0.01437590f, -0.01525579f, 
    0.01960605f, 0.01735254f, -0.03232541f, 0.04257387f, 0.02803439f, 0.04705428f, 0.03246859f, -0.04760058f, 
    -0.02043515f, -0.04889102f, -0.00708282f, 0.02399839f, -0.01442066f, 0.00115888f, 0.02575981f, 0.01625504f, 
    0.01415004f, -0.01367987f, 0.03949964f, -0.04594664f, 0.03071926f, 0.02324745f, -0.01364535f, -0.06045507f, 
    0.02448315f, -0.05105105f, -0.00592230f, 0.04128885f, -0.04644979f, 0.03494599f, -0.02520864f, -0.02132986f, 
    -0.00344769f, -0.04513724f, 0.03197931f, 0.01417048f, 0.03308197f, -0.03723335f, 0.00482982f, 0.01237706f, 
    0.00925435f, -0.04667609f, 0.05002946f, 0.00867744f, 0.02769879f, 0.02399007f, -0.03151145f, 0.01648979f, 
    -0.00185990f, -0.00837163f, 0.00413225f, -0.05239597f, 0.00479402f, 0.01695205f, -0.04616920f, 0.02436605f, 
    -0.02049930f, -0.03149166f, 0.02426754f, -0.01392019f, -0.03553915f, 0.02977238f, -0.00249423f, 0.04683153f, 
    -0.05865240f, -0.04579843f, 0.02931092f, 0.02546065f, -0.04025809f, 0.01919006f, -0.05879551f, 0.02114007f, 
    0.03987642f, 0.03050493f, -0.00691835f, -0.00637288f, 0.00747570f, -0.06409751f, -0.00607499f, -0.00439143f, 
    -0.03585752f, -0.04565913f, -0.03000248f, -0.03439244f, 0.02028911f, 0.00611665f, 0.04362930f, 0.02837280f, 
    0.01395459f, 0.01838439f, -0.02835370f, -0.01207931f, -0.03217818f, -0.01438778f, -0.00068264f, -0.03213385f, 
    -0.01885665f, 0.01057036f, -0.03933409f, -0.04491849f, 0.00302426f, -0.03813665f, 0.02054922f, 0.01015502f, 
    0.03356344f, -0.01978993f, 0.02305181f, -0.01418188f, 0.00995549f, -0.05805658f, 0.04481954f, -0.01735880f, 
    -0.01869955f, 0.01216589f, -0.01230876f, 0.03297308f, -0.05265439f, -0.04609688f, 0.02903068f, -0.00963730f, 
    -0.03270547f, 0.03738982f, 0.02653744f, -0.02615955f, -0.02460491f, 0.00474147f, -0.04014981f, -0.00684482f, 
    -0.05016983f, -0.04098351f, -0.03630757f, 0.03254727f, -0.00648404f, -0.04916249f, 0.01489145f, -0.04686841f, 
    -0.01766260f, 0.02651054f, -0.02886479f, -0.01238101f, -0.04593673f, -0.02752901f, 0.01741438f, 0.02459651f, 
    0.01554633f, -0.03292109f, 0.02897765f, 0.02470907f, 0.02138733f, -0.04443875f, 0.00898126f, 0.04527171f, 
    -0.04175767f, 0.02754069f, -0.04458320f, 0.03700384f, -0.01066280f, 0.00438997f, 0.02686482f, -0.01633273f, 
    0.02462594f, -0.02860182f, -0.03167402f, 0.03524013f, 0.02600694f, 0.04349540f, -0.00993937f, 0.00855834f, 
    0.03926186f, 0.00399510f, -0.03447208f, 0.00894414f, 0.05199587f, -0.03483879f, -0.02127312f, 0.00613181f, 
    -0.02607731f, 0.00735376f, 0.02563838f, -0.03438650f, -0.02696493f, -0.03231439f, -0.03653044f, -0.02039240f, 
    -0.03108929f, -0.05139058f, 0.00691843f, -0.03486109f, -0.04022670f, -0.04473913f, -0.04851213f, -0.02317093f, 
    -0.01833399f, -0.02356283f, -0.03181443f, -0.02747917f, -0.05486738f, -0.00273522f, 0.03858281f, -0.04389267f, 
    -0.00749420f, 0.04198730f, 0.03202378f, -0.01103338f, 0.04656226f, -0.00634800f, 0.02762983f, -0.04010443f, 
    0.19571945f, 0.27485281f, 0.02293230f, -0.19091663f, 0.13867210f, 0.12989578f, 0.03756905f, 0.03929093f, 
    0.03936011f, 0.02926201f, 0.00192172f, -0.00213151f, 0.00672652f, -0.00782572f, 0.10572132f, 0.02872634f, 
    -0.13096291f, 0.02717991f, 0.10573341f, -0.09200205f, -0.03021611f, -0.03417992f, 0.02345682f, 0.06341987f, 
    0.33694345f, -0.11428381f, -0.07858784f, 0.04141624f, 0.11965518f, 0.12353893f, 0.00010728f, -0.03777466f, 
    -0.04582357f, 0.05824582f, 0.00628583f, -0.01165226f, 0.48547482f, -0.04878999f, -0.08841628f, -0.07017139f, 
    0.05360507f, 0.01667573f, 0.06101880f, -0.03530937f, 0.03259183f, -0.04011685f, -0.10757086f, -0.05797257f, 
    0.15044482f, -0.03186277f, 0.02227831f, 0.42040539f, 0.08864661f, -0.15318915f, 0.03633519f, -0.03349414f, 
    -0.07624145f, -0.15739241f, -0.06700110f, -0.03520234f, -0.13442169f, 0.24296650f, 0.02504176f, 0.04456434f, 
    0.04204163f, 0.12088731f, 0.00295219f, -0.11996961f, 0.02210336f, -0.16280764f, 0.12892053f, 0.03278303f, 
    0.09461842f, -0.00795642f, 0.34098679f, -0.12513664f, 0.10420072f, -0.05997563f, 0.03585137f, 0.08116329f, 
    -0.10358547f, -0.02370957f, -0.03009317f, -0.13348253f, -0.01335279f, 0.02693792f, 0.19810970f, -0.11770728f, 
    -0.05957465f, -0.07441598f, -0.01839170f, 0.05508054f, -0.09556194f, -0.10892066f, -0.02468148f, -0.07359544f, 
    0.15044826f, 0.26199004f, -0.05730665f, 0.25564212f, 0.01434832f, -0.07960214f, 0.05958673f, -0.08594139f, 
    -0.05165039f, 0.00170488f, -0.07145426f, 0.09698519f, 0.20979033f, 0.06916497f, 0.11500696f, -0.04894044f, 
    -0.03131145f, 0.06900170f, 0.05887083f, 0.00310666f, 0.15749882f, -0.07683009f, 0.02215276f, -0.15906268f, 
    -0.07612564f, -0.06223927f, -0.07678142f, 0.19254269f, 0.06474615f, 0.05953565f, -0.01057864f, -0.13425933f, 
    0.00788976f, 0.04305027f, 0.03734847f, 0.23307608f, -0.08774503f, 0.18775795f, -0.09070423f, 0.02076717f, 
    -0.00440625f, -0.04526210f, -0.16512062f, -0.09261774f, -0.11240488f, 0.00861648f, -0.11409879f, -0.01789065f, 
    0.11843193f, -0.05879676f, 0.18694021f, -0.35547361f, -0.17621806f, -0.04889471f, -0.02306491f, -0.06246205f, 
    0.08428689f, 0.03152622f, -0.14289261f, -0.13409425f, -0.12076412f, -0.10640286f, 0.19458055f, 0.15046124f, 
    -0.04626377f, 0.02745892f, 0.18153255f, -0.06556351f, -0.05709502f, 0.02300653f, 0.06040010f, -0.05968634f, 
    0.23375271f, 0.21897690f, -0.06173049f, 0.26245371f, 0.19132741f, -0.00954177f, 0.08491819f, -0.04158525f, 
    0.01877025f, -0.09477086f, -0.01064918f, -0.04262602f, -0.28160870f, 0.01000106f, 0.07337501f, 0.25503159f, 
    0.03525845f, 0.00152658f, 0.06425868f, -0.07823341f, -0.09460563f, 0.01510054f, -0.05242202f, 0.07515825f, 
    -0.02281237f, -0.04510224f, -0.10181463f, 0.01907451f, -0.03421541f, -0.04678807f, 0.02162527f, 0.04728741f, 
    -0.07398364f, -0.06530068f, 0.02560434f, -0.01113234f, -0.06310130f, 0.09888254f, 0.10807254f, -0.15468313f, 
    0.11773114f, -0.06702936f, 0.11350089f, 0.00362113f, 0.02956028f, 0.03434089f, -0.07190912f, 0.16638646f, 
    -0.01714271f, 0.23845212f, 0.13429949f, -0.05025514f, -0.01212442f, -0.00937492f, 0.07555350f, 0.00144823f, 
    -0.01884448f, 0.04570934f, -0.07502169f, -0.17728637f, 0.05839581f, 0.01488296f, 0.14804853f, -0.06900699f, 
    0.07580993f, 0.11904755f, 0.15696207f, -0.07203485f, 0.07249554f, 0.02406260f, 0.05275880f, -0.13310467f, 
    -0.03233646f, 0.22759613f, 0.23243871f, -0.19196479f, 0.04362613f, 0.00099114f, 0.02211498f, -0.02829254f, 
    -0.01584809f, -0.01824934f, -0.07967810f, -0.12061588f, 0.01851773f, 0.25445053f, -0.25257888f, 0.01009839f, 
    0.10311565f, -0.01391759f, -0.01461986f, 0.05466466f, -0.02163643f, 0.01567037f, -0.05653699f, -0.07005710f, 
    0.08109591f, -0.04397342f, -0.06358251f, -0.18276595f, -0.02119920f, 0.10891657f, 0.00793610f, -0.05957083f, 
    0.13176441f, 0.03307858f, 0.05526988f, 0.03702504f, 0.31645170f, 0.12619849f, -0.13425961f, 0.19828331f, 
    -0.02578430f, 0.05135703f, 0.00160739f, -0.03916210f, 0.00679796f, -0.00523770f, -0.02982176f, 0.08683107f, 
    -0.18637216f, -0.17788106f, 0.25527465f, -0.12919807f, -0.05504008f, -0.01917636f, 0.13453263f, -0.07517409f, 
    -0.02583957f, 0.03539025f, -0.10275670f, 0.05199419f, -0.07101591f, 0.35303840f, -0.04502064f, -0.06956774f, 
    0.02139404f, -0.03665663f, -0.06764510f, -0.04442406f, -0.04526387f, -0.07373789f, 0.05611246f, -0.07534043f, 
    0.01944699f, 0.04794071f, -0.14810835f, 0.03538068f, 0.05169801f, -0.01631049f, 0.04057936f, -0.01884937f, 
    -0.01168767f, -0.05066400f, -0.05755843f, -0.01856378f, -0.03800116f, 0.22432810f, -0.15515260f, 0.09591446f, 
    -0.15374972f, 0.00944033f, -0.06286474f, -0.07202696f, 0.00844684f, -0.00754466f, 0.04201065f, -0.16569574f, 
    0.12443805f, -0.12951571f, 0.01890207f, -0.19370657f, 0.11985079f, -0.07525478f, 0.00970362f, -0.00427880f, 
    -0.13558683f, 0.02512549f, 0.11856309f, -0.02619942f, 0.08109184f, 0.19146089f, -0.08380440f, 0.24275814f, 
    0.08903152f, 0.09239407f, -0.02919649f, 0.02115403f, 0.10809234f, -0.13821512f, 0.00423684f, -0.04862044f, 
    -0.20746441f, 0.07064007f, -0.05681933f, 0.02207142f, 0.04910685f, -0.06581885f, 0.07713675f, -0.14485313f, 
    -0.08365495f, 0.03043802f, 0.00518647f, 0.00522058f, 0.31583193f, -0.04130403f, 0.10325298f, 0.08929003f, 
    0.00832561f, 0.01814007f, -0.06871399f, 0.00541051f, 0.03790416f, 0.15405124f, 0.02537183f, -0.10074908f, 
    0.04789468f, 0.20211358f, 0.01225815f, -0.05762487f, 0.11215366f, -0.00248336f, 0.17851627f, -0.10871693f, 
    0.17779860f, 0.29876408f, -0.15477683f, 0.09149145f, -0.15849511f, -0.08084917f, 0.18439424f, -0.01959904f, 
    0.17312439f, 0.13718973f, 0.01984496f, 0.02433764f, -0.02067262f, 0.09352139f, 0.03112779f, -0.12339964f, 
    0.26921383f, -0.19561213f, 0.17582604f, 0.12660155f, 0.00406366f, 0.28447995f, -0.14632066f, 0.22417778f, 
    -0.00400713f, -0.15969999f, 0.08357941f, -0.04077544f, 0.17113712f, 0.14744328f, -0.15405247f, -0.09323172f, 
    -0.00845458f, 0.06942938f, 0.06435716f, -0.16674769f, 0.08625047f, -0.17816861f, -0.09610945f, -0.08667471f, 
    0.40242967f, -0.45987529f, 0.29531893f, 0.02193973f, 0.11915339f, -0.01824262f, 0.06616406f, 0.03948554f, 
    -0.03384645f, 0.00455591f, -0.06732483f, -0.10930083f, 0.06550128f, 0.12984809f, -0.05753607f, 0.03730098f, 
    -0.13274607f, 0.15896305f, -0.09039944f, 0.01403691f, 0.07260802f, 0.04926954f, 0.25068074f, 0.42492163f, 
    -0.07234707f, 0.19174227f, 0.00819950f, -0.06357085f, 0.12107552f, 0.05803802f, 0.00663568f, 0.01127926f, 
    -0.01525354f, 0.02311847f, 0.01859899f, 0.00142930f, 0.04635051f, -0.03325950f, -0.00919646f, -0.05035254f, 
    0.08866467f, -0.03136574f, -0.06935764f, -0.33722383f, -0.17485718f, -0.10092847f, -0.02009813f, -0.04553391f, 
    0.10618779f, 0.15489343f, 0.04928236f, -0.12586527f, 0.09398247f, 0.08972292f, 0.06502028f, 0.00582040f, 
    -0.01216475f, 0.14181502f, -0.05685369f, 0.11928674f, -0.04438503f, -0.11286203f, 0.08304313f, -0.00592702f, 
    0.04700290f, 0.09091290f, -0.17426483f, -0.05626506f, 0.05720516f, -0.06953669f, -0.06267407f, -0.29140860f, 
    -0.09496730f, 0.01193439f, 0.01457433f, 0.20408462f, -0.14876537f, 0.12887855f, 0.05922318f, -0.01189110f, 
    0.11523804f, 0.12829903f, 0.11650076f, 0.05145889f, -0.05524458f, 0.10915545f, 0.08726420f, 0.07408814f, 
    0.01272237f, 0.08681450f, -0.11996791f, 0.16260371f, 0.00069550f, 0.01575302f, -0.16056795f, -0.27694938f, 
    0.19119021f, -0.07062335f, 0.06653076f, 0.30846402f, 0.05606732f, 0.18433578f, 0.05061601f, 0.09245171f, 
    0.11086648f, -0.03660271f, 0.01815159f, -0.22582118f, 0.19335972f, -0.17201224f, -0.08078934f, 0.05165792f, 
    0.11647417f, -0.02301772f, 0.04936724f, 0.00770179f, 0.04467778f, 0.00489163f, 0.06908569f, 0.02226908f, 
    0.10873754f, -0.06074916f, 0.04428909f, 0.09351607f, -0.09746525f, -0.12401080f, 0.02727187f, 0.05512100f, 
    -0.38028809f, 0.21508043f, 0.08400196f, 0.13962853f, 0.32689363f, -0.18856043f, -0.12397519f, -0.10012834f, 
    0.19699864f, 0.07111186f, -0.09414337f, 0.15300386f, 0.01399847f, -0.00068551f, -0.15469572f, 0.01020746f, 
    -0.06365393f, 0.31319806f, 0.03803463f, 0.04299024f, 0.13388947f, 0.06017167f, 0.00692278f, -0.04501717f, 
    0.02399291f, 0.08567719f, -0.16403040f, -0.06217185f, -0.08347604f, -0.03495599f, -0.12755965f, 0.16443697f, 
    0.06350389f, -0.11978287f, 0.02617947f, 0.04131168f, 0.05941228f, 0.05170892f, 0.05166255f, 0.05852457f, 
    -0.31059894f, -0.05668486f, 0.18214513f, -0.03869646f, 0.11916973f, 0.01916940f, 0.09227854f, -0.07353837f, 
    -0.05587428f, -0.15149786f, 0.05813394f, 0.05982433f, -0.09369580f, 0.04234426f, 0.15085454f, 0.06576554f, 
    -0.01533528f, -0.18261443f, 0.02751457f, 0.13512582f, 0.01896697f, 0.13754071f, 0.27433598f, 0.17738575f, 
    -0.17649667f, 0.33802712f, -0.04030628f, 0.01412411f, 0.08871353f, -0.07448479f, 0.10558439f, 0.00182991f, 
    0.03694478f, -0.10628449f, 0.30315173f, 0.02013685f, -0.06825141f, 0.11144453f, 0.13390957f, 0.30967450f, 
    -0.11185201f, 0.10934030f, -0.03650081f, -0.01400073f, -0.05408153f, 0.06327439f, 0.22923769f, 0.10378347f, 
    0.05682876f, 0.01409972f, 0.06344195f, 0.12684257f, 0.13454928f, -0.10515673f, 0.10054290f, -0.11266714f, 
    -0.05658657f, 0.23451188f, 0.08084980f, 0.38188905f, -0.07315342f, 0.05357159f, 0.17062472f, 0.15709797f, 
    -0.01990165f, 0.12025055f, -0.07229818f, 0.22788611f, 0.12875116f, -0.10399012f, 0.23114964f, 0.15654339f, 
    -0.04149616f, -0.00939131f, -0.08962746f, 0.13371290f, 0.12100961f, 0.01402831f, 0.01392135f, 0.08992082f, 
    -0.07963381f, 0.08103054f, 0.13918507f, 0.03395971f, 0.13593678f, 0.27479172f, 0.13727039f, -0.03772092f, 
    -0.02087590f, -0.10556667f, 0.03465074f, 0.16847159f, 0.01866181f, -0.15222207f, 0.11531358f, -0.14105161f, 
    0.02916890f, 0.01407217f, -0.13535845f, -0.09234405f, 0.03326388f, 0.07700092f, -0.00301548f, -0.15336931f, 
    0.09093226f, 0.10985786f, -0.31519172f, 0.01039912f, 0.30768788f, 0.04579739f, 0.00798361f, -0.06322327f, 
    -0.03427667f, 0.08928035f, 0.00961982f, 0.02360428f, -0.01424957f, 0.01564635f, -0.05004177f, 0.05399508f, 
    0.33274230f, 0.05525045f, 0.03720658f, 0.08110700f, 0.06877065f, 0.03237455f, -0.11756517f, 0.20801371f, 
    0.03299489f, 0.08365461f, 0.31552258f, 0.25182304f, 0.08693484f, 0.30702814f, 0.23780029f, -0.03339657f, 
    -0.06626296f, 0.14039187f, 0.07004860f, 0.17785540f, 0.02096470f, -0.09426527f, 0.00576742f, -0.15510531f, 
    0.25164750f, -0.07862942f, -0.08963810f, -0.00340740f, 0.19004937f, 0.03734210f, -0.04915867f, 0.33868563f, 
    0.12954687f, -0.10686705f, 0.21149100f, -0.03495863f, 0.11519124f, -0.06851191f, -0.03676692f, -0.02938160f, 
    0.21332245f, 0.02538510f, -0.01265759f, -0.06064096f, -0.24460950f, -0.01749087f, 0.05471836f, -0.06381599f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04124766f, -0.03316456f, -0.00333960f, 0.00446141f, -0.03636608f, -0.00574860f, 0.02138864f, 0.04281517f, 
    -0.00340704f, -0.05417693f, -0.00177918f, 0.01960404f, -0.00399879f, 0.01208792f, -0.02309084f, -0.01799345f, 
    0.13462876f, 0.16184722f, 0.00346584f, -0.01418152f, -0.00643491f, 0.07837684f, 0.01664549f, 0.05917984f, 
    -0.04600418f, -0.02240543f, -0.00100395f, -0.03594889f, -0.05615997f, -0.01002027f, -0.01127950f, 0.02226283f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.10160588f, 0.04710599f, 0.12327074f, 0.32984132f, -0.16748777f, -0.05271752f, -0.29109225f, -0.07958195f, 
    -0.02753197f, -0.22681624f, 0.47580206f, 0.17321824f, 0.45651785f, 0.04970539f, -0.27644959f, -0.12745385f, 
    0.18763502f, 0.17896309f, -0.09366316f, -0.05414016f, -0.14778243f, 0.14432406f, -0.09735999f, 0.30911642f, 
    0.01588956f, 0.09393484f, -0.04289193f, -0.08215538f, 0.12282518f, 0.12039454f, -0.01339562f, -0.19693393f, 
    0.12496097f, 0.14706156f, 0.12981282f, -0.11532459f, 0.06045580f, 0.14883839f, -0.05875456f, 0.12768437f, 
    0.03847311f, -0.09646627f, -0.05540085f, 0.04560165f, -0.02533947f, 0.02677645f, 0.00024352f, 0.13892965f, 
    -0.03091303f, 0.03744216f, 0.11018503f, 0.02594587f, 0.04818901f, 0.12136970f, 0.05890974f, -0.20050417f, 
    -0.16488872f, -0.13347830f, 0.00176756f, -0.13977410f, 0.17060924f, 0.06224322f, -0.01401971f, -0.13501467f, 
    0.03522405f, -0.04240894f, 0.08553665f, 0.10579361f, 0.15739328f, 0.00851571f, 0.10418886f, 0.12110642f, 
    -0.45109510f, -0.14384609f, -0.04943600f, -0.11776412f, 0.22001691f, -0.14659801f, 0.25253013f, 0.23322698f, 
    -0.03831830f, -0.07195507f, 0.03995350f, -0.18271528f, -0.14603533f, -0.25650576f, -0.00672538f, 0.15780705f, 
    -0.05146769f, 0.06203416f, 0.09613575f, -0.03497720f, -0.11892753f, 0.00753528f, 0.05012393f, 0.43124276f, 
    -0.15060058f, -0.03746808f, -0.14335860f, -0.04950838f, -0.14765871f, -0.17701589f, -0.19198574f, -0.00929981f, 
    0.01758884f, -0.20381130f, 0.14039782f, 0.01491518f, 0.06918284f, 0.08252230f, -0.11982734f, 0.25244871f, 
    0.37507913f, 0.30277079f, 0.09897015f, -0.02258730f, -0.06180199f, -0.35529956f, -0.12292135f, -0.25429922f, 
    0.10921445f, -0.03123047f, -0.12799518f, 0.14718646f, -0.15996698f, -0.10734988f, -0.33348635f, 0.00534413f, 
    -0.15802075f, -0.07373660f, 0.08587851f, 0.04384142f, -0.00595120f, -0.03702136f, -0.19163950f, -0.03195525f, 
    -0.03009765f, -0.39909494f, 0.22414267f, 0.08187515f, 0.28261060f, -0.02135978f, 0.39779288f, 0.43253195f, 
    -0.18395282f, -0.14518966f, 0.12588036f, -0.01155642f, -0.15134662f, 0.43852028f, 0.06474131f, 0.20315617f, 
    0.24028800f, 0.02375238f, 0.15628694f, -0.04849571f, -0.02295109f, -0.14825283f, 0.01224402f, 0.12948012f, 
    0.08712129f, -0.05437355f, 0.00773639f, 0.14686440f, -0.10250070f, 0.15997344f, 0.01239228f, 0.13162749f, 
    -0.10334139f, -0.27305198f, 0.30928341f, -0.00813291f, 0.25145397f, 0.01926033f, 0.06403116f, 0.05413013f, 
    0.20522778f, -0.07823641f, -0.04664626f, -0.08780090f, -0.01072546f, -0.04174159f, 0.16528346f, 0.42906222f, 
    0.09918536f, -0.04994332f, -0.03894356f, 0.16445968f, -0.10755212f, 0.06839832f, -0.53987527f, 0.12584274f, 
    -0.07988375f, -0.16364576f, 0.18081485f, 0.12521818f, -0.08673247f, -0.06322899f, -0.41451722f, -0.11927702f, 
    -0.24671134f, 0.05054066f, -0.49270952f, -0.03536036f, 0.22674049f, 0.01831689f, 0.04938224f, -0.45364603f, 
    0.18191639f, 0.20259619f, -0.14563347f, -0.05861990f, -0.00630017f, -0.26815051f, 0.04166882f, 0.27237928f, 
    -0.17092624f, -0.04405210f, -0.14220716f, -0.01575085f, -0.08736801f, -0.06353199f, 0.36772704f, 0.25787693f, 
    0.11867097f, -0.15160768f, 0.04888418f, -0.35983729f, -0.08639657f, -0.06287945f, 0.19827011f, 0.16749956f, 
    -0.47271287f, -0.11960439f, -0.06959951f, -0.12052642f, 0.25734672f, 0.09689488f, 0.25104585f, 0.07699650f, 
    -0.03890927f, 0.27032849f, 0.12850036f, 0.02465134f, 0.02368519f, 0.53225851f, -0.18307084f, 0.37147126f, 
    0.60438365f, -0.06989063f, -0.09164718f, 0.05266520f, 0.06778967f, -0.10028639f, -0.01867188f, 0.17312351f, 
    0.16137353f, -0.15911549f, -0.16474983f, 0.22035562f, -0.14252330f, -0.08578931f, -0.28587168f, 0.13440856f, 
    0.35165581f, 0.14655007f, -0.24207021f, -0.08007878f, -0.18453313f, -0.02867889f, 0.21137321f, 0.48028666f, 
    0.22253381f, 0.09071184f, -0.08459163f, -0.24081884f, -0.07702478f, 0.01599853f, 0.13607015f, -0.30833399f, 
    -0.20246917f, -0.10165839f, -0.15570806f, 0.00585078f, -0.01456837f, 0.09563603f, 0.28450117f, -0.01772069f, 
    0.17454287f, -0.12742202f, 0.02411274f, 0.24133419f, -0.00195785f, -0.11982279f, 0.11439238f, 0.05593502f, 
    -0.04069076f, -0.12737752f, -0.39203024f, 0.01286448f, 0.04774765f, 0.14462531f, 0.32281193f, 0.37578404f, 
    0.01882652f, -0.17380990f, -0.09217737f, 0.05632721f, 0.16368091f, -0.62737536f, 0.01536368f, 0.10183017f, 
    -0.11584952f, -0.13095175f, 0.11919036f, -0.11512981f, 0.08039079f, 0.16187711f, -0.29696062f, 0.34947965f, 
    0.13947462f, 0.14020979f, -0.12752078f, 0.04645798f, 0.11632589f, -0.11306649f, 0.29569185f, 0.11516369f, 
    0.25090069f, 0.30367503f, -0.07838798f, 0.06715319f, 0.22843762f, 0.09150486f, -0.32617119f, 0.21368626f, 
    0.01022279f, 0.27919838f, -0.10269906f, 0.53493488f, -0.01473824f, 0.02613417f, -0.02364695f, -0.15823659f, 
    -0.14806135f, -0.18472302f, -0.02209627f, 0.12119953f, 0.09261994f, -0.14892092f, -0.18243870f, -0.05334333f, 
    -0.15703280f, 0.05906809f, -0.00222922f, 0.09217676f, -0.06258246f, 0.15267307f, 0.31592816f, 0.02426537f, 
    0.09840573f, 0.17681223f, -0.24699208f, 0.07665022f, -0.43954164f, -0.09760529f, 0.26838684f, -0.59589010f, 
    0.17064080f, 0.13499424f, 0.10839879f, 0.47358057f, 0.04062371f, 0.05010980f, 0.17401613f, 0.39955854f, 
    0.04897023f, -0.08110653f, 0.08816366f, 0.11581654f, 0.16568826f, 0.05030135f, 0.12428646f, 0.18820411f, 
    0.10672374f, 0.16731229f, -0.17482823f, -0.18826503f, 0.13866203f, -0.07255510f, -0.08221570f, -0.15774675f, 
    -0.40862483f, 0.07266856f, -0.43568951f, -0.01146965f, 0.20169410f, 0.05715470f, 0.05442787f, -0.05824256f, 
    0.09212954f, 0.17616288f, 0.14542006f, -0.37611437f, 0.12439081f, -0.33487040f, 0.12549689f, 0.17679170f, 
    0.27943179f, -0.01557989f, 0.05116218f, 0.02207732f, 0.14533907f, -0.12215936f, 0.15218568f, 0.41587389f, 
    -0.06496200f, -0.13999663f, 0.02320290f, 0.29469213f, -0.09999348f, -0.11939321f, 0.03483256f, -0.14590800f, 
    0.03780025f, -0.47323743f, 0.12006249f, -0.05075764f, -0.00261782f, -0.06271955f, 0.16997023f, 0.15036759f, 
    0.30448002f, -0.16853145f, 0.08643518f, 0.13690138f, 0.13381734f, -0.18433398f, 0.11175410f, 0.10484522f, 
    -0.19522177f, 0.16360623f, 0.16323754f, 0.10913418f, -0.02806365f, -0.09104600f, -0.11139007f, -0.20981894f, 
    0.10728366f, -0.03767656f, 0.08897644f, -0.09465938f, 0.03030756f, -0.02612785f, -0.14392997f, -0.10771535f, 
    0.14078221f, -0.02368969f, -0.05413632f, -0.06463235f, 0.12362172f, -0.05565973f, -0.11205138f, -0.14327884f, 
    0.06727558f, -0.15753925f, 0.00509801f, 0.10630153f, 0.13914369f, -0.16352180f, 0.05056031f, -0.15490109f, 
    0.10968558f, 0.02862819f, -0.06655805f, -0.06647805f, 0.11741522f, 0.04804902f, -0.14670494f, -0.06902389f, 
    0.08026283f, -0.09387547f, -0.00548281f, 0.16032620f, -0.08727226f, -0.00410250f, 0.17218645f, 0.15789603f, 
    0.13341497f, -0.17109913f, 0.06018090f, -0.17058319f, 0.05600242f, 0.11607269f, 0.35498485f, -0.20762822f, 
    -0.06244018f, -0.09286737f, 0.07979983f, -0.03178459f, 0.07328831f, -0.12053504f, 0.11580602f, 0.41127542f, 
    -0.17953794f, 0.14967310f, -0.17514943f, -0.10781246f, -0.09908905f, -0.06628146f, -0.31001854f, 0.19709441f, 
    -0.13269633f, 0.14698274f, -0.13695687f, 0.03076715f, 0.14310701f, -0.01934550f, 0.07402786f, 0.12274657f, 
    -0.15962252f, 0.11254698f, -0.01509374f, 0.13000345f, -0.08949945f, 0.14678228f, -0.15417990f, -0.06744549f, 
    -0.19512524f, -0.03988461f, 0.17231479f, 0.08456003f, -0.09816235f, -0.18837884f, -0.02581947f, 0.00719167f, 
    -0.07610639f, -0.13972215f, 0.01312279f, 0.16244435f, -0.02874003f, -0.03621522f, 0.01088698f, -0.00668807f, 
    -0.11215612f, -0.15837325f, -0.03098388f, -0.06947322f, 0.17548738f, -0.07542355f, -0.12577799f, 0.04404761f, 
    -0.04820499f, 0.08640127f, -0.16429184f, -0.06282008f, -0.03084188f, -0.08897052f, 0.06723680f, 0.00040634f, 
    0.03289608f, -0.03592355f, 0.16035867f, -0.00393251f, -0.13808694f, 0.02542416f, 0.14649996f, -0.01684479f, 
    -0.14847186f, -0.08049485f, -0.07904512f, -0.01296226f, -0.10635993f, -0.06566871f, -0.10582861f, 0.03473891f, 
    -0.00291677f, -0.01997234f, 0.00129058f, -0.22401151f, -0.17191544f, 0.16248870f, 0.32029411f, -0.12293538f, 
    0.14455402f, 0.24921761f, 0.56470257f, -0.17979100f, 0.15674362f, -0.08980391f, -0.05021293f, 0.51790559f, 
    -0.06936790f, -0.01073865f, -0.00261541f, -0.11811272f, 0.10184503f, 0.05358446f, 0.01493080f, -0.22139761f, 
    0.31442875f, 0.08246952f, 0.04583511f, -0.01812012f, -0.08359153f, -0.03909054f, -0.05114155f, 0.22551073f, 
    -0.15962607f, 0.10081234f, -0.12129677f, 0.16195750f, 0.11756429f, 0.11572310f, 0.14412622f, 0.05654590f, 
    -0.35478485f, -0.01857925f, -0.37535766f, 0.10925478f, 0.29178289f, 0.12269082f, 0.34721893f, 0.48505974f, 
    -0.08459308f, 0.24358673f, 0.07778782f, -0.19724689f, 0.09041230f, 0.07482978f, 0.04192577f, 0.01382094f, 
    -0.05128301f, 0.02339205f, -0.04324163f, -0.03588054f, 0.14836957f, 0.13427699f, 0.43205750f, -0.12339884f, 
    -0.05210346f, 0.07423695f, 0.05888895f, 0.06618565f, 0.06500404f, -0.01851268f, -0.02023199f, -0.02073220f, 
    0.47666076f, 0.00806092f, 0.23024647f, -0.10398506f, 0.06208626f, 0.10772435f, 0.24363406f, 0.01626998f, 
    0.07029213f, -0.28372279f, 0.15643165f, -0.03816750f, -0.16447142f, 0.01185923f, 0.15589176f, -0.12053506f, 
    -0.00081684f, 0.00229226f, -0.16174336f, -0.12017763f, 0.16323401f, -0.08497540f, 0.57408875f, 0.05308236f, 
    -0.14061794f, 0.05586592f, 0.12511928f, -0.00477331f, 0.13063201f, -0.00860478f, 0.12236834f, 0.10852475f, 
    -0.16854008f, -0.03745274f, 0.50436836f, 0.03332911f, 0.26524001f, -0.14345485f, -0.02511059f, -0.08810248f, 
    -0.25570107f, -0.23397362f, -0.16099773f, 0.32099041f, -0.16786574f, 0.03175020f, -0.16247076f, -0.36567831f, 
    0.27090049f, 0.15237485f, 0.02752279f, -0.11302878f, -0.08124086f, -0.02341727f, 0.38213226f, 0.26807272f, 
    -0.07748919f, 0.15539965f, -0.09105437f, 0.17533033f, -0.10860018f, -0.06196147f, 0.30140814f, -0.14579549f, 
    -0.34758249f, 0.29449454f, 0.08921280f, 0.13768768f, -0.33884841f, -0.14496198f, 0.36537504f, -0.21509673f, 
    -0.13760665f, -0.01643097f, 0.09166922f, 0.15052515f, 0.06644823f, -0.32824236f, 0.08729406f, 0.03598872f, 
    0.12903826f, -0.06360138f, 0.04324668f, -0.05291962f, 0.06749693f, 0.05744139f, 0.16890736f, 0.15895869f, 
    -0.08510592f, 0.12590656f, 0.01713946f, 0.27859631f, -0.15765376f, -0.14154783f, 0.24699849f, -0.10682416f, 
    0.38167447f, 0.17903094f, 0.04441164f, 0.06734028f, 0.04175789f, -0.12525474f, -0.11233769f, 0.00848744f, 
    -0.14356244f, 0.15592335f, 0.00146931f, 0.39478645f, 0.14843862f, 0.25095567f, 0.12419947f, -0.16396724f, 
    -0.08135170f, -0.09769130f, -0.11847699f, -0.11640459f, 0.04964792f, -0.11950175f, -0.19653165f, -0.12800771f, 
    -0.07062562f, -0.04084639f, -0.15613909f, -0.20178585f, -0.17633830f, 0.17177083f, -0.17260189f, -0.11947600f, 
    -0.16793936f, 0.09300379f, 0.08758603f, 0.00701062f, 0.11877042f, -0.15993671f, 0.07571580f, -0.02451915f, 
    0.07536487f, -0.17520078f, -0.15555386f, 0.00734471f, -0.08243141f, 0.05298945f, -0.11249018f, -0.06956315f, 
    -0.18943603f, -0.05883038f, -0.02636819f, -0.09231169f, 0.14268537f, 0.14321095f, -0.19639131f, -0.11266410f, 
    0.14104453f, -0.03693529f, 0.11800870f, 0.35841516f, -0.00194014f, -0.15784389f, 0.04005345f, 0.04923762f, 
    0.22068712f, -0.34689140f, -0.04193323f, 0.09050323f, 0.26763883f, -0.16933867f, -0.38377756f, 0.17147794f, 
    0.33707443f, -0.11195125f, -0.16887590f, 0.20903803f, -0.01890708f, -0.28755504f, -0.15400507f, -0.00382083f, 
    -0.43404564f, -0.09030090f, 0.06547526f, -0.01079753f, 0.11401097f, -0.07936198f, -0.12333434f, -0.12316009f, 
    -0.10913103f, 0.03065710f, -0.13041028f, 0.00304348f, -0.13253602f, -0.09247973f, 0.15803841f, 0.12733504f, 
    0.44913241f, 0.00268024f, 0.14600076f, -0.08819468f, -0.54880041f, -0.08259741f, -0.15134697f, -0.26408145f, 
    0.32608032f, -0.05494902f, -0.04930461f, 0.15591772f, 0.09900355f, 0.14937051f, 0.08271012f, 0.02472356f, 
    -0.09571727f, -0.00534492f, 0.03460821f, -0.01245593f, -0.08673916f, -0.00634226f, -0.21730596f, 0.04813661f, 
    0.01026425f, 0.03660843f, 0.13617888f, 0.20273669f, -0.08430903f, 0.01766762f, 0.29836646f, 0.03827693f, 
    0.12375652f, 0.27134126f, -0.17214780f, 0.14879112f, -0.31406578f, 0.02480894f, -0.05061316f, 0.38378525f, 
    0.01557342f, -0.00851372f, -0.10825802f, 0.21582679f, -0.01872655f, -0.51785105f, -0.00675626f, -0.31374159f, 
    -0.11309437f, 0.09383786f, 0.11209252f, -0.02149966f, -0.03711019f, -0.02569085f, -0.05662803f, 0.33580032f, 
    -0.11647887f, 0.12889220f, -0.06699810f, 0.06991324f, -0.12206170f, -0.10782342f, -0.27013534f, -0.08331218f, 
    0.09583030f, 0.04150192f, 0.05705075f, 0.08696501f, 0.35626587f, -0.03216625f, 0.36064973f, 0.15464650f, 
    -0.15875934f, 0.12039608f, 0.01435365f, -0.23207654f, -0.08031504f, 0.30559868f, 0.09729140f, 0.09951243f, 
    0.21321279f, 0.17569043f, -0.15483308f, -0.13434902f, -0.06810791f, -0.14852348f, 0.06089384f, 0.10283004f, 
    -0.16377118f, 0.08647882f, -0.03686189f, 0.06872556f, -0.06863858f, -0.12602952f, 0.11021027f, 0.16996664f, 
    -0.12726127f, -0.10938378f, -0.18019588f, 0.15216748f, -0.26619685f, 0.15110710f, 0.25885862f, -0.42054582f, 
    0.32203332f, 0.23649235f, -0.17634358f, -0.12556674f, 0.09175552f, -0.12046851f, -0.15753900f, 0.30013657f, 
    -0.24984150f, 0.18233211f, 0.09834705f, -0.12280498f, 0.04077948f, -0.15706576f, 0.17594220f, 0.02601191f, 
    -0.04174712f, 0.13597018f, 0.17120959f, -0.06305359f, -0.17197311f, 0.12281972f, 0.16030467f, 0.16002354f, 
    -0.10958386f, -0.01452923f, 0.10519589f, 0.09114481f, -0.08691236f, -0.14544976f, -0.12140022f, -0.07676867f, 
    -0.16495152f, 0.07282785f, 0.15803045f, -0.08114539f, -0.04783982f, 0.11256710f, -0.01455155f, -0.06147685f, 
    -0.14625627f, 0.16445859f, -0.04269467f, -0.12810868f, -0.04649061f, -0.17357685f, -0.05556802f, -0.09608805f, 
    0.15350863f, -0.11753905f, -0.02240374f, -0.05004084f, -0.01145310f, 0.07261238f, -0.11788528f, 0.10546835f, 
    0.08645539f, 0.12259084f, -0.44428632f, -0.10192328f, -0.41351604f, -0.03763069f, 0.14646718f, 0.00093071f, 
    -0.10146208f, 0.26849538f, -0.14697418f, 0.12213093f, 0.06097233f, 0.09643061f, 0.08524950f, -0.10659231f, 
    -0.00172576f, 0.12685657f, -0.02481319f, 0.00840046f, 0.14262724f, -0.01924040f, 0.48469034f, 0.18187051f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.21418919f, 0.02121533f, 0.05890780f, 0.06027779f, -0.16532698f, 0.13526358f, -0.01852089f, 0.06725895f, 
    -0.05648396f, -0.13172016f, 0.24437703f, 0.10421176f, 0.08393659f, -0.08301821f, 0.02879196f, -0.11654139f, 
    -0.02945750f, -0.12997995f, -0.13297452f, -0.03265282f, -0.31640369f, 0.09946091f, -0.02020542f, 0.12095052f, 
    -0.05240833f, 0.15589102f, 0.00878722f, 0.16956948f, 0.13283211f, 0.15269934f, -0.06343653f, 0.00202234f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.10429918f, -0.08355776f, 0.07949598f, -0.03031094f, -0.28498635f, 0.03166800f, -0.30483276f, -0.25262022f, 
    -0.70504969f, -0.03598586f, 0.07852149f, 0.10260124f, -0.41280329f, -0.01930526f, 0.01489078f, 0.11749515f, 
    -0.11619908f, -0.07566959f, 0.24188536f, -0.53092301f, 0.07930069f, 0.52229464f, 0.31068909f, 0.03779690f, 
    -0.03123104f, 0.04349776f, 0.19303575f, 0.31681690f, -0.54623431f, -0.08369105f, 0.11015415f, -0.43792430f, 
    0.05655745f, 0.15098411f, -0.59825045f, -0.10204979f, -0.00983461f, 0.05943005f, -0.27530628f, -0.24416949f, 
    0.10947428f, 0.02009814f, 0.17637256f, 0.11631719f, -0.53098136f, 0.24369568f, -0.14443906f, 0.06183034f, 
    -0.16724977f, 0.05949826f, -0.24987958f, -0.41517827f, -0.02953686f, -0.76576537f, -0.29618838f, 0.15372990f, 
    -0.12880164f, 0.29338670f, 0.50601912f, 0.13186732f, -0.27003190f, 0.04067557f, -0.14121971f, -0.02078135f, 
    -0.03019315f, 0.09492199f, 0.35167524f, -0.04782926f, 0.16966635f, 0.15476488f, 0.22421087f, -0.42909729f, 
    0.22441605f, 0.55283165f, -0.25944686f, -0.22599179f, 0.05371204f, 0.46727860f, -0.02054758f, 0.20196946f, 
    -0.07685834f, 0.04486717f, -0.54983884f, 0.12880988f, 0.00186567f, -0.46612135f, -0.23510158f, -0.22644089f, 
    0.04120854f, 0.20932633f, -0.31959939f, 0.13981596f, -0.21224491f, 0.09831377f, 0.09161115f, 0.00207611f, 
    0.12138977f, 0.08317957f, -0.11343789f, -0.34628001f, 0.36095351f, 0.23332238f, -0.18407273f, 0.09685130f, 
    -0.38673532f, -0.41258270f, -0.03427171f, -0.03582945f, -0.37186459f, -0.74542803f, 0.06953345f, 0.24362004f, 
    0.05697301f, 0.16827987f, 0.17464952f, -0.31850162f, 0.16741738f, 0.35340396f, -0.22848257f, 0.05279409f, 
    0.01571110f, -0.77773005f, -0.23126993f, -0.95989269f, 0.25827658f, -0.61005080f, -0.17312160f, -0.44053870f, 
    -0.32410330f, 0.10907921f, 0.05887174f, -0.19384804f, 0.23551078f, -0.24179198f, -0.46845698f, 0.20111617f, 
    -0.08873691f, -0.11297899f, 0.25560620f, -0.11682391f, -0.06825210f, 0.11680452f, 0.04008372f, -0.21840408f, 
    0.16673709f, 0.09121874f, 0.13883451f, 0.37780583f, -0.27871752f, 0.18989243f, -0.07774196f, 0.14074545f, 
    0.17427461f, 0.26205361f, -0.60447580f, -0.02935872f, -0.04404915f, -0.52121514f, -0.05653474f, -0.09565309f, 
    -0.38269871f, -0.00206867f, -0.55484033f, 0.10829882f, -0.29455054f, -0.71865916f, -0.17928432f, -0.15628847f, 
    0.34562430f, -0.36277479f, 0.23208338f, 0.09566765f, -0.65610778f, -0.77357632f, -0.11402451f, -0.44945967f, 
    -0.03850743f, 0.17289808f, 0.23060480f, -0.00884628f, -0.02655547f, 0.13578488f, -0.04412527f, 0.27156377f, 
    -0.14511377f, -0.34488177f, 0.12239998f, 0.23662902f, -0.22388884f, -0.13294256f, 0.03381737f, 0.38913840f, 
    -0.46062779f, -0.15797664f, 0.01269545f, -1.01343274f, -0.04152488f, -0.44131690f, 0.16887629f, -0.12779610f, 
    -0.03359394f, -0.13764125f, -0.06853160f, 0.32330951f, -0.16521709f, -0.25185737f, -0.05708582f, 0.30765477f, 
    -0.11765767f, 0.00179033f, -0.30957684f, 0.29009214f, 0.00950953f, -0.24237244f, 0.39030692f, -0.01482576f, 
    0.14090283f, -0.64829504f, -0.25055322f, -0.03042485f, -0.04053759f, 0.35808283f, -0.05499165f, 0.17949454f, 
    -0.11010450f, 0.10424073f, 0.20803121f, -0.07966235f, 0.34996095f, -0.14259762f, -0.29845178f, 0.01898848f, 
    0.41502690f, -0.06502070f, -0.58259380f, -0.40130758f, 0.20342597f, 0.21079046f, -0.13380736f, -0.23259883f, 
    0.00899563f, -0.07174066f, 0.31366259f, 0.22344886f, 0.38258210f, 0.35929945f, 0.00953245f, -0.60460073f, 
    -0.08163174f, 0.07550386f, 0.11033893f, -0.26535881f, 0.13716188f, -0.29080045f, 0.00447576f, -0.10789363f, 
    0.44854859f, -0.13676535f, -0.26685104f, 0.34579283f, -0.41586035f, -0.34381610f, 0.43661842f, -0.61647731f, 
    0.33421269f, -0.31620964f, 0.19034861f, -0.28621766f, -0.02018345f, -0.15691406f, -0.03213089f, -0.56669712f, 
    0.14208122f, 0.07284627f, -0.32554641f, 0.20534851f, 0.05266189f, 0.08936264f, -0.39817318f, 0.21979691f, 
    0.06410794f, 0.39887345f, -0.47671711f, 0.05001243f, -0.03016140f, -0.14030191f, -0.08993441f, -0.19523543f, 
    -0.55896974f, -0.03228418f, 0.29409415f, 0.23495382f, -0.16041327f, 0.15090497f, 0.15102124f, -0.08313829f, 
    0.10569204f, 0.52430838f, -0.13571994f, -0.13206033f, 0.57841992f, -0.68513072f, -0.04500882f, 0.16301797f, 
    0.02646810f, 0.12115181f, 0.16052938f, -0.05141461f, -0.26144049f, -0.40348175f, 0.02164363f, -0.29779619f, 
    0.00953256f, -0.33575609f, -0.28541154f, 0.34460178f, -0.05575880f, -0.10009004f, -0.12205546f, -0.14077592f, 
    0.35782412f, -0.12824258f, -0.03096760f, 0.41100264f, 0.09583901f, 0.34160686f, -0.14874019f, 0.07787295f, 
    -0.33407950f, -0.26900551f, 0.00329456f, -0.11446805f, -0.29923594f, 0.18609823f, 0.03177526f, 0.08882538f, 
    0.07893745f, -0.05747184f, -0.04555117f, 0.20975578f, -0.66653723f, -0.54150790f, -0.15180121f, -0.10945401f, 
    0.09651385f, 0.00377629f, -0.32133305f, -0.90147555f, -0.02203466f, 0.20667136f, 0.12303748f, -0.67627555f, 
    -0.02680611f, -0.13925502f, -0.08299384f, 0.08233349f, -0.09234992f, -0.13450623f, 0.47049972f, 0.34643638f, 
    -0.25595963f, -1.04761541f, -0.13187513f, 0.19713637f, 0.53094226f, -0.51960284f, -0.14105919f, -0.35975543f, 
    -0.00479852f, 0.15434696f, -0.22965704f, 0.04553887f, -0.34865603f, -0.01345813f, -0.02600083f, -0.33221430f, 
    0.01919011f, -0.48783147f, 0.05330962f, -0.63216764f, -0.08837893f, 0.25079319f, 0.00712786f, 0.31358919f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.11150237f, 0.12984332f, -0.15326747f, 0.11266655f, -0.07957766f, -0.02642214f, -0.01988796f, -0.22533686f, 
    0.04943781f, 0.02210261f, 0.13418734f, 0.07791753f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
