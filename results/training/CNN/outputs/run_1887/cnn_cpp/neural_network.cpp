#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.50726014f, -0.32307822f, -0.01140691f, 0.52122164f, -0.40725660f, -0.23938002f, 0.08153608f, -0.31543913f, 
    -0.31948525f, -0.44591495f, 0.04486503f, -0.88252664f, 0.24241862f, 0.53620625f, -0.61188561f, -0.00850641f, 
    -0.00829774f, -0.34463134f, 0.56381249f, 0.21149570f, 0.34991252f, -0.54422414f, -0.60699046f, -0.42425022f, 
    -0.11375656f, 0.17478766f, -0.29415062f, -0.17385158f, -0.24241003f, -0.23477474f, -0.26505053f, -0.53297579f, 
    -0.39338234f, 0.01876630f, 0.26766464f, 0.35933664f, 0.54833138f, -0.71744597f, 0.18740031f, -0.19186425f, 
    0.04065899f, 0.43184912f, 0.12587258f, -0.04810334f, 0.32684878f, 0.46287999f, 0.12985115f, -0.39302850f, 
    -0.23764116f, 0.44642019f, -0.63247281f, 0.34730032f, 0.37320089f, 0.62319249f, -0.11768571f, 0.54686487f, 
    0.29914895f, -0.22369516f, -0.48116586f, -0.35339734f, -0.36479941f, 0.23057647f, 0.41281042f, 0.34353065f, 
    0.22068958f, 0.10980324f, 0.52231026f, 0.31415328f, -0.33133909f, 0.33095992f, -0.55437249f, 0.19499955f, 
    0.55379891f, -0.34573114f, -0.23788895f, -0.30001527f, 0.01742750f, 0.18518287f, -0.00064537f, 0.17845716f, 
    0.00841764f, -0.35728547f, -0.53533047f, 0.32936949f, -0.08633658f, -0.43560877f, 0.33108562f, 0.35015252f, 
    0.17957814f, -0.21038941f, 0.33931899f, 0.20076662f, -0.65491813f, -0.52088445f, -0.32220316f, 0.02338549f, 
    -0.08828267f, -0.53942788f, -0.03870273f, 0.60247630f, -0.25441891f, 0.11883455f, 0.60569710f, -0.37648642f, 
    -0.05010307f, -0.10439690f, -0.43631247f, 0.33163485f, 0.93242592f, -0.76072031f, -0.44311523f, -0.29217443f, 
    -0.32767630f, -0.04839247f, 0.04250072f, 0.21498075f, 0.14045589f, -0.06879038f, -0.12722905f, 0.87680662f, 
    -0.52835011f, -0.23845008f, 0.38458842f, 0.22532307f, -0.11822842f, -0.15866125f, -0.25194332f, -0.39603284f, 
    0.09585027f, 0.60966837f, 0.45527172f, -0.18056007f, -0.23090146f, -0.46095571f, -0.29650411f, 0.04125731f, 
    -0.04475343f, 0.56365281f, 0.31190881f, -0.49130771f, 0.41262466f, 0.13315721f, -0.18002136f, 0.21851312f, 
    -0.43404675f, -0.29375386f, 0.15885015f, -0.36387548f, 0.64870059f, 0.15861101f, -0.13297211f, 0.24952035f, 
    0.44766361f, -0.41127840f, -0.22719692f, -0.17318363f, 0.59236515f, -0.45381775f, -0.37486154f, -0.21194273f, 
    0.18005842f, -0.02325443f, 0.34445578f, 0.48846593f, 0.01431723f, -0.36946645f, 0.52400327f, 0.20772992f, 
    -0.10532686f, -0.60768312f, -0.29998940f, -0.46509272f, 0.90918416f, -0.69498366f, 0.11974008f, -0.16943619f, 
    -0.16987103f, 0.21281537f, 0.12411179f, 0.16119434f, 0.85441101f, -0.49613753f, 0.04424686f, 0.01071144f, 
    0.35804889f, -0.51419455f, 0.30280295f, -0.10605531f, 0.02844866f, 0.71762896f, -0.59694922f, 0.40043387f, 
    0.19468980f, 0.28165647f, -0.19791125f, -0.11832794f, 0.17342208f, 0.20491602f, 0.63164461f, 0.60378581f, 
    -0.21947260f, -0.46718049f, -0.38095799f, 0.39993617f, 0.17216907f, -0.11430348f, 0.06064166f, -0.18727668f, 
    0.59522820f, 0.03548550f, -0.61672962f, 0.26970702f, -0.11195590f, 0.20274559f, 0.36543438f, 0.03506233f, 
    0.45868376f, -0.66006488f, 0.09549505f, -0.41161418f, 0.88368714f, -0.49394667f, -0.04718474f, -0.05762947f, 
    -0.19152957f, -0.13218147f, -0.08463795f, 0.05410417f, 0.11351345f, 0.36038670f, 0.23985109f, 0.41118017f, 
    0.41148049f, 0.26769215f, -0.63888729f, -0.21775870f, -0.21181136f, 0.10583588f, -0.25037566f, 0.10791774f, 
    0.43550757f, 0.17286459f, 0.34954655f, -0.59993750f, -0.45970550f, 0.44461578f, -0.38412997f, -0.08762245f, 
    -0.68927187f, 0.37547946f, 0.10836665f, 0.13431765f, -0.46347052f, -0.65869099f, -0.68337190f, 0.67464048f, 
    0.38471839f, 0.43544176f, -0.01988253f, -0.20637900f, 0.49246046f, -0.68999070f, -0.66154242f, 0.65673703f, 
    0.15714510f, 0.37096274f, 0.54212475f, -0.21020354f, -0.07575476f, -0.27867454f, 0.23435597f, 0.31581041f, 
    0.30564237f, 0.37543839f, -0.42228809f, -0.31336379f, -0.13301902f, -0.23818611f, -0.33436117f, 0.42272073f, 
    0.56205904f, -0.23490524f, -0.30922592f, 0.28079814f, -0.08342541f, -0.47612992f, 0.35596064f, 0.03810196f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.17869055f, -0.18938671f, 0.10197614f, 0.10654857f, 0.06994934f, -0.04041149f, -0.24828155f, -0.35989410f, 
    0.32090873f, 0.13636744f, -0.16811496f, -0.00407728f, -0.10959064f, -0.09314972f, 0.05335877f, 0.11572353f, 
    0.11266562f, -0.03520993f, -0.04887270f, -0.16775769f, -0.09944190f, 0.26135996f, 0.00658526f, 0.10284118f, 
    -0.21818374f, -0.18561521f, 0.06807789f, -0.16436316f, 0.22799850f, -0.30852789f, 0.17086671f, 0.35568923f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.01311783f, 0.03750382f, 0.06251974f, 0.07391379f, 0.01876755f, 0.03339700f, 0.06429873f, -0.04461318f, 
    0.05302529f, 0.09434028f, -0.02696648f, 0.06798193f, 0.03619399f, -0.02702677f, 0.03476130f, -0.03244087f, 
    0.08055289f, 0.02784082f, 0.07823388f, 0.02209601f, 0.00511806f, 0.01116672f, -0.00189888f, 0.02234634f, 
    0.05051788f, -0.02313636f, 0.03888323f, -0.02526790f, 0.01003036f, 0.06301608f, -0.00182807f, -0.01514291f, 
    0.00908317f, -0.03887651f, 0.04860680f, 0.01679496f, -0.03703388f, -0.07493970f, -0.00644897f, 0.07066423f, 
    -0.04832653f, -0.06454985f, -0.06771768f, -0.08277786f, -0.12186374f, 0.03236142f, -0.05498504f, -0.07205015f, 
    -0.03536641f, -0.00052143f, -0.12833428f, -0.09650905f, -0.07244960f, -0.08979464f, -0.03229396f, -0.03574831f, 
    -0.00968998f, -0.00598127f, -0.06693230f, -0.06567144f, -0.07761817f, -0.04215062f, 0.02409300f, -0.07387695f, 
    -0.05600301f, -0.04440982f, -0.05316133f, -0.01013635f, 0.00307927f, -0.01926021f, -0.09138602f, -0.04689670f, 
    0.00648268f, -0.05717934f, 0.05591537f, 0.02298382f, -0.02212548f, -0.00034541f, -0.06454835f, -0.08507900f, 
    -0.06853681f, 0.05455523f, 0.06186660f, -0.07404425f, 0.07436251f, -0.00946186f, 0.07675955f, 0.01268271f, 
    0.02593070f, 0.02734419f, 0.01239821f, 0.00965333f, -0.02708932f, 0.00521125f, -0.04963080f, 0.04985740f, 
    0.03149820f, 0.01357468f, 0.05528937f, 0.06569345f, 0.01749901f, 0.07936896f, -0.06436005f, -0.06609423f, 
    0.03201457f, -0.08343630f, -0.02549366f, -0.06057424f, 0.06167507f, -0.10252810f, 0.06786814f, 0.09918565f, 
    0.05256882f, 0.07240985f, 0.01010360f, -0.01263993f, 0.00318744f, -0.00860072f, 0.00798848f, -0.08755043f, 
    0.01493547f, -0.02753394f, -0.05097942f, -0.02656913f, -0.06044587f, -0.03413543f, 0.06621445f, 0.05452958f, 
    0.04048442f, -0.07892647f, -0.07735872f, -0.01099366f, -0.06887054f, -0.02197164f, 0.02816652f, -0.04014824f, 
    -0.02529297f, -0.12489136f, -0.03484712f, -0.02917551f, -0.04076148f, -0.09205403f, -0.06311737f, -0.08815921f, 
    -0.05555205f, 0.02906838f, -0.04749005f, 0.04517192f, -0.08911807f, 0.04026013f, -0.12109267f, -0.05182667f, 
    -0.03965895f, 0.07106166f, -0.04022571f, -0.04016422f, 0.02570982f, 0.02232584f, -0.00002017f, 0.01013161f, 
    -0.03594768f, -0.00342265f, 0.02242839f, 0.03113852f, 0.00009970f, -0.08820620f, 0.00078404f, -0.01277066f, 
    -0.00786029f, -0.03293833f, 0.00890371f, -0.00990418f, 0.07982807f, 0.02488137f, -0.02204561f, -0.07524187f, 
    -0.04273973f, 0.00686115f, -0.03305401f, -0.03424446f, 0.02110201f, -0.00197575f, -0.02918179f, -0.01464846f, 
    -0.00288144f, -0.08513612f, 0.02464635f, -0.02579731f, -0.01342105f, -0.02354499f, -0.01372916f, -0.06461544f, 
    0.00111826f, -0.07641371f, -0.10422724f, -0.08286684f, -0.06692727f, -0.02367505f, 0.03916994f, 0.01069723f, 
    -0.04889807f, 0.00849230f, 0.05516525f, -0.06108658f, -0.05782342f, -0.10115713f, -0.05670961f, -0.00566085f, 
    0.04191978f, -0.05016468f, 0.01486144f, -0.08999726f, -0.07485566f, -0.00089209f, -0.01321249f, -0.11056981f, 
    -0.01072422f, 0.00121703f, 0.06215086f, -0.00181186f, -0.03875968f, 0.05702962f, -0.00620705f, 0.06224738f, 
    -0.06635897f, -0.08709831f, -0.05824591f, -0.05149256f, -0.11737218f, -0.01665909f, -0.03040234f, -0.09758615f, 
    -0.03433355f, -0.00828212f, -0.03299120f, -0.02313784f, -0.10114247f, -0.07915683f, 0.03077774f, -0.01032322f, 
    -0.02778706f, -0.02632374f, -0.06474167f, -0.00940292f, 0.02461347f, -0.07064155f, -0.00463332f, 0.06716543f, 
    0.07552874f, 0.05136343f, 0.01370271f, -0.01220547f, 0.06555533f, -0.00080050f, -0.01786328f, 0.00767504f, 
    0.06604862f, 0.02180215f, -0.01458438f, -0.07835624f, -0.04285304f, -0.03706376f, 0.08995355f, -0.07034292f, 
    -0.04119891f, 0.00287608f, 0.04184577f, -0.05329360f, -0.10809139f, 0.00144496f, 0.02512049f, -0.02128046f, 
    0.04061169f, -0.01486542f, 0.01062141f, -0.01053689f, -0.03019327f, -0.04261493f, 0.03711582f, 0.03678613f, 
    -0.05412878f, -0.04846426f, -0.01354369f, -0.06537174f, -0.01905304f, -0.02969019f, -0.05510646f, -0.12877607f, 
    -0.12590341f, -0.13519301f, -0.02783797f, 0.05568865f, -0.00182318f, -0.10468829f, -0.02207638f, 0.13445833f, 
    -0.13531066f, -0.02336070f, -0.25735608f, -0.42365500f, -0.03318632f, -0.30529404f, -0.21390456f, 0.13466728f, 
    -0.09059324f, -0.08259244f, 0.08528472f, -0.21307895f, -0.18860018f, 0.01259793f, 0.07149680f, 0.07248095f, 
    -0.02007125f, 0.05617068f, 0.01850867f, -0.14816195f, -0.06095867f, -0.09745481f, -0.02592768f, 0.04782657f, 
    0.05782865f, -0.08588883f, -0.08415398f, 0.13102306f, 0.24675727f, -0.07870457f, -0.02448795f, -0.10100248f, 
    -0.06034432f, 0.10406869f, -0.12641507f, -0.01045612f, -0.09168158f, -0.01211336f, 0.15499134f, 0.16207747f, 
    0.08092339f, 0.13200051f, 0.03908276f, -0.01149773f, -0.00009501f, -0.01008299f, -0.27797204f, -0.07271248f, 
    0.09503838f, 0.01626056f, 0.13101143f, 0.03687502f, -0.08890392f, 0.20989984f, 0.19209750f, 0.22930664f, 
    0.11213013f, 0.10176510f, -0.06768756f, 0.01343292f, -0.04778307f, 0.02698124f, -0.15479186f, -0.07151269f, 
    -0.05598435f, -0.08691759f, -0.26185194f, -0.09309177f, -0.10917350f, 0.20363894f, 0.02279646f, -0.01716273f, 
    0.03630485f, -0.30871871f, -0.24925135f, -0.02126591f, -0.03447429f, 0.04990462f, 0.04625873f, -0.03181573f, 
    0.06643339f, -0.08322742f, -0.49186310f, -0.41109425f, -0.28816220f, -0.02057956f, 0.00612921f, -0.09963644f, 
    -0.06198509f, 0.14902712f, 0.00630346f, 0.18083802f, 0.11687906f, 0.14544709f, -0.10635988f, 0.10474682f, 
    -0.07401390f, 0.04465350f, 0.20225666f, -0.20835823f, -0.15077242f, -0.13102345f, -0.06668971f, 0.08361581f, 
    0.13977835f, 0.24920212f, 0.10790926f, -0.00919951f, 0.07973988f, -0.07514322f, -0.14820315f, 0.21654385f, 
    0.00284734f, 0.07990592f, 0.11394500f, -0.19220081f, 0.14643407f, 0.09452438f, -0.07979002f, -0.18658167f, 
    -0.04655905f, 0.06976896f, -0.14316843f, -0.02934689f, -0.05698587f, -0.09022492f, -0.01873071f, -0.01628336f, 
    0.12280541f, -0.02549627f, -0.10384623f, -0.04695024f, -0.12239338f, 0.01503023f, 0.05450250f, 0.04250082f, 
    -0.10504746f, 0.10256542f, -0.02475030f, 0.06569801f, -0.02453141f, -0.02687993f, 0.09281732f, 0.03249482f, 
    -0.15689838f, -0.15326272f, -0.13089199f, 0.10185392f, 0.06264322f, -0.03917335f, -0.18036394f, -0.05916385f, 
    -0.02077072f, -0.06129871f, 0.23133902f, 0.23782207f, 0.29687589f, 0.00210939f, 0.03431826f, 0.20363700f, 
    0.22474124f, 0.08935443f, 0.04752412f, 0.12956543f, 0.11696526f, -0.03712206f, -0.01067241f, 0.00742850f, 
    0.22310950f, -0.15712450f, 0.08145648f, -0.09049106f, 0.34898382f, 0.00947900f, 0.26353651f, -0.09166289f, 
    0.10075261f, -0.03670488f, 0.27531376f, 0.08024738f, 0.07080139f, 0.29696053f, 0.00786282f, 0.12006634f, 
    0.03047980f, 0.01215259f, -0.13744052f, 0.03651755f, 0.14411543f, 0.01714344f, 0.17301771f, -0.13289037f, 
    0.00351935f, 0.10540798f, 0.03551918f, 0.09604048f, -0.13138744f, -0.00629349f, 0.07868222f, -0.10002850f, 
    0.04105863f, 0.20651175f, -0.10374253f, 0.10693964f, 0.05187623f, 0.11248850f, 0.01945728f, -0.02548365f, 
    -0.27005073f, 0.11930926f, 0.10560831f, 0.02668844f, -0.04178979f, -0.10601205f, -0.04293669f, -0.16038345f, 
    -0.07341660f, 0.24295048f, 0.18090029f, 0.10081086f, -0.08571205f, -0.12094606f, 0.00554851f, -0.01541748f, 
    -0.02389380f, -0.04116086f, 0.17645590f, -0.03060806f, -0.07158517f, -0.00340910f, 0.02257574f, 0.15473564f, 
    0.05005249f, -0.06097886f, -0.10407384f, -0.20398241f, 0.19868779f, -0.13955897f, -0.21628313f, 0.05977521f, 
    0.02327685f, 0.08198274f, 0.11742638f, -0.08671656f, 0.27774188f, -0.20586193f, -0.54068232f, -0.16977827f, 
    -0.13654488f, -0.08785284f, 0.09706417f, -0.01717828f, -0.09385606f, 0.17963977f, 0.20358992f, -0.15724950f, 
    -0.19354102f, -0.19181831f, -0.33935153f, 0.22796746f, -0.02839221f, -0.13496242f, 0.22505656f, 0.04966754f, 
    -0.07375535f, 0.10859996f, 0.04118551f, 0.10003191f, -0.04696100f, 0.00785895f, 0.05176585f, 0.06249357f, 
    0.08488254f, -0.06152580f, 0.05503739f, -0.01830335f, 0.04397026f, 0.24007042f, -0.05282106f, -0.02001598f, 
    0.03351197f, -0.05008335f, -0.00097392f, -0.03244488f, 0.00659286f, 0.02328311f, 0.03250320f, -0.03423293f, 
    0.01581959f, -0.04584804f, -0.05144676f, 0.04604066f, 0.03345468f, 0.02003628f, -0.00816009f, 0.04317121f, 
    0.02570778f, 0.01284429f, -0.05530382f, -0.04513369f, -0.01192616f, -0.05316106f, 0.02349303f, -0.06038775f, 
    -0.03480241f, 0.01603320f, -0.03738876f, -0.02494234f, -0.05380675f, 0.03565951f, -0.05017684f, -0.03231413f, 
    0.01552688f, 0.00621948f, -0.05024409f, -0.02977080f, -0.00542069f, 0.01662944f, -0.04035256f, -0.00538908f, 
    -0.02847011f, 0.03619429f, 0.04279953f, -0.05662245f, 0.04305646f, 0.02281897f, -0.01054836f, -0.02148309f, 
    0.05167371f, -0.05223715f, -0.03456300f, -0.04368404f, 0.04418050f, 0.02600642f, -0.04956099f, 0.01224154f, 
    0.02828711f, -0.06688938f, -0.03115529f, -0.01238791f, -0.00591471f, 0.00905722f, -0.05891879f, 0.04610414f, 
    0.04195544f, -0.00450737f, 0.03586917f, -0.03633235f, 0.02320268f, 0.04121060f, 0.01769666f, 0.04744948f, 
    -0.00937105f, -0.05944032f, -0.01624297f, -0.03215878f, -0.01402632f, -0.03124903f, -0.04295541f, 0.02034134f, 
    0.01176028f, -0.01778885f, 0.02896099f, 0.03940461f, -0.00824257f, -0.03290376f, -0.02732782f, 0.00787728f, 
    0.04193305f, -0.02336079f, -0.02701696f, -0.03847820f, -0.01556608f, 0.02327048f, -0.01759721f, -0.05107269f, 
    0.02205240f, 0.03155948f, -0.03792108f, 0.04907651f, 0.02418108f, 0.01635883f, 0.03315429f, 0.00980252f, 
    0.01140676f, -0.02879463f, 0.02650407f, -0.03130594f, -0.06019895f, -0.02341972f, 0.03028391f, -0.06252070f, 
    -0.03931582f, 0.02631790f, 0.03396419f, 0.00723561f, 0.02734592f, -0.05933643f, 0.02202107f, -0.01043750f, 
    0.00477871f, -0.06258650f, -0.04344415f, 0.02676808f, -0.05087394f, -0.05309124f, 0.01351588f, -0.01915045f, 
    -0.03910792f, -0.02559872f, -0.06113864f, -0.03076570f, -0.01953835f, -0.06090472f, 0.01590966f, 0.03934036f, 
    -0.03424696f, 0.01210397f, -0.01580242f, 0.02663127f, -0.04932858f, 0.03143131f, -0.02277059f, 0.00590827f, 
    -0.02283478f, -0.00111742f, 0.03606470f, 0.02675074f, -0.03670972f, -0.05954422f, -0.04368538f, -0.05664239f, 
    0.01072791f, -0.00092139f, -0.00228267f, -0.04253140f, -0.03109617f, 0.02362634f, -0.04373106f, -0.06056046f, 
    -0.00524973f, -0.00888924f, -0.00615732f, -0.01711445f, -0.00168730f, -0.06816740f, -0.02061660f, 0.03351355f, 
    -0.00837543f, -0.00811787f, -0.02210723f, -0.02493983f, -0.02023291f, 0.01171700f, -0.05105598f, -0.01267764f, 
    -0.02190353f, -0.04095147f, 0.01229850f, 0.02870712f, 0.00509384f, 0.02312258f, -0.01724798f, 0.03343499f, 
    0.03338939f, -0.07076816f, -0.02127653f, -0.04567622f, -0.04265643f, -0.06749868f, -0.02556006f, -0.06085735f, 
    0.03945449f, 0.01188362f, -0.06032456f, 0.01257721f, -0.02186595f, 0.05039465f, 0.00986214f, 0.01677069f, 
    -0.00652034f, 0.04336895f, 0.04374178f, -0.03328199f, 0.00587296f, 0.02303949f, 0.04020151f, 0.03664306f, 
    -0.05082277f, -0.04957256f, -0.05703818f, -0.01848629f, 0.01936057f, 0.03123470f, -0.06492149f, -0.05151332f, 
    -0.06174205f, 0.00923760f, 0.03332187f, -0.00990894f, -0.00629232f, 0.02973973f, -0.04946153f, -0.06134134f, 
    0.04566044f, 0.04497966f, -0.02195277f, 0.00531099f, 0.00278053f, -0.04893738f, -0.02098591f, -0.06639251f, 
    -0.01720733f, 0.04871922f, -0.05229378f, -0.04786532f, 0.00704259f, -0.02909364f, 0.02468080f, 0.04016107f, 
    -0.02721399f, 0.04121753f, -0.03006264f, 0.04210364f, 0.02114874f, 0.01328797f, -0.03674631f, 0.00543538f, 
    -0.04026886f, 0.02492393f, 0.04025210f, 0.02010662f, 0.00804666f, 0.02040374f, -0.05365302f, -0.01415822f, 
    -0.01304093f, 0.02357549f, -0.01216096f, 0.01533373f, -0.05517144f, -0.01108754f, -0.00063521f, 0.04665634f, 
    -0.02936458f, 0.04545653f, -0.01338811f, 0.03008478f, 0.00464372f, 0.03139022f, 0.02883156f, 0.04867731f, 
    0.00732465f, 0.03008366f, 0.04599694f, -0.04033995f, 0.00262508f, -0.03054337f, 0.00949797f, -0.01260305f, 
    0.00414246f, 0.02381558f, 0.04338281f, -0.02911677f, -0.00670982f, 0.04355664f, 0.02765362f, -0.05328901f, 
    0.24683248f, 0.32865337f, 0.09218871f, 0.08244357f, 0.10242125f, 0.03190375f, -0.07066797f, 0.10662104f, 
    0.04948118f, 0.25965911f, -0.00140459f, -0.10833669f, 0.22171265f, -0.10905496f, -0.00850846f, -0.04955187f, 
    -0.08955515f, 0.04289396f, -0.17859674f, -0.03506906f, 0.09390407f, 0.04876305f, -0.04647506f, 0.08420753f, 
    -0.07540614f, -0.02957903f, -0.09740022f, 0.15467982f, 0.16167797f, 0.19416595f, 0.05891392f, 0.04686080f, 
    -0.02889003f, 0.06665118f, -0.12003649f, -0.06535165f, 0.06074280f, 0.02055585f, -0.27048883f, -0.07959733f, 
    0.02661628f, 0.14268355f, -0.04739241f, 0.08876343f, 0.00270804f, -0.05683680f, 0.02655989f, 0.09023208f, 
    -0.00115101f, 0.01552639f, 0.08501876f, -0.17337561f, -0.06482630f, -0.26036346f, -0.22122528f, -0.02145452f, 
    0.06990757f, 0.00687980f, 0.12534885f, 0.17886876f, -0.13993305f, -0.03968986f, -0.11203312f, 0.02757860f, 
    0.02722073f, 0.00973702f, 0.07431554f, 0.02506375f, 0.01186313f, 0.08853330f, 0.18256497f, 0.13572416f, 
    -0.04196701f, 0.06695686f, -0.06287611f, -0.01728749f, 0.00257894f, 0.00113578f, 0.02546052f, 0.04273529f, 
    -0.08229093f, 0.02596394f, 0.05488116f, 0.11058325f, 0.13926001f, 0.12812313f, -0.01874490f, 0.01238361f, 
    0.07095722f, -0.10667454f, -0.05012796f, 0.15012759f, 0.15672562f, -0.03300111f, -0.01878372f, -0.01889367f, 
    -0.11262822f, 0.00441735f, -0.04884231f, 0.12124924f, -0.08912032f, -0.03230935f, -0.03851222f, 0.22361712f, 
    -0.05568487f, -0.00741161f, 0.22542910f, -0.09678549f, -0.09237166f, 0.28895643f, 0.12392919f, 0.03423004f, 
    0.06143812f, 0.00817962f, -0.00428230f, 0.07908113f, -0.08491240f, -0.17248252f, -0.28171155f, -0.12910871f, 
    0.06363090f, -0.14750524f, -0.03366312f, 0.14299692f, -0.00486658f, -0.04868601f, 0.28220174f, 0.17746785f, 
    0.03657701f, 0.06545487f, -0.06274752f, 0.00955175f, -0.07682982f, 0.06386434f, 0.02929298f, 0.08521610f, 
    -0.13801466f, -0.14304377f, 0.00447805f, 0.06180396f, 0.03358164f, 0.13289672f, 0.08794568f, 0.02525451f, 
    0.01159003f, -0.16471931f, 0.05657160f, 0.02983101f, 0.04002757f, 0.13006727f, -0.11251736f, 0.10672484f, 
    -0.02583994f, 0.15954569f, 0.11257751f, 0.04765651f, 0.05623303f, -0.04335642f, 0.12348530f, -0.13959940f, 
    -0.13805847f, 0.03748970f, 0.02203414f, -0.11251894f, -0.16718802f, 0.14674006f, 0.08533917f, 0.02179279f, 
    0.13794006f, -0.00583721f, 0.05699078f, 0.05087963f, 0.11802529f, -0.22584787f, 0.18033752f, -0.19291063f, 
    -0.22827625f, 0.06307784f, 0.03616818f, -0.04743582f, -0.13335808f, 0.06948440f, -0.00164524f, 0.12135372f, 
    0.05003932f, -0.04832457f, -0.09668441f, 0.06846020f, 0.03016146f, -0.01234207f, 0.05746824f, -0.03550832f, 
    0.16591822f, -0.01938309f, -0.05159494f, -0.06991450f, 0.02606054f, -0.13663286f, -0.21241103f, -0.10842386f, 
    -0.33981273f, -0.00794120f, -0.19287248f, -0.06751760f, 0.05362638f, 0.10625987f, -0.01937978f, -0.03879948f, 
    -0.09054057f, -0.16268559f, -0.07883973f, -0.13697392f, 0.03597586f, -0.05258992f, -0.23699893f, -0.16683631f, 
    0.04498679f, -0.05682055f, -0.04248845f, -0.00628154f, 0.02761324f, 0.12742831f, -0.05496924f, -0.01338761f, 
    0.07807731f, 0.09433195f, 0.06031033f, -0.07776294f, 0.12614174f, 0.06530551f, 0.03448267f, -0.06286599f, 
    -0.18316619f, -0.23581862f, 0.13155617f, -0.03534738f, 0.12380166f, 0.01845155f, 0.07158843f, 0.05523803f, 
    0.07409718f, 0.02169570f, -0.02018832f, 0.26724663f, 0.12657245f, 0.16971187f, 0.05108386f, -0.05884915f, 
    -0.05462582f, 0.13467468f, -0.02136965f, -0.17750117f, 0.13719903f, -0.05347618f, 0.02495185f, 0.03810358f, 
    0.06488056f, 0.18200585f, -0.06164081f, 0.13933596f, -0.03602714f, 0.51121652f, 0.20396794f, 0.18028305f, 
    0.02632040f, -0.21204273f, 0.06848782f, -0.00388387f, 0.11355393f, 0.06768315f, -0.15304331f, 0.00375221f, 
    0.06992837f, -0.10177616f, 0.01866163f, 0.00081993f, 0.06537738f, -0.02082960f, -0.02315555f, -0.23958927f, 
    -0.05893410f, -0.22396484f, 0.01067360f, -0.08441518f, -0.04314319f, 0.02452131f, 0.03456124f, -0.20589243f, 
    -0.03698590f, -0.02492552f, 0.03639892f, 0.00666540f, -0.06036342f, -0.00618374f, -0.03508472f, -0.03778431f, 
    -0.05548436f, 0.03039413f, 0.02059532f, -0.01103363f, -0.03306271f, 0.02691386f, -0.05882896f, 0.03153588f, 
    -0.05562253f, -0.00664223f, -0.05999825f, -0.06023250f, 0.00769799f, -0.02776582f, 0.05152240f, 0.02601792f, 
    0.00198647f, 0.00656503f, -0.05202240f, -0.03066850f, -0.01395517f, 0.03602364f, 0.01706466f, -0.00874205f, 
    -0.01167671f, 0.02522328f, -0.01133316f, -0.04713966f, 0.03416582f, 0.02463321f, -0.06590838f, 0.00146367f, 
    -0.05749381f, -0.01640672f, -0.01719659f, 0.02873692f, 0.00022624f, 0.02878373f, 0.01002762f, 0.01889110f, 
    0.00901081f, 0.04632865f, -0.00793824f, 0.01380683f, 0.02039439f, -0.05060238f, -0.05401297f, -0.05029447f, 
    0.01609298f, -0.05156192f, 0.01540648f, -0.04797706f, 0.01662295f, -0.00188183f, 0.03354019f, 0.04437499f, 
    -0.01965363f, 0.00767138f, -0.05545743f, -0.03496575f, -0.06557349f, -0.05406384f, 0.03769272f, -0.00055013f, 
    0.04455761f, -0.05591425f, 0.02000594f, 0.03729999f, 0.00804585f, -0.06408336f, 0.03655092f, -0.05602299f, 
    -0.06125246f, -0.05053565f, 0.02397779f, -0.05152105f, 0.01185344f, 0.01461615f, -0.05671564f, -0.01870698f, 
    0.04243048f, -0.03692177f, -0.05362619f, -0.02320487f, -0.04974269f, 0.02111683f, 0.04107547f, 0.03818494f, 
    0.03779381f, 0.00324970f, -0.03501470f, 0.02711987f, 0.03171769f, -0.02092336f, 0.02816453f, 0.04186232f, 
    -0.05383860f, -0.04262342f, -0.00499272f, -0.00258130f, -0.05196351f, -0.03914265f, -0.00278402f, 0.04561700f, 
    -0.01798433f, -0.03374462f, -0.00010606f, -0.01890860f, 0.02736395f, 0.04776588f, 0.02520945f, 0.05243212f, 
    -0.06524681f, -0.00377535f, 0.00208248f, 0.02956460f, -0.02000149f, -0.01296433f, 0.02832144f, -0.03302781f, 
    -0.06674248f, -0.04685989f, -0.05831201f, 0.01065755f, -0.00948241f, 0.02173030f, 0.03095150f, -0.01578689f, 
    -0.03025958f, 0.01869280f, -0.03533776f, -0.04468455f, -0.06043468f, -0.01754030f, -0.03534391f, -0.04354955f, 
    0.02252138f, 0.01629044f, -0.04174219f, 0.04123315f, 0.01241588f, 0.02777353f, 0.02156690f, -0.01749030f, 
    0.03527861f, -0.05649192f, 0.00292263f, 0.04651107f, 0.03828352f, 0.04010760f, 0.00583445f, -0.01005362f, 
    0.02009411f, 0.01468279f, -0.02989770f, -0.04444176f, 0.00551913f, 0.03034163f, 0.01176782f, -0.05626653f, 
    -0.03619326f, 0.01105717f, -0.02787654f, -0.02998869f, -0.00269115f, -0.02470547f, 0.00193333f, 0.01912224f, 
    -0.01910368f, 0.05725739f, 0.04369746f, 0.04685381f, -0.03941029f, 0.01335757f, -0.03101913f, -0.03143960f, 
    -0.00679311f, 0.02718486f, 0.04727831f, -0.05289044f, 0.03657584f, -0.06365018f, 0.01188280f, -0.04093684f, 
    -0.03355721f, -0.01684927f, 0.02861068f, -0.04608402f, -0.05623638f, 0.03765845f, -0.04985479f, -0.04882544f, 
    0.03948243f, 0.04371725f, -0.04853438f, 0.04379264f, 0.02057266f, -0.03044843f, 0.03352838f, -0.05349353f, 
    0.00828781f, -0.00516865f, -0.04928378f, -0.03737560f, -0.05488717f, 0.02607848f, 0.01674124f, 0.02053510f, 
    0.00053601f, -0.03262280f, 0.00123935f, 0.05371232f, -0.03707484f, -0.00523209f, -0.04911922f, -0.01953934f, 
    0.01092389f, 0.03246892f, -0.05596140f, 0.04252261f, -0.02181446f, -0.05953204f, 0.02866797f, -0.00128953f, 
    -0.01016700f, -0.05741644f, 0.03273290f, 0.02936226f, 0.03869925f, 0.03273037f, -0.00152861f, 0.02094550f, 
    -0.05321383f, -0.04974861f, 0.03825052f, -0.05104034f, -0.00675418f, -0.04074663f, 0.04097373f, 0.02052136f, 
    0.04881239f, -0.06303781f, 0.01752000f, -0.01134288f, 0.02150836f, -0.00137114f, -0.01738272f, -0.02479686f, 
    0.01670163f, 0.04977033f, -0.01479664f, -0.06203587f, -0.00596432f, 0.00308298f, -0.04039953f, 0.03280396f, 
    0.02945454f, -0.05462105f, -0.04008148f, -0.01123531f, 0.00501111f, -0.00523201f, -0.02133035f, -0.04337425f, 
    -0.00209950f, 0.03580171f, -0.05496300f, 0.04134178f, -0.03269340f, -0.05480984f, 0.03959286f, -0.01755574f, 
    0.01356849f, 0.00191043f, 0.02225407f, 0.04788504f, -0.06358849f, 0.03987986f, -0.05949531f, -0.02046336f, 
    -0.12664460f, -0.11366442f, -0.42834994f, -0.01575102f, -0.13746120f, 0.05379248f, 0.01369861f, -0.21913141f, 
    0.14753081f, -0.04035541f, 0.31699446f, -0.26539665f, -0.17908402f, 0.14239751f, -0.15097691f, -0.16212431f, 
    0.14702018f, 0.06205292f, 0.13387674f, 0.05710005f, 0.28611469f, 0.04141281f, 0.00979961f, 0.06028547f, 
    0.01031602f, 0.13884626f, 0.08604833f, 0.01539645f, 0.05376436f, -0.04538633f, -0.00730279f, -0.14485225f, 
    -0.07205018f, 0.05098269f, -0.03748213f, 0.22387272f, -0.02741362f, -0.05966771f, 0.00330516f, 0.04038221f, 
    -0.07602021f, 0.15020370f, 0.05860045f, 0.07963023f, 0.13328339f, 0.02275754f, -0.04926297f, -0.03375939f, 
    0.01623032f, -0.03705634f, -0.11246540f, 0.12264051f, 0.15061232f, 0.12960990f, 0.11854894f, 0.02027310f, 
    0.22367127f, -0.16394676f, 0.01732202f, 0.04769739f, 0.01245007f, -0.00903749f, 0.10220931f, -0.00171035f, 
    0.06744258f, 0.08095201f, -0.03522859f, -0.31749186f, -0.14453936f, 0.04436816f, -0.03707911f, -0.12881219f, 
    0.05833938f, -0.18256080f, 0.03904613f, -0.08202778f, 0.17767295f, 0.05628505f, 0.06227538f, 0.05680765f, 
    0.12073315f, -0.14883351f, -0.01349757f, -0.21780200f, 0.01407144f, 0.03661201f, -0.03414511f, 0.07046197f, 
    0.07448248f, 0.19165410f, -0.21198300f, -0.22107102f, -0.09853233f, -0.02805812f, 0.07691675f, 0.05815725f, 
    0.04821677f, 0.01865254f, -0.07408813f, -0.04913646f, -0.11551834f, 0.34161022f, -0.06904586f, -0.02575953f, 
    -0.16119917f, -0.00488632f, -0.13299143f, 0.04098522f, 0.08720684f, -0.34082341f, -0.06588911f, -0.06047099f, 
    -0.03902117f, -0.05247188f, -0.01302505f, -0.14256528f, 0.07962200f, -0.18040679f, 0.31132805f, 0.24464367f, 
    -0.00064177f, -0.15746294f, -0.02015783f, -0.13495670f, 0.19282700f, 0.14872105f, 0.08232586f, -0.00872480f, 
    -0.24736138f, -0.04058061f, 0.06684000f, -0.01486472f, -0.02462016f, -0.05682943f, -0.06394922f, -0.09985157f, 
    0.08264397f, 0.07894571f, 0.09701701f, 0.08066217f, 0.06477584f, 0.07644853f, 0.03433698f, -0.07051892f, 
    -0.02979432f, -0.26093298f, 0.10528401f, -0.04273435f, -0.05510416f, -0.14251527f, 0.22148795f, 0.08424152f, 
    0.09074169f, 0.02104662f, 0.01910756f, -0.26725522f, -0.06056968f, 0.01320552f, -0.08950293f, -0.00818660f, 
    0.03429656f, -0.07313778f, -0.10512089f, 0.28325292f, 0.04970699f, -0.02874455f, -0.18050635f, -0.10836741f, 
    -0.11407658f, 0.07489900f, -0.07989184f, -0.21016574f, 0.29920578f, -0.27767789f, -0.14722404f, 0.10695955f, 
    -0.04871570f, -0.21430476f, 0.28559914f, -0.11895392f, 0.24185337f, 0.08909322f, 0.00778870f, -0.12079462f, 
    -0.02501301f, 0.01852630f, 0.10982168f, 0.14038013f, 0.05371721f, 0.10001326f, 0.08400396f, 0.21774378f, 
    -0.08907844f, 0.07431608f, 0.01846287f, 0.13715120f, -0.04301611f, 0.07539473f, 0.06139833f, 0.01305644f, 
    0.06347579f, -0.07831055f, -0.15551962f, 0.14332089f, -0.09383612f, 0.05884503f, -0.07672888f, 0.12187672f, 
    0.03315118f, 0.23252121f, 0.00343788f, 0.06784962f, -0.01634149f, 0.13092719f, -0.01128774f, 0.00606380f, 
    -0.00933190f, -0.00863336f, 0.01266093f, -0.30355957f, 0.31461549f, -0.11447307f, -0.02800677f, 0.10305290f, 
    -0.16879660f, -0.01767614f, -0.02837986f, 0.07560780f, 0.07448913f, -0.02234714f, -0.08171019f, -0.01825702f, 
    0.02294072f, 0.01540275f, -0.20067580f, -0.22455817f, -0.12500237f, 0.15139580f, -0.02313013f, 0.06653504f, 
    0.23899537f, 0.01537169f, 0.08437861f, -0.19899005f, 0.24827698f, 0.07991318f, 0.01260092f, -0.18729284f, 
    -0.10572139f, 0.02303400f, 0.19856711f, 0.11293668f, -0.24911539f, -0.56360847f, -0.38351640f, -0.01188972f, 
    0.07868130f, -0.05501172f, 0.06741390f, -0.07836699f, -0.03072173f, -0.19280949f, -0.20466381f, -0.26574755f, 
    -0.20750910f, -0.10201854f, -0.08223628f, -0.13061747f, -0.10428863f, -0.23528303f, -0.03168587f, 0.12353215f, 
    0.07142226f, -0.03492682f, -0.13223067f, -0.07462712f, -0.12793079f, 0.16417742f, 0.12347653f, 0.00087456f, 
    0.10414483f, 0.27578142f, 0.08357991f, 0.11160799f, 0.03289687f, 0.06618977f, 0.00089979f, -0.00163395f, 
    -0.05320651f, -0.09221141f, -0.12996383f, -0.12880531f, 0.07998764f, -0.01669986f, -0.06510499f, 0.06039187f, 
    -0.21194126f, -0.13285682f, 0.04702717f, -0.08938183f, 0.10797098f, 0.23318990f, 0.00375488f, 0.21322389f, 
    0.18309723f, -0.09559153f, 0.22630373f, -0.18714343f, -0.08337329f, -0.04012710f, 0.06067492f, -0.06175637f, 
    0.16549630f, 0.19347511f, -0.03576010f, 0.01680108f, -0.04017595f, -0.13793318f, -0.11628889f, 0.04155613f, 
    -0.07512791f, 0.08282609f, 0.04076736f, 0.00686235f, -0.20869608f, 0.04623120f, 0.02708236f, 0.04704474f, 
    -0.00067797f, -0.10009987f, 0.01995367f, -0.31059393f, -0.02195824f, 0.27882665f, 0.08985787f, 0.08362072f, 
    0.09196473f, 0.12050622f, 0.10362035f, -0.05156373f, -0.05279016f, -0.00726811f, 0.10060579f, -0.03517673f, 
    0.19841722f, 0.06945109f, -0.01374295f, 0.15435775f, 0.14709240f, 0.23460691f, 0.15392554f, -0.01003487f, 
    0.02359827f, 0.23422322f, -0.05279561f, -0.05946063f, -0.16956609f, -0.11227094f, 0.15756562f, -0.15358539f, 
    -0.07858484f, -0.02498427f, 0.04637383f, -0.06466379f, -0.06033006f, 0.00492253f, -0.00662779f, 0.01654851f, 
    0.05857632f, -0.17757653f, 0.07331210f, 0.16937119f, -0.27713320f, -0.13244486f, 0.19215360f, -0.00684096f, 
    0.07863424f, 0.01276418f, -0.06272220f, -0.31527990f, -0.29053500f, -0.09099252f, -0.16470957f, 0.01250366f, 
    0.01627734f, -0.00004030f, 0.04119924f, -0.03148143f, -0.18217780f, 0.33452725f, -0.02760132f, 0.00374481f, 
    -0.10141439f, -0.04672051f, 0.11370484f, -0.10076384f, -0.09759855f, -0.17654328f, 0.18635549f, -0.20686160f, 
    -0.14765844f, -0.07936815f, -0.07746962f, 0.08421372f, 0.01839368f, -0.22099952f, -0.00293673f, -0.03484838f, 
    -0.01589684f, 0.16123247f, -0.01328249f, 0.01530549f, -0.07404319f, -0.10362986f, 0.05163158f, 0.09584759f, 
    -0.03421813f, 0.10011879f, 0.10467001f, -0.01058067f, 0.18279350f, 0.16437431f, -0.05217780f, 0.03092315f, 
    0.02917808f, 0.06036356f, -0.07286067f, 0.12727453f, -0.01367108f, 0.02640955f, -0.20950569f, -0.14413381f, 
    -0.11243293f, -0.05454524f, 0.08403923f, 0.12613174f, -0.14787520f, -0.10999531f, -0.03041070f, 0.09669688f, 
    -0.04045075f, -0.07267836f, -0.16627398f, -0.27187574f, -0.27176529f, 0.23345736f, 0.05064403f, 0.07325558f, 
    0.15137154f, 0.03518439f, -0.03275222f, 0.01870292f, 0.04501178f, 0.01881831f, 0.00086897f, -0.12433633f, 
    -0.13083565f, -0.05669510f, -0.07007478f, -0.46592987f, -0.07369734f, -0.12770154f, -0.61966377f, 0.11581342f, 
    0.05844151f, -0.07463402f, -0.18058689f, 0.12792659f, 0.18311341f, 0.01741575f, 0.01693826f, -0.08923019f, 
    0.04979286f, 0.11163966f, -0.05031780f, -0.00892301f, -0.14288430f, -0.05474949f, -0.10851806f, 0.05365060f, 
    0.06795182f, -0.03983661f, -0.02435702f, -0.22598909f, -0.17559958f, -0.09769566f, 0.32870284f, -0.21869759f, 
    -0.22819878f, 0.07022106f, 0.07770199f, 0.16691780f, -0.08977464f, 0.04869291f, 0.07159739f, 0.15096991f, 
    0.23748153f, -0.14585207f, 0.14838254f, 0.04568977f, 0.21754611f, 0.19943683f, 0.11844332f, 0.11899725f, 
    -0.17917538f, 0.08620778f, -0.09426639f, -0.17349426f, -0.10871903f, 0.06014995f, 0.22503887f, 0.06369426f, 
    -0.08396203f, -0.04102925f, 0.07512205f, -0.00154383f, 0.02603446f, 0.01365070f, -0.01199518f, -0.19223636f, 
    -0.10121498f, -0.04528395f, -0.09569059f, -0.14260295f, -0.09361087f, -0.18669996f, -0.18573351f, -0.29769263f, 
    -0.09792258f, 0.01368893f, -0.09765875f, -0.42954209f, -0.08919621f, -0.30424979f, -0.47617224f, -0.04555232f, 
    -0.08851951f, 0.13270436f, -0.10036410f, 0.00670389f, 0.09504385f, -0.08965252f, -0.12738957f, -0.03216749f, 
    -0.18136433f, -0.26481766f, 0.04149297f, 0.07128533f, 0.07840419f, -0.05068254f, 0.27172017f, 0.09254131f, 
    0.17167783f, -0.32612237f, 0.09263327f, 0.24049941f, 0.13312332f, 0.03489253f, -0.09867997f, -0.14961912f, 
    0.22140644f, -0.00809563f, 0.05009190f, -0.12813433f, 0.04407143f, 0.21643572f, -0.01273076f, 0.10099173f, 
    -0.15239504f, -0.01655655f, 0.05657127f, 0.05776911f, -0.01803298f, 0.04366129f, -0.00812928f, 0.04621317f, 
    -0.11597513f, 0.11227779f, 0.09235001f, 0.00989214f, -0.01991411f, 0.05978366f, 0.00266150f, 0.01332443f, 
    -0.26740164f, -0.07318263f, 0.24766225f, 0.17176695f, -0.07294377f, -0.20820832f, 0.04500435f, -0.11334543f, 
    -0.03375110f, -0.04996474f, 0.08876793f, -0.11357883f, -0.30738536f, 0.07880978f, 0.00788697f, -0.02153585f, 
    -0.04507193f, 0.09843832f, 0.03557853f, 0.03415728f, 0.08555190f, 0.07320093f, -0.04782484f, -0.12019712f, 
    0.03997916f, 0.12354390f, 0.09453356f, -0.06526485f, 0.13089627f, 0.00223361f, -0.00410382f, 0.03272871f, 
    -0.01106368f, -0.08138855f, 0.10621544f, -0.03123244f, 0.04243160f, -0.00596424f, 0.06544571f, -0.01963144f, 
    -0.03303977f, -0.15863009f, 0.05898081f, 0.21781334f, 0.08288807f, 0.16833003f, -0.01345259f, -0.38498595f, 
    -0.08044307f, 0.10235176f, 0.01179824f, -0.03834638f, 0.14846155f, -0.02209869f, -0.07935062f, 0.00324054f, 
    0.04979955f, -0.03252795f, 0.00326854f, 0.07584210f, -0.05587425f, -0.08403501f, -0.12025166f, -0.19817920f, 
    0.08544764f, -0.02246295f, -0.11771997f, -0.04209208f, -0.02846585f, -0.05437217f, 0.12829849f, -0.04503321f, 
    0.03840248f, 0.04701333f, 0.11122854f, 0.01417225f, 0.11623673f, -0.11787780f, -0.05416894f, 0.03775616f, 
    0.01478085f, 0.02295028f, 0.03268766f, 0.09722512f, -0.05563959f, 0.01774576f, 0.04325163f, -0.01173140f, 
    0.04283377f, -0.14584009f, 0.01834804f, 0.06092776f, 0.04185234f, -0.19439115f, 0.01028561f, -0.01957828f, 
    -0.06667871f, -0.11407656f, 0.00133716f, -0.17062880f, 0.16580938f, -0.12597144f, -0.27912688f, -0.07602582f, 
    0.01322352f, 0.09560117f, 0.11184950f, 0.07071772f, -0.00653535f, -0.18541031f, -0.17448291f, -0.13056454f, 
    0.13432936f, 0.03695147f, -0.08570883f, 0.01944380f, -0.03152793f, 0.06675250f, -0.00113383f, -0.04198873f, 
    0.11494572f, -0.19513941f, -0.03482624f, 0.03432916f, -0.19663101f, -0.18769354f, -0.16603202f, 0.03804476f, 
    -0.01223013f, -0.00186550f, 0.08394086f, -0.00254192f, 0.01438360f, -0.03275727f, -0.26181865f, 0.20130424f, 
    0.14931460f, -0.00755145f, 0.06090361f, -0.14304514f, 0.06921966f, -0.16664197f, 0.18269023f, 0.14119966f, 
    0.15135601f, -0.07583541f, 0.08321358f, 0.09609375f, -0.05445115f, 0.00518853f, 0.08135474f, 0.01098798f, 
    0.01496621f, -0.08776807f, 0.05037624f, -0.08829226f, -0.02849072f, 0.00167326f, 0.08361127f, -0.07887619f, 
    -0.02666766f, -0.33232766f, 0.10502548f, -0.14812666f, 0.05327535f, 0.05229622f, -0.19175011f, 0.14843556f, 
    -0.00989375f, 0.06490263f, 0.06574796f, 0.18700735f, -0.07933092f, 0.09860502f, -0.08383784f, 0.09792394f, 
    -0.04394237f, 0.06546503f, 0.00945077f, 0.03081990f, -0.03047066f, 0.07295472f, 0.09167247f, -0.08794777f, 
    -0.01745786f, -0.02262501f, -0.03750379f, 0.08543110f, 0.06143125f, 0.08708590f, -0.11857245f, -0.05675631f, 
    -0.09810820f, 0.06997966f, 0.07358251f, 0.03492355f, 0.08290417f, -0.25237298f, 0.01957077f, 0.06624665f, 
    -0.09022012f, 0.06346062f, 0.10040411f, 0.00927398f, 0.02498928f, 0.03790459f, 0.20685256f, 0.09905918f, 
    0.02692906f, -0.10964974f, -0.11173557f, 0.06309668f, 0.03388168f, 0.03865706f, -0.16778611f, -0.24051195f, 
    0.16863379f, 0.10067850f, 0.00548191f, 0.07212952f, 0.12878975f, 0.04606552f, -0.11747090f, 0.14563891f, 
    0.27012524f, 0.10363363f, 0.05240250f, 0.11389379f, 0.03684301f, 0.17692915f, -0.05179938f, -0.11908364f, 
    0.06555407f, 0.14493619f, 0.01754067f, 0.02914815f, -0.09303556f, -0.15658686f, 0.06855068f, -0.16859660f, 
    -0.03899493f, -0.05820148f, 0.06875987f, 0.03557437f, 0.15602532f, 0.12237902f, 0.01132361f, -0.10941683f, 
    -0.10937461f, -0.11155810f, 0.08559111f, 0.07851536f, 0.05541738f, 0.01945297f, -0.33595610f, 0.26672232f, 
    0.06858984f, -0.02751743f, -0.06004649f, -0.01780687f, -0.22422861f, -0.16103566f, -0.00639944f, -0.28298193f, 
    -0.07635545f, -0.00232357f, -0.00044221f, 0.05890282f, -0.09646188f, -0.14156444f, -0.07472064f, 0.14893177f, 
    -0.18161678f, -0.12867025f, 0.06333508f, 0.08458049f, 0.03602028f, 0.05328399f, -0.12608182f, 0.05125991f, 
    -0.02352140f, 0.01680389f, -0.08701575f, -0.03451744f, -0.00732391f, -0.07277864f, -0.05169651f, -0.01612626f, 
    -0.04279637f, 0.03622632f, -0.07283014f, -0.01042623f, -0.07471621f, -0.08382980f, -0.08485063f, -0.06758090f, 
    -0.00350456f, -0.02239693f, -0.08363943f, 0.02800904f, -0.04685056f, -0.03711942f, -0.03368171f, -0.08467888f, 
    -0.00846143f, 0.01667818f, -0.04891065f, -0.04755767f, -0.06458789f, -0.06179035f, -0.04785559f, -0.03379114f, 
    -0.00516921f, 0.00389189f, -0.06939175f, -0.02285701f, -0.07736794f, -0.00711086f, -0.04389337f, -0.04546443f, 
    -0.05723849f, 0.00518172f, 0.00221862f, -0.06929066f, -0.02231481f, 0.02355203f, -0.07414788f, -0.08097509f, 
    0.00787940f, -0.02378128f, -0.04882928f, 0.00790471f, 0.02067658f, -0.02245113f, -0.03585866f, -0.07528391f, 
    0.02099861f, -0.02464228f, -0.03594168f, 0.00908875f, -0.03383454f, -0.02201042f, -0.04481263f, -0.07167265f, 
    -0.08020590f, 0.05179678f, -0.05749439f, -0.08767361f, -0.07135817f, -0.00219192f, -0.05532669f, -0.03825826f, 
    0.00036162f, 0.01936100f, 0.02215342f, -0.06842593f, 0.00534533f, -0.00712094f, -0.08559453f, 0.02338055f, 
    -0.06283575f, -0.03186990f, -0.01635163f, -0.00337662f, -0.01348482f, -0.05669745f, -0.01087082f, -0.07455840f, 
    -0.06757297f, 0.02664495f, 0.01221813f, -0.00821594f, 0.02251099f, 0.00397366f, 0.01474199f, -0.06286290f, 
    -0.04464289f, -0.02050357f, -0.00085543f, -0.04376592f, -0.00224891f, -0.00346143f, -0.01927954f, -0.04675347f, 
    0.02315322f, -0.06426934f, -0.06135193f, 0.01728069f, -0.06661737f, -0.07007623f, -0.07961095f, -0.00312188f, 
    -0.00761154f, -0.05475133f, -0.00679207f, -0.01369758f, -0.02419743f, -0.03370869f, 0.00050586f, -0.08740608f, 
    0.02335532f, -0.07727236f, -0.08277573f, -0.00924567f, -0.08581370f, -0.03939909f, -0.07582342f, -0.06951639f, 
    -0.07833742f, -0.04710560f, -0.07789607f, 0.02353672f, -0.01327360f, 0.02737508f, -0.06602281f, -0.07939439f, 
    -0.03159197f, -0.01249520f, -0.06698553f, 0.01273414f, 0.01724060f, 0.02275039f, -0.03659141f, -0.04804026f, 
    -0.00136375f, -0.03515747f, 0.02200858f, 0.02192616f, -0.07328379f, -0.00561450f, -0.04153767f, -0.06797380f, 
    -0.04876937f, -0.05150801f, -0.02401080f, -0.01128574f, -0.05497880f, 0.01004908f, -0.03811041f, -0.06431735f, 
    -0.03835043f, -0.03193045f, 0.00872372f, -0.06703266f, -0.00319010f, -0.02533508f, 0.01388467f, -0.02508704f, 
    -0.08335031f, -0.04077325f, -0.05815795f, -0.03213989f, 0.01844596f, -0.05124757f, 0.03756061f, -0.05276125f, 
    -0.00940220f, -0.03221229f, -0.07753827f, -0.07474710f, 0.00469119f, 0.01629780f, -0.04169830f, -0.06248202f, 
    -0.04681055f, -0.08143598f, -0.00337962f, 0.02190181f, 0.04164864f, -0.01804176f, -0.06052155f, -0.08420043f, 
    -0.06451833f, 0.02094728f, -0.00476338f, -0.01840905f, -0.02179861f, -0.01710990f, -0.08298068f, -0.01283115f, 
    -0.03939786f, -0.00667686f, 0.01735251f, -0.04232882f, 0.01068297f, -0.00866181f, -0.01326617f, -0.00070577f, 
    0.01226337f, -0.07687072f, -0.08085023f, -0.03302396f, -0.06706868f, -0.07811481f, -0.03307106f, -0.05290009f, 
    -0.03980190f, -0.03001953f, -0.04536679f, -0.05811568f, -0.02089877f, -0.04192585f, -0.01451293f, -0.06621382f, 
    -0.04467805f, -0.06782828f, -0.07272433f, -0.07849033f, -0.03537433f, -0.05298079f, -0.03724184f, -0.07539141f, 
    0.05142442f, -0.05149137f, -0.03306485f, -0.01268821f, 0.00183369f, -0.00427034f, -0.04859659f, -0.01870163f, 
    -0.07926717f, -0.02366924f, -0.00889943f, -0.06720857f, 0.00911577f, -0.07797157f, -0.07036796f, 0.04823657f, 
    -0.05957366f, -0.05903436f, 0.00891810f, -0.08039784f, -0.07816146f, -0.08577745f, 0.00167539f, -0.02712801f, 
    -0.00908355f, -0.01213897f, -0.06334865f, -0.08684612f, -0.07243088f, 0.01951080f, 0.05180834f, -0.06393065f, 
    -0.03751316f, -0.02664392f, -0.05560062f, 0.00010718f, 0.01370888f, 0.00131838f, -0.03224050f, 0.02394961f, 
    -0.03406654f, -0.05350741f, -0.00633538f, -0.01175218f, -0.03791440f, -0.07033902f, -0.05335884f, -0.04018039f, 
    -0.00849803f, -0.03687369f, -0.05764409f, -0.04795581f, -0.05130945f, -0.01496205f, -0.04947540f, 0.01266679f, 
    -0.11545140f, 0.12811074f, -0.08526835f, 0.01170048f, -0.14147796f, 0.23410515f, 0.04516878f, 0.05519845f, 
    0.15193573f, -0.02931800f, -0.21385762f, -0.14513998f, -0.03225467f, 0.03223814f, 0.20409268f, 0.10690701f, 
    0.19328666f, 0.30164254f, 0.17245951f, 0.11456193f, 0.20128620f, 0.07458685f, -0.14390592f, 0.09563290f, 
    -0.11100697f, 0.05246063f, 0.05412812f, -0.17915334f, -0.04543624f, -0.11480096f, 0.04763939f, 0.07008857f, 
    0.06249874f, -0.12056641f, -0.19318865f, -0.05328161f, 0.16495577f, 0.01044460f, 0.09877329f, 0.02621567f, 
    -0.01661927f, -0.07618208f, 0.02142141f, -0.03032174f, -0.20533368f, 0.14218751f, 0.00884715f, -0.01847816f, 
    0.03722947f, -0.01035260f, -0.10859570f, -0.05747458f, -0.19424771f, -0.20601946f, 0.07507224f, -0.00708390f, 
    0.01558084f, -0.04814710f, 0.02691387f, -0.18441211f, -0.25175145f, -0.24569087f, -0.23324494f, 0.18524037f, 
    -0.01171757f, -0.10136423f, 0.32613021f, 0.09798861f, 0.10904071f, 0.02541410f, 0.15974185f, -0.07750190f, 
    0.02365174f, 0.00488492f, 0.09572534f, 0.02943019f, 0.10197510f, 0.01041722f, 0.07952144f, -0.06116712f, 
    -0.08644062f, -0.21032019f, 0.05273223f, 0.05788403f, 0.17140539f, -0.03100142f, 0.04813979f, 0.07232694f, 
    0.05653455f, 0.01888846f, 0.04239635f, -0.03019601f, 0.17244937f, 0.16297190f, 0.09655067f, 0.09476524f, 
    -0.03524860f, 0.08521675f, -0.04513480f, 0.01375608f, 0.11458460f, 0.14640135f, 0.10735648f, 0.26097506f, 
    0.04894697f, -0.02639158f, -0.00373148f, 0.09647486f, -0.02997966f, -0.00005953f, 0.17072591f, -0.02064787f, 
    0.02086139f, -0.05615133f, -0.10672229f, -0.10311710f, -0.17177175f, -0.07166383f, 0.17101063f, 0.05870283f, 
    0.07243279f, -0.00136611f, 0.04867027f, -0.03598407f, -0.02812617f, -0.11021495f, 0.06836438f, -0.03010059f, 
    -0.16178650f, -0.02103029f, 0.13514197f, 0.06334941f, 0.13780421f, 0.16287009f, 0.02696203f, 0.04527123f, 
    0.11829633f, -0.10030333f, 0.06154000f, 0.03017520f, 0.00925395f, -0.03291314f, 0.17899314f, -0.22248656f, 
    -0.02811595f, 0.09728048f, 0.04752007f, 0.03688935f, 0.02150756f, -0.16367474f, -0.22542493f, -0.01755888f, 
    -0.12711599f, -0.10407361f, -0.06595314f, -0.08944041f, 0.00304812f, -0.04336691f, 0.05807682f, 0.06803066f, 
    0.06832960f, 0.06649085f, -0.00289541f, 0.11701301f, 0.18685851f, 0.05702049f, 0.14249139f, 0.02911050f, 
    0.16979651f, 0.07340450f, -0.04128311f, -0.03314403f, -0.09098419f, 0.20989512f, 0.11547868f, 0.07090586f, 
    -0.08863080f, -0.00696351f, -0.24567565f, 0.00183925f, 0.11796428f, 0.04580862f, 0.22177424f, -0.00664510f, 
    -0.10001302f, 0.11780759f, 0.11115679f, -0.10303131f, -0.09139588f, -0.08525912f, 0.04823253f, 0.13027246f, 
    -0.01251807f, -0.14503789f, -0.00111935f, 0.04033766f, -0.10413312f, 0.07189772f, 0.31706402f, 0.05043780f, 
    0.00095056f, 0.07040258f, -0.05896148f, -0.16261449f, -0.03295476f, -0.03806360f, -0.20014991f, 0.04487984f, 
    0.01479264f, -0.08580751f, -0.06356847f, 0.06169239f, -0.03025376f, -0.29261485f, -0.03604401f, -0.14460494f, 
    0.05837583f, -0.04168153f, 0.20760383f, -0.01440782f, 0.00313897f, 0.29852965f, 0.25458911f, 0.16612369f, 
    0.16995148f, 0.01053875f, -0.05140768f, 0.07431938f, 0.09035136f, 0.01696850f, -0.07331049f, -0.07448543f, 
    -0.00093590f, -0.15688056f, -0.11038151f, 0.05178897f, 0.04309505f, 0.16556676f, -0.01968630f, -0.02616819f, 
    -0.13445131f, -0.03786584f, -0.23380169f, -0.12397769f, -0.02844679f, -0.28138006f, 0.07218347f, 0.18608402f, 
    -0.04164128f, 0.00027116f, -0.21699116f, -0.02050569f, 0.13067490f, -0.06006175f, -0.04135794f, -0.11385969f, 
    -0.13032441f, -0.07359271f, -0.03769716f, -0.03285420f, -0.05229541f, 0.01119942f, 0.11379907f, 0.05377590f, 
    -0.02534201f, -0.00495884f, -0.07089442f, 0.10112411f, -0.01072842f, -0.28554142f, 0.16686645f, 0.26392570f, 
    0.22653392f, -0.03950661f, 0.01637749f, 0.04329316f, 0.04226664f, 0.17248334f, -0.02335805f, 0.20198506f, 
    0.02443859f, 0.12068106f, -0.06959859f, 0.05238992f, -0.05726457f, 0.03108709f, 0.14533480f, -0.01021744f, 
    0.07412031f, -0.04103148f, -0.01916302f, -0.02008211f, 0.07444920f, -0.00988117f, 0.09548314f, -0.08664230f, 
    -0.03319858f, -0.25045729f, 0.09960591f, -0.32996994f, 0.11384611f, -0.03917035f, 0.17398547f, 0.04837477f, 
    0.04650142f, -0.04746795f, -0.08127273f, 0.05223975f, 0.02394660f, 0.04625519f, -0.05602174f, -0.12848768f, 
    -0.09832650f, -0.09936715f, 0.06532467f, 0.16964401f, 0.18342035f, 0.21425676f, -0.10030010f, -0.05925201f, 
    -0.06004694f, -0.07251848f, -0.08004483f, 0.12060729f, 0.01902045f, -0.11470653f, -0.33076087f, -0.19021814f, 
    0.02727053f, 0.05622838f, 0.09498718f, 0.04301627f, 0.12408823f, 0.15688096f, 0.06018504f, -0.04804281f, 
    0.02140296f, -0.01061911f, 0.03026697f, 0.13332702f, -0.04658334f, 0.06611537f, -0.09749197f, -0.17516162f, 
    -0.07362618f, -0.02890592f, -0.05339223f, -0.12529618f, -0.01134306f, 0.03126882f, 0.02238659f, -0.22342974f, 
    -0.08346450f, 0.03381515f, 0.15586501f, -0.13703370f, 0.01362077f, 0.14044967f, 0.03093290f, -0.04330400f, 
    0.07343970f, -0.00083683f, -0.31726637f, 0.08022165f, -0.00854778f, 0.02020719f, -0.06782833f, -0.00697276f, 
    -0.05188946f, 0.10906740f, 0.03911161f, 0.18266213f, -0.00665337f, 0.11478165f, 0.01526047f, 0.08162502f, 
    -0.04904666f, 0.04909386f, 0.04471622f, 0.17796272f, 0.11143903f, -0.00269637f, 0.05480191f, 0.03603925f, 
    -0.01616579f, -0.10090417f, -0.07714432f, 0.19476438f, -0.10467654f, -0.08731677f, -0.27974772f, 0.04323837f, 
    -0.04130172f, 0.15968098f, -0.16834089f, 0.08368869f, 0.19466853f, 0.01520204f, -0.11577558f, 0.04376508f, 
    0.00297166f, -0.05604577f, -0.05719075f, 0.03767061f, -0.02959167f, -0.45066154f, -0.21980418f, 0.20530543f, 
    0.02249696f, 0.04972143f, 0.00209728f, 0.01454806f, 0.03285701f, -0.14829813f, 0.13947460f, -0.05193072f, 
    -0.16061901f, -0.12623857f, -0.02375996f, 0.05039135f, -0.02798169f, 0.14976284f, -0.16410919f, -0.09356610f, 
    -0.04922536f, 0.24742047f, -0.04581226f, 0.07490432f, 0.06343015f, 0.03723174f, -0.08549058f, 0.03506019f, 
    -0.26456633f, -0.06040959f, -0.09804473f, 0.03302397f, -0.01317233f, 0.14178346f, 0.02681670f, 0.09631510f, 
    0.15716933f, 0.06402050f, 0.08317475f, -0.01355542f, -0.11027063f, -0.06355515f, 0.05919793f, 0.13450868f, 
    -0.09150027f, -0.03282204f, 0.15614684f, -0.26390603f, 0.13144565f, 0.15540749f, -0.26632246f, -0.21342193f, 
    0.24138112f, -0.01247451f, 0.12418811f, -0.08052202f, 0.21145870f, -0.66146266f, -0.12510040f, -0.10403368f, 
    0.13960616f, 0.14595412f, 0.07830155f, -0.01020038f, -0.09660280f, -0.32844853f, -0.33671361f, 0.00120031f, 
    -0.00659886f, -0.01067778f, 0.24733850f, -0.12858056f, -0.01301816f, -0.13668846f, -0.16717623f, -0.27567354f, 
    -0.09650975f, 0.10045076f, 0.07595332f, 0.27902502f, -0.13822375f, 0.05260039f, 0.33458239f, -0.64266497f, 
    -0.20685454f, -0.06317072f, -0.12940164f, 0.14641126f, 0.00904302f, 0.08639383f, -0.10492234f, -0.26604730f, 
    -0.08745953f, -0.12313019f, -0.07349309f, -0.08861519f, -0.07008358f, 0.04656726f, 0.05592429f, 0.12505929f, 
    0.28039429f, -0.36408424f, -0.03037898f, 0.12054501f, -0.02187027f, 0.18297212f, -0.10235628f, -0.11965515f, 
    -0.04982457f, 0.08628553f, -0.16150075f, -0.13409653f, 0.08433706f, -0.01590567f, -0.01313990f, 0.15827154f, 
    0.01753143f, 0.08233410f, 0.05264686f, 0.09541384f, 0.08530635f, -0.05614097f, -0.02735125f, 0.05273853f, 
    0.07775810f, 0.00084559f, -0.01755011f, 0.17841406f, 0.07249391f, 0.14048530f, 0.08328649f, -0.14838973f, 
    -0.05391869f, -0.03237760f, -0.10968231f, -0.02032896f, 0.02751568f, -0.14412439f, -0.34071764f, -0.08472082f, 
    -0.00837347f, 0.04675167f, -0.01107828f, 0.03449579f, 0.09534639f, 0.10766715f, -0.64024699f, -0.09595362f, 
    -0.04248569f, -0.10822714f, 0.19928871f, -0.02320168f, 0.11832710f, 0.16338871f, 0.03137864f, 0.11080653f, 
    -0.01018828f, -0.22254837f, 0.04620541f, 0.03321898f, -0.07448310f, -0.03224532f, 0.00084324f, -0.10750229f, 
    -0.34475335f, -0.43070245f, 0.16970585f, 0.03095681f, 0.06272170f, -0.01609888f, 0.04036878f, 0.00386160f, 
    0.05750738f, -0.21432644f, 0.09520900f, -0.13433573f, 0.08338180f, 0.17666012f, 0.02953879f, 0.04379898f, 
    0.23768032f, -0.00329941f, -0.13062628f, -0.01939892f, -0.17819963f, 0.07533234f, -0.03279437f, -0.19159976f, 
    0.10689923f, 0.41444278f, 0.16534714f, 0.22227536f, 0.06479107f, 0.18313268f, 0.04795082f, 0.04231445f, 
    0.14907642f, 0.07035171f, 0.01718223f, 0.13238610f, 0.02793785f, 0.08161953f, 0.19505289f, 0.12704232f, 
    -0.05590343f, -0.00206671f, -0.05915621f, -0.17169540f, -0.09104770f, -0.05108815f, 0.01037108f, 0.10990066f, 
    0.09873346f, 0.04611222f, 0.04839374f, -0.14088583f, -0.02277594f, -0.13427147f, 0.14868441f, 0.04255337f, 
    0.08362766f, 0.00191632f, -0.14378168f, -0.04681257f, -0.14311726f, -0.16567886f, -0.03768805f, 0.12493066f, 
    0.10220750f, 0.09295497f, -0.01144201f, 0.00196118f, 0.18177462f, -0.05456979f, -0.05778622f, 0.00760065f, 
    0.01275369f, -0.02251719f, 0.05117707f, 0.14836276f, 0.01889395f, -0.13155131f, 0.04693037f, -0.00343952f, 
    -0.09256682f, -0.08885545f, 0.10108884f, -0.02878233f, 0.00405860f, -0.01336231f, -0.03701640f, -0.05994412f, 
    0.02770902f, 0.05959987f, -0.02125864f, 0.06239756f, -0.05105538f, 0.06491154f, -0.09639435f, 0.26279035f, 
    -0.07858729f, -0.05807192f, 0.03179279f, -0.02558383f, 0.03878588f, 0.15554522f, -0.11836468f, -0.02491051f, 
    0.01896470f, 0.12959664f, 0.15876041f, -0.22195829f, -0.01677200f, 0.04156213f, -0.03020516f, -0.08229282f, 
    0.01847277f, -0.00348786f, 0.05225837f, 0.00045958f, 0.01114887f, 0.09875743f, 0.15924503f, 0.04543427f, 
    -0.02719675f, -0.05939488f, -0.06057240f, 0.02525234f, -0.12539570f, 0.22950242f, -0.08758406f, -0.12949544f, 
    -0.01626382f, 0.01842083f, 0.05749919f, 0.10944679f, 0.00306636f, 0.06994120f, -0.04916573f, -0.13317908f, 
    -0.04041204f, -0.04818004f, 0.02496985f, 0.08436392f, -0.07671965f, 0.02684046f, 0.16141018f, 0.13843253f, 
    -0.02059987f, -0.01155253f, -0.20659849f, -0.00232090f, -0.06279831f, -0.11148474f, 0.02078744f, -0.18532214f, 
    -0.09873174f, 0.08563823f, 0.00245454f, 0.07338550f, -0.14550970f, 0.05440754f, -0.23174593f, -0.08153864f, 
    -0.08731823f, 0.02685981f, -0.25689432f, -0.11788740f, -0.09193148f, -0.20810308f, 0.08444591f, 0.10479736f, 
    0.10555891f, 0.16773617f, -0.05930350f, 0.01676372f, -0.09879812f, 0.16330938f, 0.01247289f, 0.16516617f, 
    0.06580652f, 0.02327339f, 0.07022081f, -0.12193245f, 0.36479628f, -0.42957979f, 0.30685747f, 0.03028697f, 
    -0.12237056f, -0.03436473f, -0.09788849f, -0.22509898f, 0.09520800f, 0.02824868f, 0.03173237f, -0.09391053f, 
    -0.17398947f, 0.19171998f, 0.08516379f, -0.04898877f, -0.03494368f, -0.11832003f, -0.09478854f, -0.07676824f, 
    -0.03152383f, -0.21271876f, 0.04112974f, 0.00411871f, -0.00899222f, -0.00045803f, 0.12144624f, 0.07890432f, 
    -0.27099353f, 0.14828543f, -0.07141607f, -0.06128140f, 0.01811569f, 0.16943853f, 0.00432002f, -0.17727351f, 
    0.12007286f, 0.03824109f, 0.07440475f, -0.05560294f, 0.01081894f, -0.08784258f, -0.06728805f, 0.07647148f, 
    0.02700229f, 0.11748877f, 0.19617006f, 0.02683449f, -0.16880921f, 0.34260732f, -0.11081484f, 0.13621253f, 
    0.27248996f, -0.03368320f, -0.06789704f, -0.00622819f, -0.05969409f, -0.04583273f, -0.00044946f, 0.11673478f, 
    -0.19100112f, -0.01321902f, 0.15251271f, 0.12247495f, 0.06861433f, 0.07381090f, 0.07553491f, -0.03267652f, 
    0.01556978f, -0.38622195f, -0.26558581f, 0.18470311f, -0.03430914f, -0.03568509f, 0.21610017f, 0.05482602f, 
    -0.42410573f, 0.17807472f, -0.10205764f, -0.07138824f, 0.07299908f, 0.05747411f, -0.08301789f, 0.10946022f, 
    -0.01630121f, -0.01976561f, -0.12025687f, 0.08247146f, 0.10855015f, 0.13995843f, 0.20468396f, -0.03507966f, 
    -0.01105341f, 0.02417053f, 0.24235116f, -0.01277331f, 0.03696522f, 0.16821067f, 0.07635919f, 0.19191119f, 
    0.02284293f, -0.07465268f, 0.01357820f, -0.00844793f, -0.01981029f, 0.01098246f, -0.15004106f, -0.16271672f, 
    -0.11104090f, 0.03918185f, 0.01499944f, -0.01724849f, 0.15674399f, -0.07578124f, -0.01524965f, -0.01070154f, 
    0.05033679f, 0.01099560f, 0.04822544f, 0.00102456f, 0.00178250f, 0.04409927f, -0.00487535f, -0.01640927f, 
    -0.05253822f, -0.02501043f, 0.01988031f, 0.03805628f, 0.01955802f, -0.03140778f, -0.02307518f, -0.04980180f, 
    -0.04176485f, -0.03018596f, 0.02209761f, -0.02696378f, -0.02507215f, 0.04013446f, -0.03297660f, 0.03325304f, 
    -0.05437244f, 0.02761011f, 0.02637568f, 0.01468736f, 0.00307418f, -0.02476463f, -0.04264829f, 0.03257661f, 
    0.02919062f, -0.02452413f, -0.04320756f, -0.04028987f, -0.00914083f, -0.03527077f, -0.04221958f, -0.05813199f, 
    0.00121485f, -0.02533441f, -0.01761228f, 0.01299335f, -0.05735134f, -0.02321123f, 0.02543193f, -0.06171347f, 
    -0.03498052f, -0.03481681f, 0.03721353f, 0.04748237f, -0.04428398f, -0.04671432f, -0.04955572f, 0.01090692f, 
    -0.00646164f, 0.00764115f, 0.00215880f, 0.03090830f, -0.00468153f, -0.03314979f, 0.05225855f, -0.03490776f, 
    0.00051569f, 0.02063479f, 0.05707123f, 0.03465980f, 0.02498391f, -0.05866513f, 0.02676964f, -0.05054392f, 
    -0.05931444f, -0.02613530f, 0.03124819f, -0.03511190f, -0.01117977f, -0.00093688f, 0.01060245f, 0.02760548f, 
    -0.05893965f, 0.02526209f, -0.03656904f, -0.05785260f, 0.00568691f, 0.00075972f, -0.05509127f, 0.00590456f, 
    0.01854833f, -0.02988958f, 0.01164616f, -0.01944701f, 0.02412220f, -0.00489981f, -0.02424363f, -0.02432789f, 
    -0.00306874f, 0.05030985f, -0.04064320f, -0.04060610f, -0.03269312f, -0.04620814f, 0.01410071f, -0.05011132f, 
    0.03123969f, -0.03023254f, -0.06225703f, -0.00107663f, 0.00502432f, 0.02251702f, -0.03055019f, -0.03103025f, 
    -0.03115585f, -0.06132449f, -0.03034619f, 0.01567326f, 0.02682649f, 0.02915500f, 0.01101656f, -0.05148501f, 
    -0.00106250f, -0.02513226f, -0.04642625f, -0.02007191f, 0.04866977f, 0.02512603f, -0.05036674f, -0.04074558f, 
    -0.02480857f, -0.02803914f, -0.01163794f, 0.02931245f, -0.00071136f, -0.04374665f, -0.04611334f, -0.03944751f, 
    0.00702814f, -0.03534563f, 0.03621063f, -0.06062234f, 0.00911218f, -0.00041270f, -0.03831079f, -0.05617373f, 
    -0.02032509f, 0.03707130f, 0.04706738f, 0.05209318f, 0.04678297f, 0.02887642f, 0.00336997f, -0.01782074f, 
    -0.05734042f, 0.01788694f, -0.02000547f, 0.01873967f, 0.04861970f, 0.00261462f, -0.00571063f, -0.01929432f, 
    -0.05807505f, 0.02874035f, 0.02812966f, -0.05536851f, 0.02231741f, -0.02920763f, -0.06288080f, -0.05069076f, 
    0.05299272f, -0.01824702f, -0.01387959f, -0.01455815f, -0.06268671f, 0.00817361f, -0.03606067f, -0.06328261f, 
    -0.01610214f, 0.00441872f, -0.03979449f, 0.00532287f, -0.01319484f, 0.05539161f, -0.05811097f, 0.01894129f, 
    0.05027056f, -0.03037764f, 0.03716230f, -0.04597095f, -0.04911453f, 0.00262478f, 0.04755437f, -0.02394772f, 
    -0.03900323f, -0.04439142f, -0.06171798f, -0.00348709f, 0.05043868f, -0.03074837f, 0.05669420f, 0.04474459f, 
    0.03026301f, 0.04892093f, -0.05812518f, -0.01957729f, -0.00665891f, -0.00229740f, 0.02200020f, -0.05852757f, 
    -0.00977533f, -0.00428998f, -0.05257274f, 0.01082119f, -0.03304130f, 0.04991954f, -0.00555244f, -0.06258216f, 
    -0.04322495f, -0.00877020f, 0.00811791f, 0.02309729f, -0.05933990f, 0.01921749f, 0.01047899f, 0.02122171f, 
    0.04094187f, 0.02011591f, -0.03831961f, -0.03832180f, -0.04018869f, -0.01953196f, -0.05603277f, -0.02906782f, 
    -0.05514060f, 0.02382249f, -0.03361411f, -0.00111186f, -0.05579308f, -0.00926105f, 0.01614369f, -0.00805549f, 
    0.00872937f, -0.01456871f, -0.01452059f, -0.02095093f, 0.03050819f, 0.04301329f, -0.04637982f, -0.03565113f, 
    0.02371318f, -0.01277694f, 0.01406971f, -0.04631130f, -0.01263463f, 0.01300268f, -0.01999880f, -0.00594601f, 
    -0.05955555f, -0.02439740f, -0.05825251f, 0.05026506f, -0.02591727f, -0.02473032f, -0.03879832f, -0.04422865f, 
    0.04889577f, 0.01104495f, 0.00623342f, -0.00812606f, -0.00548363f, -0.02027565f, 0.04332472f, 0.01381326f, 
    -0.02692622f, -0.06199083f, -0.02665153f, 0.02669842f, 0.00465805f, 0.01577839f, 0.01378445f, 0.02931067f, 
    0.00829471f, 0.04169727f, -0.00768558f, 0.04407926f, -0.03348545f, 0.00092227f, -0.05227764f, 0.04949812f, 
    -0.04150920f, 0.01279697f, -0.06422925f, 0.00824389f, 0.00247864f, -0.04556549f, -0.04075843f, 0.03916291f, 
    -0.02250633f, 0.00927031f, -0.03881310f, -0.00494429f, 0.04101279f, 0.04348727f, 0.00507748f, 0.01309051f, 
    -0.02128490f, -0.05678149f, -0.02727051f, 0.04744940f, -0.01003051f, 0.02173896f, -0.06255137f, 0.02872710f, 
    0.04810926f, 0.02890200f, 0.00760904f, 0.00184324f, 0.05012828f, -0.04015578f, -0.01248405f, 0.04674559f, 
    -0.04467225f, -0.06402416f, 0.01160045f, 0.02793423f, -0.04155996f, 0.00418578f, 0.01254883f, -0.01524511f, 
    -0.00089006f, -0.04221201f, -0.06325021f, 0.04553984f, -0.00273992f, -0.03003100f, -0.04773154f, -0.04143039f, 
    0.00847263f, 0.04855474f, -0.05160915f, -0.06335130f, 0.02459423f, 0.05021527f, -0.01500502f, -0.02748681f, 
    0.00831128f, 0.00003151f, -0.03924685f, -0.01338514f, 0.05149137f, -0.05226883f, -0.06078855f, 0.01236531f, 
    0.02147867f, 0.00492879f, -0.01224829f, -0.03226671f, -0.05899566f, -0.01869749f, -0.00002481f, 0.04260354f, 
    -0.05196273f, -0.06220728f, 0.02031900f, -0.00918745f, -0.05613069f, -0.03559343f, -0.01369814f, -0.03003101f, 
    0.03943046f, -0.00341184f, -0.02956332f, -0.00129451f, -0.02821161f, -0.00714530f, 0.04844170f, -0.03702405f, 
    0.02941006f, -0.04230054f, 0.05919108f, 0.01775080f, -0.03854328f, 0.01521584f, 0.01629858f, 0.01733780f, 
    0.01209973f, -0.02071490f, -0.06496539f, -0.06232999f, 0.01240873f, 0.04354856f, -0.04648197f, 0.01879467f, 
    0.04471241f, -0.02193682f, 0.01358120f, -0.00375613f, 0.05866271f, -0.05907737f, -0.01990449f, -0.01111420f, 
    0.00016104f, -0.03797853f, 0.02327031f, 0.03644446f, 0.02435930f, -0.03975217f, 0.01652868f, 0.03931775f, 
    -0.04163022f, -0.02627213f, -0.05269701f, -0.01663617f, 0.00251721f, -0.02288955f, -0.03926901f, 0.04373967f, 
    0.02816611f, -0.03106638f, 0.00283500f, 0.04133402f, 0.03963082f, 0.01858227f, -0.05869285f, -0.00642217f, 
    -0.05147351f, -0.03277383f, -0.06807642f, 0.01272158f, -0.03144246f, -0.04871227f, -0.04716942f, 0.04069019f, 
    -0.01580195f, -0.01566512f, -0.04200836f, 0.00538580f, -0.01884520f, 0.00136153f, 0.00028964f, -0.01443400f, 
    -0.03305439f, -0.05850698f, 0.00641251f, 0.02160634f, -0.06398506f, -0.05635244f, -0.06145684f, -0.04410186f, 
    0.00297790f, -0.01452065f, -0.03279232f, -0.03640483f, -0.00595248f, -0.02584491f, -0.04253914f, 0.00104612f, 
    -0.03751168f, -0.05134748f, -0.05135357f, -0.05019629f, 0.01896799f, 0.00364786f, 0.03031993f, -0.01279475f, 
    -0.02032079f, -0.05672866f, -0.03359481f, -0.03360355f, 0.03403230f, -0.03545216f, 0.03475130f, 0.00340876f, 
    0.04724662f, -0.04355367f, 0.01886766f, -0.04607962f, 0.01464740f, -0.04041299f, -0.05227338f, 0.00354541f, 
    -0.00563552f, -0.05547386f, 0.04173093f, -0.01529119f, 0.01002043f, -0.00417073f, -0.05313142f, 0.04173987f, 
    0.01185429f, -0.02332668f, 0.03842436f, -0.03861564f, 0.00423703f, 0.03751906f, -0.03267143f, 0.03646617f, 
    -0.01087196f, -0.04203016f, -0.06902278f, 0.00490127f, -0.01156923f, -0.03415799f, -0.02177950f, -0.02564717f, 
    -0.03940677f, 0.00506962f, -0.03368054f, 0.00706243f, -0.01391267f, -0.01270073f, -0.02742849f, 0.04627246f, 
    -0.00748173f, -0.02065589f, 0.01979681f, -0.04359766f, 0.02495205f, -0.00916203f, -0.06091679f, -0.00417249f, 
    -0.02296182f, 0.01734682f, -0.02001373f, 0.00431298f, -0.02658032f, 0.03640441f, -0.01569636f, -0.05656142f, 
    -0.00828012f, -0.00666803f, 0.02755938f, 0.02145146f, 0.04381914f, 0.03052667f, -0.02516085f, 0.02496842f, 
    0.01495156f, -0.05353554f, -0.06361975f, 0.02823263f, 0.04738101f, -0.03932749f, -0.02079481f, -0.00794527f, 
    -0.05774806f, -0.02988131f, 0.03082179f, -0.03853793f, -0.03353136f, 0.01646930f, 0.04504127f, -0.04085814f, 
    0.03908324f, -0.00705529f, -0.05617970f, -0.00378616f, 0.05059848f, -0.00712498f, -0.03485921f, 0.04256684f, 
    0.00101484f, -0.01174935f, -0.04669087f, -0.00166950f, 0.02563144f, -0.03081236f, 0.02038751f, 0.03380970f, 
    0.03994966f, -0.04261788f, 0.03353700f, 0.00192644f, 0.02687282f, -0.06112247f, -0.01651746f, 0.02372923f, 
    0.17492023f, -0.30808538f, -0.14385386f, -0.03922642f, -0.11575071f, -0.18511313f, -0.01268281f, -0.00874267f, 
    0.09607258f, 0.01906020f, -0.17735657f, -0.08130176f, -0.15072030f, 0.08060697f, -0.07904228f, 0.00948031f, 
    -0.08288531f, 0.10919538f, -0.21958871f, 0.10805142f, -0.04037096f, -0.00233697f, 0.12636796f, -0.04244642f, 
    0.06883070f, 0.01758953f, -0.04061765f, 0.00599879f, -0.07935838f, 0.17457843f, -0.05591366f, -0.00164734f, 
    -0.04040059f, -0.04703638f, -0.09494874f, 0.02160111f, -0.12542227f, -0.04715207f, 0.11204269f, -0.10327066f, 
    -0.11812676f, 0.19374599f, 0.01127887f, -0.12035410f, -0.01200041f, 0.13016130f, 0.13437332f, 0.30076844f, 
    -0.22025217f, 0.02736330f, 0.05140720f, -0.09647869f, -0.07157975f, -0.09389187f, -0.34806636f, 0.19071202f, 
    -0.18456782f, -0.02814478f, 0.11399296f, 0.01226262f, -0.10672888f, -0.00913625f, 0.09244303f, 0.00927097f, 
    0.05351109f, 0.19691464f, -0.01968922f, -0.13310717f, -0.10284038f, 0.01527768f, -0.04198055f, 0.00722505f, 
    -0.10293309f, -0.17504564f, 0.07883634f, 0.06879197f, -0.08631387f, 0.24662553f, 0.01909073f, -0.00546976f, 
    0.01546054f, 0.21670799f, 0.02727707f, 0.01528741f, -0.00773297f, 0.16763438f, 0.02170516f, 0.10762513f, 
    -0.04748850f, -0.03354013f, -0.04627879f, -0.36886516f, 0.01008317f, 0.01676691f, 0.02512841f, -0.02209612f, 
    0.01710979f, 0.06426125f, -0.15322363f, -0.00621686f, -0.10379601f, 0.32136083f, -0.05440126f, 0.10660908f, 
    -0.08603394f, -0.04590316f, 0.08510938f, 0.06364433f, -0.13016506f, -0.08893918f, 0.13785434f, -0.02423379f, 
    -0.04509736f, 0.26522657f, -0.08753827f, -0.02056808f, -0.11041136f, -0.30337903f, 0.12599826f, -0.11595608f, 
    0.02125681f, 0.10573420f, 0.17798902f, 0.11899521f, 0.10421851f, -0.10717674f, 0.16019487f, 0.10453634f, 
    -0.08795545f, -0.15635061f, -0.08748062f, -0.19984783f, 0.03108902f, 0.04988151f, 0.09971819f, -0.18103261f, 
    0.12627278f, 0.02719230f, -0.00741646f, 0.06708147f, -0.04981279f, -0.12231476f, 0.11637186f, -0.01988296f, 
    0.07873746f, 0.13925892f, -0.17348070f, 0.16286021f, -0.03611078f, -0.14697042f, -0.01657380f, 0.03047411f, 
    -0.12436970f, 0.07213053f, -0.27034757f, 0.07159526f, -0.09110166f, 0.06671704f, -0.13815631f, 0.03643711f, 
    -0.20137443f, 0.02418561f, -0.07634132f, 0.05542852f, -0.01336884f, 0.08951909f, 0.01385759f, 0.01346212f, 
    0.01194097f, 0.22428212f, 0.10962125f, 0.16604131f, 0.13780068f, -0.06183926f, 0.07314058f, 0.26529548f, 
    -0.01892143f, -0.09603542f, 0.09359568f, -0.03228496f, 0.06162859f, -0.09758437f, 0.34340870f, -0.09321114f, 
    -0.14007170f, 0.16803306f, 0.08555079f, -0.10031376f, -0.10679408f, -0.08993010f, -0.06123078f, 0.15552355f, 
    0.03661766f, -0.04381023f, 0.06405877f, -0.08267231f, -0.07341336f, -0.09922006f, -0.14643773f, -0.13281344f, 
    -0.21249683f, 0.08117037f, -0.02137070f, 0.07820321f, -0.12302372f, 0.20787513f, -0.12259862f, -0.11836878f, 
    0.35412335f, -0.05494626f, 0.00575927f, 0.12931378f, 0.01281432f, 0.06280887f, -0.13557105f, -0.22940075f, 
    0.14718141f, -0.04046589f, 0.16477944f, 0.13608453f, -0.28207269f, -0.03345346f, 0.10599019f, 0.05093225f, 
    0.09610701f, 0.01578639f, 0.07882976f, 0.06206187f, -0.15408221f, -0.16203393f, -0.12124296f, -0.03403696f, 
    -0.09725998f, 0.06485634f, 0.16330668f, -0.00905907f, 0.01879332f, 0.08131716f, 0.09975807f, -0.06964441f, 
    -0.02128263f, 0.01583950f, 0.04103489f, 0.13054962f, 0.09457161f, -0.03372135f, 0.08434048f, 0.08694157f, 
    0.00392244f, 0.20233901f, -0.05306430f, 0.03072544f, 0.11425599f, -0.00938181f, -0.06074091f, -0.05390583f, 
    -0.00240378f, -0.28872380f, 0.06383008f, 0.03278076f, 0.02023924f, 0.38853750f, 0.46219593f, -0.35849732f, 
    -0.08882910f, -0.19864064f, -0.25801140f, -0.08404029f, 0.22537008f, 0.08740163f, -0.14366716f, -0.04658516f, 
    -0.03049683f, -0.11473501f, 0.03746365f, -0.14315192f, 0.06133119f, 0.04618677f, 0.08050535f, -0.09373459f, 
    -0.06766640f, 0.02948049f, 0.11804983f, 0.02631861f, 0.08079504f, 0.04492567f, 0.05004907f, 0.03415057f, 
    0.17770456f, 0.25760251f, -0.15139943f, 0.08355670f, 0.08079720f, 0.05645431f, -0.07232928f, -0.04767552f, 
    -0.20880441f, 0.17380600f, 0.23353413f, -0.25486386f, -0.01380489f, -0.04665207f, 0.01887237f, -0.08686768f, 
    0.02247463f, -0.05466764f, -0.17480429f, 0.09377185f, -0.20080754f, -0.00059782f, 0.06918079f, 0.00071314f, 
    0.03971900f, 0.03370170f, -0.00552510f, 0.03600677f, 0.13068220f, 0.02597323f, 0.06394027f, -0.03054855f, 
    0.00444600f, 0.06013741f, -0.02464761f, 0.12269103f, 0.04532491f, -0.00686828f, -0.06456430f, 0.11416127f, 
    -0.04209504f, -0.04317836f, -0.08844151f, 0.01450700f, 0.06471214f, -0.22172289f, 0.10260580f, 0.01355690f, 
    -0.27875313f, -0.06145862f, 0.14152172f, 0.04969312f, 0.09446635f, 0.10278616f, 0.09571717f, -0.22581623f, 
    -0.01575538f, -0.01280301f, 0.10117965f, -0.03617001f, 0.10625810f, -0.07204656f, 0.16790812f, -0.13737312f, 
    -0.15164095f, 0.13260439f, -0.05672446f, 0.08748569f, -0.12957048f, -0.15785331f, -0.18566948f, -0.05919907f, 
    -0.10723440f, -0.09885845f, -0.16631706f, 0.10028328f, 0.10141499f, 0.02770596f, -0.03715106f, -0.09207443f, 
    -0.09251846f, -0.06865807f, 0.03304914f, 0.05458397f, 0.08937955f, -0.21338928f, -0.06629825f, -0.02274814f, 
    0.06175800f, 0.00017711f, 0.06890675f, 0.22287966f, 0.10733061f, 0.13622546f, 0.06491004f, 0.02676365f, 
    0.09969489f, 0.05023266f, -0.15638663f, 0.09453171f, -0.27339056f, -0.05109281f, 0.02416137f, -0.02907257f, 
    -0.12361801f, 0.00320068f, -0.00767391f, -0.08241802f, -0.03143562f, -0.03846352f, -0.22972043f, 0.15733238f, 
    0.11470791f, 0.08386701f, -0.03019548f, -0.13214117f, -0.03698921f, -0.16252324f, 0.31394652f, 0.07449704f, 
    0.07974935f, -0.09471802f, 0.03822900f, 0.04995611f, 0.10594153f, 0.15628767f, 0.06602839f, 0.00148801f, 
    -0.04943789f, 0.01824369f, 0.03789347f, 0.13071544f, -0.10836059f, -0.19131027f, -0.14927961f, 0.01799591f, 
    -0.00609891f, -0.06158605f, 0.07185797f, -0.05633146f, -0.01653258f, -0.07900292f, -0.06171067f, 0.01929158f, 
    0.05532486f, -0.03248721f, 0.13597617f, -0.08333781f, 0.00757958f, -0.16567199f, 0.19216269f, 0.01021855f, 
    0.09346247f, 0.19806866f, 0.25438380f, -0.05254937f, 0.01113656f, 0.08297561f, 0.05541092f, 0.05380558f, 
    -0.02314008f, -0.02056007f, -0.03946592f, -0.09915785f, 0.07858416f, 0.03487064f, 0.00609270f, 0.07629830f, 
    -0.00319612f, -0.06839295f, -0.02963686f, -0.06130045f, 0.21850248f, -0.07099866f, -0.21585535f, -0.04423764f, 
    0.22466940f, 0.09306668f, 0.11985370f, -0.14336294f, -0.00238282f, 0.08193317f, -0.08892407f, -0.12597418f, 
    0.04725320f, 0.10830562f, -0.14740327f, 0.19074705f, 0.01103803f, -0.04877917f, 0.02443505f, -0.01433543f, 
    -0.12660345f, 0.01415074f, 0.00499791f, 0.01777801f, 0.02976058f, 0.13332546f, -0.12746823f, 0.00653295f, 
    0.08425730f, -0.01153266f, -0.02875114f, 0.14636266f, 0.02537304f, -0.15802494f, 0.01316849f, -0.18445973f, 
    -0.02751073f, 0.16642299f, -0.02589384f, -0.00345288f, 0.05307150f, -0.00764100f, 0.06273229f, 0.14278340f, 
    0.12545732f, -0.01029239f, -0.08869021f, -0.02959672f, -0.04029124f, 0.03664120f, 0.08930527f, 0.07412223f, 
    -0.14054264f, 0.05563061f, -0.04499448f, 0.02069829f, 0.08831861f, 0.00470510f, -0.22245634f, -0.10091972f, 
    0.00987972f, 0.12867314f, -0.00083209f, 0.05509795f, 0.03278742f, 0.11326090f, -0.01487019f, -0.10270540f, 
    -0.03879919f, 0.05724347f, 0.07978366f, 0.15925570f, 0.21771820f, -0.06123371f, 0.04239115f, -0.06942707f, 
    0.09188197f, 0.06153473f, 0.07305644f, 0.01737350f, 0.10069683f, 0.01665260f, -0.28650486f, -0.04063700f, 
    0.12268995f, -0.12360590f, 0.06777155f, -0.01833129f, 0.06166538f, -0.20724975f, 0.01702864f, 0.05581009f, 
    0.17352904f, 0.18600887f, 0.00019553f, -0.13346340f, -0.15612240f, -0.17344159f, -0.14700699f, -0.15206540f, 
    -0.04182466f, 0.06660327f, 0.07085208f, 0.07679065f, -0.15643868f, -0.24029770f, -0.09924741f, -0.09057935f, 
    -0.12900785f, 0.13992600f, 0.06063370f, 0.06644421f, 0.16286898f, -0.03889909f, -0.07546208f, 0.12474032f, 
    0.25453687f, 0.09551476f, 0.05229937f, -0.08399733f, -0.03386073f, -0.05834181f, 0.04305566f, 0.03695233f, 
    0.08153735f, 0.00539368f, 0.02944463f, 0.02748313f, 0.06984732f, 0.00185878f, 0.02186686f, 0.04812744f, 
    0.11282110f, 0.00943472f, 0.06312121f, -0.00348277f, -0.02573698f, -0.06618612f, 0.01599209f, -0.16404782f, 
    -0.02965629f, -0.00044519f, 0.00426585f, 0.18309475f, 0.21514371f, 0.08952256f, -0.06284816f, -0.03849325f, 
    -0.04419686f, 0.05199740f, -0.09046647f, 0.07107186f, -0.42302293f, -0.07343006f, -0.41163409f, -0.08969207f, 
    0.21190718f, -0.12645200f, -0.13036992f, -0.02472805f, 0.01376860f, -0.02996744f, -0.16633157f, -0.03905474f, 
    0.02961591f, 0.04359502f, -0.01700663f, 0.00951630f, 0.12652072f, -0.00834383f, -0.14067169f, -0.34777784f, 
    -0.01824730f, 0.11688620f, 0.00740578f, -0.17844237f, 0.00316039f, 0.08464324f, 0.01441127f, -0.29311901f, 
    -0.23556963f, 0.26309630f, 0.06653857f, -0.14601761f, -0.17703353f, -0.06626177f, -0.09125791f, 0.15073562f, 
    0.08128977f, 0.09624413f, -0.30502868f, -0.05485849f, -0.03345799f, 0.05112933f, -0.06441540f, 0.05686681f, 
    -0.03204606f, 0.12057067f, 0.04654410f, 0.22402649f, -0.11938194f, 0.03497933f, -0.03616684f, 0.10121447f, 
    0.07876301f, -0.09850746f, -0.07024223f, 0.20685604f, 0.20153232f, 0.11034559f, -0.12602454f, 0.07916457f, 
    0.00165423f, -0.03151487f, 0.04025401f, 0.38530239f, -0.34900317f, 0.23863551f, 0.08244636f, 0.04326647f, 
    0.04092617f, 0.01672726f, 0.09002442f, -0.06417721f, 0.09710501f, 0.19203745f, -0.05958005f, -0.09197559f, 
    0.04949957f, 0.03063426f, 0.03754841f, 0.11258907f, 0.01551178f, -0.46903136f, -0.06576400f, 0.12847550f, 
    -0.15536140f, 0.17822459f, -0.12530531f, 0.02318308f, -0.05110417f, -0.08336763f, 0.16221145f, -0.05761169f, 
    0.10222173f, -0.07565727f, -0.04405325f, -0.07921176f, 0.21140914f, 0.13620184f, 0.06546166f, -0.05278361f, 
    -0.00233498f, 0.03891464f, -0.01863727f, -0.00698661f, 0.18814588f, -0.00104606f, 0.01760264f, -0.13252422f, 
    -0.12865987f, -0.05924751f, -0.14530876f, -0.18197289f, -0.00602665f, 0.17957351f, -0.06796709f, 0.00845358f, 
    0.11846506f, 0.25905678f, 0.26706114f, 0.10422473f, -0.23283312f, 0.00415194f, 0.01320073f, 0.04062537f, 
    -0.00873316f, 0.12188546f, 0.17807226f, -0.32330808f, -0.13058059f, -0.01379712f, -0.16336341f, -0.07060488f, 
    0.16542877f, -0.12147589f, 0.04464240f, 0.16505967f, -0.17886446f, -0.31521899f, -0.12437989f, -0.19588165f, 
    0.00184400f, 0.07705431f, 0.27090046f, -0.11483823f, -0.19150294f, -0.09265706f, -0.27790070f, -0.18052775f, 
    -0.05408092f, -0.02759769f, -0.08005236f, 0.23174125f, 0.03157551f, -0.09531837f, -0.07316563f, -0.21667309f, 
    -0.07763419f, -0.03628613f, -0.07085929f, 0.03919078f, 0.04631326f, 0.00121405f, -0.00640786f, -0.21538629f, 
    0.03767420f, -0.15234624f, 0.01687188f, 0.05030664f, -0.00797246f, 0.01895060f, -0.00363934f, -0.11156674f, 
    -0.48555279f, -0.08022018f, -0.02729134f, 0.17128275f, -0.24022211f, 0.02442935f, 0.06412905f, 0.18962903f, 
    0.26184833f, -0.46134841f, 0.11561821f, 0.08240084f, -0.21357234f, 0.07089618f, -0.03428685f, 0.04618472f, 
    0.03819475f, -0.03799558f, -0.07861789f, -0.28615564f, -0.01642415f, -0.01672543f, -0.01887955f, 0.06862574f, 
    -0.08689891f, 0.08787046f, 0.07537550f, 0.09209768f, 0.10865463f, -0.15101458f, 0.04780796f, 0.08741880f, 
    0.05332778f, 0.01960805f, 0.01760424f, 0.36999720f, 0.28120664f, 0.23419078f, -0.20485827f, 0.01517590f, 
    0.02734666f, -0.13579744f, -0.05999024f, -0.00938953f, 0.11833062f, -0.11546268f, -0.11956632f, -0.09166027f, 
    -0.08214100f, 0.19476041f, -0.00432144f, 0.02172064f, -0.02109071f, 0.35829180f, -0.41077727f, 0.03736967f, 
    -0.37331814f, -0.09414415f, 0.24068114f, 0.05244230f, 0.12783103f, 0.10748640f, -0.04863131f, -0.07843021f, 
    -0.12859935f, 0.08172708f, 0.02121195f, -0.08044580f, -0.05148346f, -0.12966256f, -0.07697783f, -0.25417641f, 
    -0.48434415f, -0.53621423f, 0.09170251f, -0.08570313f, -0.00258864f, -0.00578352f, 0.04908222f, -0.10730112f, 
    -0.14364979f, 0.13305429f, 0.11015025f, -0.03482186f, -0.02355321f, 0.04629751f, -0.19487886f, 0.08386225f, 
    0.12444682f, -0.08112220f, -0.02836718f, 0.03263788f, 0.03973948f, 0.08752812f, 0.09563026f, -0.14589477f, 
    -0.03293533f, 0.18193622f, 0.05906609f, -0.07027765f, 0.24629402f, 0.00292931f, 0.14361735f, -0.03847013f, 
    0.04230770f, 0.03686066f, 0.06594566f, 0.05002866f, -0.05946439f, -0.03840006f, 0.08445557f, 0.07804289f, 
    0.04864744f, -0.01782493f, 0.01213133f, 0.04820802f, 0.11177565f, -0.10720760f, 0.05642964f, 0.11002156f, 
    -0.07175101f, -0.03781172f, 0.06992681f, 0.10302625f, -0.07277318f, -0.27217439f, 0.08795232f, -0.12522510f, 
    -0.03091047f, 0.02726394f, -0.05479955f, 0.10037065f, 0.12503846f, 0.18620442f, 0.03165220f, -0.10827644f, 
    0.22407024f, -0.11593827f, -0.05059467f, 0.03180599f, -0.08991245f, -0.07918634f, 0.01099569f, 0.21133721f, 
    0.38699621f, -0.22837628f, -0.12138958f, 0.09211658f, 0.01116219f, 0.15927243f, 0.02149921f, -0.01151912f, 
    -0.04078265f, -0.05034238f, -0.00394208f, -0.04258845f, 0.02336285f, 0.01249308f, 0.06409723f, 0.13071743f, 
    -0.05331220f, 0.11654227f, 0.01279976f, -0.01294188f, -0.00457757f, 0.09039892f, 0.04782796f, 0.12053840f, 
    0.04466517f, 0.01513368f, 0.22697616f, -0.20846596f, -0.02605500f, -0.15878133f, -0.02291796f, 0.05530513f, 
    0.09259145f, 0.13172390f, 0.11223733f, -0.50941753f, 0.04201750f, -0.10968660f, -0.03015698f, -0.16481714f, 
    -0.14903861f, 0.10793959f, 0.01753762f, 0.08086827f, -0.03971496f, -0.10112911f, 0.10123894f, 0.01608712f, 
    0.03178507f, -0.03891570f, -0.01395012f, 0.07738415f, -0.14135753f, 0.25698367f, 0.05585889f, -0.18687983f, 
    -0.12994687f, -0.11060682f, -0.05152711f, 0.09098358f, 0.00666512f, 0.13253579f, -0.03024152f, 0.16284142f, 
    -0.03192679f, -0.08070596f, -0.06619987f, 0.06662760f, 0.03784836f, 0.01693551f, 0.02367713f, 0.18506609f, 
    -0.02722636f, -0.25129458f, 0.00025521f, -0.06380792f, -0.21087082f, 0.03894128f, -0.04765942f, 0.01559918f, 
    0.10650455f, -0.17361756f, -0.21317303f, 0.15335479f, 0.17648771f, 0.04852176f, -0.04289500f, 0.02203687f, 
    -0.15695235f, -0.09147503f, 0.01567370f, 0.01907786f, 0.06454480f, -0.12832923f, -0.00184214f, -0.23266943f, 
    0.03118309f, 0.05086178f, 0.08229095f, -0.03022341f, 0.02681994f, -0.32071266f, 0.04988119f, -0.21129921f, 
    -0.01800590f, 0.03266999f, 0.01888389f, 0.26986733f, -0.15497011f, -0.18536419f, -0.03232606f, -0.01343243f, 
    -0.19303823f, -0.14783555f, -0.02879158f, -0.19205017f, -0.35354280f, 0.09290686f, -0.10556728f, 0.01023508f, 
    0.04238731f, -0.11030611f, 0.09745810f, 0.00504602f, -0.14847204f, -0.10922182f, 0.09351539f, 0.10366174f, 
    0.23685779f, -0.04105047f, -0.22995542f, 0.04454892f, -0.05883648f, -0.01507814f, 0.23202778f, -0.09126981f, 
    -0.21121697f, -0.07953681f, 0.04401929f, -0.23756498f, -0.14499766f, 0.03342644f, -0.13066234f, 0.04820068f, 
    -0.03360942f, 0.00015107f, -0.05729828f, 0.09075384f, -0.06556028f, -0.02852518f, 0.11590318f, -0.07594180f, 
    -0.35203162f, 0.27671173f, 0.22387090f, 0.08467012f, 0.23776449f, 0.12439816f, -0.01760366f, 0.08353555f, 
    -0.00591643f, 0.07720864f, -0.11585219f, -0.46087977f, -0.25628823f, -0.18264556f, -0.06534778f, 0.07527467f, 
    0.13640592f, 0.13022099f, -0.00921734f, -0.05306470f, 0.00362043f, 0.03971742f, 0.02936434f, 0.04381666f, 
    -0.08506849f, 0.05439040f, -0.16640975f, 0.15460381f, -0.18768694f, -0.12942016f, 0.09526756f, 0.05932124f, 
    -0.04220665f, 0.19913402f, 0.03353673f, 0.02442702f, -0.21714804f, -0.09471134f, -0.10722268f, 0.11235086f, 
    0.11385984f, 0.06378338f, -0.25575149f, -0.10078499f, -0.01102815f, -0.05446486f, -0.21912926f, -0.35363111f, 
    0.11335617f, -0.01543908f, 0.23115131f, 0.04959898f, -0.19462943f, 0.05374940f, 0.01522802f, 0.11504020f, 
    0.12580821f, -0.16146977f, -0.07884299f, 0.03104083f, 0.16438138f, 0.04602803f, 0.07753665f, -0.05624515f, 
    0.03978185f, 0.33675125f, -0.09057147f, -0.06973626f, 0.00863275f, -0.10706860f, 0.11251969f, 0.03051429f, 
    -0.31924561f, -0.12897228f, 0.28655559f, -0.19539088f, 0.07685608f, -0.03300165f, -0.00141015f, -0.01004344f, 
    0.06499075f, -0.54834467f, 0.13060594f, 0.25383511f, -0.12447233f, -0.02473472f, 0.10832039f, -0.00171757f, 
    0.06119881f, 0.23042484f, 0.27237210f, -0.13353983f, 0.11716337f, -0.00729370f, 0.04697957f, 0.05448934f, 
    0.04829491f, -0.03869435f, -0.02572692f, 0.11008092f, 0.14326742f, 0.28743050f, -0.10122588f, 0.08761350f, 
    0.05019837f, -0.03386366f, 0.01463483f, -0.12290119f, 0.05364784f, -0.19334576f, 0.14781964f, 0.06419260f, 
    -0.17339467f, 0.02205579f, 0.08370601f, 0.17712888f, 0.07314678f, 0.09240534f, -0.11517759f, 0.08256748f, 
    -0.02060765f, 0.15177500f, -0.00237425f, 0.03680150f, -0.02045401f, 0.10116709f, -0.09706867f, -0.36306259f, 
    0.05248608f, -0.22929539f, -0.00216202f, 0.10269126f, -0.01543089f, 0.00027544f, -0.12564090f, -0.05714966f, 
    0.40388390f, -0.22732164f, 0.00535630f, -0.03631650f, 0.15107168f, 0.05809098f, 0.07072891f, -0.30820340f, 
    0.15869288f, 0.04442112f, 0.04535352f, 0.19997756f, 0.08992652f, 0.08887006f, 0.10019282f, 0.06897647f, 
    0.07612552f, 0.18230385f, -0.13679288f, 0.23226225f, -0.05856067f, 0.15182629f, 0.01883745f, 0.09412000f, 
    0.02152060f, -0.10782488f, 0.24108441f, 0.12537323f, -0.15547426f, 0.07057374f, 0.08086099f, -0.04307257f, 
    0.14352770f, 0.01010418f, -0.06755435f, 0.08985065f, 0.12841274f, -0.25113451f, -0.15285139f, 0.11462042f, 
    -0.04355461f, 0.03488921f, -0.20297694f, -0.08719410f, 0.23589309f, -0.10053204f, 0.03403619f, 0.04098639f, 
    0.29504523f, -0.03166464f, -0.07228853f, -0.02372611f, -0.15999931f, -0.02068948f, -0.56530064f, -0.22628519f, 
    -0.05827772f, -0.07085885f, 0.16386254f, 0.05691522f, 0.03079275f, -0.01623663f, -0.22270764f, -0.01552001f, 
    0.01922604f, -0.06807382f, 0.01394922f, 0.08324093f, 0.08136928f, 0.04641380f, 0.01610344f, -0.05485297f, 
    -0.23198745f, -0.06679409f, 0.03490289f, 0.00747596f, 0.11842175f, -0.01773244f, -0.17250416f, 0.09755073f, 
    -0.23152517f, -0.14707458f, -0.11490041f, 0.00497647f, -0.02285665f, -0.08489726f, 0.12809058f, -0.04150097f, 
    0.16953747f, -0.27452633f, -0.10732884f, 0.37087122f, -0.11587583f, -0.01406050f, -0.10144155f, 0.04791103f, 
    0.05395229f, -0.08454916f, 0.19382697f, -0.06521304f, -0.51700532f, -0.02911557f, -0.13668129f, -0.16038723f, 
    -0.01623632f, -0.09794659f, -0.17752005f, 0.05777645f, 0.25122121f, -0.28104678f, -0.04667452f, -0.28450701f, 
    0.10692848f, 0.22288011f, -0.20125638f, -0.04318557f, 0.32449335f, -0.22809303f, -0.24519767f, 0.03194638f, 
    0.00545133f, 0.08359516f, 0.02401377f, -0.14558980f, -0.26517636f, -0.03962939f, -0.14776623f, -0.18207976f, 
    -0.04098367f, -0.00460395f, 0.03407378f, 0.12021049f, -0.02320809f, -0.05273416f, 0.63328099f, -0.06505591f, 
    -0.38131136f, 0.01321426f, -0.03498864f, -0.01733791f, -0.01250336f, 0.00490500f, -0.02343293f, -0.09566411f, 
    -0.08422032f, -0.21097986f, -0.01118366f, -0.08524588f, 0.14095744f, 0.08090471f, 0.12685412f, 0.12347266f, 
    0.10418249f, 0.01018816f, 0.19297543f, 0.10419840f, 0.03117058f, -0.00191920f, 0.04116324f, 0.11230646f, 
    0.01318994f, -0.16552430f, -0.07988967f, -0.03518545f, 0.05036417f, -0.05845929f, -0.05996239f, 0.13604459f, 
    0.06047718f, 0.19995843f, -0.03205207f, -0.06524055f, 0.09039880f, -0.09152388f, -0.04759095f, -0.03079316f, 
    0.18237136f, -0.05110100f, -0.08153528f, -0.07654089f, -0.18960844f, 0.19440785f, -0.13697244f, -0.05673116f, 
    0.19640526f, 0.04608894f, -0.06211990f, -0.09972397f, -0.04512002f, 0.00571758f, 0.02081992f, -0.05538346f, 
    0.00314595f, 0.00933778f, 0.03678944f, 0.01137788f, 0.08677889f, -0.33569351f, -0.35531262f, -0.31648749f, 
    -0.13618423f, -0.00683545f, 0.01909107f, 0.00811116f, -0.04203833f, 0.01627382f, 0.12231117f, -0.07866459f, 
    -0.17484002f, -0.03405296f, 0.14651991f, -0.10297374f, 0.08760470f, 0.05777139f, 0.06845633f, 0.19269773f, 
    -0.06108198f, -0.62108177f, 0.23373874f, 0.01270719f, 0.13046443f, -0.01777662f, 0.05045865f, 0.07121558f, 
    -0.18879084f, -0.02437328f, 0.19011995f, 0.05740945f, 0.01844805f, 0.16956195f, 0.21391366f, -0.16025558f, 
    0.03202128f, -0.36521217f, -0.11447631f, 0.01317806f, -0.06951793f, -0.07692984f, 0.09429196f, 0.13299948f, 
    -0.15095142f, 0.05680403f, -0.05803659f, 0.08402896f, 0.13038401f, 0.06665272f, -0.01289614f, -0.08073919f, 
    0.01160253f, 0.02737905f, -0.01066569f, 0.24312901f, 0.08928320f, 0.28144759f, 0.01373119f, 0.15051740f, 
    -0.01431053f, 0.05896229f, -0.07490646f, -0.05933558f, 0.13352746f, 0.05307819f, -0.24796927f, -0.10373227f, 
    0.01706148f, -0.05760787f, 0.03391871f, 0.13041313f, -0.01201741f, -0.01245908f, 0.04063713f, 0.00594197f, 
    -0.02597868f, -0.04573109f, 0.14745839f, 0.01536800f, -0.20678562f, -0.11566514f, -0.02348962f, -0.10203393f, 
    -0.12305210f, -0.02197639f, -0.01459952f, -0.14015572f, -0.06349737f, -0.14742504f, 0.01365128f, -0.30798250f, 
    -0.12890147f, -0.24498098f, 0.23165828f, 0.03484732f, -0.00508781f, -0.08298767f, -0.08874341f, 0.02031910f, 
    -0.02511144f, 0.20848539f, 0.15253451f, 0.20151600f, 0.05959008f, 0.08515910f, 0.11317897f, 0.02753012f, 
    -0.09923736f, 0.33507136f, -0.03345419f, 0.20928283f, 0.19067355f, 0.10767069f, 0.02847218f, 0.15702030f, 
    -0.06663108f, 0.03182862f, 0.09613166f, 0.26064622f, -0.03639923f, 0.10208537f, 0.05329023f, 0.07769369f, 
    0.06993587f, -0.01465813f, -0.10381136f, 0.01226585f, 0.09662820f, -0.35859603f, -0.21036129f, 0.25152299f, 
    0.18046483f, 0.06753792f, -0.08477661f, -0.09158392f, 0.08678261f, 0.15493040f, 0.16631088f, 0.05322032f, 
    0.19822441f, -0.09463099f, 0.08288740f, -0.06120804f, -0.12441260f, 0.05534600f, -0.21745279f, -0.39621180f, 
    0.27564749f, -0.10418913f, -0.23287426f, 0.09169600f, 0.07158371f, 0.08519988f, -0.05199469f, -0.14720121f, 
    -0.02876101f, 0.04977849f, 0.02012911f, 0.02191369f, -0.05820471f, 0.11866012f, 0.00394906f, 0.03571291f, 
    -0.16880804f, -0.33664382f, -0.04170622f, 0.05063349f, -0.00260291f, 0.03206459f, 0.09832025f, 0.03237765f, 
    -0.15404065f, -0.04466533f, -0.03267971f, -0.14247832f, 0.03882767f, 0.11597842f, -0.00006501f, 0.13670456f, 
    -0.04233073f, -0.07010297f, -0.04208595f, 0.05589338f, 0.11991229f, -0.14224283f, 0.00018691f, 0.04755819f, 
    0.00009881f, -0.02681252f, 0.08091182f, -0.09164343f, -0.12202867f, 0.19001204f, -0.14428492f, -0.05845028f, 
    0.07757898f, 0.15900335f, 0.08164974f, 0.19317935f, 0.34039718f, -0.30358601f, -0.01807040f, -0.25624013f, 
    -0.06498369f, 0.06842148f, -0.03802511f, -0.32717428f, -0.18222576f, -0.26979807f, -0.33082083f, 0.15973045f, 
    0.00004719f, 0.07593260f, 0.39952627f, -0.31688824f, 0.05123924f, 0.06821905f, -0.05647194f, -0.27967337f, 
    -0.04964937f, -0.01453936f, 0.10444627f, 0.08165166f, -0.11544596f, 0.11842348f, 0.12953065f, -0.14416370f, 
    -0.39714298f, 0.00600316f, -0.14804089f, 0.09476521f, 0.20592596f, 0.02836493f, -0.10604075f, 0.13908954f, 
    0.07092325f, -0.30840907f, -0.11735832f, -0.04254631f, 0.00880559f, -0.07304361f, -0.06797391f, -0.06519658f, 
    -0.00271344f, 0.00387383f, 0.17004156f, -0.12062737f, 0.03002294f, 0.15792143f, 0.22090596f, -0.08625121f, 
    0.18957983f, -0.04796361f, -0.22449481f, -0.36650565f, -0.06300785f, -0.07797737f, 0.00241410f, -0.18064350f, 
    -0.11371130f, -0.11671563f, 0.08305983f, 0.01592493f, 0.22442941f, 0.03646990f, -0.06761824f, 0.02048249f, 
    0.15975411f, -0.07746559f, 0.04505633f, 0.38447642f, 0.05921049f, 0.14346567f, 0.16492550f, -0.13751943f, 
    -0.03500809f, 0.07945791f, -0.17848028f, -0.20191428f, -0.11408141f, -0.15469405f, 0.02493921f, 0.08971754f, 
    0.05162739f, 0.04483726f, 0.07677058f, 0.12709360f, 0.07961560f, -0.18161669f, -0.30104759f, -0.33261624f, 
    0.10855354f, -0.15826462f, -0.30318075f, 0.22964364f, 0.01960228f, 0.07254849f, 0.09206218f, 0.25320098f, 
    0.06996785f, -0.00804053f, 0.17789423f, 0.10773459f, -0.02530787f, 0.03465164f, -0.04171436f, 0.15052943f, 
    0.03927689f, -0.19705001f, 0.06894440f, -0.00778858f, 0.16014554f, 0.22323948f, 0.04483563f, 0.06965722f, 
    -0.11638305f, 0.03245974f, -0.02146732f, 0.01807952f, -0.14193955f, 0.03313956f, -0.04780768f, -0.00506746f, 
    0.26173294f, -0.15201426f, -0.19859041f, -0.22841068f, 0.02620154f, -0.15246721f, -0.09256466f, -0.17085463f, 
    0.04430989f, 0.39788869f, 0.21633457f, 0.04274613f, 0.25416318f, 0.02656542f, -0.03279460f, -0.15326263f, 
    -0.02089248f, -0.00471442f, 0.16232219f, 0.04745326f, -0.12861371f, 0.03446139f, 0.06523705f, 0.13023463f, 
    -0.01673614f, 0.15209408f, -0.13031846f, -0.22986005f, -0.08801109f, -0.15971935f, -0.03271791f, -0.00305038f, 
    0.06742038f, 0.04717270f, 0.00447431f, 0.14909869f, -0.15784936f, -0.16299857f, 0.00385447f, 0.00467044f, 
    -0.05597012f, 0.09636690f, 0.01542668f, -0.06783216f, -0.04034591f, -0.09697112f, -0.01349260f, -0.04434969f, 
    0.05747119f, -0.13416095f, 0.04632658f, 0.00469899f, -0.10570973f, -0.05806826f, 0.06496077f, 0.18550590f, 
    -0.01615072f, -0.21432890f, -0.00719467f, 0.19845377f, 0.03180783f, 0.05078412f, 0.15375850f, 0.09941673f, 
    -0.26674932f, -0.00238408f, 0.15924034f, -0.00273619f, 0.06724196f, -0.08685112f, 0.01627731f, 0.06955195f, 
    0.15826444f, 0.08899631f, -0.00796742f, 0.09333884f, 0.02717221f, -0.00809344f, 0.04342218f, 0.05505839f, 
    0.19175754f, 0.03452437f, 0.07811230f, -0.07161995f, -0.01485923f, -0.20001020f, -0.15606010f, -0.14210662f, 
    0.15089303f, 0.00115802f, -0.01601051f, -0.19080432f, 0.20722495f, 0.03555593f, -0.19053462f, -0.00974666f, 
    0.03686209f, 0.11200140f, 0.10622612f, 0.24105197f, -0.31882769f, -0.04005021f, 0.22736943f, -0.06685285f, 
    0.11118156f, -0.17644545f, -0.06786416f, 0.03137523f, -0.09678893f, 0.21531428f, 0.04031807f, -0.03998277f, 
    -0.07997158f, -0.20097138f, 0.01986639f, 0.07832170f, 0.09105243f, -0.00508892f, -0.14629288f, -0.10707525f, 
    -0.22623672f, 0.07425040f, -0.01094067f, 0.12077919f, 0.07273582f, -0.02682653f, 0.04866646f, 0.23657255f, 
    -0.06533565f, -0.17653030f, 0.14354277f, 0.03789571f, 0.04072613f, 0.06696013f, 0.16348112f, 0.02111740f, 
    0.18618914f, 0.00019760f, 0.18265970f, -0.15107638f, 0.13474713f, -0.04066245f, -0.02084901f, -0.18013963f, 
    -0.12009999f, -0.03377508f, 0.01298272f, -0.05680551f, 0.04350989f, -0.25754175f, -0.12774245f, -0.03300169f, 
    -0.11119262f, 0.15969673f, 0.07140239f, -0.15738028f, 0.04486968f, -0.18610537f, 0.39972544f, 0.05819946f, 
    0.05169215f, -0.00484033f, 0.04446434f, 0.05648744f, -0.24875315f, -0.17372248f, 0.11305298f, -0.00860895f, 
    -0.02840015f, -0.06536150f, -0.03983264f, -0.32688570f, -0.04763865f, 0.32384551f, -0.05244192f, 0.02040244f, 
    -0.13684197f, -0.03721143f, 0.03685389f, -0.08842053f, 0.07793722f, -0.16262603f, 0.31168562f, -0.00783745f, 
    -0.06237513f, -0.08120351f, -0.03151653f, 0.11147340f, -0.00870534f, 0.17018697f, 0.28457710f, 0.03105633f, 
    -0.11927329f, -0.06234019f, -0.17439513f, -0.29563287f, 0.05462682f, 0.14534622f, -0.07735569f, 0.06541291f, 
    -0.05758243f, -0.07821564f, -0.10770164f, 0.19237193f, 0.15564796f, -0.21621963f, -0.02216458f, 0.08669654f, 
    -0.46351081f, 0.22500433f, -0.08511548f, 0.13655262f, -0.01934194f, 0.06681327f, 0.10421266f, 0.04213765f, 
    0.27164996f, -0.14890483f, -0.26137924f, -0.21043961f, -0.09923853f, -0.07559436f, 0.09337622f, 0.02061843f, 
    0.01164878f, -0.11045515f, 0.07433289f, -0.06131284f, 0.08487482f, 0.02958260f, 0.01116223f, 0.07020607f, 
    -0.08242061f, 0.03229623f, -0.27908069f, 0.08257837f, -0.23885925f, -0.08312067f, 0.22877690f, -0.00158505f, 
    0.04247946f, -0.11466677f, -0.10221627f, -0.18138236f, 0.13909730f, -0.17025073f, 0.09888509f, -0.04070793f, 
    0.09983393f, 0.14181830f, -0.14938545f, 0.04090007f, -0.09458441f, 0.17059205f, -0.05013442f, -0.35647258f, 
    -0.03273534f, 0.02682133f, 0.19155538f, 0.12434373f, -0.11779627f, -0.09141205f, 0.17249709f, 0.23036832f, 
    0.16497485f, -0.18626536f, -0.11610884f, -0.01191827f, -0.04981733f, 0.07743710f, 0.08783939f, 0.00653447f, 
    0.06011734f, 0.09398761f, -0.08726662f, 0.03012471f, -0.04499206f, 0.00940922f, 0.09747972f, 0.23180316f, 
    -0.04613397f, -0.00622651f, 0.03073844f, 0.02752987f, -0.03997318f, -0.05618611f, -0.02035970f, 0.04657744f, 
    0.01180123f, 0.04596787f, -0.05716357f, -0.00105378f, -0.03935129f, -0.00543296f, -0.05210820f, 0.04268452f, 
    0.01848784f, 0.00018807f, -0.04167691f, 0.03905145f, -0.02346149f, -0.02350622f, -0.02786000f, -0.04947203f, 
    -0.04258315f, -0.01636290f, -0.01592450f, -0.06140497f, 0.01768242f, 0.04826219f, 0.02296953f, 0.01354319f, 
    -0.00328880f, 0.03968278f, -0.00716448f, 0.02459732f, 0.04937109f, 0.02592494f, 0.03721149f, 0.03161100f, 
    -0.02464124f, -0.03684062f, 0.03641697f, 0.01709046f, -0.03407957f, 0.01491433f, 0.03905402f, -0.03897865f, 
    -0.06541912f, 0.00919926f, -0.04290576f, 0.04556429f, 0.00749445f, -0.06338851f, 0.02913174f, -0.00367493f, 
    0.00152540f, -0.04288279f, -0.05324964f, -0.00882612f, -0.02447905f, 0.01202869f, 0.04072202f, 0.01702943f, 
    0.03678500f, -0.04730536f, -0.00229945f, -0.00583711f, -0.05309463f, 0.00882648f, 0.01415271f, -0.03686909f, 
    -0.05507999f, -0.06129576f, -0.01528837f, 0.01723163f, -0.04286272f, -0.04386315f, -0.04427461f, -0.03946748f, 
    0.04226452f, 0.01162904f, 0.04615872f, -0.04253847f, 0.05199283f, -0.04494454f, -0.02425487f, -0.03206631f, 
    -0.04704328f, 0.03791851f, 0.04757660f, -0.04577779f, 0.01596921f, -0.04025778f, -0.02577805f, -0.04892229f, 
    -0.01831535f, -0.05865701f, -0.02416747f, -0.04099950f, 0.04505867f, -0.04606589f, -0.05031655f, -0.06375498f, 
    -0.01175598f, -0.04334698f, -0.05932663f, -0.04866713f, -0.06280058f, -0.02037481f, 0.02182560f, 0.02825344f, 
    -0.04300406f, -0.00092821f, 0.00995531f, -0.00411769f, -0.00664273f, 0.02691478f, 0.04320068f, 0.03362320f, 
    0.01527154f, -0.02259556f, -0.02944478f, -0.04110200f, -0.04674651f, -0.00362809f, -0.00579658f, 0.02816902f, 
    -0.02448139f, -0.05565377f, 0.03415186f, -0.06492063f, 0.04450557f, -0.05391571f, 0.01088506f, -0.04503468f, 
    -0.06066557f, 0.04876650f, -0.04643954f, -0.02678696f, -0.03371833f, 0.01415762f, -0.05247233f, 0.02409738f, 
    0.00983383f, 0.03665683f, -0.01552532f, -0.05515882f, 0.00513130f, -0.05504871f, -0.04291707f, -0.06417481f, 
    0.05238172f, -0.06471773f, 0.01683123f, -0.05941164f, -0.06019509f, 0.04829976f, -0.05936176f, 0.03743000f, 
    0.04348016f, -0.06669929f, -0.02198510f, -0.05247710f, -0.01481636f, -0.05222565f, 0.00641317f, 0.02330636f, 
    -0.04895272f, 0.01930937f, -0.05252391f, 0.01143627f, -0.05691057f, -0.01618023f, 0.00570624f, -0.02210395f, 
    -0.00502607f, -0.01126273f, -0.06512396f, -0.01092802f, 0.05122037f, -0.03688518f, -0.02294303f, -0.00105469f, 
    -0.04079868f, -0.01588617f, -0.05813451f, 0.01206257f, 0.02897105f, -0.00963779f, 0.05010362f, 0.01230179f, 
    -0.03374197f, 0.04021181f, -0.02557176f, -0.04026188f, 0.01068912f, -0.05302302f, -0.02122880f, 0.04176999f, 
    -0.04818090f, 0.02444222f, 0.01221691f, 0.02006599f, -0.01823849f, -0.04292135f, -0.04138945f, 0.05072005f, 
    0.00611100f, 0.00569928f, -0.04122287f, -0.02923799f, -0.05391303f, 0.03760935f, 0.02622559f, -0.00232487f, 
    0.03610008f, -0.02615337f, -0.04034459f, -0.01097266f, -0.04714654f, 0.04095446f, 0.04086576f, -0.05730485f, 
    -0.01655405f, 0.00669779f, -0.05927156f, 0.02606541f, -0.00228775f, -0.06340757f, 0.05843025f, -0.03434955f, 
    -0.02138983f, 0.00172417f, 0.00760569f, -0.02857729f, -0.05774584f, -0.02332043f, 0.05034116f, -0.03711058f, 
    0.03278654f, -0.02177575f, -0.04955608f, 0.04880968f, -0.06214856f, -0.00267362f, -0.01324655f, -0.04026204f, 
    0.04914318f, 0.04537766f, -0.04288319f, -0.06098356f, -0.00605577f, -0.01823214f, -0.05621073f, 0.02056135f, 
    0.03734683f, -0.00096804f, -0.02041170f, 0.02498103f, -0.00140056f, -0.06433206f, -0.05121190f, 0.00833866f, 
    0.02224846f, -0.01071743f, -0.03491965f, -0.02299781f, -0.06264689f, 0.03842485f, 0.03798525f, -0.04122458f, 
    -0.05262568f, 0.00918932f, 0.00471295f, -0.00857686f, 0.01365464f, -0.00341831f, 0.05367864f, -0.03305287f, 
    -0.01910148f, -0.00031310f, 0.00682554f, 0.00643826f, 0.01646425f, 0.02583231f, -0.02879255f, 0.03279116f, 
    0.00152238f, -0.02012495f, -0.05179813f, 0.05236068f, -0.10064907f, -0.05730585f, -0.02089977f, -0.02900925f, 
    -0.06153321f, 0.01933114f, 0.05732309f, 0.27367359f, -0.00595091f, -0.09203123f, -0.04895141f, -0.02297610f, 
    0.14175168f, -0.03087389f, -0.02675740f, -0.09411002f, -0.06028952f, 0.01277925f, 0.03220782f, -0.00990196f, 
    -0.04215801f, -0.04144293f, -0.00113530f, -0.01406525f, 0.17876546f, 0.22583351f, 0.00391786f, 0.03977275f, 
    -0.04283684f, 0.02217357f, 0.00263945f, 0.02128693f, -0.22983891f, -0.25075951f, 0.34081423f, 0.06552495f, 
    -0.09749498f, 0.05069061f, -0.08191488f, -0.04377851f, 0.10696882f, -0.05347166f, 0.03671866f, -0.01713492f, 
    -0.16272612f, 0.02262878f, -0.05542942f, -0.03484987f, -0.02509964f, 0.31905702f, 0.00769772f, -0.34624141f, 
    0.02499766f, 0.09854054f, 0.11381835f, -0.06337402f, -0.13339058f, 0.04803367f, -0.09685293f, -0.01732123f, 
    -0.41423899f, -0.12622677f, 0.11258481f, 0.17194995f, -0.13950652f, 0.10194599f, -0.07458595f, -0.18744451f, 
    -0.03114275f, -0.02294745f, 0.10117295f, 0.00032557f, 0.04784899f, -0.01191610f, 0.05520730f, 0.00928342f, 
    0.06977351f, -0.04091743f, 0.09641790f, 0.15147640f, -0.11484655f, -0.09165563f, -0.04264007f, 0.01026356f, 
    0.05766627f, -0.01068361f, -0.05126107f, 0.28103253f, 0.03684646f, 0.08360447f, 0.02582037f, 0.11356045f, 
    -0.02135758f, -0.05832136f, -0.18479486f, 0.01746584f, -0.33182144f, 0.04962115f, -0.05618986f, -0.01386944f, 
    0.01053180f, 0.10974376f, -0.06910890f, 0.01535370f, -0.10278038f, 0.00586207f, 0.19946960f, 0.04711417f, 
    -0.07196151f, -0.00568266f, -0.04546700f, -0.00240590f, 0.13975020f, -0.45547333f, -0.27018923f, 0.15246773f, 
    0.01089191f, 0.01305669f, 0.04994756f, -0.12454296f, 0.07242809f, 0.09711225f, 0.02238093f, -0.12965313f, 
    -0.04007512f, -0.02087125f, 0.02352215f, -0.03829881f, 0.05306917f, 0.04579273f, -0.07968359f, -0.10886665f, 
    -0.23169078f, 0.04434578f, 0.00304074f, -0.05286861f, 0.06191503f, -0.11039465f, -0.00318009f, 0.10819761f, 
    0.06827512f, -0.11347410f, 0.20585926f, -0.15865852f, -0.03296386f, 0.13563925f, 0.09252007f, 0.04226404f, 
    0.12424166f, 0.12171081f, 0.08356164f, 0.08443002f, -0.05849044f, 0.12470593f, 0.07384649f, -0.00022123f, 
    -0.13416062f, 0.01557344f, -0.06801434f, -0.16952339f, -0.10645062f, 0.05480359f, -0.03423676f, 0.07292134f, 
    0.01092534f, 0.02984383f, -0.03717766f, 0.14109983f, 0.51636136f, 0.02326636f, -0.13976780f, 0.02383706f, 
    0.25555918f, -0.08971131f, 0.18265893f, 0.13778451f, -0.17156491f, 0.10463961f, 0.15934683f, 0.07418862f, 
    -0.18686248f, -0.04427988f, -0.09120445f, 0.05564036f, 0.00122380f, -0.29726097f, -0.13737571f, 0.04251128f, 
    -0.01999393f, -0.11975610f, -0.04337793f, 0.00503301f, 0.07271989f, 0.07334585f, -0.12073327f, -0.28884071f, 
    -0.29709315f, 0.00093828f, 0.00537715f, -0.02806170f, -0.15910947f, -0.07107953f, 0.17996354f, -0.11532183f, 
    -0.09389941f, 0.02931863f, 0.05000456f, 0.01682961f, 0.09714483f, 0.01994876f, 0.09351122f, 0.11483230f, 
    -0.07583376f, -0.08041263f, 0.23271258f, 0.29689580f, -0.10528867f, -0.11045150f, -0.13643508f, 0.04526177f, 
    -0.02196128f, 0.14082012f, -0.01178288f, 0.00940398f, -0.15384045f, -0.15947415f, -0.04443714f, 0.07683679f, 
    0.03443615f, 0.05125013f, 0.11247091f, 0.10649513f, 0.17950836f, 0.00763423f, -0.01687707f, -0.06419975f, 
    0.12859052f, -0.01734276f, -0.03884565f, -0.02363011f, 0.18754363f, 0.05814390f, 0.01964110f, 0.04941720f, 
    0.03546869f, -0.11579519f, 0.08459585f, -0.10033318f, 0.02279288f, -0.13817349f, -0.05480495f, -0.10500577f, 
    0.02104441f, -0.10437224f, 0.02836396f, 0.06235090f, 0.11237539f, -0.11211099f, -0.18695945f, 0.21161731f, 
    -0.25688666f, -0.08832851f, -0.02421173f, -0.09958565f, 0.00204545f, 0.11404423f, 0.08128121f, -0.31840864f, 
    -0.21675761f, 0.07706335f, -0.01478307f, 0.08607309f, 0.01058004f, 0.02088122f, -0.10486240f, -0.15828775f, 
    -0.35560936f, -0.28886312f, -0.00590934f, 0.01212341f, 0.10273755f, -0.06843367f, 0.11643992f, 0.09242409f, 
    -0.09112794f, -0.14376570f, -0.00979171f, -0.07705172f, -0.18153214f, 0.04561533f, 0.09237941f, -0.05149428f, 
    -0.17784388f, -0.09625761f, -0.29816407f, 0.03356955f, -0.19194207f, -0.12384867f, -0.05593760f, -0.03483163f, 
    0.00820115f, -0.11038752f, -0.29211825f, -0.07096182f, 0.12626636f, -0.04174890f, -0.00745924f, -0.19447568f, 
    0.15813424f, 0.05930453f, 0.07005487f, -0.04085179f, -0.21095258f, -0.00210900f, 0.08686551f, -0.04975511f, 
    0.01162172f, 0.02602675f, -0.00104556f, 0.10480553f, 0.34092727f, -0.02526229f, -0.28524125f, -0.06398337f, 
    0.02140411f, 0.08979717f, 0.12227058f, 0.05871630f, -0.04535048f, -0.34533575f, -0.46785578f, 0.09877193f, 
    0.06710092f, 0.04265300f, -0.13426064f, 0.11497642f, 0.03709924f, -0.07993409f, -0.14300817f, -0.32397404f, 
    0.21870615f, -0.01726078f, -0.00272454f, 0.05322378f, -0.08934962f, 0.02124514f, 0.08752448f, -0.26084593f, 
    0.12222481f, 0.05134367f, -0.15332893f, -0.21582970f, -0.08673631f, -0.16668361f, 0.01824640f, -0.17775774f, 
    0.30648172f, -0.11387909f, -0.23953021f, 0.02298492f, 0.03931116f, 0.01030846f, 0.16062641f, 0.02846505f, 
    0.07671645f, 0.09900203f, -0.15704551f, -0.32995135f, 0.13558747f, 0.04481606f, -0.02466557f, -0.02453337f, 
    0.07747298f, 0.02469953f, -0.53087687f, -0.50571060f, -0.23874518f, 0.03870206f, -0.10219329f, -0.03316787f, 
    -0.00620559f, 0.10922910f, -0.03839039f, 0.01627837f, 0.18203755f, 0.04404559f, -0.11729254f, -0.10698713f, 
    0.11539503f, 0.04413851f, -0.00666236f, 0.02738335f, 0.55752087f, -0.64381677f, -0.52566803f, 0.00329055f, 
    0.07388368f, -0.10926346f, 0.07646780f, -0.05426192f, -0.01366319f, 0.37436894f, 0.03147811f, -0.16600059f, 
    -0.00067338f, -0.01353515f, 0.07899956f, -0.09261825f, 0.03865259f, 0.15944529f, -0.11981099f, 0.09723079f, 
    0.12620306f, -0.08120696f, 0.01400527f, -0.00509580f, 0.15844803f, 0.09973411f, 0.08287551f, -0.00039382f, 
    0.03645091f, -0.00747887f, 0.00250361f, -0.04657407f, 0.00907651f, 0.01649796f, 0.07927746f, 0.05124397f, 
    0.26161382f, 0.13358206f, -0.09942335f, -0.02715720f, 0.03729208f, -0.00314769f, 0.20817149f, -0.08436432f, 
    0.05524475f, 0.02651319f, -0.22057767f, -0.04534865f, 0.00311710f, -0.14787865f, -0.07223864f, 0.06266623f, 
    -0.00730806f, -0.04837173f, -0.09558472f, 0.31324992f, 0.04355568f, -0.07455941f, -0.07036044f, 0.06638690f, 
    0.01896813f, 0.11269068f, 0.07530685f, 0.00556725f, -0.25993761f, -0.37586808f, 0.06050530f, -0.17837946f, 
    0.16924922f, 0.11320975f, -0.06222153f, -0.17018925f, 0.03927568f, -0.14655821f, 0.08242150f, -0.00205336f, 
    -0.00610069f, -0.10194410f, 0.04079174f, -0.02752747f, -0.22086200f, 0.21716991f, -0.00139964f, 0.10654539f, 
    0.00156242f, -0.03165146f, 0.00941591f, 0.08382591f, 0.05700107f, 0.01531669f, -0.26596937f, 0.16437903f, 
    -0.03166433f, -0.11145906f, 0.00965117f, 0.03457356f, 0.01637950f, -0.03302231f, -0.02939830f, -0.13800219f, 
    -0.18743320f, 0.10827314f, -0.07377910f, 0.06790244f, 0.03461148f, 0.05097651f, 0.02221781f, -0.11577245f, 
    0.18051323f, -0.35599738f, 0.16597356f, 0.06644617f, 0.12092529f, -0.10807732f, -0.09994818f, -0.02472466f, 
    0.08730644f, -0.10018109f, 0.02899128f, -0.16768786f, -0.16020696f, -0.10613248f, -0.08472433f, 0.03213860f, 
    -0.07202009f, 0.01394947f, 0.30226040f, 0.18239294f, -0.20760199f, 0.03357855f, 0.11516843f, -0.06946544f, 
    0.07058079f, -0.03574015f, -0.04808166f, 0.09415993f, -0.07827911f, -0.16356987f, 0.06470418f, 0.11416110f, 
    -0.16387445f, 0.06185564f, 0.03007150f, 0.06209375f, 0.24304205f, 0.15913837f, -0.16066137f, -0.18431775f, 
    0.22222696f, 0.00658415f, 0.11827587f, -0.05363178f, -0.00461991f, -0.07208193f, -0.17009497f, -0.28775460f, 
    -0.12477200f, 0.01268435f, -0.01875863f, 0.06859267f, -0.06410114f, 0.10975458f, -0.19561255f, 0.13481250f, 
    -0.04355255f, 0.07287183f, -0.02323509f, -0.00051640f, 0.09608691f, 0.20568274f, 0.00796924f, -0.14060347f, 
    0.23833705f, 0.22380814f, -0.02538920f, 0.07387583f, -0.03347784f, -0.06433906f, 0.05621406f, 0.02770613f, 
    0.08422936f, 0.11149664f, -0.08075517f, 0.06416856f, -0.13338679f, -0.03234970f, -0.07773469f, -0.18020555f, 
    -0.14653091f, 0.11533736f, 0.28345209f, -0.02233846f, -0.02187135f, 0.00639693f, -0.01910274f, -0.18201938f, 
    0.08559757f, -0.03448431f, -0.41227427f, -0.09982716f, -0.02267666f, -0.04638425f, -0.00306223f, 0.00323334f, 
    0.02037739f, 0.13512747f, -0.11005958f, 0.12352681f, -0.01856066f, 0.07525434f, 0.00163490f, 0.04095661f, 
    0.00361785f, 0.14613464f, 0.08950718f, 0.09953784f, 0.09055416f, 0.02190725f, 0.13252781f, 0.03903551f, 
    0.04114071f, 0.12217297f, 0.03190698f, 0.04716991f, 0.14707689f, -0.04631078f, -0.01381445f, -0.00878888f, 
    -0.00015574f, 0.06613437f, 0.16618548f, 0.18655910f, 0.11556745f, 0.16831523f, -0.18595365f, -0.02724496f, 
    0.11625839f, 0.05146395f, 0.14975268f, 0.14260913f, 0.18731363f, -0.00289060f, -0.07115961f, -0.31366667f, 
    -0.07348939f, -0.21286738f, 0.20136055f, 0.12596966f, 0.19955294f, -0.06294806f, 0.21230042f, 0.01286489f, 
    0.15317488f, -0.08781300f, 0.26013047f, -0.05369597f, 0.06702641f, 0.06935460f, 0.14944215f, -0.06355467f, 
    0.02833833f, 0.28290817f, 0.01262623f, 0.14982171f, 0.06995592f, 0.01126877f, -0.01776911f, 0.00440953f, 
    0.09477080f, 0.05620417f, 0.14266202f, 0.11412061f, -0.06687964f, -0.03869165f, 0.07438637f, -0.01263019f, 
    0.01098253f, 0.00540984f, -0.11698079f, -0.23215979f, -0.08959409f, 0.03998421f, 0.05603487f, 0.05437316f, 
    -0.12647825f, 0.02801484f, -0.06702432f, 0.18475412f, -0.05363908f, -0.10316026f, 0.29701921f, 0.02715734f, 
    0.07643592f, -0.05634480f, 0.15867071f, -0.05206056f, 0.02516473f, -0.04767289f, 0.11132734f, 0.18963329f, 
    0.17344169f, 0.03713337f, -0.04117607f, -0.00122592f, 0.06515055f, 0.01756280f, 0.06417944f, 0.06610392f, 
    -0.07517251f, 0.02171254f, -0.05749135f, 0.05479950f, -0.05994568f, -0.16287848f, -0.24735443f, -0.18654348f, 
    0.02198555f, -0.06211647f, 0.26739547f, 0.01707977f, -0.06306846f, 0.09975206f, 0.16420574f, 0.13432774f, 
    0.33607340f, 0.00190864f, 0.18430358f, 0.03990202f, -0.08350410f, -0.03566431f, 0.15478480f, 0.01838268f, 
    0.26656500f, 0.23924516f, 0.08092660f, 0.12312897f, 0.07945120f, 0.05959401f, -0.19362070f, 0.04910191f, 
    -0.22141680f, -0.02975773f, -0.11381193f, -0.29169419f, -0.01608390f, 0.03253397f, -0.01129311f, -0.01949420f, 
    -0.19460768f, -0.10827687f, -0.36937061f, -0.05594296f, 0.40189683f, 0.32045877f, -0.01235505f, -0.09558433f, 
    -0.02067422f, 0.07639980f, 0.18045489f, -0.00167939f, -0.07654469f, 0.02717870f, -0.03095331f, 0.10206502f, 
    0.19109222f, 0.16194876f, -0.12832166f, 0.10334864f, 0.17528836f, -0.01062305f, 0.07811932f, 0.06224756f, 
    0.10188512f, 0.14301921f, 0.15039855f, 0.03704005f, 0.02476889f, 0.26727453f, -0.18365127f, -0.05935575f, 
    -0.09757180f, 0.06086578f, -0.02811846f, 0.11257433f, -0.10740189f, 0.08278335f, -0.02068476f, 0.03860444f, 
    0.10160594f, 0.04329933f, -0.00264884f, 0.06772198f, 0.11633501f, 0.11718628f, 0.02178028f, 0.23510496f, 
    0.08965957f, 0.00598551f, 0.20031844f, 0.18248837f, 0.07679429f, -0.04520898f, -0.09594472f, -0.01440417f, 
    -0.06947362f, 0.01446720f, 0.05511336f, 0.01692601f, 0.00546079f, 0.12759206f, 0.02446784f, 0.03983751f, 
    0.08019676f, 0.04612794f, 0.12424185f, 0.07384317f, 0.14565182f, 0.11471322f, 0.00215426f, -0.00776275f, 
    0.06407948f, 0.12937613f, 0.09785584f, 0.16675392f, 0.07357404f, -0.16676016f, 0.09526512f, -0.11950740f, 
    0.04978418f, 0.07525145f, 0.23695499f, -0.04481446f, -0.05611467f, 0.02433128f, 0.03629185f, 0.06727453f, 
    0.04313497f, 0.04284773f, -0.05419078f, -0.09605635f, 0.00385496f, -0.01617147f, 0.22236010f, -0.13326532f, 
    0.24714497f, -0.02955909f, 0.03158347f, -0.02184966f, 0.01460041f, -0.29248187f, -0.36353976f, -0.12075976f, 
    0.03705436f, 0.01847829f, 0.06214665f, -0.06204879f, -0.17717713f, -0.12577088f, -0.11816406f, -0.01984958f, 
    -0.17767715f, 0.06076291f, 0.00414811f, 0.05762465f, 0.05694859f, 0.07310154f, 0.00526589f, 0.12419651f, 
    -0.00139395f, -0.00088480f, 0.06986681f, -0.18784265f, -0.04931659f, 0.09923252f, -0.03273126f, -0.02587621f, 
    -0.12321365f, -0.05499756f, -0.10990826f, 0.24972165f, 0.02704609f, -0.07279475f, -0.13329756f, -0.14364997f, 
    0.03933405f, 0.15058993f, -0.08216494f, -0.35961011f, -0.23998283f, -0.01541516f, 0.10813717f, 0.05844026f, 
    0.13171715f, -0.00766522f, 0.04404437f, -0.34940603f, -0.05691783f, -0.03912150f, 0.05246783f, 0.04023092f, 
    -0.22050326f, 0.05096603f, 0.00478073f, 0.08222291f, 0.08781546f, 0.20252715f, -0.26224607f, -0.08456477f, 
    -0.08965829f, -0.03107397f, 0.08888021f, 0.22111113f, 0.16543147f, -0.04762837f, -0.09123756f, -0.00519102f, 
    -0.09963623f, 0.06270601f, 0.11900771f, -0.01327661f, 0.04371900f, 0.10561591f, -0.12528127f, -0.18182908f, 
    -0.07148488f, 0.04652662f, 0.15890551f, -0.05527128f, 0.14153329f, 0.05534817f, -0.00876051f, -0.16961513f, 
    -0.05647342f, 0.02600799f, -0.06247113f, -0.05746888f, -0.01852836f, -0.00342614f, -0.07376009f, 0.03479344f, 
    0.18924944f, 0.17564094f, -0.02767095f, 0.02832991f, 0.10638884f, 0.06086598f, 0.19817854f, 0.12830769f, 
    0.03019099f, -0.04473747f, -0.13139687f, -0.14449324f, 0.03494083f, 0.00997247f, 0.10117619f, 0.02520959f, 
    0.00706296f, -0.07343397f, -0.22601929f, -0.15067828f, -0.02950081f, -0.05536101f, 0.07047941f, -0.05630936f, 
    0.23954897f, 0.07566368f, 0.04972916f, -0.08317269f, 0.10060688f, 0.07329670f, -0.07476135f, 0.08182885f, 
    -0.15550071f, 0.17955457f, -0.02182969f, -0.07261815f, -0.15890962f, 0.23953514f, -0.38156378f, -0.05962845f, 
    0.03297494f, -0.02633006f, 0.05384948f, 0.04736675f, 0.03783350f, 0.26794344f, 0.09632541f, -0.42378512f, 
    -0.08771455f, -0.03605628f, 0.08003659f, -0.12933132f, 0.06610508f, 0.11297304f, 0.07640114f, 0.00781078f, 
    0.13907719f, 0.02932298f, 0.09190883f, -0.12806478f, 0.03971948f, -0.03338570f, 0.02620687f, 0.15395340f, 
    -0.00496751f, -0.01372424f, 0.03052606f, 0.13340412f, 0.00203891f, 0.08217232f, 0.05338167f, 0.06618426f, 
    -0.08490914f, -0.03890293f, -0.02166291f, 0.02529337f, 0.06563455f, 0.07653999f, 0.07856248f, 0.09327270f, 
    -0.01990077f, -0.04871814f, 0.04774913f, -0.05241954f, 0.07960856f, -0.09611272f, 0.00141110f, 0.04181213f, 
    0.02183597f, 0.01874263f, -0.05304879f, -0.00352546f, -0.04929737f, -0.03445708f, -0.16185819f, -0.13504410f, 
    -0.05955043f, 0.01773600f, 0.06028506f, -0.01581699f, -0.14184022f, -0.22383732f, 0.09225111f, 0.03202493f, 
    0.14966351f, 0.12721930f, -0.11316107f, -0.05145889f, 0.09828715f, 0.36576244f, -0.07939865f, -0.07122921f, 
    -0.03383069f, 0.02241477f, -0.08266149f, 0.07479469f, 0.04722381f, 0.25032756f, 0.19719295f, -0.02159327f, 
    -0.06045622f, 0.09049291f, 0.06315104f, 0.03498383f, 0.06794547f, 0.02018314f, 0.42639664f, 0.12394165f, 
    0.17842630f, -0.00927001f, 0.00496931f, 0.07915800f, 0.04389291f, 0.02310118f, 0.02551812f, 0.12015337f, 
    -0.29362696f, 0.06929927f, 0.00320826f, 0.05626640f, 0.01576375f, 0.09503761f, 0.05964969f, 0.25199094f, 
    -0.28465706f, -0.32973403f, 0.06842011f, -0.01754251f, 0.13024397f, 0.05595705f, 0.03012016f, -0.15727457f, 
    0.10253461f, -0.07863819f, 0.01218145f, -0.03789641f, -0.10069822f, -0.05978598f, -0.08185824f, -0.09779736f, 
    0.03352168f, 0.06943905f, -0.31586689f, 0.18411484f, 0.04405425f, -0.04044281f, 0.05521810f, -0.00991756f, 
    0.04401759f, 0.00755944f, -0.06447568f, -0.15875162f, -0.04542078f, -0.19118148f, -0.05083822f, 0.12364575f, 
    -0.02230950f, 0.06704038f, -0.05232811f, -0.13091287f, -0.35833821f, 0.15377352f, 0.21040897f, -0.00732658f, 
    -0.03872631f, -0.00776238f, -0.04560131f, -0.05242824f, 0.10039993f, -0.10294335f, -0.29712129f, -0.34326035f, 
    -0.07387255f, 0.00867194f, -0.02310076f, -0.09508518f, -0.14053230f, -0.00177248f, -0.19882230f, -0.08715425f, 
    -0.09582080f, 0.08724087f, 0.04238079f, 0.00358644f, 0.17686972f, -0.06087900f, 0.07234566f, 0.14024203f, 
    0.03446569f, 0.15283871f, 0.08569300f, 0.08468884f, 0.06176960f, -0.10420429f, 0.05279122f, -0.00583945f, 
    -0.20043072f, 0.22929297f, 0.13752222f, 0.08608790f, -0.15817206f, 0.01706207f, -0.06237613f, 0.11582677f, 
    0.01991017f, -0.46714714f, -0.14786305f, -0.18949939f, 0.01882804f, 0.01138189f, 0.11849147f, 0.11894152f, 
    0.08021154f, 0.07074460f, -0.00158180f, -0.53075665f, -0.20870803f, 0.11739125f, 0.11828847f, -0.22630401f, 
    0.11222196f, -0.09947561f, -0.02208367f, -0.12671225f, 0.07557992f, -0.07377829f, 0.00742620f, -0.01592172f, 
    -0.07089610f, 0.07272390f, 0.07226931f, -0.07630289f, -0.04354205f, 0.14315398f, 0.04545573f, -0.04321151f, 
    0.20678449f, 0.10723646f, 0.08376842f, 0.01499380f, 0.04223510f, 0.26807421f, 0.21199356f, -0.19553103f, 
    0.05956895f, -0.06286373f, 0.11483704f, 0.11531135f, 0.01129731f, 0.00734962f, 0.03076433f, -0.45275998f, 
    -0.09856356f, -0.10988288f, -0.04623315f, -0.08899506f, -0.12620382f, -0.13163085f, -0.09853382f, -0.19144085f, 
    -0.16120674f, 0.02986903f, 0.04095931f, -0.14982539f, -0.04086583f, -0.03611544f, 0.13502581f, 0.01268746f, 
    0.11277431f, 0.37658593f, -0.01970788f, 0.02622499f, 0.02802736f, -0.08682833f, -0.00778882f, 0.04036528f, 
    0.03377264f, -0.29114962f, 0.07375416f, 0.05704841f, -0.03870617f, -0.01452931f, 0.04874145f, 0.04490031f, 
    0.00979690f, 0.11557499f, -0.22842710f, -0.25222933f, -0.08198309f, -0.27318060f, -0.09759878f, -0.17110687f, 
    0.04632481f, 0.05054523f, 0.03943693f, -0.27296844f, 0.10713314f, 0.09779125f, -0.04548797f, -0.03027923f, 
    -0.01557014f, -0.02074186f, 0.09607674f, 0.03926739f, 0.20717250f, 0.33382714f, -0.54592860f, -0.06672882f, 
    -0.01696408f, -0.09288909f, -0.12942642f, -0.01346031f, -0.15006116f, -0.39094642f, -0.44413540f, -0.23677488f, 
    -0.00430972f, 0.01550560f, 0.06265125f, 0.03035398f, 0.16929439f, 0.14311545f, 0.17325766f, 0.24231240f, 
    0.19052304f, -0.09086223f, -0.08677544f, 0.07298674f, 0.12641299f, 0.08866896f, 0.10312792f, 0.16956757f, 
    0.06535953f, 0.12661970f, 0.11556600f, 0.13458805f, 0.21543571f, 0.10378344f, -0.12533274f, -0.00336216f, 
    -0.26545146f, -0.01828406f, 0.10333936f, -0.00740847f, -0.04172762f, -0.04318932f, 0.07543528f, 0.06386543f, 
    0.19674255f, -0.43406945f, -0.20149326f, -0.16121180f, -0.10570843f, -0.23366195f, 0.03255347f, 0.13242581f, 
    0.08318401f, -0.07376734f, -0.17816193f, -0.15904579f, -0.07453578f, -0.05035640f, 0.00740611f, -0.02771456f, 
    0.03545799f, 0.03365082f, 0.13725139f, -0.39604929f, -0.31252918f, -0.34761471f, 0.09853254f, -0.00019127f, 
    -0.12901302f, -0.01046911f, -0.23019192f, -0.07461321f, 0.03858496f, 0.05439283f, -0.18603025f, 0.11643523f, 
    0.12882811f, 0.04309349f, 0.10941518f, -0.13287197f, 0.01953200f, -0.16528715f, -0.04564627f, -0.02096194f, 
    0.05323323f, 0.17508452f, 0.05913068f, 0.02207328f, 0.04276001f, 0.01451079f, 0.08545005f, -0.15499601f, 
    -0.06940062f, -0.10813116f, 0.06230218f, -0.03408194f, 0.06602037f, 0.05812423f, -0.01263409f, -0.01107084f, 
    -0.11924151f, -0.10451683f, -0.01514681f, 0.03393893f, 0.04233882f, 0.01278696f, 0.00019734f, -0.09465261f, 
    -0.60737389f, -0.20592798f, -0.28126222f, -0.13646935f, -0.09612705f, 0.05882108f, 0.10564432f, -0.12597038f, 
    -0.02027192f, -0.04951522f, 0.05391180f, 0.08737105f, 0.00754051f, -0.11236269f, 0.04229767f, 0.31881297f, 
    0.07816591f, 0.11017533f, -0.31145558f, 0.29156494f, 0.22502626f, -0.07025879f, -0.06154875f, -0.00673905f, 
    -0.09739590f, 0.02236022f, 0.03897909f, -0.39988899f, -0.27272895f, -0.19793802f, -0.08000241f, -0.11921938f, 
    -0.32484874f, -0.19566266f, -0.01939181f, 0.01263339f, 0.19341363f, 0.40449134f, 0.40585014f, -0.04012187f, 
    -0.03461654f, -0.05720660f, 0.05752864f, 0.11400806f, 0.12132321f, 0.15532380f, -0.04472597f, 0.36976764f, 
    -0.36775282f, -0.35645252f, -0.03959013f, -0.08826955f, -0.09167733f, 0.00141574f, -0.28128678f, 0.04931976f, 
    0.05611141f, 0.10908795f, 0.10327500f, -0.09701266f, 0.08144945f, 0.14777152f, 0.22051027f, -0.01286943f, 
    -0.06452648f, 0.01091170f, 0.10592604f, 0.15565340f, -0.00475825f, -0.10893152f, 0.12047290f, 0.10742512f, 
    0.05676914f, -0.02049981f, -0.00024746f, -0.04524252f, -0.03094695f, -0.03148209f, -0.15117945f, 0.02328306f, 
    0.03801006f, 0.02976599f, -0.17006946f, 0.11327212f, 0.04245158f, 0.09588967f, -0.08391342f, -0.04064634f, 
    0.08719905f, 0.03926791f, -0.04049772f, 0.11007552f, 0.27188310f, -0.20285843f, -0.10115121f, -0.16127801f, 
    -0.01985602f, 0.00660338f, -0.00574738f, -0.22480865f, -0.07957077f, -0.03370884f, -0.02569911f, -0.09632048f, 
    -0.26464915f, 0.13487627f, -0.01915507f, 0.04848240f, 0.00965938f, 0.08420856f, -0.08527453f, 0.05628708f, 
    -0.01773481f, 0.15038915f, 0.07291979f, 0.00937038f, 0.11684779f, 0.03817865f, -0.21894614f, 0.09807547f, 
    0.10145705f, 0.04835588f, -0.07594681f, 0.18267052f, -0.01722758f, -0.08393053f, -0.07541377f, 0.21820968f, 
    -0.09425335f, 0.07594410f, -0.18766499f, -0.15947725f, -0.01741431f, -0.05609447f, 0.10382594f, 0.02845990f, 
    0.15888061f, 0.22511125f, 0.05754734f, -0.05130316f, -0.21452421f, -0.05801716f, 0.15980947f, -0.06053443f, 
    0.06433073f, -0.16450098f, 0.14913487f, 0.09011906f, -0.02573188f, 0.21149339f, 0.00996130f, 0.08463693f, 
    0.00414659f, -0.20330954f, 0.05388643f, -0.08949929f, -0.14226216f, 0.02166607f, 0.06429212f, -0.05056424f, 
    0.17123957f, 0.08064967f, -0.24028523f, -0.26628527f, -0.07153350f, -0.33173838f, 0.04688773f, 0.06643423f, 
    0.05416896f, 0.07655283f, 0.01333283f, -0.11729072f, 0.29848874f, 0.26216191f, -0.11731695f, 0.13647206f, 
    -0.05122766f, 0.04238641f, -0.00804717f, -0.03893412f, -0.14390427f, -0.19238073f, -0.16891509f, 0.01779976f, 
    -0.04995358f, 0.23348160f, 0.10911489f, -0.06783224f, -0.06722064f, 0.03806393f, 0.32557595f, -0.01811190f, 
    -0.12306638f, 0.03336905f, -0.00752308f, -0.13343082f, 0.09698888f, -0.09140172f, -0.11328702f, -0.16281064f, 
    0.05046967f, 0.11653200f, 0.05890528f, -0.25858635f, -0.11798612f, 0.07246716f, 0.24941295f, 0.01627358f, 
    0.19737777f, 0.03726047f, 0.12338547f, 0.06660122f, -0.01067920f, 0.10437190f, -0.07310349f, -0.02779888f, 
    0.02285514f, -0.22315477f, 0.35616112f, 0.06011417f, 0.12557279f, 0.02955613f, 0.05540064f, 0.02400063f, 
    0.01175546f, 0.06380834f, -0.15018077f, 0.19549394f, -0.03285886f, -0.16275927f, -0.15570875f, -0.04388440f, 
    0.07554978f, 0.00904283f, -0.08444032f, 0.13660212f, 0.11228267f, 0.14860974f, -0.17535178f, -0.03916238f, 
    -0.11573085f, 0.02965221f, 0.05677716f, -0.92290956f, -0.33419004f, -0.26543897f, -0.10787021f, -0.22279717f, 
    0.19942372f, 0.14163220f, -0.17170021f, -0.19645421f, 0.15993851f, -0.12550268f, 0.07129400f, 0.00150827f, 
    -0.10560240f, 0.10675328f, -0.06523506f, 0.01711340f, -0.18464729f, 0.12952714f, 0.04360993f, 0.00536622f, 
    -0.07909372f, 0.07913337f, 0.21824683f, 0.00651345f, -0.02999669f, -0.09134364f, 0.20153314f, 0.38815108f, 
    -0.01236140f, 0.03382861f, -0.27248317f, 0.01772888f, -0.07110560f, 0.03404482f, -0.08922502f, -0.05177194f, 
    -0.04736949f, 0.05569735f, 0.05457005f, -0.01800737f, 0.10797187f, -0.05504173f, 0.04521526f, -0.14551209f, 
    -0.25934905f, -0.50957531f, 0.25358042f, 0.06155983f, 0.12702949f, 0.08871036f, 0.02810362f, -0.05969785f, 
    -0.19995347f, 0.04793192f, -0.11618166f, -0.06102166f, -0.02768905f, 0.04693075f, 0.06438145f, 0.15902027f, 
    0.06933039f, -0.02844361f, -0.26659784f, 0.15560889f, 0.10750350f, 0.03117701f, 0.07151228f, -0.10009976f, 
    -0.03177316f, 0.13038954f, -0.04133423f, -0.34067303f, -0.09997638f, 0.21310708f, -0.19956619f, 0.09485483f, 
    -0.26194614f, -0.14235614f, 0.06601539f, -0.19224466f, -0.26328883f, 0.03083021f, -0.07526043f, -0.03730633f, 
    0.00794321f, -0.06147928f, -0.12292177f, -0.10652560f, 0.02674212f, -0.27414909f, -0.11045985f, -0.61147076f, 
    0.16127075f, -0.00581318f, -0.25764474f, -0.30890617f, -0.02986412f, 0.35108995f, -0.16907054f, 0.20403413f, 
    0.06897520f, 0.11119176f, 0.09425953f, -0.14459941f, 0.11235525f, 0.07255119f, 0.15281287f, 0.03614198f, 
    0.13872010f, 0.22239916f, -0.01358393f, 0.01925126f, 0.10515281f, 0.05309798f, 0.06992133f, -0.02275783f, 
    -0.12392457f, 0.07168144f, 0.26143944f, -0.02917272f, 0.04227369f, -0.02450000f, 0.25374511f, 0.08464360f, 
    0.05552419f, -0.12876911f, 0.18425456f, 0.36436254f, 0.01577797f, 0.01143633f, -0.22198755f, 0.22192582f, 
    0.05663124f, 0.05455909f, -0.12545583f, 0.00413905f, 0.24850143f, -0.06419796f, 0.05215576f, -0.08409192f, 
    -0.17486802f, -0.03365346f, 0.01877749f, -0.03788027f, 0.10650161f, 0.35375631f, 0.18755375f, 0.19950421f, 
    0.06620622f, 0.10887694f, -0.03564197f, -0.07446122f, -0.20413740f, 0.07035970f, -0.20536307f, 0.09676601f, 
    0.12268794f, 0.09521046f, 0.09570255f, 0.19336122f, 0.14384097f, -0.38418138f, -0.14695150f, -0.04485795f, 
    -0.06557926f, 0.09617034f, 0.04626348f, -0.20300958f, -0.05070922f, 0.14940512f, -0.21562141f, -0.19872580f, 
    0.03700908f, 0.10099550f, -0.00856071f, 0.09385163f, -0.16710879f, -0.11282668f, -0.01815517f, -0.41513178f, 
    -0.15492806f, -0.03770142f, 0.07884064f, -0.21255849f, -0.23110488f, 0.12008634f, -0.03792652f, 0.12994884f, 
    0.24900927f, 0.26123726f, 0.18839139f, 0.21382615f, 0.23986523f, 0.15831238f, 0.12352623f, 0.10026733f, 
    0.04939829f, -0.04773057f, 0.07226161f, 0.09882664f, 0.13785338f, 0.04794501f, 0.05335810f, 0.24669923f, 
    0.11512126f, 0.01436514f, 0.02988133f, 0.16136144f, 0.19081748f, 0.12436073f, 0.17370123f, -0.05909075f, 
    -0.10799840f, 0.13382541f, -0.47549400f, 0.01174993f, 0.08431032f, -0.08115041f, 0.00734960f, 0.10643924f, 
    0.01373405f, 0.05355651f, 0.17031130f, 0.02925448f, -0.03345382f, -0.00990500f, 0.23254295f, 0.11859369f, 
    0.23543198f, 0.07162465f, -0.16999380f, -0.12808353f, -0.19358860f, -0.11349849f, -0.27254653f, -0.10878033f, 
    -0.21628556f, -0.05369911f, -0.10787989f, -0.02443991f, 0.10921580f, -0.00301712f, -0.08576852f, 0.13263609f, 
    0.28509867f, 0.13723081f, 0.18633664f, -0.00488296f, 0.32543311f, 0.07445008f, 0.22660267f, -0.18431748f, 
    0.01899847f, -0.12885183f, 0.13622348f, -0.10168912f, 0.08913080f, 0.14046772f, 0.26331058f, 0.12892567f, 
    -0.29151806f, 0.14337434f, 0.15793696f, -0.03245738f, 0.31725931f, 0.17217901f, 0.02868477f, 0.15584727f, 
    0.16405793f, 0.02147870f, -0.01693909f, 0.52279037f, 0.08366734f, 0.13441364f, -0.02417199f, 0.11733221f, 
    0.04956581f, 0.09442534f, -0.24166681f, -0.07289795f, -0.07051899f, 0.01533027f, -0.18545868f, 0.03469770f, 
    -0.10370278f, -0.07267970f, -0.10704350f, -0.17104435f, -0.18526334f, 0.26848841f, 0.22394824f, 0.10983782f, 
    0.02047443f, -0.05005607f, -0.42490771f, 0.02470674f, -0.29566869f, 0.05114691f, -0.08767830f, -0.13455845f, 
    0.15938546f, 0.07724024f, -0.02655644f, 0.24581227f, 0.42688623f, -0.13131702f, -0.01155666f, -0.12990427f, 
    0.04621329f, 0.06159412f, 0.02669596f, 0.06288050f, 0.16572255f, 0.27610147f, -0.33905968f, -0.13205484f, 
    -0.11970710f, -0.28452736f, -0.09895846f, -0.00540071f, -0.10037105f, 0.10693119f, -0.02994092f, -0.05800566f, 
    -0.06529392f, 0.11521837f, 0.02488185f, 0.12266499f, 0.21915776f, -0.11234527f, -0.12248193f, 0.01188428f, 
    -0.18810987f, 0.11320054f, 0.30880845f, -0.06544667f, 0.17765090f, 0.01155589f, 0.01688251f, -0.10616842f, 
    -0.04939761f, -0.42212310f, -0.20332110f, -0.10420515f, -0.09801776f, -0.15582818f, -0.12075628f, 0.03552454f, 
    -0.13646735f, -0.05861454f, -0.10993314f, -0.23706067f, 0.10408626f, -0.03437815f, 0.05704902f, 0.05116240f, 
    0.09352743f, 0.09786737f, 0.10302369f, -0.16883206f, 0.08443126f, 0.14200097f, 0.19501303f, 0.02543598f, 
    -0.11280921f, -0.01443832f, -0.11556971f, -0.12748675f, -0.31586593f, 0.13964310f, 0.35575911f, 0.05520478f, 
    0.03737898f, 0.01204930f, 0.10216869f, 0.17904751f, 0.19864199f, -0.59519720f, -0.06996348f, -0.26612094f, 
    -0.15904161f, -0.09379117f, -0.33794376f, 0.11092219f, 0.15193844f, 0.02679267f, -0.13258207f, -0.00337375f, 
    0.07827611f, 0.06681947f, -0.02700634f, 0.07584888f, 0.06154865f, -0.01037814f, 0.15474644f, -0.06894604f, 
    0.03420959f, -0.02573398f, -0.09883498f, -0.05468883f, 0.26152968f, 0.10840016f, 0.15496174f, 0.06595369f, 
    -0.05820052f, 0.04601158f, -0.01074328f, -0.04299606f, -0.04811079f, -0.03588797f, -0.03590973f, -0.02170996f, 
    0.01714280f, -0.04106896f, 0.03735356f, -0.04953211f, -0.00112031f, -0.02856594f, -0.03727540f, 0.01316003f, 
    0.04611811f, -0.04072495f, -0.01000592f, -0.02040713f, 0.04258652f, 0.01632903f, 0.00925091f, -0.00692473f, 
    -0.03289619f, -0.00525381f, 0.02401864f, 0.00124793f, -0.04530818f, 0.01314213f, 0.04462934f, -0.04597216f, 
    0.01567319f, -0.01185234f, -0.00429479f, -0.04514218f, 0.04489522f, -0.03443335f, -0.03567576f, 0.02285605f, 
    0.05285925f, 0.02248131f, -0.00627369f, 0.01884358f, -0.06369670f, 0.03361562f, -0.00742310f, 0.00957988f, 
    -0.00258994f, 0.00446138f, -0.03980473f, -0.06372090f, 0.05318734f, 0.03343900f, 0.04921604f, 0.00010794f, 
    0.05442023f, 0.01171319f, 0.02822155f, 0.02602035f, 0.03251088f, 0.03969229f, -0.05249575f, -0.05333000f, 
    -0.00836078f, 0.00350317f, -0.01998453f, 0.04365881f, -0.00704088f, -0.05666519f, -0.02435772f, 0.01192407f, 
    -0.05833539f, -0.04638451f, -0.00541568f, 0.04527708f, -0.02954446f, -0.04223849f, 0.04400893f, 0.02453245f, 
    -0.06273893f, -0.04936845f, -0.06271836f, 0.01627653f, 0.03979027f, 0.04498411f, 0.02547606f, -0.02460434f, 
    0.02799220f, 0.03061976f, -0.05838635f, 0.04231027f, -0.01126216f, 0.02034940f, 0.00906789f, -0.05388394f, 
    0.01793151f, 0.02131643f, 0.02156692f, -0.01883733f, 0.03257941f, -0.06181466f, -0.02191861f, -0.01114795f, 
    -0.03142522f, -0.01439828f, -0.05725129f, -0.03875118f, 0.05253302f, 0.03314785f, -0.00343192f, -0.03413615f, 
    0.03433016f, -0.04247147f, 0.00104388f, -0.00796951f, -0.02766548f, -0.02997680f, -0.01781806f, -0.05747617f, 
    -0.02134118f, -0.04870002f, 0.02324512f, -0.04588918f, 0.03451221f, 0.03509244f, -0.00979195f, -0.05385770f, 
    0.03212036f, -0.06372644f, 0.02150817f, -0.04624682f, 0.05268282f, -0.05938205f, -0.04514258f, -0.01600979f, 
    -0.05163861f, 0.04241713f, -0.04033043f, -0.06164992f, -0.05594979f, 0.05218440f, -0.00337163f, -0.03937879f, 
    0.02721058f, -0.06351922f, -0.05189448f, 0.04713479f, -0.01561736f, -0.01979706f, -0.00452663f, 0.01291102f, 
    0.02884444f, -0.05116133f, -0.04989200f, -0.05060234f, -0.04500474f, -0.01638965f, 0.04192790f, 0.05283824f, 
    0.02636400f, -0.01962755f, 0.04309174f, -0.02056599f, 0.04742520f, -0.01036109f, 0.00976458f, -0.05526036f, 
    -0.04535288f, -0.01334719f, 0.00292424f, -0.03484233f, -0.01992029f, 0.05311735f, -0.04691793f, -0.02093287f, 
    0.04827111f, 0.03039796f, 0.00951630f, -0.01306377f, -0.04142043f, 0.02182561f, -0.04812753f, -0.01316728f, 
    0.03456989f, 0.03101727f, -0.01701705f, -0.05096502f, 0.02540090f, -0.00982871f, -0.05285425f, 0.03539626f, 
    -0.02110750f, 0.04771436f, -0.01159271f, 0.02483844f, -0.05620022f, 0.01762358f, -0.01053972f, 0.04773037f, 
    -0.05103086f, -0.00733513f, 0.02820578f, 0.00466528f, 0.03489281f, -0.04868333f, -0.02697462f, 0.03085769f, 
    -0.02025027f, 0.02167914f, -0.04341155f, -0.02320806f, -0.00596259f, 0.04417867f, -0.04117050f, -0.01890788f, 
    0.04708346f, -0.00932969f, -0.02269106f, -0.01801082f, 0.03183207f, 0.03003793f, -0.02487728f, -0.06287677f, 
    -0.06319875f, 0.00132152f, -0.01477529f, 0.04165433f, -0.04276448f, -0.02344093f, -0.04030872f, -0.01284198f, 
    -0.03179485f, -0.05588726f, 0.04930997f, -0.02325650f, 0.00550478f, -0.00385254f, -0.04814159f, -0.04011457f, 
    0.00690099f, 0.01419200f, -0.05170823f, -0.05809546f, -0.01013320f, -0.00873434f, -0.04772261f, -0.01969703f, 
    0.03462931f, 0.03489097f, -0.05517637f, 0.02523600f, -0.00432891f, -0.05542366f, 0.02251855f, 0.01295661f, 
    -0.01484008f, 0.01662979f, 0.03067150f, -0.01076423f, -0.02322959f, -0.02774257f, 0.05555891f, 0.00548667f, 
    0.00327362f, -0.04971577f, 0.04478174f, 0.04008069f, 0.04762268f, -0.02401941f, -0.02223707f, -0.03261814f, 
    -0.06442695f, 0.01267999f, -0.02992922f, -0.03678123f, 0.02561467f, -0.04615665f, 0.01693682f, 0.01053257f, 
    -0.01786515f, -0.04339191f, 0.00464307f, -0.04596604f, -0.05469382f, 0.00170187f, -0.02743161f, 0.00600640f, 
    -0.03621358f, 0.09971558f, -0.35954389f, -0.01451750f, -0.13470058f, 0.02760678f, 0.10068642f, -0.05924170f, 
    0.06094671f, 0.00624567f, -0.03082157f, -0.11092608f, -0.05425209f, 0.04197770f, 0.01135654f, -0.06639509f, 
    0.02290042f, 0.04112387f, 0.21284883f, 0.18787648f, 0.29337382f, 0.04783215f, 0.04004312f, -0.11068463f, 
    0.07854842f, -0.18290552f, 0.07975081f, -0.04155856f, -0.09542359f, -0.05863290f, -0.04538592f, 0.01597412f, 
    -0.04726322f, -0.06911708f, -0.13714948f, 0.06327993f, 0.00045735f, -0.05005758f, 0.08882084f, 0.00123478f, 
    0.04661268f, -0.03269796f, 0.04414311f, -0.08094183f, -0.01585659f, 0.00600685f, 0.11604100f, 0.00693098f, 
    -0.13016880f, 0.22951931f, 0.00313405f, -0.00197714f, 0.02596839f, -0.11545712f, 0.16146612f, 0.18488425f, 
    0.15189818f, 0.14863069f, -0.00973279f, -0.01603902f, -0.19103280f, -0.04697251f, 0.15095672f, 0.21575604f, 
    0.18348742f, -0.06340700f, 0.19240224f, -0.11040965f, 0.06421644f, 0.04413008f, -0.02560919f, 0.06331652f, 
    -0.13851669f, -0.21071598f, 0.01749661f, 0.02045104f, 0.05982284f, 0.02607297f, 0.00742469f, -0.03175911f, 
    -0.08338442f, -0.03043632f, 0.03679939f, 0.06665482f, 0.12995307f, 0.02038606f, -0.08871205f, -0.16511568f, 
    -0.07855126f, -0.08105447f, 0.24304302f, -0.09747090f, 0.11499278f, 0.06431180f, -0.05226235f, 0.04266669f, 
    -0.00047398f, -0.01037884f, 0.01310430f, 0.21797541f, 0.18289384f, 0.12869973f, 0.05207232f, -0.03157106f, 
    -0.05160810f, -0.05951511f, -0.14305371f, 0.14365543f, -0.17808254f, -0.16487728f, 0.18363093f, 0.03881013f, 
    0.15030375f, -0.00470438f, -0.02512846f, -0.03274139f, -0.03816155f, -0.00396411f, 0.35926923f, 0.26224598f, 
    -0.07595495f, 0.03037988f, 0.02445397f, -0.06372651f, -0.11264238f, -0.04141418f, -0.10006850f, -0.04007586f, 
    -0.31460032f, 0.00145007f, -0.14609446f, 0.10003323f, -0.04091814f, 0.11605994f, 0.15541002f, 0.00972559f, 
    0.32105875f, -0.07610033f, 0.00930051f, 0.02844608f, 0.03236829f, -0.01748740f, -0.10072406f, 0.00275187f, 
    0.03087440f, 0.04710742f, -0.30748573f, 0.06234881f, -0.13982090f, -0.04524900f, -0.00983138f, 0.10149066f, 
    -0.21423392f, -0.16083433f, 0.28067458f, -0.25999466f, 0.04446904f, -0.10907564f, 0.05468981f, -0.03503420f, 
    -0.12613040f, -0.08692084f, 0.14453717f, 0.15535948f, 0.23625658f, 0.06953344f, -0.14786801f, -0.00890175f, 
    0.08813391f, 0.21667181f, 0.03671574f, 0.06419890f, 0.30053753f, 0.22693402f, 0.07443120f, 0.06601284f, 
    -0.08883824f, 0.10334179f, 0.28429446f, -0.10810883f, -0.07665631f, 0.13023156f, 0.29370612f, 0.00736285f, 
    0.12513043f, 0.02553745f, -0.01010431f, -0.01144753f, -0.13707590f, -0.00851166f, 0.08105430f, 0.27755043f, 
    0.05229708f, 0.01067532f, -0.10042152f, -0.02570636f, -0.08375857f, 0.00176533f, 0.26274315f, 0.01428821f, 
    0.15956968f, 0.11246112f, -0.03083829f, -0.13704881f, 0.12603191f, 0.05282972f, -0.18708184f, 0.05647474f, 
    0.14514823f, 0.11951772f, 0.13601498f, 0.06101435f, -0.16912620f, -0.18938798f, 0.10055955f, 0.01732594f, 
    0.05982238f, 0.04101627f, 0.00433368f, -0.01418326f, -0.02623132f, 0.23118019f, -0.00098149f, 0.15863572f, 
    -0.16097534f, 0.14453989f, 0.01952187f, 0.06584340f, 0.00726601f, -0.05899218f, 0.04472385f, -0.06953906f, 
    0.13869222f, 0.11904186f, 0.08794536f, -0.01564677f, -0.16738990f, 0.21684708f, -0.11307692f, 0.03908510f, 
    -0.08511073f, -0.03125428f, -0.00058261f, 0.07567641f, 0.00886309f, 0.06626503f, 0.08408768f, -0.06545455f, 
    0.07463998f, -0.00662820f, -0.09058680f, 0.19201376f, 0.11970492f, -0.08338107f, -0.25719047f, -0.08673115f, 
    -0.19976549f, 0.00224693f, 0.03911368f, -0.02514356f, -0.05943467f, 0.10399740f, 0.35000303f, -0.10224532f, 
    0.08443367f, -0.06755649f, -0.00741052f, 0.07901088f, -0.01368969f, -0.12941682f, 0.08932871f, 0.15738995f, 
    -0.01242142f, -0.02298595f, -0.11713762f, -0.04008132f, -0.10928664f, -0.00943610f, -0.03188293f, 0.24638169f, 
    -0.03400175f, 0.12665902f, 0.05750937f, 0.00500962f, -0.15722011f, -0.00456281f, -0.00197825f, -0.09482671f, 
    -0.10980549f, -0.20844020f, 0.08566514f, -0.10858078f, 0.01843725f, 0.02764155f, -0.11673860f, 0.10547612f, 
    -0.12996587f, -0.15927643f, 0.10500339f, 0.17390433f, 0.10531134f, 0.10955533f, 0.04911972f, -0.08621721f, 
    -0.02941319f, -0.10637663f, -0.08436921f, -0.33688894f, -0.38534522f, 0.13074610f, 0.04202361f, 0.13833329f, 
    0.08072828f, 0.10099324f, 0.04781135f, -0.17715563f, 0.05716985f, -0.17115769f, -0.00411567f, 0.04360037f, 
    0.08437395f, 0.16891827f, 0.08189807f, 0.07141270f, 0.10324648f, 0.07963256f, 0.03702508f, 0.03614140f, 
    -0.12455969f, 0.11881035f, -0.03029066f, -0.05943405f, 0.11525506f, 0.12223621f, -0.09621971f, -0.16384539f, 
    -0.00384704f, 0.08586292f, 0.05381100f, 0.10525329f, 0.18944375f, 0.01313937f, -0.09884200f, -0.28031561f, 
    -0.14222780f, 0.10505389f, -0.00516512f, 0.02202817f, 0.14720444f, 0.17506827f, -0.05248813f, -0.06567467f, 
    -0.26038557f, 0.06073280f, 0.05265988f, -0.10767775f, -0.19367622f, 0.02536299f, -0.05707303f, -0.08111741f, 
    0.22787556f, 0.17450541f, -0.05805572f, 0.09933457f, 0.06421939f, -0.01796160f, -0.01589305f, 0.02961639f, 
    0.14285375f, -0.09488307f, -0.03594334f, -0.02915826f, -0.20503165f, 0.08280573f, 0.02761334f, -0.10080907f, 
    -0.01587518f, 0.15725031f, -0.11777096f, -0.22469272f, -0.16521810f, 0.16560739f, 0.18132301f, 0.07291869f, 
    -0.06018716f, -0.00182067f, -0.03892608f, 0.05489379f, -0.02745146f, 0.03838188f, 0.06735019f, -0.09571107f, 
    -0.15573853f, 0.02998242f, -0.09915137f, 0.03158246f, -0.03388325f, -0.03710196f, -0.19199222f, 0.13750176f, 
    0.09181862f, -0.03468757f, -0.05782108f, -0.09321868f, 0.15496641f, -0.09738334f, -0.01388027f, -0.02025057f, 
    -0.07746512f, -0.01255712f, 0.11439819f, -0.14480470f, 0.03115613f, 0.05246717f, -0.05647903f, 0.11017025f, 
    0.10946865f, -0.01186956f, -0.05219288f, -0.15049894f, 0.05090429f, 0.03432801f, -0.01358873f, 0.01187053f, 
    0.04159091f, 0.14645812f, 0.02181219f, 0.01590740f, 0.08248115f, 0.11945327f, -0.06662098f, -0.01402836f, 
    0.05496466f, -0.04634380f, 0.11228261f, 0.08758240f, -0.02969162f, -0.03075344f, 0.06939786f, -0.07530761f, 
    0.05097154f, -0.25495765f, -0.06347128f, -0.21406463f, 0.10689740f, 0.07671286f, 0.10998147f, 0.16460812f, 
    -0.07612273f, 0.08518320f, 0.05326878f, -0.12674360f, -0.07091800f, -0.16917825f, -0.14335828f, 0.03934018f, 
    0.08086360f, -0.03712358f, -0.13864489f, -0.54582590f, -0.11459072f, -0.13308641f, 0.02699132f, 0.15529801f, 
    -0.09330277f, 0.14563958f, 0.00402331f, -0.15922096f, 0.20652090f, -0.10103201f, -0.10630949f, 0.01438684f, 
    -0.02364933f, 0.09344265f, -0.17405681f, 0.12169537f, 0.09042461f, 0.18547550f, -0.06200980f, 0.01585895f, 
    0.02251910f, 0.08343694f, 0.02881057f, -0.01580891f, -0.00800757f, 0.06878506f, 0.19667742f, -0.09952052f, 
    0.19910003f, 0.04056454f, 0.07395868f, -0.03748697f, 0.01646056f, -0.06460956f, 0.07394385f, -0.07478467f, 
    -0.09708235f, -0.03512646f, 0.01636113f, 0.07423280f, -0.03037582f, 0.02288923f, 0.12771972f, 0.11213747f, 
    0.09309978f, -0.34003624f, 0.00884474f, 0.03300125f, 0.02520852f, -0.21447575f, 0.04210434f, -0.09771165f, 
    -0.08733236f, 0.03443767f, 0.02907677f, 0.08968639f, 0.15045366f, 0.09716716f, 0.00628557f, -0.15285648f, 
    -0.14472874f, 0.14216289f, -0.22139153f, 0.13190591f, 0.18642628f, -0.18700762f, 0.12677646f, -0.01133649f, 
    -0.05405086f, 0.11630609f, 0.08913725f, -0.37707990f, -0.06075398f, -0.21799557f, -0.03561264f, 0.00784675f, 
    0.10923046f, 0.05676230f, 0.12948097f, 0.14117260f, -0.20370629f, 0.21960969f, 0.23203960f, -0.01004811f, 
    -0.02533269f, -0.05399236f, 0.01990156f, -0.03783483f, 0.10531638f, -0.53134441f, -0.13865070f, -0.01129065f, 
    0.12190367f, -0.05990127f, 0.02234530f, -0.27328092f, -0.14271143f, -0.19985190f, -0.05730512f, -0.19349538f, 
    0.14258772f, 0.15794261f, 0.10191191f, 0.12389711f, 0.09639976f, -0.03140927f, 0.07323726f, 0.25330573f, 
    -0.11260647f, 0.17126858f, -0.00043734f, 0.10253171f, 0.18547763f, -0.02151430f, 0.05117742f, 0.10316108f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.02955930f, -0.02512719f, 0.00428600f, -0.11265006f, -0.05173386f, 0.19133671f, 0.04651164f, -0.00364683f, 
    -0.08302490f, -0.01901643f, -0.06952921f, -0.05148574f, -0.00498023f, 0.04162869f, -0.08385263f, -0.04138511f, 
    -0.03205469f, 0.15787603f, 0.16783206f, 0.08691160f, 0.08153978f, -0.01536792f, 0.03466676f, 0.10963856f, 
    0.08318131f, 0.08265454f, 0.11779271f, 0.05722113f, 0.31855482f, -0.01593898f, -0.06851962f, 0.16769542f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08793795f, -0.26534721f, 0.00857553f, -0.17101072f, -0.13405330f, 0.49827453f, 0.07009811f, 0.16442025f, 
    -0.08126669f, -0.12157480f, 0.07608312f, -0.10129748f, -0.09426191f, 0.02515251f, -0.11419965f, 0.25514239f, 
    -0.09587508f, 0.33675337f, 0.09310060f, -0.18434761f, -0.19264315f, -0.13579366f, 0.31658050f, 0.25157425f, 
    0.22659814f, -0.15558924f, -0.40582287f, -0.31824905f, -0.09711775f, -0.08284661f, 0.14661109f, 0.07758090f, 
    -0.18271168f, -0.25366279f, 0.09523005f, 0.05284213f, -0.04003181f, -0.20318344f, -0.10397895f, 0.26243764f, 
    -0.13917856f, -0.11481567f, -0.35202536f, -0.03076719f, 0.05051766f, -0.09229228f, 0.05395770f, 0.14673503f, 
    -0.29995850f, 0.02739138f, 0.05914903f, 0.30114663f, 0.01954146f, -0.15736653f, 0.09536727f, -0.10108326f, 
    0.10903636f, -0.15470213f, -0.02335823f, -0.17592317f, 0.15591049f, -0.06775589f, -0.17802267f, 0.12705083f, 
    0.13643275f, -0.06972688f, 0.04732779f, 0.03466272f, -0.16681634f, -0.17109503f, -0.06268378f, 0.06697769f, 
    0.02033067f, -0.06650685f, 0.13043918f, -0.10163499f, -0.03044185f, 0.08956372f, -0.11783791f, 0.08005203f, 
    0.14855732f, 0.04689476f, -0.05989792f, -0.03405295f, 0.02606205f, 0.14021283f, 0.14567146f, -0.08672043f, 
    -0.16899703f, 0.00307219f, -0.04532986f, 0.05787162f, -0.15336692f, -0.15690382f, -0.03209471f, 0.09398247f, 
    -0.01836360f, 0.13381645f, 0.03581410f, 0.16383602f, -0.05689386f, 0.13298942f, -0.00204873f, 0.07824460f, 
    0.09168767f, -0.03969505f, 0.16586564f, 0.08908879f, 0.02793030f, -0.09307021f, 0.00604888f, 0.14133082f, 
    0.23538630f, 0.02615738f, -0.06929308f, 0.25461146f, 0.21573141f, 0.14317286f, 0.18412387f, -0.06262045f, 
    0.13432808f, -0.24352503f, -0.22880200f, -0.38132089f, 0.25093162f, -0.03264708f, -0.06983057f, -0.06366533f, 
    -0.07257956f, -0.00633908f, -0.13575922f, -0.09321841f, 0.13904890f, -0.02870023f, -0.30089408f, -0.13072947f, 
    0.09434814f, -0.02699497f, 0.08583781f, -0.07999907f, 0.04286129f, -0.10522918f, -0.32576713f, 0.19404888f, 
    -0.37032393f, -0.07644716f, 0.06616140f, 0.01803246f, -0.18490630f, 0.05913837f, -0.32431233f, 0.26763201f, 
    0.15602954f, 0.17217427f, 0.10540606f, 0.13150668f, 0.08500499f, -0.08074065f, -0.30869189f, 0.25328153f, 
    -0.02172424f, -0.13810049f, -0.08852434f, -0.13294901f, 0.00858961f, -0.33535782f, 0.12437402f, 0.18977812f, 
    -0.16813459f, 0.11226511f, -0.13910525f, 0.04586901f, -0.00022693f, 0.10801003f, -0.28633061f, -0.19783647f, 
    0.19551504f, -0.04893211f, 0.28986648f, 0.26490268f, -0.11353128f, 0.02218985f, -0.08023320f, 0.03642142f, 
    -0.19499938f, -0.01789948f, 0.31520939f, -0.15792379f, 0.38605702f, 0.08116717f, -0.12882580f, 0.16064973f, 
    0.00898183f, -0.19906327f, 0.15108721f, -0.07219522f, -0.12850024f, -0.17180049f, 0.04984355f, -0.17430356f, 
    -0.03669922f, 0.02253418f, -0.25803941f, 0.18440829f, -0.04714103f, -0.11825409f, 0.03522721f, -0.25038484f, 
    -0.29570824f, 0.28633380f, 0.06923462f, 0.19892479f, 0.12931590f, -0.16627692f, 0.14218692f, -0.22918259f, 
    -0.04978603f, -0.09777413f, 0.50198406f, -0.21280082f, 0.19162199f, -0.12173335f, 0.03749023f, 0.13932453f, 
    -0.04453390f, 0.02596246f, -0.15527730f, -0.09563935f, 0.03519443f, 0.38603812f, -0.36973372f, 0.03808156f, 
    -0.14191087f, -0.20190907f, 0.21137989f, 0.08258254f, -0.07042690f, 0.15355583f, -0.18545973f, 0.26314688f, 
    -0.30945265f, 0.31067085f, 0.17890875f, 0.20137131f, 0.02816020f, -0.02528653f, -0.12861067f, 0.52493775f, 
    -0.10550990f, 0.19095299f, -0.30182764f, -0.07313889f, 0.09774693f, -0.04244982f, -0.01321473f, -0.05086632f, 
    -0.09418165f, 0.06828471f, -0.01628104f, 0.06070283f, -0.17147854f, 0.25487387f, -0.03105050f, -0.23955832f, 
    0.01561804f, 0.03197729f, 0.14335345f, -0.09100759f, -0.02779448f, -0.02184941f, -0.03667198f, -0.19104265f, 
    0.25402617f, 0.05146145f, 0.10287417f, -0.05275792f, 0.21686396f, 0.02647210f, -0.06490770f, -0.09791505f, 
    -0.17004466f, 0.11526512f, 0.01526826f, 0.46121296f, -0.35136271f, 0.00528699f, 0.24219945f, -0.15448186f, 
    0.05230284f, 0.20354539f, -0.04912018f, 0.11860930f, -0.03798912f, 0.17845607f, 0.20999971f, -0.19243145f, 
    0.00833980f, 0.24570487f, -0.16630547f, -0.14853767f, 0.14546181f, -0.14111161f, 0.11356097f, -0.33797753f, 
    -0.19931339f, 0.24428931f, 0.32989502f, -0.00078304f, 0.24816746f, -0.10525706f, 0.19048344f, -0.38656625f, 
    0.00166505f, 0.09406795f, -0.19642936f, 0.33032081f, 0.04210845f, 0.04428599f, 0.11268528f, -0.14647785f, 
    -0.05354525f, -0.00228212f, -0.00321148f, 0.29661664f, -0.01828072f, -0.46173027f, 0.20314287f, 0.03381816f, 
    0.16737327f, -0.34149608f, 0.17554502f, -0.01445357f, 0.01306049f, 0.10052237f, -0.18619816f, 0.25157619f, 
    0.25174761f, -0.15935764f, -0.23815706f, 0.00355878f, -0.29683203f, 0.07578181f, 0.11331896f, -0.58770311f, 
    0.06139708f, 0.25446907f, 0.09249025f, -0.32126853f, -0.00027105f, -0.10797346f, -0.10024753f, -0.00401728f, 
    -0.06862541f, -0.48264721f, -0.17431816f, -0.11704575f, -0.01825311f, -0.27683225f, -0.45515412f, 0.06529273f, 
    0.17874733f, 0.09778562f, -0.28542539f, 0.21534953f, -0.10745420f, 0.03601107f, 0.05361810f, -0.11905625f, 
    -0.30054384f, 0.26945144f, -0.05485025f, 0.04701123f, 0.00417546f, 0.05631700f, 0.14358160f, 0.39374381f, 
    -0.01750394f, 0.34197092f, 0.29065299f, -0.01581179f, 0.19774771f, 0.14266752f, -0.29365933f, -0.07716766f, 
    0.03445043f, -0.06754588f, -0.15012079f, 0.40621188f, -0.09462846f, -0.13000429f, -0.07730421f, 0.27160892f, 
    -0.03999038f, -0.04033382f, 0.62076116f, 0.28540999f, 0.17183706f, -0.10553157f, -0.12757367f, 0.03704377f, 
    0.14695272f, 0.07643852f, 0.28209519f, 0.33998585f, 0.06587022f, -0.04075238f, 0.03180296f, -0.40682009f, 
    0.10378717f, -0.31990319f, 0.11261813f, -0.19567463f, -0.10182939f, -0.02977371f, 0.13925734f, -0.19933212f, 
    -0.03036664f, 0.02054064f, 0.13238071f, -0.06702421f, -0.04569114f, 0.04517565f, 0.24740522f, -0.15025207f, 
    0.04438429f, 0.11833051f, 0.03299742f, 0.10130962f, -0.13028727f, 0.03097758f, -0.15365297f, -0.13060048f, 
    -0.33031338f, 0.23548196f, 0.42231959f, -0.01672047f, 0.18133886f, -0.08898333f, -0.05569878f, 0.20283970f, 
    -0.15192044f, 0.26858506f, 0.14659205f, 0.17982033f, 0.13655847f, 0.10622834f, -0.05292392f, 0.07321804f, 
    -0.14011735f, 0.18186553f, -0.12617338f, 0.33916739f, -0.15545690f, -0.02243337f, -0.28507239f, 0.13290611f, 
    0.08965992f, 0.07950239f, -0.07574951f, -0.03091461f, -0.11934133f, -0.12272350f, 0.28131717f, 0.05890883f, 
    0.26949367f, 0.03838128f, -0.32478970f, -0.15215497f, 0.15023342f, 0.12210180f, 0.04562635f, 0.11217144f, 
    -0.09648194f, -0.24216488f, 0.04655282f, -0.35003015f, 0.19523898f, 0.10457956f, 0.06596992f, -0.14343970f, 
    0.17816034f, -0.34071544f, 0.02163890f, -0.11732020f, -0.17870747f, -0.20845066f, -0.01500938f, -0.32337710f, 
    0.10141803f, 0.21891928f, -0.26383576f, 0.02904288f, 0.13250077f, 0.15949938f, 0.21995029f, -0.28335491f, 
    -0.13883871f, 0.13533886f, 0.05397466f, 0.18391030f, 0.20484744f, -0.14055066f, 0.17477432f, -0.40366870f, 
    0.07143161f, -0.19073075f, 0.32300577f, -0.10098993f, 0.21061325f, -0.12346370f, 0.27033913f, -0.00248605f, 
    -0.10434619f, 0.06845763f, -0.11665099f, 0.03124971f, -0.13439962f, -0.12768888f, -0.12140579f, -0.12505527f, 
    0.02271831f, -0.02158642f, 0.12997942f, 0.07783034f, -0.08834825f, 0.02185510f, 0.04509465f, -0.13033125f, 
    -0.06773657f, 0.14587897f, -0.04235167f, 0.00084315f, -0.19779742f, -0.14158233f, -0.05661961f, 0.15922959f, 
    -0.04437638f, -0.11158648f, -0.09837466f, 0.14481406f, -0.02811610f, 0.04276204f, -0.15844129f, -0.08348640f, 
    -0.08525483f, -0.31836295f, -0.06534150f, 0.21859621f, 0.03687984f, -0.38067156f, -0.20708059f, -0.39307210f, 
    0.00105713f, 0.21559967f, -0.28891081f, 0.05410538f, -0.02907363f, 0.05923094f, -0.04299847f, -0.18057232f, 
    -0.29285294f, 0.27120855f, -0.20744470f, 0.13639119f, 0.32446605f, -0.07635599f, -0.40150943f, 0.00640276f, 
    0.10389699f, 0.24371354f, -0.22321248f, 0.67959511f, 0.06462920f, -0.16678177f, -0.23813833f, -0.10573263f, 
    0.16279811f, -0.12766086f, -0.10785210f, -0.18951014f, -0.10581695f, -0.14048307f, -0.01363863f, 0.07472895f, 
    0.06578328f, -0.08396306f, -0.06074003f, 0.02979776f, 0.10038497f, -0.10749990f, 0.23814073f, -0.06825588f, 
    0.14182940f, 0.29063380f, 0.10794293f, -0.00781779f, -0.25975066f, -0.13787645f, 0.28318185f, 0.02286596f, 
    -0.04014926f, -0.04459888f, 0.09653982f, -0.18208513f, 0.05494604f, 0.14904329f, 0.03811976f, 0.09386088f, 
    0.07528772f, -0.32915261f, 0.15194632f, -0.25347254f, -0.05666973f, 0.18863939f, -0.06309840f, -0.20152105f, 
    -0.04297318f, 0.24464726f, -0.20222704f, -0.01123368f, 0.06195144f, 0.00139397f, 0.11078390f, -0.24576978f, 
    -0.33479214f, -0.03229428f, 0.24753955f, -0.13465855f, 0.21668699f, -0.00082899f, -0.06640834f, -0.12669955f, 
    0.29210055f, 0.18789370f, -0.24043983f, 0.49368450f, 0.15144068f, 0.11944493f, 0.01266402f, 0.25180668f, 
    0.12177602f, -0.10361655f, -0.16864680f, -0.07932150f, 0.04167956f, -0.10298802f, -0.12321879f, -0.18465769f, 
    -0.01288391f, -0.08391246f, 0.02249663f, 0.05559169f, 0.06591047f, 0.01295143f, -0.15195113f, -0.15049635f, 
    -0.11581626f, 0.08805428f, -0.07053327f, -0.13606133f, 0.01578685f, 0.06278469f, 0.10556752f, -0.17237510f, 
    -0.05055384f, -0.08230546f, 0.05378380f, 0.10018419f, -0.03627002f, -0.04746000f, 0.07202098f, 0.00945981f, 
    -0.20140558f, -0.20918337f, 0.06594338f, 0.40674517f, 0.03102906f, -0.14966914f, 0.09270204f, -0.06785429f, 
    -0.01888404f, -0.13443917f, 0.57916725f, 0.35698667f, 0.10868254f, 0.03727345f, -0.11146990f, 0.12731595f, 
    0.45093369f, 0.20775646f, 0.05044626f, 0.17535518f, 0.19227448f, 0.10524240f, -0.08520292f, -0.26384121f, 
    0.12338769f, -0.24909468f, 0.15962356f, -0.08618507f, -0.13834317f, -0.07802798f, -0.00057201f, -0.11712704f, 
    -0.01352310f, -0.16300158f, -0.03541911f, -0.05138623f, 0.06810233f, 0.27935231f, -0.01504593f, 0.06483899f, 
    0.12435842f, -0.20613383f, -0.16743127f, -0.31530124f, 0.06821451f, -0.00191713f, 0.20112030f, -0.05883813f, 
    -0.28927034f, 0.26813918f, -0.02607981f, 0.02091304f, 0.00208149f, 0.03652539f, 0.31878003f, 0.06907220f, 
    0.39728779f, 0.07542814f, -0.44714978f, 0.37543863f, 0.02250691f, 0.05375759f, -0.12364810f, 0.04332338f, 
    0.04641167f, 0.03287079f, -0.17596261f, 0.08256576f, 0.04758033f, 0.07199684f, 0.00541342f, 0.26355937f, 
    -0.10430754f, -0.12159443f, 0.16241638f, -0.12469660f, -0.04054744f, -0.04276026f, 0.28119814f, 0.22013578f, 
    0.50608313f, -0.05111136f, -0.03053043f, 0.00517175f, 0.09329388f, 0.10744910f, 0.00561229f, -0.24299389f, 
    -0.10420758f, -0.25158647f, -0.02329309f, -0.06870680f, 0.05285303f, 0.04976681f, 0.20645799f, 0.15648133f, 
    0.13569379f, 0.10537006f, 0.02977868f, -0.08790068f, 0.15988477f, 0.14040145f, 0.09641700f, -0.15864336f, 
    -0.09315419f, -0.22052081f, -0.05911655f, -0.27906626f, 0.05605201f, 0.14885330f, 0.22311625f, 0.09814117f, 
    0.36067888f, -0.26006678f, -0.05891071f, -0.19336945f, -0.36819956f, 0.12003006f, 0.13618699f, -0.11433319f, 
    0.08882299f, 0.05955625f, -0.04867868f, 0.04269046f, 0.18955278f, 0.04392441f, 0.19106115f, 0.05704847f, 
    0.07823158f, -0.23421061f, -0.01858315f, -0.07294969f, 0.13198118f, 0.14229758f, 0.10661512f, 0.17254804f, 
    -0.00926076f, -0.11602201f, 0.14863223f, 0.12706187f, 0.14628817f, -0.09224188f, -0.32095724f, 0.31210038f, 
    -0.18074417f, 0.30569658f, 0.19335242f, 0.14835472f, -0.06281761f, -0.18033043f, -0.01295658f, 0.37601423f, 
    0.15428567f, 0.14145477f, -0.20537736f, 0.18464127f, -0.20041211f, 0.06663080f, -0.16899204f, 0.18784748f, 
    0.15246768f, 0.05731238f, 0.16519488f, -0.03488493f, -0.12819660f, 0.10308246f, -0.18783493f, -0.04466948f, 
    -0.03297367f, 0.06158780f, -0.11487685f, -0.52238727f, 0.01244577f, -0.16115509f, -0.38734862f, 0.08423676f, 
    0.18564457f, -0.28809699f, -0.07691073f, 0.26635885f, 0.06170647f, 0.15742211f, -0.04470916f, 0.24325675f, 
    -0.07576681f, 0.33463684f, 0.01929980f, -0.20370238f, 0.27251580f, 0.09062769f, -0.16245155f, 0.08249608f, 
    0.13059078f, -0.07717929f, 0.04721410f, 0.07141450f, 0.08510876f, 0.08149001f, 0.00533234f, 0.03558327f, 
    -0.04298173f, -0.24503978f, -0.16902706f, -0.03951066f, -0.13614905f, -0.10415570f, 0.07242939f, -0.02150734f, 
    -0.22137965f, 0.04196592f, 0.18580511f, 0.29505232f, -0.07313341f, 0.16718626f, 0.44843069f, 0.00730281f, 
    0.19991128f, -0.17071675f, -0.48488504f, 0.22109832f, 0.22223219f, 0.06571233f, -0.05696513f, 0.19737588f, 
    0.17448546f, -0.05919816f, -0.17426267f, 0.06747851f, -0.08652785f, -0.10490002f, 0.09617538f, -0.07919020f, 
    -0.16509955f, -0.12026080f, 0.03429544f, 0.04832081f, -0.06643765f, -0.12378240f, 0.13082981f, 0.03236022f, 
    -0.14157973f, -0.02132632f, -0.19662127f, -0.02154954f, -0.01153982f, 0.07668136f, -0.19218947f, 0.06897568f, 
    -0.05274204f, -0.11288481f, -0.06729997f, 0.10812116f, -0.01767309f, -0.03644815f, -0.05464177f, 0.05914433f, 
    0.15783972f, 0.23673424f, 0.04274346f, 0.06597311f, -0.01522771f, 0.21946318f, -0.00935565f, 0.02314379f, 
    -0.10120809f, 0.21385436f, -0.19948973f, -0.17657407f, -0.00807028f, 0.00418079f, 0.20411998f, -0.23121582f, 
    0.34184399f, -0.30841336f, -0.17601882f, 0.07712580f, 0.18130709f, -0.12963359f, 0.17416956f, -0.46027654f, 
    -0.04402151f, -0.02560571f, -0.08934958f, 0.13839543f, 0.05182078f, 0.11819039f, 0.16373226f, -0.04670097f, 
    0.20075184f, -0.29114679f, 0.00827090f, -0.20004311f, -0.02152409f, -0.02348691f, 0.37124178f, -0.20624866f, 
    -0.08627485f, 0.36041561f, -0.19229725f, 0.27857050f, -0.14864919f, -0.05033943f, 0.25901595f, -0.16124225f, 
    -0.19335967f, 0.05149699f, 0.19893695f, -0.16066486f, 0.18086959f, -0.16807461f, -0.00360337f, 0.15774910f, 
    -0.05349435f, 0.08883701f, 0.04183401f, 0.21693437f, 0.16690464f, -0.10249380f, 0.15735079f, 0.20159163f, 
    -0.06654532f, -0.29394242f, 0.14145294f, -0.05794326f, -0.09079537f, 0.32317305f, -0.06609473f, -0.09857652f, 
    0.02590523f, 0.02898738f, -0.09394190f, -0.12198272f, -0.05257167f, 0.06318807f, -0.20429100f, 0.16866057f, 
    -0.30686867f, 0.24841145f, 0.23651887f, 0.06004414f, 0.04260717f, -0.16303295f, -0.25785208f, 0.39262411f, 
    0.18255517f, 0.25911903f, -0.32182333f, 0.32610199f, 0.01592907f, 0.01219213f, -0.25804734f, 0.28073126f, 
    0.10886866f, 0.04990235f, -0.04992595f, -0.07018813f, -0.11655186f, -0.03751976f, -0.02967530f, -0.05786246f, 
    0.04741851f, 0.13854022f, 0.05184269f, 0.07586215f, -0.10622995f, -0.17434514f, -0.14008118f, -0.03598603f, 
    0.11593464f, -0.08117951f, -0.06898250f, 0.11965210f, 0.15366165f, 0.17166542f, -0.10828956f, 0.01390469f, 
    -0.16381437f, -0.16682287f, -0.15648726f, -0.11691601f, -0.16213390f, -0.06950749f, -0.09758384f, 0.09867300f, 
    -0.03891549f, -0.19555296f, 0.06471781f, -0.14641716f, 0.13471800f, -0.13292383f, 0.07383839f, -0.16470172f, 
    -0.04260749f, -0.04718432f, -0.13434564f, 0.11778753f, 0.16325311f, 0.10942923f, -0.12026118f, -0.06598108f, 
    0.02557196f, -0.04806981f, -0.05737705f, 0.01463631f, -0.00116959f, -0.12149908f, -0.00884265f, -0.11343870f, 
    -0.19096239f, -0.06269693f, -0.17007853f, 0.02510856f, 0.05988963f, 0.16265421f, 0.09442355f, 0.10495996f, 
    -0.12417104f, 0.26061761f, 0.14908952f, 0.40928969f, 0.03433052f, 0.11520554f, -0.12996443f, -0.57341278f, 
    -0.04997912f, 0.03299402f, -0.09504660f, 0.00828534f, 0.05445151f, 0.16147803f, 0.17798097f, -0.08079482f, 
    -0.17752653f, 0.37384722f, -0.08225627f, 0.15304735f, 0.29351917f, -0.01513704f, -0.03069768f, 0.40932572f, 
    -0.03978730f, -0.11156459f, -0.67866510f, 0.05480432f, 0.09643461f, 0.14987798f, -0.05879673f, -0.57280570f, 
    0.08029564f, -0.08892272f, -0.06222682f, 0.21257497f, -0.07971257f, -0.33389506f, -0.35717940f, 0.14848830f, 
    0.09804922f, -0.36508089f, -0.33706391f, -0.34058711f, 0.12026452f, 0.16817257f, -0.00031806f, 0.06679732f, 
    0.07584482f, -0.15367320f, -0.27803227f, -0.14417677f, 0.04788359f, 0.06115091f, 0.08816395f, 0.08122116f, 
    0.25931284f, 0.06894892f, 0.44757724f, -0.24960163f, -0.06012436f, -0.04397347f, -0.02664256f, 0.07026123f, 
    0.17163438f, 0.17551398f, -0.06569488f, 0.11248344f, 0.16576426f, -0.02744927f, 0.17747526f, -0.21344109f, 
    0.07942473f, 0.20983918f, 0.13761522f, 0.24913763f, -0.03231659f, 0.04118106f, 0.19939820f, -0.01800205f, 
    0.35606661f, 0.08507419f, -0.05535588f, 0.19123657f, 0.17955758f, -0.12382349f, 0.30954999f, -0.44144928f, 
    -0.17800453f, -0.25145507f, -0.29014868f, 0.25476250f, 0.15117547f, -0.01943128f, 0.15258230f, -0.20699982f, 
    -0.12839921f, 0.13729438f, -0.05329859f, 0.08458813f, 0.14142025f, -0.10330705f, -0.15545085f, 0.02354312f, 
    -0.17423709f, 0.02113057f, -0.10293899f, 0.02445562f, -0.17353781f, 0.03324529f, -0.14089194f, -0.00540030f, 
    -0.01308651f, -0.14743634f, -0.04773676f, -0.05288019f, -0.02209968f, 0.08503337f, -0.02068778f, -0.02734351f, 
    -0.10978757f, 0.04276259f, -0.15398903f, 0.02559344f, -0.05368548f, 0.15819834f, -0.00567415f, -0.17375737f, 
    0.04791366f, 0.20232962f, 0.08282340f, -0.10228278f, 0.11712459f, 0.03769375f, -0.08160810f, 0.07671852f, 
    0.02774833f, -0.07606528f, -0.32903224f, 0.12641419f, 0.09570493f, 0.08038662f, 0.20255136f, 0.16695674f, 
    0.00547727f, -0.38584152f, -0.15399384f, -0.27384755f, -0.21458295f, 0.03895055f, -0.20711042f, -0.22850555f, 
    -0.11294951f, -0.02346324f, -0.03732309f, -0.01759980f, -0.53719407f, -0.14483367f, 0.12449367f, 0.02503487f, 
    -0.12958819f, 0.04071974f, -0.06621450f, 0.32244551f, 0.14929228f, 0.06565905f, 0.06087039f, -0.11813518f, 
    -0.13585335f, 0.11113065f, 0.24057728f, -0.06232136f, -0.07254045f, 0.14982851f, 0.09551413f, 0.29168424f, 
    0.25990075f, -0.10423805f, 0.05280289f, 0.34682637f, -0.14599411f, -0.06510304f, -0.05188654f, -0.22477466f, 
    0.02840959f, -0.11918755f, -0.30902052f, -0.31274751f, 0.30943343f, 0.01472895f, -0.02046873f, -0.24480151f, 
    0.15516868f, -0.50271624f, -0.02186763f, -0.00646614f, -0.05972781f, -0.09022646f, 0.10931224f, 0.13305975f, 
    -0.00631395f, 0.03659332f, 0.09039507f, 0.08806860f, 0.14716133f, -0.14492774f, 0.15399323f, -0.15290940f, 
    0.10640313f, -0.19870815f, 0.36734667f, 0.13894817f, 0.00548688f, 0.07529609f, 0.23268972f, -0.46012115f, 
    -0.15436277f, -0.14363623f, 0.40088448f, -0.08292514f, 0.18659338f, 0.11647885f, -0.06465006f, 0.04200192f, 
    -0.05236804f, -0.25819224f, 0.05393631f, 0.10502612f, 0.12871858f, -0.18500459f, 0.01778118f, -0.18921320f, 
    0.08721340f, -0.00047991f, 0.26222172f, 0.37492880f, -0.13286328f, 0.06439465f, -0.02507165f, -0.26002735f, 
    -0.30706793f, 0.50646949f, 0.38169259f, 0.22366005f, 0.30455101f, -0.11622322f, -0.06410804f, -0.14364517f, 
    -0.03916029f, 0.18404119f, 0.31830007f, -0.11087923f, -0.06265751f, 0.09594985f, 0.33389181f, -0.11901643f, 
    0.04307869f, 0.12000278f, 0.07712121f, 0.15138435f, -0.13109107f, -0.32576352f, -0.02391966f, 0.14884312f, 
    0.12239211f, -0.28023830f, 0.05194506f, -0.02106488f, 0.06163865f, -0.01703316f, 0.25736555f, -0.09432936f, 
    -0.01918578f, 0.31467596f, -0.29660770f, -0.13221686f, -0.05393612f, -0.05793190f, 0.06044760f, 0.30353388f, 
    -0.07510006f, -0.12059087f, 0.16649008f, -0.49542093f, 0.18557248f, 0.08572728f, -0.06163102f, -0.10934173f, 
    -0.00807660f, -0.14355813f, -0.04053050f, 0.00484630f, -0.05518963f, 0.10828701f, -0.11861745f, -0.10197306f, 
    0.02525917f, -0.13582201f, 0.05258057f, -0.06954695f, 0.09045531f, 0.06287973f, -0.06823678f, -0.06334374f, 
    0.05351326f, -0.16797942f, -0.14729615f, -0.07885756f, -0.15443574f, -0.11084693f, -0.09617468f, 0.06613304f, 
    -0.07834745f, -0.12581119f, 0.09655418f, 0.12972923f, -0.13056242f, -0.01338567f, -0.17501986f, -0.11173423f, 
    -0.00573696f, -0.09004207f, -0.07458445f, 0.08921503f, 0.08411168f, 0.22163174f, -0.24232879f, 0.13261136f, 
    -0.17542058f, 0.00421328f, 0.26408920f, -0.40192959f, -0.03380828f, 0.01797192f, -0.38427290f, 0.18272303f, 
    0.23637319f, -0.22726360f, 0.19642845f, 0.09886904f, -0.27355498f, -0.12715891f, -0.02553373f, 0.10382921f, 
    0.10887016f, 0.21962564f, -0.30540985f, -0.19084330f, 0.25612101f, -0.02327284f, -0.27271855f, 0.11980280f, 
    0.14550394f, -0.22087848f, -0.01860835f, -0.17835860f, -0.03546304f, -0.30090967f, -0.49145532f, 0.10835116f, 
    0.02496086f, -0.19358878f, -0.44828147f, -0.30204999f, -0.10195373f, 0.05659724f, -0.16917293f, -0.09969052f, 
    -0.16174746f, -0.15044522f, 0.11093646f, 0.04009645f, -0.18739522f, 0.07153524f, 0.20254183f, 0.00203733f, 
    0.30303949f, 0.22369292f, -0.09894656f, -0.10894959f, 0.32517818f, 0.04699702f, -0.40950027f, 0.22175750f, 
    -0.15202336f, 0.13008863f, 0.02175278f, 0.15597495f, 0.06480426f, -0.08873436f, 0.29551873f, -0.30284145f, 
    -0.17708525f, 0.09436816f, 0.07396886f, 0.05186763f, -0.10542732f, -0.15329140f, 0.13275556f, -0.04131450f, 
    0.04387309f, -0.15036131f, 0.03970648f, -0.04636738f, 0.20568015f, 0.07553553f, -0.19576271f, -0.42363164f, 
    0.05065894f, 0.15111989f, -0.06654590f, 0.24181750f, -0.04361634f, -0.14678782f, 0.19226138f, -0.19337696f, 
    -0.15926965f, -0.22081324f, 0.08213106f, -0.16432050f, 0.05165715f, -0.15583326f, 0.04618268f, -0.05516238f, 
    -0.01508967f, 0.08660651f, -0.00196178f, 0.12393678f, 0.01306601f, 0.01333281f, -0.19334243f, -0.20797129f, 
    -0.25096095f, 0.17180312f, 0.22873525f, 0.12527958f, 0.07528678f, 0.14543533f, -0.14919803f, 0.35011673f, 
    -0.05805298f, 0.32937104f, -0.00373850f, 0.10979543f, 0.13107263f, 0.03477749f, -0.22692175f, 0.11211219f, 
    0.03154054f, -0.30825835f, -0.13875668f, 0.27795795f, -0.12485206f, -0.43205270f, -0.57835144f, -0.03473382f, 
    -0.01470618f, -0.26031908f, -0.17275558f, 0.07719754f, 0.01574480f, -0.01232648f, -0.02191749f, -0.05241849f, 
    -0.14974086f, 0.16827402f, -0.16574691f, 0.21707274f, -0.00022573f, -0.14301153f, -0.30269289f, 0.30778667f, 
    0.14963740f, 0.21823376f, -0.06597593f, -0.48071313f, 0.12454513f, 0.09966937f, -0.35698739f, -0.01778908f, 
    0.10500172f, -0.04748166f, 0.14562240f, -0.10091362f, 0.11649854f, -0.15918487f, 0.24048981f, -0.12159427f, 
    0.12040292f, 0.27782074f, -0.01771024f, -0.04163278f, 0.08762337f, 0.07601599f, -0.20013368f, -0.32613009f, 
    -0.07691476f, 0.05560811f, 0.33547819f, 0.16168100f, -0.09557641f, 0.16593456f, -0.10417382f, -0.40946811f, 
    -0.04889091f, -0.21994977f, 0.32432714f, 0.28047895f, 0.13395570f, -0.12509523f, 0.31716621f, 0.12595874f, 
    -0.06148408f, -0.00471021f, -0.13145679f, -0.05857629f, 0.08899321f, -0.09627379f, 0.04562643f, 0.00719265f, 
    0.10128273f, -0.15765516f, 0.14670064f, -0.01738094f, -0.08744226f, 0.00636961f, -0.17656438f, -0.07029977f, 
    -0.02135793f, 0.08276827f, 0.09200241f, -0.03708653f, -0.08011401f, 0.05755133f, -0.03267917f, -0.04785060f, 
    -0.15122075f, -0.14391086f, -0.15429173f, 0.12792520f, -0.04151598f, -0.14196928f, 0.05956408f, -0.11618139f, 
    -0.11881997f, 0.16163623f, -0.11306476f, -0.03597037f, -0.12875648f, 0.44790626f, -0.21523254f, -0.10672817f, 
    0.02185956f, -0.10197785f, -0.27168623f, -0.10131197f, -0.12812096f, -0.10069115f, 0.07111960f, -0.15686800f, 
    -0.07870129f, 0.21370859f, -0.01420586f, 0.30699423f, 0.00922530f, -0.07065618f, 0.19020227f, -0.03904146f, 
    0.20369731f, -0.04856820f, -0.12521912f, 0.13881341f, 0.18097369f, 0.09740655f, 0.14406739f, -0.21991187f, 
    0.07683421f, -0.07354327f, 0.02566362f, -0.13768835f, 0.09271847f, -0.02295300f, -0.17534755f, -0.04399686f, 
    -0.08897392f, 0.01373192f, 0.11907068f, 0.02985876f, 0.17502928f, -0.07726316f, 0.05979821f, -0.10924193f, 
    -0.10483137f, -0.14315677f, 0.01654199f, 0.10455416f, -0.15591641f, 0.14701889f, -0.09691845f, -0.01312290f, 
    -0.07630436f, 0.02905632f, -0.06877112f, -0.14868942f, -0.06587469f, -0.02285929f, 0.14309870f, -0.17497392f, 
    0.13623032f, -0.15205210f, 0.15137035f, -0.02519100f, -0.05697881f, -0.13181891f, 0.14592247f, -0.08689957f, 
    -0.15249109f, -0.04521497f, 0.02437447f, -0.10571993f, 0.05282614f, 0.12582639f, 0.11124064f, -0.13298306f, 
    -0.10971393f, 0.02996740f, -0.07166173f, -0.01589704f, 0.13974462f, 0.13893652f, 0.16977328f, 0.16443717f, 
    -0.13460883f, -0.07259553f, 0.07880548f, -0.04674530f, -0.09175555f, -0.15556908f, -0.13698956f, -0.06774442f, 
    -0.00128000f, -0.09120145f, -0.09632106f, 0.04403069f, 0.13280034f, -0.07903146f, -0.13404609f, -0.02356705f, 
    0.00528193f, 0.15999930f, -0.07712737f, 0.17333671f, 0.10022963f, -0.12827510f, 0.09583234f, 0.04581565f, 
    -0.12471345f, 0.13611849f, 0.13793944f, 0.37214336f, 0.32049382f, 0.11611240f, 0.04579903f, -0.01272809f, 
    -0.20240809f, -0.20057620f, -0.11948877f, -0.33133754f, 0.07552584f, 0.07646275f, 0.19326814f, -0.42805454f, 
    -0.10800327f, 0.02353613f, -0.11103102f, 0.08834955f, -0.00790557f, -0.08050157f, -0.04792858f, 0.01018901f, 
    0.10850390f, 0.03376318f, 0.01864186f, -0.15847185f, -0.09492058f, 0.02725243f, -0.10025760f, -0.16002561f, 
    -0.01969677f, 0.02775721f, -0.05612497f, 0.05070907f, 0.06558998f, 0.16212584f, -0.14591449f, -0.01336732f, 
    -0.02315445f, -0.16769591f, -0.16097604f, -0.18936761f, -0.00958882f, -0.01465444f, -0.16052449f, 0.01260299f, 
    -0.02717731f, -0.02708504f, -0.10893825f, -0.41692400f, -0.09345802f, 0.21941946f, 0.19379939f, 0.22959994f, 
    0.04464169f, 0.22318146f, 0.23974447f, 0.04181074f, -0.10082932f, -0.06624421f, 0.00516416f, 0.00863969f, 
    0.04590816f, 0.07619241f, 0.36632907f, 0.03278344f, -0.05663306f, 0.09034635f, 0.32627708f, -0.19231413f, 
    -0.14674976f, 0.02665168f, 0.20158672f, -0.45768949f, 0.08269078f, 0.10668247f, 0.08764987f, -0.16791975f, 
    0.00360353f, -0.58816719f, 0.04735113f, -0.12735501f, -0.04367503f, -0.23500866f, -0.45249531f, 0.25822997f, 
    0.09443014f, -0.06519897f, 0.05436077f, -0.02817065f, 0.01880624f, -0.13601086f, -0.09598450f, 0.00928072f, 
    -0.45215979f, 0.26084670f, 0.07292961f, 0.16007878f, 0.27813143f, -0.06258366f, -0.01727455f, 0.03713728f, 
    0.15288474f, 0.09948289f, 0.08091567f, -0.36246312f, 0.15244195f, -0.14193398f, -0.45142946f, -0.13760476f, 
    0.11274088f, 0.22025742f, 0.08421677f, 0.15836108f, -0.16276012f, -0.18652117f, -0.14911494f, 0.09194993f, 
    0.14765514f, -0.15669879f, -0.25542635f, 0.07844662f, -0.10265014f, 0.02428211f, -0.02791345f, 0.01243689f, 
    0.09751218f, 0.08198263f, 0.09959688f, -0.28913850f, -0.11649015f, 0.06809761f, -0.07320546f, 0.60068542f, 
    0.17112802f, 0.14349750f, 0.38946834f, -0.28246793f, -0.17695589f, 0.12774080f, -0.06657179f, 0.21811228f, 
    -0.07499513f, -0.01533030f, -0.14573367f, -0.15410881f, -0.02745621f, 0.11309028f, -0.03369230f, 0.03832727f, 
    0.16016488f, -0.17909674f, 0.09495971f, 0.15370004f, -0.01236529f, 0.05535510f, 0.04981285f, 0.04952386f, 
    -0.07834835f, 0.00671178f, 0.10857812f, -0.17342977f, -0.04088575f, -0.12889342f, -0.16857712f, -0.10692351f, 
    -0.02807679f, 0.07636562f, -0.13260959f, 0.00805358f, -0.01878376f, 0.12834202f, -0.12648116f, -0.02917294f, 
    0.00667155f, -0.02787238f, -0.10095342f, 0.20276497f, 0.10028911f, -0.05951371f, 0.05260501f, -0.20576148f, 
    -0.03456228f, 0.07408167f, -0.51003224f, 0.02394818f, 0.11763388f, 0.09265915f, 0.34871808f, 0.15116592f, 
    -0.32869738f, 0.02806315f, -0.20574065f, -0.31906179f, 0.14048256f, -0.03584434f, 0.09837130f, 0.09036185f, 
    0.20145491f, 0.22095050f, -0.18067923f, 0.05690057f, 0.14049581f, -0.13877480f, -0.13399921f, 0.04419911f, 
    -0.01972727f, -0.36475760f, -0.02283259f, 0.10288528f, 0.06430267f, 0.18645872f, 0.12940083f, -0.12896691f, 
    0.16359210f, 0.04349835f, -0.01906333f, 0.19010508f, -0.04668424f, -0.10395995f, 0.34768760f, -0.10545620f, 
    0.02059890f, -0.09047725f, -0.09425411f, -0.04276339f, 0.03100487f, 0.00775579f, 0.51066530f, -0.43058002f, 
    0.23417807f, -0.26389569f, -0.14921524f, 0.10300502f, 0.13855383f, 0.05941685f, -0.12005616f, 0.12304956f, 
    -0.09453046f, 0.31670633f, 0.04496649f, -0.21886909f, 0.18352531f, 0.21660031f, -0.21270092f, -0.07084309f, 
    -0.00585670f, 0.14431056f, -0.20095582f, -0.24058369f, 0.01198724f, 0.10002664f, 0.13563755f, 0.15759988f, 
    0.25117511f, -0.05090461f, 0.03215227f, 0.33845001f, 0.10920483f, 0.11352354f, -0.38194031f, 0.32239190f, 
    -0.07330941f, 0.01009908f, -0.13142197f, 0.03786639f, -0.14746633f, 0.03513102f, 0.08635408f, 0.11703758f, 
    0.02859313f, -0.42038456f, 0.14977679f, -0.10476077f, -0.03622359f, 0.10993572f, -0.05798332f, 0.02811356f, 
    0.16777383f, 0.09717511f, -0.06262870f, -0.04054101f, -0.01555222f, 0.02862892f, 0.05820860f, -0.03073019f, 
    -0.46673551f, -0.23132363f, 0.01516637f, -0.01516475f, -0.00898325f, -0.06016427f, 0.20144592f, -0.49058077f, 
    0.28003538f, -0.07914728f, -0.10769528f, -0.05710666f, 0.13548438f, -0.05442230f, 0.08786337f, 0.12923606f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.13040860f, 0.06185306f, -0.08874911f, 0.13909876f, 0.30249712f, 0.33406070f, 0.15473831f, -0.06734869f, 
    0.25575712f, 0.13321169f, 0.10417896f, 0.06040109f, 0.03520875f, 0.26459420f, -0.08252138f, 0.30583364f, 
    0.02605079f, 0.11654924f, 0.06330208f, 0.11018764f, 0.01651099f, 0.13152312f, -0.01057187f, -0.08382642f, 
    0.03774684f, 0.07098147f, 0.10440132f, 0.24153627f, -0.04146277f, -0.14105655f, 0.15729263f, 0.23861633f, 
    -0.16054541f, -0.13589403f, -0.05856720f, 0.18119824f, 0.11126023f, -0.16481861f, -0.00361000f, 0.15967858f, 
    0.24504460f, 0.09753390f, -0.07873096f, -0.09564991f, 0.24886894f, 0.28068432f, -0.08892895f, 0.35773861f, 
    0.26168129f, 0.23673265f, -0.19444841f, -0.13942984f, -0.15981655f, -0.01384125f, 0.09996482f, 0.03694433f, 
    -0.10353006f, 0.25508276f, -0.28582484f, -0.11138471f, -0.20297064f, 0.23645304f, -0.07264089f, 0.19041696f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.02367629f, -0.10882775f, 0.12385763f, 0.02761420f, -0.08471533f, 0.00741533f, -0.09191276f, -0.06977521f, 
    -0.08457492f, -0.08521435f, 0.03689529f, -0.11536470f, -0.11150299f, -0.08295931f, 0.06891534f, -0.14090815f, 
    0.08105308f, -0.02316047f, 0.02346582f, -0.03594317f, 0.06175357f, 0.03696898f, -0.14204872f, 0.08044884f, 
    -0.04473292f, -0.06558187f, -0.08328725f, -0.05232935f, -0.03970474f, -0.15030304f, -0.01415386f, -0.11261800f, 
    0.11907278f, 0.09015165f, 0.09377527f, 0.01457845f, -0.05545754f, 0.01890512f, -0.10518213f, 0.01204121f, 
    0.09328142f, -0.09629387f, -0.07346977f, -0.01163709f, 0.04988642f, 0.04118851f, -0.05322267f, -0.02749482f, 
    0.02785667f, -0.07726297f, -0.09031749f, -0.10092758f, -0.08005689f, 0.10159740f, 0.05750190f, 0.10888126f, 
    -0.02590831f, -0.00568400f, 0.00235708f, 0.07643308f, 0.04964622f, -0.10984249f, -0.09469340f, -0.01550015f, 
    0.13913754f, 0.06455182f, -0.01519289f, 0.13092150f, 0.14743200f, -0.00790528f, -0.29208204f, 0.23184581f, 
    -0.19574979f, -0.03220272f, -0.14790475f, -0.27223682f, 0.03811693f, 0.01357848f, -0.09573974f, 0.09168267f, 
    -0.02432961f, -0.74154615f, -0.03202829f, -0.04754630f, -0.06062687f, 0.10767982f, 0.11069711f, 0.13138638f, 
    0.21772885f, 0.27455440f, 0.14047018f, 0.22039708f, -0.03020140f, -0.03331742f, -0.01904779f, 0.12869962f, 
    -0.01483411f, -0.00490885f, -0.30517629f, -0.40192962f, 0.04279609f, 0.01085152f, -0.12783758f, 0.21046454f, 
    0.16523759f, -0.12709717f, -0.12730093f, 0.04185116f, 0.23092213f, 0.11859602f, -0.13181709f, -0.02119585f, 
    0.06993675f, 0.04352633f, 0.10726772f, 0.02916035f, -0.01175717f, -0.11536737f, -0.05004327f, 0.00116393f, 
    0.32568493f, -0.00558883f, -0.15033703f, -0.00579117f, -0.15330425f, 0.05380037f, 0.14346342f, 0.00220683f, 
    -0.08548138f, -0.10647067f, 0.02883346f, -0.18183205f, -0.15783070f, 0.05585167f, 0.00501513f, 0.01164663f, 
    0.10928067f, 0.08219425f, -0.11494946f, -0.09639573f, -0.11464263f, -0.12065448f, 0.05220644f, -0.13367005f, 
    0.11849380f, 0.03771684f, 0.02902257f, -0.00559027f, 0.08502953f, -0.05513516f, -0.13120550f, -0.08080520f, 
    0.03243529f, -0.02808415f, -0.13517344f, -0.18660192f, 0.11163723f, -0.03057677f, -0.13428922f, -0.03716864f, 
    0.07777844f, 0.00072122f, -0.19209681f, -0.04389105f, -0.02947138f, 0.10843556f, 0.07703317f, -0.03574698f, 
    0.08529685f, -0.05673968f, 0.02721007f, 0.05837451f, -0.06528312f, -0.04282607f, 0.00457972f, -0.04811739f, 
    -0.10434552f, -0.05079542f, -0.10433047f, -0.04275099f, 0.08328021f, 0.06459768f, -0.16273586f, 0.06690322f, 
    -0.08901663f, -0.02466650f, -0.15879756f, -0.00414652f, 0.03775755f, 0.03359195f, 0.04936103f, -0.13046679f, 
    -0.02665243f, -0.01629774f, -0.10034022f, -0.06432582f, 0.11301234f, -0.45042306f, -0.39363313f, 0.03699338f, 
    -0.27104563f, 0.08795925f, 0.15683737f, -0.44013369f, 0.24120033f, -0.00600835f, 0.07964130f, -0.13703452f, 
    0.12479578f, -0.43153325f, -0.15972230f, 0.02535882f, -0.08399698f, 0.15594761f, 0.02844525f, 0.15364094f, 
    -0.04231151f, 0.20555484f, 0.14661704f, -0.12098417f, -0.03532480f, 0.24570386f, 0.14178130f, -0.06930487f, 
    -0.01307642f, -0.04342813f, 0.13531435f, -0.00447508f, 0.07630806f, -0.08632112f, 0.07836898f, 0.22553819f, 
    -0.24229610f, -0.16603473f, -0.20225112f, -0.08835039f, -0.05760795f, -0.18213800f, 0.34408084f, -0.30897391f, 
    -0.10737973f, 0.00362194f, -0.06165680f, 0.16476873f, -0.07523596f, 0.03859521f, 0.07466481f, -0.01646041f, 
    -0.29643860f, -0.45745727f, 0.02404939f, -0.08489300f, 0.20149967f, -0.24875353f, 0.17930387f, -0.05423528f, 
    -0.02705612f, 0.01330380f, 0.07398468f, 0.18124966f, -0.00661772f, 0.01513817f, -0.06488853f, -0.07670926f, 
    -0.03614262f, -0.47880891f, 0.39098111f, 0.00671582f, 0.06421951f, -0.25526592f, 0.04853629f, -0.14279187f, 
    0.06704859f, 0.24326418f, 0.00701959f, -0.37073192f, -0.07298326f, 0.35191941f, 0.00681000f, 0.07036173f, 
    0.06312662f, 0.03427734f, 0.00103803f, 0.13560873f, 0.04775189f, -0.26095086f, -0.43960631f, 0.05757290f, 
    0.11267412f, 0.01875442f, -0.16854627f, 0.06511375f, -0.04088096f, 0.08160855f, -0.15511183f, 0.24211685f, 
    -0.08158584f, -0.03022298f, -0.00239367f, -0.02636728f, 0.10767318f, 0.04620026f, -0.01039789f, 0.05070066f, 
    0.26593739f, -0.18082502f, -0.07862224f, -0.10233936f, 0.03310956f, 0.00429064f, -0.23271243f, 0.03437273f, 
    -0.15314746f, 0.08525991f, -0.04665670f, 0.08476093f, -0.16228680f, 0.05866833f, -0.36465812f, -0.02712298f, 
    0.40416852f, 0.02390645f, 0.00218689f, 0.04177316f, -0.18700327f, -0.20557825f, 0.11409416f, 0.06757500f, 
    -0.24954252f, 0.07098994f, -0.15944256f, -0.24118420f, 0.14431928f, -0.07210577f, -0.10496251f, 0.20191897f, 
    -0.06983211f, -0.46320522f, 0.19731130f, 0.07038574f, 0.01966402f, 0.09451492f, 0.11667533f, 0.20307365f, 
    0.18065125f, 0.10038961f, -0.39113981f, -0.07380752f, -0.14249405f, -0.03568236f, 0.11482511f, -0.13029313f, 
    0.04784395f, 0.09400463f, -0.00897503f, -0.05309669f, 0.15686831f, 0.00094403f, -0.14098492f, 0.02627003f, 
    0.02512159f, 0.21078305f, -0.05724213f, -0.11065997f, -0.04271544f, -0.21698374f, 0.04641750f, -0.04020599f, 
    -0.10994086f, 0.15160438f, -0.06732843f, 0.18602173f, 0.10108027f, -0.09127236f, 0.05807809f, -0.03219402f, 
    0.14024852f, -0.16776055f, 0.01355828f, -0.08685530f, -0.11481401f, 0.21392608f, -0.20884804f, 0.12107494f, 
    -0.10174002f, -0.45582017f, -0.04395868f, -0.42503166f, 0.18642104f, -0.31674534f, -0.13543420f, 0.10570318f, 
    -0.22352593f, 0.25319415f, -0.38079166f, -0.13794343f, -0.13752276f, 0.25634331f, -0.11841290f, -0.00054753f, 
    -0.12861384f, 0.30748856f, -0.10854014f, 0.26208213f, 0.07165767f, 0.00190862f, 0.18032254f, -0.18655272f, 
    0.05177142f, 0.18366334f, 0.10428680f, 0.02195691f, 0.06362007f, 0.12018061f, 0.12508495f, 0.26716045f, 
    -0.04015940f, 0.07732275f, 0.42313650f, 0.12846744f, 0.05689864f, 0.11999221f, -0.09495842f, -0.31505451f, 
    -0.14371307f, 0.22528130f, -0.19164641f, 0.03752668f, -0.16178609f, -0.26639807f, 0.17988901f, 0.29556820f, 
    0.01693588f, 0.10145344f, 0.02059692f, 0.05742854f, -0.00824001f, 0.00683817f, -0.02298969f, 0.03020338f, 
    0.07474659f, -0.27319902f, 0.04135307f, 0.04096137f, 0.08031115f, -0.26804283f, -0.00780261f, -0.21406592f, 
    -0.27489227f, 0.06417909f, 0.03386999f, -0.00583920f, -0.12443544f, 0.03953058f, 0.03412654f, -0.26738307f, 
    -0.12196592f, -0.12718244f, 0.28792071f, 0.00514292f, -0.04365471f, -0.19922675f, 0.18984693f, 0.22828621f, 
    -0.14162435f, 0.53077936f, -0.00567176f, 0.11570472f, -0.07099441f, 0.03356916f, -0.14108467f, 0.03879129f, 
    0.15691715f, -0.21440502f, 0.23756146f, 0.18969858f, -0.06917664f, 0.12510917f, 0.09179328f, -0.07121213f, 
    0.00741664f, 0.03210970f, -0.07549506f, 0.16605127f, -0.00382289f, -0.10442066f, 0.09864122f, 0.25480086f, 
    0.11954314f, -0.33288282f, 0.29667446f, 0.00759126f, 0.14739124f, 0.19180186f, 0.16466355f, 0.08252379f, 
    -0.04008293f, -0.03738068f, -0.05262488f, -0.03277328f, 0.11568107f, 0.07080025f, -0.24165420f, -0.06983303f, 
    -0.24818973f, -0.04926167f, -0.09782368f, 0.09546413f, 0.20988533f, 0.30575722f, 0.01485210f, 0.27605566f, 
    -0.06434903f, 0.12208898f, 0.10104155f, 0.16663983f, 0.08436558f, -0.06568824f, -0.29191911f, 0.17752828f, 
    0.19494620f, 0.17837939f, 0.51230145f, -0.05172104f, -0.08289339f, 0.00920611f, 0.04787956f, -0.14809045f, 
    -0.02659710f, 0.00234422f, 0.13625814f, -0.01043791f, -0.04847105f, 0.14663635f, 0.08502255f, 0.18264747f, 
    -0.13251773f, 0.19102742f, 0.43340027f, 0.06496954f, -0.07980604f, 0.13832529f, -0.03173092f, 0.15039280f, 
    0.04025117f, -0.09091232f, 0.47681487f, 0.18860559f, -0.08170060f, 0.11437348f, 0.04342459f, 0.25074232f, 
    -0.12725917f, -0.18696283f, 0.06519496f, 0.10450092f, 0.20694788f, 0.21772881f, 0.09185813f, 0.02857697f, 
    0.20662156f, -0.27172557f, -0.04864830f, 0.12986194f, -0.05860665f, 0.06225491f, 0.03747680f, -0.08618893f, 
    -0.06363277f, -0.00690588f, -0.11727603f, 0.13078518f, 0.08773410f, -0.17693420f, -0.03139627f, -0.12465683f, 
    0.24055701f, -0.14232573f, -0.08580002f, -0.09589701f, -0.15447792f, -0.13449933f, -0.07281690f, 0.20208597f, 
    0.00415601f, 0.24330662f, -0.28776506f, 0.29343262f, -0.07796480f, 0.08874214f, -0.05525202f, 0.06594389f, 
    -0.03875992f, 0.12866518f, 0.04890540f, 0.27015111f, 0.06366158f, 0.07908683f, 0.16359237f, -0.27231047f, 
    -0.08620732f, 0.32653180f, -0.30875233f, 0.13506767f, -0.04876719f, -0.19626297f, 0.09353093f, 0.24687617f, 
    -0.07253020f, 0.11022929f, 0.34316260f, -0.21729596f, 0.05168832f, 0.00160055f, -0.19964167f, 0.02672523f, 
    -0.02341395f, 0.26487032f, -0.22568360f, -0.03250378f, -0.19531618f, 0.04863448f, 0.04193316f, -0.04347354f, 
    0.08330472f, -0.03758536f, -0.07922591f, 0.09902453f, 0.00732759f, 0.02737074f, 0.13520192f, -0.04125556f, 
    0.17736475f, 0.11362861f, -0.32036060f, -0.07397585f, 0.09086516f, 0.00990676f, -0.33098722f, 0.09656536f, 
    0.21349341f, 0.05881691f, 0.02453239f, 0.17820966f, -0.08604845f, -0.21137376f, 0.15427299f, 0.13555481f, 
    -0.13273479f, 0.12238531f, -0.29107767f, -0.11214982f, -0.08748971f, 0.01809816f, 0.20230280f, 0.06619763f, 
    -0.11903539f, -0.01777553f, 0.18267049f, 0.01216889f, 0.10423386f, 0.07864886f, 0.32370552f, 0.03199545f, 
    0.09274920f, -0.17399420f, -0.29201096f, 0.14940242f, -0.08152092f, 0.05937643f, -0.00473775f, -0.03319430f, 
    -0.00069237f, -0.06914765f, 0.48749956f, -0.09497634f, 0.15375713f, -0.03343177f, -0.23403910f, -0.04563415f, 
    -0.06549404f, 0.14227593f, 0.22717114f, -0.09862047f, -0.30117071f, -0.10202542f, -0.20161398f, -0.21272212f, 
    0.01150346f, -0.20164198f, 0.04112518f, -0.01731357f, 0.08797188f, 0.11848568f, 0.37235636f, 0.00429337f, 
    0.09848118f, 0.03727129f, 0.05230328f, 0.01615355f, 0.17283098f, 0.30927542f, -0.17337804f, 0.02124733f, 
    -0.32458299f, 0.12752996f, 0.04755554f, -0.09208477f, 0.08212113f, 0.25336212f, 0.21467830f, -0.27122837f, 
    0.14876616f, 0.23012964f, -0.07002707f, -0.10367190f, 0.00765921f, 0.10612735f, -0.39573422f, 0.20806658f, 
    0.03183066f, -0.09212724f, -0.02315511f, 0.28960201f, 0.03325568f, -0.02520461f, -0.01137588f, -0.13692255f, 
    0.09613511f, -0.20040777f, 0.03168150f, -0.02627319f, -0.02966784f, 0.20263770f, 0.16811217f, 0.14997205f, 
    0.01204950f, 0.08105920f, -0.48661101f, -0.02645564f, 0.12449627f, 0.08736719f, -0.11578824f, 0.07125257f, 
    0.18665613f, 0.08207696f, -0.08075236f, 0.07255021f, 0.03143056f, 0.33751184f, 0.09900174f, -0.01023101f, 
    -0.15405019f, 0.35966018f, 0.12042782f, -0.10696207f, 0.02429344f, 0.04917492f, -0.36500737f, -0.08860064f, 
    0.07663979f, -0.04661585f, -0.41277355f, -0.13477500f, -0.11782436f, 0.34501144f, -0.11888973f, 0.33639789f, 
    0.15930291f, 0.08685253f, 0.07348716f, -0.09605215f, 0.12530307f, 0.21360864f, 0.16337848f, 0.15837470f, 
    0.33555436f, -0.08392024f, 0.16356209f, 0.11257972f, 0.00981943f, 0.10308643f, -0.09837573f, 0.07206038f, 
    0.06402741f, -0.52833408f, 0.04320177f, 0.11660117f, -0.02523652f, -0.04661750f, -0.04967133f, -0.03877503f, 
    -0.03650368f, 0.30483741f, 0.01947716f, -0.14327188f, -0.14501961f, -0.12872133f, 0.05874287f, 0.19838825f, 
    0.00789239f, -0.13964233f, -0.49429026f, -0.34356806f, -0.26353905f, -0.05800892f, -0.11096849f, -0.13269342f, 
    0.01521184f, 0.27245674f, 0.02872586f, -0.06137943f, 0.20581849f, 0.08621417f, 0.00416039f, 0.24274486f, 
    0.02612329f, 0.15878721f, 0.05708060f, 0.05168802f, 0.08869185f, -0.08846654f, -0.16966955f, 0.00154854f, 
    0.29341578f, 0.15464351f, -0.14044043f, 0.02292903f, -0.19242254f, -0.14196186f, 0.13432485f, 0.10352240f, 
    0.00601274f, -0.11141936f, -0.10625348f, 0.14677490f, 0.01539334f, -0.41796649f, -0.46444991f, 0.32484788f, 
    -0.06986302f, 0.32303533f, -0.03956627f, -0.59674340f, 0.06220680f, 0.02332678f, -0.16983810f, -0.07315266f, 
    0.10435214f, 0.18135205f, -0.18270135f, 0.19544145f, -0.09439599f, -0.15591593f, 0.21969870f, -0.14287290f, 
    0.03598174f, 0.16902199f, -0.05014675f, -0.00854513f, 0.10324009f, 0.09242196f, 0.14468235f, 0.20347424f, 
    -0.00658415f, -0.11632630f, 0.43971226f, -0.04275275f, 0.30810890f, -0.08915697f, -0.16293676f, 0.27732244f, 
    -0.39366761f, -0.02527658f, -0.17743196f, 0.10564837f, -0.07322881f, -0.25155738f, 0.21480674f, -0.01694983f, 
    -0.00371658f, -0.02817678f, 0.00123069f, 0.15552007f, 0.00990886f, 0.04514940f, 0.31005260f, 0.04685185f, 
    -0.12955312f, -0.20399627f, -0.14172123f, 0.11359537f, 0.13432924f, -0.05349388f, 0.10847469f, 0.00537155f, 
    -0.02670743f, -0.10845163f, 0.00932656f, 0.04976409f, -0.11679191f, -0.00109523f, -0.02538987f, -0.13373546f, 
    -0.01322064f, 0.03942201f, 0.04186424f, -0.02997790f, 0.00949130f, -0.11742385f, -0.00213323f, -0.05561139f, 
    0.06554359f, -0.03718001f, -0.04788371f, 0.02581559f, -0.08679613f, -0.01538327f, -0.03901824f, -0.00141455f, 
    0.01049966f, -0.11189867f, 0.08518000f, -0.08067928f, -0.10890821f, -0.04674824f, -0.03396591f, 0.10465184f, 
    0.11726680f, 0.06859486f, -0.05511517f, -0.06291900f, -0.13164707f, 0.05080548f, 0.04865554f, 0.07105915f, 
    0.08380317f, -0.17184719f, -0.01390807f, -0.09875320f, -0.03207034f, -0.03036503f, -0.05727565f, -0.03184905f, 
    -0.11773827f, -0.03094756f, -0.07837114f, 0.10410048f, -0.12398632f, -0.06238499f, 0.07901614f, 0.07242358f, 
    -0.06008400f, -0.01841034f, -0.06491638f, 0.10863860f, -0.11875632f, 0.01835337f, 0.06631827f, 0.00517927f, 
    0.23980220f, 0.04302526f, 0.05292499f, 0.06935515f, 0.05936238f, 0.01513251f, 0.09074141f, 0.20612356f, 
    0.02215385f, -0.03518768f, 0.02812072f, 0.32837543f, -0.23184733f, 0.13897489f, 0.02542113f, -0.03706235f, 
    0.07098964f, -0.18395652f, 0.06039486f, 0.18491109f, -0.08419295f, -0.40529343f, 0.35847494f, -0.00635630f, 
    0.12164927f, 0.13346301f, 0.44263014f, 0.12793663f, -0.10879432f, 0.13637276f, 0.02368246f, 0.25066507f, 
    -0.02810168f, -0.01619693f, -0.00228073f, -0.13066341f, -0.17383516f, -0.09629206f, 0.01759758f, 0.07321352f, 
    -0.02540534f, -0.23477212f, -0.14522427f, -0.08566050f, 0.21804540f, 0.56963336f, -0.08936843f, 0.07534423f, 
    0.21795085f, -0.08524060f, -0.01871834f, 0.05946658f, 0.01182660f, 0.02455644f, 0.00193463f, 0.02721085f, 
    0.12564558f, -0.01417267f, -0.09127740f, 0.09405195f, 0.17077577f, -0.09351236f, 0.12629738f, 0.04503583f, 
    -0.02112849f, 0.16556403f, 0.03875820f, -0.00813646f, -0.10574356f, -0.10967348f, 0.13855776f, -0.15396318f, 
    0.12031841f, -0.00773187f, -0.44392696f, 0.00297669f, 0.16698086f, -0.18826012f, 0.33268327f, 0.20897059f, 
    0.14789583f, -0.42146206f, 0.10432057f, -0.04188342f, -0.02437737f, -0.03496228f, 0.01592775f, 0.09443718f, 
    0.06039325f, -0.40231404f, -0.28553891f, 0.09134732f, -0.02176293f, 0.16290675f, 0.07503001f, -0.23954926f, 
    -0.06746872f, -0.02143418f, 0.17014605f, 0.16563417f, 0.03757858f, 0.02310668f, -0.17003883f, -0.09580871f, 
    0.10570141f, 0.00697246f, 0.27137128f, 0.06701444f, -0.16249408f, -0.23051669f, -0.21248740f, -0.26255792f, 
    -0.20796464f, -0.02842801f, -0.06406654f, 0.13277453f, -0.01689547f, -0.01873875f, -0.04667996f, 0.12680614f, 
    0.13193688f, -0.03553905f, -0.13815667f, 0.04635695f, 0.06601923f, 0.19444793f, -0.03036443f, 0.17786916f, 
    -0.06054020f, -0.02901195f, -0.06406122f, -0.04904315f, 0.11127655f, -0.09663582f, -0.08567829f, -0.01242116f, 
    -0.07559848f, 0.04210221f, -0.01217011f, 0.03083336f, 0.05511034f, -0.08171465f, -0.05906221f, 0.03043183f, 
    -0.12373255f, 0.04293581f, -0.12895595f, -0.12513019f, 0.01350285f, 0.07563998f, -0.06882216f, 0.04264129f, 
    -0.13674125f, -0.01178794f, -0.12194608f, -0.03464444f, -0.06027018f, -0.08875761f, 0.00099680f, 0.07318728f, 
    0.06190160f, 0.11557811f, 0.05823392f, 0.02271220f, -0.04825762f, -0.12471682f, 0.01488063f, -0.09582178f, 
    -0.12058334f, -0.11049155f, -0.01295593f, -0.10610560f, -0.00100011f, -0.04046011f, -0.00072880f, -0.04264323f, 
    -0.14222397f, -0.06037927f, 0.07854483f, -0.11876307f, -0.11102134f, 0.08867587f, 0.08940631f, 0.11726879f, 
    -0.03369090f, 0.09100790f, -0.06836899f, 0.02549796f, -0.02672137f, 0.08742451f, -0.08981816f, -0.09363170f, 
    -0.51311511f, 0.02572290f, 0.01959872f, -0.09535304f, -0.00332241f, 0.18029512f, 0.21784447f, -0.00462318f, 
    0.41763470f, 0.22055465f, -0.23611450f, 0.36135662f, -0.02308123f, 0.14526272f, 0.06725024f, 0.14177886f, 
    0.02563586f, 0.64477414f, -0.13402745f, 0.08679687f, 0.06464028f, 0.09905366f, -0.23029451f, -0.18155316f, 
    -0.15051609f, -0.22140962f, 0.32171357f, -0.16582154f, 0.04327557f, 0.11782473f, 0.13744044f, 0.17825870f, 
    0.00622444f, 0.05392675f, 0.30849415f, -0.05659053f, 0.11216659f, -0.04932323f, 0.08657004f, 0.02290079f, 
    0.02857768f, 0.23026082f, 0.08811007f, 0.06097907f, 0.03798589f, -0.27179161f, 0.03921413f, 0.33916834f, 
    0.22297849f, 0.13262649f, 0.06072836f, -0.03933337f, -0.06181140f, 0.10551516f, 0.14905287f, -0.04774427f, 
    -0.19737516f, 0.00835695f, -0.16004981f, 0.05075676f, -0.06745484f, -0.17772490f, 0.12001589f, -0.08556491f, 
    0.03730672f, 0.19960532f, 0.00423914f, -0.02000251f, 0.09623991f, 0.08026451f, -0.08871067f, 0.12395058f, 
    0.10514801f, 0.01780029f, -0.15296876f, 0.14915353f, -0.09208014f, -0.14821701f, -0.34206852f, -0.03528806f, 
    -0.06243977f, 0.21678354f, -0.07148053f, 0.21969548f, 0.01144387f, -0.08885900f, 0.32684764f, -0.18905459f, 
    -0.21546474f, 0.25753534f, 0.19482762f, 0.22448052f, 0.11235178f, -0.29194668f, -0.16618444f, 0.27445298f, 
    -0.06735957f, -0.08429135f, -0.15593857f, -0.48834479f, 0.02916970f, -0.06296127f, 0.09047777f, 0.13714381f, 
    0.16987912f, 0.01336635f, -0.17722289f, -0.03666393f, 0.29952320f, 0.53844422f, -0.22632270f, 0.28609651f, 
    0.20291911f, -0.05073345f, 0.01819017f, -0.03665340f, 0.09896854f, 0.06331215f, 0.05898520f, -0.10013990f, 
    0.08411502f, 0.31243625f, -0.73020262f, 0.03111551f, -0.12119652f, 0.05100998f, -0.13260219f, 0.27324048f, 
    -0.13027866f, -0.14221461f, 0.06246372f, 0.04265939f, -0.02904828f, 0.02604618f, -0.08411942f, -0.01770300f, 
    0.07641254f, -0.05927635f, 0.03553768f, 0.11944595f, -0.12821916f, -0.14289473f, 0.04909083f, 0.07518420f, 
    -0.06108865f, 0.14262141f, -0.02641199f, -0.00651430f, 0.11150025f, -0.15633959f, -0.11975595f, -0.16500920f, 
    -0.14580785f, 0.01757126f, 0.05518090f, -0.06421565f, 0.11957173f, 0.05862484f, -0.13674229f, 0.04142019f, 
    -0.04178149f, 0.10309163f, -0.08302110f, -0.06979496f, -0.12124540f, 0.03006694f, -0.14493078f, -0.09971891f, 
    0.07975708f, -0.12835412f, 0.08068807f, -0.06690142f, -0.09100015f, 0.09567049f, -0.15623976f, 0.09689115f, 
    0.02948640f, 0.04336552f, 0.05287230f, -0.01689534f, 0.09021221f, -0.09485975f, -0.13122958f, -0.09210768f, 
    -0.11258506f, -0.05705072f, -0.00244629f, 0.09795065f, 0.03862311f, -0.09302647f, -0.09766752f, -0.15770017f, 
    -0.20001242f, -0.07420865f, -0.03178701f, -0.16243073f, 0.21463820f, 0.06034442f, 0.26217729f, -0.16742198f, 
    0.26087418f, 0.00704412f, -0.02404196f, 0.36864322f, -0.12104444f, 0.12131037f, 0.01662643f, 0.18657736f, 
    0.00683448f, 0.68386954f, 0.04960557f, 0.20768650f, 0.09103804f, 0.00248354f, -0.20223768f, -0.01927073f, 
    -0.12251717f, -0.10722148f, 0.16330387f, 0.05436199f, -0.10047540f, -0.24880391f, 0.02536321f, 0.20107491f, 
    0.11555207f, -0.00413521f, -0.10825546f, 0.25798622f, -0.12187926f, -0.11527486f, 0.06866183f, -0.20630988f, 
    0.05684185f, 0.27755362f, 0.19305027f, -0.10903732f, -0.09429049f, 0.15093565f, 0.02893319f, 0.12156901f, 
    0.26711059f, 0.21215582f, 0.08523897f, -0.16668466f, -0.10476609f, 0.01212364f, -0.21092890f, -0.04402997f, 
    0.02490917f, 0.08708517f, 0.00153447f, -0.02433464f, 0.03835344f, -0.03065035f, 0.01946741f, 0.04151537f, 
    0.04330111f, 0.05745381f, -0.01415889f, -0.10247259f, -0.04656117f, -0.13156626f, -0.04110667f, 0.05800432f, 
    -0.03402378f, 0.07718159f, -0.12303467f, -0.04337094f, 0.09597006f, -0.00598375f, -0.12870629f, 0.07034680f, 
    0.04034546f, 0.06831641f, -0.05297850f, -0.10055467f, 0.00336771f, 0.02464569f, 0.05604732f, -0.11359873f, 
    -0.12513942f, -0.02013477f, 0.06351269f, -0.03898370f, 0.06854330f, 0.03314089f, 0.03270342f, -0.13519809f, 
    0.00697967f, -0.04496193f, -0.11491024f, -0.04938248f, -0.08370736f, -0.04097576f, -0.00075806f, -0.09806585f, 
    -0.00208977f, -0.00633815f, -0.02567860f, -0.07412447f, -0.07684559f, -0.07519763f, 0.00408781f, 0.10078350f, 
    -0.04164900f, -0.04507871f, -0.10404989f, -0.12715542f, -0.04229923f, -0.08136348f, -0.04138824f, 0.07497727f, 
    -0.03810545f, -0.08233030f, -0.06242933f, -0.03664815f, -0.01533861f, -0.01956963f, -0.11374547f, 0.02230868f, 
    -0.08966470f, 0.18875694f, 0.02402113f, -0.08983663f, 0.10465027f, 0.26528028f, 0.30199265f, 0.19023953f, 
    -0.12399276f, -0.07470255f, -0.29765201f, 0.40687859f, 0.29384685f, 0.15868555f, -0.03677030f, 0.05886665f, 
    0.07440002f, -0.20307621f, 0.02504993f, -0.12784714f, 0.10311466f, 0.21430182f, -0.25463375f, -0.06775401f, 
    -0.23568495f, 0.26944083f, -0.07665329f, -0.07612273f, -0.04671630f, -0.08544798f, 0.19100879f, 0.00116786f, 
    0.08325596f, -0.01364362f, -0.27577788f, -0.00959991f, -0.06240908f, -0.05910502f, 0.02058280f, -0.13915430f, 
    0.21912901f, 0.35819322f, 0.00988533f, -0.01868589f, -0.22195931f, -0.17919956f, 0.04382591f, 0.15551443f, 
    -0.07934757f, 0.26438954f, 0.04829314f, 0.00908538f, -0.05669370f, 0.07510405f, 0.27362531f, -0.13324048f, 
    0.15016948f, 0.26136959f, -0.00050795f, 0.04363098f, -0.19176775f, -0.06817561f, -0.04343832f, 0.08774865f, 
    0.25908899f, 0.04657079f, -0.01313910f, -0.09560689f, 0.29375955f, 0.05528662f, 0.18909468f, 0.12672418f, 
    -0.09832650f, -0.06754658f, 0.18348196f, 0.42616248f, -0.13729380f, 0.11697415f, -0.07550332f, 0.13286543f, 
    0.08671168f, 0.46233073f, 0.06059268f, 0.11214113f, -0.04949325f, -0.13507500f, 0.41689372f, -0.28831518f, 
    -0.06199445f, 0.28121012f, 0.01256968f, 0.13884157f, -0.03252484f, -0.37712422f, 0.20007873f, 0.48827571f, 
    0.09464337f, 0.00269217f, 0.01461090f, 0.03967663f, -0.13752630f, -0.01282665f, -0.10546690f, -0.07793189f, 
    -0.04154191f, 0.02812749f, 0.11740806f, -0.08614372f, 0.07170626f, 0.12597394f, -0.13895759f, 0.25661060f, 
    0.23718870f, -0.22593695f, -0.00659313f, -0.04407951f, 0.09592466f, 0.04238642f, -0.27683020f, -0.09321021f, 
    -0.29885027f, 0.29973733f, -0.10455788f, 0.03916186f, 0.40547034f, 0.05939071f, -0.22452851f, 0.18275127f, 
    -0.02322930f, 0.16192198f, -0.06847180f, 0.27842423f, -0.19715682f, 0.32965505f, 0.15620369f, 0.02872658f, 
    -0.76173139f, 0.00982057f, -0.00707530f, -0.39969990f, 0.51747000f, -0.13459782f, 0.03498850f, 0.12966040f, 
    -0.09798560f, -0.43279898f, 0.09072734f, -0.15905246f, -0.02535965f, 0.46785888f, -0.19374189f, 0.06818974f, 
    -0.23453273f, -0.02215060f, 0.14084145f, 0.18951939f, -0.01806493f, -0.14459476f, -0.26416957f, -0.10557530f, 
    -0.07229607f, 0.12907264f, 0.05669241f, 0.08680562f, 0.43504336f, -0.10726450f, -0.01784471f, 0.38499698f, 
    0.17003475f, 0.07954193f, 0.14720900f, 0.07954204f, 0.22672501f, -0.10584351f, -0.06526018f, 0.08350365f, 
    -0.02224025f, 0.08343885f, -0.04717820f, 0.20152709f, -0.02786027f, 0.03194593f, 0.12159221f, -0.09231281f, 
    0.02398005f, -0.00349816f, -0.02808414f, 0.10540620f, -0.46634957f, 0.03456270f, 0.12590583f, 0.00026086f, 
    0.01387711f, 0.15917078f, 0.09588894f, -0.03424190f, 0.09918325f, 0.33554834f, -0.11617307f, 0.02408778f, 
    0.20332384f, -0.26722267f, 0.17636119f, 0.21689871f, -0.12771578f, -0.13082431f, 0.17613944f, -0.05084536f, 
    -0.01275834f, -0.18391408f, 0.22777742f, 0.10950772f, -0.03038420f, -0.15518868f, -0.17852743f, 0.10666076f, 
    -0.06682904f, -0.17385517f, 0.12905583f, 0.10225792f, 0.01778926f, -0.06466088f, 0.10043216f, -0.09598867f, 
    -0.09782815f, -0.08239833f, -0.49033314f, 0.30900154f, 0.04171675f, -0.03417879f, -0.02897347f, 0.06728464f, 
    0.21240929f, -0.21787640f, 0.10662653f, -0.00511417f, 0.03059386f, 0.14071397f, -0.19849722f, -0.03889696f, 
    0.03874357f, -0.03903192f, -0.03102220f, -0.01937531f, 0.07817096f, -0.01528423f, 0.01325036f, -0.05333584f, 
    0.07588315f, 0.04538019f, 0.02999387f, -0.03343979f, 0.03870849f, -0.04830514f, -0.11811829f, 0.26948351f, 
    -0.09313111f, -0.22282468f, -0.05353639f, -0.06623342f, 0.14504741f, 0.22368000f, 0.15078351f, 0.17371768f, 
    0.25060883f, -0.02752871f, 0.00672067f, 0.27660042f, -0.07687563f, 0.01569680f, 0.20257983f, 0.10441253f, 
    0.04516159f, -0.26775482f, 0.22778715f, -0.09505548f, -0.12065554f, -0.07169954f, -0.34721932f, -0.05112927f, 
    0.02846880f, -0.21541770f, 0.27108845f, -0.29112568f, -0.09470800f, -0.04660838f, 0.08692230f, -0.01115562f, 
    -0.01053238f, -0.05333090f, -0.08775241f, -0.10139677f, -0.08473350f, -0.10372040f, 0.10389524f, -0.05126766f, 
    0.05919511f, 0.22891402f, 0.17883819f, 0.01141679f, -0.01207119f, -0.07617896f, 0.07352658f, 0.31298679f, 
    -0.04630598f, 0.02163401f, -0.03546537f, 0.12234021f, 0.01622249f, 0.04369208f, 0.00055805f, -0.11005627f, 
    0.20708573f, -0.25574005f, 0.09650008f, 0.05046041f, -0.01365026f, -0.10114440f, 0.07920595f, -0.21062316f, 
    0.07764558f, 0.15482204f, -0.03270714f, -0.03945985f, 0.18458219f, 0.17682852f, 0.29297382f, 0.00719921f, 
    -0.09889441f, 0.06511823f, -0.30570891f, 0.25961962f, -0.11520668f, 0.15493228f, 0.06186243f, 0.29379368f, 
    0.07943832f, 0.22364663f, 0.10663840f, 0.05687123f, 0.02571749f, -0.05979622f, -0.20965619f, -0.16872753f, 
    -0.05632916f, 0.01715680f, -0.19374895f, -0.02526065f, -0.06334913f, -0.08171328f, 0.26730433f, -0.18488301f, 
    -0.08680564f, 0.07814784f, -0.25013554f, -0.09039224f, -0.01088827f, 0.05642092f, 0.00781677f, -0.18841052f, 
    0.20062917f, 0.40880364f, 0.07928920f, 0.02525599f, -0.08185303f, 0.05271419f, 0.00682239f, 0.28559068f, 
    0.08850014f, 0.44027016f, 0.08628330f, 0.02169782f, -0.09922351f, -0.10197356f, 0.23775977f, 0.00085106f, 
    0.10824843f, 0.17157921f, 0.04736672f, -0.02912296f, 0.03725681f, -0.04861511f, 0.02552223f, 0.13844305f, 
    0.12702978f, 0.08731128f, -0.09564787f, 0.12416319f, -0.06411386f, -0.22735758f, -0.33020210f, 0.08221591f, 
    0.23466907f, 0.13533291f, 0.21230426f, -0.18017651f, -0.20888911f, -0.10740587f, -0.07504974f, -0.07821167f, 
    0.06992475f, 0.21238482f, -0.02640378f, 0.32326543f, 0.10344914f, -0.16713499f, 0.51618475f, 0.00482444f, 
    -0.08371655f, 0.02806821f, -0.08742664f, 0.33976558f, -0.03444723f, -0.00608298f, 0.10333264f, 0.30358449f, 
    -0.05660006f, -0.12095499f, 0.28949314f, 0.16635962f, 0.01346524f, -0.00533083f, -0.20344251f, 0.09479490f, 
    -0.24203023f, -0.37865868f, 0.11936401f, -0.05105667f, 0.12230933f, 0.21056102f, 0.02340222f, -0.06574452f, 
    0.13993758f, 0.12888262f, 0.02850874f, 0.12254416f, 0.06142871f, 0.08039618f, -0.26197970f, 0.05175185f, 
    -0.23658423f, 0.17520048f, -0.04770522f, -0.11360618f, 0.23756973f, 0.35740101f, -0.06930827f, 0.29973957f, 
    0.04920920f, 0.09000512f, 0.01531897f, -0.01634460f, -0.15918472f, 0.05859134f, 0.48303965f, -0.17380007f, 
    -0.06663387f, 0.20027813f, -0.36025992f, 0.22578682f, -0.22108118f, 0.04553084f, 0.07442111f, 0.31507400f, 
    -0.03375229f, 0.59698230f, 0.06908958f, 0.15464544f, 0.05086906f, -0.15989004f, 0.06934415f, -0.21893740f, 
    -0.06118232f, -0.26861203f, -0.11395073f, 0.11278464f, -0.08162978f, -0.11147097f, 0.07952178f, -0.13517237f, 
    0.06204760f, -0.04064887f, 0.21158129f, -0.11769563f, 0.18763465f, 0.07223515f, -0.06351947f, -0.08857089f, 
    0.15099421f, 0.42796004f, 0.11862421f, 0.06032357f, -0.28125426f, 0.13093202f, 0.10744552f, 0.06213113f, 
    0.17456481f, 0.00697240f, -0.11803171f, 0.20015235f, -0.03253643f, 0.04714543f, 0.27525419f, 0.02746761f, 
    -0.00964786f, 0.14016798f, -0.20771199f, 0.02006416f, 0.16363861f, 0.18613201f, -0.25432169f, 0.07152683f, 
    0.03224188f, 0.10446036f, -0.12352184f, -0.01985237f, 0.03655811f, 0.20226091f, 0.08959886f, 0.03901413f, 
    0.26718822f, 0.16890518f, -0.05485992f, -0.17352858f, 0.06757457f, 0.14975481f, -0.08421576f, 0.04201347f, 
    0.04055102f, -0.90996784f, 0.16035962f, 0.02308548f, 0.08887716f, -0.16130963f, -0.02622932f, -0.02127718f, 
    0.21668422f, -0.12862283f, 0.20486063f, 0.12483642f, -0.07736973f, 0.17571048f, 0.07150205f, -0.05736588f, 
    0.10651495f, 0.08346099f, -0.43018726f, -0.30953673f, 0.08383346f, 0.00876720f, -0.08014668f, 0.01583863f, 
    0.19255701f, -0.02011082f, -0.09109372f, 0.04340246f, 0.24556975f, 0.13320015f, 0.00442980f, -0.00737668f, 
    -0.15467283f, 0.42879272f, 0.11406664f, 0.02295962f, -0.02480944f, 0.10814199f, -0.08268362f, -0.13432881f, 
    0.30517402f, -0.09476496f, -0.17673284f, -0.00984305f, -0.29512125f, 0.00155700f, -0.05876736f, 0.10325545f, 
    0.32289565f, 0.12667972f, -0.06144916f, -0.10280668f, -0.07616492f, -0.16800083f, -0.16056776f, 0.05968092f, 
    0.26660293f, -0.02451395f, -0.38684118f, 0.07588697f, 0.21116318f, 0.09522776f, -0.30941963f, -0.13734208f, 
    0.13996510f, -0.08383383f, -0.11333343f, 0.13988528f, 0.02940353f, 0.11506854f, 0.08037267f, -0.09114460f, 
    -0.14719701f, 0.37322208f, -0.25931931f, 0.12214273f, 0.14908674f, -0.40939710f, 0.00601882f, 0.32542920f, 
    -0.09825811f, 0.02466513f, -0.26857674f, -0.17431088f, -0.19465913f, -0.07964274f, -0.24630977f, -0.00266460f, 
    -0.09830278f, 0.33214658f, -0.32895616f, -0.11180930f, 0.04637194f, -0.04209662f, 0.08634708f, 0.15016299f, 
    -0.03421615f, 0.07491761f, 0.00480834f, -0.06056178f, -0.02334148f, -0.05662020f, 0.01711553f, -0.00469725f, 
    0.15917310f, 0.07259764f, -0.14035314f, -0.03378074f, -0.09891367f, -0.02010680f, -0.11240698f, 0.08474226f, 
    -0.19090837f, -0.06641421f, -0.08975543f, -0.47049853f, -0.19963817f, 0.01363176f, -0.31070489f, -0.33039629f, 
    0.51584995f, 0.18622117f, 0.12638520f, -0.01674498f, -0.30525255f, -0.08088779f, -0.15800726f, -0.13905980f, 
    -0.07641341f, -0.54096252f, -0.10949424f, -0.09888660f, -0.04077278f, -0.27927393f, 0.02191028f, 0.05227824f, 
    0.14754994f, -0.21456115f, -0.16187866f, -0.74799001f, 0.03677310f, 0.16440862f, -0.10243525f, -0.16021800f, 
    0.06059997f, -0.10774380f, -0.10966779f, -0.08021633f, -0.12632480f, 0.00904192f, 0.03009340f, -0.39270362f, 
    -0.13510001f, -0.03303526f, 0.02706301f, 0.08278051f, -0.12489723f, -0.28515983f, 0.18632831f, -0.58623260f, 
    -0.10856412f, 0.08275663f, 0.07807642f, -0.02492297f, 0.10960603f, 0.02687164f, -0.34101665f, 0.04085132f, 
    -0.14758769f, -0.04405098f, 0.03251328f, -0.03672291f, -0.03976382f, -0.28009561f, -0.03083428f, -0.30640355f, 
    -0.00742567f, -0.07637575f, -0.08865717f, -0.04544405f, -0.25746503f, -0.00338436f, 0.32176355f, -0.31442514f, 
    0.01046454f, 0.23204765f, -0.24760962f, -0.09952024f, 0.00851659f, -0.03342308f, -0.12965815f, 0.23963003f, 
    0.07045663f, -0.14399633f, 0.00971455f, 0.20733738f, 0.09210182f, -0.14946453f, 0.19541329f, 0.07847238f, 
    -0.00221183f, -0.17601652f, -0.19422483f, 0.06469554f, -0.07122048f, 0.09984192f, 0.17890172f, -0.11982012f, 
    0.06644912f, 0.03288648f, -0.30801335f, -0.20958072f, 0.11382892f, 0.00434062f, -0.65097672f, -0.02551536f, 
    0.21188158f, 0.20931795f, 0.02146182f, 0.06046468f, -0.02758427f, 0.12781668f, 0.11943764f, 0.02917640f, 
    -0.27917942f, 0.32978070f, 0.09003141f, 0.07532295f, -0.08102722f, -0.03943525f, -0.04716928f, -0.04241802f, 
    0.11410878f, -0.09582984f, -0.42823175f, -0.05511389f, -0.08208132f, 0.29600245f, -0.31340471f, 0.25933105f, 
    -0.08142382f, 0.11732963f, 0.00593481f, 0.19324982f, 0.17451411f, 0.02767070f, 0.28462774f, -0.03612117f, 
    -0.05268222f, 0.06857083f, 0.23169734f, -0.32066032f, 0.30212140f, -0.13133062f, 0.02679046f, 0.07577921f, 
    0.09768451f, -0.21928272f, 0.01473296f, -0.05563041f, -0.00787089f, 0.22976553f, -0.00107517f, 0.03181223f, 
    0.00708258f, 0.03859799f, 0.10930134f, 0.04598653f, 0.07635495f, 0.19634084f, -0.14051720f, -0.03424991f, 
    -0.08016767f, 0.06833594f, -0.34848699f, -0.06551633f, 0.19336610f, 0.08319671f, -0.07345970f, 0.09080767f, 
    0.09749798f, -0.04832488f, -0.43165329f, 0.12169781f, 0.04833393f, -0.04620099f, 0.10570511f, -0.13657956f, 
    -0.00750613f, 0.21685274f, -0.05966454f, 0.20441371f, 0.05376719f, -0.06364261f, -0.01197375f, 0.02831365f, 
    -0.00695425f, 0.08363211f, -0.21930996f, 0.01778461f, -0.28330749f, 0.19349608f, 0.10031573f, 0.22661208f, 
    0.00436264f, 0.04659450f, 0.11103155f, 0.14907220f, -0.31912640f, -0.04826359f, -0.14337578f, 0.08984911f, 
    -0.14709221f, 0.15908968f, -0.13100217f, -0.24300094f, -0.02973122f, -0.05100881f, -0.02973582f, 0.17959802f, 
    -0.08857212f, -0.41549695f, 0.03044617f, -0.13738881f, 0.05091012f, 0.13019420f, -0.21899688f, 0.17464732f, 
    0.06946263f, -0.52131420f, -0.21053319f, -0.06321672f, -0.01711953f, 0.21654123f, -0.01671794f, -0.52900088f, 
    -0.06417464f, 0.09202166f, 0.33934733f, -0.56744426f, 0.35711563f, -0.06576756f, -0.00040942f, 0.25078520f, 
    0.16916491f, 0.12371808f, 0.01014862f, -0.04479669f, -0.01422827f, -0.26611945f, 0.22269498f, -0.24619871f, 
    -0.04422013f, 0.03574559f, 0.10153672f, -0.03193026f, 0.07651676f, -0.02951637f, 0.28339186f, 0.03568682f, 
    0.31560680f, 0.07437664f, -0.08571576f, -0.05267283f, 0.00045644f, 0.04732442f, 0.07318880f, -0.12841637f, 
    -0.10920139f, -0.12991054f, -0.07237245f, -0.06179135f, -0.15518929f, 0.02466765f, -0.08475198f, -0.13574204f, 
    -0.10787109f, 0.14519231f, -0.00812913f, -0.05717999f, -0.09342138f, -0.10773610f, -0.07428575f, -0.06278040f, 
    0.01544486f, -0.19681621f, -0.18862326f, 0.07505131f, 0.01442052f, -0.10612593f, 0.12885548f, 0.08230547f, 
    -0.09908776f, -0.07372213f, 0.00450838f, 0.06391207f, 0.05894281f, -0.07942053f, -0.04967324f, 0.08044477f, 
    -0.08487128f, -0.08370219f, 0.08135745f, -0.23036389f, -0.09604114f, 0.02228476f, 0.01324120f, -0.03904681f, 
    0.14996521f, -0.12528346f, -0.12131380f, 0.04408139f, -0.12710191f, -0.13791770f, -0.06769700f, -0.07678895f, 
    -0.15174866f, -0.00508121f, -0.01053418f, -0.05222633f, 0.08356804f, 0.10017887f, 0.00489831f, -0.09289660f, 
    0.04119279f, -0.17425884f, 0.05202479f, -0.09373370f, 0.03827132f, 0.08677467f, -0.00324235f, -0.05134701f, 
    0.23016497f, 0.23098378f, -0.01288293f, 0.10317199f, 0.08411314f, -0.00755340f, -0.08943043f, 0.13359204f, 
    0.12281919f, 0.14566356f, -0.22877236f, -0.02097887f, -0.06072252f, 0.01604866f, -0.17373846f, -0.02261166f, 
    0.03711108f, 0.44243813f, 0.04765762f, 0.27026412f, -0.06347371f, -0.14874995f, 0.48874179f, -0.17057033f, 
    -0.00805255f, 0.34860811f, -0.12972215f, 0.20579758f, 0.03771186f, -0.14855759f, -0.08114758f, 0.28523719f, 
    0.04051426f, 0.08861627f, 0.13036370f, -0.30035806f, 0.06862530f, -0.10485910f, -0.52150649f, -0.09400274f, 
    -0.17727280f, -0.09802467f, 0.07463552f, 0.03984624f, 0.03128656f, 0.24190971f, 0.03226312f, -0.06876871f, 
    0.08271463f, -0.00157949f, 0.12885471f, 0.14670891f, 0.10240109f, -0.02778327f, -0.06665660f, -0.08631772f, 
    -0.29802400f, 0.19752239f, -0.64935684f, 0.08495498f, 0.11141898f, 0.33465999f, -0.34442458f, 0.34563276f, 
    -0.10074254f, 0.16061044f, -0.01572037f, 0.16456939f, 0.03666858f, 0.00317647f, 0.25273636f, 0.23091045f, 
    -0.01430157f, -0.11846711f, -0.39659524f, 0.28144372f, 0.18243778f, 0.09882552f, -0.06095650f, 0.16475813f, 
    0.01555348f, 0.47663027f, 0.04686658f, -0.02239534f, 0.00814174f, 0.16626537f, -0.04975329f, -0.31351584f, 
    -0.70761049f, 0.11889640f, -0.08867007f, 0.10549566f, -0.08243068f, -0.59669036f, 0.04554480f, 0.11189133f, 
    -0.09907524f, -0.03546403f, 0.09814653f, 0.02491451f, -0.12742952f, 0.05060863f, 0.17868170f, 0.00965247f, 
    0.21294390f, 0.37331331f, 0.08922584f, -0.11853708f, -0.17491852f, -0.20278324f, -0.28887826f, 0.24516879f, 
    0.17924266f, 0.03498830f, 0.00754611f, -0.13986747f, -0.00040522f, -0.05461572f, 0.52543950f, -0.04703661f, 
    0.04037950f, 0.24803856f, 0.11141587f, -0.04884904f, -0.26089478f, -0.09092810f, -0.76568866f, 0.06356490f, 
    -0.09163529f, 0.13545857f, -0.02305407f, 0.31234854f, -0.18158382f, 0.26417986f, 0.29779568f, 0.18827866f, 
    0.00866835f, 0.14236134f, -0.25135535f, -0.17554964f, 0.30523637f, -0.08296747f, 0.21805966f, 0.19536591f, 
    -0.06449427f, -0.05490814f, -0.06822432f, -0.14430982f, -0.02080143f, 0.29926351f, -0.18133046f, 0.03976978f, 
    -0.16042820f, -0.30951256f, 0.24889134f, 0.29200345f, -0.10391950f, -0.05299411f, -0.10393430f, -0.15283687f, 
    0.11868057f, -0.01823174f, 0.39587682f, 0.09393491f, 0.24504203f, 0.09285955f, -0.18347520f, 0.33811009f, 
    0.16562027f, 0.02669053f, 0.18719392f, -0.01481748f, 0.16653478f, -0.02483561f, -0.09938302f, -0.12462918f, 
    0.01521530f, 0.05446389f, -0.01015582f, 0.23491642f, 0.10797729f, 0.04573056f, 0.29031083f, -0.03879812f, 
    -0.11107320f, 0.03603810f, -0.06927273f, -0.03371231f, -0.22696972f, 0.19451393f, -0.04140675f, 0.12993862f, 
    0.24159545f, 0.01207051f, 0.07984829f, 0.14118291f, -0.02169323f, -0.28668550f, -0.27562624f, 0.28159985f, 
    -0.07873091f, 0.19644293f, -0.25961763f, -0.42965659f, 0.37251601f, 0.06504357f, 0.13123532f, -0.10731006f, 
    -0.04920343f, -0.15276816f, -0.06295486f, 0.10476609f, -0.13477413f, 0.29434446f, 0.34872225f, 0.23355630f, 
    -0.15607285f, 0.19082624f, -0.32558051f, 0.20628615f, 0.11991762f, 0.02997971f, 0.10140211f, 0.14558518f, 
    -0.07826163f, 0.13891289f, 0.42866060f, 0.09100826f, 0.30060297f, -0.01632440f, -0.04061907f, 0.09892790f, 
    -0.17153801f, 0.14851055f, 0.01886115f, 0.08755283f, 0.08823749f, -0.35761669f, 0.06978769f, -0.21772434f, 
    -0.07250664f, -0.08943008f, 0.11460196f, 0.07556020f, -0.03746928f, -0.05562607f, 0.37534934f, 0.03999843f, 
    0.25458038f, -0.08043294f, -0.14228161f, -0.00715466f, -0.02303410f, 0.19765221f, 0.04086784f, 0.09573158f, 
    -0.04530751f, 0.06371626f, -0.04435100f, -0.03060742f, 0.03473358f, 0.06847239f, 0.04342959f, 0.07355668f, 
    -0.13129963f, 0.07203513f, -0.00879659f, -0.10719928f, -0.09140196f, -0.15397568f, -0.10440844f, -0.07327322f, 
    0.02407567f, -0.11055174f, 0.08849832f, 0.08951377f, 0.10424799f, -0.13769785f, 0.02453303f, -0.05293401f, 
    0.03204012f, -0.02640739f, 0.05280614f, -0.05536944f, -0.04688622f, 0.05121498f, 0.02605540f, -0.10594531f, 
    0.03549345f, -0.06454973f, 0.02790716f, -0.03496788f, -0.00625175f, -0.12034726f, -0.02659485f, -0.02737282f, 
    0.05802623f, 0.12640251f, -0.08666087f, -0.12127171f, 0.07118493f, 0.07215424f, -0.08022843f, 0.03229022f, 
    -0.13652548f, -0.10681852f, -0.03105445f, -0.10286433f, -0.03660467f, -0.01225533f, -0.02439991f, 0.11365613f, 
    -0.06809841f, -0.04550751f, 0.03580628f, -0.10792977f, -0.09251397f, -0.06208054f, -0.00988973f, -0.10085071f, 
    0.01505894f, -0.10040978f, 0.06327374f, 0.10293827f, -0.27705625f, 0.00616916f, -0.31477696f, -0.01340020f, 
    -0.03801497f, -0.57945490f, 0.45230663f, -0.64215946f, 0.15697795f, -0.48685077f, 0.19088136f, -0.09364569f, 
    -0.02463473f, 0.04733897f, 0.03963169f, -0.64555418f, -0.02719302f, 0.35164917f, -0.05186993f, 0.17621289f, 
    0.03064458f, -0.15248470f, -0.07395049f, 0.03547799f, 0.04561964f, -0.12200277f, -0.51647222f, -0.52186304f, 
    0.08923915f, 0.03532133f, 0.03569950f, -0.01150910f, 0.14426318f, -0.03279404f, -0.08197615f, -0.00282657f, 
    0.11056663f, -0.09430108f, 0.03315658f, -0.07173263f, 0.04146122f, -0.37021652f, 0.01566183f, -0.54821575f, 
    -0.03364206f, -0.57993704f, -0.06574970f, 0.02858655f, -0.03169872f, 0.04227085f, -0.06750737f, 0.11500965f, 
    -0.20335115f, -0.08155810f, -0.29548606f, -0.11305456f, -0.16781038f, 0.13855617f, -0.29145655f, -0.12321468f, 
    0.08532806f, 0.13026893f, 0.01256226f, 0.01680498f, -0.02314226f, 0.09472801f, 0.17979153f, 0.13857506f, 
    0.01013092f, 0.05094923f, -0.11007913f, 0.12637302f, -0.09922417f, 0.11167361f, -0.09319801f, 0.16248785f, 
    -0.10470325f, 0.72180665f, -0.04162500f, -0.02627605f, -0.06795885f, -0.01335919f, -0.07026897f, -0.09291282f, 
    0.02196736f, -0.04180432f, -0.19912921f, -0.08223572f, -0.09591512f, -0.07966661f, -0.10276676f, 0.03823828f, 
    -0.00871016f, -0.03574599f, 0.51586759f, 0.29923293f, 0.10258960f, 0.06379899f, -0.14095230f, -0.04578621f, 
    -0.06442719f, 0.39021069f, 0.14343145f, 0.05991471f, -0.12191399f, -0.15217857f, 0.04877522f, 0.17992629f, 
    0.19076455f, 0.11728270f, 0.09228040f, 0.13561723f, 0.11052147f, 0.00830618f, 0.27537760f, -0.07423951f, 
    0.00933152f, 0.28762674f, 0.05477518f, 0.03329427f, -0.16609433f, -0.24070026f, 0.06799632f, -0.10532259f, 
    0.12034312f, 0.04653816f, -0.10569720f, -0.10062301f, -0.06577483f, -0.11403757f, -0.11925212f, -0.12049656f, 
    -0.05924587f, -0.12903453f, -0.11277993f, -0.00581881f, -0.03641607f, -0.10210580f, -0.02493994f, -0.06375691f, 
    -0.11548354f, 0.08394661f, -0.03494174f, -0.09512119f, -0.04391271f, 0.07907035f, -0.07794995f, -0.13372795f, 
    0.08944838f, 0.01602149f, -0.00923987f, -0.11759160f, 0.08003613f, -0.00770893f, -0.07243070f, -0.03094335f, 
    -0.08199480f, 0.01133963f, 0.07057649f, -0.06094767f, -0.09277111f, 0.09080428f, 0.05689429f, -0.11284662f, 
    0.03980992f, 0.04292017f, -0.02435887f, -0.12183759f, -0.10798039f, 0.02893724f, 0.07364600f, 0.04798998f, 
    0.06848717f, -0.05545732f, 0.05407520f, -0.08539160f, -0.02059673f, 0.11586201f, -0.01821351f, 0.10612129f, 
    -0.11239900f, -0.07161891f, -0.06700384f, 0.05407968f, 0.03932410f, -0.04381301f, -0.00377706f, -0.11755246f, 
    0.06274281f, 0.03825226f, -0.08354051f, 0.12370048f, 0.07211859f, 0.13959090f, 0.05700463f, 0.16305500f, 
    -0.03588679f, -0.03675310f, -0.25204057f, 0.11222877f, -0.05459626f, 0.16904530f, -0.00809985f, 0.06595706f, 
    0.04434810f, -0.71123290f, 0.09666353f, 0.10284413f, -0.09645079f, -0.17071895f, -0.13307266f, 0.12270069f, 
    -0.20523888f, 0.40717581f, 0.16469891f, 0.14123017f, 0.12659556f, -0.07327954f, 0.02456833f, 0.03155269f, 
    -0.00416234f, -0.02806879f, -0.35184753f, -0.39272255f, -0.06527936f, -0.08649960f, -0.03926338f, -0.05943027f, 
    0.16982436f, 0.06435773f, -0.04300675f, 0.01709591f, 0.17594837f, 0.15102524f, -0.12683114f, 0.09122010f, 
    -0.11429954f, 0.02940844f, -0.04190340f, 0.00561164f, 0.06217919f, -0.06563819f, -0.02056750f, 0.04822581f, 
    0.12927234f, 0.11173787f, 0.01825678f, 0.09426601f, -0.07788831f, 0.02228874f, 0.12772346f, 0.06947951f, 
    -0.22090162f, 0.21411836f, 0.07825921f, 0.13403828f, 0.01573106f, 0.02652238f, -0.10347258f, 0.15687397f, 
    0.22861488f, 0.09948528f, -0.11359899f, -0.04191841f, 0.05728146f, -0.12778673f, 0.22593743f, -0.10553306f, 
    0.04614571f, 0.19945347f, 0.03374350f, -0.08484070f, -0.04305993f, 0.02828185f, 0.38583019f, -0.08374569f, 
    -0.08420944f, -0.26755130f, 0.12960498f, 0.06078380f, 0.03333920f, -0.03662876f, 0.03774428f, -0.05979587f, 
    0.03002259f, 0.12185968f, 0.61175710f, 0.60670805f, -0.06433660f, 0.10524090f, -0.02571761f, 0.20980251f, 
    -0.04502972f, -0.22976378f, 0.30254599f, 0.04288231f, -0.03048980f, 0.23280230f, 0.06000084f, -0.10263645f, 
    0.11695240f, -0.11431944f, -0.09784558f, 0.15029687f, 0.03307566f, 0.07032908f, 0.27380499f, -0.06866720f, 
    -0.11165310f, 0.27260262f, 0.06274009f, 0.05779379f, 0.10109223f, 0.19750501f, -0.00655274f, 0.03259426f, 
    0.23362237f, 0.27406991f, -0.03026442f, 0.19799027f, 0.03546413f, 0.14207795f, -0.02992253f, -0.05172591f, 
    -0.34239846f, -0.18143643f, 0.34481531f, -0.18057497f, 0.16585200f, -0.29638568f, 0.13668041f, 0.02160684f, 
    -0.11729395f, -0.08087018f, 0.17913274f, -0.06239494f, -0.12020768f, 0.15311554f, 0.24254817f, 0.08745516f, 
    0.22002523f, -0.15950356f, 0.22190824f, 0.05768596f, 0.04310905f, -0.22289747f, -0.29793945f, -0.07949150f, 
    0.09297207f, -0.02176864f, -0.30603817f, 0.26188752f, 0.01814645f, -0.04454184f, -0.72735316f, 0.15334608f, 
    0.16984758f, -0.45891756f, -0.07102388f, 0.09805410f, 0.36094385f, 0.51099604f, -0.03195579f, -0.17932858f, 
    0.20859097f, -0.06662737f, -0.07450417f, 0.09089699f, -0.06739824f, -0.03586285f, -0.44563797f, 0.08731588f, 
    -0.19482839f, 0.12086868f, -0.14636254f, -0.13452722f, 0.05696432f, 0.16177543f, -0.40670809f, 0.29628327f, 
    -0.10101335f, -0.08506814f, -0.11212645f, 0.04341451f, 0.06916287f, -0.00527523f, 0.07042569f, -0.13981760f, 
    -0.12140470f, -0.06454153f, 0.07218756f, -0.07614155f, -0.10480967f, 0.09160357f, -0.14835468f, 0.07182612f, 
    -0.11010499f, -0.10755506f, -0.12334153f, 0.03846374f, 0.03137317f, 0.01122746f, 0.05138141f, 0.03295608f, 
    0.00465217f, -0.09432792f, -0.12255313f, -0.11375152f, 0.08658081f, 0.00912431f, -0.14788811f, 0.07889915f, 
    0.06238736f, 0.04478641f, -0.09638663f, -0.12804607f, 0.07554673f, 0.03794043f, 0.06437379f, 0.05137056f, 
    -0.08885521f, -0.07725236f, -0.03898807f, 0.01431303f, 0.04638536f, -0.07110235f, -0.08110296f, -0.01657699f, 
    0.08079629f, 0.00089685f, 0.11127958f, -0.11971964f, -0.10217796f, -0.09782735f, -0.11527304f, -0.03711456f, 
    -0.13543718f, -0.00585075f, -0.05688693f, -0.07489268f, -0.15471624f, 0.10742311f, -0.12092646f, -0.10923690f, 
    0.10252945f, -0.01723309f, -0.06686755f, 0.02199578f, 0.02395619f, -0.13483098f, 0.10353600f, 0.12022848f, 
    0.06923660f, 0.08875736f, 0.10143499f, 0.09844784f, 0.04173249f, 0.06737772f, -0.27498397f, 0.09088080f, 
    0.10289702f, 0.28986350f, 0.00980606f, 0.26992595f, -0.05493226f, -0.12188314f, 0.13975868f, -0.02338992f, 
    -0.07410713f, 0.30013362f, -0.04571331f, -0.02104618f, 0.14193289f, -0.22927152f, 0.28088969f, 0.46924046f, 
    0.07222389f, 0.02894126f, -0.15517347f, -0.17780167f, -0.11964469f, -0.02354397f, -0.26622567f, -0.11237695f, 
    -0.15448369f, 0.03622088f, 0.07424312f, -0.02251853f, 0.07158615f, 0.15657967f, 0.12701939f, 0.19865018f, 
    0.12773816f, 0.16417785f, -0.10577723f, -0.10175340f, -0.05041096f, -0.08468693f, -0.18217680f, 0.02647103f, 
    0.01444110f, 0.10102986f, -0.49333856f, 0.12693228f, 0.10325474f, -0.01844307f, -0.33483967f, 0.08464724f, 
    -0.13016060f, 0.02722254f, 0.10854203f, 0.19449604f, -0.23644571f, 0.27205414f, 0.09629633f, -0.22627932f, 
    -0.27123171f, -0.01969788f, 0.06362816f, 0.19779183f, 0.23473354f, -0.11686461f, 0.11270701f, 0.13925113f, 
    0.05399184f, 0.10106841f, 0.04898497f, 0.09482512f, 0.09381934f, 0.23571073f, -0.27622586f, 0.01925824f, 
    -0.16503014f, -0.27272072f, 0.02353113f, 0.04854805f, 0.05849947f, 0.00336376f, 0.04468581f, -0.19759606f, 
    0.09213223f, 0.01269179f, -0.15487984f, -0.10311560f, 0.04320380f, -0.11110550f, -0.05595856f, 0.12836386f, 
    0.34167510f, 0.11923197f, 0.04382218f, 0.09536466f, -0.00485452f, -0.16132447f, -0.12824696f, 0.01292358f, 
    0.13847904f, 0.12690842f, -0.04367128f, -0.11452647f, 0.00198559f, 0.06726073f, 0.01453933f, 0.01084926f, 
    0.07415292f, 0.17174497f, -0.47450134f, -0.11531943f, -0.08884388f, 0.18535367f, -0.60042262f, 0.05712213f, 
    -0.08680108f, -0.53399682f, 0.07569425f, -0.34130448f, 0.13626370f, -0.04615077f, 0.24228798f, -0.02744047f, 
    0.03427764f, -0.07065946f, 0.37437406f, 0.33080998f, 0.07462408f, 0.15799323f, 0.05836397f, 0.07444753f, 
    -0.06749535f, -0.00268447f, 0.01695777f, 0.10285021f, -0.01261010f, -0.25947163f, -0.42316192f, 0.01242197f, 
    -0.14302328f, 0.09719422f, 0.17712280f, -0.56353271f, 0.07109844f, -0.08727053f, 0.12636320f, -0.04000513f, 
    -0.09198469f, -0.05239973f, -0.27027199f, 0.01580475f, 0.10705866f, 0.05105317f, 0.05402471f, -0.44446003f, 
    -0.05565808f, 0.09295117f, -0.02212021f, -0.11369215f, -0.51162678f, -0.23228821f, 0.13869467f, 0.15517959f, 
    0.01835580f, 0.07801683f, 0.03762819f, -0.08706132f, 0.08663063f, -0.07073836f, -0.13358659f, 0.11714379f, 
    -0.02401268f, -0.21924788f, 0.12323149f, -0.02913045f, 0.08726197f, -0.31820136f, 0.08239304f, -0.10491576f, 
    0.05210557f, 0.14104082f, 0.10167897f, 0.01683537f, 0.24586502f, 0.22860236f, 0.05588739f, 0.21492893f, 
    0.46488297f, -0.00138549f, 0.22492193f, 0.21980512f, -0.10577121f, 0.10978160f, -0.20772482f, -0.06383569f, 
    0.06646876f, -0.04686918f, -0.09563412f, 0.14351273f, -0.02803699f, -0.22794399f, 0.12841256f, -0.16506517f, 
    0.04300903f, 0.06011753f, 0.39336297f, 0.06827690f, -0.09980869f, -0.05304737f, -0.05794076f, 0.37857446f, 
    -0.09563668f, 0.08746928f, -0.50036359f, 0.00081809f, -0.31297505f, -0.02545020f, -0.00758179f, 0.03259822f, 
    0.04706383f, -0.12198553f, 0.01679849f, -0.12066498f, 0.37487897f, 0.29755569f, -0.02903650f, 0.33798310f, 
    0.12229575f, 0.02330719f, 0.08244012f, -0.02480683f, -0.02001923f, -0.12135848f, -0.13204940f, 0.02155765f, 
    -0.09650443f, 0.11101835f, -0.26382133f, -0.02847880f, -0.21087301f, -0.20581757f, 0.11266577f, -0.05411558f, 
    0.04581358f, -0.24130011f, 0.04684956f, -0.04728696f, -0.08670524f, -0.09510669f, -0.01911442f, -0.09541389f, 
    -0.03643708f, 0.04553879f, 0.02140662f, -0.06955665f, 0.09096710f, -0.05185319f, 0.02073365f, -0.04208995f, 
    -0.05184732f, -0.08719660f, -0.08220785f, -0.16923854f, 0.05969660f, -0.22086236f, 0.09858062f, 0.07097264f, 
    -0.08909275f, 0.06598619f, -0.14866640f, 0.02467107f, -0.08281524f, 0.00865986f, -0.09193212f, -0.06810361f, 
    0.08680265f, 0.01982372f, -0.01771256f, -0.06671795f, 0.04638930f, -0.10208133f, 0.02289592f, -0.10654986f, 
    0.07213689f, -0.20996863f, 0.07349648f, -0.08496839f, -0.14484070f, -0.01576050f, -0.16419508f, -0.10006256f, 
    0.08753946f, -0.20829654f, -0.00509472f, -0.15654734f, -0.07049535f, -0.04437594f, -0.00352024f, 0.10801852f, 
    -0.04941504f, 0.04741472f, 0.09776598f, 0.07960027f, 0.05206382f, -0.14110522f, -0.08007331f, -0.17510033f, 
    0.04774686f, 0.11748755f, 0.00672270f, 0.15868168f, 0.18856785f, -0.11630972f, -0.09914439f, 0.19332680f, 
    0.14859104f, 0.01696474f, 0.15617603f, -0.01236507f, -0.26053765f, 0.04457149f, -0.16432181f, -0.02559501f, 
    0.08074155f, 0.29462031f, -0.08087934f, 0.22435406f, -0.06741897f, -0.19706878f, 0.54362053f, -0.06825777f, 
    -0.00537940f, 0.13004962f, 0.20751609f, 0.17912173f, 0.12619677f, -0.01602435f, -0.02583965f, 0.38962898f, 
    0.04544868f, -0.12595576f, 0.31796619f, 0.11314945f, -0.03980476f, 0.02795891f, -0.09327623f, 0.15275727f, 
    -0.23968890f, -0.19230685f, 0.16397265f, -0.11341454f, 0.26735878f, 0.39498556f, 0.04439904f, -0.06454148f, 
    0.22894725f, -0.15004827f, -0.09210695f, 0.15014496f, -0.11334151f, -0.00267527f, -0.26500580f, -0.06431324f, 
    -0.09035386f, 0.06320418f, -0.03224145f, 0.00183323f, 0.29641393f, 0.13073432f, 0.14402299f, 0.01056931f, 
    -0.11669170f, 0.17188866f, 0.10124958f, 0.29985675f, -0.17385443f, -0.04606995f, 0.18182018f, 0.00961031f, 
    -0.10485742f, 0.08371756f, -0.32220197f, -0.28357929f, 0.23120633f, -0.04093031f, 0.24883376f, 0.22835918f, 
    -0.02891356f, -0.37379134f, 0.04420735f, -0.15679181f, 0.01180976f, 0.23307614f, -0.06482143f, 0.08307831f, 
    -0.10184283f, -0.26211622f, 0.18851782f, 0.22278354f, -0.11372778f, 0.28086573f, -0.19720341f, -0.25032744f, 
    -0.00110871f, 0.13199654f, 0.49609035f, -0.05767925f, 0.30612355f, 0.00812775f, 0.21727715f, 0.47682300f, 
    0.16937649f, -0.01655563f, 0.20833048f, -0.03005591f, 0.10827363f, 0.01215072f, 0.04245289f, -0.03052906f, 
    0.01757880f, 0.07662912f, -0.02650040f, 0.14352998f, 0.11444624f, 0.01455754f, 0.53022414f, -0.00542279f, 
    0.12224304f, -0.05178181f, -0.11389299f, -0.02539969f, 0.00348921f, 0.01448673f, 0.08695399f, -0.05236770f, 
    -0.20989801f, 0.07540343f, 0.08719652f, 0.10108123f, 0.07849666f, 0.30284682f, 0.43774423f, 0.12305839f, 
    -0.38519746f, -0.05184782f, -0.17221981f, 0.13162179f, 0.41551268f, 0.22433203f, -0.21964121f, 0.04618235f, 
    0.08602968f, 0.08518860f, -0.06971851f, -0.06727032f, -0.06172027f, 0.33876473f, -0.35020122f, -0.22710539f, 
    -0.43416655f, -0.13846993f, 0.01272269f, -0.02944925f, -0.16297863f, -0.16869333f, -0.01344256f, 0.00672441f, 
    0.08673339f, -0.05406741f, -0.42624560f, -0.19599447f, 0.05140110f, -0.11992764f, -0.24581835f, 0.12782207f, 
    0.27062377f, 0.58154255f, -0.00629925f, 0.01631886f, 0.05079426f, -0.10645324f, 0.05863206f, 0.22108451f, 
    0.14723054f, 0.25398812f, 0.09765699f, 0.02420240f, 0.10568278f, -0.07469267f, 0.41855046f, -0.01091191f, 
    0.05582632f, 0.17832306f, -0.02110327f, 0.02595227f, -0.19821537f, -0.10102504f, -0.28040448f, 0.11761087f, 
    -0.12257533f, 0.01695539f, -0.09852213f, -0.10394112f, -0.13879079f, 0.03055429f, 0.38579112f, -0.13432865f, 
    -0.22450684f, 0.26767957f, -0.23226067f, 0.19407748f, -0.25117877f, 0.18206538f, -0.04087800f, 0.08750763f, 
    0.07134771f, 0.21919122f, 0.10920336f, 0.10977212f, -0.08893099f, -0.19912209f, 0.09126486f, -0.03335602f, 
    0.13137028f, -0.21894538f, 0.15714616f, 0.13658589f, -0.05012350f, 0.20093542f, 0.08857428f, -0.17577678f, 
    -0.07059775f, 0.07915765f, 0.22138298f, 0.13824783f, 0.19369316f, 0.11416459f, -0.14675812f, -0.06060226f, 
    0.12648620f, 0.00383565f, -0.07333347f, -0.11993375f, -0.06077999f, 0.26249978f, 0.10777757f, 0.06245577f, 
    0.02962002f, 0.24729319f, -0.05521499f, 0.16919056f, -0.09692028f, -0.03558295f, 0.14508915f, 0.01974060f, 
    0.05313740f, -0.01673245f, 0.06089716f, 0.02137612f, -0.09296972f, -0.07527321f, 0.04016375f, 0.01474529f, 
    -0.07909013f, -0.50279850f, -0.01415160f, -0.05001544f, 0.19798410f, -0.10470337f, -0.08725587f, 0.40074506f, 
    0.06790230f, 0.32200509f, -0.40917414f, -0.15168007f, -0.18981540f, 0.22438678f, -0.17317176f, 0.03755677f, 
    0.12709479f, 0.27024150f, -0.08977260f, 0.32862863f, -0.05504855f, -0.19045526f, 0.01695487f, -0.20893326f, 
    -0.07553632f, 0.13046880f, 0.11098317f, 0.04744114f, 0.08169093f, 0.06760853f, 0.25565994f, 0.32164726f, 
    -0.02319664f, 0.09741078f, 0.53822261f, -0.01475848f, 0.27661046f, -0.08234809f, -0.30818656f, -0.17848985f, 
    -0.22119653f, 0.29169458f, -0.22354275f, 0.09360524f, -0.06519294f, -0.56959248f, 0.10577831f, 0.17910543f, 
    -0.33202073f, 0.21927412f, 0.07184426f, 0.22469179f, 0.08331266f, 0.01529634f, 0.04259344f, -0.01460813f, 
    0.12891458f, -0.32911134f, -0.12769036f, 0.01695689f, 0.11636297f, -0.31651938f, -0.05729977f, -0.23677607f, 
    -0.13787973f, -0.07567194f, -0.05043745f, 0.07414979f, 0.07022078f, -0.06458569f, 0.05461931f, -0.11876056f, 
    -0.08896271f, -0.04912352f, -0.04368776f, 0.09826271f, -0.03175092f, -0.00993877f, 0.07988160f, -0.03040721f, 
    0.03157252f, 0.09618966f, -0.10452527f, 0.00068994f, 0.05960669f, -0.09775013f, 0.00023452f, -0.02523494f, 
    0.03537865f, -0.12622468f, -0.04865244f, -0.06574805f, -0.08805566f, -0.07450648f, -0.03476625f, 0.07880655f, 
    -0.07053374f, -0.03477225f, -0.10526316f, -0.01015915f, -0.08921563f, 0.02842407f, -0.05517634f, -0.00978984f, 
    0.02654676f, -0.06761138f, -0.08523791f, 0.07683733f, 0.03477515f, -0.02738246f, 0.06764859f, -0.00377229f, 
    -0.02113262f, -0.07523859f, 0.09923360f, -0.11971569f, -0.00677176f, 0.00766592f, -0.08602314f, -0.11199731f, 
    0.04543630f, -0.04532549f, -0.04643079f, 0.10826756f, -0.01545304f, 0.09709290f, -0.06069869f, -0.14634180f, 
    0.20147802f, 0.06290256f, -0.10011736f, 0.06925659f, 0.08662529f, -0.05914428f, 0.03490579f, 0.19243726f, 
    0.21604922f, -0.16460764f, -0.23087975f, 0.30747902f, -0.05395150f, -0.09046338f, -0.13498783f, 0.10347871f, 
    0.01345790f, -0.15272260f, -0.08747291f, 0.17916431f, 0.09803613f, -0.16991760f, 0.21418367f, -0.29868296f, 
    -0.06082681f, 0.09056532f, 0.14352487f, 0.10394646f, 0.12903097f, -0.21563038f, -0.14615323f, 0.32332078f, 
    0.00619058f, 0.07976373f, -0.20607437f, -0.37395722f, -0.26534179f, 0.04284160f, -0.07838977f, -0.07406534f, 
    -0.00457804f, -0.20763282f, 0.07410756f, 0.03465861f, 0.02818506f, 0.22769798f, -0.22645970f, 0.17861368f, 
    0.04543495f, -0.28348449f, -0.08748230f, 0.11645504f, -0.11130945f, -0.11251573f, 0.17371705f, 0.02249040f, 
    0.02721673f, 0.29351157f, -0.23651168f, 0.03184068f, -0.10563570f, 0.16692057f, -0.16745664f, 0.20595495f, 
    0.29796535f, 0.00643297f, -0.00122295f, 0.05248221f, -0.03371537f, -0.11990435f, -0.26581648f, 0.17994706f, 
    0.16191311f, -0.12407514f, -0.00343198f, -0.05030842f, 0.17051373f, -0.00620889f, -0.18744443f, -0.18164714f, 
    0.12897229f, -0.30436137f, 0.04596918f, 0.15220052f, 0.03580336f, 0.23609994f, 0.19638953f, -0.09833325f, 
    -0.00984902f, 0.46917689f, -0.09222592f, 0.12561183f, -0.09330538f, -0.27460542f, -0.08735480f, 0.46746740f, 
    0.11598709f, 0.01826156f, -0.09530536f, -0.36431316f, -0.34252992f, -0.09620343f, -0.08063801f, 0.02297324f, 
    -0.06498885f, 0.09807193f, -0.02233382f, 0.08864266f, 0.23526458f, 0.09484250f, -0.21038778f, 0.06022164f, 
    0.01087193f, -0.21699516f, 0.02153135f, -0.00033590f, 0.01700516f, -0.11295418f, -0.22007182f, -0.05529032f, 
    -0.10778726f, 0.05377215f, -0.02664332f, 0.00937206f, -0.14641365f, -0.10594535f, -0.12599154f, 0.08367539f, 
    -0.31522772f, 0.13163422f, 0.03772280f, -0.37292734f, 0.03332001f, -0.19781078f, -0.19814824f, -0.04623131f, 
    0.27217257f, 0.20528772f, -0.16072957f, -0.26475164f, 0.40384686f, 0.03770258f, -0.26912540f, -0.12585181f, 
    -0.11487458f, 0.28378269f, -0.15906703f, 0.20064704f, -0.04209706f, 0.39725593f, 0.05619237f, -0.02640332f, 
    0.01867303f, 0.07182906f, -0.03464536f, 0.03895040f, -0.01377992f, -0.04450959f, 0.04543766f, 0.26307189f, 
    0.03460027f, 0.06021741f, -0.03151911f, 0.37565511f, 0.13946180f, 0.05685131f, -0.14344372f, -0.37979150f, 
    -0.07182910f, -0.04984478f, -0.14100136f, -0.01913022f, -0.10009781f, -0.17453778f, 0.13590056f, -0.03713883f, 
    -0.16109200f, 0.35266095f, 0.12259233f, 0.01658430f, -0.09638301f, 0.05849108f, -0.22895944f, -0.03883350f, 
    -0.46000499f, 0.04485137f, 0.01672399f, 0.09947312f, 0.06681685f, 0.18311785f, -0.10190628f, 0.08262242f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12783857f, -0.04467986f, -0.07187209f, 0.06099367f, 0.08084717f, 0.06406131f, -0.02472052f, 0.08296115f, 
    0.02484669f, -0.15570328f, 0.05624907f, 0.25029382f, 0.05354515f, -0.00811376f, -0.04397649f, 0.24450724f, 
    0.17847091f, -0.04298115f, 0.22572801f, 0.05071876f, -0.14494793f, 0.18413997f, 0.11436801f, 0.11135279f, 
    0.21977285f, 0.10694572f, 0.15034112f, 0.11505346f, 0.17334925f, 0.02991678f, 0.14371814f, 0.14693777f, 
    -0.06445314f, 0.24437848f, -0.01063603f, 0.30144018f, -0.18861468f, -0.09684706f, 0.09363826f, 0.12779728f, 
    0.12441905f, 0.06836101f, -0.12499360f, -0.05122971f, -0.08338325f, -0.10768141f, 0.10148340f, 0.10747003f, 
    0.15812461f, -0.10111332f, 0.23190176f, 0.02372157f, 0.03937091f, 0.12229281f, -0.07146445f, 0.04094255f, 
    0.12941648f, 0.18949272f, 0.10426664f, 0.36610490f, -0.06204100f, -0.09341662f, -0.11958098f, 0.02219735f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.04204081f, 0.07601641f, -0.12900224f, 0.01519445f, 0.19208877f, 0.14082125f, -0.31912866f, 0.12793562f, 
    0.12231448f, -0.24789114f, 0.02596292f, -0.29767522f, -0.27096260f, 0.12531470f, -0.05866614f, -0.57426709f, 
    0.01532195f, -0.09972743f, -0.11594805f, -0.16010553f, 0.00758310f, -0.01483799f, 0.05524484f, -0.32580093f, 
    -0.36508569f, 0.14160036f, 0.04689065f, 0.03765227f, -0.51123405f, -0.13301438f, -0.26162064f, -0.28591508f, 
    0.15728657f, -0.31355178f, -0.26500431f, 0.04939939f, 0.15627326f, -0.04768781f, -0.30594423f, -0.20675467f, 
    0.11205696f, 0.14793523f, -0.00820385f, 0.67304474f, -0.16407026f, -0.14800480f, -0.42928705f, 0.04883078f, 
    0.08975948f, -0.00781284f, -0.20359306f, 0.19467327f, 0.06346818f, -0.21786399f, 0.07878228f, -0.17719726f, 
    0.10617135f, 0.01489787f, -0.48815051f, -0.18658154f, 0.09558231f, -0.20261057f, -0.08026247f, -0.48802897f, 
    -0.07410415f, 0.13169280f, 0.08097736f, 0.11573865f, 0.26561463f, -0.25152519f, 0.00917693f, 0.03931161f, 
    0.27685851f, -0.42875800f, -0.15511960f, 0.03817099f, 0.04717832f, 0.18385512f, 0.02917995f, 0.15598497f, 
    -0.14344005f, -0.03243629f, 0.07971928f, 0.10856818f, 0.11963975f, 0.00631752f, -0.08685481f, -0.25881174f, 
    0.02780702f, 0.04968901f, 0.07658564f, -0.00218438f, -0.16561352f, 0.08632031f, -0.42129329f, 0.23465531f, 
    -0.45598659f, 0.16384193f, -0.35577685f, 0.07575548f, -0.72857940f, 0.01667239f, -0.04106529f, -0.55471104f, 
    0.01681950f, -0.06174405f, -0.08908074f, -0.37813887f, -0.21127601f, 0.01040800f, 0.02499199f, -0.00055107f, 
    0.39888313f, 0.09205149f, -0.03856297f, -0.12961809f, -0.05401347f, 0.34618759f, 0.03566636f, 0.21346720f, 
    -0.00836163f, -0.23253131f, 0.00996399f, 0.29097256f, -0.08898144f, 0.01811327f, -0.00712664f, 0.00816798f, 
    0.04250259f, -0.24798110f, -0.10852055f, 0.09997728f, -0.61120194f, -0.62246025f, -0.24366890f, 0.10516807f, 
    -0.05472106f, -0.05416736f, -0.24259388f, 0.03986165f, 0.01314032f, -0.58370858f, 0.09266667f, 0.04294959f, 
    -0.18920259f, 0.11231647f, 0.12821510f, 0.32162461f, 0.12110382f, 0.09601433f, -0.05735799f, 0.07451515f, 
    0.10776752f, -0.42097276f, 0.21050751f, 0.14406255f, 0.09826794f, -0.27355000f, 0.22632833f, -0.24819885f, 
    -0.11666421f, 0.06005621f, -0.11398271f, -0.16292572f, -0.77471364f, -0.00238691f, -0.07415430f, 0.33408353f, 
    -0.13903175f, -0.52608556f, -0.11397020f, -0.08574533f, 0.11125947f, 0.04681602f, 0.03152933f, 0.09023175f, 
    -0.44863737f, 0.00766173f, 0.03039962f, 0.20456378f, -0.21016033f, 0.24151766f, -0.05345725f, 0.00045032f, 
    -0.15754983f, 0.15994559f, 0.05270988f, -0.45185289f, -0.07833152f, 0.16793820f, -0.55935925f, -0.21424629f, 
    0.06240015f, -0.15104127f, -0.07633413f, -0.65332717f, 0.09208481f, -0.13533577f, -0.62954247f, -0.00811474f, 
    0.09426347f, 0.12827060f, 0.14277323f, -0.23168567f, -0.38543454f, -0.04183834f, -0.06856940f, -0.08950630f, 
    0.05412053f, 0.01543707f, 0.17255992f, -0.05713516f, 0.03981119f, -0.02794128f, -0.10915577f, 0.01380087f, 
    0.03085507f, 0.06762813f, -0.12840125f, -0.26560897f, -0.07747556f, 0.02763740f, 0.06103596f, -0.68466979f, 
    -0.07337109f, -0.73547608f, -0.19773829f, -0.05162713f, -0.13484502f, -0.21767858f, 0.10059592f, 0.13131407f, 
    0.14866723f, 0.07785427f, 0.08316326f, -0.13356292f, 0.19834180f, -0.08759694f, -0.26195708f, 0.21637437f, 
    0.09043512f, 0.06412642f, -0.17095377f, -0.04273263f, -1.21537483f, -0.28512463f, -0.05968121f, 0.14013982f, 
    0.11482848f, 0.11082999f, 0.07469329f, -0.46319538f, 0.03747546f, 0.03660551f, -0.21260716f, -0.26824746f, 
    0.09125892f, 0.13875313f, -0.14084354f, 0.01851504f, -0.19072890f, 0.11858771f, 0.07119263f, -0.05002935f, 
    -0.14376777f, -0.02636459f, -0.00407115f, 0.01890753f, -0.38184679f, -0.39181855f, 0.02543405f, -0.15012875f, 
    0.09683017f, -0.08788128f, -0.32688400f, 0.02442901f, 0.02556368f, -0.34316203f, 0.03661359f, 0.13659698f, 
    -0.55718279f, 0.19279100f, 0.07814920f, -0.04846078f, -0.05178478f, -0.18836118f, -0.07465825f, 0.31288776f, 
    -0.10340194f, 0.13657731f, 0.21494660f, -0.04268816f, 0.18915626f, -0.04189070f, -0.19526036f, -0.04674632f, 
    0.18070590f, 0.10324929f, -0.03811890f, -0.57519954f, -0.07424484f, -0.02669575f, 0.19013156f, 0.05892237f, 
    -0.00200909f, -0.08414124f, -0.58657384f, 0.13359195f, -0.14905494f, -0.65523785f, 0.00925167f, -0.20055450f, 
    0.13786051f, 0.07706828f, 0.09373441f, -0.92512232f, -0.13783795f, 0.01506712f, -0.33118379f, 0.03288116f, 
    -0.00267875f, 0.16944247f, -0.15120593f, 0.30293867f, 0.07871889f, 0.14145960f, -0.25359064f, -0.12451174f, 
    0.01664466f, 0.09750305f, -0.04970219f, 0.10835597f, 0.10507365f, 0.21411127f, -0.01106494f, -0.02247894f, 
    -0.11990495f, 0.11613433f, -0.51838577f, 0.18669239f, -0.01121892f, -0.19546117f, -0.06354183f, 0.12350745f, 
    -0.05220918f, 0.14372613f, -0.12800743f, -0.14975660f, -0.06104844f, -0.09083473f, -0.18022785f, 0.16787244f, 
    0.38952187f, -0.75638908f, 0.03849328f, 0.16905767f, -0.10394821f, 0.01316047f, 0.07681371f, 0.05708948f, 
    -0.00707327f, 0.13921748f, -0.02943309f, 0.04435471f, -0.12656474f, -0.07345252f, 0.11761848f, -0.15142520f, 
    0.05893914f, 0.05145960f, 0.06715132f, -0.17068495f, -0.04624348f, 0.04569602f, -0.00102163f, -0.00114591f, 
    0.02963597f, 0.22231719f, -0.12935929f, -0.15899092f, -0.08093419f, 0.10039663f, 0.29375386f, 0.04987316f, 
    0.08271025f, -0.14301246f, 0.03870091f, -0.19118372f, -0.00302006f, -0.06774129f, 0.17749543f, -0.44111583f, 
    -0.30224130f, 0.13209604f, -0.27628776f, 0.13939250f, 0.19146086f, -0.38097680f, 0.05634109f, 0.09399290f, 
    -0.28565508f, 0.01180662f, 0.22296895f, -0.87951183f, -0.01968041f, 0.22559334f, 0.05329385f, 0.27665815f, 
    0.21927765f, -0.68557221f, -0.32045472f, 0.09241126f, 0.11096486f, -0.52943021f, 0.04910590f, 0.13817561f, 
    -0.08488340f, 0.30349872f, 0.06088169f, -0.73982722f, -0.18062162f, -0.21734466f, -0.45773041f, 0.12559420f, 
    -0.66483200f, -0.32148895f, -0.10971963f, 0.05335327f, 0.01591015f, -0.00994506f, 0.03339901f, -0.56957370f, 
    -0.24642164f, 0.04046134f, 0.14268743f, -0.54618210f, 0.27049044f, 0.24301866f, -0.15650027f, -0.28617397f, 
    -0.59176636f, 0.17503682f, 0.06062100f, 0.23146167f, -0.09742773f, -0.20435332f, -0.37856692f, -0.14200509f, 
    -0.04116062f, -0.29189688f, -0.11930122f, 0.03881773f, -0.10318181f, 0.15028411f, 0.15232167f, -0.29674727f, 
    0.17423831f, 0.26509729f, 0.18301092f, -0.71135336f, -0.46021521f, 0.13981050f, -0.11444572f, 0.12831411f, 
    -0.16041283f, -0.02831058f, -0.12766060f, -0.57606709f, -0.12924233f, -0.16542131f, 0.01063541f, -0.30075148f, 
    -0.02661366f, -0.36361268f, -0.32173398f, -0.11073795f, -0.03594159f, -0.02176894f, 0.21165200f, -0.11447486f, 
    -0.35919544f, -0.10545830f, -0.31136680f, -0.71176571f, 0.10044107f, -0.00275689f, -0.09294878f, -0.18987697f, 
    -0.01688664f, 0.19032295f, 0.06448335f, -0.05474834f, 0.18263322f, -0.01478227f, -0.26987123f, 0.00054090f, 
    -0.14977275f, -0.00389575f, -0.04175065f, -0.49910787f, -0.24690685f, -0.38540098f, -0.12438434f, 0.18976429f, 
    0.04628279f, -0.52273142f, 0.16265304f, 0.15645531f, 0.03008125f, -0.33181533f, 0.07136305f, -0.31992227f, 
    -0.04506929f, 0.03873089f, -0.03707055f, -0.16360201f, -0.26893386f, 0.08143004f, 0.02068565f, -0.25310802f, 
    0.08753119f, 0.23089926f, 0.05338087f, -0.30658412f, 0.22488818f, 0.09122203f, 0.02776056f, -0.00950643f, 
    -0.06388104f, 0.02866363f, -0.32832041f, 0.16552792f, 0.01903834f, 0.00475430f, 0.04777196f, 0.16506398f, 
    0.17810896f, -0.61365747f, 0.18014386f, 0.00240667f, -0.00705331f, 0.19738807f, -0.40478361f, -0.14248571f, 
    0.48508483f, -0.49846986f, -0.27331626f, -0.34497747f, 0.17714782f, -0.02075339f, 0.22277820f, 0.03842647f, 
    -0.69669920f, 0.17397702f, 0.04094127f, -0.08505797f, 0.03952863f, 0.06088904f, 0.10946231f, 0.02944256f, 
    -0.20468053f, 0.05678594f, 0.19627699f, -0.52757812f, -0.12216856f, 0.12251971f, -0.03663962f, 0.16964522f, 
    -0.48912671f, -0.52727097f, -0.08401474f, -0.05006653f, -0.06328819f, 0.22156191f, 0.32375824f, 0.26678970f, 
    -0.06831910f, -0.11940299f, -0.09623684f, -0.25215563f, -0.49884224f, 0.19315252f, -0.08532780f, -0.18217291f, 
    -0.53388470f, -0.10774241f, -0.03424372f, 0.18926898f, 0.11874199f, -0.32821658f, -0.04167906f, -0.24615195f, 
    0.12247967f, 0.12415706f, 0.07866782f, -0.36921468f, -0.13851115f, 0.12833059f, 0.02997819f, 0.22667539f, 
    -0.13874856f, -0.13477306f, 0.14676115f, 0.18304086f, 0.18549845f, -0.62816203f, 0.10616500f, 0.24462174f, 
    0.05633972f, -0.75659704f, 0.26854339f, 0.13232464f, -0.19033781f, -0.21170624f, -0.34652558f, -0.01271423f, 
    0.06641807f, -0.12700263f, -0.11287822f, -0.09428103f, 0.13516277f, -0.10347796f, 0.01865081f, -0.33920231f, 
    -0.34193560f, -0.05184900f, -0.02070420f, 0.31150943f, -0.02233438f, -0.16255964f, -0.13934423f, -0.45717406f, 
    -0.06249427f, 0.13721046f, 0.08295116f, -0.07584582f, 0.09464329f, -0.22617859f, -0.22171511f, -0.04986429f, 
    -0.11169621f, -0.01413984f, -0.03772809f, -0.49025449f, -0.42766112f, 0.32466397f, -0.49694517f, 0.20418985f, 
    -0.20978947f, 0.11235556f, 0.34703434f, 0.21836416f, -0.07236680f, -0.42359707f, -0.07728956f, 0.16426392f, 
    0.28607237f, 0.08454125f, -0.62619686f, 0.05000601f, -0.05063107f, -0.16781577f, -0.09971707f, -0.34541947f, 
    0.19534825f, -0.47895092f, -0.03044466f, -0.04557788f, -0.04027289f, 0.26946241f, 0.20914593f, 0.03197880f, 
    0.02140908f, -0.69650960f, 0.36120602f, -0.00752184f, -0.22474253f, 0.01217821f, 0.22671278f, -0.51645994f, 
    -0.16834979f, 0.05319152f, -0.00248743f, -0.52979529f, -0.43038696f, -0.01287515f, -0.03714515f, 0.05349736f, 
    0.13651608f, -0.07612949f, 0.11720505f, -0.42607448f, -0.60243469f, -0.06076242f, -0.14741485f, 0.16591430f, 
    -0.11210055f, -0.61737514f, 0.09378571f, -0.66521078f, -0.12113112f, 0.17818132f, -0.00002642f, -0.45331267f, 
    0.10114256f, -0.53542584f, 0.04362453f, -0.18383141f, -0.29274839f, -0.17905775f, 0.17022461f, 0.19334903f, 
    -0.27447602f, 0.05383879f, -0.19516338f, 0.38982901f, -0.18861836f, -0.01129621f, -0.02037618f, -0.24182746f, 
    -0.25331494f, -0.04102140f, 0.04440353f, 0.14896257f, -0.05793723f, 0.11787070f, 0.03613197f, -0.00899889f, 
    0.04932873f, -0.25316843f, -0.55161721f, -0.46127674f, 0.02941028f, 0.15713307f, -0.00326761f, -0.06940682f, 
    0.14394529f, -0.75032932f, 0.24082014f, -0.10500799f, -1.07732987f, -0.12152813f, 0.39901140f, -0.07453295f, 
    -0.20488612f, -0.05189488f, -0.11357450f, -0.09806146f, 0.05448105f, -0.10622364f, -0.18546355f, -0.15249945f, 
    -0.57176721f, -0.11933570f, 0.23045996f, -0.06484585f, -0.12984331f, -0.06112714f, -0.24295270f, 0.07626762f, 
    -0.37013716f, -0.09802732f, 0.12069043f, 0.19168133f, -0.09534242f, -0.16649517f, -0.43557861f, 0.38703838f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.16719164f, 0.14072117f, 0.11095233f, 0.07588267f, 0.00699093f, -0.12785049f, -0.10074333f, -0.17280395f, 
    -0.00460512f, 0.05165813f, 0.21649466f, -0.02448991f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
