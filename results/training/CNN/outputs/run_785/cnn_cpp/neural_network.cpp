#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.33304751f, -0.23605430f, 0.39570022f, 0.92235613f, 0.17617328f, 0.48229447f, 0.58767074f, 0.45352402f, 
    0.36721650f, 0.08160646f, -0.54434037f, -0.21260905f, -0.13130225f, 0.23167826f, -0.26998565f, -0.05460819f, 
    -0.01977512f, 0.00728115f, 0.06023373f, -0.06146218f, -0.21304823f, -0.12218028f, -0.33334821f, -0.27124876f, 
    -0.10433232f, -0.06920780f, -0.38468423f, -0.53060603f, -0.59082925f, -0.67276120f, 0.10638332f, 0.40700319f, 
    0.26188269f, -0.14119142f, 0.44413382f, 0.19336653f, -0.02092323f, -0.20312886f, -0.14064729f, -0.32058904f, 
    0.15395679f, -0.01403624f, -0.01220269f, 0.13485797f, 0.19707724f, 0.05479068f, 0.20174317f, 0.11503509f, 
    -0.12213557f, 0.45719191f, -0.23793036f, -0.23415533f, 0.00755246f, 0.63340253f, 0.03921804f, -0.01870842f, 
    0.78847426f, 0.49125215f, 0.57161200f, 0.52114135f, 0.37048489f, -0.04635440f, -0.33145058f, -0.19512172f, 
    -0.26649776f, -0.03468034f, -0.06978714f, -0.21661440f, 0.19746852f, -0.19911066f, 0.14105241f, 0.31667110f, 
    -0.01324945f, 0.28636178f, -0.16432925f, -0.63438976f, -0.47518796f, -0.67385197f, -0.01768778f, -0.41494066f, 
    0.22289446f, 0.71850616f, 0.07437718f, 0.14769335f, -0.20658767f, -0.25761560f, 0.35311013f, 0.30356240f, 
    0.39530376f, 0.32098958f, -0.33058691f, -0.32797694f, 0.02378490f, 0.02349161f, -0.13063161f, 0.11733759f, 
    0.09381901f, 0.28733048f, -0.08724829f, 0.15664154f, 0.82325298f, 0.95944917f, 0.36358333f, -0.12417969f, 
    -0.45238930f, -0.26021594f, -0.07206080f, 0.15583892f, -0.09984603f, 0.28568465f, 0.07810076f, 0.12620020f, 
    -0.14614020f, 0.26588503f, -0.04863849f, 0.09164292f, -0.12350298f, 0.08991287f, -0.06376660f, 0.13079189f, 
    -0.56114537f, 0.40049127f, -0.14912073f, -0.14761280f, -0.20682187f, -0.10841012f, 0.38199013f, 0.37778908f, 
    -1.01463211f, -0.74292326f, 0.41964355f, -0.19890076f, -0.41330194f, -0.66793770f, -0.39046645f, 0.08327988f, 
    0.34182829f, -0.30602759f, 0.20919086f, 0.14072073f, -0.00341416f, 0.08966119f, -0.06993911f, -0.03856951f, 
    0.13110489f, -0.04786393f, -0.10422395f, 0.08351912f, -0.02985587f, 0.12795603f, -0.21864131f, -0.55115193f, 
    -0.32302523f, 0.11583391f, -0.15111682f, 0.38549352f, -0.17375408f, 0.09159422f, -0.51809764f, -0.33573869f, 
    -0.10218596f, 0.00072771f, 0.28308687f, -0.35468805f, -0.23368795f, -0.49626577f, 0.00535936f, 0.21794100f, 
    -0.23999760f, -0.67644620f, 0.07309016f, -0.22074719f, 0.02179946f, 0.36518428f, 0.25825951f, -1.13383973f, 
    0.63277596f, 0.44410896f, -0.51048195f, 0.42541182f, -0.39974523f, 0.45975775f, 0.30472538f, -0.38704473f, 
    -0.57520860f, -0.10595153f, 0.08722042f, 0.16891375f, -0.12338416f, -0.31496710f, -0.08074117f, -0.23602004f, 
    -0.08736198f, -0.09355371f, -0.15253301f, -0.12346587f, 0.10327624f, 0.06692953f, 0.11939676f, 0.06626032f, 
    0.71248484f, 0.42018580f, 0.11681096f, 0.88416719f, 0.62050200f, -0.43223500f, 0.18637215f, -0.58466357f, 
    -0.43674549f, 0.34327823f, 0.38418284f, 0.26298490f, 0.08037488f, -0.01613587f, 0.02432900f, 0.07301244f, 
    0.07115956f, 0.36613193f, 0.05023174f, 0.21137339f, -0.03896841f, -0.14203872f, 0.16962168f, 0.00107664f, 
    -0.00062156f, 0.80928200f, -0.24205835f, -0.19426322f, -0.45042571f, -0.03726863f, 0.69946367f, -0.11096136f, 
    -0.27792275f, -0.16792949f, 0.23625985f, 0.23725905f, 0.49273989f, 0.20981258f, -0.08635578f, 0.33731681f, 
    -0.19825478f, 0.00282254f, 0.09144434f, -0.13122116f, -0.30390650f, 0.25678608f, 0.37225801f, 0.02381198f, 
    -0.02179836f, 0.07879421f, -0.38438407f, -0.74472988f, -0.68307108f, -0.50427508f, 0.10415696f, -0.21218455f, 
    0.79862869f, 0.38460532f, -0.25772211f, 0.17136544f, -0.08605152f, -0.18412577f, -0.31237432f, -0.36067048f, 
    -0.09035576f, -0.05848454f, 0.16397181f, 0.00631019f, -0.02133088f, -0.22829503f, -0.23206753f, -0.17111185f, 
    0.18036982f, -0.17641480f, -0.04442452f, 0.49044552f, -0.14115153f, 0.79028273f, 0.70665675f, 0.57712138f, 
    0.30198288f, -0.34830832f, 0.22896354f, -0.12743939f, -0.21883401f, 0.27596489f, -0.26203388f, -0.40839571f, 
    -0.01824074f, -0.30263546f, 0.20652488f, 0.09735284f, 0.03837806f, 0.01611927f, -0.17751172f, 0.16247381f, 
    -0.00829246f, 0.09816062f, 0.19255956f, 0.19874039f, -0.51533610f, -0.45226312f, -0.53156680f, -0.59046650f, 
    -0.50354403f, -0.54441696f, -0.02226366f, 0.27127632f, -0.12555327f, 0.14889938f, -0.17956635f, 0.23365130f, 
    -0.10543225f, 0.25257266f, 0.34299624f, 0.22260338f, 0.28287560f, 0.33512086f, -0.00476186f, -0.26800126f, 
    0.11043449f, -0.14812498f, -0.27851471f, 0.13382632f, 0.05139784f, 0.24827106f, 0.89519697f, -0.52860332f, 
    0.18594302f, -0.39840114f, 0.61821282f, -0.54434448f, -0.57267517f, -0.11812475f, -0.35198575f, 0.26838723f, 
    -0.01790852f, 0.52223605f, 0.27074829f, -0.19681108f, 0.00156981f, -0.04169523f, 0.04603227f, -0.00074024f, 
    0.06247016f, 0.01400253f, -0.04159641f, 0.23414804f, 0.09263804f, -0.12152656f, 0.58605790f, 0.89776915f, 
    0.30379799f, -0.24785943f, -0.17308177f, -0.71797758f, -0.34188685f, -0.33129025f, -0.34540582f, -0.22330876f, 
    -0.21718076f, 0.04909634f, 0.05048052f, -0.06712458f, 0.09177250f, -0.29664224f, -0.06302807f, -0.09731410f, 
    -0.19392835f, 0.01548717f, 0.36649621f, 0.22292675f, 0.02215357f, 0.22428766f, 0.17535503f, -0.26032323f, 
    -1.03321362f, 0.28653568f, 0.30896112f, 0.12813027f, 0.08621560f, 0.69827169f, -0.19015890f, -0.39036959f, 
    0.23403919f, -0.14900231f, -0.10264605f, -0.46001169f, -0.10620764f, -0.27307644f, -0.11623255f, -0.15916783f, 
    -0.26253498f, -0.29960096f, -0.32894513f, -0.07966042f, -0.02801768f, -0.04777100f, -0.12625390f, -0.10369597f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08644436f, -0.01039325f, 0.02871650f, 0.25591782f, 0.11650062f, 0.44655135f, 0.22828242f, 0.18222643f, 
    0.06234901f, 0.04192621f, 0.05595252f, 0.25642323f, 0.22906999f, 0.05804487f, 0.13701311f, -0.06685060f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.15316433f, -0.17235877f, 0.17619240f, -0.09075767f, -0.05644689f, 0.05808991f, -0.07558071f, 0.10935667f, 
    -0.17811799f, -0.01249262f, 0.02701078f, 0.02621239f, -0.15734284f, 0.14471063f, -0.21355088f, 0.17156990f, 
    -0.15786058f, 0.09929507f, -0.02002041f, -0.12639192f, 0.17847794f, 0.06775957f, 0.22267972f, -0.15119450f, 
    0.13923587f, -0.36527246f, 0.07601513f, 0.14987253f, 0.05297220f, -0.04752212f, -0.00310825f, -0.09260446f, 
    -0.03968405f, 0.06141269f, 0.02785084f, 0.08557574f, 0.11499212f, -0.11459237f, 0.19573539f, 0.19056794f, 
    -0.11260975f, 0.14294100f, 0.07314663f, -0.00122218f, -0.03734240f, 0.09787697f, -0.01317789f, 0.06045074f, 
    -0.34852934f, 0.00859882f, 0.19326667f, 0.11733065f, 0.17259121f, 0.06439003f, 0.10605589f, -0.20150538f, 
    0.12450519f, 0.06764443f, -0.04577439f, 0.03718847f, 0.21238819f, -0.16177392f, -0.22058125f, 0.11012670f, 
    0.06508750f, 0.15185082f, 0.04543803f, -0.00572221f, 0.00841962f, -0.01765230f, 0.12256658f, -0.01403970f, 
    0.02573128f, 0.07598190f, -0.02759730f, -0.05367407f, -0.07756681f, 0.04750428f, 0.04557474f, 0.03489617f, 
    0.14960644f, -0.11107893f, 0.08715530f, -0.02188770f, 0.18730161f, -0.11548009f, -0.20531085f, -0.15072799f, 
    -0.07557181f, 0.05285949f, 0.12212402f, -0.03354843f, -0.05645746f, -0.01734442f, -0.03577186f, 0.04315357f, 
    -0.09597762f, 0.32855329f, -0.12253954f, -0.26168126f, 0.11940993f, -0.01908891f, -0.05709029f, 0.06963382f, 
    0.04784418f, 0.04507758f, -0.03569121f, 0.03669604f, -0.09011283f, 0.16138977f, -0.30919591f, 0.16489121f, 
    0.09505051f, -0.01228135f, 0.02488854f, 0.07539084f, 0.14166294f, 0.02791596f, -0.02330931f, 0.02889263f, 
    -0.03531609f, -0.29831085f, -0.13381548f, 0.00491637f, -0.11978307f, -0.15053183f, 0.01833777f, 0.04713147f, 
    0.07147612f, -0.02962861f, 0.08429098f, -0.09335733f, 0.13306004f, 0.26885262f, 0.23466168f, -0.33309734f, 
    0.18199773f, 0.04341551f, 0.01411320f, 0.10035615f, -0.00770146f, 0.02645269f, -0.01165624f, 0.05322134f, 
    0.02061919f, -0.02197449f, -0.07349262f, 0.00940598f, -0.01202622f, 0.08635368f, 0.11378763f, -0.02098143f, 
    -0.07657050f, -0.06058459f, 0.19675817f, -0.04479950f, -0.24759588f, -0.13985349f, 0.05525409f, 0.08699853f, 
    0.03354242f, 0.09365075f, 0.03273899f, -0.02721314f, 0.06626780f, 0.05277373f, 0.09751281f, 0.09041976f, 
    -0.28347948f, -0.18436602f, 0.15818730f, 0.17177294f, -0.00943692f, 0.02365375f, 0.09260153f, 0.14759319f, 
    -0.00879418f, 0.08652525f, 0.06168166f, 0.00954174f, 0.25445461f, -0.29156807f, -0.10950337f, -0.03627044f, 
    0.09055761f, 0.03272106f, -0.09067725f, -0.07243185f, 0.08792359f, -0.00517871f, -0.01453744f, 0.09937685f, 
    -0.05735265f, 0.13695140f, -0.16854866f, 0.08483831f, -0.08492987f, -0.01838127f, 0.21027999f, 0.08593991f, 
    0.05134515f, 0.05163547f, 0.04498643f, 0.22195989f, -0.02304364f, 0.00739920f, 0.10427660f, 0.15331025f, 
    0.04532364f, 0.02814756f, 0.03907427f, 0.17170173f, -0.17321917f, 0.06788145f, -0.01573318f, -0.02321981f, 
    -0.28819647f, 0.26176828f, -0.12186477f, -0.07272057f, 0.03204856f, 0.04279633f, -0.06457087f, 0.04787375f, 
    0.07290397f, 0.01267314f, 0.03192641f, -0.14996718f, -0.09079720f, 0.15749183f, -0.01625984f, 0.00431195f, 
    0.11871284f, 0.06941046f, -0.05680499f, 0.11055291f, 0.02441708f, 0.04253928f, -0.08175617f, 0.13271110f, 
    0.15312992f, -0.23916316f, 0.01300650f, 0.05800302f, -0.16306788f, 0.15049511f, -0.00329801f, 0.08481595f, 
    0.09495561f, -0.01510973f, -0.05609415f, 0.06847844f, 0.34304985f, 0.08167689f, 0.24812858f, 0.07780913f, 
    -0.09375902f, 0.02943601f, 0.04915583f, 0.02280862f, 0.01596259f, 0.03202594f, 0.02148694f, 0.05151313f, 
    0.09819140f, 0.03611821f, 0.12674955f, -0.10718326f, 0.05247112f, -0.14688089f, 0.18867272f, -0.06141997f, 
    -0.08452132f, 0.02507023f, -0.05817975f, 0.17190771f, -0.00608494f, 0.19769897f, 0.35249817f, -0.05577010f, 
    0.06514026f, -0.12741651f, -0.03195208f, 0.04152356f, -0.02001005f, 0.00984305f, 0.09608505f, -0.03981213f, 
    -0.33562812f, -0.15396856f, 0.01428190f, 0.20040661f, -0.17740093f, -0.01867921f, 0.03541427f, 0.06098394f, 
    0.06657816f, 0.05774842f, -0.11530268f, -0.04931293f, -0.14658920f, 0.03945642f, -0.06189631f, -0.01885486f, 
    0.07401624f, 0.09134722f, -0.11515068f, -0.07053749f, -0.08251920f, -0.03914846f, -0.08365350f, -0.04162276f, 
    -0.20360939f, 0.07784730f, 0.11818004f, 0.14932622f, 0.10242870f, 0.01289626f, 0.07684044f, 0.02472572f, 
    -0.04672306f, 0.04506231f, 0.16216826f, 0.05055620f, 0.19727652f, -0.15846503f, -0.08301007f, -0.04503309f, 
    -0.02174255f, -0.12086549f, 0.00342287f, -0.00371818f, -0.01922745f, -0.02118395f, 0.04931263f, -0.13623567f, 
    0.23162155f, 0.13949300f, 0.18442720f, -0.00176200f, 0.08175194f, -0.08884709f, -0.03965219f, 0.09670058f, 
    -0.02235820f, -0.01857609f, -0.17188717f, 0.14897794f, 0.15543580f, 0.06565098f, -0.06252004f, -0.01182302f, 
    -0.10673746f, -0.01454212f, -0.03198344f, 0.00281512f, -0.03405073f, -0.04928369f, -0.05190282f, -0.00871947f, 
    0.16076387f, -0.18527485f, 0.14486904f, -0.05592483f, -0.02767404f, -0.04031390f, -0.04378198f, -0.17164648f, 
    0.00350661f, 0.04135413f, -0.11627877f, -0.02752296f, -0.23107171f, 0.28901732f, 0.10093610f, -0.00738183f, 
    0.08604375f, -0.11308353f, -0.10753952f, -0.00713792f, -0.04555931f, 0.03931467f, -0.01313807f, 0.17433159f, 
    -0.14377290f, -0.17609824f, -0.16340610f, -0.23588222f, -0.06061863f, 0.01733813f, 0.09137335f, -0.00008408f, 
    0.01121792f, 0.01050105f, 0.02628848f, 0.13805825f, 0.09684245f, 0.03621997f, 0.10961367f, 0.05917851f, 
    -0.04648757f, -0.04949262f, 0.09469511f, 0.01836011f, -0.06948785f, -0.00599408f, 0.03609575f, -0.14281590f, 
    -0.10864612f, 0.02313079f, -0.00432963f, -0.07266110f, 0.00399366f, 0.09841523f, 0.01810729f, 0.08561315f, 
    -0.07458331f, 0.09853811f, 0.07932725f, -0.10825564f, 0.27330247f, -0.00806281f, 0.17785834f, -0.00897185f, 
    0.03495289f, -0.04881689f, 0.01255026f, -0.03511643f, -0.01827203f, 0.01817232f, -0.09680343f, 0.07506175f, 
    -0.01395390f, -0.04901794f, 0.14287810f, -0.03048814f, 0.06474779f, 0.15487386f, 0.00020776f, -0.03908163f, 
    0.11375186f, -0.06374554f, -0.01617032f, 0.06907078f, 0.37864256f, -0.03078887f, -0.07763779f, 0.07783985f, 
    0.08153079f, 0.04303899f, 0.06566755f, -0.02695625f, 0.14232549f, -0.01913649f, -0.03880674f, 0.02640981f, 
    0.04154890f, -0.05402623f, 0.07457897f, 0.05403956f, 0.00989300f, -0.02010659f, -0.03793145f, -0.09325471f, 
    -0.00501481f, 0.20513354f, -0.07114768f, 0.21541606f, -0.06303547f, 0.15074296f, 0.13907549f, 0.08250788f, 
    0.02147365f, 0.09168860f, -0.12514856f, -0.04886005f, -0.09570584f, 0.14991762f, 0.18466616f, 0.05077739f, 
    0.03501053f, 0.09302529f, -0.18428032f, 0.13837008f, 0.14261244f, 0.00622534f, -0.08169206f, 0.07619020f, 
    0.00349358f, 0.03068607f, -0.01790245f, -0.02742802f, -0.03918651f, -0.13213824f, 0.01217256f, -0.15389059f, 
    0.12248428f, -0.00744691f, 0.11044195f, -0.15893185f, -0.04835696f, -0.00164224f, -0.15418175f, 0.04648373f, 
    0.05330334f, -0.03265135f, 0.10467567f, 0.30441588f, -0.00326424f, -0.00791035f, 0.05255917f, 0.10014243f, 
    -0.09850807f, 0.12341826f, 0.18497036f, -0.10688346f, 0.08318345f, -0.21404994f, -0.14472410f, -0.25943494f, 
    0.02596458f, -0.10085683f, -0.11844648f, -0.03812924f, -0.04330194f, 0.09448364f, 0.12863334f, -0.18666202f, 
    0.17791747f, 0.04263299f, -0.02820273f, -0.06397858f, -0.13350908f, -0.11481085f, 0.12385073f, -0.11706270f, 
    -0.08802713f, -0.03799996f, -0.03260451f, 0.00436742f, 0.19331586f, 0.09925395f, -0.00338184f, -0.11207165f, 
    0.12024877f, 0.11056569f, -0.03315885f, 0.07383952f, -0.05495110f, 0.04846055f, -0.03845306f, 0.10577592f, 
    0.17086302f, 0.25893411f, 0.02435980f, -0.21981728f, 0.00329929f, 0.15698612f, -0.08827345f, -0.14770435f, 
    0.11136293f, 0.13200158f, -0.11622202f, 0.00894693f, 0.17823152f, -0.16254923f, 0.00628081f, 0.00633361f, 
    0.02292215f, -0.06811075f, -0.02653679f, 0.04733004f, 0.03426058f, 0.15192954f, 0.15755159f, 0.16405764f, 
    0.15708436f, 0.07159138f, 0.08986208f, 0.01894519f, 0.14983763f, -0.00747067f, -0.19006325f, -0.02957560f, 
    -0.03700687f, 0.00532451f, -0.08132828f, -0.11006290f, 0.08513946f, -0.13520794f, -0.19071329f, -0.04370458f, 
    -0.08642567f, -0.13888627f, -0.15283722f, 0.10645664f, 0.01216208f, -0.02319202f, -0.04793778f, 0.05603391f, 
    0.05433789f, -0.05792414f, -0.07041905f, 0.10450013f, -0.03578585f, -0.01647908f, 0.00358417f, 0.05744592f, 
    0.10929973f, -0.02846433f, -0.21135108f, 0.09665144f, -0.12263792f, -0.02366910f, -0.03900646f, 0.19499382f, 
    0.07972579f, 0.03545650f, 0.01227342f, 0.01616274f, -0.04383831f, -0.00538601f, 0.03913369f, 0.01649466f, 
    0.44427282f, 0.12952438f, -0.02108377f, -0.11535153f, 0.13626805f, -0.06499702f, 0.08410960f, -0.07460988f, 
    -0.10624348f, -0.06886649f, 0.10083328f, -0.02337890f, -0.25449467f, -0.08383048f, -0.05197681f, -0.06714079f, 
    0.03074815f, -0.01917373f, 0.04068624f, 0.06075388f, 0.08437390f, 0.11613709f, 0.09587380f, 0.10133351f, 
    -0.10271347f, -0.03610028f, 0.12404250f, 0.17033547f, 0.12681264f, -0.00122653f, -0.12937285f, 0.01876887f, 
    0.05834210f, -0.10978109f, -0.01447643f, 0.00652548f, -0.13610457f, -0.15638226f, -0.06771739f, 0.03714397f, 
    -0.00180175f, 0.14041829f, -0.04557655f, -0.05635954f, -0.07575245f, 0.02392513f, -0.09093301f, 0.02967038f, 
    0.19727638f, 0.04576883f, -0.08732089f, 0.00186231f, 0.16714321f, -0.07643525f, -0.03740626f, -0.03756347f, 
    -0.05347433f, -0.06029458f, 0.05519584f, 0.07109272f, 0.24129450f, -0.01489978f, 0.14877008f, 0.04138518f, 
    -0.02771910f, 0.00907980f, -0.10705876f, 0.07360878f, 0.13348228f, 0.02742913f, 0.03891057f, -0.00818985f, 
    0.28251931f, -0.00741054f, -0.24791940f, 0.03452600f, 0.00976701f, 0.10843718f, -0.04736338f, -0.03839082f, 
    -0.05074914f, -0.08186032f, -0.03701495f, -0.03288681f, 0.03281211f, 0.15344147f, -0.00664758f, 0.14748700f, 
    0.09223457f, 0.05835637f, 0.00100479f, 0.01818398f, 0.06754568f, 0.03068552f, -0.15295367f, 0.02462565f, 
    -0.13822094f, -0.10806517f, -0.09718900f, 0.05947420f, -0.00420257f, 0.12309626f, 0.07552382f, 0.08282788f, 
    -0.05805508f, -0.01360136f, 0.10869812f, -0.04575742f, -0.06282897f, -0.00074542f, -0.00573134f, -0.12268779f, 
    0.07624670f, 0.00090169f, 0.03726750f, 0.05871359f, -0.03319479f, -0.07581430f, -0.08807869f, -0.07260036f, 
    0.29334107f, 0.28274319f, -0.08324710f, -0.00370264f, 0.00647491f, 0.02453008f, 0.13675135f, 0.12299999f, 
    -0.02014789f, 0.01450584f, 0.07395427f, 0.05529941f, 0.00554522f, -0.08311682f, -0.12735061f, -0.01288845f, 
    -0.01223105f, 0.01731389f, 0.03318704f, -0.08360332f, -0.05915892f, -0.03809655f, 0.01880143f, -0.03734583f, 
    0.02104280f, 0.04032012f, 0.04692223f, 0.03199352f, -0.01684010f, -0.06951333f, -0.05819719f, 0.02315611f, 
    -0.03065190f, -0.01563189f, 0.03270712f, 0.03617448f, -0.03880253f, -0.05529718f, -0.07440178f, -0.06299242f, 
    -0.03495096f, -0.06346457f, 0.04431908f, -0.04562989f, 0.02862693f, -0.05966290f, -0.02135442f, 0.05744898f, 
    0.02614811f, -0.02278257f, 0.02856295f, -0.01233061f, -0.03474397f, -0.02872233f, -0.06364996f, 0.05755796f, 
    0.02494202f, -0.04334515f, -0.06134269f, 0.04178647f, 0.05196775f, 0.03776674f, 0.04796998f, 0.04051920f, 
    0.00092626f, -0.00602100f, 0.05698278f, -0.06601145f, -0.03242646f, 0.06358399f, -0.03787873f, -0.01186503f, 
    0.00269952f, -0.06269518f, 0.02683647f, 0.00872390f, -0.06789073f, 0.00383639f, -0.03540478f, 0.03774635f, 
    0.04748979f, -0.05116692f, -0.01440447f, -0.07419259f, -0.03237363f, 0.03613092f, -0.05283035f, -0.07003403f, 
    -0.05496939f, -0.06277220f, -0.06600050f, 0.03846503f, -0.02345279f, 0.04002963f, -0.04544380f, 0.02731232f, 
    -0.07474775f, 0.02422886f, -0.01016817f, -0.04107163f, -0.01508371f, 0.04853814f, -0.07167719f, -0.00489618f, 
    0.00099717f, -0.07075669f, -0.01857666f, 0.06537741f, -0.05436223f, 0.04610749f, 0.05328685f, 0.02070258f, 
    -0.01146404f, -0.07002439f, -0.04502171f, 0.04523025f, -0.03232182f, 0.02931475f, -0.00660687f, 0.02194789f, 
    -0.07408623f, 0.03533096f, 0.02101117f, -0.07451330f, -0.00418927f, -0.02829278f, -0.02992839f, -0.04269296f, 
    0.02372721f, 0.00995461f, 0.04415015f, -0.07406434f, 0.00064803f, -0.03384668f, -0.02819198f, 0.02417940f, 
    0.01368448f, 0.03046904f, 0.00514796f, -0.00734284f, -0.07178963f, -0.05147460f, 0.03516739f, 0.03829128f, 
    0.00552689f, 0.02913839f, 0.01297227f, -0.02397059f, 0.02197430f, -0.04006780f, 0.06125318f, 0.06476650f, 
    0.00024277f, -0.02079556f, -0.06470557f, -0.03170565f, 0.00046836f, -0.03749556f, 0.00970013f, -0.07134900f, 
    -0.01525796f, 0.01801306f, 0.03760710f, -0.05244501f, 0.02451565f, 0.01005051f, 0.01196818f, 0.06358109f, 
    0.06118204f, 0.03469976f, -0.01394117f, 0.05801543f, -0.03634316f, 0.04924833f, -0.05260821f, 0.05336208f, 
    -0.05253540f, -0.01035386f, 0.05865715f, -0.02761693f, 0.00832413f, -0.04000950f, 0.02719445f, -0.05181352f, 
    -0.03533001f, -0.00508382f, -0.02932763f, -0.02591359f, 0.00772561f, 0.00784296f, -0.00111213f, -0.03121364f, 
    0.01290053f, -0.00351269f, -0.04303991f, 0.02737362f, 0.01903534f, -0.01380950f, 0.00667046f, 0.06739157f, 
    -0.03815507f, -0.05500951f, -0.01339288f, 0.06538551f, -0.05991281f, -0.02500626f, -0.06770070f, -0.01696177f, 
    -0.03992438f, -0.07117023f, -0.06712777f, -0.04324618f, -0.07548102f, 0.01813284f, 0.03064060f, 0.02007415f, 
    0.18871169f, 0.05478030f, 0.38286000f, 0.01090289f, -0.04088463f, 0.01964163f, -0.21409701f, 0.03600774f, 
    -0.08289078f, -0.02244550f, 0.08650760f, -0.19692725f, -0.11204812f, 0.05780046f, -0.12523116f, 0.14073057f, 
    -0.11849702f, 0.08757052f, -0.00286534f, -0.14157215f, 0.09814645f, -0.17003112f, 0.02519283f, 0.12195493f, 
    0.28336266f, -0.15540597f, 0.18807434f, 0.08717474f, -0.07609323f, -0.24037986f, -0.07223877f, 0.04652553f, 
    0.04400424f, -0.15318233f, -0.00077605f, 0.05815199f, 0.00490559f, -0.03701472f, 0.00220838f, -0.00581320f, 
    -0.11803818f, 0.07103036f, 0.06243578f, 0.05242655f, -0.07407849f, -0.04641311f, 0.16995077f, -0.05907231f, 
    0.00908554f, 0.08030795f, -0.15616073f, 0.04897771f, -0.03235514f, 0.07721900f, -0.01445499f, 0.08989906f, 
    0.12050115f, 0.03911990f, 0.02139281f, 0.03486790f, -0.04252933f, -0.02657523f, -0.29768312f, 0.08054315f, 
    0.01310480f, 0.07817230f, -0.07268099f, -0.12682356f, -0.04988123f, 0.09011764f, -0.09696792f, 0.03027662f, 
    -0.05188291f, 0.00801076f, -0.10827738f, -0.11469384f, -0.11554623f, -0.02734288f, -0.08004828f, 0.04593807f, 
    0.09039410f, -0.12798175f, 0.08182965f, -0.18268476f, -0.10727972f, 0.09855957f, -0.01555041f, 0.02360769f, 
    0.09285036f, -0.05008123f, -0.04098982f, -0.01292039f, -0.03721330f, -0.09811049f, -0.03366105f, 0.06064831f, 
    0.26586601f, 0.17321020f, 0.04145966f, -0.01333452f, 0.04263742f, -0.02103190f, 0.10211967f, -0.03455222f, 
    0.02770876f, 0.01878824f, 0.00597250f, 0.09456704f, 0.04870467f, 0.01588427f, -0.22276881f, 0.10792827f, 
    0.00920985f, -0.01642998f, -0.00246770f, 0.08414803f, 0.21100916f, -0.03891889f, -0.01246835f, 0.12002810f, 
    -0.04495809f, -0.12880500f, -0.12462099f, -0.22603373f, -0.01273363f, 0.06448650f, -0.00234676f, -0.08508820f, 
    0.07504795f, 0.02831240f, -0.13930532f, 0.12223545f, -0.02473001f, 0.16831566f, 0.26642874f, 0.22741742f, 
    0.05666672f, 0.10037906f, -0.00888187f, 0.12562095f, 0.06845478f, 0.02063197f, -0.11190127f, 0.22287944f, 
    -0.10188152f, -0.00031040f, -0.10932440f, 0.13962360f, 0.02660430f, 0.02103929f, 0.03232220f, -0.00972590f, 
    0.03138302f, 0.01143135f, 0.17069077f, -0.07498080f, 0.01821856f, -0.10161740f, -0.16443637f, 0.14974260f, 
    -0.06885374f, -0.05214673f, -0.11446521f, -0.04433023f, 0.06519837f, 0.11197332f, 0.12202285f, 0.10827127f, 
    -0.31336075f, -0.07349391f, -0.17951067f, 0.18394510f, 0.01181565f, -0.01645640f, 0.07946328f, 0.20398262f, 
    0.11918341f, 0.05232394f, 0.16477151f, 0.01400670f, 0.12356371f, -0.23692727f, -0.22620106f, -0.00260074f, 
    0.00845272f, 0.07175697f, 0.07551504f, 0.02470648f, 0.01700460f, 0.03787291f, -0.20651549f, -0.12646508f, 
    0.01542326f, -0.06580036f, -0.01519049f, -0.07442516f, 0.01062587f, -0.05245179f, 0.05773177f, -0.02156665f, 
    -0.02892739f, -0.05393440f, -0.03626885f, 0.05059922f, 0.01295209f, 0.04081051f, -0.06712373f, -0.05986398f, 
    0.02014272f, 0.03356743f, -0.06179137f, 0.00760259f, -0.07582820f, -0.02658751f, 0.04725443f, -0.00146346f, 
    0.06333251f, 0.01891860f, -0.04874214f, -0.04107336f, 0.00999155f, -0.00901484f, -0.06490494f, -0.00691869f, 
    -0.01012155f, 0.00617318f, 0.03444342f, -0.00229004f, -0.05720737f, 0.00793868f, -0.01945522f, -0.05884821f, 
    0.01778184f, -0.01633631f, -0.02490738f, 0.04750676f, 0.00491665f, -0.06582323f, -0.06677250f, -0.00188862f, 
    -0.05460361f, 0.04246427f, -0.01562398f, -0.01549860f, 0.00107242f, -0.06377421f, 0.00248056f, 0.04554604f, 
    -0.03663474f, 0.01699871f, -0.07014359f, -0.06692032f, 0.01934722f, 0.00234324f, -0.01849945f, -0.07945255f, 
    0.03828948f, -0.01510899f, 0.01384458f, -0.05343267f, -0.06399275f, -0.08037374f, 0.05822433f, -0.02259722f, 
    0.02861317f, 0.05149315f, -0.01203176f, 0.02753160f, 0.05496546f, 0.04085946f, 0.01091713f, -0.03505144f, 
    -0.03645576f, -0.00705202f, 0.00639974f, 0.00852202f, -0.03432312f, -0.00264798f, 0.02940825f, -0.07223807f, 
    -0.07470376f, 0.02971996f, 0.04724650f, -0.04524235f, -0.01042396f, -0.07270899f, -0.02920903f, -0.08075456f, 
    -0.03239676f, 0.00292016f, -0.04640947f, 0.01963207f, 0.03557163f, -0.06890187f, -0.08153769f, -0.02939061f, 
    0.04918419f, -0.06075910f, -0.04673097f, 0.03692620f, -0.02766008f, 0.01699442f, -0.03651344f, 0.05860104f, 
    -0.04786066f, -0.00471839f, 0.04981606f, 0.05424266f, -0.04850752f, -0.02963350f, 0.01121788f, -0.04335057f, 
    0.03961182f, 0.04198605f, -0.05429589f, -0.03010852f, -0.00149946f, -0.00937483f, -0.02245774f, 0.00124961f, 
    0.04166108f, 0.01088137f, -0.05685846f, -0.01807402f, 0.06506540f, -0.02199741f, -0.05265666f, -0.07756200f, 
    0.02553548f, -0.05148954f, 0.00100869f, -0.07640281f, -0.00467498f, 0.01416018f, -0.03576344f, 0.01772346f, 
    0.00930260f, 0.05527224f, 0.05412380f, 0.04360355f, 0.00078240f, 0.02284699f, 0.05147223f, 0.01619948f, 
    -0.01166989f, 0.00834910f, -0.06332032f, -0.07231037f, -0.06288013f, 0.02465226f, 0.05198832f, 0.02078159f, 
    0.06083775f, -0.02709511f, -0.08150890f, -0.01891129f, -0.07610544f, 0.00832108f, -0.00595184f, -0.01728182f, 
    -0.01104823f, -0.03557383f, -0.02518397f, 0.04468393f, -0.05958308f, -0.02231543f, 0.04817291f, 0.01468651f, 
    -0.05653378f, -0.05136927f, -0.01287782f, -0.03615490f, 0.00181681f, -0.07943830f, 0.04067027f, 0.01047850f, 
    -0.05057672f, 0.00374417f, 0.01192367f, -0.07672904f, 0.00998832f, -0.01475261f, 0.05521280f, -0.01435285f, 
    -0.05403969f, -0.07671465f, -0.03353149f, 0.05914315f, -0.05703817f, 0.00090884f, -0.07532350f, 0.02742421f, 
    0.06284097f, -0.04062925f, 0.00694376f, 0.01165582f, -0.02429863f, -0.05053475f, 0.02724754f, 0.06270924f, 
    -0.06871933f, -0.02416029f, 0.01278573f, 0.03183387f, 0.06002821f, -0.00044472f, -0.07971108f, -0.07260239f, 
    -0.03525599f, 0.03756619f, -0.03097573f, -0.07372762f, -0.04536250f, 0.04884564f, -0.00761554f, 0.05787858f, 
    0.03514679f, -0.05844238f, -0.06345537f, 0.05885141f, 0.00570532f, -0.01157238f, -0.02509522f, 0.00891373f, 
    0.01287197f, 0.05188485f, -0.03976013f, -0.04647437f, -0.07655867f, 0.01040293f, 0.01025954f, -0.04596012f, 
    -0.01118182f, -0.06830304f, -0.02616299f, 0.05108008f, -0.05947267f, 0.06236695f, -0.01802304f, -0.01629259f, 
    -0.04095106f, 0.02714576f, -0.05436199f, -0.07406567f, -0.02145777f, 0.03318645f, 0.06139315f, 0.01208951f, 
    0.06349002f, 0.00819125f, -0.05987392f, 0.01582178f, -0.02990577f, -0.04371545f, 0.02167789f, 0.03588102f, 
    -0.00339774f, -0.03956741f, 0.03291883f, -0.04881696f, 0.03770420f, -0.04786908f, -0.03313148f, -0.02590532f, 
    0.00993387f, 0.05060636f, -0.04919391f, -0.02102645f, -0.02846124f, 0.03611094f, -0.04978397f, -0.05262965f, 
    -0.06358679f, -0.03891615f, -0.01583076f, -0.03913705f, 0.05243542f, -0.00448212f, -0.04814939f, 0.02979659f, 
    -0.06675985f, -0.05636108f, 0.01418596f, -0.02222314f, -0.04651394f, 0.05318326f, -0.03434627f, -0.04532347f, 
    0.00862805f, -0.06205207f, -0.05391306f, 0.03331159f, 0.05120334f, -0.08006538f, -0.02725020f, -0.04780053f, 
    -0.06962818f, -0.01345874f, 0.04761456f, -0.00527857f, 0.01726408f, -0.01886978f, -0.00895805f, 0.04556515f, 
    -0.05505962f, 0.02177153f, 0.03235583f, -0.01794405f, -0.07602958f, -0.02835369f, -0.01019278f, 0.04633483f, 
    0.05800964f, 0.04727963f, -0.01605405f, -0.00920053f, 0.00571267f, -0.01504777f, 0.05496929f, -0.07646288f, 
    -0.02993197f, 0.00206872f, 0.00154050f, -0.00383967f, 0.02635387f, -0.02688770f, -0.06605689f, -0.04097828f, 
    0.01232017f, -0.01537246f, 0.04716889f, -0.01098240f, -0.00082417f, 0.06109275f, -0.02649665f, -0.07232969f, 
    -0.06769635f, 0.02845532f, 0.04368099f, -0.08051786f, -0.03790011f, -0.03665639f, 0.01480864f, -0.01827982f, 
    -0.01582804f, -0.01865231f, 0.00252670f, -0.03601529f, -0.03126263f, -0.06305062f, 0.00657000f, -0.02367889f, 
    -0.00986617f, -0.07882556f, -0.03938871f, -0.01546263f, -0.04117455f, -0.03960847f, 0.04765463f, 0.04996749f, 
    0.05742700f, -0.02289412f, -0.00598315f, 0.02808171f, -0.02838892f, -0.01646050f, 0.02769935f, -0.02612055f, 
    -0.03106580f, 0.01350234f, 0.05047050f, -0.07541764f, 0.05031659f, -0.03018756f, -0.02797136f, 0.02720377f, 
    0.04260501f, 0.06823178f, 0.11921105f, -0.05499996f, -0.00778579f, 0.05201809f, -0.04852785f, 0.01576162f, 
    0.04634172f, 0.05921220f, -0.08673281f, -0.02440795f, -0.18758014f, 0.06948590f, -0.15640517f, 0.00937784f, 
    -0.08257724f, 0.03625904f, -0.06258348f, -0.02440425f, -0.07301004f, -0.02427637f, -0.10157370f, -0.05629649f, 
    0.12551816f, -0.09933783f, 0.12887110f, -0.01395162f, 0.09342584f, -0.09019147f, 0.09875000f, 0.03154088f, 
    0.03252644f, -0.02475588f, 0.02677531f, -0.03951048f, -0.13283849f, -0.09495686f, -0.00641096f, -0.12719375f, 
    0.08854594f, 0.08486351f, -0.07306257f, -0.02301027f, 0.00675818f, -0.02934959f, 0.02161283f, 0.01394576f, 
    0.29151544f, 0.34413946f, -0.04167146f, 0.07649805f, 0.03398995f, 0.07881676f, -0.07902536f, -0.08403350f, 
    0.02951000f, 0.06592353f, 0.16769814f, -0.05105648f, -0.09588171f, -0.09453876f, -0.08212327f, -0.06736225f, 
    -0.06976780f, 0.14423554f, 0.08299275f, -0.00340941f, -0.01065153f, -0.00532300f, 0.06730651f, 0.15311170f, 
    -0.30515304f, -0.05921735f, -0.00011367f, -0.21217680f, -0.04603449f, 0.03806891f, 0.04143352f, 0.02943084f, 
    0.00459178f, 0.07579821f, -0.00668944f, -0.16183783f, -0.17512399f, -0.16011500f, 0.09204536f, 0.23117508f, 
    -0.06210468f, -0.03748861f, 0.01544368f, 0.05905034f, 0.00114776f, 0.09686366f, -0.06868474f, 0.05506036f, 
    0.40629485f, 0.35022423f, 0.03683271f, -0.02486401f, 0.06439593f, 0.13750237f, 0.03889356f, -0.04630402f, 
    0.07371983f, 0.13921498f, 0.03914578f, 0.11960785f, 0.03621430f, 0.00366907f, 0.00676807f, -0.19444562f, 
    0.05312840f, -0.05665636f, 0.11766543f, 0.04480579f, 0.09345659f, 0.07206676f, 0.10595907f, -0.08591806f, 
    -0.50596470f, 0.07054843f, -0.13221261f, -0.28225783f, 0.09740270f, -0.03163009f, 0.02400281f, -0.01501051f, 
    0.05648725f, 0.04606582f, 0.00873785f, 0.17747915f, 0.26501706f, 0.19557223f, 0.22116308f, 0.11483783f, 
    -0.05886147f, 0.02116655f, -0.04385164f, -0.04705853f, 0.12691191f, 0.00759419f, 0.02336556f, 0.13097924f, 
    -0.45165971f, 0.05464719f, -0.20891382f, -0.01306503f, 0.02805875f, 0.08274348f, -0.00843883f, 0.07271948f, 
    0.04148402f, -0.02788464f, 0.08909741f, -0.02948075f, 0.13445579f, -0.00944958f, 0.09099600f, 0.10606532f, 
    -0.09602655f, -0.03122144f, -0.05531799f, -0.01076443f, 0.00501445f, -0.04921281f, 0.09149461f, 0.07232199f, 
    0.14038938f, 0.41124517f, 0.03235117f, 0.25440249f, 0.09505004f, 0.08053124f, -0.06087927f, 0.02084477f, 
    -0.02991736f, -0.02425545f, 0.04717899f, -0.02044800f, -0.13703819f, -0.11858655f, -0.08647657f, 0.04241303f, 
    -0.04417503f, -0.05643617f, 0.05438438f, -0.00164110f, -0.04000321f, 0.06700285f, -0.00946539f, 0.16122738f, 
    -0.24531493f, 0.18404385f, -0.12951308f, -0.05627717f, 0.05140940f, -0.22000405f, 0.20606574f, -0.00317965f, 
    -0.01094863f, -0.09772489f, 0.05643092f, 0.13959824f, -0.07211616f, -0.21162088f, 0.01160784f, -0.06810054f, 
    0.06150705f, 0.07087355f, -0.09304801f, 0.08965523f, -0.17028330f, 0.07756892f, 0.03376937f, 0.07068745f, 
    -0.09539059f, 0.10324661f, 0.06343340f, -0.22661439f, 0.02801430f, -0.02258099f, -0.08393779f, -0.09134145f, 
    0.02813951f, 0.05797691f, 0.17270727f, -0.08650789f, -0.14815499f, -0.02923609f, 0.13648264f, 0.03687852f, 
    0.14827400f, -0.11525860f, -0.11266981f, -0.09862715f, 0.02578180f, -0.12328216f, -0.06958847f, -0.03321051f, 
    -0.15014865f, -0.14182153f, 0.14613150f, 0.20673800f, 0.03641742f, 0.12869170f, 0.03023471f, 0.01237583f, 
    0.00934577f, -0.05207179f, 0.00554531f, 0.06439214f, 0.16162868f, -0.01552232f, 0.37363544f, -0.21130107f, 
    0.09702495f, -0.08037528f, -0.04548968f, 0.19390993f, 0.01641120f, 0.01291230f, -0.02269142f, 0.12994362f, 
    -0.08510618f, 0.03534621f, 0.03980135f, -0.05816218f, 0.08129569f, 0.01905852f, 0.29700798f, 0.08647146f, 
    -0.02599397f, 0.23024882f, 0.02764246f, 0.11177271f, 0.41533947f, -0.15533213f, 0.17657438f, 0.16871779f, 
    0.06457270f, -0.03634024f, -0.00076643f, 0.08599247f, -0.08537915f, 0.13998093f, 0.06723602f, 0.10675348f, 
    -0.30415127f, 0.11732065f, 0.13245353f, -0.17402843f, 0.07804370f, -0.07882608f, -0.03758083f, -0.03935079f, 
    0.01757994f, -0.04259768f, -0.11570280f, -0.13691995f, -0.00975767f, 0.22373481f, -0.10294072f, 0.13717058f, 
    0.00147894f, 0.08600818f, -0.01620409f, -0.10281567f, 0.07234213f, 0.01628154f, -0.12110668f, 0.01243263f, 
    -0.20813031f, -0.13960077f, -0.15670307f, 0.23817465f, 0.06574076f, 0.03095092f, 0.10173022f, 0.08640625f, 
    -0.02727252f, -0.00377244f, 0.10741997f, -0.03996122f, 0.19330528f, -0.02195836f, 0.01611693f, -0.00559524f, 
    0.18869701f, -0.10405686f, -0.07898594f, -0.19798489f, 0.05974539f, 0.02226885f, 0.08123332f, -0.04946173f, 
    0.10318770f, -0.24629612f, 0.00257289f, 0.00756616f, 0.13378119f, -0.14634362f, 0.03817755f, 0.03688220f, 
    0.02911857f, -0.02087235f, 0.03601304f, 0.04297939f, 0.05852430f, 0.36701894f, 0.04520594f, -0.06465023f, 
    0.03357312f, 0.07594121f, -0.02228725f, 0.00202361f, 0.09880074f, -0.08272413f, -0.11760762f, -0.08143924f, 
    -0.03980888f, -0.33723262f, 0.19765984f, 0.02119048f, 0.02071662f, 0.09588368f, 0.10120330f, -0.25142580f, 
    -0.00583013f, -0.00325710f, -0.03079310f, -0.02541487f, -0.10905446f, 0.17668110f, 0.14751686f, -0.10560719f, 
    0.05420895f, 0.15101084f, 0.06516518f, 0.09391784f, -0.02172473f, 0.21852687f, 0.18140176f, 0.02736351f, 
    0.08047288f, -0.03727885f, -0.11726256f, -0.22948761f, 0.07467502f, -0.06584091f, -0.15034676f, -0.08331405f, 
    -0.10645577f, -0.02586216f, 0.04442977f, -0.01510599f, 0.14359742f, 0.10483253f, 0.14934646f, 0.23263891f, 
    -0.10425328f, -0.05017601f, -0.07654833f, 0.11695326f, -0.04149745f, -0.01290484f, -0.05407176f, 0.05185147f, 
    0.10739598f, -0.04514121f, -0.11716639f, 0.04383231f, 0.09038424f, -0.10615367f, 0.00819475f, 0.23580378f, 
    -0.00423654f, -0.10345445f, -0.09836029f, 0.02285057f, 0.24908438f, 0.02292690f, 0.03424632f, 0.07291190f, 
    -0.06336939f, -0.10394025f, 0.17986208f, 0.07541786f, -0.01317021f, -0.01475519f, 0.01557218f, 0.05162118f, 
    0.03663982f, 0.01291175f, -0.04714653f, -0.15388666f, 0.25615662f, -0.05459452f, 0.10590793f, -0.06457496f, 
    0.08454262f, 0.00555872f, 0.20249450f, 0.05421121f, -0.09587244f, -0.04173855f, 0.00202357f, -0.06974644f, 
    -0.03620376f, -0.11612733f, -0.02704129f, 0.00695835f, 0.14907996f, 0.17671826f, 0.06471765f, 0.03533298f, 
    -0.16351824f, 0.02750685f, 0.30769381f, 0.14995310f, -0.10211304f, -0.12965046f, 0.08200172f, 0.07129426f, 
    -0.04944482f, -0.03301031f, -0.08134845f, -0.09483497f, 0.12038382f, -0.16995306f, -0.04027064f, 0.36170915f, 
    0.09170789f, 0.04678047f, -0.05137435f, -0.13059674f, 0.06070950f, -0.06674782f, 0.07699463f, 0.10836829f, 
    -0.02190069f, -0.19189329f, -0.17616467f, -0.05266233f, 0.37738663f, 0.10939775f, 0.16110471f, -0.06873050f, 
    -0.15059736f, -0.14937800f, 0.14978723f, 0.14727120f, -0.05639626f, 0.18974780f, 0.20024391f, -0.09699239f, 
    -0.09808872f, -0.15326494f, 0.10051489f, 0.25012314f, 0.12354375f, 0.17946909f, 0.06097715f, 0.05285805f, 
    0.21662737f, 0.00868473f, 0.05030866f, 0.23137942f, -0.09392691f, -0.12107248f, -0.07618656f, -0.08251256f, 
    -0.18243141f, 0.07282653f, -0.17235896f, -0.02820701f, -0.23279956f, -0.21057230f, -0.25932354f, 0.09608432f, 
    0.15283854f, 0.09581292f, -0.17950606f, -0.05713986f, 0.08932872f, -0.05757891f, -0.00096611f, 0.02922502f, 
    0.14597206f, 0.01324082f, 0.02844609f, 0.03613481f, -0.14235647f, -0.01848726f, -0.08442427f, -0.00085288f, 
    -0.01078677f, 0.07658221f, -0.03814438f, 0.00228185f, -0.24054573f, 0.27206811f, 0.10056214f, -0.09028444f, 
    0.16762367f, -0.05463444f, 0.12749155f, 0.12497558f, 0.11920220f, 0.04899941f, -0.01817553f, 0.03761748f, 
    -0.02765158f, 0.01390332f, -0.13991936f, -0.03243321f, -0.03028638f, -0.02456654f, 0.10896593f, -0.10992154f, 
    0.19664931f, 0.08632900f, 0.01110406f, 0.02862746f, -0.14027441f, 0.03179103f, -0.08268939f, -0.02179598f, 
    -0.02648758f, -0.05811960f, -0.14056027f, 0.02374470f, 0.05446929f, 0.02277506f, -0.09753435f, -0.02174728f, 
    0.34744322f, 0.24616177f, -0.00606174f, 0.16849771f, -0.01479309f, 0.14883357f, 0.02089375f, 0.12430993f, 
    -0.03783076f, 0.13831118f, -0.00925577f, -0.02650686f, -0.08001617f, 0.05028735f, 0.30561492f, 0.16832681f, 
    0.12341573f, 0.00855565f, 0.05719690f, 0.07712046f, -0.02696722f, -0.01120238f, 0.13396101f, 0.13894430f, 
    0.25572017f, 0.02002551f, 0.11829071f, 0.30110314f, -0.04027503f, 0.13865241f, 0.02949051f, -0.03802413f, 
    0.03597906f, 0.10554971f, 0.04237500f, -0.12785038f, 0.04008635f, 0.08824115f, 0.10718717f, -0.02682798f, 
    -0.01406301f, -0.04036602f, -0.02304002f, 0.01499074f, -0.00988720f, 0.01156923f, -0.13233721f, 0.00165448f, 
    0.01076532f, -0.02918998f, -0.01501732f, -0.15240180f, -0.00282985f, -0.11001141f, 0.15583029f, 0.02948328f, 
    -0.07064224f, 0.02641269f, -0.07651995f, 0.03393320f, -0.05571207f, 0.15269695f, 0.00803869f, -0.07477543f, 
    0.16973150f, -0.05000982f, -0.04150808f, 0.08757877f, -0.14057600f, 0.01349158f, -0.04040770f, 0.06298213f, 
    -0.27921477f, 0.01681112f, -0.12676068f, -0.01501000f, -0.02635155f, -0.08520364f, 0.00151756f, 0.12261443f, 
    -0.00321416f, -0.01713286f, 0.01184287f, -0.03531765f, 0.33259046f, -0.12450451f, -0.14180228f, -0.22119594f, 
    0.08884291f, -0.08812638f, -0.02076724f, -0.12766725f, 0.01151169f, -0.13328753f, 0.05707584f, -0.04203456f, 
    0.18543072f, 0.10912246f, 0.03894377f, -0.07314940f, -0.07462664f, -0.06310739f, -0.07675493f, -0.06954732f, 
    -0.02201446f, -0.06675091f, -0.08994206f, -0.10373407f, -0.07053336f, 0.21786514f, 0.15936431f, -0.05250840f, 
    -0.10799124f, 0.01201302f, -0.20371774f, -0.13300790f, -0.06772376f, -0.06775215f, 0.01354241f, 0.10190338f, 
    0.07247341f, 0.12139690f, 0.08555661f, 0.22326696f, -0.09462878f, 0.10136813f, -0.16449636f, 0.08470698f, 
    0.06987692f, 0.08476423f, 0.14554289f, 0.15798411f, 0.11234406f, 0.27839059f, 0.05114426f, -0.02498780f, 
    -0.03905032f, 0.01923475f, 0.07220408f, -0.06152006f, 0.01633390f, 0.08435696f, -0.16613033f, -0.06393494f, 
    0.11516216f, -0.04423264f, 0.07205454f, 0.32575342f, 0.07509113f, -0.08219799f, 0.03445674f, 0.12493961f, 
    0.01182533f, 0.00990379f, 0.00435021f, -0.00438544f, -0.35225478f, 0.06408906f, 0.19492505f, -0.10224647f, 
    -0.03990093f, 0.03601776f, 0.02639413f, 0.06000487f, -0.07345551f, 0.05897120f, 0.08620170f, -0.08540688f, 
    -0.28198022f, -0.19398673f, -0.05458242f, -0.08853101f, 0.05809774f, -0.09216914f, 0.04027394f, -0.02822572f, 
    -0.05000629f, -0.13544959f, 0.07023523f, -0.01688342f, 0.06156196f, -0.14699778f, 0.13711438f, -0.19233057f, 
    0.04839529f, 0.07057481f, -0.07078082f, -0.01994504f, -0.01637080f, 0.13483180f, 0.04684823f, 0.03339025f, 
    0.34310564f, 0.02339906f, -0.06781606f, 0.14556128f, -0.16792576f, 0.14061032f, -0.04010458f, 0.03945253f, 
    0.06261124f, -0.00271558f, -0.01643870f, -0.03225072f, 0.18165435f, 0.10428227f, -0.03458029f, -0.15876429f, 
    -0.04583222f, -0.09515820f, 0.23896559f, 0.01056821f, 0.18220142f, -0.10248249f, 0.07822622f, 0.05752352f, 
    0.36966085f, -0.00100681f, -0.01836832f, -0.00312619f, -0.05304776f, 0.09367365f, 0.03568979f, 0.11321990f, 
    -0.05249273f, 0.00320478f, 0.03642420f, 0.26756522f, 0.29688928f, 0.11955284f, -0.05524330f, -0.12694936f, 
    -0.07064878f, 0.08297965f, 0.11579237f, 0.02662866f, -0.03218111f, 0.10421614f, -0.08057693f, 0.00938487f, 
    -0.15308195f, 0.12181357f, -0.01771617f, 0.04237521f, -0.06911967f, 0.00196987f, 0.04087885f, 0.12990254f, 
    -0.06495410f, -0.03654701f, -0.12772669f, -0.00259828f, -0.22342223f, -0.02143617f, -0.30250779f, 0.05321646f, 
    0.11122657f, 0.07281813f, 0.09598376f, 0.02921292f, 0.01619324f, -0.08780576f, 0.05211093f, -0.09659834f, 
    -0.05843756f, -0.02136246f, -0.27689862f, 0.09683996f, 0.00098181f, -0.01964030f, -0.08549616f, -0.03659723f, 
    0.04109054f, -0.04282728f, -0.05927123f, 0.08478247f, -0.15274882f, 0.08193719f, -0.19750741f, -0.23287708f, 
    -0.01986263f, 0.08043001f, 0.03935601f, -0.09805273f, 0.09917691f, -0.09696513f, -0.02856695f, -0.02206796f, 
    0.36712900f, 0.11557016f, 0.18815188f, 0.28447703f, -0.14600027f, 0.08391894f, 0.08348243f, -0.00532887f, 
    -0.05363816f, 0.07720840f, -0.01135086f, -0.02010283f, -0.06350551f, -0.30275083f, 0.14063865f, -0.21666850f, 
    -0.02599666f, 0.04079903f, -0.01172336f, 0.00139199f, -0.13813891f, -0.00857905f, -0.06719751f, 0.06748649f, 
    0.32809666f, 0.07883058f, 0.06921356f, -0.15987942f, -0.00218262f, 0.12921169f, 0.00488272f, 0.02156436f, 
    0.08043575f, -0.02471302f, -0.11649676f, -0.03185612f, -0.05589193f, 0.20590435f, 0.14335869f, 0.24983875f, 
    -0.12256484f, -0.02836903f, -0.04845533f, -0.03900398f, -0.11901329f, -0.00888220f, -0.04892804f, 0.01390951f, 
    0.02270503f, 0.06153254f, -0.25974795f, -0.15787025f, -0.02822155f, -0.00237313f, -0.00613445f, 0.07164310f, 
    0.01446974f, 0.10655021f, 0.05671624f, -0.00948243f, -0.10326043f, -0.26762748f, -0.12619250f, -0.06054783f, 
    -0.11996866f, -0.06503819f, 0.10076959f, 0.02388211f, 0.03888509f, 0.05020943f, -0.11292674f, 0.16798441f, 
    -0.18614995f, 0.06866550f, -0.20444593f, -0.15864781f, 0.09288735f, 0.13745132f, 0.03701945f, 0.04217005f, 
    0.14239988f, -0.10434393f, -0.05190608f, 0.00397677f, 0.35388497f, -0.20095287f, 0.04715354f, 0.02508930f, 
    0.05045276f, 0.10799617f, -0.17342240f, 0.04238762f, -0.01515905f, 0.04570467f, -0.05114083f, -0.10232528f, 
    0.04732370f, 0.02093789f, 0.02915822f, 0.03435187f, -0.02135686f, 0.03580845f, -0.05438301f, -0.03832607f, 
    -0.01333775f, -0.04844295f, -0.00431037f, 0.04712452f, -0.03616275f, 0.02043471f, 0.03402711f, -0.00762626f, 
    0.05139160f, 0.02934290f, 0.04638215f, -0.04724712f, -0.01500188f, -0.05112151f, -0.03136754f, 0.01855123f, 
    0.01418035f, 0.04978808f, 0.00912206f, -0.06227653f, -0.00574473f, -0.06629264f, -0.06292073f, 0.06178200f, 
    0.04746899f, -0.03534401f, -0.06465257f, -0.03125867f, -0.03772089f, 0.01590177f, -0.04501590f, -0.02993308f, 
    0.03636955f, -0.06481966f, -0.04630117f, 0.02928890f, -0.07888798f, 0.00020814f, -0.02081351f, -0.02947654f, 
    -0.00586188f, 0.05604832f, 0.01533674f, -0.06711876f, -0.04280031f, -0.04607185f, 0.02500295f, 0.01282573f, 
    -0.00098618f, -0.02857387f, -0.04537887f, -0.07168113f, 0.01786969f, -0.04887516f, -0.05438037f, -0.07170546f, 
    -0.06090400f, 0.03912549f, -0.04749246f, -0.01879071f, -0.01575815f, 0.04185212f, 0.01148772f, 0.04014574f, 
    0.05876988f, -0.03676574f, 0.03502199f, 0.03289084f, -0.02625503f, -0.02739867f, -0.05963012f, -0.06119100f, 
    0.06326561f, 0.01289123f, -0.01391783f, 0.04936133f, -0.07125010f, 0.03987096f, 0.04831595f, -0.04107722f, 
    0.03983870f, 0.01697916f, 0.03932535f, -0.02461617f, -0.01680135f, 0.04178323f, -0.07014035f, 0.03589916f, 
    0.01848608f, 0.00530599f, -0.01805810f, -0.06621543f, 0.05088105f, 0.02945616f, -0.02985016f, -0.01480040f, 
    -0.04192026f, 0.04923192f, -0.01596758f, 0.04053266f, -0.01191649f, -0.07031256f, -0.06447235f, 0.01746377f, 
    -0.00839529f, -0.04182376f, -0.06862473f, 0.02725776f, 0.05731837f, -0.04958853f, -0.04548814f, -0.03394857f, 
    -0.03463316f, -0.02989442f, 0.01502520f, -0.03370052f, -0.04172032f, -0.05717885f, -0.03306958f, -0.03566873f, 
    0.01526343f, -0.04015134f, 0.03630882f, -0.05544076f, -0.02136107f, -0.00780233f, 0.02668971f, -0.05564581f, 
    0.00714844f, 0.03306140f, -0.01438513f, -0.04199506f, 0.05527263f, 0.01533179f, -0.02154621f, -0.05499138f, 
    -0.06674428f, -0.03262120f, 0.02584642f, -0.02300697f, 0.02729253f, -0.00646133f, -0.05353172f, 0.04856765f, 
    -0.06970251f, -0.05731915f, -0.07853422f, -0.03136855f, 0.02603173f, -0.01456651f, -0.01724677f, -0.03269036f, 
    -0.03925540f, -0.03429421f, 0.02273330f, 0.02157580f, 0.02871528f, 0.01948838f, 0.02637984f, 0.02067078f, 
    0.01199095f, -0.04867906f, -0.00399813f, -0.02465795f, 0.00003391f, -0.03853546f, 0.03751552f, -0.01694200f, 
    0.02598512f, 0.04456450f, 0.00083316f, -0.04439943f, 0.04262478f, -0.06346054f, -0.04163677f, -0.07640221f, 
    0.01529296f, -0.05249495f, 0.01383818f, -0.05020770f, -0.05199496f, -0.03278056f, 0.00326284f, 0.05192247f, 
    -0.03085148f, -0.03618462f, -0.00781262f, 0.03330008f, -0.06842633f, -0.02492250f, 0.00416027f, -0.02516571f, 
    -0.06523138f, 0.01222544f, 0.01384587f, -0.04426920f, -0.07818784f, -0.04752275f, -0.07918320f, -0.03622632f, 
    0.00752849f, -0.03458842f, -0.00158239f, -0.07892341f, 0.01502689f, 0.00791719f, -0.02866105f, 0.04939070f, 
    -0.05044996f, 0.03251199f, 0.01458746f, 0.03149111f, 0.01666053f, 0.01604515f, 0.02394563f, 0.04706364f, 
    -0.05858061f, -0.03009607f, 0.00737572f, -0.04769885f, 0.05855580f, 0.06627216f, 0.00864697f, -0.01603120f, 
    0.03858673f, 0.02491525f, -0.01622164f, -0.00937689f, -0.07364851f, -0.06343302f, -0.07649218f, 0.04995622f, 
    0.00371665f, 0.02745589f, 0.04423250f, -0.07488231f, 0.00909381f, -0.01115995f, -0.01924778f, -0.05213907f, 
    -0.03547834f, 0.06065995f, 0.01466171f, -0.03550942f, 0.02879888f, 0.05102170f, 0.00095300f, 0.00331870f, 
    0.04484443f, -0.04572337f, 0.02876582f, -0.04135739f, -0.04298389f, -0.05034393f, -0.02616577f, -0.06073995f, 
    0.02359498f, -0.00486448f, -0.02457260f, 0.01716991f, 0.04235050f, -0.00207420f, 0.04794776f, -0.07807919f, 
    0.00086183f, -0.01330905f, -0.06621794f, -0.07164788f, 0.01583813f, -0.01944684f, -0.00695951f, 0.05243758f, 
    0.01395084f, -0.02449007f, 0.05834773f, -0.06604356f, 0.01199325f, 0.06310925f, -0.00424309f, 0.04283014f, 
    -0.00734397f, -0.05401251f, 0.04460075f, -0.03180628f, 0.05600385f, -0.00205192f, 0.01171911f, -0.02888305f, 
    0.00707212f, 0.01219420f, -0.07268910f, -0.05411219f, -0.00763431f, -0.06893720f, -0.04974779f, -0.03511164f, 
    -0.01824663f, -0.03249932f, -0.04139396f, 0.03263097f, 0.05040133f, 0.02830785f, 0.02503181f, -0.02388464f, 
    -0.03679438f, 0.03214768f, 0.01199905f, -0.05616911f, 0.02579114f, 0.03598154f, -0.07222921f, -0.06564064f, 
    0.02244870f, 0.06543242f, -0.04554296f, -0.03330968f, -0.04769886f, -0.04142917f, -0.01512918f, -0.03780922f, 
    -0.01559232f, 0.00305129f, 0.02461674f, 0.04920495f, -0.00846017f, 0.00049975f, -0.06214423f, 0.01582830f, 
    -0.00489118f, -0.07574929f, -0.00922000f, -0.05766854f, -0.02181410f, -0.07049214f, 0.05040903f, -0.03136476f, 
    0.04217471f, 0.04352127f, -0.05961479f, -0.04776021f, -0.04619396f, 0.05316798f, 0.00706315f, -0.06182180f, 
    0.05357898f, 0.04945114f, -0.05061830f, 0.02476947f, -0.02400410f, 0.03869865f, -0.01800475f, -0.00602990f, 
    -0.03184420f, 0.02657887f, 0.05944225f, -0.07847946f, -0.04633655f, -0.06843943f, -0.00680477f, -0.02041310f, 
    -0.00291654f, 0.03958090f, 0.05175550f, 0.04836997f, -0.06207249f, 0.01879165f, 0.01592823f, -0.06598939f, 
    0.04999920f, -0.01797710f, -0.04637662f, 0.00970919f, -0.04914314f, -0.05847239f, 0.00474406f, 0.00974734f, 
    0.13841139f, 0.04230551f, -0.17813343f, 0.22106238f, 0.18189816f, 0.12820227f, 0.01691090f, -0.01199097f, 
    0.18166260f, -0.01305172f, 0.08406656f, 0.08327126f, 0.01830943f, -0.07896496f, -0.00615411f, -0.40350935f, 
    0.02282828f, -0.19407183f, -0.03175503f, 0.07901252f, 0.03848241f, -0.02746050f, 0.08846652f, 0.10968219f, 
    0.12941836f, 0.00709657f, 0.02016024f, 0.05998893f, 0.12216048f, 0.14030714f, 0.05728510f, 0.04300114f, 
    0.08459365f, 0.04571195f, 0.00185716f, 0.22033049f, -0.02605893f, -0.01089074f, -0.01963930f, 0.15461329f, 
    0.02093477f, -0.00614970f, 0.00820179f, 0.02430336f, 0.04809418f, -0.03167453f, -0.02554668f, 0.11275616f, 
    -0.02726094f, 0.06422887f, 0.10389772f, -0.07699255f, 0.14192539f, -0.01173118f, 0.08756172f, -0.14560585f, 
    -0.02630695f, -0.10012764f, -0.14883465f, 0.08864856f, -0.22893591f, 0.18663229f, 0.13467728f, 0.07409528f, 
    0.00853285f, 0.04621974f, 0.02126868f, 0.02498360f, -0.00834263f, 0.02278992f, 0.04339580f, -0.01460798f, 
    -0.04513959f, 0.06606102f, -0.02804044f, 0.18511562f, -0.08760774f, -0.00728786f, 0.02390470f, -0.08096507f, 
    -0.00984418f, 0.04532250f, 0.00942469f, 0.14726231f, 0.17223865f, -0.05114770f, -0.13326173f, -0.05773602f, 
    -0.07349041f, 0.00259608f, 0.04261768f, 0.08455984f, -0.06413057f, -0.09455129f, 0.03248013f, -0.08020967f, 
    -0.06853348f, 0.14360482f, 0.13490334f, -0.04825240f, -0.16792834f, -0.10999008f, -0.05318193f, 0.16059746f, 
    0.16588834f, 0.09226359f, 0.02922209f, -0.07188253f, 0.19972329f, 0.15202455f, 0.13926066f, 0.03073488f, 
    -0.07842633f, 0.10790315f, -0.08917291f, -0.08671059f, -0.07700309f, -0.02079635f, 0.00352636f, 0.05963061f, 
    0.31269419f, -0.04116930f, -0.09342544f, -0.07485695f, -0.01515185f, 0.04983114f, -0.14661230f, 0.11742249f, 
    -0.01748077f, -0.05591818f, 0.04366479f, -0.08018361f, 0.12631352f, 0.10336138f, -0.14670292f, -0.09905080f, 
    0.09599205f, -0.12774961f, 0.12747915f, 0.06830834f, -0.07240232f, 0.05719610f, 0.08059087f, 0.02515345f, 
    0.01952676f, -0.22895595f, -0.18219335f, -0.13790475f, -0.08138666f, -0.05631109f, 0.06317917f, -0.06898135f, 
    -0.05431594f, 0.00804392f, -0.08008257f, -0.11201656f, -0.33066726f, -0.06551120f, 0.23795205f, -0.19383365f, 
    -0.08986323f, 0.13990457f, 0.01613817f, 0.02236196f, 0.09207048f, 0.06505247f, -0.16235720f, -0.06520303f, 
    -0.08331046f, -0.00816337f, 0.21783888f, -0.17659508f, 0.04021297f, 0.05083841f, -0.06510198f, 0.02136912f, 
    -0.12950358f, -0.06745756f, 0.06453717f, 0.04262372f, 0.22121935f, -0.17986736f, 0.14234881f, 0.05946513f, 
    0.02129979f, 0.00976212f, -0.10368339f, -0.02694361f, -0.03702739f, 0.02531303f, 0.05229415f, -0.09907371f, 
    -0.24970022f, 0.00622308f, 0.09971484f, 0.01624682f, 0.09634665f, -0.00804963f, 0.02490475f, 0.05706494f, 
    0.05691571f, 0.00416306f, 0.02064144f, 0.12449451f, -0.08410782f, -0.08268681f, -0.06295687f, 0.02056806f, 
    0.08952323f, 0.09379262f, -0.03581022f, -0.00575144f, -0.01899213f, 0.06689110f, 0.09834997f, -0.05901685f, 
    0.01123204f, -0.12398653f, 0.26363263f, -0.05277893f, 0.04358625f, 0.07881659f, 0.06436375f, -0.09817094f, 
    -0.03622210f, -0.02314006f, 0.18767196f, 0.04068538f, -0.22702111f, -0.07452016f, 0.12108500f, 0.08867730f, 
    0.00022953f, 0.03023455f, -0.02427541f, -0.05700433f, 0.01052710f, -0.05862748f, 0.13335635f, 0.08670770f, 
    -0.02145196f, 0.21593195f, 0.20814350f, 0.11444743f, 0.07286432f, 0.00757816f, 0.09914998f, 0.10031836f, 
    -0.06342630f, -0.07837582f, 0.02949393f, -0.09456187f, -0.04664155f, -0.18842769f, 0.21367611f, -0.00992876f, 
    0.01722133f, 0.11868349f, -0.13300852f, 0.19323435f, 0.00092049f, -0.07333414f, 0.04864693f, 0.00239640f, 
    0.02487347f, -0.05939930f, 0.05949697f, -0.21586305f, -0.08962639f, 0.02877844f, 0.09003677f, 0.03363335f, 
    -0.11990000f, 0.19272284f, -0.04728004f, -0.02278503f, 0.25457853f, -0.35258606f, -0.01266258f, 0.31805983f, 
    0.01426058f, -0.13442802f, 0.07520952f, 0.01233538f, -0.06176107f, -0.02299436f, -0.07108635f, 0.04498230f, 
    -0.13910958f, 0.36874864f, 0.18886015f, -0.23634940f, -0.09542261f, 0.07778293f, -0.01872431f, -0.00796166f, 
    0.02276922f, -0.01663323f, -0.15930560f, -0.05699149f, 0.01487624f, 0.05874418f, -0.12298957f, 0.11385307f, 
    0.00142299f, 0.01140185f, 0.06057716f, -0.04862035f, -0.02485360f, 0.06031609f, 0.06077351f, -0.06399360f, 
    -0.17817926f, -0.04081903f, -0.14996725f, 0.05337843f, 0.13804191f, 0.10493871f, -0.05508479f, 0.09349871f, 
    -0.04194769f, -0.03693803f, 0.07866225f, 0.12341022f, 0.27733320f, 0.12244968f, 0.03072652f, -0.21340771f, 
    -0.00842283f, -0.03128810f, 0.08811084f, 0.04362088f, -0.04612109f, -0.08563731f, 0.03224752f, 0.02430692f, 
    -0.13806650f, -0.16556449f, -0.05273901f, 0.00312550f, 0.16357405f, -0.12699127f, 0.09854817f, -0.04238288f, 
    0.04603905f, -0.14054911f, 0.09936921f, 0.00584817f, 0.07960454f, 0.25417534f, 0.25562119f, 0.22764394f, 
    0.05161373f, 0.08705030f, -0.00601296f, -0.06069316f, -0.00773274f, -0.12693866f, -0.10412671f, 0.07892759f, 
    -0.15180856f, -0.13612117f, 0.07100366f, 0.08315580f, 0.03400313f, -0.01343783f, -0.00603486f, 0.02914750f, 
    -0.16062815f, -0.11351467f, 0.05013113f, -0.15674329f, 0.21911786f, 0.01510569f, 0.17081846f, -0.10189966f, 
    0.03105752f, 0.16736083f, 0.05019481f, 0.01012154f, 0.09645745f, 0.18456681f, 0.19862850f, 0.11663082f, 
    -0.05137969f, -0.05475739f, -0.01141820f, 0.00585996f, 0.06051290f, -0.03404117f, -0.04111793f, 0.05291265f, 
    0.05496592f, -0.04077121f, -0.06115639f, 0.04130273f, -0.00869289f, -0.02560794f, 0.05632989f, -0.05246514f, 
    -0.01822712f, -0.02713456f, -0.01883986f, -0.06489461f, -0.06119752f, -0.03020333f, -0.04810857f, -0.07847781f, 
    0.05008463f, -0.04621721f, -0.04329809f, -0.04926796f, 0.04165372f, -0.00627040f, -0.01684977f, -0.04622973f, 
    0.03969338f, 0.02765860f, 0.00195907f, -0.07519053f, 0.00310079f, -0.04327407f, 0.03806151f, 0.01621810f, 
    0.00950050f, -0.02683898f, 0.01429387f, 0.06490854f, 0.03381935f, -0.04009212f, 0.06135880f, -0.05150317f, 
    -0.04959346f, -0.02919074f, -0.01734529f, 0.04151890f, -0.03095133f, 0.01963601f, 0.00413226f, -0.07889076f, 
    -0.01067723f, 0.03206793f, -0.04729133f, 0.04487979f, 0.02280608f, -0.05797539f, -0.05900758f, -0.03143771f, 
    0.03445646f, -0.06421129f, 0.01474543f, -0.08040126f, -0.02851195f, 0.03091485f, 0.02575433f, -0.05923669f, 
    -0.00606051f, 0.06306875f, -0.07828943f, -0.06651048f, 0.05818494f, 0.01717114f, 0.02883446f, -0.00235083f, 
    -0.06086696f, 0.00290214f, 0.01204141f, 0.03763096f, -0.07910057f, 0.04015319f, 0.01555345f, -0.06909063f, 
    0.00913466f, 0.02226738f, 0.05998186f, -0.05855338f, -0.07598020f, 0.05418297f, 0.02732716f, -0.03059665f, 
    0.05285601f, 0.05933876f, 0.03004402f, -0.07002868f, -0.04388328f, 0.03506074f, -0.06905828f, 0.01518151f, 
    -0.07661469f, -0.00089816f, -0.04012412f, -0.01997781f, -0.02571307f, 0.00737306f, -0.05469052f, -0.00524469f, 
    -0.00838197f, 0.01966375f, 0.04148538f, -0.04978434f, 0.02651642f, 0.04274669f, 0.05301565f, -0.06868654f, 
    -0.07953932f, -0.03905291f, 0.05115125f, 0.04610059f, -0.02836414f, -0.04150068f, -0.05105132f, -0.01091146f, 
    -0.04461751f, 0.04799086f, -0.04244890f, 0.01540656f, 0.00926375f, 0.03081126f, 0.03796138f, -0.05970868f, 
    -0.01200885f, -0.03925749f, -0.03790520f, -0.07015281f, 0.04022393f, 0.02534785f, 0.06322771f, 0.05345870f, 
    -0.04840661f, -0.03138229f, -0.05777373f, 0.04131721f, -0.06824184f, -0.06143419f, -0.08029277f, -0.02861616f, 
    0.06302101f, 0.04559592f, -0.07858878f, 0.02914218f, 0.00753635f, -0.06536696f, -0.04414174f, -0.00531082f, 
    -0.02420558f, -0.04760126f, -0.05827545f, 0.00942292f, -0.07308600f, 0.03194497f, -0.07355965f, 0.02111453f, 
    0.02679310f, 0.03937251f, -0.04220615f, -0.06565206f, -0.01717581f, -0.06849948f, 0.00244934f, -0.05591089f, 
    0.05537617f, 0.00482726f, 0.02011197f, -0.03180390f, 0.00414472f, -0.00025651f, -0.03920639f, -0.01577219f, 
    -0.07514738f, 0.01974258f, 0.06846955f, -0.07362838f, -0.00554676f, 0.05306693f, -0.00880985f, -0.06571501f, 
    0.16961242f, -0.03334477f, 0.04405212f, -0.10521271f, -0.17167659f, -0.03346899f, 0.00282507f, 0.00938053f, 
    -0.06173124f, 0.11937647f, 0.03688831f, -0.10917068f, 0.07441076f, 0.15641814f, 0.15517251f, 0.28034583f, 
    0.01401778f, 0.01654497f, 0.13687339f, -0.01826780f, 0.12195800f, -0.11867600f, -0.01492966f, -0.03020529f, 
    0.19790468f, 0.05749213f, -0.11427766f, 0.07416445f, -0.10609419f, 0.02579959f, -0.00315113f, 0.03138630f, 
    0.07388864f, -0.01064477f, -0.10524415f, -0.14323322f, 0.33331224f, -0.01896759f, -0.05696256f, -0.09615856f, 
    -0.02935531f, 0.05530742f, 0.06988592f, 0.00353797f, -0.02447129f, 0.07493735f, 0.00964837f, -0.04716879f, 
    -0.00638459f, -0.01725213f, -0.16421111f, -0.03439913f, -0.01647920f, 0.09967344f, -0.17690472f, 0.15358959f, 
    0.10396312f, 0.12293389f, 0.10364980f, -0.01343081f, 0.25852558f, -0.00871499f, -0.17579068f, -0.02799629f, 
    0.05469478f, -0.04017936f, 0.03596391f, -0.12775767f, 0.03393561f, 0.04118516f, -0.04347629f, 0.03911967f, 
    -0.11148147f, 0.02802410f, -0.00571983f, 0.01934089f, 0.03811476f, -0.04206260f, -0.04634537f, 0.11827640f, 
    0.15130974f, -0.08516658f, 0.04563025f, -0.12911822f, -0.16424596f, 0.24211502f, 0.20382155f, -0.10078836f, 
    0.05686821f, 0.01584624f, 0.06455182f, -0.10462766f, 0.06571169f, 0.10645642f, 0.02380945f, -0.07095642f, 
    0.21155635f, -0.18190858f, -0.22295555f, 0.19342336f, 0.12666565f, 0.11744430f, 0.07937599f, -0.11585713f, 
    -0.06695186f, -0.03240433f, 0.11925896f, 0.02036808f, -0.24538171f, -0.15261734f, 0.04811230f, -0.16888893f, 
    -0.01762293f, -0.02602189f, -0.09681167f, -0.00059135f, 0.08705102f, 0.07464623f, -0.05529094f, -0.02177654f, 
    -0.09000506f, 0.06261894f, 0.28922909f, 0.05914010f, -0.06565585f, 0.02926007f, -0.01018411f, -0.06628016f, 
    0.02570087f, 0.11860918f, 0.00241463f, 0.03024837f, -0.13364401f, -0.02438345f, 0.09208120f, 0.18281545f, 
    0.02435527f, 0.01863036f, -0.02746462f, -0.04884578f, 0.09084369f, 0.07712679f, -0.01346746f, 0.09146344f, 
    0.21636227f, 0.30884439f, 0.22135988f, 0.26082152f, -0.04249449f, 0.00240947f, -0.09917564f, 0.13852905f, 
    0.06071931f, 0.03453845f, 0.11369102f, 0.09292575f, 0.13081793f, 0.00714053f, -0.21784954f, 0.05808122f, 
    -0.00731536f, -0.13827977f, 0.02231513f, -0.01207791f, 0.01209142f, 0.15385586f, 0.16850798f, 0.00307487f, 
    -0.10412798f, -0.00035834f, -0.14975959f, -0.02061848f, -0.05083714f, -0.01425292f, 0.04448867f, -0.03694354f, 
    0.14628117f, 0.15695292f, 0.06955969f, 0.04563916f, -0.24624497f, 0.09793081f, -0.10615836f, -0.03981027f, 
    -0.01153259f, -0.05997675f, 0.02275043f, 0.03811414f, 0.03339659f, -0.05206766f, -0.04862761f, 0.11236203f, 
    0.03854664f, -0.29666838f, 0.09062877f, 0.01248629f, -0.11490594f, 0.00043784f, -0.13237731f, 0.00580774f, 
    -0.01949916f, -0.03519345f, 0.07020967f, 0.01569099f, 0.11707833f, -0.01619323f, 0.03765142f, -0.17726484f, 
    0.04998923f, -0.12235802f, 0.04662335f, -0.08724836f, 0.10291108f, -0.19312961f, 0.07046580f, 0.05909820f, 
    0.26912236f, -0.19423126f, 0.11141697f, -0.00842270f, -0.06869903f, -0.09471845f, 0.12293939f, -0.03208966f, 
    -0.02223697f, 0.02755091f, 0.07326331f, 0.15767822f, 0.16945888f, 0.04149416f, 0.03083432f, -0.00914855f, 
    -0.00627165f, -0.09772503f, 0.08946873f, -0.14652959f, -0.10132226f, -0.00672744f, 0.06809714f, 0.02019319f, 
    -0.19237748f, 0.21807081f, -0.09640577f, 0.13780592f, -0.04103835f, 0.04300036f, -0.00973330f, 0.07682619f, 
    -0.10949156f, -0.01342665f, 0.02771303f, 0.02904624f, -0.13539679f, 0.14852455f, -0.10000049f, -0.16967607f, 
    0.11944162f, 0.11434040f, 0.05137943f, 0.02077951f, 0.02509030f, -0.26090783f, -0.01851628f, -0.14057016f, 
    0.03861850f, -0.00583805f, -0.04939431f, 0.04225925f, 0.02825720f, 0.15103742f, -0.05548232f, 0.06460595f, 
    0.01624534f, 0.21004531f, -0.08176737f, 0.05973198f, 0.14377983f, -0.07472092f, -0.13564050f, 0.05430490f, 
    0.00882862f, 0.07199737f, 0.02916558f, -0.02138866f, 0.04876013f, 0.09711623f, 0.00777142f, 0.04738081f, 
    0.33290061f, 0.22431330f, 0.11124293f, 0.01596129f, -0.06250726f, 0.03534626f, 0.02881710f, 0.07858036f, 
    0.03145292f, 0.00120523f, -0.01067519f, -0.04454456f, 0.00656458f, -0.03663293f, 0.14722976f, -0.12131145f, 
    -0.10238127f, 0.07992610f, 0.13091525f, 0.09375621f, 0.02826294f, -0.02902751f, 0.04815833f, 0.01830841f, 
    0.08698405f, 0.03698703f, -0.03880794f, -0.21426339f, 0.01313617f, 0.02188327f, 0.03038911f, 0.06728610f, 
    0.06437036f, -0.01493629f, -0.07509830f, 0.08298186f, -0.06377897f, -0.05848929f, -0.00465843f, 0.25211218f, 
    -0.11161411f, -0.10714208f, 0.01273053f, -0.05577348f, -0.07969593f, 0.03558184f, 0.05458891f, 0.06507523f, 
    -0.06975128f, -0.23089036f, -0.13477224f, 0.04622392f, -0.01295207f, -0.06200940f, -0.00616593f, 0.02409459f, 
    0.03804965f, 0.02010308f, 0.08564180f, -0.02895298f, 0.07118430f, 0.03799889f, -0.06901834f, 0.16916353f, 
    -0.01484707f, 0.08005322f, -0.03602032f, 0.06806523f, 0.00887441f, -0.03178982f, -0.04674926f, 0.01941921f, 
    -0.15675417f, 0.17098938f, -0.13674907f, -0.11699708f, 0.14450687f, 0.02669965f, -0.00489553f, 0.08602185f, 
    -0.10955925f, 0.02736346f, 0.05657768f, 0.00014290f, 0.42710540f, -0.33873117f, 0.10635661f, 0.04078379f, 
    -0.01773147f, 0.02435429f, 0.04317921f, 0.08784036f, 0.02573460f, 0.08533186f, 0.10589689f, 0.00875250f, 
    -0.00067236f, -0.00013579f, -0.00348360f, 0.01330771f, -0.05034871f, -0.07398101f, -0.01165732f, -0.06961438f, 
    0.06324760f, 0.02439748f, -0.06240399f, 0.00107086f, -0.00490411f, -0.04730060f, -0.03695468f, 0.00883108f, 
    0.05411441f, -0.04897707f, -0.01047241f, 0.03380226f, -0.04694374f, -0.03460654f, -0.01181420f, 0.04662502f, 
    -0.06778133f, 0.02853309f, 0.02725878f, -0.07345811f, 0.04919827f, 0.00269794f, 0.01615663f, -0.03270166f, 
    -0.07622872f, -0.04072050f, 0.04991600f, 0.00172498f, -0.05486442f, -0.01884496f, -0.06249244f, -0.00502234f, 
    -0.03581244f, 0.02217782f, 0.05144640f, -0.00856364f, -0.02800289f, 0.03209684f, 0.04123843f, 0.02338321f, 
    0.06110846f, -0.01338481f, -0.06862056f, -0.05799725f, 0.02884453f, -0.06946287f, 0.03177114f, -0.00530749f, 
    -0.01548454f, 0.04834665f, 0.04217619f, 0.00041644f, 0.00580375f, 0.02819841f, 0.03945132f, 0.01770971f, 
    -0.04382201f, 0.00533179f, 0.02327921f, -0.02269858f, -0.03381291f, 0.02908930f, -0.05912001f, 0.00490164f, 
    -0.01736015f, -0.02900650f, -0.00358368f, -0.01310195f, -0.06402518f, -0.05974112f, 0.05524905f, -0.06795714f, 
    -0.00337299f, -0.04472491f, -0.03747928f, 0.00530412f, -0.04967082f, 0.02180870f, -0.01153296f, -0.00981740f, 
    0.00516107f, 0.02459575f, -0.01280272f, -0.04060308f, -0.00916164f, -0.02477076f, -0.03244296f, -0.07183561f, 
    -0.01737713f, -0.02769785f, 0.04596949f, -0.04161208f, -0.04583418f, -0.03855599f, -0.04928377f, 0.00562313f, 
    0.04246550f, 0.04719574f, -0.00358583f, -0.00131683f, -0.06067085f, 0.00764384f, -0.04707452f, -0.04755544f, 
    0.06137612f, -0.00322969f, -0.01188998f, 0.01242217f, 0.02886860f, -0.01131075f, 0.03220721f, -0.04232287f, 
    -0.07518300f, -0.00305027f, -0.06961308f, 0.03065882f, -0.06120975f, -0.04141470f, 0.01157393f, -0.06918575f, 
    -0.07058267f, 0.06687018f, -0.07635503f, -0.00318875f, 0.03241096f, -0.00202858f, -0.04048827f, -0.05398591f, 
    -0.02369836f, 0.06369808f, -0.00920876f, -0.05108879f, 0.04225796f, -0.01874199f, -0.05753470f, 0.05900403f, 
    0.02658196f, -0.05648801f, -0.07438992f, 0.05583348f, -0.03627396f, -0.03967589f, -0.07180323f, 0.01202223f, 
    -0.00433518f, -0.00216953f, -0.02948286f, -0.01346351f, -0.00994774f, 0.04032905f, 0.06441639f, -0.05029942f, 
    -0.06787820f, 0.01631815f, -0.00546994f, 0.03115638f, -0.00345126f, -0.06664608f, -0.03546170f, 0.02063101f, 
    -0.00440542f, 0.04285978f, -0.06855061f, -0.06806563f, 0.01309775f, 0.06066047f, -0.02466760f, 0.06123557f, 
    -0.06904205f, 0.05528412f, -0.04375258f, 0.05538808f, 0.01696471f, -0.01626252f, 0.00762542f, -0.04982362f, 
    0.02944467f, -0.04069830f, 0.01175656f, -0.07078166f, 0.05211093f, 0.03703318f, -0.06006885f, -0.00079345f, 
    0.09351583f, -0.19226043f, 0.11661862f, -0.17478342f, 0.00122285f, 0.04636315f, -0.13583353f, 0.12257587f, 
    0.01107651f, 0.08339971f, 0.01918766f, 0.10131008f, -0.11167037f, 0.06764841f, 0.01535733f, 0.14784260f, 
    -0.00869023f, 0.00658931f, -0.00564075f, -0.02104702f, -0.02617497f, 0.00677272f, 0.19362442f, -0.00916936f, 
    0.33825058f, -0.25540721f, 0.13676493f, 0.11669134f, 0.01352932f, -0.01948655f, 0.02560952f, -0.09649730f, 
    -0.00196567f, 0.13092017f, 0.17972156f, 0.05169232f, 0.18481837f, -0.17360426f, 0.22908390f, 0.10233858f, 
    0.03409666f, -0.02869229f, 0.07232704f, -0.03422270f, -0.09003588f, -0.09121570f, -0.01917092f, 0.02225039f, 
    -0.09530311f, 0.11489905f, 0.11207221f, 0.18646438f, 0.14448029f, 0.09737749f, 0.11591959f, -0.11008114f, 
    -0.02381802f, 0.04007997f, 0.01040997f, 0.08897810f, 0.19892183f, -0.20889425f, -0.13630734f, -0.14699487f, 
    0.11539571f, 0.18471722f, 0.01682264f, 0.05771655f, -0.04451329f, -0.19362538f, -0.01973030f, -0.03199991f, 
    -0.14509262f, -0.06117488f, -0.10410967f, -0.09234279f, -0.04603625f, 0.01891133f, -0.05746548f, 0.13670295f, 
    -0.04114822f, 0.01043678f, -0.01215830f, 0.02807046f, 0.33881456f, -0.28003037f, -0.25214079f, -0.06719352f, 
    0.03927873f, 0.10014462f, 0.06554238f, -0.07134958f, 0.02535430f, 0.09254164f, 0.05798368f, 0.11922689f, 
    0.07311945f, 0.42577061f, -0.02658716f, -0.10044309f, 0.21752584f, 0.12364203f, -0.02406072f, 0.01422374f, 
    -0.05175320f, 0.03845289f, -0.04379337f, -0.00220685f, -0.05819819f, 0.30382243f, -0.05618579f, -0.04521098f, 
    0.02593923f, -0.01831800f, 0.11943087f, -0.09849762f, 0.03776857f, 0.06858354f, -0.01761002f, -0.00071085f, 
    0.09770975f, -0.29279348f, -0.07784391f, 0.16011775f, -0.08064426f, -0.11007854f, -0.12046914f, 0.12283683f, 
    -0.03000724f, -0.00077941f, 0.02536320f, -0.05762164f, 0.17372942f, 0.19171087f, 0.14073880f, -0.15712367f, 
    0.07500953f, -0.04140336f, -0.12357024f, -0.10360926f, -0.09806571f, 0.01746404f, -0.00303151f, -0.02882445f, 
    -0.05451828f, 0.02113470f, -0.17751367f, -0.00529591f, -0.14926982f, -0.07733156f, 0.05200082f, -0.04494333f, 
    -0.12126407f, -0.11188127f, 0.02350043f, -0.05660997f, -0.18668567f, 0.14034854f, 0.06447878f, -0.08909930f, 
    0.19409718f, 0.12068269f, 0.06732414f, -0.03526153f, 0.01535952f, 0.06986339f, -0.01897116f, 0.06183888f, 
    -0.20955589f, 0.01993722f, -0.11773830f, -0.10608855f, 0.08791403f, 0.06801255f, 0.05274929f, -0.07278879f, 
    -0.00525325f, 0.09343126f, 0.13782786f, -0.01678479f, 0.43219548f, -0.48689488f, -0.10759764f, -0.18800755f, 
    -0.05810503f, -0.03233151f, 0.09276698f, 0.01068089f, 0.06153227f, 0.07519936f, 0.18517672f, 0.11972233f, 
    0.02459801f, -0.07909597f, 0.19434193f, 0.07519861f, 0.03191097f, -0.05928678f, -0.05492268f, 0.08263459f, 
    0.00291344f, -0.08191232f, 0.01762722f, -0.00619424f, -0.05130328f, -0.01670283f, -0.21021800f, -0.25739896f, 
    -0.13528056f, 0.05159284f, -0.11852050f, 0.10495369f, 0.01171119f, -0.00521472f, 0.02105490f, 0.05825225f, 
    -0.07490980f, -0.19811824f, -0.02273126f, 0.11050531f, 0.00448522f, -0.03528659f, -0.01171018f, -0.07374199f, 
    0.00374968f, -0.01037234f, -0.01083814f, 0.10168048f, -0.29208860f, -0.10269744f, 0.12041995f, 0.19763288f, 
    0.06797786f, 0.13005000f, -0.10847810f, -0.07421762f, 0.07130096f, 0.09484112f, 0.00000873f, -0.03083475f, 
    0.47121760f, 0.12839006f, 0.16942300f, 0.08763281f, 0.08025222f, 0.02407893f, 0.04015305f, 0.00264287f, 
    0.08615211f, -0.01774471f, -0.04478113f, 0.00219028f, -0.01561747f, -0.10953050f, -0.00508423f, 0.03367684f, 
    -0.04868272f, 0.10415169f, -0.03192217f, 0.08421385f, 0.02868232f, 0.04735770f, 0.12638876f, 0.15226747f, 
    0.01697349f, 0.01244959f, -0.00270058f, 0.02381815f, -0.03833055f, 0.12438381f, 0.11120561f, -0.01785414f, 
    0.04955919f, -0.02528833f, 0.06894130f, 0.19241072f, -0.19286430f, -0.06066578f, -0.05961996f, 0.03481315f, 
    -0.08351483f, -0.01511551f, 0.05091684f, 0.14635760f, -0.08416133f, -0.01386437f, -0.01050224f, 0.10986382f, 
    -0.15409824f, 0.26644701f, -0.08053000f, -0.02232981f, -0.10847709f, 0.02691550f, 0.01978828f, 0.07810313f, 
    0.03776136f, 0.05818570f, -0.01046837f, -0.01038937f, 0.30801785f, 0.14978926f, -0.15739833f, 0.02976663f, 
    0.08806473f, 0.04693697f, 0.05991554f, 0.01929071f, 0.11501557f, 0.05699243f, 0.04136791f, -0.00362226f, 
    -0.09767124f, -0.02480187f, -0.15432312f, -0.15264219f, -0.04191655f, 0.02417319f, 0.10959148f, -0.05579755f, 
    0.11420716f, -0.00365159f, 0.13471918f, -0.04915282f, 0.31293789f, 0.07865087f, 0.08677548f, -0.15975133f, 
    0.01456454f, -0.00354298f, 0.10198583f, 0.09334597f, -0.16291164f, -0.03476723f, -0.08451637f, 0.06290206f, 
    -0.31484014f, 0.02573096f, -0.01610746f, -0.18314222f, -0.05667015f, 0.01988150f, 0.09616374f, -0.02742184f, 
    -0.00333743f, 0.00039561f, 0.02499382f, -0.07470645f, 0.02577172f, -0.10044646f, 0.13744360f, 0.03243241f, 
    -0.01142257f, 0.08109255f, -0.03381316f, -0.07268727f, 0.11403166f, -0.06019974f, -0.02019904f, 0.08190907f, 
    0.14529561f, 0.11512879f, 0.01676894f, 0.04347146f, 0.00077040f, 0.05784679f, 0.05927476f, 0.20255113f, 
    -0.03802473f, -0.07760426f, 0.05393684f, 0.07599445f, 0.03951307f, -0.17370002f, -0.13620910f, 0.16807599f, 
    0.05860928f, 0.10239006f, 0.07403428f, -0.17295741f, -0.04743843f, 0.00696865f, 0.04722983f, 0.02255405f, 
    -0.04181075f, 0.01264093f, 0.05840689f, 0.19569944f, 0.04607329f, -0.04784302f, -0.08475585f, 0.04866045f, 
    0.00078858f, -0.03492592f, 0.03200851f, 0.02329977f, -0.15607196f, -0.12582915f, 0.23355535f, -0.05339080f, 
    0.15798225f, 0.00302322f, 0.03731696f, 0.06797451f, -0.12606597f, -0.09126367f, -0.04761469f, 0.13894443f, 
    0.08409960f, -0.09102780f, 0.08053783f, 0.09340620f, -0.07061230f, 0.03183408f, 0.06754961f, -0.00590540f, 
    0.03986245f, -0.00098417f, 0.15858042f, 0.05402977f, -0.03758565f, 0.08569712f, 0.09998921f, -0.16383831f, 
    0.08917882f, -0.10438471f, 0.08007330f, -0.04019443f, 0.07828175f, -0.06352144f, 0.13028151f, 0.03729338f, 
    0.01420220f, 0.18445505f, -0.08880100f, -0.04480343f, 0.02463489f, -0.03307566f, 0.03701014f, 0.08194878f, 
    -0.12110503f, -0.06401588f, -0.07882422f, -0.06127753f, -0.21352057f, 0.07028716f, 0.06645226f, -0.35868132f, 
    0.08932956f, 0.11773230f, 0.07755437f, 0.00886924f, 0.03610548f, -0.09814503f, -0.04870929f, -0.02683442f, 
    -0.34557369f, 0.00813116f, -0.05816895f, -0.16226278f, 0.02004931f, 0.14896654f, -0.01512930f, 0.08409194f, 
    -0.04951233f, 0.26511079f, -0.04147756f, 0.06019141f, 0.23077810f, -0.12912957f, -0.08565805f, 0.07202669f, 
    0.02313021f, 0.02236273f, -0.03005566f, -0.00424510f, 0.05828750f, 0.03160144f, -0.01964331f, 0.13466427f, 
    0.31329849f, 0.22280155f, 0.05699104f, 0.00897247f, 0.01164397f, 0.00395623f, -0.01436521f, 0.08839446f, 
    0.04243017f, 0.07975364f, 0.03836112f, -0.00179996f, 0.02495558f, 0.08373025f, 0.12018913f, -0.17740683f, 
    -0.06091875f, 0.09735797f, 0.09154610f, -0.19568804f, 0.02504279f, 0.03466654f, 0.12347481f, 0.04845197f, 
    -0.28523886f, 0.02049767f, -0.07726277f, -0.08274470f, 0.02343840f, 0.08200253f, -0.08169776f, 0.02457434f, 
    0.05142258f, 0.11594857f, 0.05396296f, 0.11637004f, 0.06426148f, 0.06102186f, -0.03744669f, 0.15000214f, 
    -0.03866404f, -0.02494866f, 0.03079539f, -0.13508402f, 0.10555757f, -0.05012038f, 0.02492343f, 0.02041666f, 
    -0.21789527f, -0.16598225f, -0.22750087f, 0.03681010f, 0.01765891f, -0.05141898f, 0.09557923f, 0.02851665f, 
    0.13098675f, 0.04352442f, -0.05514197f, -0.03733768f, 0.05863146f, 0.26459044f, -0.01372947f, -0.07986923f, 
    0.04920665f, 0.10297036f, 0.08498556f, -0.05695947f, 0.05357105f, -0.12763484f, -0.01843760f, 0.00482204f, 
    -0.01379644f, 0.20099552f, 0.00909562f, -0.26518860f, 0.03658619f, 0.12622897f, 0.01826292f, -0.10734084f, 
    -0.00576381f, -0.01420223f, 0.00838457f, -0.00237408f, 0.17427228f, -0.18059754f, 0.09000421f, -0.10116325f, 
    0.09530938f, -0.06355763f, 0.15991829f, 0.02921546f, 0.01760970f, 0.17073487f, 0.09610789f, 0.03185027f, 
    -0.02888868f, 0.04022071f, -0.04885428f, -0.07269956f, -0.01964461f, -0.02447330f, 0.00006118f, 0.00306878f, 
    0.04088974f, -0.07636089f, 0.02292779f, 0.01950604f, -0.04511561f, 0.01312950f, -0.01890120f, -0.06175607f, 
    -0.08004145f, 0.05278449f, 0.00902059f, 0.02049209f, 0.01619593f, -0.06515740f, -0.06499182f, 0.01248005f, 
    -0.03443160f, -0.05111193f, -0.00525873f, 0.01062175f, 0.01919552f, 0.05704007f, 0.02492459f, -0.04206050f, 
    -0.07691515f, -0.06962494f, -0.06597330f, -0.02063008f, -0.06747327f, 0.04194622f, -0.04051125f, -0.00982028f, 
    0.05768677f, 0.01690789f, 0.02188306f, 0.05098127f, -0.03226120f, -0.07870048f, -0.08116722f, -0.00482932f, 
    0.02365246f, -0.05540428f, -0.04869108f, -0.08080439f, 0.02883894f, -0.02191607f, 0.00999485f, -0.05628324f, 
    0.02594942f, -0.00856528f, -0.04531913f, 0.04091559f, -0.00012340f, -0.02607532f, -0.06863412f, -0.00116230f, 
    0.01884500f, 0.02721586f, -0.07246358f, -0.03333025f, 0.00592498f, -0.02392330f, -0.01849174f, 0.00581852f, 
    0.02104622f, 0.04774736f, -0.04678604f, 0.00927615f, 0.02344546f, 0.01230458f, -0.04882517f, 0.01323825f, 
    0.01370651f, -0.07386193f, 0.00144687f, -0.01235428f, 0.02966631f, 0.03609988f, -0.05750661f, -0.02816503f, 
    0.03919689f, -0.02352580f, -0.04180866f, 0.02063399f, -0.04244317f, -0.04759572f, -0.05210718f, -0.01716228f, 
    -0.07723639f, 0.03360416f, -0.00164730f, -0.01496484f, 0.04721660f, 0.04918689f, 0.02827422f, 0.03909747f, 
    0.04368580f, -0.02965165f, -0.02293272f, -0.06257854f, 0.05112316f, -0.07337201f, 0.04831493f, 0.02558479f, 
    -0.02084716f, -0.01186799f, -0.04772412f, -0.05748921f, 0.05753667f, -0.01257035f, -0.03573590f, -0.03496237f, 
    -0.06081530f, 0.00188053f, -0.05440186f, -0.04954010f, -0.03242462f, -0.00868412f, 0.04311462f, 0.02446730f, 
    0.04047487f, -0.00634057f, 0.03681068f, -0.07260965f, 0.06661785f, -0.05623536f, 0.01193858f, 0.03478928f, 
    -0.03068034f, 0.02267515f, -0.07736061f, 0.02395342f, -0.01287535f, -0.05275106f, 0.04313812f, -0.06918588f, 
    -0.02324645f, 0.01275679f, -0.02886295f, -0.05081394f, 0.02793217f, 0.02657770f, 0.00240863f, 0.00147964f, 
    -0.03321154f, -0.00774360f, 0.02809067f, 0.00093834f, 0.00634979f, 0.00280542f, 0.01640745f, -0.03507885f, 
    -0.07650902f, -0.07709818f, -0.05116010f, -0.00239217f, 0.03792317f, 0.04493110f, -0.02683949f, 0.05750017f, 
    0.01382067f, 0.04814016f, 0.00313357f, -0.02662548f, 0.03587195f, 0.05685950f, -0.06363245f, 0.02236704f, 
    0.02113431f, -0.05957676f, 0.03158282f, 0.02272428f, -0.03020375f, 0.00461816f, -0.01703227f, -0.05814745f, 
    0.02902019f, 0.05313889f, 0.00672216f, -0.00722753f, 0.01610508f, 0.01929096f, -0.02094854f, -0.05673158f, 
    0.17740859f, -0.09550533f, 0.09808130f, -0.14679724f, 0.16930988f, 0.00063971f, -0.14555371f, 0.05134133f, 
    -0.04273409f, 0.04623524f, 0.12857261f, -0.01562484f, 0.01413680f, -0.05358704f, -0.13102603f, -0.12650882f, 
    -0.02347718f, -0.11567964f, -0.17240220f, 0.03683106f, 0.16759394f, -0.01361896f, 0.15769054f, 0.02332058f, 
    0.24133335f, -0.26197359f, -0.03469778f, 0.06688552f, 0.03468398f, -0.07872182f, -0.02995198f, 0.02528462f, 
    0.01510703f, 0.00208535f, 0.05374403f, 0.08732706f, 0.10045204f, -0.04413822f, -0.01618418f, 0.15520434f, 
    -0.15065522f, 0.05932464f, 0.09781513f, -0.04570944f, -0.00603773f, 0.07349296f, 0.10396630f, -0.07858616f, 
    -0.18656568f, 0.00848333f, 0.08685691f, 0.09890421f, 0.19800577f, 0.03965648f, 0.15073985f, -0.15153916f, 
    -0.05247239f, 0.03942814f, 0.04488626f, 0.06276783f, -0.10406093f, -0.00441303f, -0.12271722f, -0.05590823f, 
    0.03909408f, -0.05869450f, 0.05566056f, 0.01003903f, -0.05315205f, 0.10058202f, 0.11301500f, 0.01109584f, 
    -0.04738464f, 0.10129017f, 0.08280039f, 0.09508841f, -0.06277085f, 0.01527877f, -0.00097608f, 0.08849365f, 
    0.07392168f, -0.18579917f, 0.14560165f, -0.04136970f, 0.28472412f, -0.25607851f, -0.35425004f, 0.03623280f, 
    -0.02147280f, 0.02815004f, 0.03674290f, 0.01165783f, -0.03981933f, 0.06308425f, -0.06716307f, 0.09987085f, 
    0.01229345f, 0.17912526f, -0.09572680f, -0.27372676f, 0.20080476f, 0.03201748f, -0.03354692f, 0.07641117f, 
    0.06011020f, 0.10825055f, 0.04321304f, 0.11888863f, 0.02067068f, 0.24434145f, -0.09897967f, 0.17522991f, 
    -0.12144616f, 0.01102710f, 0.07299943f, 0.22391169f, 0.14319548f, -0.02452519f, 0.10545153f, 0.01156796f, 
    0.26815549f, -0.22965169f, -0.21081027f, -0.02897599f, -0.08999204f, -0.10306476f, -0.07939728f, 0.05540721f, 
    0.04531030f, -0.11330415f, 0.00763073f, -0.03093679f, -0.11436033f, 0.12458695f, 0.10722243f, -0.18826030f, 
    0.16031548f, 0.04725161f, 0.04091582f, 0.01884984f, 0.04891372f, 0.04822878f, 0.00167234f, 0.04638412f, 
    -0.02642584f, -0.04918698f, -0.05073434f, 0.03282205f, -0.11394531f, 0.00589868f, -0.01159764f, 0.05708303f, 
    -0.02647909f, 0.10128041f, 0.16632189f, -0.08192029f, -0.30682302f, 0.00218473f, 0.15853788f, -0.12096900f, 
    0.20534414f, 0.00989016f, 0.13285188f, 0.02280377f, 0.03655543f, 0.12415709f, 0.00752449f, -0.02700728f, 
    -0.21704108f, -0.13624491f, 0.02742309f, -0.04405522f, 0.13784012f, 0.08200128f, 0.11649327f, 0.14711720f, 
    0.04151454f, 0.03902477f, 0.15109876f, 0.07902902f, 0.33882076f, -0.33886033f, -0.17997359f, -0.12483688f, 
    -0.00582829f, 0.01618452f, 0.01615426f, -0.14557104f, 0.07258867f, -0.02368336f, -0.10036658f, -0.11270504f, 
    -0.02520241f, -0.05059064f, -0.03127469f, 0.04485872f, 0.05169244f, 0.03947209f, 0.01254348f, -0.06696090f, 
    -0.03894616f, 0.05847972f, 0.03833120f, -0.05827118f, 0.00060887f, -0.05091447f, 0.05589377f, -0.07530102f, 
    -0.03265433f, 0.00460806f, -0.05198421f, 0.02357879f, 0.05122868f, -0.04130359f, 0.02535717f, 0.01784345f, 
    -0.03114808f, 0.01942960f, -0.07550411f, 0.05755226f, -0.05709202f, 0.05091241f, 0.02657974f, -0.05511826f, 
    -0.07057335f, 0.03180724f, 0.01173712f, -0.04923483f, -0.06320196f, -0.07041427f, -0.04068957f, 0.04237566f, 
    0.06122173f, -0.01597960f, -0.05574222f, 0.02706336f, 0.02638756f, -0.07437255f, -0.06365635f, 0.06550049f, 
    -0.02548946f, 0.00950740f, 0.06207645f, -0.03728522f, -0.00980731f, -0.03973434f, 0.05452041f, 0.01851309f, 
    0.04355233f, -0.03723302f, -0.06623770f, 0.03135829f, -0.07770066f, -0.03475811f, 0.04645007f, 0.02722939f, 
    -0.05914757f, -0.02406661f, -0.02210215f, -0.05368982f, -0.03135638f, 0.00058045f, -0.01407027f, -0.06833009f, 
    -0.00203637f, -0.04843729f, -0.05811972f, 0.05289670f, 0.02861300f, 0.02461782f, 0.01090593f, -0.04717973f, 
    -0.07537401f, -0.04509982f, 0.05370747f, 0.02675478f, -0.05830903f, -0.03770106f, -0.06017443f, -0.00673484f, 
    0.06419352f, -0.00722746f, -0.04094601f, -0.03851113f, -0.03501929f, 0.01179814f, 0.01895486f, 0.00832501f, 
    -0.02137108f, -0.02477084f, -0.03438649f, 0.00576876f, -0.01972489f, -0.05960050f, 0.02340073f, 0.00515824f, 
    -0.04801878f, -0.02389769f, 0.01371354f, -0.04758282f, -0.00317647f, 0.03860499f, -0.01376460f, 0.04070082f, 
    -0.01579519f, -0.03583506f, -0.07004664f, 0.03735187f, 0.03432458f, -0.05522203f, -0.05166739f, -0.01175920f, 
    -0.01615630f, -0.03052238f, -0.02940517f, 0.01862838f, -0.06212078f, 0.04420425f, 0.01603509f, -0.07287278f, 
    0.00231679f, 0.01136695f, 0.05307261f, -0.05367392f, -0.06158710f, 0.04523212f, 0.02794478f, -0.06198504f, 
    0.03869831f, 0.01771319f, -0.07118236f, -0.03394195f, 0.05249203f, 0.00510797f, 0.03832297f, -0.07465295f, 
    -0.03022468f, -0.07595606f, -0.00405010f, 0.00322652f, -0.02913764f, 0.02757565f, -0.05442242f, 0.02664691f, 
    0.04846074f, 0.03709426f, 0.00193076f, -0.06623006f, 0.04656317f, 0.05745370f, 0.03698986f, 0.06124578f, 
    -0.06296324f, -0.04852784f, -0.00605833f, 0.05939680f, 0.05853833f, -0.07384011f, 0.01581935f, -0.06701201f, 
    -0.06103750f, -0.05503710f, -0.04021508f, -0.02735735f, -0.06045470f, 0.00807955f, -0.07676873f, 0.02165390f, 
    -0.00752086f, -0.01543311f, -0.02082368f, -0.07568760f, -0.03134723f, 0.07131191f, 0.02915173f, -0.05315789f, 
    -0.04032647f, -0.04339299f, -0.00662102f, 0.04989430f, -0.04662063f, -0.02798408f, 0.04582198f, -0.03887631f, 
    0.18131210f, -0.06867369f, 0.01261031f, -0.02289488f, 0.00962132f, 0.02757053f, -0.16923153f, -0.09391619f, 
    -0.01670216f, 0.10058918f, 0.11351501f, -0.18024637f, 0.23773624f, 0.01399837f, -0.01475214f, -0.05738479f, 
    -0.07554734f, 0.00500209f, -0.10693479f, -0.03622859f, 0.18191729f, -0.09552994f, 0.05070345f, 0.06311674f, 
    0.32741597f, -0.17577268f, -0.07093319f, 0.04706360f, 0.04717415f, -0.06431083f, 0.00292108f, 0.03902029f, 
    0.15111245f, 0.01247982f, -0.11802218f, 0.14831838f, 0.29112467f, 0.00676727f, -0.13266920f, 0.01075820f, 
    -0.10063154f, 0.12397826f, 0.09985205f, 0.03980039f, -0.04973687f, 0.03563134f, -0.00166278f, -0.01361309f, 
    -0.21983923f, -0.10148328f, -0.06506728f, 0.10627975f, 0.11721968f, -0.07912248f, 0.08850925f, -0.02912970f, 
    -0.02187668f, -0.05577821f, -0.04099319f, 0.03188240f, 0.04528336f, 0.21596545f, -0.15598841f, 0.07111873f, 
    0.08320232f, -0.01595481f, 0.03390830f, 0.01922973f, -0.07414547f, -0.01259660f, -0.05109714f, -0.08754878f, 
    0.21432611f, 0.17130323f, -0.02312468f, 0.13727398f, -0.00182220f, 0.04819123f, -0.09088763f, 0.00396549f, 
    0.05173562f, -0.21138440f, 0.03955396f, -0.02874442f, 0.21584989f, 0.10056912f, -0.19991870f, -0.13680653f, 
    0.11122259f, 0.08353302f, 0.08901526f, -0.05913966f, 0.15963481f, -0.01843400f, -0.08795688f, -0.01925624f, 
    -0.00315077f, -0.12189943f, -0.01271117f, -0.00693238f, 0.01783860f, -0.04001366f, -0.00338411f, -0.07168895f, 
    0.01939634f, 0.03772162f, 0.17282329f, 0.04111685f, -0.03866734f, 0.14720455f, 0.05854796f, 0.01527906f, 
    -0.12582165f, 0.01112955f, -0.07388994f, 0.22622731f, 0.06483123f, -0.00372851f, 0.02410406f, 0.00516176f, 
    0.45814046f, -0.05711890f, -0.07899417f, 0.04424278f, -0.03015405f, 0.00023093f, -0.09361684f, 0.04374007f, 
    -0.04752178f, 0.00444036f, -0.12282389f, 0.01312843f, -0.31570348f, 0.10028992f, 0.12849830f, 0.09175087f, 
    0.00989475f, 0.06985141f, -0.02649577f, 0.02082608f, 0.03258236f, 0.08552320f, -0.04592831f, -0.00814044f, 
    0.15310259f, 0.04633396f, 0.09898739f, 0.02258138f, -0.03207168f, -0.02879306f, -0.09240410f, 0.04192484f, 
    -0.07753085f, 0.10596960f, 0.05724230f, 0.00855702f, -0.18871355f, 0.00371639f, -0.06102720f, -0.09653446f, 
    0.04294542f, -0.03056506f, 0.12455399f, 0.14856791f, 0.02355224f, 0.13397938f, 0.13888809f, -0.04784854f, 
    -0.19308960f, -0.01957287f, -0.10372273f, -0.09383589f, 0.02982022f, 0.01673282f, 0.10014500f, 0.00106224f, 
    0.04175106f, 0.01464842f, 0.16456716f, 0.14132850f, 0.25097623f, -0.20740871f, -0.11003097f, 0.01465165f, 
    -0.00086006f, 0.01012502f, -0.03871171f, 0.09235725f, -0.00213465f, -0.15611547f, -0.07343158f, -0.16491050f, 
    0.32586610f, 0.20108417f, 0.08832102f, 0.29857701f, -0.15082902f, -0.02277097f, -0.01122144f, -0.00440388f, 
    0.12925543f, -0.07871825f, -0.06751273f, 0.00848187f, 0.25998494f, 0.20831706f, 0.04723857f, -0.11963075f, 
    -0.01489770f, -0.00795335f, 0.16268849f, -0.06254904f, 0.09046888f, 0.01111617f, 0.09343272f, -0.04152888f, 
    0.32337454f, 0.27494001f, 0.03750020f, 0.27764866f, -0.04593411f, 0.05860362f, -0.05777086f, -0.06929944f, 
    -0.08530548f, -0.01253259f, -0.06291033f, 0.19029602f, 0.49534616f, 0.21174785f, -0.12181299f, -0.13649438f, 
    -0.17778006f, -0.02986423f, -0.03451166f, 0.01800203f, -0.01571595f, 0.18842903f, -0.07479483f, 0.01341952f, 
    -0.15296078f, -0.10549170f, -0.02482990f, -0.01445738f, 0.03585171f, 0.06389990f, 0.10948078f, -0.09816253f, 
    -0.18934110f, -0.00737447f, -0.07726678f, 0.02421295f, -0.24347071f, 0.01080931f, -0.30390805f, -0.26975286f, 
    0.03941954f, 0.10616846f, 0.10072441f, 0.01876031f, -0.01088035f, -0.00580886f, -0.08197562f, -0.10516749f, 
    -0.07392289f, 0.08669978f, -0.28208345f, -0.03115300f, 0.02873276f, -0.00371151f, -0.03900294f, 0.10304710f, 
    0.15340050f, -0.08440999f, 0.05671229f, 0.16941437f, -0.08525395f, 0.26965728f, -0.15479229f, -0.38380629f, 
    -0.13116172f, 0.17218699f, 0.09264116f, -0.02877632f, 0.09762984f, -0.02944437f, 0.11650548f, 0.02801385f, 
    0.22372431f, -0.12921537f, 0.06159181f, 0.28375205f, 0.01888381f, 0.01905125f, -0.07289980f, 0.04452762f, 
    -0.04474845f, -0.07366340f, -0.07371864f, 0.04519572f, -0.02333126f, -0.17192945f, 0.08749326f, -0.07138813f, 
    0.01171778f, -0.09048430f, -0.15951017f, -0.15371442f, 0.02887166f, -0.12623380f, -0.03193113f, -0.01499795f, 
    0.39611590f, 0.17278439f, 0.15300961f, -0.08169492f, -0.11224031f, -0.01717369f, -0.00870678f, 0.07652208f, 
    -0.01600597f, -0.05145952f, 0.02261361f, -0.05208690f, -0.02437022f, 0.22638552f, 0.17417972f, 0.26486734f, 
    0.06360818f, 0.07270373f, 0.05864068f, 0.07880376f, -0.17145190f, -0.08077505f, -0.01300272f, 0.04957784f, 
    0.07102487f, 0.13296629f, -0.10124487f, -0.14872907f, -0.09967341f, 0.12780647f, -0.09088951f, 0.09201925f, 
    0.09468440f, 0.06296223f, 0.01389703f, -0.02575093f, -0.35886121f, -0.20010363f, -0.03842719f, -0.32745039f, 
    -0.09637664f, -0.02064007f, 0.12022513f, 0.04531651f, -0.02676804f, 0.09823006f, 0.08119858f, -0.00173293f, 
    -0.32567540f, -0.08236749f, -0.15041940f, -0.24108550f, 0.12842429f, 0.15899746f, 0.12895830f, 0.05813535f, 
    -0.02210547f, -0.10462098f, -0.13258699f, 0.02898375f, 0.23376380f, -0.06474099f, 0.01560636f, 0.14125964f, 
    0.00551087f, 0.07931597f, -0.11166106f, -0.07473910f, 0.04388367f, -0.15835094f, -0.19814757f, -0.03624436f, 
    0.21585618f, -0.13656564f, 0.00867747f, 0.28632915f, -0.01160362f, -0.05678780f, -0.06947975f, -0.08557905f, 
    0.14172685f, 0.00837822f, 0.06661399f, -0.08792359f, -0.03923870f, -0.04712890f, -0.13544254f, -0.34789181f, 
    -0.04051613f, -0.03722892f, 0.06033760f, 0.05644512f, 0.00196259f, -0.02404897f, -0.03717694f, 0.08868106f, 
    0.14419004f, -0.11335937f, -0.07256382f, 0.21874142f, 0.05127491f, -0.01320837f, 0.03428428f, -0.05223347f, 
    0.01314840f, -0.00358324f, -0.10107220f, 0.20385312f, -0.03311129f, -0.07677964f, 0.12264377f, -0.02414065f, 
    -0.01565787f, 0.06408812f, 0.06918379f, -0.04481190f, -0.01255735f, -0.01889795f, 0.04660447f, 0.00182738f, 
    0.15452068f, 0.07042190f, -0.10635640f, 0.08912652f, -0.03264492f, -0.08912313f, -0.03097060f, -0.04970183f, 
    0.04817903f, 0.00494646f, -0.03577359f, 0.06748492f, -0.10925999f, 0.37291428f, -0.00298165f, -0.05621646f, 
    0.08177651f, -0.03970203f, 0.05381820f, 0.08180811f, 0.03087443f, -0.00996823f, -0.00740426f, 0.04968657f, 
    0.04358481f, 0.08135065f, -0.09306390f, 0.00117017f, 0.12466521f, 0.20837195f, 0.00953818f, -0.14493231f, 
    0.02751705f, 0.08940525f, 0.00128111f, 0.08580820f, 0.00414268f, -0.06580126f, 0.04278735f, -0.00826954f, 
    -0.03637078f, 0.05073597f, 0.00518165f, -0.01995661f, 0.02318738f, -0.11139289f, -0.12864023f, 0.00261628f, 
    -0.07070280f, 0.14268216f, -0.05795806f, 0.14125887f, -0.13674545f, -0.05657085f, -0.11213377f, 0.01493489f, 
    0.06779491f, 0.09348483f, 0.06104718f, -0.08779779f, 0.35725001f, 0.25572792f, 0.07174786f, -0.03439692f, 
    -0.06866524f, 0.13954152f, 0.00244224f, 0.01293157f, -0.04411085f, 0.15975454f, 0.06223401f, -0.01236899f, 
    0.08471207f, -0.08670729f, -0.04588449f, -0.18910925f, 0.02675318f, 0.02697282f, -0.02109094f, -0.03082063f, 
    0.09275453f, -0.09558345f, 0.06055376f, 0.06790161f, 0.02518371f, 0.00529851f, 0.05960813f, 0.16228949f, 
    -0.05537897f, -0.07327775f, -0.00369020f, -0.02074642f, -0.06608055f, -0.03706732f, -0.00214379f, -0.04230285f, 
    -0.17992638f, -0.16022396f, -0.11390688f, -0.18115507f, 0.05385903f, 0.08894259f, -0.07911427f, -0.05915270f, 
    0.00966490f, 0.05493636f, -0.03652968f, 0.02310959f, 0.03923127f, 0.02949396f, -0.09306110f, -0.05191033f, 
    -0.06163413f, 0.01498569f, -0.08309086f, -0.02084029f, 0.15443343f, 0.07652857f, 0.01976142f, -0.00263589f, 
    0.11535582f, -0.07155915f, 0.00516784f, -0.12727220f, 0.07247269f, 0.11127117f, 0.08949124f, 0.17355101f, 
    -0.03689533f, -0.13436483f, 0.04560632f, 0.06814408f, 0.21569672f, -0.13424481f, 0.15328056f, -0.00512077f, 
    0.02863184f, -0.02543175f, -0.00666174f, -0.05339770f, 0.02877725f, -0.00991851f, 0.04985987f, 0.01563630f, 
    -0.01888354f, -0.02818275f, -0.06432570f, -0.04444792f, 0.02232279f, -0.04474802f, -0.00621621f, -0.06927849f, 
    -0.00785593f, -0.01794597f, 0.03179140f, -0.07090203f, 0.02316892f, -0.05499217f, -0.06828286f, -0.01325598f, 
    -0.05514256f, -0.01543590f, -0.01657820f, 0.00317010f, 0.04026473f, -0.03316292f, -0.06729921f, -0.06097152f, 
    -0.00881763f, -0.04204305f, 0.06669340f, -0.01653890f, -0.07668971f, -0.02494729f, -0.05236331f, -0.05647603f, 
    0.06439632f, 0.06077664f, 0.01904264f, -0.04432099f, -0.05856598f, 0.02770277f, -0.02593586f, 0.02193822f, 
    0.01958692f, 0.01062026f, -0.01838777f, -0.07683356f, -0.07194388f, 0.05510333f, -0.00608481f, 0.03680474f, 
    0.01982962f, 0.02847493f, 0.05389922f, -0.02558514f, -0.01331582f, 0.03184200f, -0.04552105f, -0.02593818f, 
    -0.00874956f, 0.02820603f, -0.06740283f, 0.00392185f, -0.04238675f, -0.07427011f, -0.04257268f, -0.03030130f, 
    -0.07192905f, 0.01584874f, 0.01868602f, 0.03462787f, -0.06820886f, 0.02974703f, -0.04732992f, -0.00151852f, 
    0.05766081f, -0.05415097f, -0.01797776f, -0.06133172f, 0.02325769f, -0.00411833f, -0.06415748f, -0.00024330f, 
    0.03294051f, -0.05199784f, -0.04881887f, -0.06983473f, -0.06107404f, 0.05503363f, 0.06405769f, -0.05791755f, 
    -0.02371741f, -0.07132366f, -0.00715483f, 0.02440427f, -0.06029467f, 0.04269728f, 0.02175938f, -0.01176422f, 
    0.04709418f, -0.06459627f, 0.06164308f, 0.01002691f, 0.04341691f, 0.03345195f, 0.05940603f, -0.07766681f, 
    -0.05219374f, -0.03588563f, 0.00304081f, 0.01048986f, -0.04948021f, -0.01541656f, -0.00053387f, -0.00593210f, 
    -0.06493461f, 0.00755867f, 0.02596792f, -0.02703676f, -0.03571505f, 0.05078444f, 0.02648335f, 0.00015980f, 
    -0.01244677f, -0.04396932f, -0.07668988f, 0.02338092f, 0.06423072f, -0.02508115f, 0.00783544f, -0.00488179f, 
    0.05381405f, 0.06392451f, -0.01943801f, -0.06371541f, 0.04587432f, 0.03440842f, 0.00400462f, -0.02335797f, 
    -0.01396396f, 0.06632193f, 0.04158332f, -0.06441673f, 0.04090995f, 0.03240324f, 0.01961529f, -0.04688629f, 
    0.05437632f, -0.00321713f, 0.06446610f, -0.06746941f, -0.01162242f, 0.05359599f, -0.03793955f, -0.04399855f, 
    0.04836109f, -0.04203570f, 0.03893208f, 0.02395095f, -0.06540457f, -0.05294212f, -0.01890349f, 0.01716982f, 
    -0.07041296f, -0.03443076f, 0.05200512f, -0.04554936f, 0.02246358f, -0.06224481f, -0.05179041f, 0.03214792f, 
    -0.01461512f, -0.07823665f, -0.07487180f, 0.01885539f, -0.01189088f, 0.05751239f, 0.04517588f, 0.00830327f, 
    0.00906142f, 0.04448917f, -0.07059581f, 0.06577019f, 0.02347210f, -0.00141325f, -0.00870724f, -0.07305337f, 
    -0.00042070f, 0.00382652f, 0.01551370f, 0.05800563f, 0.01649499f, -0.06744476f, -0.01956767f, -0.02380191f, 
    -0.27906388f, 0.00331421f, 0.04623263f, -0.03829538f, 0.01713198f, -0.08099839f, 0.06222798f, 0.12560992f, 
    -0.09231807f, -0.00447107f, -0.03002492f, -0.03734820f, 0.00140865f, 0.03073991f, -0.02994336f, 0.31269550f, 
    -0.13336393f, -0.01469520f, -0.09137268f, -0.00279226f, -0.02091849f, -0.08105174f, -0.12815382f, -0.07351886f, 
    -0.26475331f, -0.10288749f, 0.08363172f, -0.02865847f, -0.03620722f, -0.03162014f, 0.05473471f, 0.13711250f, 
    -0.07470255f, 0.00374003f, 0.02386917f, -0.20120820f, -0.02357040f, 0.02800294f, 0.02395567f, -0.01443362f, 
    0.02591013f, -0.10771780f, -0.00521003f, -0.00842451f, -0.12705761f, -0.05370660f, 0.06118716f, -0.03555971f, 
    0.40805092f, 0.10291755f, -0.08569246f, -0.03087403f, 0.06088418f, -0.01276345f, -0.03237587f, 0.03417476f, 
    0.00171956f, 0.07614348f, 0.20728222f, -0.00038361f, 0.26417848f, -0.18215126f, 0.05756162f, -0.24586600f, 
    -0.03054971f, -0.10865314f, 0.01972018f, 0.02902132f, 0.11388594f, -0.05369369f, 0.03285499f, 0.02644423f, 
    -0.21681777f, -0.06958755f, 0.19557686f, -0.13344236f, -0.11420830f, -0.02963160f, 0.07043750f, 0.11277335f, 
    -0.05551611f, 0.10103197f, -0.10525232f, 0.10056160f, -0.03294064f, 0.08279020f, 0.06595137f, 0.40561727f, 
    0.06995811f, -0.00293826f, -0.02710287f, -0.14378367f, -0.03381855f, 0.03562296f, 0.09984810f, 0.03850033f, 
    0.08698177f, -0.06799220f, 0.03360290f, 0.08341172f, 0.20113277f, 0.07698929f, 0.06995612f, -0.11573216f, 
    -0.10318455f, 0.05975672f, -0.04861696f, 0.18081798f, -0.01009013f, -0.01179173f, 0.06999713f, -0.00107573f, 
    0.16123699f, -0.05985259f, 0.06025309f, 0.08797270f, 0.03018950f, -0.03457430f, 0.10125542f, 0.05250991f, 
    -0.19076167f, -0.05331099f, 0.06229998f, 0.16483685f, 0.02962091f, -0.15390319f, 0.05364488f, -0.18036351f, 
    -0.02928927f, 0.03310906f, -0.01036283f, -0.03680375f, -0.03042165f, -0.26825863f, -0.07717940f, 0.21521704f, 
    0.07703735f, 0.04136350f, -0.01681246f, 0.03258472f, 0.11106292f, -0.06006319f, -0.08264983f, 0.07452527f, 
    -0.04730422f, 0.09864783f, 0.03804351f, -0.05977707f, -0.16351400f, -0.11297379f, -0.13416855f, 0.00538798f, 
    0.09864206f, 0.00695431f, 0.02494641f, 0.09206849f, 0.24257164f, 0.15437447f, -0.07187492f, 0.00566766f, 
    0.07560389f, -0.02766921f, -0.03599023f, -0.01474275f, 0.01883161f, -0.09583575f, 0.08666740f, 0.01627952f, 
    0.19584291f, 0.10663731f, -0.16386719f, 0.02737094f, 0.14298189f, 0.03486141f, 0.12688889f, -0.01147347f, 
    0.09780999f, 0.05502933f, 0.07077688f, -0.12998688f, -0.27764836f, 0.09654383f, -0.08662131f, 0.08619971f, 
    0.09554337f, -0.11963168f, 0.07267767f, 0.05928760f, -0.01775600f, 0.03607454f, -0.00606284f, 0.04143816f, 
    -0.10805856f, -0.18246809f, -0.30821800f, -0.04580296f, -0.05891250f, 0.06204820f, 0.07648203f, 0.02965784f, 
    0.06272678f, -0.07419449f, 0.07569474f, 0.20791279f, -0.14859872f, -0.11706023f, -0.06443722f, -0.04464766f, 
    -0.02370144f, -0.02544504f, 0.08180278f, 0.11187038f, -0.10055445f, 0.05135656f, 0.02131960f, -0.11983651f, 
    -0.20547642f, -0.12392706f, -0.26922834f, -0.00929808f, 0.00039097f, 0.07995843f, 0.09986935f, 0.15434648f, 
    -0.08763494f, 0.13083994f, 0.07692531f, 0.04439860f, 0.29598841f, 0.10332190f, 0.02640802f, -0.06014077f, 
    0.03793852f, 0.00260250f, -0.01930936f, 0.07195597f, -0.05126398f, 0.13000837f, -0.08983544f, 0.03856011f, 
    -0.09844434f, -0.11995607f, 0.04992807f, 0.00074610f, -0.01361129f, 0.25395530f, -0.19608939f, 0.10469642f, 
    0.04978720f, 0.03202879f, -0.04280696f, 0.09365921f, 0.30352953f, -0.05469419f, -0.01259276f, 0.12018111f, 
    -0.06291018f, 0.16083620f, 0.09793180f, -0.04399459f, 0.02306390f, -0.02073759f, 0.09788752f, 0.02059060f, 
    0.09118159f, -0.05245203f, -0.13885488f, -0.00179522f, -0.03478921f, -0.02956643f, 0.04696345f, -0.05646905f, 
    0.03651053f, 0.08884039f, 0.08919442f, 0.25493002f, -0.36541396f, 0.58083522f, 0.03349803f, -0.15966368f, 
    -0.00103462f, 0.03443286f, 0.10380685f, 0.13734871f, -0.01002291f, 0.11544022f, 0.05576662f, 0.04139642f, 
    -0.01729660f, -0.16050717f, -0.10968518f, 0.18765683f, 0.05075434f, -0.01450192f, 0.04691943f, 0.05337926f, 
    -0.01508655f, 0.05725545f, 0.01300393f, 0.01372948f, -0.01526950f, -0.29193664f, 0.01669963f, -0.13125002f, 
    0.20428261f, 0.11739556f, -0.02871922f, -0.11451326f, -0.01247469f, -0.09475581f, -0.07053433f, -0.05099845f, 
    -0.33119339f, -0.01773570f, 0.14969444f, 0.13264132f, -0.09440283f, -0.18745203f, 0.10931741f, 0.05922705f, 
    0.00797777f, 0.11411411f, 0.12701117f, -0.01812120f, 0.14637020f, -0.15911144f, -0.11116150f, -0.23996662f, 
    0.01359030f, -0.11727851f, -0.04865615f, 0.17394951f, -0.13863771f, 0.10450383f, 0.14118166f, -0.05546695f, 
    0.01972874f, 0.17829347f, 0.09643387f, -0.11434054f, -0.13364218f, 0.01306226f, -0.01183500f, 0.00152287f, 
    -0.07619511f, 0.08562530f, -0.01441666f, 0.10329738f, 0.17404623f, -0.19809102f, -0.06764012f, -0.12465625f, 
    -0.07405612f, 0.12681659f, -0.03072662f, 0.10643236f, -0.00290435f, 0.09003687f, 0.02661536f, 0.10129449f, 
    0.14452673f, 0.21637228f, 0.10384467f, -0.08747840f, -0.01608450f, 0.11772971f, -0.08565458f, -0.10335296f, 
    0.16717479f, 0.17034669f, -0.08000726f, 0.08670417f, -0.12395913f, -0.04631202f, -0.18559192f, 0.08382812f, 
    0.10676567f, -0.13130683f, -0.08459996f, 0.01543434f, 0.06977948f, 0.01123744f, 0.08731497f, 0.23286188f, 
    0.21973820f, 0.13484107f, 0.07870201f, -0.04097633f, 0.09484386f, -0.07561276f, -0.19866060f, -0.02434621f, 
    0.04440952f, 0.09304147f, 0.03347074f, -0.17947933f, 0.06028089f, -0.02515618f, -0.18478873f, -0.20027950f, 
    -0.08644491f, -0.02696095f, -0.10254886f, 0.07120682f, 0.08456673f, 0.02191387f, -0.07356775f, 0.03674907f, 
    -0.12418159f, -0.03315999f, -0.08851365f, 0.01317884f, 0.04863475f, -0.07017837f, -0.02592491f, -0.01122395f, 
    0.12482145f, -0.07480728f, -0.19050764f, 0.13477458f, -0.07161384f, -0.05235542f, -0.16441230f, 0.15194716f, 
    0.03531167f, 0.03402778f, -0.05548961f, 0.00789090f, 0.04795052f, 0.05528967f, 0.08597255f, -0.04302562f, 
    0.42279747f, 0.08066456f, 0.03963995f, -0.00494000f, 0.09014579f, -0.07577714f, 0.04615959f, -0.07852713f, 
    0.09859263f, -0.06092491f, 0.16625398f, -0.03748901f, -0.26162702f, -0.05442405f, -0.02470127f, -0.03783051f, 
    -0.03437620f, -0.01670440f, -0.00705499f, -0.07255864f, 0.01089778f, 0.10807312f, 0.09086232f, 0.12050212f, 
    0.09520639f, -0.00223380f, 0.10075648f, 0.18724816f, 0.04461358f, 0.04685553f, -0.05045121f, 0.02475492f, 
    0.02336187f, -0.25046170f, 0.07967872f, 0.00663355f, -0.18183479f, 0.12085147f, -0.08695789f, 0.01459132f, 
    0.11349109f, 0.14746033f, -0.02369734f, 0.04670658f, -0.08709522f, 0.01999410f, 0.03216160f, -0.04343544f, 
    0.11379673f, -0.10390955f, -0.05239637f, 0.03120335f, 0.13138993f, -0.06283381f, 0.02280184f, -0.02283375f, 
    -0.04826361f, -0.07945996f, 0.16176635f, 0.11655891f, 0.30615410f, -0.05680672f, 0.07792199f, 0.07166778f, 
    0.09904193f, -0.10267133f, -0.07422446f, 0.09181935f, 0.19289631f, 0.04447928f, 0.04990774f, 0.00916642f, 
    0.33105120f, 0.01591640f, -0.12915695f, -0.11731010f, -0.04266911f, 0.05917272f, -0.01120347f, -0.04916674f, 
    0.03611001f, -0.04821822f, -0.07086256f, -0.11860970f, -0.01043183f, 0.09523319f, 0.00310091f, 0.13539711f, 
    0.05201486f, 0.02626308f, -0.07700467f, 0.03723199f, 0.07402141f, -0.06828307f, -0.16990542f, 0.19938366f, 
    -0.10924734f, 0.10097715f, -0.02879641f, -0.13338646f, 0.00984301f, 0.16870458f, -0.03948088f, -0.02259189f, 
    -0.08231810f, 0.03543366f, 0.06011254f, -0.09699734f, -0.01939514f, -0.30659753f, -0.01327424f, -0.20740984f, 
    0.10246834f, -0.12220841f, 0.11225691f, 0.07187568f, 0.13029064f, 0.13319749f, 0.00816754f, -0.07120790f, 
    0.34363222f, 0.15328662f, -0.00649785f, 0.18707246f, -0.06388099f, 0.06847646f, 0.06632852f, 0.04862875f, 
    0.01465467f, -0.06320143f, -0.01148287f, 0.14055224f, -0.15773246f, 0.09352177f, -0.18998669f, 0.16753654f, 
    -0.03801570f, 0.09721207f, 0.09638924f, 0.01846303f, -0.07715748f, -0.14916164f, -0.08172511f, -0.18832532f, 
    -0.26631248f, -0.21365106f, -0.13179462f, 0.15929592f, -0.03126876f, -0.13955814f, 0.07620467f, 0.00402326f, 
    0.07969578f, 0.03151242f, -0.14052401f, -0.00596662f, 0.29617497f, -0.03633708f, -0.02055990f, -0.03302139f, 
    0.04353747f, 0.03217371f, -0.13484715f, -0.16076101f, -0.13775362f, 0.03732497f, 0.00017125f, 0.00980887f, 
    -0.42727479f, -0.16431126f, -0.02906591f, -0.06097586f, 0.06895681f, 0.02708669f, -0.14046311f, -0.22371788f, 
    0.06039294f, -0.00753809f, 0.04221626f, -0.03870987f, -0.00469927f, -0.05106244f, -0.07316384f, 0.11521544f, 
    -0.05294082f, 0.02934471f, -0.16984244f, -0.06908909f, 0.04232689f, -0.04896332f, -0.03594988f, 0.09418337f, 
    0.08630068f, -0.18484503f, -0.17992710f, -0.03999004f, -0.16881248f, 0.04929018f, -0.16094470f, 0.02666795f, 
    0.11130202f, 0.06510430f, -0.16004924f, -0.00448849f, 0.24527940f, 0.26640120f, 0.25730160f, -0.03519774f, 
    -0.00691298f, -0.03918664f, -0.06661003f, 0.11470853f, -0.09367177f, 0.04403658f, -0.00496624f, -0.06540624f, 
    0.24686109f, 0.21456778f, 0.18948811f, 0.10147142f, 0.01473157f, -0.03345559f, 0.02167990f, 0.05364000f, 
    -0.11173437f, 0.00698213f, 0.01966559f, 0.09743719f, 0.12573902f, -0.03655675f, 0.11461777f, -0.01778644f, 
    0.15671167f, -0.11787397f, 0.05642911f, 0.06181936f, 0.04869621f, 0.12128755f, -0.02155814f, 0.01171766f, 
    -0.23453158f, -0.32532752f, -0.03939958f, -0.10770801f, 0.08069415f, -0.04679662f, -0.17427957f, -0.10619022f, 
    -0.09468294f, -0.14122660f, -0.07199915f, -0.30649129f, 0.16437802f, 0.28230697f, -0.02433533f, 0.08082404f, 
    -0.11842278f, 0.21693482f, -0.11490794f, 0.00161432f, -0.24812052f, -0.01543394f, 0.00471168f, -0.11678285f, 
    0.22713616f, 0.15467307f, 0.05617151f, 0.19862604f, 0.11384279f, 0.13217364f, -0.01631733f, 0.06351851f, 
    -0.05661974f, 0.00301291f, -0.05754341f, 0.14465271f, -0.22481196f, -0.40457746f, 0.00845628f, 0.19232190f, 
    -0.16723233f, -0.04408444f, 0.03098621f, -0.01313640f, 0.04079426f, -0.05423059f, -0.04912908f, -0.22377929f, 
    0.27818468f, 0.06290536f, 0.37707961f, 0.35112980f, 0.15036322f, -0.07190865f, -0.04982536f, 0.10755429f, 
    0.05712610f, 0.11652371f, -0.03307610f, 0.13866615f, 0.19451049f, 0.23267448f, -0.19359341f, 0.13583978f, 
    0.02744401f, 0.02934943f, -0.00602819f, 0.09581832f, -0.07967057f, 0.02850499f, -0.13564794f, -0.05801886f, 
    0.05547268f, -0.24284786f, -0.35459790f, -0.10493100f, -0.07855402f, -0.05705088f, 0.03592809f, -0.09971716f, 
    0.00568951f, 0.04938982f, -0.02766061f, 0.07516500f, 0.05544373f, 0.22976014f, 0.17156345f, 0.03959879f, 
    -0.00722701f, 0.14809112f, 0.19932862f, 0.18571416f, -0.14724042f, -0.10387821f, 0.08402352f, 0.16975725f, 
    -0.20070903f, -0.07910065f, -0.05025682f, -0.04415184f, -0.09357925f, -0.09421743f, 0.05754138f, -0.01549882f, 
    0.07703047f, -0.03857406f, 0.02803121f, 0.00377912f, 0.09352905f, 0.10436978f, 0.09983493f, 0.03474781f, 
    0.10880772f, 0.04984874f, 0.04548075f, -0.07037121f, 0.01693646f, -0.06378511f, -0.06985207f, 0.02609595f, 
    -0.07768797f, 0.11909193f, -0.03555455f, -0.16846897f, -0.05994294f, 0.02145295f, 0.11666049f, 0.11151630f, 
    -0.00713944f, 0.07445550f, 0.08978801f, -0.09185167f, 0.01719052f, 0.03069331f, 0.06767008f, -0.20994560f, 
    0.10271388f, -0.09997033f, -0.02814906f, -0.12984534f, 0.03938342f, 0.00107058f, 0.15556979f, 0.05479274f, 
    0.05245983f, 0.08221050f, -0.10014001f, -0.06503355f, -0.19564044f, 0.10637569f, -0.14320208f, 0.13043980f, 
    -0.04571497f, 0.11793953f, 0.06342413f, -0.08217158f, 0.08348366f, 0.04490220f, 0.13470307f, 0.05054167f, 
    0.01289824f, -0.04633223f, 0.02713534f, 0.06399409f, -0.01836781f, -0.14843616f, -0.06682067f, 0.06757344f, 
    -0.00961472f, -0.08527404f, 0.02827084f, -0.16087766f, -0.07317548f, -0.01775722f, -0.04147593f, -0.04636621f, 
    0.02664616f, 0.24952635f, -0.09171425f, -0.10283294f, -0.17985572f, -0.02434036f, 0.32407290f, 0.25639060f, 
    0.02623019f, -0.02533199f, -0.08786985f, 0.01663231f, 0.12216372f, 0.11849368f, -0.00764654f, 0.00122728f, 
    0.28892589f, -0.11685941f, 0.12404745f, 0.08207104f, -0.02644506f, 0.10942316f, 0.04740363f, 0.08209725f, 
    -0.06544313f, -0.05348564f, 0.00682600f, 0.03842387f, -0.09623509f, -0.22608431f, 0.09107099f, -0.04201898f, 
    -0.05422162f, 0.02919539f, 0.10459769f, 0.01385333f, -0.14296138f, 0.06052017f, 0.08590396f, -0.08371038f, 
    -0.19614235f, 0.17312661f, 0.18127535f, -0.17854381f, 0.13341753f, 0.07101293f, 0.14119515f, 0.02085468f, 
    0.01400157f, 0.09448605f, -0.06011365f, 0.10190547f, -0.10617947f, -0.31762129f, -0.17492449f, 0.20646419f, 
    -0.14143249f, 0.08410965f, 0.06273352f, -0.10095000f, 0.01826438f, -0.03993612f, 0.15773253f, -0.05748169f, 
    -0.08296952f, -0.06609373f, 0.03195118f, -0.01737690f, -0.06178926f, 0.01886754f, -0.00540312f, -0.12176926f, 
    0.15180057f, 0.06604031f, -0.09564316f, 0.02135325f, 0.47855487f, 0.22798681f, -0.05986204f, 0.20405854f, 
    -0.05178418f, -0.04225681f, -0.12773341f, 0.01764133f, -0.00359984f, -0.08851688f, -0.01153639f, 0.01261310f, 
    0.17069951f, 0.17473178f, -0.15763608f, -0.04966241f, 0.07239676f, -0.00771964f, -0.06936315f, -0.03031888f, 
    0.02102048f, -0.00535753f, -0.03266053f, -0.06844727f, -0.07671602f, 0.15765496f, 0.14776067f, 0.08053924f, 
    -0.01753465f, 0.09992922f, 0.08022459f, 0.17951933f, 0.08754231f, 0.11413536f, 0.16899467f, 0.04146657f, 
    0.08136305f, -0.28520212f, 0.00201889f, 0.06577735f, -0.01851002f, -0.00493662f, 0.05967115f, 0.05202138f, 
    0.05541371f, 0.11970230f, 0.17718117f, 0.06719807f, 0.01528945f, -0.03730822f, -0.12524633f, -0.15808237f, 
    -0.08893689f, 0.01947089f, -0.03798417f, 0.00126945f, 0.01098721f, -0.10976624f, 0.05349086f, 0.00374633f, 
    0.06910232f, -0.12698449f, 0.03229748f, 0.14751776f, -0.02276054f, 0.07738719f, 0.00628673f, -0.17026539f, 
    0.02493577f, 0.02234166f, 0.05739488f, 0.08266079f, -0.05248544f, 0.10750761f, 0.09195393f, 0.05593223f, 
    0.01064766f, 0.06858835f, 0.01509560f, -0.15649387f, -0.07783378f, -0.00670895f, -0.02785618f, 0.09841603f, 
    -0.11006291f, 0.01924830f, 0.02586847f, 0.09814987f, -0.13885090f, -0.04407158f, 0.02063186f, 0.12682186f, 
    0.03528888f, 0.03804854f, -0.21007791f, 0.10425744f, 0.27073753f, 0.11040194f, 0.00203796f, 0.09264076f, 
    0.04751380f, 0.04043334f, -0.00143309f, 0.15276258f, -0.02531023f, -0.07716603f, -0.03278754f, 0.01638676f, 
    0.16028862f, -0.01243232f, -0.20032662f, 0.01984557f, 0.07737442f, -0.01655795f, -0.00291011f, -0.09950252f, 
    -0.00389055f, 0.01250954f, 0.03362019f, 0.25698110f, 0.03090657f, 0.09622537f, 0.03813539f, -0.24290515f, 
    0.03792140f, -0.09566309f, 0.09036969f, 0.02046113f, -0.04132469f, -0.08554585f, 0.03301806f, 0.07683262f, 
    -0.03925319f, 0.07452168f, 0.19766213f, 0.06434929f, -0.12921622f, 0.05730157f, -0.11911569f, 0.08627453f, 
    0.06404343f, -0.01272063f, -0.04457066f, -0.19312856f, 0.11508764f, 0.14510593f, -0.04652898f, 0.05506008f, 
    -0.01276905f, 0.11128014f, -0.05103147f, 0.08710804f, -0.15393147f, -0.15915143f, -0.11263931f, 0.08416104f, 
    0.10496090f, -0.10724272f, -0.03289949f, 0.02710957f, 0.02934165f, -0.08902719f, 0.00112509f, 0.09450064f, 
    0.08553855f, -0.05057797f, -0.00881659f, 0.07589059f, 0.12274735f, 0.04728671f, 0.16205643f, 0.09910179f, 
    -0.06011147f, 0.05306654f, 0.06453643f, 0.01528086f, -0.04499591f, 0.01595510f, 0.02199055f, -0.05903529f, 
    -0.10754723f, -0.12454806f, 0.04239741f, 0.04119909f, -0.05598915f, -0.11699044f, 0.07114214f, -0.01686510f, 
    0.00725743f, -0.03655605f, -0.03203571f, 0.07357243f, 0.09147091f, -0.08727491f, 0.01170035f, 0.15963893f, 
    -0.00368482f, 0.07982985f, -0.11602002f, -0.01254808f, -0.09741174f, 0.00208568f, -0.10785731f, -0.06594796f, 
    -0.24373671f, -0.15550692f, -0.19259930f, -0.17931160f, 0.00639136f, 0.06515212f, 0.04318681f, 0.00391827f, 
    0.04107301f, -0.00699861f, -0.05320940f, 0.04048118f, 0.28475475f, -0.33564937f, 0.09077854f, 0.03251764f, 
    0.00678132f, 0.14896534f, 0.05258225f, 0.06979676f, -0.03037988f, 0.02175871f, 0.10846962f, 0.16618763f, 
    0.09836499f, 0.09842410f, 0.03458612f, -0.04582085f, 0.15260847f, -0.00890987f, -0.07296682f, -0.09666618f, 
    0.08429585f, 0.01299343f, -0.01357588f, -0.04004019f, 0.13194661f, 0.09846099f, 0.00091729f, 0.03112837f, 
    0.06407852f, -0.01091953f, -0.08231301f, 0.00312332f, 0.02383740f, 0.02095784f, 0.03095645f, 0.04760874f, 
    0.15369183f, 0.11623240f, -0.01949730f, -0.03501663f, 0.16286850f, 0.08650579f, 0.01171350f, 0.00987974f, 
    0.12669010f, 0.06420701f, -0.04125400f, 0.08862927f, -0.07620632f, -0.06676681f, 0.02424711f, 0.21890382f, 
    -0.01765296f, -0.01840989f, 0.10184452f, 0.05081934f, 0.01782233f, -0.07487553f, -0.02057135f, -0.03970151f, 
    -0.11257069f, 0.02154650f, 0.11099688f, -0.02346225f, 0.16435243f, -0.06697398f, 0.10738152f, -0.12355171f, 
    -0.09692455f, -0.08745819f, 0.08737535f, -0.10960287f, -0.16405481f, 0.10960740f, -0.01422116f, 0.02095751f, 
    0.12981918f, -0.10253520f, -0.04406855f, 0.04601006f, 0.05883174f, 0.08575402f, -0.02257437f, -0.06167193f, 
    -0.02284334f, 0.10619190f, 0.09157676f, 0.18271157f, 0.14143334f, 0.02581925f, -0.03469513f, 0.03060464f, 
    -0.06253308f, -0.10626867f, -0.00036196f, -0.11275401f, 0.38068548f, -0.46672910f, -0.18662429f, 0.11849102f, 
    0.09003270f, 0.04512769f, -0.00372844f, -0.02883124f, 0.02473945f, 0.04974158f, -0.09366553f, 0.05835960f, 
    -0.03797367f, 0.07606044f, 0.14202918f, -0.18697473f, -0.05847176f, -0.00918834f, -0.05946313f, -0.01790395f, 
    0.00596724f, 0.05431618f, -0.03218390f, 0.00542035f, -0.02963073f, 0.22742578f, 0.07633243f, 0.12401696f, 
    -0.15793832f, -0.06290594f, 0.01683591f, 0.14368866f, -0.02357047f, 0.12797895f, 0.04065551f, 0.06468154f, 
    0.51674002f, 0.06171537f, -0.04466876f, 0.06547666f, 0.00357457f, 0.16099891f, -0.16237718f, 0.00976943f, 
    -0.04499605f, -0.09505764f, 0.02489584f, -0.04158547f, -0.07315180f, 0.08378858f, -0.07455368f, 0.03651792f, 
    0.06692098f, 0.02042919f, -0.06527045f, 0.01253499f, 0.08438506f, 0.01821610f, -0.11159143f, 0.00348383f, 
    0.08749753f, -0.10099149f, -0.00736267f, -0.01353789f, 0.07101430f, 0.05877864f, -0.00166989f, 0.00236042f, 
    -0.02621558f, -0.01697612f, 0.03934782f, -0.12562744f, -0.34162006f, 0.08449651f, 0.19419591f, -0.09798589f, 
    0.07395672f, -0.01229019f, 0.05727356f, 0.07081132f, -0.11094761f, 0.00379596f, -0.07050247f, -0.09612578f, 
    -0.02348995f, -0.11468216f, 0.05222431f, 0.03836548f, -0.00975367f, -0.06595600f, 0.06004621f, 0.02351866f, 
    -0.09138874f, -0.09975096f, 0.07735225f, 0.06089702f, 0.24027869f, 0.03557444f, 0.03862613f, -0.07557958f, 
    -0.05597106f, 0.03423580f, -0.00421629f, -0.09908057f, -0.11293813f, 0.04804489f, 0.04055136f, -0.10698616f, 
    -0.05584336f, -0.10400932f, -0.19841661f, -0.17499371f, -0.07074840f, 0.09163547f, 0.11748821f, 0.23087773f, 
    0.00453329f, 0.01114818f, 0.01606066f, 0.11622776f, 0.04365394f, 0.06616103f, 0.20746432f, 0.22383854f, 
    0.02393067f, 0.01726808f, 0.06138000f, -0.00918867f, -0.04809529f, -0.01301188f, 0.21766938f, 0.01927905f, 
    -0.04965183f, -0.15742002f, 0.06408798f, -0.06683781f, -0.15938911f, 0.02212452f, 0.05775414f, -0.01700772f, 
    -0.00322563f, 0.01835069f, 0.16500552f, 0.07809805f, 0.31164524f, 0.03511285f, 0.14403984f, 0.08680075f, 
    -0.12595974f, -0.08588256f, -0.07452901f, 0.10353865f, 0.02773981f, -0.01419064f, -0.09143324f, 0.20415995f, 
    -0.31474152f, -0.23190764f, 0.18260466f, 0.13700305f, 0.06252516f, 0.13706905f, 0.08430959f, -0.01971407f, 
    -0.01157361f, -0.03222118f, -0.06083912f, 0.12183997f, 0.48449680f, -0.06030658f, 0.00779760f, -0.04871251f, 
    0.17923671f, 0.10384595f, -0.08410163f, 0.17509538f, -0.03557783f, 0.00675450f, 0.01050125f, -0.04705847f, 
    0.27456576f, 0.07067852f, 0.00744282f, 0.03025263f, -0.03583658f, -0.00528662f, -0.10561681f, -0.01090205f, 
    -0.01746129f, 0.05484672f, 0.04592477f, 0.13618182f, 0.29059896f, 0.25293821f, -0.17965421f, -0.17591986f, 
    0.10877918f, 0.05353609f, -0.03172791f, -0.06497956f, -0.11340886f, 0.09886062f, -0.03823551f, 0.04150100f, 
    -0.29672307f, -0.03637161f, -0.00213303f, -0.23038448f, 0.21031369f, 0.03581838f, -0.07343356f, 0.00313155f, 
    -0.10603260f, -0.02384304f, 0.01794248f, -0.11502372f, -0.12328795f, 0.12228475f, -0.09549195f, 0.03189497f, 
    0.17345469f, 0.04412577f, -0.00072213f, -0.13324253f, -0.08502825f, -0.12799935f, 0.03420055f, 0.04674453f, 
    0.05045462f, -0.13447770f, 0.09954838f, 0.38418353f, 0.02932705f, -0.04346630f, 0.03721182f, 0.21383674f, 
    -0.08358596f, 0.00461769f, 0.20829262f, -0.05292222f, -0.09921447f, -0.02867589f, -0.07674936f, -0.21306230f, 
    0.08524612f, -0.04494289f, 0.02807673f, -0.07159728f, -0.20089728f, -0.00569376f, 0.02617754f, -0.29855189f, 
    0.41249210f, 0.07076259f, 0.26706401f, 0.10593078f, 0.04611086f, -0.10802393f, 0.19499026f, 0.00104283f, 
    -0.04712676f, 0.05041008f, 0.08953579f, 0.10908116f, -0.17694667f, 0.05420588f, 0.00485735f, -0.15433075f, 
    0.12910946f, 0.11566652f, 0.02106116f, 0.12075327f, -0.01341016f, 0.07842529f, -0.06179802f, -0.04768234f, 
    -0.27825096f, -0.24338163f, -0.02615315f, -0.16994707f, 0.09538277f, 0.09356644f, 0.07217221f, -0.13336763f, 
    0.00847288f, 0.02924740f, -0.11563737f, -0.01420664f, 0.11009077f, -0.04738799f, -0.01649906f, -0.10927507f, 
    0.08926520f, 0.03170405f, -0.04206922f, 0.13820016f, 0.04837079f, 0.06246809f, 0.18956558f, 0.07395425f, 
    -0.03382335f, -0.00128718f, -0.01146835f, 0.00824437f, 0.03385466f, 0.05878132f, 0.00938721f, 0.05039239f, 
    -0.05006306f, -0.06487539f, -0.06312255f, -0.06714239f, 0.05324171f, 0.02082270f, 0.01693690f, -0.02405048f, 
    -0.06667423f, 0.02873132f, 0.05185903f, 0.05851202f, -0.03801347f, 0.06384216f, 0.04830569f, 0.00634431f, 
    -0.05801514f, -0.01523523f, -0.03017929f, -0.05944522f, 0.01442603f, 0.04126053f, 0.01166159f, -0.07718258f, 
    0.03833411f, -0.05614651f, 0.04392522f, -0.03000889f, -0.04919291f, -0.05839518f, -0.00497214f, -0.04027636f, 
    0.03761468f, -0.04687830f, -0.02823565f, 0.04333814f, 0.06168123f, -0.01738600f, -0.02426936f, 0.04518051f, 
    -0.03760859f, -0.04283018f, 0.04359555f, 0.01083393f, 0.02031737f, 0.05251525f, 0.01788215f, 0.00122106f, 
    -0.03864927f, -0.02904625f, -0.04398068f, 0.00977636f, 0.02226159f, 0.05396689f, -0.05889155f, -0.04097436f, 
    -0.05013802f, 0.01169788f, -0.04826184f, -0.05609765f, -0.06713980f, 0.05977992f, 0.06736717f, 0.00580497f, 
    0.02583206f, 0.04834069f, -0.06532503f, -0.07826990f, -0.03853656f, -0.04174744f, -0.06558191f, 0.02147530f, 
    0.01195204f, 0.01892127f, -0.05510940f, -0.05721520f, 0.04793493f, -0.00968719f, -0.07349114f, -0.06961587f, 
    0.00662367f, -0.00795352f, -0.04042936f, 0.01647045f, -0.02116145f, -0.04574004f, -0.00342580f, -0.00726788f, 
    0.03738744f, 0.03840180f, -0.06943631f, -0.01305671f, 0.06696915f, 0.00429121f, 0.06254461f, -0.05003868f, 
    -0.02543828f, 0.03103409f, -0.05131911f, 0.04287776f, -0.01018855f, 0.00862036f, 0.02978835f, -0.01963157f, 
    -0.00801994f, -0.04632396f, 0.01367811f, -0.04376953f, 0.00460753f, 0.06937443f, -0.00188503f, -0.07214630f, 
    -0.03132072f, -0.01274564f, 0.03683099f, -0.06091507f, 0.00777459f, -0.07450733f, -0.06302660f, -0.01167845f, 
    0.01550885f, 0.06091331f, 0.00311814f, 0.03891137f, 0.03726698f, 0.05882722f, -0.03668740f, -0.04532782f, 
    -0.04368792f, 0.04708976f, 0.03505304f, -0.06944941f, 0.05279424f, 0.00107620f, 0.03850447f, -0.00501099f, 
    0.03098038f, -0.01350088f, 0.02823797f, -0.05893692f, -0.04069737f, -0.04849198f, -0.06399956f, -0.02111164f, 
    -0.05082427f, -0.07481726f, 0.02136899f, 0.03291990f, -0.02205482f, 0.03144200f, 0.03440669f, -0.06138765f, 
    -0.06085835f, -0.07291184f, -0.06868213f, -0.07877056f, -0.06742691f, 0.03906744f, -0.00367154f, 0.02957304f, 
    0.01190531f, -0.03862347f, -0.03465746f, -0.07318352f, 0.05028730f, -0.00390827f, -0.05957504f, 0.00732306f, 
    -0.07629008f, 0.03759999f, -0.05091360f, 0.01212259f, 0.02497229f, -0.01172285f, -0.05715219f, -0.03025128f, 
    0.03645271f, -0.04695053f, 0.01468284f, 0.00656074f, -0.01362994f, 0.05719367f, -0.04935139f, 0.00911020f, 
    0.38905054f, 0.07758958f, -0.05987853f, 0.22906367f, -0.16829148f, 0.07656731f, -0.02185765f, 0.00812843f, 
    0.10574719f, 0.08226569f, -0.04433541f, -0.06185547f, -0.00742406f, 0.17059760f, 0.24793880f, -0.07846090f, 
    0.08376962f, 0.00246817f, 0.12592518f, 0.08325964f, -0.02543294f, -0.05468173f, 0.07849699f, -0.00560184f, 
    0.35759351f, 0.11473535f, -0.10492377f, 0.15043366f, 0.06675081f, 0.07344112f, -0.07861070f, -0.12109748f, 
    -0.02690906f, -0.09245811f, -0.06450792f, 0.08755025f, 0.34260607f, 0.18551578f, -0.00695365f, -0.12725517f, 
    -0.13417536f, 0.01117323f, 0.02226413f, 0.05434271f, 0.00271332f, -0.00824767f, -0.07120527f, -0.06477659f, 
    -0.16500953f, -0.08965652f, -0.11368933f, 0.01956851f, -0.12163801f, 0.06580689f, 0.02823586f, -0.00119210f, 
    -0.09687632f, 0.04601263f, -0.09452990f, 0.02757916f, 0.01754306f, 0.12588969f, -0.05235738f, -0.13361979f, 
    0.09137167f, -0.01584662f, 0.06394547f, 0.00017220f, -0.02106085f, 0.04401296f, 0.00270524f, -0.02346204f, 
    -0.10439698f, -0.04375306f, -0.23596488f, 0.01754005f, 0.07763842f, -0.08030476f, -0.04474797f, 0.15744404f, 
    0.05215316f, 0.03312252f, 0.03407530f, -0.03725185f, 0.09366474f, 0.18962580f, -0.03121146f, -0.25619483f, 
    -0.03959339f, 0.07756017f, 0.00072542f, -0.07556281f, 0.00452894f, 0.01872194f, -0.02809768f, -0.02015138f, 
    0.28095686f, -0.13470837f, 0.02001153f, 0.30808747f, 0.00666350f, -0.03012006f, 0.01808228f, -0.07664619f, 
    -0.06991613f, -0.00718124f, -0.01061359f, -0.15143453f, -0.10721675f, -0.01219490f, 0.22956982f, -0.21669900f, 
    -0.08766288f, 0.03456904f, -0.01283530f, -0.10277201f, -0.07841519f, -0.00219488f, 0.03275830f, 0.02315745f, 
    0.18827218f, 0.13091643f, 0.13968222f, -0.05227683f, -0.04534497f, -0.03207584f, -0.09267855f, 0.03040264f, 
    0.01652037f, -0.01826522f, 0.11582198f, 0.01703093f, -0.19316140f, 0.13736181f, 0.10944630f, 0.33736771f, 
    -0.04626426f, 0.05438117f, 0.04525398f, -0.08885228f, -0.00212565f, -0.01324986f, -0.04423146f, -0.08832247f, 
    0.23574498f, 0.12112737f, 0.08203665f, 0.07412229f, -0.01827815f, -0.04828703f, -0.04902675f, 0.00015328f, 
    0.09897538f, 0.09184954f, 0.03090074f, -0.07402934f, -0.20873977f, 0.11832568f, -0.11853366f, -0.27341130f, 
    -0.10640956f, 0.06293280f, 0.04557574f, 0.03900711f, 0.04961428f, 0.07482400f, 0.13460065f, 0.00143483f, 
    -0.12414286f, -0.13165793f, -0.16493419f, -0.21374318f, 0.07946678f, 0.02996613f, 0.10421775f, -0.11462218f, 
    0.05475575f, 0.01602371f, -0.01916404f, 0.01401585f, 0.01004061f, -0.09790687f, 0.17680469f, -0.08447816f, 
    0.03643795f, -0.02324117f, -0.17882660f, 0.09364421f, -0.06238905f, -0.01787045f, -0.03160701f, -0.05838741f, 
    -0.03084291f, -0.18760027f, -0.03604145f, -0.03852428f, -0.06844658f, 0.08922175f, 0.12127027f, -0.04303712f, 
    0.17090394f, 0.00633748f, 0.11074128f, 0.12781774f, 0.00021204f, -0.06448035f, -0.05078508f, -0.14019094f, 
    0.11178716f, -0.02032104f, 0.08142918f, 0.00131920f, -0.07156940f, 0.00844858f, 0.08163240f, -0.07611562f, 
    0.05400547f, -0.07157011f, 0.11767615f, -0.06499165f, 0.08767825f, 0.11774757f, 0.06206411f, -0.10845350f, 
    -0.00169597f, 0.03727541f, 0.11375542f, 0.04537630f, -0.07813007f, -0.05389960f, 0.11473943f, 0.09661257f, 
    0.02369209f, 0.03107310f, -0.01354392f, -0.18749551f, 0.00956342f, 0.00882396f, 0.02119534f, 0.14275007f, 
    -0.04103827f, 0.02871208f, 0.00641968f, -0.03633608f, -0.06143870f, 0.14001043f, 0.08852769f, 0.09758082f, 
    0.01407705f, 0.04805195f, -0.13659628f, -0.09541983f, 0.18646161f, 0.02737538f, -0.01227047f, 0.24400300f, 
    -0.02935394f, 0.01801770f, -0.07723355f, 0.10421377f, 0.09653322f, -0.20463294f, -0.01104780f, 0.03785810f, 
    0.14276688f, -0.15608214f, -0.07275131f, 0.03655012f, -0.01858943f, 0.06912228f, 0.05283879f, -0.05810429f, 
    -0.13960077f, 0.21904705f, -0.07138903f, 0.16526183f, 0.01853309f, -0.31466851f, 0.18754888f, 0.17745206f, 
    -0.04508949f, -0.01567906f, 0.01580927f, 0.08802175f, -0.00265265f, 0.00770636f, -0.05068098f, 0.02012450f, 
    -0.23059556f, 0.31005654f, 0.14176324f, -0.15452445f, -0.12062140f, -0.07649218f, -0.08019275f, 0.05104356f, 
    -0.01588374f, 0.09735110f, -0.02469402f, -0.15122601f, 0.02983158f, 0.08044553f, -0.12892926f, 0.02898845f, 
    -0.00905778f, 0.02120670f, 0.08112744f, 0.01128882f, -0.17107926f, 0.02344845f, -0.05037240f, 0.05170125f, 
    0.15915827f, -0.09843446f, 0.07578587f, 0.08036644f, 0.12156706f, 0.10170680f, 0.05032334f, 0.12951665f, 
    0.02903086f, 0.04463473f, 0.06622317f, 0.05807732f, 0.20871070f, -0.12394826f, 0.01537283f, -0.06962933f, 
    -0.02518238f, 0.03298331f, 0.11355812f, -0.11673643f, -0.08353822f, -0.04021034f, 0.04292168f, -0.04355102f, 
    -0.00868326f, -0.24396148f, 0.05629665f, -0.12988523f, -0.03443186f, -0.17809124f, 0.02484657f, -0.10863584f, 
    0.06741315f, -0.07664320f, -0.02478096f, -0.05919561f, 0.13790512f, 0.11228435f, 0.08295771f, 0.25114724f, 
    -0.02336106f, -0.00012682f, -0.18832205f, -0.01055844f, -0.11179547f, 0.06134024f, -0.20780736f, 0.01063898f, 
    0.00044656f, -0.04824166f, -0.20016344f, -0.06876726f, 0.06441361f, 0.07250519f, -0.08222388f, 0.04993537f, 
    -0.14354083f, 0.00863863f, -0.00511823f, -0.04183296f, 0.40951756f, -0.11864813f, 0.17072953f, 0.08208552f, 
    -0.01789039f, 0.16022755f, 0.04393200f, -0.03326534f, 0.09591826f, 0.19724479f, 0.20694035f, 0.18905951f, 
    -0.04438480f, 0.03540023f, 0.04886113f, -0.05149412f, -0.01458812f, 0.01063376f, -0.05204576f, 0.06182526f, 
    -0.00184241f, 0.01153904f, 0.00866058f, -0.03230056f, -0.02206699f, -0.02339370f, -0.06903411f, -0.04697543f, 
    0.00773509f, -0.04815752f, -0.06185038f, -0.04662356f, -0.03504243f, -0.04971274f, 0.03063224f, -0.00834412f, 
    -0.01957378f, -0.02152512f, 0.05367852f, -0.03058409f, -0.02405079f, -0.02928080f, -0.07297780f, 0.02578362f, 
    -0.02520879f, 0.02991262f, 0.04269906f, 0.03929182f, -0.01955974f, -0.03908403f, -0.02246079f, -0.05932296f, 
    -0.05356510f, 0.03204294f, -0.00347339f, -0.01843206f, -0.06774239f, 0.00986209f, 0.03868039f, 0.02514293f, 
    -0.01501868f, -0.02747631f, -0.00395848f, -0.05411545f, -0.07721291f, -0.05802307f, 0.04531244f, -0.00748510f, 
    -0.06619959f, -0.07234454f, -0.07802287f, -0.02623124f, -0.00995368f, 0.03614574f, 0.05568894f, 0.04166980f, 
    0.05831742f, -0.06774370f, -0.04365009f, -0.01891067f, -0.00225147f, -0.03315485f, -0.02429891f, -0.06358179f, 
    0.05236766f, -0.05815361f, -0.05106787f, -0.01101869f, 0.01218583f, 0.04744267f, -0.04763350f, -0.06150687f, 
    0.02025249f, -0.03251176f, 0.03376471f, 0.02330777f, -0.04657331f, 0.00167980f, 0.01087076f, 0.06280329f, 
    -0.05392355f, -0.04730332f, 0.02701878f, 0.01385511f, -0.00120962f, -0.03731253f, 0.05382805f, 0.01494527f, 
    0.03102078f, -0.05923892f, 0.05393873f, -0.07211725f, -0.08292484f, -0.06295893f, 0.03146111f, -0.07653824f, 
    0.05326969f, -0.01360398f, 0.01207054f, 0.04964466f, 0.02984867f, 0.01574715f, -0.07930576f, 0.01297371f, 
    -0.06780333f, 0.05797163f, -0.02922000f, -0.03889396f, -0.05739400f, 0.03818452f, -0.04264396f, -0.05552723f, 
    0.04214184f, -0.04679013f, -0.02089004f, -0.07431045f, -0.04214158f, 0.05992048f, -0.04229312f, -0.02105251f, 
    -0.06052298f, 0.05960916f, 0.05781119f, -0.07869244f, 0.02571077f, -0.05738554f, -0.07493703f, -0.06105812f, 
    0.00393006f, -0.07488214f, -0.07618615f, 0.00440098f, 0.02610684f, -0.03827780f, 0.04503642f, 0.01320156f, 
    0.00767804f, -0.03818802f, -0.00820934f, 0.06410185f, 0.02884439f, 0.02473448f, -0.02672831f, -0.00174732f, 
    0.03436517f, 0.00192182f, 0.05210273f, -0.05246400f, -0.07780251f, 0.05318014f, 0.01104709f, 0.00550976f, 
    -0.05230873f, -0.07500838f, 0.02806445f, -0.02083883f, -0.02904130f, -0.01954547f, 0.05577619f, -0.07378904f, 
    -0.06574608f, 0.05305954f, 0.05839459f, 0.02740708f, 0.01830235f, -0.00572002f, -0.02992540f, -0.00051444f, 
    0.04343344f, 0.04624150f, -0.07146578f, 0.06337675f, 0.00868595f, -0.01324186f, 0.03461581f, -0.04566675f, 
    -0.06122629f, 0.06027914f, 0.05108235f, -0.05329053f, 0.06880685f, 0.06098544f, -0.04750187f, 0.02219872f, 
    0.10306167f, -0.03764863f, -0.21558359f, 0.13259335f, 0.06016217f, 0.04378132f, -0.06094152f, 0.04784948f, 
    0.06882674f, 0.01829920f, -0.09901701f, -0.02507486f, 0.10030393f, -0.06284344f, -0.02004226f, -0.46979260f, 
    -0.07081886f, -0.22389176f, 0.05574043f, 0.06467482f, 0.06637733f, 0.01262847f, -0.01679479f, 0.28769982f, 
    0.17593290f, 0.03895564f, -0.09744613f, 0.11978768f, 0.03783863f, 0.16115913f, -0.02840707f, -0.09897123f, 
    -0.00838068f, 0.01872970f, -0.22121175f, 0.07800326f, 0.10858557f, 0.13054053f, -0.02784194f, -0.00637125f, 
    -0.17709389f, -0.12420772f, 0.03320434f, -0.06164128f, -0.00608721f, -0.12361522f, -0.05940919f, -0.02778666f, 
    0.14651446f, -0.04018666f, -0.00584186f, -0.13283782f, 0.09990162f, -0.03201372f, -0.00534176f, 0.03109261f, 
    -0.05652025f, -0.07665827f, -0.02599919f, -0.07639450f, -0.42869461f, 0.21835278f, 0.09521621f, -0.11903550f, 
    0.12736270f, -0.07446556f, 0.03759760f, 0.05141450f, 0.14989446f, 0.09153546f, 0.08670297f, 0.12861183f, 
    -0.10143267f, 0.05192402f, 0.01935066f, 0.21560283f, 0.06216731f, 0.06307643f, -0.07633319f, 0.02050718f, 
    0.11505885f, 0.07757337f, -0.03862549f, -0.00727718f, -0.00397194f, -0.05541182f, -0.11300752f, -0.11157513f, 
    0.07194670f, 0.03295424f, -0.01311547f, 0.05148853f, 0.05183436f, 0.06185608f, 0.01790234f, 0.06303146f, 
    0.20960496f, -0.00615297f, -0.12883355f, 0.08201096f, 0.06647132f, -0.05444612f, -0.01686956f, 0.02237158f, 
    0.08455995f, 0.08031216f, 0.08134773f, -0.00671227f, 0.28741357f, 0.14241265f, 0.31267977f, -0.08978961f, 
    -0.13048148f, -0.05104392f, 0.08157676f, 0.00072305f, 0.08629441f, -0.01690520f, 0.02878794f, 0.07607576f, 
    0.32380241f, 0.05120816f, -0.00685617f, -0.10283513f, -0.13917355f, -0.03913717f, -0.09968835f, -0.07130380f, 
    0.12049463f, -0.03127241f, -0.01034101f, 0.07263013f, -0.12943022f, 0.01717865f, -0.19319630f, 0.03487268f, 
    0.08634093f, -0.10558080f, 0.08213682f, 0.00227971f, 0.04487401f, 0.01330014f, 0.06134063f, 0.05288697f, 
    -0.08272590f, -0.05554678f, -0.12857430f, -0.01967825f, -0.16137996f, 0.06100563f, 0.05178916f, -0.10118049f, 
    0.03996787f, 0.11001004f, 0.02142088f, 0.01879902f, -0.24814469f, -0.03412692f, 0.17807768f, -0.22151864f, 
    -0.07092726f, -0.00087070f, 0.08853646f, 0.03515472f, 0.08350241f, 0.03329798f, -0.17119718f, 0.04866190f, 
    -0.02617965f, 0.15639494f, 0.09895982f, -0.16950743f, 0.14344276f, 0.16376111f, 0.04966280f, 0.04782169f, 
    -0.14669023f, 0.02580696f, 0.00013175f, 0.04823079f, -0.05302750f, -0.15181828f, 0.06228695f, -0.03460198f, 
    0.02563865f, 0.07223351f, -0.04767923f, 0.00270819f, 0.09960576f, 0.05586487f, 0.10238568f, -0.02267475f, 
    0.20217763f, 0.19547200f, 0.05141926f, -0.01412634f, 0.01662035f, 0.05586768f, -0.04118712f, 0.16124651f, 
    -0.18856096f, 0.06208772f, -0.06098660f, -0.08323485f, -0.14989899f, 0.05000656f, 0.09085763f, 0.32378626f, 
    -0.09305613f, 0.00082062f, -0.07776682f, -0.02794149f, 0.05666668f, 0.06299536f, 0.06785177f, 0.02572196f, 
    0.13375692f, -0.13932984f, -0.01715420f, 0.09914580f, -0.09463119f, 0.04961538f, -0.07680878f, -0.05676407f, 
    0.05010494f, -0.00962559f, -0.07021970f, -0.15334131f, -0.04249270f, -0.02606435f, -0.05373345f, -0.04980422f, 
    -0.07360565f, 0.02317140f, 0.03102985f, 0.05958762f, 0.05642943f, -0.02147615f, -0.12504217f, -0.02666035f, 
    0.04540577f, 0.00419737f, 0.02413934f, 0.04514618f, 0.12728520f, -0.08707020f, 0.17516837f, -0.12461714f, 
    0.13638464f, 0.02237009f, -0.08374567f, 0.09763704f, 0.01007795f, -0.03997546f, -0.03016811f, -0.05588074f, 
    0.01309660f, 0.01859738f, 0.07609237f, -0.10613924f, -0.14311238f, 0.10153488f, 0.12834005f, 0.00723416f, 
    -0.07653074f, 0.03234786f, -0.01577264f, -0.11551528f, 0.00846543f, -0.16878535f, -0.00668377f, 0.15298492f, 
    0.10137310f, -0.22274116f, 0.07659820f, -0.04829279f, 0.06027194f, 0.26867786f, -0.15351453f, -0.30093071f, 
    -0.03586100f, 0.04983165f, 0.13815548f, -0.02895932f, -0.08756357f, -0.05425359f, 0.09270671f, 0.01970496f, 
    0.12486683f, -0.12684116f, -0.07119195f, -0.10367773f, 0.09038235f, -0.01050469f, 0.07975981f, -0.05952219f, 
    0.01912263f, -0.00520237f, -0.10170812f, 0.07525969f, -0.05175986f, -0.03373105f, -0.00509121f, -0.03442498f, 
    0.04700670f, -0.03260111f, -0.13279791f, 0.01838652f, 0.16913965f, -0.15009865f, -0.06033897f, -0.00214941f, 
    -0.15028656f, -0.07639455f, -0.02126144f, 0.04603180f, -0.09797966f, 0.00749264f, -0.10313124f, 0.04454952f, 
    0.12397028f, 0.05012904f, 0.09079533f, 0.05489864f, 0.07178541f, 0.31924677f, 0.15279584f, -0.10924278f, 
    0.09229976f, 0.06953077f, 0.05769124f, 0.11225586f, 0.14900157f, 0.01196340f, -0.08242782f, 0.17398821f, 
    0.06796259f, 0.18813105f, 0.09296469f, 0.22910790f, -0.01230438f, 0.04769873f, 0.03881162f, 0.14110151f, 
    -0.06314668f, -0.00155828f, 0.19257684f, 0.01083208f, -0.25143972f, -0.16681959f, 0.04772567f, -0.09424831f, 
    -0.02495463f, 0.02430956f, 0.14640334f, -0.07025668f, 0.03400584f, 0.13940415f, 0.18156081f, 0.07427645f, 
    -0.18831548f, -0.09103747f, 0.08466638f, 0.06948709f, 0.03192911f, 0.05403461f, 0.16921425f, 0.04879105f, 
    0.13828970f, 0.10966428f, 0.02275453f, -0.00305822f, -0.11766810f, -0.07698245f, -0.13362716f, -0.05521360f, 
    -0.04243906f, 0.01835089f, 0.05811432f, -0.01948277f, 0.05532637f, -0.04592862f, -0.20386466f, -0.10365889f, 
    0.30138230f, 0.09881916f, -0.02713337f, -0.03087930f, 0.05928625f, 0.14080024f, -0.17391823f, -0.02920906f, 
    -0.01702897f, 0.13140321f, 0.09995733f, 0.02792371f, -0.13054281f, -0.18315826f, -0.13363425f, 0.16346611f, 
    -0.10091820f, 0.08488759f, 0.19478099f, -0.00771789f, 0.08393080f, -0.07627288f, 0.02203348f, -0.06030985f, 
    0.11217228f, -0.04318005f, -0.13218462f, -0.02919922f, 0.04162721f, 0.05024233f, 0.03552492f, 0.02846407f, 
    0.03637789f, 0.10382528f, 0.03617546f, 0.00050355f, -0.18782540f, -0.06474381f, -0.36003149f, -0.26276788f, 
    -0.05964327f, 0.17151067f, 0.13453816f, 0.07908987f, -0.01634216f, -0.01384417f, -0.03708611f, 0.05567430f, 
    0.15993388f, 0.13818602f, 0.07965974f, 0.01711829f, -0.07928715f, 0.00675611f, 0.08485942f, 0.09023979f, 
    0.12243384f, 0.08938351f, -0.01638418f, 0.03062494f, -0.06041259f, -0.11170538f, -0.17781988f, -0.00942432f, 
    -0.07340100f, -0.03481628f, -0.05241576f, -0.07578988f, 0.06806575f, -0.01455865f, -0.02437360f, -0.08568444f, 
    0.02630166f, -0.07951201f, -0.09969571f, -0.03227192f, 0.10819484f, -0.17911334f, -0.12297011f, 0.04549934f, 
    0.12812354f, -0.12216816f, 0.04680901f, 0.05260056f, -0.15023433f, 0.46149927f, -0.26133606f, -0.18534519f, 
    0.17271732f, -0.03207167f, 0.08527653f, -0.13083790f, -0.07102420f, 0.08390445f, -0.01883819f, -0.04896652f, 
    0.21446262f, -0.00698738f, 0.18488315f, 0.17840086f, -0.16844895f, 0.10662554f, 0.01943646f, -0.12457556f, 
    0.05304354f, 0.01221336f, -0.01589498f, 0.01253550f, -0.13180412f, -0.16467805f, -0.07640109f, -0.14754294f, 
    0.04045821f, -0.01084032f, -0.07564253f, 0.07280018f, 0.05376475f, -0.07159546f, -0.07553964f, 0.06801239f, 
    -0.06531046f, -0.24173793f, -0.13846193f, -0.11639578f, -0.00876263f, -0.06366967f, 0.13369426f, 0.22069742f, 
    0.20470747f, -0.08973278f, -0.07569852f, -0.12628977f, 0.04015731f, 0.20365897f, 0.18173057f, 0.18053673f, 
    0.07109020f, 0.19280098f, -0.14866033f, -0.07508454f, 0.05718539f, 0.04464131f, -0.04194548f, 0.16945381f, 
    -0.24011074f, -0.23971894f, -0.09811035f, 0.01945334f, 0.04884837f, -0.07961465f, 0.15602110f, 0.26964635f, 
    -0.00274791f, 0.06188021f, 0.09435707f, -0.04867642f, -0.04232354f, 0.07006775f, 0.04317402f, 0.01838117f, 
    0.07208294f, -0.05294626f, 0.13208725f, 0.07427314f, 0.08929915f, 0.08620918f, 0.02297347f, 0.02927986f, 
    -0.21931487f, 0.04832536f, -0.03336740f, 0.21398810f, -0.07592162f, 0.00194983f, 0.12172623f, -0.01463268f, 
    0.10310666f, 0.08874315f, 0.22687933f, 0.20956187f, -0.22393295f, -0.05478917f, -0.10008809f, -0.09999417f, 
    0.13445430f, 0.03776826f, 0.03118437f, 0.01629223f, 0.14871541f, 0.08577838f, 0.10498659f, -0.12673126f, 
    -0.18210924f, 0.05781268f, -0.21628173f, 0.06299230f, -0.10686990f, 0.03806607f, 0.18741363f, 0.02522660f, 
    0.14552011f, -0.06277210f, -0.02647481f, 0.15363364f, -0.06718417f, 0.01424244f, 0.13193409f, -0.17496717f, 
    0.08991627f, -0.02484692f, 0.03884223f, 0.01236085f, -0.05269115f, 0.01561685f, -0.05839923f, -0.07392144f, 
    0.00073284f, 0.16398668f, -0.01034476f, -0.12667122f, 0.05076725f, 0.08190666f, 0.01565174f, 0.02066053f, 
    -0.08801515f, 0.07738476f, 0.16503280f, 0.02149590f, 0.05574096f, 0.21837614f, -0.02350273f, -0.18417667f, 
    -0.01264509f, -0.05659631f, 0.01674348f, -0.03838393f, 0.03803087f, 0.03997483f, -0.02103027f, 0.10126188f, 
    -0.33103609f, 0.12869568f, -0.16642475f, 0.00941691f, -0.26977378f, 0.08998686f, -0.06939961f, 0.15507378f, 
    0.06493588f, -0.02951816f, 0.00312995f, 0.05067368f, -0.07258639f, 0.18622662f, 0.22109593f, 0.08901101f, 
    0.09981429f, 0.05431114f, 0.02425212f, 0.08105939f, -0.02086695f, -0.08229891f, -0.03942252f, -0.04691942f, 
    0.05594546f, 0.02060179f, -0.03102442f, -0.05841489f, -0.01361713f, -0.03275962f, -0.00995961f, 0.00600018f, 
    -0.02690808f, 0.25766164f, -0.00046126f, -0.04692799f, -0.12936895f, 0.26056990f, 0.25636026f, 0.02447679f, 
    -0.10275353f, -0.14799578f, 0.07240788f, 0.00939679f, 0.15235503f, -0.06388667f, 0.08165226f, -0.13786437f, 
    0.07812200f, -0.05056415f, 0.22798210f, 0.08321688f, -0.18041815f, 0.05239453f, 0.04523816f, 0.02653926f, 
    0.09192145f, 0.10087632f, -0.06208427f, -0.03415122f, -0.09174976f, -0.24126825f, 0.01345768f, -0.00401737f, 
    -0.08908986f, 0.02880150f, -0.07671903f, -0.01853056f, -0.02775853f, 0.01687401f, 0.02036115f, -0.08011273f, 
    -0.35008746f, 0.14345263f, 0.21736033f, -0.20289789f, -0.00663199f, 0.04207273f, 0.07837947f, 0.05731683f, 
    -0.01121650f, 0.00163624f, 0.04991674f, 0.16247880f, 0.04147751f, -0.07493934f, -0.00318067f, 0.14467621f, 
    -0.17654938f, -0.00163674f, 0.13957432f, 0.04322375f, 0.04431408f, 0.04810917f, 0.17896082f, 0.01146333f, 
    0.07619142f, -0.00357317f, 0.03686228f, 0.06130683f, 0.07344668f, -0.07625183f, -0.10618574f, -0.06270847f, 
    0.09705386f, 0.04816357f, -0.11038008f, 0.10712888f, 0.30093870f, 0.05604957f, 0.04355698f, 0.25390312f, 
    -0.20834735f, 0.05012980f, -0.04031147f, -0.03623298f, -0.07766175f, -0.07999787f, -0.03205645f, 0.10301032f, 
    -0.17972732f, 0.07553902f, 0.09568426f, -0.08411439f, 0.00745533f, 0.04075020f, 0.01913466f, 0.00965090f, 
    -0.03569444f, -0.09075604f, -0.12767488f, -0.01935576f, -0.11099597f, 0.10937838f, 0.17678396f, 0.11678284f, 
    0.09168216f, -0.04936498f, -0.05566014f, 0.04309805f, 0.03732629f, 0.07721842f, 0.09670159f, 0.08272259f, 
    -0.04940337f, -0.06629993f, -0.01467510f, 0.05562412f, -0.04939890f, 0.03747442f, 0.02567405f, -0.02773073f, 
    -0.04544728f, 0.05899220f, -0.02607440f, 0.05555751f, -0.06388965f, -0.08208083f, -0.05969526f, -0.03476327f, 
    0.02093737f, -0.00177384f, -0.03405934f, 0.04804012f, -0.01085514f, -0.05016045f, -0.02935880f, -0.07127354f, 
    0.03143780f, 0.03128934f, 0.02354830f, -0.05680333f, 0.02195037f, 0.02208643f, -0.04039234f, 0.02050341f, 
    -0.08058207f, -0.05736326f, -0.01016391f, 0.01089714f, 0.03100465f, 0.05923225f, 0.00639890f, -0.03429157f, 
    -0.01219150f, 0.01332165f, -0.07594840f, 0.02076027f, -0.00277419f, 0.04598573f, 0.00704177f, 0.01419228f, 
    0.00509692f, 0.01568059f, -0.07325649f, 0.03566526f, 0.01232983f, -0.06848458f, -0.05092180f, -0.04952233f, 
    -0.04206781f, 0.01000783f, 0.06521159f, -0.02142076f, -0.00641306f, 0.00812458f, -0.01795864f, -0.05912689f, 
    -0.03397232f, -0.01146007f, 0.03127488f, -0.05535281f, -0.01323054f, 0.06362078f, -0.04922966f, -0.04655864f, 
    -0.06300759f, -0.03588577f, 0.05598582f, 0.05603838f, -0.06888406f, 0.00588260f, 0.05990192f, -0.01589948f, 
    -0.00724860f, -0.06465697f, -0.08034002f, -0.06582402f, 0.05962644f, -0.01585516f, -0.01624665f, -0.05361160f, 
    0.05043274f, 0.01876356f, 0.06497495f, -0.04213440f, 0.03628871f, -0.06348076f, 0.01553609f, 0.05460332f, 
    0.02306218f, -0.01647379f, -0.04028887f, -0.00912015f, 0.00114285f, -0.03588950f, -0.00573194f, -0.02110955f, 
    0.05257912f, -0.01186145f, 0.05605287f, 0.02777424f, -0.01456994f, -0.08071726f, -0.01680542f, -0.05667662f, 
    0.06636842f, 0.04956036f, 0.03180328f, 0.01268914f, -0.02928756f, -0.04422451f, -0.03897931f, -0.00566028f, 
    -0.06209946f, -0.06074384f, 0.06177770f, -0.04796218f, -0.02242189f, -0.04935224f, 0.03107467f, -0.01870536f, 
    -0.02368433f, -0.05313834f, -0.01394141f, 0.01588415f, 0.03355045f, 0.02333508f, 0.03839118f, 0.01385624f, 
    0.01912235f, -0.04697251f, 0.05306651f, 0.05273429f, 0.05105989f, 0.00269584f, 0.03673404f, 0.02543192f, 
    -0.02270489f, -0.06370939f, 0.05151515f, -0.01374952f, -0.06667488f, -0.00368156f, 0.02515518f, -0.03589539f, 
    0.06025054f, 0.02171704f, 0.00956096f, -0.00935979f, 0.01390062f, 0.04228370f, 0.05871675f, -0.07393628f, 
    0.00460504f, 0.04262837f, -0.07694774f, -0.00049584f, -0.03117085f, 0.02147810f, 0.05139827f, -0.07023741f, 
    -0.06043352f, -0.04270564f, 0.03055727f, 0.01155297f, -0.05141826f, 0.04449159f, -0.02018700f, 0.03841520f, 
    -0.03617435f, -0.07757644f, -0.05039926f, 0.04267465f, 0.04216937f, -0.02759349f, -0.04476753f, -0.02038322f, 
    -0.04454675f, -0.07022564f, -0.04344116f, -0.02269951f, -0.00784089f, -0.04948843f, -0.01415069f, -0.07723251f, 
    -0.04197830f, -0.06264596f, -0.13925879f, -0.10063585f, -0.00397117f, -0.08158225f, 0.14159092f, -0.12912564f, 
    -0.04824319f, -0.09147836f, -0.06195451f, 0.01459020f, 0.10067809f, 0.11405455f, 0.11496704f, -0.25254124f, 
    -0.02825253f, -0.06671485f, 0.10937244f, 0.00632120f, -0.04574114f, -0.01169145f, -0.05604772f, -0.02224766f, 
    -0.16762589f, 0.09660115f, -0.12814477f, -0.18825363f, 0.13049114f, -0.13425326f, -0.03476094f, 0.12627628f, 
    -0.17453289f, 0.10008171f, -0.05331355f, -0.00281778f, 0.26612428f, -0.02490639f, 0.00854933f, -0.06236133f, 
    0.10102075f, 0.07856612f, 0.08705607f, -0.00240475f, 0.07653352f, 0.11434029f, -0.00514681f, -0.04545602f, 
    -0.16858013f, -0.04357541f, -0.04367179f, 0.05224882f, 0.04745255f, 0.16882029f, -0.16895901f, -0.03036420f, 
    -0.03355300f, 0.03064884f, 0.13506857f, 0.07394251f, 0.12179504f, 0.14863504f, 0.13075905f, 0.16233014f, 
    -0.13926628f, -0.08788018f, 0.14113858f, -0.07541528f, 0.05872887f, -0.03421401f, -0.08060994f, 0.14817739f, 
    0.19494048f, 0.12359726f, 0.12288563f, -0.02224108f, -0.02946221f, 0.13698071f, 0.08012578f, -0.07555513f, 
    -0.05472670f, 0.14857136f, -0.04881298f, -0.04353361f, -0.28203526f, -0.01395805f, 0.35811859f, 0.06718236f, 
    -0.02021152f, 0.03979776f, -0.10415924f, 0.13780189f, 0.06751627f, -0.00745308f, 0.02662214f, 0.00610882f, 
    -0.08584178f, -0.03152857f, -0.16001044f, 0.19073059f, 0.06156788f, -0.02313357f, -0.04685394f, 0.15616195f, 
    0.01968154f, 0.13750282f, 0.10769949f, 0.03726371f, 0.01267032f, -0.14575140f, -0.10843454f, 0.04228316f, 
    0.00875632f, 0.06758625f, 0.12596421f, -0.01860404f, 0.05175502f, 0.08093727f, 0.02137076f, -0.09845089f, 
    0.05772671f, 0.11621208f, 0.13750006f, -0.05890529f, 0.04578818f, 0.06131320f, 0.18447705f, -0.13729937f, 
    0.02491269f, 0.00710277f, 0.07882191f, 0.01056479f, -0.20143840f, -0.33578581f, -0.17508006f, -0.02965447f, 
    -0.02133936f, -0.05951870f, -0.05983754f, 0.04775615f, 0.01358515f, 0.04117256f, 0.11167394f, -0.05761993f, 
    0.10953866f, 0.03567132f, 0.06296668f, -0.17014433f, -0.03398466f, 0.12393629f, -0.06698384f, -0.18134291f, 
    0.10046072f, 0.09555346f, -0.00627171f, 0.00562846f, 0.17314740f, -0.02173362f, -0.09208550f, 0.13531008f, 
    -0.08116350f, -0.01426668f, -0.09954604f, 0.07462309f, 0.11808027f, 0.04206045f, 0.11071089f, 0.10279120f, 
    0.35523292f, 0.15738575f, 0.25169766f, -0.07756125f, -0.01465560f, -0.00297822f, -0.13869826f, 0.03027718f, 
    -0.02310994f, 0.08592563f, -0.08795962f, -0.09469060f, 0.00912161f, 0.13093385f, 0.05491631f, 0.12307467f, 
    -0.02023114f, -0.03786283f, -0.13848971f, 0.02130767f, 0.00477065f, -0.17434214f, 0.05302915f, 0.01558504f, 
    0.00836053f, -0.02795667f, 0.05342232f, 0.06492273f, -0.05809569f, 0.04328594f, 0.04589688f, -0.01731864f, 
    -0.01605715f, 0.04986273f, 0.05513715f, 0.00020985f, -0.03669866f, -0.06118678f, 0.01180212f, 0.04189048f, 
    -0.07384542f, -0.06805557f, 0.03465059f, 0.01752304f, -0.02287187f, -0.03690513f, -0.05967716f, 0.02421810f, 
    0.06596036f, 0.00198654f, 0.03933122f, -0.06632255f, 0.02977716f, 0.03693730f, -0.04294634f, -0.02943910f, 
    0.00022034f, -0.04852166f, 0.05781699f, 0.03471628f, -0.02618086f, 0.03214906f, -0.02080450f, -0.03393641f, 
    0.02239174f, -0.04000669f, 0.00862383f, -0.01472980f, 0.06107367f, -0.02648701f, -0.03178665f, 0.03930039f, 
    -0.06294285f, -0.05233124f, 0.04824590f, -0.04245041f, -0.05634021f, -0.02964582f, 0.01375726f, -0.02947355f, 
    -0.01806461f, -0.00908535f, -0.02109810f, -0.01272565f, -0.05776603f, -0.00232195f, -0.04975419f, -0.01881954f, 
    -0.05918990f, -0.02799286f, -0.06540084f, -0.06903197f, 0.00687525f, 0.00117132f, 0.01843766f, 0.00315428f, 
    0.06587732f, -0.02125748f, -0.06356631f, 0.02845131f, -0.03490599f, -0.07028024f, -0.03699800f, 0.00865254f, 
    0.02340077f, -0.04620523f, 0.03479277f, -0.01568645f, -0.07328916f, 0.06665706f, 0.05918130f, -0.00393209f, 
    0.02264144f, 0.02517889f, -0.04934211f, -0.01490978f, 0.00840960f, -0.02315034f, 0.03862683f, -0.04886030f, 
    -0.00741397f, -0.04708149f, -0.06416716f, 0.02623281f, 0.02380423f, 0.02856286f, -0.02838470f, 0.01598786f, 
    0.00274888f, 0.02818901f, -0.07288212f, 0.03222620f, -0.05605602f, -0.04818933f, -0.06165320f, 0.05591360f, 
    -0.01946417f, -0.06605379f, -0.02811012f, 0.01687921f, -0.02307422f, 0.05503603f, -0.04815833f, -0.00757864f, 
    0.01737091f, 0.04862415f, 0.04563661f, 0.05028629f, -0.02869464f, -0.04037573f, 0.00969023f, -0.02495748f, 
    0.01983622f, -0.05475704f, -0.05635756f, -0.00372701f, -0.00359840f, 0.03764150f, -0.00533139f, 0.03297231f, 
    0.00621707f, -0.03311375f, 0.03832703f, -0.01983558f, 0.04630324f, -0.01593067f, 0.02396273f, 0.01920211f, 
    -0.02366009f, -0.07289261f, -0.00595686f, -0.03930498f, -0.05119509f, 0.05599531f, 0.02775806f, 0.02656706f, 
    0.01147177f, -0.05152683f, -0.02051366f, -0.07458340f, -0.04907024f, -0.04320385f, -0.06245738f, 0.03796967f, 
    -0.03468221f, 0.03471760f, 0.00593337f, -0.06488282f, -0.05485757f, 0.06233718f, -0.02967552f, 0.01364068f, 
    0.06194937f, 0.05267981f, 0.02041061f, -0.03351108f, 0.03185110f, 0.05527886f, 0.04505269f, 0.02116767f, 
    0.00556138f, -0.06277321f, 0.01388543f, -0.05753650f, -0.06389683f, -0.04745339f, 0.00041765f, -0.07720994f, 
    -0.03590617f, -0.00315839f, -0.04136076f, -0.03141970f, 0.01080266f, 0.02801969f, -0.04248354f, -0.04553402f, 
    -0.07764787f, -0.01418165f, -0.01485619f, 0.05213249f, -0.06049286f, -0.04718266f, -0.01185335f, -0.01280631f, 
    0.00428497f, -0.02288219f, -0.06094671f, 0.03382751f, 0.02015169f, -0.06099141f, -0.03270063f, 0.06139239f, 
    -0.00941456f, 0.00151772f, -0.02110958f, -0.00188600f, -0.05539407f, 0.06211048f, -0.07570691f, -0.05730420f, 
    -0.04848953f, 0.03201243f, -0.00313480f, -0.06510904f, 0.05274342f, -0.02397351f, -0.06409846f, 0.05896366f, 
    -0.05986022f, 0.05996927f, 0.04080125f, 0.02650157f, -0.05877446f, -0.00663793f, 0.05476255f, 0.01597183f, 
    0.02887201f, -0.06611119f, 0.01918893f, -0.01369464f, 0.05061460f, 0.04933224f, 0.02186978f, -0.06330305f, 
    -0.02746862f, -0.01507451f, 0.01302698f, -0.01982754f, -0.01121631f, 0.01571735f, -0.04933443f, 0.04816251f, 
    -0.06650506f, 0.05589269f, -0.03250808f, -0.06413807f, 0.01556350f, -0.03951398f, 0.01973991f, -0.03889814f, 
    0.06055899f, -0.05560692f, -0.06442428f, -0.03525652f, 0.03927584f, -0.00821125f, -0.07040609f, -0.05682991f, 
    -0.04356159f, -0.04365045f, -0.06135485f, -0.07095421f, -0.02226456f, -0.01084668f, -0.00018522f, 0.01453951f, 
    -0.02419534f, 0.03848194f, -0.00460313f, -0.07297791f, 0.04957700f, 0.04236411f, 0.00228614f, -0.02913119f, 
    0.02719231f, -0.04097844f, 0.04834180f, 0.04503086f, -0.04922185f, -0.04964058f, 0.04543772f, 0.06104588f, 
    0.05057706f, -0.03618872f, -0.06036448f, 0.04028122f, 0.01302218f, 0.04936993f, 0.05581399f, 0.00446542f, 
    -0.02942040f, 0.03773811f, -0.00110589f, -0.01373999f, -0.00339650f, -0.04758003f, -0.03508764f, 0.00221422f, 
    -0.01274991f, 0.02154489f, 0.05162363f, 0.01662731f, 0.06674591f, 0.06347884f, -0.06778599f, -0.04049512f, 
    -0.03664688f, 0.03577863f, -0.05680455f, 0.04430094f, 0.04830647f, -0.05329031f, -0.06947193f, -0.05081087f, 
    -0.02030065f, 0.01240500f, -0.01643958f, -0.05204181f, 0.05140673f, -0.04451751f, 0.04620839f, -0.01251962f, 
    0.00312562f, -0.00423137f, -0.00672043f, 0.04554814f, 0.00233273f, 0.05160284f, -0.06953494f, -0.02887706f, 
    0.02113327f, -0.01137024f, -0.04478901f, -0.04380671f, -0.07622369f, 0.01504391f, -0.07372701f, 0.01887470f, 
    -0.03868068f, -0.02815588f, 0.04397997f, 0.02280974f, -0.05370993f, -0.03849633f, -0.05625952f, -0.06791470f, 
    0.00988536f, -0.05062179f, 0.05791084f, 0.02871769f, -0.06441592f, 0.00251440f, -0.01283079f, -0.06538256f, 
    -0.00795143f, 0.01579945f, -0.03868150f, 0.02347222f, 0.01446087f, -0.06767752f, -0.05539989f, -0.04021455f, 
    0.01805123f, -0.00144165f, 0.02255567f, -0.05381234f, -0.00540180f, 0.00395850f, -0.05637421f, -0.01141296f, 
    -0.06727211f, -0.02142297f, -0.04718446f, -0.04777494f, -0.06400736f, 0.05200851f, -0.03199484f, 0.01818681f, 
    -0.02434058f, -0.04458125f, -0.06825181f, 0.01471589f, -0.01208783f, -0.06765766f, -0.05307825f, -0.05714104f, 
    -0.04546770f, 0.00939875f, -0.05305256f, 0.06643675f, 0.04128505f, 0.06790075f, 0.01262467f, 0.04983883f, 
    0.00091653f, 0.04950180f, -0.07019198f, 0.01267220f, 0.05199731f, 0.06390721f, 0.06217844f, 0.03850518f, 
    -0.06803738f, 0.03116421f, -0.00836014f, 0.05025439f, 0.02502148f, -0.03268845f, -0.00667522f, 0.07013562f, 
    -0.06148440f, -0.03092377f, 0.02200100f, -0.05618851f, 0.01239223f, -0.04966870f, 0.00757160f, -0.01607136f, 
    -0.04444148f, -0.02187775f, -0.05493846f, -0.00973010f, -0.03178045f, 0.02625332f, -0.03668115f, 0.01483408f, 
    -0.02199206f, -0.06876986f, -0.05607996f, 0.01569124f, 0.05685840f, -0.01682888f, -0.05680232f, -0.06818020f, 
    0.03287190f, 0.05925244f, -0.06447155f, -0.02300407f, 0.02674743f, 0.05402730f, -0.06633096f, -0.06695279f, 
    -0.06593279f, -0.05960574f, -0.04661732f, 0.01993928f, -0.00010142f, -0.06419813f, 0.00339235f, -0.05308091f, 
    0.05100734f, 0.03390049f, 0.00483159f, -0.04615709f, -0.01078368f, 0.03178570f, 0.00499519f, -0.05093861f, 
    0.04629925f, 0.04043885f, -0.00928348f, -0.02593572f, -0.03100827f, -0.03859888f, -0.02867872f, -0.04160542f, 
    0.02859442f, 0.04005440f, -0.01371211f, 0.05365567f, 0.04339755f, -0.03264785f, -0.03183756f, -0.04508242f, 
    -0.04411497f, 0.02023122f, 0.00145299f, -0.06336019f, -0.00585933f, -0.03799436f, -0.05997736f, 0.04558880f, 
    0.01742519f, 0.00485374f, -0.03679809f, -0.05150036f, -0.01816085f, 0.03202904f, -0.05430402f, 0.05481634f, 
    -0.04868241f, 0.01740012f, 0.06885313f, -0.00429968f, 0.05625113f, 0.01816524f, -0.03237900f, -0.02748195f, 
    -0.01674046f, -0.05072952f, -0.05552668f, -0.05319028f, 0.04718290f, -0.02739311f, 0.03368032f, -0.07133920f, 
    0.03423313f, -0.06240110f, -0.04335271f, 0.01820480f, -0.05979455f, 0.06783031f, -0.06397493f, 0.06003249f, 
    -0.02907762f, -0.06533158f, 0.01993308f, 0.00317945f, -0.03703527f, -0.02946918f, 0.00325557f, 0.06020612f, 
    0.04231985f, -0.05698360f, -0.00612929f, -0.06864623f, -0.06144608f, -0.05294047f, -0.01198540f, 0.03848055f, 
    -0.05690685f, -0.05023553f, 0.02847430f, -0.03786501f, 0.06005694f, -0.02560955f, -0.01407982f, 0.04861325f, 
    0.06130227f, 0.00016187f, -0.00670547f, 0.06263196f, 0.06740998f, -0.06144444f, 0.07162403f, -0.04467641f, 
    -0.00002448f, 0.01321370f, -0.02764498f, 0.05124371f, 0.00284602f, -0.00481719f, 0.04847767f, -0.05803667f, 
    0.02035957f, -0.04024475f, 0.06022162f, -0.06083414f, 0.02367220f, -0.06125124f, -0.05137976f, 0.01483180f, 
    0.02489862f, 0.01915975f, 0.00895988f, -0.02862813f, 0.03831626f, -0.00416492f, 0.03531700f, 0.06164202f, 
    0.41704804f, 0.28335226f, -0.04638810f, 0.31677991f, -0.02214561f, 0.02289611f, 0.07554608f, 0.00316667f, 
    0.13809960f, 0.11123875f, 0.11158099f, 0.03223829f, -0.23389228f, -0.03902664f, 0.08987559f, -0.12359238f, 
    0.05755860f, -0.13726799f, 0.15946369f, 0.16802847f, -0.17957717f, -0.03659981f, -0.13622858f, 0.00950441f, 
    -0.05409586f, 0.24913226f, -0.11283029f, 0.26414433f, 0.05675968f, 0.20050126f, 0.03009743f, 0.04512316f, 
    0.25321782f, 0.07921125f, -0.03083001f, 0.06714071f, -0.22442339f, 0.03824729f, -0.07567902f, -0.10165203f, 
    0.16104837f, 0.11509959f, -0.07983601f, 0.04943721f, 0.02401503f, -0.06971671f, -0.07704876f, 0.04542335f, 
    0.72496742f, 0.20472294f, 0.16481848f, -0.09843994f, -0.02793399f, -0.09523304f, 0.11849349f, 0.02386224f, 
    -0.04719989f, 0.13755549f, 0.05130736f, 0.07076093f, -0.11711415f, 0.01864132f, -0.08786446f, -0.23266540f, 
    0.04356517f, 0.08633019f, 0.11014930f, -0.03375653f, 0.01803578f, 0.06578942f, 0.03507214f, 0.14467135f, 
    -0.39208913f, -0.23646167f, -0.16416799f, -0.15407914f, 0.11435019f, -0.01788814f, -0.08282949f, 0.05047239f, 
    -0.00618604f, 0.09316535f, -0.05312759f, 0.06112343f, -0.30336416f, 0.07093854f, 0.11348763f, -0.14883003f, 
    0.04654770f, 0.00647568f, 0.07091022f, 0.00382664f, -0.15713522f, 0.04090912f, -0.00255876f, 0.05441076f, 
    0.38154384f, 0.18260109f, 0.12756720f, 0.33522388f, -0.06107310f, 0.04657133f, 0.07031672f, 0.02368635f, 
    0.06757592f, 0.11483450f, -0.00781293f, 0.08082359f, 0.14422193f, 0.03852749f, 0.23642868f, -0.31685317f, 
    0.03837296f, 0.10933963f, -0.02335082f, -0.14447001f, -0.12347463f, 0.02058327f, 0.00555914f, -0.02629176f, 
    -0.39618766f, 0.00405984f, -0.10820099f, -0.01101978f, 0.00106033f, 0.04360998f, -0.04841365f, 0.10206392f, 
    0.02262353f, 0.03640110f, 0.13398516f, -0.09020922f, 0.39881954f, 0.31154394f, 0.11127149f, 0.34657547f, 
    0.03508065f, -0.06627223f, 0.02038360f, -0.08900420f, 0.02398503f, 0.03436716f, 0.02210400f, 0.03096138f, 
    -0.46062639f, -0.11324919f, -0.21998380f, 0.06519111f, 0.00319744f, 0.01269656f, -0.06754325f, 0.13972676f, 
    0.04174720f, -0.09754297f, -0.07180472f, -0.03743949f, -0.08149667f, 0.11830314f, 0.09139506f, -0.11861066f, 
    -0.08216166f, -0.03395422f, 0.00778704f, 0.05585510f, -0.07353684f, 0.00376251f, -0.02658539f, -0.04856590f, 
    0.34031615f, 0.31445980f, 0.02712905f, -0.03792310f, 0.01858404f, 0.08061902f, -0.06626564f, -0.08595604f, 
    0.09957384f, -0.12747675f, 0.08752397f, 0.10853010f, -0.31374043f, 0.04707965f, -0.07410251f, -0.06882758f, 
    -0.06350535f, -0.02746772f, -0.14343223f, -0.07255571f, -0.06497249f, 0.08696204f, -0.02783555f, 0.02144941f, 
    0.03872345f, -0.04918760f, 0.00427059f, -0.03397658f, -0.03951724f, -0.06732732f, -0.02366354f, -0.06614339f, 
    0.01934740f, -0.02914409f, 0.06038825f, 0.04947710f, -0.03098366f, 0.04308641f, 0.02868714f, -0.03620011f, 
    -0.02259480f, 0.04128595f, 0.03741321f, 0.01144961f, -0.03023712f, -0.02689639f, -0.03816400f, -0.00032168f, 
    0.03601117f, -0.07536275f, -0.07493962f, -0.01037008f, 0.05049492f, -0.01131230f, -0.00628118f, 0.04956789f, 
    -0.06266534f, 0.00626465f, -0.06429875f, 0.02728437f, -0.03991135f, 0.04531918f, -0.02810963f, -0.03664586f, 
    -0.04140065f, 0.05580585f, -0.02985539f, -0.04508256f, 0.02621365f, -0.07719626f, 0.06221778f, 0.04038089f, 
    0.04181556f, -0.07002281f, 0.03583658f, 0.04004287f, 0.00607386f, 0.00726021f, 0.06409407f, 0.02114590f, 
    -0.00832287f, 0.01287883f, -0.02331350f, -0.01660204f, -0.05288816f, -0.05512435f, 0.06121628f, -0.02553410f, 
    0.04488419f, -0.06530101f, -0.03261930f, -0.05484402f, -0.05678054f, -0.00527958f, 0.03193187f, 0.03467897f, 
    -0.01532749f, -0.06960370f, 0.04367354f, 0.05551404f, 0.01726995f, -0.07410663f, -0.06007056f, -0.07877298f, 
    -0.02110702f, 0.02033652f, 0.00639857f, -0.00004880f, 0.02763248f, -0.02835694f, -0.06404010f, -0.07696242f, 
    -0.03960423f, 0.00310255f, -0.06596337f, 0.00097893f, 0.06169554f, -0.06465826f, 0.02026154f, -0.04287879f, 
    -0.07825319f, 0.01238610f, -0.07632602f, -0.01365078f, 0.00564999f, -0.05120274f, 0.05330652f, -0.04017439f, 
    0.05593843f, 0.03456486f, -0.06116501f, -0.06096319f, -0.01733499f, 0.04014493f, 0.00046103f, -0.04308891f, 
    -0.04197429f, -0.03551861f, -0.01726285f, -0.00659995f, 0.00253742f, 0.03220692f, -0.03711516f, 0.01617875f, 
    -0.03580458f, -0.03898949f, -0.06807917f, -0.01326213f, -0.07875925f, -0.04983275f, -0.03110485f, -0.06242505f, 
    0.00531149f, -0.06900118f, 0.03296226f, 0.01635725f, -0.07760690f, -0.05678876f, -0.01501019f, 0.04905043f, 
    0.04647984f, 0.05001813f, -0.01727504f, -0.01855773f, 0.00085212f, -0.05928951f, -0.07661627f, 0.05897322f, 
    0.04625246f, 0.02309066f, 0.03307182f, 0.02086981f, 0.03016861f, -0.01847734f, -0.07286277f, -0.02588083f, 
    -0.05023780f, 0.00864922f, -0.07227120f, -0.08039801f, -0.05661127f, 0.00749982f, 0.00455582f, 0.06080419f, 
    -0.06305249f, -0.02204658f, -0.06205816f, -0.04298333f, -0.04152861f, 0.00589944f, 0.03067422f, 0.00756407f, 
    -0.05137330f, 0.05715427f, -0.04527945f, -0.02972583f, 0.03038264f, 0.04212926f, -0.02845635f, 0.02340116f, 
    -0.06663146f, -0.00305421f, -0.00785692f, 0.02461375f, 0.03853115f, 0.00506785f, -0.01929607f, -0.02379668f, 
    -0.03754660f, 0.05962240f, 0.02270179f, -0.00150686f, -0.07572759f, 0.06239217f, -0.07386088f, 0.00039534f, 
    -0.17669779f, -0.00460151f, -0.02611309f, -0.14672169f, 0.02974573f, 0.00832129f, -0.01972110f, -0.01614699f, 
    -0.04354328f, 0.02289464f, -0.01892844f, -0.03517410f, 0.11487963f, 0.14852792f, -0.08111177f, 0.13096537f, 
    0.09619063f, 0.04142072f, 0.01149021f, -0.09003066f, -0.03322769f, -0.03822819f, -0.02815744f, -0.02635439f, 
    0.00638091f, 0.01824330f, 0.11973494f, -0.24944253f, 0.08534986f, -0.05976584f, -0.02629137f, 0.00220213f, 
    -0.09776535f, 0.08256623f, 0.14790933f, 0.01984730f, -0.13662547f, -0.03166180f, -0.01299563f, -0.06035803f, 
    0.01988640f, 0.01012444f, 0.11551587f, -0.06515776f, -0.00511439f, 0.03493682f, 0.02152968f, 0.11545549f, 
    -0.35061282f, 0.08145240f, -0.00512145f, 0.08295111f, -0.08036954f, 0.02457113f, 0.01415607f, 0.03727849f, 
    0.01410310f, -0.00242886f, 0.12587421f, -0.05745857f, -0.12608545f, 0.01427384f, 0.15113097f, 0.28942236f, 
    -0.04943533f, -0.05147136f, -0.11083351f, 0.07516743f, 0.01649839f, 0.01176356f, -0.05982115f, 0.04215235f, 
    0.15421437f, 0.07696221f, 0.02004030f, -0.08474547f, -0.08565003f, -0.00368900f, -0.05675972f, 0.01086231f, 
    -0.02986732f, 0.04931234f, 0.02321266f, -0.14345232f, 0.17470984f, -0.15411574f, 0.11813337f, 0.32928181f, 
    -0.01532921f, -0.15716676f, 0.07693309f, 0.12854221f, 0.09711941f, 0.05333418f, -0.09340426f, 0.00973093f, 
    0.01013235f, 0.03883091f, 0.07921077f, -0.22344196f, -0.04909513f, 0.05350593f, 0.03580808f, -0.00998055f, 
    0.07592986f, 0.00397293f, -0.04870179f, -0.01761111f, -0.16929701f, -0.22005311f, -0.12243647f, 0.11719205f, 
    -0.03895725f, -0.06130710f, 0.14002913f, 0.14131032f, 0.07974173f, 0.15956941f, 0.06789047f, -0.11208390f, 
    0.03764862f, 0.11718120f, -0.02830631f, -0.24518862f, 0.10452341f, 0.17563534f, 0.13732004f, 0.06300257f, 
    0.04042218f, 0.00714755f, -0.02292648f, 0.14980039f, -0.03409203f, 0.03640239f, -0.07734279f, -0.03767223f, 
    -0.13009281f, 0.13117869f, 0.06791239f, 0.08942974f, 0.09412421f, -0.02292159f, 0.08893634f, 0.03913331f, 
    0.05521968f, -0.09983309f, -0.06348950f, 0.06833341f, 0.17583290f, 0.06677204f, -0.06242201f, -0.05020664f, 
    0.04947866f, -0.01956364f, 0.05196454f, -0.06067906f, 0.06421808f, 0.02462406f, 0.16909075f, 0.39515221f, 
    -0.04102353f, 0.01028257f, -0.12779467f, 0.06084447f, -0.02916395f, -0.02521561f, 0.06072233f, 0.01806160f, 
    -0.23775141f, -0.06991212f, 0.11819272f, 0.25100988f, 0.08219162f, -0.11727352f, -0.08536290f, 0.11427202f, 
    -0.17376356f, -0.07073525f, 0.01350194f, -0.09944420f, 0.09597583f, 0.17012160f, 0.13378464f, -0.00457493f, 
    -0.03930253f, 0.00517154f, 0.03922871f, 0.06695586f, -0.07976671f, -0.03395167f, 0.02058238f, -0.04666776f, 
    0.05229838f, -0.04863730f, 0.02255223f, 0.01704485f, -0.05218788f, 0.06034699f, 0.02155064f, 0.03570845f, 
    -0.05811906f, 0.03535667f, -0.02078345f, -0.05741389f, 0.02951925f, -0.01818510f, -0.05568885f, -0.01998494f, 
    0.02953751f, 0.01339949f, -0.04719498f, 0.03004069f, 0.05638909f, -0.02357868f, 0.04390818f, 0.05785549f, 
    0.01266921f, 0.02717514f, -0.06634219f, -0.03205766f, 0.03831208f, -0.01136726f, -0.02145361f, 0.01882078f, 
    0.02064029f, -0.04131123f, -0.04879342f, -0.02401460f, -0.07026941f, -0.05271241f, -0.01909746f, 0.01330279f, 
    0.04170543f, 0.01787298f, 0.01400157f, -0.04020557f, -0.04558843f, -0.02089985f, -0.04484295f, 0.03630421f, 
    -0.01792344f, -0.07773798f, 0.04938651f, -0.03725134f, 0.06174428f, 0.03230313f, 0.01408895f, -0.03608985f, 
    -0.03265273f, -0.00388166f, 0.04142421f, -0.05282521f, -0.08122066f, -0.08474887f, -0.03171665f, 0.00720894f, 
    -0.05876671f, 0.06142357f, -0.05937967f, -0.05796473f, -0.06633049f, -0.02325693f, 0.01674949f, 0.05643988f, 
    0.06264328f, -0.02065669f, 0.05968509f, 0.01689257f, -0.00279924f, 0.00796125f, 0.00545215f, 0.00434970f, 
    -0.03911187f, 0.06509571f, -0.04782384f, 0.00144044f, 0.05693032f, -0.03990517f, -0.06037538f, -0.03891125f, 
    0.02861838f, 0.04628620f, -0.01158011f, -0.02008164f, -0.03202425f, -0.06030670f, 0.07199658f, 0.05725484f, 
    -0.06197927f, -0.07720914f, 0.03970123f, 0.04320886f, -0.02167375f, 0.03671557f, -0.06390730f, -0.06350841f, 
    -0.00992749f, -0.05639584f, -0.00716502f, -0.01076259f, 0.02241140f, -0.01603745f, 0.03662533f, 0.04079796f, 
    -0.02191114f, 0.03675539f, -0.02724695f, -0.01984646f, 0.06176905f, -0.07919843f, -0.00093252f, -0.01910654f, 
    -0.03186140f, -0.03197990f, -0.02155508f, -0.07188287f, -0.04641066f, -0.01969105f, -0.07242305f, -0.00062843f, 
    0.01493971f, -0.04315687f, 0.05079736f, -0.05187619f, -0.05611286f, -0.06090119f, -0.00378295f, -0.04545363f, 
    -0.01973886f, -0.01645734f, 0.01608294f, 0.02762171f, -0.03388796f, -0.06907301f, 0.06797369f, 0.00190245f, 
    0.00139346f, 0.00988303f, 0.00207374f, 0.04765308f, -0.06318771f, 0.04341644f, 0.06884073f, -0.03672007f, 
    0.02790197f, -0.06542922f, 0.00533775f, 0.06189574f, -0.07522620f, -0.06801160f, -0.05270058f, 0.00651380f, 
    -0.03843629f, -0.04294356f, -0.06727947f, 0.03457805f, -0.06448178f, -0.04964220f, -0.06927719f, 0.05525609f, 
    0.02635131f, 0.01694829f, 0.05716199f, -0.01102248f, 0.03599487f, -0.00278232f, -0.05548774f, 0.03737803f, 
    -0.01954642f, 0.04002276f, -0.03921485f, -0.02554369f, 0.05122947f, -0.05200506f, -0.05177983f, 0.03659100f, 
    0.00048284f, 0.04986455f, -0.08315540f, -0.05168595f, 0.04219596f, -0.03753517f, -0.06159585f, 0.02011804f, 
    -0.20745631f, -0.02181858f, -0.19283456f, -0.24274987f, 0.05180022f, -0.01339561f, 0.09140348f, 0.00672949f, 
    -0.05259353f, -0.06009959f, 0.04052618f, 0.16822010f, -0.03194775f, -0.04363815f, 0.01050867f, 0.24347796f, 
    0.04763573f, 0.13523611f, 0.02669363f, 0.06530846f, 0.00513255f, 0.06866194f, -0.03696157f, -0.19604596f, 
    -0.21839632f, 0.10613441f, -0.06210740f, -0.17699201f, 0.05060123f, 0.00767289f, -0.03532226f, 0.11413479f, 
    -0.04658010f, 0.03711310f, 0.05698444f, -0.02299332f, 0.00590392f, -0.02392923f, -0.05349148f, 0.03854216f, 
    0.01033765f, 0.03882480f, 0.04039992f, 0.14370963f, 0.10214344f, 0.00423567f, -0.10155035f, 0.12154533f, 
    -0.09082017f, -0.15767524f, 0.16401470f, 0.09857486f, 0.03171786f, 0.16737807f, -0.03422485f, -0.07250947f, 
    0.20867625f, 0.11714674f, -0.01777706f, -0.00266474f, 0.28973719f, -0.20138852f, 0.10763268f, 0.21958500f, 
    -0.01204090f, 0.00335054f, 0.02774181f, -0.08072713f, -0.05564343f, 0.11396128f, 0.07665841f, -0.04394611f, 
    0.25398427f, 0.04974709f, 0.13852030f, 0.05461633f, -0.06277425f, -0.07855445f, 0.12113454f, 0.03615598f, 
    0.07977737f, 0.01773760f, 0.15910497f, 0.09384040f, 0.00379833f, 0.36223620f, 0.02348913f, -0.05965653f, 
    0.01667341f, -0.06583042f, 0.11922479f, 0.03405064f, 0.01799409f, 0.07029122f, 0.05504827f, 0.03500153f, 
    -0.32320061f, -0.20397338f, -0.03831572f, -0.01983526f, 0.04396347f, 0.10068797f, 0.06029012f, 0.02552957f, 
    0.02675415f, -0.03320645f, -0.01661582f, -0.02624458f, -0.22705224f, -0.13465835f, -0.17839690f, 0.04941234f, 
    0.19002035f, 0.05385952f, -0.02169883f, 0.09882009f, -0.03065073f, -0.04995616f, -0.07663085f, -0.02319887f, 
    -0.20675790f, -0.10379224f, 0.09169352f, 0.04538740f, -0.02505440f, -0.13692309f, 0.03257052f, 0.07661124f, 
    -0.04798516f, -0.03473015f, 0.13253570f, -0.05514327f, 0.04069212f, -0.04863898f, -0.04984317f, -0.30328530f, 
    -0.00284540f, 0.07963264f, -0.02509657f, 0.08305701f, 0.06113843f, 0.00586066f, 0.05039295f, -0.04039746f, 
    0.23175341f, 0.13031341f, 0.19433458f, -0.00409382f, -0.01718950f, 0.04378559f, 0.12269872f, 0.05451348f, 
    0.05328367f, 0.03095371f, -0.02971854f, 0.11443658f, 0.13679557f, -0.09356888f, -0.01772129f, 0.02309847f, 
    0.07999073f, -0.00944422f, 0.04431466f, -0.03512474f, -0.02939947f, -0.06454464f, 0.04168901f, 0.02790532f, 
    -0.05628072f, -0.06356370f, 0.23631924f, 0.18619056f, -0.08009506f, -0.04832021f, -0.07056809f, -0.02705919f, 
    0.05761563f, 0.11801557f, -0.04398033f, -0.04507268f, -0.28422913f, 0.25141481f, -0.05563462f, 0.11622564f, 
    0.04552275f, -0.09528266f, -0.04634479f, 0.08308260f, -0.01127314f, -0.03908141f, -0.03388274f, -0.01020190f, 
    -0.13192631f, 0.01989052f, 0.04513915f, 0.17530996f, -0.00350053f, -0.02359263f, -0.07603779f, -0.05366715f, 
    0.06803980f, 0.14435042f, 0.07538819f, 0.00174122f, 0.14214292f, -0.16793840f, -0.11378255f, -0.07793648f, 
    -0.01677202f, 0.01998276f, -0.05429176f, -0.00166329f, 0.03966583f, -0.00403492f, -0.09137294f, 0.08469080f, 
    -0.14195453f, 0.21739584f, -0.03340972f, -0.11269160f, 0.05834039f, 0.01782764f, 0.07448637f, 0.01021822f, 
    0.02288783f, -0.00741233f, -0.02324955f, 0.08082214f, -0.15686128f, 0.02770231f, -0.22003224f, -0.08162836f, 
    -0.06048628f, -0.02874998f, -0.08410571f, -0.12681708f, -0.09390312f, -0.07268199f, 0.11624292f, -0.01704744f, 
    0.31883949f, 0.11273652f, -0.07074004f, -0.09350301f, -0.19953814f, -0.08032048f, -0.05181626f, 0.17555647f, 
    -0.05991461f, 0.00611692f, 0.04793324f, -0.04241601f, -0.39414281f, 0.02888130f, 0.21929747f, 0.03247023f, 
    -0.02962469f, -0.01170991f, 0.01493502f, -0.04765763f, -0.04428376f, 0.07237552f, -0.00207319f, -0.01275178f, 
    0.06453356f, -0.04257208f, -0.08264012f, 0.05518978f, 0.01004769f, 0.03563539f, -0.04898319f, 0.02359063f, 
    0.10317302f, -0.01674820f, 0.01360419f, -0.07220528f, -0.25386253f, 0.13158724f, -0.00840361f, -0.10538218f, 
    0.07312676f, -0.10832238f, 0.05331138f, 0.10190896f, 0.00932241f, 0.08635453f, -0.04467421f, -0.03682671f, 
    0.29387939f, -0.05709834f, 0.36225575f, 0.08536087f, -0.14365231f, 0.06012047f, 0.05333826f, 0.04983413f, 
    0.02767384f, -0.02853049f, -0.00377185f, -0.01644570f, 0.14970244f, -0.22956461f, 0.17905080f, 0.00820722f, 
    0.01044624f, 0.00897369f, -0.00901059f, 0.22197078f, -0.09059554f, -0.05203402f, 0.06569693f, -0.02434702f, 
    0.15775208f, 0.08744077f, -0.07723539f, -0.17248328f, 0.12561019f, 0.12856062f, -0.03330820f, 0.08894985f, 
    0.04003152f, -0.11683756f, -0.14752527f, 0.04463180f, -0.00701845f, -0.01497755f, 0.08577327f, 0.33789378f, 
    -0.12304783f, 0.11803739f, 0.00351427f, -0.02728187f, 0.08710637f, -0.02338246f, -0.15886070f, 0.08115334f, 
    -0.08004443f, -0.11581564f, -0.04629812f, 0.03725287f, 0.09071922f, -0.00385701f, -0.10020054f, 0.11085156f, 
    0.07095296f, 0.08174346f, -0.01706406f, 0.08118663f, 0.22263013f, -0.18200856f, 0.09244110f, 0.12369899f, 
    -0.09392827f, -0.07387042f, -0.00759012f, 0.04221192f, -0.04964839f, 0.05659687f, -0.11053014f, -0.02921170f, 
    0.18806697f, 0.18437745f, -0.07748105f, 0.21253137f, 0.02947536f, 0.02127931f, 0.14490701f, 0.16458936f, 
    -0.00966976f, -0.09178760f, 0.00217545f, 0.14226229f, -0.13402155f, 0.12107868f, 0.08385205f, 0.14054517f, 
    0.00828329f, 0.09628155f, 0.05515480f, -0.00482166f, -0.13148381f, 0.04109305f, 0.10924964f, -0.17956695f, 
    -0.29866967f, -0.02022031f, -0.13578169f, 0.12217575f, -0.02791206f, 0.10446027f, 0.05248898f, 0.12389818f, 
    0.04803084f, 0.03298609f, 0.05917367f, 0.13775617f, 0.07893869f, -0.15404065f, -0.04532762f, -0.03255807f, 
    -0.10077557f, -0.11039607f, 0.08790975f, -0.05255561f, -0.06260577f, -0.00810373f, -0.07309270f, -0.05949895f, 
    0.00969411f, 0.01885468f, -0.06664506f, -0.07700060f, 0.00870485f, 0.15213218f, 0.09556173f, 0.06324334f, 
    -0.07075575f, 0.05673425f, 0.07107040f, 0.01674316f, -0.00849782f, 0.22909187f, -0.07515158f, -0.02354570f, 
    0.07802301f, -0.00205931f, -0.02007078f, 0.07388271f, 0.06567074f, -0.04907998f, 0.01074971f, -0.02469775f, 
    -0.07857268f, 0.10805631f, -0.01264093f, -0.11671930f, -0.10987498f, -0.04208861f, 0.00077357f, 0.07992665f, 
    0.04993861f, -0.01335079f, 0.03593067f, -0.00947240f, -0.33636108f, -0.10435897f, 0.20933104f, -0.20022081f, 
    -0.00481899f, 0.14453346f, 0.16618130f, 0.06607912f, 0.03774355f, -0.05601680f, 0.01002897f, -0.06994428f, 
    0.06008830f, 0.05019137f, 0.02042607f, 0.02430492f, 0.00511907f, 0.06507461f, -0.08256124f, 0.03897019f, 
    0.07916231f, 0.13663624f, 0.09114124f, 0.05665059f, -0.24776292f, 0.43766788f, -0.10972317f, -0.14804496f, 
    -0.05630108f, 0.04065683f, 0.00697059f, 0.04164819f, 0.13906670f, 0.12407785f, 0.12986510f, 0.04831043f, 
    0.40856639f, -0.08480701f, 0.24378428f, 0.03369407f, -0.08766509f, 0.15937606f, 0.07442994f, 0.10593147f, 
    0.02489155f, 0.08749499f, -0.00381615f, -0.01167796f, 0.01405973f, -0.36413237f, 0.16809027f, -0.16622804f, 
    0.02210451f, 0.07417381f, -0.03138601f, -0.04862383f, -0.02291409f, -0.17791860f, 0.10463617f, -0.10559301f, 
    -0.07206739f, 0.08798771f, -0.03039859f, -0.16158190f, 0.01790360f, -0.01535413f, 0.01628683f, 0.05695760f, 
    0.08135399f, -0.07206607f, -0.02808056f, 0.15159643f, 0.00054059f, -0.03266417f, -0.04465216f, 0.07165496f, 
    -0.10656990f, 0.08453150f, 0.06964027f, 0.05388090f, 0.02428083f, 0.13061377f, 0.01982397f, -0.00161043f, 
    -0.05437061f, -0.04983958f, -0.14401051f, 0.00769105f, -0.07450075f, -0.01606438f, 0.01694896f, 0.11875825f, 
    0.04221910f, 0.07259169f, 0.07074913f, 0.04945925f, 0.33819553f, -0.20724642f, 0.06579885f, -0.04443521f, 
    -0.01267599f, 0.09076542f, 0.01402429f, -0.08360329f, -0.08644027f, 0.04628784f, -0.03018307f, 0.09646874f, 
    0.10153328f, 0.35499802f, 0.14194274f, -0.09147068f, -0.04317033f, 0.03277684f, 0.10209294f, 0.00911661f, 
    0.01749817f, -0.04737914f, -0.12426230f, 0.09522828f, -0.04547068f, 0.09821473f, -0.02558055f, 0.04103327f, 
    -0.02275158f, -0.01998688f, 0.15963665f, -0.00665746f, -0.03612872f, 0.04384494f, 0.09231401f, 0.07234061f, 
    0.11985511f, -0.05189810f, -0.11250478f, 0.10460606f, 0.12112675f, 0.09893860f, -0.12511244f, 0.01366374f, 
    0.14298072f, -0.00235560f, 0.04703833f, -0.11097907f, 0.16134134f, -0.11001307f, -0.19273070f, -0.33977854f, 
    -0.12328141f, -0.20944144f, 0.01173005f, 0.03318893f, 0.03996012f, 0.03926491f, 0.01012258f, 0.02096847f, 
    -0.07626962f, 0.03578698f, -0.20334886f, 0.09428418f, 0.12334698f, 0.11735111f, 0.00743571f, 0.07552817f, 
    0.11899676f, 0.06117591f, -0.08364876f, 0.12762962f, 0.02254136f, -0.05368383f, -0.16426732f, 0.19110253f, 
    0.02464522f, 0.10226771f, 0.04333566f, 0.02821432f, 0.00069328f, 0.06493395f, -0.03774247f, -0.07196014f, 
    0.18168227f, 0.04804524f, -0.01608129f, -0.11205058f, 0.06092078f, -0.09580708f, -0.02288996f, -0.13875897f, 
    0.08712039f, -0.04960710f, 0.02203548f, 0.04014860f, -0.28676453f, 0.06240318f, -0.00846948f, 0.00771206f, 
    0.00094280f, -0.02531251f, 0.17945108f, -0.01439214f, 0.11598143f, 0.06735510f, 0.09365778f, 0.01513617f, 
    0.06115473f, 0.04978634f, -0.05366500f, 0.19584559f, 0.08056520f, 0.01985982f, -0.01238023f, -0.04969981f, 
    0.14401279f, -0.21796530f, 0.15123494f, 0.14539248f, -0.10712858f, 0.20453024f, -0.15389435f, -0.12576273f, 
    0.05999153f, 0.13040221f, 0.07198637f, 0.13855760f, 0.06250211f, 0.10556584f, -0.02060239f, 0.01414026f, 
    -0.02634674f, -0.16132644f, 0.02887480f, 0.08436964f, 0.02193466f, -0.02560056f, 0.01468309f, 0.06010055f, 
    0.11392219f, -0.06695905f, 0.13207518f, 0.03427786f, 0.21838099f, 0.04644399f, 0.05192805f, -0.06295044f, 
    0.00567890f, -0.01844161f, -0.07309535f, 0.07839541f, -0.01927193f, 0.00891476f, 0.06585557f, -0.00730271f, 
    0.30464634f, -0.01707549f, -0.14503004f, -0.05485128f, -0.04542803f, -0.01739285f, -0.10131232f, 0.05650942f, 
    0.06088531f, -0.01310395f, -0.00461744f, -0.04172429f, -0.12980691f, -0.01663850f, -0.02067234f, 0.11427416f, 
    -0.03784021f, -0.01458033f, 0.02285294f, 0.11658768f, -0.10066906f, 0.03774441f, -0.03182518f, 0.09780186f, 
    -0.06709488f, 0.00416413f, -0.13009660f, -0.20316358f, -0.10748146f, 0.11350042f, -0.01387856f, 0.01009697f, 
    -0.06696022f, 0.16631322f, -0.01378371f, -0.04234082f, -0.13862568f, -0.20963062f, 0.06829332f, -0.16342002f, 
    -0.02344505f, -0.06114993f, 0.04732253f, 0.01742475f, 0.05798732f, 0.08585826f, -0.00519149f, 0.03012764f, 
    0.20445390f, 0.21194814f, 0.09133980f, -0.07697076f, 0.01104612f, 0.12135559f, 0.11532527f, 0.04208986f, 
    0.07167097f, -0.01993692f, -0.02211269f, 0.15119147f, -0.01891294f, -0.04173056f, -0.02626581f, 0.13177003f, 
    -0.02857268f, -0.01384054f, -0.02487348f, 0.00172520f, -0.10574506f, -0.10669968f, 0.05162488f, -0.10790844f, 
    0.01340484f, 0.01429062f, 0.04689460f, 0.01049687f, -0.05216471f, 0.06549937f, -0.05028653f, 0.02749822f, 
    -0.02137841f, 0.02340524f, 0.05001776f, 0.00955615f, -0.02640156f, -0.06142703f, 0.06752440f, 0.03902517f, 
    -0.02069099f, -0.08136369f, -0.06433547f, -0.04700468f, -0.03807150f, -0.02811736f, -0.01372704f, -0.06302581f, 
    0.01719174f, -0.07288027f, 0.05703435f, -0.03409012f, 0.00100452f, -0.07810059f, -0.01599825f, -0.07927091f, 
    -0.00170985f, 0.06584308f, -0.05058703f, -0.02690148f, -0.02987460f, -0.01351271f, -0.00534026f, 0.04715951f, 
    0.01011321f, 0.00647242f, -0.01810615f, -0.01931772f, -0.07260813f, 0.03355395f, -0.00418223f, 0.04489005f, 
    0.05104902f, 0.01595402f, -0.01741653f, -0.01498875f, 0.02806182f, 0.01917150f, -0.02946399f, 0.04867608f, 
    0.04695225f, -0.05354799f, -0.01935465f, -0.04344970f, -0.00382042f, 0.01525260f, 0.04854174f, -0.06172036f, 
    0.06399341f, -0.07171038f, -0.02178491f, 0.01469332f, -0.03154081f, -0.04557152f, 0.04632303f, 0.01573693f, 
    0.05062106f, -0.03663143f, -0.01639880f, -0.04400856f, -0.04481467f, -0.04047893f, -0.02210522f, -0.05615966f, 
    0.05183227f, 0.03949799f, -0.05447607f, -0.04089535f, 0.05519604f, -0.05384303f, -0.07899182f, -0.05225368f, 
    -0.03323737f, 0.04869424f, -0.02256162f, -0.06582971f, 0.06856462f, -0.01380293f, 0.03206392f, -0.05535804f, 
    -0.05437637f, 0.04237155f, -0.09265284f, 0.01676460f, 0.00889653f, 0.00142835f, 0.01821913f, -0.05987593f, 
    -0.07166851f, 0.00686480f, 0.05010840f, -0.03590307f, -0.03289111f, -0.02638149f, -0.00047670f, 0.01249202f, 
    0.03053897f, -0.02570662f, -0.00821054f, 0.02201060f, 0.06796017f, -0.06975320f, 0.00065922f, 0.05699755f, 
    -0.00701264f, -0.00655245f, 0.01578006f, -0.05970357f, 0.04672166f, 0.02992739f, -0.07863695f, -0.01321274f, 
    0.03359364f, -0.05758278f, -0.06719603f, -0.02565348f, 0.06456856f, 0.03520185f, -0.08936884f, -0.08472300f, 
    -0.04879757f, -0.03183196f, 0.00838719f, -0.04036617f, 0.03845204f, 0.04984001f, -0.02261069f, -0.07391079f, 
    -0.00962455f, -0.03375870f, -0.01852952f, 0.05475595f, 0.00997801f, 0.02725668f, 0.02425759f, -0.06918263f, 
    -0.00947068f, -0.02367953f, -0.04683281f, 0.01710507f, 0.04895209f, 0.01723947f, -0.05415647f, 0.05836385f, 
    0.04882850f, -0.05890106f, 0.04804322f, 0.00875985f, -0.01994303f, 0.05677516f, -0.05743103f, 0.00727670f, 
    -0.01649008f, -0.06215840f, -0.01403821f, 0.03323851f, -0.00265150f, 0.01507426f, -0.06686339f, 0.00893362f, 
    0.03783236f, -0.06067114f, -0.06472188f, -0.05978501f, -0.03352636f, 0.02072136f, -0.05100147f, -0.01262254f, 
    -0.01935511f, -0.06593376f, 0.02137565f, -0.05803024f, -0.07073873f, 0.03999955f, -0.03124312f, -0.03125941f, 
    -0.04689353f, 0.04631370f, 0.01598059f, 0.04803326f, 0.01965381f, -0.08190379f, -0.04450224f, -0.06256323f, 
    0.01666016f, 0.05596584f, 0.03348374f, -0.06820627f, 0.03488749f, 0.00266139f, -0.03732564f, 0.05183863f, 
    -0.06811721f, -0.02290208f, -0.00128137f, -0.04631403f, -0.03673970f, -0.01926532f, 0.06020935f, -0.02239910f, 
    0.06739090f, 0.05402457f, 0.00514054f, -0.06229116f, 0.06128589f, -0.04659645f, -0.06179195f, -0.01867033f, 
    0.03311650f, 0.00427534f, -0.07315388f, -0.01050525f, -0.00578410f, 0.01044615f, -0.06564713f, -0.01044183f, 
    0.03315466f, 0.03135221f, -0.03646326f, 0.00540086f, -0.01234139f, -0.07641216f, -0.06477030f, 0.02090522f, 
    -0.03282697f, -0.05945536f, -0.06416611f, -0.00626615f, 0.00675353f, 0.04827230f, -0.06453097f, -0.01462040f, 
    -0.06316147f, 0.05869210f, -0.05877141f, 0.03233095f, 0.01787170f, 0.03230524f, -0.04510805f, -0.06704492f, 
    -0.01845709f, 0.05420595f, 0.05427232f, -0.01256049f, -0.02711073f, 0.02726889f, -0.04953380f, -0.01582875f, 
    -0.06086688f, 0.01045723f, -0.04305598f, 0.04466102f, 0.00329978f, -0.02859359f, 0.03524845f, 0.03801937f, 
    -0.07038454f, -0.02547517f, -0.03127089f, 0.00753297f, -0.05211277f, -0.04931834f, -0.03350116f, -0.06284295f, 
    -0.07217436f, 0.00678455f, -0.06259675f, -0.06781022f, 0.00380226f, -0.04823609f, 0.01252100f, 0.00596313f, 
    0.00846666f, -0.04515375f, -0.00923256f, 0.01709530f, -0.05779048f, -0.03426030f, -0.05696140f, 0.01944568f, 
    -0.05789119f, -0.02490083f, 0.05773944f, 0.01399471f, 0.06152889f, 0.06531004f, -0.04732906f, 0.06270419f, 
    0.05178464f, 0.03474009f, 0.01889446f, -0.02803042f, 0.00898251f, -0.05504435f, 0.04763414f, -0.01569729f, 
    0.03875565f, 0.00065700f, 0.06305417f, -0.02943297f, -0.06928384f, 0.06609404f, 0.01866804f, 0.04349140f, 
    -0.03476683f, 0.02971499f, -0.03971016f, -0.04283062f, 0.01111579f, -0.03112563f, -0.02717582f, -0.07550727f, 
    -0.04901285f, -0.04501688f, 0.04727107f, -0.02027050f, 0.05773738f, -0.04780622f, 0.04843361f, -0.07290522f, 
    -0.00537752f, -0.05772672f, 0.04754371f, 0.02970883f, -0.05798890f, 0.02526771f, -0.01415089f, -0.02922112f, 
    -0.00797394f, 0.06739401f, -0.00077288f, 0.01158627f, -0.04367402f, -0.00362020f, 0.04355604f, 0.03618013f, 
    -0.04117876f, -0.05830578f, 0.02841917f, 0.07295548f, 0.00500568f, -0.00880947f, -0.05686511f, -0.05361952f, 
    -0.01031056f, -0.06071586f, -0.01125907f, -0.04330243f, -0.02293238f, -0.02274743f, 0.06187425f, 0.00561670f, 
    0.02501340f, -0.03393884f, 0.02426191f, -0.03776770f, -0.05975263f, -0.05437149f, 0.02705758f, 0.05605054f, 
    -0.04664760f, 0.02901531f, 0.04549411f, -0.07426688f, -0.00473262f, 0.00686570f, 0.01653606f, 0.02188012f, 
    -0.16127147f, -0.06774873f, 0.08466280f, 0.02547797f, 0.04281894f, -0.12669787f, 0.05214149f, -0.00307972f, 
    -0.00494297f, -0.08892883f, 0.07855278f, 0.10200127f, -0.07389462f, -0.19327441f, -0.02680223f, -0.11333463f, 
    -0.13137443f, -0.01669913f, -0.10164109f, -0.02226176f, -0.06249796f, -0.04364208f, -0.03372664f, 0.05981561f, 
    -0.23385896f, -0.07086436f, -0.02780243f, 0.00863700f, -0.08769055f, -0.09294277f, 0.04072960f, 0.01980232f, 
    -0.07575722f, -0.01130851f, 0.00850020f, -0.10651158f, -0.09865792f, -0.04911328f, 0.05771634f, 0.03599245f, 
    0.08872590f, -0.00504205f, -0.14242373f, -0.07570740f, -0.07342961f, 0.06998260f, 0.08442437f, 0.07277481f, 
    0.32882968f, -0.00836791f, 0.02786850f, 0.20996864f, 0.09025058f, 0.10908113f, -0.07241093f, 0.00760185f, 
    0.08041395f, 0.14539962f, 0.06965788f, 0.06140908f, 0.16496602f, -0.07431268f, 0.04153682f, -0.09209383f, 
    -0.13417603f, -0.07661237f, 0.02971897f, -0.02270029f, 0.01175302f, -0.00235996f, 0.03828831f, 0.06488696f, 
    0.03347699f, 0.04430182f, 0.03054880f, -0.09473629f, -0.04079868f, 0.05329758f, 0.18667679f, -0.15088524f, 
    0.13477753f, 0.04056543f, -0.00700922f, 0.20642310f, -0.21226744f, 0.28388187f, 0.19735123f, -0.01061601f, 
    -0.00900674f, -0.04729323f, -0.02360977f, 0.11189756f, -0.01413805f, 0.07897354f, 0.07736507f, 0.11749906f, 
    -0.28455412f, -0.03673011f, 0.03691469f, 0.18789011f, 0.01278497f, 0.01371274f, 0.02837452f, 0.03198939f, 
    0.05760526f, 0.01986381f, 0.03690019f, 0.10479904f, 0.19534639f, 0.08349769f, -0.04513230f, 0.08077226f, 
    0.07850228f, 0.11508937f, 0.12820472f, 0.04199219f, 0.13499299f, -0.05209091f, 0.12877356f, -0.00527689f, 
    -0.34514436f, -0.08078209f, -0.03331722f, 0.12275612f, -0.03109292f, -0.18035798f, 0.16701442f, -0.10844400f, 
    0.08461019f, 0.03208419f, 0.07209771f, 0.03033072f, 0.15240388f, -0.15666963f, 0.10535052f, 0.09756123f, 
    0.01206883f, 0.01794870f, 0.02086114f, 0.09269571f, -0.11638299f, 0.04723109f, 0.10849934f, 0.00721536f, 
    -0.18729219f, -0.08276413f, 0.00062776f, -0.12522447f, -0.17610139f, 0.00364705f, 0.03830672f, 0.07310296f, 
    0.00694710f, 0.10268721f, -0.06385639f, 0.18241416f, 0.34020996f, -0.02076267f, -0.07736090f, 0.13481948f, 
    0.04250414f, 0.10195558f, -0.08662012f, -0.00480995f, 0.17860004f, -0.12834592f, 0.01643821f, 0.06200933f, 
    0.17523794f, 0.02959997f, 0.01588425f, 0.04506575f, 0.12652488f, 0.13736467f, 0.02140881f, 0.01224202f, 
    0.01152056f, 0.08845127f, -0.05258818f, -0.03105063f, -0.27982563f, 0.04537468f, -0.05389774f, 0.04509993f, 
    0.06844398f, -0.05277178f, 0.12904666f, 0.01913979f, 0.00082031f, -0.05465814f, -0.02141498f, 0.11209729f, 
    -0.05754684f, 0.25653350f, -0.08185789f, 0.00065286f, -0.00957332f, -0.05590470f, -0.04660184f, -0.04805787f, 
    -0.00958724f, -0.05158538f, -0.07256314f, 0.05563792f, -0.07199331f, 0.05047063f, 0.18927582f, 0.17770714f, 
    0.16016178f, 0.16587906f, 0.08758622f, -0.02441563f, 0.03963150f, 0.03174203f, 0.08320484f, 0.04950623f, 
    -0.13147533f, 0.20298938f, -0.01869600f, -0.18104495f, -0.02458382f, -0.04130792f, -0.11698727f, -0.00797646f, 
    -0.04390055f, -0.03112372f, 0.05359159f, -0.11553947f, -0.20038933f, 0.00698854f, -0.12551618f, -0.01345298f, 
    0.07348470f, 0.02470548f, 0.10816768f, 0.05644744f, 0.03167854f, 0.12251788f, 0.05369604f, 0.03257583f, 
    -0.14723086f, 0.01676209f, 0.07418249f, -0.01467050f, -0.14476240f, -0.12196654f, -0.05071382f, -0.18081902f, 
    -0.13930129f, -0.05307572f, 0.08118983f, -0.05333990f, -0.21871272f, 0.10916501f, 0.13154586f, 0.08589165f, 
    0.02544180f, -0.09031468f, 0.09876194f, -0.11710475f, -0.01852284f, 0.08373326f, -0.07351611f, 0.01495528f, 
    -0.12829271f, 0.10230476f, 0.14222659f, -0.15604921f, 0.04664525f, 0.03802734f, 0.18229595f, 0.16636744f, 
    -0.02779424f, 0.05342510f, 0.04227832f, -0.22604083f, 0.08176675f, -0.25097230f, 0.08344539f, 0.13016666f, 
    -0.02728564f, -0.04002169f, 0.16500361f, 0.03844793f, 0.01056533f, -0.10957249f, -0.06750716f, -0.03929626f, 
    -0.10724261f, -0.04594071f, -0.01730528f, -0.12462342f, -0.17155764f, -0.01045314f, -0.01368102f, -0.05703190f, 
    0.15438020f, -0.04268254f, 0.00447994f, 0.09018055f, -0.34716651f, -0.07920872f, -0.20382844f, 0.07186066f, 
    0.00257759f, -0.00171488f, 0.12070474f, -0.00840801f, 0.04581868f, 0.07586602f, 0.05863798f, -0.06748906f, 
    -0.26029858f, 0.23969628f, 0.14458565f, -0.06120557f, 0.07930092f, 0.16860069f, 0.13540523f, -0.02814185f, 
    0.05715057f, 0.01182502f, -0.00380626f, 0.21048667f, 0.15205532f, 0.11937902f, -0.03675769f, 0.00811391f, 
    -0.11126673f, 0.03686962f, -0.00791891f, -0.02704876f, 0.21672146f, -0.07724556f, 0.01599561f, 0.03692815f, 
    0.05090934f, 0.04235682f, 0.12685892f, 0.10966037f, 0.32090366f, 0.20427136f, 0.06274550f, 0.02401799f, 
    0.01046521f, -0.07126289f, -0.00528746f, 0.02423065f, -0.31022552f, 0.05201241f, 0.06177349f, 0.11730318f, 
    -0.20001554f, -0.02300226f, 0.03419077f, -0.04460279f, -0.01503094f, -0.07600379f, 0.12882575f, -0.06410082f, 
    -0.06076960f, -0.11603417f, 0.30124497f, 0.12495855f, -0.10077920f, -0.16075470f, 0.00667330f, 0.01059222f, 
    0.02494094f, -0.03919759f, 0.07203127f, -0.09944939f, -0.21363305f, 0.44758463f, 0.17786507f, -0.04224442f, 
    0.00265864f, 0.11554231f, -0.00913406f, 0.01290511f, -0.00004870f, 0.02226278f, -0.22376931f, 0.01134193f, 
    0.41895860f, -0.02091491f, 0.01959364f, 0.12444713f, -0.02319393f, 0.08483891f, 0.07055767f, -0.09246049f, 
    -0.02010744f, -0.04705365f, 0.15762818f, 0.09838642f, -0.14026295f, 0.20836821f, -0.04537298f, -0.23277538f, 
    0.02848222f, 0.02857289f, 0.04722241f, -0.02318588f, 0.01469584f, -0.00001666f, 0.13927267f, 0.03767370f, 
    0.24312040f, -0.13551815f, 0.02878338f, 0.24720468f, -0.03159033f, -0.02013185f, -0.10106584f, -0.12413834f, 
    0.11617836f, -0.03043484f, 0.08189757f, 0.08555247f, 0.23852764f, -0.18117890f, 0.12566619f, -0.16244569f, 
    -0.04930986f, 0.03156393f, -0.03376267f, 0.07023183f, 0.01582544f, -0.01175761f, -0.26972747f, 0.05414190f, 
    0.17951980f, 0.04489630f, -0.00027078f, 0.06360826f, 0.27902910f, 0.17131130f, -0.08237281f, -0.09552317f, 
    0.10355994f, 0.08266377f, -0.05607872f, 0.04792584f, 0.36562639f, 0.23431052f, -0.35861051f, -0.11647187f, 
    0.06354988f, 0.03687733f, 0.18536131f, 0.02585707f, 0.02594528f, -0.04103385f, -0.07663787f, -0.11329581f, 
    -0.33124810f, -0.02974758f, -0.16217844f, -0.11602355f, 0.00548506f, -0.04558755f, 0.02868820f, -0.02991794f, 
    -0.12516333f, 0.04046335f, -0.17335699f, 0.18058454f, -0.06086698f, 0.00547553f, 0.10156500f, -0.18649267f, 
    -0.07309004f, -0.00244280f, 0.05393847f, 0.04930482f, 0.01559463f, -0.04184718f, -0.13602193f, 0.06143155f, 
    0.11369888f, 0.17153077f, -0.09649821f, 0.26911539f, -0.03351528f, -0.12897156f, -0.02450384f, 0.06828076f, 
    0.06952439f, 0.04500400f, 0.02989147f, -0.00235574f, 0.09813262f, 0.29137474f, -0.11200473f, -0.13038756f, 
    -0.02214069f, 0.23706938f, -0.06373645f, -0.10498205f, -0.04962745f, 0.14326750f, -0.08164091f, 0.06306283f, 
    -0.18379097f, -0.19210733f, -0.03416830f, -0.09852683f, -0.13762619f, -0.08692293f, -0.01540913f, -0.13292514f, 
    0.05042930f, -0.04825631f, 0.10693648f, -0.17892180f, 0.25427699f, 0.22422962f, 0.18823402f, 0.17405365f, 
    0.08007370f, -0.06455745f, -0.08017026f, -0.00531028f, -0.04141966f, 0.15841642f, -0.01387620f, -0.08905730f, 
    -0.41520539f, 0.02730438f, -0.00697497f, -0.14501120f, -0.09797337f, -0.12333742f, -0.03335714f, 0.07361109f, 
    0.04570267f, -0.02762574f, -0.03962667f, -0.04383279f, -0.12471537f, 0.15251625f, -0.10008570f, -0.01626322f, 
    0.10716504f, 0.07274871f, 0.01581983f, 0.08915553f, 0.03712266f, 0.02254501f, 0.14381500f, -0.14285092f, 
    -0.09198042f, -0.12215278f, -0.13646321f, -0.23150380f, 0.23639129f, 0.07153738f, -0.06476633f, 0.02473859f, 
    0.13813822f, 0.01792296f, 0.08229759f, 0.08981329f, 0.12560856f, -0.20306303f, -0.04727025f, -0.03870855f, 
    -0.12237964f, 0.02122579f, -0.20580137f, -0.10637980f, 0.05950185f, -0.09983615f, -0.08079027f, 0.15836735f, 
    0.05227876f, 0.04579904f, -0.05015757f, 0.02531596f, -0.05399172f, 0.01666747f, -0.01144238f, 0.04171281f, 
    -0.06425811f, 0.02812444f, -0.02198292f, 0.04741268f, 0.04010689f, -0.04296937f, 0.06461240f, 0.03959681f, 
    0.02799170f, -0.06930378f, -0.01860807f, -0.04690516f, 0.00252017f, 0.06670376f, -0.05663979f, -0.05695334f, 
    0.00848966f, -0.05986749f, -0.01201367f, 0.04256423f, -0.05280305f, 0.05701612f, 0.00791500f, -0.02275742f, 
    0.04241272f, -0.00536942f, 0.05998968f, -0.06620640f, 0.03044256f, 0.06055920f, -0.00987893f, 0.01570779f, 
    -0.01288753f, 0.04452197f, -0.03745419f, -0.01743522f, -0.00682356f, -0.01966672f, -0.03667529f, -0.07001416f, 
    0.04901097f, -0.06672575f, -0.07053294f, 0.04744790f, -0.05945754f, -0.06604908f, -0.07125867f, 0.00153717f, 
    0.01094615f, 0.04854940f, 0.02815566f, -0.06285557f, 0.01081714f, -0.04708042f, -0.06053299f, 0.02917044f, 
    0.01633368f, -0.04857533f, -0.06017364f, 0.04623310f, 0.03051501f, 0.06086814f, 0.00078373f, 0.05205983f, 
    0.02231570f, 0.03543451f, -0.06668796f, 0.04078005f, -0.06337504f, -0.07114252f, 0.03731256f, -0.06561847f, 
    -0.01271438f, -0.02910086f, -0.02336952f, 0.03510635f, -0.04193515f, 0.06814102f, 0.05352837f, 0.02514522f, 
    0.02658273f, -0.04828869f, -0.02605391f, 0.02491968f, 0.00163145f, -0.03331943f, -0.02442371f, -0.01145914f, 
    0.03203716f, 0.03105955f, -0.03374124f, 0.01096131f, -0.01969369f, 0.04547431f, -0.02854879f, -0.03296350f, 
    -0.04034268f, 0.05597671f, 0.04233733f, 0.06439936f, -0.00456773f, -0.03486989f, -0.05063617f, -0.02190106f, 
    -0.04288323f, -0.02155037f, -0.00267573f, 0.02313785f, -0.04778879f, 0.00770435f, -0.05667016f, -0.03403073f, 
    0.02962617f, -0.07114536f, -0.03552783f, 0.01011064f, 0.05390306f, -0.05029456f, 0.04379425f, 0.03913729f, 
    -0.01515930f, -0.05567703f, -0.03002999f, -0.06544929f, 0.05485459f, -0.05949883f, 0.01986303f, -0.03578582f, 
    0.03247375f, -0.02196527f, 0.05157605f, -0.06451527f, -0.06615228f, -0.03846962f, 0.05752413f, 0.05610330f, 
    -0.01777581f, 0.06350821f, -0.02997972f, 0.01148811f, -0.06559295f, -0.06171606f, -0.02440972f, -0.03948998f, 
    -0.01968585f, 0.06950337f, 0.05699614f, -0.02634872f, -0.02393766f, -0.03789593f, -0.02407280f, -0.06555207f, 
    0.01716221f, -0.06237057f, 0.06795227f, -0.04968299f, -0.03803746f, -0.07124279f, -0.06958201f, -0.02884478f, 
    -0.01395812f, 0.00940338f, -0.06127115f, 0.05151997f, -0.06311460f, -0.03429779f, 0.03099542f, -0.05053337f, 
    -0.07068199f, -0.00136141f, -0.06599682f, -0.07205579f, -0.02897734f, 0.01271452f, -0.01922717f, 0.06743095f, 
    -0.03400320f, 0.05665743f, 0.01241174f, -0.06068660f, -0.05287592f, -0.03891553f, 0.03923152f, -0.03926812f, 
    -0.00616157f, 0.28419444f, -0.19530006f, 0.19735773f, 0.06825634f, 0.02769286f, 0.18210450f, -0.07745519f, 
    0.13733405f, 0.07006287f, -0.06797945f, 0.26818568f, -0.15905839f, -0.20227566f, -0.11271904f, -0.27342293f, 
    0.06710114f, 0.04452059f, 0.08214217f, 0.13486172f, -0.17164655f, 0.00830982f, -0.10207319f, -0.07513068f, 
    -0.21994275f, 0.33822468f, -0.02805895f, -0.02534779f, 0.11558045f, 0.14582235f, -0.00880953f, 0.07882654f, 
    0.02645702f, 0.07183210f, 0.14044765f, 0.16501927f, -0.33447444f, -0.00884659f, -0.01436365f, 0.01463027f, 
    0.16530141f, 0.09035164f, -0.09767031f, 0.02664328f, 0.06214050f, 0.07390002f, 0.05790389f, 0.11833411f, 
    0.32474199f, 0.11697213f, 0.10690057f, -0.13511305f, -0.03375208f, -0.05380468f, 0.16370048f, 0.07014240f, 
    0.03267489f, 0.02197796f, 0.06455299f, 0.02990513f, -0.19177419f, 0.08094755f, 0.30476543f, 0.09087360f, 
    -0.08384123f, 0.08846479f, 0.03288864f, 0.06178487f, 0.09192796f, 0.08295671f, -0.03182653f, -0.00332013f, 
    -0.17828532f, -0.04245997f, 0.01264171f, -0.04875528f, 0.11110011f, -0.06297078f, 0.07891198f, -0.09098316f, 
    -0.00641135f, 0.13559210f, 0.00388427f, 0.07695913f, -0.13419031f, -0.04760115f, 0.10849088f, 0.08442484f, 
    0.01581118f, -0.08538361f, -0.05733721f, 0.06179218f, -0.09211421f, -0.05034354f, 0.14237638f, -0.13267311f, 
    -0.07755132f, 0.04098302f, 0.21617949f, -0.01182306f, -0.13619541f, -0.03553952f, 0.00387809f, 0.13702947f, 
    0.14612401f, 0.07456660f, -0.02976482f, 0.04139793f, 0.14402147f, -0.01660976f, 0.06337691f, -0.11155833f, 
    0.02497767f, -0.01053254f, 0.03667308f, -0.06291232f, -0.17776519f, 0.04079466f, -0.02751408f, -0.06651520f, 
    -0.23174088f, 0.02431631f, -0.03647105f, -0.11583881f, 0.21635590f, 0.06005030f, 0.04167038f, 0.10091551f, 
    0.09040235f, -0.00643777f, 0.16584149f, -0.04586728f, 0.38318506f, -0.00149723f, -0.15304565f, -0.16006087f, 
    -0.05429206f, -0.04324237f, 0.07692523f, -0.00644072f, 0.09531713f, -0.04745825f, 0.03479091f, 0.14419292f, 
    -0.26296103f, -0.18242981f, -0.23122333f, -0.17455432f, 0.08804423f, 0.02519792f, -0.04811316f, -0.03614286f, 
    0.03973917f, -0.10374559f, -0.13809830f, -0.13688599f, 0.01594142f, 0.10312853f, 0.29362583f, -0.11780985f, 
    -0.10034031f, 0.03697536f, -0.02208801f, -0.03446153f, -0.05222486f, -0.10078166f, -0.04600310f, -0.04158223f, 
    0.25102302f, 0.08580622f, 0.06339115f, 0.17321399f, -0.06965037f, -0.01488039f, 0.03712498f, -0.03749936f, 
    -0.05688739f, -0.05789961f, 0.00221180f, -0.14287452f, -0.32274777f, 0.23962127f, 0.12557276f, -0.01297260f, 
    0.09646478f, 0.11129130f, -0.04214478f, -0.13372986f, -0.04636117f, 0.13913952f, 0.12095063f, 0.02345607f, 
    -0.15276603f, -0.05817240f, -0.29751045f, 0.14571476f, -0.02727504f, 0.14572376f, -0.07143629f, 0.05597838f, 
    0.12041376f, 0.06849231f, 0.04487071f, 0.04179276f, 0.16509622f, -0.15142673f, -0.04025045f, -0.16805676f, 
    -0.05977423f, -0.11397284f, -0.00591777f, 0.08286081f, 0.07618469f, -0.01344125f, 0.02401140f, 0.00112493f, 
    -0.00258119f, 0.07965185f, -0.10492458f, -0.02236152f, 0.03777985f, 0.05106819f, 0.12117605f, 0.06757033f, 
    0.03817197f, 0.12410554f, -0.02317361f, 0.24450922f, 0.05900436f, 0.14852422f, -0.22793914f, 0.08080073f, 
    -0.05524164f, 0.05889622f, 0.01398033f, 0.03309239f, 0.01111740f, -0.04568381f, -0.01608940f, -0.03400145f, 
    -0.06794836f, 0.00602570f, 0.02142338f, -0.11809233f, -0.09403742f, 0.01056143f, 0.03742209f, 0.01434621f, 
    0.09578546f, -0.06411329f, -0.02432696f, 0.08144396f, -0.31858721f, -0.00640668f, 0.08950063f, -0.06344155f, 
    0.05436910f, 0.06474575f, 0.07089003f, 0.00672090f, -0.03765007f, 0.05611043f, 0.12760124f, -0.02874529f, 
    0.13542886f, 0.04299463f, -0.03134197f, 0.25233263f, 0.06820446f, 0.01794617f, -0.07021003f, -0.02180563f, 
    0.06990754f, -0.03959280f, 0.21647793f, 0.02437948f, -0.18886207f, 0.50020766f, -0.19339333f, -0.26075795f, 
    0.00490452f, 0.08275841f, 0.04782267f, 0.01236050f, 0.09271348f, 0.07422849f, 0.04784920f, -0.02154699f, 
    0.33611751f, -0.23174037f, 0.16869545f, 0.14537688f, -0.07400115f, 0.10467605f, -0.01286121f, 0.04344065f, 
    -0.00747346f, 0.03566311f, 0.09106635f, 0.08133169f, 0.04625431f, -0.18631743f, 0.20702042f, -0.12417804f, 
    0.05924153f, 0.01422241f, -0.07489708f, 0.12607166f, -0.07034804f, -0.09828475f, 0.05438267f, -0.07553572f, 
    0.25110787f, 0.02628435f, -0.08288396f, -0.06819221f, -0.08701002f, 0.00260122f, -0.06901567f, 0.15081646f, 
    -0.03924839f, -0.05535192f, -0.00682913f, 0.01719273f, -0.23609576f, -0.06172974f, -0.00361901f, 0.19323862f, 
    -0.01832738f, -0.03748021f, -0.01675754f, 0.13242124f, 0.04567416f, 0.04249142f, 0.05829033f, -0.01985467f, 
    -0.00740435f, -0.00107745f, -0.06336273f, -0.13379787f, -0.11218252f, 0.12449260f, 0.02774018f, 0.05386773f, 
    -0.05303296f, 0.10583019f, -0.00975701f, 0.02676020f, 0.19273417f, -0.27438396f, 0.07847644f, -0.11499923f, 
    -0.04489652f, -0.03940125f, 0.18108028f, 0.03269552f, -0.06209307f, 0.04168145f, -0.10570170f, 0.00327721f, 
    0.08529959f, 0.32946578f, 0.12936975f, -0.15591590f, -0.04662521f, 0.08390429f, 0.04035579f, 0.00344857f, 
    0.07401445f, -0.00001256f, -0.03561448f, 0.09564144f, -0.05007990f, -0.02457263f, 0.05464395f, 0.09642673f, 
    0.07146072f, 0.04700788f, 0.00938677f, 0.07854807f, -0.04077530f, -0.03229652f, 0.14230657f, -0.12269645f, 
    -0.29598564f, 0.00285751f, 0.08765214f, -0.26347128f, 0.08993251f, 0.01151292f, -0.04412330f, 0.17714262f, 
    -0.12933737f, 0.08082427f, 0.02253494f, 0.06645638f, -0.08206851f, -0.18074295f, 0.07373269f, 0.26639086f, 
    -0.04273620f, -0.05854968f, -0.08002202f, -0.10936143f, -0.08018502f, 0.00273137f, 0.07617246f, 0.03430643f, 
    0.09411698f, -0.08345476f, 0.11496092f, -0.14202021f, -0.03015598f, -0.00078328f, 0.02283021f, 0.16410241f, 
    -0.07889525f, 0.00249818f, 0.28001025f, -0.06225206f, -0.00904329f, 0.01975537f, -0.02590182f, 0.14204313f, 
    -0.05412817f, -0.09355648f, 0.18132339f, 0.04166815f, -0.03149553f, -0.01173346f, 0.17248848f, -0.00605878f, 
    -0.32555681f, 0.08098075f, 0.24135087f, 0.12314756f, 0.07368086f, 0.02364676f, 0.14883682f, 0.05296142f, 
    -0.06130044f, -0.01718890f, 0.06725112f, 0.00627357f, -0.27636564f, -0.34290764f, 0.10078748f, -0.17754163f, 
    0.02500779f, 0.00839313f, -0.15403475f, 0.10626830f, -0.01429904f, 0.03219308f, 0.04881923f, -0.10233989f, 
    0.00459654f, 0.05310959f, 0.11420057f, -0.01660007f, 0.01489790f, 0.01337936f, 0.02639989f, 0.13057721f, 
    0.04402002f, 0.07684592f, 0.16805366f, -0.02660449f, 0.46481618f, -0.13546064f, -0.34491578f, 0.21300472f, 
    -0.02155586f, -0.06017900f, 0.00752131f, 0.02288478f, -0.02759211f, 0.11429051f, 0.07601316f, 0.09340047f, 
    -0.07881216f, 0.22570246f, 0.14659710f, -0.22917904f, 0.15036549f, 0.16787611f, 0.00810378f, 0.05252897f, 
    -0.06638785f, -0.06210024f, -0.05717974f, 0.01776810f, -0.33668539f, -0.03097111f, -0.02872053f, 0.06257802f, 
    0.00145857f, -0.04982501f, 0.13448082f, 0.16611965f, 0.12311171f, -0.04576636f, 0.06399560f, 0.00685435f, 
    0.09187867f, -0.18057382f, -0.27357712f, 0.19457249f, -0.01631590f, 0.00767001f, -0.01825010f, 0.02447621f, 
    -0.01724126f, -0.04297305f, -0.05876137f, -0.02767454f, 0.00843874f, 0.06068217f, -0.08708370f, -0.17915834f, 
    0.06715911f, 0.04145067f, 0.06100747f, 0.06368107f, 0.09076861f, -0.07978925f, -0.02179144f, 0.10977459f, 
    0.04269716f, -0.15074003f, -0.23132092f, 0.01656432f, -0.02526830f, -0.01643348f, 0.19417131f, -0.02176842f, 
    0.00572433f, -0.04434796f, 0.06769078f, 0.09622511f, -0.28211001f, 0.12807830f, 0.20728260f, 0.07062276f, 
    0.28946081f, 0.05029437f, 0.16670348f, 0.01932810f, -0.00411688f, -0.05646030f, -0.02300453f, 0.04093308f, 
    -0.28960776f, -0.07557704f, 0.09099735f, -0.01252800f, 0.06887697f, 0.05146218f, 0.12076431f, -0.04706631f, 
    -0.00759998f, 0.10122958f, 0.05418815f, -0.13198511f, 0.21203111f, -0.14403188f, -0.08469835f, -0.18960489f, 
    0.09735880f, 0.00620839f, 0.18007122f, -0.00123776f, 0.10808798f, 0.09285820f, 0.14712678f, -0.04294023f, 
    0.16642682f, 0.30760020f, 0.10165504f, 0.09058739f, 0.12132974f, -0.01517945f, 0.03398251f, 0.03092459f, 
    -0.02819902f, -0.04892841f, -0.06213985f, -0.04209910f, 0.05355992f, 0.04006518f, 0.12078136f, 0.06234691f, 
    0.17310104f, 0.17096403f, -0.07074706f, 0.13378373f, 0.06516787f, 0.13064006f, -0.03270327f, 0.02162419f, 
    -0.18072820f, 0.33800352f, -0.00102460f, 0.01482567f, 0.08393062f, 0.06181363f, -0.05233191f, -0.02706966f, 
    0.14361049f, -0.12129349f, 0.08656860f, 0.02461420f, -0.39366966f, -0.12409003f, 0.00263674f, 0.06047134f, 
    0.07130513f, 0.00303409f, -0.08890675f, 0.10738418f, 0.01705098f, 0.00372906f, 0.08278289f, 0.04960414f, 
    0.45599842f, -0.09144292f, 0.08319478f, -0.08950872f, 0.11003931f, -0.08341880f, 0.00355421f, -0.01126023f, 
    -0.11823928f, -0.12406172f, 0.16783012f, -0.09470019f, -0.17857455f, -0.01058805f, 0.11899547f, 0.07094835f, 
    0.01359063f, -0.14020029f, -0.07858492f, 0.01418754f, -0.03137072f, 0.12255155f, -0.02929989f, 0.06607072f, 
    0.00043855f, 0.02110821f, 0.07535763f, 0.07212576f, 0.10542074f, 0.00871463f, -0.02549952f, -0.05157819f, 
    -0.12400223f, 0.01769975f, 0.06422991f, -0.05013245f, 0.10924975f, -0.30661824f, 0.06973543f, 0.20256460f, 
    0.03332185f, -0.01997362f, 0.02519745f, 0.12850775f, -0.11733679f, -0.10578822f, -0.00147921f, 0.00900529f, 
    -0.29624382f, -0.09687044f, 0.03524598f, -0.05229034f, -0.06933086f, -0.14482316f, -0.01834727f, -0.07426783f, 
    0.10278998f, -0.03757967f, -0.04530005f, 0.03213194f, 0.06745110f, 0.16516432f, -0.06476311f, 0.05540556f, 
    -0.05717801f, -0.00187534f, -0.04412357f, -0.00468351f, -0.06054001f, 0.05427441f, -0.11142198f, -0.06157000f, 
    0.11160283f, 0.19923654f, -0.04354409f, 0.11325645f, 0.13476992f, 0.13736726f, 0.00795267f, -0.00218135f, 
    0.07235894f, -0.02605155f, 0.07224863f, 0.02371768f, 0.19704218f, 0.09273919f, -0.10866228f, -0.02970510f, 
    0.06240632f, -0.00775858f, 0.07637458f, -0.00350128f, 0.01333183f, -0.11954716f, -0.06706692f, 0.04462548f, 
    0.09619638f, 0.04645208f, 0.00264545f, 0.17562740f, 0.16264278f, 0.08259124f, -0.02210967f, 0.05574569f, 
    -0.02202469f, -0.04481639f, -0.06859738f, -0.04107569f, -0.22174917f, 0.16856486f, 0.12746766f, -0.11902542f, 
    -0.10141098f, -0.11827381f, 0.00183731f, 0.05481140f, -0.08620707f, -0.14489186f, 0.00814957f, -0.03342045f, 
    0.28426111f, -0.12780346f, 0.08620234f, 0.18840688f, -0.01449815f, -0.10495922f, -0.03153183f, 0.02456228f, 
    0.00236817f, -0.08681584f, 0.00735826f, 0.03236878f, -0.32135668f, 0.45158178f, 0.08065895f, -0.10704768f, 
    0.00393770f, 0.09778372f, -0.04966201f, 0.01049172f, -0.15735240f, -0.01459481f, -0.08182953f, -0.05462744f, 
    0.13623948f, -0.16571428f, 0.11895721f, 0.19302101f, 0.02708340f, -0.00606055f, -0.02901531f, 0.10662401f, 
    -0.00700513f, 0.01345326f, 0.02748118f, 0.00467859f, -0.06205710f, 0.07995047f, -0.16356783f, -0.08915605f, 
    -0.09936344f, -0.08881783f, 0.09752155f, 0.04310403f, 0.00046581f, -0.08429681f, 0.12137998f, 0.13885443f, 
    0.20382975f, -0.27788216f, 0.10024396f, 0.21894409f, 0.04580621f, 0.04695209f, 0.08249381f, -0.11868545f, 
    0.09224647f, -0.04643624f, -0.08496745f, 0.07422215f, -0.02580572f, 0.04137398f, 0.06130407f, 0.01758482f, 
    -0.00189817f, 0.04448526f, -0.00821657f, -0.04083429f, -0.05694409f, -0.00537737f, -0.06916608f, -0.04801697f, 
    0.23064448f, 0.10763069f, 0.07527237f, -0.02457582f, 0.05422943f, -0.07969443f, 0.09371284f, -0.00598443f, 
    0.00914133f, 0.01716743f, -0.09791597f, -0.02759852f, 0.03316671f, 0.01853197f, -0.18687357f, -0.15546368f, 
    0.09622943f, 0.10380817f, 0.00505179f, 0.04543065f, 0.06695571f, -0.05208854f, 0.16027047f, 0.04338757f, 
    -0.17434995f, -0.03996328f, -0.21142171f, -0.04695456f, 0.01367856f, 0.14252228f, -0.06907374f, 0.02806793f, 
    0.00118300f, 0.04879944f, -0.02568214f, 0.16639547f, 0.12068398f, -0.26417544f, -0.12240264f, -0.09015025f, 
    -0.05098727f, 0.13729487f, 0.09261405f, 0.05342406f, 0.00438952f, -0.02204282f, 0.03031075f, 0.05517680f, 
    0.13716516f, 0.31409922f, -0.02893503f, -0.09704226f, 0.06304820f, 0.01930430f, -0.05307845f, 0.09806113f, 
    -0.00446266f, 0.07147161f, -0.07769629f, -0.01050703f, 0.28906864f, 0.10310239f, 0.00690425f, -0.08430340f, 
    -0.04829056f, -0.00349502f, -0.11680313f, -0.12903872f, 0.03337846f, 0.04384145f, 0.00590714f, 0.11528409f, 
    0.07346448f, -0.02270498f, -0.11844765f, -0.05650912f, -0.05573892f, -0.00496797f, -0.06622678f, -0.01775342f, 
    0.08647780f, 0.01153066f, 0.07125649f, 0.05051888f, 0.22390178f, 0.30640981f, 0.12308383f, -0.02710727f, 
    0.06140638f, -0.05525586f, 0.05268928f, 0.07829849f, -0.04825632f, 0.03519989f, -0.08925331f, -0.00437513f, 
    -0.15334772f, 0.04038907f, -0.12094975f, 0.07212716f, -0.07406425f, -0.03727372f, 0.11973157f, 0.02773412f, 
    0.06199215f, 0.05968035f, 0.13588123f, -0.09773432f, -0.14399853f, -0.16400796f, -0.01100378f, -0.04095215f, 
    0.02395246f, 0.09742940f, -0.00529776f, -0.00594342f, 0.08018836f, 0.04534917f, -0.09449002f, -0.01054030f, 
    -0.19513482f, 0.03301899f, -0.10014223f, -0.12922595f, 0.09535109f, 0.10673852f, 0.00491850f, 0.05945659f, 
    -0.02143004f, -0.09995626f, 0.01601605f, -0.01199992f, 0.41423595f, -0.37944874f, -0.04977878f, 0.07957198f, 
    0.01837017f, 0.01992020f, 0.00764708f, -0.11048911f, 0.09746376f, 0.00729388f, 0.06321226f, 0.01758338f, 
    0.10530162f, -0.34118509f, 0.00387170f, -0.24230962f, -0.07856641f, 0.06938888f, 0.18227600f, 0.05556254f, 
    0.05372661f, 0.00733824f, 0.06621273f, 0.08726865f, 0.07339250f, 0.15866517f, 0.17264599f, 0.13739473f, 
    0.02155119f, 0.01389259f, 0.03593937f, 0.02037251f, -0.02237395f, 0.02930390f, 0.04662351f, -0.03282585f, 
    -0.04361759f, -0.01145908f, 0.02252007f, -0.07009207f, -0.09066264f, -0.00507236f, -0.02071059f, 0.10798050f, 
    -0.00390152f, 0.17612769f, 0.00519754f, -0.03397179f, 0.16081372f, -0.12029503f, 0.20637453f, 0.04901212f, 
    0.06837928f, 0.15553166f, -0.05655833f, -0.04976414f, -0.06459441f, 0.03333142f, -0.13430402f, 0.13767412f, 
    0.05229754f, -0.12058590f, 0.10009125f, 0.02058899f, 0.08936256f, 0.10986229f, 0.07733978f, -0.04160574f, 
    -0.00893533f, 0.02100076f, -0.01233322f, -0.05342904f, 0.39188960f, 0.00612485f, -0.23041604f, 0.19677714f, 
    0.06389204f, 0.05184391f, 0.01329748f, -0.06148279f, 0.07891823f, 0.03773280f, -0.04076847f, 0.02211024f, 
    0.05561736f, -0.14227505f, 0.05555828f, 0.12195744f, -0.00959655f, 0.00152492f, -0.00199730f, -0.14856048f, 
    -0.08547401f, -0.00254393f, -0.09091123f, 0.15444861f, -0.04865075f, -0.20117435f, 0.17931551f, 0.07601306f, 
    0.11550742f, 0.11943772f, 0.00157700f, -0.12288909f, -0.16849567f, 0.08732550f, 0.07778492f, 0.15774700f, 
    -0.20116697f, 0.13381344f, -0.24627575f, -0.03487954f, 0.15934654f, 0.04165008f, -0.08965036f, -0.03276701f, 
    -0.09868357f, 0.01780174f, 0.06852151f, -0.09580871f, -0.07119021f, 0.09689389f, -0.07077729f, 0.07558390f, 
    0.18794154f, -0.06495983f, 0.05529599f, -0.08136904f, -0.10930331f, 0.02708455f, -0.11050395f, 0.01383207f, 
    0.18380839f, 0.04917288f, 0.07354035f, 0.23394206f, 0.05691691f, -0.02190294f, 0.03430789f, 0.06525791f, 
    -0.06310553f, 0.09680861f, 0.13020313f, -0.05004407f, 0.10762537f, -0.11117514f, -0.12043744f, -0.31640062f, 
    0.02668829f, -0.08071389f, -0.06998055f, -0.09984868f, -0.12399080f, 0.07348435f, 0.03870538f, -0.08076522f, 
    0.08137117f, 0.10243095f, 0.14605902f, 0.05178102f, -0.15502545f, -0.00209334f, 0.06867722f, -0.03042122f, 
    -0.14440186f, 0.03978718f, 0.01212754f, -0.03511930f, 0.03540228f, 0.07667120f, -0.06202909f, -0.04034366f, 
    0.11215752f, 0.01446010f, -0.07287047f, 0.01572146f, -0.06233276f, 0.14909884f, -0.00943060f, 0.01543676f, 
    0.11101221f, 0.02678495f, -0.11162959f, -0.06073595f, -0.10659459f, 0.00983605f, -0.14006804f, -0.04167372f, 
    -0.00144822f, 0.05074563f, -0.00023058f, -0.01808652f, 0.23347495f, -0.12190384f, -0.06499503f, 0.04503643f, 
    -0.02598654f, 0.02988472f, 0.01519191f, -0.03435200f, 0.13774036f, 0.08759821f, 0.14344998f, 0.11920603f, 
    -0.05987288f, -0.00968315f, -0.06580566f, -0.03790602f, 0.04928519f, -0.04352464f, -0.05547752f, -0.05333699f, 
    -0.08177852f, 0.01218029f, 0.02343323f, -0.00296941f, 0.03552061f, -0.09222694f, 0.03789533f, -0.04538876f, 
    -0.02530813f, -0.00784627f, -0.03459740f, -0.01477598f, -0.05225686f, 0.00789579f, -0.02046576f, -0.01436245f, 
    -0.06947464f, -0.06559828f, -0.00835347f, -0.03807956f, 0.00238365f, 0.01023195f, -0.02024100f, 0.05162849f, 
    -0.04765230f, 0.04861621f, -0.04704064f, 0.02902043f, 0.00454654f, -0.02358772f, -0.04447813f, -0.04837757f, 
    0.03703522f, -0.02906435f, -0.06272114f, 0.04095191f, -0.08381644f, 0.05551728f, -0.00301609f, -0.01453659f, 
    -0.04519508f, -0.02534932f, -0.04306445f, 0.02894923f, -0.04141508f, 0.07360379f, 0.02094368f, -0.06934194f, 
    0.05559168f, 0.05188094f, -0.05052128f, 0.01586823f, -0.02999702f, -0.04873349f, -0.05873990f, 0.02878472f, 
    -0.06169241f, -0.05874837f, -0.01002620f, -0.02821422f, 0.04707326f, 0.01490989f, 0.03741636f, 0.05209959f, 
    0.03673385f, 0.03597147f, 0.01210062f, 0.03526163f, 0.05875889f, -0.04406175f, -0.04555038f, 0.02112465f, 
    -0.06258295f, 0.04990485f, -0.03184989f, -0.04730376f, 0.04625475f, -0.07113289f, 0.02727024f, 0.03430164f, 
    -0.06771879f, 0.07128383f, 0.03122470f, 0.04396835f, -0.05547477f, 0.03812482f, 0.03710664f, 0.04891225f, 
    0.08423802f, -0.05898303f, -0.04767327f, -0.05850067f, 0.05246130f, -0.01085901f, 0.05859026f, -0.07234402f, 
    0.00640799f, -0.07523734f, 0.03358798f, -0.02930617f, 0.03495810f, 0.01949437f, 0.05166337f, 0.01824472f, 
    0.00037378f, 0.05274796f, 0.02276736f, -0.03082945f, 0.01642599f, 0.01009502f, 0.00567735f, 0.03753583f, 
    0.02667620f, -0.05121216f, -0.01310410f, -0.07306341f, -0.01477011f, 0.04182323f, 0.05833715f, -0.01578487f, 
    -0.01695662f, -0.05008037f, 0.02611644f, -0.03562876f, 0.01638708f, -0.05502731f, -0.01641053f, 0.03856202f, 
    0.01879933f, 0.00508830f, -0.03131634f, -0.04729275f, 0.03510256f, -0.07041850f, -0.07139807f, -0.00337497f, 
    -0.07074088f, 0.04202678f, -0.02861845f, -0.08739011f, 0.00498709f, 0.04352890f, 0.02828520f, 0.00825640f, 
    -0.02155085f, -0.03809876f, 0.02157210f, -0.01269983f, 0.02663469f, 0.06401947f, -0.00106605f, -0.04313214f, 
    -0.00255049f, -0.05077216f, 0.07105122f, 0.02396052f, -0.06241798f, 0.00499317f, -0.05310135f, -0.07436001f, 
    0.04220283f, -0.04956158f, 0.05298368f, -0.03059509f, -0.07006668f, -0.05132503f, -0.02973183f, -0.03176493f, 
    -0.02325837f, 0.02288677f, 0.00768287f, -0.03697059f, -0.03345099f, 0.03052287f, 0.02226870f, 0.01931155f, 
    -0.02052637f, -0.07598022f, -0.00593470f, -0.07166953f, -0.01130081f, -0.06178131f, -0.01295156f, 0.01197226f, 
    -0.01358246f, 0.36135188f, -0.17101388f, 0.11704229f, 0.03431136f, -0.03945450f, -0.17982882f, -0.05417075f, 
    -0.04185687f, -0.02112632f, -0.07089525f, -0.10819080f, 0.10268328f, -0.04657231f, 0.03198477f, -0.10209353f, 
    -0.01823414f, 0.05274512f, -0.00250206f, 0.06081747f, 0.09855644f, 0.08045780f, -0.06639057f, 0.07946968f, 
    -0.00516641f, 0.19748099f, -0.16101798f, 0.03852641f, 0.11031380f, -0.05009095f, -0.00843786f, 0.02464546f, 
    0.03139350f, -0.04728700f, -0.08512439f, 0.12279895f, 0.01999788f, 0.07426672f, -0.20093830f, 0.09623002f, 
    0.03153186f, 0.05082378f, 0.08918836f, 0.18808703f, 0.18093467f, 0.05574708f, 0.05714967f, 0.00394541f, 
    -0.11883085f, -0.01850035f, 0.02919005f, -0.18302067f, 0.07269107f, -0.14513907f, -0.07229444f, -0.19904695f, 
    -0.04730752f, -0.02157477f, 0.16161561f, -0.04312124f, -0.49043357f, 0.08321004f, 0.17092122f, -0.11141921f, 
    0.00471152f, 0.02132400f, -0.00259404f, -0.04272426f, 0.00081161f, 0.12978932f, 0.15649650f, 0.07587652f, 
    -0.07754578f, 0.21960795f, 0.02279085f, 0.14047231f, 0.11478731f, 0.02061226f, 0.03593405f, 0.02387122f, 
    -0.01258662f, -0.06076730f, 0.11197108f, -0.13649037f, 0.01752460f, 0.06428323f, -0.04607204f, -0.04269407f, 
    -0.05268474f, 0.02707076f, -0.10442191f, 0.11203713f, 0.00012770f, 0.09444525f, 0.07986191f, -0.00610191f, 
    0.21261263f, -0.22764336f, -0.00934277f, 0.05833326f, -0.00953990f, -0.12811120f, -0.04169734f, 0.04184741f, 
    0.11382080f, 0.04486626f, 0.14241128f, 0.12107489f, -0.03010380f, -0.12912858f, 0.17691328f, -0.08305253f, 
    -0.04046067f, 0.01774277f, 0.03324125f, -0.00774867f, 0.15920380f, 0.07870827f, 0.14313591f, 0.01315062f, 
    0.20073691f, 0.27088964f, -0.03561654f, -0.11558809f, -0.05874101f, 0.16141672f, 0.00228599f, -0.07092391f, 
    0.04502308f, -0.04033715f, -0.03919033f, -0.02772702f, -0.12355815f, 0.12794358f, -0.16174570f, 0.13950983f, 
    0.05463849f, -0.11739263f, -0.07942123f, 0.08061613f, 0.12084974f, -0.01412710f, -0.00346994f, 0.11087058f, 
    0.17922479f, -0.00847673f, -0.17461696f, 0.04753797f, 0.14950974f, 0.28481460f, -0.10220271f, 0.10123114f, 
    0.07156693f, 0.02990516f, -0.05584848f, -0.09330788f, -0.28099704f, -0.00795833f, 0.13761942f, -0.24386220f, 
    -0.12380348f, -0.10036667f, 0.13829947f, -0.07239658f, 0.04192619f, -0.02006152f, 0.06939254f, -0.07457907f, 
    0.04809873f, 0.10501374f, 0.23831008f, 0.08943211f, 0.06763074f, 0.03808647f, -0.04674931f, 0.01281745f, 
    -0.04169659f, -0.06629165f, -0.03830272f, 0.05285668f, -0.19289647f, 0.28560278f, -0.00761788f, 0.06051058f, 
    -0.10203654f, -0.03498996f, -0.00135935f, -0.03319209f, -0.11543106f, -0.00300254f, -0.18065678f, -0.23401153f, 
    0.10992606f, 0.21766959f, 0.10732955f, 0.08473729f, 0.05178009f, -0.15891032f, -0.14881606f, -0.08761218f, 
    -0.13842998f, 0.06930172f, 0.08633400f, -0.23254287f, -0.12439225f, -0.08513577f, 0.08504197f, 0.07922331f, 
    0.02094244f, 0.00787829f, -0.03334496f, 0.04692239f, 0.02221432f, -0.01653447f, -0.11944119f, 0.14581761f, 
    0.02688983f, 0.14341906f, -0.06794737f, 0.09037263f, -0.03142188f, -0.03565153f, 0.05511555f, 0.10086223f, 
    0.18182862f, -0.11427958f, -0.15033428f, -0.01768734f, -0.18531060f, 0.09219917f, -0.22790141f, -0.09550732f, 
    0.01301600f, -0.03427193f, 0.08527288f, 0.05595946f, -0.02188206f, -0.04081106f, 0.09492227f, -0.05795898f, 
    0.27035272f, 0.03730755f, -0.22572790f, -0.08289616f, -0.08793972f, -0.14120580f, -0.09191570f, 0.10993764f, 
    0.04868716f, 0.07993066f, 0.09444960f, 0.04163758f, -0.11987238f, 0.12125064f, 0.03004224f, -0.05005817f, 
    -0.05697902f, -0.10225955f, 0.01405034f, -0.04088004f, -0.03317912f, 0.15884970f, -0.06495520f, 0.07635329f, 
    -0.14046703f, 0.09703922f, 0.14191914f, -0.09813998f, 0.01147023f, -0.02205878f, 0.06694523f, 0.01983730f, 
    0.09686583f, -0.16248126f, 0.07275529f, -0.10450113f, -0.16197461f, 0.20258680f, 0.10758179f, -0.11851232f, 
    -0.02350932f, -0.04536910f, 0.03553470f, -0.01469801f, 0.05166418f, 0.03014712f, 0.01551891f, -0.05818214f, 
    0.04468587f, -0.18632933f, 0.05713933f, 0.22248755f, -0.01000812f, 0.03609952f, 0.12074784f, -0.13883670f, 
    -0.07387263f, 0.02165197f, 0.09939864f, 0.14816138f, 0.08738934f, 0.07691192f, 0.04388444f, 0.01026107f, 
    -0.02492868f, -0.04687104f, -0.06913284f, 0.18493357f, 0.17887402f, -0.04072415f, 0.04574101f, 0.04522352f, 
    -0.13177839f, 0.14718431f, -0.12241325f, -0.11531572f, 0.01126235f, 0.02352267f, 0.00202175f, -0.17667677f, 
    -0.01325140f, -0.07038388f, -0.13237974f, 0.15800096f, -0.19227418f, 0.07116771f, 0.17846754f, 0.45055926f, 
    -0.04060817f, 0.17143887f, 0.03205718f, 0.04661394f, 0.17464143f, -0.08560457f, -0.15850222f, 0.20591754f, 
    -0.03392787f, 0.06239531f, 0.10587181f, 0.17947911f, 0.07964258f, 0.03926932f, -0.19047692f, 0.24103926f, 
    0.07850928f, 0.08805802f, 0.06559077f, 0.12371572f, 0.13151799f, 0.11237711f, -0.15104274f, -0.06017922f, 
    -0.06479482f, -0.07907593f, 0.08602009f, -0.00397312f, 0.04186147f, -0.00270532f, 0.19460249f, -0.02647866f, 
    -0.04236084f, -0.12662663f, -0.07556085f, 0.11267696f, 0.02786283f, 0.01895642f, 0.08587933f, 0.08118445f, 
    0.05502940f, 0.02664058f, 0.05570791f, 0.02505615f, -0.33927643f, 0.25079608f, -0.01690050f, -0.08515592f, 
    0.04650011f, 0.02597936f, 0.11009524f, 0.03283164f, 0.01151031f, -0.02159161f, -0.25861523f, -0.17788036f, 
    0.05901803f, 0.03004930f, -0.03462490f, 0.03009634f, -0.05200589f, 0.00740415f, -0.04540102f, 0.05904771f, 
    -0.07173551f, -0.04937153f, -0.05514870f, 0.03433738f, 0.06156707f, 0.01633823f, -0.06760908f, -0.03635316f, 
    -0.03889572f, -0.05981781f, 0.03103646f, 0.00540695f, 0.03894902f, 0.02391027f, -0.06702030f, -0.04709495f, 
    -0.05922998f, 0.01982625f, -0.05913250f, -0.02204875f, -0.01009740f, 0.01265100f, -0.06357828f, 0.01683575f, 
    0.03652507f, 0.05184596f, 0.01168006f, -0.01343634f, -0.03664427f, -0.07601691f, -0.02307450f, -0.02895575f, 
    0.03320442f, -0.02615110f, -0.03500737f, -0.05139028f, -0.02710438f, 0.06231290f, 0.00550958f, 0.02050465f, 
    -0.05095573f, 0.04313918f, 0.05973570f, -0.05624199f, 0.05735321f, 0.05170669f, 0.00446917f, -0.03717489f, 
    -0.05773788f, -0.01326976f, 0.01778175f, -0.03549506f, -0.02766155f, 0.04787354f, -0.02079050f, -0.07079863f, 
    -0.02695205f, -0.01069795f, -0.05112528f, -0.05559857f, 0.05659153f, 0.04418219f, 0.04905622f, 0.06326257f, 
    -0.06079726f, -0.06190924f, 0.05466863f, -0.06474939f, -0.01143332f, -0.00872324f, -0.03605940f, 0.01543118f, 
    -0.02100949f, 0.03703156f, -0.00751409f, -0.02989870f, -0.00070298f, 0.04463029f, 0.01686969f, -0.05048439f, 
    -0.01618600f, -0.03704611f, -0.04861967f, 0.03160483f, -0.03274680f, 0.06306650f, -0.04697664f, -0.01699170f, 
    -0.02906115f, 0.00521007f, 0.00260127f, -0.02320304f, -0.05839789f, 0.05158791f, -0.02279452f, -0.02813726f, 
    0.05065466f, 0.06836038f, -0.04648815f, -0.06142005f, -0.06020643f, 0.05509317f, -0.03961360f, 0.04937577f, 
    0.06170336f, 0.05534041f, -0.02500407f, -0.01039042f, 0.03668754f, 0.02464942f, 0.05743954f, -0.01625067f, 
    -0.04785989f, 0.02679344f, 0.05072504f, 0.04160096f, 0.04629997f, 0.03450744f, -0.00903978f, -0.02516980f, 
    0.03614640f, 0.03225640f, 0.02596024f, -0.07459039f, -0.05638576f, -0.07051027f, -0.06165554f, -0.02030141f, 
    0.02204464f, -0.01562920f, 0.04288736f, 0.03185173f, 0.02479611f, -0.03374603f, -0.05120235f, -0.03390006f, 
    -0.03602288f, -0.05459655f, -0.05650396f, 0.04357404f, 0.05616912f, -0.02673161f, -0.04289263f, 0.06141579f, 
    -0.04454628f, -0.06495688f, -0.02645211f, -0.07548086f, 0.00947528f, 0.02652943f, -0.04444743f, -0.04350708f, 
    -0.02570010f, 0.01381703f, -0.03858210f, -0.00665515f, 0.00666081f, -0.05907750f, -0.06025386f, 0.04886012f, 
    0.02416749f, 0.04541764f, 0.02061702f, -0.00641524f, 0.02848831f, -0.01153613f, 0.01160316f, -0.00397497f, 
    -0.05606394f, 0.02804166f, 0.01313050f, 0.01202057f, -0.00716457f, -0.06572443f, -0.01124210f, -0.06059712f, 
    -0.02971462f, 0.01237097f, 0.05188659f, 0.07619032f, -0.03972468f, -0.03018905f, -0.06990605f, 0.05788581f, 
    0.01809535f, 0.07002515f, -0.09545770f, 0.14011197f, -0.07936104f, -0.13831869f, 0.17041776f, 0.03928826f, 
    0.03345672f, -0.06392852f, 0.20842378f, 0.15550846f, -0.23047511f, -0.03773034f, 0.05193099f, -0.11854754f, 
    -0.00404837f, 0.08964968f, -0.04566882f, 0.10801128f, -0.07544360f, -0.00467854f, 0.04612273f, -0.00628670f, 
    -0.07181314f, 0.11393448f, -0.07581283f, 0.12229209f, -0.02597598f, -0.03165950f, 0.03412453f, -0.00077440f, 
    0.10672703f, 0.01918472f, 0.03228784f, -0.02206698f, -0.04326495f, 0.03918878f, 0.01058152f, -0.04712915f, 
    0.10997604f, -0.01278262f, -0.02249744f, 0.04458348f, 0.05276527f, 0.07012328f, 0.08365288f, 0.04109809f, 
    0.16370331f, -0.19443069f, 0.01071608f, 0.04522894f, 0.06772269f, 0.05665594f, -0.05155572f, 0.00908902f, 
    0.07453948f, 0.07166257f, -0.07175971f, 0.10616387f, 0.32985610f, 0.13239554f, 0.07303408f, -0.15375352f, 
    -0.06108446f, -0.00575890f, 0.09847701f, -0.00997375f, 0.05025207f, -0.00822742f, -0.10814624f, 0.02102732f, 
    -0.02645565f, 0.05920700f, 0.02103352f, -0.13472721f, 0.06425038f, 0.00458080f, 0.22688325f, -0.13830118f, 
    0.05197793f, 0.05401712f, -0.10622073f, 0.14725500f, -0.02037227f, 0.18316972f, 0.23995131f, -0.11389347f, 
    -0.10941952f, -0.07978514f, 0.01683109f, 0.02133175f, -0.04285971f, -0.08316954f, -0.04937518f, 0.02958813f, 
    -0.40310794f, -0.01017549f, 0.02963897f, 0.21445835f, -0.15261964f, -0.02553843f, 0.06527670f, -0.06916568f, 
    0.09612054f, 0.11354987f, -0.02330320f, 0.02911750f, 0.10736845f, 0.32187378f, -0.17710370f, 0.07336981f, 
    0.05047113f, 0.15542077f, -0.03617663f, -0.10864275f, -0.01479378f, -0.00693093f, 0.06539445f, 0.06670807f, 
    -0.43940061f, -0.02847455f, 0.07880994f, 0.03498268f, -0.06150277f, -0.07869128f, 0.15668875f, -0.06264088f, 
    0.03867790f, 0.02730869f, 0.10150494f, 0.03961733f, 0.25483543f, 0.02809099f, 0.13217513f, 0.12393655f, 
    -0.00599003f, -0.02869969f, 0.08427592f, 0.00503154f, 0.02029760f, -0.01612639f, 0.09373566f, -0.04902937f, 
    -0.13054556f, -0.09785490f, 0.09022886f, -0.14699507f, -0.00878467f, -0.04414102f, 0.06164773f, 0.05728662f, 
    0.00482059f, 0.08444230f, -0.11601298f, 0.04272894f, 0.18818323f, 0.12619637f, -0.19128677f, -0.00702575f, 
    -0.11054455f, 0.12904230f, -0.03231719f, 0.10936752f, 0.12891762f, -0.15107392f, 0.01932319f, -0.03317606f, 
    0.04485393f, -0.25388548f, 0.05288237f, -0.08111734f, 0.10835540f, 0.06669307f, -0.01650036f, 0.00695432f, 
    -0.01858236f, -0.04279611f, 0.02170702f, -0.08666558f, -0.24691328f, 0.15397060f, 0.08115496f, -0.06674854f, 
    0.04965142f, -0.06192857f, -0.06782858f, -0.09867144f, 0.02340326f, -0.01161164f, -0.05294662f, 0.12660372f, 
    -0.04678473f, -0.04887432f, 0.07266686f, -0.06224279f, -0.05428013f, -0.07822873f, -0.00370661f, -0.01093726f, 
    -0.04556904f, -0.01915997f, -0.01914772f, 0.00995795f, -0.08207789f, -0.03679352f, 0.05935033f, -0.01366092f, 
    0.03429114f, -0.04765876f, 0.05797603f, -0.08323643f, -0.02242072f, 0.01183389f, 0.04692956f, 0.06323617f, 
    -0.00932648f, -0.01605657f, -0.04268968f, -0.03547591f, 0.06048615f, 0.01389998f, -0.03635368f, 0.04608473f, 
    0.05221539f, -0.03941443f, -0.06199207f, -0.02355797f, -0.03364925f, 0.04439731f, 0.02588060f, -0.04783878f, 
    -0.03447666f, -0.05973531f, 0.06023421f, 0.04221662f, -0.04925901f, -0.01702172f, -0.03186716f, -0.05623937f, 
    -0.06420850f, 0.05288099f, -0.05805086f, -0.03751383f, -0.04016980f, 0.00002904f, -0.01793956f, -0.01378378f, 
    -0.02810912f, -0.05201413f, -0.04252417f, -0.03839168f, 0.02440998f, 0.03184168f, -0.02769490f, 0.01831444f, 
    0.03565066f, -0.00089782f, 0.06197011f, -0.00699782f, 0.04872796f, 0.05767270f, 0.02100492f, -0.03632581f, 
    0.00528751f, 0.00012206f, -0.06579741f, -0.08547347f, -0.03416938f, -0.03604907f, -0.00566732f, -0.02005183f, 
    0.04606100f, 0.01741891f, -0.01422122f, -0.04224854f, 0.01033233f, 0.04313733f, 0.00618102f, 0.02846852f, 
    -0.03822979f, 0.03078169f, 0.06118213f, -0.05349991f, -0.04871853f, -0.02023884f, -0.05178406f, -0.07238512f, 
    -0.04225039f, 0.06824614f, -0.04803463f, 0.03446207f, 0.02606044f, -0.01026063f, -0.02087382f, -0.07223757f, 
    -0.05630051f, -0.01097372f, -0.05351653f, -0.02027594f, -0.06098319f, 0.03936203f, -0.00302515f, 0.02933359f, 
    -0.03662913f, -0.03944304f, -0.05231451f, -0.02592451f, -0.00850403f, 0.00481128f, -0.01127300f, 0.06517971f, 
    -0.07098262f, 0.02177482f, -0.07361643f, -0.01924057f, 0.04662997f, 0.04555204f, 0.02202904f, -0.03561513f, 
    -0.06013412f, -0.04658962f, -0.05467819f, 0.00023934f, 0.06343764f, -0.02801758f, 0.02236399f, 0.06428789f, 
    0.02573357f, 0.01607889f, -0.05910743f, -0.02357007f, -0.00908056f, -0.01140345f, -0.05451765f, -0.02118772f, 
    -0.00424865f, -0.04883576f, -0.00487304f, -0.01091299f, -0.06118650f, 0.00860584f, 0.03452298f, -0.04489284f, 
    0.04785625f, -0.02364187f, -0.06735131f, 0.04055320f, 0.04788302f, -0.00666005f, 0.02227870f, 0.05305451f, 
    0.01867727f, -0.06526625f, 0.05781169f, -0.00974312f, 0.00436963f, -0.03366188f, -0.01829133f, 0.06454683f, 
    -0.00554666f, 0.01234306f, -0.04513148f, 0.05870220f, 0.03870422f, 0.04682253f, 0.05693575f, 0.01976317f, 
    0.06027316f, -0.04636201f, 0.06802134f, -0.01051074f, -0.05872221f, -0.02793759f, 0.00571365f, 0.00353825f, 
    0.01188246f, -0.05516961f, -0.05895033f, -0.06733911f, -0.06176965f, -0.07711869f, 0.06269909f, -0.03338097f, 
    -0.26079854f, -0.13145427f, -0.05471468f, -0.15745772f, -0.07253450f, 0.14526440f, 0.07914294f, 0.05317330f, 
    -0.04156040f, 0.01070209f, -0.09587083f, 0.16064282f, -0.08034272f, 0.06036898f, 0.18706641f, 0.29190478f, 
    0.06193640f, 0.02057297f, 0.08281827f, -0.09865753f, 0.00121714f, 0.09787748f, 0.16863981f, -0.08381695f, 
    0.04883000f, -0.03091218f, 0.02654576f, -0.10104205f, 0.02650953f, 0.03042673f, 0.00317778f, 0.04454623f, 
    -0.14694181f, 0.03237536f, 0.17586675f, -0.08159299f, 0.23080675f, 0.11968528f, 0.07254831f, -0.11773098f, 
    -0.09843739f, 0.00110700f, 0.05782537f, -0.02940093f, 0.06697211f, 0.05336443f, -0.07056108f, 0.06483572f, 
    -0.62588340f, -0.10649399f, 0.07787696f, 0.13642935f, 0.08017243f, 0.17213015f, 0.01960620f, -0.04662047f, 
    0.00994662f, 0.07458351f, 0.00085196f, 0.02079652f, 0.14966558f, -0.14689377f, 0.05677378f, 0.13672838f, 
    0.10626949f, 0.14563620f, 0.08325133f, 0.10319612f, 0.00720921f, -0.03363414f, -0.01933142f, -0.09405612f, 
    0.08830291f, 0.06349821f, 0.00469758f, -0.14800932f, -0.09283699f, -0.07723171f, -0.01191124f, 0.04963650f, 
    -0.06678627f, 0.11980178f, -0.04416804f, 0.00687498f, 0.29675445f, 0.07719712f, 0.01704341f, 0.10164786f, 
    0.00455010f, 0.04552395f, -0.02519738f, -0.03941612f, 0.02345334f, 0.02010714f, 0.11119935f, -0.04236558f, 
    -0.03798871f, 0.12252576f, -0.01890492f, -0.19619404f, 0.10751654f, 0.03388971f, -0.00949828f, 0.12488449f, 
    0.06323073f, 0.05169355f, -0.04957087f, 0.01009728f, -0.30479228f, -0.05972764f, -0.08011818f, -0.02203316f, 
    0.13806002f, -0.07167996f, 0.12361153f, -0.03966748f, -0.02283915f, 0.10085446f, 0.01139439f, -0.03513500f, 
    -0.19767056f, 0.01737933f, 0.20078619f, 0.02283927f, -0.08228038f, -0.02718409f, 0.06636897f, -0.01561926f, 
    -0.06674497f, 0.00022927f, 0.06056598f, 0.02620260f, -0.00100416f, 0.02157766f, -0.10340224f, -0.41632983f, 
    0.09119415f, 0.01206906f, -0.01186715f, 0.06697197f, 0.05707278f, 0.06912030f, 0.06044529f, 0.01612316f, 
    0.24532165f, 0.18175997f, -0.04285250f, 0.07022908f, -0.03813253f, -0.11941445f, 0.03701035f, 0.00271678f, 
    0.04283522f, -0.08976573f, 0.00351047f, -0.04450699f, -0.14513548f, 0.04242402f, 0.01685126f, 0.10505906f, 
    0.00275363f, 0.06954543f, 0.08432819f, 0.00583756f, 0.00774361f, -0.00252039f, 0.11943899f, 0.14669512f, 
    -0.28396976f, -0.04090583f, 0.16523479f, -0.03252904f, 0.02347305f, -0.06459822f, -0.02692325f, -0.13698736f, 
    0.11573157f, 0.17449629f, -0.00558104f, -0.20257409f, 0.24034400f, -0.04062331f, -0.00968272f, -0.05150717f, 
    0.11326190f, -0.05372318f, -0.08547039f, 0.08605479f, 0.09238518f, 0.07811586f, 0.09769988f, 0.16134715f, 
    -0.08115556f, -0.01654516f, 0.11916458f, -0.03195610f, -0.06707055f, 0.02099140f, 0.13177557f, 0.00547585f, 
    -0.04814959f, 0.13826127f, -0.00038679f, 0.03859096f, -0.03848457f, -0.12025799f, -0.23957229f, 0.15860675f, 
    -0.05684491f, 0.05691229f, -0.05891583f, -0.09124593f, 0.06742731f, 0.03900799f, 0.01785350f, 0.00618616f, 
    -0.14834772f, 0.05097381f, -0.01936062f, -0.10364363f, -0.08590347f, -0.02966798f, -0.01931788f, -0.02790640f, 
    0.03272968f, -0.06782539f, 0.06652763f, -0.08411691f, -0.27551451f, 0.06377842f, -0.00808370f, 0.07022745f, 
    0.05162847f, 0.12578876f, -0.08312693f, -0.01378797f, -0.08660936f, 0.10021959f, 0.07659186f, 0.03654300f, 
    0.22035390f, 0.09791759f, 0.03224621f, 0.00645254f, -0.16454007f, -0.07981946f, 0.02339679f, 0.07629731f, 
    0.10463966f, -0.01229810f, 0.01630741f, 0.08760859f, -0.00051379f, -0.20042123f, 0.00067906f, 0.12511043f, 
    -0.02668426f, -0.01405583f, -0.00894368f, 0.03714017f, -0.01921635f, 0.00180410f, -0.04303636f, 0.03073038f, 
    0.26615903f, -0.13141888f, -0.03593515f, -0.12979676f, -0.06999569f, 0.05457207f, 0.08079655f, 0.05641953f, 
    0.12824191f, -0.14763622f, 0.08812882f, 0.00639189f, -0.19357201f, 0.29009449f, 0.07160784f, -0.12657358f, 
    0.09024100f, -0.13110702f, 0.15840577f, 0.02387146f, -0.10403465f, 0.05985636f, -0.00260287f, 0.00061968f, 
    -0.13642457f, -0.10346179f, 0.21693565f, 0.02525505f, -0.13950579f, 0.11733539f, -0.01834410f, -0.09606749f, 
    0.07718527f, 0.02510667f, -0.03953338f, 0.01911352f, 0.03903038f, -0.21447916f, -0.05074812f, 0.03510563f, 
    0.08532687f, -0.04523517f, -0.14496347f, 0.14442533f, 0.05021970f, -0.20014679f, -0.05194103f, -0.00168281f, 
    -0.18157528f, -0.04669720f, -0.13833004f, 0.02685397f, 0.09866971f, 0.01356712f, -0.02472477f, 0.09345163f, 
    0.03760696f, -0.07571112f, -0.03989658f, 0.06594612f, 0.15978764f, 0.07597911f, 0.15799630f, 0.07720380f, 
    -0.05930035f, 0.11370602f, 0.13737464f, 0.05273139f, 0.01156944f, 0.02582201f, -0.11907759f, -0.01084399f, 
    -0.05718977f, 0.01665728f, 0.06657627f, 0.04742225f, 0.10305660f, -0.03293627f, -0.01205721f, 0.03865632f, 
    -0.02487922f, -0.00948332f, 0.05016220f, 0.14621060f, 0.26480600f, -0.15624931f, 0.02094918f, 0.20966060f, 
    0.03800610f, -0.05371688f, -0.03872224f, -0.06462829f, 0.00509497f, -0.00270687f, -0.01662833f, -0.01496185f, 
    0.00923172f, -0.09257080f, -0.04420493f, 0.19955197f, 0.05738648f, -0.11276756f, 0.11920484f, 0.12154580f, 
    -0.03105945f, 0.01279327f, -0.03513774f, 0.03964464f, -0.23031037f, 0.11126798f, -0.13262543f, 0.07257117f, 
    0.12569703f, 0.14557342f, 0.11781333f, 0.02835686f, 0.05486887f, 0.07450202f, -0.01548846f, -0.01409312f, 
    0.13929458f, 0.34073961f, -0.02281170f, -0.01182286f, 0.18278131f, -0.08593913f, 0.06313564f, -0.02513670f, 
    0.01759577f, -0.03768062f, -0.09260032f, 0.11301065f, -0.21520494f, -0.15830925f, -0.08659808f, -0.00609553f, 
    -0.04820972f, 0.07027555f, -0.04985638f, 0.08111624f, -0.14123365f, 0.11243901f, -0.07328290f, 0.00475849f, 
    -0.17218280f, 0.14212418f, 0.00438009f, -0.00643915f, 0.11883908f, -0.03033142f, -0.05052175f, 0.07785606f, 
    0.11415365f, -0.08198250f, 0.03615987f, -0.06424293f, -0.42258373f, -0.15745136f, -0.00512641f, 0.07021639f, 
    0.16043784f, 0.12608290f, -0.04265312f, 0.08742101f, 0.02819114f, 0.02529543f, -0.07191611f, 0.04564458f, 
    0.53762841f, -0.01791307f, 0.16851847f, 0.05997864f, 0.22286589f, 0.11181595f, 0.11023076f, -0.13423598f, 
    0.02969924f, 0.04111530f, 0.11200345f, -0.04481038f, 0.05312791f, -0.11038061f, 0.14418520f, -0.01593529f, 
    -0.11711098f, 0.05279835f, -0.03118500f, -0.04367046f, 0.04119747f, 0.07449828f, 0.15286967f, 0.18591459f, 
    -0.24564034f, -0.05317082f, 0.03532588f, -0.08182424f, 0.09607098f, -0.11185640f, 0.13645011f, 0.02070763f, 
    -0.11155035f, -0.09134848f, 0.08538380f, -0.00089034f, -0.00550316f, -0.07405875f, 0.09607715f, 0.19792442f, 
    0.04259249f, -0.03843611f, -0.01033158f, 0.08269862f, -0.12269303f, -0.00972358f, 0.10105934f, 0.00791566f, 
    -0.27850524f, 0.18098171f, 0.00515459f, 0.00717284f, 0.14629586f, -0.04347358f, 0.03576538f, -0.15348502f, 
    0.03050940f, -0.04235497f, 0.05525882f, 0.07129163f, 0.13682094f, 0.21655613f, -0.02033289f, -0.04784794f, 
    0.06843714f, 0.01546829f, 0.07705800f, -0.01149350f, 0.04804941f, 0.00466299f, 0.01221217f, 0.04011267f, 
    -0.35071176f, -0.11781482f, -0.32117498f, 0.06596733f, 0.07957318f, 0.00323123f, -0.00023948f, 0.00318470f, 
    0.03609303f, -0.11262917f, 0.06536785f, -0.10043013f, 0.34210309f, 0.02852341f, 0.00619500f, -0.11921952f, 
    0.13654742f, -0.04515339f, -0.04082466f, -0.10089923f, 0.04421804f, -0.03721470f, 0.00473550f, 0.15989567f, 
    -0.18126766f, -0.07671016f, -0.11955909f, -0.04299629f, 0.14017476f, 0.11263452f, -0.00600472f, -0.01156655f, 
    -0.02196758f, -0.20901677f, 0.01275119f, -0.00856631f, -0.09706080f, 0.14374039f, 0.20191573f, -0.18107945f, 
    -0.04412447f, -0.02935605f, 0.01109378f, 0.00402118f, 0.03060516f, -0.11636982f, -0.00313472f, -0.03852933f, 
    0.38932419f, 0.05599527f, 0.18546070f, 0.29943222f, 0.00560804f, 0.02340606f, 0.00370800f, -0.13392095f, 
    -0.00421605f, -0.11363778f, 0.04197422f, -0.06963492f, -0.45521662f, 0.34252074f, -0.07046194f, -0.10935502f, 
    0.07687236f, -0.02170689f, 0.05746904f, -0.05219294f, -0.00841361f, 0.03794429f, -0.05874689f, 0.07307967f, 
    0.00958202f, -0.05507947f, -0.01305305f, -0.07872457f, -0.04179704f, -0.06817814f, 0.00183257f, -0.06967210f, 
    -0.02205944f, 0.04908055f, -0.06026156f, -0.00369779f, 0.00641444f, -0.04428853f, -0.00072623f, -0.00881931f, 
    0.01444882f, 0.05785417f, -0.02364102f, -0.01805579f, -0.05669786f, 0.01629035f, 0.00202928f, 0.05273628f, 
    0.04144188f, 0.04515289f, -0.08283517f, -0.00220087f, 0.00884185f, -0.07973317f, 0.00727551f, -0.02287507f, 
    0.00887643f, 0.02145603f, 0.00218230f, 0.03501308f, -0.03842271f, -0.02296755f, 0.03540506f, -0.05620179f, 
    -0.02958737f, -0.03100508f, -0.07391165f, -0.07982420f, -0.00175957f, -0.03463358f, 0.05616195f, -0.06754211f, 
    0.05317770f, 0.05686296f, -0.04318997f, 0.04596210f, -0.05925534f, -0.00991193f, -0.00123511f, 0.02873399f, 
    -0.01999523f, -0.01001946f, -0.04753603f, -0.00265990f, -0.00840612f, 0.03803771f, 0.00965845f, 0.00168774f, 
    -0.07583811f, -0.05001374f, -0.05339030f, 0.05730212f, 0.01553147f, -0.07150575f, 0.03971949f, -0.01859937f, 
    0.02706351f, -0.00103864f, 0.06384197f, 0.03774079f, 0.06077790f, -0.05086739f, 0.03416556f, -0.05798706f, 
    -0.03518001f, -0.06817434f, -0.00329803f, -0.01722827f, -0.02162378f, 0.01711597f, -0.04811747f, -0.01524144f, 
    -0.06977517f, 0.00938132f, 0.05053298f, -0.03568530f, 0.02714745f, -0.07997901f, 0.05821424f, -0.03478263f, 
    0.00712829f, 0.00609843f, 0.01671906f, 0.01735217f, 0.05480593f, -0.07452230f, -0.05821648f, -0.00723853f, 
    0.03395140f, 0.03927090f, -0.02638703f, -0.00077421f, 0.01581573f, -0.02923255f, 0.02040295f, -0.00840437f, 
    -0.07276663f, 0.01847831f, -0.02603620f, -0.06439921f, -0.07605104f, 0.00046140f, -0.01856583f, -0.02572307f, 
    0.05998177f, 0.04969030f, 0.06090384f, -0.07079408f, 0.00061971f, -0.04460683f, -0.03157755f, -0.06975975f, 
    -0.04462753f, -0.07284585f, -0.01357502f, -0.03825973f, 0.03744170f, -0.04084887f, 0.05619035f, -0.03050275f, 
    -0.05320206f, -0.03141228f, -0.07706475f, -0.07443710f, 0.05602064f, 0.05932265f, -0.05288030f, -0.01704244f, 
    -0.02057755f, 0.02270940f, 0.00562157f, -0.07485399f, -0.06311475f, 0.01465555f, 0.01588622f, 0.04307573f, 
    0.03813037f, 0.00312196f, -0.03864349f, -0.00429490f, -0.03303623f, -0.00311322f, 0.03121901f, -0.03728039f, 
    -0.01563170f, 0.05109293f, 0.06578583f, -0.06374818f, -0.04371643f, -0.01565255f, -0.00098438f, 0.02185402f, 
    0.03720909f, 0.03918351f, -0.00311948f, -0.03426851f, 0.04992834f, -0.00993102f, -0.06111049f, 0.01503311f, 
    0.02556956f, -0.01918666f, -0.02215486f, -0.07512302f, -0.05696689f, -0.00486805f, -0.05365847f, -0.02979865f, 
    0.03424813f, -0.05762561f, 0.02199706f, 0.01686323f, 0.05822823f, 0.00095909f, -0.01613201f, 0.04350730f, 
    -0.03004892f, -0.22838984f, -0.02248009f, -0.04690296f, 0.00291335f, 0.08360448f, 0.08431386f, 0.12543914f, 
    0.06315248f, 0.15582295f, 0.07142904f, 0.10667186f, 0.00952469f, -0.15996689f, -0.22445947f, 0.16768119f, 
    -0.13163777f, -0.13452952f, -0.08011821f, -0.11615867f, 0.01270980f, -0.04753799f, 0.09601271f, -0.01090893f, 
    -0.06466470f, -0.06832583f, 0.08950502f, 0.01384613f, -0.08938483f, 0.04795250f, 0.12672682f, -0.05254933f, 
    -0.02829405f, -0.02144966f, 0.12655970f, -0.04356462f, -0.05821936f, 0.02361577f, 0.04118935f, 0.06404790f, 
    0.02462644f, 0.00891375f, -0.15397112f, -0.01748660f, -0.06087879f, -0.08900451f, -0.07768065f, -0.02715575f, 
    0.18614602f, 0.10276686f, 0.07500938f, 0.04456751f, -0.04522397f, 0.06145753f, 0.15709619f, 0.04344923f, 
    0.08472641f, 0.00075055f, -0.10964429f, 0.04584623f, 0.03075351f, -0.17472529f, -0.01127023f, -0.00306889f, 
    -0.03730135f, 0.14384744f, 0.08452857f, 0.05601957f, 0.06709348f, 0.02569097f, 0.05432998f, -0.04562479f, 
    0.08992046f, -0.21459115f, 0.01957502f, 0.08078248f, 0.03935065f, -0.08202399f, -0.04164002f, 0.07339353f, 
    0.08631170f, 0.01568873f, -0.01885849f, 0.19717209f, -0.04416466f, 0.16808814f, -0.16941921f, -0.18784916f, 
    0.11779693f, -0.03291431f, 0.03295812f, -0.11274364f, -0.08105017f, 0.00552615f, 0.12215524f, 0.11148527f, 
    0.20468380f, 0.07626857f, 0.14520493f, -0.08213752f, 0.09428169f, 0.10665409f, -0.08564787f, -0.01987166f, 
    -0.04945064f, -0.01195433f, -0.13069402f, -0.05155336f, 0.09480152f, -0.16009930f, 0.09351879f, 0.04450062f, 
    0.15928030f, -0.06336674f, -0.06865033f, 0.00196773f, -0.04924988f, -0.15030615f, -0.12582925f, -0.07985761f, 
    0.17755783f, -0.16761871f, -0.11100569f, 0.11783174f, 0.04067268f, -0.10118625f, -0.06888450f, 0.15353853f, 
    0.04543272f, 0.05485521f, 0.12209659f, 0.01884935f, 0.17621580f, 0.07641024f, 0.14476505f, 0.03846954f, 
    0.05797880f, 0.03078579f, 0.00150704f, 0.05862739f, -0.05151132f, -0.05139545f, -0.12943789f, -0.02123496f, 
    -0.01451747f, 0.03463459f, 0.07348277f, 0.13964023f, -0.15216644f, -0.12523410f, 0.09143308f, 0.06813112f, 
    -0.02340346f, -0.04718971f, 0.02024140f, -0.02999865f, 0.06445569f, -0.18487602f, 0.06603108f, 0.02122042f, 
    0.16507490f, -0.01492591f, 0.01959396f, -0.06425343f, -0.15770160f, 0.04666759f, -0.05196394f, 0.09792512f, 
    -0.05497596f, 0.08665183f, -0.19699903f, -0.04284029f, -0.02558604f, -0.00239215f, 0.14266348f, 0.01171788f, 
    -0.00436889f, 0.06793117f, -0.03900375f, 0.12898879f, 0.08026639f, -0.27960122f, -0.06861146f, -0.01777549f, 
    0.03607014f, 0.11464413f, 0.11145456f, 0.06834154f, 0.01342003f, 0.01485238f, 0.10151441f, 0.03477753f, 
    0.20418191f, -0.02190883f, 0.17703860f, -0.29194257f, 0.03810767f, 0.03087615f, -0.13848747f, 0.13883641f, 
    -0.02310845f, 0.07801767f, 0.00280730f, 0.06292544f, -0.22267143f, -0.02816238f, -0.18086171f, 0.24284786f, 
    -0.08716116f, -0.06043601f, 0.01247708f, 0.01459410f, -0.06642506f, 0.03706208f, 0.11788937f, -0.11876009f, 
    0.09045398f, -0.14533064f, 0.02810651f, 0.02460308f, 0.00587219f, -0.03455585f, 0.01279594f, -0.00299436f, 
    0.15723199f, 0.06009339f, 0.06758217f, 0.02562739f, -0.13262837f, -0.21621798f, 0.13987014f, 0.16056883f, 
    0.02497917f, 0.07575921f, -0.01012682f, 0.03026404f, -0.13874237f, -0.06259967f, -0.01420757f, -0.07062209f, 
    0.20598951f, 0.05568710f, 0.23404750f, 0.22767484f, 0.16420391f, -0.02443792f, 0.19058694f, -0.17387934f, 
    0.08098678f, 0.09976979f, 0.06977986f, 0.05841993f, 0.16240045f, -0.24770722f, -0.24429360f, 0.04787938f, 
    -0.05699621f, 0.14710890f, -0.09364700f, -0.04404707f, 0.08207022f, 0.05107921f, 0.02394700f, 0.01205294f, 
    -0.05981341f, -0.06820050f, -0.08886401f, -0.01895473f, 0.06113070f, -0.07677574f, -0.01644514f, 0.00994406f, 
    -0.01784271f, -0.11868889f, -0.00110826f, 0.05186332f, 0.15034959f, -0.15396117f, -0.12487587f, -0.01888510f, 
    0.02687004f, 0.17205830f, 0.08332679f, -0.02781647f, -0.18098590f, 0.11189741f, 0.13212547f, 0.06532098f, 
    0.02177749f, 0.40366197f, 0.04312667f, -0.19296455f, 0.22132799f, 0.04539276f, 0.09689691f, 0.00667974f, 
    -0.03207517f, 0.02441941f, 0.00716803f, 0.02431387f, -0.11838870f, 0.24327159f, -0.17497802f, 0.03763554f, 
    0.04902096f, -0.04478879f, 0.08459067f, 0.08668005f, 0.06445562f, -0.10332134f, 0.05384732f, -0.02912135f, 
    0.02691502f, -0.36052668f, -0.27115655f, 0.15277985f, -0.01093701f, -0.13820195f, 0.02275985f, 0.08595813f, 
    -0.06488674f, 0.00033539f, 0.07853714f, -0.03854406f, 0.25802261f, 0.20447098f, 0.17466222f, -0.13183263f, 
    0.14647843f, 0.06841061f, -0.05714222f, -0.03351871f, 0.06142761f, -0.01231352f, -0.01608209f, 0.04145702f, 
    -0.24858353f, 0.03248280f, -0.11836948f, 0.09347327f, -0.05726369f, -0.01121700f, 0.11762448f, 0.05101637f, 
    -0.17741771f, -0.09398218f, 0.09781010f, -0.05740347f, -0.20032237f, -0.00197226f, 0.10050994f, -0.11878951f, 
    0.14669402f, -0.01885984f, 0.05896614f, -0.03393598f, -0.04736324f, 0.13330677f, 0.02949284f, -0.01643447f, 
    0.07921169f, 0.13702375f, 0.02424950f, 0.20649053f, -0.05965981f, -0.05290576f, 0.02238273f, -0.00341083f, 
    -0.08458667f, 0.08292875f, 0.09757002f, 0.00063450f, 0.18955015f, -0.27089632f, -0.26332000f, -0.14915277f, 
    -0.01761479f, 0.00286800f, 0.13931051f, -0.03218081f, 0.03643945f, 0.07961513f, 0.04372240f, 0.08324624f, 
    -0.22851990f, -0.21531972f, -0.09688414f, -0.02339085f, -0.14718480f, 0.04857527f, 0.17263411f, 0.06220837f, 
    0.03634429f, 0.01684142f, 0.10150440f, 0.02110559f, -0.08948696f, -0.13094477f, 0.06413210f, 0.07438035f, 
    -0.07487272f, -0.04889236f, 0.01702548f, -0.06908351f, -0.17077313f, -0.08317136f, -0.01933768f, -0.00923546f, 
    -0.06385796f, 0.05958112f, 0.06701336f, -0.06069950f, -0.07809422f, 0.09757061f, 0.10355766f, 0.10995479f, 
    -0.00319661f, 0.13510665f, 0.06568604f, -0.18853192f, 0.04955698f, 0.16297869f, 0.03133497f, -0.04269227f, 
    0.03519068f, -0.04653058f, -0.16808777f, -0.05259774f, -0.00289637f, -0.02744246f, -0.05638228f, 0.04172427f, 
    0.30500048f, 0.00202598f, -0.01905831f, -0.01057480f, -0.16526459f, -0.00017864f, 0.01589132f, 0.20643815f, 
    -0.03624092f, 0.02755028f, -0.01691635f, -0.00390816f, 0.15706472f, -0.11322057f, 0.03278886f, -0.23728313f, 
    0.03877094f, 0.12811092f, 0.04409806f, 0.05668761f, 0.06363493f, -0.05021563f, 0.04630148f, -0.04164782f, 
    -0.07002385f, -0.13489041f, -0.06216612f, -0.14165805f, 0.04618444f, 0.01018264f, 0.06934287f, -0.01635613f, 
    0.05942196f, 0.11152142f, -0.02960841f, 0.20940268f, -0.18489923f, 0.38806170f, 0.07772611f, -0.14673880f, 
    0.09323706f, -0.00172567f, 0.07494631f, -0.02113658f, 0.05586460f, 0.13633430f, 0.16213450f, 0.00790883f, 
    0.20572069f, -0.15413435f, 0.02711434f, 0.23723111f, 0.03437148f, 0.07649627f, 0.09686546f, 0.00690009f, 
    -0.04332146f, -0.00491309f, -0.09482498f, -0.07882679f, 0.07724254f, -0.24021398f, 0.14133589f, -0.19326577f, 
    0.19529575f, 0.08003315f, 0.00291263f, -0.14392322f, -0.05293678f, -0.11924712f, -0.03800609f, 0.07570376f, 
    -0.18804148f, 0.02766768f, 0.05994402f, 0.18901683f, -0.00044140f, -0.00852170f, -0.01988472f, 0.07952306f, 
    0.03575597f, 0.12235243f, 0.10494315f, 0.05579403f, 0.06980544f, -0.16054581f, -0.06688270f, 0.07343885f, 
    -0.04493241f, -0.04347884f, -0.02769757f, 0.04425723f, -0.03248756f, 0.09682169f, 0.03682619f, -0.12632552f, 
    -0.06389390f, 0.06316957f, -0.03293875f, 0.00615025f, -0.11120323f, -0.10843122f, 0.02577988f, 0.05200930f, 
    0.07957321f, 0.11901210f, -0.05217397f, 0.06359258f, 0.42235351f, 0.01630449f, -0.12124409f, 0.00478857f, 
    0.03606240f, 0.07624979f, 0.04710070f, -0.05043361f, -0.00518986f, 0.01144275f, -0.05804361f, -0.02055320f, 
    0.18574786f, 0.20856594f, -0.18530668f, -0.18913500f, 0.00521407f, 0.09736840f, -0.00483984f, -0.14405681f, 
    0.05521333f, 0.05710964f, -0.06380937f, -0.06320690f, -0.12343496f, -0.14375564f, -0.05079715f, -0.00837542f, 
    0.01359412f, 0.05954456f, 0.15943883f, 0.09445062f, 0.02959391f, 0.23450004f, 0.13955206f, 0.19314300f, 
    -0.30999705f, -0.14674209f, 0.07533859f, -0.28049886f, -0.02914708f, 0.00825367f, -0.01458866f, 0.04307230f, 
    0.00552085f, 0.03163774f, -0.07184127f, -0.01331124f, 0.04109279f, -0.09224542f, -0.29633287f, -0.09668172f, 
    -0.11721999f, -0.00833944f, -0.00560331f, -0.06778181f, 0.10724293f, -0.02371237f, -0.07445870f, 0.00486430f, 
    -0.07359053f, -0.25148961f, 0.07188854f, -0.31219214f, 0.03626839f, -0.06554038f, 0.07659082f, 0.05090417f, 
    -0.11538175f, 0.06961147f, 0.10727132f, 0.05464655f, -0.12819353f, -0.04572485f, -0.05661038f, 0.09509743f, 
    0.06769520f, 0.06092677f, 0.06260272f, -0.09474741f, -0.07935447f, -0.01665917f, 0.05272365f, -0.01084850f, 
    -0.07374763f, 0.26168606f, 0.08954379f, 0.09419143f, 0.06512412f, 0.08722064f, -0.11050248f, 0.09992411f, 
    0.03841535f, -0.01627257f, 0.08861090f, -0.00890543f, -0.08022479f, -0.19525540f, 0.08308946f, 0.20881552f, 
    -0.05522350f, 0.16952461f, 0.04788722f, -0.00683911f, 0.00616072f, 0.01863491f, 0.04501335f, -0.01158538f, 
    0.21663055f, 0.10043392f, 0.02129880f, -0.08406323f, -0.04427980f, 0.09455584f, -0.03068529f, -0.04242133f, 
    0.10713297f, 0.13380457f, 0.15585595f, -0.02687791f, -0.13526586f, -0.07050989f, -0.01131630f, 0.22990495f, 
    -0.06262677f, -0.03220938f, -0.00130718f, 0.04485739f, 0.09907423f, 0.02991041f, -0.06061088f, -0.00143273f, 
    0.11899225f, 0.18184091f, 0.00250902f, -0.21692561f, 0.07336935f, 0.02893342f, 0.06767093f, 0.11129576f, 
    -0.02611499f, 0.04969755f, -0.00150338f, 0.06628551f, 0.02580543f, -0.16156511f, -0.12714738f, 0.21009718f, 
    0.03508014f, 0.01194907f, 0.16256261f, 0.16064470f, 0.08804818f, 0.11107937f, 0.03450000f, -0.05056511f, 
    -0.03908743f, -0.03237158f, -0.08569407f, -0.30169395f, 0.04906769f, 0.08072937f, 0.03266114f, -0.06370468f, 
    -0.00376999f, -0.06020913f, -0.13002725f, -0.02745005f, -0.04520379f, -0.05534868f, 0.07181937f, -0.12720490f, 
    -0.02652388f, 0.10509831f, 0.00266142f, 0.03835993f, 0.03670321f, -0.00340389f, 0.09748229f, 0.07260192f, 
    -0.12563772f, -0.04850798f, -0.19269413f, -0.16274056f, -0.00321799f, 0.01809221f, 0.05184329f, -0.15573902f, 
    0.03985992f, -0.04302026f, 0.16498350f, -0.02336017f, 0.32036135f, -0.16453531f, 0.06909652f, 0.29540277f, 
    0.03835538f, 0.08993357f, 0.00124066f, 0.00462995f, 0.00028785f, 0.04978347f, -0.00542721f, 0.15948384f, 
    0.03272553f, 0.25365472f, 0.02043835f, 0.26176360f, 0.01087357f, -0.03577175f, 0.05019115f, 0.23405077f, 
    0.01516944f, 0.03168988f, 0.10233338f, -0.01643788f, 0.17099155f, -0.06000758f, -0.09921107f, 0.21735692f, 
    0.01221258f, 0.04186504f, 0.14429764f, 0.00857034f, -0.04750896f, -0.08952831f, 0.13295500f, 0.05876818f, 
    0.03235192f, -0.04290951f, 0.03678280f, 0.00663174f, 0.00504926f, 0.03863546f, 0.01660911f, -0.00455883f, 
    0.02215623f, 0.04776145f, 0.06207511f, 0.01133103f, -0.04384061f, -0.04571756f, 0.00151384f, -0.03496068f, 
    -0.04278101f, -0.07370351f, -0.03628917f, 0.02081415f, 0.00530921f, -0.00083264f, -0.03602055f, -0.03604429f, 
    0.00439426f, 0.02068435f, -0.06992230f, -0.00246723f, -0.01622053f, -0.00184731f, -0.06855204f, -0.07941897f, 
    0.04004524f, -0.00883057f, 0.02783879f, -0.05560366f, 0.05184617f, 0.03603399f, 0.05535637f, -0.00698785f, 
    -0.04665720f, 0.01146843f, -0.00537460f, -0.00377997f, 0.00005454f, -0.03322902f, -0.05107834f, 0.02401298f, 
    -0.08122449f, -0.04954779f, 0.01326428f, 0.03883572f, -0.02771293f, -0.05656802f, -0.03409831f, -0.04530912f, 
    0.00098518f, 0.00938702f, -0.07833621f, -0.04130881f, -0.00775450f, -0.06162779f, -0.04555947f, -0.07514557f, 
    -0.04032726f, -0.06043155f, 0.01527180f, 0.03388535f, -0.04757731f, -0.01911284f, -0.01805423f, 0.01350104f, 
    -0.01884373f, 0.02916398f, -0.07946707f, -0.01890749f, -0.01571603f, 0.01221731f, 0.01664210f, 0.00194785f, 
    -0.07416396f, -0.06469344f, -0.01336220f, -0.00638874f, 0.00759118f, -0.02306992f, -0.00959821f, -0.02161624f, 
    -0.07091866f, 0.04305370f, -0.01622690f, -0.05599146f, 0.00594863f, -0.01872283f, -0.03677486f, -0.01008585f, 
    -0.03220002f, -0.00400383f, 0.00293475f, -0.01887400f, -0.08374683f, 0.02601170f, -0.03127336f, 0.02024571f, 
    -0.04598628f, -0.00472854f, -0.09307183f, 0.02200076f, -0.04623441f, -0.03129828f, -0.01058488f, 0.00829249f, 
    -0.03060416f, -0.07417679f, -0.07260573f, 0.03998256f, -0.08030773f, 0.04386877f, 0.02155280f, 0.05212690f, 
    0.03073484f, -0.06142127f, 0.06205780f, -0.04401496f, -0.06111529f, 0.02475968f, -0.02178483f, 0.06116577f, 
    0.04600770f, -0.07063774f, 0.01025175f, -0.06425864f, -0.01990479f, -0.03802540f, -0.01708861f, -0.06074127f, 
    0.01454941f, -0.08445434f, 0.03913952f, -0.02320844f, -0.07878931f, 0.03589156f, 0.01953784f, 0.05420594f, 
    -0.06044615f, 0.05758469f, 0.00054648f, 0.05759905f, 0.04763058f, 0.02681531f, -0.00796987f, -0.07732461f, 
    -0.06644872f, -0.01889695f, -0.08520775f, -0.05999256f, -0.03485306f, -0.00939268f, 0.02375112f, -0.05434007f, 
    0.01306255f, -0.04240492f, -0.06547485f, 0.04179291f, -0.07170328f, -0.00712583f, -0.00687381f, -0.03914162f, 
    -0.02816975f, -0.07773113f, -0.02127162f, 0.03605996f, -0.05920139f, -0.03011245f, -0.00291608f, -0.08366594f, 
    -0.02303737f, -0.04873371f, -0.00880843f, -0.03799486f, 0.04325777f, -0.04761033f, 0.01149190f, -0.06965292f, 
    -0.01945803f, -0.08507738f, 0.03732257f, -0.01291247f, 0.00038481f, -0.04094161f, -0.01037596f, 0.03045328f, 
    0.01164042f, 0.16937910f, -0.11707183f, 0.08174814f, 0.14264211f, 0.05801110f, -0.05477452f, -0.03619825f, 
    0.02859951f, 0.05538187f, -0.08978479f, -0.12395041f, 0.14187211f, 0.15785687f, -0.12089353f, -0.13752508f, 
    -0.04427393f, 0.03715897f, 0.04707709f, -0.00886013f, 0.00649744f, 0.04806184f, -0.11075934f, -0.06344475f, 
    -0.10610455f, 0.18327849f, -0.13324146f, -0.17584127f, 0.10774270f, -0.00984545f, -0.00133141f, 0.02556393f, 
    -0.01553493f, 0.01524849f, -0.12604636f, 0.12554803f, -0.15466896f, -0.02976513f, -0.03565752f, -0.04632000f, 
    0.01854248f, -0.02015018f, 0.02110630f, 0.14720361f, 0.09206264f, 0.11437172f, 0.08167826f, -0.07909832f, 
    0.16718435f, 0.08418548f, 0.03107463f, -0.08687665f, -0.06589675f, -0.08001102f, -0.08168586f, -0.02961838f, 
    0.05255847f, -0.03824717f, 0.14897078f, -0.03891766f, -0.42887992f, 0.05077700f, 0.11922525f, 0.10439294f, 
    -0.05821392f, 0.10612502f, 0.12148929f, -0.09508073f, 0.04394908f, 0.04510186f, 0.08421019f, 0.11655977f, 
    -0.04161476f, -0.01624491f, -0.00716343f, 0.08075771f, -0.00133569f, 0.10519126f, -0.04150795f, 0.00490491f, 
    -0.03239514f, 0.02441403f, 0.12191673f, -0.14469905f, -0.27318481f, -0.11001364f, 0.07677613f, 0.04190567f, 
    -0.10743587f, 0.07656000f, -0.06783386f, 0.03944600f, 0.15084450f, -0.00172384f, 0.05294120f, 0.00924657f, 
    0.29543895f, -0.08932987f, -0.07237272f, 0.05761887f, -0.12928136f, 0.00413102f, 0.02560388f, 0.10329802f, 
    0.07583550f, 0.03527448f, 0.11057716f, 0.15040366f, 0.12000134f, -0.30613059f, 0.12502114f, 0.08250885f, 
    0.03021613f, -0.06696508f, 0.11190915f, -0.00635220f, 0.00382282f, 0.03918794f, 0.03042390f, -0.05148700f, 
    0.13678636f, 0.31740442f, -0.00349888f, -0.27476016f, 0.09377532f, 0.20687036f, 0.08173361f, -0.01387661f, 
    0.08237524f, -0.06325042f, 0.01059544f, 0.07984856f, 0.03162012f, -0.00782931f, -0.13017118f, -0.00463956f, 
    -0.02669122f, -0.01987503f, 0.07183258f, 0.05367403f, 0.02431715f, -0.07283915f, 0.08655966f, 0.22005838f, 
    -0.14462231f, 0.13421668f, -0.20332688f, -0.07739768f, 0.07364440f, 0.28290305f, -0.10691786f, -0.12252264f, 
    -0.01987382f, -0.00245411f, 0.00244295f, -0.16363174f, -0.04899149f, -0.14053915f, 0.17741536f, -0.01051433f, 
    -0.16058056f, -0.07102384f, 0.05925104f, -0.03865887f, -0.05182889f, -0.07395008f, -0.05176942f, 0.09387273f, 
    0.28080207f, 0.32000756f, 0.23044451f, 0.17265065f, -0.04516561f, -0.01300084f, -0.02565043f, 0.15251373f, 
    -0.04312606f, -0.08519137f, 0.06233682f, 0.07277898f, -0.21019244f, 0.27364135f, 0.09155122f, 0.21094678f, 
    0.02377080f, 0.04151896f, -0.05020967f, -0.01406920f, -0.13584681f, 0.00848779f, -0.05854700f, -0.13037479f, 
    -0.28328916f, 0.08311883f, 0.13560252f, -0.16687465f, 0.08093229f, -0.01592148f, 0.07257507f, 0.03415124f, 
    -0.04451520f, -0.10019342f, 0.06859494f, 0.05815034f, -0.17256930f, -0.01580242f, -0.04608383f, 0.25629961f, 
    0.15946503f, 0.20513494f, 0.07018560f, -0.09716223f, -0.02479712f, 0.01740805f, 0.02057860f, -0.06811781f, 
    -0.09653081f, -0.11333115f, 0.15203573f, -0.06390562f, -0.00225170f, -0.09816031f, 0.07910200f, 0.00554575f, 
    -0.08545142f, 0.01048655f, 0.19352330f, -0.10571723f, -0.17867972f, 0.08619749f, 0.07361612f, -0.11295836f, 
    0.01757067f, -0.04307942f, 0.07892112f, -0.08163602f, 0.04519676f, -0.03726295f, 0.06036244f, -0.00652648f, 
    -0.19071546f, 0.13182008f, 0.12625989f, 0.17328280f, 0.00176394f, -0.02819604f, -0.00625587f, 0.15637922f, 
    -0.00947541f, 0.04206001f, 0.10661157f, -0.11572282f, 0.13710567f, -0.01976597f, 0.11482564f, 0.01584352f, 
    0.05679256f, 0.01984993f, -0.10952549f, 0.12203591f, -0.02023728f, -0.10565802f, 0.01019277f, 0.04978403f, 
    0.07647611f, -0.00632897f, 0.03157053f, -0.21264546f, -0.11558972f, 0.02270409f, 0.15962756f, 0.05646991f, 
    0.00254602f, 0.13556509f, -0.02630557f, 0.07245301f, 0.25675237f, -0.11652283f, 0.14164659f, 0.20700464f, 
    -0.04700896f, -0.10739461f, -0.01269891f, 0.03232131f, 0.00704984f, 0.01295654f, -0.02713689f, 0.09135782f, 
    -0.17388709f, 0.13738601f, 0.11877257f, -0.18439539f, -0.09227497f, 0.03809882f, 0.05962171f, 0.00919037f, 
    0.04159685f, 0.02279809f, -0.13041615f, -0.05399359f, -0.21081027f, 0.02420155f, -0.17746474f, 0.15769252f, 
    0.01025822f, 0.05391049f, 0.04745306f, -0.08826633f, 0.05986213f, 0.10542974f, 0.07162618f, -0.00156814f, 
    -0.44556406f, -0.00213572f, -0.00159107f, 0.04452635f, 0.14794923f, 0.00894970f, 0.05633922f, -0.03916363f, 
    0.04701929f, 0.02484273f, 0.01476510f, 0.18731031f, 0.10437312f, 0.04682559f, 0.02210570f, -0.14284848f, 
    0.01745518f, -0.00816541f, 0.10088497f, 0.01022930f, 0.02359572f, 0.04637893f, 0.08870035f, -0.01529828f, 
    -0.09242741f, -0.04615019f, 0.00232400f, 0.04696939f, 0.08531371f, -0.13080348f, 0.02535780f, 0.01071235f, 
    0.10062649f, -0.06772761f, 0.00433461f, 0.15258864f, 0.25998965f, 0.24835944f, 0.06471889f, 0.31949013f, 
    0.04134177f, 0.14398254f, -0.00075376f, -0.02073126f, -0.01118936f, -0.04031576f, 0.04155438f, 0.06079591f, 
    -0.24047869f, -0.12669213f, 0.15503773f, 0.18507500f, 0.03710531f, 0.05543828f, -0.00491212f, -0.05697812f, 
    -0.00448180f, 0.00278674f, 0.09038214f, -0.15880813f, -0.00119128f, 0.05042478f, 0.05289810f, -0.02670172f, 
    0.03685288f, -0.05974686f, 0.11496044f, 0.05844740f, -0.01094764f, 0.01395342f, 0.03253304f, 0.08200005f, 
    0.21343330f, 0.07020248f, -0.12044110f, 0.10074291f, -0.01047633f, -0.01203631f, -0.02559374f, 0.10188236f, 
    0.12836201f, 0.07250862f, -0.02629668f, 0.03080716f, 0.09710817f, 0.04287316f, 0.25374514f, -0.06871364f, 
    0.07426838f, -0.14885435f, 0.09432776f, 0.06850001f, -0.03488445f, -0.01489600f, 0.00144555f, 0.00317855f, 
    0.11437918f, 0.19124895f, -0.06000020f, 0.09000387f, -0.02943996f, 0.06220043f, -0.01838883f, 0.01000380f, 
    0.02209207f, 0.09514806f, -0.09173351f, 0.04426487f, 0.25742200f, 0.04185133f, 0.08325422f, 0.03673305f, 
    -0.00773469f, -0.07357303f, -0.01236042f, 0.04865990f, -0.02252308f, -0.11016098f, -0.10350173f, 0.07313132f, 
    0.24203537f, -0.09325654f, 0.05305598f, -0.06649867f, 0.01728762f, 0.06116336f, 0.00524084f, -0.04820260f, 
    -0.00350610f, -0.04217678f, -0.02573696f, 0.10005061f, 0.06256752f, 0.07383952f, 0.04225143f, -0.12610763f, 
    0.00488576f, -0.05490975f, 0.00406333f, -0.03690225f, 0.05345479f, -0.00993347f, -0.07732648f, 0.01440503f, 
    -0.03106246f, -0.05812356f, -0.10818102f, 0.19533059f, 0.14484750f, 0.02771224f, -0.04699330f, -0.05901191f, 
    -0.04618866f, -0.01361125f, -0.02046401f, 0.18080147f, 0.10394307f, 0.04942347f, -0.01060164f, -0.04787712f, 
    0.04032798f, 0.09964396f, -0.02509383f, -0.06398598f, -0.10815070f, 0.01022462f, 0.11087143f, -0.00104934f, 
    0.10999204f, -0.14700033f, -0.02969051f, 0.26346791f, 0.07893500f, 0.05281474f, -0.08750658f, -0.01376011f, 
    0.00464298f, 0.01605099f, 0.00997314f, -0.04456563f, 0.04275540f, 0.14125668f, 0.23054567f, -0.15640704f, 
    0.00298403f, 0.04650960f, -0.04453250f, -0.01455909f, -0.05001475f, 0.02312199f, -0.05192981f, 0.10538293f, 
    0.32213750f, 0.06613138f, 0.03040450f, 0.35401073f, -0.01778233f, 0.02966350f, -0.08213469f, 0.08896409f, 
    -0.10296109f, 0.08140007f, 0.05037801f, -0.13906151f, 0.01191588f, 0.00640447f, -0.11235733f, 0.05917926f, 
    0.12060168f, -0.07458960f, -0.06490137f, -0.07730579f, -0.01698029f, 0.01517267f, -0.01923591f, -0.14217870f, 
    0.23466647f, 0.06891036f, 0.03815981f, 0.00197781f, -0.10509954f, 0.06230129f, 0.09467374f, 0.04285236f, 
    -0.06817377f, 0.02213823f, -0.10691317f, -0.00918869f, -0.13835113f, 0.04684074f, 0.02624884f, -0.25228414f, 
    0.11695092f, -0.01765384f, 0.04666230f, 0.11574406f, -0.06396290f, 0.06154830f, -0.06695674f, -0.07049340f, 
    0.17790139f, 0.08027554f, -0.12241893f, -0.27728677f, -0.05949520f, 0.10184571f, -0.02925546f, -0.19469170f, 
    0.06130239f, 0.01557511f, -0.02185263f, 0.01221177f, 0.04342655f, -0.07289587f, 0.01405269f, -0.11301946f, 
    0.03187969f, 0.02310943f, 0.01908923f, 0.05665771f, 0.05319639f, 0.03354105f, 0.06247250f, -0.00232293f, 
    0.04487371f, -0.00357403f, -0.04376164f, -0.16320130f, 0.14461140f, 0.08849984f, 0.05489634f, -0.00135375f, 
    -0.00886390f, 0.03725486f, -0.11521745f, 0.11095244f, -0.00669272f, 0.14626502f, -0.03032997f, 0.09337588f, 
    0.18948358f, 0.01975611f, -0.00456584f, 0.07812557f, 0.00994367f, 0.12409009f, 0.03421805f, -0.14107224f, 
    -0.12399299f, 0.00816217f, 0.17697597f, -0.04418820f, 0.14465946f, 0.02070333f, -0.09214520f, 0.03972755f, 
    -0.01999597f, 0.03866725f, 0.11924359f, 0.02758561f, -0.18327123f, -0.08593655f, 0.13746798f, 0.10974490f, 
    0.02036360f, 0.04068461f, 0.02384731f, 0.04180259f, 0.06909227f, 0.00856461f, 0.01617830f, 0.05688478f, 
    0.07032310f, -0.04391049f, 0.27871612f, -0.01668188f, 0.14281452f, 0.12881461f, 0.14019902f, -0.06855541f, 
    -0.06696676f, -0.08972175f, 0.07926302f, -0.01870644f, 0.10389353f, -0.15539266f, 0.06288122f, 0.22709489f, 
    -0.09409103f, -0.02556995f, -0.01736738f, 0.00246285f, 0.05797728f, -0.00639150f, 0.03851740f, -0.00160479f, 
    0.03846777f, -0.03762880f, 0.11404731f, 0.06107480f, 0.05058869f, 0.05451904f, -0.03067930f, -0.09298402f, 
    -0.13954654f, 0.11146277f, 0.00511616f, 0.07744459f, 0.22618107f, -0.41865054f, 0.02551068f, 0.28057268f, 
    -0.02610880f, 0.08765101f, 0.03736388f, 0.07902915f, -0.14707009f, -0.01929703f, 0.07271812f, -0.00704520f, 
    -0.31941923f, 0.13086304f, 0.00899030f, -0.26099202f, 0.11679593f, -0.02678434f, -0.02063821f, 0.10336205f, 
    -0.02967805f, -0.01286681f, -0.03090394f, -0.05339093f, -0.05604286f, 0.03104881f, -0.11893196f, 0.13773696f, 
    0.10338341f, -0.02618064f, 0.00842946f, -0.06257738f, -0.09383146f, 0.05738295f, -0.06413210f, 0.02391812f, 
    0.22166651f, -0.03466020f, -0.01795809f, 0.11986347f, 0.21791525f, 0.08686265f, 0.04912343f, 0.10743303f, 
    -0.05651258f, 0.05508379f, 0.11972312f, -0.07024943f, 0.21792328f, -0.07447521f, -0.14844331f, -0.32971036f, 
    0.01189921f, -0.07700961f, 0.01788488f, -0.00871209f, -0.07294980f, 0.00450613f, 0.00889660f, -0.13015650f, 
    0.10263656f, 0.04027327f, 0.00230490f, -0.00187285f, 0.03823765f, -0.06548806f, 0.12539476f, -0.08873073f, 
    -0.03300896f, -0.08203512f, -0.06103311f, 0.00114259f, -0.17541941f, 0.12715794f, 0.15382288f, -0.09811001f, 
    0.02934412f, -0.01275018f, -0.03182058f, 0.02067498f, -0.15963379f, 0.03372806f, -0.17591128f, -0.03422133f, 
    0.19961640f, -0.08074841f, -0.00716385f, 0.14165190f, 0.01050142f, -0.00348396f, -0.06500974f, -0.06642256f, 
    -0.11337908f, -0.07765821f, -0.03462712f, -0.04436680f, 0.15843345f, 0.09689261f, 0.04491435f, 0.04043159f, 
    0.02977999f, 0.07717642f, -0.06232402f, 0.02283901f, -0.03281486f, 0.08345534f, 0.13858619f, 0.11807086f, 
    -0.05967831f, -0.14630903f, 0.17271139f, -0.20473452f, 0.03213109f, 0.08220689f, -0.01005161f, -0.06569190f, 
    0.00130020f, -0.01690299f, -0.14723298f, -0.08043125f, 0.15091780f, 0.18017529f, -0.24535079f, 0.10443757f, 
    0.03216410f, 0.03368782f, 0.00576323f, -0.19593202f, 0.15012068f, -0.00305981f, 0.05718355f, -0.00156479f, 
    -0.02363251f, -0.13930117f, 0.09525236f, -0.24953853f, 0.10381940f, 0.03381154f, 0.08482593f, -0.00109612f, 
    -0.08009343f, 0.04624971f, 0.13415261f, -0.00433825f, -0.12065580f, -0.10706536f, 0.02785691f, -0.01124296f, 
    -0.01653531f, 0.03459019f, -0.01261261f, -0.07953984f, -0.00033314f, 0.00462808f, 0.07271677f, 0.00458802f, 
    -0.01539462f, 0.28839329f, 0.00269956f, -0.06036262f, -0.02756119f, 0.02509987f, 0.03249016f, 0.01135832f, 
    -0.01600404f, -0.03546340f, 0.10618557f, -0.05119331f, -0.07772497f, -0.16967480f, 0.01201796f, 0.23587444f, 
    -0.07220136f, 0.08667125f, -0.02124579f, 0.01992626f, -0.01448302f, 0.01231562f, 0.07413688f, 0.01072520f, 
    0.13560060f, -0.15671220f, 0.01455310f, 0.07541534f, 0.01144095f, 0.01373993f, -0.10942934f, 0.04735408f, 
    -0.08119277f, 0.14270301f, 0.08162633f, -0.09240729f, -0.04468894f, -0.31211331f, 0.04697574f, 0.32079878f, 
    -0.05797304f, 0.01068484f, 0.03010566f, 0.06182933f, 0.00134547f, 0.01027896f, 0.05297891f, 0.13535126f, 
    0.22727196f, 0.28325725f, 0.06142175f, -0.20240402f, 0.04089591f, 0.01015596f, -0.04523563f, 0.10805436f, 
    -0.00251059f, 0.02698750f, -0.05216322f, 0.00956596f, -0.05774888f, -0.24010485f, -0.05667063f, 0.07734402f, 
    -0.01412430f, -0.07049928f, 0.00091452f, 0.19523831f, 0.01101128f, 0.12586083f, 0.02370767f, -0.08118398f, 
    0.14402543f, 0.05727835f, 0.02555228f, -0.25129333f, 0.09069864f, 0.18699212f, 0.08181300f, 0.09619696f, 
    0.05260570f, 0.08499058f, -0.05484702f, 0.00840177f, 0.00289730f, -0.06235861f, -0.02945324f, -0.05321853f, 
    -0.05311815f, 0.12909684f, 0.03811303f, 0.05363997f, 0.04285993f, -0.09179828f, -0.00627478f, 0.18382706f, 
    -0.04246303f, 0.05177167f, 0.00511137f, -0.00609829f, 0.13722968f, 0.08069164f, 0.01279418f, -0.05403174f, 
    -0.00049588f, -0.09363284f, 0.06223497f, -0.10494471f, 0.04929538f, -0.16161378f, 0.13926935f, 0.25263903f, 
    -0.01571698f, -0.12118074f, -0.01353922f, 0.00867436f, -0.07906406f, 0.11832730f, -0.12983227f, 0.16876720f, 
    0.00902691f, 0.27368766f, -0.05517949f, 0.24337769f, 0.01677142f, -0.05885581f, -0.00751704f, 0.18359259f, 
    -0.08522741f, -0.06768475f, 0.08304642f, 0.00358076f, 0.22170611f, -0.12658435f, -0.08106433f, 0.16252656f, 
    0.03804697f, 0.08622992f, 0.13335356f, 0.08569906f, 0.02801973f, 0.02659860f, 0.05309266f, -0.00451344f, 
    -0.05708705f, -0.06647386f, -0.05026500f, 0.03109333f, -0.02345228f, -0.01839969f, -0.03611094f, 0.00114364f, 
    -0.06027641f, -0.05478225f, 0.04077306f, 0.06345985f, 0.02231403f, 0.06260053f, 0.03382464f, -0.05781880f, 
    0.06365964f, -0.03427426f, 0.02937494f, 0.04504468f, 0.00245478f, -0.00760099f, 0.01567015f, 0.05325742f, 
    -0.03033134f, -0.00579429f, 0.02221830f, 0.01798610f, 0.04322182f, 0.03879239f, 0.03263069f, 0.02876324f, 
    0.05802574f, 0.01094172f, 0.04033198f, 0.00047014f, -0.02590586f, 0.06137955f, 0.05030192f, 0.03786205f, 
    0.00483735f, -0.03721510f, 0.00542746f, -0.06425534f, -0.02601001f, -0.06917137f, -0.04753219f, -0.02760094f, 
    -0.04512658f, -0.08012193f, -0.02633430f, 0.01683500f, -0.03596799f, -0.01052586f, 0.00057803f, -0.05431860f, 
    0.06349020f, 0.00497385f, 0.02152158f, -0.03770295f, 0.00178359f, 0.02274222f, 0.01872361f, -0.07948456f, 
    -0.05249740f, -0.02186715f, -0.00628446f, 0.02907261f, -0.07574704f, -0.01980227f, -0.05586652f, -0.01825691f, 
    -0.05151667f, 0.00992281f, -0.01581013f, -0.03564094f, 0.05518018f, -0.03104419f, -0.04188007f, -0.00536265f, 
    -0.06362555f, -0.05202703f, 0.05009551f, -0.02062157f, -0.04193525f, -0.05347778f, -0.01202139f, -0.06898994f, 
    -0.07912710f, -0.07598203f, -0.05461336f, 0.02975330f, -0.04928092f, 0.01972621f, -0.00008416f, -0.01549591f, 
    0.01651546f, -0.02754106f, -0.02160649f, -0.00339508f, -0.07614643f, 0.03301226f, 0.01518980f, -0.00983599f, 
    -0.02047674f, 0.06042013f, 0.01004981f, 0.03397106f, 0.00595399f, 0.05433084f, -0.01689175f, 0.03607050f, 
    0.01309985f, 0.05883660f, 0.03215259f, -0.00350140f, -0.00156562f, -0.03200715f, -0.04276931f, -0.00498869f, 
    -0.04694730f, -0.01426288f, -0.02724767f, -0.03864408f, -0.04248854f, -0.01305971f, 0.03403923f, -0.03566067f, 
    -0.04198034f, -0.03874665f, -0.05299618f, 0.00609464f, -0.06911219f, -0.05288309f, -0.07439294f, -0.00943737f, 
    0.00636372f, -0.02264674f, -0.06646923f, -0.01320449f, 0.01277983f, -0.00373489f, -0.04291273f, 0.06226467f, 
    0.05771029f, -0.01179201f, -0.07738876f, -0.03001104f, -0.03869296f, 0.01881385f, -0.07674818f, -0.03551508f, 
    -0.01405459f, -0.04587624f, -0.00694550f, -0.01839001f, 0.04732069f, -0.00970856f, 0.04125353f, -0.05787128f, 
    -0.07086910f, 0.02318823f, -0.04871149f, -0.01593603f, -0.06576658f, -0.06621096f, -0.05433989f, -0.04412957f, 
    -0.04671057f, 0.03977611f, 0.03981462f, -0.07093799f, -0.00704453f, -0.01814159f, -0.05627235f, 0.05292459f, 
    -0.05361509f, -0.03203233f, -0.03216838f, 0.02909786f, -0.04674232f, -0.02256084f, 0.00307932f, -0.06866986f, 
    -0.02181605f, -0.06448127f, -0.02768262f, -0.02953145f, -0.01953923f, 0.05436976f, -0.07582565f, 0.04984578f, 
    -0.05354256f, 0.04095134f, -0.23270211f, -0.11492499f, -0.06479928f, 0.01685669f, 0.06756651f, 0.08158184f, 
    -0.05331830f, -0.04689458f, 0.10482859f, 0.23062904f, -0.12408128f, -0.03821956f, 0.23611932f, 0.10417607f, 
    -0.01085515f, 0.01249337f, 0.00697107f, 0.00573245f, -0.16988035f, -0.07174162f, 0.05437865f, 0.02134749f, 
    0.11687536f, -0.01099478f, -0.09276778f, -0.02200300f, -0.06041326f, 0.03604645f, 0.04677258f, 0.15174685f, 
    0.03221089f, 0.05120426f, 0.01165012f, -0.06920800f, 0.31719324f, 0.06084161f, 0.06365348f, -0.07121049f, 
    0.08776154f, -0.03115391f, -0.01824641f, 0.03863344f, -0.01653424f, -0.06934774f, -0.13596395f, 0.01992820f, 
    -0.27321461f, -0.31692764f, 0.11395549f, 0.06972481f, 0.03471031f, 0.17386386f, 0.02809684f, 0.03064056f, 
    0.08256771f, 0.15290786f, -0.08948656f, 0.05818514f, 0.40740809f, 0.06961370f, 0.02628474f, -0.22791500f, 
    0.08749691f, -0.07416376f, -0.03382480f, 0.04370730f, -0.06365217f, 0.01925344f, 0.05653722f, 0.04341492f, 
    0.03138189f, 0.05757537f, 0.03088102f, -0.03846053f, -0.02258752f, -0.13775831f, 0.11286540f, 0.00767119f, 
    -0.03954602f, 0.00299028f, -0.00409609f, 0.13062915f, 0.24166821f, 0.37352440f, 0.05442119f, -0.10425394f, 
    0.08366549f, 0.06736786f, -0.04128490f, 0.04925793f, -0.07820284f, 0.06011929f, 0.05639436f, 0.04670376f, 
    -0.16139992f, -0.11499007f, -0.05764058f, 0.13842501f, 0.10342640f, 0.06745584f, -0.04771134f, 0.02324555f, 
    -0.02629315f, -0.01667884f, -0.01768012f, -0.02527002f, -0.19690043f, 0.11589253f, 0.02736917f, -0.04327017f, 
    0.08637827f, 0.10036632f, 0.03953811f, -0.06666834f, 0.05944745f, -0.03409642f, 0.07261117f, 0.10949266f, 
    -0.18273170f, -0.10337805f, 0.09283002f, 0.36573690f, -0.09558978f, -0.11965161f, 0.07761249f, 0.09338313f, 
    -0.12285259f, 0.05279430f, 0.14798880f, -0.03656649f, -0.09281428f, -0.04403254f, -0.01284902f, -0.02742296f, 
    0.00203436f, -0.10425442f, -0.00126875f, 0.02621263f, 0.02470770f, 0.06656868f, 0.04111926f, -0.12330991f, 
    0.12529694f, 0.02061855f, 0.06424429f, -0.05545550f, -0.10426619f, -0.07858106f, 0.07640841f, 0.03838688f, 
    -0.09453931f, 0.03406901f, -0.05147710f, 0.07791968f, 0.05964193f, 0.14740182f, -0.10520627f, -0.10970779f, 
    0.14676996f, 0.06573256f, 0.09611618f, 0.02146152f, 0.04890243f, -0.02662073f, 0.11077649f, -0.09291790f, 
    -0.14022812f, -0.09747615f, 0.20897447f, -0.21998575f, -0.05575130f, 0.03434549f, -0.00745994f, -0.26335290f, 
    0.17542461f, 0.09422895f, -0.08267205f, -0.03267762f, -0.03774556f, 0.08670884f, 0.07740104f, -0.18952955f, 
    0.07173938f, -0.11037637f, -0.07201645f, -0.02396774f, 0.11033019f, 0.04957488f, -0.02471971f, 0.02220039f, 
    0.08944550f, 0.02358703f, -0.18805915f, 0.16743086f, 0.00332212f, -0.06760035f, 0.09972307f, -0.11561392f, 
    0.10604393f, -0.01255063f, -0.06190257f, 0.04267446f, 0.07618675f, 0.19183525f, 0.23401272f, -0.20913047f, 
    0.06982442f, 0.02836258f, 0.11657416f, 0.00764501f, -0.03689642f, -0.06885009f, -0.04079938f, 0.08568864f, 
    0.25954568f, 0.17453159f, -0.04819476f, 0.06903602f, 0.06135538f, 0.04256927f, 0.05557086f, -0.05248700f, 
    -0.06556384f, 0.08360267f, 0.02555502f, 0.07909904f, 0.29574570f, 0.01235292f, 0.11711158f, -0.12896498f, 
    -0.00966904f, -0.07567613f, 0.09916768f, 0.01298248f, 0.02779235f, -0.03152926f, -0.04876269f, 0.02149859f, 
    -0.24166681f, 0.01107633f, -0.12250739f, -0.08398259f, -0.04787105f, 0.01254367f, -0.09649524f, -0.04123190f, 
    0.00718405f, -0.00186335f, -0.04707063f, -0.03928451f, -0.09658028f, 0.24316648f, 0.10276192f, 0.06089590f, 
    0.12855777f, 0.04367581f, 0.12390714f, 0.06184456f, -0.00480004f, -0.06345709f, -0.05163551f, 0.00103247f, 
    -0.19031617f, 0.13103457f, -0.15867843f, -0.02735108f, -0.02407366f, 0.09369164f, -0.10300740f, 0.01655106f, 
    0.03872152f, 0.16741596f, -0.05832075f, 0.01033532f, 0.04427559f, -0.15480079f, 0.11295035f, 0.03383155f, 
    -0.08162590f, 0.05637090f, -0.02944002f, 0.06448423f, 0.07462953f, 0.02235655f, 0.05439115f, -0.07621731f, 
    0.09363796f, 0.03266223f, -0.04861658f, 0.09339024f, -0.15281001f, -0.03917562f, 0.05411669f, 0.09787087f, 
    0.01407075f, 0.07563898f, 0.07601519f, -0.10824326f, -0.02708567f, 0.04870458f, 0.18225807f, -0.07526568f, 
    -0.11734286f, 0.07068378f, 0.08194643f, -0.15164730f, 0.03155890f, 0.16731888f, -0.05515113f, 0.08635829f, 
    -0.02336016f, 0.21897313f, 0.20037034f, -0.15085237f, 0.01983940f, 0.04404042f, 0.02685240f, -0.06186946f, 
    0.00555911f, 0.02069521f, 0.03886223f, -0.00589581f, -0.11912632f, -0.04699996f, -0.21956234f, 0.03004348f, 
    -0.01834749f, -0.04267742f, 0.08155817f, -0.06216051f, 0.09352184f, -0.03558308f, 0.17162387f, -0.01336888f, 
    0.01506728f, 0.01627889f, 0.00188244f, 0.09298829f, 0.01319774f, -0.00634937f, -0.09706622f, -0.14652663f, 
    0.02084867f, -0.02543376f, -0.10023647f, -0.08671040f, -0.16699442f, 0.11889116f, 0.05824183f, -0.10741448f, 
    -0.19600567f, 0.06921074f, -0.06304294f, -0.00059351f, 0.01500123f, 0.05242068f, 0.04713180f, 0.06734320f, 
    0.03023089f, 0.05328512f, 0.10617391f, -0.19563526f, -0.01695117f, 0.08486408f, -0.14387789f, -0.04990813f, 
    0.05054805f, -0.08162178f, 0.00211846f, -0.01590372f, 0.05779044f, 0.03071184f, 0.27744800f, -0.00151788f, 
    0.01795615f, -0.02452403f, -0.09577227f, -0.01852359f, -0.05060976f, 0.01524316f, 0.03671488f, -0.01168830f, 
    0.01016653f, -0.00246366f, -0.02163527f, 0.03512369f, 0.06419630f, -0.00639907f, -0.02306795f, -0.05364822f, 
    -0.02118367f, -0.07394300f, 0.00903408f, -0.05804460f, -0.03076316f, 0.02344846f, 0.02877219f, 0.04745836f, 
    -0.03407755f, 0.00765498f, 0.02581583f, 0.06160560f, 0.05753453f, -0.00466995f, -0.07219545f, -0.02691918f, 
    -0.01649721f, 0.00140963f, 0.01936051f, -0.01819149f, -0.00435322f, 0.00222252f, -0.01863934f, -0.04557804f, 
    0.05333543f, -0.03224071f, -0.05790111f, -0.02716454f, -0.02391467f, -0.04895138f, 0.02558684f, 0.03632380f, 
    -0.06909566f, -0.01742620f, -0.02501891f, -0.00122898f, -0.03067923f, 0.05814192f, -0.06251331f, 0.05189347f, 
    -0.07190812f, -0.00712188f, -0.03560536f, -0.06666293f, -0.06505549f, -0.06311864f, -0.06804521f, -0.00952917f, 
    0.01252059f, 0.04466360f, -0.00153547f, 0.05058816f, 0.02425726f, 0.01978504f, -0.04070555f, 0.02566995f, 
    -0.00493028f, 0.04882041f, -0.05473817f, -0.01758370f, 0.01650803f, 0.00367843f, -0.03836125f, -0.02745973f, 
    0.05655473f, 0.01265982f, 0.00561418f, -0.05258111f, 0.06515519f, -0.01791497f, -0.06351516f, -0.04646413f, 
    -0.07575554f, -0.06549817f, 0.02559758f, -0.01848612f, -0.02638741f, -0.01145002f, 0.06907908f, -0.05787687f, 
    0.01740287f, -0.05846624f, 0.06178776f, -0.00128692f, -0.07114033f, -0.02256598f, 0.00228938f, 0.02084365f, 
    0.01996411f, -0.05385426f, 0.05157520f, 0.01079117f, 0.04082114f, -0.05834967f, 0.00385843f, -0.04918997f, 
    -0.04400155f, -0.04640281f, -0.01581853f, -0.06192515f, 0.02764266f, -0.04130500f, -0.01736236f, -0.05440703f, 
    0.03277966f, -0.05131679f, -0.01607061f, 0.05260238f, -0.07071394f, 0.02177679f, -0.06789891f, 0.04562383f, 
    -0.05617353f, -0.01109679f, 0.03760564f, -0.06567356f, 0.05187568f, -0.04104098f, 0.01517199f, -0.07090715f, 
    -0.04982841f, -0.01642594f, -0.04713302f, -0.02093689f, 0.01873600f, -0.05858193f, 0.05302170f, -0.06129687f, 
    -0.05397114f, 0.05894068f, 0.05487635f, 0.01998242f, -0.00904581f, -0.00424497f, -0.00892600f, -0.02704580f, 
    0.02179922f, 0.05361555f, -0.01755643f, -0.00914144f, 0.03241739f, -0.06527665f, 0.01966660f, 0.06543677f, 
    -0.00811063f, -0.02691045f, -0.05626477f, 0.02126315f, 0.04613731f, 0.03713061f, -0.00493019f, 0.03757380f, 
    0.03478265f, 0.00537695f, 0.00189055f, 0.00321044f, 0.06151164f, 0.03273101f, -0.03865730f, -0.03494541f, 
    -0.01464381f, 0.00428021f, -0.04630387f, -0.01493090f, 0.00497119f, -0.01720097f, -0.02427707f, 0.02335178f, 
    0.05323275f, 0.02771338f, -0.06262036f, -0.05867486f, -0.02406946f, -0.07032223f, -0.07298320f, -0.02325131f, 
    -0.07311174f, 0.04067722f, -0.04255774f, -0.06293395f, 0.00758449f, -0.05889823f, -0.06164378f, -0.06369776f, 
    -0.03332791f, -0.04363351f, -0.01445217f, -0.08079230f, -0.03193124f, -0.00169506f, -0.01740626f, 0.06547476f, 
    -0.01217542f, -0.04129998f, 0.02366022f, -0.04507570f, -0.05813929f, 0.03153739f, -0.02404777f, -0.05731678f, 
    0.01381680f, -0.06445562f, 0.04994472f, -0.05065099f, 0.02972244f, 0.02089143f, 0.04022536f, -0.05598374f, 
    0.01165304f, 0.04810345f, 0.05352676f, -0.07580291f, 0.02161713f, 0.01418976f, 0.02455081f, 0.02588107f, 
    -0.08184694f, 0.06153252f, 0.03530392f, 0.02854666f, -0.05222370f, -0.05064172f, -0.03061431f, -0.07803956f, 
    -0.04474162f, -0.07034717f, 0.01387762f, 0.06109003f, -0.00404250f, -0.01290746f, -0.00184362f, -0.02025076f, 
    -0.05625071f, -0.01820160f, -0.03943768f, 0.01865827f, 0.03475092f, -0.01680267f, 0.02512230f, -0.02086258f, 
    -0.00288333f, -0.02095743f, -0.00671243f, -0.02276083f, 0.03389206f, -0.00130989f, 0.00275273f, 0.05099211f, 
    0.02744306f, -0.01246241f, 0.04129356f, -0.04593898f, -0.00907160f, -0.07488015f, 0.04834968f, -0.07330862f, 
    0.04264650f, -0.04905271f, -0.06292322f, 0.05199385f, -0.06613293f, 0.04525570f, 0.00985144f, 0.04284552f, 
    -0.05595731f, 0.05390885f, 0.01531318f, 0.03449243f, -0.04318770f, 0.02534305f, 0.02406324f, -0.00915380f, 
    0.03852236f, -0.00148347f, -0.05214730f, 0.01854273f, -0.00804641f, -0.06701916f, 0.05952389f, -0.05655953f, 
    -0.04602782f, 0.00305957f, 0.00770142f, -0.07563982f, -0.08004953f, 0.01083230f, -0.01957781f, -0.05240211f, 
    -0.06716993f, -0.05501391f, 0.06217036f, -0.04847249f, 0.04784104f, -0.00612304f, -0.05022643f, 0.05713908f, 
    0.03002808f, -0.03834086f, -0.07186966f, 0.02710203f, 0.00874302f, -0.02487062f, -0.01364992f, -0.00585825f, 
    0.02822967f, -0.02625514f, -0.02558414f, 0.05672618f, -0.02933415f, -0.00338795f, -0.07860341f, 0.02361974f, 
    0.02304408f, 0.04884395f, -0.03402574f, 0.01433923f, -0.06485058f, -0.05129941f, -0.00323375f, 0.03524115f, 
    0.03961167f, -0.00227628f, -0.03737783f, -0.05554069f, -0.04598490f, -0.03629434f, -0.05798090f, -0.00614145f, 
    0.01857389f, 0.03975710f, -0.02463142f, 0.06209857f, 0.01975160f, -0.03063041f, -0.02164154f, -0.06413735f, 
    0.02641054f, -0.04660598f, 0.05551482f, -0.03568105f, -0.03413058f, 0.04783936f, 0.00581636f, -0.06500342f, 
    -0.03222638f, -0.00818105f, -0.02252634f, -0.04117180f, 0.05434652f, -0.04012065f, 0.02363103f, -0.03520156f, 
    -0.03751377f, -0.04120547f, -0.02288483f, -0.08003390f, -0.04223876f, 0.02792176f, 0.02892370f, -0.05336944f, 
    0.03885886f, -0.00707668f, 0.04954593f, -0.01492243f, -0.07485494f, -0.04070204f, 0.01887614f, -0.04105996f, 
    0.03034011f, 0.04899687f, -0.01229284f, -0.05963643f, -0.04621371f, -0.00968697f, 0.05163174f, 0.01714488f, 
    -0.07401022f, 0.37497246f, -0.21236999f, 0.27761686f, 0.02112714f, -0.03303888f, -0.02607980f, 0.05532712f, 
    0.05227930f, 0.14715230f, -0.02799377f, 0.08626090f, -0.17059574f, -0.20698532f, 0.31404188f, 0.01482504f, 
    0.00785322f, 0.01878530f, 0.04315805f, 0.11293012f, -0.10887203f, 0.03005789f, -0.00144349f, 0.04069621f, 
    0.01556015f, 0.21990061f, -0.09274022f, 0.21659371f, -0.02584662f, 0.07262319f, -0.03853688f, 0.12289814f, 
    0.12936002f, 0.10190628f, -0.06278875f, -0.09554184f, -0.10755663f, 0.10064588f, -0.04981992f, -0.01879140f, 
    -0.00569292f, -0.07532874f, 0.05213348f, 0.15287128f, 0.08551816f, -0.02937482f, -0.01430856f, 0.04224383f, 
    -0.18478416f, -0.01456319f, -0.04173651f, -0.15172309f, -0.05633993f, -0.03806503f, -0.00695663f, 0.08618159f, 
    -0.04697571f, -0.03188658f, 0.07190643f, 0.11817014f, -0.33983126f, 0.13992910f, 0.20276484f, -0.34195516f, 
    0.03013522f, -0.05041997f, 0.09595892f, 0.00645804f, -0.04664807f, 0.06335374f, 0.06084736f, -0.01081069f, 
    -0.23452730f, 0.06145220f, 0.05864310f, -0.03949826f, 0.09052325f, -0.11859726f, 0.02863529f, 0.00097927f, 
    0.04480884f, -0.00420892f, 0.02070873f, -0.02120592f, 0.18606833f, 0.25289148f, -0.09655730f, -0.17702267f, 
    0.04594990f, 0.01945628f, 0.05102744f, 0.02194301f, 0.03579281f, 0.04873050f, 0.15559542f, -0.00863496f, 
    0.02142973f, -0.21502201f, 0.15221936f, 0.12014326f, -0.01260941f, -0.01562680f, 0.04346857f, -0.06268581f, 
    0.08145231f, 0.02926614f, 0.10664319f, -0.03811849f, -0.16900977f, -0.02158752f, 0.25537434f, -0.12733497f, 
    -0.00901844f, 0.07667930f, -0.06638853f, -0.00556831f, 0.08410071f, -0.10906889f, 0.09797553f, 0.03501811f, 
    -0.16958557f, -0.00891958f, -0.03150541f, 0.14860353f, -0.08885601f, 0.00087050f, -0.04698665f, 0.06878591f, 
    0.10300861f, -0.04350838f, -0.02528559f, -0.04174193f, 0.03563610f, 0.06278980f, -0.01220219f, 0.21941596f, 
    -0.06470336f, -0.04929848f, -0.00446175f, 0.07923406f, 0.09756534f, -0.00676506f, 0.07426816f, 0.05278589f, 
    0.01874772f, -0.07674954f, -0.01904894f, -0.00175089f, 0.00846846f, 0.11799215f, -0.03413559f, 0.22755553f, 
    0.09471902f, 0.11122060f, -0.15557919f, 0.10499660f, -0.16023016f, 0.17741035f, 0.05856777f, -0.20790741f, 
    -0.00772219f, 0.00765708f, 0.20452298f, 0.03442901f, -0.01936828f, -0.06546912f, 0.02352544f, -0.15139000f, 
    -0.14466409f, -0.13559292f, 0.25433743f, -0.16059576f, 0.13185778f, 0.00356101f, -0.03191462f, -0.16025208f, 
    0.09340344f, -0.00605238f, -0.08718909f, -0.01911245f, -0.26984408f, 0.16249342f, -0.00352416f, -0.08279991f, 
    0.02685500f, 0.00663648f, 0.00955556f, 0.00420673f, 0.04015852f, 0.09309410f, 0.01863067f, -0.08097619f, 
    -0.06511455f, -0.29376790f, 0.10267276f, -0.20821342f, -0.02023099f, 0.04857694f, -0.04532753f, -0.05337641f, 
    0.01620560f, -0.06035006f, 0.08301888f, -0.03296432f, 0.19735239f, 0.08117584f, -0.18188205f, -0.02441949f, 
    -0.09528198f, -0.01934959f, 0.05923207f, -0.14702985f, 0.23138796f, -0.05193070f, -0.00942693f, -0.08809158f, 
    0.09124592f, -0.25848415f, 0.05099354f, -0.29058841f, 0.03430188f, -0.22130029f, 0.02053696f, -0.00492287f, 
    -0.04735422f, -0.04164575f, 0.06639387f, 0.18461283f, 0.16647348f, -0.11487114f, 0.00129923f, 0.02271980f, 
    -0.06010826f, 0.10389962f, 0.15260439f, -0.01328512f, -0.05746896f, 0.15189356f, 0.16027650f, 0.03151334f, 
    -0.36868981f, 0.07117378f, -0.02337282f, 0.18868184f, 0.13254498f, 0.16508268f, -0.04605678f, -0.04319536f, 
    0.13966069f, 0.06018970f, 0.04847533f, -0.04490690f, 0.13319880f, 0.07036601f, -0.17646496f, 0.31254181f, 
    -0.02455886f, 0.00336661f, -0.02775006f, 0.02344934f, 0.07546054f, 0.01148958f, 0.02038572f, -0.00158522f, 
    0.25351083f, 0.18019135f, 0.13127953f, 0.07634898f, -0.03216420f, 0.05531379f, 0.10688707f, -0.00534139f, 
    0.11520644f, 0.03626880f, -0.00179563f, -0.14109299f, -0.06715517f, -0.04156461f, 0.16685028f, 0.29152471f, 
    -0.09747686f, 0.05977078f, 0.01945406f, 0.07980777f, 0.17101783f, 0.04098205f, -0.03362519f, 0.03626898f, 
    -0.04218279f, 0.18001825f, -0.11123404f, -0.05419274f, 0.04193570f, 0.07803856f, -0.08814973f, 0.06651775f, 
    -0.01212498f, 0.04569102f, 0.09787730f, 0.12943217f, -0.08400562f, -0.06693508f, -0.23986749f, 0.16284028f, 
    -0.07790830f, -0.02485510f, 0.13371104f, 0.16013592f, 0.15848784f, 0.13123645f, 0.07069860f, -0.10100734f, 
    0.12622009f, -0.02444980f, 0.00118389f, -0.21526237f, 0.00916695f, -0.01302365f, 0.15725331f, -0.08460091f, 
    -0.05661816f, -0.00865186f, -0.15726669f, -0.01550700f, -0.26498449f, -0.18474472f, 0.05818404f, -0.09982986f, 
    -0.02146762f, 0.06402994f, -0.06498086f, 0.02641650f, -0.04063535f, -0.04293588f, 0.10260406f, 0.06771421f, 
    -0.02683552f, -0.04281142f, -0.04704805f, -0.17598613f, 0.01019590f, 0.11969243f, -0.00430236f, -0.15895495f, 
    -0.04942132f, 0.07455751f, 0.12830880f, 0.06508495f, 0.24431019f, -0.03554761f, -0.07440390f, 0.35088852f, 
    0.03091832f, 0.00586342f, -0.08130790f, 0.02020934f, 0.08263229f, 0.13636532f, 0.13324575f, 0.11324897f, 
    -0.13120376f, -0.01553619f, 0.08807231f, 0.12437616f, 0.03149190f, -0.02949120f, -0.06464420f, 0.14836213f, 
    -0.04160204f, 0.12451395f, 0.16944540f, 0.09905237f, 0.28705981f, -0.12844896f, -0.06378923f, 0.20551129f, 
    -0.02726823f, 0.00607464f, -0.07784210f, 0.05064471f, -0.00599909f, -0.04671497f, 0.02374594f, -0.01885206f, 
    -0.00596943f, -0.16505411f, 0.07439707f, -0.21207242f, 0.15116514f, -0.03554527f, -0.16345899f, -0.02731217f, 
    -0.13485406f, 0.02142462f, 0.02345071f, -0.15898773f, 0.17683461f, -0.05071439f, -0.17693321f, -0.05159633f, 
    -0.08229043f, -0.07261297f, -0.06150927f, -0.09736257f, 0.18889789f, -0.18745145f, -0.08006261f, 0.14533551f, 
    0.16844922f, -0.29517648f, -0.14774317f, -0.15350033f, 0.01471601f, -0.18563884f, 0.00792250f, 0.12632193f, 
    0.02176398f, 0.03572451f, -0.06445344f, 0.18690120f, 0.24157339f, -0.04406112f, -0.20086081f, 0.07712426f, 
    -0.15033472f, 0.00020322f, 0.03273208f, -0.08200328f, 0.00967246f, 0.09353136f, 0.11457229f, -0.09525502f, 
    -0.23035021f, -0.02161161f, -0.21830027f, 0.15049486f, 0.12999713f, 0.05405048f, 0.07799816f, -0.01505522f, 
    0.09609188f, -0.03498419f, 0.10927804f, 0.01733644f, 0.05750376f, 0.05191205f, -0.09155979f, -0.00171388f, 
    -0.03228857f, -0.08498987f, -0.01703259f, -0.01398798f, -0.04188802f, 0.07987939f, 0.06235419f, -0.07440051f, 
    0.24371028f, 0.13977925f, 0.15253317f, 0.08334178f, 0.01012412f, 0.03664174f, -0.00649359f, 0.14052334f, 
    0.11176988f, -0.12288812f, 0.19457115f, -0.03859808f, -0.00794629f, 0.14867572f, -0.13998593f, 0.08412190f, 
    0.05442414f, 0.00627791f, 0.13777384f, -0.01073870f, 0.11488171f, 0.10324250f, -0.07289084f, 0.16416448f, 
    -0.11651118f, -0.12165843f, -0.02347941f, -0.11016647f, 0.15390199f, 0.09299129f, 0.03570545f, -0.04352815f, 
    -0.12976706f, -0.08373546f, 0.05288105f, 0.13872476f, 0.04176349f, 0.08939450f, -0.01994765f, 0.10118758f, 
    -0.01991308f, -0.13819793f, 0.01011851f, 0.38953495f, 0.26940030f, -0.05189664f, 0.08438049f, 0.03863629f, 
    0.37113744f, -0.21375209f, -0.17546357f, -0.14562076f, -0.02828494f, -0.10913248f, 0.01204187f, -0.02909998f, 
    0.07559387f, -0.01756721f, -0.14604461f, -0.17038348f, -0.32503384f, -0.15221587f, -0.05371603f, 0.09712601f, 
    0.01645084f, 0.15766662f, -0.06998017f, -0.04223067f, 0.04366154f, 0.07244071f, 0.02697045f, 0.07219245f, 
    0.11475471f, -0.05145787f, -0.07644328f, -0.14649571f, -0.06007300f, 0.02025310f, -0.05258339f, 0.05601836f, 
    -0.07889234f, 0.12395381f, 0.10620120f, 0.10971781f, 0.16029806f, -0.11134396f, 0.03421822f, 0.03585688f, 
    0.15250058f, -0.08186955f, 0.11980373f, 0.07555729f, 0.07350798f, 0.04098106f, 0.04091791f, 0.09668967f, 
    -0.07082524f, 0.00064743f, -0.01579107f, 0.05503471f, 0.04735973f, -0.06877758f, 0.12684119f, 0.16223072f, 
    0.09189215f, 0.08552144f, 0.10114446f, 0.15763262f, 0.20845821f, -0.06298560f, -0.15375020f, 0.15827157f, 
    0.07338528f, 0.12462483f, 0.02863533f, -0.01454329f, -0.00092740f, -0.03166818f, -0.01951825f, -0.09527101f, 
    -0.03717695f, 0.04062337f, -0.02520401f, 0.01148610f, -0.02947512f, 0.02240677f, 0.03444813f, 0.03788300f, 
    -0.03228474f, 0.01949959f, -0.03617591f, -0.00992621f, 0.03922427f, -0.04453764f, 0.00892337f, -0.07525542f, 
    -0.05274085f, 0.02982832f, -0.05288520f, -0.06133134f, 0.01642445f, -0.04331731f, -0.07246500f, -0.02683094f, 
    -0.01047056f, -0.01658020f, -0.01459202f, 0.06147633f, -0.06369395f, 0.02441115f, -0.04131848f, 0.02536977f, 
    -0.06065885f, -0.04538430f, -0.05863962f, -0.01035437f, -0.07512572f, -0.01203203f, 0.03739901f, 0.04423251f, 
    -0.01114514f, -0.05925990f, -0.03430191f, -0.00423382f, -0.05895571f, -0.06296848f, -0.04607740f, 0.01853598f, 
    -0.02744261f, -0.00148201f, 0.03446727f, 0.02429326f, 0.04678072f, 0.00373258f, -0.01380530f, -0.00834372f, 
    0.05549270f, -0.05672174f, 0.05555341f, -0.04042032f, 0.04309409f, -0.02172689f, -0.03130758f, -0.03196351f, 
    0.02292758f, -0.04674501f, 0.02192144f, -0.08074059f, -0.02137374f, 0.00206684f, -0.02547032f, 0.02662878f, 
    -0.00116882f, -0.00736073f, 0.04684946f, -0.05298829f, -0.03385973f, -0.02202492f, -0.04584906f, -0.00906824f, 
    0.04203493f, 0.01709239f, -0.01686409f, 0.01461886f, -0.06831301f, -0.06549292f, -0.04846923f, 0.03406803f, 
    0.02136805f, -0.04955649f, 0.05023805f, 0.03533589f, 0.00962135f, -0.01516607f, 0.04973533f, -0.01573416f, 
    -0.06649579f, 0.01054341f, -0.03584790f, 0.00414030f, -0.02550292f, 0.03612533f, 0.03071800f, -0.03470904f, 
    0.02339512f, 0.05730798f, -0.00272770f, -0.07613555f, -0.03546224f, 0.00171189f, 0.02780041f, 0.01146514f, 
    -0.00744551f, 0.00132803f, 0.06688718f, -0.07437729f, -0.01002651f, -0.00360494f, 0.06429666f, -0.04470033f, 
    -0.00627238f, 0.02704457f, 0.04710766f, 0.03095846f, 0.04341284f, 0.01315491f, 0.05728443f, -0.04172530f, 
    0.03453557f, -0.07005443f, -0.06600016f, -0.00658992f, -0.04919997f, -0.02690778f, 0.02193963f, 0.04511299f, 
    0.01766536f, 0.02951176f, -0.07029281f, -0.02097006f, 0.04097913f, 0.06039043f, 0.03924783f, 0.03487530f, 
    -0.06413116f, 0.03329676f, -0.06821804f, -0.01924367f, -0.02719637f, 0.00217242f, 0.06360120f, 0.00114101f, 
    -0.05440757f, -0.04744323f, -0.03294889f, -0.06631190f, -0.03739308f, -0.04848885f, -0.03178035f, -0.00183157f, 
    -0.06358828f, -0.01068653f, 0.00066453f, 0.05208036f, 0.03767609f, -0.01041734f, 0.05847847f, -0.05777730f, 
    0.04908559f, 0.02460859f, -0.04925317f, -0.02083108f, -0.06280230f, -0.05549190f, -0.00001799f, -0.06185924f, 
    -0.01386377f, -0.01988963f, -0.00466239f, -0.05006653f, -0.02206301f, 0.05469744f, -0.02724200f, -0.02975619f, 
    -0.06553993f, 0.03959766f, -0.00004154f, 0.06241301f, -0.02677448f, -0.01872966f, -0.05726273f, -0.04879948f, 
    0.16005060f, -0.34251598f, 0.15301631f, -0.12041231f, 0.09068255f, -0.06263918f, -0.03638896f, -0.07788620f, 
    0.04511154f, -0.09241199f, 0.11895757f, -0.01521865f, 0.26051518f, 0.08750109f, -0.03338742f, -0.22308336f, 
    -0.09045605f, -0.12603997f, -0.03194993f, 0.04887725f, 0.01692735f, 0.01211187f, 0.01621784f, -0.01919433f, 
    0.02555359f, -0.18231367f, 0.00665336f, -0.01489799f, 0.11787960f, -0.10974269f, 0.07296713f, 0.10903956f, 
    -0.06323598f, -0.04345497f, -0.07600565f, 0.03888032f, 0.27461767f, -0.08953090f, 0.05225123f, 0.05551344f, 
    -0.12436605f, -0.06954571f, 0.05497590f, -0.08424779f, 0.04749511f, 0.03987537f, 0.10880133f, 0.00337478f, 
    0.12901860f, 0.07174914f, -0.08571251f, -0.16177377f, 0.02452017f, 0.08618803f, -0.02482366f, -0.06697010f, 
    0.05710843f, 0.02731245f, 0.12412973f, 0.00739282f, 0.10297792f, -0.08077789f, -0.19620819f, 0.05675882f, 
    -0.10626820f, -0.00734325f, 0.01141003f, 0.06478873f, 0.06019395f, -0.03395858f, -0.03532021f, 0.05911392f, 
    0.10237261f, 0.01903589f, 0.04771990f, 0.08278765f, -0.13544856f, 0.08181428f, -0.06546516f, -0.01830290f, 
    0.08189101f, 0.04035175f, -0.00641791f, 0.00860459f, -0.24812409f, -0.13537820f, 0.11412577f, 0.08778486f, 
    0.00369731f, 0.14332651f, -0.12173494f, -0.02754663f, 0.06751519f, 0.07772136f, 0.01058296f, 0.07642078f, 
    0.20313519f, 0.13600737f, -0.35280752f, 0.01982275f, 0.28514355f, 0.07167618f, -0.07936248f, 0.05675215f, 
    -0.07525513f, -0.01508219f, 0.09573791f, 0.07254494f, 0.23522024f, 0.04704850f, 0.04668947f, -0.04214721f, 
    -0.07611971f, -0.00250888f, 0.16374113f, 0.14355440f, 0.10287940f, 0.08680876f, 0.00981731f, 0.01423131f, 
    0.29948890f, -0.14722741f, 0.04604232f, -0.08061219f, 0.00475719f, -0.01706242f, 0.09253608f, -0.01362959f, 
    0.04484239f, -0.06369141f, -0.03783303f, -0.01177684f, -0.14648986f, -0.18703945f, -0.17578755f, 0.02105235f, 
    0.07020035f, 0.08848926f, -0.03339402f, 0.05153582f, -0.01619214f, -0.00889644f, 0.15706435f, 0.13790885f, 
    -0.10368500f, 0.05229409f, -0.04274995f, -0.07709059f, -0.15972424f, 0.00758940f, 0.09326053f, -0.11614795f, 
    0.06346166f, -0.03057994f, 0.02579150f, -0.04531626f, 0.10174543f, -0.07924484f, -0.05012482f, 0.05684388f, 
    0.11844466f, 0.00972693f, -0.16495350f, 0.02812005f, 0.04627310f, 0.04915955f, -0.01781913f, 0.12140691f, 
    0.19237779f, 0.34323281f, -0.18493657f, -0.06224074f, 0.00652399f, 0.10293269f, -0.08404705f, 0.03165241f, 
    -0.05364084f, -0.01815592f, 0.03969433f, 0.15348260f, 0.30525011f, -0.17492193f, -0.04628035f, 0.20781429f, 
    0.03474021f, -0.04492068f, 0.07727277f, -0.07613145f, 0.03219279f, -0.05289064f, 0.14847702f, 0.05275587f, 
    -0.08277671f, -0.11170577f, 0.00375693f, -0.00510471f, -0.13672489f, -0.14833476f, 0.11223063f, -0.02844001f, 
    0.05819811f, 0.04647737f, 0.21322185f, -0.03150587f, -0.01095183f, -0.01080826f, 0.11167505f, 0.18730833f, 
    -0.09264751f, 0.15428957f, 0.00189147f, 0.00020017f, 0.01913966f, 0.01668834f, -0.02291062f, 0.02097498f, 
    -0.13410845f, -0.02365405f, -0.08612352f, -0.02670057f, -0.05688403f, -0.09766892f, 0.06845990f, 0.11510440f, 
    -0.03340722f, -0.13479789f, 0.00444733f, -0.09231219f, 0.09341897f, 0.08319148f, -0.09700750f, -0.09241974f, 
    -0.05546129f, -0.00939498f, -0.04376262f, 0.01518486f, -0.01237735f, 0.05355733f, 0.08997350f, 0.06946570f, 
    -0.01362210f, -0.04480064f, -0.24056427f, 0.06814875f, -0.11088772f, 0.11663004f, -0.17189381f, 0.18944752f, 
    0.03570342f, 0.14989762f, 0.11945012f, 0.09657308f, 0.38710591f, 0.01728767f, -0.06052632f, -0.05939060f, 
    0.07293453f, -0.09297223f, 0.08660852f, -0.02850641f, 0.04618618f, 0.00421133f, -0.06991309f, 0.00781470f, 
    0.12862313f, -0.05636450f, 0.03359637f, -0.10732202f, 0.00225872f, 0.00482812f, 0.18348692f, 0.03178093f, 
    0.07583684f, -0.00724876f, -0.09275647f, -0.01653995f, -0.16826387f, 0.35364786f, 0.22855811f, 0.05300178f, 
    -0.03400773f, -0.04460786f, 0.02986474f, -0.09150098f, -0.02226876f, 0.02589831f, 0.01161093f, 0.04030307f, 
    -0.08682472f, -0.25621819f, 0.01088089f, 0.30155015f, 0.12317251f, 0.07398047f, 0.00886201f, -0.03960744f, 
    -0.09962697f, 0.05315531f, 0.10772800f, 0.09610689f, 0.01398209f, -0.03018246f, -0.15319476f, -0.06562316f, 
    0.03728741f, 0.05598260f, 0.05543295f, 0.08444970f, 0.09904292f, -0.00442197f, -0.00188058f, 0.05884978f, 
    -0.28901756f, 0.04667492f, 0.18567930f, 0.00435301f, -0.06513450f, -0.09470455f, 0.13536343f, -0.06171827f, 
    0.03036364f, -0.01718351f, -0.05641823f, 0.06199276f, -0.27263308f, -0.20305990f, 0.13425867f, 0.25864872f, 
    0.01076595f, 0.09805983f, -0.01582698f, 0.00856995f, 0.02258046f, 0.01047625f, 0.13364787f, 0.01060841f, 
    0.07566731f, 0.15520427f, 0.20750809f, -0.02808160f, -0.04789248f, -0.10040502f, -0.02180868f, 0.11293455f, 
    0.06278955f, 0.16207181f, 0.01896130f, 0.15882730f, 0.35557425f, 0.03536432f, -0.34218431f, 0.16271916f, 
    -0.05089581f, -0.01049676f, -0.04276102f, 0.08766527f, 0.05333835f, 0.02669622f, 0.13773659f, 0.00202604f, 
    0.02918784f, 0.06284131f, -0.11592640f, -0.12201072f, 0.00381133f, 0.12491740f, 0.03891666f, 0.02425216f, 
    0.11727129f, 0.12454262f, 0.00791068f, 0.11702944f, -0.29556856f, 0.10331824f, -0.10033024f, 0.08293301f, 
    0.03423566f, -0.00805388f, 0.01234795f, -0.00423214f, 0.01788212f, 0.03437578f, -0.00851792f, 0.02238563f, 
    0.06466165f, -0.23398584f, 0.02528979f, -0.01973890f, -0.23289569f, 0.10066771f, 0.09342277f, 0.09697269f, 
    0.11389039f, 0.16705124f, -0.02393598f, 0.09853401f, 0.23510553f, 0.20244184f, 0.17370956f, 0.16470650f, 
    -0.00328832f, 0.00113892f, 0.00937729f, 0.11508048f, -0.13674569f, 0.05166117f, 0.04527669f, -0.04387483f, 
    -0.16968165f, 0.05484609f, 0.20095780f, 0.06386317f, -0.01251119f, 0.06088453f, 0.01154162f, 0.02169080f, 
    -0.05815525f, 0.09486386f, -0.01768052f, 0.10793547f, -0.18358740f, 0.03278035f, 0.17976245f, 0.31656134f, 
    -0.02405259f, 0.15954086f, -0.07109336f, 0.00685883f, -0.09407115f, -0.10635747f, -0.13817149f, -0.00282569f, 
    0.17957945f, -0.06357127f, 0.04830645f, -0.10730903f, 0.14851996f, -0.04830080f, 0.07750696f, 0.02563054f, 
    0.02635004f, -0.10335441f, 0.02414803f, -0.18440242f, 0.08953013f, -0.14027987f, -0.02587266f, 0.17374337f, 
    -0.02420227f, 0.05580885f, -0.08415841f, 0.03870694f, -0.02649697f, 0.05041293f, 0.03096730f, -0.01097587f, 
    0.00877360f, -0.03729424f, -0.07075617f, 0.28160307f, 0.02937370f, 0.07590009f, -0.12607597f, -0.04695717f, 
    -0.08250554f, -0.03977598f, 0.01865034f, 0.08381653f, 0.08760118f, -0.35641140f, -0.01081601f, 0.10535592f, 
    0.00693430f, 0.03728483f, -0.03129540f, 0.02383826f, -0.18405481f, -0.04014331f, 0.08785235f, 0.21497965f, 
    -0.35843739f, -0.00620392f, -0.11311626f, -0.25202820f, 0.07724749f, -0.24383751f, -0.13277131f, -0.04906785f, 
    0.01705913f, -0.03052995f, 0.06820969f, -0.16546063f, 0.25418079f, 0.12822428f, -0.16115206f, 0.11388222f, 
    0.23151273f, -0.00385841f, -0.10340337f, -0.11607001f, -0.27308387f, -0.07448202f, -0.01592402f, -0.00834726f, 
    0.25899431f, 0.10717598f, 0.15046963f, 0.28765637f, 0.12955648f, 0.03203755f, 0.00383858f, 0.30786130f, 
    -0.12837240f, 0.03576294f, 0.15834627f, 0.03968995f, 0.16404058f, -0.02110320f, -0.11122153f, -0.24909297f, 
    0.11000433f, -0.12754065f, 0.02736461f, -0.08358559f, -0.08488175f, 0.00012533f, -0.09039723f, 0.01567870f, 
    0.10205608f, 0.11981886f, 0.09493094f, 0.18771198f, -0.05563318f, 0.00780675f, 0.13234110f, -0.14738201f, 
    -0.21266544f, -0.01024040f, 0.00923338f, 0.01093117f, -0.24062346f, 0.08433954f, 0.04196525f, -0.07479778f, 
    0.06317687f, -0.12657879f, -0.11823040f, -0.02964482f, -0.13890342f, 0.11685468f, -0.03278048f, -0.06269999f, 
    -0.00560680f, -0.05273929f, -0.16329610f, 0.09627118f, 0.02716218f, -0.12006889f, -0.05621729f, -0.01972359f, 
    -0.12366957f, -0.01982111f, -0.02294346f, 0.13150167f, 0.14563119f, 0.06662054f, 0.11228991f, -0.01627112f, 
    -0.16470140f, 0.00550083f, 0.01484883f, 0.12643978f, -0.09257127f, 0.17371912f, 0.08885395f, 0.07663520f, 
    -0.04445736f, -0.06733736f, 0.03413965f, 0.01379629f, -0.02245224f, -0.06579502f, 0.06249848f, 0.06476899f, 
    0.03068856f, 0.03158707f, -0.00468416f, -0.03827450f, 0.03122468f, -0.04402249f, 0.06055009f, -0.02344739f, 
    -0.00370882f, 0.03127366f, 0.02366825f, 0.02553761f, 0.03966310f, -0.05701209f, 0.00749885f, 0.03705908f, 
    -0.03455773f, -0.01586682f, -0.07067509f, -0.06360192f, -0.07624573f, 0.03712573f, -0.05713888f, 0.03129752f, 
    -0.02213407f, -0.07382631f, 0.01656297f, 0.04653378f, 0.04244425f, 0.03624720f, -0.04536755f, -0.02568774f, 
    -0.07860625f, -0.00431689f, 0.05854440f, 0.01729118f, 0.01975925f, -0.06136242f, -0.03515042f, 0.03229186f, 
    -0.07105821f, -0.03698516f, -0.04290809f, 0.05342848f, -0.04475169f, -0.01264874f, -0.06134780f, -0.00981427f, 
    -0.00653541f, -0.01067275f, 0.01339159f, 0.00342303f, 0.04867371f, -0.05051631f, -0.00007738f, 0.01749671f, 
    -0.02460047f, -0.04762850f, -0.05055145f, -0.02175453f, 0.02178695f, -0.03451207f, 0.04316077f, -0.06713992f, 
    0.06030610f, 0.04775822f, -0.06111908f, -0.04399951f, -0.04498638f, -0.05482221f, -0.00335562f, 0.03091832f, 
    -0.00465658f, -0.04235623f, 0.05665484f, 0.01508189f, -0.04099507f, -0.02960941f, -0.01686232f, 0.02031719f, 
    -0.04670886f, 0.00988859f, -0.05745106f, 0.00059239f, -0.03722071f, 0.02415167f, -0.01252985f, -0.01577679f, 
    -0.06401785f, 0.00075721f, 0.05176706f, -0.01260381f, 0.05182672f, -0.01570635f, -0.03617622f, 0.02364085f, 
    -0.05524921f, 0.00481095f, -0.03141286f, -0.01625044f, 0.03904751f, -0.03921393f, -0.02445317f, 0.00246931f, 
    -0.04446731f, 0.01662494f, -0.01308067f, 0.00029865f, 0.05329316f, 0.00197263f, -0.03173053f, -0.00218533f, 
    0.01680027f, 0.03967673f, 0.05754639f, -0.05618655f, -0.04613616f, 0.05803792f, -0.06064532f, 0.04169998f, 
    -0.01929861f, -0.02760738f, 0.04864237f, -0.01929866f, 0.01324907f, 0.04985660f, 0.00483835f, -0.01300087f, 
    -0.01597080f, 0.02544465f, 0.01506497f, -0.05405919f, -0.04489657f, 0.05602017f, -0.06037210f, 0.00309935f, 
    -0.01099468f, 0.05226011f, -0.03006626f, 0.03515790f, -0.03518536f, -0.06013178f, 0.03584561f, 0.04031418f, 
    0.04220568f, 0.02879249f, 0.00482484f, -0.04923622f, -0.07309501f, -0.06297468f, -0.01233186f, -0.04302634f, 
    -0.05909394f, 0.02260352f, -0.06191706f, -0.03030617f, 0.02640565f, -0.04570029f, -0.07786886f, -0.00783684f, 
    -0.05520141f, -0.05729626f, -0.07911187f, -0.00678021f, 0.04032285f, -0.04777608f, 0.02118183f, -0.07996120f, 
    -0.00038249f, -0.03048271f, 0.04016179f, -0.02827678f, 0.01933419f, -0.01129473f, 0.06086124f, 0.04960423f, 
    -0.06359874f, -0.03929314f, 0.02261605f, -0.02111914f, -0.02112495f, -0.07206127f, -0.06521346f, 0.03674537f, 
    -0.10843249f, 0.01043334f, -0.05150625f, 0.06122848f, -0.13022774f, -0.02143310f, 0.13429965f, 0.05563747f, 
    -0.06494795f, 0.01174770f, 0.04535452f, 0.05945597f, -0.10068870f, -0.06079037f, 0.10625195f, 0.17376269f, 
    0.06251887f, 0.12177075f, -0.03510170f, 0.05854263f, -0.06079248f, -0.00948523f, 0.10640720f, 0.06871686f, 
    -0.04031443f, 0.11873283f, 0.03407773f, -0.02025923f, -0.15062213f, -0.02879442f, -0.04512593f, 0.02824596f, 
    0.01107960f, 0.00549653f, 0.14002602f, -0.16236182f, -0.07583281f, 0.07328545f, 0.01550170f, -0.20545471f, 
    0.06308486f, -0.02526687f, 0.06208557f, -0.06789558f, -0.06899403f, -0.01175343f, -0.00737626f, 0.05509924f, 
    -0.06936187f, -0.13939126f, -0.14110845f, 0.05140257f, -0.19632758f, 0.09126548f, -0.05646545f, 0.11713026f, 
    0.02177390f, 0.06549925f, -0.00599393f, 0.00301223f, 0.27820608f, 0.07677156f, 0.15997791f, -0.14284788f, 
    0.06089615f, 0.01643491f, -0.05568095f, 0.10835091f, -0.01835547f, -0.04044145f, -0.07084961f, -0.05376193f, 
    0.10376912f, -0.00003869f, 0.05884081f, -0.10944925f, 0.04008351f, -0.04484644f, 0.08779826f, -0.01560595f, 
    0.00390617f, 0.09573213f, -0.05989059f, 0.07125998f, 0.20149229f, 0.22980919f, 0.17069057f, 0.06613867f, 
    0.01282225f, -0.18656835f, 0.08400566f, 0.01628909f, -0.00125991f, 0.02493789f, 0.07723904f, -0.00278074f, 
    -0.35548943f, -0.09290770f, 0.20662723f, 0.03631496f, -0.13536862f, 0.04939715f, 0.06733877f, -0.06770971f, 
    -0.03183654f, -0.01694504f, -0.08075589f, -0.03645169f, -0.16352071f, 0.15378584f, -0.07654677f, 0.04619591f, 
    0.05335162f, 0.10058980f, -0.07680376f, -0.02537018f, 0.01624383f, -0.11990878f, -0.03546358f, 0.03329213f, 
    -0.40573558f, -0.08016033f, 0.13479763f, 0.20249178f, -0.04230336f, -0.01172667f, 0.02487894f, 0.00346419f, 
    -0.02636768f, 0.10089494f, -0.02961377f, 0.16494665f, 0.01200651f, -0.01107135f, 0.15715089f, 0.16966720f, 
    -0.00473369f, 0.00878010f, 0.01181218f, 0.00229276f, -0.00715146f, -0.01314911f, -0.01274423f, -0.13966379f, 
    0.08440291f, -0.08087538f, 0.12263363f, 0.00825193f, 0.00107131f, -0.20611960f, 0.04246982f, 0.16262861f, 
    0.10071714f, 0.07336291f, -0.04377154f, 0.27074090f, 0.17628160f, 0.26464990f, -0.08910879f, 0.08516756f, 
    -0.05080590f, 0.00919742f, -0.04929256f, 0.03944442f, 0.04789002f, 0.01166875f, 0.05932639f, -0.09873873f, 
    -0.24762362f, -0.29335099f, -0.05589575f, -0.00874939f, 0.03838909f, -0.03694875f, 0.08799885f, -0.12141106f, 
    0.10722645f, 0.08941324f, -0.00954773f, -0.01951707f, -0.15460622f, 0.04217811f, 0.03388090f, -0.09358048f, 
    0.11414967f, 0.05641336f, -0.00915367f, 0.05048312f, 0.05564420f, 0.08173622f, 0.01948833f, 0.13100454f, 
    0.05640838f, -0.04244279f, 0.09284392f, -0.15640377f, 0.12764704f, -0.03207535f, -0.19501299f, -0.03478968f, 
    -0.20934547f, 0.08902310f, 0.03742212f, -0.08743329f, 0.01272018f, 0.08848853f, 0.04333320f, 0.11630119f, 
    0.04400855f, 0.08504027f, -0.06202833f, 0.04904698f, 0.07431935f, -0.09712595f, -0.02101637f, 0.05747722f, 
    0.18690567f, -0.22314383f, -0.00519945f, 0.07646289f, 0.01302916f, -0.12316052f, 0.03413400f, 0.17883821f, 
    0.00654396f, -0.07396434f, -0.06671533f, -0.02824266f, 0.13761368f, -0.10795361f, 0.07847266f, 0.14668036f, 
    -0.20030898f, 0.04293288f, 0.13139167f, -0.03398353f, 0.05230641f, 0.02447022f, 0.10651426f, 0.01102163f, 
    -0.03798356f, -0.02856121f, -0.09674559f, -0.09843303f, 0.22542430f, -0.01465377f, 0.08985364f, -0.05389517f, 
    -0.00533934f, -0.06809521f, 0.22301485f, 0.09056655f, 0.06395377f, 0.00172915f, -0.01525815f, -0.11024168f, 
    -0.00627705f, -0.11232322f, -0.07264784f, -0.02794742f, 0.13854800f, 0.00410292f, 0.08487774f, 0.02634861f, 
    -0.13901301f, 0.19360475f, 0.22896181f, 0.03494676f, -0.04818255f, 0.01289374f, -0.00991700f, 0.00388058f, 
    0.12215130f, 0.01169838f, -0.06113352f, -0.18030962f, 0.30659014f, -0.41169059f, -0.11817242f, 0.23880510f, 
    0.02728050f, -0.03503247f, 0.03257405f, -0.07050461f, 0.02696263f, 0.01209863f, 0.02128415f, 0.12779991f, 
    -0.07257826f, 0.05805368f, -0.23763721f, -0.17204031f, 0.23375103f, -0.00145498f, 0.04572576f, 0.09346528f, 
    -0.11466382f, -0.01858439f, 0.07656282f, 0.15962441f, -0.03935582f, 0.24217629f, -0.06899069f, -0.00041667f, 
    -0.06578308f, -0.17231101f, 0.18280278f, 0.16713494f, 0.25388846f, 0.01943300f, 0.09168115f, 0.09239098f, 
    0.14535464f, -0.03627762f, -0.11424014f, 0.07947857f, -0.04022434f, 0.03325902f, -0.02093530f, -0.01092355f, 
    -0.00268223f, 0.01226871f, -0.09556424f, -0.17110410f, -0.13313580f, -0.07544596f, -0.11756518f, -0.04239082f, 
    0.22282866f, 0.07832885f, -0.15203731f, -0.08610117f, 0.00960077f, -0.01780603f, -0.01483847f, 0.18281136f, 
    0.06974244f, -0.03762605f, -0.00694086f, 0.08733562f, -0.09283133f, 0.00146990f, 0.02490236f, -0.03587656f, 
    0.05878554f, 0.06129859f, 0.03515754f, -0.09533121f, -0.21543066f, 0.21264173f, -0.00274819f, -0.14938606f, 
    0.09666045f, -0.04956615f, 0.11917464f, 0.08262874f, 0.11329835f, 0.00507484f, 0.17431873f, 0.05569607f, 
    -0.15057001f, -0.02461118f, 0.01652330f, -0.01170405f, 0.05940793f, 0.00678750f, -0.04852017f, -0.01193358f, 
    -0.02638365f, 0.09733266f, 0.17084366f, 0.02311470f, 0.14703640f, -0.04635706f, -0.06191112f, -0.10742021f, 
    -0.07664667f, -0.05229158f, 0.00586275f, -0.03202344f, 0.15790498f, -0.04839182f, -0.14537625f, -0.10542341f, 
    -0.03029047f, 0.04134389f, 0.02907687f, 0.06000771f, -0.04177092f, 0.01033847f, -0.06823462f, -0.01834164f, 
    -0.06172358f, 0.01541980f, 0.01852695f, -0.03540399f, 0.06426500f, -0.02457630f, 0.01068156f, -0.00719955f, 
    -0.00056912f, 0.02712999f, 0.03626248f, 0.01309537f, -0.05826233f, -0.05170152f, -0.03343607f, 0.01330549f, 
    -0.05661898f, -0.03910379f, -0.00825330f, 0.04498206f, -0.03852391f, -0.06115075f, -0.00434384f, 0.04144046f, 
    0.03926237f, -0.05821192f, 0.06291221f, 0.03415759f, 0.06237736f, 0.01372909f, -0.02370566f, 0.00538976f, 
    -0.03753200f, -0.06773731f, 0.05829809f, -0.05642597f, -0.05082665f, -0.00315728f, -0.07828441f, 0.01210978f, 
    0.00184214f, -0.01230756f, 0.05549810f, -0.03507666f, -0.03250333f, 0.01040377f, -0.07470117f, 0.06027393f, 
    0.05254638f, 0.03465160f, -0.07445991f, 0.03943117f, 0.05019483f, 0.03155783f, -0.06462528f, 0.02158113f, 
    -0.00572986f, -0.05419783f, -0.03526031f, 0.06800575f, 0.00644185f, -0.08521505f, 0.00686600f, -0.05564009f, 
    0.01602577f, 0.02939478f, 0.04151328f, 0.01820567f, -0.02711472f, -0.06048097f, -0.03957231f, -0.02800527f, 
    -0.05711255f, 0.03349062f, 0.05524780f, -0.02349506f, 0.00231966f, -0.01081446f, -0.05204356f, -0.04182953f, 
    0.02525276f, -0.03818278f, 0.06315418f, 0.06090220f, -0.04792864f, 0.05208292f, 0.03416844f, -0.04093684f, 
    0.05831329f, -0.04770777f, -0.02405242f, 0.04864154f, 0.01194298f, -0.00846421f, 0.05728674f, -0.07373837f, 
    -0.05352826f, -0.05319872f, 0.04482111f, 0.03880093f, 0.06161759f, -0.03589815f, 0.07259518f, -0.05904492f, 
    -0.04156359f, -0.02193351f, -0.01821056f, -0.01786215f, 0.02991266f, 0.01744026f, -0.07948995f, 0.03567151f, 
    0.04629829f, -0.01373144f, 0.04051936f, 0.02677583f, 0.03367093f, 0.00627757f, -0.05409749f, 0.06153785f, 
    0.00326041f, -0.02194583f, -0.05848357f, -0.03259645f, -0.00924294f, -0.02349776f, -0.06537504f, -0.00493596f, 
    0.05717355f, 0.01179776f, -0.04120956f, -0.06266448f, -0.00041512f, -0.04654954f, -0.03409590f, -0.03712010f, 
    -0.01957994f, -0.04958606f, 0.01074043f, 0.06019706f, 0.05382117f, 0.00439857f, -0.06159040f, 0.03270098f, 
    -0.04253579f, 0.02749350f, 0.02992567f, 0.01938145f, -0.01245426f, -0.03182811f, -0.02454155f, -0.07767285f, 
    -0.02383682f, 0.05192938f, 0.01916443f, -0.01616269f, 0.04377124f, 0.02042234f, 0.04472804f, -0.02640930f, 
    0.03718330f, -0.05192238f, 0.06573404f, 0.03694979f, -0.01594904f, -0.02208067f, 0.04633456f, -0.00212706f, 
    -0.07513518f, 0.02100088f, -0.07224158f, 0.04669740f, 0.01853392f, -0.04875221f, -0.06752476f, 0.00402274f, 
    -0.05663377f, 0.04608576f, -0.07951026f, 0.03180259f, -0.02521319f, 0.00569921f, 0.01000940f, -0.07835189f, 
    -0.03791419f, 0.32387194f, -0.14411514f, 0.10365727f, 0.06564969f, 0.01010185f, 0.16612692f, -0.00102367f, 
    0.10909107f, 0.06864776f, -0.08097599f, 0.14409451f, -0.02172052f, 0.15188587f, 0.26699954f, 0.15040697f, 
    0.18361020f, 0.06686335f, 0.03617908f, 0.14211307f, -0.19559260f, 0.07660413f, 0.07555014f, 0.10885916f, 
    0.02376862f, 0.31233737f, 0.08939073f, -0.03609028f, 0.06118944f, 0.14430867f, -0.04253436f, -0.01631925f, 
    0.07133439f, 0.12062130f, 0.15320790f, -0.03304535f, -0.12251307f, 0.02191422f, 0.04113959f, -0.13687474f, 
    -0.03522062f, -0.09565249f, 0.08559220f, 0.09195697f, 0.04388717f, -0.00304504f, 0.00345674f, -0.01675007f, 
    -0.12591787f, -0.02506245f, 0.06607576f, 0.00837027f, -0.12399635f, -0.07237171f, 0.14589375f, 0.08796420f, 
    -0.14766248f, -0.05475190f, 0.06100140f, -0.06212819f, -0.06725775f, 0.10726054f, 0.23748314f, 0.09518912f, 
    0.06344560f, -0.04549614f, -0.11016222f, 0.02666586f, -0.09960657f, 0.00616946f, -0.11881667f, 0.06336689f, 
    -0.05556690f, -0.04387942f, 0.12286390f, 0.02764455f, -0.01463185f, -0.04876472f, 0.02261147f, 0.08094295f, 
    -0.07011233f, 0.13386847f, -0.09707522f, -0.03527843f, 0.34839326f, -0.30937159f, 0.02734918f, 0.24345316f, 
    0.06011349f, -0.03087340f, -0.04081159f, -0.02183794f, -0.04250690f, -0.06629410f, 0.01761702f, -0.08258011f, 
    -0.14273506f, -0.07263142f, 0.13064265f, -0.06851377f, -0.08262414f, 0.00091243f, -0.04413810f, 0.01334537f, 
    0.07440442f, -0.06444506f, -0.09891557f, -0.10350110f, -0.20848066f, 0.10745883f, 0.12147126f, -0.05684512f, 
    -0.03044032f, 0.05663475f, -0.00201348f, -0.13058752f, -0.06857613f, -0.03586387f, -0.01067867f, 0.05596251f, 
    0.07684539f, 0.15911828f, 0.11022805f, 0.23090689f, 0.11357693f, 0.20739596f, -0.03457265f, 0.07741309f, 
    -0.05334989f, 0.01668677f, 0.04619245f, 0.10815560f, 0.04803877f, -0.05062979f, -0.11348226f, -0.04414055f, 
    -0.05767881f, -0.07920938f, -0.03661073f, -0.11888844f, 0.06622831f, -0.01493904f, 0.01481324f, -0.05501350f, 
    0.20822614f, -0.05476487f, 0.03399054f, 0.16928503f, 0.16997147f, -0.08701606f, -0.08110003f, 0.06722102f, 
    0.09467073f, -0.04766457f, -0.04577133f, -0.01521852f, -0.26024988f, 0.37947947f, 0.13267390f, -0.09112211f, 
    -0.12422150f, 0.07303654f, 0.00454924f, -0.04078745f, -0.09553818f, -0.09019205f, 0.00746407f, -0.11393067f, 
    -0.03277631f, -0.24512874f, -0.03239825f, 0.05442676f, -0.02029287f, -0.10646279f, -0.08780907f, -0.10349131f, 
    -0.01674964f, -0.13363716f, -0.09670760f, -0.08888896f, -0.06864671f, 0.34713349f, 0.23683050f, -0.16703816f, 
    -0.03164740f, 0.08660714f, -0.06353732f, 0.11857019f, 0.00189381f, 0.20083816f, 0.10682107f, 0.11737627f, 
    0.04114285f, 0.14460702f, -0.14977820f, -0.10929795f, 0.02152729f, -0.03106829f, 0.01445782f, 0.04484648f, 
    -0.09167399f, 0.08070741f, 0.02114375f, 0.01043199f, 0.13083299f, 0.04805275f, 0.01598246f, 0.15174855f, 
    -0.06344903f, -0.00748995f, -0.08630171f, 0.07754728f, 0.06173645f, 0.09284523f, -0.02997508f, -0.04629463f, 
    -0.12355148f, 0.08213928f, -0.15912092f, -0.08122591f, -0.04746784f, 0.04191092f, -0.06224917f, 0.12080350f, 
    0.08998754f, 0.08003213f, 0.02467792f, -0.06494052f, 0.04184627f, 0.00043102f, -0.12817332f, -0.01162784f, 
    0.00639347f, 0.12696888f, 0.10317991f, 0.13784994f, 0.03344528f, 0.08587290f, -0.02691333f, -0.03585910f, 
    -0.21356520f, -0.23678206f, -0.03484207f, -0.05279201f, -0.03127282f, 0.00877740f, 0.04283149f, 0.03826223f, 
    0.08721099f, 0.03576953f, 0.10459744f, 0.12671240f, 0.00751360f, -0.02893271f, 0.07244607f, 0.04096580f, 
    0.03918190f, -0.10872769f, 0.03446032f, -0.02359096f, -0.02554815f, 0.26016191f, 0.09573422f, 0.02426557f, 
    0.19346566f, 0.16833515f, 0.11679867f, 0.12009579f, 0.01310474f, -0.13321404f, 0.03945841f, 0.01131316f, 
    0.10361497f, -0.16149648f, 0.21514806f, -0.07201160f, -0.04601201f, 0.49938333f, -0.02200216f, -0.18007801f, 
    0.06229138f, 0.02016866f, 0.01605061f, -0.03049754f, -0.00870516f, -0.02518640f, -0.01690356f, -0.11632106f, 
    -0.25606418f, -0.37339038f, 0.01887982f, 0.09380879f, -0.04145224f, 0.05518071f, -0.02067817f, -0.11673427f, 
    -0.02824004f, 0.06583473f, 0.02320017f, -0.02296600f, -0.11800182f, -0.08601134f, -0.01233795f, 0.12292362f, 
    0.00348087f, -0.04463322f, -0.03101086f, 0.15140641f, 0.09605462f, -0.01549727f, 0.03599472f, -0.01411883f, 
    0.09736022f, -0.12511036f, 0.04157548f, 0.06921840f, -0.06528939f, -0.04763849f, -0.02370561f, -0.07585038f, 
    -0.00818710f, -0.00045937f, -0.04706441f, -0.00554932f, -0.28997508f, 0.02373621f, 0.15391837f, 0.13169132f, 
    0.00237389f, 0.03696731f, -0.02738351f, 0.13883102f, 0.01725641f, 0.03761725f, 0.03626070f, 0.09220361f, 
    0.33196554f, 0.12201258f, 0.17203255f, 0.04623737f, 0.01980009f, 0.00489022f, 0.00514580f, 0.23409444f, 
    -0.10720705f, 0.11043993f, -0.00747943f, 0.03348274f, -0.03509094f, -0.23977083f, -0.03421851f, 0.01166717f, 
    -0.04688160f, 0.02293403f, 0.06407919f, 0.09374517f, 0.04493306f, 0.14659421f, 0.04886035f, 0.04770225f, 
    -0.14874208f, -0.23916994f, 0.12117887f, 0.16867818f, -0.03978062f, -0.03146540f, 0.05003684f, 0.07224496f, 
    0.16187778f, 0.03345513f, 0.03784874f, 0.11146738f, -0.29768309f, 0.18818238f, -0.14679244f, -0.02190941f, 
    -0.01978894f, -0.01565802f, -0.06711689f, 0.04362551f, -0.01699850f, -0.14301820f, -0.05348712f, -0.10893503f, 
    0.03455266f, -0.05016492f, -0.00460619f, 0.05610163f, -0.04102532f, 0.02301846f, -0.04191249f, 0.03276670f, 
    -0.03779188f, 0.00445761f, -0.04583279f, -0.06921952f, -0.04599501f, 0.02992232f, -0.01142929f, 0.00770184f, 
    -0.06765667f, -0.06344610f, -0.04748936f, -0.07893388f, -0.01752934f, -0.06337759f, -0.08374414f, 0.03740980f, 
    0.01521069f, -0.05108535f, 0.00873368f, 0.01463656f, 0.00177916f, -0.05066726f, -0.04563267f, 0.04708953f, 
    -0.07527121f, 0.04798942f, 0.01294176f, 0.05613042f, 0.04813660f, 0.01303140f, -0.03868989f, 0.00647670f, 
    0.02364717f, -0.04147311f, -0.04855660f, -0.06618403f, 0.05767423f, 0.05296999f, -0.00604157f, -0.01252910f, 
    -0.04833642f, -0.01354448f, -0.01509647f, -0.04032698f, -0.05061834f, -0.07034212f, -0.00024034f, -0.04630584f, 
    0.03032738f, -0.06200592f, -0.05044056f, -0.05924862f, -0.02230729f, -0.06174153f, 0.04816371f, 0.03940353f, 
    -0.07512903f, -0.00026611f, 0.00769236f, -0.04952550f, -0.04088642f, -0.00435051f, -0.08301939f, -0.07127276f, 
    0.03554557f, -0.03929451f, -0.01625646f, 0.00740825f, 0.03871272f, -0.05108730f, -0.06284933f, 0.04092305f, 
    -0.00620797f, -0.01116295f, 0.01455572f, -0.03405811f, 0.03660462f, 0.04083322f, -0.05600798f, -0.01232653f, 
    -0.02247078f, 0.04413767f, -0.00440636f, 0.04062796f, -0.06262835f, -0.01528274f, 0.00712325f, -0.05998367f, 
    -0.00898066f, -0.04277787f, -0.01462809f, -0.01118872f, 0.04894546f, -0.06340358f, 0.03158394f, -0.07516880f, 
    -0.02990949f, -0.06275223f, -0.08008046f, -0.08429783f, -0.00088505f, 0.02601548f, -0.05458949f, 0.02518668f, 
    -0.06770989f, -0.06479075f, 0.03508742f, 0.00368865f, -0.05348777f, 0.05388668f, -0.05197217f, -0.04901833f, 
    0.01779131f, 0.03522035f, 0.02790082f, -0.05229452f, 0.03959455f, 0.05688556f, -0.03005915f, -0.01025090f, 
    -0.05316042f, 0.02302881f, -0.07786663f, 0.05121623f, -0.01381501f, -0.05820771f, 0.05359843f, -0.03525086f, 
    -0.02688531f, 0.03412169f, -0.02628491f, -0.00530592f, -0.02579791f, 0.01716460f, -0.00373070f, -0.04460706f, 
    -0.01022236f, -0.07812228f, -0.05331190f, -0.05239073f, -0.03143224f, -0.07677978f, 0.00220998f, -0.00655618f, 
    -0.04279423f, 0.04519718f, 0.03124196f, 0.00756751f, -0.07817636f, -0.06485741f, -0.07606072f, -0.05547956f, 
    -0.05558427f, 0.02653060f, -0.04437759f, -0.01058064f, 0.01894771f, -0.00748310f, 0.05656539f, -0.04740185f, 
    -0.03140358f, 0.01782892f, -0.06689421f, -0.00607758f, -0.00396132f, -0.01160407f, -0.05402943f, -0.02849048f, 
    -0.06875809f, -0.02843085f, -0.01346461f, -0.01252462f, 0.00633292f, -0.05280874f, -0.05297901f, 0.00194356f, 
    -0.03702275f, -0.07782231f, 0.05667643f, 0.00933442f, -0.01232209f, -0.02726882f, 0.02715663f, -0.05525405f, 
    0.04693892f, -0.12464026f, -0.02436456f, -0.22392397f, 0.10532425f, -0.11265128f, -0.10796944f, 0.14308962f, 
    -0.01146178f, 0.12877662f, 0.00786275f, -0.00438163f, 0.19718389f, 0.16532898f, 0.01184035f, 0.29356042f, 
    -0.16031496f, -0.03078568f, 0.01057464f, 0.00682175f, 0.12178507f, -0.05825615f, -0.01691203f, -0.09790093f, 
    -0.25119233f, 0.03519682f, -0.17841066f, -0.11189650f, -0.03145314f, -0.08526978f, -0.00648100f, 0.26460394f, 
    -0.03741206f, 0.06932025f, -0.14277926f, 0.10191848f, 0.09797240f, -0.02209949f, -0.00739475f, 0.25862291f, 
    0.06063056f, 0.04098473f, 0.10402667f, 0.06892882f, -0.02784825f, 0.05305362f, -0.06134172f, -0.07003735f, 
    0.36091256f, -0.18831621f, -0.12366282f, -0.05314506f, 0.01212673f, -0.02656335f, -0.09580715f, -0.01808921f, 
    0.15703672f, -0.01222715f, 0.09286753f, 0.09391558f, 0.18249360f, -0.08466958f, 0.01391980f, 0.06923501f, 
    -0.03615483f, -0.09394949f, -0.09912540f, -0.13118187f, 0.01975191f, 0.13636792f, 0.02804532f, -0.08451985f, 
    0.15010819f, 0.01898266f, -0.02558384f, 0.31807917f, 0.01775960f, -0.11249906f, -0.04634912f, -0.03291655f, 
    0.08269271f, -0.10651401f, 0.04372074f, -0.05454211f, -0.20970871f, 0.24757618f, 0.03015916f, 0.09537090f, 
    0.07659323f, 0.08707651f, -0.01432746f, 0.06107208f, -0.07591481f, 0.00223102f, 0.02672614f, -0.06721776f, 
    -0.07422062f, -0.22177276f, -0.19642897f, 0.23311813f, 0.15667424f, -0.06710683f, 0.07344230f, -0.03031893f, 
    -0.13379304f, -0.07593657f, 0.09827221f, 0.02599891f, 0.15113154f, 0.06938531f, 0.02060587f, 0.03878919f, 
    0.17656031f, -0.11481727f, -0.00321175f, 0.15306161f, 0.08039166f, -0.03923240f, 0.02252517f, -0.06901554f, 
    0.39711526f, 0.00587080f, 0.01712928f, 0.33176413f, -0.05169241f, -0.19289540f, 0.07717461f, 0.03246218f, 
    -0.08077484f, -0.06632770f, -0.05614712f, -0.16435294f, -0.23556995f, -0.20842554f, -0.00340553f, 0.08347505f, 
    -0.01469569f, 0.01953607f, -0.10822689f, 0.07388231f, 0.03544164f, 0.01127035f, -0.07662575f, -0.08555934f, 
    0.20726082f, 0.14479376f, 0.16105983f, 0.07708394f, -0.14629886f, 0.10157924f, -0.02292322f, 0.05646371f, 
    -0.02621062f, 0.09789328f, -0.05804686f, -0.01431018f, 0.25157604f, -0.16480845f, -0.18284030f, -0.10616904f, 
    0.17477708f, -0.06682827f, 0.02020719f, 0.03290401f, 0.00030193f, 0.01692566f, 0.09801588f, -0.02532444f, 
    0.33414632f, 0.19243774f, -0.17474331f, 0.03205108f, -0.09693767f, -0.02899092f, 0.00666381f, 0.00057527f, 
    0.19595239f, 0.11300870f, 0.03627175f, 0.16077062f, -0.12195434f, 0.20700394f, -0.23335186f, 0.00730681f, 
    -0.02421383f, -0.03622745f, -0.05049901f, 0.11312639f, 0.03941174f, 0.00044850f, -0.09568156f, -0.06819101f, 
    -0.04100351f, -0.02446525f, 0.08556632f, -0.11034502f, 0.00442981f, -0.03876025f, 0.05478478f, -0.05440986f, 
    -0.06348360f, -0.06658500f, -0.13130786f, -0.05237757f, -0.03839288f, 0.13050401f, 0.07759265f, 0.11228458f, 
    -0.06211331f, -0.05070303f, 0.13448001f, -0.01789773f, -0.01208082f, 0.02694080f, -0.12269244f, 0.00762488f, 
    -0.07075890f, -0.05460469f, 0.00645932f, 0.05840383f, 0.02249300f, -0.01756617f, -0.06367064f, 0.05851331f, 
    -0.16341549f, 0.00067748f, -0.01999727f, -0.16072781f, 0.09873862f, 0.00047078f, 0.13703506f, 0.00189711f, 
    0.09582987f, -0.02484011f, -0.02838665f, 0.04569464f, 0.11723982f, 0.05342948f, 0.04119145f, -0.06893361f, 
    0.25394398f, 0.02347286f, 0.09329209f, -0.04933482f, 0.16181491f, 0.12552767f, -0.08942821f, -0.00435011f, 
    -0.03880555f, 0.11582947f, 0.05783081f, -0.01605496f, 0.17886573f, -0.09188024f, -0.05207598f, -0.19594742f, 
    -0.09107122f, -0.01043174f, 0.02268027f, -0.10095151f, 0.03092426f, -0.07615563f, 0.04842265f, 0.13204595f, 
    -0.26378769f, -0.09627085f, 0.14274667f, -0.09197880f, -0.02444040f, 0.08957250f, 0.05373408f, -0.03694760f, 
    -0.07785975f, 0.15564634f, -0.19767927f, 0.01374897f, -0.08017901f, -0.17977111f, 0.11842237f, 0.24995564f, 
    -0.03932150f, 0.04365718f, -0.15279572f, -0.00232918f, -0.08305539f, 0.11320123f, 0.10641202f, 0.09108399f, 
    0.24947780f, 0.15485908f, -0.19183651f, 0.13368900f, 0.18494046f, 0.11090830f, 0.08066010f, -0.01605709f, 
    -0.01455364f, -0.07532605f, 0.08063643f, 0.07786393f, 0.04915823f, -0.05412826f, 0.18796441f, -0.18423069f, 
    0.06971464f, -0.06029027f, 0.15092976f, -0.08895861f, 0.05197454f, 0.04493203f, 0.01443904f, 0.03786730f, 
    -0.06322455f, 0.13922384f, 0.13483350f, 0.15152057f, -0.04781950f, 0.05214319f, 0.05720764f, -0.03153505f, 
    -0.07319442f, 0.11334818f, 0.00715430f, 0.02646319f, 0.05355713f, -0.08538122f, -0.20427954f, 0.00988200f, 
    0.07791463f, 0.00445326f, 0.01065036f, 0.02365099f, -0.01551726f, -0.06577770f, 0.05961194f, -0.05138832f, 
    -0.11122119f, 0.16870794f, -0.10298698f, -0.04854794f, -0.16108491f, 0.04270973f, -0.00750908f, -0.05357765f, 
    0.09489694f, -0.04092587f, -0.02340306f, -0.02178528f, 0.07778927f, 0.09574618f, -0.07623537f, -0.08965982f, 
    0.15307480f, 0.08986493f, 0.00413943f, -0.02967357f, 0.00729908f, -0.07280835f, 0.05066631f, -0.03046878f, 
    0.27106202f, 0.35692832f, -0.01411672f, -0.10439928f, 0.13029774f, 0.13709253f, 0.00717796f, -0.15458366f, 
    -0.00273529f, 0.01925208f, -0.05765089f, -0.09729446f, -0.09770574f, -0.03307025f, -0.02827066f, -0.05045933f, 
    -0.06040384f, -0.14417082f, 0.02310205f, -0.04234949f, 0.09040779f, 0.10875604f, 0.09612998f, 0.12566352f, 
    0.21124066f, 0.20816477f, 0.02934983f, 0.31952745f, 0.08756262f, 0.05820791f, -0.10458866f, -0.07585862f, 
    -0.01810860f, -0.01388449f, 0.00572916f, -0.12170614f, -0.01911656f, -0.04741923f, -0.01874844f, -0.31444943f, 
    -0.02664333f, 0.04706601f, 0.01602703f, 0.13452758f, 0.18785277f, -0.02870974f, 0.06872136f, 0.24870984f, 
    0.18033367f, 0.12875275f, -0.00044189f, 0.08793850f, 0.06087074f, 0.00439350f, 0.05182119f, -0.00843440f, 
    0.08147281f, -0.11687150f, -0.04959754f, 0.21980739f, -0.02751904f, 0.10430419f, -0.13418086f, -0.00955050f, 
    0.00306419f, -0.03024983f, 0.14244181f, 0.05911000f, 0.01765721f, 0.02034316f, 0.05879930f, 0.04292403f, 
    -0.17308806f, 0.04679229f, -0.15320317f, -0.00498343f, -0.01608958f, -0.10057639f, 0.02763881f, -0.00078504f, 
    0.05143462f, 0.04010751f, -0.02138258f, 0.00205128f, -0.18579654f, 0.23739415f, 0.07687514f, -0.09463210f, 
    0.12425194f, 0.00700989f, 0.03924732f, 0.09692729f, -0.13345826f, 0.09722775f, -0.04013298f, 0.04136517f, 
    -0.01591665f, 0.13916108f, -0.08760723f, 0.12968735f, 0.01558237f, 0.10703317f, -0.02838575f, 0.01670380f, 
    0.14613704f, -0.08570497f, 0.03241007f, 0.00670854f, 0.02826708f, 0.03954262f, -0.03069677f, -0.11677475f, 
    -0.10083903f, -0.09283166f, 0.00947746f, 0.02921104f, 0.06193422f, -0.09813441f, -0.05137602f, -0.01928760f, 
    0.00361402f, -0.12509541f, 0.13679709f, 0.02820567f, -0.14728467f, -0.05471574f, 0.03448443f, -0.06249411f, 
    0.06910673f, 0.03296576f, 0.07010843f, 0.07008593f, 0.11436102f, 0.15470386f, 0.05061319f, 0.00020344f, 
    -0.18960670f, 0.08504921f, -0.02270941f, 0.11626211f, 0.18098095f, 0.06118429f, 0.07392658f, 0.08460093f, 
    0.05932724f, 0.04267971f, -0.06062423f, -0.26495138f, -0.05296155f, 0.06434248f, -0.03800964f, -0.07906478f, 
    0.06195818f, -0.17061624f, -0.09858043f, 0.10954374f, -0.11159673f, 0.18930663f, 0.19376644f, 0.28466806f, 
    -0.08251043f, 0.00998641f, 0.11187779f, -0.01530494f, 0.02756975f, 0.04436925f, 0.09108562f, 0.15083162f, 
    -0.11658593f, -0.08874327f, -0.07072172f, -0.02974678f, 0.17759143f, 0.18818222f, -0.15295938f, 0.04180781f, 
    -0.01101737f, 0.11797584f, 0.08791153f, 0.04275266f, -0.07026291f, -0.01000877f, -0.02285900f, 0.10122961f, 
    -0.14432444f, 0.05081186f, 0.08653829f, -0.02922530f, 0.09825411f, -0.01361484f, 0.07212920f, -0.02208763f, 
    -0.11371489f, -0.19067898f, 0.15749563f, 0.11064931f, -0.00065661f, -0.05407925f, 0.08603216f, 0.14591333f, 
    0.04608654f, -0.10507021f, 0.08140686f, 0.12947552f, 0.00237272f, 0.03147229f, 0.07342169f, 0.04823351f, 
    -0.05537539f, 0.09293532f, -0.02053081f, -0.05841956f, -0.03865070f, -0.16655068f, -0.20557772f, -0.17664042f, 
    0.04523209f, -0.07530624f, -0.00882210f, -0.03980621f, -0.07558547f, -0.00830224f, 0.00293038f, -0.01075531f, 
    -0.07056837f, 0.02706056f, -0.06901584f, 0.05810600f, 0.01295126f, -0.01788951f, 0.06165310f, 0.02146854f, 
    -0.01007654f, 0.03232332f, 0.04507735f, -0.06104227f, -0.00270767f, -0.07346862f, -0.06173866f, -0.02125690f, 
    -0.02696472f, 0.00998331f, 0.02766697f, -0.06006587f, 0.05481883f, 0.02572626f, 0.04021713f, 0.05426889f, 
    0.06046908f, -0.03720392f, 0.01334248f, -0.02241116f, -0.02364498f, 0.00643077f, 0.03782257f, -0.00591580f, 
    -0.04795257f, -0.05980439f, -0.07571875f, -0.06643923f, -0.00838254f, -0.07548320f, -0.01297355f, -0.04143661f, 
    -0.02774288f, -0.06504018f, -0.04454520f, -0.05308653f, 0.00539169f, -0.00591146f, 0.00083286f, -0.06490950f, 
    -0.00603843f, -0.05142894f, 0.05118654f, -0.02162493f, 0.04212596f, -0.03510183f, 0.01944799f, 0.04426608f, 
    0.02506896f, 0.03897348f, -0.02244193f, -0.06431334f, 0.06307413f, 0.05515086f, -0.02634265f, 0.05718215f, 
    -0.04336134f, 0.05118562f, -0.04879333f, -0.02861436f, -0.04209872f, 0.02415453f, 0.00109440f, -0.05310073f, 
    -0.05466460f, 0.05710668f, 0.01293241f, -0.01731283f, 0.06599174f, -0.05808109f, -0.05041648f, -0.04095627f, 
    0.00611488f, -0.04932533f, 0.01123368f, 0.02103616f, 0.01384314f, 0.04254638f, 0.00060665f, -0.00891121f, 
    0.01762393f, -0.00344025f, -0.03997765f, -0.05138991f, -0.00934933f, 0.02491659f, 0.05050855f, -0.00293590f, 
    -0.02677249f, -0.06456932f, 0.03898071f, -0.06598842f, 0.05955550f, -0.00468959f, -0.04296168f, -0.01871617f, 
    -0.05938004f, 0.04174303f, 0.00416817f, 0.00373182f, -0.01369805f, -0.06843089f, -0.02398716f, -0.00828547f, 
    0.02920422f, 0.04085494f, 0.05349967f, -0.02302703f, -0.01420315f, -0.07715274f, -0.04011960f, -0.03545818f, 
    -0.00833271f, -0.06911990f, -0.06947985f, -0.02210328f, -0.03506574f, -0.00403552f, -0.03786363f, 0.02004110f, 
    0.03006240f, -0.02887737f, 0.05454232f, -0.04572036f, 0.03432006f, -0.02517150f, -0.05091939f, 0.00272196f, 
    0.01006055f, -0.03140458f, -0.05981160f, 0.02008060f, -0.06476231f, 0.04394766f, -0.03810231f, 0.02393586f, 
    -0.01652172f, -0.01104588f, -0.04505236f, -0.05733373f, -0.04832732f, -0.05655021f, -0.05498446f, 0.00591314f, 
    -0.05939824f, -0.03270246f, 0.02636431f, 0.04841614f, 0.02641977f, 0.00392047f, 0.05739903f, 0.02195364f, 
    -0.00879304f, -0.07094093f, -0.00175351f, 0.01690718f, -0.04377124f, -0.02065307f, -0.06067766f, -0.04680407f, 
    -0.06453853f, 0.03260177f, 0.02706796f, 0.05044814f, -0.00212788f, -0.00830457f, 0.05313665f, 0.00156517f, 
    0.03072280f, -0.03839296f, -0.04765533f, -0.03232291f, 0.05690034f, 0.00454755f, 0.00817750f, 0.02018973f, 
    -0.08855570f, -0.22858077f, -0.06631795f, -0.16109435f, 0.15551510f, 0.01060241f, -0.01801449f, -0.02670914f, 
    0.13688949f, 0.04591623f, -0.03331451f, 0.16288081f, 0.14992666f, 0.09370721f, -0.17747788f, -0.20228928f, 
    0.03336048f, -0.02109660f, -0.04181660f, 0.07513285f, 0.08563652f, 0.12807214f, 0.21794102f, -0.02106027f, 
    0.09737314f, -0.21650778f, 0.03727958f, -0.06158260f, 0.20527613f, 0.05255214f, -0.08688517f, 0.07021378f, 
    -0.02261461f, 0.12299938f, 0.12664571f, 0.03940900f, 0.18914242f, -0.10121012f, 0.04925375f, 0.19134565f, 
    -0.05648617f, 0.00648632f, 0.11169702f, -0.04664752f, 0.13934039f, 0.06906250f, -0.05356835f, 0.02463241f, 
    -0.30596396f, 0.03787421f, 0.06761997f, 0.03780935f, 0.12906797f, 0.16994362f, 0.19800711f, -0.06237189f, 
    0.01824578f, -0.01237111f, 0.02835626f, -0.00728910f, 0.13291311f, -0.09953259f, 0.05527418f, 0.17502582f, 
    0.02327435f, 0.02699318f, 0.00505458f, 0.05926202f, 0.05840816f, -0.03409195f, 0.00659463f, -0.02107239f, 
    0.13045844f, 0.01312030f, 0.08731033f, 0.05436344f, -0.10406725f, 0.06001157f, -0.04774370f, -0.01636848f, 
    -0.07882208f, 0.15874377f, 0.12289322f, 0.10026813f, 0.18898533f, -0.49019381f, 0.01566670f, 0.18198337f, 
    0.04929204f, 0.07332734f, -0.13795546f, 0.04759889f, 0.00585160f, 0.09254336f, 0.01147449f, 0.03776355f, 
    -0.30790076f, 0.31693110f, 0.00689855f, -0.29935917f, 0.19075014f, -0.03496745f, -0.06716737f, 0.22628400f, 
    0.05224646f, 0.06437566f, 0.00341114f, -0.03775826f, -0.07950789f, 0.17418410f, -0.13112919f, 0.12356583f, 
    -0.05532016f, -0.05444275f, 0.15615380f, 0.04825550f, 0.05111786f, 0.01193591f, 0.06415296f, -0.02472630f, 
    0.35343111f, -0.23999599f, -0.20591737f, -0.04742147f, 0.05319013f, -0.07759105f, -0.02941637f, 0.05575438f, 
    -0.02509440f, 0.04443111f, 0.06997640f, -0.09721680f, 0.00157234f, -0.05248399f, -0.15818459f, -0.48421654f, 
    0.08215059f, -0.03824444f, -0.04785724f, -0.01432376f, -0.06899656f, 0.06437194f, 0.12004502f, -0.02991222f, 
    -0.01478640f, -0.06829064f, -0.19644186f, -0.19126469f, -0.11618188f, 0.01589713f, 0.07818495f, -0.14636159f, 
    -0.06724098f, -0.05849044f, -0.05515091f, -0.06815115f, -0.32530829f, 0.05902584f, 0.25891176f, 0.05712057f, 
    0.12817216f, 0.06566373f, 0.08172940f, 0.03800341f, 0.01141302f, 0.01087797f, -0.08476241f, 0.08728281f, 
    -0.08354366f, -0.04812613f, -0.03103822f, -0.10286224f, 0.10900813f, 0.03474846f, -0.12865756f, -0.05534570f, 
    -0.11036004f, 0.03968003f, -0.00070754f, 0.05140566f, 0.40980539f, -0.20656168f, 0.02971517f, 0.06339929f, 
    -0.03988925f, -0.10551004f, 0.00452913f, -0.02951735f, 0.04177107f, -0.03445120f, 0.16224352f, 0.03509608f, 
    0.20834617f, 0.08249775f, 0.24227192f, 0.02653134f, 0.07423926f, 0.05834984f, -0.08913732f, 0.04777795f, 
    -0.01239243f, 0.11507586f, 0.03920302f, -0.07479300f, -0.13243872f, -0.08515767f, -0.14834844f, 0.11885332f, 
    -0.11863849f, -0.00236623f, -0.06626453f, 0.04694331f, 0.11460164f, -0.04362442f, -0.00416243f, 0.00185552f, 
    0.01548854f, -0.10958358f, 0.04400235f, 0.25167376f, -0.04345620f, 0.01794665f, -0.07783794f, -0.06649668f, 
    0.03494813f, -0.06712302f, -0.05028626f, -0.12353855f, -0.19359992f, -0.02088493f, 0.00980998f, 0.07060740f, 
    0.07002655f, 0.02276676f, -0.04154045f, 0.08558659f, 0.02362407f, 0.07161534f, -0.01979275f, 0.00454606f, 
    0.41082323f, 0.02205334f, 0.08405167f, 0.01700795f, 0.13135049f, -0.15768111f, 0.07916111f, -0.02715066f, 
    -0.02848844f, -0.05254304f, 0.01531150f, 0.09465556f, -0.05805752f, -0.12629887f, -0.12567496f, -0.10468218f, 
    -0.03875387f, 0.06934625f, 0.03251082f, -0.01968936f, -0.01547657f, 0.15505758f, 0.16224816f, 0.03314565f, 
    -0.16062474f, 0.04500148f, -0.04376381f, 0.03261979f, -0.03465217f, -0.09748239f, -0.03676694f, 0.03360749f, 
    0.03453708f, -0.14530894f, 0.04193919f, 0.05578485f, -0.02641190f, -0.00275327f, -0.25643444f, -0.16733061f, 
    0.07452129f, 0.01795432f, 0.06459251f, -0.06226989f, -0.04140889f, -0.09800529f, 0.05611719f, 0.02393423f, 
    0.06422072f, 0.17669678f, 0.04078861f, -0.01824027f, 0.11634076f, 0.01451990f, 0.08844043f, -0.01177378f, 
    -0.00372695f, 0.00649832f, -0.10199804f, -0.00166821f, 0.12105607f, 0.12929939f, 0.04635533f, -0.09227710f, 
    0.05729910f, -0.01655400f, -0.13819231f, -0.00444969f, 0.15127578f, -0.11715708f, 0.04861508f, 0.02570666f, 
    -0.03420216f, 0.00557526f, -0.09981874f, -0.05484673f, -0.05269667f, -0.05504411f, -0.14784083f, 0.06440131f, 
    0.11099508f, -0.05539095f, 0.12299094f, 0.00037372f, 0.17909537f, 0.34576860f, 0.23635942f, 0.06300371f, 
    0.04049524f, -0.04415052f, 0.05458413f, 0.05986808f, 0.06720508f, 0.03958192f, -0.09750807f, 0.11862395f, 
    -0.12266409f, 0.08566222f, -0.00370552f, 0.11246640f, 0.06376174f, 0.08393506f, 0.03152689f, 0.08775659f, 
    -0.02006775f, -0.00095515f, 0.15253237f, 0.01831710f, -0.22021811f, -0.16891988f, 0.08518033f, -0.12890156f, 
    0.07363328f, -0.02841023f, 0.05425439f, -0.06069550f, 0.07803075f, 0.07341517f, 0.07167094f, -0.00731807f, 
    0.01885868f, 0.06508832f, 0.04644978f, 0.08887509f, -0.00266240f, 0.06805971f, 0.08428531f, -0.02413364f, 
    0.02601321f, 0.03385698f, 0.13069257f, 0.11924503f, -0.02041351f, -0.09611116f, -0.15438430f, 0.02213872f, 
    0.05463836f, 0.06531542f, 0.00093689f, -0.12897231f, 0.05785602f, -0.05902273f, -0.17234750f, -0.03877487f, 
    0.02600696f, -0.01857130f, -0.02048145f, 0.00011865f, 0.06016616f, 0.00657830f, 0.03921499f, -0.06617194f, 
    -0.04357386f, -0.04823925f, -0.05632536f, -0.01281238f, 0.06073764f, -0.03395656f, -0.01310863f, -0.04399451f, 
    -0.00106023f, 0.03756294f, 0.04419921f, -0.05988292f, -0.02840378f, 0.05518892f, 0.03794964f, -0.00342773f, 
    -0.04042262f, -0.01004054f, 0.05794890f, -0.03888658f, 0.04629559f, 0.03559275f, -0.06731750f, -0.04183961f, 
    -0.06362359f, -0.04003676f, -0.06888489f, 0.02949350f, -0.05198960f, -0.05601321f, 0.03667613f, -0.07267335f, 
    0.01625249f, -0.01374019f, -0.04487192f, 0.00627882f, -0.03971084f, -0.04827904f, -0.02151001f, -0.02262972f, 
    0.06316803f, -0.02012073f, -0.04074546f, -0.04172999f, -0.07620538f, 0.03777464f, 0.03647961f, -0.06245311f, 
    -0.03930144f, -0.01263181f, 0.01766572f, 0.01953611f, -0.04842321f, -0.00172490f, -0.01534028f, -0.03865325f, 
    0.06338240f, 0.03430172f, 0.06692116f, 0.00415735f, -0.04088451f, 0.05424048f, 0.03463645f, 0.02932148f, 
    0.03939847f, -0.06264408f, -0.04294569f, 0.00011954f, 0.06444477f, -0.04285453f, -0.01705347f, -0.04213586f, 
    -0.03562676f, 0.05877534f, 0.03395854f, -0.05889053f, -0.05717015f, -0.05899655f, -0.06858533f, -0.02427826f, 
    0.02409382f, -0.06172325f, 0.02427709f, -0.07194920f, 0.05586974f, -0.05488029f, -0.04854347f, -0.01884866f, 
    -0.00362391f, 0.02287642f, 0.01554817f, 0.04229107f, 0.01280225f, 0.01825454f, 0.05591884f, 0.04646661f, 
    -0.06692907f, -0.03414737f, -0.07429098f, 0.04453341f, -0.07470780f, -0.07030030f, -0.04518752f, 0.03021369f, 
    -0.00282161f, 0.02643995f, -0.04953282f, 0.02622889f, 0.00888629f, -0.04255074f, -0.00902365f, -0.06024863f, 
    0.06062400f, 0.02034588f, -0.03322212f, -0.07160443f, 0.05291354f, -0.05093376f, -0.06199299f, -0.05798739f, 
    -0.03170985f, -0.06190971f, 0.05766962f, 0.03126197f, -0.07048773f, 0.06682552f, -0.06911994f, 0.03482997f, 
    0.03559420f, 0.03159839f, -0.03453869f, -0.02074142f, -0.04428848f, -0.07541946f, 0.05704613f, 0.01901304f, 
    0.01746995f, -0.02926550f, -0.03042768f, -0.05852164f, -0.03685725f, -0.07584376f, 0.03687234f, 0.01237280f, 
    0.04632864f, -0.02827107f, -0.04326604f, -0.03418712f, -0.05361886f, 0.00286369f, -0.03907468f, -0.06057145f, 
    -0.04573099f, 0.04044349f, -0.02375868f, -0.01812859f, -0.07451671f, 0.01784883f, 0.06182287f, -0.02413866f, 
    0.02880784f, 0.03041936f, 0.02633814f, -0.03289318f, -0.00070853f, 0.02506668f, -0.00970756f, 0.03113057f, 
    -0.03742658f, 0.06354274f, 0.04126773f, 0.03877670f, -0.06030178f, -0.06095821f, -0.02104420f, 0.03286215f, 
    -0.06404700f, -0.07692268f, -0.00102575f, 0.06945919f, 0.00677301f, 0.02869914f, -0.00225824f, 0.02036635f, 
    -0.02894856f, -0.16148856f, -0.17675233f, -0.01105361f, -0.03600859f, -0.02002594f, 0.00598631f, -0.15633880f, 
    0.08857796f, -0.07408614f, -0.03727241f, -0.03366688f, 0.07656093f, 0.00001497f, -0.22640999f, -0.28924865f, 
    -0.04568813f, -0.01936365f, 0.11293818f, -0.05511648f, 0.18008944f, 0.02698431f, -0.08564812f, -0.00635797f, 
    -0.16384885f, 0.02767921f, -0.27070081f, -0.19712029f, 0.06606728f, 0.01343224f, 0.07025315f, 0.14415646f, 
    -0.10554048f, -0.01492994f, -0.07951751f, 0.22313133f, 0.17406099f, 0.01877755f, -0.13732950f, -0.01524609f, 
    0.12406825f, 0.10287872f, 0.02569610f, 0.09334461f, 0.08306845f, 0.18834803f, -0.01621270f, 0.00124072f, 
    0.01916416f, 0.08224264f, -0.15061931f, -0.10210691f, -0.06575484f, 0.11296471f, -0.23359041f, 0.06275075f, 
    0.23044801f, 0.08503481f, 0.05548786f, 0.11859493f, -0.00186134f, 0.06080671f, 0.06304958f, 0.23068121f, 
    -0.08929850f, 0.00832970f, 0.16058137f, 0.00951068f, 0.02409444f, 0.07276792f, 0.03256150f, 0.05927762f, 
    0.17167233f, -0.00763901f, -0.08689149f, 0.01821245f, 0.02084499f, 0.08122069f, -0.01592123f, -0.01354501f, 
    0.10606231f, -0.03865235f, 0.08164851f, -0.00581764f, -0.64751059f, 0.35910186f, 0.20489317f, -0.00345405f, 
    -0.00882723f, 0.06421696f, 0.08927719f, 0.15685527f, 0.12028296f, 0.01423247f, 0.05619621f, -0.03530817f, 
    0.19900306f, -0.17039077f, -0.06588251f, 0.25826889f, -0.15100090f, -0.04777961f, -0.06306648f, 0.01668997f, 
    0.02903670f, 0.01742026f, 0.17230718f, 0.17930734f, 0.21578574f, -0.29533419f, -0.02744281f, 0.07363133f, 
    0.06823976f, -0.01763719f, 0.04004254f, 0.04362179f, -0.02790798f, 0.04669503f, 0.07328717f, -0.19039533f, 
    -0.12820238f, -0.00043793f, 0.15404072f, -0.33339372f, 0.00499736f, -0.05036192f, 0.08818937f, -0.05270266f, 
    0.06741174f, -0.03915153f, -0.12676390f, 0.00415133f, -0.11061436f, -0.24339956f, 0.00081246f, 0.12962925f, 
    -0.10520905f, -0.01198355f, 0.01436712f, 0.13468172f, 0.01788533f, 0.07021620f, 0.10394151f, 0.08608471f, 
    -0.09168567f, 0.09287272f, -0.02896422f, -0.19898942f, -0.11469278f, 0.17338626f, -0.10384714f, -0.06883037f, 
    0.08375016f, 0.09368846f, 0.06497393f, -0.05800081f, 0.42032394f, -0.32524133f, -0.03336500f, 0.21651636f, 
    -0.03747484f, 0.00984847f, -0.04365565f, -0.06411443f, 0.07753729f, 0.04627274f, 0.10382839f, 0.12294776f, 
    0.28766572f, 0.24156135f, 0.17992748f, 0.09048188f, -0.01177216f, 0.01205892f, -0.01995263f, 0.10515323f, 
    0.10758850f, 0.03382162f, 0.03423029f, 0.16406040f, -0.15403537f, 0.07156648f, -0.00158615f, 0.30871400f, 
    0.06702315f, -0.09001301f, 0.01699262f, 0.02458046f, 0.01217684f, -0.04350584f, -0.05476463f, -0.04473281f, 
    -0.00782584f, 0.23878941f, -0.25676632f, 0.13221446f, 0.07252450f, -0.04591161f, 0.02516550f, -0.17100674f, 
    -0.03070861f, 0.00222002f, 0.00875510f, 0.03747043f, 0.00535940f, -0.17208208f, -0.00619272f, -0.35234073f, 
    -0.03975762f, 0.00424056f, -0.11575237f, 0.23592593f, 0.01180068f, 0.07498623f, 0.06420338f, 0.17200221f, 
    -0.18547964f, 0.19547316f, -0.09361849f, -0.03367470f, 0.04231506f, -0.01831662f, 0.01966270f, 0.11888507f, 
    -0.01217792f, -0.09201585f, 0.00774130f, 0.13006175f, -0.39908272f, -0.10693141f, -0.00827716f, 0.18564911f, 
    0.01944674f, 0.13796286f, -0.08652054f, 0.03043290f, -0.02919713f, 0.05555384f, 0.16446353f, 0.12064313f, 
    0.24607842f, 0.02370068f, 0.01130760f, -0.12191737f, 0.05482699f, -0.06760924f, 0.09312481f, -0.02182354f, 
    -0.03778505f, -0.04185636f, 0.23745556f, -0.01232175f, -0.24326448f, 0.14832163f, 0.33398381f, -0.15600856f, 
    -0.03377423f, -0.19695675f, -0.09210593f, 0.03806545f, 0.03947895f, 0.07180950f, 0.08060636f, 0.07328214f, 
    -0.10534762f, 0.17005782f, 0.16594282f, 0.12232228f, -0.03948212f, 0.07407118f, 0.03828026f, -0.05108016f, 
    -0.03401137f, 0.06783536f, -0.05936511f, 0.03607283f, 0.10133030f, -0.28546861f, 0.12724335f, 0.10851154f, 
    0.01411322f, -0.02400192f, 0.02213884f, 0.13608050f, -0.00229024f, 0.04971937f, 0.01867122f, 0.00439851f, 
    -0.19353488f, 0.05047162f, 0.17192759f, 0.01157494f, 0.02541529f, -0.17996146f, 0.05831151f, 0.05165960f, 
    0.05782606f, 0.07723795f, 0.04486199f, 0.07003705f, 0.26100624f, 0.28362864f, 0.10213241f, 0.12639840f, 
    -0.03098703f, -0.02541006f, 0.06927917f, 0.18184800f, 0.05105670f, -0.07450263f, -0.01167634f, 0.11018866f, 
    0.05828946f, 0.10516909f, -0.24909414f, 0.03311525f, 0.01416004f, 0.08750091f, -0.09567896f, -0.00040634f, 
    0.00662950f, -0.17714302f, -0.03057595f, -0.09276873f, 0.05346265f, -0.07116568f, -0.19050412f, 0.08769085f, 
    0.13204095f, -0.02984241f, 0.06443613f, -0.00918842f, -0.01418073f, 0.03069771f, 0.05836970f, 0.06452436f, 
    -0.05262657f, -0.28828347f, -0.11635522f, -0.22906964f, -0.06076476f, -0.07040594f, -0.05969670f, -0.12994556f, 
    -0.00777745f, 0.05486954f, -0.14134352f, 0.05180471f, -0.07840146f, 0.28622758f, 0.20770472f, -0.04531381f, 
    -0.01872346f, 0.05434711f, 0.01216849f, 0.05841058f, 0.02839111f, -0.21352741f, -0.04235126f, -0.13980092f, 
    0.14435537f, -0.17895645f, 0.06071978f, 0.02218692f, 0.02667886f, 0.11795036f, 0.08921418f, 0.09104691f, 
    -0.08544001f, 0.01870597f, 0.13941386f, 0.05149446f, -0.30029872f, 0.10447016f, -0.02003717f, -0.06877325f, 
    -0.07608391f, 0.11076501f, -0.01784059f, 0.00902200f, -0.05076770f, -0.08907294f, -0.05736035f, -0.19444914f, 
    0.15438773f, 0.26412725f, -0.02116191f, 0.14454551f, 0.06650764f, 0.03354253f, -0.09001220f, -0.05758356f, 
    0.03198859f, 0.08823454f, 0.07238741f, -0.03540135f, -0.03042501f, -0.05069090f, -0.11512277f, -0.21146573f, 
    0.00674898f, -0.02218456f, -0.09756318f, 0.02587522f, 0.06340120f, -0.07323170f, -0.12512699f, 0.05395534f, 
    0.00748384f, 0.04021328f, -0.12732106f, 0.06518082f, 0.02135843f, 0.04383314f, -0.03484229f, -0.08605342f, 
    0.14014667f, -0.16863082f, -0.15390134f, 0.17301841f, -0.21752317f, 0.11270694f, -0.18391754f, -0.06056753f, 
    0.09351977f, 0.13882621f, -0.02160564f, 0.12661670f, 0.04758587f, 0.04649417f, 0.07828755f, 0.06323604f, 
    0.31321684f, 0.02916106f, -0.12946503f, -0.09992079f, -0.02974851f, -0.14141791f, -0.05971076f, 0.01332083f, 
    -0.02280312f, 0.08183017f, 0.11692620f, 0.04813867f, -0.19281563f, 0.12520768f, 0.12500721f, 0.03913125f, 
    0.01289185f, -0.04035198f, 0.08749949f, -0.09786782f, -0.08438953f, 0.13864408f, 0.01342090f, 0.04032525f, 
    0.08933365f, 0.09221429f, -0.07245896f, 0.00441686f, 0.01982740f, 0.06608391f, 0.08778696f, 0.03337949f, 
    0.17483018f, -0.23181823f, 0.14427270f, -0.03200459f, -0.27473453f, 0.29260334f, 0.06544190f, -0.15498674f, 
    0.01754864f, -0.04546482f, 0.08642261f, 0.04068309f, 0.07353868f, 0.01239078f, -0.10443935f, -0.05299737f, 
    -0.00236533f, -0.15141520f, 0.16943456f, 0.21757828f, -0.14357920f, -0.08344836f, 0.10549009f, -0.00483426f, 
    0.07334544f, -0.00180781f, 0.05374351f, 0.03720564f, 0.27800074f, 0.01037623f, 0.02999003f, -0.02750931f, 
    -0.09375735f, 0.09494797f, -0.10174739f, 0.15494199f, 0.03462187f, -0.09766078f, 0.13536119f, 0.06066450f, 
    -0.09502595f, 0.02906610f, -0.00745949f, -0.22469610f, -0.04047653f, -0.00806203f, 0.01327254f, -0.08850712f, 
    0.15612109f, -0.05416749f, -0.10317694f, 0.01714893f, 0.05273709f, 0.11773510f, 0.16935465f, 0.29209384f, 
    0.00424896f, 0.13658342f, 0.10236534f, 0.00205259f, 0.04171836f, 0.05733948f, -0.07987790f, 0.19581065f, 
    -0.05072315f, -0.06566568f, 0.03621784f, -0.01668163f, 0.07943758f, 0.07698855f, -0.03722714f, 0.13024533f, 
    0.02042813f, 0.07816757f, 0.08177911f, 0.14249150f, 0.13766219f, -0.21593350f, -0.05821633f, 0.05241645f, 
    -0.18280290f, -0.09500512f, 0.06556932f, -0.03080598f, 0.05607403f, 0.04932171f, 0.07534997f, -0.04562483f, 
    0.02554722f, -0.14062355f, 0.04336167f, 0.16411045f, 0.03818720f, -0.02422200f, 0.09377708f, 0.09375392f, 
    -0.02196350f, 0.00994875f, 0.10327563f, 0.16598719f, -0.21125230f, 0.20205905f, 0.02506819f, 0.07134597f, 
    0.04746469f, 0.03402866f, -0.02758940f, 0.02064624f, -0.07701039f, -0.16341376f, -0.25847191f, -0.19074613f, 
    -0.26644674f, 0.07732668f, -0.07922238f, -0.05021968f, 0.12112319f, 0.01247653f, 0.13301972f, 0.09668775f, 
    -0.02854823f, -0.07579549f, -0.09239192f, 0.17238711f, -0.04979514f, -0.13657184f, 0.00670737f, 0.04849436f, 
    -0.06318151f, 0.06371886f, -0.06547385f, 0.13490142f, -0.13081214f, 0.12094694f, 0.01703128f, -0.02626031f, 
    -0.29588112f, 0.11090552f, -0.14207341f, -0.05237572f, 0.07865264f, 0.03444412f, -0.06213749f, 0.11079931f, 
    0.00150412f, -0.04653839f, 0.06912876f, -0.06186217f, -0.18873234f, -0.07754747f, 0.08368799f, 0.08225638f, 
    0.22004898f, -0.08654736f, -0.00185171f, 0.17489129f, 0.11441218f, 0.02587241f, -0.10324380f, 0.01264426f, 
    0.05647770f, -0.04330043f, 0.21184839f, 0.03730198f, 0.18233122f, 0.04532988f, 0.14686473f, -0.16829412f, 
    0.12777680f, -0.01241688f, 0.06403206f, 0.07134154f, -0.07449083f, -0.18356499f, 0.12131657f, -0.05387091f, 
    -0.05464550f, -0.02166478f, -0.02044980f, 0.03362912f, 0.10444990f, 0.02157341f, 0.17214799f, 0.10285406f, 
    -0.11940371f, -0.04826456f, 0.18573102f, -0.03114966f, 0.04517746f, -0.15240636f, 0.20627220f, 0.02307640f, 
    -0.06520515f, 0.13227168f, -0.02667196f, 0.10688623f, 0.10025845f, 0.04564083f, 0.03925687f, 0.02010973f, 
    0.01164541f, 0.05018422f, 0.02004767f, 0.04180425f, 0.02687507f, -0.02845059f, 0.17310637f, -0.07067259f, 
    -0.14593625f, -0.05980713f, -0.03808143f, -0.11533058f, 0.03104057f, -0.03302121f, 0.00790310f, 0.01359144f, 
    0.05640916f, 0.05782183f, -0.06276422f, 0.11850304f, 0.00435189f, 0.00813000f, 0.03103470f, 0.01913974f, 
    0.18542527f, -0.01774836f, 0.06478599f, -0.02382881f, 0.09781469f, 0.06010421f, -0.00435621f, 0.06861451f, 
    -0.36222437f, 0.01958254f, -0.09138373f, 0.13204649f, 0.10099464f, -0.00635151f, 0.03811477f, -0.05700204f, 
    -0.01299765f, -0.05247751f, 0.13853146f, -0.11586539f, 0.24270786f, -0.04556700f, -0.17240259f, -0.38001177f, 
    0.01550089f, -0.02133177f, 0.02715964f, 0.10340326f, -0.00597796f, -0.01168925f, -0.04701677f, 0.00551462f, 
    -0.00347034f, 0.09758675f, -0.14780021f, -0.04554543f, -0.06342638f, 0.00813658f, 0.03595261f, -0.07820096f, 
    -0.09407043f, -0.14578696f, -0.07322503f, -0.01151554f, -0.03223788f, 0.03747565f, 0.08037487f, -0.28460267f, 
    -0.02042118f, 0.00363408f, 0.12501949f, -0.01926169f, 0.02528011f, -0.00676755f, 0.02709546f, -0.05537384f, 
    0.27343196f, -0.03684848f, 0.35842872f, 0.07875463f, -0.14053632f, -0.05851035f, -0.07503384f, -0.09127989f, 
    0.22093579f, 0.01692617f, -0.06946705f, -0.12315206f, -0.32228893f, 0.16916680f, -0.11661047f, -0.14335172f, 
    0.08407655f, -0.00623601f, -0.01543763f, -0.02255220f, -0.06492934f, 0.03280112f, 0.02766356f, 0.09213488f, 
    0.05003189f, -0.10359708f, -0.12251059f, 0.10655112f, -0.06471022f, 0.11851197f, -0.02614642f, 0.02670084f, 
    0.06209583f, -0.01478734f, 0.03537133f, 0.14216380f, -0.05026676f, -0.03224020f, 0.00005567f, -0.10868099f, 
    0.01072063f, -0.01584928f, 0.00143008f, 0.03447709f, 0.04035746f, -0.05560366f, 0.12784556f, -0.05679329f, 
    0.22002363f, -0.22947344f, -0.05635370f, 0.28277907f, -0.07766014f, 0.09026157f, 0.01093652f, -0.05887975f, 
    0.02314760f, 0.06423294f, 0.07182619f, 0.11148849f, 0.28662437f, -0.01590995f, 0.11704744f, 0.08276848f, 
    0.02077201f, 0.01455085f, -0.04187907f, -0.00875754f, 0.09839172f, 0.02714664f, -0.09594345f, 0.07307060f, 
    -0.28252548f, -0.03411134f, 0.08798298f, 0.10391807f, 0.12330962f, 0.02019307f, 0.04823007f, -0.03166255f, 
    0.06263097f, 0.03060936f, -0.24395637f, 0.02531319f, 0.11583844f, 0.03280113f, -0.04548076f, -0.13751332f, 
    0.07802019f, 0.04809512f, 0.12315734f, 0.00787673f, 0.01795142f, -0.00083882f, 0.09537850f, 0.02275164f, 
    -0.09838946f, 0.07857464f, -0.07784293f, 0.09994639f, -0.01419111f, -0.06187025f, -0.04514256f, 0.05930766f, 
    0.00969869f, -0.01616448f, 0.05844234f, 0.24936023f, 0.25815019f, 0.24288395f, -0.34766138f, -0.31770894f, 
    -0.09024433f, 0.06108162f, 0.02893943f, 0.03109026f, -0.00889131f, 0.03356657f, 0.01071536f, 0.07063891f, 
    0.11076241f, 0.04877676f, 0.00977421f, -0.06180630f, 0.00578885f, -0.06871179f, 0.01906060f, 0.03069648f, 
    0.01180024f, 0.00939015f, -0.10223556f, -0.01067999f, -0.00700669f, 0.07006641f, 0.14013380f, -0.10764302f, 
    0.10052091f, 0.13666968f, -0.12092394f, -0.07541463f, -0.01854757f, -0.05897804f, 0.00443712f, 0.09486718f, 
    0.00599895f, -0.13177504f, 0.01268727f, 0.06422658f, -0.08065663f, -0.00807961f, -0.06827766f, 0.00836729f, 
    -0.03348007f, -0.01105853f, 0.02901855f, -0.03403153f, 0.17012663f, 0.27196240f, 0.08292142f, -0.17156391f, 
    0.03918923f, -0.01978270f, 0.05689232f, 0.07055157f, -0.12473989f, 0.04544269f, 0.12099112f, -0.11023042f, 
    0.01992029f, -0.07797554f, -0.09327770f, 0.02925870f, -0.00449546f, -0.07319506f, 0.09584602f, -0.05765787f, 
    -0.05315128f, -0.04340265f, -0.03994491f, -0.09759405f, -0.32131112f, -0.04328785f, 0.07154025f, -0.11570261f, 
    0.06237294f, 0.11250152f, 0.04124921f, -0.05667491f, 0.05532483f, 0.15127213f, 0.03906781f, -0.02672451f, 
    -0.21208756f, 0.01079531f, 0.13478775f, -0.19941132f, 0.08071419f, 0.11847457f, -0.04425566f, -0.01158067f, 
    0.05647251f, -0.05231708f, -0.02265995f, 0.05158649f, 0.22821176f, -0.25654349f, -0.04517170f, 0.04808374f, 
    0.05121655f, -0.03645820f, -0.11218725f, -0.09798835f, 0.15116942f, 0.09991697f, 0.05358923f, -0.05377709f, 
    -0.11181562f, 0.11653473f, -0.03829380f, -0.27793300f, 0.20241219f, -0.08293591f, -0.02199427f, 0.07606456f, 
    -0.14248025f, -0.03718593f, 0.08419879f, 0.13605456f, 0.01257237f, -0.04367043f, 0.01539661f, 0.23237792f, 
    0.07248223f, 0.11489212f, -0.09944995f, 0.10969504f, -0.04752732f, 0.12284876f, 0.04662477f, 0.01252845f, 
    -0.08188546f, 0.03707075f, -0.07026856f, -0.12425954f, 0.01666394f, -0.05633053f, -0.05576926f, 0.10754686f, 
    0.02686385f, -0.00629991f, 0.07807264f, -0.11874343f, -0.02606057f, -0.09080840f, 0.00587027f, 0.21997888f, 
    0.02926756f, 0.09987797f, 0.11145739f, 0.14460620f, 0.05094575f, 0.09568793f, 0.01653861f, 0.02608599f, 
    -0.24491154f, -0.21633971f, 0.13664816f, 0.17669995f, 0.21852100f, 0.02125609f, 0.15009549f, -0.09789868f, 
    0.03292168f, -0.01581941f, 0.14857548f, 0.05825561f, 0.17088343f, -0.09334671f, 0.07155816f, 0.01883078f, 
    0.02928915f, -0.00624064f, -0.15401204f, -0.00427252f, 0.04990781f, 0.11167365f, 0.09119681f, 0.06296312f, 
    0.13554579f, 0.06776904f, 0.27471545f, 0.04163593f, 0.02212206f, -0.05550453f, 0.02674951f, 0.01070814f, 
    -0.08503405f, -0.14059401f, 0.17955078f, 0.03088267f, 0.40273449f, -0.02805658f, -0.19505388f, 0.13399562f, 
    0.10456728f, 0.02247025f, -0.01733175f, -0.00320940f, -0.10097866f, 0.10003008f, 0.02993027f, 0.04997896f, 
    -0.48096669f, 0.01137145f, -0.01438810f, -0.24294414f, 0.15745997f, 0.00655178f, 0.05869387f, -0.04920613f, 
    0.03333557f, 0.03121822f, 0.10282012f, 0.09082676f, -0.28114855f, 0.15511814f, -0.17012997f, 0.17676927f, 
    0.07295036f, -0.02096576f, -0.00471122f, 0.09299690f, 0.08474257f, 0.07026922f, 0.02833413f, 0.08489890f, 
    0.23055348f, -0.09162793f, -0.14015487f, 0.23858951f, 0.01885727f, -0.06055165f, -0.00527267f, -0.02218408f, 
    -0.07328468f, -0.06899934f, -0.02393626f, -0.06319934f, -0.04477398f, -0.03332702f, -0.00510505f, -0.13232313f, 
    0.19754080f, 0.09590515f, -0.07975765f, -0.00618419f, 0.03919646f, 0.01454661f, -0.05297715f, 0.05597356f, 
    0.34991688f, 0.03341937f, 0.08662359f, -0.02798039f, 0.04495320f, -0.06434008f, 0.08079743f, 0.14943770f, 
    -0.13817286f, -0.05006158f, 0.00980350f, 0.10962793f, -0.25391138f, 0.09372429f, 0.05869275f, -0.14054199f, 
    0.21279979f, -0.01945171f, 0.09995395f, 0.07593913f, 0.00241749f, -0.00153903f, 0.05747104f, -0.06400990f, 
    0.00054213f, -0.32885817f, 0.26741558f, 0.16582134f, -0.06269587f, -0.07935218f, 0.02405847f, -0.12810752f, 
    0.01017930f, 0.11246771f, 0.08888358f, 0.04336941f, -0.02876247f, 0.27877089f, -0.11129981f, -0.08995448f, 
    0.09832985f, -0.02656026f, 0.01978959f, -0.06414028f, -0.03496394f, -0.04845735f, -0.09643635f, -0.03609619f, 
    -0.15104455f, 0.05218468f, -0.30517927f, 0.08425231f, -0.03798377f, 0.11395505f, 0.20576799f, 0.01580483f, 
    -0.00488484f, -0.01485504f, 0.08132724f, 0.32376063f, -0.12243474f, -0.27077138f, 0.08406825f, 0.02421081f, 
    0.10153271f, -0.01277964f, 0.01555388f, 0.12086959f, -0.09973451f, -0.01833664f, 0.00880862f, -0.05397181f, 
    0.06070125f, 0.04236337f, -0.02853050f, -0.08306091f, -0.01462653f, 0.17944105f, 0.03766799f, 0.10702117f, 
    -0.06812031f, 0.05031193f, 0.18170415f, 0.01533884f, 0.02183739f, 0.13257037f, -0.02718953f, -0.16130966f, 
    0.02948354f, -0.21606678f, -0.11459934f, 0.06614880f, 0.04573140f, -0.02528947f, 0.05016793f, 0.06117367f, 
    -0.39146242f, 0.00299159f, 0.04437588f, 0.13289817f, -0.08660683f, 0.15529513f, 0.02614161f, -0.09593613f, 
    -0.04801708f, -0.04712342f, -0.02799020f, -0.03566293f, -0.04743906f, 0.06078450f, 0.24268541f, -0.10823976f, 
    -0.03277833f, 0.06799924f, 0.05101641f, 0.07703286f, 0.06973462f, -0.01975089f, -0.06089694f, 0.06143590f, 
    -0.14581691f, 0.16601537f, -0.01355832f, -0.09585768f, 0.03621299f, -0.07081845f, 0.09756336f, 0.07062412f, 
    0.00795350f, 0.30524725f, 0.02442466f, 0.29647022f, 0.25680640f, 0.07003044f, 0.02727457f, -0.06558097f, 
    -0.04771711f, 0.03606468f, -0.05213315f, 0.10926376f, -0.05065492f, 0.16951533f, 0.03684887f, 0.12488303f, 
    -0.01178728f, -0.05258083f, 0.24855588f, -0.02484409f, -0.10581706f, -0.06867780f, -0.07743538f, -0.01918976f, 
    0.08369212f, 0.01173828f, -0.09217461f, -0.25294524f, -0.15093298f, -0.07277226f, 0.14754160f, -0.24681038f, 
    -0.01347390f, 0.08887836f, -0.06957717f, -0.15777197f, 0.03156883f, -0.04670092f, -0.07069155f, -0.02561667f, 
    -0.32703328f, -0.00600091f, 0.00819250f, 0.03207072f, 0.07756532f, 0.05854980f, 0.07467671f, 0.13763231f, 
    0.01960155f, 0.10068300f, 0.06267734f, 0.13226591f, 0.11704465f, -0.04689089f, -0.00205256f, 0.06157843f, 
    0.20242076f, -0.05107442f, -0.10650307f, -0.15530553f, 0.09421046f, -0.07138805f, 0.20836657f, -0.04475888f, 
    0.20375338f, -0.13099630f, -0.01878826f, 0.21015899f, 0.01775069f, -0.17335548f, 0.07427025f, 0.10700958f, 
    0.10810955f, -0.00380508f, -0.11328094f, -0.02720679f, 0.02871434f, 0.30774105f, 0.06018297f, -0.10149782f, 
    -0.06334298f, 0.08219646f, -0.12052234f, -0.12097637f, 0.05408379f, -0.14406799f, -0.21232997f, -0.05383754f, 
    -0.19352676f, -0.15585050f, 0.13238996f, -0.07917417f, -0.03256873f, 0.09013605f, 0.00795074f, -0.43489853f, 
    0.07492054f, -0.00941083f, 0.02904544f, 0.03222622f, -0.00611615f, -0.05863894f, 0.08659881f, -0.23697077f, 
    -0.00839288f, -0.01284647f, 0.01512670f, 0.17782831f, 0.06605043f, 0.26908159f, 0.20417520f, 0.16483587f, 
    0.02622194f, -0.00059648f, 0.07997277f, -0.10249787f, -0.11718506f, 0.09655299f, 0.02142605f, -0.01115982f, 
    0.10088254f, 0.04415745f, 0.05013688f, 0.04776867f, 0.06102668f, 0.04220581f, -0.22817846f, -0.16634868f, 
    0.04269382f, 0.05810409f, 0.06032798f, -0.03978227f, -0.01960999f, -0.01545709f, -0.05527661f, -0.11234101f, 
    0.07096658f, -0.05324592f, 0.03774714f, -0.43208653f, 0.06399856f, 0.07650017f, 0.14348194f, 0.11205648f, 
    -0.06644598f, -0.07011266f, 0.03347079f, 0.06747288f, -0.06748973f, 0.10852733f, -0.07066438f, -0.28981566f, 
    0.09289374f, 0.01167428f, -0.01245295f, 0.01226909f, 0.03478833f, 0.02359939f, -0.08401714f, 0.08107210f, 
    0.04626274f, 0.35075304f, 0.00541888f, 0.04072418f, -0.20417888f, 0.03979336f, -0.00439472f, 0.08240616f, 
    0.06970707f, -0.04011424f, 0.03138825f, -0.00858308f, -0.17776217f, 0.00710412f, 0.09014501f, 0.29373276f, 
    -0.14439289f, -0.04084266f, 0.06520285f, 0.02333724f, -0.11863859f, -0.04114804f, 0.03661225f, -0.02032910f, 
    0.01189777f, -0.10065579f, -0.16436812f, -0.18534073f, 0.01399099f, -0.01170858f, -0.08848394f, -0.03468244f, 
    0.10307471f, 0.25232533f, -0.06037858f, -0.01790090f, -0.22286709f, -0.07852208f, 0.15707409f, 0.20732418f, 
    -0.03472703f, -0.06622975f, -0.16152258f, -0.01479307f, 0.14259227f, -0.06095763f, 0.00564513f, 0.00999238f, 
    0.32616264f, 0.06339882f, 0.09570237f, -0.05564222f, -0.03408618f, 0.07079292f, 0.03009907f, -0.03464941f, 
    0.03707295f, -0.04111374f, 0.03080016f, -0.03919977f, -0.00816371f, -0.28809357f, -0.04303713f, -0.08413030f, 
    -0.03821915f, -0.06148925f, 0.07509097f, 0.05114725f, 0.00682805f, 0.04960995f, -0.02657180f, -0.25013152f, 
    -0.23710130f, 0.10149134f, -0.03107260f, -0.40469387f, 0.04827903f, 0.14309928f, 0.10894499f, 0.14240019f, 
    0.04321782f, 0.10167634f, -0.07869370f, 0.04868095f, 0.16725798f, 0.01569153f, 0.08928064f, 0.08770251f, 
    -0.09405528f, 0.05816643f, -0.06205130f, -0.02499583f, -0.02648330f, 0.05329689f, 0.11255948f, 0.22059163f, 
    -0.13692714f, -0.07757188f, -0.15190679f, -0.00646387f, 0.15320463f, 0.10297717f, -0.11467154f, -0.06192523f, 
    0.07639775f, -0.05473294f, -0.05112178f, -0.06303825f, 0.13318197f, 0.01100559f, 0.03941874f, 0.28679335f, 
    -0.06938171f, -0.10849302f, -0.05674834f, -0.04139870f, -0.03308376f, -0.08844154f, -0.12260555f, 0.06220243f, 
    0.09772987f, 0.26246175f, -0.05632158f, 0.27920565f, 0.07352781f, -0.00768497f, -0.03457339f, 0.08172762f, 
    -0.14865334f, -0.17007391f, -0.03418519f, -0.06649628f, 0.12078030f, 0.03298315f, 0.04847935f, -0.06020493f, 
    0.16632167f, 0.09706903f, 0.03045147f, 0.10839916f, -0.05921385f, 0.14138876f, 0.14722985f, 0.14321129f, 
    -0.01710251f, 0.04056032f, -0.08059477f, 0.04134990f, 0.01491862f, -0.03397727f, -0.06321580f, 0.04192121f, 
    0.04152581f, -0.05105155f, -0.02562621f, -0.06754238f, 0.01287793f, -0.00376364f, -0.07667435f, 0.03274758f, 
    -0.04972783f, 0.03645786f, -0.08275133f, 0.06279325f, 0.04852232f, 0.05998083f, 0.04838950f, 0.00095283f, 
    -0.02649789f, -0.01591120f, -0.02437222f, -0.01094890f, -0.05524116f, -0.04181531f, -0.04146517f, -0.04708232f, 
    -0.04063151f, 0.05225298f, 0.02687894f, -0.01631106f, 0.03003457f, -0.07106035f, -0.06682534f, 0.01393106f, 
    0.02084281f, -0.03213143f, -0.01763558f, -0.06177108f, 0.05603061f, 0.03515648f, -0.07666731f, 0.05798901f, 
    0.01819361f, -0.06355076f, -0.07295405f, -0.03213682f, -0.05804503f, -0.00978703f, -0.08134648f, -0.03279815f, 
    0.05092201f, 0.00449431f, -0.01077213f, 0.04428330f, -0.05507224f, -0.02853051f, 0.01120039f, -0.00908062f, 
    0.01881503f, -0.07718793f, -0.06534337f, -0.04253582f, 0.03329702f, -0.01666991f, -0.00566255f, -0.06985920f, 
    -0.00998075f, 0.00691810f, 0.01794114f, -0.06456077f, -0.01046094f, -0.02384000f, 0.00490142f, -0.00890361f, 
    -0.07110901f, 0.03924661f, 0.04535399f, -0.01170817f, -0.00383370f, -0.07807356f, -0.06835801f, 0.00692759f, 
    -0.02936018f, -0.05299091f, -0.06805434f, 0.01547746f, -0.01572059f, 0.03422382f, 0.01424374f, 0.01700262f, 
    -0.06944333f, -0.00666056f, -0.01627303f, 0.05175934f, -0.01088822f, 0.02863818f, -0.08088600f, -0.05902987f, 
    -0.04743103f, -0.04027980f, 0.01118270f, -0.01414540f, -0.04779191f, -0.05404387f, 0.05852470f, -0.03453439f, 
    0.01489047f, 0.01241987f, -0.00879146f, -0.03649684f, 0.03396367f, -0.05428695f, 0.05292128f, -0.02833848f, 
    -0.03023004f, 0.03862358f, -0.01545673f, 0.03245537f, -0.04550371f, 0.00611650f, 0.00487587f, 0.03387135f, 
    -0.01532647f, -0.00468781f, 0.04617238f, 0.06264422f, 0.06057544f, -0.03754302f, 0.01926235f, 0.02561922f, 
    -0.07858024f, 0.00089533f, 0.02087517f, -0.06680053f, -0.01124118f, 0.02385102f, -0.01422958f, -0.03098396f, 
    -0.03245502f, -0.00687679f, 0.05895037f, -0.02147506f, -0.02694464f, 0.01629608f, -0.03120808f, 0.02058593f, 
    -0.05881055f, 0.03140895f, -0.04797441f, 0.05232833f, 0.02101505f, -0.03975638f, -0.01885935f, -0.05327668f, 
    -0.01680281f, 0.03383663f, -0.05400759f, -0.01900302f, 0.03476169f, 0.02664044f, 0.03993720f, -0.04751240f, 
    -0.04485849f, 0.03293895f, 0.03623683f, -0.06728981f, 0.03833220f, -0.01422092f, -0.00390784f, 0.05145623f, 
    -0.06630732f, -0.00446214f, 0.00480256f, 0.03420532f, 0.00170737f, -0.03906868f, -0.03350212f, 0.04695484f, 
    -0.00990461f, 0.05192985f, 0.00780709f, -0.05928803f, 0.01571415f, 0.05152139f, 0.02105860f, 0.01220064f, 
    0.03054082f, -0.15647818f, 0.23127899f, -0.27341390f, -0.08282821f, 0.09048522f, 0.07930997f, 0.02170305f, 
    -0.08716275f, -0.07974423f, -0.01573547f, -0.14827740f, 0.10336169f, 0.17218670f, -0.00701923f, 0.35518113f, 
    0.02197276f, 0.11921666f, 0.04161081f, -0.18780574f, 0.11775128f, 0.02692696f, 0.01596503f, -0.09724726f, 
    0.04346246f, -0.22600228f, 0.07983670f, -0.18124714f, -0.08940812f, -0.00728434f, 0.00282781f, -0.10067305f, 
    -0.04127230f, -0.06121361f, 0.13691719f, -0.04161199f, 0.24587236f, -0.03646338f, 0.03191413f, -0.12505668f, 
    -0.06789402f, 0.04631361f, 0.00205601f, -0.07578422f, 0.00001705f, -0.00572576f, -0.00338126f, 0.03620123f, 
    -0.15538441f, 0.13763222f, -0.09068106f, 0.10916422f, -0.06080667f, 0.12455295f, 0.01043002f, 0.08938033f, 
    0.08519644f, 0.10349384f, 0.01322864f, 0.03110323f, 0.37666380f, -0.02184331f, -0.20854755f, 0.20639282f, 
    -0.03193264f, 0.08869854f, -0.08307019f, -0.04761107f, -0.07928940f, 0.03571349f, -0.11871813f, 0.01248587f, 
    0.18939501f, -0.03394212f, 0.05321840f, -0.00954045f, -0.10063516f, -0.03625378f, -0.05659478f, 0.11845212f, 
    0.12874638f, -0.00849174f, -0.00196202f, -0.12570126f, 0.05135529f, -0.02349327f, 0.02330588f, 0.17834443f, 
    0.03616191f, -0.08414008f, 0.02904177f, -0.07863203f, 0.01961314f, 0.10638610f, -0.08853883f, 0.03131158f, 
    0.13449721f, 0.12802385f, -0.15861169f, -0.17641780f, 0.09071968f, 0.01136765f, 0.00619031f, -0.09834941f, 
    -0.12311742f, -0.05201802f, -0.07849221f, 0.02087459f, -0.25842381f, -0.07791709f, -0.18290418f, 0.03725476f, 
    -0.01859979f, -0.09924199f, 0.02561612f, 0.08713317f, 0.10799558f, 0.06453008f, -0.08094338f, -0.09259084f, 
    0.08310271f, 0.02491841f, 0.10784987f, 0.06869692f, 0.08446784f, -0.05894984f, 0.06274301f, 0.06230664f, 
    -0.06304166f, 0.11076519f, -0.05334202f, 0.12566805f, -0.05061666f, -0.10450054f, 0.11627042f, -0.10175216f, 
    -0.08485202f, 0.15011321f, 0.02825563f, 0.07133296f, -0.04267269f, 0.00934552f, 0.08700964f, -0.02503394f, 
    0.13629960f, 0.13745859f, 0.20064358f, 0.17368843f, -0.05332031f, -0.05331507f, 0.11390495f, 0.07452038f, 
    -0.01051560f, -0.11200580f, 0.06922298f, 0.01480600f, 0.15410306f, 0.02435025f, -0.11069960f, 0.32197550f, 
    0.07776041f, -0.13171920f, -0.07459275f, 0.03953537f, 0.02253321f, 0.05160400f, 0.14131191f, 0.13926713f, 
    -0.13857523f, 0.07071414f, -0.16099848f, 0.10924325f, 0.05523400f, -0.07586523f, -0.01374554f, 0.07592817f, 
    0.12800604f, 0.16103837f, 0.02503519f, 0.01591070f, 0.28712749f, -0.13486190f, -0.06135665f, 0.07739156f, 
    0.03858097f, -0.03919882f, 0.01844587f, 0.04221563f, 0.11497982f, 0.03006929f, 0.06636015f, 0.05459155f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.18217605f, -0.04354869f, 0.07412913f, 0.07618008f, 0.02361525f, -0.01504203f, 0.01138645f, 0.05434318f, 
    0.06323002f, -0.06131268f, 0.12117759f, -0.02147910f, 0.03048206f, -0.01624613f, 0.05059593f, 0.10044553f, 
    0.00187561f, 0.05538829f, 0.07951359f, 0.01760477f, -0.00787614f, 0.06903313f, 0.09481251f, -0.10544505f, 
    0.01635147f, 0.08096956f, 0.04586663f, 0.05425650f, -0.00639103f, 0.06012943f, -0.07051169f, -0.06277485f, 
    0.07666967f, 0.10399912f, -0.11204733f, -0.01926594f, 0.02488633f, -0.01164341f, 0.00980563f, -0.00922794f, 
    -0.04776420f, -0.10115901f, 0.00623368f, 0.01992301f, 0.12083419f, 0.03555018f, -0.02166477f, 0.02946064f, 
    0.00819055f, -0.02600291f, -0.03326936f, -0.05720706f, 0.06422026f, 0.03239256f, 0.01023435f, -0.01584000f, 
    0.15984473f, 0.04670870f, 0.02095807f, 0.07860019f, 0.04522087f, 0.04597030f, 0.14653875f, -0.01322762f, 
    0.00897222f, 0.02051326f, 0.05238557f, 0.10451265f, 0.03605404f, -0.10307287f, 0.00079735f, -0.00474518f, 
    0.00813246f, 0.10047319f, 0.04632762f, -0.02843501f, 0.03870019f, -0.04335777f, 0.05898996f, -0.01863367f, 
    -0.01854527f, 0.00033863f, 0.06485844f, 0.06430694f, 0.07147304f, 0.08141953f, 0.00989680f, 0.01058817f, 
    0.02223452f, -0.00817403f, 0.02173563f, -0.04962017f, 0.00687418f, 0.00119734f, -0.01955537f, -0.00603537f, 
    0.05711551f, -0.01733403f, 0.03549089f, 0.13164558f, 0.03028825f, -0.00237567f, -0.02580032f, -0.03278359f, 
    -0.05314994f, 0.02108546f, 0.01991118f, -0.07576112f, -0.09007268f, 0.04073912f, -0.03722825f, 0.07972404f, 
    0.04672349f, 0.09417719f, 0.01801673f, 0.12595603f, 0.05385029f, -0.05855007f, 0.12566198f, 0.05409970f, 
    0.00068714f, 0.06707869f, 0.13639057f, 0.15416107f, 0.01746016f, -0.08792485f, -0.00742289f, 0.03251178f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.54365361f, 0.07094979f, -0.01271986f, -0.00853525f, 0.07290437f, -0.29917216f, 0.00407652f, -0.05191183f, 
    0.05310544f, -0.06580939f, -0.31996945f, 0.03122533f, 0.16978815f, -0.05275720f, 0.01764074f, 0.18347801f, 
    -0.07843714f, 0.00452363f, -0.07121601f, 0.04495364f, 0.03352191f, -0.40695757f, -0.01468728f, 0.18967488f, 
    0.00687586f, -0.44232574f, -0.06544509f, -0.23100284f, 0.16276754f, 0.21400239f, 0.04204574f, -0.14139803f, 
    0.14030598f, -0.07267070f, -0.62579280f, 0.27574483f, -0.08014376f, -0.13015802f, -0.45618159f, -0.06201036f, 
    0.13196376f, -0.01401509f, 0.00929531f, 0.25358254f, -0.19670913f, -0.14004801f, 0.32430646f, 0.08145479f, 
    0.18464775f, -0.08779529f, 0.01764261f, 0.06953352f, 0.28119573f, -0.00692564f, -0.01441688f, -0.03679741f, 
    -0.18248028f, 0.17639628f, 0.22719346f, 0.10987986f, -0.09921739f, -0.07978614f, -0.01780410f, 0.08020503f, 
    -0.02190092f, -0.06791948f, 0.24193069f, 0.19242674f, -0.35609114f, 0.02075784f, 0.00400907f, -0.29217911f, 
    -0.00673092f, 0.24007909f, 0.03210828f, -0.08386091f, 0.09916581f, 0.04149418f, -0.12578778f, -0.13215904f, 
    -0.05963243f, -0.05349723f, -0.24208865f, -0.46389031f, 0.13643017f, -0.10693555f, -0.02804389f, 0.27423221f, 
    -0.09465859f, 0.08228011f, -0.16425319f, -0.07915309f, -0.00473063f, -0.10123155f, 0.35500214f, 0.02695739f, 
    0.05968670f, 0.21874045f, -0.24976073f, -0.60760176f, -0.05718708f, -0.06243593f, -0.05214972f, -0.49715734f, 
    0.06864987f, -0.07785094f, -0.58680874f, 0.04307246f, 0.06816401f, -0.18098673f, -0.05252363f, -0.28002831f, 
    0.10790791f, 0.15962681f, -0.00931958f, -0.28820840f, -0.12469556f, -0.07825320f, 0.21264365f, 0.15600775f, 
    0.09100054f, 0.04159598f, 0.00974608f, -0.47606328f, 0.21797337f, 0.20568305f, -0.04000806f, -0.40055040f, 
    -0.01835999f, -0.11496606f, -0.21418101f, 0.18257664f, -0.02502907f, 0.12723334f, 0.04674685f, -0.06250026f, 
    -0.06108171f, -0.55506516f, -0.16669486f, 0.10978022f, 0.26152444f, 0.06302819f, -0.03481835f, 0.14313810f, 
    -0.18807128f, 0.03991882f, 0.00571681f, -0.05970067f, -0.00279619f, -0.10375467f, 0.08617488f, -0.09900026f, 
    0.06544945f, 0.07853768f, 0.00477877f, 0.21578667f, 0.26755989f, 0.09323671f, 0.00214994f, -0.32475480f, 
    -0.06802341f, 0.25699422f, 0.36762995f, -0.31221828f, 0.14330588f, 0.07845112f, -0.00675462f, -0.00313543f, 
    0.08791296f, -0.09966820f, -0.07357840f, 0.16764075f, 0.13915908f, 0.39023027f, -0.18416366f, 0.03274110f, 
    -0.25343567f, -0.07304539f, -0.05281948f, -0.00524613f, 0.22099264f, 0.03951013f, -0.18673360f, -0.08096732f, 
    -0.09104547f, 0.19218735f, 0.02533734f, 0.28690648f, -0.05313984f, 0.08666342f, -0.10844895f, -0.22362450f, 
    0.08682847f, -0.01626888f, -0.00420543f, 0.20016548f, -0.21019237f, 0.04202920f, 0.09987418f, -0.01117847f, 
    -0.08915459f, 0.07119451f, 0.14867730f, 0.07398955f, -0.11026975f, 0.07091683f, -0.38277975f, 0.12489977f, 
    -0.04262710f, 0.03667800f, 0.16970894f, 0.10000335f, -0.06985146f, -0.13589326f, -0.03398138f, 0.01956870f, 
    -0.32361552f, 0.06819894f, -0.14560781f, -0.03854962f, -0.08963041f, -0.25239691f, -0.17543675f, -0.03371849f, 
    0.05173544f, -0.00076842f, -0.16580045f, 0.13858047f, -0.08662104f, -0.00935470f, -0.10369296f, 0.35373968f, 
    0.02572853f, -0.19355242f, -0.17386277f, -0.05252863f, -0.15124449f, 0.13789518f, 0.04494570f, 0.18234663f, 
    -0.24752659f, 0.14744024f, -0.01599972f, -0.30326563f, 0.17494975f, 0.06753225f, 0.03727293f, 0.00200271f, 
    0.19482763f, -0.29581222f, 0.09590951f, -0.11912355f, -0.28759515f, -0.09730650f, 0.04996622f, -0.11780938f, 
    -0.07867009f, -0.41918856f, 0.11610983f, 0.08947670f, -0.00415143f, -0.02439087f, 0.02249911f, 0.00815229f, 
    -0.06180993f, -0.07261446f, 0.14216222f, 0.25982940f, 0.22352110f, 0.05700532f, -0.02375302f, -0.06314301f, 
    -0.00106870f, 0.06126153f, 0.11944325f, 0.27769226f, -0.06076885f, 0.35498154f, -0.29598564f, 0.28906041f, 
    -0.06501761f, 0.11862249f, 0.04270528f, 0.19186136f, 0.16578151f, -0.22263400f, -0.06949162f, 0.04682239f, 
    -0.23899071f, -0.15791537f, -0.34058073f, 0.02107144f, -0.03263674f, 0.18023062f, 0.24539851f, 0.07360970f, 
    0.20991462f, -0.15064327f, -0.08278982f, 0.14445789f, 0.08351306f, 0.01967964f, -0.16976337f, 0.03898478f, 
    -0.40642580f, 0.06584661f, 0.03293748f, -0.08378559f, -0.04064886f, 0.02793682f, -0.10442174f, 0.07016816f, 
    -0.27704823f, -0.03201747f, 0.15196104f, -0.13447331f, 0.00099812f, -0.04393534f, -0.32179624f, -0.34819132f, 
    -0.22846125f, -0.06208278f, -0.40634087f, 0.13866223f, 0.32994846f, -0.28645399f, 0.13449714f, 0.01380040f, 
    0.07451901f, 0.03828093f, -0.07612526f, 0.05085631f, -0.53063869f, -0.05820544f, 0.17805471f, -0.34008139f, 
    -0.54490632f, 0.03761937f, 0.17961265f, 0.10839593f, 0.19763626f, -0.18893054f, 0.05393337f, -0.21966976f, 
    -0.04706238f, 0.26180270f, -0.11516904f, -0.01311314f, 0.00097463f, 0.17570603f, 0.02713083f, -0.04537320f, 
    0.00499915f, 0.18095435f, -0.24857678f, 0.05158129f, -0.06467306f, 0.00937009f, -0.14421532f, -0.17673260f, 
    0.02111318f, -0.08937328f, 0.17013492f, 0.06972955f, 0.09178168f, -0.19693527f, 0.01229218f, -0.03638953f, 
    0.15967061f, -0.08987635f, -0.08096464f, -0.07222643f, 0.02671604f, 0.06308553f, -0.48705149f, -0.39821810f, 
    -0.35473636f, -0.20468284f, 0.19222933f, -0.01092288f, 0.21161540f, -0.34818482f, -0.08437270f, 0.08542803f, 
    -0.34445629f, 0.12893854f, 0.09362782f, -0.33882466f, -0.00574344f, -0.23965770f, -0.06777866f, 0.07176373f, 
    -0.49787700f, 0.24059018f, -0.04271838f, -0.29569018f, -0.10744826f, 0.04329826f, -0.05154983f, -0.27627084f, 
    -0.07357745f, -0.08558203f, 0.02796705f, 0.08720277f, 0.00418354f, -0.32155040f, -0.16692807f, 0.00004587f, 
    -0.02996682f, -0.24701792f, 0.07115998f, 0.08289783f, -0.38310570f, 0.06521601f, 0.02498927f, 0.14925285f, 
    0.12580116f, -0.24126272f, 0.22867253f, 0.24092108f, 0.24433079f, -0.20049794f, 0.15830438f, -0.01729869f, 
    -0.01756987f, 0.16476518f, -0.03256726f, -0.29011363f, -0.37770629f, -0.01219589f, 0.17944236f, 0.03440960f, 
    0.11779859f, -0.06796965f, 0.04878902f, 0.04476111f, -0.55903023f, -0.04858714f, 0.02119227f, 0.04394215f, 
    0.14714724f, 0.15009309f, 0.07313601f, -0.10186195f, -0.06753048f, -0.01406158f, 0.21405840f, -0.31951481f, 
    -0.13677566f, 0.03821718f, -0.13276841f, 0.12933081f, 0.00016202f, -0.22933334f, -0.35135919f, -0.01125081f, 
    -0.03262187f, -0.34166977f, 0.08891428f, -0.09114359f, 0.19930539f, -0.00059479f, -0.02264158f, 0.14990449f, 
    -0.47678190f, 0.04240660f, 0.02794684f, -0.57822943f, 0.21906881f, 0.05452310f, -0.08414654f, -0.29757389f, 
    0.10723514f, 0.02239664f, -0.13013335f, -0.12863111f, -0.08384158f, 0.22537711f, -0.14811847f, -0.03467239f, 
    0.03666929f, 0.03140537f, 0.14977218f, 0.22216295f, -0.01224379f, 0.00615954f, 0.22520696f, -0.25867334f, 
    -0.01746807f, 0.32663760f, -0.19346738f, 0.07245211f, -0.04841212f, 0.12417874f, 0.06260708f, 0.13659714f, 
    -0.14205354f, -0.01888573f, -0.01322456f, -0.11581240f, -0.46869168f, 0.07539909f, 0.12651736f, 0.16863005f, 
    -0.00192093f, -0.22891967f, -0.15641794f, 0.03769492f, 0.23743796f, -0.07751010f, 0.06706129f, 0.03326611f, 
    0.01164383f, 0.20722495f, -0.05537846f, -0.25705281f, -0.01015713f, -0.02599551f, 0.06209224f, 0.06092596f, 
    -0.03834565f, 0.17665294f, -0.16033807f, 0.16321461f, -0.18270126f, 0.00815505f, -0.05669039f, -0.17447589f, 
    0.05868097f, 0.05265786f, 0.05909947f, -0.35616961f, -0.03588261f, -0.08392940f, -0.04412754f, -0.01772488f, 
    0.00521367f, -0.21478614f, -0.01147539f, -0.23008674f, 0.29402649f, -0.29822364f, 0.01636302f, 0.08871370f, 
    0.12732886f, -0.29866058f, 0.04652845f, -0.13127108f, -0.05497713f, -0.22283848f, 0.17016110f, -0.04310277f, 
    0.08786918f, -0.16975804f, 0.06240320f, -0.45346850f, 0.26262936f, 0.12848957f, 0.08770300f, -0.00106607f, 
    -0.16878307f, 0.04532797f, -0.07807341f, 0.00933618f, 0.06079261f, 0.04168408f, -0.00917540f, 0.07460868f, 
    0.25654483f, -0.10787802f, 0.03858132f, -0.28861582f, 0.00943392f, -0.08221928f, 0.05115403f, 0.25066373f, 
    0.10799123f, -0.00273822f, 0.10118993f, -0.09756465f, 0.05761288f, 0.08571362f, -0.10120895f, -0.13560170f, 
    -0.02792057f, -0.03603683f, 0.12687315f, -0.08137017f, 0.20613483f, -0.03484108f, 0.18038297f, 0.19190817f, 
    0.19782746f, 0.06878342f, 0.01828554f, 0.00765596f, 0.08247849f, -0.16538930f, -0.03712298f, -0.14279480f, 
    0.19316481f, -0.09708115f, -0.03452039f, -0.18641625f, -0.05377136f, 0.25077936f, -0.15209010f, 0.00583751f, 
    -0.00001331f, 0.24649900f, -0.31385207f, -0.47734594f, 0.02033512f, -0.63280821f, 0.00684946f, -0.20685418f, 
    0.03493107f, 0.27490836f, -0.22904110f, 0.04525289f, 0.09572224f, 0.16868138f, -0.10122427f, -0.09015951f, 
    -0.07938236f, -0.02130129f, 0.05698100f, -0.38026386f, 0.08231085f, 0.06135644f, -0.13543163f, -0.13002096f, 
    0.01506690f, 0.23700707f, 0.09602069f, 0.13758086f, 0.28939682f, -0.06208635f, 0.03563194f, -0.03754336f, 
    -0.10884098f, -0.15837345f, -0.41109037f, 0.16917139f, 0.05372369f, 0.16959673f, 0.01569738f, -0.04917204f, 
    0.13821165f, 0.05848131f, 0.27646509f, -0.12329995f, -0.34123388f, 0.02676122f, 0.04618630f, -0.14152950f, 
    0.15379973f, -0.04242628f, -0.14815927f, -0.04983092f, -0.02778263f, -0.19923541f, 0.07355647f, 0.04369177f, 
    0.00916160f, 0.06675348f, -0.05170592f, -0.08455043f, -0.63227564f, -0.07020271f, -0.03038088f, 0.22255732f, 
    -0.55653298f, 0.19459628f, 0.27707800f, 0.08437228f, -0.29467621f, 0.13936551f, -0.68495417f, -0.09195912f, 
    -0.43670896f, -0.12951437f, 0.01686133f, -0.06375518f, -0.01235472f, 0.02352088f, -0.02468004f, 0.04662240f, 
    -0.01932675f, -0.01198621f, -0.05376774f, 0.02223125f, -0.02505536f, 0.01631317f, 0.21350859f, 0.02780657f, 
    -0.04426550f, 0.25531304f, 0.05666620f, -0.03500479f, -0.02706170f, -0.01908782f, -0.00356284f, 0.27520651f, 
    -0.58137959f, 0.00119410f, 0.10340473f, -0.02207479f, 0.18334691f, 0.22113109f, -0.09557729f, -0.49696010f, 
    0.01200672f, 0.22584437f, 0.28631642f, 0.03315584f, -0.14137761f, -0.00153324f, -0.17826360f, 0.12971070f, 
    0.19850518f, 0.03258799f, -0.14282690f, 0.02676168f, -0.22048895f, 0.21312730f, -0.02671538f, 0.22524072f, 
    0.15419436f, -0.34034705f, -0.01904286f, 0.18361603f, 0.07060536f, -0.47488153f, -0.20113452f, -0.02109485f, 
    0.07754390f, 0.03428160f, 0.06341689f, 0.18529120f, 0.01018061f, -0.02113609f, -0.09376755f, -0.40656796f, 
    0.07829109f, -0.10566366f, 0.27581459f, -0.00644045f, 0.01804793f, -0.01624758f, -0.05588926f, 0.02053013f, 
    -0.01687476f, 0.14950605f, -0.01086114f, -0.15386039f, 0.04276926f, -0.06033080f, 0.01123979f, 0.29334006f, 
    0.13456693f, -0.03919296f, -0.33915320f, 0.07612361f, -0.08083118f, 0.16904598f, -0.07222448f, -0.06016774f, 
    0.32241926f, -0.23658925f, -0.03144707f, -0.12443696f, 0.00095373f, 0.20181856f, 0.07147948f, -0.07448015f, 
    0.12312640f, -0.08035354f, -0.68160892f, -0.00775951f, 0.18061212f, 0.02260557f, 0.07622486f, 0.06930239f, 
    0.27675930f, -0.01049850f, -0.26600063f, 0.23896995f, 0.08192663f, 0.29881844f, 0.19400828f, 0.07335672f, 
    -0.00677447f, 0.14424965f, -0.05948975f, -0.03797279f, -0.20389701f, 0.07680286f, 0.07786907f, -0.29510680f, 
    0.01115923f, -0.34559029f, -0.08573484f, -0.03919150f, 0.30222723f, -0.09457621f, 0.05483051f, 0.04909859f, 
    -0.27261814f, 0.31561080f, 0.00717885f, -0.18546923f, -0.02854430f, -0.00832793f, 0.09192724f, 0.07058211f, 
    -0.09824594f, 0.06339630f, 0.05932325f, 0.00429152f, -0.13861685f, 0.06616487f, 0.16805616f, 0.07958300f, 
    -0.05180359f, -0.06675387f, 0.03010749f, -0.20052357f, -0.03272541f, 0.06889684f, -0.02383437f, -0.13273636f, 
    0.05258800f, -0.06103023f, -0.04423599f, -0.13297693f, 0.11777189f, -0.30992174f, 0.22660853f, -0.00578152f, 
    -0.09774669f, -0.48999655f, -0.40615612f, 0.05346552f, -0.08635942f, 0.02507737f, 0.21033722f, 0.05577907f, 
    -0.20168826f, -0.03490488f, 0.14809656f, 0.18748353f, -0.06687514f, 0.28796232f, -0.05027600f, -0.09773008f, 
    0.23898172f, -0.38643107f, 0.03784481f, 0.23899244f, -0.03647336f, -0.21830906f, -0.00895662f, 0.07197337f, 
    -0.06181078f, -0.48926032f, 0.26565593f, 0.01245374f, -0.05556915f, 0.13661799f, -0.19597086f, -0.07039455f, 
    -0.03380946f, -0.05461882f, -0.08756228f, -0.04647901f, -0.19616406f, -0.35033414f, -0.05501758f, -0.56337869f, 
    -0.14286320f, -0.00722093f, -0.01540673f, 0.29035810f, -0.00470870f, -0.01046035f, -0.00201322f, -0.36013740f, 
    -0.16441682f, -0.24025352f, 0.18880597f, -0.16789751f, 0.04530267f, 0.27299035f, -0.01986079f, 0.22101896f, 
    -0.11279299f, 0.07907525f, 0.07810634f, -0.22766286f, -0.04449103f, 0.00518837f, -0.07321375f, -0.01665246f, 
    -0.24941994f, 0.00385777f, 0.12306758f, 0.16743416f, 0.03330128f, 0.04420420f, -0.05034894f, -0.12746772f, 
    -0.00415521f, 0.03382276f, 0.18211763f, -0.18598424f, -0.09011002f, -0.08378850f, -0.36493930f, -0.30624124f, 
    0.01704025f, -0.17695788f, 0.02387763f, 0.08462584f, 0.07620832f, -0.21790884f, 0.01723011f, -0.18159282f, 
    -0.19868676f, -0.33309364f, 0.11418603f, 0.13239729f, -0.10012618f, 0.22572188f, 0.16843900f, -0.03183870f, 
    0.15717153f, 0.18679138f, 0.01806569f, -0.18321326f, -0.14735183f, -0.20851925f, 0.02670338f, -0.05643785f, 
    0.10479680f, -0.08665808f, -0.02548688f, 0.06812395f, -0.28897953f, -0.00387610f, 0.19064717f, -0.04355768f, 
    0.04823596f, -0.21436790f, -0.42786655f, -0.55131322f, -0.03829924f, 0.02529750f, -0.42956689f, 0.25317505f, 
    0.23131719f, -0.02719451f, -0.12685540f, -0.36655882f, -0.25370821f, 0.20795965f, -0.23214249f, 0.24907753f, 
    -0.04884745f, -0.09048947f, -0.11275562f, -0.00880297f, -0.16036336f, 0.01021847f, 0.17193416f, -0.11483566f, 
    -0.09125841f, -0.03683533f, -0.23935954f, -0.10749445f, -0.28533506f, -0.22496781f, 0.08176986f, -0.03822430f, 
    0.01070724f, 0.11354675f, 0.22795726f, 0.16197467f, 0.03520003f, -0.04741845f, 0.17571047f, 0.00748548f, 
    0.02384681f, -0.24046518f, 0.11654752f, -0.11886725f, -0.02272433f, 0.02896730f, -0.04278971f, 0.24397534f, 
    0.06116108f, 0.02189296f, 0.11510755f, 0.00136520f, 0.25859341f, 0.05215393f, -0.04777239f, 0.04272222f, 
    -0.03462084f, -0.11353642f, 0.07814199f, 0.21697213f, -0.25964457f, 0.05289852f, -0.18364093f, -0.14315270f, 
    -0.28745374f, -0.22664866f, -0.27480733f, 0.10486276f, -0.04183431f, 0.09056652f, -0.06105313f, 0.24333452f, 
    0.08675766f, -0.15138881f, -0.12815133f, 0.11112975f, 0.02493087f, 0.26408702f, 0.03296193f, -0.07955051f, 
    0.15691964f, 0.04049627f, 0.12760772f, 0.08798031f, -0.05141121f, -0.00866870f, 0.08422404f, -0.35315996f, 
    -0.20649287f, 0.02623256f, 0.27106720f, 0.03698332f, -0.00417901f, 0.18883155f, 0.08868332f, 0.11897074f, 
    -0.02522437f, 0.10180125f, -0.03056409f, 0.13992737f, 0.02460201f, 0.24076387f, 0.06146783f, 0.14902371f, 
    -0.18704571f, 0.03666485f, -0.26267153f, -0.06170747f, -0.06941561f, -0.15578197f, -0.10806553f, -0.01930857f, 
    0.15587369f, -0.24748065f, 0.03444289f, 0.01691726f, 0.10113671f, -0.23634213f, -0.30464977f, -0.05104355f, 
    0.02270507f, -0.08144011f, -0.07112043f, 0.07476818f, 0.18359852f, 0.03101446f, -0.23927701f, -0.02591916f, 
    -0.30926779f, -0.30486590f, -0.36131266f, -0.15072751f, 0.02225208f, 0.02327807f, 0.15044597f, -0.09974785f, 
    0.55644614f, 0.08742319f, -0.47743714f, -0.44329211f, -0.34375224f, -0.09464845f, 0.18144920f, -0.01811624f, 
    -0.01555811f, -0.17022483f, 0.28548953f, -0.03823993f, 0.25290197f, 0.05174799f, -0.25131920f, -0.18466742f, 
    0.04189678f, -0.00316149f, -0.26431838f, 0.10277753f, -0.07465056f, -0.25878581f, -0.08220746f, -0.23817383f, 
    -0.00863341f, 0.01972239f, -0.35228318f, -0.21247402f, 0.02903310f, 0.09493076f, 0.04795753f, -0.07319808f, 
    -0.02893702f, -0.06521953f, 0.06505483f, 0.07693473f, 0.01559844f, 0.16731483f, 0.17597066f, -0.22772530f, 
    0.07578882f, 0.06849346f, 0.28915590f, -0.08112638f, -0.25202441f, -0.09291130f, 0.07447251f, 0.05321248f, 
    0.23039755f, 0.14782383f, 0.07468745f, -0.58067912f, 0.13582489f, 0.00351618f, -0.04978121f, -0.08115895f, 
    0.05768659f, -0.31077215f, 0.02080858f, -0.10395797f, -0.35114241f, -0.38301641f, 0.04210505f, 0.09185362f, 
    0.06903762f, 0.01625527f, 0.03267930f, 0.11676133f, -0.09472701f, -0.48827976f, 0.06644708f, 0.03366953f, 
    -0.11721966f, 0.30337870f, 0.08515128f, 0.08375311f, -0.57002544f, -0.07019143f, -0.03469960f, 0.36469874f, 
    0.19710730f, -0.08268408f, -0.55169338f, -0.14444910f, -0.01251858f, 0.18439844f, 0.16775896f, 0.05592808f, 
    0.01979261f, 0.18707511f, -0.00566731f, -0.04762505f, -0.67465955f, 0.13838200f, -0.05020145f, -0.16495956f, 
    -0.22546747f, -0.01678887f, -0.33737156f, -0.37969890f, 0.02358657f, 0.28616521f, 0.11728427f, -0.02229866f, 
    -0.26176813f, 0.17093137f, -0.02703921f, 0.28301477f, -0.12839225f, -0.25038314f, -0.32203761f, -0.00694082f, 
    -0.09723709f, 0.04134413f, -0.08007578f, -0.07712608f, 0.04555593f, -0.05698346f, -0.10407874f, -0.05327122f, 
    -0.05257787f, -0.22639084f, -0.20476589f, 0.07327710f, -0.00076009f, 0.01040578f, 0.00865212f, -0.04820497f, 
    0.10679208f, 0.00234839f, 0.19086161f, -0.16488315f, 0.15023240f, 0.24042639f, 0.09867430f, 0.08146614f, 
    0.07139739f, -0.01818165f, -0.35768569f, -0.05788429f, 0.09563725f, 0.00978199f, -0.06926077f, -0.14427447f, 
    0.28704253f, -0.00228449f, -0.05816054f, 0.19930926f, -0.19099154f, -0.13117917f, -0.06055292f, -0.11033264f, 
    0.02239970f, 0.14711455f, 0.25599027f, -0.11297365f, -0.06302074f, 0.04594024f, -0.07181823f, -0.05204264f, 
    0.01511730f, 0.01922699f, -0.21271749f, -0.12967707f, 0.05557793f, -0.05137695f, -0.38901839f, 0.38940978f, 
    -0.00951573f, -0.09376223f, 0.17630693f, 0.02275421f, 0.11258151f, -0.23816261f, 0.02945109f, -0.09211682f, 
    0.01371926f, -0.03158956f, -0.01828742f, 0.39316851f, 0.02772473f, 0.03488094f, -0.39932930f, 0.47525597f, 
    -0.19037019f, 0.17688702f, 0.12264724f, 0.21807408f, 0.08475958f, -0.30001694f, -0.03907818f, -0.33080319f, 
    0.28978792f, -0.09948919f, 0.05004947f, -0.08431185f, -0.02155881f, -0.00002151f, 0.07739483f, -0.07505260f, 
    -0.34352717f, -0.32891539f, 0.18356615f, -0.20948519f, 0.21046679f, 0.04343582f, -0.07831522f, 0.12429722f, 
    -0.32780385f, 0.07536398f, 0.04139444f, -0.10402726f, -0.00264772f, -0.06767574f, -0.12825876f, -0.37908217f, 
    -0.05181675f, 0.26411250f, -0.04849019f, 0.27462399f, 0.36123919f, -0.08541846f, -0.01340596f, -0.28511748f, 
    0.16691902f, 0.10464705f, -0.38880566f, -0.24353875f, -0.29578352f, 0.05620052f, 0.11673962f, -0.02012019f, 
    0.01921313f, -0.32884905f, -0.03545247f, 0.10454272f, 0.11598939f, -0.76457500f, -0.06488226f, 0.06798095f, 
    0.22886182f, -0.05856755f, -0.02298779f, 0.04513955f, -0.93543351f, 0.02688880f, 0.06425656f, 0.06603186f, 
    0.19540958f, -0.32250699f, 0.03778934f, 0.26069084f, 0.01273663f, -0.05889321f, -0.11837692f, 0.21257389f, 
    -0.29527658f, 0.06758909f, -0.44000074f, 0.23196420f, 0.11955964f, -0.24607672f, -0.15928794f, -0.02967894f, 
    0.04207361f, 0.34575155f, -0.14983317f, 0.02589570f, -0.16248646f, -0.02257972f, 0.26234457f, -0.29587612f, 
    -0.41785005f, -0.00507802f, -0.26839700f, -0.08981542f, -0.27962548f, 0.10440814f, -0.00811825f, 0.13844427f, 
    -0.15443738f, -0.02898828f, -0.07023475f, -0.01843847f, -0.02278206f, 0.16811907f, 0.06522471f, 0.01047950f, 
    -0.03790838f, 0.04728410f, 0.27850035f, 0.37245974f, 0.06840894f, 0.08184462f, -0.05285638f, -0.25954092f, 
    -0.06432507f, -0.31072497f, 0.21070647f, -0.00949725f, -0.20149952f, 0.26866740f, -0.03985657f, 0.15457356f, 
    -0.09003146f, 0.11193591f, -0.08615475f, 0.29898071f, -0.14138213f, -0.02998415f, 0.21916279f, -0.29494774f, 
    -0.09865756f, 0.09263391f, 0.21330200f, 0.24158885f, -0.29721382f, -0.39199567f, -0.06457271f, 0.01306804f, 
    -0.10449531f, 0.03661282f, 0.28149781f, 0.12908411f, -0.06580611f, -0.12403353f, -0.01474174f, -0.05421108f, 
    0.10246177f, -0.29857281f, 0.03235651f, -0.48630536f, -0.23983811f, -0.05293620f, -0.04364319f, -0.45406565f, 
    -0.12178716f, -0.01149468f, 0.07709496f, -0.24065498f, 0.05488137f, -0.06772949f, 0.16051054f, -0.16728330f, 
    -0.01321303f, -0.29807520f, 0.00836386f, -0.35048869f, -0.09463352f, -0.23225228f, 0.05920240f, 0.32602346f, 
    0.29829895f, 0.21460472f, -0.49459589f, 0.16887631f, -0.23746656f, -0.43416265f, -0.10011361f, 0.01321915f, 
    -0.36445028f, -0.00973359f, -0.08506707f, -0.19883147f, -0.04815464f, -0.12948978f, -0.16634129f, -0.07942329f, 
    0.15090418f, 0.00582366f, -0.05754429f, 0.06859667f, 0.10674557f, -0.03723083f, -0.14297464f, -0.01770424f, 
    0.15148191f, 0.01294109f, 0.09830243f, 0.04549313f, 0.05426466f, -0.01173552f, 0.17357457f, -0.27281174f, 
    -0.23631398f, -0.04880257f, 0.03607520f, 0.04068298f, -0.12531081f, -0.03069089f, -0.06768059f, 0.24597478f, 
    0.08145630f, -0.19385186f, -0.14216429f, -0.01327686f, -0.07117213f, 0.07627350f, -0.06248603f, 0.10528641f, 
    0.20394754f, -0.03328241f, 0.22383831f, 0.15297292f, 0.29756039f, 0.14247079f, 0.03883324f, 0.13164030f, 
    -0.08865149f, 0.08194087f, 0.09396118f, 0.13727021f, -0.08115625f, -0.04738115f, -0.29898602f, 0.05533001f, 
    0.03211872f, -0.39322141f, 0.00163621f, -0.05983731f, -0.05401057f, 0.28999412f, 0.07855362f, 0.09418762f, 
    -0.01184167f, -0.23905104f, -0.08894806f, 0.08317561f, -0.27762377f, -0.12204855f, -0.00048228f, 0.26845613f, 
    0.37603948f, -0.43078279f, 0.03956512f, -0.04274158f, 0.01359628f, -0.08000942f, 0.20145446f, -0.25200328f, 
    -0.16656905f, 0.16968010f, -0.18754451f, -0.08870628f, -0.42268112f, 0.09976993f, -0.00946410f, 0.07546391f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01784453f, 0.01939126f, -0.10889757f, -0.08621883f, 0.01025767f, -0.01494104f, -0.05132244f, -0.11470757f, 
    0.02001872f, 0.00376111f, 0.06219101f, 0.04140384f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
