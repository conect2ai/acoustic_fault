#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.32984179f, -0.36871356f, 0.38193437f, -0.53148186f, -0.74862432f, 0.45105875f, 0.33495104f, 0.16048709f, 
    -0.26405466f, 0.70477062f, -0.28994492f, -0.09662905f, 0.09146994f, 0.07829053f, 0.27991909f, 0.13328753f, 
    0.03797024f, -0.05353970f, -0.22889507f, -0.19888362f, 0.07649924f, -0.10437314f, 0.08326071f, 0.17412567f, 
    0.07134592f, -0.46127003f, -0.63784736f, -0.17322226f, 0.28369325f, 0.44051325f, -0.35689732f, -0.32549810f, 
    -0.19695619f, 0.11398707f, 0.05536163f, -0.03605663f, -0.20453928f, -0.22997917f, 0.26345861f, 0.05576426f, 
    -0.09387779f, 0.29700807f, 0.08121384f, -0.32116151f, -0.11419433f, -0.25672385f, -0.19546181f, -0.10745210f, 
    -0.22237654f, -0.08083034f, 0.32341975f, 0.33486843f, 0.15881668f, -0.07999070f, 0.29090145f, 0.22228496f, 
    0.07514981f, 0.08234299f, -0.22705556f, 0.08670703f, -0.27135786f, 0.04613978f, 0.28676468f, -0.23801784f, 
    -0.12536931f, -0.18063131f, 0.17830421f, -0.06569876f, -0.15964192f, 0.06989568f, -0.25156537f, -0.25156507f, 
    -0.08848669f, -0.27401087f, -0.42331749f, 0.28028464f, -0.02233391f, -0.29095399f, 0.18177523f, -0.43257228f, 
    0.00750015f, 0.25399116f, -0.56064457f, -0.54180092f, 0.32248560f, 0.27625376f, -0.39988238f, -0.30131748f, 
    0.11938244f, 0.32708552f, -0.30769110f, 0.05457032f, -0.17028673f, -0.06067733f, 0.20225661f, 0.32509056f, 
    -0.29331416f, 0.30293646f, 0.29642382f, -0.18541463f, -1.24630749f, 0.13625351f, -0.18338367f, -0.85512167f, 
    -0.60973901f, 0.40999231f, 0.12959445f, -0.30669752f, 0.18600452f, 0.76167423f, -0.02241456f, -0.05218653f, 
    -0.05444325f, 0.05269688f, -0.27516112f, -0.07313688f, -0.21043181f, -0.12331340f, -0.08319525f, -0.17916824f, 
    -0.10923678f, 0.01579148f, -0.09917574f, -0.08352189f, -0.02242484f, -1.17667222f, -0.52398807f, 0.00663247f, 
    0.10571618f, 0.06810705f, 0.59397572f, 0.60306060f, -0.07650038f, -0.03272463f, 0.46800438f, 0.36631420f, 
    -0.06228802f, 0.14466541f, -0.42111748f, -0.42744577f, 0.05436966f, 0.02219331f, -0.16523360f, 0.27836442f, 
    -0.06774128f, 0.12226546f, -0.07603119f, 0.10476771f, 0.06610535f, -0.17448737f, -0.36640647f, 0.11578733f, 
    0.13891013f, 0.45808962f, 0.40036824f, -0.64233685f, -0.04319533f, -0.29673967f, -0.08291792f, 0.12656759f, 
    -0.07530819f, -0.20779219f, -0.09090126f, 0.26227701f, -0.07490593f, 0.00067960f, 0.29329315f, -0.26481453f, 
    -0.24553160f, -0.31418777f, -0.32593867f, 0.08047578f, 0.21431352f, 0.21282177f, -0.21895701f, 0.29781947f, 
    -1.04518747f, 0.03710267f, -0.13852274f, 0.67397267f, -0.23664257f, -0.53354919f, -0.69263017f, -0.48520303f, 
    0.46864334f, 0.35506496f, -0.00125416f, 0.01756947f, -0.35723624f, -0.29947028f, 0.18602037f, 0.12666355f, 
    -0.06461212f, 0.13907129f, 0.07125986f, 0.14046283f, -0.40573519f, -0.08587283f, -0.00737478f, -0.08943091f, 
    -0.34280223f, -0.41022587f, -0.52809864f, -0.43051437f, -0.06573062f, -0.03103269f, -0.12941632f, -0.67461342f, 
    -0.49381700f, -0.23460200f, -0.30395040f, -0.14614746f, -0.10544375f, 0.20928563f, -0.37644571f, -0.01240018f, 
    -0.34360898f, -0.07584619f, -0.35195577f, -0.43277672f, -0.41725940f, -0.06275871f, -0.23329443f, 0.14618179f, 
    -0.15196469f, 0.54428858f, 0.90962690f, 0.50155461f, -0.33834052f, 0.35934821f, -0.65660381f, -0.43320128f, 
    -0.23507050f, -0.34253606f, -0.37960941f, -0.10597431f, 0.15659110f, 0.13322443f, 0.27187741f, -0.04146249f, 
    -0.09264031f, -0.22990550f, 0.19488612f, 0.12750195f, 0.15880704f, -0.07389084f, 0.02873576f, -0.13991421f, 
    0.08716357f, 0.25067264f, 0.46584737f, 0.25123388f, 0.26443067f, 0.09033249f, 0.11516107f, 0.02126000f, 
    -0.00411235f, -0.38098809f, -0.34888572f, -0.29761001f, 0.28474662f, -0.14991668f, 0.03192155f, -0.10992204f, 
    0.01860943f, 0.18163738f, -0.22328201f, -0.25535923f, 0.16701713f, -0.08837008f, -0.07597906f, 0.06842797f, 
    0.05124291f, 0.11871140f, 0.00474258f, -0.30930334f, -0.20319892f, -0.27642906f, 0.18390961f, -0.31931084f, 
    -0.08464863f, -0.29477361f, -0.44004425f, -0.12465445f, 0.34575054f, 0.14376535f, -0.20301424f, 0.21696863f, 
    0.19568028f, -0.11405827f, 0.04599367f, 0.00529981f, -0.22106920f, -0.02617457f, -0.46072695f, -0.36779907f, 
    -0.11811088f, -0.12366086f, -0.43306467f, -0.43519059f, -0.29841316f, -0.69883978f, 0.34866583f, 0.81656826f, 
    0.35204330f, 0.64644343f, -0.43721572f, -0.72601104f, -0.49096557f, 0.43282712f, -0.08495954f, 0.12678216f, 
    -0.49990720f, -0.03488429f, 0.27424374f, 0.05067204f, -0.20707013f, 0.18948659f, 0.03372939f, -0.11803073f, 
    -0.05526381f, 0.18420653f, -0.00651921f, -0.05927569f, -0.20804575f, -0.14326221f, -0.39939928f, -0.24501005f, 
    -0.06673836f, -0.12381237f, -0.23740166f, -0.19456957f, -0.23865786f, 0.28622299f, -0.29765874f, -0.18249239f, 
    0.02073761f, 0.02241495f, 0.07019626f, -0.23965099f, 0.14712363f, 0.29247320f, 0.32376722f, -0.29683554f, 
    0.28292811f, -0.20888463f, 0.24588329f, 0.13702273f, -0.34552011f, -0.19102708f, -0.41838369f, -0.38062340f, 
    0.09983994f, -0.20487584f, -0.39874160f, 0.12445674f, 0.33803886f, -0.42763892f, 0.03431342f, 0.20878132f, 
    0.35515276f, -0.22543937f, 0.14631757f, 0.28227490f, -0.36986873f, 0.10199187f, -0.04749645f, 0.16629760f, 
    -0.20237665f, -0.19400679f, 0.04920398f, 0.26324409f, 0.38188559f, -0.21156859f, 0.05553053f, -0.25848982f, 
    -0.18833031f, -0.24249481f, -0.52351779f, -0.01158075f, 0.11558614f, -0.70376033f, -0.52085018f, -0.37719727f, 
    -0.58024305f, -0.22053006f, -0.06576469f, 0.16659983f, -0.09865287f, -0.05846842f, -0.26636621f, -0.69244403f, 
    0.22843201f, -0.17524625f, 0.12202197f, -0.24234770f, 0.06330494f, -0.19228648f, 0.05465833f, 0.38976225f, 
    -0.24184346f, -0.76303804f, 0.12410071f, 0.28006959f, 0.62427706f, 0.22530486f, -0.52191979f, 0.15427123f, 
    0.38510647f, 0.42426381f, -0.04691902f, -0.33232155f, 0.24315469f, 0.02250247f, 0.21749651f, -0.17571308f, 
    0.01944738f, -0.02032710f, -0.28629321f, 0.13483743f, 0.10023753f, -0.10367609f, -0.13006362f, 0.22936167f, 
    -0.05953726f, 0.46468827f, 0.02294839f, 0.15633185f, -0.09915414f, -0.43036565f, -0.21832775f, -0.51106703f, 
    -0.16773269f, -0.27845398f, -0.52264494f, 0.27620217f, -0.12382547f, 0.00550820f, 0.24330993f, 0.26754057f, 
    -0.07863531f, -0.00209598f, 0.03468769f, 0.12487534f, 0.07993504f, -0.38414824f, -0.20000707f, -0.09241029f, 
    -0.35432038f, -0.37690872f, 0.60910147f, -0.99695092f, -0.15067391f, 0.08764678f, 0.02912342f, 0.15492809f, 
    0.56397080f, 0.22487257f, -0.14563596f, -0.43321782f, 0.10142941f, 0.00891253f, -0.14735688f, -0.23247884f, 
    0.02864441f, -0.24142809f, -0.32442445f, 0.09584429f, 0.22119057f, 0.17371707f, 0.05642646f, -0.37038550f, 
    -0.23483618f, 0.31908843f, 0.21511671f, 0.37031814f, -0.29077932f, -0.00816162f, -0.57769406f, -0.16483040f, 
    -0.11738449f, 0.03747881f, 0.14319091f, 0.39019647f, 0.12133270f, -0.20773385f, -0.39280656f, -0.17289960f, 
    0.19589916f, 0.26303485f, -0.24384214f, -0.13201846f, -0.14944421f, 0.14734983f, -0.16591443f, 0.13034676f, 
    0.07815778f, 0.24520557f, 0.25547481f, 0.07480285f, 0.19940910f, 0.28502274f, 0.55061156f, 0.44624990f, 
    0.11676067f, -0.47723013f, -0.32855240f, -0.14257674f, -0.37004280f, -0.17295091f, -0.25614604f, 0.02525585f, 
    -0.02523270f, 0.12907390f, 0.19627826f, 0.02172307f, 0.18936290f, -0.35075617f, 0.02908882f, 0.15319997f, 
    -0.20151210f, -0.10333347f, 0.04718566f, 0.25791705f, -0.31214985f, 0.98535591f, -0.34605777f, 0.03122560f, 
    0.05776735f, -0.45029953f, 0.00916026f, 0.13619509f, -0.33688080f, -0.25785714f, -0.33908752f, -0.03175852f, 
    -0.12717848f, -0.06731946f, -0.24966034f, 0.33684883f, 0.21598031f, 0.19734848f, 0.10593033f, -0.40524635f, 
    -0.21400912f, -0.42069089f, -0.26992682f, -0.13002695f, 0.06889385f, -0.56708735f, -0.45610085f, -0.54341233f, 
    -0.39302227f, -0.11743464f, -0.56925666f, 0.23942645f, 0.17166738f, 0.07103762f, 0.39104193f, -0.25609460f, 
    -0.23302200f, -0.24035914f, 0.04829195f, -0.59131199f, -0.05871027f, 0.12604700f, -0.10124341f, 0.10139231f, 
    0.31628293f, 0.32590574f, -0.11461799f, 0.11867932f, -0.07639683f, -0.26826990f, 0.47284538f, -1.15758884f, 
    -0.86630404f, -0.33798516f, 0.55117315f, 0.61577255f, 0.14812964f, 0.08807836f, 0.70982319f, -0.07284405f, 
    -0.01036581f, -0.13065673f, 0.07768507f, 0.16661121f, 0.30356938f, -0.24720907f, -0.28118283f, 0.23914716f, 
    -0.10352325f, -0.22449717f, 0.25280720f, -0.00389503f, -0.33024362f, -0.04702562f, 0.23461291f, 0.10164269f, 
    -0.10880659f, -0.17409736f, -0.25976500f, -0.41170543f, -0.53130102f, -0.14643535f, -0.05205399f, 0.20449495f, 
    0.15554498f, -0.39528197f, 0.18609372f, 0.36625755f, -0.00387739f, 0.12101082f, 0.31994531f, -0.11275455f, 
    0.08587302f, 0.20055000f, -0.15900065f, -0.16526361f, -0.05022274f, 0.20354600f, 0.27791685f, -0.09147169f, 
    0.32707474f, 0.29110539f, -0.22104786f, 0.31851232f, 0.31980318f, -0.26693434f, 0.10592518f, -0.11784863f, 
    0.08978460f, 0.29317951f, -0.40165064f, -0.22649558f, -0.04531437f, -0.17853788f, -0.11997710f, 0.26731065f, 
    0.10341583f, 0.04409517f, 0.05414832f, -0.37981674f, 0.10492101f, -0.31808415f, -0.15499499f, 0.27095547f, 
    0.13827352f, 0.15434057f, 1.27180839f, -0.14017802f, -0.18659045f, -0.59329391f, -1.09535050f, 0.62761092f, 
    0.01685061f, 0.11697360f, 0.19488648f, -0.05757193f, 0.21973570f, -0.03182994f, -0.03338031f, 0.24605677f, 
    -0.22136183f, -0.15510027f, -0.05767251f, 0.07338831f, 0.26218289f, -0.14335710f, 0.00281155f, -0.13107334f, 
    -0.04234570f, 0.08855209f, -0.00996679f, 0.39629474f, 0.28025004f, -0.05227765f, -0.40166476f, -0.28085151f, 
    -0.06880298f, 0.17957816f, 0.21147603f, 0.03106388f, 0.03161194f, 0.13773234f, 0.26988456f, -0.36341619f, 
    -0.34447214f, 0.09531654f, 0.14935598f, 0.26012433f, 0.19123831f, -0.16477773f, -0.22879164f, 0.27310207f, 
    -0.11835353f, -0.20084935f, 0.01135098f, -0.15706147f, 0.67976874f, 0.11504767f, 0.07281358f, -0.23595858f, 
    0.42214414f, -0.13666697f, 0.38669500f, -0.34606940f, -0.50152951f, -0.24637663f, -0.03427029f, -0.08096315f, 
    0.05613726f, -0.22400562f, 0.33503342f, 0.14055879f, 0.07572692f, -0.01304718f, -0.02391908f, -0.15077810f, 
    -0.09434833f, -0.01496649f, 0.08434425f, 0.05983917f, -0.06381217f, -0.59424901f, -0.62644291f, -0.54880750f, 
    -0.06638049f, 0.41898799f, -0.66592759f, -0.55640286f, -0.54956162f, -0.36937013f, 0.07374874f, 0.38724044f, 
    -0.09433275f, 0.18344726f, 0.09948269f, -0.00239271f, 0.12500301f, -0.01794480f, 0.04987898f, 0.32814461f, 
    0.30948192f, 0.01495382f, 0.02301004f, -0.01694121f, -0.17575131f, 0.28497127f, -0.14127254f, -0.29639348f, 
    -0.11360505f, 0.10622393f, 0.00801868f, 0.09402192f, -0.35774571f, -0.36689466f, -0.01713282f, 0.39675826f, 
    0.06725122f, 0.67885858f, -0.08604009f, -0.12193112f, -0.28426674f, -0.23004562f, 0.18199722f, -0.36011353f, 
    -0.09992938f, -0.07968681f, 0.25997949f, 0.15935229f, 0.24549742f, 0.32120034f, 0.07572075f, 0.09500133f, 
    0.02785973f, -0.08425173f, 0.32773957f, 0.17076132f, 0.14765991f, -0.35681477f, 0.14567108f, -0.02132481f, 
    -0.30402485f, -0.13769639f, 0.21324237f, 0.10633057f, 0.03734595f, -0.30006459f, -0.45593065f, 0.16415086f, 
    -0.00436947f, -0.02744052f, 0.20800602f, -0.13619825f, 0.31217071f, 0.11874606f, 0.34487671f, 0.18944569f, 
    -0.03469147f, 0.10354576f, 0.25141132f, 0.17849234f, 0.22112912f, -0.42597020f, -0.19485007f, 0.08465038f, 
    0.22159904f, -0.07368699f, 0.01991651f, -0.25826418f, -0.05252552f, 0.19430970f, 0.13868843f, -0.06349161f, 
    -0.03717620f, 0.05438571f, -0.05717634f, -0.37337226f, 0.02605771f, 0.00864941f, 0.11749636f, 0.31464678f, 
    -0.12907366f, 0.04204462f, -0.39500415f, -0.02698368f, -0.15470444f, -0.35881040f, 0.51722109f, 0.36299035f, 
    0.23261969f, -0.21890828f, 0.04932682f, 0.01406440f, -0.29065126f, -0.38528737f, -0.23802231f, -0.22268289f, 
    0.24881124f, 0.45371592f, -0.03708947f, -0.22211753f, 0.24269037f, -0.25539553f, -0.16867907f, -0.10310746f, 
    -0.36902764f, -0.54544908f, -0.32905978f, -0.29959562f, -0.49353427f, -0.84315664f, -0.42926139f, -0.18462890f, 
    0.14642690f, 0.36185610f, 0.31770533f, -0.08535403f, -0.09290911f, -0.01951866f, -0.12216733f, 0.04432695f, 
    0.15611002f, -0.11902925f, 0.00798013f, -0.26989025f, -0.10004817f, -0.12422246f, -0.20913902f, -0.03882237f, 
    0.02103947f, -0.20852806f, -0.30327410f, -0.47109041f, -0.49240729f, -0.38023764f, 0.26920122f, 0.25888896f, 
    0.14679615f, -0.22076602f, 0.83256376f, -0.08585022f, -0.25511017f, -0.17925578f, -0.40604994f, 0.07674766f, 
    0.34610975f, -0.11861431f, 0.07071699f, 0.02978927f, 0.04828826f, 0.02325471f, 0.41108984f, -0.10294832f, 
    -0.32469285f, 0.19858900f, -0.09579799f, -0.11578028f, 0.74567789f, -0.20488165f, -0.30567041f, -0.46796188f, 
    0.22816461f, 0.15083069f, -0.02927044f, 0.01101963f, -0.00298858f, 0.24441867f, -0.49468565f, 0.72871357f, 
    -0.39877513f, -0.24072960f, 0.39644307f, 0.10840485f, -0.02334438f, 0.02959982f, 0.00986909f, -0.17511149f, 
    0.10285141f, -0.32821217f, 0.16813406f, 0.09774224f, 0.19966571f, -0.12559251f, 0.34004423f, 0.15597941f, 
    0.28238091f, 0.12827507f, -0.06536682f, 0.17967197f, 0.21376048f, 0.10010265f, -0.10462186f, 0.04419884f, 
    0.37040353f, 0.19630706f, -0.16005044f, -0.35767975f, -0.01477841f, -0.09532955f, 0.01483578f, 0.00679984f, 
    -0.07573722f, -0.19501157f, 0.24566960f, -0.01483775f, 0.01194524f, 0.02863496f, -0.02308446f, -0.51517355f, 
    -0.54198092f, -0.35152662f, -0.64996576f, 0.12022702f, 0.04644376f, 0.11334566f, -0.04487487f, 0.13709460f, 
    0.13239042f, 0.06105487f, -0.30716327f, -0.16541274f, -0.17802292f, -0.40933564f, 0.31522599f, 0.03819016f, 
    0.08488069f, -0.33283386f, -0.06815076f, -0.32687774f, -0.01956666f, -0.29994860f, -0.45822355f, -0.44966722f, 
    -0.85769826f, -0.52703094f, 0.86328918f, 0.85976452f, 0.45940101f, 0.85537624f, -0.28827679f, -0.70162034f, 
    -0.53602958f, -0.20911258f, -0.16987182f, -0.08806498f, -0.15216628f, 0.09915418f, 0.11314852f, -0.08291401f, 
    -0.00703543f, 0.43448153f, -0.18663965f, 0.16793086f, -0.27469608f, 0.04210328f, 0.12191498f, -0.19815700f, 
    -0.17186056f, 0.18724957f, 0.56003559f, -0.20096999f, -1.06360590f, -0.01324775f, -0.09150197f, -0.37421274f, 
    -0.19118719f, 0.03759600f, 0.16564173f, 0.05597836f, 0.38203973f, 0.52183568f, 0.09665208f, -0.03942496f, 
    -0.04323203f, -0.06070272f, 0.07578562f, -0.14735210f, 0.22729777f, 0.36110327f, -0.03661355f, -0.32259992f, 
    0.01451539f, 0.53438461f, -0.07536479f, 0.10793672f, 0.33212632f, -0.29900229f, -0.28489989f, 0.11863910f, 
    -0.23925030f, 0.06259463f, -0.04138663f, -0.28515822f, 0.02237837f, 0.17656611f, 0.03024871f, -0.00433287f, 
    0.29199159f, 0.09098696f, 0.15090317f, -0.20224777f, -0.29745165f, 0.09784631f, -0.07897213f, -0.11865287f, 
    -0.17154673f, 0.10921230f, 0.06611528f, -0.27278310f, -0.36890078f, -0.28879803f, -0.31638315f, -0.39382970f, 
    -0.15602262f, 0.42286453f, -0.11340053f, -0.10966203f, -0.07133865f, -0.14074267f, 0.41659647f, -0.14910501f, 
    -0.03577743f, -0.33272010f, -0.32839355f, -0.02136684f, -0.32126033f, -0.49189731f, 0.57648534f, -0.07253531f, 
    0.13440157f, 0.38934791f, 0.28524190f, -0.04659836f, -0.50234669f, -0.63222766f, -0.47718951f, -0.35545614f, 
    0.61091423f, 0.15632084f, 0.38684893f, 0.07944695f, 0.25461873f, 0.10284559f, 0.35888255f, 0.04426455f, 
    -0.27173555f, -0.20998450f, -0.39537385f, -0.16271129f, -0.12399855f, -0.08470604f, -0.40769580f, 0.14903645f, 
    0.29467735f, 0.51555818f, 0.37597835f, 0.03122348f, -0.05042468f, -0.42599189f, -0.07694898f, 0.21651416f, 
    0.54115868f, 0.60511756f, 0.32750896f, -0.06969657f, 0.01284519f, -0.15063253f, 0.52495778f, -0.53703678f, 
    -0.19315325f, -0.18741277f, 0.32644290f, 0.05564313f, -0.02575507f, -0.01143635f, -0.03321438f, -0.50959659f, 
    0.07942411f, -0.05554752f, 0.07672323f, -0.09965762f, 0.11152183f, 0.52906960f, 0.22249368f, -0.08288100f, 
    -0.29026610f, 0.58847290f, 0.10913163f, -0.23328426f, -0.45715785f, -0.19504762f, -0.02604402f, -0.23887141f, 
    0.01231278f, 0.19399846f, -0.04177765f, -0.08679654f, -0.20510906f, -0.14867263f, -0.05830312f, -0.08742983f, 
    -0.33697578f, 0.14129980f, 0.12437747f, 0.10678860f, 0.17445372f, 0.12234863f, 0.14162573f, -0.11519486f, 
    -0.46464255f, -0.74288791f, -0.60672987f, 0.62777996f, 0.06670073f, 0.18938415f, -0.19605678f, 0.02840686f, 
    0.25496691f, 0.26019153f, 0.13742489f, -0.05273985f, 0.09952106f, 0.00246484f, 0.21625924f, 0.08416247f, 
    -0.22042960f, -0.05615805f, -0.11971162f, -0.34977156f, -0.13383365f, 0.32413644f, -0.09970335f, 0.20302193f, 
    -0.60051095f, -0.50610644f, -0.12533772f, -0.70611537f, 0.17431812f, -0.12373557f, 0.07123146f, 0.14644362f, 
    -0.00586658f, -0.04210682f, -0.28596205f, 0.27716687f, -0.19464752f, 0.11996035f, 0.16950309f, -0.30757499f, 
    0.00196746f, -0.01429384f, -0.10167596f, 0.08916241f, -0.02766982f, 0.23252924f, -0.48422772f, -0.13364562f, 
    -0.98420459f, -0.19141422f, -0.44571385f, -0.17421581f, 0.69526511f, 0.47544616f, 0.04036153f, 0.12137033f, 
    0.11470540f, 0.43008718f, 0.36862099f, -0.04650265f, -0.15112339f, -0.20659328f, 0.33400145f, 0.15126386f, 
    -0.01069731f, 0.06608290f, -0.14902332f, -0.31526530f, -0.04307386f, 0.06366936f, -0.21909228f, 0.21127976f, 
    -0.07377227f, -1.09554529f, -0.20691328f, -0.57622957f, -0.72553790f, 0.10986493f, 0.02685989f, 0.17766666f, 
    0.36030868f, 0.39363798f, 0.44128457f, -0.07834645f, -0.35697174f, -0.34556630f, -0.20226248f, 0.08673927f, 
    0.01824591f, 0.10729816f, -0.00793492f, 0.10094389f, -0.17880034f, -0.08336035f, -0.26356521f, 0.01332755f, 
    -0.21366285f, -0.38976917f, -0.06497779f, 0.37043706f, 0.28548512f, 0.31170908f, 0.17969754f, -0.17558296f, 
    -0.45406821f, -0.41923666f, -0.10024368f, 0.33078966f, -0.08859214f, 0.08923495f, 0.21002382f, -0.10236530f, 
    -0.39012033f, 0.28064623f, 0.04621524f, 0.02117305f, 0.18002331f, -0.11767519f, 0.10310040f, -0.44101816f, 
    -0.21299587f, 0.00173160f, -0.20947784f, 0.38605636f, 0.72490716f, 0.32202151f, -0.37568465f, -0.27719817f, 
    -0.46887070f, -0.37539923f, -0.25146270f, -0.14369555f, -0.39409861f, -0.10592387f, -0.12896116f, -0.24669605f, 
    -0.12259917f, 0.20783159f, 0.25787038f, 0.04591793f, 0.11986627f, 0.13747315f, 0.29525644f, -0.15291867f, 
    0.21697381f, -0.04967858f, -0.30341282f, -0.27479783f, -0.73249477f, 0.28129366f, 0.07317197f, 0.15466504f, 
    0.33677468f, -0.46899644f, -0.58605874f, 0.09608305f, 0.48601067f, 0.36026999f, 0.07947395f, 0.09579350f, 
    0.04176169f, -0.23169339f, 0.05409271f, -0.02508573f, 0.02576367f, -0.04524454f, -0.00862379f, -0.07989270f, 
    0.08980441f, -0.25346297f, 0.11292045f, 0.37103444f, -0.06057552f, -0.16812541f, 0.10475389f, -0.09147312f, 
    0.20784247f, 0.16638193f, -0.37081659f, -0.10371167f, 0.21042775f, 0.09640495f, 0.32759088f, 0.19811502f, 
    0.01991359f, 0.15714608f, -0.20350765f, -0.08813563f, -0.07027054f, 0.06428533f, 0.05220419f, -0.08097169f, 
    -0.26525381f, -0.07325779f, -0.12612081f, 0.32223988f, 0.01610689f, -0.05161759f, 0.05830195f, -0.85939491f, 
    -0.29232377f, 0.60356516f, 0.06805384f, -0.36937448f, -0.13717364f, -0.31058356f, 0.23351696f, 0.10421082f, 
    -0.22053522f, -0.24647634f, -0.37938321f, -0.16838221f, 0.26428020f, 0.01257788f, 0.21311693f, -0.11328419f, 
    0.42964321f, -0.01531199f, -0.13841338f, -0.24639310f, -0.23217037f, -0.21527012f, -0.30239144f, -0.50871700f, 
    0.37557971f, -0.37784818f, 0.32347232f, -0.24600813f, 0.25920621f, 0.49236855f, -0.27171996f, -0.63229156f, 
    -0.64731598f, 0.27612785f, -0.08773320f, -0.05300891f, -0.26429093f, -0.03031751f, -0.12986720f, -0.19150174f, 
    0.04136990f, -0.09184289f, -0.39539653f, 0.18442383f, -0.14871173f, 0.13140702f, -0.13412322f, -0.47971290f, 
    0.18604311f, 0.41442522f, -0.13970523f, -0.44192243f, 0.22936882f, -0.21216606f, 0.19552708f, 0.25807980f, 
    -0.10074773f, -0.07576502f, 0.02385261f, -0.34804153f, -0.27067703f, 0.20056047f, -0.10598783f, -0.14776248f, 
    -0.09922738f, 0.04986895f, -0.04077452f, -0.23447880f, -0.12414786f, -0.31308305f, -0.34749031f, -0.27749977f, 
    -0.53609663f, -0.68407887f, 0.05476531f, -0.78337532f, 0.13281445f, 0.17877167f, -0.20547289f, -0.00951632f, 
    0.33533201f, -0.16327244f, -0.55170214f, 0.38536167f, -0.17634971f, -0.25359431f, -0.34698644f, 0.43372625f, 
    -0.01612568f, 0.00600700f, 0.17159407f, -0.28053039f, -0.00771679f, -0.03151615f, 0.14426945f, 0.30590540f, 
    -0.04133253f, -0.26105654f, 0.07627961f, -0.75186890f, -0.69515616f, 0.28021330f, 0.27780917f, -0.23278984f, 
    -0.12871772f, -0.31239131f, 0.23557507f, -0.01756309f, 0.44801524f, -0.18095878f, 0.17248070f, -0.14145042f, 
    -0.03327047f, 0.03900827f, -0.16154943f, -0.17609952f, -0.52102798f, -0.36099619f, 0.19180369f, -0.18741579f, 
    0.28185701f, 0.09796677f, 0.59763080f, 0.41564143f, 0.53663349f, 0.18468584f, -0.25300080f, -0.21470264f, 
    -0.01321739f, -0.59020495f, -0.35869077f, 0.42765784f, 0.19053426f, 0.36954036f, -0.27937233f, -0.25857612f, 
    -0.05152787f, 0.06565703f, -0.11167255f, 0.13562752f, 0.15324111f, 0.08286688f, -0.21567990f, 0.08660257f, 
    -0.15465708f, 0.13474736f, 0.23093534f, -0.12308969f, -0.73978317f, -0.26456448f, -0.19108845f, -0.38249928f, 
    -0.55873811f, 0.25393865f, 0.41960436f, -0.51457387f, -0.68081379f, -0.07540789f, 0.02457374f, 0.43681544f, 
    -0.50248098f, -0.59158081f, -0.32491848f, -0.36122766f, -0.10590879f, -0.00582301f, -0.35801268f, -0.32018068f, 
    0.03113222f, -0.09314228f, -0.08677346f, 0.18011202f, 0.00761335f, 0.40108383f, 0.48441672f, -0.24126479f, 
    -0.26397535f, -0.13377717f, 0.04334199f, 0.43357611f, -0.25601900f, -0.00699520f, -0.06453694f, -0.09110256f, 
    -0.10241918f, 0.01000574f, 0.04183462f, 0.14346033f, 0.20074835f, -0.14670254f, -0.21846537f, 0.11980325f, 
    -0.13815376f, 0.24570063f, 0.22004689f, 0.02500120f, -0.19414951f, -0.13710830f, 0.17498890f, -0.15465312f, 
    -0.10386406f, -0.13466354f, 0.18391864f, -0.20959413f, -0.00881743f, -0.03036768f, -0.08754068f, 0.26962879f, 
    -0.12290467f, 0.02205132f, 0.12687212f, -0.05320784f, 0.21145654f, -0.01675298f, -0.34679860f, 0.04028062f, 
    0.09078145f, -0.41144928f, 0.08672080f, 0.34502274f, -0.16809531f, 0.05956234f, 0.32524407f, 0.05240621f, 
    0.18280731f, 0.38431203f, -0.17224121f, -0.42314413f, -0.33944327f, -0.62862754f, 0.27006754f, 0.09946256f, 
    0.46991342f, -0.51216114f, 0.10686720f, 0.39851579f, 0.16651510f, -0.13919221f, 0.04024088f, 0.06960873f, 
    0.04453462f, 0.18586366f, -0.32489416f, 0.25228783f, -0.19619639f, 0.20187779f, -0.24243292f, -0.10854876f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14480127f, 0.18195099f, 0.06387870f, 0.07194813f, 0.20135295f, 0.18650945f, -0.04179942f, 0.12694357f, 
    -0.30642208f, 0.14323175f, 0.09075306f, -0.11594219f, 0.31873795f, 0.11066546f, 0.03600894f, 0.14785029f, 
    0.47238046f, -0.24215659f, 0.34622186f, 0.02365090f, -0.00157411f, 0.27338934f, 0.06045885f, 0.11684113f, 
    0.13372573f, -0.15693249f, 0.28282297f, 0.16067463f, -0.02635120f, 0.10396059f, 0.03114253f, -0.02172235f, 
    0.04502933f, -0.13009448f, -0.18416706f, -0.19879590f, 0.03524997f, -0.21112022f, 0.08702409f, 0.04369802f, 
    0.17425595f, 0.16321546f, -0.18908411f, -0.10531781f, 0.35434660f, -0.04104344f, 0.26172224f, 0.08048450f, 
    0.31183830f, -0.15542956f, -0.01305883f, -0.13644022f, 0.00666663f, 0.09301275f, -0.06846963f, 0.15265664f, 
    -0.00932881f, -0.02103861f, 0.11772993f, 0.14388782f, 0.04625636f, 0.11406902f, 0.14886427f, 0.12744945f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00538628f, -0.02121622f, 0.01956060f, 0.01018351f, -0.02432889f, -0.03435464f, 0.01744738f, 0.02195433f, 
    -0.01280426f, -0.02469430f, 0.01676277f, -0.00797988f, 0.01499107f, -0.01869168f, -0.03027001f, -0.01692033f, 
    -0.02568568f, -0.00834976f, -0.02433240f, -0.02108110f, 0.02848751f, 0.02063831f, 0.03137967f, 0.02951031f, 
    -0.03937896f, 0.00511571f, 0.01689735f, 0.01126886f, 0.02587857f, -0.00235153f, -0.03202178f, -0.03672466f, 
    0.00740063f, 0.00638139f, -0.00335998f, -0.02836124f, -0.00981409f, -0.03754849f, -0.02921839f, -0.01338341f, 
    -0.02745918f, -0.04073742f, 0.00981532f, 0.00069796f, -0.02354070f, 0.00732653f, -0.02013641f, -0.01046466f, 
    0.00455965f, -0.03203954f, -0.01436290f, 0.01982577f, 0.02625493f, -0.03860058f, -0.03860195f, 0.01098929f, 
    0.00371427f, -0.01178018f, -0.03034229f, 0.01127505f, -0.01033061f, 0.01333766f, -0.01090586f, 0.02070045f, 
    -0.01634550f, -0.01135455f, -0.01715738f, 0.00052429f, -0.03515196f, 0.00210878f, -0.04219839f, -0.00964884f, 
    -0.00476723f, -0.02885189f, -0.00735783f, 0.00327999f, 0.00873912f, 0.01020357f, 0.02017604f, -0.02590038f, 
    -0.02570070f, -0.03348999f, 0.02140385f, -0.03162603f, -0.02815731f, -0.01185096f, 0.03230378f, -0.01577223f, 
    0.01136433f, -0.03723114f, 0.02233684f, 0.02578663f, -0.02202678f, 0.02928527f, -0.01964736f, -0.02960269f, 
    -0.01721340f, -0.01878937f, 0.01816040f, -0.00327836f, 0.00752119f, -0.00527160f, 0.02258603f, 0.02539014f, 
    0.00487513f, 0.00280332f, -0.02249094f, 0.00802230f, 0.00473140f, -0.03082913f, -0.03538214f, 0.01896408f, 
    -0.00254419f, -0.04563016f, -0.03113094f, -0.01453131f, -0.01014862f, 0.01973150f, -0.01887263f, -0.01521185f, 
    -0.02082672f, 0.01139281f, -0.03154919f, -0.01992891f, 0.02709976f, 0.01677795f, 0.01229034f, -0.02833808f, 
    -0.00902371f, -0.03442178f, 0.01550073f, -0.01380067f, 0.02273514f, -0.03191520f, -0.01102777f, -0.01490001f, 
    0.00865477f, 0.01613346f, -0.01165193f, 0.00469569f, -0.02319726f, -0.00168219f, -0.02614129f, 0.02252332f, 
    -0.01950591f, -0.03665095f, -0.04311804f, -0.01984409f, -0.01905374f, -0.03154072f, -0.01225381f, -0.01804944f, 
    -0.00568826f, -0.00536191f, 0.01533191f, 0.01830989f, -0.03386679f, -0.00967509f, 0.02925073f, -0.00637631f, 
    0.01317809f, 0.02158040f, -0.01327288f, -0.03570567f, -0.02781285f, 0.02891258f, 0.00540634f, -0.03604703f, 
    0.02173229f, -0.01095122f, -0.01787363f, 0.01787941f, -0.04628889f, -0.02783126f, -0.00117730f, 0.02036168f, 
    -0.02088680f, 0.02880743f, -0.00095006f, -0.02128771f, 0.02352761f, -0.03889739f, 0.01337201f, 0.02866573f, 
    0.01789862f, 0.00918359f, -0.04022062f, -0.03446719f, -0.01024055f, 0.02179752f, -0.01466125f, -0.01363146f, 
    0.00084612f, -0.02000547f, -0.02435992f, 0.02553678f, -0.03510547f, -0.01171609f, -0.03259782f, 0.02154960f, 
    -0.03353688f, 0.02564139f, -0.02164043f, 0.01399736f, -0.02732423f, -0.02456799f, 0.01373838f, 0.01825901f, 
    0.00109174f, -0.02398490f, -0.00938657f, 0.01099309f, -0.01546866f, -0.02245717f, 0.01995089f, 0.02461774f, 
    -0.03683197f, 0.00836698f, -0.01351788f, 0.01230819f, -0.01334984f, 0.02173313f, -0.02157542f, -0.02973737f, 
    -0.01330108f, -0.00196119f, 0.02136842f, 0.02193267f, 0.02124791f, -0.02916435f, 0.01328340f, -0.02736642f, 
    -0.02744254f, -0.02219064f, -0.03262163f, -0.01857771f, -0.00344632f, -0.00762489f, -0.02233327f, 0.03528515f, 
    0.04020328f, -0.00471785f, -0.03814751f, 0.00734478f, 0.01713256f, -0.02157743f, 0.02350570f, -0.02181620f, 
    0.00304397f, -0.00218211f, -0.00496034f, -0.04172830f, -0.00440480f, -0.03217184f, -0.02995300f, 0.03036715f, 
    -0.01123778f, 0.00292388f, -0.03385279f, 0.02902922f, -0.02138880f, 0.00863550f, 0.02288930f, -0.02636551f, 
    0.01863300f, -0.04146324f, -0.01261392f, 0.02057234f, -0.04004350f, 0.03142467f, 0.02684881f, -0.03281127f, 
    0.00057962f, -0.04323163f, 0.02591468f, 0.01203706f, -0.02795496f, 0.00291347f, 0.00407329f, -0.03586272f, 
    -0.01812622f, -0.01750603f, 0.00689076f, -0.01768917f, -0.00235350f, 0.01310604f, 0.01733135f, -0.00011759f, 
    0.02066824f, -0.01774126f, -0.03596221f, -0.02535606f, -0.03055384f, -0.01893681f, -0.02819647f, -0.00315667f, 
    -0.01043373f, 0.01524434f, -0.01136791f, -0.02973505f, 0.01133268f, 0.01509871f, -0.03677958f, -0.02428369f, 
    -0.00479533f, -0.00995738f, 0.01866370f, -0.02725336f, -0.03135511f, 0.00717922f, -0.03130179f, 0.00149321f, 
    -0.00640169f, -0.02511414f, -0.00936096f, -0.01283180f, 0.00421382f, -0.01975630f, -0.02751150f, -0.01527498f, 
    -0.00350411f, 0.02590395f, 0.00484226f, -0.02098062f, 0.02348624f, 0.02851997f, 0.01410876f, 0.02093032f, 
    -0.03075871f, -0.00483404f, -0.01497244f, -0.00981561f, 0.00990398f, 0.02697317f, 0.01159352f, 0.00290846f, 
    0.00828598f, -0.00242123f, -0.01960085f, 0.00969953f, -0.03783328f, -0.02512302f, -0.02861972f, -0.00599353f, 
    0.00802905f, -0.02321015f, 0.01864629f, -0.00524237f, -0.01705148f, -0.01819559f, -0.03272999f, 0.00324116f, 
    0.01654965f, -0.03313966f, -0.03299586f, 0.00762558f, 0.01418066f, -0.01277194f, 0.02310796f, -0.02128402f, 
    -0.01017272f, -0.03230993f, -0.01412468f, -0.02766858f, 0.02718055f, -0.00088070f, -0.01877814f, -0.03668454f, 
    -0.03608531f, 0.02615137f, 0.01210949f, -0.01579436f, 0.01651825f, 0.02758604f, 0.00628116f, 0.00603518f, 
    -0.01217021f, 0.02094014f, -0.00936024f, -0.00993572f, 0.00579894f, -0.02677608f, -0.01530605f, 0.00654408f, 
    0.01624263f, 0.02026287f, -0.03967468f, -0.00898516f, 0.01525930f, 0.00092656f, -0.01852859f, -0.00349380f, 
    0.00044878f, -0.03819861f, 0.02629311f, -0.00607671f, 0.02501849f, -0.00418112f, -0.03416883f, 0.01155780f, 
    0.01555491f, 0.03379072f, -0.03361112f, -0.00904846f, -0.04653983f, -0.00527893f, -0.02291799f, -0.00796901f, 
    -0.03425532f, -0.02852800f, -0.03709619f, -0.00515909f, 0.01121805f, -0.00779837f, -0.00635517f, -0.00678697f, 
    0.00005295f, -0.00459800f, -0.04264244f, 0.01277451f, -0.03592539f, 0.02085182f, 0.01755258f, 0.01475993f, 
    0.03894268f, -0.00092372f, 0.03032680f, -0.01295925f, 0.00814193f, 0.01266627f, -0.00882344f, -0.01775424f, 
    -0.03679838f, 0.02407834f, -0.00527159f, -0.04143558f, 0.02905831f, -0.00055120f, 0.01220492f, -0.03255101f, 
    0.00950837f, 0.01171306f, -0.02687427f, 0.02380422f, -0.00845390f, 0.01639648f, 0.00368400f, -0.00208077f, 
    0.00599269f, -0.03483164f, -0.02677345f, 0.02680719f, -0.00429731f, -0.03290990f, 0.01955930f, -0.01427133f, 
    -0.02963197f, 0.02418549f, -0.00976122f, -0.02853146f, 0.01412166f, -0.00840656f, -0.02165992f, -0.00622061f, 
    -0.03206987f, 0.01218670f, -0.00838468f, 0.00637171f, 0.02480645f, -0.04162810f, -0.00498868f, -0.01166560f, 
    -0.00523724f, -0.02575740f, -0.01007451f, 0.02118958f, -0.01009507f, -0.04532683f, 0.00686068f, -0.04217889f, 
    0.03379564f, 0.02615419f, -0.00638009f, -0.02801562f, 0.00615094f, -0.02963209f, 0.02155648f, -0.00916232f, 
    -0.02446329f, -0.02162220f, 0.02357830f, -0.03722294f, -0.02559875f, -0.01984210f, -0.02148701f, -0.01876932f, 
    -0.03277707f, 0.00496033f, -0.03410060f, -0.03619060f, 0.02941222f, -0.03535699f, 0.02452025f, -0.01388720f, 
    -0.01627430f, -0.01723574f, 0.03359027f, -0.00387268f, 0.02826332f, 0.02299046f, -0.00178160f, 0.01607024f, 
    0.01932078f, 0.01567320f, 0.00793254f, -0.01290872f, -0.03561001f, 0.02772586f, -0.01951064f, 0.02293786f, 
    -0.00241488f, -0.00700391f, 0.02081058f, 0.00294803f, -0.01331834f, -0.01419676f, 0.00491909f, -0.02701540f, 
    0.01929387f, -0.02065512f, 0.00889789f, 0.02636211f, -0.00702633f, 0.02124735f, 0.03001423f, -0.01212889f, 
    0.00393497f, -0.01305701f, 0.00587426f, 0.02769614f, -0.02480161f, -0.03126414f, -0.02710120f, -0.02225574f, 
    0.01748306f, -0.03369756f, 0.02749994f, 0.01677550f, 0.00778650f, 0.01159704f, -0.00503776f, 0.01134066f, 
    -0.00564932f, -0.01366450f, -0.04181967f, -0.00232516f, 0.03247834f, 0.02496424f, 0.02063511f, 0.02796567f, 
    -0.04453759f, -0.03875142f, 0.00338237f, 0.00462557f, -0.03561443f, 0.01691640f, -0.02212145f, -0.00230789f, 
    0.02625858f, -0.02646143f, -0.01694160f, 0.02080997f, -0.00688796f, -0.03239461f, -0.03762490f, -0.01672036f, 
    -0.01352055f, -0.02004954f, 0.02454083f, 0.01039002f, -0.02041635f, -0.01610571f, -0.02274452f, -0.02745264f, 
    -0.03546180f, 0.00957282f, -0.03888307f, -0.03317223f, -0.02978273f, -0.02703554f, 0.02457093f, 0.02767744f, 
    0.00696737f, 0.02190435f, 0.00407075f, 0.02944646f, 0.01809756f, -0.03264415f, -0.00714602f, -0.03800888f, 
    0.02765666f, -0.02433041f, -0.03624676f, -0.03939984f, -0.00074621f, -0.03891822f, -0.02159954f, -0.00508181f, 
    -0.00258039f, -0.02929916f, -0.02000220f, 0.01119686f, -0.00620055f, -0.00541636f, -0.00212439f, -0.03332569f, 
    0.00354668f, 0.00071851f, -0.00660179f, 0.00512203f, -0.00644630f, 0.00825078f, -0.02449505f, 0.03127043f, 
    -0.02070583f, 0.00626153f, 0.00886560f, -0.03656053f, -0.02087717f, -0.04200169f, -0.01015235f, -0.01583300f, 
    0.00739472f, -0.04265052f, 0.00993730f, 0.02270896f, 0.00429211f, -0.02205736f, -0.03428534f, -0.02023511f, 
    0.00666299f, -0.01279502f, -0.02587737f, -0.03094017f, 0.02496744f, 0.02168808f, -0.04542627f, 0.02727413f, 
    -0.00692239f, 0.01165436f, -0.02313447f, -0.02475160f, 0.00152004f, -0.03777667f, -0.04077149f, -0.00582884f, 
    -0.00414088f, -0.01356664f, 0.01863233f, -0.02190250f, -0.03695872f, -0.01022407f, 0.01085145f, -0.00605077f, 
    0.01740061f, -0.04294660f, -0.00254146f, -0.03013176f, -0.02364817f, -0.02407711f, 0.02332049f, -0.03361343f, 
    0.01030951f, 0.02688462f, -0.01221297f, 0.00485397f, -0.01657420f, 0.01149565f, -0.03059733f, 0.01249351f, 
    -0.01182253f, -0.01762406f, 0.01219215f, 0.01522602f, -0.01714262f, 0.01518507f, -0.01465167f, 0.01165458f, 
    -0.00471129f, 0.00549655f, 0.00375627f, -0.02918528f, -0.03375358f, -0.03025081f, -0.03421536f, 0.00668427f, 
    0.02183671f, -0.02418690f, -0.03087384f, -0.02805852f, -0.02046207f, 0.02300906f, -0.01616997f, -0.01338643f, 
    0.03295135f, -0.04512464f, 0.01072636f, -0.01428565f, -0.00547391f, 0.02742433f, -0.01960512f, -0.04084561f, 
    -0.02109326f, -0.03721895f, 0.01718877f, -0.01750044f, 0.01546622f, 0.00245533f, -0.00411898f, -0.00119719f, 
    -0.02433462f, -0.04107524f, 0.02417813f, 0.01141362f, -0.03905988f, -0.03169555f, -0.04240156f, -0.03667204f, 
    -0.00658471f, 0.01478739f, -0.03847816f, 0.01756295f, -0.02037148f, 0.00710167f, 0.01323471f, -0.02582490f, 
    -0.03234192f, 0.01973574f, -0.01519652f, -0.01903644f, 0.00781128f, 0.01455202f, -0.01953124f, -0.01559441f, 
    0.01140947f, -0.01908656f, 0.00890905f, -0.03549803f, -0.01632478f, -0.02325237f, -0.00280602f, 0.01244649f, 
    -0.00713921f, -0.01257414f, -0.01024757f, -0.01300880f, 0.02379690f, 0.00626551f, -0.00438545f, -0.01747854f, 
    -0.03690942f, 0.01705886f, 0.01429302f, 0.02364545f, 0.00417037f, -0.00162101f, -0.02025089f, -0.03480813f, 
    0.00670447f, -0.02269587f, -0.01620353f, 0.01235227f, -0.01046425f, -0.01808718f, 0.00050792f, -0.04279426f, 
    -0.02545229f, -0.03235586f, 0.01637876f, -0.02895197f, 0.00238186f, -0.02240593f, -0.04256292f, 0.02599290f, 
    -0.03665559f, -0.02838964f, -0.03991954f, 0.02293450f, 0.02184193f, 0.02882474f, 0.01284475f, 0.03469339f, 
    -0.03990331f, 0.01349938f, 0.02488497f, -0.00080081f, -0.00006612f, 0.01606245f, -0.02252114f, -0.01668615f, 
    0.01937876f, 0.00347934f, -0.03605398f, -0.01333605f, 0.00017884f, 0.02530783f, -0.02180036f, 0.02270314f, 
    0.01018816f, -0.01209254f, -0.04241921f, 0.01864263f, -0.01671369f, 0.01480239f, 0.02751057f, -0.00541283f, 
    0.02021590f, 0.02608859f, -0.02513055f, -0.03710980f, -0.03447709f, 0.02221924f, -0.01870472f, 0.02190819f, 
    0.02697347f, -0.02797036f, 0.01130413f, 0.02488045f, -0.00024732f, -0.04362173f, 0.00765489f, -0.00156579f, 
    0.02747492f, 0.02190530f, -0.00904492f, -0.01237885f, -0.00548402f, 0.00248369f, -0.03157410f, 0.01840505f, 
    -0.03625014f, 0.02267458f, -0.03704347f, -0.02313792f, 0.01242221f, -0.00279212f, -0.02686295f, 0.01388909f, 
    0.00130416f, 0.00498609f, 0.01905043f, 0.01285273f, -0.00416976f, 0.00777095f, 0.00055444f, 0.02472001f, 
    0.00162415f, -0.03685155f, 0.02523952f, 0.01814642f, -0.00713787f, -0.00782871f, -0.00969058f, -0.03469369f, 
    0.00742648f, 0.02855713f, -0.03021232f, -0.00961602f, 0.02863121f, -0.00869038f, 0.00778153f, 0.01259402f, 
    0.02233957f, -0.01598944f, 0.01103012f, 0.03363447f, -0.00752301f, 0.01109262f, 0.01259857f, -0.02618157f, 
    -0.02569470f, -0.01721259f, 0.00637165f, -0.04058414f, -0.01433486f, 0.02139849f, 0.00593879f, -0.02101083f, 
    -0.00836578f, -0.02347102f, -0.04050726f, -0.00055479f, 0.02304191f, 0.00325326f, 0.02286532f, -0.00989789f, 
    0.00732355f, 0.02693703f, -0.02633241f, -0.00629738f, -0.01195631f, 0.01266283f, 0.02992765f, 0.01640447f, 
    0.01139598f, -0.02583076f, -0.03536590f, 0.00606408f, -0.04025781f, -0.00255081f, 0.00480906f, -0.01904476f, 
    -0.01716221f, -0.00370381f, -0.02761301f, -0.02859182f, -0.02162969f, 0.00399307f, -0.00080862f, 0.00017491f, 
    0.02558187f, 0.02357513f, -0.03786651f, -0.02396780f, -0.03165686f, 0.02336764f, 0.01523757f, -0.04412325f, 
    0.01367343f, -0.00903043f, -0.01991008f, -0.02162901f, 0.02490144f, -0.03191416f, 0.00703586f, -0.00514392f, 
    0.01880406f, 0.00407586f, 0.01530827f, 0.01918487f, 0.02732746f, 0.02185985f, 0.00730025f, -0.03922000f, 
    0.02391626f, -0.01632922f, 0.01649191f, -0.03951696f, -0.01594428f, -0.02824536f, -0.01294271f, 0.00526104f, 
    -0.00286868f, -0.03078304f, -0.01686828f, -0.01542218f, 0.01019931f, -0.01487527f, -0.01999022f, -0.02358609f, 
    -0.02058148f, -0.02140909f, 0.01692198f, 0.01640230f, -0.01657149f, -0.03397743f, 0.02189454f, -0.02285545f, 
    -0.00645490f, 0.01342421f, -0.00487336f, 0.01942758f, -0.04314978f, -0.00994917f, -0.01121043f, 0.02180353f, 
    -0.00824430f, 0.02197834f, -0.00471449f, -0.02841001f, 0.01384313f, 0.02399171f, -0.03365942f, 0.03258608f, 
    0.02683743f, 0.01046711f, -0.02859500f, 0.00986689f, 0.00333151f, -0.01671777f, -0.03358332f, 0.00097661f, 
    -0.02421773f, -0.00354640f, -0.00126944f, -0.03629409f, -0.01641861f, 0.00385338f, -0.02178980f, 0.00106039f, 
    -0.00750709f, -0.02431840f, -0.02432097f, 0.02689955f, 0.01621947f, -0.02599574f, -0.01869879f, 0.02015193f, 
    0.00544448f, -0.01069304f, -0.03437659f, -0.01468491f, 0.02715783f, 0.02373966f, -0.03167033f, 0.01194335f, 
    -0.04281178f, -0.03994721f, 0.00029030f, 0.01739101f, -0.03194232f, -0.03019083f, 0.00554776f, -0.03115652f, 
    -0.03608060f, -0.00172048f, -0.02275370f, 0.01151383f, -0.02027826f, -0.03107600f, -0.00969125f, -0.02001645f, 
    0.02072251f, 0.00074087f, 0.00056773f, 0.02394575f, 0.01426524f, -0.04212842f, -0.01379694f, -0.01000680f, 
    0.01313965f, 0.01934484f, -0.03779429f, -0.02499259f, 0.02425337f, 0.02473828f, 0.00474375f, 0.02526974f, 
    -0.03496476f, -0.00736666f, -0.00195928f, 0.01796786f, -0.04101576f, -0.02149661f, 0.00345909f, -0.00314148f, 
    -0.04079409f, -0.01453359f, -0.00658405f, -0.04090508f, 0.02337667f, -0.01893773f, 0.02097548f, -0.02009601f, 
    -0.03688978f, 0.02458454f, 0.02476659f, -0.03112735f, 0.02512358f, 0.02036572f, -0.00273589f, -0.02886728f, 
    -0.03211620f, 0.00123556f, 0.01278111f, -0.02456488f, 0.02600678f, 0.00784235f, -0.03639557f, 0.02635555f, 
    0.01802508f, 0.01495283f, -0.02366397f, -0.03361931f, -0.03921057f, 0.00534254f, 0.00016714f, 0.00904690f, 
    -0.02012766f, -0.03174451f, -0.00702790f, -0.03890640f, -0.00171392f, 0.02458525f, -0.01714335f, -0.01791235f, 
    -0.04176901f, 0.02407948f, -0.00126069f, -0.01084112f, -0.00887760f, -0.03620779f, -0.01291487f, 0.02568687f, 
    -0.04168192f, -0.03988752f, -0.01670054f, 0.01051166f, 0.00267572f, 0.01873296f, -0.02332430f, -0.01176615f, 
    -0.00795131f, -0.02164806f, -0.04154816f, -0.01105904f, -0.00676636f, 0.01838926f, -0.00170016f, -0.02545395f, 
    0.01673031f, 0.00318431f, 0.00988618f, -0.01820137f, 0.02494047f, -0.00212100f, 0.02440194f, -0.02069195f, 
    -0.03470426f, 0.00229765f, 0.02709038f, -0.04016485f, 0.00430002f, -0.01345609f, -0.00697570f, 0.01912249f, 
    0.02826813f, -0.00885801f, -0.01450412f, -0.03169411f, -0.02991861f, -0.00238918f, 0.00637479f, -0.00088290f, 
    -0.02683181f, -0.03994879f, -0.02789716f, 0.02482389f, -0.03025079f, -0.03727438f, -0.02151377f, -0.04183807f, 
    0.02472119f, -0.01763876f, -0.03710980f, -0.03166244f, -0.01573821f, -0.03321261f, 0.00926915f, -0.04304415f, 
    0.01914633f, -0.00705868f, 0.00872475f, 0.00139688f, 0.02276395f, -0.02547169f, 0.00150262f, 0.00269345f, 
    0.00736540f, 0.03006571f, -0.03211763f, 0.00053656f, -0.00769046f, 0.02197473f, 0.02304061f, 0.00367878f, 
    -0.00838753f, 0.00720077f, 0.01813953f, 0.00206430f, 0.01494092f, -0.02384841f, -0.01144146f, 0.01878344f, 
    -0.00578914f, -0.01850274f, -0.03805178f, -0.01246742f, 0.00630888f, -0.03188096f, -0.02816707f, -0.03063636f, 
    -0.03497889f, 0.00071227f, -0.00539158f, -0.03405815f, -0.03358651f, 0.01961215f, -0.00824658f, 0.02721539f, 
    0.00501971f, -0.03202849f, -0.00522575f, -0.00204543f, 0.01344466f, 0.00787012f, -0.02719531f, 0.01011773f, 
    -0.02167171f, -0.02047159f, 0.01457338f, -0.03475751f, 0.00739653f, -0.02519501f, 0.02632332f, 0.00105849f, 
    -0.01593924f, -0.02433184f, -0.00369167f, -0.02420197f, 0.00187221f, 0.01170330f, -0.04324248f, 0.01019427f, 
    -0.02640780f, -0.03006054f, -0.02142428f, -0.03909557f, 0.00865111f, 0.00307494f, 0.02901912f, 0.00849772f, 
    -0.03424465f, -0.01183193f, -0.01067353f, -0.03531720f, -0.03619956f, 0.01184667f, -0.04186757f, 0.00477196f, 
    -0.01411968f, 0.01634402f, -0.01709676f, -0.02371444f, -0.01346564f, -0.00281713f, 0.01747741f, 0.00137034f, 
    -0.00268521f, -0.01539968f, -0.04032933f, -0.00601367f, 0.00834685f, 0.02720334f, -0.01918672f, -0.00549439f, 
    -0.00871305f, 0.01661428f, 0.02559316f, 0.01944900f, 0.00252000f, -0.04201304f, -0.00382602f, -0.00938130f, 
    -0.00035148f, -0.03891558f, 0.00214852f, 0.01285219f, -0.00639401f, 0.00991370f, -0.03745066f, -0.01032449f, 
    0.02156660f, -0.02732017f, -0.02733756f, -0.04411152f, 0.00982218f, -0.02844435f, -0.04059657f, -0.01952005f, 
    -0.01972544f, -0.00355702f, 0.01598465f, 0.02059691f, -0.00483583f, 0.00097080f, -0.03936439f, -0.03311702f, 
    0.00261303f, 0.02859475f, -0.01051820f, 0.02969773f, -0.01242262f, 0.02739379f, -0.03220091f, -0.03718558f, 
    -0.03389164f, -0.00424293f, 0.00143325f, 0.02689685f, -0.02816422f, -0.01341635f, -0.00283947f, 0.02515933f, 
    -0.01279136f, -0.00228845f, 0.02844375f, 0.02685824f, 0.02775748f, -0.01821742f, 0.01175583f, 0.02139634f, 
    -0.00428418f, -0.02534387f, 0.03069087f, 0.02630806f, -0.01700791f, -0.03577678f, 0.01237094f, -0.03468393f, 
    0.02736256f, -0.01217473f, -0.00358228f, -0.00677093f, 0.00689413f, -0.01739043f, 0.01039102f, 0.01568766f, 
    -0.01940048f, -0.04335696f, 0.01767925f, -0.00691158f, 0.01559632f, -0.02621598f, -0.00635910f, 0.02704108f, 
    0.02352263f, -0.03942632f, -0.02488566f, 0.00127835f, -0.01232907f, 0.01841895f, -0.01715613f, -0.00103689f, 
    -0.00242951f, -0.04014679f, -0.01372112f, 0.01208840f, 0.01186882f, -0.01245099f, -0.00878775f, 0.00601400f, 
    -0.03414916f, 0.01717666f, 0.01072317f, -0.00793073f, 0.00498102f, -0.02981901f, -0.03848042f, -0.01976730f, 
    0.02202278f, -0.02053746f, 0.03623076f, 0.01134395f, 0.01957941f, -0.02799491f, -0.04290471f, -0.00672992f, 
    -0.02685588f, -0.01413573f, -0.03775172f, -0.00722681f, 0.02644788f, -0.02439100f, 0.01120181f, -0.02575767f, 
    -0.02168943f, -0.01698664f, -0.03681225f, -0.00855850f, 0.02343903f, -0.00740955f, -0.00006794f, 0.02263109f, 
    -0.03856098f, -0.02029283f, -0.04217311f, -0.01893210f, -0.02102233f, -0.02316886f, 0.00214022f, -0.03596163f, 
    -0.00691673f, -0.02112278f, 0.01440369f, 0.02319188f, 0.02710451f, -0.01133460f, -0.02217834f, -0.00153139f, 
    -0.00890169f, 0.02214083f, -0.01782199f, -0.00133202f, 0.02586115f, -0.01633620f, 0.00694795f, -0.02271625f, 
    -0.00887287f, -0.03806123f, 0.01657659f, -0.01048094f, 0.01629611f, 0.02361475f, -0.03251249f, -0.00769854f, 
    -0.02372352f, -0.00505354f, -0.02904738f, -0.03937596f, -0.03623563f, 0.01445616f, 0.00526290f, 0.00276741f, 
    0.01805229f, -0.00446158f, -0.00090914f, 0.01335884f, -0.03929504f, -0.01873114f, -0.01319363f, 0.00719560f, 
    -0.03359915f, 0.02082204f, 0.02906318f, -0.02496699f, -0.01851198f, -0.01825137f, 0.00113698f, 0.01593070f, 
    -0.03790107f, 0.01232778f, -0.01027511f, -0.02665571f, 0.02320425f, 0.00656594f, 0.00444682f, 0.00323881f, 
    -0.00856990f, 0.00396726f, -0.01429198f, 0.01558037f, -0.03780115f, -0.00855647f, 0.00009055f, -0.03396571f, 
    0.01078079f, -0.00718471f, 0.02664932f, 0.02424575f, 0.02068316f, -0.00685177f, 0.00669308f, -0.01025298f, 
    -0.00138455f, -0.02521137f, 0.00249048f, -0.02707080f, -0.00481052f, 0.00075173f, 0.01370319f, -0.00063818f, 
    -0.00931834f, -0.00174159f, -0.04261751f, -0.01710299f, 0.02072521f, -0.01791309f, -0.01063695f, -0.03367832f, 
    -0.02462527f, -0.02439261f, 0.01970570f, 0.00038141f, -0.01118595f, -0.01896170f, -0.02767452f, -0.03057169f, 
    -0.02030507f, -0.04075415f, 0.00161898f, -0.01418780f, 0.02775702f, -0.02332322f, -0.02141831f, 0.00061060f, 
    0.02371869f, 0.02753329f, 0.02162471f, 0.02168784f, 0.00354450f, 0.02077764f, -0.01690416f, 0.02550329f, 
    0.00254276f, -0.01416783f, -0.02895369f, -0.04358029f, -0.00796119f, 0.01540836f, -0.00175904f, 0.01313230f, 
    -0.03443822f, 0.01708782f, 0.00648942f, -0.03686722f, -0.00301119f, -0.04267298f, 0.00087887f, 0.00218179f, 
    -0.03944049f, -0.03941878f, -0.03626983f, -0.01545787f, 0.01229251f, -0.02911702f, 0.01828602f, -0.02187728f, 
    -0.02909125f, -0.01809825f, -0.04192855f, -0.02593476f, -0.04295719f, 0.01234198f, 0.00499768f, 0.01845361f, 
    -0.09865466f, 0.13432899f, -0.16136497f, -0.30995625f, -0.06638349f, -0.17472282f, -0.06301641f, -0.16572800f, 
    0.00246669f, -0.01817461f, -0.11001436f, 0.01831441f, 0.10149362f, 0.12090986f, 0.04246594f, -0.03208841f, 
    0.07513611f, 0.00834337f, 0.03477599f, -0.03502785f, 0.08880585f, 0.03094522f, -0.02634764f, -0.05503109f, 
    0.14064302f, 0.10752910f, 0.15440419f, 0.18190321f, 0.00482192f, 0.03011741f, 0.03269316f, -0.10760269f, 
    0.10075230f, -0.09535307f, 0.04996672f, 0.01189308f, 0.07563648f, 0.07110306f, -0.14429829f, -0.43823174f, 
    0.04733932f, 0.00292861f, -0.09942456f, 0.19625622f, 0.01868872f, -0.03296524f, 0.00415352f, 0.09449716f, 
    -0.25856787f, -0.08272947f, -0.22741920f, -0.31517059f, -0.10282093f, -0.02332338f, -0.00139538f, -0.18752867f, 
    0.06873055f, -0.07096139f, 0.05980061f, 0.08363658f, 0.08787206f, 0.01806039f, -0.13774528f, 0.20485890f, 
    -0.10851993f, 0.04682869f, -0.08924948f, -0.03951728f, 0.04509089f, -0.09173597f, 0.05693953f, 0.04986749f, 
    0.03587831f, 0.07344096f, 0.06491429f, 0.09288528f, 0.09734949f, -0.04081732f, -0.00134033f, -0.09010047f, 
    -0.04416548f, -0.05352078f, -0.04916852f, -0.04577892f, -0.31825897f, 0.28306842f, -0.19040269f, -0.07164968f, 
    0.07817660f, -0.04844853f, -0.02923933f, 0.02039892f, -0.05576906f, 0.02786750f, -0.07919024f, 0.11004399f, 
    0.21933101f, -0.28039554f, -0.19626303f, -0.05312400f, 0.09182677f, 0.14162755f, 0.10197075f, 0.18858038f, 
    -0.01553571f, 0.07019536f, 0.08295102f, 0.00154181f, 0.09033603f, 0.25414082f, 0.07466405f, 0.08588568f, 
    0.10885112f, 0.04186255f, 0.05601627f, 0.14092191f, -0.08754725f, -0.09810439f, -0.03868025f, -0.07283866f, 
    0.21920805f, 0.11001932f, 0.04335864f, 0.14766744f, 0.06883319f, 0.03933872f, -0.05768940f, 0.01684799f, 
    -0.05047263f, -0.01726273f, -0.06584027f, 0.01083482f, 0.21679862f, 0.09855153f, 0.08204341f, 0.32003024f, 
    0.03441111f, 0.06223340f, 0.00023911f, -0.06048291f, -0.11167382f, -0.01850035f, 0.08298946f, -0.11806587f, 
    0.22069138f, 0.18618931f, -0.02442118f, -0.21021003f, -0.07632051f, 0.08736654f, -0.00085375f, 0.10256984f, 
    -0.14901631f, 0.02132409f, -0.03594962f, -0.05660352f, 0.13175191f, 0.08017565f, -0.16338161f, -0.31650564f, 
    0.07103917f, -0.11339080f, 0.04502405f, 0.08724191f, 0.00522925f, -0.05293272f, 0.00335080f, -0.01351518f, 
    0.00298144f, -0.17261337f, -0.20870346f, -0.21138552f, -0.02975309f, -0.08006402f, 0.02199859f, 0.08114607f, 
    -0.07593410f, -0.03806528f, 0.06509569f, 0.02134970f, 0.13196404f, 0.01345602f, -0.05328561f, 0.04707917f, 
    -0.03423353f, 0.13455878f, 0.14435206f, 0.17395192f, -0.03993687f, 0.09263478f, 0.03091917f, -0.01365056f, 
    0.10291883f, 0.25244138f, 0.06415095f, 0.21276107f, -0.09066734f, 0.03475930f, -0.04158583f, -0.15970585f, 
    0.03473473f, -0.00958992f, -0.06263465f, -0.05090127f, 0.00976127f, 0.02745960f, 0.01794899f, -0.10827590f, 
    -0.08400280f, -0.03996357f, 0.16440815f, 0.16785996f, -0.14146672f, 0.07416271f, 0.05281181f, -0.10569614f, 
    0.41564256f, -0.17838030f, 0.06645549f, 0.06257714f, 0.01216689f, -0.04877042f, 0.01474262f, -0.00411252f, 
    0.11242498f, 0.26600733f, -0.03107851f, 0.00969921f, 0.01275492f, -0.06850721f, 0.02826568f, -0.13113953f, 
    -0.07817526f, -0.16671811f, -0.07048376f, -0.09373103f, 0.01615598f, -0.03930685f, -0.07919510f, -0.06910427f, 
    0.09523470f, 0.11186086f, 0.10500320f, 0.02737517f, 0.18738209f, 0.02418431f, 0.06001851f, 0.06002908f, 
    -0.11556100f, -0.06099190f, -0.03018347f, -0.00626719f, 0.12898451f, -0.05025969f, 0.06258441f, 0.08123900f, 
    0.18292014f, -0.00121273f, 0.09360676f, 0.15837680f, -0.06458528f, 0.06733274f, -0.09123868f, 0.07544223f, 
    -0.11283972f, -0.44042832f, -0.41910329f, -0.55415756f, -0.02728208f, -0.15604140f, -0.13239175f, 0.15161368f, 
    -0.02386281f, -0.04377267f, 0.08398486f, 0.08080895f, 0.13853893f, -0.14706914f, -0.05864922f, 0.20892851f, 
    -0.07390808f, 0.01475000f, -0.08583985f, -0.13015391f, 0.15138949f, -0.09333553f, -0.05105005f, 0.02409896f, 
    -0.21863285f, -0.26085305f, -0.17766820f, -0.23577404f, 0.03033672f, -0.00470260f, 0.00453712f, 0.17409424f, 
    -0.00210562f, -0.04987283f, 0.00590779f, -0.02853001f, 0.16867706f, 0.15315342f, 0.06416902f, 0.17697765f, 
    -0.04048391f, -0.02942331f, -0.10168885f, 0.01342249f, -0.02636096f, -0.05507448f, -0.01371596f, -0.12286322f, 
    0.05653441f, -0.20022054f, 0.04262313f, -0.35792395f, -0.12808563f, 0.03940909f, -0.07485426f, 0.17793910f, 
    -0.02185483f, -0.06503127f, -0.02421924f, 0.10733342f, -0.02157017f, 0.04082952f, 0.12379435f, -0.05074918f, 
    -0.00771699f, -0.00626755f, -0.05353893f, -0.07569870f, 0.12569632f, -0.07967189f, -0.11655417f, -0.05083677f, 
    0.25722662f, 0.02270655f, 0.07614987f, -0.00064767f, 0.13720225f, 0.05746021f, 0.02287444f, 0.00914546f, 
    -0.04637503f, -0.08741211f, -0.07738084f, -0.05249722f, -0.13270673f, 0.31705099f, -0.11391094f, -0.31888831f, 
    0.18442830f, 0.12458741f, 0.11642032f, 0.11830598f, -0.00620786f, -0.05431951f, -0.01926284f, -0.01729723f, 
    -0.13031571f, -0.01011581f, -0.02828963f, -0.10965025f, -0.00523552f, 0.02292566f, -0.05292951f, 0.02885064f, 
    0.01704358f, 0.00975026f, -0.09723265f, 0.02405535f, -0.03865095f, -0.02344656f, -0.04929864f, 0.10830275f, 
    0.15774894f, 0.02114308f, -0.12994868f, -0.04987708f, -0.03077691f, -0.04260470f, -0.03137540f, -0.06462286f, 
    0.05674403f, 0.04843357f, 0.13266915f, 0.17986691f, 0.05048196f, -0.06250352f, -0.05954054f, -0.07942331f, 
    -0.05589226f, -0.02531953f, -0.00141644f, -0.05029491f, -0.00381318f, -0.21435070f, -0.04826076f, -0.02395896f, 
    -0.05660545f, -0.04409975f, -0.19930463f, -0.04709629f, 0.19904052f, -0.05872909f, -0.08804151f, 0.00713250f, 
    -0.23207439f, -0.38725889f, 0.07068513f, -0.05125764f, -0.01616915f, -0.13873281f, -0.02585650f, -0.15205318f, 
    0.03134393f, -0.03979716f, 0.02434502f, 0.09939791f, -0.27490717f, -0.06107773f, -0.08795365f, -0.03630969f, 
    -0.08566415f, 0.05404686f, -0.17970468f, -0.24936336f, 0.23099309f, -0.04893573f, -0.04159545f, 0.03213157f, 
    0.34476960f, 0.28539774f, 0.15701924f, -0.01815979f, -0.04627357f, -0.08893520f, -0.08469532f, -0.08823413f, 
    0.10711987f, 0.17068908f, -0.14741628f, -0.14576818f, 0.13845818f, 0.13137107f, 0.13614562f, 0.18596587f, 
    0.04632708f, -0.00577508f, -0.08659023f, -0.06115096f, 0.04704830f, -0.00218846f, -0.05375292f, 0.03060338f, 
    0.12560616f, -0.26924771f, 0.10452610f, -0.15014540f, 0.06804248f, -0.11415806f, -0.13026656f, -0.11774285f, 
    0.08231027f, -0.08211777f, 0.00919276f, 0.03237788f, 0.09909886f, -0.00480863f, -0.05549875f, -0.27554575f, 
    0.01849194f, 0.23947082f, -0.26895365f, 0.28097573f, 0.07082371f, -0.01984168f, -0.02363156f, -0.04944582f, 
    -0.15950100f, 0.20653859f, -0.12040795f, -0.17846023f, 0.05317243f, 0.02643329f, -0.04464393f, 0.25872746f, 
    -0.01268161f, 0.07190980f, 0.04072414f, -0.08205030f, 0.13439721f, 0.14020373f, 0.13562348f, 0.10414864f, 
    0.11325914f, 0.00046167f, -0.06299945f, 0.05382782f, 0.02112423f, -0.09036782f, 0.06960220f, 0.01560515f, 
    0.18237169f, -0.06118716f, 0.29239088f, 0.09923644f, 0.00742388f, 0.15605892f, 0.10559940f, 0.00583776f, 
    0.03666025f, -0.06139951f, 0.00256078f, -0.03042968f, 0.15822265f, -0.07279735f, 0.16387185f, -0.06957473f, 
    -0.01260706f, -0.17135012f, -0.07202548f, -0.04539346f, -0.00666319f, 0.10241415f, -0.10826403f, -0.01045983f, 
    0.26973954f, 0.08047844f, 0.18685998f, 0.31133479f, -0.02053926f, 0.05045814f, -0.09266519f, -0.09472238f, 
    -0.02856565f, 0.17666787f, -0.09599514f, 0.06479232f, 0.40457660f, 0.28372607f, 0.15668267f, 0.36278683f, 
    -0.00323659f, -0.05342769f, -0.04737838f, -0.09988868f, -0.00270609f, -0.07010645f, -0.07416056f, -0.04369083f, 
    -0.11469019f, -0.24038133f, 0.01642220f, -0.35192207f, -0.00382854f, -0.02549876f, -0.05154236f, 0.00753172f, 
    0.16805153f, 0.18683979f, 0.07485317f, 0.05596030f, 0.23097154f, -0.58255178f, -0.18817851f, -0.44139823f, 
    -0.11852710f, -0.14711736f, -0.05177386f, 0.02227069f, -0.02078840f, 0.02652106f, 0.08058996f, -0.03937119f, 
    0.06969468f, 0.16670740f, -0.07865541f, 0.25001520f, -0.08091459f, 0.08120503f, -0.11698789f, -0.08951091f, 
    0.13255462f, -0.05788354f, -0.01074904f, 0.09233973f, -0.18232410f, -0.27404535f, 0.10089125f, 0.17177875f, 
    0.00071483f, -0.13562714f, -0.20429182f, -0.41914076f, 0.04995986f, -0.06790399f, 0.01773936f, 0.06437745f, 
    -0.02594861f, 0.15756364f, 0.07024933f, 0.16559522f, 0.00531040f, 0.03701159f, -0.03554556f, -0.09975508f, 
    -0.03772888f, -0.10779878f, 0.09078544f, 0.09310679f, 0.06572857f, 0.17022622f, -0.00955711f, -0.03602122f, 
    0.08841611f, -0.01281518f, 0.12682670f, 0.26460207f, -0.09632039f, -0.06131678f, -0.05277534f, -0.06790292f, 
    -0.15075408f, 0.11610333f, 0.03062693f, 0.05556806f, -0.07263473f, -0.05706847f, -0.03837293f, -0.12440812f, 
    0.02817524f, -0.01683302f, -0.05007486f, 0.06408393f, 0.01253480f, 0.13364720f, 0.08907101f, 0.03184742f, 
    -0.00052130f, 0.00082127f, -0.06631302f, -0.14608136f, 0.05769339f, 0.03757976f, -0.01938841f, 0.00317848f, 
    -0.03476248f, 0.13037626f, -0.04487810f, -0.13014260f, 0.10475787f, -0.01005617f, -0.15724608f, 0.10655628f, 
    -0.01341997f, 0.02619985f, -0.05109351f, 0.01154014f, 0.20069705f, -0.03532396f, 0.03131944f, -0.16015963f, 
    -0.00945976f, -0.01014053f, -0.08234028f, 0.18835853f, 0.02599561f, -0.02797288f, -0.00559470f, -0.04219776f, 
    0.17328918f, 0.04939538f, 0.20766677f, 0.20450810f, -0.03968678f, -0.03016466f, -0.02625757f, -0.10713411f, 
    -0.08594801f, -0.20244724f, -0.02158968f, 0.00540569f, -0.11029764f, -0.19992304f, 0.01381742f, -0.00024424f, 
    0.26048410f, 0.10067116f, 0.13518873f, 0.26642296f, 0.07063818f, -0.12315226f, -0.08999655f, 0.05425216f, 
    -0.05835623f, -0.01547318f, 0.09258205f, -0.13726494f, 0.02592762f, 0.07269029f, 0.00613366f, -0.01623142f, 
    0.13359256f, -0.07147469f, 0.01041956f, -0.01636836f, 0.03561552f, 0.13167261f, 0.04084728f, 0.13773909f, 
    0.01085334f, -0.05694589f, -0.00059453f, -0.01732923f, -0.08061289f, 0.03367437f, -0.12183332f, 0.00123174f, 
    0.01840675f, -0.12119947f, -0.19186980f, -0.26127285f, 0.05893663f, -0.08808374f, -0.04133052f, 0.19035155f, 
    0.13366416f, 0.00327689f, -0.06227453f, 0.03672386f, 0.08094049f, 0.02781086f, -0.01858209f, 0.03209843f, 
    0.01513651f, -0.02012078f, -0.06214464f, -0.04724655f, -0.02941960f, 0.08681429f, -0.04619731f, 0.06122902f, 
    -0.03261998f, 0.00871877f, 0.11158497f, 0.05930334f, -0.11951707f, 0.02091304f, 0.03304913f, -0.09724287f, 
    0.02480576f, -0.06151021f, -0.14148028f, -0.05999099f, -0.20329063f, 0.12755190f, 0.12223743f, -0.06069468f, 
    0.06891719f, 0.05298080f, 0.11480337f, -0.07569718f, 0.08662427f, 0.03562638f, 0.01359277f, -0.01561408f, 
    0.02502715f, -0.04009287f, -0.01194858f, -0.00101456f, 0.00298732f, -0.00726649f, 0.00682796f, -0.02761283f, 
    0.02875707f, -0.01690844f, 0.02699788f, -0.03267782f, -0.03060521f, -0.00547572f, -0.02257912f, -0.01418809f, 
    0.01052089f, -0.01268340f, -0.03501426f, -0.02936416f, -0.00695517f, 0.00472392f, 0.00854176f, -0.00177153f, 
    0.00291853f, -0.00493684f, -0.02898758f, 0.02226884f, -0.04155640f, 0.02437916f, 0.01591783f, 0.02343357f, 
    -0.03126761f, -0.00951654f, 0.01028234f, 0.02234751f, 0.00169550f, -0.03542799f, -0.00483167f, -0.01383827f, 
    -0.02450839f, -0.01200899f, 0.02288125f, -0.00839298f, 0.00427028f, 0.02616608f, -0.00408193f, 0.01963146f, 
    0.03372473f, -0.00886586f, -0.00684969f, 0.03535128f, 0.01157703f, -0.00930313f, 0.02675144f, 0.02615871f, 
    -0.03322396f, -0.03333303f, 0.03271595f, 0.01115139f, -0.00976616f, 0.00647073f, -0.03972214f, -0.01885546f, 
    0.01556842f, -0.03128216f, 0.02848856f, 0.02093323f, -0.01466721f, 0.02677684f, 0.00043841f, -0.02006180f, 
    0.01872718f, 0.00861900f, -0.03583770f, -0.01547035f, -0.00668311f, -0.03752678f, 0.00335577f, 0.02919075f, 
    -0.03749856f, -0.00845118f, 0.00560106f, -0.01908076f, 0.02799652f, 0.01489242f, -0.02179534f, -0.02535244f, 
    0.02610688f, -0.01484491f, 0.01883607f, -0.00936573f, -0.03350676f, -0.04080393f, -0.00940275f, 0.00476627f, 
    -0.00457655f, 0.01664488f, -0.01796124f, 0.01577382f, -0.00198821f, 0.00908684f, 0.01347915f, -0.01566048f, 
    0.01672697f, 0.00662520f, -0.00923226f, 0.02145266f, -0.01562185f, -0.01721903f, -0.00628181f, -0.02609351f, 
    0.03095397f, -0.03305074f, 0.00629569f, 0.02185754f, -0.01777102f, -0.03917872f, 0.01921668f, 0.00529502f, 
    -0.01717087f, -0.02394242f, -0.03054435f, -0.00709146f, -0.02104524f, -0.01751759f, -0.02565604f, -0.00840172f, 
    -0.03414316f, -0.02038675f, 0.02391306f, 0.00980841f, -0.01095508f, 0.00526913f, 0.02000087f, -0.03281137f, 
    -0.03194766f, -0.02652578f, -0.01225106f, -0.00446674f, -0.00291350f, -0.01890837f, -0.02438682f, -0.03018924f, 
    -0.00177075f, -0.01980198f, -0.03873911f, -0.02801459f, -0.01009856f, -0.02679967f, -0.04014640f, -0.00265685f, 
    0.01698727f, -0.00045617f, 0.00451740f, -0.04062443f, 0.00145296f, -0.03267424f, -0.00186734f, -0.02820013f, 
    0.02993194f, -0.00844452f, -0.00029413f, 0.01425540f, -0.03527197f, -0.01867246f, 0.00236626f, -0.04131006f, 
    -0.01838523f, -0.01984926f, -0.00999407f, -0.00918588f, -0.01306417f, 0.02784639f, -0.00105657f, -0.02597467f, 
    -0.01461540f, 0.00864002f, 0.00961971f, -0.03658542f, -0.03383122f, -0.00652822f, 0.00507025f, 0.02358105f, 
    0.00040150f, -0.02153349f, -0.01178511f, 0.02261060f, 0.02822508f, -0.02047202f, -0.00140832f, 0.01256452f, 
    0.02449486f, -0.02233086f, -0.01735024f, 0.01324346f, -0.02281759f, 0.02278064f, 0.01907555f, -0.01838349f, 
    -0.03482962f, -0.03450729f, -0.02084246f, 0.00284902f, -0.00604392f, 0.02420276f, -0.02856444f, -0.02441614f, 
    0.02113970f, -0.02074382f, 0.00092903f, -0.03852636f, 0.01944856f, 0.02953998f, 0.01063863f, 0.00894354f, 
    -0.03162609f, 0.02711246f, -0.01492557f, 0.02209479f, -0.03205583f, -0.00703522f, 0.01194706f, 0.00604706f, 
    -0.03686194f, 0.01489396f, -0.02282494f, -0.00502222f, 0.01547770f, -0.01238374f, -0.02644201f, -0.00558846f, 
    -0.00592060f, -0.01213144f, 0.01384008f, 0.02958108f, 0.01911112f, 0.00571319f, 0.01530439f, -0.02803673f, 
    -0.03011748f, 0.02959250f, -0.03837662f, 0.00130071f, 0.03523125f, 0.03208440f, 0.02980528f, 0.02011016f, 
    -0.03609869f, -0.03744812f, -0.02551679f, 0.02977058f, 0.01040852f, -0.01114590f, -0.02665745f, -0.03450487f, 
    0.00326531f, 0.02624211f, -0.01245584f, -0.00545393f, -0.01557556f, -0.02681761f, -0.00681691f, 0.03224114f, 
    0.01011292f, -0.00656415f, -0.01754887f, 0.00800759f, -0.01971563f, 0.01179999f, 0.01720982f, -0.03485269f, 
    -0.01126751f, 0.00862676f, -0.01220098f, 0.00635409f, -0.03296380f, -0.01844423f, -0.01806737f, -0.01778275f, 
    0.00903411f, -0.04113280f, -0.01994889f, 0.01102265f, 0.01002503f, -0.02506601f, -0.01543577f, -0.03176762f, 
    -0.00502404f, 0.01013960f, -0.03697323f, -0.03982199f, -0.00348419f, 0.00495132f, 0.01125601f, -0.01234571f, 
    -0.00730057f, -0.00046848f, 0.01098665f, 0.01572950f, -0.04090185f, 0.00349298f, 0.01853227f, -0.00736365f, 
    -0.00702810f, -0.02531441f, -0.03390709f, -0.01849445f, -0.01179906f, 0.00369969f, -0.02228897f, 0.00333285f, 
    0.02566244f, -0.00443566f, -0.02878835f, -0.03423290f, -0.00433482f, 0.01407166f, -0.02478004f, -0.01662895f, 
    0.02370183f, -0.00340586f, 0.02181244f, 0.02526426f, -0.03320899f, 0.02520127f, 0.01039310f, 0.01308367f, 
    0.01631470f, -0.03659631f, 0.01700720f, 0.02272107f, 0.00029868f, -0.01625079f, -0.00761286f, -0.00814478f, 
    -0.02609675f, -0.02126767f, 0.00454808f, -0.03469452f, 0.02665360f, -0.02432548f, -0.00278042f, 0.02582661f, 
    0.01973313f, -0.03931036f, 0.00139805f, 0.00886529f, 0.01971472f, 0.01247333f, 0.02757321f, 0.02015993f, 
    -0.02393968f, 0.00671919f, 0.01049550f, 0.00771991f, -0.01317051f, -0.01195255f, 0.01831339f, 0.00999718f, 
    -0.02012977f, 0.02073872f, 0.01783228f, 0.01081963f, 0.02727754f, 0.02925450f, 0.01839810f, -0.03186353f, 
    0.01191286f, 0.00877430f, -0.03222744f, -0.03710130f, -0.02618379f, 0.02883700f, -0.02565230f, -0.04015084f, 
    -0.01117614f, -0.04207077f, -0.02281673f, -0.01154484f, 0.02591088f, -0.00659165f, -0.02298371f, -0.02140695f, 
    0.00762560f, 0.00290315f, -0.04048289f, -0.04181092f, -0.02837664f, 0.02842180f, -0.01177685f, -0.01993911f, 
    0.02326021f, -0.04173310f, -0.03009885f, -0.00421263f, 0.00062063f, 0.00312042f, -0.03406925f, -0.02800376f, 
    -0.00257219f, -0.00586576f, 0.01179142f, 0.01028671f, -0.03053099f, 0.00435447f, -0.02631073f, 0.03296635f, 
    0.01730397f, 0.01039846f, -0.02243789f, 0.00845308f, -0.02872113f, 0.00452150f, 0.02520961f, 0.00987562f, 
    0.03598285f, -0.03525349f, 0.02931591f, 0.01749543f, 0.02295961f, -0.03514890f, -0.03314892f, -0.03800818f, 
    0.02713584f, 0.00866693f, -0.02539390f, 0.01359337f, -0.03131989f, 0.02061030f, 0.01536485f, 0.00145901f, 
    -0.01149644f, -0.02452494f, 0.00546686f, 0.00275988f, 0.02642145f, -0.02850586f, 0.00540903f, 0.02194836f, 
    -0.01359924f, -0.04180260f, 0.03143735f, -0.00361340f, -0.04052356f, 0.00101650f, 0.00727787f, -0.00176618f, 
    -0.00237412f, 0.02715213f, -0.01309369f, -0.03913895f, -0.02411037f, 0.01535600f, -0.01671883f, -0.03301849f, 
    0.00739561f, 0.02939134f, -0.03048132f, -0.00872541f, 0.02202808f, 0.00431504f, 0.02768143f, 0.00543731f, 
    -0.03081634f, -0.00010732f, 0.00104647f, 0.01224880f, -0.01331654f, -0.01218400f, -0.02583428f, -0.04195550f, 
    -0.02318048f, -0.03149701f, -0.01302442f, 0.01172794f, 0.01839978f, 0.00629422f, -0.02591096f, -0.03868689f, 
    -0.03980270f, -0.00425195f, 0.00598674f, 0.01052622f, -0.03765594f, -0.02176813f, -0.01051717f, -0.02683761f, 
    0.03601956f, -0.04132566f, -0.01218734f, -0.03312318f, -0.03202874f, -0.00449706f, -0.03099222f, -0.00023626f, 
    -0.01000293f, -0.02692742f, -0.00558411f, -0.04166967f, -0.04097627f, -0.02502541f, -0.02899051f, -0.01383168f, 
    -0.02984833f, 0.00779134f, -0.01655983f, 0.02411856f, -0.00150841f, -0.00122189f, 0.01908408f, -0.01594243f, 
    0.00646891f, 0.01104356f, 0.01115936f, 0.00886274f, 0.02044124f, -0.02061904f, -0.02984531f, -0.03901814f, 
    -0.03068576f, -0.02766812f, -0.01321513f, 0.02922006f, 0.02964192f, -0.02371589f, 0.02646053f, -0.01575426f, 
    -0.02783014f, -0.02498160f, -0.02176308f, -0.03364388f, -0.02481254f, -0.02546608f, -0.02638062f, 0.00732834f, 
    0.01103041f, 0.02098155f, -0.02461203f, 0.00452151f, -0.01698035f, 0.00023895f, 0.02137187f, -0.01738826f, 
    0.01050868f, -0.02662651f, 0.01449838f, -0.02769762f, 0.02522358f, -0.02030306f, -0.02128661f, -0.01662120f, 
    0.01518951f, -0.04177752f, -0.00345085f, -0.00135177f, 0.00548893f, -0.02379959f, -0.03633816f, -0.00511347f, 
    -0.00996686f, 0.03385238f, 0.02951778f, 0.00094327f, 0.01847553f, -0.02376953f, -0.02200716f, 0.00974086f, 
    -0.00743838f, -0.01005182f, -0.02416888f, 0.01035571f, 0.00879316f, -0.02254280f, -0.00877088f, -0.00523502f, 
    -0.01555546f, 0.01514162f, -0.01954321f, -0.02750973f, -0.00771682f, 0.00462898f, 0.00057715f, 0.01874732f, 
    -0.03433180f, -0.02422567f, 0.02408241f, -0.03365911f, 0.01200482f, 0.00422913f, -0.03202928f, 0.01016169f, 
    -0.03053422f, -0.00981283f, 0.00258799f, 0.01640713f, 0.03101450f, 0.01230035f, -0.01998883f, 0.00746479f, 
    0.00864655f, 0.02020582f, -0.03929940f, -0.03535636f, -0.00450328f, 0.01070166f, -0.01262870f, 0.00625621f, 
    -0.01259647f, -0.00210751f, 0.01427368f, -0.03170753f, -0.02131152f, -0.02605598f, -0.03436440f, 0.03464433f, 
    -0.01446314f, -0.01195941f, 0.02589284f, -0.01121318f, 0.02880752f, -0.03557794f, 0.01755683f, 0.00017763f, 
    -0.02757614f, 0.00822362f, 0.00353443f, 0.00391224f, 0.00575039f, -0.01047027f, 0.02417026f, -0.01911730f, 
    -0.01099602f, -0.03088219f, -0.02620709f, -0.03684484f, 0.02018434f, -0.00792730f, 0.00736428f, 0.01617878f, 
    0.02606459f, -0.04082685f, -0.03945874f, -0.00337309f, -0.00026355f, 0.02778506f, -0.01737532f, 0.00125419f, 
    -0.01660641f, 0.00913365f, -0.03086838f, -0.02761830f, -0.02854129f, 0.03075327f, -0.01390088f, -0.00633703f, 
    -0.03506467f, -0.02596165f, 0.00258783f, 0.00332335f, -0.00714171f, -0.00778309f, -0.02498020f, -0.01149044f, 
    0.02560072f, -0.02163969f, -0.00977141f, 0.02768307f, -0.01154535f, 0.00713416f, 0.01745288f, -0.01998236f, 
    0.00976923f, -0.01636194f, 0.01743957f, -0.01026172f, 0.01826311f, 0.01885222f, -0.01148821f, -0.01057464f, 
    -0.01572192f, -0.00766988f, -0.02145309f, -0.02266274f, -0.01923029f, 0.03410005f, -0.01682447f, -0.03038447f, 
    -0.00457825f, 0.00783778f, -0.02011395f, -0.03581556f, 0.01418137f, 0.02681716f, -0.03011878f, 0.02570035f, 
    0.02217521f, 0.00152478f, -0.01900771f, -0.00546635f, 0.02703897f, -0.04049777f, 0.01689389f, -0.02027966f, 
    -0.03174896f, 0.01457179f, -0.03607125f, -0.01427477f, -0.00593445f, 0.02515888f, 0.02013719f, 0.00425377f, 
    -0.02418334f, 0.00609040f, -0.03428176f, -0.00574479f, -0.01113637f, 0.01963512f, 0.00074193f, 0.01996131f, 
    0.01318448f, 0.00666736f, 0.00823215f, 0.01853106f, -0.03045705f, 0.01957591f, 0.00468164f, 0.02557163f, 
    -0.03925396f, -0.03631167f, -0.00621212f, 0.00325887f, -0.00877395f, -0.01376858f, -0.01603247f, 0.01330297f, 
    -0.00879840f, -0.01868431f, 0.02782299f, 0.00655326f, 0.01019588f, -0.03119741f, 0.00853579f, 0.01388091f, 
    -0.00248980f, 0.00345469f, 0.01592169f, 0.01074076f, -0.02850292f, -0.00546969f, -0.02861463f, -0.02903663f, 
    -0.03527359f, 0.00606616f, -0.03085335f, -0.03028956f, 0.00685287f, -0.02573529f, 0.02069685f, 0.00676018f, 
    -0.00993863f, -0.02951861f, -0.00220800f, -0.02705952f, -0.01696077f, -0.01818787f, -0.01649767f, 0.00374075f, 
    0.01143312f, 0.08607462f, 0.17798997f, -0.01112143f, 0.09100694f, -0.11384173f, 0.09835288f, 0.06853027f, 
    -0.13455306f, -0.13038310f, -0.11916204f, 0.04426366f, -0.12054648f, -0.02306995f, -0.17946795f, -0.11485873f, 
    -0.12267084f, -0.09052399f, 0.01743203f, 0.02193305f, 0.16104105f, 0.07392962f, 0.19668150f, 0.02470350f, 
    0.07244927f, 0.01723383f, 0.11888272f, -0.00407881f, -0.03568071f, 0.10883044f, -0.00264342f, 0.08365104f, 
    0.15951931f, 0.19222251f, 0.14457251f, 0.28696314f, -0.03149569f, 0.00951616f, -0.23585434f, 0.02077416f, 
    0.12348549f, -0.04021461f, 0.03365844f, -0.01638739f, -0.09249645f, -0.01499009f, -0.00055334f, 0.01878197f, 
    -0.34385014f, 0.10369007f, 0.11011731f, 0.14527081f, -0.14948218f, -0.11769585f, -0.02519430f, 0.07914782f, 
    0.05736600f, 0.08833229f, 0.14512897f, -0.00706439f, -0.14723156f, 0.06274597f, -0.04840576f, 0.00141885f, 
    0.02545228f, 0.07988133f, 0.08833240f, 0.08796416f, -0.23632252f, -0.07046059f, 0.00611227f, 0.19413102f, 
    -0.09244607f, -0.07181623f, -0.07381902f, -0.06786597f, -0.19564332f, 0.04213087f, 0.02135531f, 0.05902334f, 
    -0.09030721f, 0.00855180f, 0.02688268f, -0.00557877f, -0.21073353f, 0.13219918f, -0.26255468f, 0.05763583f, 
    0.19721034f, -0.13161536f, 0.01114613f, 0.06714273f, -0.03749745f, 0.15655872f, -0.03207376f, 0.07269935f, 
    -0.01185920f, -0.27588627f, -0.23420407f, -0.04173010f, 0.01827635f, -0.02113405f, -0.06143402f, -0.07296227f, 
    0.00408359f, 0.03278099f, 0.12949270f, 0.14887707f, 0.34469348f, -0.15374643f, 0.15119269f, -0.05221426f, 
    0.06006742f, 0.13711672f, -0.09786297f, -0.16396552f, -0.13600537f, -0.13135535f, -0.01215372f, 0.00465421f, 
    0.20585801f, 0.09607738f, -0.05061806f, -0.00013286f, 0.10948224f, -0.08294745f, 0.01167427f, -0.12130769f, 
    -0.08497950f, -0.05179235f, 0.03303372f, 0.05015755f, -0.12529081f, 0.00956231f, -0.01418098f, 0.03427696f, 
    0.06696499f, 0.03223637f, -0.05198264f, 0.06917915f, 0.00339688f, 0.01189685f, 0.33065796f, 0.09879760f, 
    -0.23091879f, 0.59931082f, -0.13205919f, 0.30776358f, 0.06716666f, 0.12632711f, 0.20819600f, 0.17116416f, 
    -0.06177212f, -0.00197455f, 0.19258878f, -0.09396764f, 0.10124283f, 0.01780579f, -0.01475817f, -0.29545239f, 
    -0.08309772f, -0.05552392f, 0.11192004f, 0.02291310f, 0.00607066f, -0.06184862f, 0.06278761f, -0.10789156f, 
    -0.16587144f, -0.05374435f, 0.01035579f, -0.07223740f, -0.05957777f, -0.12761106f, 0.08493682f, -0.01164318f, 
    -0.12782505f, -0.03599865f, 0.00074164f, -0.10342022f, -0.12119579f, -0.18484440f, -0.25557929f, -0.10486296f, 
    0.19844776f, 0.03430407f, -0.04585502f, -0.14055863f, -0.02686202f, 0.03593184f, 0.02928251f, 0.10094648f, 
    -0.11014433f, 0.22508585f, 0.20246635f, 0.24969545f, -0.04175998f, 0.08347336f, 0.06281461f, 0.06667157f, 
    0.14938578f, 0.13990414f, 0.30040327f, 0.03631557f, -0.19180547f, -0.15515932f, -0.00690331f, -0.08867241f, 
    -0.14203334f, -0.01422061f, 0.02082773f, -0.15597014f, 0.10351844f, -0.10649814f, 0.05667976f, 0.09269740f, 
    0.11979712f, 0.25453517f, -0.03600286f, 0.12057561f, 0.08774828f, -0.05975594f, 0.16559622f, -0.10249686f, 
    0.15410271f, 0.18082495f, -0.05625270f, 0.09004293f, 0.14376757f, 0.00173858f, 0.11771475f, 0.10310065f, 
    -0.04352029f, -0.11097789f, 0.06632601f, -0.08244611f, -0.06275617f, -0.05846260f, -0.04284063f, -0.27615336f, 
    0.03026176f, 0.02199016f, 0.01003926f, -0.05436255f, 0.06456145f, 0.08442759f, 0.08463292f, -0.13914350f, 
    -0.08251530f, -0.08566927f, -0.00915864f, 0.06382416f, 0.13425609f, 0.09085004f, -0.00407404f, 0.12746643f, 
    0.08851526f, 0.11495502f, 0.32006291f, -0.00699895f, 0.14867112f, 0.26221168f, 0.05289874f, 0.13339500f, 
    -0.21916248f, -0.08362414f, 0.07260428f, -0.13070793f, -0.20203522f, -0.19588169f, -0.10765970f, -0.22188996f, 
    -0.06983946f, -0.10997345f, -0.06716638f, -0.08220451f, -0.33703944f, -0.00274881f, 0.30493724f, -0.12305354f, 
    -0.00594200f, -0.04488023f, 0.06653516f, 0.03100419f, -0.12341200f, 0.01446845f, -0.03664042f, 0.17041218f, 
    -0.00674776f, -0.09614832f, 0.04160869f, -0.11429244f, -0.10862396f, 0.10552240f, 0.03188374f, -0.06643817f, 
    -0.09375442f, -0.06195310f, -0.06097596f, -0.06564077f, 0.20269381f, 0.02065559f, 0.06057557f, 0.05634756f, 
    -0.04436350f, 0.03101874f, -0.01400822f, -0.02081992f, -0.06741310f, 0.01501105f, -0.07840797f, 0.00794528f, 
    0.38121012f, -0.02332511f, -0.22132879f, 0.03917333f, -0.01297289f, 0.01555104f, -0.04047908f, 0.17161088f, 
    0.17332225f, 0.04569755f, 0.07856432f, 0.12829140f, 0.18124497f, -0.05814730f, -0.06023841f, 0.05734293f, 
    0.02601554f, 0.08119091f, 0.06270774f, 0.15219165f, 0.07729761f, 0.07255001f, 0.07928193f, 0.03043318f, 
    0.16596289f, 0.03721887f, -0.16668205f, 0.11322052f, 0.03965585f, -0.01706000f, 0.03602907f, -0.03672840f, 
    -0.11683750f, 0.00497545f, -0.04973799f, 0.01319500f, -0.02604170f, -0.01391937f, -0.21083540f, -0.28614578f, 
    0.02020514f, -0.10919920f, -0.05032614f, -0.13213030f, -0.03684544f, -0.00853193f, -0.04489109f, -0.05232889f, 
    -0.16505553f, 0.11004665f, -0.20004705f, 0.07524183f, -0.04463891f, -0.05801045f, -0.06242901f, 0.11154665f, 
    -0.06385539f, 0.02091012f, -0.09517298f, -0.15551423f, -0.00572861f, 0.03764836f, 0.07063127f, 0.03940475f, 
    0.16866611f, 0.06327228f, -0.12247010f, 0.00303316f, -0.11319479f, -0.05194390f, -0.11947200f, -0.05182388f, 
    0.14070652f, 0.02938285f, 0.06022479f, -0.03060636f, -0.06485803f, -0.06394565f, 0.02297233f, 0.00824922f, 
    -0.11977442f, -0.01177043f, 0.02870522f, -0.02005638f, 0.05599613f, -0.08488553f, -0.13987730f, -0.04547048f, 
    -0.08420470f, 0.08342578f, -0.04983478f, -0.00124468f, -0.01993203f, 0.06129698f, 0.18238480f, 0.05662850f, 
    0.07832543f, 0.06953470f, 0.05730179f, -0.00242748f, -0.18350275f, -0.01329742f, -0.01734860f, 0.10879210f, 
    0.04754284f, -0.03053745f, 0.10257801f, 0.11568651f, -0.14720497f, 0.08581746f, 0.07301722f, -0.08243780f, 
    -0.02107200f, -0.14874084f, 0.07063048f, -0.04618650f, -0.07203729f, -0.12798418f, 0.02873563f, -0.17184649f, 
    0.38753539f, 0.33343220f, -0.08070789f, 0.33510506f, 0.01784426f, 0.08415192f, 0.03181240f, 0.09769668f, 
    0.01001680f, 0.21308415f, -0.11324383f, 0.09090021f, 0.14322683f, 0.07206570f, 0.11789385f, 0.14568943f, 
    0.02914933f, -0.03149146f, -0.05827179f, 0.00824137f, -0.03886382f, 0.07428242f, 0.00351030f, 0.02356354f, 
    -0.06721187f, 0.11346882f, -0.02915738f, 0.04098880f, -0.09434830f, -0.05930667f, 0.14867395f, 0.01007273f, 
    0.12182685f, 0.09339823f, 0.12800826f, 0.14763917f, -0.21864879f, 0.27220166f, -0.20808814f, 0.34731078f, 
    0.14208730f, 0.08676509f, 0.15125416f, 0.10445420f, 0.05237731f, 0.03800721f, 0.05971928f, -0.11344016f, 
    -0.02096440f, -0.37157556f, -0.01935088f, -0.12111135f, 0.14509605f, 0.14509673f, -0.01096578f, 0.01206409f, 
    -0.01120974f, -0.16198091f, 0.01191763f, -0.01548296f, 0.13146964f, 0.07106563f, 0.09367274f, 0.01882648f, 
    -0.04304881f, 0.02576951f, 0.11097139f, 0.12412893f, 0.07765781f, 0.09388585f, -0.01292184f, 0.06464519f, 
    -0.09321532f, -0.29894736f, -0.22736488f, -0.43544275f, -0.15671480f, -0.00909171f, -0.14076464f, 0.02454407f, 
    -0.10655462f, -0.05923493f, -0.06595825f, -0.08573673f, -0.10126057f, 0.07184172f, -0.17724538f, 0.09545992f, 
    -0.10758101f, -0.15678240f, -0.03439862f, -0.03318012f, -0.05225888f, -0.00615649f, -0.17226832f, -0.31705573f, 
    0.02182012f, 0.16041860f, 0.06543215f, 0.18192740f, -0.00079894f, 0.09074226f, -0.00543059f, -0.00578854f, 
    -0.01578795f, 0.32872194f, 0.23605670f, 0.13982807f, 0.38806853f, 0.38067219f, 0.04862277f, 0.08664014f, 
    -0.03007588f, -0.06948123f, -0.04405075f, 0.01593117f, -0.10658126f, -0.05077762f, -0.06353728f, -0.03862249f, 
    0.05290761f, -0.05104999f, -0.22185704f, -0.08463976f, -0.01877205f, -0.07179786f, 0.00979731f, 0.03409588f, 
    0.18674599f, 0.21101348f, -0.14050142f, 0.08169762f, 0.00459426f, -0.01078773f, -0.06268632f, -0.01564845f, 
    -0.10225834f, -0.03279569f, -0.05046604f, -0.06261858f, 0.10185173f, 0.00868799f, 0.04255490f, 0.01289350f, 
    -0.27690798f, 0.26461455f, 0.10653633f, -0.12166536f, -0.01987015f, 0.01883517f, 0.03879682f, 0.14450286f, 
    -0.11080232f, -0.08262558f, 0.15400778f, 0.12601589f, -0.16611953f, 0.08106866f, -0.05043381f, -0.06595735f, 
    -0.16006707f, -0.07102704f, -0.04393003f, -0.03971249f, -0.03380160f, -0.00022349f, 0.11610235f, -0.01378991f, 
    -0.00200708f, 0.05468746f, 0.09591527f, 0.08043464f, -0.02400509f, 0.06527392f, -0.02793723f, 0.03501376f, 
    0.20817989f, -0.00769654f, 0.11815540f, 0.12773299f, 0.07731638f, -0.14013727f, -0.03583744f, -0.19017638f, 
    -0.21355714f, -0.03027605f, 0.09510004f, 0.01727086f, 0.05492350f, -0.01848057f, 0.00588727f, -0.02923675f, 
    -0.08382955f, 0.09076218f, 0.11211260f, 0.10741004f, -0.06298482f, 0.01610876f, 0.02692842f, 0.05809452f, 
    0.01267017f, 0.07484631f, -0.02409121f, -0.05045510f, 0.01775616f, 0.03378258f, 0.12641473f, 0.06538416f, 
    0.02569499f, 0.00286059f, 0.03627982f, 0.06468224f, 0.00064624f, 0.13403389f, 0.00831703f, 0.00715283f, 
    -0.10950764f, -0.01100064f, -0.27167857f, 0.09702158f, 0.07045574f, -0.08185798f, 0.03753236f, -0.01696574f, 
    0.13650969f, 0.15431993f, 0.19426905f, 0.05432994f, -0.15395273f, -0.17270628f, -0.04183179f, 0.05760465f, 
    -0.01391488f, 0.10595776f, 0.12257586f, 0.19216681f, 0.06321716f, 0.12797622f, 0.25055388f, 0.07920679f, 
    0.20460594f, 0.01855258f, 0.14839974f, 0.03509944f, 0.02068892f, -0.02575339f, -0.03421379f, 0.04191870f, 
    -0.06670057f, 0.03094863f, 0.21660593f, 0.02662309f, -0.14040680f, -0.17205147f, -0.01791178f, -0.21162571f, 
    -0.36002892f, 0.02519392f, 0.09638730f, -0.14621475f, -0.05654045f, -0.12523541f, 0.01873982f, -0.11914969f, 
    -0.46575570f, 0.01247546f, -0.30827415f, -0.15158594f, -0.05274507f, -0.00718379f, -0.04124828f, 0.15913926f, 
    0.15347995f, 0.20998611f, 0.07953262f, -0.11717987f, 0.18211232f, 0.14774159f, 0.17642790f, 0.08203454f, 
    -0.01433580f, -0.03507008f, 0.02419849f, 0.06657080f, -0.06521796f, 0.02355809f, -0.04464148f, -0.08152869f, 
    -0.15421568f, -0.14312258f, -0.17435393f, -0.00736255f, -0.04376844f, -0.04301723f, -0.05465407f, 0.11955424f, 
    0.10874977f, 0.08381278f, 0.02837594f, 0.13988283f, 0.22843726f, -0.03132011f, 0.00008716f, 0.10798453f, 
    0.00866200f, -0.02545145f, 0.02672547f, 0.04702885f, -0.02836322f, -0.06032125f, 0.01683394f, -0.01447328f, 
    0.07011392f, 0.18065867f, 0.02947191f, 0.05142469f, -0.03995796f, -0.03684658f, 0.01749788f, 0.08308414f, 
    -0.04011378f, -0.04772821f, -0.01505997f, -0.12670828f, 0.00709929f, -0.13782912f, 0.16719949f, -0.11064000f, 
    0.06161437f, 0.30511820f, 0.09873796f, 0.12550201f, 0.17751887f, 0.01525067f, -0.12375973f, 0.11190806f, 
    0.40107176f, -0.28210223f, -0.03779546f, 0.00084028f, -0.04809261f, 0.03053580f, 0.02242818f, 0.11093367f, 
    -0.06617622f, 0.18809620f, 0.21451296f, -0.05766255f, -0.00696832f, -0.05606415f, 0.04295745f, -0.01787633f, 
    0.13832189f, 0.11557136f, 0.00340593f, 0.09334858f, -0.14401688f, -0.12775484f, -0.08717851f, 0.02808951f, 
    0.03649954f, 0.03222828f, 0.06247173f, 0.01667371f, 0.06066035f, 0.01537111f, 0.02426094f, 0.02725006f, 
    0.20746388f, 0.04816692f, 0.10888811f, 0.11041305f, 0.16857941f, -0.00267848f, 0.24690679f, -0.16407353f, 
    -0.17812000f, -0.10232686f, -0.13914600f, -0.02747216f, -0.08746651f, 0.01638601f, 0.05317316f, -0.02488362f, 
    0.37768874f, -0.17295234f, 0.03946314f, 0.15526991f, 0.02498551f, 0.04564459f, 0.08477001f, 0.12435562f, 
    -0.16580623f, -0.02346451f, 0.08973072f, 0.15142475f, 0.40587988f, -0.01144497f, 0.14753914f, -0.06747521f, 
    -0.04387392f, 0.00893237f, -0.05714979f, 0.07504994f, -0.09707964f, -0.08407326f, -0.27317587f, -0.00774619f, 
    -0.01183943f, -0.10073706f, 0.05405605f, 0.27670556f, -0.09923415f, -0.24275310f, -0.01971135f, 0.03351927f, 
    0.01252262f, -0.02259346f, -0.03175136f, 0.06972364f, -0.14997938f, -0.10064410f, -0.07787686f, 0.11021663f, 
    0.02868751f, -0.08261783f, -0.15134186f, -0.12656701f, -0.05576304f, -0.10349444f, -0.14284472f, 0.02186226f, 
    -0.02110172f, -0.11939728f, 0.01075969f, 0.04424702f, 0.24676064f, 0.02519374f, 0.13531409f, 0.12839030f, 
    -0.03652354f, -0.05269728f, 0.01478431f, 0.07476605f, -0.06044919f, 0.12536824f, -0.13108742f, 0.10152721f, 
    -0.14680178f, -0.15680799f, -0.13300858f, -0.03116779f, 0.06837726f, 0.04881064f, 0.02048822f, 0.10132422f, 
    0.18369602f, 0.09401034f, 0.10434539f, 0.19892450f, -0.08315997f, 0.02215764f, 0.02063479f, -0.02647352f, 
    0.02061966f, 0.04447362f, 0.02520895f, 0.04157146f, -0.01770299f, -0.03461060f, 0.05243699f, 0.10362324f, 
    -0.00104155f, 0.03769900f, 0.05797110f, -0.07778563f, 0.03068164f, 0.02319351f, -0.09754296f, -0.06801934f, 
    0.34273067f, -0.26287800f, 0.15708828f, 0.02624797f, -0.14003119f, 0.20829666f, 0.07868467f, 0.14517301f, 
    0.01921636f, 0.05524244f, 0.07883117f, -0.07488832f, -0.18424438f, 0.15976711f, -0.05568604f, 0.11339346f, 
    -0.01409473f, 0.03317515f, -0.15226141f, -0.05796801f, -0.10884629f, -0.07958189f, -0.04650920f, -0.02834779f, 
    0.13522065f, -0.08347739f, -0.01211398f, -0.31317261f, 0.03800415f, -0.07008003f, -0.17964610f, 0.14007032f, 
    -0.04319729f, -0.00308274f, 0.08200666f, 0.00289686f, -0.21342464f, 0.02757310f, -0.10357746f, 0.06493648f, 
    -0.00140685f, 0.08472090f, 0.11336282f, 0.07749264f, -0.06865136f, -0.05877666f, -0.03661634f, -0.05348241f, 
    0.20397510f, 0.02270481f, 0.06488402f, -0.03877594f, -0.07836585f, 0.06310290f, 0.03278944f, 0.01777807f, 
    -0.05204554f, -0.03388219f, -0.14293708f, -0.15242925f, -0.03274450f, -0.01754858f, -0.03962974f, -0.04520286f, 
    0.07542844f, 0.14436778f, 0.38225973f, 0.10776719f, -0.03294569f, 0.13764991f, 0.00269675f, 0.02442722f, 
    0.23100857f, -0.15798055f, 0.13748299f, 0.09384882f, -0.01226758f, 0.07322066f, 0.03607396f, -0.19292718f, 
    -0.02016830f, 0.17702551f, 0.05874147f, -0.04444401f, 0.02515414f, 0.33482251f, -0.02282996f, -0.01163628f, 
    -0.25483486f, -0.15039869f, 0.06205230f, 0.06911598f, -0.02844394f, 0.06907819f, 0.07763623f, -0.03125739f, 
    0.06270248f, -0.02025574f, -0.07081810f, 0.13195716f, -0.14496402f, -0.10590316f, 0.09630395f, 0.03331268f, 
    0.03921339f, 0.03911583f, 0.04045491f, 0.04680884f, 0.13055871f, -0.09489485f, 0.02052818f, -0.25574565f, 
    -0.02056029f, -0.05025736f, -0.11582351f, -0.11748742f, 0.02618588f, 0.08715813f, -0.01645136f, -0.02109190f, 
    -0.16931103f, 0.07324021f, -0.12696488f, 0.09393654f, -0.25034004f, -0.15496062f, -0.02562290f, -0.02671510f, 
    -0.03761835f, -0.05768601f, -0.08999024f, -0.07648221f, 0.30915552f, -0.16346839f, 0.08832853f, -0.10785517f, 
    -0.11796929f, 0.06168236f, 0.03876955f, 0.01067376f, -0.15668954f, -0.02681068f, -0.13128407f, -0.00002271f, 
    -0.08575031f, -0.05225838f, -0.03578337f, -0.09301359f, 0.01940851f, 0.00801380f, -0.11804794f, -0.24094285f, 
    -0.05425432f, 0.06774808f, 0.08232050f, -0.00259748f, 0.26381481f, 0.11419470f, -0.01785902f, 0.11376272f, 
    -0.06643578f, 0.05717150f, 0.03689662f, -0.03786917f, 0.02659339f, 0.09704278f, -0.03219251f, -0.05071682f, 
    0.36354584f, 0.23558362f, -0.04972057f, -0.26589254f, 0.06574752f, -0.03548339f, 0.04349890f, -0.00738839f, 
    0.14010282f, 0.05224870f, -0.01250807f, 0.08343220f, 0.10571098f, 0.03378088f, 0.13904449f, -0.07486018f, 
    0.11683730f, 0.06554200f, -0.00449922f, 0.03690561f, 0.21863927f, 0.00411726f, -0.15232886f, -0.19485582f, 
    0.20740792f, 0.04346725f, 0.00648072f, 0.05622495f, -0.06840758f, -0.18396080f, -0.02758185f, -0.03734684f, 
    0.02991770f, 0.07442509f, 0.04865024f, 0.04622550f, -0.12755059f, 0.00572868f, -0.01892532f, 0.13793401f, 
    -0.12673679f, -0.11468684f, -0.08804911f, 0.01651386f, -0.07818416f, -0.05119871f, -0.04203779f, 0.05101562f, 
    0.11835945f, -0.01356595f, 0.05253330f, -0.00404591f, 0.08471111f, -0.01265898f, -0.19609626f, 0.14071514f, 
    -0.05792275f, -0.12982684f, -0.01797361f, 0.01378914f, 0.02509977f, 0.06446513f, 0.02316332f, 0.10551847f, 
    -0.05652393f, -0.05848183f, 0.03701160f, -0.08377550f, -0.09662030f, -0.04015809f, 0.00287935f, 0.03007459f, 
    0.05937700f, 0.12448592f, 0.11668772f, 0.10934759f, -0.12307606f, -0.02279924f, 0.03418863f, 0.00534361f, 
    0.02398136f, -0.02901082f, -0.02947243f, 0.01772454f, 0.02542254f, -0.06678063f, 0.11110774f, -0.06421936f, 
    -0.01856813f, 0.02922664f, -0.06148008f, 0.04143487f, 0.05315433f, -0.08131868f, -0.07600315f, -0.07186456f, 
    -0.27424192f, 0.12499560f, 0.07991881f, 0.10108247f, -0.00217310f, 0.05655015f, 0.05692598f, 0.02814386f, 
    -0.04623185f, -0.02307470f, 0.05130219f, 0.13214804f, -0.15342863f, -0.02700252f, 0.00070711f, 0.07497505f, 
    -0.28742361f, 0.09989992f, -0.07046095f, -0.13019580f, -0.14953172f, -0.04143114f, 0.00726260f, -0.03600122f, 
    0.51958340f, 0.19428843f, 0.05797387f, -0.28971100f, -0.08705664f, -0.02773857f, 0.00185157f, 0.02050430f, 
    0.22264768f, 0.22369120f, 0.07232038f, -0.27649504f, 0.13271445f, -0.01440088f, 0.07993635f, 0.01335439f, 
    0.04450618f, -0.00153967f, 0.00780250f, -0.04609564f, 0.05870948f, 0.00279884f, -0.01634066f, 0.10588729f, 
    -0.04353153f, -0.08369076f, 0.22583173f, -0.07872355f, 0.12757400f, 0.03390959f, -0.05549807f, 0.04947418f, 
    -0.08936414f, 0.10790972f, -0.06970863f, -0.05919034f, 0.27914473f, -0.31496093f, 0.40434062f, 0.06906922f, 
    -0.00458642f, -0.01562559f, -0.17767248f, 0.15255933f, 0.06696073f, -0.08003782f, 0.06456987f, -0.08836608f, 
    -0.05908277f, 0.06265689f, -0.08362903f, -0.10301129f, 0.14209528f, 0.13316196f, -0.15351203f, 0.07944863f, 
    0.15761918f, 0.09058466f, 0.07685954f, 0.05408072f, 0.09885955f, 0.13128234f, 0.07496235f, 0.02926743f, 
    -0.04655507f, 0.03692537f, -0.09958508f, -0.03630128f, 0.14277788f, 0.08552863f, 0.03129081f, 0.07291161f, 
    -0.28285936f, 0.01196403f, -0.12466466f, 0.06299715f, -0.12141752f, 0.10647292f, 0.01326465f, -0.05187824f, 
    -0.07229988f, -0.10434899f, 0.02039388f, 0.01142401f, 0.35981053f, 0.05739520f, -0.04938341f, -0.31833303f, 
    -0.00094380f, -0.07888761f, 0.02391058f, 0.06873748f, -0.05530509f, 0.11454086f, 0.02131678f, 0.19610813f, 
    0.44925734f, -0.14399868f, 0.38947985f, -0.03031031f, 0.07199311f, 0.01008810f, 0.00545856f, 0.06155464f, 
    0.14362545f, 0.10514193f, -0.14260696f, -0.22237495f, 0.20448829f, 0.19082627f, 0.10314316f, 0.28165326f, 
    -0.00489957f, -0.16346280f, 0.03870984f, -0.01543996f, 0.02712496f, -0.03204338f, 0.00811811f, 0.01950898f, 
    0.05693488f, -0.14572228f, -0.00217498f, -0.05084413f, 0.13652240f, 0.04326806f, -0.00070658f, -0.00200196f, 
    0.04854966f, 0.18149310f, 0.08137248f, 0.02541797f, -0.24146484f, 0.08159090f, -0.12048665f, 0.00901406f, 
    -0.06878944f, 0.08450987f, -0.09433121f, -0.13422491f, -0.10327797f, -0.10008060f, 0.01299643f, -0.06465743f, 
    0.38680461f, -0.10668511f, 0.03615315f, 0.00120210f, 0.03465506f, 0.06241855f, -0.04877219f, 0.07612278f, 
    -0.08367860f, -0.03420109f, -0.04510510f, -0.14899388f, 0.06433497f, 0.01419080f, 0.11236858f, 0.16781050f, 
    -0.04943100f, -0.02821302f, -0.05354720f, 0.22460459f, -0.13204864f, -0.18095818f, -0.13543704f, 0.04499991f, 
    -0.04707691f, 0.07320989f, 0.09256798f, 0.07896097f, 0.00402429f, 0.04314445f, -0.09643504f, -0.01367011f, 
    0.17713699f, 0.06069529f, 0.23709026f, 0.27604333f, 0.00637790f, 0.19545309f, -0.21777301f, 0.02377691f, 
    -0.03954872f, 0.09721436f, 0.21519594f, 0.02812731f, -0.04074207f, 0.08097104f, 0.08093102f, 0.06357063f, 
    -0.00737637f, -0.07867359f, 0.03778328f, -0.01610946f, -0.01743720f, -0.01231384f, -0.03848905f, 0.03048449f, 
    0.01019983f, -0.15108822f, 0.02587476f, 0.02504458f, 0.01699450f, -0.00247582f, 0.04747593f, 0.00532451f, 
    0.00684460f, 0.01909413f, 0.01839772f, -0.01572760f, 0.07847468f, -0.07119624f, -0.06688319f, -0.00321664f, 
    -0.07776030f, -0.03077083f, -0.00811154f, 0.11119247f, -0.01966257f, 0.04415781f, -0.15297908f, -0.19972584f, 
    -0.11705033f, -0.15534037f, 0.02777745f, 0.10725393f, -0.11006484f, -0.37426278f, 0.03672822f, -0.33125430f, 
    0.13081989f, -0.10163920f, -0.05141177f, 0.09060490f, -0.08208357f, 0.03602204f, -0.00322321f, 0.03161799f, 
    -0.14478454f, 0.02473804f, 0.05058488f, -0.06922544f, 0.00020148f, -0.05581260f, -0.04513556f, -0.01804942f, 
    -0.01097177f, -0.03344581f, -0.03255611f, 0.04739488f, -0.16148560f, -0.07260554f, -0.04547641f, -0.03457136f, 
    0.00534486f, -0.06632969f, -0.15691541f, -0.02664208f, -0.09708229f, -0.04505944f, -0.06440154f, 0.02572907f, 
    -0.24265930f, 0.03241140f, 0.05918327f, -0.18876973f, 0.07024414f, 0.16168121f, 0.04574756f, -0.03503434f, 
    -0.12441485f, -0.19345868f, 0.01730101f, 0.02045663f, 0.05427594f, 0.07112172f, 0.08174245f, -0.12761185f, 
    -0.01368858f, 0.00299230f, 0.03373959f, -0.03955410f, 0.12540948f, 0.02196269f, 0.02465253f, -0.00683437f, 
    0.01409298f, -0.24208732f, 0.05184313f, -0.15570717f, 0.10602964f, 0.11534001f, -0.09190629f, 0.22853321f, 
    -0.06528476f, -0.01727868f, -0.00161878f, 0.06963706f, 0.19920364f, 0.10170135f, 0.02118038f, 0.02559702f, 
    -0.00862302f, -0.01905540f, 0.03592378f, 0.05894964f, 0.15442571f, 0.05321660f, -0.01151202f, -0.10982090f, 
    0.06188597f, 0.04063108f, 0.13330771f, 0.08124471f, -0.10243466f, -0.00555766f, 0.04621642f, 0.03788229f, 
    -0.01512260f, -0.07458274f, -0.12595403f, -0.03941166f, -0.23878340f, 0.22250414f, -0.08912387f, -0.07372444f, 
    -0.02950082f, 0.32516003f, -0.03028865f, 0.05076828f, 0.15561420f, -0.00804651f, -0.00044962f, -0.00807545f, 
    0.18167703f, -0.40406147f, -0.08331657f, 0.10076217f, -0.03190276f, 0.11285727f, -0.21004659f, 0.14306155f, 
    0.18443654f, 0.11658297f, 0.01322737f, 0.03710950f, 0.11804269f, 0.00878601f, 0.03610911f, -0.04949020f, 
    0.12927373f, 0.00393137f, 0.17116275f, 0.05089257f, 0.13537996f, 0.00449963f, 0.07983880f, 0.01622838f, 
    0.02385633f, 0.01746229f, 0.02882976f, 0.12259350f, -0.04912836f, -0.01846486f, -0.06485569f, 0.02915509f, 
    -0.05954177f, -0.04990995f, 0.01756437f, -0.12339111f, 0.10494634f, -0.13459453f, 0.03104419f, -0.23426715f, 
    0.12212964f, 0.08768461f, 0.03873469f, 0.03024446f, 0.04287831f, -0.01415110f, 0.11908302f, -0.12539174f, 
    -0.31406578f, -0.19548802f, 0.04704477f, -0.07703667f, 0.10612776f, 0.22452132f, 0.04517059f, 0.07863721f, 
    -0.03998166f, 0.20497520f, 0.06717365f, 0.07911678f, 0.12539686f, 0.11096018f, 0.19032420f, -0.07713962f, 
    -0.05295458f, -0.03682376f, -0.03489664f, 0.07575252f, 0.05481914f, -0.00353442f, 0.09205142f, 0.02682559f, 
    -0.01913065f, -0.04722464f, 0.13334176f, -0.21035373f, 0.22749057f, 0.10748883f, 0.01721386f, 0.01415199f, 
    0.01113594f, -0.00560253f, -0.03296377f, 0.01672117f, 0.22601332f, 0.08083323f, -0.03175865f, -0.18436451f, 
    0.10715085f, 0.06118396f, 0.15038906f, 0.04816034f, 0.01314471f, -0.00066638f, 0.07501578f, 0.05124819f, 
    0.14014262f, 0.00060242f, -0.06602085f, -0.18240638f, 0.04801782f, 0.02328901f, -0.02296703f, -0.09307148f, 
    -0.04866675f, -0.07181749f, -0.08378476f, 0.05151192f, -0.29811612f, -0.13721450f, -0.35556623f, -0.08142397f, 
    0.00260504f, 0.06135210f, 0.14506541f, 0.03867731f, -0.08734110f, 0.01331982f, -0.01603906f, 0.06895508f, 
    -0.17660306f, -0.06980433f, -0.06757588f, -0.15128936f, 0.06158302f, -0.02581171f, 0.07985099f, -0.05863837f, 
    -0.02733987f, -0.02564874f, -0.04320809f, -0.05339515f, 0.01271272f, 0.00601787f, 0.06924204f, -0.20328058f, 
    -0.02589790f, 0.02985056f, 0.01930876f, 0.11801633f, 0.01372941f, -0.05298156f, 0.09420349f, -0.13103515f, 
    0.38498914f, -0.05884391f, 0.31946209f, -0.07661285f, 0.13047321f, 0.11274663f, 0.06310452f, 0.17802399f, 
    0.12759635f, 0.05359969f, 0.01637884f, -0.12043400f, 0.10434729f, 0.03220963f, -0.12485027f, -0.10049120f, 
    0.11636199f, 0.23738810f, 0.16635524f, 0.10093314f, -0.01774169f, -0.00443254f, 0.03206944f, 0.01842179f, 
    -0.13095278f, -0.09541052f, -0.04713881f, -0.14702983f, 0.18524072f, 0.16151923f, 0.02413817f, 0.20492166f, 
    -0.01650900f, -0.00116161f, -0.03545756f, 0.00841726f, 0.11590389f, 0.08485001f, -0.14130294f, -0.17444195f, 
    0.10680437f, 0.10904293f, -0.05907383f, -0.22478428f, -0.04845438f, -0.05059734f, 0.00531959f, 0.05330243f, 
    0.32144400f, -0.09979843f, 0.30094150f, 0.02923702f, -0.04081692f, -0.09853539f, -0.03025803f, 0.00563694f, 
    0.09974548f, 0.10545112f, 0.21978270f, 0.03697465f, -0.01748993f, -0.17618719f, -0.18112312f, -0.23245628f, 
    -0.12777199f, 0.04668891f, 0.09809733f, -0.01565529f, 0.12913679f, -0.04127521f, 0.04238344f, 0.03448237f, 
    0.32074890f, 0.06394359f, -0.06075158f, -0.03561422f, -0.00194744f, -0.03764505f, 0.18836589f, -0.18828590f, 
    0.03126371f, -0.03923850f, 0.18614323f, 0.13086854f, 0.05569168f, -0.03626396f, 0.02029406f, 0.00833514f, 
    0.08891486f, 0.05754714f, -0.02596157f, -0.10687567f, 0.03070244f, 0.00412799f, 0.02215926f, -0.00854379f, 
    -0.26265150f, -0.17104022f, -0.14144941f, -0.07226065f, 0.12259622f, 0.02374351f, 0.10148072f, 0.05180892f, 
    0.01864563f, -0.06987519f, 0.00348355f, -0.03296540f, 0.10805400f, -0.23362263f, -0.02797111f, 0.01849359f, 
    -0.02833635f, 0.15776217f, 0.08381611f, -0.05467003f, 0.09127676f, 0.06993522f, 0.19396582f, -0.05669390f, 
    0.14346868f, 0.06591589f, -0.13929740f, -0.12126657f, 0.21685919f, 0.07982313f, 0.13967633f, -0.00056490f, 
    -0.06475883f, -0.04664876f, -0.04216144f, 0.13379760f, 0.27221411f, 0.19469535f, -0.14704323f, -0.03849791f, 
    -0.04016110f, -0.08643240f, 0.14067079f, -0.02776922f, 0.03653574f, -0.01493656f, -0.00378510f, 0.11908728f, 
    -0.05782790f, 0.09122128f, -0.14543526f, -0.05878583f, 0.06234198f, -0.04956389f, -0.05036781f, -0.01297739f, 
    -0.06731326f, -0.00211922f, 0.00672733f, 0.05533807f, 0.21713606f, 0.02658090f, 0.11499057f, -0.01959878f, 
    0.01103566f, 0.02224801f, -0.02416557f, -0.11278266f, -0.03481876f, -0.11749402f, 0.01816794f, 0.02864837f, 
    0.33890095f, 0.09593903f, -0.26729709f, -0.16977532f, -0.05820734f, -0.09049962f, 0.05402084f, -0.08460552f, 
    0.14103679f, 0.14394747f, 0.08185569f, 0.08491013f, 0.00512088f, -0.04522960f, -0.01194092f, 0.04200755f, 
    0.02911363f, -0.02330257f, -0.06821653f, -0.11202024f, 0.12412196f, 0.13582404f, 0.02471728f, 0.04127301f, 
    -0.22424728f, -0.19993658f, -0.09295949f, 0.02621837f, 0.03874512f, -0.02852323f, -0.03926037f, -0.01373728f, 
    -0.03597511f, -0.07445323f, -0.07264984f, -0.03832367f, 0.18034127f, 0.07762482f, -0.02395220f, -0.26953378f, 
    0.17097230f, 0.07625455f, 0.22824629f, 0.04546428f, 0.04711759f, -0.03158829f, -0.01559633f, 0.05438548f, 
    -0.01341975f, -0.19026820f, 0.20111735f, -0.04179678f, -0.02029037f, 0.04757173f, 0.01697117f, 0.07314152f, 
    0.05228353f, 0.00794906f, 0.10228562f, -0.04183540f, -0.12666452f, -0.07798259f, -0.08818057f, -0.10619450f, 
    -0.00195795f, 0.05590934f, 0.04264506f, -0.09787658f, -0.03300849f, 0.02823230f, -0.02525307f, 0.01691066f, 
    0.00737192f, 0.06711734f, 0.08381459f, -0.06735137f, -0.00174489f, 0.00076783f, -0.05593791f, -0.06104336f, 
    -0.05458922f, -0.06396124f, -0.04871137f, -0.08397444f, 0.10267591f, -0.02162093f, -0.02294588f, 0.11575576f, 
    -0.05241274f, 0.02365274f, 0.04401609f, 0.09254188f, 0.00726528f, 0.07048263f, 0.00891193f, -0.08356988f, 
    0.12962364f, 0.01102086f, -0.13433501f, -0.06443135f, 0.06865771f, 0.17184079f, 0.04569637f, 0.06766883f, 
    0.09541982f, 0.00606690f, 0.05166245f, -0.02861515f, 0.27373284f, -0.02613320f, -0.33908266f, -0.08537139f, 
    0.20114413f, -0.00968540f, 0.15827297f, 0.02159051f, 0.08148047f, -0.00991077f, -0.10873788f, 0.04291003f, 
    -0.08596484f, -0.06890810f, 0.06090204f, -0.23942322f, 0.06166341f, -0.07546725f, 0.02540215f, 0.05933216f, 
    0.10895116f, -0.13634129f, 0.16878504f, 0.01631131f, 0.03984214f, 0.05005740f, 0.00357878f, 0.03533731f, 
    -0.03929190f, -0.10086203f, -0.14179873f, -0.02177675f, -0.16095154f, -0.10414995f, -0.05498623f, -0.07570211f, 
    0.09514377f, 0.05297846f, -0.01319151f, -0.04445223f, 0.08441041f, 0.23935801f, 0.07309439f, 0.05069113f, 
    -0.00027539f, 0.04020098f, 0.09402384f, -0.02213094f, 0.52123165f, 0.06823765f, -0.14740866f, -0.15475106f, 
    0.11575985f, -0.12680426f, 0.40435195f, -0.01981300f, -0.00570827f, 0.08534537f, 0.11027402f, -0.08361999f, 
    0.13069417f, -0.22878860f, -0.16235167f, -0.09252533f, -0.04903440f, 0.01975969f, 0.14331236f, 0.05731571f, 
    0.08082383f, -0.03817210f, 0.02923373f, 0.04266114f, 0.07143666f, -0.09839360f, -0.00469355f, 0.06470254f, 
    -0.04485410f, -0.01856903f, 0.09610549f, -0.06055429f, -0.06819490f, -0.07972879f, -0.04328372f, -0.01765458f, 
    0.02387758f, -0.07397965f, -0.21359001f, -0.16002822f, 0.21306309f, 0.02222915f, 0.06260857f, -0.00344325f, 
    0.02251095f, 0.04001560f, -0.10046738f, 0.06098750f, -0.21784323f, -0.23273501f, -0.06331935f, -0.08111852f, 
    -0.03938755f, -0.07245630f, 0.00169821f, 0.04335165f, 0.10502001f, 0.09798153f, 0.16407740f, 0.02032122f, 
    0.13238578f, -0.11028024f, 0.26770765f, -0.11304989f, -0.12172849f, -0.02024981f, 0.01733914f, -0.01215273f, 
    0.03884194f, 0.11540960f, 0.05443706f, 0.10481479f, -0.21449257f, 0.04781168f, -0.10404705f, -0.14439841f, 
    0.07849745f, -0.04075039f, -0.01899375f, -0.02953663f, -0.02135067f, -0.01732800f, -0.08347022f, 0.02887097f, 
    0.01125601f, -0.09249970f, -0.15143810f, -0.21260878f, -0.01905369f, 0.13758774f, 0.03548903f, 0.16700074f, 
    0.08549107f, 0.01696700f, 0.12480272f, 0.01226023f, 0.17108925f, 0.02108752f, -0.15164062f, -0.17625391f, 
    0.22268108f, 0.21497424f, 0.03306082f, -0.06124306f, -0.00939020f, 0.01935703f, -0.00617676f, 0.07430954f, 
    0.02326884f, -0.01933311f, 0.20501663f, -0.20161267f, -0.08734169f, -0.03963549f, 0.03333975f, 0.05005816f, 
    0.12131641f, 0.00692384f, 0.06135917f, 0.14151579f, 0.03258980f, 0.06724349f, -0.00468423f, 0.01106574f, 
    -0.01513310f, 0.08189626f, 0.06273574f, 0.00318530f, 0.04783169f, 0.00327503f, 0.02438833f, -0.03767295f, 
    -0.12259778f, -0.06042306f, -0.07577379f, -0.05471211f, 0.03854165f, 0.03477469f, 0.09300620f, 0.21125458f, 
    -0.15529811f, -0.06026919f, -0.06046712f, -0.11830721f, -0.22262532f, -0.20987584f, -0.07485616f, -0.25885260f, 
    -0.06623507f, 0.17284004f, 0.10851043f, 0.17237574f, -0.01059069f, 0.04515915f, 0.10546737f, 0.01777760f, 
    0.14229509f, -0.10881894f, 0.08963601f, -0.01422364f, -0.05304150f, -0.04825157f, -0.02361166f, 0.02195699f, 
    -0.04732032f, -0.06040759f, 0.05093340f, -0.15440165f, 0.11327028f, 0.00408430f, 0.01582657f, 0.02284231f, 
    -0.01976454f, -0.08192145f, -0.06604800f, 0.05419077f, -0.01113743f, -0.00402590f, 0.09578617f, -0.08119417f, 
    0.08428790f, -0.11176077f, 0.14841510f, -0.14842094f, 0.19627622f, -0.03750740f, 0.21129985f, 0.00124609f, 
    0.06853005f, -0.05911675f, 0.14846312f, -0.01663296f, -0.03040310f, 0.20514451f, -0.04832347f, -0.11957179f, 
    0.00359384f, 0.14380895f, 0.07639132f, 0.04329021f, -0.02999899f, 0.02580397f, 0.11035796f, -0.03694950f, 
    0.02991321f, 0.04588898f, 0.06831380f, 0.16836159f, -0.04779791f, -0.02892395f, -0.00503376f, -0.01132553f, 
    0.05343076f, 0.06450935f, -0.08610255f, -0.13407156f, 0.06805661f, 0.14316227f, -0.13698287f, -0.09596053f, 
    -0.01578191f, 0.13741682f, 0.13278896f, -0.02167741f, -0.02552371f, -0.00765805f, 0.04855526f, -0.06859847f, 
    -0.06263872f, -0.03760187f, 0.02049502f, -0.23843034f, 0.08478449f, 0.09501076f, 0.19524011f, 0.03663833f, 
    0.12445085f, 0.14365402f, 0.01044025f, 0.04027931f, 0.04344040f, -0.02267990f, 0.14459787f, -0.11941922f, 
    -0.05518029f, -0.00843356f, -0.12418011f, 0.07001814f, -0.00884958f, -0.02246008f, 0.04758738f, -0.04925171f, 
    0.01237697f, 0.09192305f, -0.01729420f, -0.19920440f, 0.09736357f, 0.19631809f, 0.05861289f, 0.15278326f, 
    -0.00643399f, -0.06903272f, -0.02583841f, 0.05252873f, 0.05048511f, 0.12176525f, -0.05636101f, -0.03644666f, 
    -0.12973323f, -0.08500311f, -0.01774565f, -0.10357504f, -0.03991744f, 0.02140563f, -0.09802683f, 0.06346752f, 
    0.05857434f, -0.00259475f, -0.08538784f, -0.07154934f, 0.02004762f, -0.06060278f, -0.03085592f, -0.09943521f, 
    0.00424380f, 0.08416452f, -0.02175692f, 0.12202908f, 0.15274343f, -0.11693411f, -0.11355216f, 0.08729690f, 
    -0.02972139f, -0.02674119f, 0.02636233f, 0.08398172f, 0.09363747f, -0.00411295f, -0.12526487f, 0.09080502f, 
    0.08180495f, 0.16623834f, -0.31156716f, 0.24046196f, -0.04993709f, 0.09027799f, -0.05934754f, -0.15293664f, 
    0.00428207f, 0.07495659f, -0.05167995f, 0.24547434f, -0.02577791f, -0.09600028f, -0.09787694f, 0.09084047f, 
    0.01110137f, 0.06588145f, -0.03417701f, -0.03016633f, 0.07376466f, 0.09896068f, 0.07147219f, 0.07408810f, 
    0.04121084f, -0.01323023f, -0.05323646f, -0.02644382f, -0.00746925f, -0.11223238f, 0.02632997f, -0.04458982f, 
    0.22513977f, 0.25323415f, 0.20438392f, 0.34886321f, 0.10722786f, -0.14827967f, -0.06198677f, 0.21807526f, 
    -0.01548367f, 0.04104386f, 0.16204679f, -0.00364852f, -0.20512484f, -0.18328720f, -0.01817945f, -0.07365758f, 
    0.25515950f, -0.12180782f, -0.01383205f, 0.09088445f, -0.06158406f, -0.09832198f, -0.10265736f, -0.10524209f, 
    0.13781492f, 0.01413157f, -0.02485746f, 0.14840773f, 0.14340004f, 0.21568702f, 0.07515576f, -0.15710238f, 
    -0.15635221f, 0.08391654f, -0.02972774f, -0.10477587f, 0.07660140f, 0.01227954f, -0.02710997f, -0.10376725f, 
    0.06648105f, 0.08997161f, -0.10732562f, 0.31531948f, -0.05392174f, 0.03238187f, -0.23795547f, -0.05637969f, 
    -0.05457829f, -0.16850197f, -0.05165206f, -0.16305405f, -0.16110380f, -0.24048740f, 0.25509530f, 0.15358222f, 
    -0.09813141f, 0.02965510f, 0.15521814f, -0.07359763f, 0.19038878f, 0.13355041f, 0.03611099f, 0.02327099f, 
    -0.16479649f, -0.14121531f, 0.05394451f, 0.20884985f, -0.06971385f, -0.03626830f, -0.02212035f, 0.20293126f, 
    0.10695595f, 0.16554689f, 0.07754011f, 0.12502620f, -0.01511814f, 0.12613374f, 0.00707993f, 0.16725308f, 
    0.10362433f, 0.15853086f, 0.16271831f, 0.08708043f, 0.05782858f, -0.17270806f, -0.13133952f, -0.17635156f, 
    0.06425066f, -0.00225725f, 0.04247215f, -0.00877387f, 0.15585202f, 0.06949186f, -0.07908783f, -0.05162337f, 
    -0.15882772f, -0.13156635f, -0.18915889f, -0.17250898f, 0.18447186f, -0.09158626f, 0.03511589f, 0.18326154f, 
    0.00776748f, 0.05440871f, -0.08242230f, -0.01816898f, 0.22731087f, 0.20154455f, 0.05714072f, 0.26095334f, 
    0.15114799f, -0.39317650f, 0.16023840f, 0.02354152f, -0.00142798f, 0.12539396f, -0.05507961f, -0.10721780f, 
    -0.05292832f, 0.16961715f, -0.06909043f, 0.04379137f, -0.08176357f, -0.17272009f, 0.03301305f, -0.03023675f, 
    -0.08687141f, -0.03292799f, -0.13099948f, 0.02077467f, 0.06391101f, -0.04165063f, -0.06319766f, 0.01317675f, 
    0.08800945f, -0.18849391f, -0.04440665f, 0.10625939f, -0.03917943f, -0.02965576f, -0.10616975f, -0.14950958f, 
    -0.05764162f, -0.03486557f, -0.08337374f, -0.20412731f, -0.17760862f, -0.07963240f, 0.19360968f, 0.12574507f, 
    -0.07570765f, -0.08281133f, 0.06367774f, 0.22504425f, 0.08239843f, -0.10580797f, -0.02622029f, -0.05003780f, 
    0.12483979f, -0.05784636f, -0.02844414f, -0.44643104f, 0.07334884f, 0.01216648f, -0.08489569f, -0.12122233f, 
    0.00763535f, 0.10246800f, -0.00208873f, 0.04701660f, 0.24616557f, 0.17826799f, 0.08894987f, 0.32132089f, 
    0.17357621f, 0.23296973f, 0.17632844f, 0.22224297f, 0.19271711f, 0.06114873f, 0.05033216f, 0.20948854f, 
    -0.37604719f, 0.17286651f, 0.05002270f, -0.12681538f, 0.03712898f, -0.14955319f, 0.08602133f, -0.10302573f, 
    -0.08371372f, 0.07568464f, -0.06466075f, -0.08167481f, -0.18121767f, 0.07747803f, -0.09273431f, 0.13789362f, 
    -0.05392638f, 0.15717471f, 0.03909562f, -0.10455061f, -0.32344949f, -0.14615668f, 0.07482310f, 0.15552482f, 
    0.08101831f, 0.04380153f, -0.11527437f, 0.14903365f, 0.03798832f, 0.04349571f, 0.06867509f, -0.02283035f, 
    -0.09613594f, -0.11085679f, -0.14378643f, -0.04612224f, 0.03232170f, 0.14550906f, -0.03944721f, 0.18940687f, 
    -0.01512622f, 0.01317028f, 0.15910521f, 0.09432526f, 0.11517981f, 0.07053239f, -0.01992947f, 0.16794877f, 
    -0.15560094f, -0.21526572f, -0.07833476f, -0.01616901f, 0.00293447f, -0.16356389f, -0.05523653f, 0.09732554f, 
    0.04843388f, -0.10622147f, -0.04473555f, 0.04057700f, 0.06024629f, 0.38532704f, -0.12353729f, -0.27556017f, 
    -0.19631851f, 0.04684010f, 0.00082367f, 0.02586753f, -0.07378755f, 0.17855436f, 0.02305302f, -0.11452752f, 
    0.15609284f, 0.06156014f, 0.06482852f, 0.15533264f, 0.11352446f, -0.15054817f, -0.03010008f, 0.10993157f, 
    -0.00550934f, -0.05751698f, -0.12798950f, -0.33552060f, -0.07099339f, 0.10502916f, 0.15566503f, -0.08240834f, 
    -0.00031570f, -0.03610364f, -0.03566650f, 0.11522814f, -0.23239431f, 0.06661126f, -0.07896505f, -0.30728009f, 
    -0.16439879f, 0.12933303f, 0.34982383f, 0.07110117f, 0.07726873f, -0.02859550f, 0.12284021f, 0.00841577f, 
    -0.06831388f, 0.20131862f, 0.12845904f, 0.17990707f, -0.02566916f, -0.08618851f, -0.07101844f, -0.00055295f, 
    -0.03283855f, -0.02359494f, 0.11816274f, -0.04591394f, 0.04792040f, 0.20976022f, 0.19187066f, 0.05374896f, 
    0.07046067f, 0.09074875f, 0.08037204f, -0.04070976f, 0.25413340f, -0.03599170f, 0.00472023f, 0.01636305f, 
    -0.01638800f, 0.01555946f, -0.14967616f, -0.00908015f, -0.01614778f, -0.07786530f, 0.01523864f, 0.09829561f, 
    -0.01252738f, 0.01457574f, -0.06624785f, -0.02317693f, 0.14580049f, -0.03356521f, 0.03589490f, -0.08275789f, 
    0.05271384f, -0.21428680f, 0.08524577f, 0.15373975f, -0.00477761f, -0.02927414f, -0.04706535f, -0.17175096f, 
    -0.06072746f, -0.01906047f, -0.18757869f, -0.25349146f, -0.05089221f, -0.14906973f, 0.06735142f, -0.21949288f, 
    0.14488982f, -0.13086116f, -0.09024746f, -0.04364287f, -0.39494699f, -0.39060283f, -0.24584004f, -0.42203960f, 
    -0.05853533f, -0.01748110f, -0.09304864f, -0.04046830f, 0.05432790f, 0.00950388f, -0.00602505f, -0.10040805f, 
    -0.11089487f, -0.15228122f, -0.17687313f, -0.08976404f, -0.26148754f, 0.12114610f, 0.07269203f, 0.18673672f, 
    0.07272591f, 0.08303943f, 0.21786086f, 0.15408629f, 0.06456232f, 0.15625861f, 0.21957859f, 0.18690690f, 
    -0.05807861f, -0.10864289f, 0.03630534f, 0.11282783f, 0.01876959f, -0.04479953f, 0.06415556f, -0.06962831f, 
    0.11291796f, 0.02989323f, 0.14845468f, 0.29330283f, 0.10629122f, 0.11862674f, -0.12486318f, -0.12806648f, 
    0.07846411f, 0.10588047f, 0.02501735f, 0.15399975f, 0.06273561f, 0.01824967f, 0.04071724f, 0.13118641f, 
    0.05833921f, -0.26868761f, 0.00320355f, -0.29498890f, 0.25035241f, -0.22838226f, 0.12105402f, -0.04170675f, 
    -0.08144534f, -0.02207180f, 0.04154545f, -0.08182956f, 0.01642390f, -0.03336126f, -0.02801205f, -0.18454725f, 
    0.06389048f, 0.05786569f, 0.22453022f, -0.06290948f, 0.12029301f, 0.04020229f, -0.07974239f, 0.06490484f, 
    -0.21501012f, -0.22577509f, 0.01797625f, 0.19901720f, 0.05046739f, 0.01450295f, 0.04384824f, -0.07017221f, 
    0.13169102f, 0.07493661f, 0.15993989f, 0.28380910f, -0.17155650f, -0.07978288f, -0.07182304f, -0.09189823f, 
    0.06395926f, 0.14782706f, -0.21024297f, 0.05352027f, -0.10261729f, 0.04320528f, 0.01438262f, -0.01064060f, 
    0.05313602f, 0.45735744f, 0.11491270f, 0.19363295f, 0.06932186f, 0.01240971f, -0.00248845f, 0.10629449f, 
    0.06130862f, 0.10769439f, -0.25830400f, -0.13281162f, 0.01320273f, -0.13562441f, -0.19611900f, -0.06804874f, 
    0.06142398f, -0.05763788f, 0.10499335f, -0.14180537f, 0.04018082f, 0.10098872f, -0.20465241f, -0.01963851f, 
    -0.09083860f, 0.00329503f, -0.11289863f, 0.27118722f, -0.06047462f, -0.14160161f, 0.15571506f, 0.08007325f, 
    -0.16255985f, 0.08484507f, -0.14011811f, -0.08215448f, 0.11950448f, 0.11178510f, 0.17096843f, 0.11349983f, 
    -0.00062780f, -0.14175136f, 0.02595538f, -0.15045094f, -0.01588893f, -0.04086334f, -0.02359221f, -0.11419617f, 
    0.08254290f, -0.04753083f, 0.03578066f, -0.31995913f, 0.08656804f, -0.17636578f, -0.10247368f, -0.05743277f, 
    -0.01893687f, 0.02943597f, 0.12522660f, -0.13268808f, 0.14971890f, -0.16927652f, 0.41973031f, 0.14276974f, 
    0.13862777f, -0.07203227f, -0.03163657f, -0.17131409f, -0.13917156f, -0.12170216f, -0.06151220f, -0.19544780f, 
    -0.03197505f, 0.21602795f, 0.12436997f, 0.11007431f, -0.02290143f, -0.02109326f, 0.03462819f, 0.01455265f, 
    0.02151887f, 0.10529966f, 0.02821748f, 0.16573076f, -0.19160697f, -0.07065154f, -0.10226011f, 0.00247192f, 
    -0.04254605f, -0.03526385f, 0.07204670f, -0.04716487f, 0.00528411f, -0.08179390f, -0.08915737f, 0.13701373f, 
    0.43019408f, -0.20208146f, 0.09492796f, -0.16028430f, 0.03736786f, -0.13639095f, -0.07715153f, -0.13505779f, 
    0.07793294f, 0.03751111f, 0.05767214f, -0.11199141f, 0.42443931f, -0.30391136f, -0.01139011f, 0.22039086f, 
    0.12483177f, 0.01763741f, 0.05167841f, -0.09262878f, 0.10501748f, 0.12656958f, 0.14041300f, 0.30754665f, 
    0.04473720f, -0.18606476f, -0.07421801f, -0.01567850f, 0.06764580f, 0.22329788f, 0.23794375f, -0.18069682f, 
    0.19580688f, 0.21065156f, 0.00878761f, 0.21547352f, 0.09306657f, 0.17978828f, 0.02613733f, 0.33408704f, 
    0.13873897f, 0.20839508f, 0.29149550f, 0.17934765f, 0.06786935f, -0.07359758f, 0.09412382f, 0.07788366f, 
    0.20636012f, -0.02122915f, -0.18796504f, -0.10666358f, 0.07145938f, 0.09113473f, -0.07041920f, -0.17679860f, 
    -0.00229557f, -0.01550234f, -0.10676321f, -0.06648739f, 0.05866133f, -0.10286527f, -0.13552551f, -0.14096765f, 
    -0.03127638f, 0.05555490f, -0.06833344f, -0.09297428f, 0.00280387f, -0.01555869f, -0.17818235f, -0.09265175f, 
    -0.09906267f, -0.06870221f, -0.21444495f, 0.15631191f, -0.12681815f, 0.04024865f, -0.00915331f, 0.00611361f, 
    0.19991702f, 0.10722043f, 0.06393547f, 0.31018579f, -0.10019179f, -0.09920020f, -0.00543732f, 0.20985106f, 
    0.03631158f, 0.00196545f, -0.03490103f, -0.00475990f, 0.03417466f, 0.08897520f, 0.06689558f, 0.08675551f, 
    0.03767299f, 0.03932619f, 0.00366674f, 0.15203577f, 0.03958704f, -0.06275019f, 0.02705060f, -0.12414337f, 
    0.12567860f, 0.29091683f, 0.29591897f, 0.33185139f, 0.10100523f, -0.18455453f, -0.16978441f, -0.09458864f, 
    0.18282923f, -0.00664865f, -0.08005172f, 0.07382697f, -0.04292982f, -0.18611903f, 0.03780197f, -0.12679937f, 
    0.17738275f, -0.06512962f, 0.31199959f, 0.08130474f, -0.08982681f, -0.21507432f, -0.10397721f, -0.08827384f, 
    -0.20733255f, 0.11144686f, -0.04594770f, -0.31034359f, 0.06877586f, -0.18018456f, -0.04647708f, -0.09370434f, 
    -0.04328030f, 0.12275394f, -0.02038296f, -0.09365372f, -0.04608762f, -0.16801965f, -0.13104576f, -0.08435858f, 
    -0.22172992f, -0.17876986f, -0.04422089f, 0.32186714f, -0.00130079f, -0.13737604f, 0.05096815f, 0.01251314f, 
    0.03274440f, 0.18509214f, 0.12113609f, 0.07990761f, -0.09589782f, 0.01479128f, 0.05175996f, -0.04840017f, 
    0.03737998f, 0.00305564f, -0.05010047f, 0.23942469f, 0.06512763f, -0.21398892f, 0.04802912f, -0.13017154f, 
    0.10510372f, -0.06737299f, 0.06732163f, -0.14073765f, 0.05347494f, -0.30545664f, -0.07797433f, -0.12052173f, 
    -0.19581990f, -0.08930127f, -0.24945469f, -0.26820329f, 0.01369544f, 0.21105579f, -0.27634349f, -0.13799588f, 
    -0.03215682f, 0.06022796f, 0.06174944f, -0.15363923f, 0.03831414f, 0.03898093f, -0.08471106f, -0.05209173f, 
    0.05808250f, 0.09582507f, 0.05533636f, 0.06364656f, -0.11558504f, 0.12452035f, 0.11121871f, 0.03270416f, 
    0.22551452f, 0.08425874f, 0.13549303f, -0.02724409f, 0.05388557f, 0.08278672f, 0.00298679f, 0.13198884f, 
    0.15120065f, 0.06681909f, 0.17199077f, -0.00404921f, 0.23430744f, 0.04173511f, 0.06274804f, -0.01245779f, 
    0.04004237f, 0.13549362f, 0.05090147f, -0.06043597f, -0.03712643f, -0.04586729f, -0.07167787f, -0.07773928f, 
    0.15053903f, 0.29092249f, 0.10855526f, 0.06363855f, -0.14827883f, -0.09490895f, 0.17244530f, -0.09588423f, 
    0.23722337f, 0.04098727f, 0.17568149f, 0.18251812f, 0.03203979f, 0.00424994f, 0.09683856f, 0.01321451f, 
    0.09839789f, 0.17980875f, -0.08789124f, 0.06935593f, 0.06009826f, -0.04724187f, 0.03858929f, 0.08224647f, 
    0.04942458f, 0.10734738f, 0.08066861f, 0.05473209f, 0.21267821f, 0.04047699f, 0.00268270f, 0.11655016f, 
    0.05930094f, -0.05364491f, -0.01449954f, -0.00917719f, 0.02511884f, -0.10913049f, 0.22387923f, 0.15160212f, 
    0.25546321f, 0.04242432f, -0.24110335f, -0.01374091f, 0.10272439f, -0.04071430f, 0.04280081f, -0.07442687f, 
    -0.00257318f, 0.04223503f, -0.03949014f, -0.01776308f, -0.03430089f, -0.15674929f, 0.11650831f, 0.21266159f, 
    -0.10770061f, -0.01067504f, 0.12314283f, 0.12317990f, 0.02112051f, 0.03358580f, -0.11212979f, 0.04046191f, 
    -0.14952612f, -0.09160883f, 0.19493613f, 0.13860704f, 0.03900511f, -0.08639947f, 0.02613979f, 0.08939491f, 
    0.12501627f, 0.04189754f, 0.05559435f, 0.00269218f, 0.18150555f, 0.14390595f, 0.11357051f, -0.13368361f, 
    0.02515446f, -0.13421366f, 0.02123358f, 0.34919992f, -0.13353626f, -0.01005181f, 0.03196744f, -0.08107744f, 
    0.07894717f, 0.16163374f, 0.06146016f, -0.11815204f, -0.18726669f, 0.01465116f, 0.02253121f, -0.03982368f, 
    0.00852632f, -0.00314388f, 0.02799154f, -0.05472824f, -0.02054478f, -0.04063106f, -0.09226812f, 0.20880200f, 
    -0.01920070f, -0.08025649f, -0.01521522f, 0.14614053f, -0.08622924f, -0.05457701f, 0.16819790f, -0.28303555f, 
    0.09542655f, 0.01445541f, 0.02269836f, 0.09835372f, 0.31897610f, 0.14256109f, 0.02025650f, 0.26172689f, 
    0.04096994f, 0.16378985f, 0.11106258f, -0.02694781f, -0.16467734f, -0.06625922f, 0.01576017f, 0.05904032f, 
    0.12765306f, 0.04435685f, 0.04741678f, 0.04012277f, 0.01818482f, -0.00329217f, -0.03114944f, -0.03991382f, 
    -0.09570675f, -0.05748161f, 0.01427493f, 0.08794651f, 0.11475602f, 0.18720733f, 0.14188872f, 0.27010834f, 
    -0.08457160f, -0.06234505f, 0.00205860f, -0.00609980f, -0.23097154f, -0.07091048f, 0.18352558f, 0.18422946f, 
    -0.04691069f, 0.08200664f, 0.13413183f, 0.17772765f, 0.08086699f, 0.07453306f, -0.04014983f, -0.00832856f, 
    0.52164507f, -0.22183867f, -0.23827034f, 0.10517394f, 0.12189357f, -0.05806180f, -0.04574088f, -0.11761682f, 
    0.39981443f, 0.22881733f, 0.21639147f, 0.18038201f, -0.14360319f, -0.08185068f, -0.07268058f, -0.01615561f, 
    0.20219974f, 0.04017375f, -0.06465136f, 0.00549507f, 0.21972774f, -0.18829761f, -0.08533999f, -0.09578764f, 
    0.46091494f, 0.26252350f, 0.21674226f, 0.12610243f, 0.01386533f, 0.07441817f, 0.10400823f, -0.03484028f, 
    0.14762065f, 0.32558301f, 0.17766140f, 0.18992715f, 0.04581862f, 0.06537855f, 0.01628651f, -0.01377615f, 
    -0.01107551f, 0.32494012f, 0.11631046f, -0.01455327f, -0.00732975f, 0.11161363f, 0.10225978f, -0.11797278f, 
    0.28015813f, 0.12248329f, -0.01043294f, -0.08282292f, 0.09931218f, -0.03731434f, 0.04636002f, 0.02357232f, 
    -0.05289333f, 0.01567332f, -0.04551682f, -0.03975882f, 0.07157896f, -0.02351361f, 0.21955064f, 0.03535931f, 
    0.11552072f, 0.04615882f, 0.08710404f, 0.18727775f, 0.32311419f, 0.03480649f, -0.00800722f, 0.18813692f, 
    -0.13154508f, 0.07431938f, 0.04007797f, 0.06252165f, -0.02016925f, 0.07749181f, 0.12802880f, 0.16712846f, 
    0.03192322f, -0.06308899f, -0.07826323f, -0.19547719f, 0.48754311f, -0.24377869f, -0.12269352f, -0.03694886f, 
    -0.01384386f, 0.05467923f, -0.00677108f, -0.13916686f, 0.30273741f, 0.16467382f, 0.19719210f, 0.14856541f, 
    -0.16916388f, 0.02893803f, 0.00523646f, -0.06779475f, -0.00477133f, 0.19840190f, 0.19515480f, 0.05965683f, 
    -0.08882158f, 0.00715565f, 0.04286839f, 0.05067286f, 0.02293503f, 0.03496460f, 0.00463015f, -0.00926025f, 
    -0.05386519f, -0.03979593f, 0.01262264f, -0.08094230f, -0.02819863f, 0.01632371f, -0.04459273f, -0.05166579f, 
    0.22623004f, 0.35673046f, 0.42368892f, -0.22495010f, -0.07674270f, -0.02160411f, 0.45140702f, 0.20095672f, 
    0.10610411f, 0.24396342f, 0.18129791f, 0.17950861f, -0.07434273f, 0.02355639f, 0.17891388f, -0.04395059f, 
    -0.10632389f, 0.05285089f, 0.09665038f, 0.01216563f, 0.12917314f, 0.06474545f, 0.07349393f, 0.20649600f, 
    0.07778671f, 0.09678815f, 0.14904428f, -0.13167107f, -0.05402818f, -0.01618450f, 0.04088670f, 0.04999844f, 
    -0.04883837f, 0.00634798f, -0.01880789f, -0.01246964f, -0.32203573f, -0.19874796f, -0.08374388f, -0.01933367f, 
    -0.13962997f, -0.12466802f, 0.09595419f, 0.13183556f, -0.05852629f, 0.00658924f, 0.00950141f, -0.04779425f, 
    -0.00871519f, -0.11216936f, 0.02780061f, 0.22277161f, 0.10971048f, 0.03195370f, 0.19387797f, 0.32496095f, 
    -0.00652991f, -0.07080191f, -0.00313140f, 0.04868809f, 0.00359235f, 0.03279402f, -0.07438605f, -0.05858066f, 
    0.40633520f, 0.05025952f, 0.02994871f, -0.00588118f, -0.08444297f, -0.00598811f, -0.00178946f, 0.01550652f, 
    0.20809127f, 0.15987051f, -0.01618364f, 0.00615673f, -0.00357240f, -0.01058428f, -0.05120908f, -0.03135623f, 
    -0.00813403f, -0.01558734f, 0.03658555f, -0.05440619f, -0.18462990f, -0.05864849f, 0.11849265f, 0.00638377f, 
    -0.04729197f, -0.11233951f, -0.08698313f, 0.08259049f, 0.16951546f, -0.23831114f, -0.11388904f, -0.03898091f, 
    -0.17057881f, 0.08279658f, 0.12510669f, 0.02601759f, -0.07874726f, -0.00402467f, 0.25701448f, 0.06542251f, 
    0.15524909f, 0.12639391f, 0.05578613f, 0.00163682f, -0.05575047f, -0.05610267f, -0.16210307f, 0.01089179f, 
    0.11250433f, -0.08451600f, 0.17161395f, 0.03632714f, 0.15858187f, 0.01299645f, 0.01762640f, -0.14390352f, 
    0.41903779f, -0.11193545f, 0.19846383f, 0.20038648f, 0.01271440f, 0.09761468f, -0.00550826f, 0.05026031f, 
    0.15125112f, 0.22831604f, -0.14572361f, 0.18950833f, 0.13873842f, 0.21125014f, 0.07421938f, -0.03287508f, 
    -0.11040345f, 0.02880072f, -0.01839618f, -0.04500657f, -0.03602448f, 0.10477199f, 0.01505505f, 0.08961409f, 
    0.02724274f, 0.05575001f, 0.20154026f, 0.12502150f, 0.03984214f, 0.08472822f, 0.26445696f, 0.14737892f, 
    0.26603061f, -0.03325196f, -0.04828959f, -0.00806932f, 0.01270902f, -0.15595195f, 0.12248883f, 0.08027438f, 
    0.21480103f, 0.07257365f, 0.34880564f, 0.25011319f, 0.19301169f, -0.04453045f, 0.11034903f, 0.09048384f, 
    -0.26817507f, 0.00893666f, 0.14802286f, 0.01480110f, 0.07627136f, 0.08012208f, 0.12358022f, 0.24175176f, 
    0.01447293f, -0.05678783f, 0.11188894f, 0.02241088f, 0.10704868f, 0.12936765f, 0.04983839f, 0.01353384f, 
    0.01412848f, 0.01806694f, -0.03091276f, -0.02356076f, 0.01767399f, -0.01977396f, 0.05860478f, 0.09771267f, 
    -0.30761841f, -0.10467034f, 0.02342377f, -0.12756915f, 0.09904548f, 0.08720409f, 0.30320749f, 0.38095340f, 
    0.03228006f, 0.03747682f, 0.05412749f, 0.03971338f, 0.00431968f, 0.14393091f, 0.26618779f, -0.01982192f, 
    -0.29782575f, -0.07259315f, 0.22318307f, 0.21417868f, -0.22166923f, 0.08060108f, 0.05712863f, -0.03764637f, 
    0.11032132f, 0.09207398f, 0.10360017f, 0.42479891f, -0.00229885f, -0.00402224f, -0.00627437f, 0.04316984f, 
    0.27239615f, 0.22115266f, 0.23434606f, 0.17717975f, 0.41826057f, 0.05762194f, 0.36048302f, 0.03266414f, 
    -0.00543967f, -0.12781319f, -0.01446872f, 0.00543459f, -0.05145225f, -0.04428964f, -0.00452694f, -0.09492452f, 
    -0.22134738f, -0.07853727f, 0.28557760f, -0.09523221f, -0.16618605f, 0.01390731f, 0.30959734f, 0.30660513f, 
    0.14001696f, 0.15356758f, -0.05192177f, 0.10153746f, -0.02842217f, 0.05279844f, 0.01457945f, 0.01249279f, 
    0.08095210f, 0.13460265f, 0.20566559f, 0.01594713f, 0.00790515f, -0.03762392f, 0.01475643f, -0.11869955f, 
    0.44013050f, -0.21663187f, 0.06707408f, -0.00516246f, -0.02149511f, -0.10647554f, -0.05826098f, 0.05081030f, 
    0.14547706f, 0.21454118f, 0.26546687f, 0.09478413f, 0.00474849f, -0.01173415f, 0.10607162f, -0.03154080f, 
    -0.02575821f, -0.19393754f, -0.10590851f, -0.14899579f, 0.10296545f, 0.05713587f, -0.03530535f, -0.15226805f, 
    0.01398822f, -0.01455615f, 0.06381620f, -0.10410143f, 0.09024247f, 0.06084470f, -0.10946354f, -0.03637663f, 
    -0.14057828f, 0.06953463f, 0.01934432f, -0.02022138f, -0.00098721f, -0.12541850f, -0.02786376f, -0.11514243f, 
    0.07499405f, -0.17769757f, 0.05086223f, -0.10182500f, -0.18399090f, -0.07007358f, 0.00115454f, -0.07180733f, 
    0.18231101f, -0.06807474f, -0.00112520f, -0.06941675f, 0.23774479f, 0.09913883f, -0.05141423f, -0.06016961f, 
    0.07941546f, 0.09949435f, 0.17072444f, 0.01626486f, 0.08357964f, 0.03782981f, 0.03804258f, -0.07833894f, 
    0.00361156f, 0.03170944f, -0.01069201f, -0.09090117f, 0.06855626f, 0.11210333f, 0.15625587f, 0.09019928f, 
    0.05534210f, -0.10284504f, -0.17030714f, 0.06813379f, 0.23212373f, 0.01326053f, 0.13706192f, 0.04602927f, 
    0.10661151f, -0.01177391f, -0.03570404f, 0.11794844f, -0.03819155f, -0.00567208f, 0.18389590f, -0.04356442f, 
    0.12860170f, -0.02102130f, 0.09016136f, 0.25894108f, 0.11233871f, 0.15528458f, 0.14965053f, 0.20657568f, 
    0.10632022f, 0.05777710f, 0.16354510f, -0.04892731f, -0.02388768f, -0.01139880f, -0.05539201f, -0.01709436f, 
    0.02654945f, 0.05500290f, 0.24949260f, -0.06522036f, -0.40976265f, -0.00740071f, 0.23527737f, 0.17952989f, 
    0.11140365f, 0.18345474f, 0.03159831f, 0.00233772f, -0.13160512f, 0.03616555f, -0.07358997f, 0.00470116f, 
    -0.11931053f, -0.36734939f, -0.11960535f, 0.12472246f, 0.02069507f, -0.05044594f, 0.21654935f, 0.33640683f, 
    0.09554970f, 0.04466420f, 0.26690334f, 0.09849627f, 0.05997753f, 0.12857752f, 0.20561689f, 0.04400826f, 
    -0.01924727f, 0.04029311f, -0.02288621f, -0.02123281f, 0.05387639f, -0.04201720f, 0.16561516f, -0.05597794f, 
    -0.00824339f, -0.08062458f, 0.12962547f, 0.06850650f, 0.05465833f, 0.09046187f, 0.02244201f, 0.13198695f, 
    0.06753241f, 0.07976311f, -0.09432814f, 0.23433933f, -0.01610214f, 0.04986310f, 0.07355950f, -0.02632153f, 
    -0.04824476f, -0.01480972f, -0.04180827f, 0.06885086f, 0.02710651f, 0.05315466f, 0.18030635f, 0.13734604f, 
    0.26318350f, -0.05721347f, -0.05147168f, 0.01841152f, 0.04884036f, 0.04128230f, -0.00618078f, 0.01902519f, 
    0.04958835f, 0.07771003f, 0.10143109f, 0.08143740f, 0.03053587f, 0.00226617f, -0.09457082f, -0.09116906f, 
    0.17035921f, 0.28225935f, 0.13333139f, -0.00921608f, 0.08714106f, 0.17867815f, 0.17837019f, 0.11089147f, 
    -0.21048504f, -0.09756268f, 0.20393506f, 0.01676297f, 0.16512465f, -0.00393211f, -0.10612664f, -0.05736356f, 
    0.08735961f, -0.09882338f, -0.10423178f, 0.01715103f, 0.04158129f, 0.05495888f, -0.02919129f, 0.06611845f, 
    -0.09725343f, -0.05126693f, -0.02790612f, -0.01828614f, -0.01997044f, -0.04625258f, -0.07790926f, 0.06834883f, 
    -0.14355357f, -0.15678860f, -0.12704313f, -0.00250450f, -0.03381768f, 0.03178563f, 0.02463039f, 0.01264067f, 
    0.05328807f, -0.27129689f, -0.06202806f, -0.27797297f, -0.06505905f, 0.00340990f, 0.07686218f, 0.33609000f, 
    -0.03134647f, 0.12353361f, 0.13594013f, 0.23551984f, 0.03894458f, 0.05926754f, 0.04991823f, 0.04456444f, 
    -0.09351431f, -0.06342188f, 0.04465632f, 0.24509278f, 0.15225932f, 0.16960378f, 0.13004202f, 0.10195056f, 
    0.03879995f, -0.13640475f, 0.00103165f, 0.07215083f, -0.30539069f, -0.08336871f, -0.28915951f, -0.17250769f, 
    -0.01120691f, 0.05680999f, 0.16099115f, 0.16421765f, 0.19275494f, 0.06077167f, 0.23072171f, 0.11529204f, 
    0.23482648f, 0.24726279f, 0.39918134f, 0.04790404f, 0.00662188f, 0.12529314f, 0.02160472f, 0.03848223f, 
    0.04309598f, 0.00757586f, 0.07639589f, 0.12558794f, 0.27974033f, 0.20500673f, 0.14475104f, -0.02678933f, 
    0.08918035f, 0.18088487f, 0.04878862f, 0.10153753f, 0.00842840f, -0.01597476f, 0.13898902f, 0.04011850f, 
    -0.06737360f, 0.12122111f, 0.06320115f, -0.09313818f, 0.09025422f, -0.00269597f, 0.09593552f, -0.07999151f, 
    -0.00774798f, -0.00307840f, -0.01162704f, 0.15073231f, -0.04136125f, -0.08387195f, 0.31035206f, 0.19170165f, 
    0.05553322f, 0.07130583f, -0.01162931f, -0.09407437f, 0.02137026f, 0.02313616f, -0.04952963f, -0.00476673f, 
    -0.15025714f, 0.06973605f, 0.08332358f, 0.02211345f, 0.13896944f, -0.06386857f, -0.01640221f, -0.01612301f, 
    0.04673920f, -0.02102699f, 0.01510867f, 0.08858287f, -0.15540896f, -0.16964254f, -0.05616553f, -0.14933710f, 
    0.10298199f, 0.07334368f, 0.04947830f, 0.01860316f, 0.07470748f, -0.14235285f, 0.04142648f, -0.01688061f, 
    0.06430170f, 0.47649160f, 0.15369329f, -0.02317667f, 0.06448892f, -0.27727479f, -0.06852318f, -0.11453307f, 
    0.09475222f, -0.07302972f, -0.08802990f, 0.25420326f, 0.22773869f, -0.04570839f, 0.15723115f, 0.06763310f, 
    0.09209047f, 0.06034845f, 0.19762383f, 0.15725118f, 0.02015405f, 0.05462439f, 0.03394293f, 0.00725597f, 
    -0.14534143f, -0.11436909f, 0.00914904f, 0.26161009f, 0.11378641f, 0.11172810f, 0.11427312f, 0.11209249f, 
    0.02410312f, 0.01319985f, 0.04635520f, 0.01727932f, 0.21207686f, 0.12989737f, 0.12288837f, 0.02399614f, 
    0.19595841f, 0.22515509f, 0.05862322f, -0.11391713f, 0.02131894f, -0.00083424f, 0.07968521f, 0.09580079f, 
    -0.17004940f, 0.08142602f, -0.05112535f, -0.12361234f, -0.03162828f, -0.00736871f, 0.06183246f, 0.06559192f, 
    0.10860762f, 0.09534936f, 0.12913135f, 0.17915066f, -0.06580240f, -0.02393708f, 0.11880231f, 0.02768793f, 
    -0.05628271f, -0.01560677f, -0.06002554f, 0.00788594f, -0.07750341f, -0.08156081f, 0.04509758f, -0.09453496f, 
    0.00160297f, 0.17648675f, -0.05751598f, -0.14896539f, -0.04134178f, -0.02225684f, 0.02030921f, 0.06167201f, 
    0.19072245f, -0.10976817f, 0.03953898f, -0.03553934f, 0.04868896f, 0.00858513f, 0.22443826f, 0.09305617f, 
    0.16995353f, 0.05214043f, -0.17597286f, -0.06837772f, 0.09213851f, 0.00561374f, -0.09148535f, 0.09892531f, 
    -0.25702131f, 0.04101110f, 0.24079473f, 0.02755979f, 0.01870675f, -0.11306276f, 0.03906570f, -0.11165018f, 
    0.04824437f, 0.03106595f, 0.03460528f, 0.01999494f, -0.20724028f, 0.03187127f, 0.09501328f, 0.30406681f, 
    0.00296527f, 0.00591200f, 0.10240116f, 0.05623676f, 0.10015771f, -0.03317119f, 0.10457053f, -0.09727590f, 
    0.15694210f, -0.04126817f, -0.03301598f, 0.32770434f, 0.14860167f, 0.05700373f, 0.10363071f, 0.00550380f, 
    -0.09527081f, 0.00485291f, 0.02962671f, 0.07039721f, -0.11269067f, 0.00889333f, -0.32510102f, -0.12503983f, 
    0.07709059f, -0.03169684f, 0.16974553f, 0.15824316f, 0.10268655f, 0.02136969f, 0.03155264f, 0.07358404f, 
    -0.10805161f, -0.06759532f, -0.02972060f, 0.12791061f, 0.18348931f, 0.16606881f, 0.19889821f, 0.32942218f, 
    0.15983510f, -0.05314907f, -0.04295520f, 0.01203125f, -0.00896884f, -0.03425477f, 0.03132710f, 0.09042658f, 
    0.06594034f, -0.08922179f, -0.10590144f, -0.06087254f, 0.09550940f, -0.01737884f, 0.05634570f, 0.18477832f, 
    -0.30892372f, -0.04433320f, -0.21205002f, 0.33639568f, 0.06552362f, 0.13688324f, -0.30753353f, -0.07073459f, 
    0.23089772f, -0.06212234f, 0.11619721f, -0.04676896f, -0.12721570f, -0.01457216f, -0.18112342f, 0.04077993f, 
    0.04819186f, 0.00319008f, -0.08491453f, -0.05664444f, -0.01570933f, -0.11677808f, -0.05982951f, 0.21971244f, 
    -0.25608027f, -0.09446159f, -0.15106222f, 0.11679797f, -0.05905008f, 0.17643014f, -0.04434513f, 0.07656554f, 
    0.02451690f, -0.04109417f, 0.01595080f, 0.03602164f, 0.43559766f, 0.12799387f, 0.05756019f, 0.10483038f, 
    0.21839280f, 0.26991877f, 0.09170493f, 0.11387339f, 0.04507229f, -0.03873359f, 0.01588540f, 0.02058995f, 
    0.02998666f, 0.09713195f, -0.11776301f, -0.07293219f, -0.09648839f, -0.00259188f, -0.05056918f, -0.25265530f, 
    0.06656169f, 0.11840697f, 0.16938406f, 0.10328047f, 0.03044103f, -0.06754185f, 0.00587869f, -0.03209154f, 
    -0.20606509f, -0.08091313f, -0.09938450f, -0.06044935f, 0.10873514f, 0.04582898f, -0.00348278f, 0.03293680f, 
    -0.05422680f, 0.00171017f, 0.16592637f, -0.04818851f, 0.09270968f, -0.05688990f, -0.03628437f, 0.02882698f, 
    -0.01350650f, 0.08397564f, 0.03377226f, 0.09244098f, -0.04445944f, 0.02903309f, -0.24650916f, -0.03394217f, 
    -0.01219107f, -0.00079534f, 0.10141112f, 0.02218916f, -0.25228304f, 0.02998013f, -0.21069555f, -0.09129659f, 
    0.26035172f, 0.03104632f, -0.16794047f, 0.10795529f, 0.08429734f, 0.13827199f, 0.09031317f, 0.17633902f, 
    -0.02964529f, -0.09570998f, -0.27708322f, -0.13116431f, 0.16441722f, -0.03592197f, -0.21598558f, -0.15858237f, 
    0.12611316f, -0.05257732f, 0.12343075f, 0.07865886f, 0.03332501f, -0.04077439f, -0.12931029f, -0.04272738f, 
    -0.45810014f, 0.05653771f, -0.11716022f, 0.16138469f, -0.05292450f, 0.02827634f, -0.05086831f, -0.01645089f, 
    0.08132143f, -0.04703245f, 0.19009675f, 0.36061522f, -0.05655748f, -0.08722283f, -0.17588252f, 0.03192376f, 
    0.02587085f, -0.10829277f, -0.03947034f, 0.10492679f, 0.02993038f, 0.03604397f, 0.12462044f, 0.15161617f, 
    -0.04843207f, 0.10930041f, -0.06215519f, 0.18036559f, -0.08707786f, -0.01355329f, 0.17373718f, 0.04850731f, 
    -0.14324945f, -0.12066974f, 0.09042133f, 0.06860950f, 0.15119931f, 0.47753978f, -0.33492821f, -0.06381708f, 
    -0.24153727f, 0.00060892f, 0.09201262f, -0.02420929f, 0.04181330f, 0.08897360f, -0.03582653f, 0.02784263f, 
    0.14900927f, -0.26485008f, 0.00169407f, 0.13222004f, 0.15383376f, 0.05274449f, 0.01029536f, 0.10219922f, 
    -0.20567325f, 0.01294903f, -0.05978430f, -0.07303894f, -0.12811409f, -0.08334030f, 0.05195557f, 0.11276967f, 
    -0.01743680f, -0.01519427f, 0.03910636f, 0.02843000f, 0.04263454f, 0.10521431f, 0.09884031f, 0.01680120f, 
    0.21817863f, -0.02049892f, 0.12514657f, 0.28175655f, 0.08660308f, 0.16922845f, 0.06766896f, -0.21205318f, 
    0.00733983f, 0.01903935f, 0.03772508f, -0.01422410f, -0.40206751f, -0.26362446f, -0.19054554f, 0.17779231f, 
    0.04237599f, 0.15470923f, -0.05500453f, -0.21808104f, 0.51260167f, 0.03054314f, 0.16321059f, -0.05886676f, 
    -0.03448913f, 0.24264362f, -0.26366222f, -0.45755041f, -0.08014046f, -0.05682747f, 0.01937041f, 0.05016257f, 
    -0.06896640f, -0.00797595f, -0.07168790f, 0.25882557f, -0.14263216f, 0.26486135f, 0.12078593f, -0.08873331f, 
    0.01033509f, 0.09282008f, -0.08969815f, -0.00383498f, -0.02587458f, 0.06516384f, 0.04849658f, 0.08692157f, 
    -0.05229358f, 0.02193510f, -0.24578388f, 0.19439028f, 0.16334963f, 0.11947691f, 0.05216167f, 0.02322498f, 
    0.07469735f, -0.22948724f, -0.07632564f, -0.12999594f, 0.15983857f, -0.03321892f, 0.04686060f, 0.28900394f, 
    0.15918100f, 0.07196541f, -0.00593948f, 0.13503805f, -0.02714224f, 0.01116180f, -0.05847220f, 0.03340399f, 
    -0.35528937f, 0.11969581f, -0.27933255f, -0.15246847f, 0.03721724f, 0.04316640f, 0.11500118f, 0.11846282f, 
    0.13595840f, -0.10582709f, -0.09362725f, 0.28449059f, -0.17421094f, -0.04947329f, -0.40435970f, -0.13948537f, 
    0.07991566f, 0.12007298f, 0.21947037f, 0.06271189f, -0.04318153f, -0.13892968f, -0.12733962f, -0.04603038f, 
    -0.02313509f, 0.05788059f, -0.01118877f, -0.02691340f, -0.09741122f, -0.10988885f, 0.12472242f, 0.01761653f, 
    0.09067693f, 0.05928856f, -0.00699695f, -0.15513659f, -0.08161310f, -0.02516039f, 0.44998169f, 0.22328275f, 
    0.18078236f, 0.00309274f, -0.11215962f, 0.18752442f, 0.03108862f, 0.04299325f, -0.03505778f, -0.11852376f, 
    0.01250516f, 0.12589824f, -0.05682410f, -0.01353713f, -0.09616258f, -0.11968387f, 0.10482270f, 0.07294323f, 
    0.08088385f, 0.15876785f, 0.05859556f, 0.07999709f, -0.02543474f, 0.04312210f, -0.06518398f, -0.01405731f, 
    0.02530372f, -0.08401142f, -0.04519859f, 0.09880676f, 0.12945962f, 0.08450034f, 0.17203689f, 0.10257048f, 
    -0.06965470f, -0.06678038f, 0.19888794f, -0.02035386f, -0.02788691f, -0.05657141f, 0.04132380f, -0.08713637f, 
    -0.00753837f, -0.01819130f, -0.06975866f, -0.21864747f, 0.20962676f, 0.42297730f, -0.00653047f, 0.04378063f, 
    0.07850603f, 0.02047851f, 0.16628957f, 0.01258100f, -0.01465589f, 0.02782897f, 0.05136384f, -0.01150435f, 
    0.03583672f, -0.05512764f, -0.13628520f, -0.00769613f, 0.01091446f, 0.03352151f, 0.06275670f, 0.04232385f, 
    -0.01628051f, -0.01596507f, -0.21709365f, -0.33272687f, 0.32495558f, 0.14875746f, -0.13203883f, 0.04330726f, 
    -0.09868676f, -0.01290642f, 0.24690092f, 0.08897976f, 0.11411356f, 0.01203303f, 0.03502078f, 0.01739239f, 
    0.19496189f, -0.06306454f, 0.03374511f, -0.06672261f, -0.06466468f, 0.33685061f, -0.06524329f, -0.16698505f, 
    0.08586256f, 0.09715942f, -0.01740803f, 0.10295942f, -0.16515185f, 0.02889006f, -0.00547295f, -0.01376281f, 
    0.14614448f, -0.07998336f, -0.12331176f, 0.11217713f, 0.02719516f, 0.06446446f, 0.04918298f, 0.03865990f, 
    -0.05340450f, 0.23207131f, -0.01912228f, 0.16297716f, -0.04323756f, 0.02502474f, 0.31385913f, -0.00614947f, 
    0.09684233f, -0.00670491f, 0.13053340f, 0.10315501f, -0.20204276f, -0.09873438f, -0.06051085f, 0.04736486f, 
    0.05950953f, 0.03609284f, -0.02127848f, -0.01496897f, -0.08105954f, 0.06748482f, 0.10162344f, 0.19386767f, 
    -0.15080309f, 0.01136064f, -0.01098658f, -0.03504015f, 0.00840173f, 0.12969026f, -0.06510890f, -0.01235927f, 
    0.01307208f, 0.10459196f, 0.14933707f, 0.20965166f, 0.14891991f, -0.31565970f, 0.12964709f, 0.15440360f, 
    0.02459916f, -0.32159188f, 0.09490706f, 0.07487749f, -0.15193574f, -0.03069758f, 0.01400750f, -0.02753559f, 
    0.24870987f, 0.10288721f, 0.13203999f, -0.08126785f, -0.00673394f, -0.03130445f, 0.11735030f, -0.09690244f, 
    -0.04957623f, -0.07361953f, 0.08472107f, -0.10857914f, -0.00111828f, 0.08971756f, 0.10008806f, -0.06633177f, 
    0.19741628f, -0.04430093f, 0.02744305f, 0.03643547f, 0.10524304f, -0.04620846f, -0.05283124f, -0.05159059f, 
    -0.08233437f, -0.07439819f, -0.01081090f, -0.06809315f, -0.01356122f, -0.01383568f, 0.00909874f, 0.01996583f, 
    -0.21271573f, 0.06588733f, 0.01383892f, 0.12493841f, 0.05873531f, 0.21936247f, 0.12407057f, -0.27708453f, 
    -0.06837486f, -0.15485720f, 0.05989838f, -0.03259852f, -0.10367462f, -0.04078777f, 0.06018948f, 0.01315432f, 
    0.49389252f, 0.31629130f, -0.00636173f, 0.00723613f, -0.07215911f, 0.05254447f, -0.16489746f, -0.17319551f, 
    0.07117967f, -0.03322634f, 0.04982338f, 0.03984410f, 0.08720258f, 0.00162467f, -0.23285973f, 0.14667509f, 
    -0.01072848f, 0.08074916f, 0.02627264f, -0.04528836f, -0.02229429f, 0.00248352f, -0.01314579f, 0.19529992f, 
    -0.04297725f, 0.09196137f, -0.14875501f, -0.02065111f, 0.07850941f, -0.21886989f, 0.19542907f, -0.07922155f, 
    -0.04064786f, 0.04937774f, 0.00915627f, 0.02112484f, -0.06328769f, 0.19482850f, -0.25992000f, 0.01955377f, 
    -0.14953326f, -0.19881938f, -0.07703458f, -0.14028460f, 0.05232841f, 0.01636098f, -0.03271261f, -0.00983953f, 
    0.25325188f, -0.00499542f, 0.04572891f, 0.19271088f, 0.10194148f, 0.00321667f, 0.02359601f, 0.26672259f, 
    0.00497739f, -0.02670498f, 0.07206974f, -0.12763242f, 0.19826110f, 0.08945799f, -0.06744199f, -0.15251701f, 
    0.10102741f, -0.22689754f, -0.14352436f, -0.02490410f, -0.05246516f, 0.01654223f, 0.04376601f, 0.01170417f, 
    -0.01533788f, -0.17868461f, -0.10090436f, -0.03898271f, -0.14898477f, 0.04755782f, 0.01810147f, 0.02396451f, 
    -0.09204759f, 0.00399265f, 0.05228412f, 0.03049551f, 0.04462888f, 0.09346716f, 0.00930393f, 0.07482378f, 
    0.02901856f, -0.05935861f, -0.02127068f, -0.08707500f, -0.06172837f, 0.18330739f, 0.15850428f, 0.12936847f, 
    -0.26564485f, 0.21355172f, -0.30023420f, 0.08067074f, -0.25079998f, 0.04877194f, 0.11136343f, -0.02395296f, 
    -0.10473964f, 0.00108069f, 0.28347984f, -0.14327407f, 0.01876972f, 0.20517953f, 0.04643810f, -0.09725492f, 
    -0.04385529f, -0.14523502f, 0.00693218f, -0.02544112f, -0.02044867f, 0.01783418f, -0.03099508f, 0.03588416f, 
    0.26993582f, 0.22263867f, 0.05336206f, -0.05945018f, 0.05176731f, 0.02441701f, -0.01640727f, 0.07701062f, 
    -0.01777173f, -0.09797873f, 0.00801957f, -0.05353517f, 0.04948874f, 0.08649449f, -0.10886338f, 0.10078603f, 
    -0.06661698f, 0.05690175f, 0.07636797f, 0.28151074f, -0.03960739f, 0.01077026f, -0.02318811f, -0.11848024f, 
    -0.22972947f, 0.30322242f, -0.06292360f, 0.08401880f, 0.00884427f, 0.06143695f, 0.08096689f, -0.09387829f, 
    0.08142206f, 0.00795368f, -0.02337804f, -0.11588752f, 0.09552538f, 0.10339693f, 0.12488683f, -0.10820119f, 
    -0.03401732f, -0.01335829f, 0.16649143f, 0.06012399f, 0.07781073f, 0.16312231f, 0.07841864f, 0.08384226f, 
    0.18042065f, -0.19617297f, 0.00712633f, 0.01860617f, -0.00140624f, -0.00197537f, -0.01593594f, -0.06678933f, 
    0.08434126f, 0.09955198f, 0.04861829f, -0.00923008f, 0.05321597f, 0.13168934f, 0.14149916f, 0.12884055f, 
    0.01989804f, -0.03172959f, 0.06805218f, 0.01743270f, -0.12942821f, -0.06550663f, -0.01333486f, -0.24394386f, 
    0.14718163f, 0.06736822f, -0.19084924f, -0.27988663f, 0.09494345f, -0.08711308f, 0.05051025f, -0.17890684f, 
    -0.01433921f, 0.04611851f, 0.00161038f, 0.07951353f, 0.11370406f, -0.10084443f, -0.00599053f, -0.32466316f, 
    0.06220068f, -0.10167634f, -0.08329025f, 0.03982314f, -0.18138556f, 0.05659868f, -0.07429581f, 0.24101996f, 
    0.15909302f, 0.30764326f, 0.06764194f, -0.24158847f, -0.09959471f, 0.07920157f, -0.05562936f, 0.02496601f, 
    0.09439018f, -0.02158654f, -0.01410323f, -0.08071563f, -0.08045189f, -0.16014718f, 0.29934588f, 0.18405667f, 
    0.03573355f, 0.09202710f, 0.07452063f, -0.05571759f, 0.06681311f, -0.02913598f, 0.07543126f, -0.08593717f, 
    0.16350010f, 0.15510987f, 0.17090233f, -0.01144487f, -0.02431610f, 0.16542703f, 0.00904080f, -0.06897585f, 
    -0.13318186f, 0.09361731f, -0.02725573f, 0.03772710f, -0.09340010f, -0.08560602f, -0.06875839f, -0.03838787f, 
    -0.03890188f, 0.01002815f, 0.13601434f, -0.01001930f, -0.03955057f, 0.09772679f, 0.00637192f, -0.03949491f, 
    0.14902109f, -0.42277610f, 0.08430273f, -0.19997117f, -0.02265403f, -0.02265055f, -0.13699201f, -0.00470944f, 
    -0.17589000f, 0.08980805f, 0.04736560f, 0.03204139f, 0.02216926f, -0.17571092f, 0.17647709f, -0.06864618f, 
    -0.04465653f, 0.03524845f, -0.00503966f, 0.00184099f, 0.00159880f, 0.06496070f, -0.01603106f, 0.00311945f, 
    0.25108483f, -0.14605597f, -0.16747670f, -0.13975342f, 0.00299156f, -0.14300543f, 0.13682002f, -0.13726738f, 
    -0.07031041f, 0.08004449f, 0.02480543f, 0.03951887f, 0.00608292f, 0.25818163f, 0.07378050f, 0.11551978f, 
    -0.14506535f, -0.15904237f, -0.01641500f, -0.09653603f, 0.00926810f, -0.01315564f, -0.02005356f, 0.00100625f, 
    0.05082467f, 0.25825420f, -0.05410947f, 0.05521489f, 0.13545255f, 0.11151514f, -0.06220389f, 0.15640697f, 
    -0.04496298f, -0.08349995f, -0.13072914f, -0.03119534f, -0.02524304f, -0.03108985f, -0.02014525f, 0.07172223f, 
    0.17773442f, 0.08215118f, -0.04541269f, 0.07698211f, -0.10504590f, -0.06014761f, -0.00188067f, 0.08262775f, 
    -0.17496006f, -0.04664201f, -0.11835216f, 0.02009371f, 0.00988085f, 0.01272234f, 0.07922132f, 0.00544290f, 
    0.01527829f, -0.01453234f, 0.05272592f, -0.02336056f, 0.10890724f, -0.00814218f, -0.03178830f, -0.01663683f, 
    0.00810922f, 0.01644629f, -0.11115867f, -0.16799851f, 0.17651944f, 0.08888675f, 0.11027018f, 0.16738103f, 
    0.01785391f, 0.13210328f, 0.24685092f, -0.05707112f, 0.08908236f, 0.02177213f, -0.17311037f, -0.18722659f, 
    -0.14578690f, 0.17992122f, 0.11343520f, 0.12496461f, -0.07076456f, 0.10795712f, 0.26616359f, 0.13005938f, 
    0.07563479f, 0.15303765f, 0.12797160f, -0.07909879f, 0.05900523f, 0.10563897f, 0.16921659f, -0.11544041f, 
    0.60300660f, -0.00873701f, -0.15170468f, 0.00754425f, -0.02857072f, 0.02136092f, 0.01925501f, -0.24415629f, 
    -0.12723300f, 0.18497881f, -0.17356522f, -0.27613696f, -0.17816828f, -0.17818916f, 0.01779718f, 0.05206839f, 
    0.03785708f, 0.07136278f, 0.05041533f, 0.03311950f, 0.00951875f, 0.08235417f, 0.02120419f, 0.11258262f, 
    0.23500885f, 0.04629304f, 0.19405372f, -0.12915403f, 0.04684187f, 0.05589199f, -0.28696296f, -0.05286723f, 
    0.10631174f, 0.03881853f, -0.01034952f, 0.09181450f, -0.09934211f, -0.42125401f, 0.30839142f, 0.22337434f, 
    0.06060331f, 0.13570662f, -0.08799368f, -0.01142917f, 0.18027739f, -0.16905183f, 0.09793636f, -0.06574656f, 
    -0.00800870f, 0.26910514f, 0.08414339f, -0.07105315f, 0.03966989f, -0.03337155f, -0.14585684f, -0.06137941f, 
    0.08249607f, -0.01622156f, 0.06864020f, 0.07411050f, -0.14427805f, -0.00056773f, -0.10465708f, -0.20917585f, 
    -0.00499747f, 0.03469180f, -0.05120275f, 0.09629475f, -0.01517184f, -0.00023135f, -0.00748312f, 0.09583738f, 
    -0.00818056f, 0.24051206f, 0.14400709f, 0.01265156f, -0.07693082f, 0.13328426f, 0.07667572f, -0.04990936f, 
    -0.10408061f, -0.06741182f, -0.09270394f, -0.11108473f, 0.42770347f, 0.22926146f, 0.00671273f, -0.00627282f, 
    0.06896903f, 0.00352687f, 0.00501394f, 0.02555212f, -0.25406396f, 0.01529217f, -0.21287814f, -0.09306584f, 
    -0.15859383f, -0.36232352f, 0.01076903f, 0.17240758f, -0.02766384f, 0.02733414f, -0.03572975f, -0.01238556f, 
    0.01759632f, 0.09190404f, 0.15278292f, -0.08091522f, 0.00580925f, -0.06697457f, -0.18815522f, 0.32286376f, 
    -0.07546442f, -0.06287434f, 0.07154858f, 0.00487234f, -0.03670944f, 0.00202806f, -0.01748869f, -0.02948537f, 
    0.35005224f, -0.04989283f, 0.13540366f, -0.07062953f, -0.02889720f, 0.02776047f, -0.03152333f, -0.14846618f, 
    0.01180159f, 0.18180862f, -0.07115611f, 0.04472993f, 0.09548306f, 0.14404862f, 0.11915284f, -0.10157118f, 
    -0.05517770f, -0.09783804f, 0.06269602f, -0.07677344f, -0.01030261f, -0.07553566f, -0.00318613f, -0.12070060f, 
    0.03654474f, 0.02875893f, 0.01637107f, 0.18797088f, 0.05072385f, 0.11537667f, -0.05358738f, -0.00026038f, 
    -0.09582178f, -0.00819163f, 0.10257586f, -0.08992337f, 0.34807667f, 0.21700448f, 0.32436717f, 0.14793757f, 
    0.07393518f, 0.14469516f, -0.15431713f, -0.20991957f, 0.11754851f, 0.20185819f, 0.09835299f, 0.10221343f, 
    -0.15252399f, 0.05632124f, 0.02422462f, 0.06120311f, 0.07299245f, 0.06957270f, -0.08794064f, -0.12013786f, 
    -0.04599616f, -0.03438962f, 0.17357007f, 0.14471555f, 0.07974659f, 0.05471838f, -0.10949983f, -0.36982608f, 
    -0.07569786f, -0.01210470f, -0.01709678f, -0.02135835f, -0.06369936f, 0.05840507f, -0.05039292f, 0.00188469f, 
    -0.38019124f, 0.09434935f, 0.11971074f, 0.03552332f, 0.11129780f, 0.14911996f, 0.00644750f, 0.01389929f, 
    0.14924340f, -0.04042965f, 0.06713360f, 0.13806117f, -0.19360566f, -0.05793831f, 0.09420592f, -0.00992150f, 
    0.00707981f, 0.16787036f, 0.02350154f, -0.06954020f, 0.08166756f, 0.08627646f, 0.05161119f, 0.02181927f, 
    -0.00211149f, 0.18142453f, 0.02485100f, -0.08486600f, -0.00783471f, -0.03667509f, 0.02918222f, 0.07676443f, 
    0.08547183f, 0.02635112f, -0.05098523f, 0.07547536f, 0.04137660f, -0.15822954f, 0.05905088f, -0.09992502f, 
    -0.03921819f, -0.09490701f, -0.10943168f, 0.03256463f, -0.06639136f, -0.06239092f, -0.06479788f, 0.12192432f, 
    -0.05843222f, -0.21335906f, 0.06838778f, 0.01707673f, -0.03278562f, -0.04392438f, -0.08909728f, -0.05765257f, 
    -0.15776688f, 0.05289605f, 0.17643510f, 0.31187126f, -0.11048024f, -0.00117395f, 0.23975064f, -0.04164864f, 
    0.17018007f, 0.03064965f, -0.08244400f, -0.01673133f, -0.06567243f, -0.05538876f, -0.08172785f, 0.01610371f, 
    -0.05842935f, 0.28220016f, 0.07895635f, 0.06655702f, 0.03357211f, 0.01439030f, 0.04228009f, -0.07509789f, 
    -0.03487043f, -0.12024838f, -0.02466740f, -0.16890828f, -0.10662948f, -0.14109729f, -0.01827854f, 0.05818871f, 
    -0.01487526f, -0.00140325f, 0.17043641f, -0.07359807f, -0.01029449f, -0.09108381f, 0.00072656f, 0.02550431f, 
    0.31936926f, 0.03940937f, 0.07928599f, -0.10426871f, -0.07842137f, 0.02153659f, -0.20432958f, 0.12020019f, 
    0.01195846f, 0.01850334f, -0.31789327f, 0.01650560f, 0.00539904f, -0.21199256f, -0.09213746f, -0.02084591f, 
    0.00783895f, 0.01927942f, 0.04018568f, 0.06265234f, -0.03742158f, -0.06210473f, 0.03912378f, -0.02673105f, 
    0.00100921f, 0.04090047f, 0.02268052f, 0.07924341f, 0.02023422f, 0.09876702f, 0.03557647f, -0.02220585f, 
    -0.04102286f, -0.04614004f, -0.03449130f, -0.16719650f, -0.30750504f, 0.20129773f, 0.12127744f, -0.11654754f, 
    0.11375348f, 0.23091103f, 0.02523839f, -0.14805639f, 0.03306978f, 0.03422266f, 0.02142954f, 0.02643338f, 
    0.05520387f, -0.16932607f, -0.22065318f, -0.21891432f, 0.11514426f, -0.13295019f, 0.04278707f, -0.07000642f, 
    -0.08950067f, -0.06803261f, 0.08543185f, 0.02979783f, 0.22091241f, 0.06094385f, 0.16285753f, 0.02270677f, 
    0.09278303f, -0.07428348f, 0.05395447f, -0.05237709f, -0.00818136f, -0.07468344f, -0.06012730f, 0.01195567f, 
    -0.14410011f, -0.13380358f, -0.08626277f, -0.15663877f, 0.01518632f, 0.00089759f, -0.04390088f, -0.02783342f, 
    -0.23306479f, -0.09894381f, -0.05091750f, -0.00772296f, 0.17264335f, 0.14593758f, 0.09285060f, 0.07433977f, 
    -0.10020806f, -0.17617825f, -0.01016192f, 0.13823721f, -0.06799748f, -0.02750369f, 0.00557726f, 0.00094426f, 
    -0.00873968f, -0.00603723f, 0.10769587f, -0.02858776f, 0.03789282f, 0.12624729f, 0.00703772f, 0.05940216f, 
    -0.07178015f, 0.04166479f, 0.04383557f, 0.15336986f, 0.03074627f, 0.14035204f, -0.20080969f, -0.08741715f, 
    0.02296115f, 0.14674461f, 0.11348168f, -0.06403732f, 0.01171129f, 0.00703810f, -0.04088918f, 0.05073048f, 
    -0.02797482f, 0.04588532f, 0.10528242f, -0.04042427f, -0.05374311f, -0.07104086f, -0.05695881f, 0.06709458f, 
    0.00435177f, -0.00138842f, -0.06880894f, -0.09091295f, 0.33375305f, 0.25399503f, 0.20572218f, 0.03422891f, 
    -0.16687752f, -0.15609097f, -0.10390811f, -0.06469695f, -0.03411435f, -0.09697451f, 0.00778285f, 0.02055172f, 
    0.34783170f, 0.21305060f, 0.16177559f, 0.23569234f, 0.13878077f, 0.00809347f, 0.06556017f, 0.18485837f, 
    -0.11244570f, -0.05509026f, 0.09872066f, 0.13565069f, 0.28892776f, 0.19742610f, -0.16718443f, -0.06969712f, 
    0.08223703f, -0.03205499f, 0.00746069f, 0.04802824f, 0.00153863f, -0.01624892f, -0.05751956f, 0.09990203f, 
    -0.08217632f, -0.08876964f, -0.08004954f, -0.10913808f, -0.04332536f, 0.01511209f, -0.04291497f, -0.04842041f, 
    -0.00822653f, 0.03982955f, 0.00543729f, -0.08787800f, 0.07340713f, 0.08630124f, 0.06607289f, 0.01281898f, 
    0.04833988f, 0.02418794f, 0.01051306f, 0.05637391f, -0.07132053f, 0.08872724f, 0.02866927f, 0.00396956f, 
    0.02927675f, -0.12957905f, 0.08884624f, -0.07963191f, -0.06903161f, -0.07467441f, 0.04413836f, 0.01540185f, 
    0.00610326f, -0.01107592f, -0.03836622f, -0.00585035f, 0.21685492f, 0.14994672f, 0.22958308f, 0.12525831f, 
    -0.11882094f, -0.14265655f, -0.04247173f, -0.06517956f, -0.02940170f, -0.05667695f, -0.04043984f, -0.10554138f, 
    0.21221197f, 0.04930406f, 0.07604400f, 0.03025134f, 0.07643567f, -0.11291572f, 0.00451306f, 0.00178506f, 
    -0.03646057f, 0.02886595f, 0.09008053f, -0.09850325f, 0.25926551f, 0.37094906f, 0.18367568f, 0.23755312f, 
    -0.09931611f, 0.04428455f, -0.01386658f, 0.01512927f, -0.11730178f, -0.06252474f, -0.03326308f, -0.00542665f, 
    -0.19255529f, -0.24289300f, -0.04644672f, -0.18395044f, -0.01680946f, -0.08105135f, -0.05718806f, -0.14132278f, 
    0.08032402f, -0.00442781f, -0.02414671f, -0.06018979f, 0.22595792f, 0.07199200f, 0.11359956f, -0.03966690f, 
    -0.06256872f, 0.09453673f, 0.12176439f, 0.15886882f, -0.05749635f, 0.01646195f, 0.01589119f, 0.03715644f, 
    0.15406901f, -0.17067422f, -0.20958619f, 0.08805525f, -0.02892829f, -0.05410282f, 0.09837715f, -0.05365034f, 
    -0.10314239f, -0.03808626f, -0.14692986f, 0.07700483f, 0.09269387f, -0.04600027f, -0.03381100f, 0.05748285f, 
    0.09594592f, -0.02356148f, -0.00932705f, -0.05161557f, -0.05870587f, -0.06528199f, -0.02940036f, 0.06719787f, 
    0.13309640f, -0.05956245f, -0.16146059f, -0.13407329f, -0.01903196f, 0.03083083f, -0.08135233f, 0.06504077f, 
    0.06643313f, 0.01775867f, -0.05470501f, -0.02405271f, 0.26271203f, -0.16604000f, 0.04311755f, 0.05059505f, 
    -0.08975695f, -0.02934825f, 0.02875820f, 0.02218724f, 0.04701657f, 0.02146978f, 0.03044311f, 0.10917764f, 
    0.27927974f, 0.24724166f, 0.00887148f, -0.06427281f, 0.01871555f, 0.08141568f, 0.10303114f, 0.06220892f, 
    0.04340488f, -0.07258832f, -0.10142460f, -0.01719095f, -0.17196773f, -0.09725951f, -0.09768681f, -0.19092150f, 
    -0.01036064f, -0.00324454f, 0.16680245f, -0.11047968f, 0.01393178f, -0.03665338f, -0.07329714f, -0.02971885f, 
    0.23093869f, 0.11377216f, 0.00282233f, 0.02633781f, 0.11674367f, 0.01972531f, 0.00256786f, 0.04505236f, 
    -0.03580186f, 0.04630973f, -0.03298891f, -0.02414961f, 0.14752962f, -0.36310276f, -0.05193619f, -0.05545340f, 
    0.04380567f, -0.03647835f, 0.03590896f, -0.10078478f, -0.02563572f, -0.08447780f, -0.07625425f, -0.01627801f, 
    0.29415998f, -0.55045599f, -0.12188699f, -0.28669000f, -0.07219075f, -0.06231855f, 0.09167612f, 0.02633555f, 
    -0.00734943f, -0.00634530f, 0.00091289f, 0.12557057f, 0.03861217f, -0.21393432f, -0.10727013f, -0.02788583f, 
    0.02266637f, 0.03921286f, -0.00060160f, -0.03477983f, 0.02939332f, -0.09986332f, 0.05279823f, -0.08625576f, 
    0.17932706f, -0.04310646f, -0.43535885f, -0.10920092f, 0.04340792f, 0.08018598f, 0.02417354f, -0.07694545f, 
    0.00594881f, 0.02371003f, 0.00677588f, -0.05442491f, 0.37945756f, 0.34687313f, 0.29178849f, 0.10590623f, 
    -0.07155346f, -0.15279116f, -0.03395356f, -0.07521567f, -0.00790138f, -0.05911607f, -0.01153039f, -0.03332153f, 
    0.07130783f, 0.09471463f, 0.12072838f, 0.07652875f, 0.10332227f, 0.04877104f, -0.04388340f, 0.11875461f, 
    -0.05449669f, -0.04073692f, -0.11614442f, 0.00802412f, 0.03112792f, -0.10490274f, -0.14680681f, -0.09027117f, 
    0.12822245f, 0.06018734f, -0.14445341f, -0.07351162f, -0.07606733f, -0.08755377f, -0.10912209f, -0.08004755f, 
    -0.10210634f, -0.16235366f, -0.06176410f, -0.01115376f, -0.01442093f, -0.02553533f, -0.06179440f, -0.07108835f, 
    0.02485209f, 0.03459676f, -0.00914373f, -0.04158227f, 0.12189298f, 0.09769765f, -0.02023889f, 0.06878062f, 
    0.06482875f, 0.05487366f, 0.14484285f, 0.15678507f, 0.03903355f, -0.03645748f, -0.02497903f, 0.04831443f, 
    0.19696246f, -0.00702357f, 0.09112689f, 0.11441100f, 0.07521742f, 0.12471592f, -0.06012148f, -0.02089239f, 
    0.00162168f, 0.10284901f, 0.09516767f, 0.13824789f, 0.03156452f, -0.02622944f, 0.01773315f, -0.08523291f, 
    0.08247242f, 0.11892724f, 0.08016738f, -0.05509603f, 0.06427725f, -0.10867546f, -0.06375461f, -0.10167793f, 
    0.37918514f, -0.38048947f, -0.48745105f, -0.00471568f, 0.04438733f, 0.00347090f, 0.02873089f, -0.07247119f, 
    0.09300730f, -0.06563503f, -0.09538604f, -0.11837927f, -0.08326954f, -0.20551126f, -0.22846103f, 0.01816296f, 
    0.14522095f, -0.01783512f, -0.08994293f, -0.03404776f, -0.06600448f, 0.18302982f, -0.02906514f, 0.03319996f, 
    0.26452029f, 0.05962829f, 0.08649025f, 0.10596248f, 0.03751193f, 0.04341526f, 0.01761908f, 0.02722268f, 
    0.00935455f, 0.06727646f, 0.05015700f, 0.06952594f, 0.05294546f, -0.13373308f, 0.17370482f, 0.07152706f, 
    0.10463532f, -0.02671943f, 0.21627551f, 0.08833513f, 0.18848981f, -0.02323110f, 0.08806983f, 0.03439450f, 
    -0.01781681f, 0.05455073f, 0.02818869f, 0.09464451f, -0.06467959f, -0.02261961f, 0.02924550f, 0.09187157f, 
    0.11618494f, 0.03847576f, -0.00027038f, -0.01862779f, 0.05755072f, -0.23233834f, -0.20918931f, -0.22475511f, 
    -0.00442893f, -0.01855824f, 0.07134694f, -0.12802389f, 0.03743606f, 0.07587579f, 0.01371113f, 0.06616872f, 
    0.22124429f, 0.36267811f, 0.24889813f, 0.17740409f, 0.05743120f, -0.00890836f, 0.04233300f, -0.01589826f, 
    -0.09740987f, -0.05790535f, -0.04860013f, 0.03663202f, 0.28514355f, 0.04867345f, -0.08685676f, 0.04423419f, 
    0.19758394f, 0.13175759f, 0.03169204f, 0.05961004f, 0.10811462f, 0.05347306f, 0.06382051f, 0.09431498f, 
    -0.28306580f, -0.42392802f, -0.00099615f, -0.24343231f, -0.05296759f, 0.03086322f, -0.01676479f, 0.01345307f, 
    -0.06126811f, -0.07944137f, 0.06150381f, -0.13160524f, -0.06350441f, 0.03371477f, -0.06732969f, 0.17673722f, 
    -0.03366205f, -0.12584497f, -0.03264056f, -0.06226309f, -0.00838306f, -0.06871679f, -0.07634482f, -0.06140633f, 
    0.09220004f, -0.07264207f, -0.05641372f, -0.09283276f, 0.05384477f, 0.02464851f, 0.04769053f, 0.05966740f, 
    -0.00090270f, 0.01802502f, 0.08383123f, -0.03603387f, 0.27558380f, 0.15151802f, 0.04757500f, -0.10286388f, 
    0.07377844f, 0.05432003f, -0.13874388f, -0.13959637f, 0.00619242f, -0.00020614f, -0.02566984f, -0.02936907f, 
    -0.08682265f, -0.00593629f, -0.12292905f, -0.03626570f, -0.01564468f, 0.03196714f, -0.02451252f, -0.08744097f, 
    0.01066907f, 0.04183664f, 0.02220685f, -0.04165122f, 0.20476733f, 0.11169744f, -0.00773020f, 0.11913878f, 
    0.14171885f, 0.17134033f, 0.02964029f, 0.06064046f, 0.01651371f, 0.10571159f, 0.03054463f, -0.00598278f, 
    -0.04947723f, 0.08007047f, 0.02591308f, -0.04147102f, 0.01837984f, -0.08505081f, -0.16497494f, -0.08270059f, 
    -0.01418661f, -0.05717490f, 0.07394376f, 0.08251916f, 0.13913386f, 0.16281225f, 0.08454704f, 0.19856238f, 
    -0.02584908f, 0.00764980f, 0.04602494f, 0.13948508f, 0.00335509f, 0.04371532f, 0.07242728f, -0.03711543f, 
    -0.31919682f, -0.09492627f, 0.06470083f, -0.10827055f, 0.15195285f, -0.03367354f, -0.11868559f, -0.06114216f, 
    0.06432468f, 0.12219521f, 0.01740911f, 0.08999473f, -0.13584042f, -0.13518013f, -0.00997483f, -0.20036216f, 
    0.04596566f, -0.00815580f, -0.15472950f, -0.05953875f, 0.04345021f, 0.08709843f, 0.00538302f, -0.08274808f, 
    0.22847456f, 0.09886018f, 0.21373206f, 0.05795815f, -0.00523199f, -0.12434465f, -0.03561103f, -0.06912555f, 
    0.00783235f, -0.07669673f, -0.08030439f, 0.06226744f, 0.08379369f, 0.17630062f, 0.12097574f, 0.01700896f, 
    0.00774354f, -0.09455013f, -0.06257439f, 0.03423925f, -0.05818310f, -0.00501904f, 0.17153066f, 0.13957110f, 
    -0.16154265f, -0.11701656f, -0.05996355f, 0.07035328f, -0.00389921f, -0.01261657f, -0.02295024f, 0.01949407f, 
    -0.15058225f, -0.11646231f, 0.02789444f, 0.02423255f, 0.29867929f, 0.27338314f, 0.15826094f, 0.01454080f, 
    0.01437811f, 0.02067856f, -0.09261847f, -0.14667530f, -0.03233262f, -0.00865908f, 0.04803131f, -0.08447121f, 
    0.00665734f, 0.19660620f, 0.33770171f, 0.06048909f, 0.03995491f, 0.00997270f, 0.00414447f, -0.00786466f, 
    0.01146615f, -0.00746299f, 0.10179301f, 0.03562488f, -0.17247333f, -0.44607848f, 0.05221429f, -0.13239071f, 
    -0.09446393f, -0.02145083f, -0.04291155f, -0.08009285f, 0.07875922f, -0.00346638f, -0.02379288f, -0.10632153f, 
    0.21562420f, 0.21883288f, 0.01451469f, 0.09650104f, 0.05099115f, 0.11861135f, 0.00757976f, 0.04804533f, 
    -0.00616785f, -0.08106817f, 0.02817103f, 0.14062308f, -0.01843911f, -0.18673486f, -0.41479644f, -0.02585042f, 
    -0.02145348f, 0.07147060f, -0.02431169f, -0.05879578f, 0.10596105f, -0.02741470f, 0.14538234f, -0.03201042f, 
    -0.06593343f, -0.02042116f, -0.05189801f, -0.07671188f, -0.02815497f, -0.12791450f, 0.01819783f, -0.05095375f, 
    -0.08449969f, -0.03731769f, -0.09039992f, -0.07296683f, -0.13817132f, -0.16673160f, 0.01978266f, -0.21093825f, 
    0.02407659f, 0.14510059f, 0.04732669f, -0.03713404f, 0.13101161f, 0.09830077f, 0.00385532f, 0.02416783f, 
    0.21153565f, 0.07830054f, 0.31334931f, 0.28689155f, 0.04437948f, 0.10477390f, -0.10844343f, -0.11069212f, 
    0.01497598f, 0.04076837f, 0.01388825f, -0.00647586f, 0.01470579f, 0.01465809f, 0.04792448f, 0.07270825f, 
    0.09980882f, -0.03446224f, -0.06281429f, 0.05774226f, 0.00982288f, -0.01155705f, 0.00706862f, 0.09960535f, 
    -0.10906485f, -0.09254182f, -0.11014986f, -0.07544959f, 0.01205917f, -0.03464283f, -0.04050308f, -0.13515374f, 
    0.15997086f, 0.08833507f, 0.06334072f, 0.06820276f, -0.15103334f, -0.10064240f, 0.00484684f, -0.06117633f, 
    -0.15031491f, -0.07854135f, 0.02849219f, -0.03228668f, -0.14827348f, -0.03752358f, -0.03651673f, 0.12380387f, 
    0.71424961f, 0.27131602f, 0.06653631f, 0.47881287f, -0.04070842f, 0.09929407f, -0.04758289f, -0.04886173f, 
    -0.00056907f, -0.11420216f, 0.04555307f, 0.04761764f, 0.13789503f, 0.04230832f, -0.05039123f, -0.00680326f, 
    0.01546860f, 0.02893930f, -0.00057697f, 0.00935583f, 0.03235975f, -0.12727785f, 0.16415767f, 0.02935997f, 
    0.28725368f, 0.18762627f, 0.08518013f, 0.20055741f, -0.08015600f, -0.11579662f, 0.02747542f, 0.03617286f, 
    -0.09698771f, -0.15853561f, -0.06932165f, -0.04859040f, -0.04166580f, -0.02206338f, -0.12737346f, 0.17647222f, 
    -0.08046129f, -0.04360295f, -0.10959148f, -0.15430592f, 0.00344470f, -0.00708928f, 0.05855593f, -0.01422935f, 
    -0.14030838f, -0.18258634f, 0.05772213f, 0.10133233f, 0.03191374f, 0.00040345f, 0.10038809f, 0.22615691f, 
    0.04496810f, 0.01234764f, 0.10335436f, -0.06353300f, -0.29853383f, 0.23284642f, 0.57112384f, -0.01599095f, 
    0.06575439f, -0.06907789f, -0.09339626f, 0.17194141f, 0.06791770f, -0.05086950f, 0.06326125f, -0.20544145f, 
    -0.10022618f, 0.21268970f, 0.18445158f, 0.05798209f, -0.04400130f, -0.02576149f, -0.02098475f, 0.16334179f, 
    -0.14738655f, -0.08494394f, 0.03884279f, -0.10421167f, 0.07060412f, -0.08185420f, 0.06955668f, 0.25139660f, 
    0.04158246f, -0.00529388f, -0.00018408f, -0.12172324f, 0.04570042f, -0.01108918f, 0.23311281f, 0.26766270f, 
    0.02809484f, 0.23309407f, -0.00874381f, -0.01742804f, 0.06084751f, -0.19356602f, -0.11105788f, -0.02542701f, 
    -0.20104311f, -0.12080899f, 0.02469341f, 0.05494694f, -0.00571345f, -0.08033247f, 0.00245321f, 0.11620953f, 
    -0.03553759f, -0.15873763f, 0.00985108f, -0.08117706f, 0.03343423f, -0.05832070f, -0.09964583f, -0.00068146f, 
    0.21663041f, 0.05483977f, 0.03387742f, 0.15611568f, -0.03072173f, 0.06369960f, -0.02751271f, 0.01246963f, 
    0.10586485f, -0.11656977f, 0.04580157f, -0.05180596f, -0.10405529f, -0.05338646f, 0.00102910f, -0.02983715f, 
    -0.04579550f, 0.01319920f, 0.05511471f, 0.24529432f, -0.02122815f, 0.02570700f, -0.04776524f, -0.14486614f, 
    -0.00406027f, 0.19095777f, -0.29323646f, -0.09975250f, -0.04959022f, -0.10329481f, -0.05551760f, -0.07727288f, 
    0.03096674f, 0.11623717f, -0.05853227f, -0.01990039f, -0.25358719f, 0.09457938f, 0.14554912f, -0.01272833f, 
    0.17027551f, 0.13663983f, 0.06632924f, -0.07891686f, 0.15359500f, 0.01173200f, 0.08281227f, 0.14457336f, 
    -0.09417298f, 0.09659343f, 0.07068599f, 0.01713637f, 0.04451628f, -0.05368071f, 0.07393486f, 0.01665864f, 
    0.03839834f, 0.10518713f, -0.02276240f, -0.07804797f, -0.18545981f, -0.05916033f, 0.06077942f, 0.19569424f, 
    -0.01909912f, 0.21657006f, 0.03477314f, -0.04842285f, -0.11420435f, -0.12685600f, -0.01044957f, 0.01465345f, 
    -0.05737812f, 0.48144764f, 0.15414663f, 0.17861779f, -0.01559169f, -0.01910631f, -0.04831519f, -0.07086469f, 
    -0.00332513f, -0.02640485f, -0.04699210f, 0.02980240f, -0.33194917f, 0.08518360f, 0.07126155f, 0.09480681f, 
    0.05332607f, 0.01685531f, 0.10164310f, -0.15166438f, 0.15557070f, 0.16759475f, -0.05504459f, 0.09924001f, 
    -0.01839255f, 0.08757163f, 0.02069386f, 0.14364007f, -0.19762178f, -0.04969975f, -0.05556049f, 0.08734416f, 
    -0.00036530f, 0.03564104f, -0.04021237f, -0.13847108f, 0.21835139f, -0.14179163f, -0.10809286f, 0.06621651f, 
    0.01301096f, -0.03118071f, 0.10725126f, 0.08049595f, -0.03662524f, 0.06686515f, -0.02600721f, 0.02776679f, 
    -0.00506497f, -0.04925594f, 0.02878425f, -0.02900877f, -0.10570261f, 0.13912709f, 0.04878340f, -0.00885992f, 
    0.03263549f, 0.04525519f, -0.01002490f, -0.03296217f, -0.36889255f, -0.03650720f, -0.21052410f, -0.07956596f, 
    -0.01262506f, -0.15637460f, 0.10452890f, 0.00972360f, -0.08072274f, 0.18123916f, -0.08254658f, -0.17380661f, 
    -0.67194086f, 0.29971889f, 0.26411662f, -0.13433559f, 0.02637651f, 0.07534977f, 0.02300281f, -0.07061474f, 
    -0.11906181f, 0.00066618f, 0.05067702f, 0.15207310f, -0.08393711f, 0.08022904f, 0.11752816f, -0.10134637f, 
    0.01089863f, 0.07341338f, 0.01972004f, -0.17497241f, 0.07214301f, 0.08686896f, 0.00262649f, 0.20353651f, 
    -0.03612723f, -0.04529001f, -0.03581838f, -0.14686863f, -0.04855065f, -0.05910870f, 0.02099349f, -0.12478843f, 
    -0.12949845f, 0.04763320f, -0.02380499f, -0.13285117f, -0.00248187f, -0.15359047f, -0.18725365f, 0.03469869f, 
    -0.04869112f, -0.03743229f, -0.17308594f, 0.09700288f, 0.01477339f, 0.07801664f, 0.05197477f, -0.10272772f, 
    0.15625797f, 0.00960428f, -0.22188890f, -0.05382442f, 0.14723352f, 0.02709135f, 0.02277027f, 0.11210338f, 
    0.05729568f, -0.00858895f, -0.32436121f, 0.03321002f, -0.13150148f, -0.05171967f, -0.15302137f, -0.17625588f, 
    0.09998456f, -0.17734793f, -0.04104936f, 0.12763563f, -0.20304239f, -0.13054749f, -0.18041547f, -0.24906595f, 
    -0.12000833f, 0.06800684f, 0.06580395f, 0.24703780f, -0.14442921f, -0.11035793f, 0.00637616f, 0.00356533f, 
    -0.08173422f, -0.13071536f, -0.01400653f, -0.10535455f, -0.07312852f, 0.10482692f, 0.19069181f, -0.03801281f, 
    0.13677296f, 0.04305823f, 0.06603874f, -0.05726745f, 0.09221093f, 0.19415957f, -0.11701967f, 0.22952393f, 
    -0.02757345f, 0.20962046f, 0.28992009f, 0.26755518f, 0.05735368f, 0.01979046f, 0.10951743f, -0.07824846f, 
    -0.04404946f, 0.09548105f, -0.03597199f, 0.20543003f, -0.00225789f, -0.07481777f, -0.06321736f, 0.00828178f, 
    0.02130021f, -0.02722816f, 0.14349090f, 0.04023218f, 0.01211645f, 0.14053695f, 0.10588559f, 0.03168024f, 
    0.16513586f, -0.10299009f, 0.03736101f, -0.05342325f, -0.08898858f, -0.00277852f, -0.32438552f, -0.27620828f, 
    -0.11759081f, 0.15699621f, -0.28434655f, -0.04770526f, -0.24963978f, -0.26247713f, -0.20108128f, -0.22405565f, 
    -0.05730176f, -0.03184962f, -0.06054467f, 0.03844282f, -0.06790581f, -0.09940442f, -0.03889841f, 0.01086717f, 
    0.02966759f, 0.16656280f, 0.27471736f, 0.17580728f, 0.02366125f, -0.09110602f, 0.06040820f, -0.13478933f, 
    0.01670246f, 0.03649270f, -0.00039869f, 0.13636190f, 0.18673857f, 0.09906842f, -0.01219280f, 0.08462344f, 
    0.03488928f, 0.00242006f, -0.01246691f, 0.15868793f, 0.01920823f, -0.01718282f, 0.09276331f, 0.12033924f, 
    -0.05399133f, 0.10004403f, 0.13390148f, 0.16911849f, -0.07083706f, -0.03386091f, -0.18042538f, 0.02732532f, 
    0.11389728f, 0.03445356f, -0.01501004f, 0.06916175f, -0.31426847f, 0.11401890f, 0.04184520f, 0.00341032f, 
    -0.00729787f, -0.00364890f, -0.17807284f, 0.03768452f, -0.03404960f, 0.00235370f, 0.03414504f, 0.02293760f, 
    0.02091710f, 0.10202647f, 0.02900117f, 0.20969318f, -0.17982018f, 0.07022166f, 0.13522583f, -0.04776685f, 
    -0.05251339f, 0.12060068f, 0.03722838f, -0.12982854f, 0.02854907f, 0.13540505f, 0.25741044f, 0.11605821f, 
    0.02457917f, 0.08644906f, 0.06997200f, -0.05662131f, -0.01230456f, -0.15885805f, -0.04714626f, 0.02564523f, 
    0.07827003f, 0.06026290f, 0.01112728f, -0.09251521f, 0.09412334f, -0.01106540f, -0.07541382f, 0.07336453f, 
    -0.03693260f, 0.02843986f, -0.01044799f, -0.01447317f, -0.05523126f, -0.07087717f, 0.31229240f, 0.10223499f, 
    0.02812010f, -0.17656431f, -0.09088156f, -0.07512562f, -0.11632145f, -0.02131763f, 0.00933965f, -0.27339804f, 
    0.10818582f, -0.01770745f, 0.17792165f, 0.17938559f, 0.02458719f, -0.10711142f, 0.16832075f, -0.09942900f, 
    -0.06420253f, 0.06809488f, -0.04834662f, 0.09135357f, -0.13050233f, 0.01241579f, 0.08661809f, 0.26472536f, 
    -0.25275767f, -0.03458839f, 0.13962398f, -0.11086122f, -0.01062070f, -0.00382901f, 0.02015421f, -0.06352342f, 
    0.19956706f, -0.25915733f, -0.00234585f, 0.12875843f, 0.16228288f, -0.12589560f, -0.04570619f, -0.03763697f, 
    -0.09639840f, -0.06483113f, 0.02662019f, 0.01080553f, 0.28170100f, 0.11465334f, 0.14938501f, 0.32348463f, 
    0.15721126f, -0.00296346f, 0.05546816f, -0.05592072f, 0.01438096f, 0.10635296f, -0.02081452f, 0.15271693f, 
    -0.14332020f, 0.03147135f, 0.14272040f, 0.07009839f, 0.03133091f, 0.00517621f, -0.19870156f, -0.16039033f, 
    0.03763404f, 0.05551433f, 0.20245211f, 0.10225266f, -0.08535228f, -0.00279714f, 0.28453377f, 0.04776224f, 
    0.15204105f, 0.06345382f, -0.06347389f, -0.00109150f, 0.10406502f, -0.10755867f, -0.05320352f, 0.08351619f, 
    0.05482027f, 0.13528132f, 0.05883649f, 0.06604272f, 0.28310865f, -0.07769701f, -0.18100405f, -0.17196761f, 
    0.00207787f, 0.04175356f, -0.10515349f, 0.19147028f, -0.20583941f, -0.14735545f, 0.01672161f, -0.06940236f, 
    -0.02864600f, -0.02014771f, -0.08273532f, -0.30316287f, -0.00203530f, -0.01017804f, 0.00383026f, 0.01507908f, 
    -0.09491830f, 0.02888483f, -0.10668495f, 0.18896013f, -0.07620650f, 0.03134379f, -0.04404498f, -0.00193226f, 
    0.11887881f, 0.08840482f, -0.02913321f, 0.17388353f, 0.09734006f, -0.00996885f, 0.01856286f, -0.08193592f, 
    0.12599522f, -0.20276381f, 0.02204174f, -0.02088645f, 0.01740076f, 0.03207129f, 0.07676521f, 0.15359692f, 
    0.08513635f, -0.02885993f, 0.09085403f, 0.03663659f, 0.01067658f, -0.06982784f, 0.00336605f, -0.11684036f, 
    0.10807684f, 0.15306617f, 0.06909397f, 0.11723986f, 0.07648908f, -0.18558638f, 0.14564668f, -0.04732927f, 
    0.07201060f, -0.13223244f, -0.12667519f, -0.03705110f, 0.03190653f, -0.10418615f, -0.02349680f, 0.00696281f, 
    0.29067767f, 0.01017271f, 0.00469977f, 0.03769150f, -0.01591638f, 0.04216239f, -0.03927134f, -0.06304046f, 
    -0.16948131f, 0.01291143f, 0.01557705f, -0.07049274f, -0.50034130f, -0.07967144f, 0.36227432f, -0.05937305f, 
    0.03677279f, 0.00172599f, -0.09203472f, 0.00211783f, -0.01375333f, -0.15172315f, -0.09314088f, 0.06556106f, 
    0.05465867f, -0.02112322f, -0.00068074f, 0.07424226f, 0.09069005f, -0.07360116f, 0.01749651f, 0.01244116f, 
    -0.04610927f, 0.05867870f, -0.03907688f, 0.08834057f, -0.27749595f, -0.30437845f, -0.08889421f, -0.12577610f, 
    0.02686601f, 0.01785591f, -0.15323268f, 0.03547797f, -0.07705335f, -0.24276963f, 0.04596486f, 0.05079322f, 
    -0.06077010f, -0.02521403f, 0.07629533f, 0.12261977f, 0.02225296f, 0.13159324f, -0.09966876f, 0.13628204f, 
    -0.12599677f, -0.07785422f, -0.03905389f, -0.12051788f, -0.09391049f, -0.00719081f, -0.02370944f, -0.04712166f, 
    -0.05814278f, 0.18249269f, 0.03245534f, -0.04476522f, 0.12135362f, -0.04248282f, 0.20104384f, 0.01332368f, 
    -0.03099547f, 0.01523203f, 0.01857269f, 0.02429005f, 0.00244041f, 0.01894010f, -0.02922792f, -0.01448787f, 
    0.01916009f, -0.03689147f, 0.02207636f, 0.02298602f, -0.00467987f, -0.00709050f, -0.03296994f, 0.02496113f, 
    0.00105525f, -0.03318672f, 0.02634184f, -0.02405684f, -0.02802580f, -0.00845274f, -0.00142948f, -0.00556669f, 
    0.00622444f, -0.00956512f, 0.00993408f, -0.03391086f, 0.00266774f, 0.01231320f, -0.03210474f, -0.01974890f, 
    0.00648702f, -0.01901262f, -0.01170984f, -0.04232390f, 0.02733242f, 0.02482842f, -0.01911460f, 0.02156918f, 
    -0.03062842f, -0.02876113f, 0.00958907f, -0.02694551f, -0.04463043f, -0.02466526f, -0.02059508f, 0.00843651f, 
    0.02500613f, -0.03156287f, -0.01513272f, 0.00101719f, 0.02062131f, 0.02142423f, -0.02142808f, -0.00045081f, 
    0.02512480f, -0.01039701f, 0.00048105f, -0.01488183f, -0.04408054f, 0.00371497f, -0.03603452f, -0.01893715f, 
    -0.00114572f, -0.00121276f, -0.01840267f, -0.03732547f, 0.02674833f, 0.02874013f, 0.02146467f, 0.02484092f, 
    0.01654412f, -0.00787743f, 0.00271223f, -0.02265086f, -0.03063271f, 0.02604548f, 0.00734182f, 0.01088258f, 
    -0.03030441f, 0.00080701f, 0.00289180f, -0.03386268f, -0.03676783f, 0.01329485f, -0.02577903f, -0.00337862f, 
    0.01524242f, -0.01864843f, -0.01823106f, 0.02134632f, 0.00541454f, 0.01347857f, -0.02760641f, 0.02385027f, 
    0.04415742f, -0.03592620f, -0.02966630f, 0.03113632f, -0.00533204f, 0.02735432f, 0.00123789f, -0.00214455f, 
    -0.00127737f, -0.01182374f, -0.03374552f, -0.02782977f, 0.00479078f, 0.01365174f, -0.01605964f, -0.01832353f, 
    0.01939213f, -0.00374977f, 0.00304482f, -0.04463011f, 0.00196709f, 0.02360670f, -0.02079114f, 0.01653561f, 
    -0.00131153f, 0.01215637f, 0.02375356f, -0.02749229f, -0.00452209f, -0.00226667f, 0.00129569f, -0.01907209f, 
    0.02434996f, -0.02724869f, -0.03253889f, -0.03023903f, 0.00647112f, -0.01880232f, -0.03072407f, -0.00620454f, 
    -0.02960020f, -0.01954781f, -0.00101814f, -0.01359536f, 0.01370371f, -0.00491032f, 0.00453786f, 0.01121330f, 
    -0.00572403f, -0.01301614f, -0.04382073f, -0.01383854f, 0.00989931f, -0.00314049f, 0.02181141f, 0.01005133f, 
    -0.01108406f, -0.01250187f, 0.01709375f, -0.03912416f, 0.01333212f, -0.01904934f, 0.00518282f, -0.04055715f, 
    -0.03835464f, 0.00893941f, -0.03478701f, 0.00211680f, -0.02774456f, -0.02767687f, -0.00507724f, -0.00818272f, 
    -0.02181789f, 0.00544717f, -0.01943753f, -0.01847125f, 0.03076428f, 0.02520768f, -0.03009115f, -0.01335103f, 
    0.01753703f, 0.02552447f, -0.04022652f, 0.02292212f, -0.02932543f, 0.00459166f, -0.00326296f, -0.01028801f, 
    -0.03797441f, 0.00167502f, 0.01384274f, -0.00539620f, 0.01485649f, 0.00436948f, 0.02447143f, -0.03461066f, 
    -0.01599755f, 0.02229390f, 0.01241664f, -0.01761524f, 0.01252956f, -0.01539978f, 0.02218229f, 0.00948137f, 
    -0.03196509f, -0.02842680f, -0.04430982f, -0.02834120f, 0.01035222f, 0.01925674f, 0.00881270f, -0.02210013f, 
    0.01507452f, 0.00639263f, -0.02997318f, -0.00081570f, -0.00854117f, -0.02996031f, 0.01015560f, -0.00558783f, 
    -0.04408879f, -0.00274966f, -0.01619249f, -0.02058705f, -0.03697747f, -0.01894912f, 0.01539152f, -0.03888983f, 
    -0.04574410f, 0.00530157f, -0.02327348f, -0.00875255f, -0.03416721f, 0.01163448f, -0.00802125f, 0.01536596f, 
    -0.03400837f, -0.03589759f, -0.02916284f, -0.03482922f, -0.04110511f, -0.00710525f, 0.00336490f, 0.00159320f, 
    -0.02458865f, -0.04348418f, 0.00922022f, 0.02106282f, -0.02885782f, 0.01540856f, 0.00486203f, -0.03576574f, 
    -0.02334752f, -0.01418474f, -0.02489588f, -0.03703006f, 0.01220008f, 0.01522664f, 0.01957694f, -0.04409475f, 
    0.01972215f, 0.02334041f, 0.00082925f, 0.02172863f, -0.03334114f, -0.00828779f, 0.00910648f, 0.01871090f, 
    -0.00629063f, 0.00727978f, -0.01245301f, -0.00639347f, 0.01839430f, -0.02138470f, -0.00824392f, 0.00612966f, 
    -0.02233871f, -0.01672069f, -0.00353858f, -0.04016860f, 0.02069788f, 0.02529538f, 0.02276192f, -0.03962176f, 
    0.02318036f, -0.02686131f, -0.01920523f, 0.01309817f, 0.00558414f, -0.02606494f, -0.04283594f, -0.00177218f, 
    0.01905647f, 0.01310938f, 0.02167781f, 0.02308880f, -0.00691372f, -0.01785706f, -0.02975864f, 0.01825411f, 
    0.00194895f, -0.02546084f, -0.03305286f, -0.03423962f, -0.02415776f, -0.00591374f, -0.02299367f, 0.00837984f, 
    0.01478124f, -0.00442517f, -0.00263147f, -0.03158756f, -0.01243806f, 0.00987165f, -0.03813401f, 0.01832299f, 
    -0.03018254f, -0.01804038f, -0.04207673f, -0.02361769f, -0.01981490f, 0.00729491f, -0.02565260f, 0.02568365f, 
    0.01102436f, 0.00656012f, -0.01560777f, 0.02246728f, 0.01319753f, -0.02041060f, -0.01125401f, -0.00028629f, 
    -0.00207660f, 0.02136048f, 0.02079386f, -0.02363352f, 0.00379646f, -0.02015830f, 0.01637042f, 0.01661707f, 
    -0.03425442f, -0.02331926f, 0.01501160f, -0.01540728f, -0.02725931f, -0.03257199f, -0.00525382f, -0.01185349f, 
    -0.00755591f, -0.04280046f, -0.01295558f, -0.03960551f, 0.02177666f, 0.01029993f, 0.02379282f, -0.00360162f, 
    -0.02274159f, -0.01504660f, -0.04264474f, -0.04461948f, 0.02059576f, -0.03871480f, -0.02754212f, -0.03820824f, 
    -0.03418188f, -0.01253482f, 0.02227083f, -0.01787434f, -0.01051093f, 0.00115328f, 0.00051779f, 0.00860497f, 
    0.01409727f, 0.00422297f, -0.03548340f, -0.02889070f, -0.03128578f, -0.02502611f, -0.01149797f, 0.02564744f, 
    -0.02882991f, -0.02455167f, -0.04246574f, -0.02650827f, -0.00111119f, 0.02635380f, 0.01602371f, 0.00239303f, 
    -0.02753636f, -0.01988645f, -0.03223561f, -0.02113903f, 0.00321001f, -0.00282908f, -0.01107643f, -0.00135952f, 
    0.00411454f, -0.03771011f, 0.00851097f, -0.03086032f, 0.02489311f, -0.01238673f, -0.02599389f, -0.01462574f, 
    -0.03327980f, -0.01878741f, 0.01149755f, -0.04193358f, 0.01190886f, 0.01375648f, -0.03053038f, -0.00395693f, 
    0.01424234f, -0.00034109f, -0.03204539f, 0.02264913f, 0.02424263f, -0.01946769f, 0.01693820f, -0.02590730f, 
    -0.00499163f, 0.01383896f, 0.00186694f, -0.02162736f, -0.03040638f, -0.04215677f, 0.00810717f, 0.01567029f, 
    -0.00647016f, -0.00325108f, -0.00775878f, 0.02214546f, -0.01365742f, -0.01121407f, 0.00186792f, 0.00197906f, 
    -0.01924101f, -0.03689997f, -0.02820707f, -0.03622225f, -0.03550675f, -0.03066986f, 0.01309547f, -0.02877928f, 
    0.02873314f, -0.02899134f, -0.04166658f, -0.01507387f, -0.04224007f, -0.03271836f, -0.03000666f, 0.00497297f, 
    -0.02310642f, 0.01551024f, -0.02111765f, 0.01392586f, -0.02996312f, -0.03393726f, -0.03224856f, -0.03793735f, 
    -0.01765071f, 0.01833644f, -0.03516590f, 0.00553125f, 0.02218200f, -0.04176039f, -0.03011498f, 0.00679835f, 
    -0.00499338f, -0.03054955f, -0.01669527f, 0.00464341f, -0.01848398f, -0.04077494f, -0.00650354f, -0.02513377f, 
    -0.03645886f, 0.01408926f, 0.02289258f, 0.00080029f, 0.01425710f, 0.00547502f, 0.02226721f, 0.01435268f, 
    -0.00795246f, -0.00623930f, -0.00439944f, -0.00692961f, 0.01336094f, -0.02514601f, -0.00747251f, -0.01790943f, 
    0.00037277f, -0.04292053f, 0.02447200f, -0.00610038f, 0.01277514f, 0.00989831f, -0.00811498f, -0.03835807f, 
    0.00327452f, 0.01064199f, 0.02372794f, 0.01394722f, -0.01847369f, -0.03523324f, 0.01169395f, -0.02283011f, 
    0.02417355f, 0.01790198f, 0.02514308f, -0.00584761f, -0.00668921f, -0.04470134f, 0.01299247f, -0.04243548f, 
    0.01047390f, 0.02178392f, -0.02260922f, 0.02435858f, 0.02279864f, 0.00101126f, -0.04037549f, 0.00642638f, 
    -0.03797000f, 0.00074257f, -0.00667249f, -0.03999893f, -0.00457914f, 0.02664570f, -0.00842813f, -0.03385460f, 
    0.00168608f, 0.01842150f, -0.02069414f, -0.02773489f, -0.03009257f, -0.02029593f, -0.00335336f, -0.01771454f, 
    0.00742752f, 0.00914013f, -0.00244097f, 0.01764391f, -0.01674644f, -0.02881051f, -0.00506057f, -0.00058392f, 
    -0.00940299f, -0.01152450f, 0.00239352f, -0.03115221f, -0.01869987f, -0.01952249f, -0.02066972f, -0.03501879f, 
    0.02263518f, 0.01238315f, -0.00802998f, -0.02041578f, -0.01760513f, 0.01012375f, -0.00400034f, 0.02091463f, 
    0.01329700f, -0.00985819f, 0.00711692f, 0.01547226f, 0.01198607f, -0.01207555f, 0.02160783f, 0.02942820f, 
    0.01661978f, 0.00249309f, -0.03037929f, 0.02380869f, 0.00181243f, -0.03717200f, 0.01254561f, 0.01044492f, 
    -0.03200077f, 0.02285311f, 0.01091770f, -0.00689473f, 0.01397186f, -0.01111247f, 0.02545522f, -0.02716305f, 
    -0.01646120f, -0.00982129f, -0.00096784f, -0.03114059f, 0.00916932f, -0.02242110f, 0.00262005f, 0.01319484f, 
    -0.02985151f, 0.01849024f, -0.00662084f, -0.01742644f, 0.01680339f, -0.02687901f, -0.00176684f, 0.01552428f, 
    -0.01231155f, -0.03082336f, 0.01894533f, 0.00957170f, -0.01022432f, 0.01572779f, 0.00030493f, -0.02385946f, 
    0.01811442f, 0.02171224f, -0.01481029f, -0.03220803f, -0.01392000f, -0.00151280f, -0.02094712f, -0.00281444f, 
    0.01478782f, -0.03044673f, -0.00825046f, -0.02727864f, 0.01584870f, -0.00842147f, -0.03146998f, -0.01266281f, 
    -0.02921394f, -0.03095306f, -0.04312913f, -0.03951501f, 0.01632744f, -0.02455210f, 0.00078162f, -0.01430283f, 
    0.00226456f, 0.02880449f, 0.01257118f, 0.01685097f, -0.01588168f, -0.02778694f, -0.00315199f, -0.00319920f, 
    -0.02704470f, -0.00886212f, 0.01239292f, -0.00762992f, -0.01524536f, -0.03269869f, 0.00914662f, 0.02202021f, 
    0.02313600f, 0.03774308f, -0.03474750f, -0.00100047f, -0.00081040f, -0.02017876f, -0.01803267f, -0.00962696f, 
    -0.02407104f, -0.03077533f, 0.00299113f, -0.00838254f, -0.00580216f, -0.02443107f, 0.00527150f, 0.01105337f, 
    0.02562710f, 0.00778868f, 0.00572337f, -0.00899195f, -0.03166968f, -0.00308136f, -0.04186422f, 0.00151286f, 
    -0.02509749f, 0.00658470f, -0.01927952f, -0.03991801f, -0.00703714f, -0.00985975f, -0.03810560f, 0.01933597f, 
    -0.02222802f, 0.02204540f, 0.01205137f, -0.04324771f, -0.00091342f, -0.04020856f, -0.02658754f, -0.02770094f, 
    -0.04609012f, -0.02313653f, 0.02335475f, 0.02392421f, 0.01768724f, 0.01507505f, -0.03686579f, -0.02682971f, 
    0.00649923f, -0.00908892f, -0.00630132f, -0.00571433f, 0.00086406f, -0.00560145f, 0.02550417f, -0.00438900f, 
    -0.00034327f, -0.02371859f, -0.02964028f, -0.03427002f, -0.01378292f, -0.03251253f, 0.01290478f, -0.04002869f, 
    0.01103923f, -0.02087032f, -0.03038684f, -0.00889826f, -0.01447997f, 0.01355277f, 0.02178345f, -0.00267233f, 
    0.01334885f, -0.01231732f, -0.01273679f, 0.00790483f, 0.02879235f, -0.03397813f, -0.02497877f, -0.00402864f, 
    -0.04026125f, 0.00871523f, 0.00992100f, -0.00482484f, -0.00527333f, 0.00852215f, -0.04404241f, -0.01228156f, 
    0.01575899f, -0.04190943f, -0.00545040f, -0.02967192f, -0.00785517f, -0.00970486f, -0.03574263f, 0.00534881f, 
    -0.04183123f, -0.03643152f, -0.01404196f, 0.00381910f, -0.00338460f, -0.02712590f, -0.00366690f, -0.03938596f, 
    0.00707279f, 0.01852365f, -0.03361853f, 0.02331482f, 0.01824585f, -0.03925709f, 0.02116500f, -0.01338258f, 
    -0.01814594f, -0.00291101f, 0.02258741f, -0.01075231f, 0.02612060f, -0.03398938f, -0.02868130f, -0.00296690f, 
    0.00789893f, 0.01110988f, -0.00111333f, -0.02042121f, -0.00738933f, -0.03630963f, -0.03256790f, 0.01383383f, 
    -0.00538355f, 0.02544593f, -0.03252044f, 0.00389997f, 0.00715637f, -0.02566663f, 0.00257051f, -0.01584378f, 
    -0.03849706f, 0.02655731f, -0.01188796f, 0.01650502f, -0.01894735f, -0.03558069f, -0.02425966f, -0.00515406f, 
    0.00666054f, 0.02039138f, -0.03084749f, 0.00175845f, -0.01226682f, -0.04008528f, 0.02216207f, 0.00826698f, 
    -0.01130531f, -0.00841278f, -0.00597285f, -0.00761259f, -0.04029306f, -0.01106750f, 0.02978443f, -0.00397655f, 
    -0.02617635f, 0.01180653f, 0.02212172f, -0.04315175f, -0.02049376f, 0.00176092f, 0.02341155f, -0.03944498f, 
    0.00715115f, 0.02824955f, -0.00406572f, -0.02478177f, -0.01305464f, -0.00017913f, -0.04201179f, -0.02901827f, 
    -0.04158136f, 0.02253696f, 0.02391315f, -0.02323437f, -0.03989329f, -0.03631959f, -0.03409987f, -0.00051769f, 
    0.01929720f, -0.01466358f, -0.03678528f, 0.01341672f, -0.03786378f, -0.00648223f, 0.02494696f, 0.02186662f, 
    0.02444893f, 0.00973925f, -0.00928425f, -0.00669910f, -0.02432151f, -0.01368711f, 0.00558781f, -0.00618188f, 
    -0.03874900f, -0.02522556f, 0.01026466f, 0.01242271f, 0.00550493f, -0.03302257f, 0.02106950f, 0.00540169f, 
    -0.03634316f, 0.01420412f, -0.00145831f, -0.03857971f, 0.00604227f, -0.01004619f, 0.02259487f, -0.00141769f, 
    0.02841816f, -0.04269040f, -0.02329063f, -0.01006253f, -0.02519001f, -0.03327945f, -0.00043960f, -0.01035526f, 
    -0.00554032f, 0.00913716f, -0.03708353f, -0.03023556f, -0.01030991f, -0.01917116f, 0.01111252f, -0.00584170f, 
    -0.02557816f, 0.01046997f, -0.03257677f, 0.01773473f, -0.00912072f, -0.00487535f, -0.00488911f, -0.01286571f, 
    -0.01784668f, 0.01348686f, 0.02590031f, -0.03548573f, -0.02580646f, 0.00489497f, -0.03513446f, -0.03161275f, 
    0.00193677f, 0.02764383f, -0.00790977f, -0.04109898f, -0.00194102f, 0.01282268f, -0.03160363f, 0.03086645f, 
    0.01696296f, -0.00297575f, 0.00267438f, -0.04214239f, 0.00543390f, 0.00668350f, -0.04339765f, -0.02816026f, 
    0.00628995f, -0.00569179f, 0.01630787f, -0.02766694f, -0.00668462f, 0.00444197f, 0.01379052f, 0.00150897f, 
    -0.01698292f, -0.00914460f, -0.03446394f, 0.02432989f, 0.01170033f, 0.02064222f, 0.01603045f, 0.00628111f, 
    0.02701288f, -0.00727055f, -0.02032036f, -0.02255934f, -0.00692748f, -0.00563981f, -0.01221530f, 0.01609006f, 
    -0.01377301f, -0.02825218f, 0.02301346f, 0.01377779f, -0.01459150f, 0.00614866f, 0.01245803f, -0.01421289f, 
    -0.02763263f, -0.03598324f, -0.03017876f, 0.01377046f, 0.00167884f, -0.01279856f, -0.02283135f, 0.01151283f, 
    0.00392413f, -0.03141624f, -0.03201053f, -0.01094308f, -0.02500081f, -0.03449507f, -0.03934737f, 0.01615991f, 
    -0.02108674f, 0.02168955f, -0.02365688f, -0.03336989f, -0.01139684f, 0.00228737f, -0.01812542f, -0.02755892f, 
    -0.03988737f, 0.03046332f, -0.02889091f, 0.02239691f, 0.01775870f, -0.01629600f, -0.01445019f, -0.01527503f, 
    0.00543904f, 0.01278620f, -0.01773587f, -0.00047375f, -0.02560313f, 0.01884418f, -0.01138127f, -0.02093757f, 
    -0.00648840f, -0.03905484f, -0.04004958f, 0.02110096f, -0.01077770f, -0.02671362f, -0.01369823f, 0.02377516f, 
    -0.02325048f, -0.02256718f, -0.02560593f, -0.03150605f, -0.03291334f, 0.01577380f, 0.00992756f, 0.02293563f, 
    -0.01737202f, -0.01029825f, -0.03896064f, -0.02453631f, -0.03796203f, 0.01896499f, -0.00892206f, -0.02568709f, 
    0.00486250f, -0.01572358f, -0.02380647f, 0.02738911f, -0.02408035f, -0.03013583f, 0.00449764f, -0.02567169f, 
    0.02121367f, -0.02359242f, -0.00582257f, -0.03380726f, 0.02514431f, -0.02490621f, 0.01262468f, 0.01802650f, 
    -0.00130236f, 0.00319653f, -0.02952123f, -0.00039102f, 0.01711280f, 0.01109806f, 0.02331883f, 0.02499187f, 
    -0.02005939f, 0.01928353f, 0.01633000f, 0.00548079f, 0.02318516f, -0.02534601f, -0.01084716f, 0.01421013f, 
    -0.02261628f, -0.01858443f, -0.02097916f, 0.02021272f, 0.02367020f, 0.02154951f, -0.00654374f, -0.00812175f, 
    0.00098031f, 0.02311458f, -0.02443674f, 0.01054980f, 0.00498708f, -0.00426011f, 0.02390728f, -0.03243264f, 
    0.03141682f, -0.03177725f, -0.01619720f, 0.01911792f, -0.01815160f, 0.02464641f, -0.01375120f, -0.01498378f, 
    -0.00462491f, 0.02790325f, 0.01706392f, 0.03223061f, 0.00022439f, 0.00027032f, 0.03320697f, -0.03469875f, 
    -0.03748773f, -0.02611004f, -0.01721409f, 0.00546127f, -0.02030475f, -0.00801872f, 0.00676148f, -0.02314501f, 
    -0.03670402f, -0.03214589f, 0.01327875f, -0.03054113f, -0.02473709f, -0.03238965f, -0.00140797f, 0.00330972f, 
    0.02488843f, 0.02556330f, 0.00201781f, 0.00150928f, 0.02084715f, -0.01238528f, -0.00802745f, 0.00693792f, 
    0.00589433f, -0.03361183f, 0.02660790f, -0.00743879f, 0.02492195f, -0.03506691f, -0.02735697f, 0.01473971f, 
    -0.01011167f, -0.00569925f, -0.02464795f, 0.01337814f, -0.03891906f, -0.02330279f, -0.01186056f, -0.00467850f, 
    0.00617502f, -0.02716072f, -0.03463719f, -0.00840137f, -0.02131495f, -0.03225534f, 0.00775137f, 0.01642000f, 
    0.01748749f, -0.00892739f, 0.03312342f, -0.03555083f, 0.01881236f, -0.00745265f, -0.02227926f, -0.04283249f, 
    0.02207356f, -0.03263947f, 0.01395958f, 0.02016986f, -0.01519956f, -0.02080284f, -0.04116387f, -0.00679144f, 
    0.01232940f, 0.01249424f, 0.01458128f, -0.03866572f, 0.00209544f, -0.02506571f, -0.02323284f, -0.02155202f, 
    -0.03798133f, -0.00991001f, -0.00370244f, -0.00932514f, 0.00168413f, 0.00937846f, 0.02562929f, -0.02114320f, 
    -0.00699760f, 0.01701252f, -0.03525256f, -0.00698965f, 0.02148573f, 0.01729466f, -0.03875159f, -0.02165623f, 
    -0.00865257f, 0.00219365f, 0.03177176f, 0.02087773f, -0.03979475f, 0.02117417f, 0.02763537f, -0.00491302f, 
    -0.04379491f, 0.00320539f, -0.01840172f, -0.00302534f, -0.04314946f, 0.02054817f, 0.02328405f, 0.03083776f, 
    -0.03176229f, -0.00032535f, -0.04114659f, -0.01041278f, -0.01306789f, -0.01727459f, -0.00014294f, -0.02674776f, 
    0.02175928f, -0.00189383f, -0.03713947f, -0.01788919f, 0.01450398f, -0.04153488f, -0.01863838f, 0.00930112f, 
    0.01090981f, 0.02287658f, 0.01912622f, 0.02488774f, 0.00152030f, 0.00406205f, -0.01925675f, -0.01346465f, 
    0.02085793f, -0.00138578f, 0.00018410f, 0.00340652f, 0.02168491f, 0.00245401f, -0.03328915f, 0.01212005f, 
    0.02553321f, 0.03298694f, -0.02377957f, -0.00695865f, -0.02733648f, 0.01377837f, -0.01260863f, -0.01262275f, 
    -0.02845341f, -0.02304813f, 0.00662258f, 0.00146595f, -0.01739342f, 0.03010518f, 0.02237418f, -0.01198279f, 
    0.02530490f, -0.02584624f, -0.00289326f, -0.00058526f, -0.01589515f, -0.00679898f, 0.00298798f, -0.00745488f, 
    0.01616040f, 0.01931055f, 0.01424278f, 0.01149997f, 0.00491620f, -0.02809552f, -0.03831172f, 0.02737588f, 
    0.03205423f, -0.00149137f, -0.02212071f, -0.00415289f, -0.00418397f, -0.03647356f, -0.00411313f, 0.00008568f, 
    -0.02753461f, -0.04287383f, -0.00304333f, 0.01426898f, -0.02199587f, -0.01922881f, -0.01499959f, -0.00101731f, 
    0.00899228f, -0.00307688f, 0.03251180f, -0.01911231f, -0.03452631f, 0.02279335f, 0.00459675f, -0.01869167f, 
    0.01312572f, 0.00903237f, 0.01412034f, -0.01096784f, 0.01929384f, -0.01715989f, 0.00375620f, 0.00319066f, 
    -0.03222663f, 0.00646800f, -0.02390143f, -0.03186749f, 0.02304264f, -0.01418382f, -0.00863525f, -0.03073412f, 
    0.01547316f, -0.02275970f, -0.00753631f, -0.01572579f, 0.01382087f, 0.02148998f, 0.00048676f, -0.03368746f, 
    -0.02478039f, 0.02669284f, 0.01780980f, 0.01921174f, -0.01938211f, -0.02596069f, -0.00157834f, -0.01681527f, 
    -0.03120288f, 0.02801522f, -0.03776370f, 0.02510472f, -0.03035039f, -0.03877046f, 0.00928129f, -0.02878183f, 
    0.02705690f, 0.02696470f, 0.01971646f, 0.01281809f, -0.01054557f, 0.01145542f, -0.02392572f, 0.02188133f, 
    -0.03808905f, 0.02848843f, 0.02334457f, 0.01315242f, 0.00670362f, -0.00103262f, 0.02893154f, -0.01862773f, 
    0.00401834f, -0.03631958f, -0.00618277f, 0.02608280f, -0.03791691f, -0.03846164f, -0.03389330f, -0.02304026f, 
    0.03212275f, -0.02161233f, 0.01370815f, 0.00940274f, -0.03930999f, 0.01112128f, -0.00332394f, -0.01893041f, 
    -0.01011110f, 0.02697912f, -0.00191269f, -0.03855773f, -0.02780199f, -0.01898466f, -0.03351328f, -0.04283952f, 
    0.01917231f, -0.01458300f, 0.02091482f, -0.03893381f, -0.03543668f, 0.02222279f, -0.02956775f, -0.02227950f, 
    -0.01407465f, 0.03133582f, 0.00335761f, -0.03635163f, -0.00495838f, 0.01171390f, -0.00115184f, 0.00074009f, 
    0.01669039f, -0.01155739f, 0.01779529f, -0.02866635f, 0.01678972f, -0.03021483f, 0.02520859f, -0.04070889f, 
    0.01687495f, 0.00527933f, 0.00030168f, 0.00488585f, 0.01110875f, 0.02476361f, 0.01255405f, -0.02179975f, 
    0.00748301f, -0.01215578f, -0.00529025f, 0.01268331f, 0.01948621f, 0.01457805f, -0.03418798f, -0.00489107f, 
    -0.02260546f, -0.01240565f, -0.02121828f, -0.03826661f, 0.02525381f, 0.01571151f, -0.01159897f, -0.03470675f, 
    -0.02888097f, -0.01330354f, -0.02167736f, 0.01551029f, 0.02300026f, 0.00727904f, 0.01026538f, 0.00098072f, 
    0.02193816f, 0.01190098f, -0.01935401f, -0.02133288f, -0.00948012f, -0.00320662f, -0.00878632f, -0.02723974f, 
    -0.02971629f, 0.00019130f, 0.02974507f, -0.02109662f, -0.01007055f, 0.02754293f, -0.03484383f, -0.03219741f, 
    0.01441523f, -0.02836682f, -0.01911224f, 0.01803240f, 0.01817363f, -0.02714224f, -0.01474895f, -0.00779804f, 
    0.01281983f, -0.01656950f, 0.02216401f, 0.01890902f, -0.03037756f, -0.00978042f, -0.00576097f, 0.00427145f, 
    -0.00244911f, 0.00340500f, 0.01274560f, 0.01722519f, 0.00329530f, -0.02070242f, 0.01870794f, -0.02586660f, 
    -0.02891777f, -0.01835702f, 0.01521114f, -0.04264335f, 0.01666033f, 0.00271293f, -0.02024361f, -0.00674970f, 
    -0.02642679f, -0.03954460f, -0.02741680f, -0.00869355f, -0.01551706f, -0.01762934f, -0.02399521f, -0.03334542f, 
    -0.01458987f, -0.02776999f, -0.00100722f, -0.00051501f, -0.04029163f, 0.00520186f, -0.04122142f, 0.00146161f, 
    0.00288564f, 0.02060322f, -0.03449915f, -0.02763575f, 0.02663730f, -0.02789346f, -0.00507704f, -0.02242960f, 
    0.01525473f, -0.01303847f, -0.04004499f, -0.00604124f, 0.01108713f, -0.02016680f, -0.03035014f, -0.02320931f, 
    0.01344013f, -0.02209640f, -0.02957888f, 0.03157346f, -0.01553292f, 0.01457645f, -0.02140524f, 0.01539613f, 
    -0.01343403f, -0.02805396f, -0.02516385f, -0.00681489f, 0.02220254f, -0.00801790f, -0.01397634f, 0.02987559f, 
    0.01350721f, -0.00390031f, -0.03349718f, 0.02626065f, 0.01008773f, -0.00711245f, 0.00969855f, 0.02704860f, 
    0.01541036f, -0.01270736f, 0.01477687f, -0.02284797f, 0.00600806f, -0.01313927f, -0.02545901f, 0.01402760f, 
    0.03156291f, -0.03607709f, 0.01373731f, 0.02420166f, 0.01029327f, -0.00912371f, -0.01746166f, -0.03656172f, 
    -0.03899690f, 0.02069597f, -0.02026577f, 0.03088806f, -0.02513658f, 0.01844736f, -0.03728902f, -0.03007183f, 
    0.02511487f, 0.01994293f, -0.03414640f, 0.01881853f, -0.03134524f, -0.00339309f, -0.01715539f, -0.03145142f, 
    -0.19659820f, 0.16501777f, 0.06239283f, 0.04965950f, -0.02924618f, -0.08844475f, -0.03419599f, -0.00265397f, 
    0.18915500f, 0.09999973f, -0.03814486f, -0.03455618f, 0.01187198f, 0.18837382f, -0.09453005f, 0.10933497f, 
    -0.00602496f, -0.02415310f, 0.08389550f, 0.13877527f, 0.05482142f, -0.01814021f, -0.00503303f, 0.05027761f, 
    -0.18836409f, -0.10253791f, 0.06987902f, -0.00236314f, -0.02547759f, -0.06164530f, -0.02525268f, -0.06954393f, 
    -0.00841385f, -0.00216170f, -0.13359378f, -0.04319896f, 0.23049019f, -0.00440979f, -0.15745209f, 0.06903879f, 
    0.02123746f, 0.15042529f, 0.12593918f, 0.03490093f, 0.02735713f, 0.03620920f, 0.08886243f, 0.03884406f, 
    -0.27987292f, -0.14160515f, -0.04950531f, -0.28817374f, 0.05309088f, -0.02257657f, 0.13629927f, -0.01165522f, 
    0.00734194f, 0.12436956f, 0.05071574f, 0.01990787f, -0.21453215f, -0.03037741f, 0.14655259f, 0.04671831f, 
    -0.08020829f, 0.03505585f, -0.12161131f, -0.14822783f, 0.03289353f, 0.18884324f, 0.11958151f, 0.01176608f, 
    0.24224527f, 0.13598908f, -0.11007171f, -0.11832643f, 0.28387856f, 0.10395819f, 0.02769982f, -0.01550508f, 
    0.01275364f, 0.07380135f, 0.04949097f, 0.12713169f, 0.21255855f, 0.07886916f, -0.06772267f, -0.09617634f, 
    0.01960994f, 0.13961670f, 0.14259857f, 0.08601943f, -0.05143869f, 0.03721713f, 0.17381461f, -0.02123865f, 
    -0.03727613f, 0.07268509f, -0.17913228f, -0.05452656f, -0.01887681f, 0.23121345f, 0.12266430f, -0.01730716f, 
    0.06391262f, 0.07316136f, -0.00612914f, 0.15087974f, -0.12973303f, -0.08163801f, -0.13573019f, 0.00443273f, 
    0.07500128f, 0.16516817f, 0.39123735f, 0.01189314f, -0.13029343f, -0.03565929f, 0.01088099f, -0.06157415f, 
    -0.11638352f, -0.27985677f, -0.06497491f, 0.07688689f, 0.11251026f, 0.15659912f, -0.01260737f, -0.02277434f, 
    0.03022946f, 0.01640736f, -0.05139432f, 0.00435074f, 0.01687059f, 0.13937804f, -0.02844294f, -0.04222353f, 
    -0.04487144f, -0.01182641f, -0.01555150f, 0.04916716f, -0.07215614f, -0.11442631f, -0.22593255f, -0.25626081f, 
    0.26788896f, 0.15596981f, 0.02849136f, 0.02304168f, 0.06470694f, 0.13866094f, -0.10201015f, -0.16414995f, 
    -0.03104099f, 0.08694854f, -0.03908294f, 0.15880956f, 0.15051265f, 0.06182441f, -0.11254178f, 0.12857823f, 
    0.12639235f, -0.01640400f, 0.01028765f, 0.17190740f, -0.01615386f, 0.06724711f, -0.04140756f, 0.03660293f, 
    -0.10652079f, 0.02843856f, -0.00519409f, 0.07634029f, 0.12106051f, 0.13571940f, 0.06646647f, 0.11272210f, 
    -0.08070500f, 0.10875142f, -0.16020896f, 0.17607012f, 0.20071946f, -0.19233033f, -0.10339598f, 0.00304188f, 
    -0.08135726f, 0.05698792f, 0.03241147f, -0.00814147f, 0.07064704f, 0.09629004f, 0.14822307f, 0.14067595f, 
    0.01557473f, 0.42647621f, 0.12105992f, -0.16384196f, 0.07313462f, -0.02850682f, -0.06317189f, -0.13495153f, 
    0.08620726f, -0.04898611f, 0.12241885f, 0.12301439f, 0.06355421f, -0.14192991f, -0.12209298f, -0.05046451f, 
    -0.10680096f, -0.05860493f, 0.02744618f, 0.30485564f, -0.15116908f, -0.01035040f, -0.01000030f, -0.15103173f, 
    0.02898126f, 0.01663651f, 0.25976244f, 0.16535760f, 0.09207899f, 0.02504969f, -0.17290196f, 0.12952295f, 
    0.11455484f, 0.00008109f, 0.39245808f, 0.08065756f, 0.15206797f, 0.01166928f, 0.00198267f, -0.13977487f, 
    0.12893361f, -0.32720640f, -0.11125951f, 0.01436736f, 0.17394564f, 0.07456979f, 0.09274658f, 0.07892787f, 
    0.00475328f, -0.30808726f, 0.02681877f, -0.09485623f, 0.18614991f, 0.10093862f, 0.10624029f, 0.09744204f, 
    -0.00557653f, -0.11793474f, 0.04927389f, -0.06963704f, -0.16258484f, -0.13340874f, -0.08208127f, 0.22049361f, 
    0.06094793f, 0.03643719f, 0.06379194f, 0.24376221f, -0.16525102f, 0.03319325f, 0.08203463f, 0.06673826f, 
    0.24830818f, -0.12616365f, -0.07622382f, -0.02222132f, 0.28721875f, 0.04359622f, 0.00304316f, 0.14209442f, 
    -0.00086253f, -0.05559576f, 0.11281555f, 0.05349295f, -0.17534298f, 0.38142464f, 0.07113262f, 0.17133094f, 
    0.06010681f, -0.08150121f, -0.17575410f, -0.14419927f, -0.05601216f, -0.26756698f, 0.17470439f, 0.10857016f, 
    -0.00654922f, -0.05018903f, 0.00106965f, -0.02901376f, 0.18890084f, -0.03322375f, 0.01782332f, 0.34667346f, 
    -0.06613021f, -0.06021337f, -0.04377136f, 0.06796184f, -0.32058614f, -0.07690493f, -0.02499931f, -0.02753242f, 
    -0.10266384f, -0.10368756f, -0.18329957f, -0.00258345f, -0.00263023f, -0.21616541f, 0.19686814f, 0.11570553f, 
    -0.13262047f, -0.26848090f, 0.16242135f, 0.37428832f, -0.00229132f, 0.01652308f, -0.04618683f, 0.12791418f, 
    0.09403671f, 0.10798547f, -0.02124698f, -0.10868523f, -0.23723641f, -0.01976227f, -0.01287292f, -0.00086096f, 
    -0.06581242f, -0.00523478f, -0.07458480f, 0.01665839f, -0.01777994f, 0.11524905f, -0.06197276f, -0.11035630f, 
    -0.35408261f, -0.19494663f, -0.01796313f, -0.05469882f, 0.12508248f, 0.26685256f, 0.08293600f, -0.04062041f, 
    -0.02583553f, -0.06417746f, 0.03308882f, 0.06640781f, 0.03942128f, 0.11411189f, -0.08471689f, 0.00378223f, 
    0.16311948f, 0.07066904f, 0.22038415f, -0.00724733f, -0.07852154f, -0.06986357f, 0.01305476f, 0.02588943f, 
    0.07490689f, 0.03153634f, 0.14905001f, -0.01318182f, -0.07234296f, 0.07958273f, 0.21204147f, -0.08973540f, 
    -0.04954377f, 0.24310854f, 0.11219295f, 0.18886954f, -0.14440228f, -0.17500478f, -0.06822481f, -0.00388100f, 
    0.09301063f, -0.03645600f, -0.11327082f, -0.14481784f, 0.11444993f, 0.09298599f, 0.07930834f, 0.03226081f, 
    -0.03939621f, -0.08379940f, -0.19449280f, -0.11587772f, 0.01894354f, -0.08199315f, 0.01630740f, -0.02576888f, 
    0.01983950f, -0.04854578f, 0.06169417f, 0.09890062f, -0.01282604f, -0.11751440f, -0.02551951f, -0.04945089f, 
    -0.04399105f, 0.06148328f, -0.01099502f, 0.27022651f, -0.00158302f, -0.02380608f, -0.09725896f, -0.26185045f, 
    0.22321895f, -0.18327998f, -0.17338243f, -0.06547239f, 0.15270334f, -0.00089177f, -0.11177634f, 0.18090335f, 
    0.01060622f, 0.02147235f, -0.00215621f, -0.09975398f, 0.08360848f, 0.16658631f, -0.16199082f, 0.00262798f, 
    0.26538524f, -0.01587774f, -0.13490783f, 0.20480387f, 0.08942445f, -0.10608566f, -0.12514605f, -0.07613330f, 
    -0.42125517f, 0.16054592f, 0.24357022f, -0.16037589f, 0.17161018f, -0.12635100f, -0.02415998f, -0.03245995f, 
    0.01276731f, -0.11138824f, 0.26770815f, 0.13098733f, -0.19909163f, -0.09042042f, -0.00118416f, -0.03372095f, 
    -0.11197781f, -0.01061856f, -0.07340568f, -0.15813997f, 0.12724319f, 0.01230197f, -0.08658469f, 0.06536991f, 
    0.10794200f, -0.15244403f, -0.00724615f, 0.06630389f, 0.11537956f, 0.05312845f, -0.06270451f, 0.19014618f, 
    0.05793314f, -0.01404857f, -0.07156428f, -0.16359481f, -0.09053757f, 0.47937214f, -0.17542262f, -0.34577575f, 
    -0.00090906f, 0.16891694f, -0.27412042f, -0.11235170f, -0.02284580f, -0.08430437f, 0.07771721f, 0.04985715f, 
    0.10409965f, 0.26350844f, -0.21631390f, -0.18043046f, -0.00642835f, 0.13442867f, 0.23985894f, 0.25927669f, 
    -0.27084085f, 0.04995853f, -0.07706763f, -0.13591345f, -0.22446473f, -0.04089256f, -0.10080642f, 0.06186609f, 
    0.07697365f, -0.06239830f, -0.01460385f, -0.12288900f, -0.08915222f, -0.09118640f, 0.04423258f, 0.00517147f, 
    0.18371327f, 0.00239012f, -0.08999206f, 0.05751400f, 0.12473872f, -0.02444855f, 0.08492748f, 0.23354721f, 
    0.12021843f, 0.07114331f, 0.10017407f, 0.15970582f, -0.01479870f, -0.08787090f, 0.28498372f, 0.27357736f, 
    -0.07956266f, -0.12062705f, -0.06160704f, -0.11964633f, -0.04439384f, 0.29696938f, 0.26493794f, 0.26719034f, 
    -0.00627511f, 0.29413828f, 0.01217622f, 0.28491074f, -0.13462581f, 0.01388029f, -0.02047817f, -0.10744613f, 
    -0.05820232f, 0.10659281f, 0.14486668f, 0.11147954f, -0.15185821f, -0.04995669f, -0.22093423f, 0.14639822f, 
    0.03749091f, 0.03740718f, 0.07278863f, -0.11858782f, -0.00605299f, 0.06598639f, -0.01598796f, 0.15864712f, 
    -0.13841537f, -0.06482819f, 0.06110261f, 0.09576823f, 0.02931689f, 0.08418251f, -0.12955101f, 0.20216656f, 
    -0.02487525f, 0.02175484f, 0.14081524f, 0.00208078f, 0.15205273f, -0.16522551f, -0.14689268f, 0.06246984f, 
    0.11532148f, 0.06996857f, -0.10586275f, 0.18619464f, -0.04170210f, 0.09483352f, -0.10027864f, 0.09336436f, 
    0.05103537f, 0.33087781f, 0.00463395f, 0.12663135f, -0.02342647f, 0.02011557f, 0.03247042f, -0.10756545f, 
    -0.01908241f, 0.24733754f, 0.11735299f, 0.17628746f, 0.16629207f, -0.05772540f, 0.08505812f, -0.03888366f, 
    0.11694526f, 0.02788657f, -0.00811503f, -0.00080131f, -0.03755335f, 0.03439417f, -0.04677628f, -0.09213389f, 
    -0.12770036f, -0.10283656f, -0.18502985f, -0.00715898f, 0.00791471f, 0.15260866f, 0.18287735f, -0.18634844f, 
    -0.17773286f, -0.11264791f, -0.12505601f, -0.16602404f, -0.11222854f, -0.33608577f, 0.06059442f, 0.05585231f, 
    -0.10396474f, 0.06888196f, 0.02304958f, 0.09138488f, -0.10621850f, 0.01931971f, 0.00428840f, -0.07851305f, 
    0.05593025f, 0.01309280f, -0.13188142f, -0.17494583f, -0.03099478f, 0.01066326f, 0.03176577f, -0.19093996f, 
    0.12692644f, -0.11607606f, 0.03570952f, 0.10424999f, -0.01655001f, 0.08132803f, -0.07158992f, -0.04387850f, 
    -0.04739949f, 0.04789574f, -0.00788781f, -0.03554518f, 0.07218520f, 0.06388514f, 0.12339438f, 0.24673136f, 
    0.15172324f, 0.19393958f, -0.03863493f, 0.00447964f, 0.03975008f, 0.01462813f, -0.02087408f, 0.18309200f, 
    -0.01041142f, 0.05460790f, 0.04786883f, -0.14625080f, 0.12661204f, -0.00744695f, 0.04748473f, 0.07287882f, 
    0.07835446f, 0.32659733f, 0.05053510f, 0.09866183f, 0.11279541f, 0.01425961f, -0.13580097f, 0.00986030f, 
    0.04492216f, -0.04701641f, 0.04086864f, 0.05469593f, -0.02318493f, 0.07568438f, -0.00856440f, -0.01871130f, 
    -0.06661870f, -0.02375157f, -0.19882646f, -0.20528319f, 0.20193510f, 0.05434353f, -0.17984679f, 0.13519403f, 
    0.22349358f, 0.08850205f, -0.01424330f, 0.33710515f, -0.04971281f, -0.04955355f, -0.05472106f, 0.15552740f, 
    0.24175277f, 0.15074211f, 0.01121437f, 0.00424330f, 0.03816430f, -0.01497662f, 0.06945600f, 0.22408430f, 
    0.10794953f, 0.11435519f, 0.04512333f, 0.17874438f, -0.10845168f, 0.01486709f, -0.51960641f, 0.10491624f, 
    -0.13242894f, -0.09415752f, 0.06696101f, -0.12650655f, -0.09116273f, 0.03507823f, -0.03655954f, 0.08249579f, 
    -0.09458832f, -0.08179958f, -0.04594697f, -0.13801578f, -0.00932615f, 0.21326357f, 0.22446829f, 0.14089009f, 
    0.08223077f, -0.00234628f, 0.13506752f, 0.10581629f, -0.34736198f, 0.05151244f, 0.00791077f, -0.16642573f, 
    -0.10352711f, -0.07263408f, 0.03981060f, -0.11785332f, -0.04766111f, 0.14063932f, -0.05081978f, 0.14163269f, 
    -0.06228815f, 0.10306332f, -0.07786609f, -0.19762874f, 0.08219712f, 0.01166662f, 0.03368574f, -0.10714538f, 
    0.04242303f, 0.02410767f, 0.12318545f, 0.29230130f, 0.08021155f, 0.24238957f, -0.11077481f, 0.03939625f, 
    0.02014584f, -0.23336859f, 0.05192672f, 0.06225598f, -0.03563609f, 0.03442892f, -0.05502542f, 0.02333900f, 
    0.39038664f, 0.02515065f, 0.70854717f, 0.34588876f, 0.16190405f, 0.05266467f, 0.03258518f, 0.10253815f, 
    -0.19848691f, 0.09484068f, 0.13171634f, 0.00598471f, -0.19050652f, 0.13799296f, -0.15540458f, 0.00861782f, 
    0.13369828f, 0.15586463f, 0.03437041f, 0.12671253f, -0.12998955f, -0.01828613f, -0.09932666f, 0.02480373f, 
    -0.05044218f, -0.07905977f, -0.12375013f, -0.06001516f, -0.21163818f, -0.14029175f, 0.03477288f, 0.02581580f, 
    0.12530594f, -0.00287301f, 0.05733708f, 0.07964553f, 0.10623049f, -0.01371112f, -0.01384659f, 0.12685622f, 
    -0.00483730f, 0.07577117f, -0.00031908f, -0.04327640f, 0.06373219f, -0.06741442f, -0.02896036f, -0.01401947f, 
    0.73845345f, 0.28129375f, 0.29724368f, 0.42958888f, 0.09090098f, 0.09275665f, 0.03088084f, 0.01929114f, 
    -0.03982548f, -0.07971091f, 0.03956746f, 0.06865416f, 0.21011436f, -0.08755721f, 0.42990136f, -0.15802754f, 
    0.23882517f, -0.08030327f, 0.05380614f, 0.04576414f, -0.09294794f, 0.04545375f, 0.05026558f, 0.14931978f, 
    -0.11530259f, 0.10729413f, 0.05132707f, -0.07787108f, -0.09575719f, -0.08291146f, 0.09831852f, 0.02053787f, 
    -0.05749962f, 0.04539480f, -0.06589582f, 0.04131902f, -0.33848619f, 0.04057722f, -0.44964319f, 0.13248755f, 
    0.24464402f, 0.09686281f, -0.10231912f, 0.06789433f, 0.03427223f, -0.01799764f, 0.05535158f, -0.07900799f, 
    0.02396988f, -0.12382219f, -0.12424353f, 0.14662282f, 0.19484246f, 0.08806573f, 0.08667337f, 0.04133771f, 
    -0.01445543f, -0.01428351f, -0.07524329f, 0.06559892f, -0.31894353f, -0.42679396f, 0.06496351f, -0.19563051f, 
    -0.06396735f, 0.00456728f, -0.03096654f, -0.10910682f, 0.10573251f, -0.04106694f, 0.01785386f, -0.09319417f, 
    -0.25415602f, -0.21383992f, -0.02550516f, 0.06943561f, -0.11741866f, -0.03742132f, -0.10464758f, 0.00993744f, 
    -0.04844081f, -0.00504725f, -0.03117460f, 0.03310388f, -0.11624493f, 0.05614043f, 0.03363610f, 0.08808450f, 
    0.02326581f, 0.08832387f, 0.01430504f, 0.04373529f, 0.07381015f, 0.07543561f, 0.06189397f, 0.15812829f, 
    -0.29223019f, 0.30727348f, -0.19093220f, 0.21857150f, 0.11033992f, 0.09773915f, -0.06238771f, -0.07509913f, 
    0.07263828f, -0.06795584f, 0.04301985f, -0.00193080f, -0.10468308f, 0.12534848f, -0.24972744f, 0.12990746f, 
    0.04767117f, 0.04211567f, 0.00652286f, 0.02397417f, -0.10478281f, 0.12030330f, -0.15778854f, 0.09075179f, 
    0.10085478f, 0.14440171f, 0.17764448f, 0.03763925f, 0.07005347f, -0.07565913f, 0.00971738f, 0.17039964f, 
    0.08292082f, 0.09632330f, -0.01747268f, 0.07781018f, -0.04336732f, -0.08112157f, -0.11529724f, 0.10142709f, 
    0.08804430f, 0.11973839f, -0.00635818f, 0.02787005f, -0.04509145f, -0.04157642f, -0.05489497f, -0.07271907f, 
    -0.39366677f, 0.47690728f, -0.03467151f, -0.10585278f, -0.04024154f, 0.15584658f, -0.04895007f, 0.08978806f, 
    -0.07750384f, 0.02325935f, 0.08696610f, -0.05255229f, -0.32103121f, -0.14044726f, -0.11519700f, 0.02060383f, 
    0.08369810f, 0.02582012f, 0.04344778f, -0.08767389f, 0.05018791f, -0.03046361f, 0.02532185f, 0.00806772f, 
    -0.02501700f, 0.47918838f, 0.06717011f, 0.18028198f, 0.02476332f, -0.07696995f, -0.15277602f, 0.01949977f, 
    0.17557509f, -0.01291308f, 0.07416073f, -0.05192847f, -0.00592753f, 0.21242611f, -0.01158402f, 0.25014263f, 
    0.01199369f, 0.08045823f, 0.01160679f, 0.10552375f, 0.07882347f, -0.11357848f, -0.03212855f, -0.07653615f, 
    -0.39694592f, -0.20019734f, -0.07178358f, -0.06801930f, -0.22342816f, -0.02393673f, -0.00885474f, -0.17643270f, 
    -0.07068655f, -0.02919243f, -0.06931097f, -0.02371600f, -0.25109756f, 0.21130583f, 0.01386925f, 0.06659362f, 
    -0.08605689f, -0.00617888f, -0.07772395f, -0.04224839f, 0.02328258f, 0.11513139f, -0.02326980f, 0.12375422f, 
    -0.07898302f, 0.17556271f, 0.14615884f, 0.17779286f, -0.05534799f, 0.05420423f, -0.00365336f, -0.09668744f, 
    0.02898878f, 0.03229020f, 0.02202631f, -0.17256112f, -0.11838993f, 0.24131240f, 0.32226107f, -0.27138442f, 
    -0.00553898f, 0.01356280f, 0.06492479f, 0.14712483f, -0.01485078f, 0.09398798f, -0.03989398f, 0.05191873f, 
    0.13274990f, 0.04582811f, 0.07906582f, -0.03613738f, -0.07509665f, 0.09039558f, 0.13018727f, -0.07464005f, 
    0.17197837f, 0.11962851f, 0.04194047f, 0.00920888f, -0.20892444f, 0.05721987f, -0.11499218f, -0.07631445f, 
    -0.26909742f, -0.06213951f, -0.02365305f, -0.16750400f, -0.06793791f, 0.23448955f, 0.08810349f, 0.02359388f, 
    -0.00682871f, 0.43852690f, -0.30238765f, 0.16726764f, -0.08524919f, -0.16080472f, -0.11787643f, 0.02754384f, 
    0.09473159f, 0.08582744f, -0.03338046f, 0.03133057f, 0.18738365f, 0.05202095f, 0.04445537f, -0.06329539f, 
    -0.00343652f, -0.07859910f, -0.13185340f, 0.05019519f, 0.06713407f, 0.01272743f, 0.00928934f, 0.11250859f, 
    -0.30203977f, -0.18316217f, -0.14863431f, 0.11623424f, -0.23692578f, -0.19482097f, -0.06229775f, -0.04373180f, 
    -0.10772003f, 0.06200353f, 0.08361510f, -0.03788078f, -0.34320286f, 0.02658877f, -0.29920250f, 0.06400686f, 
    0.09414942f, 0.10505880f, 0.01492628f, -0.00369234f, -0.03552793f, 0.08936208f, 0.01552194f, -0.04241312f, 
    -0.02871863f, 0.15350483f, -0.02279598f, -0.15065740f, 0.06973388f, 0.01218591f, 0.01968477f, 0.04827030f, 
    0.07736979f, 0.08372069f, 0.07544234f, 0.15855029f, -0.10480791f, 0.01250135f, -0.02983892f, 0.00009935f, 
    -0.03726230f, -0.04881357f, 0.07138639f, -0.08958817f, -0.04295601f, -0.05376890f, 0.04338126f, -0.03430696f, 
    -0.24180946f, -0.03493056f, 0.10732967f, -0.05777463f, -0.27391970f, -0.04950039f, 0.06276998f, -0.09974303f, 
    -0.01889524f, 0.04569826f, -0.05777657f, 0.03109095f, 0.20313981f, -0.08198921f, 0.18322200f, -0.07213931f, 
    0.13309519f, 0.00662631f, -0.08689456f, -0.03531142f, 0.00491266f, 0.12500612f, -0.07012262f, 0.08430011f, 
    0.14934109f, 0.27111700f, 0.13291633f, 0.29824215f, 0.13767093f, 0.10387748f, -0.04283821f, -0.04525308f, 
    0.09228336f, 0.11916972f, -0.03305743f, 0.04819808f, -0.16641846f, 0.02737164f, 0.00460678f, 0.00855750f, 
    0.12570600f, 0.11223530f, 0.07646328f, 0.13100250f, -0.07090698f, 0.19729339f, -0.02731597f, -0.06659404f, 
    0.09788264f, 0.38408616f, 0.07776594f, -0.13892569f, -0.26454598f, 0.04369277f, 0.01670753f, -0.20417142f, 
    0.05485252f, 0.15747981f, 0.03544354f, -0.06056475f, -0.30957091f, -0.32647926f, -0.04577754f, -0.22060215f, 
    -0.17225441f, -0.14515871f, 0.02123566f, 0.00987328f, 0.03816055f, -0.03736586f, -0.02104821f, 0.02436748f, 
    0.01635010f, 0.08745138f, 0.21972390f, 0.17453718f, 0.02383107f, 0.03719888f, -0.07691334f, -0.07885592f, 
    0.00688653f, 0.07229833f, -0.10853000f, 0.09501161f, 0.11548129f, 0.32259899f, -0.08264756f, 0.07381787f, 
    0.13678317f, 0.12815258f, -0.10775705f, 0.05907604f, 0.13731399f, -0.05133613f, 0.07044452f, -0.01520996f, 
    0.23568887f, -0.25594831f, 0.00040144f, 0.03069773f, 0.11869754f, -0.00370222f, -0.10907231f, -0.00815349f, 
    -0.00780148f, 0.06494256f, 0.09781112f, 0.05296097f, -0.22634260f, 0.03966392f, -0.04881938f, -0.07266366f, 
    -0.26826927f, -0.04263328f, -0.13753605f, 0.02001819f, -0.12194407f, 0.03326181f, 0.04769501f, 0.01524121f, 
    0.13262239f, 0.16205299f, 0.09661189f, 0.21824752f, -0.09550838f, 0.21782380f, 0.03848973f, -0.03877638f, 
    0.01685070f, 0.01988306f, 0.10009479f, 0.06698264f, 0.16724968f, 0.35749918f, 0.09727989f, 0.11948668f, 
    -0.01635014f, -0.03929467f, -0.02543827f, -0.02465473f, 0.12259927f, 0.03965233f, -0.06179038f, 0.15116340f, 
    0.07963472f, 0.30762085f, 0.04332949f, 0.14917140f, 0.13474110f, 0.06292092f, -0.02444865f, -0.00402918f, 
    0.03520888f, 0.05364977f, -0.02714673f, 0.06779294f, -0.23963366f, 0.05877053f, -0.25823575f, 0.07128385f, 
    -0.12694107f, -0.02685254f, 0.00252129f, -0.04418143f, -0.08714072f, -0.00971664f, 0.02745632f, 0.07420126f, 
    0.25683016f, 0.06527319f, -0.03103930f, 0.23538607f, 0.11073630f, -0.02382972f, -0.00283459f, -0.03195958f, 
    0.05746415f, 0.18032010f, -0.00238698f, 0.07553739f, -0.14481531f, 0.19094145f, 0.13349928f, 0.36811095f, 
    -0.06107745f, 0.03739915f, -0.02997039f, -0.02752363f, 0.01731505f, -0.07044969f, 0.02430719f, 0.11748429f, 
    0.07887767f, 0.10911909f, 0.12603153f, -0.09805004f, 0.20762117f, -0.08389978f, 0.00081132f, 0.02764197f, 
    -0.06549255f, 0.03927203f, 0.10822099f, 0.00173388f, 0.20323049f, 0.16251962f, 0.02991826f, 0.13063799f, 
    0.17798956f, 0.07061028f, 0.03970679f, -0.03030368f, -0.04859496f, 0.15805492f, -0.03463904f, -0.01727329f, 
    -0.25022954f, -0.05299152f, -0.11022484f, -0.07431325f, -0.26049042f, -0.04066843f, -0.11644647f, 0.01056720f, 
    0.12556496f, -0.06095974f, 0.01147410f, -0.01080704f, -0.01684652f, -0.27729419f, 0.05430088f, -0.14357767f, 
    -0.05921023f, -0.00239622f, 0.02735501f, -0.03254788f, 0.05928206f, 0.00059109f, -0.07090058f, 0.00678076f, 
    -0.43596035f, -0.01077974f, 0.04969772f, -0.05903332f, -0.11159094f, -0.08378725f, -0.13858241f, -0.03188452f, 
    0.08181665f, 0.02937841f, -0.00667005f, 0.03472217f, -0.29434288f, -0.21839531f, -0.02441388f, -0.03492970f, 
    -0.14614220f, -0.09448832f, 0.02563292f, -0.00597994f, 0.02950462f, 0.06392171f, 0.07117140f, 0.07711891f, 
    -0.28161654f, 0.26666489f, -0.16120474f, 0.14187534f, 0.07401120f, 0.22552773f, -0.13889958f, -0.13292521f, 
    0.03212376f, 0.02329938f, -0.01714045f, -0.08398882f, 0.17945105f, -0.43050963f, 0.07260485f, 0.02010557f, 
    0.14604767f, 0.04909935f, 0.07215158f, 0.17550775f, -0.05956072f, -0.04263843f, 0.03818517f, 0.16949587f, 
    0.21837357f, -0.02257946f, 0.00535371f, -0.12591514f, -0.12811279f, -0.12688714f, -0.00200944f, -0.00059320f, 
    -0.03323292f, 0.06064847f, 0.00183479f, 0.05511415f, 0.01340285f, -0.17210646f, -0.05297955f, 0.12325849f, 
    0.03288522f, -0.00080270f, 0.01265296f, 0.07486527f, 0.04117599f, -0.04077363f, 0.04288696f, 0.03700184f, 
    0.03071001f, 0.41026178f, -0.19746770f, 0.07600979f, -0.03531310f, 0.08263449f, 0.09582318f, -0.10910790f, 
    0.10625245f, 0.01372903f, 0.04258696f, 0.05039310f, -0.32082942f, -0.09204657f, -0.03323736f, -0.18462652f, 
    -0.13390574f, -0.13675456f, 0.02680446f, 0.04890506f, 0.00026602f, 0.05440807f, -0.13885102f, 0.06696492f, 
    0.22031058f, -0.14395449f, 0.24711660f, -0.03160485f, 0.07089449f, -0.04115859f, -0.06212070f, 0.17161275f, 
    -0.09881844f, -0.04988134f, -0.08053099f, 0.11908772f, 0.15864049f, -0.19769102f, 0.12756848f, 0.15736723f, 
    0.03840844f, -0.19212978f, -0.07097650f, 0.06326593f, -0.18648344f, -0.09467384f, -0.01522605f, 0.00265251f, 
    -0.17045112f, 0.04260518f, 0.04776408f, 0.07888176f, -0.02734775f, 0.16162814f, 0.02299964f, -0.04349723f, 
    0.01124092f, -0.04350346f, 0.15620716f, 0.00213209f, 0.03629373f, 0.02164627f, -0.09823120f, -0.04149924f, 
    -0.14003231f, 0.17535309f, -0.04662139f, 0.12468654f, 0.01969101f, -0.01899170f, 0.11853153f, 0.06987713f, 
    -0.03673432f, -0.04175613f, -0.04106007f, 0.00370943f, -0.03951627f, -0.01625993f, -0.02199588f, 0.02540467f, 
    -0.03310601f, -0.01773928f, -0.00987143f, 0.01948385f, -0.01805823f, -0.01732437f, -0.00183472f, 0.02652439f, 
    -0.04168548f, -0.01943036f, -0.01445448f, -0.00195390f, 0.01017961f, -0.00591974f, 0.02276028f, 0.01403409f, 
    0.00705871f, 0.02602671f, 0.02929817f, -0.01691110f, -0.01148606f, -0.00600546f, -0.04082887f, -0.00195095f, 
    -0.02534685f, -0.02948934f, -0.03944412f, -0.02734303f, -0.04098925f, 0.01669727f, 0.01838344f, -0.02040132f, 
    -0.02017797f, 0.02458924f, 0.02601111f, 0.00488781f, -0.03103381f, 0.01733632f, -0.02477764f, -0.00733309f, 
    -0.03203840f, 0.00369627f, -0.01164087f, -0.02975275f, -0.00367196f, 0.02388162f, -0.02445875f, 0.02784432f, 
    0.01887285f, 0.02287011f, 0.02444931f, -0.01966704f, -0.01412057f, -0.01419457f, 0.01748376f, -0.02877993f, 
    -0.01772895f, -0.03283969f, -0.01883802f, -0.01597499f, -0.00186587f, 0.01415426f, 0.01919239f, -0.00558390f, 
    -0.01593784f, -0.00659472f, -0.01438670f, -0.01210209f, 0.00134899f, -0.00048191f, 0.02180289f, -0.02742981f, 
    0.01543045f, -0.02353127f, -0.02379193f, 0.00682118f, 0.00106248f, -0.00270390f, -0.02007739f, -0.00597052f, 
    0.00502737f, 0.00783085f, 0.01590917f, -0.00556903f, 0.01146233f, 0.01999344f, 0.02544832f, -0.00364851f, 
    0.02985225f, -0.02112364f, -0.03472808f, -0.02157203f, -0.02133522f, -0.02759979f, -0.01639009f, 0.02162367f, 
    0.02741125f, 0.01176478f, -0.00209558f, 0.02056176f, -0.00477447f, 0.01820972f, -0.00436247f, -0.00203485f, 
    -0.02021102f, -0.02145731f, -0.00590591f, 0.00063994f, -0.01879389f, -0.04104609f, -0.02541926f, 0.01726361f, 
    0.02816501f, 0.00817747f, -0.03575317f, 0.02627409f, -0.03429846f, 0.01528044f, 0.00102332f, -0.01497751f, 
    0.00446627f, -0.00244676f, 0.02540240f, 0.01480311f, 0.02448852f, 0.01529296f, -0.02050988f, -0.01250830f, 
    -0.03481255f, 0.02132556f, 0.01609476f, -0.03577237f, 0.01044612f, -0.01077950f, -0.03150807f, -0.01102181f, 
    -0.03864061f, 0.02811858f, 0.02473841f, 0.02600484f, 0.02105666f, 0.02323947f, -0.00747892f, 0.02785111f, 
    0.01245286f, 0.01814417f, -0.03246444f, -0.00083701f, 0.02486841f, 0.00133402f, 0.00606640f, -0.00131056f, 
    0.00706978f, 0.02599876f, 0.01565349f, -0.00192030f, -0.02259720f, 0.01487755f, -0.01700688f, -0.03376389f, 
    -0.03051078f, 0.02675549f, -0.01468523f, 0.00068234f, 0.00188110f, -0.03299803f, -0.01230162f, -0.00989227f, 
    0.00522714f, -0.03240768f, 0.00209675f, 0.00455439f, 0.02605117f, -0.00875334f, -0.01449826f, 0.02015174f, 
    -0.01262874f, -0.00087519f, 0.01777775f, -0.03643986f, -0.00032846f, -0.04072490f, 0.01757309f, -0.03196731f, 
    0.01138488f, 0.02029719f, 0.01786236f, -0.03162583f, 0.02879366f, 0.00480217f, -0.01476116f, 0.01860023f, 
    -0.03691428f, 0.01874973f, -0.00010795f, 0.02841169f, -0.03711369f, 0.01011016f, -0.01290912f, -0.01259801f, 
    0.01378879f, 0.00029209f, -0.02808788f, -0.00530427f, -0.03394534f, -0.01316844f, -0.00344446f, -0.00522089f, 
    -0.03681656f, 0.01579937f, 0.01913102f, -0.01725207f, -0.02308307f, 0.01638988f, -0.02959433f, -0.02483544f, 
    -0.01274147f, 0.00711256f, 0.00568869f, 0.00059683f, -0.02541738f, -0.02662634f, 0.02146739f, -0.01778332f, 
    -0.00594231f, -0.00576042f, 0.01852684f, 0.00929564f, 0.00426773f, -0.03109886f, -0.01400926f, -0.02786754f, 
    -0.01138241f, -0.03824682f, -0.00680695f, -0.04182769f, 0.02246718f, 0.01527255f, -0.04177672f, -0.04008578f, 
    -0.03554262f, 0.01549698f, -0.02280069f, 0.00500557f, -0.01263028f, 0.01903433f, -0.03772734f, 0.01471743f, 
    -0.03088867f, -0.02727159f, 0.02081526f, 0.01876316f, 0.00252004f, 0.00793922f, -0.01318271f, -0.02701568f, 
    -0.00120370f, -0.01285424f, 0.00812847f, -0.00582083f, -0.03781484f, -0.03815044f, 0.00376359f, -0.04059309f, 
    -0.00651426f, 0.02388101f, -0.01609357f, 0.01559748f, 0.00645858f, -0.00671167f, -0.03530059f, 0.01408639f, 
    0.02826043f, -0.01717383f, -0.00392704f, -0.00683500f, -0.03627313f, -0.01278190f, -0.00393699f, -0.03508176f, 
    -0.03795093f, -0.02985769f, -0.02878356f, -0.00663461f, -0.03821969f, -0.00258460f, -0.04086563f, 0.01482229f, 
    -0.02837491f, 0.00803187f, -0.02353602f, -0.03728378f, -0.01596125f, -0.03080269f, 0.00789191f, 0.02340045f, 
    -0.04020957f, -0.03527284f, -0.03382365f, -0.00181271f, -0.03544845f, -0.03033409f, -0.01852704f, 0.00153362f, 
    -0.00389179f, -0.03258954f, -0.01392276f, 0.00529196f, -0.04141025f, 0.00928677f, -0.02714688f, -0.01233754f, 
    -0.02158418f, 0.01636476f, -0.00206280f, 0.01452375f, -0.03143336f, 0.00363300f, 0.00406398f, -0.03961271f, 
    0.02901673f, 0.00869445f, -0.04120610f, -0.03223727f, -0.03745686f, -0.01954492f, -0.03837531f, 0.01456672f, 
    -0.03361226f, 0.02181768f, 0.00732286f, -0.03348085f, 0.02603949f, -0.03284313f, 0.00178662f, -0.00720929f, 
    0.02262806f, -0.00944184f, 0.00026567f, -0.00549600f, 0.00265895f, -0.02825616f, -0.03024373f, 0.02077867f, 
    0.01364388f, -0.01291522f, 0.00061444f, 0.00123565f, 0.00773001f, -0.01145191f, -0.01948709f, -0.02982307f, 
    -0.01700785f, 0.01845154f, 0.02742543f, -0.01345021f, -0.02771729f, -0.03514226f, -0.02245931f, -0.03700593f, 
    -0.01406037f, 0.02894043f, 0.00081629f, 0.01935279f, -0.03729286f, -0.02160263f, -0.01654210f, -0.01088491f, 
    -0.03185225f, 0.00369765f, 0.02518482f, -0.01387800f, 0.02087902f, -0.02858104f, -0.01477163f, -0.03218592f, 
    -0.01915684f, -0.02206110f, -0.00398337f, -0.03078120f, -0.00557263f, -0.01020323f, 0.00340029f, 0.01073992f, 
    0.01899206f, 0.01705983f, -0.00665025f, -0.02938103f, -0.02960497f, 0.01512801f, 0.01524383f, -0.02408291f, 
    0.02728751f, 0.02340980f, 0.00791643f, 0.02598093f, -0.00483624f, 0.01512143f, -0.01427340f, 0.02463347f, 
    -0.00492178f, -0.00246465f, -0.00218117f, 0.01490252f, -0.00512639f, -0.03117694f, -0.00167894f, -0.00086075f, 
    -0.00985719f, 0.02547524f, -0.00179737f, -0.02431452f, -0.03859529f, -0.01104249f, -0.04053979f, -0.00481030f, 
    -0.01133736f, -0.00918485f, -0.00602919f, -0.02788776f, 0.02127752f, -0.00720576f, -0.01646146f, 0.02772770f, 
    0.02361434f, -0.02366893f, -0.03270335f, -0.02424866f, -0.03010256f, -0.03581847f, 0.00538931f, 0.01305612f, 
    -0.00502543f, -0.01984479f, -0.04087042f, -0.01937001f, -0.01345770f, -0.01211440f, 0.02178976f, 0.01256370f, 
    -0.01172782f, 0.02646353f, -0.00717344f, 0.01762092f, -0.03331959f, 0.03411678f, -0.02384514f, 0.02751770f, 
    0.02109393f, -0.02478132f, 0.01691737f, -0.02491579f, -0.01310071f, -0.03469982f, -0.03548640f, -0.03453229f, 
    0.00752785f, 0.00576179f, 0.01871834f, 0.00988101f, -0.03672707f, -0.03414140f, -0.04146939f, -0.03287575f, 
    0.01113994f, 0.04044696f, -0.03123391f, -0.00735934f, -0.01801952f, -0.01690141f, 0.00965637f, -0.00985209f, 
    -0.03187848f, -0.00859273f, -0.03152055f, 0.02940133f, 0.02896189f, -0.00460038f, -0.03597577f, 0.02662430f, 
    -0.03881522f, -0.00103419f, -0.02473570f, -0.02508550f, 0.02214915f, 0.00035516f, -0.02484347f, -0.03723328f, 
    -0.03361091f, -0.01712715f, -0.03353058f, -0.00794351f, -0.02464115f, 0.00016365f, 0.00548389f, -0.02229041f, 
    -0.01324771f, -0.00736021f, -0.00358653f, -0.01648888f, -0.01517398f, 0.01025743f, 0.01096644f, -0.03821899f, 
    -0.03252656f, 0.02196478f, 0.02953886f, -0.00916780f, -0.01430237f, 0.01890540f, -0.00350740f, -0.02791055f, 
    0.01105891f, 0.00113121f, 0.01993706f, 0.02033384f, 0.00684271f, 0.01483676f, 0.00046978f, -0.01194795f, 
    -0.03951363f, -0.02031381f, 0.01577763f, 0.00142587f, 0.01676377f, 0.00539075f, -0.02797933f, 0.00225890f, 
    -0.00905492f, 0.01619470f, -0.01791996f, -0.03143911f, -0.03425786f, 0.01788864f, -0.00513323f, -0.02281375f, 
    0.01568679f, 0.00066525f, -0.00279190f, 0.00753456f, -0.00909443f, -0.00399237f, 0.01427010f, -0.02948898f, 
    -0.00280092f, -0.02753315f, -0.04094424f, 0.01510409f, 0.00195995f, -0.02007028f, -0.02534426f, 0.02236479f, 
    -0.01441924f, -0.00862350f, -0.01015870f, 0.02194548f, 0.01274777f, -0.02953946f, -0.00694289f, -0.02530213f, 
    0.02117562f, -0.01467288f, -0.04120260f, 0.02592743f, -0.01302739f, -0.03843484f, -0.03065721f, -0.01343709f, 
    0.00998954f, 0.01543144f, -0.01362763f, -0.00405061f, -0.02600270f, -0.02315189f, -0.03788209f, -0.02537541f, 
    0.00291224f, -0.00278243f, 0.02836234f, 0.01176562f, 0.01292456f, -0.03976607f, -0.00236302f, -0.01978834f, 
    0.00528343f, 0.00958815f, 0.02598969f, -0.00343738f, -0.03453486f, -0.03370422f, -0.01414979f, 0.01916725f, 
    0.00183435f, 0.01068225f, -0.03258938f, 0.02953666f, -0.03773699f, 0.01465749f, -0.04177127f, -0.02550726f, 
    -0.01061963f, -0.03002444f, -0.03626821f, -0.03385992f, 0.00359871f, -0.01298397f, -0.01494467f, -0.02897660f, 
    0.01165836f, 0.02039986f, -0.01593285f, 0.01085947f, -0.00072658f, -0.01296694f, 0.01051395f, -0.01812463f, 
    -0.01433116f, -0.01558350f, -0.04072458f, 0.01478631f, -0.03738392f, 0.02357550f, 0.00809461f, 0.01110634f, 
    0.02905848f, -0.01788446f, -0.02913575f, -0.00908044f, 0.00624956f, -0.04146330f, -0.00140467f, -0.01920190f, 
    -0.01640370f, -0.00822509f, -0.00735540f, -0.03387070f, -0.03145654f, 0.01412453f, 0.00038477f, -0.03922604f, 
    -0.01062372f, -0.03363308f, -0.00468585f, -0.01291854f, -0.01570708f, 0.02663158f, 0.00101082f, 0.02111820f, 
    0.01626934f, 0.02788143f, -0.00268339f, 0.01429502f, 0.01376663f, -0.04067554f, -0.03030912f, 0.01686997f, 
    0.01889347f, -0.01922146f, -0.02936131f, -0.03445628f, 0.01151370f, -0.02680649f, 0.01648017f, -0.03384466f, 
    -0.00679575f, 0.02931193f, 0.00803741f, 0.01380462f, 0.01115094f, -0.01116929f, -0.00352709f, -0.02943327f, 
    -0.02960932f, -0.02305187f, -0.03229700f, -0.00548090f, -0.00160116f, -0.01957861f, 0.00428444f, -0.03748181f, 
    -0.03630304f, -0.02812574f, -0.01116220f, -0.01684424f, -0.02028249f, -0.00482993f, 0.00686440f, 0.01773547f, 
    0.00563955f, -0.01901426f, -0.01866425f, -0.03662590f, -0.02387157f, -0.00152059f, 0.00094554f, 0.00394441f, 
    -0.02580131f, -0.01117629f, -0.01928014f, 0.01017370f, -0.01671984f, -0.03359217f, -0.00006600f, -0.01133724f, 
    -0.04074223f, 0.01221035f, -0.00482689f, 0.01925815f, 0.01785014f, -0.00017775f, 0.01001584f, -0.03992282f, 
    0.02270029f, 0.00360714f, 0.01777751f, -0.00376238f, -0.04006460f, 0.02480760f, 0.00083864f, -0.00904253f, 
    -0.01808901f, 0.01950720f, 0.00351411f, -0.02310015f, -0.01661016f, -0.02183709f, -0.01352391f, 0.02442610f, 
    0.01238996f, -0.00810596f, -0.01076943f, -0.01990415f, 0.00739075f, -0.02461210f, 0.00825750f, -0.03064227f, 
    0.02282821f, -0.00825504f, -0.02572128f, 0.00197296f, -0.02089546f, 0.01068615f, -0.01810991f, 0.02366241f, 
    0.02937633f, -0.03003537f, -0.00793657f, -0.03727754f, 0.02441842f, -0.02604753f, -0.00390632f, 0.02684178f, 
    -0.03038624f, -0.04026011f, -0.03961371f, 0.00833847f, -0.00131743f, -0.01301618f, -0.00621162f, 0.02762811f, 
    -0.11444973f, -0.08722260f, -0.38384706f, -0.38843027f, -0.13268106f, -0.06086953f, -0.15407385f, -0.11915251f, 
    0.17515336f, 0.02729956f, -0.15561387f, 0.00289559f, 0.26876256f, -0.06283354f, 0.36306009f, 0.09332602f, 
    0.08484612f, -0.05423531f, 0.04567314f, 0.09515710f, 0.07013280f, -0.01263201f, 0.05062455f, -0.00468625f, 
    -0.12945029f, -0.25233603f, -0.05271665f, 0.11292768f, 0.11566908f, 0.16740116f, 0.06009659f, -0.12289239f, 
    0.00738610f, -0.01888859f, 0.11172751f, -0.05306708f, 0.05886312f, 0.15453158f, 0.03661906f, -0.14380968f, 
    0.01543560f, 0.05282656f, -0.03592706f, 0.18712977f, 0.09144893f, 0.02794223f, -0.14824857f, -0.06149834f, 
    -0.42235821f, -0.06552862f, -0.01982023f, -0.30889261f, -0.08471841f, -0.03351394f, 0.05379626f, 0.02958594f, 
    0.02006477f, 0.00202486f, -0.04236213f, 0.06650878f, -0.48020214f, -0.06598587f, -0.18183877f, 0.22215404f, 
    -0.03788643f, -0.02266144f, -0.16521981f, 0.08043212f, 0.09069639f, 0.01775215f, 0.04315522f, -0.04555353f, 
    -0.13109444f, -0.12149480f, 0.27765051f, 0.14142767f, 0.24792837f, 0.03293145f, -0.06229534f, -0.11159034f, 
    -0.00130432f, -0.10561212f, 0.02818610f, -0.07209503f, 0.23021781f, 0.18087788f, 0.29642579f, -0.23683521f, 
    -0.01104872f, 0.02943746f, 0.03445185f, 0.10015155f, -0.04429287f, 0.01662136f, 0.02079073f, 0.11091163f, 
    0.10632731f, 0.26168039f, 0.13022520f, -0.18936829f, 0.10758898f, 0.16656365f, 0.05890408f, 0.04894187f, 
    0.05294069f, -0.10800461f, 0.02389858f, 0.00820535f, -0.10446118f, 0.34804520f, -0.29462790f, 0.06232746f, 
    0.10592597f, -0.05045254f, -0.07222101f, 0.05107886f, -0.08024953f, 0.08763953f, -0.08908190f, -0.02372214f, 
    -0.00113164f, -0.07461507f, -0.06136755f, -0.04802881f, 0.08364154f, 0.00980951f, 0.02770530f, 0.09981497f, 
    0.09957159f, -0.06031332f, -0.05737332f, -0.09898897f, 0.18388686f, 0.07146575f, 0.07541386f, -0.03734137f, 
    -0.01818481f, -0.11743809f, -0.08251294f, 0.05323686f, 0.03218162f, -0.03177696f, -0.00843685f, 0.08280046f, 
    0.21733050f, -0.12334209f, 0.37879479f, -0.25870603f, -0.06659479f, -0.01600915f, 0.01281084f, -0.00000428f, 
    0.03640825f, -0.07385704f, -0.00378724f, -0.09282454f, 0.21583900f, 0.16431786f, 0.17612292f, 0.03664812f, 
    0.02156649f, 0.08151845f, 0.16978574f, 0.12978016f, 0.02463337f, -0.04091324f, 0.23581927f, -0.01059975f, 
    -0.00712804f, 0.10020690f, -0.03476131f, -0.04964990f, -0.09639405f, 0.08649319f, 0.03872642f, 0.01963304f, 
    0.02710078f, -0.12595750f, 0.07482485f, 0.01677254f, 0.21285564f, 0.30374646f, 0.06512778f, -0.17073926f, 
    0.12718029f, 0.22746949f, 0.08730107f, 0.12245874f, 0.09262955f, 0.05189782f, 0.00263357f, 0.03402804f, 
    0.07020965f, -0.26013544f, 0.23976067f, 0.24313635f, -0.00257317f, -0.00076455f, -0.08491890f, -0.13483849f, 
    0.11150292f, 0.04409817f, -0.02600174f, 0.06374046f, 0.14859959f, 0.17194386f, -0.20103377f, -0.13554500f, 
    -0.12221219f, -0.13873847f, 0.07670076f, 0.15476063f, -0.07350899f, 0.13763663f, 0.07833504f, -0.06158904f, 
    0.10908546f, -0.42046866f, -0.08360563f, -0.17117630f, 0.07505658f, 0.00901955f, 0.04762001f, 0.06826443f, 
    -0.08268408f, 0.15693341f, -0.08638524f, 0.10712028f, 0.12679200f, -0.16961648f, -0.01565795f, -0.19405103f, 
    0.08290380f, -0.09523408f, -0.08776115f, -0.22313175f, 0.10996857f, 0.09294609f, -0.10969981f, -0.03460717f, 
    0.01070441f, -0.23065343f, -0.08830077f, 0.00792551f, 0.23261729f, -0.08900718f, -0.00902179f, 0.07073372f, 
    -0.06386194f, 0.00906511f, -0.08131354f, -0.20782320f, 0.18831451f, -0.18716082f, -0.09506565f, -0.09171515f, 
    0.05956625f, 0.05272790f, 0.00339927f, 0.07362968f, -0.07227143f, -0.09752243f, 0.11292587f, -0.03482471f, 
    0.21566327f, 0.05713205f, 0.02582902f, -0.11905443f, 0.15899262f, 0.06981169f, 0.06963363f, 0.09165350f, 
    -0.19041614f, 0.08351719f, 0.02051153f, 0.31268826f, 0.26268312f, -0.12420695f, -0.02937879f, 0.52122629f, 
    0.13528974f, -0.04416960f, -0.28684101f, 0.11907271f, -0.04610578f, -0.05057210f, 0.04777993f, -0.04325336f, 
    0.16889225f, 0.16587605f, -0.01088041f, -0.01915140f, 0.05925579f, 0.00437062f, 0.08269188f, 0.06867368f, 
    -0.13171151f, -0.06120152f, -0.06150398f, 0.03322323f, 0.01238655f, -0.14856911f, -0.23711349f, 0.16174518f, 
    0.07372776f, -0.07782043f, -0.14695552f, -0.01612875f, 0.02972941f, -0.24540974f, 0.00914563f, -0.02062269f, 
    -0.11943195f, -0.23773977f, -0.15722544f, -0.46962282f, -0.20323448f, 0.14118360f, 0.05742497f, 0.05990024f, 
    -0.06209317f, -0.08583287f, -0.00457734f, 0.00702552f, -0.22576110f, 0.04566698f, -0.13507646f, -0.12886956f, 
    0.03096087f, 0.01679530f, -0.03207166f, -0.01392669f, 0.13278124f, 0.08439133f, 0.06686256f, 0.10990743f, 
    -0.05359282f, -0.24514706f, -0.10203736f, -0.43443632f, 0.08929112f, 0.04210551f, 0.10083765f, 0.09974627f, 
    0.13614771f, -0.10120911f, -0.06807128f, -0.08302631f, 0.24864437f, 0.13578917f, 0.34896019f, -0.07496794f, 
    0.15050109f, -0.01611230f, 0.06058651f, 0.11558580f, -0.02167669f, -0.08177328f, -0.06236884f, 0.04526097f, 
    0.09553088f, 0.00764442f, 0.28946367f, -0.14168650f, -0.07088968f, 0.10378931f, -0.02966630f, 0.05534397f, 
    0.03757918f, -0.16484708f, 0.03118340f, -0.04460173f, -0.00432391f, -0.15231980f, -0.04654990f, -0.09188265f, 
    -0.13867831f, 0.15115181f, -0.01815494f, 0.05874657f, 0.18394394f, -0.04002327f, 0.00675454f, -0.30788070f, 
    -0.08547588f, -0.23782326f, 0.06613029f, 0.17318223f, 0.13331132f, 0.02508514f, -0.09249532f, -0.11426759f, 
    0.02920818f, -0.07831345f, 0.02808244f, -0.08086117f, -0.01662527f, -0.00327454f, -0.27722898f, -0.10015660f, 
    -0.13607322f, 0.10318228f, -0.01040612f, 0.02956245f, 0.03950832f, 0.09271622f, 0.02604671f, 0.21241230f, 
    0.08742564f, 0.03860161f, -0.00744245f, -0.04384372f, 0.03845941f, -0.12565327f, 0.03720288f, 0.06752395f, 
    -0.04965620f, -0.08472061f, -0.01755084f, -0.01274397f, 0.19073428f, -0.02767343f, 0.00711026f, 0.08741579f, 
    0.06346674f, 0.01793273f, -0.17207855f, -0.07534117f, 0.01937273f, -0.02806005f, -0.00153996f, 0.08519836f, 
    -0.33797604f, -0.12381945f, -0.02604166f, -0.01716530f, 0.09463340f, -0.17375202f, -0.23013644f, -0.05755103f, 
    -0.02314669f, 0.01214702f, 0.05106593f, 0.08667433f, -0.25371352f, -0.16589159f, -0.16629122f, 0.33904323f, 
    0.22192933f, 0.24695379f, -0.19437325f, 0.05841829f, 0.07141268f, 0.00700607f, 0.14896433f, 0.00215704f, 
    0.20830362f, 0.14218433f, 0.03110603f, -0.14549223f, 0.07702472f, -0.02088766f, -0.01311707f, 0.15727310f, 
    -0.02148394f, 0.01826484f, 0.12879576f, 0.02976226f, 0.03704424f, -0.03487145f, 0.18105172f, -0.42103994f, 
    -0.00488953f, -0.04882606f, 0.06090302f, 0.21263494f, -0.10846712f, -0.01743163f, -0.12532325f, 0.07940044f, 
    0.16857854f, 0.41810167f, -0.19102325f, -0.14653152f, -0.09233166f, 0.10472503f, 0.21629928f, 0.19425765f, 
    0.12495643f, -0.03760366f, -0.14974029f, -0.01437661f, -0.09619889f, -0.23527519f, -0.01568677f, 0.08432826f, 
    0.17566821f, -0.14025164f, 0.00804725f, 0.15118988f, 0.18764849f, -0.08589905f, 0.13459605f, -0.01320144f, 
    0.19037251f, 0.05670541f, 0.02115528f, -0.17034093f, 0.09412140f, 0.00695362f, -0.03372716f, 0.02718211f, 
    0.05003724f, -0.05205173f, -0.07056177f, -0.10178200f, 0.07198738f, -0.21091324f, -0.02391499f, -0.18649603f, 
    -0.03847371f, -0.00480831f, -0.18468931f, -0.18087758f, -0.01752864f, -0.07695317f, 0.07283395f, -0.09848157f, 
    0.07157033f, -0.14633696f, 0.04518865f, 0.21002693f, -0.09393685f, -0.03904954f, 0.03449820f, -0.02943888f, 
    -0.00313081f, 0.03638292f, -0.01486335f, 0.08674216f, 0.01590923f, 0.02229759f, 0.11249046f, -0.08400213f, 
    -0.02856806f, 0.07748449f, -0.16660514f, 0.05806182f, 0.06946837f, -0.19412236f, -0.12200982f, -0.11338080f, 
    -0.05376738f, 0.04126676f, 0.02428937f, -0.35103208f, -0.05346059f, 0.07413779f, -0.01863766f, 0.07932859f, 
    0.02569029f, 0.01977535f, 0.07306445f, 0.02804061f, 0.26341614f, 0.02306201f, 0.11114520f, -0.21260959f, 
    0.09815365f, -0.00640213f, 0.03544575f, 0.24901658f, -0.08020748f, 0.02104874f, 0.00922961f, -0.00014861f, 
    -0.28232905f, 0.07845701f, 0.08036269f, 0.28246036f, -0.14538114f, 0.09464036f, -0.15227747f, -0.12651713f, 
    0.13314751f, -0.05072656f, -0.04964145f, 0.07709629f, -0.22856501f, 0.15731275f, 0.21007100f, 0.05850197f, 
    -0.05170503f, -0.08365417f, -0.03578682f, -0.01329539f, 0.06014932f, -0.13600937f, 0.03608303f, 0.03089371f, 
    -0.10798605f, -0.14165346f, 0.05750839f, 0.10750345f, 0.09445672f, 0.01590869f, -0.08588902f, 0.07505961f, 
    -0.05730196f, -0.08704209f, 0.17965420f, -0.17556269f, -0.01355696f, 0.32093224f, -0.21402146f, 0.01468533f, 
    0.02062228f, -0.01053856f, -0.01282705f, 0.12146739f, 0.02278350f, 0.11161459f, 0.13554382f, -0.07381867f, 
    -0.38323921f, -0.03458234f, 0.17534426f, 0.16946515f, 0.01269982f, 0.04585288f, 0.02994518f, -0.08839595f, 
    -0.00259345f, 0.03935148f, -0.00989254f, -0.05111530f, -0.11918725f, -0.00093030f, 0.00776043f, 0.18451034f, 
    0.15485787f, 0.03308081f, -0.10513030f, -0.11048602f, 0.00914014f, -0.02821787f, 0.08677563f, -0.01388542f, 
    0.26056704f, -0.09800197f, 0.40366352f, -0.11649837f, 0.07356007f, -0.11122169f, 0.11155527f, 0.18990643f, 
    -0.05396928f, -0.02187038f, 0.03108210f, -0.00803967f, 0.04074483f, 0.44718754f, 0.04328586f, 0.00437755f, 
    0.00871685f, -0.00784229f, -0.01682647f, 0.12076413f, 0.05418175f, -0.06864551f, 0.01966872f, -0.05898502f, 
    -0.18178752f, -0.08480591f, -0.13050161f, 0.20561455f, 0.02257683f, 0.10993964f, 0.06135979f, -0.08457075f, 
    0.16158739f, -0.12062411f, -0.11916340f, 0.03466496f, 0.13461782f, 0.26601630f, 0.14528197f, 0.05093057f, 
    0.05432398f, -0.10821182f, 0.25599861f, 0.10010920f, 0.11094996f, -0.03968216f, -0.05208400f, 0.11109278f, 
    0.09634505f, -0.01470023f, 0.25725830f, -0.15993911f, 0.05103954f, -0.00989371f, -0.03147691f, 0.05045608f, 
    -0.09156086f, -0.16472845f, -0.14662583f, -0.07178883f, -0.06516331f, -0.03744356f, -0.28607634f, 0.11044460f, 
    -0.00985590f, 0.08573776f, -0.02414294f, -0.03274413f, -0.01952371f, -0.01314338f, 0.20175570f, -0.00140139f, 
    0.01566357f, 0.33025280f, -0.03295488f, -0.15225363f, 0.10627963f, 0.13740666f, 0.10528987f, 0.16000775f, 
    0.05653616f, -0.08751554f, 0.05844725f, -0.05859358f, -0.11171274f, -0.03709623f, -0.27374113f, -0.26918536f, 
    -0.11152632f, 0.07766935f, 0.11954394f, -0.29581738f, 0.18018979f, 0.15287602f, 0.02636682f, 0.03510709f, 
    -0.02810018f, -0.06703792f, 0.01224046f, -0.15441735f, -0.00773585f, 0.03677828f, -0.05416059f, -0.06281012f, 
    -0.01602914f, -0.00599743f, -0.13729288f, 0.07643589f, 0.04864422f, 0.09828800f, 0.17734279f, 0.24778850f, 
    0.10222251f, -0.20351204f, 0.00346135f, -0.05525907f, 0.09482406f, 0.04215444f, -0.05603439f, 0.03111601f, 
    -0.03324557f, -0.00164393f, 0.00110043f, 0.00090045f, -0.02772963f, 0.02019543f, 0.00945574f, 0.02301652f, 
    0.01623307f, 0.01621626f, -0.01906377f, 0.02856148f, 0.02023527f, 0.00466175f, -0.02576950f, 0.00635863f, 
    0.02255351f, -0.00290392f, 0.01237405f, -0.00972089f, 0.03001317f, -0.03486339f, -0.00553032f, -0.00608748f, 
    -0.00018279f, -0.00635337f, 0.01762862f, 0.02744406f, 0.00542306f, -0.01264155f, 0.02861438f, 0.01228167f, 
    0.03221041f, -0.01923709f, -0.02068902f, -0.02536166f, -0.00408313f, 0.02019890f, -0.01919425f, -0.02383234f, 
    -0.01140047f, 0.00165675f, -0.04061202f, 0.02371432f, -0.02857301f, -0.00543412f, -0.01925926f, -0.02140595f, 
    -0.03155590f, -0.01421169f, -0.02544506f, -0.00067220f, 0.01304477f, -0.03351697f, -0.00715310f, -0.01915088f, 
    -0.02852773f, 0.01210060f, 0.00162032f, -0.03574333f, 0.02044914f, -0.03075747f, 0.00927780f, 0.02939709f, 
    0.01153565f, 0.01976212f, -0.00050045f, 0.01134004f, -0.00645575f, 0.01189371f, -0.00018585f, -0.03273880f, 
    0.00599529f, 0.00101325f, -0.01599589f, -0.01145132f, -0.00798007f, -0.02738218f, -0.04136064f, 0.02747845f, 
    -0.00537314f, 0.00173788f, -0.00647816f, -0.00340506f, -0.03477610f, 0.02835648f, 0.02812766f, -0.00203264f, 
    -0.02567503f, -0.00044413f, 0.01309673f, -0.00475618f, 0.01104235f, -0.02372827f, -0.03757782f, 0.00017896f, 
    -0.00975890f, 0.01363651f, -0.02925415f, 0.02027995f, 0.00288200f, 0.02326995f, 0.02891588f, -0.03076555f, 
    0.04285146f, -0.00687175f, -0.03034027f, -0.02327630f, 0.01145749f, 0.01532157f, 0.01701685f, 0.00198399f, 
    -0.01899160f, -0.03117418f, 0.00112809f, 0.02383039f, -0.02577214f, -0.02294388f, -0.00970464f, 0.01335661f, 
    -0.00805277f, -0.03508830f, 0.01726860f, 0.00913733f, 0.02494060f, 0.02403204f, -0.01270373f, 0.02598864f, 
    -0.00156566f, -0.01273635f, 0.03084999f, 0.01171293f, -0.02395851f, -0.01578128f, -0.03585264f, 0.02142021f, 
    0.01707372f, -0.01581772f, 0.01889062f, 0.03373897f, 0.01904914f, -0.00110830f, -0.01019165f, -0.00610538f, 
    0.02795213f, -0.02515520f, -0.03878110f, -0.00721803f, 0.01912347f, 0.00441916f, -0.03019805f, -0.01205106f, 
    -0.00161180f, 0.00165012f, -0.02755899f, -0.01010967f, -0.01953132f, -0.00526422f, 0.02573959f, 0.03405775f, 
    -0.01670654f, -0.00382226f, -0.00159085f, -0.03358528f, -0.02277778f, -0.01228711f, -0.02534897f, -0.01244078f, 
    0.02155443f, 0.03151625f, 0.00377331f, -0.00940946f, 0.02570729f, -0.03681035f, -0.01144645f, -0.02911555f, 
    -0.02092086f, -0.03751719f, -0.03631557f, 0.00529755f, 0.00571769f, 0.00058331f, -0.01632189f, -0.02809159f, 
    -0.03334098f, 0.01876282f, -0.01802523f, 0.00885054f, 0.01533404f, 0.02701521f, -0.02447027f, -0.01997666f, 
    -0.01471604f, -0.03391790f, -0.00466563f, -0.02799383f, 0.02064987f, -0.01704510f, 0.03160276f, 0.02451948f, 
    -0.00764177f, 0.02584714f, -0.00071764f, 0.00364013f, -0.03429547f, -0.03827519f, -0.01370437f, 0.00306206f, 
    0.01524763f, -0.01105313f, 0.01355254f, 0.02404595f, -0.04231952f, -0.03200040f, 0.00218760f, -0.00950234f, 
    -0.00430448f, -0.03746408f, -0.01114974f, -0.03833715f, -0.02934173f, -0.00509718f, -0.00666881f, 0.00367236f, 
    -0.01181577f, 0.02266515f, -0.03144432f, -0.00089570f, 0.00454131f, 0.00641470f, -0.02631912f, 0.03354195f, 
    -0.01172102f, -0.02338500f, -0.02152540f, 0.02622698f, 0.01023293f, 0.00452421f, 0.01424504f, -0.00804817f, 
    0.01263838f, 0.02500156f, 0.03374420f, -0.02237694f, 0.02380058f, -0.00413184f, -0.02270105f, -0.03911766f, 
    -0.02503863f, -0.01868319f, -0.02488836f, -0.01696792f, -0.02375619f, -0.03033286f, 0.00227065f, 0.03396888f, 
    -0.00848585f, -0.00931931f, -0.02752454f, -0.00701624f, -0.00375248f, -0.00534244f, 0.01066874f, -0.00279418f, 
    0.00518327f, -0.03423814f, 0.02695694f, -0.01184777f, 0.02621976f, 0.03035095f, -0.01342037f, 0.02691290f, 
    0.00864024f, -0.02744361f, 0.01505972f, -0.03695337f, 0.01567760f, 0.02999945f, -0.02063499f, -0.01477091f, 
    -0.02795135f, -0.00941220f, 0.01017591f, 0.02566967f, 0.03411194f, 0.02272152f, -0.03169401f, -0.00195035f, 
    -0.01236667f, 0.01607447f, -0.01856128f, 0.01245538f, -0.03949757f, 0.02331056f, -0.03096817f, -0.00105294f, 
    0.02954112f, -0.00667032f, -0.00444224f, 0.02969054f, 0.00289708f, 0.02792127f, -0.00557373f, 0.01317091f, 
    -0.01457702f, 0.02095971f, -0.01912687f, 0.02172027f, 0.00231373f, -0.03608493f, -0.02836705f, 0.02929709f, 
    -0.01886082f, 0.01690316f, -0.03451320f, -0.01835377f, 0.01103601f, 0.00781637f, -0.01619220f, -0.01001478f, 
    0.03087553f, -0.03284633f, -0.03000559f, 0.01864616f, -0.00437366f, -0.03224186f, -0.01872890f, -0.01272414f, 
    -0.01050804f, -0.02310460f, -0.03003652f, -0.00783189f, -0.02008067f, -0.00953341f, 0.01817527f, 0.02076080f, 
    0.00338171f, -0.01175043f, -0.00647584f, -0.02495093f, 0.02357043f, 0.00366272f, -0.03180531f, 0.01899552f, 
    0.00548670f, 0.00323505f, -0.01106416f, -0.01822668f, -0.02823774f, -0.01605476f, -0.01704706f, 0.03291361f, 
    -0.03314902f, 0.01958431f, 0.02513825f, -0.00521563f, -0.01844727f, -0.02408896f, 0.02114668f, 0.01771573f, 
    -0.03904323f, -0.00529605f, -0.03681977f, 0.03137286f, -0.02797215f, -0.01978466f, -0.00757500f, 0.02331067f, 
    0.02113887f, 0.01007519f, 0.01880315f, -0.00440683f, -0.03533474f, -0.01526303f, -0.01458867f, 0.01218766f, 
    -0.01001122f, 0.01086061f, 0.02282213f, -0.02932758f, -0.00222343f, -0.02297350f, -0.02015691f, 0.00069700f, 
    -0.02827199f, -0.03686411f, 0.01238546f, 0.01102241f, -0.03293762f, -0.00812739f, -0.02942304f, 0.00169510f, 
    0.02331977f, -0.02415250f, -0.02982140f, -0.02528314f, -0.01365122f, -0.01610349f, -0.00824340f, 0.00501988f, 
    -0.00508358f, 0.00484516f, 0.03300493f, -0.01936379f, 0.01399744f, -0.00793800f, 0.01673701f, 0.02141783f, 
    -0.00309364f, -0.04002645f, -0.00562485f, -0.02226712f, 0.01349400f, 0.04180531f, -0.01042441f, 0.01603191f, 
    -0.03119260f, -0.03670157f, -0.00072138f, -0.00216324f, 0.01763252f, -0.02390615f, -0.03041983f, 0.01135736f, 
    0.02329488f, -0.02240864f, -0.00148130f, -0.01161598f, -0.01317396f, 0.00985976f, 0.01984209f, 0.00856241f, 
    0.01989598f, 0.01408670f, -0.01317689f, 0.02453047f, -0.01788398f, -0.01379758f, -0.00100069f, -0.00379348f, 
    -0.03980675f, -0.01366563f, -0.02224389f, -0.02809325f, 0.02286580f, -0.03788774f, -0.02809474f, -0.02068521f, 
    -0.01653182f, 0.02069265f, -0.00693008f, -0.00525477f, -0.01946284f, -0.01718215f, -0.01865886f, 0.02507585f, 
    -0.02724440f, -0.01705358f, -0.03466789f, -0.00864435f, -0.02185392f, -0.01112760f, 0.00498797f, -0.00576797f, 
    0.03241627f, -0.00613827f, 0.01561908f, 0.01616344f, 0.00524338f, -0.01203671f, -0.02288626f, -0.01392292f, 
    0.00314928f, 0.00895972f, 0.01265915f, 0.01342784f, 0.01322783f, -0.00749385f, 0.03279176f, -0.01031937f, 
    0.01586848f, -0.03530277f, -0.03801935f, -0.00299143f, -0.00747644f, 0.00506018f, 0.02056752f, -0.02730910f, 
    -0.03865135f, -0.03983035f, -0.02373260f, -0.00754224f, 0.00309280f, -0.00839764f, -0.03142637f, -0.02573045f, 
    0.01785467f, 0.02297027f, -0.00594855f, -0.00259195f, -0.01383723f, -0.01478590f, 0.00218471f, -0.03700528f, 
    -0.02282506f, 0.01118501f, -0.00576412f, -0.03755778f, 0.02860601f, 0.01492104f, 0.01502721f, 0.01565138f, 
    0.00350852f, -0.03148802f, 0.02752415f, -0.03425116f, -0.02032112f, -0.03713641f, -0.00106975f, 0.01507243f, 
    0.00230298f, -0.03620667f, -0.02765962f, -0.02354344f, -0.03777438f, 0.01314662f, 0.00411454f, -0.00055660f, 
    -0.02278212f, -0.00966564f, -0.02045528f, 0.01231075f, -0.00346548f, -0.00963753f, -0.03723094f, 0.03245459f, 
    0.01159791f, -0.01438715f, 0.00558587f, -0.00667770f, -0.00039457f, 0.00363944f, -0.02235249f, 0.02477088f, 
    0.03176667f, -0.02466794f, 0.01807072f, 0.02083629f, 0.02664863f, -0.02199520f, 0.02929755f, -0.01705120f, 
    -0.00241890f, -0.02791856f, 0.01199658f, -0.03547696f, 0.02247809f, 0.02451723f, 0.00782367f, -0.02592034f, 
    0.01197444f, 0.00243519f, -0.03395026f, -0.03812340f, 0.00716569f, 0.00406435f, -0.04052474f, 0.00572474f, 
    0.00026647f, -0.03077281f, -0.00592648f, 0.01241264f, -0.03061110f, 0.00376585f, -0.02645835f, 0.01644653f, 
    -0.01177590f, 0.00878392f, 0.02286106f, -0.03568740f, 0.00662768f, -0.00731360f, -0.00038006f, 0.03389362f, 
    -0.02554014f, 0.01204341f, -0.03681448f, -0.01341112f, -0.02865270f, 0.01545477f, -0.01157398f, -0.02622122f, 
    0.00574575f, 0.01515189f, 0.03357623f, -0.01376556f, 0.02212605f, 0.02047871f, 0.00508735f, -0.04080492f, 
    0.00203914f, -0.02226892f, 0.02588294f, -0.01273834f, 0.01528183f, -0.02030833f, 0.00387672f, -0.02326789f, 
    0.02407570f, 0.00194670f, 0.02587368f, -0.02107913f, -0.01166597f, -0.03042020f, 0.03991726f, 0.03352125f, 
    0.00108414f, -0.01589164f, -0.02862889f, -0.03799498f, 0.00161899f, -0.01927452f, 0.00436694f, 0.01966187f, 
    0.00237646f, -0.01916608f, 0.03122452f, 0.02984701f, -0.00899700f, 0.03283503f, 0.03175398f, -0.01211116f, 
    0.02251587f, -0.00374689f, 0.00536827f, 0.02952291f, 0.01623102f, -0.00669532f, -0.02258280f, 0.01188620f, 
    -0.01570254f, -0.01275408f, 0.03074927f, 0.00967733f, -0.02422094f, -0.02276650f, 0.01339683f, 0.00032918f, 
    0.00874094f, -0.01386889f, -0.02297069f, 0.00779539f, -0.03049315f, 0.02754085f, -0.01486016f, -0.03283740f, 
    0.02552173f, 0.01523907f, 0.02796819f, -0.03733739f, -0.00048750f, -0.00417207f, 0.01653520f, -0.02269480f, 
    0.01332291f, 0.02323384f, 0.00846735f, 0.00598964f, 0.01853729f, 0.01591596f, -0.00371254f, 0.03821984f, 
    -0.01964075f, -0.03409744f, -0.01101055f, 0.01548242f, 0.02795024f, 0.04433310f, -0.02425683f, -0.03388218f, 
    0.03444469f, 0.01603859f, -0.02520483f, -0.00302591f, -0.00926623f, -0.02409995f, -0.02980516f, 0.01570202f, 
    -0.03762780f, 0.00481639f, -0.04055798f, 0.02305892f, 0.02494244f, -0.02554467f, -0.00745555f, 0.01650048f, 
    -0.00084717f, 0.03287699f, 0.02117419f, 0.02468705f, 0.00052932f, 0.01950971f, 0.01411109f, -0.01249932f, 
    0.03041654f, -0.01084713f, -0.01424473f, -0.00678558f, 0.01797901f, 0.02002754f, -0.01648017f, -0.02327069f, 
    -0.00916518f, -0.00482774f, 0.02649058f, -0.02899158f, 0.02666451f, 0.02415940f, 0.01776310f, 0.02535454f, 
    0.01671740f, -0.03700997f, -0.00048240f, 0.00116919f, -0.01591285f, -0.00059247f, 0.02242546f, 0.02370124f, 
    -0.01647799f, 0.02714939f, 0.03630917f, 0.02396190f, -0.03322315f, -0.01937571f, -0.02584948f, -0.01247397f, 
    -0.02577559f, 0.02047654f, -0.00368550f, -0.03565750f, 0.02806082f, 0.03082131f, 0.00834800f, 0.01950788f, 
    0.01474664f, -0.02532499f, 0.00966188f, -0.00082990f, 0.00555865f, 0.00839832f, 0.03300030f, -0.02959121f, 
    -0.02260985f, 0.02760397f, -0.02950056f, -0.03831347f, -0.00176409f, 0.00196830f, -0.02159226f, 0.02052754f, 
    -0.03773626f, 0.00516573f, -0.02445460f, 0.02772641f, 0.00411126f, 0.02554155f, 0.02346221f, -0.01607262f, 
    -0.03850816f, -0.01320886f, -0.02959655f, -0.00998793f, 0.00995243f, -0.00007940f, -0.00194126f, 0.00127282f, 
    0.02380861f, 0.02171239f, -0.01700156f, -0.02590632f, -0.02229531f, -0.02117478f, 0.02742444f, -0.04053103f, 
    0.02787464f, 0.02361033f, 0.00235116f, -0.02443189f, -0.01096841f, -0.01063193f, -0.03334834f, -0.01704918f, 
    -0.01249425f, 0.01439650f, -0.00092535f, 0.01902666f, -0.01211338f, -0.00749893f, 0.02048809f, -0.04194890f, 
    -0.00461133f, -0.03265794f, 0.00076042f, -0.01153038f, -0.01629333f, -0.01170429f, -0.03376168f, 0.01418342f, 
    -0.00230307f, -0.04171189f, -0.00087276f, 0.01405694f, 0.01386277f, -0.00787031f, -0.01288607f, -0.00183041f, 
    0.01729224f, -0.01979852f, 0.02466990f, -0.02195781f, -0.00950706f, -0.03578391f, 0.02663976f, 0.01754829f, 
    -0.03842970f, 0.00917752f, -0.02186675f, -0.03380323f, 0.00558292f, 0.01465230f, -0.03610143f, 0.00317078f, 
    -0.04063727f, -0.03286041f, -0.02575408f, 0.00267804f, 0.00053034f, 0.01998794f, -0.03873498f, 0.01119592f, 
    -0.01947418f, 0.00544037f, 0.02795491f, -0.03366732f, 0.02217677f, -0.01747536f, -0.03025385f, -0.01652026f, 
    0.00603358f, -0.03727384f, -0.02374277f, -0.03403735f, -0.02536508f, -0.03408961f, -0.03624343f, -0.01834558f, 
    -0.00491450f, -0.03045169f, -0.00688288f, 0.00778274f, -0.02181120f, 0.00450032f, -0.01561354f, 0.01361538f, 
    -0.00473307f, -0.03987429f, 0.00277667f, 0.00247031f, 0.02640176f, 0.01982340f, -0.01317607f, 0.01741388f, 
    -0.01765517f, -0.03938637f, -0.00031264f, -0.04168242f, -0.00058430f, 0.00548913f, -0.02199783f, 0.02197592f, 
    -0.02381480f, -0.02147170f, -0.01677480f, 0.00539094f, 0.01788151f, 0.00067705f, -0.01243004f, -0.03130417f, 
    -0.03438704f, 0.01795760f, -0.02086104f, 0.01389617f, 0.00652016f, 0.00996897f, -0.00311980f, -0.03707534f, 
    0.00080576f, 0.01748868f, -0.03008658f, -0.03508636f, 0.02742385f, -0.00446914f, -0.00529514f, 0.01566427f, 
    -0.03556194f, -0.00329909f, -0.02030558f, -0.00764483f, -0.02974367f, 0.03409551f, -0.02102459f, -0.01499573f, 
    -0.03908238f, -0.03753858f, 0.02032339f, 0.02736320f, -0.00696368f, -0.01639068f, 0.01562463f, -0.00735445f, 
    0.01227110f, -0.03527709f, 0.02319714f, -0.02056831f, 0.00919493f, -0.00539738f, -0.02014316f, -0.02309395f, 
    -0.00795079f, 0.01428097f, -0.03176983f, 0.01379529f, 0.02726596f, 0.00220765f, -0.00595792f, -0.00896759f, 
    -0.00170139f, 0.02697397f, -0.00002117f, 0.01330746f, -0.00204649f, -0.03075814f, -0.00074229f, 0.00552937f, 
    -0.01495637f, -0.03263727f, -0.02406939f, -0.03321292f, -0.04198487f, 0.01095949f, 0.00630404f, -0.03816225f, 
    -0.00752544f, 0.02887381f, -0.00094254f, -0.00031604f, 0.02157846f, 0.00929906f, -0.01533823f, -0.00527799f, 
    0.02818317f, -0.00304929f, -0.03925509f, -0.01716409f, -0.03870004f, -0.02152836f, 0.02261642f, -0.02130637f, 
    -0.01233769f, -0.01235455f, -0.02876590f, 0.01836178f, 0.00295920f, 0.00497341f, 0.00154569f, -0.03411251f, 
    -0.00375528f, -0.03618826f, 0.01677461f, 0.02791341f, -0.03614078f, -0.01185381f, 0.01983685f, -0.00602230f, 
    -0.00427763f, -0.02838924f, -0.01353629f, -0.01553317f, -0.04010587f, -0.02092165f, -0.02509139f, -0.03299178f, 
    -0.04104120f, -0.00141016f, -0.01812405f, 0.02096247f, -0.02224324f, 0.01359920f, -0.01494442f, -0.04181476f, 
    -0.00393711f, 0.01949812f, 0.00012109f, -0.02529772f, 0.01199007f, -0.03489702f, 0.02311351f, 0.01961931f, 
    -0.00011114f, -0.04046463f, -0.01276344f, -0.02501258f, -0.00577720f, -0.01997755f, 0.02660526f, -0.03879627f, 
    -0.02934993f, -0.00523118f, 0.01655189f, -0.00407342f, 0.00828197f, -0.01106486f, -0.00408002f, -0.01892433f, 
    -0.02514238f, 0.02124268f, 0.02772331f, -0.04084140f, -0.02605551f, -0.04155903f, 0.02912540f, -0.01928388f, 
    0.01261766f, -0.02024946f, 0.01913873f, 0.01355582f, 0.01042186f, -0.03591135f, -0.00526955f, -0.02264178f, 
    -0.03975417f, -0.01343864f, -0.03299910f, 0.00255101f, -0.00840851f, -0.04206941f, -0.00135949f, -0.02466819f, 
    -0.00482162f, 0.02435000f, -0.00800101f, -0.03156379f, -0.01094353f, -0.01097968f, -0.02122995f, -0.00465526f, 
    0.00032527f, -0.03407696f, -0.02719046f, -0.01504363f, 0.01935604f, 0.00969157f, 0.02599436f, 0.02375284f, 
    -0.01075881f, 0.01158706f, -0.00755455f, -0.03956882f, 0.02331471f, -0.00215670f, -0.01519024f, -0.02281672f, 
    -0.00540571f, 0.00825252f, -0.01686987f, 0.01952045f, -0.04070851f, -0.02833076f, 0.00476621f, 0.00467199f, 
    0.00123796f, 0.01125365f, -0.03460010f, -0.03532593f, -0.02335798f, -0.01434381f, -0.01202400f, 0.02399293f, 
    -0.01376658f, -0.02894488f, 0.00502355f, 0.01571363f, -0.02064763f, 0.01446680f, -0.01817934f, -0.02279152f, 
    -0.03348288f, -0.03049457f, -0.01464264f, -0.01338281f, -0.01252215f, -0.04061966f, 0.00660661f, -0.00719157f, 
    -0.02992551f, -0.03507005f, -0.01387716f, -0.01842284f, -0.02863963f, -0.03308270f, -0.03634592f, 0.02254189f, 
    -0.00461620f, -0.02502723f, -0.01132245f, 0.00449700f, -0.01614184f, -0.02280865f, -0.01664413f, 0.01906258f, 
    0.01094989f, -0.00610112f, -0.02361160f, -0.02212115f, -0.03382630f, 0.02874282f, 0.01509824f, -0.02819177f, 
    -0.03029460f, -0.01604180f, -0.00346414f, -0.02840842f, 0.00097110f, -0.00268636f, 0.02635835f, 0.02320834f, 
    0.01485459f, 0.02892771f, 0.01429574f, -0.01915389f, 0.00060259f, 0.01293917f, -0.01638469f, -0.03560572f, 
    0.00179699f, -0.00599472f, 0.02457282f, 0.02669637f, 0.02071765f, 0.01061970f, -0.02287745f, 0.02125745f, 
    -0.00895934f, -0.02588383f, -0.02688911f, 0.01611847f, 0.02282503f, 0.02136141f, -0.01070107f, -0.00851477f, 
    -0.03623729f, 0.00935038f, 0.02342127f, -0.03173194f, -0.02660477f, -0.02124928f, 0.00575279f, 0.02295098f, 
    -0.01630198f, -0.02234739f, -0.01603782f, 0.01817653f, 0.00137403f, 0.00857725f, -0.00376355f, -0.00769513f, 
    -0.02487041f, -0.00815146f, -0.04034785f, -0.00485890f, -0.02009106f, -0.03315930f, 0.02275192f, -0.03243881f, 
    -0.00981513f, 0.02256251f, -0.03221021f, -0.03813094f, -0.00514992f, -0.02010433f, -0.03489158f, -0.03519467f, 
    -0.01991240f, -0.01684240f, -0.02851593f, -0.02195196f, 0.01958623f, -0.01412338f, -0.00194898f, -0.01203005f, 
    0.02619823f, -0.03210781f, 0.01305098f, -0.02001939f, 0.00658842f, 0.01592121f, -0.03478886f, 0.02715052f, 
    0.00146925f, 0.02123475f, -0.01204996f, -0.00223149f, -0.01343420f, 0.02615358f, -0.01243523f, -0.03392830f, 
    -0.00665371f, 0.00982080f, 0.02565903f, -0.02173517f, -0.02663372f, -0.03495422f, 0.00864808f, -0.01254126f, 
    -0.01839022f, 0.00464661f, 0.01657268f, 0.01740715f, -0.00728611f, -0.03687454f, 0.02625108f, -0.00491341f, 
    -0.03130759f, -0.01069488f, 0.02935963f, 0.00956573f, -0.01154783f, -0.03857399f, 0.02990278f, 0.00638536f, 
    -0.02905795f, -0.00469724f, 0.01165275f, 0.00144715f, 0.00043916f, 0.01840743f, 0.00953384f, 0.00910678f, 
    -0.01427862f, -0.03521234f, 0.00672961f, -0.00121983f, -0.03174717f, 0.00312714f, 0.01016734f, -0.00496343f, 
    0.02468915f, -0.01046495f, -0.00488333f, -0.03308651f, -0.02085846f, 0.01908532f, -0.01375944f, 0.02173002f, 
    -0.01568035f, 0.02368441f, 0.00365818f, -0.00926296f, -0.03343205f, -0.02510197f, -0.03963405f, 0.02760814f, 
    -0.00707430f, 0.00591239f, 0.00473579f, -0.03196389f, -0.04176478f, 0.02126251f, -0.01393344f, 0.01418766f, 
    -0.03807108f, 0.01320017f, 0.01733104f, 0.01870490f, -0.02261832f, -0.00373603f, -0.03082434f, -0.02750121f, 
    -0.04023443f, -0.04020215f, 0.00490152f, 0.00835244f, -0.00676531f, -0.03755685f, -0.02769752f, -0.00850268f, 
    0.00999232f, -0.02279478f, -0.02468761f, 0.01739732f, -0.03288295f, -0.01078686f, -0.01306095f, 0.00584866f, 
    -0.00879229f, 0.01517936f, -0.03568823f, 0.00265889f, 0.02577551f, -0.00905454f, -0.02710695f, 0.00350697f, 
    -0.01907029f, 0.02214077f, 0.01138308f, -0.02317481f, 0.00527286f, -0.00659775f, -0.02853473f, -0.01797467f, 
    -0.01861497f, 0.00720592f, -0.01870362f, 0.01675696f, 0.01860332f, -0.00943889f, 0.00252925f, 0.02201695f, 
    0.01110203f, -0.01373439f, -0.00950475f, -0.03963538f, -0.00956401f, -0.01583353f, 0.01630529f, -0.03069510f, 
    0.01236742f, 0.01323181f, -0.03202147f, -0.03306905f, 0.00558956f, 0.00461738f, -0.03081914f, -0.00538507f, 
    -0.00516964f, -0.03728189f, -0.00708958f, -0.02563790f, -0.02372321f, 0.01033783f, 0.00796989f, 0.00616807f, 
    -0.03743666f, -0.03357426f, 0.00616832f, -0.02906665f, 0.00039484f, 0.02545486f, -0.00067200f, -0.03763040f, 
    0.02121053f, 0.00317754f, 0.03377820f, -0.03197020f, 0.01861609f, -0.03534878f, -0.00108222f, -0.00512341f, 
    0.01283420f, 0.02631400f, -0.01766019f, -0.00712510f, 0.01971196f, -0.02037623f, 0.01249226f, 0.01494203f, 
    -0.01442519f, 0.00689994f, 0.00769464f, 0.00435839f, 0.02805200f, -0.00295953f, -0.03648585f, 0.02466843f, 
    0.02820866f, 0.02844878f, -0.00895100f, -0.03134070f, -0.00961277f, -0.02781915f, -0.00649688f, -0.03051565f, 
    0.02788862f, 0.00090521f, -0.03559154f, -0.01165417f, -0.00057397f, -0.00605623f, 0.01533468f, 0.02734452f, 
    0.00810251f, 0.02846248f, -0.01336792f, 0.00793350f, -0.00844426f, -0.00094549f, 0.01949647f, -0.04153411f, 
    0.01642777f, -0.02165040f, -0.03032383f, -0.03738800f, 0.02407171f, 0.00109270f, 0.02531426f, 0.00956441f, 
    -0.01588687f, -0.01472419f, 0.02709927f, 0.02168188f, -0.01278944f, -0.03646722f, -0.00429772f, 0.02705953f, 
    -0.02033294f, 0.00287515f, -0.02165696f, -0.00061004f, -0.00330169f, 0.00886829f, 0.00920762f, 0.00765483f, 
    -0.03142941f, 0.02927044f, -0.02732071f, -0.01824280f, 0.01409352f, -0.01127683f, 0.02019283f, -0.03692180f, 
    0.02791320f, 0.02217059f, -0.01466006f, -0.02386177f, 0.01124069f, -0.02379682f, 0.00974066f, 0.00953105f, 
    0.00351515f, 0.02408551f, -0.03580235f, 0.01249984f, 0.00166298f, -0.00750464f, -0.01412523f, 0.00582028f, 
    0.02586008f, 0.01879223f, -0.00779061f, -0.02121241f, 0.00367487f, -0.01799068f, 0.01012713f, 0.00823419f, 
    0.01996395f, 0.01478066f, 0.00765597f, 0.02966345f, -0.02381251f, 0.02318912f, 0.01797509f, 0.01834694f, 
    -0.03464442f, 0.02951229f, -0.01073759f, -0.02906707f, -0.04025960f, 0.01629216f, 0.00600277f, 0.00570147f, 
    -0.03958959f, -0.03038527f, 0.01814349f, -0.02949896f, 0.00572249f, 0.00916137f, -0.00282753f, -0.02069612f, 
    0.02623471f, 0.00610714f, -0.03786701f, -0.02345268f, 0.02850627f, 0.00909698f, -0.03144417f, 0.00755425f, 
    -0.00648116f, 0.00527080f, 0.02805169f, 0.02688240f, -0.02854579f, -0.01475148f, 0.02922167f, 0.00016716f, 
    0.01727759f, -0.01374490f, 0.00236844f, -0.01578981f, 0.01138011f, 0.00277367f, 0.01717493f, 0.02117027f, 
    0.02346401f, -0.04116328f, 0.00692018f, -0.02269748f, -0.03633287f, -0.03277515f, -0.02336161f, 0.02663998f, 
    -0.01817542f, 0.00294693f, 0.02506698f, -0.02440006f, -0.00630069f, -0.01704706f, -0.03640185f, -0.01367712f, 
    -0.01037261f, -0.03582533f, 0.02628620f, -0.00213687f, -0.02856031f, -0.01857447f, -0.04075398f, -0.00303268f, 
    0.01943023f, -0.00000417f, -0.01017295f, -0.01928416f, -0.00830925f, -0.02708334f, -0.01605932f, -0.04348395f, 
    0.01264622f, 0.02130710f, -0.01027039f, 0.02343507f, 0.01168969f, -0.01637012f, 0.01704810f, -0.01603300f, 
    0.02480920f, -0.02190282f, -0.00677625f, 0.01615350f, 0.01254755f, 0.00229234f, -0.03115671f, 0.00564515f, 
    0.01077956f, -0.02565374f, -0.00115556f, -0.01851090f, -0.03141185f, -0.00589765f, -0.02052649f, 0.00258211f, 
    -0.01465513f, -0.02975833f, -0.00053083f, 0.00070326f, -0.04468485f, -0.01841632f, -0.00893198f, 0.01260231f, 
    0.01750750f, 0.01895179f, 0.00883929f, -0.02836780f, 0.00853343f, -0.02686073f, 0.02298187f, 0.01380780f, 
    0.01339041f, -0.00097637f, -0.03820597f, 0.00939626f, -0.01889570f, -0.02216977f, -0.01828297f, -0.00040701f, 
    -0.02459776f, -0.01060143f, -0.03128252f, -0.02301010f, 0.01261370f, 0.01375328f, 0.00655539f, 0.00783316f, 
    -0.03242174f, -0.00593347f, -0.00106200f, -0.00584857f, -0.01482800f, 0.01562461f, 0.02961891f, 0.01324530f, 
    0.03419976f, 0.00893452f, -0.03684683f, -0.03155661f, 0.02831667f, -0.02964714f, -0.04047922f, 0.01868458f, 
    0.02462147f, 0.00556669f, 0.02803058f, 0.02209286f, 0.01364790f, 0.02577426f, 0.01486947f, 0.01646252f, 
    -0.04096888f, -0.03599610f, -0.02467782f, -0.02346946f, -0.01792603f, 0.03290066f, 0.01568796f, 0.02884116f, 
    -0.04590116f, 0.00435077f, 0.01782629f, 0.02179690f, -0.00008938f, -0.03215203f, 0.01254477f, 0.02530675f, 
    0.03445957f, -0.01209618f, -0.03814257f, -0.02995285f, -0.00553548f, 0.00049287f, 0.00187152f, 0.01567139f, 
    0.03097160f, 0.00644694f, -0.03475807f, -0.01946014f, 0.01910819f, -0.03199974f, -0.00800984f, 0.02103894f, 
    -0.01216759f, -0.01648906f, 0.02219850f, -0.04105988f, -0.03848249f, -0.01636242f, -0.03157660f, -0.02227238f, 
    0.02220226f, 0.00481214f, -0.01352231f, -0.00615427f, -0.01380859f, 0.00186904f, -0.03273654f, -0.01150438f, 
    0.03169624f, 0.02845507f, 0.00905403f, -0.03535174f, 0.01559590f, -0.03212447f, -0.03129179f, -0.04468593f, 
    -0.02123125f, 0.01862716f, 0.01459850f, 0.02473609f, 0.01868976f, -0.00321821f, 0.00975991f, -0.02939640f, 
    0.02164840f, 0.02256497f, 0.01514508f, 0.02238348f, -0.03341669f, -0.03509045f, -0.03661150f, -0.00440968f, 
    -0.00435579f, -0.01167405f, -0.00210564f, 0.02224728f, -0.02773958f, -0.03149105f, 0.00011179f, 0.03234546f, 
    -0.01525722f, 0.01201936f, 0.00229458f, 0.00089819f, -0.00254031f, -0.03550002f, -0.00977434f, 0.01655220f, 
    -0.00972200f, -0.01388497f, -0.03165591f, 0.01825724f, 0.03019017f, -0.02747857f, -0.04410409f, -0.03643448f, 
    0.02047976f, -0.01473445f, -0.02530535f, -0.00960453f, -0.02719704f, -0.01297714f, -0.00365513f, -0.02933061f, 
    0.00091003f, -0.03233529f, -0.03180563f, -0.03874814f, 0.00035840f, 0.02717192f, -0.00355570f, 0.02096506f, 
    -0.02079860f, -0.01427957f, -0.00534385f, -0.00391243f, -0.03958096f, -0.01274079f, 0.00797049f, 0.01239814f, 
    0.03072970f, -0.03608431f, 0.03025788f, -0.02208656f, -0.03339196f, -0.00460138f, -0.02239929f, -0.00066327f, 
    0.03267537f, 0.00407485f, -0.01123162f, -0.02187032f, -0.00628821f, -0.01995379f, -0.00527773f, -0.01475204f, 
    -0.01115544f, 0.00794507f, 0.00550892f, 0.02428924f, -0.00754192f, -0.01483139f, -0.01505076f, -0.02842718f, 
    0.03096925f, -0.01417876f, 0.01986379f, -0.00715438f, 0.01622317f, -0.01106011f, -0.00685825f, -0.01834054f, 
    0.01478722f, -0.02473062f, -0.03434429f, -0.01425054f, -0.01018437f, -0.03632091f, -0.00972953f, -0.02594392f, 
    0.00037536f, -0.03158024f, 0.00879530f, 0.01655468f, -0.04071324f, 0.01246691f, -0.03520101f, 0.02393215f, 
    0.01416311f, 0.02669317f, 0.01022883f, -0.00777496f, -0.01818641f, -0.00465617f, 0.01600231f, 0.01689595f, 
    0.03654703f, -0.01129208f, -0.00528587f, -0.03405391f, 0.01172897f, -0.00048414f, 0.00551428f, 0.03192063f, 
    0.01022395f, -0.01043276f, 0.01711197f, -0.03440057f, -0.02911614f, -0.03242743f, -0.02613349f, 0.02231080f, 
    -0.03435677f, -0.01639128f, 0.02695316f, -0.03246384f, -0.01451440f, 0.00552141f, -0.01051814f, -0.00868437f, 
    -0.01498626f, -0.03868202f, 0.00069204f, -0.02413436f, 0.00600882f, 0.02351412f, 0.00701703f, -0.01027587f, 
    -0.02345042f, -0.01476324f, -0.03233955f, 0.02419376f, -0.02863099f, -0.02273512f, 0.03427942f, -0.03008000f, 
    -0.02223321f, -0.00162782f, -0.00083213f, -0.03950572f, 0.04064294f, -0.01040733f, 0.00438923f, 0.02774506f, 
    -0.02244893f, 0.01684690f, -0.03787844f, -0.00244092f, 0.02524443f, 0.01333408f, 0.03338173f, -0.00317831f, 
    0.03200518f, -0.02659942f, -0.00095364f, -0.02148226f, 0.01068939f, 0.01215873f, -0.05152653f, -0.02915954f, 
    0.00917279f, 0.01607085f, 0.00485982f, -0.00195635f, 0.00224871f, 0.00297809f, -0.03834269f, 0.01137400f, 
    0.02163577f, 0.01270096f, -0.00893161f, -0.02873576f, -0.04911870f, -0.03614848f, 0.00897163f, -0.01129399f, 
    0.01703521f, 0.03523961f, -0.03538192f, -0.01958847f, 0.01433844f, -0.01852821f, -0.02364529f, -0.00290533f, 
    -0.03385393f, -0.03669340f, 0.01673994f, -0.02684550f, 0.03343123f, 0.01984522f, -0.04617354f, 0.01264149f, 
    -0.01508974f, 0.01636321f, -0.00733824f, -0.02519174f, 0.02834604f, -0.03185574f, -0.03892010f, -0.02428415f, 
    -0.01113218f, -0.00296811f, 0.01108949f, 0.03111935f, -0.01096674f, -0.00927039f, -0.03044833f, -0.03354632f, 
    -0.02020691f, -0.02292006f, 0.01184563f, -0.01056119f, -0.02276076f, 0.02774139f, -0.02241481f, -0.03529081f, 
    0.02930142f, -0.00264891f, 0.02053606f, -0.00161532f, 0.03055871f, -0.02148028f, -0.00469795f, 0.01723508f, 
    0.02263794f, 0.00412311f, 0.03502808f, -0.00270885f, -0.03141634f, 0.02463324f, 0.01599370f, 0.02014908f, 
    -0.00311083f, 0.00466666f, -0.01249433f, -0.00826540f, 0.00247408f, 0.00668886f, -0.03337056f, -0.02641249f, 
    -0.03698153f, -0.04500247f, -0.03677763f, -0.02083865f, -0.01888609f, 0.04190804f, -0.03380509f, 0.02773000f, 
    0.01868297f, -0.00121334f, -0.01193899f, -0.00411527f, 0.01395874f, 0.02137132f, -0.03140005f, -0.02530297f, 
    -0.01806591f, -0.00991211f, -0.02764851f, -0.00907054f, -0.01330042f, -0.00360335f, 0.01473152f, 0.01229746f, 
    -0.02967818f, -0.02706562f, -0.02417363f, 0.02437712f, 0.03402901f, -0.02470424f, -0.04369001f, -0.01320144f, 
    -0.01316511f, 0.02472508f, 0.03108381f, 0.02128286f, -0.01915842f, 0.00086323f, 0.01408660f, -0.04406937f, 
    -0.01714546f, -0.02915833f, -0.01348502f, -0.00157277f, -0.00871277f, -0.02950110f, -0.01042426f, -0.02818688f, 
    -0.04285152f, 0.02323123f, -0.00589253f, 0.02556545f, -0.01775539f, 0.03154707f, -0.00165083f, 0.03358920f, 
    -0.01551436f, -0.03865848f, -0.02576353f, -0.01495040f, 0.02519840f, -0.02653847f, -0.01162552f, 0.00101484f, 
    -0.01931422f, 0.01402683f, -0.01457898f, 0.00121113f, -0.01120228f, -0.02358950f, 0.01422227f, -0.01766519f, 
    -0.00730757f, 0.01438706f, -0.03538114f, -0.00979413f, -0.00974485f, -0.01477473f, 0.01120520f, 0.02774142f, 
    0.00526985f, -0.02796132f, -0.00057164f, 0.01955772f, -0.01226013f, 0.03101769f, 0.02602416f, 0.03759827f, 
    0.02148044f, 0.01334283f, -0.02379675f, 0.00092527f, -0.02297854f, -0.02271571f, 0.02399603f, 0.00736490f, 
    -0.03830212f, 0.00856642f, 0.01434144f, -0.01500285f, -0.02807597f, -0.01039666f, -0.02837415f, -0.02938546f, 
    0.00319942f, -0.02221449f, 0.00546380f, 0.03673520f, -0.01556197f, -0.02829226f, -0.03805340f, -0.01601725f, 
    -0.02499859f, -0.03314391f, -0.00833821f, -0.03331424f, 0.01475609f, -0.03506961f, -0.02772927f, -0.03309139f, 
    0.00823462f, -0.01437405f, 0.00235248f, 0.01511330f, -0.03704530f, 0.02722306f, -0.01533340f, -0.00027431f, 
    -0.02543008f, 0.03551400f, -0.02953419f, 0.01993529f, 0.01094823f, -0.01181836f, -0.03486129f, -0.00322725f, 
    -0.00389476f, -0.01549864f, -0.02994197f, 0.01819122f, -0.01146616f, 0.01135946f, 0.01499087f, 0.01483379f, 
    -0.03511914f, 0.00607903f, 0.00462189f, -0.00337004f, -0.02127913f, -0.00323394f, -0.00379910f, -0.03098085f, 
    0.00414622f, -0.02882551f, -0.02215539f, 0.00162875f, 0.00761549f, 0.01600619f, 0.00916897f, 0.02186867f, 
    0.00075922f, 0.01181596f, -0.01124495f, -0.00643891f, 0.00363724f, -0.00919420f, -0.03903892f, -0.00952766f, 
    -0.03180993f, -0.01144373f, 0.00964869f, -0.03780052f, -0.00864912f, -0.02121271f, 0.01065789f, -0.00859203f, 
    0.01491931f, 0.01237950f, -0.01364306f, 0.01158614f, -0.03759859f, -0.01303223f, -0.01778463f, -0.04792198f, 
    -0.00693483f, -0.01711949f, 0.00564830f, -0.03121106f, -0.01375051f, -0.02821712f, 0.00387564f, -0.03194453f, 
    0.02567733f, -0.01792660f, 0.01997682f, 0.03003359f, -0.00152911f, 0.03018443f, 0.02053904f, 0.00852809f, 
    0.03264488f, 0.02033735f, -0.03798597f, -0.03564831f, -0.02899876f, 0.01468782f, 0.03919363f, 0.00672107f, 
    0.02062870f, -0.01430739f, 0.01580399f, 0.00346907f, 0.03442027f, 0.01694071f, 0.03731194f, 0.02596638f, 
    0.00950975f, 0.02480904f, -0.03428309f, 0.01853688f, -0.03205157f, 0.01260259f, -0.02892520f, -0.02853085f, 
    -0.01203592f, -0.01701581f, 0.00963715f, -0.02085427f, -0.03292133f, -0.02489802f, 0.00318492f, -0.00506736f, 
    -0.02127375f, 0.01683778f, -0.02046810f, 0.02015176f, 0.02417894f, 0.02016919f, -0.00158542f, -0.02222591f, 
    -0.03078428f, 0.02128461f, 0.01291040f, 0.02920549f, 0.00324848f, -0.02925193f, -0.00790415f, 0.00673835f, 
    -0.01933802f, -0.01537726f, 0.03377497f, -0.03029141f, 0.01554732f, -0.02847216f, 0.01530427f, -0.02289516f, 
    -0.02599295f, 0.01215028f, -0.00489832f, 0.01216287f, -0.02583219f, -0.00711688f, -0.02332970f, -0.00157503f, 
    0.00387817f, 0.01238309f, -0.03672121f, -0.01904621f, -0.01179798f, 0.03761918f, -0.03195029f, -0.01496696f, 
    -0.02165335f, -0.04175257f, -0.02627988f, 0.01548041f, 0.02574660f, 0.00411343f, 0.00580580f, -0.02350301f, 
    0.02997753f, -0.01093694f, -0.02814959f, -0.00744898f, -0.02969234f, 0.01531943f, -0.04265866f, 0.00932395f, 
    -0.02146010f, 0.00672301f, -0.03575721f, -0.01073756f, -0.02614215f, -0.01333029f, 0.01090800f, 0.02249094f, 
    -0.01893769f, -0.02946369f, 0.00958071f, -0.02409284f, 0.02786174f, -0.00343435f, -0.00881648f, -0.03393181f, 
    -0.03305478f, -0.03169699f, 0.01261639f, 0.02274287f, -0.03523832f, -0.01628205f, -0.00243106f, -0.01569596f, 
    -0.04591361f, -0.04681924f, -0.02497814f, -0.01389668f, -0.02585120f, -0.00792049f, -0.00308016f, -0.01247249f, 
    0.03280621f, 0.01373267f, 0.01310752f, 0.01005034f, 0.01101165f, -0.03236064f, 0.01496667f, 0.00853328f, 
    0.01950870f, 0.02004148f, -0.02641505f, -0.00483594f, -0.00543089f, 0.02467116f, -0.04450058f, 0.00931577f, 
    -0.03361516f, 0.00605076f, 0.02289245f, 0.03185504f, 0.02529350f, 0.01195801f, -0.01328047f, -0.00938402f, 
    -0.03280231f, 0.01192262f, -0.00684548f, -0.01263218f, -0.00362090f, -0.02278819f, -0.00143019f, 0.02038744f, 
    -0.02398259f, 0.02897167f, -0.02903181f, 0.01451289f, -0.00271208f, -0.00611068f, -0.00492231f, -0.01773489f, 
    0.14723501f, -0.32938221f, -0.06773574f, -0.01768332f, -0.04736143f, 0.08342981f, -0.13578235f, 0.09640267f, 
    -0.00837087f, -0.00174831f, -0.24727876f, 0.13349335f, 0.16102725f, -0.02583555f, 0.05535319f, -0.05435045f, 
    0.13261363f, 0.09091037f, -0.06970678f, 0.07119517f, 0.02918462f, -0.01106602f, 0.02341643f, -0.01628984f, 
    -0.13422069f, 0.00630951f, -0.14444634f, 0.11680216f, -0.01990293f, -0.04061092f, 0.01633074f, -0.03425249f, 
    0.23340847f, 0.01021466f, 0.18156965f, 0.05909506f, -0.06398432f, 0.01233168f, -0.08391817f, 0.06652179f, 
    -0.03242238f, 0.05460429f, 0.14434840f, -0.09974964f, 0.02541647f, 0.09021380f, -0.18678519f, -0.07970020f, 
    0.23441999f, -0.07570773f, 0.06193593f, 0.10935801f, 0.09205379f, 0.11390758f, 0.01144163f, 0.14883338f, 
    0.02828343f, -0.04836366f, -0.07696969f, 0.05633629f, 0.06008581f, 0.25298283f, 0.03412527f, -0.39469290f, 
    0.06073887f, -0.05228238f, 0.03026622f, 0.05872941f, 0.02349204f, -0.00138806f, 0.10051402f, -0.07002829f, 
    0.10984657f, 0.00765249f, 0.32784799f, 0.18443066f, 0.04815265f, -0.01719618f, 0.00057328f, 0.04846419f, 
    -0.19214407f, -0.14837648f, -0.09863343f, 0.02924563f, -0.04081067f, 0.15808873f, -0.05049245f, 0.01254157f, 
    0.13306633f, 0.08429611f, 0.07772230f, -0.04010192f, -0.06612168f, -0.05808598f, 0.13362402f, 0.03237715f, 
    0.14256631f, 0.05444525f, -0.09421120f, -0.01749005f, 0.11572745f, -0.00017321f, 0.00798015f, 0.02641603f, 
    0.00269835f, -0.08905625f, -0.05487601f, 0.02177234f, -0.49404004f, 0.04611473f, 0.07236276f, 0.18070915f, 
    0.16696714f, 0.16154577f, -0.10709431f, -0.03486546f, -0.02647539f, 0.05584710f, -0.03118530f, -0.04374878f, 
    -0.43734396f, 0.09831152f, 0.05259280f, 0.16355664f, 0.15212461f, -0.11599239f, 0.03555352f, 0.02021740f, 
    -0.09108456f, -0.09605229f, -0.03576873f, -0.03458029f, 0.11991877f, 0.07735791f, 0.11542067f, 0.03843741f, 
    0.08963859f, -0.04266518f, -0.12125941f, -0.05315528f, 0.24028006f, -0.06781872f, 0.08123238f, 0.28595918f, 
    0.21141766f, 0.31463626f, 0.17171465f, -0.07795443f, -0.00749478f, -0.26990473f, -0.02414375f, -0.09309807f, 
    -0.04164692f, 0.06127312f, -0.10820964f, 0.04050214f, 0.20918135f, -0.01266340f, 0.04172970f, 0.02171928f, 
    0.00337650f, -0.03006766f, 0.19311018f, 0.01542753f, -0.16433854f, 0.06789407f, 0.11239175f, -0.01753395f, 
    0.04617701f, -0.00318041f, 0.00806247f, -0.00752008f, 0.03896133f, 0.06745644f, -0.00933751f, -0.03390516f, 
    0.10634796f, -0.04320883f, -0.07428209f, 0.00371882f, 0.20062539f, 0.08955071f, -0.05706542f, -0.10093775f, 
    0.19825844f, 0.14438960f, -0.08836217f, 0.15148646f, -0.16683488f, -0.17783587f, -0.07258258f, -0.12883511f, 
    -0.16006356f, 0.06616151f, 0.27081734f, -0.53614736f, 0.01218170f, 0.10483943f, -0.24362437f, -0.14851667f, 
    0.03015801f, 0.18445566f, 0.04350331f, -0.07353908f, -0.03898655f, -0.14120018f, 0.04615368f, 0.11902611f, 
    0.09100137f, 0.08768968f, 0.10801947f, 0.16761820f, 0.20421340f, 0.16999806f, 0.10428824f, 0.13125071f, 
    -0.21463624f, 0.25909072f, -0.20235787f, -0.15605287f, 0.11545719f, -0.12925899f, 0.17161374f, -0.03109481f, 
    -0.13777027f, 0.07336970f, -0.10526504f, -0.04378178f, 0.06538206f, -0.06777585f, -0.00506483f, 0.17766000f, 
    0.03960775f, 0.04134649f, -0.11973213f, -0.17066678f, -0.12806866f, -0.06913841f, -0.19493796f, -0.00259816f, 
    -0.48522466f, -0.04612546f, 0.16532043f, 0.15191194f, -0.07294910f, -0.12159853f, -0.03378317f, 0.04108272f, 
    -0.00965300f, -0.06915163f, -0.08041970f, 0.06248136f, -0.22396502f, 0.01245585f, -0.01451240f, 0.11372784f, 
    -0.08377984f, 0.04320010f, 0.13569707f, 0.05614686f, -0.06748185f, 0.11978837f, 0.04539832f, -0.02550887f, 
    0.19329521f, -0.01581907f, -0.01693596f, -0.02833250f, 0.11493902f, 0.09313084f, 0.00340446f, 0.06445708f, 
    -0.01094431f, 0.11025295f, 0.11071341f, 0.18503082f, 0.32878819f, 0.37557155f, -0.07365604f, -0.35451844f, 
    0.11119072f, 0.09517998f, -0.08423477f, 0.11775665f, -0.18763758f, 0.03208883f, -0.08930650f, -0.14451365f, 
    0.13123763f, -0.19263412f, -0.11622722f, 0.02366544f, -0.00474260f, 0.09843149f, 0.06187296f, -0.00268038f, 
    -0.03978368f, 0.01362760f, -0.09883033f, -0.05871647f, 0.26014933f, 0.03417674f, -0.18047461f, -0.04945360f, 
    0.11583165f, -0.06614813f, 0.02303230f, -0.02940527f, -0.26278248f, 0.00672377f, -0.10813796f, -0.21983391f, 
    -0.66749835f, -0.27252185f, -0.38044778f, 0.16422354f, -0.19884595f, -0.01678231f, -0.02618999f, 0.04365195f, 
    -0.05148766f, 0.03255980f, 0.09714752f, 0.11057587f, -0.15172175f, -0.13658386f, -0.24132359f, 0.05726767f, 
    0.06985097f, -0.03664019f, -0.06392306f, 0.06658957f, 0.00556655f, 0.05381279f, 0.13651620f, 0.16127875f, 
    -0.55741030f, 0.20861138f, -0.04507951f, 0.12804329f, 0.11623696f, -0.19043872f, 0.01605345f, -0.00949716f, 
    -0.07212733f, 0.08343395f, 0.04923728f, -0.09265323f, 0.33341435f, 0.12977251f, -0.09652773f, -0.12418078f, 
    0.30683962f, 0.16570739f, -0.01790238f, 0.08675897f, -0.01468239f, -0.11967856f, 0.07939368f, 0.01687571f, 
    0.01955432f, -0.01145379f, 0.14156772f, -0.30975157f, 0.08381440f, 0.03880887f, -0.00681393f, -0.13594295f, 
    0.07328286f, -0.14590842f, 0.00354853f, 0.01574906f, -0.04259531f, 0.03191168f, 0.35510615f, -0.33081368f, 
    -0.19797468f, 0.06728262f, -0.09448149f, -0.03707658f, -0.00391450f, -0.09987820f, -0.04286735f, -0.50157398f, 
    -0.07879437f, -0.05513572f, 0.36261657f, 0.17246041f, 0.03702216f, -0.04973264f, -0.07051103f, -0.12130053f, 
    -0.10573563f, -0.05911668f, -0.21684308f, 0.00728180f, 0.15170471f, 0.01277891f, -0.20828640f, -0.00382267f, 
    0.01532905f, 0.06459913f, 0.17491987f, 0.14225253f, 0.03688806f, 0.26380330f, 0.02806350f, 0.14084320f, 
    0.31002131f, -0.02445588f, 0.01898314f, 0.11007529f, 0.05875309f, 0.06136890f, 0.06298400f, 0.06383345f, 
    0.03776379f, -0.02172837f, -0.06481358f, 0.09069178f, 0.70985317f, 0.14819716f, -0.06163748f, -0.27949819f, 
    0.21729115f, 0.09068205f, -0.00838707f, 0.03581689f, -0.01064550f, 0.00509984f, 0.11439212f, 0.03100822f, 
    -0.81590229f, 0.11275496f, 0.00583151f, 0.07582566f, -0.03547794f, -0.17925519f, -0.04543142f, -0.18256691f, 
    -0.06581917f, -0.05524756f, 0.09967215f, 0.03822801f, 0.11449793f, 0.10794029f, -0.07914720f, 0.15759578f, 
    -0.03002832f, -0.10082804f, -0.17266220f, -0.00444959f, -0.14346448f, -0.23512295f, 0.18477066f, -0.13197573f, 
    0.04250961f, 0.01107826f, -0.06351122f, 0.13239621f, 0.11425225f, 0.03321818f, 0.01063551f, 0.10665610f, 
    -0.05371260f, 0.03396872f, 0.06915886f, 0.13404272f, 0.40447178f, 0.50287259f, -0.32023567f, -0.22266178f, 
    0.11543747f, -0.06735099f, 0.13056205f, -0.19512375f, -0.13015293f, -0.01475208f, 0.06667997f, 0.09855264f, 
    0.03943377f, -0.29549474f, -0.01568000f, -0.05118170f, 0.05741556f, 0.17497271f, 0.09515017f, 0.01169024f, 
    0.28857893f, -0.08899232f, -0.08326795f, -0.01924241f, -0.36045724f, -0.13119824f, 0.10915866f, 0.09348132f, 
    0.01296685f, -0.14308445f, -0.02210468f, 0.10397615f, -0.04602019f, -0.00239053f, 0.09025885f, -0.15265533f, 
    0.15095404f, 0.08276960f, -0.09654704f, 0.19488914f, 0.09260540f, 0.04499789f, 0.00913899f, -0.04846700f, 
    -0.07526556f, 0.10575087f, -0.09753951f, -0.04381995f, 0.02964865f, -0.20582569f, -0.11391567f, 0.10822368f, 
    0.14652824f, 0.02964518f, 0.01403159f, -0.17689379f, 0.02395270f, -0.06298432f, 0.08271773f, -0.04081120f, 
    0.18627667f, 0.08589336f, 0.00835397f, -0.22587687f, -0.15269892f, -0.00654177f, 0.02131436f, -0.20894946f, 
    -0.08738435f, 0.04841803f, -0.06974765f, 0.07131121f, -0.16959083f, 0.32608387f, 0.28946230f, 0.13267928f, 
    0.15601347f, 0.08972797f, 0.01506902f, -0.10014302f, -0.04521727f, -0.16207598f, -0.02012442f, -0.01736087f, 
    -0.10614525f, -0.11494482f, -0.14443009f, 0.08379956f, -0.01972303f, 0.03015702f, -0.01493487f, 0.02275850f, 
    0.03506707f, -0.02224805f, -0.06732274f, 0.09722450f, 0.07476711f, -0.05065287f, 0.03160965f, 0.04048421f, 
    0.09671967f, -0.01263536f, 0.02714228f, 0.11141305f, -0.06947614f, 0.07921697f, 0.03667520f, 0.07256234f, 
    0.11897922f, -0.10943167f, -0.01417125f, -0.32117626f, 0.05446588f, 0.02048135f, -0.03901891f, -0.22742142f, 
    0.05296023f, -0.11692716f, -0.12117407f, 0.03627064f, 0.44276372f, 0.08643768f, -0.07854588f, -0.05611246f, 
    0.09717175f, 0.11776391f, 0.24091287f, 0.11665292f, 0.05930972f, 0.03904495f, 0.03423896f, 0.23485391f, 
    -0.29348150f, 0.25585729f, 0.11177491f, 0.10824919f, -0.07857373f, -0.11005524f, -0.12498181f, -0.02083294f, 
    0.04169125f, -0.12023091f, 0.09567708f, 0.09207895f, -0.13124886f, 0.08489835f, 0.09814435f, 0.12144997f, 
    0.03826176f, 0.16933498f, -0.06135578f, 0.23432291f, 0.24833934f, 0.02470257f, -0.05734175f, 0.07872041f, 
    0.26031065f, -0.04968180f, 0.29429856f, -0.11733671f, -0.04372168f, 0.06286024f, -0.04650092f, -0.11818439f, 
    -0.03527557f, -0.07975053f, -0.17115748f, -0.14187956f, 0.12524670f, -0.05580880f, 0.03656605f, -0.04295067f, 
    -0.13017616f, 0.01740597f, 0.01353725f, -0.22744241f, -0.07149791f, -0.01345653f, 0.07468666f, -0.04767045f, 
    0.04557102f, 0.00350480f, 0.12832876f, 0.06528147f, 0.17432830f, -0.01236837f, 0.11540305f, 0.02225541f, 
    -0.06176294f, 0.13770765f, 0.04675524f, 0.23538768f, 0.14238225f, 0.28958473f, -0.06467904f, 0.10338393f, 
    0.03638408f, 0.08442608f, 0.14175464f, 0.07921137f, -0.05912019f, -0.19985572f, 0.05403765f, 0.13334452f, 
    0.13518827f, -0.03996212f, -0.08863672f, 0.22587435f, -0.10928287f, -0.07495911f, -0.09868228f, -0.07985154f, 
    0.21739917f, 0.06687725f, -0.05742496f, 0.14023659f, 0.42364493f, -0.04590316f, -0.14948621f, -0.14763765f, 
    0.12022841f, -0.03483160f, 0.19244407f, 0.07615893f, 0.06588786f, -0.07174543f, 0.02703275f, 0.08891310f, 
    0.14801815f, 0.12972091f, -0.00113783f, -0.07596797f, 0.05772905f, 0.10715009f, 0.10936627f, -0.13363867f, 
    -0.05718590f, 0.00818625f, -0.10310076f, -0.08628730f, -0.26707697f, -0.12704654f, 0.09486853f, -0.09669859f, 
    -0.23388366f, 0.09038983f, -0.26751491f, 0.02981965f, -0.07849144f, -0.06615611f, -0.16554523f, -0.04402741f, 
    0.03309705f, 0.08877263f, -0.05289818f, 0.08745207f, 0.05668027f, 0.01308764f, 0.05652732f, 0.09736314f, 
    -0.08350398f, -0.08002580f, -0.00477259f, -0.00297361f, -0.18643399f, 0.10032839f, -0.07803648f, 0.08431962f, 
    0.02054677f, -0.12628119f, 0.09803978f, -0.23142326f, -0.05129796f, -0.13785769f, -0.10052281f, -0.14338692f, 
    -0.22227974f, 0.16125256f, -0.10818423f, 0.05225920f, 0.13982072f, -0.05474745f, -0.11121216f, -0.17083491f, 
    -0.21396868f, -0.06414959f, -0.08309166f, -0.15380323f, -0.15107973f, -0.12210859f, 0.04825793f, 0.11740854f, 
    -0.02234147f, 0.05236569f, -0.07561918f, -0.01601128f, 0.10758350f, -0.09505910f, -0.15426908f, 0.01962614f, 
    -0.00702096f, -0.03567810f, -0.00888780f, -0.02171044f, -0.01855933f, 0.00499948f, -0.00560081f, 0.01544840f, 
    -0.02458304f, 0.02281060f, -0.03897896f, -0.01510643f, -0.02113508f, 0.01968381f, 0.01779349f, 0.01278288f, 
    -0.01380791f, -0.02924633f, -0.03145613f, -0.00395264f, -0.00988115f, -0.00866104f, 0.00010655f, -0.02309069f, 
    -0.04052858f, -0.01799191f, 0.02188097f, 0.01164303f, -0.01389603f, -0.00070932f, 0.01924655f, 0.02204387f, 
    0.00592881f, -0.02505422f, -0.00170808f, 0.02171458f, -0.00622635f, 0.01603374f, -0.01467982f, 0.02064588f, 
    -0.00914944f, -0.01000882f, 0.00717573f, 0.01072439f, -0.01661634f, 0.00605801f, -0.03041500f, 0.00905013f, 
    0.01222067f, 0.01676159f, 0.00267417f, -0.00466791f, -0.00568314f, -0.02430058f, -0.00118494f, 0.00254527f, 
    -0.02796647f, 0.02140407f, -0.01307835f, -0.03540397f, 0.02349934f, -0.00877806f, 0.01136607f, -0.03591640f, 
    0.01042645f, -0.03567918f, 0.00113820f, 0.01603440f, 0.01310738f, 0.01494684f, -0.03434705f, 0.00225642f, 
    0.02331709f, -0.01069937f, -0.02391275f, -0.01418371f, -0.03239155f, 0.01310970f, 0.01047034f, 0.01624339f, 
    0.01081556f, 0.01212760f, -0.01295217f, -0.02467602f, 0.00475792f, -0.01570151f, 0.00019032f, -0.02567486f, 
    -0.01930116f, -0.02345021f, -0.01111043f, -0.03999460f, 0.00682738f, -0.01014057f, 0.00429907f, 0.02692411f, 
    -0.03378213f, -0.01081986f, 0.01143858f, 0.00104387f, 0.01184185f, -0.00931063f, -0.01135320f, -0.02065087f, 
    0.02056254f, -0.00078120f, 0.00664533f, 0.02654779f, 0.00878121f, -0.01225583f, -0.00323762f, 0.02749825f, 
    -0.01571356f, 0.00561741f, -0.00302960f, -0.03028850f, -0.01228155f, -0.01719873f, 0.00426035f, -0.04088482f, 
    -0.03002865f, -0.00914287f, -0.01103746f, -0.00751253f, 0.01038578f, -0.00008620f, 0.02670609f, 0.01068989f, 
    -0.02653118f, 0.01965712f, -0.00322011f, -0.01485211f, 0.01504598f, -0.01361927f, -0.02276568f, -0.03057925f, 
    -0.01700207f, 0.01616004f, -0.02531071f, -0.00183812f, 0.01532039f, -0.03775581f, 0.00073859f, 0.01635079f, 
    -0.00264448f, -0.00201032f, -0.03971199f, 0.01007391f, -0.02658617f, -0.01990888f, 0.00557885f, -0.04304428f, 
    -0.00033272f, -0.03613168f, -0.03674444f, -0.00863285f, -0.02927435f, -0.02380841f, -0.03614651f, -0.02314745f, 
    0.00064309f, -0.01588987f, 0.01273364f, 0.00769802f, -0.01977269f, 0.00848845f, -0.04003017f, 0.00657447f, 
    -0.03106786f, -0.01939165f, 0.01524097f, -0.03921358f, 0.00599160f, -0.00799172f, -0.02278225f, 0.01073605f, 
    -0.01600356f, 0.00531756f, -0.01016218f, -0.00652555f, -0.01304269f, 0.02649125f, 0.00139162f, -0.01470965f, 
    -0.02735228f, 0.00777777f, -0.00117427f, -0.00464106f, 0.00850615f, 0.00126288f, -0.01853386f, -0.03651487f, 
    -0.03739704f, 0.02720447f, -0.00538235f, -0.03054469f, 0.02771275f, -0.02944468f, -0.02214206f, -0.00971881f, 
    -0.00570670f, -0.02966276f, 0.00119077f, -0.03696422f, 0.02721472f, 0.02227613f, 0.02833848f, -0.01483930f, 
    -0.04283756f, -0.02754509f, 0.00896773f, 0.01383454f, -0.03279596f, -0.02528536f, -0.03724457f, -0.01454607f, 
    0.00673001f, -0.03316613f, -0.00121277f, 0.00518547f, 0.02176812f, 0.01530724f, -0.01015436f, -0.02679990f, 
    0.02577732f, 0.00903398f, 0.02388864f, -0.00957561f, 0.02096313f, -0.00827999f, 0.01332876f, -0.00313449f, 
    0.01226464f, -0.00554114f, 0.02913357f, 0.02159364f, 0.00485530f, 0.01944478f, -0.02809711f, -0.00294703f, 
    -0.03654643f, 0.02854491f, -0.03464615f, -0.00631388f, 0.02173075f, 0.00480258f, -0.00423675f, 0.01120515f, 
    -0.00960936f, -0.01096895f, -0.03295257f, -0.02210025f, 0.02073209f, -0.02718782f, -0.02372609f, -0.01384561f, 
    0.02070051f, 0.01246787f, -0.01208566f, 0.00784351f, -0.03946337f, -0.01036144f, 0.02738262f, 0.00164360f, 
    -0.00343090f, 0.00125917f, -0.03773741f, 0.02074127f, -0.03020588f, 0.02823087f, -0.03946250f, -0.00152833f, 
    -0.02989732f, -0.01678245f, -0.01822472f, -0.02331613f, -0.00316600f, -0.03244825f, -0.03282655f, -0.01334828f, 
    -0.02225947f, -0.01055481f, 0.01362556f, -0.01005278f, -0.01164537f, 0.02752818f, -0.03239775f, -0.00435599f, 
    -0.02279977f, 0.01993715f, 0.02348117f, 0.00667002f, -0.01972550f, -0.01313639f, -0.03719189f, 0.02496849f, 
    -0.02200773f, 0.02730555f, -0.03298267f, -0.02494399f, -0.01123766f, 0.00770564f, -0.03505543f, -0.00089155f, 
    0.01292167f, -0.00565406f, -0.00159371f, -0.00468086f, -0.03536317f, 0.01144105f, -0.01771501f, 0.01586600f, 
    -0.01894232f, -0.00052623f, -0.02381724f, -0.01572611f, 0.02928668f, -0.01882147f, -0.00362630f, 0.00559086f, 
    0.00272132f, -0.03611814f, -0.03035370f, -0.03808942f, -0.01290338f, 0.00860917f, 0.02275831f, -0.01124619f, 
    -0.00497377f, -0.03256003f, -0.03798129f, -0.01149786f, -0.04583053f, -0.04067718f, -0.00261743f, -0.03732725f, 
    0.01385604f, 0.02327917f, 0.00064062f, 0.02061298f, -0.00489020f, 0.01186047f, 0.01359579f, 0.00538491f, 
    0.00998077f, 0.00260101f, -0.03015443f, -0.03794293f, -0.01197650f, -0.02093830f, 0.02092498f, 0.01921948f, 
    -0.04246753f, 0.01913949f, 0.01192513f, -0.01392068f, -0.00468888f, 0.01141953f, 0.01137007f, -0.01751763f, 
    -0.03316625f, -0.01764189f, -0.02529891f, 0.01073010f, 0.01314556f, -0.00816086f, -0.01791835f, 0.02317396f, 
    -0.01820482f, 0.02754969f, -0.01493476f, -0.04066036f, -0.03397919f, -0.02731485f, -0.02945214f, -0.00099082f, 
    -0.00942261f, -0.04016789f, -0.04167939f, 0.01663924f, -0.01223183f, -0.02042931f, -0.03955017f, -0.00118806f, 
    -0.00958210f, -0.03709688f, 0.02516433f, -0.01954916f, 0.01790339f, 0.02659933f, 0.01849658f, 0.00973663f, 
    -0.00986655f, -0.02776965f, 0.02702861f, 0.01626021f, 0.02398130f, -0.01257835f, -0.01213469f, 0.01471408f, 
    0.01534452f, -0.01201691f, -0.00396962f, -0.01239437f, -0.00786259f, -0.03234299f, 0.00900074f, -0.02322501f, 
    0.02448863f, -0.00142331f, -0.03057090f, 0.02093595f, -0.03531940f, 0.01977545f, -0.01233242f, -0.02979539f, 
    0.01915551f, -0.03470049f, -0.00542557f, 0.00832393f, -0.03233969f, 0.01535599f, -0.03459227f, -0.01338293f, 
    -0.03432448f, -0.02488052f, 0.01466283f, 0.01871700f, -0.04330761f, -0.01076381f, 0.02772890f, 0.01147745f, 
    -0.00069620f, 0.00264264f, -0.00105012f, 0.00080194f, 0.00045217f, 0.00533001f, 0.00535037f, -0.00725645f, 
    -0.00869065f, -0.00174621f, -0.02238995f, -0.01654775f, 0.00903021f, -0.04053174f, -0.01642759f, 0.00214551f, 
    0.00707916f, -0.02380446f, -0.04139224f, 0.02061915f, -0.00687654f, 0.02040638f, -0.01205918f, 0.01998147f, 
    0.00957443f, -0.00729907f, -0.01133835f, -0.03081285f, -0.03351334f, -0.03356551f, 0.01671353f, -0.03234640f, 
    -0.01997756f, 0.02492316f, -0.04300302f, 0.00250120f, -0.03847868f, 0.02569594f, -0.03055829f, -0.01091530f, 
    -0.01681129f, 0.00225103f, -0.03352866f, -0.02145180f, 0.02513515f, 0.01309083f, 0.00734311f, -0.00352008f, 
    0.01635110f, -0.02629039f, 0.02849749f, 0.01445487f, -0.02305347f, -0.02368919f, 0.00184479f, -0.03220367f, 
    0.02186449f, -0.00160741f, -0.01806520f, 0.02509524f, -0.00003027f, -0.03905937f, -0.03174913f, -0.03803013f, 
    -0.04031917f, -0.02156401f, -0.03427990f, -0.02304745f, 0.02502426f, 0.01919444f, -0.03635613f, 0.00042623f, 
    -0.03396730f, 0.00767461f, -0.03516981f, 0.01819853f, 0.00699154f, -0.02625538f, -0.00753613f, -0.00157937f, 
    -0.02749556f, -0.01716546f, -0.03747109f, 0.00997019f, 0.01451665f, -0.03456937f, 0.00693747f, -0.01880462f, 
    0.01805147f, -0.04156981f, -0.02388647f, 0.01758751f, -0.00007972f, 0.00367142f, 0.01262410f, -0.01116519f, 
    0.01306889f, -0.00744860f, -0.03168385f, 0.02135379f, 0.00276749f, -0.01880920f, -0.00228110f, -0.02661629f, 
    -0.01734581f, 0.01011863f, -0.03113021f, -0.02031948f, -0.02613963f, -0.00738396f, -0.01777942f, 0.00612100f, 
    -0.00296979f, 0.01680543f, -0.01269074f, -0.02341787f, -0.02823348f, 0.01828966f, 0.00621920f, -0.01758910f, 
    -0.00291897f, 0.01635952f, 0.00747823f, 0.00865649f, 0.02756311f, 0.00510014f, 0.00458986f, -0.02670925f, 
    0.02616468f, -0.02595856f, 0.01660928f, -0.02483378f, -0.02581695f, -0.00047558f, -0.02551027f, -0.04263321f, 
    0.00080722f, -0.04416124f, 0.02174012f, 0.01464078f, 0.02489959f, 0.02246095f, 0.01320231f, 0.01177221f, 
    -0.02542628f, -0.03616015f, -0.02693098f, 0.01971690f, 0.00328782f, -0.03730456f, 0.02347823f, 0.01956599f, 
    -0.00900060f, -0.00156471f, 0.02506454f, 0.00810568f, -0.01832158f, -0.02680830f, 0.00871322f, -0.04228025f, 
    -0.03803838f, -0.00838345f, -0.02307541f, -0.00391989f, 0.01505822f, -0.02027690f, 0.02779538f, -0.02313149f, 
    0.02773124f, -0.01442208f, 0.01441638f, 0.01429176f, -0.04346863f, -0.00704331f, -0.00864512f, -0.02150272f, 
    -0.03654159f, 0.01640260f, 0.02627445f, 0.00796445f, -0.03870123f, -0.00404526f, -0.02981092f, 0.02346500f, 
    0.00313752f, 0.02484998f, -0.00337446f, 0.01831031f, -0.03028091f, -0.02806077f, -0.01996270f, -0.02880459f, 
    -0.02074542f, -0.00900582f, -0.01272143f, -0.03487479f, -0.04281368f, 0.01128198f, -0.03444909f, -0.01956043f, 
    0.02545711f, 0.00216066f, 0.00124014f, 0.01990869f, -0.01555059f, -0.03559816f, -0.03372072f, -0.00261338f, 
    -0.01318957f, -0.01928217f, -0.00309354f, -0.03906209f, -0.00627766f, 0.00266704f, -0.04206290f, 0.02168493f, 
    0.02332829f, -0.00346683f, 0.01856767f, 0.02803454f, 0.02467532f, -0.03524494f, -0.01072697f, 0.01421923f, 
    -0.02820657f, 0.02189283f, -0.02974205f, -0.00527302f, -0.00020234f, 0.00324368f, 0.01021684f, 0.01322045f, 
    -0.01454940f, 0.00619114f, 0.00276162f, 0.00218476f, 0.02028847f, -0.00301212f, 0.00495654f, 0.00080651f, 
    0.02694978f, 0.02858560f, 0.01422778f, 0.00008351f, 0.00774402f, -0.00376411f, 0.02914522f, -0.02637442f, 
    -0.03115252f, 0.02238037f, 0.00859732f, -0.02351903f, -0.03290103f, 0.02365807f, -0.03753202f, 0.02306722f, 
    -0.00763085f, -0.00691647f, -0.03154068f, -0.00779053f, 0.01716157f, -0.01128273f, -0.00218072f, 0.02319406f, 
    -0.01329998f, -0.02165760f, 0.01216848f, -0.00484546f, -0.02147298f, -0.02721819f, -0.00699748f, 0.00554924f, 
    0.01626869f, -0.00427666f, -0.03380255f, -0.02063792f, -0.00101659f, -0.01881207f, -0.03004016f, -0.00392624f, 
    -0.02652161f, -0.00722024f, -0.01886939f, -0.02794381f, -0.03117772f, -0.02271930f, -0.01875861f, -0.01768117f, 
    -0.01047987f, 0.01911613f, 0.01297494f, 0.02737952f, -0.02410496f, -0.03101723f, -0.04077495f, 0.00416594f, 
    0.00014343f, -0.00839344f, 0.02600515f, -0.01008382f, -0.03910513f, 0.02804595f, -0.01585243f, 0.02846268f, 
    -0.01993234f, 0.02104245f, 0.00062846f, -0.01089599f, -0.01703824f, -0.03411888f, -0.01988863f, -0.01005524f, 
    0.01396013f, -0.00427395f, -0.03294573f, 0.01336352f, -0.01020688f, -0.00029204f, 0.01036426f, 0.01740453f, 
    -0.02251866f, 0.01201721f, 0.00863844f, -0.01645303f, -0.00785434f, -0.02059655f, 0.00677564f, -0.00405219f, 
    0.00812449f, 0.01939696f, 0.02788254f, -0.03620989f, 0.00974651f, -0.03695422f, -0.03488301f, -0.03407300f, 
    0.18880302f, 0.08051927f, 0.01491144f, 0.01482117f, -0.06287828f, -0.10071951f, -0.04836464f, -0.09550495f, 
    0.01001513f, 0.04999077f, 0.17948754f, -0.12198427f, -0.15649168f, 0.04694606f, 0.17366979f, 0.01945002f, 
    -0.02110682f, -0.01499948f, 0.08226573f, -0.03532138f, -0.00966305f, -0.02313904f, -0.09451392f, 0.10696013f, 
    0.16306736f, -0.00656832f, 0.03997955f, 0.06985556f, 0.04994373f, 0.00363612f, 0.00689810f, -0.06092278f, 
    -0.08952790f, -0.11466948f, -0.03682451f, 0.02103845f, 0.19211961f, 0.15692975f, 0.15543753f, -0.03478361f, 
    0.06650937f, 0.12376528f, -0.15518939f, 0.16947599f, -0.00961135f, -0.02990500f, -0.05863878f, -0.08520006f, 
    -0.18893938f, 0.04260610f, 0.07782529f, -0.00061585f, -0.07046824f, -0.02043531f, 0.06655665f, -0.04279397f, 
    0.01382540f, -0.06078855f, 0.06957512f, 0.06559459f, 0.08304140f, -0.02346469f, 0.20320165f, 0.19389571f, 
    -0.08559331f, -0.14259809f, -0.13817489f, -0.00630389f, -0.03581924f, 0.05055812f, -0.12245216f, 0.14151669f, 
    -0.31583297f, -0.18992501f, 0.02398672f, 0.06936739f, -0.02334844f, 0.14345798f, 0.01478227f, 0.12761086f, 
    -0.03175676f, 0.01059106f, 0.00358721f, -0.10895344f, 0.08256759f, -0.05147716f, 0.21992125f, -0.04764029f, 
    0.03511306f, 0.03235639f, -0.10464771f, 0.18938401f, 0.06440867f, 0.02850323f, -0.01582037f, 0.07725699f, 
    0.00112238f, 0.17697570f, 0.16524601f, 0.01187030f, 0.04130213f, 0.10743292f, 0.08726884f, 0.12004071f, 
    0.17069693f, 0.17743069f, 0.01637878f, 0.06190080f, -0.08862385f, 0.09593825f, -0.40738150f, 0.11426284f, 
    0.04805722f, 0.06426640f, 0.22994450f, 0.05097901f, 0.05950242f, -0.01377734f, -0.10622966f, -0.08153494f, 
    0.01406962f, -0.16014977f, 0.08444344f, 0.13532688f, 0.07910163f, 0.09379817f, 0.05439628f, 0.02029669f, 
    0.01658934f, -0.03885939f, -0.09813736f, -0.04113881f, 0.08645288f, 0.05162737f, 0.02814667f, -0.01270054f, 
    -0.01885181f, 0.08469047f, 0.10154085f, 0.03753877f, -0.00738723f, 0.02842120f, -0.17006868f, -0.03528115f, 
    0.03614601f, -0.48782960f, 0.33904940f, -0.05840532f, -0.01709448f, 0.28061062f, 0.00368162f, -0.08600413f, 
    0.03893760f, -0.02489778f, -0.07284705f, 0.03864104f, -0.13281216f, 0.19216961f, 0.01007482f, 0.15861957f, 
    -0.02558855f, 0.05508306f, -0.10209755f, 0.02066794f, 0.06252940f, -0.00678692f, 0.02607836f, 0.06248725f, 
    0.04120890f, 0.10309370f, 0.09459575f, -0.12166748f, -0.05975628f, -0.14209950f, 0.01706919f, 0.12424518f, 
    0.01112411f, -0.05273129f, 0.02977273f, -0.02425201f, -0.06095166f, 0.07519972f, 0.10222033f, 0.05174663f, 
    -0.10360907f, 0.04365827f, 0.12628941f, 0.00695704f, 0.16174382f, 0.06693359f, 0.05333119f, 0.13530415f, 
    0.05522064f, 0.09812341f, 0.07409860f, 0.24549450f, -0.20443994f, 0.01000622f, -0.02878457f, -0.02120880f, 
    -0.01873199f, -0.00815191f, -0.08312657f, -0.00600247f, 0.07971831f, 0.22001979f, -0.08462681f, -0.06651478f, 
    -0.01158042f, -0.00006119f, 0.09950475f, -0.01441485f, -0.22932741f, 0.01635381f, -0.02929134f, 0.01621304f, 
    0.38592276f, -0.23022096f, 0.20282492f, 0.05050420f, -0.03274237f, 0.06263182f, -0.20668103f, -0.01222946f, 
    0.09221090f, 0.05646980f, -0.01777942f, 0.08852459f, -0.08381939f, 0.09035988f, -0.03882038f, -0.10874102f, 
    0.01741701f, 0.04740553f, 0.04502088f, 0.13666514f, 0.08566222f, 0.05814288f, -0.02392418f, -0.02032138f, 
    -0.08050267f, -0.19798854f, -0.15640366f, 0.08428717f, 0.03141603f, 0.22216547f, 0.00210166f, 0.04300369f, 
    -0.02895670f, -0.06968285f, -0.06757510f, -0.16022734f, 0.38912967f, 0.09722462f, -0.03953671f, -0.19389066f, 
    0.14779115f, 0.18684588f, -0.06740597f, 0.01636739f, 0.03371299f, -0.08704179f, 0.03885671f, 0.10276226f, 
    -0.18109341f, 0.03080224f, -0.00161787f, 0.06262267f, -0.16955109f, -0.00157639f, -0.05639796f, 0.03996886f, 
    0.01225231f, -0.02353506f, -0.01302311f, -0.07342692f, -0.00047964f, -0.24717151f, 0.26537237f, 0.33424059f, 
    -0.14459251f, -0.02770669f, -0.08566127f, -0.00241661f, 0.11820390f, 0.16089226f, 0.05517075f, 0.05692292f, 
    0.03554580f, 0.13855106f, 0.10402421f, -0.15956868f, 0.00471985f, -0.03581268f, 0.09770105f, 0.04575369f, 
    0.11239519f, -0.00352834f, 0.07108515f, 0.02047633f, -0.06019122f, 0.05089009f, -0.02918841f, 0.08652964f, 
    -0.08037842f, 0.09197471f, -0.09989175f, 0.03865507f, 0.00956834f, -0.09046124f, 0.09551430f, -0.09526105f, 
    0.63768560f, 0.23399456f, -0.06772968f, -0.20439921f, 0.03790881f, 0.04577057f, -0.10352812f, -0.01870305f, 
    0.01459380f, -0.01054863f, -0.07430116f, -0.15282330f, 0.09804355f, 0.02828947f, 0.01817726f, -0.18474196f, 
    0.02657081f, -0.14306243f, -0.06809995f, -0.00612901f, 0.19408327f, -0.04503439f, -0.02460441f, 0.03538786f, 
    0.13050058f, -0.19208410f, 0.03740707f, -0.11340659f, 0.08244313f, 0.05612222f, 0.08774083f, -0.00399360f, 
    0.09725486f, -0.09820791f, -0.00573948f, -0.03829824f, -0.30036998f, 0.06872715f, 0.33453801f, 0.20765212f, 
    -0.12472694f, -0.05236120f, 0.01058579f, 0.08484384f, 0.01507603f, 0.03887014f, -0.00420761f, 0.11077905f, 
    -0.05755471f, 0.10590333f, 0.18948689f, -0.04453810f, -0.03138138f, 0.08276760f, 0.02951280f, 0.10536017f, 
    -0.01999825f, -0.01814882f, 0.01078644f, -0.01601004f, 0.00223092f, -0.16207729f, -0.20077856f, 0.16215293f, 
    0.07761093f, -0.00303812f, 0.07824644f, 0.00717142f, 0.07688542f, -0.07348228f, -0.02171655f, 0.06659467f, 
    -0.35028785f, -0.15210375f, -0.09451779f, 0.05533695f, -0.04449408f, 0.03013757f, 0.12935236f, 0.12664051f, 
    0.00751638f, -0.06657715f, 0.02033220f, -0.06640570f, 0.03387846f, -0.10337365f, 0.09173699f, -0.08589742f, 
    0.00389224f, -0.04388525f, -0.19822310f, -0.03246198f, 0.06597565f, -0.11681040f, 0.07029581f, 0.06144812f, 
    -0.27694613f, 0.07060525f, 0.09205145f, 0.06879175f, 0.02050332f, -0.02359556f, -0.05597101f, -0.01686274f, 
    0.15785095f, 0.00845488f, 0.03677658f, -0.01576449f, -0.48729241f, -0.06028157f, 0.08391474f, 0.08659989f, 
    -0.34054470f, -0.07108082f, -0.11171643f, -0.09308308f, 0.04265390f, 0.14923418f, -0.06591030f, 0.08451664f, 
    0.56927872f, 0.08930972f, 0.07242189f, -0.45993215f, -0.03094877f, -0.03219585f, -0.00713042f, 0.00853738f, 
    0.05334400f, 0.07300487f, -0.10860436f, -0.16769864f, -0.10288717f, -0.19381617f, -0.02631534f, -0.02534685f, 
    0.05911228f, -0.05222240f, -0.05407841f, -0.03880895f, 0.08801159f, -0.01550446f, -0.06481028f, 0.14003380f, 
    0.03109233f, -0.00274399f, 0.14542811f, -0.07361988f, 0.01750919f, 0.01095534f, -0.10566573f, 0.02098974f, 
    0.09317932f, -0.04117697f, -0.05496799f, -0.08936268f, -0.07162182f, -0.49214348f, 0.60618514f, -0.30829838f, 
    -0.06865840f, 0.09622686f, -0.28560334f, 0.25111714f, 0.22091682f, 0.00712754f, -0.14334027f, -0.08342467f, 
    0.12681510f, 0.31756422f, -0.19305229f, -0.14303553f, -0.04284541f, -0.05295993f, 0.00176638f, 0.14824440f, 
    -0.07551706f, 0.12966433f, 0.07857895f, -0.04275751f, 0.06551522f, -0.06304160f, -0.12636022f, -0.07710868f, 
    -0.00570659f, 0.09078287f, -0.11201045f, -0.08457159f, 0.04985973f, -0.11502182f, -0.09274118f, 0.01166205f, 
    -0.06003324f, 0.10159016f, 0.17820828f, 0.05304991f, -0.11309676f, 0.10434436f, 0.00827281f, 0.10328976f, 
    0.05099460f, -0.07623500f, 0.08148757f, -0.00992194f, 0.37553957f, 0.24548163f, 0.09152269f, -0.05253416f, 
    -0.08581539f, -0.06526475f, -0.00246789f, 0.02647258f, -0.02286081f, 0.04118500f, -0.09733496f, 0.06119400f, 
    0.29037741f, -0.13835381f, 0.22208300f, 0.25904384f, 0.07325689f, -0.06959398f, -0.04401219f, 0.02316887f, 
    0.00666681f, -0.04666486f, -0.04939258f, -0.09492514f, 0.00757852f, -0.22243491f, -0.23073258f, 0.04913494f, 
    -0.00378411f, -0.03155831f, 0.04744858f, 0.04062000f, 0.07126430f, -0.05085475f, -0.07746570f, -0.02464149f, 
    0.31344312f, 0.17811160f, 0.10192210f, -0.05283386f, 0.11554741f, 0.04241228f, -0.05071075f, -0.01299345f, 
    0.04478331f, 0.05950454f, 0.08510699f, -0.01217135f, -0.00206535f, 0.07844009f, 0.08832932f, 0.06500538f, 
    -0.05967100f, 0.05879311f, -0.06471051f, 0.01804713f, 0.02336675f, -0.07968987f, -0.02435576f, 0.02588535f, 
    0.04948555f, 0.21535762f, 0.13155453f, 0.32513034f, -0.05935293f, -0.04364714f, -0.09070281f, -0.04430522f, 
    0.16468517f, 0.04181091f, 0.02119472f, 0.03225151f, -0.42546374f, 0.08359054f, 0.20576592f, 0.09455140f, 
    -0.05673781f, 0.01344635f, -0.12289699f, 0.02132806f, 0.14863159f, -0.08524531f, -0.05152431f, -0.07316334f, 
    0.01489437f, -0.13591132f, -0.07321855f, 0.03137349f, 0.05153692f, 0.09526398f, -0.05675215f, -0.03111882f, 
    0.05566500f, -0.01684568f, 0.03990733f, -0.07623225f, 0.07059210f, 0.21782611f, -0.31001410f, 0.12365269f, 
    0.14145395f, 0.14613155f, 0.22793712f, -0.05766355f, -0.00878779f, -0.02874274f, 0.05798427f, -0.04450846f, 
    -0.55179673f, 0.01750256f, -0.10143643f, 0.05867008f, -0.06017910f, -0.03784066f, -0.02242951f, -0.01098718f, 
    0.03767117f, 0.02372884f, 0.08768151f, 0.02202439f, -0.27456009f, -0.04484546f, -0.01113774f, 0.02593226f, 
    -0.05155599f, -0.11740490f, 0.00894499f, 0.02434967f, 0.00846171f, 0.04547285f, -0.04832954f, 0.05570707f, 
    -0.05090427f, 0.02744603f, 0.15742089f, -0.05481933f, -0.11416376f, 0.04736108f, -0.15538822f, -0.05027913f, 
    0.02380288f, -0.09777209f, -0.01168623f, -0.13659614f, -0.04935136f, -0.18359423f, 0.16337264f, -0.04227680f, 
    0.09452306f, -0.10942992f, -0.06549180f, 0.06099482f, 0.14397347f, 0.03977950f, -0.10737970f, 0.04165069f, 
    -0.04568088f, 0.14049959f, 0.04136793f, 0.02580414f, -0.00243001f, -0.00402967f, 0.08007780f, -0.01273760f, 
    0.05511820f, -0.03084916f, -0.04512698f, -0.02401340f, -0.19151694f, 0.15047103f, 0.14377241f, 0.25803024f, 
    -0.00544442f, -0.09547237f, -0.03841288f, 0.07707857f, -0.01093012f, -0.00343982f, -0.04243733f, 0.07423046f, 
    -0.01214499f, 0.13661827f, 0.20200814f, 0.10730289f, -0.04505932f, -0.00344974f, -0.01312905f, 0.19583194f, 
    -0.03442581f, -0.13544594f, 0.04673529f, 0.03731942f, -0.08228701f, 0.03704806f, -0.29165617f, -0.02087980f, 
    0.06737982f, -0.03245642f, 0.10811573f, -0.12673172f, 0.03154376f, -0.01939431f, 0.02704326f, 0.04179013f, 
    0.07050097f, 0.05151214f, 0.16801797f, -0.05191457f, -0.02922090f, 0.05715268f, -0.03081469f, 0.07211807f, 
    0.14366867f, 0.02905630f, 0.08899353f, -0.05993073f, 0.17926654f, -0.06276684f, -0.04622410f, -0.09035964f, 
    -0.03364544f, -0.03457398f, 0.01698896f, -0.04541018f, 0.11548710f, 0.05753822f, 0.05266404f, 0.03297384f, 
    -0.06581517f, -0.22617970f, 0.25163329f, -0.10410296f, -0.15624739f, -0.02617373f, 0.06628481f, 0.03861557f, 
    0.01531317f, 0.01360267f, -0.13033843f, 0.01467253f, -0.01512199f, 0.15537830f, -0.12760715f, 0.03083742f, 
    -0.03745735f, -0.18697354f, -0.10463088f, 0.05839811f, 0.11054558f, 0.11323348f, 0.01618414f, -0.04958208f, 
    -0.03467420f, -0.01216808f, 0.02080980f, -0.03797778f, 0.02505239f, -0.03104587f, 0.02203487f, 0.02093988f, 
    -0.01424845f, -0.01401558f, 0.01135004f, -0.00146435f, -0.04259038f, 0.01328860f, -0.00445719f, 0.02610769f, 
    -0.01801942f, 0.00171348f, -0.03687338f, 0.01902552f, -0.02585232f, 0.01453214f, 0.02832615f, -0.01007553f, 
    -0.00266030f, 0.03051262f, -0.02054890f, 0.01908091f, 0.00825134f, -0.01352186f, -0.01272708f, -0.03332535f, 
    -0.01260435f, 0.01623802f, -0.01062444f, 0.00662152f, -0.01244397f, -0.02647530f, 0.00653499f, -0.01615632f, 
    -0.02047403f, -0.02429363f, -0.02443705f, -0.01075204f, -0.02862358f, -0.00365450f, -0.00414606f, -0.03907294f, 
    -0.01739372f, 0.00108470f, 0.02176417f, -0.01401440f, 0.00416347f, 0.02070263f, -0.01588356f, -0.02421502f, 
    -0.03387554f, -0.01991848f, -0.01715392f, -0.01242146f, 0.01938707f, 0.00682641f, 0.00040343f, -0.02350798f, 
    -0.00637158f, -0.03251594f, 0.02188434f, 0.00453341f, 0.00012721f, 0.01142194f, 0.00821754f, 0.02158882f, 
    -0.00813587f, -0.00746188f, -0.02053121f, -0.03194335f, 0.02444260f, -0.02731050f, 0.01086871f, 0.01558517f, 
    0.00140845f, -0.00911761f, -0.03232369f, -0.02576246f, -0.02331558f, -0.03032157f, -0.00433608f, -0.00818705f, 
    0.00941836f, -0.03907771f, 0.01615764f, -0.03123623f, -0.01770778f, -0.02657251f, -0.00538241f, 0.02967146f, 
    -0.04239393f, 0.02276986f, -0.01074900f, -0.00670808f, -0.03835717f, -0.04022072f, -0.02626667f, -0.03033722f, 
    -0.01078230f, -0.03917461f, 0.01135101f, -0.02309856f, -0.02862898f, 0.00235847f, -0.03606594f, 0.02639760f, 
    -0.04077740f, 0.02496159f, -0.03458548f, -0.03794646f, -0.02531839f, 0.01433728f, -0.01488537f, -0.01802202f, 
    -0.02639490f, -0.02878090f, 0.02284233f, 0.02792955f, -0.02704237f, 0.02418158f, 0.02250187f, 0.01351725f, 
    -0.01277859f, 0.03431692f, 0.01361427f, -0.01624853f, 0.02292867f, -0.01179223f, -0.00609999f, 0.02596089f, 
    0.00116368f, -0.02413454f, -0.02352500f, -0.00527507f, -0.04237384f, -0.04290458f, 0.01641192f, 0.02327180f, 
    0.00823884f, -0.01219964f, 0.02039876f, 0.01707192f, 0.00681741f, 0.01822159f, -0.00796037f, -0.02121967f, 
    -0.01830228f, 0.01202852f, -0.00157281f, 0.01823001f, 0.02148620f, -0.03693905f, -0.00051842f, -0.02711388f, 
    -0.01926525f, 0.02374173f, 0.00083067f, 0.01617926f, -0.02729102f, 0.02779303f, -0.01514850f, 0.02052408f, 
    0.01662339f, 0.02073042f, -0.01381778f, -0.02258046f, -0.02930282f, 0.01528750f, 0.00205528f, 0.00590726f, 
    -0.03044182f, -0.03002848f, 0.00618634f, 0.00122185f, 0.02307989f, 0.02684294f, -0.02259784f, 0.00899351f, 
    -0.02972137f, 0.01975603f, -0.00964329f, 0.01758864f, -0.02941140f, 0.01812679f, -0.01038782f, -0.02076261f, 
    0.00515339f, -0.00591230f, -0.03286402f, 0.01550884f, 0.01410187f, 0.03526839f, 0.03196963f, -0.01553500f, 
    0.01595906f, -0.01502525f, -0.01861235f, 0.00313677f, -0.00536466f, 0.00694913f, 0.00331659f, 0.03152642f, 
    -0.00137009f, -0.02675592f, -0.01053894f, 0.01775750f, -0.02489225f, -0.01779202f, -0.02710360f, -0.00891695f, 
    -0.02792524f, -0.01231948f, -0.03513941f, 0.01246174f, 0.01799643f, 0.01364425f, 0.00270995f, -0.00991859f, 
    -0.01796171f, 0.02744638f, -0.02240676f, -0.02914240f, -0.02695587f, 0.01853705f, 0.00003451f, 0.03507742f, 
    0.00623180f, 0.02697835f, -0.00772114f, -0.03559579f, 0.01077671f, 0.00490176f, -0.00953505f, -0.01456798f, 
    -0.00363242f, 0.04045521f, 0.01303351f, 0.00439547f, -0.02921012f, -0.02753037f, 0.01480390f, 0.01690518f, 
    0.01496271f, 0.00526467f, -0.00249827f, 0.02083816f, -0.03103234f, 0.00208418f, -0.02627569f, -0.04000899f, 
    -0.03918625f, 0.00135256f, -0.00842422f, -0.03884436f, -0.00424544f, 0.03085375f, -0.04263064f, 0.01353823f, 
    -0.00792596f, 0.01305950f, -0.03208025f, 0.00203201f, 0.00117798f, -0.00567411f, -0.02264605f, -0.00230761f, 
    0.00315528f, -0.00289481f, 0.01776994f, 0.00927677f, 0.03956761f, -0.00918201f, 0.00263610f, -0.03693831f, 
    -0.02375948f, -0.00738614f, 0.01745943f, 0.01586575f, -0.01485352f, 0.02976822f, 0.00670557f, 0.01384585f, 
    0.00259054f, 0.01202006f, -0.01064662f, -0.00673399f, -0.04130734f, 0.01663285f, 0.03445232f, -0.01954822f, 
    -0.03765092f, -0.00814182f, -0.04019915f, -0.02561783f, 0.03506204f, -0.02096070f, 0.01416059f, 0.00536162f, 
    -0.03186483f, -0.00075190f, -0.03959731f, 0.01711087f, -0.00375570f, -0.01005409f, -0.01466331f, 0.02800236f, 
    0.02754403f, -0.02737449f, -0.00916451f, -0.00819289f, 0.01514524f, 0.00243019f, -0.03033310f, 0.00930704f, 
    -0.02525031f, -0.01256253f, 0.03123382f, -0.02820673f, -0.00132797f, -0.02495373f, -0.00988102f, -0.03160653f, 
    -0.01183463f, 0.01187713f, -0.03308219f, -0.03756969f, 0.00043328f, -0.02318795f, 0.01122092f, -0.03493736f, 
    0.01105913f, -0.01618620f, 0.00656641f, -0.01152932f, 0.01233397f, -0.02887697f, -0.03452582f, 0.01937621f, 
    0.00961711f, 0.03120419f, -0.02373628f, -0.03215872f, -0.00636829f, -0.01294076f, -0.00754760f, -0.01287854f, 
    -0.00692917f, -0.02064935f, 0.01005335f, 0.01215735f, -0.02719867f, 0.01314387f, -0.01004686f, 0.00058931f, 
    0.00139848f, -0.03342960f, 0.00425435f, -0.03794098f, 0.01682202f, 0.00387148f, -0.01354187f, 0.02356801f, 
    -0.01804285f, -0.03502032f, -0.01453051f, -0.03922689f, 0.01136366f, -0.01741580f, -0.01713168f, -0.00272338f, 
    -0.00637606f, 0.01335933f, 0.01432900f, -0.01079065f, -0.03539531f, -0.01050105f, -0.00279480f, -0.00374066f, 
    0.02011370f, 0.01649807f, 0.02528342f, -0.00399960f, -0.00958884f, -0.02067940f, 0.02534142f, 0.02430332f, 
    -0.04025562f, -0.01105141f, 0.01519254f, -0.02241472f, -0.04030700f, 0.02588550f, 0.03698577f, 0.02134020f, 
    0.03983683f, 0.03486388f, 0.00967657f, -0.01687561f, -0.00898999f, -0.00639407f, -0.00656935f, 0.00735390f, 
    0.01959242f, 0.00108019f, -0.01928233f, -0.02703368f, -0.00513969f, 0.01065977f, -0.00234189f, 0.00499816f, 
    -0.03508431f, -0.02115240f, 0.01019381f, 0.02063466f, -0.02997409f, -0.02368828f, -0.03066168f, -0.03259572f, 
    0.01818361f, 0.01098043f, 0.01247499f, -0.02012084f, -0.01486648f, -0.01589396f, 0.01372158f, 0.00175763f, 
    -0.01653697f, 0.02398314f, 0.01490526f, -0.01876291f, -0.02241904f, -0.00306883f, 0.03452660f, -0.03351433f, 
    0.01953499f, -0.02591295f, 0.02533924f, -0.02557115f, 0.00740359f, -0.00066053f, 0.01923496f, -0.00544147f, 
    -0.01899725f, -0.00272812f, 0.02207083f, -0.02726967f, 0.00606119f, 0.01356630f, -0.03558620f, 0.00963756f, 
    0.02654187f, 0.02248159f, 0.01849196f, 0.02596637f, -0.00279987f, -0.03439787f, -0.01327330f, -0.03708572f, 
    0.01047294f, -0.01002026f, -0.01921118f, 0.02048578f, 0.02399690f, -0.02146813f, -0.02574898f, 0.00232190f, 
    0.00880698f, 0.00314323f, -0.02849777f, 0.00597998f, -0.00622564f, 0.01349855f, -0.04125136f, 0.00739031f, 
    -0.01457037f, -0.03890902f, 0.02123440f, -0.00236095f, -0.03032239f, -0.01451556f, -0.00999597f, 0.02704334f, 
    -0.00594539f, -0.04276959f, -0.01300459f, 0.01410035f, 0.02549016f, 0.01498914f, -0.00249212f, -0.01753649f, 
    -0.01593019f, -0.02487818f, 0.02738735f, -0.01715146f, -0.04046924f, -0.04000021f, -0.02480916f, -0.03473548f, 
    -0.03948865f, -0.03969648f, -0.02766378f, 0.00948348f, 0.01839750f, 0.01895841f, -0.03609982f, 0.00671751f, 
    -0.00296949f, -0.02649701f, 0.02081634f, -0.02921613f, -0.00836107f, 0.01704858f, -0.01807090f, 0.00345170f, 
    0.00942007f, 0.00218697f, 0.01737034f, 0.01296119f, 0.01348312f, 0.02191553f, -0.00843518f, -0.01223288f, 
    -0.00065723f, 0.00293472f, -0.01200888f, -0.02757026f, 0.01971434f, -0.01716263f, -0.00242613f, 0.01570560f, 
    0.03371098f, -0.02830327f, -0.01707706f, -0.00061053f, -0.00560880f, 0.02881562f, 0.00791639f, -0.02380009f, 
    -0.00498156f, 0.02799802f, -0.03302751f, -0.00343989f, 0.01577403f, -0.02585369f, -0.00188550f, -0.04113730f, 
    0.02452477f, 0.00204433f, -0.02561115f, 0.00107073f, -0.03360570f, -0.02471712f, 0.01343367f, -0.03007419f, 
    -0.02745935f, -0.02833621f, -0.00382980f, 0.02643161f, 0.01773186f, 0.00781615f, -0.00805685f, 0.00626687f, 
    0.01774381f, 0.00258937f, -0.01976009f, -0.00122738f, -0.04028801f, 0.00105220f, 0.02929659f, -0.00229271f, 
    0.03661199f, 0.02904345f, 0.02093643f, -0.00999023f, -0.02323036f, -0.01933496f, -0.01185371f, -0.00888763f, 
    -0.03316737f, -0.03331208f, -0.02203991f, -0.04065635f, 0.01125005f, -0.03280795f, -0.04007535f, -0.01020651f, 
    0.02600586f, -0.01843441f, 0.01271679f, -0.01487074f, -0.03777171f, 0.02316216f, -0.02803994f, -0.02711314f, 
    0.02033317f, -0.02520732f, -0.00901841f, 0.00793155f, 0.02305248f, -0.03154460f, 0.01756604f, -0.00683694f, 
    0.00761498f, -0.01788258f, -0.00706430f, 0.00495153f, 0.02345533f, -0.04091933f, -0.02369065f, -0.01651217f, 
    0.00051860f, 0.02170684f, 0.02894305f, -0.02002844f, 0.03061339f, 0.01011026f, -0.02641738f, 0.04108432f, 
    0.03489624f, 0.00613437f, 0.01624063f, -0.00807535f, 0.01331323f, 0.01057046f, -0.03704074f, -0.03950791f, 
    -0.01296985f, -0.00525858f, -0.02876839f, -0.01577252f, 0.03383074f, -0.01724993f, -0.02041519f, -0.03464187f, 
    -0.01577531f, -0.00876350f, -0.01724783f, -0.01039835f, 0.00450395f, 0.01484716f, 0.01494948f, -0.02677928f, 
    0.02078645f, -0.01051025f, -0.04134591f, -0.02522008f, -0.00243014f, -0.01926580f, -0.01558740f, -0.02876124f, 
    0.01703741f, -0.00656324f, 0.01721892f, 0.01974371f, 0.01239232f, -0.00352194f, -0.00275856f, -0.01145314f, 
    -0.02815388f, 0.01291137f, -0.03718490f, -0.02337780f, -0.03378416f, 0.00053563f, 0.00142114f, 0.01748218f, 
    0.00264905f, -0.00016671f, 0.02366872f, 0.01633786f, -0.02463784f, 0.01093210f, -0.01582623f, -0.03269313f, 
    0.01262596f, -0.00098883f, -0.02963945f, -0.03918011f, -0.02370635f, 0.01356041f, -0.00157103f, 0.01312371f, 
    -0.00425351f, -0.01937131f, 0.00669144f, -0.02571986f, -0.00495744f, -0.00194912f, 0.02212437f, 0.02706219f, 
    0.02200553f, 0.00830646f, -0.02119834f, 0.01454000f, -0.03117916f, 0.01459255f, 0.02598534f, -0.00105220f, 
    -0.01175784f, 0.01068149f, 0.00547015f, -0.02674180f, 0.00631358f, 0.02499425f, -0.02262940f, 0.03313736f, 
    0.00769916f, 0.01958238f, -0.03430991f, -0.02022494f, 0.00448354f, -0.03375283f, -0.04272322f, -0.02830248f, 
    0.00625553f, -0.02634230f, -0.02837490f, -0.00799060f, -0.02001294f, -0.00580765f, 0.00926970f, 0.02077668f, 
    -0.01704931f, 0.00191176f, 0.01097070f, 0.02221463f, -0.01220560f, 0.00816559f, -0.02764243f, 0.02117420f, 
    0.02328386f, -0.02668694f, -0.00667635f, -0.02309026f, -0.02205378f, -0.03882280f, -0.00261121f, -0.02182889f, 
    0.00341202f, 0.00097347f, -0.01329869f, 0.00489811f, 0.03644343f, -0.02925463f, -0.02655808f, 0.00454328f, 
    0.02708623f, 0.01439998f, -0.00419895f, -0.03848215f, -0.02884119f, 0.00532728f, -0.02758156f, 0.01601794f, 
    0.01355284f, 0.01945287f, -0.01979029f, -0.00416515f, 0.01536862f, 0.00553328f, -0.03210217f, 0.00807520f, 
    -0.14352143f, 0.36337057f, 0.03574178f, -0.03272665f, 0.10132831f, -0.10892345f, 0.09605511f, -0.08686136f, 
    -0.05513705f, 0.06164959f, 0.01155320f, 0.31209618f, -0.22229856f, -0.20179148f, -0.07718275f, 0.29705584f, 
    -0.17209956f, 0.07687316f, -0.05823731f, 0.06029493f, -0.14440861f, 0.04182109f, 0.12929276f, 0.10274386f, 
    0.14008029f, -0.00343250f, 0.05025028f, -0.05215974f, -0.06097085f, -0.00836168f, 0.08910984f, 0.07332874f, 
    0.25316089f, 0.16956717f, 0.14958748f, 0.08786483f, 0.07963862f, -0.06619240f, -0.11744368f, 0.29647145f, 
    0.16729201f, 0.09109730f, 0.01772816f, 0.09094885f, 0.10070258f, -0.05458797f, -0.18670578f, -0.07045139f, 
    -0.19433597f, 0.15442644f, 0.24905339f, 0.18385063f, 0.06044089f, -0.25394550f, 0.06782241f, 0.05029681f, 
    0.08504331f, -0.05010518f, -0.01125079f, 0.09216606f, -0.43039212f, -0.17267932f, 0.30696008f, 0.19005704f, 
    0.09809688f, 0.06040473f, 0.05628211f, -0.07853957f, 0.11280415f, 0.16340731f, 0.07078114f, 0.08158857f, 
    -0.04025145f, -0.16267021f, -0.08499572f, 0.23710537f, -0.05762502f, 0.30955896f, -0.05943477f, 0.10685763f, 
    -0.03058080f, -0.11867399f, 0.08229143f, -0.07422362f, -0.27919123f, -0.32066077f, 0.27037105f, 0.09483922f, 
    0.06848204f, 0.11985762f, 0.10179210f, 0.26319605f, -0.07496763f, 0.08774842f, 0.07323777f, -0.04389517f, 
    -0.37988985f, -0.05121933f, 0.12075596f, -0.02507121f, -0.13591734f, 0.08706122f, -0.07240558f, -0.20191702f, 
    -0.00491005f, 0.05321431f, 0.02446894f, -0.10115839f, 0.05949770f, -0.24033406f, 0.02431327f, 0.02696268f, 
    0.05627524f, 0.44546014f, 0.32089800f, 0.13101548f, 0.02111705f, -0.02273622f, -0.05232398f, -0.01909913f, 
    0.11225218f, -0.05255263f, -0.05593281f, -0.06983209f, 0.11371571f, 0.14211681f, 0.06493986f, 0.05175054f, 
    0.00923888f, -0.00361601f, -0.06240992f, -0.06668688f, -0.07989301f, 0.03432452f, 0.07821412f, 0.07836399f, 
    0.02010014f, -0.07145245f, -0.00629238f, 0.01576046f, 0.24135321f, 0.04056305f, 0.07927406f, 0.27536938f, 
    -0.32273242f, -0.19639947f, -0.11759476f, 0.47609279f, 0.20630839f, 0.24429809f, -0.00845894f, 0.02992497f, 
    0.01307136f, -0.05617948f, -0.09149643f, 0.04634041f, -0.17395821f, -0.15384978f, 0.01627467f, 0.11936904f, 
    -0.00517161f, 0.15281308f, 0.07384180f, 0.11186191f, 0.03728319f, 0.02754508f, 0.11014778f, -0.05757154f, 
    -0.10438451f, 0.00715235f, 0.13087392f, 0.21430290f, -0.06949731f, -0.00329135f, 0.13787147f, -0.06953331f, 
    0.09304519f, 0.02098719f, -0.04251052f, -0.01436956f, -0.18049203f, -0.10579380f, 0.25732505f, 0.00516159f, 
    0.15399180f, -0.13610351f, 0.03585478f, -0.13124576f, -0.03466718f, 0.00804717f, 0.00130291f, 0.00467635f, 
    -0.22829153f, -0.16680367f, -0.01878679f, 0.35624287f, 0.04905277f, -0.01402246f, -0.00862657f, 0.15623595f, 
    -0.08451550f, -0.12248889f, 0.06754299f, 0.22231895f, -0.04549983f, -0.01630372f, -0.02683547f, 0.06111057f, 
    0.10074735f, 0.03773782f, -0.09683946f, -0.16252123f, -0.07486697f, -0.02759672f, 0.02539078f, 0.01285537f, 
    -0.52783400f, 0.25109017f, 0.16412833f, -0.10123831f, 0.00818835f, -0.03045586f, -0.10973327f, 0.25322762f, 
    -0.08487061f, 0.10269863f, -0.16603878f, 0.05988773f, 0.10193767f, -0.08780567f, -0.23944612f, -0.17152528f, 
    0.05385144f, -0.06085170f, 0.06751679f, 0.02471020f, 0.06822962f, 0.02923495f, -0.02925100f, 0.07867151f, 
    -0.02501630f, -0.09850015f, -0.05672657f, 0.15816753f, 0.02014866f, 0.32092768f, 0.23301096f, 0.15682599f, 
    -0.03228269f, -0.01829830f, -0.03932239f, -0.05698994f, 0.09299304f, 0.24943338f, -0.02283614f, 0.07528963f, 
    -0.00334688f, 0.14376670f, 0.09569782f, 0.00239405f, 0.06241297f, -0.05701832f, 0.08833186f, -0.08211762f, 
    -0.39131150f, -0.16371883f, 0.29533088f, 0.29979590f, 0.02989559f, -0.02993858f, 0.02345248f, -0.02558234f, 
    0.00676962f, 0.04024506f, 0.06852061f, 0.07098304f, -0.48827711f, 0.07927628f, 0.24634160f, 0.22667906f, 
    -0.02726448f, -0.00521056f, -0.08000330f, 0.12633130f, -0.00329306f, 0.23954834f, 0.05460333f, 0.00039985f, 
    0.03490210f, 0.26501960f, 0.13503639f, 0.05221168f, -0.02960756f, -0.18151487f, 0.12742715f, 0.09253988f, 
    0.19670893f, -0.03186553f, -0.00571996f, -0.03039490f, -0.03885233f, -0.13045318f, -0.08896495f, -0.07059249f, 
    0.00515432f, 0.01105800f, -0.07067592f, 0.07186750f, -0.01754181f, -0.07074513f, -0.05585089f, -0.07233784f, 
    -0.05884012f, 0.63203955f, 0.21353363f, -0.00045570f, 0.04355004f, -0.06463908f, 0.07585844f, -0.03103450f, 
    0.08701410f, 0.09877258f, 0.14722729f, 0.04128608f, 0.13959561f, 0.14218724f, -0.11648696f, -0.02403018f, 
    0.03342034f, -0.04429612f, 0.07568240f, 0.06876615f, 0.08001292f, 0.21600273f, 0.16314818f, 0.26124740f, 
    0.08938676f, -0.01560171f, 0.01994665f, -0.03368635f, 0.11747075f, 0.12867120f, 0.08538380f, 0.16838154f, 
    0.06841303f, -0.06453007f, -0.09312565f, -0.03194404f, -0.47483858f, -0.41959876f, 0.09472329f, 0.12631577f, 
    0.07575922f, 0.10509475f, -0.04953344f, 0.06093551f, -0.00508941f, 0.04877904f, 0.02919036f, -0.00974997f, 
    -0.01877552f, -0.26932043f, -0.03464360f, 0.00940892f, -0.03614091f, -0.03917285f, 0.02951049f, -0.10612652f, 
    0.08124444f, 0.04864012f, 0.09879505f, -0.07316098f, 0.02433819f, -0.13107030f, -0.05067568f, -0.10723093f, 
    -0.11080854f, 0.09509821f, 0.05230946f, 0.03729177f, 0.04740371f, -0.05584281f, -0.03676081f, -0.10244970f, 
    0.06474309f, -0.22340947f, -0.21585655f, 0.04342494f, -0.00847763f, 0.04949779f, 0.08117399f, -0.00207755f, 
    -0.07366867f, -0.01595851f, -0.06098457f, 0.00625571f, -0.09248041f, 0.07093826f, 0.02467789f, -0.04257828f, 
    -0.03654484f, -0.01186625f, 0.15204243f, -0.02373165f, 0.02694807f, 0.08821508f, 0.22190893f, 0.33110958f, 
    -0.16265005f, 0.15244837f, 0.17261478f, 0.07429495f, -0.15127154f, -0.20386171f, 0.06172298f, 0.07359373f, 
    0.03428628f, 0.01071367f, 0.05527504f, 0.02660114f, -0.26984543f, -0.00299009f, 0.01034678f, 0.06595029f, 
    -0.06576224f, -0.03152205f, -0.06295824f, 0.07116136f, -0.04507524f, 0.04831176f, 0.04660947f, 0.08529014f, 
    -0.39702621f, -0.01220816f, -0.06833262f, 0.07868236f, 0.06596810f, -0.11252628f, 0.00659464f, 0.10227854f, 
    -0.00164783f, 0.07184694f, 0.14545730f, 0.26783961f, -0.12612613f, -0.09140420f, -0.05856027f, -0.03897808f, 
    0.01280026f, 0.00259134f, -0.00609527f, 0.06219445f, 0.12696534f, -0.08534822f, -0.01586843f, -0.25221026f, 
    -0.15402621f, 0.24067789f, 0.12743865f, 0.14225011f, -0.12044056f, -0.06459159f, 0.17275599f, 0.08448909f, 
    -0.08401109f, 0.01626743f, 0.17711408f, 0.13023569f, -0.72655314f, 0.18966143f, 0.10203622f, 0.27316087f, 
    0.40142444f, 0.01576434f, 0.01555490f, 0.21773782f, -0.05434475f, 0.07803922f, -0.06929132f, 0.07317062f, 
    0.11374819f, 0.12356662f, -0.04528937f, 0.12643984f, 0.15893894f, -0.16915189f, 0.06310807f, -0.05641994f, 
    0.09254337f, 0.05391146f, -0.10080309f, 0.00830037f, 0.09559377f, 0.03955369f, -0.11795174f, 0.03561736f, 
    -0.05244495f, 0.00122776f, 0.14682814f, 0.05670074f, 0.09367310f, -0.03817998f, -0.01187981f, -0.09836867f, 
    0.04139483f, -0.09665325f, -0.03331156f, -0.17174569f, -0.16196658f, -0.19958952f, -0.15596664f, 0.06669930f, 
    0.05596762f, 0.10748239f, -0.04707158f, -0.08349992f, -0.31749105f, 0.23994073f, 0.20951693f, 0.02033840f, 
    0.06052099f, -0.02816195f, -0.19927801f, -0.09817490f, 0.11990111f, -0.12641323f, 0.07312603f, 0.03119414f, 
    -0.33561051f, 0.24364138f, -0.09417849f, 0.15141560f, 0.14795560f, 0.05766262f, 0.00588450f, -0.00212567f, 
    -0.13074040f, 0.01214744f, 0.17185122f, 0.07739267f, 0.22308202f, -0.14968541f, 0.22103830f, -0.45347494f, 
    0.04037176f, 0.13529155f, 0.01825725f, -0.00633942f, -0.00693165f, -0.02517034f, 0.03906184f, -0.05434519f, 
    -0.07064056f, 0.36209497f, 0.20943238f, 0.04522998f, -0.01515436f, -0.14379585f, -0.02025077f, 0.03912767f, 
    -0.08379336f, 0.08293640f, 0.09538638f, 0.10555233f, -0.15526465f, 0.10484403f, 0.13072880f, 0.20503092f, 
    0.00009578f, -0.04870214f, 0.08032218f, 0.29054517f, 0.06120247f, 0.11875009f, 0.01198312f, 0.08839775f, 
    -0.37967086f, -0.02136800f, 0.30277821f, 0.17579120f, 0.09500456f, -0.07616591f, -0.01187486f, 0.01372953f, 
    0.11535480f, 0.01115194f, 0.08535869f, 0.16952425f, -0.41593313f, 0.05305744f, 0.05056187f, 0.07478365f, 
    -0.08885782f, -0.13162841f, 0.08384326f, 0.17437759f, 0.01472510f, -0.01715510f, 0.12785360f, 0.11203227f, 
    0.04697248f, -0.13708958f, -0.12247956f, -0.04147659f, -0.04110962f, 0.03229102f, 0.10654762f, 0.10178813f, 
    0.09515501f, 0.03244658f, -0.06768040f, -0.07984574f, 0.13482520f, -0.10815608f, -0.08329923f, 0.17866807f, 
    -0.00876858f, -0.09551184f, 0.02007451f, 0.01929138f, 0.11691213f, -0.01115716f, -0.00433298f, 0.07982010f, 
    -0.06007069f, -0.11403728f, -0.15779263f, 0.09057897f, -0.00330071f, -0.02775876f, -0.04234561f, 0.03925483f, 
    -0.06499095f, 0.13585921f, -0.07610380f, -0.07762349f, 0.02423245f, -0.05142353f, -0.09951284f, 0.06089831f, 
    0.10701890f, -0.04107087f, 0.00532471f, 0.05558886f, -0.06381553f, 0.06750783f, -0.05418255f, -0.06754567f, 
    -0.17123975f, -0.15326314f, -0.18195507f, 0.27152011f, -0.02559861f, -0.03129458f, 0.06507432f, 0.13590594f, 
    -0.01786660f, 0.05501965f, 0.06046383f, 0.02903344f, -0.20753999f, 0.03060510f, 0.13226303f, 0.22109394f, 
    0.10596795f, 0.17463654f, 0.05223829f, -0.05174582f, 0.10364199f, 0.00097724f, 0.00880222f, -0.20425709f, 
    0.14946008f, 0.18039532f, -0.02813551f, -0.02062071f, -0.00792761f, -0.09088586f, 0.08511424f, 0.04660714f, 
    0.20496055f, 0.12397388f, 0.20440525f, 0.16206449f, -0.23157093f, 0.00202681f, 0.11318075f, 0.21530819f, 
    -0.09688436f, -0.09854735f, 0.03089003f, -0.03535656f, 0.10509006f, -0.02262529f, 0.05220300f, -0.06050826f, 
    -0.04906296f, -0.03648574f, 0.10792475f, 0.24916096f, -0.07718930f, -0.07944445f, -0.20103443f, 0.20459665f, 
    -0.06960437f, 0.07231628f, 0.00299540f, -0.03745111f, 0.16411723f, -0.08226895f, -0.21671836f, 0.08640124f, 
    -0.06420574f, 0.02972577f, 0.10275970f, 0.03829722f, -0.02721042f, 0.14896727f, -0.08150008f, -0.06720682f, 
    -0.35792440f, -0.06664957f, 0.20317321f, 0.20881858f, 0.01399313f, 0.01856159f, -0.00093624f, -0.24455965f, 
    -0.03835084f, 0.05789708f, 0.16294217f, -0.18651997f, 0.18659906f, 0.04674461f, -0.03241817f, -0.00824670f, 
    0.04202315f, 0.02197750f, -0.00347154f, -0.00557589f, 0.15082818f, 0.04461896f, 0.04385251f, -0.01946943f, 
    0.04059653f, -0.03356242f, -0.08936229f, -0.05015812f, 0.03983675f, -0.08763368f, 0.04234768f, 0.06402736f, 
    0.03591494f, -0.03211091f, -0.00040302f, 0.04070134f, 0.22509259f, 0.11433049f, -0.14411969f, 0.02651267f, 
    0.15198749f, -0.10232209f, -0.01011473f, -0.02550924f, 0.20125535f, 0.16571747f, -0.05680811f, -0.02480958f, 
    0.06415123f, 0.16239923f, -0.04633799f, 0.04657562f, -0.09569950f, -0.00594815f, 0.01110129f, -0.09304094f, 
    0.10244746f, -0.03779151f, 0.00646483f, 0.04043764f, 0.12658754f, -0.09880386f, 0.17050134f, -0.09207988f, 
    0.06593005f, 0.05150229f, -0.01692409f, -0.03514427f, 0.00343246f, -0.04742014f, 0.02457786f, 0.22122191f, 
    -0.03454630f, -0.23093882f, -0.09361141f, -0.02420544f, 0.02827043f, 0.00865358f, 0.13598938f, -0.00447754f, 
    0.10317865f, 0.24612583f, 0.19511266f, 0.32493046f, 0.08109961f, -0.03499352f, -0.20052432f, -0.02643399f, 
    0.09720067f, 0.16770819f, -0.10818762f, -0.00917017f, -0.04596231f, 0.01321373f, -0.15524964f, -0.19547994f, 
    -0.21228269f, 0.02860379f, 0.08789337f, 0.03083719f, -0.13256191f, -0.05603018f, 0.03309219f, 0.02957991f, 
    0.03077889f, -0.01966949f, 0.07183979f, 0.11781267f, 0.02243186f, -0.02443022f, 0.24482897f, 0.22982353f, 
    -0.10130973f, -0.04866835f, 0.05803616f, 0.01722557f, 0.07388524f, 0.10379454f, -0.01646714f, -0.06216507f, 
    -0.10607079f, -0.18846622f, 0.07830334f, 0.10014163f, 0.16837512f, 0.07860848f, -0.09389079f, 0.03042756f, 
    -0.09898486f, -0.13338438f, -0.07085151f, -0.05094526f, 0.26477510f, -0.11155882f, 0.13831227f, -0.14641580f, 
    0.06777001f, 0.03371296f, -0.09712738f, 0.00561662f, -0.01899980f, 0.08605931f, 0.08658412f, 0.03184192f, 
    0.00811882f, 0.02890118f, -0.01303751f, -0.25820068f, -0.02231901f, 0.03304188f, -0.01509267f, -0.06043528f, 
    0.06282879f, 0.05259237f, 0.13276289f, 0.14788957f, -0.17040668f, 0.10843507f, -0.36806130f, 0.12214721f, 
    0.14350104f, 0.21292004f, 0.17703508f, 0.12751797f, -0.02109377f, -0.08745658f, -0.05183677f, -0.11863694f, 
    -0.06505089f, -0.16273159f, -0.01533400f, 0.07920908f, 0.33766806f, 0.12953316f, 0.12903044f, 0.09378158f, 
    -0.09412222f, -0.10824062f, -0.12061037f, -0.15301985f, 0.12663898f, 0.00109759f, 0.00243868f, -0.03353738f, 
    -0.05368941f, 0.00401867f, 0.00700146f, -0.10245688f, 0.26369280f, 0.25555918f, -0.00089553f, 0.44829127f, 
    0.34771729f, -0.39353994f, 0.25215846f, -0.02233433f, 0.09611083f, 0.08153333f, -0.05148193f, -0.17052715f, 
    0.06236659f, -0.02451032f, -0.07321781f, 0.07063796f, -0.02401421f, -0.01055924f, 0.12943982f, -0.08389758f, 
    -0.04031768f, 0.04589912f, -0.06411352f, -0.16569097f, 0.01212727f, -0.11483988f, 0.08826102f, -0.03785191f, 
    0.03357976f, 0.04594192f, 0.00687208f, -0.00437017f, -0.01009679f, 0.03036551f, -0.00570122f, -0.14754696f, 
    -0.01008583f, -0.14591871f, -0.02085974f, -0.15595829f, 0.03447450f, 0.02190765f, -0.12805691f, -0.26903358f, 
    0.04751501f, -0.16415776f, -0.01193585f, -0.06333960f, 0.03473733f, -0.06289800f, -0.02264862f, 0.03132714f, 
    0.26646352f, -0.14187619f, 0.09442493f, 0.23317233f, 0.04618918f, -0.04808560f, 0.06078435f, 0.15933265f, 
    -0.03501286f, 0.00402315f, 0.05664637f, 0.15148833f, 0.20716470f, 0.14092870f, -0.08198150f, 0.03846287f, 
    -0.02741703f, -0.03875228f, 0.06732403f, 0.08797704f, 0.22042431f, 0.08044492f, 0.09392550f, 0.07765660f, 
    0.00653621f, -0.38584509f, 0.10536101f, -0.09145278f, -0.00441288f, -0.08532749f, -0.09869169f, 0.09452537f, 
    0.05744178f, -0.04081500f, -0.18502237f, 0.01913397f, -0.06351236f, -0.08396780f, -0.03667467f, 0.01005546f, 
    0.23422225f, -0.07276320f, -0.00382009f, 0.01606641f, 0.04408155f, -0.05126871f, -0.08141056f, 0.05376872f, 
    -0.05290373f, -0.11819465f, -0.06948701f, 0.21013063f, 0.12263234f, 0.24018185f, 0.05959993f, 0.30227178f, 
    -0.06064713f, -0.15479343f, -0.09658158f, -0.01663850f, 0.08291299f, -0.04617466f, -0.12699699f, -0.10134753f, 
    0.09998573f, 0.05031909f, -0.02102216f, -0.10434392f, 0.08612129f, 0.03267401f, 0.16484325f, 0.20916845f, 
    -0.08999132f, -0.11045935f, 0.01767388f, 0.09960698f, -0.07462013f, -0.09161554f, 0.01046065f, -0.14073871f, 
    -0.06220134f, -0.05998807f, -0.05278348f, 0.05987165f, 0.40875709f, -0.33513877f, 0.26921681f, 0.38558406f, 
    -0.08231503f, -0.15330401f, -0.02065686f, 0.04627125f, -0.01276575f, 0.10190485f, 0.09709750f, -0.06394399f, 
    0.25302199f, 0.22492652f, 0.22178376f, 0.01890898f, 0.01337908f, -0.15605167f, 0.02532056f, -0.06430161f, 
    0.02942024f, -0.07475310f, -0.09506648f, -0.10776183f, -0.23562101f, 0.00196720f, -0.00667213f, 0.02108746f, 
    0.06437806f, -0.01168885f, -0.06349988f, 0.10251981f, -0.04244395f, -0.13461438f, -0.04208156f, -0.10448809f, 
    -0.11552106f, 0.29618162f, 0.03983547f, -0.08584569f, 0.05903592f, -0.02651292f, -0.01576513f, -0.02846674f, 
    0.06971931f, 0.01756652f, -0.03463263f, 0.08188683f, -0.05391285f, 0.12205985f, -0.17581491f, -0.08685664f, 
    0.01181862f, -0.00972808f, 0.05393907f, -0.00381138f, 0.11781438f, 0.20801759f, 0.10468470f, 0.15451653f, 
    -0.06885578f, -0.22260714f, -0.01838315f, -0.01665979f, 0.13970919f, 0.13683754f, 0.24562353f, 0.02663416f, 
    -0.01908441f, 0.03896536f, -0.13544942f, 0.00251206f, 0.12133452f, 0.01771265f, 0.26027569f, 0.01688024f, 
    -0.00666460f, -0.02482605f, -0.15395685f, -0.03893474f, 0.05292620f, -0.01310841f, -0.02173657f, -0.00854469f, 
    0.14307082f, 0.04816056f, -0.01407157f, 0.04987375f, 0.09937315f, 0.15057924f, -0.09119993f, -0.13473994f, 
    -0.01007527f, -0.14469923f, -0.03231082f, -0.07789946f, -0.04137656f, -0.13580638f, -0.03162017f, 0.08042479f, 
    -0.01189847f, 0.08738930f, 0.00047605f, 0.03367344f, -0.00039277f, -0.19712530f, -0.13213353f, -0.11905210f, 
    -0.18880513f, -0.15888229f, 0.00772027f, 0.08431852f, 0.16313723f, 0.07226922f, 0.11094837f, 0.03903408f, 
    -0.14138211f, -0.11769345f, -0.05170176f, -0.00499938f, -0.13718183f, -0.05356537f, -0.09293369f, -0.10628341f, 
    0.00893216f, -0.01374948f, 0.14775483f, 0.03213532f, 0.18088710f, 0.21841905f, 0.31520239f, 0.34791929f, 
    -0.07335205f, 0.08164535f, 0.06466407f, 0.06158824f, -0.02868618f, -0.04245737f, 0.00490374f, -0.02057678f, 
    0.01710533f, -0.03434800f, 0.16287303f, 0.17147218f, 0.12900931f, -0.24140055f, 0.12571624f, -0.01141792f, 
    -0.12457031f, -0.17287809f, 0.02531341f, -0.02890321f, 0.02564868f, -0.04350616f, 0.18825656f, 0.05305099f, 
    -0.25927454f, -0.22353089f, -0.15817879f, -0.27684191f, -0.06349790f, -0.13481694f, -0.00304159f, 0.07191209f, 
    -0.12421534f, -0.08499045f, -0.01991902f, -0.00144463f, -0.17684312f, -0.22308376f, -0.25821379f, 0.00351830f, 
    0.10262720f, 0.04539103f, -0.01313822f, 0.08596009f, 0.09837846f, -0.00000521f, 0.02790731f, 0.07285177f, 
    0.01619169f, 0.15966681f, 0.07921609f, 0.05003643f, 0.04775716f, -0.02998042f, -0.04320608f, -0.00911280f, 
    0.01813418f, 0.14019859f, 0.12720183f, 0.22892430f, 0.10886978f, -0.57675093f, 0.12475239f, 0.01050789f, 
    0.00452759f, -0.00775779f, -0.16281210f, 0.02751657f, -0.07318785f, -0.04743519f, -0.17168652f, -0.03128691f, 
    0.35210264f, 0.26090112f, -0.23732519f, -0.11904976f, 0.00753745f, -0.08306786f, 0.06689963f, 0.01038807f, 
    0.21007952f, 0.04290694f, -0.11913938f, -0.07461767f, -0.12096046f, -0.11454792f, -0.03726667f, 0.00822666f, 
    0.02309535f, -0.07493854f, 0.02690103f, 0.15549982f, 0.00447171f, 0.02368310f, -0.05570435f, 0.02600921f, 
    0.13065782f, -0.02361112f, -0.05263376f, -0.12767518f, -0.00059165f, -0.11340482f, 0.00875256f, -0.14296940f, 
    -0.01209983f, -0.11505498f, -0.11297295f, -0.12458444f, 0.12649986f, 0.20334341f, 0.19180772f, 0.13175233f, 
    0.09224179f, -0.04850207f, -0.15815806f, -0.09437070f, -0.03237964f, -0.07422838f, -0.07690336f, 0.09717381f, 
    0.11738069f, -0.29854596f, 0.16202866f, 0.01593390f, 0.07760489f, -0.16841975f, -0.13025992f, 0.05686296f, 
    -0.01988194f, -0.03781448f, -0.04296951f, -0.03560386f, -0.24108632f, -0.32316160f, -0.10534135f, -0.13778311f, 
    0.14836791f, 0.09915118f, -0.02499901f, -0.00699843f, -0.08888627f, -0.11081468f, -0.07245641f, -0.00618832f, 
    0.14540832f, 0.31014973f, 0.24662045f, 0.03732835f, 0.02251440f, -0.00694888f, -0.09181254f, -0.04407500f, 
    -0.00932628f, 0.03977475f, 0.07172844f, 0.10548434f, 0.04994857f, -0.00410805f, -0.00463200f, -0.07172845f, 
    0.01760248f, -0.04546865f, -0.00749475f, 0.05021456f, -0.06901830f, -0.09577890f, -0.10573082f, 0.08341686f, 
    -0.06098197f, 0.15770122f, 0.28658181f, 0.31274131f, -0.05784432f, -0.05007379f, -0.14598304f, 0.01803931f, 
    0.05313914f, 0.02342842f, -0.02074780f, 0.03775233f, -0.34730327f, 0.09867251f, 0.17327744f, 0.25955459f, 
    -0.04513745f, 0.09465101f, 0.06403314f, 0.11066376f, 0.12581101f, -0.03116824f, 0.12166453f, 0.23578478f, 
    0.09057314f, -0.22759518f, -0.09426655f, 0.23980370f, 0.05449632f, -0.01675964f, 0.15133011f, 0.10267355f, 
    0.14184693f, 0.15814941f, 0.07819650f, 0.03594783f, 0.04981515f, 0.39375135f, -0.20408458f, 0.22818290f, 
    0.00000200f, 0.16525574f, -0.05860046f, -0.00396307f, 0.08668090f, 0.01677630f, 0.08649340f, 0.00523196f, 
    -0.01941208f, 0.02450836f, -0.13636935f, 0.12809825f, -0.01280879f, 0.03952092f, 0.12049652f, 0.08640998f, 
    0.02504497f, -0.10595497f, 0.03287143f, -0.07798585f, -0.06003123f, -0.06105525f, -0.13043746f, 0.08403244f, 
    0.05192964f, 0.01725112f, 0.09724567f, 0.11442763f, -0.02965640f, -0.03878175f, -0.05033334f, -0.01969308f, 
    0.16816218f, -0.15626308f, 0.12144395f, -0.10163419f, -0.00665546f, 0.05064229f, 0.04082483f, -0.00535626f, 
    0.00830179f, -0.01668498f, 0.02114138f, 0.21010971f, 0.04563808f, 0.04500168f, -0.11056620f, -0.08000623f, 
    0.00888874f, -0.02929138f, -0.01353765f, -0.12970214f, 0.01283215f, 0.08265303f, -0.00906461f, -0.01846043f, 
    -0.10198025f, -0.00014441f, -0.14545369f, 0.03640503f, 0.01624787f, -0.04356547f, 0.11871953f, 0.02563563f, 
    0.21671267f, 0.16830696f, 0.07921451f, 0.29815727f, 0.05939237f, -0.08628327f, -0.02381480f, -0.15532726f, 
    -0.04242660f, -0.05640184f, -0.22982852f, -0.13529624f, -0.07477494f, -0.04994981f, -0.05815334f, -0.01212799f, 
    0.25598752f, 0.05955314f, 0.29086301f, -0.06038426f, 0.06284498f, -0.05065024f, -0.20523416f, -0.05457243f, 
    -0.18039727f, -0.11925596f, -0.06855049f, -0.11601313f, 0.01664651f, -0.09867257f, -0.36478564f, 0.03858817f, 
    0.09970940f, 0.10188974f, 0.07724921f, -0.00389009f, 0.02742494f, -0.08824883f, -0.03876733f, 0.01402175f, 
    -0.05192899f, 0.06985971f, -0.04972427f, -0.06981601f, -0.01645109f, -0.05516410f, 0.13484000f, -0.20756626f, 
    -0.06543010f, 0.05974528f, 0.12045659f, 0.03167252f, 0.07127766f, 0.00080129f, -0.07487684f, -0.03284680f, 
    0.11501803f, 0.07323603f, 0.14584960f, -0.04321675f, 0.01407151f, 0.01190513f, 0.03175408f, 0.06977290f, 
    -0.07425005f, -0.13086042f, 0.06753983f, -0.01864684f, 0.13561301f, -0.06092199f, 0.00991018f, 0.00133083f, 
    -0.08302057f, -0.12088871f, -0.21749133f, 0.00148756f, 0.16100304f, 0.12861513f, -0.17413898f, 0.05822505f, 
    0.03488165f, -0.19387949f, -0.08957347f, -0.01478029f, 0.05910368f, 0.00307384f, -0.23059556f, 0.06150632f, 
    -0.01799338f, 0.01300754f, 0.04138471f, -0.02589791f, 0.01328646f, -0.02467773f, 0.01205582f, 0.03962519f, 
    0.00337334f, -0.00584343f, -0.00020844f, 0.01984667f, 0.01550013f, -0.00598531f, 0.00079139f, -0.03595058f, 
    0.02076741f, -0.00134263f, -0.03749280f, 0.01089466f, 0.02545433f, 0.00962735f, -0.00266732f, -0.02922900f, 
    -0.01544654f, -0.02715152f, 0.02380602f, -0.00899886f, -0.00877001f, -0.01565373f, -0.00030161f, -0.00734960f, 
    -0.02066187f, 0.00444723f, -0.02252680f, 0.00911956f, -0.00561180f, 0.01565491f, -0.04079579f, 0.01970512f, 
    0.01876121f, -0.03271015f, 0.00086858f, -0.00043639f, 0.00785946f, -0.02955559f, 0.00035708f, -0.00176537f, 
    0.01235556f, 0.01844219f, -0.00309711f, 0.02518384f, 0.01573989f, -0.02235431f, 0.02642906f, 0.01778152f, 
    -0.01182326f, -0.00286972f, 0.02192818f, 0.02421909f, 0.00062668f, 0.02865646f, -0.00092548f, 0.02641580f, 
    -0.01960628f, -0.02667271f, -0.02863019f, 0.01017832f, -0.03006089f, -0.02418127f, 0.00892397f, -0.01158511f, 
    -0.00217127f, -0.01481517f, -0.00774295f, -0.04196111f, -0.03562152f, -0.02347868f, -0.00107311f, -0.03487422f, 
    -0.02365651f, -0.01029676f, 0.00883233f, -0.02466420f, -0.02162472f, 0.02133400f, 0.02299740f, 0.00593362f, 
    -0.00703386f, -0.04191049f, -0.01229991f, -0.02385544f, -0.00754277f, 0.00553558f, 0.01062158f, 0.00900654f, 
    -0.03350304f, -0.03967041f, -0.03566393f, -0.02138613f, 0.01908760f, -0.01872774f, -0.03089273f, -0.02944841f, 
    -0.00938220f, 0.00517671f, 0.02205946f, 0.01669230f, -0.01732637f, -0.02306261f, 0.00912904f, 0.01422066f, 
    0.00719867f, -0.03019257f, -0.01447388f, -0.02684459f, -0.02805710f, 0.02243503f, -0.00852606f, 0.02668927f, 
    0.02704195f, -0.03566689f, -0.00647227f, -0.02846487f, 0.00191393f, -0.00070950f, -0.00614044f, 0.00190757f, 
    -0.02058968f, -0.02830341f, 0.00243837f, 0.01242942f, -0.03817798f, -0.01212817f, 0.00668720f, 0.01333664f, 
    -0.00426039f, -0.02602624f, 0.02067050f, -0.03307001f, 0.01803151f, 0.02068279f, 0.02686081f, -0.00444194f, 
    0.00562996f, -0.02053806f, -0.03394923f, 0.02826341f, -0.00501538f, -0.01833030f, -0.03806479f, -0.02050323f, 
    -0.01313390f, 0.01472485f, -0.02091338f, -0.01211305f, -0.03291344f, 0.02881255f, 0.02631291f, -0.00549375f, 
    -0.00656951f, -0.00556524f, -0.00611301f, -0.04155721f, -0.01346787f, -0.01378787f, -0.02212206f, -0.00743934f, 
    0.01104519f, 0.02711396f, -0.03696811f, 0.00455279f, -0.03231437f, 0.02124409f, -0.01607130f, -0.03842267f, 
    0.01101623f, -0.01546856f, -0.02398657f, -0.01134602f, 0.02057428f, -0.02101015f, -0.01427421f, -0.03637606f, 
    -0.00681711f, -0.04015342f, -0.00068750f, 0.00660911f, -0.01658352f, -0.03458862f, 0.02303648f, 0.00320647f, 
    0.02350921f, 0.03991092f, 0.00386901f, -0.02829827f, -0.02855727f, -0.03419514f, 0.01694577f, -0.02716382f, 
    -0.00603870f, -0.01260460f, 0.00427797f, 0.01755811f, 0.00149568f, 0.00399058f, -0.01274283f, -0.01238322f, 
    0.00894084f, -0.03701963f, -0.00019621f, 0.01191185f, -0.02923913f, 0.00387167f, -0.02704852f, -0.02595275f, 
    0.00585940f, 0.01537718f, -0.02974210f, -0.00761759f, -0.02835807f, 0.01567220f, -0.00309129f, -0.01553326f, 
    -0.01755975f, -0.00904080f, 0.01024434f, -0.02636863f, 0.02429260f, 0.00514245f, 0.02505334f, 0.01104107f, 
    -0.04158314f, 0.02028881f, 0.02272670f, -0.00523927f, -0.03739763f, -0.00897345f, -0.00388537f, -0.00518510f, 
    0.03180977f, -0.01680772f, -0.02661457f, -0.03421698f, 0.03433235f, -0.03248532f, -0.02634651f, -0.02503741f, 
    0.03783401f, 0.00829885f, 0.02045945f, 0.00774423f, -0.00922834f, -0.03358568f, 0.02880155f, -0.00889053f, 
    -0.01828320f, -0.00063343f, 0.01514947f, -0.00450805f, -0.01173732f, 0.00083829f, -0.00247947f, 0.01613324f, 
    0.02643538f, 0.00708203f, 0.02116682f, 0.00177924f, 0.02940622f, 0.02866110f, -0.00370749f, 0.01383688f, 
    -0.03371990f, -0.02021920f, 0.01655559f, 0.02768634f, 0.02511840f, -0.02275372f, -0.01234877f, -0.02952141f, 
    0.00982117f, -0.02309256f, -0.03930983f, -0.00826939f, 0.03511616f, 0.01034369f, -0.00751925f, -0.04067635f, 
    0.01870317f, 0.02441499f, 0.02637326f, 0.00542384f, 0.01555409f, 0.02375977f, 0.00793568f, -0.00274869f, 
    -0.03853719f, -0.00768291f, -0.02902942f, -0.02130909f, -0.01807957f, 0.01174873f, -0.02432105f, 0.02104159f, 
    -0.01585736f, 0.02172872f, -0.03770348f, -0.03075195f, 0.02767039f, 0.01764719f, 0.00401679f, 0.01481976f, 
    0.01024424f, -0.02805238f, 0.00016746f, -0.00667047f, -0.03268777f, -0.02263165f, -0.00613898f, -0.03691285f, 
    0.01463699f, -0.02070730f, -0.01288013f, 0.00368953f, -0.01876114f, -0.02251410f, 0.00660940f, 0.00089178f, 
    -0.00198688f, -0.00452581f, 0.03006775f, 0.01047041f, -0.02584210f, 0.01294417f, -0.01321062f, -0.02717039f, 
    0.03807770f, 0.01487534f, -0.02423329f, 0.01471868f, -0.03215048f, 0.02080931f, -0.01827469f, -0.00996910f, 
    -0.01057285f, 0.01052503f, -0.00637143f, 0.01834812f, -0.01050562f, 0.02295619f, 0.01942091f, 0.00844856f, 
    -0.02911681f, 0.00190089f, 0.01804578f, 0.00390300f, -0.03024584f, 0.02505114f, 0.00176029f, 0.00981669f, 
    0.00545224f, -0.00011444f, 0.00488847f, 0.00754236f, 0.00198696f, 0.00879038f, -0.01934951f, 0.00988756f, 
    -0.03712820f, 0.02262569f, -0.02283001f, 0.01491534f, 0.02024979f, -0.00118675f, 0.01072745f, 0.02199336f, 
    -0.02778769f, -0.02841781f, -0.02829292f, 0.01195206f, 0.04110188f, -0.03246790f, -0.00935108f, -0.03113483f, 
    0.00979990f, -0.02670343f, 0.00199080f, 0.02031850f, 0.01660737f, 0.02067544f, -0.00585502f, -0.02075144f, 
    -0.04168651f, -0.02522911f, -0.02873745f, 0.02582363f, 0.01990451f, -0.00134496f, 0.01220517f, -0.00829039f, 
    -0.00278798f, -0.01023355f, 0.01826226f, -0.01819283f, 0.02511071f, -0.02068091f, -0.01110149f, -0.01271714f, 
    0.02247149f, -0.02556316f, 0.01150393f, -0.02374454f, -0.00975467f, -0.03924591f, 0.00054835f, -0.03423036f, 
    -0.01121747f, 0.01415825f, -0.03488263f, -0.01312296f, 0.00350690f, 0.02407360f, -0.01266323f, 0.02905244f, 
    -0.03085439f, 0.01263607f, -0.03421813f, 0.00090241f, -0.00931839f, -0.02434746f, -0.02164371f, -0.03860917f, 
    0.00305296f, 0.02801950f, -0.02276144f, -0.01077662f, 0.00574791f, 0.03003357f, -0.02558971f, -0.01541488f, 
    0.01055811f, -0.02506042f, 0.01871621f, -0.03105739f, 0.01112323f, -0.03140236f, 0.04069589f, -0.01295200f, 
    -0.01520903f, -0.00160213f, 0.01439338f, -0.02281346f, -0.00199201f, 0.01538902f, 0.02594307f, 0.02345321f, 
    -0.02452141f, 0.01246337f, 0.02231894f, 0.00907469f, 0.00200183f, 0.01982323f, -0.03787220f, -0.02966896f, 
    -0.02242864f, 0.02129597f, -0.00624827f, 0.02131517f, -0.02996600f, 0.02557026f, 0.00852077f, -0.01844941f, 
    0.01230538f, 0.02804087f, -0.01103468f, -0.00517433f, -0.03623513f, -0.02642269f, 0.03162545f, 0.02800841f, 
    -0.00919557f, -0.02112199f, 0.02352310f, 0.02827780f, 0.02337906f, -0.02417637f, -0.02890984f, 0.01410582f, 
    -0.03391619f, -0.01919266f, -0.03599014f, -0.03462274f, 0.02959179f, -0.00753904f, 0.00638257f, -0.01765880f, 
    -0.00199899f, -0.02803459f, -0.03170783f, -0.02083876f, -0.01490434f, -0.00753740f, -0.00876338f, 0.00788008f, 
    0.00232756f, 0.01155999f, 0.02130956f, 0.02835980f, 0.01534078f, -0.00408164f, 0.00105807f, -0.02825320f, 
    0.02159191f, -0.00087756f, 0.02569890f, -0.02202147f, -0.04161272f, 0.00336903f, 0.01676826f, 0.02028520f, 
    -0.02154142f, -0.01567338f, 0.02126997f, -0.03035023f, -0.01377078f, 0.01492556f, 0.01154848f, -0.03028930f, 
    -0.02617229f, 0.02694195f, 0.03304585f, -0.00266936f, -0.03038028f, -0.02489956f, -0.02032265f, -0.01376132f, 
    -0.03395315f, 0.01380143f, -0.01591089f, -0.00451746f, 0.00600909f, -0.04173664f, -0.02605154f, 0.03186544f, 
    -0.00847904f, -0.02826029f, 0.01255384f, 0.02805087f, 0.00820160f, -0.00122348f, 0.00334738f, -0.01180058f, 
    -0.00149045f, 0.02580214f, -0.04000613f, -0.03223904f, -0.01403256f, -0.01877890f, 0.01227500f, 0.01414550f, 
    0.03475615f, 0.01188644f, -0.01705327f, -0.03664939f, -0.02866332f, -0.01521998f, -0.03672649f, 0.02459684f, 
    -0.01891461f, 0.02137415f, 0.01857931f, 0.02663701f, -0.03681931f, -0.01879752f, -0.00133422f, -0.01768131f, 
    -0.02996574f, 0.04075373f, 0.02918815f, -0.03812098f, -0.02720403f, -0.03517597f, 0.02128214f, 0.03935226f, 
    -0.00898312f, -0.04132402f, -0.02377092f, -0.00683829f, 0.00690654f, 0.01818340f, -0.01396172f, -0.01612058f, 
    -0.02375100f, -0.02331305f, 0.00308366f, -0.04127809f, -0.02496285f, -0.03097270f, -0.02824712f, 0.02037081f, 
    -0.00934923f, -0.02198446f, -0.03774528f, -0.02208065f, 0.01864817f, 0.02840845f, 0.02655670f, 0.01430755f, 
    -0.03746217f, -0.00772829f, 0.02831379f, 0.00675060f, -0.03357570f, 0.01126651f, 0.00242593f, -0.03843655f, 
    0.01958898f, 0.03737696f, 0.01293201f, -0.03985561f, -0.03468649f, 0.02211666f, 0.02285473f, -0.00430373f, 
    -0.01306628f, 0.03041860f, 0.02740080f, -0.02557426f, 0.02008466f, -0.02832342f, 0.00470115f, 0.02991503f, 
    -0.00801532f, -0.00638478f, -0.00105427f, -0.03569771f, 0.00789923f, 0.03999871f, 0.02259384f, 0.01831233f, 
    -0.01712051f, -0.01937772f, -0.01348669f, -0.02336364f, -0.01989863f, 0.01243191f, 0.04085303f, -0.00104272f, 
    0.00289882f, 0.00462188f, 0.00671124f, -0.03678425f, -0.00608507f, -0.00841942f, -0.03307565f, -0.01107472f, 
    -0.01151346f, -0.02016741f, -0.00143948f, -0.01561589f, 0.00380538f, 0.01027725f, -0.01808459f, 0.00744705f, 
    -0.01472760f, 0.01977413f, -0.02670205f, -0.01219480f, 0.00519805f, -0.01668628f, -0.02519721f, -0.01954467f, 
    0.00164827f, 0.02795403f, -0.01010878f, 0.02271013f, 0.00028720f, 0.02885932f, 0.00658323f, -0.03290660f, 
    0.00877969f, -0.00199646f, 0.02096210f, -0.02285587f, 0.02596887f, -0.02898994f, -0.02366680f, 0.00977053f, 
    -0.04121158f, 0.02380606f, -0.00633403f, 0.00928217f, -0.02638933f, -0.00045164f, -0.01556849f, 0.01417815f, 
    -0.02378064f, -0.02708368f, -0.02741753f, -0.02731936f, -0.01157481f, -0.03215844f, -0.02040475f, 0.01988620f, 
    0.00566275f, -0.03569892f, -0.02753424f, -0.00506460f, 0.03036579f, 0.01648823f, -0.02452672f, -0.00089455f, 
    0.02610706f, 0.03398263f, 0.01616941f, -0.00872566f, -0.03222169f, -0.04108021f, 0.00719838f, -0.00139058f, 
    -0.00957934f, 0.00166562f, -0.01346073f, -0.04189827f, 0.02409607f, 0.00284839f, -0.02967309f, -0.01801585f, 
    -0.00528996f, -0.02671743f, -0.01418568f, 0.02696905f, 0.04106715f, 0.02347029f, -0.01005978f, -0.02137421f, 
    0.00879871f, -0.02577259f, -0.02827573f, -0.01984804f, -0.00350270f, -0.01679929f, -0.03801422f, 0.01072175f, 
    0.01550690f, 0.00382583f, -0.00277027f, -0.01478504f, 0.01935812f, 0.02284618f, 0.03149176f, -0.03967516f, 
    0.01557477f, 0.01184214f, -0.04179758f, -0.00842536f, -0.03850687f, 0.03238291f, 0.00406597f, -0.01057239f, 
    -0.03153867f, -0.03866434f, -0.01945643f, 0.01288924f, 0.00392857f, 0.01474729f, -0.04069158f, 0.00001696f, 
    -0.20553736f, 0.41290325f, 0.01603392f, -0.13710779f, 0.04043140f, -0.10808977f, 0.23175712f, -0.05543542f, 
    -0.18176048f, -0.05959651f, -0.01998117f, 0.08769545f, -0.02623011f, 0.11434974f, -0.01428084f, 0.02828456f, 
    0.04169445f, 0.14586908f, -0.01094551f, 0.06238203f, -0.09724188f, 0.03653311f, -0.02375772f, -0.06756252f, 
    -0.00462685f, 0.05487780f, 0.05720348f, -0.09608173f, -0.06370521f, 0.01612491f, -0.06643283f, -0.02792204f, 
    0.05497440f, 0.04058703f, 0.02049171f, 0.11700454f, -0.05926941f, 0.32671034f, -0.08820516f, 0.22281021f, 
    0.04370090f, -0.06059349f, 0.13911669f, -0.00896207f, 0.02153578f, -0.06746542f, -0.08987265f, 0.07295714f, 
    0.30089247f, 0.15210512f, -0.13164175f, -0.24064220f, 0.02335873f, -0.15305792f, 0.10337012f, 0.02816693f, 
    0.03783728f, 0.07606330f, -0.01361354f, -0.06475096f, 0.04828551f, 0.12269200f, -0.16164775f, -0.01562310f, 
    0.05037058f, 0.02563276f, 0.02657770f, -0.06972860f, -0.15264973f, 0.05010695f, -0.05610352f, 0.06099190f, 
    0.00033976f, 0.16668472f, -0.10492962f, 0.05320127f, -0.04656850f, 0.09002972f, -0.05160654f, -0.00616279f, 
    -0.08888312f, -0.02501711f, -0.02921471f, -0.17196244f, -0.23896699f, 0.18688276f, -0.12928951f, 0.15225533f, 
    0.01555374f, -0.13143396f, 0.05053785f, -0.16008553f, -0.02095685f, 0.07268308f, -0.02029218f, -0.09157769f, 
    0.03611771f, 0.04988338f, -0.16277203f, 0.27859056f, 0.02779998f, 0.02640741f, -0.06305049f, 0.12683758f, 
    0.04958132f, 0.11614005f, 0.04141190f, 0.06782743f, 0.46636796f, 0.06218771f, 0.21971393f, -0.03267314f, 
    0.09264717f, 0.04873056f, -0.00745479f, 0.08251610f, 0.02117057f, -0.01998782f, -0.02793161f, -0.08052182f, 
    0.16281006f, 0.08620119f, 0.00156116f, 0.04629433f, -0.09781348f, 0.04574234f, -0.07709275f, 0.05078572f, 
    -0.07322558f, 0.04495599f, -0.01691955f, 0.00279260f, 0.00045230f, 0.19037193f, -0.07625050f, 0.21157722f, 
    0.04641903f, 0.00988624f, 0.06356624f, 0.09080478f, 0.01847083f, 0.18814264f, 0.12285633f, 0.17184541f, 
    -0.45044750f, 0.28495237f, -0.35925820f, 0.12719783f, -0.05264479f, -0.07995996f, 0.06285729f, -0.04057520f, 
    -0.12312229f, 0.05040469f, 0.09113004f, -0.07872648f, 0.13254823f, 0.13101172f, 0.16370063f, 0.06003261f, 
    -0.10365028f, -0.11515032f, -0.10213291f, -0.06913193f, -0.03797238f, 0.01839490f, -0.04213565f, -0.01605209f, 
    0.21446814f, 0.24217971f, -0.03341611f, 0.12618858f, 0.01055344f, -0.13516185f, 0.11813303f, -0.19950087f, 
    -0.06746685f, 0.10164858f, -0.10316321f, -0.10135725f, 0.03283187f, -0.15692905f, -0.06156020f, 0.22797219f, 
    -0.12025642f, -0.11642870f, -0.00611426f, 0.20827770f, 0.00647612f, -0.01963081f, -0.03140485f, -0.01490230f, 
    -0.21252929f, 0.11489778f, -0.02270389f, -0.02508395f, -0.01113410f, 0.04649612f, -0.03141871f, -0.03412126f, 
    0.03395520f, -0.06246031f, -0.02743379f, -0.01826672f, 0.09191427f, 0.06410716f, 0.15817790f, 0.19489291f, 
    0.18635941f, -0.00357556f, -0.15342900f, 0.10381851f, 0.06822308f, 0.07015368f, -0.07969093f, 0.06596086f, 
    -0.22704077f, 0.09706002f, -0.08860730f, 0.16194840f, 0.09139898f, 0.00490079f, -0.15554777f, 0.18612032f, 
    0.03058958f, -0.05509276f, -0.09716049f, 0.06353294f, 0.07527664f, -0.07041383f, -0.02785989f, -0.05458351f, 
    0.00501523f, 0.06160832f, 0.01214784f, 0.02579356f, -0.06536372f, -0.07458439f, -0.11290173f, 0.11546724f, 
    0.37468401f, 0.12127843f, 0.16657726f, -0.10326453f, -0.00562293f, 0.09990697f, -0.07800471f, 0.07820828f, 
    -0.05902572f, 0.06332795f, -0.00075721f, -0.09400278f, 0.01317533f, 0.25411943f, 0.09911936f, 0.12754191f, 
    -0.04011546f, -0.05642803f, 0.05640962f, 0.30359820f, -0.00832225f, 0.16118740f, -0.05311183f, 0.11633997f, 
    0.22689921f, 0.08400963f, 0.26464522f, -0.21557726f, -0.08917732f, 0.13985670f, -0.08595857f, 0.06524728f, 
    0.02074928f, -0.02948517f, 0.01138672f, -0.09654617f, -0.35856780f, 0.01538633f, 0.26498488f, -0.14990047f, 
    0.20713277f, 0.11472490f, -0.08477914f, -0.00138276f, 0.00328930f, -0.02071527f, -0.01612650f, -0.05323966f, 
    0.28568807f, -0.12824056f, 0.10098713f, -0.01080113f, 0.02708247f, 0.04833061f, -0.00621221f, -0.00806661f, 
    -0.07084019f, -0.10229345f, -0.02734856f, -0.12123685f, 0.04114505f, -0.04502232f, 0.00004068f, 0.01173866f, 
    0.05112270f, -0.01664920f, 0.01587705f, 0.04808088f, -0.00300352f, 0.00951316f, 0.00593727f, -0.12701012f, 
    -0.14715452f, -0.57078564f, 0.07492148f, 0.27782032f, -0.05487775f, -0.00731107f, 0.13101237f, 0.15504180f, 
    -0.21925533f, -0.10614826f, -0.05120480f, -0.06377926f, -0.08846085f, -0.01060175f, -0.05697471f, -0.00413367f, 
    -0.08589223f, -0.03650078f, 0.09965330f, 0.13329415f, -0.15079886f, -0.05118115f, 0.12866347f, -0.12226671f, 
    0.30897433f, 0.29687780f, 0.09454009f, -0.03401466f, -0.01082102f, 0.07994932f, -0.02050611f, 0.10391473f, 
    -0.12213513f, 0.07531337f, 0.04555381f, -0.01520701f, 0.14355671f, 0.22588882f, 0.01403769f, 0.14712727f, 
    -0.08864795f, -0.06117323f, -0.10005194f, -0.15729997f, -0.01477107f, -0.01847593f, -0.00245509f, -0.12662047f, 
    -0.04673452f, 0.26901978f, -0.10295925f, -0.05682867f, 0.13731200f, 0.11495701f, 0.08003852f, 0.02863206f, 
    -0.15490036f, -0.02590221f, 0.00706256f, -0.08182871f, 0.05042601f, 0.06370588f, 0.05398187f, 0.02149988f, 
    0.09356446f, 0.04606797f, -0.14065734f, 0.08786590f, -0.11374521f, -0.03655848f, -0.07932170f, -0.11542036f, 
    0.12804374f, -0.02909972f, -0.08376871f, -0.03154504f, 0.01414947f, 0.04684216f, -0.07750192f, -0.02599540f, 
    -0.02223361f, 0.03984986f, -0.08501409f, -0.07918026f, 0.02611374f, 0.05526773f, 0.01314884f, -0.04796959f, 
    0.03109262f, 0.02666565f, 0.02284063f, 0.11718043f, -0.04824569f, 0.05603974f, 0.21730132f, 0.01645448f, 
    0.05580919f, -0.26797444f, 0.07586795f, -0.05815049f, 0.07152595f, -0.05983906f, 0.06480312f, 0.01895107f, 
    0.02587601f, 0.08123461f, 0.09554690f, 0.06308573f, -0.05487766f, 0.12414932f, 0.50156701f, -0.03038650f, 
    0.10530593f, 0.27581012f, -0.10427064f, 0.03592176f, -0.13372658f, -0.07019473f, -0.01779393f, 0.04680317f, 
    0.09978091f, 0.10448147f, -0.03380414f, 0.52367294f, -0.01035650f, 0.09033755f, -0.02537414f, 0.00678346f, 
    -0.10582587f, 0.05226223f, 0.09365636f, -0.07937300f, 0.05125757f, 0.08958767f, 0.06013979f, -0.02098215f, 
    -0.00544589f, 0.08144752f, 0.04494300f, -0.07963685f, -0.04423901f, 0.08937398f, 0.01280090f, -0.08072243f, 
    -0.01694850f, -0.11673788f, -0.05362082f, 0.06075684f, 0.12298256f, 0.01366903f, 0.01438268f, 0.18422744f, 
    0.07542555f, 0.06508221f, 0.04551152f, 0.01252785f, -0.46213546f, 0.17150256f, -0.02732210f, 0.31814489f, 
    0.07711393f, 0.25668553f, -0.07717749f, -0.07779495f, -0.05599772f, -0.08313844f, -0.05771033f, 0.20517038f, 
    -0.20202652f, 0.09483224f, 0.20004444f, 0.00153488f, -0.00333319f, 0.01981791f, -0.02572097f, -0.19041243f, 
    0.11896196f, 0.01488731f, -0.01100519f, -0.02158095f, 0.09897901f, 0.00038680f, 0.05229216f, -0.12641916f, 
    -0.00120575f, -0.04725589f, 0.01307323f, 0.08605202f, -0.06015557f, 0.06361330f, -0.01559584f, -0.10646366f, 
    0.06029376f, 0.09514968f, 0.15150934f, 0.03873651f, -0.09658843f, 0.00045100f, -0.04575856f, 0.16174038f, 
    -0.01785034f, 0.06333286f, -0.03775408f, 0.05657323f, 0.37011960f, 0.11873498f, -0.14259252f, 0.18842053f, 
    0.04161675f, 0.07553589f, -0.00463171f, 0.07392466f, -0.15424751f, -0.03016873f, -0.03367119f, -0.09591024f, 
    -0.13245283f, 0.18158457f, -0.18430232f, 0.22244346f, -0.03113511f, 0.03615058f, -0.03212377f, -0.12808751f, 
    0.03419172f, 0.02915464f, 0.08525083f, 0.02689603f, 0.19131079f, 0.16293864f, -0.12955004f, 0.22570176f, 
    -0.09355593f, 0.13892627f, -0.01624148f, -0.03755033f, -0.00484996f, -0.00373396f, -0.03346262f, -0.09923290f, 
    -0.09717096f, -0.12963869f, -0.04126247f, 0.12999655f, -0.02058807f, -0.02593572f, -0.02167850f, -0.02858371f, 
    -0.03431476f, 0.03891299f, -0.12292153f, -0.11747138f, -0.11527065f, -0.03688955f, 0.15371293f, -0.04737891f, 
    -0.03478407f, -0.09785398f, 0.06797738f, 0.09100552f, -0.00599863f, -0.00418398f, 0.03300474f, -0.01327432f, 
    -0.06630608f, 0.12710650f, -0.25815493f, 0.03192179f, -0.01467016f, 0.04815131f, 0.01904564f, -0.07152251f, 
    -0.01726511f, 0.00196535f, 0.13632187f, -0.08487023f, 0.30540308f, -0.12431347f, -0.10527895f, -0.20640121f, 
    0.09278116f, 0.10766768f, 0.01579464f, 0.05671316f, 0.01738212f, 0.13393442f, 0.13584071f, -0.03244895f, 
    0.07255512f, 0.11813015f, 0.00279917f, 0.04228462f, 0.01088457f, -0.01804644f, -0.00727974f, -0.16941039f, 
    0.15558395f, 0.04426361f, -0.02615007f, 0.14530937f, 0.36226732f, 0.19096091f, 0.24475329f, 0.32738024f, 
    0.00402421f, -0.15261690f, -0.00152963f, 0.03573138f, 0.00966591f, 0.00157195f, -0.07223532f, -0.09102326f, 
    -0.13320424f, 0.06055170f, 0.06015481f, -0.05641960f, 0.09082905f, 0.05256930f, -0.02246460f, -0.02128656f, 
    -0.07770607f, 0.00617469f, -0.10533658f, 0.01416582f, -0.04908787f, -0.00725676f, 0.09933101f, -0.08818974f, 
    -0.04883185f, 0.05045110f, 0.01949236f, -0.05933636f, -0.03505678f, -0.03240590f, -0.05670285f, -0.01603759f, 
    0.08802555f, 0.32694978f, -0.08480693f, 0.05441515f, 0.03342057f, 0.09929816f, 0.04711111f, 0.20877054f, 
    -0.05027109f, 0.00788856f, 0.00156453f, 0.14646974f, 0.08582280f, -0.17379333f, -0.01758164f, 0.20927340f, 
    -0.02591319f, 0.11450363f, 0.00836749f, 0.06985655f, 0.02436442f, 0.03101954f, 0.05831800f, 0.08815411f, 
    0.07871375f, 0.00810131f, 0.05920039f, 0.02940501f, -0.08420958f, 0.03673890f, -0.05234776f, -0.00045808f, 
    0.08342682f, -0.08002199f, 0.12456767f, 0.24994604f, 0.30812976f, -0.04292688f, 0.13417162f, 0.10399935f, 
    0.02468544f, 0.07219142f, -0.02411565f, 0.01550973f, -0.06290678f, -0.03306201f, 0.02011844f, -0.09236161f, 
    -0.16833664f, 0.12114513f, -0.12991241f, 0.31771341f, 0.09008081f, 0.00393581f, 0.09826455f, 0.03495861f, 
    -0.02452075f, -0.13837722f, 0.12887751f, -0.10509279f, 0.15847300f, -0.01429501f, -0.11370599f, 0.19707924f, 
    -0.14618070f, -0.03935418f, 0.04064347f, -0.08739492f, -0.01576294f, -0.07158419f, -0.15610774f, -0.05107569f, 
    0.08179571f, -0.15358655f, -0.15185532f, 0.14843231f, 0.08666186f, -0.06840584f, -0.10202020f, 0.03713104f, 
    -0.01409496f, 0.06427968f, 0.10162531f, 0.01367694f, 0.09657736f, -0.01665902f, 0.03251424f, 0.02946284f, 
    -0.06055182f, 0.01157412f, 0.08970062f, 0.01892268f, -0.01481098f, -0.02237935f, 0.06099928f, -0.07932029f, 
    0.05926364f, 0.12625226f, -0.03282280f, 0.07277517f, 0.03176076f, -0.01429353f, 0.07631822f, -0.02533233f, 
    -0.06018666f, -0.08969179f, 0.01414471f, -0.08087467f, -0.16433193f, 0.00878269f, 0.21598881f, -0.09469420f, 
    0.04556897f, 0.13626204f, 0.05958730f, -0.08814845f, -0.00340494f, 0.08588281f, -0.02570136f, -0.03366596f, 
    -0.01416600f, -0.01385988f, -0.02292636f, 0.00191989f, 0.00869828f, -0.03023615f, 0.01546794f, 0.01809067f, 
    -0.03663055f, 0.01134983f, -0.02133139f, 0.01758105f, 0.02857699f, 0.01166696f, -0.03535798f, -0.02204692f, 
    -0.02496051f, 0.01695804f, -0.02742780f, 0.01858619f, 0.02564730f, -0.01059585f, -0.00441875f, 0.02331476f, 
    0.01606954f, 0.01368629f, 0.01784576f, 0.01553959f, -0.00308443f, -0.01981854f, 0.00699255f, 0.01198754f, 
    0.01817781f, -0.03409775f, -0.02650286f, 0.02656563f, -0.00181342f, -0.00061081f, 0.01482238f, -0.00560960f, 
    0.01319482f, 0.02314371f, -0.03603322f, -0.01145837f, -0.02142723f, 0.00012562f, -0.01764967f, -0.02531972f, 
    0.00357447f, -0.00234783f, -0.03534535f, -0.02081036f, 0.00674008f, 0.02625603f, -0.03518802f, 0.02633077f, 
    -0.02096644f, -0.00983712f, -0.01595053f, 0.02384661f, 0.00254757f, 0.01184736f, -0.01335540f, -0.03923314f, 
    0.00127851f, -0.00995145f, -0.03755022f, 0.01717654f, -0.00672520f, 0.00910262f, 0.00127631f, 0.02407256f, 
    -0.01289753f, -0.00397586f, -0.02449780f, -0.01551894f, -0.03472554f, 0.02517704f, -0.03679559f, -0.03481264f, 
    0.02792210f, -0.03686476f, 0.03051600f, -0.01404612f, 0.03014394f, 0.02656914f, 0.02296003f, -0.03775363f, 
    -0.02090478f, -0.01379950f, -0.00300179f, -0.01808077f, -0.00875827f, 0.03106275f, 0.00995019f, -0.01951346f, 
    -0.02609793f, -0.02214285f, -0.02384038f, -0.02442027f, -0.00059851f, 0.02146345f, -0.00388278f, 0.01837818f, 
    -0.00756561f, 0.00247176f, -0.02584234f, -0.02296026f, -0.01178809f, 0.00763930f, -0.02239562f, 0.01768778f, 
    0.01104552f, 0.02206144f, 0.02762691f, 0.00802579f, 0.01308452f, -0.02947429f, 0.00167198f, -0.01061954f, 
    -0.02302525f, -0.02178882f, -0.00274806f, -0.00487756f, 0.00549118f, -0.02521590f, 0.00269029f, -0.01270319f, 
    0.01274357f, -0.00567032f, -0.01654096f, -0.01774364f, -0.01837069f, 0.02586775f, 0.02023135f, -0.04138605f, 
    0.02212919f, 0.00072209f, -0.03480402f, -0.02525943f, -0.02624345f, 0.02056703f, 0.01740206f, 0.00901490f, 
    -0.00977204f, -0.01825858f, -0.01435059f, 0.00843288f, -0.03694488f, 0.02416586f, -0.02759026f, 0.01837507f, 
    0.01324411f, 0.00387022f, 0.02386823f, 0.02246944f, 0.01455022f, 0.01913448f, 0.00783038f, 0.02414007f, 
    0.01811610f, -0.00831884f, -0.03961359f, 0.00306801f, -0.02369479f, -0.03442189f, -0.03094898f, -0.00484029f, 
    -0.02000933f, -0.00518909f, 0.02209278f, -0.01407024f, 0.01845125f, -0.03570709f, -0.01328322f, 0.02120028f, 
    0.00652903f, 0.02406672f, 0.00116082f, 0.01773180f, 0.02279092f, 0.02101134f, -0.03160066f, 0.00404662f, 
    -0.02701492f, 0.00371784f, 0.01457717f, 0.02141743f, -0.01259120f, -0.03072980f, 0.02373007f, -0.03798153f, 
    0.03037832f, 0.00346224f, -0.00429358f, -0.02819477f, -0.00568119f, -0.01528365f, -0.03712332f, -0.02086071f, 
    -0.03768077f, 0.01397168f, -0.03186546f, 0.02200001f, -0.02936894f, 0.02822498f, -0.02143519f, 0.00969736f, 
    0.01355007f, 0.02582836f, 0.01597768f, -0.00765295f, -0.00735998f, 0.02207427f, 0.00966608f, -0.00840376f, 
    0.01217649f, 0.03063359f, 0.00580159f, 0.02039347f, -0.02102525f, 0.02066920f, 0.01416635f, -0.00765537f, 
    0.02966974f, -0.00363330f, -0.00630803f, 0.02311398f, -0.03726809f, -0.02201282f, -0.00773407f, -0.00496966f, 
    0.01403531f, 0.01446447f, -0.00227574f, 0.00455674f, -0.02571286f, 0.00650168f, 0.02678000f, -0.00892123f, 
    0.01907931f, 0.00210570f, 0.00252691f, -0.03661630f, 0.02413986f, -0.02481099f, 0.03015590f, 0.01909556f, 
    -0.03953883f, -0.02526352f, 0.02221805f, 0.02851170f, -0.03818453f, -0.00859267f, -0.00189635f, -0.02949504f, 
    -0.02860308f, 0.01829431f, -0.00601807f, -0.00722912f, 0.03050386f, -0.02225534f, -0.00568656f, 0.02952787f, 
    -0.02335741f, -0.03021243f, -0.03973784f, 0.02653191f, -0.02795574f, 0.00021616f, -0.02821445f, -0.00699470f, 
    -0.03280208f, -0.03600025f, -0.02986750f, -0.03108444f, 0.00876872f, -0.00850256f, -0.01286657f, 0.01845456f, 
    -0.02578532f, 0.01423777f, 0.00298006f, -0.00939963f, 0.02958581f, -0.03072144f, -0.02698564f, -0.02511926f, 
    -0.01789702f, 0.00994366f, -0.01687715f, 0.03049706f, -0.02524118f, -0.01855402f, 0.02415655f, 0.03105043f, 
    0.02588279f, 0.01062560f, 0.02941802f, 0.02306764f, -0.02904302f, 0.02787224f, 0.00651661f, -0.02160365f, 
    -0.03058483f, -0.03491733f, -0.00596281f, -0.00288160f, -0.02683125f, -0.01928511f, 0.02833229f, 0.01868779f, 
    -0.03776034f, -0.03269173f, -0.01173636f, -0.02860384f, 0.01609634f, 0.00536326f, 0.01436053f, -0.02043613f, 
    0.03320222f, 0.00043388f, -0.01573809f, 0.00070508f, 0.02621977f, 0.02865208f, -0.03301908f, -0.03754174f, 
    -0.03575554f, 0.01666773f, -0.02913746f, -0.02325095f, 0.00651085f, -0.03531851f, 0.00160752f, -0.01116677f, 
    -0.00197619f, -0.03690528f, -0.03757601f, -0.00398538f, -0.01180461f, -0.03406194f, -0.03808331f, -0.01543392f, 
    0.02746871f, 0.00675844f, -0.02667314f, 0.02388752f, -0.02275285f, -0.00625890f, 0.00612715f, -0.00480927f, 
    0.00342493f, 0.00764418f, -0.01420737f, -0.02415137f, 0.00270981f, -0.03426653f, -0.00272625f, -0.01581986f, 
    0.00301720f, -0.00418816f, -0.02202990f, -0.00996403f, -0.00793615f, -0.02099846f, -0.00241114f, 0.00683712f, 
    -0.01381038f, -0.01674265f, -0.03415379f, -0.01264793f, 0.00138255f, 0.02871468f, -0.02771633f, 0.02880778f, 
    0.02833944f, -0.03205806f, -0.00369028f, 0.00123436f, 0.02508033f, -0.03333884f, 0.00782687f, 0.01585235f, 
    -0.00894311f, 0.02716675f, -0.00153685f, -0.03819843f, -0.00881643f, 0.01391129f, -0.01018413f, 0.02950528f, 
    0.02169453f, -0.03950812f, 0.00281439f, -0.01549708f, -0.01768156f, -0.02133829f, 0.02843346f, -0.00879567f, 
    0.00033226f, -0.03353946f, 0.02034891f, -0.00949800f, -0.03651111f, 0.00200960f, -0.01542023f, -0.02133114f, 
    0.02857801f, -0.00086049f, -0.02359582f, 0.00443880f, 0.00666681f, -0.02990411f, -0.02377553f, 0.02064210f, 
    0.02096624f, -0.01405507f, -0.04184752f, 0.00137851f, -0.01866446f, -0.01540811f, -0.02031055f, 0.02478958f, 
    0.02337330f, -0.03668809f, -0.02349474f, 0.00156301f, -0.02397472f, -0.02926150f, -0.01469443f, -0.00494937f, 
    0.00248253f, 0.02331407f, 0.00876702f, 0.02658438f, -0.01187270f, -0.02589143f, 0.00973082f, -0.00267893f, 
    0.01938199f, 0.02345804f, 0.01243272f, -0.04033170f, 0.00484484f, -0.03280547f, 0.03022174f, -0.03333047f, 
    -0.01211442f, 0.01164837f, -0.00371807f, 0.02767745f, 0.02426257f, -0.02891697f, -0.00991744f, -0.01952385f, 
    0.00373421f, -0.01474587f, -0.02500981f, -0.01461994f, -0.04131761f, 0.00869016f, 0.02258408f, 0.01801755f, 
    0.02912551f, -0.00663841f, -0.01417402f, -0.00674950f, 0.02393627f, 0.00296066f, 0.02873635f, -0.02664091f, 
    -0.02723744f, -0.01450842f, 0.02798033f, 0.01319816f, -0.01410247f, 0.00109473f, 0.01669055f, -0.00658074f, 
    0.01887914f, -0.02226746f, -0.03834040f, 0.02586950f, 0.00450229f, 0.02231404f, -0.03853646f, 0.03085451f, 
    -0.03393267f, 0.00225271f, -0.02957283f, 0.01414259f, -0.00042290f, -0.00690672f, 0.01104678f, 0.01259985f, 
    0.00162617f, -0.02660225f, 0.02552399f, -0.02630469f, -0.02403088f, -0.02424262f, -0.00794411f, -0.00119987f, 
    0.01925046f, 0.02083433f, -0.02761939f, 0.02210156f, -0.02223719f, 0.00947320f, 0.02274683f, -0.01638071f, 
    -0.02267484f, 0.00308541f, -0.01564036f, -0.02210625f, -0.02332035f, -0.03050937f, 0.01798923f, 0.02755188f, 
    -0.02754835f, -0.03150563f, -0.03072549f, -0.03769289f, -0.01451080f, -0.00083244f, -0.02731270f, -0.03871867f, 
    0.02728437f, 0.00820096f, 0.01000080f, 0.02543429f, 0.01226959f, -0.04044998f, -0.01860606f, 0.02720963f, 
    0.03104808f, 0.01089727f, 0.02053223f, 0.01148559f, 0.01973550f, -0.02491858f, -0.02233789f, 0.01596545f, 
    0.02018759f, 0.02340232f, -0.02402586f, -0.01641480f, 0.00920607f, -0.02812234f, 0.01098582f, 0.02086957f, 
    -0.04040378f, -0.02172173f, -0.02922753f, -0.03770099f, 0.02460095f, 0.00289602f, -0.00869488f, -0.02831393f, 
    0.03053836f, -0.02106370f, 0.02107932f, -0.03259995f, -0.00463149f, 0.00331460f, 0.01973740f, 0.02659387f, 
    -0.00218875f, -0.01024749f, -0.01443697f, -0.03745930f, 0.01591482f, -0.03468188f, -0.03423179f, -0.01324514f, 
    -0.02923380f, -0.03896863f, -0.01936956f, 0.01937177f, -0.03107023f, 0.02772885f, -0.00851512f, 0.00594482f, 
    0.01298549f, -0.03539187f, -0.00967283f, 0.00814688f, -0.02823085f, 0.01394085f, -0.02255278f, -0.01372986f, 
    -0.01532493f, -0.03665169f, 0.01077195f, 0.02146750f, 0.00754936f, -0.00576134f, 0.00590496f, -0.03347481f, 
    0.01575972f, 0.00347481f, 0.01831142f, -0.00616671f, -0.02532262f, -0.03524368f, -0.01385113f, -0.00096125f, 
    -0.00111753f, 0.01685733f, 0.00276412f, -0.01358932f, -0.01134901f, -0.03148405f, -0.01330897f, 0.02115510f, 
    -0.03580693f, 0.01301541f, -0.00841543f, 0.02938269f, -0.02258476f, 0.02826148f, 0.02574471f, 0.00193343f, 
    -0.03536725f, 0.02531198f, -0.01235298f, 0.01473301f, -0.00529488f, -0.03403721f, 0.02905259f, -0.02456245f, 
    0.02765859f, 0.00212255f, -0.00653181f, 0.00894093f, 0.02803613f, -0.02914054f, 0.00383645f, 0.01861766f, 
    0.01320115f, -0.01199786f, -0.00257589f, 0.00072387f, 0.00025676f, 0.02118999f, 0.00724366f, 0.01295780f, 
    -0.02053271f, -0.03306038f, -0.00385310f, 0.01192180f, 0.01760069f, -0.03876071f, -0.03535494f, -0.00613584f, 
    -0.00358014f, -0.02910564f, -0.04085456f, 0.01650050f, -0.02952337f, -0.00510719f, 0.01093862f, 0.02492198f, 
    -0.02914980f, -0.00242285f, 0.02980890f, -0.02755320f, 0.00753290f, -0.00719397f, 0.02466970f, -0.01426746f, 
    -0.02220437f, -0.00824591f, -0.02131705f, -0.03479487f, 0.02637269f, 0.02509857f, -0.00895751f, -0.02462540f, 
    0.02571758f, -0.02160717f, 0.01593198f, -0.04270972f, 0.01251572f, 0.02900610f, -0.03177089f, 0.01180139f, 
    0.01590675f, 0.02006643f, -0.01977976f, 0.01427783f, 0.02677043f, 0.01016025f, 0.00887438f, -0.01398543f, 
    0.01651642f, -0.00379665f, -0.03594475f, 0.01582689f, -0.02389072f, -0.01883414f, 0.02079443f, -0.02033361f, 
    0.03228343f, 0.02278217f, -0.02835608f, -0.01570270f, -0.02775806f, 0.01007248f, -0.03697560f, -0.00285427f, 
    0.02105503f, 0.00015411f, -0.02400227f, 0.03019159f, -0.02956966f, -0.01129222f, 0.02333834f, -0.01587201f, 
    0.02512280f, -0.03138223f, 0.02402151f, 0.01409100f, -0.03071571f, -0.01368858f, 0.02759083f, 0.00058682f, 
    -0.02949790f, 0.01637493f, -0.03269922f, -0.00902614f, 0.02873204f, 0.02475013f, 0.03111234f, -0.00935009f, 
    0.00233484f, -0.00919194f, -0.03864223f, 0.00853188f, -0.01400525f, 0.00205027f, -0.02436019f, 0.03054676f, 
    -0.03953137f, 0.01000524f, -0.01218768f, -0.03350857f, -0.02862306f, 0.02371423f, -0.02832485f, 0.00939828f, 
    0.00318598f, 0.02367759f, 0.01677896f, -0.00195386f, 0.00862186f, 0.00040060f, 0.01487895f, -0.00977101f, 
    0.02925552f, 0.01546414f, -0.00804998f, 0.02754428f, -0.00384841f, 0.02938047f, -0.00396825f, -0.00360769f, 
    -0.05575575f, -0.00333940f, 0.08805663f, -0.11076943f, -0.17313853f, -0.07794572f, 0.10993721f, -0.12270343f, 
    0.08958779f, -0.02424576f, 0.16243584f, 0.02719508f, 0.11264713f, 0.04072398f, 0.16892976f, -0.08847659f, 
    0.03675255f, 0.11786273f, 0.05721898f, -0.01838576f, -0.04963735f, -0.06326502f, -0.08554106f, -0.02640273f, 
    0.03305829f, 0.03548046f, -0.05329920f, 0.13393356f, 0.01516476f, 0.00065846f, 0.00437116f, -0.02952622f, 
    -0.11742033f, -0.11012284f, 0.07104890f, -0.06786297f, 0.04609985f, 0.22467659f, 0.08055554f, 0.03400357f, 
    0.01407014f, 0.04164796f, -0.13089481f, 0.13218309f, -0.05209563f, 0.05956013f, -0.04563001f, -0.15817691f, 
    -0.20578505f, 0.11904491f, 0.02532844f, -0.09367518f, -0.04177658f, 0.04042607f, 0.06918357f, 0.19494240f, 
    -0.00635648f, -0.06068013f, -0.01819317f, -0.00463179f, 0.15728767f, 0.00805928f, -0.00889679f, 0.02771429f, 
    -0.21855812f, -0.23332570f, 0.02986221f, 0.05327168f, 0.03382207f, 0.09590266f, -0.10759351f, 0.05435290f, 
    -0.27482277f, -0.00292787f, 0.26280689f, -0.04332318f, 0.12634167f, 0.21747956f, 0.09487773f, -0.02953226f, 
    0.01493789f, -0.00793413f, -0.07187555f, -0.06000558f, 0.27202186f, 0.11066048f, 0.06949314f, -0.03113120f, 
    0.10449114f, 0.08295558f, -0.06471137f, 0.20827901f, -0.04976608f, -0.06102790f, 0.06203573f, 0.05735650f, 
    0.20673868f, 0.24580309f, 0.12881996f, -0.03324475f, 0.08669905f, -0.01796359f, 0.07954351f, -0.03661142f, 
    -0.03872238f, -0.16094162f, -0.00757807f, 0.00184070f, -0.04116470f, 0.08647873f, -0.33029968f, 0.06834741f, 
    0.06233165f, 0.07623659f, 0.12098457f, 0.08289579f, -0.00777567f, 0.08406322f, -0.11164206f, -0.08311100f, 
    -0.10750513f, 0.05174448f, -0.00431923f, 0.05885930f, 0.06944147f, 0.06649777f, 0.14536104f, 0.00686206f, 
    -0.04117187f, -0.02711419f, -0.14235295f, -0.01003815f, 0.10663141f, 0.11813617f, -0.01333811f, -0.04107324f, 
    0.04706467f, 0.02582160f, 0.11307288f, -0.00577830f, -0.01713189f, 0.01571836f, -0.14509885f, -0.05228579f, 
    0.04159407f, -0.05389174f, 0.12270454f, -0.19497313f, 0.05829880f, 0.19886746f, 0.05237575f, -0.03328538f, 
    0.03451086f, -0.12951989f, -0.00940860f, 0.08200738f, 0.01917417f, 0.10849901f, 0.07720153f, -0.00280957f, 
    0.09020812f, 0.15034528f, 0.09629118f, 0.03571941f, -0.08477602f, -0.06544437f, 0.13495512f, -0.03954442f, 
    -0.01827386f, 0.16927497f, 0.05929637f, -0.02599624f, -0.00481436f, -0.11952063f, 0.08706737f, 0.00874491f, 
    -0.07898580f, -0.09394842f, 0.14899334f, -0.06244946f, 0.14440489f, 0.21789645f, -0.02732511f, 0.08097366f, 
    0.01363916f, 0.04930042f, 0.01672974f, -0.02916967f, -0.01041839f, 0.02873066f, -0.01793061f, 0.07267869f, 
    0.02032509f, -0.13765581f, 0.04890007f, 0.23761968f, -0.12853958f, 0.06404800f, -0.02997477f, 0.06082074f, 
    0.02786690f, -0.05969827f, -0.03564634f, 0.05554591f, 0.05480260f, 0.12861703f, -0.09041093f, 0.03507425f, 
    0.18157993f, -0.10540211f, 0.08338145f, 0.11659836f, -0.13137616f, 0.11723207f, -0.05402848f, -0.13073590f, 
    0.42122850f, -0.46164402f, -0.12636247f, 0.02266092f, -0.18735220f, 0.07387060f, -0.09883128f, 0.05579846f, 
    0.07585901f, 0.05835047f, -0.20531200f, 0.05599161f, -0.11642964f, 0.05803520f, -0.06366315f, -0.04862711f, 
    -0.03961898f, 0.01634103f, -0.10185267f, 0.16557245f, 0.02773156f, 0.05384034f, -0.17035124f, -0.00033241f, 
    -0.29412949f, 0.05235815f, 0.03846545f, -0.07791378f, 0.09963340f, 0.26570246f, 0.01668603f, 0.06337253f, 
    -0.09665433f, 0.06505396f, -0.13596794f, -0.09224688f, 0.27755228f, 0.08723372f, 0.03373643f, -0.14521781f, 
    0.16616721f, 0.05037664f, -0.11436407f, 0.09407279f, -0.11099999f, -0.16905646f, 0.10129807f, 0.00448162f, 
    0.01951161f, 0.10951380f, 0.04407701f, 0.01567810f, -0.06603537f, 0.14126539f, 0.13400218f, 0.03493037f, 
    -0.02517111f, 0.14778583f, -0.03457373f, -0.08864857f, 0.38853338f, -0.26746848f, 0.15633631f, 0.01079907f, 
    -0.20994869f, -0.03273074f, -0.01006083f, -0.07796915f, 0.16531931f, 0.12633397f, 0.07088378f, -0.05242433f, 
    0.13597132f, 0.03480824f, 0.04904095f, -0.00267454f, -0.16509554f, -0.07318092f, 0.12059189f, -0.09422442f, 
    -0.07980327f, -0.03408978f, -0.01516628f, -0.02028364f, 0.30842227f, -0.00222919f, -0.03803703f, 0.17482513f, 
    0.02672492f, 0.18261686f, -0.07682938f, 0.02379783f, 0.06337974f, 0.04870224f, -0.07402983f, 0.09448016f, 
    0.36138466f, -0.23962528f, -0.35990492f, -0.03541033f, -0.08609085f, 0.01845789f, -0.10075409f, 0.07233097f, 
    -0.00902883f, -0.05587985f, -0.18335487f, -0.03878682f, -0.02781447f, -0.06095957f, 0.00821449f, -0.05395096f, 
    0.02389226f, -0.05886827f, 0.02761753f, 0.02940028f, 0.05491572f, -0.11181281f, 0.07375962f, -0.02419086f, 
    -0.03086011f, 0.09805719f, 0.03665555f, -0.00301623f, 0.04836582f, 0.09087308f, 0.05024381f, 0.08461878f, 
    -0.06707809f, -0.07196074f, 0.07817140f, -0.02155020f, 0.14434637f, 0.21768440f, 0.21922094f, -0.00048492f, 
    -0.01758065f, 0.07872519f, 0.04748399f, 0.05243846f, -0.02782411f, 0.04919013f, -0.04430895f, 0.07338065f, 
    -0.11337236f, 0.24076274f, 0.18743381f, -0.05245958f, -0.01574245f, 0.04882754f, -0.06797447f, 0.04665350f, 
    0.01252240f, -0.16907001f, 0.28187740f, -0.05255130f, -0.04105966f, 0.10868112f, 0.01070983f, 0.10871606f, 
    -0.15211906f, 0.15560232f, 0.07770558f, -0.01949572f, 0.00599489f, 0.00783667f, 0.02640637f, -0.03468877f, 
    -0.28386205f, -0.01363694f, 0.14823118f, 0.00332958f, 0.04697285f, 0.17523456f, 0.04090945f, 0.06279240f, 
    -0.06980903f, 0.08374114f, -0.14419580f, -0.04367957f, 0.05657649f, -0.14299634f, -0.08209667f, -0.13540795f, 
    -0.03981357f, -0.09242810f, 0.00880241f, -0.06267413f, 0.07034314f, 0.06140033f, 0.07239259f, -0.08014533f, 
    0.02809008f, 0.10283324f, 0.00864661f, -0.10441644f, -0.01465146f, 0.01086328f, -0.00653955f, 0.06183789f, 
    0.07166085f, -0.08817309f, -0.04538942f, -0.05118476f, -0.07462391f, -0.25092480f, 0.28556398f, 0.00836010f, 
    -0.25693098f, -0.01396075f, 0.05469971f, -0.11294536f, 0.00228590f, 0.12463599f, 0.03847960f, 0.03826897f, 
    0.14093712f, -0.06310009f, -0.10695038f, 0.24272431f, -0.23314665f, 0.06586647f, 0.04412084f, 0.09111372f, 
    -0.02053385f, 0.01570776f, 0.09678573f, -0.08256208f, 0.13573977f, 0.05664971f, -0.04977781f, 0.02062488f, 
    -0.03700089f, -0.05126161f, -0.01515971f, -0.17810780f, -0.15077366f, -0.11709579f, 0.06680124f, 0.00191002f, 
    0.09342577f, 0.13851622f, -0.03428282f, -0.07797032f, 0.07189850f, 0.00846438f, 0.00506589f, 0.17840338f, 
    -0.00275097f, -0.06954616f, -0.06135928f, -0.07870126f, 0.22261406f, -0.36029959f, 0.40250733f, -0.24468638f, 
    -0.10330370f, 0.02958035f, -0.01674352f, 0.01871967f, 0.08183630f, 0.14845912f, -0.09395987f, 0.14123769f, 
    -0.03195855f, -0.12671131f, 0.04435552f, -0.07740860f, -0.05692391f, -0.04007958f, 0.10763599f, 0.00202039f, 
    0.03522409f, 0.03115095f, -0.06207334f, 0.06642456f, 0.04092410f, -0.22182421f, 0.15558948f, -0.12073162f, 
    -0.06746249f, 0.16776706f, -0.00678501f, 0.12670188f, -0.04802312f, -0.10385462f, -0.03645956f, 0.00843667f, 
    0.06819864f, 0.04139646f, 0.21497539f, 0.00720433f, 0.06455012f, 0.13899429f, -0.08572401f, -0.03331783f, 
    0.03991511f, -0.20957601f, -0.04441159f, 0.02259956f, 0.09420196f, 0.05272138f, -0.15319051f, 0.00081084f, 
    -0.15200911f, -0.01989524f, -0.17585477f, -0.03765497f, 0.06206625f, -0.05391081f, -0.09333727f, -0.00743940f, 
    0.16904773f, -0.36837259f, 0.02906822f, 0.22823489f, -0.12731849f, -0.11192797f, 0.03079114f, -0.05825342f, 
    0.05122013f, -0.05186810f, -0.07079884f, 0.17250550f, -0.08660588f, 0.07686553f, -0.29744056f, -0.01973401f, 
    -0.02541310f, 0.21851228f, -0.02537024f, 0.15793632f, -0.04145791f, -0.07973140f, 0.05200291f, 0.00906284f, 
    0.19860564f, -0.03430413f, -0.16783923f, -0.04568253f, -0.03055049f, 0.01313850f, -0.15043625f, 0.12073793f, 
    0.07836802f, -0.06212464f, 0.06415762f, -0.07358296f, 0.19661732f, 0.10775609f, 0.15263602f, -0.09439775f, 
    0.13320027f, 0.01780844f, 0.05947829f, 0.11848750f, -0.06397910f, -0.07450262f, -0.08237337f, 0.04836198f, 
    -0.12437918f, 0.19087920f, -0.15751371f, 0.01029756f, -0.23424956f, 0.04980629f, -0.06135370f, 0.02436277f, 
    0.10288334f, -0.08732852f, 0.01960963f, 0.05534577f, -0.37781101f, 0.16474092f, -0.09052064f, -0.09761238f, 
    -0.13528383f, 0.12307145f, 0.00906352f, 0.24754383f, 0.20911627f, -0.07167400f, -0.06076646f, -0.11409778f, 
    -0.08516619f, -0.02602321f, 0.01301337f, 0.01274997f, 0.09772008f, 0.11121704f, -0.03220035f, 0.04038663f, 
    -0.07094822f, -0.06302888f, 0.00512904f, -0.01459537f, -0.02931149f, 0.29450190f, -0.23149301f, 0.06035209f, 
    0.27240628f, 0.10433138f, 0.16567008f, -0.09331863f, -0.05625262f, -0.00134973f, 0.02294022f, -0.12837431f, 
    -0.31958395f, 0.10613053f, 0.01170387f, -0.00488401f, -0.14942406f, 0.01003123f, 0.02033100f, 0.09812671f, 
    -0.18670779f, -0.05270634f, 0.10191508f, 0.02931828f, -0.17839828f, 0.03038499f, 0.04668203f, 0.07262694f, 
    -0.02838159f, -0.06498160f, -0.03439483f, 0.09987339f, -0.07839669f, -0.08318130f, 0.10561818f, 0.08511882f, 
    0.10244165f, 0.10482008f, 0.23662466f, -0.21244758f, 0.17086893f, 0.19286834f, 0.05235552f, 0.02057630f, 
    -0.10813614f, -0.11580519f, -0.11745238f, 0.01792320f, 0.13489148f, 0.08712554f, 0.01131428f, 0.05003731f, 
    0.02718058f, -0.14047401f, 0.07962402f, 0.01164658f, -0.00792173f, -0.10121924f, -0.01602699f, 0.01604148f, 
    -0.17702405f, 0.14323023f, -0.00412320f, 0.05280063f, 0.01393910f, -0.00434435f, 0.07625648f, 0.05246609f, 
    0.10426838f, -0.07392977f, -0.09069591f, 0.00482280f, 0.08288755f, 0.16254342f, 0.07579906f, 0.11453728f, 
    -0.10956352f, 0.03866797f, 0.18023208f, 0.01105629f, -0.11863732f, 0.12516771f, -0.07476693f, 0.13253315f, 
    -0.06523488f, 0.09105675f, 0.09245205f, 0.07404958f, 0.04823681f, 0.12132089f, -0.00520116f, 0.00675058f, 
    -0.05138819f, -0.25119239f, 0.04461767f, 0.04830447f, -0.03584931f, -0.02820970f, -0.09113368f, 0.07262053f, 
    0.08613490f, -0.02978615f, 0.08737426f, 0.03518106f, -0.05302887f, -0.01974201f, 0.00906027f, -0.00304256f, 
    0.22147705f, 0.14067432f, 0.12052523f, 0.02646742f, 0.01793644f, 0.01782517f, 0.00043611f, 0.07349584f, 
    -0.05248527f, -0.17262325f, 0.01061303f, -0.00303814f, 0.25082880f, -0.05230360f, -0.07093566f, 0.03020866f, 
    -0.02414164f, -0.00077086f, 0.18757725f, -0.04037494f, -0.04078354f, 0.03089530f, 0.00426513f, 0.00867115f, 
    -0.09371611f, -0.03300389f, 0.11225299f, 0.00934565f, -0.09634364f, 0.12807344f, 0.03363186f, 0.01047941f, 
    -0.00102370f, -0.03061531f, -0.01308895f, -0.02613558f, -0.13025400f, -0.21374598f, 0.14853874f, -0.03651800f, 
    -0.02417297f, -0.02507537f, -0.05135923f, 0.13554746f, -0.00954543f, 0.02144059f, -0.02275472f, -0.01454761f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00202510f, -0.02507653f, 0.12225389f, -0.00399629f, 0.23159146f, 0.03612905f, 0.10653675f, -0.12747043f, 
    0.26252565f, 0.04374581f, -0.02683515f, -0.03970121f, -0.00607516f, -0.01990250f, -0.00604400f, 0.10441793f, 
    0.03353314f, 0.00360266f, 0.09245776f, 0.03103842f, -0.02534279f, 0.01609777f, -0.10415912f, 0.02153040f, 
    0.07259709f, 0.00981463f, 0.10754193f, 0.02637599f, -0.00302237f, -0.09139274f, 0.00462656f, 0.02139688f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.00479933f, -0.15665120f, -0.33078811f, 0.10909089f, -0.11865780f, 0.11614877f, 0.12857087f, -0.19025560f, 
    -0.36529458f, 0.08589086f, 0.24741031f, 0.22343323f, -0.07386852f, 0.07148454f, 0.12084175f, -0.07850569f, 
    -0.00366539f, 0.03713966f, 0.21597174f, 0.02053974f, -0.05220009f, -0.09576097f, 0.38005722f, -0.16579887f, 
    -0.15800203f, -0.15338846f, -0.62776178f, 0.25603291f, -0.03794712f, 0.10283173f, -0.14610028f, 0.26343095f, 
    -0.15359321f, 0.04509716f, 0.50051475f, -0.08789621f, 0.24687865f, 0.14306682f, 0.06913266f, -0.35685962f, 
    0.11968013f, -0.06096127f, 0.24291965f, 0.35017636f, -0.07605369f, 0.12474946f, -0.07912225f, -0.19856605f, 
    0.03405561f, -0.04807907f, -0.21966924f, -0.09846447f, 0.13798325f, -0.04992877f, -0.56469506f, -0.07085905f, 
    0.17969903f, -0.00707646f, -0.40460807f, -0.64754736f, -0.11649173f, 0.01549786f, -0.01282905f, 0.17012821f, 
    -0.03412804f, 0.01915208f, -0.24834478f, 0.01334687f, -0.10645257f, 0.02500007f, 0.00121164f, -0.21438439f, 
    -0.01950713f, 0.00604091f, 0.18054317f, -0.72805065f, 0.57422537f, -0.02307935f, 0.15300235f, -0.28862157f, 
    0.28368923f, -0.11049004f, -0.07635406f, -0.05354242f, -0.17688087f, -0.00718460f, -0.03453998f, 0.14883052f, 
    0.08862591f, 0.11795832f, 0.14950317f, 0.09576596f, 0.07765321f, -0.41827992f, 0.08436805f, -0.24489467f, 
    -0.00314366f, 0.15588453f, -0.08759397f, 0.15780845f, 0.00798703f, -0.17910779f, -0.20349421f, 0.30315772f, 
    -0.17281573f, 0.18550737f, -0.09497930f, 0.14944036f, 0.24655689f, 0.08081575f, 0.11753292f, 0.04658751f, 
    0.20328829f, -0.13957252f, -0.38745493f, 0.01884537f, -0.16645415f, -0.10962000f, 0.31373304f, 0.02182400f, 
    -0.35413688f, 0.08299462f, -0.03173000f, -0.35010681f, 0.01107075f, 0.18844426f, -0.11010209f, -0.47090232f, 
    -0.08029176f, 0.15092678f, -0.12660640f, 0.03642516f, -0.65050787f, 0.19688779f, -0.40528351f, 0.21726424f, 
    -0.15168186f, 0.04096662f, -0.03753601f, 0.16548066f, 0.13905817f, -0.01533875f, -0.06238593f, -0.23934548f, 
    -0.08808268f, 0.09629419f, -0.03730777f, 0.01816942f, 0.14102855f, -0.06471526f, -0.04819248f, 0.05807554f, 
    0.22171086f, -0.00460251f, 0.02412634f, 0.38985318f, -0.10580356f, 0.16046083f, 0.15644436f, 0.21446936f, 
    -0.04344197f, -0.02456614f, -0.10668857f, 0.00686972f, 0.03800514f, -0.09909605f, 0.22984192f, -0.47297654f, 
    -0.12377600f, 0.28058895f, -0.35444888f, 0.17484646f, -0.54484558f, -0.13444312f, -0.09639415f, 0.05135313f, 
    -0.23140118f, -0.05748708f, 0.57035553f, -0.04588059f, -0.15737994f, -0.07878946f, -0.02609783f, -0.05076427f, 
    0.09324931f, -0.02829623f, 0.08487123f, 0.03725709f, -0.15524629f, -0.21382548f, -0.07735670f, 0.20200533f, 
    -0.10389293f, 0.13265283f, -0.54910409f, 0.11887557f, 0.14203694f, 0.06583222f, 0.21522012f, 0.24146579f, 
    -0.04567687f, -0.31602642f, -0.23779832f, -0.52053678f, -0.67105174f, 0.09178586f, 0.00869059f, -0.07107016f, 
    0.02599753f, 0.09527358f, -0.93626428f, -0.04644405f, 0.00494363f, -0.06630190f, -0.47083753f, 0.00409598f, 
    0.12967780f, -0.11286288f, 0.40280408f, 0.30974072f, -0.01233636f, -0.20146491f, 0.12952793f, -0.20278946f, 
    -0.12219697f, 0.11296537f, -0.06349573f, 0.06154894f, -0.35267943f, 0.18857010f, 0.23326266f, 0.55188859f, 
    0.23839091f, -0.23045222f, -0.28713486f, -0.31848094f, -0.13935249f, -0.00757005f, -0.10945720f, -0.30917332f, 
    -0.56350082f, 0.14189295f, -0.11059324f, -0.11686136f, -0.16247641f, -0.15169388f, 0.31081894f, -0.09491657f, 
    -0.10659955f, 0.17644943f, -0.14513665f, -0.29709089f, -0.00510368f, -0.06273352f, 0.14962144f, 0.07172310f, 
    0.00308654f, -0.04683936f, -0.13799277f, -0.11533016f, -0.17548503f, -0.36462098f, 0.25997314f, -0.22203122f, 
    0.25928372f, 0.23283845f, -0.64949429f, -0.43824664f, 0.04860777f, -0.11062942f, 0.08426214f, 0.39051539f, 
    -0.37789771f, 0.08043836f, -0.37809554f, 0.05019435f, -0.03351727f, 0.13515276f, -0.21941905f, -0.02724806f, 
    -0.28710124f, 0.14683591f, -0.39846686f, -0.19737329f, 0.05646541f, -0.26635468f, 0.18203092f, -0.34205645f, 
    0.03751822f, -0.15959154f, 0.30727151f, -0.09740894f, -0.37087938f, 0.05647563f, -0.05825239f, 0.24638799f, 
    -0.01208279f, -0.54607338f, 0.24461122f, -0.07554107f, -0.06123663f, -0.11323033f, -0.07466072f, 0.18947574f, 
    -0.24934711f, -0.12630109f, 0.49161169f, -0.12631322f, 0.06869486f, -0.08072802f, -0.37891588f, -0.07434344f, 
    0.31929776f, -0.16901626f, 0.00191305f, 0.40482053f, 0.07925845f, -0.04935717f, 0.01762836f, -0.47569868f, 
    0.11904330f, -0.05704106f, -0.40220428f, -0.01012408f, -0.21533790f, -0.18470502f, -0.27894887f, -0.37423402f, 
    -0.03258203f, -0.11526413f, -0.09020843f, -0.49775770f, -0.39050722f, 0.12639557f, 0.06458563f, 0.25804281f, 
    0.41017494f, 0.02778009f, -0.51022083f, -0.05714277f, 0.00395786f, -0.15320162f, -0.20690729f, 0.15671928f, 
    0.26116624f, 0.00354096f, 0.02513350f, -0.45483088f, 0.03306059f, 0.39337641f, 0.07753792f, 0.18636474f, 
    0.15805657f, -0.04589488f, -0.10424997f, 0.13712496f, 0.24177213f, -0.59812009f, -0.13156204f, -0.05602260f, 
    0.21142267f, -0.15303433f, 0.13257675f, 0.09121877f, -0.13303651f, 0.07903022f, 0.05168577f, -0.12755863f, 
    -0.51386440f, 0.16627873f, 0.02829668f, 0.07933556f, -0.13793191f, 0.15544209f, -0.22222142f, 0.12306022f, 
    -0.61155695f, -0.10901901f, 0.22423106f, -0.31748787f, -0.00787100f, 0.55003464f, -0.13123827f, -0.23624223f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.45491794f, 0.01789295f, 0.21537398f, 0.01417715f, -0.03616324f, 0.03173670f, 0.01776313f, -0.15996809f, 
    0.16798706f, -0.14237230f, -0.02133319f, 0.07531406f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
