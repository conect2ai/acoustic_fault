#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.30409092f, 0.49981430f, 0.58383280f, -0.11597915f, -0.17056361f, -0.02505056f, 0.43250546f, 0.29160330f, 
    -0.22128288f, -0.02169179f, -0.37922695f, -0.00452684f, -0.29945910f, 0.95659333f, -0.36243254f, 0.07609209f, 
    -0.01502158f, -0.42176479f, 0.40802005f, 0.51752102f, 0.41870704f, -0.20511460f, 0.19150551f, -0.30334756f, 
    -0.44281408f, -0.07830336f, -0.23238043f, 0.16136265f, -0.12636048f, 0.13262595f, 0.26278549f, 0.19595911f, 
    0.85768503f, 0.44403908f, 0.13426800f, 0.40907830f, -0.33840251f, 0.50601035f, -0.09880660f, -0.04448646f, 
    -0.65516633f, -0.91556555f, -0.09714267f, 0.09915318f, -0.03819913f, -0.91953576f, -0.31560704f, 0.05821807f, 
    -0.09601257f, 0.02343698f, -0.16760938f, 0.33494979f, 0.55498838f, -0.22934332f, 0.24544536f, 0.56387222f, 
    0.47616285f, 0.36610562f, -0.12090976f, -0.03667841f, 0.50935864f, -0.03072041f, 0.61984164f, 0.42310682f, 
    0.55660403f, 0.43364486f, -0.63625890f, 0.14249261f, -0.47679785f, -0.05059549f, -0.05077629f, 0.28716239f, 
    -0.33884174f, -0.75296497f, -0.56219172f, 0.47794008f, 0.41328236f, 0.12466717f, 0.07280876f, -0.04027334f, 
    0.13269874f, 0.33434141f, 0.00119838f, 0.32313278f, 0.34992048f, 0.41273382f, 0.07672533f, -0.78338325f, 
    -0.19090994f, -0.04036741f, -0.98083949f, 0.39971080f, 0.00233158f, 0.58000767f, 0.91360980f, 0.39207122f, 
    -0.03880927f, -0.18664934f, -0.08568617f, -0.33163133f, -0.49825281f, -0.65369862f, -0.16034000f, 0.21060161f, 
    0.43560484f, -0.33611482f, -0.07818567f, -0.53620732f, 0.17771491f, -0.62927294f, -0.29988110f, -0.62884146f, 
    -0.45212257f, -0.34026814f, -0.24134757f, 0.25712475f, 0.06155002f, -0.45575815f, -0.05835837f, 0.64929557f, 
    0.26236653f, -0.55294836f, 0.13283132f, -0.24986507f, 0.31649056f, 0.61426955f, 0.60739708f, 0.50702190f, 
    0.54432487f, 0.28144252f, -0.12184095f, 0.55923063f, -0.15728472f, -0.01514082f, -0.04252700f, 0.09970155f, 
    0.44729629f, -0.55876374f, 0.27460328f, -0.58179688f, -0.39726865f, 0.19167207f, 0.22787175f, 0.52715117f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01216719f, -0.01007758f, 0.33858058f, 0.27890554f, -0.03426485f, 0.04629595f, -0.54875469f, 0.15956286f, 
    -0.08455838f, 0.08614796f, 0.04701579f, 0.01213339f, 0.23244874f, -0.22939000f, 0.30838722f, 0.16879869f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.22007193f, -0.16415560f, 0.12279622f, -0.12120765f, 0.11186095f, -0.13488936f, -0.02926601f, 0.07663541f, 
    0.06692468f, -0.21663491f, 0.10168959f, 0.25776264f, 0.11348853f, 0.09637181f, 0.09412557f, -0.08455799f, 
    -0.15580411f, -0.32623515f, -0.08923659f, 0.11323081f, 0.21611789f, -0.14559449f, 0.04283864f, -0.05306093f, 
    -0.03598464f, 0.14354752f, 0.07767851f, -0.14915998f, -0.16345443f, -0.11833374f, 0.08971421f, -0.03043341f, 
    -0.05709611f, 0.40382272f, 0.04893238f, -0.08561262f, -0.19038339f, -0.11928747f, 0.13051443f, -0.32059616f, 
    -0.02146621f, -0.00868709f, 0.03865143f, -0.07279624f, 0.06385286f, 0.02035219f, 0.12704837f, 0.30047110f, 
    0.23759101f, 0.12933952f, 0.00476040f, 0.04130196f, 0.00530172f, 0.19866376f, 0.13299935f, -0.22591886f, 
    -0.06524833f, -0.23212343f, -0.17976114f, -0.09780795f, 0.13059682f, 0.01367048f, -0.09012011f, -0.25427577f, 
    0.10353434f, 0.28409043f, -0.26960719f, -0.07694839f, -0.03601823f, -0.06221288f, 0.05742734f, 0.04926402f, 
    0.06909575f, 0.11645589f, 0.01929604f, 0.15798816f, 0.14365797f, 0.38884658f, 0.03899273f, -0.14725067f, 
    -0.05994571f, 0.29686728f, 0.05121765f, -0.10851151f, 0.03744566f, -0.09651476f, -0.12180442f, -0.01118265f, 
    0.04781353f, 0.11976512f, -0.01344220f, 0.07304547f, -0.13262898f, 0.08172639f, 0.07820372f, -0.02954806f, 
    0.02270040f, 0.03166200f, 0.28863817f, 0.32388186f, 0.35965610f, 0.03173832f, 0.04766667f, 0.14727359f, 
    -0.19676188f, -0.14266939f, -0.12947637f, 0.03109318f, 0.05059024f, 0.13925768f, 0.13205607f, -0.24769090f, 
    0.13200401f, -0.01781815f, 0.00983208f, -0.04264048f, -0.10623460f, -0.00262668f, -0.31842065f, -0.28897890f, 
    0.12417967f, -0.16932812f, -0.03626726f, -0.14805278f, 0.01705012f, -0.07855710f, 0.16425727f, 0.06458151f, 
    0.19913697f, 0.11643507f, 0.07031678f, -0.01015077f, 0.05377235f, 0.14314969f, 0.18178195f, -0.34589911f, 
    0.18937199f, 0.15632515f, 0.01358134f, 0.14930324f, -0.10427155f, -0.10746540f, -0.01943979f, -0.10856984f, 
    0.04068546f, 0.29359344f, -0.12856947f, -0.27519527f, 0.04376965f, 0.08318668f, -0.09736313f, 0.04636791f, 
    -0.08444367f, -0.22541086f, -0.25984758f, -0.03309459f, 0.27513075f, 0.02108541f, 0.09971901f, 0.02519672f, 
    -0.03029650f, 0.19125552f, 0.24952820f, -0.01494789f, 0.07204897f, 0.19972804f, -0.11200278f, 0.06354561f, 
    0.03239183f, -0.06219608f, 0.18596624f, 0.04734032f, 0.08462226f, -0.20410331f, 0.00653090f, 0.08016689f, 
    0.07605691f, 0.22451282f, 0.09506927f, 0.11121283f, 0.14042698f, -0.00156485f, -0.25714618f, -0.00159878f, 
    0.18006641f, -0.04188698f, 0.00071774f, 0.10489934f, 0.01301835f, -0.77814364f, -0.14025903f, 0.15936297f, 
    -0.05938859f, 0.03006921f, 0.01003278f, -0.05613857f, 0.00143224f, 0.13748311f, -0.01840933f, 0.18697231f, 
    -0.36675057f, -0.08591571f, -0.09124075f, -0.15962462f, 0.02454022f, -0.00654853f, -0.19549695f, 0.00288602f, 
    -0.05719970f, -0.01909946f, 0.01008261f, -0.24871722f, -0.01650700f, 0.00192684f, 0.05905174f, 0.14316595f, 
    -0.06055292f, -0.45145839f, -0.09936514f, 0.14477706f, 0.13488923f, 0.07653566f, -0.08175583f, 0.00378152f, 
    -0.14282759f, 0.18216118f, -0.03301188f, 0.18651879f, 0.02599002f, -0.07685192f, -0.09788788f, 0.10877500f, 
    0.19710733f, 0.29137793f, 0.43525130f, -0.06435533f, 0.08075871f, -0.14567891f, 0.09663804f, -0.13014369f, 
    -0.14375728f, -0.04042169f, -0.15661849f, -0.09922829f, -0.09860054f, -0.05118608f, -0.00654464f, -0.12427641f, 
    0.00098778f, -0.05456779f, 0.10918202f, 0.20124269f, -0.22259441f, -0.15243205f, 0.14344957f, 0.14388886f, 
    0.02606711f, 0.06231622f, 0.07844795f, -0.03936005f, -0.12873192f, -0.12493988f, 0.14039601f, -0.04637180f, 
    0.18840307f, -0.26086351f, 0.07347509f, -0.06794167f, 0.10248941f, -0.03582298f, 0.01919450f, -0.02018304f, 
    0.17866969f, -0.01973045f, 0.07520966f, -0.20438202f, -0.03959225f, -0.07872180f, -0.00471972f, -0.24801379f, 
    -0.01373989f, 0.12540154f, 0.12502496f, 0.10868678f, 0.01541443f, -0.10797519f, -0.00751215f, 0.00354360f, 
    0.77376974f, 0.14284056f, -0.08105806f, 0.03676767f, 0.07894617f, -0.09736008f, 0.01080274f, -0.00264493f, 
    -0.01154353f, -0.18542983f, -0.21049832f, -0.24657622f, -0.01181761f, 0.06969105f, 0.10556193f, 0.00975603f, 
    -0.06002304f, 0.15503326f, 0.20937015f, 0.17980881f, -0.18361203f, 0.14574724f, -0.05437007f, 0.09220657f, 
    0.03184319f, 0.03023962f, 0.24328133f, -0.28606862f, 0.08861937f, 0.26713157f, -0.15220362f, 0.16537222f, 
    0.19160111f, 0.05987145f, -0.03576125f, -0.20970294f, 0.21446389f, 0.00224878f, -0.21312460f, 0.15156755f, 
    -0.00662876f, 0.05913937f, -0.06198989f, 0.08938928f, -0.02244805f, -0.42795485f, 0.00707226f, -0.09160821f, 
    0.15327108f, 0.00427605f, 0.04090622f, -0.01137133f, 0.05295821f, 0.12875247f, 0.29063621f, -0.18489861f, 
    -0.10911816f, 0.28035969f, -0.18869530f, -0.01254440f, 0.16531417f, -0.07928065f, -0.22792500f, 0.34514078f, 
    0.41742045f, -0.32811186f, 0.11494414f, -0.01827972f, 0.18200251f, 0.10903978f, 0.03984617f, -0.21420756f, 
    -0.09614368f, -0.12965541f, 0.16082460f, 0.09436447f, 0.08609235f, -0.02594591f, -0.07817481f, 0.00206589f, 
    -0.04426994f, -0.28210628f, -0.10963317f, 0.09015907f, 0.12771741f, 0.06240127f, -0.04161059f, 0.17630120f, 
    -0.13143577f, 0.13888770f, -0.49186549f, -0.37761053f, 0.08286849f, -0.01344889f, 0.01053934f, -0.10966181f, 
    -0.17475863f, 0.01754062f, 0.04289015f, 0.08879462f, 0.05848701f, 0.03783103f, 0.00330607f, -0.02380658f, 
    -0.04495339f, -0.28140074f, -0.25664735f, -0.00643979f, -0.18898284f, 0.03201950f, -0.47397685f, 0.22403438f, 
    -0.01760639f, 0.14025186f, -0.13816705f, 0.01196056f, -0.15217267f, -0.36840516f, -0.23653387f, -0.19739561f, 
    -0.01515228f, 0.08321674f, 0.33727655f, -0.02624888f, -0.04018370f, -0.00723178f, 0.43867251f, 0.00968006f, 
    0.14154236f, 0.16330677f, 0.17922862f, 0.06628183f, -0.01758441f, 0.12460298f, 0.17058851f, 0.22034459f, 
    0.20730439f, -0.15884827f, 0.25314969f, 0.02245762f, 0.00839374f, 0.15937981f, 0.00514713f, -0.00750430f, 
    0.08493181f, 0.12986095f, 0.01851937f, 0.09676173f, 0.07534488f, -0.03257878f, 0.12786050f, 0.03604840f, 
    0.00716691f, -0.09698597f, -0.06662413f, -0.33179763f, 0.03646109f, 0.06758843f, 0.07704350f, 0.22015534f, 
    -0.13753626f, -0.05029498f, -0.10085619f, 0.09208331f, 0.10044124f, 0.06402625f, -0.05041070f, -0.02551441f, 
    -0.11674755f, -0.00810423f, -0.14620195f, 0.08260313f, 0.15266433f, 0.07951924f, -0.05058320f, 0.12516648f, 
    0.25642228f, -0.13496661f, 0.04791375f, 0.07719971f, -0.37594545f, -0.36839399f, -0.28811026f, 0.31192461f, 
    0.17250891f, 0.14085682f, -0.02728327f, 0.08363016f, -0.00995089f, -0.12011223f, -0.10878932f, 0.25169906f, 
    -0.11823203f, -0.00651592f, -0.01833174f, -0.04062396f, -0.03628856f, -0.08297312f, 0.11558447f, 0.33660874f, 
    -0.18365318f, 0.10354681f, -0.25889957f, -0.12887293f, 0.05621772f, 0.05128051f, 0.07587118f, -0.24971132f, 
    -0.35653666f, -0.22758405f, 0.03127719f, 0.00732608f, 0.16384503f, -0.02794911f, -0.05854882f, 0.13516399f, 
    0.24811836f, 0.08202179f, 0.16736721f, 0.00040919f, -0.14879885f, 0.03516431f, 0.01622122f, -0.02942207f, 
    0.09656388f, 0.16815591f, -0.09586422f, 0.15671112f, -0.08121424f, -0.17911649f, 0.06907321f, 0.16236687f, 
    0.08170253f, 0.09515780f, -0.17437886f, -0.17973398f, 0.00911871f, 0.01945148f, 0.00285489f, -0.15745725f, 
    0.18512695f, -0.00491451f, 0.03610607f, 0.31238717f, 0.19938363f, 0.21485922f, 0.12301675f, -0.09149259f, 
    -0.35293117f, 0.06114348f, 0.25038230f, -0.16764155f, -0.22400367f, 0.58711010f, -0.06634744f, -0.10117580f, 
    -0.09621626f, 0.25699407f, -0.09804829f, -0.02481251f, -0.01461324f, 0.21948346f, -0.19424160f, -0.01323246f, 
    -0.15030921f, -0.13261081f, -0.05969026f, 0.12437845f, -0.05062998f, 0.21935013f, -0.13033316f, -0.02476443f, 
    0.16555391f, 0.11457930f, -0.00511804f, -0.21235590f, 0.01255492f, 0.06611673f, 0.09320279f, -0.54862750f, 
    0.09887691f, -0.11732972f, 0.07309195f, 0.14794491f, -0.00180804f, 0.12204203f, -0.05945409f, 0.01658600f, 
    -0.03462428f, 0.03211328f, 0.07378137f, -0.04115205f, 0.01362862f, -0.05277963f, 0.06994313f, -0.01693995f, 
    -0.06928129f, 0.06636968f, -0.05950092f, -0.05211863f, 0.00950059f, -0.05912415f, -0.00194700f, -0.03578630f, 
    0.00837350f, -0.05962000f, -0.00876826f, -0.02878098f, 0.07055022f, 0.00250520f, -0.05887561f, -0.07874191f, 
    -0.02559111f, 0.07430359f, -0.03209791f, 0.04551394f, -0.05871852f, -0.03562496f, -0.04151418f, 0.01564748f, 
    -0.06880403f, -0.02882048f, 0.02112743f, -0.01424639f, 0.05276468f, 0.02805634f, 0.06451491f, -0.03643952f, 
    0.03921150f, -0.08584066f, -0.01582186f, 0.00826426f, -0.01515175f, 0.01681932f, 0.07193074f, -0.06128209f, 
    -0.04065731f, -0.01462201f, -0.01827328f, -0.08037810f, -0.08597443f, 0.04103978f, -0.00422497f, -0.04149340f, 
    -0.02441375f, 0.03049925f, 0.00426349f, 0.04953835f, -0.07723285f, -0.04937617f, 0.03446389f, 0.03842338f, 
    0.07225262f, -0.07777285f, -0.06469666f, 0.00701889f, -0.02098545f, 0.05147417f, -0.08758533f, 0.01803104f, 
    -0.09157144f, -0.00618746f, -0.01548092f, -0.00141851f, -0.08088247f, -0.01185368f, -0.02584843f, 0.03062003f, 
    -0.08507451f, 0.00047709f, -0.05821817f, 0.00711069f, -0.03784313f, 0.00032428f, 0.00385798f, -0.07328577f, 
    -0.03487491f, -0.05254575f, 0.00005549f, 0.03252705f, -0.00895217f, 0.05336637f, -0.07167441f, 0.02212062f, 
    0.00019185f, -0.03093667f, 0.02148467f, 0.05435021f, -0.00777641f, 0.01085815f, -0.05685967f, -0.00878380f, 
    -0.08693741f, -0.03451268f, 0.06567573f, -0.01151166f, -0.07455924f, -0.07188278f, 0.06930730f, -0.00559891f, 
    0.03130128f, -0.06130948f, 0.00210250f, -0.08372538f, 0.00063857f, -0.03874865f, -0.01352126f, 0.06461174f, 
    -0.05399057f, -0.02251942f, -0.05058974f, -0.08490958f, -0.00021013f, -0.06417227f, 0.00123076f, -0.05107961f, 
    -0.06215234f, 0.03257422f, -0.02043916f, -0.05509584f, 0.03968542f, -0.03798860f, -0.07377561f, 0.06954277f, 
    0.06108971f, 0.07299955f, 0.04950093f, -0.01177414f, 0.04400925f, -0.04019244f, 0.01116427f, 0.05478622f, 
    -0.01601386f, -0.08808018f, -0.10369531f, -0.10154489f, -0.05629905f, -0.04628590f, -0.07499399f, -0.08271995f, 
    -0.10788469f, -0.02075003f, 0.03039718f, 0.04711639f, -0.04083242f, -0.06111658f, -0.11640300f, 0.04653519f, 
    -0.10382015f, 0.03304707f, -0.10115343f, -0.00467345f, 0.01435401f, -0.03458185f, -0.01477065f, -0.00469408f, 
    -0.01027503f, -0.11072911f, -0.01532158f, 0.00582828f, -0.07833705f, -0.05513409f, -0.03966695f, 0.01178606f, 
    -0.07135040f, 0.00221119f, -0.03491597f, -0.02683947f, -0.05092509f, -0.10335816f, 0.00059245f, 0.03730683f, 
    -0.00249870f, -0.01137625f, -0.00908519f, -0.02334093f, -0.07032853f, -0.07402499f, -0.08126261f, -0.05679079f, 
    -0.09085618f, -0.08986426f, 0.01586687f, -0.00918031f, -0.03185477f, -0.05560705f, -0.07679643f, -0.08852953f, 
    0.06595203f, -0.06781999f, 0.03872405f, 0.04365477f, -0.06359316f, -0.02083871f, 0.01554482f, 0.02406493f, 
    0.03669156f, 0.00237901f, -0.02913062f, 0.00207683f, 0.03355008f, 0.00667333f, 0.04203135f, -0.01490181f, 
    -0.08066098f, 0.00457409f, -0.08365663f, 0.01347133f, -0.06030193f, -0.09491079f, 0.01681028f, -0.02112011f, 
    -0.00905589f, 0.03287153f, -0.03096523f, -0.03828100f, -0.05710530f, -0.10404246f, -0.11750450f, -0.08926809f, 
    -0.09771595f, -0.08843990f, -0.11717562f, 0.03653252f, -0.10122414f, -0.10070831f, -0.07401176f, 0.03420011f, 
    0.01448482f, 0.04500777f, -0.04302840f, 0.01973866f, -0.04998719f, -0.10924982f, -0.11442317f, -0.08086814f, 
    -0.02258096f, -0.02069335f, -0.09487616f, -0.09002422f, -0.04984165f, -0.08640915f, -0.10735154f, -0.09098020f, 
    -0.05036600f, -0.10968599f, -0.05109622f, 0.03218400f, 0.00877469f, 0.02545514f, -0.10377446f, -0.06121990f, 
    -0.03872317f, -0.02050012f, -0.03358231f, -0.01856712f, 0.02167779f, -0.03680017f, -0.05521840f, -0.09067226f, 
    -0.03953743f, -0.06280329f, -0.05939611f, -0.01114614f, -0.04292715f, -0.00530014f, -0.01748103f, -0.07003497f, 
    0.01885933f, -0.02362718f, 0.03988177f, -0.07466584f, 0.02263846f, -0.03753084f, -0.05505763f, -0.07686967f, 
    -0.04640444f, 0.04725405f, -0.04914690f, -0.06535625f, 0.03275127f, -0.02525194f, -0.01427016f, -0.07906940f, 
    -0.07131155f, 0.01754229f, -0.04332382f, 0.02983986f, 0.07382236f, -0.04031365f, -0.07157149f, -0.08900487f, 
    0.03916883f, 0.04325331f, 0.05403272f, -0.07108377f, -0.03648587f, 0.03535651f, -0.00913695f, -0.06627900f, 
    -0.02398769f, -0.05938379f, 0.04767904f, 0.03416332f, -0.07690051f, -0.08310331f, 0.03458887f, -0.01559661f, 
    -0.08076015f, -0.08710315f, -0.03048779f, 0.00127558f, 0.02231965f, -0.02791248f, 0.07300228f, -0.01518473f, 
    -0.02436194f, -0.05543977f, -0.04293500f, 0.03882501f, 0.06477436f, 0.04505281f, -0.01832567f, 0.02615609f, 
    -0.00367100f, -0.07362882f, 0.00731006f, -0.04418205f, 0.00933072f, -0.08326576f, 0.00700752f, -0.04337011f, 
    0.05034476f, 0.07068944f, 0.03989529f, 0.07017701f, -0.01453767f, -0.06222917f, 0.06796661f, -0.09532654f, 
    0.02123289f, -0.03627420f, 0.05769186f, -0.08590474f, 0.07076240f, 0.05746786f, 0.00273567f, -0.00863902f, 
    -0.05272371f, -0.02609049f, -0.00723246f, -0.07829281f, -0.01543363f, 0.02915215f, -0.02469617f, -0.01864099f, 
    -0.09294240f, 0.02590617f, -0.02682906f, -0.02251400f, -0.07236329f, -0.04465211f, 0.04214663f, -0.08031945f, 
    0.04833516f, -0.01368457f, -0.01317929f, -0.02803133f, 0.01487090f, -0.02534261f, 0.00100239f, -0.03832953f, 
    0.03740786f, 0.01429580f, 0.03795713f, 0.06056790f, 0.04721712f, -0.04619198f, 0.01310318f, 0.02101044f, 
    -0.07735558f, -0.06172094f, -0.01296345f, 0.01945634f, -0.02275576f, 0.01207229f, -0.05898311f, -0.04747893f, 
    0.03703846f, 0.05400170f, -0.03631454f, 0.00554334f, -0.06479746f, -0.06263351f, 0.02967693f, 0.00402531f, 
    -0.05340355f, -0.05024043f, -0.09218694f, 0.00212124f, -0.05647299f, -0.06964006f, -0.00485570f, -0.08983261f, 
    0.01609637f, 0.01857549f, 0.00852492f, 0.04243405f, -0.01856691f, 0.00529856f, -0.06380677f, 0.06372239f, 
    0.04524471f, -0.04420654f, -0.02281407f, -0.08406188f, 0.00631505f, -0.00091626f, -0.03520411f, -0.08514327f, 
    -0.46993563f, -0.19764557f, -0.31185359f, 0.15478842f, -0.08151671f, -0.08837656f, -0.06962483f, -0.16194886f, 
    -0.02392033f, 0.27846277f, 0.14350829f, 0.00766839f, 0.00789987f, -0.02595924f, 0.07178936f, 0.17565621f, 
    -0.15452929f, -0.09677806f, -0.41102073f, -0.06841791f, 0.04751975f, 0.00460351f, 0.09847045f, 0.15673098f, 
    -0.12509508f, -0.08247552f, 0.11915908f, 0.01958141f, 0.22102651f, -0.14651416f, 0.05566018f, -0.01790548f, 
    -0.07644201f, 0.08751460f, 0.19258344f, 0.11013584f, 0.18397973f, -0.29215181f, -0.04156980f, -0.05897035f, 
    -0.19922999f, -0.03771038f, -0.12715204f, 0.20489319f, -0.01471870f, 0.22676796f, 0.26820242f, 0.25410059f, 
    -0.02649271f, -0.06334227f, -0.07425646f, 0.03532755f, -0.06641092f, 0.02403507f, -0.14159045f, -0.24921145f, 
    -0.09221657f, 0.11585332f, -0.05725127f, 0.11425084f, -0.16240807f, -0.04397358f, -0.04743797f, -0.38935784f, 
    -0.11648197f, 0.19374566f, 0.15563296f, 0.14457281f, 0.04420713f, -0.17561893f, -0.04527888f, -0.06441993f, 
    0.30885309f, 0.42395887f, 0.12336679f, 0.01625389f, -0.06603183f, 0.10718798f, 0.22625729f, 0.21409033f, 
    0.07653604f, -0.20652601f, -0.21687408f, -0.17621231f, -0.21541664f, -0.09444898f, 0.03184332f, 0.02635566f, 
    -0.02014987f, 0.08712757f, 0.02357559f, -0.04900686f, -0.03761189f, 0.02743983f, -0.07032217f, -0.07711672f, 
    0.17743486f, 0.20309947f, -0.04547802f, 0.04273279f, 0.12709811f, 0.24178363f, 0.32910272f, 0.16555631f, 
    -0.14004715f, -0.16317098f, 0.07846504f, 0.09233428f, 0.24124256f, 0.01055780f, -0.09229865f, -0.00873621f, 
    -0.08883813f, 0.06892303f, 0.03226496f, 0.00072169f, -0.12010656f, -0.29567206f, -0.20778590f, -0.27398551f, 
    -0.05914829f, -0.05543961f, -0.01597375f, 0.11205039f, -0.02074315f, 0.17085212f, -0.40780833f, -0.24421954f, 
    0.01216632f, -0.09928174f, 0.08371402f, 0.17357484f, -0.05394622f, 0.14069779f, -0.09994385f, 0.37847134f, 
    0.16886692f, -0.07675790f, 0.03397823f, 0.10236654f, -0.24202064f, 0.11988037f, 0.18596922f, 0.05415338f, 
    0.04444116f, 0.01801445f, -0.07711889f, -0.06605314f, -0.04255067f, -0.05922760f, 0.01645727f, -0.08790781f, 
    0.03115662f, -0.05242351f, 0.01502071f, -0.09657096f, -0.04512604f, 0.00670818f, 0.02731965f, 0.04612248f, 
    -0.09627171f, -0.08652143f, -0.06121368f, 0.05539013f, -0.06253050f, -0.09708572f, -0.05418363f, -0.00280782f, 
    -0.09577356f, 0.04774740f, -0.04932475f, -0.07990610f, -0.03173814f, -0.01539926f, -0.00534523f, -0.02207068f, 
    -0.01363867f, -0.00248525f, -0.05892113f, 0.06992650f, -0.08951139f, 0.03157311f, 0.04905618f, -0.06185181f, 
    0.06873737f, 0.03226819f, -0.02124891f, 0.02379049f, -0.02979772f, 0.02031774f, -0.01868698f, 0.02543764f, 
    0.01852656f, 0.05284935f, -0.06607474f, -0.06692839f, 0.00398492f, 0.03209464f, 0.03306032f, 0.06569723f, 
    -0.09131476f, -0.09197199f, -0.04960496f, -0.06026725f, -0.07219595f, 0.04712769f, 0.02869870f, 0.00816365f, 
    -0.08544061f, -0.03941733f, 0.03232926f, -0.09292941f, 0.01234556f, 0.06017484f, -0.06916057f, 0.03344274f, 
    -0.09550104f, -0.02885581f, 0.01235698f, 0.06854956f, -0.06719131f, -0.01987828f, -0.01924314f, 0.03340221f, 
    0.03295365f, -0.04795527f, 0.03398236f, -0.01449381f, -0.01806166f, 0.02731011f, -0.04947382f, -0.07919773f, 
    0.00166290f, -0.06536806f, -0.07265143f, -0.06233720f, 0.06005719f, 0.06340314f, 0.03193468f, -0.08532383f, 
    0.02458031f, 0.02552347f, -0.05773966f, -0.00620828f, -0.00391834f, 0.02279352f, -0.00873086f, -0.07462215f, 
    -0.03649279f, -0.00652767f, 0.03732906f, 0.01732547f, -0.01941895f, 0.00417589f, -0.05433053f, -0.03460904f, 
    0.01059731f, -0.03265911f, -0.07860333f, 0.02626643f, 0.03740752f, 0.00945175f, -0.02013765f, 0.04639205f, 
    -0.04795797f, 0.04336064f, -0.05306111f, -0.02529396f, -0.06768500f, -0.00621941f, -0.07011023f, -0.06296827f, 
    -0.02202958f, -0.02618303f, 0.00652838f, -0.04069630f, -0.01262735f, 0.00097503f, 0.07864979f, -0.02361822f, 
    -0.01018187f, -0.05311954f, -0.06140595f, -0.01561075f, -0.03326404f, 0.03269547f, 0.03171395f, -0.03586870f, 
    0.42203304f, -0.18018462f, 0.21276504f, 0.01098119f, 0.07860241f, -0.09085553f, 0.09919865f, -0.01465235f, 
    0.03449836f, -0.27021185f, 0.29793084f, 0.15627557f, -0.18827899f, -0.27127033f, 0.04503892f, -0.10559986f, 
    0.12578040f, -0.03568894f, 0.31607804f, 0.10256834f, -0.08923929f, 0.12165919f, 0.09321933f, 0.11945167f, 
    0.11386909f, -0.11629710f, 0.02789674f, -0.17003396f, -0.11120138f, -0.14806908f, 0.14087722f, 0.17222045f, 
    -0.09667330f, -0.15966809f, 0.05421911f, 0.00277404f, 0.56598032f, 0.03828571f, 0.25293118f, 0.10884161f, 
    0.01343866f, 0.03552845f, 0.11300056f, 0.15014228f, 0.00305460f, 0.20986252f, 0.10095181f, 0.01243196f, 
    -0.11746190f, -0.21312544f, -0.04371941f, -0.04688675f, 0.16328412f, 0.03619710f, -0.31045473f, -0.04414781f, 
    0.04160541f, 0.07482152f, -0.04379674f, 0.19102898f, -0.00579191f, 0.07708698f, -0.23453897f, 0.15836568f, 
    -0.02311840f, 0.14348425f, 0.17154524f, -0.05994088f, -0.10646299f, -0.01924410f, -0.02972010f, 0.06493226f, 
    0.01867294f, -0.15097293f, 0.06377000f, -0.17337874f, 0.02602074f, -0.16430928f, 0.02022030f, 0.13185164f, 
    -0.06379870f, -0.59849817f, -0.12187334f, -0.17989598f, 0.09557136f, -0.00983933f, 0.22493567f, 0.15082769f, 
    0.17778979f, -0.16159168f, 0.09891232f, -0.10297396f, -0.03673998f, -0.04754512f, 0.06065659f, 0.03122532f, 
    -0.05188816f, 0.09287937f, -0.16817833f, -0.25265628f, 0.03218871f, -0.06561506f, -0.27729452f, 0.08213946f, 
    -0.02327563f, -0.06607235f, -0.01087833f, 0.08889084f, 0.19223200f, 0.03908088f, 0.02727151f, 0.09046248f, 
    -0.02414864f, -0.08190646f, 0.07129622f, 0.00128392f, 0.17703809f, -0.05706619f, -0.07080259f, 0.13282280f, 
    0.09140863f, 0.27937955f, 0.02729915f, 0.05009688f, 0.02243940f, -0.14163485f, -0.29770750f, -0.25513041f, 
    0.00723193f, 0.15401724f, 0.33148810f, 0.09517036f, -0.05203910f, -0.03611060f, -0.09556804f, 0.36715230f, 
    0.00334365f, 0.18847847f, 0.00029572f, 0.01691955f, 0.04830676f, 0.14271981f, 0.19843510f, -0.01208575f, 
    -0.02526908f, 0.21910240f, 0.07419201f, -0.02841982f, 0.04336231f, 0.10294064f, -0.18452410f, -0.07716116f, 
    -0.05975967f, -0.15468323f, 0.16905686f, -0.17225643f, 0.07169780f, 0.12564836f, 0.04452690f, 0.01927189f, 
    0.07243890f, -0.12840270f, 0.26798913f, 0.36026588f, -0.01484956f, 0.00952293f, -0.05464845f, -0.11408211f, 
    0.00646632f, 0.03381913f, 0.07838868f, -0.26504910f, -0.09981912f, -0.44991887f, 0.31241190f, -0.03253397f, 
    0.34578854f, 0.17850108f, -0.00344332f, -0.18976541f, -0.02219093f, 0.20083362f, -0.10780200f, -0.03625229f, 
    -0.03552333f, -0.03030924f, 0.04913054f, 0.15524645f, 0.13769932f, -0.00735626f, 0.14502405f, 0.14604896f, 
    -0.23681109f, -0.08731090f, -0.00012420f, 0.09147798f, 0.07021760f, -0.01791221f, -0.37487099f, 0.44852546f, 
    -0.07064059f, -0.09496310f, 0.10838740f, -0.14184253f, -0.17712222f, 0.02817191f, -0.13414846f, -0.10331014f, 
    0.17760372f, -0.16992500f, 0.03193742f, 0.06275179f, 0.14189991f, -0.09159107f, -0.02327810f, -0.21174452f, 
    -0.07781354f, 0.37663335f, -0.17209172f, 0.15579197f, -0.07458070f, 0.12106421f, 0.16656598f, -0.09515988f, 
    0.13624313f, -0.09359059f, -0.03029144f, -0.09653813f, -0.05112539f, -0.05881577f, 0.03468526f, 0.17474718f, 
    0.12771571f, -0.08200858f, 0.88899559f, 0.24257727f, 0.29589811f, 0.02204518f, -0.08118387f, 0.04209561f, 
    -0.08009313f, -0.08257622f, 0.06731559f, 0.17266099f, 0.37960216f, -0.19862926f, 0.00449108f, -0.50817120f, 
    -0.10859679f, 0.15975013f, 0.05731162f, 0.17971057f, 0.10302557f, -0.47605327f, -0.05094524f, -0.12739232f, 
    0.10881763f, -0.14760193f, 0.04294390f, 0.00790322f, -0.13265193f, -0.42115638f, -0.07980970f, -0.18791197f, 
    -0.05206908f, -0.02727330f, -0.01235764f, -0.10384123f, 0.06652014f, -0.02078382f, -0.06310806f, -0.05683101f, 
    -0.13694809f, 0.10308284f, -0.01270874f, 0.05920185f, 0.04015951f, 0.02386583f, -0.00114758f, -0.18613707f, 
    -0.06008519f, -0.00624395f, -0.07485858f, 0.18404272f, 0.03345551f, -0.16604590f, 0.15471523f, -0.05013539f, 
    -0.08769542f, -0.01391316f, 0.03822265f, -0.06534059f, 0.01623901f, 0.04710830f, -0.05309463f, 0.04653213f, 
    -0.00836352f, -0.02522199f, -0.04772021f, 0.01261929f, 0.06539784f, -0.06623670f, 0.04262849f, -0.01244618f, 
    -0.10477879f, -0.07267635f, -0.09181199f, -0.01675354f, -0.06956582f, -0.04868072f, -0.05759249f, 0.06228919f, 
    -0.06597178f, -0.07163614f, -0.03039112f, 0.05722976f, -0.07469940f, -0.10042991f, -0.09038989f, -0.11371754f, 
    0.01761374f, -0.02338319f, 0.04528026f, -0.06302580f, -0.03650155f, -0.07766866f, 0.04688082f, -0.03130560f, 
    -0.01399107f, 0.03897135f, 0.01395070f, 0.00535427f, -0.10431845f, -0.02854964f, -0.05599346f, -0.04151750f, 
    -0.03374017f, -0.05198378f, 0.02033279f, -0.01298827f, -0.02325253f, -0.01275474f, -0.08990085f, 0.01935650f, 
    -0.03977829f, 0.00517706f, -0.10821176f, -0.00535697f, 0.03709868f, -0.06646293f, 0.03923921f, -0.08243192f, 
    -0.01777786f, -0.04155403f, 0.01220869f, 0.00521262f, -0.01326953f, -0.07178277f, -0.03938482f, -0.09310820f, 
    0.05066117f, -0.06742785f, 0.08173770f, 0.05017879f, -0.08691418f, 0.01770861f, 0.02846468f, 0.03449639f, 
    -0.07097658f, -0.06188847f, -0.06250007f, 0.05498109f, -0.00270788f, -0.00057579f, 0.06031098f, -0.02688689f, 
    -0.03254145f, -0.06131085f, -0.03623996f, 0.03957721f, -0.00639716f, -0.06291976f, -0.02003325f, -0.09170369f, 
    -0.04151591f, 0.00278755f, 0.00147582f, -0.02730181f, -0.02990288f, 0.01967840f, -0.04286435f, -0.02132706f, 
    -0.02773259f, -0.09629619f, -0.07429212f, 0.01104574f, -0.08716664f, -0.07831035f, -0.00580328f, 0.02258527f, 
    -0.10259512f, 0.02615048f, -0.07181991f, -0.08998889f, 0.02554002f, -0.00172051f, -0.00317432f, -0.05314128f, 
    0.01828326f, -0.01708624f, -0.04538710f, 0.05357116f, -0.06757730f, 0.03462410f, -0.01445689f, 0.05358375f, 
    -0.10982617f, -0.07304000f, 0.01414346f, 0.02334611f, 0.04763655f, 0.00035228f, -0.01315377f, 0.02682422f, 
    -0.06980325f, 0.00505998f, 0.03196771f, -0.07311783f, -0.05802099f, 0.03974799f, 0.05027873f, -0.05302954f, 
    -0.02561708f, 0.30811667f, 0.17032157f, -0.03467073f, -0.01540018f, 0.00409215f, -0.04709653f, 0.12131834f, 
    0.11514236f, 0.08068864f, -0.10635599f, -0.08083457f, 0.10283750f, 0.08908433f, -0.13787921f, -0.00839413f, 
    0.04046311f, 0.05723129f, -0.06082943f, 0.28316996f, 0.19634880f, 0.12843589f, -0.03063604f, 0.14059092f, 
    0.08280724f, 0.07562024f, 0.06905222f, -0.32039192f, -0.02014084f, -0.19836317f, 0.12443792f, 0.00027871f, 
    0.10388861f, -0.18179411f, -0.25131959f, -0.01639989f, 0.17992994f, 0.16811466f, 0.00698647f, -0.07826665f, 
    0.10736270f, -0.06301467f, 0.12895153f, 0.21651885f, 0.22360851f, -0.36840343f, -0.25725427f, -0.17579469f, 
    0.02663011f, -0.09785224f, -0.04018089f, 0.05527192f, -0.05158995f, -0.22919153f, 0.16681555f, -0.13328557f, 
    0.12612192f, 0.11020413f, -0.13648634f, 0.03195658f, -0.05740622f, 0.11555711f, -0.04305939f, -0.14382128f, 
    0.14931320f, 0.17177084f, -0.10741113f, 0.10453057f, 0.06707542f, 0.00969761f, -0.13732821f, 0.05251656f, 
    -0.32090637f, -0.36219972f, -0.37317708f, 0.01852323f, -0.10356658f, 0.07721122f, -0.04197077f, -0.06705233f, 
    -0.06385668f, -0.13654999f, 0.04677833f, -0.04008050f, 0.02364514f, 0.00227784f, 0.17083213f, 0.07410168f, 
    0.17850821f, -0.06921662f, 0.20098023f, -0.00323710f, -0.10980703f, 0.16640159f, 0.15156980f, 0.07043117f, 
    0.05221722f, -0.06701379f, -0.09732933f, -0.05127247f, -0.12054186f, -0.16225269f, 0.13441834f, 0.07569782f, 
    -0.03895017f, 0.18522567f, -0.10875890f, -0.04389244f, -0.05962700f, -0.09592944f, -0.00354292f, -0.04700097f, 
    0.03733799f, -0.03908736f, 0.07440201f, 0.03565573f, -0.00041096f, -0.08172802f, -0.27266580f, -0.07704474f, 
    -0.14505136f, -0.09530155f, -0.10210022f, -0.04181333f, -0.14224531f, 0.15230750f, -0.11413833f, 0.09799021f, 
    0.38043362f, 0.07277711f, 0.23662254f, 0.19598404f, 0.23655574f, -0.03270738f, -0.02282802f, -0.16665898f, 
    -0.06931462f, -0.09789421f, -0.19307967f, 0.25557989f, 0.04668769f, -0.05641268f, 0.04051146f, -0.01311076f, 
    0.06866827f, 0.00507598f, 0.06559332f, 0.11321268f, -0.07750663f, 0.12190643f, -0.10915641f, -0.04380401f, 
    0.10238486f, 0.22329919f, -0.29602808f, -0.33959037f, 0.05351200f, 0.17814885f, 0.15294749f, -0.00091447f, 
    -0.15846452f, -0.11696994f, 0.25913712f, 0.06261281f, -0.01027996f, 0.21916744f, 0.06404293f, -0.05485044f, 
    0.03034887f, 0.16553396f, -0.05881125f, 0.00011092f, 0.20091021f, 0.01004614f, 0.12035795f, -0.22093545f, 
    0.08249650f, 0.10709327f, -0.13036998f, 0.05969923f, 0.01073867f, -0.11691612f, -0.01763100f, 0.02457368f, 
    0.19455396f, 0.04924256f, 0.06907231f, 0.06997710f, 0.08871597f, -0.46088266f, -0.03015863f, -0.34197855f, 
    -0.21644059f, 0.05451334f, -0.06645152f, -0.03987068f, -0.10119162f, 0.26851308f, -0.10456678f, 0.05853815f, 
    0.13757637f, -0.18215533f, 0.09396327f, -0.04017866f, -0.19122164f, 0.07905657f, 0.05515597f, 0.33243361f, 
    0.07423300f, 0.06283283f, 0.07963933f, 0.03894397f, 0.13311559f, -0.06534740f, -0.03330523f, 0.14148776f, 
    -0.08870630f, 0.10894933f, -0.42899656f, -0.06545891f, 0.10357797f, 0.03469800f, -0.09718928f, -0.03335078f, 
    -0.23933810f, 0.29694709f, 0.02809311f, 0.13676336f, -0.14927976f, 0.23200499f, -0.18481518f, 0.11820621f, 
    0.19867654f, -0.06143874f, -0.15147379f, 0.23263834f, -0.14076194f, -0.07218177f, -0.07459810f, -0.22317073f, 
    0.06201829f, -0.01685332f, -0.07346107f, 0.00711383f, 0.11268573f, -0.17904456f, 0.18864670f, -0.19306205f, 
    -0.05478797f, 0.15634128f, 0.01746491f, -0.12111812f, -0.24010080f, -0.24868429f, -0.01025610f, -0.02893636f, 
    0.08025794f, 0.05807281f, -0.08735145f, -0.15368679f, -0.08374895f, -0.21595867f, -0.11295437f, 0.05961774f, 
    -0.14449634f, 0.16104475f, -0.00345243f, -0.01793608f, 0.11094981f, 0.00156374f, -0.04067054f, 0.10269563f, 
    0.09945221f, 0.09109144f, -0.04739271f, 0.02408349f, 0.06846605f, 0.20995836f, -0.10588031f, -0.22753423f, 
    -0.34139782f, -0.02288977f, 0.15491942f, -0.00305846f, 0.16905338f, 0.03333669f, -0.06923179f, 0.22844939f, 
    0.04981068f, -0.05320240f, -0.09650706f, 0.08037023f, 0.30330300f, 0.02934957f, -0.02756605f, -0.19594851f, 
    -0.07320253f, -0.07888975f, -0.14669514f, -0.22046353f, -0.02402196f, 0.18325247f, 0.01229627f, 0.11375205f, 
    -0.10377060f, -0.16484353f, -0.14170070f, 0.02358562f, 0.03433498f, 0.28949407f, -0.05190492f, 0.14667709f, 
    -0.13697806f, -0.10211581f, 0.08012307f, 0.21366486f, 0.23495151f, 0.18311256f, -0.11764558f, -0.13767762f, 
    -0.08443733f, -0.01962004f, 0.18085232f, -0.02634053f, 0.06980702f, -0.31732807f, -0.38505939f, 0.15890110f, 
    0.03413317f, -0.11360668f, 0.00394552f, 0.01234542f, -0.00439466f, -0.32024789f, -0.34257233f, 0.05713905f, 
    -0.04792577f, -0.05302132f, 0.01919341f, -0.02306883f, 0.11798253f, -0.14619251f, 0.02603304f, -0.14939101f, 
    0.20373698f, -0.03038963f, -0.08309114f, 0.05037047f, -0.02096458f, -0.29899192f, 0.03278175f, 0.01127898f, 
    -0.09293584f, -0.13630874f, 0.12927370f, 0.10074848f, 0.10174477f, 0.10462852f, 0.00539109f, -0.02638919f, 
    -0.07827397f, 0.14646776f, 0.46848518f, -0.59726387f, -0.25485548f, 0.04702572f, -0.08555720f, 0.12588727f, 
    0.13735421f, 0.01352273f, 0.21400787f, 0.02564886f, 0.02067799f, -0.10226350f, 0.31771559f, -0.19591950f, 
    0.16609153f, 0.16238844f, 0.46813360f, 0.15999138f, 0.04093688f, -0.04874660f, -0.11226315f, -0.07721896f, 
    0.07332132f, 0.07782435f, -0.08474615f, -0.03904280f, 0.02099835f, 0.27802917f, -0.16480035f, 0.03260680f, 
    -0.00700524f, -0.10004983f, 0.10485654f, -0.06866755f, 0.11999856f, 0.14402851f, -0.25632310f, 0.06114918f, 
    -0.10214522f, 0.08722541f, 0.13156655f, -0.17260112f, -0.04255367f, 0.12854414f, 0.09269327f, -0.06089426f, 
    0.01149773f, 0.03414178f, 0.00036638f, -0.25268736f, 0.01703990f, 0.10349035f, -0.16605069f, -0.11587813f, 
    -0.13101293f, 0.24808942f, 0.14731090f, 0.00510888f, -0.13521574f, 0.12320568f, 0.06820706f, -0.07692316f, 
    0.14901721f, -0.06517667f, -0.05459541f, 0.02907200f, -0.03923980f, 0.11859032f, 0.08322101f, 0.02725078f, 
    -0.06889753f, -0.07133749f, -0.07313180f, -0.00104013f, 0.04217010f, 0.02446952f, -0.01417613f, -0.01716277f, 
    -0.12128486f, -0.02042775f, 0.00346158f, -0.05654706f, -0.01395747f, -0.03083859f, -0.06814281f, 0.03719376f, 
    -0.08511091f, -0.06187747f, -0.04429283f, -0.04333793f, -0.09414823f, -0.02227117f, -0.05034998f, 0.01330068f, 
    0.00241619f, -0.10862526f, 0.01559004f, -0.10048023f, 0.00381805f, -0.06343023f, -0.11400767f, -0.04965782f, 
    -0.01911501f, 0.02727976f, -0.01712127f, 0.03635575f, -0.03552726f, -0.02646018f, -0.09595260f, -0.01533550f, 
    -0.00711619f, 0.01044684f, -0.02834793f, 0.02319200f, -0.02663384f, -0.03998897f, -0.04672965f, 0.00436869f, 
    0.01251585f, -0.04359161f, -0.09543778f, -0.11106388f, -0.06102080f, 0.03863217f, -0.10414266f, -0.11744934f, 
    0.03400911f, -0.04299737f, -0.02681509f, -0.10268279f, -0.06369343f, -0.06678059f, -0.11023400f, -0.09777486f, 
    -0.03396750f, -0.05657915f, -0.08459901f, 0.04216256f, -0.11776163f, -0.05770542f, 0.01666492f, 0.01556618f, 
    0.02609791f, -0.05295889f, 0.02110152f, 0.01141270f, 0.02690528f, -0.06294287f, -0.01766438f, 0.05147999f, 
    -0.03029227f, -0.03227887f, -0.02160172f, -0.10262409f, 0.02696619f, -0.08624543f, -0.01062201f, -0.09222477f, 
    -0.09353275f, -0.05507086f, -0.02228707f, -0.11324956f, -0.09909563f, -0.05264971f, -0.04015539f, -0.03377655f, 
    -0.07092457f, -0.09138229f, -0.04347670f, -0.05229165f, 0.03189968f, -0.01156882f, -0.08492035f, -0.03825115f, 
    -0.01201350f, -0.05858757f, -0.03721794f, -0.02100506f, -0.07903825f, -0.05262983f, -0.04190855f, -0.06998607f, 
    0.02817545f, -0.03894939f, 0.02507946f, -0.10350884f, -0.09051659f, -0.09477295f, 0.00811814f, 0.04211695f, 
    0.04767687f, 0.02470112f, -0.01018477f, -0.04071432f, -0.08135409f, 0.00232105f, -0.08905169f, 0.01639190f, 
    0.03575865f, 0.00054694f, -0.01644324f, 0.00743615f, 0.00913248f, 0.01418072f, -0.10558176f, 0.04038432f, 
    -0.09758645f, -0.01782653f, -0.03110130f, -0.08700759f, -0.03258167f, -0.04881545f, -0.02854297f, -0.11272795f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.00809762f, 0.22682302f, 0.14646505f, 0.11811291f, 0.06873427f, -0.00980801f, 0.05034521f, 0.05427407f, 
    -0.08928877f, 0.04608577f, 0.09974874f, -0.10284299f, 0.20877180f, 0.28892374f, 0.07759350f, -0.07361598f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.10069412f, -0.10722522f, 0.02774253f, -0.16138013f, -0.13027771f, 0.06657176f, -0.07358640f, -0.14209947f, 
    0.11070205f, 0.11861862f, 0.46601230f, -0.12558883f, 0.17047192f, 0.20609461f, -0.43243167f, 0.04682893f, 
    -0.02225331f, 0.10744194f, 0.15023479f, 0.21717586f, 0.04950463f, 0.18110192f, -0.03109455f, -0.19691601f, 
    -0.09257421f, -0.08473329f, 0.32291788f, -0.14862210f, 0.08041149f, -0.23788288f, 0.41790596f, 0.20760541f, 
    0.11303308f, 0.43942055f, 0.11679269f, 0.21919607f, 0.21234161f, -0.08185080f, -0.12539600f, -0.54560435f, 
    0.23424155f, 0.14393242f, 0.38498050f, 0.01701184f, -0.15596019f, 0.10759147f, 0.01134004f, -0.00527078f, 
    0.13935906f, 0.43940353f, 0.40752688f, 0.63352507f, -0.13300157f, -0.23303287f, 0.08254829f, -0.15442407f, 
    -0.06059027f, -0.26688841f, -0.24632254f, -0.18813603f, -0.30156487f, 0.04431090f, 0.40066987f, 0.10599930f, 
    0.01233125f, -0.15932387f, -0.07000905f, -0.20423058f, 0.03672743f, -0.04000503f, 0.12364241f, -0.03187877f, 
    -0.00363830f, 0.00461590f, -0.18971905f, 0.00976396f, -0.12431091f, -0.03227171f, 0.00092945f, -0.06794217f, 
    0.07580084f, 0.17459330f, -0.16045260f, 0.14844744f, 0.05263597f, 0.05246387f, 0.10433196f, -0.12289082f, 
    -0.00898225f, -0.15528359f, -0.29098645f, -0.09464588f, -0.03279213f, -0.24863707f, -0.24927448f, -0.18814586f, 
    -0.00253754f, -0.09173486f, -0.29906306f, -0.02144995f, 0.12562813f, -0.08232685f, 0.01149742f, 0.23019479f, 
    0.02709328f, -0.33107400f, -0.38243693f, -0.25542217f, 0.39982659f, 0.31712401f, 0.35673720f, -0.18373320f, 
    0.13397616f, -0.31504300f, -0.05887473f, 0.18271369f, -0.04439700f, -0.06827221f, -0.10899775f, 0.34479636f, 
    -0.20157628f, 0.22097209f, 0.15065840f, -0.16100821f, -0.16978119f, -0.43938926f, 0.21121505f, 0.16665098f, 
    -0.06520358f, -0.37140915f, 0.15861239f, -0.22061679f, 0.11369713f, 0.03938000f, -0.06568696f, -0.05014366f, 
    0.02941350f, 0.08122388f, -0.02807756f, -0.13330880f, 0.23908436f, 0.25062096f, -0.38314834f, 0.17666516f, 
    0.15387866f, -0.39744917f, 0.01993379f, 0.05453147f, -0.01953840f, -0.01207805f, 0.22631451f, 0.18001513f, 
    -0.04930946f, -0.12442032f, 0.49412805f, -0.20285910f, -0.55254734f, -0.05220361f, 0.28291598f, 0.26769519f, 
    -0.15990639f, 0.12421169f, -0.20463847f, -0.16140342f, 0.07260313f, -0.05129588f, -0.07247458f, -0.14190103f, 
    -0.18778053f, -0.04295897f, -0.14487021f, 0.10947811f, 0.23610842f, -0.25005910f, -0.23378740f, -0.24081701f, 
    0.14792654f, 0.17926212f, 0.22635251f, -0.34136477f, 0.18206251f, 0.25698310f, 0.19194612f, -0.56901848f, 
    -0.15519157f, 0.31479895f, 0.31660107f, -0.06034135f, 0.40466216f, -0.07894254f, -0.05841612f, -0.16729860f, 
    -0.01517960f, -0.22428468f, -0.13434587f, -0.18154216f, -0.00198916f, 0.05695650f, 0.14249432f, -0.11407766f, 
    0.16884623f, -0.02094183f, 0.08352339f, 0.04524688f, -0.27427420f, 0.15668610f, -0.05331884f, -0.17657739f, 
    -0.24730411f, 0.02665557f, -0.28730455f, -0.24600868f, -0.09425171f, 0.20926210f, 0.15069309f, -0.08283924f, 
    0.05887831f, 0.25107393f, 0.26605579f, -0.10410821f, 0.00712154f, 0.61075002f, 0.35104874f, -0.22264689f, 
    0.44365212f, 0.17934465f, -0.04218423f, -0.42294034f, 0.04519263f, -0.22162540f, -0.03537944f, -0.10785470f, 
    -0.12395894f, 0.15082389f, -0.03231009f, 0.22796467f, 0.64589983f, -0.15906179f, -0.29448280f, -0.16646093f, 
    -0.27930963f, 0.39776421f, 0.28548375f, -0.05890318f, -0.08128894f, -0.23451902f, -0.11986110f, 0.13487050f, 
    0.16719733f, 0.26682457f, 0.07742311f, 0.22153246f, 0.07319966f, -0.32666534f, 0.16338369f, -0.20953602f, 
    0.16544910f, -0.56587952f, 0.22516312f, -0.31875905f, 0.09573472f, 0.03159080f, -0.21907647f, 0.47610730f, 
    -0.23971774f, 0.29705784f, -0.14834276f, 0.08317692f, -0.28568378f, -0.11638610f, 0.46768770f, 0.12918346f, 
    -0.25472456f, 0.30506963f, -0.14901347f, -0.20221318f, -0.03325076f, 0.09604325f, 0.22423716f, 0.57456625f, 
    -0.07085041f, -0.27302992f, 0.41808271f, 0.19142377f, 0.02714803f, 0.13836543f, 0.10703230f, -0.15990055f, 
    0.32027969f, 0.51681137f, 0.03952914f, 0.51324701f, -0.12478688f, 0.01844120f, -0.15028758f, 0.11137983f, 
    0.15402885f, -0.44169492f, -0.26198399f, -0.18035470f, 0.05867180f, 0.44920531f, 0.14524956f, 0.01430710f, 
    0.17270774f, -0.08018841f, -0.07498138f, 0.13660580f, 0.22294858f, -0.01555481f, 0.09719973f, -0.26058954f, 
    0.14981805f, -0.27224278f, -0.07928436f, 0.13058858f, -0.19764753f, -0.25154608f, -0.19468763f, 0.14202967f, 
    -0.03995172f, 0.32158256f, 0.34042296f, -0.46292365f, -0.13143575f, -0.12749399f, -0.01862122f, 0.05690437f, 
    0.13085227f, -0.27252132f, 0.38488176f, 0.11066780f, 0.55249822f, 0.19813833f, -0.33234718f, 0.18498276f, 
    -0.00218841f, -0.22062322f, -0.16290998f, 0.17575091f, -0.19430274f, 0.20809364f, 0.02145898f, -0.10861484f, 
    -0.11912903f, -0.10707890f, -0.15193456f, -0.16969675f, 0.00114280f, -0.23199479f, 0.10783692f, 0.23742229f, 
    0.17175598f, 0.07890490f, -0.02893755f, -0.31589550f, 0.17527379f, -0.11615251f, 0.21082146f, -0.38848120f, 
    0.01354800f, -0.05938443f, 0.48267999f, -0.21545547f, 0.55764723f, 0.27278802f, -0.27930725f, 0.17053762f, 
    0.06704428f, 0.29452702f, 0.39950767f, 0.27040246f, -0.05657896f, -0.11921403f, -0.09936562f, -0.14517412f, 
    -0.02734441f, -0.03081329f, 0.16823198f, 0.10838722f, -0.25815901f, 0.44827095f, -0.27675045f, -0.06504658f, 
    -0.13070312f, -0.35618940f, 0.38366988f, -0.24999574f, 0.06996452f, 0.08371154f, 0.17126618f, 0.30310655f, 
    -0.10617530f, 0.43490362f, -0.10109467f, -0.17213470f, -0.15717155f, -0.09009995f, 0.19192322f, -0.19903113f, 
    -0.23794137f, 0.36401570f, 0.21675082f, -0.18724285f, 0.09591516f, -0.24085090f, -0.10227276f, 0.29232588f, 
    0.16866149f, 0.59397322f, 0.45246404f, -0.07427146f, 0.11667798f, -0.45104712f, -0.05906683f, 0.14740729f, 
    -0.21635760f, 0.07334017f, 0.40993890f, -0.03982393f, -0.01229968f, 0.22104932f, -0.00521182f, -0.42872268f, 
    -0.12232579f, 0.25430411f, -0.38386416f, -0.15033264f, 0.38181108f, 0.53998983f, -0.21888290f, -0.05071674f, 
    0.34060648f, -0.36015090f, 0.16091543f, 0.25881526f, -0.07415663f, 0.06671188f, 0.00980579f, -0.03275178f, 
    0.10825171f, -0.13011202f, -0.22517058f, -0.08556899f, 0.66909534f, 0.37332964f, -0.14069140f, -0.10347617f, 
    -0.29858103f, 0.16232137f, 0.11648677f, 0.28874126f, -0.12695435f, -0.03499219f, 0.24321234f, -0.19898267f, 
    0.23761915f, -0.10054075f, 0.29670966f, -0.13144740f, -0.39759815f, 0.37247586f, 0.55460018f, 0.21302210f, 
    0.04514763f, 0.53999966f, 0.06298749f, 0.31150007f, 0.02802471f, 0.02698831f, 0.19361912f, -0.04808099f, 
    -0.09180668f, -0.38185552f, 0.37480739f, -0.23171338f, 0.15045166f, -0.12476308f, 0.05181605f, -0.07031602f, 
    0.40902719f, 0.26987231f, -0.48548961f, 0.34088981f, 0.18305704f, 0.05594534f, 0.01067330f, 0.55182606f, 
    0.10331713f, -0.18071660f, 0.27217656f, 0.07655292f, 0.20461252f, 0.36613029f, -0.15381558f, -0.22179843f, 
    0.12102991f, -0.47932643f, -0.02566097f, 0.01513164f, 0.18290313f, -0.02778422f, -0.21284255f, 0.27711919f, 
    0.08930426f, -0.09248793f, 0.36662042f, -0.18341331f, -0.02513465f, 0.32711270f, -0.19539644f, -0.21927887f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.37728676f, 0.19859102f, 0.23662782f, 0.31227934f, -0.10161254f, 0.16711785f, -0.39784625f, 0.39200705f, 
    0.17490730f, -0.51211143f, 0.09017350f, 0.28939414f, 0.01664514f, 0.18184753f, 0.34216371f, 0.38492286f, 
    0.29861671f, -0.40814546f, 0.30437973f, 0.17206337f, -0.12780921f, -0.23857963f, 0.25156903f, -0.26212481f, 
    -0.06792474f, 0.28599611f, 0.04545483f, -0.21903765f, 0.03587008f, 0.02273495f, -0.12621680f, 0.11548612f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.08506157f, 0.14966068f, 0.38197899f, 0.04152626f, 0.08166792f, -0.05379469f, 0.50961423f, -0.00939428f, 
    -0.44942361f, -0.35991195f, 0.14533129f, 0.35407797f, 0.01067824f, 0.23462538f, -0.02076495f, -0.05995857f, 
    -0.19509059f, -0.07646662f, -0.20651251f, -0.00144549f, -0.31595945f, 0.00378076f, 0.44819304f, -0.18600297f, 
    -0.39812031f, -0.07974675f, -0.39448538f, -0.05768410f, 0.43899828f, 0.25786796f, 0.19888406f, 0.01734963f, 
    -0.12786621f, -0.02544532f, 0.04143870f, -0.13871729f, 0.02239395f, 0.07143281f, -0.09067186f, 0.06742986f, 
    0.16571030f, 0.02874615f, -0.08349893f, 0.17490156f, 0.09548524f, -0.13150090f, -0.06095947f, -0.11768336f, 
    -0.14236169f, 0.11600090f, -0.08879004f, 0.15110052f, -0.09476989f, 0.06488132f, 0.07183938f, -0.14752419f, 
    0.04120409f, -0.15343225f, -0.03702868f, -0.10240365f, 0.16440122f, 0.08212499f, -0.01650144f, 0.13552535f, 
    0.04246738f, -0.18661541f, -0.29186943f, -0.11058193f, 0.09501672f, 0.07845488f, 0.05600305f, 0.54813582f, 
    -0.06918992f, 0.22446847f, 0.04347149f, -0.43842712f, -0.05341144f, 0.06189564f, 0.06490873f, 0.21275727f, 
    0.52602792f, -0.05086700f, 0.07442154f, -0.16011269f, -0.47364518f, 0.13981190f, -0.34715065f, -0.15067182f, 
    0.36122108f, 0.07946961f, 0.54263353f, 0.02422581f, -0.09308156f, -0.04159144f, 0.38247073f, 0.33753183f, 
    0.20510326f, 0.03985303f, 0.00201178f, -0.19600105f, 0.15417336f, -0.09002701f, 0.26734766f, 0.08191352f, 
    -0.54547852f, -1.05919325f, -0.17315674f, 0.49375695f, 0.17286925f, -0.13294916f, 0.67296302f, 0.37041464f, 
    -0.20143877f, -0.07425151f, 0.08415666f, 0.05724313f, 0.31867436f, 0.14381070f, 0.25868133f, -0.20000157f, 
    -0.08734442f, 0.36136952f, -0.37711084f, -0.37448144f, -0.35902694f, 0.05140597f, 0.05609008f, -0.33043373f, 
    -0.03651742f, -0.13221036f, 0.02135987f, 0.05791305f, -0.00960929f, 0.14501911f, -0.16041914f, 0.04399668f, 
    -0.03436102f, -0.16594845f, -0.04387582f, -0.07375666f, 0.16195008f, 0.11091744f, 0.03162233f, 0.00190018f, 
    0.02794965f, -0.09157392f, 0.05073960f, 0.15722999f, 0.15821338f, 0.01665431f, -0.19686110f, -0.13685878f, 
    -0.06116875f, -0.20300585f, -0.05184208f, -0.13536622f, 0.06992637f, -0.09275831f, 0.00254972f, 0.16510819f, 
    -0.18291137f, -0.19135943f, 0.03426752f, -0.13651709f, 0.08643387f, -0.06866025f, 0.20497979f, -0.17135103f, 
    0.07257964f, -0.09637047f, -0.18334492f, -0.00259121f, -0.06302053f, -0.02313887f, 0.00226169f, -0.05421696f, 
    -0.12648357f, 0.16900663f, 0.17215958f, -0.05203109f, 0.07531167f, -0.08154058f, -0.00986780f, 0.07659974f, 
    0.09830771f, -0.02593867f, 0.09138551f, -0.05606893f, 0.17665124f, -0.21738899f, -0.03247046f, 0.14907570f, 
    -0.02906942f, 0.33106518f, 0.20499714f, 0.37078303f, 0.16053587f, 0.02603983f, 0.07854848f, -0.04573175f, 
    -0.13423000f, 0.55551291f, 0.10571446f, 0.04803946f, -0.06678264f, -0.43562144f, -0.36143076f, 0.22294512f, 
    -0.22943330f, 0.39681447f, -0.03184066f, 0.14094156f, 0.36307749f, -0.08774759f, 0.15751672f, 0.39710581f, 
    0.01745554f, 0.20353736f, -0.17038763f, -0.36765569f, 0.40232486f, 0.27557898f, -0.37545687f, -0.11530156f, 
    0.37466085f, -0.29338703f, -0.00113462f, -0.39003119f, 0.10560017f, -0.08546795f, -0.20120092f, -0.70584297f, 
    0.52662891f, 0.30576843f, -0.07804662f, 0.06095178f, 0.07872909f, -0.08951356f, 0.26689708f, -0.14056379f, 
    -0.51405346f, 0.38781938f, 0.14294758f, -0.01110992f, 0.67240375f, 0.16452412f, 0.50954217f, 0.46306786f, 
    -0.20181678f, -0.00678211f, 0.58463234f, 0.39229584f, -0.54006010f, -0.02285954f, 0.19890457f, 0.27288890f, 
    0.17100193f, 0.05815642f, -0.15374491f, 0.34873953f, -0.13215876f, -0.12940277f, -0.20328297f, -0.09363165f, 
    -0.01918623f, 0.78098023f, 0.14302018f, 0.00092519f, -0.07816049f, -0.00750693f, -0.05184140f, -0.21162285f, 
    0.00695586f, 0.46518824f, 0.47084117f, 0.02134096f, -0.19478020f, 0.00980419f, 0.02886968f, -0.04436444f, 
    -0.28000993f, -0.21097645f, 0.34033686f, 0.31371301f, 0.24671537f, 0.28312272f, 0.55944568f, 0.35024670f, 
    0.38337466f, 0.02484513f, 0.45573753f, -0.12158234f, 0.03562806f, 0.05767822f, -0.39815876f, 0.12417784f, 
    -0.60133755f, 0.52256811f, 0.03790427f, 0.18095645f, 0.01972565f, -0.08907309f, 0.16706620f, -0.27988932f, 
    -0.31007466f, -0.13979065f, -0.09212592f, 0.00739928f, -0.06243338f, -0.02712204f, 0.24205990f, 0.01030589f, 
    -0.36955532f, 0.08603523f, -0.13744161f, 0.03156522f, 0.16399597f, 0.23039663f, 0.26055360f, 0.13219294f, 
    -0.11472809f, 0.17182809f, -0.02110343f, 0.34625092f, 0.13372763f, -0.14387026f, 0.59159261f, 0.28035834f, 
    0.54712021f, -0.54910928f, 0.07575835f, -0.12489890f, -0.16956498f, 0.27188566f, -0.37688076f, 0.37472048f, 
    0.23341133f, 0.18038218f, -0.08078976f, 0.13621148f, 0.00956412f, 0.08609377f, -0.20364286f, -0.04953099f, 
    0.50237179f, 0.36753896f, -0.42553419f, -0.31454557f, 0.50166637f, 0.04706556f, -0.05994312f, -0.12092815f, 
    0.34850380f, -0.16054821f, 0.23408483f, -0.34653401f, 0.02551545f, -0.15588519f, -0.57252252f, 0.07343712f, 
    -0.15457112f, 0.61362457f, 0.02446572f, -0.04606288f, 0.18115473f, -0.10417894f, 0.07400025f, 0.01966983f, 
    -0.23247470f, 0.29948843f, -0.12147254f, 0.12449301f, 0.04618292f, 0.08574560f, 0.19401026f, 0.14575696f, 
    -0.20098849f, 0.24736834f, -0.90906757f, -0.29388052f, -0.09035354f, 0.28292167f, 0.56452614f, 0.20434721f, 
    0.05806463f, -0.13445863f, -0.03355803f, -0.08304888f, 0.03634160f, -0.17828201f, -0.10097219f, 0.07276627f, 
    -0.14207679f, 0.06011362f, 0.07477447f, -0.04225553f, -0.16245259f, -0.06464387f, 0.10096861f, 0.00725362f, 
    -0.21346971f, -0.20860688f, 0.02300297f, -0.06128468f, -0.02624192f, -0.05502048f, -0.12576461f, 0.03572845f, 
    0.11132235f, -0.06563612f, 0.10830837f, -0.08515107f, -0.05132624f, -0.10296524f, 0.08498053f, -0.11688073f, 
    0.09580828f, 0.11613891f, 0.17477445f, 0.40489155f, -0.08748174f, 0.04570586f, -0.14896636f, -0.02834610f, 
    0.30942920f, 0.02504289f, 0.12441143f, 0.30481660f, 0.06588366f, -0.31940717f, -0.17892225f, 0.16295655f, 
    0.07086394f, 0.21688165f, 0.01274079f, -0.07355491f, 0.66504127f, 0.01901033f, 0.03488437f, 0.10854691f, 
    0.28136784f, 0.00138141f, 0.74041849f, 0.43592873f, -0.14690211f, 0.33824080f, -0.28465167f, -0.08089543f, 
    0.27024063f, -0.05344893f, -0.29591629f, -0.36502936f, -0.00704563f, -0.04727137f, 0.27527246f, 0.18563230f, 
    0.34120226f, 0.42117918f, 0.01702518f, 0.02424442f, 0.08607094f, -0.00330937f, 0.05198184f, 0.01340153f, 
    0.41096812f, 0.18696740f, -0.53267103f, 0.02976581f, 0.26192212f, 0.00471134f, -0.04253646f, 0.05242757f, 
    0.46510091f, 0.39500809f, 0.35496837f, -0.13870291f, 0.02209763f, -0.24528269f, -0.37166369f, 0.13918091f, 
    0.06269619f, -0.03578418f, -0.41113362f, -0.08424695f, 0.13121207f, 0.15831140f, -0.30154482f, 0.18102716f, 
    -0.36889654f, 0.52439183f, -0.05392194f, -0.23248111f, -0.00370232f, -0.71125150f, 0.35136536f, -0.01908230f, 
    0.12964636f, 0.25005898f, -0.08709627f, 0.16828927f, 0.38533407f, -0.13708071f, 0.17522906f, -0.20660365f, 
    -0.09844940f, -0.00965599f, -0.29216266f, 0.48976934f, -0.49724621f, -0.05264356f, 0.24216747f, 0.34219182f, 
    0.11182088f, -0.01361318f, -0.05807677f, 0.19438395f, 0.01441275f, -0.11016072f, 0.16019385f, -0.00279530f, 
    -0.08218219f, 0.52405721f, -0.09861340f, -0.20237428f, -0.14051116f, 0.29079488f, -0.09271453f, -0.04006273f, 
    -0.26914665f, 0.50920230f, 0.40058830f, -0.15595184f, -0.02564774f, 0.20317505f, 0.25887066f, 0.12542848f, 
    -0.21507354f, 0.08933799f, 0.07018679f, 0.01098650f, 0.39847809f, 0.20382535f, 0.62386823f, 0.05298453f, 
    0.02332509f, 0.09339600f, 0.13325074f, -0.18266405f, -0.11992106f, 0.09608990f, 0.09892792f, -0.17732589f, 
    0.08416224f, 0.10431472f, -0.15244918f, -0.14150013f, -0.11412494f, -0.07900232f, -0.03327877f, -0.05295066f, 
    -0.17956538f, -0.03341969f, -0.08175292f, -0.02510717f, -0.11179235f, -0.14002050f, 0.14517145f, -0.10938168f, 
    -0.11636556f, -0.07147109f, 0.08012031f, 0.08695932f, -0.11812669f, -0.02037454f, -0.02394278f, 0.16006489f, 
    0.23711681f, -0.08251418f, -0.12274830f, -0.26342517f, -0.09887817f, -0.06136648f, -0.15890476f, 0.16689748f, 
    0.11114316f, -0.35781389f, -0.00865737f, 0.33270702f, 0.02132903f, 0.01881401f, 0.61907887f, 0.09037553f, 
    0.58067274f, -0.37682647f, -0.14747810f, -0.12410376f, 0.08171875f, -0.05515669f, 0.22478989f, -0.28848425f, 
    0.51873046f, 0.31327152f, 0.34269312f, 0.35364723f, -0.13426712f, -0.24269380f, -0.18593621f, 0.20126696f, 
    0.08737897f, 0.10488472f, 0.30981639f, 0.32395846f, -0.09700687f, -0.13446693f, 0.04624982f, 0.07288498f, 
    -0.13625567f, -0.53514826f, -0.15684527f, 0.37738493f, -0.07255130f, -0.60692197f, 0.38375875f, 0.24384263f, 
    -0.14470240f, -0.43180764f, 0.39847672f, 0.13018012f, -0.24135049f, -0.09843113f, 0.01357408f, 0.40523544f, 
    -0.10152890f, 0.22272441f, -0.08608530f, 0.05801752f, -0.56505322f, 0.22243771f, -0.09254289f, -0.21803723f, 
    -0.12522815f, 0.10056654f, -0.05457138f, -0.08364443f, -0.15194887f, 0.16469483f, -0.00990761f, -0.14230707f, 
    0.03397809f, 0.00410675f, -0.01019710f, 0.15585420f, 0.00379786f, -0.18993834f, -0.11170192f, -0.00174559f, 
    0.05439945f, -0.15164809f, -0.05103168f, -0.03451236f, 0.04415710f, -0.03928727f, -0.05852209f, 0.02493412f, 
    -0.01243530f, -0.16842313f, 0.15837990f, -0.07279545f, -0.12337355f, -0.06063678f, 0.04588376f, -0.05720091f, 
    0.20268559f, 0.05227563f, 0.38290834f, 0.31545153f, -0.03370129f, 0.15569510f, -0.75112915f, -0.16364044f, 
    -0.27569169f, 0.49548662f, -0.07173831f, 0.49642116f, -0.08615953f, -0.03241715f, 0.16035999f, -0.00186171f, 
    -0.16983393f, -0.61938018f, -0.15514551f, -0.01216705f, 0.34885344f, 0.12860335f, 0.58970273f, 0.28428224f, 
    -0.15873560f, 0.00364532f, 0.84478068f, 0.11728446f, -0.01745371f, -0.05580549f, -0.41467893f, -0.09180257f, 
    0.11078185f, 0.02905176f, -0.00795545f, -0.15126409f, -0.03336307f, 0.00409946f, 0.11362168f, -0.07990823f, 
    0.01048845f, -0.12746109f, 0.08249541f, 0.16968364f, -0.01526220f, -0.05499222f, -0.15430629f, -0.05667463f, 
    -0.14893267f, -0.12460313f, -0.12341821f, -0.00553871f, 0.10193959f, -0.03689215f, -0.12405345f, 0.06274806f, 
    0.14066498f, -0.08345615f, 0.02562526f, -0.16822746f, -0.15004425f, -0.13030429f, 0.17061202f, -0.13732998f, 
    0.35482293f, -0.11768796f, -0.07074272f, -0.34453616f, 0.02315470f, 0.12904865f, -0.28426591f, 0.27117527f, 
    0.45640683f, 0.38446134f, -0.04589907f, 0.16029471f, 0.07091875f, 0.52153558f, -0.25100666f, -0.03571639f, 
    0.19725029f, 0.20757647f, -0.50497073f, 0.15062919f, 0.16551325f, -0.19799200f, 0.31856656f, -0.06066624f, 
    0.19463278f, 0.29715225f, -0.24959923f, -0.78582311f, 0.32245603f, -0.33244896f, 0.04621205f, 0.50353569f, 
    0.04488642f, 0.20591855f, 0.10330059f, 0.17637005f, 0.07396795f, 0.03894676f, 0.35290280f, 0.03689065f, 
    0.50740021f, -0.49064672f, 0.16017099f, 0.03249460f, 0.14255443f, -0.11889390f, -0.34111288f, 0.13527496f, 
    0.49563211f, -0.29470637f, 0.05608881f, -0.01263805f, -0.27152827f, -0.19525550f, -0.34260896f, 0.29760799f, 
    0.43808064f, -0.10261530f, -0.15384521f, -0.07365391f, 0.61832285f, 0.01374485f, -0.45959458f, 0.14743003f, 
    0.24638546f, 0.05581830f, 0.27042779f, 0.23369339f, 0.11029731f, 0.14543732f, -0.39958906f, 0.08371065f, 
    -0.15501155f, -0.38802284f, -0.17973787f, 0.07492284f, 0.08655820f, -0.07286636f, -0.06501380f, 0.34783033f, 
    -0.07474242f, -0.05835257f, -0.08059300f, -0.02795739f, 0.01218836f, -0.01966727f, -0.28180295f, 0.21251370f, 
    0.09117335f, 0.28246483f, -0.58481914f, -0.61776710f, -0.06566863f, 0.20258380f, -0.14278151f, -0.22571772f, 
    -0.07363578f, 0.03150229f, 0.18280229f, 0.34516001f, -0.13253662f, -0.11427843f, 0.13636769f, -0.01356418f, 
    -0.03737607f, 0.60136813f, 0.05019646f, 0.04675692f, 0.02129842f, -0.26211041f, -0.22450051f, 0.11839745f, 
    0.28843573f, -0.17963423f, 0.14129259f, 0.08981229f, -0.24830885f, -0.10385672f, -0.26216033f, 0.23212753f, 
    0.06894061f, 0.04985704f, 0.36930498f, -0.09037059f, 0.35356620f, -0.04854175f, -0.29588723f, 0.13498957f, 
    -0.07074615f, -0.20001248f, 0.05259504f, -0.16947195f, -0.06493145f, -0.09156144f, -0.04323377f, -0.16486368f, 
    0.06263479f, 0.07430711f, 0.16829658f, 0.06028887f, 0.06298096f, 0.08433560f, -0.11890984f, -0.06691040f, 
    -0.04442547f, -0.18192407f, -0.10262313f, 0.04840433f, -0.16838454f, -0.03989165f, -0.06051506f, -0.12427299f, 
    -0.15057711f, 0.00390680f, 0.08468378f, 0.06534839f, 0.14114112f, 0.05684064f, 0.08677050f, 0.08282022f, 
    -0.08519176f, -0.08587581f, -0.02187042f, -0.15111123f, -0.00639197f, 0.01616477f, 0.09854373f, 0.10690306f, 
    -0.02713790f, 0.00102207f, 0.12253653f, 0.04473887f, 0.15807024f, 0.17213735f, -0.02314559f, -0.19046302f, 
    -0.08808102f, -0.21095288f, -0.07530835f, 0.01169360f, 0.11705766f, 0.17668399f, 0.09528597f, -0.13203794f, 
    0.12781273f, 0.03642874f, -0.05424061f, -0.16303065f, -0.13882923f, 0.01603431f, -0.11684384f, -0.09419360f, 
    -0.08926407f, 0.27896982f, 0.31302670f, 0.26908603f, -0.15630275f, -0.13002193f, -0.43240309f, 0.23188472f, 
    -0.56884402f, 0.51655000f, 0.12887520f, 0.01101716f, -0.00558157f, 0.25744787f, -0.46194509f, 0.08957792f, 
    -0.06937944f, -0.72595870f, -0.08145027f, 0.03350678f, -0.33026755f, -0.09610086f, 0.05278991f, -0.00205473f, 
    -0.23371962f, -0.05962070f, 0.43293086f, 0.04706553f, 0.38101014f, -0.17742585f, -0.20874213f, -0.27736056f, 
    0.18071987f, -0.28911650f, -0.28247857f, -0.22297102f, -0.16022101f, -0.05998579f, 0.07446940f, 0.51945454f, 
    0.58415580f, -0.19937122f, 0.08217395f, -0.38870361f, 0.05226056f, 0.11758739f, -0.29354173f, 0.17914052f, 
    0.09259591f, 0.24634068f, -0.13084666f, 0.14459328f, -0.59208179f, -0.04184384f, -0.50954241f, -0.18202135f, 
    0.40262955f, 0.30997950f, 0.25847375f, -0.33861127f, 0.03158316f, -0.38056150f, 0.15215123f, 0.26067901f, 
    0.35801765f, 0.37812132f, 0.21268201f, -0.44209361f, 0.03953168f, -0.06386735f, -0.48517567f, 0.09227078f, 
    -0.78894711f, -0.12573296f, -0.00044648f, 0.51009822f, 0.07645389f, 0.44176224f, 0.36131427f, 0.13366994f, 
    -0.14215180f, 0.12801036f, -0.28081313f, -0.18373781f, 0.42846426f, 0.03316110f, 0.61240649f, -0.07704834f, 
    0.12225296f, 0.19930300f, -0.30235851f, -0.00172047f, 0.01791814f, 0.17370251f, -0.36806178f, 0.03555077f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.35790452f, 0.03160628f, 0.53315228f, 0.42621908f, -0.10102104f, -0.19702294f, -0.28643480f, -0.17004462f, 
    0.20300160f, 0.10714089f, 0.24961767f, -0.18029465f, -0.18952075f, -0.01217140f, -0.07134920f, -0.21651456f, 
    -0.16720636f, -0.08885990f, 0.08063800f, 0.52051848f, 0.11159626f, 0.33134279f, -0.08096758f, 0.17532210f, 
    0.06528719f, 0.54292148f, 0.02069054f, -0.05727325f, -0.10061833f, 0.27087039f, 0.27570865f, 0.36237314f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.38459706f, -0.15131818f, -0.53601152f, 0.22672728f, -0.19031589f, -0.12243890f, 0.06134232f, 0.06289798f, 
    -0.03920951f, 0.44643033f, -0.26100838f, 0.88814425f, -0.13389383f, -0.30457070f, -0.66199279f, -0.50505453f, 
    0.25951540f, -0.05640694f, -0.40016875f, 0.09374531f, 0.10185461f, -0.25536105f, 0.00175780f, 0.16387935f, 
    -0.47493634f, 0.19532444f, -0.43848866f, -0.11559660f, -0.24910286f, -0.31709969f, -0.10587602f, 0.11907785f, 
    0.00228117f, -0.17642133f, 0.15170109f, -0.40250802f, 0.10657187f, -0.02372936f, -0.22459976f, 0.38558698f, 
    0.39615893f, 0.04199146f, -0.41953656f, -0.28480956f, -0.03852253f, 0.08652456f, -0.89730525f, -0.29987016f, 
    0.36094323f, -0.10844152f, -0.31100884f, 0.13065130f, -0.06161669f, 0.28709614f, 0.17442094f, 0.13123056f, 
    -0.15277365f, -0.47196928f, -0.18861586f, -0.04404964f, 0.06091463f, -0.16068488f, 0.52457350f, -0.03666787f, 
    0.22969300f, 0.04516349f, -1.54613042f, -0.13551295f, -0.10338411f, -0.19547290f, 0.37492454f, -1.00386453f, 
    -0.05304983f, -0.10995860f, 0.19524160f, -0.33169574f, -0.10378038f, 0.21721715f, 0.18477884f, -1.25261545f, 
    -0.07337363f, -0.03403600f, -0.19457106f, -0.09159876f, 0.04691190f, -0.05784816f, 0.08912838f, 0.48496753f, 
    0.08868288f, 0.10327457f, -0.19951440f, 0.13155332f, 0.05384805f, -0.09689336f, -0.26647890f, 0.37827325f, 
    -0.18891294f, 0.08282241f, 0.01863974f, 0.29903477f, 0.02174295f, -0.09809521f, -0.97374284f, -0.56613117f, 
    -0.68940324f, -0.53270155f, 0.20651726f, -0.40945041f, -0.14067177f, -0.30859265f, 0.38872853f, -0.42699611f, 
    -0.35431379f, 0.11306095f, 0.36592028f, -0.22260170f, 0.12409659f, -1.17263138f, -0.02438751f, 0.16429575f, 
    0.01603313f, 0.09958447f, -0.15997298f, -0.16795112f, 0.01736384f, 0.43592340f, 0.42501450f, 0.09342758f, 
    0.22130163f, -0.02983516f, -0.08457822f, 0.35044450f, 0.12866913f, 0.04874085f, -0.32858327f, -0.38565695f, 
    0.04225010f, 0.09599221f, -0.25805169f, 0.07243280f, -0.07096475f, -0.23367180f, -0.38791931f, 0.38659129f, 
    -0.32244194f, 0.06501961f, 0.31131583f, 0.24717586f, -0.08678494f, 0.19410354f, 0.14924331f, -0.34038377f, 
    0.13606991f, -0.00308076f, -0.14455254f, 0.08778437f, 0.10049952f, 0.17014208f, -0.37169081f, 0.17680255f, 
    -0.36883056f, -0.01592156f, -0.21582966f, -0.20537962f, 0.14644812f, -0.13154818f, -0.07363097f, 0.47574562f, 
    0.35589215f, 0.03157365f, -0.60795671f, 0.21307297f, -0.01069865f, 0.14922847f, -0.43105063f, 0.50460243f, 
    -0.00296026f, 0.00215371f, 0.03894138f, 0.01075142f, -0.04378892f, 0.07861265f, -0.15446433f, -0.24999894f, 
    -0.22359338f, -0.65564531f, 0.24012928f, 0.11777813f, -0.15909922f, 0.23440897f, -0.36249569f, 0.09904108f, 
    -0.54817915f, -0.10876601f, -0.20409289f, 0.14738785f, -0.04073286f, -0.01751061f, 0.07212757f, 0.32238927f, 
    -0.13113163f, -0.15738072f, -0.26017180f, -0.83245051f, 0.06793575f, 0.30709180f, -0.00580221f, 0.03702927f, 
    -0.22190969f, 0.07239400f, 0.29377896f, 0.17295545f, 0.15371764f, 0.22955346f, -0.12451690f, -0.25121143f, 
    -0.07106718f, -0.52261686f, -0.22051749f, -0.13583609f, -0.08057809f, -0.69309068f, -0.16073427f, 0.08152333f, 
    0.40399355f, -0.16929245f, 0.32950956f, -0.37242258f, -0.02268215f, 0.06682821f, 0.27227208f, -0.44613758f, 
    0.02311016f, 0.06505627f, -0.07340003f, 0.06836121f, -0.09596245f, -0.65654778f, 0.08934075f, 0.17770214f, 
    0.26770458f, -0.07625838f, -0.04437149f, -0.87802738f, -0.14254944f, 0.33669025f, 0.06325732f, 0.24321926f, 
    -0.26680294f, -0.51707399f, 0.05298543f, 0.09148565f, -0.08296093f, -0.22050610f, 0.23946035f, -0.82940936f, 
    -0.06782804f, 0.12470561f, -0.33499521f, -1.14721107f, -0.07432910f, -0.03012959f, 0.36848608f, -0.42108443f, 
    0.16914494f, -0.81132948f, 0.17655349f, -0.06872862f, 0.12269375f, 0.08258343f, -0.62431002f, 0.07688285f, 
    0.19532073f, -0.09326638f, -0.77882314f, 0.17429620f, 0.00803628f, -0.12788001f, 0.14981630f, -0.74507487f, 
    0.39086330f, 0.20731775f, 0.33050311f, -0.04693129f, -0.02893569f, 0.05339868f, -0.39951718f, -0.76403195f, 
    -0.18007684f, -0.02227193f, 0.12944187f, 0.33863559f, -0.00391964f, -0.10053007f, 0.28022537f, -0.09549644f, 
    -0.16793360f, -0.00310165f, -0.25557575f, 0.05453708f, -0.09656594f, 0.15736654f, -0.12944642f, 0.23982470f, 
    -0.26365063f, -0.18103628f, -0.20868284f, 0.29739141f, -0.13243176f, 0.34964666f, -0.02658811f, -0.67063946f, 
    -0.39317590f, 0.33507475f, -0.16662286f, -0.10369471f, -0.26490358f, 0.16671927f, -0.47386989f, -0.00825003f, 
    -0.41046387f, 0.12359302f, 0.04201479f, -0.17104048f, 0.05531064f, 0.13599187f, 0.13571818f, -0.98054564f, 
    0.11067151f, -0.47786084f, 0.24598749f, -0.36116338f, -0.15222383f, -0.11465489f, 0.01477349f, -0.40142006f, 
    -0.14765461f, -0.05426081f, 0.10635690f, -0.13728192f, 0.16857284f, -0.85341853f, -0.13030855f, 0.23128787f, 
    0.14085607f, 0.31485173f, 0.22766921f, 0.01704958f, -0.16387463f, -1.07812858f, 0.25071898f, -0.16880251f, 
    -0.67764819f, 0.13479921f, -0.19287442f, -0.20434956f, 0.00034572f, 0.06386298f, 0.10863818f, 0.05739597f, 
    -0.44607297f, -0.02125414f, 0.00545101f, -0.70382887f, -0.15533578f, 0.11260545f, 0.53485447f, -0.12144652f, 
    -0.83247304f, 0.09108716f, 0.35531613f, 0.07163221f, 0.00104042f, 0.11569663f, 0.01730790f, 0.24068560f, 
    0.35407123f, 0.01382938f, 0.34792402f, -0.04678906f, -0.14838840f, -0.14708027f, -0.20571032f, -0.09640379f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.15384306f, 0.08429253f, -0.05494621f, 0.01939753f, 0.34269696f, 0.05273840f, -0.27479032f, -0.48097542f, 
    -0.00028925f, 0.19354495f, 0.30367428f, -0.33944649f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
