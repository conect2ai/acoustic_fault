#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.01709956f, 0.62202305f, -0.39417896f, 0.22192068f, 0.40866870f, 0.23131223f, 0.21780926f, 0.25646460f, 
    -0.15445562f, 0.65663099f, -0.18648560f, -0.41884521f, -0.40154245f, 0.15416364f, 0.47141820f, -0.20623082f, 
    0.06423678f, 0.08026444f, -0.41704983f, -0.06154163f, 0.13795717f, 0.30324551f, -0.01556497f, -0.51237804f, 
    0.14705400f, -0.04417615f, -0.06075870f, 0.55650282f, 0.44987443f, 0.41335544f, 0.10323101f, 0.01779585f, 
    0.16470706f, 0.17636663f, -0.11144459f, 0.09000473f, 0.71834481f, 0.55977321f, 0.42749387f, -0.43175769f, 
    -0.23299207f, -0.29651636f, 0.04837251f, 0.26962084f, 0.08833846f, 0.02132590f, -0.18008070f, -0.22328004f, 
    0.45800579f, 0.51759440f, 0.00092960f, 0.26770669f, 0.38188824f, 0.25239715f, 0.51791698f, 0.04905087f, 
    0.54909950f, 0.24317907f, 0.04081236f, -0.15088901f, -0.31369504f, 0.05627044f, 0.32111862f, -0.50054020f, 
    -0.26607031f, -0.11627346f, 0.47701073f, 0.53638482f, 0.52614272f, 0.07156967f, -0.07871761f, -0.08939246f, 
    0.30701998f, 0.37990138f, 0.57044220f, -0.46849862f, -0.29222253f, -0.11239009f, -0.31303358f, -0.09213509f, 
    -0.30416161f, -0.45800024f, 0.09825671f, -0.11443647f, -0.46174547f, -0.04077430f, -0.52085787f, 0.02307237f, 
    0.23714995f, 0.12182727f, -0.60650361f, -0.65121388f, -0.64197618f, 0.20038812f, -0.11448049f, -0.18000545f, 
    -0.08115868f, 0.06647793f, 0.13855802f, 0.53377223f, -0.00432227f, 0.02412198f, 0.53668898f, 0.51242018f, 
    0.07665702f, -0.15544897f, 0.15907587f, -0.28381410f, -0.18870372f, -0.42168468f, -0.34056807f, -0.47101948f, 
    0.22334142f, 0.23667367f, 0.25450495f, 0.16419984f, 0.41044155f, -0.27320519f, 0.28706127f, -0.36822775f, 
    0.73747534f, -0.27721611f, -0.32712317f, -0.02262359f, -0.11691894f, -0.29281759f, -0.45449859f, -0.52266282f, 
    -0.60588551f, -0.35001922f, 0.30565885f, 0.28274176f, -0.19385377f, -0.02705713f, -0.27982518f, 0.08509390f, 
    -0.65137374f, 0.12037896f, -0.34645852f, -0.67946094f, 0.06390228f, -0.11471803f, 0.14068367f, 0.09750137f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.21322125f, -0.60286868f, -0.06654579f, -0.17495950f, 0.03700328f, -0.05507241f, -0.04806965f, 0.05976820f, 
    -0.03323364f, 0.29333702f, 0.09075293f, 0.14223716f, -0.23961796f, -0.37008336f, -0.23525549f, 0.19850808f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.02170706f, 0.01521784f, -0.03727781f, -0.02478016f, 0.03326252f, -0.04498941f, -0.00878754f, -0.08961639f, 
    0.06587199f, 0.04818542f, -0.06892417f, 0.00914642f, -0.00147784f, 0.00634444f, -0.05848014f, -0.06673556f, 
    -0.03314907f, 0.02529228f, -0.02568247f, -0.04568062f, -0.02322670f, -0.00255505f, -0.00502634f, 0.02485443f, 
    0.01005989f, -0.07456356f, -0.09323432f, -0.06564917f, -0.08492690f, 0.06370252f, -0.06157965f, -0.04035413f, 
    -0.03072602f, -0.00563441f, 0.04072747f, -0.01369548f, -0.01534053f, 0.06831051f, 0.00798305f, -0.08547209f, 
    -0.00755306f, 0.05394636f, -0.00111203f, -0.06800763f, -0.03063209f, 0.05629962f, 0.06128081f, 0.07259677f, 
    -0.03813590f, 0.05717753f, -0.00364953f, -0.02359623f, 0.06812809f, 0.05326496f, -0.04920222f, -0.04945197f, 
    -0.02102057f, 0.02948771f, -0.08939628f, -0.05799218f, 0.04137911f, -0.01435838f, 0.07385933f, -0.00585140f, 
    -0.01266688f, -0.00269868f, -0.09158397f, 0.04738311f, 0.02949688f, 0.01242151f, -0.04127250f, -0.06210836f, 
    -0.07418501f, -0.08092837f, -0.08720087f, -0.03802102f, -0.04448406f, -0.07572395f, -0.08220339f, 0.03166671f, 
    -0.03477743f, -0.08921023f, 0.06997369f, -0.04116785f, -0.09022121f, -0.03480384f, -0.04391203f, -0.04447670f, 
    0.02098912f, 0.00299558f, 0.06723949f, 0.02229485f, -0.06788214f, -0.02024725f, 0.03686031f, -0.05632263f, 
    0.05457097f, 0.02779614f, 0.05357239f, -0.06098702f, -0.01602104f, -0.01616940f, -0.01303008f, -0.01381712f, 
    0.02343139f, -0.07375044f, -0.03610440f, 0.03741173f, -0.07781154f, 0.03248458f, 0.07737874f, -0.06898486f, 
    0.06800389f, -0.00705173f, 0.04280814f, -0.02427057f, -0.00543736f, 0.04886596f, -0.04937388f, -0.08436100f, 
    -0.07600333f, 0.03852081f, -0.01976026f, 0.04763106f, -0.03634609f, -0.08166848f, 0.00243572f, -0.06311174f, 
    0.00022913f, 0.03613526f, -0.03611594f, 0.00624450f, -0.01891287f, 0.04578392f, -0.06515846f, -0.00567798f, 
    -0.05619027f, 0.01405298f, 0.02146610f, -0.00712856f, -0.08583246f, 0.04016447f, -0.05706200f, 0.02368677f, 
    -0.02961990f, -0.01641733f, 0.18816869f, -0.00298005f, 0.16944803f, -0.01780557f, 0.01511417f, -0.05106134f, 
    -0.13527733f, -0.29300809f, 0.05331020f, 0.19531706f, 0.00563595f, -0.13855596f, -0.03584786f, 0.02944843f, 
    -0.03117180f, -0.04071140f, -0.04700188f, -0.16709419f, -0.08457132f, -0.09454598f, -0.07373979f, 0.05234538f, 
    0.02594796f, -0.08782920f, -0.09422532f, 0.34959823f, -0.04701991f, 0.12312418f, 0.18632789f, 0.08710655f, 
    0.12917021f, 0.07019117f, 0.14611828f, -0.03695998f, 0.37656641f, 0.14291751f, -0.13297521f, 0.00190453f, 
    0.02774014f, -0.00745108f, -0.00523842f, 0.04398266f, 0.03544579f, 0.01491319f, 0.02893480f, -0.08762151f, 
    0.13443816f, 0.02955846f, 0.14901096f, -0.11813774f, 0.15024725f, -0.00611156f, -0.05063739f, -0.08103011f, 
    0.05786897f, 0.05476125f, 0.02323406f, 0.25024208f, 0.16932802f, -0.05782349f, 0.00959997f, -0.59287828f, 
    -0.07631024f, -0.02357887f, 0.07646447f, 0.07433920f, 0.09832530f, -0.00741900f, 0.09533776f, -0.01752344f, 
    0.28836885f, 0.03064332f, 0.00770605f, -0.00183050f, 0.08941917f, -0.13144463f, -0.07039803f, 0.00071015f, 
    0.10901141f, -0.03217434f, -0.01930720f, 0.00281427f, -0.15326287f, 0.18226765f, -0.12297229f, -0.00501644f, 
    -0.04802588f, -0.11701226f, 0.09748295f, 0.13311471f, -0.11945784f, -0.13863993f, 0.13487466f, -0.10893416f, 
    0.07336272f, 0.11315960f, 0.03668693f, -0.07987220f, -0.10536116f, -0.11498068f, 0.13217132f, 0.13623458f, 
    0.12051299f, -0.04091446f, -0.04004993f, 0.07130820f, -0.42404801f, 0.06619747f, -0.04760473f, -0.16722184f, 
    0.07393216f, -0.12552163f, 0.02357903f, 0.13451849f, -0.00984365f, -0.05133886f, -0.16687110f, -0.00151582f, 
    0.01918668f, -0.09413942f, -0.06008773f, 0.03512360f, 0.01888545f, 0.13801014f, -0.08730911f, 0.00450868f, 
    -0.06553852f, 0.04083985f, -0.00987159f, -0.00539473f, -0.07939821f, -0.08190366f, 0.05761235f, -0.02397797f, 
    -0.07145130f, -0.29629728f, 0.01842222f, -0.12400827f, -0.07587149f, 0.12273451f, 0.11867219f, 0.20342557f, 
    -0.06310067f, -0.01237727f, -0.02763251f, -0.04706650f, -0.05975009f, -0.02723744f, 0.00174424f, 0.05282631f, 
    -0.03664229f, 0.06657925f, 0.03171030f, -0.03659138f, -0.06853433f, -0.00171669f, -0.03635806f, -0.05951693f, 
    0.00057448f, 0.03854931f, -0.06489836f, -0.01726556f, -0.07460279f, -0.04147654f, 0.03204764f, -0.02154199f, 
    -0.01317036f, -0.02716430f, -0.01096518f, -0.02983171f, -0.01930828f, -0.05699163f, 0.07586741f, 0.04492147f, 
    0.02198567f, 0.07088299f, 0.02756894f, 0.05726059f, -0.05538668f, -0.07520926f, -0.05866598f, 0.02217086f, 
    0.01449299f, -0.05449706f, -0.01884577f, -0.06173039f, 0.02473594f, -0.00079474f, -0.02182569f, -0.03380165f, 
    -0.04151546f, -0.01667603f, -0.05293509f, 0.03033772f, -0.06804471f, -0.07689841f, -0.06306837f, 0.02845845f, 
    -0.00310205f, -0.03401290f, 0.00177127f, -0.05733446f, -0.01208076f, -0.06047468f, -0.03921646f, -0.07525478f, 
    0.04838508f, 0.05844199f, 0.00467336f, 0.01932513f, -0.08205510f, 0.03311334f, 0.03576485f, -0.07379933f, 
    -0.04957825f, -0.03694959f, 0.02368457f, -0.02985311f, 0.02282861f, -0.05808305f, -0.07153843f, -0.02982923f, 
    -0.08508718f, -0.01286160f, 0.04953901f, -0.00093451f, -0.08904949f, -0.07627055f, -0.02383955f, -0.00631562f, 
    -0.02598811f, 0.03929329f, 0.01146710f, -0.08155509f, -0.05202110f, -0.03232978f, 0.02036473f, 0.06755225f, 
    -0.07420009f, 0.05403348f, 0.01613396f, 0.05942522f, 0.01507566f, -0.04403552f, 0.06293961f, -0.06879842f, 
    0.04952321f, -0.02398730f, 0.05798330f, -0.01175576f, 0.06113389f, 0.00936876f, 0.02844444f, -0.00939326f, 
    0.06763718f, 0.01444869f, 0.06237491f, -0.03231516f, -0.00438661f, 0.04673318f, -0.08559469f, -0.03025675f, 
    -0.00816908f, 0.00016292f, -0.02621761f, 0.06623204f, -0.01176301f, 0.06902119f, 0.06359801f, -0.08786905f, 
    0.03677320f, 0.01071596f, 0.01168746f, 0.01666369f, 0.01927157f, -0.07465848f, 0.01213036f, 0.07135714f, 
    -0.00775044f, -0.04996677f, -0.08649129f, -0.05036045f, -0.00183005f, 0.06701228f, 0.00470280f, -0.04088744f, 
    -0.20307273f, 0.24760173f, -0.04739906f, 0.10012253f, -0.09932624f, -0.01694202f, 0.04955193f, 0.13998513f, 
    0.03315121f, -0.07978495f, -0.02918387f, -0.15465528f, -0.11866251f, 0.04323779f, -0.12173794f, -0.17542771f, 
    0.10045520f, 0.05478688f, 0.06488335f, 0.08518845f, -0.02847192f, -0.07641015f, 0.03499708f, -0.06425899f, 
    -0.00407013f, -0.14486860f, -0.15176840f, -0.29491094f, 0.01655490f, -0.18289572f, 0.04806316f, -0.14397202f, 
    0.19803208f, -0.02576566f, 0.10283513f, -0.11776907f, 0.25849432f, -0.04987208f, 0.01068439f, -0.20249678f, 
    0.01504496f, -0.08401807f, 0.01650897f, -0.03333841f, 0.06803776f, 0.11815891f, 0.11527972f, 0.07413673f, 
    0.23230350f, 0.00532068f, 0.16250750f, 0.03147118f, -0.01510195f, -0.18215662f, 0.13452007f, -0.05127004f, 
    0.00490649f, -0.03456307f, -0.07914019f, -0.00884010f, 0.01119807f, -0.17901373f, -0.06187847f, 0.07931288f, 
    0.18339613f, -0.19578449f, 0.19323541f, 0.07989141f, 0.11052869f, -0.11383777f, -0.08624458f, 0.03143845f, 
    0.15389383f, -0.18307175f, 0.05521188f, -0.05495827f, -0.06261996f, 0.02724806f, -0.04748213f, 0.01559282f, 
    -0.03011255f, 0.09258494f, -0.06406458f, 0.02706069f, -0.04350889f, -0.14485072f, 0.13222018f, -0.01407809f, 
    0.02953066f, -0.04045687f, 0.08764720f, 0.11098514f, 0.14768316f, -0.01399146f, 0.14715815f, -0.12265202f, 
    0.10841826f, 0.01001764f, 0.07294912f, -0.08360571f, -0.09588319f, -0.13910787f, 0.09136943f, 0.09676363f, 
    0.05692977f, -0.01277735f, 0.01977311f, -0.15688154f, 0.03355876f, -0.09898603f, 0.03957530f, 0.13325319f, 
    -0.11788424f, 0.04810574f, -0.26484323f, -0.00122955f, -0.19021823f, 0.42117190f, 0.19601364f, -0.07025930f, 
    -0.16993982f, -0.23940596f, -0.06683557f, -0.00272601f, 0.04006059f, 0.03087790f, 0.27627754f, 0.20873396f, 
    0.02264675f, 0.08818995f, 0.07482538f, -0.32870272f, -0.10736744f, 0.05220453f, 0.02164176f, 0.19422062f, 
    -0.01109232f, -0.08144710f, -0.22612739f, -0.08130871f, -0.27077895f, 0.01607831f, 0.18435721f, 0.01405323f, 
    0.16381916f, 0.12980948f, -0.26092595f, 0.06911042f, -0.14585371f, -0.13882056f, 0.06991867f, -0.05129857f, 
    0.18561885f, -0.13264188f, 0.28699178f, -0.24469170f, 0.03379491f, 0.00969153f, -0.00248604f, -0.05389026f, 
    -0.00251608f, -0.19381343f, -0.04389675f, -0.33771920f, 0.29403472f, -0.02538035f, -0.01643261f, -0.02024419f, 
    0.03058798f, 0.11264461f, 0.15541011f, -0.13648410f, 0.19055116f, 0.07034934f, 0.07832749f, 0.10426091f, 
    -0.07880788f, -0.01724003f, -0.04826032f, 0.04789932f, 0.10058515f, -0.00670925f, -0.02539010f, 0.07538963f, 
    0.09708916f, 0.20012540f, 0.02730628f, 0.09443654f, 0.14360730f, 0.01429324f, -0.05740677f, -0.00272061f, 
    -0.00817103f, -0.13570406f, 0.14890383f, -0.04504656f, 0.04558909f, 0.11895676f, -0.13996918f, -0.00152354f, 
    0.04195856f, 0.05782067f, 0.12893720f, -0.07327823f, 0.05318100f, 0.09800936f, 0.15381360f, 0.12186278f, 
    -0.10694078f, -0.03648493f, -0.06424610f, -0.01532583f, -0.08680158f, 0.11980631f, -0.04737719f, -0.10274422f, 
    -0.10755073f, -0.20160159f, -0.10209295f, 0.14174324f, 0.03450152f, -0.10820358f, 0.08639163f, 0.11216770f, 
    0.05293606f, -0.21309355f, -0.17293262f, -0.22032075f, 0.02303329f, 0.09547756f, 0.16126594f, 0.11018237f, 
    0.11279970f, 0.19928552f, -0.11342394f, -0.07602048f, 0.35831827f, -0.02139068f, 0.14351274f, -0.03595834f, 
    -0.05859940f, 0.06477027f, -0.05158651f, 0.19396950f, 0.20926999f, -0.02354123f, -0.05110049f, -0.04736194f, 
    -0.27808994f, 0.07566910f, 0.19016267f, 0.12803490f, -0.09605026f, -0.20065702f, 0.21207042f, -0.04783916f, 
    -0.11566681f, -0.05459814f, -0.18125153f, 0.01706774f, 0.17844488f, -0.25680447f, -0.11530304f, -0.50834250f, 
    0.09310385f, -0.08916424f, -0.08029661f, -0.05734017f, -0.04029085f, -0.06911968f, -0.47036579f, -0.03368442f, 
    -0.06356199f, 0.02566984f, -0.16943696f, -0.02892399f, -0.04022659f, -0.03610223f, -0.19257307f, -0.04532974f, 
    -0.07390507f, -0.02355835f, 0.25994718f, 0.04928160f, -0.06945650f, -0.04091211f, 0.14975671f, 0.00264792f, 
    0.07593914f, -0.08696074f, 0.01225067f, 0.02259791f, -0.10281890f, -0.17559041f, 0.12304706f, 0.10490578f, 
    0.15024842f, -0.16856170f, -0.38264492f, -0.36682022f, -0.07934812f, -0.09515736f, -0.19476353f, -0.09381749f, 
    -0.07175673f, 0.09196711f, -0.41085795f, 0.01207098f, -0.08468983f, 0.01645790f, 0.11570773f, -0.12842178f, 
    0.07723828f, -0.02972656f, -0.00932543f, 0.05722161f, 0.00738407f, 0.11049418f, 0.16786432f, -0.13720769f, 
    -0.10429766f, -0.00939440f, 0.09146556f, 0.08515089f, -0.36012077f, -0.33327183f, -0.02458572f, 0.01840651f, 
    -0.04862186f, 0.02217155f, -0.05158550f, -0.08116230f, 0.01777743f, 0.10019028f, -0.03565488f, 0.20020467f, 
    -0.12822717f, 0.14619063f, -0.06327030f, 0.19537784f, 0.05647717f, 0.02713845f, -0.04409902f, 0.07840025f, 
    0.06616770f, 0.08184855f, 0.13703078f, -0.00039301f, -0.03380265f, 0.00145298f, 0.21351698f, 0.20351699f, 
    0.24596608f, 0.22758251f, 0.08923986f, 0.09364253f, -0.11815465f, 0.15074174f, -0.04738548f, -0.04402406f, 
    -0.11805180f, -0.03358715f, 0.01442960f, -0.04438401f, 0.08557712f, 0.06090305f, -0.15197456f, -0.06818654f, 
    -0.10328867f, -0.00769352f, -0.09038071f, -0.31865254f, 0.07363734f, -0.03265293f, 0.02157676f, -0.11794404f, 
    0.06764250f, -0.04519580f, 0.14302577f, 0.29863968f, 0.00514054f, -0.02946185f, 0.09753788f, 0.05098398f, 
    0.01740284f, 0.12494043f, -0.01347773f, 0.10918199f, 0.04842578f, 0.17223147f, -0.09966408f, -0.02971545f, 
    -0.09557029f, 0.02660257f, 0.01201035f, 0.16037859f, 0.02292056f, 0.19182798f, 0.00748291f, -0.08604734f, 
    0.11620039f, 0.07705072f, 0.03762112f, 0.20748231f, -0.09910322f, -0.04759683f, 0.03202754f, -0.07450404f, 
    0.11547550f, -0.04342647f, 0.12482014f, -0.00982962f, -0.09751549f, -0.04506867f, 0.22628899f, -0.03466164f, 
    0.33665103f, -0.00801606f, 0.00019408f, -0.14016287f, 0.02758655f, -0.01647782f, -0.05626745f, -0.19547346f, 
    0.17953637f, -0.26606250f, 0.06272295f, -0.10839532f, 0.06629009f, -0.04608834f, -0.06154085f, -0.02607588f, 
    0.02540180f, -0.01859199f, 0.05550156f, -0.06480697f, 0.00809029f, -0.08204842f, -0.04273905f, 0.03002388f, 
    0.05274891f, -0.06300171f, -0.09211624f, 0.05323690f, -0.01520785f, -0.05428048f, 0.02008692f, 0.02581505f, 
    0.01805498f, 0.02810681f, -0.07201327f, -0.01712594f, -0.01587496f, 0.04097611f, -0.04641831f, 0.05627036f, 
    -0.02137208f, -0.07567029f, -0.02048576f, -0.05499990f, -0.06578058f, 0.00569042f, 0.01381671f, -0.00415429f, 
    -0.04663517f, 0.06857217f, -0.06959501f, 0.01629332f, -0.08175741f, -0.04049323f, -0.01413657f, 0.02881638f, 
    -0.00137140f, 0.03877788f, 0.01870447f, 0.04789269f, 0.00431257f, -0.06456996f, -0.06663687f, -0.08356676f, 
    0.05315891f, -0.01808106f, -0.08467318f, -0.06420924f, 0.02594599f, 0.03481680f, -0.04427916f, -0.02892534f, 
    0.04942086f, -0.07545497f, -0.02477871f, -0.04500520f, 0.06911721f, -0.00955031f, -0.02911593f, -0.04583161f, 
    -0.00350775f, -0.04864644f, -0.09192152f, 0.03209905f, 0.02908784f, 0.00645145f, 0.06228751f, -0.03771041f, 
    0.01995128f, 0.01098221f, -0.04155442f, -0.02264898f, -0.05134789f, 0.00049933f, -0.01997528f, -0.06198167f, 
    -0.04935366f, -0.01521042f, 0.06974958f, -0.04333708f, 0.00219216f, 0.01056689f, -0.02682518f, -0.07315404f, 
    -0.01976655f, -0.07609208f, -0.00355229f, -0.05285569f, -0.00133934f, -0.00174604f, -0.08589912f, 0.04752792f, 
    0.00437045f, -0.04319216f, -0.00671247f, 0.02617283f, 0.05279004f, -0.00090920f, -0.07230183f, -0.08856610f, 
    -0.05182985f, 0.02649075f, 0.05615418f, 0.00300815f, -0.02833758f, -0.08669994f, -0.06601647f, -0.03942558f, 
    -0.02973143f, 0.07150462f, -0.05206447f, -0.05156404f, -0.01248732f, -0.07047511f, -0.03297581f, 0.00385199f, 
    -0.09005667f, -0.01978974f, 0.06956806f, 0.04923651f, -0.03365203f, 0.04327622f, -0.05517832f, 0.06401593f, 
    -0.00492356f, 0.06419124f, -0.03796769f, -0.02884343f, 0.04459009f, -0.04717388f, 0.02165037f, 0.00828326f, 
    0.00591179f, 0.02729343f, -0.09028593f, -0.02250409f, -0.07127213f, 0.04729950f, -0.04915038f, -0.06577140f, 
    0.27023610f, 0.03558333f, -0.17923540f, -0.14598535f, -0.01054436f, -0.13618210f, 0.05064123f, -0.05346212f, 
    0.15044051f, 0.30885866f, -0.16332532f, -0.32881600f, -0.01812084f, 0.05274510f, 0.03021917f, 0.06378295f, 
    0.02588290f, -0.11189929f, 0.15166752f, -0.46174732f, 0.01400561f, -0.02717186f, -0.13074906f, -0.02347237f, 
    0.04035338f, 0.04330172f, 0.17932266f, 0.06571632f, 0.08752991f, -0.05912798f, -0.02848504f, 0.01705384f, 
    0.09335680f, 0.04343510f, -0.01789352f, -0.00477617f, -0.02726978f, 0.35918716f, -0.06246336f, -0.00492864f, 
    -0.01949080f, 0.07138871f, -0.06688648f, 0.07226330f, -0.00794022f, 0.08214780f, -0.28330803f, 0.37174416f, 
    -0.18847123f, 0.02772300f, 0.08572005f, -0.05884542f, -0.11670966f, -0.04437140f, -0.16922759f, -0.07082926f, 
    -0.06910893f, -0.03155045f, 0.02961907f, 0.01565194f, 0.04003992f, 0.09632318f, 0.08421092f, 0.17578717f, 
    0.04525050f, -0.09750815f, 0.02933031f, -0.09032296f, 0.10900594f, 0.09294432f, 0.03209758f, -0.09010550f, 
    -0.07447168f, 0.06063328f, -0.23210533f, -0.02462442f, 0.03571087f, 0.00037122f, -0.08483830f, 0.05256725f, 
    -0.04437137f, 0.07444422f, -0.03794652f, -0.16171348f, -0.05018173f, -0.01814978f, 0.04329198f, -0.01161813f, 
    -0.04448993f, -0.05819531f, 0.09937740f, -0.11142288f, 0.13116527f, 0.08350012f, 0.01564883f, -0.07184187f, 
    -0.03848897f, -0.03471139f, -0.00255457f, 0.10021082f, -0.11459925f, 0.08441021f, -0.06666108f, -0.03141849f, 
    -0.04735984f, 0.01519956f, 0.08401206f, -0.02175472f, 0.64216870f, -0.04292108f, -0.04400206f, -0.05930376f, 
    -0.05147116f, 0.07731482f, -0.15810366f, -0.17008680f, -0.00198411f, -0.32940507f, -0.32283717f, -0.11937699f, 
    0.18415116f, 0.17984070f, 0.00532312f, -0.25155535f, -0.02154661f, 0.01860361f, 0.24561660f, 0.00159468f, 
    -0.12870620f, 0.08138916f, -0.08730433f, -0.14991580f, 0.01556672f, 0.04939644f, 0.21768460f, -0.12333346f, 
    0.09683340f, -0.17671189f, 0.13293363f, 0.08437894f, 0.09987625f, 0.04806391f, 0.06933425f, 0.04831372f, 
    -0.03855115f, -0.15934077f, 0.09727888f, 0.03308380f, -0.01229191f, -0.00299991f, 0.02918704f, 0.06609327f, 
    0.03083706f, 0.10064407f, 0.05856523f, 0.11061297f, 0.00938775f, 0.04923171f, 0.05099574f, 0.06293710f, 
    -0.09304029f, 0.06872410f, 0.00286723f, -0.06759263f, 0.00074887f, -0.06768501f, -0.07624666f, 0.03185407f, 
    -0.03985020f, -0.04005773f, 0.04041229f, -0.00922309f, -0.06250864f, -0.19026525f, 0.07659887f, -0.00718010f, 
    0.11492439f, 0.16158815f, -0.12733090f, -0.15000135f, -0.01629830f, -0.05429646f, -0.20072693f, 0.15410662f, 
    -0.00531393f, -0.13935335f, -0.01780528f, -0.10181810f, -0.03716234f, 0.04253953f, 0.01329139f, 0.08481011f, 
    -0.10513533f, 0.02720308f, 0.16486280f, -0.01367715f, 0.20391655f, -0.03542075f, 0.01598202f, -0.14626101f, 
    -0.12530458f, 0.00779291f, -0.00286873f, 0.14034089f, -0.01174157f, 0.02836721f, -0.06660737f, 0.09725202f, 
    0.10312123f, 0.22815961f, -0.23020287f, -0.07264366f, 0.03180141f, 0.04433841f, 0.07195437f, 0.14979732f, 
    -0.16924228f, -0.11859687f, -0.33296183f, 0.03276677f, 0.09472880f, 0.18444102f, 0.03888780f, 0.02897372f, 
    -0.05646713f, 0.04973868f, -0.22404683f, 0.08786117f, -0.19037636f, -0.22528893f, -0.23236449f, 0.07523825f, 
    0.00499145f, -0.00301849f, -0.04559569f, 0.02652151f, 0.38484871f, -0.03169275f, -0.07035984f, -0.03713241f, 
    -0.09827825f, 0.11269997f, 0.02017997f, 0.13743259f, 0.01244586f, 0.04696315f, 0.02462782f, -0.01048141f, 
    0.10553838f, -0.05281261f, -0.01830515f, 0.01912003f, 0.17839575f, 0.12026224f, 0.21090022f, -0.07505710f, 
    0.01484138f, 0.06108816f, -0.11243375f, 0.01152063f, -0.06755125f, -0.15113910f, 0.05167399f, -0.30616045f, 
    -0.06884849f, -0.13489909f, -0.04286561f, 0.08811225f, -0.09920823f, 0.16351198f, 0.19761711f, -0.03240864f, 
    0.40110463f, -0.06110229f, 0.17224932f, -0.10399260f, -0.03555387f, 0.05835931f, 0.16687739f, 0.24408434f, 
    -0.07265797f, -0.18620734f, 0.14815918f, -0.00232509f, 0.10386393f, -0.00917459f, 0.03117634f, 0.07195527f, 
    -0.22291932f, -0.05507788f, 0.03744411f, -0.08135650f, -0.11968475f, 0.11704279f, -0.02368908f, -0.01389703f, 
    0.21600863f, -0.29690632f, -0.11164638f, -0.36480862f, -0.20653826f, 0.18677777f, -0.04477887f, -0.10489640f, 
    0.06474977f, -0.04020956f, 0.12084788f, 0.10746490f, 0.03356012f, -0.04639598f, 0.00834630f, -0.10138410f, 
    0.09859552f, 0.01449957f, 0.12803580f, 0.04346767f, 0.12891681f, 0.23977289f, 0.13641848f, 0.10300670f, 
    0.01528737f, 0.03960894f, -0.11300586f, 0.02826007f, -0.06601453f, 0.17250668f, 0.21375452f, -0.16013800f, 
    0.09648546f, 0.10149840f, -0.00896688f, -0.04218289f, 0.03035079f, -0.06458311f, 0.09082890f, -0.16739304f, 
    0.05675191f, 0.02657345f, 0.00148773f, 0.10153889f, -0.17009705f, -0.11216420f, 0.01538073f, 0.00348293f, 
    0.24960090f, 0.00109124f, 0.18643807f, -0.00973504f, 0.08846711f, 0.01025490f, 0.11350776f, -0.09365245f, 
    -0.12798946f, -0.27320442f, -0.05585521f, -0.03003071f, 0.14364506f, 0.02108271f, 0.00796205f, 0.08999854f, 
    -0.03469891f, 0.23108271f, 0.12767807f, 0.02900823f, 0.13411970f, -0.12434461f, 0.21553440f, 0.01460321f, 
    0.05773105f, 0.16824292f, -0.03367027f, -0.14202423f, 0.16089422f, 0.02902384f, -0.06143617f, -0.05373539f, 
    0.03994941f, 0.13217483f, -0.39050573f, -0.10139184f, 0.06054100f, -0.05122613f, -0.02707660f, -0.02517713f, 
    0.03753117f, 0.00342212f, 0.05072337f, -0.15953407f, -0.20491096f, 0.12343412f, 0.07305747f, 0.03297418f, 
    0.01934309f, -0.01659966f, 0.08769911f, -0.05925815f, 0.04602551f, -0.05633919f, -0.28845865f, 0.13819447f, 
    -0.02932712f, 0.09445948f, 0.06320917f, -0.17385595f, 0.09233282f, 0.26283178f, -0.02296671f, 0.16530615f, 
    0.05008251f, -0.04619407f, -0.13557911f, -0.06548199f, 0.03494271f, 0.05639552f, -0.26126584f, -0.09473670f, 
    0.12462611f, 0.16045132f, -0.03939402f, 0.07217739f, 0.01668393f, -0.16926458f, 0.12617719f, -0.25714129f, 
    -0.27783585f, -0.04503398f, -0.04959360f, -0.06826399f, -0.04028549f, 0.07629231f, 0.03747811f, 0.09019688f, 
    -0.11807340f, -0.47698975f, 0.09798776f, -0.04433058f, 0.10636908f, 0.13730650f, 0.06380519f, -0.02054037f, 
    -0.10928495f, -0.13690756f, -0.16802889f, -0.04594203f, -0.22339241f, -0.11860204f, -0.05021572f, 0.02914044f, 
    -0.14891872f, -0.08622072f, -0.01608836f, -0.02377420f, -0.06532235f, 0.02266481f, -0.10452354f, -0.07843143f, 
    0.03810483f, -0.17971620f, 0.06842061f, -0.48416200f, -0.17403916f, -0.10438376f, 0.02273642f, 0.25623655f, 
    -0.08286267f, -0.03870507f, -0.23341769f, -0.00757846f, 0.10933810f, -0.00076646f, 0.16507217f, -0.04996577f, 
    0.07107269f, -0.09487684f, -0.05252413f, 0.14800860f, -0.07816005f, -0.02784400f, -0.01552499f, -0.12161727f, 
    0.12358052f, -0.02896490f, 0.03035410f, 0.05391053f, 0.18423788f, -0.02097790f, 0.06808971f, -0.09938233f, 
    -0.06875766f, -0.06445286f, 0.09820151f, 0.05412776f, 0.12417161f, -0.04278160f, -0.04659468f, 0.00558454f, 
    0.21996340f, -0.13658398f, 0.18093938f, 0.14743920f, 0.07203020f, 0.03078329f, -0.06630045f, 0.13076402f, 
    0.11724963f, -0.07587319f, 0.30897292f, -0.13757543f, 0.01109584f, -0.00078469f, -0.14362095f, 0.19502954f, 
    -0.00857452f, 0.16153088f, 0.04853098f, 0.10803826f, 0.04745348f, -0.00982306f, -0.01155546f, 0.14675002f, 
    -0.07046313f, 0.10070103f, -0.70484197f, -0.10160422f, 0.03496348f, 0.14070217f, 0.11011047f, -0.10539038f, 
    0.07245658f, -0.03486199f, 0.15043366f, -0.18461202f, 0.26938123f, -0.01232143f, -0.05859440f, -0.18894990f, 
    0.04572039f, -0.07660636f, -0.04753138f, 0.06439240f, -0.20794611f, -0.15243554f, -0.05676809f, -0.07370374f, 
    -0.02804493f, 0.02689820f, -0.12331805f, 0.11735199f, -0.03785391f, -0.12213194f, 0.10644812f, 0.14612421f, 
    -0.08958752f, 0.09890182f, 0.01863533f, 0.05567496f, -0.00904688f, 0.02918199f, -0.25625765f, 0.06110850f, 
    -0.08678555f, 0.04128255f, 0.05757225f, -0.10121108f, 0.03320017f, -0.14215469f, -0.01577520f, 0.35956872f, 
    -0.13868038f, -0.10679252f, -0.03120031f, 0.05696568f, -0.03359935f, 0.01121020f, 0.00205245f, -0.02226914f, 
    0.12555604f, 0.20273468f, -0.47893065f, -0.01420855f, -0.00533731f, 0.09824700f, -0.19683546f, -0.11810964f, 
    -0.03339302f, -0.39368635f, -0.28975680f, -0.02265063f, -0.07004735f, -0.08624431f, -0.08133819f, -0.10362819f, 
    0.05788460f, 0.01762528f, -0.25694531f, 0.08223898f, 0.26338595f, 0.04751883f, 0.05102091f, -0.02259711f, 
    -0.05331081f, 0.04283968f, 0.03863136f, 0.04132717f, 0.12474836f, -0.00836797f, -0.15954220f, -0.03872265f, 
    0.03805935f, 0.04511157f, -0.04712552f, -0.02821457f, 0.28767052f, 0.01841200f, 0.05488973f, -0.08083639f, 
    -0.06394508f, 0.12429714f, -0.07392687f, 0.07063574f, 0.10558529f, -0.04993818f, -0.08447477f, -0.24880059f, 
    0.14313483f, 0.09266658f, 0.08177460f, 0.08410825f, -0.04554353f, 0.06455106f, 0.06923696f, 0.05210602f, 
    0.26375121f, -0.20140433f, 0.02748135f, -0.04704627f, 0.13037743f, -0.02049782f, -0.02745093f, 0.16470231f, 
    0.27390987f, -0.12298350f, 0.13970810f, 0.15072861f, 0.07697611f, 0.00000483f, 0.00256997f, -0.01659580f, 
    0.16754375f, -0.17686579f, 0.26892385f, -0.16087382f, -0.24019168f, 0.13434543f, 0.01705279f, -0.05501958f, 
    -0.04947383f, -0.15790063f, -0.27409533f, -0.24616148f, 0.18612875f, -0.01993979f, 0.13831075f, 0.07968825f, 
    -0.15752287f, 0.02314083f, 0.01321423f, -0.21272787f, -0.05115216f, 0.06206828f, 0.09462127f, 0.04128628f, 
    -0.02342034f, -0.03186685f, 0.02797147f, 0.20516521f, -0.10315354f, -0.29414263f, -0.21079598f, -0.12297711f, 
    0.06177188f, 0.19500594f, 0.02090339f, 0.13191719f, 0.23233163f, -0.17541720f, -0.28354859f, 0.06906572f, 
    -0.02544159f, 0.00913491f, 0.14072019f, -0.14255086f, -0.01162715f, -0.34674904f, -0.02143889f, 0.00999040f, 
    0.01973882f, 0.02378478f, 0.00104044f, 0.05884960f, -0.05854803f, -0.03256211f, 0.26448464f, -0.16193050f, 
    -0.24339867f, 0.03241532f, -0.12424816f, -0.08508740f, 0.04587654f, -0.04088865f, -0.05218412f, -0.17221628f, 
    0.16419397f, 0.19939651f, 0.05394334f, 0.06571966f, 0.03088963f, 0.02388820f, 0.08286879f, 0.05604914f, 
    -0.01991321f, 0.10131563f, 0.02734164f, -0.01825628f, -0.00528986f, 0.04367962f, 0.09839358f, 0.06672727f, 
    0.09902628f, -0.01063897f, -0.20194821f, -0.03588714f, 0.09558942f, 0.03193130f, -0.04055629f, -0.05866962f, 
    0.03762217f, 0.20625162f, -0.06663468f, -0.09696022f, -0.12239456f, 0.07988193f, 0.02167904f, 0.02911641f, 
    0.00422610f, 0.00707578f, 0.02962191f, -0.16889073f, 0.21695761f, 0.32241887f, 0.11092599f, 0.03309567f, 
    -0.14258245f, -0.21067408f, -0.05042665f, -0.10889729f, 0.22388081f, 0.35768297f, 0.11554686f, -0.07082061f, 
    -0.05848261f, 0.09274475f, -0.04784966f, 0.08217584f, 0.05461108f, -0.13484798f, -0.30223379f, 0.01614219f, 
    0.16651627f, 0.05713167f, -0.10238876f, 0.02188503f, -0.13428143f, -0.15069383f, -0.11806895f, 0.13245359f, 
    0.07873872f, -0.01355981f, 0.05736854f, -0.16739480f, 0.07328373f, 0.06062043f, 0.12597018f, 0.17019346f, 
    -0.41598976f, -0.18014109f, 0.09094219f, -0.13895077f, -0.01188053f, 0.03970699f, -0.15848698f, -0.01518902f, 
    -0.14551383f, 0.17886049f, 0.03098418f, 0.07254522f, -0.07076780f, -0.00027659f, -0.03436440f, 0.07487079f, 
    0.06738590f, 0.07453299f, -0.00330563f, -0.41713423f, 0.07758031f, -0.01543486f, 0.11998114f, 0.05797073f, 
    -0.07701296f, -0.04089549f, -0.24666362f, 0.10907133f, -0.17438456f, 0.07301439f, 0.01758820f, 0.01372495f, 
    -0.05073294f, 0.22121702f, -0.07458325f, 0.05935225f, -0.01280612f, 0.04502103f, 0.05399799f, -0.02989514f, 
    -0.08161440f, 0.09963429f, 0.03203792f, 0.01834881f, -0.11914374f, -0.15135583f, -0.00351898f, -0.05825187f, 
    0.08928081f, 0.04338858f, 0.20902476f, -0.17115985f, -0.02217788f, -0.13895458f, 0.07552385f, -0.03775781f, 
    0.00783526f, 0.03200018f, -0.13546985f, 0.02398038f, -0.06925184f, -0.17921217f, -0.01879034f, -0.33061793f, 
    -0.13934276f, 0.17612673f, 0.13313280f, 0.10091198f, -0.04027705f, -0.16092907f, -0.30539021f, -0.17546529f, 
    0.20996928f, -0.17727441f, 0.07128549f, 0.09712327f, 0.05389074f, -0.09788798f, -0.08614386f, -0.01597962f, 
    -0.06657501f, 0.15780386f, -0.04758773f, -0.07550529f, 0.14922592f, 0.21311919f, -0.02744826f, -0.23247376f, 
    -0.15920095f, 0.04519746f, 0.04378412f, -0.04197021f, -0.10080226f, 0.07848125f, -0.17249110f, -0.01102849f, 
    0.06189472f, -0.15709142f, 0.16263880f, -0.11101925f, -0.16284180f, 0.05783922f, 0.17446776f, 0.07588185f, 
    0.03724395f, 0.14305638f, -0.05115122f, 0.19502924f, 0.07427219f, -0.06162716f, -0.00379091f, -0.15387231f, 
    -0.11798929f, 0.12548073f, -0.14961372f, -0.29468977f, 0.11865871f, 0.15610668f, 0.00714348f, -0.13845390f, 
    -0.09232080f, -0.22678261f, -0.05905835f, -0.01698090f, 0.02063020f, 0.05924794f, -0.07402916f, 0.19140667f, 
    0.10062980f, -0.09075034f, 0.13302557f, -0.19126597f, -0.09517834f, -0.13774571f, 0.14129040f, 0.11887195f, 
    -0.11587507f, -0.10976344f, -0.18971285f, -0.01766679f, -0.02255818f, 0.22760606f, -0.08775114f, -0.05330946f, 
    -0.08637747f, 0.07219267f, 0.06224114f, 0.04752618f, 0.19003929f, -0.05865805f, -0.02857682f, 0.06249801f, 
    -0.08721883f, 0.29380995f, -0.10291842f, -0.09812579f, 0.02188547f, -0.08423389f, 0.11588394f, 0.10000256f, 
    -0.10911289f, -0.15334754f, 0.13529484f, 0.09928464f, 0.09431309f, 0.06069610f, -0.02399098f, 0.02274304f, 
    -0.04372129f, 0.06763801f, 0.17160225f, -0.04300250f, 0.27814236f, 0.03579250f, 0.10029851f, -0.06460623f, 
    -0.06706030f, -0.12192108f, 0.18263406f, 0.03853504f, 0.09558705f, -0.01697571f, 0.18441473f, 0.02017913f, 
    0.27361199f, 0.02523101f, 0.15094554f, -0.22912298f, 0.05529879f, 0.01422426f, 0.00268516f, 0.07432574f, 
    -0.04518178f, -0.07933673f, -0.04215372f, -0.14114234f, -0.37207347f, 0.02396482f, 0.17824279f, -0.07446239f, 
    -0.08656341f, 0.22320010f, 0.01780936f, -0.12274904f, 0.14931062f, 0.06891093f, -0.20785972f, -0.13126071f, 
    0.12220427f, -0.03509963f, 0.05806488f, -0.00208554f, -0.15106392f, -0.05849745f, 0.19798446f, 0.13788736f, 
    -0.01375749f, -0.15989351f, 0.15126564f, -0.06572221f, 0.02818761f, 0.28549290f, -0.08918601f, -0.08025364f, 
    -0.21058096f, -0.06055228f, -0.03637350f, -0.13229211f, -0.02112700f, -0.19380420f, 0.09242390f, -0.00616372f, 
    -0.04764934f, -0.11775234f, -0.30687845f, 0.04567311f, -0.11243989f, -0.07761773f, -0.12407544f, 0.14788501f, 
    -0.30829313f, 0.05064929f, 0.32313082f, 0.00552234f, 0.01085729f, -0.08640901f, -0.01789520f, -0.05663342f, 
    0.03115794f, 0.03716824f, 0.04544299f, -0.69333327f, -0.34622884f, -0.20411095f, -0.02438770f, 0.07530969f, 
    -0.16870758f, -0.15430683f, 0.04371334f, 0.07959858f, 0.08195040f, 0.22495647f, -0.02947443f, 0.23320284f, 
    0.11751153f, 0.05200529f, 0.04147202f, -0.04561656f, 0.00094866f, 0.14793807f, 0.07565434f, -0.00926042f, 
    -0.09442171f, -0.11824208f, 0.05867166f, -0.02499978f, 0.08966447f, 0.12448995f, -0.73142862f, -0.22886714f, 
    -0.10259306f, 0.10373279f, 0.09176624f, 0.03090296f, 0.02715195f, 0.15419236f, -0.08743627f, 0.29110542f, 
    0.08081676f, 0.02455137f, -0.04657725f, 0.05022684f, 0.10907417f, 0.00311810f, -0.09428931f, 0.07873034f, 
    -0.00407236f, 0.33530107f, -0.02771441f, 0.28667250f, -0.00892950f, 0.06863240f, -0.09797895f, -0.21706821f, 
    0.01159032f, 0.29469681f, 0.14581469f, -0.01638706f, 0.07950388f, -0.01086508f, -0.00190388f, 0.06595892f, 
    -0.04984821f, 0.06183201f, -0.01950108f, 0.00739923f, 0.15769620f, -0.12044477f, -0.20318384f, 0.01449532f, 
    0.06539901f, 0.13391119f, -0.01742086f, -0.16178147f, -0.09508592f, -0.07218152f, 0.05437305f, 0.01360127f, 
    -0.02115410f, 0.02502891f, -0.03561999f, -0.07058102f, -0.02045820f, -0.02519386f, -0.06230213f, 0.20696843f, 
    -0.11904887f, -0.11297546f, -0.08427332f, 0.06790850f, -0.01856573f, 0.05897279f, 0.02300269f, -0.32163998f, 
    -0.03783524f, -0.01526827f, 0.04501570f, -0.04640570f, -0.14697155f, 0.04840632f, 0.06315676f, -0.19439563f, 
    -0.06669666f, -0.05224275f, -0.12178798f, -0.03123395f, -0.22866379f, 0.13679221f, -0.04785556f, 0.24832560f, 
    0.11657941f, 0.06681271f, 0.07914535f, 0.05805534f, -0.11154743f, 0.05857248f, 0.05614635f, 0.13697027f, 
    -0.21532136f, 0.20960736f, 0.07977250f, 0.03570712f, -0.11253162f, 0.15824889f, -0.01363617f, -0.03610891f, 
    -0.09236635f, 0.05688959f, -0.03853332f, -0.07353000f, -0.07195484f, 0.11180262f, -0.13963503f, -0.04708046f, 
    0.20120130f, -0.02998162f, 0.21837306f, 0.11531519f, 0.05422312f, 0.15425047f, -0.14325431f, 0.06913767f, 
    -0.13978449f, 0.09397686f, 0.02968420f, -0.23289439f, -0.12274668f, -0.21057792f, -0.12064403f, 0.05225768f, 
    0.04104928f, -0.04072374f, 0.05313842f, 0.02265462f, -0.09800150f, -0.47764489f, 0.14753069f, 0.03913300f, 
    0.03951324f, 0.13639875f, -0.06576245f, -0.08475698f, -0.04422779f, 0.07645874f, 0.18533586f, -0.05620939f, 
    -0.16613953f, -0.10843132f, -0.07212239f, 0.07497215f, 0.14040330f, -0.07925075f, -0.02315828f, -0.30807173f, 
    -0.03739495f, -0.01470041f, 0.09168532f, 0.00969724f, -0.01201797f, 0.05110308f, -0.07029846f, 0.04686139f, 
    0.08195050f, -0.02254914f, 0.06424430f, 0.00447235f, 0.01431574f, 0.02697167f, 0.10032355f, 0.17186914f, 
    -0.02712114f, -0.09273842f, 0.18699566f, -0.08021878f, -0.08139899f, 0.17249490f, 0.02440608f, -0.03722928f, 
    -0.06449091f, 0.02415975f, 0.01530318f, 0.06526408f, 0.16227566f, 0.03369226f, -0.04552977f, -0.10303276f, 
    -0.07927754f, 0.06465928f, 0.04491077f, 0.10414599f, -0.09705520f, -0.07844827f, -0.05908483f, 0.15228437f, 
    0.02853110f, -0.00319769f, -0.07978979f, -0.07440316f, 0.04461651f, -0.08574636f, -0.06668844f, 0.01043816f, 
    -0.15732986f, -0.00521937f, -0.02190186f, -0.00920660f, -0.06734274f, 0.03105169f, 0.04566361f, -0.06642754f, 
    -0.02753071f, -0.11924399f, 0.06362722f, -0.13831131f, -0.04624401f, 0.53179771f, 0.03984752f, 0.00328062f, 
    0.09156641f, 0.15264381f, -0.09212198f, 0.04877641f, -0.00317676f, 0.00967998f, 0.11296830f, 0.16359824f, 
    0.06461600f, 0.10825804f, -0.12511072f, -0.08304808f, 0.08519347f, 0.08830484f, 0.07992463f, 0.24006265f, 
    0.05358490f, 0.09109381f, 0.02059473f, -0.00258450f, 0.01640875f, -0.03500373f, 0.00157497f, 0.03922139f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.00266057f, 0.04649950f, 0.06197325f, 0.01359684f, 0.21786276f, 0.01970849f, 0.07401665f, 0.05761905f, 
    -0.00652176f, 0.09435765f, 0.10811009f, 0.02425350f, 0.13219497f, 0.10071047f, 0.13738525f, -0.00962595f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.14843969f, -0.17783312f, -0.19394469f, -0.25207603f, 0.54014134f, 0.06896776f, -0.03293330f, 0.08078927f, 
    -0.26280570f, -0.04938439f, 0.36591896f, -0.13551451f, -0.04922684f, 0.40941817f, -0.17265050f, 0.06140534f, 
    -0.13028964f, -0.05256964f, 0.16761240f, 0.17787656f, -0.13635944f, -0.19316699f, 0.13260210f, 0.07643565f, 
    -0.09415393f, -0.19420847f, -0.48461565f, -0.31339854f, -0.60082155f, 0.00061243f, 0.41526020f, 0.44160879f, 
    -0.09875715f, 0.15196051f, 0.05002069f, -0.30360356f, 0.58912086f, -0.29398423f, 0.13968436f, -0.05399347f, 
    0.02949264f, 0.04486146f, 0.08082402f, -0.20137061f, 0.34535459f, 0.27118036f, -0.14619225f, -0.10155717f, 
    0.00410378f, 0.03374355f, 0.03132948f, -0.23332927f, -0.22980720f, -0.12725066f, 0.24742952f, -0.06037915f, 
    0.13216192f, -0.20175923f, -0.05542852f, -0.04557154f, 0.02299422f, -0.22760019f, -0.11419392f, 0.04385348f, 
    -0.18368986f, -0.11036950f, 0.05960435f, 0.02546194f, 0.18855487f, -0.28819159f, -0.05072752f, 0.40464243f, 
    0.12937137f, 0.04610752f, 0.15040281f, -0.16831756f, -0.06702244f, 0.20278409f, 0.09404444f, -0.65918458f, 
    -0.16606899f, 0.04689592f, -0.25028226f, -0.01589611f, -0.14002940f, -0.01189448f, -0.18621944f, 0.16412847f, 
    -0.25968421f, 0.42922902f, -0.31639647f, -0.04546426f, -0.32066983f, 0.24457482f, 0.23668486f, 0.04870154f, 
    0.11415093f, -0.08136524f, -0.01818111f, -0.05741312f, 0.16004564f, 0.23781119f, 0.15431671f, -0.15373909f, 
    -0.36270937f, 0.43751866f, -0.04363022f, 0.18673776f, 0.29125294f, -0.31949881f, 0.31988761f, 0.17335062f, 
    -0.20304830f, -0.07322367f, -0.18646720f, 0.08877339f, -0.11313834f, 0.12736912f, -0.06939445f, 0.32284632f, 
    0.36684859f, -0.05457554f, -0.11135475f, -0.24206953f, 0.19843812f, 0.28651959f, -0.30299288f, -0.33018002f, 
    -0.19654556f, 0.17531046f, -0.23554175f, -0.40652961f, -0.33372107f, -0.21398117f, -0.08690926f, 0.09940381f, 
    0.06015055f, -0.04994776f, -0.23672830f, 0.10469827f, 0.09076472f, -0.23702228f, 0.62305492f, -0.02832363f, 
    0.15462916f, -0.41192496f, -0.08213219f, -0.22186884f, 0.15180601f, 0.35208750f, -0.19239594f, 0.22276506f, 
    -0.14569953f, 0.15704201f, 0.33780783f, 0.28594959f, 0.21853401f, 0.20638046f, -0.31531769f, 0.01875176f, 
    -0.12685119f, 0.11821599f, -0.10084146f, 0.19601399f, -0.29081684f, 0.15100709f, -0.17467651f, -0.04493045f, 
    -0.13443302f, 0.26715332f, 0.14728843f, -0.15042213f, 0.22860149f, -0.23571506f, 0.43004936f, -0.28448907f, 
    -0.13625461f, 0.19421682f, -0.05705291f, 0.45157552f, -0.13528876f, -0.14872019f, 0.17068073f, 0.45556167f, 
    -0.04443059f, -0.19802755f, -0.12201725f, -0.33858392f, -0.43629852f, 0.16694918f, 0.35178804f, 0.01348111f, 
    -0.02399123f, -0.12160270f, 0.01517332f, 0.21711862f, 0.17182861f, 0.06598581f, -0.09708139f, 0.15630551f, 
    -0.06829847f, -0.25737688f, 0.17706680f, -0.10755749f, -0.62992120f, -0.08959717f, 0.39317468f, 0.28354931f, 
    0.00500373f, -0.37411973f, 0.19722626f, 0.00442460f, 0.34054124f, 0.01147453f, -0.20293665f, 0.06260226f, 
    0.23525071f, 0.30441478f, -0.26865253f, -0.01069309f, 0.24610208f, -0.13832067f, -0.00162754f, -0.24463098f, 
    -0.19712745f, -0.07103696f, -0.15299447f, 0.01120988f, -0.08110159f, 0.11668618f, -0.14476204f, -0.09286672f, 
    -0.08856193f, -0.22328250f, 0.17166863f, -0.43874756f, 0.20087041f, 0.33889493f, 0.20610210f, 0.26645282f, 
    -0.17248052f, -0.32991070f, -0.13570477f, 0.10458394f, 0.36227977f, -0.20552321f, 0.23992923f, 0.18839888f, 
    -0.08849537f, 0.03431117f, -0.14473042f, 0.31488129f, -0.12924591f, -0.32260740f, 0.45644641f, -0.04836493f, 
    -0.11266630f, 0.37326267f, 0.20150612f, -0.03285446f, 0.11031974f, 0.15689488f, 0.03726705f, 0.38877377f, 
    -0.33894551f, -0.11000351f, -0.50245422f, 0.30178276f, -0.05064191f, -0.03576967f, 0.18598978f, -0.10896593f, 
    0.22423929f, 0.13250129f, -0.08091656f, -0.09390977f, -0.23948149f, 0.33746716f, -0.18760164f, -0.05721589f, 
    0.08168895f, -0.44417164f, -0.08061260f, -0.31151167f, -0.03281108f, 0.20059469f, 0.33618066f, 0.23543170f, 
    0.23191413f, 0.13089833f, -0.08078980f, -0.16036311f, -0.02865419f, -0.20084524f, -0.14497438f, 0.03826478f, 
    0.06191462f, -0.23402098f, -0.02355114f, -0.10526541f, -0.24505413f, -0.05377311f, -0.18764773f, -0.09496382f, 
    -0.15200242f, 0.29783836f, 0.14059767f, 0.02417279f, -0.00161995f, -0.14670798f, -0.06873520f, -0.03918760f, 
    0.34661409f, 0.13534120f, 0.18783604f, -0.30123514f, 0.20098981f, 0.31158778f, -0.21949665f, -0.17267548f, 
    0.05398328f, -0.40082943f, -0.07239899f, 0.24502689f, 0.30248001f, 0.25499877f, -0.17452936f, 0.23182932f, 
    -0.15230128f, 0.30790812f, 0.22109607f, 0.14999285f, -0.15691887f, -0.12374080f, 0.03960520f, -0.16956095f, 
    0.17977533f, 0.25137717f, -0.02085891f, 0.03793903f, 0.01649009f, 0.24251887f, -0.25184730f, -0.18132007f, 
    0.32752639f, -0.26031229f, -0.02493464f, -0.06961788f, -0.21555084f, -0.07171502f, 0.23431899f, -0.00002418f, 
    -0.08798365f, 0.04387080f, 0.23857488f, -0.21612024f, 0.10469935f, 0.31791872f, 0.17195472f, 0.28334650f, 
    -0.24093863f, -0.01943685f, 0.18938379f, -0.06370651f, 0.21786007f, -0.40407631f, 0.38643387f, 0.16602799f, 
    0.01447758f, 0.38832644f, -0.21571532f, 0.38621068f, -0.37534046f, 0.21823014f, 0.06150997f, 0.41091725f, 
    0.04700818f, -0.10389722f, -0.25306851f, -0.05583788f, 0.24364571f, -0.06727158f, -0.45928037f, 0.03283823f, 
    -0.11466047f, 0.05302390f, -0.15092903f, 0.19062304f, -0.07703862f, 0.30073869f, 0.12648451f, 0.34987780f, 
    0.10815073f, -0.10802197f, 0.52084142f, 0.10698478f, -0.30127555f, -0.16864790f, -0.29697740f, 0.25448629f, 
    -0.07774196f, -0.03337651f, 0.14777979f, -0.16600701f, 0.01568528f, 0.25970641f, -0.08574666f, 0.38459665f, 
    0.02644274f, -0.16760878f, -0.24378483f, 0.29916546f, -0.13984163f, -0.03610333f, -0.03239061f, -0.04487737f, 
    -0.24208185f, -0.01377943f, -0.03526276f, -0.66950727f, -0.28782555f, 0.02749785f, -0.15305513f, -0.27157035f, 
    0.22113638f, 0.38597202f, -0.47206128f, 0.29354432f, 0.50982559f, -0.67607808f, 0.31784099f, -0.01268686f, 
    0.09815464f, 0.31005034f, -0.17854109f, 0.32512012f, -0.19260155f, -0.16421056f, -0.18143754f, 0.07445367f, 
    0.05819781f, 0.12453210f, -0.03570250f, 0.18020086f, 0.14685869f, -0.04761869f, 0.00360299f, -0.36706552f, 
    -0.02971977f, 0.15597156f, 0.04484087f, 0.31373453f, 0.11997157f, -0.07188274f, 0.23264946f, -0.30642360f, 
    -0.11083191f, 0.41331828f, -0.30045184f, -0.27082273f, 0.19117929f, -0.22504741f, 0.02820938f, 0.11910310f, 
    0.19964933f, 0.29031521f, -0.10921094f, -0.39142430f, -0.11919467f, 0.10034441f, -0.03214189f, -0.50461960f, 
    0.23703583f, 0.35192394f, -0.41726646f, -0.12168557f, 0.31307152f, -0.64344180f, 0.05434449f, 0.38206366f, 
    -0.17240795f, 0.38465133f, -0.21499214f, -0.26065964f, -0.37776315f, 0.22369504f, 0.03392889f, 0.21217525f, 
    -0.44229820f, 0.28529817f, 0.13173339f, -0.02720691f, -0.05537945f, 0.21528073f, 0.00992799f, 0.14246333f, 
    0.06642450f, -0.09339324f, -0.00865731f, -0.25740361f, -0.18320718f, -0.16044439f, 0.02307876f, 0.08716562f, 
    -0.04102936f, -0.11451154f, -0.07404135f, 0.03052597f, -0.14901248f, 0.05860394f, 0.08708213f, -0.18231466f, 
    0.02620124f, 0.09382251f, 0.07238901f, -0.01925678f, 0.01650456f, -0.32110974f, -0.03343339f, -0.13589004f, 
    0.04433947f, 0.34566596f, 0.00441219f, 0.24339303f, 0.21925357f, -0.06386434f, 0.08054341f, -0.13710022f, 
    -0.24806267f, -0.06259385f, 0.10831472f, 0.05600499f, 0.52337289f, 0.13101220f, 0.16948624f, -0.08084609f, 
    -0.11490429f, -0.18694806f, -0.20197138f, -0.28253087f, 0.28652024f, 0.05673085f, 0.44115150f, -0.14499184f, 
    0.04284465f, -0.01239761f, 0.24478768f, -0.21115616f, -0.36125243f, 0.18362331f, -0.06161807f, 0.32967120f, 
    0.34142378f, 0.03788035f, -0.32379290f, -0.18862057f, 0.16831402f, 0.04478224f, 0.37415302f, -0.24322224f, 
    -0.17447118f, -0.25483492f, -0.03845497f, -0.20309207f, 0.12409231f, -0.01767568f, -0.00105857f, 0.04651655f, 
    0.07759456f, 0.22144963f, 0.11158110f, 0.38528606f, -0.10278139f, 0.04400960f, -0.27698874f, 0.21696410f, 
    -0.22741330f, -0.09055863f, -0.24181381f, 0.16882959f, -0.51732272f, -0.08322597f, 0.10630687f, -0.16223939f, 
    0.04097750f, -0.14552677f, 0.70397735f, 0.34498692f, -0.24969919f, -0.02179513f, 0.30897108f, -0.12090940f, 
    0.05003163f, -0.13827384f, -0.07167611f, -0.24148330f, 0.01510344f, -0.20002453f, -0.11581776f, -0.22071230f, 
    -0.21380313f, -0.06541318f, -0.14240730f, 0.03419306f, 0.04454590f, -0.17602198f, 0.12128306f, -0.01563126f, 
    -0.15746875f, -0.22547966f, 0.19166557f, 0.16835493f, 0.11189270f, 0.15372972f, 0.16651563f, 0.05225124f, 
    0.36941066f, 0.07636227f, 0.01359193f, -0.63417923f, -0.31302664f, 0.11446235f, 0.21325664f, -0.07204597f, 
    0.00441203f, -0.02921702f, 0.12767734f, -0.19234253f, -0.15075707f, -0.07815099f, 0.18221518f, 0.39420369f, 
    0.07550157f, -0.31149396f, 0.20043430f, 0.22130904f, -0.31154415f, 0.35292599f, -0.18841830f, 0.04886993f, 
    -0.01486447f, -0.18535280f, 0.14871174f, -0.06718417f, -0.05127044f, 0.42689866f, -0.14712003f, 0.44124749f, 
    0.32567862f, -0.22844836f, -0.13547434f, -0.01582582f, -0.13578252f, 0.14397918f, 0.08489241f, -0.30620742f, 
    0.08023935f, 0.09852361f, 0.05951108f, 0.15547964f, -0.15529536f, 0.00922619f, -0.04065576f, 0.20578827f, 
    -0.27815601f, -0.01494212f, 0.54502672f, 0.02288208f, 0.26687688f, 0.15685640f, 0.04165132f, 0.00924862f, 
    -0.04475379f, 0.12141511f, -0.02169626f, 0.39926720f, 0.21279396f, -0.19911250f, -0.02774655f, -0.29014376f, 
    0.20664912f, -0.33019468f, -0.01187007f, 0.23777896f, -0.19902480f, -0.03852922f, 0.08822442f, 0.33435583f, 
    0.12170938f, -0.27965587f, 0.00753015f, 0.47401127f, -0.52362502f, -0.35801283f, 0.12360868f, -0.11972348f, 
    0.05818469f, -0.00684740f, 0.25262529f, -0.09671254f, 0.26873687f, 0.17496601f, 0.19039075f, -0.05525457f, 
    -0.00514082f, -0.22559808f, -0.02587771f, 0.39224413f, 0.33246160f, 0.26533899f, 0.02902212f, 0.30207425f, 
    0.21449795f, -0.34476942f, 0.04038449f, 0.29439792f, -0.07726095f, -0.01171081f, -0.17944971f, -0.11052695f, 
    -0.18293418f, 0.12549937f, -0.00048266f, 0.19394147f, -0.05371552f, -0.23393312f, 0.10952195f, -0.26609921f, 
    0.20649253f, 0.21558566f, 0.27024925f, -0.19404198f, 0.05146772f, 0.17572090f, -0.29311693f, 0.12754717f, 
    0.18073979f, 0.38202426f, -0.09278618f, 0.03226729f, -0.08921034f, -0.39204550f, -0.14810097f, 0.12696443f, 
    -0.29076707f, -0.01943931f, -0.48835811f, 0.26038772f, 0.20336773f, -0.03116525f, 0.10702451f, 0.38742018f, 
    0.16165033f, 0.18005541f, -0.13359569f, -0.03035982f, -0.16742975f, -0.05932656f, -0.20179678f, -0.01573362f, 
    -0.23832595f, -0.16564056f, 0.27418438f, 0.33683956f, 0.46750847f, -0.05387199f, 0.03269002f, 0.34411657f, 
    -0.05249261f, -0.25337967f, -0.00189000f, -0.41713768f, 0.39218593f, 0.20352767f, -0.04891321f, -0.04512088f, 
    0.30274901f, -0.02357830f, 0.37829533f, 0.05702941f, -0.05946797f, 0.09052218f, 0.01501830f, -0.17356178f, 
    0.22372736f, 0.16147490f, 0.00125954f, 0.19484779f, -0.30412340f, 0.16432163f, -0.05213638f, -0.27169701f, 
    0.02078249f, 0.32443923f, -0.20951200f, 0.17749029f, -0.00237851f, -0.21666062f, 0.14045365f, 0.30836830f, 
    -0.07549856f, 0.05418536f, 0.17936249f, -0.42576450f, 0.13618411f, 0.27498105f, 0.12704752f, -0.25579971f, 
    -0.07618675f, 0.00647692f, -0.39334267f, -0.20649016f, -0.04272744f, -0.06533305f, 0.33191171f, 0.21097401f, 
    -0.17121686f, -0.32771170f, 0.18071118f, -0.25980023f, 0.31409162f, 0.04831086f, 0.25576416f, 0.01162494f, 
    -0.21748315f, 0.21540779f, -0.03936333f, 0.35392082f, 0.00310551f, 0.28460976f, -0.25158808f, 0.17861570f, 
    -0.19644712f, 0.14079261f, -0.10495916f, 0.05468526f, -0.00289337f, -0.02760454f, 0.00693136f, -0.16240251f, 
    0.32170716f, -0.17939080f, 0.06927919f, -0.13004954f, -0.36759230f, -0.00300721f, 0.00074912f, 0.38434476f, 
    0.23224035f, -0.10018584f, -0.20683730f, 0.03821018f, -0.16445884f, -0.05481973f, -0.24925169f, 0.01814330f, 
    -0.24219108f, -0.06835350f, 0.00814006f, -0.08726022f, 0.08084154f, -0.11634490f, -0.00505880f, -0.14740452f, 
    0.12155024f, -0.25349373f, 0.18970872f, -0.09996813f, 0.04537432f, 0.38409257f, 0.17762680f, 0.36631349f, 
    -0.02893004f, -0.45356524f, 0.12600620f, 0.29828036f, -0.30447042f, 0.39553893f, 0.18102960f, -0.15504031f, 
    -0.13405113f, 0.20267794f, -0.21450852f, 0.03835689f, -0.29107678f, -0.21057682f, 0.11319103f, -0.14710173f, 
    0.20235480f, 0.01103785f, 0.32428077f, 0.20006163f, -0.21385461f, 0.16684374f, -0.05405112f, 0.23856947f, 
    0.05748593f, -0.05930664f, 0.09108803f, 0.08975366f, -0.20663998f, 0.14553587f, 0.00431008f, -0.31955722f, 
    -0.34472620f, 0.30533043f, 0.44242007f, 0.07573758f, -0.40844250f, 0.19724952f, 0.21215552f, 0.28013512f, 
    0.05685460f, 0.02603830f, -0.07342386f, 0.17871979f, 0.21516050f, 0.25882745f, -0.11452751f, 0.22800802f, 
    -0.33405262f, 0.28147462f, -0.14845891f, 0.31407902f, -0.10887650f, -0.19888969f, -0.18057421f, 0.00643628f, 
    0.16078196f, 0.07107463f, -0.17852196f, -0.04512553f, -0.12514205f, -0.13768685f, 0.24576798f, 0.45932525f, 
    -0.10335284f, 0.29103750f, -0.34085426f, -0.02085000f, -0.03298788f, -0.06138364f, 0.27900299f, -0.06290197f, 
    -0.08322144f, 0.01020938f, 0.14489579f, 0.14058374f, 0.17640182f, 0.18833899f, -0.15125206f, 0.02827975f, 
    0.32038012f, -0.22342251f, 0.03750773f, -0.46152869f, -0.24959742f, -0.11414360f, 0.27458742f, 0.20136008f, 
    0.03268688f, -0.05222858f, -0.14275421f, -0.03896663f, 0.16886696f, -0.12228844f, -0.18740886f, -0.01506877f, 
    -0.47915888f, 0.35734087f, 0.03473330f, 0.17506278f, 0.00451052f, -0.24103709f, 0.38267279f, 0.27181330f, 
    0.20372982f, -0.07875143f, 0.07150483f, -0.30947047f, 0.08671463f, 0.46641129f, -0.04807920f, -0.17233546f, 
    0.13078763f, -0.17611878f, -0.65068102f, 0.30444118f, -0.02239835f, -0.25238851f, 0.36146903f, 0.14478251f, 
    0.03769708f, -0.18879277f, 0.07640556f, 0.41278452f, -0.19614501f, 0.32152656f, -0.11456302f, -0.01691772f, 
    0.23926999f, 0.12736508f, 0.23411967f, 0.11356386f, -0.20125720f, -0.21048899f, -0.10004792f, 0.41372746f, 
    0.06565872f, 0.24984469f, -0.04302061f, -0.31453267f, -0.22732088f, -0.11025815f, 0.13107115f, -0.04920409f, 
    -0.32403946f, 0.41137716f, -0.22241406f, -0.29729414f, 0.09125741f, -0.20920274f, -0.13267234f, 0.08512827f, 
    -0.02961662f, -0.05736210f, -0.23229469f, -0.29654402f, 0.25296846f, 0.40705830f, 0.23735525f, 0.23283203f, 
    -0.41251311f, -0.18794206f, -0.33731866f, -0.01825535f, 0.11069009f, 0.05980384f, 0.01859890f, 0.14066862f, 
    -0.17615108f, 0.08057487f, -0.10396211f, 0.29846400f, 0.06744981f, -0.18713444f, -0.16283454f, 0.05065752f, 
    -0.20510042f, 0.03517862f, -0.05395165f, 0.19233546f, -0.26664549f, 0.34190235f, -0.12450466f, 0.07448587f, 
    -0.06952503f, -0.29749739f, -0.15853497f, 0.00985817f, 0.19073518f, 0.05946797f, -0.19079682f, 0.39740053f, 
    -0.35335842f, 0.17971441f, 0.13851175f, -0.13653386f, -0.00580789f, 0.18542671f, 0.20600626f, 0.17595094f, 
    0.09302688f, 0.17401908f, 0.02123380f, -0.06288846f, 0.33920738f, -0.26726773f, -0.03506619f, 0.18882610f, 
    -0.28935897f, -0.25044429f, 0.20676617f, 0.28324890f, -0.34198728f, 0.28030333f, 0.18509939f, -0.15734023f, 
    0.07712042f, -0.09913815f, 0.21635184f, -0.01952795f, 0.14894496f, -0.37032136f, -0.00921260f, 0.31091252f, 
    0.07635700f, 0.10946660f, 0.40949398f, -0.27314520f, -0.11285759f, 0.35913858f, 0.21753822f, -0.18173952f, 
    0.20471445f, 0.28404829f, -0.19559422f, 0.28866643f, -0.04096739f, 0.13526529f, 0.16147926f, -0.39951265f, 
    0.07503150f, 0.09007074f, -0.18838544f, 0.25356731f, -0.50210685f, -0.01497797f, 0.12469038f, 0.07406547f, 
    -0.02337669f, 0.11251155f, 0.03839120f, 0.22706562f, -0.21923465f, -0.11265858f, 0.16513896f, -0.14227617f, 
    -0.09679117f, 0.17759614f, 0.14213121f, 0.21048321f, -0.37287745f, 0.03785763f, 0.17562330f, 0.37317479f, 
    -0.24070702f, -0.43872106f, 0.21167083f, -0.36084273f, 0.10277952f, 0.40879765f, 0.04574309f, 0.32557163f, 
    -0.15805647f, -0.15916829f, 0.03646123f, 0.32150853f, -0.15985440f, 0.14738597f, 0.27857521f, -0.16019918f, 
    -0.22172996f, 0.26126328f, 0.18711931f, 0.15727581f, 0.39552754f, 0.22679405f, 0.22370049f, 0.30203155f, 
    -0.19704451f, -0.19064891f, -0.12270418f, -0.27728739f, 0.02855408f, -0.11393037f, 0.10045914f, -0.18624313f, 
    -0.16179314f, -0.00029405f, 0.19219187f, -0.09265701f, 0.02631652f, 0.08100472f, 0.18495537f, 0.21751425f, 
    -0.20693897f, 0.00917065f, 0.07200326f, 0.09204607f, 0.18601787f, 0.21579996f, -0.13654804f, -0.08208067f, 
    -0.07218072f, -0.26738623f, -0.16244528f, 0.27469304f, -0.08796138f, 0.09404133f, 0.00810432f, -0.25392595f, 
    -0.12397832f, 0.33247307f, 0.38716778f, 0.27555534f, 0.04123028f, 0.16101636f, -0.14409648f, 0.04688673f, 
    0.10246396f, -0.24080835f, -0.22352067f, -0.06793468f, -0.15117246f, 0.25399753f, -0.09265497f, 0.33725131f, 
    0.38816109f, -0.07222557f, -0.42019725f, 0.25207046f, -0.09250348f, -0.11732560f, 0.16868693f, -0.15402588f, 
    -0.01658016f, 0.09090345f, -0.09404191f, 0.33781490f, -0.37837717f, 0.37704745f, 0.24566634f, 0.01701776f, 
    0.07069653f, -0.07212685f, 0.44200724f, -0.13854696f, 0.32531217f, -0.37070259f, -0.17676458f, 0.36668193f, 
    0.21690181f, 0.08389866f, -0.21695513f, 0.08211634f, -0.14236499f, -0.21125941f, 0.17351435f, -0.05438798f, 
    0.00968931f, -0.25037214f, -0.24985483f, 0.06224179f, 0.03941905f, -0.12597772f, -0.23485504f, -0.08945470f, 
    0.23661217f, 0.05658749f, 0.12497288f, -0.20566350f, -0.44681343f, 0.06504650f, -0.20296247f, 0.60659409f, 
    -0.03074657f, 0.35753378f, -0.47994548f, 0.05212591f, 0.56529450f, -0.28003460f, -0.21592951f, 0.05857484f, 
    -0.08111954f, -0.18381841f, 0.06252262f, 0.03884396f, -0.25168991f, 0.05999601f, -0.02017413f, 0.16036457f, 
    0.14313765f, 0.19954571f, 0.49049309f, -0.41301715f, 0.30771106f, 0.18426324f, 0.29806551f, -0.09338178f, 
    0.00236705f, -0.12549423f, -0.00858291f, 0.28397375f, -0.20406362f, 0.26036233f, -0.11565038f, 0.39500070f, 
    -0.32321751f, 0.34875661f, 0.24238777f, -0.00869626f, 0.37006333f, -0.09566818f, 0.02835993f, -0.12772122f, 
    -0.08254464f, -0.06409472f, 0.08622954f, 0.06577974f, -0.00523895f, -0.26663536f, 0.00942410f, 0.26373887f, 
    0.26191255f, -0.40917575f, 0.21453691f, 0.13175508f, -0.17815058f, 0.29080826f, 0.01654900f, -0.19002061f, 
    0.20397034f, -0.10594638f, -0.15734781f, 0.21243045f, 0.17158593f, -0.10293847f, -0.03584968f, -0.23407942f, 
    0.28519550f, -0.20353664f, -0.04080602f, 0.04500159f, -0.19617063f, 0.30901802f, -0.06889679f, -0.09582661f, 
    0.15945047f, 0.51554847f, -0.22008680f, 0.25579920f, -0.22887307f, 0.03569319f, 0.08883711f, -0.19432484f, 
    -0.10827114f, -0.08879926f, -0.23559970f, -0.13017823f, 0.26497805f, 0.16605704f, 0.18975008f, 0.03431620f, 
    -0.14693496f, 0.30663142f, 0.16588062f, 0.14927742f, -0.39950359f, -0.11839930f, 0.20996109f, 0.16608642f, 
    -0.06202196f, 0.11627664f, 0.30212519f, 0.08752103f, 0.31473792f, 0.26887834f, -0.25203130f, -0.22861652f, 
    -0.15064326f, -0.37356490f, -0.00194265f, -0.19172113f, 0.42144781f, -0.19834411f, 0.11351027f, 0.12274048f, 
    0.14502838f, 0.15999763f, 0.51862729f, -0.05476173f, -0.13083245f, 0.12547159f, 0.22536209f, -0.29900274f, 
    0.09849170f, 0.21472993f, -0.19234705f, 0.52061093f, 0.23379953f, -0.19115186f, 0.16752142f, -0.05446701f, 
    0.29909128f, 0.22689767f, 0.08453865f, -0.17618190f, -0.30406308f, -0.40966666f, -0.20669761f, 0.07800096f, 
    0.08907974f, 0.02544232f, 0.08746079f, 0.17225347f, 0.24002293f, -0.27112076f, -0.14779150f, -0.25015402f, 
    0.17781423f, -0.24639875f, -0.49894288f, -0.57391465f, 0.49172094f, -0.04281927f, 0.17871040f, 0.08966906f, 
    -0.24395317f, -0.26012293f, 0.19673881f, -0.27408725f, 0.17409550f, -0.03055156f, 0.21799362f, -0.33380458f, 
    0.18096647f, 0.03774952f, 0.32499275f, -0.15603769f, -0.01603340f, -0.14055525f, 0.17680804f, 0.12012469f, 
    0.07046650f, 0.33957016f, 0.05974760f, -0.10436414f, 0.22267292f, -0.20096901f, -0.05288942f, 0.20929594f, 
    0.22040027f, -0.54301411f, 0.22112277f, -0.28147343f, 0.18304841f, 0.11823943f, 0.27844673f, -0.33239883f, 
    0.05847623f, 0.13673295f, -0.09966610f, 0.37010282f, -0.24113144f, -0.18250403f, 0.05072908f, 0.12369568f, 
    0.16932136f, -0.10855892f, -0.16130681f, 0.14402187f, -0.55411828f, 0.18381354f, 0.15481533f, 0.17607741f, 
    0.18256857f, -0.25837395f, 0.03378669f, 0.05293077f, 0.36700580f, -0.55030775f, -0.21938020f, 0.52207005f, 
    0.02690173f, 0.06944089f, -0.37970725f, 0.32383743f, -0.20071256f, -0.04563494f, 0.33449730f, -0.21486685f, 
    0.11308571f, 0.32301387f, 0.04380696f, -0.44731727f, -0.21023586f, -0.27844700f, -0.13287592f, 0.40916765f, 
    -0.15353243f, -0.18333395f, -0.36937129f, 0.09104172f, 0.31556576f, -0.01428563f, 0.37374830f, 0.06336687f, 
    0.14705524f, -0.79411227f, -0.09801143f, 0.22542803f, -0.30718002f, -0.06875524f, 0.22820535f, -0.04492457f, 
    0.01269966f, 0.32259354f, -0.14104874f, -0.74495178f, -0.13161461f, 0.10773160f, -0.18648785f, 0.30297104f, 
    0.00101602f, 0.20264243f, -0.16663794f, 0.29289016f, -0.14599527f, 0.21082750f, -0.00623228f, 0.03636728f, 
    0.06005706f, 0.15411572f, -0.23044695f, -0.19374187f, 0.01633261f, -0.28695688f, 0.17264947f, 0.07394284f, 
    0.04047210f, -0.00608371f, 0.17013249f, -0.06480213f, 0.29505980f, -0.11655591f, -0.02308319f, -0.25317222f, 
    0.09553286f, -0.12664808f, -0.21972013f, 0.30851635f, 0.12446060f, -0.07384904f, 0.20599985f, -0.28460422f, 
    0.22318000f, -0.15432343f, -0.15770224f, -0.03526610f, -0.17054650f, -0.07777786f, 0.22609049f, 0.18366808f, 
    -0.15117216f, -0.18226004f, -0.18085086f, -0.10719869f, 0.07861701f, -0.14084223f, 0.02370644f, -0.14926082f, 
    -0.24423084f, -0.17158431f, 0.04369178f, -0.03893171f, -0.22132684f, -0.22929636f, -0.07384714f, -0.08069253f, 
    -0.16139181f, 0.13959947f, 0.09708290f, -0.17891851f, -0.12865248f, 0.12088218f, 0.06321109f, -0.10583289f, 
    0.08892611f, -0.03988147f, 0.20019975f, -0.24487573f, -0.21968728f, -0.01292288f, 0.08180889f, -0.08247995f, 
    0.04528931f, -0.22835734f, 0.05645555f, -0.11436334f, 0.14830142f, -0.15423435f, 0.06661338f, -0.18044144f, 
    -0.07368483f, -0.41958407f, -0.20198092f, 0.06216872f, 0.25617641f, 0.18214522f, -0.01003626f, 0.49133074f, 
    -0.24931449f, 0.24478187f, 0.08867675f, 0.11957447f, 0.22840251f, -0.05191569f, -0.04565962f, -0.27121586f, 
    0.11163556f, -0.25193068f, 0.13264459f, 0.02805629f, 0.37856084f, 0.18996681f, -0.01076677f, -0.04711254f, 
    -0.10638508f, -0.06918950f, -0.19561802f, 0.47388089f, 0.10946812f, 0.08715887f, -0.17511308f, -0.07972191f, 
    0.19128965f, 0.09763878f, -0.17257021f, 0.08002154f, -0.21486935f, 0.00245931f, 0.15510514f, -0.27966863f, 
    0.18634839f, 0.01001178f, 0.22256316f, 0.20832619f, -0.13806407f, -0.06088093f, 0.39568692f, 0.18036631f, 
    -0.07306042f, 0.16131949f, -0.11148632f, 0.14777042f, -0.23174128f, 0.08729044f, -0.14714652f, -0.16083083f, 
    0.13544299f, -0.51682884f, 0.21242329f, 0.07206684f, -0.39245373f, 0.22098699f, 0.19398497f, 0.25512910f, 
    0.17773950f, -0.11192162f, 0.00946030f, 0.01640789f, -0.01168758f, -0.14472999f, -0.22957987f, -0.05577593f, 
    -0.12492971f, 0.12674777f, 0.20053178f, -0.13204373f, -0.23094042f, -0.20813836f, 0.11675204f, -0.19319135f, 
    -0.21469469f, 0.31673673f, 0.10944671f, -0.12146655f, 0.24825701f, -0.30782586f, 0.06542369f, -0.09529293f, 
    -0.30908152f, -0.06304643f, 0.18214913f, 0.22962914f, 0.32833323f, 0.11439181f, -0.08996207f, 0.02448404f, 
    -0.12494619f, -0.15683742f, -0.14557952f, -0.30121747f, 0.34609383f, -0.30777639f, -0.04964853f, 0.39753279f, 
    0.07532293f, 0.05339060f, 0.21710090f, -0.16455355f, -0.27632838f, 0.37985647f, -0.06316463f, -0.33572879f, 
    -0.20631039f, 0.07745661f, 0.13262047f, 0.39567536f, -0.36811423f, -0.20400877f, 0.24691612f, -0.00320492f, 
    0.04776496f, -0.07398794f, -0.20160845f, -0.32549644f, -0.21550241f, 0.27619946f, 0.22748110f, 0.02687505f, 
    0.20397066f, 0.16180222f, 0.16440201f, 0.09573966f, -0.07754989f, 0.00406214f, -0.18032557f, -0.40490049f, 
    -0.10383060f, 0.03958978f, -0.06391458f, -0.03309253f, -0.04677512f, 0.25621697f, 0.05063418f, 0.22717710f, 
    -0.21863437f, 0.17741062f, -0.06702377f, -0.16872145f, 0.11707533f, -0.22784275f, 0.16542201f, -0.09704985f, 
    0.17695946f, 0.27705649f, -0.27209938f, -0.29771748f, -0.07760172f, 0.27399102f, 0.30821946f, -0.30743670f, 
    -0.14030501f, -0.11264331f, 0.21121840f, -0.18849680f, 0.38995928f, 0.20594977f, -0.00989627f, -0.25290492f, 
    -0.36606342f, 0.23417959f, -0.33369565f, -0.30705965f, -0.04956984f, 0.03991957f, 0.42311364f, 0.13864011f, 
    0.06908593f, -0.21818656f, 0.03269467f, 0.04622838f, -0.04718416f, 0.40965122f, -0.13028872f, -0.16139631f, 
    0.26287681f, -0.31963572f, -0.40185118f, 0.48695624f, 0.25388667f, 0.05054019f, -0.39946181f, -0.34607980f, 
    -0.06412929f, 0.41783398f, -0.17079777f, -0.16685191f, -0.00026450f, 0.24537641f, -0.04369235f, 0.13668633f, 
    0.05002251f, 0.04528486f, 0.47039109f, -0.53941250f, -0.31141239f, -0.42986691f, -0.24472955f, -0.13203505f, 
    0.20275395f, 0.03242043f, -0.05469398f, -0.18589164f, 0.25738999f, -0.33231893f, 0.25577250f, 0.12893321f, 
    -0.24049641f, 0.12058776f, 0.30275172f, -0.27040038f, 0.57229394f, 0.15471865f, 0.26158017f, -0.12340563f, 
    0.17391270f, -0.12474925f, 0.17378017f, -0.08465658f, 0.35790986f, -0.22384852f, 0.14043763f, 0.07326067f, 
    0.11508052f, -0.36297905f, 0.17732361f, -0.20979868f, 0.45858020f, 0.05665333f, 0.23486468f, -0.04975063f, 
    -0.02206293f, -0.04968806f, 0.19536051f, -0.00975065f, 0.32028136f, 0.23306090f, 0.15425953f, 0.01553395f, 
    -0.15487230f, -0.05688376f, -0.23123956f, 0.06824700f, 0.43085572f, 0.14911243f, 0.04125511f, -0.15067214f, 
    0.23908520f, 0.18223989f, -0.15744770f, -0.11248300f, -0.07619380f, -0.20888169f, 0.10288674f, -0.25293121f, 
    -0.19434182f, -0.26282945f, 0.10264426f, 0.03421631f, -0.12734984f, -0.04526339f, -0.19127177f, 0.17657891f, 
    0.10106528f, 0.13800754f, 0.00767113f, 0.17798965f, 0.19335510f, 0.02183894f, -0.12564820f, -0.15558904f, 
    -0.27206126f, 0.31898183f, -0.28125578f, 0.19874157f, 0.16652779f, 0.03063366f, 0.23538451f, -0.17204270f, 
    -0.24710941f, 0.54300565f, 0.02235860f, 0.06518044f, 0.51448226f, 0.23490487f, -0.25278980f, 0.07240835f, 
    -0.03699438f, 0.06747159f, 0.03592198f, -0.18336456f, -0.19909947f, -0.29909739f, -0.36438227f, -0.03067502f, 
    -0.13260375f, 0.58790493f, -0.11295474f, 0.05719999f, -0.13439335f, 0.27716607f, -0.08494537f, -0.38459924f, 
    -0.10331698f, -0.28852808f, 0.32165796f, -0.13372490f, 0.06806072f, -0.28760114f, -0.29696506f, 0.15386081f, 
    0.18568045f, 0.07976660f, -0.22665557f, 0.09212745f, 0.25878742f, 0.24123442f, 0.07429114f, -0.24093889f, 
    0.16280216f, 0.04049205f, 0.01586816f, -0.33525702f, -0.25695372f, -0.12923437f, -0.06773821f, 0.29379055f, 
    -0.12657511f, -0.30920780f, 0.16049415f, 0.18671834f, -0.06960005f, -0.01514493f, 0.17579404f, -0.08597631f, 
    0.15614922f, 0.28152543f, 0.14660321f, 0.22296228f, -0.27423343f, -0.00664098f, -0.12163891f, 0.33478650f, 
    -0.10122426f, -0.11987057f, 0.04539239f, 0.24465233f, -0.03562998f, -0.15236458f, -0.16818073f, 0.20722862f, 
    -0.28893420f, 0.32402647f, 0.11150674f, 0.19687606f, -0.25170740f, 0.20985144f, 0.05046187f, 0.02868525f, 
    0.12483048f, -0.00276236f, -0.24289146f, 0.08807517f, 0.15043756f, 0.07786753f, -0.08255539f, 0.40430576f, 
    -0.17492971f, -0.36377683f, 0.09524254f, 0.27266300f, -0.09118475f, 0.15792820f, 0.07262622f, -0.09207530f, 
    -0.20041315f, 0.24663131f, -0.06353340f, -0.19430894f, -0.27352732f, -0.29077142f, -0.19363531f, 0.10212025f, 
    -0.05181712f, 0.04858910f, -0.09368548f, 0.05611881f, 0.24831022f, 0.25201756f, 0.00664485f, -0.02237548f, 
    -0.14469218f, 0.28387153f, 0.08497618f, 0.29031861f, -0.15484737f, 0.16336665f, 0.18654430f, -0.20413405f, 
    0.12871777f, -0.41521186f, -0.20063160f, 0.31772137f, -0.33422008f, -0.08948189f, 0.10075571f, 0.10347031f, 
    -0.15720421f, -0.13244173f, -0.24544093f, -0.14318654f, -0.25039214f, -0.23367999f, -0.02873075f, -0.01771212f, 
    0.09395128f, 0.09275875f, -0.26144025f, 0.04444335f, -0.10351320f, -0.24939492f, 0.06345347f, -0.20285638f, 
    -0.24150470f, 0.25057894f, -0.17741281f, 0.10506631f, -0.04430667f, 0.31395754f, 0.08049446f, 0.25067496f, 
    0.03488068f, -0.15937555f, -0.33037236f, -0.31589454f, -0.00387562f, -0.17420492f, 0.25901270f, -0.02159745f, 
    -0.06351492f, -0.10393108f, -0.16807646f, -0.56232560f, 0.14662053f, 0.39260226f, 0.18882610f, 0.02812558f, 
    0.36414039f, -0.18888770f, -0.27171731f, -0.05789311f, 0.11556602f, 0.01164098f, 0.01775323f, -0.03335141f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.20321426f, -0.14258593f, 0.04905415f, 0.13884476f, 0.01435615f, 0.19738591f, -0.28146133f, 0.38722262f, 
    0.36723015f, -0.10392869f, 0.12197972f, 0.12199732f, 0.01976528f, -0.31748655f, 0.21362476f, -0.12266181f, 
    0.45937651f, 0.27389467f, -0.20477131f, 0.05246756f, 0.04569707f, -0.10557677f, -0.14248608f, -0.06701975f, 
    -0.27042338f, 0.47652090f, -0.20011568f, 0.39904395f, 0.29442212f, -0.35072705f, -0.20406961f, 0.06480224f, 
    0.26007193f, 0.06432451f, 0.25901499f, -0.15262972f, 0.03573770f, -0.00806545f, 0.22322235f, 0.33848897f, 
    0.16655926f, -0.22060931f, -0.14095068f, -0.29856890f, -0.10225810f, 0.27996945f, -0.08964168f, -0.16583171f, 
    -0.12001905f, 0.23114863f, 0.37917405f, -0.09127625f, 0.10855383f, 0.11928734f, -0.09365965f, 0.17623959f, 
    -0.20072177f, -0.09226237f, 0.45020652f, 0.09999578f, 0.06346280f, -0.21864045f, -0.34997100f, 0.26071307f, 
    0.41530260f, 0.36589158f, -0.33760586f, -0.07406143f, -0.10503221f, 0.38643166f, 0.03427484f, 0.05711692f, 
    0.11335848f, 0.37369925f, -0.20062880f, 0.01702266f, -0.50686294f, 0.20466456f, 0.08846548f, 0.05400014f, 
    0.24385279f, 0.11965308f, 0.31030533f, 0.03198625f, 0.35963526f, 0.28105447f, -0.27577454f, 0.09454138f, 
    0.04195577f, 0.38882905f, 0.19731343f, 0.10911109f, 0.17410557f, -0.13660346f, -0.03087921f, 0.45978943f, 
    0.07206255f, -0.26771268f, -0.06333503f, -0.26356861f, 0.02429753f, 0.16930249f, 0.22375847f, -0.09172026f, 
    0.20654692f, 0.35235330f, 0.20292923f, 0.19229396f, 0.47965473f, 0.27552763f, -0.00108776f, -0.22245778f, 
    0.09735782f, 0.35364470f, 0.04542133f, -0.19257085f, 0.44373301f, -0.08977729f, 0.39794379f, 0.10994423f, 
    -0.06129202f, 0.29924569f, -0.19712889f, 0.47290921f, 0.31061718f, -0.11790048f, 0.28733605f, -0.15308160f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.12005654f, 0.09632693f, -0.19587252f, 0.01011201f, -0.21649548f, 0.12197181f, 0.00331927f, 0.12698784f, 
    0.39963537f, 0.22679760f, 0.05146742f, -0.19028489f, -0.72415721f, 0.11140428f, -0.31140846f, 0.42656624f, 
    0.20758294f, -0.68427294f, -0.04853826f, -0.23579134f, 0.13678923f, -0.48869181f, 0.05261585f, 0.14526489f, 
    -0.06684613f, 0.17725503f, 0.25175604f, 0.00329156f, -0.40886420f, 0.11446804f, 0.05783814f, 0.04379110f, 
    -0.06822733f, -0.29392529f, 0.12962946f, 0.16564362f, 0.06886642f, -0.01399157f, -0.34699726f, 0.38289276f, 
    0.27801931f, 0.13064709f, -0.05008057f, -0.41847271f, 0.06412736f, -0.17649160f, 0.04786516f, 0.11472499f, 
    -0.02982669f, -0.07105836f, -0.15340716f, 0.19236423f, -0.53020364f, -0.03693980f, 0.28069615f, -0.06179788f, 
    -0.08340948f, 0.13792534f, 0.06427973f, -0.69645327f, 0.13896717f, 0.14707713f, -0.20893745f, 0.09375150f, 
    0.33613768f, 0.09739878f, 0.05261829f, 0.16632035f, -0.12134954f, -0.15575837f, -0.01193284f, 0.36135674f, 
    -0.22573619f, 0.10565145f, 0.10044382f, 0.27934617f, -0.09748580f, 0.02552189f, 0.25883248f, -0.03852750f, 
    0.11694162f, 0.11030264f, -0.01240982f, -0.34004414f, 0.06946625f, -0.14494278f, -0.80128133f, -0.77488035f, 
    0.07921255f, -0.17425059f, 0.24643685f, 0.29859677f, 0.35203442f, -0.05470964f, -0.28409773f, 0.01913124f, 
    -0.02033867f, -0.04740223f, -0.06778593f, 0.19707879f, 0.24066733f, -0.17627628f, -0.29460955f, 0.01671498f, 
    0.11663246f, 0.18954431f, -0.31669867f, -0.10167924f, -0.25296026f, -0.17610222f, 0.31635505f, 0.04549563f, 
    -0.00307436f, -0.27091077f, -0.04097711f, -0.04678517f, -0.05805165f, -0.37807298f, -0.78338879f, -0.75333172f, 
    0.05043298f, 0.19410208f, 0.29164851f, 0.11760122f, -0.01988202f, -0.02232062f, -0.39635214f, 0.29187703f, 
    -0.01862696f, -0.01966699f, -0.05252096f, -0.07622136f, -0.03345253f, 0.06865548f, 0.05148130f, 0.05584950f, 
    0.03918219f, -0.02087124f, -0.00499090f, -0.06877857f, 0.00671366f, -0.10200938f, 0.03224246f, 0.07623111f, 
    -0.05746284f, 0.04386365f, 0.07347333f, -0.00771493f, -0.12383164f, -0.05510034f, -0.05424408f, -0.00573334f, 
    -0.05879397f, -0.04862341f, 0.04154818f, 0.03867756f, -0.08581626f, -0.04542977f, -0.09177242f, -0.04836841f, 
    0.02849690f, -0.05771172f, -0.01084199f, -0.10230005f, 0.00808295f, 0.03827961f, -0.01761091f, 0.05786973f, 
    -0.04665737f, -0.01171085f, 0.00096913f, 0.08235110f, -0.04698716f, 0.04085743f, 0.02048508f, 0.00950145f, 
    -0.09687623f, 0.04370635f, 0.01193694f, 0.02993851f, 0.00462091f, -0.07408173f, -0.00330598f, -0.01399510f, 
    0.02833241f, -0.10193764f, 0.00646369f, -0.03489495f, -0.09857958f, -0.08315452f, 0.02620145f, 0.04403462f, 
    -0.05411940f, 0.03175400f, -0.06919820f, -0.04484758f, -0.04151493f, -0.06900100f, -0.00066878f, -0.07498030f, 
    -0.02331734f, 0.01872258f, -0.01035507f, -0.04303467f, 0.07808516f, -0.06484253f, -0.03873749f, -0.01603152f, 
    -0.05547689f, 0.04914836f, -0.00294203f, -0.00248634f, 0.02739516f, -0.00253531f, -0.10076660f, 0.07826622f, 
    0.03541392f, -0.04196330f, -0.07969218f, -0.05387973f, 0.14118385f, -0.02510366f, 0.00694423f, -0.00687595f, 
    -0.04750825f, -0.02857902f, 0.00285965f, -0.02235299f, -0.09539252f, -0.03731716f, 0.03064930f, 0.01567835f, 
    0.01928659f, -0.10739627f, 0.03588980f, 0.01180265f, -0.06639200f, -0.05689470f, 0.07931230f, 0.00493291f, 
    -0.11468504f, 0.00654720f, -0.09399668f, -0.08974914f, 0.02274363f, 0.01649047f, -0.01991311f, -0.05432153f, 
    0.04383607f, -0.07368451f, -0.07677119f, 0.04338246f, -0.03038841f, 0.03782708f, 0.03956325f, 0.00659272f, 
    0.19391192f, 0.04542685f, 0.00083319f, -0.07661220f, -0.20620884f, -0.04305007f, -0.03070896f, 0.02517182f, 
    -0.05984954f, -0.20609106f, -0.43804327f, 0.05071751f, -0.08715963f, -0.10648473f, -0.20263162f, -0.15016109f, 
    0.15693136f, -0.09410539f, -0.00051431f, 0.16842373f, -0.05559535f, 0.13269976f, -0.06504218f, 0.22844338f, 
    0.18332259f, -0.04704607f, 0.13904752f, 0.11831429f, 0.11600512f, 0.15888759f, 0.04398558f, 0.06989074f, 
    -0.09351721f, 0.17915893f, -0.09261315f, -0.10962540f, -0.38620481f, -0.06707097f, -0.07496893f, -0.20213595f, 
    0.00981805f, -0.05663659f, 0.20115750f, -0.14747253f, 0.11758696f, 0.14132580f, 0.32085624f, 0.02777638f, 
    0.03853065f, 0.02596157f, -0.05226212f, -0.24213840f, 0.19672456f, -0.05688551f, -0.25320685f, 0.13283487f, 
    -0.05989609f, 0.08077772f, 0.02707577f, 0.12759696f, -0.40408176f, 0.12458336f, 0.17367633f, -0.46253189f, 
    -0.12246390f, 0.06713952f, -0.18916495f, 0.23301384f, -0.09232502f, 0.06568659f, -0.05065731f, -0.50702429f, 
    0.11784781f, 0.12840325f, -0.11366027f, -0.06745894f, 0.22351789f, -0.01373543f, 0.08880882f, -0.30131105f, 
    -0.19948600f, 0.03236929f, 0.06468302f, 0.15103637f, 0.08626641f, -0.18921041f, 0.23210308f, -0.10946133f, 
    -0.15803568f, 0.10363371f, -0.05201365f, 0.05408983f, 0.19159882f, 0.05680924f, 0.06207717f, 0.04283027f, 
    0.08194027f, -0.05979019f, 0.00497999f, -0.19617639f, -0.02517464f, -0.05946207f, -0.02257955f, -0.04895952f, 
    0.19247386f, -0.00360640f, -0.01361118f, 0.02553077f, 0.07620353f, 0.17569979f, 0.20010920f, -0.66905254f, 
    -0.24600804f, -0.01603490f, 0.14659815f, 0.01677044f, -0.00333732f, 0.28250659f, 0.21544613f, 0.22491962f, 
    0.03676889f, -0.05249566f, 0.04712355f, -0.03663893f, 0.15720627f, -0.11284901f, 0.01801457f, 0.25825846f, 
    -0.28111711f, 0.00241873f, -0.39980939f, 0.07402912f, 0.07371400f, -0.18143652f, -0.20582265f, -0.02041481f, 
    0.15129477f, 0.15119386f, -0.23836289f, 0.10247120f, 0.19211200f, 0.19067465f, 0.12525713f, 0.13887587f, 
    -0.19938539f, 0.02052318f, 0.04808241f, -0.11367942f, 0.01317497f, 0.01467371f, -0.16778727f, -0.21625826f, 
    0.03756771f, 0.07555793f, -0.39394063f, 0.01102753f, -0.41281965f, -0.26128435f, -0.21662346f, -0.04814126f, 
    0.07691830f, -0.49406552f, 0.10428059f, 0.20958887f, 0.70481366f, -0.06100786f, 0.05853420f, 0.35394335f, 
    0.13691878f, 0.13144211f, 0.36160126f, 0.40914986f, 0.12738608f, 0.03272343f, -0.02795136f, 0.16585246f, 
    0.11664452f, 0.04686408f, -0.27233273f, 0.14240363f, 0.13367699f, -0.05792635f, 0.28442994f, 0.27939507f, 
    0.29825151f, -0.19673640f, -0.17398161f, 0.15868127f, 0.07934724f, 0.20406502f, 0.26693848f, 0.01113137f, 
    -0.26834428f, -0.01490570f, 0.13208419f, -0.08599339f, 0.22301885f, 0.17783889f, 0.21281375f, 0.36572686f, 
    -0.33851010f, 0.02233454f, 0.31036070f, 0.20094064f, -0.17303577f, 0.10727955f, -0.43788618f, 0.10068870f, 
    -0.01496581f, 0.45745316f, 0.14129324f, -0.09880138f, -0.04396470f, 0.20324320f, -0.13428791f, 0.34577525f, 
    0.32292122f, -0.06381665f, 0.10269867f, 0.09800237f, -0.33389166f, 0.27306131f, -0.42002714f, 0.16646990f, 
    -0.08321285f, 0.02567257f, -0.08750935f, 0.00283251f, 0.03686345f, 0.31840649f, 0.26572779f, -0.00507906f, 
    -0.14571035f, -0.11832289f, -0.20258750f, -0.03327987f, -0.22756965f, -0.37762204f, 0.35958058f, -0.23315875f, 
    -0.23260564f, 0.10132654f, -0.21110351f, 0.01462197f, -0.20723931f, -0.34973654f, 0.14189357f, 0.00754299f, 
    0.40460637f, 0.14176835f, 0.11199751f, 0.04992663f, 0.28631410f, 0.05540507f, -0.04051355f, 0.02542803f, 
    -0.07743050f, -0.11049042f, 0.05366657f, 0.02175430f, 0.05175532f, -0.10309678f, -0.08647437f, -0.02060385f, 
    -0.13023756f, 0.01314693f, -0.04524799f, -0.07333513f, -0.00445970f, -0.06110489f, -0.01869493f, -0.04701028f, 
    -0.05766758f, 0.04841859f, 0.01851984f, -0.07828188f, 0.04936041f, 0.03550945f, 0.02436796f, 0.07551897f, 
    -0.02078676f, -0.05656735f, 0.02504781f, -0.00424320f, -0.10878175f, 0.06482614f, 0.04962879f, 0.04206815f, 
    -0.04899897f, -0.01639207f, 0.06115166f, -0.04347319f, -0.10010141f, 0.00183710f, -0.05465028f, -0.00540059f, 
    0.02999489f, -0.05748105f, -0.09558369f, 0.07052234f, -0.03356333f, 0.03617238f, -0.01713702f, -0.07321908f, 
    -0.03138174f, -0.06948344f, -0.00507827f, -0.04040830f, 0.00401219f, -0.04783160f, 0.00075144f, -0.05169936f, 
    0.03038415f, -0.12381388f, -0.08263277f, 0.06075322f, -0.09482414f, -0.08898392f, 0.04650875f, -0.04965403f, 
    -0.00291054f, -0.04553100f, -0.07653731f, -0.07820296f, -0.08104646f, -0.06462699f, -0.09075777f, -0.02693827f, 
    -0.07571077f, -0.00389527f, -0.09249916f, -0.08349550f, -0.06333903f, 0.01156052f, -0.03620231f, -0.06028649f, 
    -0.10940040f, -0.09283649f, -0.07317563f, -0.04524868f, 0.01767542f, -0.06932104f, 0.00874447f, -0.13446577f, 
    -0.06283083f, 0.07733954f, -0.01957021f, -0.03767155f, -0.02204233f, 0.00526827f, -0.02030139f, -0.08406053f, 
    0.05964592f, -0.07408196f, -0.04660041f, -0.00241572f, -0.02020241f, -0.02870443f, -0.09846882f, -0.05341743f, 
    -0.05400843f, 0.08640988f, 0.00377356f, -0.08566780f, -0.06153607f, -0.04774543f, -0.05667995f, -0.02587619f, 
    -0.06260425f, -0.02669670f, -0.08788109f, 0.05131524f, 0.01294419f, -0.02754663f, -0.04992934f, -0.00083364f, 
    -0.01476872f, -0.05677527f, -0.07972724f, -0.02190225f, -0.07299404f, -0.03445350f, -0.08544328f, 0.06228728f, 
    -0.01674661f, 0.00676399f, -0.00723779f, -0.06839410f, 0.01079047f, -0.02290876f, -0.02343580f, 0.03943202f, 
    -0.01575991f, -0.07692544f, -0.00375000f, 0.07137691f, -0.02905329f, 0.01980012f, -0.04566881f, -0.05961637f, 
    -0.05689871f, 0.05201824f, 0.08111908f, -0.08833770f, 0.04201734f, -0.07208121f, -0.09424265f, -0.05504222f, 
    0.07598937f, 0.02260623f, 0.04436956f, 0.00221202f, -0.04893094f, 0.04685147f, -0.03982152f, -0.02958442f, 
    -0.00370666f, 0.02657795f, -0.00711430f, -0.00146711f, -0.06093701f, 0.08755180f, -0.07526171f, -0.07897071f, 
    -0.08125146f, -0.02280928f, -0.09397010f, 0.03347207f, 0.01460247f, -0.01311779f, -0.07947636f, -0.01362401f, 
    0.07706888f, -0.06392033f, 0.00771297f, 0.02668301f, 0.03081586f, 0.08471013f, -0.03972484f, -0.00599012f, 
    -0.07946078f, -0.00672290f, 0.06633025f, -0.02393849f, 0.04394536f, -0.05290113f, -0.07216652f, -0.03817421f, 
    -0.07065305f, 0.03544220f, -0.00282985f, -0.06854811f, 0.06537667f, -0.02427632f, -0.06897003f, -0.04757245f, 
    0.00612721f, -0.03184555f, 0.03229118f, -0.05166546f, -0.06412552f, -0.01541405f, 0.01880509f, -0.03008247f, 
    0.07006311f, -0.00863265f, 0.03358847f, -0.09750806f, 0.02743623f, -0.09436352f, 0.01262125f, 0.03273852f, 
    -0.00757512f, -0.06145531f, -0.05251453f, -0.02076312f, -0.00104879f, -0.01521317f, -0.01392941f, 0.01807187f, 
    0.01340875f, -0.07503661f, -0.01153625f, 0.03853986f, -0.03385492f, 0.06958598f, -0.04535997f, 0.07876879f, 
    0.04952363f, 0.01383368f, 0.06089107f, 0.06912752f, -0.00782063f, 0.07197341f, 0.00410764f, 0.02699584f, 
    -0.06737913f, 0.02109000f, -0.08744232f, 0.02058911f, 0.06866146f, -0.07123686f, -0.06053252f, 0.04317592f, 
    0.03965084f, 0.05416078f, 0.05378484f, 0.05827155f, 0.02230085f, -0.02468318f, -0.04844839f, -0.01371838f, 
    -0.14270516f, 0.15110368f, -0.09241134f, -0.02134560f, -0.08887713f, 0.16167191f, 0.00043760f, -0.13035604f, 
    0.02617363f, 0.04321782f, -0.28712666f, -0.08182807f, 0.17117040f, -0.10253825f, -0.07425290f, 0.22933601f, 
    -0.08361465f, -0.25055778f, -0.05614799f, -0.08266646f, 0.17386451f, 0.01486556f, -0.08055711f, -0.37954488f, 
    -0.15448847f, -0.03827852f, -0.10374589f, -0.05488119f, 0.07485900f, -0.17629825f, -0.02815567f, 0.03717428f, 
    0.09300190f, -0.30348387f, -0.08130967f, 0.23352286f, 0.16926406f, 0.00366163f, 0.02922220f, 0.00970434f, 
    -0.17192596f, -0.02889633f, 0.25981331f, -0.17420416f, -0.08527599f, 0.11775956f, 0.05414468f, -0.02732787f, 
    0.10935249f, 0.16653582f, 0.09880762f, 0.20848551f, 0.10492194f, 0.03409706f, 0.00366662f, 0.20062988f, 
    0.28816622f, -0.05238554f, 0.04955036f, 0.03724002f, 0.36908805f, -0.13349706f, 0.12834112f, -0.34614238f, 
    -0.01185679f, 0.19784755f, -0.01099865f, 0.07239607f, 0.11240339f, 0.28413156f, 0.35339493f, 0.16358118f, 
    -0.33776340f, -0.03212388f, 0.17759788f, -0.05113073f, -0.44970426f, -0.06418025f, -0.03414801f, -0.12549764f, 
    -0.01495158f, 0.02391464f, 0.17166863f, -0.16780385f, -0.01285843f, 0.15823174f, -0.06226987f, 0.15199713f, 
    0.01906999f, -0.18620189f, 0.16373587f, 0.10560556f, -0.24183129f, -0.49466637f, -0.04685291f, 0.14217201f, 
    0.04920041f, 0.01989336f, 0.04731507f, -0.13171327f, 0.11913799f, 0.20538495f, 0.06745799f, -0.09416734f, 
    -0.01236939f, -0.00912578f, -0.06641480f, 0.12361447f, -0.02871493f, 0.17712924f, 0.15653275f, -0.22960614f, 
    -0.12123833f, -0.03449111f, -0.13171157f, 0.03145303f, -0.03143209f, -0.02139572f, -0.17953655f, -0.01343052f, 
    0.28739074f, 0.19351181f, -0.04585894f, -0.04215571f, -0.05061579f, 0.04924655f, -0.12406861f, -0.22569585f, 
    0.23409697f, 0.00281866f, 0.41614980f, 0.06457659f, 0.29979122f, -0.02606345f, 0.07083777f, 0.06579192f, 
    -0.02300511f, -0.09762459f, 0.20283870f, -0.07227098f, 0.08665282f, 0.09077850f, 0.29585421f, 0.27061436f, 
    0.04232481f, 0.13175929f, 0.00847249f, 0.07985294f, -0.03785627f, -0.16104613f, 0.10780528f, -0.27840558f, 
    -0.20606372f, 0.03389858f, -0.34498352f, -0.06476817f, 0.12673615f, -0.12651139f, -0.14832331f, 0.01229576f, 
    0.03952790f, 0.44363320f, -0.12092972f, -0.08079681f, -0.22855034f, 0.02169888f, 0.05313903f, -0.14699693f, 
    -0.25674868f, 0.08448925f, 0.05444018f, 0.29609120f, -0.05785015f, -0.00714054f, -0.05820104f, -0.07771877f, 
    -0.05963306f, -0.12703568f, 0.15980931f, -0.04174358f, -0.06128309f, -0.05197993f, -0.27230597f, -0.08108386f, 
    -0.09413632f, -0.14409348f, 0.07372448f, -0.02156620f, 0.20127392f, -0.12792057f, -0.04028012f, 0.16330321f, 
    0.29408669f, -0.00887576f, 0.11473875f, 0.11686159f, 0.10047785f, -0.26455283f, -0.01111159f, -0.03215278f, 
    0.26086697f, -0.01632692f, -0.05255024f, -0.21379817f, 0.02630773f, -0.06817565f, -0.16663852f, 0.30306700f, 
    0.12576179f, 0.12040170f, -0.06477922f, -0.10857993f, -0.04381126f, 0.25971651f, -0.25032127f, 0.40248629f, 
    0.08911492f, 0.16055007f, -0.05179121f, 0.37136087f, -0.10315572f, 0.55313647f, -0.13354830f, 0.08035999f, 
    -0.02503507f, -0.05538195f, 0.08448770f, 0.19202565f, -0.04223884f, -0.04658681f, -0.01235326f, 0.02931497f, 
    0.13782175f, 0.05372707f, 0.05460724f, 0.01855981f, 0.10229351f, 0.17993581f, -0.32797539f, -0.05353582f, 
    0.32681748f, 0.56378466f, 0.07745323f, 0.05994684f, -0.01976712f, -0.07111043f, 0.01538400f, -0.06763209f, 
    -0.07129930f, 0.16128813f, -0.04306400f, 0.06233428f, -0.14333095f, -0.06597972f, -0.04063848f, -0.23815604f, 
    0.38745031f, 0.21270983f, 0.52384889f, 0.00758303f, 0.55642688f, 0.09822171f, -0.05811920f, 0.15429676f, 
    0.00853021f, 0.06985811f, 0.07005261f, 0.09541693f, -0.04710893f, 0.13053496f, 0.16699621f, 0.01220646f, 
    0.19078231f, 0.13667218f, -0.02056674f, 0.19453056f, 0.16985397f, -0.11201971f, -0.02136490f, -0.27460831f, 
    -0.15984075f, 0.05965962f, -0.02044152f, -0.02466021f, -0.08449847f, 0.18925065f, 0.02759721f, -0.06099219f, 
    0.10733376f, 0.41261560f, 0.08945522f, 0.15287174f, -0.06519400f, -0.02614111f, 0.04384957f, 0.20067148f, 
    0.05435249f, -0.13896605f, -0.40763533f, 0.02866434f, -0.02118807f, 0.06001578f, -0.22440495f, -0.37574434f, 
    0.31959385f, -0.40326825f, 0.11888097f, 0.17390318f, -0.25339413f, -0.05727494f, 0.09109301f, -0.09149276f, 
    -0.19509268f, 0.09246249f, 0.32464570f, -0.00655223f, 0.04128071f, -0.20487420f, -0.56485099f, 0.25220850f, 
    0.23408312f, 0.08757893f, 0.06599133f, 0.20187122f, 0.33075926f, -0.28684086f, -0.20446256f, 0.20470153f, 
    0.24971239f, 0.21121609f, -0.18358767f, -0.00112388f, -0.34382769f, -0.04789022f, -0.13071045f, 0.16143107f, 
    -0.06571174f, 0.04804556f, 0.07213226f, -0.13097104f, 0.04289442f, 0.46566802f, -0.15955360f, -0.28214425f, 
    0.13801040f, 0.27827170f, -0.17142801f, 0.17161478f, 0.22413251f, 0.21908891f, -0.22463037f, 0.22301362f, 
    0.05316189f, -0.01351781f, -0.03146893f, 0.00276416f, 0.20073104f, -0.23517238f, -0.00771816f, 0.09295511f, 
    0.25277570f, 0.48032326f, 0.10757080f, 0.02785283f, 0.33087912f, 0.20693439f, 0.14496557f, -0.05614112f, 
    0.26622108f, 0.29237789f, 0.12039956f, -0.00984612f, 0.10812344f, 0.00705001f, -0.34560040f, -0.02947610f, 
    -0.23265791f, 0.08937992f, 0.00394512f, 0.11685879f, -0.21658443f, -0.01671746f, -0.14963377f, 0.25213754f, 
    0.09842601f, -0.29434836f, 0.06835503f, 0.06112655f, 0.71455431f, 0.10795416f, -0.25147027f, 0.19863033f, 
    0.02608793f, -0.06139190f, 0.03646619f, 0.06087415f, -0.19850792f, -0.19401208f, -0.10128888f, 0.08190561f, 
    0.00397971f, -0.17016812f, 0.00207322f, 0.03845279f, -0.01866299f, -0.05478080f, -0.22513676f, 0.46401858f, 
    0.42668819f, 0.08357883f, 0.12804680f, 0.06929274f, -0.15064497f, 0.16122976f, 0.17444393f, -0.03365196f, 
    -0.02938799f, -0.29162523f, -0.10788960f, -0.06040184f, 0.26679274f, -0.05131227f, -0.07925361f, 0.21954881f, 
    -0.02476718f, 0.13855205f, -0.09356830f, 0.20425040f, 0.06081942f, 0.13113768f, 0.13084310f, 0.11474288f, 
    -0.03551422f, -0.03253437f, -0.29102758f, -0.28263542f, -0.09447780f, -0.07953998f, 0.10013193f, 0.04719311f, 
    0.01002132f, -0.00531635f, 0.22721367f, -0.08419472f, -0.30358565f, -0.25324628f, 0.03533984f, -0.23278452f, 
    0.07954299f, 0.24576569f, -0.02085103f, 0.26416704f, 0.08128030f, 0.01585229f, -0.07448302f, -0.19800597f, 
    0.09405399f, 0.07669443f, 0.08306040f, 0.02743350f, 0.31536341f, 0.02509755f, 0.17058189f, 0.10924783f, 
    0.11560595f, 0.11617605f, -0.06451228f, 0.03162659f, 0.37383035f, 0.01207020f, 0.19630523f, -0.58561838f, 
    -0.14329483f, 0.12405822f, 0.07595554f, 0.26120690f, 0.09405360f, -0.06174171f, 0.03403743f, 0.01419342f, 
    -0.06552684f, 0.03809326f, 0.08497349f, 0.00013577f, -0.15844852f, -0.02488052f, -0.02025907f, -0.07165174f, 
    -0.08122692f, 0.34601340f, -0.01186682f, -0.05066129f, -0.00107477f, -0.37076262f, -0.17697525f, 0.35896382f, 
    0.01768072f, 0.00436319f, 0.05423783f, -0.11385822f, -0.04964443f, 0.11747970f, 0.15957244f, -0.18219389f, 
    -0.08993403f, 0.17697293f, 0.16827758f, 0.15155911f, -0.00801730f, 0.05026584f, -0.00006888f, -0.35993987f, 
    0.01387364f, -0.05114220f, -0.09675471f, 0.03272879f, -0.05871831f, 0.03843840f, -0.11205507f, -0.11533121f, 
    0.04060512f, -0.01507101f, 0.03189805f, -0.04223249f, 0.03196792f, -0.06023253f, 0.03496500f, 0.05055712f, 
    -0.10156302f, 0.04181019f, 0.08094507f, 0.03507953f, 0.01705356f, -0.01208652f, -0.09647997f, -0.03844787f, 
    -0.02488496f, 0.01011930f, 0.06185400f, 0.03471147f, -0.02239056f, 0.01132542f, -0.13037662f, 0.01789358f, 
    -0.01496357f, -0.02751583f, -0.02698779f, -0.08083851f, 0.01409345f, -0.04877212f, -0.09091630f, 0.04642221f, 
    0.00114933f, -0.07570744f, 0.01178689f, -0.01823947f, 0.02454334f, -0.07313330f, -0.10755721f, -0.05275016f, 
    0.00024290f, -0.05052064f, -0.07254764f, -0.10729068f, 0.00573499f, -0.08195290f, 0.02479263f, -0.10204701f, 
    -0.04122644f, 0.01746908f, 0.01115597f, -0.06357047f, 0.02918819f, 0.03006349f, -0.08313707f, 0.07164007f, 
    -0.01552865f, 0.04408697f, -0.04114565f, 0.06682654f, 0.07794810f, -0.09363969f, -0.02209461f, -0.06503072f, 
    -0.06400495f, 0.02723233f, 0.05137185f, -0.03200708f, -0.07954314f, -0.07337192f, 0.03516101f, -0.04008080f, 
    -0.02900516f, 0.00857865f, -0.09337272f, -0.09626401f, -0.03710782f, 0.04129466f, 0.00391918f, -0.00911210f, 
    0.04999463f, -0.04962803f, 0.04764725f, -0.02863616f, -0.04215017f, -0.01501712f, 0.05114794f, 0.02440271f, 
    -0.03797115f, 0.08833879f, 0.02497598f, 0.04468239f, -0.06907103f, 0.02842403f, -0.08310018f, 0.02743643f, 
    -0.02221058f, -0.07130118f, 0.02568458f, 0.02917012f, 0.03066539f, 0.04599941f, -0.05589619f, 0.01452066f, 
    -0.05864817f, -0.11504014f, -0.05213752f, 0.01530370f, -0.11393797f, 0.01381738f, -0.06987082f, 0.04021541f, 
    -0.00255134f, -0.10949877f, 0.06150719f, 0.03258826f, -0.01072218f, 0.06865711f, -0.06772301f, -0.02797955f, 
    0.15576601f, -0.44969577f, 0.04740278f, 0.08739403f, 0.20069134f, -0.00153584f, -0.05026748f, 0.06623922f, 
    0.12528135f, -0.13313326f, 0.39850879f, -0.01818830f, 0.00639134f, -0.26066595f, 0.05493053f, -0.05091676f, 
    0.23752873f, 0.30014583f, -0.02589989f, -0.01047924f, -0.07272045f, 0.13801658f, 0.19649453f, 0.11174593f, 
    0.14508161f, 0.22910418f, -0.33366823f, 0.07554418f, -0.08702185f, -0.02338806f, -0.10189983f, 0.03573524f, 
    -0.09651871f, 0.31530687f, 0.12314382f, -0.20610218f, -0.17385051f, -0.00370284f, -0.05408310f, 0.05966004f, 
    0.16721147f, -0.02843628f, -0.08757176f, 0.06591988f, 0.15290555f, -0.17924702f, -0.13143586f, -0.00942575f, 
    -0.00045219f, -0.07076110f, 0.21896616f, -0.09229671f, -0.05296501f, -0.06627268f, 0.13931794f, -0.02260834f, 
    -0.15312579f, -0.00020239f, -0.08721459f, 0.11397459f, -0.32853657f, 0.08051983f, -0.04821718f, -0.40159318f, 
    0.14189896f, -0.12154153f, -0.15993702f, -0.02687512f, -0.07360441f, -0.01186123f, -0.09809425f, 0.04963229f, 
    0.33402744f, 0.05560321f, -0.15469962f, 0.17815584f, 0.30813974f, -0.04751792f, -0.26611501f, 0.13201796f, 
    0.18904684f, 0.03722944f, 0.04006926f, 0.20371675f, 0.06360149f, 0.00329879f, -0.12816729f, -0.31988341f, 
    -0.18119702f, 0.30852818f, -0.06111487f, 0.16599078f, 0.01276317f, -0.05797345f, 0.17966442f, 0.23659858f, 
    -0.03317132f, 0.08554249f, 0.02363666f, -0.04475042f, -0.01605478f, 0.08675809f, 0.03581720f, -0.03347510f, 
    0.07746553f, 0.16081738f, 0.07937700f, 0.00185021f, 0.10156614f, -0.07303652f, -0.22279344f, 0.22972172f, 
    0.06461812f, 0.29159406f, 0.05618576f, 0.03603013f, 0.04892604f, 0.22718859f, 0.62701464f, 0.04542864f, 
    -0.22429799f, 0.02172237f, 0.00133366f, 0.17794330f, 0.16801201f, 0.06119151f, 0.27379408f, 0.00967567f, 
    0.04086102f, 0.12595324f, 0.03685835f, -0.00187348f, 0.26164603f, 0.06319880f, 0.02373411f, -0.09640118f, 
    0.22265750f, 0.06363563f, 0.35288519f, 0.03131460f, 0.01822914f, -0.26038474f, 0.19389367f, 0.09627745f, 
    0.13520403f, 0.05391706f, -0.00854438f, 0.05696236f, 0.10129268f, 0.00982820f, 0.21384524f, 0.07943808f, 
    -0.00222653f, -0.15178239f, -0.65977108f, 0.17173488f, 0.00927732f, -0.50495714f, 0.22417320f, 0.04700332f, 
    0.13752139f, 0.26570284f, 0.00267144f, -0.09979153f, -0.17368148f, 0.05032032f, -0.00086917f, -0.36504638f, 
    -0.11234800f, 0.27456531f, -0.21898182f, 0.39066777f, -0.09912463f, -0.01254208f, 0.06615379f, 0.04481932f, 
    -0.11212280f, -0.01903554f, -0.13809897f, -0.01376323f, -0.41081068f, -0.06197421f, -0.38644207f, -0.08446267f, 
    0.16592719f, 0.06646679f, 0.17219651f, 0.00042897f, 0.12322007f, -0.28066704f, -0.27522188f, -0.04453547f, 
    -0.10588047f, -0.08931276f, 0.17930031f, -0.02731919f, 0.07946321f, -0.22955766f, -0.10143412f, -0.05627947f, 
    0.34775034f, 0.13740066f, 0.08528733f, -0.13907631f, 0.07811565f, 0.07473174f, -0.07823124f, 0.33083665f, 
    0.28282735f, -0.31198466f, -0.19792461f, 0.17437255f, 0.10681870f, 0.13620256f, -0.05888260f, 0.36459559f, 
    -0.19246405f, 0.14231449f, -0.35770059f, 0.16095281f, 0.33626819f, 0.41517708f, -0.05785703f, -0.05350062f, 
    -0.00256118f, -0.03832196f, 0.06719504f, 0.24080518f, -0.12880978f, -0.05052228f, -0.39682060f, 0.01507892f, 
    0.18901023f, -0.20890182f, 0.01648758f, 0.06230742f, 0.17305684f, 0.24985853f, -0.65144867f, 0.61638457f, 
    0.28752822f, 0.15973969f, 0.10486998f, 0.06319043f, 0.20051804f, 0.22504243f, 0.25923872f, -0.14809522f, 
    -0.30344358f, 0.07189072f, -0.03963784f, 0.13235755f, -0.33250570f, -0.01272683f, 0.25350839f, -0.41818428f, 
    -0.16472773f, 0.32036412f, -0.11206890f, 0.07204010f, -0.08315957f, 0.19947062f, -0.07255368f, 0.12806623f, 
    0.43833661f, -0.06786788f, -0.20711556f, -0.03976537f, -0.03625510f, -0.21110772f, 0.02973270f, 0.09320644f, 
    0.08767944f, -0.14093438f, -0.02732488f, 0.11676008f, -0.09790209f, -0.01999584f, -0.18515672f, 0.36648980f, 
    -0.08910438f, 0.14272363f, -0.08479954f, 0.12769528f, -0.04609862f, -0.38926563f, 0.07048273f, 0.07575694f, 
    0.09669329f, -0.03192741f, 0.15994166f, 0.02893406f, -0.52672201f, -0.07311970f, 0.02610412f, 0.12333916f, 
    0.15379284f, -0.07597546f, 0.03515355f, -0.43920252f, 0.02929051f, 0.06970147f, 0.11665859f, -0.02457674f, 
    -0.01490668f, 0.09133183f, 0.04777603f, 0.07065450f, 0.21034993f, 0.02972244f, 0.05399632f, 0.12848182f, 
    0.07997589f, 0.07573799f, 0.13577811f, -0.11593637f, 0.03007729f, 0.01534765f, -0.31671181f, -0.38045663f, 
    -0.26708049f, 0.22942047f, -0.04112236f, -0.06006601f, 0.09599164f, 0.16847464f, 0.04438783f, -0.02742255f, 
    -0.23141623f, 0.05963524f, 0.01472696f, -0.07155040f, -0.55900025f, 0.02408709f, 0.02382367f, -0.23572941f, 
    -0.11777401f, 0.18698877f, 0.20700504f, 0.19557454f, 0.09599495f, -0.01065611f, -0.09159513f, 0.08491862f, 
    -0.12317301f, 0.18015444f, 0.21459298f, 0.06027376f, 0.33775088f, 0.36029214f, 0.01237385f, 0.01476329f, 
    0.07492158f, 0.03205520f, -0.03999817f, 0.00906784f, 0.13516618f, 0.11689833f, 0.00035784f, -0.05683228f, 
    0.05735263f, -0.09064472f, 0.03721684f, 0.20769960f, 0.01274380f, -0.00301199f, 0.40416801f, 0.26984021f, 
    0.09662819f, 0.11299023f, -0.03543353f, 0.02562126f, 0.03913816f, -0.27113011f, -0.01980248f, 0.10216093f, 
    0.06856656f, 0.13393001f, 0.02240350f, 0.23610713f, 0.07793657f, -0.03868628f, -0.06400374f, -0.38137221f, 
    0.06877207f, -0.49606135f, -0.03073691f, 0.08034749f, -0.77141255f, -0.09692395f, -0.07473703f, 0.09867136f, 
    0.01813758f, -0.16753572f, -0.35115731f, -0.05554331f, 0.03961592f, -0.16337188f, -0.00835722f, 0.01924591f, 
    0.14634886f, 0.10888957f, 0.08506291f, 0.00392412f, -0.09536309f, -0.03494617f, -0.03223088f, 0.29630512f, 
    0.04577267f, 0.09535068f, -0.48068064f, 0.07720236f, 0.09070985f, -0.22363774f, -0.19560912f, 0.04693945f, 
    -0.09221839f, 0.12198921f, 0.06604637f, -0.01339618f, -0.44068807f, -0.06018732f, 0.09824201f, -0.09798244f, 
    -0.07345423f, -0.13429184f, 0.08369709f, -0.46919426f, 0.05527616f, 0.00924230f, 0.09405845f, 0.05237572f, 
    -0.18513389f, 0.04720303f, -0.03520114f, -0.04674439f, 0.13915184f, -0.08811064f, -0.09410863f, -0.01546291f, 
    -0.22427674f, -0.01556394f, 0.17315578f, 0.02330230f, -0.00767726f, -0.09485413f, 0.01158210f, -0.18037274f, 
    -0.02017893f, 0.24479108f, -0.11456837f, 0.05307226f, -0.39419988f, 0.16297325f, 0.00434608f, -0.21154289f, 
    -0.05895535f, 0.01336850f, 0.00027749f, 0.04987476f, -0.08175763f, 0.01811560f, 0.21302089f, -0.24467415f, 
    0.07473612f, 0.12869816f, 0.09116134f, 0.12460957f, 0.02677380f, -0.03105688f, -0.06851352f, -0.03688746f, 
    -0.33579960f, 0.04034033f, 0.13230328f, 0.17018634f, 0.03919513f, -0.56211567f, -0.02851925f, 0.21873376f, 
    -0.07147768f, -0.00735154f, -0.01225815f, -0.05080324f, 0.12432306f, 0.03087075f, 0.20226897f, -0.04765001f, 
    0.27634695f, -0.28189477f, -0.01735096f, 0.19712856f, 0.06990266f, 0.19628517f, -0.14880896f, -0.25088668f, 
    -0.12492068f, 0.18066387f, 0.00769292f, 0.00364903f, 0.13551754f, 0.06405392f, 0.57066357f, 0.04239611f, 
    0.02514460f, 0.07138375f, -0.09847204f, 0.15771404f, 0.15554562f, -0.05857700f, 0.02230862f, -0.21574700f, 
    0.06591424f, 0.25983161f, -0.01181620f, -0.04902654f, -0.49913582f, 0.25354716f, -0.03213102f, 0.08680413f, 
    0.08964309f, -0.12354118f, 0.03973069f, 0.15884450f, 0.04792302f, 0.05588268f, 0.08656360f, 0.09636289f, 
    0.11001194f, 0.08219942f, -0.00391600f, 0.07561437f, 0.01434902f, 0.10578602f, 0.10416384f, -0.12736554f, 
    -0.31759956f, 0.01632122f, 0.08757954f, 0.08186861f, 0.18344705f, -0.53746712f, 0.00903434f, -0.02210808f, 
    0.12856770f, 0.07431570f, 0.05263238f, 0.01524531f, -0.38442868f, -0.01374328f, 0.09352969f, -0.08415569f, 
    -0.05919395f, 0.01682093f, 0.05322430f, -0.36688104f, 0.02691620f, 0.17573431f, 0.00531778f, -0.00304468f, 
    -0.11373951f, 0.21512660f, 0.31563097f, -0.00542594f, 0.11670975f, -0.07022143f, -0.00146552f, 0.08439959f, 
    0.11217386f, 0.09472137f, 0.24149913f, 0.09624290f, 0.15299602f, 0.01510355f, -0.17899837f, -0.42261377f, 
    0.11612466f, 0.15879667f, -0.02600260f, -0.11136878f, -0.00573618f, 0.25517833f, 0.09629021f, 0.00737233f, 
    -0.05107473f, 0.06788672f, -0.14856236f, -0.03627910f, -0.48729116f, -0.01462054f, -0.04865912f, -0.00410193f, 
    -0.06905980f, -0.30540708f, 0.07166937f, 0.12956677f, -0.03532650f, -0.02578321f, -0.09813550f, 0.25440159f, 
    0.01723865f, 0.01703783f, -0.00564425f, 0.04224666f, 0.29011026f, -0.31817016f, 0.16013615f, 0.08633862f, 
    -0.04145750f, 0.07246999f, 0.05976965f, -0.24882919f, 0.08300029f, 0.09408798f, 0.10451709f, -0.01794285f, 
    0.09974574f, -0.13668886f, 0.23886985f, 0.06338688f, 0.24841407f, 0.26997536f, -0.26105681f, -0.01173836f, 
    0.08248340f, 0.00415651f, 0.00492863f, 0.02298366f, 0.15954494f, -0.35241827f, -0.51060295f, 0.17796212f, 
    0.12701923f, 0.02790863f, -0.04629271f, 0.23979495f, 0.08933728f, 0.04769430f, 0.15822282f, -0.06501576f, 
    0.21503676f, 0.15492007f, -0.34022036f, 0.05096356f, -0.62963390f, 0.05949573f, -0.21281609f, 0.11219748f, 
    -0.02194262f, -0.04557844f, -0.04552222f, 0.26379076f, 0.22042990f, -0.02445283f, 0.02998466f, -0.67203510f, 
    -0.03540115f, 0.33586040f, 0.02495209f, 0.07074468f, -0.21157336f, 0.17372066f, 0.07537279f, 0.05283833f, 
    0.17005333f, 0.10283121f, 0.20053366f, -0.07518830f, -0.07105978f, 0.06148270f, -0.05271877f, -0.08209310f, 
    -0.33550471f, 0.00400768f, 0.19171639f, -0.18518412f, 0.15955243f, 0.07563430f, 0.16254990f, 0.23476163f, 
    0.31733778f, -0.18827035f, -0.00872688f, 0.17057429f, 0.06135604f, 0.07712436f, 0.01483920f, -0.03068924f, 
    0.02096424f, -0.02064976f, 0.05710053f, -0.26292974f, 0.28848061f, 0.00318633f, 0.26546898f, 0.04943033f, 
    0.11118399f, -0.30660444f, 0.05617321f, 0.28806779f, -0.37142840f, 0.05512250f, 0.16160196f, -0.34119433f, 
    0.21013601f, 0.14671408f, -0.02845489f, 0.24891949f, -0.28973198f, 0.14741190f, 0.07738924f, 0.32640785f, 
    -0.12788895f, -0.07686377f, -0.30213296f, 0.13210098f, 0.05731609f, 0.14463203f, 0.08490897f, 0.06121672f, 
    -0.18289424f, 0.29353750f, 0.03867442f, 0.11380047f, -0.00496866f, -0.29757968f, 0.35407317f, 0.08933600f, 
    -0.13203186f, 0.19646540f, 0.24515380f, -0.49491701f, 0.20064533f, 0.01141985f, 0.17614914f, -0.17500862f, 
    0.04439274f, -0.05409326f, -0.07575920f, -0.19991647f, -0.22495830f, 0.13154270f, 0.40252349f, -0.08623964f, 
    -0.11055930f, 0.06804758f, 0.10625397f, 0.06906039f, 0.11724328f, 0.13794416f, 0.31842488f, -0.48219657f, 
    -0.49908096f, -0.21653792f, -0.20797123f, 0.04259549f, -0.24772178f, 0.15765129f, 0.23497291f, 0.12623391f, 
    0.05536463f, -0.03458361f, 0.01766348f, -0.01895902f, 0.31035191f, -0.08598384f, 0.31133959f, 0.35716045f, 
    0.00596081f, 0.19676292f, -0.12770231f, 0.00090291f, -0.38337007f, 0.01005831f, 0.34760576f, -0.33555180f, 
    -0.14093062f, 0.15782203f, 0.00739323f, 0.00467401f, 0.40000299f, 0.33434683f, -0.07660968f, -0.00689754f, 
    0.00914166f, 0.08069540f, 0.03914609f, -0.20830709f, 0.31301793f, 0.03079649f, 0.26383749f, -0.55503595f, 
    -0.11736168f, -0.02585057f, -0.12641051f, -0.06381797f, 0.09735209f, 0.17145990f, -0.05205915f, -0.03841135f, 
    -0.04580333f, 0.19233163f, 0.04532371f, 0.08328050f, 0.35861897f, 0.02981183f, -0.03781485f, -0.05044354f, 
    -0.11678061f, 0.01655551f, 0.04357636f, 0.14394610f, 0.06361594f, -0.09412581f, -0.03546947f, 0.07691810f, 
    0.16746351f, 0.02632542f, 0.23841579f, 0.19250847f, 0.03332582f, -0.01814527f, 0.21803173f, 0.06886220f, 
    0.29858676f, 0.08677063f, -0.00805658f, 0.13562195f, 0.27977401f, 0.08813369f, 0.00289936f, -0.04077180f, 
    0.10293324f, -0.03489855f, 0.14231642f, -0.17518558f, -0.04156264f, 0.10863651f, 0.19464779f, 0.26895475f, 
    0.04723386f, -0.02613452f, 0.01686575f, -0.05427738f, -0.32950240f, 0.08624692f, -0.00489181f, -0.06998271f, 
    0.04832042f, -0.07084597f, 0.00877715f, -0.10418272f, -0.16116111f, 0.08696559f, -0.07691272f, 0.15074864f, 
    -0.20213316f, -0.21229975f, 0.09750585f, -0.04932892f, -0.22684853f, -0.34755865f, 0.04599153f, -0.00034624f, 
    0.07595140f, 0.09248094f, -0.08674639f, 0.34126252f, 0.22602384f, 0.15858872f, 0.07179563f, -0.08108029f, 
    -0.09830121f, -0.16130766f, -0.11609419f, 0.03815722f, -0.08380141f, 0.09835682f, -0.05393112f, -0.25253302f, 
    -0.04690656f, -0.22950128f, 0.09827140f, -0.05195193f, -0.02420023f, 0.36567736f, 0.22165187f, 0.14445266f, 
    0.13884903f, -0.02406983f, 0.00343323f, -0.20406480f, 0.08177117f, -0.06950358f, -0.01593946f, 0.04213545f, 
    -0.14146473f, -0.14129913f, -0.44813907f, -0.03509762f, -0.07147469f, 0.16540879f, -0.06214816f, 0.03110993f, 
    0.55102962f, 0.05046602f, -0.14532094f, 0.18463467f, 0.08040345f, -0.19746150f, -0.02475429f, 0.40182599f, 
    0.09780508f, -0.00609890f, -0.05620978f, -0.10954066f, 0.16338199f, -0.11049260f, 0.00206984f, 0.32963043f, 
    -0.04679099f, 0.16049133f, 0.06430098f, 0.01763294f, -0.09465770f, -0.04782815f, 0.24049723f, -0.08144337f, 
    0.06877984f, -0.11059184f, 0.25563562f, 0.09766802f, -0.04497275f, -0.04918858f, 0.15616307f, 0.22204131f, 
    0.17931964f, 0.17888467f, -0.12323160f, -0.39319015f, -0.06710719f, 0.05390773f, 0.05927938f, 0.17580453f, 
    -0.17939039f, -0.03110054f, -0.16259511f, 0.05423465f, -0.11180945f, 0.03578026f, 0.17457254f, 0.04679375f, 
    0.14450073f, 0.12239563f, 0.35874882f, -0.05934202f, 0.18435720f, -0.24350870f, -0.06787453f, -0.07778391f, 
    0.11034857f, 0.24394527f, 0.18262473f, -0.08950693f, 0.02522269f, 0.04835377f, -0.04530480f, 0.07915743f, 
    0.06096170f, 0.14918736f, -0.04159429f, 0.14198695f, -0.33284688f, 0.01969873f, 0.45622483f, 0.00252955f, 
    0.29017219f, 0.00931169f, 0.05208081f, 0.11673354f, 0.16473724f, -0.04312750f, -0.24537659f, -0.26113191f, 
    0.10483495f, -0.02715609f, -0.00472305f, 0.34954509f, 0.51358825f, -0.35400587f, -0.15863128f, -0.03707685f, 
    -0.02789077f, 0.11372703f, 0.00761513f, 0.07627798f, 0.04431859f, -0.08369302f, 0.06014851f, -0.09730031f, 
    -0.19197105f, -0.15935335f, 0.07277025f, 0.05946329f, 0.01757244f, 0.19872797f, -0.00588998f, 0.28989810f, 
    0.00169193f, 0.01918582f, -0.07126968f, 0.05824082f, 0.05477623f, -0.19111548f, 0.01726367f, -0.22347619f, 
    0.07830193f, 0.17468290f, 0.17227688f, 0.21079700f, -0.01602344f, -0.06561562f, 0.16792440f, -0.22037694f, 
    -0.03899176f, 0.40784425f, 0.19347093f, -0.07339429f, -0.28595680f, -0.01137532f, 0.26483148f, -0.21817550f, 
    -0.28369105f, 0.27369037f, -0.02505148f, -0.15556705f, 0.24894702f, 0.20051536f, -0.06030505f, 0.03221828f, 
    0.04994649f, -0.04090987f, 0.03582566f, -0.06195686f, 0.12498432f, -0.03918531f, 0.13762918f, -0.24292485f, 
    -0.02426481f, 0.02730098f, -0.43617103f, 0.08101498f, 0.05220374f, -0.09531762f, -0.03806378f, 0.01246132f, 
    0.00906120f, 0.04650527f, -0.16895397f, 0.12784231f, 0.39252329f, -0.01986520f, -0.06026407f, 0.10468332f, 
    -0.01399105f, 0.03610333f, 0.11755159f, 0.19016176f, 0.08647639f, -0.04250575f, 0.00598739f, 0.05262109f, 
    0.05631848f, 0.08537455f, -0.03306374f, 0.38426214f, 0.17263961f, -0.07552458f, -0.04720949f, -0.05123346f, 
    0.16316086f, 0.20060258f, -0.07736997f, 0.03287616f, 0.42635354f, 0.18884890f, 0.22983436f, 0.24675211f, 
    0.09763739f, 0.02380845f, 0.00410608f, -0.00746283f, 0.02336936f, 0.05552634f, 0.09208211f, 0.16719221f, 
    0.04784394f, 0.04042191f, 0.09721659f, 0.11401215f, -0.09580266f, 0.05326202f, -0.24369910f, -0.17051888f, 
    -0.03812890f, 0.06351454f, -0.01270733f, -0.14670080f, -0.10834596f, -0.03904293f, 0.01424243f, 0.48241445f, 
    -0.08901914f, -0.15701185f, 0.02865016f, 0.07096723f, -0.33245328f, 0.29509529f, -0.16943324f, 0.02465010f, 
    -0.05898076f, 0.04936308f, -0.06955707f, 0.28476840f, 0.18152429f, 0.01034242f, 0.09906109f, -0.02443667f, 
    0.18847676f, -0.19185346f, -0.16203929f, 0.05466292f, -0.07690971f, 0.09471954f, 0.28157809f, -0.14348103f, 
    0.01908780f, 0.01772034f, 0.03788338f, 0.01352458f, 0.14159809f, 0.15367186f, -0.05485043f, 0.02331419f, 
    0.12177851f, 0.09757213f, 0.00150666f, -0.11966989f, 0.03324753f, -0.07270800f, -0.16074708f, 0.13354008f, 
    -0.40453604f, 0.06419535f, -0.15911396f, -0.08792093f, -0.96036178f, 0.15628049f, 0.19475664f, -0.06106101f, 
    0.68820715f, 0.05783634f, 0.18034606f, -0.18925312f, -0.11971328f, -0.11904664f, -0.19646831f, -0.10796458f, 
    0.18162414f, 0.11986941f, 0.02959660f, 0.12337609f, -0.44724050f, -0.00595746f, 0.13046871f, 0.13431811f, 
    -0.54186165f, 0.09492107f, 0.44055349f, 0.16698191f, 0.18702310f, 0.14447320f, 0.32496709f, 0.02208705f, 
    0.26817995f, -0.07359993f, 0.19715485f, 0.08303773f, -0.03897353f, 0.04518853f, -0.28246579f, -0.00618037f, 
    -0.35021609f, 0.00845635f, -0.12742738f, -0.30900264f, -0.39925292f, -0.04303766f, 0.38214102f, 0.38700601f, 
    -0.09972580f, 0.33709779f, 0.35874504f, 0.02690064f, -0.04695341f, 0.08138662f, -0.07275766f, 0.13669407f, 
    -0.10403956f, 0.06590551f, 0.12729461f, -0.30200240f, 0.03058494f, 0.25273350f, -0.11841194f, 0.01016599f, 
    0.16833816f, -0.15482016f, -0.30794883f, -0.33490023f, -0.24844483f, 0.13939703f, 0.02864756f, 0.13599892f, 
    -0.43046713f, 0.13507093f, 0.08701365f, -0.02916197f, -0.25031674f, 0.11750410f, 0.35499689f, -0.02284201f, 
    0.01083085f, -0.24010006f, -0.20552081f, 0.34691218f, 0.22348261f, -0.65439588f, -0.39428002f, -0.47002590f, 
    -0.10987107f, -0.16676576f, -0.08226820f, -0.14887834f, 0.62541610f, -0.06279104f, 0.12860468f, -0.00738238f, 
    -0.01602028f, 0.06130277f, 0.05856869f, -0.40529373f, 0.02084206f, 0.14083405f, -0.21206464f, 0.11513741f, 
    0.13161567f, -0.83120286f, 0.03200595f, 0.16939233f, -0.00734398f, 0.02486007f, 0.27027375f, -0.10556937f, 
    0.12463398f, -0.14351904f, 0.09226119f, -0.00165625f, 0.08473445f, -0.29099491f, 0.24243192f, -0.19171353f, 
    -0.00165072f, -0.17155512f, 0.03850569f, 0.22654882f, -0.05459801f, 0.03692994f, -0.00201677f, 0.01170552f, 
    0.20086960f, 0.55158257f, -0.11233296f, -0.06676504f, 0.22889327f, -0.09345823f, 0.09838440f, 0.00190467f, 
    0.38984212f, 0.06182512f, -0.05926257f, 0.35370120f, 0.36691603f, -0.00097717f, 0.07980248f, 0.22310281f, 
    -0.03413102f, 0.23702449f, 0.08047988f, -0.21503060f, 0.14229168f, 0.19411956f, 0.30669037f, -0.16224769f, 
    -0.23713151f, 0.12145006f, 0.45128599f, -0.15463078f, -0.33358565f, -0.12033603f, -0.02604321f, -0.05680625f, 
    -0.21202388f, 0.31264696f, 0.12430745f, -0.03946110f, -0.16536444f, 0.02658266f, 0.27270612f, 0.10723908f, 
    0.32062089f, -0.01380717f, 0.15817195f, -0.41068634f, 0.17212486f, -0.27850175f, -0.05613030f, 0.13231480f, 
    0.20434211f, -0.14762247f, 0.03923751f, 0.12581281f, 0.09705707f, 0.05951595f, 0.42854279f, -0.07156325f, 
    0.08186974f, 0.01811443f, -0.02363838f, 0.26775831f, 0.02390855f, 0.48269480f, -0.08935151f, -0.76928997f, 
    0.19061284f, -0.03829785f, 0.22717758f, 0.16301090f, 0.29395619f, -0.20480858f, 0.04377903f, 0.50732857f, 
    0.09971267f, -0.11907264f, -0.15181631f, 0.08578739f, -0.29243270f, 0.04743616f, 0.09583292f, -0.04358624f, 
    -0.15722224f, 0.21274480f, -0.06846921f, -0.10612831f, -0.19942468f, 0.12823570f, -0.06596304f, -0.40559292f, 
    0.05354123f, 0.19459422f, 0.17601423f, 0.11986322f, 0.32727394f, 0.24155015f, -0.11225338f, 0.10758267f, 
    -0.08014768f, 0.04116227f, -0.01161891f, 0.32326877f, 0.07795811f, 0.13155790f, 0.14985192f, -0.00620780f, 
    -0.00783261f, 0.17327946f, 0.09516748f, -0.13570374f, -0.10659020f, -0.01352111f, 0.32067981f, 0.22750558f, 
    -0.08605393f, 0.10694692f, -0.09127470f, 0.05905590f, -0.08422075f, -0.15849385f, 0.50812358f, -0.07277459f, 
    -0.18633533f, -0.06100234f, 0.29269889f, -0.19938995f, 0.20096295f, -0.04648104f, 0.07353646f, 0.34122792f, 
    0.01327736f, 0.03998412f, 0.15104501f, -0.03148969f, -0.15403165f, -0.19381453f, -0.00290435f, 0.04122424f, 
    0.08646844f, 0.04328250f, 0.10970967f, -0.07230499f, 0.04080592f, -0.04216715f, 0.25576842f, -0.03022868f, 
    0.05744211f, 0.20290154f, -0.05217164f, 0.15408492f, -0.30621219f, -0.11630702f, -0.12976409f, -0.35500452f, 
    -0.48172149f, 0.09575479f, 0.06149466f, -0.03466497f, 0.00062312f, 0.31190184f, -0.18667826f, -0.06329957f, 
    0.08490492f, 0.38110569f, 0.16252454f, 0.06566534f, -0.29739666f, 0.05246657f, -0.13920940f, 0.14622736f, 
    -0.14069225f, 0.01439598f, 0.12210840f, 0.20057254f, -0.16398577f, 0.01600936f, -0.16573165f, 0.22719169f, 
    0.11338295f, 0.02417759f, 0.36620197f, 0.02188494f, 0.06790199f, -0.00534648f, 0.04896106f, 0.11827942f, 
    -0.11249739f, -0.34785530f, -0.24468216f, 0.00475540f, -0.19945639f, 0.15179940f, -0.28319484f, -0.50446999f, 
    -0.07377773f, 0.03016401f, -0.11487404f, 0.06574178f, -0.09375812f, -0.03184415f, -0.01419133f, -0.11415666f, 
    -0.12606198f, 0.15119721f, -0.01926970f, -0.19149502f, 0.18536249f, -0.06908759f, -0.35258278f, 0.08704545f, 
    -0.11543628f, 0.18121618f, 0.11282989f, 0.08101531f, 0.06104381f, 0.00554328f, -0.85601234f, 0.04559381f, 
    -0.05370083f, 0.21947065f, -0.01531438f, 0.06385138f, -0.12417947f, 0.55455601f, -0.20527627f, 0.35481730f, 
    -0.00420984f, 0.02815482f, -0.01067595f, -0.39651367f, 0.15585767f, 0.15236136f, 0.02798428f, -0.07538470f, 
    0.12910368f, 0.05802822f, 0.08685310f, 0.20447898f, 0.19172032f, 0.10007222f, 0.01662713f, -0.07768368f, 
    0.09741032f, 0.46687940f, 0.18880238f, -0.00637949f, 0.16535188f, -0.16350392f, 0.32218513f, -0.13167098f, 
    -0.15203996f, -0.07471967f, -0.00194630f, 0.28042713f, -0.05768410f, 0.01939446f, -0.07215168f, -0.02046729f, 
    -0.00347449f, 0.02355492f, -0.02569838f, -0.04859601f, 0.02216117f, -0.04063261f, 0.02423100f, -0.08999172f, 
    0.00207867f, -0.00814335f, 0.04718551f, -0.01060775f, 0.05031525f, -0.02165888f, -0.07471140f, 0.01213350f, 
    -0.00282749f, 0.05979198f, 0.00817803f, -0.09788869f, 0.02626225f, -0.05311685f, -0.00421728f, -0.07360162f, 
    -0.03188108f, -0.01921816f, 0.02215664f, 0.01548458f, -0.03230012f, -0.01822690f, -0.09626024f, -0.08866473f, 
    -0.07114300f, -0.02713488f, -0.09866580f, -0.01962773f, -0.09292741f, 0.03900194f, 0.01667616f, -0.08303308f, 
    -0.05073228f, -0.07650844f, -0.03274087f, -0.01753905f, -0.06197735f, -0.03771724f, -0.04803558f, -0.08825733f, 
    -0.01931344f, -0.08407644f, 0.06034413f, -0.05541109f, 0.06020473f, 0.03565628f, -0.03361953f, 0.01168428f, 
    -0.06259134f, -0.07458236f, -0.11138698f, 0.03227596f, 0.05253221f, 0.03873187f, 0.00501332f, -0.04970781f, 
    -0.08182701f, -0.08231521f, 0.06250579f, 0.00549519f, -0.05760166f, -0.04163797f, 0.05152080f, -0.03125755f, 
    0.01356217f, -0.09402780f, 0.00605396f, -0.06491005f, -0.00255576f, -0.02787402f, -0.00182988f, -0.05538710f, 
    0.03116592f, 0.05242051f, -0.06992191f, 0.02837126f, 0.03740446f, -0.09657875f, 0.07697481f, 0.00719664f, 
    0.01939271f, 0.03143577f, 0.03385607f, -0.04641271f, -0.08581465f, 0.06978133f, 0.00738878f, -0.01359773f, 
    -0.02621759f, -0.07565536f, 0.03700675f, -0.04216261f, 0.03181766f, -0.00043114f, -0.10646462f, 0.05083983f, 
    -0.05738799f, -0.10825629f, 0.05361139f, 0.01077454f, -0.01505995f, 0.02960496f, -0.07856733f, 0.01088716f, 
    -0.02916778f, 0.05595348f, -0.06011479f, 0.07392509f, -0.00103356f, -0.02549937f, 0.03119081f, 0.00402826f, 
    0.03796196f, 0.02084752f, -0.01020934f, 0.05959425f, 0.03578777f, 0.02790006f, -0.06737860f, 0.05099422f, 
    -0.03121591f, 0.24098572f, -0.26172310f, -0.07007550f, 0.59124631f, 0.21475065f, -0.38105863f, 0.03698749f, 
    0.29240352f, -0.11564352f, -0.44111198f, 0.44311312f, 0.18867703f, 0.20746668f, -0.19789454f, 0.14994216f, 
    0.12767145f, -0.18910787f, -0.06950911f, 0.01561873f, 0.23815124f, -0.06285412f, -0.20087168f, 0.11579431f, 
    -0.00423394f, 0.11829270f, -0.24812201f, 0.14108397f, -0.27518961f, -0.61442065f, 0.14857802f, 0.07576990f, 
    0.05392772f, -0.13740754f, -0.01718337f, 0.02663205f, 0.14512685f, -0.01102264f, 0.20944594f, 0.13452442f, 
    0.10640116f, -0.07712794f, 0.15890560f, -0.07910546f, 0.09843159f, -0.06200155f, 0.17511694f, -0.07232022f, 
    -0.09029634f, -0.03031387f, -0.31655252f, -0.07947105f, -0.00034706f, 0.05205829f, 0.16095774f, 0.09149563f, 
    0.01398817f, 0.04194687f, 0.19135754f, 0.04472298f, -0.10400122f, -0.07581370f, -0.18254034f, -0.23005266f, 
    -0.07134736f, 0.21113198f, 0.15739505f, 0.07032089f, 0.19557767f, 0.10374924f, 0.19259615f, 0.06393900f, 
    0.23032930f, 0.09149186f, 0.00486066f, 0.03864125f, -0.53410709f, -0.07730012f, 0.05666840f, -0.19984706f, 
    -0.03904973f, 0.37159351f, 0.11262196f, 0.03369675f, 0.13194226f, 0.04657904f, 0.38756210f, -0.46223071f, 
    0.24372146f, 0.21028699f, 0.33700737f, 0.35564947f, 0.35841584f, -0.19904432f, -0.05337020f, 0.13032940f, 
    -0.08074546f, -0.00805449f, -0.06641786f, 0.16445993f, 0.11064214f, -0.01535843f, -0.05099259f, -0.02413242f, 
    -0.22408313f, 0.09274152f, 0.09977008f, -0.02687348f, -0.03706579f, -0.17792177f, 0.10244499f, -0.18533377f, 
    -0.19526751f, -0.18658523f, -0.12409835f, -0.01405876f, 0.06226748f, 0.19103256f, -0.06946278f, -0.07998758f, 
    0.05771424f, 0.12424663f, 0.08299860f, 0.16080004f, 0.04031017f, 0.08344416f, 0.11365995f, -0.43020996f, 
    -0.47117698f, 0.55153567f, -0.29983965f, -0.04115884f, -0.21099417f, 0.36613855f, 0.31039321f, -0.43066475f, 
    0.73243326f, -0.40049973f, 0.32073188f, 0.23505600f, 0.42538112f, -0.18528610f, 0.05622452f, 0.19045302f, 
    0.11803848f, 0.36995944f, -0.02150775f, -0.20602016f, -0.08721623f, 0.16696416f, 0.27386665f, -0.36769918f, 
    -0.66666436f, -0.16024756f, 0.71914762f, -0.00180292f, 0.19691917f, 0.21949841f, 0.19444053f, 0.08105993f, 
    0.04896116f, 0.33709434f, 0.07010559f, -0.17545018f, -0.07505878f, -0.07447219f, 0.23447666f, -0.40431154f, 
    -0.02644146f, 0.05783882f, 0.02872252f, -0.00072707f, -0.37103179f, -0.14330769f, 0.15007898f, 0.16490658f, 
    -0.21171753f, 0.15517470f, 0.51752657f, -0.15514237f, 0.00342535f, 0.01434572f, -0.02739709f, -0.05997823f, 
    0.19147572f, 0.02979597f, 0.29705569f, 0.22159413f, 0.33221948f, 0.21761805f, -0.18438046f, 0.44475150f, 
    -0.22691388f, -0.11290880f, 0.01150387f, 0.10134047f, -0.02444037f, 0.21633419f, 0.09883670f, 0.33096081f, 
    -0.05500750f, -0.13544939f, -0.25505584f, -0.16106702f, -0.56595659f, -0.00956685f, 0.04142747f, -0.06458789f, 
    -0.00122348f, -0.30833104f, -0.05569293f, 0.21197976f, -0.04639008f, 0.00376877f, -0.22735885f, -0.01716781f, 
    0.07088494f, 0.29080182f, 0.13053486f, -0.08674221f, 0.55183220f, -0.27126294f, 0.09883714f, 0.08444507f, 
    0.06044400f, 0.08125073f, -0.05993898f, -0.24528098f, -0.31590399f, 0.30829662f, 0.09213816f, 0.14579129f, 
    0.05938412f, -0.57408404f, 0.34538820f, 0.11963802f, 0.24584368f, 0.26063529f, -0.36320487f, 0.53914177f, 
    0.10086953f, 0.07431959f, -0.07993640f, 0.04625170f, 0.08847658f, -0.47521889f, -0.19493230f, 0.18503846f, 
    -0.28597975f, -0.00324374f, 0.08506546f, 0.12880778f, -0.00996578f, 0.03891460f, 0.15990803f, 0.25078326f, 
    0.20409004f, -0.51911730f, 0.26769739f, 0.04514256f, -0.13756293f, -0.17914838f, -0.07489477f, 0.10614640f, 
    -0.31326053f, 0.09240219f, 0.11629853f, -0.16207129f, -0.24586233f, -0.05960041f, 0.09901614f, -0.24227788f, 
    0.00310080f, 0.11403823f, -0.08107081f, 0.07341900f, -0.01352155f, 0.16508463f, -0.12253419f, -0.01479383f, 
    -0.13161412f, 0.01112560f, -0.14412177f, 0.12368494f, -0.00968756f, -0.06417362f, -0.36944354f, -0.11615809f, 
    0.02595788f, 0.25277546f, 0.00967272f, -0.07167298f, -0.18791322f, 0.02378058f, 0.03630318f, -0.00383631f, 
    0.10027306f, -0.04090704f, 0.03517288f, -0.28296331f, 0.16334574f, 0.00756457f, -0.18050270f, -0.13203306f, 
    0.15576985f, 0.01074991f, 0.02045945f, 0.01656530f, -0.01296890f, 0.01891050f, 0.14792074f, 0.02977810f, 
    -0.20593035f, -0.01766676f, -0.22985953f, 0.11009526f, -0.17609374f, 0.09976668f, 0.00968923f, -0.04241609f, 
    -0.04194956f, -0.09404335f, -0.13702419f, 0.20696886f, 0.06628785f, 0.02907118f, -0.06391457f, -0.11597155f, 
    -0.00337292f, 0.04015036f, -0.03007942f, 0.10465066f, 0.31074116f, -0.01494444f, -0.78711605f, -0.01261527f, 
    -0.13544627f, 0.02225622f, 0.07354408f, 0.05480374f, -0.01361775f, 0.01670093f, -0.02866669f, -0.27075788f, 
    0.19687243f, 0.12701203f, -0.01912184f, -0.06102936f, -0.50531888f, 0.51491797f, 0.02402313f, 0.26762614f, 
    0.01010726f, -0.07802711f, 0.04931313f, -0.25801212f, 0.24172466f, 0.05240441f, 0.15824638f, -0.05040814f, 
    0.23391438f, 0.25576168f, -0.16941768f, 0.00129892f, 0.04048923f, -0.09158342f, 0.35474640f, -0.34763479f, 
    0.10953034f, 0.21023537f, 0.06605958f, -0.03047289f, 0.11386003f, -0.07978254f, 0.01007126f, 0.14738154f, 
    -0.02394705f, 0.01510570f, 0.16564761f, -0.04263787f, 0.10669034f, 0.02927441f, -0.05849558f, 0.11010952f, 
    -0.06899439f, 0.05689072f, -0.01323103f, 0.06930754f, -0.12438953f, -0.05715957f, -0.09568052f, -0.00911777f, 
    -0.03741916f, 0.00681138f, -0.09992503f, -0.03117748f, 0.06380866f, -0.04476918f, -0.08148858f, -0.01835993f, 
    0.04225207f, -0.10997365f, -0.05302677f, -0.08414294f, -0.03710788f, -0.07825477f, 0.02421349f, 0.07098086f, 
    -0.04015364f, -0.00676057f, -0.00977910f, -0.01011363f, 0.01806608f, 0.08668213f, -0.03599449f, -0.05982539f, 
    -0.04737111f, 0.02523947f, -0.00511030f, 0.02041350f, -0.06990463f, -0.04549890f, -0.08684175f, 0.00594209f, 
    0.00904701f, -0.07088926f, -0.05676519f, -0.09520485f, -0.02924532f, -0.01445959f, 0.00521389f, -0.12340862f, 
    -0.00962372f, -0.02173823f, 0.03365390f, 0.00741702f, -0.09484726f, -0.03513433f, -0.09031061f, -0.12056722f, 
    -0.00569816f, -0.08179895f, -0.10187446f, 0.02725413f, -0.04134605f, 0.01300859f, 0.04637941f, -0.03732399f, 
    0.04897433f, -0.06817748f, -0.05543450f, 0.05999002f, -0.08388280f, -0.09060178f, -0.09834816f, -0.05238539f, 
    -0.02437692f, -0.00390990f, -0.10212570f, 0.03452795f, 0.00068679f, -0.07787089f, 0.03604139f, -0.01263165f, 
    -0.10368155f, -0.08452061f, -0.12375685f, 0.00663182f, 0.00409934f, -0.09871188f, 0.01276933f, -0.07449635f, 
    -0.06422769f, -0.05954540f, -0.05206117f, -0.10428513f, -0.04495138f, -0.00945064f, -0.02534433f, -0.02200927f, 
    0.04899874f, -0.02967919f, 0.07241739f, -0.08473280f, -0.03724051f, 0.00138678f, -0.11158730f, 0.07250150f, 
    -0.09924138f, 0.04232603f, 0.03807741f, -0.06794384f, -0.13301843f, 0.04220262f, -0.01022136f, -0.01326588f, 
    -0.00547758f, -0.13441955f, -0.11687391f, -0.05411433f, -0.11625107f, 0.01104027f, -0.05102578f, 0.01161902f, 
    -0.04445204f, -0.00094679f, -0.06925799f, -0.01849492f, 0.02807647f, -0.08135122f, -0.10283822f, 0.04998127f, 
    0.03558033f, -0.01337698f, -0.08707331f, 0.03203773f, -0.02301328f, -0.01106176f, -0.02550375f, 0.04567304f, 
    -0.09185515f, -0.06510461f, -0.02797035f, 0.02351370f, -0.01310741f, 0.03822379f, -0.02712218f, -0.03030687f, 
    -0.09467754f, -0.00404413f, 0.00797645f, -0.03441092f, -0.09985949f, -0.10503302f, -0.06494069f, -0.12146645f, 
    -0.06048904f, 0.02010662f, -0.00683369f, -0.10363863f, -0.07737714f, 0.07588167f, 0.00644626f, -0.01905929f, 
    -0.03699656f, -0.06851889f, -0.12780854f, -0.03054069f, -0.02485369f, 0.05846004f, -0.06617229f, 0.05476293f, 
    -0.04459974f, -0.02975293f, 0.08272945f, -0.00681756f, 0.00967855f, -0.03971799f, 0.04582977f, -0.07615136f, 
    -0.00041051f, -0.01183425f, 0.05042497f, 0.01402628f, 0.03799977f, 0.06667203f, -0.08387934f, -0.01564821f, 
    -0.02603058f, 0.04034100f, -0.05467224f, -0.08410829f, -0.10110329f, 0.00205087f, -0.01001306f, 0.00341965f, 
    0.07369085f, 0.00997725f, -0.05835200f, -0.03864601f, -0.03450336f, -0.05585207f, -0.10463860f, -0.05885261f, 
    0.02875733f, 0.04798530f, -0.01332318f, 0.02312165f, 0.07628428f, 0.01159744f, 0.06312338f, 0.02493849f, 
    -0.04079900f, -0.06497005f, -0.06359743f, -0.10248140f, -0.07940915f, -0.08793452f, -0.03854353f, 0.00373409f, 
    -0.00815694f, 0.06004298f, 0.02299570f, 0.03670279f, -0.08052265f, 0.03733461f, -0.11746303f, -0.05556358f, 
    -0.04917652f, -0.03503101f, -0.02915762f, 0.01624250f, -0.04077716f, -0.11168225f, -0.03219841f, -0.04830246f, 
    -0.02871853f, -0.05078978f, -0.00337365f, -0.02103067f, 0.03429469f, -0.00985327f, -0.06985824f, 0.07407630f, 
    -0.07454590f, -0.01180074f, -0.00676002f, 0.02555449f, -0.04589484f, -0.01723258f, -0.08365574f, -0.00872347f, 
    -0.04251445f, -0.07577251f, 0.03964602f, 0.03671642f, 0.01064393f, 0.07382949f, 0.08006582f, 0.01335019f, 
    -0.26184335f, 0.55909413f, -0.30868790f, 0.00286453f, -0.12915039f, 0.15759565f, 0.16061141f, -0.24526197f, 
    0.42015579f, -0.09955794f, 0.20676678f, 0.31851923f, 0.31841367f, 0.07946520f, 0.08748596f, 0.51050675f, 
    -0.10587640f, 0.19671749f, -0.06168703f, -0.07690848f, -0.01879596f, 0.18595056f, 0.18339057f, -0.33262876f, 
    -0.34140691f, -0.18984567f, 0.24026816f, -0.09117754f, 0.11001661f, 0.04202873f, 0.23241308f, 0.05120286f, 
    0.10890970f, -0.00917366f, 0.20037021f, 0.01285923f, -0.12125558f, 0.06682355f, 0.31357011f, -0.31319293f, 
    -0.02985560f, -0.09587397f, 0.08208049f, -0.25683594f, -0.26544216f, -0.03217997f, -0.00117157f, 0.05513446f, 
    -0.05406046f, 0.06430002f, 0.29839969f, -0.03179394f, 0.19800599f, -0.06452433f, -0.05851621f, 0.07764458f, 
    0.15426433f, -0.13286036f, 0.25866222f, 0.31986627f, 0.39479268f, 0.09289235f, -0.08294176f, 0.03839444f, 
    -0.00746666f, -0.05749479f, 0.09601183f, -0.04971016f, 0.02319018f, 0.15661088f, 0.18286057f, 0.04433608f, 
    -0.21562079f, -0.09857426f, -0.13470149f, 0.03353658f, -0.24777511f, 0.02781712f, 0.21085618f, 0.08157837f, 
    -0.10978003f, -0.18066089f, -0.06320920f, 0.06200701f, -0.25108701f, -0.01352791f, -0.45102257f, 0.05500605f, 
    0.33674061f, 0.06780275f, 0.04573976f, 0.05266997f, 0.30612698f, -0.31530073f, 0.04387068f, 0.01907277f, 
    -0.06877115f, -0.04394361f, -0.05407157f, -0.19436057f, -0.25741690f, 0.09742619f, 0.10770787f, 0.03004484f, 
    -0.13681249f, -0.13193110f, 0.34026667f, 0.00425077f, 0.24724564f, 0.31507167f, -0.12492720f, 0.40771189f, 
    0.07913655f, 0.07399481f, -0.18727711f, 0.10548238f, 0.06519341f, -0.52913862f, -0.57934469f, 0.22258075f, 
    -0.01257717f, 0.03714444f, -0.09990329f, -0.00153159f, -0.07303297f, 0.00673653f, 0.12493447f, 0.12697272f, 
    -0.06848822f, -0.06561096f, 0.01517086f, 0.04345931f, -0.05845190f, 0.03364674f, -0.07232221f, 0.04043179f, 
    -0.01759989f, 0.05447319f, 0.05023243f, -0.04767006f, -0.05422672f, -0.05442383f, -0.08428086f, -0.08505706f, 
    0.06259743f, -0.09685607f, -0.07916653f, -0.00336282f, -0.02442840f, -0.10594115f, -0.06434190f, -0.01367995f, 
    -0.05637788f, 0.01737352f, 0.04782295f, 0.04723040f, -0.08623186f, -0.06716697f, 0.01898241f, 0.07932327f, 
    0.05616324f, -0.05649739f, 0.03989225f, -0.04037447f, -0.05627209f, 0.08232531f, -0.00187387f, -0.03238585f, 
    0.02646795f, -0.04537600f, -0.05185876f, 0.07742556f, 0.05574334f, 0.01720002f, 0.07161240f, 0.05679177f, 
    -0.04708147f, -0.03703107f, 0.04858560f, -0.00127746f, -0.00893084f, 0.02752800f, -0.04868148f, -0.07209837f, 
    -0.08535572f, -0.04139442f, -0.01282131f, 0.06490722f, -0.02928082f, -0.05548266f, -0.02150757f, 0.02731185f, 
    0.01896933f, -0.07691418f, 0.03411098f, 0.07533600f, -0.07816384f, -0.04028684f, 0.05252678f, 0.02183031f, 
    -0.05279548f, -0.02900953f, 0.05250492f, 0.05298416f, -0.00074269f, -0.08699019f, -0.08033644f, 0.05517200f, 
    -0.08131686f, 0.00069380f, -0.04749931f, 0.04088327f, -0.07401159f, -0.04618494f, -0.00732237f, 0.00354853f, 
    -0.05516129f, -0.08122589f, 0.06873195f, -0.10466084f, -0.09204430f, -0.03523683f, -0.08658741f, -0.05990694f, 
    -0.02470530f, 0.08768344f, -0.04231677f, -0.04783459f, 0.00700777f, -0.02624360f, -0.08997764f, -0.04822911f, 
    -0.04942905f, 0.03165605f, 0.06197126f, -0.10420622f, 0.03780172f, -0.06842582f, -0.08329088f, -0.07195070f, 
    -0.09627402f, -0.09247470f, -0.04272695f, -0.05767430f, -0.08736631f, 0.06280532f, -0.08642995f, -0.03851559f, 
    -0.07721376f, -0.09905098f, 0.01355142f, -0.08405198f, 0.03777541f, 0.07355577f, -0.04685144f, -0.01590200f, 
    0.05118757f, -0.25015289f, 0.16100416f, 0.07273365f, 0.22234903f, -0.10373826f, -0.05582934f, 0.23372230f, 
    0.23840132f, -0.06375261f, 0.00202895f, -0.09821045f, -0.21385390f, 0.15507753f, 0.10168100f, 0.04439434f, 
    0.04443263f, 0.00563656f, -0.04399558f, 0.05293761f, 0.03388179f, 0.12924659f, 0.12740529f, -0.06310601f, 
    -0.00738524f, 0.21408030f, -0.22345701f, -0.01684706f, 0.05862273f, -0.32862505f, -0.24152736f, 0.04835833f, 
    -0.00440314f, 0.11131114f, 0.21009795f, 0.04531682f, 0.04128313f, -0.06637329f, 0.08511040f, 0.14160356f, 
    0.25975385f, -0.44682628f, -0.18335886f, -0.43934962f, 0.04989094f, -0.00776852f, -0.18102646f, -0.27625653f, 
    0.24652101f, -0.01516854f, 0.44354373f, -0.04440290f, 0.02938857f, 0.03295179f, -0.00767754f, -0.13030529f, 
    -0.45367226f, 0.08908981f, 0.03795306f, 0.16042991f, 0.03235760f, 0.23708111f, -0.22144476f, 0.19696438f, 
    0.20945498f, -0.13310453f, -0.22358558f, -0.27873695f, -0.16924044f, -0.07512697f, -0.25283384f, 0.12199038f, 
    0.20284164f, -0.01102619f, -0.42754802f, 0.28252906f, -0.36106387f, -0.02636690f, -0.12166191f, 0.06483319f, 
    -0.09674872f, 0.07600281f, 0.09216471f, -0.10011565f, -0.11532062f, 0.18793094f, -0.07631327f, 0.05195517f, 
    0.19245054f, 0.23986535f, -0.16115774f, 0.02861934f, 0.08339763f, 0.22934118f, -0.00160370f, 0.21988040f, 
    -0.03817962f, 0.04281995f, -0.07589479f, 0.15900147f, 0.09834968f, -0.00707383f, 0.08054603f, 0.06685552f, 
    -0.24974920f, -0.01150544f, -0.00268184f, -0.02361150f, 0.20287277f, 0.17164360f, 0.19371600f, -0.21517515f, 
    0.00510548f, 0.15886085f, 0.17878401f, 0.01799405f, -0.03837929f, 0.21550496f, 0.06593768f, 0.13774018f, 
    -0.12403338f, -0.18399979f, -0.25451806f, -0.00240661f, 0.09213635f, 0.07040104f, 0.21726032f, 0.45723233f, 
    -0.38810626f, -0.27743453f, -0.21409234f, -0.02537172f, 0.03274608f, 0.13382098f, -0.01211362f, 0.18217449f, 
    0.57355905f, -0.44091976f, 0.59733629f, 0.18573084f, 0.01501484f, -0.31145465f, 0.20518352f, 0.14283045f, 
    0.17086393f, 0.11622100f, -0.01399855f, 0.12938322f, -0.10335587f, 0.13176860f, 0.25710297f, 0.03900718f, 
    -0.18366838f, 0.01412424f, -0.53193057f, 0.16177276f, 0.03250371f, -0.23305501f, -0.06226440f, -0.04742390f, 
    0.11409224f, 0.27920848f, 0.39126572f, -0.36405206f, 0.17328973f, -0.05683901f, 0.13837244f, -0.06038519f, 
    0.12903692f, 0.10164269f, -0.10596447f, -0.07125461f, -0.20471321f, 0.04849612f, 0.01194155f, 0.17408001f, 
    -0.36291644f, 0.00029561f, 0.23682046f, -0.52666074f, -0.07209419f, -0.06024202f, -0.11307824f, -0.04633111f, 
    -0.06826554f, -0.19223157f, 0.34711164f, 0.07281357f, 0.00504323f, -0.09817991f, -0.09165567f, -0.55126631f, 
    0.24403286f, -0.07970861f, -0.13123861f, -0.33559093f, -0.06326175f, 0.06889224f, -0.02553073f, 0.09697364f, 
    0.30525735f, 0.09146281f, -0.31993553f, 0.02311863f, -0.02558547f, 0.05732805f, 0.34158170f, 0.17400017f, 
    0.31074178f, -0.00926248f, -0.04683792f, 0.25784972f, 0.17074864f, 0.04916156f, -0.25027493f, 0.08522473f, 
    -0.04842179f, 0.38408732f, 0.00441695f, 0.14866573f, 0.62572062f, -0.23730528f, 0.18488412f, 0.05425715f, 
    -0.07307576f, -0.05094356f, -0.03061826f, -0.07418374f, -0.33702913f, 0.12433597f, 0.01199173f, -0.05944047f, 
    -0.49427634f, -0.20468560f, 0.09467582f, -0.05747202f, 0.26965109f, 0.15909082f, -0.96686423f, 0.48716101f, 
    0.24023686f, 0.36356527f, 0.05950134f, -0.01549690f, 0.07493262f, -0.21354856f, 0.10530298f, -0.06722883f, 
    -0.19840297f, -0.13190103f, -0.02493100f, 0.28531560f, 0.07358612f, -0.07021990f, 0.26723841f, -0.24807604f, 
    -0.09991302f, -0.23406383f, -0.16826223f, 0.04371026f, -0.65995270f, 0.09877539f, 0.17616086f, 0.13040543f, 
    0.28746215f, -0.10031769f, 0.37678203f, -0.00066732f, 0.05159543f, 0.01534681f, 0.27324316f, 0.05838178f, 
    0.04043178f, 0.15460831f, -0.00134429f, 0.00331253f, 0.15634057f, 0.08225502f, 0.18177307f, -0.03896149f, 
    -0.41024575f, 0.04801963f, -0.03817128f, 0.10459390f, 0.16863447f, -0.24524195f, 0.14919049f, -0.06041705f, 
    0.07052573f, 0.30100849f, 0.21650708f, -0.07128113f, 0.15805505f, 0.04008213f, 0.07182500f, -0.22515453f, 
    0.07733298f, 0.04055423f, -0.17010084f, -0.03367035f, 0.03391369f, 0.00546215f, -0.16446315f, 0.01629478f, 
    -0.00745969f, 0.11613353f, 0.30521947f, -0.04083484f, -0.09075944f, -0.04635647f, -0.08634184f, 0.01526682f, 
    0.02353813f, -0.02018525f, 0.07361419f, 0.13033630f, 0.05706865f, -0.10721901f, -0.11888083f, -0.28844762f, 
    0.16938224f, -0.08965500f, -0.02339888f, -0.28032988f, -0.18124281f, 0.01774685f, -0.06285122f, 0.10780376f, 
    0.11012013f, 0.07645676f, -0.02011195f, -0.04360545f, -0.14362749f, 0.02192816f, -0.11723250f, 0.24863492f, 
    0.09757335f, -0.32494864f, 0.06035819f, 0.12814596f, 0.11990534f, 0.09121262f, -0.30527627f, -0.00365094f, 
    -0.00038121f, 0.12069531f, -0.04900468f, -0.27372962f, 0.14653677f, -0.31212589f, 0.16238248f, 0.20822439f, 
    -0.00012521f, 0.07489366f, 0.04462375f, -0.01036714f, -0.03886634f, 0.10030467f, -0.00436638f, -0.02350751f, 
    -0.17460720f, -0.33688968f, 0.22507137f, 0.06975977f, 0.24784467f, 0.19558302f, -0.42255026f, 0.01999372f, 
    0.09708115f, 0.08850452f, 0.06176857f, 0.00125964f, 0.20176467f, -0.33746389f, -0.48859996f, 0.03295958f, 
    -0.15553768f, -0.07825404f, -0.11858828f, 0.06148089f, 0.07266565f, 0.08439095f, 0.21015058f, 0.06998898f, 
    -0.01110390f, -0.05556985f, 0.08257380f, -0.00679585f, -0.01438121f, -0.08177645f, -0.07976420f, 0.01356577f, 
    0.03967210f, -0.06358509f, -0.07632711f, -0.01642911f, -0.08571379f, -0.01591366f, -0.01296765f, 0.01024535f, 
    -0.02605354f, -0.00217396f, 0.03639761f, -0.06435245f, -0.04929252f, -0.06413302f, -0.04197245f, 0.06903750f, 
    -0.06105967f, -0.04358433f, -0.00707359f, -0.09026714f, 0.05917823f, 0.00319590f, 0.05050064f, -0.01237270f, 
    -0.03274164f, -0.03685072f, -0.00865429f, -0.06710953f, 0.04982632f, -0.06147446f, -0.07417917f, 0.05729963f, 
    -0.01699252f, 0.01323300f, 0.05032883f, 0.03325713f, 0.02273049f, -0.07167647f, 0.02985828f, -0.08415127f, 
    -0.06237679f, -0.05475868f, -0.08860339f, 0.06379347f, -0.00636056f, -0.08334298f, -0.04187330f, 0.06973976f, 
    -0.09015397f, -0.05761812f, -0.04349303f, 0.01147609f, -0.06734218f, 0.00008153f, -0.03519388f, 0.01236209f, 
    -0.05109958f, -0.09496691f, 0.05671064f, 0.08063146f, -0.02302844f, 0.04827407f, -0.09601697f, -0.07339294f, 
    0.06351996f, 0.00792155f, -0.00554502f, -0.03813621f, 0.04175262f, 0.06319585f, -0.02660811f, 0.00529665f, 
    -0.09284370f, -0.07827539f, 0.03315736f, -0.01876142f, -0.01756121f, -0.04805038f, -0.06535447f, -0.00736129f, 
    0.01699656f, -0.10544188f, -0.09393832f, -0.03063537f, 0.06991101f, -0.04303463f, -0.04876836f, -0.08747333f, 
    -0.03027256f, -0.06630327f, 0.05841827f, 0.05331922f, -0.04380639f, -0.05288839f, -0.03066125f, 0.04094558f, 
    0.00828145f, -0.00956261f, -0.03544800f, -0.07943475f, 0.00733734f, -0.02176487f, -0.08005113f, -0.02004272f, 
    0.02583048f, -0.03817052f, 0.01699924f, 0.05835933f, -0.08317096f, 0.00117449f, -0.07870667f, 0.05236932f, 
    -0.05938666f, 0.03494139f, 0.03761534f, 0.00663879f, 0.02317934f, -0.04498060f, -0.06574950f, 0.01248283f, 
    0.06100265f, -0.17381801f, -0.05031625f, -0.05994100f, -0.36364749f, 0.14846517f, 0.10569949f, 0.08321504f, 
    -0.40817824f, 0.40047294f, -0.02846686f, -0.14884950f, 0.01786336f, 0.16829185f, -0.14906856f, 0.08533249f, 
    0.07327227f, -0.25753990f, -0.00379663f, -0.09827641f, 0.30048656f, -0.33495140f, -0.05117163f, 0.08388344f, 
    0.21049732f, 0.06120650f, -0.15373775f, -0.09150933f, -0.09893876f, -0.03030502f, 0.22066242f, 0.04615026f, 
    0.01240779f, -0.39856723f, -0.14899220f, 0.19680712f, 0.43679187f, -0.03380086f, -0.19660169f, 0.10280292f, 
    0.09086064f, 0.13879213f, -0.11793913f, 0.22135729f, 0.09940388f, -0.03102350f, 0.00260923f, 0.09239010f, 
    -0.04596293f, 0.00519759f, -0.36593595f, 0.32855353f, -0.15435296f, 0.07361294f, 0.11103760f, -0.08499449f, 
    0.18542299f, 0.29583269f, 0.01006922f, -0.32310840f, 0.35644925f, -0.34093916f, 0.13854179f, 0.43852079f, 
    0.27377486f, 0.22662862f, 0.28969935f, 0.11105907f, -0.13652709f, -0.16525228f, 0.10706376f, 0.27466112f, 
    0.15063943f, 0.17709784f, 0.42267567f, -0.03553946f, -0.05808046f, 0.06690207f, 0.35463426f, -0.05335265f, 
    0.35485134f, -0.05524465f, -0.07841045f, -0.16083333f, 0.04200293f, 0.06182743f, -0.28023055f, -0.03294097f, 
    -0.00143280f, -0.38154587f, -0.07302099f, 0.06135844f, -0.41761377f, -0.47423956f, -0.12770908f, -0.05329295f, 
    -0.08663975f, 0.08109896f, 0.02125629f, 0.51470149f, 0.20557405f, -0.04869844f, -0.17848545f, 0.08108038f, 
    0.14425513f, -0.00475950f, -0.30746067f, -0.08893085f, -0.25276414f, 0.04904091f, 0.09662731f, 0.10582150f, 
    -0.11774738f, -0.22992724f, 0.09821790f, -0.04149106f, 0.04870234f, 0.08741614f, -0.13277885f, -0.28089646f, 
    0.37314463f, 0.21448807f, 0.01845468f, -0.02207906f, -0.13711745f, -0.00736401f, -0.13045131f, -0.13856667f, 
    -0.18522386f, -0.33365086f, 0.04090463f, -0.02783352f, -0.43986800f, 0.07847702f, 0.18227233f, -0.05774472f, 
    -0.00159189f, 0.07869464f, 0.13271424f, -0.61903608f, -0.06945477f, -0.55662590f, 0.04660040f, -0.07271254f, 
    0.15117393f, -0.17926040f, -0.07850700f, 0.07285804f, -0.06657930f, -0.03582033f, 0.20516717f, 0.08706438f, 
    0.30359033f, 0.10878571f, -1.10530317f, 0.15091927f, 0.05460564f, -0.86603957f, 0.23724195f, -0.05328662f, 
    0.12238284f, -0.19199646f, 0.22726995f, 0.03871277f, -0.14710368f, 0.04356293f, -0.49026126f, -0.04211137f, 
    -0.10117564f, 0.07728565f, -0.33957994f, 0.40634489f, -0.13271807f, 0.02614421f, 0.14977647f, 0.06759030f, 
    0.04945615f, 0.11134242f, 0.17835367f, -0.00075969f, -0.37380677f, 0.04241066f, -0.36901867f, 0.12492871f, 
    0.07501544f, 0.03953363f, 0.10249459f, -0.37607729f, 0.12618165f, -0.26877996f, 0.01268222f, -0.23331115f, 
    0.03743576f, 0.01358850f, -0.07172598f, -0.13885537f, -0.19313347f, -0.04629758f, 0.03017575f, -0.14167507f, 
    0.06102587f, 0.14721934f, 0.08189920f, -0.07039185f, 0.11342008f, -0.06929214f, 0.08003789f, 0.01642719f, 
    0.22013704f, -0.27839267f, -0.05528763f, 0.15136282f, 0.20764348f, 0.02966427f, -0.35509413f, 0.33918050f, 
    -0.26178303f, -0.08268418f, -0.42410675f, -0.04992869f, 0.19906808f, -0.35934353f, 0.08533005f, 0.02188411f, 
    -0.07360968f, 0.08413349f, -0.05765641f, 0.01094961f, 0.08290309f, 0.09884322f, -0.45020390f, 0.00993228f, 
    0.06582296f, -0.20954981f, -0.07416002f, 0.06182485f, -0.00023128f, 0.13741137f, -0.24754700f, 0.18160580f, 
    0.14883024f, -0.01153114f, 0.07220919f, -0.04191364f, 0.16494942f, 0.26282796f, 0.30778828f, -0.23588945f, 
    -0.02700682f, 0.04288709f, -0.07418542f, 0.20279382f, -0.29892755f, 0.08363032f, 0.09760622f, -0.30942219f, 
    -0.05288468f, -0.06770495f, 0.00148242f, 0.06352788f, 0.02881388f, 0.04006517f, 0.07237236f, -0.01832085f, 
    -0.08708638f, -0.08192565f, -0.07491649f, 0.02780651f, -0.05412627f, 0.08330259f, -0.10029202f, 0.07986747f, 
    -0.02092599f, -0.00956478f, 0.00255307f, 0.01118036f, -0.00182770f, 0.02694924f, -0.05279280f, -0.10177012f, 
    -0.08164518f, -0.10715835f, 0.03959843f, -0.06803329f, -0.07168812f, 0.06885934f, 0.02368263f, -0.08123946f, 
    -0.05305517f, -0.00668565f, -0.09960700f, 0.02147751f, -0.00835732f, -0.06752758f, 0.05971648f, 0.01192414f, 
    0.04247982f, -0.04807972f, 0.04209809f, -0.01730832f, -0.05257415f, -0.06877881f, -0.09418909f, -0.01025554f, 
    0.04906783f, 0.01903420f, 0.02730466f, -0.01091333f, -0.06384321f, -0.04599981f, -0.04663676f, -0.00695681f, 
    0.02839143f, -0.06191155f, 0.03368930f, -0.10036522f, 0.06502808f, 0.00379916f, -0.05858390f, -0.08659267f, 
    0.07179914f, -0.07512005f, -0.03589743f, 0.01506161f, -0.07244916f, 0.00559676f, -0.03137122f, -0.04820331f, 
    0.03833027f, 0.06922230f, 0.05966929f, -0.09606257f, -0.00051775f, 0.05698918f, -0.00082987f, -0.03074535f, 
    -0.02937092f, -0.04264224f, -0.11258021f, -0.08580348f, -0.05448595f, 0.00502501f, -0.05662008f, -0.04257201f, 
    0.00958733f, -0.10270710f, 0.01831657f, -0.03139210f, 0.01988262f, 0.00706290f, 0.05661420f, -0.07116462f, 
    0.08819202f, -0.08175342f, -0.04813878f, -0.04305546f, 0.05366408f, -0.05071240f, -0.00873358f, -0.05100513f, 
    -0.01553343f, 0.04052545f, 0.03684375f, 0.02808667f, -0.01655985f, -0.03298668f, -0.10963883f, 0.01618474f, 
    -0.02411166f, -0.11097102f, -0.06568590f, -0.02261520f, 0.00972335f, -0.01474240f, -0.03878928f, 0.02691590f, 
    -0.09050433f, -0.01211829f, 0.02965413f, -0.10207108f, 0.00691929f, -0.08400705f, -0.09121355f, 0.03075253f, 
    -0.15137200f, 0.45562640f, -0.11112482f, -0.00087176f, -0.32469398f, -0.06452024f, 0.24709533f, -0.31459287f, 
    -0.35305044f, 0.03116301f, 0.29884219f, 0.10531396f, 0.14669646f, 0.04222182f, 0.17157628f, 0.05032814f, 
    -0.07322887f, 0.07349084f, 0.06392542f, -0.11981086f, 0.03514630f, 0.11223089f, 0.34142008f, 0.01715128f, 
    0.02079329f, -0.08403652f, -0.35148954f, -0.04551966f, -0.00189869f, -0.04290019f, 0.22454315f, -0.08930189f, 
    -0.05698825f, 0.05206653f, 0.03990661f, -0.02818319f, 0.04643993f, 0.04128842f, 0.05701763f, -0.20589219f, 
    0.00551000f, 0.16907692f, 0.25114831f, 0.59093922f, -0.02960610f, -0.00604850f, 0.02943242f, 0.25997198f, 
    -0.17903587f, 0.06607835f, -0.07387945f, -0.02352760f, 0.02515633f, -0.03253349f, 0.17770292f, -0.05751218f, 
    0.28144240f, 0.07480522f, -0.18803196f, 0.18404584f, 0.12158538f, 0.16835354f, 0.34050843f, 0.37746033f, 
    -0.01464654f, -0.24510878f, 0.23861030f, -0.11161799f, -0.06160862f, 0.00403501f, 0.14259537f, 0.04917680f, 
    -0.08296644f, -0.17561729f, 0.17085382f, 0.27211496f, 0.33398944f, -0.03341191f, -0.41753009f, 0.21110322f, 
    0.16729489f, -0.13889392f, -0.02394553f, 0.18908520f, -0.12906078f, -0.11815827f, 0.28084472f, 0.56882310f, 
    -0.18459073f, -0.25958616f, 0.08982757f, -0.11743193f, -0.38490176f, 0.53927606f, 0.25297394f, -0.08830311f, 
    0.02934378f, 0.00123355f, 0.08078387f, 0.12338413f, 0.03888136f, 0.18696742f, 0.01459826f, -0.08026736f, 
    -0.19859233f, -0.67680544f, 0.07575578f, 0.13170090f, -0.28891656f, 0.01303355f, -0.08771762f, -0.02260967f, 
    0.11731225f, -0.00119371f, -0.10009571f, -0.04490712f, -0.11614712f, -0.28277931f, -0.12456171f, 0.11548289f, 
    0.18439287f, 0.04845280f, 0.05233543f, -0.20373632f, 0.04329836f, -0.07372746f, 0.19168070f, 0.04207435f, 
    -0.07025938f, -0.46007159f, -0.33208832f, 0.02972156f, -0.42109400f, -0.06258236f, 0.14310332f, -0.43610442f, 
    0.26354194f, 0.18855663f, -0.26663911f, -0.22359665f, 0.03860422f, -0.02486361f, 0.08972197f, -0.27141041f, 
    -0.04199540f, 0.09757657f, -0.05033432f, -0.37217343f, 0.09546574f, 0.07859847f, 0.14060341f, -0.07973139f, 
    0.13274650f, 0.10650860f, -0.11607487f, -0.30599892f, -0.43227702f, -0.36830962f, 0.26486409f, 0.08191225f, 
    -0.08051855f, -0.35694325f, 0.00122095f, 0.03002195f, 0.26563710f, 0.02040646f, -0.48466638f, 0.01752478f, 
    -0.01391597f, 0.08324715f, 0.09111080f, 0.02954854f, 0.05270683f, -0.11722820f, -0.00288973f, 0.08742481f, 
    0.08931214f, 0.10387594f, 0.09600795f, 0.21480943f, 0.00328289f, -0.02409013f, 0.16912031f, 0.08410270f, 
    0.35192502f, 0.07644822f, -0.22580357f, -0.20674381f, 0.11205690f, 0.06660309f, 0.05169091f, 0.39374843f, 
    0.15974846f, -0.05198458f, 0.00652033f, -0.00182429f, -0.30106851f, 0.11064100f, 0.07248908f, 0.26808611f, 
    -0.02312280f, -0.06220078f, 0.20973392f, 0.13147616f, 0.12428162f, 0.08377239f, -0.10979091f, -0.20329922f, 
    -0.00481476f, 0.12778422f, -0.05685376f, 0.01859881f, -0.13291427f, -0.20592533f, -0.18931662f, 0.19263163f, 
    0.09987546f, -0.40328282f, -0.04544973f, -0.28762981f, -0.22063191f, -0.13586113f, -0.28669474f, -0.12570685f, 
    -0.05775431f, -0.03899742f, 0.07627127f, 0.03370234f, 0.19455397f, 0.09918445f, 0.25602603f, 0.06144191f, 
    -0.14692348f, -0.37028760f, 0.13124084f, 0.13149421f, -0.53365260f, -0.05722497f, 0.26140651f, 0.04068080f, 
    -0.49997154f, -0.67948717f, -0.02353627f, 0.07913657f, -0.08339552f, 0.05633569f, 0.31572494f, -0.07004283f, 
    0.07668847f, -0.09995604f, 0.10829353f, -0.01753276f, 0.25836453f, -0.05962027f, -0.16079286f, -0.38878340f, 
    -0.05234031f, -0.08698942f, -0.03915230f, 0.01120501f, -0.07627213f, 0.01508218f, -0.00735501f, -0.03371723f, 
    0.01129537f, 0.01192857f, -0.00805412f, -0.08844034f, -0.10794999f, 0.05000627f, 0.03005740f, -0.08632273f, 
    -0.02234494f, -0.10405193f, -0.06012367f, -0.09313279f, 0.02341204f, 0.02670378f, 0.05083569f, -0.01959451f, 
    0.02506238f, 0.01706963f, 0.06781603f, -0.02975329f, -0.00993240f, 0.07627101f, 0.02327560f, 0.02932305f, 
    -0.04928826f, 0.01324250f, 0.06212893f, 0.00259388f, 0.02913281f, 0.04602366f, 0.01764364f, -0.04316479f, 
    0.07148512f, 0.01187978f, -0.06859217f, 0.06264427f, -0.04338525f, -0.03431342f, 0.06044994f, -0.03149869f, 
    -0.07399239f, -0.01247947f, 0.05103244f, -0.03954634f, -0.10737199f, -0.02067527f, -0.00924319f, -0.13078436f, 
    -0.03507514f, 0.03161593f, 0.10143354f, -0.08588818f, -0.00264504f, 0.06267670f, 0.02751879f, 0.08340560f, 
    -0.09242443f, 0.03204352f, -0.01510421f, -0.13789365f, 0.04098321f, -0.12253691f, -0.07475641f, -0.01578904f, 
    -0.05336000f, -0.01611373f, -0.08945594f, 0.02798438f, -0.03817672f, -0.08521818f, -0.01748449f, 0.03032253f, 
    -0.09187764f, -0.11678370f, -0.07030019f, 0.00392914f, -0.08896323f, 0.02579867f, -0.08680276f, -0.04890102f, 
    0.03636053f, -0.05229004f, -0.06275587f, 0.01668127f, -0.09361753f, 0.05842600f, -0.05906577f, -0.02509570f, 
    0.07635164f, -0.01112397f, -0.08625993f, 0.04076476f, -0.07292831f, 0.00800389f, -0.08805592f, -0.02650232f, 
    0.04393120f, 0.01531182f, -0.01208672f, -0.07952729f, -0.07141723f, -0.05102527f, 0.03888655f, 0.01578283f, 
    -0.06997376f, 0.01571831f, 0.00484415f, 0.06835763f, -0.04835526f, -0.00895621f, 0.03969359f, -0.04193478f, 
    -0.01803344f, -0.07205823f, -0.10885473f, -0.04635813f, -0.03337901f, -0.04308339f, -0.05508396f, -0.03168929f, 
    -0.11440559f, 0.73103768f, -0.14964613f, -0.00643281f, 0.22027932f, 0.01856045f, -0.42451259f, -0.09395861f, 
    0.15404245f, -0.86021137f, -0.25860909f, 0.66333455f, 0.47602516f, -0.42156154f, 0.18500602f, 0.00817118f, 
    0.14855435f, 0.27960429f, -0.04901582f, -0.08981019f, -0.21528050f, 0.15897056f, -0.14574769f, 0.18202065f, 
    0.10366701f, -0.13228969f, -0.26638806f, 0.13147788f, -0.02734382f, -0.58138078f, 0.04884428f, -0.07249081f, 
    -0.20735982f, 0.17629005f, -0.24875969f, -0.56164038f, 0.21849284f, -0.05086773f, 0.04855283f, 0.03705858f, 
    -0.10619601f, 0.11658562f, 0.25340509f, 0.15317172f, -0.07674194f, -0.03593630f, 0.35163912f, 0.22636321f, 
    -0.46583483f, -0.06661543f, -0.38788274f, -0.73006099f, 0.13896510f, 0.01616920f, 0.01469110f, 0.07062841f, 
    0.07111271f, -0.14157557f, 0.15688878f, 0.29491040f, -0.34590417f, -0.21106775f, -0.05717005f, -0.56925064f, 
    -0.09271911f, 0.20138450f, -0.00814973f, 0.05746119f, 0.08497424f, 0.24101642f, 0.26012588f, -0.22635789f, 
    0.32783604f, -0.18192106f, -0.40393534f, -0.28055999f, 0.11998041f, 0.04238892f, 0.11048315f, -0.21359701f, 
    -0.13010125f, 0.28087652f, 0.05342834f, 0.29019284f, -0.01828843f, -0.31973144f, 0.36391896f, -0.31572297f, 
    -0.05931948f, 0.21483572f, 0.33177182f, 0.23037264f, 0.61728668f, -0.18946266f, -0.05794169f, -0.02177374f, 
    -0.07793818f, -0.05602513f, 0.07446587f, -0.18365918f, -0.34769407f, 0.05487067f, 0.34755725f, -0.02732342f, 
    0.06038607f, -0.13792765f, 0.57050204f, 0.18308227f, -0.10213131f, -0.20452657f, -0.62345177f, 0.07067645f, 
    -0.22982223f, -0.12352040f, -0.21251218f, -0.07445616f, -0.14957009f, 0.31287083f, 0.76452106f, 0.12369484f, 
    -0.13328117f, 0.05806732f, 0.11877037f, 0.13805449f, 0.26873922f, 0.04547142f, 0.32301766f, -0.71973538f, 
    0.10060869f, -0.23981212f, -0.07928583f, -0.07597466f, -0.07148413f, 0.06857305f, -0.02833304f, 0.20689687f, 
    0.25854594f, -0.00217678f, 0.16653581f, 0.18632624f, 0.03143497f, -0.16270986f, 0.01175068f, 0.08889924f, 
    0.17821489f, 0.19947974f, -0.01165897f, 0.05512247f, 0.03035500f, 0.14640486f, 0.13440774f, 0.21881053f, 
    -0.11340121f, 0.04976049f, -0.04240270f, 0.02769509f, 0.00839200f, 0.01783994f, 0.00960942f, 0.05703920f, 
    -0.11640057f, 0.37493131f, 0.06208887f, -0.08685973f, -0.24081913f, -0.07850853f, 0.05746294f, 0.07673100f, 
    0.16156003f, 0.10688349f, -0.02914638f, -0.12982963f, 0.06974491f, -0.14557786f, 0.04253373f, 0.09299948f, 
    -0.18029928f, -0.09240886f, 0.01217154f, -0.06808066f, -0.06378128f, -0.01027802f, 0.16542244f, -0.13726720f, 
    -0.15122366f, 0.01180698f, 0.21875477f, 0.08873002f, -0.06884453f, 0.12498336f, -0.05943289f, 0.26266947f, 
    0.17192370f, 0.06367110f, 0.17557903f, 0.11757072f, -0.07639460f, -0.04305101f, -0.15329972f, 0.11102432f, 
    0.14851584f, 0.06153181f, -0.22765501f, 0.09533443f, 0.04919282f, -0.05682480f, 0.03699563f, -0.00364110f, 
    0.11126398f, 0.16193433f, 0.07009543f, 0.15606692f, 0.09344497f, -0.04003847f, -0.19966517f, -0.12627450f, 
    -0.16267739f, 0.21986632f, 0.09908362f, 0.17771660f, 0.21600744f, 0.08482375f, 0.11703850f, 0.14077803f, 
    -0.05285040f, 0.01911252f, 0.03933074f, 0.11265850f, 0.07898580f, -0.01947192f, 0.00792462f, 0.02580596f, 
    0.24523364f, -0.06191692f, 0.08139689f, 0.06811889f, 0.03869278f, 0.13057031f, -0.23874269f, 0.67818964f, 
    0.24862953f, 0.32527250f, 0.17785202f, 0.02085439f, 0.18378171f, -0.18407562f, 0.32472408f, -0.14611262f, 
    -0.24353981f, 0.08348516f, 0.18735203f, 0.16736183f, 0.03888927f, -0.00241331f, 0.21899335f, -0.03509458f, 
    -0.29886189f, -0.22468768f, -0.20858923f, 0.07577591f, -0.10007134f, 0.23104733f, 0.17957337f, 0.11590143f, 
    0.35251799f, 0.03001612f, 0.40798607f, -0.05192920f, -0.12603071f, -0.16510050f, 0.11109643f, 0.28347015f, 
    0.04221583f, 0.08563753f, -0.01229191f, -0.02573274f, 0.26800585f, -0.03553385f, 0.24142952f, 0.15570186f, 
    0.10123720f, 0.06245143f, -0.44320983f, 0.10696986f, 0.04276846f, -0.30279970f, 0.22706307f, -0.00411382f, 
    -0.00952574f, -0.13397637f, 0.32098022f, 0.05214363f, 0.19868185f, -0.02033896f, 0.13507560f, -0.06121966f, 
    0.28157151f, 0.10051576f, -0.28145951f, -0.01877435f, 0.06762474f, -0.06532045f, -0.18361445f, -0.07240141f, 
    -0.00956064f, 0.10310277f, 0.03840415f, 0.00938231f, -0.25264114f, -0.01306486f, -0.01007946f, 0.06677847f, 
    0.13507256f, 0.13826135f, 0.21548899f, -0.01056820f, 0.22574158f, -0.18400988f, -0.00678590f, -0.25550032f, 
    0.14705928f, -0.08797467f, 0.09460565f, -0.25952262f, -0.19559479f, -0.00050605f, 0.10755238f, 0.23517343f, 
    0.04700446f, 0.02213469f, 0.14918870f, 0.18120699f, -0.08678232f, 0.07119278f, 0.01821239f, 0.26806131f, 
    0.26011950f, -0.16660665f, -0.08361225f, -0.06869391f, 0.07084549f, 0.14291765f, -0.17862245f, 0.20022191f, 
    0.10532075f, 0.02690934f, 0.02434585f, 0.00181483f, 0.01025806f, -0.44762933f, 0.03592428f, -0.01555097f, 
    0.05234016f, 0.12249255f, 0.07663012f, 0.17010988f, -0.05441385f, 0.11632139f, -0.09570020f, -0.02611685f, 
    -0.32959703f, -0.15155762f, -0.07145564f, -0.00897531f, 0.14567630f, 0.22272202f, -0.42479143f, 0.71151030f, 
    0.04391691f, -0.01495734f, 0.04421265f, -0.06521458f, 0.11714385f, -0.04844154f, -0.07202605f, -0.10090869f, 
    -0.02929859f, 0.15619017f, -0.02389283f, 0.12435620f, -0.06755123f, -0.05970681f, 0.19829828f, -0.04857901f, 
    -0.12033885f, 0.03516098f, -0.09808300f, 0.04834241f, -0.05619229f, -0.04337232f, -0.26614201f, 0.01270120f, 
    0.16545002f, -0.19403872f, -0.18360983f, 0.18373002f, -0.01516849f, -0.29149392f, 0.16986237f, 0.21244924f, 
    0.09015647f, -0.05128598f, 0.01423738f, 0.15530838f, -0.23692602f, 0.06444158f, -0.33294588f, 0.17295063f, 
    0.13774528f, -0.10062303f, 0.04768759f, 0.14807665f, -0.05912125f, -0.08074371f, -0.00958640f, 0.03352777f, 
    0.12872291f, -0.08485560f, -0.01232163f, -0.02830468f, -0.28794670f, 0.06872446f, -0.07803228f, 0.16740339f, 
    -0.12409867f, 0.12070489f, 0.23722680f, -0.09029422f, -0.02894104f, 0.23206802f, 0.22759740f, 0.18092537f, 
    -0.02992989f, 0.07142651f, -0.25696939f, -0.09211218f, 0.10853602f, 0.06400143f, 0.01658851f, 0.35189790f, 
    0.14754373f, -0.16086806f, 0.02756484f, -0.05298384f, -0.09915562f, -0.28228495f, -0.02519109f, -0.22433147f, 
    -0.33158708f, 0.22855408f, -0.10512375f, 0.15609224f, 0.07908577f, 0.11693089f, 0.11835466f, -0.27699873f, 
    -0.19058277f, 0.05160429f, 0.08749287f, -0.09500791f, 0.02506905f, 0.09210026f, -0.05127701f, -0.04182394f, 
    -0.19944890f, 0.19486225f, 0.07418537f, 0.23726173f, 0.15043400f, 0.07247090f, 0.11686098f, -0.12391683f, 
    0.02327127f, 0.11627915f, 0.27382508f, 0.24292158f, 0.41991252f, 0.42418364f, -0.09260426f, 0.22255957f, 
    -0.01664081f, -0.03965553f, -0.01954180f, -0.34549227f, 0.01482293f, 0.20111547f, 0.15172215f, 0.05333055f, 
    0.09162040f, 0.05688865f, 0.12246574f, 0.08678454f, -0.04387286f, -0.20187549f, 0.14333379f, 0.23976916f, 
    -0.05274088f, 0.11100686f, 0.06986646f, -0.00161578f, 0.08342626f, 0.02272605f, 0.23302400f, -0.01808282f, 
    0.11574472f, 0.05021045f, 0.16112851f, 0.24001543f, 0.14734107f, 0.03097162f, -0.16122526f, -0.59028298f, 
    -0.04835824f, -0.03609740f, -0.06933634f, -0.02600964f, -0.00647637f, -0.01231236f, -0.05697644f, -0.09178876f, 
    -0.07429147f, -0.08249975f, 0.04372467f, -0.07619146f, 0.01955166f, -0.03978289f, -0.06387205f, -0.02516269f, 
    -0.03771698f, 0.07666568f, 0.03602732f, -0.10759915f, -0.09474929f, -0.05573457f, -0.05780178f, -0.01898272f, 
    -0.03763733f, -0.07565521f, -0.03921186f, 0.05567404f, -0.01289920f, 0.00733535f, 0.01551755f, 0.07795770f, 
    0.06407478f, 0.01578411f, -0.02938431f, -0.04217547f, 0.00030122f, -0.00107528f, -0.08112125f, -0.07633258f, 
    -0.00649283f, 0.02587890f, -0.04842715f, -0.06523209f, -0.07855643f, -0.03425502f, -0.01243058f, 0.02030020f, 
    0.00362579f, -0.02218775f, -0.07821283f, -0.06181716f, -0.07819422f, -0.05883423f, -0.03990821f, 0.02108925f, 
    0.01199824f, -0.07484223f, 0.03213999f, -0.00761457f, -0.06137405f, 0.05413349f, 0.00178861f, 0.08571969f, 
    0.06817224f, -0.03800213f, 0.01771432f, 0.05284518f, 0.00867494f, -0.05181987f, -0.02204981f, -0.02736175f, 
    -0.09678104f, 0.01974218f, -0.05438145f, 0.07694736f, -0.07422522f, 0.01993573f, 0.00159248f, -0.00508471f, 
    0.05339551f, -0.01716174f, 0.02382481f, 0.00321502f, 0.03081840f, -0.07362041f, 0.03625584f, 0.00933999f, 
    -0.08589854f, 0.00484259f, -0.06789652f, 0.01052422f, -0.07082367f, -0.08370563f, -0.04453631f, -0.06661619f, 
    0.04205620f, 0.08518959f, -0.06474935f, -0.04740710f, -0.05356093f, -0.05088834f, -0.02152242f, -0.06303246f, 
    0.00279420f, 0.05868617f, 0.02436345f, -0.01533389f, -0.06970751f, 0.01041039f, -0.03679384f, 0.00706924f, 
    -0.01523743f, -0.08699030f, -0.10291483f, -0.01543576f, 0.04554458f, 0.05842056f, 0.03750015f, 0.02373683f, 
    -0.01669823f, -0.07099464f, 0.07224919f, -0.00954161f, -0.05504737f, 0.05504337f, 0.05727361f, 0.01404235f, 
    -0.08770473f, 0.01111101f, -0.09794181f, 0.06500343f, -0.01294470f, -0.02811104f, -0.10832289f, -0.10483520f, 
    -0.04681014f, -0.04066738f, -0.10938174f, -0.10908723f, 0.07509756f, 0.00255954f, -0.05727215f, -0.01661734f, 
    -0.04554439f, -0.03534340f, 0.07906295f, -0.03153527f, -0.00007128f, -0.02724661f, -0.07404780f, -0.06052382f, 
    -0.04444182f, -0.00097158f, 0.03650241f, -0.04555677f, -0.05483820f, 0.00423273f, -0.00387550f, 0.08676238f, 
    -0.09706186f, -0.01219476f, -0.05218232f, -0.09867959f, -0.05090259f, 0.05572850f, -0.03646315f, -0.07024878f, 
    -0.08664977f, 0.04793629f, -0.06862960f, -0.10895944f, -0.06733194f, -0.02803764f, -0.01876750f, -0.04503331f, 
    -0.06987377f, -0.04297605f, -0.02320036f, -0.08635044f, 0.04136473f, -0.05924508f, -0.11762047f, -0.11244632f, 
    -0.09911739f, -0.08355706f, -0.00207779f, -0.06207125f, -0.05780554f, -0.07078860f, -0.02287070f, 0.07110853f, 
    -0.04004938f, 0.01577834f, 0.04689483f, -0.00547249f, 0.01784910f, -0.09011956f, -0.11038779f, -0.06576978f, 
    -0.01714906f, -0.09319848f, -0.02661381f, 0.00913908f, -0.06426072f, -0.06898066f, 0.00211536f, -0.06521086f, 
    0.03227651f, -0.00322312f, -0.10281419f, -0.01596465f, -0.00611266f, 0.04946074f, 0.00124306f, 0.08369700f, 
    0.02653695f, -0.02188443f, 0.02297810f, 0.02579445f, 0.00715202f, -0.01482477f, -0.05703828f, -0.06315855f, 
    0.00287033f, -0.03244360f, -0.06621870f, -0.01945965f, 0.05665796f, 0.04883437f, -0.07212194f, -0.06065160f, 
    -0.03604805f, -0.06038203f, 0.03735185f, -0.04873388f, -0.02424290f, -0.08016269f, -0.04667385f, -0.04312812f, 
    0.00657033f, 0.03234731f, -0.03287069f, 0.01140277f, 0.04094475f, 0.01694127f, 0.02873209f, -0.01388457f, 
    -0.03103350f, 0.03996394f, -0.06146514f, -0.04771487f, -0.02609304f, 0.08468058f, 0.05110461f, 0.06882919f, 
    0.20506583f, -0.34568962f, 0.38122240f, -0.03593365f, 0.46496287f, 0.01727484f, -0.07334907f, 0.15121490f, 
    -0.36704916f, 0.11055666f, 0.03058856f, 0.06973061f, -0.08408043f, -0.11932344f, 0.10057465f, 0.18293945f, 
    0.16340069f, 0.03747193f, -0.01601527f, -0.00446707f, 0.16232036f, -0.08295140f, 0.04508718f, 0.15744953f, 
    0.31024325f, 0.15855409f, -0.53115886f, 0.00516997f, -0.02666453f, 0.11431105f, 0.02970203f, -0.02807044f, 
    -0.13199730f, -0.07422996f, -0.00387716f, -0.05466811f, 0.16540717f, 0.05246050f, -0.02967407f, 0.03145866f, 
    0.07158624f, 0.04815265f, -0.09600213f, 0.36972317f, 0.06148878f, -0.08555069f, 0.05341027f, -0.15720692f, 
    0.04424154f, -0.08672118f, -0.14636745f, -0.00422504f, -0.08970632f, -0.01184837f, 0.02233117f, -0.02534078f, 
    0.04318518f, 0.03521670f, 0.11051810f, 0.06101619f, -0.02680381f, -0.08662866f, 0.01350596f, 0.21498816f, 
    0.09816973f, 0.07397356f, 0.11037579f, 0.30888787f, 0.12841289f, -0.21712460f, -0.06166601f, -0.01671183f, 
    0.21949692f, 0.01445041f, 0.09964784f, 0.08805069f, 0.38717741f, 0.04473573f, -0.10191049f, 0.18908274f, 
    0.15598240f, 0.05246475f, -0.03764836f, -0.00675610f, 0.13912092f, 0.18131015f, 0.31780168f, -0.11236963f, 
    -0.00173266f, 0.04652439f, 0.04361592f, 0.30519271f, -0.18417327f, 0.14369883f, 0.07522997f, 0.01721080f, 
    0.02591067f, 0.04443461f, -0.06690462f, 0.10980229f, 0.00450112f, -0.10803249f, -0.08594296f, -0.03944638f, 
    0.13171853f, 0.34839642f, -0.16577134f, -0.03570550f, -0.04007245f, -0.07143729f, -0.17671123f, 0.27636588f, 
    0.13543534f, 0.04214760f, -0.00204369f, 0.05297288f, 0.04092994f, 0.32576409f, 0.19910823f, -0.07202786f, 
    -0.01511886f, 0.11764494f, 0.09769861f, 0.03357080f, -0.04942976f, 0.00752128f, 0.15051337f, -0.09926315f, 
    0.35397100f, -0.14574091f, 0.40806130f, 0.03236842f, 0.05693543f, -0.14072759f, 0.10041375f, 0.25056958f, 
    -0.18979007f, 0.01606505f, 0.02342299f, -0.09079137f, 0.08239038f, 0.20824270f, 0.01855710f, 0.08331996f, 
    0.09316684f, 0.27579588f, 0.03306215f, 0.06571691f, -0.00473373f, 0.04356305f, -0.00983659f, -0.27374685f, 
    -0.44757226f, 0.02929875f, 0.19572861f, 0.05107432f, -0.02413659f, -0.12844719f, -0.31067470f, 0.00898937f, 
    0.10484554f, 0.46566075f, 0.02099335f, 0.06185872f, -0.12084265f, 0.01101469f, 0.10306998f, 0.11491290f, 
    0.20067255f, -0.11528479f, 0.04945002f, -0.36821947f, 0.24430718f, -0.01333300f, -0.11510120f, -0.26532862f, 
    0.28801730f, -0.08472955f, 0.03429701f, 0.01745421f, 0.08629026f, -0.07104389f, 0.07699282f, -0.08056658f, 
    -0.39004228f, -0.09758513f, -0.03393241f, 0.04804868f, 0.01798612f, 0.18014394f, -0.24782762f, 0.57811165f, 
    0.19465466f, -0.09390575f, -0.00126827f, 0.08920103f, 0.01564294f, -0.01610840f, -0.18828569f, 0.22776876f, 
    0.20988801f, 0.02649989f, -0.17009299f, 0.10559461f, -0.19634317f, -0.03241954f, -0.19377773f, -0.02317319f, 
    -0.06481794f, 0.03439809f, 0.02977454f, -0.10545197f, -0.13684066f, 0.29939255f, -0.09142392f, -0.17762248f, 
    0.27031466f, 0.26692331f, 0.01255588f, -0.02078575f, -0.09141136f, 0.14450052f, -0.12290935f, 0.14226477f, 
    0.04870792f, 0.00980481f, 0.02520462f, 0.24807397f, 0.23452176f, -0.14642310f, 0.19549781f, 0.06396110f, 
    0.24860746f, 0.29525495f, -0.22950022f, -0.06679985f, 0.11950933f, 0.17307636f, -0.02206695f, -0.39439616f, 
    0.24359791f, 0.30870995f, 0.14013641f, -0.05342020f, 0.00693452f, -0.06356692f, -0.35857749f, 0.04921543f, 
    -0.12926747f, -0.13949081f, 0.12153446f, -0.03876133f, 0.22405110f, -0.02167636f, -0.08466535f, 0.43279457f, 
    0.03009449f, 0.07269026f, -0.07737046f, 0.07808275f, -0.50724858f, 0.11101595f, 0.04673870f, 0.14992581f, 
    0.12637199f, -0.00755552f, -0.04205576f, 0.08477808f, 0.08016904f, -0.00407551f, 0.05806604f, 0.17141595f, 
    0.18134312f, 0.10676162f, 0.08392243f, -0.11954334f, -0.05718810f, -0.02984203f, 0.02821543f, 0.20056789f, 
    0.03235750f, 0.14750651f, -0.12411792f, 0.03896644f, -0.11994278f, -0.10628780f, -0.06029016f, -0.03046769f, 
    -0.00115445f, 0.02203933f, 0.05181833f, 0.01770313f, -0.41276813f, -0.09512576f, -0.01012861f, 0.13610573f, 
    0.03730099f, -0.03974506f, 0.00638668f, -0.30800197f, 0.12076984f, 0.05695795f, -0.00310833f, 0.03936775f, 
    -0.20287156f, 0.00256630f, -0.23834887f, 0.16275142f, -0.11472464f, -0.00162505f, 0.19011864f, -0.00591545f, 
    -0.06537741f, 0.12035149f, 0.06073975f, -0.11127438f, 0.05460125f, 0.01514502f, -0.12609738f, 0.47119358f, 
    0.06897598f, 0.27208692f, 0.14239095f, 0.23798649f, 0.01696457f, -0.04033733f, -0.06361170f, -0.03161562f, 
    -0.14025366f, 0.10881817f, 0.01305320f, 0.04723358f, -0.15101829f, 0.04363091f, -0.09008124f, -0.01510467f, 
    0.20087405f, 0.11173557f, 0.06350529f, 0.02754270f, -0.00768210f, -0.26909250f, -0.19641177f, -0.02106068f, 
    -0.07534225f, -0.02500368f, 0.18416123f, 0.15700731f, 0.15864228f, 0.19424456f, -0.10922775f, 0.03150234f, 
    -0.07337864f, 0.02976800f, -0.03407506f, 0.05996920f, 0.24627161f, -0.13608171f, 0.07835080f, 0.07931812f, 
    0.41219670f, -0.11540987f, -0.02605635f, 0.05450204f, -0.11845770f, 0.18342032f, 0.07259633f, 0.54813492f, 
    0.16811965f, 0.19458863f, 0.17666590f, 0.03229424f, 0.13733143f, -0.22312839f, 0.20770201f, -0.09190322f, 
    -0.03917709f, 0.00891253f, 0.17988129f, 0.18279907f, 0.05383446f, -0.09730790f, -0.04662553f, -0.16222122f, 
    -0.13719800f, -0.17574942f, -0.11317507f, 0.02565523f, -0.03620312f, -0.15919162f, -0.03897206f, 0.03725027f, 
    -0.05489931f, -0.10843591f, -0.09126298f, -0.10295456f, -0.20428029f, 0.03347699f, -0.05966425f, -0.08148579f, 
    0.03799845f, -0.06170424f, -0.00602094f, -0.02557034f, -0.04419814f, -0.00030010f, -0.09159899f, 0.00487894f, 
    0.02218054f, -0.05412822f, -0.01397946f, -0.04545186f, -0.06238855f, 0.07074717f, 0.06227877f, -0.08069520f, 
    -0.00785979f, -0.09563448f, 0.05767742f, -0.06769126f, 0.05417080f, 0.07838744f, 0.09386532f, -0.07922690f, 
    -0.07420035f, -0.02106304f, 0.09553773f, 0.08296846f, -0.08614650f, 0.01221324f, -0.01691843f, -0.08648980f, 
    -0.12023292f, -0.02384663f, 0.07643609f, -0.13049823f, 0.04762842f, -0.06608237f, -0.16470847f, 0.02459529f, 
    -0.10116339f, -0.04601292f, -0.09339193f, -0.02629263f, -0.13904849f, 0.02060637f, -0.04767944f, 0.00038924f, 
    0.06178213f, -0.03629782f, -0.01898261f, -0.02657109f, -0.11026123f, 0.01206203f, 0.00849702f, -0.03583970f, 
    0.01107232f, -0.09496489f, 0.01612140f, -0.09345765f, 0.10084941f, 0.04778757f, -0.09748345f, -0.00695373f, 
    -0.01568215f, -0.15651992f, -0.09313907f, 0.05847671f, 0.01904669f, -0.16156404f, 0.01919299f, 0.01943211f, 
    -0.11335962f, -0.02753150f, -0.12862623f, -0.13678940f, -0.01876003f, 0.04074649f, -0.00462928f, -0.15969270f, 
    0.02711798f, -0.07635383f, -0.05520488f, -0.15973729f, -0.11979610f, -0.04308601f, -0.05470809f, -0.04662772f, 
    0.06552296f, -0.05695415f, -0.04176686f, -0.05583362f, -0.09557526f, 0.01678430f, -0.09078076f, 0.13406676f, 
    -0.02621500f, -0.06259549f, -0.13042234f, -0.06686302f, 0.01664029f, -0.04982048f, 0.08068147f, 0.01342002f, 
    -0.12475850f, -0.08108269f, -0.01959632f, -0.04976850f, 0.02782559f, 0.03278404f, 0.08329502f, -0.01700074f, 
    -0.32782716f, 0.40386894f, -0.25584251f, -0.00498606f, 0.05809847f, 0.05077265f, -0.05365042f, -0.04174389f, 
    0.11208493f, -0.20084743f, -0.32697582f, 0.11998374f, 0.35746133f, 0.35568026f, -0.22518502f, 0.33063918f, 
    -0.06312838f, -0.32850975f, 0.03537994f, -0.07944176f, 0.14206073f, 0.07980302f, -0.27335891f, -0.21208890f, 
    -0.26628277f, -0.05531335f, 0.11294553f, 0.03807744f, 0.02766134f, -0.02610569f, -0.12830821f, -0.05552906f, 
    0.14484292f, -0.17946041f, -0.20240735f, 0.19634470f, 0.13230647f, -0.05493154f, 0.16523831f, 0.12487241f, 
    -0.09889511f, -0.17159043f, 0.41049913f, -0.36758685f, 0.10323717f, 0.07199097f, 0.13176629f, 0.03534209f, 
    0.11686171f, 0.21216772f, -0.09127858f, -0.00821892f, 0.18251671f, 0.07102551f, 0.00966882f, 0.28469944f, 
    0.13653289f, -0.01687121f, -0.02514428f, 0.17469516f, 0.09175584f, 0.15188932f, 0.07932981f, -0.41728902f, 
    -0.19801511f, 0.15854508f, 0.05215115f, -0.06885500f, 0.20603280f, 0.37742305f, 0.33438915f, 0.11138013f, 
    -0.26982221f, -0.08762007f, -0.06633591f, -0.00373523f, -0.50310570f, -0.06811971f, -0.24112189f, -0.13501787f, 
    -0.26530096f, 0.03772243f, 0.14295892f, -0.13309893f, -0.06417737f, 0.15365930f, 0.17582898f, 0.22985448f, 
    0.24210173f, -0.08652199f, 0.24538422f, 0.33489561f, -0.07189620f, -0.21083270f, -0.07582632f, 0.13884792f, 
    0.07870736f, 0.09966748f, 0.08636288f, -0.06833722f, 0.02281831f, 0.32391977f, 0.01412291f, 0.03803765f, 
    -0.03730774f, -0.13408878f, -0.01599792f, -0.01691905f, 0.00517488f, -0.08036440f, 0.32975060f, -0.18372278f, 
    -0.19882368f, -0.04493742f, -0.14858063f, -0.01534518f, 0.09412777f, -0.15032887f, 0.38812944f, 0.16771132f, 
    0.41173255f, 0.08017617f, -0.09313347f, -0.02069253f, 0.14416888f, -0.01800583f, -0.09682573f, -0.25194085f, 
    0.22871421f, -0.01856570f, -0.06976932f, 0.04154693f, -0.17930000f, -0.36055347f, 0.19552001f, 0.12453850f, 
    0.15059507f, 0.17008138f, 0.03354788f, -0.29971123f, -0.16196717f, 0.14944495f, -0.05475311f, -0.24944346f, 
    0.08076134f, 0.12306173f, -0.00270151f, -0.04817606f, 0.10488823f, 0.13797152f, 0.19788800f, -0.27895373f, 
    -0.06712427f, 0.22186565f, -0.01005765f, -0.10039354f, -0.08611496f, -0.29409838f, -0.18503556f, -0.01356522f, 
    -0.09898667f, 0.19214234f, 0.14111531f, 0.18073501f, -0.26263708f, 0.04347626f, 0.21837342f, 0.00545365f, 
    0.21510105f, -0.26798144f, 0.05004819f, -0.50488526f, 0.09611711f, -0.07824659f, -0.32389370f, -0.30083656f, 
    0.33595940f, 0.00553698f, 0.32631454f, 0.10740475f, 0.20408896f, -0.01212908f, 0.08812314f, -0.11656972f, 
    -0.40405563f, 0.09968289f, -0.15855791f, 0.20712127f, -0.20861770f, 0.30937105f, -0.01441400f, -0.49070096f, 
    0.23841310f, -0.31588829f, -0.14188857f, -0.36213529f, -0.29027727f, 0.07688715f, -0.16690686f, 0.17037913f, 
    0.07628417f, 0.02070817f, -0.08877252f, 0.22590265f, -0.36717689f, 0.01826767f, -0.27468312f, -0.11790430f, 
    -0.20071200f, -0.19684531f, 0.11838305f, -0.18915358f, -0.36213800f, 0.20832659f, -0.27506125f, -0.39237446f, 
    0.02530609f, 0.15980464f, -0.15381610f, -0.24828067f, -0.09358057f, 0.39505339f, -0.05616299f, 0.12737322f, 
    -0.00677184f, -0.03101801f, 0.01734062f, -0.04961444f, 0.20284970f, 0.03794045f, 0.12017244f, 0.08219813f, 
    -0.28567821f, 0.11570185f, -0.13357298f, -0.06766549f, 0.14807552f, 0.23604082f, 0.12891315f, -0.36564192f, 
    -0.02673713f, 0.00419059f, 0.05479120f, -0.06860547f, -0.07669199f, 0.01572445f, -0.15776923f, 0.24691191f, 
    0.12398217f, -0.35134548f, -0.00285253f, -0.40085641f, 0.26910794f, 0.04517598f, 0.10872038f, 0.45591584f, 
    -0.02551535f, 0.62435609f, -0.03764698f, 0.08422979f, 0.34603405f, 0.09813088f, 0.00243598f, -0.21834441f, 
    0.03408477f, -0.34484372f, -0.01836999f, 0.26155940f, 0.28225181f, 0.13325557f, 0.16646664f, -0.21557292f, 
    -0.09852296f, 0.27779347f, 0.05982686f, 0.01824233f, -0.27331683f, 0.16341828f, 0.09024680f, -0.47898263f, 
    -0.29538989f, -0.24906582f, 0.23202212f, -0.22563203f, 0.16955279f, 0.22873583f, 0.03486225f, 0.07740942f, 
    -0.25994879f, 0.45715481f, 0.08318987f, -0.21642068f, -0.26265377f, -0.05624395f, 0.31561059f, -0.28459147f, 
    -0.04313603f, -0.07627957f, 0.09008148f, 0.16459449f, -0.35194105f, 0.02865869f, 0.08194163f, -0.19352111f, 
    -0.17623197f, -0.07532643f, 0.35022232f, 0.04634382f, 0.15568517f, -0.00648152f, 0.01449727f, -0.05308431f, 
    0.11327994f, -0.33382675f, 0.07242598f, 0.27902138f, -0.07939214f, 0.30885559f, 0.04315860f, 0.06840520f, 
    -0.00119689f, -0.08318430f, 0.08503234f, -0.03074481f, 0.19794816f, 0.15072212f, 0.06546231f, 0.22756518f, 
    -0.04597642f, -0.38223532f, -0.34396556f, -0.19480252f, -0.20120214f, -0.08307377f, 0.16147262f, 0.01606549f, 
    -0.24765874f, -0.15472528f, 0.09964711f, 0.06059012f, -0.42736247f, -0.29905152f, 0.66996068f, 0.78985494f, 
    -0.16051896f, 0.09179388f, 0.14859782f, -0.13382466f, 0.15210451f, 0.60902864f, 0.02564464f, -0.15624951f, 
    0.07492347f, -0.07949738f, 0.01394543f, -0.01287997f, -0.37584427f, 0.11579991f, 0.09657381f, -0.01943272f, 
    -0.53029245f, -0.21219438f, 0.25273943f, 0.09307732f, 0.30987179f, 0.42743587f, -0.10826946f, 0.02334215f, 
    -0.09711126f, -0.05674183f, -0.22883244f, 0.09238230f, -0.04719357f, -0.10984760f, -0.02814863f, 0.32663056f, 
    0.00261198f, -0.01057460f, -0.11787118f, -0.20866895f, -0.03811349f, 0.06631290f, 0.13707219f, 0.25616321f, 
    -0.03918318f, 0.02582720f, 0.02182224f, -0.07939771f, -0.00771931f, -0.02206170f, 0.01441472f, 0.06838411f, 
    0.00899042f, -0.07743365f, -0.09789812f, -0.05206566f, -0.04344779f, -0.00519159f, -0.06859112f, 0.02875637f, 
    -0.09188855f, 0.01259442f, -0.06068399f, -0.01638624f, 0.00017062f, 0.02398182f, -0.03437750f, -0.05697285f, 
    -0.02440875f, 0.04239335f, -0.05407746f, 0.04292893f, 0.01262105f, -0.01239107f, -0.00919949f, -0.06934787f, 
    -0.09928654f, -0.04770017f, -0.05700937f, -0.02295114f, 0.05912436f, 0.08416238f, -0.06221578f, -0.05857100f, 
    -0.06062717f, -0.07737301f, 0.02128525f, 0.04698847f, 0.06743830f, -0.03445358f, -0.06313387f, 0.06085194f, 
    -0.00975501f, -0.06189543f, -0.01508680f, 0.02291498f, -0.05229395f, -0.07311624f, -0.07864115f, 0.01616059f, 
    -0.08791601f, 0.05325864f, -0.03654211f, 0.07526165f, -0.01386618f, -0.01876586f, -0.01299327f, 0.00188631f, 
    0.04970166f, -0.08081577f, -0.03029350f, 0.04981088f, -0.08536556f, 0.07108768f, 0.03563480f, -0.00548264f, 
    0.02729937f, -0.03139556f, -0.04713303f, 0.05823700f, -0.03935565f, -0.02271048f, -0.06651434f, -0.01790162f, 
    -0.09742628f, -0.05296113f, -0.04167293f, -0.05035856f, -0.07785240f, -0.04121149f, -0.05464252f, 0.08725008f, 
    0.05463143f, -0.08531211f, 0.03314361f, 0.03374472f, 0.02769824f, -0.07328615f, 0.00218594f, 0.04190716f, 
    -0.08540062f, -0.08733334f, 0.05096338f, -0.08679687f, -0.07766392f, 0.03807452f, 0.04923102f, -0.07642194f, 
    -0.07939494f, 0.00328483f, 0.04436788f, -0.06691491f, 0.01661670f, -0.08147477f, 0.08836286f, 0.04177030f, 
    -0.06486706f, 0.01873443f, -0.05157806f, -0.00586982f, 0.06447049f, 0.00810324f, 0.08821621f, -0.04947122f, 
    -0.04593947f, -0.07524285f, 0.00323846f, -0.01269477f, -0.01398246f, -0.00388629f, -0.07114202f, 0.07040453f, 
    -0.11183105f, 0.51790917f, 0.26546088f, -0.03649022f, -0.34096590f, 0.26794124f, 0.21543394f, -0.10894081f, 
    -0.10018267f, 0.22007245f, 0.08299848f, -0.03139345f, 0.10372719f, -0.07697817f, 0.03458835f, 0.05203933f, 
    0.01706077f, -0.17459753f, -0.01101164f, -0.00642585f, 0.02593192f, -0.04777722f, 0.16612303f, -0.23985443f, 
    0.01852617f, 0.07592630f, -0.59692520f, 0.08945589f, 0.15286925f, -0.37307346f, 0.16673292f, -0.08758695f, 
    0.18915737f, -0.13512346f, 0.05669343f, 0.17159799f, 0.18675327f, -0.06697778f, -0.17246045f, -0.16879614f, 
    -0.20602368f, 0.07125619f, -0.06964630f, 0.17350398f, -0.03031066f, 0.13274032f, 0.10010391f, 0.11135071f, 
    -0.04769717f, 0.10163315f, 0.19744095f, 0.15050130f, -0.10409912f, 0.07190526f, -0.18790561f, 0.08073665f, 
    0.21467455f, 0.22246908f, 0.02737320f, -0.12635747f, 0.32182840f, -0.01281579f, 0.05780944f, -0.38553607f, 
    0.09079747f, -0.04479960f, 0.09458160f, -0.06427326f, -0.15221089f, 0.15749499f, 0.21579713f, 0.04266694f, 
    0.00549320f, 0.07270215f, 0.17738838f, -0.05369518f, -0.25904590f, 0.01963036f, -0.13078371f, 0.02783469f, 
    0.11395030f, -0.28864774f, -0.00674894f, 0.09483719f, -0.03693351f, 0.04356618f, -0.08328196f, 0.62568009f, 
    -0.10361632f, -0.21372110f, 0.01278485f, -0.15922105f, -0.00756251f, -0.18503314f, -0.02219256f, -0.01117513f, 
    0.06378853f, 0.10539041f, -0.08160999f, 0.06451821f, 0.15303351f, 0.14682892f, -0.13491736f, -0.08642837f, 
    0.14905556f, -0.28473777f, 0.16986990f, 0.15449050f, 0.15087117f, 0.28511071f, -0.03324407f, -0.03864728f, 
    -0.01103625f, -0.14599247f, 0.07404239f, 0.08410802f, 0.18804023f, 0.07384754f, -0.32819593f, 0.08388215f, 
    0.22483499f, 0.12123370f, -0.21225910f, 0.01340646f, -0.16479583f, -0.04515471f, 0.03592474f, -0.10883559f, 
    0.15636605f, -0.28646433f, 0.45599332f, -0.05036752f, -0.02027319f, 0.01767497f, 0.20454404f, -0.02803782f, 
    0.02249595f, 0.11333176f, 0.16459270f, -0.43631902f, -0.31859520f, -0.15393050f, -0.03412488f, 0.58029896f, 
    0.19258937f, -0.30659407f, 0.02528014f, 0.06371961f, 0.06499628f, -0.40799102f, 0.10925979f, -0.26915771f, 
    -0.29220030f, 0.02308875f, -0.93252838f, 0.16410257f, 0.29504687f, -0.86754256f, 0.13280284f, -0.06966323f, 
    0.23596078f, 0.33667827f, -0.10003165f, 0.08321559f, -0.19980104f, -0.01977934f, -0.42675495f, -0.32941362f, 
    -0.70324093f, 0.12201908f, -0.22371918f, 0.21440636f, -0.21714994f, 0.07933505f, 0.23768812f, 0.16410841f, 
    -0.02842526f, -0.10505912f, 0.02643051f, 0.19243126f, -0.55580896f, 0.01009450f, -0.74702793f, -0.17978100f, 
    -0.05964505f, 0.09120028f, 0.31763846f, -0.62095428f, 0.51911592f, -0.19017227f, -0.11254483f, 0.14844754f, 
    -0.00442761f, -0.06598414f, 0.19922623f, 0.17255989f, 0.19581875f, -0.42450109f, -0.11466482f, -0.35694563f, 
    0.10508871f, 0.18520691f, 0.19834565f, -0.41088024f, 0.17335451f, 0.00948187f, -0.15968613f, -0.00977440f, 
    0.12248578f, -0.48108405f, -0.10891327f, 0.10667834f, 0.16591485f, 0.14508851f, -0.60748821f, 0.03547111f, 
    -0.14930958f, -0.00153267f, -0.54347914f, 0.52863455f, 0.20794375f, 0.46711576f, -0.29930252f, 0.14462669f, 
    -0.07240958f, -0.01035805f, 0.02223610f, 0.26108578f, 0.03998164f, -0.14194366f, -0.65064621f, -0.07976782f, 
    0.58065027f, -0.11647166f, -0.02857007f, 0.06269012f, 0.16728035f, 0.37420580f, -0.37272000f, 0.10546278f, 
    0.36776096f, 0.26005882f, 0.13346963f, 0.03680709f, 0.29447567f, 0.10341521f, 0.34166679f, -0.51307464f, 
    -0.16602018f, 0.05631784f, -0.02765093f, 0.23497848f, -0.64339471f, -0.02682718f, -0.36488104f, -0.46691453f, 
    0.06543042f, 0.02105246f, 0.15382026f, 0.07280938f, -0.33429033f, 0.12711893f, 0.21661027f, 0.03369404f, 
    0.03287807f, 0.06785149f, 0.13056560f, 0.04652989f, 0.23296319f, 0.11965328f, -0.16693863f, 0.03710269f, 
    0.10465927f, 0.10628062f, 0.06378648f, -0.20805325f, 0.15630916f, 0.01730244f, 0.18282351f, 0.09492926f, 
    -0.03447758f, 0.13405700f, -0.23931858f, -0.04574961f, 0.20763789f, -0.13256659f, -0.09709413f, -0.03523913f, 
    0.04287751f, 0.22408658f, 0.07088216f, 0.03414376f, -0.46882832f, -0.04443279f, 0.10554493f, -0.19961402f, 
    0.13610309f, -0.11419754f, -0.07353476f, -0.39020047f, 0.11173381f, -0.15318206f, 0.14462380f, -0.07562556f, 
    -0.14286993f, 0.01574338f, 0.11325702f, 0.01811452f, -0.02280816f, 0.06232416f, -0.03579500f, -0.28909746f, 
    -0.10437997f, 0.12242400f, 0.30666286f, 0.12043868f, 0.38063079f, 0.19063331f, -0.03457636f, 0.20397276f, 
    0.11880508f, 0.00395134f, 0.21614809f, 0.05889506f, -0.20503831f, -0.15262860f, -0.22418886f, 0.18773171f, 
    0.15798819f, 0.05621240f, -0.15511048f, 0.05517769f, -0.14930010f, 0.00932591f, 0.14085357f, -0.18395473f, 
    0.13359120f, -0.00657889f, 0.03080167f, 0.01294514f, -0.17469917f, 0.02925029f, 0.04692338f, 0.17176691f, 
    -0.07041980f, -0.01620933f, 0.00588543f, 0.23384647f, 0.12683119f, -0.38326600f, 0.11327235f, 0.07154155f, 
    -0.05754299f, -0.03917185f, 0.08539990f, 0.22353452f, 0.14213806f, -0.13242732f, 0.05923359f, -0.05821954f, 
    0.23423542f, -0.21194802f, -0.17087556f, 0.06800745f, 0.05003113f, 0.25565481f, -0.17124790f, 0.01838265f, 
    0.13089952f, 0.15871847f, 0.17812386f, -0.10745024f, 0.08588240f, 0.04234355f, 0.22875395f, -0.10322127f, 
    -0.09006939f, 0.00708497f, 0.07013045f, -0.12296320f, 0.16378972f, -0.03402060f, 0.23352526f, 0.02633746f, 
    -0.01658683f, 0.04058645f, -0.00650323f, -0.06963680f, -0.00646812f, 0.03190477f, -0.02866060f, -0.09882432f, 
    -0.07901579f, -0.03088695f, 0.01540137f, 0.00165382f, 0.09947234f, -0.07669475f, 0.06723743f, 0.06231827f, 
    -0.08090851f, -0.06037914f, -0.01500758f, -0.10047068f, 0.01575030f, 0.05336107f, -0.07942352f, 0.03928876f, 
    -0.09364848f, -0.03237282f, -0.00515900f, -0.02241346f, -0.03788138f, -0.00810798f, -0.09774750f, 0.07935300f, 
    -0.03034289f, -0.02501530f, 0.04586576f, -0.03782426f, 0.05105103f, 0.04353314f, 0.08034679f, -0.05283075f, 
    -0.06473528f, 0.06276628f, -0.04127032f, -0.07387588f, -0.09177185f, -0.03454255f, -0.03181836f, -0.05118297f, 
    -0.09088795f, -0.07765815f, -0.01000854f, 0.04175916f, -0.04693490f, 0.04704832f, -0.08620168f, -0.07610164f, 
    -0.05305928f, -0.00691181f, -0.07270427f, 0.08914504f, -0.01587910f, 0.05503605f, 0.02899701f, -0.09867379f, 
    0.05006076f, -0.00839518f, -0.07545957f, -0.08960230f, 0.05713986f, -0.06812833f, 0.02105224f, 0.01789122f, 
    0.05754331f, 0.05998774f, -0.09430916f, 0.04382995f, -0.01434171f, 0.00380568f, 0.05800384f, -0.02902736f, 
    -0.10732430f, 0.03589174f, -0.05367220f, 0.06469660f, -0.01240958f, 0.03906860f, -0.07079004f, 0.11044772f, 
    0.05735027f, -0.05375568f, -0.08821924f, 0.01233587f, -0.00144075f, -0.11127058f, -0.10448746f, -0.06055724f, 
    0.03226702f, 0.06090753f, 0.06031362f, -0.08755895f, -0.02757469f, 0.03243499f, -0.04626212f, -0.07317003f, 
    0.06453003f, 0.04449812f, -0.00686939f, 0.03614780f, 0.00200349f, -0.01508064f, -0.01914167f, -0.02751291f, 
    0.01067318f, 0.05337552f, -0.03017406f, -0.04435375f, 0.02645337f, -0.01924225f, 0.01074175f, 0.03416222f, 
    0.03859816f, 0.01127012f, -0.03852361f, -0.01573361f, -0.02147082f, 0.04442474f, 0.05042313f, -0.05722520f, 
    0.16539963f, 0.34081066f, -0.17557836f, -0.00585555f, 0.44818023f, 0.24443027f, -0.32383224f, 0.30564424f, 
    0.30766946f, 0.03939452f, -0.23092885f, 0.24855490f, -0.14924887f, -0.25472957f, 0.04895857f, 0.09152908f, 
    0.13305968f, -0.17379838f, 0.01884134f, 0.22663839f, 0.08594452f, -0.02036174f, -0.22887328f, 0.20658308f, 
    0.05633414f, 0.12837283f, 0.07975822f, 0.06169823f, -0.24586262f, -0.44639957f, 0.12384060f, -0.00377765f, 
    -0.04606349f, -0.24210922f, -0.01583533f, 0.12825361f, -0.05873157f, -0.03019655f, 0.23821537f, 0.23167512f, 
    0.30798173f, 0.08425382f, 0.01211639f, -0.27848396f, 0.17076193f, 0.07498715f, -0.01590685f, -0.14759319f, 
    0.01770089f, -0.14211094f, -0.18958226f, 0.09953900f, 0.00310668f, 0.01127965f, 0.14156097f, 0.18931955f, 
    0.23653777f, 0.03458183f, 0.15199704f, -0.11240425f, -0.33915246f, -0.09243410f, -0.27371690f, -0.42171231f, 
    0.06240307f, 0.26372793f, 0.11028583f, 0.07345881f, 0.32259858f, 0.18046717f, 0.14311847f, 0.15927975f, 
    0.01457427f, 0.11637256f, -0.02867520f, -0.02962722f, -0.53162128f, -0.06149039f, -0.08462558f, -0.05292569f, 
    -0.07330868f, 0.13810338f, 0.11864720f, 0.01059785f, 0.14323638f, -0.01532862f, 0.10174014f, -0.51725149f, 
    0.06353568f, 0.14647938f, 0.19470967f, -0.04152039f, 0.24057713f, -0.14334545f, -0.05297949f, 0.00128602f, 
    0.07184982f, 0.01726496f, 0.04832877f, 0.02406260f, 0.03155284f, -0.05908905f, -0.00076607f, -0.00333836f, 
    -0.17232741f, 0.12743801f, 0.08628383f, 0.12162971f, 0.03447898f, -0.10343770f, 0.25382367f, 0.17722447f, 
    -0.05356359f, -0.26055714f, -0.10358357f, 0.05814921f, -0.02928150f, -0.00722055f, -0.10882168f, -0.03179257f, 
    0.07544535f, 0.02225281f, 0.14197809f, 0.04430317f, -0.08156070f, -0.01787377f, -0.02013563f, -0.30673233f, 
    -0.06080103f, -0.03366316f, 0.18678266f, 0.01540335f, 0.05230837f, -0.11888865f, -0.04467037f, 0.09312894f, 
    -0.44038811f, 0.03750652f, -0.21117143f, -0.26177269f, -0.06391364f, -0.10433610f, 0.10009931f, 0.09619012f, 
    -0.09111015f, -0.20636143f, -0.06002382f, 0.26179311f, -0.02520624f, 0.04961199f, -0.19426954f, -0.01589503f, 
    0.19467814f, 0.06861732f, -0.04124584f, 0.04226821f, 0.15156730f, -0.03210811f, -0.10295054f, -0.05467024f, 
    0.13912086f, -0.24756052f, -0.18993518f, 0.22066389f, 0.16090663f, -0.04209817f, -0.06553675f, 0.20871183f, 
    -0.19154514f, 0.04721262f, 0.35369271f, 0.23369926f, 0.09894697f, 0.30019385f, -0.11030648f, 0.02344311f, 
    0.16717209f, 0.04485813f, -0.10512886f, 0.06210218f, 0.24842784f, -0.04202890f, 0.04523649f, 0.19670561f, 
    0.23495084f, -0.01795369f, -0.33614829f, 0.04955361f, -0.01934777f, -0.24363190f, 0.30559996f, -0.21652663f, 
    -0.36400455f, 0.27691534f, -0.10425516f, 0.00595744f, 0.16943988f, 0.18238652f, 0.28874129f, -0.34189180f, 
    -0.29696390f, 0.05037640f, 0.32934970f, -0.10207792f, 0.34474114f, 0.05782524f, -0.19823270f, 0.02007048f, 
    -0.18273565f, 0.28527829f, 0.23610480f, 0.05620953f, 0.16354842f, 0.18316279f, 0.06152095f, 0.07395639f, 
    0.12665305f, 0.03044780f, 0.09710961f, 0.11667904f, -0.30039680f, 0.34438142f, -0.12538071f, 0.14321657f, 
    -0.01475931f, 0.04955924f, -0.01835235f, -0.27778712f, 0.09216806f, 0.24481125f, -0.00093360f, -0.06254493f, 
    0.24896644f, 0.09752399f, -0.12414026f, 0.22121102f, -0.04898275f, -0.18698664f, 0.29567379f, -0.19228020f, 
    -0.01460748f, 0.24248812f, 0.02864919f, -0.04385915f, 0.04521269f, 0.06634869f, 0.23353864f, 0.14924636f, 
    0.20974514f, 0.18276182f, 0.00833626f, 0.18398115f, 0.01432439f, -0.01596085f, -0.24754195f, -0.08850154f, 
    -0.15354735f, -0.04510855f, 0.12000283f, 0.04826465f, -0.41149139f, 0.00422943f, 0.18232159f, -0.00457786f, 
    0.07287449f, -0.12028748f, 0.09608882f, -0.05478086f, -0.08074826f, -0.08379205f, 0.08593272f, -0.02982389f, 
    0.14564437f, 0.05758898f, 0.05972580f, -0.01228421f, 0.00865207f, 0.13918394f, 0.11708256f, -0.21077244f, 
    0.05262719f, 0.08048909f, -0.35995695f, 0.11326898f, 0.17260468f, -0.38339970f, 0.07985103f, 0.03634214f, 
    0.01146092f, 0.01664213f, 0.03680551f, 0.06259062f, -0.00717147f, 0.04004385f, -0.01786458f, -0.16775177f, 
    -0.07538566f, 0.03638329f, -0.02597956f, 0.25036177f, -0.06209948f, 0.07389218f, 0.10339945f, -0.02141041f, 
    0.01339324f, 0.24955218f, 0.33884072f, -0.06674349f, -0.09182683f, -0.08232123f, -0.20501629f, 0.10662419f, 
    0.14062171f, 0.09069035f, 0.15449402f, 0.03625578f, 0.08216124f, 0.11632996f, 0.02666789f, -0.54272377f, 
    0.21086575f, 0.01800850f, -0.20405501f, -0.13415928f, -0.22138630f, 0.34639889f, 0.05956154f, -0.14178620f, 
    0.02108213f, 0.03255398f, -0.08582874f, -0.02217026f, -0.18122895f, 0.07978924f, -0.01763007f, -0.01200009f, 
    0.09256602f, -0.38448203f, -0.04570839f, 0.18944925f, 0.04568217f, 0.03290894f, -0.02281418f, 0.19762759f, 
    -0.13752511f, 0.00707378f, -0.22805880f, -0.12435549f, 0.10566369f, -0.52853429f, 0.02000592f, 0.16851673f, 
    -0.08833894f, 0.02150903f, 0.05071716f, -0.08395715f, 0.00690314f, 0.27069882f, -0.11452437f, 0.03522329f, 
    0.05646092f, -0.24097894f, 0.36093655f, 0.12988104f, 0.08566935f, 0.24835525f, -0.51919657f, -0.38640547f, 
    -0.00190601f, -0.05817827f, -0.02372676f, -0.00493899f, 0.08573909f, 0.08178584f, 0.02240498f, 0.18020900f, 
    -0.00883426f, -0.05547697f, -0.21162699f, 0.20478790f, 0.17322758f, -0.01605368f, 0.24659516f, -0.13663474f, 
    0.03203814f, 0.02465169f, -0.08249625f, 0.08063050f, 0.07820910f, -0.06319907f, -0.06390898f, 0.04488245f, 
    -0.00842618f, -0.06293871f, 0.05622866f, -0.08341423f, -0.08717282f, 0.03287516f, -0.05940684f, 0.00865254f, 
    -0.01700581f, -0.03706191f, -0.08205291f, -0.08077246f, -0.08994636f, 0.02973032f, -0.02399479f, -0.03082739f, 
    -0.07580993f, 0.01731218f, 0.01771744f, 0.00388253f, 0.01915975f, -0.04562017f, 0.00992908f, -0.00403988f, 
    -0.04489265f, -0.07335421f, -0.05342430f, 0.03106822f, 0.04462387f, -0.05524182f, -0.02840599f, -0.09924688f, 
    0.04475504f, 0.04978383f, -0.04738609f, 0.04250779f, 0.03931940f, 0.03219017f, 0.03799209f, -0.01015962f, 
    0.00455316f, 0.00286209f, -0.03404181f, -0.00846886f, -0.10272122f, 0.03404653f, 0.05655659f, -0.07925076f, 
    0.05572949f, -0.09755679f, -0.06648234f, -0.01773619f, -0.07930807f, -0.00131230f, -0.00628818f, 0.06550267f, 
    -0.01744493f, 0.00256047f, -0.05613364f, 0.00136133f, 0.00530771f, -0.07008582f, -0.04214116f, 0.01409273f, 
    -0.08024191f, 0.01657768f, 0.02746406f, -0.03840836f, 0.01793070f, 0.00338910f, -0.03130236f, 0.05736329f, 
    -0.04658201f, -0.06763392f, 0.03115899f, -0.05116171f, 0.05984103f, -0.07791378f, -0.06495249f, -0.08304492f, 
    0.02191823f, -0.07255173f, -0.01714462f, -0.04501628f, 0.04810587f, 0.07328435f, -0.00960884f, -0.09098873f, 
    0.08490390f, 0.00229248f, 0.06388938f, 0.02213223f, -0.04922258f, 0.01123462f, 0.01093975f, -0.00162174f, 
    -0.01855820f, 0.06655930f, -0.10104215f, 0.01784963f, -0.04354770f, 0.05994058f, -0.01815351f, 0.02392262f, 
    -0.09017298f, -0.08636826f, -0.00733199f, -0.01569375f, -0.00815963f, -0.07024298f, 0.02427815f, -0.10781067f, 
    -0.10489774f, -0.06428924f, 0.06922368f, -0.01547637f, -0.03608852f, -0.05060877f, -0.02449451f, -0.07790007f, 
    0.03972959f, 0.11881929f, 0.09016238f, -0.07062867f, 0.25847587f, 0.21925196f, -0.11348972f, 0.00276708f, 
    0.08462673f, 0.05257222f, -0.10892047f, -0.08913292f, -0.13147414f, -0.46519491f, 0.11125308f, -0.05603321f, 
    0.18567088f, 0.07986704f, -0.06868970f, 0.16686569f, -0.10099705f, -0.14294349f, -0.03853612f, -0.07162157f, 
    0.03897868f, 0.09217244f, -0.85665673f, 0.05222593f, -0.10052925f, -0.09086683f, 0.23248103f, 0.05465519f, 
    -0.00732308f, -0.03008334f, 0.11244485f, 0.02156601f, -0.13459262f, 0.08037645f, -0.11611511f, 0.15643874f, 
    -0.00998948f, 0.09062130f, -0.06839668f, 0.25079298f, -0.30188897f, 0.11221380f, 0.10185546f, 0.08940382f, 
    -0.02385538f, -0.04353615f, 0.23353273f, 0.10471371f, -0.14670013f, 0.06139773f, 0.01624604f, 0.13127570f, 
    0.21843354f, -0.04144302f, 0.06906628f, -0.07146810f, -0.03675025f, -0.08208432f, -0.26091725f, -0.23909442f, 
    -0.00772606f, 0.17222370f, -0.05093188f, 0.20044856f, 0.06691734f, -0.03614711f, 0.12864201f, -0.18592568f, 
    0.01231264f, 0.11110207f, -0.06181384f, -0.18793871f, -0.14423512f, -0.06123649f, 0.00877238f, 0.09223377f, 
    -0.04229689f, 0.19810145f, -0.03540402f, 0.16756822f, 0.15153562f, -0.05821599f, -0.33557546f, 0.26661348f, 
    0.07797424f, 0.18284668f, -0.10378554f, 0.13765244f, 0.17679638f, 0.33598787f, -0.16911025f, 0.06827056f, 
    -0.04292241f, 0.03434964f, -0.02194422f, -0.18375665f, 0.02019146f, -0.03526313f, -0.02619143f, -0.01633334f, 
    0.12432522f, 0.11454525f, 0.08902609f, 0.11045101f, 0.22094773f, 0.07847180f, 0.04717840f, 0.50276774f, 
    0.10212173f, 0.18741041f, 0.13572037f, -0.01281229f, 0.13954450f, 0.13240050f, 0.39922431f, 0.01203459f, 
    -0.00427493f, 0.06326299f, 0.04829790f, 0.33569181f, -0.21326706f, 0.08254099f, -0.05222376f, -0.50674444f, 
    0.08803308f, -0.14621414f, -0.10825341f, -0.05555283f, 0.29173154f, -0.10368203f, -0.10007211f, 0.15821354f, 
    -0.42179748f, -0.01575871f, 0.23792890f, 0.01738705f, 0.03705150f, 0.05843063f, 0.03639786f, -0.26778272f, 
    -0.32462502f, 0.12145282f, -0.06653505f, 0.00400418f, 0.35381973f, -0.00054660f, -0.11678270f, -0.13540816f, 
    0.07151008f, -0.06979531f, -0.28828120f, 0.04598341f, 0.04919057f, -0.23724759f, -0.00762334f, 0.00714611f, 
    -0.10801500f, -0.54332983f, 0.08230759f, -0.03610500f, 0.57556909f, 0.02380116f, 0.21865593f, -0.01446633f, 
    0.25780636f, 0.08494191f, 0.13533442f, 0.58047616f, 0.08134329f, 0.00573402f, -0.17131066f, -0.07280453f, 
    -0.01458903f, 0.02582128f, -0.14852820f, -0.00288216f, 0.06038322f, 0.01297560f, 0.00643075f, 0.10514864f, 
    0.25146949f, -0.06365664f, -0.02056862f, 0.17899749f, -0.06413731f, -0.19349018f, 0.26666772f, 0.60683709f, 
    0.04353556f, -0.01607895f, 0.02661410f, -0.37247473f, -0.03577532f, 0.06426838f, 0.10540593f, 0.09690298f, 
    -0.45248047f, 0.01762895f, 0.12701729f, 0.23732111f, 0.08133453f, -0.19679587f, -0.08304964f, 0.29158974f, 
    0.15699130f, 0.17555606f, -0.00306713f, -0.07033397f, 0.10353251f, 0.25293306f, 0.23083401f, 0.32356340f, 
    -0.19244236f, -0.16819274f, 0.07543266f, -0.19685517f, -0.82692784f, -0.37291202f, 0.05961917f, -0.08314458f, 
    0.02334446f, 0.11220633f, -0.06362685f, 0.24317382f, -0.05664145f, 0.15516068f, 0.02104066f, 0.04351690f, 
    -0.29370138f, 0.13363680f, -0.02100126f, 0.08225112f, -0.07978842f, -0.14366500f, -0.00215952f, -0.28696790f, 
    -0.14633216f, -0.13592681f, -0.19998318f, -0.04742540f, -0.17140245f, -0.38417417f, -0.62243158f, 0.14473654f, 
    0.11712224f, 0.06534561f, -0.14139169f, -0.14624514f, 0.00531924f, -0.04511748f, 0.22536860f, 0.25837338f, 
    0.02703219f, 0.34904635f, 0.23209080f, -0.01717892f, 0.27188417f, 0.06635433f, -0.05928680f, 0.18440099f, 
    -0.34970295f, -0.25655282f, 0.15319729f, 0.14340846f, 0.21401639f, 0.25371945f, 0.15095276f, -0.53106654f, 
    -0.37193173f, 0.23777103f, -0.04832869f, 0.16161376f, -0.04659370f, 0.07112622f, -0.09000464f, 0.04454762f, 
    -0.00764849f, -0.35824952f, 0.12386858f, -0.08627070f, 0.15676570f, -0.00013565f, 0.18756279f, 0.07785617f, 
    0.04015633f, -0.13119562f, 0.16784327f, -0.07442684f, 0.32518682f, 0.08308743f, 0.16870168f, -0.13430917f, 
    0.15607944f, 0.01617485f, 0.08545978f, 0.24059704f, -0.07438861f, 0.16250587f, 0.08179594f, -0.28185672f, 
    0.04302369f, 0.03245043f, 0.01111981f, -0.27695203f, 0.31350079f, -0.05062305f, -0.06826690f, 0.08057448f, 
    0.20612323f, -0.23410189f, -0.05036880f, 0.23153442f, -0.18437208f, -0.10942955f, 0.14679112f, 0.35493696f, 
    -0.13988540f, -0.13721049f, 0.05481507f, -0.50485224f, 0.23891471f, 0.07825968f, 0.08019928f, -0.25118729f, 
    -0.11620141f, -0.27081689f, -0.07215318f, -0.00639113f, 0.02087036f, -0.05538202f, 0.13994162f, 0.27372286f, 
    -0.12078828f, 0.03072844f, -0.02089534f, 0.03188957f, -0.06458278f, 0.11004666f, 0.33820516f, 0.44249839f, 
    -0.21263704f, 0.02437347f, 0.07941910f, -0.62060803f, -0.50659490f, -0.30256879f, 0.09417257f, -0.20850118f, 
    0.04739176f, 0.05424999f, 0.03117659f, -0.18774064f, -0.43478429f, 0.13342901f, 0.21303779f, 0.08255577f, 
    -0.34082824f, 0.21833794f, 0.30511737f, -0.02006886f, 0.32958767f, 0.24326813f, -0.05926916f, -0.37263325f, 
    -0.10788061f, -0.04591011f, -0.22392651f, 0.04763526f, -0.22363468f, -0.22789037f, -0.50762552f, 0.23209766f, 
    0.07875638f, -0.03398742f, -0.37677610f, 0.01658139f, -0.14451617f, 0.05839691f, 0.12198540f, 0.25108159f, 
    0.00541157f, -0.02617529f, 0.01878177f, -0.05389940f, -0.47918388f, 0.08943534f, 0.23440382f, -0.09025484f, 
    0.03638338f, 0.23554927f, 0.01735309f, -0.29197919f, -0.11815278f, 0.05776546f, -0.13117436f, -0.07018875f, 
    0.13424927f, -0.04146871f, -0.04407260f, -0.20586360f, 0.24664249f, -0.03602364f, 0.15238854f, -0.24173608f, 
    0.05083042f, 0.10256423f, -0.38400713f, 0.06589171f, 0.01739267f, -0.26715347f, -0.03066513f, 0.02654688f, 
    0.07052501f, 0.10990352f, 0.02756297f, 0.07105254f, 0.17468660f, 0.07485531f, -0.33360708f, -0.05359660f, 
    0.10960372f, -0.02448339f, -0.11120884f, 0.41762245f, 0.12412725f, -0.04596883f, 0.07645502f, 0.04599313f, 
    0.04060408f, 0.12760597f, 0.10836795f, 0.29290113f, -0.27208331f, 0.05501858f, -0.01645060f, -0.08373618f, 
    0.00385657f, 0.16541426f, -0.06154668f, -0.12055772f, 0.21075194f, 0.14189994f, 0.04071982f, -0.10539564f, 
    0.26632613f, -0.02800622f, 0.01073820f, 0.00096103f, -0.23594679f, 0.07410705f, 0.06698549f, 0.22234800f, 
    0.16799532f, 0.15415671f, 0.16154039f, 0.22428532f, -0.18521944f, 0.02999422f, -0.06434955f, -0.18687630f, 
    0.13979989f, -0.03975472f, -0.09214878f, 0.01439974f, -0.10976183f, -0.08034957f, 0.02431338f, 0.24391253f, 
    -0.16797695f, -0.15477575f, -0.18051225f, -0.03775908f, -0.03398272f, -0.62906885f, -0.07169870f, 0.09891479f, 
    -0.04478554f, 0.06549073f, -0.04120717f, 0.17257677f, 0.24853601f, 0.00590514f, -0.05140350f, -0.01298740f, 
    0.04060629f, -0.13802171f, -0.28114867f, 0.02755933f, 0.02007218f, 0.13564667f, 0.10191417f, 0.00002356f, 
    -0.09726705f, -0.08045816f, 0.09494746f, 0.05198683f, 0.13598683f, 0.32785869f, 0.01819411f, -0.13880412f, 
    0.20750612f, 0.10191361f, 0.03098806f, -0.11230031f, 0.03500278f, -0.05867109f, 0.05755089f, 0.10406033f, 
    0.05253173f, 0.03613613f, -0.08035687f, -0.03251173f, -0.02080295f, -0.05104395f, -0.00866785f, -0.06906550f, 
    -0.03431637f, -0.03602443f, -0.07041645f, 0.05762221f, -0.06332883f, 0.05467198f, -0.07638244f, 0.00153027f, 
    -0.09864342f, -0.00732196f, 0.05833235f, -0.06438014f, 0.06416627f, -0.08158983f, 0.04451701f, -0.06857608f, 
    0.04953813f, -0.01535418f, -0.06888998f, -0.09945904f, -0.08198034f, -0.08153909f, -0.00283514f, 0.07270923f, 
    0.05263114f, 0.07387530f, -0.07133968f, 0.06205861f, -0.06566679f, 0.04714692f, -0.10220937f, 0.05703814f, 
    -0.03670648f, -0.05814643f, -0.04705208f, -0.08741016f, -0.07716221f, 0.02999707f, -0.05832371f, 0.04770264f, 
    -0.06307285f, 0.04405088f, -0.04284135f, -0.04395265f, -0.07915281f, 0.04119865f, -0.05471848f, -0.07248493f, 
    -0.01920634f, 0.01602302f, 0.05222011f, 0.08393005f, 0.01142022f, -0.06368556f, -0.00287081f, -0.06045260f, 
    -0.09830191f, 0.01013586f, 0.05127404f, -0.00664746f, 0.00524325f, -0.02611447f, -0.08099616f, -0.09526688f, 
    -0.03221905f, 0.00933518f, -0.01278324f, 0.04135605f, -0.05313420f, 0.03918388f, 0.04346692f, -0.05661635f, 
    0.06452444f, 0.08574383f, -0.02263992f, 0.05949284f, 0.03680865f, -0.10125154f, -0.01568287f, 0.00104279f, 
    -0.04762339f, 0.03834745f, -0.06751888f, 0.06010676f, -0.01583299f, 0.05832944f, 0.06469885f, -0.10185070f, 
    -0.00880292f, 0.06530160f, -0.05449332f, 0.00459310f, -0.10021476f, 0.04900178f, -0.03477472f, 0.02107389f, 
    0.00041987f, 0.05082595f, -0.01852429f, 0.00391449f, 0.03906957f, 0.04374761f, -0.04903752f, 0.06984540f, 
    0.01769763f, -0.08970347f, 0.04010768f, -0.02079549f, 0.04885691f, -0.09672786f, -0.02375791f, -0.06224491f, 
    -0.10172466f, -0.08174623f, -0.07663673f, -0.06154063f, 0.02104353f, -0.04536607f, -0.04550667f, 0.02502960f, 
    -0.00661963f, 0.02807259f, 0.05405774f, -0.00335284f, -0.03121249f, -0.04398726f, -0.08510118f, -0.07766008f, 
    0.06053366f, -0.03989117f, -0.02829097f, 0.01792280f, 0.01930005f, 0.00577919f, -0.07465944f, 0.05235586f, 
    0.00814968f, 0.02724957f, 0.03979053f, 0.02505112f, -0.02512341f, -0.04180429f, -0.05030649f, -0.06807926f, 
    0.02871946f, -0.08679400f, 0.04341071f, 0.05227836f, -0.03726945f, 0.07582691f, -0.10462611f, -0.02497585f, 
    -0.04185462f, -0.09052420f, 0.05389217f, -0.04216159f, 0.00677803f, 0.01380549f, -0.02831865f, -0.07734879f, 
    -0.04378350f, -0.05157865f, 0.05678862f, 0.00986333f, -0.10057707f, 0.05735133f, -0.02148905f, -0.04818057f, 
    -0.00341841f, -0.09563051f, 0.03204489f, -0.06744207f, -0.10867622f, -0.05694615f, 0.01766555f, 0.05762760f, 
    0.04992479f, -0.05114841f, -0.10158184f, -0.00313745f, -0.03475804f, -0.05427102f, -0.10426279f, -0.00781890f, 
    -0.02332965f, -0.09252296f, -0.00200213f, -0.07878640f, -0.00983499f, -0.01983098f, -0.06922112f, 0.04646345f, 
    -0.00261816f, 0.05437039f, 0.01855634f, 0.01118586f, -0.06197316f, -0.07682467f, -0.07273891f, -0.01421175f, 
    -0.09897114f, -0.09997819f, -0.10700597f, 0.02224868f, 0.08201753f, 0.03103225f, -0.04989766f, 0.07843206f, 
    -0.05136886f, -0.01351168f, -0.02614563f, -0.05943311f, -0.00382141f, -0.00068499f, 0.01877525f, -0.01975399f, 
    -0.00087112f, 0.00427957f, 0.04614140f, -0.00867566f, -0.03159933f, 0.02462050f, -0.04194076f, 0.04119913f, 
    -0.07799927f, -0.07604924f, -0.05332516f, -0.10925841f, -0.10898976f, -0.00400790f, 0.08053494f, 0.07989645f, 
    0.06439251f, -0.06533305f, -0.04755247f, -0.06217182f, -0.09251153f, -0.04817557f, -0.00184112f, 0.06258545f, 
    -0.04013088f, -0.03335299f, 0.06204205f, -0.10718390f, 0.00110665f, 0.06605198f, 0.03999811f, 0.04365288f, 
    -0.00732865f, -0.67910045f, -0.03391341f, -0.04996774f, -0.31488347f, 0.01099539f, -0.15376204f, 0.11073795f, 
    -0.10244816f, 0.09743177f, -0.13007025f, -0.28594837f, -0.32096577f, -0.15864146f, -0.02101743f, 0.04101375f, 
    0.03717447f, -0.21935156f, -0.06933480f, 0.22466467f, 0.10796515f, -0.12424756f, -0.12096299f, 0.34307811f, 
    0.36993545f, 0.08937947f, -0.44791797f, 0.17319183f, 0.13257708f, -0.23559414f, 0.04911593f, -0.04678627f, 
    0.14065731f, -0.34280059f, -0.01641051f, 0.10956161f, 0.41718638f, -0.06407780f, -0.08640917f, 0.15278381f, 
    0.06831978f, 0.07225943f, -0.01210390f, 0.07255574f, 0.13851625f, 0.19974513f, -0.10005577f, 0.09109882f, 
    -0.00201678f, 0.19203715f, -0.02759095f, 0.02966649f, -0.15875468f, -0.08303320f, -0.05727840f, 0.18063675f, 
    0.24306911f, 0.06588791f, -0.05310359f, -0.21971762f, -0.03511579f, -0.44083259f, 0.13450526f, -0.40352502f, 
    -0.08170356f, 0.16016397f, -0.04769558f, -0.13985990f, -0.09656113f, 0.20966165f, 0.18817830f, -0.20949072f, 
    -0.06408861f, 0.15673071f, 0.36167732f, -0.05839437f, 0.06047744f, -0.04850150f, 0.05005695f, 0.07489970f, 
    0.21190178f, -0.06804452f, 0.12649539f, 0.03200644f, 0.26527214f, 0.12945373f, 0.02797130f, -0.04469439f, 
    0.15647408f, 0.01151807f, -0.08027098f, 0.10598777f, -0.06840016f, -0.55344987f, 0.05142828f, 0.08580122f, 
    -0.00269429f, 0.03877624f, 0.01546596f, -0.15040340f, 0.07297094f, 0.10283025f, -0.10400311f, -0.05630516f, 
    -0.03659506f, 0.05892619f, -0.04193978f, 0.11984979f, -0.03162323f, -0.02329683f, -0.20080163f, -0.01828679f, 
    0.02404596f, -0.04801065f, 0.05722061f, 0.01903488f, 0.08666427f, 0.16900147f, 0.17972030f, 0.01247005f, 
    0.29210776f, 0.21537626f, -0.01996471f, 0.12647699f, 0.03077032f, 0.01204162f, -0.11971233f, -0.31411794f, 
    0.11023653f, -0.09318759f, -0.31613311f, 0.07648457f, -0.10408621f, -0.04463912f, 0.05551927f, 0.17229506f, 
    0.22661914f, 0.10746742f, 0.11001910f, -0.04832189f, 0.03911464f, 0.16865210f, -0.12092053f, 0.22036770f, 
    0.05592659f, 0.01603445f, -0.03852102f, -0.21114315f, 0.24520554f, 0.06074062f, 0.31515944f, 0.06224765f, 
    -0.09154003f, 0.24592976f, -0.01256414f, -0.06458908f, -0.19798663f, -0.12463772f, 0.00603982f, 0.01826604f, 
    -0.03491285f, 0.06796061f, 0.17381115f, 0.01732007f, 0.13366157f, 0.05487414f, 0.16232133f, 0.10248338f, 
    0.42728990f, 0.00673144f, -0.28290707f, -0.15064341f, 0.15463029f, -0.14288369f, -0.16501488f, 0.03192139f, 
    0.11407419f, -0.06275100f, -0.03341365f, 0.09453557f, 0.00809693f, -0.00414826f, 0.34654936f, -0.17747730f, 
    -0.03640680f, 0.07771451f, 0.15422069f, 0.11121707f, 0.12192966f, 0.23992157f, -0.08559378f, 0.34811550f, 
    0.22421187f, -0.20159768f, 0.25351021f, 0.00127412f, -0.04135076f, -0.22032352f, -0.18683739f, 0.46568060f, 
    -0.03796538f, 0.10163459f, -0.07052200f, 0.20408249f, -0.36045745f, -0.06274734f, 0.07347180f, 0.20455478f, 
    0.17481557f, -0.04505216f, -0.01704949f, -0.18263856f, -0.16468191f, 0.08897359f, -0.34505880f, -0.30413651f, 
    0.04828385f, -0.02609782f, -0.05302630f, -0.02685920f, 0.14185008f, -0.19627714f, -0.08187678f, -0.11895140f, 
    0.05562079f, 0.01660175f, -0.06828750f, 0.29664811f, -0.00782746f, -0.01783853f, -0.04525355f, 0.00075130f, 
    -0.14377426f, -0.04433475f, -0.14594886f, -0.11060678f, -0.05377203f, 0.22093743f, 0.22989014f, 0.51927453f, 
    -0.02721172f, -0.06904731f, 0.08095092f, 0.03377996f, -0.12591501f, -0.20087728f, -0.54563445f, -0.07345040f, 
    0.06024502f, 0.06280082f, 0.11063500f, -0.20682696f, -0.10873166f, 0.02912622f, 0.13736223f, 0.47420338f, 
    0.32773915f, -0.01768665f, -0.08550254f, 0.05246283f, -0.79363644f, 0.16752681f, 0.08045570f, -0.05328693f, 
    0.03165261f, 0.12613945f, 0.26441741f, -0.01451610f, 0.13074659f, 0.09969050f, 0.06536911f, 0.06968187f, 
    0.26109380f, 0.14442639f, 0.02268985f, -0.22204219f, 0.15926148f, 0.06338760f, 0.36403367f, -0.01957398f, 
    -0.15200059f, 0.11237737f, 0.09917742f, 0.01729309f, 0.06247563f, -0.16452657f, 0.34166685f, -0.03629634f, 
    -0.08833716f, 0.36116806f, -0.03875299f, -0.04378594f, 0.15246640f, -0.02237574f, 0.03381603f, 0.06516901f, 
    0.15475625f, 0.00479150f, -0.28377944f, -0.39146104f, -0.05384328f, -0.12060262f, 0.06967828f, -0.07489061f, 
    0.08551459f, -0.04853614f, 0.21797097f, 0.13606572f, -0.19559696f, -0.01553051f, 0.22983259f, -0.25718039f, 
    0.07988130f, 0.10144103f, 0.22248334f, 0.03295326f, 0.16354595f, 0.12668307f, -0.30832568f, 0.37968823f, 
    0.52580571f, -0.00856682f, 0.23544826f, 0.08596310f, -0.24053934f, -0.09588072f, -0.08021365f, 0.39177218f, 
    0.19211312f, 0.24315572f, -0.18750286f, -0.04300385f, -0.35081637f, 0.02498232f, -0.06063896f, -0.05917394f, 
    0.17263454f, -0.63491470f, -0.07961538f, -0.00717403f, -0.06784365f, 0.05406613f, -0.51673037f, -0.10732525f, 
    0.11169083f, -0.05871030f, -0.25202754f, -0.28216675f, 0.09428546f, -0.02949201f, 0.07660875f, 0.06815258f, 
    0.03365075f, -0.00264683f, -0.04318706f, 0.16366327f, 0.14479224f, -0.24603745f, 0.04688097f, 0.00219340f, 
    0.03948213f, -0.23776118f, -0.03225370f, 0.02205705f, 0.07127414f, 0.38126189f, 0.13087751f, 0.01063724f, 
    0.18962193f, -0.14414826f, 0.09311473f, -0.03602918f, 0.06787436f, 0.06150826f, -0.31971800f, -0.04792406f, 
    -0.26887864f, -0.00146102f, 0.14095052f, -0.01518697f, 0.01849179f, -0.04085881f, 0.23565808f, 0.27955413f, 
    -0.07000890f, -0.30500421f, 0.14997709f, -0.07153224f, -0.10996770f, 0.02043246f, 0.16239920f, 0.05460414f, 
    -0.20599590f, 0.11478713f, 0.02689571f, -0.31500465f, 0.09893207f, 0.06678493f, -0.09870022f, 0.35977378f, 
    -0.03405724f, -0.34038612f, 0.03591802f, -0.02890488f, 0.18667006f, -0.24561280f, 0.08381910f, 0.08043730f, 
    0.20661406f, -0.04755857f, -0.30341554f, 0.00441202f, 0.10260752f, -0.11939923f, 0.05627672f, 0.00278299f, 
    0.06012016f, 0.14458652f, -0.13582093f, 0.09463115f, 0.09839869f, 0.08916932f, -0.45813304f, -0.10603283f, 
    -0.21765034f, 0.17680785f, -0.10722266f, 0.46496257f, 0.02627239f, 0.05987398f, 0.32493523f, 0.12503649f, 
    0.04614795f, -0.09923654f, -0.24104595f, 0.14774454f, -0.25709993f, -0.04700338f, -0.29876021f, -0.06327660f, 
    -0.04397478f, 0.25547692f, 0.18582211f, -0.46956936f, 0.39940038f, -0.26774442f, -0.01432102f, 0.27160111f, 
    -0.12414481f, 0.00286630f, 0.11647930f, 0.17753747f, 0.00266423f, -0.40966707f, -0.14897932f, -0.10330398f, 
    0.13680157f, 0.14073037f, 0.25438929f, -0.12338103f, 0.01493565f, -0.01345481f, -0.03058529f, 0.00090097f, 
    0.17690213f, -0.12760124f, -0.12753056f, -0.06806637f, 0.14857583f, 0.01228925f, -0.18613017f, 0.08623425f, 
    -0.24673013f, -0.02022354f, -0.28105512f, 0.21470909f, 0.08909879f, 0.03403848f, -0.14531560f, -0.11904497f, 
    0.02319258f, -0.09396970f, 0.04289789f, 0.20597413f, 0.12474333f, -0.22028400f, -0.25756130f, -0.05636028f, 
    0.40543312f, -0.23835729f, -0.26960477f, -0.00325511f, -0.09606878f, 0.06472448f, -0.17564847f, 0.46349403f, 
    0.26172298f, 0.18271402f, 0.09899685f, -0.01008462f, 0.15507695f, 0.10801980f, 0.29211956f, -0.43304750f, 
    -0.00272439f, 0.05147506f, -0.07198778f, 0.02696737f, -0.54264325f, -0.04098069f, -0.24454641f, -0.18930824f, 
    0.00843826f, 0.06935910f, 0.01039592f, -0.05221821f, 0.58859640f, 0.14476117f, -0.14897850f, 0.27317446f, 
    0.36278278f, 0.03639027f, 0.31760204f, 0.20611559f, -0.06934607f, -0.04192114f, 0.29606703f, 0.09838239f, 
    -0.02176441f, 0.19472748f, -0.03054424f, -0.00719824f, -0.08249836f, -0.06228345f, 0.05102342f, -0.30691355f, 
    -0.34262526f, -0.04505095f, 0.24602942f, 0.00325075f, -0.13242203f, -0.11349523f, 0.02564716f, -0.05147213f, 
    0.01026881f, 0.34181565f, 0.32338339f, -0.14142223f, -0.12147456f, 0.01307467f, 0.25397930f, 0.20310163f, 
    0.22097856f, 0.13759115f, -0.04308143f, 0.08663865f, -0.15850165f, 0.06238327f, -0.12876771f, 0.07928651f, 
    -0.13846098f, -0.17705150f, 0.20888755f, -0.00119555f, -0.01745516f, 0.00470448f, 0.19044474f, -0.06131181f, 
    -0.00021302f, -0.23464486f, -0.01703127f, 0.14765020f, -0.25188428f, -0.01643951f, -0.32770014f, -0.01329519f, 
    0.14450534f, 0.03056545f, 0.01457551f, -0.15475182f, 0.26710209f, -0.18536456f, -0.06470087f, 0.12036469f, 
    0.10504927f, 0.07947992f, -0.17392038f, 0.07588542f, -0.13966951f, -0.00374921f, -0.19737059f, 0.39902201f, 
    0.11438394f, 0.28088334f, 0.09570135f, 0.08337796f, 0.00435553f, 0.17796353f, -0.67748171f, 0.25611845f, 
    -0.13903075f, 0.35349703f, 0.03907256f, 0.00298236f, 0.25154901f, 0.26941800f, -0.09157989f, 0.08598691f, 
    -0.06802185f, -0.04091156f, -0.05839234f, -0.03711106f, -0.17531750f, 0.05116991f, -0.01278643f, -0.05515841f, 
    -0.09932442f, 0.25012013f, 0.08253306f, -0.02008191f, 0.17245406f, 0.16177352f, -0.20004793f, 0.19202331f, 
    0.16303791f, 0.41405612f, -0.00765849f, -0.00695407f, -0.12276795f, -0.52060181f, 0.12654366f, 0.03851669f, 
    -0.17502579f, 0.05220504f, 0.07204200f, 0.16781738f, -0.31170374f, -0.05090797f, 0.08107208f, 0.00122312f, 
    0.05054221f, 0.10035175f, 0.06190247f, -0.02828520f, 0.12580186f, -0.04872032f, -0.06927303f, 0.05558231f, 
    0.02036886f, 0.04410795f, -0.07919670f, -0.00157122f, -0.04183249f, -0.09375252f, 0.03320277f, -0.04124389f, 
    0.04347730f, -0.06458262f, 0.08473117f, 0.00834308f, 0.03921381f, 0.05014968f, -0.07631451f, 0.03480478f, 
    -0.05687413f, -0.12353376f, -0.03173468f, -0.09443359f, -0.08206272f, 0.05508092f, -0.11922123f, 0.08061183f, 
    -0.08892556f, 0.07473414f, -0.02255908f, -0.11063629f, -0.08957011f, 0.01887541f, 0.01103581f, -0.06524487f, 
    0.02697250f, -0.02882005f, -0.05670479f, -0.04012970f, -0.05529429f, -0.03120717f, -0.12269451f, -0.07983159f, 
    -0.08588163f, -0.00250912f, -0.02053973f, -0.00190057f, -0.03840286f, 0.05121308f, 0.08287389f, -0.01056873f, 
    -0.08425711f, -0.00826101f, -0.06494044f, -0.09416543f, -0.07464191f, 0.05955259f, -0.00919719f, 0.02619254f, 
    -0.02556778f, -0.05836748f, 0.01641486f, -0.06308778f, -0.05492856f, -0.03151183f, -0.14655577f, -0.06418245f, 
    -0.04868836f, 0.00198576f, -0.09393238f, -0.06439675f, 0.02240034f, 0.05102243f, -0.08724925f, -0.09291812f, 
    0.03745715f, -0.09581516f, -0.05020421f, -0.05699174f, -0.05679806f, 0.05411988f, -0.00000108f, 0.03604485f, 
    -0.08377737f, -0.05383281f, -0.16672011f, -0.05917447f, -0.03052711f, 0.04901871f, -0.03177056f, -0.08700063f, 
    -0.06797127f, -0.05211546f, -0.03255998f, -0.09337749f, 0.02059843f, -0.04036019f, 0.03305874f, -0.05481319f, 
    -0.02756211f, -0.05421187f, -0.06719860f, -0.09644543f, -0.08916888f, -0.10484753f, -0.02018783f, -0.03899745f, 
    -0.08392491f, -0.08086834f, 0.03775701f, 0.04725356f, 0.04186615f, 0.07691527f, 0.08850188f, -0.02786210f, 
    -0.01618295f, -0.13089739f, -0.04795529f, -0.07621959f, -0.08184282f, -0.02503277f, -0.10084605f, 0.06093027f, 
    0.00273877f, -0.07082006f, -0.02336252f, -0.08040838f, 0.06606583f, -0.08658352f, 0.07633341f, 0.00548151f, 
    -0.00468376f, 0.00749961f, -0.03048174f, -0.02285296f, -0.04321149f, -0.08274098f, 0.00308763f, -0.09408206f, 
    0.03479023f, 0.03709149f, 0.07197611f, 0.04331009f, 0.05985889f, 0.01535060f, -0.03567779f, 0.03908840f, 
    -0.03089965f, 0.06628175f, -0.04741277f, -0.07051865f, -0.07951577f, -0.06770153f, -0.05228467f, 0.06671023f, 
    0.07517985f, 0.02742636f, -0.03945149f, -0.07677264f, -0.08958493f, -0.07190599f, -0.08557670f, 0.07532185f, 
    -0.09739011f, -0.07651796f, -0.06264506f, 0.01785694f, -0.06644750f, -0.04400430f, 0.02886715f, -0.05759815f, 
    0.00789088f, -0.08639047f, -0.08140311f, 0.05329271f, -0.07365245f, 0.01580852f, 0.01172399f, 0.01407366f, 
    -0.05697620f, 0.00827962f, 0.00737128f, -0.12665774f, 0.02331029f, 0.07262870f, 0.00164276f, -0.05590300f, 
    -0.08549165f, -0.05850776f, 0.01352014f, 0.00247675f, 0.01280127f, 0.06613062f, 0.07934628f, -0.04038120f, 
    -0.00177977f, -0.10252659f, 0.05788621f, -0.06603595f, -0.03817200f, -0.05160795f, -0.02656226f, 0.03457935f, 
    -0.06932364f, 0.07039638f, -0.04913679f, -0.02038674f, -0.02665585f, 0.01621415f, -0.07143775f, -0.05575689f, 
    0.03501214f, -0.06474312f, -0.09047866f, 0.06223179f, 0.07285786f, 0.04230110f, -0.02517329f, -0.05170443f, 
    0.03474439f, -0.05670203f, -0.06690192f, 0.00236257f, -0.10794612f, -0.02986537f, 0.08037898f, 0.03607835f, 
    0.07906432f, 0.00130397f, -0.00751288f, 0.07686483f, -0.02547775f, -0.05130212f, -0.02946100f, -0.01381279f, 
    -0.04926322f, 0.02630482f, -0.08349749f, -0.05567424f, -0.03502507f, 0.01720141f, 0.05953840f, 0.01424782f, 
    -0.05730816f, -0.00584212f, -0.05467590f, -0.02601506f, 0.07544792f, -0.07863284f, -0.00567596f, 0.03372961f, 
    0.04484517f, 0.27408138f, -0.01688414f, 0.03230656f, -0.11793310f, -0.03974489f, 0.11392337f, -0.11550457f, 
    0.00235375f, -0.01303832f, -0.19243568f, 0.28340518f, 0.34695911f, 0.01765851f, -0.11804761f, 0.02785027f, 
    0.18708640f, 0.08416483f, 0.01864298f, -0.22197667f, 0.16630936f, 0.14125867f, -0.00968608f, -0.03775183f, 
    -0.18058230f, 0.03311524f, -0.07611612f, 0.01400993f, -0.13581474f, 0.02364733f, -0.17839892f, 0.02735384f, 
    -0.11661071f, 0.20599163f, -0.17754140f, 0.02976429f, -0.30042309f, 0.08637483f, 0.07313231f, -0.00116925f, 
    0.09256457f, -0.10884573f, 0.38964722f, -0.33880204f, 0.16194583f, -0.17051160f, -0.00610134f, -0.08441327f, 
    0.00139740f, -0.09927580f, -0.02298192f, 0.12080522f, 0.13586478f, -0.04778019f, 0.34071216f, -0.13657030f, 
    -0.16509824f, 0.08133955f, -0.16470793f, 0.15677828f, 0.06819336f, 0.23427904f, -0.03709446f, 0.05445518f, 
    0.08529022f, 0.06545978f, 0.16992831f, 0.06358309f, 0.03478586f, 0.22139378f, 0.14810787f, 0.26027030f, 
    0.17772840f, -0.06181756f, -0.06107524f, 0.04204860f, -0.35773534f, -0.00464164f, -0.19527057f, -0.34238523f, 
    -0.13101551f, 0.07670411f, 0.12626439f, 0.04136425f, -0.17667954f, -0.01393696f, 0.27135673f, -0.14561558f, 
    -0.13504454f, 0.06853221f, 0.21572426f, 0.11743649f, -0.05148278f, 0.21578358f, -0.01258814f, 0.18121983f, 
    -0.01309638f, 0.01741419f, -0.04814109f, 0.16753821f, 0.27233332f, -0.05391990f, 0.14513703f, -0.07272127f, 
    0.06970614f, 0.02608493f, 0.05420628f, 0.06852374f, -0.06920506f, -0.11615608f, 0.29204002f, -0.24502434f, 
    -0.19927485f, -0.01909423f, 0.02967585f, -0.01619953f, 0.10743919f, 0.30357945f, 0.29679203f, 0.11163855f, 
    0.01338863f, -0.00193442f, 0.09543309f, -0.06304304f, 0.27308068f, -0.04192289f, 0.04191252f, 0.04479301f, 
    0.04661625f, -0.04369039f, -0.09573583f, 0.07611778f, 0.00564633f, 0.03359902f, -0.06559109f, -0.03572743f, 
    -0.09551708f, -0.01539454f, -0.06056834f, 0.02095247f, 0.05423262f, -0.05996352f, 0.03418599f, -0.09402610f, 
    -0.06814311f, -0.05700342f, -0.01041892f, -0.05552351f, -0.04810432f, -0.02149532f, 0.07169966f, 0.00401196f, 
    -0.03730204f, 0.04897241f, -0.05094574f, 0.02022731f, 0.01130874f, -0.04202133f, -0.05361686f, -0.05564498f, 
    0.04407771f, -0.04076963f, -0.06242700f, 0.07650276f, 0.04314596f, -0.07903039f, 0.00897801f, 0.06174834f, 
    -0.05248604f, 0.07809251f, -0.00679489f, -0.03764053f, -0.09585240f, 0.07460720f, 0.06253166f, -0.05135168f, 
    0.00944125f, -0.07165810f, -0.06730001f, -0.02617844f, 0.01372594f, -0.03319583f, 0.04082261f, -0.02718989f, 
    -0.02191161f, -0.07184790f, 0.01283994f, 0.01059218f, -0.02889760f, -0.03310482f, -0.09226129f, 0.00523409f, 
    -0.08388393f, -0.04406204f, -0.07392552f, -0.04526887f, -0.05776933f, -0.06390612f, -0.07245774f, 0.03081454f, 
    0.00691834f, 0.02459738f, -0.05294401f, 0.07960106f, -0.07498696f, -0.05944535f, -0.05479006f, 0.02805220f, 
    -0.05259919f, -0.00733328f, -0.08545464f, 0.05689749f, 0.02331238f, -0.06618500f, -0.01205205f, -0.03420125f, 
    0.08282847f, -0.01224784f, 0.07501274f, -0.08796668f, -0.03103144f, 0.06521136f, -0.09558722f, 0.06374978f, 
    0.05408847f, -0.01976654f, -0.03279271f, 0.06585906f, 0.04572765f, 0.02590828f, -0.09579237f, 0.02181927f, 
    -0.02028571f, -0.03940882f, 0.02489915f, 0.01256792f, 0.00526433f, -0.09582035f, -0.00337984f, 0.02602396f, 
    -0.04671486f, 0.03978484f, 0.04095571f, -0.06443428f, -0.08508965f, -0.01405300f, -0.08765868f, 0.06484363f, 
    0.04280990f, 0.03684929f, 0.05885280f, 0.03805854f, 0.03309471f, 0.07715916f, 0.08446158f, -0.05191924f, 
    0.10463201f, 0.01509683f, -0.15427917f, 0.04156661f, -0.67892271f, 0.41001037f, 0.11442297f, -0.24057013f, 
    0.30619779f, 0.04699106f, -0.14548253f, -0.02008050f, 0.03425914f, -0.23725361f, -0.06880743f, 0.17034681f, 
    0.17171052f, 0.05567667f, -0.06892983f, -0.12503856f, -0.10680668f, -0.16422965f, 0.00318424f, -0.07876790f, 
    -0.11367531f, -0.03002262f, 0.08948487f, -0.06417663f, 0.05963257f, 0.03322923f, 0.52946687f, 0.00410844f, 
    0.09782173f, -0.24389249f, -0.06462667f, 0.11546242f, -0.10298415f, -0.08156920f, -0.22344108f, 0.21777734f, 
    -0.34300441f, 0.14914793f, -0.08341494f, -0.43517852f, -0.29780015f, 0.03923678f, 0.40703356f, 0.26324278f, 
    -0.18202668f, 0.01672222f, 0.07213071f, 0.33724087f, -0.15306646f, 0.07658599f, -0.01777893f, 0.13240066f, 
    0.21421383f, 0.19756477f, 0.20305853f, -0.21986477f, 0.49783862f, -0.16938026f, -0.09281605f, 0.16566968f, 
    0.22180636f, 0.23320603f, 0.17794329f, 0.19946472f, -0.06084723f, -0.06164784f, 0.08382288f, 0.09544307f, 
    -0.11098625f, 0.10846371f, 0.24812412f, -0.30469370f, -0.20911820f, -0.01828444f, 0.27778006f, -0.16750057f, 
    0.12413772f, -0.35424009f, -0.22297546f, 0.07610340f, 0.16461104f, -0.24297565f, -0.37755516f, 0.09269175f, 
    0.16192217f, -0.16206828f, 0.07441820f, 0.02856901f, 0.27479491f, -0.09670771f, -0.06504970f, -0.09754033f, 
    0.07063925f, 0.01899464f, 0.07500608f, -0.00296970f, 0.01918448f, 0.03958933f, -0.01430661f, 0.04082811f, 
    0.30840451f, -0.19679633f, 0.02252937f, 0.14643446f, -0.14806697f, 0.23934670f, 0.05345248f, 0.27357894f, 
    0.12828875f, -0.16048953f, -0.00715425f, -0.02214765f, 0.12041403f, -0.22216828f, -0.12440848f, -0.15419911f, 
    0.10234979f, 0.22513086f, 0.20343471f, 0.16039281f, -0.12198669f, -0.09641585f, -0.16681437f, -0.25955474f, 
    0.35289505f, -0.18499278f, 0.37102509f, -0.01122810f, -0.25105190f, -0.05454635f, -0.06806692f, 0.03639277f, 
    -0.60448122f, 0.25014222f, -0.16952924f, -0.39455777f, -0.23105261f, 0.12365901f, -0.03138731f, -0.19898675f, 
    -0.03457724f, -0.02415559f, 0.03962370f, 0.11218292f, 0.20148589f, 0.00778415f, -0.21222508f, -0.09480949f, 
    0.14910956f, 0.08990995f, -0.29278216f, -0.04749316f, 0.16830188f, -0.01383354f, -0.19894573f, -0.01747490f, 
    0.06531914f, 0.07809703f, -0.22824167f, 0.20607013f, 0.17013684f, -0.01587190f, 0.05692334f, 0.17965992f, 
    0.09974670f, -0.04813658f, 0.30115744f, 0.05084577f, 0.28069028f, 0.14867489f, -0.18522364f, -0.21887285f, 
    0.26060057f, 0.00890119f, 0.01930493f, 0.40244913f, 0.15993187f, -0.07919107f, 0.09948566f, 0.07225793f, 
    -0.00773318f, -0.02275430f, -0.21964577f, 0.05349550f, 0.11175808f, -0.14450419f, 0.27140895f, 0.54746950f, 
    0.00638896f, 0.20692903f, 0.00214226f, 0.18027310f, 0.04153246f, 0.07746200f, 0.01471958f, 0.00864523f, 
    -0.14938436f, 0.09931821f, 0.41577601f, 0.00208431f, 0.26569408f, 0.07342605f, -0.53906536f, 0.02597689f, 
    -0.06826343f, 0.14278154f, 0.10381929f, -0.01691651f, -0.01485513f, 0.18087004f, 0.04850216f, 0.12564933f, 
    0.05060943f, -0.05401551f, 0.05439520f, -0.00215579f, -0.47825640f, 0.39543065f, -0.06745701f, 0.26173711f, 
    0.04920322f, 0.05065732f, 0.01754177f, -0.13383110f, 0.30556521f, 0.06316577f, 0.13954513f, -0.05103984f, 
    0.24331301f, 0.25854960f, -0.35832572f, 0.19289182f, 0.11278342f, -0.11034559f, 0.73695028f, -0.43362805f, 
    -0.04724734f, 0.16158089f, 0.19150476f, 0.02074689f, 0.08246613f, 0.02197452f, -0.32653865f, 0.24247837f, 
    0.30052823f, 0.08460047f, -0.08381506f, 0.01501610f, 0.16854554f, -0.03240055f, -0.14714371f, 0.25225306f, 
    0.16951808f, -0.74620831f, 0.18507947f, -0.00683625f, 0.26505679f, 0.07129991f, -0.16225983f, 0.25611195f, 
    -0.24280974f, 0.15440147f, 0.10326176f, -0.36922541f, -0.31995657f, -0.08977629f, -0.04611715f, 0.21427195f, 
    -0.00662452f, -0.12921649f, -0.06627858f, 0.28461978f, 0.22547346f, -0.13735256f, -0.21853296f, 0.19636628f, 
    0.49467862f, 0.18293189f, -0.57880682f, 0.21069573f, -0.13918471f, -0.24382269f, 0.09072734f, -0.05058999f, 
    0.12115486f, -0.42897090f, 0.14937896f, 0.19018984f, 0.41981739f, -0.01751360f, -0.12863314f, 0.34157023f, 
    0.19612148f, 0.12194211f, -0.09727610f, 0.21099362f, 0.06272309f, 0.18271694f, -0.10783941f, 0.06577663f, 
    0.05799296f, 0.08922694f, -0.35012391f, 0.17092702f, -0.16633467f, 0.08348294f, 0.21165456f, 0.15705451f, 
    0.26841775f, -0.09449660f, 0.04560727f, -0.29385075f, 0.11230997f, -0.41465876f, 0.12480769f, -0.10745181f, 
    -0.10093755f, 0.25486034f, 0.07924861f, 0.32683241f, 0.25879651f, -0.02552339f, 0.10434571f, -0.02440065f, 
    -0.00296809f, 0.27001002f, 0.38678816f, 0.10182582f, 0.14485145f, 0.03043888f, -0.09111252f, 0.27651823f, 
    0.29277682f, 0.22336932f, 0.04509963f, -0.11361703f, 0.44991475f, 0.29163209f, -0.32941082f, -0.29226971f, 
    0.22390030f, 0.02903133f, -0.00112497f, 0.21451408f, -0.28956294f, -0.07796991f, -0.08215698f, 0.14861181f, 
    -0.01005129f, -0.09692543f, 0.06066284f, -0.13949914f, 0.02411564f, 0.06135969f, 0.03929497f, -0.04189928f, 
    0.18901721f, 0.14112484f, -0.17654979f, -0.02033300f, 0.09413025f, -0.08361255f, 0.04784159f, 0.24826685f, 
    0.19182624f, 0.16580430f, 0.07143119f, -0.02797828f, 0.14498845f, 0.03365894f, 0.09029976f, -0.33780158f, 
    0.24849200f, 0.13665536f, 0.17133611f, 0.17615646f, -0.08893867f, 0.09319227f, -0.21420562f, -0.33276331f, 
    -0.00907580f, 0.09781083f, -0.10379699f, -0.04463193f, -0.56433737f, -0.18991575f, -0.24346085f, 0.12250418f, 
    -0.40216258f, 0.03237858f, -0.21225464f, 0.17010216f, 0.26951650f, 0.14223160f, 0.05535385f, -0.71638948f, 
    -0.18196991f, 0.36506557f, 0.07244325f, 0.02067341f, -0.19520198f, 0.32151508f, -0.05013384f, 0.29610416f, 
    0.34926432f, 0.18846317f, 0.04644573f, -0.03970085f, -0.20688079f, 0.21143006f, 0.00008909f, -0.03070676f, 
    -0.23796585f, -0.57190335f, 0.10119116f, 0.05421235f, 0.19527075f, -0.02089265f, 0.05641885f, 0.32134950f, 
    0.43749541f, 0.04169716f, 0.05180446f, 0.48696309f, 0.15877631f, 0.02500256f, 0.16278498f, 0.05474233f, 
    0.00762541f, 0.05791827f, -0.15143672f, -0.14419360f, 0.32629448f, -0.00589914f, 0.34546331f, 0.23321588f, 
    0.20104679f, -0.19922975f, -0.27148846f, 0.23472258f, -0.54380929f, 0.15016468f, 0.17825536f, 0.09261776f, 
    -0.01954600f, -0.08252841f, -0.07434295f, 0.33028284f, -0.29173383f, 0.13243116f, 0.04148491f, 0.34143829f, 
    -0.14895248f, -0.01047108f, -0.00324183f, 0.29614794f, 0.27179739f, -0.08957571f, 0.07556723f, 0.09576005f, 
    -0.09285607f, 0.21714632f, 0.12525716f, 0.00078048f, 0.04825776f, -0.30287004f, 0.35263747f, 0.27332643f, 
    0.05389166f, -0.02925418f, 0.25674951f, -0.75700814f, -0.10320991f, 0.18041208f, 0.16649675f, -0.31359693f, 
    0.00705621f, -0.09382562f, -0.01920312f, -0.12977782f, -0.01139246f, 0.03846455f, 0.35767740f, 0.05567437f, 
    -0.44710222f, -0.15960093f, 0.15942259f, 0.15536375f, -0.13068749f, -0.28386033f, 0.11747658f, -0.39448664f, 
    -0.50509077f, -0.41738397f, -0.15717967f, -0.01575251f, -0.31859681f, 0.30287695f, -0.31140134f, 0.13920045f, 
    0.11426822f, -0.17237249f, 0.16842322f, -0.03426614f, 0.28743806f, -0.00766522f, 0.20464875f, 0.33660710f, 
    -0.09765378f, 0.00350074f, 0.00891290f, -0.07123630f, 0.03123610f, -0.07780786f, -0.01924650f, -0.02989018f, 
    0.04787681f, -0.03428267f, 0.02909194f, -0.04658345f, -0.07008170f, 0.04058045f, -0.07981363f, -0.01547424f, 
    -0.04064403f, -0.06677809f, -0.05886095f, 0.00627907f, -0.06158416f, 0.07048457f, -0.07909419f, 0.01749321f, 
    0.06826340f, -0.00193604f, -0.05074454f, 0.02255748f, -0.01159946f, -0.08321403f, -0.04673831f, -0.02583525f, 
    -0.06612229f, -0.01185945f, -0.00923396f, -0.05214225f, -0.02163877f, 0.05948309f, -0.09156705f, 0.04119357f, 
    0.06373616f, 0.04458033f, -0.05849570f, -0.11201837f, -0.03661931f, -0.06698743f, -0.07856783f, -0.05362828f, 
    -0.03783934f, -0.03976480f, -0.09073149f, -0.08492315f, 0.05708735f, -0.07059076f, -0.02828135f, -0.10970985f, 
    -0.05097560f, -0.02329732f, -0.03155985f, 0.06954997f, 0.00850265f, 0.07198407f, 0.03240031f, -0.00867242f, 
    0.00989117f, -0.01251824f, 0.05489587f, -0.07874750f, -0.01423855f, 0.05344796f, -0.07831515f, 0.00316255f, 
    0.06643455f, 0.00712527f, -0.06492363f, -0.06579168f, -0.02303449f, -0.04978621f, -0.03463762f, -0.07397180f, 
    -0.11278323f, -0.05833825f, -0.05466516f, -0.04431148f, -0.11361873f, -0.08906356f, -0.06943501f, -0.06011607f, 
    0.05852693f, -0.06235868f, -0.00224635f, -0.00043727f, 0.05623444f, -0.08698966f, -0.10194428f, 0.07033225f, 
    -0.00568840f, -0.07833652f, 0.04376127f, -0.05686437f, 0.00324526f, -0.07213263f, 0.00601859f, 0.02765259f, 
    -0.07636399f, -0.00935920f, -0.12119951f, 0.01978319f, -0.07964863f, -0.04114126f, 0.02087960f, -0.07232849f, 
    -0.11707217f, -0.06622754f, 0.00515415f, 0.03983626f, 0.02631955f, -0.08845578f, -0.05297373f, -0.10500614f, 
    -0.02636638f, 0.04912238f, -0.09188768f, 0.03490002f, 0.01009428f, 0.08531255f, 0.03036500f, -0.03525104f, 
    0.41570005f, -0.12149147f, 0.03611371f, 0.01895402f, -0.26642606f, -0.28779319f, 0.27306587f, -0.01723187f, 
    -0.51654708f, 0.07712597f, 0.00721522f, 0.04139601f, -0.01458495f, 0.16073464f, -0.00363473f, -0.15744741f, 
    -0.07563476f, -0.15224937f, -0.02027299f, 0.01485179f, 0.21202309f, 0.16205633f, 0.03635199f, -0.00554068f, 
    0.12067183f, 0.01184507f, 0.02007184f, -0.04256565f, 0.33287734f, -0.25427136f, -0.48080373f, -0.05554949f, 
    0.02336559f, 0.45703754f, -0.05437044f, 0.12212525f, -0.69485742f, 0.06281342f, 0.13084131f, -0.36457273f, 
    0.05715462f, -0.32939109f, 0.10928709f, -0.01252456f, 0.22587748f, 0.00045106f, -0.36131370f, -0.26681924f, 
    0.26890624f, -0.00062501f, 0.35083649f, 0.08569151f, 0.04916076f, -0.01950395f, -0.17960496f, -0.24375415f, 
    -0.22809578f, 0.10272597f, -0.26203871f, 0.24845137f, -0.19715859f, 0.14497262f, 0.13095818f, -0.22189003f, 
    0.32372707f, -0.09538521f, 0.07955672f, -0.30123100f, -0.09730966f, 0.02210788f, -0.17027214f, -0.02695747f, 
    0.26600605f, -0.11352520f, 0.08270773f, -0.18766315f, -0.09006730f, -0.09218192f, -0.17227687f, -0.22062089f, 
    -0.22877344f, -0.19507632f, 0.03806185f, 0.00955693f, -0.29880482f, 0.11304171f, 0.54391903f, -0.34573698f, 
    -0.13089536f, -0.01619243f, -0.19853607f, -0.33769605f, -0.64787191f, -0.04406785f, 0.05854255f, 0.09880295f, 
    0.01384486f, -0.01516575f, 0.06849010f, -0.03333115f, 0.13488038f, -0.14091176f, -0.14812854f, -0.05387166f, 
    -0.24038348f, 0.14842160f, -0.02672634f, 0.05339583f, 0.11967589f, 0.26364118f, -0.11346501f, -0.49533454f, 
    -0.09391838f, 0.01491759f, 0.20299903f, 0.00697975f, 0.18689981f, 0.27499649f, -0.15188867f, 0.44918156f, 
    0.16683842f, -0.22030561f, -0.20423520f, -0.34529006f, -0.13448934f, -0.03201452f, 0.16100964f, 0.29421961f, 
    0.13084967f, -0.39686763f, -0.02739899f, -0.01363256f, 0.41818830f, -0.16754161f, -0.06117625f, 0.20156433f, 
    0.12055903f, -0.15239592f, 0.09249181f, 0.15270342f, -0.02846461f, -0.09307148f, 0.23290046f, -0.15788744f, 
    0.07482100f, 0.05058876f, -0.03010971f, 0.20802279f, -0.05116609f, 0.15408677f, -0.15646499f, -0.00121131f, 
    0.06689695f, -0.06105122f, 0.38001940f, 0.07919630f, -0.04362443f, -0.02788590f, -0.12057277f, 0.06304499f, 
    0.00104336f, 0.15891775f, -0.03519000f, -0.06357723f, -0.16314739f, -0.04308267f, 0.12065739f, -0.06792092f, 
    0.06031660f, -0.07790367f, -0.02101590f, -0.04342625f, 0.14338885f, 0.08856367f, -0.12399698f, -0.04084750f, 
    0.20030829f, -0.10389573f, 0.07854167f, -0.11019642f, 0.00069385f, 0.01565647f, 0.18477282f, 0.13138625f, 
    0.06101359f, -0.11305649f, -0.09222975f, -0.06492341f, -0.47631943f, -0.06338431f, -0.14979404f, -0.28200567f, 
    -0.05449036f, -0.03352773f, -0.12127959f, -0.06171297f, -0.01812399f, 0.16001137f, -0.07149482f, -0.05593658f, 
    0.17420748f, 0.00555279f, -0.09085636f, -0.15261793f, 0.05926690f, 0.07601388f, -0.34583509f, 0.08826169f, 
    -0.03785349f, 0.19078249f, 0.14562701f, 0.06646754f, 0.04996643f, 0.14797807f, 0.08873843f, -0.49236161f, 
    -0.00301443f, 0.26896662f, -0.01052563f, 0.01516379f, -0.01225354f, -0.18663010f, -0.03891994f, 0.19287415f, 
    -0.04079056f, -0.10087364f, -0.03876854f, -0.22340184f, -0.02737192f, 0.03433779f, 0.07754568f, 0.07183686f, 
    -0.13502494f, 0.20543057f, 0.20141923f, 0.07785892f, 0.08816640f, -0.08969328f, -0.13253462f, -0.15609217f, 
    0.02874237f, 0.12887645f, 0.03328570f, -0.03465251f, 0.08003204f, 0.15339094f, 0.30606076f, 0.03954798f, 
    -0.26264301f, -0.02660955f, 0.10780244f, 0.04582201f, 0.13171639f, 0.05197129f, 0.05211211f, -0.09692039f, 
    0.05487028f, -0.47476265f, -0.05465558f, 0.05557553f, 0.48480770f, -0.09093499f, -0.06096742f, 0.20825677f, 
    0.20319277f, -0.05626117f, 0.22165447f, 0.00020911f, 0.04526206f, 0.10733890f, 0.03197742f, 0.35795876f, 
    -0.05283305f, -0.02855414f, 0.06507228f, -0.06338116f, 0.19787624f, 0.04464529f, 0.00425181f, -0.05892058f, 
    -0.13487597f, 0.20038542f, 0.10816425f, -0.08130762f, -0.25408560f, -0.16692786f, -0.11518559f, 0.06534468f, 
    -0.10270066f, 0.13691312f, 0.17986518f, 0.06885622f, 0.02872422f, -0.01255973f, 0.10879118f, 0.05893401f, 
    0.36594057f, -0.05691344f, -0.05441769f, -0.42623013f, 0.18771198f, -0.06307653f, -0.40412325f, -0.21558070f, 
    0.29523015f, -0.03061310f, 0.06879622f, -0.00269756f, -0.01044195f, 0.04686441f, 0.16716500f, 0.08038411f, 
    -0.13325073f, -0.09992539f, -0.05391657f, 0.14379288f, -0.25062302f, 0.16346847f, -0.22631398f, -0.67084014f, 
    0.03055146f, 0.04231097f, -0.00253474f, 0.00940016f, 0.16321799f, 0.05110735f, -0.10517937f, 0.30677375f, 
    0.09654165f, 0.01725063f, -0.09664192f, 0.27172813f, -0.24943730f, 0.09000015f, -0.43889654f, 0.18412995f, 
    0.06668834f, 0.08524310f, 0.11649124f, -0.15005699f, -0.00797145f, 0.31711689f, -0.18443201f, -0.22986764f, 
    0.27292782f, 0.28419757f, 0.03280058f, 0.11777462f, -0.25049606f, -0.47941557f, -0.01802312f, 0.13743767f, 
    -0.02454172f, 0.04997618f, 0.01415685f, 0.14151250f, 0.01468231f, 0.05692851f, 0.10666024f, -0.06318312f, 
    -0.39529943f, 0.27241945f, -0.06237233f, -0.04861357f, 0.11250860f, -0.01789542f, 0.07835222f, 0.05147548f, 
    0.07658098f, 0.21417819f, 0.06205979f, -0.05319655f, -0.05493531f, -0.06782462f, 0.33803743f, 0.07373886f, 
    -0.07989681f, -0.06323138f, 0.08459087f, -0.11410987f, 0.12625957f, -0.02340624f, 0.10851422f, 0.25174001f, 
    0.03924187f, -0.19849029f, -0.08136600f, 0.08667726f, 0.34719387f, 0.07396891f, -0.26911485f, 0.08044016f, 
    0.14607114f, 0.09295266f, -0.08923891f, 0.01253462f, 0.11385756f, -0.19416384f, -0.13347620f, 0.22419809f, 
    0.11990081f, -0.04038488f, 0.08287204f, -0.08071727f, -0.02241135f, -0.16792548f, -0.22266208f, 0.04301314f, 
    -0.23664421f, 0.13704261f, -0.32850897f, 0.08340953f, -0.22551972f, -0.17674127f, -0.17379935f, 0.06354377f, 
    0.07930979f, 0.08271481f, 0.03116014f, 0.14285335f, -0.00139099f, 0.07879034f, -0.00205008f, 0.22178040f, 
    0.20280467f, 0.11499663f, 0.02517135f, -0.17861022f, 0.12659876f, -0.06160630f, 0.10108349f, -0.09672300f, 
    0.01716390f, -0.13120268f, -0.41585049f, 0.11510207f, -0.15445131f, 0.07659891f, 0.33643103f, 0.06140640f, 
    -0.30494580f, -0.02951541f, 0.14355521f, -0.15704995f, 0.01432583f, -0.10096491f, -0.36721155f, 0.13248168f, 
    0.00937369f, 0.27351889f, 0.12057628f, 0.34002513f, 0.33300954f, -0.01243395f, -0.10052621f, 0.35404566f, 
    0.01417204f, 0.10894508f, 0.03980172f, 0.06870220f, -0.64728659f, -0.07005674f, -0.18495877f, -0.13207914f, 
    -0.11727332f, 0.49128711f, 0.12008362f, -0.03364633f, 0.07066675f, 0.24551862f, -0.51088107f, -0.78622967f, 
    0.04823637f, 0.27005687f, 0.13198252f, 0.25949892f, 0.17655297f, 0.03266767f, -0.33993220f, 0.17134424f, 
    -0.07500080f, -0.03189673f, -0.06581693f, 0.26627809f, 0.19538461f, -0.08275928f, 0.05098982f, 0.00822807f, 
    0.15877518f, 0.23961499f, -0.38054571f, 0.00212702f, 0.14984272f, 0.02019815f, 0.38783148f, -0.29252014f, 
    0.19364154f, 0.14541689f, 0.09318426f, -0.02849955f, 0.00926664f, -0.35582182f, -0.26451656f, -0.38831845f, 
    -0.07800339f, 0.13140750f, 0.26375562f, 0.14581674f, -0.02930582f, -0.01554769f, -0.09166416f, -0.43384251f, 
    0.02814597f, -0.06350448f, -0.00800331f, -0.04781350f, -0.00394294f, 0.04542230f, -0.03536144f, -0.09485525f, 
    0.00123922f, 0.01502456f, 0.03478206f, -0.06668452f, -0.05602365f, -0.09907351f, 0.04405291f, 0.00845933f, 
    -0.10410053f, 0.01712334f, -0.00337796f, 0.03827005f, -0.09009224f, 0.01541294f, -0.01974699f, 0.00950522f, 
    -0.00144893f, 0.01532358f, -0.06379781f, 0.03798883f, -0.07025047f, -0.08517552f, -0.10171170f, 0.03888783f, 
    0.01765179f, -0.03896924f, -0.05926493f, 0.03767108f, 0.07520703f, 0.03021477f, -0.01855987f, 0.02386140f, 
    -0.05349334f, -0.00820846f, -0.07367433f, 0.00883159f, -0.02750999f, -0.01829138f, -0.07574372f, -0.07140812f, 
    -0.05916205f, 0.02468562f, 0.05966994f, -0.05281536f, 0.00323879f, -0.00858783f, -0.08191551f, -0.07986712f, 
    -0.03325823f, -0.04334008f, -0.07544282f, 0.01078008f, -0.04507077f, -0.06352726f, -0.06123928f, -0.00263425f, 
    0.03653475f, 0.02831281f, -0.05449592f, -0.05833594f, -0.08891689f, -0.07254111f, 0.03093638f, 0.02342375f, 
    -0.05237250f, -0.04778604f, -0.10584744f, 0.06074470f, 0.03613867f, 0.03435507f, 0.04925328f, -0.06814995f, 
    0.02756725f, -0.07526245f, -0.09412817f, 0.00208898f, 0.03438335f, -0.04076032f, -0.05031301f, -0.00426401f, 
    0.08377463f, -0.02341297f, -0.09695661f, -0.07030134f, 0.08681789f, -0.02700216f, -0.02013007f, -0.05692884f, 
    0.07851548f, 0.06225343f, -0.00929369f, -0.03741807f, -0.03615346f, -0.04950071f, -0.07250008f, 0.04484062f, 
    0.01250748f, 0.01331550f, 0.08559027f, 0.04326237f, -0.05883653f, 0.04694057f, -0.07471868f, 0.03836867f, 
    -0.02701401f, -0.00081365f, -0.05797500f, -0.00466346f, 0.06647083f, 0.03276870f, -0.06074993f, 0.06391222f, 
    0.06136404f, -0.00004819f, -0.01750861f, -0.02757405f, -0.06126377f, -0.05669099f, -0.00816304f, 0.00906503f, 
    0.48903862f, 0.38019320f, 0.49629629f, 0.08052006f, -0.12612736f, 0.12211795f, -0.18645184f, 0.34714949f, 
    -0.53057641f, 0.00343614f, -0.11091325f, 0.16031662f, 0.18677430f, -0.24362950f, 0.31684658f, -0.12239068f, 
    -0.19441980f, 0.10203324f, 0.03944866f, 0.28375033f, 0.03096855f, 0.01788705f, -0.20102341f, -0.09974948f, 
    0.06937279f, -0.04945393f, -1.01312649f, -0.20648065f, 0.13273820f, -1.25205779f, -0.08661693f, 0.06609846f, 
    -0.15498371f, 0.03100449f, 0.02796829f, 0.03609554f, 0.01818147f, 0.03988130f, 0.46555176f, 0.05638700f, 
    0.02545118f, 0.04565206f, 0.08189555f, -0.11304756f, 0.09210773f, 0.26006794f, -0.19706847f, -0.17256777f, 
    0.17872852f, -0.06284921f, 0.17631733f, 0.14176530f, 0.29759440f, 0.05626869f, -0.01163442f, 0.11840075f, 
    0.20382926f, -0.15142083f, -0.09318665f, 0.28978842f, -0.08147206f, -0.41491157f, -0.03978758f, -0.51756847f, 
    0.08069842f, 0.08362105f, 0.14877449f, -0.27325982f, 0.27529421f, -0.01312337f, 0.06988342f, -0.35375199f, 
    -0.21306552f, 0.05953209f, 0.03023238f, -0.24365811f, 0.02921150f, 0.01595302f, -1.27678621f, 0.23164828f, 
    -0.20536514f, 0.11150271f, 0.11041819f, 0.04783388f, -0.06787598f, 0.26100343f, -0.10593165f, -0.12803304f, 
    0.22180064f, 0.07927460f, 0.03308655f, -0.07404960f, -0.26749983f, -0.17870553f, 0.08712923f, -0.16162394f, 
    0.06565058f, 0.04179427f, 0.00403490f, -0.48081279f, -0.09581384f, 0.01252415f, 0.12955070f, 0.06792355f, 
    0.04836214f, 0.50565439f, 0.27008703f, 0.09811905f, 0.10063543f, 0.14776997f, -0.30675787f, -0.52719814f, 
    0.15043420f, 0.27721685f, 0.00413581f, -0.06036935f, -0.16912925f, -0.47276220f, -0.43798444f, 0.41963062f, 
    0.09125337f, 0.03843502f, -0.10103621f, 0.02458669f, -0.11034273f, -0.03756056f, -0.00430916f, 0.16130154f, 
    0.43019345f, -0.51170886f, 0.04575350f, 0.08067459f, 0.09320772f, 0.11823675f, -0.14290391f, 0.21886288f, 
    -0.41312689f, 0.16815580f, -0.02224682f, -0.04955198f, -0.20882021f, -0.18424691f, -0.00318284f, -0.03616788f, 
    0.06954917f, 0.00901849f, 0.01002697f, 0.28864342f, 0.19355209f, -0.19659147f, -0.38852295f, 0.42160031f, 
    0.09399008f, 0.06032151f, 0.06075278f, 0.18238185f, -0.00681361f, 0.16625668f, 0.10107207f, -0.03806886f, 
    0.03344610f, -0.16381600f, -0.20673159f, 0.13107121f, 0.12060510f, 0.01246765f, 0.02877400f, 0.28336430f, 
    0.06596698f, 0.15852274f, -0.07303234f, -0.12857425f, 0.07422344f, 0.07345024f, -0.06245746f, -0.18604417f, 
    -0.01194356f, -0.13267767f, -0.30994067f, 0.22961892f, -0.09915268f, -0.07384107f, 0.12392776f, 0.10209950f, 
    0.04034606f, 0.04159998f, 0.10304008f, -0.19853878f, -0.02223295f, -0.36690530f, -0.12505782f, 0.54557794f, 
    0.24253666f, 0.32674006f, 0.21465567f, 0.27609721f, 0.15391456f, 0.02047863f, 0.00535808f, 0.00925214f, 
    -0.03507123f, 0.19622275f, 0.33356625f, -0.11988840f, -0.19524674f, 0.07651868f, 0.06755606f, -0.02940860f, 
    0.06269869f, 0.06730378f, 0.19794002f, -0.00075608f, 0.23919582f, 0.14458284f, -0.05920453f, -0.47330719f, 
    0.15441114f, -0.06604344f, 0.13344851f, 0.10898104f, -0.26809952f, -0.18565546f, -0.00416186f, 0.06649622f, 
    -0.06225493f, 0.05949264f, 0.02787054f, -0.10537511f, 0.23718646f, -0.13694742f, 0.16986670f, -0.01807339f, 
    0.06325453f, 0.35118833f, -0.04873079f, 0.11625835f, 0.10900715f, 0.01883651f, 0.24119429f, -0.27534547f, 
    0.13581760f, 0.01747626f, 0.11324546f, -0.03422773f, 0.14464314f, -0.25472641f, -0.20671664f, -0.07288501f, 
    0.07655513f, 0.21014528f, 0.10848900f, 0.20788242f, 0.02372745f, -0.04426376f, -0.11704168f, -0.24652748f, 
    0.24947856f, 0.31051090f, 0.34651446f, 0.03594541f, 0.45261949f, -0.54596752f, -0.11184210f, -0.07298033f, 
    -0.57325405f, 0.28394896f, -0.07372504f, -0.07930446f, 0.31407341f, 0.02163186f, 0.31696638f, 0.01600677f, 
    -0.18760996f, 0.13571168f, 0.03508581f, 0.08937778f, -0.17040917f, -0.00252809f, -0.02159315f, -0.15307190f, 
    0.35002214f, -0.17975749f, 0.03670314f, -0.22405668f, -0.34281883f, 0.13759066f, 0.10857523f, 0.01332567f, 
    -0.07081242f, 0.34848019f, -0.36182967f, 0.06051974f, 0.16034283f, -0.01777966f, -0.13507661f, 0.13348766f, 
    -0.07921157f, 0.22679862f, 0.18338419f, 0.19884412f, 0.06063008f, 0.04814638f, -0.18127815f, 0.13059019f, 
    0.28544712f, -0.37740284f, -0.38996968f, 0.08387186f, 0.16844365f, 0.03305919f, 0.27470818f, 0.06604053f, 
    0.10621941f, -0.31913638f, -0.59451407f, 0.07982295f, -0.16317023f, 0.13648495f, -0.11729189f, 0.13408570f, 
    -0.33040485f, -0.01932479f, 0.11630257f, 0.44634435f, 0.15193820f, -0.39059231f, -0.13844477f, 0.01104682f, 
    0.16700442f, 0.11546794f, -0.02918492f, -0.33934867f, 0.55929625f, 0.07706237f, -0.42095199f, 0.01600934f, 
    -0.07931906f, 0.24665166f, -0.08456935f, 0.00198350f, 0.10186483f, 0.14210370f, -0.35798657f, 0.03870288f, 
    0.29344249f, 0.27193597f, -0.07659930f, -0.03867973f, -0.25133190f, 0.59429622f, -0.38454899f, -0.00076200f, 
    0.06043828f, 0.00200325f, 0.03058613f, 0.32300806f, 0.12209736f, -0.09105355f, 0.24948235f, 0.03167692f, 
    0.27378926f, 0.25843143f, -0.13774075f, -0.02839529f, -0.09690318f, -0.26457003f, 0.68881685f, 0.23412138f, 
    0.25260386f, 0.39424890f, 0.02254799f, 0.03541765f, -0.29509604f, 0.07511520f, 0.28027272f, -0.01629652f, 
    -0.14962783f, -0.07249058f, 0.25961468f, -0.10076375f, -0.08066341f, -0.00527488f, -0.24676177f, 0.20647614f, 
    0.10038945f, 0.20609309f, 0.02888580f, -0.08793152f, 0.09442911f, 0.31507951f, 0.03373738f, 0.12340821f, 
    0.29589251f, -0.10848060f, 0.16965021f, -0.03985488f, -0.33111235f, -0.05686349f, 0.26990497f, -0.00256258f, 
    -0.16631049f, 0.10198617f, 0.06369489f, 0.35256237f, -0.15971422f, -0.05490027f, -0.04687501f, -0.26247901f, 
    -0.13234563f, -0.27470738f, 0.19931756f, 0.00974381f, 0.18854405f, 0.10882672f, 0.23328193f, -0.00288806f, 
    0.14483689f, -0.21024597f, 0.20067160f, 0.09633644f, -0.10632724f, 0.08212583f, 0.16634098f, 0.01720114f, 
    -0.15858942f, 0.06374289f, -0.25166506f, 0.03299302f, -0.45665720f, 0.23302981f, -0.09081881f, -0.00723236f, 
    -0.00660133f, 0.05633669f, 0.12798338f, 0.04291044f, 0.00702329f, -0.05559597f, -0.12934251f, 0.18270764f, 
    0.17473952f, -0.16500187f, 0.02812902f, -0.12431535f, 0.04408853f, -0.29011586f, -0.04797227f, -0.26362443f, 
    -0.25585520f, 0.01896259f, -0.09051473f, -0.15333529f, 0.15642732f, 0.09932131f, 0.12453970f, -0.28432596f, 
    -0.51977581f, 0.05149476f, 0.11317820f, -0.29944360f, -0.12400154f, -0.08599678f, -0.08214274f, 0.21916924f, 
    0.02562747f, -0.05171654f, 0.08672284f, 0.04535676f, 0.13064668f, -0.01165116f, -0.14728238f, 0.24538837f, 
    0.06488758f, 0.08813972f, -0.07918067f, -0.14368647f, 0.27530390f, -0.08082476f, 0.01047623f, -0.02637688f, 
    0.06570702f, 0.04280943f, 0.06655969f, -0.42036751f, -0.24869023f, 0.05485438f, -0.06084843f, -0.07270624f, 
    -0.08844846f, -0.02774365f, 0.17230663f, 0.21921591f, 0.33712572f, 0.11379655f, -0.34521192f, 0.28242755f, 
    0.16124871f, 0.04932756f, -0.09957238f, -0.04770850f, 0.02270095f, -0.28249082f, -0.12161516f, 0.04692906f, 
    0.10264554f, 0.10423711f, -0.12388711f, 0.28465319f, -0.24210006f, 0.06609147f, -0.13417915f, -0.00937044f, 
    0.10435919f, -0.31967595f, 0.17513929f, 0.03528060f, -0.61014062f, -0.18253550f, 0.04426732f, 0.03263984f, 
    -0.18561246f, 0.07268557f, 0.02757923f, 0.05176117f, -0.01023941f, 0.15955454f, -0.06536745f, 0.23717217f, 
    0.18337178f, 0.09387944f, -0.06172559f, -0.01301782f, 0.23796189f, -0.11925855f, 0.06461601f, 0.10685679f, 
    -0.09588046f, 0.10838229f, -0.24620983f, 0.09238639f, 0.07135137f, -0.15134339f, -0.14257039f, 0.03694337f, 
    -0.11034384f, 0.28931484f, 0.06830790f, -0.06669746f, 0.05069118f, 0.07181000f, 0.15341169f, 0.00595986f, 
    0.03828006f, 0.11509535f, 0.06998702f, 0.08158825f, 0.08217764f, -0.10009930f, 0.13231261f, 0.06817093f, 
    -0.11481634f, 0.00913780f, -0.15884319f, 0.08327258f, 0.03754018f, -0.00516033f, -0.04759865f, -0.16735615f, 
    -0.01078036f, -0.01518739f, 0.16804315f, -0.02558276f, 0.03055043f, -0.05209831f, -0.03995353f, 0.30274031f, 
    0.21638642f, 0.10628431f, 0.21760991f, 0.22041890f, -0.21459980f, -0.11818802f, -0.12636271f, 0.01687794f, 
    0.16042404f, 0.10565121f, -0.00540512f, 0.11822792f, -0.01503214f, -0.06890836f, -0.02886781f, 0.02526986f, 
    0.21709940f, 0.05645172f, 0.05539884f, 0.07169820f, 0.05009520f, 0.04883320f, -0.02726679f, 0.08257525f, 
    0.07443511f, -0.00695390f, 0.07318294f, 0.25139067f, -0.26581237f, -0.05158724f, 0.06686306f, 0.05482311f, 
    -0.03017683f, -0.01009591f, -0.03248642f, 0.33241519f, 0.13640714f, -0.12131163f, 0.16385235f, 0.03619160f, 
    0.21992399f, -0.09309956f, -0.07482921f, -0.03408472f, -0.07768884f, 0.03619973f, -0.05094061f, -0.26343811f, 
    0.08520010f, 0.38532877f, 0.09942742f, 0.02426890f, 0.07504176f, 0.04502708f, 0.09563422f, -0.16560192f, 
    -0.10235338f, 0.03458232f, 0.00260902f, 0.03250083f, 0.11282516f, -0.03711695f, 0.08742700f, -0.03403927f, 
    -0.38880765f, 0.20127739f, -0.61218756f, -0.02321515f, -0.32843870f, -0.47369123f, -0.16224307f, -0.13015476f, 
    -0.26450148f, 0.17494258f, -0.12722348f, -0.05578899f, 0.14343934f, 0.10014158f, -0.01392192f, -0.24734640f, 
    -0.90745497f, 0.03655577f, 0.06166034f, -0.05267395f, -0.14010289f, 0.06359828f, -0.08424440f, -0.01006369f, 
    0.23625444f, -0.40754518f, 0.26953042f, -0.17928259f, -0.02450455f, 0.23834147f, -0.36265999f, 0.02246884f, 
    -0.04608626f, -0.58476001f, 0.01209598f, 0.09342800f, 0.26540044f, -0.03924171f, 0.00086296f, -0.10909760f, 
    -0.11011191f, 0.11690328f, 0.20973770f, 0.31768176f, 0.08523060f, 0.07248632f, 0.00800590f, 0.13359380f, 
    0.26403391f, 0.13124414f, -0.27973449f, -0.22113061f, 0.21133497f, 0.05600576f, -0.18286037f, 0.19321418f, 
    -0.04319483f, -0.42453739f, -0.49710310f, 0.11813018f, -0.22938025f, -0.00018865f, 0.36491048f, -0.06054021f, 
    -0.55845785f, -0.13941136f, -0.10981733f, -0.40758404f, 0.00733021f, 0.01150704f, 0.15110406f, -0.07791141f, 
    -0.79763693f, -0.46287555f, 0.24594666f, 0.14872395f, 0.42402291f, 0.06130025f, 0.11159131f, 0.15793535f, 
    -0.03525513f, 0.20610534f, 0.02327342f, -0.09889534f, -0.14364114f, -0.05467459f, 0.17058741f, -0.00854357f, 
    0.14354035f, -0.23446158f, 0.00420779f, -0.43423527f, -0.51222956f, -0.11499950f, -0.06041755f, -0.32465824f, 
    0.06964281f, -0.08429873f, -0.00608806f, -0.05142007f, -0.32204047f, 0.18797117f, -0.01520165f, -0.04520679f, 
    -0.53628683f, -0.42172426f, 0.05980684f, -0.00410613f, -0.57514518f, -0.34070376f, -0.03781900f, -0.45021340f, 
    -0.81494409f, -0.07530433f, -0.43438476f, 0.01522544f, -0.53963858f, -0.27135518f, -0.47516397f, 0.05602101f, 
    0.31255206f, -0.11701418f, -0.22650661f, -0.23801924f, -0.06793119f, -0.03686893f, -0.05602697f, 0.26387820f, 
    0.07434009f, -0.04970956f, 0.03137429f, -0.08314624f, 0.41705453f, 0.04080297f, 0.03170367f, 0.00536080f, 
    0.11802635f, -0.06726430f, 0.03393864f, 0.48181298f, 0.06695094f, 0.28073755f, -0.04856658f, 0.04263188f, 
    0.03154097f, -0.05140887f, -0.00353112f, -0.02528956f, 0.22994672f, -0.06220157f, -0.11539691f, -0.06248253f, 
    0.19068325f, 0.05119846f, 0.11384213f, 0.07043059f, 0.00673579f, 0.14285184f, -0.00270305f, 0.02254989f, 
    0.12008879f, 0.10401489f, 0.00622567f, -0.13387738f, 0.60306299f, -0.03664036f, 0.08597743f, 0.06683528f, 
    0.11009105f, -0.14733563f, -0.00623098f, 0.19392590f, 0.02601494f, -0.00962620f, -0.01176109f, -0.14299341f, 
    0.04094690f, -0.15383853f, 0.05054256f, -0.22878349f, 0.10879867f, -0.06225445f, -0.13850757f, -0.09186405f, 
    0.02715870f, 0.01130062f, 0.23354723f, 0.07188204f, -0.15304103f, -0.26074988f, -0.18003069f, -0.09173434f, 
    0.17415152f, -0.11300349f, -0.08056363f, -0.14807342f, 0.06078947f, 0.06398490f, 0.08318098f, 0.00712430f, 
    0.37433505f, 0.07824018f, -0.16014181f, -0.05896249f, -0.26507661f, 0.05404479f, 0.15736812f, 0.14615954f, 
    0.01272504f, 0.21059300f, -0.00301037f, -0.06402255f, 0.02028736f, 0.25365674f, 0.30800191f, -0.45155969f, 
    0.18939549f, 0.08501833f, 0.03378874f, 0.24998143f, 0.24348637f, -0.44003767f, 0.04125866f, 0.06511244f, 
    0.00647852f, -0.02925220f, 0.06384412f, 0.17080657f, -0.08791751f, -0.14112510f, 0.03694959f, -0.00555183f, 
    -0.28957605f, 0.32620037f, 0.38722593f, 0.02791950f, 0.18364571f, 0.03050384f, -0.62847793f, -0.23254417f, 
    0.01728884f, -0.14930001f, -0.13719012f, -0.03352959f, 0.09865487f, 0.30115819f, 0.13351296f, 0.15694387f, 
    -0.02106518f, -0.00816250f, -0.05921115f, 0.02248139f, -0.01558666f, 0.02554095f, 0.17574403f, -0.07516592f, 
    0.17861518f, 0.42018816f, 0.30475605f, -0.01128983f, 0.71340805f, -0.08281433f, -0.11816977f, -0.05473194f, 
    -0.19850336f, 0.14132103f, 0.01501655f, 0.25864506f, 0.24794629f, 0.16577907f, 0.01056166f, 0.15710598f, 
    -0.15775652f, -0.04492022f, -0.01409057f, 0.10075402f, -0.11671536f, -0.11095505f, -0.25808024f, -0.00606674f, 
    0.14264706f, -0.14519332f, 0.12807235f, -0.03424456f, -0.12667044f, 0.41838002f, -0.00547332f, -0.06563133f, 
    -0.01950458f, 0.04749248f, -0.07801990f, 0.06713038f, 0.10948344f, -0.04372479f, 0.09634964f, 0.13280573f, 
    -0.03736174f, 0.03955461f, 0.10242712f, 0.25687605f, -0.06836926f, -0.01150493f, 0.09257768f, -0.08781525f, 
    0.10225414f, -0.15760329f, -0.44665730f, 0.09213562f, 0.27100503f, 0.00433410f, 0.10063971f, 0.03918847f, 
    0.09051224f, -0.13442644f, 0.07644691f, 0.02631436f, -0.02900305f, 0.02950712f, 0.15306623f, 0.64139462f, 
    -0.27474064f, 0.03361612f, 0.17849608f, 0.46948609f, 0.39163229f, -0.25531849f, -0.02670495f, -0.02236996f, 
    0.05027531f, -0.00845084f, -0.04633505f, -0.05385454f, 0.38551655f, -0.01176375f, 0.05973557f, 0.05164427f, 
    -0.12883607f, 0.32751498f, -0.02596656f, -0.05941535f, -0.08088287f, 0.20493062f, 0.11476879f, 0.14877908f, 
    0.04702429f, -0.08597268f, 0.17821437f, 0.31335014f, -0.18934543f, 0.47939321f, -0.13519630f, -0.07137787f, 
    0.02213167f, 0.04101693f, 0.00434829f, 0.28580329f, -0.08979543f, -0.12264818f, 0.12014024f, -0.06255239f, 
    0.16951883f, 0.38148567f, -0.03625863f, 0.00698237f, 0.03025789f, -0.00938468f, 0.17253159f, -0.34050652f, 
    0.15048413f, 0.12803799f, 0.00843676f, -0.06760179f, -0.10560244f, -0.09023342f, -0.43631795f, -0.09297913f, 
    -0.00815242f, 0.03394810f, 0.05844514f, -0.05642395f, -0.11724252f, -0.04071723f, -0.18134749f, 0.06203248f, 
    -0.02121147f, -0.08967542f, -0.08771674f, -0.01035595f, 0.49118155f, 0.23867193f, -0.03380398f, 0.32845455f, 
    0.26720926f, 0.10309942f, 0.21050458f, 0.18045716f, -0.10481084f, 0.16340652f, -0.01652856f, 0.15596965f, 
    -0.13255969f, -0.13293500f, 0.03093380f, 0.17590366f, 0.09656996f, -0.19856128f, 0.12847228f, 0.20017554f, 
    -0.18025295f, -0.02649140f, 0.18754724f, -0.04418261f, -0.05587691f, 0.20676593f, 0.14252535f, 0.05326987f, 
    -0.11621284f, -0.10753167f, 0.27192834f, 0.07482594f, -0.27112314f, -0.07375216f, 0.30232817f, 0.15619667f, 
    0.36078304f, 0.03223431f, -0.32253000f, -0.46820816f, 0.08803363f, -0.05006110f, -0.21599331f, -0.18152417f, 
    0.04729230f, -0.06064608f, -0.03678700f, -0.05324635f, -0.06021025f, 0.03326651f, 0.31887937f, -0.04522677f, 
    -0.26719052f, 0.01609124f, 0.20184737f, 0.06483284f, -0.12072759f, -0.24765031f, -0.19566114f, 0.49390638f, 
    0.07670333f, -0.08913069f, 0.38969705f, -0.22498576f, 0.32705101f, -0.38387367f, -0.22709250f, 0.35077101f, 
    0.02303856f, 0.08618466f, -0.01706067f, 0.22140515f, -0.30125207f, -0.02781674f, 0.24110821f, 0.24817169f, 
    0.16225807f, 0.31854603f, -0.04753878f, -0.11672013f, 0.01869731f, 0.11702665f, 0.24591899f, -0.02668269f, 
    0.00875265f, -0.05931067f, 0.01132581f, 0.02528691f, 0.01578357f, -0.03853786f, 0.10615103f, -0.14537916f, 
    0.04599203f, -0.04050319f, 0.08066840f, 0.41289979f, -0.14586844f, -0.23641980f, -0.19488531f, 0.05268978f, 
    -0.46064582f, 0.14479034f, 0.13561803f, -0.28916743f, 0.13903119f, 0.07136158f, 0.13518822f, 0.48815355f, 
    -0.01746117f, 0.06295618f, 0.01704327f, -0.07522166f, -0.03992126f, -0.00423593f, -0.25113261f, -0.12644082f, 
    0.11646968f, 0.04917450f, -0.04470415f, -0.00843426f, -0.47754711f, 0.07290187f, 0.03402924f, -0.06025706f, 
    -0.19256014f, 0.44275105f, -0.17116965f, 0.00592897f, 0.00745448f, -0.04877556f, 0.20437150f, -0.61406857f, 
    -0.44720396f, 0.17896259f, 0.26640251f, 0.05835590f, 0.07546312f, 0.00163287f, 0.17654999f, -0.33275357f, 
    -0.13264538f, -0.03311999f, 0.01539174f, -0.20920415f, 0.01268648f, -0.02520736f, 0.24063164f, -0.29764402f, 
    -0.06047778f, 0.00683032f, -0.22838625f, 0.01316140f, -0.08034351f, 0.14973982f, 0.41027552f, -0.04325253f, 
    -0.09195144f, -0.42076272f, -0.10004905f, 0.03159973f, 0.67793131f, -0.02766959f, -0.13743827f, -0.02276776f, 
    0.02456918f, 0.27601621f, 0.13506566f, 0.73332381f, -0.13721831f, -0.03624547f, 0.02649874f, 0.31640238f, 
    -0.06073008f, 0.16636524f, -0.04762185f, 0.01099566f, 0.01082353f, 0.05220519f, 0.19826628f, 0.17836930f, 
    0.41322368f, -0.05114388f, -0.24921003f, -0.03349562f, 0.20486361f, 0.03781257f, 0.17572658f, 0.21018282f, 
    -0.04979339f, -0.13216873f, 0.10076764f, -0.33124498f, 0.06434396f, 0.10002191f, 0.28672406f, 0.44364798f, 
    -0.19814971f, -0.04726453f, 0.23257405f, 0.05038778f, 0.19681600f, -0.07782486f, -0.18549970f, 0.24442443f, 
    0.15725638f, 0.01770107f, -0.08181963f, -0.05824662f, -0.09040815f, -0.00241529f, -0.11857199f, 0.36243787f, 
    0.03229942f, -0.28549430f, 0.08677164f, -0.32458964f, -0.46697992f, -0.22512753f, 0.02654813f, -0.15782607f, 
    0.04450434f, -0.02963937f, -0.06477937f, 0.19342677f, -0.13937649f, 0.25152653f, 0.13491084f, 0.07102325f, 
    -0.17484759f, -0.27942696f, 0.12955478f, 0.07353603f, -0.24742508f, -0.20262682f, -0.15928911f, -0.07595526f, 
    0.01324249f, -0.34456632f, -0.12641761f, 0.08421185f, -0.10573205f, -0.19670431f, -0.08891077f, 0.09884723f, 
    0.14220016f, 0.14718221f, 0.06481702f, -0.07363002f, 0.09888358f, -0.05436895f, 0.08986809f, -0.16142474f, 
    -0.08846711f, -0.08438321f, -0.12209418f, 0.00698277f, 0.45205003f, 0.35423353f, -0.25279406f, 0.24532406f, 
    0.48111945f, -0.19904017f, 0.04636837f, 0.13178274f, -0.30625331f, -0.34774965f, 0.03386661f, -0.12247057f, 
    0.19093229f, 0.02731291f, -0.05974245f, 0.18003833f, -0.23935950f, -0.03503493f, -0.23667724f, 0.17998549f, 
    -0.11926334f, 0.02292863f, -0.34171665f, 0.14742643f, -0.21821953f, -0.44696438f, 0.32811344f, -0.04379870f, 
    0.02299073f, -0.27857301f, 0.20931163f, -0.21689981f, 0.22997856f, 0.01173548f, 0.10059588f, 0.26940450f, 
    0.08742722f, 0.16672219f, -0.24069442f, 0.22537525f, -0.27314344f, 0.09835996f, 0.23047620f, 0.10816929f, 
    -0.09673031f, 0.05975758f, -0.17638589f, -0.18596469f, -0.20216806f, 0.04046950f, 0.12827225f, 0.22775508f, 
    0.10538153f, -0.16805039f, 0.30816716f, -0.25239080f, -0.13875830f, -0.36999050f, -0.51335919f, -0.09309051f, 
    -0.06611396f, 0.12897903f, -0.13966371f, -0.04705960f, 0.20595421f, -0.01263617f, 0.07111332f, -0.00052891f, 
    -0.15253787f, 0.13347280f, -0.06971606f, -0.12873073f, -0.29987636f, 0.04801124f, 0.21350910f, 0.20434234f, 
    0.01713657f, 0.33258441f, -0.03696440f, 0.17722733f, 0.31726521f, 0.03573630f, -0.25528073f, -0.26620299f, 
    0.02112938f, 0.15610284f, 0.11602639f, -0.02946201f, 0.59419262f, -0.44101590f, -0.09767458f, 0.07464457f, 
    0.03015839f, -0.01160304f, -0.06538159f, -0.06990885f, -0.12329245f, -0.04104098f, 0.01099148f, -0.04477026f, 
    -0.06428155f, 0.11560897f, 0.27908403f, 0.07462934f, 0.17485888f, -0.19840437f, -0.41692722f, -0.01275474f, 
    0.06555339f, -0.10841291f, -0.09856540f, 0.04774041f, 0.03156937f, -0.14921299f, 0.01750605f, -0.26827052f, 
    -0.24849120f, 0.12280485f, 0.07343785f, 0.45895869f, -0.12507439f, 0.06104738f, -0.01030141f, -0.56210709f, 
    -0.10912190f, -0.09746293f, -0.21013597f, -0.01519322f, -0.65525019f, 0.10016387f, -0.00307243f, 0.12762354f, 
    0.24652086f, 0.07390177f, 0.05507641f, -0.03736272f, 0.01288318f, 0.03134848f, 0.09010951f, 0.33184004f, 
    -0.06554836f, 0.08717147f, 0.07004724f, 0.09733780f, 0.04899941f, 0.07659645f, 0.09911996f, -0.06286398f, 
    -0.10250082f, 0.12632050f, 0.02484149f, -0.03774461f, 0.01875693f, -0.20986176f, 0.01319385f, -0.00321104f, 
    0.07214732f, -0.01726545f, 0.22997874f, 0.05212676f, -0.28865510f, 0.01963064f, 0.20912668f, -0.12971130f, 
    0.15222768f, 0.03543257f, -0.11966094f, -0.38621262f, -0.20849203f, 0.05623908f, 0.03285375f, -0.04161554f, 
    -0.04180322f, 0.13293318f, 0.20647810f, 0.10445510f, 0.09679677f, 0.04576502f, -0.08212113f, 0.01060870f, 
    0.13963880f, -0.00685987f, 0.15049145f, 0.12824447f, 0.19956473f, 0.06405171f, -0.08993311f, -0.41798356f, 
    0.01641657f, 0.03981952f, -0.06594706f, -0.14601159f, -0.08792578f, 0.06409257f, 0.03741547f, 0.11869762f, 
    -0.33167750f, -0.01567017f, -0.01710378f, 0.14485852f, -0.30918255f, 0.02398771f, 0.18631649f, 0.20009696f, 
    0.06336922f, -0.35908383f, 0.07045148f, -0.16896264f, 0.02160672f, 0.04057105f, -0.62703365f, 0.04547147f, 
    0.24645260f, 0.00449286f, 0.00323208f, -0.06377133f, 0.17681250f, -0.49668229f, 0.04416121f, 0.06616676f, 
    -0.02975259f, 0.06376300f, 0.04743170f, -0.01405848f, -0.03910199f, 0.02403527f, -0.14087634f, 0.10972089f, 
    0.06317700f, -0.30131337f, 0.07201608f, 0.02633486f, 0.01045714f, 0.20704114f, -0.15015821f, 0.01009693f, 
    0.11176920f, 0.00118020f, 0.02705262f, 0.10330721f, -0.06930575f, -0.55603164f, -0.53083789f, 0.06713023f, 
    0.12105563f, 0.06388056f, -0.08380805f, 0.13338202f, -0.04801730f, 0.02760316f, 0.04823139f, 0.14081182f, 
    -0.11817432f, 0.27072150f, 0.01508198f, -0.06074887f, -0.14128944f, -0.09299090f, -0.07553831f, 0.18844864f, 
    -0.34009469f, -0.02978284f, 0.07204301f, 0.03144175f, 0.01290928f, 0.19749297f, 0.03891312f, -0.36155015f, 
    -0.28272885f, 0.13911165f, -0.06307592f, 0.18898354f, 0.00907193f, 0.17879091f, 0.00507829f, 0.10386354f, 
    0.16617341f, -0.11305892f, -0.14710791f, -0.00248604f, 0.04742744f, -0.15219364f, 0.26870981f, 0.00558114f, 
    -0.14835320f, -0.25063157f, 0.30741942f, 0.04057447f, 0.37455991f, -0.07503909f, 0.04865533f, -0.14415188f, 
    0.16611511f, 0.09317544f, 0.16912229f, 0.42668664f, 0.04983290f, 0.11167800f, 0.12253215f, -0.19494574f, 
    0.05562094f, 0.00252095f, -0.08961135f, -0.09713089f, 0.17892809f, 0.03395423f, -0.21241903f, 0.05284889f, 
    0.17672895f, -0.21857432f, 0.06287051f, 0.19336808f, -0.45577848f, 0.05923300f, 0.28182012f, 0.04142522f, 
    -0.25420910f, -0.12344195f, -0.10529601f, -0.32510778f, 0.06775318f, -0.11897508f, 0.17131364f, -0.56175649f, 
    -0.12637691f, -0.23689732f, -0.10575851f, 0.28397766f, 0.37059543f, -0.10838494f, 0.16201434f, 0.40203673f, 
    -0.01145439f, 0.02300633f, 0.00317022f, 0.05279851f, -0.05303216f, 0.02983915f, 0.06570774f, 0.55135715f, 
    -0.11381812f, 0.24204071f, 0.09238474f, -0.56777245f, -0.40467486f, 0.00537081f, 0.09995582f, -0.42409253f, 
    -0.07579597f, -0.10606702f, 0.04358514f, 0.03970049f, -0.50931984f, 0.15027785f, 0.13072316f, 0.04779719f, 
    -0.37990642f, -0.02365546f, 0.04543768f, -0.07580817f, -0.05359727f, -0.18681186f, -0.06290200f, -0.41332489f, 
    -0.14157186f, 0.21179627f, -0.16917187f, -0.03570160f, -0.39819321f, -0.19837466f, -0.50362980f, 0.20371266f, 
    0.15431756f, -0.08268414f, -0.16379745f, 0.00729165f, 0.10101929f, -0.07696921f, 0.32676589f, 0.35507119f, 
    -0.14996019f, 0.46526423f, -0.26735735f, 0.02737985f, -0.14161591f, 0.05746090f, 0.21479309f, -0.36294621f, 
    -0.32563347f, 0.02527724f, 0.10381325f, 0.18949099f, 0.25950485f, 0.03745602f, 0.13102947f, 0.13339442f, 
    0.01873989f, 0.06027021f, -0.05153831f, -0.17873448f, 0.04421639f, -0.03715681f, 0.26310131f, -0.09217271f, 
    0.07301406f, -0.10714068f, -0.31797111f, -0.13985121f, 0.07269472f, 0.06073931f, 0.10268367f, -0.05869612f, 
    0.00706971f, 0.07432292f, 0.04981305f, -0.04129665f, -0.10049692f, 0.08999359f, -0.13745408f, -0.23439190f, 
    -0.01384465f, 0.09979807f, 0.27517435f, 0.53567237f, 0.08957834f, -0.03011253f, 0.11696523f, 0.25954339f, 
    -0.14429200f, 0.14465302f, 0.06526969f, 0.05467680f, -0.03874415f, -0.06495798f, 0.11910477f, 0.04755196f, 
    0.22324461f, 0.07544338f, -0.11183318f, 0.18243977f, 0.09287447f, 0.28136185f, 0.20607631f, 0.04485775f, 
    0.03730493f, -0.00481878f, 0.26316962f, -0.27825466f, 0.04346152f, -0.01672969f, 0.17716706f, -0.00921659f, 
    -0.01395592f, -0.20686515f, 0.16927606f, 0.00207416f, 0.35164371f, 0.03863983f, -0.35823089f, 0.07198463f, 
    0.04073907f, -0.10592400f, -0.02556130f, 0.20782606f, -0.12667552f, -0.16096923f, 0.30195364f, 0.18051395f, 
    -0.11164315f, -0.27211091f, -0.06296839f, -0.07052660f, -0.20025951f, 0.64363039f, 0.24194220f, -0.11588875f, 
    0.01168472f, -0.00182480f, 0.07098070f, 0.02920084f, 0.15108246f, 0.09579665f, -0.02709345f, -0.00741709f, 
    -0.20412576f, -0.55290538f, 0.11705436f, 0.11422919f, -0.25929314f, 0.11167998f, -0.07485766f, 0.03392068f, 
    0.08708275f, -0.11438920f, 0.08010611f, -0.00679295f, -0.01154410f, -0.00004720f, -0.22649893f, 0.25372624f, 
    0.13424751f, 0.00074621f, 0.06199676f, -0.20449604f, 0.15707655f, -0.08316104f, 0.10170126f, -0.07422920f, 
    0.13697854f, -0.39998367f, 0.13589506f, 0.02277393f, 0.20948647f, -0.08519512f, -0.08082387f, 0.16247594f, 
    0.07035680f, 0.07599039f, 0.03929006f, 0.08294167f, 0.08924589f, -0.03169298f, 0.02668376f, 0.17065719f, 
    0.21414445f, 0.06292157f, -0.06129441f, -0.06337249f, -0.09137048f, -0.02092415f, 0.01888520f, 0.33548096f, 
    0.10537338f, 0.16460958f, -0.03016979f, 0.12071569f, -0.04663432f, 0.09337701f, -0.12725684f, 0.06429961f, 
    -0.03297463f, 0.01018637f, 0.05027457f, 0.00967656f, 0.04123701f, -0.05689482f, 0.02975390f, 0.06631805f, 
    0.18630287f, 0.12824045f, -0.06054337f, -0.21702920f, 0.11288602f, 0.07796673f, 0.08307112f, 0.17332096f, 
    0.09984272f, -0.10505119f, -0.22304802f, -0.05366143f, -0.06967121f, -0.00241875f, 0.06533249f, -0.06172016f, 
    -0.20792875f, -0.07055425f, 0.08475133f, -0.05921339f, -0.05116593f, 0.03897623f, 0.00541400f, 0.34388793f, 
    -0.02642484f, 0.06756252f, 0.06270105f, 0.25302052f, -0.06933033f, -0.16280520f, -0.13139074f, 0.07034236f, 
    0.23397805f, 0.06532654f, -0.13019367f, 0.08116216f, 0.09010310f, -0.01928432f, 0.13889144f, 0.06890478f, 
    0.23611148f, 0.24153998f, -0.03775348f, -0.02379109f, 0.19515893f, 0.13049372f, -0.22397803f, 0.01131711f, 
    0.11035345f, 0.24010837f, 0.01599264f, 0.34745449f, 0.09705362f, 0.34672242f, -0.05951574f, 0.15027116f, 
    -0.05217978f, -0.01999841f, -0.03672916f, 0.28274286f, 0.09720446f, 0.04381014f, -0.00855311f, 0.00624611f, 
    0.19401307f, 0.05965687f, -0.17418166f, 0.04887469f, -0.01342889f, -0.10365294f, 0.04122236f, 0.50032490f, 
    0.09618457f, 0.44771931f, -0.00033118f, 0.00334298f, -0.03857990f, 0.01032601f, 0.92192721f, -0.15030731f, 
    -0.03634017f, -0.00069605f, 0.14336865f, 0.11498480f, 0.18253247f, 0.08783017f, 0.06586767f, -0.11198572f, 
    0.06019196f, -0.01537355f, -0.09083459f, -0.00255576f, -0.03217802f, -0.09215065f, -0.09236782f, 0.04487550f, 
    -0.08930054f, -0.10008015f, -0.09975428f, 0.01450446f, 0.07754698f, 0.04540050f, -0.08731478f, -0.03156256f, 
    0.02301404f, 0.03095702f, -0.06234329f, 0.03858267f, -0.09299982f, 0.03761842f, -0.02833164f, -0.04011467f, 
    -0.05351985f, -0.10085973f, -0.00844096f, 0.06687811f, 0.04020596f, -0.08166601f, 0.00065905f, 0.08073524f, 
    -0.04888818f, -0.02200503f, -0.06518690f, -0.02438701f, -0.01071576f, 0.08290651f, 0.01587370f, -0.00047094f, 
    0.01643822f, 0.00097088f, 0.04830518f, -0.01834934f, -0.10642803f, 0.00270154f, -0.02818882f, -0.06090836f, 
    -0.02207722f, -0.00414219f, 0.02858157f, -0.03056242f, -0.07872572f, 0.02800398f, 0.06490095f, 0.00407630f, 
    -0.05362487f, -0.07344028f, 0.02378564f, -0.02881428f, 0.03140933f, 0.01649438f, 0.00136703f, -0.03177699f, 
    0.00843725f, -0.03211679f, -0.08836216f, -0.01057626f, 0.03972530f, -0.04011961f, -0.04052673f, 0.02900049f, 
    0.00339563f, 0.03460069f, -0.07625952f, -0.04763817f, -0.01980824f, 0.00745336f, 0.04992593f, 0.05759122f, 
    -0.04772957f, -0.09786685f, -0.09514034f, 0.00166233f, 0.06040277f, -0.07003631f, -0.01887592f, 0.07934075f, 
    0.00834657f, 0.01657030f, -0.08097328f, 0.01887860f, 0.06804430f, 0.06642859f, 0.01041323f, -0.01976796f, 
    -0.00845157f, 0.04655106f, 0.07074417f, -0.01357070f, -0.06270598f, -0.05626217f, -0.03695899f, -0.04818742f, 
    0.05232316f, -0.02058755f, 0.04155641f, -0.02116855f, -0.02391556f, -0.01796516f, -0.02881515f, -0.03741296f, 
    -0.08231375f, -0.04231543f, -0.09447185f, -0.04307655f, 0.03218473f, -0.00013149f, 0.01702211f, 0.03504455f, 
    -0.08753452f, 0.00813657f, 0.04694965f, 0.02224179f, -0.06027135f, -0.03035782f, 0.02863063f, 0.03933373f, 
    0.20200218f, -0.14316101f, -0.02785921f, 0.02400490f, 0.58028716f, 0.05916485f, -0.05466987f, 0.02210221f, 
    -0.09709077f, -0.16889688f, -0.07977391f, 0.39490026f, 0.22391339f, 0.27606171f, -0.13083640f, -0.03498445f, 
    0.10841462f, 0.10822602f, 0.04136778f, -0.07941654f, 0.08648605f, 0.08577571f, -0.18619959f, 0.07927526f, 
    -0.27963817f, 0.11065683f, 0.48647013f, 0.01884562f, 0.05478806f, 0.42450261f, -0.22864667f, -0.07013198f, 
    0.08724204f, 0.33201912f, 0.02794619f, -0.12221491f, -0.13126256f, -0.01550575f, 0.15634960f, 0.12605478f, 
    0.04415345f, -0.05721979f, 0.09016081f, -0.11160387f, 0.22115146f, -0.12519692f, 0.02388945f, -0.08263168f, 
    -0.01415657f, -0.14760821f, -0.13363610f, -0.10053603f, 0.04549528f, 0.06867234f, 0.25275362f, -0.15133549f, 
    -0.34702650f, 0.09691225f, -0.05404440f, 0.03930324f, -0.14131382f, 0.21818388f, -0.20401779f, 0.49152231f, 
    0.35666645f, 0.10564579f, 0.14464638f, 0.12554371f, 0.19000667f, 0.06058153f, -0.10540058f, 0.19634023f, 
    0.19765256f, 0.03212574f, -0.09035241f, 0.07683457f, -0.08244045f, 0.04333724f, 0.14032783f, -0.14960793f, 
    -0.03677867f, 0.35328496f, 0.05698371f, 0.03513715f, -0.02516614f, 0.13453798f, 0.40320387f, -0.43360069f, 
    -0.09293749f, 0.04038598f, 0.18273355f, 0.37287021f, 0.06491099f, -0.38646948f, -0.01360012f, 0.27015942f, 
    0.02589691f, 0.02089308f, -0.08568274f, 0.23007119f, 0.21555062f, -0.09263196f, 0.10181770f, -0.03680031f, 
    -0.01740381f, 0.35754830f, 0.05833216f, -0.00144341f, 0.04720510f, -0.11652451f, 0.11756642f, -0.53843474f, 
    -0.05096030f, 0.02112645f, 0.03323837f, -0.09090517f, 0.01938920f, 0.13108394f, 0.00071463f, 0.07472584f, 
    -0.11158563f, 0.01607102f, 0.21490760f, -0.04327918f, 0.34207916f, 0.06026532f, 0.14325571f, 0.10482121f, 
    -0.08931352f, -0.05831601f, -0.02231784f, -0.02720072f, 0.01591861f, -0.00579392f, -0.05725687f, -0.05710590f, 
    -0.08133603f, -0.07446261f, 0.03501933f, -0.03048085f, -0.06951538f, -0.10175920f, -0.04826732f, -0.00138195f, 
    -0.07681053f, -0.06546564f, -0.02788836f, 0.01505948f, 0.00879398f, 0.01852191f, 0.06164948f, 0.05776773f, 
    -0.00538851f, -0.07561582f, 0.07396836f, -0.03949705f, 0.00250919f, 0.08001977f, -0.00676373f, 0.00789206f, 
    -0.01533958f, 0.04164668f, -0.01032597f, 0.02863733f, 0.00796649f, 0.04190520f, -0.02523966f, 0.00287831f, 
    0.05569111f, -0.07672697f, -0.05596209f, -0.03278445f, 0.02262120f, 0.05476859f, 0.06747010f, -0.04364811f, 
    -0.04887071f, -0.05270437f, -0.06471644f, -0.04044305f, 0.00857315f, 0.02115979f, -0.02825780f, -0.04167530f, 
    0.06959914f, 0.04110589f, -0.05991445f, -0.01596580f, -0.04760448f, 0.01837108f, -0.07359714f, -0.00736165f, 
    -0.06441437f, -0.01563056f, -0.02333402f, -0.08876789f, 0.05764472f, -0.08458371f, -0.01119406f, 0.01559458f, 
    -0.08660160f, -0.05848524f, -0.06492417f, -0.09507315f, -0.07551942f, 0.02433243f, -0.05765512f, -0.00954623f, 
    0.03127688f, -0.07268865f, -0.02641783f, 0.00794524f, -0.01459858f, 0.03026713f, -0.01887332f, 0.04839535f, 
    -0.08244298f, -0.00946266f, -0.03246119f, -0.03237217f, -0.01978611f, 0.04721618f, -0.07137357f, -0.07534035f, 
    -0.04188890f, -0.02761456f, -0.03451755f, -0.04242641f, 0.06136530f, -0.07756566f, -0.05860848f, -0.00679756f, 
    -0.00330834f, -0.00621541f, 0.00362346f, 0.00372476f, 0.01511076f, -0.09432252f, 0.05539836f, -0.06018143f, 
    0.05318964f, -0.09517123f, 0.05190527f, 0.04616245f, -0.03410301f, 0.04179146f, -0.02224874f, 0.03178551f, 
    0.02585320f, -0.09867877f, -0.01954825f, 0.05776506f, 0.04408933f, 0.04313794f, -0.05338637f, 0.08765797f, 
    0.03011486f, -0.37026978f, -0.21128975f, -0.03202089f, -0.19094846f, 0.13620520f, 0.03297890f, 0.26121312f, 
    0.06113755f, 0.06818834f, 0.16393070f, -0.05586413f, -0.33686212f, -0.29703957f, -0.06984653f, -0.12235725f, 
    0.23606300f, -0.02420430f, -0.08833732f, 0.02297409f, 0.14896517f, -0.02154976f, -0.01979899f, 0.46120313f, 
    0.10578090f, 0.09164990f, -0.33892277f, 0.12510391f, 0.02357965f, -0.08227833f, 0.13058937f, 0.04247740f, 
    -0.07428570f, -0.14002578f, 0.16131225f, -0.07934896f, -0.09204510f, 0.00675119f, -0.08628079f, 0.15604019f, 
    0.24014637f, 0.11912461f, -0.09862600f, -0.17110321f, 0.12927367f, 0.01154050f, -0.04037187f, 0.00929381f, 
    -0.09981700f, 0.06498706f, -0.14118275f, -0.13981859f, -0.17734456f, -0.06345323f, 0.00394453f, 0.04162091f, 
    -0.06665373f, 0.26181176f, 0.13379148f, -0.13516876f, -0.12602407f, -0.20810384f, -0.07592478f, -0.26454610f, 
    0.22856803f, 0.02329546f, -0.03617123f, -0.03278532f, -0.17598696f, 0.00974235f, -0.03433761f, -0.00373726f, 
    0.24387176f, 0.12076902f, 0.01757376f, -0.03664980f, 0.08651531f, -0.00611570f, -0.02905724f, 0.04204464f, 
    0.19186167f, -0.04868377f, -0.03037574f, 0.22566141f, 0.19079998f, -0.29027149f, 0.04599641f, -0.20644049f, 
    -0.25910181f, 0.01515048f, -0.04085185f, -0.01377484f, 0.20121779f, -0.44690740f, 0.06280281f, -0.01339709f, 
    -0.06898744f, 0.00720888f, -0.04563229f, -0.08319825f, -0.05212332f, -0.01978062f, -0.05062975f, -0.00745762f, 
    0.03007257f, -0.12223946f, 0.05505812f, -0.00017180f, 0.04020061f, -0.07735227f, -0.22276397f, 1.02260888f, 
    -0.02749583f, -0.01203219f, 0.07252684f, -0.02585939f, 0.08257358f, 0.20029992f, 0.43062612f, -0.12228785f, 
    -0.12038055f, 0.08686512f, -0.05644978f, 0.15193814f, -0.05194848f, -0.01169610f, 0.24459371f, -0.17178382f, 
    -0.14959499f, 0.36912337f, -0.21658359f, -0.03242642f, -0.43417510f, 0.01355660f, 0.08090496f, -0.48273301f, 
    0.00459629f, 0.09269008f, -0.04372884f, 0.06391487f, 0.22767703f, 0.02794485f, 0.07360379f, 0.08300662f, 
    -0.13060182f, 0.10137415f, 0.01061452f, -0.17388134f, -0.19499552f, 0.15183316f, 0.07113180f, -0.38367230f, 
    -0.09937681f, -0.11693271f, -0.21266861f, -0.11839078f, 0.09148262f, -0.11071817f, -0.12885378f, -0.06562146f, 
    0.03100951f, 0.06338011f, -0.12172156f, 0.10934099f, 0.02129118f, -0.07684436f, 0.05005261f, -0.05416884f, 
    -0.10608581f, -0.05708064f, 0.21953011f, 0.14613873f, -0.04527492f, 0.00848117f, 0.16845220f, 0.07756153f, 
    -0.17950593f, 0.13441481f, 0.03316718f, 0.38392889f, 0.24314828f, -0.03951597f, 0.22059131f, 0.15018575f, 
    0.15370327f, -0.09107440f, -0.22896588f, 0.05037189f, 0.15139925f, 0.33203474f, 0.15142018f, 0.18960249f, 
    -0.19906859f, 0.11863631f, 0.14307776f, -0.01438890f, 0.06793387f, 0.04352667f, 0.19309328f, 0.31636137f, 
    -0.28118202f, -0.23436579f, 0.14992908f, 0.13120632f, -0.10286698f, -0.08450014f, -0.37101340f, -0.13252401f, 
    -0.09460942f, -0.10302664f, 0.12406679f, -0.01259390f, -0.22694646f, -0.20930500f, -0.05792077f, 0.53423619f, 
    -0.08875549f, -0.22942325f, 0.11471219f, -0.03264454f, -0.07160536f, 0.74632066f, -0.01967862f, -0.03265173f, 
    0.07052813f, -0.09726899f, 0.01528587f, -0.21162042f, 0.05071829f, 0.20733859f, 0.17091659f, 0.01692650f, 
    0.04587105f, -0.44001088f, -0.07327247f, 0.15631977f, -0.20283028f, 0.12342926f, 0.16917004f, 0.07398841f, 
    -0.04532630f, -0.13427971f, -0.10791850f, 0.09271007f, -0.16308965f, -0.43549126f, 0.06327172f, 0.19129977f, 
    0.12813742f, 0.06757289f, -0.02372760f, -0.07106777f, 0.15355748f, 0.07217135f, -0.01303389f, -0.02560213f, 
    -0.00474228f, -0.03603605f, -0.08514742f, -0.07584455f, -0.07120092f, -0.04795647f, -0.10009217f, 0.01615871f, 
    -0.01774081f, -0.11590236f, -0.12782107f, -0.09492874f, 0.03464013f, -0.02280426f, -0.08110545f, 0.03268505f, 
    -0.03761116f, -0.00338091f, 0.00713128f, -0.10224309f, -0.07918211f, 0.00618332f, -0.11643545f, 0.05924132f, 
    -0.08622630f, -0.12201321f, 0.02303545f, 0.03459089f, -0.02748971f, 0.02188971f, -0.03295356f, 0.08633474f, 
    -0.11768246f, -0.02820873f, -0.12290264f, -0.04237527f, -0.08718476f, -0.07172897f, -0.05807553f, -0.02226666f, 
    -0.05809677f, 0.02059279f, -0.10300592f, 0.08068449f, -0.02210196f, -0.12767176f, 0.02570159f, -0.00302723f, 
    0.03833805f, -0.04803023f, -0.06500818f, -0.05047878f, 0.02249219f, 0.06336195f, 0.01773537f, -0.01337955f, 
    0.04737424f, 0.01316703f, -0.03119715f, -0.09622815f, 0.00888369f, 0.02653895f, -0.03781881f, 0.05495217f, 
    0.02106894f, 0.00312780f, -0.00411175f, 0.00487425f, 0.07834437f, -0.04696108f, -0.12925072f, 0.00660896f, 
    -0.07908092f, 0.02392571f, -0.10850482f, -0.01668142f, 0.00864831f, 0.05132087f, -0.03568365f, 0.01325366f, 
    -0.03769258f, -0.00467247f, -0.10202398f, -0.12220194f, -0.12785594f, -0.10141247f, 0.03632132f, -0.08353858f, 
    -0.06260622f, 0.06592363f, -0.05631841f, 0.04045595f, -0.03899397f, -0.00239303f, -0.01867895f, -0.02691903f, 
    0.01400618f, -0.02230215f, 0.07388841f, -0.06033559f, -0.07524142f, -0.00558896f, 0.04720550f, -0.04241587f, 
    0.04895195f, -0.04193787f, 0.01548367f, -0.09998369f, 0.04585352f, -0.10034342f, -0.01517030f, -0.04884904f, 
    0.04763212f, -0.09649038f, 0.02587443f, -0.01415675f, -0.02509975f, 0.01200914f, 0.02417686f, 0.00101562f, 
    0.03765427f, 0.06204632f, -0.09040193f, 0.03930533f, -0.13023469f, 0.07808786f, -0.03906294f, 0.02139006f, 
    0.05233055f, 0.07593846f, 0.01515063f, 0.05722199f, 0.00784696f, -0.05370935f, -0.03035155f, 0.03097119f, 
    -0.05430374f, -0.02630340f, 0.03732817f, -0.08684815f, 0.04183477f, -0.06284423f, 0.04057747f, -0.09574296f, 
    -0.08128349f, -0.06578945f, -0.00981446f, -0.02198526f, 0.06171091f, -0.00824499f, -0.02299501f, 0.06826382f, 
    -0.10012292f, -0.06022433f, -0.00233941f, -0.03624513f, -0.04222620f, -0.08126936f, 0.06301253f, 0.07377094f, 
    -0.01465700f, 0.06460068f, 0.04884216f, 0.01456764f, -0.07254518f, -0.03243935f, -0.09522452f, 0.00918744f, 
    -0.04606792f, 0.00583528f, -0.08493535f, 0.07822604f, 0.04270606f, 0.03998415f, -0.00307009f, 0.06116497f, 
    -0.03707941f, 0.03303686f, -0.03489902f, -0.05616324f, -0.08520613f, -0.04633041f, -0.02987635f, -0.08078580f, 
    -0.02138237f, -0.10479999f, 0.05840625f, -0.06018543f, -0.05032229f, 0.00804564f, 0.06642414f, -0.04146168f, 
    -0.08289880f, 0.06756044f, -0.03936666f, 0.00559155f, 0.02927791f, -0.01868547f, -0.00548247f, -0.02662930f, 
    -0.02434813f, 0.05684757f, -0.03566715f, -0.01681048f, 0.04958360f, 0.06523478f, 0.00600640f, -0.05963128f, 
    -0.09943496f, -0.01800284f, -0.06907208f, -0.02297176f, -0.02670314f, 0.04654130f, -0.00176899f, 0.04487735f, 
    0.02257038f, 0.00472439f, -0.07950522f, 0.00744824f, -0.00304005f, -0.08166433f, -0.00884548f, -0.05469294f, 
    -0.05800927f, 0.03283484f, -0.01164630f, -0.08854149f, -0.10650159f, -0.03712925f, 0.02268429f, -0.05945779f, 
    0.05336430f, 0.04426295f, -0.05536763f, -0.09155099f, 0.05453379f, 0.01189882f, 0.00578904f, -0.07098795f, 
    -0.03229387f, -0.08900416f, -0.08696254f, 0.03694578f, -0.07051627f, 0.02018200f, 0.06567374f, 0.01357593f, 
    0.03730065f, 0.00003891f, -0.05585171f, 0.01036802f, -0.04107799f, 0.02800892f, -0.00442170f, 0.00155630f, 
    0.03387415f, 0.00899648f, -0.06653840f, 0.01469752f, -0.06881034f, -0.08782838f, -0.09473832f, -0.02785721f, 
    -0.08551998f, -0.03552945f, 0.02230348f, 0.05033784f, -0.00875793f, 0.01967379f, -0.08023225f, 0.00841705f, 
    -0.07657273f, 0.06202112f, 0.02698026f, -0.00637751f, 0.00449924f, -0.12186189f, -0.05678710f, -0.01621135f, 
    -0.03247062f, -0.04060709f, -0.08181271f, -0.04296990f, -0.02585132f, 0.01709617f, -0.06867649f, 0.05865365f, 
    -0.03594491f, -0.03636845f, 0.04280090f, -0.08020741f, 0.03215406f, 0.06882975f, -0.04297188f, 0.00081056f, 
    -0.07036126f, 0.01745736f, -0.00260607f, 0.01249667f, -0.02621476f, -0.02659536f, -0.07379564f, -0.02574284f, 
    -0.02925716f, 0.00578474f, 0.01592563f, -0.02245636f, -0.09961120f, -0.01962663f, 0.06294462f, -0.04497175f, 
    0.02547064f, -0.01180029f, -0.04510880f, -0.02372869f, -0.11284916f, -0.11197358f, 0.02591909f, -0.07761405f, 
    0.01312041f, -0.01139765f, 0.06995168f, 0.02316087f, -0.05385309f, -0.00265262f, -0.11271365f, -0.06077099f, 
    0.01206997f, 0.04028488f, -0.08503719f, 0.03935369f, 0.04657354f, 0.06175650f, -0.09172121f, 0.04166900f, 
    0.00893035f, -0.03067788f, -0.02205249f, -0.01645104f, -0.04206657f, -0.01122792f, -0.05165670f, -0.04688282f, 
    -0.05944904f, 0.02056344f, 0.02476220f, -0.10052347f, 0.05879647f, -0.02546540f, 0.04349724f, -0.02467124f, 
    0.00410861f, -0.06199117f, -0.03228699f, -0.04424265f, 0.04553065f, -0.11701053f, 0.06565334f, 0.02840923f, 
    -0.07422165f, 0.01244769f, 0.04526926f, -0.06040926f, -0.02491911f, -0.09850967f, -0.03772163f, 0.02858063f, 
    -0.01068974f, -0.05842082f, -0.00257471f, 0.07808738f, -0.02738796f, -0.01881778f, 0.03047280f, -0.11542553f, 
    0.01808778f, 0.01068086f, -0.00755241f, 0.05829350f, -0.04737314f, -0.00130450f, -0.06085152f, -0.11716130f, 
    0.05913213f, -0.34946939f, 0.17981753f, 0.08189556f, 0.63061690f, -0.16894732f, -0.38711661f, 0.17624307f, 
    -0.04715945f, -0.12502618f, -0.24661104f, 0.00799666f, -0.10441630f, -0.03341506f, 0.03908864f, 0.03532982f, 
    -0.03557169f, -0.06649887f, -0.08701125f, 0.23990011f, -0.22351083f, 0.11387341f, -0.29378822f, 0.26892215f, 
    0.35172325f, 0.07897748f, -0.17639279f, 0.17127556f, -0.16093107f, 0.04673420f, -0.14925815f, 0.01919323f, 
    0.17873991f, -0.12321638f, 0.08649702f, 0.00547347f, 0.06501904f, 0.06745266f, -0.08819207f, 0.31554055f, 
    0.03638028f, 0.07080230f, 0.14750874f, 0.11640366f, 0.11024466f, 0.21097377f, 0.10018026f, 0.12636581f, 
    0.13202463f, -0.05308129f, -0.28429219f, -0.04939791f, 0.04377415f, 0.03157719f, -0.02228607f, 0.16301098f, 
    0.02388174f, -0.18677312f, -0.06077449f, -0.07830898f, -0.19834302f, -0.22292559f, -0.01639985f, 0.39325035f, 
    -0.30165485f, 0.05892890f, -0.10402955f, 0.13674462f, 0.25953546f, -0.02547025f, 0.08015962f, -0.20633693f, 
    0.10082898f, 0.11553274f, 0.06647781f, -0.07872413f, 0.48993397f, -0.02349561f, -0.24184622f, -0.03579142f, 
    -0.10143203f, 0.40502852f, 0.14588916f, 0.07982796f, 0.14247969f, 0.05798870f, 0.27631065f, -0.29094511f, 
    -0.13320443f, 0.26307663f, 0.04445659f, 0.31513008f, 0.27530465f, 0.24130018f, 0.02182726f, 0.09964735f, 
    0.05205850f, 0.05309561f, -0.07105400f, -0.13748375f, -0.05407518f, -0.04216626f, 0.10677527f, 0.05965487f, 
    0.24146023f, 0.27364579f, -0.04819309f, 0.05869092f, 0.06176725f, -0.40278381f, 0.05693959f, 0.40918830f, 
    0.12927455f, 0.20482513f, 0.04921868f, 0.01258549f, -0.06708428f, 0.20268285f, 0.65658915f, 0.02554434f, 
    0.02890939f, 0.03338100f, 0.00494479f, 0.26435360f, 0.07224458f, 0.05897438f, -0.13398512f, -0.17787005f, 
    -0.00154989f, -0.08899125f, -0.03165657f, 0.00238338f, 0.00996944f, -0.05031798f, -0.03569571f, -0.00305628f, 
    -0.00150740f, -0.03749980f, 0.01423825f, -0.01988844f, -0.01962684f, 0.07908055f, -0.07844897f, -0.08277710f, 
    0.02387257f, 0.00742415f, 0.01806771f, 0.02900718f, 0.03198621f, 0.03081482f, -0.06490597f, 0.03628877f, 
    0.04722615f, -0.08419192f, -0.06363795f, -0.04909635f, -0.04559060f, -0.01130283f, -0.05130506f, -0.07683592f, 
    0.01989239f, -0.00256805f, -0.02811224f, -0.06310365f, -0.05139222f, -0.03277960f, -0.05603316f, 0.07478365f, 
    -0.09481596f, 0.01427620f, -0.00938627f, -0.07074516f, -0.11423322f, 0.02605739f, -0.08109276f, 0.01210385f, 
    0.02415626f, -0.07068389f, -0.08288891f, -0.01676485f, -0.00075673f, -0.03523588f, 0.00262825f, 0.02068260f, 
    -0.03700422f, -0.02820247f, 0.00844077f, 0.02314115f, 0.07422206f, -0.07247016f, -0.06732097f, 0.06770907f, 
    0.01746573f, 0.05216906f, -0.04664158f, -0.05759275f, -0.01189026f, -0.04609086f, 0.00065670f, -0.07428589f, 
    0.04153561f, -0.09754327f, -0.02874956f, -0.05728672f, 0.06765697f, 0.07869449f, 0.05604446f, 0.04258675f, 
    -0.04958684f, -0.06438348f, -0.03532209f, 0.04026903f, -0.00626655f, -0.07425890f, 0.05697833f, -0.08044546f, 
    0.02734540f, -0.08337427f, 0.05102616f, 0.03057416f, -0.03789864f, 0.02196564f, -0.09908023f, -0.08170488f, 
    -0.07773698f, -0.05498936f, 0.04115183f, -0.05872170f, -0.07210593f, 0.01145929f, -0.06529339f, -0.06407560f, 
    -0.09032203f, 0.01153648f, 0.04373328f, 0.06745975f, -0.09219065f, -0.03362245f, 0.02314775f, -0.08454055f, 
    0.05460291f, -0.04840442f, -0.08169644f, 0.01703935f, -0.06459858f, -0.08222933f, -0.04138450f, 0.06120609f, 
    -0.03974627f, -0.03911820f, -0.04214752f, -0.06316426f, 0.06928715f, -0.00523459f, -0.09749587f, -0.03464607f, 
    0.16460456f, -0.18491845f, -0.15422180f, -0.08266315f, 0.10895565f, 0.06391481f, -0.06277462f, 0.05786050f, 
    -0.18492042f, 0.22079599f, 0.00566618f, 0.08368324f, 0.02656156f, 0.17037369f, -0.00488226f, 0.14151004f, 
    -0.02420877f, -0.32638055f, -0.07632495f, -0.15128875f, 0.26716530f, -0.06522316f, 0.02834416f, 0.10050846f, 
    0.11633485f, 0.08572142f, 0.22282355f, -0.11010794f, -0.27438688f, 0.00983802f, 0.08981735f, 0.07614001f, 
    -0.11751174f, -0.24376191f, -0.05529074f, 0.13707812f, 0.56453753f, -0.09592957f, 0.22976178f, 0.12150935f, 
    0.27748775f, 0.06286045f, -0.17832227f, -0.13119806f, 0.16162416f, -0.05073855f, -0.05823449f, 0.00108223f, 
    0.20208602f, -0.23214059f, -0.29584163f, 0.17395583f, -0.04494071f, 0.01874143f, 0.23104647f, -0.00642103f, 
    0.14288345f, 0.14621043f, 0.06936163f, -0.05095831f, 0.14925541f, -0.38435897f, -0.11753549f, 0.48766589f, 
    0.13884747f, 0.12628461f, 0.23147145f, -0.04337744f, 0.16442172f, -0.11241616f, -0.01008449f, 0.36826518f, 
    0.08099248f, 0.15597779f, 0.19106336f, 0.19359994f, -0.14775155f, 0.00234648f, 0.27090207f, 0.09867848f, 
    0.10814727f, 0.07395506f, 0.01448890f, -0.36089167f, -0.08421133f, 0.20327847f, -0.39529133f, -0.32705879f, 
    0.12090056f, -0.20175321f, 0.15391369f, 0.03324053f, -0.25346449f, -0.35477966f, -0.21321298f, -0.12082054f, 
    0.03825074f, 0.10827285f, -0.04650705f, 0.42973429f, 0.06713396f, -0.18566895f, 0.04242503f, -0.02465465f, 
    -0.29252696f, 0.24476820f, -0.22033748f, -0.08243987f, -0.05491020f, -0.13776016f, 0.34153315f, 0.14021365f, 
    -0.06529643f, -0.12477040f, 0.03133388f, 0.04817818f, -0.08818935f, -0.16669728f, -0.38265851f, -0.27104124f, 
    0.08904116f, 0.11887160f, 0.09191094f, -0.06029551f, -0.11561903f, 0.09696712f, -0.19632003f, 0.17832990f, 
    0.07914802f, -0.38415202f, -0.04335598f, 0.08067752f, -0.81415749f, 0.02180704f, 0.03399561f, 0.11128379f, 
    -0.20155770f, 0.18848148f, 0.03273906f, -0.24533765f, 0.05603752f, -0.02978058f, -0.03041551f, 0.21856360f, 
    0.10366116f, -0.05347937f, -0.02517254f, 0.00981081f, 0.19727840f, -0.16942684f, 0.10757927f, 0.16014479f, 
    -0.09834184f, 0.06724111f, -0.20229180f, -0.03347421f, 0.03827110f, -0.26019996f, -0.08592068f, -0.08386717f, 
    0.00518668f, -0.13757479f, 0.03267969f, 0.08703359f, 0.35955787f, 0.05565793f, 0.05660222f, 0.13775735f, 
    0.12399364f, 0.06362751f, -0.04425735f, -0.40308139f, 0.20660213f, 0.09888586f, -0.12756152f, 0.09780303f, 
    0.06728864f, -0.06218251f, -0.25984564f, 0.15231439f, 0.00219821f, 0.03649675f, 0.13623342f, -0.00486914f, 
    0.18628868f, 0.07156128f, -0.06158101f, -0.05043381f, 0.15280713f, -0.23524904f, 0.11333816f, 0.07483437f, 
    0.14021103f, 0.15469924f, 0.13127445f, 0.00620606f, -0.24812311f, -0.01414961f, 0.07346539f, 0.07255968f, 
    -0.11093066f, 0.16233712f, 0.22743936f, 0.18046169f, -0.12660795f, -0.06347970f, -0.11702339f, 0.04404255f, 
    0.31036648f, -0.03456583f, 0.10220192f, -0.11313539f, 0.15863024f, 0.02438078f, -0.44282353f, 0.08750084f, 
    0.08321474f, -0.15402213f, 0.15005890f, -0.09051238f, -0.34445712f, -0.34835500f, -0.01300124f, 0.00473282f, 
    -0.02055647f, 0.06022530f, 0.03467125f, 0.23888287f, 0.13790432f, 0.01290243f, 0.05199924f, -0.06682827f, 
    0.12938851f, -0.18086055f, -0.29282400f, -0.01709358f, -0.06230386f, -0.00478021f, 0.15527074f, -0.08981883f, 
    0.00005970f, 0.20087107f, 0.10753001f, 0.01669730f, 0.10315327f, -0.22562496f, -0.36251822f, -0.09543581f, 
    0.10347060f, 0.19870804f, 0.08443867f, 0.02261075f, -0.00740741f, -0.03807148f, -0.08909537f, 0.00506666f, 
    -0.20567878f, 0.43358898f, -0.28003517f, 0.02949907f, 0.20441699f, -0.00061001f, 0.00217043f, -0.01059496f, 
    0.34725934f, -0.36409518f, 0.11835968f, 0.21165225f, 0.22636600f, 0.17959617f, 0.04434039f, -0.12528461f, 
    -0.06367455f, 0.36580187f, 0.06264613f, -0.02011469f, -0.16229694f, 0.26704663f, 0.21531117f, -0.21990067f, 
    -0.38819832f, 0.06863103f, 0.01326014f, -0.08705885f, 0.14989918f, -0.01432055f, -0.02370556f, 0.03456658f, 
    -0.12234450f, 0.27633497f, 0.07916231f, -0.27800557f, -0.14756155f, -0.05449953f, 0.25217888f, -0.34389940f, 
    0.04194145f, -0.18294306f, 0.05844293f, -0.03618285f, -0.18601039f, -0.10596544f, -0.01580193f, -0.04301855f, 
    0.05590044f, 0.04006295f, 0.38649765f, -0.33653694f, 0.15673731f, 0.06184306f, -0.12523741f, -0.04766129f, 
    0.04564273f, -0.25038692f, 0.14836514f, 0.25399143f, 0.04508767f, 0.30918419f, -0.04903509f, -0.27323443f, 
    -0.03229504f, -0.24179071f, -0.06030408f, 0.01017360f, -0.05974945f, 0.12543574f, 0.03725084f, 0.13788696f, 
    0.02165488f, -0.17348477f, -0.42515498f, 0.07262711f, -0.21886666f, 0.10893986f, 0.11285415f, 0.14490902f, 
    -0.24694493f, -0.08714467f, -0.08135334f, 0.05379619f, -0.16098990f, -0.08221322f, 0.19100770f, 0.45885515f, 
    -0.11278247f, 0.20547047f, 0.00296633f, -0.07338379f, 0.01985785f, 0.28650317f, 0.15787348f, 0.06928169f, 
    0.05571762f, 0.05783829f, -0.01447982f, -0.13941485f, -0.36776796f, 0.09668829f, 0.04845650f, -0.02015534f, 
    -0.42782715f, -0.09522975f, 0.11074911f, 0.00082352f, 0.20574267f, 0.23200577f, -0.10712709f, 0.12565567f, 
    0.00090027f, 0.07453345f, -0.05709429f, -0.00581055f, -0.00839704f, 0.12299982f, 0.31035486f, 0.36841124f, 
    -0.24819042f, -0.04432704f, -0.23231204f, -0.00270836f, 0.25675207f, 0.08116644f, 0.28047171f, 0.20517337f, 
    0.00007326f, 0.04409635f, -0.09209261f, -0.03178830f, -0.01154953f, -0.02445818f, -0.00834151f, 0.03628837f, 
    0.05736165f, -0.05671954f, 0.00696653f, -0.07467683f, 0.07127018f, 0.04758476f, -0.03067646f, -0.06213054f, 
    -0.08058751f, -0.04539074f, -0.01996417f, 0.03677647f, -0.00171163f, 0.04587668f, -0.05998985f, -0.08197185f, 
    0.02599455f, -0.00162508f, 0.01487636f, -0.03744831f, -0.10164072f, -0.06468093f, -0.03948867f, 0.04079073f, 
    0.07139067f, 0.03957914f, 0.06844603f, -0.05832803f, -0.07392676f, 0.01237842f, -0.06107303f, -0.02938779f, 
    -0.05505435f, 0.08205508f, -0.06853197f, -0.01327072f, -0.08432320f, -0.03629915f, -0.07015368f, 0.04220370f, 
    -0.01655566f, -0.01978955f, 0.02154800f, 0.06427384f, -0.01349347f, -0.02688151f, -0.01598622f, -0.05099132f, 
    -0.07855646f, -0.04444409f, 0.00045489f, 0.04008688f, 0.08583834f, -0.02054740f, 0.03301870f, -0.05813679f, 
    -0.05602694f, -0.09172245f, 0.08309700f, -0.04325566f, -0.09044214f, 0.06176354f, -0.03515504f, -0.04605956f, 
    -0.00806192f, -0.04394614f, -0.07830077f, 0.00825491f, -0.04953967f, -0.02615757f, 0.00948069f, -0.00981893f, 
    -0.02775672f, 0.06321504f, -0.04594675f, 0.08101933f, 0.01911975f, 0.04921547f, -0.01165663f, -0.11507300f, 
    -0.05946270f, 0.03028196f, -0.06758562f, 0.04917362f, -0.10894424f, -0.08074664f, 0.01695706f, 0.06773309f, 
    -0.02261337f, 0.03031487f, 0.01211987f, 0.07214136f, -0.04994833f, -0.00334623f, -0.04279036f, 0.01319959f, 
    -0.05057104f, -0.00153454f, -0.03071791f, 0.04980328f, -0.06293844f, 0.06455764f, 0.01585566f, 0.02714373f, 
    -0.07256548f, 0.06856522f, -0.03302173f, -0.05380764f, -0.03865625f, 0.00072240f, 0.00772403f, -0.06403044f, 
    0.02656202f, -0.08391349f, 0.02864805f, 0.04154104f, 0.01974882f, -0.02599057f, 0.06591351f, -0.04814073f, 
    0.30894059f, -0.02289828f, 0.18676005f, 0.05562156f, 0.01307645f, 0.24148767f, -0.02021731f, -0.12855649f, 
    0.19354086f, -0.20225385f, 0.06428359f, 0.23668064f, 0.19924931f, -0.17812534f, 0.24922436f, 0.07194766f, 
    0.24159028f, 0.32233289f, 0.04156441f, -0.00878180f, -0.07203469f, -0.04721340f, 0.14187700f, -0.27050033f, 
    -0.33102390f, 0.04540507f, -0.21740006f, -0.05077225f, -0.02630177f, -0.04488460f, 0.01976581f, -0.10232457f, 
    -0.08255104f, 0.53952897f, 0.01306278f, -0.20983750f, -0.31398183f, -0.02935880f, 0.17738698f, -0.02772100f, 
    -0.16307072f, 0.04396661f, -0.03987392f, -0.05367425f, -0.21938138f, 0.03302786f, -0.02468241f, -0.14314047f, 
    -0.15195310f, -0.18336755f, 0.24417056f, 0.00963200f, -0.05626234f, -0.08750448f, 0.04948742f, 0.00070012f, 
    -0.01191062f, -0.10542744f, 0.21152842f, 0.06639206f, 0.24097513f, -0.04431265f, -0.27650476f, 0.25165558f, 
    0.40853891f, 0.16130877f, 0.06457765f, 0.18502243f, 0.10349205f, -0.04515744f, 0.01110574f, -0.05433883f, 
    0.26053149f, 0.15571992f, -0.35247573f, -0.29527372f, -0.16894884f, -0.00208156f, 0.23607579f, -0.07148531f, 
    0.07124382f, 0.00596840f, 0.10423536f, 0.04269414f, -0.09225462f, 0.07760582f, -0.17217843f, 0.10931459f, 
    0.02221885f, 0.33501464f, -0.06907966f, 0.24296528f, 0.39801225f, 0.29098108f, -0.14257400f, 0.15013228f, 
    -0.00704731f, 0.00683136f, 0.02823287f, 0.15882127f, -0.13493210f, -0.04232815f, 0.07318407f, -0.00774969f, 
    0.29103124f, 0.07978676f, 0.18665175f, 0.17954464f, 0.33555669f, 0.51535922f, -0.85119784f, 0.36727926f, 
    0.31735411f, 0.34542552f, 0.07890779f, -0.10714568f, 0.06477346f, -0.06060654f, 0.48948467f, 0.04865880f, 
    -0.21052897f, -0.00189944f, 0.04408885f, 0.13652211f, 0.11056585f, -0.00605167f, 0.13871467f, -0.14186969f, 
    -0.06662853f, 0.18594310f, 0.19115062f, 0.07138266f, 0.13549896f, 0.24225596f, 0.01427508f, 0.13915364f, 
    -0.01361640f, -0.10305925f, 0.18235074f, 0.19295664f, -0.08381223f, 0.11326864f, 0.17442307f, 0.16571690f, 
    -0.14052357f, 0.10295101f, -0.06748171f, 0.16980898f, 0.03210448f, 0.06113404f, -0.03485256f, -0.43316585f, 
    -0.54890746f, -0.01609363f, 0.12983127f, 0.18315890f, 0.16105831f, -0.14475410f, -0.14894807f, -0.01287471f, 
    0.12513977f, 0.12123976f, 0.05606108f, -0.09574082f, -0.01674424f, -0.06153614f, 0.25779825f, -0.11768390f, 
    -0.06152449f, -0.12623039f, -0.00896823f, 0.13689773f, -0.11050104f, 0.15028189f, -0.06777479f, -0.15061659f, 
    -0.05709542f, 0.11699451f, 0.32022199f, -0.07001053f, -0.09375963f, 0.06143430f, -0.19853830f, -0.02720188f, 
    0.09678462f, -0.09903366f, 0.04751230f, 0.10905728f, 0.06410876f, -0.17429537f, -0.05647367f, -0.51792848f, 
    0.17027473f, 0.09676064f, -0.11687047f, -0.13648656f, 0.04783786f, 0.12149445f, 0.07853756f, -0.23518857f, 
    -0.10608231f, -0.04367778f, -0.01959967f, -0.10718209f, -0.21533471f, -0.05331683f, -0.08017145f, 0.15315673f, 
    0.04449325f, -0.11014156f, 0.10410898f, -0.02388793f, 0.10223293f, 0.18351777f, 0.01402289f, 0.22224095f, 
    -0.11019313f, 0.02180145f, -0.06244307f, 0.13979928f, 0.15071651f, -0.39650506f, 0.12871939f, 0.17460313f, 
    -0.03672143f, 0.03472285f, -0.06256071f, -0.21506336f, -0.07571699f, 0.07651755f, -0.02315931f, -0.02229078f, 
    -0.18273947f, 0.03700450f, 0.36766946f, 0.14810330f, 0.29147470f, 0.24417312f, -0.37974915f, -0.32745692f, 
    0.14176895f, 0.06143058f, -0.09520175f, 0.09753993f, 0.11428712f, -0.33931813f, -0.55911350f, 0.28569359f, 
    0.07327893f, 0.06130449f, -0.21903056f, 0.04281627f, -0.13148849f, -0.03586141f, 0.16611770f, -0.04728937f, 
    0.17397784f, -0.46821374f, 0.24833086f, 0.00451172f, -0.07178908f, 0.00531226f, 0.05509497f, 0.12892759f, 
    -0.33649349f, -0.03761663f, -0.02491828f, -0.16138400f, -0.20149095f, -0.01543781f, 0.22834517f, 0.13551204f, 
    -0.14102204f, 0.11680732f, 0.07996436f, 0.14189589f, 0.06176398f, -0.16472098f, -0.10983484f, -0.42886251f, 
    -0.06365915f, -0.08900505f, -0.68296665f, 0.02967949f, 0.14111212f, -0.38111666f, -0.18635587f, 0.03309468f, 
    0.12171976f, 0.23497041f, 0.02676630f, -0.06873875f, 0.08784632f, 0.08247691f, 0.26507843f, -0.16007157f, 
    -0.21513955f, -0.04371889f, -0.09579375f, 0.43675151f, -0.01951567f, 0.18327303f, -0.26417181f, -0.23640828f, 
    -0.09075665f, 0.07168516f, 0.29514828f, -0.02678150f, -0.32654187f, 0.04580882f, -0.24533977f, -0.04146130f, 
    0.17652406f, 0.00058057f, -0.10205729f, 0.01882367f, -0.10827816f, -0.58877134f, 0.01921183f, -0.30799043f, 
    0.10625126f, 0.11770745f, -0.10771687f, -0.13890997f, -0.04700045f, -0.03579697f, 0.00568024f, -0.36371496f, 
    0.08852899f, 0.03950272f, 0.06312687f, -0.22612429f, -0.05133342f, -0.01981234f, -0.41555625f, 0.24963021f, 
    0.08041446f, -0.04418944f, 0.18426530f, 0.03404492f, 0.13976467f, 0.25435346f, 0.27273676f, 0.16048990f, 
    0.08253771f, 0.10948715f, -0.22495346f, 0.25994200f, -0.21898361f, -0.45327362f, 0.07105211f, 0.09657269f, 
    -0.05748882f, 0.04593510f, -0.01873071f, -0.10966653f, 0.02780639f, 0.09660032f, -0.07027680f, -0.04689411f, 
    0.09854796f, 0.10209476f, 0.12282710f, 0.06378490f, 0.14962058f, 0.12868351f, -0.56910092f, -0.50041860f, 
    0.17352775f, 0.29119763f, 0.11530440f, -0.02596140f, 0.12375158f, 0.13844234f, -0.11296237f, 0.01956530f, 
    0.04250315f, 0.10629793f, -0.12518910f, 0.00553360f, -0.12448776f, 0.05664581f, 0.03692180f, -0.53838873f, 
    0.10649379f, 0.49144712f, 0.33172995f, 0.05360473f, -0.40710175f, 0.15956444f, 0.09101725f, -0.03629675f, 
    -0.31379527f, 0.11813268f, -0.11369816f, -0.02971169f, 0.02278542f, 0.19822831f, 0.17461146f, -0.02575028f, 
    0.05692638f, -0.04321572f, 0.02460109f, 0.06621253f, 0.03256390f, 0.10186861f, 0.13553943f, -0.17749016f, 
    -0.11957191f, 0.03765038f, -0.13984591f, -0.07316580f, 0.21364459f, -0.23539644f, -0.03173763f, 0.03822080f, 
    0.04450556f, 0.05131276f, -0.09193884f, 0.09925140f, -0.05884103f, 0.03511220f, 0.07741857f, -0.00084346f, 
    -0.03626430f, -0.13205075f, 0.18252574f, 0.14146866f, -0.03086486f, 0.10267727f, -0.00842724f, -0.03004652f, 
    0.00134127f, 0.06309259f, 0.42099181f, 0.12304928f, 0.12054122f, 0.02379075f, -0.19561008f, 0.13634916f, 
    0.04201318f, -0.03220485f, 0.08341316f, 0.21192925f, 0.38878775f, 0.02642237f, 0.16952331f, -0.44433808f, 
    0.17273846f, 0.06151180f, -0.05415222f, -0.12141006f, -0.01487996f, 0.28271306f, 0.07903852f, -0.15567906f, 
    -0.15087827f, -0.06454974f, 0.05973809f, -0.10956649f, -0.29265413f, -0.04213192f, 0.02382427f, -0.02433001f, 
    -0.03070854f, -0.20450447f, 0.06233022f, 0.05940078f, 0.04681513f, 0.03050936f, 0.02700372f, 0.44228613f, 
    -0.11643785f, 0.00521680f, -0.00668279f, -0.08469123f, -0.11887541f, -0.35829636f, 0.01259102f, 0.16769519f, 
    -0.05640479f, -0.03786864f, -0.05554398f, -0.12008748f, 0.02178454f, 0.14842376f, 0.07426061f, 0.02786804f, 
    0.12590444f, -0.13638134f, 0.20871943f, 0.19102687f, 0.08305964f, 0.21843980f, -0.23458810f, -0.37293696f, 
    -0.02708256f, -0.06529735f, 0.09632587f, 0.04873910f, 0.06135224f, -0.09553991f, -0.63323987f, 0.32969666f, 
    0.19776642f, 0.09224005f, -0.09158823f, 0.02949736f, 0.13628680f, 0.01732146f, 0.10083804f, -0.00769444f, 
    -0.00899909f, -0.52289331f, 0.37577939f, -0.02613215f, -0.30638975f, 0.13200735f, 0.06794744f, 0.26064739f, 
    -0.33332321f, 0.00290641f, 0.01528671f, -0.49543527f, -0.55149031f, -0.08678155f, 0.22775753f, 0.08051471f, 
    0.05418306f, -0.08491802f, -0.06444363f, 0.23256560f, 0.01230060f, -0.15389676f, -0.16831771f, -0.02907870f, 
    0.15093368f, -0.03950356f, -0.30455604f, 0.09313025f, 0.28150016f, -0.26861307f, 0.03421360f, 0.06014832f, 
    0.17697863f, -0.10535438f, 0.05296417f, 0.18463811f, -0.00593333f, 0.01795995f, -0.05327442f, -0.00939625f, 
    -0.08596879f, -0.00848317f, 0.01952560f, 0.44347376f, -0.15162779f, 0.39087087f, 0.04874380f, 0.02542328f, 
    -0.02723032f, 0.11043674f, 0.09625746f, 0.11771112f, -0.06308557f, 0.05492457f, -0.32807657f, 0.22861677f, 
    0.22709700f, 0.07478764f, 0.07306948f, -0.20078783f, 0.28033090f, -0.34108716f, 0.05142944f, -0.38904476f, 
    -0.19029142f, 0.26878232f, -0.15570575f, -0.01971432f, 0.02583916f, 0.05047818f, 0.04295063f, -0.51911646f, 
    -0.11174212f, 0.14449039f, 0.31205544f, -0.08019003f, 0.09719404f, -0.01571299f, -0.31160268f, 0.22552650f, 
    0.13239101f, -0.12717710f, 0.24668472f, 0.17465460f, 0.32638600f, 0.08199420f, -0.08827306f, 0.41356170f, 
    0.20948610f, -0.05949612f, -0.08778488f, 0.13091142f, -0.15387703f, 0.10499278f, 0.08680283f, 0.08882691f, 
    0.07389234f, 0.00182183f, -0.02566274f, -0.11050103f, 0.10005619f, 0.05219178f, -0.10111732f, 0.01545492f, 
    0.23101214f, -0.03455779f, -0.15053333f, 0.20265777f, 0.13842300f, 0.01133147f, -0.13751696f, -0.01390641f, 
    0.14741741f, 0.21591383f, 0.14503355f, 0.01756449f, 0.17928211f, 0.02347568f, -0.27700737f, 0.03629634f, 
    0.32533672f, 0.12607072f, -0.16964471f, 0.28641880f, -0.16199635f, -0.04417045f, -0.08133905f, -0.23906875f, 
    0.02433989f, 0.55729401f, -0.37670681f, 0.08598501f, -0.31794062f, 0.13401864f, -0.10782515f, -0.06109073f, 
    0.17182253f, -0.07163170f, -0.31910118f, 0.27900913f, 0.21687815f, -0.10967688f, 0.08603878f, -0.19121175f, 
    -0.05852139f, 0.00933691f, 0.03575352f, -0.04066147f, 0.01898294f, 0.14723387f, -0.17033085f, -0.10107707f, 
    -0.08718388f, 0.05943848f, 0.26959723f, 0.02977506f, 0.02736777f, 0.01334983f, 0.01439666f, -0.07720403f, 
    -0.03793947f, 0.02425073f, -0.10153001f, 0.03527100f, -0.01234403f, -0.07102325f, 0.16425468f, 0.10940330f, 
    -0.02924109f, -0.00487054f, 0.28557533f, -0.28582847f, 0.19940482f, 0.09818206f, 0.11486337f, 0.04556176f, 
    -0.05858155f, 0.09207295f, -0.01373703f, 0.01705095f, 0.21455860f, -0.05038091f, 0.13342427f, 0.20914885f, 
    0.08554652f, 0.01797446f, 0.00439290f, 0.11308159f, 0.02075415f, 0.14971875f, 0.08543460f, 0.13598193f, 
    0.02246490f, 0.25087956f, 0.02668815f, -0.06066370f, 0.17807032f, 0.29669079f, 0.18295984f, -0.09888085f, 
    0.01276298f, -0.11607028f, -0.08021041f, -0.23391366f, -0.34359387f, -0.04079509f, -0.04520651f, -0.15256755f, 
    -0.18471470f, 0.05718184f, 0.18517588f, 0.19683622f, 0.04172613f, -0.03101468f, 0.27969348f, -0.33081561f, 
    0.02802199f, 0.07609117f, 0.20500146f, -0.06048004f, 0.06194445f, -0.06392493f, -0.02388803f, 0.08413764f, 
    -0.01182829f, 0.09643503f, -0.06380827f, -0.16813038f, 0.13586536f, 0.11754502f, 0.11024694f, -0.10211734f, 
    0.07415580f, -0.07888960f, 0.06245064f, 0.15420769f, -0.03140079f, -0.03458980f, 0.19059409f, -0.33207986f, 
    -0.20848244f, -0.15522799f, -0.05078325f, 0.04724211f, 0.05798884f, 0.15946402f, 0.13289073f, 0.21451838f, 
    0.16570808f, 0.10539092f, -0.07078388f, 0.06602401f, 0.24303432f, 0.05786410f, 0.02195145f, -0.33227408f, 
    0.40668929f, 0.63528174f, 0.29311752f, -0.04537357f, 0.44842696f, -0.07108996f, -0.22106436f, 0.23039643f, 
    -0.17748716f, 0.06896554f, -0.11761982f, 0.49576852f, 0.14111337f, -0.23913890f, 0.46241453f, -0.27044469f, 
    -0.04704599f, 0.42473406f, 0.04766401f, 0.16151589f, 0.09047519f, 0.12056395f, -0.02881109f, -0.17695324f, 
    -0.13478681f, -0.11126886f, -0.15194042f, -0.20424367f, -0.08498257f, -0.67549831f, -0.12878783f, -0.03183091f, 
    -0.20872626f, 0.49248141f, -0.23311223f, -0.03349282f, -0.17667726f, -0.07271763f, 0.36750188f, 0.06926173f, 
    0.18287846f, 0.01883414f, -0.03815920f, 0.03487143f, 0.07864776f, 0.06321955f, -0.21269862f, -0.08877212f, 
    -0.01482342f, -0.18266767f, 0.07955761f, -0.05408325f, 0.27714938f, -0.00511452f, 0.21253775f, 0.04542449f, 
    0.04772580f, -0.11173380f, -0.18643615f, 0.40462360f, -0.43254220f, -0.17691572f, -0.28516430f, -0.88939965f, 
    0.25248736f, 0.14287604f, 0.09699680f, 0.02484067f, 0.34533161f, -0.09025450f, 0.04408967f, 0.11862703f, 
    0.26309630f, 0.07362708f, -0.22463371f, -0.11627167f, 0.06531859f, 0.07026318f, -0.78830463f, 0.31168115f, 
    -0.11644261f, 0.11421074f, 0.16394763f, -0.00950412f, -0.10028479f, 0.28875023f, -0.09715755f, -0.59487826f, 
    0.27775061f, 0.31928933f, 0.12791415f, 0.01034899f, 0.05755807f, 0.23966931f, -0.16730854f, -0.03286533f, 
    -0.01410130f, -0.01477871f, -0.00365070f, -0.00376796f, -0.01741046f, -0.10683893f, 0.16482626f, -0.03018312f, 
    -0.05523983f, 0.46061707f, 0.36300525f, 0.03174065f, 0.02824984f, 0.01916188f, -0.35854405f, 0.28948095f, 
    0.09233126f, 0.23891696f, -0.01273249f, 0.04000590f, -0.10133140f, -0.07498588f, -0.09215149f, 0.42647499f, 
    -0.12154312f, 0.09912039f, 0.20488966f, -0.02979087f, -0.04394728f, 0.01369667f, 0.27162519f, 0.06998857f, 
    -0.12803122f, 0.27926579f, -0.16854002f, -0.07831171f, 0.77340454f, 0.22717571f, -0.19822811f, -0.04543875f, 
    0.30595532f, -0.03075002f, -0.31748760f, 0.13405758f, 0.03357339f, 0.04680103f, -0.05279758f, 0.10711096f, 
    0.04612355f, -0.35589424f, -0.04881649f, -0.02479881f, 0.13914223f, -0.05721040f, -0.30706492f, -0.05531699f, 
    0.08085243f, 0.11652735f, -0.11439196f, 0.11837287f, -0.02578517f, -0.21401630f, 0.20928273f, -0.05797191f, 
    0.05637906f, -0.51324379f, 0.07432560f, 0.13648492f, 0.43943503f, -0.06981259f, 0.05373051f, 0.21730259f, 
    0.20867355f, -0.02534162f, 0.07025689f, -0.05100213f, 0.06462539f, 0.13611035f, 0.10778300f, -0.05716050f, 
    0.07954269f, 0.08573110f, 0.04340722f, 0.07968705f, 0.09466559f, -0.04391564f, 0.05219963f, 0.27729726f, 
    0.34062549f, 0.07480509f, 0.15349495f, -0.03561419f, -0.06232324f, -0.09613012f, -0.02498647f, 0.11893126f, 
    0.02713365f, 0.19179167f, 0.07681200f, -0.02262501f, 0.36255202f, 0.14834490f, 0.21197353f, 0.17283483f, 
    0.00943807f, -0.08035409f, 0.05765345f, 0.13251577f, -0.50789678f, -0.03644412f, 0.23839293f, 0.00903849f, 
    -0.04221691f, 0.20800388f, 0.04245818f, -0.13826934f, 0.05095754f, 0.17837664f, 0.41188762f, -0.02070133f, 
    -0.02101898f, -0.11063018f, 0.12622559f, 0.12697700f, 0.06433877f, -0.56180817f, -0.03288979f, -0.00781800f, 
    -0.02788060f, 0.04140919f, 0.00902192f, 0.01803891f, -0.06049137f, 0.05686288f, 0.01841827f, 0.04519387f, 
    -0.20419231f, 0.27551129f, 0.06183026f, 0.05731895f, 0.05522843f, -0.14183621f, 0.35892087f, -0.44404137f, 
    -0.09727924f, -0.30423424f, -0.16956721f, -0.07876816f, 0.08459212f, 0.12211411f, -0.32716328f, 0.00684121f, 
    0.14956717f, 0.11804654f, -0.04401417f, 0.03014952f, 0.01810556f, -0.03897322f, -0.02805531f, -0.31293243f, 
    -0.03696049f, 0.05199313f, -0.04886983f, 0.00276936f, -0.02203142f, -0.03018858f, -0.05238234f, -0.09538002f, 
    -0.04319003f, -0.04820758f, -0.01393215f, -0.05910859f, -0.02668499f, 0.00631748f, -0.04386193f, -0.03744735f, 
    0.01017179f, -0.06318906f, -0.03508647f, -0.03040246f, 0.02564766f, 0.05620781f, -0.00635527f, -0.06210381f, 
    -0.04323452f, 0.01447351f, -0.07284151f, 0.03958780f, 0.02184351f, 0.05232209f, -0.02250153f, -0.09504720f, 
    -0.03961376f, -0.00160215f, -0.02998804f, 0.03235798f, -0.01878716f, -0.01734683f, -0.05049854f, 0.06759079f, 
    0.00547816f, 0.05215114f, -0.06358708f, -0.07087618f, -0.08417752f, -0.04326782f, -0.08980080f, 0.05313220f, 
    0.01587712f, -0.04194631f, -0.06869145f, 0.05342043f, -0.06103602f, -0.07932274f, -0.02505394f, -0.00780769f, 
    -0.00035107f, -0.07322221f, 0.07960071f, -0.06241391f, -0.07978198f, 0.04857062f, -0.02212660f, 0.06364536f, 
    -0.02497988f, 0.04632359f, -0.04866580f, -0.00705731f, -0.06275903f, -0.01570315f, -0.00195836f, -0.07986810f, 
    0.06519585f, 0.04897743f, 0.05419446f, -0.01670642f, 0.08469810f, 0.07395377f, -0.03406105f, 0.08176429f, 
    0.00031724f, -0.07623406f, 0.00535663f, -0.09050112f, 0.00263694f, 0.03917505f, -0.06833854f, 0.08784820f, 
    -0.02484513f, 0.05364702f, 0.07974605f, -0.07747332f, -0.03916278f, -0.08269912f, 0.01877391f, 0.07875028f, 
    0.02995912f, 0.08810685f, -0.04923433f, -0.06639904f, 0.05264696f, -0.08585271f, -0.08750468f, -0.01748126f, 
    -0.03339851f, 0.06995393f, 0.03993404f, 0.05632694f, 0.02698855f, 0.04888560f, -0.02775387f, 0.05350123f, 
    -0.08890809f, 0.05314500f, 0.04176178f, -0.04805747f, -0.03201940f, 0.02505043f, -0.05008961f, -0.04827801f, 
    -0.05011123f, -0.00735817f, -0.02632046f, 0.00930386f, -0.03391024f, 0.07132744f, -0.08391982f, -0.04110795f, 
    0.15551455f, 0.27617571f, 0.18011193f, 0.01374017f, -0.21422581f, 0.34702456f, -0.16239357f, 0.12555790f, 
    -0.07229984f, -0.11071441f, 0.08590153f, 0.05211035f, -0.05013513f, -0.05541083f, 0.19478431f, -0.02577395f, 
    -0.17616421f, 0.09032290f, 0.04920424f, 0.27187651f, 0.02002185f, -0.08408660f, -0.26499677f, 0.05012620f, 
    -0.02916593f, -0.16825755f, 0.12749924f, 0.16366117f, 0.20600294f, 0.13656437f, 0.11767499f, -0.06020417f, 
    0.05518179f, -0.09434710f, -0.13744485f, -0.12548219f, -0.03516734f, -0.05712316f, 0.16029328f, 0.20419243f, 
    -0.05920850f, -0.04230942f, -0.02472692f, 0.13312833f, -0.18042575f, 0.16814625f, 0.03333506f, -0.23869219f, 
    -0.18832010f, 0.11246015f, -0.15689990f, -0.08249741f, -0.00448169f, -0.07578391f, -0.00776389f, 0.17588380f, 
    0.24625802f, -0.12365756f, 0.10383462f, 0.06591491f, -0.10964580f, -0.70242918f, 0.00550253f, -0.12119059f, 
    0.04162528f, 0.25329566f, 0.16841045f, -0.13016281f, 0.09624302f, 0.08035073f, 0.16749813f, -0.26681575f, 
    -0.40721503f, 0.10105497f, 0.11805879f, -0.48776075f, -0.02463733f, -0.00353040f, -0.27827686f, 0.19778118f, 
    -0.02205596f, 0.02307088f, 0.17279786f, 0.13831024f, 0.26171026f, -0.02363450f, 0.32088029f, -0.21380308f, 
    0.01277849f, -0.03467483f, 0.19221659f, -0.07698872f, 0.28458494f, -0.24363476f, 0.21362370f, -0.15196224f, 
    0.06858670f, 0.02981841f, -0.05944945f, -0.53981018f, -0.20627627f, -0.00595530f, 0.12891656f, 0.03861208f, 
    0.01161160f, 0.10909478f, 0.33220464f, 0.22269465f, 0.21248382f, 0.08601778f, -0.74788421f, -0.31399000f, 
    -0.01064118f, 0.05170693f, -0.01907592f, 0.04265739f, 0.06218943f, -0.18607995f, -0.31370571f, 0.16994469f, 
    0.07938103f, 0.18400507f, -0.11945207f, 0.11955605f, -0.21560885f, 0.02724113f, 0.04285934f, -0.73460501f, 
    -0.05137298f, -0.01934348f, -0.03285377f, 0.01332833f, 0.07319606f, -0.05129976f, -0.08913334f, -0.00615553f, 
    -0.08571457f, 0.00202953f, -0.08196673f, -0.02307535f, -0.02849532f, -0.02678064f, -0.01578662f, -0.10836770f, 
    0.01632641f, -0.01019200f, -0.01050957f, -0.01179633f, 0.03920726f, -0.07580510f, 0.01195670f, -0.08251327f, 
    -0.01603561f, 0.03778446f, 0.01166064f, -0.01887558f, -0.04118445f, -0.10227669f, -0.07313970f, 0.06322400f, 
    0.04678206f, -0.06201936f, 0.00770821f, -0.00530860f, 0.03673566f, -0.04021858f, -0.02847358f, 0.06756382f, 
    0.03767800f, -0.02570905f, -0.06159466f, -0.04079275f, 0.02960946f, -0.03408034f, -0.03350319f, -0.12910686f, 
    -0.08485760f, -0.14252584f, -0.01174370f, -0.10161833f, -0.04553135f, 0.04134235f, -0.02939286f, 0.05983943f, 
    0.08738788f, -0.11640268f, 0.04154719f, -0.03875536f, -0.07454056f, -0.02805643f, -0.03031270f, -0.05270854f, 
    -0.12202277f, 0.09239569f, 0.00717466f, -0.05134185f, 0.00982031f, -0.08640473f, -0.04547882f, -0.04384130f, 
    0.03892254f, -0.12209252f, 0.01298054f, -0.09072661f, 0.00737150f, -0.04691097f, -0.03712092f, 0.07837586f, 
    -0.07293682f, 0.02575979f, -0.09782362f, -0.13835837f, 0.04022467f, 0.06471495f, 0.04056932f, 0.08648748f, 
    -0.08300427f, -0.08113211f, -0.03762617f, 0.06459147f, -0.08904075f, 0.10664439f, -0.03727295f, -0.04352053f, 
    -0.06218221f, -0.04045425f, -0.04953230f, -0.06401657f, -0.12447411f, 0.00835669f, -0.00426866f, 0.04874530f, 
    -0.04835184f, 0.11445082f, -0.02234548f, -0.02720089f, -0.07311521f, 0.03745389f, -0.03395723f, -0.09297965f, 
    -0.10546561f, -0.04366074f, -0.03755406f, -0.04783070f, -0.02643564f, -0.01108573f, -0.09319603f, 0.07090075f, 
    -0.02745140f, -0.02723179f, -0.00924758f, -0.08387796f, -0.09539662f, -0.05884030f, -0.10317202f, -0.03872241f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12085197f, -0.08601401f, -0.02425478f, 0.16045411f, -0.06080672f, -0.04047001f, 0.15401307f, 0.17827524f, 
    0.11942387f, 0.08412793f, -0.10899950f, 0.18989760f, 0.03850304f, 0.18702841f, 0.30001208f, 0.30996916f, 
    0.11608452f, -0.13483712f, 0.23207912f, -0.09036749f, 0.00083303f, -0.16279204f, 0.22237824f, 0.02325785f, 
    -0.03758409f, 0.02112974f, 0.12260079f, 0.01803896f, 0.05000911f, -0.00578525f, 0.01672733f, 0.17982471f, 
    0.25304690f, 0.22080627f, -0.00584114f, -0.01005190f, 0.05966379f, -0.06988736f, -0.27238765f, -0.18532832f, 
    -0.03715403f, 0.06570365f, 0.15166365f, 0.12352131f, 0.06651070f, -0.00590883f, -0.09796162f, 0.01916993f, 
    0.07928744f, 0.04758945f, -0.06909183f, 0.09617818f, 0.03583091f, -0.18537523f, -0.09882766f, 0.06927373f, 
    0.06209423f, -0.04017447f, 0.01097001f, 0.03805731f, 0.12938298f, 0.22505929f, -0.04151359f, 0.15007558f, 
    -0.02422501f, 0.01630047f, 0.04262136f, -0.06728864f, -0.05655131f, 0.32167476f, 0.05969232f, 0.17152770f, 
    -0.06314712f, 0.08745548f, -0.11961781f, 0.01014928f, 0.04033694f, -0.02022506f, 0.08002841f, 0.02890029f, 
    0.28928453f, -0.01908541f, -0.05776491f, 0.00474815f, 0.11480220f, 0.09868659f, 0.03300484f, -0.07923395f, 
    0.17393836f, 0.18414114f, -0.17615966f, 0.03835320f, 0.05692905f, -0.10360717f, 0.15903842f, -0.21709965f, 
    -0.18041208f, -0.15780360f, 0.11578789f, 0.19304810f, -0.14963385f, -0.13362698f, 0.12220825f, 0.04558456f, 
    -0.08989787f, -0.08169875f, -0.00487595f, -0.24180602f, -0.13286929f, 0.06991597f, -0.08332789f, 0.13089648f, 
    0.07453424f, 0.03124668f, 0.10534204f, 0.05529133f, -0.02525439f, 0.24891537f, 0.24180792f, 0.31133321f, 
    0.20655811f, 0.24364136f, 0.06112831f, 0.10905334f, 0.01870702f, -0.03860859f, 0.15191555f, -0.04279304f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.06788509f, -0.00813395f, -0.05992325f, 0.30375665f, 0.04537594f, 0.03472920f, 0.23181275f, -0.28662509f, 
    -0.43113181f, 0.02567652f, -0.00360306f, -0.21704797f, -0.69545227f, 0.21616714f, 0.13292980f, -0.07119490f, 
    -0.42028752f, 0.06983144f, 0.12332735f, 0.14243302f, 0.02606850f, -0.06527847f, -0.02684514f, 0.02006440f, 
    0.20574661f, -0.34818473f, 0.01236656f, -0.04439785f, -0.00765388f, -0.01134689f, 0.05466435f, -0.17513354f, 
    -0.22523437f, -0.28280279f, -0.07425523f, 0.18740575f, -0.16546740f, 0.00303644f, -0.21896011f, 0.10584880f, 
    -0.12300178f, -0.41284877f, -0.10742120f, 0.02204918f, 0.17416471f, 0.06768444f, -0.05569369f, -0.04811234f, 
    -0.29893327f, 0.06578267f, 0.05362873f, 0.23884882f, -0.38729191f, -0.55523300f, 0.07329522f, 0.05329593f, 
    -0.47048032f, -0.09841853f, 0.04254444f, 0.15838596f, 0.22553149f, -0.16058017f, 0.06961309f, 0.03439516f, 
    -0.18894728f, -0.89500022f, -0.00983200f, -0.02667276f, 0.02625961f, 0.18034481f, -0.04160756f, -0.33637825f, 
    -0.02903606f, -0.07065327f, -0.13387620f, -0.09293726f, 0.10993835f, 0.06212126f, 0.13926691f, 0.21230151f, 
    0.14519788f, -0.48244554f, -0.03194203f, -0.47493368f, -0.19322766f, 0.09642021f, 0.19253010f, -0.06634837f, 
    -0.07404096f, 0.08373799f, 0.11222484f, -0.25944060f, 0.00678280f, -0.61893851f, -0.03244108f, 0.10804269f, 
    0.34708673f, 0.00235331f, -0.14213246f, -0.03356409f, -0.67387086f, -0.16419324f, 0.09046633f, -0.07886951f, 
    -0.07635484f, 0.00208804f, 0.05067593f, 0.20382148f, -0.04631657f, 0.06180914f, -0.09403618f, 0.19876893f, 
    -0.00515450f, 0.19129464f, 0.16578113f, -0.30845737f, -0.04095330f, -0.48144042f, -0.31450486f, -0.31375924f, 
    -0.07618281f, 0.05729126f, 0.17025192f, -0.30678406f, 0.27230167f, 0.02259024f, -0.20693423f, -0.06461667f, 
    0.14143659f, -0.11090992f, 0.10337950f, 0.02504451f, 0.02016820f, 0.04670630f, -0.09932198f, 0.05828070f, 
    0.01464252f, -0.06014384f, -0.03863720f, -0.07712003f, 0.16446272f, -0.08938430f, 0.06984836f, -0.08881701f, 
    0.50197613f, -0.06209543f, 0.13537446f, 0.09792899f, -0.09669286f, 0.05620420f, -0.09008689f, 0.03380903f, 
    -0.09258344f, -0.06544103f, -0.03474224f, 0.02542852f, 0.00410968f, -0.15235704f, 0.07237124f, -0.02644293f, 
    -0.34637570f, -0.00842725f, -0.00665753f, 0.26218691f, -0.03477372f, -0.07039858f, -0.10618003f, -0.42614135f, 
    0.01222910f, -0.65393555f, 0.15777346f, 0.05937024f, -0.42794713f, -0.07327551f, 0.01273691f, 0.04618799f, 
    0.11676455f, 0.16846362f, 0.03251458f, -0.12016346f, -0.07802559f, 0.46097475f, 0.06412043f, -0.02545438f, 
    0.32384008f, 0.18801121f, -0.03748994f, -0.07257511f, -0.17167023f, -0.15383972f, 0.04789697f, -0.12188091f, 
    0.29352674f, 0.14649928f, 0.07318038f, -0.00251626f, -0.04171734f, -0.01462126f, 0.22462270f, 0.20746133f, 
    0.29221943f, -0.56247294f, -0.04080917f, 0.01202701f, -0.04608066f, -0.02483804f, 0.11617085f, 0.03374868f, 
    0.07702283f, 0.31606370f, -0.00383802f, -0.34163228f, -0.13526794f, 0.00856543f, 0.16401593f, -0.04157779f, 
    -0.46937636f, 0.12074775f, -0.09427056f, -0.26715976f, 0.18859857f, 0.26106092f, -0.22559178f, 0.08409540f, 
    0.02022518f, -0.14525390f, -0.24409898f, 0.01035657f, 0.21138786f, -0.30457398f, 0.13718443f, 0.07195155f, 
    -0.04255716f, -0.02501472f, 0.09532925f, -0.02718681f, -0.05403401f, -0.05637621f, 0.00319110f, -0.24127179f, 
    0.04708400f, 0.18876161f, 0.17915820f, 0.26669043f, 0.07589083f, 0.16844521f, -0.28329155f, -0.20397452f, 
    -0.06474470f, 0.01287528f, -0.10052017f, -0.06727757f, -0.29631171f, -0.03774627f, -0.39373702f, -0.05440927f, 
    0.30412576f, 0.02306788f, -0.07055782f, -0.77883530f, -0.07605176f, 0.02540717f, -0.45267588f, 0.01129073f, 
    0.22109087f, 0.28413722f, -0.04464706f, 0.13828881f, 0.28468707f, -0.06009719f, -0.27186370f, -0.40617123f, 
    -0.32698902f, -0.16116732f, 0.14193285f, -0.21416970f, 0.22820328f, 0.14619114f, -0.18613514f, -0.06792085f, 
    0.24171163f, 0.15424661f, -0.21906392f, 0.04168967f, 0.04272643f, 0.09484053f, -0.07531814f, -0.01762074f, 
    0.21276438f, -0.03666372f, -0.08108243f, 0.07634670f, -0.38304096f, -0.02126784f, -0.70194232f, -0.18592726f, 
    -0.02871838f, 0.20328437f, 0.15927404f, 0.06474104f, -0.14440571f, 0.01867168f, -0.03851816f, 0.21258657f, 
    -0.07524469f, 0.01681496f, -0.05174311f, -0.30010769f, -0.29371873f, 0.14947148f, 0.01988364f, -0.69783789f, 
    -0.77072358f, -0.05429207f, -0.00382880f, 0.24440676f, -0.39821711f, -0.40925294f, 0.05259197f, 0.04985727f, 
    -0.52193087f, -0.15388487f, -0.09962434f, 0.00888422f, -0.06584870f, -0.20673667f, 0.13421410f, 0.01865990f, 
    -0.09058011f, 0.26254207f, -0.08229063f, 0.02352857f, -0.13590647f, 0.00822033f, -0.10884105f, -0.50692207f, 
    -0.02216577f, -0.51957017f, -0.01313949f, -0.27315754f, 0.10162715f, 0.13254708f, 0.22480984f, -0.04572509f, 
    -0.32469782f, -0.01004447f, 0.26412377f, 0.15528579f, -0.05860784f, -0.04798156f, 0.24121186f, 0.26945576f, 
    0.41695324f, -0.63335955f, 0.34267601f, -0.11208943f, -0.74370009f, -0.79176080f, 0.17933914f, 0.04088752f, 
    0.13835207f, 0.00565208f, 0.16078743f, -0.38987142f, 0.01260911f, 0.07239160f, 0.04202497f, 0.22796014f, 
    -0.08769680f, 0.23112386f, -0.24871266f, 0.02963494f, 0.00819990f, 0.02949897f, -0.17546502f, -0.29346931f, 
    -0.71292263f, -0.33656028f, -0.30886185f, 0.21662675f, 0.18972240f, 0.04379875f, -0.19070624f, 0.10977460f, 
    -0.14982204f, 0.03396007f, -0.15784809f, 0.00048951f, -0.06465539f, -0.08042000f, 0.12218063f, -0.03466202f, 
    -1.22690427f, -0.49158362f, 0.00261768f, -0.28120363f, 0.04714571f, 0.08755015f, -0.19666122f, 0.17024872f, 
    -0.07090390f, 0.13770996f, 0.01540704f, 0.15362914f, 0.31645587f, 0.13937989f, -0.17933813f, -0.09129541f, 
    0.06700162f, 0.25100905f, -0.17141268f, -0.08010361f, -0.02873268f, 0.15685064f, 0.03907910f, -0.76966965f, 
    -0.07001297f, -0.04832695f, -0.03706681f, -0.79625660f, 0.22287863f, 0.01966329f, 0.12880883f, -0.02581913f, 
    -0.01009655f, 0.11612351f, -0.13652204f, -0.10272807f, -0.02596845f, -0.07097443f, -0.02546949f, -0.28703141f, 
    -0.30192658f, 0.06179940f, -0.08427408f, 0.09421199f, -0.15124838f, 0.25085509f, -0.09230936f, 0.19806403f, 
    -0.12884074f, 0.08439036f, -0.07320670f, 0.05006927f, -0.15533093f, 0.05419691f, 0.03449785f, 0.07018879f, 
    -0.10637358f, 0.03082306f, 0.18831863f, -0.02788075f, -0.05222776f, -0.32880729f, -0.13207030f, -0.08131836f, 
    -0.49053812f, 0.12235700f, -0.01664683f, 0.07763141f, 0.10204678f, 0.05980675f, 0.33346567f, -0.15216805f, 
    -0.53870916f, -0.04472289f, 0.00250554f, 0.06767216f, -0.20341490f, -0.35501784f, -0.35190406f, -0.06173038f, 
    0.07381769f, -0.26043993f, 0.03120738f, 0.15513091f, -0.20420921f, -0.56432068f, -0.06055069f, -0.08716653f, 
    -0.14027649f, 0.09386255f, -0.11711755f, -0.01333085f, -0.10372324f, 0.17928328f, -0.39003021f, 0.04816365f, 
    -0.02540406f, -0.03174662f, -0.18274774f, 0.20874457f, 0.05556913f, -0.00884037f, -0.00049568f, -0.42188311f, 
    -0.03952754f, -0.37884712f, -0.15343095f, 0.05888987f, 0.00434200f, 0.10059416f, 0.18265125f, 0.15072700f, 
    0.14549546f, 0.12183365f, 0.14148219f, 0.13642128f, 0.09025058f, 0.00416779f, 0.08257321f, 0.08514141f, 
    0.58364862f, 0.04000544f, -0.27672645f, 0.02141809f, 0.03299513f, -0.06773148f, 0.10637105f, 0.01605233f, 
    0.16830319f, 0.11189552f, 0.03597380f, -0.12674940f, -0.20340863f, -0.11090415f, -0.30952466f, 0.10073169f, 
    -0.32957467f, -0.12049231f, 0.07219871f, -0.05798193f, -0.18940865f, -0.19529781f, -0.23743483f, -0.04978595f, 
    -0.03871467f, -0.03862020f, 0.04466570f, 0.04940264f, -0.10204362f, 0.09824959f, -0.03812991f, 0.30498636f, 
    0.09895979f, 0.19304347f, -0.03391837f, 0.06869022f, -0.19638133f, 0.01789687f, 0.01177611f, -0.46266764f, 
    -0.06424920f, -0.27398586f, -0.10696363f, 0.10002731f, -0.03004870f, -0.03316407f, -0.04857791f, -0.03560897f, 
    0.17790966f, -0.08638775f, -0.17000876f, 0.04651821f, 0.25012422f, -0.75841576f, 0.02428406f, 0.02187394f, 
    -0.56717944f, -0.26205066f, -0.06321672f, 0.03943927f, 0.03241632f, 0.06465841f, -0.05055029f, -0.06225565f, 
    0.23714854f, 0.15923277f, -0.11029072f, -0.08861629f, -0.08485352f, 0.14215793f, -0.05286911f, 0.32955152f, 
    -0.25333670f, 0.06799574f, -0.08547357f, 0.07005529f, -0.18905331f, -0.01616839f, 0.10409970f, 0.06032842f, 
    0.07801674f, -0.23446704f, 0.03970291f, 0.25833118f, 0.01376783f, 0.08175797f, -0.28006071f, -0.00395988f, 
    0.37977576f, 0.14185201f, -0.77913409f, 0.18080921f, -0.04369913f, 0.16088142f, 0.08187944f, -0.14986762f, 
    0.10009138f, 0.19756040f, 0.03652341f, 0.13767557f, 0.08207849f, -0.02348263f, -0.08582302f, 0.08889922f, 
    -0.02860674f, 0.05032614f, 0.03925597f, -0.16675447f, 0.05239183f, -0.01307222f, -0.02278029f, -0.03938579f, 
    0.05232812f, 0.14562641f, 0.08188551f, -0.56190044f, 0.01925537f, -0.23771933f, 0.18567708f, 0.30541420f, 
    0.08201192f, 0.12428287f, -0.07267153f, 0.17767410f, 0.16309035f, -0.03710119f, 0.34627458f, -0.05576425f, 
    -0.49341559f, -0.06721845f, -0.05182572f, 0.22406584f, -0.09279598f, -0.07827447f, 0.09384481f, 0.11192998f, 
    0.09178615f, 0.01878480f, -0.05720550f, 0.00455004f, 0.19212011f, -0.31059706f, 0.12410233f, -0.08690408f, 
    0.03498826f, 0.19853833f, -0.00521812f, 0.20258772f, -0.52536386f, -0.73153681f, 0.04814592f, -0.01327427f, 
    -0.25682628f, -0.75169271f, -0.18633890f, -0.01562175f, 0.01944021f, -0.41596988f, -0.07670612f, 0.05867192f, 
    0.17479432f, -0.09395921f, 0.00170258f, 0.15415671f, 0.26872054f, -0.07856002f, 0.20844249f, 0.55783552f, 
    -0.04759029f, 0.30499476f, -0.04415996f, 0.10091889f, -0.11025791f, -0.02660729f, -0.03571792f, 0.13646968f, 
    -0.13091169f, 0.01627906f, 0.07256512f, -0.19082223f, -0.32900316f, 0.11027699f, -0.01390789f, 0.17435350f, 
    0.34740409f, 0.10578566f, -0.00795479f, -0.44024047f, 0.07105099f, 0.16937183f, 0.02816113f, 0.13393368f, 
    0.18245555f, -0.19727090f, 0.22135894f, -0.04506215f, -0.05064144f, 0.18009940f, -0.37542111f, -0.00681001f, 
    0.18962958f, -0.09962228f, -0.03640907f, -0.06975858f, -0.20754544f, -0.01961857f, -0.03015784f, 0.06920506f, 
    0.15569049f, 0.45825335f, -0.02699948f, 0.08352131f, -0.34073618f, -0.48134193f, -0.08681812f, -0.03019842f, 
    -0.69302332f, -0.02421602f, -0.35359293f, -0.22156978f, 0.07594413f, -0.45076779f, 0.03690830f, -0.08305854f, 
    -0.35246453f, 0.36942515f, -0.04048491f, -0.23721492f, -0.24678303f, 0.15413177f, 0.05157313f, -0.04667424f, 
    -0.15392177f, -0.03751182f, 0.04893228f, -0.05692355f, -0.12187283f, -0.07765016f, 0.00527536f, 0.02236079f, 
    -0.07768670f, -0.07005757f, 0.03796840f, 0.04766310f, 0.06498495f, 0.14134480f, -0.00129858f, 0.20921420f, 
    0.05100183f, 0.16784519f, -0.30543008f, -0.82168120f, -0.02585612f, -0.05895483f, -0.40916017f, -0.07187236f, 
    -0.13682650f, 0.07033974f, 0.02435740f, -0.74123448f, 0.04545446f, 0.00384587f, 0.05166087f, -0.07619432f, 
    -0.23961045f, 0.03869684f, -0.06145764f, 0.02314224f, 0.16092619f, 0.26243836f, 0.17062902f, 0.15748146f, 
    -0.71359795f, -0.36642444f, 0.10603847f, -0.14147183f, 0.14699252f, -0.41639093f, 0.10775580f, 0.03465551f, 
    -0.36126745f, 0.30384216f, -0.12822904f, 0.01991982f, -0.02631403f, 0.17779207f, 0.03816117f, -0.20515600f, 
    0.22518143f, 0.20845868f, -0.06978926f, -0.13743085f, 0.44321057f, -0.03707632f, -0.41336203f, -0.16360173f, 
    0.00084367f, -0.63592684f, 0.02281670f, 0.18486056f, 0.15788798f, -0.03704063f, 0.01689922f, -0.07200350f, 
    -0.44008893f, 0.05611801f, -0.06452671f, -0.20390035f, -0.07547747f, -0.15553507f, -0.05801398f, 0.15412869f, 
    0.18719615f, -0.14718875f, -0.04532314f, 0.01850783f, 0.07754895f, 0.24232616f, -0.06693220f, 0.18376063f, 
    -0.58134228f, -0.33320090f, -0.03140769f, -0.03101573f, 0.05690347f, 0.16338684f, -0.09166187f, -0.18898372f, 
    0.11386043f, -0.07455801f, -0.00788971f, -0.05757675f, -0.64048231f, -0.02101089f, 0.10886900f, -0.17372076f, 
    0.10464285f, 0.00378663f, -0.03917820f, -0.09857382f, 0.09154214f, -0.29637280f, -0.18966666f, 0.05799849f, 
    0.11999536f, -0.07581057f, -0.48792216f, 0.26746026f, -0.10529964f, 0.49245146f, -0.39256322f, -0.39136717f, 
    -0.18387061f, -0.44903231f, 0.31971186f, 0.30484089f, 0.01761662f, -0.24406897f, -0.03773342f, 0.05248306f, 
    -0.66556293f, -0.03785746f, 0.14629547f, -0.37347186f, -0.00564710f, -0.00591235f, -0.07819168f, 0.11921775f, 
    0.08446137f, -0.33585119f, 0.05814999f, -0.31845349f, 0.01534625f, 0.00364958f, 0.09287166f, 0.09497655f, 
    0.06560056f, 0.23320585f, -0.21675983f, -0.18612993f, -0.05929166f, -0.03911225f, 0.10344370f, -0.01067332f, 
    -0.39825761f, -0.04305027f, 0.20109925f, 0.11130260f, -0.05721149f, -0.03800091f, 0.01871795f, -0.57270133f, 
    0.17867021f, -0.07663558f, 0.02999574f, -0.44188967f, -0.22372687f, -0.13153408f, -0.32071331f, -0.18530633f, 
    0.18941374f, -0.02956027f, -0.46548963f, 0.02959168f, 0.01175089f, 0.08407382f, -0.79256821f, -0.06051572f, 
    -0.02578550f, -0.02452713f, -0.05458105f, 0.09220941f, -0.04837013f, 0.00693979f, 0.02276229f, 0.33548379f, 
    -0.77777606f, -0.38955867f, 0.00878409f, 0.03173775f, -0.10686748f, -0.01055865f, 0.06309646f, -0.12997802f, 
    -0.01786251f, 0.13357064f, -0.55800676f, -0.56358188f, 0.03429712f, -0.02645822f, -0.02702321f, -0.35612768f, 
    0.04262573f, -0.59019738f, -0.07329061f, 0.04256792f, 0.26848781f, 0.12263395f, -0.05398352f, -0.03726490f, 
    0.01430330f, -0.30875406f, 0.02956512f, -0.03335473f, 0.12040831f, -0.11792433f, 0.03175160f, -0.45113650f, 
    0.09602523f, 0.16983089f, -0.13694778f, -0.03416786f, -0.01768634f, -0.25767416f, 0.14449903f, -0.22044933f, 
    -0.15722461f, -0.47686216f, -0.03444749f, -0.03298800f, -0.05664646f, 0.03269382f, -0.47192135f, 0.09850303f, 
    -0.08396848f, 0.26217121f, 0.03567073f, -0.01650903f, -0.06828125f, -0.21284437f, -0.16029057f, -0.02038518f, 
    0.20053928f, -0.19712061f, 0.67029947f, -0.14138705f, -0.42269662f, 0.48054522f, -0.01575956f, 0.17897959f, 
    0.03704001f, 0.11131304f, -0.43824670f, -0.09626629f, 0.21268570f, 0.07087424f, -0.23714726f, 0.05575498f, 
    -0.00962916f, -0.04880731f, -0.64359856f, 0.11163296f, -0.09274576f, -0.04151972f, -0.06686470f, 0.11418643f, 
    0.00023632f, -0.06516615f, -0.29185563f, 0.08195560f, -0.08694033f, -0.68945807f, -0.12069894f, -0.09498750f, 
    0.06494004f, -0.34444645f, 0.13999656f, 0.06662136f, 0.06017538f, -0.04231985f, 0.11764049f, -0.07847200f, 
    -0.03782488f, 0.06817027f, 0.11299510f, -0.45324981f, -0.03475919f, 0.03730872f, -0.38733807f, -0.22870144f, 
    0.17640290f, -0.38872087f, -0.04962740f, 0.23205458f, -0.34062052f, -0.41188002f, -0.08537106f, -0.23100096f, 
    -0.05164900f, 0.12313624f, -0.52803957f, 0.17978759f, 0.00882694f, 0.03750631f, 0.25559300f, -0.01657876f, 
    -0.51648951f, -0.26794207f, 0.26130161f, -0.01666777f, 0.01961833f, -0.51701164f, -0.05380226f, 0.29215395f, 
    -0.06337108f, 0.12589724f, -0.02011119f, -0.02755457f, -0.29875118f, -0.03765722f, 0.09340306f, -0.09807733f, 
    -0.05867712f, -0.39730218f, 0.09223343f, -0.02426468f, -0.36389384f, -0.03717189f, -0.05252102f, -0.02380950f, 
    0.24684936f, -0.06076549f, -0.13567632f, -0.72205049f, 0.37021819f, -0.65468818f, -0.06257965f, 0.12033179f, 
    -0.43646953f, 0.07752492f, 0.04921605f, -0.28686473f, -0.20553440f, 0.08324087f, -0.03036041f, -0.18246663f, 
    0.16191813f, 0.06246516f, 0.25797245f, 0.05694565f, -0.04577031f, -0.22547679f, 0.13132319f, 0.18590948f, 
    -0.17997672f, 0.15736231f, 0.02401859f, 0.02343940f, 0.21977614f, -0.04373006f, -0.56189823f, 0.25289240f, 
    -0.24851087f, -0.12135616f, 0.04150864f, 0.36184528f, 0.15952872f, 0.04800339f, -0.01737217f, 0.00330632f, 
    0.01226150f, -0.09599856f, 0.47646511f, -0.49596387f, 0.07437357f, -0.02319838f, 0.10089749f, -0.10561273f, 
    -0.03187940f, 0.00201223f, -0.36780915f, -0.33908382f, 0.26937157f, 0.08287157f, 0.02619327f, -0.04841131f, 
    0.22217326f, 0.04403755f, 0.11134028f, -0.32449478f, -0.06438164f, -0.02369492f, 0.05770395f, -0.12377344f, 
    -0.00142547f, 0.10740524f, 0.02848736f, -0.07644691f, -0.05655562f, -0.34146950f, -0.25556394f, -0.21419032f, 
    -0.04200159f, -0.19431068f, 0.02567155f, 0.05788189f, -0.52541065f, 0.02973305f, -0.37082222f, -0.04301138f, 
    -0.70822281f, -0.03279775f, -0.08275051f, 0.00510155f, -0.10967398f, -0.00020799f, -0.05687436f, 0.22290595f, 
    0.17759404f, 0.10863823f, -0.03709752f, 0.07764848f, -0.03952490f, 0.09713873f, 0.00265191f, -0.05232845f, 
    -0.22921279f, -0.45275968f, -0.21247707f, -0.05637911f, -0.72547925f, -0.20310488f, 0.27229926f, -0.04787902f, 
    -0.09920622f, -0.74276245f, 0.23466630f, -0.02511279f, -0.01344755f, -0.29563975f, -0.05149116f, -0.26706287f, 
    -0.35734349f, -0.18763098f, -0.07695865f, -0.40243018f, -0.27734303f, 0.05118984f, 0.29230255f, -0.51088113f, 
    -0.07023930f, -0.61814600f, 0.06040305f, -0.15920144f, 0.15555751f, -0.07339481f, 0.00026021f, 0.10455135f, 
    0.16639194f, 0.05330671f, 0.03820398f, -0.04070003f, -0.56060398f, -0.37520224f, -0.01294279f, -0.13985586f, 
    0.00302205f, -0.11386945f, -0.00408276f, -0.05923756f, 0.23532192f, -0.11679652f, 0.02602188f, 0.13339712f, 
    -0.20140494f, -0.33769470f, -0.31825069f, -0.00668399f, 0.06266858f, -0.02809779f, -0.47452581f, -0.47497046f, 
    -0.05227955f, 0.20675986f, -0.09884468f, 0.06429721f, 0.02940257f, -0.05444902f, -0.27652118f, 0.22099064f, 
    0.12400933f, 0.09171055f, 0.01030033f, -0.35492244f, 0.10184303f, 0.05751074f, 0.19028586f, -0.08995089f, 
    0.14693572f, 0.10493322f, 0.51032895f, 0.14596204f, 0.03395546f, -0.51383936f, -0.23869883f, 0.19621187f, 
    -0.47549954f, -0.06699769f, 0.02003266f, -0.14970547f, 0.05480948f, 0.27854031f, 0.13120082f, 0.08585029f, 
    0.05200480f, -0.07721473f, -0.02637659f, 0.08829816f, 0.07060036f, 0.03777755f, -0.08601804f, 0.25264442f, 
    0.01318685f, -0.23409812f, -0.00644726f, -0.57103920f, -0.05866500f, 0.04772626f, -0.06312677f, 0.09327934f, 
    -0.04505681f, 0.14419660f, -0.10233182f, 0.09777245f, -0.06584555f, -0.04381347f, 0.11631293f, -0.08842571f, 
    0.03955216f, -0.08439251f, -0.29748255f, -0.02248668f, -0.01615051f, 0.08163237f, -0.04531278f, 0.05053154f, 
    -0.13649902f, -0.25963265f, -0.03704920f, 0.05756276f, 0.27025598f, -0.06818130f, 0.09308644f, 0.11534560f, 
    0.02531287f, 0.12137783f, 0.01591580f, -0.03050042f, -0.49879298f, 0.21727185f, -0.03042583f, -0.01942187f, 
    -0.09897712f, 0.29904029f, -0.21614553f, -0.10503513f, -0.00242139f, 0.16864155f, -0.05278397f, 0.17458679f, 
    0.25571692f, 0.23843874f, 0.02394283f, -0.25925949f, -0.20068695f, 0.07484311f, -0.06678116f, -0.79632217f, 
    0.02970995f, 0.12043052f, 0.05410179f, 0.15215237f, -0.15052164f, -0.08550194f, 0.03008564f, -0.19830659f, 
    0.11446073f, -0.09280282f, -0.08632976f, 0.00808671f, 0.23892790f, 0.10235623f, 0.00131520f, 0.00559281f, 
    -0.04379044f, 0.13777545f, 0.01096179f, -0.20057353f, -0.46197918f, 0.16266708f, -0.00973938f, -0.39025548f, 
    -0.03861022f, 0.02380243f, -0.07735886f, -0.05913790f, -0.06247760f, -0.47442055f, 0.25701234f, 0.23608659f, 
    -0.12749293f, 0.17409827f, -0.03259636f, 0.03319661f, 0.10406799f, -0.07076219f, -0.52079111f, -0.42914906f, 
    -0.75478899f, -0.21742918f, -0.03635610f, -0.31384674f, 0.06019254f, 0.14302294f, -0.47306076f, -0.01847691f, 
    -0.14594291f, -0.88622737f, -0.53148413f, -0.04188943f, -0.01099579f, -0.42245698f, 0.07817636f, -0.54697996f, 
    0.30269846f, -0.07382576f, -0.58850908f, 0.15516940f, -0.16062951f, -0.00024788f, -0.01220595f, 0.03852365f, 
    0.06618591f, -0.04148619f, -0.16974385f, 0.01271640f, -0.05420493f, -0.07993697f, 0.04984406f, -0.27652460f, 
    -0.00733820f, -0.19001833f, -0.11513120f, 0.25121692f, -0.04447396f, 0.24328309f, 0.17212170f, -0.29310966f, 
    0.01937369f, -0.62629747f, 0.02749478f, 0.11498930f, -0.15813474f, 0.01869025f, -0.12838109f, -0.03742729f, 
    -0.16474600f, 0.03317761f, 0.29759628f, -0.19883999f, 0.03319400f, 0.07081329f, 0.00194016f, -0.17891544f, 
    -0.34994078f, 0.09852470f, -0.07594246f, 0.02758170f, -0.49947110f, 0.09716277f, 0.18551780f, 0.11391518f, 
    0.04010908f, -0.14884755f, 0.21465196f, -0.40671313f, 0.56858051f, 0.02027429f, 0.06981611f, 0.03442218f, 
    0.21239625f, -0.11217204f, 0.03543357f, 0.00844023f, 0.04806516f, -0.07325932f, -0.00825749f, -0.32554331f, 
    0.04882931f, -0.04416282f, 0.05342182f, -0.46895340f, 0.01661782f, -0.05766360f, -0.39989886f, -0.06061602f, 
    -0.02821650f, 0.38654843f, 0.06042708f, -0.19628491f, 0.26010895f, -0.05359006f, 0.05554247f, -0.10883565f, 
    -0.05329333f, 0.06665528f, -0.02228655f, 0.06442962f, -0.11730295f, -0.21455015f, -0.07284501f, -0.29443812f, 
    -0.29345161f, 0.00844579f, 0.04533174f, 0.12804976f, 0.04515355f, 0.11403255f, -0.05131197f, 0.10137534f, 
    -0.34695655f, -0.33206570f, -0.22724965f, -0.08454037f, -0.07051998f, 0.05671522f, -0.30851421f, -0.41538700f, 
    -0.41352278f, 0.05620046f, -0.07484759f, 0.00906111f, 0.00954570f, 0.00746654f, 0.06106431f, -0.15321533f, 
    -0.25205949f, -0.09169548f, -0.00149049f, 0.21853837f, 0.19324969f, -0.07366000f, -0.01789523f, 0.03426453f, 
    -0.08551656f, -0.05185332f, -0.13916238f, -0.04297872f, 0.00746402f, 0.06449959f, 0.18484259f, -0.17069174f, 
    -0.38877413f, -0.48230892f, 0.28927657f, -0.02400152f, -0.50131452f, -0.18984607f, 0.08424186f, 0.07346714f, 
    0.17396235f, 0.05214623f, 0.05758730f, -0.37486207f, -0.03790104f, -0.02823062f, -0.03131183f, 0.16763696f, 
    0.00102674f, -0.22142658f, -0.33159003f, -0.11096644f, -0.05337174f, 0.19731987f, 0.04883173f, 0.08042439f, 
    -0.01817024f, -0.06056365f, 0.21408342f, 0.19812965f, 0.01613048f, -0.00135931f, 0.22384766f, -0.07401571f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.02131667f, -0.02810149f, -0.14581603f, -0.19507198f, 0.10923491f, 0.06414092f, 0.02068969f, -0.17729418f, 
    -0.05263352f, 0.04955127f, 0.18117183f, 0.11813041f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
