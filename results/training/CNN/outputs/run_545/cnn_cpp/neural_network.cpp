#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.58180243f, -0.71530652f, -0.24171831f, -0.17879882f, 1.00145626f, -1.45641923f, -0.20287581f, -0.22517525f, 
    -0.01513662f, 1.46557641f, -0.90823174f, -0.58512348f, -0.47146538f, -1.16946673f, -0.74829692f, -0.51683092f, 
    -0.27886569f, 0.04487668f, 0.35883057f, 0.66103321f, 0.06428892f, -0.21755101f, -0.09531347f, -0.77995098f, 
    0.86356634f, 0.32550558f, 0.91098738f, 0.25062940f, 1.41469646f, -0.88341546f, -0.19082980f, -1.17434633f, 
    -0.70221591f, -0.18634853f, -0.10209698f, -0.12710638f, -0.57173699f, -0.84752047f, 1.35434544f, 1.29452384f, 
    0.21179670f, -0.65836757f, 0.35715961f, -0.09097273f, 0.45048633f, 0.20223567f, -1.09195125f, -0.49658287f, 
    -1.40678942f, -0.32172683f, -0.13895482f, 0.23994058f, 0.40262517f, 0.54845071f, 0.97816116f, -0.21948603f, 
    1.13449216f, 1.03257751f, 0.24690083f, 0.04538628f, 0.05909661f, -0.16713518f, -0.34381691f, -1.15066147f, 
    -1.19398940f, -1.14806461f, -0.03835902f, 1.10301733f, 0.40825683f, -0.46611235f, 0.04173600f, -0.40255558f, 
    -0.26955622f, -1.12630415f, -0.50248438f, -1.41252017f, 0.64974517f, 1.01017785f, 0.30342156f, 0.84467405f, 
    -0.04880317f, 0.92561322f, 0.76852810f, 0.19226696f, 0.07083772f, 0.03565362f, 0.46500811f, -0.72692817f, 
    0.00616649f, -1.00828886f, 0.84394318f, -1.42221451f, -0.42381781f, 1.46839929f, 0.42814523f, 0.39540249f, 
    0.16224046f, 0.25672844f, -0.30780751f, 1.44921613f, 1.09313989f, 0.73804462f, -0.44274515f, 0.68943447f, 
    -0.22046155f, -0.65999913f, 0.22574535f, 0.68422329f, -0.95739156f, -1.34901798f, -1.08901489f, -0.08317476f, 
    -0.78275549f, -0.43246302f, -0.23935470f, 0.18984045f, -0.45524082f, -1.19862950f, -0.01997940f, 0.71455950f, 
    1.14271855f, 1.19439912f, 0.76900262f, -0.23244724f, -0.20754717f, -0.31997222f, 1.00397277f, 0.82979017f, 
    0.77267575f, 1.29923189f, 0.70365667f, -0.08070627f, 0.27156565f, 0.76973355f, 0.05454295f, 1.40608144f, 
    0.91618365f, 0.77678061f, -0.79882014f, -1.68177998f, 0.26347810f, 0.28980884f, 0.08871405f, 0.03127081f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14848582f, 0.63558269f, 0.18923916f, 0.37111607f, -0.48899356f, 0.45014122f, 0.06079397f, 0.09948657f, 
    0.15370849f, 0.51180965f, 0.43180227f, 0.59699088f, -0.21906136f, -0.00567038f, 0.08561819f, 0.54238307f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.16977318f, 0.42567056f, -0.06019603f, -0.08954029f, -0.11421783f, -0.03992352f, -0.30017060f, 0.10284038f, 
    -0.27478686f, 0.41005942f, -0.44246432f, 0.20031406f, -0.12291444f, -0.02105022f, -0.12273099f, 0.15064585f, 
    -0.05868469f, 0.24478072f, 0.09614015f, 0.24038760f, 0.00788432f, -0.10451392f, -0.12774138f, 0.00119159f, 
    -0.14109690f, -0.10076150f, -0.04867512f, 0.28455141f, 0.01224464f, 0.12076745f, -0.15213156f, -0.13377087f, 
    0.08697592f, -0.10120297f, 0.07228798f, 0.21554232f, 0.00293129f, 0.01316309f, 0.04534748f, 0.15565316f, 
    -0.01705387f, -0.36930570f, -0.13169810f, 0.04772498f, 0.08427134f, -0.10746939f, -0.06196811f, -0.00179334f, 
    0.24034207f, -0.00600923f, 0.15041339f, -0.05632166f, 0.15927574f, -0.25954324f, 0.04876625f, -0.14161789f, 
    -0.16250941f, -0.10029232f, -0.16189496f, -0.10960198f, 0.11260792f, -0.01356415f, 0.23639497f, -0.21599485f, 
    0.43927550f, -0.02314970f, 0.05209117f, -0.02910958f, 0.08003207f, 0.12756254f, 0.01809163f, 0.13037302f, 
    -0.39663973f, 0.41701248f, -0.45777303f, 0.13353877f, 0.06733488f, -0.12824509f, 0.19712734f, -0.11199369f, 
    0.32609084f, 0.00277411f, 0.03074918f, -0.14008734f, -0.32039961f, 0.03054951f, 0.04063997f, 0.02433947f, 
    0.10020681f, 0.00747247f, 0.16917308f, 0.07775529f, -0.34661162f, -0.12595859f, 0.11792692f, 0.10667223f, 
    0.07052918f, -0.18459086f, 0.19121997f, -0.23423776f, -0.07878266f, 0.10945759f, -0.14591409f, -0.05810140f, 
    -0.13395073f, -0.14743233f, -0.10216755f, -0.11843346f, -0.54753411f, -0.04246596f, 0.15192066f, -0.00628003f, 
    0.08424540f, -0.28599253f, 0.05673437f, 0.06076188f, 0.05499211f, 0.43875378f, 0.36022818f, 0.34243375f, 
    0.09338526f, -0.09832188f, 0.05886838f, -0.03861694f, -0.05962102f, 0.08401997f, -0.04468061f, -0.19156681f, 
    0.50335306f, -0.03868588f, -0.00824842f, 0.08500390f, 0.16930163f, -0.09778132f, 0.09143028f, 0.19057511f, 
    -0.16712101f, -0.08809385f, -0.24575467f, -0.02976258f, -0.03488104f, -0.11366704f, 0.00471690f, 0.11341202f, 
    -0.28298441f, -0.17374903f, 0.48911938f, 0.28527188f, 0.06993462f, 0.23843871f, -0.08192089f, -0.15385556f, 
    -0.06072653f, 0.77069342f, 0.04905452f, -0.26837394f, -0.25729942f, 0.18083037f, -0.09610127f, -0.08252306f, 
    0.02476284f, -0.14380403f, -0.46876416f, 0.07566337f, 0.15070426f, -0.13177523f, -0.08811844f, -0.42793810f, 
    -0.35822368f, -0.13974790f, 0.28015250f, -0.03588066f, 0.52063191f, -0.01358502f, -0.01979215f, -0.05902157f, 
    -0.14621924f, 0.08928528f, 0.04856614f, -0.03504987f, 0.00011677f, -0.07784180f, -0.55683249f, -0.02883353f, 
    -0.05437404f, -0.03462151f, -0.31076232f, 0.24932371f, -0.21810445f, 0.44218507f, -0.15241149f, -0.05236222f, 
    -0.18757661f, -0.10043340f, -0.13174395f, -0.05898094f, -0.06577692f, 0.04861255f, 0.17544504f, -0.23375069f, 
    -0.37945962f, 0.14665046f, -0.00394657f, 0.30703169f, -0.13673177f, 0.01888246f, -0.03928540f, 0.17764759f, 
    -0.10175306f, 0.80277979f, 0.10296173f, 0.23645164f, 0.02622996f, -0.25543401f, 0.16405931f, 0.48494509f, 
    0.31831968f, -0.20898508f, 0.08878462f, -0.16340652f, -0.07138070f, -0.01000072f, 0.08907262f, 0.06508373f, 
    -0.01888469f, 0.07422011f, 0.14918578f, 0.15984876f, -0.12890896f, -0.10342246f, 0.08208765f, -0.08205827f, 
    0.13368244f, -0.11080933f, 0.13130468f, -0.00811760f, 0.06426837f, -0.05442977f, 0.12712893f, -0.32355180f, 
    -0.24875516f, 0.04188849f, -0.18545267f, 0.14473905f, 0.36152849f, -0.10304990f, -0.02411842f, -0.00675649f, 
    0.06809930f, 0.12902683f, -0.11578966f, -0.10750122f, -0.00741099f, -0.08167999f, 0.49613777f, 0.24745996f, 
    0.01062335f, 0.24399185f, -0.10433741f, -0.27779856f, 0.08346031f, -0.13958101f, 0.11498525f, 0.12047405f, 
    0.26211879f, 0.21023348f, 0.10995205f, -0.03525442f, -0.06712078f, -0.16122644f, -0.37703371f, 0.45906857f, 
    -0.31749967f, -0.06125057f, 0.19420186f, 0.19708531f, 0.11127027f, 0.28896293f, 0.04787650f, -0.52007741f, 
    0.14392176f, -0.45409954f, -0.03468955f, -0.07763694f, 0.10942592f, -0.17931743f, 0.05327499f, -0.08589074f, 
    -0.42078620f, 0.07790729f, -0.15099749f, 0.04242922f, 0.11761480f, 0.30980808f, 0.12176408f, 0.06627274f, 
    -0.16195983f, -0.10977002f, -0.09413181f, -0.37125945f, -0.13753320f, 0.10891724f, 0.18645991f, -0.09111868f, 
    -0.02130701f, -0.09898867f, 0.00025053f, 0.24099924f, 0.31328705f, -0.36369479f, 0.03042370f, 0.07619398f, 
    0.03586357f, -0.09056758f, 0.34136349f, -0.05138856f, -0.17581210f, 0.02508555f, 0.09954283f, -0.08517032f, 
    0.12963925f, -0.23959239f, -0.01107910f, -0.06763417f, -0.00922791f, -0.27061507f, -0.32924473f, -0.31225541f, 
    -0.08152344f, -0.18796030f, 0.05049222f, 0.03050728f, -0.05110631f, -0.22504823f, -0.19090161f, 0.00755031f, 
    -0.18884435f, 0.10503063f, 0.19007272f, 0.31989732f, -0.11192647f, 0.10741301f, -0.05829016f, 0.01997325f, 
    -0.09949959f, 0.14184020f, 0.19468266f, -0.07466661f, 0.21287990f, 0.07113722f, 0.04465088f, -0.25905201f, 
    0.19167608f, 0.01383767f, 0.26290315f, 0.23874812f, 0.03613192f, -0.10385285f, -0.14144036f, -0.12877497f, 
    -0.50852072f, -0.10995594f, 0.15656227f, 0.08208559f, 0.13704973f, -0.06928216f, -0.00041530f, 0.13455942f, 
    -0.28639477f, 0.20624900f, 0.14998718f, 0.21685413f, 0.14307451f, -0.07571874f, -0.09086212f, 0.27598476f, 
    0.23251982f, 0.06305095f, -0.54938024f, -0.12587209f, -0.06367362f, -0.36049357f, -0.04685424f, -0.15220205f, 
    0.18006036f, 0.23805775f, -0.07296591f, -0.02556607f, 0.06956107f, 0.18034129f, -0.04856991f, 0.27099276f, 
    0.18467224f, 0.01377666f, 0.12499766f, 0.22272952f, -0.39208293f, 0.30575758f, 0.37996000f, 0.43709162f, 
    -0.17898457f, 0.23875907f, 0.07299154f, 0.21387641f, -0.26744372f, 0.31638083f, 0.07554065f, -0.26218724f, 
    -0.14152594f, -0.23706932f, -0.17988341f, 0.17486054f, 0.01568954f, 0.09804443f, -0.21502149f, 0.05425420f, 
    0.30781195f, 0.23317716f, -0.19136415f, -0.03061640f, -0.08459182f, 0.16147251f, 0.00800261f, -0.32998261f, 
    -0.03625609f, 0.36834270f, 0.06973692f, 0.05310955f, 0.16690794f, -0.05991810f, -0.00317597f, 0.20145075f, 
    -0.15091808f, -0.39311194f, -0.03829734f, 0.10791402f, -0.14965564f, 0.03226112f, -0.03944832f, -0.09822170f, 
    -0.04170894f, -0.08927681f, 0.35757300f, 0.11576234f, -0.32268783f, -0.22160199f, 0.02222942f, 0.08172706f, 
    0.21372624f, -0.02571579f, 0.27841911f, 0.17789160f, -0.61660761f, 0.11351608f, 0.08509509f, -0.01381513f, 
    -0.00547614f, -0.14149286f, -0.01009982f, 0.07352721f, -0.28779051f, -0.41853037f, 0.00085740f, -0.25854707f, 
    -0.37220365f, -0.03405300f, 0.20811956f, 0.26778284f, 0.30058828f, -0.39382592f, -0.40307620f, -0.08456088f, 
    -0.21666709f, 0.06536777f, 0.22938311f, -0.25512967f, 0.16027139f, 0.20775285f, -0.03009060f, -0.06926992f, 
    0.05891260f, -0.05584437f, -0.06670545f, 0.11602699f, -0.15520221f, 0.04833251f, 0.47445950f, 0.35605574f, 
    -0.02756254f, 0.19702478f, 0.25497916f, -0.03468509f, -0.26622289f, -0.08104692f, -0.16229726f, -0.49339625f, 
    -0.23177904f, 0.52181447f, 0.06771719f, -0.12688129f, 0.04493917f, -0.18557322f, 0.00420925f, 0.17602789f, 
    -0.18074133f, 0.42378625f, 0.15423462f, 0.05757122f, 0.07638315f, -0.02988251f, -0.03535127f, -0.01383744f, 
    -0.09619265f, 0.13508987f, 0.20479508f, 0.04731944f, 0.29534590f, 0.06595281f, 0.08568681f, 0.00060177f, 
    0.24186863f, -0.28002834f, -0.03927405f, 0.37037954f, 0.44471210f, -0.06022158f, -0.21627000f, 0.09028710f, 
    0.10724842f, 0.00144205f, 0.17712530f, -0.02685905f, -0.26807010f, -0.01700210f, 0.27095345f, -0.04595631f, 
    0.06931844f, 0.10871296f, -0.32800868f, 0.05192614f, 0.16737974f, -0.15330277f, 0.42364392f, 0.15795007f, 
    0.07517979f, -0.35271096f, 0.04192770f, 0.16637503f, -0.22294217f, 0.20750698f, 0.05474369f, 0.02814489f, 
    -0.28640074f, -0.12083632f, 0.23753296f, -0.18329941f, 0.12253878f, 0.04261052f, 0.31847125f, -0.40880170f, 
    -0.19161026f, 0.17689185f, 0.19524769f, -0.10876578f, -0.02508156f, 0.26392695f, 0.00776440f, -0.40489122f, 
    0.10241506f, -0.10037496f, 0.25007308f, 0.10562676f, -0.14809969f, 0.19828628f, 0.08632258f, -0.21043019f, 
    -0.20880963f, -0.20610529f, -0.25456208f, 0.15168786f, -0.26701993f, 0.06242149f, 0.21431993f, 0.22416455f, 
    0.03669062f, 0.12784660f, -0.00903012f, 0.49843809f, 0.16141745f, 0.01714187f, 0.06401390f, -0.01025502f, 
    -0.06609377f, -0.07063264f, 0.04838199f, 0.09596269f, -0.26289091f, -0.00006655f, -0.00653215f, 0.11903317f, 
    -0.16833203f, -0.01370575f, 0.42913249f, 0.15266891f, -0.26024306f, -0.22880493f, 0.34017333f, 0.21950953f, 
    0.05318396f, -0.14635898f, 0.05039861f, -0.11573502f, -0.51377839f, -0.03437475f, -0.14545220f, -0.24324447f, 
    -0.35801989f, -0.09258474f, -0.03755146f, -0.12708566f, 0.25881717f, -0.03692020f, 0.10386395f, 0.07303565f, 
    -0.09589601f, 0.04281340f, -0.03460282f, -0.05742599f, 0.21765788f, 0.37811434f, -0.46963421f, -0.28687096f, 
    -0.05225056f, -0.01606876f, 0.14030950f, 0.08796600f, 0.13870943f, 0.19028008f, -0.03181512f, 0.45107615f, 
    0.04737589f, 0.17483440f, -0.34979615f, 0.01856473f, -0.03824624f, -0.12859622f, 0.33374617f, -0.11337616f, 
    -0.13418448f, -0.01929207f, -0.03535093f, -0.02010317f, -0.00011590f, -0.39041263f, 0.14827520f, 0.19550994f, 
    0.08687628f, -0.52262229f, -0.59136838f, 0.29834428f, 0.11301339f, -0.02732800f, 0.24024011f, -0.04939340f, 
    -0.19553083f, -0.18553336f, 0.22461401f, 0.40508637f, 0.21958490f, 0.16658351f, -0.09386043f, -0.25109866f, 
    0.09814973f, 0.18289341f, 0.22351335f, -0.80351835f, -0.67947161f, 0.17564681f, 0.26802927f, 0.08233634f, 
    0.22581734f, 0.01147213f, -0.02130969f, 0.01154116f, -0.18250377f, -0.14912727f, 0.17753164f, -0.15836686f, 
    -0.21713677f, 0.26058978f, -0.04596978f, -0.05345719f, -0.09310378f, 0.03451277f, 0.11537510f, -0.14369246f, 
    -0.13195840f, 0.17129122f, 0.09134600f, 0.27907655f, -0.10716481f, 0.02884016f, -0.39162421f, -0.27693307f, 
    -0.18772291f, -0.13179198f, 0.21061252f, 0.13897072f, 0.18224175f, -0.02603013f, 0.04629118f, -0.22189374f, 
    0.18280658f, -0.16267569f, 0.27512190f, 0.12633267f, -0.00102520f, -0.03408827f, -0.24612625f, -0.07959756f, 
    -0.30968472f, 0.01203364f, 0.37285987f, -0.10103466f, 0.00257326f, 0.05044119f, -0.13904728f, 0.13733102f, 
    -0.08734296f, 0.39457443f, 0.45760331f, -0.20606185f, -0.17989613f, -0.10781897f, -0.12894061f, 0.25394318f, 
    0.03265823f, 0.08040097f, 0.17855708f, -0.04429790f, 0.24743925f, 0.24940038f, 0.14776018f, 0.07364541f, 
    -0.11661553f, 0.11949618f, -0.13521576f, 0.91320693f, 0.14861713f, 0.23734485f, 0.20155483f, -0.08024025f, 
    -0.05509435f, 0.00889750f, -0.07172685f, 0.14208096f, -0.19581993f, -0.29697680f, -0.08354457f, -0.02035305f, 
    -0.04135865f, 0.03170384f, 0.06983569f, -0.10273534f, -0.03088385f, -0.36455297f, 0.17655191f, -0.26494411f, 
    0.02494840f, 0.01365786f, -0.08266484f, 0.14202675f, 0.19485871f, -0.04044783f, -1.12971842f, -0.42776811f, 
    -0.36882630f, 0.29742262f, -0.00969974f, 0.22025886f, 0.07306023f, 0.12230106f, -0.09267189f, -0.12778646f, 
    0.39469892f, 0.29878584f, -0.20124649f, -0.22230022f, -0.11998401f, -0.07679603f, 0.12654717f, 0.22838533f, 
    -0.57458758f, 0.25304085f, -0.25049305f, -0.10541680f, -0.24602433f, -0.04466198f, 0.13882609f, -0.04658916f, 
    -0.13482724f, 0.10843139f, -0.49027872f, 0.05108808f, 0.37115952f, 0.26849210f, 0.04750568f, 0.19739912f, 
    -0.09032276f, 0.03568343f, -0.27027357f, -0.04681030f, -0.20767947f, 0.03845387f, 0.10573886f, 0.04122072f, 
    -0.18764600f, 0.19802362f, -0.00796879f, 0.18192656f, -0.11251210f, 0.25739521f, 0.08127632f, 0.01072372f, 
    0.21743385f, -0.01302098f, -0.02070733f, 0.12960212f, 0.07519960f, -0.05527570f, -0.40168175f, -0.24162161f, 
    0.09227346f, 0.08132469f, -0.21648940f, -0.05180968f, 0.15499599f, -0.63077849f, 0.32493061f, 0.06478762f, 
    -0.02790004f, 0.07115076f, 0.29830915f, -0.45381019f, 0.29596916f, 0.09232076f, -0.06229610f, -0.37955430f, 
    -0.15712212f, -0.02576929f, -0.00725045f, 0.09833343f, 0.20675327f, 0.19477451f, 0.05500212f, 0.46288794f, 
    -0.55464441f, -0.10638432f, 0.06788854f, 0.06049540f, 0.17020059f, 0.07128668f, 0.04332980f, 0.02139418f, 
    -0.04305809f, -0.26758796f, -0.39012679f, -0.21353929f, -0.00966927f, 0.18001606f, -0.06906377f, -0.01315726f, 
    -0.05351489f, 0.13870582f, -0.01442016f, 0.21671474f, -0.13248490f, 0.21738435f, 0.05046066f, -0.02641784f, 
    0.00556163f, 0.01686220f, 0.08555520f, -0.38692933f, -0.03805420f, 0.18810774f, 0.27868587f, 0.13463937f, 
    -0.07594536f, 0.19116072f, 0.22437824f, 0.20873518f, -0.20205213f, -0.16198771f, 0.15674315f, 0.03835403f, 
    -0.05449631f, 0.13091694f, -0.30562514f, 0.06521681f, -0.94085968f, -0.13600674f, 0.22386491f, -0.41726595f, 
    0.12371287f, -0.09838946f, 0.01709237f, -0.17439066f, 0.14695476f, -0.11842825f, -0.39792389f, -0.16610922f, 
    0.17083746f, 0.10002424f, 0.04828908f, -0.06118452f, -0.07093816f, 0.17681131f, 0.21099992f, -0.16236375f, 
    -0.05380390f, 0.16776501f, 0.02685163f, -0.11718832f, 0.10086891f, 0.23057938f, -0.09559181f, 0.55800951f, 
    0.36124173f, -0.25401211f, 0.09351207f, 0.04034287f, 0.01426940f, -0.12048891f, 0.10992301f, -0.14934447f, 
    -0.17847028f, 0.42097226f, -0.29449499f, -0.06980043f, -0.02162581f, -0.18894175f, 0.26115394f, -0.15675595f, 
    0.07726707f, 0.21853708f, 0.14424112f, -0.26616585f, 0.22488047f, -0.18227941f, -0.03496687f, -0.13331136f, 
    0.03400915f, -0.18442596f, 0.36704302f, -0.67621845f, -0.21354862f, -0.02754744f, 0.01933081f, -0.02568224f, 
    0.15662335f, -0.13088495f, -0.07040218f, 0.45627984f, 0.28428924f, -0.12806039f, 0.04576119f, -0.04629994f, 
    -0.01355208f, -0.09951396f, -0.07759294f, 0.30840319f, 0.10797469f, 0.30975601f, 0.09365062f, -0.26224065f, 
    0.13643342f, -0.03255100f, -0.02808313f, 0.12094235f, -0.11780443f, -0.23887630f, 0.43825725f, 0.13410059f, 
    0.02966896f, -0.03784671f, -0.17775886f, -0.09929086f, 0.09729578f, -0.14477952f, 0.04960046f, 0.02659350f, 
    0.47246474f, -0.04316567f, 0.03193327f, -0.09354915f, 0.11470256f, 0.09753223f, 0.09779663f, 0.21770506f, 
    0.14059189f, -0.06890951f, 0.12468899f, -0.27095869f, 0.08397715f, -0.03392161f, 0.07900282f, 0.11235337f, 
    -0.08337284f, -0.28238630f, -0.01264158f, 0.03153941f, 0.09037569f, -0.02187110f, 0.05251140f, 0.16821176f, 
    -0.05999316f, -0.10389964f, 0.02827069f, -0.41808546f, -0.02364747f, 0.00174529f, 0.14001150f, -0.02578234f, 
    -0.03614828f, -0.16958290f, 0.07834122f, 0.12533665f, 0.00369772f, 0.04300444f, -0.00928136f, 0.00763902f, 
    0.25653973f, -0.21589923f, 0.28750741f, 0.12221364f, -0.56484032f, -0.05632424f, 0.04566512f, 0.12068656f, 
    0.10942069f, -0.36348319f, -0.03759879f, -0.09127624f, 0.32980332f, -0.00469184f, -0.03387303f, 0.02748113f, 
    -0.43770757f, 0.25899416f, 0.04078302f, -0.09207955f, 0.40006247f, 0.21509968f, -0.07887807f, 0.00128220f, 
    0.27317077f, 0.09200065f, 0.18733075f, 0.05597737f, 0.11512388f, -0.26704037f, -0.07328356f, 0.10758243f, 
    -0.17510930f, -0.11885645f, 0.09276557f, 0.20875587f, -0.01786433f, 0.04406337f, -0.06201989f, -0.16798884f, 
    -0.13454399f, -0.30998752f, -0.31194404f, 0.14018129f, -0.48917985f, -0.13655160f, -0.02803786f, -0.09405072f, 
    0.22127585f, -0.25118008f, 0.04772973f, -0.14576709f, 0.11256890f, -0.02569446f, -0.01259980f, 0.05949791f, 
    0.11333812f, -0.24161413f, 0.10627173f, 0.24926484f, 0.22290882f, -0.10440172f, -0.00141041f, -0.14432850f, 
    0.23916608f, -0.06448711f, 0.40120873f, 0.05439120f, 0.13673528f, 0.17158331f, -0.19472365f, 0.05664783f, 
    -0.02946643f, 0.00278973f, -0.00569577f, 0.01406262f, 0.30134383f, 0.06929655f, -0.11054607f, -0.06959891f, 
    0.10527583f, 0.01687171f, -0.03543739f, 0.00595462f, -0.13840799f, 0.26561907f, -0.44640842f, -0.08237983f, 
    0.09907272f, 0.05928473f, -0.02311642f, 0.03309614f, 0.15788126f, 0.00184623f, -0.50662911f, -0.31950277f, 
    0.30154365f, -0.01550394f, 0.00968319f, -0.25950602f, 0.00794289f, -0.06837611f, 0.01818517f, 0.43539855f, 
    -0.09576779f, 0.08110797f, -0.06579344f, 0.09857896f, -0.10761575f, 0.23956032f, 0.03207928f, 0.28751600f, 
    0.36459252f, 0.04152037f, -0.09267908f, 0.15984286f, 0.14067563f, -0.22219145f, -0.05072951f, 0.16235425f, 
    -0.20241420f, -0.60899842f, 0.11379509f, -0.05335454f, -0.16426712f, 0.04230167f, 0.01729928f, 0.11888749f, 
    -0.06636517f, -0.37285542f, 0.08905148f, 0.26050302f, 0.25199443f, 0.12620629f, 0.13922857f, -0.00417482f, 
    -0.00762237f, -0.09982983f, -0.12353272f, 0.61960900f, -0.26223963f, -0.37720188f, 0.13083768f, 0.07928907f, 
    -0.07366219f, -0.03700257f, 0.13174994f, 0.05886578f, 0.05424312f, -0.30490813f, -0.04177985f, 0.09839382f, 
    0.20218475f, -0.14283676f, -0.14513350f, 0.10189731f, -0.41702002f, -0.23830029f, -0.01177971f, -0.13939309f, 
    -0.11832193f, -0.14338616f, -0.14226337f, 0.18723454f, -0.01340890f, -0.48314387f, -0.24718483f, 0.28723583f, 
    0.09399676f, 0.01286289f, 0.06200315f, -0.04879381f, 0.11028556f, 0.11107113f, -0.22740248f, 0.10707549f, 
    -0.07577496f, -0.37042770f, 0.15094104f, 0.03251655f, 0.12286898f, -0.02660235f, 0.12423275f, -0.07945924f, 
    0.07407175f, -0.05334721f, -0.00057888f, -0.15886109f, -0.20371807f, -0.00167844f, -0.05677334f, -0.09640346f, 
    -0.33864447f, -0.27939963f, -0.20179474f, 0.06273879f, -0.09088090f, -0.03107110f, -0.07870860f, -0.03792907f, 
    -0.14724556f, 0.38391399f, -0.17697981f, 0.39077654f, -0.14967738f, -0.17402247f, -0.24199694f, 0.11566386f, 
    0.08606319f, -0.02221737f, 0.84568495f, 0.00554142f, -0.19636717f, 0.10034610f, 0.24336962f, -0.03485970f, 
    0.01717067f, 0.05046113f, 0.05599448f, -0.07036275f, -0.29241297f, -0.08636012f, 0.06473930f, 0.06113393f, 
    0.07048100f, 0.09412321f, 0.08155864f, 0.21222612f, -0.57995349f, -0.09593069f, 0.32643655f, 0.06419481f, 
    -0.26863986f, -0.11227991f, 0.24687649f, 0.37020424f, 0.09054393f, 0.19526830f, 0.36444938f, 0.02804035f, 
    -0.03648164f, -0.19371936f, -0.24832715f, 0.14774960f, -0.09235316f, 0.02905819f, -0.04946855f, 0.48534936f, 
    -0.24060214f, -0.07522381f, -0.20782539f, 0.09806567f, 0.13480179f, 0.17600213f, 0.21382892f, -0.10177883f, 
    0.23009622f, -0.06997878f, -0.09529036f, 0.16997205f, 0.05387897f, 0.08573577f, 0.32926160f, 0.09704871f, 
    -0.05074575f, -0.02387464f, -0.06719565f, -0.02387195f, -0.04092285f, 0.05504609f, -0.01309950f, -0.01029118f, 
    -0.01792737f, 0.03859636f, 0.04333443f, 0.08225972f, -0.03073053f, -0.08593670f, 0.08157744f, -0.00952210f, 
    -0.01622602f, 0.05429914f, -0.07439891f, -0.07630259f, -0.03968180f, 0.03953020f, -0.07640186f, -0.06975779f, 
    0.04500383f, 0.04396227f, 0.07398181f, -0.06485665f, -0.02686713f, -0.05270728f, 0.08093458f, 0.07103226f, 
    -0.07770270f, -0.06747199f, 0.04266078f, -0.05746333f, -0.05546198f, -0.01116251f, 0.02703015f, -0.04199265f, 
    -0.00879611f, 0.06194871f, 0.01064421f, 0.02239493f, -0.04631653f, 0.05641743f, 0.06793668f, -0.02189119f, 
    -0.07814877f, 0.02268967f, -0.01149451f, -0.01150184f, -0.06104220f, -0.05086076f, -0.05436444f, -0.04785972f, 
    0.00252465f, -0.03226277f, 0.04240175f, 0.00460070f, -0.07607473f, -0.06073615f, -0.03219248f, -0.01298155f, 
    -0.05354590f, -0.03983325f, 0.03907446f, -0.07806190f, -0.05136704f, 0.03132138f, 0.02856083f, -0.06098660f, 
    -0.08284784f, 0.01570779f, -0.06476600f, 0.02170471f, -0.02886199f, 0.05003801f, -0.08613349f, 0.04259014f, 
    -0.00757441f, -0.07747946f, -0.01896020f, 0.02709395f, 0.03040894f, -0.03475629f, 0.04315775f, -0.08167236f, 
    -0.02417273f, -0.05201469f, 0.04340095f, -0.00578707f, 0.04199213f, -0.07385209f, 0.04351252f, -0.02354522f, 
    -0.08321336f, -0.05781338f, -0.00697681f, -0.06217714f, -0.01715127f, -0.02300109f, 0.00399797f, -0.04239397f, 
    -0.00131310f, 0.02566545f, -0.03929607f, 0.07388057f, -0.03311455f, -0.06633538f, -0.08282723f, 0.03404011f, 
    0.03706900f, 0.02509238f, -0.07062173f, -0.06669093f, -0.03088362f, -0.00180577f, -0.08182039f, -0.07229854f, 
    0.08195185f, -0.01979062f, -0.06217805f, -0.06031344f, 0.02255877f, 0.00723863f, -0.01132779f, -0.07266281f, 
    -0.03620222f, 0.00534416f, -0.04523262f, 0.02422165f, -0.05917126f, 0.07604234f, 0.05564159f, 0.00565108f, 
    -0.06708211f, -0.03658907f, 0.04521806f, 0.07438819f, -0.05098702f, 0.02219689f, 0.06188941f, 0.06001594f, 
    -0.06983744f, 0.16620982f, 0.07429624f, -0.01962156f, 0.03009670f, 0.31251222f, -0.10799951f, 0.12716110f, 
    -0.26406682f, 0.01656854f, 0.24905539f, -0.13852361f, 0.05915770f, 0.28040633f, 0.15131654f, -0.13143192f, 
    -0.30504960f, -0.54909724f, 0.19491270f, -0.44013238f, 0.03564389f, 0.09477012f, 0.12826870f, 0.33689085f, 
    0.00654806f, 0.07180095f, -0.04124874f, 0.28866568f, -0.20963427f, -0.00109745f, 0.01337430f, -0.14448085f, 
    0.10428432f, -0.12159899f, -0.08040669f, -0.15962394f, -0.10561047f, -0.06623257f, -0.01725112f, 0.03050293f, 
    -0.10337187f, -0.23671946f, 0.16526619f, 0.34828788f, 0.01933457f, 0.34308493f, 0.25275230f, -0.15184566f, 
    -0.36832196f, -0.13697490f, 0.08218200f, -0.18084954f, 0.15253739f, -0.11183638f, -0.23536430f, -0.03400253f, 
    0.02461329f, 0.04817940f, -0.03181814f, -0.05168739f, 0.14524893f, 0.08188124f, 0.25440335f, 0.41526157f, 
    0.63275439f, 0.39380673f, 0.12655294f, -0.15001941f, -0.01685948f, -0.16381603f, -0.04938122f, -0.03369077f, 
    -0.10706397f, 0.22806466f, 0.05416569f, 0.18163091f, -0.14899652f, -0.28943497f, 0.17827567f, -0.13928260f, 
    0.10272504f, -0.12440964f, -0.15520102f, 0.01682033f, -0.11243279f, -0.03469709f, -0.19651785f, -0.18598898f, 
    -0.13826916f, -0.12127233f, 0.12595096f, 0.13490960f, -0.04664214f, 0.10170881f, 0.18005505f, -0.14542325f, 
    0.22831480f, 0.04872851f, 0.40538913f, -0.52302742f, -0.60802042f, 0.12301090f, -0.15163620f, 0.07990843f, 
    0.03201766f, -0.13767354f, -0.21660194f, -0.09462799f, 0.32074675f, 0.54060185f, 0.06780577f, 0.08899812f, 
    -0.10192276f, 0.02480492f, -0.13809679f, 0.14010511f, 0.13259824f, 0.15252574f, 0.07437597f, 0.03624830f, 
    0.07063395f, -0.03474043f, -0.26075250f, -0.06057259f, 0.25701076f, 0.04357881f, 0.00131509f, -0.06030317f, 
    -0.18742147f, -0.13212296f, -0.07620554f, 0.00070850f, 0.02247180f, 0.21152180f, 0.07863218f, -0.31101131f, 
    -0.39715222f, -0.16857569f, 0.03916387f, -0.16971333f, -0.02487908f, -0.12622295f, -0.16852784f, 0.17124002f, 
    -0.09296007f, 0.05883493f, -0.05476530f, -0.04995601f, -0.06260718f, -0.04308146f, -0.05076259f, -0.02798748f, 
    -0.00934938f, -0.00666724f, -0.08908598f, 0.05323034f, -0.02570128f, -0.05647169f, 0.01947322f, -0.06682763f, 
    -0.01288451f, 0.06044038f, -0.00834273f, -0.00653827f, -0.08611999f, -0.03786229f, 0.00576606f, -0.07345689f, 
    -0.06897867f, -0.00634054f, 0.04973181f, -0.04981456f, 0.05864837f, 0.05625015f, 0.00801791f, -0.03582966f, 
    0.04743484f, 0.02366947f, -0.07568743f, 0.06902745f, -0.05788272f, 0.01734971f, -0.07338520f, -0.02575910f, 
    0.00179352f, 0.01921151f, -0.03083435f, -0.00334083f, -0.01963078f, 0.06322964f, -0.09922966f, -0.08990357f, 
    -0.00441515f, -0.06984089f, 0.04555987f, 0.03747614f, -0.03485613f, 0.04238610f, 0.05668624f, -0.07863844f, 
    -0.08627136f, 0.04176719f, 0.04499212f, -0.07594685f, -0.08106210f, -0.05442975f, -0.08312324f, -0.04420023f, 
    -0.00967206f, 0.01078600f, 0.02366139f, -0.02040872f, 0.04930276f, -0.08085813f, -0.01174130f, 0.06873816f, 
    -0.04239069f, -0.02279093f, -0.03608691f, 0.03045626f, -0.08434697f, 0.02671801f, -0.07652290f, -0.06230053f, 
    0.02190698f, -0.03646883f, -0.09723739f, -0.00143681f, 0.01423749f, 0.06178879f, 0.02403856f, -0.03481311f, 
    -0.04677885f, 0.00609675f, 0.05915514f, 0.04831347f, -0.08577854f, 0.00047289f, 0.00164134f, 0.01341382f, 
    0.03208710f, -0.07792696f, 0.04549741f, 0.00138721f, 0.04581921f, 0.04871409f, 0.03564450f, 0.03280693f, 
    -0.08654413f, -0.00997256f, -0.08007065f, -0.09234729f, 0.03143233f, -0.07260132f, -0.04176792f, 0.01709385f, 
    -0.02040822f, 0.02977305f, 0.05894392f, -0.07972386f, -0.06328912f, -0.01075986f, 0.01778253f, 0.00827020f, 
    -0.05294367f, 0.01207492f, 0.01581537f, -0.06623925f, -0.00859974f, -0.03400878f, -0.06640086f, -0.00804317f, 
    0.01809855f, 0.00337512f, -0.05283815f, 0.00506713f, 0.06810574f, 0.06728088f, 0.06548871f, -0.01235725f, 
    -0.02494022f, 0.01608748f, -0.00140158f, -0.00281628f, 0.01368607f, -0.08429490f, -0.06506332f, -0.07625462f, 
    -0.03182445f, -0.03303664f, -0.01786218f, 0.03784029f, -0.03934223f, 0.03133097f, -0.07342479f, 0.05020859f, 
    0.04128334f, -0.05117606f, -0.06337615f, -0.06847378f, -0.05054926f, 0.04494801f, 0.02913530f, -0.03860185f, 
    0.00796207f, 0.00764507f, -0.03068687f, 0.00115647f, 0.02622323f, -0.01322821f, -0.06122898f, 0.01375978f, 
    -0.04722269f, 0.00357433f, -0.00346180f, 0.03394873f, 0.01099005f, -0.06051879f, 0.05107864f, -0.08456039f, 
    -0.03053323f, -0.00420978f, -0.00475284f, -0.05049665f, 0.05034401f, -0.03942688f, 0.06292000f, 0.04633410f, 
    -0.03232520f, 0.06006636f, -0.07830528f, -0.01146080f, 0.03734542f, -0.06982308f, -0.02953826f, -0.05875381f, 
    -0.04598739f, -0.02963666f, 0.05614727f, -0.04061817f, -0.03369234f, -0.09142056f, -0.06427901f, -0.10166077f, 
    0.01430344f, -0.00491856f, -0.03284541f, 0.05954450f, 0.04383131f, 0.07575690f, -0.01144544f, 0.06775980f, 
    0.02803990f, -0.07250450f, 0.03477124f, 0.03866486f, -0.03425081f, 0.01011375f, -0.01673776f, -0.08365168f, 
    0.06319865f, -0.04058520f, -0.03212216f, -0.02195093f, 0.00428381f, 0.00333321f, -0.03259973f, 0.04445256f, 
    0.06040150f, -0.01823758f, -0.01213730f, -0.04651247f, -0.09591182f, 0.05620641f, 0.07479974f, 0.03852112f, 
    0.00011958f, -0.00612198f, -0.06436405f, 0.02943412f, -0.00071661f, -0.02424543f, -0.08666165f, -0.08856607f, 
    0.03886272f, -0.07903633f, 0.03856261f, -0.07159287f, -0.05411222f, -0.08674338f, 0.00158505f, -0.01692464f, 
    -0.08429914f, 0.02343745f, 0.06239108f, -0.02744872f, -0.02087683f, -0.03826498f, 0.02854027f, 0.01306528f, 
    -0.09984787f, -0.03236100f, -0.02054203f, 0.02339106f, 0.01156054f, -0.02200711f, -0.09114408f, -0.04691432f, 
    0.06961448f, 0.06577630f, -0.01938532f, 0.03581989f, 0.04471743f, -0.09511128f, -0.04264103f, -0.05777124f, 
    0.01352460f, -0.03521480f, 0.06582128f, -0.05848556f, -0.05041028f, 0.07027357f, -0.09024625f, 0.00167343f, 
    -0.05559867f, 0.06169576f, -0.07608392f, 0.06451549f, -0.00769339f, -0.00589910f, -0.02661383f, 0.05778141f, 
    -0.26231641f, -0.26090556f, -0.41604054f, 0.09722232f, 0.04788938f, 0.13152525f, 0.11244802f, -0.10893431f, 
    0.12346641f, 0.01481049f, -0.13111551f, -0.25788182f, -0.02158505f, 0.20112607f, -0.10465226f, -0.18141010f, 
    0.13159560f, 0.20982845f, 0.07998947f, -0.03783571f, 0.02648490f, -0.36432666f, -0.23517103f, -0.09478443f, 
    -0.09846544f, 0.11545111f, -0.23277339f, 0.25220332f, 0.31334236f, 0.28866985f, -0.30938175f, -0.16939078f, 
    -0.19940317f, -0.37954187f, 0.17279032f, 0.22396749f, -0.71194369f, -0.31171411f, -0.21106090f, -0.20678847f, 
    -0.11749637f, -0.29556608f, 0.09741271f, -0.14271900f, -0.25673169f, -0.45034528f, -0.03821838f, -0.21166489f, 
    0.19274601f, 0.20261851f, 0.15695283f, 0.16935892f, -0.08210070f, -0.05099511f, 0.14927952f, 0.06682739f, 
    0.35244372f, 0.01600592f, 0.01165597f, 0.24376476f, 0.18617761f, 0.08862312f, -0.03494113f, 0.13733093f, 
    -0.54608142f, -0.75099647f, 0.34423602f, 0.28637910f, 0.42727986f, -0.15984662f, -0.06032785f, -0.30999681f, 
    -0.07157274f, -0.29077655f, -0.45014995f, 0.04462462f, 0.28243810f, 0.04356935f, 0.02412545f, -0.13554475f, 
    -0.26770097f, 0.15006486f, 0.26099536f, 0.26266962f, 0.33814839f, -0.19460836f, 0.09387507f, 0.18417694f, 
    0.19870687f, 0.07614663f, -0.01142492f, -0.38591510f, -0.40883678f, 0.11613187f, 0.16575167f, 0.24134202f, 
    0.02590112f, -0.06386300f, -0.20327547f, 0.16053452f, 0.41609558f, 0.08913503f, -0.12122186f, -0.06403960f, 
    0.06647702f, -0.05871725f, 0.07253183f, 0.28745669f, -0.37523425f, 0.19079058f, 0.01336760f, 0.07018951f, 
    0.10024127f, -0.01563892f, 0.28247240f, 0.10292698f, -0.02121460f, 0.31912029f, -0.06386599f, 0.28108391f, 
    0.35710371f, 0.07522264f, 0.16740137f, -0.12354029f, -0.21636428f, -0.12462542f, -0.16880958f, 0.22173961f, 
    0.36678496f, 0.32734320f, 0.26562771f, 0.11234371f, 0.12243313f, 0.13364048f, -0.15234832f, 0.27516133f, 
    0.31306374f, 0.50116181f, -0.34506553f, -0.34139794f, 0.16290545f, 0.23924737f, 0.25329614f, 0.25337788f, 
    0.12320003f, -0.01169337f, -0.27218509f, -0.17553759f, -0.07247119f, 0.05522076f, 0.17134863f, 0.00203406f, 
    0.17931446f, 0.04042107f, -0.20787127f, 0.07853170f, -0.00280240f, 0.16439153f, -0.05533081f, 0.04619636f, 
    0.04139362f, 0.14152259f, 0.08127466f, 0.08234076f, 0.06274837f, 0.34382546f, 0.09220542f, -0.19826384f, 
    -0.28092974f, 0.13414681f, 0.18705465f, -0.14104608f, 0.21755311f, 0.23218817f, 0.05126057f, 0.08619428f, 
    0.04451940f, 0.05186610f, 0.10069962f, -0.02999084f, 0.28809375f, -0.55516171f, -0.35272744f, -0.11274511f, 
    -0.14284246f, 0.14448355f, 0.06109868f, -0.07922895f, -0.19724083f, 0.27892083f, 0.09424709f, 0.23964456f, 
    -0.00354634f, -0.21248351f, 0.09934013f, 0.09513652f, 0.10373750f, -0.18107000f, -0.50166273f, 0.16257109f, 
    -0.18107007f, 0.32977486f, 0.02501839f, 0.16872358f, -0.09501902f, 0.09014018f, 0.12061577f, 0.29095948f, 
    -0.24406371f, -0.23283765f, -0.01258256f, -0.24394713f, 0.05847297f, 0.00982408f, 0.00340716f, 0.17828514f, 
    0.29831904f, 0.10162053f, -0.16844688f, -0.09682912f, -0.31523260f, -0.07402176f, -0.08155513f, 0.23494454f, 
    0.11744644f, -0.01615337f, 0.23539117f, 0.13503428f, 0.02035294f, -0.20419657f, -0.00928245f, -0.17321216f, 
    -0.08917858f, 0.08659555f, 0.30060327f, 0.07940928f, 0.17770644f, 0.13814352f, -0.12523870f, -0.25442508f, 
    -0.10985545f, 0.05831441f, 0.02769514f, -0.57557952f, 0.39970767f, 0.00309487f, 0.03671972f, 0.25741079f, 
    0.31491345f, 0.10955949f, -0.25064367f, -0.15031824f, -0.20265394f, -0.13555284f, 0.10036295f, -0.04315078f, 
    -0.03461127f, 0.10110751f, -0.05130888f, -0.45947710f, 0.07242798f, 0.57919067f, -0.56173968f, -0.12451204f, 
    -0.16273428f, -0.18949194f, 0.14361286f, 0.13173804f, -0.15247267f, -0.01373534f, -0.82233149f, -0.37687528f, 
    -0.07824566f, 0.13196591f, -0.03705817f, 0.27381364f, -0.02017784f, 0.14200106f, -0.05012758f, -0.59324980f, 
    0.72179759f, 0.20031489f, 0.06923003f, 0.23620491f, -0.19524476f, -0.06302980f, 0.19570513f, 0.02054983f, 
    0.00652289f, -0.34982076f, -0.55309343f, 0.18981664f, -0.01700054f, 0.16689856f, 0.02958172f, -0.09525178f, 
    0.06044311f, -0.60400039f, -0.19486791f, 0.08183100f, 0.09612795f, 0.35121518f, 0.03342929f, -0.07789300f, 
    0.16389705f, -0.24019708f, 0.26210058f, -0.05195238f, 0.07313287f, 0.19023593f, 0.19168806f, 0.11813352f, 
    0.15662152f, 0.09224973f, -0.13592389f, -0.06284799f, -0.74972135f, -0.43541268f, 0.09909490f, -0.01861604f, 
    0.04997940f, -0.10529853f, 0.10718856f, -0.10389820f, 0.35454512f, -0.41291040f, 0.20641173f, -0.35424015f, 
    0.19470160f, -0.30061510f, -0.07585211f, -0.14029460f, -0.12037081f, 0.68256515f, -0.09283341f, 0.00922142f, 
    0.05402157f, 0.06195790f, 0.14112923f, -0.14682841f, -0.02238567f, 0.03031522f, -0.53273433f, -0.04749970f, 
    0.07235654f, 0.08859804f, 0.15610662f, -0.04679433f, -0.14521743f, 0.15946460f, 0.15677376f, 0.21595925f, 
    0.24144137f, 0.19188549f, -0.14723697f, -0.09421293f, -0.02879452f, -0.01269922f, -0.01970350f, -0.01671093f, 
    0.58825523f, 0.11355919f, -0.02723071f, -0.08532052f, 0.04537618f, -0.14971660f, -0.13499252f, 0.10933014f, 
    0.09950714f, 0.17446305f, -0.02529921f, -0.17866510f, 0.16764587f, -0.19630693f, 0.02542515f, -0.25750309f, 
    0.17235491f, 0.32338533f, -0.02644347f, 0.12635393f, 0.23880848f, 0.02404662f, -0.20131242f, -0.01996886f, 
    0.14439049f, 0.10286213f, -0.16350116f, 0.14926022f, 0.15393890f, 0.02887910f, -0.14556243f, 0.05694038f, 
    0.23755674f, 0.01844024f, 0.05314510f, 0.02895444f, -0.94265461f, 0.14225335f, -0.08198355f, 0.00595988f, 
    -0.16485989f, -0.14530480f, 0.03675847f, -0.00045394f, 0.04822237f, 0.59976244f, 0.49982652f, 0.12611052f, 
    -0.28848800f, -0.12280587f, 0.06326757f, -0.05360461f, 0.27470362f, -0.12195490f, 0.10259952f, -0.26714540f, 
    0.24529113f, -0.02768059f, 0.03955260f, -0.10743020f, -0.26456553f, 0.10511863f, 0.13080904f, -0.73671108f, 
    0.17486711f, -0.21016774f, -0.00177826f, -0.02116576f, 0.06404724f, -0.16625513f, -0.06870178f, 0.12218785f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.12891306f, -0.09825261f, 0.11257485f, 0.13752516f, 0.11902554f, -0.02991982f, 0.03542272f, 0.15182391f, 
    0.39171365f, 0.05867672f, -0.00006365f, 0.03097222f, -0.03609919f, 0.19759235f, 0.30437118f, -0.02654106f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.85333353f, -0.12281530f, -0.50472891f, -0.22323468f, -0.18583314f, -0.07330748f, 0.44133550f, -1.28261781f, 
    0.70085013f, 0.21685304f, -0.47435272f, -0.17532574f, -0.24799556f, 0.30103737f, -0.27286330f, -0.02570435f, 
    -0.72079372f, -0.17246757f, 0.11918480f, -0.67082667f, -0.03722148f, -0.60850626f, 0.81778467f, 0.20082298f, 
    0.37088463f, -0.03495552f, 0.01858828f, 0.22793941f, 0.06851914f, 0.19418947f, -0.30010262f, 0.13983712f, 
    -0.02031308f, -0.08821515f, -0.41757908f, -0.17699328f, 0.15562014f, -0.53717798f, -0.21435341f, 0.06498511f, 
    -0.12505050f, -0.21439871f, -1.20246637f, -0.21895504f, -0.12166672f, -0.35869867f, 0.55618179f, 1.21230328f, 
    0.27000937f, -0.24556099f, -0.29008162f, -0.27957150f, 0.28621605f, 0.73076105f, -0.51587832f, -0.11451894f, 
    0.01065824f, 0.10848346f, 0.30640975f, -0.01363629f, 0.19441475f, -0.41895938f, 0.39812830f, -0.26920244f, 
    0.17178544f, 0.17205392f, 0.51251358f, 0.60324258f, -0.08304197f, -0.04518136f, -0.65035963f, -0.54138863f, 
    -0.45821363f, -0.11124262f, -0.41746640f, -0.15872657f, -0.06492694f, 0.10610357f, 0.35934049f, -0.12835860f, 
    0.23367520f, -0.60094631f, 0.52189618f, -0.29038274f, -0.78901494f, -0.16417150f, 0.06964673f, -0.14367218f, 
    0.17552218f, -0.21758868f, 0.32129321f, 0.17394389f, -0.18171969f, 0.41466281f, -0.10227031f, -0.18488434f, 
    -0.36018920f, -0.26087508f, 0.14779323f, -0.19034499f, -0.37322178f, 0.03939225f, -0.11532345f, 0.17866772f, 
    -0.60109538f, 0.07254439f, -0.54739463f, -0.09402883f, -0.10975698f, 0.59256560f, 0.52212197f, -0.46313390f, 
    0.62880790f, 0.84882319f, 0.09583881f, -0.08695128f, 0.14642462f, -0.11474871f, -0.49326926f, 0.29461867f, 
    -0.67432642f, -0.06211045f, 0.34968039f, 0.16060448f, -0.08855026f, -0.60466659f, -0.68185103f, -0.00511679f, 
    0.10468294f, -1.02366853f, 0.50230223f, 0.93384176f, 0.15604609f, -0.39042643f, 0.15348847f, -0.25568303f, 
    0.15691869f, 0.12897687f, 0.36724192f, -0.13765140f, -0.18775931f, -0.25930321f, -0.92255741f, 0.34501240f, 
    -0.12402678f, 0.30152741f, -0.08550036f, 0.44782642f, -0.18642865f, -0.30070835f, -0.58481288f, 0.36160606f, 
    0.36123282f, -0.00028321f, -0.10831638f, 0.22547613f, 0.03045126f, 0.33141005f, -0.08613981f, -0.71640849f, 
    -0.78485411f, -0.27568245f, 0.09706172f, 0.04765373f, 0.94672585f, -0.24157591f, -0.15702316f, 0.47504696f, 
    -0.18693574f, -0.01899896f, 0.32194242f, -0.05393027f, 0.10745756f, -0.70597500f, 0.40731302f, 0.21522003f, 
    -0.47932717f, 0.02549138f, -0.67416257f, 0.19621004f, 0.02606715f, 0.70299011f, 0.45407635f, 0.20132731f, 
    -0.64487725f, 0.22011556f, -0.61680251f, 0.09435021f, -0.11330147f, 0.01128902f, -0.16544288f, -0.08581505f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.32825181f, -0.13655864f, -0.30575275f, -0.03009719f, 0.35731915f, 0.03880359f, -0.16053116f, -0.80125958f, 
    -0.56277829f, 0.04956648f, 0.50242800f, -0.28155842f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
