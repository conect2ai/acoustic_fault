#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.24018157f, -1.05503404f, -0.76725352f, -0.10230564f, 1.12270045f, 1.09880948f, -0.09380306f, -0.41472805f, 
    -0.41822395f, 0.94404566f, 0.31934345f, 0.27250972f, 1.33462000f, 0.14400598f, 0.35501292f, 0.81869918f, 
    0.24892692f, 0.40450177f, 1.20356798f, -1.16981781f, -0.82067847f, -0.32159957f, 0.09619700f, 0.07744807f, 
    -0.11465772f, 0.52716172f, 0.67744577f, 1.31724489f, 1.15142286f, 0.42259735f, -0.81233805f, -0.40281132f, 
    -0.03742052f, 0.09184151f, 0.32200325f, 0.86956662f, -0.79058284f, 0.08236511f, 1.11268127f, 0.84166378f, 
    0.82382083f, 1.08962321f, -0.43423426f, -0.06681990f, -0.05578742f, 0.42215648f, 0.21849652f, 0.91787672f, 
    -1.47091508f, -0.90279073f, -1.10535729f, -0.15950240f, 0.18522307f, -0.19261010f, 1.39041650f, 1.23158944f, 
    0.88352913f, 0.02813332f, 0.80458474f, 0.16337292f, -0.08467121f, -0.10793675f, -0.48972189f, -0.18767761f, 
    1.06333077f, -0.76401281f, 1.33302021f, -0.52055651f, -0.70616138f, -0.07100227f, 0.21390375f, -0.43635449f, 
    0.97980380f, -0.82400012f, -0.65793699f, -0.80468035f, 1.03572631f, 0.14214247f, -0.16503593f, 0.08880872f, 
    -0.39447373f, 0.63790458f, 0.78776830f, 1.06334043f, 0.47058138f, -0.97439480f, 0.84589130f, -0.32923427f, 
    0.31167889f, 0.18472010f, -1.28914654f, 0.58883047f, 0.07046843f, 0.94898015f, 1.29629052f, -0.31005937f, 
    0.06358252f, -0.07816316f, 0.22002438f, -1.47554624f, 0.66846079f, -0.54944575f, -0.42917708f, 0.41337335f, 
    -0.94576210f, -0.19556469f, -0.19814442f, 0.24773772f, -0.93027806f, 0.14818411f, 0.33169806f, 0.50713176f, 
    -0.99909180f, 0.93374205f, 0.53772259f, -0.35592321f, 0.97657579f, -1.41945469f, -1.32564533f, -1.12440419f, 
    0.40573141f, -0.33807632f, -0.16675520f, 0.10809648f, 0.18742840f, 0.19229807f, -1.21150100f, 0.66727185f, 
    0.96701729f, -1.25035775f, 0.18123709f, 0.64270395f, -0.40171483f, 0.47475556f, 0.03915158f, -0.95964974f, 
    0.72172397f, -0.45045707f, -0.31387499f, 0.92954308f, 0.00196122f, 0.91999871f, 0.04827936f, -0.15300712f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28224438f, 0.24748953f, 0.08750295f, 0.31203473f, 0.09562421f, 0.70397353f, 0.38468668f, -0.14841415f, 
    0.03621122f, 0.36214161f, -0.62550867f, 0.44456205f, -0.24530755f, -0.17166227f, 0.17509232f, 0.23099376f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.03577542f, -0.03484689f, -0.05553266f, 0.02640808f, 0.05132378f, -0.09478571f, -0.03109751f, -0.00373562f, 
    -0.02956386f, 0.00592651f, -0.03801437f, 0.07396251f, 0.06684787f, -0.06527460f, -0.00556580f, -0.07736100f, 
    -0.02641432f, 0.04182446f, -0.06378448f, -0.05247237f, 0.02424877f, 0.05587442f, -0.03059244f, 0.01555006f, 
    -0.04168361f, 0.03813868f, -0.01799985f, -0.00760270f, -0.03649303f, -0.03696998f, -0.01252414f, -0.01579071f, 
    -0.08354598f, -0.03100501f, -0.00142998f, 0.06662282f, -0.09278283f, 0.01227632f, -0.09088536f, 0.06408076f, 
    0.06179614f, -0.05083058f, -0.02271796f, 0.01965708f, 0.05358269f, 0.06515078f, -0.03522346f, -0.05596274f, 
    0.03533437f, -0.03892882f, -0.09217014f, -0.00374907f, -0.05280870f, 0.00938279f, 0.03078810f, 0.04313938f, 
    -0.06184295f, 0.03624592f, 0.02536232f, -0.06331179f, 0.01308911f, 0.04729370f, -0.06078532f, -0.08254083f, 
    -0.05802496f, -0.07352192f, -0.07589390f, -0.03593839f, -0.08404160f, -0.02339585f, -0.09580616f, -0.00548518f, 
    0.03014401f, -0.06910301f, 0.01056245f, 0.00222307f, 0.02067734f, -0.06236871f, 0.00391433f, 0.00875528f, 
    0.01606965f, 0.05660470f, 0.02193622f, 0.02192845f, 0.00770386f, 0.04938812f, 0.00043044f, 0.01541936f, 
    -0.07901040f, -0.01455540f, 0.06890082f, 0.02329447f, -0.01151389f, -0.07568463f, 0.04568500f, 0.05072112f, 
    0.01022313f, -0.02075689f, 0.05055439f, -0.07002403f, -0.03250464f, -0.02400954f, 0.03275435f, -0.08393833f, 
    -0.04942477f, 0.04809828f, -0.01155668f, 0.01413621f, 0.02664547f, 0.01172893f, -0.06026452f, -0.02027140f, 
    -0.00070839f, 0.04540370f, 0.01546402f, -0.04853338f, 0.00919367f, 0.07111582f, -0.10356753f, -0.01046100f, 
    0.01818356f, 0.06744336f, -0.08271728f, -0.09653325f, 0.06787963f, -0.05477389f, 0.05843043f, 0.01476112f, 
    -0.05714188f, 0.03372087f, -0.05725211f, 0.00713481f, 0.04965867f, -0.09572391f, 0.00163524f, -0.09292601f, 
    -0.04807288f, 0.01347631f, -0.00129106f, -0.08826884f, -0.07600043f, -0.03171811f, 0.01903008f, -0.06010957f, 
    0.31296489f, 0.48411667f, 0.17442305f, 0.33187756f, 0.02710870f, 0.16160147f, 0.11302051f, 0.01069488f, 
    0.26203617f, -0.36096087f, 0.53487009f, 0.04874593f, 0.09437986f, -0.21508871f, 0.29164693f, -0.20380074f, 
    -0.16919619f, -0.20534158f, 0.20953837f, 0.27042532f, -0.15716675f, -0.18099141f, -0.37893933f, 0.32730702f, 
    0.32572705f, 0.23206361f, 0.29492936f, 0.08645438f, -0.73174626f, -0.10918371f, -0.11863820f, 0.13212472f, 
    0.12279113f, -0.17218842f, 0.01051378f, 0.05072802f, -0.50625068f, 0.13816091f, -0.19033371f, 0.04841521f, 
    0.09054706f, -0.08640625f, -0.18621327f, 0.32403740f, -0.20314489f, -0.37216729f, -0.19627339f, 0.22611786f, 
    -0.24444985f, -0.08392576f, 0.02427632f, -0.06063736f, -0.24355704f, 0.22253947f, -0.84813362f, -0.03142328f, 
    0.11032657f, 0.04368389f, 0.13325170f, 0.06361851f, 0.05877411f, -0.07744939f, 0.08602946f, 1.27892745f, 
    0.26314545f, 0.03402818f, -0.15102860f, -0.03605660f, -0.28515100f, 0.11190537f, 0.30947974f, 0.13230462f, 
    -0.21837907f, 0.36566791f, -0.18505007f, -0.01774681f, -0.04358269f, -0.15341516f, 0.03657103f, 0.18022703f, 
    -0.28537250f, -0.05592574f, -0.67459899f, -0.18012175f, -0.22452858f, -0.09353447f, -0.03428164f, -0.13391240f, 
    0.30589637f, -0.13576965f, 0.12048054f, 0.36192915f, 0.15529338f, 0.42606875f, 0.04408906f, 0.09785054f, 
    -0.05058622f, 0.17879227f, -0.09691826f, 0.58831757f, 0.05383650f, 0.25740343f, -0.12251669f, -0.22164214f, 
    -0.07323136f, -0.27454576f, -0.19241160f, 0.15482847f, 0.02440471f, -0.15051132f, 0.26790649f, -0.06085571f, 
    0.20923549f, 0.05095869f, 0.08274969f, -0.35712609f, -0.01506394f, 0.10171095f, 0.44791302f, 0.23644811f, 
    0.23252134f, 0.22615221f, -0.14205880f, -0.08167402f, -0.01848381f, 0.02460095f, -0.30824468f, 0.07606991f, 
    0.35342443f, 0.02941058f, -0.22920567f, -0.17972811f, 0.05468256f, 0.15665089f, 0.18537205f, 0.16355662f, 
    0.18194970f, 0.19528671f, -0.12668896f, -0.02408691f, 0.38308775f, -0.12502381f, 0.26472843f, 0.00898817f, 
    0.04832035f, -0.18042260f, 0.15612377f, -0.42787376f, 0.04205739f, 0.09884954f, -0.03626813f, 0.02862853f, 
    0.30513036f, -0.27733666f, -0.36452508f, -0.15507482f, -0.13880979f, 0.13724342f, 0.02521025f, -0.42278633f, 
    0.05754390f, -0.14297533f, 0.45556396f, -0.23715591f, -0.28436789f, -0.11319129f, 0.08968631f, -0.28276989f, 
    0.10991991f, -0.10628638f, -0.13873990f, -0.45650983f, 0.42501029f, -0.48092920f, 0.27856365f, 0.38237479f, 
    -0.00240442f, -0.02874267f, -0.00128480f, -0.27002478f, 0.29926848f, -0.39871654f, -0.09056438f, -0.05839205f, 
    0.00264823f, 0.17329852f, 0.12995081f, 0.12190143f, -0.14269280f, 0.00895379f, 0.30223501f, 0.11729445f, 
    0.22273415f, -0.02417792f, -0.18068066f, 0.03135370f, 0.07102373f, 0.12130388f, -0.14449997f, 0.73397183f, 
    0.40295970f, 0.05031550f, -0.02004444f, 0.32112694f, 0.14540964f, -0.21245006f, 0.10550898f, 0.08224604f, 
    -0.36415678f, 0.08181170f, 0.00103343f, -0.00008118f, -0.01929792f, -0.04470010f, -0.02541673f, -0.00200636f, 
    0.23830083f, -0.22165065f, 0.02120915f, 0.13653198f, -0.18376011f, 0.21002087f, -0.00118346f, 0.03762511f, 
    0.11831256f, -0.12885049f, 0.44752833f, 0.18662301f, -0.07411882f, 0.34403512f, 0.16621478f, -0.06982410f, 
    0.06428838f, -0.21994489f, 0.58564812f, -0.17544051f, -0.11037867f, 0.06613397f, -0.33115131f, -0.09549697f, 
    -0.09585815f, 0.00670658f, 0.03151337f, 0.23080659f, 0.23415254f, -0.21189108f, -0.16089986f, -0.25123006f, 
    0.19860080f, 0.34821099f, 0.18739712f, 0.10934497f, 0.16070588f, 0.35328859f, 0.06339832f, -0.01417169f, 
    -0.25929394f, -0.10706885f, -0.00849488f, -0.18266523f, -0.03041106f, 0.23934740f, -0.36566517f, 0.08876832f, 
    -0.16749820f, 0.10120603f, -0.02660176f, -0.03641611f, -0.22981247f, 0.01830000f, 0.01525781f, -0.08924475f, 
    -0.21038209f, -0.27724195f, 0.00767259f, 0.19001336f, -0.08837972f, -0.14754486f, -0.01589765f, 0.09054147f, 
    0.23660839f, -0.23266254f, 0.04991004f, 0.23338181f, -0.32531464f, -0.06278782f, -0.16511056f, 0.29307866f, 
    -0.48901513f, 0.36094633f, 0.21986647f, -0.01125006f, -0.12876154f, 0.07304627f, -0.25625002f, 0.02100529f, 
    -0.00620248f, 0.46600360f, -0.15563048f, 0.22728141f, -0.13266337f, 0.10341639f, 0.00863651f, -0.07973963f, 
    0.03175001f, -0.09579410f, 0.61025155f, 0.27440804f, -0.11421377f, 0.29988733f, -0.11109310f, 0.11285653f, 
    0.15270683f, 0.05357468f, 0.25525022f, 0.00468213f, -0.50295001f, 0.22992840f, 0.32359153f, 0.07353672f, 
    -0.09983766f, 0.04856733f, -0.11779190f, -0.01174676f, 0.20363294f, 0.37036455f, 0.03901616f, -0.25408152f, 
    0.23555163f, -0.09001787f, 0.28292543f, 0.18852645f, -0.15428804f, -0.09811479f, -0.55267316f, -0.33777425f, 
    0.27993593f, 0.15931599f, -0.13441132f, 0.13503225f, -0.13151380f, 0.09796733f, -0.17319125f, -0.55180997f, 
    0.27985531f, 0.23898080f, -0.10750992f, -0.40669480f, -0.03733963f, 0.10090169f, -0.13016076f, 0.06564106f, 
    -0.27667394f, -0.25773832f, -0.12763302f, -0.19932404f, -0.17606135f, -0.05076761f, -0.00882625f, 0.22039090f, 
    0.21333645f, -0.26490358f, 0.18189491f, 0.10816285f, 0.28425047f, -0.09503205f, -0.05803208f, 0.01455626f, 
    0.01644994f, 0.08381932f, -0.15690593f, 0.07077432f, 0.17080376f, 0.02800109f, -0.19205491f, 0.03254713f, 
    -0.11418381f, 0.31187174f, 0.04403585f, 0.16248626f, 0.12794209f, -0.45845658f, -0.12239971f, 0.04486173f, 
    -0.22061740f, -0.11860901f, 0.00090697f, -0.45730731f, -0.16761944f, -0.44178420f, 0.02554662f, 0.02393900f, 
    -0.04042799f, 0.09680937f, -0.00463411f, 0.04342042f, 0.16257542f, 0.38177904f, 0.18231790f, -0.01987721f, 
    -0.13671754f, -0.10726172f, -0.25537860f, 0.16485669f, 0.05644747f, -0.77765274f, 0.52337462f, -0.00389605f, 
    0.00874228f, -0.08880837f, 0.03462625f, -0.30686322f, 0.00212378f, -0.05414394f, 0.06157987f, 0.51615274f, 
    0.13161829f, -0.19096357f, -0.07499997f, 0.10894846f, -0.04179815f, -0.15887487f, -0.05805784f, 0.26504582f, 
    -0.03078077f, -0.15772608f, -0.32454762f, -0.18232508f, 0.31369320f, 0.10327464f, 0.10133097f, 0.15909185f, 
    0.02765762f, 0.37941363f, 0.19621299f, 0.22063836f, -0.13564242f, -0.33308297f, 0.02199848f, 0.06850915f, 
    0.03059989f, -0.12752306f, -0.38142252f, 0.38036987f, 0.05196552f, -0.15337929f, -0.02999655f, 0.12038803f, 
    0.02631486f, -0.13223885f, -0.33452293f, 0.02204074f, 0.01820659f, 0.13175914f, -0.24749827f, 0.08899003f, 
    -0.06026865f, -0.04044001f, -0.17986348f, 0.47923908f, 0.38485974f, 0.08850336f, -0.08772757f, -0.01725657f, 
    -0.07308302f, 0.09483412f, -0.03295001f, -0.02751931f, -0.65717673f, -0.09802407f, -0.24476874f, -0.02004647f, 
    -0.10730501f, 0.05515005f, -0.11144422f, 0.18027593f, 0.22133552f, -0.27292114f, -0.46395925f, -0.26045212f, 
    -0.07154375f, -0.02893090f, 0.12538733f, -0.14536746f, 0.07943773f, -0.11103233f, 0.31618327f, -0.18174557f, 
    -0.08321212f, 0.15778887f, 0.07003742f, -0.09300884f, 0.05476769f, -0.03199601f, 0.11954068f, -0.13705170f, 
    -0.10890895f, -0.17737350f, -0.08618712f, -0.10992216f, 0.03821159f, 0.13477688f, -0.02900507f, 0.25375041f, 
    -0.19360588f, 0.09733789f, -0.13325442f, 0.07070334f, -0.00576469f, -0.07625219f, -0.04813379f, -0.22604112f, 
    0.03591287f, 0.22060293f, -0.04072892f, -0.33303702f, -0.15116727f, -0.00935591f, -0.07188777f, 0.11988814f, 
    -0.06718349f, 0.08602405f, 0.15134162f, -0.03760331f, -0.02100511f, 0.14598387f, 0.29407197f, 0.11157713f, 
    -0.22269681f, 0.00380407f, 0.08788226f, -0.10939051f, -0.01435258f, -0.10448856f, -0.13731602f, 0.08752252f, 
    0.13057745f, -0.06434295f, -0.05298346f, -0.13438863f, -0.06679824f, -0.23396631f, 0.16556244f, -0.00156930f, 
    0.08424912f, 0.26065966f, 0.13642204f, -0.11202167f, -0.22051188f, 0.81808102f, 0.37241444f, 0.17656094f, 
    0.07867369f, 0.18490323f, 0.13752286f, 0.26064342f, 0.09036788f, 0.15280028f, -0.21800269f, 0.10180943f, 
    -0.01642748f, 0.05102216f, -0.19930628f, -0.12405287f, -0.00857408f, 0.12812831f, 0.00502412f, 0.20236902f, 
    0.13920183f, -0.13949361f, 0.19923668f, 0.30056792f, -0.12523431f, 0.02581926f, -0.06770391f, -0.35190636f, 
    0.42479900f, 0.10785605f, -0.07713163f, -0.18389557f, 0.02423619f, -0.13806461f, 0.14333797f, 0.38754943f, 
    -0.01306478f, -0.65470165f, -0.06214940f, -0.07381458f, 0.08073100f, -0.08212321f, -0.00802791f, 0.09552696f, 
    -0.03114273f, 0.46338552f, 0.04038432f, -0.30440262f, 0.06117764f, -0.13676615f, -0.33636975f, -0.05241190f, 
    0.21984056f, -0.11762407f, 0.25320664f, -0.08166921f, -0.48681211f, 0.18083975f, 0.35722649f, 0.10086331f, 
    0.22208801f, 0.05367231f, -0.10269689f, 0.13776162f, -0.02153455f, 0.17159230f, 0.15389875f, 0.13567108f, 
    0.06265029f, -0.05291478f, 0.04694255f, -0.08775838f, -0.22245800f, 1.11797667f, 0.37050709f, 0.49867770f, 
    0.34862220f, 0.02031748f, 0.26507282f, -0.11113225f, 0.01466507f, 0.09952311f, -0.43181163f, -0.38913813f, 
    -0.18335725f, 0.32926422f, 0.30355793f, 0.19266346f, -0.08856619f, -0.22743195f, 0.03424481f, 0.35762122f, 
    -0.31235433f, -0.14455262f, -0.10396015f, 0.12068871f, -0.22322966f, -0.08522344f, -0.06456026f, -0.09284832f, 
    0.29488733f, 0.13159966f, -0.09807857f, 0.09421361f, -0.00640144f, -0.19191608f, 0.12142904f, -0.28159732f, 
    -0.29558593f, -1.01121402f, -1.08922541f, -0.02998640f, 0.08413216f, 0.23350197f, 0.06134300f, -0.05356652f, 
    0.04165598f, 0.07921175f, 0.00323532f, 0.21772027f, -0.44841558f, -0.09890356f, 0.04980661f, -0.06901396f, 
    0.15740941f, 0.12895921f, 0.15443672f, -0.08476990f, -0.13302650f, -0.07061768f, -0.12786582f, -0.19145952f, 
    0.25969544f, -0.27303287f, -0.31763625f, -0.13725948f, -0.28670892f, -0.08744159f, -0.21509078f, 0.24615316f, 
    0.04923195f, 0.14288838f, 0.20117415f, -0.14182068f, 0.35676721f, -0.00368809f, 0.17482348f, -0.09577008f, 
    -0.47553629f, -0.39705509f, -0.07872012f, -0.34405032f, 0.18986319f, 0.10875905f, -0.01567971f, -0.09181352f, 
    -0.16337362f, -0.16853070f, -0.06717595f, 0.00310466f, -0.00685924f, 0.26880455f, 0.07279619f, -0.07889872f, 
    -0.13316984f, -0.04049474f, 0.25288194f, 0.16867003f, -0.04686042f, 0.29959670f, 0.12252615f, -0.20337564f, 
    0.41940784f, 0.11524633f, 0.11978808f, 0.20573145f, -0.03498692f, 0.11749392f, 0.08592740f, 0.15540464f, 
    0.09232523f, 0.06086260f, -0.01809473f, 0.06636641f, -0.11482288f, -0.09565376f, -0.03349499f, 0.02730897f, 
    -0.23938859f, 0.13846962f, -0.39160141f, 0.06658601f, 0.14614399f, -0.12832004f, 0.07112689f, -0.13176052f, 
    -0.05982108f, -0.17341042f, -0.18021956f, -0.20333914f, -0.08628336f, -0.15374389f, -0.19073406f, -0.04522010f, 
    -0.20429955f, -0.08785764f, -0.08733352f, -0.00862189f, 0.51811486f, 0.28333160f, 0.34675059f, -0.00212682f, 
    -0.02999511f, -0.37179270f, 0.01057169f, 0.08243300f, 0.11779388f, -0.40635842f, -0.36497855f, -0.12689838f, 
    0.07596539f, 0.20913275f, -0.12506464f, -0.02831400f, 0.15191665f, 0.06254455f, 0.13545217f, 0.20466344f, 
    0.17189914f, -0.16663893f, -0.11635463f, 0.04892216f, 0.18108402f, 0.03701707f, 0.07876090f, -0.32392550f, 
    -0.42279407f, -0.71351290f, -0.21997713f, 0.02953041f, 0.03118373f, -0.06132492f, 0.23273629f, 0.05557004f, 
    -0.50704873f, -0.32372895f, -0.21218732f, -0.04901108f, 0.01403749f, 0.10352255f, -0.05113708f, -0.19274274f, 
    0.11948289f, 0.08776034f, -0.33512351f, 0.06444725f, 0.03641305f, 0.02109081f, 0.06201752f, 0.13542314f, 
    -0.02142207f, 0.16660121f, -0.08520406f, 0.06769318f, 0.04875273f, 0.01942637f, 0.05543919f, -0.13117351f, 
    0.06909768f, 0.20209470f, 0.06567330f, -0.13645765f, 0.01327436f, -0.35586631f, 0.23969206f, 0.26704678f, 
    0.19977418f, 0.02920394f, -0.09934756f, 0.09899846f, 0.13861679f, 0.22041301f, -0.30108970f, 0.07579368f, 
    -0.11331349f, 0.07378602f, -0.05436787f, -0.24435420f, -0.17882715f, 0.24584404f, 0.15194269f, 0.71231514f, 
    -0.08275922f, -0.07056821f, 0.12843482f, 0.02932972f, 0.10635243f, 0.21768072f, -0.13397908f, 0.12536524f, 
    -0.33637735f, 0.00196099f, 0.09553331f, -0.34410387f, 0.03520752f, 0.04659817f, 0.01278943f, 0.42492685f, 
    -0.01252100f, -0.14198162f, 0.19866242f, 0.05334605f, 0.01962553f, -0.04056285f, -0.06928802f, 0.05147598f, 
    0.47494897f, -0.05234291f, -0.52667487f, 0.17407086f, 0.16006091f, 0.03683578f, 0.25539905f, -0.10473634f, 
    -0.20057875f, -0.30280185f, -0.41532257f, 0.41823322f, -0.02288740f, 0.36419103f, -0.17138523f, 0.02743745f, 
    -0.07703216f, -0.04588535f, -0.82892340f, -0.35002950f, 0.20753747f, -0.19218202f, 0.05664107f, -0.27757853f, 
    -0.10440682f, 0.07486717f, 0.14677712f, 0.50226086f, 0.16076927f, -0.03117720f, -0.11879635f, -0.46422186f, 
    0.21107562f, -0.07432936f, 0.12655218f, 0.36233643f, -0.07613749f, 0.22164196f, 0.45660907f, 0.07298823f, 
    -0.11724172f, -0.22853850f, -0.02974207f, -0.11162469f, -0.08083369f, -0.22978371f, 0.01256771f, -0.02097862f, 
    0.12488750f, -0.01932102f, 0.03532115f, -0.09461581f, 0.09020898f, 0.07609963f, 0.48074499f, 0.27900794f, 
    0.05213429f, -0.01321571f, 0.13993497f, 0.07756323f, 0.04257273f, 0.02581424f, -0.09871847f, -0.12599459f, 
    -0.30674994f, -0.33569863f, 0.23008992f, 0.10741364f, -0.00848978f, 0.16033047f, -0.06490374f, 0.06084548f, 
    -0.06464218f, -0.56510240f, -0.57036746f, -0.14026982f, 0.04220883f, 0.15107401f, 0.14633211f, -0.05897352f, 
    -0.08492289f, 0.15417281f, 0.25394735f, 0.49247488f, -0.10271429f, 0.01416276f, 0.14302646f, 0.15899517f, 
    0.09697493f, 0.15371978f, -0.52216107f, -0.12751158f, 0.30285773f, -0.18501608f, 0.03862681f, -0.10487452f, 
    0.02828417f, -0.07150644f, -0.02117487f, -0.02572602f, -0.00701706f, -0.52117926f, 0.13357447f, -0.03409081f, 
    0.20260438f, -0.17585716f, -0.00592288f, 0.14044018f, -0.21444416f, 0.10293220f, 0.00778349f, 0.16916922f, 
    0.12896760f, 0.33680004f, 0.07643048f, -0.07467571f, -0.08292916f, -0.11569217f, 0.50077528f, -0.43853119f, 
    -0.14759007f, 0.37774542f, -0.10615870f, 0.18302989f, 0.14099297f, 0.02879746f, -0.27568477f, -0.02701174f, 
    -0.82864016f, 0.03517203f, -0.08027588f, -0.01447082f, 0.18258689f, 0.10172901f, 0.05056503f, 0.26154959f, 
    -0.33323717f, -0.20441659f, -0.06163577f, -0.09822098f, -0.17096725f, -0.03545956f, 0.07591140f, -0.09031231f, 
    -0.00622420f, -0.01377928f, 0.00323786f, 0.05972593f, -0.01969430f, -0.02835854f, -0.01292600f, 0.01151000f, 
    -0.01442351f, -0.03067209f, -0.07303221f, -0.04503362f, -0.04818450f, 0.00479380f, -0.08375623f, 0.05569801f, 
    0.05108877f, -0.07456853f, 0.06270562f, 0.05060339f, 0.05203758f, -0.06986330f, 0.06228086f, -0.03723603f, 
    -0.03817076f, -0.05433796f, -0.01905116f, -0.08397347f, -0.06775299f, -0.04406781f, -0.07933085f, -0.02493150f, 
    0.03269046f, -0.08683108f, 0.03304718f, -0.08374283f, -0.04043848f, -0.01951412f, 0.06420510f, -0.00880473f, 
    0.01677870f, -0.08451044f, -0.02648105f, 0.04493590f, 0.01052040f, 0.06838852f, -0.05331981f, 0.05399349f, 
    -0.09044735f, -0.00548520f, 0.04061410f, 0.03129018f, -0.04611889f, -0.01260613f, -0.07847431f, -0.07008573f, 
    0.03960522f, 0.05980796f, 0.03695268f, -0.04574186f, -0.03006235f, -0.01754253f, -0.08265533f, 0.05383310f, 
    0.06208357f, 0.03966360f, 0.00125775f, -0.08449683f, -0.04214596f, -0.07313441f, -0.04879915f, 0.06111166f, 
    0.02418882f, -0.08934540f, -0.00247206f, 0.00889111f, -0.02406871f, -0.00372473f, -0.06035604f, -0.08588570f, 
    0.03645296f, 0.00606703f, 0.05717437f, -0.01600391f, -0.01761230f, -0.02642529f, 0.04620103f, 0.05234909f, 
    0.05409515f, 0.00110149f, 0.01548386f, 0.01558428f, 0.03592743f, -0.03780884f, -0.07939921f, -0.06464345f, 
    0.00569658f, 0.04707990f, -0.05936268f, -0.04363100f, 0.07485259f, -0.02172775f, -0.03665644f, -0.06943896f, 
    -0.06893587f, -0.07683861f, -0.06866215f, -0.01040724f, -0.08474626f, -0.02759543f, 0.06240441f, -0.08775336f, 
    -0.00936266f, 0.02829402f, -0.02058476f, -0.02558461f, -0.03884689f, -0.06710935f, 0.04754385f, 0.00637957f, 
    -0.04271502f, -0.05131311f, 0.01373484f, -0.04057005f, 0.02344250f, 0.02363927f, -0.03141744f, 0.00033290f, 
    0.03198968f, 0.05416654f, -0.05713914f, 0.04096501f, -0.04342552f, -0.04221410f, -0.07646505f, -0.03380847f, 
    0.06682999f, -0.03050373f, -0.00986366f, -0.02870202f, -0.00121156f, -0.02984655f, 0.05268960f, -0.02032649f, 
    0.02158169f, 0.04314653f, -0.09159313f, -0.08884495f, -0.07069969f, 0.04482609f, -0.07028915f, -0.03742304f, 
    0.02053134f, -0.03258604f, 0.04176776f, -0.01480208f, 0.01353787f, -0.06720239f, -0.00550457f, -0.01546960f, 
    0.03443541f, -0.08678485f, 0.07541373f, -0.03650124f, 0.06576321f, -0.09287610f, 0.00796316f, 0.04841932f, 
    -0.08032517f, -0.00187199f, -0.05274443f, -0.00515786f, -0.03388356f, 0.00138055f, 0.02634775f, -0.00599271f, 
    -0.05095501f, -0.00774016f, 0.03605921f, -0.06867564f, 0.04379169f, -0.02068217f, -0.02407343f, -0.00593541f, 
    0.04520528f, 0.02621680f, 0.03001061f, 0.04311322f, -0.08206658f, 0.00666965f, 0.03673397f, -0.06722303f, 
    -0.03107551f, -0.06729050f, 0.03376589f, 0.07610171f, -0.04733376f, -0.05723294f, 0.02132549f, 0.01711947f, 
    -0.08855173f, 0.03470615f, -0.01723280f, -0.07961584f, -0.07595990f, 0.06756479f, 0.05987085f, -0.00439471f, 
    -0.03982110f, -0.02096202f, 0.04950898f, -0.08066874f, -0.01869261f, -0.05123887f, 0.02670907f, -0.01657826f, 
    -0.00254282f, 0.03037035f, 0.01963886f, -0.01049979f, 0.03240530f, -0.05546084f, -0.08542289f, 0.03713150f, 
    0.01693945f, -0.04834632f, 0.03819500f, -0.02180879f, -0.04433940f, -0.07895137f, 0.02962404f, 0.03406185f, 
    -0.06897994f, 0.02880099f, 0.02091871f, -0.00209185f, 0.01102458f, -0.04569187f, -0.01078639f, 0.00668791f, 
    0.04641620f, 0.00886210f, 0.04406973f, 0.06666895f, -0.07834230f, -0.04297062f, -0.06181907f, -0.04104223f, 
    -0.07682468f, -0.00268712f, -0.00719512f, 0.00140792f, 0.04329725f, -0.04650439f, -0.00813633f, 0.05310479f, 
    -0.04223608f, -0.02217660f, 0.04887660f, 0.04675720f, -0.05802807f, -0.00206716f, 0.04502884f, 0.00533163f, 
    -0.04817351f, -0.02848630f, -0.08802456f, -0.06705290f, -0.03256527f, 0.01059839f, 0.01681709f, 0.05354945f, 
    -0.05182955f, -0.00219115f, 0.07514935f, 0.00335944f, -0.09090792f, -0.00452736f, -0.01784321f, -0.04591160f, 
    -0.07885008f, 0.06022663f, -0.07747035f, 0.05720683f, 0.05663121f, -0.02956452f, 0.02855594f, -0.07149976f, 
    0.01575883f, -0.07564850f, -0.03775368f, 0.06042676f, -0.07887977f, -0.01484798f, 0.06690294f, -0.00620255f, 
    -0.07329134f, -0.07784897f, -0.05587800f, -0.04492589f, -0.01098563f, -0.06573933f, -0.02477084f, 0.03080803f, 
    0.03945946f, 0.01327120f, 0.03000074f, 0.05313012f, 0.00074941f, -0.03912058f, -0.01294127f, -0.00486342f, 
    -0.07325299f, 0.01742043f, 0.03987682f, -0.04322269f, 0.01320192f, 0.03125007f, -0.06797624f, 0.06100836f, 
    -0.05181934f, -0.02904061f, -0.03143127f, 0.03877214f, -0.04144596f, -0.05335421f, -0.03058859f, -0.01965837f, 
    -0.00340080f, -0.03586713f, -0.03238504f, 0.00846693f, 0.04748229f, -0.07076722f, 0.03931083f, 0.00101597f, 
    0.05298078f, 0.05713033f, -0.07563391f, -0.01940355f, 0.03699004f, -0.01116652f, 0.01354621f, 0.02844542f, 
    0.04962307f, -0.07678805f, -0.06975465f, -0.07888438f, -0.05887144f, -0.05560551f, -0.08376653f, -0.01421612f, 
    -0.02570916f, -0.08109248f, -0.08578000f, -0.07363908f, 0.05168312f, -0.01042281f, 0.01094111f, -0.06279506f, 
    -0.00286783f, 0.01437142f, -0.02039169f, 0.05237119f, -0.01259156f, 0.06322293f, -0.09405819f, -0.06315274f, 
    0.04706157f, -0.04599595f, -0.07038457f, -0.05493791f, -0.05042271f, -0.01838961f, -0.00662337f, -0.06570417f, 
    -0.01541198f, -0.07257967f, -0.03955333f, 0.02302393f, -0.03415440f, -0.02158120f, 0.01305021f, 0.05128323f, 
    0.03650764f, -0.01211069f, 0.00464674f, -0.03262569f, -0.02793664f, 0.00828525f, -0.07625114f, 0.03430655f, 
    -0.04524708f, 0.02674272f, -0.01265617f, -0.06140535f, -0.06162010f, 0.00433552f, -0.07537568f, 0.03408825f, 
    0.01298420f, -0.02294463f, 0.03485715f, -0.05330756f, -0.01654394f, -0.01101966f, -0.08950100f, 0.05584375f, 
    0.02212021f, -0.08110115f, -0.06864370f, 0.05937168f, 0.01066479f, -0.05329233f, 0.01510916f, 0.01589326f, 
    -0.02342595f, -0.05631771f, -0.01382372f, -0.07250153f, -0.06345671f, -0.04882424f, 0.06388624f, 0.02718436f, 
    0.07309184f, -0.06630684f, 0.02554731f, 0.06609175f, -0.02219841f, -0.05198804f, 0.00145413f, 0.04466255f, 
    -0.12313873f, 0.00636841f, -0.08854640f, 0.03926786f, 0.04345797f, -0.10421555f, -0.04915457f, 0.00057826f, 
    0.00505333f, -0.07249862f, 0.05932477f, 0.04626440f, -0.09262858f, -0.09400095f, -0.04993341f, 0.01090855f, 
    0.02081349f, -0.04165602f, -0.06267817f, -0.03944392f, -0.09791047f, -0.00985492f, -0.02206841f, 0.03947571f, 
    -0.03683108f, -0.03030923f, -0.04898505f, 0.04308116f, -0.00993309f, 0.01531832f, 0.02808443f, -0.03356495f, 
    0.03309186f, -0.01433785f, 0.01925661f, -0.02004519f, -0.07762334f, -0.11751450f, -0.07254621f, 0.02375947f, 
    -0.00502438f, 0.00682039f, -0.08207068f, -0.05122179f, -0.09239826f, 0.05842245f, -0.08942062f, 0.01845137f, 
    -0.08085568f, 0.03882402f, 0.04796797f, 0.04771858f, -0.01720803f, 0.00515596f, -0.07826685f, 0.06653386f, 
    -0.05335755f, 0.00095959f, -0.02357244f, -0.09130272f, -0.06457537f, -0.08048154f, 0.06205407f, 0.03371977f, 
    0.04851281f, -0.05801201f, -0.07075972f, -0.00713095f, -0.02487907f, 0.02020953f, -0.02029308f, -0.01070909f, 
    -0.01833584f, -0.01573433f, -0.06186536f, -0.10337815f, -0.08752713f, 0.01947858f, -0.06006179f, 0.06219278f, 
    0.01818663f, 0.02078999f, 0.06657439f, 0.05417682f, 0.02841514f, -0.10004011f, 0.05684925f, -0.03759797f, 
    -0.01278663f, -0.09845030f, 0.02949022f, -0.01642898f, 0.04256204f, -0.04508778f, -0.02893106f, -0.05021343f, 
    -0.03622170f, -0.06039121f, 0.00986157f, -0.03601077f, -0.05101470f, -0.02956364f, -0.08057691f, -0.07403694f, 
    -0.06357212f, -0.05491078f, -0.00577581f, 0.00789734f, -0.09334716f, 0.04187659f, 0.05521308f, -0.00551897f, 
    -0.01823784f, -0.08694153f, 0.02998992f, -0.09185188f, -0.08012423f, -0.04457513f, -0.01327207f, -0.02459927f, 
    -0.08954720f, 0.02501919f, -0.09919994f, -0.00284906f, 0.08557196f, -0.00491290f, -0.08775579f, 0.05956234f, 
    -0.07641342f, -0.03652213f, 0.03097191f, -0.06238119f, 0.01322144f, 0.05396229f, 0.03944959f, -0.06558981f, 
    0.04620937f, -0.02345732f, 0.00556266f, -0.00440246f, 0.05392473f, -0.05983469f, -0.00988497f, -0.04367664f, 
    -0.24042353f, 0.53443557f, -0.26164845f, 0.07588200f, 0.04143044f, 0.24051000f, -0.01311548f, 0.18920676f, 
    0.22678246f, -0.04289795f, -0.09250637f, -0.17264411f, -0.14099759f, 0.12721774f, 0.25711221f, 0.00087372f, 
    0.16790643f, -0.05871267f, 0.07916833f, -0.23475811f, -0.09001108f, -0.02008660f, 0.05526191f, 0.03177980f, 
    0.06611846f, 0.07498769f, -0.16546050f, 0.27378297f, 0.22794610f, -0.25319555f, -0.01939956f, -0.04265403f, 
    -0.14219791f, 0.06672785f, -0.08787706f, -0.01257255f, -0.41607234f, 0.23037106f, 0.32151103f, 0.21266977f, 
    0.19890666f, -0.02862388f, 0.01817011f, -0.15865391f, 0.06046049f, 0.18194401f, -0.08584326f, -0.09364015f, 
    0.13603961f, -0.00472984f, -0.09012990f, 0.12940176f, 0.04750903f, 0.07830703f, 0.32592148f, 0.56335807f, 
    -0.19770959f, -0.18262033f, -0.18566419f, -0.13055257f, 0.07570319f, 0.05943210f, 0.10545368f, -0.12956180f, 
    -0.36812124f, 0.11377009f, -0.06351055f, -0.24572307f, -0.05011727f, 0.15525596f, 0.11684511f, 0.00193536f, 
    -0.17095724f, -0.04588863f, -0.13983096f, -0.23540851f, -0.08270209f, -0.06311221f, -0.15046966f, -0.23632757f, 
    0.04866644f, -0.10418333f, -0.10098247f, -0.08929811f, 0.00490764f, 0.13554825f, 0.02524238f, 0.03167247f, 
    -0.06841337f, -0.29287216f, 1.10274041f, 0.09102117f, 0.41830495f, -0.19248618f, -0.03126735f, 0.05297541f, 
    -0.13544342f, 0.08815669f, -0.10282693f, 0.54703200f, -0.12931146f, -0.19001248f, 0.03591368f, -0.04382125f, 
    -0.01484675f, 0.08834323f, -0.01010113f, -0.14885613f, -0.22848856f, -0.10445184f, -0.22267106f, 0.06531204f, 
    0.30844536f, 0.05255975f, -0.29999968f, -0.01676829f, 0.07201629f, -0.28611264f, 0.08399471f, -0.23861353f, 
    -0.01266437f, 0.02687104f, -0.02221114f, -0.07092031f, 0.02679742f, -0.09517562f, -0.52839148f, -0.10356049f, 
    0.23591247f, -0.22479123f, 0.02417449f, -0.13450120f, 0.14938143f, -0.03473412f, 0.00042957f, 0.22973967f, 
    0.08040186f, 0.06093398f, 0.00487283f, 0.15630478f, -0.22607662f, -0.10338399f, -0.16330975f, 0.09563834f, 
    -0.12910619f, -0.35762361f, 0.12154541f, 0.07305816f, 0.09699013f, 0.18542780f, -0.05728477f, -0.01903265f, 
    0.08835112f, 0.48631305f, 0.35829651f, -0.24546479f, -0.01143441f, 0.07507797f, -0.04157853f, -0.14704266f, 
    0.06737933f, -0.04983412f, 0.26490393f, -0.18818182f, 0.16038613f, 0.05501043f, -0.05872019f, -0.00890575f, 
    -0.00370712f, 0.03032879f, -0.12566303f, 0.01823163f, 0.43316400f, -0.02976312f, -0.14988545f, 0.13328607f, 
    -0.11511094f, -0.01117994f, -0.03742635f, -0.10053565f, 0.16752638f, 0.24967305f, -0.12100264f, 0.03783818f, 
    -0.01840566f, 0.02386310f, 0.05740799f, 0.06077357f, 0.16186738f, 0.06422343f, 0.35787457f, -0.68381381f, 
    0.25095153f, 0.04253434f, 0.09282439f, 0.05330439f, 0.31513166f, 0.08026962f, -0.09128413f, 0.09736308f, 
    0.16259652f, 0.38276038f, 0.07247165f, 0.02299118f, -0.02117768f, 0.14242861f, -0.16034362f, -0.15461726f, 
    0.07511898f, -0.35091540f, -0.00817518f, 0.08580436f, 0.01506068f, 0.00960748f, -0.03103834f, -0.03315086f, 
    0.66242588f, -0.16903660f, -0.06551769f, -0.14837287f, -0.18947908f, -0.02830130f, 0.16399468f, -0.11280355f, 
    0.16333073f, -0.31883660f, 0.10127712f, -0.02711991f, 0.09534506f, 0.23006445f, -0.02743534f, 0.16761610f, 
    0.03314596f, 0.11980108f, -0.43665388f, -0.49984124f, -0.12225508f, -0.00525310f, -0.17894019f, -0.12581813f, 
    -0.06357279f, -0.23248029f, -0.15097314f, -0.96801907f, 0.05416113f, 0.33417612f, 0.23193295f, 0.16153447f, 
    0.01103172f, -0.02079492f, 0.02005524f, 0.12540323f, -0.35607591f, -0.54438859f, -0.46319005f, -0.03436028f, 
    0.18855557f, 0.19661316f, -0.05380049f, -0.00202030f, 0.14602254f, -1.06206465f, -0.48345137f, 0.58458149f, 
    0.34189638f, 0.07522766f, -0.16599761f, -0.00991736f, 0.04398530f, -0.10882885f, -0.81354088f, 0.24279313f, 
    0.11770210f, 0.04576739f, -0.18691140f, -0.10237844f, 0.17250010f, 0.05810132f, -0.05792159f, -1.27171290f, 
    0.06537851f, 0.22702588f, -0.04642741f, -0.16158147f, 0.00616396f, 0.07384980f, -0.08381001f, -0.24728142f, 
    0.26920602f, 0.15099297f, 0.03419403f, 0.00030752f, 0.15176241f, -0.23291883f, 0.24353436f, -0.10407198f, 
    0.08096326f, -0.12440974f, 0.14007716f, 0.31124988f, -0.05246912f, -0.05006404f, -0.05200464f, -0.15275109f, 
    -0.04120759f, -0.08778475f, 0.21798833f, -0.04197120f, -0.02134906f, 0.14697872f, -0.10773554f, 0.32438648f, 
    -0.09943052f, -0.08116964f, -0.06001384f, -0.04846204f, 0.30812261f, -0.00077442f, -0.06082205f, -0.02772384f, 
    0.24506280f, -0.12226070f, -0.11034581f, 0.13761212f, 0.55982351f, 0.01870807f, -0.11589023f, 0.03453734f, 
    -0.38966325f, -0.01946311f, -0.06624116f, 0.12654285f, 0.00786066f, -0.11026081f, 0.34836799f, -0.25635388f, 
    0.11630937f, 0.12888744f, 0.10336089f, -0.25786644f, 0.05069610f, 0.03974125f, -0.10106108f, -0.12526244f, 
    -0.15548255f, -0.16436721f, -0.11669227f, 0.11435714f, -0.21013978f, 0.13241126f, 0.12392797f, -0.21441127f, 
    -0.29826814f, -0.00373803f, 0.36736572f, 0.28676659f, -0.12480377f, -0.12680098f, 0.00715790f, -0.05474884f, 
    0.38570350f, -0.14699167f, -0.28443435f, -0.13749611f, 0.05670059f, 0.04909549f, -0.09944211f, 0.11423457f, 
    0.11958256f, -0.46738708f, 0.02860532f, -0.12383249f, 0.00069895f, 0.14950825f, 0.03763712f, -0.09513438f, 
    0.13333118f, 0.24868444f, 0.91497648f, 0.39469659f, -0.21429601f, 0.16870259f, -0.01326616f, 0.03829688f, 
    0.03379076f, 0.18656628f, -0.15153155f, -0.48661703f, -0.27721310f, -0.47351658f, -0.06085510f, -0.08088949f, 
    0.13829008f, -0.29407912f, 0.05175393f, 0.01069369f, 0.08747973f, 0.72236377f, -0.19683664f, 0.15055135f, 
    0.11373877f, 0.07147426f, 0.03734165f, 0.24142800f, 0.18649621f, 0.08732024f, 0.06337262f, 0.36669618f, 
    -0.48113081f, -0.00928825f, -0.21061195f, -0.13951944f, -0.05702057f, -0.09877261f, 0.35201892f, 0.01456565f, 
    -0.62341762f, -0.21069744f, -0.04085376f, 0.14508863f, -0.18497129f, 0.05358503f, -0.10232283f, -0.01735559f, 
    -0.09519951f, 0.14519180f, 0.27973646f, -0.06213557f, -0.03271129f, 0.10802210f, -0.23330607f, 0.04983658f, 
    0.04139272f, 0.07007998f, -0.41713241f, 0.10483894f, 0.13044870f, -0.08143868f, 0.10216027f, -0.21074244f, 
    -0.09920660f, 0.32379803f, 0.04027708f, -0.42536592f, -0.01814036f, 0.02935889f, 0.02189506f, 0.15789860f, 
    0.21799789f, 0.25989276f, -0.61744398f, -0.61088997f, 0.18635228f, -0.06430215f, -0.15497725f, 0.02116339f, 
    -0.28370976f, 0.09886756f, -0.06162389f, 0.05854869f, 0.03786291f, 0.15550113f, -0.09524100f, -0.27152243f, 
    -0.06311311f, -0.11812008f, -0.00870319f, -0.00078412f, 0.37182879f, 0.12778565f, 0.01796104f, 0.29335952f, 
    0.39751452f, 0.02284881f, 0.01616793f, 0.13993324f, 0.01180598f, -0.03320603f, 0.05119251f, 0.33785671f, 
    0.07226483f, 0.23659879f, 0.21668020f, 0.11822063f, 0.02565969f, 0.21794732f, 0.60036969f, 0.04706331f, 
    0.22338438f, 0.08457111f, -0.00346144f, 0.04104827f, 0.27003443f, 0.05665735f, -0.00247095f, -0.41070250f, 
    -0.00055371f, -0.27888313f, 0.20233791f, -0.03551001f, 0.15089570f, -0.13799654f, -0.02516325f, -0.36842310f, 
    -0.47501823f, 0.14045452f, -0.14075413f, 0.17164260f, -0.00916952f, 0.07846144f, 0.06922399f, -0.11307745f, 
    0.17843460f, -0.16953200f, -0.13354205f, 0.19450322f, 0.01912298f, -0.16256051f, 0.23455192f, 0.33233881f, 
    0.06989399f, 0.05444664f, 0.15671779f, -0.17449211f, 0.04220907f, 0.05572627f, 0.25809348f, -0.27682754f, 
    -0.33637893f, -0.12732063f, -0.06751339f, -0.20448789f, 0.21823870f, 0.19478224f, 0.19863705f, 0.28568217f, 
    0.35007298f, 0.06275298f, -0.05028115f, -0.21527542f, -0.17775282f, -0.10454839f, -0.70310360f, 0.11581982f, 
    -0.08263322f, -0.02454819f, 0.04245950f, 0.16169871f, -0.12700452f, -0.09275000f, -0.25460044f, 0.06488558f, 
    -0.07710415f, -0.00083848f, 0.12712412f, 0.04910144f, 0.12994421f, -0.28182244f, 0.12127759f, -0.06700078f, 
    -0.10102878f, -0.17624490f, 0.19695386f, -0.05005283f, -0.08298215f, 0.11328985f, 0.25478041f, 0.02505681f, 
    -0.12581001f, -0.17569938f, 0.13198361f, -0.10437596f, 0.10837427f, 0.12850393f, 0.16700493f, 0.20414010f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.04926796f, -0.14185302f, 0.06143622f, 0.00750137f, -0.09692597f, 0.36084518f, 0.15510622f, 0.19800436f, 
    0.01679219f, 0.03103470f, 0.02118771f, -0.05871561f, -0.16940030f, 0.46643248f, 0.18017584f, 0.64068943f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15519881f, 0.17278521f, -0.28654572f, -0.78696114f, -0.43276563f, -0.32115352f, 0.20944937f, -0.24321200f, 
    -0.00128954f, -0.04907522f, 0.00517128f, -0.04926992f, 1.43598199f, -0.61434865f, -0.45055908f, 0.15014990f, 
    -0.09151381f, -0.33151621f, -0.29208115f, -0.45567250f, 0.11856336f, -0.24829458f, 0.79027110f, 0.73876977f, 
    -0.23117320f, -0.08200225f, -0.14762999f, -0.11065971f, -0.49773929f, -0.72970778f, -0.06718453f, 0.27943403f, 
    -0.18220359f, -0.66405761f, 0.55043721f, -0.31490734f, -0.36673892f, -0.11796119f, -0.14279896f, -0.49124148f, 
    0.20694801f, 0.21803376f, 0.07775044f, 0.23000796f, -0.00147370f, -0.14065175f, 1.13608098f, -0.39915314f, 
    -0.09151226f, 0.55460703f, 0.16659315f, -0.21545385f, -0.81656903f, 0.85893714f, -0.65921736f, -0.85194474f, 
    -0.04780004f, -0.23642579f, 0.19564660f, 0.11610317f, 0.34770095f, -0.54487383f, -0.47609439f, -0.74527395f, 
    -0.07419892f, 0.17812629f, 0.27993831f, -0.21779439f, -0.35458064f, -0.20998797f, 0.30070776f, -0.55995464f, 
    0.18440071f, -0.09557329f, -0.22990005f, 0.00345341f, -0.37567705f, 0.01198251f, -0.44388330f, 0.35837734f, 
    0.05593593f, -0.00935552f, -0.48401231f, -0.49483851f, 0.36268428f, -0.30649573f, -0.28330728f, 0.52699208f, 
    -0.23789220f, -0.05583212f, -0.18849182f, -0.11803728f, -0.43974259f, 0.12498814f, -0.02870109f, 0.36489233f, 
    -0.24611576f, 0.12246063f, 0.58207643f, -0.39127183f, -0.34868836f, -0.34041137f, -1.03944099f, 0.25118583f, 
    0.23766047f, -0.11437326f, 0.24482961f, 0.11073127f, 0.20367874f, 0.19042401f, -0.54852623f, 0.09001895f, 
    -0.18564551f, 0.85046738f, -0.50279224f, -0.57995439f, 0.49984711f, -0.16045800f, 0.11390536f, -0.58244121f, 
    -0.00179622f, 0.09263537f, 0.10384819f, 0.16664882f, 0.15588245f, -0.26160228f, -0.03325953f, -1.01874256f, 
    -0.12358465f, -0.33073771f, -1.07417214f, 1.40979600f, 0.08305252f, -0.20762730f, 0.03621312f, -0.29526877f, 
    -0.22607933f, 0.07897302f, 0.07405131f, 0.08544195f, 0.04356787f, 0.35808226f, -0.14697716f, 0.05442990f, 
    0.05048032f, -0.00001847f, -0.03212183f, -0.49459982f, -0.34420073f, -0.53609645f, -0.23203756f, -0.67928529f, 
    0.00002286f, 0.11182602f, 0.01516165f, 0.06069127f, 0.00780267f, 1.16096902f, -0.13014723f, 0.29763800f, 
    -0.11973149f, -0.26030821f, -0.38380277f, 0.11768448f, -0.21171780f, 1.12442815f, -0.15924455f, -0.57878166f, 
    0.15883321f, 0.17090349f, 0.16267762f, 0.19753358f, -0.96240175f, -0.74345440f, 0.34293649f, 0.00941124f, 
    0.19971032f, -0.13492802f, 0.24244201f, 0.29721087f, 1.00269353f, 0.14405386f, -0.85038006f, -0.21978725f, 
    -0.12374574f, 0.24185197f, 0.15192312f, 0.00792127f, 0.20455083f, -0.78320515f, -0.25823066f, 0.03756209f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.29374036f, -0.21639435f, -0.59240597f, 0.01157522f, 0.23132080f, 0.39932716f, 0.17445457f, -0.21116528f, 
    -0.53154385f, 0.25569317f, 0.38209665f, 0.24184428f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
