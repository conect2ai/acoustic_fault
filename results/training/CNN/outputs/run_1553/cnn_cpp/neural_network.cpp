#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.24956386f, -0.65051472f, 0.62465721f, -0.47342354f, -0.14562808f, 0.32029986f, 0.53407669f, 0.42122933f, 
    -0.80433661f, -1.25656796f, 1.85710204f, -0.72895628f, -0.06165806f, -0.35884184f, 0.08782279f, 0.10911313f, 
    0.01112532f, -0.13107745f, -1.24821591f, -0.15794212f, 1.79961586f, -0.15671742f, -0.42054483f, -0.49767807f, 
    -0.06435282f, -0.06526953f, -0.18479645f, 0.37441173f, -0.96848363f, 0.76521498f, -0.91760403f, 0.00879714f, 
    0.95538408f, -0.07824911f, -0.27702633f, 0.46809357f, -0.79792148f, -0.86479509f, -0.61800456f, 0.41869614f, 
    0.76364768f, -0.23031539f, 0.49160641f, 0.77185965f, 0.49048144f, 0.47688025f, 1.08143318f, -0.48795947f, 
    -0.47487307f, 0.16181439f, 0.29426736f, 0.49241361f, -0.32110235f, -0.42844716f, -0.97083139f, -0.57180303f, 
    -0.13454498f, 0.08718088f, -0.13267928f, -0.29936409f, -0.31035197f, 0.40345854f, 1.02667391f, 0.20560981f, 
    0.71631402f, 0.61595845f, 0.70982635f, 0.27030954f, 0.92061538f, -0.36987311f, -0.53030974f, -0.65831041f, 
    -0.15706144f, 0.68721884f, 0.57110995f, -1.32834935f, -1.51784348f, -1.26466107f, 0.59649056f, -0.28277758f, 
    0.63327038f, -0.08190700f, -0.21357930f, -0.72461116f, -0.60867876f, 0.08160505f, -0.99490458f, 0.69543695f, 
    0.68394214f, 0.20908581f, 0.96568847f, -0.56623644f, 0.41061434f, 0.68260962f, -0.92792255f, 0.45993018f, 
    0.02094812f, -0.05531496f, 0.21076135f, -1.24580646f, 0.26862946f, 0.75460833f, 0.06821927f, 0.55376351f, 
    -0.32501063f, -0.43692613f, 0.04171797f, -0.82962525f, 0.84884465f, 0.55283558f, 0.77994728f, 0.78471470f, 
    -0.50686419f, -0.59425092f, 0.17452262f, 0.93506789f, 0.15224835f, 0.41397268f, 0.29550400f, 0.70680124f, 
    -0.19940795f, 0.48770124f, -0.06406102f, -0.34329650f, 1.10600293f, -1.24161208f, -1.20935965f, 0.14652351f, 
    1.30716741f, 0.26010132f, 0.39933857f, 0.18281013f, 0.07628348f, 0.38143197f, 0.14947055f, -0.14277266f, 
    0.40843576f, 0.20921186f, -0.52247989f, -0.83045560f, -0.77560735f, -0.58595395f, 0.11661351f, -0.82250035f, 
    -0.76225811f, -0.68524837f, -0.56909794f, 0.44875339f, 1.50314796f, -0.85172206f, 0.09870666f, -0.21155207f, 
    -0.27621821f, 0.92783618f, -0.20364028f, -0.68470567f, -0.70732564f, 0.01158370f, 0.64333534f, 0.65127939f, 
    0.42837492f, 0.49271935f, 0.27670649f, 0.22020531f, 0.37671411f, 0.81090045f, 0.39901045f, 0.31122527f, 
    0.86532295f, 0.35243484f, 0.53273106f, 0.50893706f, -1.23114383f, -0.80004388f, -0.31563038f, 0.68719476f, 
    1.13425338f, -0.04830695f, 0.48586977f, -0.02276224f, 0.10346167f, -0.00498383f, 0.09973285f, -0.24784982f, 
    0.20119059f, 0.36272714f, 0.02909437f, 0.59218204f, 0.81003398f, -1.08884060f, -0.69402874f, -0.41198841f, 
    1.20667624f, -0.56245756f, -0.08880367f, -0.39316273f, 0.50029939f, 0.18638304f, -0.71465123f, 1.35438359f, 
    -0.93163007f, -0.33091497f, 0.76261592f, -0.10832391f, -0.02818148f, -0.20984769f, 0.15876482f, -0.37343791f, 
    -0.61243087f, -0.10670799f, -0.57619292f, -0.92356479f, -0.67042869f, -0.18901771f, 0.93862462f, 0.27266595f, 
    1.12726653f, 0.00277511f, -0.84922779f, 0.33734569f, 0.76108307f, 0.20288369f, 0.18089524f, 0.22778958f, 
    -0.51005328f, -0.74057579f, -0.21981899f, -0.72537082f, -0.32970715f, -0.60797334f, -1.09126008f, -0.54883254f, 
    -0.61656374f, -0.49559695f, 1.52202773f, -0.69499236f, -0.54025847f, -0.48796210f, -0.42313474f, -0.25875044f, 
    0.53829366f, 0.61697650f, 0.40518355f, 0.67760754f, 0.92574972f, -0.07505988f, 0.63031042f, -0.88988256f, 
    -0.41032633f, -0.17042279f, -0.32809642f, -0.29272971f, 0.17572466f, -0.88831979f, -0.72023952f, 0.57249707f, 
    0.29535288f, 0.67221439f, -0.41105807f, -0.66023231f, -0.92749584f, -1.00003994f, -0.21263467f, -0.68937039f, 
    -0.25169078f, -0.30137917f, 0.25058344f, -0.24202618f, 0.76592064f, -0.40033224f, -1.35934293f, -0.44222605f, 
    -0.21739985f, -0.25834656f, -0.26742440f, -0.27500126f, 0.21105346f, -0.49490982f, -0.57234043f, -0.44827899f, 
    -0.63301909f, -0.33601633f, -0.81911421f, -0.76055080f, -0.17694443f, 0.66164786f, -0.09496161f, -0.34524775f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.67983240f, 0.19094884f, -0.18365833f, 0.57533950f, 0.08576730f, 0.64191425f, 0.29344362f, -0.11340539f, 
    0.16494174f, 0.88552976f, 0.67440289f, 0.51511753f, 0.71354210f, 0.36510968f, 0.12623446f, 0.52724248f, 
    0.11458427f, -0.37752214f, -0.43502215f, 0.00120974f, 0.55820060f, 0.09076805f, -0.01294738f, -0.24643815f, 
    0.26951832f, -0.29216951f, -0.01263193f, 0.41988105f, 0.41284761f, 0.21622497f, 0.24144615f, 0.56654084f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.19588035f, 0.33528098f, 0.17121547f, -0.15464681f, 0.24467474f, 0.04456442f, -0.22007395f, 0.03819175f, 
    0.04337766f, 0.00575895f, 0.50316131f, 0.51433903f, -0.06295449f, -0.09933995f, 0.19264047f, 0.02864951f, 
    0.07634287f, 0.05944548f, -0.79684764f, 0.76046979f, 0.40193266f, -0.03906157f, 0.11452709f, 0.15206015f, 
    -0.02696460f, 0.18789831f, -0.55897164f, -0.09745728f, 0.22799778f, 0.22353695f, -0.07706719f, -0.03731916f, 
    0.28393444f, -0.18950871f, 0.13054153f, -0.09743523f, -0.01158139f, -0.13366576f, 0.08585814f, -0.09311694f, 
    0.04269818f, 0.12707096f, 0.05778313f, 0.09854914f, -0.00393267f, 0.19733205f, -0.03390136f, 0.04980189f, 
    -0.10537432f, -0.06703136f, 0.07618042f, -0.05293302f, -0.09996352f, -0.13562492f, 0.14697628f, 0.07128553f, 
    0.10762615f, -0.14345676f, 0.14123702f, 0.05918251f, 0.05921797f, -0.28616157f, -0.04168395f, 0.07777677f, 
    -0.03118455f, -0.04641484f, 0.21669264f, -0.13730690f, -0.22063707f, 0.15067533f, -0.27602494f, -0.13129856f, 
    -0.52760059f, -0.07093205f, -0.04960071f, 0.08649199f, 0.02892156f, 0.16969329f, 0.15294282f, -0.00374449f, 
    0.24942288f, 0.03496179f, -0.17949882f, -0.16075219f, 0.02914516f, -0.06670683f, 0.07201117f, 0.05757345f, 
    0.21864991f, -0.14566065f, -0.14083198f, 0.14038587f, 0.05787944f, -0.04631456f, 0.00945815f, -0.00985155f, 
    -0.10511364f, -0.02708866f, 0.09906590f, 0.00707277f, -0.02095708f, -0.06363681f, 0.12589625f, 0.26213661f, 
    -0.11448156f, 0.04836618f, -0.10135216f, -0.26918471f, 0.00332522f, 0.28343502f, 0.01269393f, 0.06368146f, 
    0.14207545f, -0.06516452f, -0.05754882f, 0.14112435f, 0.11167574f, 0.01295332f, 0.18184939f, 0.24522653f, 
    0.05843341f, 0.22760102f, -0.05404970f, 0.00865814f, -0.11658630f, -0.22742243f, 0.06550945f, 0.25541523f, 
    0.11328172f, 0.03227919f, -0.05478586f, 0.04678913f, -0.17317894f, 0.10299777f, 0.07125746f, -0.04725854f, 
    -0.09087775f, -0.11024809f, -0.07244398f, 0.02602898f, -0.06736500f, -0.05305340f, 0.02253460f, -0.13211216f, 
    -0.01371360f, -0.11192403f, -0.04942952f, 0.07548437f, -0.04918419f, -0.06213367f, 0.09631798f, 0.13904808f, 
    -0.17399244f, -0.02661022f, -0.17104892f, 0.12881298f, -0.19396344f, -0.02987692f, 0.13012177f, 0.08879980f, 
    -0.06613309f, -0.03168244f, 0.14048794f, 0.03590290f, 0.01493776f, 0.20937058f, -0.04514010f, 0.23830423f, 
    -0.23773262f, -0.09841714f, 0.03319965f, 0.04033532f, -0.33856383f, -0.24404433f, 0.01539753f, 0.09613518f, 
    -0.12173692f, 0.04686430f, 0.19844598f, -0.13931350f, 0.14862187f, -0.03362666f, -0.02184935f, -0.14050457f, 
    0.02311323f, 0.07986575f, 0.17547949f, -0.06307768f, 0.03235637f, -0.04685863f, 0.25807744f, -0.06206938f, 
    -0.07011237f, 0.15023270f, -0.20938200f, 0.06761874f, -0.22221279f, 0.15623201f, 0.30921522f, 0.70389688f, 
    0.09330977f, 0.20738016f, -0.13240395f, 0.08017249f, 0.18679091f, 0.23575585f, -0.14997193f, -0.14703980f, 
    0.19606538f, -0.07776916f, 0.20765460f, 0.00364418f, 0.10297853f, 0.16393983f, -0.06309479f, -0.04074957f, 
    0.13353664f, -0.09724139f, 0.11799721f, -0.07227392f, -0.17679372f, -0.20579329f, -0.10331018f, 0.10542615f, 
    -0.21756123f, -0.00410667f, 0.11391035f, 0.13845916f, 0.10656779f, 0.05534180f, -0.05842425f, 0.01354118f, 
    0.03846722f, -0.08319508f, -0.11309531f, 0.02487927f, 0.37221968f, -0.16233696f, 0.15013503f, 0.33258870f, 
    -0.00648529f, 0.05500967f, 0.24156617f, -0.09344286f, -0.05341341f, -0.07766895f, -0.07915808f, 0.15660511f, 
    -0.00034052f, -0.08666810f, 0.00104640f, 0.13677076f, 0.11497657f, 0.08593939f, -0.21191220f, 0.00484979f, 
    0.11724061f, -0.36710837f, -0.30063295f, -0.13490681f, -0.30804825f, 0.00003890f, 0.17126124f, 0.01371817f, 
    0.01835147f, 0.03810357f, -0.17973873f, -0.04771693f, -0.05344068f, 0.26585057f, -0.27212647f, 0.03986018f, 
    0.17160697f, 0.04344125f, -0.03576359f, -0.11246490f, -0.00242444f, 0.04170406f, 0.10805631f, -0.37016064f, 
    -0.07729266f, 0.03428787f, -0.10352676f, -0.05876576f, -0.02621948f, -0.07152275f, -0.00439121f, -0.31184876f, 
    -0.19661275f, 0.05233436f, 0.10838199f, 0.13473703f, 0.05417001f, 0.24335459f, 0.25700355f, 0.21012980f, 
    -0.14199282f, -0.42832634f, -0.60587484f, -0.38281122f, 0.03862141f, 0.43088338f, 0.19206461f, 0.03385694f, 
    -0.04401552f, 0.10954424f, -0.26805976f, -0.21801445f, -0.07671921f, -0.11581977f, 0.32387853f, -0.50390822f, 
    -0.16122533f, -0.32721967f, 0.08085696f, -0.72886175f, 0.13810988f, -0.19545281f, -0.10307261f, -0.09347452f, 
    0.19366349f, -0.17945158f, 0.05901304f, -0.07426713f, 0.41100350f, 0.18626375f, 0.26523343f, -0.16441594f, 
    -0.23172849f, -0.24226543f, 0.01370069f, -0.12057281f, -0.05799674f, 0.04461328f, -0.14724901f, -0.06437649f, 
    0.18529651f, -0.02365696f, 0.00024041f, 0.12231296f, 0.16806996f, 0.12673765f, 0.31341258f, 0.08192556f, 
    -0.24408016f, 0.00110452f, 0.00991116f, -0.10912497f, 0.11237615f, -0.10737272f, -0.16688272f, -0.14981151f, 
    0.15906030f, 0.11923479f, 0.04431171f, -0.22090243f, 0.06360557f, -0.09115342f, 0.10292780f, 0.21874259f, 
    0.17238687f, 0.30361497f, 0.12894580f, 0.06589296f, -0.05310004f, -0.26275209f, -0.03799239f, -0.20264217f, 
    -0.15003829f, 0.28246546f, 0.21568348f, 0.10859589f, -0.03496670f, 0.04341875f, -0.12520029f, 0.14553885f, 
    -0.00185029f, -0.06282026f, -0.41927209f, -0.24380115f, 0.33453977f, -0.09464961f, -0.11196454f, 0.07477830f, 
    0.17182203f, -0.23128295f, -0.25673351f, -0.30112302f, 0.20031627f, 0.00752367f, -0.14421396f, 0.14495902f, 
    -0.07511850f, -0.04228555f, 0.25309527f, 0.13619283f, -0.14562152f, -0.05963037f, 0.24066149f, 0.01900185f, 
    0.05064286f, -0.23689443f, 0.21532145f, 0.04930891f, -0.14556856f, -0.11584727f, 0.31571963f, 0.42650947f, 
    -0.08849787f, -0.05372984f, -0.17493060f, 0.01889728f, 0.21845958f, 0.07008215f, -0.04675803f, 0.03793996f, 
    -0.43759912f, -0.24264437f, 0.09562355f, -0.15214026f, 0.03821181f, -0.13440861f, 0.05539316f, 0.08306373f, 
    0.45562321f, 0.34321272f, -0.01556345f, 0.18771856f, -0.11250769f, 0.04762185f, 0.06489702f, -0.16782758f, 
    -0.15613647f, 0.27164704f, 0.67294663f, -0.16383509f, -0.50167328f, -0.41794422f, -0.16958947f, 0.23322277f, 
    0.16590007f, -0.06535275f, 0.04420914f, -0.12150601f, -0.06192254f, 0.06214742f, 0.00347856f, -0.00623902f, 
    -0.09965507f, 0.03156098f, 0.08921777f, -0.12165924f, 0.02775103f, -0.03903267f, -0.25418386f, -0.32525274f, 
    0.19851695f, -0.02680079f, 0.08048713f, -0.23604102f, 0.23492453f, -0.28077620f, -0.39263573f, -0.26331720f, 
    0.01467966f, 0.01563569f, 0.09235583f, 0.18096192f, -0.11777167f, -0.00081773f, -0.16498475f, -0.03506501f, 
    -0.15373117f, -0.00227434f, -0.09875291f, -0.50425410f, -0.15800944f, 0.09642784f, 0.15657039f, 0.46080306f, 
    -0.42254019f, -0.15065718f, -0.12067220f, -0.01035122f, 0.01074454f, -0.07460780f, -0.17571111f, 0.08109633f, 
    0.39500737f, -0.05143563f, 0.41205126f, 0.01329565f, -0.20280021f, -0.12981175f, 0.05744613f, 0.28794214f, 
    0.38666975f, 0.23682417f, -0.15879293f, -0.07864946f, -0.01067185f, 0.11070038f, -0.00204228f, 0.12568586f, 
    -0.38156995f, -0.01940241f, 0.13946258f, 0.06213791f, 0.08725072f, -0.21575896f, 0.00702953f, 0.05873332f, 
    0.19559698f, 0.04867194f, -0.03820739f, 0.15764923f, 0.04233748f, -0.00247682f, -0.02835681f, 0.04370396f, 
    -0.07442065f, 0.12288369f, -0.18638931f, 0.04284631f, 0.13285518f, 0.08520420f, 0.04756963f, 0.12141164f, 
    -0.03331876f, -0.01386714f, -0.22200370f, -0.07819150f, 0.10007953f, 0.36001781f, -0.01608952f, -0.04157922f, 
    -0.28917366f, 0.09102854f, 0.09005819f, 0.11036564f, -0.16724938f, -0.29150543f, -0.13446821f, -0.09157510f, 
    -0.16233167f, 0.39209497f, 0.09259257f, 0.15381785f, 0.22615242f, 0.36690634f, 0.50528437f, -0.09153812f, 
    0.00421022f, -0.17790212f, 0.20184873f, 0.10011218f, 0.06719116f, 0.00049192f, -0.19378285f, -0.33977088f, 
    0.04706161f, 0.03246705f, 0.00642429f, 0.07518854f, 0.11233502f, -0.12660278f, 0.10901371f, 0.23761331f, 
    0.07845728f, 0.21550645f, -0.15586567f, -0.12255944f, -0.09824193f, 0.10954934f, -0.07713749f, 0.13785465f, 
    0.07925089f, -0.02444011f, 0.06578413f, -0.15070753f, 0.09697817f, -0.04300383f, -0.04530112f, 0.27058449f, 
    0.10276948f, 0.30380869f, 0.18538596f, 0.05875431f, -0.16158058f, 0.04081691f, -0.00692358f, 0.02665547f, 
    0.23853917f, -0.06331155f, 0.11665902f, 0.12175447f, -0.31072101f, -0.06750090f, 0.07345325f, 0.04052181f, 
    -0.03037653f, 0.07772072f, -0.00053091f, -0.18556859f, -0.08159017f, -0.12911060f, -0.15397172f, -0.12046630f, 
    -0.31831691f, 0.07584022f, -0.25189888f, 0.15976129f, 0.14018846f, -0.01288319f, -0.22585101f, 0.05685543f, 
    0.04307938f, -0.00119084f, 0.07706940f, 0.23950711f, 0.31002650f, -0.39464018f, 0.04770074f, -0.04873810f, 
    -0.18974741f, -0.05643722f, -0.01972253f, -0.23273875f, -0.05849940f, 0.06997139f, 0.14328496f, 0.32121992f, 
    0.11180041f, -0.14122321f, -0.00450204f, 0.02806571f, 0.16398108f, 0.19500348f, 0.26328775f, -0.27903920f, 
    -0.06659561f, 0.00059100f, -0.03138363f, -0.04455623f, -0.02656048f, 0.13121173f, -0.28396407f, -0.35769454f, 
    0.21201740f, 0.11540239f, 0.49150378f, -0.05194521f, 0.16954309f, -0.13489598f, 0.21457800f, 0.21395586f, 
    0.17958660f, 0.09059556f, 0.32162207f, 0.34984308f, -0.13577464f, -0.02259517f, 0.11349443f, 0.15782958f, 
    0.15413360f, 0.16108823f, -0.33569962f, -0.18683091f, -0.03075211f, -0.02059571f, 0.07663143f, -0.14981979f, 
    0.14946887f, 0.03615385f, -0.12669376f, 0.05559450f, -0.12511602f, 0.12701970f, -0.04507050f, -0.07550011f, 
    -0.10359809f, -0.11534599f, -0.13988911f, -0.31270882f, -0.25723213f, -0.23783690f, -0.10871667f, -0.06621447f, 
    0.05703522f, -0.11608828f, 0.15786113f, 0.27494839f, 0.14640142f, -0.52249700f, -0.16254470f, 0.17763342f, 
    0.02644414f, 0.04348724f, -0.05065286f, -0.12034930f, 0.02810698f, -0.32243210f, -0.39131367f, -0.24622881f, 
    -0.23676626f, 0.14257812f, 0.13811561f, 0.05260889f, -0.17458294f, 0.07104550f, -0.12030914f, 0.13580462f, 
    -0.03406269f, 0.10280317f, -0.04995229f, -0.04218321f, -0.05795068f, 0.01015630f, -0.14127067f, -0.04327424f, 
    0.31998861f, 0.04549795f, -0.39408201f, -0.00117171f, -0.02203738f, -0.02846499f, 0.02462174f, 0.12566029f, 
    -0.08714389f, -0.00949574f, -0.16459668f, -0.17903645f, -0.11670265f, 0.01321540f, -0.02417968f, 0.12604275f, 
    -0.00176543f, 0.22540736f, -0.01609142f, 0.05390306f, -0.07047828f, 0.21063064f, 0.06834802f, -0.00858903f, 
    -0.06954556f, -0.09280455f, -0.05592860f, 0.06249852f, -0.41946474f, -0.26738515f, 0.12179238f, -0.08420596f, 
    -0.05340953f, 0.08943129f, -0.20159379f, 0.09478895f, -0.04090464f, -0.10821772f, -0.17180432f, -0.01714016f, 
    -0.03442913f, -0.03138421f, 0.35794458f, 0.14117953f, 0.29827294f, 0.18186472f, 0.17952770f, -0.16124566f, 
    -0.01237796f, 0.01785388f, -0.01279802f, -0.13210057f, 0.11691157f, -0.01030162f, -0.33579314f, 0.26309243f, 
    -0.12287300f, -0.05981578f, 0.07604380f, 0.17133108f, 0.13586374f, 0.30258876f, 0.00906578f, 0.24558598f, 
    0.72660345f, 0.46550292f, -0.04956515f, 0.15295547f, -0.03092659f, 0.05718048f, 0.03669874f, 0.13901445f, 
    -0.48012304f, -0.11320662f, -0.18112297f, -0.02319441f, -0.04971335f, -0.01130659f, 0.03250012f, -0.14275874f, 
    -0.28475899f, 0.48057932f, 0.42661750f, 0.18209375f, 0.05924086f, 0.21417025f, 0.12713300f, 0.01427049f, 
    -0.06478789f, -0.10734905f, 0.05162000f, -0.15332608f, -0.09062922f, -0.20056191f, 0.23240097f, 0.18664932f, 
    0.23742172f, 0.06228064f, 0.15343763f, -0.42295930f, -0.33975688f, -0.18154371f, -0.00007228f, -0.17493431f, 
    -0.12863296f, -0.06463468f, 0.03280691f, -0.21903731f, -0.05460257f, -0.24069203f, -0.18141967f, -0.11170863f, 
    -0.13795304f, -0.08882989f, -0.01110475f, -0.18156283f, -0.42860469f, -0.01313992f, 0.07150926f, 0.12708619f, 
    -0.05416821f, 0.01649509f, -0.09413705f, -0.04587573f, 0.08388187f, -0.02130904f, 0.41975731f, 0.16019212f, 
    -0.01493338f, 0.06984163f, 0.02184658f, 0.10063381f, -0.17371362f, -0.07911022f, -0.09357829f, 0.14399326f, 
    0.31451404f, 0.39490268f, -0.09857775f, -0.02508073f, -0.04762262f, -0.10013611f, 0.03028303f, -0.04523102f, 
    -0.39630461f, -0.07460602f, 0.22156882f, 0.11526219f, 0.11748181f, 0.11940502f, -0.18047203f, 0.00387773f, 
    0.12123325f, -0.40332273f, 0.15826777f, -0.59832650f, -0.25766778f, 0.22367537f, 0.28802207f, 0.21540532f, 
    -0.20738786f, -0.22599253f, -0.00434170f, -0.56881726f, -0.66377759f, -0.10598028f, -0.43375438f, 0.27476457f, 
    -0.07804571f, -0.10720789f, -0.18784554f, -0.58004123f, -0.24337770f, 0.29165411f, 0.03811728f, 0.06197738f, 
    0.04679620f, 0.05326140f, -0.09157975f, 0.11595783f, 0.25361788f, 0.01750141f, -0.12196089f, -0.26888615f, 
    -0.07063285f, 0.12930523f, -0.03095003f, 0.14647219f, 0.13032855f, -0.12106697f, 0.17147611f, 0.21102865f, 
    0.08255706f, -0.02656383f, 0.10983652f, 0.14804281f, 0.24404588f, 0.07020026f, 0.02503023f, 0.42763278f, 
    0.27869084f, 0.05866875f, 0.04073206f, 0.16616783f, -0.02671864f, 0.06179411f, 0.23202629f, 0.11452173f, 
    0.00847898f, 0.16841780f, -0.09225494f, -0.12159742f, -0.19622792f, -0.02337688f, -0.12593360f, 0.21399777f, 
    -0.41332060f, -0.14521505f, -0.46661803f, -0.02304176f, -0.21430150f, -0.04627964f, -0.10069064f, 0.12492453f, 
    0.27488273f, 0.10030878f, 0.10916772f, -0.13212973f, -0.00488151f, -0.04678357f, 0.05472292f, -0.01680713f, 
    0.02270187f, 0.04145377f, 0.26023433f, -0.06855813f, 0.13863891f, -0.09825241f, 0.09559734f, 0.04758066f, 
    -0.09941672f, 0.04187945f, 0.12010601f, -0.19300340f, 0.01210802f, 0.47152707f, 0.09490971f, 0.10109328f, 
    0.07257020f, 0.29526094f, 0.01975639f, -0.02840532f, -0.21239716f, -0.25661099f, -0.04878800f, -0.04405037f, 
    0.00984073f, 0.18568823f, -0.14409876f, 0.07552777f, 0.01683277f, -0.22555706f, -0.05262194f, 0.39008424f, 
    -0.07743755f, 0.00054194f, -0.09939622f, -0.17730953f, 0.29643422f, 0.36268911f, 0.28592026f, 0.04265478f, 
    0.36991438f, -0.37815136f, -0.24043234f, 0.13151664f, 0.10402542f, -0.16460986f, 0.02406056f, -0.01041073f, 
    0.19418547f, -0.27102834f, 0.09699720f, -0.08760213f, -0.13602898f, -0.00296263f, 0.07236777f, 0.05736113f, 
    0.03630490f, 0.00451508f, -0.19661637f, 0.12033436f, -0.10444851f, -0.20545910f, 0.14216164f, -0.02519721f, 
    -0.21840765f, -0.09236003f, -0.04110915f, 0.06885985f, 0.03254846f, -0.07104050f, -0.29389063f, 0.08294389f, 
    -0.19483152f, -0.01711529f, 0.09375682f, 0.06539295f, 0.23308042f, -0.14904088f, -0.12537734f, -0.18627575f, 
    -0.03624062f, -0.04231222f, -0.10352291f, 0.46195930f, -0.05821184f, 0.14823613f, 0.06021119f, -0.01467902f, 
    -0.37421113f, -0.03675328f, -0.05404366f, 0.02028760f, -0.10227588f, -0.12601197f, 0.11502945f, -0.03863175f, 
    0.13730295f, -0.04984879f, -0.02678111f, 0.12358860f, 0.19872874f, -0.02656268f, 0.28139761f, 0.30393577f, 
    -0.05510214f, 0.19428663f, 0.04080706f, 0.16668697f, 0.11575522f, 0.09609585f, -0.98564762f, -0.30581591f, 
    -0.58929002f, -0.57285500f, -0.10312066f, 0.52586865f, 0.39580259f, 0.08171831f, -0.18200976f, -0.00646369f, 
    0.24385223f, 0.05559802f, -0.03560516f, -0.03584290f, -0.08950251f, -0.14395459f, -0.11426538f, 0.10357869f, 
    0.24026017f, 0.08682588f, 0.36508527f, 0.08624264f, -0.51232797f, -0.19512779f, -0.14531627f, -0.00595967f, 
    -0.04231131f, 0.31652340f, 0.52667212f, 0.11378647f, -0.01825468f, 0.00839984f, -0.11442716f, -0.02216133f, 
    0.07420050f, -0.04130605f, 0.02144671f, -0.27668574f, -0.58684015f, -0.07381687f, 0.06826071f, -0.18263924f, 
    -0.05922848f, -0.14478591f, 0.15044491f, -0.10355923f, -0.28433385f, -0.40064403f, -0.03613095f, 0.00428205f, 
    0.24743822f, -0.02612276f, 0.09606746f, 0.17301607f, 0.04672638f, 0.01518823f, -0.06952345f, -0.05939309f, 
    -0.00420749f, -0.09598798f, 0.22474943f, 0.05441624f, -0.12757388f, -0.22059530f, 0.25243011f, 0.43569112f, 
    -0.17542318f, -0.02443280f, 0.02525425f, -0.00898539f, -0.04318024f, 0.04743791f, 0.27477890f, 0.45033112f, 
    0.24061434f, 0.06186892f, -0.06777462f, -0.00472783f, 0.09887423f, -0.06074788f, -0.17239462f, 0.11350142f, 
    0.25595266f, -0.10605833f, 0.09798805f, -0.09817901f, -0.14647619f, 0.01167513f, -0.01890956f, -0.05139295f, 
    -0.03494655f, -0.00541335f, 0.00424530f, -0.06048258f, -0.01417081f, -0.00388292f, -0.02749038f, -0.05324884f, 
    -0.05061279f, -0.01143637f, -0.01173410f, -0.04959112f, 0.03355327f, -0.01663439f, 0.00063893f, 0.04541352f, 
    0.02862942f, -0.00888020f, 0.05469162f, -0.04753792f, 0.04805535f, -0.02761357f, 0.00238443f, 0.03334378f, 
    0.00808572f, -0.01090258f, -0.03899516f, 0.04698712f, 0.02829439f, 0.04530760f, 0.02190975f, 0.03812509f, 
    -0.04380102f, 0.01332558f, 0.00663768f, 0.01664148f, -0.05054636f, 0.05435173f, -0.05498157f, -0.03363274f, 
    -0.04257762f, -0.04907029f, -0.00973695f, -0.03464822f, -0.04623811f, 0.01546341f, 0.04455843f, 0.03009301f, 
    -0.04930656f, 0.03384385f, -0.06175220f, 0.04576831f, -0.00041628f, -0.01304828f, -0.05173760f, -0.02779148f, 
    0.01245456f, -0.04281020f, -0.04527739f, -0.05612318f, -0.01595348f, 0.01300122f, -0.06040198f, -0.05367273f, 
    -0.04912821f, 0.01119614f, 0.00047573f, -0.00471951f, 0.02832746f, 0.04764497f, 0.01244448f, -0.05515503f, 
    -0.03061110f, -0.05345659f, -0.05356889f, 0.05043067f, 0.00086688f, -0.06339008f, -0.03492074f, 0.02946137f, 
    -0.02348208f, -0.02359540f, -0.03502458f, -0.03534868f, 0.00722895f, 0.05067783f, -0.00291674f, 0.03994097f, 
    -0.02324920f, -0.00652389f, -0.01216497f, 0.01454403f, 0.02328180f, 0.01151946f, -0.05202011f, -0.02916069f, 
    -0.02159627f, -0.02580143f, -0.05554745f, -0.00136794f, 0.00291971f, -0.04837866f, 0.02664932f, 0.00534317f, 
    0.02282812f, -0.05232754f, -0.04375796f, 0.02380469f, -0.00271594f, -0.01963698f, 0.00319093f, 0.00179872f, 
    -0.04801487f, 0.00964902f, -0.02236270f, -0.04855284f, 0.00930288f, -0.05301242f, -0.03620370f, -0.03467605f, 
    -0.03862537f, -0.03817074f, -0.05291198f, -0.06189477f, 0.00932143f, -0.06204494f, -0.06243384f, -0.00627306f, 
    0.03031688f, 0.03086737f, 0.05014535f, 0.04766935f, -0.02960310f, -0.04547914f, -0.05803472f, 0.02677380f, 
    0.05033483f, 0.04678811f, -0.00947259f, -0.00566524f, 0.00148986f, -0.06191511f, -0.05914683f, -0.03487569f, 
    -0.03617036f, -0.02644832f, 0.01608453f, -0.00834695f, -0.00727598f, 0.00854177f, -0.00378399f, 0.03670886f, 
    0.04623877f, 0.05248178f, -0.02277624f, 0.00892431f, 0.01083346f, -0.04414784f, -0.02686242f, -0.00077504f, 
    -0.01951607f, -0.01499323f, -0.00192504f, -0.01845269f, -0.02399146f, -0.02691923f, -0.00049766f, 0.02492150f, 
    -0.05507072f, -0.01009282f, -0.05474959f, 0.02094052f, -0.03891000f, -0.01328472f, -0.05571939f, -0.03588759f, 
    0.02332839f, 0.01526210f, -0.05734505f, -0.01346499f, 0.02620926f, -0.03789980f, -0.05333773f, -0.02382613f, 
    0.03873099f, -0.04517654f, 0.00100571f, -0.05794416f, -0.02447036f, 0.00545665f, 0.01745478f, -0.02515783f, 
    0.03619881f, 0.01584170f, 0.04433522f, 0.01772932f, -0.03968171f, 0.01903196f, 0.01706449f, 0.02839512f, 
    0.02190083f, -0.05041639f, -0.00807708f, 0.03999993f, -0.01899000f, -0.00380230f, -0.02066672f, -0.01821792f, 
    0.00876992f, -0.01609129f, 0.00684080f, -0.05413491f, 0.01184493f, -0.06185119f, -0.02830518f, -0.05354202f, 
    -0.00687816f, -0.00559801f, -0.03513628f, 0.02671489f, -0.03763092f, -0.00833654f, -0.02521492f, -0.00964179f, 
    -0.00765394f, -0.01287612f, -0.03125576f, -0.05113420f, -0.06352263f, 0.01150697f, 0.01731768f, 0.02953273f, 
    -0.05728003f, -0.05684229f, 0.00146123f, -0.05804095f, 0.03634307f, -0.05949616f, -0.03191581f, -0.02958034f, 
    0.02402707f, 0.05331411f, 0.01368243f, 0.00762310f, -0.06199780f, 0.03350896f, 0.03078518f, 0.03762425f, 
    -0.02882028f, -0.03747963f, 0.04856014f, -0.02293634f, 0.02956418f, 0.04196272f, -0.05395198f, -0.03115712f, 
    0.02460621f, -0.00679811f, -0.03423654f, 0.01547511f, -0.01495313f, 0.00224363f, -0.03958193f, -0.04845213f, 
    -0.01925059f, 0.01950398f, -0.02810886f, 0.04206183f, 0.03956576f, -0.00297767f, 0.03509720f, -0.00581502f, 
    0.03422963f, -0.05707620f, 0.02424498f, -0.02064410f, 0.03598668f, 0.01448200f, 0.03187323f, 0.03494637f, 
    -0.05817072f, -0.06215326f, -0.02671290f, -0.04432426f, 0.01113174f, 0.03923562f, -0.01646877f, 0.01875206f, 
    -0.00642421f, -0.02717752f, -0.05692409f, -0.05018397f, 0.00570839f, 0.04146346f, -0.00331977f, 0.00669172f, 
    -0.04202064f, -0.00278208f, 0.02917567f, -0.00435331f, -0.02216087f, -0.05784508f, 0.01967482f, -0.03279204f, 
    -0.01485496f, -0.02017459f, -0.03646152f, 0.04994158f, 0.02165730f, 0.04507231f, -0.02391086f, -0.05438899f, 
    -0.05623531f, -0.00964231f, 0.01117922f, -0.05920512f, 0.03520103f, 0.00072368f, 0.00398440f, -0.03204126f, 
    0.00127519f, 0.02349198f, -0.03310772f, 0.01166635f, 0.04087940f, 0.04923029f, -0.05538629f, -0.04428916f, 
    -0.04461767f, -0.04265405f, 0.03621219f, 0.00373943f, -0.05482692f, 0.01956915f, 0.00055550f, -0.03043951f, 
    0.01200295f, -0.05604530f, 0.02149748f, 0.00378491f, -0.01099686f, -0.01827387f, -0.04170250f, -0.02710217f, 
    0.04501832f, -0.01701820f, 0.00489116f, -0.00693449f, -0.01119108f, 0.00946768f, -0.06267907f, 0.00925671f, 
    0.02956550f, -0.05307514f, -0.04149096f, 0.02383520f, -0.01768109f, 0.04675077f, 0.04052124f, -0.00049226f, 
    0.00359841f, 0.03900369f, 0.04784792f, -0.05899310f, 0.01627986f, -0.02404309f, -0.00340131f, 0.02559355f, 
    -0.04286387f, -0.03822902f, -0.01836078f, 0.03717226f, -0.04724843f, -0.01850736f, 0.00246189f, 0.00727288f, 
    0.03639250f, 0.04402901f, -0.01092231f, -0.00249729f, 0.03596950f, -0.04162194f, -0.02095003f, 0.01473101f, 
    -0.02061480f, -0.03698896f, 0.00801035f, 0.01595237f, 0.01549156f, -0.05751183f, -0.03969637f, 0.03190810f, 
    -0.03878022f, -0.01955383f, -0.02404466f, -0.00443722f, 0.00909549f, -0.02686736f, 0.00622262f, 0.00179156f, 
    -0.01461142f, -0.01523246f, -0.00014458f, 0.00165931f, -0.05734155f, -0.05865442f, 0.02984500f, -0.06003417f, 
    -0.01994293f, -0.06205632f, 0.03189541f, -0.01801406f, -0.02704518f, 0.03757411f, 0.00395770f, -0.01958367f, 
    0.02582386f, -0.04610615f, -0.06017766f, 0.02239297f, 0.03915733f, 0.04241920f, 0.03848352f, 0.01054544f, 
    0.02620265f, 0.04822858f, -0.04623260f, -0.01226552f, 0.01392832f, -0.06623343f, 0.04574110f, 0.01449033f, 
    -0.03695315f, -0.03498169f, 0.02570480f, -0.05895991f, -0.06482010f, -0.00114230f, -0.02880680f, 0.00523008f, 
    0.01435920f, 0.04892702f, -0.05004573f, 0.03573309f, 0.02475790f, -0.04747970f, -0.02836775f, -0.00905246f, 
    0.01872087f, -0.04597987f, 0.02393043f, -0.05679320f, 0.04420055f, 0.03455133f, 0.04405664f, 0.03313766f, 
    -0.02796703f, -0.00523106f, 0.01250234f, -0.03482048f, -0.02196508f, 0.03119833f, 0.02795366f, -0.02502127f, 
    0.02377228f, 0.00556679f, 0.03449814f, 0.02306589f, -0.02296378f, -0.03431559f, -0.02750912f, -0.04816874f, 
    0.04235223f, -0.01038704f, -0.06725750f, -0.00727906f, -0.03455821f, 0.02313895f, -0.03654845f, -0.01215493f, 
    0.02227465f, -0.03333093f, -0.03724496f, 0.01990874f, -0.05928618f, 0.01448103f, 0.01827395f, 0.03366654f, 
    0.04887156f, 0.02784252f, -0.03950463f, 0.03193291f, -0.03670033f, 0.00286634f, -0.03811902f, -0.05771979f, 
    -0.02558294f, 0.00464945f, -0.06196126f, -0.00602498f, -0.03849629f, -0.02637991f, -0.02010438f, -0.06811377f, 
    0.03253146f, 0.02129523f, 0.03768818f, 0.01680963f, 0.00308323f, 0.02501099f, -0.06603269f, 0.03285274f, 
    0.02734672f, -0.00397407f, 0.00925235f, 0.03838594f, -0.04864830f, -0.06632913f, 0.03017000f, 0.01931253f, 
    -0.06309445f, -0.04167378f, -0.02842195f, -0.00373601f, -0.00238810f, -0.06102750f, 0.03001375f, -0.04549295f, 
    0.04095929f, -0.03703911f, -0.05648144f, 0.02113794f, 0.04408042f, -0.03396397f, -0.01643314f, 0.02682753f, 
    0.01135538f, 0.00435096f, -0.06396864f, 0.04447939f, 0.01790804f, -0.04996907f, 0.03579148f, -0.01987457f, 
    -0.03873403f, 0.00326038f, 0.01833123f, -0.03492094f, -0.04060201f, 0.02552986f, -0.06354100f, -0.01388937f, 
    0.03642650f, -0.02779849f, -0.04616967f, 0.02817904f, -0.00372903f, 0.04001214f, -0.00414982f, -0.02642778f, 
    0.00292961f, -0.01268995f, 0.00779406f, 0.03456507f, 0.01795455f, 0.00939233f, -0.03200648f, -0.05180548f, 
    -0.03461376f, -0.04848573f, 0.00608486f, -0.00870723f, -0.05461591f, 0.01921957f, -0.05996077f, 0.01845917f, 
    -0.03811040f, -0.31926319f, 0.06349391f, 0.10834368f, 0.04704356f, 0.05481804f, -0.12034900f, 0.07431849f, 
    0.14666128f, 0.16066408f, -0.79661638f, 0.23075785f, 0.17828333f, 0.04706081f, -0.04011979f, 0.08566032f, 
    0.14216150f, 0.32673040f, 0.17614473f, 0.06957182f, 0.23724405f, 0.03600411f, 0.05914323f, 0.06165484f, 
    0.06760919f, 0.31770474f, -0.08826400f, 0.41750509f, -0.14934687f, -0.00010591f, 0.04829634f, 0.06643848f, 
    -0.11447939f, -0.07002369f, 0.06962299f, -0.37768072f, -0.12711304f, -0.33389753f, 0.13265766f, -0.17354566f, 
    0.26493651f, 0.09844699f, 0.06611129f, -0.12392472f, -0.10885298f, 0.06907592f, 0.16427061f, 0.09170339f, 
    -0.07148361f, -0.01899603f, -0.18353726f, -0.00681025f, 0.23951474f, 0.15619349f, -0.29272342f, -0.27786064f, 
    -0.14634264f, -0.04957018f, 0.03623257f, -0.01597350f, -0.06888713f, 0.05276650f, -0.23257424f, 0.07957894f, 
    0.16600935f, 0.02466100f, -0.15207559f, 0.15053891f, -0.15492569f, 0.00880002f, 0.07423694f, 0.04604126f, 
    -0.12207779f, -0.05284584f, 0.28650406f, 0.12524600f, 0.03385177f, -0.01392386f, -0.13436124f, -0.18804108f, 
    0.01452051f, -0.36981523f, -0.19025156f, 0.00724425f, -0.09232520f, 0.25667554f, 0.01348261f, -0.00041130f, 
    0.12751499f, -0.11715143f, 0.03306111f, 0.16668291f, -0.22002994f, -0.00145535f, -0.16811903f, 0.00351618f, 
    0.14783463f, -0.11276069f, 0.01003455f, 0.25835568f, -0.14787129f, -0.46066391f, 0.03971303f, 0.00289417f, 
    0.01703624f, 0.06309754f, 0.02825783f, 0.30449247f, 0.27177164f, 0.31647152f, -0.13952391f, 0.00489203f, 
    -0.00294865f, -0.10478340f, 0.02288059f, 0.08393157f, 0.01239632f, 0.09675729f, 0.25756478f, -0.12037996f, 
    0.01960872f, 0.07394284f, -0.16583559f, -0.06560287f, 0.20315205f, 0.21336947f, 0.27255750f, 0.05307643f, 
    -0.43751097f, -0.29920718f, 0.12035452f, 0.13834754f, 0.04891904f, 0.05520420f, -0.10640459f, -0.13046642f, 
    -0.01283921f, 0.36542401f, 0.07656984f, 0.03090921f, -0.04004361f, 0.33229116f, -0.05801684f, 0.55229467f, 
    -0.41581672f, -0.54173213f, -0.55642653f, 0.06470228f, 0.22931662f, 0.21569659f, -0.04863572f, 0.00380628f, 
    0.02571732f, -0.18242939f, -0.19809896f, 0.03660240f, -0.51064712f, 0.02996856f, -0.17265105f, 0.15118690f, 
    0.06687605f, -0.14963108f, 0.21981488f, 0.12445184f, -0.11164555f, -0.57236439f, -0.21478988f, -0.26280254f, 
    0.09259064f, 0.02896376f, 0.08513589f, -0.38919774f, -0.35413069f, 0.21007876f, -0.25413275f, 0.29629794f, 
    -0.06858944f, 0.06028368f, 0.02788933f, -0.07974042f, 0.10584087f, -0.02392366f, -0.06077719f, -0.41924167f, 
    -0.03793656f, -0.02113167f, -0.03326897f, 0.09403489f, -0.14458616f, -0.35221782f, -0.30276808f, 0.21985444f, 
    0.11781640f, -0.14787869f, 0.22879173f, -0.07173386f, -0.11108199f, -0.14646687f, 0.67015111f, -0.34931961f, 
    0.10352643f, 0.09685481f, 0.30093738f, -0.01392654f, -0.14577021f, 0.27356946f, 0.08860154f, -0.27646625f, 
    -0.01514203f, 0.03810632f, -0.09753881f, 0.03907558f, -0.09563597f, -0.00323675f, -0.01341417f, 0.12166450f, 
    -0.20153458f, 0.14845988f, 0.01453421f, -0.13186111f, 0.15565616f, -0.01946945f, 0.11203226f, 0.33912238f, 
    0.12814212f, 0.10944384f, -0.02097418f, -0.06658268f, -0.03867278f, -0.04343745f, 0.06175274f, -0.11463433f, 
    -0.19589452f, 0.40193814f, -0.42375177f, 0.18518920f, 0.09361114f, -0.14075641f, 0.06075615f, -0.11694860f, 
    0.16162974f, -0.00484125f, -0.09668624f, 0.18720916f, 0.03532936f, 0.07548468f, -0.07412167f, 0.13185455f, 
    -0.03085742f, -0.00695451f, -0.08777383f, 0.21877001f, -0.28409037f, 0.05322895f, 0.07837364f, 0.05650312f, 
    0.13120966f, 0.20695633f, -0.08353999f, 0.05999096f, 0.42558420f, 0.24269098f, -0.36588553f, -0.06589531f, 
    0.10950383f, -0.00476612f, -0.00272430f, 0.11523229f, -0.13180125f, -0.08242501f, 0.26286736f, -0.16461243f, 
    -0.08297630f, 0.05239438f, -0.08664705f, 0.08018249f, -0.19459057f, -0.08782306f, 0.31914046f, 0.04037552f, 
    -0.30344090f, 0.29551953f, -0.04525580f, 0.02775785f, 0.01152955f, -0.02705236f, 0.14523853f, 0.23241727f, 
    0.12316731f, -0.18997833f, -0.04299524f, -0.04966204f, 0.26085770f, 0.05011412f, -0.04358568f, 0.11518894f, 
    0.13949008f, 0.20840241f, -0.20108478f, -0.24746028f, -0.15983170f, 0.08280084f, 0.21551852f, 0.05207896f, 
    0.06989618f, 0.12923175f, 0.54450506f, -0.15203358f, -0.16209635f, -0.02689962f, -0.24197619f, -0.48098621f, 
    0.08642052f, 0.29150519f, 0.06531977f, 0.20116185f, -0.09708060f, -0.21479024f, -0.08519046f, 0.07958132f, 
    0.23058254f, 0.09518444f, -0.04999524f, 0.21288925f, 0.19579962f, 0.09685536f, -0.18197377f, -0.10568817f, 
    0.23873739f, -0.14389481f, 0.05997792f, 0.00809540f, -0.01613546f, -0.07993971f, 0.08148319f, -0.09253834f, 
    -0.16334084f, -0.12212954f, 0.10332247f, 0.17968051f, 0.25083876f, -0.05128332f, 0.68999237f, -0.05247924f, 
    0.06791186f, 0.19242731f, 0.11899387f, -0.20372921f, -0.00491486f, -0.02704254f, 0.11273555f, -0.03505833f, 
    0.03198369f, -0.15330769f, -0.09065416f, -0.19722569f, -0.23651946f, 0.05281845f, -0.01057349f, -0.08677465f, 
    -1.64874065f, -0.37002680f, 0.44505751f, 0.05681787f, -0.03180726f, -0.12410034f, 0.09270720f, 0.14791238f, 
    0.19135736f, -0.21806896f, -0.25795618f, 0.41849065f, 0.14964068f, 0.17218094f, -0.28574708f, -0.04913350f, 
    0.03603882f, 0.18283060f, 0.29636836f, 0.23502202f, -0.02591505f, -0.06953784f, 0.09625762f, -0.02451244f, 
    0.07099844f, -0.00201252f, -0.19421968f, 0.14178099f, 0.27351019f, 0.08649213f, 0.03322925f, 0.12430337f, 
    0.02539466f, 0.03312436f, 0.15296152f, -0.07337541f, -0.05139489f, 0.01043259f, -0.06292887f, 0.05631019f, 
    -0.11025921f, -0.14021964f, 0.23762746f, 0.05701122f, 0.07311411f, -0.04611968f, 0.08069835f, 0.25293934f, 
    -0.12888935f, -0.09513804f, -0.23361714f, -0.04730984f, 0.27369788f, 0.36029989f, 0.25161359f, 0.08034291f, 
    -0.21505511f, -0.13545425f, -0.06994314f, -0.07104227f, 0.10963289f, 0.14666966f, 0.11725999f, -0.23847562f, 
    0.18905067f, 0.13080347f, 0.17764470f, 0.01193682f, 0.13463405f, 0.15811992f, 0.17067659f, 0.16038193f, 
    0.00202588f, 0.22056042f, 0.33354616f, -0.33107921f, 0.25548357f, -0.19483306f, -0.00422408f, -0.07011349f, 
    -0.07563957f, -0.02888334f, -0.65176558f, -0.64426643f, -0.12589791f, -0.07530593f, 0.08825707f, -0.01457945f, 
    -0.16213410f, 0.12029050f, -0.13393283f, -0.11998365f, -0.23754191f, -0.33077487f, -0.25050652f, -0.15044387f, 
    -0.00353996f, -0.11875281f, -0.27151054f, 0.18653004f, -0.04338676f, -0.47021997f, -0.10067209f, -0.12106328f, 
    0.22021055f, -0.16288668f, -0.21194932f, 0.13603504f, -0.29551935f, -0.29768962f, -0.09752007f, -0.00580937f, 
    0.00892427f, 0.11255212f, 0.10663340f, -0.09853183f, 0.27687195f, 0.36736223f, 0.33802718f, 0.28460675f, 
    -0.17949116f, -0.28345591f, -0.21349679f, 0.10167538f, -0.04338229f, -0.09182529f, 0.12311252f, -0.15854561f, 
    -0.20055947f, -0.07582572f, 0.20172577f, 0.59777868f, 0.04762927f, -0.08922312f, 0.03900248f, -0.31801149f, 
    -0.69556487f, -0.03057796f, 0.08472329f, 0.04300017f, -0.17550758f, -0.13286038f, 0.00928601f, 0.02127186f, 
    0.14747496f, -0.01148553f, 0.12335504f, -0.04157984f, -0.17501016f, -0.34308675f, -0.02695703f, 0.14272624f, 
    0.29431194f, -0.22402045f, -0.16551174f, -0.07410362f, -0.12745036f, -0.11444143f, -0.12751551f, 0.12469128f, 
    0.08448651f, -0.03932015f, 0.16257787f, -1.07760918f, -0.25442991f, 0.18276601f, 0.03467853f, -0.05009466f, 
    0.01405811f, -0.17990060f, 0.10841523f, -0.31057602f, 0.11769300f, -0.29913577f, -0.06275791f, -0.16522551f, 
    -0.06824289f, 0.10557199f, 0.18401493f, 0.14222899f, 0.03305690f, -0.08659084f, -0.10705895f, 0.15562356f, 
    -0.03777533f, 0.11725957f, 0.02875598f, -0.06204296f, -0.11926604f, 0.59172249f, 0.38709465f, -0.12557918f, 
    -0.03955103f, 0.05548688f, 0.05964961f, -0.09946984f, 0.22648335f, -0.02619258f, 0.14763644f, -0.35540849f, 
    -0.23811527f, -0.11560559f, -0.02470886f, 0.09778490f, -0.04942519f, -0.02960299f, -0.13444737f, -0.35535428f, 
    -0.66105741f, -0.33969110f, -0.01495100f, 0.03094466f, 0.12016946f, 0.01314908f, 0.12620367f, 0.02186500f, 
    0.38655549f, 0.17923811f, 0.43545756f, 0.32365143f, 0.17498867f, 0.24078719f, -0.09250893f, 0.09438957f, 
    0.37635991f, -1.16061747f, -0.13536867f, -0.63043630f, -0.07479320f, -0.07547609f, 0.62394762f, 0.23494710f, 
    0.03720061f, 0.03071530f, -1.87177324f, -0.57689852f, -0.07140044f, -0.05809324f, 0.46487549f, -0.36703080f, 
    0.12139338f, -0.15705720f, 0.11607768f, 0.11955395f, 0.44913766f, -0.04512566f, 0.16855402f, 0.25335792f, 
    0.14542566f, 0.35337871f, 0.25254083f, 0.20011425f, -0.37408867f, -0.08453538f, 0.02775562f, 0.03216090f, 
    -0.22299558f, -0.14231925f, -0.06111473f, 0.03059833f, -0.17548895f, 0.11951822f, 0.08277256f, -0.07144650f, 
    0.01625681f, -0.31873918f, 0.12475258f, 0.08801695f, 0.23111625f, 0.12301362f, -0.24069919f, 0.11671817f, 
    0.08786780f, -0.02260304f, 0.00325255f, 0.00050639f, 0.10453895f, -0.14559115f, -0.05433970f, -0.19584304f, 
    0.00059752f, -0.05072106f, -0.31633055f, -0.24726056f, -0.14618488f, 0.04223896f, 0.03747558f, -0.02446094f, 
    -0.15337011f, -0.47629243f, -1.10845780f, 0.04029178f, -0.11219410f, 0.07792431f, -0.00605953f, -0.00727879f, 
    -0.02505215f, 0.07648643f, 0.30735162f, 0.24807078f, 0.29330134f, 0.19639815f, 0.09156919f, 0.01111191f, 
    0.08645324f, 0.00751695f, 0.29511198f, -0.01894614f, 0.32159853f, -0.09253462f, 0.12930083f, 0.11688086f, 
    0.09398394f, 0.17609967f, -0.10782190f, -0.11930594f, 0.14267984f, 0.08930652f, 0.01647385f, 0.30154410f, 
    0.04661847f, 0.20836677f, 0.29215014f, 0.61233836f, 0.27273974f, -0.13345920f, -0.03997149f, 0.14872913f, 
    -0.02539813f, -0.14895825f, 0.04480405f, 0.12793691f, -0.07271566f, -0.10918435f, -0.13598862f, 0.13080828f, 
    0.05147763f, 0.01416676f, -0.19476777f, 0.03400782f, -0.01788453f, 0.15621699f, -0.37546685f, 0.00953883f, 
    -0.03731265f, -0.01141177f, 0.17557178f, -0.13896735f, 0.21826293f, 0.03378886f, -0.03235883f, -0.58858079f, 
    -0.74422449f, -0.58461696f, 0.24486846f, 0.10550074f, 0.19948976f, 0.20160986f, -0.04697734f, 0.01770055f, 
    0.27427945f, 0.03392433f, 0.31526849f, 0.07222506f, -0.13540879f, -0.28609997f, -0.08559640f, 0.01442694f, 
    0.18678215f, 0.03364659f, 0.08622526f, -0.23303188f, 0.09550549f, 0.02118541f, 0.16738871f, 0.05191423f, 
    0.07644454f, -0.16155790f, -0.16688310f, -0.12704736f, -0.09214087f, -0.04332320f, -0.06813536f, -0.10904080f, 
    -0.17912990f, 0.11953624f, -0.17332512f, 0.03966427f, -0.08198365f, 0.08541659f, -0.09027550f, -0.27246982f, 
    0.16493222f, -0.00652652f, -0.07283909f, -0.01852835f, 0.14232954f, 0.07039722f, -0.09212241f, 0.21075860f, 
    0.09888724f, 0.11177395f, 0.13958110f, 0.27925578f, -0.04783755f, 0.00196266f, 0.14400770f, 0.25126654f, 
    -0.13123737f, -0.65391845f, -0.25801557f, -0.17239940f, -0.06633153f, 0.06448178f, -0.68658745f, -0.06367224f, 
    0.64352041f, 0.22756350f, 0.05567010f, 0.63706225f, 0.14658426f, 0.03681920f, -0.01586872f, -0.26208463f, 
    -0.12204881f, -0.30022049f, -0.30654126f, -0.29245660f, -0.08197507f, -0.01899613f, -0.05231710f, -0.08884168f, 
    0.19423063f, -0.09919066f, 0.01820019f, -0.04632655f, 0.06500361f, 0.18140885f, -0.05908991f, 0.18474074f, 
    0.11929587f, 0.07343185f, -0.40976703f, -0.72863781f, -0.10115522f, 0.03087962f, 0.05421043f, 0.00603292f, 
    0.05597552f, 0.08146529f, 0.31157324f, 0.12052611f, -0.08638385f, 0.18188103f, 0.27057159f, 0.26795721f, 
    -0.09130812f, -0.00093986f, -0.05618513f, -0.04599699f, -0.18833117f, 0.36077750f, -0.00254022f, -0.11314075f, 
    0.03680313f, 0.17159861f, 0.08492231f, -0.01225211f, 0.47110337f, 0.17189424f, -0.10543320f, -0.06239094f, 
    -0.23751999f, 0.12981416f, 0.04789593f, 0.11830059f, 0.46402961f, -0.28207210f, -0.00617485f, -0.04869394f, 
    0.08084060f, -0.28773952f, -0.03806923f, 0.06903652f, 0.14497361f, 0.10546417f, -0.21100999f, -0.45853436f, 
    -0.41873115f, -0.10013661f, 0.01083930f, 0.19320911f, 0.07683422f, 0.09963465f, 0.10910583f, -0.52990401f, 
    0.04664120f, 0.23765816f, -0.07279389f, -0.21369974f, 0.16998722f, 0.10180245f, 0.18785347f, -0.02151549f, 
    0.00088760f, 0.00634498f, -0.06404779f, -0.06400786f, 0.02697417f, 0.02978703f, 0.03263444f, -0.00920310f, 
    0.04643884f, -0.02783747f, 0.01813783f, -0.04614542f, -0.06461024f, 0.02290804f, -0.02406785f, -0.01303592f, 
    -0.01712367f, -0.01414089f, -0.04752272f, 0.06451605f, 0.00207946f, 0.03106044f, 0.00330910f, 0.02085791f, 
    -0.00153811f, 0.02800891f, 0.04573665f, -0.02275160f, 0.01608192f, -0.03490138f, 0.04381400f, -0.00421205f, 
    -0.04551639f, -0.01724682f, -0.01168771f, 0.01966416f, 0.02631428f, -0.00901985f, -0.03974026f, -0.05551008f, 
    -0.01664731f, 0.01119646f, 0.00243712f, -0.05182382f, -0.03564379f, -0.06461728f, -0.05326999f, -0.04865641f, 
    0.03553522f, 0.04702183f, -0.00737641f, 0.00223350f, 0.00138056f, -0.02347322f, -0.00198509f, -0.01895353f, 
    -0.06358887f, 0.03361729f, -0.05108913f, -0.03228062f, -0.06213833f, -0.05167934f, 0.02157805f, 0.00723162f, 
    0.03879049f, 0.01812078f, 0.03021574f, 0.01825518f, 0.00094634f, -0.00258571f, -0.03456195f, -0.00332069f, 
    0.03541774f, -0.05582861f, -0.02060853f, 0.05205976f, -0.02701907f, 0.01219873f, -0.06177323f, 0.03261954f, 
    -0.04414705f, -0.01442171f, 0.02179394f, -0.00016778f, 0.04529605f, 0.00680219f, 0.05018141f, -0.02301122f, 
    0.01766941f, 0.02941552f, -0.03454726f, 0.01730334f, 0.01072628f, 0.00687933f, 0.01653415f, 0.03868245f, 
    -0.01291752f, 0.02751048f, 0.03789314f, -0.05367083f, -0.05193203f, 0.03205702f, 0.00172769f, -0.01522361f, 
    0.01486177f, -0.00384372f, 0.02994931f, 0.01997393f, -0.01675409f, -0.03774561f, 0.01574134f, -0.05073842f, 
    -0.04198851f, 0.03312309f, 0.03998760f, -0.03510123f, -0.04637430f, -0.00019575f, -0.07062191f, -0.01715930f, 
    -0.01474111f, -0.05232147f, 0.02373011f, -0.01541719f, 0.01576376f, -0.02317842f, 0.01233247f, -0.00574049f, 
    -0.02068586f, 0.00785611f, -0.03014235f, -0.01227988f, 0.01016653f, -0.05098864f, 0.02462361f, -0.04155937f, 
    -0.02578402f, -0.04564599f, -0.05602637f, -0.05868952f, -0.00191154f, -0.01304018f, 0.01284021f, -0.00351251f, 
    -0.00005202f, 0.01961957f, 0.04699231f, -0.05662150f, -0.02683559f, -0.01335214f, -0.04544787f, -0.03176264f, 
    -0.03249789f, 0.01309845f, -0.01402117f, -0.02709639f, 0.03300679f, -0.05922358f, 0.04533406f, -0.04201329f, 
    0.02023250f, -0.00433294f, 0.03361591f, -0.06851699f, 0.03099854f, -0.03934090f, -0.03874718f, -0.02645344f, 
    -0.05930096f, -0.01320700f, -0.03070589f, 0.00691300f, -0.00263819f, -0.05663652f, -0.05688985f, -0.02838558f, 
    -0.00604662f, -0.01945751f, -0.06633078f, -0.04548747f, 0.01670451f, -0.01886973f, -0.03296539f, 0.00550580f, 
    0.02358305f, 0.00197648f, 0.02808874f, -0.04269835f, -0.03907534f, -0.01228563f, -0.01910089f, -0.02290098f, 
    0.00074595f, -0.03344634f, -0.00490215f, -0.04161972f, 0.05076925f, 0.00052500f, 0.00625252f, 0.03112463f, 
    -0.00602054f, 0.01323998f, -0.00260295f, -0.05722031f, -0.01416193f, 0.00843170f, 0.02014857f, -0.03693311f, 
    0.01233436f, 0.03735162f, -0.05133535f, 0.00127306f, -0.00902294f, 0.03730854f, -0.06276588f, 0.04432319f, 
    0.01113496f, -0.06862575f, -0.05859929f, -0.06226148f, 0.03377095f, 0.04180542f, 0.04309515f, -0.01419080f, 
    -0.03447055f, -0.00481935f, -0.02528607f, -0.03274685f, -0.03701768f, -0.01841841f, -0.04838311f, 0.02155204f, 
    -0.04621341f, 0.01627353f, -0.00409955f, 0.01420802f, 0.03516588f, 0.00931413f, -0.04432634f, -0.00025895f, 
    -0.02016452f, -0.00925892f, -0.03477590f, -0.06286047f, 0.00274539f, -0.04666135f, 0.01395545f, -0.00986129f, 
    -0.06511138f, 0.03633457f, -0.02623355f, 0.02638204f, -0.05774349f, 0.02617160f, -0.01304833f, 0.01172353f, 
    0.04268145f, -0.04311063f, 0.03216942f, -0.02947093f, 0.04533820f, -0.01007504f, -0.00151763f, -0.04827652f, 
    -0.01130507f, -0.00493738f, -0.04260205f, -0.04150255f, 0.04965099f, -0.03095154f, -0.03093635f, 0.00406612f, 
    0.04562585f, -0.06441920f, -0.01499623f, -0.01749565f, -0.00004997f, 0.03512446f, -0.01202374f, -0.04707363f, 
    -0.05584558f, 0.05669308f, -0.03516014f, 0.03134173f, -0.02367992f, 0.01643890f, -0.04551063f, 0.01762024f, 
    -0.05417930f, -0.05366821f, -0.07657616f, 0.00858070f, -0.05270745f, -0.02090538f, -0.01955297f, -0.05512295f, 
    0.00031957f, -0.07392833f, -0.07104369f, -0.03864993f, -0.02150813f, -0.03196578f, -0.06009246f, 0.00137015f, 
    -0.05632921f, -0.02820115f, -0.08082645f, 0.00314860f, 0.00960838f, 0.02298286f, 0.01113755f, -0.01982428f, 
    -0.07956430f, -0.03463593f, 0.03207302f, -0.04636319f, 0.00302017f, -0.08376592f, -0.01036298f, -0.06931639f, 
    -0.04163836f, 0.00159588f, -0.03818366f, -0.01072507f, -0.01743775f, 0.02525151f, 0.02701282f, -0.05984983f, 
    -0.02869799f, -0.08056544f, 0.01257716f, 0.02948262f, -0.04995167f, -0.03722497f, 0.00714460f, -0.05652890f, 
    -0.03988138f, -0.06574024f, -0.00692060f, -0.00852509f, -0.07270113f, -0.07230911f, -0.07629552f, 0.00915850f, 
    -0.05403684f, 0.00082443f, -0.04141425f, 0.01169626f, -0.05896590f, -0.05494241f, -0.05126604f, 0.02791905f, 
    0.01247759f, -0.06938211f, -0.03287306f, -0.05461790f, -0.02381393f, -0.06884869f, -0.05793609f, -0.05623020f, 
    0.10117490f, -0.03018345f, -0.02009933f, -0.05102615f, 0.02470991f, 0.03075680f, -0.04703818f, -0.07046364f, 
    -0.00799137f, -0.05586919f, -0.08215473f, 0.00288879f, -0.05113208f, -0.01992609f, -0.08419877f, -0.03720130f, 
    -0.05741580f, -0.01685117f, 0.01649870f, -0.02496864f, -0.01934029f, 0.00232851f, -0.01075550f, 0.00555337f, 
    0.03137258f, -0.00914442f, -0.06299887f, 0.02403598f, 0.03095062f, 0.02853585f, -0.07285219f, -0.02319060f, 
    -0.00812627f, -0.04490765f, -0.05089363f, -0.02118173f, 0.00678396f, 0.00498624f, -0.00653709f, 0.02627570f, 
    -0.07779561f, -0.06985912f, -0.01052196f, -0.07360639f, -0.08024370f, -0.06696428f, -0.07073282f, 0.03425340f, 
    -0.00998066f, -0.06447209f, -0.02433679f, -0.07955480f, -0.04860097f, -0.03335008f, -0.05178360f, -0.04554514f, 
    -0.05755770f, -0.02932407f, 0.00865903f, -0.05943211f, -0.06084163f, 0.02868590f, -0.00655113f, -0.05658029f, 
    -0.06804062f, -0.01748864f, -0.03878926f, -0.03232807f, -0.04527730f, -0.06747711f, 0.00120574f, 0.01280339f, 
    -0.06246574f, -0.07212101f, 0.01108727f, -0.08037250f, -0.03747013f, -0.05931286f, -0.01795952f, -0.06790869f, 
    -0.05683136f, -0.07494228f, -0.02900030f, 0.00753783f, 0.02304939f, -0.00385802f, 0.05014058f, -0.00194537f, 
    -0.03931487f, -0.00532014f, 0.01371009f, -0.02594942f, -0.01615901f, -0.06979792f, 0.06039319f, -0.04799255f, 
    -0.00817173f, -0.04456623f, -0.07795849f, -0.01080400f, -0.04775628f, -0.02475881f, -0.05013831f, -0.00971146f, 
    0.03345057f, -0.05603607f, 0.02239937f, -0.04482145f, -0.06792321f, -0.06399859f, 0.02341742f, -0.05535959f, 
    -0.03910386f, -0.02646426f, -0.05265021f, -0.01563411f, -0.00510387f, -0.03068867f, -0.07840712f, 0.00131917f, 
    -0.05527124f, -0.08113066f, 0.00232792f, -0.04833684f, -0.02736657f, 0.02353198f, -0.03278724f, -0.05323442f, 
    -0.06877123f, -0.03582460f, -0.01608181f, 0.00603835f, -0.00521979f, -0.06536334f, -0.04252032f, 0.00075127f, 
    -0.01759120f, -0.00916935f, 0.00461722f, -0.04774008f, -0.07942991f, -0.03434889f, -0.05098936f, -0.06028498f, 
    -0.06138454f, -0.03921075f, 0.01746205f, 0.01504050f, -0.03292197f, -0.01845840f, 0.00748512f, 0.00635020f, 
    0.02532053f, -0.06609012f, -0.01473885f, -0.00884721f, -0.07041617f, -0.05389848f, -0.00993063f, -0.08435825f, 
    -0.07050994f, 0.02922702f, 0.03226547f, -0.01758839f, 0.03156270f, 0.01135584f, -0.02975246f, 0.01117929f, 
    -0.02831207f, -0.05005220f, -0.00843779f, -0.08315667f, -0.04150425f, -0.05391055f, -0.02016812f, -0.03184606f, 
    -0.00617124f, -0.00788863f, -0.00777874f, -0.01258525f, -0.07948425f, -0.03817522f, -0.03256750f, -0.07423151f, 
    0.02978434f, 0.01101819f, -0.00463642f, -0.07723422f, -0.03133498f, -0.04579324f, 0.01602323f, 0.00503275f, 
    -0.03396669f, -0.03744310f, -0.01692078f, -0.06783564f, 0.02035875f, -0.03047732f, -0.05494909f, -0.04684449f, 
    -0.05629026f, -0.02526859f, 0.01758841f, -0.02526945f, -0.00303047f, -0.04093524f, -0.02189072f, 0.00878930f, 
    -0.06856202f, 0.02788659f, -0.00132476f, -0.07012079f, -0.08299934f, -0.07226354f, -0.01044964f, -0.04606182f, 
    0.23159336f, 0.18777214f, 0.13031358f, 0.28940696f, -0.07539049f, 0.07391874f, -0.05906147f, 0.20227422f, 
    0.13982716f, 0.21910426f, 0.24461356f, 1.00757170f, -0.21041742f, -0.09808608f, 0.16939119f, -0.08652896f, 
    0.15263361f, 0.28717974f, 0.62614369f, 0.46018973f, 0.43270808f, -0.02813884f, -0.14828157f, -0.12135149f, 
    0.05490571f, 0.11396566f, -0.20322135f, 0.35985363f, -0.00084019f, -0.07263023f, 0.00943893f, 0.24566692f, 
    -0.02829755f, 0.12258383f, 0.11979601f, -0.02036301f, -0.02997941f, 0.04671622f, 0.02375897f, -0.02484871f, 
    0.01892908f, 0.05456744f, -0.09252521f, 0.04813681f, -0.00183552f, 0.14547193f, -0.10279850f, 0.05869188f, 
    0.03268161f, -0.03216191f, 0.30357194f, -0.05881283f, -0.30469525f, 0.03233686f, 0.05054671f, 0.07089674f, 
    0.22583063f, -0.16103582f, 0.07609744f, -0.12423510f, 0.12655468f, -0.01831592f, 0.03093397f, -0.18212587f, 
    -0.42842048f, -0.31037578f, 0.01508597f, 0.17894170f, -0.02322546f, 0.18385339f, -0.09281681f, -0.35638168f, 
    -0.62821513f, -0.29546311f, -0.03950317f, 0.11363090f, -0.10451566f, 0.13733925f, 0.12529375f, 0.26205504f, 
    0.00909898f, -0.12696537f, -0.00584931f, 0.13915829f, -0.10384493f, 0.05914423f, -0.03329177f, 0.11177000f, 
    0.28437501f, 0.15273306f, -0.01359588f, -0.18181001f, -0.34503555f, 0.29020318f, 0.19210441f, -0.00091670f, 
    -0.07472876f, 0.18194452f, 0.24688992f, 0.17924544f, 0.06364757f, 0.07253706f, 0.15533261f, -0.07501783f, 
    0.13316052f, -0.08205797f, -0.06516533f, -0.38170078f, -0.42841333f, -0.16032593f, -0.10580836f, -0.03020714f, 
    0.02726462f, 0.16335399f, -0.22838506f, 0.05514225f, 0.14269051f, -0.14104788f, -0.12673733f, 0.04719210f, 
    0.01601939f, 0.02288074f, 0.35301954f, -0.12126551f, -0.03660126f, 0.07942657f, 0.40619853f, 0.13544045f, 
    0.21772131f, 0.03617850f, -0.15314873f, 0.05879621f, 0.12308551f, 0.09405930f, 0.14411719f, -0.08289694f, 
    -0.12707579f, -0.08116272f, 0.19790404f, 0.08855969f, 0.13732539f, -0.11830119f, -0.10421196f, -0.32427529f, 
    0.01485484f, 0.31806090f, 0.29882869f, 0.14296386f, -0.02308751f, 0.05674684f, -0.01277385f, -0.09991137f, 
    -0.01531626f, 0.01008952f, -0.33930042f, -0.16658619f, -0.13634704f, -0.02712676f, 0.08909442f, 0.04357893f, 
    0.07849079f, 0.07555121f, -0.22792001f, -0.24777819f, -0.26893425f, -0.12172866f, -0.08528005f, 0.02800355f, 
    -0.25846571f, -0.07567216f, 0.05544006f, 0.41466671f, 0.27113160f, -0.02173455f, 0.05605945f, 0.17681883f, 
    0.02236648f, -0.06699860f, -0.16859482f, 0.07660352f, -0.06540637f, -0.06210350f, -0.01265811f, -0.08154456f, 
    0.02627082f, -0.12098882f, 0.22131696f, 0.15644409f, 0.20222615f, -0.00308426f, 0.24718924f, 0.38406590f, 
    -0.02670967f, 0.09092728f, -0.21286158f, -0.15754288f, -0.07159908f, 0.09669565f, 0.15105601f, -0.08442123f, 
    0.72599608f, -0.12130391f, -0.27897120f, 0.07355763f, 0.05830634f, 0.30547872f, 0.19129249f, -0.11423036f, 
    -0.36375025f, -0.05677468f, 0.05964032f, -0.05469584f, -0.04440215f, 0.04832558f, 0.00079350f, -0.02428594f, 
    0.15959699f, 0.07561040f, 0.05476758f, 0.10136655f, 0.26374406f, -0.12266320f, 0.00146186f, -0.26640993f, 
    0.08793201f, -0.09512275f, -0.10749938f, 0.09577333f, -0.04075389f, -0.10007720f, -0.11964868f, -0.00961611f, 
    -0.19933367f, -0.41488078f, -0.31248513f, -0.20841272f, -0.04627608f, 0.15346058f, 0.09116179f, 0.00665727f, 
    0.17801660f, 0.19564287f, 0.34346864f, -0.23662855f, -0.37661949f, -0.24202886f, -0.13791715f, 0.19130100f, 
    0.01962915f, 0.01858549f, -0.06000368f, 0.03073383f, 0.00599062f, 0.32550436f, -0.02070157f, 0.18292221f, 
    -0.07458968f, 0.01797573f, -0.11387037f, -0.27724966f, -0.41458488f, 0.08604155f, -0.00150693f, 0.24229755f, 
    -0.05379010f, 0.02610838f, 0.07977241f, -0.15781212f, -0.05888222f, 0.21882308f, -0.06425761f, 0.10828549f, 
    0.03767367f, -0.09992987f, -0.05163620f, -0.03757698f, -0.19683678f, -0.16995405f, -0.02558059f, -0.04313623f, 
    0.08494671f, -0.19215514f, -0.03199839f, -0.07754532f, 0.01680068f, -0.10267328f, 0.00852439f, 0.02162418f, 
    0.02768299f, -0.00951636f, -0.05268167f, 0.00649569f, 0.00176952f, -0.02260491f, -0.04191107f, -0.04432986f, 
    -0.02470643f, -0.01526408f, 0.04364926f, 0.03939593f, -0.03791560f, -0.01501671f, 0.01521049f, 0.02714803f, 
    0.01298030f, -0.04734837f, -0.04081526f, -0.00191538f, 0.01218325f, 0.02058156f, -0.00826547f, 0.02565126f, 
    0.02606240f, -0.05501920f, -0.03873090f, -0.02269488f, -0.03262686f, -0.00598387f, 0.03181011f, -0.00930641f, 
    -0.01301320f, -0.02682022f, 0.02492393f, -0.02853499f, 0.04608980f, -0.03849786f, -0.02566177f, -0.02487104f, 
    -0.01805630f, -0.05438991f, -0.04386393f, -0.06026315f, -0.06864490f, -0.00913048f, -0.05148716f, -0.05431512f, 
    0.00987610f, -0.02945988f, -0.06756008f, -0.04496922f, -0.01777527f, -0.02964761f, -0.01368262f, -0.03985230f, 
    0.00782779f, 0.01154762f, -0.06830858f, -0.03546220f, 0.04519909f, 0.00519330f, -0.01462865f, 0.02984491f, 
    0.04053058f, -0.01314857f, -0.03168862f, -0.03384959f, -0.04564923f, 0.05230720f, 0.00189237f, -0.02495783f, 
    0.00698751f, 0.04857909f, 0.00358910f, -0.05348977f, 0.02627777f, 0.00350746f, -0.04699988f, -0.06174008f, 
    0.02285242f, -0.03027285f, 0.00944414f, -0.06836205f, -0.00026365f, -0.04056301f, -0.02077803f, -0.00533462f, 
    -0.00678742f, -0.06299234f, -0.00256846f, 0.03772053f, 0.00381127f, 0.04608630f, -0.05271798f, 0.02258422f, 
    -0.03973238f, 0.03961630f, -0.02075257f, 0.00913069f, 0.00278882f, -0.02742063f, -0.02014765f, 0.02240922f, 
    0.02289905f, -0.05007145f, 0.01173610f, -0.04263241f, -0.05762242f, 0.02263319f, 0.04036945f, -0.05212244f, 
    -0.06551278f, 0.00086786f, -0.01624545f, -0.00186887f, -0.01213382f, 0.00751324f, 0.04233022f, 0.02690068f, 
    -0.01239849f, -0.00570788f, 0.03906573f, -0.02907932f, -0.06020313f, 0.03362285f, -0.02323036f, 0.03263640f, 
    -0.01909879f, -0.01692342f, -0.05961268f, 0.00625149f, 0.01757179f, 0.03032292f, -0.04182928f, 0.03328928f, 
    -0.05923761f, 0.03550151f, -0.06153872f, -0.03178282f, 0.02294763f, -0.02700392f, -0.01507101f, 0.00758872f, 
    -0.02260372f, -0.00559091f, 0.01694549f, -0.04648856f, -0.01437591f, -0.02016169f, 0.01430985f, -0.03948266f, 
    -0.05195659f, 0.02416862f, -0.00702916f, 0.05179181f, 0.03248575f, 0.03287093f, 0.04982965f, -0.06254198f, 
    0.00896051f, -0.03394540f, -0.00506568f, -0.01700175f, 0.03239734f, -0.05137227f, -0.01323485f, -0.05392381f, 
    -0.01373411f, -0.03387066f, -0.04804478f, -0.05334567f, -0.01110558f, 0.00069876f, 0.04160075f, -0.01676678f, 
    -0.04985880f, 0.02161271f, -0.06802455f, -0.00607345f, -0.06283017f, -0.00062977f, -0.03334782f, 0.01304075f, 
    -0.00650504f, 0.00762512f, 0.00230225f, 0.01378990f, 0.01193307f, 0.04086874f, -0.00829266f, -0.03537768f, 
    -0.04066437f, -0.00869446f, -0.04862934f, 0.00396976f, -0.05346331f, -0.03355294f, 0.01668881f, -0.06218526f, 
    -0.04331642f, 0.02960339f, -0.04981405f, -0.00138701f, -0.02977530f, 0.00261940f, -0.02252819f, -0.05983169f, 
    -0.04533251f, 0.00565955f, -0.05175982f, 0.04501388f, 0.02995184f, -0.03208479f, 0.03042627f, 0.00321671f, 
    0.00826154f, 0.03317941f, -0.04741113f, -0.00054159f, 0.01526471f, 0.01857467f, -0.00602816f, 0.00424880f, 
    0.01769166f, -0.04599357f, -0.01572431f, 0.03737167f, 0.00591828f, -0.03244781f, 0.01747059f, -0.04146163f, 
    -0.02468988f, 0.02786921f, -0.03225432f, -0.03675007f, -0.06315360f, 0.02450000f, 0.02149378f, -0.01363345f, 
    0.00420981f, -0.03808055f, -0.06649874f, 0.03469414f, 0.03930841f, 0.02753238f, 0.04224095f, 0.00179101f, 
    0.03665146f, -0.01530432f, -0.05746484f, -0.03398447f, 0.00256974f, -0.04012694f, 0.03481596f, 0.00312259f, 
    -0.04593674f, -0.06520769f, 0.02686179f, 0.03100761f, 0.00491557f, -0.04057182f, -0.01723292f, 0.05541694f, 
    -0.04083944f, -0.05917225f, -0.00704078f, 0.01208312f, -0.05481093f, -0.00269114f, 0.00176318f, 0.01983557f, 
    0.02906443f, -0.02155962f, 0.04335030f, -0.00960773f, 0.04445709f, 0.04250001f, 0.00203462f, 0.05901083f, 
    -0.02173669f, 0.01205844f, -0.03461562f, 0.00391158f, -0.01661062f, -0.03423310f, 0.02747909f, -0.05669484f, 
    0.04843413f, -0.02066313f, 0.04836568f, -0.02837352f, 0.03168803f, -0.04091491f, 0.03702787f, 0.04166984f, 
    -0.05925349f, 0.00230380f, -0.04597700f, -0.03519652f, 0.03387342f, 0.01626121f, 0.01166961f, 0.02109262f, 
    -0.03793671f, 0.00579893f, -0.06453849f, 0.02316958f, -0.05456637f, -0.05108272f, -0.01746261f, -0.06362736f, 
    -0.06344201f, -0.00171267f, -0.04548621f, -0.02835844f, -0.00201032f, 0.03315961f, 0.01045826f, -0.03244580f, 
    0.01885322f, -0.01897553f, -0.05945843f, -0.03664295f, -0.01918223f, -0.00434905f, -0.02986035f, 0.06112767f, 
    0.03289158f, -0.05393329f, -0.00386445f, -0.05144671f, 0.02741134f, 0.04555847f, -0.02185905f, -0.06112972f, 
    0.01446704f, -0.06290835f, -0.04793220f, -0.05924288f, -0.01727268f, -0.00571429f, -0.01407226f, -0.04666723f, 
    -0.04283227f, -0.01292834f, -0.05520094f, 0.00167063f, 0.05089421f, 0.01312990f, 0.01464112f, -0.00795832f, 
    -0.00371903f, 0.03422076f, -0.05086831f, 0.00274013f, -0.06043674f, -0.02053964f, -0.03818902f, 0.03864040f, 
    -0.04987421f, -0.03850099f, -0.02424612f, 0.01286720f, 0.00660768f, -0.02728324f, -0.05508443f, -0.02163824f, 
    -0.04214218f, 0.02860437f, -0.04308265f, 0.00511936f, -0.00102406f, 0.05065649f, 0.04093147f, 0.00647922f, 
    0.00870941f, 0.04133088f, 0.04094177f, -0.00638761f, -0.00391517f, 0.01840789f, 0.04150979f, 0.00402355f, 
    0.00782609f, -0.03861628f, 0.00197159f, -0.03232815f, -0.05901764f, -0.01454318f, -0.06086387f, -0.03963544f, 
    -0.04099451f, -0.03237020f, -0.03916737f, 0.03345900f, -0.00730894f, 0.01233592f, -0.05202018f, 0.02527979f, 
    0.01070114f, -0.01392349f, 0.00542529f, -0.04081002f, 0.01670949f, 0.02149887f, -0.05203929f, 0.03135785f, 
    0.03267278f, -0.04617306f, 0.02863616f, -0.01453737f, 0.00752885f, -0.03081434f, -0.03232170f, -0.06629053f, 
    0.00500568f, -0.00513728f, 0.04142190f, -0.02643138f, -0.06094033f, 0.04183466f, 0.03774597f, 0.00353037f, 
    0.02436441f, 0.05235445f, 0.01977479f, -0.02449553f, -0.03844635f, -0.02094403f, 0.03809078f, -0.00069750f, 
    0.03169351f, -0.00280936f, -0.04924731f, 0.02728509f, -0.01825433f, 0.00615039f, 0.02101990f, 0.02881512f, 
    -0.03245547f, -0.01010061f, -0.00844964f, 0.03577781f, -0.04343243f, -0.05848993f, 0.01090136f, -0.00236276f, 
    0.02955857f, -0.06008632f, 0.01514349f, -0.01322571f, -0.05723023f, -0.05390369f, -0.00769804f, -0.05917342f, 
    -0.04026725f, 0.03579076f, -0.01253641f, -0.05327425f, -0.00669379f, -0.02274084f, 0.00773473f, 0.00771297f, 
    -0.04048545f, 0.02490099f, 0.00008958f, 0.02463550f, -0.05442535f, 0.03044010f, 0.00662562f, 0.02234331f, 
    -0.01398026f, 0.05043071f, -0.01301882f, -0.03055791f, -0.02919389f, -0.02351343f, 0.00528935f, 0.03386070f, 
    -0.04578765f, -0.04030358f, 0.04133156f, 0.02575268f, 0.02133646f, 0.00195583f, -0.00476263f, 0.01155581f, 
    0.02764990f, -0.02705350f, 0.04658531f, -0.03234772f, -0.01727472f, 0.04007261f, -0.04841407f, 0.00603694f, 
    -0.00713409f, 0.03338994f, -0.01505630f, -0.06594825f, -0.02198829f, -0.06236405f, -0.03091456f, -0.06170318f, 
    -0.03927261f, -0.03494558f, -0.01592286f, -0.01302847f, -0.05592001f, 0.00827575f, 0.00818602f, -0.01191612f, 
    -0.05258672f, -0.05404593f, 0.02614681f, 0.04328548f, -0.00040777f, 0.00865166f, 0.04097141f, -0.02247052f, 
    -0.00920722f, 0.02709416f, -0.00876896f, 0.00337228f, -0.06310112f, -0.01020344f, -0.04885951f, 0.02812136f, 
    0.01207455f, -0.01157856f, -0.03370837f, -0.05158750f, -0.05040298f, -0.06598315f, 0.01934050f, -0.01800136f, 
    0.05206478f, 0.04031049f, 0.01452171f, -0.06415176f, -0.06304573f, 0.01157651f, -0.03160871f, 0.04998271f, 
    -0.04024897f, 0.04687415f, 0.04437241f, -0.04356287f, -0.02123872f, 0.03645439f, -0.01645699f, -0.04140658f, 
    -0.04058315f, 0.03259265f, 0.03348813f, -0.05249145f, 0.03574888f, -0.06081543f, -0.04820652f, 0.00026190f, 
    0.02311930f, -0.04678238f, -0.01492351f, 0.04788464f, -0.05832564f, -0.03159038f, 0.03522696f, -0.01837525f, 
    -0.03184366f, 0.01429530f, -0.01880079f, -0.06472903f, -0.02174832f, -0.00202930f, -0.02299155f, 0.04946944f, 
    0.16498485f, -0.12160305f, -0.00938906f, 0.28434148f, -0.04961826f, -0.18413575f, -0.01157928f, -0.02941256f, 
    -0.06122067f, -0.05650403f, 0.47019553f, 0.21968833f, -0.06281890f, -0.28413120f, 0.13754487f, 0.06259710f, 
    -0.11422969f, 0.07957633f, 0.46611711f, 0.00157538f, 0.38195366f, 0.07089207f, -0.23145850f, -0.19046699f, 
    0.03329250f, 0.00638367f, -0.13958241f, 0.21584819f, -0.27095637f, -0.58095425f, 0.12112202f, -0.05072168f, 
    0.07007477f, 0.03116150f, 0.22253732f, -0.15867677f, -0.07845222f, -0.17035511f, 0.07272147f, 0.11731261f, 
    -0.04220800f, 0.06272084f, -0.05641474f, -0.07426209f, 0.01724213f, 0.43462229f, -0.01914677f, -0.33824781f, 
    0.16081056f, 0.07654073f, -0.13788876f, 0.25354013f, 0.04162718f, 0.04442468f, 0.03476419f, -0.22020668f, 
    0.17443195f, 0.06427504f, -0.03761262f, -0.02401264f, 0.05958810f, 0.13329713f, -0.22123817f, -0.12790145f, 
    0.19150418f, -0.18263105f, -0.02878206f, 0.22705270f, 0.11998749f, 0.04349992f, 0.02240263f, 0.18427883f, 
    0.25787014f, -0.16406925f, -0.01133004f, -0.01312860f, -0.14852932f, -0.00192845f, -0.05192384f, -0.01905034f, 
    -0.19549678f, 0.12398112f, 0.11577376f, 0.20045805f, -0.04735421f, -0.06647026f, 0.12463646f, 0.07674920f, 
    -0.07208597f, -0.31325358f, -0.43494958f, 0.02239437f, -0.53742129f, -0.16836075f, 0.21589515f, 0.02547409f, 
    0.03771535f, 0.24567239f, 0.06669228f, 0.00196171f, 0.12744738f, 0.12899067f, 0.02761020f, -0.09691014f, 
    0.02256867f, -0.06691316f, -0.06581947f, -0.02236865f, 0.00928248f, -0.47584766f, -0.55602884f, 0.17336534f, 
    0.06095977f, 0.06919964f, -0.01523840f, -0.15146792f, -0.12499443f, -0.16601093f, -0.00128142f, -0.09778225f, 
    0.29709634f, -0.12093285f, -0.22865506f, -0.15057129f, -0.03874848f, 0.08394250f, 0.26770777f, 0.08145421f, 
    0.01021989f, 0.13822064f, -0.25371301f, -0.21204790f, 0.04324416f, -0.24048103f, -0.08860481f, 0.26798117f, 
    0.10865185f, 0.33433366f, 0.08932676f, 0.03569566f, 0.09955274f, 0.00497046f, 0.10630958f, -0.03074027f, 
    -0.41084993f, -0.33311111f, -0.03691242f, 0.04592877f, 0.13838439f, 0.24057169f, 0.16104579f, 0.12884311f, 
    -0.10197385f, 0.39094746f, 0.10102578f, -0.20254692f, -0.10481464f, -0.09038127f, 0.12998134f, -0.25116083f, 
    -0.06424037f, -0.26002571f, -0.06955779f, -0.04717556f, -0.17050479f, 0.13927931f, -0.07634710f, 0.11654061f, 
    -0.15044181f, 0.07681489f, -0.11745998f, -0.17600498f, -0.22724698f, 0.05522387f, 0.01088439f, 0.04451719f, 
    0.06133015f, -0.30677411f, -0.00117922f, 0.02381916f, 0.14460242f, -0.11037045f, -0.09411675f, -0.14168480f, 
    -0.14210233f, 0.04066074f, -0.09668227f, 0.03397507f, -0.19543386f, -0.43392247f, -0.32227975f, -0.17897484f, 
    0.28055570f, 0.08930551f, -0.05620158f, -0.03682586f, 0.22017510f, 0.11810549f, 0.11719314f, 0.42095056f, 
    -0.28401920f, -0.23520774f, -0.40317997f, 0.08852291f, 0.28669739f, -0.05605100f, 0.13385171f, 0.23729067f, 
    -0.16821426f, 0.27343827f, 0.19393326f, 0.15565979f, 0.05503534f, 0.05633663f, 0.06410607f, -0.27097833f, 
    -0.45307535f, 0.12922747f, -0.36560458f, 0.02215118f, 0.06103021f, -0.09216993f, 0.08003555f, 0.08330036f, 
    0.20360100f, -0.06266020f, 0.01067180f, 0.16104780f, 0.04883251f, 0.06488660f, 0.21451798f, -0.04576267f, 
    -0.02608179f, -0.15906785f, -0.00022194f, 0.25026253f, -0.06830132f, 0.03655591f, 0.26584506f, 0.12419921f, 
    -0.20149928f, -0.22798756f, -0.26441410f, 0.23324314f, -0.13548070f, -0.04165658f, -0.03646677f, 0.12045846f, 
    -0.00199665f, 0.20866513f, -0.03686119f, -0.05910994f, -0.09207111f, -0.00360410f, -0.17166677f, -0.10605732f, 
    0.20566243f, 0.14769422f, 0.02608306f, 0.32910523f, 0.15460837f, -0.24056810f, -0.14511245f, -0.16542318f, 
    0.19653620f, -0.05474743f, 0.06493914f, 0.22263093f, 0.13882345f, -0.12790230f, -0.05617502f, 0.03360563f, 
    0.18163458f, 0.27739370f, -0.13547240f, 0.25840589f, -0.01340378f, 0.13156630f, -0.03962121f, 0.16348019f, 
    -0.01953073f, 0.13152766f, 0.09880232f, 0.02838025f, 0.08499091f, -0.07419332f, -0.09065896f, -0.14499626f, 
    0.07387620f, -0.01349509f, 0.07829490f, 0.01846514f, 0.19549136f, 0.02335321f, 0.14089914f, 0.21181586f, 
    0.15077043f, 0.10302229f, 0.16234967f, -0.01110265f, 0.22943461f, 0.03923307f, 0.08718627f, -0.08330032f, 
    0.06851891f, 0.11253697f, -0.33244503f, 0.27755511f, 0.26579574f, 0.06279013f, 0.00382216f, 0.16113466f, 
    -0.16075607f, -0.11476172f, -0.39071149f, -0.12746541f, -0.03034023f, 0.11218911f, 0.00654977f, 0.04383501f, 
    0.04131919f, 0.12592651f, 0.16666204f, -0.03461939f, 0.04697356f, -0.13862664f, -0.02289602f, 0.01124045f, 
    0.00886854f, -0.18824637f, -0.01290414f, 0.14171042f, 0.13942145f, -0.16820060f, -0.15590712f, -0.04903468f, 
    -0.09531110f, 0.01127960f, 0.11928843f, -0.10827377f, 0.13294402f, -0.24370936f, -0.07414649f, -0.31422698f, 
    -0.10817796f, -0.14923720f, -0.18942715f, -0.15610816f, 0.14694887f, 0.08737922f, 0.00107077f, -0.18163887f, 
    -0.08867840f, 0.02795251f, 0.13946389f, -0.00758274f, 0.19161354f, -0.05514744f, -0.21215980f, -0.53004891f, 
    0.38246769f, 0.09453360f, 0.06955845f, 0.09941702f, 0.23814771f, 0.01036371f, 0.05878073f, 0.08327098f, 
    0.01065809f, 0.25213298f, 0.08470479f, -0.17812510f, -0.06485526f, 0.03270204f, 0.09681021f, 0.03523159f, 
    0.11178082f, 0.12822704f, -0.31466725f, -0.25109950f, -0.03506539f, 0.26042125f, 0.11087334f, -0.02365175f, 
    -0.15071045f, 0.03181758f, 0.07569850f, 0.19260736f, 0.24307099f, 0.01442671f, 0.04788168f, -0.09735705f, 
    0.04311866f, 0.08365259f, -0.06568987f, -0.32066613f, -0.25216615f, -0.12083021f, 0.03230622f, 0.11449561f, 
    0.00343698f, 0.04246318f, 0.24737351f, -0.08132560f, 0.12298504f, -0.20106211f, -0.07720906f, 0.13769050f, 
    0.07072879f, 0.02553990f, 0.19411673f, 0.10299691f, -0.01536092f, 0.07762726f, -0.10457842f, 0.10967265f, 
    0.05706897f, 0.16979896f, -0.19599450f, 0.02453846f, -0.06436448f, 0.02229495f, 0.00074603f, -0.39034772f, 
    -0.19283298f, -0.13430783f, 0.11845791f, 0.04592911f, 0.13745628f, 0.03446008f, -0.13982578f, -0.14683047f, 
    0.02247017f, 0.03800007f, -0.11971150f, -0.03672969f, 0.03650453f, -0.07934571f, -0.07050863f, -0.00203846f, 
    -0.00807800f, -0.06971647f, -0.05023175f, 0.08028554f, 0.09388162f, 0.08906938f, 0.01188640f, 0.12701474f, 
    0.15648562f, 0.15861930f, 0.02841283f, -0.09262296f, 0.08711347f, 0.08243626f, 0.09229477f, 0.09898410f, 
    -0.07320239f, 0.05668415f, 0.04653767f, 0.19309343f, -0.28993335f, 0.19475153f, 0.09090368f, 0.09697619f, 
    0.07923993f, -0.00783520f, -0.09864907f, 0.13947828f, 0.02383017f, 0.07628793f, 0.19531567f, 0.09573958f, 
    -0.10587475f, -0.25507540f, 0.36015630f, 0.18189920f, 0.25979093f, -0.36190939f, 0.12824874f, -0.43534231f, 
    0.26042202f, -0.22426210f, -0.22420497f, -0.23650536f, 0.11400877f, 0.06910425f, 0.37869352f, 0.06476684f, 
    0.13393147f, 0.02973753f, -0.21201572f, 0.05412897f, 0.07075800f, 0.06490701f, -0.11264518f, 0.16343161f, 
    -0.10607061f, -0.15516575f, 0.17128561f, 0.04286324f, 0.09978340f, 0.07404202f, 0.09924379f, 0.08830368f, 
    -0.20234920f, -0.13726655f, 0.03665892f, 0.09437516f, 0.09696017f, 0.02727458f, -0.13002187f, -0.09690058f, 
    -0.13948233f, -0.01654209f, -0.01071823f, -0.01847121f, 0.04817553f, 0.03141529f, 0.20564549f, 0.17260428f, 
    0.08250908f, -0.08395535f, -0.13847774f, -0.08822705f, 0.04807181f, 0.10010402f, -0.05110703f, 0.31398970f, 
    0.10228798f, 0.21303056f, 0.12314560f, -0.55566704f, -0.44337288f, 0.08019996f, 0.07759289f, 0.01646729f, 
    -0.10768373f, -0.05321919f, -0.10991983f, -0.10151264f, 0.18659849f, -0.01704059f, -0.06591983f, -0.09155167f, 
    -0.08643611f, 0.01181731f, -0.11818622f, -0.29385391f, -0.47928041f, -0.02057413f, -0.07251062f, 0.00146096f, 
    -0.00448757f, -0.07422038f, 0.00882556f, 0.10169300f, 0.05555601f, 0.04208872f, 0.05131418f, 0.19731185f, 
    0.05584532f, 0.10455444f, -0.08582968f, 0.17916843f, -0.04515632f, 0.07476393f, 0.12757079f, 0.09446453f, 
    0.20879088f, 0.11082616f, 0.00697571f, -0.08959594f, 0.12752384f, -0.01559063f, -0.00753323f, 0.13211645f, 
    -0.04331297f, -0.02147746f, 0.02123702f, 0.02759184f, 0.01585511f, 0.04446923f, 0.04606869f, 0.02223274f, 
    -0.04964901f, -0.05850700f, 0.01220751f, -0.04926126f, 0.02379413f, 0.03757365f, 0.03149382f, 0.03132472f, 
    -0.03488105f, 0.04640324f, 0.00571928f, -0.01383426f, -0.03804400f, 0.00923788f, -0.02115458f, -0.02241628f, 
    -0.06317411f, 0.00065028f, -0.00575645f, 0.04923938f, 0.00371053f, 0.00282726f, -0.01903439f, 0.02746406f, 
    0.01727856f, -0.02895269f, 0.00266033f, 0.02265175f, 0.02261494f, -0.01501175f, 0.04777183f, 0.00344999f, 
    0.04019196f, 0.01233422f, -0.00864322f, 0.00200065f, -0.04523568f, 0.04938235f, -0.00067016f, -0.03256147f, 
    -0.03139739f, -0.00290259f, -0.00489958f, -0.04778836f, -0.04950630f, 0.02062972f, 0.04549542f, -0.01983986f, 
    0.02813233f, -0.01519339f, -0.05683615f, -0.02044048f, -0.05507441f, 0.03428673f, 0.00486453f, 0.00223755f, 
    -0.02576529f, 0.01383608f, 0.00371000f, 0.01602870f, -0.03587165f, 0.01162331f, 0.02012299f, 0.02363327f, 
    -0.03173192f, -0.03994460f, -0.06093735f, -0.00317978f, -0.02492276f, 0.02101875f, 0.01818737f, -0.02418678f, 
    0.04524967f, -0.01741216f, 0.04212654f, 0.00058262f, -0.01438396f, 0.02030179f, 0.02212635f, 0.01710557f, 
    -0.00624126f, -0.04190091f, -0.01718933f, -0.02133250f, 0.00684371f, -0.01468511f, 0.00513031f, -0.04085479f, 
    -0.00238768f, 0.02649270f, -0.06632905f, -0.02686362f, -0.03446986f, 0.01129175f, 0.03576185f, -0.00213453f, 
    0.02891440f, -0.06146954f, 0.02774150f, -0.04267242f, -0.03264716f, 0.00089462f, -0.06568868f, -0.00039390f, 
    -0.04028522f, -0.06498117f, -0.05821623f, -0.01088393f, -0.03183135f, -0.04863774f, 0.00019496f, -0.01172949f, 
    0.04528234f, -0.02291039f, -0.01463416f, -0.03278710f, 0.03652065f, 0.04647410f, 0.03853213f, -0.02464717f, 
    -0.06291004f, 0.01833449f, -0.02242459f, 0.03827778f, 0.00502158f, -0.02842387f, -0.04588072f, -0.05385141f, 
    -0.01218796f, 0.00872247f, 0.03100928f, -0.06665979f, 0.01291753f, 0.04157150f, -0.03731507f, 0.04631812f, 
    0.02475575f, 0.05127519f, -0.01547031f, -0.06544676f, 0.02252873f, -0.05879600f, -0.00308253f, -0.03767410f, 
    -0.02010449f, -0.00666866f, 0.04568977f, -0.02144752f, 0.02410175f, 0.01870816f, -0.05949971f, 0.02622340f, 
    -0.00356722f, 0.01920166f, -0.00312989f, 0.03913359f, 0.01173520f, -0.06237710f, 0.01927215f, 0.04923750f, 
    0.00907419f, 0.01543631f, 0.03092723f, -0.06006011f, -0.03807965f, 0.01937216f, -0.00565300f, -0.03797769f, 
    -0.02606672f, -0.05755800f, 0.03917560f, -0.00857649f, -0.03585467f, 0.03033326f, -0.02673801f, 0.03318362f, 
    -0.05026774f, -0.06742685f, 0.03267477f, 0.02637822f, -0.05321588f, -0.00994509f, -0.04981674f, -0.00497969f, 
    -0.01761934f, 0.04623601f, -0.03118823f, -0.03895959f, -0.01018072f, 0.01035807f, -0.03255389f, 0.04239126f, 
    0.02168339f, -0.01204542f, 0.00101157f, -0.03122050f, -0.05773901f, -0.01168125f, 0.00915328f, -0.04068365f, 
    -0.03408860f, 0.03548742f, -0.05755300f, -0.05621725f, -0.06776116f, 0.00174662f, -0.03929687f, -0.04036746f, 
    0.00919251f, 0.03035213f, -0.01755787f, 0.01234665f, 0.00007737f, 0.00888728f, -0.06188687f, 0.02862696f, 
    -0.01784290f, -0.03617861f, 0.04109197f, -0.03026021f, 0.01971058f, 0.01458725f, -0.00330085f, -0.05908467f, 
    -0.03649224f, -0.05928621f, 0.04595939f, -0.03130546f, 0.04626911f, -0.05586300f, 0.03435167f, 0.00609082f, 
    -0.03809080f, 0.04155993f, 0.04150704f, -0.02229986f, -0.01753307f, 0.02607704f, 0.03384250f, -0.01699848f, 
    -0.04842008f, 0.03393793f, -0.05321654f, -0.01390975f, 0.03689507f, 0.04601885f, 0.02054878f, 0.00304717f, 
    -0.04345508f, -0.04045315f, 0.03894695f, -0.01951787f, -0.02186892f, 0.04666665f, -0.01758780f, 0.03131476f, 
    0.01036884f, -0.02446706f, -0.01124233f, -0.01456460f, -0.03603138f, -0.01771367f, 0.01212349f, -0.02004563f, 
    0.00237917f, -0.01042337f, 0.02761655f, -0.02836410f, 0.04838832f, -0.06067990f, -0.03092282f, 0.01115620f, 
    -0.03923678f, -0.01597884f, 0.00911079f, -0.05651763f, -0.00913607f, -0.03664375f, 0.03080964f, 0.03712261f, 
    0.03668905f, -0.05222907f, -0.00563090f, -0.05065698f, -0.06326818f, -0.02807330f, 0.00210605f, 0.03523313f, 
    0.02719499f, -0.05222548f, 0.04616962f, -0.00282575f, -0.02493616f, -0.00403635f, 0.02985599f, 0.02265041f, 
    -0.05339693f, -0.06336664f, -0.02995703f, -0.05678985f, -0.01784053f, -0.02671155f, -0.00048450f, 0.05921903f, 
    -0.02380404f, -0.05049784f, -0.05181438f, -0.05544090f, -0.01106856f, 0.00113050f, 0.02189630f, -0.04355139f, 
    -0.05430048f, -0.02014639f, 0.04894052f, 0.03934056f, 0.05021980f, 0.05106838f, 0.03129083f, -0.03412225f, 
    -0.03137498f, -0.05412669f, 0.00135091f, -0.04421266f, -0.02436335f, -0.06091851f, -0.00811574f, -0.01821185f, 
    0.01567354f, 0.05684111f, -0.04405024f, 0.00103176f, -0.05082040f, 0.00706092f, -0.05741701f, -0.03593319f, 
    0.04912230f, 0.03465198f, 0.00430221f, 0.03373874f, 0.04388709f, 0.04861532f, -0.00130258f, -0.01882327f, 
    0.00828727f, 0.04001996f, -0.05647389f, 0.00639778f, 0.01718662f, 0.01429589f, 0.02445986f, 0.03717505f, 
    -0.04359146f, -0.02002279f, -0.00249790f, -0.04100039f, 0.02112626f, -0.05632700f, -0.05434232f, 0.03019875f, 
    -0.05885642f, 0.02331855f, -0.06477218f, -0.00661314f, 0.01631891f, -0.03514887f, 0.00652278f, 0.00292999f, 
    -0.02737523f, -0.05507090f, 0.04265298f, -0.04724828f, -0.05654798f, -0.05773902f, -0.02016192f, -0.01792273f, 
    -0.06642541f, -0.05809746f, -0.06825326f, 0.01903345f, 0.03599850f, 0.02120649f, -0.00895666f, -0.03036209f, 
    -0.02924697f, -0.03839413f, 0.02509525f, 0.02709703f, -0.04345675f, -0.06451505f, -0.02517677f, 0.04557555f, 
    -0.00861502f, 0.04279191f, 0.00407380f, -0.02251168f, -0.03294095f, -0.06054560f, 0.04365611f, -0.03197828f, 
    -0.00519640f, -0.03657769f, 0.01614032f, 0.00136471f, -0.00519499f, -0.03835772f, 0.00806973f, -0.04134336f, 
    0.03512283f, -0.04403111f, 0.02791185f, -0.03647713f, 0.03579260f, -0.04111207f, -0.01690120f, 0.01586149f, 
    0.03014524f, 0.04058324f, 0.04480001f, -0.05922493f, 0.00600951f, -0.01737742f, -0.00459788f, 0.04910114f, 
    -0.05845891f, -0.05385752f, -0.00851137f, -0.01667214f, -0.03152031f, -0.03737565f, 0.02694108f, 0.03573782f, 
    0.00169877f, -0.01969866f, -0.01518070f, -0.04211785f, 0.02200917f, 0.04201752f, -0.04894682f, -0.02467273f, 
    0.00107828f, -0.05154864f, -0.03546989f, -0.00606386f, 0.01169870f, -0.02111488f, -0.05705430f, -0.02688283f, 
    0.05645133f, -0.01868393f, -0.01317809f, 0.05348095f, -0.03666303f, -0.04819066f, -0.03128881f, -0.01965440f, 
    -0.04404605f, 0.02400020f, -0.04944429f, 0.03450361f, 0.00571750f, -0.02582327f, -0.05569482f, 0.01883031f, 
    -0.01514751f, -0.05683824f, -0.00493907f, -0.05843325f, -0.02911818f, 0.04407321f, 0.02342692f, 0.00179615f, 
    0.02074916f, -0.03357102f, 0.03552832f, -0.00247083f, -0.02183703f, 0.04011547f, -0.01324258f, -0.00919940f, 
    -0.04627751f, 0.04405728f, 0.02736049f, -0.00912238f, 0.02095179f, -0.04632360f, -0.04897703f, -0.00590054f, 
    -0.05460786f, -0.04695899f, 0.03498516f, 0.00806519f, -0.05429824f, -0.03018967f, 0.05358625f, 0.03508064f, 
    0.00496525f, -0.00304867f, 0.00674960f, -0.03310853f, -0.03993262f, 0.03455676f, -0.03124463f, 0.00900223f, 
    -0.03040713f, 0.00343443f, -0.02786488f, 0.01565671f, -0.03266818f, -0.04756451f, -0.03250706f, 0.04057337f, 
    -0.03917235f, -0.02738885f, -0.06229018f, 0.00851416f, -0.00678128f, 0.03667184f, 0.03222032f, -0.03161556f, 
    -0.02264468f, -0.04190935f, 0.04154682f, 0.04237206f, -0.03668252f, 0.04067010f, 0.04444076f, -0.02255144f, 
    -0.03919885f, 0.00225705f, 0.02231563f, -0.03403399f, 0.01189593f, -0.02604927f, -0.04453987f, -0.04969388f, 
    0.04040663f, -0.02627331f, 0.05002195f, -0.00598878f, -0.01639462f, 0.00148343f, -0.06329776f, 0.01910760f, 
    -0.01993544f, 0.00252563f, 0.02713415f, 0.00055314f, 0.00552457f, -0.00678718f, -0.00315539f, 0.02215331f, 
    -0.05836694f, 0.01638931f, -0.05402091f, 0.00853323f, 0.02863280f, 0.02808245f, -0.04965448f, 0.03257238f, 
    -0.06162317f, -0.00091271f, 0.00290341f, -0.01945665f, -0.00551528f, 0.04608492f, -0.02454467f, 0.00437024f, 
    -0.06745362f, 0.00672144f, 0.04293787f, 0.04165966f, 0.02546248f, -0.02022203f, 0.02710369f, 0.04079196f, 
    -0.06842123f, -0.06043763f, -0.04725724f, 0.03011932f, 0.04425462f, -0.01126795f, -0.01581409f, -0.06925250f, 
    0.04067983f, 0.03405078f, -0.01516913f, -0.03101761f, -0.05707882f, -0.03481761f, -0.03166196f, -0.00818446f, 
    0.04546770f, 0.02118463f, -0.05066586f, -0.05847838f, 0.02521401f, 0.01084871f, -0.00563506f, -0.06201561f, 
    -0.01475441f, 0.04530372f, -0.04549434f, 0.01414669f, -0.05961908f, 0.03943639f, 0.04171385f, -0.02098899f, 
    0.04228855f, 0.01669425f, 0.00707970f, 0.02265306f, 0.02677276f, 0.03347016f, -0.04671548f, 0.01908807f, 
    0.02225380f, 0.02142446f, -0.06898440f, -0.05459733f, 0.00597674f, 0.01855185f, -0.05384006f, 0.03731975f, 
    -0.03977420f, 0.03724699f, 0.03667252f, -0.00394530f, -0.06486866f, -0.03659168f, 0.01449242f, 0.04372118f, 
    0.01044001f, 0.04011307f, -0.00814548f, 0.00490036f, 0.00721517f, 0.03978577f, 0.04317134f, -0.05921684f, 
    -0.05755329f, -0.01114587f, -0.02107070f, -0.00468542f, 0.03005968f, -0.05434768f, -0.04368373f, -0.05118972f, 
    0.00408333f, -0.01584880f, -0.04000950f, 0.00196948f, 0.01833514f, -0.03048008f, -0.05482160f, -0.03440314f, 
    0.02370083f, 0.00582937f, 0.04020770f, 0.01829519f, 0.02857114f, -0.03846320f, -0.03556059f, -0.01739861f, 
    -0.04273989f, -0.01843914f, -0.04298539f, 0.01267235f, 0.01534408f, -0.02182757f, -0.00596019f, -0.04059701f, 
    -0.01793953f, -0.02044666f, 0.01448804f, 0.01686652f, -0.03199549f, 0.03986511f, -0.04886307f, -0.04742793f, 
    -0.06299133f, 0.03224701f, -0.04784055f, 0.02342815f, -0.01302143f, -0.03247030f, -0.04611144f, -0.03414530f, 
    0.01634974f, -0.02390897f, -0.02652666f, 0.00753730f, 0.02644177f, 0.00792393f, -0.00868904f, -0.04185803f, 
    -0.06267792f, -0.02874049f, -0.05049962f, -0.06233017f, 0.02042728f, -0.00076327f, -0.00224222f, 0.00349750f, 
    0.04742132f, 0.02798957f, 0.00938090f, -0.02442686f, -0.02469588f, -0.01763753f, -0.04658562f, -0.01468128f, 
    -0.04637938f, -0.01233066f, -0.05155824f, 0.01966288f, 0.01591776f, -0.04025057f, -0.07003645f, -0.00543254f, 
    0.03611295f, 0.04160551f, 0.01869032f, 0.02118296f, -0.00857296f, -0.06216247f, 0.01644639f, -0.01958716f, 
    -0.00760687f, 0.01726720f, -0.00706210f, -0.03021315f, -0.05167245f, -0.06167054f, 0.05926172f, -0.02139519f, 
    0.05389817f, -0.05340961f, 0.00471426f, -0.03970382f, -0.02302532f, 0.04798885f, -0.01166483f, -0.04852068f, 
    0.05357235f, -0.01780580f, 0.01332844f, -0.03043560f, -0.02994612f, 0.01195662f, -0.04368415f, -0.05398524f, 
    -0.05609569f, 0.00338315f, 0.00732453f, -0.03317307f, 0.00505428f, -0.03239807f, 0.02396192f, -0.04271230f, 
    -0.02201210f, 0.02996929f, -0.06834265f, 0.02456241f, -0.01565116f, 0.04108741f, 0.03187548f, -0.06899929f, 
    -0.01313950f, 0.02667510f, 0.03535302f, 0.02558275f, 0.01780116f, 0.02137487f, 0.01480142f, 0.01444642f, 
    0.05122912f, -0.01102698f, -0.04967830f, -0.02279175f, -0.00897212f, 0.04470527f, -0.03031356f, -0.01866283f, 
    0.00000777f, -0.01146071f, -0.02949402f, 0.00752604f, -0.01561951f, -0.04053479f, -0.05038061f, 0.03407716f, 
    -0.05667306f, 0.04332079f, 0.06041228f, 0.04923512f, 0.03090272f, -0.01563357f, -0.01490913f, 0.01536154f, 
    -0.01640345f, -0.03004447f, 0.01546981f, -0.00180118f, -0.02090536f, 0.00921050f, -0.07148407f, 0.00561031f, 
    0.05094993f, -0.04982543f, 0.04099771f, -0.06881872f, -0.05768429f, 0.02716239f, -0.01156968f, -0.06207221f, 
    -0.01541248f, 0.02663682f, -0.01862857f, -0.01477854f, -0.02450817f, 0.03663629f, -0.00288776f, 0.03921157f, 
    0.02031167f, -0.03380035f, -0.01979734f, 0.01920729f, -0.01778372f, -0.02300900f, 0.04607537f, -0.03990052f, 
    0.02488925f, 0.02114723f, 0.02872734f, -0.01249842f, -0.02633936f, -0.01704953f, -0.02395583f, -0.01053501f, 
    0.01706143f, -0.03537517f, -0.03373023f, 0.02287512f, 0.01633278f, -0.01148433f, -0.01355876f, -0.00587841f, 
    -0.02483325f, 0.05095127f, 0.00095166f, -0.01682173f, 0.04172171f, -0.06343278f, -0.04800010f, -0.00827484f, 
    0.41947356f, -0.27130118f, 0.38752028f, -0.09918468f, -0.11031424f, 0.18505982f, 0.02409781f, -0.00454694f, 
    0.18975876f, -0.23290150f, 0.01562682f, -0.45403492f, 0.04150804f, 0.11940165f, 0.17375065f, 0.10602474f, 
    0.01295845f, -0.04416404f, -0.78613830f, -1.03939974f, 0.32393926f, -0.47979134f, -0.23126358f, 0.12634432f, 
    -0.06410169f, 0.08986725f, -0.15877199f, 0.58729237f, -0.48431575f, -0.10853734f, 0.15318508f, -0.08045880f, 
    0.04492377f, 0.18875228f, 0.11686452f, 0.06746841f, -0.11349306f, -0.53440940f, 0.46411115f, -0.06818330f, 
    -0.09557874f, -0.04131044f, 0.12460431f, -0.11781176f, 0.27615353f, 0.68518549f, 0.27903983f, -0.46017948f, 
    0.26586187f, -0.09501384f, -0.12469730f, 0.03823050f, 0.11351731f, 0.00785892f, -0.00411072f, -0.17396739f, 
    0.49083930f, -0.00875609f, -0.02222044f, -0.32002085f, 0.06488959f, -0.01520544f, -0.07843720f, -0.12585463f, 
    -0.04670045f, 0.12179743f, -0.36602870f, -0.28889373f, -0.42566672f, 0.10006037f, -0.07613416f, -0.36391705f, 
    0.05443980f, -0.20161952f, -0.02980716f, -0.09805764f, 0.00965544f, -0.21669841f, -0.11502987f, 0.04655054f, 
    0.02554428f, 0.08222149f, -0.03469002f, 0.25879124f, 0.15379679f, -0.09006967f, 0.12315202f, 0.01853890f, 
    -0.04009404f, -0.00257854f, 0.12932846f, -0.67746711f, -0.22162049f, -0.04667373f, -0.22614516f, 0.12763850f, 
    -0.11256393f, -0.03229242f, 0.00834679f, -0.60307962f, 0.11350637f, 0.25369161f, 0.04038339f, -0.00333812f, 
    -0.04974677f, 0.07314105f, 0.13033086f, -0.16498180f, -0.31796104f, -0.16263738f, -0.19377282f, -0.21680348f, 
    0.01288324f, 0.03496780f, 0.19910447f, 0.05403610f, 0.42967501f, -0.71538156f, -0.35281438f, 0.19873944f, 
    0.04990683f, -0.00188909f, -0.37729502f, -0.22430603f, 0.08911646f, 0.16687244f, -0.96105313f, -0.17019494f, 
    -0.50017351f, 0.20621155f, 0.05104038f, -0.19636320f, 0.07414268f, -0.09576585f, 0.19933680f, 0.13559103f, 
    -0.08201090f, 0.40361199f, -0.00976399f, 0.25864711f, 0.20086192f, 0.07440379f, 0.08636066f, 0.07993019f, 
    -0.56079972f, -0.25644949f, 0.12174355f, -0.15547615f, -0.07417820f, -0.05729839f, 0.02242959f, 0.11777290f, 
    0.06550696f, -0.02244582f, 0.09930837f, 0.20744404f, -0.02983780f, -0.12174638f, 0.04412596f, 0.05351620f, 
    0.05022030f, 0.20035399f, -0.22854629f, -0.36294863f, -0.46600771f, -0.12869944f, -0.35059550f, -0.26144013f, 
    0.15000893f, 0.19375446f, 0.33338249f, 0.19354872f, -0.63728291f, -0.24426952f, 0.28283608f, -0.06543538f, 
    0.03752387f, 0.13011289f, 0.06044986f, 0.09531399f, 0.27400053f, 0.18005614f, -0.13455315f, -0.05372468f, 
    -0.00203655f, -0.09549048f, 0.02174550f, 0.07426356f, -0.10705968f, 0.01717130f, -0.18124686f, 0.20621112f, 
    -0.00915396f, 0.02445623f, -0.17304358f, 0.08589073f, -0.03537260f, 0.00169068f, -0.22154242f, 0.11434921f, 
    -0.76705873f, -0.08465215f, -0.12674744f, 0.12132100f, -0.00799632f, -0.14147830f, -0.31211430f, 0.00325792f, 
    -0.02894335f, 0.43440735f, -0.26509392f, -0.07807405f, -0.16679476f, -0.12764555f, 0.01898285f, -0.08008826f, 
    0.35575315f, -0.46393648f, -0.43930709f, 0.06507016f, -0.04314427f, -0.06800806f, 0.17551984f, -0.07585671f, 
    0.14650507f, -0.15564184f, -0.02517076f, 0.18644419f, -0.08529727f, -0.18706951f, -0.06422705f, 0.07648826f, 
    0.10351250f, 0.09372946f, -0.02258811f, -0.35597995f, -0.02912144f, -0.08004076f, 0.11248880f, 0.14321233f, 
    -0.11282342f, -0.24038789f, -0.15486194f, 0.83021015f, 0.02915785f, -0.11516222f, 0.05388810f, 0.03383178f, 
    0.07830381f, 0.31426188f, 0.15345623f, 0.07394937f, -0.03698580f, -0.00571786f, -0.25780261f, 0.03278768f, 
    -0.01635048f, 0.03524874f, 0.11615694f, 0.09829774f, 0.12073253f, 0.01354110f, 0.17353301f, 0.06599019f, 
    -0.14890322f, -0.05822010f, 0.04196639f, 0.05284181f, -0.11687063f, 0.03533714f, -0.19805862f, -0.00625056f, 
    0.16431326f, -0.18077183f, -0.17012419f, 0.04425978f, 0.19506223f, 0.10908896f, 0.05993529f, 0.19616616f, 
    -0.01347666f, 0.25530830f, -0.06288183f, 0.03139016f, 0.20119499f, 0.19356424f, 0.09522743f, 0.10281236f, 
    -0.15230553f, -0.36048183f, 0.09302156f, -0.17576772f, 0.11290915f, -0.23040539f, -0.11379565f, -0.08996036f, 
    0.02458879f, -0.50248498f, -0.12502584f, -0.41496506f, -0.01599147f, -0.35044217f, -0.25942391f, 0.00954774f, 
    -0.25634760f, -0.10290119f, 0.13584124f, 0.18398075f, -0.26327077f, -0.12115460f, 0.00512135f, 0.17850062f, 
    -0.03254043f, 0.06810464f, 0.03514336f, -0.71633869f, -0.15058354f, -0.34494582f, 0.04200626f, 0.18160632f, 
    -0.22528881f, 0.18056659f, 0.04352722f, -0.03523655f, 0.15421693f, -0.22572871f, 0.04635665f, 0.07836770f, 
    0.05198201f, 0.03419739f, -0.26096109f, -0.08332669f, 0.00641594f, -0.60635102f, -0.47531986f, -0.01115041f, 
    0.08989890f, 0.07996387f, 0.00627572f, 0.00405089f, 0.04471987f, -0.01841353f, 0.03680383f, 0.15572487f, 
    0.28552464f, 0.21293080f, 0.17907330f, 0.12939891f, -0.17806970f, -0.00143492f, 0.09043803f, -0.10796280f, 
    -0.26919863f, -0.67618203f, 0.15703818f, -0.14768873f, -0.16602638f, 0.03867282f, -0.05373972f, 0.16114460f, 
    -0.00517772f, 0.14951491f, 0.22733973f, -0.04876259f, -0.22599940f, -0.06283414f, -0.25118673f, -0.07409210f, 
    0.01502349f, 0.19114585f, 0.13676259f, 0.13628128f, 0.17490330f, 0.04839388f, -0.06866563f, 0.16687466f, 
    -0.02944358f, -0.01832208f, 0.32418591f, -0.20128734f, -0.24141006f, -0.06095517f, 0.11088084f, -0.04434112f, 
    0.12781532f, 0.17092223f, 0.03530362f, -0.04745169f, -0.20989618f, 0.16511543f, 0.14691612f, 0.06672201f, 
    -0.04155361f, 0.06730334f, -0.00523616f, 0.13131128f, -0.31893229f, -0.31203726f, 0.19016892f, -0.10366900f, 
    -0.11371498f, -0.06958171f, 0.02997508f, 0.14367484f, -0.18361516f, 0.20355059f, -0.44330567f, 0.00768885f, 
    -0.07761265f, 0.01691601f, -0.41406068f, 0.09013837f, 0.12869486f, -0.10366613f, -0.02489124f, -0.04933199f, 
    -0.28866583f, -0.37477210f, -0.21612532f, 0.04377266f, -0.27976134f, 0.09987774f, 0.28935391f, -0.03237939f, 
    0.05706563f, 0.00553142f, 0.04815450f, 0.05225867f, -0.10601465f, 0.09077503f, 0.03780228f, 0.05448131f, 
    0.23462892f, -0.48366553f, 0.24405503f, 0.31965247f, -0.05749588f, 0.14203098f, 0.05986574f, 0.15360376f, 
    0.04015143f, -0.23591450f, -0.28696704f, -0.32546723f, 0.00417045f, -0.05845434f, 0.12015959f, 0.13442725f, 
    -0.16047074f, -0.20034000f, -0.51862937f, -0.00724551f, -0.22610511f, 0.03511237f, -0.11009082f, -0.03050517f, 
    0.22712791f, 0.18760671f, 0.13965318f, 0.73543352f, 0.21945594f, -0.29284725f, -0.32104409f, -0.04189965f, 
    0.01588664f, 0.10669653f, 0.06931949f, -0.13322450f, -0.05174141f, -0.24919887f, -0.21737421f, 0.27587253f, 
    0.05381620f, -0.08473287f, -0.10268302f, -0.14597252f, -0.06180579f, -0.01114593f, 0.15548573f, 0.33714619f, 
    -0.08489705f, -0.02421668f, 0.38048756f, -0.14145295f, -0.13018483f, 0.27692589f, -1.05771422f, -1.06542170f, 
    -0.98594201f, 0.06692014f, -0.32152954f, -0.19693452f, 0.26954776f, 0.11293318f, 0.15995176f, 0.08861516f, 
    0.27846447f, 0.11472511f, -0.01145791f, -0.18391691f, -0.06214890f, 0.23962992f, -0.02733348f, -0.11367504f, 
    0.46006313f, -0.21517630f, -0.33720380f, -0.06416926f, -0.41081575f, 0.12367938f, -0.09229782f, 0.14103928f, 
    0.17751089f, 0.36491483f, 0.22246803f, 0.25367588f, 0.06447391f, 0.15872954f, -0.07810484f, 0.16756226f, 
    0.01564005f, 0.02291026f, 0.33678031f, 0.32736117f, -0.09895098f, -0.11965665f, 0.07965013f, -0.03877584f, 
    0.20887154f, 0.20222023f, 0.06695487f, -0.45972756f, 0.20074119f, 0.10725636f, -0.06493697f, 0.04771160f, 
    0.16929859f, 0.02641757f, 0.16669096f, -0.13932940f, 0.25550562f, 0.22302070f, 0.30212501f, 0.08092991f, 
    0.13571733f, 0.05525050f, 0.28775167f, 0.10496867f, 0.01977431f, -0.08370989f, -0.08429089f, 0.06004027f, 
    0.06807810f, -0.04021156f, 0.17311844f, 0.00618737f, 0.02236084f, 0.09247402f, 0.32508710f, 0.16453327f, 
    0.23528089f, 0.13464494f, 0.09841142f, -0.00473700f, 0.19400558f, 0.04654818f, -0.06870013f, 0.21317443f, 
    0.25772440f, 0.21296333f, 0.10953808f, -0.03489042f, 0.03784984f, 0.09524006f, 0.03812864f, 0.03774463f, 
    -0.05154410f, -0.01030606f, 0.01455728f, -0.02968346f, -0.05721234f, -0.02790212f, 0.01938890f, -0.03633326f, 
    -0.05620830f, -0.01196033f, 0.03434971f, -0.01997035f, 0.05008786f, -0.01168703f, -0.05352600f, 0.00909858f, 
    -0.01718919f, -0.01671935f, -0.04381917f, -0.04775814f, 0.01178413f, 0.01025813f, -0.03526291f, 0.01986743f, 
    -0.02489673f, -0.05059943f, -0.00335909f, 0.04132773f, -0.04529530f, -0.01627707f, -0.03201415f, -0.03491424f, 
    -0.05867460f, -0.03774281f, -0.06521089f, 0.03298156f, 0.01403627f, 0.01616005f, 0.03423591f, -0.03154692f, 
    -0.04611192f, -0.06790036f, -0.01135825f, -0.01307576f, 0.03623831f, 0.03891538f, -0.02773085f, 0.01072333f, 
    -0.02232338f, -0.01444281f, -0.05587862f, -0.06407239f, 0.04775652f, 0.02971761f, 0.01974028f, 0.01277798f, 
    0.01759304f, -0.00352290f, -0.00264792f, 0.03399319f, -0.04781480f, -0.03038121f, 0.02879815f, 0.04195043f, 
    -0.03256931f, -0.01745424f, 0.02441107f, -0.01441896f, -0.05792114f, -0.06242390f, 0.04029854f, 0.02583757f, 
    0.03304186f, -0.04997009f, 0.01090198f, -0.02321581f, 0.03371431f, -0.01686098f, 0.00995858f, 0.00239283f, 
    -0.05869561f, -0.01966250f, 0.05501727f, -0.04009719f, -0.01283510f, -0.02417721f, -0.03544440f, -0.03068575f, 
    -0.00279485f, 0.00729785f, 0.03481969f, -0.05457507f, 0.02313793f, -0.03326887f, -0.06082066f, -0.02674443f, 
    0.03357058f, 0.04580013f, -0.06275830f, 0.01691108f, 0.02025332f, 0.00500305f, -0.04346227f, -0.01260025f, 
    -0.04011529f, 0.02858385f, -0.00394458f, -0.05455136f, 0.01865190f, -0.05451889f, 0.00396562f, -0.00179937f, 
    0.00530880f, 0.00142821f, -0.05244801f, 0.00219567f, 0.03252845f, -0.00800434f, -0.05301607f, -0.03112156f, 
    0.05126144f, 0.02483543f, -0.01177285f, 0.00890486f, 0.04732189f, -0.01304581f, -0.03508399f, -0.04887112f, 
    -0.01723540f, -0.03311970f, -0.02907930f, 0.03143024f, -0.05013959f, -0.01643717f, -0.01677737f, 0.03338828f, 
    -0.02683736f, 0.03223677f, 0.03926402f, 0.01687255f, -0.01076026f, 0.03113458f, -0.06679513f, 0.02437198f, 
    0.04107040f, -0.03194786f, -0.00328611f, -0.00612385f, 0.03126536f, 0.01753720f, -0.00712354f, -0.04746213f, 
    0.01379099f, -0.05346313f, 0.04554039f, -0.03180101f, -0.03466969f, 0.03519075f, -0.00952627f, -0.02927224f, 
    0.04558967f, 0.03570811f, 0.02146620f, 0.00377648f, -0.00414805f, -0.00147648f, -0.02277798f, 0.04645483f, 
    0.04929247f, 0.04303932f, -0.06093378f, 0.01819053f, -0.05933839f, -0.00324094f, 0.04890339f, 0.03083609f, 
    -0.00010198f, 0.00154884f, 0.03714988f, 0.03970107f, -0.01996239f, 0.03847338f, -0.05925159f, 0.00988586f, 
    0.02882071f, 0.03940162f, 0.00578035f, 0.01421749f, -0.01332099f, -0.01855208f, 0.04545485f, 0.00927835f, 
    -0.00807602f, 0.00266629f, 0.02287680f, -0.02061078f, -0.02318802f, -0.04282397f, 0.02083630f, -0.01414773f, 
    0.01916497f, -0.01879746f, -0.02598420f, -0.03903962f, -0.01691449f, 0.03056112f, 0.03988523f, -0.00350480f, 
    0.04116372f, -0.05505780f, -0.05848057f, -0.04813910f, 0.02953600f, -0.00174259f, -0.02846447f, 0.00117354f, 
    0.00518409f, -0.04308352f, -0.02618612f, -0.04167174f, 0.05422915f, -0.01007922f, -0.02160798f, 0.04334100f, 
    0.00711925f, 0.04264008f, -0.03732686f, -0.03512117f, 0.03496738f, 0.04652694f, 0.06025046f, -0.04787292f, 
    0.01834911f, -0.00457334f, -0.04962623f, 0.00471547f, -0.02461353f, -0.01211179f, -0.06548443f, -0.05226833f, 
    0.02816824f, -0.04264826f, 0.01312357f, -0.06607239f, -0.00467409f, -0.01140671f, -0.00362183f, -0.01658134f, 
    0.02543423f, -0.01763787f, -0.01319791f, -0.05024784f, -0.04200971f, -0.03601664f, -0.05667268f, -0.04114147f, 
    -0.01200579f, -0.04374569f, 0.00338545f, -0.00513618f, -0.02358105f, -0.03364601f, 0.01726032f, 0.02996743f, 
    -0.04373721f, -0.05789378f, 0.01826325f, -0.02941114f, -0.05019606f, -0.05909179f, 0.04286575f, -0.02705659f, 
    -0.00062528f, -0.02669225f, -0.04925663f, -0.01498195f, 0.05078702f, -0.02602738f, -0.01073111f, 0.01595019f, 
    0.02217403f, -0.03695073f, -0.03667431f, 0.05096684f, -0.03031733f, -0.01775642f, -0.05279915f, 0.01405566f, 
    -0.00428909f, -0.02006791f, 0.02747290f, -0.03428643f, 0.03945205f, -0.04003956f, 0.01707208f, 0.04113724f, 
    0.04530761f, -0.01557121f, 0.01306332f, -0.05560128f, -0.04585947f, -0.03824367f, -0.06159622f, -0.05698608f, 
    -0.05619963f, -0.00362926f, 0.01760558f, 0.03863991f, 0.01273452f, -0.05213882f, 0.03255600f, -0.03861593f, 
    0.04120962f, -0.01477908f, 0.03627150f, -0.04130236f, -0.05808061f, 0.00893346f, -0.05582154f, -0.05540429f, 
    -0.06021424f, -0.04083956f, -0.02385827f, -0.05424980f, 0.03807455f, 0.01899850f, 0.01534865f, 0.00842272f, 
    -0.04350849f, 0.00798343f, 0.02578142f, 0.01805714f, -0.01580629f, -0.05258692f, -0.03288913f, -0.01994944f, 
    0.01351739f, -0.00394834f, -0.01065236f, -0.05915907f, -0.06257244f, -0.00407459f, -0.01509450f, -0.00351606f, 
    0.02449361f, -0.04803210f, -0.05746489f, 0.04360119f, -0.03649270f, -0.00342205f, -0.01569208f, -0.06376320f, 
    -0.01863695f, 0.00497078f, -0.00597375f, 0.00581814f, 0.03724494f, 0.04646712f, 0.04386409f, 0.02765645f, 
    -0.01866209f, -0.04239524f, 0.01077293f, 0.05729400f, -0.02032655f, -0.00905631f, 0.01117808f, 0.01854930f, 
    -0.01667403f, -0.02462183f, -0.03830616f, 0.04181864f, -0.00370275f, -0.05644091f, -0.03434400f, -0.05696874f, 
    -0.06239320f, 0.02619145f, 0.00131360f, 0.04576161f, 0.02681778f, -0.03151126f, 0.00133648f, 0.01790290f, 
    0.05336931f, 0.01969652f, 0.00125803f, 0.05244505f, -0.05488133f, 0.01157180f, -0.02252591f, 0.01490609f, 
    -0.00487731f, 0.00038654f, 0.04034974f, -0.03959403f, 0.00970283f, -0.05850478f, -0.06138611f, -0.05551516f, 
    -0.01643691f, 0.01426169f, 0.03018827f, -0.01205825f, -0.02758133f, -0.04661543f, -0.00876233f, 0.04537252f, 
    -0.01321768f, -0.04833522f, -0.06194422f, -0.00377104f, 0.00138812f, 0.02930279f, -0.03738766f, -0.05953095f, 
    0.00420857f, 0.03423896f, 0.01400064f, -0.00656680f, -0.01159318f, -0.01153369f, -0.04524231f, 0.04466856f, 
    0.03251012f, 0.00740177f, -0.01482456f, -0.03155886f, 0.04882861f, -0.06470457f, -0.01418854f, -0.02809903f, 
    -0.00808703f, -0.05363380f, -0.02382064f, -0.05280793f, 0.01791405f, -0.02350320f, -0.00503747f, -0.03770750f, 
    -0.03864770f, 0.00328413f, 0.02892277f, 0.03791020f, -0.05087875f, 0.03779217f, 0.04514207f, -0.00269078f, 
    -0.01440279f, -0.01912789f, -0.04401179f, 0.02253967f, -0.04956087f, -0.00660460f, 0.02725611f, 0.01973507f, 
    0.04219420f, 0.02084953f, 0.05243932f, -0.03513041f, -0.04987199f, 0.04428028f, -0.03320355f, -0.05147766f, 
    -0.05844242f, -0.06110948f, 0.03859358f, 0.04782364f, 0.04067613f, 0.00370334f, 0.02983643f, -0.01444996f, 
    0.04983218f, -0.04743747f, -0.00960462f, 0.04589577f, -0.01349120f, -0.04718261f, -0.02460296f, -0.05060801f, 
    -0.02698080f, -0.02896740f, 0.00591660f, -0.05304715f, 0.02838767f, -0.05724981f, 0.00989641f, -0.04222370f, 
    0.02257447f, -0.00144689f, -0.06058013f, 0.00668897f, -0.02442504f, 0.01679994f, -0.01543815f, -0.00434147f, 
    0.04353679f, 0.01427571f, -0.05185792f, 0.03516266f, -0.01021303f, -0.05178590f, -0.04485501f, 0.03075548f, 
    -0.03310231f, -0.03767645f, 0.03128275f, -0.01222597f, -0.00158555f, -0.03333107f, -0.03323379f, -0.05414831f, 
    -0.03085702f, -0.00895582f, 0.04709733f, -0.05586052f, 0.00362000f, 0.05167654f, -0.04070151f, -0.04285677f, 
    -0.04031635f, 0.03646861f, -0.03768922f, -0.04791380f, -0.04904272f, -0.03450036f, 0.04410183f, 0.02229450f, 
    -0.05032420f, -0.03106326f, -0.01738291f, 0.04290306f, 0.01860486f, -0.06432840f, -0.00956205f, 0.05539179f, 
    -0.00814374f, 0.04715773f, 0.00225839f, -0.00623496f, 0.04186390f, -0.05850532f, -0.03309227f, 0.04962686f, 
    0.01834224f, -0.06246699f, 0.03790450f, -0.01429871f, 0.00057198f, 0.03204312f, -0.01706005f, -0.02415976f, 
    0.03838788f, 0.00632989f, 0.05118781f, 0.04724403f, -0.02840925f, 0.01269024f, 0.02920721f, 0.04036288f, 
    -0.02294597f, -0.03001637f, -0.04624578f, 0.04636871f, -0.01632259f, 0.03815277f, 0.02921374f, -0.05607095f, 
    -0.04285767f, -0.02533185f, 0.02206574f, 0.00975392f, 0.03640870f, -0.01530648f, -0.02174459f, -0.03842843f, 
    0.00105294f, 0.00847955f, -0.04169823f, -0.04975057f, -0.05798584f, -0.05891391f, 0.02961344f, -0.04890974f, 
    -0.01574028f, -0.03402504f, -0.03677454f, 0.03523781f, 0.02697364f, 0.03849030f, 0.00045226f, -0.04685214f, 
    -0.03499249f, 0.03118937f, -0.01011823f, 0.02487056f, 0.04751096f, 0.01579847f, -0.04810103f, 0.02168691f, 
    -0.01773854f, -0.04481131f, -0.02447525f, 0.03960234f, -0.06068677f, 0.00912921f, 0.02002797f, 0.02739689f, 
    -0.03585365f, 0.02396214f, 0.05301650f, 0.04014851f, 0.04726767f, 0.04763248f, -0.04576346f, -0.01279026f, 
    -0.03000850f, -0.03164648f, 0.03753233f, 0.02568953f, 0.04368564f, -0.03944939f, 0.04126621f, -0.05213889f, 
    -0.00434134f, -0.03576861f, -0.03298907f, -0.00349517f, 0.00550323f, 0.04870460f, -0.01757574f, -0.01371423f, 
    0.01915382f, -0.02770112f, -0.03822299f, -0.04862981f, -0.03620509f, -0.05534792f, 0.03236098f, 0.04171449f, 
    -0.01725001f, 0.02406586f, 0.02840402f, -0.00297375f, -0.05443272f, 0.02084651f, 0.02690175f, -0.04060374f, 
    0.03167963f, -0.00641431f, 0.00057968f, -0.01371477f, -0.02673436f, -0.02085583f, -0.00719522f, -0.05158973f, 
    0.01168142f, -0.03435322f, 0.02637107f, -0.02141965f, 0.01611151f, 0.00921055f, -0.00867258f, 0.03447298f, 
    0.01480220f, 0.00958351f, 0.01825511f, 0.04934731f, -0.04766577f, -0.05280654f, 0.01573477f, -0.01322000f, 
    0.00745006f, 0.02148430f, -0.04281639f, -0.00397097f, 0.03978164f, -0.04541452f, -0.01496420f, -0.01442471f, 
    0.01107307f, 0.00751097f, -0.03419190f, -0.01248449f, 0.00997098f, -0.03219059f, 0.02925567f, -0.02064517f, 
    -0.00386894f, 0.02935151f, 0.01136971f, -0.00897492f, -0.05096058f, -0.02033069f, -0.01109944f, 0.01550318f, 
    -0.03850693f, -0.01672650f, -0.00234343f, 0.01903535f, 0.00463352f, -0.06281110f, -0.04751409f, -0.00409279f, 
    -0.05589117f, -0.00425585f, -0.06145839f, 0.00653769f, 0.04342594f, -0.04281349f, 0.02069343f, 0.04521212f, 
    -0.05265189f, 0.01222488f, -0.06294204f, -0.03430394f, -0.05863030f, 0.03326961f, -0.06061513f, -0.04481265f, 
    0.01534986f, -0.04733289f, -0.06329244f, -0.03964663f, 0.02618844f, -0.06077152f, -0.01383356f, -0.05128973f, 
    0.03605524f, 0.04604668f, 0.00735962f, -0.02103610f, 0.04372913f, -0.02053427f, -0.04794535f, 0.02855008f, 
    0.04959825f, 0.03473553f, -0.00516637f, -0.05137239f, -0.05337783f, -0.05890184f, -0.00315247f, 0.03532602f, 
    0.02695059f, 0.00436228f, -0.01981373f, 0.05132065f, 0.00563832f, 0.01239332f, -0.02225418f, 0.05379964f, 
    -0.05020569f, -0.06245627f, 0.03509638f, 0.03346498f, 0.02435202f, 0.05277922f, 0.03561686f, -0.05340648f, 
    0.04360670f, 0.00107679f, 0.01424098f, 0.02521228f, -0.05417678f, 0.03183803f, -0.01784965f, 0.04043045f, 
    0.05239885f, 0.00798289f, -0.04938002f, -0.02698679f, -0.02226899f, -0.05049424f, -0.02885463f, 0.02191146f, 
    0.00562090f, -0.03845827f, -0.03012250f, 0.03478496f, 0.02912076f, -0.02161986f, -0.04211431f, -0.03127083f, 
    0.04569527f, -0.03211638f, -0.05003728f, 0.03125922f, -0.03714731f, 0.00900525f, -0.02025230f, -0.01758975f, 
    -0.05330889f, -0.03072304f, 0.03773356f, -0.04651379f, -0.05514022f, 0.03709739f, 0.00774510f, -0.00038181f, 
    0.04276732f, 0.02274252f, -0.05385469f, -0.05955869f, 0.03801880f, 0.02060749f, -0.01537880f, 0.03128015f, 
    -0.02379593f, 0.05075031f, -0.01038290f, 0.02626954f, -0.04504329f, -0.04250572f, -0.02199493f, -0.02526217f, 
    -0.03812455f, 0.01711132f, -0.03779529f, 0.00080395f, -0.04801622f, 0.04641094f, 0.01471846f, 0.01289865f, 
    0.05214263f, -0.06174861f, -0.04208158f, 0.04748865f, -0.03633586f, 0.05282465f, -0.03383303f, 0.03170607f, 
    0.00344518f, 0.00960659f, -0.01953608f, 0.00203847f, 0.03482888f, -0.02184640f, 0.01405140f, 0.03728919f, 
    -0.00725660f, -0.02344438f, 0.00387720f, -0.06399394f, 0.01816007f, -0.04914542f, -0.02471413f, -0.02637671f, 
    0.02335878f, -0.02100813f, 0.04687807f, -0.00941478f, -0.04718730f, -0.00413118f, -0.03579080f, 0.02195494f, 
    0.05642837f, -0.00812493f, 0.00104610f, -0.02154887f, -0.05241878f, -0.03534116f, -0.02228140f, 0.03643038f, 
    -0.20873395f, 0.20745227f, -0.28136227f, 0.18049471f, -0.19274743f, -0.02308701f, -0.07326648f, 0.13186954f, 
    0.00072226f, 0.54466969f, 0.28897256f, -0.15905447f, 0.13033421f, -0.12991215f, 0.09530596f, 0.04168611f, 
    0.16824614f, -0.06667734f, 0.52938849f, 0.15254891f, -0.13383999f, 0.08620724f, -0.08390699f, -0.13014969f, 
    -0.22285068f, 0.07556422f, 0.03232765f, -0.34622613f, -0.00150353f, -0.81939399f, -0.01930498f, 0.05363551f, 
    0.11418983f, -0.16679449f, 0.15100849f, 0.00592587f, -0.03395913f, -0.26418462f, 0.37865317f, 0.06157588f, 
    0.04017693f, -0.03148261f, 0.07216260f, 0.00308167f, 0.33473656f, -0.14383782f, 0.14050460f, -0.43273523f, 
    -0.02760002f, 0.15204743f, 0.05282887f, -0.01820436f, -0.02163623f, -0.15648881f, -0.06718048f, -0.00752319f, 
    0.23617272f, 0.22717761f, 0.18057008f, 0.03758724f, -0.00058703f, -0.01944128f, -0.02657785f, 0.27916422f, 
    0.29868498f, -0.03852915f, 0.03673463f, 0.09749166f, 0.17153308f, 0.11280572f, 0.10606944f, -0.01467894f, 
    0.28347388f, 0.15869439f, 0.48639283f, -0.02919922f, -0.15717217f, 0.07010427f, -0.14111617f, -0.16891941f, 
    -0.02363133f, 0.16900174f, 0.07808935f, 0.37689659f, 0.26522768f, 0.21688792f, 0.01388055f, 0.14520900f, 
    -0.05872580f, -0.00762108f, -0.38109586f, -0.27748546f, -0.66118139f, 0.04610899f, 0.04771357f, 0.18074417f, 
    -0.06484953f, 0.00214747f, 0.18381038f, 0.26854205f, -0.04301194f, 0.05063015f, -0.18303744f, 0.10342202f, 
    -0.08403134f, -0.16075392f, -0.05628872f, 0.13010316f, -0.03074309f, -0.56313431f, -0.23395467f, 0.02680011f, 
    -0.00391551f, -0.07436511f, -0.02113991f, -0.20824715f, 0.08523982f, -0.16745767f, -0.18972218f, -0.31615952f, 
    0.09992521f, 0.08177954f, -0.18878600f, 0.10140365f, 0.02656070f, -0.11779651f, 0.15883394f, -0.15761937f, 
    -0.31363511f, -0.33683011f, -0.14604618f, -0.25861788f, -0.14055800f, -0.00313595f, 0.13786837f, 0.02407340f, 
    -0.04318960f, 0.15288146f, 0.09903964f, -0.01391474f, 0.06289584f, 0.11764645f, 0.11307364f, 0.02683214f, 
    0.12164728f, -0.08747704f, 0.56682831f, -0.05049491f, -0.01285259f, -0.13125011f, -0.02585489f, -0.10394998f, 
    -0.01662293f, -0.04669709f, 0.39930084f, -0.06577371f, -0.01613705f, 0.05933456f, 0.00998028f, 0.00944065f, 
    0.10964546f, -0.05774067f, 0.02916348f, -0.22932246f, -0.05707309f, -0.00860072f, -0.32364881f, -0.11418456f, 
    0.17343308f, 0.03045312f, 0.11194948f, -0.45869327f, 0.25691301f, -0.08073783f, -0.09142222f, -0.14290436f, 
    -0.11084706f, -0.11634106f, 0.11032849f, -0.00876085f, -0.13022035f, -0.11766409f, -0.03112633f, 0.02470897f, 
    -0.05705044f, 0.04682506f, -0.14477961f, -0.09307537f, 0.10413460f, 0.04213528f, -0.39283079f, 0.47655806f, 
    -0.14242497f, -0.12118993f, 0.01974020f, 0.09876564f, -0.15442872f, 0.25134340f, 0.07224524f, -0.08674844f, 
    -0.26964259f, -0.02176768f, -0.12956016f, 0.06141070f, 0.00153430f, 0.12137429f, -0.03495463f, -0.05163690f, 
    0.11113328f, 0.45007476f, -0.02992945f, 0.06974700f, -0.01760723f, 0.02097198f, -0.02266933f, -0.11088221f, 
    -0.17468986f, -0.08961175f, -0.04404390f, 0.00567420f, 0.02898601f, -0.34237474f, -0.01125382f, 0.30359238f, 
    0.08170666f, -0.22464047f, -0.11156553f, 0.24391563f, -0.06669706f, -0.34205472f, -0.12980145f, 0.08522186f, 
    -0.00343961f, -0.09291963f, 0.02870133f, 0.38907787f, 0.37879291f, 0.19483285f, 0.10159542f, -0.04215983f, 
    0.14737932f, -0.20624207f, 0.03432526f, -0.50380814f, 0.00643212f, -0.33847579f, 0.05620499f, 0.08993489f, 
    0.17745939f, 0.14010218f, -0.07852600f, 0.03056480f, 0.31199804f, 0.42883375f, 0.24406651f, 0.21263133f, 
    -0.04257660f, 0.05836175f, 0.00859740f, -0.05317833f, -0.27309656f, -0.19958963f, -0.03829720f, 0.06585751f, 
    -0.07177099f, -0.13333876f, 0.01685559f, 0.02645211f, 0.05481015f, -0.04956370f, -0.14133561f, -0.31962338f, 
    0.01963684f, -0.10988561f, -0.34744036f, -0.17394403f, 0.17650653f, -0.05011644f, -0.01124007f, -0.12017456f, 
    0.08355030f, 0.22300118f, 0.05243374f, -0.07962857f, 0.06110495f, 0.12346789f, -0.06073537f, 0.03286184f, 
    -0.36752632f, -0.11149516f, -0.03385085f, -0.12768254f, -0.29671878f, 0.11526250f, -0.04141298f, 0.26339325f, 
    0.02862212f, 0.34975678f, 0.15730967f, 0.04626811f, -0.15579851f, -0.09436825f, 0.42169207f, -0.05484826f, 
    0.02362639f, 0.01181489f, -0.04293016f, 1.10359609f, 0.15558340f, 0.05734307f, -0.14112552f, -0.13454382f, 
    0.30016747f, -0.04208644f, -0.11106556f, -0.84147394f, -0.21940356f, -0.01136885f, 0.04079790f, -0.23794286f, 
    -0.16655411f, 0.01720814f, 0.20948125f, -0.15763113f, -0.45968589f, -0.19449252f, -0.06556402f, 0.32830939f, 
    -0.05370987f, -0.03410635f, 0.04705464f, 0.00499213f, -0.25437400f, 0.23313034f, -0.88774663f, -0.03542761f, 
    0.13265537f, -0.17057770f, -0.18306053f, 0.05615902f, -0.03336844f, 0.05816400f, 0.14947790f, 0.00265980f, 
    0.07257436f, -0.03976305f, 0.03781230f, -0.07628825f, -0.10911116f, 0.04338527f, -0.07764003f, 0.27158347f, 
    -0.76972836f, -0.25503141f, 0.20265728f, 0.21011542f, 0.15311830f, -0.14401901f, -0.16749580f, -0.16726337f, 
    0.32790944f, 0.16477183f, 0.42188224f, -0.48072460f, -0.14000504f, -0.24106069f, -0.21422322f, 0.09305683f, 
    0.12969308f, 0.24731952f, 0.44126534f, -0.14480011f, -0.08999900f, -0.12356712f, -0.02620113f, 0.17894824f, 
    -0.14307164f, 0.03642217f, -0.75617188f, -0.35908791f, 0.03846658f, -0.12556054f, 0.02944841f, -0.02164748f, 
    0.21486484f, 0.13446234f, 0.13623068f, 0.56466824f, 0.62122887f, -0.25193802f, 0.06788678f, 0.05843103f, 
    0.28784925f, -0.21198460f, -0.14831050f, 0.09892666f, 0.01929953f, -0.01255214f, 0.09992184f, 0.00092914f, 
    0.11199263f, -0.04939486f, 0.02259372f, 0.23059799f, 0.22928545f, -0.07497733f, 0.24550135f, 0.37806764f, 
    -0.14350905f, -0.03634516f, 0.23321180f, -0.13747057f, 0.03057390f, 0.38001341f, -0.13320851f, 0.01671454f, 
    -0.06133468f, -0.07709063f, 0.13420643f, 0.13802503f, -0.03600533f, -0.10911236f, 0.04722220f, -0.06903220f, 
    0.21473534f, 0.32791197f, -0.27435946f, 0.00647698f, 0.05905196f, 0.00337640f, 0.00014150f, 0.05998878f, 
    -0.06051425f, 0.16405863f, -0.15034281f, 0.30915791f, 0.04071255f, -0.19982591f, -0.11054906f, 0.26046461f, 
    0.02110251f, -0.31433970f, -0.00918820f, -0.26210982f, 0.04422793f, -0.19898853f, 0.03682904f, 0.19148961f, 
    0.21325023f, -0.12125157f, 0.35147700f, -0.26490098f, 0.07416902f, 0.00557957f, 0.01492309f, -0.13974300f, 
    -0.07033556f, 0.22752756f, 0.17580596f, -0.64353520f, -0.58562320f, -0.10697976f, 0.03684748f, -0.07738293f, 
    -0.10295209f, -0.33280975f, 0.24875271f, -0.07540920f, -0.15868381f, -0.03061874f, -0.03530776f, -0.00214322f, 
    -0.02507083f, -0.09063928f, -0.01726490f, 0.29012883f, -0.17493258f, -0.36904579f, -0.03249327f, -0.19216186f, 
    0.28763509f, -0.00141832f, -0.10735655f, -0.10078974f, -0.01889017f, 0.21367520f, 0.61696804f, -0.24056271f, 
    -0.16627060f, -0.03239358f, -0.07806109f, 0.22315688f, -0.28804618f, -0.25497696f, -0.14617804f, 0.30266649f, 
    0.13458186f, -0.10945362f, 0.02366030f, -0.16012940f, 0.14180350f, -0.05385353f, -0.11043572f, 0.16862696f, 
    0.26635724f, -0.28604621f, -0.35179037f, 0.22025359f, -0.03196546f, -0.25370148f, 0.12687945f, -0.36423942f, 
    0.08951131f, 0.26249665f, 0.18396285f, 0.08113997f, -0.04567427f, 0.15015775f, -0.18180417f, -0.05284743f, 
    -0.07309934f, 0.00479057f, -0.34920084f, 0.45747814f, 0.09057184f, -0.12611686f, -0.01313437f, 0.35667485f, 
    0.05662709f, -0.00934245f, -0.04299485f, -0.26324144f, -0.47881931f, 0.29539832f, -0.16983126f, -0.00723177f, 
    -0.14606716f, 0.18008949f, 0.09178484f, 0.03139324f, 0.12059458f, 0.10990843f, -0.21370566f, 0.12435519f, 
    0.06191531f, 0.04458867f, -0.09936307f, 0.10380910f, 0.03149246f, 0.24028277f, 0.08178868f, 0.01958312f, 
    0.25700393f, -0.01209617f, 0.01416734f, 0.05343352f, 0.09191424f, 0.14581782f, 0.30684954f, 0.20867701f, 
    0.10148989f, 0.11613466f, -0.06553137f, 0.06707159f, -0.05065817f, -0.02057131f, -0.05044983f, 0.21765837f, 
    0.17342533f, 0.11740883f, 0.11002871f, -0.19118130f, -0.24049090f, 0.04979745f, -0.08056842f, -0.01716119f, 
    0.18478473f, 0.18928841f, 0.20122038f, 0.14660522f, 0.08246714f, 0.15599212f, -0.04138793f, 0.18977347f, 
    0.30703530f, -0.11647870f, -0.27684453f, -0.41891041f, -0.03617992f, 0.67243522f, 0.19692698f, 0.22712404f, 
    0.09964728f, 0.05753572f, 0.08903940f, -0.41960534f, -0.63651681f, -0.32681552f, -0.19337618f, 0.00800159f, 
    0.06320216f, 0.13638207f, 0.03965611f, 0.30087438f, 0.04479271f, 0.16114049f, 0.08144438f, -0.02244467f, 
    -0.00625263f, 0.28233850f, 0.22374687f, 0.01284300f, -0.29096064f, -0.68998146f, -0.32927459f, -0.09316117f, 
    0.22810872f, 0.02202774f, 0.09515987f, -0.06344582f, -0.09541468f, 0.16131195f, 0.24879448f, 0.10301697f, 
    0.01895928f, 0.00260727f, -0.12128573f, -0.03028125f, 0.09032778f, -0.03438390f, -0.33483535f, -0.09277322f, 
    -0.22019693f, -0.01156713f, 0.01033437f, 0.06297736f, -0.10899280f, 0.03083382f, -0.04038815f, 0.03448111f, 
    0.14271428f, 0.17576189f, -0.19906087f, -0.11035408f, -0.16869383f, -0.17473154f, -0.25889030f, -0.11732996f, 
    0.14449354f, 0.16951457f, 0.45522100f, -0.24384186f, 0.00336817f, -0.17500378f, -0.08543987f, 0.05598301f, 
    0.04383159f, -0.42037404f, -0.18252982f, -0.06634858f, 0.03702928f, 0.20212431f, 0.17240816f, 0.01794758f, 
    0.04949445f, 0.20743588f, 0.37661543f, 0.09574458f, 0.03110783f, 0.07938706f, -0.15440652f, 0.02993028f, 
    0.26217762f, 0.11825333f, 0.20457570f, 0.19660646f, -0.07658932f, -0.11657794f, 0.05512566f, 0.17541620f, 
    0.34114933f, 0.17101793f, -0.07960799f, 0.12819904f, 0.19907394f, 0.24292941f, 0.02592496f, -0.06541703f, 
    -0.18586868f, -0.08332238f, 0.26824620f, 0.14008720f, -0.10588009f, 0.14338976f, 0.34559557f, 0.20028545f, 
    0.06561954f, -0.01366974f, -0.06884795f, 0.05993537f, -0.05875854f, 0.14200491f, 0.25848538f, 0.11434247f, 
    -0.05059405f, -0.17299040f, -0.06499220f, 0.10230653f, 0.14181907f, -0.16211395f, 0.01676534f, 0.02525706f, 
    0.49397835f, 0.15817261f, -0.07395352f, -0.05014182f, 0.08491623f, 0.00520658f, -0.00577568f, 0.13243085f, 
    -0.64999521f, -0.58542091f, -1.16263402f, -0.48620072f, -0.01368874f, -0.01094256f, -0.09874039f, -0.23509839f, 
    0.02681918f, -0.15159443f, -0.26233572f, -0.32810462f, 0.07969555f, 0.08001129f, -0.08028283f, 0.16555990f, 
    0.06425077f, -0.04750832f, 0.08896887f, 0.07498538f, 0.04851281f, -0.05664847f, -0.11189510f, -0.14375824f, 
    -0.02598996f, -0.15567183f, -0.13530199f, -0.06326239f, -0.59714025f, -0.25221753f, -0.21193552f, 0.17225334f, 
    -0.36395973f, -0.00487542f, -0.08955859f, -0.02143131f, 0.09771208f, -0.01230545f, -0.00512382f, 0.15985821f, 
    0.12808309f, -0.00755150f, 0.32526112f, 0.11657205f, 0.15530659f, -0.55111545f, -0.94211072f, -0.69859928f, 
    -0.42929798f, -0.18071449f, -0.12670442f, 0.23331106f, -0.23330648f, -0.19909833f, -0.25662768f, -0.02447666f, 
    -0.49227414f, 0.15004702f, 0.66350389f, -0.19475874f, 0.14830652f, 0.30977693f, -0.10427216f, 0.53202087f, 
    -0.18605049f, -0.01731849f, -0.23168027f, -0.17372432f, -0.13609074f, -0.20538567f, -0.08259145f, -0.08078342f, 
    0.18424100f, 0.19020483f, 0.09013718f, -0.15338305f, -0.00024373f, -0.17457709f, 0.11931677f, 0.16737951f, 
    0.00818026f, -0.01936314f, -0.67400795f, -0.59006554f, -0.07720261f, -0.47035524f, -0.06753594f, 0.11915636f, 
    0.05286541f, -0.01573149f, -0.06371643f, -0.22411342f, -0.15314686f, -0.00898642f, 0.11029491f, -0.01689563f, 
    0.17357780f, -0.00174147f, 0.11697830f, 0.21064647f, 0.18236823f, -0.03130405f, -0.05714485f, -0.07046495f, 
    -0.05924353f, 0.04987570f, 0.03249287f, 0.06197238f, -0.17031971f, -0.64045435f, -0.31383708f, -0.24758883f, 
    -0.10883021f, -0.22014646f, 0.10672965f, -0.16133673f, -0.21935196f, -0.04549525f, -0.46513522f, -0.93719655f, 
    -0.16706297f, -0.07162184f, -0.12107369f, -0.05348304f, -0.03169895f, 0.05137583f, 0.17929637f, -0.73503506f, 
    -0.74961215f, -0.15112281f, -0.11610692f, 0.23764053f, 0.21266645f, 0.01241574f, 0.01492619f, 0.20387571f, 
    -0.44956017f, -0.08341102f, 0.13589798f, -0.11096272f, 0.35957479f, -0.00272960f, 0.10884560f, 0.07033638f, 
    -0.03357891f, -0.04026762f, 0.00908745f, 0.00535840f, -0.03648869f, 0.03389411f, -0.02345425f, 0.03407998f, 
    -0.00871868f, -0.01478689f, 0.01641925f, -0.04672681f, -0.04192179f, 0.05733706f, 0.04700727f, -0.05990827f, 
    0.02303904f, -0.04299769f, -0.01078612f, -0.06225013f, 0.00549825f, 0.00410780f, 0.01522088f, -0.00796436f, 
    -0.04639016f, 0.03020049f, 0.04782515f, -0.05054381f, 0.00960700f, -0.04505644f, -0.04005986f, -0.01089404f, 
    -0.04002778f, -0.01422126f, -0.01899869f, -0.01346370f, 0.00929756f, -0.06034001f, 0.05667659f, -0.03367893f, 
    0.05107689f, -0.00487852f, -0.00659795f, 0.02578744f, -0.00252948f, 0.00783557f, 0.02378272f, 0.00027267f, 
    0.00902758f, 0.02030672f, 0.02527962f, 0.00395683f, -0.00476427f, -0.05304061f, -0.01777190f, -0.04763007f, 
    0.03081999f, -0.00652610f, 0.03263625f, 0.00770444f, -0.02232974f, 0.00658596f, 0.01842286f, -0.03840574f, 
    0.04251651f, -0.04961715f, -0.04778176f, -0.06041843f, -0.05148375f, -0.00379581f, -0.04472002f, -0.03517304f, 
    0.03633190f, 0.03821785f, -0.01090973f, 0.05521068f, -0.00858566f, -0.02893751f, -0.06829931f, -0.02952608f, 
    -0.06269170f, -0.01251830f, -0.02917789f, -0.05820462f, 0.03188913f, -0.02919134f, -0.05463549f, 0.02358267f, 
    -0.03076320f, -0.05614145f, 0.03846491f, -0.06731953f, -0.01909875f, -0.02930457f, -0.01159673f, -0.02932216f, 
    -0.05222412f, -0.04386429f, 0.02108201f, 0.01906368f, 0.02110440f, 0.05050511f, -0.03233343f, 0.04396939f, 
    -0.05058246f, -0.04742859f, 0.04532775f, 0.00020417f, -0.04312465f, -0.04797028f, -0.03976547f, -0.01517321f, 
    -0.03629661f, 0.01171524f, -0.01907493f, 0.01495852f, -0.00108886f, -0.00560222f, -0.05915152f, -0.06359031f, 
    -0.06437604f, 0.00360555f, 0.00658531f, -0.04559398f, 0.04526893f, -0.04187303f, 0.04019036f, -0.00985057f, 
    -0.06823433f, 0.01675464f, -0.06058652f, 0.02458071f, -0.01292120f, 0.03369537f, 0.03495675f, 0.00767982f, 
    0.00488152f, -0.03611008f, -0.03100339f, 0.02807219f, 0.05087952f, 0.04253158f, -0.02851440f, -0.03888056f, 
    -0.00723313f, -0.00478830f, -0.04155702f, 0.03068973f, 0.01868165f, -0.03570634f, 0.01301879f, -0.03472389f, 
    -0.05184215f, -0.03688972f, -0.01697024f, -0.02446183f, 0.04781139f, -0.02474264f, 0.03474160f, 0.03044291f, 
    0.03737868f, -0.04405511f, 0.02107293f, -0.03046616f, 0.01446087f, -0.06312141f, 0.00879958f, 0.04143423f, 
    0.01379159f, -0.02871502f, -0.01960848f, -0.03963047f, 0.04412072f, -0.05842023f, 0.04062576f, 0.00771147f, 
    -0.02399592f, -0.04552660f, 0.03292916f, 0.02092167f, -0.05476477f, 0.01731905f, 0.04469777f, 0.04782312f, 
    0.02838988f, 0.04905080f, 0.03063120f, -0.03215742f, -0.06310726f, 0.01087797f, -0.00210052f, 0.06233318f, 
    0.01628388f, 0.01371687f, 0.02651654f, 0.04125134f, -0.01010228f, -0.01007747f, -0.02729562f, -0.00922753f, 
    0.06496772f, 0.02142118f, -0.00271330f, -0.00618773f, 0.01660267f, -0.03803343f, -0.06008552f, -0.03092510f, 
    0.03126720f, 0.01070773f, -0.00038340f, -0.05561564f, 0.04991867f, -0.04216305f, -0.05515349f, 0.05403668f, 
    0.00058696f, -0.04079195f, -0.05203493f, -0.02311436f, 0.04573855f, -0.05003987f, -0.04718272f, -0.05144144f, 
    0.01291233f, 0.01081887f, -0.02632751f, -0.03475745f, -0.02090869f, 0.03877102f, -0.01648173f, -0.01121860f, 
    -0.03825091f, -0.03693960f, -0.03811313f, -0.05708151f, -0.03504842f, -0.06047573f, -0.00786980f, 0.00135786f, 
    -0.06626773f, -0.06185412f, 0.02025797f, -0.03174004f, -0.02183273f, -0.00856362f, 0.02760057f, 0.02379653f, 
    0.02707254f, 0.00950044f, -0.02059549f, -0.05085239f, -0.01611191f, 0.04774444f, -0.00374030f, 0.04416459f, 
    0.04970923f, -0.05034078f, -0.04035984f, -0.00286864f, 0.03300891f, 0.02878553f, 0.04690025f, -0.04868304f, 
    0.01975477f, 0.02265114f, 0.05564652f, -0.05589109f, -0.01842464f, -0.04887735f, -0.07175904f, 0.04030308f, 
    0.05192769f, -0.04604750f, -0.01954286f, -0.03331136f, -0.03746749f, -0.00700970f, -0.04298551f, 0.01696152f, 
    0.04771730f, 0.04463767f, -0.03525274f, 0.04591669f, -0.01532059f, -0.03082556f, -0.03580863f, -0.01200528f, 
    -0.05279773f, -0.03600592f, -0.03916690f, -0.05859592f, -0.06138358f, 0.00896362f, 0.02628200f, -0.06663417f, 
    0.02695047f, -0.01106209f, 0.03234194f, 0.02419938f, -0.05804074f, -0.02095049f, 0.01898798f, -0.01012435f, 
    -0.06541098f, -0.06078069f, 0.01950409f, 0.06742039f, 0.03818159f, 0.00913455f, 0.04206543f, 0.00035114f, 
    0.01096472f, 0.03824811f, 0.02425353f, -0.06179198f, 0.03980762f, 0.03780489f, 0.02063861f, 0.00172879f, 
    -0.04543117f, -0.04318973f, -0.03081777f, -0.03357463f, 0.02525366f, -0.03783896f, -0.04622412f, -0.05414964f, 
    -0.01711782f, -0.02023493f, -0.05003186f, -0.00658955f, -0.05067368f, 0.01063686f, -0.02013206f, 0.02958477f, 
    0.01797760f, -0.03608140f, -0.05886638f, -0.00628043f, -0.00436316f, 0.01065383f, -0.00355794f, -0.04014929f, 
    0.04203541f, 0.03760834f, 0.03393876f, -0.05309738f, -0.00728317f, 0.04652191f, -0.02257238f, -0.05140024f, 
    -0.04093367f, 0.05930207f, 0.00292320f, -0.01424531f, 0.02393245f, -0.01058907f, -0.05746265f, -0.05675006f, 
    0.03188839f, -0.00489445f, -0.02514074f, -0.01454935f, 0.01267318f, 0.01343267f, 0.03621736f, -0.03149289f, 
    -0.03585128f, -0.01660677f, -0.06418861f, -0.05703874f, -0.05970114f, 0.03170221f, 0.03520900f, -0.05491088f, 
    0.01373247f, -0.00311780f, -0.00195200f, -0.04057471f, 0.02450840f, 0.00940954f, 0.01878019f, -0.06088454f, 
    0.01478107f, -0.04361491f, -0.06616671f, -0.03515642f, -0.00530651f, -0.00261589f, 0.01939335f, -0.01383737f, 
    -0.02117584f, 0.00709970f, -0.05444208f, -0.04809314f, -0.00344229f, 0.02849361f, -0.04209011f, -0.05385700f, 
    0.00075139f, 0.00814270f, -0.02108466f, 0.03138801f, 0.03057052f, 0.04507605f, 0.03681031f, 0.01469371f, 
    -0.03293249f, 0.03144852f, 0.03604430f, -0.02251244f, -0.03304376f, -0.05659945f, 0.04767596f, -0.05293843f, 
    -0.03702243f, 0.04588639f, -0.05472625f, -0.02377121f, 0.03292567f, -0.01788108f, -0.05050812f, -0.05426504f, 
    -0.00153413f, 0.01232788f, -0.02254233f, 0.01555029f, 0.05302181f, -0.01517331f, 0.00563266f, -0.00673937f, 
    0.03745518f, 0.01926664f, -0.06409817f, -0.04337590f, 0.04636980f, -0.04511642f, 0.04662586f, 0.00277772f, 
    0.02731668f, 0.01019165f, 0.02365375f, 0.05652669f, 0.01133020f, -0.06405639f, 0.02465297f, 0.02347262f, 
    -0.01945911f, -0.04839275f, -0.01365902f, -0.00488165f, 0.05203865f, 0.01689159f, -0.02448385f, 0.04289604f, 
    0.01981549f, -0.01326007f, -0.02940869f, -0.05982174f, 0.03984419f, 0.03736757f, 0.03730328f, -0.05137192f, 
    -0.01975051f, 0.04931655f, -0.04235951f, -0.01546420f, -0.03028284f, -0.02857944f, -0.01394642f, -0.05066675f, 
    0.00514824f, 0.01882103f, 0.04370523f, 0.01453549f, -0.04494797f, 0.02035132f, 0.00190401f, -0.06350926f, 
    -0.00732591f, -0.03677482f, 0.00936269f, 0.03311628f, -0.03388861f, 0.03940952f, 0.03940500f, -0.00953179f, 
    -0.00316035f, -0.00848020f, -0.04910382f, -0.01557234f, -0.00394497f, 0.04562959f, -0.03034062f, -0.05478413f, 
    0.04999105f, -0.01858871f, -0.03554869f, -0.03141318f, 0.04917904f, -0.01098176f, 0.02191521f, -0.03955815f, 
    0.03532922f, -0.03255825f, -0.03197422f, -0.04746525f, -0.00220534f, -0.02588115f, 0.01122706f, -0.05118012f, 
    -0.00390133f, -0.02147212f, 0.02851054f, 0.03687503f, 0.04518911f, -0.02111522f, -0.05063453f, -0.00811146f, 
    -0.02469047f, -0.02729241f, -0.00872744f, -0.04931505f, 0.00734283f, 0.01330156f, 0.04217229f, 0.04292085f, 
    0.02830442f, 0.02863467f, 0.03897121f, -0.02375977f, -0.05420617f, 0.03746257f, -0.04142632f, -0.03215118f, 
    0.01431715f, -0.05799114f, 0.00809761f, 0.02896798f, -0.00272377f, -0.04224350f, 0.01906228f, 0.01534395f, 
    -0.05712634f, -0.02024197f, -0.06396642f, 0.00148113f, 0.02076552f, 0.02112139f, -0.02332480f, 0.04572322f, 
    -0.00770042f, -0.05451889f, 0.00761738f, 0.04063428f, 0.01899629f, 0.03993195f, -0.05097787f, -0.01079420f, 
    -0.02476056f, 0.04591800f, 0.00513217f, 0.05320334f, 0.00234027f, -0.01809494f, -0.06301975f, -0.00322521f, 
    -0.04377579f, 0.03495937f, 0.05318658f, -0.06170971f, -0.04537959f, 0.03350526f, 0.01106879f, -0.00512895f, 
    0.06794143f, -0.21832623f, -0.00515824f, -0.04446306f, 0.22210522f, 0.02434994f, 0.22109878f, 0.09296150f, 
    0.43724820f, 0.24725360f, -0.04701569f, -0.16535819f, 0.11622310f, 0.16580330f, 0.01057331f, 0.10037946f, 
    -0.16663998f, 0.05344320f, 0.36802593f, -0.16060448f, -0.93625253f, -0.45228755f, -0.10233065f, -0.07446543f, 
    -0.34432614f, 0.17807747f, -0.22974160f, 0.21136582f, -0.13673939f, -0.13721126f, 0.01297500f, 0.13711362f, 
    -0.08947083f, 0.17257214f, 0.35176203f, 0.27459785f, -0.58070350f, 0.09418511f, 0.24064064f, -0.06184254f, 
    0.04369843f, 0.16736630f, -0.13934277f, -0.19592436f, 0.01258228f, -0.00988783f, -0.06169977f, -0.24230781f, 
    -0.04074012f, 0.16150674f, -0.01748257f, 0.13263956f, 0.27001148f, 0.20893660f, -0.14838760f, 0.00721908f, 
    0.13702677f, -0.01027414f, 0.04993966f, 0.16457586f, 0.06636897f, 0.07676430f, 0.17774858f, -0.19489963f, 
    -0.06426485f, -0.12177023f, -0.11801698f, -0.12227325f, -0.14730629f, -0.02504461f, -0.01623940f, 0.08926266f, 
    -0.17024086f, -0.55189353f, -0.33647323f, 0.02468129f, 0.03532270f, 0.05200593f, 0.00219992f, 0.16314198f, 
    0.07613896f, 0.01565927f, 0.10531083f, 0.33982569f, 0.06994884f, 0.17238492f, 0.23657696f, 0.14934567f, 
    0.17880476f, 0.12007523f, -0.18505713f, -0.06158254f, 0.08348653f, 0.27138141f, -0.03642902f, 0.10601456f, 
    0.24285296f, 0.44411114f, 0.15639278f, 0.54107654f, 0.42285135f, -0.01585904f, 0.15683022f, 0.14324915f, 
    0.15902017f, 0.15248013f, 0.11934482f, 0.08423066f, -0.31038910f, -0.14817350f, -0.15453735f, -0.00262527f, 
    0.00722290f, 0.05815220f, 0.38242745f, 0.06850510f, 0.14267854f, 0.00695819f, 0.08623464f, -0.15018642f, 
    -0.30970550f, -0.00837023f, 0.14899828f, 0.45736799f, 0.09839091f, 0.24919675f, 0.14466241f, -0.13797788f, 
    -0.42619660f, -0.22419414f, -0.30559129f, -0.32004288f, 0.08055831f, 0.01126783f, 0.04424912f, -0.04279644f, 
    -0.14206122f, 0.06517243f, 0.05447316f, 0.20999740f, 0.25661129f, 0.18810539f, 0.07379832f, 0.26917630f, 
    -0.30753261f, 0.00113099f, 0.03143832f, 0.05912038f, -0.06462980f, 0.13014002f, 0.03982012f, -0.26931286f, 
    0.05601395f, -0.25685248f, -0.00663536f, -0.03698366f, -0.10286473f, -0.46827686f, -0.10244299f, -0.01405729f, 
    0.06251322f, 0.21951610f, -0.23898284f, -0.26861551f, -0.18911712f, -0.07571405f, -0.33791482f, -0.38913396f, 
    0.19640531f, -0.04451330f, -0.07721740f, -0.13921297f, 0.03446212f, -0.02776829f, 0.10141528f, -0.29021260f, 
    0.07890549f, -0.16942047f, -0.09831083f, 0.11308061f, -0.07013726f, 0.11646996f, 0.07888550f, 0.10287166f, 
    0.14913350f, 0.06156236f, 0.14954783f, 0.16157188f, 0.24167627f, -0.33938774f, -0.27280498f, -0.22669208f, 
    0.10560294f, 0.03381604f, -0.10249501f, -0.08873548f, 0.20241041f, 0.13995932f, 0.13297853f, -0.34722739f, 
    -0.30157518f, 0.10606992f, 0.19012135f, -0.08790070f, 0.28598762f, -0.26909766f, 0.13542941f, -0.17632198f, 
    -0.55088151f, -0.32208177f, -0.06955073f, -0.06146244f, -0.09512403f, 0.00765880f, 0.17534645f, -0.35488233f, 
    0.06748386f, 0.08273891f, -0.00330457f, -0.08993208f, 0.02580316f, -0.15708111f, 0.43046761f, 0.11822566f, 
    -0.09222151f, -0.15538059f, -0.52982283f, -0.04648336f, -0.01866893f, -0.06534968f, -0.04996750f, 0.13076401f, 
    0.15679114f, 0.02456875f, -0.11105194f, -0.28977004f, -0.26632953f, -0.04725140f, -0.08805621f, -0.04359213f, 
    -0.06032939f, 0.00352336f, -0.19408347f, -0.43684572f, -0.34636357f, 0.26456293f, -0.01200797f, -0.10064033f, 
    -0.05880334f, 0.09361217f, 0.25206393f, -0.15953302f, 0.14753352f, 0.02581135f, 0.37372416f, -0.01521994f, 
    -0.04812375f, 0.09872442f, 0.16125196f, -0.05859917f, -0.06320401f, -0.13070720f, -0.09953880f, 0.24100947f, 
    0.06088115f, 0.00186055f, 0.16070613f, 0.15205047f, 0.15553701f, 0.10178200f, -0.00162914f, -0.06614206f, 
    0.08325878f, -0.07179057f, 0.12084040f, 0.00384207f, 0.02636852f, 0.06035101f, 0.09858916f, -0.16362923f, 
    0.00298434f, 0.05534738f, 0.04852317f, 0.00972881f, 0.22526839f, 0.09860834f, 0.14187613f, -0.01318640f, 
    0.19554244f, 0.13462794f, -0.32693934f, 0.15438372f, 0.27688566f, -0.13278353f, 0.18148883f, -0.01032917f, 
    0.16573408f, 0.13022889f, -0.43523279f, -0.13331549f, 0.32483307f, -0.00948219f, -0.12703826f, 0.12365703f, 
    0.07139173f, 0.01475433f, -0.08663183f, -0.48943153f, -0.25365782f, 0.00756995f, -0.22980444f, 0.10805706f, 
    -0.08654628f, 0.03265820f, -0.07817791f, 0.42553356f, -0.21647750f, -0.18537274f, -0.05107286f, 0.28112277f, 
    0.13209426f, 0.30130246f, -0.05298595f, 0.00526865f, -0.24472916f, 0.48286384f, 0.50461727f, -0.09157421f, 
    -0.22091310f, -0.06471102f, 0.16580363f, 0.13816181f, 0.03906793f, 0.35523832f, -0.06963550f, -0.08280201f, 
    0.14341493f, 0.22691673f, 0.03744817f, 0.15568988f, 0.18984942f, -0.15215586f, -0.38446441f, -0.13332589f, 
    -0.01284560f, -0.10991365f, 0.09819008f, 0.00828478f, 0.09409618f, -0.03296475f, 0.10001305f, -0.04380368f, 
    0.10666009f, -0.13492122f, 0.05005934f, -0.38994595f, -0.00462772f, 0.10847478f, 0.15957329f, 0.12515321f, 
    -0.47711071f, -0.86315221f, 0.09900919f, -0.01416653f, 0.01420334f, -0.24384350f, 0.09253153f, 0.03801260f, 
    -0.19358046f, -0.05949335f, 0.39704955f, -0.00756093f, 0.03747369f, -0.00054312f, 0.02257145f, 0.02692399f, 
    0.05054985f, -0.18778755f, 0.15476243f, 0.28191033f, 0.04619469f, 0.11196946f, 0.15716207f, -0.20462245f, 
    0.11304123f, -0.04094868f, -0.01517376f, -0.18795034f, 0.11078060f, 0.31548706f, -0.15225244f, -0.11109471f, 
    0.01067882f, -0.03141285f, 0.04537648f, -0.01838248f, -0.09961814f, -0.17108612f, 0.07138996f, 0.03831733f, 
    0.10249396f, -0.20158926f, -0.08210720f, -0.04535987f, -0.01860960f, 0.08035113f, 0.09245319f, -0.17962736f, 
    0.15864393f, -0.09174208f, -0.20050377f, -0.06383830f, 0.23666817f, -0.02779141f, 0.21939044f, -0.06636284f, 
    0.06141083f, -0.10764388f, -0.10214715f, 0.22392957f, 0.23301333f, 0.05529937f, 0.10934194f, -0.22070915f, 
    -0.20576404f, 0.01593267f, -0.00540909f, 0.19333242f, 0.00348369f, -0.06955060f, 0.03730332f, 0.02421749f, 
    -0.72987032f, 0.09784631f, 0.68229896f, -0.18904693f, 0.14131069f, 0.25323823f, -0.01346142f, 0.06650926f, 
    0.18213588f, 0.11011484f, 0.25816181f, -0.46577618f, -0.31832987f, -0.14835782f, -0.02604712f, 0.17380136f, 
    0.13172977f, -0.07700291f, -0.00954374f, -0.01155838f, -0.23404898f, -0.41709962f, -0.43108106f, -0.09860783f, 
    0.14368124f, 0.04581496f, 0.11268418f, 0.15125827f, 0.61736357f, 0.31006745f, -0.05331239f, -0.03560875f, 
    0.24316053f, 0.20354056f, 0.05231848f, -0.05087302f, 0.17490880f, -0.03529984f, -0.22846627f, -0.25851983f, 
    -0.00554588f, 0.01891343f, 0.24772350f, 0.20887740f, 0.10794445f, -0.28918564f, 0.18950787f, 0.38800955f, 
    -0.04238702f, 0.09684257f, -0.05814855f, 0.08967977f, -0.06880410f, -0.12191115f, 0.06603514f, -0.13194941f, 
    -0.62785614f, 0.24096192f, 0.16297604f, -0.00918460f, -0.23526473f, 0.14073440f, -0.18739702f, -0.37111190f, 
    -0.42086339f, -0.54820967f, -0.17907353f, -0.02522040f, -0.05472718f, -0.03357393f, -0.04826145f, -0.06142434f, 
    0.09860864f, 0.25328943f, -0.05963619f, -0.03516199f, 0.06879460f, 0.20734088f, -0.00866177f, 0.13692217f, 
    -0.11687925f, -0.30982533f, -0.07112427f, -0.62694299f, -0.17270967f, -0.11587162f, 0.01538682f, -0.21448503f, 
    0.06283370f, -0.11196676f, 0.08855947f, 0.18093517f, -1.09987116f, 0.04177229f, 0.12128276f, -0.28873330f, 
    0.07186996f, 0.02112040f, -0.12165808f, -0.13342641f, 0.03185202f, 0.22943065f, 0.23267579f, 0.18982647f, 
    -0.05661207f, 0.18098323f, -0.23375602f, 0.04453146f, -0.05297229f, 0.05188679f, 0.09358672f, -0.04787138f, 
    0.25666708f, 0.26275861f, 0.02536803f, 0.24605414f, 0.31021133f, -0.31286386f, 0.76263851f, 0.33949569f, 
    -0.01842226f, -0.05582214f, -0.13058548f, -0.09697454f, -0.00404190f, -0.03823669f, -0.42377260f, -0.00227546f, 
    0.32575551f, -0.16041110f, -0.01882062f, 0.00554354f, -0.15126094f, -0.02309954f, 0.08855549f, -0.25599080f, 
    0.32164940f, -0.02552741f, -0.00803242f, 0.19229791f, -0.11854907f, 0.01784893f, 0.03311896f, 0.07830935f, 
    0.04943981f, -0.06402533f, -0.00876686f, -0.02626407f, 0.00288822f, 0.02994305f, 0.00711613f, -0.00293850f, 
    -0.02189572f, -0.02054306f, -0.06104804f, 0.05304535f, 0.01179920f, -0.03754394f, -0.02509311f, -0.01014317f, 
    -0.03118313f, -0.04916175f, -0.01433113f, -0.03542949f, -0.00566108f, -0.01362184f, -0.04886881f, 0.02261417f, 
    -0.04359202f, -0.05515525f, 0.03950344f, -0.06599065f, -0.01145993f, -0.03158586f, -0.02757848f, 0.03461250f, 
    -0.00626240f, -0.02865663f, 0.00221337f, 0.02750524f, 0.01771880f, 0.01095480f, 0.03702186f, 0.01972611f, 
    -0.01218179f, -0.03348349f, 0.04351723f, 0.00783161f, -0.05391078f, -0.02542638f, -0.01840897f, 0.01571755f, 
    -0.06208843f, -0.05422318f, 0.02421462f, -0.03799015f, 0.02647120f, 0.00465026f, -0.01489081f, -0.04168764f, 
    0.03646342f, -0.06422637f, 0.02465650f, 0.03636074f, 0.00018772f, -0.04036659f, -0.01586563f, 0.02588539f, 
    0.03271413f, 0.05133070f, -0.04786363f, -0.00143493f, 0.00837551f, 0.04146550f, 0.03146508f, -0.03553290f, 
    0.02350944f, 0.00449583f, -0.00555578f, -0.00976597f, -0.05541178f, -0.02243434f, 0.01126823f, -0.02120776f, 
    -0.00334989f, 0.03289895f, 0.03257994f, 0.04324478f, 0.02272602f, -0.00497245f, -0.01260398f, 0.01258717f, 
    0.02326661f, -0.02185537f, -0.02922108f, -0.00436717f, 0.01184057f, 0.01238266f, 0.00463381f, -0.04799569f, 
    0.04212197f, 0.00576493f, -0.04383842f, 0.04525845f, -0.06368688f, -0.05352695f, -0.01592799f, -0.01928178f, 
    -0.00641273f, 0.02205296f, -0.03925745f, -0.01530659f, -0.05323459f, -0.03707668f, 0.04422392f, -0.02839190f, 
    -0.02030818f, -0.05967606f, 0.01449185f, -0.05068286f, -0.03694094f, -0.01615559f, -0.02386816f, 0.04342532f, 
    -0.00141361f, -0.02962210f, -0.05975630f, -0.00018392f, -0.00915475f, -0.02624975f, -0.01375722f, -0.02723163f, 
    0.04795529f, -0.02428215f, -0.00786983f, -0.02808051f, -0.03355002f, -0.02827269f, -0.01620565f, 0.00672552f, 
    0.02337116f, 0.00951953f, 0.03774798f, -0.00315407f, -0.03200103f, -0.02100985f, 0.02306777f, 0.05072186f, 
    0.03947050f, 0.03174198f, 0.00747641f, -0.05852097f, 0.02044720f, 0.02678238f, 0.00017681f, 0.00318460f, 
    -0.03967986f, -0.00002860f, -0.00840655f, -0.05357666f, 0.05033779f, 0.00872600f, 0.04230651f, -0.01025025f, 
    -0.03243554f, 0.02472949f, -0.00002572f, -0.05225745f, 0.02771435f, -0.03791383f, -0.02957195f, -0.01005611f, 
    -0.06338472f, -0.01115947f, -0.03087770f, 0.02680457f, 0.03818079f, 0.01378644f, -0.01016528f, 0.03056314f, 
    0.03765671f, 0.01881644f, 0.01324804f, -0.03773152f, -0.00825768f, -0.02947170f, -0.03337619f, 0.03187104f, 
    -0.00863740f, 0.00919384f, 0.03476046f, -0.05942911f, -0.00488730f, -0.00988849f, 0.00127182f, 0.00472074f, 
    0.00109296f, -0.02519774f, -0.06632630f, -0.05496830f, -0.03556504f, -0.03473615f, -0.02228446f, -0.03294795f, 
    -0.03504151f, -0.06002381f, -0.03861095f, -0.02303885f, -0.04744924f, -0.03105354f, -0.03602992f, 0.03118044f, 
    0.04819243f, -0.04708078f, -0.01123832f, 0.03234876f, 0.03249545f, -0.00538566f, 0.01620934f, -0.04269176f, 
    0.01699883f, -0.01480205f, 0.03177662f, 0.04761362f, -0.05931914f, 0.02069083f, -0.04310548f, 0.00641232f, 
    0.04001085f, 0.01076205f, -0.04072919f, -0.03068873f, 0.03661760f, -0.01874863f, -0.06580449f, 0.02355478f, 
    0.00782563f, -0.04117491f, -0.00452058f, 0.02681835f, 0.04701016f, -0.05804005f, -0.01813161f, -0.06105123f, 
    -0.00328247f, -0.00746840f, -0.05706642f, -0.00917561f, 0.04183337f, -0.00101985f, -0.06512021f, 0.03459471f, 
    -0.02244297f, -0.00557377f, -0.00759131f, 0.04073005f, 0.03525314f, -0.06631799f, -0.04971521f, 0.03561193f, 
    0.00348905f, -0.04000043f, -0.03644083f, -0.02358768f, -0.05523608f, -0.05212668f, 0.02789739f, 0.04200727f, 
    0.03510204f, 0.00793490f, -0.02816732f, 0.05413524f, -0.02549171f, -0.01053624f, -0.06119784f, -0.00278990f, 
    -0.04061791f, 0.01453693f, -0.00862091f, -0.02665990f, 0.00991770f, 0.03901586f, -0.05126492f, -0.04257729f, 
    0.03336685f, 0.02626340f, -0.03693883f, -0.05537718f, 0.03241096f, 0.04845472f, -0.02371779f, -0.05598373f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.04190669f, 0.01152658f, -0.02381600f, 0.25192469f, 0.00897990f, -0.01490587f, -0.01632423f, 0.13249330f, 
    0.40425533f, -0.00346343f, -0.06840397f, 0.05284556f, -0.00023846f, -0.01152282f, 0.09576914f, -0.02102330f, 
    0.00807522f, -0.00457048f, -0.00974589f, 0.41998661f, 0.03615741f, 0.02215098f, 0.02169383f, -0.03226941f, 
    0.02015052f, -0.05633625f, 0.46924132f, 0.02835781f, -0.07092791f, 0.45295340f, 0.28423467f, -0.03462646f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00273382f, -0.00920224f, 0.46942091f, 0.46506628f, 0.04872954f, -0.03334203f, -0.51271415f, -0.18527105f, 
    -0.22222729f, 0.09579591f, -0.06675760f, -0.22777511f, -0.15340787f, -0.08196966f, -0.13347213f, 0.06244571f, 
    0.11268979f, -0.11044384f, 0.06733429f, -1.17692852f, 0.55484587f, 0.10308496f, -0.04449587f, 0.02409518f, 
    -0.59972787f, 0.30494127f, -0.39201918f, -0.09468410f, 0.09296945f, -0.59230018f, -0.04936271f, -0.15247171f, 
    0.20927469f, -0.83816510f, 0.11905470f, 0.36619213f, -0.15426460f, -0.04711987f, -0.56024814f, -0.23876503f, 
    0.08928200f, -0.03248126f, -0.11615236f, 0.22961077f, -0.10881387f, -0.03839475f, -0.33721203f, -0.10239717f, 
    -0.08168284f, 0.12659049f, 0.06816009f, -0.07889396f, 0.58771205f, 0.03743190f, -0.15950391f, -0.00867604f, 
    0.09244631f, -0.19728121f, 0.70222384f, 0.04013589f, 0.10375369f, -0.01545770f, -0.14992836f, -0.10111796f, 
    -0.24875104f, -0.12831916f, -1.18274796f, 0.24965902f, -0.13006394f, -0.16909832f, -0.16367833f, 0.44464591f, 
    -0.42491311f, -0.14346373f, 0.06580631f, 0.37676510f, -0.04785789f, -0.04795744f, 0.39337975f, -0.17092296f, 
    0.03475907f, -0.05170954f, 0.04978173f, -0.23516566f, 0.28321591f, 0.09725651f, 0.07100462f, 0.03090046f, 
    -0.00558844f, -0.53435451f, -1.06245100f, -0.04666793f, -0.11446772f, 0.38790980f, 0.39768198f, 0.05764613f, 
    -0.54028118f, -0.03517695f, -0.09880680f, -0.67098218f, -0.16833991f, -0.01506573f, 0.02215032f, 0.19047549f, 
    -0.15348144f, 0.15792699f, -0.07010663f, -0.13909425f, -0.08698693f, -0.06840651f, 0.37531555f, 0.26517716f, 
    -0.10490143f, -0.09452139f, -0.09722183f, -1.06583786f, -0.09459557f, 0.01425622f, -0.01187424f, -0.08897176f, 
    0.55510712f, 0.65812963f, -0.99355060f, 0.01730673f, 0.09665083f, 0.22013953f, -0.58714020f, 0.09111977f, 
    0.17545342f, 0.56916434f, 0.26783389f, -0.07723814f, 0.03156941f, 0.13529721f, 0.11161193f, -0.51843381f, 
    -0.08404356f, -0.01160505f, -0.08201949f, -0.58379436f, -0.18493313f, 0.13762504f, -0.13121726f, -0.17275064f, 
    0.10640100f, 0.01399614f, 0.02663685f, 0.28259611f, 0.20735489f, 0.09396745f, 0.14257202f, 0.16965559f, 
    0.45186237f, -0.28891554f, -0.47671056f, 0.15055379f, 0.14552587f, -0.62032562f, 0.04077565f, 0.00645784f, 
    0.03606392f, -0.31764308f, 0.11930384f, -0.09903601f, -0.01700041f, 0.01333007f, -0.11810689f, -0.04080072f, 
    -0.11781082f, -0.07216054f, 0.08546838f, 0.19563378f, 0.06749647f, 0.04290685f, 0.43890718f, 0.33106047f, 
    -0.10459337f, 0.04827151f, 0.04890382f, 1.14639437f, -0.47086889f, 0.00389416f, -0.06713652f, 0.11834236f, 
    -0.15122621f, 0.09459060f, -0.09628080f, 0.04320596f, -0.07636244f, -0.26036352f, 0.01669021f, 0.14994779f, 
    -0.36012375f, -0.13828900f, -0.75924218f, -0.11949014f, -0.04162571f, -0.11723326f, 0.11013404f, 0.66995060f, 
    0.50757527f, -0.17270739f, -0.13477755f, -0.80275822f, -0.16960251f, -0.05120229f, -0.62618172f, -0.61169535f, 
    -0.14568983f, 0.06359083f, -0.00317906f, -0.58164233f, -0.51815605f, 0.05976169f, -0.03871547f, 0.00385264f, 
    -0.79492748f, -0.37602028f, -0.79823190f, 0.05107612f, 0.15887877f, 0.19745924f, 0.55187154f, 0.01448562f, 
    0.19987555f, 0.01010490f, -0.25807199f, -0.20483080f, 0.00170947f, 0.01822857f, 0.54125661f, 0.74072462f, 
    -0.28614751f, -0.13269605f, 0.05575569f, -0.18679161f, -0.16006979f, -0.03091785f, -0.12818694f, -0.18217808f, 
    -0.13004224f, 0.10043823f, -0.15032114f, -0.40680560f, 0.06526878f, 0.01590836f, -0.11022856f, -0.09765261f, 
    0.48513630f, -0.33899683f, 0.18923941f, 0.13328576f, -0.12977250f, -0.74301279f, 0.07833645f, -0.05772120f, 
    -0.20330888f, -0.66688448f, 0.69853234f, -0.39572993f, -0.14714737f, 0.00152549f, -0.19570416f, 0.18130231f, 
    -0.18301412f, -0.05065061f, -0.12272702f, 0.53991234f, -0.14372319f, -0.14955197f, -0.47202432f, 0.40139091f, 
    0.00968907f, 0.11381339f, 0.03415481f, -0.66656601f, -0.71506876f, -0.16106334f, 0.03844927f, 0.10186026f, 
    -0.58364397f, -0.84909320f, 0.38272816f, -0.12464193f, -0.11852197f, 0.37475467f, 0.04812377f, 0.11475535f, 
    -0.52292180f, 0.42804208f, -0.11840151f, 0.13690260f, -0.03984163f, -0.03368736f, 0.18715349f, -1.47937405f, 
    0.45824638f, 0.14705367f, 0.01178817f, -0.82492650f, 0.00025967f, 0.16670063f, 0.21394090f, -0.11025523f, 
    0.16651408f, -0.06792758f, -0.10484678f, 0.31069586f, -0.04749648f, -0.01149754f, -0.11891539f, 0.06373364f, 
    0.09191474f, -1.14826798f, -0.60174382f, -0.12192988f, -0.15692630f, 0.26816595f, 0.21742260f, -0.06732278f, 
    0.48632377f, 0.66043687f, 0.02255607f, 0.08553606f, 0.05707978f, -0.06178382f, -0.57143456f, 0.46403095f, 
    -0.24716364f, -0.14690277f, -0.08223619f, 0.47593340f, 0.12519430f, -0.06013124f, -0.84809029f, 0.08105097f, 
    -0.10102081f, 0.05967620f, 0.01723292f, -0.05427343f, -0.80886149f, -0.15217620f, -0.15362409f, -0.08141281f, 
    -0.14046490f, -0.12365134f, -0.64809960f, 0.00476172f, 0.02443190f, 0.26587039f, -0.40199623f, -0.17778702f, 
    0.15807703f, 0.45973057f, -0.58976460f, -1.11506736f, 0.05236972f, 0.06896550f, 0.38567215f, -0.24129963f, 
    0.53015578f, -0.10671628f, 0.11586691f, 0.06617241f, 0.06459472f, 0.13742082f, -0.58401501f, -0.07859999f, 
    0.16791266f, 0.01107111f, 0.05512802f, 0.74928617f, 0.04914891f, 0.04970037f, 0.14142799f, 0.12226104f, 
    -0.76030618f, 0.01067522f, -0.12286109f, -0.07287680f, -0.01041997f, -0.00010858f, -0.38346103f, 0.10767928f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.27732068f, -0.01919464f, 0.17744470f, 0.07942470f, 0.01933489f, -0.12857859f, 0.07880201f, -0.47047028f, 
    0.07601079f, 0.18149349f, -0.21564172f, 0.22598325f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
