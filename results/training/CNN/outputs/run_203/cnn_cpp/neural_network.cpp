#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.56400692f, 0.50830716f, 0.68460345f, 0.57260561f, -0.15431133f, -0.34609684f, 0.04863512f, -0.33721244f, 
    -0.07847618f, -0.00046448f, 0.10212370f, -0.06233243f, -0.03543562f, 0.53059226f, -0.03699253f, 0.00525270f, 
    -0.16341691f, -0.11815679f, 0.14299028f, -0.13861904f, -0.36257139f, -0.09518389f, 0.29268539f, 0.20625426f, 
    0.15365496f, 0.55385464f, 0.60423136f, -0.10034108f, -0.31386283f, -0.78884780f, -0.01297440f, -0.27401635f, 
    -0.50372052f, -0.50219625f, 0.15479338f, 0.41467014f, 0.55038029f, 0.35225990f, 0.10267018f, -0.03354440f, 
    0.14365661f, -0.28203309f, 0.42259553f, 0.29039630f, 0.17396581f, 0.14027365f, 0.01271626f, 0.03863927f, 
    0.20889056f, -0.08423249f, 0.95992512f, -0.58947486f, 0.27956724f, -0.94221234f, 0.25303832f, 0.44709519f, 
    -0.54362875f, 0.07930465f, 0.16249835f, 0.21635133f, -0.46587601f, 0.12304591f, -0.02993909f, 0.02588921f, 
    0.03124769f, -0.18070124f, 0.10922814f, 0.22397862f, -0.05372570f, 0.42874473f, -0.30329752f, 0.08159526f, 
    -0.14788218f, -0.28889591f, -0.16092961f, 0.89623016f, 0.53653598f, 0.25439772f, 0.55801910f, 0.58522689f, 
    -0.19353426f, 0.29718694f, -0.26801994f, -0.36537680f, -0.11715354f, 0.20599894f, 0.31468442f, -0.13194580f, 
    -0.23491721f, -0.21403462f, -0.09803211f, -0.06891176f, 0.01207301f, -0.02061092f, -0.15930432f, 0.40127167f, 
    0.44225097f, 0.13289726f, 0.10985364f, 0.16186209f, -0.61517984f, 0.09549788f, 0.36248881f, -0.06642708f, 
    0.36307931f, 0.78826493f, -0.46311757f, 0.52518177f, 0.23524149f, -0.44519958f, -0.66983324f, -0.06674407f, 
    -0.12932533f, -0.22396533f, -0.34519133f, 0.14330171f, 0.21138692f, -0.14512621f, 0.05903398f, -0.00005854f, 
    0.01461118f, -0.07165756f, -0.19527501f, -0.04337622f, 0.04113561f, -0.76555079f, 0.13360696f, -0.06669391f, 
    -0.31679246f, -0.19805394f, -0.61579078f, 0.29981282f, -0.07661058f, 0.13414705f, -0.18362495f, -0.34337604f, 
    -0.10282165f, 0.16881758f, -0.58816087f, -0.44724566f, 0.05499262f, 0.55586195f, 0.37655035f, 0.30391899f, 
    -0.46897390f, 0.09661409f, -0.28486064f, 0.01312828f, -0.08969867f, 0.26139966f, 0.54959172f, -1.00346720f, 
    0.52457666f, 0.81546909f, 0.56402773f, -0.84160441f, 0.38807204f, -0.04540389f, -0.46465963f, 0.30769062f, 
    0.44718045f, 0.40494141f, -0.00061538f, 0.05342039f, 0.26853544f, -0.55607170f, -0.02181870f, -0.10431893f, 
    0.13845702f, 0.02068958f, -0.14315075f, -0.01701930f, 0.22885199f, 0.00730237f, 0.12857077f, 0.94273007f, 
    -0.32399884f, -0.73502082f, 0.39087817f, 0.15810840f, -0.23013800f, 0.53920466f, -0.13787369f, -0.25216708f, 
    0.12085959f, -0.27398109f, 0.43527398f, 0.11548308f, 0.23157544f, -0.04569192f, -0.39337015f, -0.01810699f, 
    0.12267121f, -0.22917233f, -0.36062598f, 0.06711153f, -0.30450729f, 0.25882992f, 0.22785558f, -0.08545803f, 
    0.47576618f, -0.60269248f, -0.57379633f, 0.04931549f, 0.68785912f, 0.81101251f, -0.20262861f, -0.55781394f, 
    -0.19651808f, -0.21962026f, -0.18898143f, 0.59862316f, -0.03639831f, 0.53204435f, 0.23495436f, 0.15051222f, 
    0.03616154f, -0.05245434f, 0.17219689f, -0.21203345f, 0.02905482f, -0.13953744f, -0.10326955f, -0.15703724f, 
    0.11467950f, 0.62074286f, 0.62380499f, 0.71479094f, 0.23634970f, 0.49221179f, -0.42478570f, -0.49554199f, 
    -0.38651356f, 0.16617805f, -0.09996002f, 0.18104859f, 0.40231219f, -0.25084683f, 0.22767149f, -0.18577257f, 
    0.33967707f, -0.11010845f, -0.15076190f, -0.14300923f, -0.24886036f, 0.17335084f, 0.04014035f, 0.04593495f, 
    0.10875773f, 0.08153577f, 0.00481338f, 0.21331504f, -0.05783633f, 0.69725913f, 0.34577659f, 0.72674370f, 
    -0.45606098f, -0.65482301f, 0.38127226f, -0.27847046f, 0.41988200f, -0.44512892f, -0.02068531f, 0.30094004f, 
    -0.10349102f, -0.52441132f, -0.12537770f, -0.12868051f, -0.19217201f, 0.07221501f, 0.06270342f, -0.28456548f, 
    -0.04531542f, -0.13350908f, 0.38580787f, 0.85523975f, 0.61989516f, 0.39415407f, -0.67767668f, -0.76670957f, 
    -0.39999700f, -0.14627908f, 0.17743358f, -0.00424915f, 0.54985875f, 0.35258520f, 0.05935921f, -0.12709987f, 
    -0.03974492f, 0.10299613f, 0.09260896f, 0.14106482f, -0.09747064f, -0.03965842f, 0.14398818f, 0.30646229f, 
    0.28490224f, -0.04193590f, 0.20206665f, 0.27744815f, 0.96464598f, -0.35513940f, 0.02656640f, 0.70784080f, 
    -0.04535706f, 0.00747115f, -0.22216074f, -0.43841028f, 0.47375557f, -0.41256952f, -0.51378626f, -0.35443911f, 
    -0.24892350f, 0.07224844f, -0.46179593f, 0.14024407f, -0.06563386f, -0.14986593f, -0.04856712f, 0.13243784f, 
    -0.23078603f, -0.01292121f, -0.21305652f, 0.07316869f, 0.04209070f, 0.61521840f, 0.48898411f, 0.70504808f, 
    -0.08701817f, -0.09101221f, 0.34218428f, -0.32875824f, -0.09106449f, 0.31113583f, 0.29902220f, 0.16059315f, 
    -0.06405781f, 0.07294261f, 0.00917692f, 0.38239387f, 0.30644929f, 0.07940206f, 0.35744864f, -0.12420791f, 
    -0.40393737f, 0.16423658f, 0.42719609f, 0.10787467f, -0.00862297f, 0.36946651f, -0.89749533f, 0.86302590f, 
    0.90444744f, -0.55104440f, 0.70565969f, 0.08004522f, 0.77841341f, 0.52967691f, -0.45621935f, -0.03607260f, 
    -0.10232732f, 0.17152038f, 0.12534493f, -0.29845235f, -0.18253298f, -0.16964835f, -0.19566323f, -0.16302429f, 
    -0.04694606f, 0.10885384f, 0.07482444f, 0.05016998f, 0.04038693f, -0.04716536f, 0.06628852f, 0.73845530f, 
    0.21658599f, 0.38505375f, 0.15264386f, -0.23696706f, 0.11600070f, 0.30550626f, 0.57041991f, 0.62909681f, 
    0.33004752f, -0.00295887f, 0.06092808f, -0.09931044f, -0.04862124f, -0.07453786f, 0.38238639f, -0.29790288f, 
    0.11438932f, -0.38502327f, 0.12312844f, -0.20892701f, -0.49648732f, 0.47592616f, -0.08149657f, -0.05036118f, 
    -0.65308344f, 0.43450698f, -0.80419511f, -0.50527036f, 0.18396586f, -0.53315246f, 0.19743228f, 0.28377607f, 
    -0.13230188f, -0.35597479f, 0.56095296f, -0.17386790f, -0.11616636f, -0.25044984f, 0.27444500f, -0.15778071f, 
    0.10380549f, -0.00060392f, -0.22588786f, 0.07065973f, 0.31700000f, 0.51229358f, -0.03427220f, 0.20990647f, 
    -0.00046678f, -0.51190650f, -0.39727274f, -0.36506078f, -0.25139269f, -0.15052924f, -0.54000264f, 0.02985370f, 
    -0.60779381f, -0.40686131f, 0.51381773f, 0.30556783f, 0.44716871f, -0.28198200f, 0.09299193f, 0.25165358f, 
    -0.07923975f, 0.00006085f, 0.58142465f, -0.09586452f, -0.51072121f, 0.01044646f, 0.08963411f, -0.22624625f, 
    -0.06207702f, 0.23517579f, -0.30647969f, 0.61964315f, -0.31337085f, -0.71227574f, -0.56503373f, 0.60868394f, 
    -0.60325241f, -0.56077510f, 0.19052680f, 0.28779528f, 0.04940129f, -0.11902197f, 0.55235624f, 0.57928199f, 
    0.07000805f, -0.10818044f, 0.17243272f, -0.23683648f, 0.14480889f, 0.00499428f, 0.04781416f, 0.28603736f, 
    0.11042639f, 0.00832309f, 0.45645443f, 0.24001329f, -0.86469442f, -0.33227503f, -0.40625122f, 0.39092052f, 
    -0.54304707f, 0.32977220f, 0.01880577f, -0.04636362f, -0.38171458f, 0.10443315f, -0.30139464f, 0.15097691f, 
    0.06130113f, 0.13085626f, -0.17940611f, 0.20813292f, -0.49391881f, -0.17636587f, -0.18067423f, -0.01055442f, 
    -0.30216080f, -0.07748017f, 0.44669592f, 0.26748446f, -0.81185156f, 0.28643459f, -0.52458984f, -0.73533183f, 
    -0.44803402f, 0.58080441f, 0.01370339f, -0.32235661f, 0.37916118f, 0.45266154f, -0.27079901f, -0.31340003f, 
    0.23937806f, -0.23295712f, -0.22981280f, 0.00712340f, 0.14661539f, 0.35759890f, 0.03881327f, 0.06106340f, 
    -0.28888637f, -0.46773106f, -0.32266417f, -0.33919930f, -0.06700054f, 0.34040344f, 0.43856415f, 0.39876822f, 
    0.61409909f, 0.46269920f, -0.40646023f, 0.49443272f, 0.33964068f, -0.53485137f, -0.47417465f, 0.28974453f, 
    -0.35465923f, -0.41618559f, 0.15014346f, 0.11510050f, -0.39832044f, 0.25686041f, 0.11764311f, 0.19795090f, 
    0.05527069f, -0.04225018f, 0.13328218f, 0.21828580f, 0.19853354f, 0.11415670f, 0.09016538f, -0.00543633f, 
    0.27063006f, 0.82091010f, 0.13173892f, -0.45377487f, 0.11383665f, 0.48552373f, 0.40182862f, 0.43182105f, 
    -0.14180343f, -0.03531294f, -0.17433567f, -0.10559539f, 0.11636159f, 0.39767501f, -0.29831949f, -0.38757199f, 
    -0.24404576f, 0.08652119f, -0.04645060f, -0.21206266f, 0.29171789f, -0.15658492f, -0.43317196f, 0.03947625f, 
    0.94430941f, 0.04287747f, -0.67697424f, 0.35543692f, -0.00422207f, -0.52141136f, -0.10095628f, 0.37609714f, 
    0.50128007f, 0.02723807f, -0.19765069f, -0.29229447f, 0.42052543f, -0.30963355f, -0.33981207f, 0.14196435f, 
    -0.34959701f, -0.18594246f, -0.40661240f, -0.38961262f, 0.13758764f, -0.20455936f, 0.01668685f, -0.03485782f, 
    0.72410673f, -0.57420355f, 0.46551454f, 0.90122962f, 0.91248971f, 0.58202380f, 0.60045606f, 0.35744640f, 
    -0.00103889f, 0.10677883f, -0.34142023f, -0.17370577f, -0.24979590f, 0.36890721f, -0.07704652f, 0.07484727f, 
    0.17561090f, 0.15317766f, 0.32894188f, 0.17728370f, -0.01387376f, 0.09154341f, -0.04691482f, -0.11134895f, 
    -0.00338244f, 0.84297812f, 0.61741817f, 0.45274568f, 0.70158851f, 0.53677773f, -0.56396967f, 0.47734407f, 
    -0.23417373f, 0.30268145f, 0.13825053f, -0.19207489f, -0.05814122f, -0.05891077f, -0.19159532f, 0.04856978f, 
    -0.18786663f, 0.04560774f, -0.10961626f, 0.13209541f, 0.25453937f, 0.31094497f, 0.00559538f, 0.12772106f, 
    0.24825597f, -0.14402258f, -0.19331360f, -0.16263500f, 0.33907118f, -0.56808096f, -0.77947074f, 0.11845393f, 
    -0.44564024f, -0.50165212f, 0.04839225f, 0.35728985f, -0.07722845f, -0.04273723f, -0.27008697f, 0.06002286f, 
    -0.38735831f, 0.13103750f, 0.09422084f, 0.21685193f, 0.24604453f, 0.15689929f, 0.42129645f, 0.30789715f, 
    0.29893276f, -0.09804230f, -0.14318289f, 0.96080852f, 0.29938579f, -0.00829244f, -0.23020399f, -0.35619193f, 
    0.00747790f, -0.59996706f, 0.22105238f, -0.32639945f, 0.30005878f, -0.00417075f, 0.27998966f, 0.10863674f, 
    -0.30066514f, -0.09614929f, -0.34882000f, -0.23984323f, -0.16106687f, 0.16375768f, 0.22692914f, 0.11823758f, 
    0.11791879f, -0.40216404f, -0.02781895f, -0.27879250f, -0.46258193f, 0.43888015f, 0.11085708f, 0.17079559f, 
    0.43529043f, -0.80604887f, -0.49931630f, -0.29964361f, -0.32940793f, -0.20813937f, 0.38260603f, 0.27520105f, 
    0.10540333f, -0.24727634f, 0.47939029f, 0.23028639f, 0.09426400f, -0.28719375f, 0.35504311f, 0.39536569f, 
    0.22302206f, -0.12747283f, -0.18141362f, -0.21534547f, 0.25246748f, 0.37608963f, 0.93978423f, 0.75128245f, 
    -0.45866835f, -0.65741527f, -0.71749550f, 0.68459707f, -0.23031926f, -0.37488118f, -0.29739732f, 0.16001847f, 
    0.27795246f, -0.35252473f, -0.07183959f, 0.26002905f, 0.14141883f, -0.35290304f, -0.06379777f, 0.13495024f, 
    -0.16257851f, 0.08373973f, 0.22859003f, 0.01725081f, -0.03094465f, -0.03690193f, -0.15168963f, 0.20089155f, 
    0.41838554f, 0.87537163f, 0.27274096f, -0.01747124f, 0.12162860f, 0.03842814f, 0.29059130f, -0.11624204f, 
    -0.17691308f, -0.19389601f, -0.02069479f, -0.00722128f, 0.23000839f, 0.12580369f, 0.03105703f, 0.12954007f, 
    0.03406139f, -0.12779388f, 0.02672369f, -0.26248339f, -0.33144557f, -0.03504714f, -0.57916719f, -0.61980689f, 
    -0.67358065f, 0.22359657f, 0.55901021f, 0.26286733f, -0.27144361f, -0.05544010f, 0.04071180f, 0.33432195f, 
    -0.65277147f, 0.30207738f, -0.17269063f, -0.31785357f, 0.18640368f, 0.07011476f, 0.28457925f, 0.14809614f, 
    0.30732545f, 0.13068889f, 0.26140058f, 0.18494500f, 0.29301855f, -0.10877271f, 0.03996156f, -0.35082072f, 
    -0.31171331f, -0.81610858f, -0.50638223f, -0.74812675f, -0.20250702f, -0.08667407f, 0.07606562f, -0.53613085f, 
    -0.46055591f, 0.09013970f, 0.19297144f, 0.48272550f, 0.07792518f, 0.00715327f, -0.03037933f, -0.01168446f, 
    0.20743638f, 0.48999986f, 0.31204525f, 0.07674885f, 0.09718503f, 0.09472895f, -0.28175458f, 0.25532284f, 
    -0.03741133f, -0.29107100f, -1.06790781f, -0.55304855f, 0.02392884f, -0.30166137f, -0.35778481f, 0.94970596f, 
    0.92249084f, -0.82471693f, 0.14987445f, 0.18125919f, -0.24338272f, -0.14010541f, -0.47903582f, -0.19587287f, 
    -0.39071152f, -0.00577153f, -0.04441696f, -0.09919216f, -0.02878034f, -0.16995679f, -0.01852938f, 0.03943813f, 
    -0.12113412f, -0.04287348f, -0.01177107f, 0.87527335f, 0.37885895f, 0.04825466f, 0.65760458f, 0.57259667f, 
    -0.18965837f, -0.82631958f, -0.60383993f, -0.25264350f, -0.04834897f, 0.07010999f, -0.01520716f, 0.00589901f, 
    0.04593118f, 0.02506011f, -0.30345905f, -0.14494194f, -0.44327787f, -0.19260694f, -0.16386671f, 0.38421407f, 
    0.26828292f, 0.05599375f, -0.04559242f, -0.25038099f, -0.18867107f, -0.34556511f, -0.62113762f, -0.39522070f, 
    0.42083567f, -0.15979405f, 0.34555203f, 0.17014152f, -0.19495320f, -0.07619092f, 0.01402424f, 0.08484961f, 
    0.00624183f, 0.34724885f, 0.34459096f, -0.08314415f, -0.44003406f, 0.06653872f, 0.26759028f, -0.44210592f, 
    -0.43334687f, -0.22833396f, -0.53248060f, 0.28516242f, 0.04218698f, -0.34872714f, -0.67917705f, -0.12443836f, 
    -0.35793814f, -0.12084665f, 0.39906818f, -0.27847162f, 0.04321875f, -0.27599335f, -0.09488440f, -0.08697327f, 
    -0.40973243f, 0.20337279f, 0.29993683f, -0.09223758f, 0.13483860f, -0.54289645f, -0.51314849f, -0.11716992f, 
    0.08033828f, -0.00225206f, 0.39592919f, 0.04224832f, -0.30924594f, 0.07489500f, -0.72822982f, -0.84026653f, 
    -0.62121344f, -0.01286720f, 0.38964769f, 0.18331540f, 0.10248004f, 0.66520280f, 0.55334783f, -0.22105360f, 
    -0.17075601f, -0.18317994f, -0.09892824f, -0.19062373f, -0.28298303f, -0.01345402f, 0.14138229f, 0.20354337f, 
    -0.26997477f, -0.16358000f, 0.03118724f, -0.20552519f, 0.01476947f, 0.17058444f, -0.74884295f, -0.61737263f, 
    -0.65578443f, -0.22685580f, -0.62060612f, 0.56551224f, 0.75132453f, 0.11422363f, 0.37745410f, 0.41431627f, 
    -0.13628943f, -0.12594807f, 0.20126198f, 0.05631262f, 0.24600631f, -0.22048050f, -0.13814765f, 0.08872218f, 
    -0.09670937f, -0.11820121f, -0.02279534f, -0.10947269f, 0.10030845f, 0.25575089f, 0.22417445f, 0.59464973f, 
    0.06930580f, -0.45765555f, -0.72677535f, -0.31887993f, 0.24489512f, -0.35900602f, -0.18342899f, -0.69307566f, 
    -0.20676365f, 0.25853103f, -0.19970694f, 0.01122931f, 0.17551543f, -0.21218392f, 0.24782161f, 0.40390173f, 
    -0.61242759f, 0.10246148f, -0.00663223f, -0.10535771f, 0.17847267f, 0.31341857f, 0.42270291f, -0.16998599f, 
    -0.53742766f, -0.57057446f, 0.59828621f, 0.66700888f, -0.38844258f, -0.03444286f, 0.27111948f, 0.48955345f, 
    -0.04717236f, 0.03512757f, 0.29964450f, 0.04786522f, 0.23566484f, 0.29655501f, 0.17482607f, 0.03642464f, 
    0.13133915f, -0.15552223f, -0.37119251f, 0.06007460f, -0.23224574f, 0.15551306f, -0.04867868f, -0.05729359f, 
    0.15169826f, 0.59839362f, 0.55533916f, 0.58703983f, 0.41596124f, -0.66572201f, -0.00623530f, 0.01394999f, 
    -0.11364369f, -0.14070241f, 0.66278255f, 0.23651432f, 0.19504356f, -0.13159107f, -0.08086985f, -0.38826501f, 
    -0.29946700f, -0.12243155f, 0.19446062f, -0.25035462f, -0.44715330f, -0.13239333f, 0.01021037f, -0.28765109f, 
    0.13575470f, -0.29434749f, 0.23889686f, 0.34961459f, 0.13685888f, -0.33248484f, 0.59918123f, -0.56255376f, 
    -0.87329036f, -0.27519023f, -0.33314282f, -0.66264850f, 0.26501694f, -0.16010173f, 0.19655968f, -0.04651253f, 
    -0.21075961f, 0.11203180f, -0.14274216f, -0.35817325f, 0.14777137f, -0.05423376f, -0.36734039f, -0.10395354f, 
    -0.11277386f, 0.34137446f, 0.28377464f, -0.38408190f, -0.54098421f, 0.61414129f, -0.03322024f, -0.62939632f, 
    0.51206523f, -0.84116381f, 0.47133678f, -0.11681492f, -0.31972519f, 0.06187432f, -0.32424951f, -0.16702117f, 
    0.34342533f, 0.24513519f, -0.25984204f, 0.35949776f, -0.02770100f, -0.42719141f, 0.23636995f, 0.21055678f, 
    0.42628011f, 0.42097422f, 0.37812710f, 0.07134866f, -0.52151757f, -0.04763394f, 0.52979106f, 0.26594186f, 
    -0.06028603f, -0.90961289f, -0.33007225f, -0.58464360f, -0.59974509f, -0.24305257f, 0.30532202f, 0.29531580f, 
    0.12211809f, 0.01429371f, -0.38617831f, -0.36352521f, -0.13897721f, 0.07156008f, -0.25475222f, 0.30018649f, 
    0.40823483f, -0.05461458f, -0.14030175f, 0.20420927f, 0.12732922f, 0.71269584f, -0.09267902f, -0.70370448f, 
    -0.28398898f, -0.28152367f, 0.35146287f, 0.08980824f, -0.33462018f, -0.36025134f, -0.43085212f, -0.17294382f, 
    -0.04711283f, 0.50410849f, -0.11684503f, 0.12659679f, -0.34344950f, 0.09411170f, -0.10925481f, 0.28978390f, 
    0.05726952f, 0.09293748f, 0.20654999f, -0.32557195f, -0.04501664f, 0.18586697f, 0.92914182f, 0.59524739f, 
    -0.48086125f, -0.21184656f, 0.28180495f, 0.10834790f, 0.49743992f, -0.07448939f, 0.34414726f, 0.20226046f, 
    0.09537492f, -0.11084242f, -0.07371195f, -0.14772949f, 0.26523107f, -0.09889853f, -0.29933193f, -0.03675345f, 
    -0.34721920f, -0.02054728f, 0.03445458f, 0.13668433f, 0.13021758f, 0.09071081f, -0.26581678f, 0.97244263f, 
    0.25165254f, -0.51483208f, -0.67719239f, -0.39131892f, 0.07310138f, -0.20130855f, 0.32848328f, 0.07191317f, 
    0.34058544f, -0.27554700f, 0.28721607f, -0.01149910f, -0.06539472f, -0.21940674f, 0.31447458f, -0.11577346f, 
    -0.17756502f, -0.11078639f, 0.43630630f, 0.27859738f, -0.37435120f, 0.47055534f, -0.44676560f, 0.20188367f, 
    0.10536075f, -0.03979148f, -0.21593741f, -0.83152014f, -0.54094529f, 0.13906294f, -0.51339400f, 0.26065335f, 
    0.79814696f, -0.35856059f, -0.04596878f, 0.41132823f, -0.31529471f, -0.15856409f, 0.25898546f, 0.13068716f, 
    0.24648705f, 0.06973800f, 0.06780995f, -0.32368037f, -0.02580827f, -0.00978665f, 0.06932753f, 0.09248690f, 
    -0.20068921f, 1.05250907f, 0.01352006f, -0.60895270f, 0.97299767f, 0.54677057f, -0.27053890f, -0.36779940f, 
    0.32789242f, 0.32310432f, 0.19095017f, -0.32402670f, -0.23460332f, 0.10945207f, -0.47651279f, -0.01979936f, 
    0.06441013f, -0.05808963f, 0.25594527f, 0.24044102f, 0.06459322f, 0.43108943f, 0.19337748f, 0.00063430f, 
    -0.23579368f, 0.17946832f, 0.06496347f, 0.28401431f, 0.41015875f, 0.30239776f, 0.39338899f, -0.63180459f, 
    0.23264505f, -0.46803564f, -0.15650260f, -0.11950365f, -0.33378023f, -0.29064667f, 0.33372238f, 0.37929156f, 
    0.03540399f, 0.04256890f, 0.34479165f, 0.42055628f, -0.08866618f, 0.24330620f, -0.41511157f, -0.21270983f, 
    -0.42970884f, 0.01775373f, 0.17623998f, -0.24462545f, -0.56432390f, -0.43051186f, -0.23653086f, -0.25979906f, 
    0.15773270f, 0.51644629f, -0.01550926f, -0.12727536f, -0.23694734f, -0.51897228f, 0.11057585f, -0.36478719f, 
    -0.17762056f, 0.07668149f, 0.25867650f, 0.08336801f, 0.08547510f, 0.35322076f, 0.23996054f, -0.28172141f, 
    -0.26941013f, -0.28290176f, 0.31336775f, -0.03056557f, -1.16958678f, 0.62006396f, 0.94257390f, -0.73610699f, 
    0.41670913f, 0.60516948f, 0.24087410f, -0.24600005f, 0.71640736f, -0.50241703f, 0.21068287f, -0.19196644f, 
    -0.32661763f, 0.06933854f, -0.45136544f, -0.18686086f, -0.24629270f, -0.02148652f, -0.30931950f, -0.21936382f, 
    0.17801462f, 0.20236745f, -0.00943587f, 0.18277609f, -0.18402006f, -1.14586389f, 0.72218239f, -0.46578190f, 
    0.13482001f, -0.17553076f, -0.16093434f, 1.17345691f, 0.19049534f, -0.14515182f, 0.34572271f, -0.18377942f, 
    -0.14290227f, 0.15914203f, -0.44293141f, 0.09817800f, 0.15599076f, 0.03055345f, -0.12221673f, 0.17625856f, 
    -0.19480383f, 0.05343580f, -0.09804334f, -0.06946954f, 0.00097310f, 0.18077853f, 0.53358650f, -0.09509129f, 
    0.10254045f, -0.11027396f, 0.03444871f, 0.34367537f, -0.47100276f, 0.19101645f, -0.31352931f, 0.01163150f, 
    0.19979508f, -0.29859927f, 0.25086874f, 0.25807375f, -0.49466860f, 0.22505057f, 0.27827939f, 0.35893336f, 
    0.46480843f, -0.27432415f, -0.02954073f, 0.17926282f, 0.22487327f, -0.07090389f, 0.26621100f, -1.18012559f, 
    -0.37872437f, 0.03062633f, 0.62887120f, 0.24811204f, 0.79199892f, 0.35618195f, 0.19864033f, 0.09886126f, 
    -0.83764023f, -0.11162034f, -0.07663147f, 0.01310294f, 0.35585093f, 0.28259602f, -0.08748186f, 0.39549187f, 
    -0.12781550f, -0.24866618f, -0.00696716f, -0.07019155f, -0.16397309f, -0.04132942f, -0.30317956f, -0.12785810f, 
    0.65384471f, -0.17312679f, -0.43791711f, -0.14405075f, 0.20553109f, 0.57915562f, 0.62851703f, -0.56843174f, 
    0.32807803f, 0.34602889f, -0.27756861f, -0.08192430f, -0.13325514f, 0.34688681f, -0.17488320f, 0.04284668f, 
    0.26973718f, -0.12116779f, -0.43065569f, 0.08707679f, -0.00268257f, -0.07599389f, -0.20385215f, -0.11657818f, 
    0.09741045f, -0.59324735f, 0.21091531f, -0.49654686f, -0.18049178f, 0.02561375f, -0.69792521f, -0.57082087f, 
    0.00491870f, -0.06219839f, 0.05113839f, -0.41877675f, -0.01701450f, -0.33345854f, 0.14796379f, -0.58262783f, 
    -0.16512065f, -0.09011979f, 0.14706403f, -0.09200664f, -0.30332050f, 0.30713329f, -0.25159103f, 0.37181267f, 
    0.35904992f, 0.28649908f, -1.13511515f, -0.26624498f, -0.25345388f, 0.22728622f, -0.80310887f, 0.50899708f, 
    0.10927666f, -0.47793579f, -0.02533073f, -0.04716523f, 0.20994812f, -0.01691384f, -0.11536393f, 0.10911884f, 
    0.41989341f, -0.26239482f, -0.37649459f, -0.13900767f, -0.26415116f, -0.33973190f, 0.11168083f, 0.19412096f, 
    0.31242785f, 0.03231377f, -0.20416912f, -0.87773520f, -0.73686230f, 0.67814928f, 0.64545137f, 0.00067269f, 
    0.52327591f, 0.61239260f, 0.20070340f, 0.48450610f, 0.00934399f, -0.34749135f, 0.19895279f, -0.09152595f, 
    0.34640619f, -0.03802974f, 0.05374833f, -0.06276277f, 0.00791647f, -0.32279104f, -0.22907808f, 0.01311369f, 
    -0.01368328f, -0.09201051f, 0.10292244f, -0.34364560f, 0.86434871f, 0.65145969f, 0.19488718f, 0.85616356f, 
    0.56008416f, 0.15610223f, 0.18233532f, 0.59307677f, -0.38263825f, 0.19696222f, -0.47343037f, -0.17154871f, 
    0.39574766f, 0.16622400f, 0.23459120f, 0.10091259f, -0.10448781f, 0.40907764f, 0.22358832f, 0.21142755f, 
    0.28286254f, -0.24816194f, -0.21761192f, 0.19023581f, 0.10750727f, -0.72210264f, -0.82715315f, -0.44604427f, 
    -0.23829831f, 0.35923609f, 0.18215366f, 0.49613968f, 0.52081698f, 0.33551446f, 0.50782239f, -0.21707036f, 
    -0.02739093f, 0.36672965f, -0.07012168f, 0.00058717f, -0.27503255f, -0.19742493f, 0.23887965f, 0.18269336f, 
    -0.02687687f, 0.10370526f, -0.14492095f, -0.35497814f, -0.16782524f, -0.18762076f, 0.69863260f, 0.73762250f, 
    0.44200981f, 0.60244691f, 0.48867881f, 0.22661650f, -0.64950383f, -0.23451976f, -0.23815519f, 0.23687574f, 
    0.31946859f, 0.02571120f, -0.26278555f, 0.31678659f, -0.06966960f, 0.20431407f, 0.13379532f, 0.54727584f, 
    -0.10592936f, 0.12481549f, 0.06081514f, -0.13954732f, 0.19436046f, -0.00462565f, 0.04008830f, 0.95268881f, 
    0.57885993f, 0.23920323f, 0.26969659f, 0.03617633f, 0.15460925f, 0.13354620f, -0.31024101f, 0.55314034f, 
    0.50820822f, -0.28165925f, 0.24584283f, 0.13087344f, -0.35733941f, 0.02618479f, -0.10056493f, -0.10285866f, 
    -0.36425585f, 0.02541408f, -0.21028660f, -0.38874325f, -0.07391867f, 0.02033614f, -0.29942924f, 0.05071018f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.21037750f, 0.19954357f, 0.05129381f, 0.21722184f, -0.16142376f, 0.23447233f, 0.05859149f, 0.20629618f, 
    0.11463369f, 0.26030156f, 0.23425312f, 0.22720611f, 0.20280783f, 0.06139947f, 0.14822091f, 0.18807271f, 
    0.25169253f, 0.25926509f, 0.18964222f, 0.08146340f, 0.10665900f, -0.01547929f, 0.04218176f, 0.14184278f, 
    0.15274842f, 0.15598507f, 0.18665507f, 0.12103654f, 0.05106758f, -0.01683213f, 0.13362201f, 0.23512217f, 
    0.13340151f, 0.17306031f, 0.16673872f, -0.05767517f, 0.28491664f, 0.00720001f, 0.09245588f, 0.23778293f, 
    0.28127077f, 0.20687732f, 0.27358910f, 0.08828500f, 0.09809669f, 0.23353833f, 0.24298894f, -0.00085841f, 
    0.23805116f, 0.11432976f, 0.14264585f, 0.06953731f, 0.19080715f, 0.09732365f, 0.20498057f, 0.06234484f, 
    0.20428403f, 0.01810538f, 0.10528023f, 0.14845899f, 0.13641860f, 0.10997146f, 0.00353767f, 0.15481324f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.11341153f, 0.02899060f, -0.20720351f, 0.08480134f, -0.06540630f, -0.12463696f, -0.02822269f, 0.07299425f, 
    -0.05938862f, -0.02470746f, -0.01160326f, -0.06638171f, -0.22756121f, 0.09467767f, 0.12603775f, -0.12322392f, 
    -0.01328703f, 0.06067269f, 0.00446645f, 0.03884055f, 0.03203331f, -0.01901676f, -0.06408115f, -0.00531473f, 
    0.30875185f, -0.11055491f, 0.22573963f, -0.47431314f, 0.04591686f, 0.03096933f, 0.02038299f, -0.00740248f, 
    -0.14751284f, -0.07513320f, -0.01793366f, 0.18143763f, 0.16612528f, 0.04392227f, 0.09347468f, 0.01534697f, 
    -0.09241004f, -0.13149199f, 0.00143315f, 0.03115410f, -0.06515790f, -0.01907892f, -0.08658856f, -0.06617191f, 
    -0.13094148f, -0.02376487f, 0.22883417f, 0.08899263f, 0.02751741f, 0.00381120f, 0.04541680f, -0.00488112f, 
    -0.00132134f, 0.02218052f, 0.02443687f, 0.04312767f, 0.07633927f, 0.13154735f, -0.11019558f, 0.13472982f, 
    0.00800976f, -0.06481659f, -0.00657380f, 0.02081837f, 0.05322798f, -0.01617688f, -0.03177594f, 0.07173877f, 
    0.30012619f, -0.09569014f, -0.14139980f, 0.19738331f, -0.23501824f, -0.11492620f, 0.01953128f, 0.02328512f, 
    0.00345484f, 0.06108182f, -0.09391014f, 0.01577886f, 0.03186626f, -0.02634273f, 0.04980552f, 0.09252835f, 
    -0.15472755f, -0.08014578f, -0.06182480f, -0.00503064f, -0.11916302f, 0.12834911f, 0.04281153f, -0.04885382f, 
    -0.01323727f, -0.15712178f, 0.19311082f, -0.01276422f, 0.04009543f, 0.01811236f, 0.04837818f, -0.23101078f, 
    -0.00991452f, 0.13394266f, 0.16112047f, -0.03114080f, 0.10912217f, -0.00526704f, 0.00398996f, -0.07568838f, 
    -0.21256225f, -0.08246905f, -0.06085234f, 0.00158418f, 0.08582094f, 0.03199583f, 0.09474499f, -0.13938248f, 
    0.01807863f, -0.10517275f, -0.04740397f, 0.17360109f, -0.02471257f, -0.03454411f, -0.09194461f, -0.02335883f, 
    -0.04490647f, 0.02766323f, 0.02987279f, 0.05186798f, -0.28843150f, 0.05575351f, -0.08015864f, -0.19352961f, 
    -0.01483962f, -0.01009614f, 0.01273958f, 0.01378298f, -0.03162805f, 0.04054120f, -0.01212143f, 0.06289182f, 
    0.14248879f, -0.19024386f, -0.07111934f, 0.30203006f, 0.07815488f, -0.07901149f, -0.09585595f, 0.01267400f, 
    -0.00939083f, -0.09442275f, 0.00713031f, 0.03670139f, 0.09597913f, 0.03470274f, -0.08158005f, -0.10264300f, 
    -0.13850702f, 0.04251924f, 0.02038835f, -0.03175259f, 0.05139639f, 0.06370410f, -0.13144726f, 0.00539490f, 
    -0.39135355f, -0.07183587f, 0.31614044f, -0.06054607f, 0.00394173f, 0.00429116f, 0.06381609f, -0.13837221f, 
    0.02585284f, -0.10070065f, -0.05391140f, 0.04433222f, 0.07859550f, -0.01871059f, -0.15378872f, 0.07315115f, 
    -0.15992723f, 0.10478131f, -0.08363075f, 0.00674074f, 0.08199902f, -0.01266389f, 0.04885405f, -0.18037434f, 
    -0.12765288f, 0.14530580f, -0.01784506f, 0.07731050f, -0.04028985f, -0.05402279f, 0.01259599f, 0.03483674f, 
    -0.14177544f, 0.01361045f, 0.01792907f, 0.02270975f, -0.32189327f, -0.21765977f, -0.03039181f, 0.08589288f, 
    0.05133928f, -0.04501984f, -0.02225273f, -0.01458441f, -0.02909452f, 0.05152801f, -0.14050974f, 0.01477330f, 
    0.00163730f, -0.15342772f, 0.04472474f, -0.28917959f, -0.10011140f, -0.00949229f, -0.01858283f, -0.10999768f, 
    -0.00737264f, -0.05754678f, 0.06577756f, 0.08535688f, -0.17649451f, 0.06111836f, -0.02674878f, -0.11497042f, 
    -0.00200464f, -0.17353375f, 0.04546659f, -0.15712321f, 0.11244650f, 0.00958859f, 0.01433356f, -0.12588961f, 
    0.47903210f, -0.05776480f, -0.03432710f, -0.07977822f, 0.03956070f, -0.02377018f, -0.01986995f, 0.07092562f, 
    0.08241908f, -0.09067468f, -0.04919358f, -0.02184735f, 0.06721144f, 0.10522112f, -0.06865106f, -0.00558647f, 
    -0.17300934f, -0.04315924f, 0.03552141f, -0.05806816f, 0.02850413f, -0.09193394f, -0.01728568f, -0.10603585f, 
    -0.01816659f, 0.00551616f, -0.14538768f, 0.31350988f, -0.07791610f, 0.11379639f, -0.05215706f, -0.11260816f, 
    0.07609154f, -0.00210640f, 0.09435538f, -0.04329237f, -0.04687488f, 0.00260675f, 0.05297858f, -0.31870213f, 
    0.10415722f, 0.05195045f, 0.10048179f, -0.05998759f, 0.04433327f, 0.02681805f, -0.00545930f, -0.10006277f, 
    0.06864492f, -0.01483776f, -0.02668362f, 0.25277695f, -0.11022723f, -0.03368253f, 0.02747508f, 0.02340572f, 
    0.00076852f, -0.04571287f, -0.02882273f, -0.01693490f, 0.19482875f, -0.03898541f, -0.08175771f, 0.09269045f, 
    -0.09108143f, 0.00978153f, -0.08107302f, 0.03985071f, -0.05654337f, -0.05158705f, -0.07596529f, 0.04151501f, 
    -0.01777742f, -0.03423587f, 0.02716061f, 0.01707116f, 0.05470373f, -0.10284533f, -0.01732752f, -0.04814765f, 
    -0.06293424f, -0.00668035f, -0.00473546f, -0.01917695f, 0.07175727f, -0.05975025f, -0.00233320f, -0.17344825f, 
    0.04924977f, -0.04130427f, -0.04088433f, -0.00780366f, 0.06240254f, -0.03452433f, -0.08661376f, 0.02409211f, 
    -0.11067741f, 0.13919789f, 0.14160359f, -0.03090747f, -0.05721889f, -0.02891166f, -0.02142051f, -0.01169947f, 
    0.02846598f, 0.02517044f, -0.00696041f, 0.02941822f, -0.17824952f, 0.17946374f, 0.00553889f, -0.00845025f, 
    0.01801413f, 0.11344739f, -0.05861653f, -0.00524382f, -0.05118383f, 0.01233654f, 0.01560836f, -0.13397016f, 
    0.01980902f, 0.02443926f, -0.03364529f, 0.19771336f, -0.08154116f, 0.00761693f, 0.08052821f, -0.06797855f, 
    0.02601018f, -0.02924854f, -0.04856504f, -0.02927840f, -0.08688902f, -0.05287493f, -0.12432663f, 0.19255246f, 
    0.06065107f, 0.00846834f, 0.07269582f, 0.07781652f, 0.02014795f, -0.18922411f, 0.06231562f, -0.07134678f, 
    -0.49705061f, -0.38789690f, 0.03405662f, -0.04224472f, -0.06172233f, 0.04140156f, 0.04047415f, 0.05714021f, 
    -0.02636669f, 0.01369455f, -0.08479719f, -0.02495219f, -0.48670721f, 0.20061655f, 0.12242791f, -0.10779170f, 
    -0.02305347f, 0.04552019f, -0.03927123f, -0.01136659f, 0.07636867f, -0.01022336f, 0.02279614f, 0.05319462f, 
    0.01936460f, 0.05750973f, 0.11634067f, -0.10913499f, 0.06041533f, -0.14363015f, 0.01054448f, -0.02269199f, 
    0.00996216f, 0.02836333f, -0.06285957f, -0.05229580f, 0.18591702f, -0.04048809f, -0.06496519f, -0.22797285f, 
    -0.01158778f, -0.03313534f, 0.00462147f, 0.19052793f, 0.15368515f, -0.10063456f, -0.02997691f, -0.03395969f, 
    -0.11288455f, -0.05776124f, 0.04555050f, -0.12442913f, -0.00658388f, 0.01727306f, 0.01732437f, -0.11138876f, 
    -0.10263557f, -0.05508279f, 0.03838061f, -0.01695130f, 0.22718163f, 0.06779256f, -0.02739042f, -0.23991470f, 
    0.11489891f, 0.01511626f, 0.11891828f, -0.06144412f, -0.08638402f, -0.00153573f, -0.00021183f, 0.09297667f, 
    0.33882982f, 0.15741007f, -0.05125574f, -0.27218607f, 0.00857022f, 0.02743819f, -0.08165372f, 0.07838618f, 
    0.03936438f, -0.05876056f, -0.02208212f, 0.09598260f, -0.18522917f, -0.02829902f, 0.09060210f, -0.25902775f, 
    -0.01135381f, 0.05942357f, -0.00190387f, 0.00825906f, -0.07162749f, 0.04448971f, 0.09352029f, -0.14034487f, 
    -0.15724429f, 0.03301341f, -0.14162633f, 0.23109154f, -0.07930829f, 0.01833156f, 0.06661890f, -0.07483797f, 
    -0.00562715f, 0.05090141f, 0.00938121f, 0.03827006f, -0.08918682f, 0.06004859f, -0.11185250f, 0.12915725f, 
    -0.13211903f, -0.16952783f, -0.02353394f, -0.07663810f, -0.05028588f, 0.06868010f, -0.09822771f, -0.04549258f, 
    0.14134528f, -0.00309752f, 0.17587227f, -0.09003068f, -0.08252984f, -0.12729385f, -0.08223902f, 0.10356178f, 
    0.10410752f, -0.10941447f, 0.02769289f, -0.07586341f, -0.04333739f, -0.11451446f, -0.01666195f, 0.07774407f, 
    0.04789013f, 0.14983331f, -0.11287450f, -0.01302453f, -0.08734004f, -0.02851146f, -0.02953001f, 0.04045831f, 
    -0.30199364f, -0.18056615f, -0.01954617f, 0.08982681f, -0.08391643f, -0.01498519f, 0.05166078f, -0.02097898f, 
    0.02625602f, -0.07050262f, -0.05474725f, -0.03827235f, -0.13042696f, -0.13530345f, 0.05489028f, -0.14956684f, 
    0.01462903f, 0.01350662f, 0.10760193f, -0.02591193f, 0.05695276f, -0.00284955f, -0.03863629f, 0.06676955f, 
    -0.05097378f, 0.12631285f, 0.11923924f, -0.07643836f, -0.13193190f, -0.00108716f, 0.05499130f, 0.08110903f, 
    0.01802228f, -0.02413235f, 0.00488447f, -0.04124675f, 0.07574268f, -0.14763294f, -0.07798205f, -0.26154459f, 
    0.01898697f, -0.04090990f, 0.07005593f, 0.13723296f, -0.10449181f, -0.05324653f, 0.00555629f, 0.04818182f, 
    0.09252993f, -0.06656580f, 0.02728151f, -0.08345593f, -0.03589119f, -0.04543719f, -0.07225274f, -0.15467672f, 
    -0.04961994f, -0.03908437f, 0.04251306f, 0.00633822f, 0.18336886f, -0.01822542f, -0.04198357f, 0.29034895f, 
    -0.08907987f, 0.13318877f, -0.03775854f, 0.01616631f, 0.01031963f, 0.01787671f, 0.01650133f, -0.02381118f, 
    0.04170686f, 0.02014919f, -0.04636162f, 0.04650568f, -0.14042111f, -0.11718602f, 0.08299919f, 0.02007790f, 
    -0.01582286f, -0.03457930f, 0.03882689f, -0.02723219f, -0.10116600f, 0.02324505f, 0.07994993f, -0.22281793f, 
    0.04385059f, 0.04431910f, -0.00349401f, 0.01061831f, 0.09167017f, -0.10610401f, 0.06809892f, -0.03142174f, 
    -0.09418910f, -0.02175710f, 0.18733232f, -0.11125799f, -0.15795812f, 0.02875348f, 0.04776967f, -0.12655592f, 
    0.01553636f, -0.08174575f, 0.02154886f, 0.05474079f, 0.48344937f, 0.15897234f, 0.17417289f, -0.21379286f, 
    0.02183606f, 0.03465076f, -0.06420819f, 0.00794683f, -0.03020041f, -0.05471645f, -0.09629307f, 0.01377885f, 
    -0.00817613f, -0.04354129f, 0.12728095f, -0.16079113f, -0.02624765f, -0.00076356f, 0.02021542f, -0.04273277f, 
    -0.05120231f, 0.18098892f, -0.01430557f, -0.05360541f, -0.20388635f, -0.00752822f, -0.00502420f, 0.10582864f, 
    0.11101475f, 0.08580548f, -0.03923548f, 0.11918763f, 0.04616811f, -0.05223402f, 0.02432730f, -0.00714128f, 
    -0.06167566f, -0.00294427f, 0.04956331f, -0.02786280f, 0.01423557f, -0.08190640f, 0.04651761f, 0.03117900f, 
    0.01580217f, 0.09893703f, 0.01606221f, 0.12971023f, -0.08222914f, -0.07112652f, 0.02524462f, 0.10298086f, 
    0.03555693f, -0.04681928f, 0.01662250f, 0.14295425f, 0.05199551f, 0.11709837f, 0.01280215f, -0.04785891f, 
    0.27431715f, -0.00703197f, -0.11613675f, -0.04157509f, 0.08593520f, -0.05523917f, -0.03822462f, 0.11150245f, 
    0.02977895f, 0.09661391f, 0.09799572f, 0.04728895f, -0.34323293f, 0.11353402f, 0.06559489f, 0.25366795f, 
    0.01377315f, 0.04233711f, 0.09204376f, 0.04127155f, -0.00601716f, -0.04698328f, -0.01958071f, -0.07436818f, 
    0.15812983f, -0.02287445f, -0.03798793f, 0.02018176f, -0.10592942f, 0.01650871f, -0.03104550f, 0.07867765f, 
    0.00213652f, 0.02401228f, 0.04524556f, 0.06142328f, -0.03651112f, 0.13235188f, -0.06866057f, -0.11134499f, 
    0.10109745f, 0.07827779f, 0.05822515f, 0.07562054f, -0.04747429f, -0.01266748f, 0.00265492f, 0.08403994f, 
    0.17589182f, -0.01154972f, 0.08127305f, -0.07632291f, -0.28083175f, -0.05091314f, -0.01107547f, 0.04991380f, 
    0.06618667f, 0.05043412f, -0.04316011f, -0.14829978f, 0.09050164f, -0.03233740f, -0.00639796f, 0.07391302f, 
    -0.06857301f, -0.21383160f, -0.09806804f, 0.11442073f, 0.01043254f, 0.00699075f, 0.06001835f, 0.02668601f, 
    -0.00957019f, 0.02577446f, 0.01234462f, 0.05735108f, 0.02847668f, -0.04944686f, 0.08643839f, 0.01768095f, 
    0.06307265f, -0.05651173f, 0.01536707f, 0.03665586f, 0.19295847f, -0.08309314f, -0.05443905f, -0.11137322f, 
    -0.02827202f, -0.13649125f, 0.05932258f, 0.04476244f, -0.02174640f, 0.17858042f, 0.08798612f, 0.03388165f, 
    0.19571270f, -0.11638060f, 0.13667840f, -0.06637156f, 0.10331204f, 0.04721490f, -0.09407955f, -0.05883132f, 
    -0.08548116f, 0.08908923f, 0.13099818f, -0.16674756f, 0.08603141f, 0.02419051f, 0.13243559f, 0.16066828f, 
    -0.04477203f, 0.04901952f, 0.01244015f, 0.01544926f, 0.03893567f, 0.06851053f, 0.03402819f, 0.05025098f, 
    -0.10205917f, -0.01775624f, -0.17637591f, -0.06213814f, -0.07807995f, 0.07425710f, -0.11346646f, -0.13448533f, 
    0.08443091f, 0.17784089f, -0.09869627f, 0.01920039f, -0.07924233f, -0.07415105f, -0.21397707f, -0.17930432f, 
    0.04054931f, 0.00909456f, -0.03794959f, 0.07368606f, 0.00321291f, -0.17694242f, -0.00958001f, -0.10089573f, 
    -0.27243173f, -0.12265009f, 0.10008146f, 0.12603340f, -0.01206136f, 0.02273206f, -0.03340909f, 0.02812249f, 
    0.05014403f, 0.04772449f, 0.10661211f, 0.00591743f, 0.20694782f, -0.22881980f, -0.00430638f, -0.12560385f, 
    0.04134748f, -0.03415428f, -0.08403821f, 0.10624994f, 0.06929852f, -0.20698373f, -0.00097353f, 0.00225284f, 
    0.24809486f, -0.18807796f, -0.04289645f, -0.00858901f, -0.07798723f, -0.01591212f, -0.11682477f, 0.05733871f, 
    -0.08436849f, -0.06382627f, -0.08172151f, 0.06714590f, 0.06781380f, 0.01778002f, 0.15238406f, 0.22606878f, 
    0.02252585f, -0.01284951f, 0.04952515f, 0.03642524f, 0.07507785f, -0.04082942f, -0.18197237f, 0.07078448f, 
    -0.08489218f, 0.05932980f, 0.02180012f, 0.02360667f, 0.03335879f, 0.05329515f, 0.00269436f, 0.10578432f, 
    -0.08104160f, 0.06860437f, -0.07747455f, -0.11886429f, 0.14627495f, 0.05768644f, -0.14572816f, -0.17489703f, 
    -0.01124978f, -0.00153765f, -0.03193818f, 0.07011393f, -0.06891064f, -0.02398341f, 0.06274643f, 0.01024226f, 
    0.14308225f, -0.23232712f, -0.01658209f, -0.01224719f, -0.10998122f, 0.06221237f, -0.07361906f, 0.02457466f, 
    0.00803962f, 0.08066550f, -0.05211963f, -0.16826205f, 0.00964471f, 0.03425960f, 0.09323797f, 0.04535811f, 
    -0.06209974f, -0.10985661f, 0.04902557f, -0.01784350f, -0.00271674f, -0.01160086f, 0.07278735f, 0.02022503f, 
    -0.04777952f, 0.22150685f, -0.10579115f, -0.18406701f, -0.09528369f, 0.04154663f, 0.07138349f, -0.00196267f, 
    -0.04243249f, 0.06372467f, 0.06285349f, -0.08704320f, 0.16700250f, 0.02695886f, 0.14889272f, 0.02946133f, 
    -0.05589570f, -0.14009489f, 0.04251218f, 0.00443062f, 0.00531907f, 0.00234975f, 0.00341207f, 0.05151495f, 
    0.19968870f, 0.03715600f, -0.23307763f, -0.30341718f, -0.02362851f, 0.13412133f, -0.03175447f, 0.01729264f, 
    0.19634542f, -0.07983407f, 0.03715021f, 0.03491503f, 0.04811379f, 0.06667277f, -0.25722575f, 0.01271701f, 
    -0.16929661f, 0.03059600f, -0.01306533f, 0.16227673f, 0.00137150f, -0.11707570f, 0.06774098f, 0.00458714f, 
    -0.42457595f, -0.14901640f, 0.04629686f, -0.20371383f, 0.00338283f, 0.00435850f, 0.09241901f, 0.13624179f, 
    0.00186876f, 0.08434439f, -0.03117324f, -0.11677554f, 0.16934265f, -0.38844386f, 0.07381885f, -0.04336669f, 
    0.11761876f, 0.08631885f, -0.04717339f, 0.02423677f, 0.01901537f, -0.05665788f, -0.14059360f, 0.13703029f, 
    -0.26588368f, -0.05925008f, 0.07775754f, -0.15674274f, 0.09607642f, 0.02106672f, -0.06817129f, -0.02664814f, 
    0.03549189f, -0.03410498f, 0.06380467f, -0.00726636f, -0.05533277f, 0.13971090f, 0.05807342f, 0.21827646f, 
    -0.10923004f, 0.07785396f, 0.00114986f, -0.00730933f, -0.00088268f, 0.04788258f, 0.04476169f, 0.04419111f, 
    0.10066947f, -0.03097856f, 0.05799316f, 0.11065579f, -0.10137760f, -0.00880794f, 0.00218805f, -0.03173378f, 
    -0.06844988f, 0.01534793f, -0.22296338f, 0.10127454f, -0.14480042f, 0.09509606f, -0.01941081f, -0.00799236f, 
    -0.06700740f, -0.14163850f, 0.03502600f, 0.04423777f, -0.05516930f, -0.05502635f, -0.05332853f, -0.10552750f, 
    0.31867477f, -0.02965236f, -0.00393201f, 0.19958711f, -0.13195154f, 0.10698837f, -0.04031108f, 0.04681408f, 
    0.05469927f, 0.12302513f, 0.03249845f, 0.00169021f, 0.28687021f, 0.04402895f, -0.04153522f, 0.23259445f, 
    -0.04177896f, -0.00034010f, 0.02220818f, 0.01850083f, 0.04554829f, -0.00019340f, -0.02652986f, 0.12900652f, 
    -0.31818378f, 0.06451616f, 0.00589296f, 0.09953025f, -0.00808094f, -0.03328094f, 0.03746728f, 0.04220350f, 
    0.07579757f, 0.04170405f, 0.05553112f, -0.04379142f, 0.10550657f, 0.00934035f, 0.11348061f, 0.05732417f, 
    0.03370468f, -0.10688706f, 0.07511635f, -0.04370847f, 0.04324023f, 0.05530857f, 0.02930929f, 0.01105973f, 
    -0.19938053f, -0.17710565f, -0.26001361f, -0.11205491f, 0.10106209f, -0.02573065f, -0.06009333f, -0.13542151f, 
    -0.11872322f, 0.12549332f, 0.06870014f, -0.02320983f, -0.17934026f, 0.04799753f, -0.26393107f, -0.15960842f, 
    0.00052545f, -0.10718559f, -0.00014207f, 0.06682963f, 0.10828564f, -0.00352678f, -0.05983390f, 0.14125015f, 
    0.13693380f, 0.01237497f, -0.17730637f, 0.08092599f, 0.01379978f, 0.08198607f, -0.07805672f, -0.00505711f, 
    -0.04054400f, -0.04388778f, 0.00365033f, 0.10433219f, -0.15597221f, 0.07525037f, -0.15116252f, 0.05063356f, 
    0.07193046f, 0.01910391f, -0.05839636f, 0.00576165f, -0.06759028f, 0.11495072f, -0.10141113f, 0.06598715f, 
    0.21731474f, 0.07933369f, -0.07056194f, 0.06231346f, 0.00583117f, -0.00329077f, 0.04913803f, 0.12713698f, 
    0.04077484f, 0.04532344f, 0.08354206f, 0.01636407f, 0.39284497f, -0.07510614f, -0.16303629f, 0.06597961f, 
    -0.08429895f, 0.00356264f, -0.02773111f, -0.06483616f, 0.05201856f, -0.12632897f, -0.03601815f, -0.08355490f, 
    0.10158826f, -0.11694392f, 0.03684884f, -0.13226300f, -0.05495410f, 0.13128631f, 0.08874469f, -0.07840320f, 
    0.01532714f, 0.01502133f, 0.02937205f, -0.01411894f, -0.23895974f, 0.04243181f, 0.05218293f, 0.09074246f, 
    -0.00491428f, 0.00843855f, -0.11371255f, -0.12097903f, -0.14200948f, 0.11913542f, 0.01576863f, 0.02514517f, 
    0.06931370f, -0.15636371f, -0.21870407f, -0.10088038f, 0.02290301f, -0.06123913f, 0.02478905f, 0.07830463f, 
    -0.09851070f, 0.06495647f, -0.14675187f, 0.00101598f, 0.14669381f, -0.18510491f, 0.05150062f, -0.21418877f, 
    0.10514216f, 0.00638888f, -0.07532683f, 0.02667708f, 0.05782651f, -0.07896517f, -0.03690000f, -0.11757427f, 
    0.00072060f, -0.01874854f, -0.13820447f, -0.07265468f, 0.00294578f, -0.07897867f, -0.01928523f, 0.03813819f, 
    0.00676623f, 0.00934411f, -0.00492026f, -0.00132123f, 0.20820338f, -0.01084807f, -0.07850894f, -0.33953360f, 
    0.09945627f, -0.01963986f, 0.14749442f, -0.02136868f, -0.08195502f, 0.02049374f, -0.01605907f, 0.07425973f, 
    -0.23563926f, 0.20461993f, 0.06650139f, 0.08317058f, -0.08733081f, -0.01112693f, -0.07581386f, 0.03995636f, 
    -0.05624276f, -0.13668250f, 0.04936697f, -0.03584877f, 0.07816053f, 0.06404219f, 0.07353868f, 0.10253439f, 
    -0.10180409f, -0.00595133f, 0.03683268f, -0.04753487f, 0.04614801f, -0.16434075f, 0.04352568f, 0.02064424f, 
    -0.12073344f, -0.02882551f, -0.08170621f, -0.13888451f, 0.06494091f, 0.01270983f, 0.09634032f, 0.01825918f, 
    -0.03248140f, 0.17917609f, -0.15090202f, 0.08853034f, -0.48102796f, 0.22801058f, -0.07876679f, 0.03842763f, 
    -0.05121884f, -0.12128141f, 0.04025540f, 0.00068992f, 0.21914442f, 0.01018173f, 0.03835486f, 0.08693461f, 
    -0.34589559f, -0.20340374f, -0.17937373f, -0.14255543f, 0.00921360f, 0.01595290f, -0.07898423f, 0.07771800f, 
    -0.06012988f, 0.05328095f, 0.14464836f, -0.08388641f, 0.16958052f, -0.27682444f, 0.02394355f, -0.03102290f, 
    -0.02820972f, 0.02253605f, -0.10390572f, -0.05019533f, -0.07826047f, -0.01260144f, 0.00319019f, -0.09265185f, 
    0.19848193f, -0.13686313f, 0.05376671f, 0.00110360f, -0.05212425f, -0.12103043f, 0.02349459f, 0.00508138f, 
    -0.09635369f, -0.03582362f, -0.13376004f, 0.10243254f, 0.22336152f, -0.10279621f, 0.18590678f, -0.38021371f, 
    -0.02930428f, -0.08967034f, -0.02641489f, 0.10409366f, -0.08249816f, -0.06560251f, 0.06337628f, 0.03181002f, 
    -0.15501063f, -0.11701542f, 0.01221900f, -0.21207368f, -0.00347713f, -0.04244504f, 0.05181228f, -0.00787872f, 
    0.07323440f, 0.01984515f, -0.06955194f, -0.05711760f, 0.07945721f, -0.11311683f, 0.05987061f, 0.11940166f, 
    -0.05672316f, -0.03146650f, -0.10128259f, -0.04880801f, -0.05009184f, -0.05730543f, -0.08625633f, 0.08328359f, 
    0.13215606f, -0.00985860f, -0.08239494f, -0.06007998f, 0.04943326f, 0.14356615f, -0.03309545f, -0.08102570f, 
    0.06107762f, -0.04169132f, 0.00727114f, -0.15914062f, 0.02864085f, -0.04997318f, -0.00640970f, 0.01825511f, 
    0.05837328f, 0.12533300f, 0.03898164f, -0.07556052f, -0.01143627f, 0.10398823f, -0.08936920f, 0.06531662f, 
    -0.31708741f, -0.03185202f, -0.06011977f, 0.03871515f, 0.04226835f, 0.10475542f, 0.00013578f, 0.04525155f, 
    -0.02727318f, -0.07440083f, -0.05478309f, -0.10127268f, -0.08229916f, 0.03359061f, -0.16517931f, -0.11721129f, 
    0.04987767f, 0.13973227f, -0.09573615f, -0.07105897f, 0.05908362f, -0.00495102f, 0.07289042f, -0.01753545f, 
    0.00155687f, -0.00036065f, 0.07922651f, -0.03560495f, -0.05807670f, -0.03620724f, 0.06869970f, -0.03269226f, 
    0.01836186f, -0.04765854f, 0.00450863f, 0.04484536f, -0.14433722f, 0.30690309f, -0.24355564f, 0.13550265f, 
    0.01642957f, 0.08452168f, -0.05995089f, -0.07947338f, -0.08715928f, 0.07007425f, 0.00138106f, -0.02563434f, 
    0.28515431f, -0.22693895f, -0.02416065f, -0.08061138f, 0.02672297f, 0.10823639f, -0.16546743f, -0.05491371f, 
    -0.08981576f, -0.02713813f, 0.06117551f, -0.11831231f, -0.08050940f, -0.07881601f, -0.16507278f, -0.33325049f, 
    -0.06149028f, 0.00492381f, 0.01979263f, 0.00584306f, 0.12772804f, -0.08245187f, -0.06843026f, -0.01830216f, 
    -0.35962495f, 0.11717605f, -0.15621369f, 0.09738873f, -0.02459643f, 0.04965046f, -0.00820638f, -0.00884369f, 
    -0.04785299f, -0.14992857f, -0.19196679f, 0.12213141f, 0.17167662f, 0.12606816f, -0.19767044f, 0.04696340f, 
    -0.05547383f, 0.08180410f, -0.03901876f, -0.13362198f, -0.09084545f, -0.08346361f, -0.02179215f, 0.00993156f, 
    0.21233939f, 0.10296266f, 0.01247853f, 0.36257902f, -0.07122766f, -0.06768503f, -0.05882179f, 0.05410471f, 
    0.10952406f, 0.06056130f, -0.02447830f, 0.04760724f, 0.19367976f, 0.00655781f, -0.04280914f, -0.09411295f, 
    0.08714482f, -0.12780048f, -0.06269483f, 0.11522342f, 0.03659812f, 0.05214480f, -0.03134041f, -0.01762389f, 
    -0.00917150f, -0.04999025f, 0.16488704f, 0.16241777f, -0.01074234f, -0.06473590f, 0.00206717f, -0.04630652f, 
    -0.07787013f, -0.01282607f, 0.03104272f, 0.09277584f, 0.27384874f, 0.12145767f, 0.08270733f, 0.17610559f, 
    0.03824284f, -0.05873936f, -0.03536662f, -0.01944886f, -0.01220796f, -0.01260732f, -0.03981118f, -0.08378607f, 
    -0.05370747f, 0.07523332f, -0.16270383f, -0.04560576f, -0.01614097f, 0.04969222f, -0.02382621f, -0.02434112f, 
    -0.06314485f, 0.13764574f, -0.02969575f, -0.07518104f, -0.20873244f, -0.02741713f, 0.10874341f, -0.21213415f, 
    -0.06487171f, 0.11595947f, 0.05725791f, 0.01903108f, 0.04610744f, -0.08611901f, -0.08587763f, -0.15023839f, 
    -0.56900179f, 0.07090804f, -0.03267133f, -0.14483404f, 0.14522740f, 0.08261821f, 0.00910281f, -0.05612168f, 
    -0.04695346f, 0.01250305f, -0.03987378f, -0.04951213f, 0.05386038f, 0.13335611f, -0.00028957f, -0.05681185f, 
    0.16193371f, -0.06736892f, -0.00207572f, -0.11129361f, 0.05440344f, 0.06577288f, 0.00933989f, 0.01338974f, 
    -0.12202083f, -0.01778749f, 0.15821570f, 0.09374492f, -0.09161999f, 0.11848840f, 0.04294626f, -0.07380383f, 
    -0.04075566f, -0.06854199f, -0.06855565f, -0.00582252f, 0.08503319f, -0.04934333f, -0.14263661f, 0.02751144f, 
    -0.07678300f, -0.03931025f, 0.02314484f, -0.09580656f, -0.02578620f, 0.01307007f, -0.06188198f, -0.02662373f, 
    0.27503243f, 0.05141118f, -0.04221387f, 0.04073860f, -0.00450263f, 0.09677333f, -0.00030325f, 0.06842554f, 
    -0.07589377f, 0.02408282f, -0.03587075f, -0.05861173f, 0.16023898f, -0.03186860f, -0.03947464f, -0.10687697f, 
    0.01174164f, -0.02692702f, 0.02350462f, -0.02700934f, -0.06921980f, 0.08860245f, -0.06884007f, -0.03905600f, 
    -0.14801650f, -0.26256573f, 0.11994565f, -0.21883397f, 0.03349762f, 0.08584989f, -0.03099805f, 0.09175899f, 
    -0.05958914f, -0.10645289f, 0.03178386f, -0.15894887f, 0.08013821f, 0.09616823f, -0.07394971f, 0.07737428f, 
    0.01610546f, 0.02301492f, 0.06241263f, -0.03347957f, 0.01629337f, 0.04425795f, 0.06860519f, -0.09970271f, 
    0.09168969f, -0.09598292f, -0.07184067f, 0.03201282f, 0.15297560f, 0.03891569f, -0.00767961f, -0.00988623f, 
    -0.00948189f, 0.05668107f, 0.02972390f, 0.08332308f, -0.24009705f, 0.04456164f, 0.17668658f, -0.01447181f, 
    -0.04853244f, -0.00342124f, 0.07023267f, -0.09417786f, -0.05252042f, -0.10854298f, 0.00626336f, -0.02495648f, 
    -0.39328176f, -0.04116577f, -0.11405611f, -0.09750323f, 0.08086603f, -0.01519638f, -0.03154059f, 0.06939323f, 
    -0.04147232f, 0.03728919f, -0.01783639f, -0.06517663f, 0.01756523f, 0.01975144f, 0.03691773f, -0.11779789f, 
    0.02193500f, 0.02181104f, 0.02687361f, -0.05584832f, -0.09837183f, -0.00807290f, -0.04680469f, -0.05100797f, 
    0.47849178f, 0.01405699f, -0.15590626f, 0.10987414f, 0.10529651f, -0.01253737f, 0.01663277f, -0.02637387f, 
    -0.04997906f, 0.04087591f, 0.01476668f, 0.10532426f, 0.07652514f, 0.01926178f, -0.05937498f, 0.00725187f, 
    0.00035658f, -0.05705752f, 0.06865744f, 0.09798270f, -0.10254307f, 0.02417002f, 0.02367888f, -0.11270815f, 
    0.01555123f, -0.07532413f, -0.14075956f, -0.01898875f, -0.10913585f, 0.01669102f, -0.04034736f, -0.09688655f, 
    -0.05282708f, -0.02713859f, -0.00248197f, 0.02025002f, 0.18185790f, -0.19996856f, 0.17386989f, -0.06944378f, 
    0.02728761f, -0.07797107f, 0.07501853f, -0.00130987f, -0.04559413f, -0.04209467f, 0.01031947f, -0.07574265f, 
    -0.19571728f, 0.23510407f, 0.02605507f, -0.08160187f, 0.11862254f, 0.07438114f, -0.08332329f, -0.08364300f, 
    -0.10126209f, 0.05565284f, -0.03675481f, -0.01046133f, 0.23940481f, -0.10880074f, -0.13291156f, -0.14764088f, 
    -0.05938167f, -0.08712856f, -0.03115271f, -0.04618261f, 0.06332134f, -0.01700260f, 0.04482078f, -0.09465533f, 
    0.10242068f, 0.07189885f, 0.01283300f, 0.00989327f, -0.00639936f, -0.02636783f, 0.05494009f, -0.01203410f, 
    -0.10441659f, 0.07644781f, -0.01037914f, -0.02980541f, 0.04451172f, 0.07692948f, -0.07392517f, 0.00297335f, 
    0.11830834f, -0.01158892f, -0.03031278f, 0.03697712f, -0.03642175f, 0.04758750f, 0.00996914f, 0.07546967f, 
    0.02519002f, -0.00961252f, -0.13359860f, -0.02476733f, -0.05561312f, 0.11141078f, -0.04471847f, 0.00052300f, 
    0.03164525f, -0.02203269f, 0.19634847f, -0.08507113f, 0.00998063f, -0.02693964f, 0.01059415f, -0.01252277f, 
    0.08466345f, 0.03520443f, 0.05742921f, -0.14482647f, -0.04484143f, 0.10517371f, 0.00741720f, 0.00511740f, 
    -0.28716657f, -0.12160481f, 0.10611431f, -0.01561716f, 0.05825362f, 0.00997339f, -0.03020081f, 0.02168793f, 
    0.03068490f, -0.00757790f, -0.01309107f, 0.03127519f, 0.02610143f, 0.18085302f, -0.06890206f, 0.03508710f, 
    0.02775917f, -0.00379141f, -0.00425248f, -0.04029877f, 0.02496509f, -0.04049252f, 0.05426518f, 0.00022652f, 
    -0.11294711f, -0.17104095f, 0.14673348f, -0.13422182f, -0.11103146f, 0.04512366f, 0.01280943f, -0.07177534f, 
    0.02399290f, -0.01955215f, -0.01371932f, 0.00792697f, -0.23849006f, 0.04675100f, 0.07803281f, -0.18137814f, 
    0.00317538f, 0.02129718f, 0.08879808f, 0.00373730f, -0.10827923f, 0.02297971f, 0.01961915f, -0.00053645f, 
    0.17274028f, 0.03958969f, -0.10297713f, 0.04440135f, 0.09070539f, -0.00556949f, 0.01919656f, -0.05469153f, 
    -0.11573262f, -0.03827677f, -0.00109813f, -0.10649733f, -0.02205343f, 0.06088342f, -0.14915472f, -0.15839657f, 
    -0.03919601f, 0.05634002f, -0.00672336f, -0.09633920f, -0.02987757f, -0.08363309f, -0.05143107f, -0.14726514f, 
    -0.06670485f, -0.07249046f, -0.06691785f, 0.04391239f, 0.08704825f, 0.05788802f, -0.08038892f, -0.10009778f, 
    0.02801650f, -0.05124344f, -0.01390898f, 0.00758935f, 0.10776769f, -0.23763706f, -0.20091380f, 0.01986651f, 
    -0.13736691f, -0.01629038f, -0.09402773f, -0.00526109f, -0.03619413f, -0.09682121f, -0.01116050f, -0.01080362f, 
    0.09106118f, -0.28381032f, 0.20545600f, -0.18949123f, -0.18690498f, -0.01345411f, 0.03798167f, -0.01156510f, 
    -0.03234456f, -0.07209391f, 0.01544166f, -0.03485432f, 0.34503931f, 0.07085406f, 0.03833752f, 0.15589410f, 
    -0.05864845f, -0.05453158f, -0.03520507f, 0.04729806f, 0.00312204f, 0.12771416f, 0.02522539f, -0.00205431f, 
    0.02794390f, -0.10346339f, -0.03434874f, -0.13076781f, 0.09933431f, -0.05162604f, -0.04977764f, -0.10655841f, 
    0.04983816f, 0.08093835f, -0.05136501f, -0.02429323f, -0.07688526f, 0.16285013f, -0.00891667f, 0.05174927f, 
    -0.09778810f, -0.14203085f, -0.00870243f, 0.11635093f, -0.11190308f, -0.07495342f, 0.00523096f, 0.00190666f, 
    -0.02561740f, -0.04755985f, -0.07604842f, -0.05210213f, -0.11443757f, -0.06947212f, -0.00633689f, -0.03381639f, 
    0.08334187f, -0.07214478f, 0.03090105f, -0.02514111f, -0.02002491f, 0.12749363f, 0.10826843f, 0.33334723f, 
    -0.09050218f, 0.00114292f, -0.01566871f, 0.05387755f, -0.06145756f, 0.02403984f, -0.05263517f, 0.01755903f, 
    0.28413367f, 0.12874424f, 0.24339111f, 0.28230211f, -0.08018994f, -0.21813650f, -0.07383511f, 0.05291490f, 
    -0.02378425f, -0.04306287f, -0.04932506f, 0.01707864f, -0.42554340f, -0.11858082f, -0.03338986f, -0.16187829f, 
    -0.03654475f, -0.02110787f, 0.03048019f, -0.01299230f, -0.00622655f, -0.02610798f, 0.04991173f, -0.06136558f, 
    0.22713657f, -0.01320435f, -0.05648905f, 0.02317013f, -0.03496855f, 0.09070652f, -0.10438610f, 0.02643650f, 
    0.00399529f, 0.09320294f, -0.07628715f, -0.05455139f, -0.10574786f, 0.03042425f, 0.10765728f, -0.05554655f, 
    -0.02073275f, 0.11524706f, 0.09452854f, 0.08298668f, 0.00482468f, 0.05443671f, -0.03655872f, -0.00738955f, 
    -0.04053038f, 0.03355071f, -0.25233358f, -0.09288096f, 0.11676894f, 0.06641897f, 0.00489022f, -0.09603091f, 
    -0.05390078f, 0.00277345f, 0.11183755f, -0.11921568f, -0.25030929f, 0.15281948f, -0.03256282f, -0.17940004f, 
    -0.10725151f, 0.01370124f, -0.04491092f, -0.02398110f, 0.10016304f, -0.06137415f, 0.06020516f, -0.03418257f, 
    0.18135072f, 0.01144470f, -0.18081357f, 0.00500135f, -0.11044691f, -0.00407102f, -0.04177641f, 0.06007007f, 
    0.02919123f, 0.05036189f, -0.05786112f, -0.03632130f, -0.29562247f, -0.07899691f, 0.02981544f, -0.19087562f, 
    -0.06578584f, -0.11814255f, 0.02591537f, -0.03901970f, 0.00915339f, -0.03035770f, 0.00516296f, 0.05963876f, 
    0.21820758f, -0.13117458f, -0.00570310f, -0.01469283f, 0.03831401f, -0.05012777f, 0.00269806f, -0.00887687f, 
    0.04022914f, -0.01386364f, 0.06596418f, 0.07439423f, 0.04623784f, 0.03318585f, 0.01246390f, -0.02122443f, 
    -0.01982667f, -0.04118436f, 0.07301676f, 0.05889674f, -0.09358554f, 0.04645800f, -0.05741262f, -0.00661969f, 
    -0.43572697f, 0.16114470f, 0.02459182f, 0.05974386f, -0.04080836f, -0.04293726f, 0.09759436f, 0.00146605f, 
    0.03036006f, -0.02899037f, 0.03154308f, -0.08250222f, 0.09050253f, 0.05336295f, -0.01763295f, -0.00456887f, 
    0.05270948f, 0.01328403f, 0.04879371f, 0.04714064f, 0.07710620f, -0.03104567f, -0.00010260f, -0.04298672f, 
    0.07013015f, -0.02331837f, -0.13793993f, 0.07607290f, 0.06015638f, 0.06007012f, 0.00509877f, -0.07833638f, 
    -0.04749751f, -0.02424937f, -0.13284665f, 0.01564667f, -0.03781733f, -0.02803273f, 0.06417585f, -0.10706575f, 
    -0.19331583f, -0.13013083f, -0.08728521f, 0.00894513f, -0.01010722f, -0.03012928f, 0.01207399f, 0.03735351f, 
    0.24953347f, -0.06563688f, -0.22299950f, 0.06561316f, 0.01593675f, -0.08422044f, 0.03289335f, -0.10122854f, 
    -0.04846420f, 0.10048707f, -0.03538841f, 0.01309066f, 0.12843993f, 0.08388821f, -0.05973614f, 0.03009900f, 
    0.08236656f, 0.03498382f, -0.01970698f, 0.03241114f, -0.02980449f, 0.04074157f, 0.05406967f, -0.09163709f, 
    -0.27036586f, -0.01737353f, -0.03300506f, -0.03894772f, 0.03460327f, -0.08308391f, 0.02050195f, -0.00974323f, 
    -0.14686069f, -0.05446417f, -0.04579214f, 0.00115203f, 0.25045764f, -0.08655642f, 0.00063097f, -0.03253374f, 
    -0.03378883f, 0.05181482f, -0.11561970f, 0.02479577f, 0.00417741f, -0.02299005f, -0.10345468f, 0.07743345f, 
    0.09805708f, -0.12335145f, 0.08206096f, -0.09730853f, 0.09928748f, 0.00148488f, 0.05249290f, 0.05051755f, 
    -0.08393216f, 0.01265448f, -0.02134160f, -0.03839359f, -0.23614514f, -0.15796387f, -0.10816764f, -0.12846272f, 
    0.01161689f, -0.01628665f, -0.08152787f, 0.00391941f, -0.03563786f, 0.02255405f, -0.02308054f, -0.04373637f, 
    0.35162669f, -0.03049010f, -0.11769690f, -0.24560814f, -0.09391513f, -0.01799378f, -0.17696157f, -0.06662334f, 
    0.03946637f, -0.08169184f, 0.01515761f, -0.01533249f, 0.34418580f, -0.05124851f, -0.00217361f, -0.02924447f, 
    -0.13279104f, -0.03587138f, 0.00091333f, -0.07315619f, 0.00077232f, 0.08803725f, -0.06665637f, -0.06542103f, 
    -0.09343974f, -0.04123447f, 0.09144081f, -0.03371974f, 0.12796299f, 0.04843725f, -0.00024700f, -0.01290821f, 
    -0.08595646f, -0.06045915f, -0.02381335f, 0.02688721f, 0.19868648f, 0.13684024f, 0.04147742f, 0.22167748f, 
    -0.15597565f, -0.02498226f, 0.02545239f, 0.02758836f, 0.01481728f, -0.01001462f, -0.09793039f, 0.05689389f, 
    0.06219783f, 0.00061498f, -0.05928493f, 0.10319150f, 0.07169336f, 0.02750652f, 0.06371784f, -0.00573580f, 
    -0.04774350f, -0.01818352f, -0.05951943f, -0.02295045f, 0.11114028f, 0.00022074f, 0.07751410f, -0.06919787f, 
    -0.01476215f, 0.10837632f, 0.03430240f, 0.06547343f, -0.01681631f, 0.10994205f, 0.08993275f, 0.00975514f, 
    -0.40921485f, -0.22164468f, -0.10314876f, 0.08092634f, -0.00971944f, 0.08323320f, 0.01668471f, 0.04284634f, 
    -0.02213351f, -0.04015695f, 0.01944142f, 0.01123471f, -0.02318965f, -0.09212661f, -0.01789788f, 0.19061480f, 
    0.02572665f, 0.02095581f, -0.10281896f, -0.03217253f, -0.11513884f, -0.00496585f, -0.11127159f, 0.05349869f, 
    -0.12466656f, 0.12899514f, -0.12906308f, 0.10473210f, 0.08957580f, 0.07830439f, 0.02066000f, 0.01668253f, 
    -0.01005104f, 0.02490216f, -0.04273879f, 0.04015414f, -0.27473497f, -0.39227146f, -0.00938973f, 0.05099174f, 
    0.01392887f, 0.02441348f, -0.05223830f, -0.05014778f, -0.11907805f, 0.05170050f, 0.04508809f, -0.03650513f, 
    -0.06961679f, -0.27917674f, -0.12287527f, 0.26078776f, -0.03754263f, -0.13961311f, 0.11100333f, 0.03209066f, 
    0.00061236f, -0.02855285f, 0.03520158f, 0.07711712f, -0.16741741f, 0.24139242f, 0.01924769f, 0.00159341f, 
    -0.04864138f, -0.05925186f, -0.02449103f, 0.09108484f, 0.01275283f, 0.11752741f, 0.01655113f, -0.00834935f, 
    -0.26888281f, 0.03667258f, 0.16597149f, 0.13645875f, -0.02327689f, 0.07396917f, -0.02898647f, 0.02068208f, 
    0.01981401f, 0.07938903f, 0.04592557f, -0.10121436f, 0.11391238f, -0.06893838f, 0.12674172f, 0.10016546f, 
    0.03995528f, 0.08030605f, -0.01417201f, -0.00925319f, 0.05525381f, 0.14822154f, 0.00046057f, 0.02288837f, 
    0.15527835f, 0.11729845f, -0.05606714f, 0.21667457f, -0.01897404f, 0.14479341f, -0.02786393f, -0.03583340f, 
    0.07765619f, -0.07696781f, -0.03780046f, 0.02447940f, -0.03357189f, -0.32630801f, -0.18966088f, 0.19683473f, 
    0.03121310f, 0.03738671f, 0.09349673f, -0.10567212f, -0.07043483f, 0.04939820f, -0.01239203f, -0.15905762f, 
    0.30119249f, 0.08986233f, -0.15452990f, 0.17245947f, 0.09648541f, 0.02281804f, 0.11763172f, -0.12808144f, 
    0.06508576f, -0.01104746f, 0.07950920f, -0.05529707f, -0.15862103f, -0.18368591f, -0.09209287f, -0.00000126f, 
    -0.06082348f, -0.03351967f, -0.03670900f, -0.01191415f, 0.00029497f, -0.02600204f, -0.07634626f, 0.00043531f, 
    0.15240692f, -0.18090707f, 0.07611445f, 0.04279967f, 0.03128979f, -0.01415102f, -0.04458816f, -0.02616810f, 
    0.04941192f, 0.00773657f, 0.00970414f, -0.01214821f, -0.28862384f, -0.19987683f, -0.04786779f, -0.04761125f, 
    -0.00781484f, -0.01630707f, -0.04313524f, -0.06648373f, -0.04706817f, -0.02500411f, -0.04280598f, -0.07058827f, 
    -0.27380508f, 0.04216086f, 0.26701358f, -0.12336846f, 0.10504808f, -0.03726406f, 0.04201097f, 0.09774758f, 
    0.09830671f, -0.09689187f, -0.02647345f, 0.06554677f, -0.13325109f, -0.21661918f, -0.23883863f, -0.07321361f, 
    -0.14334339f, 0.03270972f, -0.03468271f, 0.06019962f, -0.06633428f, 0.08222579f, -0.04301227f, -0.06263330f, 
    -0.05742959f, 0.22749135f, 0.12077261f, -0.03315094f, -0.07419498f, -0.07260621f, 0.07164147f, 0.01335908f, 
    -0.01789343f, 0.01565369f, -0.10427284f, 0.09693719f, -0.03469477f, 0.16285078f, 0.08825698f, 0.07999130f, 
    -0.06925338f, -0.05766114f, -0.15161470f, -0.06373242f, 0.04453238f, 0.00154789f, 0.03473001f, 0.06974494f, 
    0.19258355f, 0.11421047f, 0.03267267f, -0.00948077f, -0.01564008f, -0.05288212f, -0.07618344f, 0.04018814f, 
    0.09922875f, -0.00733337f, -0.07574973f, 0.01649734f, 0.08056105f, 0.13227884f, 0.20394479f, 0.21459627f, 
    -0.05003486f, -0.14506532f, 0.09522644f, -0.02563490f, -0.05699388f, 0.09641012f, 0.01160770f, 0.01389525f, 
    -0.01835334f, 0.13120480f, -0.01597167f, -0.15779276f, -0.06852729f, -0.00749879f, -0.06034846f, 0.04975713f, 
    0.01770665f, -0.02485197f, -0.06210378f, 0.11770958f, -0.62086123f, -0.18949468f, 0.30295634f, 0.02354899f, 
    -0.00084981f, 0.00284853f, -0.00228251f, 0.00107536f, -0.06052351f, -0.11246645f, -0.02235059f, -0.01748380f, 
    -0.16882341f, -0.05863096f, 0.05324626f, -0.04745075f, 0.01572650f, 0.00080003f, 0.03239861f, -0.01689740f, 
    0.03706322f, -0.02257686f, -0.01293109f, 0.00284393f, 0.25802806f, 0.11681300f, -0.11271029f, -0.10352768f, 
    -0.05728231f, -0.01074167f, -0.03371492f, 0.04356164f, 0.04002518f, 0.03603953f, 0.10721431f, 0.07027540f, 
    -0.57466328f, -0.32473221f, 0.04931289f, -0.00712327f, -0.08096403f, 0.01034355f, -0.02194144f, -0.09031821f, 
    0.05321435f, -0.13320874f, 0.00939861f, 0.02752827f, -0.32134488f, -0.35655430f, -0.20288934f, -0.07892896f, 
    0.03313538f, -0.04670569f, 0.06322529f, -0.06701849f, -0.04135051f, -0.03814645f, 0.01022053f, 0.04243886f, 
    0.02090137f, 0.07093709f, 0.10854946f, -0.14153779f, -0.00480884f, 0.01944030f, -0.00482340f, 0.01524240f, 
    -0.02140240f, -0.06232703f, -0.00545277f, 0.07080378f, 0.21214469f, -0.08390166f, -0.15080288f, 0.14646837f, 
    -0.05277101f, 0.01581790f, 0.05489937f, 0.10972010f, -0.02009192f, 0.11290742f, -0.01442660f, 0.05326570f, 
    -0.16265605f, 0.19086276f, 0.11836040f, 0.10441117f, 0.08748925f, 0.00505639f, 0.06425180f, 0.09581753f, 
    -0.10072462f, -0.01827450f, -0.06272381f, -0.11987626f, -0.26527929f, 0.34959012f, 0.01138922f, -0.04289567f, 
    -0.05209703f, -0.01377347f, -0.05311068f, -0.10811669f, -0.01758515f, 0.01447080f, 0.08482313f, -0.14287186f, 
    -0.12620087f, -0.04800270f, 0.04357774f, 0.06220185f, 0.00696697f, 0.03935170f, 0.10417471f, -0.02156590f, 
    0.01994573f, -0.00152291f, 0.02730300f, -0.02506637f, -0.05376386f, -0.02154129f, 0.11604854f, 0.11856065f, 
    -0.06069766f, 0.01000067f, 0.03802434f, 0.01901858f, -0.01847000f, 0.05557341f, 0.01493998f, -0.10102386f, 
    -0.00960409f, 0.00067581f, -0.00216924f, 0.00486239f, -0.11108597f, -0.03795002f, -0.04301897f, -0.02949965f, 
    0.00701018f, -0.02606178f, -0.07744613f, 0.12008078f, 0.08207420f, -0.26595756f, 0.08942915f, -0.02013077f, 
    0.06700591f, 0.09361007f, 0.07831249f, 0.04554909f, -0.08208612f, 0.08690093f, 0.00111840f, 0.10424753f, 
    0.36607191f, -0.13505036f, 0.02491244f, 0.10553516f, -0.06115548f, -0.05956300f, -0.15775508f, 0.08742598f, 
    -0.00084252f, 0.00077439f, -0.04484256f, -0.06356204f, -0.01612494f, -0.08478316f, -0.07803269f, -0.06748819f, 
    0.07422253f, 0.02706758f, 0.01878118f, -0.00427267f, 0.05543753f, 0.03319230f, 0.05065737f, 0.05404207f, 
    0.20122562f, 0.02015262f, 0.00574606f, 0.09050141f, -0.10625011f, 0.05025004f, -0.01340969f, 0.00490692f, 
    -0.00409084f, 0.00889960f, 0.13039085f, -0.03666958f, -0.01356663f, 0.06979954f, -0.07104600f, -0.09148014f, 
    -0.14795426f, -0.03982364f, -0.02720368f, -0.07371355f, -0.02809239f, -0.03218618f, 0.01521870f, 0.02014508f, 
    0.07145082f, -0.03487312f, -0.03975377f, -0.09537725f, -0.04598138f, -0.07050580f, 0.06619290f, -0.13338616f, 
    -0.12866279f, -0.10307721f, -0.03322494f, -0.00697217f, 0.14889565f, -0.07106736f, 0.04965177f, -0.07650618f, 
    -0.11447427f, -0.01988566f, -0.04494946f, 0.11918752f, 0.04085897f, -0.02944713f, 0.02450244f, -0.02756684f, 
    0.13815379f, 0.04579470f, 0.06895115f, -0.14537422f, 0.04228448f, -0.02917997f, 0.05323323f, 0.01731032f, 
    -0.04066661f, -0.04071876f, -0.00210021f, 0.02026777f, -0.21784371f, -0.13453834f, -0.22143033f, 0.14866436f, 
    -0.07628929f, 0.07639580f, -0.02883049f, 0.05780988f, 0.00049905f, 0.10333933f, -0.01849668f, -0.00014528f, 
    0.11497474f, 0.02952068f, 0.16962087f, 0.15085621f, 0.05194038f, 0.03322302f, 0.04512106f, -0.01046894f, 
    0.05587652f, 0.00503903f, 0.04615747f, -0.17932186f, 0.20116121f, 0.03173262f, -0.01490560f, -0.10523288f, 
    0.06347281f, 0.01874240f, -0.03270409f, 0.10200396f, -0.04912247f, -0.03260774f, -0.07327829f, 0.06953017f, 
    -0.15969889f, 0.23627470f, 0.15943006f, 0.21113443f, 0.07164205f, 0.01670212f, 0.03009892f, -0.07364862f, 
    -0.11432973f, 0.06053821f, -0.05971068f, 0.00422312f, 0.15747730f, -0.06588986f, 0.11269422f, 0.04028008f, 
    0.00209649f, -0.02962089f, 0.07764208f, 0.07681026f, -0.12214840f, 0.00876331f, -0.04807282f, 0.08147793f, 
    -0.16038089f, -0.19836728f, -0.19904757f, -0.10142685f, -0.01148694f, -0.01897646f, -0.05076082f, -0.01264837f, 
    -0.08996461f, -0.11442955f, 0.06944868f, -0.03624655f, -0.04414780f, -0.13124807f, -0.14775102f, 0.02938134f, 
    -0.13413069f, 0.14043809f, -0.04230397f, 0.09708034f, 0.02858891f, 0.11852118f, -0.04353539f, -0.02462717f, 
    -0.03884575f, -0.21594857f, 0.09856571f, 0.02052171f, -0.11376716f, 0.12592398f, -0.11964991f, 0.00781273f, 
    0.00225555f, 0.00678291f, -0.05390538f, 0.05984675f, 0.28280953f, 0.03520073f, -0.01443179f, -0.11535050f, 
    0.01593723f, 0.01281273f, 0.07621902f, -0.13647132f, -0.04771939f, -0.10455807f, -0.09423865f, -0.04531137f, 
    -0.11858261f, -0.03368869f, 0.10523799f, 0.10331520f, -0.05655894f, -0.00520580f, 0.07507364f, 0.03163529f, 
    -0.08217847f, -0.00591783f, -0.07469038f, 0.11935259f, -0.03984816f, -0.06604905f, 0.01493589f, -0.07215278f, 
    -0.02442844f, -0.10232148f, 0.07337980f, 0.05122239f, -0.01392528f, -0.01448947f, 0.09197960f, 0.03841337f, 
    0.26843157f, 0.13086423f, 0.08667455f, 0.01602382f, -0.03718287f, -0.03197070f, 0.09089043f, -0.01857379f, 
    -0.02046408f, 0.03125928f, 0.00565789f, -0.02860241f, -0.47104400f, 0.22430913f, -0.02354755f, -0.13284135f, 
    0.01054863f, -0.04342438f, -0.02083417f, 0.07798375f, -0.04083774f, -0.00462716f, -0.04901888f, 0.00561543f, 
    0.02433180f, -0.07984789f, -0.14414299f, -0.07175858f, -0.10706390f, 0.06032018f, 0.00547723f, 0.00468077f, 
    0.02819085f, -0.00905062f, -0.07662899f, 0.06426009f, 0.05826842f, 0.00924400f, -0.07859161f, 0.14196104f, 
    0.03704228f, -0.09716040f, -0.04871681f, 0.03622197f, 0.00203199f, -0.03335149f, -0.04188953f, 0.02674328f, 
    0.03124763f, -0.09885301f, -0.06723085f, 0.10175790f, -0.07308371f, -0.06962401f, 0.01121343f, -0.02620808f, 
    -0.02853144f, -0.01506145f, 0.02321938f, 0.01273716f, 0.09236185f, 0.23462549f, 0.15895496f, 0.16923904f, 
    0.00144958f, -0.14446248f, -0.01811546f, -0.04876947f, 0.04238518f, 0.00436285f, -0.03705405f, -0.00424492f, 
    0.18075946f, 0.15079194f, -0.08222166f, -0.10198997f, 0.01711374f, 0.08638477f, -0.05877195f, 0.05541381f, 
    0.01598874f, 0.02135315f, -0.01034136f, 0.01996682f, -0.10792993f, 0.01007110f, -0.02714242f, -0.18177694f, 
    -0.01756665f, -0.12553404f, -0.01469412f, 0.03606302f, -0.03158759f, -0.06108233f, -0.00261578f, 0.00361127f, 
    -0.11567132f, -0.50865787f, -0.07540885f, 0.03569513f, -0.08810975f, -0.02193229f, 0.07321887f, -0.07029574f, 
    0.03111812f, -0.11457577f, 0.06807556f, 0.01435543f, 0.02126537f, -0.01184404f, -0.05982628f, -0.09546822f, 
    -0.12284383f, -0.04574879f, 0.06036336f, -0.10001925f, -0.12015515f, -0.10033882f, -0.06764381f, 0.03686993f, 
    -0.02318305f, -0.20910893f, -0.25529048f, 0.25466028f, -0.01217726f, 0.06816044f, -0.00868958f, -0.08950753f, 
    0.00911133f, -0.16008997f, 0.08719692f, -0.11997339f, -0.10871899f, -0.30722633f, -0.33836144f, -0.02941571f, 
    -0.07367409f, -0.07018659f, 0.05013769f, -0.03424937f, 0.00739926f, 0.03116888f, -0.02256993f, 0.09748876f, 
    -0.15786381f, 0.05494862f, 0.08506560f, 0.06305093f, -0.00503073f, -0.04826142f, -0.02903759f, 0.02133556f, 
    0.07290766f, -0.01538794f, -0.01635685f, -0.00631708f, -0.14738634f, -0.25486144f, 0.04840448f, -0.02734310f, 
    -0.09313979f, 0.10752428f, 0.02216516f, -0.16270396f, 0.01904812f, -0.11523551f, -0.07411517f, -0.00270209f, 
    -0.20432770f, -0.24236667f, -0.12407617f, -0.04949507f, 0.04190510f, -0.00513973f, -0.00500009f, 0.06000794f, 
    0.10181902f, 0.02949365f, 0.03634344f, -0.05882536f, 0.14281183f, -0.03087023f, 0.11972756f, 0.08846179f, 
    -0.07230484f, -0.03623929f, -0.05977554f, 0.02072563f, 0.06650040f, -0.02029071f, -0.07291864f, -0.08973650f, 
    0.26208067f, -0.02672773f, -0.32499599f, -0.25278214f, 0.03020805f, 0.03416380f, 0.08390313f, 0.04337776f, 
    0.02568882f, 0.00280115f, 0.07074299f, -0.00435231f, -0.00730172f, -0.00400042f, 0.23840597f, -0.14175016f, 
    0.01202817f, -0.06094575f, 0.02544123f, 0.13735585f, 0.01153073f, 0.12303026f, 0.05028193f, 0.17591786f, 
    -0.47402936f, -0.00215948f, 0.06839295f, -0.07222390f, -0.01116665f, 0.00923298f, -0.08312009f, 0.00714088f, 
    -0.06620807f, -0.02579619f, -0.09084969f, -0.03942399f, 0.16965108f, 0.11680037f, -0.03539583f, 0.01350723f, 
    0.04288446f, 0.00872739f, -0.06787020f, -0.11021800f, -0.08907985f, 0.04976920f, -0.08828475f, -0.02547991f, 
    -0.17603694f, 0.11132265f, -0.01342405f, 0.09037634f, -0.11872711f, -0.17594707f, 0.02734284f, 0.06051618f, 
    0.05006530f, -0.06675206f, 0.00553049f, 0.04820085f, -0.08329900f, -0.01133054f, 0.07970241f, 0.17801559f, 
    -0.12124514f, 0.02442388f, 0.01090837f, -0.00722267f, 0.00825035f, 0.10995697f, 0.01982049f, 0.00345812f, 
    -0.06768695f, 0.12424174f, 0.07245723f, -0.14813356f, 0.05479618f, -0.04017477f, -0.03838041f, -0.10355559f, 
    -0.01855772f, -0.14272773f, 0.09392373f, -0.01686602f, 0.00901440f, -0.23758464f, 0.08694645f, -0.06959807f, 
    -0.06951668f, -0.04687963f, 0.02470396f, -0.03619863f, 0.13616179f, 0.00738939f, -0.05502314f, -0.09280928f, 
    0.18291493f, 0.26782614f, 0.01311743f, 0.18142582f, -0.08104721f, 0.05068245f, 0.00262204f, -0.06762114f, 
    -0.05161500f, -0.07149506f, 0.01215651f, 0.04881243f, -0.03074163f, -0.06123685f, -0.03408010f, -0.12182274f, 
    -0.06043484f, -0.00553007f, -0.12216397f, -0.10583903f, 0.11042313f, -0.02104859f, -0.04926697f, 0.05761700f, 
    -0.03084295f, 0.33917525f, -0.15609850f, -0.00235092f, -0.12758918f, 0.02033007f, 0.14385389f, 0.11004397f, 
    -0.12953831f, -0.06595802f, 0.03004874f, 0.00062849f, -0.10891034f, -0.03965122f, 0.03469147f, -0.05750676f, 
    0.08346468f, -0.01008947f, -0.07776366f, 0.08673438f, -0.14898801f, 0.03179655f, 0.01647775f, 0.07254517f, 
    0.08525871f, 0.08360187f, -0.16877966f, -0.17542095f, 0.06567883f, -0.01334346f, 0.02522194f, -0.07247209f, 
    0.01823724f, -0.04885510f, 0.06716746f, -0.15970482f, 0.00414177f, 0.00304503f, 0.22707601f, -0.02757746f, 
    0.02183278f, 0.01254437f, -0.00794782f, 0.08432376f, 0.09556545f, -0.00405916f, -0.04802512f, 0.01584279f, 
    0.24141543f, -0.20359977f, -0.00944603f, 0.06505104f, 0.04696784f, 0.06114137f, -0.00070018f, 0.04222276f, 
    -0.03052392f, -0.05449616f, -0.04920388f, -0.02441563f, -0.12675579f, 0.04501895f, -0.13917968f, -0.09213524f, 
    0.02525986f, -0.13271353f, -0.01224234f, 0.17109162f, -0.02183360f, -0.13747844f, 0.04329622f, -0.05929221f, 
    -0.04104917f, -0.02898347f, 0.13291411f, 0.22627936f, -0.03975838f, -0.10027426f, 0.10903346f, 0.11818922f, 
    -0.06594826f, 0.17359252f, 0.05234025f, 0.12349358f, -0.07281350f, 0.05864724f, 0.05732213f, -0.06916216f, 
    0.02543511f, 0.09851599f, 0.07792747f, -0.03698340f, -0.04197685f, -0.03579126f, -0.02254022f, -0.09894212f, 
    -0.10094255f, -0.04905613f, 0.02403354f, 0.08324654f, 0.06188146f, 0.03057053f, 0.06218714f, 0.05194335f, 
    -0.07497905f, 0.03155631f, -0.00061319f, 0.04596477f, 0.25880796f, -0.11421774f, -0.13422234f, 0.08148274f, 
    -0.12275836f, -0.00078738f, -0.02069676f, 0.02901435f, -0.00190730f, -0.01740992f, -0.07992415f, 0.06773343f, 
    -0.08859325f, 0.26381901f, -0.30357885f, -0.03781082f, 0.06138112f, -0.03046819f, 0.04451638f, 0.06671906f, 
    0.00449945f, 0.01431773f, -0.00772542f, -0.06293202f, 0.03635345f, 0.13653684f, 0.10830633f, 0.03924862f, 
    -0.00091364f, -0.04994036f, -0.01997460f, 0.00582758f, 0.08554117f, 0.04330338f, 0.05305311f, -0.09554612f, 
    0.22184516f, 0.06155430f, 0.08309785f, -0.12691082f, -0.08884837f, 0.06864217f, 0.03645550f, 0.15215127f, 
    0.04952193f, -0.07802445f, -0.05403143f, 0.12620521f, -0.12639682f, -0.21632354f, 0.10792902f, -0.01836409f, 
    -0.06708354f, 0.10163143f, -0.00304737f, -0.14154583f, 0.07154971f, -0.06944463f, 0.10514797f, -0.05441191f, 
    -0.14200102f, -0.15403710f, 0.12201153f, 0.18473019f, -0.05692165f, -0.01027778f, -0.05969325f, 0.04720882f, 
    0.09765154f, -0.11752845f, -0.07702006f, -0.09061532f, -0.28658524f, -0.11614866f, 0.19114247f, -0.10552656f, 
    0.04044948f, -0.07651683f, 0.05931288f, -0.09873617f, 0.06783127f, -0.02870003f, -0.02029437f, -0.08892102f, 
    0.00366071f, -0.02890566f, -0.07455754f, -0.06402653f, 0.03026015f, 0.09179612f, 0.08231782f, 0.07455620f, 
    0.05390400f, 0.05255575f, -0.02681229f, 0.01586243f, -0.08298536f, 0.07275417f, -0.03236634f, -0.09902086f, 
    -0.01153587f, 0.06386527f, -0.06466249f, -0.11712714f, 0.07320996f, -0.14692570f, -0.00549071f, -0.04131756f, 
    -0.09406438f, -0.00666169f, 0.29241946f, 0.09519252f, 0.05401594f, 0.01972769f, -0.03702343f, 0.14055146f, 
    0.15343700f, -0.01676495f, -0.03927672f, -0.00194236f, -0.60297829f, -0.01549789f, 0.12933099f, 0.05567316f, 
    -0.01056420f, 0.06651216f, -0.02757283f, -0.03487645f, -0.00657208f, 0.05398495f, 0.04403421f, 0.11379873f, 
    -0.24074328f, 0.13140066f, 0.11044139f, 0.04353398f, -0.04379654f, -0.00980548f, -0.07235549f, 0.03737530f, 
    -0.16210325f, -0.06809822f, 0.07375197f, 0.10533251f, 0.13489921f, -0.02537837f, 0.08221537f, 0.17619215f, 
    -0.04825402f, 0.11458872f, 0.03776884f, 0.04011757f, 0.06525450f, -0.03653176f, 0.03723181f, -0.08443600f, 
    -0.07730236f, 0.10784389f, -0.02145775f, 0.04617553f, 0.08903207f, -0.07545295f, 0.04350730f, 0.13613205f, 
    0.02119070f, -0.05946158f, -0.02075025f, 0.13413052f, -0.36788800f, -0.01756996f, 0.06778552f, 0.34955496f, 
    0.03280434f, -0.10796866f, 0.08606426f, -0.03761800f, -0.07368954f, 0.06800120f, 0.07308165f, 0.00532193f, 
    -0.44664535f, -0.18495438f, -0.00436973f, 0.17724854f, 0.13685435f, -0.01361483f, -0.00100591f, 0.01290027f, 
    0.03949502f, -0.02453169f, 0.00563614f, -0.01173556f, 0.00934865f, -0.00877836f, 0.03850809f, 0.04888964f, 
    0.01468638f, 0.06957412f, 0.07146449f, 0.06794486f, 0.05710650f, 0.09163289f, -0.07364025f, -0.04359548f, 
    -0.12802319f, -0.10592256f, -0.12403318f, -0.13590704f, 0.02488599f, 0.01400628f, 0.01092588f, -0.02509705f, 
    -0.05816112f, -0.09668504f, -0.02141832f, 0.01082033f, -0.35880184f, -0.15785594f, 0.11102715f, -0.14380923f, 
    0.02688628f, 0.06296689f, -0.02462560f, 0.13896422f, 0.07498183f, -0.09011795f, 0.00953009f, 0.10296551f, 
    -0.08921493f, 0.00581958f, 0.13047619f, 0.09197214f, -0.15911222f, -0.01798227f, -0.00725515f, -0.04393518f, 
    -0.01924497f, -0.03493261f, 0.06706543f, -0.08962055f, 0.14545920f, -0.02403575f, -0.02630844f, -0.35231343f, 
    0.01056398f, 0.01015075f, -0.12839566f, -0.00867742f, -0.09462968f, -0.09514407f, -0.08748872f, -0.04921285f, 
    -0.21221073f, -0.25731692f, 0.19533499f, -0.00252722f, 0.04777035f, -0.02235418f, -0.08879755f, -0.04367733f, 
    0.00674687f, 0.00431054f, -0.02462307f, 0.04016785f, 0.05488127f, 0.18515287f, 0.00808873f, 0.02666077f, 
    -0.03941451f, 0.05415260f, 0.01186716f, -0.04882159f, -0.05558378f, -0.04304552f, 0.01610522f, 0.04863407f, 
    0.16175389f, -0.14329089f, -0.04512747f, -0.00267766f, -0.00785573f, 0.07698779f, -0.13943326f, -0.01138996f, 
    -0.10774416f, 0.05630172f, -0.06362232f, 0.06297852f, 0.05579595f, -0.12151470f, -0.08464327f, -0.02835316f, 
    -0.11128960f, 0.08475050f, 0.09663377f, -0.14184752f, -0.01134404f, 0.02549370f, -0.08076340f, -0.08639423f, 
    0.19265594f, 0.00472299f, -0.05788267f, 0.00842687f, -0.06843071f, 0.05975287f, 0.06078837f, -0.02749007f, 
    -0.11989919f, -0.04015843f, 0.06004146f, 0.09809764f, 0.18736792f, -0.01016460f, -0.04374523f, 0.08977047f, 
    0.00374153f, -0.01270643f, 0.08183128f, -0.08719876f, -0.00860257f, 0.00117589f, 0.03107287f, -0.05029521f, 
    -0.13940878f, 0.11618000f, 0.12219986f, 0.02700543f, 0.01494010f, 0.11881828f, -0.01438616f, 0.04840278f, 
    0.05939402f, 0.04503184f, -0.08637654f, -0.05356522f, -0.23097335f, 0.08035023f, 0.16450338f, 0.13683036f, 
    0.07307228f, -0.08818597f, -0.06042643f, 0.08476974f, -0.03980642f, 0.03120268f, -0.02904839f, 0.10187963f, 
    0.37903169f, 0.48826015f, -0.25421259f, -0.21522255f, 0.00186074f, 0.03063589f, 0.00946872f, -0.09456623f, 
    0.06839080f, 0.03791742f, -0.06531560f, 0.04667234f, -0.34913528f, -0.17586020f, 0.12364478f, -0.00455299f, 
    0.01471420f, -0.08825620f, 0.16277872f, -0.12624039f, -0.03322206f, 0.09891517f, -0.05268448f, 0.00163477f, 
    -0.04255582f, 0.09324439f, -0.06979842f, 0.05527078f, -0.09356013f, 0.02452615f, -0.14767589f, 0.07153866f, 
    0.02793271f, -0.01256792f, -0.01267910f, 0.03138649f, -0.18993349f, 0.04727869f, -0.23044391f, -0.38892698f, 
    0.06740887f, -0.09177224f, 0.13746315f, -0.02001773f, 0.06389182f, -0.04468883f, -0.00856628f, 0.05204257f, 
    -0.13862476f, 0.08033369f, 0.01949788f, 0.09995137f, 0.03533215f, -0.10967214f, 0.04584993f, 0.07300963f, 
    -0.01933986f, -0.04415328f, -0.02687989f, -0.01255062f, 0.23467351f, -0.06881597f, 0.09162883f, 0.01361599f, 
    -0.04784035f, -0.05819827f, 0.07765082f, 0.11551894f, -0.01397657f, 0.13495314f, -0.12690283f, 0.02654636f, 
    -0.07310718f, -0.09538832f, 0.03370372f, -0.29653382f, 0.02191881f, 0.00577065f, 0.00265688f, 0.02228172f, 
    0.01279767f, -0.14973053f, -0.09016758f, 0.03682462f, -0.15505093f, 0.11812030f, -0.11952692f, -0.10891587f, 
    -0.07377253f, 0.01555232f, 0.04926926f, 0.18222688f, 0.06065720f, -0.03440324f, -0.06572579f, 0.01455602f, 
    0.24830396f, 0.01798993f, -0.05704708f, 0.02512122f, -0.05546593f, -0.10242679f, 0.04881737f, 0.00104002f, 
    -0.02562409f, 0.03148821f, 0.02255052f, -0.09960028f, -0.33060190f, 0.04820507f, 0.00932600f, 0.17255406f, 
    -0.01563489f, 0.01630431f, 0.09921218f, -0.03859642f, 0.08949143f, 0.01424329f, 0.01041114f, 0.01924201f, 
    -0.10865629f, -0.11531529f, 0.05848383f, 0.05421592f, -0.14620239f, 0.07139824f, -0.04606500f, 0.08307141f, 
    -0.01091088f, 0.05024860f, 0.00588678f, -0.01673865f, -0.09840719f, -0.03965488f, -0.00186623f, 0.01130676f, 
    -0.10471607f, -0.00823119f, 0.09671430f, 0.14829706f, -0.06407956f, -0.03168361f, 0.05654423f, 0.03669057f, 
    0.16571361f, 0.03637477f, 0.01960334f, 0.13474287f, -0.06509712f, 0.09063162f, 0.02195332f, -0.00616241f, 
    -0.10073262f, -0.16254583f, -0.03274786f, 0.02646623f, -0.01582239f, 0.16202755f, -0.08324352f, 0.03253723f, 
    -0.01012538f, -0.02019588f, 0.04618782f, 0.05334537f, 0.07900199f, -0.10917561f, 0.16635774f, 0.01167447f, 
    -0.11108758f, 0.01073331f, 0.18114392f, -0.02511827f, -0.13359031f, -0.19752526f, -0.03028035f, -0.12826309f, 
    0.13241830f, -0.11038945f, 0.07912288f, 0.07526325f, -0.10842367f, -0.10868447f, 0.12231614f, 0.03792248f, 
    -0.02291474f, -0.01569363f, 0.03473999f, -0.02212427f, 0.05090925f, -0.01217806f, -0.02061213f, -0.01507314f, 
    -0.10878756f, 0.01284325f, 0.33996344f, 0.16314900f, 0.28135037f, -0.00826978f, -0.03143914f, -0.02532832f, 
    -0.09726555f, -0.12565790f, -0.00847581f, -0.00310073f, 0.00160149f, -0.12631966f, 0.03272672f, -0.01125939f, 
    0.11818189f, 0.11119708f, -0.03435342f, -0.09901325f, 0.10098444f, -0.06548746f, -0.02146669f, -0.05964843f, 
    -0.03236791f, -0.00842932f, 0.12006228f, -0.20636967f, 0.00117219f, -0.00365394f, -0.00092948f, -0.02113788f, 
    -0.02585716f, -0.23786186f, 0.07940590f, -0.08116024f, -0.20144875f, -0.01280847f, 0.10538453f, -0.08570354f, 
    -0.03044100f, -0.01699958f, 0.09635409f, -0.06768450f, -0.01413121f, -0.15184952f, 0.07663420f, 0.04762581f, 
    -0.28869042f, 0.03227009f, 0.02839041f, -0.03393493f, 0.08798436f, -0.00760546f, -0.04324898f, -0.03952712f, 
    0.13215190f, 0.11266960f, 0.09932084f, 0.13509190f, 0.06526858f, 0.12860899f, 0.01483983f, 0.07848961f, 
    -0.02258495f, 0.00122640f, -0.01473602f, -0.00931995f, -0.03379415f, -0.07977086f, -0.02744013f, 0.13508916f, 
    0.02737029f, -0.11835619f, 0.04372111f, -0.15034649f, -0.11028813f, 0.06798981f, 0.06346795f, -0.00173526f, 
    -0.02652790f, -0.04607946f, -0.10654537f, 0.04049506f, 0.08997820f, 0.04319273f, -0.00110413f, -0.03837828f, 
    -0.06902742f, -0.00459245f, 0.06862454f, 0.02620954f, 0.01763792f, 0.04419759f, 0.05198867f, 0.05301921f, 
    -0.08243161f, -0.04669001f, -0.08964540f, 0.00366328f, -0.09262764f, -0.09526064f, -0.01334829f, -0.10757960f, 
    -0.05188348f, 0.02461615f, -0.04497022f, -0.02421064f, 0.11009492f, 0.00381736f, -0.04877476f, 0.08494768f, 
    0.09008512f, 0.01823847f, 0.09765674f, 0.05842907f, -0.00103966f, -0.01460707f, 0.04377062f, 0.06393951f, 
    -0.14483367f, -0.13317035f, 0.16051513f, 0.07404371f, 0.01329519f, -0.11628269f, -0.07206069f, -0.06904428f, 
    0.05497516f, 0.08204415f, -0.04373729f, -0.01526730f, 0.18322666f, 0.09540396f, -0.08519371f, 0.07033285f, 
    0.04827770f, -0.01771704f, 0.05760441f, -0.20103423f, 0.09047449f, -0.02182783f, -0.07309796f, 0.08045246f, 
    -0.28871176f, -0.21898375f, 0.10558819f, 0.11539820f, 0.03868848f, -0.05673051f, -0.02603126f, 0.09823672f, 
    0.08202352f, 0.14398560f, -0.18661694f, 0.07319485f, -0.10081822f, -0.00692911f, -0.11396979f, 0.05808625f, 
    0.06534296f, 0.04827175f, -0.00530655f, 0.06489713f, -0.05464315f, -0.08634634f, 0.11439972f, -0.03768821f, 
    -0.14764197f, 0.09773719f, -0.02507500f, 0.12335961f, -0.07043454f, -0.01653030f, 0.04822480f, -0.12518582f, 
    0.00843120f, -0.16294454f, 0.05934395f, 0.08761941f, -0.13934845f, 0.16247292f, -0.09513013f, 0.04551745f, 
    -0.02544603f, 0.17365597f, 0.05109752f, -0.01766810f, -0.11329295f, 0.01549312f, 0.01591878f, 0.07990316f, 
    -0.00224958f, -0.10776971f, -0.04867897f, -0.05833627f, 0.08670522f, -0.01448766f, -0.22141707f, -0.17536455f, 
    -0.01406146f, -0.09457111f, 0.06945653f, -0.18570618f, -0.02834240f, -0.00628016f, 0.10318302f, 0.03043490f, 
    -0.14739093f, -0.05592030f, -0.05211138f, 0.05464597f, 0.00945509f, 0.12233512f, 0.02697438f, 0.12060278f, 
    0.18893528f, 0.14361553f, 0.02969825f, -0.08699120f, 0.06786130f, -0.12883404f, 0.01614488f, 0.00312493f, 
    0.02498395f, 0.05660490f, -0.20922624f, -0.08004952f, 0.05753374f, -0.02018837f, 0.08781607f, 0.10877254f, 
    0.08340041f, -0.03161183f, -0.06439628f, -0.07493601f, -0.06018500f, -0.17932592f, -0.05319225f, -0.08970129f, 
    -0.23770261f, 0.27762419f, 0.23324224f, -0.11361685f, 0.05459828f, -0.07932723f, 0.00133058f, -0.09191385f, 
    0.14404878f, 0.00280836f, 0.05574426f, 0.09116778f, -0.10691163f, -0.03402552f, 0.20128039f, -0.15155758f, 
    -0.03517514f, -0.01774209f, 0.05139758f, 0.02520204f, 0.10841454f, 0.08503638f, 0.03045078f, -0.02434110f, 
    -0.17660436f, -0.02864433f, -0.13359037f, -0.04186122f, 0.15613563f, -0.07109838f, 0.00067282f, -0.01745578f, 
    0.03113649f, -0.03991668f, -0.08115201f, 0.00602784f, 0.16395049f, 0.01224319f, -0.01103218f, 0.06997574f, 
    -0.07709238f, -0.08771507f, -0.07238959f, 0.00790439f, -0.02960720f, -0.02300593f, 0.00413676f, -0.19572511f, 
    0.19025783f, -0.04125915f, -0.04826171f, -0.09112908f, 0.04112826f, -0.01137841f, 0.05429512f, 0.01239072f, 
    -0.14475390f, 0.01727209f, 0.02394409f, 0.28374535f, -0.00755831f, 0.07007795f, -0.02810965f, 0.10536788f, 
    -0.08523568f, 0.04497955f, -0.02922323f, 0.11309512f, 0.01726977f, 0.02771727f, 0.03251878f, 0.04939435f, 
    0.03667077f, 0.08921155f, 0.16409649f, -0.08642579f, 0.02776407f, -0.05617456f, -0.07120969f, 0.07058237f, 
    0.02280783f, 0.02200273f, 0.00680388f, -0.07170542f, -0.10616332f, -0.03289557f, -0.07767196f, -0.18791015f, 
    0.04643918f, -0.06736117f, 0.02813064f, 0.02798237f, 0.07814483f, 0.16171637f, 0.04021758f, -0.00886266f, 
    -0.23571208f, -0.09203628f, -0.18676475f, 0.10391184f, 0.08432158f, -0.01911648f, 0.05196987f, -0.04380293f, 
    0.06847951f, 0.07414592f, 0.13195492f, 0.06916147f, -0.29068491f, 0.07088124f, -0.24562518f, -0.11677232f, 
    0.11558674f, -0.04924644f, 0.02272770f, 0.08786338f, -0.09593114f, 0.01330926f, -0.03572091f, -0.13822588f, 
    -0.03286032f, -0.01482497f, 0.18723220f, 0.28311265f, -0.25369093f, 0.00071870f, 0.11039671f, 0.05338065f, 
    -0.02710987f, 0.03768589f, -0.12076669f, -0.01323645f, -0.14071769f, -0.07116881f, -0.08433046f, -0.10729045f, 
    0.14516962f, 0.10207977f, 0.00037974f, -0.27424330f, -0.10089413f, 0.17285554f, -0.04101768f, 0.06753831f, 
    -0.24446741f, -0.09352127f, 0.05858853f, -0.06723592f, 0.07540370f, 0.13142590f, 0.12026590f, 0.07771834f, 
    0.15002973f, 0.09252512f, -0.13249449f, -0.04631594f, 0.03654852f, -0.12332895f, -0.33232048f, -0.15500671f, 
    0.10239734f, 0.10838639f, -0.07190849f, -0.03226651f, 0.04962704f, -0.16595212f, 0.01136014f, -0.02541396f, 
    -0.41130689f, -0.05523955f, -0.28580725f, -0.08968934f, 0.08412310f, 0.19503038f, 0.10687499f, -0.07540940f, 
    0.09593325f, -0.01175171f, 0.03270586f, -0.04828875f, -0.06136625f, -0.04813661f, 0.23263851f, 0.14232768f, 
    0.06623510f, -0.09915996f, -0.02324126f, 0.09338058f, 0.12216584f, 0.02719238f, -0.19395380f, 0.01106497f, 
    -0.09224351f, -0.01837354f, -0.03155119f, -0.06912067f, 0.02555417f, -0.06136352f, 0.00858379f, 0.03698425f, 
    -0.02066245f, 0.00575236f, 0.07312997f, -0.00528140f, 0.14511162f, -0.01278357f, -0.10250819f, -0.05830581f, 
    0.07325216f, 0.01900806f, -0.06951939f, 0.05297469f, -0.04413534f, -0.09046099f, 0.04550498f, -0.14608607f, 
    0.07501459f, 0.07120924f, 0.04473283f, 0.27815649f, 0.03960348f, -0.00893276f, -0.04174594f, -0.09011699f, 
    -0.10552918f, -0.18175751f, -0.02140430f, 0.20888174f, -0.08102891f, -0.25561491f, -0.05770176f, 0.30361596f, 
    -0.01973565f, -0.07550864f, 0.14043482f, 0.03495325f, 0.07019542f, 0.10908548f, -0.03719521f, -0.11856925f, 
    0.17105040f, 0.09008466f, -0.05729920f, 0.18309380f, -0.04145646f, -0.05505485f, 0.05111837f, 0.08889472f, 
    -0.00657227f, 0.10648575f, 0.04239440f, 0.17321496f, -0.00741295f, 0.14311504f, -0.03015366f, 0.10221132f, 
    -0.02767803f, -0.07962508f, -0.06888422f, 0.14001735f, 0.05038786f, 0.05252464f, 0.16532271f, -0.03899484f, 
    0.10364306f, -0.08285422f, -0.01970172f, -0.05984858f, -0.09147384f, -0.10339221f, 0.03716322f, -0.03039416f, 
    0.01118206f, 0.04903884f, -0.03990269f, -0.13727529f, 0.06717461f, 0.00374776f, 0.00960902f, -0.00386625f, 
    -0.10631625f, -0.10548901f, -0.08050557f, -0.18113664f, 0.07018065f, 0.01138228f, -0.20272492f, -0.09907725f, 
    -0.03107848f, -0.17678435f, -0.15163089f, 0.13508831f, 0.13008884f, -0.22292021f, -0.04651187f, -0.01121874f, 
    0.03150341f, 0.10708632f, -0.05613280f, 0.13327035f, 0.09325905f, -0.02531677f, 0.01747561f, -0.46827099f, 
    0.00246840f, -0.13522364f, -0.12430586f, 0.06792196f, 0.03820919f, 0.03037543f, 0.03255730f, 0.02186221f, 
    0.04241781f, -0.01389497f, 0.01557178f, -0.06938553f, 0.01802392f, -0.10020758f, 0.00853308f, -0.06914592f, 
    -0.12031538f, 0.01551698f, 0.12311269f, 0.17696819f, -0.00833811f, 0.05349387f, -0.28875592f, -0.06106164f, 
    0.07830772f, -0.01239204f, 0.03454803f, 0.04562769f, 0.01679432f, 0.05355994f, 0.10376883f, -0.07931919f, 
    -0.04518171f, -0.24105483f, 0.21541630f, 0.22915141f, -0.10084245f, -0.12281305f, 0.03235062f, 0.13887733f, 
    0.03867211f, -0.04707873f, -0.18083656f, -0.08658901f, -0.29667056f, 0.12184329f, 0.01593553f, -0.03003648f, 
    -0.02121730f, 0.04399741f, 0.03615627f, -0.05429314f, 0.13800226f, -0.04553515f, 0.03196977f, 0.02758581f, 
    0.01372196f, 0.01233073f, 0.05931336f, 0.13752437f, -0.01849992f, -0.02150494f, -0.02113609f, 0.08780658f, 
    0.21287078f, -0.17731091f, 0.06591143f, 0.12707025f, -0.57079101f, -0.03066269f, 0.37083298f, -0.17879088f, 
    -0.00211981f, 0.08611202f, 0.07001042f, -0.15142117f, 0.04880097f, -0.03410606f, -0.03330541f, 0.07133065f, 
    0.04237067f, 0.05065813f, -0.01053180f, -0.11965463f, -0.21018596f, 0.01438551f, 0.00759243f, -0.09537440f, 
    0.16845629f, -0.06621154f, -0.09456646f, 0.07714841f, 0.11535779f, -0.05789405f, -0.09833339f, 0.21768613f, 
    0.10048846f, 0.08813624f, 0.04191213f, -0.04468354f, -0.03727966f, -0.21768665f, 0.09623066f, -0.09403539f, 
    -0.47139227f, -0.14653757f, 0.08867081f, 0.03209268f, 0.02950912f, -0.01266257f, 0.10524026f, 0.11450730f, 
    -0.04230205f, 0.15299037f, 0.06214647f, -0.14640458f, -0.53230780f, 0.13216624f, 0.05289527f, -0.05884349f, 
    0.10430717f, -0.11979192f, 0.01755402f, -0.00057670f, 0.04051926f, 0.03698205f, -0.00031130f, -0.07400396f, 
    0.01114350f, 0.08268629f, 0.22763832f, -0.27444062f, 0.01858774f, 0.10881878f, -0.01112055f, -0.00569613f, 
    -0.03265590f, -0.00306893f, 0.04374688f, -0.01286956f, -0.15556110f, -0.03727682f, -0.19118401f, -0.16414472f, 
    0.12640466f, 0.07861587f, -0.08393687f, -0.21732242f, -0.08361516f, -0.02642069f, 0.11200471f, -0.18732882f, 
    0.05902407f, 0.07881120f, -0.02280590f, 0.06892977f, -0.03736988f, 0.01455021f, 0.01142582f, 0.04037583f, 
    -0.00150006f, 0.01675862f, 0.06030076f, 0.17419535f, 0.18278992f, -0.15045910f, 0.01454747f, -0.06750281f, 
    0.00523641f, 0.00796121f, -0.00068444f, -0.05620760f, -0.04824032f, -0.03529721f, -0.18740450f, -0.02515901f, 
    0.02407445f, 0.13695526f, 0.10558409f, -0.14392111f, 0.04690815f, -0.08708010f, 0.03847420f, 0.03030382f, 
    0.10823054f, 0.12009828f, -0.09562045f, -0.01885082f, -0.01391984f, 0.00417779f, -0.05567091f, 0.13990000f, 
    0.06459635f, 0.04213691f, -0.04397132f, 0.08980479f, -0.05515543f, -0.05424887f, -0.17992795f, -0.13967730f, 
    -0.03431521f, 0.14605087f, 0.01244708f, 0.25386584f, -0.08230335f, 0.05214631f, 0.16461527f, 0.05028730f, 
    0.00499005f, 0.00419105f, -0.04981169f, -0.04445719f, 0.02338116f, 0.09536939f, -0.04139991f, -0.15089700f, 
    -0.02339284f, 0.02942701f, -0.01306084f, 0.13401452f, -0.05460892f, 0.04643335f, 0.05097001f, 0.04132733f, 
    -0.18175329f, -0.06006424f, -0.20066302f, 0.03436034f, -0.26996729f, 0.01244269f, 0.10784307f, -0.03697802f, 
    0.06648175f, 0.05890499f, -0.04598491f, 0.10338947f, -0.03841211f, -0.16282789f, -0.10787217f, -0.07044948f, 
    -0.02015395f, -0.02042020f, 0.10650444f, -0.12962484f, -0.02628309f, 0.05887965f, -0.07376353f, -0.00940620f, 
    0.45390004f, 0.09798457f, 0.03261458f, -0.03131927f, -0.11998489f, 0.01888605f, -0.08086361f, -0.01633570f, 
    0.05821066f, 0.01880738f, -0.04222509f, 0.01700868f, 0.04601469f, -0.07244059f, 0.07057527f, -0.08301021f, 
    -0.03585177f, 0.07744952f, -0.10831593f, -0.00686811f, -0.00834741f, 0.10213179f, -0.05787290f, 0.05444490f, 
    0.18734272f, -0.29637966f, -0.13430810f, -0.23775935f, -0.06132109f, -0.05311609f, 0.04444622f, 0.04223112f, 
    0.00540239f, -0.05251289f, -0.08234344f, -0.22314925f, -0.09857238f, 0.14581691f, 0.05502284f, -0.17783335f, 
    0.00627812f, -0.00711561f, -0.01625606f, 0.01798086f, -0.00398181f, 0.06682481f, 0.03541177f, -0.01181931f, 
    -0.01302778f, 0.00254574f, 0.03951934f, 0.01072002f, -0.16213526f, -0.04812747f, -0.02404148f, -0.00129801f, 
    0.17153287f, -0.11461507f, 0.03325945f, 0.07925421f, -0.52909297f, 0.03417608f, -0.10092814f, 0.34423012f, 
    -0.00825084f, 0.04019267f, -0.06677073f, 0.00634471f, 0.00044955f, -0.09468926f, -0.01529197f, -0.25012952f, 
    -0.20583694f, 0.12113537f, 0.05562776f, -0.19595046f, 0.08322808f, 0.08185383f, 0.01555591f, -0.00571547f, 
    0.06605356f, -0.02449218f, 0.03714342f, 0.01478730f, -0.08007647f, 0.21397482f, -0.01517558f, 0.23741698f, 
    0.00887987f, -0.10272907f, -0.00058527f, -0.02587933f, 0.05861467f, 0.06574328f, 0.09534542f, -0.19907109f, 
    0.06542203f, -0.28048363f, -0.13544589f, 0.28528988f, -0.02316503f, 0.05616159f, 0.03162074f, -0.03414046f, 
    0.13076071f, -0.11185463f, -0.10370247f, 0.01834378f, -0.10756700f, -0.02780436f, 0.10590042f, 0.12240970f, 
    -0.01254911f, 0.05724327f, -0.00252817f, 0.02556809f, -0.05178591f, 0.08766394f, 0.09347560f, 0.04187735f, 
    -0.25111595f, -0.06844652f, -0.12722059f, 0.20356870f, 0.05348214f, -0.09405185f, 0.05294893f, -0.02127802f, 
    -0.04391780f, -0.06380135f, 0.15143079f, -0.04039784f, -0.19555782f, 0.00322904f, -0.10953861f, -0.12394448f, 
    -0.00773964f, -0.02095224f, 0.06104408f, -0.05728445f, 0.02759205f, 0.06176379f, 0.00202547f, 0.04412182f, 
    0.18894088f, -0.11614101f, -0.11249816f, 0.20619684f, -0.03072486f, 0.03914022f, -0.02773219f, 0.09123214f, 
    -0.12499510f, 0.03148615f, -0.00835678f, -0.15141204f, 0.03541809f, 0.04770241f, -0.00971754f, -0.11509601f, 
    -0.13280870f, -0.11009655f, 0.02443947f, -0.15145887f, 0.16130885f, -0.01505002f, 0.07916499f, -0.05311859f, 
    0.00515037f, -0.04918853f, -0.17352070f, 0.05893384f, -0.10714518f, 0.05388469f, 0.11247677f, 0.01697946f, 
    0.01631411f, 0.12550263f, -0.07294636f, 0.07920254f, 0.17898250f, -0.00912746f, 0.13947992f, -0.17978027f, 
    0.13801035f, -0.14038046f, 0.01085322f, 0.04863284f, 0.04758622f, 0.06105757f, -0.08353848f, 0.01086336f, 
    -0.06948381f, -0.06181402f, 0.18001461f, -0.15521403f, -0.01276502f, -0.00862458f, 0.08743006f, 0.11075044f, 
    0.02227619f, 0.05609013f, 0.18478817f, -0.04929250f, -0.26546147f, 0.17684840f, -0.02114527f, 0.08714151f, 
    -0.02432084f, 0.09020453f, 0.04619806f, 0.03282220f, -0.09323939f, 0.14526953f, 0.00566694f, 0.04668368f, 
    0.22505654f, -0.21348055f, 0.18869494f, -0.18170966f, 0.01177737f, 0.03472891f, -0.03848825f, 0.04033662f, 
    -0.05362711f, -0.00471093f, -0.14902967f, -0.03720635f, -0.02558411f, 0.20696414f, 0.17039227f, -0.22935885f, 
    0.02421197f, 0.00462128f, -0.02710841f, -0.00483896f, -0.19065994f, -0.08133687f, 0.03805695f, 0.03651234f, 
    -0.02822838f, 0.11115468f, -0.13588507f, 0.22764896f, -0.10375079f, 0.06708971f, -0.01596473f, 0.01656054f, 
    -0.11489824f, 0.02830069f, 0.04468109f, 0.01619008f, -0.11577223f, 0.06579348f, -0.10783146f, 0.05233063f, 
    0.10067198f, 0.06373248f, 0.00782611f, 0.04722491f, -0.05912016f, 0.02930170f, -0.02261011f, 0.09202547f, 
    0.03027071f, 0.09916377f, 0.09380603f, 0.00027943f, -0.02616924f, 0.16766079f, 0.12313975f, -0.08398715f, 
    0.04598910f, -0.13537054f, -0.04500296f, -0.06841629f, -0.19583035f, -0.14665468f, -0.06395304f, 0.15538897f, 
    0.09626731f, 0.02412174f, 0.05159983f, 0.04650710f, -0.12463220f, 0.03936609f, -0.04596508f, -0.01734486f, 
    0.18491860f, 0.02271041f, 0.11910374f, -0.22503766f, -0.07907696f, -0.01502523f, 0.01142575f, 0.02394418f, 
    -0.06727461f, 0.05850210f, -0.02542738f, -0.02633463f, 0.10647869f, 0.00690153f, 0.02596775f, -0.19330761f, 
    0.04310063f, 0.11229011f, -0.03023325f, -0.00158568f, -0.11317567f, -0.03532783f, -0.05260387f, -0.08412682f, 
    -0.09083173f, 0.07545885f, -0.18783203f, -0.15785320f, 0.03885573f, -0.00835170f, -0.08568048f, -0.08609590f, 
    -0.17775747f, -0.00807074f, -0.13580447f, -0.07610449f, 0.06716078f, -0.28335014f, 0.01067795f, -0.11705708f, 
    0.09163874f, 0.00545054f, 0.00592754f, 0.01564519f, -0.04406839f, -0.00073127f, 0.12715597f, 0.19430633f, 
    -0.00840446f, 0.02051071f, -0.08230616f, -0.17959061f, 0.04268394f, -0.07521187f, 0.04749224f, 0.08841868f, 
    -0.13234481f, 0.04432762f, -0.01794942f, -0.05404064f, 0.04942545f, -0.04771749f, -0.15150058f, 0.10592549f, 
    -0.01151112f, -0.04785996f, -0.09015899f, 0.00537870f, 0.02526800f, -0.05728999f, 0.03324091f, 0.08237078f, 
    0.16180037f, 0.04453306f, -0.02482464f, -0.00255677f, 0.03411190f, -0.06557038f, -0.12163346f, -0.17501220f, 
    0.01834225f, -0.04383738f, 0.12434284f, 0.12350295f, -0.29754654f, -0.09755138f, -0.14962673f, -0.35056430f, 
    -0.05742313f, 0.00748647f, 0.03816750f, -0.03574980f, -0.05408517f, 0.05724335f, 0.11765123f, 0.09530144f, 
    0.12991056f, -0.11769100f, -0.04453544f, -0.22568268f, -0.14724208f, 0.10119564f, -0.02776344f, -0.07741553f, 
    -0.08156788f, 0.04721562f, -0.03894219f, 0.10105831f, 0.12316981f, -0.04168354f, -0.33999965f, 0.01093435f, 
    -0.06721728f, 0.03847979f, -0.23501724f, -0.08923239f, 0.06639849f, 0.00291624f, 0.04894376f, 0.02882940f, 
    0.17900890f, -0.30825767f, 0.10485053f, -0.08112674f, -0.02344558f, 0.01009831f, 0.09110139f, -0.00118570f, 
    0.10727593f, 0.01779816f, -0.01732999f, -0.14789480f, 0.01943245f, 0.15838821f, 0.17960709f, 0.08462915f, 
    -0.00221684f, 0.00261327f, -0.00947409f, 0.04151967f, 0.00570153f, 0.11461549f, 0.02725145f, 0.12189158f, 
    -0.03833251f, 0.02748946f, -0.02576615f, -0.25819764f, -0.08391933f, 0.08029378f, -0.02671681f, 0.01496847f, 
    0.06510803f, 0.07633085f, -0.10059532f, 0.00443376f, -0.11682785f, -0.10670031f, 0.01877328f, -0.08480599f, 
    0.16815336f, 0.04456933f, 0.04202828f, -0.02376688f, -0.08455025f, -0.04391193f, -0.02197181f, -0.02041829f, 
    0.08822713f, -0.09158500f, -0.11093837f, -0.14628828f, 0.15288602f, 0.09336573f, 0.00864128f, -0.03899745f, 
    -0.02451585f, -0.17368402f, -0.06463329f, -0.06245063f, 0.08448850f, -0.14601988f, -0.13412981f, 0.04109456f, 
    -0.00534496f, 0.06665069f, 0.03228738f, -0.04830503f, 0.06169626f, -0.08743529f, -0.00062830f, -0.01347172f, 
    -0.38028339f, 0.12958471f, 0.00616141f, 0.11253288f, 0.05820331f, -0.00640516f, -0.03385771f, 0.09968760f, 
    -0.05220278f, -0.03707897f, 0.05059095f, 0.09044615f, -0.11981861f, 0.09847900f, -0.00749905f, 0.27501041f, 
    0.13261281f, 0.02655034f, 0.06952611f, 0.08131970f, -0.03597360f, -0.04499958f, 0.18743268f, 0.02855707f, 
    -0.09102629f, 0.02289677f, -0.13637404f, 0.15907289f, 0.03321428f, 0.02789924f, -0.09220807f, -0.12587249f, 
    0.06919604f, 0.03511668f, 0.02717412f, -0.08982007f, -0.04453042f, 0.10468718f, 0.11179576f, -0.21620397f, 
    -0.14546113f, 0.16692860f, 0.19694397f, 0.06787212f, -0.16689314f, -0.06695578f, -0.02333654f, -0.02674337f, 
    0.18930234f, 0.16373286f, 0.12307622f, -0.13106012f, -0.09079937f, -0.02550311f, 0.05374267f, 0.07488102f, 
    0.01639291f, 0.05392807f, -0.05148520f, -0.14006652f, 0.07377577f, -0.16672647f, -0.18444405f, -0.00845726f, 
    -0.08612480f, 0.10569075f, -0.02482932f, -0.04053209f, 0.03568761f, 0.02558368f, -0.03457889f, -0.01971351f, 
    0.20729913f, -0.18668360f, 0.00320900f, -0.01523534f, 0.11384474f, 0.04929988f, -0.09631649f, 0.00182296f, 
    -0.08949817f, -0.00170140f, 0.04699532f, 0.11172782f, -0.02638661f, -0.22942173f, 0.01889274f, 0.21699400f, 
    0.05256771f, -0.04536333f, 0.12457895f, 0.01763393f, -0.04301063f, -0.04571444f, 0.01441676f, 0.05306790f, 
    0.09692430f, -0.09724594f, -0.08647539f, -0.05141397f, 0.03694352f, 0.06634931f, 0.01718689f, -0.11220107f, 
    -0.16745949f, -0.02761094f, -0.02312102f, -0.00977806f, 0.26331356f, -0.28935036f, 0.02715690f, 0.05305260f, 
    -0.06423520f, 0.00833518f, -0.05731581f, 0.09336079f, 0.02112261f, 0.06651798f, 0.01367004f, 0.00666182f, 
    -0.19832771f, -0.06358925f, -0.00501438f, 0.06260327f, -0.03642613f, 0.01728122f, 0.02180720f, 0.03032231f, 
    -0.07845657f, 0.10154794f, 0.05291611f, 0.04496195f, -0.15441185f, 0.02214191f, -0.09557573f, -0.13132237f, 
    -0.04877216f, -0.04587873f, -0.06961373f, -0.08363274f, -0.06190031f, 0.00153989f, -0.06049632f, -0.00131193f, 
    0.25033766f, 0.16512139f, 0.12977593f, -0.11252774f, -0.06788275f, 0.01080947f, -0.07486193f, -0.07775080f, 
    0.00258919f, -0.00229991f, 0.12334863f, -0.03059598f, 0.33570296f, -0.60043645f, 0.08806964f, -0.07191420f, 
    0.04301104f, 0.09843401f, 0.04982264f, -0.01007163f, 0.00960998f, 0.07543702f, 0.03386428f, -0.00217055f, 
    -0.08638586f, 0.10726807f, 0.17105322f, -0.30404860f, -0.19831666f, -0.02862239f, -0.15346627f, 0.02605358f, 
    0.05629053f, -0.08404151f, -0.06246423f, -0.06052178f, -0.19944519f, -0.36022079f, 0.03526282f, -0.10768365f, 
    -0.04696187f, -0.01540210f, -0.05409793f, 0.07664113f, 0.01513014f, -0.00252792f, -0.08087935f, 0.19064961f, 
    0.05033884f, 0.14233154f, 0.02744642f, -0.22696398f, -0.05358936f, -0.00505576f, -0.02154296f, 0.04885041f, 
    0.08867070f, -0.04786400f, -0.11574172f, 0.03552508f, -0.36631256f, 0.22688673f, 0.15140174f, 0.04553597f, 
    -0.19057043f, 0.11164709f, 0.00415945f, 0.01984765f, 0.01892962f, 0.04191551f, 0.13521291f, 0.00548091f, 
    0.09068102f, -0.14272116f, -0.03199430f, -0.13890931f, -0.04259399f, -0.03639537f, -0.03654442f, -0.02205006f, 
    -0.00501957f, 0.04040582f, 0.00718572f, -0.04283034f, -0.22010069f, 0.00389116f, -0.04374202f, 0.07277828f, 
    -0.07437373f, -0.09093616f, -0.10525603f, -0.03356480f, -0.01111662f, -0.01265393f, -0.06667385f, 0.01077875f, 
    0.12066444f, -0.03186442f, -0.21677116f, 0.00930898f, -0.08797831f, 0.03248448f, 0.05504038f, 0.00720102f, 
    -0.03690208f, -0.01695846f, 0.00183946f, -0.04891475f, -0.18467568f, 0.00413514f, -0.13219610f, -0.06453133f, 
    0.01116864f, -0.04571497f, -0.05157886f, -0.08514395f, -0.00323433f, -0.01060418f, -0.00895084f, -0.02999243f, 
    0.32035518f, 0.29717153f, 0.05269773f, 0.00492678f, 0.00263006f, -0.06495816f, 0.05514924f, 0.01195575f, 
    -0.00448053f, -0.00233008f, 0.02824041f, 0.09633473f, 0.15462427f, -0.01224127f, 0.08565231f, 0.06682723f, 
    0.12496601f, -0.04278174f, -0.02996299f, -0.02566849f, -0.04672105f, 0.01758721f, 0.01373145f, 0.01314551f, 
    0.31989384f, 0.04514353f, -0.17923109f, -0.13079314f, -0.12760806f, -0.01864932f, 0.00234036f, -0.02362341f, 
    -0.11575949f, -0.01989477f, -0.06667455f, -0.02635514f, -0.08106794f, 0.11807063f, 0.00105430f, -0.15145141f, 
    -0.15922497f, 0.02633566f, -0.08249526f, -0.04918839f, -0.02308992f, 0.00929033f, -0.05480178f, -0.07038543f, 
    -0.27197269f, 0.08328759f, -0.08541137f, -0.09946005f, -0.12998928f, 0.02564493f, -0.04917061f, -0.00737873f, 
    -0.02705275f, -0.03380053f, -0.06240726f, -0.11175787f, -0.29064569f, -0.11568712f, -0.14824627f, -0.04356823f, 
    -0.03258347f, -0.00887587f, -0.04931619f, -0.02927918f, -0.10789261f, 0.02887030f, 0.10186417f, 0.00087363f, 
    -0.33753806f, 0.13371360f, -0.14782088f, -0.13738996f, -0.08165554f, -0.04440980f, -0.04136284f, -0.11602093f, 
    -0.07815027f, 0.02238978f, 0.00703523f, -0.06542561f, -0.16064520f, 0.00801731f, -0.02246202f, -0.09434917f, 
    0.05624177f, 0.00851762f, -0.01844127f, -0.07114345f, 0.00453996f, -0.03850129f, 0.05615606f, -0.04809192f, 
    0.13046494f, 0.14075045f, -0.09564374f, 0.07887942f, -0.10712885f, -0.02131144f, 0.02559753f, -0.05354645f, 
    -0.06398697f, 0.00576827f, -0.04862344f, -0.08515656f, -0.07951410f, -0.06421784f, -0.18641187f, -0.16094707f, 
    0.06344813f, 0.03313334f, -0.06039822f, -0.02023635f, -0.09040645f, 0.05700509f, -0.00489428f, -0.00287738f, 
    0.20333607f, -0.27510548f, 0.10959344f, 0.10281654f, 0.00673135f, -0.01367037f, -0.00163340f, -0.09451360f, 
    -0.03684006f, -0.08374692f, -0.09105443f, 0.01137749f, -0.16360284f, 0.01518394f, -0.08363900f, -0.09432886f, 
    -0.06557323f, -0.04531533f, 0.01120223f, -0.05473562f, 0.01373524f, -0.02740151f, -0.06900117f, -0.08483419f, 
    0.08576467f, 0.00993817f, 0.18023559f, 0.12828852f, 0.09059271f, -0.02230908f, -0.02201656f, -0.00147139f, 
    -0.08440208f, -0.04342784f, 0.07254317f, -0.04071654f, 0.03241492f, 0.07968187f, 0.14969994f, 0.02296272f, 
    0.09566354f, 0.01912514f, 0.00407166f, -0.01517489f, 0.00595608f, -0.01257384f, -0.04047131f, -0.03939107f, 
    -0.00043578f, 0.15542017f, -0.01039132f, 0.13993688f, 0.01831260f, -0.10673469f, -0.00594126f, 0.01383866f, 
    0.00602918f, 0.09917825f, 0.04790468f, -0.02547667f, 0.13218030f, -0.00610191f, 0.05587665f, 0.00168479f, 
    -0.02750393f, 0.06912007f, -0.01842862f, -0.00753920f, -0.08563028f, 0.00518988f, 0.04836794f, -0.00233022f, 
    0.00816647f, 0.16721974f, -0.00009624f, 0.16333354f, 0.13328210f, -0.01408081f, 0.10553580f, 0.04416301f, 
    -0.03541067f, -0.00020231f, -0.00788357f, -0.05456883f, 0.16631575f, -0.40237620f, 0.10808776f, 0.01048952f, 
    -0.06647847f, 0.03367073f, -0.06107884f, -0.08533684f, 0.03056751f, 0.05605052f, 0.01327145f, -0.08400642f, 
    0.21204932f, 0.04002885f, -0.15946212f, -0.22326629f, -0.09223758f, 0.09260091f, -0.01616400f, -0.00465373f, 
    0.00623785f, -0.02610048f, 0.06078290f, -0.05273410f, -0.06234858f, 0.02047899f, -0.04153173f, -0.01416524f, 
    0.01391869f, 0.01114443f, -0.04766733f, -0.02358629f, -0.04342571f, 0.00870020f, 0.04357708f, -0.09904639f, 
    -0.04277049f, -0.12756360f, -0.06190995f, -0.08577848f, -0.01396964f, 0.01350746f, -0.00419939f, -0.12148031f, 
    -0.03290411f, 0.00415032f, -0.03332762f, -0.07092123f, -0.12627436f, -0.02023593f, -0.08780146f, -0.18584862f, 
    0.00562191f, 0.04033462f, -0.07503979f, -0.05071243f, -0.03560654f, -0.01761374f, -0.06022044f, -0.07406825f, 
    0.10125929f, 0.13275850f, -0.02993752f, 0.23863739f, 0.10722595f, -0.04190465f, 0.00810894f, -0.07683368f, 
    0.00065273f, -0.05302580f, -0.03057253f, 0.02937012f, -0.13383396f, 0.02525439f, -0.10126687f, -0.06700069f, 
    -0.03858431f, -0.08905432f, -0.05463858f, 0.01863622f, -0.08818603f, 0.00980726f, -0.00448695f, -0.03693203f, 
    -0.04374808f, -0.16025952f, -0.02649107f, 0.01304265f, 0.02141672f, -0.07459895f, -0.00445453f, 0.01525094f, 
    0.04287685f, -0.06789204f, 0.04178068f, -0.06170053f, 0.21168718f, -0.30270070f, -0.00945629f, 0.06114365f, 
    0.04662241f, 0.00444054f, 0.02084768f, 0.00549315f, -0.02623457f, -0.11531867f, 0.04686595f, -0.02871430f, 
    -0.01332739f, 0.00146952f, 0.08056203f, -0.13440658f, 0.01882779f, -0.05074178f, 0.00224932f, -0.09145331f, 
    -0.04515042f, -0.01311119f, -0.06589673f, -0.08579124f, 0.10319552f, -0.14049008f, 0.13454881f, -0.04562565f, 
    0.05235510f, 0.01963314f, -0.05135156f, -0.05487778f, -0.00851065f, -0.01313084f, 0.04531876f, -0.04407880f, 
    0.11238219f, 0.13082138f, 0.20562215f, 0.12203959f, 0.01790302f, 0.03307276f, 0.01443169f, -0.02959165f, 
    -0.00449241f, -0.00016969f, -0.05857739f, -0.08115891f, 0.23670338f, 0.09482443f, 0.18458833f, 0.03840072f, 
    -0.01040597f, 0.03662311f, 0.01878041f, 0.00015482f, -0.05495292f, 0.07424087f, -0.01001439f, -0.08849957f, 
    -0.24543999f, 0.06099126f, -0.02600020f, 0.09633221f, -0.04297018f, -0.11228350f, -0.05489793f, 0.00624747f, 
    -0.06556047f, 0.04891347f, 0.04547153f, 0.01973160f, 0.15279017f, 0.11186668f, -0.01147882f, 0.18350968f, 
    0.10002450f, -0.04210372f, 0.01315128f, 0.15931500f, 0.05943178f, -0.05544544f, -0.03392716f, -0.03397822f, 
    0.06742563f, 0.11555038f, 0.04047843f, 0.06228743f, 0.00452368f, 0.07237959f, -0.01691970f, -0.01096650f, 
    0.02476435f, -0.01555607f, -0.01353520f, 0.03577310f, 0.08190747f, 0.19422062f, 0.06190762f, 0.09842785f, 
    0.00927848f, 0.09221276f, 0.03590389f, -0.07872226f, 0.00461510f, 0.04972662f, 0.02195623f, -0.08877426f, 
    -0.00497416f, 0.12183354f, 0.14269051f, 0.18546063f, 0.07762883f, 0.03333627f, 0.02529485f, 0.00924753f, 
    -0.03254541f, 0.05219707f, 0.00443419f, 0.02755580f, -0.17556669f, 0.08697588f, 0.00452997f, 0.14717893f, 
    -0.01492892f, -0.01455601f, -0.10091443f, 0.01110712f, 0.01176205f, -0.01389944f, 0.01357478f, -0.03131632f, 
    0.20292026f, -0.04712440f, 0.00506025f, -0.06621471f, 0.03186667f, -0.08009282f, -0.06879164f, -0.03361735f, 
    -0.05875649f, 0.03542874f, -0.04345064f, -0.00298855f, 0.03744938f, -0.13767527f, 0.00332698f, -0.17512955f, 
    -0.02804601f, -0.02382366f, -0.03028127f, 0.02083574f, -0.01196411f, -0.00382674f, -0.06248550f, -0.04811943f, 
    -0.11283354f, -0.07246464f, -0.04989905f, 0.21074748f, -0.05452888f, -0.13866898f, -0.08455058f, 0.02290889f, 
    -0.04518997f, 0.00291968f, 0.00687046f, -0.05953389f, 0.12782922f, 0.13244161f, -0.01436352f, 0.26788759f, 
    0.06364580f, -0.03248801f, -0.03358188f, 0.03232785f, -0.08046503f, -0.05996704f, 0.03636912f, -0.02056715f, 
    0.15542555f, -0.17037369f, 0.05500362f, 0.08152206f, 0.03418043f, -0.05675101f, -0.05710595f, -0.01528467f, 
    -0.03823416f, -0.00418359f, 0.01101488f, -0.07659476f, -0.03208154f, 0.08048686f, -0.01902963f, 0.01630526f, 
    -0.13494268f, -0.01758865f, 0.01913404f, 0.03001446f, -0.06993843f, 0.05093198f, -0.03654820f, -0.03331913f, 
    -0.21279894f, 0.05696531f, -0.08320194f, -0.04177620f, 0.06656370f, 0.03093047f, -0.07095953f, -0.03807250f, 
    0.00910928f, 0.04436760f, 0.01152798f, -0.03623888f, -0.03662952f, 0.02382901f, -0.13807976f, 0.06157348f, 
    -0.04427210f, -0.01091060f, -0.09187732f, 0.02218435f, 0.04835208f, -0.01450948f, 0.01896713f, -0.09749325f, 
    0.09683347f, 0.17126961f, -0.12550488f, 0.13981625f, -0.00783185f, -0.03457704f, -0.05929895f, 0.05074434f, 
    -0.02844165f, -0.04907760f, -0.00708236f, -0.09190018f, -0.01245991f, 0.16539161f, 0.02512378f, -0.09624147f, 
    0.04074255f, -0.01720319f, -0.00039278f, -0.08556408f, -0.05047058f, 0.03749990f, 0.01222073f, -0.05156177f, 
    -0.00440028f, -0.20661417f, 0.12886879f, 0.05600880f, -0.00506313f, 0.00290504f, -0.01862529f, -0.02685133f, 
    -0.01203820f, 0.00328131f, -0.00724067f, -0.05995708f, 0.13193522f, 0.13733062f, 0.13125084f, 0.04686571f, 
    0.07616708f, 0.07015844f, 0.00282093f, 0.03516924f, -0.03010951f, 0.05359013f, -0.05626984f, -0.05987024f, 
    -0.12108926f, 0.00953437f, 0.05010122f, -0.06046251f, -0.00431707f, 0.06927434f, 0.01464245f, -0.06796629f, 
    -0.00195085f, -0.09923419f, 0.03937270f, -0.02686997f, 0.13172337f, 0.00404284f, 0.09671559f, 0.00612215f, 
    0.12122793f, -0.09867314f, -0.04579938f, 0.03529835f, -0.03291713f, 0.02504317f, 0.01198965f, -0.00487749f, 
    -0.18142988f, -0.00871052f, -0.11408961f, -0.03518587f, -0.03475944f, -0.07304075f, -0.05596127f, 0.01154086f, 
    -0.06911865f, 0.05726995f, -0.02428046f, -0.01203803f, 0.05301717f, 0.03534124f, 0.12283694f, 0.01283180f, 
    0.05642433f, 0.02618378f, -0.04165893f, 0.00319696f, -0.06792465f, 0.05169346f, 0.03724894f, -0.09804108f, 
    -0.18181010f, 0.07804636f, -0.06468124f, -0.08946545f, -0.04474459f, -0.00275337f, 0.02303962f, 0.02546850f, 
    0.00944648f, -0.00929898f, -0.06265666f, -0.05049981f, 0.06543091f, 0.05533244f, 0.06964579f, 0.11780202f, 
    0.10105496f, -0.02109947f, -0.00599332f, -0.06474990f, -0.02210015f, -0.01456997f, -0.04290652f, -0.04889769f, 
    0.08820313f, 0.09886635f, 0.15145375f, 0.16649404f, 0.06903344f, 0.02448401f, 0.04633296f, 0.00975378f, 
    -0.10210615f, 0.05107982f, 0.04498871f, -0.01124972f, -0.05692413f, -0.08351447f, 0.12734476f, 0.05107975f, 
    0.14805891f, 0.02071844f, -0.00585730f, -0.09078678f, -0.06002282f, -0.02268795f, 0.02264881f, -0.09220725f, 
    -0.26634884f, 0.09794226f, 0.03256327f, -0.18560530f, -0.07261627f, 0.00889200f, 0.00160882f, -0.04510448f, 
    -0.01236341f, -0.02189142f, -0.02856288f, 0.00906156f, -0.14276946f, 0.04354115f, 0.11204243f, 0.03463701f, 
    0.00310123f, 0.06384941f, 0.06432449f, -0.10859853f, -0.06869026f, 0.03146037f, -0.02215599f, -0.01118074f, 
    -0.35283697f, 0.10452154f, -0.09335496f, -0.19081163f, 0.01242384f, -0.05405286f, -0.00521127f, -0.02523600f, 
    -0.00793417f, 0.02152949f, -0.01602111f, -0.07150093f, -0.22627950f, 0.04210795f, -0.09036866f, -0.08103365f, 
    0.01297130f, 0.06339047f, -0.02373523f, -0.02553890f, -0.01111018f, -0.06219253f, -0.00413099f, -0.12770444f, 
    0.02003385f, -0.26703855f, -0.05959673f, 0.13797128f, 0.11091885f, 0.04184130f, 0.01257551f, -0.08322442f, 
    0.01245068f, -0.00269697f, 0.02743495f, -0.00551323f, 0.13783190f, 0.12110492f, -0.30759278f, -0.14170235f, 
    0.05685933f, -0.08862158f, -0.01453188f, -0.05063384f, 0.02389470f, 0.05578335f, 0.10679758f, 0.07136966f, 
    -0.13598768f, 0.18551292f, -0.16745190f, -0.15708657f, -0.11628092f, 0.03099347f, -0.14396006f, -0.06277178f, 
    0.01485458f, 0.08414504f, 0.00711870f, 0.02580248f, -0.01681506f, 0.03031929f, -0.12215858f, 0.08080570f, 
    0.05328328f, 0.07644961f, 0.02664214f, 0.02556203f, 0.01302296f, -0.01648432f, -0.05261714f, 0.07906751f, 
    0.01313245f, 0.05471822f, 0.08390659f, -0.12557121f, 0.04171386f, -0.14184049f, -0.11397342f, 0.05871766f, 
    0.06938881f, -0.02628638f, 0.04355621f, 0.00432451f, -0.10975698f, -0.10764106f, 0.07770166f, -0.10904031f, 
    -0.11757132f, 0.03879748f, -0.02044886f, -0.21561979f, 0.07185080f, -0.04504263f, 0.03867941f, -0.01863344f, 
    0.05359899f, -0.03850571f, -0.10803121f, -0.07711564f, 0.03549402f, -0.04584875f, 0.00089804f, -0.10788558f, 
    0.01507728f, 0.03529049f, 0.09711412f, 0.03170213f, 0.03319295f, 0.07997864f, -0.09785381f, 0.01907752f, 
    -0.05977599f, -0.04646516f, 0.05013963f, -0.04479313f, -0.00002668f, -0.16557746f, 0.02835639f, -0.02058671f, 
    -0.12962870f, 0.01103436f, -0.09364327f, -0.07363407f, -0.10790128f, 0.10367120f, 0.09036738f, -0.10838768f, 
    0.02948330f, 0.00905847f, 0.04204164f, 0.04813388f, -0.21315546f, -0.18035957f, -0.03106583f, 0.01679844f, 
    0.07358335f, 0.03080662f, -0.03500102f, -0.03160723f, 0.03426805f, 0.01162564f, -0.02067649f, 0.09288947f, 
    -0.09553818f, -0.11922316f, 0.16339247f, 0.19056208f, -0.04521490f, 0.00456025f, -0.03791273f, -0.00988368f, 
    0.03809516f, 0.08868758f, 0.01157230f, 0.03151286f, 0.16682117f, 0.05600644f, -0.14650077f, -0.06739360f, 
    0.02007548f, 0.03262004f, -0.00181034f, 0.05407269f, 0.06734034f, -0.04240807f, -0.04259603f, 0.08208653f, 
    -0.14048724f, -0.11574137f, 0.21069412f, 0.06980644f, -0.00259938f, -0.05954485f, 0.04281220f, 0.00633360f, 
    0.05217823f, -0.01907113f, 0.04949864f, -0.03986049f, 0.08922771f, 0.05608008f, -0.04859843f, 0.02528285f, 
    0.03039776f, 0.08381086f, -0.03327598f, 0.07448922f, 0.08759759f, -0.02139516f, 0.06028143f, -0.04566861f, 
    0.20697962f, 0.12503675f, 0.06556117f, 0.07411310f, -0.03242704f, -0.03071533f, -0.12554799f, -0.04998245f, 
    -0.10191506f, -0.05546864f, -0.07057443f, -0.09683326f, 0.13405877f, 0.04328765f, -0.01107516f, 0.09443893f, 
    0.05268948f, -0.07683614f, 0.06532812f, -0.06527949f, -0.04670317f, -0.04190845f, -0.11551401f, 0.02948324f, 
    -0.13875268f, 0.07716806f, 0.06017396f, -0.14703630f, -0.01790410f, -0.00440103f, -0.11045952f, 0.08580087f, 
    -0.00380850f, 0.06865577f, -0.09207194f, 0.12734389f, -0.02710669f, -0.01875271f, -0.04182070f, -0.05975726f, 
    -0.00708594f, 0.08225265f, -0.07946306f, -0.01005231f, 0.02515027f, 0.00451440f, 0.11934437f, 0.08326925f, 
    0.00926935f, 0.19889130f, -0.06410822f, -0.07331828f, 0.01802429f, -0.05751714f, 0.00947925f, 0.03267247f, 
    0.03038131f, 0.06445242f, 0.09795655f, 0.06675275f, -0.27871960f, 0.02500383f, -0.06359898f, -0.16274023f, 
    0.05785718f, 0.05556722f, 0.02188789f, -0.05439264f, 0.00185254f, -0.12891935f, -0.05075520f, -0.00256733f, 
    -0.22326656f, 0.01439664f, -0.00652333f, -0.04829906f, -0.03632668f, -0.09089848f, -0.13006635f, -0.09386303f, 
    0.02005258f, -0.04490185f, 0.08786362f, -0.10164937f, 0.09527310f, -0.07987776f, -0.00082346f, 0.18535054f, 
    0.13554455f, -0.02190328f, 0.05080783f, -0.06706166f, 0.09172210f, -0.00126176f, 0.01635324f, 0.10630558f, 
    0.04760331f, -0.11249638f, 0.06355795f, 0.15014808f, 0.05581417f, -0.13049302f, -0.00595692f, -0.08165926f, 
    -0.03773034f, 0.07086948f, -0.16875274f, 0.02080523f, -0.05775325f, -0.05463827f, -0.11135484f, -0.13951801f, 
    0.12540835f, -0.00100696f, -0.07743986f, 0.07140840f, 0.02601332f, -0.04430798f, -0.02616118f, 0.00952707f, 
    0.17025743f, 0.07633208f, 0.09684906f, 0.16110232f, 0.03686893f, -0.09236241f, 0.00963400f, -0.09027822f, 
    0.00203081f, -0.11460436f, 0.08659901f, 0.01130802f, 0.12217549f, -0.12427783f, 0.03321373f, 0.15612942f, 
    0.10973107f, 0.00206352f, -0.00784078f, -0.05922662f, -0.02213385f, 0.02863283f, 0.04023635f, -0.08251758f, 
    0.08657496f, -0.14625232f, 0.02431964f, -0.07619082f, -0.05324905f, -0.05199587f, 0.09544623f, 0.04511053f, 
    0.01614423f, -0.07994747f, 0.06308854f, -0.05871110f, 0.03532227f, 0.11931300f, -0.18415454f, -0.19630489f, 
    0.00733420f, 0.01488089f, -0.05173916f, 0.06631307f, 0.11739831f, 0.06495404f, 0.04634937f, 0.03478858f, 
    -0.03322432f, -0.04201838f, -0.03167285f, -0.16916326f, -0.11331815f, 0.02489997f, -0.11833622f, 0.02764648f, 
    0.14347363f, 0.07230635f, -0.11947306f, 0.08181999f, 0.18178064f, 0.09822780f, -0.21817809f, -0.08377108f, 
    0.03730837f, 0.03799862f, 0.04815098f, -0.02055766f, -0.05213182f, 0.06814802f, -0.03811203f, 0.07759613f, 
    0.01305222f, -0.13944264f, 0.03218169f, 0.16157234f, -0.01305992f, -0.15225101f, -0.03282566f, -0.03532556f, 
    0.00551670f, 0.01713157f, 0.02545190f, -0.07181669f, -0.32753944f, -0.17838678f, 0.05708307f, -0.01487078f, 
    -0.00616958f, -0.10354136f, 0.00673951f, 0.07275438f, 0.00872515f, 0.10057358f, -0.04613405f, 0.06857485f, 
    -0.12169977f, 0.10708397f, 0.00944054f, -0.04159643f, -0.02832391f, 0.05076476f, -0.03090939f, -0.12312284f, 
    0.02010869f, -0.14045294f, 0.08966140f, 0.03395966f, -0.06449164f, -0.06391504f, 0.03770014f, -0.10565373f, 
    -0.01492334f, -0.16963002f, 0.07618067f, -0.09898212f, 0.05458671f, 0.02475073f, -0.08897065f, -0.00051443f, 
    -0.11468256f, 0.04000956f, -0.14764887f, 0.05205026f, 0.07269822f, 0.07054989f, -0.07414412f, -0.00820779f, 
    0.13839985f, 0.00122096f, -0.09938487f, -0.04798824f, -0.09445915f, -0.07257096f, 0.03299504f, -0.13466643f, 
    0.05588557f, 0.04818788f, -0.04226455f, -0.00144043f, -0.02484663f, 0.08195578f, -0.00245268f, -0.11058742f, 
    -0.09683120f, 0.11476550f, 0.06909653f, -0.18959725f, -0.00894026f, -0.08290307f, -0.03663324f, -0.06142382f, 
    -0.04271450f, -0.01965035f, -0.10783000f, -0.14021851f, -0.13557778f, 0.19556819f, 0.20900869f, 0.19914472f, 
    -0.10385234f, 0.07113659f, -0.25442505f, 0.04138588f, -0.00261178f, -0.01767115f, -0.01831886f, -0.10875009f, 
    0.02015824f, -0.04687530f, 0.23169684f, 0.06572001f, -0.08051062f, 0.02666548f, 0.01170038f, -0.07097378f, 
    -0.09921785f, 0.00875526f, 0.06455845f, -0.10807980f, -0.09055261f, 0.24335898f, -0.15025736f, -0.18778832f, 
    -0.08609378f, -0.07274789f, 0.06756853f, -0.07427203f, 0.03846263f, -0.20481157f, -0.04039208f, 0.02657452f, 
    0.08422508f, -0.25810453f, 0.08570756f, -0.04052955f, -0.02862079f, -0.03873765f, -0.01771592f, -0.00217194f, 
    -0.04383780f, 0.01694104f, 0.00696644f, -0.06367316f, 0.20966721f, -0.12702721f, -0.12875968f, 0.01773405f, 
    0.13914599f, -0.01431591f, -0.07000708f, -0.07017819f, 0.03172729f, -0.09138495f, 0.01408955f, -0.04120943f, 
    -0.21987545f, -0.13415682f, -0.15163830f, -0.16175663f, -0.02621188f, 0.02363820f, -0.05855221f, 0.01077654f, 
    0.02563990f, 0.01234035f, 0.02425239f, 0.02809886f, -0.19744121f, -0.03272153f, 0.04682357f, -0.20398505f, 
    -0.07127242f, -0.05685969f, 0.10705086f, 0.00638188f, -0.01645702f, 0.07394648f, -0.05509026f, -0.01292121f, 
    -0.04977284f, -0.13188456f, -0.12346295f, -0.25892147f, 0.01522544f, 0.00583057f, 0.08164294f, -0.01173766f, 
    0.07250481f, 0.06076519f, -0.03438881f, 0.09233395f, -0.10378947f, 0.09708924f, -0.15084763f, -0.13928011f, 
    0.07247579f, 0.00192430f, -0.00521705f, 0.03236479f, 0.10597625f, 0.03401117f, 0.03758882f, -0.07058501f, 
    0.08634690f, 0.14917724f, -0.11112729f, 0.03766093f, 0.05050506f, 0.02309121f, 0.02047637f, 0.00485459f, 
    0.01677220f, 0.03921289f, -0.12308455f, -0.13884287f, -0.02407856f, 0.20183378f, -0.21265799f, 0.06648549f, 
    0.02374733f, 0.08073678f, -0.11609995f, -0.05892922f, 0.08874850f, 0.06938163f, -0.12869789f, 0.09656990f, 
    0.02080017f, 0.12340978f, -0.08768360f, -0.11438993f, 0.04487637f, 0.00197219f, 0.03344851f, 0.09495024f, 
    -0.08375929f, -0.00618039f, -0.04904463f, 0.12689145f, 0.02310595f, -0.05697189f, 0.03488501f, 0.08477399f, 
    0.02153812f, -0.08879114f, 0.01338342f, 0.14274815f, 0.07981656f, -0.01663705f, 0.02044275f, -0.05581841f, 
    -0.05610215f, -0.22497767f, -0.14991127f, 0.15048683f, 0.09272810f, 0.00799254f, -0.09768688f, -0.07492784f, 
    0.05372308f, -0.02600714f, 0.05429769f, -0.00708908f, -0.05980310f, -0.06434385f, -0.05149651f, -0.14862376f, 
    0.01046021f, -0.06626985f, 0.01182901f, -0.08275827f, -0.04676149f, -0.01972937f, 0.06873452f, -0.05267957f, 
    0.05107959f, -0.02768878f, -0.14758435f, 0.06575049f, 0.06699118f, -0.13095872f, -0.00444239f, 0.05232510f, 
    0.09851015f, 0.02556175f, -0.00124609f, 0.02845823f, 0.17310561f, 0.04404606f, 0.01150880f, 0.11750789f, 
    -0.16993572f, -0.03311378f, -0.09375618f, -0.15580845f, -0.04659778f, -0.04072841f, -0.01517865f, -0.03302832f, 
    -0.00981856f, 0.18581137f, -0.04040852f, 0.03653776f, -0.00288111f, 0.09917174f, -0.05132704f, -0.01547313f, 
    0.06952551f, -0.03622408f, 0.09423271f, 0.07324227f, -0.00914129f, -0.21913131f, 0.09769525f, -0.11807629f, 
    -0.09742658f, -0.06483863f, -0.04051676f, -0.18347259f, -0.06842974f, 0.05500746f, -0.07107470f, -0.02668215f, 
    0.10421780f, 0.11277472f, 0.11726926f, 0.04783905f, -0.10673376f, 0.06611779f, -0.03769211f, -0.00289554f, 
    0.06270394f, -0.14477164f, 0.02785810f, 0.09053908f, -0.25944108f, -0.07782942f, -0.00885773f, -0.21937943f, 
    -0.00807060f, 0.03159116f, 0.04467220f, -0.02392906f, -0.02035915f, -0.11765274f, 0.14491136f, -0.08658007f, 
    -0.10506807f, -0.25064009f, 0.20573206f, -0.14657779f, -0.00029731f, -0.15370025f, 0.03455286f, -0.03262063f, 
    -0.04452912f, 0.09792162f, -0.05930530f, -0.07134032f, 0.03651300f, -0.21356298f, 0.18357383f, 0.05734989f, 
    -0.11176696f, -0.04793840f, 0.02794837f, -0.10162449f, -0.01375362f, -0.04815417f, -0.04334266f, -0.02862747f, 
    0.19341150f, 0.06006584f, -0.04986532f, 0.18271141f, 0.06690097f, -0.02502753f, -0.04183904f, -0.04679281f, 
    -0.03716099f, 0.03894146f, 0.14683954f, -0.06363800f, -0.02697868f, -0.03077254f, 0.21564668f, 0.17249362f, 
    -0.08889943f, 0.02437408f, -0.14781162f, -0.06424383f, -0.05476861f, -0.00654724f, 0.08730277f, -0.23200682f, 
    -0.18695137f, -0.02775098f, -0.00493485f, 0.12348773f, 0.08921026f, 0.06658365f, -0.06825382f, -0.03323379f, 
    0.00359338f, 0.05234772f, 0.11960973f, 0.00035252f, 0.12810394f, -0.00100671f, -0.02626457f, 0.08622620f, 
    0.07123172f, -0.00736909f, -0.03299478f, -0.01985389f, -0.11862777f, 0.01063409f, -0.01292998f, -0.01085620f, 
    -0.12556550f, -0.01501295f, 0.08546850f, -0.22474064f, -0.00124555f, 0.06311319f, -0.07970584f, -0.03218681f, 
    -0.01633456f, -0.04489975f, 0.04228243f, -0.00346746f, -0.11315408f, 0.20689772f, 0.13969311f, -0.16054574f, 
    0.04307369f, 0.06083478f, -0.07103117f, -0.00263988f, -0.13049397f, 0.03224502f, -0.03053059f, -0.10554984f, 
    0.23644429f, 0.20304509f, -0.08972188f, 0.09771769f, -0.03636345f, 0.09739833f, -0.05249861f, 0.14048769f, 
    0.00828144f, 0.01256046f, -0.15506116f, 0.11614772f, -0.39024425f, 0.10237394f, -0.12153455f, -0.22002228f, 
    0.09120885f, -0.06120306f, -0.04446336f, -0.07876219f, -0.08301830f, -0.09197325f, 0.05251567f, -0.06355875f, 
    0.01633750f, 0.03807838f, -0.16097747f, -0.01010143f, 0.09270120f, -0.10092727f, -0.07222880f, 0.05921388f, 
    -0.09062479f, -0.01141045f, 0.11765011f, 0.06181990f, 0.22893812f, -0.19626927f, 0.00079857f, 0.14529063f, 
    0.02184683f, 0.00388567f, -0.03944956f, 0.10731942f, -0.16886358f, 0.02510813f, 0.02404296f, 0.06108176f, 
    -0.22183996f, 0.05868495f, 0.00040596f, -0.17889580f, 0.09267440f, -0.12257101f, 0.09309787f, -0.01572140f, 
    -0.01036252f, -0.02363085f, 0.01031292f, 0.05824402f, -0.54028112f, 0.18642680f, -0.13435364f, 0.17618510f, 
    -0.03102266f, 0.07210539f, 0.09033623f, 0.00252364f, 0.01335184f, 0.11475708f, 0.12681612f, -0.00425910f, 
    -0.08955153f, 0.50178862f, -0.17743193f, 0.09540570f, 0.07887704f, 0.01337787f, 0.05129863f, -0.01378956f, 
    -0.02543207f, 0.17938112f, -0.03700251f, 0.02255525f, -0.03488147f, -0.02788631f, 0.14876135f, -0.33370411f, 
    -0.04234730f, 0.01076459f, -0.10650206f, -0.10513799f, -0.04784643f, 0.01824081f, 0.05528006f, -0.10226151f, 
    -0.17459862f, 0.17057014f, -0.06288949f, -0.11749782f, -0.01414103f, -0.01129491f, 0.04717151f, -0.01077085f, 
    -0.08590884f, 0.04222995f, 0.05862970f, -0.00554496f, 0.33028153f, -0.04299182f, 0.23726599f, 0.06283066f, 
    0.07201185f, 0.11500432f, 0.05859984f, -0.14647956f, -0.11456493f, -0.00889640f, -0.03923350f, 0.04885385f, 
    -0.06403276f, 0.12638994f, -0.00454226f, -0.13639601f, -0.01880177f, -0.05531996f, -0.03431857f, 0.06419668f, 
    -0.03856101f, 0.01151328f, 0.04435195f, 0.07411967f, 0.05591479f, 0.01190740f, 0.22023544f, -0.15097106f, 
    -0.00317860f, 0.07838724f, -0.14246722f, 0.02608878f, -0.07760194f, -0.05075578f, -0.06440298f, -0.06095898f, 
    0.24866445f, -0.42294654f, 0.02891670f, -0.19440131f, 0.05161282f, 0.02571985f, -0.06455857f, -0.01679765f, 
    -0.10157009f, -0.02179757f, 0.07629707f, -0.01394230f, 0.09404662f, 0.05130980f, 0.03470170f, -0.11118644f, 
    0.07081188f, 0.07966059f, -0.08029330f, 0.06100291f, 0.14751004f, 0.01911082f, 0.03068317f, -0.08705343f, 
    0.18917891f, -0.46656710f, 0.03114996f, 0.05580034f, -0.08998302f, 0.02641018f, -0.01690210f, 0.07104674f, 
    -0.11164270f, -0.09616718f, 0.01548234f, -0.04980991f, -0.04452697f, -0.21426757f, -0.00368088f, 0.03783681f, 
    -0.04506215f, 0.01312894f, 0.03622588f, -0.19617394f, 0.04437231f, 0.07054619f, -0.02365031f, -0.12848715f, 
    -0.26748958f, 0.10483097f, 0.26150495f, -0.16006616f, 0.00898926f, -0.07127889f, -0.00033717f, -0.09533096f, 
    0.03486818f, -0.12249739f, -0.05196732f, 0.02038330f, -0.02210305f, -0.05033262f, -0.12786375f, 0.23061921f, 
    -0.00486737f, -0.01676962f, -0.04800334f, -0.03709582f, -0.08543482f, 0.02391243f, 0.07468151f, 0.04174066f, 
    -0.11209075f, -0.23984101f, 0.20862240f, -0.10821899f, -0.10768366f, 0.10095867f, 0.08504091f, 0.10727946f, 
    0.05409291f, 0.00639641f, -0.03952141f, 0.06071598f, -0.02197239f, -0.03288844f, -0.17828059f, -0.10936470f, 
    0.10199816f, 0.03062803f, -0.02325494f, 0.04043828f, -0.11208690f, -0.10169493f, -0.02597682f, -0.07609743f, 
    -0.06387180f, 0.07853068f, 0.12485054f, -0.14166620f, 0.04635459f, 0.00663174f, -0.10389605f, -0.14230765f, 
    0.09275528f, -0.13758452f, 0.12923205f, 0.03738270f, -0.06368868f, -0.18490058f, 0.14874656f, -0.10255175f, 
    -0.09681929f, 0.02350061f, -0.02155755f, 0.06645120f, 0.00657536f, 0.00050804f, 0.11999074f, 0.08117779f, 
    0.12786290f, 0.18834899f, -0.30187011f, -0.20525715f, 0.17099300f, 0.01589921f, 0.05360720f, -0.06274040f, 
    -0.07616758f, -0.11462084f, -0.02388430f, -0.01571110f, -0.16244780f, -0.13613249f, -0.03497075f, -0.04668371f, 
    -0.02834371f, 0.01337706f, 0.01760467f, -0.11940803f, -0.02947341f, -0.07851921f, -0.14271414f, -0.01979165f, 
    -0.00058180f, -0.12050970f, -0.04139648f, -0.23337576f, 0.08657165f, 0.02799879f, -0.08326100f, -0.01050622f, 
    -0.12900536f, 0.07628687f, 0.00000285f, 0.03040530f, -0.01341898f, 0.09331850f, 0.03019398f, 0.06488983f, 
    0.02552723f, 0.01468182f, 0.07711491f, -0.01484637f, -0.16128512f, 0.04903986f, 0.04572661f, -0.00507078f, 
    0.06913847f, -0.15470068f, 0.01877867f, -0.30422780f, -0.11282328f, -0.04046094f, 0.05293064f, 0.01382774f, 
    0.09220032f, -0.06033527f, 0.05193767f, -0.24181995f, 0.20789301f, -0.21318154f, 0.24574044f, 0.06917646f, 
    0.00444482f, 0.01323315f, -0.08056332f, -0.04411590f, -0.05087661f, 0.07237072f, 0.04206650f, 0.09194930f, 
    -0.01239174f, 0.08234627f, 0.00166215f, 0.06107331f, 0.06252174f, -0.05512597f, 0.06238251f, -0.01992151f, 
    0.07906266f, -0.00167601f, 0.03634918f, 0.03262809f, 0.30241156f, 0.03016379f, -0.08583813f, 0.20843446f, 
    -0.10888491f, -0.07583280f, 0.12349457f, -0.05173101f, 0.10883415f, -0.02133257f, 0.01596208f, -0.04430757f, 
    0.02362556f, -0.24647401f, -0.18420264f, 0.06762657f, 0.08058801f, 0.12834053f, 0.04164736f, -0.15651433f, 
    -0.03799324f, 0.01116973f, -0.07788008f, -0.03266571f, 0.03364496f, 0.06159792f, -0.12295613f, 0.15530637f, 
    -0.02454566f, 0.09576594f, -0.03244698f, 0.07497599f, -0.01518683f, -0.00270119f, -0.03525277f, -0.05790872f, 
    -0.09955305f, 0.05046521f, -0.10247765f, -0.33012551f, 0.07532694f, 0.10555813f, -0.14951034f, 0.02261275f, 
    0.04353992f, -0.06815181f, 0.06072280f, -0.06284377f, -0.12773646f, 0.03778649f, 0.04435446f, -0.00324338f, 
    0.04640820f, -0.10904077f, 0.15079339f, 0.13335979f, 0.08022606f, -0.10039202f, -0.05015213f, -0.02410030f, 
    -0.37987587f, -0.06552796f, 0.00973352f, 0.15449268f, -0.07886494f, 0.13635589f, -0.07807112f, -0.02532711f, 
    -0.11404091f, -0.03286306f, 0.10342374f, -0.03167927f, -0.14064960f, -0.01272429f, 0.04486563f, 0.04843139f, 
    0.10965532f, -0.06704665f, -0.02234336f, 0.16581742f, 0.09465892f, 0.07536148f, -0.04102658f, 0.05762652f, 
    -0.23614833f, -0.11725799f, 0.13458374f, 0.00046510f, 0.13727406f, 0.02198375f, -0.02223790f, 0.00327109f, 
    0.03203016f, 0.05005446f, -0.01119309f, 0.07277294f, -0.09199440f, 0.00044769f, 0.10412820f, 0.24097410f, 
    -0.05110728f, 0.07338737f, -0.02695005f, 0.04383297f, -0.08029617f, -0.12097688f, 0.11943074f, 0.03480191f, 
    0.19495998f, 0.25354904f, -0.09418808f, -0.01102984f, -0.06980059f, -0.04253100f, -0.02688597f, 0.01822260f, 
    0.02269009f, 0.08626790f, -0.11137535f, 0.01969581f, 0.05349751f, 0.08138711f, 0.09044061f, -0.07679649f, 
    -0.02355793f, -0.00219973f, 0.10719085f, -0.00922938f, 0.06363173f, 0.02769043f, -0.00521495f, -0.01730774f, 
    -0.03785424f, -0.12919502f, -0.15139329f, -0.16550091f, -0.06280074f, -0.00269222f, 0.01917826f, 0.02197542f, 
    0.00579207f, -0.02345355f, 0.13775748f, -0.02365413f, 0.31133604f, 0.02278825f, -0.00787218f, -0.11497389f, 
    0.07775158f, 0.02452107f, -0.10349362f, -0.04937424f, -0.12418750f, 0.03695919f, -0.01283635f, 0.05388968f, 
    0.01830097f, -0.01503865f, -0.07656401f, -0.08918800f, -0.08239485f, 0.00700942f, 0.08082218f, -0.02386490f, 
    -0.02253045f, -0.05011479f, -0.10504667f, -0.10527993f, -0.29537913f, 0.11855993f, 0.07367676f, -0.00246532f, 
    0.10290959f, -0.03678764f, 0.03348477f, -0.02552838f, -0.14036764f, 0.00648309f, -0.12433406f, -0.05281629f, 
    -0.12761129f, 0.29822457f, 0.08506159f, 0.05997432f, 0.09829155f, 0.06464449f, -0.01772891f, -0.00575642f, 
    0.08038223f, 0.06991263f, 0.12978904f, -0.00228648f, -0.01785262f, 0.11772373f, 0.16275454f, 0.10870346f, 
    0.07059060f, 0.04660532f, -0.04366302f, 0.10903824f, 0.07111485f, -0.00988931f, 0.13224846f, 0.06909112f, 
    0.10551838f, -0.03730782f, 0.16907126f, 0.04091940f, -0.09220350f, -0.01491452f, 0.07658561f, 0.25120863f, 
    0.07139708f, -0.04403437f, -0.02322659f, -0.03031178f, -0.30347535f, -0.00614027f, -0.03250899f, 0.05928819f, 
    -0.02733455f, -0.04113722f, -0.03061017f, -0.14535205f, -0.04580521f, 0.03309866f, 0.00038004f, 0.03120852f, 
    0.06575863f, -0.08939990f, -0.06467263f, -0.23821966f, -0.03865220f, -0.12740599f, -0.01977007f, 0.13521677f, 
    -0.00027668f, 0.06427221f, 0.04533379f, 0.02275795f, -0.11214810f, -0.00506473f, -0.06154344f, 0.06798679f, 
    0.03647807f, 0.04646830f, 0.06626576f, 0.09496126f, -0.01900196f, -0.18929885f, 0.01057076f, 0.01984044f, 
    -0.31525096f, -0.15132938f, 0.02715399f, -0.13440663f, -0.03882835f, -0.08656229f, 0.00421735f, -0.10373724f, 
    -0.01321040f, -0.00442235f, 0.16276668f, -0.04055145f, 0.44646531f, -0.38261300f, -0.04439744f, 0.04299560f, 
    -0.01616609f, -0.02485240f, 0.02356795f, 0.07146207f, -0.00849091f, 0.03639726f, 0.02921178f, 0.04412953f, 
    0.11922072f, 0.04976135f, 0.05556994f, -0.08731995f, 0.00948790f, -0.00593619f, -0.02466887f, 0.00165767f, 
    0.01428135f, 0.02569338f, -0.14225538f, -0.13035314f, 0.24996075f, 0.15359533f, -0.33232111f, 0.33986363f, 
    -0.00278405f, -0.04878575f, -0.02958115f, 0.03345203f, -0.00680668f, -0.04598461f, 0.05086921f, 0.02466938f, 
    -0.25729263f, 0.35839376f, -0.02872447f, 0.02638068f, 0.10708106f, 0.08284340f, -0.04206714f, 0.07198913f, 
    0.02515225f, 0.08234837f, 0.01803808f, -0.05486125f, 0.03218128f, -0.24304460f, 0.05335722f, -0.02304312f, 
    -0.09395823f, 0.00509350f, -0.02494114f, -0.12027597f, -0.11157583f, 0.05256696f, -0.03314988f, 0.12649199f, 
    -0.25417933f, -0.04841482f, -0.12187085f, 0.15763712f, 0.00975131f, 0.01957641f, 0.06913050f, -0.13658124f, 
    0.11010127f, 0.07099061f, 0.01749553f, 0.01642759f, 0.28331372f, -0.02607040f, -0.11209440f, 0.13412173f, 
    0.06798863f, -0.05568491f, -0.09969765f, -0.07415684f, 0.06342682f, 0.01722983f, 0.07470841f, 0.13187011f, 
    -0.24107099f, -0.00682115f, -0.22113506f, -0.03657650f, 0.04062272f, -0.02403807f, 0.13627471f, -0.00755719f, 
    -0.04967719f, -0.03405459f, -0.21248031f, -0.06701533f, 0.05535311f, -0.19516948f, 0.03532144f, -0.09256714f, 
    0.04891305f, 0.06039970f, -0.03800229f, 0.00255857f, 0.00662364f, -0.01278989f, 0.02120834f, -0.01657926f, 
    -0.14950734f, 0.12099141f, 0.07449964f, -0.24286960f, 0.09051518f, 0.04461918f, -0.07986363f, -0.03833196f, 
    -0.02625155f, -0.00818249f, -0.10177775f, -0.17502452f, -0.09402011f, 0.16487575f, 0.11562489f, -0.18114139f, 
    0.00163949f, 0.06867390f, -0.00334868f, -0.05818868f, 0.12042456f, 0.04915711f, -0.07137377f, -0.06962021f, 
    -0.14679703f, -0.15525313f, 0.07244466f, -0.10490236f, 0.07196070f, -0.02631142f, 0.01404375f, -0.03729584f, 
    0.02392598f, 0.02595438f, 0.03587651f, -0.02326751f, -0.00867508f, -0.00887262f, -0.04838361f, 0.00002385f, 
    0.06106739f, -0.02083903f, 0.05808633f, 0.05934915f, 0.03588147f, 0.09486383f, 0.05103023f, 0.06912299f, 
    -0.17329782f, -0.05925101f, 0.11724704f, 0.06552966f, 0.03254547f, 0.03210500f, 0.04482659f, -0.06026628f, 
    0.02737768f, -0.00765374f, 0.00106170f, -0.02381833f, -0.17167465f, -0.08056822f, -0.08828097f, -0.13721871f, 
    -0.01824354f, -0.00261172f, 0.04441952f, 0.08705680f, 0.15425806f, 0.10064224f, 0.04259628f, 0.11666735f, 
    -0.10407642f, 0.10627086f, 0.07118724f, -0.35654968f, 0.06984014f, -0.03113862f, -0.09240425f, 0.02704650f, 
    -0.07039102f, -0.06031516f, -0.05610398f, -0.13723953f, 0.03927077f, 0.01979163f, 0.06154614f, 0.01386216f, 
    0.02389661f, 0.11514353f, 0.03649137f, 0.00171447f, -0.03487864f, -0.04893111f, 0.09647930f, 0.01762128f, 
    0.03354478f, -0.07877349f, -0.05320700f, 0.03093936f, -0.03563054f, 0.03549713f, 0.00301365f, -0.05192748f, 
    0.00074565f, 0.07798747f, -0.01852004f, 0.10574646f, -0.10080116f, -0.02860140f, -0.03389307f, 0.12133510f, 
    -0.00820154f, -0.00708182f, 0.07916107f, 0.06195229f, 0.00652485f, -0.06373321f, 0.05720311f, -0.10222732f, 
    0.02667533f, -0.08982637f, -0.04771408f, -0.01942995f, 0.10144763f, -0.11688723f, 0.03493031f, 0.09739414f, 
    -0.05484011f, 0.05991918f, 0.01577701f, 0.11569851f, -0.06941991f, 0.01506092f, -0.03766814f, -0.26371822f, 
    0.09510550f, 0.03325061f, -0.02708065f, 0.09159414f, 0.04291676f, -0.10133102f, -0.02292643f, 0.14170550f, 
    -0.05884623f, -0.16600668f, 0.06027909f, -0.01592059f, -0.07256295f, -0.00459363f, -0.03135021f, 0.16239019f, 
    0.12406673f, 0.01521575f, -0.11335522f, 0.00497312f, -0.27287683f, 0.03799051f, 0.19125403f, 0.12532777f, 
    0.11227031f, 0.03574273f, 0.04084232f, 0.10128781f, 0.03571506f, 0.04301195f, 0.00294375f, 0.14399308f, 
    -0.34747383f, -0.15574212f, 0.22806764f, -0.07165952f, 0.05950557f, 0.00430147f, 0.07582471f, 0.03056738f, 
    0.01630814f, -0.02753058f, -0.09156895f, 0.02212805f, -0.39770246f, -0.13806039f, 0.00214192f, 0.12739240f, 
    0.03472153f, -0.02262974f, -0.05054253f, 0.03528376f, -0.02999450f, -0.05160662f, 0.07977056f, 0.15077336f, 
    -0.43066716f, 0.26278120f, -0.33193108f, -0.24801329f, 0.08022898f, -0.04836790f, -0.15226926f, 0.00483206f, 
    0.01436101f, 0.03964178f, 0.00818532f, -0.04162621f, -0.26148060f, -0.09285729f, 0.04730536f, -0.08086821f, 
    0.03180701f, 0.03897548f, 0.03868131f, -0.13137525f, 0.02720757f, 0.00434450f, 0.06665410f, 0.13796212f, 
    0.12308213f, -0.06086449f, 0.05630458f, 0.00842459f, 0.03684219f, 0.06606801f, -0.03837341f, -0.02056537f, 
    0.09356652f, 0.10134652f, 0.07894695f, 0.07352035f, 0.07206721f, 0.01653446f, -0.12158313f, 0.01489384f, 
    0.11532278f, 0.06907552f, 0.05910449f, 0.07590485f, -0.02960030f, 0.05533635f, 0.10499058f, 0.02500213f, 
    -0.05921331f, 0.05359871f, -0.11403960f, 0.05964949f, 0.09291078f, 0.10614037f, 0.05171753f, 0.03418228f, 
    -0.03773490f, 0.10231325f, 0.09255054f, 0.02749316f, 0.04104377f, -0.11968952f, 0.03916116f, 0.05605030f, 
    -0.04622382f, 0.12271751f, -0.08843481f, 0.03258815f, 0.04079138f, -0.02951021f, -0.12671909f, -0.05732994f, 
    0.03117423f, 0.00088515f, -0.10552936f, 0.01109144f, -0.02511140f, -0.06840777f, -0.04941552f, -0.16138132f, 
    -0.01566477f, -0.11196043f, -0.03741398f, -0.14601848f, -0.25426364f, 0.07707228f, -0.24936661f, -0.09577246f, 
    -0.05058517f, 0.01513921f, -0.07024457f, -0.03288779f, -0.01524250f, 0.09150332f, -0.03723216f, 0.00225972f, 
    -0.17016554f, -0.08419331f, -0.16704963f, -0.00510779f, 0.02628562f, -0.10058976f, -0.13118775f, -0.07031660f, 
    -0.03716388f, -0.07926770f, -0.13516502f, 0.09855473f, -0.35456678f, -0.01609695f, -0.02198789f, 0.12191895f, 
    0.15354161f, 0.04623139f, -0.02032313f, -0.03354372f, -0.03415708f, -0.07076414f, -0.14394294f, -0.06201605f, 
    -0.12143216f, -0.12251051f, -0.12400470f, -0.07785740f, -0.10945199f, -0.04229553f, -0.00621336f, 0.05636231f, 
    -0.06573202f, 0.04726610f, 0.02734864f, -0.04671663f, -0.38891900f, -0.26021931f, -0.15022328f, -0.09760920f, 
    0.04575498f, 0.04730404f, -0.07490975f, 0.03329384f, 0.06423235f, 0.12702765f, -0.01197414f, 0.04684019f, 
    -0.05313674f, 0.00025918f, -0.03570963f, 0.12587138f, 0.06178181f, -0.07888925f, 0.00500017f, -0.01551047f, 
    0.05307119f, 0.13633645f, 0.05143796f, -0.02731598f, -0.31509194f, -0.26234710f, 0.06254795f, 0.06568901f, 
    0.10213897f, 0.07379419f, -0.04670730f, -0.02200695f, 0.16075648f, -0.05486756f, -0.10979682f, 0.01759498f, 
    0.25890771f, 0.18176346f, -0.07022488f, -0.05665214f, 0.09638911f, -0.03986346f, -0.06589638f, 0.06122756f, 
    0.06358290f, 0.05413276f, 0.03853515f, 0.28273207f, -0.41949567f, -0.15051618f, -0.00765135f, -0.01709192f, 
    -0.02037470f, -0.02825035f, 0.02379379f, 0.02095966f, -0.02459219f, -0.07914222f, -0.07759050f, 0.07916402f, 
    -0.27998289f, -0.06467863f, -0.10794417f, 0.00874841f, 0.03526938f, -0.14839567f, -0.13201152f, 0.02759068f, 
    -0.11515324f, -0.07719088f, 0.04116276f, 0.05232303f, 0.04673498f, 0.04087208f, 0.00846003f, 0.06033656f, 
    0.02769571f, -0.12260500f, 0.06941813f, 0.16058940f, -0.08246298f, 0.03099071f, 0.05725573f, 0.13854186f, 
    0.17828600f, 0.11277766f, -0.17982648f, -0.10050174f, -0.04257879f, -0.00176342f, 0.03098697f, 0.03181265f, 
    -0.02356363f, 0.00162882f, 0.13366686f, -0.02317173f, 0.25004762f, 0.12347627f, -0.09548465f, 0.00371764f, 
    -0.11676987f, -0.07341215f, -0.08337155f, -0.14755601f, 0.01063026f, -0.14986256f, -0.09910785f, -0.02785080f, 
    -0.13344093f, 0.11133759f, -0.08649423f, -0.28679493f, 0.11930174f, 0.05337954f, 0.01162561f, -0.04508195f, 
    0.10550992f, -0.07512297f, -0.04235422f, -0.04024090f, 0.19595271f, -0.04995884f, 0.07965311f, -0.17686877f, 
    -0.10186143f, 0.00454242f, -0.00316396f, -0.15284131f, -0.01870860f, -0.04327217f, -0.08674225f, 0.12314075f, 
    0.05672386f, -0.03873611f, 0.08169018f, -0.00535151f, 0.03633579f, 0.02215444f, 0.05166616f, -0.00826187f, 
    0.11196868f, 0.01908253f, -0.13640523f, -0.01550577f, 0.17745928f, -0.03518476f, -0.06708505f, 0.00284611f, 
    -0.08586520f, -0.02752485f, -0.03220033f, 0.03290860f, 0.07466846f, -0.05830003f, -0.05577118f, -0.12661499f, 
    0.23495319f, 0.12104396f, -0.05544605f, 0.00575331f, -0.19616430f, -0.10979006f, 0.04164573f, 0.07369970f, 
    0.05327090f, 0.05406501f, 0.03095935f, -0.07770047f, -0.07217652f, 0.02061566f, 0.05019493f, 0.09627006f, 
    0.14979409f, 0.05233851f, 0.05987764f, -0.09098487f, 0.07485977f, 0.02920161f, -0.01168145f, 0.01202802f, 
    -0.12980235f, 0.02656411f, -0.07081991f, 0.17528524f, 0.02467731f, -0.01712227f, 0.01790749f, -0.02496319f, 
    0.02138161f, 0.07223845f, 0.07828797f, 0.00894801f, -0.51727962f, -0.12698126f, -0.05590593f, 0.04763259f, 
    0.07994603f, -0.02532823f, -0.00332371f, -0.13672596f, -0.09646767f, -0.14971060f, -0.04982367f, 0.05686576f, 
    0.22256736f, 0.03229094f, 0.02913407f, -0.12961227f, 0.03031058f, 0.07803812f, 0.04662630f, 0.06429116f, 
    0.04513991f, -0.01210126f, -0.05357077f, 0.08879460f, -0.05729862f, 0.01047431f, 0.01212734f, 0.11204683f, 
    -0.01217590f, 0.01835348f, 0.01691834f, -0.04002610f, 0.05405536f, 0.18799573f, 0.10427538f, -0.00401746f, 
    0.29096740f, 0.30833110f, 0.11625480f, -0.17317854f, -0.03116588f, 0.05256064f, 0.05636776f, 0.05710491f, 
    0.04159455f, -0.04054880f, 0.05130997f, 0.05975521f, -0.05478368f, -0.00208788f, -0.03519769f, -0.00233550f, 
    0.04229048f, 0.13013303f, -0.04913427f, -0.01796265f, 0.11768602f, 0.01487960f, 0.03709977f, -0.04051634f, 
    -0.21014805f, -0.24604538f, -0.08387763f, 0.01537569f, -0.06865900f, 0.03034365f, 0.07577682f, -0.04056511f, 
    0.13487494f, 0.06197281f, -0.00168849f, -0.09434419f, -0.38253346f, -0.22053987f, 0.19090298f, 0.08608747f, 
    0.06463935f, 0.01689930f, -0.00405176f, -0.06030002f, 0.01693211f, -0.10913557f, -0.02004526f, 0.08812030f, 
    0.04381247f, 0.05813802f, 0.07311542f, -0.16600706f, 0.10687248f, 0.06039966f, 0.04071271f, -0.00618296f, 
    0.00160996f, -0.00342718f, 0.03897029f, -0.05995846f, -0.35778633f, -0.39209276f, -0.09117195f, 0.00290313f, 
    -0.01370821f, -0.06120383f, 0.02567486f, 0.08260322f, 0.04029091f, 0.07411812f, 0.00705031f, 0.15310639f, 
    -0.15699653f, -0.06330696f, -0.06080560f, -0.01023249f, -0.01794959f, 0.03893422f, -0.02735593f, 0.02892867f, 
    0.04053452f, 0.08707760f, 0.03983412f, -0.04050282f, 0.21795996f, 0.03730978f, -0.04472633f, 0.07099568f, 
    -0.06964697f, 0.06302480f, -0.10853238f, -0.12423135f, 0.01745155f, -0.06138277f, -0.03608796f, -0.05594764f, 
    -0.12057353f, 0.06104993f, -0.08468892f, -0.26056346f, 0.17414519f, 0.00001923f, -0.08671039f, 0.10948125f, 
    0.08195179f, 0.01415221f, -0.02844101f, 0.00577022f, 0.02427072f, -0.00826752f, -0.06521074f, 0.05925577f, 
    -0.05578951f, 0.03846396f, -0.13204962f, -0.00529091f, 0.01994493f, 0.02110900f, 0.03345852f, 0.06279332f, 
    -0.21186493f, -0.09342372f, 0.14903149f, 0.10676968f, 0.05328737f, 0.03633890f, -0.00870975f, 0.03481665f, 
    0.07484766f, 0.09008925f, 0.17737545f, -0.02425888f, 0.17494006f, 0.00718251f, -0.04448823f, 0.03888884f, 
    -0.07114857f, -0.03099885f, -0.00950960f, 0.00433677f, -0.02339511f, -0.00386881f, -0.06270913f, -0.17101419f, 
    -0.17816344f, -0.01239575f, -0.10119186f, 0.07861080f, -0.00125404f, 0.03652152f, 0.03562334f, 0.01213822f, 
    0.07005534f, -0.09120107f, 0.12459216f, 0.02237733f, 0.11206560f, 0.10857078f, -0.00781901f, -0.06776702f, 
    0.04574128f, 0.21045142f, 0.03035961f, 0.05123303f, 0.01668822f, -0.02713923f, 0.05845787f, 0.01260212f, 
    0.11252085f, 0.05034876f, -0.00537253f, 0.17858903f, -0.06990193f, -0.10791523f, 0.09296142f, -0.10815711f, 
    -0.05140535f, 0.00594796f, 0.05478610f, 0.02962301f, 0.23817451f, 0.13243493f, -0.10562402f, 0.06599200f, 
    -0.04124662f, -0.01677016f, -0.07217823f, 0.03035476f, 0.00528835f, -0.08874762f, 0.00921905f, -0.03701326f, 
    -0.61971831f, -0.38109040f, -0.10390824f, -0.15159409f, 0.03300354f, -0.01293458f, -0.12781583f, -0.00337438f, 
    0.04711812f, 0.09124657f, 0.08421528f, 0.01632261f, 0.21483058f, 0.12638548f, -0.00740895f, -0.01153769f, 
    -0.04413076f, -0.09948760f, -0.05648317f, 0.06939007f, -0.01085576f, 0.09006544f, 0.01576379f, -0.09165122f, 
    -0.55065233f, -0.28592366f, -0.01155035f, -0.17666130f, 0.08468870f, -0.07872842f, 0.04743765f, -0.02758453f, 
    -0.04038163f, 0.03224197f, 0.01620735f, 0.11300380f, -0.56829244f, -0.38386816f, -0.09080211f, -0.03449845f, 
    0.07934868f, 0.05310462f, -0.05752658f, -0.13571039f, 0.07394198f, -0.04486958f, -0.00237779f, 0.02256152f, 
    0.31065968f, 0.09869098f, -0.03890483f, -0.02617275f, 0.07695759f, -0.07105623f, -0.06789515f, -0.00646210f, 
    -0.02094266f, 0.05936124f, -0.02221794f, 0.05351609f, 0.27006459f, -0.02918749f, -0.14419816f, 0.15207240f, 
    0.05282950f, -0.11640861f, -0.15970118f, 0.04414664f, 0.09151696f, 0.01940900f, 0.00631196f, 0.05204561f, 
    0.08894585f, -0.16767065f, -0.25737908f, 0.13661134f, -0.08622100f, -0.14325565f, -0.00785715f, 0.03580931f, 
    -0.05111786f, 0.01763573f, -0.01471767f, -0.02539236f, 0.34016997f, 0.08170418f, -0.22911425f, 0.06202538f, 
    0.01628421f, -0.05509300f, 0.06641836f, -0.10044888f, 0.05383831f, -0.03521718f, -0.03255185f, -0.05240653f, 
    -0.07397650f, -0.12017478f, 0.11471216f, -0.13600917f, -0.06536526f, 0.14227758f, -0.12108885f, 0.16342080f, 
    -0.00841936f, -0.11869790f, -0.05235603f, -0.15790378f, -0.04500518f, 0.23079142f, -0.01778401f, 0.05708249f, 
    -0.19252698f, -0.00907111f, 0.08448284f, -0.14838170f, -0.08912624f, 0.01746227f, -0.04281948f, -0.11657365f, 
    -0.10240669f, 0.12896667f, -0.19412485f, -0.00887668f, 0.19581345f, -0.07825306f, -0.00885347f, 0.07503288f, 
    -0.03336447f, 0.05121291f, 0.02552116f, 0.04145553f, -0.14052947f, 0.01576424f, -0.08931937f, 0.03847781f, 
    0.13843320f, 0.01257274f, 0.01289952f, 0.01365772f, 0.01849062f, -0.08210546f, -0.03024681f, 0.03741048f, 
    0.13531430f, -0.19579124f, 0.09003398f, 0.17618336f, 0.04279947f, 0.01139241f, -0.00135353f, 0.04519368f, 
    0.04772778f, 0.03904862f, -0.00635902f, -0.06135693f, 0.27425104f, 0.03623306f, -0.21757735f, -0.07615177f, 
    -0.07794379f, -0.01811875f, 0.02901813f, 0.05219414f, 0.04108336f, 0.03676980f, -0.05792632f, -0.03451445f, 
    0.37197068f, -0.28855756f, 0.01957601f, -0.06986520f, 0.05757874f, -0.08227595f, -0.00363432f, 0.01207295f, 
    -0.04790844f, 0.15983875f, -0.03292146f, 0.06467728f, 0.29366249f, 0.15719320f, 0.00977816f, -0.01083952f, 
    -0.02083459f, -0.07259873f, -0.01414722f, 0.01062141f, 0.05968496f, 0.11352514f, -0.01434620f, 0.06386884f, 
    -0.05150760f, 0.03665342f, 0.00434938f, -0.37734705f, 0.05858923f, 0.04669841f, 0.03202837f, 0.01541873f, 
    0.01766799f, 0.03578959f, 0.00014417f, -0.01457221f, 0.26807132f, -0.08960069f, -0.06075175f, -0.07541279f, 
    -0.02789159f, -0.02930138f, 0.06501099f, 0.08359102f, 0.06012997f, -0.02685814f, -0.07549723f, 0.00439882f, 
    -0.43786260f, -0.03364980f, -0.06287234f, 0.02575323f, -0.02103050f, 0.02983943f, 0.02137540f, 0.09565006f, 
    -0.01929663f, 0.03063351f, 0.13429742f, 0.02107284f, -0.36073241f, -0.20279233f, -0.00940571f, -0.19734129f, 
    0.02639576f, 0.03127697f, 0.03464396f, 0.12838368f, -0.05976557f, 0.03556749f, -0.04766390f, -0.14925447f, 
    -0.07343891f, 0.05839366f, 0.04726420f, 0.05566395f, -0.11797015f, 0.06398499f, -0.09020634f, -0.18151629f, 
    -0.09791483f, -0.10916079f, -0.05096838f, -0.12070934f, 0.25258148f, 0.03292139f, -0.04463608f, -0.05378003f, 
    -0.10758708f, -0.04859236f, 0.01465946f, -0.02779821f, -0.06518435f, -0.05303197f, -0.04958210f, -0.06489154f, 
    0.15896915f, -0.16321868f, -0.10321042f, 0.06413436f, -0.01866329f, 0.07879362f, -0.15160277f, 0.00043871f, 
    0.03493597f, 0.04275980f, -0.07638735f, 0.09900302f, -0.06286812f, 0.05736908f, 0.09700487f, 0.00371509f, 
    0.12636125f, -0.04296260f, 0.03061682f, 0.02898736f, 0.00770806f, 0.08457147f, 0.04189588f, 0.11739320f, 
    0.14841338f, -0.12523419f, -0.08279692f, 0.08075294f, -0.10016118f, -0.00352882f, 0.01599942f, -0.08568227f, 
    0.00006006f, -0.09260456f, -0.12112627f, -0.03084638f, 0.21136965f, -0.07556129f, -0.08371488f, -0.08997437f, 
    0.09454320f, 0.04115050f, 0.02486978f, -0.01459309f, -0.07186081f, -0.02211380f, -0.09246749f, -0.05716712f, 
    -0.25726271f, 0.06917146f, -0.02394445f, -0.24381922f, -0.01671052f, 0.01159998f, -0.02168859f, 0.17268729f, 
    -0.12174562f, 0.03480218f, 0.06285617f, -0.03161914f, 0.24114004f, -0.06071596f, 0.01875152f, 0.12175339f, 
    0.01660690f, 0.08224732f, -0.04287058f, 0.04304149f, 0.15260316f, 0.02146869f, 0.03960404f, 0.12875193f, 
    -0.17648725f, -0.33271056f, -0.02596063f, -0.13626891f, -0.01520646f, -0.01573788f, -0.01276877f, -0.07957412f, 
    -0.12647121f, -0.01606997f, -0.12005511f, 0.00674921f, 0.20097840f, 0.06856326f, -0.21570365f, -0.10933354f, 
    0.03090006f, 0.00750215f, -0.03093167f, 0.06209702f, 0.01349672f, -0.07936680f, -0.02454144f, -0.01032758f, 
    0.13118050f, -0.10406448f, -0.00523457f, 0.02316504f, -0.09764811f, 0.10282693f, -0.16552845f, -0.10306323f, 
    -0.08859246f, 0.00482446f, 0.00653362f, -0.13371544f, 0.09143964f, 0.18835698f, 0.00147159f, -0.04875193f, 
    0.12746979f, -0.06091814f, -0.08091837f, 0.05139717f, 0.10215796f, 0.03130163f, 0.07985374f, 0.10995955f, 
    -0.09152018f, 0.08694740f, -0.12251449f, 0.15467322f, -0.03704909f, 0.06405610f, -0.02719012f, 0.09279138f, 
    -0.07241943f, -0.16128632f, -0.10064742f, -0.12139281f, 0.55460364f, -0.01473382f, -0.07457706f, 0.11543793f, 
    -0.13806547f, -0.08103898f, 0.03606274f, 0.00378919f, 0.02257448f, 0.03087637f, 0.07935968f, -0.01870487f, 
    -0.03027536f, -0.11344845f, -0.00335422f, -0.24393672f, -0.06454426f, 0.00274174f, -0.01083287f, -0.03189430f, 
    0.00778487f, -0.04561323f, 0.04518379f, 0.02709012f, -0.05566949f, 0.09285744f, 0.11967708f, -0.14080721f, 
    -0.02002209f, -0.00809118f, -0.04821513f, -0.02396247f, -0.02676193f, -0.18487577f, -0.00669344f, -0.03975592f, 
    0.06311972f, 0.00724970f, -0.11653758f, -0.00441325f, -0.00585728f, -0.03070028f, -0.07490496f, -0.04210035f, 
    -0.16357768f, -0.02232511f, -0.06691765f, -0.07207956f, -0.32897672f, 0.07756434f, 0.02989217f, 0.12850387f, 
    -0.03647944f, 0.00241937f, 0.06465546f, -0.03268107f, 0.05242054f, 0.01623600f, 0.00713568f, 0.00129663f, 
    0.22844380f, -0.11087783f, -0.16976514f, 0.23886289f, 0.05107222f, 0.01508587f, 0.00423864f, -0.01699654f, 
    0.05697267f, -0.00470762f, 0.10403278f, 0.04764795f, -0.09864547f, 0.00049365f, 0.04712078f, 0.09708310f, 
    -0.05024919f, -0.03710127f, 0.02702876f, -0.03188424f, -0.03266659f, -0.06625762f, 0.00984163f, -0.09237989f, 
    0.10728046f, 0.04673610f, 0.04591439f, -0.07149456f, 0.08356121f, -0.09754032f, 0.05660392f, -0.03284983f, 
    -0.00341473f, 0.00279075f, 0.09027009f, 0.09287764f, 0.03899172f, -0.19118020f, -0.02586413f, -0.04869055f, 
    -0.04312135f, -0.11913686f, 0.02683071f, -0.04540185f, -0.03956793f, 0.06019441f, -0.02563373f, -0.07896633f, 
    0.01001138f, -0.18439262f, 0.01649347f, 0.05562400f, -0.01575521f, -0.00491150f, -0.11785018f, -0.01623162f, 
    -0.00239166f, -0.08598451f, -0.01357172f, -0.06201953f, 0.21590012f, -0.07725260f, -0.13958114f, 0.08432635f, 
    -0.16889998f, -0.11752554f, -0.05805847f, -0.10321549f, -0.05919797f, 0.02829235f, -0.02186306f, -0.08498161f, 
    -0.29730684f, 0.11330916f, 0.10835263f, 0.03835557f, 0.02830718f, 0.00025574f, -0.03076870f, 0.08723231f, 
    0.05162710f, 0.04382370f, 0.00219836f, -0.01218562f, 0.41184270f, 0.06464855f, -0.01789945f, -0.12493090f, 
    0.07367822f, -0.13746417f, -0.04632973f, 0.02730699f, 0.06230393f, 0.14901486f, 0.05821212f, -0.03076303f, 
    0.09585771f, 0.03692256f, -0.08303533f, 0.22125879f, 0.07124919f, 0.01032689f, 0.02847065f, 0.08200391f, 
    0.00829543f, 0.08176392f, -0.04380842f, -0.01149490f, -0.02411302f, -0.13509700f, 0.09591502f, -0.05077052f, 
    -0.23314692f, -0.05936721f, -0.03903171f, 0.03401069f, -0.08990204f, -0.17461106f, 0.00114282f, 0.04168773f, 
    0.09165045f, 0.03896988f, -0.15340947f, 0.08260483f, -0.05290800f, 0.00024431f, -0.07852902f, 0.05869652f, 
    0.12427099f, -0.05971916f, -0.06301198f, -0.05919442f, 0.06229481f, -0.06116705f, -0.09074122f, 0.07619308f, 
    0.02633641f, -0.05314985f, 0.01687836f, -0.05960517f, 0.01783160f, 0.04527340f, -0.06983919f, 0.00445979f, 
    -0.01188974f, -0.04770504f, -0.02237791f, 0.02970128f, -0.00576776f, 0.08912069f, 0.06060870f, 0.00462064f, 
    0.09279663f, 0.02007214f, 0.04815986f, 0.06784149f, -0.09798839f, 0.23914672f, -0.09809398f, 0.09418058f, 
    0.10454404f, -0.06562976f, -0.09071310f, -0.15222992f, -0.05656486f, -0.04075383f, 0.02595271f, 0.04131844f, 
    0.01842721f, 0.12458848f, -0.00645297f, -0.08850536f, 0.01967083f, 0.07394908f, -0.09471941f, 0.06933257f, 
    -0.11842658f, -0.02913895f, 0.00269171f, -0.13944814f, -0.32802588f, 0.21669076f, -0.04162208f, 0.09233049f, 
    0.11899201f, -0.04767145f, -0.00141073f, 0.02780767f, 0.06851941f, -0.06265296f, 0.05272078f, 0.09446876f, 
    -0.14894862f, 0.06619550f, -0.07201085f, 0.09915061f, 0.02306162f, -0.08726043f, -0.05079132f, 0.02899593f, 
    0.01627746f, -0.04839337f, -0.02288837f, -0.00429076f, 0.09827100f, -0.03777973f, -0.02098162f, 0.11543104f, 
    -0.16148558f, -0.10464468f, 0.00082100f, -0.06423511f, -0.05516188f, 0.03382053f, -0.04930409f, -0.10188074f, 
    -0.12173395f, -0.09290268f, 0.02862446f, 0.06064477f, -0.08573841f, 0.12585233f, -0.04816782f, 0.13843939f, 
    -0.01344876f, 0.02193501f, 0.06827055f, 0.07754003f, -0.33971429f, 0.06361900f, -0.00842177f, 0.06982738f, 
    -0.03629470f, -0.01413707f, -0.03541581f, 0.18587589f, -0.15149076f, 0.02472469f, -0.06294525f, -0.07524829f, 
    0.16446508f, -0.10029608f, -0.11880928f, 0.10380113f, 0.06669980f, -0.07361984f, 0.02976175f, 0.03650960f, 
    -0.05334024f, 0.12069590f, -0.10527831f, -0.15948729f, 0.04190442f, -0.17101054f, 0.17770335f, -0.11565713f, 
    0.03268759f, -0.00078913f, 0.02374545f, 0.03363870f, -0.15233985f, 0.00151532f, 0.18000986f, 0.09542564f, 
    0.07645629f, -0.08760925f, -0.09061399f, 0.03038751f, -0.00337802f, -0.01233104f, 0.12942344f, -0.01457480f, 
    -0.03629256f, 0.04408394f, -0.09789352f, -0.05696538f, -0.07396743f, 0.14597444f, -0.10124916f, -0.02737561f, 
    0.06532115f, -0.03637445f, -0.01408201f, -0.10170677f, 0.07253396f, 0.09364312f, -0.01411618f, -0.02521799f, 
    -0.00769804f, -0.13985328f, -0.10316198f, 0.09551684f, -0.09378894f, 0.09378837f, -0.00144475f, -0.04181957f, 
    0.02680179f, 0.03867285f, 0.09784676f, 0.04658030f, -0.41847247f, 0.06672565f, 0.07611026f, -0.18510725f, 
    0.03004449f, 0.00344807f, -0.02223163f, 0.02361586f, 0.02446524f, 0.06193636f, 0.04047342f, 0.08145480f, 
    -0.19542283f, -0.05140982f, -0.10282012f, 0.03095584f, 0.11607721f, 0.04210844f, 0.01543697f, 0.01779081f, 
    -0.03813636f, -0.11550770f, -0.10597421f, -0.02094181f, -0.13061681f, 0.01052042f, -0.01673601f, -0.00858143f, 
    -0.01830642f, 0.07990041f, 0.13659537f, 0.03243285f, 0.06591514f, 0.01166461f, -0.01508029f, 0.03442183f, 
    0.33438975f, -0.11385368f, -0.11760730f, -0.07423149f, 0.10815972f, -0.09216875f, 0.01416770f, 0.04346488f, 
    -0.05621615f, -0.00598076f, -0.02101866f, -0.01861415f, 0.09798197f, 0.10477930f, -0.10275115f, -0.15862344f, 
    0.02296423f, -0.00945875f, -0.04474808f, 0.07348365f, 0.02395915f, 0.00112684f, 0.02486374f, -0.02845166f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04451656f, -0.01298199f, -0.05192037f, 0.01871105f, 0.02814817f, 0.04899701f, 0.01484592f, -0.07402512f, 
    -0.00874303f, -0.00650854f, 0.09676296f, 0.04837186f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
