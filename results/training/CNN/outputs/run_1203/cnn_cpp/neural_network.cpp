#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.28275657f, -0.05297719f, 0.57449681f, -0.44843978f, -0.06785449f, -0.19801921f, 0.42499283f, -0.03824638f, 
    0.37589756f, -0.05255476f, 0.19429836f, -0.13974890f, -0.28615424f, -0.23765701f, -0.54784173f, 0.69672203f, 
    0.22986507f, 0.24818933f, -0.41648245f, 0.18143716f, 0.17678724f, -0.69287199f, -0.32191834f, 0.51331359f, 
    0.16175386f, 0.26836255f, 0.31682131f, 0.28691038f, 0.19625092f, 0.24719815f, -0.36009380f, 0.98678863f, 
    -0.64600664f, -0.19887635f, 0.24147491f, -0.00294100f, 0.44468915f, 0.49262193f, 0.33502910f, 0.43248892f, 
    -0.46644470f, -0.36601397f, -0.16349475f, -0.19430928f, -0.00344428f, 0.43643767f, 0.66577393f, -0.56261557f, 
    -0.08352584f, -0.32883209f, -0.05941013f, -0.12390604f, 0.26918569f, 0.07900132f, 0.92526752f, -0.04848989f, 
    0.37261871f, -0.61708027f, -0.00224676f, -0.28795117f, 0.16281293f, 0.02519053f, -0.06635914f, -0.78705299f, 
    0.21974906f, 0.16181690f, 0.69385195f, -0.04079055f, 0.34305042f, 0.17432551f, 0.27198288f, 0.49504060f, 
    0.05754892f, 0.07033525f, 0.33057404f, -0.06966464f, -0.00365756f, 0.11661027f, -0.43495521f, 0.74227268f, 
    -0.46345890f, 0.14977156f, 0.57822192f, -0.29764172f, 0.16770473f, 0.23859437f, 0.42143854f, 0.38826358f, 
    -0.00372192f, -0.20213033f, -0.48224029f, -0.60218614f, 0.18110952f, 0.04554012f, 0.23599078f, -0.41145507f, 
    -0.10380161f, 0.07438784f, 0.53501177f, 0.50580198f, -0.49509966f, -0.34854218f, 0.04401534f, 0.37479776f, 
    0.02932172f, -0.36750782f, -0.32505724f, -0.70318776f, -0.24224272f, 0.02412505f, -0.35746041f, -0.32298785f, 
    -0.45217761f, -0.59619784f, 0.08583009f, -0.50148988f, 0.43808928f, -0.87006205f, -0.15995009f, 0.77168775f, 
    -0.05563664f, -0.18948090f, -0.36612204f, -0.02444523f, -0.09547671f, -0.32845098f, -0.43118107f, -0.64252114f, 
    -0.47139269f, 0.67380673f, 0.44842026f, 0.40547636f, -0.05732999f, -0.21173665f, -0.11621057f, 0.28939629f, 
    -0.00920750f, 0.32142162f, 0.03469452f, -0.11897814f, 0.82912290f, 0.14519377f, 0.20648994f, -0.09125572f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03864047f, -0.26906690f, 0.02022420f, -0.21647890f, -0.19100554f, 0.08978621f, -0.10068149f, -0.28694984f, 
    0.42438793f, 0.32252252f, 0.25012505f, -0.04686736f, -0.16993579f, -0.04719615f, 0.09343667f, 0.31437302f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.12801240f, -0.54152644f, 0.00597595f, -0.00441201f, -0.12957275f, -0.22798757f, -0.01770186f, 0.16916159f, 
    0.05561443f, -0.46684521f, -0.20193744f, -0.34645680f, -0.08941284f, 0.04670516f, -0.18948889f, -0.08039223f, 
    -0.01825230f, -0.13006602f, 0.06600735f, -0.08495165f, -0.38726518f, -0.39549169f, -0.01638587f, 0.05936386f, 
    0.07085320f, 0.11264858f, 0.00052140f, 0.00747086f, -0.30456761f, 0.38508916f, 0.03781231f, 0.03042377f, 
    0.02146604f, -0.17642456f, 0.02528591f, 0.09391065f, -0.29071715f, -0.21874867f, 0.00855921f, 0.00331613f, 
    0.28589192f, -0.08529063f, 0.10441083f, -0.03948801f, 0.00326440f, 0.44065285f, -0.12600487f, -0.02052192f, 
    -0.04886853f, -0.06596802f, -0.10304009f, 0.11554076f, 0.11373505f, -0.06723244f, 0.22952539f, -0.17150001f, 
    -0.24850915f, -0.04698044f, 0.02511983f, 0.06357829f, -0.02530623f, 0.18042362f, -0.00002047f, -0.40353382f, 
    -0.12215503f, 0.14752801f, -0.23640318f, 0.04999127f, -0.18546012f, 0.15317672f, -0.08195263f, 0.03102219f, 
    0.24690232f, -0.08378174f, 0.05156930f, 0.03627340f, 0.03730196f, 0.04732504f, 0.04135439f, 0.05981822f, 
    0.16394499f, 0.08601812f, 0.07504253f, -0.17226495f, -0.00751917f, 0.09247224f, -0.04426983f, 0.11353780f, 
    0.01770506f, 0.22840637f, 0.01157934f, 0.02187482f, 0.20766397f, 0.23628889f, 0.10485474f, -0.07795796f, 
    0.14201921f, 0.02824879f, 0.04202276f, -0.08507714f, 0.09011836f, 0.12825960f, -0.18580820f, -0.00049992f, 
    -0.02453677f, 0.26443264f, -0.09536424f, 0.23681316f, -0.30810744f, -0.35255450f, -0.20224957f, 0.02457609f, 
    -0.06145808f, -0.19263880f, -0.06536832f, -0.08596922f, 0.07499951f, 0.03848222f, -0.35826513f, -0.23547620f, 
    -0.08948132f, 0.03560861f, -0.09761021f, 0.06319870f, 0.05661842f, 0.22654845f, -0.29447860f, 0.18120332f, 
    0.24418190f, 0.06455385f, 0.07367984f, 0.05591429f, -0.06872967f, 0.08948714f, 0.16319881f, 0.03479862f, 
    0.20700346f, 0.04953615f, -0.02340829f, 0.04935609f, 0.03589406f, 0.07574854f, -0.02241327f, 0.12748532f, 
    -0.07033325f, 0.01563254f, -0.07153837f, 0.00552907f, 0.06725170f, -0.01472253f, 0.04499988f, 0.02321219f, 
    0.01276542f, -0.01016186f, -0.03483989f, 0.04963901f, -0.04013847f, 0.06096556f, 0.06754900f, -0.06218959f, 
    0.03997801f, -0.07505439f, 0.04016797f, -0.01473390f, -0.00556751f, 0.07039550f, -0.05401425f, 0.02133356f, 
    -0.07629437f, -0.04508093f, 0.04062080f, -0.08687164f, -0.04703657f, 0.04988484f, 0.04316493f, 0.00800795f, 
    -0.07361080f, -0.07019466f, -0.03991378f, -0.06922420f, 0.00566942f, 0.01576002f, -0.04990394f, -0.05432134f, 
    0.06651162f, 0.02271108f, 0.05506121f, 0.01731474f, -0.00167297f, -0.03072228f, 0.06165351f, -0.06915398f, 
    -0.04028431f, 0.03422021f, -0.08463565f, -0.04914305f, -0.01998824f, 0.03272743f, 0.02594987f, -0.04748992f, 
    -0.08398601f, -0.07877452f, -0.03790466f, 0.03419368f, -0.01834183f, -0.06916936f, 0.00136976f, -0.03184589f, 
    0.08082814f, -0.02524684f, -0.08022352f, 0.06685950f, -0.07694547f, 0.06144602f, 0.02020890f, -0.07787494f, 
    -0.04377471f, -0.01333869f, 0.00462651f, 0.03949176f, -0.06848533f, -0.00525512f, 0.06024370f, -0.05194609f, 
    -0.00642480f, 0.02716605f, -0.06573164f, -0.05714092f, 0.00511409f, -0.01865632f, -0.06544901f, 0.04707795f, 
    0.03233332f, 0.04103909f, 0.02788482f, 0.05021648f, -0.00407605f, -0.01858471f, -0.03077932f, 0.05092409f, 
    0.06042243f, -0.04909037f, 0.01955494f, -0.00990208f, 0.02014326f, -0.09386455f, -0.09009944f, 0.01854880f, 
    0.06856623f, 0.02854302f, -0.07663625f, 0.05983587f, 0.04468945f, 0.03006659f, -0.04550401f, -0.09025746f, 
    -0.08947396f, -0.01594494f, 0.02670177f, 0.03332696f, -0.06134572f, 0.01240547f, -0.10414521f, -0.07674085f, 
    -0.04780925f, 0.01031259f, 0.06118717f, -0.06550473f, 0.03161219f, -0.02492883f, -0.05683084f, 0.00973911f, 
    0.05530443f, -0.06796222f, 0.00073796f, -0.05946765f, -0.02994097f, -0.03253697f, 0.06440854f, -0.00130508f, 
    -0.00491991f, 0.05124103f, -0.08431910f, 0.02218335f, -0.05940576f, -0.05721352f, -0.04157659f, -0.03702345f, 
    -0.02415603f, -0.17689896f, 0.15443406f, -0.07877865f, 0.14738323f, -0.22768301f, 0.06168199f, 0.13995990f, 
    0.03238312f, 0.32100874f, 0.40762937f, 0.14600633f, -0.04478347f, 0.08740730f, -0.19533254f, 0.00240217f, 
    0.18267781f, 0.06269945f, -0.33521521f, -0.26298645f, 0.20003089f, -0.10892022f, 0.02333102f, -0.10902827f, 
    0.11352781f, -0.07975824f, -0.06506421f, -0.32453474f, -0.61130351f, -0.16855104f, 0.03311843f, -0.08263309f, 
    0.14436056f, 0.01629808f, -0.08064105f, 0.05029247f, 0.20193377f, -0.23740458f, -0.16234776f, -0.00229851f, 
    0.02408673f, 0.03050667f, 0.03327795f, 0.07509318f, -0.09559293f, -0.02789788f, -0.25487018f, -0.55535352f, 
    -0.25869507f, 0.10764318f, -0.04850341f, 0.03478122f, 0.09945992f, -0.07689438f, 0.08416071f, -0.41670540f, 
    -0.30485699f, -0.05607135f, -0.05173075f, -0.18963954f, 0.00460269f, -0.05230092f, 0.06087636f, -0.24699919f, 
    -0.11993171f, -0.44660318f, -0.03351994f, -0.21579382f, -0.09278043f, 0.13133718f, -0.03631238f, 0.05171263f, 
    -0.29517236f, -0.22459751f, -0.05633347f, 0.20988996f, 0.17617157f, -0.02643995f, 0.00336901f, 0.10327977f, 
    0.14772023f, -0.14446247f, 0.42199999f, -0.26620287f, 0.08827149f, -0.10283814f, 0.00510079f, 0.01548653f, 
    0.09888311f, 0.08981921f, 0.24132989f, 0.28330949f, -0.10369531f, -0.07334042f, 0.00426130f, 0.24899317f, 
    -0.09060255f, 0.09517439f, 0.10526304f, 0.23215368f, -0.19857949f, 0.21934085f, -0.03018991f, -0.18564536f, 
    0.07224929f, 0.09173498f, -0.00635031f, -0.08009718f, 0.30977580f, 0.40566805f, 0.31858310f, -0.05002204f, 
    0.11429928f, -0.13302507f, 0.02034760f, 0.07967045f, -0.03095036f, -0.06166763f, 0.19046980f, -0.02577434f, 
    -0.27245724f, -0.14789282f, 0.12709177f, 0.06872645f, 0.10835789f, -0.13820851f, 0.28967178f, -0.25337511f, 
    0.18414718f, -0.12432471f, -0.05480875f, 0.09827482f, 0.05301277f, 0.02852721f, 0.01133830f, 0.15999144f, 
    0.21860896f, -0.30283201f, -0.16766016f, -0.06080120f, 0.02408103f, -0.01530199f, 0.07566629f, 0.07983503f, 
    0.12979151f, 0.14287160f, 0.13964003f, 0.03206792f, 0.15941589f, 0.01949942f, -0.06718363f, 0.27565795f, 
    0.33010232f, -0.19255346f, -0.09229118f, -0.32971182f, -0.05465491f, -0.09168887f, 0.23966472f, 0.13547081f, 
    0.35943794f, 0.26085451f, 0.13577859f, 0.01794848f, 0.17691989f, 0.15901154f, 0.09022887f, -0.03288596f, 
    0.13453428f, 0.22268495f, 0.33736876f, 0.13476384f, -0.37271085f, 0.09960781f, 0.08489809f, 0.12480361f, 
    -0.18915360f, 0.30769828f, -0.02111745f, 0.02763093f, -0.19290879f, -0.08760317f, 0.09030972f, 0.09292372f, 
    0.15450633f, 0.06535477f, -0.03653669f, -0.09320181f, 0.00861855f, -0.01595213f, -0.27316982f, 0.15746632f, 
    0.17422093f, 0.09050328f, 0.13107464f, 0.02026475f, 0.15843795f, 0.14732504f, 0.13104619f, 0.03921028f, 
    0.13706233f, 0.12781319f, 0.08329573f, 0.03854000f, 0.05776370f, -0.08910549f, 0.17140751f, -0.05795516f, 
    0.12491824f, 0.08978619f, 0.35398805f, 0.04268157f, -0.02325233f, -0.02077392f, 0.12615177f, 0.02107165f, 
    0.14114259f, -0.11748423f, 0.17826964f, 0.05591693f, -0.01185070f, 0.00631263f, -0.03318145f, -0.07134835f, 
    -0.04110574f, 0.03102805f, -0.15676323f, -0.04360168f, 0.18666531f, 0.11326530f, 0.01456717f, -0.04236006f, 
    0.06330650f, -0.14610606f, 0.14245801f, 0.15912594f, 0.18327266f, -0.00991774f, -0.04292308f, -0.01604353f, 
    0.15746687f, -0.14956331f, 0.11634494f, -0.11247177f, -0.11741212f, -0.09575608f, -0.19246942f, -0.03772969f, 
    -0.09213708f, -0.25557879f, -0.19829561f, -0.51241010f, 0.01259091f, -0.03062811f, -0.07008392f, 0.22947155f, 
    0.11186001f, -0.07168050f, 0.14097059f, -0.03238880f, -0.18797153f, -0.20029908f, -0.00124844f, 0.19667789f, 
    0.10784824f, 0.00436896f, 0.15305062f, -0.17693165f, -0.02948061f, -0.16753450f, -0.12889700f, -0.10807388f, 
    0.00133575f, 0.13631390f, -0.15337269f, -0.07007810f, -0.05232742f, -0.26698673f, -0.06085450f, 0.06148734f, 
    -0.12180466f, 0.11381725f, 0.16224021f, -0.08161573f, 0.04274136f, -0.16008861f, -0.07710208f, -0.02422924f, 
    -0.05443204f, 0.09970908f, 0.18387857f, 0.01574357f, 0.05169486f, -0.09896529f, 0.06975271f, 0.11866531f, 
    -0.19126095f, -0.42500922f, -0.26190367f, 0.17950639f, -0.05384723f, -0.03389216f, -0.02617834f, -0.05362362f, 
    -0.04739343f, 0.20206143f, -0.08682618f, -0.10854758f, -0.35093293f, 0.06086221f, 0.02705302f, -0.04545533f, 
    0.15932007f, 0.02294736f, 0.27088791f, 0.01081229f, -0.14359222f, 0.16675472f, -0.01220147f, -0.11219855f, 
    -0.25839522f, 0.20376515f, -0.15711190f, -0.03897963f, -0.21592270f, -0.04357038f, -0.08161699f, -0.12937760f, 
    -0.11787930f, -0.15439206f, 0.09916025f, -0.02385457f, 0.15499055f, -0.28589517f, -0.14564629f, 0.17874995f, 
    0.00491427f, 0.01688959f, 0.19465266f, -0.03837591f, 0.10824653f, 0.19165641f, 0.37299272f, 0.02497396f, 
    -0.06733198f, -0.18761596f, -0.00143079f, -0.14061825f, -0.18096676f, 0.06724477f, 0.14269753f, 0.12093804f, 
    -0.14779201f, -0.28359249f, -0.18770614f, 0.09339394f, -0.04408964f, 0.01813808f, -0.01299215f, 0.04629998f, 
    0.29742625f, 0.19456983f, 0.51615030f, -0.01010573f, 0.04015271f, -0.13374841f, 0.11553008f, 0.02985011f, 
    0.15624401f, 0.11329909f, 0.23761697f, 0.14428274f, 0.06990547f, -0.19439870f, -0.00635837f, 0.06276620f, 
    0.01356190f, -0.03237631f, 0.10405554f, -0.03318067f, -0.08226483f, 0.08349435f, 0.19793940f, 0.05317240f, 
    0.04644023f, 0.14487359f, -0.03216328f, -0.30742615f, -0.22509651f, 0.05963377f, 0.00614791f, -0.05032598f, 
    0.07042807f, -0.00379513f, 0.00632864f, -0.11600627f, -0.07651178f, -0.12896265f, -0.13345353f, -0.14910060f, 
    0.07619330f, -0.20118564f, 0.03442818f, -0.00117733f, 0.11547121f, -0.10494029f, -0.11005659f, -0.15976807f, 
    -0.21406363f, 0.16688453f, 0.07910347f, 0.00277584f, 0.16211341f, 0.00983202f, -0.34209734f, -0.40382621f, 
    -0.71979624f, 0.01925703f, -0.03849030f, 0.08545484f, -0.05279392f, -0.25739154f, -0.08240550f, 0.13758954f, 
    0.26847959f, 0.30807281f, -0.07936050f, -0.16486135f, -0.09319712f, -0.02960344f, -0.15836442f, 0.14931110f, 
    -0.08335198f, -0.34749341f, 0.22959417f, 0.00460230f, 0.13714260f, -0.27873355f, 0.01753354f, -0.04356447f, 
    -0.24610890f, -0.27047643f, -0.12222361f, -0.16600947f, -0.01523974f, -0.11056389f, -0.11373284f, 0.15746891f, 
    0.02441085f, -0.26807737f, -0.33937365f, 0.18983446f, -0.32950348f, 0.08338370f, -0.12010703f, -0.12923227f, 
    0.00269860f, 0.08156217f, -0.09652787f, -0.25602385f, 0.01774840f, 0.38380736f, 0.28675669f, -0.16480842f, 
    -0.23936260f, 0.08944590f, -0.20148034f, -0.10538106f, -0.05353353f, 0.03845494f, 0.04322798f, -0.10258427f, 
    0.02177232f, -0.02831503f, 0.13177788f, 0.08098841f, -0.15135218f, 0.45947409f, 0.03172737f, 0.17740579f, 
    -0.04691703f, 0.22779316f, 0.29183966f, -0.00328259f, 0.06164390f, 0.12399649f, 0.08473016f, 0.13288046f, 
    -0.14145598f, -0.12753111f, 0.07884651f, 0.28790829f, -0.17683463f, 0.03754682f, -0.00766965f, -0.04622896f, 
    -0.13540505f, 0.19367822f, 0.15113263f, 0.03868703f, 0.07390762f, 0.15830602f, 0.06531121f, -0.04154526f, 
    -0.29162425f, 0.05988872f, 0.50058085f, -0.06919163f, 0.06455983f, 0.05371827f, -0.02777408f, 0.19430202f, 
    0.32529569f, -0.13266844f, -0.38775367f, -0.04891870f, 0.05344417f, 0.07355755f, 0.10311668f, -0.01331327f, 
    0.17047207f, -0.01384355f, -0.05817176f, -0.25409552f, 0.25991595f, -0.05326928f, -0.02249793f, -0.16730683f, 
    0.06831124f, 0.02540343f, 0.03406561f, -0.14060664f, -0.05619966f, 0.04551709f, 0.15781319f, -0.14901763f, 
    0.16032675f, -0.08743079f, -0.05912074f, 0.25118265f, -0.10818370f, 0.22532502f, 0.47582239f, -0.16868104f, 
    -0.12368802f, 0.09274212f, -0.00291716f, -0.01278306f, 0.03254914f, -0.34311062f, 0.01998844f, 0.48502392f, 
    -0.14728032f, 0.12263972f, -0.10060872f, -0.10886932f, -0.06659921f, 0.10035082f, -0.76331961f, 0.12176820f, 
    0.05007618f, 0.00943346f, 0.06370516f, -0.06143286f, 0.02326501f, -0.02081399f, 0.08758301f, -0.56437218f, 
    -0.00953329f, -0.05999209f, -0.08809309f, -0.27350748f, -0.20933172f, -0.04563476f, -0.02608351f, 0.09902924f, 
    0.05399975f, -0.02077724f, 0.00290493f, 0.03755392f, 0.00874062f, 0.04263575f, -0.05176987f, -0.04201659f, 
    -0.09040100f, -0.00359430f, 0.04311141f, 0.00995164f, 0.00296283f, 0.04776622f, 0.02670257f, -0.03501116f, 
    0.10165258f, -0.02889431f, 0.01248469f, -0.00871284f, 0.02771784f, -0.05714137f, -0.03366690f, -0.07730926f, 
    -0.04771801f, -0.01738136f, 0.01223399f, -0.12008623f, -0.00214402f, -0.05684886f, -0.06358806f, -0.05102345f, 
    -0.00765133f, -0.02396435f, 0.03830575f, 0.05420884f, -0.03855420f, 0.02857384f, -0.10028766f, -0.04385373f, 
    -0.09930541f, -0.02995113f, 0.01409134f, -0.08667609f, -0.04920042f, -0.06768269f, 0.00165448f, -0.06697825f, 
    -0.05043750f, -0.05094464f, 0.01793807f, -0.09456455f, -0.05020554f, 0.04947655f, -0.10327325f, -0.00613857f, 
    0.04301662f, -0.11797563f, 0.00317840f, -0.01224323f, -0.08659987f, 0.02609877f, -0.08059304f, -0.00860756f, 
    -0.02047831f, -0.03020234f, 0.01762175f, 0.02802564f, 0.04592247f, -0.06308013f, -0.04856827f, -0.02830877f, 
    -0.09864088f, -0.02885471f, -0.07236767f, -0.08676010f, -0.03283938f, -0.06268183f, -0.05995609f, -0.08623662f, 
    0.02274163f, -0.08976210f, 0.03530053f, -0.06471153f, -0.10189507f, -0.07127599f, 0.02712092f, 0.01787848f, 
    -0.03957330f, 0.04406914f, -0.00240261f, 0.02524844f, -0.08457680f, -0.02407212f, -0.05806883f, 0.03999748f, 
    -0.05566302f, -0.09767868f, -0.02522982f, 0.00636385f, -0.09187811f, -0.07049648f, -0.10568899f, -0.09991205f, 
    -0.08414861f, -0.04040296f, -0.03598278f, -0.09312799f, -0.10636835f, -0.06154529f, -0.01306244f, -0.01509736f, 
    0.05714403f, 0.06664901f, -0.06411691f, -0.06641245f, 0.02877908f, -0.10007947f, -0.10107467f, -0.03404621f, 
    0.03651138f, -0.09592277f, -0.08547249f, -0.07808621f, -0.10317562f, -0.02954618f, -0.06374624f, -0.09771135f, 
    -0.06146971f, -0.10451204f, 0.05059689f, 0.03264742f, -0.07485464f, 0.03117890f, -0.00396873f, -0.01117057f, 
    0.03645331f, -0.06311301f, -0.08970442f, 0.03488389f, -0.04387757f, 0.00651910f, -0.04815571f, -0.01165018f, 
    -0.23112187f, 0.15290502f, 0.04249267f, -0.00269096f, 0.14786263f, -0.09866535f, -0.15769394f, 0.20005396f, 
    0.15008689f, -0.04504550f, 0.22003265f, 0.10865239f, -0.27344242f, 0.04181443f, 0.20712730f, 0.02350619f, 
    -0.21193929f, 0.21625116f, -0.27305168f, 0.05944305f, 0.15737979f, 0.14891969f, -0.06691569f, -0.06365016f, 
    0.02531523f, -0.18257968f, 0.09230455f, -0.33814996f, 0.20735228f, 0.08387543f, -0.10023963f, 0.01200219f, 
    -0.13978836f, -0.06444739f, 0.10756525f, 0.29497430f, -0.11108071f, -0.38888973f, -0.16478074f, -0.00765264f, 
    -0.01345473f, 0.08595321f, 0.12305358f, -0.14304577f, -0.21778305f, -0.37873676f, 0.07695947f, -0.25366959f, 
    0.11892831f, 0.20818062f, 0.09802149f, -0.11687344f, 0.15738286f, 0.13194683f, -0.44567245f, -0.17808920f, 
    0.00257775f, -0.12479711f, 0.02189427f, 0.11871643f, -0.22869183f, -0.08732805f, 0.07768258f, 0.00187982f, 
    -0.39632595f, -0.15523674f, -0.03905492f, -0.13997224f, -0.13772948f, 0.03371080f, -0.07777877f, 0.04136591f, 
    -0.10740694f, 0.18881193f, 0.29679635f, 0.14799839f, 0.15803853f, 0.01989427f, 0.06801772f, 0.13318355f, 
    0.13230968f, -0.12364759f, -0.07961670f, 0.16683097f, 0.13297789f, -0.01755492f, -0.15341072f, 0.04864372f, 
    0.13422470f, -0.00866143f, 0.05237952f, 0.10369318f, 0.00176427f, 0.00371543f, 0.00194221f, -0.01642018f, 
    0.07848287f, 0.24467997f, 0.11550034f, -0.04395527f, -0.06544140f, -0.02122205f, 0.10008599f, 0.07747199f, 
    -0.02020294f, 0.12688784f, -0.12182041f, -0.02435650f, 0.09685628f, 0.04631688f, 0.32771379f, -0.09146905f, 
    0.13295807f, -0.08859885f, 0.12411493f, -0.06301341f, 0.01642471f, -0.12355802f, 0.05997549f, -0.02801051f, 
    -0.01234087f, 0.08752298f, 0.22953796f, 0.00809636f, 0.11425269f, -0.06342362f, -0.09463318f, -0.22416937f, 
    -0.04365575f, -0.11502235f, 0.03313679f, -0.15830049f, 0.02473154f, -0.09353349f, -0.07800166f, -0.22603236f, 
    -0.06123265f, 0.12452063f, 0.10266237f, -0.18611510f, -0.20361911f, 0.03296397f, -0.13894281f, 0.12954865f, 
    0.00542219f, -0.20703340f, -0.10484970f, 0.13823171f, -0.03187063f, 0.13747004f, 0.09770107f, 0.10633733f, 
    -0.19272970f, 0.20119408f, 0.14922184f, 0.01307632f, 0.06261176f, -0.11031011f, -0.08779308f, -0.01553332f, 
    -0.19744281f, -0.35953876f, 0.04736380f, -0.00279821f, -0.05598250f, 0.07474537f, -0.03049518f, 0.04757456f, 
    -0.15142125f, -0.15060185f, -0.02728998f, 0.21438523f, 0.23724605f, -0.13999274f, 0.03248733f, -0.08736991f, 
    0.31684148f, 0.04320039f, -0.04439029f, 0.12985103f, 0.30179477f, 0.14404821f, 0.03421632f, 0.05715245f, 
    -0.02899103f, -0.00416327f, 0.00593995f, 0.14068884f, -0.06303562f, -0.00350003f, 0.10905609f, -0.11864410f, 
    0.11817410f, -0.10207106f, -0.05349515f, -0.02176998f, -0.08838255f, -0.02954816f, -0.08754897f, 0.26255617f, 
    -0.32828543f, -0.03905204f, -0.15926704f, 0.19526382f, 0.07669596f, 0.00887173f, -0.00928879f, 0.03354847f, 
    -0.15714589f, 0.06123161f, 0.10790691f, 0.06569610f, 0.22402352f, -0.00070376f, -0.08342639f, -0.18523781f, 
    -0.05017800f, -0.00518616f, -0.22011749f, -0.04370486f, -0.00948737f, -0.01674273f, 0.22212072f, -0.06041887f, 
    -0.01282594f, -0.01854365f, -0.04840850f, -0.18323407f, 0.02249210f, 0.06327794f, 0.05019142f, -0.03127217f, 
    -0.09585002f, -0.05325276f, 0.07466736f, -0.14496128f, -0.16339590f, 0.19313128f, -0.00001321f, -0.01686594f, 
    0.03216412f, 0.07227443f, -0.25265983f, -0.05552147f, 0.16294131f, 0.09113950f, -0.01918246f, 0.17499574f, 
    0.21387014f, 0.09303911f, 0.18345618f, 0.17130964f, 0.22550425f, 0.12080293f, 0.17192979f, 0.40795928f, 
    -0.04310013f, 0.08072910f, 0.04241197f, -0.05229883f, -0.14920013f, 0.08075102f, 0.23161466f, 0.13038695f, 
    0.20067534f, 0.03348341f, 0.02058508f, 0.05497722f, 0.07483508f, 0.01983091f, -0.25886154f, -0.22655796f, 
    0.18066762f, 0.06734716f, 0.02718933f, 0.12398273f, 0.01689883f, 0.01838715f, 0.26295841f, 0.22216250f, 
    0.01464275f, -0.01767828f, 0.07839328f, -0.01351107f, -0.05867954f, -0.09443258f, 0.14835250f, -0.05071783f, 
    -0.09308791f, 0.01670273f, 0.29671925f, -0.06622652f, -0.00286307f, 0.04393635f, -0.04499023f, 0.02093893f, 
    -0.05491889f, 0.22054555f, 0.15988941f, 0.05213417f, -0.16153130f, -0.11259326f, 0.05340945f, 0.03229436f, 
    0.01767306f, 0.04832234f, -0.26967129f, 0.08252739f, 0.02086824f, -0.02917201f, 0.06165057f, -0.27289394f, 
    -0.00410023f, 0.04730545f, 0.00175259f, -0.14852919f, -0.00165891f, 0.32735613f, 0.01248512f, -0.11627121f, 
    0.06055171f, 0.12404649f, 0.03141556f, -0.18964128f, 0.12039449f, -0.17496580f, 0.12253847f, -0.15897417f, 
    0.04054539f, -0.09558205f, 0.06801584f, -0.07400769f, 0.11478298f, -0.21052328f, 0.02554085f, -0.07062958f, 
    0.01466821f, -0.10769138f, 0.24223429f, -0.13831222f, 0.02200663f, 0.15846269f, -0.29000533f, -0.36195618f, 
    -0.01713784f, -0.07445343f, 0.15120488f, 0.13877453f, -0.08467948f, 0.10870905f, -0.09606817f, 0.58073139f, 
    0.09376497f, 0.10137943f, -0.20320426f, -0.02195150f, -0.14550437f, 0.14922737f, 0.05576259f, -0.01651028f, 
    -0.23664908f, 0.08256686f, 0.25259173f, -0.18634640f, -0.13222966f, 0.10114967f, -0.07060092f, 0.08859926f, 
    0.04952736f, 0.15537089f, -0.05338494f, 0.10530254f, -0.05222451f, -0.28052285f, 0.05321823f, 0.07583077f, 
    -0.04471460f, -0.01708172f, 0.36740381f, -0.06501511f, -0.05590242f, 0.11195882f, 0.02105185f, 0.16897008f, 
    -0.03028664f, 0.04183996f, 0.09103747f, 0.13445823f, -0.00799783f, -0.02645634f, -0.00967457f, -0.23872471f, 
    -0.02629580f, -0.06523044f, 0.12040932f, -0.00587345f, 0.27938259f, -0.14548230f, 0.10525211f, -0.16762665f, 
    -0.08545796f, -0.08047356f, 0.04121213f, -0.02776930f, -0.08917122f, 0.43884856f, 0.06932937f, -0.20578472f, 
    -0.17628928f, -0.12280037f, -0.14330767f, 0.07185502f, 0.05541187f, 0.11447132f, 0.20286317f, -0.17923963f, 
    -0.10119434f, -0.08128862f, -0.01209168f, -0.23421714f, 0.04146164f, 0.05137441f, -0.11410062f, 0.16869463f, 
    -0.08345774f, 0.16712078f, 0.09314352f, -0.14556760f, -0.05045919f, 0.15257968f, 0.05722680f, 0.02449843f, 
    0.03296976f, 0.12195393f, -0.05138362f, 0.05672645f, 0.05761625f, 0.01174595f, 0.01850989f, 0.10091017f, 
    0.02516931f, 0.26464373f, -0.11760330f, 0.38405910f, 0.01422859f, 0.20768885f, 0.18094085f, -0.01518436f, 
    -0.11790812f, 0.02801388f, 0.09623597f, 0.15295584f, -0.08734965f, -0.11566601f, -0.12348498f, 0.01232202f, 
    0.10481728f, 0.10019054f, -0.01165384f, 0.10505641f, -0.15734588f, -0.27587321f, -0.26276457f, -0.19714500f, 
    -0.23409526f, 0.14473729f, -0.03602066f, 0.07046893f, -0.78672153f, -0.56066287f, -0.01486788f, 0.06268906f, 
    -0.00684175f, -0.02751023f, -0.06480412f, -0.04840902f, -0.07740780f, -0.38943776f, 0.22963347f, 0.27884284f, 
    0.30603611f, -0.13680628f, 0.03228894f, -0.13040225f, 0.12272425f, -0.13370839f, -0.33415523f, 0.02713831f, 
    0.20485564f, -0.00931069f, 0.14164282f, -0.00250399f, 0.02703496f, 0.23180400f, -0.08463790f, -0.19721881f, 
    0.02001646f, -0.02166859f, -0.06966177f, -0.11040321f, -0.08004978f, 0.06391998f, 0.02329830f, -0.13688356f, 
    -0.17875750f, 0.13573654f, -0.23128603f, -0.02580759f, 0.17663416f, -0.12954666f, 0.05612641f, 0.30693454f, 
    -0.00448592f, -0.22760661f, 0.19700535f, -0.03342323f, 0.20458131f, 0.00820449f, 0.12516619f, -0.18403429f, 
    0.03446608f, 0.06194275f, -0.15411507f, -0.01916705f, 0.22216317f, -0.13124326f, -0.04750675f, -0.13769285f, 
    0.06374380f, 0.07631154f, -0.00046464f, 0.44399682f, 0.05806509f, 0.17834628f, -0.05978828f, 0.14769246f, 
    0.12167349f, 0.18264082f, 0.00796373f, -0.02377878f, -0.15111662f, 0.09167235f, 0.61009085f, -0.16988507f, 
    -0.05437317f, -0.01817621f, 0.06606756f, -0.08079588f, -0.00042244f, 0.08456763f, -0.03526325f, 0.01425628f, 
    0.18212590f, 0.01752717f, -0.21575248f, 0.17113569f, -0.04758704f, 0.03467880f, -0.03176123f, 0.25869709f, 
    0.51767033f, -0.24771935f, 0.00085104f, -0.02411072f, 0.02368079f, 0.05355809f, 0.00453763f, -0.36424693f, 
    0.10900032f, -0.35208440f, -0.11958554f, -0.02628568f, 0.06448398f, 0.05713821f, 0.14328508f, 0.08676120f, 
    0.10368498f, -0.22468942f, -0.34875757f, 0.00413240f, 0.10204627f, -0.02182185f, -0.05074964f, 0.06047409f, 
    0.04357351f, 0.17211291f, 0.14930926f, 0.01942713f, -0.00507790f, 0.03384866f, -0.05862213f, 0.11553943f, 
    -0.07429843f, 0.02246060f, -0.12742786f, -0.04372092f, -0.47131470f, 0.04570679f, 0.04231263f, 0.11102569f, 
    -0.07326739f, -0.01578130f, 0.02654421f, -0.14099339f, -0.40653282f, -0.29860815f, 0.03969200f, -0.03062574f, 
    0.08401314f, -0.05903648f, -0.12683523f, 0.07344917f, -0.40093017f, -0.41611770f, 0.07977383f, 0.13407950f, 
    0.01360495f, 0.02696458f, -0.00957689f, -0.02534344f, -0.19953933f, 0.18006498f, 0.31551757f, 0.09020860f, 
    -0.10325454f, 0.10290508f, -0.09435581f, 0.09274493f, -0.06739419f, 0.01445634f, -0.69902730f, -0.00604414f, 
    0.22678109f, 0.05254937f, 0.07101183f, 0.05900953f, 0.09422291f, -0.16191918f, -0.02309284f, 0.21145891f, 
    -0.16628401f, 0.10714721f, -0.02585335f, -0.20616412f, 0.08108871f, 0.11217374f, 0.07008641f, 0.08875474f, 
    -0.01393895f, 0.12490121f, -0.13283440f, 0.23088990f, 0.05760965f, -0.11259409f, 0.00124979f, 0.04385150f, 
    0.13335277f, 0.48611021f, -0.18414539f, 0.15298499f, -0.10656834f, 0.01802279f, 0.04772894f, 0.13824557f, 
    -0.03577004f, -0.05497581f, 0.05336036f, -0.38422969f, 0.05186163f, -0.11869565f, 0.12520704f, -0.04618969f, 
    0.08678594f, -0.00618458f, 0.02270641f, 0.08123457f, -0.08134048f, 0.05415930f, -0.09669747f, -0.09992155f, 
    -0.01568587f, 0.04536730f, -0.02597000f, 0.07283266f, 0.22426549f, -0.07368571f, 0.10886948f, -0.01374416f, 
    -0.27790165f, -0.06713167f, 0.02674994f, -0.01311594f, 0.10356285f, 0.55245984f, 0.11555697f, -0.06863826f, 
    0.06439848f, -0.08210699f, -0.07857590f, -0.09180298f, 0.00400843f, -0.10186383f, -0.15333796f, -0.04316627f, 
    0.37564293f, 0.07457570f, -0.12300858f, -0.00822378f, -0.09790616f, 0.02598488f, -0.00514965f, -0.00501968f, 
    -0.26822194f, -0.01262549f, 0.07742119f, -0.06889418f, -0.02455714f, 0.03341478f, 0.06523968f, 0.08484542f, 
    0.07252899f, -0.00335201f, 0.01290984f, 0.05924825f, -0.00934456f, -0.00250151f, 0.00058417f, 0.05008265f, 
    0.05092504f, -0.04289716f, 0.03566852f, 0.02286044f, 0.02425216f, -0.08338312f, -0.06356566f, -0.01908448f, 
    0.02783814f, 0.05362143f, -0.07015380f, -0.05446695f, -0.08463464f, 0.04315768f, 0.01515726f, 0.02463658f, 
    -0.00469068f, -0.04905275f, -0.02499404f, 0.01754327f, -0.01944343f, -0.06084614f, -0.03658276f, -0.06523288f, 
    0.02589439f, 0.04658570f, 0.03482530f, 0.05185051f, -0.08127926f, 0.04988975f, -0.03785285f, -0.01916043f, 
    0.01950693f, -0.04030932f, -0.04822035f, -0.06559741f, 0.06276359f, 0.07464281f, 0.07094710f, -0.02598375f, 
    -0.01859285f, -0.03214211f, -0.01457907f, 0.00638342f, -0.06314123f, -0.01035929f, -0.02657706f, 0.00169054f, 
    -0.08231057f, -0.06157653f, -0.09019316f, 0.03070867f, -0.09104446f, -0.07956104f, -0.04592683f, -0.07687791f, 
    -0.02627780f, -0.02897926f, -0.08307323f, -0.04498551f, 0.02894371f, -0.02956849f, 0.06709830f, 0.06375822f, 
    -0.00994537f, 0.02005314f, 0.05009289f, 0.05370779f, -0.04759372f, 0.01584308f, -0.04114883f, -0.04500285f, 
    0.07404163f, -0.04049810f, 0.05636965f, -0.06769691f, -0.03482507f, -0.08262838f, -0.00830299f, -0.08438555f, 
    -0.01142921f, 0.02393863f, -0.04959892f, 0.00682332f, 0.01670565f, -0.08765851f, -0.01495395f, -0.04999731f, 
    0.01917103f, -0.08543775f, -0.07645003f, -0.04210712f, 0.00113812f, -0.02410628f, 0.01819310f, 0.00894258f, 
    -0.04547687f, -0.07486273f, 0.02223531f, -0.00153374f, -0.07695661f, -0.04486429f, -0.00553624f, -0.06570769f, 
    -0.06453115f, 0.05374660f, -0.00455053f, -0.03882791f, -0.07151379f, -0.06520390f, 0.00873584f, -0.06469836f, 
    0.05847805f, 0.02571736f, 0.05246579f, -0.00458249f, -0.02202666f, 0.01552196f, 0.02813445f, -0.00159618f, 
    -0.02877417f, -0.08328021f, 0.04453018f, -0.02210784f, -0.01877474f, -0.03219413f, -0.01279508f, 0.04416798f, 
    0.04416247f, 0.05047069f, -0.05700615f, 0.03677351f, 0.00760020f, 0.00380619f, -0.00496004f, 0.05552130f, 
    0.07664085f, -0.10410669f, 0.22335824f, 0.07480755f, -0.04617129f, 0.21246046f, 0.11931358f, -0.15803282f, 
    -0.11543980f, -0.06243188f, -0.35222378f, 0.15570672f, -0.03892579f, 0.13034475f, -0.02881794f, 0.05038455f, 
    -0.00561471f, -0.26050076f, 0.09009546f, 0.13850665f, 0.25714278f, -0.11632618f, 0.14031546f, -0.10937604f, 
    -0.13527611f, 0.06892334f, -0.17562281f, 0.21042933f, 0.28941140f, 0.00914583f, -0.04979413f, 0.01248033f, 
    -0.14064786f, 0.05008336f, 0.03128452f, -0.10661432f, 0.55219871f, 0.18345401f, 0.16321041f, 0.03452770f, 
    -0.06204914f, -0.19034100f, -0.00489025f, 0.14043458f, 0.10362134f, 0.15569252f, -0.09911869f, 0.30474368f, 
    0.07824498f, 0.05426167f, -0.10607287f, 0.09388264f, -0.01309306f, -0.02644014f, 0.38039127f, 0.32480893f, 
    0.28940514f, -0.00593962f, -0.00706540f, -0.01144346f, 0.11229635f, -0.01233925f, -0.11600998f, -0.08070187f, 
    0.15352474f, -0.17243291f, 0.11982986f, -0.06031337f, 0.04728084f, -0.06261440f, -0.18100014f, -0.10288154f, 
    0.02076315f, 0.19328874f, -0.04863597f, 0.11483309f, -0.02581493f, -0.08527549f, -0.11616350f, -0.15715294f, 
    -0.10286664f, 0.24434437f, -0.00322621f, 0.05820727f, 0.07943276f, 0.05869383f, 0.15095425f, -0.10273652f, 
    0.04853679f, 0.19561969f, -0.05864267f, 0.02335818f, -0.28403747f, -0.18676600f, -0.06437290f, 0.00621543f, 
    0.00484771f, 0.12410976f, -0.12009351f, -0.14536610f, -0.31970641f, -0.04089795f, -0.03103029f, 0.18809639f, 
    -0.05730249f, -0.05972809f, 0.10697197f, 0.08035045f, 0.11445148f, -0.06402636f, -0.08355023f, 0.25344548f, 
    -0.07283867f, 0.07742824f, -0.02536336f, -0.11431877f, 0.09790847f, -0.31955868f, -0.04428916f, -0.23078336f, 
    0.24851646f, 0.04874891f, 0.28623703f, 0.09750609f, -0.07326990f, 0.06474443f, -0.10608739f, -0.28631526f, 
    -0.42514318f, 0.00725121f, 0.01279243f, 0.17260693f, 0.01035223f, -0.09391948f, 0.15856610f, -0.04589746f, 
    0.23176923f, 0.21319273f, 0.15429640f, 0.16127820f, 0.07773306f, -0.06745400f, -0.11912163f, -0.02613166f, 
    -0.05212855f, 0.16048878f, 0.14556384f, 0.07701828f, -0.00924083f, -0.14706346f, 0.01721624f, -0.03729919f, 
    0.12078242f, 0.20249838f, 0.19288787f, 0.03765758f, -0.05981702f, -0.03927911f, -0.07977339f, -0.08895507f, 
    -0.05524199f, -0.24880859f, -0.05143223f, -0.20582066f, 0.07560246f, 0.28530478f, -0.00800171f, -0.14011043f, 
    0.07507489f, -0.01740406f, -0.16161360f, -0.14850231f, -0.01289303f, 0.11615197f, 0.01744995f, 0.01053577f, 
    0.23661749f, -0.07631800f, -0.06119807f, 0.06230080f, -0.06653007f, -0.41527480f, -0.10995589f, 0.08316805f, 
    -0.02651430f, -0.16096565f, -0.07130339f, 0.15994884f, 0.03003384f, 0.20051257f, -0.10761482f, -0.41881374f, 
    0.05105825f, 0.02685410f, 0.08517185f, 0.04622189f, 0.04999297f, -0.07346672f, -0.27721956f, -0.12732631f, 
    -0.16502559f, -0.14523564f, -0.03790640f, 0.05271018f, -0.07572389f, 0.00633727f, 0.04776482f, -0.04946645f, 
    -0.16311273f, -0.02947005f, 0.03774383f, -0.07979842f, 0.12943709f, -0.15303634f, -0.02145449f, -0.04420389f, 
    0.01740106f, -0.06608986f, 0.17130253f, -0.06247820f, 0.01927764f, -0.06494824f, -0.11478090f, 0.09168884f, 
    0.08067989f, 0.00149341f, -0.13421814f, -0.32082722f, 0.08907036f, -0.00107981f, 0.03763963f, 0.02345498f, 
    0.00012593f, 0.13478363f, 0.16935767f, -0.11660356f, 0.27744061f, -0.03535135f, -0.17345828f, 0.09672780f, 
    -0.06850903f, -0.01952286f, -0.05981672f, 0.27848577f, 0.15218502f, 0.17210609f, 0.26198092f, 0.01472604f, 
    -0.05407418f, 0.20025538f, -0.15538283f, 0.02554119f, 0.19652317f, 0.07589029f, 0.12978685f, -0.08396540f, 
    -0.17892428f, 0.16533548f, 0.00359072f, -0.01159081f, 0.05930735f, 0.27996266f, 0.16532558f, 0.25018933f, 
    -0.00294488f, -0.02452549f, 0.07772627f, -0.01079944f, -0.09496127f, -0.03002082f, 0.20745522f, -0.08867151f, 
    -0.16697079f, 0.13749804f, 0.17674308f, 0.07739491f, 0.07953999f, 0.09448987f, 0.11015829f, -0.04873785f, 
    -0.11527345f, -0.39633223f, -0.10766207f, -0.12933382f, -0.07570652f, 0.21002564f, 0.16910908f, 0.16848253f, 
    -0.02287931f, -0.01818806f, 0.07575115f, -0.02833661f, -0.06495978f, 0.07880311f, -0.00635292f, -0.07715696f, 
    0.04138679f, 0.00507409f, 0.07540132f, -0.00209629f, 0.05706002f, 0.03147670f, -0.05059163f, 0.00213481f, 
    0.01043651f, 0.04402469f, -0.03445997f, 0.01042636f, 0.06960838f, -0.08630663f, -0.04700339f, 0.02460318f, 
    -0.08471120f, -0.07209980f, 0.00591610f, -0.08688648f, -0.00845950f, -0.00966566f, 0.01750110f, 0.00602264f, 
    0.04982444f, 0.01780683f, -0.06908515f, -0.01097222f, 0.04539050f, 0.00375012f, 0.05743508f, 0.06530910f, 
    0.07032935f, -0.03162787f, -0.01532872f, -0.06222095f, 0.01890246f, 0.02777161f, -0.04059513f, 0.01714815f, 
    -0.08587167f, -0.08225362f, -0.08697530f, -0.05896972f, -0.00077662f, -0.07266942f, -0.03252609f, 0.02622753f, 
    0.05933930f, 0.03441602f, -0.06922670f, 0.02128222f, -0.02218099f, -0.01503439f, 0.01743684f, -0.07834259f, 
    -0.00579965f, -0.06552128f, -0.03747076f, 0.05595708f, -0.05925837f, 0.05847334f, -0.03885058f, 0.06136350f, 
    0.05415063f, -0.07747874f, 0.05625299f, -0.03367488f, 0.00678722f, -0.03471289f, -0.03961000f, -0.02199715f, 
    0.01488725f, -0.00728331f, 0.01778455f, 0.04117953f, -0.06798197f, 0.02490018f, 0.00683075f, 0.06089488f, 
    -0.04838176f, -0.02410325f, 0.00427123f, -0.04288309f, -0.07172482f, -0.07197529f, -0.03425875f, -0.08079419f, 
    -0.04434757f, -0.00564071f, -0.08426929f, -0.06675244f, -0.08203875f, 0.02802650f, 0.03344100f, -0.00152990f, 
    -0.02824949f, 0.05601864f, 0.07068511f, -0.01128174f, -0.06846683f, -0.01174776f, -0.04918706f, 0.05607374f, 
    0.02344186f, 0.03981342f, 0.05556546f, -0.03426833f, 0.06018291f, -0.07401490f, 0.04144529f, 0.06994344f, 
    -0.04920807f, -0.02497887f, -0.08798320f, 0.00178129f, -0.06275853f, -0.04705404f, -0.03489801f, 0.00821962f, 
    0.06041937f, 0.02196166f, -0.06994779f, -0.00313992f, -0.07178282f, -0.05478764f, -0.07914016f, 0.00207169f, 
    -0.00616531f, -0.00356131f, -0.01448748f, 0.06796461f, -0.01497859f, -0.08624325f, -0.08252436f, -0.03248155f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.32986319f, 0.03223652f, 0.02128121f, 0.09324152f, 0.23938310f, 0.32682973f, -0.08063968f, 0.19157989f, 
    -0.04656946f, -0.10683994f, 0.11231736f, 0.12025733f, -0.08728877f, -0.00832873f, 0.06076643f, -0.07646697f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.22026645f, 0.20443754f, -0.07783500f, 0.25104368f, -0.14907229f, 0.15751275f, 0.13301736f, 0.19864798f, 
    -0.23986770f, -0.19387308f, 0.36884063f, -0.22686709f, 0.23250103f, 0.32382840f, 0.13243391f, 0.18209240f, 
    0.02971156f, 0.24718128f, 0.14690974f, 0.20217144f, -0.17987007f, 0.13051315f, -0.16629833f, 0.38078034f, 
    -0.40050411f, -0.20552102f, -0.09787150f, -0.50064820f, 0.17462009f, 0.11805284f, 0.35955060f, -0.17819226f, 
    0.56407058f, -0.03449905f, -0.43085933f, -0.02472822f, -0.24783222f, 0.20131327f, 0.00991373f, 0.17659682f, 
    0.00520072f, 0.09693883f, 0.41655350f, 0.16738182f, 0.04050224f, -0.33577099f, -0.25069395f, 0.10887808f, 
    -0.22490984f, -0.13286874f, -0.17760912f, -0.10699254f, -0.11548944f, 0.12789956f, -0.07862890f, 0.00471526f, 
    0.08771271f, 0.02101626f, -0.02827549f, -0.23522636f, -0.18420318f, -0.11769070f, -0.17728013f, 0.09787723f, 
    -0.27411494f, 0.18923484f, -0.21069600f, -0.00466494f, 0.23855263f, -0.07828310f, -0.03068433f, 0.15031475f, 
    0.43266171f, 0.02299018f, -0.05988540f, 0.83453959f, -0.08143681f, -0.31703907f, 0.48052773f, -0.21215117f, 
    -0.16823936f, 0.12039214f, -0.04887234f, 0.10663629f, 0.33010548f, 0.08665187f, -0.07093804f, 0.33430409f, 
    0.13567020f, 0.12551221f, 0.28054282f, 0.03440857f, -0.09482767f, -0.12617153f, 0.39860779f, 0.02755270f, 
    -0.20365614f, -0.00874544f, -0.29995215f, -0.30150568f, -0.29970351f, 0.39777678f, -0.07644340f, 0.56456566f, 
    0.16292405f, 0.33380646f, 0.42459974f, 0.17687532f, 0.17607361f, -0.27175647f, 0.29608208f, 0.01727650f, 
    0.25385013f, -0.06872626f, -0.41044256f, -0.07765352f, -0.30405068f, 0.23679376f, -0.09645721f, 0.41432086f, 
    -0.18068023f, 0.39997873f, 0.02562878f, 0.69158560f, 0.02204882f, -0.47729754f, 0.21868886f, -0.09332895f, 
    0.23372239f, 0.02006911f, 0.01803551f, -0.17087981f, 0.34355524f, 0.27317268f, 0.22715105f, -0.01791662f, 
    0.42586634f, -0.45594004f, -0.28137028f, -0.29629681f, -0.20780471f, 0.32211098f, 0.06855007f, -0.07976118f, 
    -0.17258650f, 0.17971805f, 0.04032680f, 0.13393520f, 0.16106501f, -0.36318594f, -0.04471516f, 0.16847853f, 
    0.06901609f, -0.15738598f, 0.07638711f, -0.02927154f, 0.18896118f, -0.11716449f, -0.25357267f, -0.05506808f, 
    0.42421076f, -0.11158850f, 0.09097520f, 0.22692846f, 0.06356533f, 0.08148457f, -0.17256358f, -0.14897582f, 
    0.10527340f, -0.45697525f, -0.12161996f, -0.11095305f, 0.11344908f, 0.25691119f, -0.03709705f, -0.12275209f, 
    0.29187882f, 0.17899789f, 0.12782076f, 0.28750271f, 0.56630617f, -0.26673034f, 0.03660747f, 0.21162289f, 
    -0.31856260f, -0.25758147f, -0.03836477f, -0.18869330f, -0.13185309f, -0.58720040f, 0.35551420f, 0.19496106f, 
    -0.03871610f, 0.08725490f, 0.10858342f, -0.07834698f, 0.39750627f, -0.19631906f, 0.25447556f, 0.44052374f, 
    -0.35845909f, 0.22590327f, 0.24558499f, -0.64380586f, 0.23609221f, 0.15506060f, 0.14457457f, 0.11549821f, 
    -0.04453627f, 0.18908486f, 0.31275064f, 0.01438262f, 0.12358309f, 0.64494407f, 0.10728037f, 0.02657963f, 
    0.06609844f, -0.27373418f, -0.11128583f, -0.14143306f, -0.12834880f, -0.23081213f, -0.15599731f, 0.03067562f, 
    0.03962983f, 0.16074280f, 0.21021353f, 0.04992317f, -0.20749797f, -0.27928364f, 0.19817972f, 0.44655323f, 
    0.38323972f, 0.03541452f, 0.04974604f, 0.50922984f, 0.09707298f, -0.22052976f, -0.09394851f, 0.13011289f, 
    -0.15321709f, -0.12646033f, 0.50595415f, 0.18569027f, 0.04636466f, -0.04707728f, -0.02131194f, 0.12787269f, 
    -0.27315947f, 0.11423006f, 0.24500881f, 0.18221983f, 0.09023663f, -0.61119497f, 0.11843499f, -0.12514544f, 
    -0.24849451f, 0.14081094f, -0.06697088f, 0.00155813f, -0.08965498f, -0.12737870f, -0.19515052f, -0.04588526f, 
    -0.00875449f, -0.16114840f, -0.01279315f, -0.08579341f, -0.24918354f, -0.03317833f, 0.04810175f, -0.16475219f, 
    -0.06552056f, 0.24328968f, -0.16166596f, 0.36362532f, 0.03135959f, 0.20649233f, -0.05666459f, 0.40674263f, 
    -0.17730829f, 0.18876317f, 0.13080202f, -0.74830568f, 0.18068320f, -0.24387114f, -0.06247105f, -0.16791475f, 
    0.30783984f, -0.01451207f, 0.52697814f, -0.01691289f, 0.02982201f, -0.15889013f, -0.12038681f, 0.02916731f, 
    0.43256429f, -0.02587809f, -0.17408316f, -0.14244901f, 0.11648837f, 0.00417148f, -0.25027031f, 0.23175950f, 
    0.18261805f, -0.13546000f, 0.28928345f, -0.05883779f, 0.10299052f, 0.21388306f, -0.22100647f, 0.04966195f, 
    0.37178716f, -0.15604797f, -0.52466798f, -0.37692013f, -0.02258778f, 0.06620099f, 0.41438910f, -0.01073109f, 
    0.45452857f, -0.07232508f, -0.16917638f, 0.05481303f, -0.22926062f, 0.19306502f, -0.03688302f, 0.06906313f, 
    0.30819571f, -0.11398997f, -0.23851062f, 0.76966029f, -0.11778489f, -0.29054403f, -0.15682091f, -0.05934852f, 
    0.27164176f, 0.16790709f, 0.90458518f, -0.19798738f, -0.26394197f, -0.12448215f, -0.22752093f, 0.22722705f, 
    0.05188040f, -0.06678607f, -0.05840632f, 0.13555510f, 0.00024105f, 0.11049602f, -0.21461445f, -0.23416319f, 
    0.15515159f, 0.01476602f, -0.28566009f, 0.34893689f, 0.27072382f, -0.23206031f, -0.17199147f, -0.08249737f, 
    -0.29765990f, -0.59593695f, 0.37124115f, -0.16907588f, 0.15692210f, -0.38326764f, 0.35574058f, 0.09418949f, 
    0.21619754f, -0.11495289f, -0.19539824f, 0.03354935f, 0.05414117f, 0.20577870f, 0.13862671f, 0.20573200f, 
    -0.04921998f, -0.18655312f, 0.02026848f, 1.09689641f, -0.19482858f, -0.62687874f, 0.24618781f, 0.02666315f, 
    -0.27120253f, -0.21905544f, 0.69287336f, 0.10446127f, -1.06649053f, -0.29734078f, -0.27760103f, 0.19595003f, 
    -0.00244138f, 0.16423336f, 0.06032060f, -0.22147818f, -0.22210631f, -0.38551342f, 0.07263629f, -0.24714029f, 
    -0.16530778f, 0.00432737f, 0.03815402f, 0.23907083f, -0.06402767f, 0.30185193f, 0.13198839f, 0.34484467f, 
    -0.43692282f, -0.47547945f, -0.00366204f, -0.49038219f, -0.11751589f, 0.17392424f, 0.29016873f, 0.00186701f, 
    0.25885919f, 0.17383760f, -0.16944297f, 0.12549624f, 0.37816355f, 0.45457822f, 0.17810822f, -0.05512851f, 
    -0.23625498f, -0.65236998f, 0.38277936f, -0.28499040f, -0.08439306f, 0.03338758f, -0.00101211f, -0.04030656f, 
    -0.30829540f, 0.07995410f, 0.28976804f, 0.13051346f, 0.12753180f, 0.02927743f, -0.04098026f, -0.15494519f, 
    -0.01651217f, -0.25739408f, 0.25799206f, -0.06233535f, -0.10267915f, 0.30089602f, 0.11187905f, 0.07468794f, 
    0.35527363f, -0.07963409f, -0.04466144f, -0.39343193f, 0.19243109f, 0.53475302f, -0.08108838f, -0.34820384f, 
    0.11359387f, -0.37764505f, 0.36618939f, 0.24578802f, 0.15727572f, 0.22565396f, -0.13801903f, -0.17142704f, 
    0.33992094f, -0.22286409f, -0.08253587f, 0.18694556f, 0.62706745f, 0.09748588f, 0.11732592f, 0.18363780f, 
    -0.33674833f, -0.24531153f, -0.20952576f, -0.22021364f, -0.07307407f, -0.31056330f, 0.32628214f, 0.06700256f, 
    -0.13632326f, 0.13529864f, 0.22080266f, 0.08996101f, 0.52390337f, 0.04289984f, 0.11403514f, 0.13078068f, 
    -0.34944046f, -0.06972740f, -0.02613834f, -0.47672281f, 0.11447770f, 0.04089390f, 0.56104541f, -0.15552774f, 
    0.14891602f, -0.17415853f, 0.09082703f, 0.39134496f, -0.29496169f, -0.01978409f, -0.26052195f, 0.25805661f, 
    -0.25983608f, -0.30710691f, 0.27462596f, 0.12754197f, -0.06382174f, 0.04511666f, -0.26594117f, 0.06567464f, 
    -0.34477469f, 0.15123980f, 0.05260796f, -0.09976038f, 0.64961153f, 0.22997111f, -0.20551157f, -0.05410036f, 
    -0.19895305f, -0.05206947f, 0.38162732f, -0.11164745f, -0.11109288f, 0.46259111f, 0.14061204f, -0.10335022f, 
    -0.08689342f, -0.06366670f, -0.36510694f, 0.05324876f, 0.16765022f, 0.08128699f, -0.17611846f, 0.24001057f, 
    -0.09356313f, -0.21783182f, 0.44835410f, 0.47365957f, -0.10314617f, -0.26772353f, -0.17917389f, 0.21235189f, 
    -0.00226557f, 0.08899632f, -0.25270599f, 0.12764503f, 0.29173666f, 0.50651103f, 0.19900306f, -0.16372515f, 
    0.09043474f, -0.74749702f, 0.09459150f, -0.11853442f, 0.13161314f, -0.01713006f, 0.17768542f, -0.10899802f, 
    -0.26918906f, -0.02854235f, 0.54381841f, 0.33614725f, 0.31019300f, -0.03624627f, -0.10471157f, -0.04032118f, 
    0.18798487f, -0.06380123f, -0.41003737f, 0.03821634f, 0.00392494f, -0.15403515f, 0.11258450f, 0.23820217f, 
    -0.09405448f, 0.20412838f, -0.51836509f, 0.26163355f, 0.36575976f, 0.18094832f, -0.13264379f, 0.18164499f, 
    -0.30581909f, 0.19515906f, 0.11718298f, -0.21139999f, -0.22451741f, -0.19560337f, 0.40054950f, 0.21282990f, 
    0.11231985f, -0.07801194f, 0.15601729f, -0.26909709f, 0.34434018f, -0.19609003f, -0.12370889f, -0.17415787f, 
    -0.16232650f, -0.22874525f, -0.44543171f, -0.01642332f, -0.14431047f, 0.13458176f, 0.50237197f, 0.14481005f, 
    0.41919452f, 0.01967948f, -0.20185465f, 0.08928763f, 0.27435550f, -0.19041835f, 0.17420809f, 0.13913205f, 
    -0.01119274f, -0.54250568f, 0.33218721f, 0.32713556f, -0.13194880f, -0.43381098f, -0.17026284f, 0.11969325f, 
    -0.14335972f, -0.01313507f, 0.25351724f, -0.36274025f, -0.32443860f, 0.09898996f, -0.10543919f, -0.08492205f, 
    0.28338006f, 0.36060014f, 0.36435580f, 0.54250389f, -0.00348388f, 0.02552849f, 0.33881101f, 0.20970371f, 
    -0.39134714f, -0.06661749f, -1.14736450f, -0.16779694f, -0.45832887f, -1.54510260f, -0.03813649f, -0.33510524f, 
    0.14241053f, 0.18741892f, -0.10614616f, -0.10768744f, 0.16800639f, 0.35222733f, -1.24018312f, -0.12636575f, 
    0.05098984f, -0.08584396f, 0.44293144f, 0.04909299f, -0.36117175f, 0.31853321f, -0.21500432f, -0.15353253f, 
    -0.06451166f, -0.22500767f, -0.28972465f, -0.34757587f, -0.13020512f, 0.39179203f, 0.34069642f, 0.18654238f, 
    -0.28741571f, -0.10968110f, 0.12165873f, 0.25472960f, -0.54089969f, -0.71478534f, -0.22405741f, -0.03679555f, 
    0.11146521f, 0.23337123f, 0.20043756f, 0.18450835f, -0.13656458f, -0.08500702f, 0.17246473f, -0.09934485f, 
    -0.14952376f, -0.06598115f, 0.04738007f, -0.21345873f, 0.03148034f, 0.07218259f, -0.23822072f, 0.07778853f, 
    -0.09825265f, -0.12557121f, 0.10497923f, -0.06447657f, -0.19318742f, 0.04348023f, -0.15409362f, 0.14136115f, 
    0.28139552f, -0.20210914f, 0.03614495f, 0.26799577f, -0.01873499f, 0.41712523f, -0.00543449f, 0.05629831f, 
    0.02731393f, -0.35029984f, -0.16263886f, -0.31350511f, -0.10153230f, -0.10329490f, -0.27322802f, -0.12591515f, 
    -0.23230527f, -0.14018387f, -0.06178184f, 0.14398523f, -0.22021881f, -0.07010549f, 0.15643862f, -0.18699317f, 
    0.14214645f, -0.14634959f, -0.05241844f, -0.25882363f, -0.19581711f, -0.24369313f, -0.23645231f, 0.09152767f, 
    -0.14009397f, 0.18368359f, 0.27151522f, 0.28813794f, 0.15791206f, -0.00726720f, -0.07193446f, 0.37567648f, 
    -0.25020471f, -0.48626712f, 0.20677121f, -0.36038303f, -0.02233162f, -0.07230754f, -0.04167109f, 0.18431184f, 
    0.13709027f, -0.03487888f, 0.54782385f, 0.27974001f, 0.22697501f, -0.11067614f, 0.16848676f, -0.20774564f, 
    0.06084784f, -0.57192242f, -0.22911255f, 0.20985004f, -0.04084116f, 0.34974569f, -0.16891363f, -0.03103231f, 
    0.36836898f, -0.09915161f, -0.14704022f, 0.15606786f, 0.20901905f, 0.24990259f, 0.01903713f, -0.14416881f, 
    -0.20045666f, -0.22181413f, 0.18847547f, -0.19993559f, 0.04180447f, -0.27604526f, 0.05774652f, 0.10497004f, 
    0.09605460f, 0.17540482f, 0.13558453f, 0.08744486f, -0.32424113f, 0.04239958f, 0.07030424f, -0.07280215f, 
    0.36041182f, -0.04827387f, -0.12956147f, 0.65004283f, 0.23773056f, -0.30413425f, 0.34073260f, -0.14522256f, 
    -0.16047545f, 0.20294166f, -0.85962319f, 0.00534867f, -0.36930731f, -0.19874397f, -0.01081420f, -0.45928121f, 
    0.08804595f, -0.16655375f, -0.07054371f, 0.09686889f, -0.07901427f, 0.33553767f, -0.87917864f, 0.10675237f, 
    0.12291878f, 0.04286742f, 0.38842437f, -0.29691732f, -0.00572652f, 0.49559933f, -0.13719450f, 0.09487832f, 
    0.14497250f, -0.70536816f, 0.27695596f, -0.04822024f, 0.04054865f, 0.08801403f, -0.31240442f, 0.03491828f, 
    -0.18062299f, -0.05939196f, -0.25005758f, 0.10392314f, -0.02322569f, 0.63963354f, -0.04120417f, 0.02442941f, 
    0.08714636f, -0.54980040f, 0.13675763f, -0.24355294f, -0.17136790f, 0.18468003f, 0.08023307f, -0.02652553f, 
    -0.34995475f, -0.10338189f, 0.18295223f, 0.08953024f, -0.01775109f, -0.06664770f, 0.02843789f, 0.21802095f, 
    0.23257981f, -0.46846825f, 0.30855593f, 0.53120559f, 0.13022438f, -0.10960853f, -0.13053292f, -0.17276941f, 
    0.30555916f, 0.22947937f, -0.13878468f, -0.13650262f, 0.60873270f, 0.40266922f, -0.18698831f, -0.34128588f, 
    0.03550156f, 0.20099188f, -0.38341334f, -0.76728421f, -0.16548350f, 0.31773379f, -0.27409348f, 0.23683444f, 
    -0.42505470f, -0.24045955f, -0.10483439f, -0.12942021f, 0.11114375f, 0.14311144f, 0.06133511f, 0.46946535f, 
    0.18125084f, 0.58470964f, 0.31572184f, -0.20277391f, -0.03338303f, -0.09047202f, 0.26429588f, -0.09709427f, 
    -0.34003764f, -0.11059796f, -0.05054792f, 0.23109674f, 0.42368495f, 0.48694590f, -0.11604485f, 0.28896433f, 
    -0.19568269f, -0.52514511f, -0.20865422f, 0.21436559f, -0.22639385f, 0.06629723f, 0.36178043f, 0.20502031f, 
    0.42389014f, 0.04603042f, -0.44611254f, 0.35185033f, 0.15704173f, 0.19057618f, 0.10458944f, -0.58881700f, 
    0.11900516f, -0.06193714f, -0.45034787f, 0.32854855f, 0.12476709f, -0.15927380f, 0.10589766f, 0.01820409f, 
    -0.46796557f, -0.17481023f, 0.69339973f, 0.09134240f, 0.41511557f, -0.01298118f, -0.19681226f, 0.20724761f, 
    0.00724406f, -0.05122651f, 0.01964961f, -0.13122785f, 0.20161015f, 0.22460990f, 0.35063598f, -0.08238871f, 
    0.01407549f, -0.06864595f, -0.10130182f, -0.21322413f, 0.10636731f, -0.08252502f, -0.13357714f, 0.28111303f, 
    -0.06895006f, -0.15473804f, 0.21194847f, 0.04506861f, 0.01138180f, -0.08454115f, -0.16167539f, 0.21388981f, 
    -0.38071176f, 0.10367496f, 0.54843205f, -0.04034012f, -0.91869432f, -0.25328448f, 0.02029055f, 0.37461752f, 
    -0.24515443f, 0.18278450f, 0.09914637f, 0.02280791f, -0.14056876f, -0.41553962f, 0.33439180f, 0.18543866f, 
    -0.13511035f, 0.15896364f, 0.13570362f, -0.14471760f, -0.05717681f, -0.13110560f, 0.01591509f, 0.31039897f, 
    0.34004623f, 0.62913895f, 0.32263616f, 0.16734740f, -0.11545985f, -0.10146561f, 0.13755248f, -0.02075210f, 
    0.39044878f, 0.04345591f, -0.00196313f, 0.22301503f, 0.21059051f, -0.14443654f, 0.09197774f, 0.02362882f, 
    -0.11727495f, -0.16210532f, 0.10983484f, -0.27586302f, 0.19788884f, 0.19283935f, -0.07689751f, -0.08495463f, 
    0.46256286f, -0.20018908f, 0.07657277f, -0.00661520f, 0.03494984f, 0.24487641f, -0.04594656f, -0.19282593f, 
    0.33502963f, -0.33197451f, 0.10866740f, -0.17144169f, 0.14575611f, -0.10306035f, -0.32202452f, 0.21478134f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00317481f, -0.09393100f, 0.56494337f, -0.02513489f, 0.01433709f, -0.11780848f, -0.02622847f, 0.04247596f, 
    0.23427199f, -0.20022348f, 0.58575749f, 0.23060475f, -0.23108405f, 0.08355025f, 0.45012599f, -0.04444564f, 
    -0.23822901f, -0.19004326f, 0.06908832f, -0.17009330f, -0.11213955f, 0.46964031f, 0.15635811f, 0.12110442f, 
    0.05205309f, 0.16891141f, 0.46095702f, -0.31504804f, 0.12246714f, 0.43661204f, -0.05128624f, 0.52611130f, 
    0.03565009f, 0.60460132f, 0.49423903f, -0.18417212f, 0.00093758f, 0.28594461f, 0.40486997f, 0.33393282f, 
    -0.23287094f, -0.25409377f, -0.47604546f, -0.24413259f, 0.37244907f, 0.09569617f, 0.10254531f, 0.29452890f, 
    0.44414929f, 0.09169264f, -0.08820982f, -0.21034749f, 0.13493423f, 0.40035114f, -0.07845969f, 0.13585940f, 
    0.16221200f, -0.32370341f, -0.29399678f, -0.06808571f, -0.05578964f, 0.20199594f, 0.41196018f, 0.29235893f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.24143969f, 0.14376818f, -0.43440160f, 0.04557827f, 0.02251332f, -0.11101196f, -0.14097051f, -0.05125077f, 
    0.19084236f, -0.10723395f, 0.01265697f, 0.33848459f, 0.01793214f, 0.15927024f, 0.04179467f, 0.28244501f, 
    -0.00895914f, 0.16790548f, 0.21032041f, 0.35911101f, 0.02095288f, 0.24499580f, -0.19580391f, 0.01756258f, 
    0.39036697f, 0.17073727f, -0.08040635f, 0.02991601f, -0.40948471f, 0.26138055f, 0.34103751f, -0.14538325f, 
    -0.05383199f, -0.17420903f, 0.04753665f, 0.39660066f, -0.14407271f, -0.06901433f, -0.14859578f, -0.10404792f, 
    0.20471352f, 0.10463211f, 0.01816061f, -0.04761487f, 0.11984265f, 0.00808771f, 0.20632295f, 0.11863561f, 
    -0.19021071f, 0.12201106f, 0.28173697f, -0.08168380f, -0.07176213f, -0.02367197f, 0.15467578f, -0.10211226f, 
    0.03543635f, 0.08131632f, 0.28567508f, -0.19957261f, 0.06488343f, -0.14614883f, -0.00032638f, 0.00194341f, 
    0.08998432f, -0.05932366f, 0.56602776f, -0.08135047f, -0.38784605f, 0.10549528f, 0.39212188f, -0.36000845f, 
    0.14822696f, 0.07064781f, 0.16865046f, -0.58043981f, -0.03548111f, -0.63752079f, -0.09553982f, -0.47084638f, 
    0.04446624f, 0.16406173f, 0.06133311f, 0.17997260f, -0.37313262f, 0.17742062f, -0.33806854f, -0.56518310f, 
    -0.51517987f, -0.02759565f, 0.17884931f, 0.03854499f, 0.45143157f, -0.50270247f, -0.16463184f, 0.07608099f, 
    0.02440400f, 0.20873788f, -0.00073676f, -0.19999789f, 0.03143219f, -0.15111652f, 0.07518215f, 0.17750934f, 
    -0.23037460f, 0.02148928f, -0.13119416f, -0.06343742f, 0.02679081f, -0.13167986f, -0.22636345f, 0.09087151f, 
    0.02442158f, -0.31599128f, -0.39314979f, 0.01969746f, 0.18642482f, -0.01652777f, 0.09457169f, 0.21585779f, 
    -0.09234025f, -0.07795677f, -0.03023548f, 0.04752104f, -0.36726770f, 0.18284459f, 0.25499380f, 0.09660769f, 
    0.13864350f, -0.22869100f, -0.00345840f, -0.06708279f, 0.15172634f, 0.01242032f, -0.14065908f, -0.08871052f, 
    0.18835823f, -0.11851826f, 0.12710021f, -0.25105232f, -0.77510089f, 0.39711365f, 0.03135446f, -0.03668763f, 
    -0.09696956f, -0.26597923f, 0.03262625f, 0.08048832f, -0.07546901f, -0.10033240f, 0.23819600f, 0.18474443f, 
    -0.34892783f, -0.08276903f, 0.01690989f, 0.31671780f, 0.11463948f, -0.29115531f, -0.17204434f, 0.01159867f, 
    0.20258844f, 0.38582388f, 0.41213676f, 0.28841683f, -0.19290678f, 0.10564063f, 0.23862317f, -0.03602551f, 
    -0.37560943f, 0.25107598f, 0.10849621f, 0.11065972f, 0.00870201f, 0.09334004f, -0.06681676f, 0.18923654f, 
    -0.04586108f, 0.17380525f, -0.36087558f, 0.13045062f, 0.20762636f, 0.28637269f, -0.34112161f, -0.17096630f, 
    0.20832004f, 0.05929445f, 0.10967572f, -0.06857176f, -0.41313145f, -0.07070959f, -0.07391914f, 0.20334058f, 
    0.19267206f, 0.18469390f, 0.10244540f, -0.07233803f, -0.12178165f, -0.02551170f, -0.07267229f, -0.13653402f, 
    -0.15426704f, 0.15966009f, 0.09364191f, 0.24155211f, 0.46476153f, -0.10341930f, 0.01130469f, -0.09577814f, 
    -0.08753847f, -0.09030758f, 0.07719491f, -0.56588006f, 0.04767599f, 0.20990725f, 0.24208608f, 0.01528785f, 
    -0.06076033f, 0.18690068f, 0.24899456f, -0.01188742f, -0.17539340f, 0.19233589f, 0.05683494f, 0.44962913f, 
    0.22683217f, 0.20935972f, -0.16537938f, -0.33217594f, -0.06564139f, 0.27596334f, 0.25389391f, -0.15693273f, 
    0.20595260f, -0.00327769f, -0.15227228f, 0.09510053f, 0.17575729f, 0.19891992f, 0.52924424f, 0.01356998f, 
    0.16547287f, -0.15667471f, 0.40063724f, 0.05887699f, -0.07027754f, 0.17940867f, -0.19433129f, -0.16110751f, 
    0.03779138f, -0.23732336f, 0.09800360f, -0.01198166f, 0.02476993f, 0.05926232f, 0.29559708f, 0.08432820f, 
    0.04757268f, 0.08394558f, -0.01271839f, 0.08963402f, -0.03999986f, -0.23061801f, -0.08251561f, -0.24740233f, 
    0.00017601f, -0.07944267f, -0.07248414f, 0.07212441f, 0.32755798f, -0.29300636f, -0.14371169f, -0.08730453f, 
    0.00956519f, 0.14944361f, -0.16057384f, -0.38638341f, -0.07066859f, 0.05951021f, 0.05801580f, -0.10533705f, 
    0.17007543f, 0.03847852f, -0.04025342f, -0.13424616f, -0.13361935f, 0.24480833f, 0.13545683f, 0.15277489f, 
    0.21601124f, -0.13784245f, -0.14326595f, 0.04042655f, 0.15576006f, 0.42444435f, -0.04224474f, -0.19540200f, 
    0.18504800f, -0.01554163f, 0.05291567f, 0.05824047f, -0.06457753f, 0.13514178f, 0.18006198f, -0.01595277f, 
    0.03687406f, -0.08081111f, 0.25178203f, -0.24018559f, -0.34033006f, -0.28537437f, 0.08992977f, -0.15796009f, 
    0.07820347f, -0.05997063f, -0.02849781f, -0.36915487f, -0.02749984f, -0.25320196f, 0.11994603f, -0.40711290f, 
    -0.32830277f, 0.09643939f, -0.07722697f, 0.00752585f, -0.07187151f, -0.04582908f, -0.08833627f, 0.08533314f, 
    0.13515955f, -0.21619350f, 0.08106242f, 0.13949929f, -0.23453911f, 0.52907956f, -0.01950743f, 0.15858474f, 
    0.07970217f, 0.04397485f, 0.38604528f, 0.42326230f, 0.27234951f, 0.43498352f, -0.36414346f, 0.15192108f, 
    -0.05873538f, 0.01705067f, 0.01571951f, -0.16943817f, -0.02150548f, 0.10342257f, 0.02272230f, -0.14956644f, 
    -0.50726432f, -0.19466092f, -0.06675613f, 0.27996454f, -0.12256685f, -0.99239463f, 0.14504726f, -0.17811459f, 
    0.32855940f, 0.13198850f, 0.03768709f, -0.06747043f, 0.27984849f, -0.04410560f, 0.00398867f, -0.03849092f, 
    0.06730665f, 0.07327649f, 0.28353193f, 0.26768646f, 0.14925620f, 0.02978693f, 0.13226788f, 0.02818530f, 
    0.01211863f, -0.14730696f, 0.05615981f, -0.01073040f, -0.09681939f, 0.00229001f, -0.00672330f, 0.26200023f, 
    0.05938775f, 0.15345950f, 0.11232262f, -0.10520460f, 0.26709312f, -0.07956860f, 0.13977531f, 0.33928269f, 
    -0.07388391f, 0.14539605f, -0.02068202f, 0.33496231f, 0.37760180f, -0.53469020f, -0.23056191f, 0.04804268f, 
    0.03200833f, 0.10747536f, -0.30037975f, -0.18986981f, -0.00286098f, -0.59723544f, 0.67998451f, 0.09343021f, 
    -0.07497369f, 0.30085903f, 0.24230734f, 0.03624236f, -0.07335480f, 0.38809642f, 0.21682765f, -0.16927905f, 
    0.30669659f, 0.43505725f, 0.18353534f, -0.21044689f, 0.21143667f, 0.58604372f, 0.30041710f, -0.09632382f, 
    0.20197572f, -0.08900184f, -0.16972776f, -0.11028466f, 0.05410786f, 0.02310011f, 0.36854506f, -0.13506716f, 
    0.08804478f, 0.14495072f, -0.03857632f, -0.37769943f, 0.21520132f, 0.04586203f, -0.01739592f, 0.09284491f, 
    0.11138482f, 0.21059823f, -0.09538088f, 0.22081986f, 0.11388046f, -0.17934138f, 0.07844777f, 0.00390798f, 
    0.19575168f, -0.41566589f, 0.01655205f, -0.11009838f, 0.11756024f, -0.00511704f, 0.19815886f, -0.01973869f, 
    0.24689676f, 0.01382572f, -0.22501126f, -0.46106040f, -0.23847987f, 0.26689941f, 0.09392722f, 0.12710123f, 
    0.00935176f, -0.45802096f, 0.03557749f, -0.09745441f, -0.19566426f, -0.04828029f, -0.47275397f, 0.21669410f, 
    -0.05522568f, -0.22065914f, 0.17351888f, 0.26909718f, 0.57457459f, -0.99226004f, -0.33857647f, -0.16594973f, 
    0.69272405f, 0.10398065f, 0.08269308f, -0.20384178f, -0.30426195f, -0.34602478f, -0.17586845f, 0.24465804f, 
    -0.76953256f, 0.06654911f, -0.68088430f, -0.05088227f, -0.24001287f, -0.08149231f, -0.22886968f, -0.15109353f, 
    -0.37690529f, 0.07011365f, -0.68042606f, 0.67817205f, 0.14531085f, 0.26910365f, 0.00981431f, 0.26718542f, 
    -0.00514370f, -0.04111769f, 0.10016564f, 0.22941186f, 0.13107631f, 0.18033352f, -0.21306427f, 0.09678341f, 
    0.00759806f, 0.55239624f, -0.41047031f, 0.03376893f, 0.17158063f, 0.04432574f, 0.11756857f, 0.30283606f, 
    -0.03510729f, -0.11360628f, -0.12825084f, 0.46459138f, 0.10558922f, 0.17913118f, 0.18209454f, 0.22309843f, 
    -0.03259626f, -0.10505047f, -0.01591484f, 0.28159729f, 0.02988946f, 0.11226919f, 0.04435080f, 0.30425987f, 
    0.06997972f, 0.37656811f, 0.02899335f, 0.15720797f, -0.17048076f, 0.35825959f, 0.40214011f, 0.12435510f, 
    0.14433600f, -0.05372892f, 0.05344886f, 0.26600298f, -0.20574676f, 0.48806968f, 0.03929436f, 0.00394551f, 
    -0.32319787f, 0.25324318f, -0.30648407f, 0.10615440f, 0.10601184f, 0.01234378f, 0.17722061f, 0.06453901f, 
    0.07591088f, 0.12100050f, -0.10187113f, -0.23846544f, 0.17555405f, 0.17222497f, -0.06995125f, 0.01122104f, 
    0.38301560f, -0.24190231f, 0.15423198f, -0.10218893f, 0.09344046f, -0.11989383f, -0.07700960f, -0.06914587f, 
    0.18023515f, 0.20146839f, -0.05085058f, 0.03380997f, -0.08966907f, 0.03494754f, 0.14020438f, -0.16741483f, 
    -0.19543430f, 0.14198864f, -0.19164483f, 0.07680004f, 0.20213443f, -0.15030813f, 0.08295668f, 0.29165074f, 
    -0.06851017f, -0.25583944f, -0.21092343f, -0.46601728f, -0.01910826f, 0.37523356f, 0.22057502f, 0.06837099f, 
    0.37541026f, 0.16592990f, -0.16867584f, 0.25460815f, -0.14416470f, -0.43065324f, 0.19939861f, -0.02969199f, 
    0.19303761f, -0.23801722f, -0.18221945f, -0.10465664f, -0.30070001f, 0.11528029f, 0.12344114f, 0.10343275f, 
    0.24570332f, -0.05154514f, 0.11441453f, 0.02088473f, -0.38351747f, -0.01830081f, 0.14359248f, -0.22694060f, 
    -0.16827169f, 0.15546811f, 0.07582568f, 0.24304356f, 0.07576808f, 0.20684135f, -0.11415041f, 0.14465311f, 
    -0.13331836f, -0.27463150f, 0.18611737f, 0.09099045f, 0.41065177f, 0.08486047f, -0.32617110f, 0.00797353f, 
    -0.09672161f, -0.17611790f, 0.46709824f, 0.09624919f, -0.13932312f, 0.08740791f, -0.35563681f, -0.15118903f, 
    0.13112929f, 0.13527113f, 0.28815734f, -0.50689924f, -0.63910335f, 0.15011691f, 0.12469312f, -0.64479607f, 
    0.06690060f, 0.05790947f, 0.13848379f, -0.09087866f, 0.53628218f, 0.10327109f, -0.32469437f, -0.28116512f, 
    0.00043837f, -0.22075592f, 0.14304791f, -0.11080753f, 0.59279031f, 0.23574750f, -0.36132997f, 0.13739981f, 
    -0.59071612f, -0.14856479f, -0.06620710f, -0.08687791f, 0.08510057f, -0.22620912f, 0.26002336f, 0.12598829f, 
    0.14416827f, 0.29512900f, 0.27753779f, 0.04517385f, 0.30546248f, 0.07481273f, -0.44010347f, 0.12602165f, 
    0.49202743f, 0.24195939f, -0.08747418f, 0.11444711f, 0.08900961f, -0.33800456f, 0.03680731f, -0.15870908f, 
    -0.04674869f, 0.27317905f, -0.39799803f, -0.26241419f, -0.34991267f, 0.09823633f, 0.30777198f, 0.25887275f, 
    -0.13066433f, -0.33630267f, -0.17610300f, -0.06389704f, 0.24395578f, 0.14616446f, -0.40236449f, -0.38468152f, 
    0.13512126f, 0.26844040f, 0.19009440f, 0.10132601f, -0.08535717f, -0.37517476f, 0.30463544f, 0.01122069f, 
    -0.06788178f, -0.18915910f, 0.18030339f, -0.12988618f, -0.08601885f, 0.16700993f, 0.09810627f, -0.02618122f, 
    -0.00492574f, -0.38360718f, -0.08538483f, 0.03361921f, 0.08002233f, -0.18636587f, 0.01572055f, 0.07142536f, 
    0.07629548f, 0.14261952f, -0.13709058f, -0.11295698f, -0.13599417f, -0.05678931f, 0.25298551f, 0.08532755f, 
    -0.16835190f, -0.13948604f, 0.20488310f, 0.10914409f, -0.15272947f, 0.16528606f, 0.09025618f, 0.20197277f, 
    0.05245857f, 0.09537948f, -0.11236882f, -0.29100522f, 0.03813802f, 0.26568279f, -0.16077736f, -0.07343359f, 
    -0.08904805f, -0.27015039f, 0.20622952f, 0.11994684f, -0.14801863f, 0.12559922f, 0.25415996f, 0.11710919f, 
    0.06428389f, -0.11684314f, -0.13079669f, -0.10308562f, 0.06085736f, -0.02172389f, -0.01434747f, -0.04943247f, 
    -0.03339690f, 0.08281694f, -0.04485182f, -0.08012829f, -0.06997748f, -0.12692910f, -0.10195617f, -0.02185016f, 
    0.04380380f, -0.03620123f, 0.05549669f, 0.07384572f, -0.09042948f, -0.04718079f, 0.00730731f, 0.03601514f, 
    -0.08855458f, -0.08755046f, -0.11594260f, 0.04314414f, -0.00663673f, -0.09761450f, -0.02361339f, -0.09707782f, 
    -0.13463750f, 0.02968337f, 0.01150565f, -0.13904704f, -0.03142551f, 0.03349545f, -0.07902209f, -0.00807273f, 
    0.02185418f, 0.08455930f, 0.03500317f, 0.06121659f, -0.13602838f, 0.05682723f, 0.07925279f, -0.07850146f, 
    -0.00490855f, 0.04075909f, -0.03922914f, -0.06057912f, 0.03333406f, -0.10838915f, -0.05430483f, -0.12736878f, 
    -0.06711684f, 0.02307480f, -0.13479821f, -0.12974036f, -0.10833675f, -0.02763470f, -0.11990244f, -0.11378182f, 
    -0.10196564f, -0.01465656f, 0.01498452f, 0.05601418f, 0.03460937f, -0.11613169f, -0.20945795f, 0.12463760f, 
    0.02663499f, -0.34199819f, -0.02758778f, 0.27075848f, 0.08687204f, 0.06897134f, -0.22816256f, 0.07429928f, 
    -0.00600351f, -0.16889757f, -0.05259804f, 0.09963068f, 0.07356090f, 0.09234842f, 0.37221843f, 0.22669254f, 
    0.10341001f, -0.09396861f, 0.02129411f, -0.10788291f, 0.05959919f, 0.19159070f, 0.00822969f, -0.15840770f, 
    -0.02115962f, -0.16169465f, 0.07962341f, -0.15969905f, -0.06442406f, 0.30904031f, -0.00310056f, -0.03781607f, 
    0.08162905f, -0.01032877f, -0.03147713f, -0.03577620f, 0.07542310f, 0.03156494f, -0.08976798f, 0.05607511f, 
    0.03434813f, 0.05736085f, -0.12888008f, -0.15170179f, -0.03396226f, -0.13640316f, 0.13936937f, -0.07639873f, 
    0.05017117f, -0.01351200f, 0.01173656f, -0.09091412f, -0.00478671f, -0.11609764f, 0.02017116f, -0.03494966f, 
    0.31057966f, 0.39395359f, -0.14327513f, -0.04570545f, 0.15486848f, 0.09194671f, 0.25629723f, 0.16881976f, 
    -0.12527932f, -0.04856027f, -0.02255758f, -0.17614147f, 0.32785261f, -0.02604575f, -0.09956182f, -0.05507376f, 
    0.02847867f, 0.19021690f, -0.23110089f, -0.02238716f, 0.08754122f, -0.52086127f, 0.39667940f, 0.04784854f, 
    0.00786771f, 0.45462015f, 0.26558247f, 0.11141495f, -0.08132436f, 0.15431406f, 0.32077730f, 0.11368630f, 
    0.29401720f, 0.10248585f, 0.12119199f, 0.05884108f, 0.25229028f, 0.35346520f, -0.21486138f, -0.12591574f, 
    -0.18133658f, 0.09155305f, -0.12301102f, -0.03241432f, 0.13320434f, 0.16820818f, 0.38253799f, 0.15445419f, 
    -0.08659919f, 0.07643601f, -0.07675954f, -0.06878189f, 0.10509705f, 0.00069581f, -0.06249870f, 0.12438878f, 
    0.34979436f, 0.37670630f, -0.01908293f, 0.10317478f, -0.05037135f, -0.05205254f, 0.15823400f, -0.08453393f, 
    0.18688181f, 0.19987886f, -0.12370750f, 0.01899487f, 0.24793150f, -0.02049373f, 0.21052237f, -0.02836612f, 
    -0.03636126f, -0.30410540f, -0.11717705f, -0.14143373f, -0.08577026f, 0.14683931f, 0.26798019f, 0.51393801f, 
    -0.02602726f, -0.29760179f, 0.06786827f, -0.06997582f, -0.00327928f, 0.59347481f, -0.07278821f, 0.05036754f, 
    0.56788695f, 0.20589079f, 0.07264834f, 0.13717905f, -0.15230271f, -0.13195512f, 0.05672240f, 0.16672775f, 
    -0.05389664f, -0.35904604f, 0.10727606f, 0.08186589f, -0.21894129f, 0.53717822f, -0.11854810f, 0.36088738f, 
    -0.00961664f, 0.29623681f, 0.07958873f, 0.06065647f, -0.19668567f, -0.01576880f, -0.11281920f, -0.12243775f, 
    -0.04918286f, 0.35647106f, -0.08559039f, 0.36289886f, 0.10044340f, 0.33920014f, -0.53433865f, 0.18456274f, 
    0.11864234f, -0.29366213f, 0.14748229f, 0.03717038f, 0.27089885f, 0.21651334f, -0.09360373f, -0.05912955f, 
    -0.34015918f, -0.37676656f, 0.15173402f, 0.05608886f, 0.26876950f, 0.07265446f, -0.00678490f, 0.28012142f, 
    -0.07637507f, -0.02269405f, 0.01333697f, 0.65669227f, -0.20340787f, -0.23095988f, 0.17315146f, 0.12284229f, 
    -0.03597611f, 0.01065923f, 0.18107396f, 0.01275106f, 0.23690788f, -0.01266761f, 0.52177459f, 0.41114905f, 
    -0.13651544f, -0.50414145f, -0.05702169f, -0.15674165f, 0.02383481f, 0.47922131f, -0.10189511f, -0.02407579f, 
    -0.37013239f, 0.22166285f, 0.06137474f, 0.18368611f, 0.04775923f, 0.01080358f, 0.61153883f, -0.07040961f, 
    0.00419653f, -0.17856097f, 0.07329626f, -0.11179179f, 0.19391091f, 0.07640699f, -0.14947015f, 0.04486836f, 
    0.24333608f, 0.21445899f, 0.18327560f, -0.40271422f, -0.07978658f, 0.09738528f, 0.04656684f, -0.10095252f, 
    0.07067668f, 0.10320105f, -0.17686448f, -0.12154620f, 0.04131496f, -0.02800842f, 0.01719441f, 0.06315825f, 
    -0.18828176f, 0.00144480f, -0.64301026f, -0.05445448f, 0.52966237f, 0.20713153f, -0.01089696f, -0.26733488f, 
    0.16594842f, 0.28872791f, -0.17087606f, 0.33938852f, 0.28546801f, -0.50182909f, 0.06030091f, 0.16862705f, 
    0.00158468f, -0.31717896f, -0.21611978f, -0.02335693f, -0.24312550f, -0.31173611f, 0.46405971f, -0.10153209f, 
    0.18184067f, -0.06839231f, 0.17662336f, 0.13120590f, 0.05011059f, 0.21725242f, 0.56324214f, -0.34221366f, 
    0.59204209f, -0.04229620f, 0.28733355f, 0.12614749f, 0.22352290f, 0.15534016f, 0.00733151f, 0.11461097f, 
    -0.40029380f, -0.20074171f, -0.24805775f, -0.03894189f, -0.32236645f, 0.00652461f, 0.10088307f, -0.15006040f, 
    -0.11897218f, 0.02799933f, -0.70056248f, -0.54546982f, 0.01875442f, 0.20700599f, -0.15896609f, 0.25802001f, 
    0.27827680f, -0.57705307f, 0.37018383f, 0.03684144f, 0.00989906f, 0.10691442f, -0.11672992f, -0.15409864f, 
    -0.04382698f, -0.02134066f, -0.08091856f, -0.11297077f, 0.18839984f, 0.25387549f, 0.33496976f, 0.34595880f, 
    0.24503410f, -0.26336411f, -0.01119617f, 0.03554036f, -0.10545524f, 0.22276045f, 0.01814593f, 0.16711347f, 
    0.11797237f, -0.05285047f, 0.06662844f, -0.01227000f, -0.17440963f, -0.21797153f, 0.02044268f, 0.39215934f, 
    -0.16413707f, -0.14359920f, -0.04931314f, -0.06376968f, 0.09038612f, -0.34365910f, -0.07345087f, -0.29945731f, 
    0.18490918f, 0.06117475f, 0.11183754f, -0.26860437f, -0.11864498f, -0.33619639f, -0.12794867f, 0.35350358f, 
    -0.37657630f, -0.12078201f, -0.60832709f, -0.04289366f, -0.16355242f, -0.03306191f, -0.35064512f, -0.21691301f, 
    -0.14252017f, -0.00096085f, -0.54122108f, -0.00608108f, 0.10782321f, 0.16428077f, -0.08904504f, 0.55284178f, 
    0.09214445f, -0.70963335f, 0.07780970f, 0.06359579f, 0.06802442f, 0.26365039f, -0.13091639f, -0.10135993f, 
    0.34678245f, 0.56562245f, -0.11944181f, 0.11458859f, 0.10806759f, 0.03260302f, 0.10353620f, 0.32274362f, 
    0.02957589f, -0.11934643f, -0.09122793f, 0.48075515f, 0.41483521f, 0.10859953f, -0.19597189f, 0.05202683f, 
    0.04503332f, 0.23595178f, -0.34232318f, -0.12362386f, -0.01745501f, -0.52320623f, 0.44604650f, 0.18094948f, 
    -0.11765753f, 0.69817764f, 0.30388314f, 0.13742162f, -0.18085122f, 0.42909390f, 0.53827238f, 0.10023987f, 
    0.50248700f, 0.28947765f, 0.34733742f, -0.13787143f, 0.33503070f, 0.50064003f, 0.08920553f, -0.27642015f, 
    0.23760478f, -0.08004294f, -0.74977171f, 0.11337387f, 0.03799941f, 0.06571698f, 0.54176128f, -0.08212568f, 
    0.22519484f, -0.03498827f, 0.13417119f, -0.21422541f, 0.28582242f, 0.06193940f, -0.02997283f, 0.15031803f, 
    0.32681242f, -0.23172298f, 0.09262740f, 0.14002457f, 0.02423524f, -0.10182871f, -0.16339867f, -0.12680382f, 
    -0.16424596f, 0.00277441f, -0.11594892f, 0.11224605f, -0.11687437f, -0.06876838f, -0.27183631f, -0.23172687f, 
    0.00272692f, 0.08046341f, 0.02989284f, 0.06676905f, 0.21650504f, -0.05803283f, 0.10485448f, 0.02313496f, 
    0.09828584f, 0.24982196f, 0.14738533f, 0.00491653f, -0.26364258f, -0.01778786f, -0.02453405f, 0.01357258f, 
    -0.05972723f, 0.03693667f, -0.28824401f, -0.00236757f, 0.08045988f, -0.20738898f, -0.14052454f, 0.03293220f, 
    -0.18179414f, -0.22721919f, -0.18379334f, -0.04518549f, 0.19318764f, 0.11451950f, -0.00996017f, -0.32213259f, 
    0.04536141f, -0.09291980f, 0.04318735f, 0.06682755f, -0.02533678f, -0.05029695f, -0.04831831f, -0.06854308f, 
    -0.08309198f, -0.12803768f, -0.09280822f, 0.04237350f, -0.20160203f, -0.12847580f, 0.19156922f, 0.13564588f, 
    0.07735827f, 0.16642384f, -0.00344751f, -0.02173185f, -0.14067456f, 0.10280129f, 0.02028168f, 0.03582693f, 
    0.02024853f, 0.31335518f, 0.02805683f, 0.12255500f, -0.02506021f, 0.15080810f, -0.14309327f, 0.08412714f, 
    -0.03689134f, 0.10298671f, 0.18230958f, 0.67664623f, 0.38308996f, -0.16563322f, -0.05411628f, 0.11475272f, 
    0.05415711f, 0.16573873f, -0.11843344f, 0.08466727f, -0.06038084f, -0.29499346f, 0.78531486f, 0.09097980f, 
    -0.05062256f, 0.27985284f, 0.13567790f, -0.13584021f, -0.23533396f, 0.54679537f, 0.31655166f, 0.15049741f, 
    0.19613850f, 0.22708695f, 0.25685096f, 0.01915198f, 0.21203361f, 0.35520643f, 0.25967380f, -0.25167787f, 
    0.31057370f, -0.20831014f, -0.08863783f, 0.06766284f, 0.21499106f, 0.09509909f, 0.25454110f, -0.02249140f, 
    0.35728490f, 0.07624346f, 0.33505329f, -0.78413862f, -0.03860518f, 0.08000822f, -0.08230080f, -0.09024713f, 
    0.10233908f, -0.02809121f, -0.01547017f, -0.11952849f, 0.00014959f, -0.21815045f, 0.21881761f, 0.12709850f, 
    -0.20198923f, -0.25047287f, 0.45100635f, -0.07090883f, 0.08336008f, -0.10124644f, 0.19877499f, 0.29281378f, 
    -0.00560187f, -0.09395041f, -0.07788587f, -0.05686250f, -0.52100146f, -0.25725219f, 0.02220345f, -0.04183828f, 
    -0.04147746f, -0.01140592f, -0.06152419f, -0.11165285f, 0.24179848f, -0.24972530f, 0.35068429f, 0.38038746f, 
    -0.02003678f, -0.39141864f, 0.08566997f, -0.02554657f, 0.29501197f, 0.43516997f, -0.26054990f, 0.10041180f, 
    -0.14952381f, 0.45753473f, 0.19949529f, -0.04719714f, 0.33079779f, 0.05937427f, 0.25142214f, -0.12313561f, 
    -0.02476535f, -0.03518989f, 0.17535451f, 0.10296558f, 0.05989191f, 0.01080267f, -0.38773331f, -0.01115342f, 
    0.29615873f, 0.13003945f, 0.01550888f, -0.12007198f, 0.04513778f, -0.04458362f, 0.23162928f, 0.00139633f, 
    0.03570971f, 0.17296080f, -0.17584109f, -0.03374254f, -0.07761456f, 0.00538699f, -0.03341412f, 0.22636817f, 
    -0.02123179f, 0.15369414f, 0.43024611f, -0.07806875f, 0.00703960f, 0.10953461f, 0.02771532f, 0.06483289f, 
    -0.05487454f, -0.19714011f, 0.12822887f, 0.30640173f, -0.02412626f, -0.07329942f, 0.03101252f, -0.03253499f, 
    -0.06208807f, 0.12772350f, -0.06457637f, -0.07884587f, 0.15549593f, -0.12914221f, 0.46172068f, 0.35698330f, 
    -0.14642420f, 0.19041644f, 0.30985445f, -0.17684641f, -0.09149767f, 0.32207489f, 0.01929731f, 0.22614247f, 
    -0.20972456f, 0.35817751f, 0.26987183f, -0.21766479f, 0.28355217f, -0.01425760f, 0.45349610f, -0.18263768f, 
    0.46832389f, -0.04746851f, -0.09487589f, 0.11234866f, 0.03429020f, -0.09990630f, 0.24354146f, -0.16727863f, 
    0.22981542f, 0.15721604f, 0.37573293f, -0.12381092f, 0.03800313f, 0.05780959f, -0.20023753f, -0.01277782f, 
    0.16988873f, -0.17638454f, -0.21292317f, -0.15994079f, -0.19397660f, -0.04129819f, 0.05954128f, 0.06149916f, 
    -0.16521557f, 0.04659637f, -0.07262235f, -0.06540942f, 0.34562883f, -0.00199938f, 0.04121994f, 0.33536929f, 
    0.30473921f, -0.05367448f, 0.03973463f, -0.31559193f, -0.54611772f, 0.41805613f, 0.25111800f, 0.15878017f, 
    -0.08991064f, -0.36984557f, 0.07953795f, 0.28177771f, 0.24216509f, 0.71900463f, -0.17511703f, 0.46376646f, 
    0.12812309f, 0.01360432f, -0.01522650f, 0.01258211f, -0.00697687f, -0.24825497f, -0.18491268f, 0.01121742f, 
    -0.23277029f, 0.07183629f, 0.10294784f, 0.29731056f, -0.39449510f, 0.33286485f, 0.13453470f, 0.25550109f, 
    0.25407332f, 0.30528423f, -0.27287954f, -0.07241915f, 0.03691192f, 0.04789597f, -0.21569610f, 0.22453097f, 
    -0.08709037f, 0.34469765f, 0.32901648f, 0.37919602f, 0.01515042f, 0.21608303f, -0.49084115f, -0.00840314f, 
    0.20666841f, -1.08802736f, 0.01059080f, -0.09514052f, -0.22569542f, 0.06433024f, -0.18397334f, 0.08485483f, 
    -0.09160837f, -0.13604037f, -0.22617179f, 0.03925404f, 0.40807232f, 0.05129171f, -0.34430841f, -0.31768975f, 
    0.04103275f, 0.10562273f, 0.01219093f, 0.47567052f, 0.05109344f, -0.25658524f, 0.21939905f, 0.17044501f, 
    -0.05069439f, -0.05328019f, 0.18718377f, -0.02198246f, 0.19506417f, 0.47143593f, 0.11117169f, 0.17227967f, 
    0.35035571f, -0.10661682f, -0.08384817f, -0.14459017f, -0.06121496f, 0.33038792f, 0.10992039f, 0.05708656f, 
    -0.03798989f, -0.13283318f, -0.08869922f, 0.09295703f, -0.21199648f, 0.05827672f, 0.32395017f, 0.10194526f, 
    0.06646253f, -0.00901855f, -0.12110133f, -0.09839697f, -0.00149907f, 0.03827684f, 0.31350532f, 0.10010725f, 
    0.04216675f, 0.32038909f, 0.39052367f, -0.58840597f, -0.03370506f, 0.30760205f, 0.07104114f, 0.12179196f, 
    -0.13396291f, -0.22479087f, 0.11002621f, 0.04330132f, 0.18327317f, 0.05881475f, 0.10580231f, 0.03333876f, 
    0.15128489f, -0.46780190f, 0.31003556f, 0.07648548f, 0.07610665f, 0.02511314f, 0.39253578f, 0.14779615f, 
    -0.08348092f, -0.28066406f, -0.01734185f, -0.57306761f, -0.04040141f, 0.04504950f, 0.11266464f, -0.13959844f, 
    -0.00358109f, -0.28360674f, -0.07143736f, -0.29059139f, 0.16629827f, 0.07365212f, -0.38874531f, -0.02071360f, 
    -0.27063081f, -0.52106917f, 0.18872200f, 0.02762240f, 0.57471108f, -0.33569688f, -0.31855634f, 0.12456807f, 
    0.41377461f, 0.49916008f, 0.00937479f, -0.35785100f, -0.04154355f, 0.10592204f, -0.01173214f, 0.33270106f, 
    -0.20635581f, -0.48811960f, 0.17411953f, 0.09414033f, 0.00427307f, 0.01404958f, -0.51565534f, -0.16102539f, 
    0.08087426f, 0.00784307f, -0.08206034f, 0.38481757f, -0.00801846f, 0.27529585f, -0.78613913f, 0.19175535f, 
    -0.03077353f, 0.02561160f, -0.05213974f, 0.07989457f, -0.08253285f, 0.21262665f, -0.03638904f, -0.04462584f, 
    -0.17614193f, -0.26574379f, -0.00253299f, 0.07019362f, 0.12389791f, 0.15481767f, -0.07877164f, -0.07525731f, 
    0.25141498f, -0.05846376f, 0.08629650f, -0.02718011f, -0.32569277f, 0.25271365f, -0.02170014f, 0.15900749f, 
    -0.00930218f, -0.00561680f, 0.07608768f, 0.35541937f, 0.05412798f, -0.07134944f, 0.09738485f, -0.00743164f, 
    -0.35300058f, -0.25415301f, -0.05848783f, 0.08579274f, 0.28353265f, -0.08901599f, -0.07255749f, -0.25364575f, 
    -0.06093606f, 0.08493844f, 0.10472910f, 0.20803009f, -0.02257645f, -0.35001382f, 0.03788291f, 0.03545079f, 
    0.07203361f, -0.06338578f, 0.06020033f, -0.07475081f, -0.06110845f, -0.18205947f, -0.09227603f, 0.10411611f, 
    0.08239622f, 0.07325651f, -0.05587329f, 0.14186446f, 0.06082068f, 0.17153189f, 0.08180226f, -0.03827094f, 
    0.15142675f, -0.11525119f, -0.04271990f, 0.05987651f, -0.19505835f, 0.14586285f, 0.05257007f, 0.24619432f, 
    0.06936821f, 0.04066916f, 0.17825465f, 0.11345262f, -0.13454899f, 0.02471013f, -0.32052663f, -0.27572531f, 
    0.35481045f, 0.19802243f, 0.31370842f, 0.29399559f, -0.04569133f, -0.35425526f, 0.03131025f, -0.02050144f, 
    0.09688532f, 0.04790099f, 0.19412294f, 0.03649538f, -0.20112084f, -0.03774060f, 0.41914484f, -0.26389271f, 
    0.14419146f, 0.23186438f, 0.33498579f, 0.13562062f, 0.20647456f, 0.08106586f, 0.24357808f, 0.19892678f, 
    0.07022022f, 0.27154261f, 0.36674049f, 0.10498677f, -0.03505336f, 0.49007434f, 0.32264289f, -0.12585360f, 
    -0.24155648f, -0.19165444f, 0.02554363f, 0.08383639f, 0.13958311f, -0.00655374f, 0.06992994f, 0.26185942f, 
    0.32823274f, -0.11860481f, -0.29086521f, -0.56876767f, 0.04839135f, 0.13721657f, 0.05996413f, -0.10503211f, 
    0.03244060f, -0.19188455f, -0.05332915f, -0.06810944f, 0.09946822f, -0.06364736f, 0.23470338f, 0.15545070f, 
    0.14023884f, -0.07061604f, 0.09290349f, 0.11001231f, 0.07943687f, -0.04768035f, -0.12535848f, -0.00444286f, 
    0.22026992f, -0.13666676f, 0.23515680f, 0.20385830f, -0.30907884f, -0.04469703f, 0.14605699f, -0.18695025f, 
    -0.03954424f, 0.04664091f, 0.20378290f, 0.00069051f, 0.04938113f, -0.10662662f, 0.12315933f, 0.06577772f, 
    -0.09074210f, 0.09243354f, 0.21333311f, 0.08830477f, 0.00567240f, 0.09020375f, -0.13137375f, 0.14417930f, 
    -0.19535980f, 0.21336076f, 0.20157629f, 0.03450814f, -0.03658861f, 0.07368927f, 0.35227904f, -0.24601038f, 
    -0.19876045f, 0.00484883f, -0.03413311f, 0.01640736f, 0.24899413f, -0.07441536f, 0.14524071f, 0.26985207f, 
    0.13784896f, 0.08569161f, 0.03923214f, -0.17055866f, 0.18866226f, -0.05438305f, -0.06941425f, 0.04296162f, 
    0.03621307f, -0.29444969f, 0.02197796f, -0.28387693f, -0.13253562f, -0.10903729f, 0.01000379f, 0.28009087f, 
    0.05001388f, 0.18683283f, -0.45393607f, -0.06232464f, 0.06508285f, -0.06032763f, -0.10393538f, -0.18225251f, 
    0.09049753f, -0.13889465f, 0.14964238f, -0.07693747f, 0.02737078f, 0.32959935f, -0.22069024f, -0.03476841f, 
    0.03379382f, -0.24618773f, -0.18907057f, 0.08652648f, -0.15428938f, -0.06997319f, -0.09099266f, -0.22000898f, 
    -0.07723690f, 0.37950534f, 0.27202016f, 0.06745385f, 0.25471881f, 0.01055262f, 0.34280473f, -0.13876374f, 
    0.71275049f, 0.02550744f, 0.34130400f, 0.02579890f, 0.02570903f, -0.04829705f, -0.28233284f, 0.04024480f, 
    0.37985578f, 0.32529423f, -0.10642451f, -0.01362972f, 0.03349165f, -0.04905728f, 0.08121315f, 0.22321218f, 
    0.12681212f, -0.18628861f, 0.19692543f, 0.25314277f, 0.10638796f, 0.01589947f, 0.30124620f, -0.15995127f, 
    0.39667621f, 0.24411100f, 0.26309666f, -0.17150198f, 0.00952928f, -0.14922528f, -0.13104570f, -0.11068644f, 
    -0.14836949f, 0.06983551f, 0.05685079f, 0.01621197f, 0.11552961f, 0.04734885f, -0.10457513f, -0.10117461f, 
    -0.07169753f, -0.07637098f, -0.04975207f, 0.05415574f, 0.02085712f, -0.03006108f, 0.08081399f, -0.08452844f, 
    -0.02646086f, -0.06566253f, -0.09394623f, -0.11394896f, -0.06898844f, 0.03371222f, -0.02642947f, -0.03349440f, 
    -0.03164029f, -0.07999552f, 0.05730692f, -0.06609643f, -0.09276269f, 0.03437228f, -0.01896730f, -0.04343879f, 
    -0.03088201f, -0.15235995f, -0.11166949f, 0.08724486f, -0.03950634f, -0.09721941f, 0.01602565f, -0.09546740f, 
    0.03351261f, 0.08385113f, -0.01729475f, 0.05493242f, -0.03782884f, -0.01910825f, 0.07736529f, -0.08618767f, 
    -0.04841170f, 0.03883691f, -0.02333310f, 0.04454873f, -0.16401677f, -0.00482696f, -0.04101655f, -0.06632880f, 
    -0.02912045f, 0.01137003f, -0.03779218f, -0.10336611f, -0.10000511f, -0.02238532f, -0.15649228f, -0.09538057f, 
    0.10452123f, 0.25936639f, 0.05026636f, 0.00066862f, 0.17357090f, 0.01557563f, 0.16224831f, 0.09200301f, 
    -0.37199914f, -0.14393464f, -0.20442767f, 0.19625238f, 0.17842710f, -0.49600255f, 0.12091265f, 0.33836567f, 
    -0.08866575f, 0.02105733f, -0.12366018f, -0.41195437f, 0.04913317f, -0.00387944f, 0.40955177f, 0.05080760f, 
    0.32080969f, 0.03180227f, 0.04778861f, -0.03569625f, -0.46004760f, 0.22533175f, 0.30668867f, 0.06386271f, 
    -0.17366436f, -0.03848639f, 0.06557190f, 0.00691210f, 0.20638648f, -0.65823555f, -0.13399361f, 0.10149332f, 
    0.02680442f, -0.40398490f, 0.20337299f, 0.11478487f, -0.10370242f, 0.26297787f, 0.16802320f, -0.28561586f, 
    0.02299526f, 0.22774164f, 0.18062168f, -0.30597007f, 0.13400447f, 0.11147200f, -0.18181680f, 0.04157560f, 
    0.04897308f, 0.14877319f, 0.12527679f, 0.21240336f, 0.44700098f, 0.20988812f, -0.09440117f, -0.17652376f, 
    0.07654201f, -0.20023456f, -0.25443909f, 0.10854779f, 0.37359959f, 0.06636302f, 0.13155489f, 0.38108289f, 
    -0.09826066f, 0.16423038f, 0.04258223f, 0.14951095f, 0.61334509f, -0.68389678f, 0.26827982f, -0.04864849f, 
    0.11638474f, 0.24517272f, -0.06083917f, -0.40201253f, 0.07751507f, -0.20778468f, 0.21490334f, 0.27872315f, 
    0.19976383f, -0.32278723f, -0.11485996f, -0.00845118f, -0.09998865f, 0.14810286f, 0.23898436f, 0.06362059f, 
    0.27446732f, 0.05819878f, -0.22006318f, -0.05932125f, 0.41180402f, 0.20160909f, 0.11681187f, 0.20778628f, 
    0.11187121f, -0.28625023f, 0.04248103f, 0.09183430f, -0.04718626f, -0.01451947f, -0.15710013f, -0.06604294f, 
    -0.18090954f, -0.06556110f, 0.17698953f, -0.38222247f, -0.09176034f, 0.07944145f, 0.16106752f, 0.32830179f, 
    0.02420241f, 0.14598188f, -0.04561082f, 0.11277858f, 0.12282214f, 0.37373060f, 0.04927403f, -0.06911525f, 
    -0.04622927f, 0.07564635f, -0.83449572f, -0.08672921f, 0.34992611f, 0.12332378f, 0.16747113f, 0.13573819f, 
    -0.01362341f, 0.23854360f, -0.16737406f, -0.07170008f, -0.07542253f, 0.10505000f, 0.16554333f, 0.05741173f, 
    -0.07445164f, -0.28489614f, -0.02668215f, 0.49384081f, 0.11116322f, 0.03779376f, -0.36506319f, 0.21588941f, 
    0.20751086f, -0.16844402f, -0.60014826f, 0.02901825f, -0.75415444f, -0.01834866f, 0.07053298f, -0.18413720f, 
    0.02556236f, -0.78702700f, -0.43697637f, 0.16000880f, 0.01528406f, -0.39622849f, -0.57725126f, 0.19237413f, 
    -0.54732102f, 0.57837790f, -0.12816967f, 0.09778360f, -0.30974436f, 0.08384515f, -0.14424059f, -0.13357621f, 
    -0.45439848f, 0.15091480f, -0.68577075f, -0.23574048f, -0.01900057f, -0.07088387f, 0.11827341f, 0.03205776f, 
    0.21156994f, 0.00476883f, 0.30424458f, -0.20177017f, 0.32556671f, 0.11347467f, -0.45609596f, -0.55108458f, 
    -0.08630943f, 0.36394301f, -0.16400854f, -0.12229501f, 0.27369466f, 0.11764793f, 0.16859800f, 0.04300095f, 
    -0.27030921f, -0.08783460f, -0.23303138f, 0.48270282f, -0.16501814f, -0.28177559f, 0.19433153f, 0.51193750f, 
    0.04156485f, 0.08294046f, -0.21777855f, -0.19181974f, 0.26713401f, 0.00441865f, 0.57895994f, 0.18905799f, 
    0.45158440f, 0.20102350f, -0.09359942f, -0.12738459f, -0.54087424f, 0.48954701f, 0.36659732f, 0.05975960f, 
    -0.40322265f, 0.14224820f, 0.10272930f, 0.27531999f, 0.16087422f, -0.65449482f, 0.08409107f, 0.07908698f, 
    0.22354457f, -0.30469269f, 0.11554088f, -0.02163835f, 0.01095671f, 0.04337519f, 0.32002905f, -0.08384131f, 
    0.21909517f, 0.25324678f, 0.15717192f, -0.44028738f, -0.03733295f, 0.02267416f, -0.23241092f, -0.05113172f, 
    0.31196550f, 0.15526594f, 0.11213078f, 0.18263724f, 0.41199398f, 0.03865931f, -0.23421027f, -0.14767028f, 
    0.07811986f, 0.02077669f, 0.12089454f, 0.02880624f, 0.00772063f, -0.12425323f, -0.03186345f, 0.04643069f, 
    0.05023119f, 0.02648357f, -0.06467324f, -0.00181818f, 0.02750680f, -0.03556250f, -0.09836437f, 0.04809417f, 
    -0.06731449f, 0.00216961f, -0.04636398f, -0.03612155f, 0.03020743f, -0.10457902f, -0.12017205f, 0.00352918f, 
    0.05504124f, -0.09243524f, -0.04444146f, -0.05804762f, -0.03677262f, 0.00677359f, 0.09851414f, -0.01942736f, 
    -0.09778175f, -0.04203995f, -0.07974769f, 0.08490802f, -0.10416104f, 0.04851712f, -0.05615781f, 0.05445106f, 
    0.00106391f, 0.06959465f, -0.12169592f, 0.01153415f, 0.03443922f, -0.01268138f, -0.11987449f, 0.04356942f, 
    -0.02370594f, -0.08236019f, -0.06640975f, 0.03857313f, 0.00765547f, 0.09450459f, 0.08997966f, 0.02983451f, 
    0.05755191f, -0.12351184f, -0.12136164f, -0.04542004f, 0.00328396f, -0.10392153f, 0.05361684f, -0.03610164f, 
    0.19585738f, 0.23618029f, 0.19809987f, -0.08191492f, -0.05970676f, -0.04887267f, 0.14429575f, 0.10952563f, 
    0.10539603f, -0.25133637f, 0.04308598f, -0.18404455f, -0.62535644f, 0.56547457f, 0.05521857f, -0.16394399f, 
    0.08954272f, -0.02863213f, -0.06541906f, 0.16103563f, 0.25716627f, 0.07526514f, -0.10575535f, 0.23049411f, 
    -0.10763828f, 0.23329176f, -0.02957112f, -0.01849820f, -0.07763037f, -0.06430846f, -0.42512125f, 0.10201111f, 
    -0.33251184f, 0.19171864f, 0.09345708f, 0.18416648f, -0.09262245f, 0.16888157f, 0.12290701f, -0.03165098f, 
    -0.12284574f, 0.13977663f, -0.04801784f, 0.02708419f, 0.27554354f, -0.07703651f, 0.15038353f, 0.13523914f, 
    -0.15416965f, 0.19277862f, 0.03927757f, 0.22534509f, 0.08527415f, 0.19559468f, -0.09427869f, 0.05608631f, 
    0.02771125f, 0.04106932f, -0.12423610f, -0.11565355f, -0.20887825f, 0.03913974f, 0.03228039f, 0.09342405f, 
    -0.14906585f, -0.16456750f, 0.85721475f, -0.00835847f, 0.01010088f, 0.07662744f, 0.30542570f, 0.09728776f, 
    0.40248892f, -0.12140723f, 0.25168189f, 0.03816309f, -0.44488642f, -0.52624351f, 0.18559115f, -0.29318789f, 
    0.05599800f, -0.18339650f, 0.02972541f, 0.16685994f, 0.18306299f, -0.01086012f, 0.39285716f, 0.06902932f, 
    -0.36797991f, 0.07642595f, 0.22207668f, -0.20523363f, 0.29105440f, 0.48611659f, -0.25425735f, -0.03054713f, 
    -0.07564209f, 0.50227910f, 0.33951536f, -0.36131495f, -0.21337536f, 0.45789191f, 0.34275576f, 0.13862313f, 
    -0.04914152f, -0.08481941f, -0.00180791f, 0.06423118f, 0.28281945f, 0.06829657f, -0.52717507f, -0.11651560f, 
    0.31571338f, 0.11879992f, -0.02693661f, -0.31722999f, 0.22370827f, -0.03687878f, 0.19960821f, 0.03004122f, 
    0.04179496f, -0.15845251f, -0.27499640f, -0.11216694f, -0.29709300f, 0.05773374f, 0.07925388f, 0.33242559f, 
    0.20000751f, 0.06809872f, -0.00169148f, -0.03137742f, -0.17425035f, 0.18340364f, 0.01871002f, -0.62055838f, 
    0.28275543f, 0.07145543f, 0.19349784f, -0.67344111f, -0.20521283f, 0.46080798f, -0.24584386f, -0.05925002f, 
    0.08591855f, -0.19297759f, 0.10506937f, 0.13136740f, -0.09778181f, 0.12282329f, -0.33102334f, -0.44964796f, 
    0.22501388f, 0.13940632f, 0.30852982f, 0.18979649f, 0.48440588f, -0.23769820f, 0.02985931f, -0.09031949f, 
    0.42452544f, -0.14116988f, 0.29977328f, 0.13467531f, -0.11635785f, -0.34283835f, -0.34435815f, 0.18047701f, 
    -0.24933590f, 0.35167465f, -0.07532129f, 0.04375293f, 0.04184848f, -0.09945813f, -0.10592512f, 0.12221069f, 
    0.30721551f, -0.06239514f, -0.36066175f, 0.52847338f, 0.19322459f, -0.10947476f, 0.07529609f, -0.06116078f, 
    0.12420193f, -0.08329876f, 0.16094488f, 0.06327672f, 0.13710593f, 0.05444113f, 0.13203232f, 0.17132778f, 
    -0.32941630f, -0.53939533f, 0.16148473f, 0.05763733f, 0.48990077f, -0.06385162f, 0.07653441f, 0.34660438f, 
    -0.06107355f, 0.15164320f, -0.04848647f, 0.01519243f, -0.56365830f, -0.19022946f, 0.14147931f, 0.15011936f, 
    -0.02422819f, -0.48365507f, -0.22024344f, -0.44258866f, 0.38021171f, 0.19836234f, 0.21874395f, 0.62500453f, 
    0.24050835f, -0.56258267f, -0.16061130f, -0.25283739f, -0.00414726f, -0.03347545f, -0.34024557f, 0.02647563f, 
    -0.30055746f, 0.23937902f, 0.03612651f, -0.18462685f, -0.26452702f, -0.28659350f, 0.24648349f, 0.24230176f, 
    0.05175778f, -0.90255874f, 0.30197772f, 0.00649321f, -0.07864331f, -0.13256285f, -0.40755486f, -0.22325015f, 
    0.01084948f, 0.27538812f, -0.00680362f, -0.15423156f, -0.11612128f, 0.27192289f, -0.86435652f, -0.06108111f, 
    -0.00871059f, -0.28182560f, -0.27589962f, 0.03270163f, 0.13687801f, 0.13389313f, -0.28125599f, 0.06739330f, 
    -0.07128644f, -0.04567281f, -0.05580834f, -0.11264276f, 0.24509473f, 0.23497631f, 0.19935158f, 0.36338228f, 
    -0.13694459f, -0.03503301f, -0.01869569f, -0.19418533f, 0.21458896f, 0.09490546f, 0.08672568f, 0.06798012f, 
    0.07301478f, 0.05845925f, 0.08435680f, -0.02853773f, 0.02362468f, 0.18156284f, -0.30669990f, 0.17229758f, 
    0.00399041f, -0.41820931f, -0.04145852f, 0.03474177f, 0.12153221f, -0.22984800f, -0.11751085f, 0.00907382f, 
    0.25567147f, -0.16024545f, -0.19801162f, -0.05584708f, 0.05174419f, -0.11920183f, -0.20227882f, 0.38412523f, 
    -0.08621994f, -0.07518470f, -0.13033874f, -0.05801333f, -0.21466778f, -0.21600679f, -0.22028320f, 0.04560978f, 
    -0.30986077f, 0.13747534f, -0.14289790f, 0.19259189f, 0.04166111f, 0.27110374f, -0.04022379f, 0.38455620f, 
    0.05966265f, -0.07857267f, 0.21510603f, 0.12782218f, -0.04372264f, 0.33365500f, -0.08544915f, -0.13890621f, 
    -0.01104910f, 0.32721138f, 0.06886840f, 0.11523339f, 0.01266624f, -0.09984986f, 0.06024686f, -0.07593580f, 
    0.17269017f, -0.07866876f, 0.23213217f, -0.14129078f, -0.25987646f, 0.45411238f, -0.12857182f, -0.01013635f, 
    -0.07542951f, -0.04550876f, -0.08791617f, 0.21923621f, 0.12746038f, 0.10904042f, 0.01266589f, 0.00245077f, 
    0.16665711f, 0.64151782f, 0.41535723f, -0.01896776f, 0.15657020f, 0.16973171f, 0.00542027f, 0.13641353f, 
    0.08554677f, 0.14520296f, 0.26610228f, 0.07610077f, -0.07438456f, -0.17533132f, 0.09425660f, -0.21108855f, 
    0.02705671f, 0.37185010f, -0.04402351f, -0.08661605f, 0.25836998f, -0.00848825f, 0.21614146f, 0.06308418f, 
    0.41503772f, -0.04891548f, 0.51695675f, 0.13002414f, 0.26565850f, -0.05910814f, 0.23965234f, -0.20604594f, 
    0.25234488f, -0.10650382f, -0.00393543f, 0.02902345f, 0.07086392f, -0.10641371f, 0.00430049f, 0.28772372f, 
    0.07959466f, -0.37777022f, 0.30397290f, 0.06215669f, 0.06551832f, -0.03534846f, 0.13271055f, -0.23326990f, 
    0.12016890f, 0.13732463f, 0.19270948f, -0.39103016f, -0.38158801f, 0.23724832f, 0.15199871f, -0.18730748f, 
    -0.01359476f, -0.08155038f, -0.04139677f, -0.11097382f, 0.17546988f, 0.27843148f, 0.13405964f, 0.25011048f, 
    -0.21714856f, -0.12844278f, 0.22860432f, 0.06881602f, 0.39474100f, -0.29266876f, -0.38458094f, 0.25210348f, 
    -0.12544452f, 0.53402740f, 0.20793687f, -0.11741214f, -0.21151064f, 0.26479131f, 0.25224477f, 0.08221820f, 
    -0.06505661f, 0.14865491f, 0.23714527f, 0.12213966f, 0.20044936f, 0.03038658f, 0.03252819f, 0.29472145f, 
    0.24484508f, 0.25590771f, 0.20616369f, 0.40957347f, 0.17496178f, 0.32196090f, -0.15757406f, -0.16258046f, 
    -0.13677077f, 0.08465742f, -0.09916136f, -0.04266360f, -0.26946291f, -0.06761982f, 0.11071252f, 0.34109098f, 
    0.31065464f, -0.09194272f, 0.38724425f, 0.11253211f, 0.31102142f, 0.16717082f, 0.56736082f, 0.60744119f, 
    -0.18024813f, -0.51625788f, -0.01770328f, -0.44599921f, -0.10612531f, 0.35936746f, 0.08912239f, -0.08793215f, 
    -0.01362051f, 0.12014093f, -0.41817245f, -0.30595741f, 0.12178838f, -0.25993675f, -0.15020345f, 0.38824415f, 
    -0.43076140f, 0.01633139f, 0.05377242f, -0.11659754f, 0.20263556f, -0.05151894f, -0.08410681f, 0.11772895f, 
    0.00361698f, 0.29985359f, 0.16819195f, -0.22234927f, 0.25073820f, 0.14751516f, 0.00625712f, 0.33507460f, 
    -0.40217912f, -0.09847477f, 0.16328764f, -0.00589559f, 0.11617403f, 0.07560562f, -0.33027458f, -0.28124064f, 
    0.10730423f, 0.13310334f, -0.32925174f, 0.03124098f, 0.13864157f, 0.06743129f, -0.58500385f, 0.15451081f, 
    0.21683954f, 0.06569684f, -0.07762500f, -0.00510606f, -0.30775255f, 0.06490353f, -0.15398869f, -0.08726988f, 
    0.54543519f, 0.32696015f, -0.35501432f, -0.03138134f, -0.00029373f, 0.06045871f, -0.18379283f, -0.27517685f, 
    -0.08896963f, -0.13670167f, 0.15640007f, 0.23371390f, 0.05960100f, 0.44753632f, 0.18483706f, 0.13057838f, 
    0.11022119f, -0.07155567f, -0.07749825f, -0.23284923f, -0.13603887f, 0.09249831f, 0.03390842f, 0.01260397f, 
    -0.05696577f, 0.53524792f, 0.09897357f, 0.31977743f, -0.21698792f, -0.05815798f, -0.14832444f, 0.35740799f, 
    0.34793827f, 0.05605262f, -0.06711769f, 0.02074322f, -0.32250482f, 0.43501684f, 0.09333723f, -0.17579134f, 
    -0.15783653f, 0.16967839f, -0.38280192f, 0.05934728f, 0.16417329f, 0.02920383f, 0.51311153f, 0.28212795f, 
    -0.24222846f, -0.02879559f, 0.06850766f, 0.13770515f, 0.02576930f, 0.33742958f, -0.11733348f, -0.08981498f, 
    0.12428001f, -0.20068051f, 0.27207270f, -0.03998652f, -0.17921907f, -0.08428215f, 0.05646164f, 0.01867175f, 
    -0.04181210f, 0.13357148f, -0.08408327f, 0.05648474f, -0.08930281f, 0.05723110f, -0.02240711f, -0.06205675f, 
    -0.07024792f, 0.02901230f, -0.04896131f, -0.02109895f, -0.09802801f, -0.02153654f, -0.06113068f, 0.00969219f, 
    0.10144384f, -0.13168372f, 0.08159755f, 0.06933084f, 0.09602121f, 0.11626475f, -0.04126989f, -0.00805014f, 
    -0.10662421f, -0.04407142f, -0.06876378f, -0.15990859f, 0.02333180f, -0.07666054f, 0.07431231f, -0.12841272f, 
    -0.00721023f, -0.04135818f, 0.05672506f, -0.14520413f, -0.04433243f, 0.03250824f, -0.06248038f, 0.05860287f, 
    -0.03719224f, 0.04598302f, 0.02434289f, -0.01039083f, -0.04534222f, 0.10549416f, -0.04852501f, -0.08408372f, 
    -0.10384686f, -0.09979383f, -0.14566271f, -0.02819374f, 0.09630995f, -0.03268219f, 0.09476124f, -0.06736076f, 
    -0.05554354f, 0.09317848f, -0.02442332f, 0.15617874f, -0.07721125f, -0.01973978f, -0.09090361f, -0.04357266f, 
    0.01368133f, 0.11252609f, -0.44038773f, -0.00590126f, 0.22044973f, 0.00831587f, 0.35300574f, 0.41340408f, 
    -0.12865493f, 0.21079105f, -0.75384063f, 0.03195949f, 0.31062451f, 0.13180076f, 0.12814158f, 0.18075807f, 
    0.11987346f, -0.23561314f, -0.13892460f, 0.15891321f, 0.01424423f, 0.23458047f, -0.60279262f, 0.14764392f, 
    0.29640687f, -0.24918583f, -0.67922390f, 0.03487328f, -0.26541057f, -0.22637500f, 0.22439258f, -0.22035283f, 
    0.14511441f, -0.32282266f, -0.61127162f, -0.03953723f, -0.19567688f, 0.46298563f, -0.52840602f, 0.18606615f, 
    0.09399547f, 0.10179067f, 0.00561914f, 0.08068644f, -0.66629916f, 0.14509900f, -0.20075125f, -0.39790234f, 
    -0.57099569f, 0.06371401f, 0.19251214f, -0.04796825f, -0.13125680f, 0.03551499f, -0.25569245f, 0.31443158f, 
    -0.01431876f, -0.32512546f, 0.18833314f, 0.15066957f, 0.39922854f, 0.29279515f, -0.43859816f, -0.60814524f, 
    0.11140244f, 0.08070964f, -0.10777232f, -0.05583063f, -0.00064230f, -0.11974747f, 0.11828998f, -0.05857101f, 
    -0.06698215f, 0.04360828f, -0.11637695f, 0.01154438f, -0.03935562f, 0.09055206f, 0.04914261f, -0.08162011f, 
    0.00449833f, -0.01626483f, 0.11372624f, -0.05700202f, 0.07596129f, 0.11943178f, -0.05255362f, -0.03530918f, 
    -0.03770314f, -0.07870969f, -0.12161979f, 0.01428674f, -0.03191793f, -0.02600798f, -0.00087093f, -0.08596140f, 
    0.06027731f, 0.02458510f, 0.10888031f, -0.09219231f, 0.01670238f, -0.06014448f, 0.02856801f, -0.08046474f, 
    0.01579414f, -0.12411836f, 0.06695986f, 0.04518515f, 0.10559230f, 0.12480801f, -0.03387120f, 0.02746801f, 
    0.10674351f, -0.10654742f, 0.00852190f, 0.10162543f, -0.05229373f, -0.07644150f, -0.07782093f, 0.12225114f, 
    -0.05244070f, -0.11709800f, 0.00004980f, 0.07573174f, 0.02064040f, -0.05752219f, 0.00685123f, -0.10790288f, 
    -0.10835050f, -0.11154512f, -0.11583679f, 0.08792887f, 0.27297801f, 0.20512711f, 0.19716604f, 0.51261282f, 
    0.06845206f, -0.07105526f, -0.16916311f, -0.09385063f, -0.23569238f, 0.09185927f, 0.22741187f, 0.08507025f, 
    0.03416385f, -0.01964237f, 0.09904086f, 0.22506662f, 0.12961878f, -0.12646581f, -0.18604988f, 0.44765285f, 
    -0.18073069f, -0.28786302f, -0.01354870f, -0.07104506f, -0.09157383f, 0.13617837f, -0.06029317f, -0.06262048f, 
    -0.07728766f, -0.01323955f, -0.02731044f, 0.09932069f, -0.05398598f, -0.05747754f, -0.18984801f, 0.17501429f, 
    0.06017263f, -0.07432192f, -0.10331836f, 0.05815482f, -0.07056712f, -0.11921659f, -0.32382581f, -0.20784648f, 
    -0.11353827f, 0.10434490f, 0.07886212f, -0.28196675f, 0.15930767f, 0.23185289f, 0.11727378f, 0.18619569f, 
    0.08943949f, -0.10023142f, 0.16652481f, 0.11603139f, -0.21479854f, 0.27715996f, -0.15494499f, -0.11760060f, 
    0.13464414f, 0.51976544f, 0.04274883f, -0.09913499f, 0.00432845f, 0.12421902f, 0.19856404f, 0.34948197f, 
    0.05794192f, -0.13373482f, -0.18322173f, 0.05620829f, 0.33622301f, 0.37170863f, 0.01617984f, 0.09635243f, 
    -0.03827302f, 0.24655102f, -0.07179177f, 0.26580063f, 0.17793889f, 0.21045156f, -0.30491197f, -0.01469139f, 
    0.06785459f, 0.32155377f, -0.17086965f, -0.08246253f, -0.18909942f, 0.17275645f, 0.10695790f, -0.06536219f, 
    -0.20809722f, -0.27486652f, -0.16188651f, 0.16990736f, 0.31505641f, -0.51743037f, -0.38323927f, 0.01691105f, 
    0.18735830f, 0.16446126f, -0.16835110f, 0.00451776f, 0.05625930f, -0.01549495f, 0.08918977f, -0.20863907f, 
    0.03861508f, -0.03002424f, 0.23349085f, 0.19362465f, 0.01393988f, -0.24413097f, 0.02396548f, 0.08966588f, 
    0.07986254f, 0.09469662f, 0.13913056f, -0.02634581f, 0.05204320f, 0.21068847f, -0.00242811f, 0.05983990f, 
    0.02564418f, -0.13370614f, -0.15199530f, -0.11079784f, 0.04439648f, -0.03995639f, 0.10464527f, -0.00999072f, 
    -0.13613960f, -0.02347980f, 0.04892667f, -0.09525737f, 0.08877391f, -0.15150325f, -0.06821010f, 0.00957390f, 
    -0.05534501f, -0.09665101f, 0.00701345f, 0.07462251f, -0.05710257f, -0.00740594f, 0.01374090f, -0.08798520f, 
    -0.04226486f, 0.05197604f, -0.12384823f, 0.06639771f, -0.01384555f, 0.07886971f, 0.07212438f, -0.13684109f, 
    -0.11763318f, -0.02507362f, 0.08328927f, 0.07417270f, -0.09992706f, -0.04461216f, 0.04732802f, 0.00976996f, 
    -0.00134661f, -0.02126156f, -0.14411937f, 0.08464849f, 0.00240120f, 0.05035007f, -0.01363790f, -0.10984301f, 
    -0.07613695f, 0.06913231f, 0.07621864f, -0.00073176f, -0.05992470f, -0.01949342f, 0.10502636f, -0.07168730f, 
    -0.11310880f, -0.10868307f, -0.06306416f, -0.07628155f, -0.06780338f, 0.01942489f, -0.12599842f, 0.00800206f, 
    -0.26400426f, -0.38185698f, 0.71949202f, 0.01828986f, 0.20134267f, -0.01608682f, 0.10712694f, 0.20460060f, 
    0.29422614f, -0.08858316f, 0.15247238f, -0.30078834f, -0.41127753f, 0.13644363f, 0.32117972f, -0.24612652f, 
    -0.05139050f, -0.13574407f, 0.30642480f, 0.19847409f, 0.41516623f, 0.31807303f, -0.29503542f, 0.15086441f, 
    -0.48593536f, -0.38027248f, 0.09102847f, -0.34263435f, 0.12058126f, 0.04927113f, -0.65530992f, 0.10183682f, 
    -0.38405389f, 0.22500382f, 0.15503666f, -0.30522627f, -0.25161412f, 0.04056096f, 0.43967897f, 0.25341892f, 
    -0.37542278f, -0.10654348f, -0.61383986f, -0.08341166f, 0.11367331f, -0.13860923f, -0.39507410f, -0.05183569f, 
    0.06447881f, 0.19276679f, -0.88063049f, 0.37341920f, 0.14366408f, 0.13904552f, 0.11866596f, 0.04340567f, 
    -0.08634388f, -0.27859715f, -0.33407372f, -0.02337155f, -0.28757560f, 0.12426891f, -0.00930818f, 0.39641950f, 
    0.19422211f, 0.10283629f, -0.03233774f, 0.01285116f, -0.13431053f, 0.15255040f, 0.29800394f, -0.32107526f, 
    -0.15474266f, -0.05117910f, 0.04639963f, -0.22173627f, 0.33436376f, 0.10898821f, -0.01627211f, 0.24043426f, 
    0.00535239f, 0.00180266f, -0.12502390f, -0.16732489f, -0.28006157f, 0.09763470f, -0.02793013f, -0.42536971f, 
    0.30776215f, -0.11228557f, 0.07315663f, 0.10181483f, -0.04697804f, -0.31012225f, 0.02045453f, 0.12258358f, 
    0.46846280f, -0.20583305f, 0.00213012f, -0.02823816f, 0.14829698f, 0.09337254f, -0.11014027f, 0.39709300f, 
    -0.16752449f, 0.10183238f, -0.06853058f, 0.05734769f, -0.09321424f, -0.05789946f, 0.07854820f, -0.12800273f, 
    -0.12139408f, -0.02568462f, -0.38609105f, 0.40683332f, 0.02788343f, -0.01019026f, 0.20133601f, 0.25348088f, 
    -0.11860389f, 0.01715043f, 0.14708979f, 0.08902143f, 0.12135656f, 0.21268998f, -0.09364714f, 0.03386158f, 
    0.46716100f, 0.55533278f, -0.32723030f, 0.10159060f, 0.07882218f, 0.23292969f, 0.17836763f, -0.10988121f, 
    0.11732349f, 0.00547974f, -0.06640722f, 0.10333492f, 0.54573309f, 0.24437949f, 0.02935684f, 0.17711881f, 
    0.07151987f, 0.17613307f, -0.12107206f, -0.10003474f, -0.03745921f, -0.17861308f, 0.10779487f, -0.20137942f, 
    0.01967920f, 0.59198815f, 0.18754362f, 0.16116682f, -0.19418725f, -0.11801929f, 0.32795858f, 0.20402585f, 
    0.80356050f, 0.02305221f, 0.10093429f, 0.06899261f, 0.26882508f, 0.05452173f, -0.20498060f, 0.13367543f, 
    -0.58336890f, 0.06256859f, -0.37801734f, -0.09858867f, -0.03123277f, 0.14689833f, 0.72882754f, -0.02831575f, 
    -0.09252942f, -0.07664864f, -0.47099400f, 0.25777939f, 0.19111161f, 0.13733707f, -0.08200438f, 0.18312787f, 
    0.37228960f, 0.07890131f, 0.41768444f, 0.11287396f, 0.05054840f, 0.02864123f, -0.04899130f, -0.02324759f, 
    -0.05123042f, -0.15082604f, -0.03985001f, 0.03975694f, -0.05365483f, -0.15332550f, -0.07973339f, 0.11695339f, 
    -0.00404797f, 0.01662515f, -0.04689686f, 0.08451311f, -0.07861622f, -0.05204469f, -0.00369934f, -0.08558490f, 
    0.00500433f, -0.01106143f, 0.05905012f, 0.07922634f, -0.06157949f, -0.04119324f, 0.10053335f, -0.09664106f, 
    -0.08589748f, -0.06892500f, 0.07186563f, 0.06302422f, 0.01745091f, -0.11461060f, -0.04308853f, -0.01320919f, 
    -0.07870876f, -0.06463224f, -0.14689396f, -0.16585648f, 0.03834628f, -0.01523247f, -0.05463293f, 0.06744960f, 
    -0.06330350f, -0.00685439f, -0.08566952f, 0.08046718f, -0.04506480f, 0.11651136f, -0.00685192f, -0.14176728f, 
    -0.07086654f, -0.00507969f, -0.08531830f, -0.05307854f, -0.11059118f, -0.07637160f, 0.02273742f, 0.00258636f, 
    -0.02650037f, 0.08190665f, 0.02860938f, 0.12308452f, -0.07236660f, -0.00086088f, -0.16118208f, -0.07281218f, 
    -0.08366670f, 0.24955451f, -0.39984730f, -0.05385381f, 0.02402350f, 0.13176116f, 0.02362602f, -0.02111738f, 
    0.12572290f, -0.14636932f, -0.00307208f, 0.36565208f, 0.12689209f, 0.03220434f, 0.19579636f, 0.29884550f, 
    0.06695953f, 0.00163793f, 0.02810732f, 0.14321446f, -0.05443575f, 0.24390021f, -0.09861025f, -0.16960359f, 
    0.31133413f, 0.05955055f, -0.08657164f, -0.10512029f, -0.23062190f, 0.01565142f, 0.17344594f, 0.05697519f, 
    0.04522413f, -0.43973079f, 0.07424543f, 0.24487078f, -0.11001688f, -0.18032619f, -0.25194296f, 0.23236308f, 
    -0.14441851f, -0.06787749f, -0.28685391f, 0.04275241f, 0.11180077f, -0.01008136f, 0.17765228f, 0.06719419f, 
    -0.23730041f, 0.01172489f, -0.05024465f, -0.18058655f, -0.13679142f, 0.12512383f, 0.04879235f, 0.31973395f, 
    0.03185960f, -0.12695536f, 0.10083361f, -0.05887615f, 0.19985121f, 0.22072695f, 0.04306876f, -0.13411093f, 
    -0.09706885f, -0.14072323f, -0.09900451f, 0.10422069f, 0.00174668f, 0.07225374f, -0.21099643f, -0.17636722f, 
    0.09351522f, 0.26646903f, 0.25810540f, -0.00982688f, -0.00411360f, 0.24078572f, 0.30571347f, 0.17587261f, 
    0.05207422f, -0.18508448f, 0.37045205f, 0.14663887f, 0.06837523f, 0.89774197f, -0.10211912f, 0.02091123f, 
    0.10796112f, -0.24099097f, -0.03460883f, 0.07067113f, 0.06545477f, 0.09399643f, -0.16697431f, 0.25600994f, 
    -0.24477114f, -0.25450048f, -0.01041508f, 0.08893132f, -0.37411189f, 0.14781015f, -0.00279285f, 0.10691796f, 
    0.22624250f, 0.18182921f, -0.29613250f, -0.07280690f, 0.08180828f, -0.08903336f, 0.15126158f, 0.23898858f, 
    -0.01034440f, 0.11838216f, 0.50740916f, 0.01297390f, -0.10330305f, 0.14799260f, 0.06884488f, -0.09245872f, 
    -0.06064405f, -0.44043618f, 0.13150975f, 0.00780731f, 0.11068933f, 0.16553482f, 0.04355223f, 0.11080009f, 
    0.20871836f, 0.21339451f, 0.38039201f, 0.09699091f, -0.12156948f, 0.00853568f, 0.21266587f, 0.31721133f, 
    -0.03098880f, -0.24449706f, -0.20592678f, -0.08373303f, 0.27463037f, 0.25302455f, -0.05913875f, 0.00687224f, 
    -0.08281104f, 0.26992622f, -0.45175046f, -0.46078393f, 0.02042868f, -0.17757818f, -0.01362525f, 0.14825909f, 
    -0.04646366f, 0.44371158f, 0.41874304f, -0.12160308f, 0.19998728f, 0.21147491f, 0.13905112f, 0.08862295f, 
    0.40053159f, 0.38770017f, 0.27977240f, -0.34883705f, 0.38831913f, -0.09426669f, 0.13064124f, -0.05856235f, 
    -0.00562136f, -0.18950820f, -0.20598724f, 0.01833326f, 0.13221881f, -0.08969178f, 0.13686384f, -0.33827764f, 
    0.37379819f, -0.01518553f, -0.06624378f, 0.38533947f, 0.25598577f, 0.07878360f, -0.27112445f, 0.10487220f, 
    0.14880484f, 0.05153893f, -0.16498832f, 0.16326860f, -0.02328847f, 0.06857737f, -0.13420074f, 0.07914344f, 
    0.30309671f, -0.08603046f, 0.03772898f, -0.04003471f, 0.02562343f, 0.10316647f, 0.12125529f, 0.19747025f, 
    0.15210748f, 0.14661571f, 0.00520031f, 0.09075703f, 0.20568021f, -0.35079947f, 0.02037490f, -0.35835752f, 
    0.07064344f, 0.26818419f, -0.17873223f, -0.19275685f, -0.26733935f, -0.67054385f, 0.15526347f, -0.20144124f, 
    -0.59481251f, -0.06945910f, 0.13993323f, 0.17185445f, 0.11155006f, -0.24833900f, 0.02652795f, -0.05306685f, 
    0.35090971f, 0.25822735f, 0.04458081f, -0.18857260f, 0.24261686f, -0.13274105f, 0.06928944f, -0.08007809f, 
    -0.78086257f, -0.23142152f, -0.14057757f, -0.12328234f, -0.06935117f, -0.03708506f, 0.04062470f, -0.13643305f, 
    -0.04302340f, -0.21495980f, -0.70455760f, -0.19340454f, 0.14279279f, 0.10036525f, -0.29860863f, 0.30204216f, 
    0.02689110f, -0.10090162f, 0.08204155f, 0.26605472f, -0.25963026f, 0.20699100f, 0.10418617f, 0.05425016f, 
    0.04496703f, 0.52666092f, 0.22847001f, 0.01460534f, -0.13238440f, -0.00991595f, -0.08617536f, -0.03266933f, 
    0.03388567f, -0.19353816f, 0.14672756f, 0.08387158f, 0.04826174f, 0.04532019f, -0.14381474f, 0.21070458f, 
    0.08621380f, -0.16332659f, -0.09742866f, 0.26962161f, -0.13402587f, -0.01554148f, 0.24050835f, -0.01773849f, 
    0.25728971f, 0.75345695f, 0.35184139f, 0.00272535f, 0.15847446f, 0.50855458f, 0.42701825f, 0.14328489f, 
    0.13367000f, 0.05704211f, 0.17275561f, 0.05568035f, -0.01844025f, 0.22235420f, 0.14131056f, -0.07739262f, 
    0.12169882f, 0.17457768f, -0.44789821f, -0.08173272f, 0.33480394f, -0.03337928f, 0.54918516f, 0.08096713f, 
    0.38197923f, 0.02738813f, 0.28435552f, 0.05595222f, 0.15732847f, -0.10734560f, 0.27651322f, -0.18328930f, 
    0.26494434f, -0.23242205f, -0.11188125f, -0.15683417f, 0.22599769f, -0.34193224f, -0.18360855f, 0.11809404f, 
    -0.01942856f, -0.13946746f, 0.09265798f, 0.04031561f, 0.00888117f, 0.02021080f, -0.03775164f, -0.03223930f, 
    -0.02147154f, -0.11114508f, -0.01256039f, -0.13542984f, -0.03196201f, 0.03296036f, -0.06494940f, 0.02119928f, 
    -0.01342578f, -0.10878382f, -0.09908522f, -0.05521844f, 0.03781774f, -0.05723613f, -0.13596517f, 0.03546351f, 
    -0.00474692f, 0.07412231f, -0.03199340f, -0.15116820f, 0.03463065f, -0.13024847f, 0.00439361f, 0.01640494f, 
    0.07762814f, -0.12496337f, -0.10707233f, 0.03553740f, -0.03532282f, 0.04628494f, 0.08399764f, -0.09027066f, 
    0.09799139f, -0.14222033f, -0.05411160f, 0.07135190f, -0.13109295f, 0.02234446f, -0.08738460f, -0.04209318f, 
    0.03779456f, 0.01742487f, -0.11020002f, -0.12239382f, 0.01014164f, -0.10263797f, 0.07377052f, -0.04371810f, 
    -0.07708707f, 0.06412492f, -0.07964735f, 0.08881874f, 0.05101674f, -0.06997028f, -0.12785973f, -0.07573963f, 
    -0.37006873f, -0.31571311f, -0.04483393f, 0.05232142f, 0.10053933f, -0.03447682f, -0.34632099f, -0.75046104f, 
    0.24954899f, 0.03571459f, -0.01807298f, -0.12377328f, 0.11536872f, -0.18822062f, -0.11174520f, -0.43736267f, 
    -0.01372348f, -0.13243783f, -0.00097264f, 0.17200355f, 0.15269251f, -0.24762566f, -0.05400494f, -0.63961470f, 
    -0.18518315f, -0.07267985f, 0.30804911f, -0.11001492f, 0.52285224f, 0.63867527f, 0.26720929f, -0.37044203f, 
    0.59886742f, -0.03166576f, 0.26809213f, -0.09544127f, 0.18059951f, 0.21122180f, 0.12803386f, 0.03303744f, 
    0.17606995f, -0.11531921f, -0.26357296f, 0.06574608f, 0.15815166f, -0.04631420f, -0.14315861f, 0.00169735f, 
    0.44857973f, 0.10247555f, 0.06697176f, -0.01759905f, 0.04989195f, -0.31845391f, 0.13839829f, -0.05345683f, 
    0.16697405f, 0.12470207f, -0.04679636f, -0.09383326f, -0.35402697f, -0.05186648f, 0.07077421f, 0.14072384f, 
    -0.13445170f, -0.11205615f, 0.02721728f, -0.05463281f, -0.11849972f, 0.06824332f, 0.00248942f, -0.00270183f, 
    -0.06656346f, 0.08843860f, 0.06253364f, 0.07326970f, 0.01897266f, -0.03287238f, -0.06871499f, -0.08967773f, 
    0.05886263f, -0.01066434f, 0.09313880f, -0.08807413f, 0.06325154f, -0.12916964f, -0.11404745f, 0.02603938f, 
    0.02617726f, -0.00837055f, -0.11690339f, -0.08258796f, -0.03791544f, 0.04463989f, 0.01372630f, -0.11999805f, 
    0.06820315f, -0.00341641f, -0.02328348f, -0.16105558f, 0.03029026f, 0.11560284f, 0.01028620f, -0.08581017f, 
    -0.05515975f, 0.04303486f, -0.03955133f, 0.11158833f, -0.17163222f, 0.04695094f, -0.05775693f, -0.12395444f, 
    0.02395611f, -0.00732803f, -0.01281190f, 0.10892645f, -0.12768295f, 0.04704089f, -0.09722205f, -0.06694072f, 
    -0.15880619f, 0.13761553f, -0.15536694f, -0.08408406f, 0.04290999f, 0.07113824f, -0.15039901f, -0.09431592f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.41788414f, 0.25381860f, 0.18720083f, 0.33942112f, 0.17789185f, -0.15000673f, 0.07011802f, 0.10556880f, 
    0.07309868f, -0.06780048f, 0.22266437f, 0.31896991f, -0.00950423f, -0.08469846f, 0.13384916f, -0.00618102f, 
    0.14907552f, 0.14964743f, 0.16051269f, -0.05038988f, -0.19358522f, 0.21847907f, 0.11966549f, 0.18656524f, 
    0.32981128f, 0.30077222f, 0.19282246f, -0.05656374f, 0.37364340f, 0.38337123f, -0.17862625f, -0.14638433f, 
    -0.02700049f, 0.17680140f, -0.05938744f, 0.11714998f, -0.10049181f, 0.21906878f, 0.34294498f, -0.01867045f, 
    0.21301423f, 0.10646185f, 0.21821679f, 0.27466935f, 0.26636738f, 0.23345213f, -0.12954788f, -0.17638151f, 
    -0.10085407f, 0.03707914f, -0.24080081f, -0.08364100f, 0.42669177f, 0.10577033f, 0.08254331f, -0.08477134f, 
    0.18468811f, 0.42249498f, 0.08430982f, 0.01736666f, 0.06731459f, 0.00608667f, 0.21503116f, -0.09550472f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.22743787f, 0.21849394f, -0.54010201f, -0.35733771f, -0.07524519f, 0.12334716f, -0.26688081f, -0.01798286f, 
    0.19755873f, 0.16542421f, -0.02729863f, -0.17575110f, -0.03010567f, -0.14261520f, -0.17524526f, 0.13223305f, 
    0.07993381f, 0.07982973f, 0.06858514f, -0.21261673f, 0.10537119f, -0.41390553f, -0.24259071f, -0.48588043f, 
    0.14878710f, 0.07687400f, -0.00784093f, -0.14904723f, -0.23042755f, -0.38747489f, -0.33030969f, 0.11551262f, 
    0.14858718f, 0.03154046f, 0.51192927f, 0.19851667f, -0.08951873f, -0.16272379f, 0.26324838f, -0.31618133f, 
    0.08184423f, 0.14678918f, -0.42546037f, -0.60860538f, -0.15201268f, -0.17487922f, -0.01695290f, 0.43127647f, 
    -0.10881402f, 0.05103930f, 0.21211407f, 0.03887159f, -0.30286601f, 0.10500039f, -0.11475779f, 0.05804217f, 
    0.22507963f, 0.18328547f, -0.56000221f, 0.05955836f, -0.31557673f, 0.00639667f, -0.10190163f, 0.05654788f, 
    0.11343038f, -0.27957109f, -0.22448613f, 0.09311558f, 0.33114481f, -0.22357714f, 0.15501460f, -1.02574480f, 
    0.03062102f, 0.40576702f, -0.06207379f, 0.03008387f, -0.02187851f, -0.09356306f, 0.12290564f, 0.20292082f, 
    0.07419110f, 0.34574813f, -0.02383622f, 0.07931974f, -0.06772636f, 0.10795145f, -0.06673611f, -0.06266469f, 
    -0.07815500f, 0.24140060f, -0.76301163f, -0.18893217f, 0.03630904f, 0.04850169f, 0.18869521f, 0.01455830f, 
    0.29228973f, 0.12025300f, -1.24576139f, 0.29289585f, 0.07774581f, -0.12320746f, -0.15155028f, -0.08967922f, 
    0.12421533f, -0.07893994f, 0.08990937f, -0.17429611f, -0.25543371f, 0.01081186f, -0.10448178f, -1.19015288f, 
    -0.11619800f, -0.03402317f, -0.08138680f, 0.02334926f, -0.44150621f, 0.10487792f, 0.07782049f, -0.02745977f, 
    0.19782607f, 0.09444816f, -0.24666132f, -0.30915779f, 0.15715852f, -0.10668752f, 0.35231411f, -0.02644000f, 
    0.11445625f, -0.02780119f, 0.10559406f, -0.09904389f, -0.03904099f, 0.03757403f, -0.02437105f, -0.19003512f, 
    -0.19356720f, -0.72398752f, 0.00900045f, 0.02244881f, 0.00057695f, 0.01364504f, 0.00721984f, -0.30591494f, 
    0.29633948f, -0.30006361f, -0.08693170f, -0.37608540f, 0.15327589f, -0.10064408f, 0.33395630f, 0.07285891f, 
    0.49317890f, -0.05538905f, 0.17751233f, -0.05271657f, -0.12386727f, 0.05962053f, -0.27791882f, 0.05171477f, 
    -0.57978916f, 0.19527347f, -0.63920730f, -0.58424878f, -0.01522116f, 0.14620495f, 0.21651779f, -0.43394053f, 
    0.65918517f, 0.01552223f, -0.06942686f, 0.17950852f, 0.27605176f, -0.35389790f, -0.01277388f, -0.46482819f, 
    -0.07363322f, 0.14002517f, -0.10563347f, 0.04237602f, 0.43766707f, -0.25411481f, -0.43189263f, -0.08143508f, 
    -0.16447456f, 0.05359685f, 0.09042706f, -0.17311309f, -0.21713805f, -0.01428228f, -0.45944011f, 0.05923627f, 
    -0.20571023f, -0.05583135f, 0.20154805f, -0.41486585f, -0.26305130f, -0.24254723f, 0.16756174f, 0.32385668f, 
    -0.05607362f, -0.05976797f, -1.24526715f, -0.01138790f, 0.04494615f, -0.06380250f, -0.09699880f, 0.09590410f, 
    0.26510796f, 0.17478965f, 0.20244300f, -0.17719239f, -0.21951853f, 0.03465748f, 0.26060456f, -0.08093254f, 
    0.11687411f, -0.00012147f, 0.32540780f, 0.25298789f, -0.16734034f, -0.12504856f, -0.46801519f, 0.02001133f, 
    0.19475251f, 0.10184142f, -0.06408782f, 0.17088516f, -0.09062146f, -0.08711922f, 0.05784928f, -0.33100340f, 
    0.33846536f, 0.17347214f, -0.41271201f, -0.05057498f, 0.17123888f, -0.33393207f, -0.06632479f, 0.11603419f, 
    -0.04258516f, 0.17446415f, -0.16456966f, -0.10800977f, 0.20089631f, 0.08774563f, -0.08209809f, 0.08423278f, 
    -0.03926579f, -0.06547029f, -0.19058293f, -0.08687084f, -0.54551494f, -0.06620602f, 0.05379674f, -0.04292709f, 
    -0.01595264f, -0.63278019f, 0.06121949f, -0.00122620f, -0.25496700f, 0.03918228f, -0.00389994f, 0.27284902f, 
    0.01938244f, 0.07652435f, -0.00707601f, -0.07047420f, -0.02216026f, 0.10000310f, 0.07334817f, 0.15747003f, 
    -0.26384851f, -0.20103250f, -0.01718574f, -0.03490751f, -0.27706107f, -0.63694483f, -0.27379358f, -0.15741651f, 
    0.07556809f, -0.02003486f, 0.22712448f, -0.01574221f, -0.58053249f, -0.19559860f, 0.28917944f, 0.03720571f, 
    -0.03096895f, 0.01564631f, -0.11681741f, 0.01064929f, 0.08391573f, 0.18456556f, -0.94464612f, 0.15315491f, 
    -0.09198886f, 0.20087178f, 0.00805338f, 0.09158368f, 0.16547348f, 0.16999434f, -0.05125387f, -0.05807867f, 
    0.06899653f, 0.06510448f, 0.11986614f, 0.03268477f, -0.02299973f, 0.21118154f, 0.15737541f, -0.05033758f, 
    0.02448687f, 0.07714154f, 0.14501128f, -0.23528506f, -0.08454814f, -0.00454923f, -0.37395063f, -0.10734344f, 
    0.16455206f, -0.16177748f, 0.22195572f, -0.04580401f, -0.25759181f, 0.30466199f, 0.03052403f, -0.27629039f, 
    0.17901447f, -0.26393127f, -0.48924366f, -0.09220593f, 0.03511603f, 0.09461671f, 0.07037371f, 0.05064815f, 
    0.08212332f, 0.05769481f, 0.04055016f, 0.14324673f, 0.02407389f, -0.02242491f, -0.04401001f, 0.12439148f, 
    0.13978012f, 0.10316121f, -0.33217117f, 0.11546291f, -0.11903031f, 0.16436280f, 0.04412922f, -0.01043856f, 
    -0.08165212f, -0.13382076f, 0.37099636f, 0.16563217f, 0.05008174f, 0.16669859f, -0.03989572f, -0.19624829f, 
    -0.09169398f, -0.04803259f, 0.16958435f, -0.06612676f, 0.04130085f, 0.18410973f, -0.04008586f, -0.07005314f, 
    0.09496917f, 0.09379271f, 0.08633567f, -0.06880937f, -0.21411791f, -0.12025193f, 0.09155652f, -0.06120108f, 
    0.19870576f, 0.12878771f, 0.00152854f, -0.12924665f, 0.09977289f, -0.03375170f, -0.46689773f, -0.10500397f, 
    -0.19668609f, 0.19747131f, -0.08604769f, 0.00300657f, -0.21087839f, 0.36260831f, -0.21918981f, -0.44355699f, 
    -0.99078739f, -0.01015609f, 0.37673289f, 0.05162171f, 0.01360368f, 0.05829495f, -0.53528649f, -1.15189970f, 
    0.10180103f, -0.99370670f, -0.69595724f, -0.61803591f, 0.06362061f, -0.12673149f, 0.30853021f, 0.14527164f, 
    0.03010300f, -0.04493805f, -0.53799123f, 0.24810036f, 0.12620509f, 0.20719215f, -0.24942139f, -0.08870707f, 
    -0.37694824f, -0.54873300f, -0.41036958f, -0.64607209f, -0.02389005f, -0.08560184f, 0.38803643f, 0.08330438f, 
    -0.64135873f, -0.50774252f, 0.26422918f, 0.30505100f, -0.97578955f, -0.62941283f, -0.01684256f, -0.19927745f, 
    0.11965978f, -0.32813099f, -0.03914575f, -0.11304057f, 0.34505442f, -0.32395002f, -0.81989729f, 0.00262459f, 
    -0.36481106f, 0.31953046f, 0.13324545f, -0.29493293f, 0.21275999f, 0.07410169f, 0.11682948f, -0.08383022f, 
    -0.02623807f, 0.16531062f, -0.16274226f, -0.15505239f, -0.04556875f, -0.07288445f, -0.16204204f, 0.63935363f, 
    -0.33040032f, -0.89653611f, -0.19798385f, 0.12416826f, 0.02024986f, -0.12515958f, 0.04609052f, -0.76559675f, 
    -0.39487225f, 0.26340485f, 0.65535468f, -0.20431858f, 0.12800181f, -0.06033922f, -0.71148366f, -0.57259399f, 
    -0.50402057f, -0.15134832f, -0.28137240f, 0.15189737f, 0.02647076f, -0.07383030f, 0.10478266f, -0.11925457f, 
    -0.05092331f, 0.17423323f, 0.29621604f, 0.00324734f, 0.06413078f, -0.69877064f, -0.37912452f, 0.16614074f, 
    -0.22714096f, 0.13438781f, -0.06536459f, -0.29233289f, -0.74719930f, -0.20763840f, 0.02042728f, -0.12748051f, 
    -0.03818731f, -0.01963401f, 0.05788475f, 0.09840125f, -0.82054871f, 0.26887503f, 0.17353642f, 0.07322676f, 
    0.16713491f, -0.09972761f, -0.11713465f, 0.57978159f, -0.25607508f, 0.05337521f, 0.10007278f, 0.03442211f, 
    -0.16648476f, -0.18497938f, 0.28937104f, 0.25392139f, -0.27891096f, -0.35678875f, 0.28909832f, -0.19219011f, 
    0.07745814f, -0.62553054f, -0.14643970f, 0.32025194f, 0.05197236f, 0.22108778f, 0.08704066f, -0.66594100f, 
    0.34532246f, 0.40703601f, -0.71548402f, 0.21926615f, -0.25278440f, 0.26308966f, 0.02192121f, 0.18122052f, 
    -0.72063303f, 0.28329229f, -0.96901089f, -0.08632737f, 0.18244626f, 0.20687252f, -0.06817620f, 0.00116834f, 
    -0.29477704f, 0.01614850f, -0.89407390f, -0.13718623f, -0.09333885f, -0.08829334f, -0.04984792f, -0.33203232f, 
    -0.58632791f, -0.28164712f, 0.02702771f, 0.15345921f, -0.38758719f, 0.36610162f, -0.20238374f, -0.13892733f, 
    0.12089905f, -0.29527187f, -0.63572705f, 0.08138935f, -0.52675790f, -0.25982490f, 0.01827266f, -0.06206086f, 
    -0.19411330f, 0.11613480f, -0.11078707f, 0.21457846f, 0.07183179f, 0.08934362f, -0.03740143f, 0.08340997f, 
    -0.59230006f, 0.31911564f, 0.18885091f, 0.17925036f, -0.36154687f, -0.17167829f, -0.68068290f, 0.06652983f, 
    -0.19879089f, -0.13620499f, 0.03386219f, 0.21672499f, -0.07290430f, -0.10614762f, -0.20046233f, 0.28727138f, 
    -0.19293796f, -0.93553072f, 0.01577810f, -0.64513129f, -0.07859096f, -0.19419503f, -0.14942659f, -0.02113178f, 
    0.23173171f, -0.07176219f, 0.15788692f, -0.05480524f, 0.13264403f, 0.14085832f, -0.41418129f, -0.02310451f, 
    -0.57093924f, -0.27535787f, -0.90393764f, -0.47214410f, -0.11940794f, 0.08480182f, 0.10546737f, 0.20652018f, 
    -0.46158639f, 0.05248759f, -0.04160090f, 0.20961097f, -0.24421628f, 0.36718649f, -0.08827066f, -0.53524667f, 
    -0.02857508f, -0.19161622f, -0.36835417f, -0.09436583f, 0.27708712f, 0.32676268f, -0.02151246f, 0.10670558f, 
    0.08595143f, 0.27463084f, -0.37481153f, -0.43839177f, -0.16926841f, -0.10014521f, -0.12749116f, 0.01120271f, 
    -0.58462995f, 0.06883117f, -0.65648437f, 0.10682184f, -0.02086155f, -0.58975905f, 0.32511532f, -0.72860068f, 
    0.08975045f, -0.06846689f, 0.17962550f, -0.57650697f, 0.09649867f, -0.19183041f, 0.28267068f, -0.09345800f, 
    0.00494573f, -0.48997980f, 0.10627396f, 0.33455813f, -0.34567472f, 0.24884208f, 0.00088687f, 0.14653985f, 
    -0.63889033f, -0.36964437f, -0.07709267f, -0.62861073f, -0.13595639f, 0.03304031f, -0.62608504f, -0.05991676f, 
    0.26108789f, 0.21876262f, -0.62662560f, 0.10271662f, 0.01759006f, -0.03755518f, 0.09070777f, -0.56670797f, 
    -0.34166923f, -0.03322586f, -0.09572737f, -0.30647150f, 0.28659654f, -0.09009269f, -0.09327288f, -0.33785155f, 
    -0.10145041f, 0.02438014f, 0.26806423f, -0.04452290f, 0.03248833f, 0.09517908f, 0.16866982f, -0.00211787f, 
    -0.10494398f, -0.60548395f, 0.32737753f, 0.29434839f, 0.01199426f, -0.15003571f, -0.29388401f, -0.10771214f, 
    0.11490981f, 0.16607261f, 0.29129624f, -0.26155561f, -0.44907457f, -0.18387121f, 0.10870100f, -0.37462550f, 
    -0.00558229f, -0.80192614f, 0.02037636f, -0.23628250f, 0.01096446f, -0.12706998f, 0.23315133f, -0.47470781f, 
    -0.57197738f, -0.35509181f, -0.50035954f, 0.02627577f, -0.38657388f, -0.00918427f, 0.09437419f, -0.03994449f, 
    -0.42128354f, -0.89928836f, 0.37468353f, -0.04424570f, 0.14314260f, 0.03237596f, 0.27763724f, -0.14535548f, 
    -0.77828270f, -0.58293366f, -0.22823788f, -1.21725452f, -0.11478665f, -0.06890194f, 0.14316277f, 0.31607381f, 
    -0.12241372f, -0.60376400f, 0.26524168f, 0.06731743f, 0.40006050f, -0.03938073f, -0.08762602f, -0.14166613f, 
    -0.00970046f, -0.62646055f, -0.20911168f, -0.02800976f, -0.30510664f, -0.00150806f, 0.05317105f, 0.00362741f, 
    -0.37598673f, -0.33187878f, 0.41389558f, -0.00555034f, 0.28723460f, 0.03021654f, 0.09849526f, -0.05916314f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.31916389f, 0.14274979f, 0.07254063f, -0.06945206f, -0.24249089f, -0.11340759f, 0.00112513f, -0.25155604f, 
    -0.08150361f, 0.40830618f, 0.04679435f, -0.05120903f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
