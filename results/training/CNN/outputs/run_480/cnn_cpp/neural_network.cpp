#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.56114477f, 0.36405417f, 0.43048465f, 0.17047668f, -0.64347827f, 0.29094437f, 0.37343997f, 0.43129414f, 
    -0.06443716f, 0.46446103f, -0.72405744f, 0.45685193f, -0.14826788f, -0.26061028f, -0.41259152f, -0.14344190f, 
    -0.15319355f, 0.45324510f, 0.20175764f, 0.27671129f, -0.59006953f, 0.34206131f, 0.58650672f, -0.53130174f, 
    0.51013952f, -0.04713271f, 0.07061177f, 0.50000411f, 0.47670278f, 0.61973035f, 0.56160903f, 0.25040177f, 
    0.14111532f, 0.26135269f, 0.44484743f, 0.06995193f, 0.10219726f, 0.30478171f, 0.25115734f, 0.06132302f, 
    -0.58170253f, 0.22296725f, 0.25975481f, -0.26618791f, 0.24974547f, 0.31852898f, 0.54072809f, 0.57310563f, 
    -0.22740254f, -0.38729644f, 0.41935971f, -0.66843969f, -0.35847017f, -0.28586233f, -0.66513616f, -0.16415535f, 
    0.14610790f, 0.03418009f, 0.76144183f, -0.61612201f, -0.03566795f, -0.03368264f, -0.53390402f, 0.00141148f, 
    -0.36171344f, -0.38864550f, -0.65527052f, -0.29122347f, 0.63431406f, -0.25301087f, 0.02336917f, 0.35833344f, 
    0.05654717f, 0.32504737f, 0.58049107f, 0.69938534f, -0.47856668f, -0.40295336f, -0.30583832f, -0.34666187f, 
    -0.34576142f, 0.62224799f, 0.52246666f, 0.04130628f, -0.05938858f, 0.39752799f, 0.05124870f, -0.09375794f, 
    0.38834676f, -0.42662415f, 0.34809452f, 0.47503248f, 0.23318183f, -0.60760790f, -0.32450697f, 0.38196626f, 
    -0.03102766f, 0.00873653f, -0.17493469f, 0.40337542f, -0.58136725f, 0.41017994f, -0.63788211f, 0.01030352f, 
    0.48578739f, 0.27254584f, -0.25321820f, -0.34492388f, -0.27733392f, -0.44185385f, -0.48730513f, 0.72810876f, 
    0.61323905f, -0.60052150f, -0.13547355f, 0.05286889f, 0.29738984f, 0.77215916f, 0.18865494f, 0.35236675f, 
    0.05410608f, 0.24667633f, 0.13133126f, -0.63179457f, 0.20822158f, 0.47126889f, -0.27596751f, 0.72239083f, 
    -0.30986333f, -0.46077955f, 0.69123131f, 0.65452397f, -0.00450291f, -0.11886209f, 0.15505978f, -0.74097425f, 
    -0.18397287f, -0.39144447f, 0.62888676f, 0.74067754f, 0.50049114f, 0.14168772f, 0.10944381f, -0.06129611f, 
    -0.54448611f, -0.58142328f, -0.83431077f, -0.27222133f, -0.30580464f, -0.00376041f, -0.13314937f, -0.04896170f, 
    -0.25288647f, -0.35313860f, 0.09245493f, 0.30334291f, -0.76946580f, -0.15622935f, -0.45484772f, -0.33800396f, 
    0.26405454f, -0.22118515f, 0.05366632f, -0.48500681f, 0.05419140f, 0.39052829f, -0.88131899f, 0.10777465f, 
    -0.26954645f, -0.63494623f, -0.08958425f, 0.03354530f, -0.35864270f, 0.64036202f, 0.15130955f, -0.00887796f, 
    0.65858328f, 0.20646712f, -0.51089078f, -0.07427983f, -0.72644353f, -0.66956955f, -0.30593324f, -0.37648991f, 
    -0.57254547f, -0.02577589f, 0.18691160f, 0.10801280f, -0.03190270f, 0.10573530f, 0.01451479f, 0.08119847f, 
    -0.43904766f, -1.00873315f, -0.55346775f, 0.36600071f, 0.02930014f, 0.40902439f, -0.83907807f, -0.19784188f, 
    -0.38473618f, 0.03369622f, -0.30247974f, 0.51486552f, -0.05111208f, 0.25141850f, 0.25459445f, -0.68352467f, 
    -0.62332857f, -0.18851440f, 0.27994311f, 0.04536650f, 0.35335997f, -0.20502076f, -0.34088731f, -0.39611921f, 
    0.72486323f, 0.35581604f, -0.48106703f, -0.23528482f, 0.46444428f, -0.32371163f, 0.17631827f, 0.11074675f, 
    0.10115580f, 0.62802827f, 0.71713364f, -0.01688929f, 0.16299444f, -0.16678195f, 0.09647180f, -0.05984950f, 
    -0.36694252f, -0.20874998f, 0.63924521f, 0.66691649f, 0.86834025f, -0.33467409f, 0.26338044f, -0.37338722f, 
    0.16842239f, -0.09661096f, -0.13936089f, 0.36069840f, 0.53869051f, -0.03200735f, -0.68143284f, -0.29934305f, 
    -0.54532766f, 0.35028994f, 0.19315323f, 0.14764358f, 0.19347019f, -0.77694273f, -0.59867609f, -0.01086038f, 
    0.51668012f, 0.57555234f, 0.26185670f, -0.13937673f, 0.41111007f, -0.71516627f, 0.16968963f, 0.34572306f, 
    0.16230945f, -0.34249157f, -0.80518758f, 0.12136019f, 0.03277043f, -0.02643658f, 0.18362941f, -0.71720785f, 
    -0.10046585f, -0.75666368f, 0.52603239f, 0.42521518f, -0.40393388f, 0.23427504f, 0.32711858f, -0.55397242f, 
    -0.73390108f, 0.19387586f, -0.16323712f, 0.04738133f, -0.58641142f, 0.48334989f, 0.38442019f, -0.28120863f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.27316272f, -0.10791427f, 0.13019590f, 0.24212421f, 0.10566131f, 0.06287335f, -0.14708143f, 0.16158745f, 
    0.19933689f, 0.02240094f, 0.06872000f, -0.09526375f, -0.08780399f, -0.15010564f, -0.37528908f, -0.13951851f, 
    0.29062018f, 0.34732494f, 0.12387642f, -0.03459576f, -0.15401730f, -0.30542886f, -0.11215310f, -0.05114381f, 
    -0.24577922f, 0.02653666f, 0.19530974f, -0.02863431f, -0.35591576f, 0.13708459f, -0.24582177f, -0.09832651f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04726642f, -0.04564839f, -0.04856472f, -0.00687942f, -0.00302277f, -0.04549475f, -0.00627142f, 0.04580173f, 
    -0.00380897f, -0.06000931f, -0.03094294f, -0.00634256f, -0.00733514f, 0.04913335f, -0.00627121f, 0.01511063f, 
    0.01883629f, -0.06371242f, -0.03986245f, 0.00755178f, -0.05118438f, 0.00010208f, 0.02958037f, -0.06012603f, 
    0.04501342f, 0.02445599f, -0.00622576f, -0.03392028f, 0.00296793f, 0.03442026f, -0.02797162f, -0.04901484f, 
    0.06134322f, 0.02716877f, -0.03255856f, -0.03441400f, -0.02805750f, -0.05503340f, -0.01425816f, -0.00076682f, 
    -0.06506641f, -0.02094528f, -0.04357050f, 0.01306034f, -0.01866240f, 0.00251008f, -0.01135781f, -0.03552625f, 
    0.01008368f, 0.04233231f, 0.03148848f, 0.01544185f, -0.02394884f, -0.05452593f, -0.02301918f, 0.05180693f, 
    -0.05566151f, -0.05262329f, 0.04533932f, -0.01198507f, -0.06212793f, 0.02667845f, 0.01122945f, 0.02979845f, 
    -0.03055152f, -0.00750308f, -0.00452309f, -0.01964082f, 0.00695142f, 0.00117597f, 0.05034003f, -0.03454969f, 
    0.00302856f, -0.02409367f, 0.03306082f, -0.01866276f, 0.02445232f, -0.01304484f, 0.03230066f, -0.02292940f, 
    -0.02447175f, 0.00114093f, -0.03548391f, -0.04376780f, -0.05007163f, 0.00859673f, 0.03252769f, -0.00574492f, 
    0.00500744f, 0.00694980f, -0.05598571f, 0.05092565f, -0.05742766f, -0.03339777f, 0.05672804f, 0.04563101f, 
    0.02921990f, -0.04728763f, 0.02763404f, -0.02567577f, -0.05571191f, -0.06048838f, -0.05417147f, 0.03143559f, 
    0.05805027f, 0.03469293f, 0.03091871f, -0.03510674f, -0.03732019f, 0.01839008f, -0.02365156f, 0.03746849f, 
    -0.04354211f, -0.00723067f, -0.02816871f, 0.04363485f, -0.00665038f, -0.00927657f, 0.04689328f, 0.03527588f, 
    0.00007998f, -0.03216237f, -0.03922334f, -0.01779460f, -0.04452669f, -0.02733712f, 0.06103391f, -0.04113494f, 
    -0.03664153f, 0.02198431f, 0.01324040f, 0.04680290f, -0.04931919f, -0.00679949f, -0.04594209f, -0.03748844f, 
    -0.05312448f, -0.01336717f, -0.03314049f, -0.00239838f, 0.00492686f, -0.02694144f, 0.02147996f, -0.00043306f, 
    -0.00586917f, 0.01159136f, 0.02139265f, 0.00868286f, -0.04027743f, -0.01518576f, -0.00104099f, 0.02887462f, 
    -0.06282359f, 0.02131239f, -0.00358766f, 0.02644840f, -0.05798060f, -0.00005978f, -0.06634657f, -0.00423817f, 
    0.02696704f, -0.02410269f, -0.01219354f, -0.00553050f, 0.02955085f, -0.00165698f, -0.00410179f, -0.05194786f, 
    -0.03467843f, -0.04172672f, 0.00890474f, -0.06074843f, -0.00705898f, 0.05853309f, -0.01715616f, -0.05322050f, 
    0.04728477f, -0.04652097f, 0.00266946f, 0.05171830f, 0.00101207f, -0.00211031f, 0.01230353f, 0.02164488f, 
    -0.02883065f, -0.03902566f, -0.02906402f, -0.03605527f, -0.00083785f, -0.05776403f, 0.02575180f, 0.00651649f, 
    -0.05482993f, -0.04555881f, -0.03148469f, -0.05994203f, 0.00189308f, 0.00438441f, -0.00016939f, -0.04485346f, 
    0.01895574f, 0.04548300f, 0.03772411f, -0.02113142f, 0.04582625f, 0.02071962f, -0.01447994f, -0.01309080f, 
    0.01129769f, -0.02871392f, -0.04780400f, -0.06212002f, 0.00312201f, -0.04993848f, 0.02309945f, -0.02072806f, 
    -0.02894969f, -0.02023072f, -0.03584252f, 0.02699239f, -0.02296280f, -0.01931829f, -0.00012918f, 0.01053395f, 
    0.00232295f, 0.01462051f, -0.06328636f, 0.01048867f, 0.01061859f, 0.00667226f, 0.01399412f, 0.04225747f, 
    -0.02608647f, -0.02433265f, -0.06551002f, -0.01361954f, -0.03299258f, 0.05459702f, -0.05184303f, -0.03584094f, 
    0.02713022f, -0.01279392f, -0.05469755f, -0.00714117f, -0.03784971f, -0.04965016f, 0.01749104f, -0.05889591f, 
    0.04925929f, -0.00105988f, 0.01693314f, -0.05808694f, -0.03454288f, -0.03058875f, -0.04724348f, 0.00943496f, 
    0.02753098f, -0.04396834f, 0.04839077f, 0.04401125f, 0.03985069f, -0.06116533f, -0.01881626f, 0.01619561f, 
    0.02538284f, -0.03225074f, 0.02799574f, 0.00631450f, 0.04436805f, 0.00867725f, -0.00405671f, 0.02717314f, 
    0.00378348f, -0.04177703f, 0.02694002f, -0.02538620f, -0.03620065f, -0.02905483f, -0.06291158f, -0.05594095f, 
    0.03644922f, 0.02578395f, -0.04013891f, 0.00637638f, -0.04805992f, -0.02409129f, 0.01130846f, 0.01499897f, 
    0.08106794f, 0.17197362f, -0.08405989f, 0.04443601f, 0.15579140f, 0.05198141f, -0.18022656f, 0.09316030f, 
    -0.18356393f, 0.02538995f, -0.13931803f, -0.16002749f, -0.13103542f, 0.01595054f, 0.01813384f, 0.06039022f, 
    -0.22410615f, 0.23834215f, 0.05530540f, 0.17267764f, 0.30849552f, 0.07512490f, 0.01016968f, -0.06749453f, 
    0.06027869f, -0.00809181f, 0.11315027f, 0.15741517f, 0.13092940f, 0.08610049f, -0.05073215f, 0.07117923f, 
    -0.05598103f, -0.06001556f, -0.00258036f, -0.01734235f, 0.03163819f, 0.01607200f, 0.03700625f, 0.20285423f, 
    0.04014878f, 0.11672790f, 0.01729424f, 0.11519694f, 0.12304701f, -0.04387864f, -0.13698328f, -0.11564182f, 
    0.10366867f, 0.05940188f, 0.00109066f, 0.06239992f, 0.04381312f, 0.21072908f, -0.60146832f, -0.31626049f, 
    -0.15317352f, 0.24418238f, 0.10558817f, -0.04702992f, 0.03417734f, -0.13243209f, -0.03956259f, -0.18467747f, 
    -0.03456168f, -0.04707304f, 0.11108994f, 0.09443402f, 0.24868628f, 0.01904003f, -0.01999797f, -0.13572697f, 
    0.13063163f, -0.18734424f, -0.05289594f, -0.01245564f, 0.12486891f, 0.12128556f, 0.04656387f, 0.08887750f, 
    -0.00777251f, 0.03119456f, 0.10697274f, 0.05836089f, -0.01214425f, 0.01507710f, 0.11838441f, -0.02824928f, 
    -0.01894073f, 0.13061509f, 0.08623874f, 0.05747401f, -0.05527079f, 0.08878451f, 0.06317641f, 0.13212477f, 
    -0.00511275f, 0.02771298f, -0.00377222f, 0.14365903f, 0.01124904f, -0.03508093f, -0.02507887f, 0.02168744f, 
    -0.08377027f, -0.02654037f, 0.06595776f, 0.11571106f, -0.33543348f, -0.16619202f, 0.10030895f, 0.16838917f, 
    0.02546550f, -0.09511016f, -0.07069967f, -0.09956759f, -0.13715512f, 0.07973438f, 0.05026000f, -0.11237586f, 
    0.02486566f, -0.07331381f, -0.00297259f, 0.06196357f, 0.01400462f, -0.13969345f, -0.12641171f, -0.29272860f, 
    -0.03437527f, -0.04343385f, -0.18597551f, 0.26758230f, 0.14262034f, 0.07271027f, -0.13090582f, -0.46875036f, 
    -0.33393741f, 0.04243146f, -0.02503325f, -0.02427248f, -0.03664086f, -0.10562112f, 0.07217327f, -0.12567250f, 
    -0.40335241f, 0.05980327f, 0.13536292f, -0.01913879f, 0.12380891f, -0.02409753f, -0.04048620f, 0.02031081f, 
    0.02314830f, -0.17519343f, 0.02050166f, 0.01662929f, -0.13456506f, 0.12177148f, -0.08947053f, -0.07559634f, 
    0.11704928f, 0.08452449f, -0.17817454f, -0.01780671f, 0.02891107f, -0.05729210f, 0.10186312f, 0.01574694f, 
    0.04555174f, 0.09308308f, 0.10715970f, 0.21136332f, -0.21200374f, -0.10844211f, 0.02576019f, 0.03453919f, 
    -0.04720193f, 0.18133321f, 0.17232873f, 0.09251858f, -0.16541141f, -0.13099578f, -0.05355615f, 0.02869336f, 
    0.09819961f, 0.01595029f, -0.02682922f, -0.09579506f, 0.02162847f, 0.04339793f, 0.10206822f, -0.24051017f, 
    -0.06551170f, -0.09755830f, -0.10984138f, 0.11528117f, -0.12025145f, 0.18691435f, -0.44870573f, -0.21467946f, 
    0.20491029f, -0.01794966f, 0.12291850f, 0.23103258f, 0.01291907f, -0.14489874f, -0.07992050f, -0.05410357f, 
    -0.03050766f, -0.03734985f, -0.13690670f, 0.01330967f, 0.05205723f, -0.08451582f, 0.04407334f, 0.09826986f, 
    0.23524728f, 0.13610207f, 0.15164785f, 0.09384224f, -0.00357031f, -0.03927749f, 0.10199023f, -0.14167657f, 
    0.04109833f, -0.00948614f, -0.04519063f, 0.11973064f, 0.00203537f, -0.04866758f, -0.02135175f, 0.02656054f, 
    -0.10760932f, -0.09691849f, -0.04545466f, 0.29315138f, 0.13009512f, 0.08547076f, 0.00510297f, -0.03758041f, 
    0.03943022f, -0.00378264f, 0.00828561f, 0.03413263f, 0.19855925f, -0.10074018f, 0.07114054f, -0.13819245f, 
    0.02958733f, -0.00837627f, -0.12421355f, -0.04596144f, -0.20209582f, -0.34713492f, 0.01398265f, 0.07484652f, 
    -0.02153014f, -0.01158959f, 0.02841092f, 0.02763372f, -0.10514574f, 0.13389063f, -0.07071544f, -0.04123055f, 
    0.02465673f, 0.04716438f, 0.06264600f, 0.10893340f, 0.00850348f, 0.11914498f, 0.00679305f, -0.09877101f, 
    -0.16383649f, -0.14205927f, -0.10244015f, -0.21849597f, 0.00565000f, -0.02137691f, 0.02349606f, 0.11450243f, 
    -0.20147605f, -0.20480931f, -0.00997342f, 0.23638332f, -0.13776888f, -0.01502647f, -0.04844744f, -0.07473100f, 
    0.14852376f, -0.00536919f, 0.14111654f, -0.14244136f, -0.07571536f, 0.05650915f, 0.11907905f, 0.00137939f, 
    0.06396099f, 0.19487701f, -0.08802809f, -0.07576394f, 0.04576792f, -0.00658742f, 0.03439429f, -0.19563080f, 
    0.03706283f, -0.03111930f, -0.06733063f, -0.22357373f, -0.02344078f, 0.05273058f, 0.06981257f, -0.08816797f, 
    -0.06170850f, 0.00896669f, 0.09090753f, 0.24612637f, -0.16041520f, 0.05646284f, -0.08353976f, -0.15029205f, 
    -0.04536213f, 0.02473416f, 0.05802446f, -0.02558109f, 0.12904784f, 0.09223429f, 0.01219513f, -0.17069690f, 
    -0.03478794f, -0.05936846f, 0.20355512f, 0.07281575f, 0.06990165f, 0.06079782f, 0.13565265f, 0.16986518f, 
    -0.05794894f, -0.16241960f, -0.08052056f, -0.02539703f, -0.11027432f, 0.11054701f, -0.02585365f, -0.21327429f, 
    -0.22810340f, 0.07346714f, 0.17287834f, 0.16581288f, -0.19593719f, 0.16669782f, -0.00081880f, 0.07099614f, 
    0.03877360f, -0.13546494f, 0.00853623f, -0.11173978f, 0.05994359f, -0.07348906f, 0.06509899f, 0.08039385f, 
    -0.22836588f, 0.08113334f, 0.01204760f, -0.01239385f, 0.08564738f, 0.03198415f, 0.01940392f, -0.19964746f, 
    -0.00518085f, 0.17789961f, -0.07603283f, 0.05166355f, -0.27992415f, -0.13048401f, -0.15505315f, 0.10030480f, 
    0.04909144f, -0.05228779f, 0.14702378f, 0.20103452f, 0.14449996f, 0.00056754f, -0.21064353f, -0.07032282f, 
    0.12442005f, -0.04822497f, 0.03137801f, 0.03806809f, -0.17718327f, -0.03785499f, 0.01431096f, -0.15365413f, 
    -0.08886176f, 0.01272095f, 0.12211363f, -0.08233990f, 0.00364811f, -0.01447300f, -0.19931479f, 0.15495270f, 
    0.09249732f, -0.08611899f, -0.06837516f, -0.16026048f, 0.13754943f, 0.14965945f, -0.01597269f, 0.01107743f, 
    -0.13675237f, -0.15568991f, 0.01904006f, -0.00677685f, 0.13820533f, -0.08052784f, -0.10079490f, 0.04019983f, 
    -0.07678337f, 0.04865226f, -0.11140309f, -0.14643769f, -0.14792079f, -0.01862446f, 0.04577477f, -0.09930561f, 
    -0.05895579f, 0.13473900f, 0.13173789f, 0.03601936f, -0.04417709f, 0.08697111f, -0.08823460f, -0.02631697f, 
    0.24754244f, 0.27500474f, -0.04811453f, 0.03500378f, -0.05361281f, 0.11594243f, 0.03606670f, -0.01554881f, 
    -0.10652678f, -0.05550691f, -0.16148309f, -0.09593203f, 0.11772081f, -0.00717689f, 0.03652602f, 0.09342930f, 
    0.08399626f, -0.02714204f, -0.25527778f, 0.11611836f, 0.11593203f, 0.09786385f, 0.01300073f, 0.11220541f, 
    -0.01676681f, -0.02949378f, 0.07310529f, 0.11501570f, -0.03301029f, 0.08231377f, 0.01689472f, 0.10201133f, 
    -0.25749883f, -0.00771956f, 0.11281168f, 0.03203391f, 0.06200039f, 0.16122924f, -0.00853211f, 0.09736168f, 
    0.01277170f, 0.00957138f, -0.13222264f, 0.03504023f, -0.01234914f, 0.09330940f, 0.01978206f, -0.11999021f, 
    0.16627826f, 0.15204938f, 0.08471143f, 0.15098609f, 0.03666395f, -0.16625702f, -0.02844933f, 0.12563777f, 
    0.16327450f, 0.05363353f, -0.06234645f, 0.01101426f, -0.01850625f, -0.07942113f, -0.06544455f, 0.12621199f, 
    0.11957600f, 0.04311476f, 0.26050159f, -0.04656064f, 0.08617671f, -0.03182743f, -0.05155206f, -0.06306375f, 
    0.23722090f, -0.15448821f, -0.01686099f, 0.02584968f, -0.01038147f, -0.06499290f, -0.15237300f, -0.00616141f, 
    0.00633302f, 0.02313020f, -0.02299398f, 0.11961412f, -0.05979382f, -0.05780199f, -0.09405805f, -0.06407496f, 
    -0.00722656f, 0.05199879f, 0.12115194f, -0.07757159f, 0.03083238f, -0.00627189f, -0.19246517f, 0.07034632f, 
    0.06661917f, -0.02372895f, -0.06876258f, 0.24261451f, -0.05335566f, -0.08333335f, 0.08462925f, -0.04182303f, 
    0.15476410f, 0.04830349f, -0.11775962f, -0.06889818f, 0.15527344f, -0.12860517f, 0.25362924f, 0.01166797f, 
    -0.01265868f, -0.04320775f, 0.07141265f, -0.15044622f, -0.16406289f, -0.20019789f, -0.07451048f, -0.11541475f, 
    0.12824012f, -0.04918545f, -0.04796430f, -0.14290357f, -0.10403252f, 0.08312324f, 0.17064027f, -0.01244848f, 
    0.16301225f, 0.11543459f, -0.17819272f, -0.12512529f, 0.06663059f, -0.09441429f, 0.06106121f, 0.06810265f, 
    0.00948443f, 0.05187372f, -0.03071478f, 0.17571370f, 0.08029962f, -0.19227391f, -0.04796046f, -0.14396873f, 
    0.03061613f, 0.01507130f, -0.03679353f, -0.03670451f, -0.05654136f, 0.00629983f, 0.00167965f, 0.02720647f, 
    -0.02290699f, -0.06096570f, -0.03730955f, -0.03473153f, -0.04243740f, -0.04249265f, 0.00527579f, -0.00349399f, 
    -0.02039751f, -0.01706282f, -0.04354297f, -0.02459995f, -0.05020051f, -0.02783426f, -0.00359757f, 0.01280798f, 
    -0.06407053f, -0.05325564f, -0.06104404f, 0.00076840f, -0.05557600f, -0.06368303f, -0.05586733f, -0.02876166f, 
    -0.04059726f, 0.01401802f, -0.04294081f, 0.04125789f, -0.04979591f, 0.01160986f, -0.06144357f, -0.05197336f, 
    -0.00314472f, 0.00529414f, -0.00908062f, 0.03623082f, -0.00971520f, -0.01030910f, 0.04515464f, 0.00258335f, 
    0.02136509f, 0.04274417f, -0.04043411f, -0.00128273f, 0.03903352f, -0.01229588f, 0.00895766f, 0.04656020f, 
    0.01298878f, -0.01695694f, 0.02471563f, -0.04307350f, 0.03945420f, -0.00557681f, -0.04233444f, -0.04229249f, 
    -0.04791385f, 0.04090694f, -0.03001337f, -0.02014872f, 0.04301814f, -0.00563732f, 0.00985408f, 0.01292768f, 
    0.03874422f, -0.06093077f, 0.02965333f, 0.04103142f, 0.03119948f, 0.00919355f, 0.01914193f, 0.02711052f, 
    0.00409194f, -0.00303818f, 0.03979917f, -0.05902891f, -0.01013444f, -0.00233091f, -0.00501724f, -0.01697334f, 
    -0.04521658f, -0.01286447f, 0.00772538f, -0.00434727f, 0.00379001f, 0.00500789f, 0.04993745f, -0.01932465f, 
    -0.02163826f, 0.00282031f, -0.05915722f, -0.06039411f, 0.00229602f, -0.01090249f, -0.01487770f, -0.04078312f, 
    -0.00290230f, 0.03900433f, 0.01050907f, 0.01577559f, 0.03941328f, -0.01282019f, -0.05013286f, -0.02725969f, 
    0.00220466f, -0.00147332f, -0.06263866f, -0.05049907f, -0.00084154f, 0.04880917f, 0.02936223f, 0.03071977f, 
    0.02541572f, 0.03946627f, -0.00763088f, 0.02550408f, 0.01013871f, -0.02388875f, 0.04724743f, -0.06308290f, 
    -0.00068751f, 0.02427187f, -0.05266302f, 0.03176971f, -0.06085163f, 0.02293866f, 0.02461914f, 0.00797521f, 
    -0.00686652f, 0.05389853f, 0.01937987f, -0.02028092f, -0.04460377f, -0.04807567f, 0.00945666f, -0.00277245f, 
    -0.04464711f, -0.01503959f, -0.04576669f, -0.00434498f, -0.01203532f, -0.02847490f, -0.02304837f, -0.05291924f, 
    0.03145083f, -0.05243845f, 0.04322569f, 0.00674421f, 0.01732049f, 0.03787961f, -0.05234419f, -0.01857870f, 
    -0.05002607f, -0.02677059f, 0.00963636f, -0.02827709f, 0.00952628f, -0.01836145f, -0.01693408f, 0.01180058f, 
    0.04295494f, -0.01116667f, 0.02186616f, 0.04496446f, -0.06505410f, 0.03154784f, -0.02240796f, -0.01368534f, 
    -0.00150331f, 0.00295387f, 0.01213998f, 0.03627846f, 0.00732332f, -0.00001125f, -0.05902844f, -0.05725436f, 
    -0.03224535f, 0.03455573f, -0.04341265f, -0.04033921f, 0.02810070f, 0.01975915f, -0.06145034f, -0.02113707f, 
    0.04869227f, 0.02312595f, -0.01720422f, -0.02450696f, -0.02168808f, 0.02508359f, 0.01204395f, -0.04878870f, 
    0.04384851f, 0.03380783f, 0.03575553f, -0.01408605f, 0.03524370f, -0.02834648f, 0.03315461f, -0.04952490f, 
    -0.01484570f, 0.00372079f, 0.00579278f, -0.01644285f, -0.05546650f, -0.06422084f, -0.00858470f, -0.05863499f, 
    0.02732805f, 0.01555396f, -0.04570300f, -0.00479941f, -0.00080939f, 0.05043627f, -0.02490933f, 0.02923389f, 
    0.01027917f, 0.02318342f, -0.02642194f, -0.06597234f, -0.00957267f, -0.04816872f, -0.01525019f, -0.06399964f, 
    -0.02425198f, -0.00462638f, -0.05102057f, -0.01471304f, 0.03202244f, -0.01506645f, -0.04873483f, 0.02264655f, 
    0.01756583f, 0.02676609f, -0.00389467f, 0.04028472f, -0.04542312f, -0.01212194f, -0.04497067f, -0.01348399f, 
    -0.02666255f, -0.05763005f, -0.04271956f, -0.02721774f, -0.02132352f, 0.03612894f, 0.00919106f, 0.01008018f, 
    0.03690768f, -0.05823856f, 0.00687160f, 0.04441355f, 0.03097016f, 0.00746517f, -0.02728216f, -0.06527043f, 
    -0.05813219f, -0.01239773f, 0.01307223f, 0.01789339f, -0.05522373f, -0.01855569f, -0.01867869f, -0.05603749f, 
    0.04444008f, 0.02003139f, 0.00544221f, -0.02069759f, 0.04300847f, 0.00642228f, 0.00594526f, 0.03379723f, 
    -0.04833855f, 0.00956120f, -0.03606777f, 0.03819863f, -0.04147290f, 0.01200790f, -0.01619640f, -0.01670391f, 
    0.11023013f, -0.27058724f, 0.15727127f, -0.01153566f, 0.00200343f, -0.06211910f, 0.03077201f, -0.01216868f, 
    0.16011906f, -0.06602278f, -0.16989459f, 0.06686833f, 0.14635454f, 0.00272242f, -0.01455075f, 0.02285176f, 
    0.02326192f, 0.00541885f, -0.02037824f, -0.30487210f, -0.13651484f, 0.02810340f, 0.02301065f, 0.05074391f, 
    0.06491523f, 0.09169451f, -0.01899308f, 0.03299990f, -0.17441304f, 0.07477304f, -0.04342676f, 0.04466001f, 
    -0.03522472f, 0.08316194f, 0.00616400f, 0.08783434f, 0.30562365f, -0.01375387f, 0.13353533f, 0.05863522f, 
    -0.04131427f, 0.14215176f, 0.12206206f, -0.05938359f, 0.03514637f, -0.03432768f, 0.14944467f, -0.05886831f, 
    0.10776082f, -0.02226674f, 0.01553086f, -0.10941748f, -0.02490923f, 0.09170412f, -0.16325818f, 0.01764235f, 
    -0.23126327f, 0.01924218f, 0.15739320f, -0.03192344f, 0.05800169f, -0.07783675f, 0.05355897f, 0.00648326f, 
    0.21633886f, -0.14040722f, 0.07602928f, -0.16214487f, -0.00940889f, 0.04646771f, -0.03649374f, 0.10165139f, 
    -0.15643746f, -0.10434950f, -0.01890518f, 0.04451428f, 0.07676896f, 0.13644381f, -0.21422373f, -0.07350657f, 
    0.06434823f, -0.13728692f, 0.01406170f, -0.08644177f, -0.02891751f, -0.08494653f, 0.03019085f, 0.03258971f, 
    -0.12996681f, -0.02820150f, -0.06283110f, 0.24457645f, -0.15385754f, 0.14024629f, -0.10109872f, -0.01679599f, 
    0.05021136f, 0.05568373f, 0.01649434f, -0.35536671f, -0.07737999f, -0.15295532f, -0.04837922f, -0.01353046f, 
    -0.02609239f, -0.01223577f, -0.01863966f, -0.05100521f, 0.12001644f, 0.12251719f, -0.19241801f, -0.14959258f, 
    0.02821820f, 0.11668969f, 0.03487035f, -0.01236745f, 0.03041973f, -0.22229199f, 0.18505552f, -0.00378401f, 
    0.10648192f, -0.06985334f, 0.06918757f, 0.08228852f, 0.02360438f, 0.17319292f, -0.01863711f, -0.00019153f, 
    0.00581779f, 0.09183993f, -0.11348341f, -0.15890035f, -0.05003783f, 0.09349265f, 0.09162911f, -0.01353382f, 
    0.16420449f, 0.18778259f, -0.04133196f, -0.00044635f, -0.13773344f, -0.01872916f, 0.07210667f, -0.03515531f, 
    0.32820231f, 0.34596649f, -0.10060759f, 0.06775532f, -0.04869171f, 0.07182680f, 0.10955075f, 0.07430507f, 
    -0.05207875f, -0.24977504f, -0.14383811f, -0.27418867f, -0.03062536f, -0.03460167f, -0.16496041f, -0.10517746f, 
    0.01905881f, -0.05865685f, -0.09202775f, -0.10697103f, 0.00660874f, 0.00764222f, -0.09135801f, 0.16994822f, 
    -0.07424225f, 0.09070881f, 0.01617125f, -0.14550094f, 0.16644438f, -0.06298353f, 0.21673784f, 0.12945913f, 
    -0.05579957f, -0.00447148f, -0.02472954f, -0.03899436f, -0.07120531f, 0.31209120f, -0.04275938f, 0.11859640f, 
    -0.14823097f, 0.05677550f, -0.01081236f, 0.00065962f, 0.02538500f, 0.06247558f, -0.44292501f, -0.01400455f, 
    0.01986540f, 0.06269545f, -0.06261982f, 0.02422252f, -0.04242475f, 0.11664254f, -0.24832931f, 0.19862616f, 
    0.07292107f, 0.12927753f, -0.05163377f, 0.06610686f, -0.01839497f, 0.13256676f, -0.07595869f, 0.16354692f, 
    0.36477044f, -0.04292113f, 0.02218007f, 0.02352108f, -0.11150435f, 0.06171686f, 0.09662952f, -0.11066765f, 
    0.07325835f, -0.49774376f, -0.12214252f, 0.06876694f, -0.14075457f, 0.11709826f, -0.04916101f, -0.13399155f, 
    0.09985521f, 0.22317007f, -0.00565970f, 0.13080952f, 0.09750620f, -0.11037713f, 0.01907404f, -0.09116212f, 
    0.01574242f, 0.00949890f, 0.08484305f, -0.13906895f, 0.01078641f, 0.04856212f, 0.11140485f, -0.00566226f, 
    -0.03283273f, 0.04890607f, 0.03121598f, 0.26437321f, -0.17624794f, -0.00009022f, -0.17832330f, -0.01309476f, 
    0.19587712f, 0.01437724f, -0.08001620f, -0.03244622f, -0.01820126f, 0.15848252f, 0.15875864f, 0.00722385f, 
    -0.08149368f, -0.23928902f, 0.01292311f, 0.06652928f, -0.11548617f, -0.54655576f, -0.15165941f, -0.24935053f, 
    0.04433684f, -0.08231917f, 0.00036931f, -0.09804741f, 0.07641189f, 0.00436382f, -0.09674536f, 0.07704372f, 
    -0.20875157f, 0.11882872f, 0.00752229f, 0.03986895f, 0.03641601f, -0.00413457f, -0.08786586f, -0.05545895f, 
    0.07089128f, -0.22454445f, 0.07362048f, -0.14226632f, 0.02139999f, 0.12667616f, 0.02305453f, 0.05181150f, 
    0.01514821f, -0.04297576f, 0.03817874f, -0.01073696f, -0.02563099f, -0.00242540f, -0.00509647f, 0.02604531f, 
    -0.02835641f, 0.03039588f, 0.00265880f, 0.00497122f, 0.01858777f, -0.02994135f, -0.03049125f, -0.05326371f, 
    0.01261696f, -0.02412367f, -0.01393579f, 0.02216589f, 0.02074241f, 0.03796069f, 0.03835478f, -0.01631487f, 
    -0.01925416f, -0.05441060f, -0.00852664f, -0.04302789f, 0.00776039f, -0.03669560f, 0.04020851f, -0.02547749f, 
    -0.02874672f, -0.05324829f, 0.03343545f, 0.03138952f, 0.03637492f, 0.04044103f, -0.04438522f, -0.05423803f, 
    -0.00211545f, -0.06002040f, 0.00536043f, 0.04448669f, -0.00695267f, 0.02435936f, 0.00198498f, 0.02146998f, 
    0.01672009f, -0.00551317f, 0.01036033f, 0.03274681f, -0.02551784f, 0.03895929f, -0.04416517f, 0.00114475f, 
    -0.05474574f, 0.01732648f, -0.05937282f, -0.03183569f, 0.03532780f, -0.02750179f, -0.03903224f, 0.02337545f, 
    0.00887908f, -0.02135875f, -0.03153392f, 0.04527796f, 0.01010422f, 0.02299496f, -0.00252275f, 0.03816187f, 
    0.03561531f, -0.02096828f, 0.02999788f, 0.00178229f, -0.02562531f, -0.03061576f, -0.00111528f, 0.01356483f, 
    -0.02323671f, -0.00318420f, 0.02271965f, -0.04399694f, 0.03853480f, -0.04630062f, 0.02622401f, 0.02057545f, 
    -0.03114846f, -0.04126465f, -0.02954432f, -0.00824140f, -0.05624748f, -0.06260472f, -0.05633934f, -0.01891681f, 
    0.04598727f, -0.02969408f, 0.04276728f, 0.02243445f, 0.02151720f, -0.06342122f, -0.00653826f, 0.02601853f, 
    -0.05296369f, -0.05966988f, -0.04469033f, 0.01357893f, -0.05840646f, 0.02657687f, -0.00357920f, 0.04464682f, 
    0.00453097f, -0.01225708f, -0.05827126f, -0.04528283f, 0.05112253f, -0.01929467f, -0.00131177f, 0.03347738f, 
    -0.01889530f, 0.00601255f, -0.05481976f, 0.01541752f, 0.04830379f, -0.01544171f, 0.02031802f, -0.02958594f, 
    -0.01157447f, -0.00643070f, -0.02546414f, 0.00330344f, -0.04390533f, 0.01754926f, 0.03082807f, 0.04202896f, 
    0.05203332f, 0.02967052f, -0.02128285f, 0.01219679f, 0.02782120f, 0.02206100f, 0.01268053f, 0.04112142f, 
    -0.05012207f, 0.05559189f, -0.01743364f, -0.03460367f, -0.03973918f, 0.05063698f, 0.01520703f, 0.04255109f, 
    -0.04028445f, 0.03274664f, 0.04128404f, -0.01227899f, -0.06607166f, -0.05461859f, -0.00709930f, -0.03084587f, 
    -0.03696625f, 0.04180840f, -0.01239071f, 0.00542066f, 0.03042880f, 0.00070810f, 0.00516982f, -0.01894771f, 
    -0.01592246f, -0.02413680f, 0.01802078f, 0.02205534f, -0.04567182f, 0.01646722f, -0.01356387f, 0.04985803f, 
    0.04658065f, 0.02762065f, -0.05165952f, 0.04818717f, 0.01825368f, -0.00536481f, -0.04858730f, 0.00157469f, 
    0.04216657f, 0.01460258f, -0.01097002f, 0.00061614f, 0.04157627f, 0.04292212f, -0.03499671f, -0.05407983f, 
    0.00686582f, -0.00652933f, 0.02067920f, -0.02013169f, -0.02786808f, -0.03484866f, -0.05864663f, 0.01231609f, 
    -0.05217274f, 0.01254390f, 0.00833413f, -0.00977227f, -0.01027635f, 0.04513871f, 0.03324557f, -0.04398768f, 
    -0.00890157f, 0.02618982f, -0.00027923f, -0.04296578f, -0.02090115f, -0.02357940f, 0.04071797f, 0.03234833f, 
    -0.03023605f, 0.02470159f, -0.03661577f, 0.00410145f, -0.06069532f, -0.00036694f, 0.02613011f, -0.01809795f, 
    -0.02593967f, 0.01625977f, 0.03068592f, -0.01340331f, -0.05279306f, -0.00582561f, -0.02725054f, -0.01365296f, 
    -0.02266726f, 0.03735726f, -0.06072214f, 0.04571050f, -0.01157487f, 0.02191701f, 0.02527903f, 0.01275232f, 
    0.04486421f, 0.00035594f, -0.04814051f, 0.00179536f, -0.04111971f, -0.03717123f, -0.00078628f, -0.06266384f, 
    0.00861544f, -0.01923166f, -0.06311962f, -0.02912328f, 0.04896288f, 0.04722618f, -0.06491571f, 0.01969273f, 
    0.03721405f, -0.04584844f, -0.01836120f, -0.01924467f, -0.06634793f, 0.01620855f, 0.04275042f, 0.05358357f, 
    0.00445350f, -0.06122218f, -0.04187034f, 0.01572680f, 0.02134301f, -0.04019025f, -0.02467936f, -0.01863858f, 
    0.02722634f, 0.00921165f, -0.02666082f, -0.03349871f, -0.01688449f, -0.02894469f, -0.05736538f, -0.05824290f, 
    0.01884035f, 0.03719958f, 0.01690240f, -0.02410758f, -0.05663178f, -0.06949325f, -0.04632377f, -0.03362329f, 
    0.07314900f, -0.17267893f, -0.14180750f, -0.05062147f, 0.23816359f, -0.06792340f, 0.04536685f, 0.09005067f, 
    -0.11568794f, 0.19777507f, 0.07453611f, 0.13595203f, -0.28386617f, 0.09181584f, 0.03984306f, 0.12943512f, 
    0.11060264f, 0.04218537f, 0.06126334f, 0.18622567f, 0.08494330f, -0.03278886f, 0.07253376f, -0.05634465f, 
    -0.07080489f, 0.15659727f, 0.10267236f, 0.16180097f, -0.03796756f, -0.12208632f, 0.08998770f, 0.02697014f, 
    0.11859673f, -0.03296464f, 0.04833332f, -0.08702195f, -0.00098165f, -0.12762937f, -0.07048848f, 0.07988630f, 
    0.04520612f, -0.05891064f, 0.00198730f, 0.07097999f, -0.09678577f, 0.01042729f, -0.16773149f, -0.26762426f, 
    -0.04080135f, 0.08368800f, 0.09497977f, 0.25014657f, -0.06429705f, 0.05634929f, -0.14302889f, 0.28684539f, 
    0.05380938f, -0.10405007f, -0.23592946f, 0.07850726f, -0.16088590f, 0.13975468f, -0.11928595f, 0.12587321f, 
    0.02730754f, -0.03268589f, -0.02782345f, -0.07083621f, 0.24727271f, -0.03456433f, 0.04878227f, -0.07584615f, 
    -0.02358508f, -0.14024128f, -0.07541072f, 0.00201190f, 0.11306471f, 0.16334361f, 0.04342992f, 0.10006294f, 
    -0.09465337f, -0.07044242f, 0.08793551f, -0.23707578f, 0.09659638f, 0.12265860f, 0.06998444f, 0.08168741f, 
    -0.06152257f, -0.15959303f, -0.02466769f, -0.26306808f, -0.38024497f, -0.10399699f, 0.08346598f, 0.12324566f, 
    0.22454953f, -0.05354708f, -0.01318673f, -0.09045660f, -0.02586174f, -0.31802180f, 0.02581342f, 0.07540105f, 
    0.22308195f, 0.04605930f, -0.06667064f, -0.01611452f, -0.21791680f, 0.11311036f, 0.04378132f, -0.00529577f, 
    0.10789757f, -0.03739206f, 0.07421550f, 0.10401410f, -0.00155924f, 0.07846696f, -0.08816650f, -0.10286780f, 
    0.12857075f, 0.24786346f, -0.12185274f, -0.07651617f, 0.05847257f, -0.06852863f, -0.11215003f, -0.00530067f, 
    0.00680946f, -0.03981843f, 0.05065694f, 0.08415446f, 0.13972251f, -0.13771945f, -0.21465352f, 0.04140004f, 
    0.13575715f, 0.03634970f, 0.10615744f, 0.09795847f, 0.17085485f, -0.02141974f, -0.10946895f, 0.07340640f, 
    0.04889739f, -0.08040719f, 0.13552630f, 0.01414238f, 0.04028902f, -0.03484756f, -0.10903502f, 0.00859597f, 
    0.18660030f, 0.01289934f, 0.21071754f, 0.09422116f, -0.03908681f, -0.04197420f, -0.05932846f, -0.02400672f, 
    -0.00502705f, 0.14083481f, -0.07749743f, 0.21908048f, 0.06192570f, 0.06120837f, 0.05679233f, 0.11754587f, 
    0.25798830f, 0.12941696f, -0.18992835f, -0.10051564f, -0.12719712f, -0.39998120f, 0.15445471f, -0.05321089f, 
    0.25572127f, 0.00765144f, -0.19615868f, -0.27207431f, -0.22222121f, -0.12273896f, 0.05099079f, 0.08467057f, 
    -0.01569147f, -0.18641636f, 0.01471804f, 0.02445344f, 0.08943329f, -0.10623778f, 0.14347279f, 0.11592017f, 
    -0.01334067f, -0.06349631f, -0.31728086f, 0.05345680f, 0.18007797f, -0.08620750f, 0.01829691f, 0.02520866f, 
    -0.06693379f, 0.08502017f, 0.02567029f, 0.09113146f, -0.00906402f, -0.07215516f, 0.07649028f, -0.08291923f, 
    0.10118124f, 0.15831943f, 0.01287358f, -0.13003780f, 0.04233680f, -0.06561230f, -0.06638367f, 0.03385350f, 
    -0.19879653f, 0.29646331f, 0.06300350f, -0.04154020f, 0.03891695f, -0.00168603f, 0.08921490f, 0.01155310f, 
    0.20190234f, -0.05503828f, -0.04372030f, -0.24445575f, -0.01600032f, 0.16200967f, 0.05493060f, 0.09822077f, 
    0.12649225f, -0.09433788f, -0.01328641f, 0.22092424f, -0.27232757f, 0.23427193f, -0.03623663f, 0.04801920f, 
    0.02442446f, 0.06254559f, 0.03141731f, -0.20955136f, 0.24543057f, 0.10370716f, 0.04799404f, 0.00594174f, 
    -0.09544961f, -0.00654053f, 0.13766254f, 0.09253140f, 0.12320194f, -0.04595618f, -0.05248339f, 0.10069424f, 
    0.16528599f, -0.03688664f, 0.06087044f, -0.14532743f, -0.16554219f, 0.06793430f, 0.12177627f, 0.09088295f, 
    -0.00412136f, -0.12619293f, -0.05171173f, 0.00723168f, 0.09286650f, 0.09865330f, -0.16558966f, -0.02264137f, 
    0.18923822f, -0.09253772f, -0.03269441f, 0.08234698f, -0.02609095f, 0.00758754f, -0.18208773f, -0.17552115f, 
    -0.09672446f, 0.00603889f, -0.02431120f, -0.14434089f, 0.05395960f, -0.04448862f, 0.10077160f, 0.14449850f, 
    -0.20255652f, 0.02142400f, -0.08382801f, -0.00245265f, -0.02913289f, -0.14996998f, -0.01274579f, -0.11323129f, 
    -0.14028563f, 0.37686446f, 0.07743863f, 0.03028083f, -0.23119146f, -0.14868882f, -0.05567427f, 0.10400096f, 
    0.06374474f, 0.03906348f, -0.43416166f, 0.05306634f, -0.14028035f, 0.02517969f, 0.04459227f, -0.04242255f, 
    0.02252706f, -0.06647123f, 0.02063224f, -0.09069702f, 0.06444109f, 0.08036055f, 0.02432124f, 0.04186933f, 
    0.00429235f, 0.04618702f, -0.10072707f, -0.17313254f, -0.27208108f, -0.13754907f, -0.00719080f, -0.02812653f, 
    -0.17382888f, 0.02340745f, -0.09731075f, -0.25307301f, -0.03884147f, 0.25304320f, 0.16674133f, -0.06046914f, 
    -0.08877705f, 0.04638535f, -0.20506443f, -0.10748322f, 0.06751861f, -0.08647019f, -0.23123518f, 0.13212800f, 
    0.08505487f, 0.18372793f, -0.03843013f, -0.01675571f, -0.06407614f, 0.10174946f, 0.10578293f, 0.50937778f, 
    0.09131411f, -0.04442615f, 0.01520640f, 0.01313864f, 0.08858541f, -0.08574211f, -0.05916130f, 0.01441097f, 
    0.10513474f, 0.13732536f, -0.05304352f, -0.29378924f, -0.00517652f, 0.00011140f, 0.02756080f, -0.15298058f, 
    -0.08700733f, -0.14857566f, 0.13428393f, -0.00206888f, 0.19994940f, 0.11369579f, 0.02315959f, 0.04842284f, 
    0.18499997f, -0.22299318f, 0.07598921f, -0.08957411f, -0.04972439f, -0.15488808f, 0.10444266f, -0.00565998f, 
    -0.07078958f, -0.00953515f, -0.03025441f, 0.14313354f, -0.18406247f, 0.07563404f, -0.29666179f, -0.16120809f, 
    0.06085981f, 0.10588765f, 0.16192882f, 0.03391611f, -0.24699773f, -0.03043467f, 0.07695980f, 0.34162706f, 
    0.08865956f, 0.07235682f, 0.10476934f, -0.16714126f, 0.09929926f, -0.20255776f, 0.20785192f, -0.05016743f, 
    0.12614267f, 0.04155854f, -0.29134667f, -0.06931082f, -0.05945744f, -0.14672828f, 0.20264217f, -0.29810938f, 
    0.11164907f, -0.04696748f, -0.10396644f, 0.13806576f, 0.02730464f, -0.04002616f, -0.01500801f, 0.02656138f, 
    -0.01069570f, -0.03090237f, 0.21316525f, 0.30715337f, 0.06421164f, 0.05604998f, -0.01174754f, 0.13968870f, 
    -0.01585650f, -0.10731216f, 0.13373832f, 0.22033325f, 0.03363758f, 0.10473994f, -0.02868261f, 0.05889758f, 
    0.11796636f, 0.18760361f, -0.26821217f, 0.10488657f, 0.02373040f, -0.04509208f, -0.04264668f, -0.03991025f, 
    0.01330129f, 0.03749453f, 0.17341831f, 0.01027058f, -0.05570336f, 0.05489505f, -0.01752539f, 0.16607891f, 
    -0.01207428f, 0.00955903f, 0.00450688f, 0.18326877f, 0.03311984f, -0.17158577f, -0.06673298f, 0.06066829f, 
    -0.03722999f, -0.01018060f, 0.02894673f, -0.10947831f, -0.12727404f, -0.12037218f, 0.19141512f, 0.28204656f, 
    0.12409614f, 0.07219072f, 0.18381636f, -0.05637274f, -0.15421586f, 0.05038662f, 0.03641606f, 0.02556018f, 
    -0.01331257f, -0.07875016f, 0.09493571f, 0.17365648f, 0.01211619f, 0.05368019f, 0.01589448f, -0.07679670f, 
    -0.07338489f, 0.19456334f, 0.03224543f, 0.21554276f, -0.05528664f, -0.04845162f, 0.08253200f, 0.18442078f, 
    0.16682909f, -0.02154544f, 0.15379623f, 0.12889883f, 0.02266627f, -0.24976639f, -0.01229269f, 0.17165202f, 
    -0.26154718f, 0.26654413f, -0.01749634f, -0.04648762f, -0.15223135f, 0.02156292f, 0.01616233f, 0.03118519f, 
    0.03732376f, 0.02209373f, 0.08114565f, 0.08438046f, 0.05533576f, -0.11984580f, 0.00958701f, 0.01408389f, 
    0.16284242f, -0.01422182f, 0.05605349f, -0.36592051f, 0.01719226f, -0.13322082f, 0.04886784f, 0.05284007f, 
    0.02234855f, 0.00368457f, -0.03017511f, 0.04827047f, 0.15579231f, 0.01833728f, -0.33342963f, -0.07942640f, 
    -0.03623940f, -0.03687443f, -0.02289736f, 0.19110920f, 0.09772188f, -0.08444627f, 0.01710454f, 0.09672345f, 
    -0.00636512f, -0.14441822f, -0.18462023f, -0.20337640f, -0.16849303f, -0.11901833f, 0.09648636f, -0.00925651f, 
    0.17731330f, -0.06097427f, 0.17523888f, -0.07254310f, -0.03132838f, -0.00907380f, 0.17121094f, -0.07128063f, 
    -0.08178955f, 0.02283621f, -0.03685588f, 0.08215851f, -0.26102662f, -0.06553301f, -0.00421137f, -0.03112536f, 
    0.07646040f, 0.07570917f, 0.11308718f, 0.06657647f, -0.03595506f, 0.22091018f, -0.07500909f, -0.18551275f, 
    -0.47455180f, 0.05068777f, -0.02553145f, 0.01593691f, 0.19663194f, 0.19087397f, -0.25747254f, 0.00078038f, 
    -0.16840856f, 0.09589153f, -0.07419612f, 0.13843675f, 0.13204342f, 0.13135639f, 0.11392607f, 0.04480040f, 
    0.05177719f, 0.03488773f, 0.09335785f, -0.02715692f, 0.06562234f, -0.01299832f, -0.24130443f, -0.01827973f, 
    -0.18127072f, 0.06535652f, 0.14057916f, -0.33792213f, -0.07893529f, 0.00038467f, -0.02990716f, 0.04916940f, 
    0.13193741f, -0.02832134f, 0.00689523f, -0.04699609f, 0.00912784f, 0.13162486f, 0.08711910f, 0.06088968f, 
    0.13450578f, -0.01907576f, -0.09084491f, -0.10260839f, -0.04777077f, -0.10882840f, 0.07082635f, 0.06500516f, 
    0.11797936f, 0.03820159f, 0.03992005f, -0.00616669f, -0.09686991f, 0.00745582f, 0.26926097f, -0.14242381f, 
    0.01425752f, -0.04001031f, 0.06230370f, 0.03972512f, -0.01479376f, -0.00712185f, -0.08683415f, 0.08850846f, 
    -0.31184283f, 0.01361430f, 0.03286422f, -0.00293942f, 0.03025946f, -0.00228484f, -0.05753195f, -0.09348933f, 
    0.03646358f, 0.04313185f, 0.01866580f, -0.00137662f, 0.12829345f, 0.09743966f, -0.13566750f, 0.03399846f, 
    0.00909878f, -0.08032127f, 0.18888527f, 0.03560317f, -0.04515664f, -0.15589273f, 0.14415155f, -0.06427389f, 
    0.01595028f, 0.20392954f, -0.49232924f, 0.06623261f, 0.06472247f, 0.03463358f, 0.02620097f, 0.07303721f, 
    0.04909386f, -0.08402970f, -0.15850747f, 0.14364980f, 0.16689388f, -0.08626539f, -0.10231464f, -0.07289669f, 
    0.01177256f, 0.07748263f, 0.12943678f, -0.16866934f, 0.22990511f, -0.25260541f, 0.05804592f, 0.01330800f, 
    -0.33152595f, -0.04841181f, 0.12672669f, 0.00122453f, 0.03632281f, -0.54024029f, -0.00992731f, -0.10738855f, 
    0.09506629f, 0.12117063f, 0.01870776f, 0.03628462f, -0.10305110f, 0.03775463f, -0.27974311f, 0.04247958f, 
    -0.16370313f, -0.04577581f, 0.04054290f, 0.07267179f, -0.06229428f, -0.11169404f, -0.03315409f, 0.35038495f, 
    -0.11211371f, 0.00251672f, -0.18949053f, 0.04812112f, -0.07243440f, 0.09514874f, -0.04261365f, 0.03497820f, 
    -0.04883927f, -0.14164965f, 0.09496394f, -0.02687388f, 0.12337074f, 0.09400259f, -0.03557976f, -0.04866223f, 
    0.16716833f, 0.26031280f, 0.04367079f, 0.20162749f, -0.01183140f, 0.06937210f, -0.02802935f, -0.05606896f, 
    -0.03348409f, 0.08013574f, -0.34112260f, 0.15614216f, 0.14258340f, 0.05985850f, 0.16523924f, -0.08741990f, 
    -0.01667321f, -0.07537095f, 0.08392871f, -0.12181731f, -0.04614745f, -0.01857655f, 0.05416775f, -0.07750802f, 
    0.02866048f, 0.03391000f, -0.08723349f, -0.13092953f, 0.15657881f, 0.00153132f, 0.00818053f, 0.11184417f, 
    -0.00202434f, 0.02409521f, -0.07211246f, -0.08949595f, -0.00178124f, -0.00517972f, 0.17315881f, 0.20044948f, 
    0.13869670f, 0.06876145f, -0.18775117f, -0.09429011f, 0.01450964f, 0.15547037f, 0.13820547f, -0.03786799f, 
    -0.08233216f, -0.07321589f, 0.08102307f, 0.03491983f, 0.02027154f, -0.17176875f, 0.04270987f, 0.04297237f, 
    -0.25133833f, -0.14771181f, -0.12294059f, 0.04341600f, 0.02037343f, 0.05501485f, -0.03721311f, 0.01163707f, 
    -0.11972509f, 0.20086706f, -0.00768901f, -0.01061454f, 0.05104313f, 0.05466310f, -0.09852970f, -0.12107592f, 
    0.00745179f, 0.11801626f, -0.01953599f, -0.06599619f, 0.04873824f, -0.08504466f, 0.14908506f, 0.10063751f, 
    -0.00983354f, 0.08605294f, -0.15068574f, 0.22335607f, 0.27513564f, 0.09318894f, -0.04282511f, 0.01560946f, 
    -0.07193464f, -0.10502510f, -0.07258412f, 0.05585612f, -0.02640010f, -0.01671863f, 0.29325494f, 0.08235718f, 
    -0.05821434f, 0.03104781f, 0.04608326f, -0.06289217f, 0.27424529f, -0.05677307f, 0.03604073f, 0.02384384f, 
    -0.07064644f, -0.00626994f, -0.14403403f, -0.07583842f, 0.00387373f, 0.36222100f, -0.06785687f, 0.03007583f, 
    -0.08380085f, -0.07681817f, -0.05552960f, -0.03661434f, 0.10286447f, -0.05627818f, 0.26971307f, -0.12850183f, 
    -0.03033803f, -0.17741498f, -0.03860238f, -0.01203997f, 0.03338147f, 0.02975866f, -0.07134557f, 0.30368191f, 
    -0.11026458f, 0.04720972f, -0.07720390f, 0.03250779f, -0.05456783f, -0.05505149f, -0.03723547f, -0.07120492f, 
    0.02813347f, -0.05199425f, -0.04347508f, -0.03965230f, 0.00738038f, -0.02877646f, -0.00932146f, -0.02894669f, 
    0.02965380f, -0.01099543f, -0.05121649f, 0.04410856f, -0.02946204f, 0.04381813f, -0.04491593f, 0.04683214f, 
    -0.02018898f, -0.03823340f, 0.00183103f, -0.06402469f, -0.02388483f, -0.03478131f, -0.03592243f, -0.00188913f, 
    0.03169204f, 0.04958606f, -0.03885407f, 0.04655494f, -0.03156148f, -0.00819477f, -0.01725263f, -0.06601751f, 
    0.02733357f, 0.04977842f, -0.00107694f, 0.02776240f, 0.05161894f, 0.00721457f, 0.01099616f, -0.02347097f, 
    -0.02339295f, -0.02856492f, -0.01654441f, -0.06239261f, -0.00142635f, -0.01653658f, 0.00279815f, -0.06241407f, 
    0.04876418f, -0.04099091f, -0.01782875f, 0.04467500f, 0.04204112f, -0.00092568f, -0.05808453f, -0.02681243f, 
    -0.04084207f, -0.04801762f, -0.01905724f, -0.02822456f, 0.04813071f, -0.05450656f, 0.02173008f, 0.00099234f, 
    -0.00273922f, 0.03563193f, -0.00495123f, -0.04704060f, -0.05575192f, -0.04503337f, -0.05540185f, -0.05518649f, 
    -0.02422428f, -0.05227765f, -0.03950551f, -0.06145643f, 0.04257385f, 0.04824424f, -0.06001707f, 0.03197091f, 
    0.02236332f, 0.04880094f, 0.04913264f, 0.03952221f, 0.03090600f, 0.05124640f, 0.00043891f, 0.01001121f, 
    -0.04134719f, -0.04593870f, -0.01146968f, -0.06077357f, -0.03849300f, 0.00902103f, -0.04133474f, -0.02450148f, 
    -0.04863495f, -0.02432621f, 0.00255213f, -0.01556460f, 0.04127685f, -0.00956135f, 0.04843940f, -0.05645513f, 
    0.02509796f, -0.03963682f, -0.03426336f, 0.04194199f, 0.04980510f, 0.00426293f, 0.00349246f, -0.04025730f, 
    0.04195318f, 0.03161129f, -0.04291444f, -0.05752834f, -0.02290694f, -0.01440677f, -0.01631746f, 0.00636837f, 
    0.00322143f, -0.06076941f, -0.02824653f, -0.02532551f, 0.04129977f, 0.01435222f, 0.02424705f, -0.03424312f, 
    -0.02465155f, -0.00524881f, -0.02711346f, -0.01256576f, 0.01031701f, 0.01922775f, 0.04207554f, -0.05104233f, 
    0.00278550f, 0.00429399f, 0.00820149f, 0.03217076f, -0.00404932f, 0.04458855f, 0.02122233f, 0.04551907f, 
    0.01513914f, 0.05307521f, -0.02561444f, 0.00755752f, 0.03581772f, -0.00836810f, -0.02297518f, 0.02300630f, 
    0.00975253f, 0.03497134f, -0.03340131f, -0.04724341f, 0.05055771f, -0.00345135f, 0.02969592f, 0.04109829f, 
    -0.04224002f, 0.05771818f, 0.00935654f, -0.06546261f, -0.05453014f, -0.01334191f, -0.02076741f, -0.02987738f, 
    -0.03679151f, -0.03633954f, -0.03051730f, -0.03764639f, -0.05475310f, -0.05719548f, 0.00198863f, -0.04530580f, 
    0.02208373f, -0.04735769f, 0.02824650f, -0.01156769f, 0.03097020f, -0.00604636f, 0.00245306f, -0.03834404f, 
    0.02409757f, -0.05416127f, 0.03538021f, -0.02411099f, 0.01200827f, -0.03333535f, 0.03132631f, 0.00809188f, 
    -0.05707887f, -0.03937054f, 0.03868012f, 0.02233659f, -0.00031301f, -0.01296058f, 0.02850254f, -0.01696008f, 
    0.01344484f, -0.03034844f, -0.01113827f, -0.01527347f, -0.02398157f, -0.00335036f, -0.05878367f, -0.01933174f, 
    -0.06268482f, 0.03552727f, -0.05569924f, 0.03668626f, -0.03127595f, -0.05342599f, -0.03301310f, 0.05323249f, 
    0.03824440f, -0.04010848f, -0.03460037f, 0.00554107f, -0.02737380f, 0.02065481f, 0.00885892f, 0.04858592f, 
    -0.06095088f, -0.01003705f, -0.05696840f, 0.03907953f, -0.02930994f, -0.04863515f, 0.03590531f, -0.01773589f, 
    -0.00735313f, -0.01968247f, 0.05029364f, -0.01713285f, 0.03876990f, 0.03375814f, -0.04541697f, -0.03547869f, 
    0.02207012f, 0.01254183f, -0.00764904f, 0.02633668f, 0.03081759f, 0.03917134f, 0.00921941f, -0.04288324f, 
    -0.02997585f, -0.05826737f, 0.06123753f, -0.05913576f, 0.00508964f, -0.06649924f, -0.03574411f, 0.02568807f, 
    -0.05619546f, 0.00799926f, 0.03844361f, -0.00711065f, 0.02635766f, -0.02602505f, -0.04494625f, -0.04435371f, 
    -0.01400418f, 0.01998296f, 0.01856836f, -0.02596640f, -0.02150313f, 0.01249289f, -0.05118961f, 0.02376048f, 
    -0.00618037f, -0.02565145f, 0.00557015f, -0.02675241f, -0.04961836f, -0.00706495f, -0.02006864f, 0.04500125f, 
    -0.01142846f, 0.02480871f, -0.01673550f, -0.02090844f, 0.01582998f, -0.02546331f, -0.04776360f, 0.02571762f, 
    -0.04425832f, 0.04294333f, 0.03189275f, 0.00524061f, -0.04221209f, 0.01987458f, 0.03382410f, -0.06948897f, 
    -0.04103075f, 0.06390993f, -0.03749780f, 0.01362170f, 0.05193938f, -0.05457316f, 0.02031790f, -0.05648554f, 
    0.05010073f, 0.04177423f, 0.05609297f, 0.03753805f, -0.02091452f, 0.02693517f, 0.00972095f, -0.00715389f, 
    -0.00967259f, -0.03593786f, 0.00762766f, -0.06020967f, 0.04465864f, -0.03983068f, -0.03456682f, -0.03804436f, 
    -0.06081952f, 0.01767554f, 0.01093565f, -0.00037295f, 0.01508908f, -0.02413984f, 0.04277760f, 0.02662059f, 
    -0.06949064f, 0.03065227f, 0.02230248f, 0.00820794f, -0.00200966f, 0.01334988f, 0.02444484f, -0.00325281f, 
    -0.04751828f, 0.01277335f, 0.01371365f, -0.04919333f, 0.02896221f, -0.04712735f, -0.06012984f, -0.01072387f, 
    0.03164275f, -0.03955143f, 0.03918927f, -0.01557208f, -0.04360257f, -0.05042817f, 0.03212548f, 0.03488565f, 
    -0.03186418f, -0.06821944f, -0.01207536f, 0.04340145f, -0.00410515f, -0.01099874f, -0.02124574f, -0.00283738f, 
    -0.03858319f, -0.05711435f, 0.05579525f, -0.04071614f, -0.01003343f, 0.03761483f, -0.03239780f, -0.03991862f, 
    -0.02708790f, -0.03428886f, 0.02997162f, 0.01646244f, -0.04907845f, -0.03083637f, 0.04356470f, -0.00731453f, 
    0.02939739f, -0.01466351f, -0.03787546f, 0.00651208f, -0.06013575f, 0.02015562f, -0.02093134f, 0.02674910f, 
    -0.04601814f, -0.02305868f, -0.07140858f, -0.03498409f, -0.03689636f, 0.03595799f, -0.03554154f, -0.04704591f, 
    0.04386577f, -0.04474666f, -0.04185653f, -0.04669857f, -0.01003387f, -0.02555601f, -0.03735755f, 0.02580582f, 
    0.01113405f, 0.03928024f, -0.05750159f, 0.03152771f, 0.02128496f, 0.02812532f, 0.03563635f, 0.00271607f, 
    -0.02729587f, -0.01282006f, 0.00271640f, -0.02358446f, -0.03042356f, 0.01748687f, 0.04878190f, -0.00542533f, 
    -0.03281447f, 0.03571022f, -0.03629917f, -0.04729077f, -0.04117795f, -0.00301077f, -0.01186773f, -0.05974394f, 
    -0.05545237f, -0.02460905f, -0.04018531f, -0.04908753f, -0.00579184f, -0.00975141f, 0.00481057f, -0.01666931f, 
    -0.02819737f, -0.03514221f, -0.01583787f, -0.03348680f, 0.06033097f, 0.06914391f, -0.04878791f, 0.02362279f, 
    0.03273992f, -0.03393457f, 0.03656443f, -0.04967331f, -0.03267239f, -0.00930137f, 0.01246407f, -0.03802735f, 
    -0.05626758f, 0.04984638f, 0.00098866f, 0.03316242f, -0.03989897f, -0.06153119f, -0.01561973f, 0.00468583f, 
    0.01182445f, 0.02904814f, 0.05167987f, 0.03553689f, -0.05619568f, 0.01630526f, 0.03037874f, 0.03614663f, 
    -0.05892309f, -0.05146659f, -0.02193073f, -0.05085893f, -0.05143175f, -0.04699095f, 0.00333867f, -0.01348261f, 
    0.01514417f, -0.04636911f, -0.04846375f, -0.02567238f, 0.03816394f, -0.02568359f, 0.01329326f, -0.03438689f, 
    -0.02537976f, -0.00634484f, -0.05654496f, -0.03339363f, -0.03656406f, -0.00136581f, 0.00899539f, 0.02663344f, 
    0.03279139f, -0.05992400f, -0.06312093f, -0.02803120f, -0.05770254f, 0.05456280f, -0.00145752f, -0.00587110f, 
    -0.02915836f, 0.00030770f, 0.01339634f, -0.01288819f, 0.00279504f, -0.06484846f, -0.00511047f, -0.00056033f, 
    0.01380382f, 0.02462821f, 0.00026879f, 0.02776554f, 0.01257741f, -0.00104127f, -0.06454180f, 0.04289714f, 
    0.03253362f, -0.05427730f, -0.05484543f, 0.01674805f, -0.04426958f, -0.00192289f, -0.06844421f, 0.01332274f, 
    0.00064712f, 0.02808025f, 0.04909725f, 0.02292535f, 0.00631338f, -0.03855912f, 0.02505516f, -0.01396113f, 
    -0.05507437f, 0.04595712f, -0.03485991f, 0.00588194f, 0.00497724f, -0.03025063f, -0.00512817f, -0.05389522f, 
    -0.02540159f, 0.02632616f, -0.02737087f, -0.06865327f, 0.03924319f, -0.01450711f, 0.00132313f, -0.03303466f, 
    -0.04281010f, -0.02708781f, -0.02824726f, -0.04300838f, 0.01152263f, 0.07056777f, -0.03775742f, -0.03448219f, 
    -0.00250257f, -0.01581446f, 0.00723562f, -0.05253362f, -0.05414193f, 0.04178432f, 0.02602351f, 0.04325540f, 
    -0.02490910f, 0.01974760f, 0.01342833f, 0.00123899f, 0.04866572f, -0.07575314f, 0.02091179f, -0.00998707f, 
    0.01747055f, -0.02360877f, 0.05855554f, -0.00407976f, -0.02111530f, -0.04400841f, 0.06249219f, -0.01048864f, 
    -0.09788273f, -0.26316509f, -0.18858218f, 0.01485705f, 0.00203380f, -0.03880319f, -0.01197789f, -0.11405274f, 
    -0.09893672f, 0.18565364f, -0.04427890f, 0.10225665f, -0.17701982f, -0.06335153f, 0.00361342f, 0.12946588f, 
    -0.06386182f, 0.14607447f, 0.00983429f, 0.02011646f, 0.09123411f, 0.00250604f, -0.09023046f, -0.01524710f, 
    -0.25793138f, 0.11278134f, 0.13217437f, -0.26077515f, -0.01000955f, -0.04109959f, 0.04639159f, 0.00915206f, 
    0.08595707f, -0.10710967f, 0.02566635f, -0.00350774f, 0.02318037f, -0.18009286f, -0.18457247f, 0.12913652f, 
    0.02716484f, 0.12725730f, 0.13832310f, -0.02626118f, -0.15909232f, -0.21488538f, -0.25604936f, -0.01081191f, 
    0.01569973f, -0.06216326f, 0.07895789f, 0.15219574f, 0.00237448f, 0.19053178f, 0.25336877f, 0.21169683f, 
    -0.06510366f, -0.07023627f, -0.05544576f, 0.00111841f, -0.16414322f, -0.05911762f, 0.13142678f, 0.13075146f, 
    0.11679913f, -0.06568672f, -0.06387842f, -0.09289596f, -0.09520277f, 0.05299019f, 0.15044345f, -0.12449846f, 
    0.31157723f, -0.37237623f, 0.12463405f, 0.06982421f, -0.12597336f, 0.06728391f, -0.03897493f, 0.09287257f, 
    0.00991902f, 0.09100225f, -0.08349997f, 0.04917257f, 0.05958625f, 0.00244997f, -0.04395051f, 0.12478931f, 
    -0.04727196f, -0.04461948f, -0.23324457f, -0.19844119f, -0.07139861f, -0.04093879f, 0.02157113f, 0.10027048f, 
    0.11695272f, -0.04767989f, -0.06960680f, -0.01792328f, -0.06708556f, -0.03853538f, 0.05308722f, 0.27389354f, 
    0.06563354f, 0.12365635f, -0.04238200f, -0.10400530f, 0.03649506f, -0.01245743f, -0.04925760f, -0.12748134f, 
    -0.02550791f, 0.04654460f, 0.02103262f, 0.05158656f, 0.08476864f, -0.07856727f, -0.22901379f, 0.05529680f, 
    0.02200662f, 0.07530345f, 0.08415033f, 0.00285683f, 0.06861170f, -0.01338439f, -0.14991219f, -0.00583431f, 
    0.10961042f, -0.03580024f, -0.18546538f, 0.05832288f, 0.14453968f, -0.02090533f, 0.03630903f, 0.00814139f, 
    0.00200275f, 0.06274427f, 0.05508865f, -0.06628805f, 0.00336592f, 0.00330014f, 0.11516729f, 0.17000221f, 
    0.06797646f, 0.00185794f, 0.16666016f, -0.02259803f, -0.02823408f, -0.09025034f, -0.02520581f, 0.02246730f, 
    0.06643577f, -0.02297664f, 0.16858380f, 0.09380454f, 0.08942923f, -0.06355839f, 0.00673679f, -0.08908239f, 
    -0.10607605f, 0.07982115f, 0.32184717f, -0.11487153f, -0.12498188f, 0.06975861f, -0.00945903f, 0.13117075f, 
    0.02213603f, -0.01795566f, -0.02197894f, 0.02642127f, 0.01654131f, -0.07712869f, -0.03518662f, -0.04784905f, 
    0.13615897f, 0.04538696f, 0.02647841f, -0.02116972f, -0.03730962f, -0.00352456f, 0.24866827f, -0.14222166f, 
    -0.03034957f, -0.28230238f, 0.02186152f, 0.02614726f, -0.05416848f, 0.15068659f, -0.31073236f, 0.00956932f, 
    -0.09138010f, 0.03519822f, -0.02908778f, 0.12308649f, -0.14047547f, -0.05921466f, -0.02184122f, -0.08241962f, 
    0.01272653f, 0.01761155f, 0.04553967f, -0.03744755f, -0.08867410f, 0.08567431f, -0.00809009f, 0.18069613f, 
    0.06782050f, 0.02990285f, -0.01606464f, 0.02686419f, -0.02976280f, -0.08818700f, 0.23368955f, 0.10714015f, 
    -0.02992694f, -0.31185296f, -0.01064003f, 0.00957221f, 0.03578346f, -0.04642212f, -0.01947426f, -0.10358152f, 
    0.02806161f, 0.11304627f, 0.06117850f, -0.23217216f, -0.02198313f, -0.03863817f, 0.03771774f, 0.07685953f, 
    0.03095799f, 0.08880014f, -0.31087682f, 0.01139485f, 0.04407377f, 0.00144309f, -0.05390512f, 0.04538245f, 
    0.00730266f, 0.04459291f, -0.03553577f, -0.07924448f, -0.24987236f, -0.09404439f, -0.04542494f, 0.06520635f, 
    -0.12000421f, -0.07785046f, 0.00619807f, -0.04525004f, -0.13607866f, -0.09634562f, 0.12485262f, -0.07221874f, 
    -0.05724620f, 0.10628377f, 0.01264781f, 0.06615903f, 0.00718496f, 0.33853483f, 0.04982115f, 0.28779951f, 
    0.10139386f, -0.05774007f, -0.08982456f, -0.01150735f, -0.07620001f, 0.03889352f, -0.16555911f, 0.28273234f, 
    -0.13430864f, 0.07480191f, -0.00382090f, 0.06778669f, 0.03791466f, -0.05865098f, 0.03588414f, 0.04249950f, 
    0.04399467f, 0.09386629f, -0.01728706f, -0.03352930f, -0.02024375f, -0.02237532f, -0.19524081f, -0.10416780f, 
    0.08956607f, -0.19641998f, -0.20590687f, -0.00196692f, -0.03641317f, -0.14333978f, 0.10778259f, -0.06066185f, 
    -0.07162189f, -0.13422342f, -0.08021010f, -0.14034386f, -0.01243939f, 0.00954969f, -0.07223599f, 0.20416065f, 
    -0.05158199f, 0.01461020f, 0.27009740f, 0.06200974f, -0.17524482f, 0.06072763f, -0.02991955f, 0.10321067f, 
    -0.03039948f, 0.04357245f, -0.12894514f, 0.18073814f, -0.00196549f, -0.09130402f, 0.00197780f, 0.03812986f, 
    -0.03760865f, -0.01618804f, -0.02066226f, 0.03638771f, 0.19098897f, -0.01862872f, 0.09835760f, 0.07771490f, 
    0.05211065f, -0.05744724f, -0.02713842f, 0.08647601f, -0.08220709f, -0.10925912f, 0.07985581f, 0.00478451f, 
    0.02922285f, 0.04401351f, -0.03189600f, -0.02058568f, 0.00616739f, -0.05053195f, -0.24306479f, -0.10140475f, 
    -0.13286339f, -0.00147262f, -0.13883944f, -0.04138733f, -0.00461831f, 0.10026336f, -0.13497642f, 0.04580330f, 
    0.03984333f, 0.14281930f, 0.13089341f, 0.13958947f, 0.13189420f, 0.13857687f, 0.03336491f, -0.11631704f, 
    0.14365329f, -0.15583782f, -0.43539685f, -0.03441364f, -0.02666945f, -0.02921503f, -0.09812263f, 0.09199614f, 
    0.10116301f, 0.20594192f, 0.08204994f, 0.05350111f, -0.02571042f, 0.06100505f, -0.03151166f, 0.03206465f, 
    -0.07788190f, -0.10070302f, -0.03508167f, 0.18197012f, 0.05270438f, 0.17340173f, 0.05570772f, -0.11332339f, 
    -0.01890234f, 0.08030828f, -0.02389443f, -0.09755101f, 0.00118259f, -0.02547109f, 0.09116222f, 0.17506263f, 
    0.00740360f, 0.07651915f, 0.16162370f, 0.01385641f, 0.08625758f, -0.02818228f, 0.08414729f, -0.04850353f, 
    -0.24099910f, 0.21200413f, -0.03002980f, 0.01973753f, 0.09181808f, -0.14701362f, 0.05896980f, -0.10525775f, 
    0.06915253f, -0.06025395f, 0.03133516f, -0.08002148f, -0.13079046f, -0.06349390f, -0.39416251f, -0.00560392f, 
    -0.01938793f, -0.12699801f, 0.04540106f, 0.01779786f, -0.14943047f, -0.04743433f, -0.09838313f, -0.11993612f, 
    -0.08619019f, 0.30712870f, -0.10233229f, -0.02719725f, 0.16605574f, -0.02376562f, 0.00930462f, 0.05431574f, 
    -0.05772736f, -0.07546539f, 0.21377584f, 0.11301294f, -0.02373060f, 0.01147756f, -0.16095074f, 0.02554854f, 
    0.11851411f, -0.14154114f, 0.16465542f, -0.21276006f, 0.04880103f, 0.08446717f, 0.11793716f, 0.20653325f, 
    -0.11561348f, -0.00554401f, 0.21093066f, 0.02953010f, -0.16531105f, -0.00482742f, -0.05628676f, 0.11414222f, 
    -0.08850154f, 0.10520515f, 0.04611826f, 0.03112577f, 0.02951216f, -0.11090691f, 0.04408743f, 0.10731028f, 
    0.07460901f, 0.03072012f, -0.02028434f, 0.03374969f, -0.08743751f, 0.03644314f, -0.00543349f, 0.04169728f, 
    -0.02063795f, -0.08906134f, -0.26297146f, -0.05429632f, -0.03488671f, 0.18428330f, -0.04875584f, -0.32339045f, 
    0.02440991f, 0.02140340f, -0.06641841f, 0.00431108f, 0.00301924f, -0.14694621f, 0.04605733f, -0.00293469f, 
    0.02947280f, -0.06053172f, 0.06151687f, 0.11244501f, 0.00771418f, -0.08053005f, -0.14747123f, -0.11489949f, 
    -0.24311900f, 0.26041356f, -0.07426724f, 0.04363121f, 0.10646587f, -0.17927289f, 0.06566200f, 0.23971148f, 
    0.06460284f, 0.20245141f, -0.02352878f, 0.03529236f, 0.00673263f, -0.12410076f, -0.08921977f, -0.02452600f, 
    0.04719974f, 0.31162032f, 0.03782945f, 0.11265722f, -0.01048436f, 0.11159594f, 0.02583435f, -0.12632109f, 
    -0.00548281f, -0.21030341f, 0.21808201f, 0.22664739f, -0.26803011f, 0.06110345f, -0.14456533f, -0.09468627f, 
    0.03400486f, -0.04327924f, 0.01881636f, 0.12169208f, 0.17012966f, -0.38435382f, 0.09248356f, 0.04390584f, 
    -0.17239106f, 0.01779040f, 0.05507137f, -0.06401311f, -0.12104606f, -0.01417215f, 0.26107386f, -0.07337823f, 
    -0.04748267f, -0.01367842f, -0.09041044f, -0.10955895f, 0.02836304f, 0.09654371f, 0.20851006f, -0.14359729f, 
    -0.10013621f, -0.03869958f, 0.09588394f, 0.08300124f, 0.03947331f, -0.01635648f, -0.10416958f, -0.08292739f, 
    0.14356396f, 0.09848849f, 0.04389019f, 0.12391175f, 0.04202753f, -0.10015704f, -0.06419978f, -0.44324455f, 
    0.08074823f, -0.00508403f, 0.18712132f, -0.07423905f, -0.08944899f, -0.00789380f, -0.00217289f, 0.03343666f, 
    0.08418547f, 0.21246696f, 0.13696073f, -0.09844819f, 0.04229867f, 0.07567741f, 0.25644451f, 0.15206072f, 
    0.00682882f, -0.25282454f, -0.07563100f, -0.22505429f, 0.03385096f, 0.06304726f, -0.14479133f, -0.04150797f, 
    -0.24084279f, 0.14573020f, -0.10178070f, -0.01373621f, 0.10084620f, -0.05501321f, 0.04101909f, -0.05415250f, 
    0.27968475f, 0.04032702f, -0.01148389f, 0.19253063f, 0.04439930f, 0.16593339f, 0.12357229f, -0.01890066f, 
    0.18796092f, 0.19020045f, 0.08827003f, 0.09961700f, 0.03952369f, -0.01783192f, 0.10358828f, 0.04733454f, 
    -0.00946091f, 0.21094401f, 0.08534133f, 0.09454179f, 0.03246731f, 0.25627860f, 0.13858530f, 0.06055847f, 
    0.00344308f, 0.04562289f, 0.03435139f, -0.02957892f, -0.12497642f, 0.28806242f, -0.25733498f, -0.12453989f, 
    -0.36409664f, 0.01825568f, 0.14320837f, 0.11793831f, -0.06935723f, -0.09781960f, -0.17889924f, -0.02491512f, 
    0.01556167f, -0.20361555f, 0.13520005f, 0.06718405f, -0.00102090f, -0.04458566f, -0.16892402f, -0.09858716f, 
    0.20916703f, 0.02434027f, -0.01365262f, 0.01899938f, -0.00250506f, 0.26110762f, -0.10488103f, 0.12105509f, 
    -0.15579435f, -0.03891792f, 0.04735132f, 0.05019484f, 0.11525226f, -0.10533744f, 0.06919535f, -0.17803353f, 
    0.19368911f, 0.05849498f, 0.06407361f, 0.18614861f, 0.12501809f, -0.01248303f, -0.11544932f, 0.04352367f, 
    -0.00062120f, -0.07230935f, 0.15202044f, -0.02789269f, 0.19468923f, 0.25035468f, -0.02921697f, -0.19440179f, 
    0.19750910f, 0.10561007f, 0.06244259f, 0.06500373f, -0.26060206f, -0.20762965f, -0.06760561f, -0.04695432f, 
    -0.03029719f, 0.12875377f, 0.09701509f, -0.07334186f, -0.03624992f, -0.07702684f, 0.00125985f, 0.11262479f, 
    0.03504966f, 0.02986764f, -0.15415724f, -0.06670280f, -0.07573690f, 0.02638101f, -0.47799265f, -0.06467560f, 
    0.11826336f, -0.14208031f, 0.10842115f, 0.15198588f, 0.06812467f, 0.04502765f, 0.08812010f, -0.53784811f, 
    -0.06855100f, 0.03383941f, -0.06192272f, -0.00015417f, 0.08836528f, 0.05898654f, -0.00447397f, -0.18249702f, 
    0.09789892f, 0.23425567f, -0.34583610f, 0.09207679f, -0.04297119f, -0.01570058f, -0.01363075f, 0.05206327f, 
    -0.30238536f, 0.08551514f, 0.08352767f, -0.02909014f, -0.06279229f, 0.12964109f, 0.04610566f, 0.06034718f, 
    0.06114496f, -0.13674051f, -0.08874661f, 0.14032862f, -0.18893689f, 0.05396503f, 0.05383983f, 0.21925870f, 
    -0.09012454f, 0.09037333f, 0.01303041f, 0.02252011f, -0.05233780f, 0.30004546f, 0.16630097f, 0.23744337f, 
    0.10688451f, 0.24306545f, 0.06836332f, 0.04861516f, 0.12381021f, 0.21330445f, -0.19216144f, 0.14298108f, 
    0.07394498f, 0.16633092f, -0.02585817f, 0.02073418f, -0.14979167f, 0.02089352f, 0.12629111f, -0.15090460f, 
    -0.06487720f, 0.10686329f, 0.09557238f, -0.08221891f, 0.00390089f, -0.21307409f, -0.18518510f, 0.13504200f, 
    -0.19184820f, 0.19136062f, 0.14304401f, -0.04558397f, 0.06466441f, -0.13768168f, -0.14564998f, -0.22402975f, 
    0.05417215f, -0.15195334f, -0.00380563f, 0.03537470f, -0.12803586f, -0.03271269f, 0.06078439f, -0.10455468f, 
    0.14392629f, -0.06130384f, 0.03519404f, 0.10955571f, 0.03021022f, -0.14934155f, -0.10430857f, -0.02848482f, 
    0.06236805f, 0.18478483f, -0.01636765f, 0.11381675f, -0.01886646f, 0.15188284f, 0.04294462f, -0.19239579f, 
    -0.05589943f, 0.02375246f, 0.21757072f, 0.18821900f, 0.14183901f, 0.08378954f, 0.06094183f, -0.02209046f, 
    0.03159266f, 0.12044062f, 0.05537753f, 0.18844166f, 0.02559581f, -0.14202599f, 0.00607614f, -0.04725001f, 
    0.01544777f, -0.15997151f, -0.12085647f, -0.14353697f, -0.23155265f, -0.09031914f, -0.00509501f, -0.00973879f, 
    0.00077796f, 0.12552373f, 0.15963456f, 0.09098931f, -0.05920422f, 0.07537424f, -0.06848264f, -0.03759605f, 
    -0.01434528f, 0.04111670f, 0.08715547f, 0.02972911f, 0.07611687f, -0.02409041f, 0.06826066f, 0.01767085f, 
    -0.11280851f, 0.01701417f, 0.08207626f, -0.00418150f, -0.12200999f, -0.05304699f, -0.01488592f, 0.26184532f, 
    -0.04351113f, -0.05849918f, -0.15136370f, -0.07489780f, 0.15016024f, 0.10753223f, -0.05524940f, -0.02296175f, 
    0.07775691f, 0.18305334f, -0.06349614f, -0.02118409f, -0.08079363f, 0.07799512f, -0.03134048f, -0.08680928f, 
    0.03113128f, 0.05961722f, -0.21233846f, 0.21250993f, -0.03731114f, -0.01409976f, 0.02167213f, 0.15065104f, 
    0.06752422f, 0.18532480f, -0.02091986f, -0.24064066f, -0.00238938f, -0.01555844f, 0.12796363f, -0.03534690f, 
    -0.11332052f, 0.03896685f, 0.05932961f, 0.21120936f, 0.09202325f, 0.12509631f, -0.10530359f, 0.02568335f, 
    -0.03482488f, -0.08753565f, -0.11395045f, -0.03060065f, 0.08148354f, 0.10247260f, -0.02654892f, -0.00726311f, 
    0.07544845f, 0.09459906f, 0.00699877f, 0.03805949f, 0.05921211f, 0.22462185f, 0.21975140f, 0.06699958f, 
    0.04227766f, -0.04663879f, 0.04922680f, -0.03154481f, 0.12462258f, -0.11717311f, 0.06004050f, -0.16217405f, 
    -0.16943026f, 0.08507725f, 0.02664473f, 0.08392587f, -0.09481563f, -0.10201970f, -0.01840022f, -0.00506430f, 
    -0.03053260f, -0.05956088f, 0.13196003f, -0.02224294f, -0.06036355f, -0.06215741f, -0.04453953f, 0.17360251f, 
    -0.14057834f, 0.00504728f, 0.18981160f, 0.17437209f, 0.31387356f, -0.02900190f, 0.01942827f, 0.15070850f, 
    -0.13043416f, 0.24753162f, 0.10268870f, -0.11268655f, -0.11848072f, -0.11291454f, -0.10924435f, -0.17697783f, 
    0.08549150f, 0.06470238f, 0.24211185f, 0.21416657f, -0.05437220f, 0.06411492f, -0.08500762f, 0.02718019f, 
    0.01895090f, 0.05464218f, 0.01674921f, -0.03399043f, -0.19324976f, 0.03423730f, -0.04997015f, 0.10498516f, 
    0.01299515f, 0.21762179f, 0.01911245f, 0.08054023f, -0.08708917f, -0.06340108f, -0.23148063f, 0.02188283f, 
    0.21142989f, -0.00478096f, -0.15728681f, -0.04277973f, 0.00800526f, 0.05767052f, 0.15825619f, 0.07012632f, 
    -0.26485571f, 0.07491971f, 0.10231574f, 0.08290087f, 0.18897787f, 0.14227039f, 0.19958819f, 0.04777912f, 
    -0.18368006f, 0.10430998f, 0.06381208f, 0.04070393f, 0.04842076f, -0.04642759f, -0.21824780f, 0.12774530f, 
    0.07535478f, -0.08562449f, -0.10520586f, -0.02604620f, -0.05025870f, 0.08964512f, -0.06563056f, -0.02871709f, 
    0.21154217f, 0.03915152f, -0.23335318f, 0.04671585f, 0.04936761f, -0.07185841f, 0.07450983f, -0.07106751f, 
    -0.01278279f, -0.23502141f, -0.19303189f, -0.16493262f, 0.09527281f, 0.03538048f, 0.15701444f, -0.04587699f, 
    0.22485317f, 0.01752478f, -0.25909409f, 0.01637259f, 0.02025436f, 0.02937544f, 0.10206556f, 0.09233178f, 
    -0.02612332f, 0.11338405f, 0.03970331f, -0.36334690f, -0.00378878f, 0.06056487f, 0.05047751f, 0.17272057f, 
    0.01592276f, -0.07443140f, -0.03716475f, -0.13737807f, -0.20222421f, -0.01836115f, -0.19918552f, -0.00030894f, 
    0.11474357f, 0.09143537f, -0.20553038f, -0.06345396f, -0.13104248f, 0.02785114f, -0.06959676f, -0.03701280f, 
    0.03100335f, -0.11849738f, 0.04289572f, -0.09339972f, 0.07840811f, 0.14068246f, -0.27833354f, 0.24043426f, 
    -0.35008806f, -0.09723064f, -0.13595501f, -0.03996645f, 0.06407983f, -0.02252013f, -0.05632604f, -0.05244432f, 
    0.13638525f, -0.28403825f, -0.00808435f, -0.04987196f, -0.08048256f, 0.06863882f, 0.12739876f, -0.16947056f, 
    0.33464006f, -0.08017494f, -0.11723736f, -0.21996157f, 0.03218108f, 0.02956444f, -0.04446869f, -0.08518395f, 
    0.05133531f, 0.19492060f, 0.01473960f, -0.01378136f, 0.01450552f, -0.00308028f, 0.11513729f, 0.11788937f, 
    0.01415043f, -0.13229421f, 0.23586667f, 0.15402627f, -0.06165750f, -0.08768353f, -0.05607954f, 0.02355698f, 
    0.12692270f, -0.12727031f, -0.08933985f, 0.27125934f, 0.06396668f, -0.07910969f, 0.03233875f, -0.11552183f, 
    0.00000799f, -0.00097362f, -0.22696131f, 0.08814313f, 0.14267153f, -0.01722960f, -0.04019864f, 0.03965450f, 
    -0.07920248f, -0.04680083f, -0.02704205f, -0.04756769f, -0.11638702f, -0.29623261f, -0.18473342f, 0.06971912f, 
    0.02067744f, -0.03244006f, 0.10349716f, 0.03839999f, 0.05503752f, 0.02548560f, -0.07986784f, -0.06521475f, 
    0.00747633f, -0.04285213f, 0.29183277f, 0.02746402f, 0.11160443f, 0.01780485f, 0.06270936f, -0.14799117f, 
    -0.29932815f, 0.10309530f, 0.09921756f, -0.04448335f, -0.03732914f, -0.01452756f, -0.08038092f, 0.08639362f, 
    -0.06371739f, -0.03687131f, 0.05716348f, -0.04004519f, -0.03522519f, 0.03381453f, 0.06629033f, -0.02475525f, 
    0.01258932f, 0.34996939f, 0.01452204f, -0.05124619f, -0.08253472f, 0.13615482f, -0.10093917f, -0.27316725f, 
    0.08518480f, 0.11333782f, -0.13102268f, 0.04998301f, 0.12457227f, 0.03384367f, -0.16004795f, -0.01581579f, 
    0.13120329f, 0.19254267f, 0.00906777f, 0.06647991f, 0.08482859f, 0.01291948f, 0.04654260f, 0.13140762f, 
    0.18538783f, 0.02387019f, -0.00161407f, 0.05538268f, 0.02505512f, -0.00261635f, 0.05790255f, -0.00719458f, 
    0.00463187f, -0.00440598f, 0.00590484f, 0.18664648f, -0.08065178f, -0.01682488f, -0.02880809f, -0.11746076f, 
    0.02247150f, 0.05296478f, 0.08007052f, -0.10268002f, -0.15954959f, -0.00561661f, 0.04784831f, 0.01913248f, 
    0.17959899f, -0.04730368f, 0.08540234f, 0.02378407f, -0.13572349f, -0.00671162f, -0.02228679f, 0.21457197f, 
    -0.02655652f, 0.10983691f, -0.17752890f, 0.01647593f, -0.01747782f, -0.10539670f, -0.07042751f, 0.16817336f, 
    -0.06484976f, 0.04526958f, -0.04092284f, 0.02278138f, -0.06865674f, 0.09325869f, 0.08443602f, -0.16068779f, 
    -0.03883777f, -0.08563155f, 0.03434849f, 0.12505069f, 0.07525885f, -0.10826033f, 0.02707485f, 0.00156650f, 
    0.06399895f, -0.03166994f, -0.11282490f, -0.04367492f, -0.08153213f, 0.00530239f, -0.04373921f, -0.01319350f, 
    0.03069847f, 0.07134991f, 0.13389270f, 0.19313934f, 0.02773286f, -0.37809622f, 0.05982132f, 0.01385677f, 
    0.04484720f, -0.06951797f, -0.03491048f, 0.20308444f, -0.20766556f, 0.05628084f, 0.35426620f, -0.06469582f, 
    0.01931741f, 0.04341679f, 0.03781229f, 0.13593952f, -0.14679767f, 0.02120633f, 0.11476374f, 0.05608272f, 
    0.27772203f, 0.18557188f, 0.21043134f, 0.01444699f, -0.12297754f, 0.08234512f, -0.06256852f, 0.06037864f, 
    0.06862529f, -0.19700345f, -0.09569300f, 0.04217652f, -0.11245900f, 0.17481340f, -0.12363200f, 0.21807434f, 
    0.21526417f, 0.29794082f, 0.01610269f, 0.00387863f, -0.13841076f, 0.15474389f, -0.10535844f, 0.00716400f, 
    -0.19934654f, -0.11636041f, 0.23885053f, 0.06114278f, -0.01570179f, -0.11173649f, -0.01333387f, 0.05854844f, 
    0.13045387f, 0.09975739f, -0.17104131f, -0.18077768f, -0.09630536f, 0.00667419f, -0.04832367f, -0.13380398f, 
    0.01187958f, -0.10282974f, 0.18253453f, -0.14650214f, 0.04369790f, -0.07603181f, 0.05113086f, 0.07034604f, 
    -0.07325452f, -0.12866940f, -0.11603384f, 0.05017512f, 0.05853019f, -0.31726342f, 0.08228780f, 0.16076468f, 
    0.03455176f, -0.24472664f, -0.07913036f, 0.13972014f, -0.15430538f, -0.13145262f, 0.11009529f, 0.10450911f, 
    -0.05331530f, -0.04591633f, 0.12326569f, 0.03825923f, 0.10132659f, 0.09941953f, -0.02666298f, -0.00560923f, 
    -0.02201703f, -0.12850095f, -0.23872809f, -0.01166083f, 0.11906520f, -0.08093277f, -0.00187200f, -0.03615886f, 
    -0.12587889f, 0.03044242f, 0.14571817f, 0.02100166f, -0.06449543f, 0.00840344f, 0.00590448f, -0.06370606f, 
    0.26459289f, 0.20955534f, 0.14676070f, -0.06436060f, -0.01905773f, -0.12039505f, 0.17064065f, -0.02647002f, 
    -0.22455120f, 0.08221275f, -0.02109635f, 0.13846979f, -0.12351421f, 0.04793442f, -0.05822998f, -0.04677938f, 
    0.22702987f, 0.08360349f, 0.06688856f, 0.03787399f, 0.11113894f, 0.03769076f, 0.01216601f, 0.08847912f, 
    -0.27631530f, -0.12239174f, -0.02515255f, -0.03418182f, -0.05832845f, -0.00179529f, 0.04169030f, 0.04925285f, 
    -0.06083418f, -0.00324899f, -0.02365504f, -0.18477723f, 0.10887975f, 0.00372039f, -0.04650405f, -0.02436372f, 
    -0.02865651f, -0.09769832f, 0.07096340f, 0.02861531f, 0.31407264f, 0.00562432f, 0.17492646f, -0.27784574f, 
    0.12408261f, -0.00132402f, -0.04906835f, 0.02202463f, 0.13733277f, -0.15976690f, -0.22083390f, 0.07134192f, 
    -0.00382481f, -0.09777520f, -0.01888178f, -0.00347545f, 0.00968424f, 0.07329825f, 0.11644257f, -0.09901717f, 
    0.16013363f, -0.02581878f, -0.08158686f, 0.18430452f, -0.24999179f, 0.07496648f, -0.02128056f, -0.06843267f, 
    0.02167250f, 0.07478972f, 0.06213023f, 0.04212311f, 0.16317596f, 0.02867677f, 0.02897738f, -0.02492398f, 
    -0.11843553f, 0.04130839f, -0.00736466f, 0.06302643f, 0.08236157f, -0.03543011f, -0.06400594f, 0.01403779f, 
    -0.02609996f, -0.12234180f, -0.25375542f, -0.04816441f, -0.06234815f, -0.03253456f, -0.30478811f, -0.16252875f, 
    0.01629939f, 0.10697484f, -0.35146093f, 0.02363048f, 0.22529198f, -0.00541489f, 0.07700758f, 0.01583757f, 
    0.15350635f, 0.01090595f, 0.06234346f, 0.00686244f, 0.08702591f, 0.22276320f, 0.20697552f, 0.12561443f, 
    0.07096659f, 0.16056101f, -0.00741832f, 0.03135355f, -0.09176023f, -0.03116593f, 0.09646807f, -0.00098412f, 
    -0.02994523f, -0.09508267f, -0.08105169f, 0.03637910f, 0.02471704f, 0.12941621f, 0.09283336f, 0.19503799f, 
    0.02008948f, -0.03177097f, -0.00688397f, 0.25829825f, 0.03241129f, -0.10044355f, -0.00607508f, 0.03586334f, 
    -0.11901209f, -0.05583283f, -0.10729390f, -0.01822459f, -0.07971936f, 0.03541924f, -0.11926914f, -0.00809642f, 
    -0.01567083f, -0.13726042f, -0.03527650f, 0.06030126f, -0.05977996f, 0.09481356f, -0.02663959f, 0.09392320f, 
    0.09405682f, 0.03349379f, 0.27484012f, 0.02836291f, 0.08798076f, -0.01972659f, 0.21513008f, -0.02408443f, 
    0.06059992f, 0.06480023f, 0.22289774f, -0.08403365f, 0.08592747f, -0.09183066f, 0.02496956f, -0.02032732f, 
    -0.02067196f, 0.04979083f, -0.02297247f, 0.13030975f, 0.12491071f, -0.14609599f, -0.09638993f, -0.08572916f, 
    0.12004587f, 0.01097369f, -0.09933759f, -0.23195362f, -0.19523039f, -0.00740377f, 0.09604855f, -0.08846655f, 
    -0.05497860f, 0.02454299f, 0.04803222f, 0.03324493f, -0.34808776f, -0.20831439f, -0.27081823f, -0.03319738f, 
    0.01078703f, -0.09786728f, 0.02129474f, 0.07994881f, 0.05814966f, 0.09506054f, 0.10051619f, -0.02417388f, 
    0.07696216f, -0.10134747f, 0.08551516f, 0.00538693f, 0.00235393f, -0.02578663f, -0.49898916f, -0.00339541f, 
    0.07118652f, -0.02945334f, 0.00207156f, -0.14103161f, -0.07933838f, -0.18814023f, 0.04514640f, 0.07979988f, 
    0.14316304f, -0.26956284f, 0.08462612f, 0.12796438f, 0.20924076f, 0.16206816f, -0.23768350f, -0.05114965f, 
    -0.25835028f, 0.19949701f, -0.14688641f, 0.17138958f, 0.14692470f, 0.03676773f, 0.13081504f, 0.02935589f, 
    0.04848976f, 0.11242518f, -0.00303179f, -0.00361443f, -0.02083129f, -0.05617641f, 0.10040011f, 0.03486453f, 
    0.05551311f, 0.06911562f, -0.21516262f, -0.18374604f, -0.12701495f, 0.14077301f, 0.08465348f, -0.08949959f, 
    0.15402941f, 0.06748071f, 0.01327738f, -0.27608457f, -0.23000310f, -0.11364380f, 0.02326581f, 0.00011610f, 
    0.00914406f, 0.01527724f, 0.04205472f, -0.03043373f, -0.21272339f, -0.21208242f, 0.00398186f, 0.28396675f, 
    0.09628342f, -0.06024081f, 0.09736507f, 0.02980486f, -0.11994831f, -0.04016664f, 0.03529780f, 0.01732281f, 
    0.00793260f, -0.00740486f, -0.05404697f, 0.03930918f, 0.05226331f, 0.23106310f, -0.19229797f, -0.16178060f, 
    -0.44393471f, 0.11945118f, 0.13880992f, 0.04924493f, -0.09675855f, -0.02573187f, -0.00954776f, -0.15605816f, 
    0.08347564f, -0.20985486f, 0.08956010f, 0.03494191f, 0.11994143f, 0.13208972f, -0.10559851f, 0.03189071f, 
    -0.31687307f, 0.06371699f, 0.02507687f, -0.04365632f, -0.15749079f, -0.02788598f, -0.08288263f, 0.00545688f, 
    -0.09214804f, -0.12500788f, 0.09220716f, 0.05907401f, 0.17781441f, 0.03187824f, 0.05157036f, 0.09119164f, 
    -0.08865032f, -0.04130348f, -0.09140062f, 0.22217809f, 0.28546143f, 0.13423494f, 0.03516844f, 0.04413220f, 
    0.13204135f, 0.05315189f, 0.07317507f, -0.04932219f, -0.00863907f, 0.22921547f, -0.16002460f, 0.00812973f, 
    -0.03387560f, 0.04841915f, 0.14686710f, 0.07686632f, -0.06803682f, 0.04822146f, -0.33878234f, 0.14847544f, 
    -0.10908336f, -0.11505362f, -0.02729518f, -0.08363767f, -0.02191656f, 0.26626730f, -0.09894574f, -0.07702249f, 
    0.20074716f, 0.03968998f, -0.27940065f, 0.04712551f, 0.12480672f, 0.25924608f, -0.17694138f, 0.05183152f, 
    -0.07200802f, 0.00151776f, -0.13041376f, -0.08102399f, -0.24868254f, 0.06835993f, 0.15347469f, -0.11639905f, 
    -0.00417854f, -0.05745813f, 0.09248200f, -0.14325675f, 0.01417718f, 0.03319254f, 0.07598371f, 0.01200746f, 
    -0.02091023f, -0.01874433f, 0.04811244f, 0.01902140f, 0.05768501f, -0.04564660f, 0.01830283f, 0.02077560f, 
    0.01415031f, -0.05564247f, -0.03161778f, -0.02556591f, 0.04467323f, -0.03698108f, 0.03472878f, -0.04485527f, 
    -0.00117937f, -0.02125382f, 0.04583988f, 0.00304315f, 0.01975514f, 0.00741621f, 0.00108775f, 0.02838819f, 
    -0.00583248f, -0.05109195f, -0.05776399f, -0.05668098f, -0.03575951f, -0.05078273f, -0.03733263f, 0.02689563f, 
    0.00603347f, 0.01636565f, -0.00195013f, -0.00281400f, -0.00710736f, -0.01646017f, -0.05488772f, 0.02332795f, 
    0.04448923f, -0.00053006f, -0.03827545f, 0.00046142f, -0.05862998f, -0.02007101f, -0.00314701f, -0.00761027f, 
    -0.05742914f, 0.01270068f, -0.06438520f, -0.03711199f, -0.03099536f, 0.02156157f, 0.02830931f, 0.03667749f, 
    0.00938339f, -0.04433042f, 0.00251554f, 0.03465548f, 0.05002280f, -0.05825927f, -0.05642103f, -0.00981211f, 
    -0.04685438f, -0.01962907f, -0.01440702f, -0.02715843f, -0.04598742f, 0.00260984f, -0.02732751f, -0.02015467f, 
    -0.00503425f, -0.03985914f, -0.03651230f, 0.00211311f, -0.04294341f, -0.02634376f, -0.00018507f, -0.01682579f, 
    0.01897077f, 0.03966713f, -0.01840013f, 0.01964855f, -0.00302160f, -0.00941982f, 0.04779050f, -0.02938534f, 
    -0.04635176f, -0.00579420f, 0.01328559f, 0.01923529f, -0.04506431f, 0.00643557f, 0.01850365f, 0.04092273f, 
    0.04532216f, -0.00321183f, -0.00417772f, -0.05313615f, 0.03472552f, -0.01588297f, -0.02094317f, 0.03145539f, 
    -0.00086236f, -0.05866447f, -0.03033810f, -0.02558411f, -0.01089158f, 0.04370950f, -0.03932479f, 0.04244923f, 
    0.02732140f, -0.02672166f, -0.01271031f, -0.03923151f, 0.00079840f, -0.03957075f, -0.01556081f, -0.02099504f, 
    0.00350801f, 0.02990305f, 0.03841064f, 0.04521690f, -0.05287072f, 0.02433041f, -0.00274740f, 0.00187888f, 
    -0.04486176f, 0.03165542f, -0.06022800f, -0.02353253f, -0.00670764f, 0.04867481f, -0.00007905f, -0.02189283f, 
    -0.01556863f, 0.03561114f, -0.03163593f, 0.00886066f, 0.05085639f, -0.05132985f, -0.04160780f, -0.03978486f, 
    -0.00872290f, 0.03255229f, -0.06704079f, -0.01515813f, 0.03397176f, 0.01729612f, 0.00263709f, 0.03825268f, 
    -0.01339719f, -0.03711587f, -0.06459883f, 0.03974463f, 0.03369332f, 0.03225369f, 0.01117399f, -0.03616815f, 
    0.01901069f, -0.01309496f, -0.01240948f, -0.03881485f, 0.02786204f, -0.06624289f, 0.03698376f, -0.03696268f, 
    -0.01439146f, -0.01653575f, 0.00431887f, 0.02880948f, -0.03263252f, -0.02274194f, 0.01043819f, -0.00020378f, 
    -0.02079178f, -0.01744117f, 0.01550694f, -0.06294630f, 0.00938494f, 0.01866864f, -0.05355289f, -0.00001344f, 
    0.03036650f, -0.01172249f, 0.04949610f, -0.04488995f, -0.04985613f, -0.05032376f, 0.01428628f, 0.02702936f, 
    -0.03276545f, 0.04686037f, -0.05487778f, -0.02162767f, -0.02473041f, 0.02919749f, -0.02322726f, -0.02120309f, 
    0.04502004f, -0.01969595f, -0.00768171f, -0.00877017f, -0.02402403f, -0.04030389f, 0.04949973f, -0.03498265f, 
    0.01220015f, 0.01080205f, -0.05677834f, 0.04523164f, 0.03027027f, -0.00026567f, -0.03596354f, 0.01648736f, 
    -0.06006324f, -0.02587107f, -0.05955807f, -0.01790199f, 0.02980341f, 0.02306006f, -0.02697720f, -0.02238487f, 
    -0.03963723f, 0.02534407f, 0.00965613f, -0.01602464f, -0.05345852f, 0.02197034f, 0.04941415f, -0.03985270f, 
    0.04473581f, 0.02172125f, 0.04417314f, -0.02143777f, 0.04512360f, 0.01137058f, -0.04239240f, -0.04187922f, 
    0.03416119f, -0.03368229f, 0.04023928f, -0.00545798f, 0.02374455f, 0.04732666f, 0.04014686f, 0.01582547f, 
    0.04010687f, 0.03448627f, -0.02487904f, -0.02743513f, 0.02122582f, 0.00337080f, -0.04195760f, -0.01695300f, 
    -0.04119650f, -0.05688564f, 0.03475056f, 0.02955468f, -0.00119293f, 0.00208985f, -0.01625780f, 0.01063590f, 
    0.02258367f, 0.04211635f, 0.04618076f, -0.01681246f, 0.03288712f, -0.03230283f, -0.04162076f, -0.03604841f, 
    -0.05511446f, 0.00598434f, 0.03247016f, 0.03703211f, -0.04014632f, -0.01070018f, 0.02546633f, 0.01081429f, 
    -0.06446337f, -0.05773505f, 0.02165912f, 0.01402627f, 0.00583104f, -0.05156902f, 0.00158943f, -0.01115142f, 
    0.00093898f, 0.25844631f, -0.12337731f, 0.07062530f, 0.06069852f, -0.00749226f, -0.04029572f, -0.15808567f, 
    -0.05425776f, -0.31099534f, -0.03753559f, -0.00866394f, 0.19865456f, -0.07505319f, -0.09353948f, 0.16604240f, 
    -0.00217155f, 0.03183888f, -0.10202952f, 0.01361564f, -0.18442479f, -0.10235122f, 0.01918103f, 0.04344011f, 
    -0.01553394f, -0.06177792f, 0.11208537f, 0.17925352f, 0.30078623f, -0.05841570f, 0.22803125f, -0.01666327f, 
    -0.01232364f, -0.02957225f, 0.04197735f, 0.04648354f, 0.18815894f, 0.29397643f, -0.01064207f, 0.06641853f, 
    0.03738324f, 0.02401101f, 0.09919584f, 0.02941053f, -0.02613753f, 0.02425152f, 0.05766749f, 0.05078592f, 
    0.01991433f, 0.00904749f, 0.06940672f, 0.09734774f, 0.03800929f, 0.01532466f, -0.34036639f, -0.23744123f, 
    -0.18351761f, 0.07998696f, 0.04735659f, 0.01834924f, -0.07301915f, -0.04661298f, 0.08565953f, -0.20254607f, 
    -0.09643926f, 0.11694737f, -0.08733243f, 0.02477127f, 0.08822887f, 0.11073187f, 0.06486259f, -0.00377150f, 
    -0.08843235f, 0.04344641f, -0.18936498f, -0.02614621f, 0.00919512f, -0.04285041f, 0.00133269f, 0.04544430f, 
    0.00856489f, 0.17544551f, 0.10184038f, 0.12062216f, 0.14581051f, 0.11747794f, -0.00811447f, 0.08188535f, 
    0.00840117f, -0.11955634f, 0.09360453f, -0.01472944f, 0.17733695f, 0.08304009f, 0.17591925f, -0.04484931f, 
    0.17007981f, 0.15150361f, 0.05275075f, -0.09821728f, -0.24164975f, -0.01554012f, 0.03641510f, 0.09079971f, 
    -0.06890317f, 0.15042780f, 0.05135830f, 0.11030752f, -0.23414753f, -0.15554117f, -0.19375184f, -0.14451748f, 
    -0.18810377f, 0.02437504f, -0.15393889f, -0.07871351f, 0.02083361f, 0.00411415f, -0.10241407f, -0.15749578f, 
    0.07278042f, 0.07081345f, -0.11529645f, 0.07261337f, 0.10787404f, 0.04014779f, 0.10561889f, -0.05184241f, 
    0.05248568f, 0.03145999f, -0.01794687f, 0.09469152f, 0.02285751f, 0.10856532f, 0.01936364f, -0.16013564f, 
    -0.19214727f, -0.00873803f, -0.16865802f, -0.15463962f, -0.09098188f, 0.02100637f, -0.03720761f, -0.04958290f, 
    -0.27886546f, -0.07435517f, 0.04010238f, 0.00163136f, -0.13064660f, -0.06669184f, -0.09316511f, 0.03552289f, 
    0.06731193f, -0.13040540f, -0.23791465f, -0.02868840f, 0.10111419f, 0.10000607f, 0.00629616f, 0.02325770f, 
    0.07484690f, 0.15617903f, 0.31618950f, -0.01105006f, -0.12889135f, -0.10540669f, -0.01743877f, 0.11192628f, 
    0.05656238f, 0.07553298f, -0.01928558f, 0.18050638f, 0.19642372f, 0.19758643f, -0.03543141f, -0.01170641f, 
    -0.07575468f, 0.09227701f, -0.08811436f, -0.01507464f, -0.52132404f, -0.11741316f, 0.36371058f, -0.06102216f, 
    0.04610235f, -0.01922645f, -0.14282282f, -0.01374007f, 0.04132127f, 0.17765531f, 0.20009890f, -0.33712131f, 
    -0.00383239f, 0.06915520f, 0.08634250f, 0.06657685f, 0.09833210f, 0.14150470f, -0.09847840f, -0.19723593f, 
    0.22664945f, -0.12645420f, 0.09233413f, -0.10772341f, 0.04439524f, -0.02775237f, -0.00142687f, 0.13190497f, 
    -0.09251586f, 0.16841729f, -0.19946694f, -0.11780281f, -0.08756703f, -0.03790240f, 0.09100144f, 0.04156663f, 
    0.01501508f, 0.18103686f, -0.25818971f, -0.05032115f, -0.01456824f, -0.04669375f, -0.12429930f, -0.09065331f, 
    0.08002645f, -0.15504247f, 0.13386251f, 0.05956633f, -0.06336558f, 0.04632797f, 0.04546931f, -0.02441118f, 
    0.05467988f, -0.08499154f, 0.05541205f, -0.08639760f, -0.13136278f, 0.19602528f, 0.02374860f, 0.09062110f, 
    0.13648351f, -0.09273624f, 0.06273892f, 0.02381953f, 0.01412122f, -0.30777234f, -0.01113576f, 0.02388636f, 
    0.08191171f, -0.00919534f, 0.06034619f, -0.03834702f, -0.11535318f, -0.11290225f, 0.13458237f, -0.07565977f, 
    -0.08797872f, 0.12688051f, -0.14923058f, -0.00730463f, -0.17097910f, -0.24003032f, -0.24509530f, 0.01013769f, 
    0.02380917f, -0.05460490f, -0.00163470f, -0.00421654f, 0.13391933f, 0.08508639f, -0.08097880f, 0.09481963f, 
    -0.12322535f, 0.13595527f, -0.15319869f, 0.06982245f, -0.03099169f, -0.01551297f, -0.09184802f, -0.32965282f, 
    -0.19931796f, 0.32009882f, 0.00791874f, 0.15083767f, 0.08884799f, -0.07670304f, -0.08148884f, -0.04996349f, 
    0.03234449f, 0.00118283f, 0.03304583f, -0.06330936f, -0.02115604f, -0.01095046f, -0.06445358f, 0.03191819f, 
    -0.00217660f, 0.04186872f, 0.00382369f, 0.03088916f, 0.01293400f, -0.03727362f, 0.02471549f, 0.02900100f, 
    0.02991664f, 0.03020015f, -0.02864871f, 0.05292704f, -0.00512067f, 0.01374117f, 0.00482894f, -0.03105278f, 
    -0.06441305f, 0.01348177f, -0.02861118f, -0.06518055f, 0.05204746f, 0.01271156f, -0.00899357f, -0.04981238f, 
    -0.02859212f, -0.05833868f, -0.01248738f, -0.00349351f, 0.01781606f, 0.01425831f, 0.00249519f, 0.01000858f, 
    -0.04680398f, 0.01561758f, 0.00086283f, -0.06111002f, 0.00980490f, 0.01549540f, -0.06472421f, -0.05723264f, 
    -0.04619867f, -0.02810775f, 0.02510610f, -0.05390469f, 0.03782604f, -0.05242825f, -0.02595618f, -0.04412049f, 
    -0.01602814f, -0.01466946f, 0.00285081f, -0.00868754f, 0.01638102f, -0.03376988f, -0.05057434f, -0.05502957f, 
    -0.01672097f, 0.01889866f, 0.04736398f, -0.00945674f, 0.02023957f, -0.00463975f, -0.02318824f, -0.03102581f, 
    -0.02578620f, -0.05117886f, -0.03121432f, 0.03695157f, -0.00315917f, 0.03221305f, -0.00970759f, 0.02838499f, 
    -0.00138610f, -0.03081549f, -0.03324593f, 0.02360787f, 0.03771790f, 0.04519998f, -0.01148402f, -0.03489372f, 
    0.00734987f, 0.04438720f, -0.05020067f, -0.01011608f, -0.05722161f, 0.03713249f, 0.01093675f, 0.02008565f, 
    -0.06125295f, 0.04484975f, -0.02990674f, -0.03742748f, 0.01457824f, 0.01186385f, -0.05350716f, -0.05167837f, 
    0.03733473f, 0.04156460f, -0.01676097f, -0.01294478f, 0.05094579f, -0.06039171f, -0.00906527f, -0.02089629f, 
    -0.01993779f, 0.00683700f, -0.01178192f, -0.05776223f, 0.00635818f, -0.01099736f, -0.00391169f, -0.03087381f, 
    -0.02426814f, -0.04866372f, -0.02229157f, 0.03705944f, -0.04204623f, -0.02484678f, -0.04369639f, -0.01780261f, 
    -0.00544387f, 0.00885026f, -0.05087842f, 0.02440308f, -0.00299438f, -0.05742145f, 0.00275752f, 0.02362428f, 
    -0.00884903f, -0.00133137f, 0.00991327f, 0.00389095f, 0.00373267f, 0.00815895f, 0.03342244f, -0.06208245f, 
    -0.06429805f, 0.02510455f, -0.03272319f, 0.02122883f, 0.01048018f, -0.05156678f, -0.00154758f, -0.02956992f, 
    0.00968815f, -0.02348501f, -0.03339612f, -0.05317155f, -0.01765718f, 0.02309768f, -0.02911620f, 0.01200722f, 
    0.01683168f, 0.02102277f, -0.01595527f, 0.03952182f, -0.06619590f, 0.02142813f, -0.00890556f, 0.00980553f, 
    -0.05193594f, 0.01022229f, -0.00403297f, -0.01636042f, 0.02487387f, 0.00411150f, 0.04988888f, -0.04174785f, 
    0.02664915f, 0.01170939f, 0.05212718f, -0.05482225f, 0.02565698f, 0.04683066f, -0.01932153f, -0.00176313f, 
    -0.00448317f, 0.03255419f, -0.01405738f, 0.05042313f, -0.02953980f, -0.03771436f, 0.01329217f, -0.04217197f, 
    0.02884893f, -0.02372397f, 0.00801218f, 0.00165960f, -0.06328056f, -0.04445679f, 0.03028521f, -0.05342824f, 
    -0.01929394f, 0.01049058f, -0.05183451f, 0.04540988f, 0.00123203f, -0.01212720f, 0.01122849f, 0.01914886f, 
    0.01784607f, 0.00691523f, -0.03214910f, 0.03059434f, 0.00577881f, -0.06245458f, -0.01897178f, 0.04501859f, 
    -0.03967391f, -0.02101132f, -0.05873588f, -0.04969493f, -0.04896423f, 0.03521708f, -0.04687125f, -0.06430449f, 
    0.00403023f, 0.04081350f, -0.05928342f, -0.02702190f, 0.03176128f, -0.06553669f, -0.03190246f, -0.05889289f, 
    0.02802605f, -0.03913500f, -0.02071405f, 0.03428501f, -0.02198274f, -0.03178255f, 0.02789422f, 0.02181540f, 
    0.00822895f, 0.00546392f, 0.00348862f, -0.02270661f, 0.02307833f, 0.04648826f, -0.05842637f, -0.01517429f, 
    -0.05041595f, 0.04380940f, 0.00272876f, -0.02673209f, 0.04193189f, 0.04773342f, 0.03580562f, 0.02609657f, 
    0.01086510f, 0.02448361f, -0.02314997f, -0.04055434f, -0.03956835f, 0.00100095f, 0.02266388f, -0.04312155f, 
    -0.03652894f, -0.05128853f, -0.05040475f, 0.02980085f, -0.03117586f, 0.04067359f, 0.04210153f, 0.04906464f, 
    0.02642692f, 0.00370383f, -0.00411210f, -0.02036470f, -0.03084800f, -0.05946552f, -0.05848906f, -0.02752735f, 
    0.02994306f, 0.02350566f, -0.01726926f, 0.02563357f, 0.05172453f, 0.05149289f, 0.04330234f, 0.00137003f, 
    0.15802051f, -0.00407906f, 0.01141245f, 0.07368615f, -0.03462024f, -0.02045275f, -0.02217939f, 0.12532462f, 
    -0.06364562f, 0.16483140f, 0.12744221f, -0.03936157f, -0.00879442f, 0.02003955f, 0.00673484f, -0.12256976f, 
    0.03075921f, -0.02231910f, 0.05665685f, -0.08877016f, 0.10843050f, -0.01637890f, -0.01786633f, -0.07744485f, 
    -0.01202243f, 0.00777491f, -0.20248766f, 0.00171367f, -0.01275406f, -0.09086724f, -0.01505906f, -0.11843745f, 
    -0.10018212f, 0.02145421f, -0.03188771f, 0.09587817f, 0.18357590f, -0.12088707f, -0.17255704f, 0.08712234f, 
    0.06792496f, -0.07263036f, -0.07387440f, 0.08611710f, -0.01482477f, 0.06770376f, -0.09970961f, 0.01279809f, 
    -0.26680577f, -0.03210251f, 0.05117131f, -0.05130482f, 0.04237604f, 0.09649578f, 0.09851805f, 0.41351309f, 
    0.17957647f, 0.22054151f, 0.02320758f, 0.02589827f, -0.14798144f, -0.07483760f, -0.15720466f, -0.00449743f, 
    0.12811330f, -0.07444951f, 0.01585023f, -0.08792397f, 0.04552043f, -0.08289974f, 0.03936345f, -0.07336417f, 
    0.05803562f, 0.17757568f, -0.06781064f, -0.08058623f, 0.03824282f, 0.09492543f, -0.07549709f, -0.07328025f, 
    -0.09997473f, 0.13451579f, -0.00061885f, 0.01952233f, 0.07859327f, -0.10034123f, -0.15549387f, 0.08085470f, 
    -0.06872195f, 0.02567316f, -0.10112928f, -0.15263735f, 0.05164491f, -0.14979659f, -0.01765619f, 0.06833570f, 
    -0.07099938f, -0.05563152f, 0.10370603f, 0.15828806f, -0.10539902f, 0.03956044f, -0.11113258f, 0.08530077f, 
    -0.14098470f, 0.01103116f, 0.05379088f, 0.23122558f, 0.09155558f, 0.13206464f, 0.04143177f, -0.06455587f, 
    0.04822411f, -0.05518320f, 0.09528586f, 0.11429523f, -0.27156413f, 0.09463193f, -0.16471983f, -0.12094729f, 
    0.07912165f, -0.03536513f, -0.05670371f, 0.07545196f, -0.10041325f, -0.00676427f, -0.15393715f, 0.00584810f, 
    0.01534861f, 0.17804581f, -0.04435246f, -0.04385911f, 0.05092195f, -0.02272942f, 0.04257014f, 0.10293000f, 
    0.13035801f, 0.13226213f, 0.07433010f, -0.11026745f, -0.06642183f, 0.20558122f, 0.15232432f, 0.06098092f, 
    0.17642486f, 0.19460620f, 0.17036445f, 0.10617030f, 0.01617949f, 0.01572757f, 0.00603638f, 0.03335281f, 
    -0.08191238f, -0.03140084f, -0.00823016f, 0.05854608f, -0.03726074f, -0.08122931f, -0.03638419f, -0.10459090f, 
    -0.01883160f, -0.13672018f, 0.14907052f, 0.05287091f, 0.07153248f, 0.02829143f, 0.00628481f, -0.05215894f, 
    -0.04131623f, 0.00311291f, -0.05242281f, -0.01234938f, 0.06182377f, -0.13323937f, -0.09037671f, -0.02520482f, 
    -0.03086155f, 0.00999419f, 0.02726156f, 0.15379012f, -0.06726903f, 0.09824401f, 0.20873404f, 0.00143815f, 
    -0.15674235f, 0.10828287f, 0.05171181f, -0.10443624f, 0.01356223f, 0.09796266f, -0.18315805f, -0.23291263f, 
    -0.10845648f, -0.16513111f, 0.02815492f, -0.03768739f, 0.07584145f, -0.09823849f, -0.04894583f, 0.15426160f, 
    0.25741217f, 0.07224292f, 0.00654166f, 0.13675182f, 0.01951246f, 0.00418789f, 0.11161683f, 0.14292838f, 
    0.16060229f, 0.10785410f, 0.21093652f, -0.00859440f, 0.01309634f, 0.01602223f, -0.00747543f, -0.00354565f, 
    -0.01134670f, -0.22279027f, -0.09393007f, 0.04812344f, -0.00517902f, -0.11950745f, -0.06277293f, -0.09710006f, 
    -0.01852859f, 0.06203132f, 0.09000784f, -0.20735058f, -0.20569818f, -0.09871589f, 0.03221788f, 0.03883933f, 
    0.04147815f, -0.10914417f, -0.24280550f, -0.06929729f, 0.09308194f, -0.03796923f, 0.02545764f, 0.03752141f, 
    0.05085771f, -0.01407180f, 0.06784884f, -0.19157770f, -0.27016774f, -0.08419232f, -0.04446819f, -0.09725856f, 
    0.02590151f, -0.10055941f, -0.04685765f, -0.30379456f, 0.29544920f, 0.02088887f, -0.13591300f, -0.01978857f, 
    0.09975779f, -0.05276532f, 0.16049609f, 0.03223830f, 0.03102117f, 0.04048239f, 0.10167109f, -0.00750426f, 
    0.19373810f, -0.01311683f, 0.04730274f, -0.03802378f, 0.02207349f, -0.06602782f, 0.12718670f, 0.07456604f, 
    -0.01642835f, 0.21611221f, -0.01886018f, -0.08784866f, -0.20949343f, 0.03203212f, -0.00420091f, -0.01384586f, 
    0.29489243f, 0.03583817f, 0.05385026f, -0.01720118f, -0.06083343f, 0.04476894f, -0.16097713f, 0.08187057f, 
    0.04816620f, -0.02348398f, 0.00071939f, 0.00054145f, -0.03793184f, -0.02035495f, 0.01175662f, -0.00049529f, 
    -0.04317917f, -0.04109713f, 0.02800927f, -0.00564750f, -0.01503533f, -0.00959442f, -0.05341424f, -0.03548920f, 
    0.00623890f, 0.04129415f, 0.00737462f, -0.03057248f, -0.05957793f, 0.01392029f, 0.01915227f, -0.00869936f, 
    -0.06470150f, 0.01161118f, -0.05621441f, -0.04764930f, -0.00711247f, -0.06658253f, -0.04581859f, 0.01980169f, 
    0.02438200f, -0.01984366f, -0.04356570f, -0.06334047f, 0.04358206f, 0.00541682f, -0.02596138f, 0.00778544f, 
    0.02626121f, -0.06328703f, -0.00782706f, 0.03372175f, 0.01181875f, 0.00130792f, 0.00465990f, -0.01291939f, 
    -0.04894123f, 0.01682434f, -0.02909707f, -0.05654446f, 0.01424030f, 0.02291687f, -0.00785335f, -0.04534987f, 
    0.04491529f, -0.04269847f, 0.04524148f, -0.04009071f, -0.05721144f, 0.03501376f, 0.05396010f, -0.04096507f, 
    0.01707963f, 0.04520059f, -0.05763881f, 0.02859142f, -0.00741153f, -0.05971050f, -0.02305981f, 0.04631330f, 
    -0.05507086f, -0.06250405f, -0.06654885f, -0.04250956f, -0.06612670f, 0.02554743f, 0.01938993f, 0.02503118f, 
    -0.05125140f, 0.04773426f, 0.02661466f, 0.03949942f, 0.01094996f, -0.01339156f, 0.02034472f, 0.03456238f, 
    0.01566024f, -0.03067554f, -0.05276559f, 0.02409679f, 0.03970796f, 0.00204851f, -0.05303362f, -0.07086810f, 
    0.04413055f, -0.03658995f, 0.00210869f, 0.04309939f, -0.02323375f, -0.00527753f, -0.03438354f, -0.06442679f, 
    -0.06044088f, -0.03484710f, 0.02108424f, 0.01439900f, 0.01526340f, 0.04528107f, 0.05607729f, 0.03130866f, 
    -0.01135213f, -0.06008568f, 0.04014229f, 0.03169313f, -0.03857782f, 0.04887336f, 0.00167203f, 0.02161360f, 
    0.00730026f, 0.03835598f, -0.04300115f, 0.03492852f, -0.02374700f, -0.00242906f, -0.01804787f, -0.04544822f, 
    0.03271532f, -0.03651831f, 0.04349051f, -0.05299353f, -0.03111020f, 0.05388329f, 0.04700815f, 0.01233207f, 
    -0.04583282f, -0.00837634f, -0.00191585f, 0.00347513f, -0.04669227f, -0.00566784f, -0.06029682f, 0.03322939f, 
    0.04153492f, -0.01599183f, 0.00086198f, -0.04782755f, -0.01708357f, 0.02736541f, -0.01540515f, -0.03258624f, 
    0.01840829f, -0.01067798f, -0.06189123f, 0.02801272f, -0.02221804f, 0.00959458f, -0.00180059f, -0.01778018f, 
    0.03470148f, 0.00151168f, -0.00440858f, -0.03203313f, 0.01519808f, -0.03681297f, -0.03832011f, -0.00118851f, 
    0.04671586f, 0.00283193f, -0.05309325f, -0.03525256f, 0.00033537f, -0.00602383f, 0.02408404f, 0.00020625f, 
    0.00320885f, 0.03951523f, -0.01693186f, 0.00362216f, 0.06067857f, -0.00512675f, 0.02083823f, -0.04717223f, 
    -0.04263899f, 0.00727744f, -0.06294139f, -0.00550472f, 0.00831937f, -0.01465437f, -0.00320573f, -0.04726906f, 
    0.03045163f, -0.04728752f, 0.01951222f, 0.05874441f, 0.04369057f, -0.04825514f, -0.02433700f, 0.00255022f, 
    0.05453195f, -0.04759787f, 0.02016384f, 0.00693371f, -0.05529007f, -0.03655070f, 0.02325245f, 0.01957131f, 
    -0.01147805f, -0.01046919f, 0.04658753f, -0.02056334f, -0.04577168f, -0.00740221f, -0.03263922f, -0.05609803f, 
    0.05642112f, -0.04914734f, -0.05615892f, 0.00542459f, -0.02363882f, 0.00303664f, 0.00636032f, -0.05841001f, 
    -0.03329385f, 0.00330110f, -0.02827046f, -0.05626196f, -0.00643235f, 0.02619320f, -0.00230655f, 0.03404972f, 
    -0.01778402f, -0.05259034f, -0.03370719f, -0.04280479f, -0.05775294f, 0.01326743f, 0.00608273f, 0.03711424f, 
    -0.05228226f, 0.04862166f, -0.01041227f, 0.00277388f, 0.04561741f, 0.04530254f, -0.00433104f, 0.00722756f, 
    -0.01324170f, -0.05073234f, -0.03483300f, -0.04951970f, -0.01085847f, 0.02979809f, -0.04583504f, 0.05168057f, 
    0.04478383f, 0.00626549f, 0.03194769f, -0.04896971f, -0.00668498f, -0.00384648f, -0.01916421f, 0.05059509f, 
    0.00474555f, 0.01208551f, -0.03315121f, -0.06684554f, -0.01634018f, -0.05644127f, 0.04908770f, -0.04450871f, 
    0.03616612f, -0.00538864f, 0.00513272f, -0.03343084f, -0.06528549f, 0.00923090f, -0.06290181f, -0.01442394f, 
    0.03070104f, 0.04964792f, 0.01939258f, 0.02929194f, -0.04138974f, 0.01826380f, -0.00874864f, -0.02681721f, 
    -0.02179086f, 0.00648046f, -0.03630581f, -0.02987495f, -0.00766995f, 0.04610913f, -0.06198407f, -0.02766616f, 
    0.00662429f, 0.04432731f, 0.03528293f, -0.00295675f, 0.04627500f, 0.04399008f, -0.04314749f, -0.02784214f, 
    0.02009450f, 0.02696843f, -0.00452522f, -0.05982008f, -0.04970317f, 0.04257575f, -0.02919277f, -0.04623148f, 
    -0.00859362f, -0.01716418f, 0.00187649f, -0.00596635f, 0.01752699f, -0.02783470f, -0.05247822f, 0.02624367f, 
    0.00588509f, 0.01146670f, 0.04058557f, -0.00770391f, -0.02116496f, -0.02912149f, 0.04793283f, -0.04611904f, 
    -0.01700231f, -0.03276321f, 0.00760981f, -0.01728700f, 0.04552547f, 0.03405159f, 0.04370652f, -0.06270337f, 
    0.01171920f, -0.03574575f, 0.04338516f, 0.00231419f, -0.01592842f, -0.04310299f, -0.04654957f, 0.00633619f, 
    -0.04010760f, 0.03951092f, -0.05628398f, -0.02880910f, 0.01151683f, 0.02246392f, -0.01793718f, -0.01463750f, 
    0.02523709f, -0.03139701f, 0.03376808f, 0.01169149f, -0.04797503f, -0.04738062f, 0.01055545f, -0.04380497f, 
    -0.02066981f, -0.02813208f, -0.04695591f, 0.02438614f, 0.03948571f, 0.02386174f, 0.03162367f, -0.03242513f, 
    -0.04738236f, -0.05152502f, 0.03557935f, -0.02990277f, -0.00020368f, 0.04722548f, -0.04197121f, 0.00661429f, 
    0.04581671f, -0.00096448f, -0.06062263f, -0.01674482f, 0.04004923f, -0.01588612f, -0.04057135f, -0.04480039f, 
    0.01182435f, -0.01528042f, -0.00184081f, -0.01166144f, -0.01347754f, -0.05976484f, -0.06197249f, 0.03641450f, 
    0.01345372f, -0.03174638f, -0.04225363f, -0.04572826f, -0.00998078f, -0.01293406f, -0.03150341f, -0.01032117f, 
    0.02342482f, 0.01747530f, -0.05711130f, 0.00532402f, -0.03693971f, -0.06482258f, -0.03798219f, 0.01643899f, 
    0.02119708f, 0.01704546f, -0.05006405f, -0.01046458f, 0.00317922f, 0.03943330f, -0.00651173f, 0.05152076f, 
    -0.05553885f, 0.04915747f, -0.00075764f, 0.03268256f, -0.03148789f, -0.00848422f, -0.06109677f, -0.05157010f, 
    -0.05714752f, -0.06281261f, -0.02133262f, 0.03222813f, -0.04192851f, -0.06477079f, -0.01242445f, -0.01067968f, 
    0.01195731f, -0.00588672f, -0.02461391f, -0.02650080f, 0.04253202f, -0.03962613f, -0.03105330f, 0.04375736f, 
    -0.02487622f, 0.04189843f, -0.05049149f, -0.01654262f, 0.04760979f, 0.03435672f, 0.04070581f, -0.03949243f, 
    -0.04554944f, 0.01709432f, -0.01821873f, -0.04138410f, 0.04547368f, -0.03402430f, -0.04123506f, -0.01788136f, 
    -0.00779024f, 0.00927784f, -0.02693153f, 0.02914173f, 0.00021240f, -0.00065689f, -0.00966980f, -0.01143361f, 
    0.01203675f, 0.02397468f, 0.02841786f, 0.01919411f, -0.04320911f, 0.04500141f, -0.01654703f, -0.01871127f, 
    -0.02212931f, -0.01362492f, 0.01385704f, -0.00379694f, -0.01070376f, -0.02916222f, -0.05881809f, 0.01382702f, 
    -0.05736321f, 0.05648383f, 0.04102884f, -0.02814350f, -0.01345749f, 0.02111333f, 0.01880982f, 0.05008663f, 
    -0.05883175f, -0.03321591f, -0.02882892f, -0.01594500f, 0.04274274f, -0.06042128f, 0.01096453f, -0.04700009f, 
    0.04131905f, 0.00242850f, -0.03139880f, -0.05157549f, -0.00027005f, -0.06079390f, -0.04966569f, -0.02342359f, 
    -0.05503323f, -0.03434729f, -0.03959140f, 0.03166861f, -0.01889511f, 0.03429706f, 0.00331140f, -0.05401977f, 
    -0.06285737f, -0.02773262f, -0.01972358f, 0.00621116f, 0.02808996f, -0.00265871f, 0.01307189f, 0.03807161f, 
    0.04810591f, -0.05640485f, 0.01089304f, -0.00245591f, -0.03488795f, 0.01908240f, -0.04709287f, -0.05781261f, 
    -0.04828682f, -0.02764087f, -0.00644811f, -0.01749333f, 0.01075390f, -0.06487451f, 0.04422847f, -0.02926528f, 
    -0.05862991f, 0.05241504f, -0.02123316f, -0.03125609f, 0.00056036f, -0.02063301f, -0.04777494f, -0.02117244f, 
    0.03318822f, 0.04312636f, -0.04947847f, -0.01612502f, -0.02762214f, 0.03272542f, 0.03296663f, -0.05566886f, 
    0.03459492f, -0.03231124f, 0.04297012f, -0.00787174f, 0.01362726f, -0.02357678f, -0.04627151f, -0.01112662f, 
    0.01960730f, -0.04817877f, 0.00737456f, -0.03752397f, -0.05302168f, -0.01457136f, 0.03295683f, -0.00689640f, 
    0.01465085f, -0.03269858f, 0.05024489f, -0.05055736f, -0.00928724f, -0.01156558f, 0.01663199f, 0.02499616f, 
    0.07036674f, 0.14530134f, 0.19696696f, -0.03163172f, -0.12013893f, 0.09545224f, -0.08810107f, 0.09089363f, 
    0.03807563f, -0.04640232f, -0.16567053f, -0.09512373f, 0.03898596f, 0.17489947f, -0.03266034f, 0.12893055f, 
    -0.15845750f, -0.01287508f, -0.04781017f, -0.22417852f, 0.04242143f, -0.06861987f, 0.13808750f, -0.03718285f, 
    -0.02814403f, 0.11967420f, 0.06198319f, -0.07943579f, 0.15121864f, 0.09585534f, -0.11460805f, -0.06664675f, 
    -0.06893634f, 0.04314373f, 0.12197730f, -0.04034832f, 0.02317012f, 0.01537658f, 0.14661774f, 0.05957379f, 
    -0.06459003f, 0.01769304f, -0.25038230f, 0.05142055f, 0.08011474f, 0.03436207f, 0.13646488f, 0.12164373f, 
    -0.19237396f, -0.00552960f, -0.07169287f, 0.18668875f, 0.09895478f, 0.05170615f, 0.04263201f, 0.05532679f, 
    0.11260016f, 0.09039247f, 0.16356777f, -0.14025207f, -0.19629230f, -0.10468651f, -0.09967973f, -0.26572302f, 
    -0.08713885f, -0.28571978f, 0.02152668f, 0.10777999f, 0.00166005f, -0.04038570f, -0.12880288f, -0.03143681f, 
    -0.06027999f, 0.12564795f, 0.31296527f, -0.07642686f, 0.01736587f, 0.02679822f, 0.06927072f, 0.12059186f, 
    0.07560427f, 0.13202433f, 0.05367606f, 0.11892489f, -0.09814075f, -0.13199633f, -0.00667652f, -0.20544483f, 
    0.11242940f, 0.06232457f, -0.01633645f, 0.04770269f, 0.04049847f, -0.21190789f, -0.14271849f, -0.01927891f, 
    0.04778877f, 0.07269914f, 0.08118248f, 0.00769023f, -0.21096329f, -0.23535176f, -0.10293702f, 0.00853135f, 
    -0.08495245f, 0.06592344f, 0.00620935f, 0.10222644f, 0.03456901f, -0.02223017f, -0.18390723f, 0.08933724f, 
    -0.04477797f, 0.09409671f, 0.10024483f, -0.09113938f, 0.00947664f, 0.12225787f, 0.04010526f, -0.02475055f, 
    -0.10194474f, 0.16447631f, 0.03053301f, 0.09044950f, 0.13178816f, -0.04296893f, 0.13133724f, 0.04710305f, 
    -0.26767385f, -0.11809257f, 0.06999742f, 0.16171089f, 0.08635975f, 0.09328885f, 0.11461984f, 0.42483419f, 
    0.14591914f, -0.25043625f, 0.20298412f, 0.19051436f, -0.00613354f, 0.12286455f, -0.05914913f, -0.16432476f, 
    -0.10357752f, 0.12611690f, 0.04109775f, 0.08470692f, -0.00009584f, -0.14151378f, -0.00492782f, 0.03095505f, 
    -0.15316367f, -0.17205250f, 0.16294183f, -0.02605763f, 0.03082160f, 0.10480041f, 0.00139380f, -0.03489982f, 
    0.15390104f, 0.03365314f, 0.16549899f, 0.04231972f, 0.05193132f, 0.17369927f, 0.11609983f, 0.07734063f, 
    -0.02250254f, 0.15292950f, 0.04642331f, -0.16298826f, 0.04373845f, -0.22546758f, -0.12163966f, -0.01179020f, 
    -0.14126544f, 0.29046541f, -0.00474826f, -0.08885179f, -0.46681675f, -0.45802629f, 0.00500700f, -0.10852468f, 
    0.04388537f, -0.03249383f, -0.18326047f, 0.23550765f, -0.09188123f, -0.09578706f, -0.00329874f, 0.04949642f, 
    0.01746988f, 0.00738215f, 0.06650426f, 0.04392598f, 0.16989915f, 0.03361360f, 0.11947310f, 0.08893139f, 
    -0.22363620f, 0.03348882f, 0.07427566f, -0.06828884f, -0.09633029f, -0.04828530f, 0.01322350f, 0.14384866f, 
    0.39506155f, -0.13136843f, -0.00802369f, -0.12523691f, 0.01307770f, 0.15856124f, -0.10627095f, -0.00464389f, 
    0.00002826f, -0.30258027f, 0.01832140f, 0.00174906f, -0.00708004f, -0.02821208f, -0.02510491f, 0.10048487f, 
    0.05161371f, -0.03933343f, -0.03179925f, 0.22398680f, -0.07990097f, -0.06056754f, -0.10696451f, -0.02429840f, 
    0.01191031f, -0.01170666f, -0.05713065f, 0.17844640f, 0.08614825f, -0.04351061f, -0.10046889f, -0.14794262f, 
    -0.02450000f, 0.01349572f, 0.09740891f, 0.08811899f, 0.05528001f, 0.10003472f, -0.07971756f, -0.01291149f, 
    -0.04709703f, 0.06686873f, -0.10380624f, 0.11343009f, 0.10944867f, 0.02611731f, -0.17999965f, 0.10710096f, 
    0.06053440f, 0.01436745f, -0.05016554f, -0.01770923f, -0.18203434f, -0.16221866f, -0.07299268f, -0.09379780f, 
    0.11872216f, 0.01307499f, -0.04962752f, -0.11998970f, 0.13537045f, 0.04233854f, -0.30797872f, -0.15475655f, 
    -0.07701890f, 0.07697804f, 0.09878841f, 0.12215307f, -0.11032545f, 0.05670818f, 0.05355895f, -0.41486141f, 
    -0.14980215f, -0.10292803f, 0.00571841f, 0.26009345f, -0.04555674f, 0.01507105f, -0.01632535f, -0.06574731f, 
    -0.20239098f, -0.22224712f, 0.00165077f, 0.16222373f, -0.02434671f, 0.05544734f, -0.09251171f, 0.12092873f, 
    0.02434922f, 0.07396246f, 0.06579818f, 0.10037511f, -0.03078567f, -0.00963324f, -0.11199319f, -0.00124986f, 
    -0.06370398f, -0.06236201f, -0.00164314f, 0.06417810f, -0.10331152f, 0.03183370f, 0.10108174f, -0.04140354f, 
    0.03010301f, 0.14181107f, -0.11665137f, -0.08573683f, -0.02497505f, -0.03157076f, 0.13317172f, -0.02590102f, 
    -0.01974507f, 0.08708737f, 0.09874398f, -0.12661199f, 0.08428545f, -0.27646822f, -0.03374706f, 0.16437550f, 
    -0.04221398f, -0.00129747f, 0.00131080f, -0.04857058f, 0.16932710f, -0.18882065f, 0.01146960f, 0.20313747f, 
    -0.00689238f, 0.03280405f, 0.06394042f, 0.04211555f, 0.06056587f, 0.23299330f, 0.22817223f, 0.27441072f, 
    0.19358726f, -0.05376970f, 0.00143764f, 0.12463796f, -0.01225924f, 0.04230847f, 0.06153946f, 0.08597064f, 
    0.21706901f, -0.13938031f, -0.12559891f, 0.06715269f, -0.21068838f, 0.03468635f, 0.06980782f, -0.01342706f, 
    0.21228169f, 0.06354811f, 0.18918319f, 0.05802492f, 0.01929031f, 0.19477808f, -0.09876737f, -0.10135641f, 
    0.03519710f, -0.12377758f, 0.06117421f, 0.00606145f, 0.06581396f, 0.04562001f, -0.02064288f, 0.14012583f, 
    0.08898003f, -0.01069296f, -0.21212822f, -0.02530953f, 0.08372004f, -0.01826868f, -0.02100482f, 0.04512603f, 
    -0.06149672f, -0.00255971f, 0.13647255f, -0.19941661f, 0.01292605f, -0.17217226f, 0.09962378f, 0.02200082f, 
    0.14005642f, -0.06119609f, 0.20227744f, -0.10385856f, 0.13225974f, 0.01902370f, 0.01757192f, -0.23461615f, 
    -0.09025712f, 0.15421243f, 0.07514997f, 0.05066177f, 0.02669733f, -0.05296399f, -0.17405654f, 0.01313450f, 
    0.10449400f, 0.01721880f, 0.00077529f, -0.00306051f, -0.13075249f, -0.03237522f, -0.07019710f, -0.06815761f, 
    -0.04727129f, 0.18058437f, -0.12331280f, -0.14758611f, -0.00007508f, -0.03164877f, -0.02189963f, 0.10862159f, 
    0.11567512f, -0.01831000f, 0.10355969f, 0.08818831f, 0.12314217f, 0.15193139f, 0.08876373f, 0.15786162f, 
    0.23075187f, 0.17041624f, 0.14008178f, -0.01342406f, 0.11225641f, 0.10897198f, 0.06909476f, 0.05783444f, 
    -0.09517524f, 0.13622451f, 0.05102479f, 0.17312761f, 0.02777715f, -0.02505403f, 0.02868174f, -0.05366062f, 
    0.01133558f, 0.17764610f, 0.14622186f, -0.03218089f, 0.14428720f, 0.19777772f, 0.17126882f, 0.08014873f, 
    -0.00853154f, 0.00322416f, -0.05622993f, -0.20018594f, -0.12011216f, 0.10102528f, 0.06008683f, 0.00602894f, 
    -0.05004104f, 0.04253943f, -0.07419602f, -0.01271832f, 0.10448832f, 0.09715077f, 0.16889538f, 0.00019611f, 
    0.05632409f, 0.05275977f, 0.04121120f, 0.05486254f, -0.20782132f, -0.00456809f, -0.29988191f, -0.21341354f, 
    -0.02305463f, -0.00541155f, 0.03207789f, 0.07490796f, -0.15077490f, 0.01604027f, 0.09337348f, 0.20355107f, 
    0.15691286f, 0.04017347f, 0.01775580f, -0.01584223f, 0.02756530f, -0.03674071f, -0.03297881f, 0.08553123f, 
    0.12720008f, 0.19238926f, 0.11123310f, 0.18286374f, -0.06538803f, 0.10668468f, 0.00727445f, -0.05921509f, 
    -0.24500619f, -0.21232952f, -0.16508058f, 0.14668402f, 0.04610281f, -0.05898687f, -0.00873374f, -0.01732451f, 
    -0.05142051f, -0.01557456f, 0.19993831f, -0.16686006f, -0.03862491f, -0.01901275f, -0.06609827f, -0.10896156f, 
    -0.05268646f, 0.07004678f, -0.05012398f, 0.11092759f, 0.19454446f, -0.00786536f, 0.00334179f, 0.18809168f, 
    0.07314560f, 0.10717339f, 0.00942985f, -0.22076409f, -0.28968358f, -0.01912334f, 0.09463140f, -0.10332350f, 
    -0.15479392f, -0.04689930f, 0.00278035f, -0.17826626f, -0.06107393f, -0.00099237f, -0.17937204f, 0.04102171f, 
    -0.07034130f, -0.13965264f, -0.03145009f, -0.04885197f, 0.14399593f, 0.02238620f, 0.02699901f, 0.06958402f, 
    -0.06237479f, 0.04056757f, 0.11512432f, -0.00189115f, -0.01612003f, 0.15758193f, 0.04226488f, 0.16984653f, 
    -0.03686085f, -0.02146536f, 0.06087016f, 0.10249092f, -0.11018180f, -0.00840086f, 0.05501737f, 0.04135462f, 
    0.14173852f, 0.05413610f, -0.03929277f, 0.06575152f, -0.05369545f, 0.19447252f, 0.17668650f, -0.22020149f, 
    0.14897986f, 0.24627332f, 0.02600111f, -0.07124224f, -0.11981353f, -0.08751685f, -0.00848102f, 0.22505540f, 
    0.13455723f, -0.08966470f, -0.15244569f, -0.04831968f, 0.00909821f, -0.06346700f, -0.11555408f, -0.07354301f, 
    0.07504670f, -0.03610926f, -0.04636582f, 0.05808036f, -0.02497194f, 0.00477836f, 0.07723834f, 0.03653613f, 
    0.06117333f, 0.13358098f, -0.00160843f, 0.16758814f, 0.17918947f, -0.08139519f, -0.10682318f, 0.03049056f, 
    0.00265685f, 0.07082875f, 0.02318063f, 0.07101839f, 0.06552415f, 0.08686509f, 0.02223601f, 0.09475385f, 
    -0.18243200f, 0.07165579f, 0.12326515f, 0.11508621f, 0.12580952f, 0.02188042f, -0.03751901f, 0.11000299f, 
    0.01036560f, -0.05819139f, 0.12366042f, -0.07639577f, -0.09042867f, -0.04988975f, -0.20617779f, -0.28393322f, 
    0.16088657f, 0.05284411f, 0.03109837f, -0.05297707f, 0.10380153f, -0.11878683f, -0.06491220f, -0.18867940f, 
    0.08180299f, -0.01222695f, -0.03688576f, -0.01140317f, 0.05406826f, -0.02073498f, 0.10130563f, -0.04075874f, 
    -0.16772275f, -0.03974248f, 0.12464465f, 0.10939238f, 0.02740702f, 0.06890345f, -0.05954948f, -0.07846407f, 
    0.07143626f, 0.02289263f, -0.07053421f, -0.02042892f, 0.01161978f, -0.04352669f, -0.03548057f, 0.18990846f, 
    -0.02581347f, 0.07947862f, 0.12334513f, 0.03116797f, 0.16961521f, 0.04129352f, 0.02186195f, 0.13668261f, 
    0.07710377f, 0.07199347f, 0.00505985f, 0.22803910f, 0.02245410f, 0.10894033f, -0.06134886f, -0.00583425f, 
    0.04729407f, 0.05724462f, 0.03237959f, 0.05058212f, -0.17606109f, -0.11191063f, -0.13956141f, 0.08551129f, 
    0.13083464f, 0.01111764f, -0.00004293f, 0.04710698f, -0.02878221f, 0.07626809f, -0.16631983f, -0.14766926f, 
    -0.13365598f, -0.07172586f, -0.00060318f, -0.03372549f, 0.22455445f, 0.01285781f, 0.28352937f, -0.20914200f, 
    -0.14682160f, -0.11720298f, -0.22953485f, -0.28477886f, -0.03824725f, 0.07813978f, -0.01775291f, -0.27240777f, 
    -0.34834489f, -0.06552112f, -0.08274870f, -0.10828110f, -0.01284362f, 0.04266579f, -0.03927651f, 0.02715619f, 
    -0.14025599f, 0.07529138f, -0.32746544f, 0.14183216f, -0.06085108f, 0.04270394f, -0.06647483f, 0.04692408f, 
    -0.01551535f, -0.19718213f, -0.17382340f, 0.06895567f, 0.11261551f, 0.07094355f, 0.01966333f, 0.02168570f, 
    0.10648581f, 0.08913425f, 0.10148682f, 0.16401288f, 0.10143496f, 0.09946521f, -0.00178307f, -0.07238205f, 
    0.13809492f, 0.02215343f, 0.12451428f, 0.27285364f, -0.00009736f, 0.16766492f, -0.15473510f, -0.12686783f, 
    -0.11891070f, 0.14264551f, 0.07592211f, -0.01759362f, -0.36198089f, 0.03289817f, -0.32342747f, -0.02717633f, 
    -0.04871632f, 0.12151888f, 0.05202219f, -0.05847765f, -0.05611349f, -0.02437322f, 0.09142426f, 0.08082180f, 
    0.15768579f, -0.23710002f, 0.16920267f, -0.03496043f, 0.13177483f, 0.06991214f, -0.47165096f, 0.03333244f, 
    0.00789573f, -0.06274611f, 0.07718460f, -0.07974638f, 0.15597668f, 0.05502729f, -0.14464147f, 0.06647453f, 
    0.10702505f, 0.00931848f, -0.10079011f, 0.06659978f, -0.04018813f, 0.03955962f, 0.04442316f, -0.02956153f, 
    -0.21114384f, 0.01367959f, -0.04554859f, -0.14029813f, -0.20124045f, -0.06732631f, -0.03065916f, -0.11538530f, 
    0.04651178f, -0.08605714f, 0.11672387f, 0.01854861f, -0.04630072f, -0.16560031f, -0.07770815f, 0.07112171f, 
    -0.14031824f, 0.01047095f, -0.00765174f, -0.00753771f, -0.03190792f, 0.12289134f, 0.05584040f, 0.15772608f, 
    0.08816849f, 0.01822781f, 0.03057690f, -0.05828205f, 0.00079244f, 0.07944531f, -0.12153094f, -0.14804554f, 
    0.20666422f, -0.06641916f, 0.03317786f, -0.03312197f, -0.13279630f, -0.12275744f, -0.15421239f, 0.08131462f, 
    -0.03445143f, -0.06585833f, -0.07956620f, -0.14697790f, 0.04926225f, -0.10786872f, -0.11912403f, -0.02923824f, 
    0.06208881f, -0.07856842f, -0.00593610f, 0.00121892f, 0.18041265f, -0.09843818f, -0.01710354f, 0.23089574f, 
    -0.19488131f, 0.13518955f, -0.23854658f, -0.10200235f, -0.07401812f, -0.02437142f, 0.06674837f, -0.21150832f, 
    -0.13967161f, 0.15239133f, 0.08464098f, 0.01427187f, 0.09011726f, 0.10800082f, 0.02625529f, 0.09315348f, 
    -0.10635023f, 0.01955029f, -0.03797014f, 0.10749864f, -0.01972688f, 0.03372841f, -0.00343346f, 0.00880545f, 
    -0.11180174f, -0.06306966f, -0.02612215f, -0.09336656f, 0.07426705f, 0.00662177f, 0.06116699f, 0.06356306f, 
    0.01859551f, -0.03764406f, 0.07062554f, -0.13849843f, 0.15091187f, 0.10187413f, -0.09576715f, -0.03370262f, 
    0.06705522f, -0.01798576f, -0.00851814f, 0.00632619f, -0.12744781f, -0.03516032f, 0.07277407f, 0.10675432f, 
    0.07241771f, 0.04956567f, -0.08685186f, -0.01987178f, -0.00494920f, 0.14951783f, 0.04320521f, 0.06623157f, 
    0.01825095f, 0.06736143f, 0.00837053f, -0.25435814f, 0.13503410f, 0.11941092f, -0.00153686f, -0.00075902f, 
    0.06283186f, -0.03351175f, 0.04719885f, -0.00822494f, 0.00331902f, 0.00163929f, 0.00538344f, -0.32047433f, 
    0.01302856f, 0.08058264f, 0.05311263f, -0.00815188f, -0.15462781f, 0.04616335f, 0.01791300f, 0.21795532f, 
    -0.06911027f, -0.04403358f, -0.07261311f, 0.13752064f, 0.01984280f, 0.01339092f, -0.00013376f, 0.02917937f, 
    -0.07448177f, -0.12091364f, 0.02147318f, 0.08715208f, 0.17253223f, -0.16037874f, -0.00105387f, -0.13402340f, 
    -0.00632560f, 0.17847261f, 0.05203152f, 0.09136359f, -0.10554239f, -0.09561133f, -0.00634512f, 0.01329478f, 
    0.08653011f, 0.03186216f, -0.04014814f, -0.04146473f, -0.06554735f, -0.03205348f, -0.06964330f, 0.05141241f, 
    0.05437876f, 0.00410755f, -0.04136261f, 0.29285067f, 0.02381868f, -0.02358330f, -0.00232626f, -0.14437589f, 
    -0.05760558f, -0.06404385f, 0.11291966f, 0.02304248f, 0.12633313f, -0.26600319f, 0.18306229f, 0.01217574f, 
    0.04751297f, -0.06864297f, 0.08500788f, 0.07716589f, 0.00879062f, -0.31783012f, -0.07664986f, 0.00273818f, 
    0.05802597f, 0.20175472f, 0.06683744f, -0.01384369f, -0.15468225f, -0.11209068f, -0.08845353f, -0.04849820f, 
    -0.06445750f, 0.04047664f, 0.08079774f, 0.09291671f, -0.13666867f, 0.03242708f, 0.05398929f, 0.11504542f, 
    0.04461043f, 0.20457385f, -0.09529001f, -0.04988012f, 0.03642076f, -0.12307592f, 0.18390112f, 0.09347096f, 
    -0.02120074f, -0.17856897f, -0.08937126f, -0.08778305f, 0.12118766f, 0.03574360f, 0.05050045f, 0.07771080f, 
    0.05964991f, 0.29936180f, 0.05442400f, 0.00667887f, -0.00620547f, -0.07530224f, 0.08386503f, -0.11682092f, 
    0.06612934f, 0.11020655f, -0.19089143f, -0.02532697f, 0.11013455f, 0.02088834f, 0.07717933f, 0.00580692f, 
    -0.00254583f, -0.12586291f, 0.02547701f, -0.09436097f, -0.00090972f, -0.05568017f, 0.17900325f, -0.00572339f, 
    0.09767626f, -0.00082882f, -0.06939318f, 0.07010967f, 0.05512334f, 0.04465405f, -0.18732880f, 0.01377618f, 
    0.13093400f, 0.10062791f, -0.02700537f, 0.09905516f, 0.01896260f, 0.11264863f, 0.20224503f, 0.05858657f, 
    0.03229459f, -0.22384112f, -0.07375687f, 0.04063242f, 0.09863812f, -0.11749319f, 0.11588714f, -0.04839865f, 
    -0.04814515f, -0.13497803f, -0.06654578f, 0.07102472f, -0.13495965f, 0.04987313f, 0.03376365f, -0.12486871f, 
    0.12125929f, 0.02679652f, -0.20078106f, -0.02078791f, 0.10798214f, -0.11459171f, 0.13283119f, 0.08198503f, 
    0.17408742f, 0.10432521f, 0.28209725f, -0.00218295f, 0.03721824f, 0.05883400f, 0.02262035f, 0.11342704f, 
    -0.02319684f, 0.45982191f, 0.03607127f, -0.03930733f, 0.12254912f, -0.08805173f, 0.01088864f, 0.14401168f, 
    0.08704287f, 0.05191815f, 0.09978794f, 0.07653667f, 0.01656629f, 0.04765486f, 0.03900107f, 0.00009332f, 
    0.09523862f, -0.01174560f, 0.01618360f, 0.23981933f, 0.17332391f, -0.12265536f, 0.19322018f, -0.13039453f, 
    0.07970782f, -0.01809374f, 0.13926183f, -0.17806263f, 0.30044562f, 0.08774430f, 0.20974855f, -0.07407743f, 
    -0.12864377f, 0.00004391f, 0.09139021f, -0.04229909f, -0.04976290f, 0.15161619f, -0.06114566f, -0.14536746f, 
    -0.17859016f, -0.08780509f, -0.12090149f, 0.04127024f, 0.08011650f, 0.04982384f, 0.36593688f, 0.02327401f, 
    -0.05375581f, 0.00937129f, -0.07474321f, 0.01788417f, -0.02657401f, 0.07596581f, 0.04746561f, 0.26789397f, 
    -0.23206343f, -0.01413188f, 0.04447002f, -0.07697544f, -0.00448443f, 0.08519430f, -0.07635018f, -0.09205741f, 
    0.04029614f, -0.55647719f, -0.08693640f, 0.12268356f, -0.02921381f, 0.02252437f, 0.15267341f, 0.09726152f, 
    -0.40870827f, 0.14312029f, 0.05942003f, -0.09316829f, 0.19940160f, 0.03610060f, -0.02627055f, 0.03051621f, 
    -0.20047154f, 0.01468076f, 0.17577894f, -0.19064772f, -0.02819471f, 0.17793402f, 0.28846908f, 0.08311150f, 
    -0.05574231f, 0.04850166f, -0.02639676f, 0.26135284f, -0.28880838f, -0.12589881f, 0.06885652f, -0.06813924f, 
    0.10234161f, 0.17334670f, 0.23081547f, -0.07564725f, 0.05261615f, -0.14227985f, -0.08417646f, -0.07917897f, 
    0.03690698f, -0.05042668f, 0.02613668f, 0.07053189f, -0.21233532f, 0.13971439f, 0.04437177f, 0.08736048f, 
    -0.03997643f, 0.13228320f, 0.10171665f, 0.10847847f, 0.01075544f, 0.10729376f, -0.23560734f, -0.07365131f, 
    0.06673596f, -0.00694076f, -0.09805936f, -0.15106267f, -0.06962168f, 0.25446516f, 0.19535750f, 0.03357522f, 
    0.17251390f, -0.02724965f, 0.09603391f, -0.09953275f, -0.20602807f, 0.16560888f, -0.02622074f, 0.05488595f, 
    -0.01223495f, -0.23390372f, -0.11744551f, -0.09052819f, -0.00506973f, 0.11107964f, 0.13466780f, 0.06978706f, 
    0.04231067f, 0.25753748f, 0.19634393f, -0.10196052f, -0.07805797f, 0.19663756f, 0.04266411f, -0.00934287f, 
    0.09808291f, 0.14502484f, 0.24962842f, 0.08296866f, -0.08329237f, -0.07501690f, 0.14323366f, 0.11895538f, 
    0.20466833f, 0.10729662f, -0.07601149f, -0.19282843f, -0.14667764f, -0.05383707f, 0.11488691f, 0.09484684f, 
    0.10166216f, -0.09750126f, 0.21510249f, -0.04324640f, -0.16405569f, -0.00395394f, 0.06354733f, 0.17135306f, 
    0.15337197f, 0.13255548f, -0.15184759f, -0.24412818f, 0.12398999f, -0.05103081f, 0.05512113f, -0.17734177f, 
    0.11532403f, -0.17749675f, -0.04477441f, 0.12392816f, 0.07109259f, -0.04989056f, -0.60416234f, -0.39726388f, 
    -0.04797354f, -0.06485022f, 0.28508794f, 0.16445322f, -0.09269275f, 0.04112900f, -0.21622042f, -0.39931381f, 
    0.02355890f, 0.01441119f, 0.04138261f, 0.16192076f, 0.11138582f, -0.26085863f, -0.04726055f, 0.16663378f, 
    0.17868659f, 0.22329816f, 0.03692988f, -0.26662779f, -0.16706936f, 0.00550236f, -0.07764520f, 0.10295043f, 
    0.26207376f, -0.02898396f, -0.13549669f, -0.08798387f, -0.09458224f, 0.06481571f, 0.10674816f, 0.19053446f, 
    0.11644405f, -0.02322921f, 0.09181780f, 0.00579027f, -0.03678894f, 0.10059488f, 0.00636201f, 0.18276168f, 
    -0.18054019f, -0.03382678f, 0.07153630f, -0.38316590f, -0.14216472f, 0.08154760f, 0.11020090f, 0.04896609f, 
    0.01718582f, -0.04991517f, 0.23428552f, 0.00197072f, 0.12851511f, 0.24584827f, -0.18877476f, -0.25855806f, 
    -0.02780214f, -0.02964010f, -0.09055959f, 0.02163005f, 0.14733635f, 0.16355278f, -0.28698069f, -0.06048037f, 
    0.23580800f, 0.04073336f, -0.15024567f, -0.05665589f, -0.14805245f, 0.01939321f, 0.21090500f, 0.17140956f, 
    0.00014981f, -0.14846687f, -0.01159368f, 0.03862343f, -0.05059335f, -0.16619924f, -0.09268109f, -0.35532516f, 
    0.09087740f, -0.00295020f, -0.02613597f, -0.11408789f, 0.00380752f, -0.15601622f, -0.04816314f, 0.26828131f, 
    0.33604482f, 0.16694282f, 0.19550224f, -0.04839009f, 0.14277627f, -0.16569279f, 0.07172278f, 0.00722502f, 
    0.10669798f, 0.35738298f, -0.06149012f, -0.03092481f, 0.26439753f, 0.04001184f, 0.16333979f, 0.05255844f, 
    0.25266880f, -0.04211621f, 0.44225127f, 0.05401349f, -0.04820136f, 0.01607034f, -0.22338873f, -0.07044224f, 
    0.19826750f, 0.18186729f, 0.15510283f, 0.35753226f, 0.03984876f, -0.15721044f, 0.01415897f, -0.03981576f, 
    -0.19949305f, 0.16142242f, 0.09541579f, 0.00607007f, -0.26657382f, 0.13943328f, -0.11456416f, 0.06920058f, 
    0.19993608f, -0.23312421f, 0.03990392f, -0.16663164f, -0.25323734f, -0.07865640f, -0.11819353f, 0.13817371f, 
    -0.22216234f, 0.08229624f, 0.13434817f, 0.01118904f, -0.09190010f, 0.05085341f, -0.36233485f, 0.08982621f, 
    -0.07504991f, 0.03727740f, -0.20899940f, -0.09165438f, 0.06596397f, 0.11254913f, 0.01310397f, -0.05142494f, 
    -0.00873364f, -0.14954822f, -0.01749916f, 0.09403756f, 0.04334027f, 0.01769735f, 0.08429959f, -0.03770710f, 
    0.01398937f, -0.04109380f, -0.04684097f, 0.04276194f, -0.04230629f, 0.02545296f, -0.05310243f, 0.01681685f, 
    -0.01659780f, -0.01806921f, 0.00242536f, -0.03337606f, -0.06165463f, 0.04183514f, -0.01048726f, 0.00064076f, 
    -0.01109129f, -0.06874911f, 0.04257863f, 0.04936422f, 0.04203594f, -0.04646304f, 0.00251580f, -0.04882492f, 
    -0.05949369f, -0.01624052f, -0.03429843f, 0.02212762f, -0.04090316f, 0.02485210f, 0.04373082f, -0.02093644f, 
    0.01923734f, -0.03628580f, -0.02985450f, 0.01506513f, -0.03119458f, 0.01719282f, -0.00222224f, -0.05901794f, 
    0.03306200f, 0.02866416f, -0.02892241f, -0.01196370f, -0.03019904f, -0.04488740f, -0.02281808f, 0.02708657f, 
    0.05395969f, 0.04110919f, 0.02870036f, 0.04641738f, -0.06496453f, -0.01165273f, -0.06058602f, -0.05794714f, 
    -0.01323054f, -0.05282782f, -0.03699502f, -0.01505456f, -0.00542694f, 0.03882677f, 0.02965608f, -0.04563287f, 
    -0.04792102f, -0.01245630f, 0.00696130f, 0.02047572f, -0.05227430f, -0.02280109f, -0.06413979f, -0.05486602f, 
    0.01579312f, 0.03523668f, -0.03115563f, -0.06616964f, -0.04966476f, 0.01506758f, -0.05378452f, -0.03479093f, 
    0.01298299f, 0.00978305f, -0.02927298f, 0.04310068f, 0.05113048f, -0.03822303f, -0.03897350f, -0.04055478f, 
    0.02756036f, 0.04300257f, -0.02592770f, 0.03249035f, 0.02795091f, -0.01191071f, 0.04340286f, 0.01703869f, 
    -0.04902331f, -0.02479046f, -0.01843089f, -0.06064394f, -0.05829811f, -0.05646228f, -0.00205538f, -0.00611390f, 
    0.03447487f, 0.02981975f, -0.00349968f, -0.00978745f, 0.01541588f, -0.05761376f, 0.03699895f, 0.00225695f, 
    0.00380221f, -0.02692826f, 0.01560949f, 0.00579584f, -0.03719319f, -0.03053516f, 0.02943223f, -0.00991966f, 
    0.04697303f, -0.03416093f, -0.03872188f, -0.02233044f, -0.04495287f, 0.01402729f, -0.00859017f, 0.02762737f, 
    -0.00830984f, -0.03947534f, -0.00872282f, 0.01092593f, 0.02706117f, -0.00971402f, -0.01860858f, -0.00293978f, 
    -0.02126224f, 0.04962185f, -0.00521282f, -0.01316752f, 0.04632233f, -0.03141845f, -0.03488183f, 0.01582785f, 
    -0.06292042f, -0.04298604f, 0.03658079f, -0.00684025f, 0.01887664f, 0.00880920f, -0.04310748f, 0.01790355f, 
    -0.02423461f, 0.01008689f, 0.03888906f, 0.01858470f, 0.00828382f, -0.03539604f, -0.05206130f, -0.06508251f, 
    0.04105969f, 0.01572715f, 0.01993850f, 0.02846478f, 0.01819201f, -0.00492673f, -0.01126301f, 0.01249778f, 
    -0.00375149f, 0.04922963f, -0.02005914f, 0.00964424f, 0.00290986f, -0.01779939f, 0.01733429f, -0.01749329f, 
    0.00220352f, -0.02644047f, -0.01720963f, -0.02306558f, 0.03035924f, -0.00439091f, -0.03227994f, 0.01583903f, 
    0.03287486f, -0.01325308f, 0.01547104f, -0.02243037f, -0.05516254f, 0.00916115f, -0.03459606f, -0.01889316f, 
    -0.05884772f, -0.00618475f, -0.04219587f, 0.03706182f, 0.02821949f, 0.00160393f, -0.03225468f, -0.06007708f, 
    -0.05153199f, 0.02512285f, 0.01470582f, 0.00291875f, -0.00557193f, -0.05909156f, 0.02711846f, 0.00305200f, 
    -0.02740360f, -0.05326731f, -0.03924022f, -0.01791589f, 0.04159358f, 0.05564362f, -0.04667738f, 0.03467266f, 
    -0.02501852f, -0.03671513f, 0.04908085f, -0.01796460f, -0.03797397f, 0.00994694f, -0.01202692f, -0.00079223f, 
    -0.05322274f, 0.00953020f, -0.04746488f, -0.06579732f, 0.03274247f, 0.02334787f, -0.01866739f, -0.04030712f, 
    0.02381955f, -0.03807748f, 0.00722304f, -0.05273649f, 0.04432246f, -0.00516754f, 0.05275147f, -0.01138042f, 
    -0.06584344f, 0.02636570f, 0.04779289f, 0.00627219f, -0.05822730f, 0.05542123f, -0.04378996f, 0.02334273f, 
    0.01886607f, 0.02156971f, -0.05508755f, -0.01309889f, 0.05125351f, 0.04079730f, -0.00269004f, 0.01238389f, 
    -0.05258031f, -0.02267146f, 0.02001825f, 0.03868788f, 0.01210760f, -0.05776971f, -0.04453451f, 0.00801360f, 
    0.04737567f, 0.04746127f, -0.06196719f, 0.04314419f, -0.05980054f, 0.03483048f, 0.03732042f, -0.01996961f, 
    0.01455254f, 0.01529469f, 0.01455546f, -0.05244418f, 0.02549912f, -0.02757536f, -0.03984914f, -0.03727346f, 
    -0.01184530f, 0.01544564f, 0.01094062f, -0.02904289f, 0.01957057f, -0.01953113f, 0.02178123f, 0.02940003f, 
    -0.05837483f, -0.01292600f, 0.02297297f, 0.00122948f, -0.00230847f, -0.01035619f, 0.04486529f, -0.06514908f, 
    -0.04677360f, 0.00609147f, -0.05705284f, -0.03230423f, 0.03334706f, -0.01261967f, 0.03153965f, -0.04433953f, 
    -0.03195596f, 0.03401829f, -0.02447180f, -0.05926756f, -0.02441711f, -0.04780253f, -0.00796683f, -0.02848390f, 
    -0.00053155f, -0.04554351f, 0.01782669f, 0.00369354f, -0.01408652f, -0.03472244f, -0.03913828f, -0.01539552f, 
    -0.01472327f, -0.00536754f, -0.03158424f, -0.03658160f, -0.06687412f, -0.02366385f, 0.01166209f, 0.02860047f, 
    -0.01026219f, 0.05002136f, 0.04037157f, -0.01795187f, 0.00332003f, -0.00616556f, -0.04229014f, 0.00927198f, 
    0.01811965f, 0.04886971f, -0.01809131f, 0.00539244f, -0.04195687f, -0.05810661f, -0.03147303f, -0.04009920f, 
    -0.03182040f, -0.01337798f, -0.04842119f, -0.02605130f, -0.02215150f, -0.04005225f, 0.03490095f, -0.05779850f, 
    0.00912314f, 0.02776534f, -0.04041261f, 0.00796224f, -0.03321972f, -0.06525820f, 0.04295313f, 0.00402075f, 
    -0.00379354f, -0.03407160f, -0.00353964f, 0.00921156f, 0.02077923f, -0.02409834f, -0.00676593f, -0.03488624f, 
    -0.04722630f, 0.02214824f, 0.04067259f, -0.01147288f, 0.00735350f, 0.00307833f, -0.01365300f, -0.02408497f, 
    -0.00549323f, 0.02753439f, 0.04895701f, -0.05743820f, -0.01868891f, -0.04009192f, 0.03685274f, 0.02618474f, 
    0.01874916f, -0.04978776f, -0.01913737f, -0.01901430f, -0.04993509f, 0.01111025f, -0.05831591f, -0.00683004f, 
    0.00610637f, 0.03324709f, 0.04434981f, -0.02465451f, -0.00368672f, -0.04250286f, -0.00758820f, -0.04390310f, 
    0.02785010f, 0.01461956f, 0.00300066f, -0.06260819f, 0.04024646f, 0.01260869f, -0.01554751f, 0.04223575f, 
    0.00068346f, 0.01629641f, 0.04831036f, -0.02541493f, -0.00301008f, -0.01253595f, 0.00373674f, -0.04459676f, 
    -0.01821790f, 0.01165781f, -0.02839772f, 0.01754208f, 0.01535732f, 0.03943505f, 0.00027942f, 0.04836185f, 
    0.00104952f, -0.03918563f, 0.00985214f, -0.01925650f, -0.02502934f, 0.01210654f, 0.03638437f, 0.01389652f, 
    -0.01067054f, -0.01406595f, -0.04677318f, 0.04473203f, 0.00586080f, -0.03962216f, 0.04521817f, 0.02460267f, 
    -0.03443801f, 0.04428550f, -0.05061202f, 0.00013142f, -0.04955922f, -0.03640983f, -0.01997557f, -0.05864426f, 
    0.00555997f, 0.01500414f, 0.02402966f, 0.03318879f, -0.06056562f, -0.00249188f, 0.01576925f, 0.02671586f, 
    -0.02209203f, -0.01398632f, -0.04034799f, 0.04190082f, 0.02150682f, -0.00934717f, 0.02206486f, -0.00282447f, 
    -0.01806877f, -0.05693875f, -0.05433084f, 0.02108418f, 0.01584573f, 0.00388920f, -0.00961141f, 0.02116627f, 
    0.00244787f, 0.03938756f, 0.04171724f, -0.01969037f, -0.06774247f, -0.02964829f, -0.00339344f, -0.00800366f, 
    -0.00888591f, -0.00871844f, -0.02325469f, 0.03887947f, -0.03619137f, -0.02884711f, 0.02748593f, -0.04055567f, 
    -0.01020720f, -0.04141789f, 0.05286911f, -0.03975967f, -0.01629933f, -0.06276339f, -0.00291507f, 0.03955943f, 
    0.02936337f, -0.02255885f, -0.02464535f, -0.03125421f, -0.00601410f, 0.01846473f, 0.04119524f, 0.03352113f, 
    -0.05642292f, 0.02832673f, -0.04577595f, 0.01167989f, -0.06057105f, 0.00408578f, 0.03328244f, -0.05302924f, 
    0.00204692f, -0.00763906f, -0.04797057f, -0.04070786f, 0.01086419f, 0.02788486f, -0.05506081f, -0.06690569f, 
    -0.03611027f, -0.00995478f, -0.03137666f, 0.04640423f, -0.01942280f, -0.01820471f, 0.03430505f, 0.02141571f, 
    0.01289878f, -0.00269620f, -0.02468150f, 0.00238709f, 0.04228685f, 0.03328305f, -0.03857730f, 0.00025754f, 
    0.04808354f, 0.04736562f, 0.02810049f, -0.00160700f, 0.03857794f, -0.00663136f, -0.02824792f, 0.01576036f, 
    -0.01233605f, 0.00644003f, -0.05771560f, -0.05432745f, 0.01761268f, 0.04324707f, 0.03295939f, 0.02655455f, 
    -0.06116012f, 0.02440400f, 0.02876003f, -0.03451446f, 0.01652673f, -0.01120492f, 0.00184900f, 0.01399125f, 
    -0.00259077f, 0.04639304f, 0.01260895f, -0.01932681f, -0.04812813f, -0.04285453f, 0.01081004f, 0.00075921f, 
    0.00119389f, 0.01124071f, -0.03420289f, 0.00213203f, -0.05508690f, -0.02037571f, 0.05231398f, -0.00184863f, 
    -0.01338054f, 0.17096272f, 0.00840293f, -0.02982385f, 0.09430303f, -0.09719766f, 0.10416325f, -0.03091328f, 
    -0.10150515f, -0.36252567f, -0.07556137f, -0.07282206f, -0.10524072f, 0.05576950f, 0.07378594f, -0.11210203f, 
    -0.25362813f, -0.05115181f, 0.03305418f, -0.11368093f, -0.14349940f, 0.03005666f, 0.05143413f, 0.09210453f, 
    -0.07414868f, -0.06481318f, 0.01619423f, 0.10013924f, 0.01350033f, -0.09058432f, 0.07878660f, -0.04878232f, 
    0.00641760f, 0.04504493f, 0.01785318f, 0.16953839f, -0.03431274f, 0.32186186f, 0.14453857f, 0.03978116f, 
    -0.03708908f, -0.06141501f, 0.15563795f, 0.03400943f, -0.06345186f, -0.15529451f, -0.16163853f, -0.11165005f, 
    0.10208867f, -0.00617056f, 0.06097160f, -0.03111360f, -0.02575296f, -0.09437171f, 0.06134747f, 0.07084953f, 
    -0.04877426f, 0.00844617f, -0.10065272f, 0.09924991f, 0.09130405f, -0.03218974f, -0.00675315f, 0.06061070f, 
    0.21488747f, 0.11485051f, 0.17241150f, -0.00775136f, 0.06060426f, -0.01351947f, -0.02475975f, 0.09323727f, 
    -0.39531890f, -0.03476730f, -0.24231528f, 0.09701303f, 0.01326152f, -0.04870982f, 0.12892622f, -0.07007275f, 
    -0.08841275f, -0.06701659f, -0.14614411f, -0.09125163f, 0.13138022f, -0.07336107f, -0.06102800f, 0.00909191f, 
    0.04432693f, -0.06595357f, -0.04628583f, -0.02060178f, -0.03594405f, 0.14079449f, 0.01749471f, 0.05421040f, 
    0.08287855f, -0.02387635f, -0.04952466f, -0.02380641f, 0.10307298f, -0.13207859f, 0.07993685f, -0.10267083f, 
    -0.04854796f, 0.04001010f, 0.01803146f, -0.02568262f, 0.22757578f, 0.01654896f, -0.02130681f, -0.17483228f, 
    0.00901848f, 0.02820046f, -0.09025838f, -0.17706250f, 0.21880671f, -0.16746329f, -0.02883139f, -0.04691071f, 
    -0.05443793f, 0.08002349f, 0.04483509f, 0.26406011f, 0.01229883f, 0.11904645f, -0.12505150f, -0.22015543f, 
    -0.19291863f, -0.29334456f, 0.05370707f, 0.00467253f, -0.13612068f, -0.04903790f, 0.18530525f, 0.04840846f, 
    -0.04557861f, 0.01307097f, -0.27440369f, 0.09950057f, -0.07501066f, -0.02415716f, -0.07599233f, 0.11737640f, 
    -0.09082604f, 0.21694623f, 0.18757690f, 0.03093870f, 0.15908884f, -0.21045905f, -0.07436333f, -0.00868608f, 
    -0.02893206f, -0.20738356f, -0.11477800f, -0.08684286f, -0.09097313f, 0.05354038f, 0.09240039f, 0.03818792f, 
    -0.02771785f, -0.14069240f, -0.04053172f, -0.18762058f, 0.00930399f, -0.06260969f, -0.01185065f, -0.02858278f, 
    0.02755737f, -0.10770854f, -0.05065335f, -0.06572555f, 0.13970305f, 0.00288407f, 0.13880007f, -0.06309675f, 
    -0.06334756f, 0.05771441f, 0.04862655f, 0.01060311f, 0.07768729f, -0.03684318f, 0.16877377f, -0.02190349f, 
    0.14796662f, -0.02327182f, 0.02863666f, 0.09445675f, -0.07309275f, 0.06739208f, -0.09151050f, -0.08808631f, 
    0.05972518f, -0.05041754f, 0.01632676f, 0.12687936f, -0.04678425f, -0.13865834f, 0.05661149f, -0.06588300f, 
    0.15780744f, -0.06633318f, 0.28985503f, -0.01147056f, 0.02871968f, -0.09923144f, 0.08142889f, 0.13938437f, 
    0.07192012f, 0.26149747f, 0.06721146f, 0.10616666f, -0.19224185f, -0.03639642f, -0.10460026f, 0.07240629f, 
    -0.16781861f, 0.04955792f, -0.09229238f, 0.18584339f, 0.10422458f, -0.03255130f, 0.10920236f, 0.04666717f, 
    -0.11033297f, 0.07208860f, 0.00414353f, -0.00779617f, 0.13891456f, -0.05108688f, -0.01881903f, -0.06741183f, 
    0.09618881f, -0.07333113f, -0.08055513f, -0.17092150f, -0.35870227f, 0.10678825f, 0.12860303f, 0.08499338f, 
    -0.03612382f, -0.01877130f, 0.08183317f, 0.20352037f, 0.08228964f, -0.09622505f, -0.01747388f, 0.07471405f, 
    0.09046189f, 0.04197221f, 0.01813742f, -0.03812930f, 0.13276610f, 0.22646178f, -0.03474624f, -0.22203211f, 
    0.05975090f, 0.06444321f, 0.11051732f, 0.08098115f, -0.00335787f, -0.21714467f, -0.26862174f, 0.09975734f, 
    0.01252127f, -0.10375694f, -0.02777077f, 0.05026515f, -0.10883002f, 0.01962665f, 0.01414275f, 0.16336296f, 
    0.14712575f, 0.00203980f, -0.05697993f, 0.20523511f, 0.09618186f, -0.02625167f, 0.14731914f, 0.17972454f, 
    -0.00560538f, -0.04507498f, 0.07003804f, 0.00978806f, 0.09237453f, 0.03673970f, 0.09442570f, -0.11903103f, 
    -0.39048636f, -0.59939849f, -0.20482583f, 0.07176313f, 0.06450272f, -0.00425689f, -0.09357684f, 0.17341498f, 
    -0.06823523f, 0.09314692f, 0.10846917f, 0.07943864f, -0.14912984f, 0.10865121f, 0.02905774f, 0.18186846f, 
    0.08348687f, -0.08386388f, -0.03373604f, 0.08008274f, -0.12760460f, -0.16128451f, -0.06949980f, 0.07239109f, 
    -0.04144767f, 0.12843639f, 0.25360003f, -0.64201891f, -0.41299295f, -0.06347693f, 0.08970926f, 0.03788800f, 
    0.03515105f, 0.06260439f, 0.00526545f, -0.02912324f, -0.04470912f, 0.02001577f, -0.02590282f, 0.24829662f, 
    0.14058439f, 0.02656624f, 0.00865567f, 0.03708014f, 0.08378297f, -0.14466527f, -0.34003109f, -0.01340859f, 
    0.17623886f, 0.10255925f, 0.04032107f, -0.08522123f, -0.08741596f, -0.03132846f, -0.10691099f, 0.00179887f, 
    -0.03384002f, -0.27358195f, 0.07218955f, 0.02685423f, 0.03130976f, -0.00718660f, 0.02417629f, -0.14565778f, 
    -0.04885406f, 0.05499887f, -0.13058548f, 0.00501530f, -0.03962328f, 0.09867148f, 0.03237866f, 0.07466585f, 
    -0.07536846f, -0.21723561f, -0.08358853f, 0.11481131f, 0.05228930f, -0.04538694f, -0.03692851f, -0.04831671f, 
    0.05410458f, -0.09922355f, -0.31498575f, -0.09814634f, -0.09128556f, 0.02709742f, 0.01883787f, 0.14784600f, 
    -0.05042448f, 0.02872266f, -0.28160936f, -0.21482576f, 0.06118432f, 0.10226244f, 0.10587212f, -0.01706698f, 
    0.06599863f, -0.12039253f, -0.17618974f, -0.01809961f, 0.06844956f, -0.07713541f, 0.00482615f, 0.00923749f, 
    -0.09372729f, 0.07092776f, 0.15767574f, -0.11902383f, 0.01078431f, 0.27842337f, -0.11006886f, -0.11249849f, 
    -0.02087653f, 0.05589288f, 0.13154306f, 0.14242791f, 0.10094305f, -0.38555086f, -0.52489102f, -0.09691222f, 
    0.11763038f, 0.07485119f, -0.01585404f, 0.11543920f, 0.11496788f, -0.00322902f, -0.07045440f, 0.11490948f, 
    -0.07697153f, -0.04688590f, 0.00009942f, 0.02213307f, 0.07245456f, 0.01157871f, -0.01649752f, 0.18781833f, 
    0.09612739f, 0.12961614f, 0.15875047f, 0.21341494f, -0.13477270f, 0.06279643f, 0.06632081f, -0.06531341f, 
    -0.03226513f, -0.03533165f, -0.00196501f, 0.14005664f, 0.06326959f, 0.06842317f, -0.00282925f, 0.02902394f, 
    0.05304858f, 0.11919052f, 0.29505762f, 0.04630164f, 0.20904049f, -0.03586164f, 0.13390732f, 0.09362340f, 
    0.05817908f, 0.02542488f, -0.10997157f, 0.08020088f, 0.13040224f, 0.17919165f, 0.05591992f, 0.03971946f, 
    0.03977682f, -0.10022206f, -0.02392928f, 0.02724968f, -0.01244417f, -0.13661397f, 0.03559158f, -0.01337496f, 
    -0.08778772f, -0.01803428f, 0.04148774f, -0.00977653f, 0.00456094f, 0.16869135f, -0.06662326f, -0.07968330f, 
    -0.03691802f, -0.09125255f, 0.01203124f, 0.02038730f, 0.12097643f, 0.32100296f, 0.24759856f, -0.02018228f, 
    -0.00017614f, 0.05505693f, -0.00942153f, -0.15108006f, 0.11975668f, 0.02169035f, -0.01051204f, 0.02776125f, 
    -0.00538618f, -0.13193403f, -0.14339544f, 0.04895043f, 0.08723593f, 0.01961008f, 0.18687563f, 0.12446679f, 
    0.20030294f, -0.01348587f, 0.04299991f, -0.08762029f, -0.04027861f, -0.05143128f, 0.15826494f, -0.02933340f, 
    -0.45468941f, -0.19261588f, -0.06753809f, -0.03926434f, 0.03159774f, -0.02456149f, 0.01529004f, 0.01570806f, 
    0.07159847f, -0.00025475f, -0.10638934f, -0.05237086f, 0.11619502f, 0.06118839f, -0.00888821f, -0.11877536f, 
    -0.06766301f, -0.20234646f, -0.18290949f, -0.07800988f, 0.05029970f, 0.22444396f, 0.10448275f, 0.03970535f, 
    -0.13270915f, -0.08982977f, 0.01966652f, 0.13771054f, 0.02917469f, 0.08981749f, 0.25215790f, -0.01354962f, 
    -0.01139930f, -0.05698344f, 0.09166268f, 0.07228708f, 0.16572602f, -0.10279625f, -0.04684797f, 0.01590703f, 
    -0.04350312f, -0.11247238f, -0.05945365f, 0.31334010f, 0.00432800f, 0.22902332f, 0.02779504f, -0.04978935f, 
    0.02123295f, -0.16138810f, 0.10792071f, -0.07628481f, -0.06826463f, 0.01114374f, 0.10881852f, -0.00888256f, 
    -0.00135054f, -0.06545353f, -0.14841083f, 0.03409072f, 0.19710457f, 0.00690661f, -0.03320001f, 0.03390970f, 
    0.21570939f, -0.01748615f, -0.08288831f, -0.03619510f, -0.02058453f, -0.11599016f, -0.00243705f, 0.08768294f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.02859977f, 0.06313955f, -0.04932920f, 0.03188791f, 0.07412824f, -0.04528865f, 0.14467430f, -0.00333820f, 
    0.08533176f, 0.03146408f, 0.03952803f, 0.01880285f, 0.07201581f, 0.13018849f, 0.00962483f, 0.02942258f, 
    0.13877246f, -0.06230729f, 0.06357327f, -0.06099524f, -0.05066871f, -0.02859199f, 0.02404872f, 0.08063050f, 
    0.04210640f, 0.13477474f, -0.00755637f, 0.16008304f, -0.05829506f, 0.02600910f, 0.03611512f, 0.13043652f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.11277889f, 0.02783931f, 0.00612988f, 0.16567549f, 0.02737630f, -0.16179454f, -0.06607843f, -0.05448414f, 
    0.39426959f, -0.09286024f, -0.08809313f, -0.16808057f, 0.14595161f, 0.28008753f, 0.12255620f, -0.22821546f, 
    0.02815318f, -0.09982308f, -0.55241072f, 0.07579556f, -0.26148158f, 0.07507988f, 0.06853105f, -0.34770495f, 
    -0.02015556f, -0.23096827f, 0.36270595f, 0.25045094f, -0.00287026f, 0.16775692f, -0.04734581f, 0.29370126f, 
    -0.15619577f, 0.03686472f, 0.07220098f, -0.07233562f, -0.03551262f, -0.07834918f, -0.14980486f, -0.03968690f, 
    0.00438304f, 0.14770859f, 0.16695146f, -0.10639697f, 0.10251342f, -0.09011292f, 0.11125646f, -0.12445170f, 
    0.00120798f, -0.00514988f, 0.02304390f, 0.13244417f, -0.13775858f, 0.04665479f, -0.03362714f, -0.08555107f, 
    0.08662378f, -0.00821390f, -0.21193916f, -0.00766151f, 0.05065486f, 0.09546214f, -0.07851431f, 0.07037333f, 
    0.02694643f, 0.33914948f, -0.20688482f, -0.06152728f, -0.24302870f, 0.12117783f, -0.21407062f, 0.04081799f, 
    0.01565791f, -0.13841833f, -0.14829096f, 0.15744688f, -0.03884619f, 0.11559535f, -0.24111097f, -0.20395416f, 
    -0.04718517f, 0.11690120f, 0.22926964f, -0.00091770f, 0.43354815f, 0.10586677f, 0.02714518f, 0.31152776f, 
    0.34379023f, 0.25824142f, -0.14152551f, -0.07624645f, -0.16261128f, -0.07187403f, -0.09379432f, 0.36169127f, 
    -0.15872894f, -0.16902417f, -0.26221278f, 0.03750263f, 0.31521460f, 0.10557719f, 0.09599946f, -0.02292727f, 
    -0.15630932f, -0.00867339f, -0.15324274f, -0.06479186f, -0.71697694f, 0.04951360f, 0.02314100f, 0.29678985f, 
    0.24269788f, 0.11643360f, 0.07820626f, 0.14863040f, 0.41993093f, 0.17545034f, -0.05557100f, -0.14702021f, 
    0.44549227f, 0.04779617f, -0.07999610f, -0.21336065f, -0.13123809f, 0.04835638f, 0.30319428f, 0.29698324f, 
    -0.02867697f, -0.62546128f, 0.19593488f, 0.09601501f, 0.03220838f, 0.09933031f, 0.15941684f, 0.29822835f, 
    0.16445245f, 0.09514257f, -0.08978564f, 0.07695062f, 0.36413267f, -0.13078468f, 0.27191621f, 0.15747535f, 
    -0.30112329f, 0.01762148f, 0.26895469f, 0.11910340f, -0.40850633f, -0.02345535f, 0.15848826f, 0.05471924f, 
    -0.08305293f, -0.02061099f, 0.19153221f, 0.11459970f, -0.09577359f, -0.09409136f, 0.29613295f, 0.04074799f, 
    -0.05693869f, 0.21102689f, -0.18551458f, 0.02571758f, -0.07031191f, -0.10322589f, 0.06675778f, -0.04493840f, 
    -0.13843194f, -0.16026813f, 0.07168201f, 0.05495776f, 0.10949066f, 0.01365202f, -0.17209432f, 0.04344237f, 
    -0.32147956f, 0.11284799f, 0.24867515f, 0.02726402f, -0.13444896f, 0.02073762f, 0.01169470f, -0.20861378f, 
    0.17538036f, -0.13796242f, -0.01152163f, -0.07829050f, -0.07536354f, 0.16144238f, 0.08499111f, 0.28703710f, 
    0.16304247f, 0.32218742f, 0.02546093f, 0.10380345f, 0.10740175f, -0.11722721f, -0.01881314f, -0.05882523f, 
    -0.33675620f, -0.01602086f, -0.07545961f, -0.10879435f, -0.51683712f, 0.21339239f, 0.38733158f, -0.08123235f, 
    0.32419017f, -0.07460536f, 0.12783483f, 0.04893100f, 0.33076471f, 0.06874635f, -0.02637948f, 0.21173471f, 
    0.13697067f, 0.27916121f, -0.14476170f, 0.00661254f, -0.15394752f, -0.05796072f, -0.09282633f, -0.23350574f, 
    -0.00051720f, -0.38041803f, -0.18413581f, -0.04555932f, 0.05326564f, 0.14009503f, 0.10268629f, -0.24235778f, 
    0.05993067f, 0.05704070f, 0.05468968f, 0.44081777f, 0.47796106f, -0.11019135f, -0.05412322f, 0.29773936f, 
    -0.26784563f, 0.04541162f, 0.08327191f, 0.11495692f, 0.12353750f, 0.05634109f, 0.00283723f, 0.03248813f, 
    0.19002092f, -0.06416553f, -0.09002765f, 0.13101612f, 0.15849483f, -0.13349861f, -0.28265253f, 0.39069217f, 
    -0.05906536f, -0.53549123f, 0.04192215f, -0.06939971f, 0.09408061f, 0.12454228f, 0.05220404f, -0.01050895f, 
    0.16795823f, -0.06641377f, -0.02215947f, 0.03339500f, 0.12995292f, -0.29778239f, 0.45233670f, -0.03580913f, 
    -0.26112810f, -0.09378566f, 0.04712394f, 0.07446122f, -0.15710130f, 0.16177015f, -0.02926679f, -0.19881664f, 
    0.15757231f, -0.07577043f, 0.26352969f, 0.27106199f, -0.06584241f, 0.14078096f, -0.15076795f, 0.09831167f, 
    0.13798074f, -0.10456101f, 0.18588609f, 0.18001445f, 0.40021768f, -0.06470662f, -0.15637149f, 0.23415513f, 
    0.06047323f, 0.12653504f, -0.05292255f, 0.25545159f, 0.17955187f, -0.25444275f, 0.26328224f, 0.02069685f, 
    -0.39397940f, -0.09841187f, 0.61443478f, -0.16156372f, 0.34947515f, 0.09606533f, -0.05620204f, 0.40314773f, 
    -0.06163967f, 0.39975858f, -0.10725105f, 0.10503799f, 0.14001995f, 0.14966978f, 0.03343374f, -0.26712653f, 
    0.14700916f, 0.30411306f, 0.01103504f, -0.15326303f, -0.22889011f, -0.02282863f, -0.11793683f, 0.33002192f, 
    0.11605211f, -0.15931563f, -0.10827558f, -0.15865768f, 0.66660589f, -0.05661013f, -0.10443601f, 0.10295576f, 
    -0.43869478f, 0.06406244f, 0.38835478f, -0.08590453f, -0.23041818f, 0.10341804f, 0.03095760f, -0.15464798f, 
    -0.13239780f, 0.12027030f, 0.34206536f, -0.04528317f, 0.14277810f, 0.00395890f, 0.51764101f, -0.02901351f, 
    -0.06399541f, 0.04641606f, -0.07327054f, 0.04401661f, -0.33025306f, -0.09205937f, 0.17946379f, 0.41593000f, 
    0.04565589f, -0.06150353f, 0.05388445f, 0.14306080f, 0.79069185f, 0.13525128f, -0.16422312f, 0.23851748f, 
    -0.04393737f, -0.03482920f, -0.40533170f, -0.11775137f, -0.29363021f, 0.14039019f, -0.11803090f, -0.03636122f, 
    -0.07018779f, -0.17031769f, 0.11628363f, 0.03724127f, -0.13251628f, 0.11035341f, 0.07200556f, 0.17043130f, 
    0.06873584f, -0.01239517f, -0.03296061f, -0.00407484f, -0.08097862f, -0.17028435f, 0.12466180f, 0.12761229f, 
    -0.12369462f, 0.01812272f, 0.14924692f, 0.01337486f, -0.11404998f, -0.10291785f, -0.04659672f, -0.20666462f, 
    0.09410009f, 0.11671545f, 0.01115790f, -0.05434455f, -0.10852864f, 0.17089312f, 0.15614887f, -0.22853723f, 
    -0.06510764f, -0.01127356f, -0.11708668f, 0.01662137f, 0.15624677f, 0.13929597f, -0.07298523f, -0.09739861f, 
    0.00423381f, -0.19895747f, -0.25550860f, -0.06460068f, -0.28558415f, -0.14919636f, 0.21832938f, 0.25552028f, 
    0.03610123f, -0.13206583f, -0.10176746f, 0.10356173f, 0.23423317f, 0.03393533f, 0.01450718f, 0.07933839f, 
    0.45860952f, 0.13183682f, 0.02757017f, 0.10569721f, 0.05317461f, 0.15285397f, 0.12193936f, 0.35900125f, 
    -0.01304266f, 0.08788421f, 0.02813227f, 0.21961768f, 0.12958142f, 0.04713583f, -0.34137854f, -0.31448072f, 
    -0.14097323f, -0.06331028f, 0.08846975f, 0.15534508f, -0.03315963f, 0.15384884f, -0.03294744f, 0.09864737f, 
    -0.00471118f, -0.06498847f, -0.08143894f, 0.03659039f, -0.04056770f, -0.12474820f, 0.06830013f, -0.08554571f, 
    0.04727052f, 0.16668329f, 0.02916502f, 0.09450053f, -0.17361660f, 0.08970135f, -0.14856753f, -0.06421907f, 
    0.05752446f, -0.01484849f, -0.09387422f, -0.12656781f, 0.14568500f, -0.02747899f, -0.10852742f, -0.15723288f, 
    0.14842014f, -0.23985140f, 0.39520568f, 0.11497133f, 0.45054910f, 0.10800247f, 0.02480547f, -0.04499958f, 
    -0.31062752f, -0.17071636f, 0.15249662f, -0.36391208f, -0.04954456f, -0.03387887f, 0.32538739f, -0.00766956f, 
    0.01357572f, 0.14434941f, 0.32460895f, 0.00560015f, 0.02944067f, -0.10373416f, 0.05917926f, -0.00971609f, 
    -0.22559550f, 0.45133966f, 0.09810003f, 0.19856293f, 0.12589145f, -0.02524993f, 0.36866292f, 0.12832104f, 
    0.00099843f, 0.14329951f, 0.29926923f, 0.08998732f, 0.55245578f, -0.11592441f, -0.10527050f, -0.34675035f, 
    -0.10456692f, -0.11439173f, 0.15575379f, -0.04582370f, 0.03869049f, 0.25226787f, -0.10701289f, -0.24587637f, 
    -0.19502273f, 0.04159380f, 0.06804273f, -0.06950029f, -0.04050681f, 0.07125233f, -0.08058353f, -0.18921992f, 
    0.13683079f, 0.00804334f, 0.20354211f, 0.05035041f, 0.01126716f, -0.14298224f, 0.26665184f, 0.27928209f, 
    -0.17123917f, 0.03256677f, -0.23276719f, 0.05951567f, -0.18457085f, -0.06997035f, 0.34718013f, 0.01860165f, 
    -0.00635786f, 0.05948421f, -0.11156212f, 0.40300998f, 0.52567345f, -0.06296361f, -0.09081180f, -0.03505142f, 
    0.40770468f, -0.05231955f, -0.37195224f, 0.14310321f, 0.02325846f, 0.01464072f, 0.10664687f, -0.16100337f, 
    0.11158951f, -0.28624839f, 0.08366716f, 0.20509070f, 0.09869687f, 0.05525296f, -0.26135349f, 0.00630852f, 
    0.03006927f, 0.19790928f, 0.18193169f, 0.12730514f, -0.37631696f, 0.17367209f, 0.40987307f, 0.38343033f, 
    0.24938598f, 0.04928437f, -0.03814852f, 0.29107541f, 0.81926465f, 0.19003260f, 0.19810520f, -0.12825021f, 
    0.05471401f, -0.12761773f, -0.43907315f, -0.11377602f, -0.33116010f, -0.03010282f, -0.12163728f, -0.09164207f, 
    -0.05018104f, -0.15012006f, 0.01759129f, 0.35194519f, -0.08330849f, 0.09945717f, -0.09493725f, -0.18918109f, 
    -0.08601176f, 0.39567471f, -0.32631245f, -0.02802204f, 0.50465024f, -0.13507366f, -0.06074125f, -0.00534015f, 
    -0.38923305f, -0.11847114f, -0.19068313f, 0.20796502f, 0.10537413f, 0.03338761f, -0.19883946f, 0.04793557f, 
    -0.17156854f, -0.00174659f, 0.04551408f, -0.09568181f, 0.11168782f, 0.13698560f, -0.10079280f, 0.02216359f, 
    0.22771294f, 0.23636746f, 0.03786944f, 0.17014197f, -0.07614433f, -0.12956028f, 0.37240306f, 0.25697398f, 
    0.08947138f, 0.80698925f, 0.14229304f, -0.12703672f, -0.28825918f, -0.05849240f, 0.05567596f, 0.39190209f, 
    -0.18842882f, -0.06759436f, -0.09353991f, -0.11366923f, 0.15746130f, 0.33039612f, 0.13554034f, -0.02728135f, 
    0.17659931f, 0.07655577f, 0.29843804f, 0.05006176f, 0.10021939f, -0.07132609f, 0.06490414f, 0.23352610f, 
    0.01772637f, 0.27198738f, -0.21782100f, 0.13077810f, -0.16246575f, 0.05901778f, 0.01891069f, -0.35560173f, 
    0.06334974f, 0.03497892f, -0.40346345f, -0.05817077f, -0.07886003f, 0.05082681f, 0.30418095f, 0.30110562f, 
    -0.14787371f, -0.06197841f, 0.16553038f, 0.47305477f, 0.01464182f, -0.19055901f, -0.29249093f, 0.17748010f, 
    0.02893212f, -0.15731187f, -0.10349084f, -0.08264893f, 0.20238778f, 0.05375388f, -0.05996872f, 0.14084981f, 
    0.32034901f, -0.18207438f, -0.02102420f, -0.14897497f, 0.06007471f, -0.13452449f, -0.19588535f, 0.31680340f, 
    -0.03846243f, 0.49981675f, 0.24768473f, 0.01693089f, -0.36723685f, -0.12767522f, 0.06568486f, 0.21500087f, 
    0.36786848f, 0.11609112f, 0.14413844f, -0.29596382f, -0.04826444f, 0.35033956f, -0.09459732f, -0.32166067f, 
    0.46138567f, -0.08978458f, -0.26782015f, 0.05822294f, -0.18184985f, -0.02212241f, -0.05082520f, 0.00083928f, 
    0.06544103f, 0.00352258f, 0.26285374f, 0.20760952f, -0.12736608f, -0.00691620f, -0.15882410f, -0.24667835f, 
    -0.07231565f, -0.15424132f, 0.20272686f, 0.12882303f, 0.48063171f, 0.11325406f, -0.05345845f, -0.04736807f, 
    0.11208323f, -0.00095639f, 0.10919078f, 0.25857520f, -0.09640229f, -0.02876737f, 0.29017782f, -0.31337851f, 
    0.31607154f, 0.05664214f, -0.29380816f, 0.14799988f, 0.17902927f, 0.02749089f, 0.15401515f, 0.00574523f, 
    0.35884425f, -0.25077802f, -0.10055012f, 0.39143819f, 0.01919491f, -0.01720010f, -0.45754984f, -0.24336889f, 
    0.04703742f, -0.49349430f, 0.41775012f, -0.16504277f, 0.15996839f, -0.00879848f, 0.02119165f, -0.11300085f, 
    0.07108764f, 0.09862664f, -0.13404012f, -0.37902415f, -0.61519808f, 0.13568035f, 0.51853848f, 0.12283255f, 
    0.11313018f, -0.01391760f, 0.50680238f, 0.06985795f, -0.09743463f, 0.06961047f, 0.04316242f, 0.36700517f, 
    0.04553472f, 0.29473647f, 0.10796566f, 0.10508079f, 0.03659996f, 0.08084513f, -0.03211541f, -0.18551205f, 
    0.09860121f, 0.67651927f, -0.02195928f, 0.04723818f, 0.03880372f, -0.04269126f, 0.02610832f, -0.16575666f, 
    0.09551395f, -0.07227473f, -0.13006994f, -0.15390481f, 0.21283971f, 0.18052220f, -0.37348825f, 0.02213681f, 
    -0.11714710f, 0.09332601f, 0.02721008f, 0.17187332f, 0.19754672f, -0.14543884f, 0.10532919f, -0.30358934f, 
    0.19282781f, -0.17272565f, 0.19598208f, 0.26188782f, 0.09794111f, 0.15087588f, 0.16775708f, 0.09029319f, 
    0.00742182f, -0.04289201f, 0.25590396f, 0.10537459f, 0.36346972f, -0.12810588f, 0.02739506f, -0.09416026f, 
    -0.13007365f, 0.00199503f, -0.01986846f, -0.41239658f, 0.41824293f, 0.27036402f, 0.04507467f, 0.20134820f, 
    -0.35267439f, -0.00255233f, 0.11650384f, -0.09372548f, -0.15569359f, 0.13039441f, -0.14135848f, 0.00012725f, 
    -0.25258639f, 0.05910355f, 0.19202982f, 0.32447714f, 0.14527494f, 0.01430900f, 0.48801672f, 0.06142450f, 
    0.03340737f, -0.44130710f, -0.30981845f, -0.04690451f, 0.16570199f, -0.14703853f, 0.28465819f, -0.10181408f, 
    0.23965174f, -0.16563919f, -0.16441020f, 0.22455117f, 0.35136324f, -0.13911839f, -0.26825622f, 0.45068672f, 
    -0.03409440f, -0.10116050f, -0.05562181f, -0.08378991f, 0.08557179f, 0.15275076f, 0.06793166f, 0.05516798f, 
    0.01264176f, -0.35272944f, 0.12649143f, 0.08378700f, -0.01466557f, -0.04922770f, -0.06309048f, 0.07522064f, 
    0.07072236f, -0.05759060f, -0.10229723f, 0.01363778f, -0.44774389f, -0.12698187f, 0.22462526f, 0.35691494f, 
    0.33864877f, -0.09470519f, -0.11823878f, 0.23782897f, -0.37544253f, -0.09603909f, 0.34789813f, 0.01845528f, 
    0.34644061f, 0.16342598f, -0.30838957f, 0.14905843f, 0.23874006f, -0.17240134f, 0.05083468f, 0.33085421f, 
    0.29815593f, -0.30579919f, 0.01096357f, 0.00947232f, -0.11497773f, -0.02340407f, -0.46245354f, -0.11772409f, 
    -0.17001066f, 0.13331188f, -0.02076224f, 0.06272373f, -0.21098195f, 0.14602645f, 0.01174195f, -0.31515107f, 
    0.47694692f, 0.15446243f, -0.00693276f, -0.15652223f, 0.21996805f, 0.18493214f, -0.04319614f, 0.09354883f, 
    -0.21251163f, -0.13676997f, -0.03146311f, -0.01566479f, -0.07735078f, -0.12602276f, -0.02350568f, -0.19520426f, 
    -0.11893812f, 0.02888726f, 0.38955966f, -0.03094549f, -0.04105559f, 0.08209858f, 0.04055370f, 0.44001749f, 
    0.14747404f, -0.42070735f, 0.25834277f, -0.08382663f, 0.58354318f, -0.07062396f, -0.11386073f, 0.30441710f, 
    -0.45946833f, -0.00900017f, -0.06950471f, 0.07724065f, -0.13852741f, 0.01316224f, -0.01594683f, 0.28122863f, 
    -0.25871858f, 0.16661225f, -0.09898683f, 0.09969435f, 0.28424644f, 0.04215677f, -0.03118918f, 0.00314374f, 
    0.18833272f, 0.22551371f, -0.10438813f, 0.10603346f, 0.09279987f, 0.02454548f, 0.38720658f, -0.05011645f, 
    0.11108482f, 0.23333095f, 0.03733106f, 0.16683379f, -0.20833734f, 0.04237839f, -0.06589332f, -0.43265262f, 
    0.55311292f, 0.04699706f, -0.03644676f, -0.17425130f, -0.27137223f, 0.31030151f, 0.20286541f, -0.21585959f, 
    -0.17767406f, 0.11107025f, -0.24865167f, 0.06160470f, -0.03218413f, -0.11013509f, 0.16027755f, 0.23147766f, 
    0.20980921f, 0.32118756f, -0.00590097f, 0.12575489f, 0.02418035f, -0.12907165f, -0.29037553f, 0.34723499f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11670371f, -0.18458010f, 0.10675071f, 0.19014651f, -0.01696350f, -0.03772067f, 0.06359435f, 0.23363696f, 
    -0.09018975f, 0.00515588f, 0.25269169f, -0.02578420f, -0.04227510f, 0.28900075f, 0.03616666f, -0.01616960f, 
    -0.02641991f, 0.11640190f, 0.26891997f, 0.27685037f, 0.10792585f, 0.18264225f, 0.25942957f, -0.03218291f, 
    0.13132900f, -0.11147279f, 0.09724598f, 0.13185117f, 0.23434336f, 0.13017568f, -0.02216442f, 0.32015333f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.07887781f, -0.04242578f, 0.12089322f, -0.09738301f, -0.28513595f, -0.54644608f, 0.29524246f, -0.22644319f, 
    -0.51226097f, 0.17985621f, -0.00265022f, 0.16087547f, 0.07501006f, 0.32357681f, -0.14291462f, -0.13127786f, 
    -0.23578222f, 0.10991760f, 0.24653064f, -0.02035267f, 0.46046096f, 0.03018709f, 0.51572531f, 0.27042335f, 
    0.12074225f, 0.17136870f, 0.09654630f, -0.35743356f, 0.34861574f, -0.33937356f, -0.01287365f, -0.00342962f, 
    0.13722464f, 0.05072695f, 0.38767725f, 0.02967538f, -0.14417520f, 0.01993424f, 0.20755480f, -0.02206058f, 
    -0.39971790f, -0.44477573f, -0.19714530f, -0.24138096f, -0.03176185f, 0.31414503f, -0.14136308f, -0.23563749f, 
    0.00476424f, -0.13258480f, -0.02587543f, 0.07129946f, 0.09419248f, 0.12736277f, 0.46462783f, -0.06370296f, 
    0.13880251f, 0.13564704f, -0.16145529f, -0.16771133f, 0.33413070f, 0.37129584f, -0.32603303f, 0.49283981f, 
    0.52676845f, 0.14795822f, -0.06383648f, -0.19986601f, 0.10454732f, 0.07349810f, -0.37367713f, 0.16146128f, 
    0.18287255f, -0.04130643f, 0.36296043f, 0.50209779f, 0.12840073f, -0.05721462f, -0.02495653f, -0.33478257f, 
    -0.01227336f, 0.23725218f, 0.22781433f, -0.09943676f, -0.10383154f, 0.04896384f, 0.25282511f, -0.06205611f, 
    -0.17517534f, 0.07186271f, -0.00558720f, 0.28269213f, 0.00102778f, 0.59545302f, -0.54453343f, 0.20061438f, 
    0.22009571f, 0.10868856f, 0.21687476f, 0.00944858f, -0.14592373f, 0.44606820f, 0.30784369f, -0.14522895f, 
    -0.62114209f, 0.17081387f, 0.44211286f, -0.00372236f, -0.11364572f, -0.07000507f, 0.12635218f, 0.19516490f, 
    0.45530903f, -0.25708190f, 0.06078456f, 0.18552253f, 0.33132049f, -0.16130427f, 0.12059091f, -0.15609299f, 
    0.03377165f, 0.04782300f, 0.04562801f, -0.70606047f, -0.17823565f, 0.17220666f, -0.09303834f, 0.33367491f, 
    0.35907197f, 0.15290233f, -0.36683735f, 0.08948509f, 0.19765161f, -0.29535836f, -0.11212703f, -0.06939914f, 
    0.26481900f, -0.43897405f, 0.04359228f, -0.08123775f, 0.01828735f, 0.27156693f, 0.14190276f, 0.21432352f, 
    -0.11765026f, 0.20010464f, 0.01690782f, -0.13272575f, -0.06468628f, -0.16482075f, 0.29600814f, 0.30844325f, 
    0.39004868f, 0.05172407f, 0.06001684f, 0.22019145f, 0.03504098f, -0.00966830f, -0.33007690f, 0.08684787f, 
    -0.36240053f, -0.16502880f, 0.11718246f, -0.17448758f, 0.26661900f, -0.26533923f, -0.13639189f, -0.17395492f, 
    -0.32946643f, 0.31184739f, 0.70264167f, 0.25188047f, -0.07196020f, 0.26352617f, -0.09469324f, -0.29211086f, 
    -0.71372676f, -0.11721630f, 0.23283273f, -0.25847843f, 0.30170929f, 0.30393139f, 0.10594049f, -0.41036293f, 
    0.01511874f, -0.12949847f, 0.13574116f, 0.06167087f, 0.40503952f, 0.15940851f, -0.24653266f, -0.08313560f, 
    0.75950319f, -0.08440103f, -0.17428115f, -0.16083285f, 0.04348172f, 0.10068159f, -0.36855322f, 0.04289796f, 
    0.00425101f, -0.46092492f, 0.42102909f, 0.31927851f, 0.08190417f, -0.07374014f, 0.10527743f, 0.21020643f, 
    0.25922361f, 0.22532180f, 0.07841381f, -0.00367174f, 0.08894717f, -0.32241228f, 0.23368666f, -0.04786509f, 
    0.10403462f, 0.14690900f, 0.39636463f, 0.07268557f, -0.05215050f, 0.41606149f, -0.24820203f, 0.24344429f, 
    0.44206637f, -0.05234107f, -0.17104612f, -0.05125741f, 0.06412920f, -0.05272795f, 0.06260598f, 0.23176970f, 
    0.18733299f, -0.31947121f, -0.65594804f, 0.17402801f, 0.01159565f, 0.34133461f, 0.17007472f, -0.21913144f, 
    -0.25948447f, 0.57303846f, 0.34877974f, -0.24691543f, 0.14266510f, 0.22163948f, 0.08555916f, 0.51508147f, 
    0.08257767f, -0.17793645f, -0.24389741f, 0.34702986f, 0.56161088f, -0.09243616f, -0.36145905f, 0.31506160f, 
    0.51963186f, -0.04495423f, -0.19904442f, 0.10855785f, 0.16972573f, 0.54023653f, -0.40440574f, 0.37906080f, 
    0.22063050f, -0.25207624f, 0.70233816f, 0.12847634f, 0.11678664f, -0.25940129f, 0.01477266f, -0.06342789f, 
    0.41829771f, 0.10037955f, 0.04983517f, 0.32457444f, -0.07130674f, -0.09400496f, -0.23937933f, -0.25933936f, 
    -0.09827864f, 0.47667292f, 0.27059737f, 0.32332805f, -0.23344457f, 0.71117365f, -0.11455518f, 0.19649063f, 
    -0.23444018f, -0.04881674f, 0.31258070f, 0.27699265f, -0.22729266f, -0.07509361f, 0.54157192f, -0.18425423f, 
    0.08275066f, 0.25247672f, -0.57976860f, -0.45496765f, 0.07146614f, -0.09675819f, -0.11714132f, 0.12686808f, 
    0.18262966f, -0.17065588f, -0.07108971f, 0.17944475f, 0.17579891f, -0.01030916f, 0.22026731f, 0.26711074f, 
    0.35811767f, 0.08373434f, -0.07079246f, -0.12131157f, 0.22608463f, -0.18148457f, 0.19818109f, 0.44182292f, 
    -0.35014585f, 0.12032053f, -0.40674803f, -0.14757288f, -0.11336459f, -0.00837381f, 0.26669586f, -0.21456660f, 
    -0.19345529f, -0.43377164f, 0.18544254f, -0.25358048f, 0.04720684f, 0.02651353f, 0.00226092f, 0.42463249f, 
    0.33682290f, 0.23738176f, 0.09813685f, 0.25766182f, 0.26996660f, -0.01472639f, 0.05714850f, -0.13226254f, 
    -0.03706468f, 0.27159709f, 0.19823359f, -0.16593841f, -0.18690768f, -0.06970081f, 0.16296276f, -0.11389807f, 
    -0.35066974f, 0.04234394f, 0.02119338f, -0.21084982f, 0.52697164f, -0.06817333f, -0.19667523f, 0.34000167f, 
    0.52060616f, 0.96304649f, 0.62474781f, -0.16174196f, 0.14791454f, 0.19992012f, 0.05831680f, 0.45510849f, 
    0.24093060f, -0.27749267f, -0.11727668f, 0.21896113f, 0.05555216f, -0.10013179f, -0.28138644f, 0.04907041f, 
    0.33890411f, -0.09964205f, 0.31868282f, 0.20207538f, -0.06183883f, -0.00772937f, 0.57058871f, 0.02115786f, 
    -0.14926195f, -0.13917693f, -0.17386614f, -0.16697593f, -0.04449424f, 0.09744901f, -0.11208499f, -0.04153065f, 
    -0.13749984f, 0.02210533f, -0.09681846f, -0.00888115f, 0.07980701f, -0.11935898f, 0.03949105f, 0.00019808f, 
    0.12409587f, 0.11095864f, -0.09279312f, -0.16914600f, 0.05456959f, -0.01838829f, -0.00487224f, -0.01014116f, 
    -0.05238974f, 0.02573046f, 0.16408741f, 0.10995532f, -0.10190311f, -0.02374498f, -0.09234093f, -0.16754928f, 
    -0.17963794f, 0.12159722f, 0.07958034f, -0.06160882f, 0.08536572f, 0.11763728f, -0.00243144f, 0.02840720f, 
    -0.19850160f, -0.16190834f, 0.09317060f, 0.05598140f, -0.16430695f, 0.08376519f, -0.14499858f, -0.09292918f, 
    -0.17284064f, -0.19909777f, -0.08709203f, -0.16077252f, 0.06061507f, -0.04101622f, -0.16515625f, 0.05224566f, 
    -0.06391434f, 0.06972247f, -0.20200431f, 0.10860980f, 0.05184763f, -0.05353668f, -0.05447059f, -0.17947400f, 
    -0.30875239f, -0.10184904f, 0.54158801f, 0.39491826f, 0.00162535f, 0.31805822f, 0.21817976f, 0.34565267f, 
    0.02723401f, 0.27398628f, -0.05872046f, -0.31599078f, -0.12759311f, -0.06575216f, 0.01082519f, 0.31467161f, 
    0.15575877f, -0.29170746f, -0.21594870f, 0.26663101f, -0.04642306f, 0.24767095f, -0.22905758f, -0.09425483f, 
    0.27723882f, -0.13326041f, 0.10765550f, 0.08299781f, -0.09353668f, 0.15362960f, -0.05717183f, 0.43899402f, 
    -0.40962753f, 0.13977304f, -0.15346830f, -0.17863515f, 0.23250178f, -0.19628930f, -0.13276023f, 0.32395887f, 
    -0.11942658f, 0.30464590f, 0.04444895f, 0.38413841f, 0.14828293f, 0.30175418f, 0.12265678f, -0.09816724f, 
    -0.42967460f, 0.60121274f, 0.34359944f, 0.24166103f, 0.18431388f, 0.34404963f, 0.02294111f, 0.05761191f, 
    -0.14227855f, -0.09902457f, -0.03220038f, 0.48975593f, 0.06621422f, -0.42854545f, 0.14536111f, -0.27919689f, 
    0.01236040f, 0.15748124f, 0.06997181f, -0.14777030f, 0.29094952f, -0.19518501f, -0.16942339f, 0.15963048f, 
    -0.44694337f, -0.37275779f, 0.28747299f, 0.71014851f, -0.02048972f, 0.08936334f, -0.10549819f, -0.19793370f, 
    -0.09992424f, 0.18664707f, 0.24933712f, 0.21313524f, 0.21729648f, 0.43670318f, -0.05163794f, -0.33162606f, 
    -0.13459453f, 0.00557676f, -0.01706240f, 0.20802395f, 0.12073845f, 0.18161444f, -0.02119374f, 0.14125979f, 
    -0.26186216f, 0.10342000f, 0.20867118f, 0.40734851f, -0.07605861f, 0.17049772f, 0.62770689f, 0.11671005f, 
    0.15207671f, 0.26719859f, -0.22728509f, -0.44201988f, 0.00224875f, -0.10114875f, -0.15537323f, 0.04753074f, 
    -0.07214570f, -0.19216162f, -0.08518679f, 0.14224868f, 0.31362155f, 0.14414200f, -0.06891863f, 0.14450730f, 
    0.27129772f, 0.04088868f, -0.31252155f, -0.15514886f, 0.36261579f, -0.22522447f, 0.38740599f, 0.02927345f, 
    -0.02417726f, 0.11500893f, -0.19004470f, 0.19632165f, 0.54852599f, -0.14921680f, -0.09486093f, -0.05963017f, 
    0.18394101f, 0.24475656f, 0.70345938f, 0.12561922f, 0.01043558f, 0.01156877f, 0.14078721f, 0.43101567f, 
    0.07467007f, -0.22660886f, 0.26332188f, -0.07480499f, -0.13846132f, -0.10858440f, 0.09298569f, -0.38602328f, 
    0.27758870f, 0.03977535f, 0.37939507f, -0.16348435f, -0.01211537f, 0.02112827f, 0.06706305f, -0.19416516f, 
    0.85993218f, -0.11368162f, -0.13048679f, -0.08058896f, 0.14939378f, -0.05793653f, -0.21627840f, -0.20748372f, 
    0.27973399f, -0.60996467f, -0.14737962f, 0.01855690f, -0.12880920f, 0.02867349f, -0.04769283f, -0.01122137f, 
    0.27331433f, 0.30265880f, 0.31095266f, -0.18968761f, -0.15435094f, -0.14862216f, 0.38838059f, 0.40327936f, 
    0.02528503f, 0.26297465f, 0.11550051f, -0.15822163f, 0.22085671f, 0.47686103f, -0.29001585f, 0.40284184f, 
    -0.04938775f, -0.03588329f, 0.03824747f, 0.40778834f, 0.27329567f, 0.19247983f, 0.04553991f, 0.35959205f, 
    0.44923165f, 0.00984612f, -0.21816526f, 0.22723870f, -0.05842721f, 0.04350378f, -0.05070600f, -0.00896817f, 
    -0.31833777f, 0.37369883f, -0.00536667f, 0.24679711f, -0.20458589f, 0.50377190f, -0.32409620f, 0.15288936f, 
    0.01325829f, -0.32519549f, -0.20014304f, 0.11625677f, 0.32179993f, -0.40868792f, 0.52167368f, -0.45191097f, 
    -0.03221680f, 0.04661172f, -0.13256256f, -0.09222814f, -0.14279638f, -0.04244887f, -0.11313312f, -0.12280063f, 
    0.05828859f, -0.11347920f, 0.13845018f, -0.00452088f, 0.12532264f, -0.13191462f, -0.05265298f, -0.07364500f, 
    -0.10877014f, 0.09057880f, -0.05127002f, 0.07293830f, -0.03802124f, -0.04163295f, -0.05949055f, 0.11438412f, 
    -0.12757765f, -0.12187549f, 0.11559226f, -0.06509631f, -0.01694579f, -0.08935566f, 0.07600570f, 0.06938069f, 
    -0.00345166f, 0.16607466f, 0.04705151f, -0.10852458f, 0.02814719f, -0.02634142f, -0.17624193f, 0.19114372f, 
    0.09234890f, 0.21006908f, 0.40434432f, -0.02655577f, -0.00190012f, 0.08137258f, 0.02683282f, -0.72785997f, 
    -0.03009393f, 0.30451065f, 0.00616073f, -0.00673134f, 0.00338098f, 0.12655023f, 0.06488279f, 0.11148785f, 
    -0.32748443f, 0.28145689f, -0.39448693f, 0.06283823f, 0.12544736f, 0.19821402f, -0.41127446f, -0.01762574f, 
    -0.08363582f, -0.12379865f, -0.11919702f, -0.01048096f, -0.06279496f, -0.15394916f, 0.01543583f, -0.13228188f, 
    -0.16697752f, -0.02686679f, -0.14478011f, 0.15369245f, -0.16659123f, 0.18606023f, 0.01125587f, 0.09436347f, 
    0.11410490f, -0.08621656f, -0.15849082f, -0.09505323f, -0.05761549f, -0.10012394f, -0.02828502f, -0.06501079f, 
    -0.16401978f, -0.00987265f, 0.10754789f, -0.15804681f, 0.04650399f, 0.12642758f, -0.02519018f, 0.08892205f, 
    -0.01304608f, 0.08537523f, -0.06324916f, 0.00785265f, -0.04335625f, -0.17663118f, 0.11094827f, -0.07963808f, 
    0.06444781f, -0.17672025f, 0.03654400f, -0.14026214f, -0.13111617f, -0.16317192f, 0.02512915f, -0.09772919f, 
    -0.20040829f, -0.08713818f, -0.02970522f, -0.18088092f, -0.17068629f, -0.19471958f, 0.09020865f, 0.12741438f, 
    0.03874118f, 0.13216178f, -0.17277838f, 0.06187399f, 0.00291279f, -0.08976551f, 0.06450320f, -0.13965969f, 
    0.16715084f, -0.09168312f, 0.58837116f, 0.29320815f, -0.40221950f, 0.01493549f, 0.13301402f, 0.27725673f, 
    -0.27125442f, -0.33958697f, -0.31319839f, -0.02523419f, 0.07726673f, 0.18522458f, 0.12734810f, -0.26997805f, 
    0.22228643f, 0.64399046f, 0.21033493f, 0.46827379f, -0.06076125f, 0.60399151f, 0.11788379f, 0.59663373f, 
    -0.37136260f, 0.35844657f, -0.12748197f, 0.00636353f, 0.09949590f, -0.16595560f, 0.02156913f, 0.07862578f, 
    0.52243447f, -0.03100319f, 0.09638991f, -0.41306967f, 0.05160273f, 0.16640790f, -0.08322787f, -0.02195756f, 
    -0.02490689f, 0.06793085f, 0.16870943f, 0.13698350f, 0.02560234f, -0.27225086f, -0.10546423f, 0.26327488f, 
    0.63798898f, -0.21888743f, 0.24731451f, 0.21135351f, 0.20026635f, -0.27902710f, 0.16900434f, -0.01127927f, 
    -0.19914402f, 0.36592802f, 0.35905224f, -0.20178218f, -0.20503320f, 0.14205448f, 0.27824110f, 0.11002862f, 
    0.06181758f, -0.12270747f, -0.14939217f, 0.33373821f, -0.02736920f, -0.15544581f, 0.11341246f, -0.29328406f, 
    -0.46656609f, -0.43689689f, 0.63634086f, 0.14507224f, 0.02620123f, -0.04865857f, 0.15321979f, 0.26675835f, 
    0.23604690f, 0.08961278f, 0.03524821f, 0.31420493f, 0.26397505f, 0.05421595f, 0.22735734f, -0.10693269f, 
    0.02850595f, 0.25708133f, 0.30339500f, 0.09420812f, -0.20654516f, -0.05886377f, 0.45126617f, -0.50361115f, 
    0.01870457f, -0.03927239f, 0.21412371f, 0.41836503f, -0.12953186f, 0.28792796f, -0.44545272f, 0.23468761f, 
    -0.05104309f, -0.08229753f, 0.03221425f, 0.24041730f, 0.01128421f, -0.06943823f, 0.09405421f, -0.50613874f, 
    0.15314232f, 0.02617553f, -0.14424129f, 0.13997212f, -0.29473072f, 0.35636744f, -0.20073046f, -0.04411641f, 
    -0.37345377f, 0.47937879f, 0.05248688f, 0.67672944f, 0.05511331f, 0.25845343f, 0.20596522f, 0.04955063f, 
    0.51063317f, 0.06383661f, -0.21021792f, 0.17683467f, 0.30659914f, 0.15951049f, -0.07415491f, 0.06289492f, 
    0.73360705f, 0.33214965f, -0.09687464f, -0.13083401f, 0.07388052f, -0.17025375f, -0.09981028f, 0.17493698f, 
    0.33420482f, -0.19607414f, 0.03352296f, 0.02595291f, -0.27782434f, -0.27308968f, -0.05117250f, 0.31721863f, 
    0.28919154f, -0.06421139f, 0.31791580f, 0.02748377f, 0.00146158f, 0.18191516f, 0.25366086f, 0.21578452f, 
    -0.30738258f, 0.07956180f, 0.01654858f, -0.22235096f, 0.27344450f, -0.22701001f, 0.38570657f, -0.16175684f, 
    -0.02141526f, 0.81441951f, -0.18235958f, -0.14248241f, -0.04738585f, 0.35822350f, 0.07240972f, 0.26569083f, 
    -0.00696278f, -0.05392375f, 0.33073026f, -0.02887026f, 0.30608729f, -0.24060966f, 0.13797300f, 0.51729095f, 
    0.30172145f, -0.05219258f, 0.16048142f, -0.09789564f, 0.03062306f, -0.44452503f, 0.30132413f, -0.03937792f, 
    -0.08477238f, 0.07439145f, 0.11285762f, -0.08779910f, -0.02340047f, -0.04672035f, 0.04992092f, 0.08303124f, 
    0.05269016f, -0.08779240f, 0.05435300f, 0.06307817f, -0.01217037f, -0.04035302f, -0.07722823f, 0.02523864f, 
    -0.03583674f, -0.08258691f, -0.07083154f, 0.10363229f, 0.04905364f, -0.12372618f, -0.01174001f, -0.12488052f, 
    -0.12599081f, 0.03792825f, -0.09301089f, 0.03386291f, -0.09732193f, -0.15328754f, -0.13923238f, 0.08610625f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.03822403f, 0.47143328f, -0.16584933f, 0.03748442f, 0.40157124f, 0.02514180f, 0.16179571f, 0.22724600f, 
    -0.18755250f, 0.00259136f, 0.02985345f, -0.03337519f, 0.03757282f, -0.07777482f, 0.38029006f, -0.01954065f, 
    0.36135828f, 0.07962836f, 0.36757770f, 0.03931006f, 0.26742679f, -0.12649848f, -0.20145793f, 0.14584421f, 
    0.04418683f, 0.24820730f, -0.23235843f, 0.25199020f, 0.18006891f, -0.13765799f, 0.13343202f, 0.04645671f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.11697619f, 0.01441172f, -0.32849237f, -1.06701279f, 0.14509335f, 0.11669517f, -0.24391717f, 0.35275126f, 
    -0.58955872f, 0.05705417f, -0.16153300f, 0.19761458f, 0.03750119f, -0.14172302f, 0.14469247f, 0.31058738f, 
    0.10400095f, 0.14294878f, 0.14999177f, -0.08634225f, 0.38201845f, 0.15661134f, -0.40621170f, 0.01252339f, 
    -0.17115477f, -0.14947647f, -0.73896188f, -0.56671435f, -0.48148772f, 0.02678510f, 0.20612620f, -0.13994195f, 
    0.13670714f, 0.11253704f, -0.65518469f, 0.14658302f, 0.06650817f, -0.07638106f, -0.12851594f, -0.21305314f, 
    -0.02821876f, 0.38944349f, -0.29351702f, 0.26863241f, 0.12684464f, 0.00122914f, 0.30981264f, -0.31242880f, 
    -0.59986728f, 0.33784023f, -0.08062827f, -0.22114737f, -0.35533389f, 0.05641945f, -0.52006698f, 0.12283509f, 
    -0.18379596f, -0.18506323f, 0.02120338f, -0.29111940f, 0.12270612f, 0.22131152f, 0.31047738f, -0.06413126f, 
    -0.13338053f, 0.01494636f, 0.44470382f, -0.21090911f, 0.37306786f, 0.41230291f, 0.28855321f, -0.06415991f, 
    0.23709238f, -0.26767680f, -0.36342832f, 0.07782844f, -0.11461102f, 0.04608987f, -0.26126823f, -0.25745142f, 
    0.03974842f, -0.16620626f, 0.44102269f, 0.24139704f, -0.56599104f, -0.14363907f, 0.25043294f, 0.03355453f, 
    -0.13297530f, -1.03823555f, -0.05134856f, 0.09482983f, -0.46319392f, 0.15581286f, -0.17464317f, 0.01451001f, 
    -0.49271068f, 0.15052441f, 0.35881737f, -0.12411412f, -0.17845824f, -0.33791643f, 0.03608175f, 0.16980989f, 
    0.30940282f, -0.27641895f, -0.33682638f, -0.14584257f, -0.00789804f, 0.03727733f, 0.23444852f, 0.15726468f, 
    0.04563513f, -0.07305223f, -0.44867662f, 0.06510253f, -0.02181762f, 0.03620246f, 0.50022763f, -0.17279068f, 
    0.02249309f, 0.21517016f, -0.33647439f, -0.57737881f, 0.29840839f, -0.29074582f, -0.68526143f, 0.14318912f, 
    0.05332863f, 0.20122932f, -0.00244046f, -0.68136406f, 0.27802181f, 0.05090196f, 0.13267154f, 0.25530192f, 
    -0.22112706f, -0.03726805f, -0.19700606f, -0.51465273f, -0.01006125f, 0.07029113f, -0.15301672f, 0.26510760f, 
    0.26503101f, -0.19029984f, -0.13597488f, 0.01992772f, -0.12049495f, 0.16631526f, 0.16077347f, -0.12545499f, 
    0.13941024f, 0.14798412f, -0.25738326f, 0.18821470f, 0.05095504f, -0.51116621f, -0.01738600f, -0.07049994f, 
    0.20491445f, 0.28881022f, -0.98157090f, 0.21203326f, 0.07459748f, -0.08393920f, -0.04970004f, 0.04703293f, 
    -0.38454172f, 0.22589056f, 0.51726842f, -0.58924621f, 0.00889309f, -0.19165209f, 0.01037888f, -0.15705951f, 
    -0.19137658f, 0.34250045f, -0.06306390f, 0.03083238f, 0.20073678f, 0.07261811f, -0.53765869f, 0.06869274f, 
    -0.11825076f, 0.21449077f, -0.31261984f, 0.26541528f, -0.03400916f, -0.40118194f, -0.08589790f, 0.17202029f, 
    0.19741580f, 0.21531604f, 0.22486582f, 0.13428101f, -0.04641179f, -0.24081337f, 0.20706184f, 0.34069914f, 
    -0.28978509f, 0.15245387f, -0.26645648f, -0.77776229f, -0.03130892f, -0.09472413f, -0.38463199f, -0.25609046f, 
    0.00452931f, -0.07436894f, -0.26233202f, 0.36832371f, -0.82413417f, 0.04649164f, -0.38066068f, -0.03832865f, 
    0.07728815f, 0.10901891f, 0.24807759f, -0.39445379f, -0.92559332f, -0.04525453f, 0.01032598f, 0.03683809f, 
    -0.17756742f, -0.61785913f, -0.34894577f, 0.14591028f, -0.59925067f, 0.07978629f, -0.69245487f, 0.08901992f, 
    0.02034564f, -0.11308872f, 0.13166055f, 0.06357071f, 0.13697174f, -0.12224649f, -0.04032313f, 0.33387598f, 
    0.15841286f, 0.38316467f, -0.23913136f, -0.73338693f, 0.44529763f, -0.07854276f, 0.21952210f, 0.03595168f, 
    -0.10534219f, 0.14880013f, -0.45643508f, 0.18018028f, 0.29754516f, -0.16108111f, -0.16757250f, -0.07735775f, 
    -0.28154889f, -0.35660422f, -0.15277073f, 0.40454575f, -0.30569977f, -0.64603579f, 0.07121789f, -0.99673992f, 
    0.09794604f, 0.10633076f, 0.55576086f, 0.42881969f, 0.09408258f, 0.03786594f, 0.29915348f, -0.21243267f, 
    -0.33338639f, 0.13042150f, 0.26580387f, -0.35350087f, -0.13357133f, -0.10182545f, -0.57749707f, -0.10138059f, 
    0.02809479f, -0.31982920f, 0.26059309f, 0.32413262f, -0.32090521f, 0.06274749f, 0.18106094f, 0.04958644f, 
    0.15707649f, -0.03072900f, -0.01926937f, 0.37130764f, -0.27587667f, 0.45955983f, 0.07803894f, -0.21948779f, 
    -0.13715155f, -0.31279865f, 0.17068945f, 0.18227026f, -0.03666864f, -0.06189005f, -0.27980152f, 0.34129441f, 
    0.41260275f, -0.27661100f, 0.11893061f, -0.21427475f, -0.19804786f, -0.01796324f, -0.03609319f, 0.07656055f, 
    0.10983943f, 0.03993941f, 0.28467610f, 0.15545674f, 0.04062540f, -0.78282511f, 0.05754947f, -0.14509442f, 
    -0.84950209f, 0.11918999f, 0.09951075f, 0.38593537f, -0.07272715f, -0.71447659f, 0.25327334f, -0.23076770f, 
    0.38835949f, -0.13825643f, -0.36601958f, 0.02773865f, 0.10551047f, -0.05910295f, 0.37575290f, -0.40826163f, 
    0.26272979f, -0.31311262f, 0.05703279f, 0.03389663f, -0.07118699f, 0.08096869f, -0.59490734f, -0.16728789f, 
    0.13071385f, 0.02841322f, 0.21070413f, -0.02423823f, 0.19951704f, 0.18445215f, -0.87259156f, 0.01913382f, 
    -0.19264139f, -0.38663042f, 0.00076377f, -0.46461296f, 0.27972904f, -0.71495348f, 0.27693334f, 0.13242659f, 
    0.12555499f, -0.36338422f, 0.05898425f, 0.15212710f, -0.00612440f, -0.16870257f, -0.58216614f, 0.17059979f, 
    -0.14661965f, -0.61093682f, 0.08156143f, 0.26963729f, 0.01458888f, -0.09614697f, -0.54618406f, -0.13807251f, 
    0.08304802f, -0.03399325f, 0.37355509f, 0.10158917f, -0.34535286f, 0.34284315f, 0.07078283f, -0.16533090f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.00852026f, -0.25955960f, -0.04095007f, -0.01645433f, 0.14991322f, 0.11072619f, -0.19164628f, -0.16480587f, 
    0.02073239f, -0.16460043f, 0.32681668f, -0.03975162f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
