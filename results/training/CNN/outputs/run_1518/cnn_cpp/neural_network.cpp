#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.04750276f, -0.38756940f, 0.85639685f, 0.58018380f, 0.03190206f, 0.42078736f, -0.00571404f, 0.90984666f, 
    -0.52469516f, -0.17029159f, -0.23648743f, -0.14353278f, -0.70220077f, -0.67945021f, -0.85369265f, 0.18525848f, 
    0.16114253f, 0.82183594f, -0.08086667f, 1.13091993f, -0.22291054f, -0.41253373f, -0.09500205f, 0.10207054f, 
    -0.29300094f, 0.53167832f, 0.53065687f, 0.82114238f, 0.63821334f, 0.44853446f, -0.76892233f, -0.50124913f, 
    -0.31019300f, 0.54227877f, 0.34034893f, 0.30221081f, 0.04136810f, 0.38227022f, 0.59772223f, -0.34186673f, 
    -0.62158155f, 0.74654293f, -0.14342187f, -0.00947396f, 0.07634075f, -0.00922253f, 0.88010716f, 0.22156624f, 
    -0.71901059f, -0.54967499f, -0.56954467f, -0.35140228f, -0.80782610f, -0.53651232f, -0.59780502f, -0.54637188f, 
    -0.67566484f, 0.46046025f, -0.21702488f, -0.01991041f, 0.63257790f, 0.70230848f, 0.69680929f, 1.31872499f, 
    -0.31192806f, -0.18527153f, -0.19506413f, 0.48508909f, -0.52100271f, -0.05671572f, 0.02619494f, 0.07195111f, 
    -1.60334694f, 0.53525275f, 0.19499525f, -0.11712189f, -0.75826180f, -0.43464378f, -0.10265715f, -0.22350280f, 
    -0.19471398f, -0.08693418f, 0.26821911f, 0.54666638f, -0.11620208f, 0.32118258f, 0.48188388f, 0.44959593f, 
    -0.83681875f, 0.67764586f, 0.08813641f, 0.13125946f, 0.03472051f, -0.69044757f, -1.01307631f, -1.00016749f, 
    -0.16584726f, 0.75624043f, -0.31092381f, -0.47598398f, 1.23805809f, -0.83477515f, -0.26076889f, 0.35311756f, 
    -0.37618217f, 0.28432372f, -0.26147443f, 0.36774668f, -0.94511628f, -0.37784004f, -0.12756838f, 0.24394549f, 
    -0.37933829f, -0.42400679f, -0.37765080f, -0.46835199f, -0.43103415f, -0.61277115f, -0.92946798f, -0.59215969f, 
    1.10209489f, 0.04873526f, 0.37853417f, -0.37617278f, -0.52802122f, -0.52105582f, 0.06393128f, -0.30401114f, 
    0.73566741f, -0.46024230f, -0.31178638f, -0.31817728f, 0.57940257f, 0.49530721f, 0.64659232f, 0.25832301f, 
    0.27801281f, -0.00068931f, 0.88689297f, 1.34044719f, 0.42309314f, 0.14890184f, -0.34416464f, 0.04487187f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.26994136f, -0.19509500f, 0.25144497f, 0.49022716f, 0.57984000f, -0.47734955f, 0.34560290f, 0.19294728f, 
    0.25329465f, 0.25134018f, 0.54535228f, 0.44276068f, -0.67505014f, 0.46576291f, -0.02114599f, 0.05101303f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.11247917f, -0.03402958f, -0.07613521f, 0.00241829f, 0.05381583f, -0.06600544f, -0.03863812f, 0.04809384f, 
    0.04402061f, -0.06456830f, -0.05098754f, -0.03884382f, -0.01087369f, -0.02489508f, -0.01845879f, 0.01032335f, 
    0.02809784f, 0.02128442f, 0.00061602f, 0.00988542f, -0.10600612f, -0.00169748f, 0.00375192f, 0.00081837f, 
    -0.04291738f, -0.10299812f, -0.08947799f, -0.08264381f, 0.04675607f, -0.10073050f, -0.07579148f, -0.08365818f, 
    0.02257937f, -0.07141038f, -0.07652435f, -0.05839079f, -0.09284867f, 0.02146030f, -0.03652607f, -0.04054336f, 
    -0.05763655f, -0.10964615f, -0.00882717f, -0.10927706f, -0.08556725f, -0.07493020f, -0.08138074f, -0.05434262f, 
    0.02009678f, 0.03166664f, -0.08084255f, 0.06485036f, -0.07373812f, 0.06544286f, -0.01335822f, 0.03232449f, 
    -0.09329177f, -0.08207490f, -0.05487022f, -0.07749935f, -0.03203633f, -0.01105174f, 0.01195617f, -0.08798195f, 
    0.01184989f, -0.02984339f, -0.05506132f, -0.04543534f, -0.09101474f, 0.01868750f, 0.06675397f, -0.08228909f, 
    -0.08082964f, -0.06959434f, -0.00087042f, 0.00733043f, -0.09895770f, -0.02823544f, -0.11182521f, -0.07530098f, 
    -0.09075914f, -0.01943590f, -0.01777226f, 0.02654533f, 0.05150844f, 0.04078586f, 0.01495340f, 0.02859804f, 
    -0.07939288f, 0.01437378f, 0.07650768f, 0.01585831f, 0.03548872f, -0.08681025f, 0.00045483f, -0.11225735f, 
    -0.09381562f, -0.02090237f, -0.09312712f, -0.07312068f, -0.02669951f, 0.01064257f, -0.10793360f, 0.02066406f, 
    -0.09303175f, -0.10002476f, -0.01447176f, -0.10886198f, -0.01259624f, -0.04836228f, -0.03887507f, 0.02339721f, 
    -0.01629946f, 0.04538617f, -0.05313738f, -0.08737545f, -0.00356775f, -0.07480136f, -0.05480241f, 0.04062470f, 
    -0.08144057f, -0.05233248f, -0.08102354f, -0.01564754f, -0.01232776f, 0.02897671f, 0.01692504f, -0.05177448f, 
    -0.10314128f, 0.00928726f, -0.10821430f, -0.00210182f, -0.05400480f, -0.07823274f, -0.09568154f, 0.03839608f, 
    -0.08922613f, -0.08272518f, 0.03279896f, -0.06178429f, 0.03408220f, -0.00706407f, 0.00772029f, 0.00989781f, 
    0.10476115f, 0.17239329f, 0.46784422f, -0.21054381f, -0.16094920f, 0.02384169f, -0.27453119f, -0.05534625f, 
    -0.14612339f, 0.26318035f, 0.04071754f, -0.18533249f, -0.00008182f, 0.04461993f, 0.18000707f, 0.08513966f, 
    0.04324620f, 0.23367165f, 0.42422888f, 0.24036027f, 0.32063314f, 0.27943000f, -0.06256433f, -0.02951646f, 
    0.22390711f, 0.00876519f, 0.18140677f, 0.23863322f, 0.11208951f, 0.12994453f, 0.05929956f, 0.12828366f, 
    0.01799942f, 0.09064253f, 0.20875847f, 0.22017205f, -0.07496470f, -0.04050287f, 0.33867905f, 0.04538114f, 
    0.20373993f, 0.18218876f, 0.14892063f, 0.01998738f, -0.05165466f, -0.15884124f, -0.30121267f, 0.06833320f, 
    0.16108413f, 0.15226592f, 0.12040605f, -0.13562275f, -0.15043682f, 0.14773849f, 0.07467747f, -0.21711113f, 
    -0.38199496f, -0.00766745f, 0.11159526f, 0.11257578f, 0.08613319f, 0.08847989f, -0.12899555f, 0.48005930f, 
    0.04769630f, 0.23739024f, -0.00056429f, 0.00546971f, -0.03130011f, -0.07084540f, -0.10473783f, 0.02492112f, 
    -0.31817952f, -0.07497629f, 0.42311046f, -0.09515708f, 0.06973908f, 0.08255524f, 0.20817402f, 0.01965563f, 
    -0.17017323f, 0.06026278f, 0.36433667f, 0.30223525f, -0.10712466f, -0.18916011f, -0.22804534f, -0.05666256f, 
    -0.06517483f, -0.13436992f, -0.21256022f, -0.41835067f, -0.06757986f, 0.12008455f, 0.08256452f, 0.09626394f, 
    0.08773161f, 0.24669027f, 0.12184776f, -0.18490039f, 0.00334725f, 0.23293485f, 0.20593609f, -0.12678576f, 
    0.06471495f, 0.12646048f, 0.29880461f, -0.10096039f, -0.12801318f, 0.16181454f, 0.02826243f, -0.13286944f, 
    0.01383467f, -0.11867353f, 0.03738678f, 0.21193020f, -0.20075773f, -0.19366138f, -0.32829940f, -0.60591638f, 
    -0.01437071f, -0.11068976f, -0.15681762f, -0.24627455f, -0.42365810f, -0.26052859f, -0.07384807f, 0.14636967f, 
    -0.02958765f, 0.21916549f, 0.04213915f, 0.07437679f, -0.03126645f, 0.10265362f, 0.34174895f, 0.18663843f, 
    0.13499099f, 0.02898256f, -0.15553875f, -0.09670077f, -0.05086413f, 0.00607623f, -0.03162486f, -0.16361755f, 
    0.07399762f, -0.10033897f, 0.41030848f, -0.32262793f, 0.13696027f, 0.16647103f, -0.04181968f, 0.16887484f, 
    0.38765800f, 0.10446824f, 0.54100019f, 0.35446000f, -0.01540703f, -0.06969486f, -0.14861748f, 0.06482358f, 
    -0.07806391f, 0.05587560f, -0.01763610f, -0.28945428f, -0.43857679f, 0.26267907f, 0.07181782f, 0.34183294f, 
    -0.07835731f, 0.14760050f, 0.11066175f, -0.39848909f, -0.41185769f, -0.19401455f, -0.29160699f, -0.01639361f, 
    0.10739285f, -0.09455799f, -0.10346367f, 0.02655008f, -0.53081250f, -0.32430458f, 0.20030580f, -0.24307612f, 
    -0.28385371f, -0.17104355f, -0.03593039f, -0.01145982f, 0.01813995f, -0.30424252f, 0.11322329f, -0.09257969f, 
    -0.13367245f, 0.07769515f, -0.02932091f, 0.16030981f, 0.03141922f, 0.08682393f, 0.28639388f, 0.07114951f, 
    -0.23358375f, -0.02052755f, 0.08222398f, -0.02081213f, -0.12916227f, 0.08168155f, -0.06053485f, -0.14045475f, 
    -0.09363853f, 0.26579356f, -0.13404450f, -0.19680721f, -0.14978647f, -0.21040782f, 0.03401609f, 0.00707622f, 
    0.09106866f, 0.36089122f, 0.09076525f, 0.01486657f, 0.11212491f, 0.02208069f, -0.15067853f, 0.04651659f, 
    0.08328399f, -0.14406590f, -0.10268385f, 0.39038938f, 0.26298630f, -0.12463438f, -0.00597291f, -0.14597201f, 
    0.01342100f, -0.21957245f, -0.08153548f, 0.09423263f, -0.21593529f, 0.03374137f, -0.01806062f, -0.18354066f, 
    0.00875997f, -0.04723980f, 0.21451794f, -0.16166413f, -0.23290302f, 0.31763414f, 0.03522305f, -0.04018492f, 
    0.51417744f, 0.09174812f, 0.06473731f, 0.09467371f, 0.41071397f, 0.39011317f, 0.08298726f, 0.14691469f, 
    0.03086448f, -0.07128283f, -0.10332447f, -0.04775911f, -0.00231937f, 0.30146480f, -0.07409624f, -0.22783974f, 
    0.00910545f, 0.20523390f, 0.09144700f, 0.03310588f, 0.08574989f, -0.27025881f, -0.04035057f, 0.38679519f, 
    0.44076928f, -0.13350667f, 0.00725726f, -0.01556467f, 0.05052780f, 0.13264713f, 0.08688350f, 0.03784804f, 
    -0.92737514f, -0.06938289f, 0.00517605f, -0.26497015f, -0.23663118f, 0.06867225f, 0.09440988f, 0.06023417f, 
    0.07228903f, -0.04111637f, 0.14598051f, -0.09410496f, -0.07223334f, -0.28330818f, 0.00294210f, 0.04405607f, 
    -0.17603450f, 0.65600467f, 0.17903817f, -0.08346207f, -0.06377465f, -0.08379588f, 0.05612051f, -0.12674090f, 
    0.03069456f, 0.01389767f, -0.33315381f, -0.14133310f, 0.01491211f, -0.04860188f, -0.12171610f, -0.07319419f, 
    0.09871806f, -0.16492437f, 0.06679536f, -0.26389658f, 0.14440930f, 0.13321945f, 0.00940950f, -0.04983898f, 
    0.24634856f, 0.11167368f, 0.11460759f, 0.15196261f, -0.22084852f, 0.43411663f, 0.24938312f, 0.01447349f, 
    0.02916873f, 0.07547684f, 0.12482889f, 0.12018730f, -0.11080258f, 0.20069912f, 0.12916304f, -0.16904831f, 
    -0.07684618f, -0.24028715f, -0.01575094f, -0.16243669f, 0.17358814f, 0.13499703f, -0.18781739f, -0.13226694f, 
    -0.05938297f, 0.00039799f, -0.00583718f, 0.12265865f, 0.10152545f, 0.05617776f, 0.18376371f, 0.01506779f, 
    -0.22162920f, -0.18416713f, -0.05083174f, 0.08277437f, -0.01257733f, 0.24646913f, -0.08872494f, -0.02988130f, 
    0.62818503f, 0.07592330f, -0.61037916f, -0.03836742f, -0.09878805f, 0.08662189f, 0.01163341f, 0.05463060f, 
    -0.09634718f, -0.05411081f, 0.01183894f, 0.24227047f, -0.13514248f, 0.12638752f, -0.19653587f, 0.09492622f, 
    0.10258412f, 0.03338635f, 0.50648284f, 0.05066321f, -0.32132336f, -0.23576082f, -0.06402300f, 0.08019084f, 
    0.08963300f, -0.05820170f, -0.04865493f, -0.01150659f, -0.34172517f, -0.57926255f, -0.19819050f, 0.18235840f, 
    0.10036339f, 0.09625085f, -0.02850062f, -0.09423392f, 0.83216959f, 0.17383364f, -0.61680627f, 0.04641648f, 
    -0.13678542f, -0.15892126f, 0.00006011f, -0.09053849f, 0.00501233f, -0.18246032f, 0.04500409f, -0.23331654f, 
    -0.22643369f, 0.00242693f, -0.06040335f, 0.03383183f, 0.08081670f, -0.21133408f, 0.53092134f, 0.05392487f, 
    -0.29432568f, -0.02952067f, -0.07273033f, 0.00252387f, 0.23482263f, 0.06743476f, -0.01837174f, 0.27543646f, 
    -0.04342283f, 0.39202875f, -0.16710734f, 0.18912315f, -0.27739757f, 0.05364804f, -0.08063199f, -0.14745398f, 
    0.12866859f, 0.30811673f, -0.02427922f, 0.00031199f, 0.20804711f, 0.02226412f, -0.14145772f, -0.23676877f, 
    -0.05184746f, -0.15521790f, -0.17210658f, -0.32531163f, 0.39427534f, 0.25684968f, 0.02748938f, 0.02838388f, 
    -0.03624523f, -0.25445020f, 0.08117805f, 0.08401947f, 0.07136720f, 0.02909154f, -0.05364507f, -0.05333018f, 
    0.04926016f, -0.01997176f, -0.09164276f, 0.17526029f, 0.34056416f, -0.05762059f, -0.18420322f, -0.00912641f, 
    -0.14218293f, 0.05346755f, 0.01071478f, 0.00281440f, 0.12196357f, 0.15521376f, -0.43636289f, -0.28611201f, 
    0.19074684f, 0.05036906f, 0.04980170f, -0.05494159f, -0.08273225f, 0.07823715f, 0.28182238f, 0.09284936f, 
    0.12556058f, 0.09884237f, 0.13840680f, 0.13176292f, 0.14912255f, 0.12728961f, -0.15359117f, -0.06960071f, 
    -0.02531905f, 0.31130570f, -0.06032880f, 0.03196659f, 0.10006904f, -0.27540919f, -0.13843872f, -0.06980310f, 
    0.22776560f, 0.32064486f, 0.01713585f, -0.17792797f, 0.25497752f, 0.19776846f, 0.11171154f, 0.03472881f, 
    0.31591210f, 0.16442688f, -0.27306151f, 0.02545357f, -0.01775051f, 0.08505692f, 0.12598653f, -0.12736388f, 
    0.20450301f, -0.19259295f, -0.00885341f, -0.11905497f, 0.17776553f, 0.33231387f, 0.04058742f, 0.35999101f, 
    0.03010894f, -0.18310793f, 0.12021308f, 0.24619761f, 0.03947381f, 0.26357809f, 0.14467087f, 0.06868286f, 
    0.18317625f, -0.01904872f, 0.01547174f, 0.08547457f, 0.29841626f, 0.18234068f, 0.14703900f, 0.11214350f, 
    -0.18649334f, -0.23599721f, -0.04911638f, 0.01579556f, 0.04109915f, 0.12746508f, -0.30375245f, -0.25391719f, 
    -0.19073370f, 0.11949772f, -0.15456788f, 0.09820900f, 0.14555550f, 0.05116026f, 0.01281159f, -0.01325950f, 
    0.09280396f, 0.07319853f, 0.19733489f, 0.08461910f, 0.53753692f, 0.17443116f, -0.11789170f, 0.01479942f, 
    -0.09872147f, -0.09923232f, -0.02268587f, 0.03736579f, -0.26087633f, -0.20873196f, -0.40691385f, -0.32035542f, 
    -0.04939780f, 0.25741917f, 0.16132775f, 0.10490030f, 0.04962726f, -0.19515055f, -0.17212062f, -0.20543472f, 
    0.05798884f, -0.05935027f, -0.22487783f, 0.21536712f, -0.01448077f, -0.23245841f, 0.13290380f, -0.06322271f, 
    0.11409117f, 0.12303205f, 0.39633760f, 0.40274078f, -0.09255826f, -0.07453821f, -0.04222033f, -0.03593602f, 
    -0.21954899f, -0.07147484f, -0.09657396f, -0.16391589f, -0.05892009f, -0.22069259f, -0.00271691f, -0.11864536f, 
    -0.02991250f, 0.06564780f, -0.16360310f, 0.06015312f, -0.03873768f, -0.28437510f, -0.00409666f, 0.05730968f, 
    0.01867083f, -0.03701375f, 0.08197347f, 0.04539343f, -0.42211664f, -0.37716427f, -0.58638823f, 0.02841843f, 
    0.20025256f, -0.22111899f, 0.00757684f, 0.04978254f, -0.02077581f, 0.42424479f, -0.57439190f, -0.16104068f, 
    -0.06837117f, -0.14724658f, 0.01548752f, -0.05694769f, 0.07065173f, -0.16263278f, 0.06899523f, 0.04420561f, 
    0.23756047f, 0.17656459f, -0.03906689f, -0.10088082f, 0.16659203f, 0.08648781f, 0.15178816f, -0.25376591f, 
    -0.43670923f, -0.52430475f, 0.06162725f, 0.13559328f, -0.07312542f, 0.32661533f, -0.11781724f, 0.13124910f, 
    -0.24225281f, -0.05171134f, 0.04501432f, 0.02481540f, 0.00329079f, -0.20720042f, -0.06371588f, 0.09725022f, 
    -0.02831661f, -0.07411999f, 0.08826278f, -0.22871467f, 0.15348496f, 0.15480424f, 0.09714290f, -0.12723531f, 
    -0.11830789f, 0.11069557f, 0.29359376f, 0.51640773f, 0.23943086f, 0.06514280f, 0.10292953f, 0.04239926f, 
    0.09750392f, 0.03639661f, -0.14913046f, 0.35866350f, 0.08484701f, -0.04727135f, -0.09255102f, 0.04721392f, 
    0.16654755f, 0.03488051f, 0.14283527f, -0.10873847f, -0.55266583f, -0.18700393f, -0.04931361f, -0.00251475f, 
    -0.26831114f, -0.02157528f, 0.29636151f, -0.14870109f, 0.14349233f, -0.04090312f, -0.00509257f, 0.24181406f, 
    -0.11041565f, -0.05186193f, -0.14713730f, -0.08704845f, -0.13852687f, 0.24358238f, 0.15837979f, 0.08317647f, 
    0.04860305f, -0.00018928f, 0.08710034f, 0.10782379f, -0.18398359f, 0.10727705f, -0.31781167f, 0.19534296f, 
    0.06804726f, 0.03634826f, -0.11325650f, -0.18150041f, -0.03256694f, 0.16718191f, 0.12531927f, 0.24165586f, 
    0.20377557f, -0.36162490f, -0.39067200f, 0.23281153f, -0.23920213f, 0.27323261f, 0.34887317f, -0.20117226f, 
    -0.01275814f, 0.20040081f, 0.61251050f, 0.37565428f, 0.08904694f, 0.15838628f, -0.25834256f, 0.14094023f, 
    0.04812882f, 0.12013851f, -0.10287892f, -0.67982715f, -1.04527354f, 0.07638431f, 0.12662143f, 0.08546159f, 
    0.16354369f, 0.05369794f, -0.23150966f, -0.08413150f, -0.35987946f, -0.29585129f, 0.01987823f, -0.16964747f, 
    -0.08798023f, 0.09197530f, 0.07742587f, 0.08614958f, -0.06843252f, -0.51461941f, -0.13017924f, -0.34074435f, 
    -0.18554656f, -0.18854503f, -0.10225783f, -0.12127010f, -0.07895152f, 0.45340258f, 0.44392520f, -0.18185513f, 
    0.14259106f, -0.27144530f, 0.07776915f, 0.03758565f, -0.23624618f, -0.05269983f, 0.49350199f, 0.25742069f, 
    -0.06137833f, -0.23208040f, 0.12455031f, -0.16694805f, 0.14988001f, -0.03960704f, 0.07938430f, -0.13488410f, 
    -0.12234931f, -0.88968593f, 0.15465342f, -0.21604651f, -0.15567248f, 0.17397146f, -0.02452054f, -0.09769790f, 
    0.05395751f, 0.21378855f, 0.10990202f, -0.11912873f, 0.09959762f, 0.03552797f, 0.19304720f, 0.11356497f, 
    -0.00432647f, -0.60730141f, -0.34629783f, 0.28064173f, 0.03701171f, 0.12221380f, -0.11312548f, -0.13282961f, 
    -0.09835815f, -0.11480302f, 0.20722114f, 0.11476333f, 0.23781043f, -0.03988778f, 0.09267516f, -0.09022138f, 
    -0.04232765f, -0.04237854f, 0.02500879f, 0.19207832f, 0.08835636f, -0.13342129f, 0.05339854f, 0.01394125f, 
    0.05644660f, 0.02476625f, -0.12397176f, -0.05631588f, 0.11224221f, 0.00940597f, -0.16504890f, 0.00235043f, 
    -0.01914014f, -0.07074708f, 0.34909394f, -0.08117279f, 0.30806476f, -0.04711786f, -0.28281507f, -0.05992385f, 
    -0.14187610f, 0.05314902f, -0.02519363f, 0.08245874f, -0.03574482f, -0.05767655f, -0.02739101f, 0.12746274f, 
    0.18093243f, -0.21079601f, 0.35607967f, -0.09167480f, 0.07328204f, 0.02773796f, 0.02202530f, 0.47722235f, 
    0.09599360f, -0.41338542f, -0.24418001f, -0.31519121f, 0.01297665f, 0.16445768f, 0.09055401f, 0.05246867f, 
    0.02365415f, 0.22840269f, 0.03040745f, -0.09025565f, -0.02007316f, 0.17311780f, 0.13491568f, 0.14624441f, 
    0.09536420f, -0.60333085f, -0.18815106f, 0.26647425f, 0.00380541f, -0.11921349f, -0.28943169f, 0.05446924f, 
    0.09052500f, 0.00766334f, 0.13083178f, -0.09777958f, 0.02482235f, 0.09452428f, 0.17943344f, 0.08521567f, 
    -0.07374049f, 0.28015226f, -0.10330147f, -0.26648003f, -0.14531311f, -0.01179984f, 0.01316183f, -0.04009971f, 
    -0.08152387f, 0.11183178f, 0.07461476f, -0.03510860f, 0.01254558f, 0.06447139f, 0.09962609f, 0.14068918f, 
    -0.16821197f, -0.11425123f, 0.02823034f, 0.09435293f, 0.21679875f, 0.30830798f, 0.18895896f, 0.03784400f, 
    -0.07656478f, 0.06754765f, -0.06956022f, 0.24965616f, -0.39112380f, 0.17841668f, 0.05679645f, 0.18215284f, 
    0.44348031f, 0.04728077f, 0.09936272f, -0.09250762f, 0.03751072f, 0.03365737f, -0.07808893f, -0.02270348f, 
    0.19334891f, 0.18828394f, -0.11700983f, -0.14569816f, 0.19444402f, -0.22305341f, 0.03030173f, 0.12092983f, 
    -0.02519166f, -0.04370279f, 0.22770222f, -0.08523122f, -0.12577716f, -0.02174505f, -0.18564412f, -0.07273081f, 
    0.32385904f, 0.11015987f, -0.02637766f, 0.17740208f, -0.35679820f, -0.12623711f, -0.11901478f, 0.03789397f, 
    0.17368078f, 0.21339041f, -0.34927410f, 0.08147361f, 0.45347586f, -0.21334516f, -0.05170069f, -0.27682459f, 
    -0.04490283f, -0.00544867f, 0.13434456f, -0.00922566f, -0.24494745f, 0.42931163f, 0.02060646f, 0.17394055f, 
    0.42056027f, -0.08040049f, -0.07907964f, -0.08730199f, -0.47468379f, -0.26111975f, -0.19064030f, -0.02057095f, 
    -0.04405292f, -0.27454305f, -0.18487793f, 0.11098628f, 0.07015984f, -0.27121753f, -0.06180030f, 0.41192055f, 
    0.18840681f, 0.09584583f, 0.07956424f, -0.08606327f, -0.31675336f, 0.05860959f, -0.61790884f, -0.08079394f, 
    -0.26006261f, 0.12058785f, 0.10516026f, 0.30320671f, 0.11544067f, -0.05686837f, 0.20291021f, -0.05205934f, 
    -0.04707174f, -0.16688508f, -0.18547098f, -0.06794357f, -0.22030663f, 0.05708034f, 0.14781696f, 0.10232809f, 
    -0.02560706f, 0.25426471f, 0.48081470f, -0.18656242f, 0.08993119f, -0.42996252f, 0.00175390f, 0.00029348f, 
    0.17236759f, 0.32492793f, -0.24200428f, 0.45445409f, -0.20004304f, 0.03439069f, -0.03189978f, -0.14549057f, 
    -0.18442021f, 0.18334046f, 0.06599630f, 0.41197294f, -0.38903081f, 0.04343158f, -0.11964323f, 0.13923761f, 
    0.22653186f, -0.04070751f, -0.05836059f, -0.05559130f, 0.23003307f, -0.02385925f, 0.04518218f, 0.10182632f, 
    0.20917785f, 0.18312658f, 0.09543782f, 0.04936812f, -0.31989315f, -0.07249708f, -0.26559418f, 0.02992650f, 
    0.06800439f, 0.04059201f, -0.00753176f, 0.08328945f, -0.15593439f, 0.06918082f, -0.04916299f, -0.05890036f, 
    -0.10846004f, 0.07731957f, -0.07346550f, -0.14361465f, 0.06012792f, 0.09381969f, 0.31253895f, -0.27772298f, 
    0.03935312f, -0.00730512f, 0.01710874f, -0.04781584f, 0.11392306f, -0.03640089f, 0.30026186f, -0.28681970f, 
    -0.03820068f, 0.54539651f, 0.21250309f, -0.04918998f, 0.06788983f, 0.23928316f, 0.15926886f, 0.23014687f, 
    0.54752576f, -0.47743729f, 0.18426473f, -0.07953341f, 0.12038709f, -0.24031438f, 0.14234859f, -0.07293537f, 
    -0.03986699f, -0.12353991f, -0.02058644f, 0.11007805f, 0.21561310f, -0.12040346f, -0.17323674f, 0.00369448f, 
    0.03969225f, -0.06180441f, -0.18655506f, 0.03893656f, 0.27165225f, -0.25175962f, 0.02277628f, -0.06708392f, 
    -0.03312024f, 0.03429014f, 0.14110889f, 0.48756689f, 0.42115724f, -0.46442088f, 0.00027128f, 0.26047066f, 
    -0.19413005f, 0.23689052f, -0.03214778f, -0.16612932f, 0.65394396f, -0.08601613f, -0.04851967f, 0.04017770f, 
    -0.08474419f, -0.08435092f, 0.01565810f, 0.08285195f, 0.19540285f, 0.15934871f, -0.58744365f, -0.37716395f, 
    -0.19341883f, -0.06737985f, -0.32384738f, -0.00101468f, -0.22713247f, -0.01262004f, -0.08291084f, 0.11667681f, 
    -0.09479385f, 0.25114545f, 0.08139075f, 0.16828470f, 0.20539725f, 0.17093448f, 0.20455898f, 0.03573013f, 
    0.18067351f, 0.38704801f, -0.37354144f, -0.29374942f, -0.35764778f, -0.21392816f, -0.14999396f, -0.01958884f, 
    -0.11990694f, 0.05828393f, 0.17464386f, 0.06678659f, 0.29368281f, -0.36402184f, -0.17031516f, -0.01151131f, 
    -0.04022982f, -0.20123756f, -0.29932114f, 0.14310236f, -0.29323229f, -0.29533109f, -0.16029763f, 0.01048116f, 
    -0.21804294f, 0.10947251f, 0.24603313f, 0.69487715f, -0.19929126f, 0.15840071f, 0.03947723f, 0.27175224f, 
    0.16003458f, 0.07887277f, -0.03674613f, 0.36762384f, 0.40087977f, -0.08424283f, 0.14380379f, 0.16498750f, 
    -0.22027007f, 0.09852301f, 0.21229327f, 0.19886042f, 0.05576327f, 0.11594484f, 0.08855209f, 0.08913513f, 
    0.13501301f, 0.04675723f, 0.21655710f, 0.10577895f, 0.04414200f, -0.03504567f, 0.42434663f, -0.07300876f, 
    0.09249571f, -0.03835191f, -0.08012340f, -0.03802685f, 0.06866652f, -0.01678541f, -0.67412597f, -0.35840121f, 
    -0.19125572f, -0.11531021f, 0.13976191f, 0.06057391f, 0.13911748f, 0.02947152f, -0.01625683f, 0.55848002f, 
    -0.15045337f, 0.28147840f, -0.38603878f, 0.06992815f, 0.21816140f, 0.10660296f, -0.02833834f, 0.11352389f, 
    -0.15519531f, -0.20660159f, 0.11657494f, -0.03947752f, 0.07800985f, 0.06377872f, -0.23051900f, 0.04523073f, 
    -0.01170766f, -0.08152032f, 0.57555419f, 0.21774419f, 0.16983317f, -0.24438138f, -0.21055770f, -0.06387214f, 
    0.15950492f, 0.07307205f, -0.05310104f, 0.06397983f, 0.32351524f, -0.23296143f, 0.08108476f, -0.11702655f, 
    0.08380001f, -0.03744066f, 0.08752461f, -0.11432159f, 0.29254133f, -0.02143735f, 0.14271422f, -0.10658945f, 
    0.59044600f, 0.24213894f, 0.33582410f, -0.32442674f, -0.05787311f, 0.11181618f, -0.12550101f, -0.09284519f, 
    0.31572896f, 0.09217511f, 0.15731543f, 0.22760914f, 0.04979951f, -0.26302534f, -0.45763895f, -0.35221109f, 
    -0.04246633f, 0.01699078f, 0.21544576f, -0.29244053f, -0.13262261f, 0.00709290f, -0.17198610f, 0.11275867f, 
    -0.19727409f, 0.05673267f, 0.02828062f, -0.21082982f, -0.00005890f, 0.19388562f, -0.16234969f, -0.21953623f, 
    -0.39796165f, 0.06572426f, -0.00097704f, -0.23711489f, -0.18093070f, 0.10762093f, -0.20953235f, 0.16440150f, 
    -0.23251398f, -0.23297283f, -0.19773860f, 0.16805317f, 0.12536834f, 0.18969738f, -0.08782048f, -0.23816791f, 
    0.05677812f, 0.10445506f, -0.17600623f, -0.09140449f, -0.01328227f, 0.21943629f, -0.05736863f, 0.07765369f, 
    0.21708088f, 0.07629686f, -0.13499209f, -0.22378074f, 0.29960784f, -0.07462974f, -0.26501319f, -0.01594553f, 
    0.21281587f, 0.13664229f, 0.11294861f, -0.25333253f, -0.17195255f, 0.22153328f, 0.12848356f, 0.08141682f, 
    0.00483094f, 0.11693296f, 0.09887827f, 0.08403906f, -0.01591043f, 0.04173984f, 0.40475562f, 0.26356247f, 
    0.24509339f, 0.07648931f, -0.04639780f, 0.07412419f, 0.13063663f, -0.25939026f, -0.43813884f, -0.16407543f, 
    0.08748115f, 0.11101194f, 0.19656892f, -0.14637226f, 0.02384196f, -0.24135287f, -0.02188453f, 0.23847860f, 
    0.00911707f, 0.15615502f, 0.02749678f, 0.09272595f, 0.19382845f, 0.14583807f, 0.38403443f, 0.12100492f, 
    -0.30493024f, -0.36312720f, -0.01397525f, 0.10758524f, -0.12766059f, -0.02710306f, 0.07050297f, -0.16686971f, 
    0.06971676f, -0.12707163f, 0.02202358f, 0.10314800f, 0.04664756f, -0.03845102f, 0.00295854f, -0.04736375f, 
    -0.02664142f, -0.05373432f, -0.23000586f, 0.23759270f, 0.16292572f, -0.07452617f, -0.01447035f, 0.08348320f, 
    0.10635987f, -0.09505773f, -0.00633325f, -0.03147500f, -0.34873679f, 0.29021621f, -0.07774755f, 0.17790771f, 
    0.13810433f, 0.15320250f, 0.05405008f, -0.03581668f, 0.26950529f, -0.16068305f, 0.05326582f, -0.15468125f, 
    0.09655757f, 0.27788174f, 0.05891121f, -0.05960041f, -0.15003662f, -0.05602129f, 0.10726274f, 0.00961335f, 
    -0.16935816f, -0.07105572f, -0.00499865f, 0.11877647f, -0.12551965f, -0.05268018f, 0.23958346f, 0.05342729f, 
    -0.15246370f, -0.26258633f, 0.00600714f, -0.32376304f, -0.40974674f, -0.19023992f, 0.03447642f, -0.11884678f, 
    -0.19638512f, -0.10083794f, 0.01306807f, 0.00926961f, 0.28782558f, 0.25112930f, 0.27197996f, 0.04656636f, 
    -0.13300949f, -0.06658226f, 0.20228253f, 0.13480298f, 0.11122292f, 0.14213306f, -0.05298625f, -0.26872849f, 
    -0.16478342f, -0.18229458f, -0.23312922f, -0.21356750f, -0.20973329f, -0.17790295f, -0.11399073f, -0.11998384f, 
    0.23209183f, -0.56951118f, -0.79639304f, -0.29688752f, 0.01887412f, -0.05656640f, -0.42388114f, -0.16413513f, 
    -0.12890753f, 0.11075468f, 0.35137534f, -0.20719247f, -0.04567136f, -0.01237870f, -0.12459830f, 0.10418250f, 
    -0.04917847f, -0.03779126f, 0.12189568f, -0.11182185f, 0.21506698f, -0.01561770f, -0.00323172f, -0.01334592f, 
    -0.08182500f, -0.11078392f, 0.08914816f, 0.18430448f, 0.40510002f, 0.34569353f, 0.08715518f, 0.16805866f, 
    0.24198706f, 0.13830805f, 0.09829252f, 0.20609865f, 0.14955932f, -0.45253548f, 0.08156277f, -0.18281589f, 
    -0.15868559f, 0.02188287f, -0.19596666f, 0.05906716f, 0.01232825f, 0.05667929f, -0.52966255f, 0.13370678f, 
    -0.09889966f, -0.09574315f, -0.02593883f, -0.04804338f, 0.10799133f, -0.11919115f, -0.07131327f, -0.24583863f, 
    0.03846956f, 0.18123299f, 0.03807137f, -0.11525029f, 0.00187171f, 0.07447217f, 0.19178890f, 0.00101850f, 
    0.38139135f, -0.32703486f, -0.36615431f, -0.04115305f, 0.00931962f, -0.09876795f, -0.04900017f, -0.00076983f, 
    0.04973691f, 0.36273217f, 0.04641276f, -0.21700042f, 0.09911389f, -0.16035253f, -0.15576191f, 0.09547110f, 
    0.18789425f, 0.26672369f, -0.21704209f, -0.41450113f, -0.00012247f, 0.12155098f, 0.09766683f, -0.00262781f, 
    0.09945422f, -0.01384550f, 0.08338942f, 0.57135463f, -0.65590292f, -0.01290812f, 0.24717085f, 0.19325413f, 
    0.24500355f, 0.12965845f, -0.06392901f, 0.16648839f, -0.66802883f, -0.30341110f, -0.23938636f, -0.46147522f, 
    -0.14416680f, -0.13495201f, 0.15738563f, -0.11708136f, 0.09276804f, -0.17506249f, 0.17994232f, 0.45370916f, 
    0.02736951f, -0.01177884f, 0.12525587f, 0.19666223f, -0.14019200f, 0.09178182f, 0.26958513f, -0.34968364f, 
    -0.35657221f, -0.20380023f, -0.07172269f, -0.05373174f, 0.15971999f, 0.15457833f, -0.16209649f, -0.49312913f, 
    0.03693195f, 0.09490395f, -0.00652441f, -0.08801962f, -0.06958348f, -0.01143754f, -0.20531999f, 0.04893998f, 
    -0.37339479f, 0.10442866f, -0.05415259f, -0.23630938f, 0.11215786f, -0.17272578f, 0.21682669f, 0.06991326f, 
    -0.14162380f, 0.04217324f, 0.18656090f, 0.31253782f, 0.07423680f, 0.09040997f, -0.01075236f, 0.21955472f, 
    -0.00065030f, -0.09659421f, -0.17989632f, -0.20076168f, -0.10706145f, 0.15466867f, 0.13427411f, -0.04933091f, 
    -0.16021860f, 0.06489691f, 0.06436680f, -0.32902396f, -0.23769112f, -0.03976169f, -0.16764247f, 0.04139949f, 
    0.03439409f, -0.10666513f, -0.00580350f, 0.21905258f, -0.34272075f, 0.01156482f, 0.18813993f, 0.09032118f, 
    0.02179744f, 0.05101814f, -0.22494175f, 0.07607850f, 0.21312520f, -0.21030377f, -0.27181047f, 0.05322110f, 
    0.05138263f, 0.14005579f, 0.05982842f, 0.02010933f, -0.36007813f, -0.28710559f, 0.26669806f, 0.19713557f, 
    0.19613287f, -0.00840352f, 0.07249643f, -0.01051058f, 0.18975772f, -0.06440247f, -0.10387721f, -0.08515445f, 
    -0.21513283f, -0.03799593f, 0.03544185f, -0.04761168f, 0.27187744f, -0.24250567f, 0.12900558f, 0.19822380f, 
    0.23143561f, 0.00843339f, 0.40044084f, 0.06843600f, 0.16783813f, 0.25523749f, -0.02984445f, -0.09871727f, 
    -0.23235135f, -0.26773936f, -0.12882553f, -0.13644671f, 0.06856418f, 0.00102654f, 0.14132801f, -0.20072475f, 
    0.10465678f, -0.05787210f, -0.02095554f, 0.05655216f, 0.20523988f, -0.03344686f, 0.04551275f, 0.13050748f, 
    0.04482510f, 0.27554440f, 0.07143953f, -0.04667215f, 0.29282832f, 0.31979993f, 0.39285499f, 0.32327417f, 
    0.02170799f, 0.08388855f, 0.10452148f, 0.00512262f, 0.30668667f, -0.04985461f, -0.04378630f, 0.15236710f, 
    0.05912955f, 0.00562465f, 0.27250707f, -0.04736038f, -0.00703764f, -0.18861510f, 0.14336550f, 0.10171884f, 
    0.18958250f, -0.02329911f, -0.27436498f, 0.14258584f, -0.09416957f, -0.17336710f, 0.12690559f, 0.37923574f, 
    0.14571500f, 0.03071540f, 0.07500225f, -0.16877377f, -0.02607020f, 0.11758979f, 0.11697949f, -0.18672687f, 
    -0.24293001f, 0.06400365f, 0.33197588f, -0.18514481f, -0.15830171f, -0.28050011f, -0.13818341f, -0.00458864f, 
    -0.04997943f, 0.08249138f, 0.18365252f, 0.03595743f, -0.00217740f, -0.08373428f, 0.25055966f, 0.08271481f, 
    0.22915561f, -0.11812521f, 0.40007028f, -0.25767168f, -0.11395074f, -0.03464084f, -0.25979868f, 0.00838394f, 
    -0.03371755f, -0.11240122f, 0.04246288f, -0.17926867f, -0.13701616f, 0.13303007f, -0.02915537f, 0.19842194f, 
    0.12515746f, -0.04256795f, -0.10912699f, 0.71040726f, -0.20917302f, -0.28584522f, -0.00316722f, 0.03786543f, 
    0.00402563f, 0.07281560f, 0.05522015f, -0.17579661f, 0.12402895f, 0.11361944f, 0.37104687f, 0.04934562f, 
    0.34451994f, 0.12513770f, 0.17689060f, 0.19993910f, 0.10869554f, -0.24747275f, -0.36555529f, -0.57482940f, 
    -0.31383634f, 0.08496780f, 0.02578145f, -0.01354742f, 0.06246142f, 0.10747503f, -0.38848487f, 0.56975394f, 
    0.29115376f, -0.08434337f, 0.06961602f, -0.13926852f, 0.00402598f, -0.07813870f, -0.03826533f, 0.54408103f, 
    0.14044255f, -0.08902480f, 0.23153113f, 0.02750034f, 0.09608230f, 0.25712290f, -0.00951517f, 0.05592363f, 
    -0.90553427f, -0.44350144f, -0.15894081f, 0.05230622f, 0.03508162f, -0.09035758f, 0.06463937f, 0.14638908f, 
    0.15728383f, 0.01624091f, 0.29401800f, 0.18348624f, 0.00727284f, -0.10231985f, 0.12461492f, 0.08260805f, 
    0.10405184f, 0.13503629f, -0.49387392f, -0.83096784f, -0.85749418f, 0.11091285f, -0.02645551f, 0.06247760f, 
    0.12206203f, -0.09279112f, -0.06444094f, -0.13678089f, -0.17891455f, 0.08502866f, 0.03947195f, 0.22036512f, 
    0.11232866f, 0.26997045f, 0.08692388f, 0.15204296f, 0.06806432f, 0.07197512f, 0.66697830f, -0.31660596f, 
    -0.33266681f, -0.31284881f, -0.06543189f, 0.13990036f, 0.23145427f, -0.26457492f, 0.03234410f, -0.00226621f, 
    0.07547115f, -0.10405327f, -0.10082567f, 0.11967443f, 0.21529417f, 0.50041586f, 0.05830658f, -0.13365749f, 
    -0.35750777f, -0.09230583f, 0.03881556f, 0.04531455f, -0.22815385f, -0.15788211f, -0.31802064f, -0.21624130f, 
    0.00074572f, 0.07771107f, -0.11221790f, -0.31978261f, -0.11829131f, -0.09672213f, -0.13367422f, 0.27751306f, 
    0.09128166f, 0.40060288f, -0.15443714f, -0.02321894f, 0.01564534f, -0.10786499f, -0.08080718f, -0.29467496f, 
    0.13598877f, 0.06696922f, -0.26366812f, 0.21296883f, 0.02436449f, -0.13780072f, -0.24939017f, -0.05373431f, 
    0.15233995f, -0.01945617f, 0.01340584f, 0.02283705f, -0.05860000f, -0.04808272f, -0.09868900f, 0.06316879f, 
    -0.06342054f, 0.09837629f, -0.05518835f, 0.15967214f, 0.28652096f, -0.03031768f, 0.14395660f, -0.21055624f, 
    0.00585671f, 0.03347408f, 0.00197682f, -0.14727141f, 0.17670012f, 0.03064934f, -0.15421028f, 0.10645573f, 
    -0.12640435f, -0.13813201f, 0.01942560f, 0.20121042f, 0.04710385f, 0.96236414f, -0.36837751f, 0.35528746f, 
    0.05359972f, -0.18960461f, -0.06157914f, -0.10562811f, -0.03374294f, 0.20494182f, -0.17629656f, -0.34332335f, 
    0.07745151f, -0.10121842f, -0.23592438f, 0.11479688f, -0.09829061f, 0.09752198f, 0.01944087f, -0.13669704f, 
    0.09496484f, 0.32667139f, -0.23870409f, 0.12939441f, -0.10671463f, 0.16546737f, -0.16203283f, 0.14389032f, 
    0.09990092f, 0.24565965f, 0.65013391f, 0.19132333f, -0.18451984f, 0.08723985f, 0.24587594f, -0.00109307f, 
    0.16961348f, 0.24582256f, 0.12262198f, 0.13083941f, 0.35275459f, 0.03336675f, -0.06997935f, -0.11002713f, 
    -0.01291843f, 0.25088364f, 0.01167629f, 0.17434445f, 0.59961742f, 0.13039993f, 0.12476142f, 0.00319425f, 
    0.01923812f, -0.19228634f, 0.04167150f, 0.10962095f, -0.06648553f, 0.14465839f, 0.09704984f, -0.37018645f, 
    0.14571540f, 0.05189112f, -0.07514960f, 0.35934976f, -0.28291711f, 0.03879571f, 0.20227304f, 0.17524853f, 
    -0.00550329f, 0.26213965f, 0.02679116f, -0.07768023f, 0.05430346f, -0.41461843f, -0.06503409f, -0.27149668f, 
    0.06833105f, -0.05481360f, 0.31787243f, 0.09216156f, 0.05047562f, 0.32911381f, -0.07067938f, -0.27921453f, 
    -0.20770763f, -0.05112660f, -0.21987839f, -0.04940028f, -0.06970253f, -0.28174707f, -0.23255610f, -0.15683062f, 
    0.10883038f, -0.15467571f, -0.07256907f, 0.17810710f, 0.01897929f, 0.20666957f, -0.02929795f, 0.16955133f, 
    -0.19707730f, -0.55988151f, -0.46793476f, 0.01796687f, 0.01334064f, -0.34203193f, -0.04387179f, -0.02224248f, 
    0.20068854f, -0.01399810f, 0.10542011f, -0.01382526f, 0.00467481f, -0.10161906f, 0.08440922f, 0.17291299f, 
    -0.16941696f, -0.07906525f, -0.12890083f, 0.21343827f, -0.33270240f, 0.10182761f, -0.15457545f, 0.07916567f, 
    0.07271097f, 0.10716398f, 0.21510538f, -0.22554553f, -0.45516941f, -0.12972763f, -0.10530230f, -0.14777184f, 
    0.01295089f, -0.30048528f, 0.05020145f, 0.21168165f, -0.05519159f, -0.06198836f, -0.06191261f, 0.00513820f, 
    0.16879414f, -0.06332055f, 0.26381031f, 0.17668384f, -0.01647409f, -0.31260735f, -0.07139885f, 0.10255597f, 
    0.07380440f, -0.19396619f, -0.02048350f, -0.25214511f, -0.13623635f, -0.28932518f, -0.31722030f, -0.04215317f, 
    0.42600691f, 0.09498611f, 0.07450020f, 0.13753448f, -0.17418462f, 0.20742536f, -0.12751819f, -0.16046467f, 
    0.18951884f, -0.22228594f, 0.07990319f, -0.12954889f, 0.15521045f, -0.06727183f, 0.12899046f, 0.11173072f, 
    0.12796162f, 0.36416861f, 0.16420977f, 0.06403052f, -0.16599992f, 0.32655045f, 0.02086053f, 0.23785788f, 
    -0.01203449f, 0.11584860f, 0.02055333f, -0.80864710f, 0.42886448f, -0.11036875f, 0.02721635f, 0.23554252f, 
    0.25967020f, 0.53901052f, 0.10186870f, 0.02560437f, -0.10349368f, -0.16767187f, -0.27919811f, 0.03845866f, 
    -0.10171298f, -0.13017994f, 0.05061402f, 0.06058216f, 0.29796997f, -0.35354117f, 0.03931637f, 0.19288389f, 
    0.07632639f, 0.23130769f, 0.21330200f, 0.17514946f, 0.12914751f, 0.26973370f, 0.28162304f, 0.11670229f, 
    -0.01732750f, -0.02521632f, 0.28282264f, 0.11288164f, -0.21085979f, 0.24399129f, 0.50350308f, 0.03747619f, 
    0.44133735f, 0.34512290f, 0.25349388f, 0.20342921f, 0.29800549f, 0.12134341f, 0.23336402f, -0.07314426f, 
    -0.48719984f, -0.06443240f, -0.22426176f, 0.00196868f, -0.15666088f, -0.17906079f, -0.17155564f, 0.21629739f, 
    -0.49551213f, -0.44602823f, 0.06271616f, -0.16367303f, 0.12264299f, 0.13444944f, 0.09209823f, 0.06536033f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.02503202f, -0.11826217f, -0.05893227f, 0.17348945f, 0.05202754f, 0.26603755f, 0.10700111f, 0.07466536f, 
    -0.29702362f, 0.08132323f, 0.29971117f, 0.45523077f, 0.17231473f, 0.40674058f, 0.17558360f, 0.29852745f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06507829f, -0.17173924f, -0.42404863f, -0.21504599f, 0.09866709f, 0.07623953f, -0.38793528f, 0.38933727f, 
    0.09533368f, 0.34281263f, 0.29320124f, 0.65168864f, 0.00887179f, -0.17320202f, 0.46724522f, 0.11599453f, 
    0.17789954f, -0.19698814f, -0.17031524f, 0.11119366f, -0.10222828f, -0.19178131f, 0.11982507f, 0.07570872f, 
    -0.23028153f, -0.13252777f, -0.07465792f, -0.00170207f, 0.17418671f, -0.05489272f, -0.04367527f, -0.16056359f, 
    0.00136438f, -0.04021047f, -0.11002157f, 0.59945458f, -0.04296675f, 0.12267406f, -0.01588144f, -0.19960424f, 
    -0.14226951f, -0.15519306f, 0.26302040f, 0.67991054f, -0.01080035f, -0.69947815f, 0.37997356f, 0.21265516f, 
    -0.04034619f, 0.30581877f, 0.24424189f, -0.26091433f, -0.18929943f, 0.28740132f, 0.25487226f, 0.49515128f, 
    -0.19809292f, 0.82698756f, -0.19050755f, -0.25662270f, 0.56816679f, -0.27649948f, -0.14029665f, -0.24941121f, 
    -0.27719653f, 0.03883205f, -0.35851735f, 0.01289472f, 0.28664342f, 0.27536038f, 0.57149881f, 0.18915229f, 
    0.07042468f, 0.30832416f, 0.26570004f, -0.15569527f, -0.24473277f, -0.36571470f, 0.27108008f, -0.24735557f, 
    0.16517010f, -0.63858294f, 0.49258617f, 0.58150190f, 0.25172257f, 0.10571331f, 0.63234448f, -0.03815773f, 
    0.18536115f, 0.28799254f, -0.77043885f, -0.27981246f, -0.21143194f, 0.20856087f, -0.05637653f, 0.09589040f, 
    0.17515683f, 0.44159383f, -0.14007711f, -0.43250296f, -0.06769251f, 0.18356884f, 0.39647958f, -0.20867039f, 
    -0.09626625f, 0.55902874f, -0.18321556f, -0.98522365f, -0.39907840f, 0.11720037f, 0.51095819f, 0.24129276f, 
    0.13747561f, -0.48122275f, -0.41484576f, -0.11446296f, 0.20780399f, 0.76738340f, 0.21797357f, -0.33180481f, 
    -0.17345144f, -0.16989383f, 0.44934353f, -0.03537991f, -0.06068614f, 0.27624333f, 0.41100881f, -0.11857396f, 
    -0.06583883f, -0.19903600f, -0.22735256f, -0.16731431f, 0.30564034f, 0.48086342f, -0.18079990f, 0.11313374f, 
    0.12889372f, -0.07112502f, 0.22345008f, -0.27567762f, -0.20123369f, 0.28945711f, 0.05464312f, -0.03883658f, 
    -0.04014170f, 0.12048761f, 0.56213444f, -0.70415038f, -0.10118757f, 0.14586569f, 0.03442223f, 0.57190627f, 
    0.33265269f, -0.04468502f, -0.23803729f, -0.02113735f, 0.43829620f, -0.47577450f, 0.17168294f, 0.14271012f, 
    0.16727421f, -0.07171673f, -0.13623556f, -0.16410494f, -0.17406847f, 0.18482311f, -0.26593339f, 0.14782026f, 
    0.16007015f, -0.21818958f, 0.04087291f, -0.05235182f, -0.21828990f, -0.24551515f, -0.06843682f, 0.30613244f, 
    0.05632132f, 0.05136582f, 0.13155289f, -0.08824839f, 0.17005810f, -0.16229619f, 0.19533475f, 0.05786940f, 
    0.13683313f, -0.16558141f, -0.25474715f, -0.12578328f, -0.33768311f, -0.11188876f, -0.28039816f, -0.15990438f, 
    -0.10354990f, 0.20059846f, -0.43656889f, 0.60334402f, 0.20048566f, 0.06001862f, -0.11569327f, -0.30673325f, 
    0.25575024f, -0.21423869f, 0.13431892f, 0.30138060f, -0.23062709f, 0.29888266f, -0.23627985f, 0.19586623f, 
    0.11540818f, 0.23613881f, 0.46772194f, 0.23949058f, -0.58957154f, -0.26608372f, -0.21557896f, -0.29594269f, 
    -0.62018919f, 0.26064652f, 0.20178373f, 0.36657590f, 0.14890361f, 0.02475385f, 0.23788056f, 0.51025504f, 
    -0.21706116f, 0.16706900f, -0.54506308f, 0.31369808f, 0.14611854f, 0.19888325f, 0.29682016f, 0.05189475f, 
    0.07733407f, -0.09700281f, -0.01780739f, -0.13054101f, -0.31888762f, 0.08472303f, -0.10772843f, -0.32307911f, 
    -0.11313578f, -0.56134379f, -0.07376015f, -0.15992294f, -0.01471406f, 0.65218741f, 0.31814256f, 0.35632497f, 
    -0.86015683f, -0.35958663f, 0.04205181f, 0.67129803f, 0.28342432f, -0.13408433f, -0.05906839f, 0.35932955f, 
    -0.05355224f, -0.61471802f, -0.32966894f, -0.19459870f, 0.53606218f, 0.30277115f, 0.27501383f, 0.13198920f, 
    0.20244680f, 0.15587147f, -0.61911607f, 0.04707200f, -0.22666918f, 0.12544507f, 0.62199241f, 0.04329615f, 
    0.16299474f, 0.15523408f, 0.25698349f, 0.56451017f, -0.32545301f, -0.02373304f, 0.46320525f, -0.28860736f, 
    0.34542802f, 0.18490382f, -0.31969827f, -0.40972021f, 0.38094136f, -0.23785095f, -0.21184707f, 0.55603433f, 
    0.10999531f, -0.02665501f, -1.07113695f, -0.21908598f, 0.15536070f, 0.13240859f, 0.14660850f, 0.28125158f, 
    -0.51540762f, 0.55180097f, -0.00782405f, 0.24085338f, -0.40269402f, 0.36919674f, 0.22301781f, -0.28995949f, 
    -0.10231765f, 0.15732644f, 0.21150905f, -0.38913557f, 0.13302556f, -0.38247621f, -0.71331245f, 0.75552732f, 
    -0.41914654f, 0.04953259f, 0.03139234f, 0.29631633f, 0.06413323f, 0.37953711f, 0.19900359f, -0.10429408f, 
    0.18859980f, -0.33603087f, 0.21957296f, 0.32881877f, -0.12938294f, -0.20931627f, -0.39564440f, -0.25076988f, 
    -0.30897936f, 0.27917421f, 0.49399346f, 0.35623091f, 0.27511254f, -0.36341509f, 0.07605544f, 0.51698226f, 
    -0.14173779f, 0.16661641f, 0.23692563f, 0.17154703f, -0.04512741f, 0.45439345f, 0.39694923f, -0.48611510f, 
    0.54903096f, 0.24604754f, -0.04667327f, -0.55885142f, 0.53107136f, -0.21177408f, 0.06925856f, 0.02387248f, 
    -0.15769745f, -0.05513335f, -0.21127617f, -0.39999744f, 0.19137579f, -0.23927560f, -0.35243538f, 0.25936002f, 
    0.29131585f, 0.19284986f, -0.06571687f, -1.08258724f, 0.07327808f, -0.08743228f, 0.30702713f, 0.43793124f, 
    -0.09368287f, -0.01376565f, -1.07359374f, 0.01587709f, 0.12693039f, -0.81021416f, -0.20360349f, 0.30260211f, 
    -0.06156426f, 0.09676583f, 0.09671073f, 0.79645008f, -0.33790192f, 0.58175933f, 0.13189696f, 0.10091155f, 
    0.09794679f, 0.19551772f, 0.41793481f, 0.41399875f, 0.27239937f, -0.06774325f, 0.20802210f, -0.44057551f, 
    0.29242924f, 0.22457890f, -0.09025370f, -0.74397147f, -0.14204493f, -0.23770918f, -0.37113720f, -0.00249025f, 
    0.04169199f, -0.19050969f, -0.21568957f, -0.13387875f, -0.03239186f, 0.02477207f, -0.13755715f, -0.11322078f, 
    0.20083399f, -0.18179098f, 0.05108998f, 0.14909784f, -0.10065009f, 0.02366209f, -0.12082363f, 0.10437907f, 
    -0.03646553f, -0.28291559f, 0.11216163f, -0.20014392f, 0.20404679f, 0.39830574f, 0.27330232f, 0.13676491f, 
    0.39196169f, -0.37216282f, -0.27862895f, -0.40783504f, -0.00086170f, 0.30036515f, 0.15852001f, 0.50928664f, 
    0.18222685f, 0.17300601f, -0.23027849f, 0.11299348f, -0.39635777f, -0.02243418f, 0.01262431f, -0.40495405f, 
    0.56748599f, 0.10578802f, 0.33731306f, 0.67202163f, 0.31625915f, -0.27953514f, 0.22639810f, 0.19557151f, 
    -0.12593801f, -0.12725882f, 0.59257609f, 0.13246793f, -0.25326285f, -0.51773059f, -0.30991283f, 0.08117186f, 
    0.35117340f, 0.16162308f, 0.13209367f, 0.53213805f, 0.52628577f, 0.10324967f, -0.36681291f, 0.17189559f, 
    0.09210627f, 0.23339540f, 0.11361864f, 0.06374142f, -0.03684653f, 0.08016559f, 0.36634952f, -0.07885478f, 
    -0.72306204f, 0.54817712f, 0.10519227f, 0.09562282f, 0.32623994f, 0.36464497f, -0.13928348f, -0.14953893f, 
    -0.00928929f, -0.25287580f, 0.37151885f, 0.45178390f, 0.18695356f, 0.09402424f, 0.41455537f, -0.04475771f, 
    -0.33615333f, -0.51030833f, 0.15407518f, 0.12747879f, -0.34736925f, 0.67997324f, 0.05098876f, 0.39416727f, 
    -0.01153117f, -0.55183619f, -0.25725141f, 0.25351664f, 0.40585932f, -0.21224102f, -0.71381700f, -0.09014016f, 
    0.08506799f, 0.18177055f, 0.27675390f, 0.89233935f, -0.08011330f, -0.52384090f, 0.01152458f, 0.20364581f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.23859468f, -0.21550983f, 0.00856864f, 0.28067112f, -0.55728346f, -0.20231089f, 0.10055017f, 0.49426684f, 
    0.48043263f, -0.08691681f, 0.21767323f, -0.15451930f, -0.00054136f, 0.06701987f, 0.23429123f, 0.58386189f, 
    0.23229161f, 0.21842265f, 0.44319785f, 0.10719413f, 0.14673641f, 0.11222600f, 0.27763173f, 0.38823870f, 
    -0.30657783f, -0.11649670f, -0.05934322f, -0.18211713f, 0.21224621f, 0.30775359f, 0.15564442f, 0.07890868f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.72595394f, 0.04398620f, 0.13832481f, -0.09144179f, 0.09948553f, 0.44663385f, -0.44771466f, -0.59811419f, 
    -0.33800420f, -0.13193600f, 0.02234895f, -0.13803139f, 0.00493752f, 0.13143337f, 0.02357633f, -0.02414497f, 
    -0.02427005f, 0.27393892f, -0.28965959f, -0.06608663f, 0.12690091f, 0.00525900f, -0.55246395f, -0.17289618f, 
    0.45686883f, -0.10956104f, -0.06767057f, -0.17071784f, 0.17140083f, 0.08216479f, 0.47484678f, -0.02755949f, 
    -0.18306349f, 0.09303173f, -0.05243954f, -0.02197029f, -0.40920037f, -1.75130188f, 0.13412477f, -0.42402002f, 
    -0.17347169f, -0.02279914f, 0.08131137f, -0.08237373f, -0.00688539f, 0.49342531f, -0.04564473f, 0.30967078f, 
    -0.99995863f, 0.47004500f, 0.20675650f, -0.17145912f, 0.16908912f, 0.21870039f, 0.12687929f, 0.28547168f, 
    -0.34427178f, 0.02780260f, 0.02309517f, 0.10477751f, 0.27430585f, 0.07099492f, -0.01561321f, -0.57141185f, 
    0.12340441f, 0.14282772f, 0.43506283f, -0.63041574f, -0.20224984f, -0.92740530f, -1.04984844f, 0.22772820f, 
    0.13697085f, 0.04677743f, -0.03964454f, 0.10558660f, 0.15783000f, -0.27763095f, 0.29433450f, 0.81030273f, 
    0.15486382f, -1.07376158f, -0.21767105f, 0.09595576f, 0.16888618f, -0.51680315f, -0.14912887f, 0.24930260f, 
    0.15569852f, -0.13501455f, -0.13243264f, -0.04365638f, 0.03258979f, -0.26475367f, 0.42100158f, 0.51428384f, 
    0.00689388f, 0.05678641f, 0.35078764f, -0.53779775f, 0.11277097f, 0.05287934f, -0.40151846f, -0.06501474f, 
    -0.10158212f, -0.05089606f, -0.12509559f, 0.14426510f, 0.33286211f, -0.35081592f, -0.08356844f, -0.11761977f, 
    0.39195424f, 0.24172460f, -0.62817538f, -0.43562457f, 0.08156814f, 0.10024006f, 0.09924857f, -1.13319087f, 
    -0.19747984f, -0.07843310f, 0.25916585f, 0.26010489f, -0.09062852f, -1.26000750f, -0.13958362f, 0.62442255f, 
    -0.27173808f, -0.02301939f, -0.37935024f, 0.51896596f, 0.17652705f, -0.00473754f, 0.02173972f, 0.21166512f, 
    0.02767506f, 0.27001867f, -0.14106137f, -0.12989247f, 0.07553290f, -0.78560865f, 0.10098221f, 0.32486773f, 
    0.34235531f, 0.14084736f, -0.27608746f, -0.43515491f, -0.45882565f, 0.19089536f, -0.20151986f, -0.23715442f, 
    -0.08235509f, -0.13886029f, 0.15596618f, -0.14823215f, -0.17393805f, 0.08127391f, -0.06335648f, -1.71106803f, 
    0.00144027f, 0.02242231f, 0.27220365f, 0.15675645f, 0.21618582f, -0.28404060f, 0.40218431f, 0.01320527f, 
    -0.15607266f, 0.22915684f, -0.27345091f, -0.05875181f, -0.10129976f, 0.40312532f, -0.01716122f, 0.27097160f, 
    -0.55847508f, -0.14877196f, -0.58913136f, -0.00484720f, 0.08352922f, -0.02145595f, -0.04534071f, -0.29944575f, 
    -0.28695029f, 0.00838853f, -0.12225134f, 0.23705639f, -0.08762117f, 0.10674886f, -0.03959733f, -0.56133211f, 
    -0.03502228f, -0.09157271f, -1.38904941f, -0.68355167f, -0.19449815f, -0.69692636f, -0.08195363f, 0.37379619f, 
    0.23933230f, -0.74658155f, -0.06632384f, -0.17249605f, 0.10815246f, -0.26620224f, -0.25580844f, -0.98758173f, 
    0.06600802f, -0.20415075f, 0.32678959f, 0.40846685f, -0.44782627f, -0.89365518f, 0.01464359f, 0.60080731f, 
    0.17938995f, 0.01792738f, -0.00176096f, -0.75824916f, -0.15797965f, 0.04248149f, 0.71466768f, 0.12737639f, 
    0.06290011f, 0.02074714f, -0.54560566f, 0.10659160f, 0.05537957f, -0.05301711f, 0.39456061f, -1.29304600f, 
    -0.00675607f, 0.40580413f, 0.07139202f, 0.03022578f, -0.16796541f, -0.53773654f, -0.22095013f, -1.09739816f, 
    0.59179741f, 0.07152957f, -0.22991195f, 0.05194468f, -1.45701575f, 0.07460890f, 0.26743969f, -0.21206172f, 
    -0.03642052f, -0.09339552f, 0.19995002f, 0.25616521f, -0.01102749f, -0.32282755f, -0.91857308f, -0.25261006f, 
    0.21171936f, -0.10770113f, 0.64874882f, 0.09297422f, -0.10167915f, -0.68634737f, -0.37350535f, 0.44148973f, 
    -0.01569532f, -0.64313889f, 0.09909149f, 0.06188290f, -0.03775740f, 0.00641750f, -0.21325718f, -0.90555781f, 
    -0.81564695f, -0.10376034f, 0.11123754f, -0.04518181f, 0.41231063f, -0.01100691f, -0.37479427f, 0.21322729f, 
    -0.77956772f, 0.02051812f, -1.12158978f, 0.45977405f, 0.37896824f, 0.09390578f, -0.65581840f, 0.56140590f, 
    0.06304232f, -0.12362785f, -0.16196512f, -0.62183356f, 0.07429460f, -0.87122315f, 0.27385768f, 0.73665696f, 
    0.53666627f, -0.63624680f, -0.07611816f, -0.10468078f, 0.19035760f, -0.45845774f, 0.25549749f, -0.14342681f, 
    0.45927352f, -0.84064579f, 0.11852333f, -0.17258282f, -0.18243612f, 0.01029282f, 0.19590238f, -0.26586589f, 
    -0.89601558f, 0.07498667f, 0.20077983f, -0.12019273f, -0.54572952f, -0.16656525f, 0.35664767f, -0.02707228f, 
    0.07376064f, 0.05653005f, -0.52160519f, 0.56671292f, -0.33760974f, -0.41123122f, -0.69652933f, -0.80264330f, 
    0.18964060f, 0.67263931f, 0.01448279f, 0.12124596f, -0.75383312f, 0.16828822f, -0.42114225f, -0.67360353f, 
    -0.53348434f, -0.25672832f, -0.35631865f, 0.42530873f, 0.10978194f, 0.08455553f, 0.30326253f, -0.47289577f, 
    0.50419742f, 0.14823909f, -0.10656925f, 0.01378531f, 0.65410286f, -0.23762912f, -0.89764100f, -0.19912001f, 
    0.16163686f, -0.14244425f, 0.01898625f, 0.59320128f, 0.13582230f, -0.51142675f, 0.32584429f, -0.09234890f, 
    0.02114467f, -0.25755757f, -0.10407373f, 0.00706138f, -0.59486276f, 0.20099065f, -0.07226788f, 0.05341959f, 
    0.05117350f, -0.58739877f, 0.55399704f, 0.20500229f, 0.01012250f, -0.47444215f, 0.10763613f, 0.03365476f, 
    -0.55623269f, -0.04386489f, -0.62756729f, -0.49130869f, -0.42737228f, 0.25823840f, -0.58798677f, 0.29260278f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.29031703f, 0.45044795f, 0.22549592f, -0.08230702f, 0.05212716f, 0.03095298f, -0.23745839f, -0.49154672f, 
    -0.06401306f, 0.30792189f, 0.07921776f, 0.13115714f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
