#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.37124968f, 0.66549551f, 0.64549100f, -0.60174793f, 0.27740413f, 0.83148754f, 0.32047442f, -0.33858657f, 
    0.29148200f, -0.26186284f, 0.08490555f, 0.16998777f, 0.18781516f, 0.16589396f, -0.18188663f, -0.35686746f, 
    -0.19667690f, -0.32854462f, -0.15583290f, -0.24428101f, -0.11298508f, -0.02086717f, 0.00777387f, 0.05893993f, 
    -0.03722987f, 0.89800853f, 0.92115170f, 0.06664247f, -0.26001966f, 0.22601122f, 0.48649454f, -0.11971210f, 
    -0.79742301f, 0.02653666f, 0.16370560f, 0.28379163f, 0.24709222f, 0.11422441f, 0.25673974f, -0.24037318f, 
    0.01864443f, 0.22182734f, 0.21974576f, 0.09417511f, -0.12294146f, 0.14648156f, 0.11343038f, -0.08152573f, 
    -0.21920219f, 0.16688880f, -0.04505214f, -0.85902500f, -0.19251075f, 0.84147823f, 0.16785301f, -0.59457749f, 
    -0.06441466f, -0.22739579f, -0.10155772f, -0.15950873f, 0.44284257f, 0.43420881f, 0.33595267f, -0.00232168f, 
    -0.07042959f, -0.15105079f, -0.02377531f, -0.33861688f, -0.11657955f, -0.18363197f, -0.27243310f, -0.22262782f, 
    -0.08151657f, 0.13691396f, 0.03289280f, -0.41625601f, -0.97301847f, 0.65780872f, 0.71595556f, -0.59783322f, 
    -0.09589040f, 0.27766505f, 0.39818275f, 0.04328952f, -0.24037036f, 0.08577804f, -0.07590974f, -0.10186993f, 
    0.26481938f, 0.16898365f, 0.08090833f, 0.23084287f, 0.18340397f, -0.25213367f, -0.06210037f, 0.06446543f, 
    0.14467703f, -0.08658747f, 0.16756950f, -0.13309555f, -0.81629831f, -0.17326114f, -0.37160546f, 0.10640366f, 
    0.48778611f, -0.20575941f, 0.92493600f, 0.02330833f, -0.01869639f, 0.48555952f, -0.24499945f, -0.07056765f, 
    -0.15120028f, 0.12481360f, 0.46734962f, -0.11973996f, -0.04639719f, -0.08655387f, -0.00326148f, 0.00922534f, 
    0.21022809f, 0.16187124f, 0.14105655f, 0.02834365f, 0.07659440f, 0.41143492f, -0.21700798f, -0.79579061f, 
    -0.66089934f, -0.72170901f, 0.35896999f, 0.76112878f, 0.46634582f, 0.38211802f, 0.42519307f, 0.07808358f, 
    0.09172344f, -0.14734474f, -0.16456027f, -0.13952938f, -0.04774855f, 0.16335736f, 0.18226238f, 0.17456791f, 
    -0.20038269f, 0.14619435f, 0.00205487f, 0.02343785f, -0.25491279f, 0.19974265f, 1.10883629f, 0.27880740f, 
    -0.05919521f, -0.26477885f, 0.07739943f, -0.55781931f, 0.03311439f, -0.39968601f, -0.17641465f, 0.21645960f, 
    -0.47723320f, -0.02432384f, 0.07466730f, 0.01239498f, 0.01756286f, -0.43982512f, -0.11115643f, 0.02321666f, 
    -0.32020608f, -0.04480967f, 0.20535684f, 0.14004956f, 0.19500183f, 0.07982229f, -0.04596711f, -0.85829848f, 
    -0.15211836f, -0.26921883f, -0.04351665f, 0.15554637f, -0.65858579f, 0.05931725f, 0.54823244f, -0.18374857f, 
    0.32674867f, 0.43520984f, -0.03565551f, 0.47006482f, -0.41168424f, 0.01258324f, 0.26961052f, 0.18621857f, 
    0.22335646f, 0.17389055f, -0.28263509f, -0.14024903f, 0.00506046f, -0.02212085f, -0.03030688f, -0.01663670f, 
    0.30135188f, 0.24117674f, 0.35362849f, 0.95380110f, 0.57827061f, 0.60749424f, 0.58423275f, 0.25304461f, 
    0.26796499f, -0.02325456f, -0.00588460f, 0.13131243f, -0.09730811f, -0.04850511f, -0.12363459f, -0.07962793f, 
    0.15215346f, 0.25668529f, -0.06756143f, 0.15982375f, 0.24705885f, -0.08114953f, 0.09919298f, 0.04434758f, 
    0.10118701f, -0.33338332f, -1.04524660f, -0.67860210f, -0.17334738f, 0.14506017f, -0.51332211f, 0.68225604f, 
    0.59609908f, -0.31021282f, -0.30514178f, -0.01489778f, -0.22511876f, -0.05455992f, -0.09584536f, -0.14033170f, 
    -0.14723735f, -0.07079620f, -0.21770312f, -0.16022867f, -0.14438996f, -0.10708376f, -0.02720915f, 0.12770599f, 
    -0.05087719f, 0.10929739f, -0.72833246f, 0.79280519f, -0.15662493f, -0.61311340f, 0.32986441f, 0.31447825f, 
    -0.27188328f, -0.49339959f, -0.35710621f, -0.57636720f, -0.07473174f, 0.14706847f, -0.16644441f, -0.12027268f, 
    -0.11649470f, 0.00161281f, 0.18851003f, -0.02595442f, -0.22532348f, -0.10652746f, 0.28007102f, 0.19203444f, 
    0.09097941f, 0.03992140f, 0.05736226f, -0.70563096f, -0.71496809f, -0.44591832f, -0.31773973f, -0.58040088f, 
    -0.09637371f, -0.22549742f, -0.18198369f, -0.22902937f, 0.13924409f, -0.14745480f, 0.28148377f, -0.16504969f, 
    0.07242093f, -0.13643773f, -0.05863249f, -0.06268264f, 0.19111231f, 0.03353450f, 0.17284152f, 0.11134800f, 
    0.05043933f, -0.25249484f, 0.07880999f, 0.11277181f, 0.54334742f, 0.53710294f, -0.47827739f, -0.53796095f, 
    -0.72275156f, 0.38528758f, -0.36096326f, 0.24394709f, 0.23680009f, 0.13265540f, 0.34110716f, 0.13525276f, 
    -0.14161439f, 0.17475511f, 0.18646759f, 0.26156554f, -0.15345611f, -0.15310173f, -0.03236278f, 0.51097560f, 
    0.07707418f, -0.05223537f, 0.24604397f, -0.11850941f, -0.23266363f, 0.76917672f, 0.65645689f, 0.64749473f, 
    0.65189028f, 0.86222029f, -0.49960363f, -0.37944025f, -0.00670991f, -0.32682973f, 0.22981167f, 0.22828804f, 
    0.02099767f, -0.24535888f, 0.12692370f, -0.01907515f, -0.10809208f, 0.14762548f, -0.19983137f, 0.00640864f, 
    -0.20477307f, 0.26054025f, -0.07251663f, -0.14933115f, 0.05433298f, 0.08860309f, 0.31576878f, -0.20700923f, 
    -0.48675328f, 0.27706221f, 0.97895038f, -0.13655438f, -0.67266345f, -0.39162469f, -0.37746695f, -0.08018332f, 
    0.15246379f, 0.31130707f, -0.30922109f, 0.03026622f, 0.00974473f, 0.19232132f, 0.10515723f, 0.36864480f, 
    0.21313253f, 0.39865512f, 0.12186828f, -0.10129651f, 0.14475405f, -0.08191462f, -0.30159169f, -0.69042343f, 
    0.43435752f, -0.04053238f, 0.01242306f, 0.16398017f, -0.55773354f, 0.60323268f, -0.39616710f, -0.63756526f, 
    -0.36666778f, 0.01024170f, 0.14629869f, 0.47091594f, 0.13249713f, 0.31951731f, 0.13255045f, 0.21781476f, 
    0.30007073f, 0.27485773f, -0.15989739f, -0.09018133f, -0.16583857f, 0.00480330f, 0.17334072f, 0.19122057f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09674924f, 0.17554021f, 0.01023117f, 0.16401181f, 0.05089176f, 0.15302302f, 0.13092238f, 0.07100605f, 
    0.19378944f, 0.04420363f, 0.09367123f, 0.03940485f, 0.16494302f, 0.23803897f, 0.30855352f, 0.37200880f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.21072882f, -0.30412471f, 0.09197886f, 0.21694860f, 0.03171539f, 0.02084789f, -0.02866910f, 0.04607751f, 
    0.03640528f, -0.08113592f, 0.02902055f, 0.13067588f, 0.28691733f, 0.09817179f, 0.03678941f, -0.09242490f, 
    0.05281538f, 0.00563700f, 0.07193194f, -0.12595119f, 0.05928227f, -0.02354117f, 0.00015390f, 0.01840115f, 
    0.11936565f, -0.34373757f, -0.03072217f, 0.09392142f, 0.06750377f, 0.01163632f, 0.09957980f, 0.02303396f, 
    0.00673397f, 0.08452273f, 0.14043912f, -0.05949121f, 0.04916718f, 0.01803440f, -0.06000851f, 0.05145366f, 
    -0.01557089f, -0.05622575f, 0.04018589f, 0.16900358f, 0.14711033f, -0.00653293f, -0.07319431f, -0.03344482f, 
    0.08574541f, 0.04845571f, 0.16768032f, -0.04876377f, 0.00752569f, 0.12674367f, -0.04622400f, -0.00992234f, 
    0.02159490f, -0.03677321f, 0.00832606f, 0.01359488f, 0.14118455f, 0.09308816f, -0.16777675f, 0.02772047f, 
    0.11625400f, -0.10784100f, 0.03300875f, 0.04981503f, -0.05792131f, -0.05389089f, -0.07691235f, 0.03569738f, 
    0.14128456f, 0.40835878f, -0.22740071f, -0.27065745f, 0.04926065f, -0.05425479f, 0.15312146f, -0.00085229f, 
    -0.03448457f, -0.00759272f, 0.00154468f, -0.04571404f, -0.19895881f, -0.14246538f, -0.03886271f, 0.01694830f, 
    -0.04213939f, -0.03717977f, -0.09135313f, 0.03852766f, 0.01330238f, -0.03936672f, -0.03379891f, 0.09615610f, 
    0.03647538f, -0.10758833f, 0.08137129f, 0.15178613f, -0.11137003f, -0.02356553f, 0.04172221f, 0.01530736f, 
    0.12024266f, 0.05834275f, -0.10464187f, 0.07267525f, -0.40468708f, 0.40005851f, -0.03387854f, 0.11600995f, 
    0.11659705f, 0.07620735f, 0.18096226f, 0.01090422f, 0.08039979f, 0.15214388f, -0.06454396f, 0.00307938f, 
    -0.14829944f, -0.11373369f, 0.23989625f, 0.12788260f, -0.01083379f, -0.08785737f, -0.02149718f, 0.07289890f, 
    0.09391832f, 0.04023141f, -0.03629610f, 0.12271946f, -0.27745304f, -0.14502043f, -0.10469414f, -0.14027113f, 
    -0.10285589f, -0.10875387f, 0.02381680f, -0.02280735f, 0.04863436f, -0.04662650f, 0.04655448f, -0.13510048f, 
    0.16157329f, 0.09901571f, 0.03690670f, -0.10195453f, -0.00451428f, 0.12243561f, 0.10778263f, 0.08071567f, 
    -0.01764312f, -0.11270224f, 0.04557312f, 0.00974912f, 0.19822763f, 0.04662481f, 0.06676650f, 0.07302945f, 
    -0.06394526f, 0.01544151f, 0.07950226f, -0.03311235f, -0.04676627f, -0.09146644f, 0.13045476f, 0.04881981f, 
    -0.01502524f, 0.04212265f, 0.17412871f, 0.05801968f, -0.03874099f, 0.12192771f, 0.05959638f, 0.05381155f, 
    -0.10260667f, -0.00080792f, 0.05349803f, 0.02866831f, 0.18694445f, 0.14469974f, -0.10101634f, -0.03513887f, 
    0.12830360f, -0.13422142f, 0.05245511f, 0.08242335f, -0.10718145f, 0.03095282f, 0.01071796f, 0.01341312f, 
    -0.05935382f, -0.01744745f, -0.05491746f, 0.05943970f, -0.07568792f, 0.01696957f, 0.05519881f, 0.01129658f, 
    -0.06959470f, -0.00986448f, 0.03420887f, -0.03309611f, -0.03028646f, -0.00082615f, 0.00016271f, -0.04032088f, 
    -0.05489199f, -0.04847562f, 0.03006948f, -0.02547032f, -0.02611968f, -0.07308895f, -0.02645798f, 0.02897003f, 
    -0.03846958f, -0.02135214f, 0.02095255f, 0.02574485f, 0.03708633f, -0.05743913f, 0.01122354f, 0.01463318f, 
    -0.04790714f, -0.00100380f, -0.01104635f, -0.06066122f, 0.01509503f, 0.05221843f, -0.04066959f, 0.00377339f, 
    -0.07378227f, 0.03505078f, -0.00617724f, 0.05233853f, 0.04323205f, 0.03163230f, -0.04428092f, 0.04831453f, 
    0.06649843f, -0.06676555f, 0.03176539f, 0.01982216f, -0.00488407f, -0.06024490f, -0.01942189f, 0.01858123f, 
    -0.07579984f, 0.04971586f, 0.05989872f, -0.07694127f, -0.06681295f, -0.05006253f, -0.01480224f, 0.03547451f, 
    -0.00215144f, 0.03939159f, 0.05353012f, -0.05066456f, -0.08012505f, -0.00292746f, -0.00667385f, 0.02100599f, 
    -0.04565355f, 0.00671579f, 0.05689792f, -0.00809346f, -0.04843056f, 0.05225858f, 0.05921953f, 0.02649168f, 
    0.02831651f, 0.03931683f, -0.03999541f, 0.01165852f, -0.02995050f, 0.02521863f, -0.01257422f, -0.06382153f, 
    -0.02284013f, -0.01172450f, -0.00820711f, 0.05944109f, -0.03290150f, 0.03946131f, 0.00299567f, 0.01483834f, 
    0.04030091f, 0.00503131f, 0.02838067f, -0.05739016f, 0.03814716f, 0.00670415f, 0.03760254f, -0.04823390f, 
    -0.05035990f, -0.05413714f, -0.06235939f, 0.03304229f, -0.00092350f, 0.00768895f, 0.04435630f, 0.03477627f, 
    0.00896064f, -0.05927892f, -0.01991052f, 0.03226005f, -0.01652275f, 0.01652445f, -0.05597325f, -0.07614047f, 
    -0.08243295f, 0.03901930f, 0.02066124f, 0.00869632f, 0.05829039f, 0.01115301f, -0.05143357f, -0.05365996f, 
    -0.07693372f, -0.05430657f, 0.00126890f, 0.02295617f, -0.00280044f, 0.01399878f, 0.05100256f, 0.03968443f, 
    0.00469105f, -0.00386344f, -0.06628955f, -0.01477166f, -0.06336969f, -0.04761475f, 0.04319768f, 0.03810410f, 
    -0.03317417f, -0.00945532f, -0.00136958f, -0.02564043f, -0.04532695f, -0.04935376f, 0.01269902f, -0.00529303f, 
    0.03978439f, -0.03305808f, -0.07569829f, 0.03317721f, -0.01655429f, 0.02576824f, -0.05327356f, 0.04780608f, 
    -0.07899942f, -0.04597488f, -0.00983204f, 0.01041169f, 0.02202642f, -0.07100500f, -0.03479135f, -0.04022579f, 
    -0.03258257f, -0.01521692f, 0.04850661f, -0.00537564f, -0.04497981f, -0.07280666f, 0.01925445f, 0.06112176f, 
    0.02342831f, -0.01228649f, 0.03181044f, -0.08080206f, -0.07972690f, -0.00676894f, 0.03503406f, -0.00058380f, 
    -0.04165069f, -0.05809556f, -0.07551239f, -0.01302686f, -0.04811682f, -0.07682610f, -0.05345442f, -0.06624863f, 
    -0.04301677f, 0.19379809f, 0.09321366f, -0.06174488f, 0.09461173f, -0.02946271f, 0.11555499f, 0.03843024f, 
    -0.08042143f, 0.02133629f, 0.08224457f, -0.05991453f, 0.01362257f, 0.11959304f, 0.19003515f, 0.12764850f, 
    -0.13483194f, 0.06299308f, 0.02064499f, 0.11029274f, -0.04160397f, -0.05714960f, -0.21413665f, 0.02307872f, 
    -0.39880881f, 0.18497643f, -0.07172417f, 0.08022973f, -0.02652869f, 0.00266251f, -0.09825468f, 0.07807509f, 
    -0.00419605f, -0.04298441f, 0.03296126f, 0.11966402f, 0.09187312f, 0.10429665f, -0.05413920f, -0.23950435f, 
    -0.06249955f, 0.08720749f, -0.01743567f, 0.00733836f, -0.06392740f, -0.10883036f, -0.03369183f, 0.05383539f, 
    -0.39161083f, 0.02604083f, -0.05668827f, -0.12758087f, 0.01448866f, -0.07139706f, 0.07387286f, -0.02740622f, 
    -0.05037334f, -0.19468221f, 0.12899479f, 0.05833751f, -0.38081196f, -0.25594836f, 0.14895992f, 0.20412770f, 
    0.09727064f, 0.09856131f, -0.05846225f, 0.04278824f, -0.04621319f, 0.09386063f, -0.04584387f, 0.07029378f, 
    0.17745474f, 0.00060617f, 0.08492031f, 0.14680310f, 0.12274407f, -0.01643190f, -0.11403810f, 0.01852159f, 
    -0.05223601f, -0.02814271f, -0.11543553f, 0.15143970f, 0.08982332f, -0.09761240f, -0.09161975f, 0.12176701f, 
    -0.03759565f, 0.03955443f, 0.03685049f, -0.02709451f, 0.16021773f, 0.12214145f, 0.03319268f, -0.11738227f, 
    -0.06362809f, 0.25610238f, -0.12140854f, 0.12723292f, 0.13300374f, 0.10615762f, 0.08469041f, 0.05859608f, 
    0.02578158f, -0.03211556f, 0.05997118f, -0.00451401f, -0.23212039f, -0.01319486f, -0.35832676f, 0.03790354f, 
    0.17056119f, -0.01783172f, -0.02428737f, 0.02862698f, -0.16842945f, -0.10075874f, 0.04829551f, 0.05820083f, 
    0.29234812f, -0.06222558f, 0.06337237f, -0.07320884f, -0.01047050f, 0.06562001f, 0.07923248f, 0.07678059f, 
    -0.03477081f, 0.03998205f, 0.05608218f, -0.02451166f, -0.01274665f, 0.05298920f, 0.01378806f, 0.07211609f, 
    0.14514819f, 0.11703045f, -0.01599865f, 0.18069215f, -0.06298834f, 0.00328648f, 0.11658571f, 0.02444573f, 
    0.13288428f, -0.13484955f, 0.08196618f, 0.20652166f, 0.02103773f, 0.05040016f, -0.00825292f, 0.02225055f, 
    0.07721376f, -0.04044712f, 0.03251377f, -0.14556125f, 0.09143981f, 0.04160495f, 0.17770839f, 0.15983729f, 
    -0.05309888f, -0.01367665f, 0.02242660f, 0.04316925f, 0.06905183f, 0.07784941f, -0.10740688f, -0.10974006f, 
    -0.08111402f, 0.14221714f, -0.15454295f, 0.15369588f, 0.14844438f, 0.01220231f, 0.08856957f, -0.03421028f, 
    0.04141226f, -0.04197121f, -0.01519719f, 0.00905429f, -0.15248139f, -0.11425626f, 0.21686852f, 0.03140109f, 
    -0.00524984f, -0.04237378f, 0.03056601f, 0.11778247f, 0.07669476f, -0.05307339f, -0.00696670f, 0.01776140f, 
    -0.17580281f, 0.07486463f, 0.19482170f, -0.13765261f, -0.19461899f, -0.02182858f, 0.02537540f, 0.06210120f, 
    0.07198649f, 0.01059975f, 0.16369021f, -0.02051104f, -0.17739175f, 0.14398505f, 0.27531889f, -0.10980330f, 
    0.05535651f, -0.05002085f, -0.06002720f, -0.00270992f, -0.10453112f, -0.01515457f, -0.05304054f, 0.00539338f, 
    -0.03718472f, -0.14302780f, -0.13068327f, 0.25696081f, -0.17076910f, 0.09353121f, 0.00646442f, -0.11304547f, 
    0.09670587f, 0.00402242f, 0.03156390f, -0.03141709f, 0.33609897f, 0.03582794f, -0.29708555f, 0.17774616f, 
    -0.05102877f, 0.03534949f, 0.14022413f, -0.01872117f, 0.08951563f, 0.05549789f, 0.13834082f, -0.03710625f, 
    0.14602967f, -0.23663378f, -0.08155936f, -0.08680383f, -0.04231791f, 0.11525312f, -0.03013925f, -0.04788348f, 
    0.11851382f, 0.03224383f, 0.02467160f, -0.01278655f, 0.21662840f, -0.13945232f, 0.06690899f, -0.14954513f, 
    0.07969400f, -0.07412181f, -0.02603496f, 0.11662675f, 0.02312091f, -0.14152375f, 0.01877337f, 0.14078256f, 
    -0.12618560f, -0.02483068f, 0.18405972f, 0.10870788f, 0.03690589f, 0.12011961f, -0.02793696f, -0.03293144f, 
    -0.03034433f, -0.17786425f, 0.09443280f, 0.08898278f, 0.10458397f, -0.24326703f, -0.17504232f, 0.16542660f, 
    0.01548608f, 0.04945563f, -0.05029238f, 0.03975539f, 0.03373756f, -0.14655927f, 0.17683674f, 0.16103920f, 
    -0.15840034f, 0.26927224f, -0.12408117f, -0.07942948f, 0.06648703f, 0.09499782f, 0.04623761f, 0.06247934f, 
    0.04336310f, -0.07254622f, -0.01977706f, -0.01440938f, 0.10568418f, -0.10487465f, -0.19282885f, 0.21879183f, 
    -0.12394597f, 0.00899753f, -0.04829933f, -0.03319653f, -0.03576006f, 0.09391647f, -0.03028648f, -0.05842230f, 
    -0.18100338f, -0.26631775f, 0.02099980f, -0.17601572f, 0.11798318f, 0.04019294f, 0.06064022f, 0.04738839f, 
    0.00040333f, -0.01355916f, 0.02590460f, -0.01171311f, -0.18189985f, -0.09703577f, -0.05631595f, 0.08923251f, 
    -0.01386075f, -0.05945325f, 0.07128718f, 0.03740888f, 0.04353851f, 0.10438297f, -0.03403931f, 0.08697605f, 
    -0.01247800f, -0.05138607f, 0.35084033f, -0.01704375f, -0.05085973f, -0.05377095f, 0.15572138f, 0.16103891f, 
    -0.00979515f, -0.04236022f, 0.04460086f, 0.17372131f, -0.12049422f, 0.04473947f, 0.06516564f, -0.30834192f, 
    -0.00557819f, 0.02488859f, 0.12756801f, 0.09348268f, -0.00829896f, -0.09306618f, -0.10396201f, 0.12619814f, 
    0.00436378f, -0.09305178f, 0.04414516f, -0.03781210f, 0.05077241f, 0.06203897f, 0.03471446f, 0.02373325f, 
    0.03710327f, 0.16800378f, 0.05472177f, 0.06673596f, 0.20232424f, 0.02836579f, -0.07913871f, -0.09248091f, 
    -0.06367036f, 0.03310438f, -0.06964340f, -0.02977980f, 0.13452059f, -0.03824674f, 0.10061134f, -0.01129746f, 
    0.07451800f, -0.01927416f, 0.03210119f, -0.05021586f, -0.00101194f, -0.00783010f, 0.07785386f, -0.05058005f, 
    0.11844990f, -0.11233843f, 0.02903183f, -0.02768495f, -0.12912428f, 0.18817416f, -0.15960483f, -0.05518353f, 
    0.13726777f, 0.04297474f, 0.10989511f, 0.06140212f, -0.01046667f, -0.02329394f, 0.08966149f, 0.10540438f, 
    -0.07352202f, 0.03932546f, 0.16479142f, 0.00294354f, 0.00771746f, -0.05578301f, 0.02081223f, -0.08495267f, 
    -0.07368305f, 0.00339691f, -0.00080588f, 0.11852755f, 0.05984354f, -0.01183629f, 0.06938734f, 0.11491196f, 
    0.07444053f, 0.03141442f, 0.06604581f, 0.10264129f, -0.01165696f, -0.01193562f, -0.00464998f, -0.07348166f, 
    -0.04702690f, 0.05565337f, 0.17791940f, -0.08686460f, 0.08122197f, 0.00501187f, 0.00804331f, 0.16516766f, 
    -0.06495509f, 0.05302506f, -0.03647083f, 0.07526645f, -0.15352944f, 0.23142727f, -0.03627465f, -0.03767828f, 
    -0.01920643f, 0.03472149f, -0.05741929f, 0.00492333f, -0.06082504f, 0.09470960f, -0.04352136f, 0.03200426f, 
    0.09044185f, 0.01519705f, -0.23088644f, -0.04161133f, -0.11690878f, -0.11963926f, 0.10887483f, -0.00287998f, 
    0.02383575f, 0.01269936f, 0.07279232f, -0.16435421f, -0.15168977f, -0.04497288f, 0.12634447f, -0.04730204f, 
    0.13753922f, 0.01380454f, 0.08707871f, -0.02469351f, -0.04604378f, 0.07892510f, 0.10800240f, 0.02596766f, 
    -0.15316032f, -0.03713124f, 0.16398904f, -0.09598842f, -0.07839689f, -0.04099626f, 0.01577996f, -0.04281830f, 
    0.01774438f, 0.06031904f, 0.01455818f, 0.07473607f, -0.32174298f, 0.10416720f, 0.09401912f, -0.17483814f, 
    0.12509637f, 0.10431300f, -0.01788814f, -0.07810166f, 0.03726117f, 0.06492316f, 0.03983236f, -0.03220610f, 
    -0.09052485f, 0.11122581f, 0.24912387f, 0.43868700f, 0.10185069f, -0.01439003f, -0.05624188f, 0.05871136f, 
    0.09126505f, -0.20492007f, 0.06171915f, 0.10726254f, 0.10316518f, -0.03142528f, 0.08054964f, 0.24099027f, 
    0.05357310f, 0.14579797f, 0.01537490f, -0.12767261f, 0.04742410f, -0.14367579f, 0.04777868f, -0.14902118f, 
    0.03973960f, 0.33023018f, -0.18130986f, -0.00600240f, 0.13093890f, -0.03573306f, -0.16089194f, -0.05433612f, 
    0.08860962f, 0.09558648f, 0.02272068f, -0.06752691f, -0.11124284f, -0.06489900f, -0.07087941f, -0.14417903f, 
    0.02438527f, -0.03027790f, -0.06497410f, -0.01146762f, -0.00318744f, -0.02274559f, 0.12858884f, 0.02254766f, 
    -0.14744201f, -0.04168274f, -0.01356814f, 0.13649772f, -0.04867148f, -0.08743472f, -0.02687563f, -0.08753181f, 
    0.11396164f, -0.03530705f, 0.02694010f, 0.02408688f, 0.06321975f, -0.11624388f, 0.19285414f, 0.19216128f, 
    0.03988354f, -0.10336079f, 0.05697077f, -0.15951402f, -0.02671581f, 0.03593988f, 0.04430432f, 0.05110291f, 
    0.22374459f, -0.01316946f, -0.00918189f, -0.02604456f, -0.01357251f, 0.06821989f, 0.00402088f, 0.12510926f, 
    -0.06640040f, 0.07631730f, -0.06272530f, 0.06756638f, -0.02279152f, -0.02292500f, -0.06500387f, 0.07666956f, 
    -0.04111369f, 0.02024711f, 0.09473424f, 0.03886103f, 0.14021809f, -0.02715014f, -0.00754499f, 0.07145896f, 
    0.28457510f, 0.17993881f, 0.18051611f, -0.10994959f, 0.02572474f, 0.05376673f, 0.14267246f, -0.06381096f, 
    0.03506783f, 0.07743459f, 0.07554421f, 0.06137140f, 0.23726130f, -0.09680460f, 0.09775156f, -0.23630957f, 
    0.03977000f, 0.04413508f, 0.02457880f, 0.01471709f, 0.00347189f, 0.03718619f, 0.04651586f, -0.09635368f, 
    -0.01291818f, -0.15621957f, 0.08148274f, 0.06922247f, 0.03430102f, -0.08950203f, 0.08863065f, 0.03854478f, 
    -0.02086960f, -0.09617549f, 0.05658609f, 0.04449591f, -0.11107056f, 0.06095287f, 0.04366549f, 0.19298536f, 
    -0.05325723f, -0.02108012f, 0.08254962f, 0.02368766f, 0.06226354f, -0.06299622f, 0.00817936f, 0.07818666f, 
    -0.22570117f, -0.19247185f, 0.06297714f, -0.12122923f, -0.00547986f, 0.09491811f, 0.04142705f, -0.09842436f, 
    0.03990088f, -0.03509244f, 0.10585065f, 0.06855793f, -0.05735033f, 0.06905150f, 0.06287035f, -0.14904842f, 
    0.07114327f, 0.14237432f, 0.11497109f, -0.10749380f, -0.00199680f, 0.14961638f, 0.08306900f, 0.04681648f, 
    -0.17733990f, -0.21012226f, -0.00325790f, -0.32985413f, -0.07714348f, -0.02685278f, -0.05827385f, -0.00874481f, 
    0.04349545f, -0.05862519f, 0.06311116f, 0.02735686f, 0.33796605f, -0.10753717f, 0.07239450f, 0.19323295f, 
    0.03567740f, -0.04009047f, 0.02398027f, 0.01456858f, 0.03454505f, 0.08596765f, -0.09974064f, 0.15047647f, 
    0.49170583f, -0.06725504f, 0.16310814f, 0.23002531f, 0.06842873f, 0.09945571f, -0.09629532f, 0.05925107f, 
    -0.03208819f, 0.01318726f, -0.01673222f, -0.06873928f, 0.25566995f, 0.20557727f, -0.00701724f, 0.07315587f, 
    -0.04039060f, -0.08038425f, -0.08663983f, -0.05904491f, -0.00977913f, -0.10365388f, 0.09174827f, 0.01594050f, 
    -0.24703000f, 0.08115316f, -0.03922471f, 0.27804747f, 0.02241143f, 0.07342415f, 0.05506976f, 0.16998282f, 
    0.05440051f, 0.00766063f, -0.08445962f, -0.13454069f, -0.41553637f, -0.10404623f, -0.12638791f, -0.10567604f, 
    0.02238418f, 0.04551284f, 0.02275210f, -0.12566715f, -0.05289769f, -0.05105124f, 0.10043202f, 0.02512604f, 
    0.11986752f, 0.06854985f, 0.07162307f, -0.10037486f, 0.13652736f, 0.00587742f, 0.09480610f, -0.07484253f, 
    0.03933998f, -0.09275369f, -0.08198456f, 0.00030041f, 0.21051793f, -0.03215923f, 0.15421197f, 0.13699305f, 
    -0.03093308f, 0.04058065f, -0.04308405f, 0.13803369f, -0.04711454f, 0.00373388f, -0.17273429f, 0.08788791f, 
    -0.02576688f, -0.07968748f, -0.01954983f, 0.01048898f, -0.02094875f, -0.04971072f, -0.06960369f, -0.02334821f, 
    -0.07741830f, -0.01764083f, 0.04187680f, 0.04132714f, -0.05232546f, 0.01731500f, 0.02058185f, -0.07097740f, 
    -0.06759001f, -0.07719199f, 0.00005788f, -0.03780589f, -0.00006438f, 0.03258906f, 0.04231924f, -0.07300793f, 
    -0.04139822f, -0.06151563f, -0.00382233f, -0.00175200f, -0.03340003f, 0.04954721f, 0.04940978f, 0.02117570f, 
    0.02200301f, 0.01410016f, 0.04706361f, -0.08084309f, 0.00089576f, 0.02631366f, 0.06752347f, -0.05255682f, 
    -0.01828869f, 0.04734843f, -0.02376910f, 0.04365589f, -0.04356898f, -0.00737734f, 0.02935592f, -0.00131098f, 
    0.01422447f, -0.03501327f, -0.06786815f, -0.03330015f, 0.04379325f, -0.01989162f, -0.03725359f, -0.02700890f, 
    0.04506133f, 0.04985748f, -0.03849417f, -0.02950623f, -0.02068337f, -0.00353701f, 0.04785559f, 0.02455393f, 
    0.00062984f, 0.03623721f, 0.02180365f, 0.03209574f, 0.05535184f, 0.05984859f, -0.04638698f, 0.03595250f, 
    -0.05874095f, -0.06844048f, -0.07389963f, -0.02401892f, -0.03266156f, -0.06647281f, 0.01730733f, 0.04276880f, 
    -0.04508712f, 0.02378604f, -0.01499362f, 0.03420804f, 0.02699675f, -0.01563669f, -0.00093579f, -0.05526162f, 
    -0.06573462f, -0.06214042f, -0.05311535f, -0.04638138f, -0.03473689f, -0.05839359f, -0.04641832f, 0.01241123f, 
    0.02603705f, 0.04236256f, 0.00384346f, -0.04868573f, -0.01980032f, 0.01660978f, 0.04773879f, 0.05039153f, 
    0.05399369f, 0.01616437f, -0.03391619f, 0.02127903f, -0.07478853f, -0.02894541f, -0.03511646f, -0.04825313f, 
    0.01099200f, 0.04465616f, -0.03817951f, 0.01515639f, 0.05837975f, -0.00523643f, -0.03091236f, -0.02435950f, 
    0.00491766f, -0.06022312f, 0.06498335f, 0.02122968f, 0.02563377f, 0.05766582f, 0.04173717f, -0.02892214f, 
    -0.04675858f, -0.04453972f, 0.04134833f, -0.03232545f, 0.07820066f, -0.04924403f, 0.06579310f, 0.04972197f, 
    -0.05404799f, 0.01799020f, -0.00780642f, 0.00004055f, -0.01345472f, 0.01971004f, 0.00360952f, -0.01097102f, 
    -0.02229516f, -0.07551309f, -0.07890479f, -0.05505333f, -0.02533023f, 0.05146350f, 0.04853370f, -0.03591797f, 
    -0.04526472f, 0.00760752f, -0.01359419f, -0.05539710f, 0.02729301f, 0.03980013f, 0.00610130f, -0.06012003f, 
    -0.01432724f, -0.03739566f, 0.03832207f, 0.03919141f, 0.05452689f, -0.02853834f, -0.02900725f, -0.05660425f, 
    -0.01493349f, 0.02080474f, -0.04539574f, -0.06734455f, 0.04585935f, -0.04230995f, -0.04817555f, 0.03391819f, 
    -0.07696656f, -0.07329564f, 0.02579858f, 0.05235373f, 0.01739489f, 0.00042899f, -0.05003177f, -0.06905610f, 
    0.02438674f, -0.03407301f, 0.06026628f, -0.02642153f, 0.03078706f, -0.07395922f, 0.00189138f, 0.04030408f, 
    0.18460134f, -0.03623464f, 0.20560804f, 0.15503564f, -0.05411501f, 0.03177807f, 0.12614067f, 0.11478356f, 
    -0.06821224f, 0.14084625f, -0.04426447f, 0.12368295f, 0.47706366f, 0.09167174f, 0.14174031f, 0.10278945f, 
    -0.17538333f, -0.01348375f, 0.01611688f, -0.00943117f, -0.01467234f, -0.08763684f, -0.09596943f, -0.00725721f, 
    -0.08858585f, -0.17415370f, -0.05580605f, 0.06295246f, 0.05245433f, 0.08513690f, 0.02562964f, 0.02719402f, 
    0.03720159f, 0.09098527f, 0.15981939f, -0.10944077f, -0.11849225f, 0.07817320f, -0.07116999f, -0.09717748f, 
    -0.03106064f, 0.00989218f, -0.02702849f, 0.08484049f, 0.12130316f, -0.13871227f, -0.01506485f, -0.07783796f, 
    -0.10720749f, 0.01987435f, -0.01368723f, 0.09216833f, 0.07375482f, 0.13846338f, -0.03377194f, 0.00612203f, 
    0.06155701f, -0.08705173f, -0.01027930f, 0.00369370f, 0.09467210f, -0.20671506f, -0.13779582f, -0.00563170f, 
    0.06220707f, 0.01717370f, -0.04953776f, 0.05805987f, -0.02441487f, 0.00064835f, -0.01718991f, 0.12133033f, 
    0.15623899f, 0.14315166f, 0.05540900f, -0.20121270f, 0.11649854f, 0.04495285f, 0.04064138f, 0.00877246f, 
    -0.06671651f, -0.01967774f, 0.00745107f, 0.10340075f, -0.00517021f, -0.02978537f, -0.12724693f, 0.00151817f, 
    -0.00899947f, -0.04615528f, -0.04562800f, 0.07828983f, 0.06181693f, -0.05482614f, -0.02902074f, -0.04054181f, 
    0.29880202f, -0.14039560f, 0.20086516f, 0.27592137f, -0.01131118f, 0.05343045f, 0.09502228f, 0.06215325f, 
    0.07694730f, -0.03844716f, 0.01655164f, 0.01105123f, -0.05680334f, -0.09738823f, -0.13665242f, 0.17329048f, 
    0.12411293f, -0.08570988f, 0.14288834f, -0.07622167f, -0.01002253f, -0.05380197f, 0.10469046f, 0.13664488f, 
    0.21273926f, -0.05884988f, -0.04579031f, -0.18315817f, -0.00462065f, -0.05420272f, -0.01722110f, -0.04232635f, 
    0.03284204f, 0.05715110f, 0.00485254f, 0.05268722f, -0.12445096f, -0.01452312f, -0.09905118f, -0.16347261f, 
    -0.01329440f, -0.12308173f, -0.03198340f, 0.03812093f, 0.01888361f, 0.08983329f, 0.00909846f, 0.11604502f, 
    0.04089069f, -0.02002163f, -0.02341423f, -0.04871118f, -0.00938828f, 0.14310788f, 0.09496076f, 0.06127645f, 
    0.02596113f, 0.05871037f, 0.03827904f, -0.05744616f, 0.28506717f, 0.07038835f, 0.16232431f, 0.34990612f, 
    -0.09217636f, 0.10537740f, 0.09643439f, -0.00315380f, 0.08820970f, 0.03254350f, 0.01293532f, 0.02287461f, 
    0.01402364f, 0.05509381f, 0.11637330f, -0.03182749f, -0.00406553f, 0.14676228f, -0.05967187f, -0.04648408f, 
    -0.13332632f, 0.02343928f, -0.08820052f, -0.01106002f, -0.19465087f, 0.12736805f, -0.10856699f, 0.00815450f, 
    0.12002006f, 0.00544257f, -0.05292718f, 0.09656449f, -0.03306755f, -0.06622215f, -0.04625144f, -0.03030870f, 
    0.10139944f, 0.17906189f, -0.00868091f, 0.04735143f, 0.01162314f, 0.05910996f, 0.12577055f, 0.09445760f, 
    -0.08625822f, 0.05461960f, -0.02892105f, -0.03062856f, -0.04835990f, 0.14503139f, 0.22378954f, 0.26329145f, 
    -0.08634731f, 0.03045977f, 0.01784066f, -0.01150072f, 0.04670046f, -0.04118950f, -0.04875128f, 0.02861340f, 
    0.03553167f, -0.12722503f, 0.02415232f, -0.17081270f, -0.10194497f, 0.07419128f, -0.12878571f, 0.01699710f, 
    0.04735731f, 0.13102019f, -0.01676500f, -0.12808460f, -0.00079611f, -0.01863828f, -0.21367611f, -0.17407945f, 
    -0.02250981f, 0.06894283f, -0.01911202f, -0.05184365f, 0.00673613f, -0.00206691f, -0.04380422f, 0.02129098f, 
    -0.10515647f, -0.15271561f, -0.21272773f, -0.08024061f, 0.16693000f, 0.14739862f, 0.12419296f, -0.09625401f, 
    -0.00535032f, 0.04096117f, 0.02452258f, -0.07239763f, -0.11619738f, -0.15144546f, -0.03874637f, 0.13365313f, 
    0.07003114f, 0.01980113f, 0.04247305f, 0.17861077f, -0.04763132f, -0.05451730f, 0.03300811f, -0.08472478f, 
    0.06058343f, -0.06413378f, 0.22844115f, 0.14207357f, -0.06217425f, -0.06892812f, 0.00615602f, -0.25124440f, 
    0.04631923f, -0.04726995f, -0.01599609f, 0.04193308f, 0.12297798f, -0.26179838f, -0.03646818f, -0.05278442f, 
    0.16723461f, 0.11110840f, -0.01710443f, 0.07309213f, -0.00365759f, -0.01288198f, -0.03535438f, -0.02228421f, 
    0.47875345f, 0.22848219f, 0.26025933f, 0.21178187f, 0.02295378f, 0.05081267f, -0.07502457f, 0.04538513f, 
    0.10839556f, 0.01089387f, 0.03605337f, 0.06732669f, 0.03317682f, -0.13919820f, -0.26906696f, -0.14474915f, 
    0.08475801f, 0.06922153f, -0.02644223f, -0.00247069f, -0.01388077f, -0.06461043f, 0.01533023f, 0.02677987f, 
    -0.05518674f, -0.18290813f, -0.08467819f, -0.15676717f, -0.01098483f, 0.01843478f, 0.06090214f, -0.01838363f, 
    -0.00550471f, 0.11749203f, 0.02537155f, -0.04267323f, -0.43336961f, -0.11461310f, 0.06432021f, -0.03095262f, 
    0.30154890f, 0.08972651f, 0.07128915f, 0.06855679f, -0.02432792f, 0.08091056f, -0.15160580f, -0.01875841f, 
    -0.10593477f, 0.16031732f, 0.08261748f, 0.04524267f, 0.01010080f, -0.01298395f, 0.15483494f, -0.01821568f, 
    -0.02605066f, -0.03606625f, 0.02083400f, -0.04027034f, 0.23854572f, 0.31112471f, 0.37383685f, 0.35433757f, 
    -0.06475490f, -0.14152488f, 0.04459688f, -0.06734706f, 0.08341181f, 0.07700044f, -0.08630686f, 0.17505872f, 
    -0.15601493f, -0.01255482f, 0.11428840f, -0.14758664f, 0.06575688f, -0.04407908f, -0.00838531f, 0.01181615f, 
    0.01602842f, 0.07833330f, 0.00207519f, 0.05924850f, 0.13546987f, -0.00048441f, -0.02119509f, -0.13370995f, 
    0.01542298f, 0.07682639f, -0.02377653f, -0.12100737f, 0.08453951f, 0.03167794f, 0.08448118f, -0.11032557f, 
    -0.24799347f, -0.03263097f, -0.31819931f, -0.02617395f, 0.10948332f, -0.07167036f, -0.01430882f, -0.11092531f, 
    0.02258557f, 0.16763774f, 0.00759815f, 0.03826911f, -0.06855228f, 0.05830922f, -0.25920942f, 0.13281062f, 
    -0.02457343f, -0.03483893f, -0.19005536f, 0.00341310f, -0.05495007f, -0.01261499f, -0.07783019f, -0.11262682f, 
    -0.06185805f, 0.21369918f, -0.01556565f, -0.14045586f, 0.04069527f, -0.11023957f, -0.06263702f, 0.04657725f, 
    -0.04789937f, 0.10659263f, 0.06954879f, -0.09904160f, -0.08654565f, 0.03775636f, 0.24003913f, 0.09451085f, 
    -0.01394540f, -0.05639046f, 0.06103795f, 0.12718236f, -0.09969644f, -0.01757236f, -0.02521684f, -0.06961196f, 
    -0.46923691f, -0.11041866f, -0.04801828f, -0.09257362f, -0.08671589f, 0.00246243f, 0.07141216f, 0.10364398f, 
    0.07018714f, -0.18880111f, -0.13261032f, -0.22970611f, 0.22824004f, 0.18241587f, 0.18207723f, 0.18000297f, 
    0.04590975f, 0.13765261f, 0.18837851f, 0.04114322f, -0.11519351f, -0.00834277f, -0.05011783f, 0.04550974f, 
    0.33662409f, -0.00328425f, 0.09253521f, 0.12284993f, -0.08718406f, -0.05651853f, -0.02299869f, -0.08933935f, 
    -0.05509910f, -0.07930236f, 0.09742725f, -0.03394421f, -0.18624610f, 0.23278639f, 0.17244713f, 0.08719014f, 
    0.06679180f, 0.10361846f, -0.00333775f, 0.05686597f, 0.09110135f, -0.00749586f, -0.08311971f, 0.00341992f, 
    0.07152151f, -0.07349848f, -0.13584438f, -0.06617134f, 0.03563471f, 0.01542658f, -0.09087572f, -0.07529083f, 
    -0.12635207f, 0.02938759f, -0.09119125f, -0.04665773f, 0.19524057f, 0.07245991f, 0.07687435f, 0.20648739f, 
    -0.03702104f, 0.13452724f, -0.04394904f, 0.14277746f, -0.02188248f, 0.02469202f, -0.06342141f, 0.13869445f, 
    -0.13605443f, 0.07445889f, -0.08591728f, 0.02203827f, -0.04327480f, -0.03061087f, -0.03950084f, -0.13279983f, 
    -0.01364809f, 0.07866757f, -0.10327239f, -0.07762621f, 0.34558272f, 0.32646349f, 0.22853398f, 0.45436075f, 
    0.16386093f, 0.02464834f, 0.01284083f, 0.02145687f, -0.08250875f, 0.09806859f, 0.03937783f, 0.15051177f, 
    0.33885497f, 0.08063619f, 0.14314437f, 0.24239823f, 0.15984087f, 0.02364941f, -0.17652237f, 0.02194099f, 
    -0.05329153f, 0.09906860f, -0.03540228f, -0.08961127f, 0.02137464f, -0.01915712f, -0.00976842f, -0.04225782f, 
    0.07200864f, -0.11434512f, -0.07149353f, 0.02982615f, -0.08808053f, 0.03836636f, -0.19918549f, -0.07142942f, 
    -0.13064499f, 0.13960774f, -0.21311569f, 0.19001806f, 0.13731122f, -0.14705023f, -0.14191936f, 0.00622011f, 
    -0.05679661f, -0.04183282f, 0.03642941f, -0.12170663f, 0.03560042f, -0.00159518f, 0.17755355f, 0.07304696f, 
    -0.03054472f, 0.03572473f, -0.09902902f, -0.07176232f, 0.05220139f, -0.04928271f, -0.03072990f, 0.00590355f, 
    0.02694131f, 0.08565969f, -0.09277545f, -0.01772912f, -0.04480812f, 0.03456575f, 0.04401764f, 0.16920975f, 
    0.03737970f, 0.03381310f, -0.04048840f, 0.15600835f, 0.11361510f, -0.11809165f, 0.09985644f, 0.14466418f, 
    -0.16092756f, 0.17393051f, -0.04021325f, -0.00432981f, 0.11252725f, 0.01101299f, -0.17408997f, -0.07483242f, 
    -0.11159015f, -0.01611372f, 0.02957344f, 0.04632609f, 0.07110121f, -0.04603519f, -0.02435292f, 0.00119854f, 
    0.07402346f, -0.00401168f, 0.14360265f, -0.02176289f, -0.23212788f, -0.01372427f, -0.00613529f, -0.09132962f, 
    -0.04435642f, 0.01877689f, 0.04359280f, 0.06827947f, -0.01527453f, -0.08000486f, -0.06014699f, 0.02009830f, 
    -0.44039369f, 0.16709919f, 0.04628499f, 0.13189349f, -0.01917102f, -0.08803374f, 0.10415941f, 0.07123095f, 
    0.01601180f, -0.11035466f, 0.07280400f, 0.04090820f, -0.26718244f, -0.18803102f, -0.09728239f, 0.03795065f, 
    -0.01399344f, 0.07287732f, -0.00117032f, -0.18866028f, 0.02709014f, 0.03505674f, 0.13845836f, 0.10545759f, 
    0.06179529f, -0.02497244f, 0.34971946f, 0.04091099f, -0.01250330f, 0.08087176f, -0.08392526f, 0.03105672f, 
    0.02873532f, 0.03387593f, -0.02968574f, 0.18524246f, -0.20728368f, 0.20828342f, -0.14400840f, -0.10572195f, 
    0.07115436f, 0.02444175f, 0.03446449f, 0.00774071f, 0.04447429f, 0.15557438f, -0.04759165f, 0.00356120f, 
    0.08729123f, 0.01149117f, -0.03518990f, 0.02596678f, 0.02237429f, 0.04534270f, 0.02555844f, 0.16296895f, 
    0.00560165f, 0.02877988f, -0.06257534f, -0.03381618f, -0.33704883f, 0.18418184f, -0.15101859f, -0.04913685f, 
    0.06606027f, -0.07288905f, 0.04077205f, -0.00564509f, -0.05969473f, -0.10864563f, 0.14291032f, 0.09418330f, 
    0.30979195f, -0.00139285f, 0.01437019f, -0.05436190f, -0.05378737f, 0.14438012f, 0.12670001f, 0.03411697f, 
    -0.06956151f, 0.08437251f, 0.04438302f, 0.09076867f, 0.00127424f, -0.00566003f, -0.09014478f, -0.00589312f, 
    -0.00159445f, -0.02073844f, -0.02977150f, 0.16304828f, 0.07128492f, 0.03454628f, 0.05811999f, 0.13428503f, 
    0.13538291f, -0.20216168f, -0.09464123f, 0.14582951f, -0.04148370f, 0.10745478f, 0.06713800f, -0.04021874f, 
    0.01903231f, 0.04543633f, 0.05233211f, -0.05860995f, 0.18117432f, 0.10597249f, 0.12026417f, 0.20035875f, 
    -0.15835692f, 0.02641651f, 0.09554382f, 0.08780717f, 0.02327079f, 0.04060310f, -0.04067885f, -0.06438008f, 
    0.34584528f, 0.09484994f, 0.09136875f, 0.01998285f, 0.06122784f, 0.11686374f, 0.07428702f, 0.02048246f, 
    -0.00510312f, -0.10427332f, -0.02551935f, -0.04652048f, -0.34366414f, 0.12567703f, 0.26127067f, 0.01501060f, 
    0.01876271f, 0.07069928f, 0.03218127f, 0.11215122f, 0.03038435f, -0.07336339f, -0.08277997f, -0.01335963f, 
    0.31262454f, 0.21524617f, -0.14967577f, -0.00159634f, 0.00706061f, 0.02912846f, 0.02195689f, -0.03937940f, 
    -0.00545961f, -0.03702771f, -0.14785078f, 0.02277336f, -0.03454336f, -0.09048957f, -0.04733857f, 0.00633111f, 
    -0.05844933f, 0.09525004f, -0.06545292f, -0.06663854f, 0.13475570f, -0.15746117f, 0.02727843f, 0.17659949f, 
    -0.00589342f, -0.36474383f, 0.19766195f, 0.08783228f, 0.02029110f, -0.02228296f, 0.07499842f, 0.00691377f, 
    0.03816277f, -0.05530378f, -0.02192286f, 0.01040388f, -0.30361316f, -0.19127196f, 0.13530041f, -0.01580827f, 
    0.10510769f, -0.04854127f, 0.02785126f, 0.10808174f, -0.02327316f, 0.00024533f, -0.08678672f, 0.14929864f, 
    -0.20215209f, 0.34243730f, -0.06343882f, 0.12471319f, -0.02917836f, 0.03411895f, 0.04875024f, -0.03448210f, 
    -0.01237550f, 0.04033728f, -0.07901210f, 0.08658761f, 0.14842701f, 0.04487136f, -0.06237031f, -0.05982919f, 
    -0.14323592f, 0.15111688f, -0.10733033f, -0.06465118f, -0.00070433f, -0.00156538f, 0.01156026f, 0.09488492f, 
    0.09946758f, -0.27443200f, 0.13351966f, -0.02228276f, -0.18355033f, -0.07447083f, 0.13732278f, -0.04478009f, 
    0.02513896f, 0.10030250f, -0.03914457f, -0.21261168f, 0.06443996f, 0.03384848f, 0.17411038f, -0.03877071f, 
    0.03594311f, -0.03305274f, -0.03330142f, 0.09413030f, -0.00669485f, -0.11669901f, -0.07249116f, 0.11363766f, 
    0.34434938f, -0.04768992f, 0.06237970f, 0.38266748f, -0.05406035f, -0.07298122f, -0.03662929f, 0.04867927f, 
    0.01535864f, 0.06230545f, 0.01354231f, -0.00980229f, -0.21995234f, 0.04840070f, 0.00246693f, -0.28428155f, 
    -0.06965840f, 0.07225974f, -0.02395742f, 0.02161006f, 0.10082673f, -0.10756560f, -0.05313293f, 0.00088875f, 
    0.07799183f, 0.21324898f, 0.05956722f, -0.30602860f, -0.04418015f, 0.04272486f, -0.04789735f, 0.10183598f, 
    0.06855959f, 0.15111500f, 0.03681958f, 0.01597225f, -0.04665304f, 0.00393281f, 0.22280492f, 0.08241339f, 
    0.05772987f, -0.10213733f, 0.06489012f, 0.33836758f, -0.02746715f, 0.06444865f, 0.12557034f, 0.04149149f, 
    0.09686441f, 0.12002541f, -0.22655864f, -0.10041973f, -0.07509807f, 0.09192498f, 0.06467955f, -0.14242296f, 
    0.07484896f, 0.12277991f, -0.01122401f, 0.09652727f, 0.13389573f, 0.01671144f, 0.20711797f, 0.41235399f, 
    -0.12809993f, -0.01914904f, -0.07142516f, 0.07567573f, 0.09844879f, 0.06056507f, -0.01497103f, -0.06820416f, 
    0.05691854f, -0.20264451f, 0.08902927f, -0.11021851f, -0.00249550f, 0.02177043f, 0.03679093f, 0.09610920f, 
    -0.01865046f, -0.06284539f, -0.10860464f, 0.06661411f, -0.41161871f, 0.09129192f, 0.17259827f, -0.06291021f, 
    0.14855483f, -0.07321118f, 0.03180078f, -0.06150265f, 0.08937795f, 0.06811097f, 0.04343902f, 0.15476872f, 
    -0.00958630f, 0.15107542f, -0.01037305f, -0.13608043f, -0.00091062f, -0.08087183f, -0.00105154f, -0.01930916f, 
    0.14611132f, 0.11083306f, 0.10146260f, 0.00243085f, -0.01484470f, 0.05741184f, 0.01241740f, -0.15804048f, 
    -0.01994134f, 0.02081506f, -0.10337698f, 0.11314125f, -0.10643774f, 0.01387838f, -0.07545634f, 0.05553938f, 
    -0.27703050f, 0.01303805f, 0.04354237f, 0.22913998f, 0.01285681f, -0.07132650f, -0.03754561f, 0.01139143f, 
    -0.05648391f, 0.06932148f, -0.05472935f, 0.03298313f, 0.05080152f, -0.06221971f, 0.02034778f, 0.16482617f, 
    0.02385741f, 0.02232972f, 0.01699232f, 0.05772887f, 0.04350508f, -0.01430245f, 0.01028344f, 0.17722723f, 
    0.19792710f, 0.23224919f, -0.11470220f, 0.12181941f, 0.07367384f, -0.05360896f, -0.00630398f, -0.03625288f, 
    0.05872362f, 0.22095557f, -0.03937514f, 0.11977786f, 0.03705744f, 0.01254177f, 0.14359891f, -0.12762053f, 
    0.05036898f, 0.08172183f, -0.07080252f, 0.09390350f, -0.00592246f, 0.03419201f, -0.04618332f, 0.07906719f, 
    -0.09601619f, -0.15936583f, -0.01090023f, 0.07816246f, -0.02955358f, 0.14766161f, -0.03399389f, 0.05465542f, 
    0.16272360f, 0.10066523f, -0.04015904f, 0.08409784f, 0.23338744f, 0.09496724f, 0.09851731f, 0.13112424f, 
    -0.03199033f, -0.13192746f, -0.05115418f, 0.07551327f, 0.08512940f, 0.01822166f, 0.08360934f, -0.06155339f, 
    -0.20302612f, 0.04900643f, -0.29995692f, 0.26925525f, 0.08714854f, -0.01820881f, -0.03734056f, -0.01276130f, 
    -0.01505771f, 0.01657664f, -0.00931043f, 0.02775189f, -0.07659747f, -0.00947283f, 0.03858889f, 0.22374193f, 
    0.06607656f, 0.01444024f, -0.02838610f, 0.01464415f, -0.03432653f, 0.01472781f, -0.03218494f, -0.06297195f, 
    0.22824377f, 0.23976403f, -0.18650384f, -0.30860260f, 0.05191758f, 0.06247954f, 0.06068642f, -0.00293512f, 
    0.02986061f, -0.03760619f, 0.01275037f, -0.02187905f, 0.04956029f, -0.25979385f, 0.25111979f, -0.08487278f, 
    0.10456159f, 0.08283748f, 0.03036788f, 0.21364993f, -0.06246783f, 0.01190383f, -0.09330262f, 0.22290334f, 
    -0.07142669f, -0.20121267f, 0.16338637f, -0.15690283f, -0.08718758f, 0.03652844f, -0.04988481f, 0.10536271f, 
    0.04973633f, -0.05155993f, -0.06707892f, 0.03927333f, -0.25606802f, -0.26347321f, -0.07184436f, 0.17518741f, 
    -0.03968482f, -0.01287877f, -0.09779139f, -0.00296688f, 0.03303386f, 0.09731063f, 0.08108932f, -0.09492699f, 
    -0.08271345f, 0.17153579f, 0.04567743f, 0.15637892f, -0.04265412f, 0.02353739f, 0.05106281f, 0.05671953f, 
    0.08852940f, 0.09290220f, 0.13217761f, -0.01702911f, -0.01628155f, 0.02233101f, -0.12553699f, -0.14970754f, 
    0.00456240f, 0.20539013f, 0.07873525f, 0.06558927f, 0.04176566f, 0.01680792f, 0.11854619f, 0.02764308f, 
    -0.08215268f, -0.05120542f, -0.13028188f, 0.18243092f, 0.14680649f, -0.00956596f, -0.00077079f, 0.03608968f, 
    0.17761800f, 0.07970852f, 0.08191919f, 0.09496733f, 0.16121219f, 0.16930270f, 0.11777999f, -0.07199375f, 
    0.18317805f, 0.08701033f, -0.01978031f, 0.01801712f, -0.03039673f, 0.04638949f, 0.03052484f, -0.13053554f, 
    -0.26594061f, 0.13748403f, -0.14791395f, -0.16668867f, 0.10315406f, 0.04246600f, -0.02065719f, 0.12215227f, 
    -0.05483731f, 0.03876835f, 0.04929722f, 0.12194712f, 0.18122251f, -0.01244497f, 0.01406522f, -0.04703936f, 
    -0.11660855f, -0.04815244f, -0.02620218f, -0.05806169f, 0.11332521f, 0.00626509f, -0.00127742f, -0.03997276f, 
    0.37358657f, -0.21982288f, -0.14848596f, 0.11884341f, -0.00471922f, -0.09765530f, 0.01035601f, -0.00721026f, 
    0.03128067f, 0.02452929f, 0.08728027f, 0.00870557f, -0.04612142f, 0.01138459f, 0.06939045f, 0.06735758f, 
    0.09152163f, -0.04534064f, 0.02670156f, 0.07767274f, 0.08217035f, 0.03881451f, -0.02846794f, -0.02211372f, 
    -0.07554030f, 0.33919039f, -0.20173323f, 0.10498387f, 0.20579737f, 0.02929030f, 0.12075955f, 0.06377236f, 
    0.02275496f, 0.02340825f, 0.03934607f, 0.06502542f, 0.07915886f, -0.11525364f, 0.04713206f, 0.12859397f, 
    -0.22413678f, -0.00526731f, 0.09496064f, 0.07174330f, 0.04029129f, 0.10317452f, 0.11801163f, -0.06962188f, 
    0.01830926f, 0.04595227f, -0.07028631f, -0.09830838f, 0.10131894f, 0.00821898f, 0.01537141f, 0.00016275f, 
    -0.01209105f, 0.00065978f, -0.07341525f, 0.00266671f, -0.07605863f, 0.00194818f, -0.04809478f, 0.14819370f, 
    0.11101893f, -0.02423993f, -0.06931177f, 0.04458064f, 0.02452480f, -0.00689366f, 0.05962945f, -0.10069469f, 
    -0.29068586f, -0.17986535f, -0.20683816f, -0.05417737f, -0.05461153f, 0.09486707f, -0.01545583f, 0.02528170f, 
    0.04217185f, -0.07507244f, 0.05534843f, 0.03113600f, -0.15366702f, -0.12406736f, -0.08207718f, -0.14468531f, 
    0.01290394f, 0.07634277f, -0.04276663f, -0.13808990f, -0.07275860f, -0.03145610f, -0.09746926f, 0.04822968f, 
    0.13433008f, 0.12644497f, 0.20373555f, 0.06658096f, 0.10607362f, 0.00628072f, 0.02799335f, 0.07935713f, 
    0.09202398f, -0.12836358f, 0.01945639f, 0.15113662f, -0.02693076f, -0.06240463f, -0.01148019f, -0.25651890f, 
    0.10464633f, 0.05581820f, 0.02999273f, 0.08976458f, 0.01278357f, 0.01684548f, 0.01400248f, 0.01948752f, 
    -0.20807420f, 0.12359794f, -0.12970863f, -0.00205943f, -0.01803014f, -0.08314441f, 0.04896878f, 0.08494305f, 
    0.01581357f, 0.07328920f, 0.21640663f, 0.10743820f, 0.32309398f, 0.01278977f, -0.31416818f, -0.04352294f, 
    -0.10564476f, 0.12342116f, 0.04170342f, 0.06349610f, -0.10468760f, -0.04988709f, 0.05589554f, 0.01540307f, 
    -0.38413909f, 0.16073541f, 0.08063956f, -0.07964171f, -0.08737029f, 0.04497089f, 0.09900072f, 0.03145736f, 
    -0.05085000f, -0.15759040f, -0.07819679f, -0.13948013f, -0.19846065f, -0.11709661f, 0.14173783f, -0.00251029f, 
    -0.03441823f, 0.06789778f, -0.01478980f, 0.02715449f, 0.10227056f, 0.02608467f, 0.01085513f, 0.16807699f, 
    -0.06615893f, -0.28824434f, 0.07632239f, -0.04041192f, -0.11689749f, 0.05091414f, -0.06418999f, 0.02429412f, 
    0.00107051f, 0.02771033f, -0.05945348f, 0.06864600f, -0.47248062f, -0.09067009f, -0.37282470f, 0.13684615f, 
    0.09168258f, 0.08843640f, -0.09035599f, 0.03951652f, 0.16175008f, -0.04401408f, -0.02515201f, 0.02798791f, 
    -0.34111410f, -0.03301000f, -0.25426713f, -0.25590384f, 0.10835835f, 0.10579380f, 0.01966792f, 0.03510535f, 
    -0.01280305f, 0.17435677f, -0.02365673f, -0.09326246f, 0.10638962f, -0.19993347f, -0.14260946f, -0.30437419f, 
    -0.01965229f, -0.02310112f, -0.10819263f, 0.11176240f, 0.11487206f, 0.05938024f, -0.06322207f, 0.11054593f, 
    0.23745844f, -0.31073189f, 0.16632703f, 0.18718582f, -0.01901008f, 0.08933137f, 0.00581492f, 0.03325215f, 
    0.16907962f, 0.09851166f, 0.03179488f, -0.16662104f, 0.06826524f, 0.00672219f, -0.20756932f, -0.04067814f, 
    0.13693404f, 0.04984893f, 0.04072580f, 0.13372470f, 0.18081172f, -0.00755237f, -0.05073031f, 0.08184566f, 
    0.19688444f, 0.17324957f, 0.16959414f, 0.16453399f, 0.10443949f, 0.00852972f, -0.06591731f, -0.19097836f, 
    0.04443699f, -0.00622053f, 0.15351184f, 0.05979897f, -0.43341041f, -0.18447916f, -0.19023730f, -0.24773937f, 
    0.16468984f, -0.02901464f, 0.05645388f, 0.14350538f, 0.02072706f, -0.02974274f, -0.06451421f, -0.08028716f, 
    -0.11936843f, 0.11455415f, -0.06200051f, -0.07542081f, 0.03788455f, 0.03767168f, 0.01709961f, 0.01881946f, 
    0.12520251f, 0.08117938f, 0.09764956f, -0.09774377f, -0.41689503f, -0.32272458f, -0.16111174f, 0.32746351f, 
    0.27190667f, 0.09843946f, 0.10395982f, 0.20500503f, 0.11153276f, -0.07224891f, 0.04561165f, 0.25096714f, 
    -0.04490699f, -0.11165652f, 0.02236787f, -0.17969230f, 0.08280076f, -0.00662254f, 0.01497950f, -0.11323113f, 
    -0.06570445f, 0.23709568f, -0.00097043f, 0.13658796f, 0.16568749f, -0.03019542f, 0.17859243f, 0.43314150f, 
    -0.07650893f, -0.06798818f, -0.10977776f, 0.04710095f, 0.03080660f, 0.07146280f, 0.06289859f, 0.17533460f, 
    -0.07787918f, -0.20993114f, 0.10062050f, 0.02873284f, -0.10745244f, -0.15984057f, -0.02070144f, -0.00485994f, 
    0.20855771f, 0.14701287f, 0.03517289f, 0.20046669f, -0.34971899f, 0.14272927f, -0.00569340f, -0.14516594f, 
    0.04969194f, 0.07727588f, 0.14450125f, -0.04054025f, 0.14834885f, 0.02240111f, 0.19529256f, 0.05460451f, 
    -0.17861676f, 0.01004207f, -0.16499422f, 0.01733577f, 0.15500598f, 0.09441249f, 0.06497544f, 0.07903831f, 
    0.11602677f, -0.10685775f, -0.10007880f, -0.10183637f, 0.05659917f, -0.31789178f, -0.12750077f, 0.19218798f, 
    0.06007652f, 0.07440832f, -0.11388718f, -0.06154856f, 0.03474636f, -0.04984600f, 0.05593599f, 0.01104087f, 
    -0.15750587f, 0.09077218f, -0.00121602f, -0.10970604f, 0.11103735f, -0.07656463f, -0.08096667f, 0.04288366f, 
    -0.17099154f, -0.05270107f, -0.04417456f, 0.09705588f, -0.26298475f, 0.04353596f, -0.02508933f, -0.08132072f, 
    -0.15733556f, -0.03700876f, -0.18053301f, -0.09868854f, 0.06417501f, 0.06225311f, 0.08867522f, 0.07537746f, 
    -0.00200841f, -0.02074243f, -0.31453949f, 0.11596630f, 0.01553967f, -0.04570613f, 0.17873621f, 0.06325629f, 
    0.14747727f, 0.09447832f, -0.03277049f, -0.20834832f, 0.16844596f, -0.03891584f, -0.07808257f, 0.13817962f, 
    -0.03395843f, 0.01981110f, -0.02515466f, 0.09166268f, 0.16144173f, 0.08639811f, -0.06137497f, -0.07511851f, 
    -0.00525471f, -0.07941539f, 0.10186685f, 0.03581224f, 0.04880556f, 0.05724254f, 0.03954918f, -0.04161970f, 
    0.26803988f, 0.11991064f, 0.00849568f, -0.06375782f, 0.09980902f, 0.17028190f, 0.12951787f, 0.08395969f, 
    -0.09439629f, 0.09528742f, 0.06085250f, 0.02261223f, 0.00091883f, 0.01237388f, 0.03054698f, 0.08686799f, 
    0.23456076f, -0.00469094f, 0.03344262f, -0.00682097f, 0.18976346f, 0.07587764f, -0.08989345f, 0.01466185f, 
    -0.05681129f, 0.03496943f, 0.14924151f, 0.06663983f, 0.04875756f, -0.13902575f, -0.12863374f, 0.10775342f, 
    0.02902217f, 0.03062313f, -0.12014844f, -0.01350687f, -0.06058546f, -0.05581459f, 0.02233728f, -0.09844678f, 
    -0.04880760f, 0.14391237f, -0.23581591f, -0.20349640f, -0.04724323f, 0.06410986f, -0.03551832f, -0.03450712f, 
    0.09301873f, 0.07848392f, 0.07956127f, -0.01081541f, 0.01418026f, 0.01868138f, -0.09992735f, -0.14108989f, 
    -0.00058041f, -0.06911638f, 0.00410372f, -0.00753224f, -0.03552449f, 0.03807659f, 0.07830809f, 0.12878665f, 
    -0.05912699f, 0.01181871f, 0.06930183f, -0.03884285f, 0.16574650f, -0.12457075f, -0.13219087f, -0.03574705f, 
    0.05040958f, 0.21140443f, -0.03168127f, 0.10562609f, -0.07075115f, -0.05710403f, -0.21176001f, 0.06758576f, 
    0.13821521f, 0.08520956f, -0.07627069f, 0.01967292f, 0.05514164f, 0.07247070f, -0.06864560f, -0.04432020f, 
    -0.09217054f, 0.09176126f, -0.05521676f, -0.02448582f, 0.10593426f, -0.10108341f, -0.01258854f, 0.11048639f, 
    0.02429492f, 0.07397883f, 0.12486929f, 0.10715671f, 0.09355919f, 0.08025449f, -0.16603069f, -0.06462767f, 
    0.02768764f, 0.22928929f, -0.05969074f, -0.08964826f, 0.04513683f, 0.10410648f, 0.18491946f, 0.12357784f, 
    -0.37342682f, 0.01112750f, 0.08936527f, -0.03622761f, -0.00373532f, 0.00920383f, 0.04095984f, -0.05819146f, 
    0.15285864f, -0.17836918f, 0.03330914f, -0.06094902f, -0.09011522f, 0.12631150f, -0.06600300f, 0.02366404f, 
    0.26670778f, -0.01132464f, 0.03665034f, 0.08863591f, -0.01325410f, 0.03486341f, 0.06071889f, 0.04161458f, 
    -0.31198764f, 0.13255395f, -0.14331780f, -0.09133192f, 0.05721452f, 0.00677506f, -0.04414451f, 0.11431680f, 
    -0.12021591f, 0.00052520f, -0.05980196f, 0.09982446f, -0.07206325f, 0.23420098f, -0.12107409f, 0.10513093f, 
    -0.01314096f, 0.05780391f, 0.00805214f, 0.04253449f, 0.03627014f, 0.03671752f, -0.02352474f, 0.01239308f, 
    0.05362877f, -0.04130402f, 0.00221913f, -0.05723688f, 0.00946117f, -0.04349777f, 0.03597729f, 0.08298024f, 
    0.02287132f, -0.00041352f, -0.01225548f, -0.00966373f, -0.03743109f, 0.09615512f, 0.05682811f, 0.00965967f, 
    0.19981436f, -0.04705053f, -0.05087719f, 0.00414681f, -0.05850347f, -0.00065665f, -0.14564687f, 0.01854545f, 
    0.26528439f, 0.24850769f, -0.02719586f, 0.08537695f, 0.09741616f, 0.01488273f, -0.01357197f, 0.02095894f, 
    0.05387084f, 0.01688169f, 0.00515337f, 0.03204620f, -0.09841751f, -0.04608708f, -0.02017375f, 0.05988560f, 
    -0.08664395f, -0.05310556f, 0.14970522f, 0.01286866f, 0.08709763f, 0.11841378f, -0.04966089f, -0.06711476f, 
    -0.32667232f, 0.14019977f, -0.12717628f, -0.18135735f, 0.07353506f, 0.06427404f, -0.05175025f, 0.00084661f, 
    -0.07627967f, 0.13657287f, -0.04783447f, 0.05934332f, -0.20892939f, 0.14830518f, 0.00488451f, 0.10541279f, 
    0.13378549f, -0.01520496f, -0.02994271f, 0.10682275f, 0.02673174f, 0.13464431f, -0.02178647f, -0.04646508f, 
    -0.20541942f, -0.03975552f, 0.15296240f, 0.30251122f, 0.02215526f, 0.00738028f, 0.03062891f, -0.10935926f, 
    0.01424635f, -0.07166800f, 0.10821202f, -0.06563770f, 0.11754286f, -0.01964465f, -0.16622448f, 0.18212381f, 
    0.03192950f, 0.26938465f, 0.08977882f, -0.10325370f, 0.06515963f, -0.09317327f, 0.07597858f, -0.00809676f, 
    0.11872113f, -0.07918978f, 0.13074361f, -0.03389686f, 0.14116724f, -0.14464003f, -0.11054327f, -0.09259750f, 
    -0.00522651f, 0.03980548f, 0.01587182f, 0.00813530f, 0.11962798f, -0.09415192f, -0.21515258f, -0.21782558f, 
    0.09574913f, -0.00395068f, -0.10695971f, 0.06692348f, -0.06024778f, -0.01195124f, 0.02172043f, -0.00528784f, 
    -0.11976415f, 0.06251411f, -0.09197244f, 0.26080421f, 0.03878531f, -0.14781268f, -0.06360584f, 0.07889819f, 
    0.10942011f, 0.06593463f, 0.13281703f, -0.02255432f, 0.12268554f, -0.13618319f, 0.03759617f, 0.09912033f, 
    -0.02717061f, -0.04339335f, 0.05228061f, 0.04436094f, -0.00887532f, -0.00488608f, 0.18733312f, 0.01001209f, 
    0.02799902f, -0.01310296f, -0.06225636f, -0.04028694f, 0.02544628f, -0.02631728f, 0.03817978f, -0.03839988f, 
    0.00809580f, 0.05717091f, -0.07378925f, -0.04078403f, -0.07693315f, -0.07863781f, -0.01924793f, 0.00419010f, 
    -0.03361889f, -0.04892953f, 0.00552454f, -0.08315692f, 0.03556677f, 0.03786573f, -0.00890315f, -0.00763916f, 
    0.03599148f, -0.02846171f, -0.05080886f, 0.04165458f, -0.05716283f, 0.03364969f, 0.04696367f, 0.01016257f, 
    0.00772369f, -0.06234805f, 0.03666842f, -0.06933269f, 0.01332832f, -0.02431596f, -0.05100231f, -0.03578420f, 
    -0.04234019f, -0.01898541f, -0.06863294f, -0.05163668f, 0.05563612f, -0.06183089f, 0.04653249f, -0.01311891f, 
    0.03576509f, 0.05696032f, 0.01164900f, 0.03744678f, -0.07729753f, -0.02652068f, 0.05113653f, -0.03300447f, 
    0.00557316f, 0.00234811f, -0.05701787f, -0.00877214f, 0.04552040f, -0.05503060f, -0.03551589f, 0.01162806f, 
    0.00642610f, -0.06523871f, 0.05768565f, 0.01687489f, -0.01885308f, 0.05425893f, -0.06678882f, 0.04353357f, 
    -0.01256981f, -0.03353248f, -0.01664989f, 0.00654891f, -0.01374462f, -0.01110947f, -0.05730554f, -0.02106678f, 
    0.02630892f, 0.03417806f, 0.01099849f, -0.00697800f, 0.03880886f, 0.01367184f, -0.02749001f, 0.02232456f, 
    -0.03224664f, 0.05667341f, 0.05064988f, -0.04489002f, -0.06674808f, -0.08567081f, -0.04812204f, -0.02463163f, 
    -0.01947087f, -0.01161061f, 0.01919850f, -0.00395578f, 0.01849268f, -0.04132174f, -0.06372723f, 0.03661705f, 
    0.02545108f, 0.03672829f, -0.04016832f, -0.04711130f, -0.07978059f, -0.05931789f, 0.04921109f, -0.00235028f, 
    -0.03819446f, -0.03515890f, 0.05293854f, -0.02393454f, 0.01383922f, -0.08506712f, 0.02741960f, -0.04225749f, 
    -0.06938204f, 0.03949150f, 0.04218570f, 0.01057021f, 0.02330933f, 0.03845010f, 0.03311726f, -0.03410669f, 
    0.02177366f, 0.05717643f, -0.01602551f, 0.01314303f, -0.03114608f, -0.04792426f, 0.02773717f, -0.00275635f, 
    -0.03597989f, -0.02785919f, 0.05833434f, -0.07154898f, -0.00138755f, 0.04472274f, -0.02249112f, -0.05468444f, 
    -0.08719409f, 0.04341291f, -0.06862576f, -0.06016009f, 0.01254938f, -0.02119600f, 0.01171759f, 0.01730088f, 
    0.02580017f, 0.01107116f, -0.07540604f, -0.08366296f, -0.06157960f, -0.02047971f, 0.00466948f, 0.04557702f, 
    0.03293480f, -0.07279587f, 0.04785369f, 0.00641905f, 0.01436383f, 0.01393099f, -0.04862239f, -0.02280795f, 
    -0.00884519f, -0.06964650f, -0.06555772f, 0.05912605f, -0.00505395f, -0.02525031f, -0.06015792f, -0.08027317f, 
    -0.06655940f, 0.01200031f, -0.05454825f, 0.03920137f, -0.00915771f, -0.04183786f, 0.00345989f, 0.03423756f, 
    -0.07792821f, -0.04050322f, 0.04247899f, -0.00561556f, 0.04190866f, 0.00199324f, 0.01817229f, -0.03269963f, 
    -0.02011476f, -0.02603155f, -0.07544906f, -0.05456766f, -0.07146508f, -0.05107627f, -0.00052547f, 0.06420482f, 
    -0.02765472f, -0.00553982f, -0.00587342f, -0.01271190f, -0.00188979f, 0.00965493f, -0.02870986f, -0.00726633f, 
    -0.04083980f, -0.06169176f, -0.06919905f, 0.03083354f, 0.04954014f, -0.06641883f, -0.04100454f, -0.04185452f, 
    -0.02197794f, -0.04826851f, 0.00595299f, -0.06860392f, 0.04583629f, 0.00277520f, -0.05917276f, -0.06703531f, 
    -0.05241496f, 0.02954134f, -0.03736494f, -0.03425197f, -0.00372776f, 0.04738685f, -0.00853779f, 0.00533790f, 
    -0.02406513f, 0.03854041f, 0.05603284f, -0.05835399f, 0.01455966f, -0.01147145f, 0.06014822f, -0.01095178f, 
    0.06381890f, -0.00213489f, 0.04899128f, 0.02543124f, 0.01201864f, -0.05319263f, 0.02101930f, -0.05645354f, 
    -0.01713671f, -0.01743934f, -0.05564171f, 0.05295525f, -0.01324881f, 0.04639391f, 0.05201387f, -0.03783685f, 
    0.02192131f, -0.00579652f, -0.04128737f, -0.05173794f, -0.01134470f, -0.06117312f, -0.05804188f, -0.03578787f, 
    0.04568714f, 0.03716717f, -0.04159370f, -0.04974452f, -0.03435624f, 0.05785765f, 0.03205140f, -0.00060549f, 
    -0.07704491f, -0.00188687f, 0.03479919f, 0.02673184f, -0.01944807f, 0.05507398f, -0.04627726f, 0.05217947f, 
    0.01850609f, -0.06389899f, -0.01369025f, -0.05700109f, 0.03461830f, -0.04050722f, 0.05408346f, -0.01056530f, 
    0.04409199f, 0.00846497f, 0.00211039f, 0.00211829f, 0.01287305f, -0.03054976f, -0.04799821f, 0.06449576f, 
    -0.06482290f, -0.00770528f, -0.04079450f, -0.02345341f, 0.02752827f, 0.06409738f, 0.01060079f, 0.01127343f, 
    -0.02486566f, -0.02075305f, 0.03581192f, 0.02486076f, -0.05957967f, 0.02710690f, 0.03944119f, 0.02705478f, 
    0.02845468f, 0.02320688f, 0.02975182f, 0.02033561f, 0.02981371f, -0.02729244f, -0.05580658f, -0.00252656f, 
    0.03670451f, -0.02591549f, 0.05372402f, 0.00477060f, 0.02937525f, -0.01898625f, -0.03423152f, -0.05480949f, 
    0.04841506f, -0.05612834f, -0.06963530f, 0.04459833f, 0.03441862f, 0.03655152f, -0.01654766f, -0.04165145f, 
    -0.02240385f, -0.00365456f, -0.05058306f, -0.01758824f, -0.03079076f, -0.02846033f, 0.04461395f, 0.03246902f, 
    -0.04640712f, -0.05611615f, 0.04995125f, 0.04989477f, -0.03642031f, -0.03882665f, 0.05562469f, 0.01484678f, 
    -0.06479234f, -0.04188661f, 0.02178997f, -0.00856198f, 0.02259232f, 0.03308897f, 0.00608031f, -0.04647158f, 
    -0.03446154f, -0.02389506f, -0.05400055f, -0.03892746f, -0.04159930f, -0.07533589f, -0.06588019f, -0.04088001f, 
    0.03531904f, -0.02088949f, -0.07167699f, 0.01299006f, 0.04336189f, -0.01520775f, 0.04796824f, -0.02642829f, 
    -0.06656376f, 0.05079073f, 0.03420438f, 0.04287124f, -0.05906593f, -0.00943636f, 0.02033068f, -0.05825829f, 
    -0.39087284f, -0.30451107f, 0.13384457f, 0.21476066f, -0.19682720f, -0.18382138f, -0.00980304f, -0.27525872f, 
    -0.09763960f, 0.15012071f, -0.04785981f, -0.11703201f, 0.04227613f, 0.20512930f, -0.19663219f, 0.14540055f, 
    -0.10029723f, -0.09504473f, -0.07472944f, -0.13899122f, -0.09661578f, 0.05041670f, -0.04432088f, -0.07022452f, 
    0.02958888f, 0.14450698f, 0.03195231f, -0.06626887f, 0.06229455f, 0.05816808f, 0.02802437f, -0.02019388f, 
    -0.18967256f, -0.14899328f, 0.04209366f, 0.03604278f, -0.04754169f, 0.25834137f, 0.03605955f, -0.02358426f, 
    0.20898117f, 0.03801040f, -0.02574196f, -0.03412539f, 0.02374343f, 0.02831510f, -0.09638429f, -0.06349992f, 
    -0.00439434f, 0.11258074f, 0.10643264f, 0.07517586f, 0.17871141f, 0.08107650f, -0.05152658f, -0.00185815f, 
    0.01531272f, -0.08344599f, -0.00137172f, -0.13483253f, 0.28811547f, -0.02983423f, -0.58719796f, -0.08323803f, 
    0.06622948f, 0.01837712f, 0.02397780f, -0.00303923f, 0.04995067f, 0.09082437f, -0.05908985f, -0.15206918f, 
    0.14687033f, 0.23816296f, 0.25453231f, 0.09336989f, -0.26230583f, -0.08655085f, -0.29729557f, 0.04182585f, 
    0.08287258f, 0.10457034f, -0.10574206f, 0.06520735f, -0.06645345f, -0.09459049f, 0.10829853f, -0.04681031f, 
    0.22261682f, 0.14285776f, 0.02702327f, -0.03355037f, 0.03829426f, 0.00348914f, -0.06859096f, 0.05817594f, 
    -0.54086751f, 0.11941462f, 0.38910913f, 0.09584039f, -0.04275874f, -0.05766290f, 0.02562931f, -0.05887936f, 
    0.03027743f, -0.21285324f, -0.10385379f, -0.19967760f, 0.10248359f, 0.00462903f, -0.05886116f, -0.03829943f, 
    0.28627589f, 0.07952742f, 0.19843997f, 0.14348377f, -0.10908204f, 0.09864994f, -0.06920807f, -0.06889045f, 
    0.24698934f, 0.23483612f, 0.20742260f, -0.01315238f, -0.09447978f, 0.06588060f, 0.00426829f, -0.00244372f, 
    -0.34628931f, 0.03905638f, 0.15065849f, -0.05137281f, 0.05677054f, 0.09003738f, -0.30229509f, 0.04039896f, 
    0.25760269f, 0.22473449f, 0.22638929f, 0.10302295f, 0.08540582f, 0.01147458f, 0.09217620f, 0.18974754f, 
    -0.12161084f, 0.15265170f, 0.00943908f, -0.07432729f, 0.11969505f, 0.08272367f, -0.01285647f, -0.25674903f, 
    0.01534375f, 0.03359274f, 0.09432593f, -0.11496982f, -0.03396565f, 0.02508582f, 0.00860398f, 0.29716635f, 
    -0.35387415f, -0.16060460f, -0.16123272f, -0.01986313f, 0.05804731f, -0.12580548f, -0.04131343f, -0.05961864f, 
    0.12090714f, 0.13492846f, -0.03340651f, -0.14197648f, -0.00902716f, 0.07450758f, 0.08605244f, -0.02213302f, 
    -0.27089790f, 0.04761434f, -0.06423978f, -0.02429084f, 0.14609316f, 0.04314621f, 0.00829909f, -0.15310146f, 
    0.03607110f, 0.07685819f, 0.07330213f, 0.14232683f, -0.23297828f, 0.05868364f, -0.03718582f, 0.05304459f, 
    -0.02784445f, 0.16975361f, 0.01756418f, 0.00356928f, 0.10120872f, 0.06233296f, -0.09669442f, 0.07156828f, 
    -0.07504194f, 0.08293393f, 0.10794861f, -0.02278718f, -0.25276792f, 0.15145347f, 0.01538595f, 0.19870122f, 
    -0.07630415f, 0.14311896f, -0.03030826f, 0.07743814f, 0.07952654f, -0.08321099f, -0.00873059f, -0.00337010f, 
    -0.03457344f, 0.15638690f, 0.00598102f, -0.02806563f, -0.03030130f, 0.11095295f, 0.01608706f, 0.01342544f, 
    0.09105671f, -0.00416939f, 0.11811113f, 0.07471814f, 0.16230823f, -0.06290994f, 0.02432281f, -0.26138982f, 
    0.07667284f, -0.00568899f, -0.01915459f, -0.04496684f, -0.04851099f, -0.09792016f, -0.01428005f, -0.00955965f, 
    -0.22912724f, -0.24028942f, 0.05367622f, -0.05415824f, 0.08243222f, 0.02144529f, 0.06013570f, -0.07669122f, 
    -0.10513409f, -0.18679988f, 0.06323060f, -0.01333020f, -0.44937450f, -0.24022856f, -0.04558768f, 0.25542596f, 
    0.04576678f, 0.02354397f, 0.02239955f, 0.12001146f, -0.04145498f, -0.00086083f, 0.03368117f, -0.00761130f, 
    -0.01329746f, -0.09537257f, 0.20835504f, 0.24683285f, -0.05461085f, -0.01797313f, -0.09736882f, 0.00452084f, 
    -0.01825518f, -0.10010751f, -0.02380368f, -0.00099700f, -0.00243132f, -0.31387693f, -0.07509686f, -0.13354456f, 
    0.26660770f, 0.09034562f, 0.08475191f, -0.11403849f, -0.06671409f, 0.00423313f, 0.07435043f, -0.02217115f, 
    0.17091124f, 0.15183868f, 0.23767343f, -0.07434277f, 0.09387996f, -0.02209872f, -0.01465815f, 0.08636509f, 
    -0.06221507f, -0.06965576f, 0.03416332f, -0.04209051f, 0.03224255f, -0.37495393f, -0.21145433f, -0.12921533f, 
    0.24093355f, 0.08732111f, -0.08057376f, 0.01213734f, -0.06869315f, -0.07730623f, 0.07472705f, 0.08384816f, 
    0.27578491f, -0.15333188f, 0.03202419f, 0.08526627f, -0.07209095f, 0.03529477f, 0.01104691f, 0.02223399f, 
    -0.11235590f, 0.08694645f, 0.00349177f, -0.03940446f, -0.18101947f, 0.14358363f, -0.18060005f, 0.15844601f, 
    0.16965191f, 0.13420153f, 0.12910925f, 0.07137152f, -0.02082780f, 0.10452013f, 0.09451400f, -0.02435522f, 
    -0.18906298f, 0.12272457f, -0.10464919f, 0.23234795f, 0.03245630f, 0.01969002f, 0.01921915f, 0.05539667f, 
    0.10656340f, -0.00137287f, -0.08791426f, -0.14891967f, -0.05364987f, 0.24278025f, 0.27327687f, -0.14060260f, 
    -0.02730747f, 0.04492462f, -0.03578440f, 0.03453722f, 0.02888445f, -0.01496283f, 0.00228578f, 0.04445011f, 
    0.01930681f, 0.10838868f, -0.25341630f, -0.15512551f, -0.04102343f, 0.00012151f, 0.03200521f, -0.04879749f, 
    0.10420929f, 0.04530736f, -0.02856800f, 0.11482770f, 0.07511847f, -0.18593131f, 0.26053146f, 0.17971376f, 
    -0.07212479f, -0.00135079f, 0.01414440f, 0.00602148f, 0.05780004f, -0.10652279f, -0.01833332f, 0.02249707f, 
    -0.06822765f, -0.03361103f, -0.03399397f, 0.03235456f, 0.05975610f, -0.06844886f, 0.03179517f, 0.00547438f, 
    -0.05156011f, -0.00585028f, -0.07730085f, -0.07233857f, 0.01579511f, 0.05237209f, 0.04505740f, 0.06517538f, 
    0.05532570f, 0.00260787f, 0.05189427f, -0.07574877f, -0.03896363f, -0.06174527f, 0.00611038f, -0.04741507f, 
    -0.03025786f, 0.00775723f, 0.06144362f, -0.01260800f, -0.02672658f, -0.00011181f, -0.00832270f, 0.01203087f, 
    0.01631197f, -0.04164512f, -0.04049460f, 0.02517474f, -0.06078753f, -0.02668453f, -0.03950602f, -0.02530060f, 
    0.03636104f, -0.02234740f, -0.04637596f, -0.07403376f, 0.01660337f, -0.05761072f, -0.01347621f, 0.00255474f, 
    0.00717025f, 0.00430217f, -0.00316400f, -0.02418404f, -0.03335052f, -0.03003388f, -0.01176116f, -0.03517339f, 
    -0.05655703f, 0.06527353f, -0.07185077f, -0.05467939f, 0.01671195f, -0.03333227f, -0.01469280f, 0.01351214f, 
    0.01190957f, 0.03599804f, 0.00884582f, -0.05212852f, 0.01448716f, 0.01662431f, -0.00452152f, 0.03110325f, 
    0.03914711f, -0.05752550f, -0.03371029f, -0.05176460f, -0.03846505f, 0.06487324f, -0.01661348f, 0.02326325f, 
    -0.05005421f, 0.00836480f, -0.04026985f, -0.02174811f, 0.05404942f, 0.01184182f, 0.02197334f, -0.01105714f, 
    0.04643997f, 0.00107800f, 0.02292969f, 0.04308706f, 0.02214756f, 0.02076332f, -0.02606286f, 0.03040978f, 
    -0.04484532f, 0.06052382f, -0.03774394f, 0.04785086f, -0.03145522f, -0.05492635f, 0.03759374f, -0.03954348f, 
    -0.00872292f, 0.03040611f, -0.01190101f, 0.01424312f, 0.01767448f, -0.06770159f, 0.01109831f, -0.03946176f, 
    -0.07448979f, 0.05380906f, -0.06543155f, -0.02968818f, -0.04962492f, -0.04295374f, -0.00223560f, 0.05405974f, 
    0.05154541f, -0.06588168f, -0.03670388f, -0.04454900f, 0.06204041f, -0.07604612f, -0.06946886f, -0.00658569f, 
    -0.03011892f, 0.04942392f, -0.03195257f, 0.01753072f, 0.06619743f, 0.02428801f, -0.04561643f, -0.03314402f, 
    0.02603675f, -0.03514409f, 0.02008923f, 0.01939571f, -0.01350394f, 0.02440949f, 0.04166234f, 0.00417439f, 
    0.03074119f, 0.01769404f, -0.06050156f, -0.05461512f, 0.01834911f, -0.07319696f, 0.00533333f, -0.01645758f, 
    0.00717204f, 0.01549053f, -0.05990161f, 0.00811643f, -0.01873821f, 0.03447807f, 0.01607938f, -0.04816901f, 
    -0.03774634f, -0.04566111f, -0.06148230f, -0.05537014f, 0.03767742f, -0.03293371f, 0.04442492f, -0.05401408f, 
    -0.05130281f, -0.07962593f, 0.05352246f, -0.06373091f, 0.02718888f, -0.04634720f, 0.02121251f, 0.02382926f, 
    0.01579996f, -0.04393487f, 0.05789141f, 0.05174989f, -0.00887566f, -0.00680746f, -0.05296152f, 0.04357404f, 
    -0.06911130f, -0.06016237f, -0.00082600f, 0.03149925f, -0.05382686f, -0.05496340f, -0.07501836f, -0.00179361f, 
    0.00998716f, 0.11371326f, -0.16177489f, -0.16378447f, 0.05017627f, -0.07417232f, 0.02003794f, 0.03913267f, 
    0.06895647f, 0.20859911f, -0.03654339f, 0.02592793f, 0.18876135f, -0.17273077f, 0.08518494f, 0.02117403f, 
    -0.14173710f, 0.01467728f, 0.02828727f, -0.03326526f, -0.05446960f, 0.09197897f, -0.01705590f, -0.05146186f, 
    -0.03531981f, 0.13730066f, -0.10637213f, -0.05836157f, 0.16085349f, -0.08524358f, -0.10348883f, 0.12832680f, 
    0.10639306f, 0.11381914f, -0.10938764f, 0.00475361f, 0.11847627f, -0.03557228f, 0.07530896f, 0.01701147f, 
    -0.08258191f, 0.17421137f, -0.08476119f, 0.00962428f, 0.04947982f, -0.06818245f, 0.03511269f, 0.12651646f, 
    0.25793523f, -0.00633604f, -0.13281012f, 0.17434776f, 0.02366681f, -0.13075787f, -0.05131449f, 0.14651023f, 
    0.02504500f, 0.00153586f, 0.06846507f, 0.13828222f, -0.07658272f, -0.13657245f, 0.24399965f, -0.11736166f, 
    0.06457376f, -0.04515061f, 0.18316640f, 0.03141263f, -0.03227374f, 0.03572757f, 0.08592631f, -0.05590831f, 
    -0.00450752f, -0.00765370f, 0.15328391f, 0.03506347f, -0.00243761f, 0.03974881f, -0.03055905f, -0.08379421f, 
    0.10007905f, 0.22108467f, -0.06173829f, 0.32283637f, 0.23888117f, 0.27832729f, 0.03952667f, -0.01122039f, 
    -0.05732383f, -0.07790998f, 0.02126797f, 0.07216223f, -0.07404356f, 0.10889673f, 0.04942016f, -0.07791653f, 
    -0.07612597f, -0.07675618f, -0.31914696f, 0.06473738f, 0.03984912f, -0.02232374f, -0.11586811f, -0.11317254f, 
    -0.01183197f, 0.03700123f, 0.01175387f, 0.01288640f, 0.34448326f, 0.14694223f, 0.10029841f, 0.18580531f, 
    -0.01291125f, -0.11035996f, 0.10165241f, 0.08250497f, -0.07978197f, 0.04484339f, 0.10051771f, 0.05004719f, 
    0.15300882f, 0.37537780f, -0.20145971f, -0.15425213f, 0.06080840f, -0.06559911f, 0.09728833f, -0.10257570f, 
    -0.00671030f, -0.03187712f, -0.01570964f, -0.08727948f, 0.29977003f, -0.00760538f, 0.16306093f, -0.05324389f, 
    -0.04303590f, -0.04187177f, -0.13521017f, 0.07633239f, -0.00422859f, -0.07120728f, -0.10778642f, 0.10101895f, 
    -0.03963687f, -0.49228182f, 0.02183670f, -0.01884599f, -0.08078348f, 0.11227696f, 0.03019836f, 0.08121906f, 
    0.07813558f, -0.20488331f, 0.08299041f, -0.10858935f, -0.05108383f, -0.14061083f, -0.10929524f, 0.19683219f, 
    -0.01590994f, 0.02956510f, -0.08291584f, -0.03661073f, 0.01954799f, 0.11318783f, 0.07793943f, -0.03620386f, 
    0.21946768f, 0.09689483f, 0.14849405f, 0.33425063f, 0.11384656f, 0.07125332f, 0.07590326f, -0.10959745f, 
    0.03702004f, -0.03100278f, 0.13330939f, -0.20978506f, -0.14517827f, 0.10788270f, 0.04295768f, -0.06131306f, 
    0.05513274f, 0.10774828f, 0.07434224f, 0.04805668f, -0.01881825f, 0.08289395f, -0.14645910f, -0.09755366f, 
    0.02607771f, -0.03195373f, -0.09440993f, -0.02501285f, -0.03589187f, -0.00625771f, -0.00946091f, -0.00598069f, 
    0.05365843f, 0.12335465f, -0.01288626f, 0.09813210f, -0.07163029f, -0.07623866f, -0.08062728f, 0.03349597f, 
    0.04013184f, -0.01651790f, 0.09885122f, 0.01104557f, 0.02649487f, 0.08659270f, -0.05560657f, -0.16603425f, 
    0.32619041f, 0.14128312f, 0.00284160f, 0.08660155f, 0.02227436f, -0.01352801f, -0.10833199f, -0.00130666f, 
    0.15529227f, 0.01484666f, -0.12253703f, -0.05317331f, 0.06884497f, -0.19192436f, 0.04143069f, 0.04314839f, 
    -0.06631816f, 0.14703593f, 0.13769069f, -0.03175764f, -0.09283072f, -0.06868257f, 0.03447893f, 0.02969899f, 
    0.11454869f, -0.07430793f, 0.21197975f, 0.06122011f, -0.03878800f, -0.00389700f, -0.07215841f, 0.03949192f, 
    -0.06202311f, -0.03405958f, 0.00202620f, 0.11438143f, -0.09653173f, 0.05018051f, 0.18632320f, -0.04256989f, 
    -0.01016148f, 0.03468874f, 0.08942462f, -0.06050612f, 0.00279531f, 0.12529117f, 0.16182524f, -0.09069937f, 
    -0.06538089f, 0.04171236f, 0.18723273f, 0.12143621f, 0.04486676f, 0.00437481f, -0.13140430f, 0.06582590f, 
    -0.07855798f, 0.00881113f, -0.11301321f, 0.17808677f, 0.06107615f, 0.20905714f, -0.04176288f, -0.01988374f, 
    0.11679031f, -0.00075455f, 0.09793163f, 0.09843797f, -0.13437618f, 0.05406800f, 0.00432021f, -0.10716536f, 
    0.01125338f, 0.03858060f, -0.13196643f, 0.02764030f, 0.00892971f, 0.05393446f, 0.05447432f, 0.01400602f, 
    -0.13270615f, -0.04548043f, -0.00720383f, 0.08431123f, 0.35688555f, 0.05208985f, 0.16576879f, -0.08289592f, 
    -0.07438555f, 0.02031287f, -0.05960620f, 0.03754685f, 0.05535279f, -0.04254608f, 0.12344848f, -0.04863051f, 
    -0.12330537f, 0.05186033f, -0.15520623f, -0.00864705f, 0.06146484f, -0.04030519f, 0.15292847f, -0.05183918f, 
    0.06158354f, -0.03854800f, 0.02191181f, 0.00356507f, 0.14176691f, 0.10941062f, 0.09440663f, -0.11731005f, 
    -0.03043306f, 0.03023251f, 0.05072337f, -0.00979653f, -0.01897102f, 0.04963553f, 0.00445502f, -0.08345626f, 
    -0.10791045f, -0.22123227f, -0.00878388f, 0.14542207f, -0.03410013f, 0.04470532f, 0.10256094f, 0.06723972f, 
    -0.03655242f, -0.15916310f, 0.09558992f, -0.02883236f, 0.10377679f, 0.27723417f, 0.03790247f, -0.16242151f, 
    -0.02286406f, 0.04728310f, 0.06549154f, -0.02668304f, -0.03341004f, 0.04700123f, 0.04236381f, 0.03666683f, 
    0.29564235f, 0.00231409f, 0.15842398f, 0.13145243f, -0.01444784f, 0.02338235f, -0.02026067f, -0.05608617f, 
    -0.03432557f, -0.10032956f, -0.09191447f, -0.15916407f, 0.00077075f, -0.09280214f, 0.03264824f, 0.11222850f, 
    0.02410451f, -0.06874716f, 0.03784495f, 0.01595611f, -0.05228997f, -0.01198178f, -0.19843952f, -0.06791823f, 
    -0.05513054f, -0.05998500f, 0.01728260f, 0.17986040f, 0.01089642f, 0.07436950f, 0.09060193f, 0.07371255f, 
    -0.01059180f, -0.05532339f, -0.05761307f, 0.08906895f, 0.26357809f, 0.02388935f, -0.00351199f, 0.14496088f, 
    0.00746953f, -0.03862759f, -0.07223845f, 0.08294417f, -0.08020041f, -0.01334144f, 0.10865744f, -0.04786594f, 
    -0.06904552f, -0.11936772f, -0.07347576f, -0.09816127f, -0.01686780f, 0.04714293f, -0.06190012f, 0.10875188f, 
    -0.01985820f, 0.10208233f, 0.00339213f, 0.00699614f, -0.21870175f, 0.01742783f, 0.00721612f, 0.05786803f, 
    0.00400475f, -0.10479856f, -0.06956049f, -0.10151961f, 0.02896665f, -0.07779073f, 0.06053617f, 0.06474966f, 
    0.03844787f, -0.04550547f, -0.11074494f, 0.05562859f, 0.08464377f, 0.16621801f, 0.00707798f, -0.07005482f, 
    -0.00061965f, 0.05882869f, 0.02573904f, -0.14723141f, 0.14693123f, -0.10872618f, -0.09824135f, -0.01260154f, 
    0.14681141f, -0.02841062f, -0.03401735f, 0.05448769f, 0.04712926f, 0.09897172f, 0.05164819f, -0.10325221f, 
    0.22516209f, 0.22799473f, -0.08667362f, -0.02624975f, 0.12680705f, -0.04483322f, 0.10360814f, 0.07754042f, 
    -0.00230252f, 0.00724878f, -0.02045783f, -0.04868443f, 0.03419929f, -0.01006947f, 0.10124912f, -0.09888499f, 
    -0.01792811f, -0.01315120f, -0.00745677f, 0.04479466f, 0.06436222f, -0.19357462f, -0.06318453f, 0.06778434f, 
    0.31322390f, -0.07746830f, 0.11531740f, 0.18177287f, 0.06394779f, 0.06564998f, 0.03811847f, -0.03162638f, 
    -0.03474847f, 0.03026408f, 0.06430924f, 0.10199567f, 0.16096428f, -0.21948989f, 0.05148163f, -0.02118767f, 
    0.04643533f, 0.00911728f, -0.07485077f, -0.01567886f, 0.03774463f, -0.00682102f, 0.02027647f, 0.02446574f, 
    -0.18438084f, -0.06391577f, -0.26427326f, -0.16062285f, -0.03345866f, -0.02206231f, 0.01677380f, -0.07230803f, 
    0.07682049f, 0.05277947f, 0.00266542f, 0.01839598f, -0.13228296f, 0.05617797f, -0.11306556f, -0.23580368f, 
    -0.03153524f, -0.00010671f, -0.03887926f, -0.17506306f, -0.01711681f, 0.15148734f, -0.06052953f, 0.00665028f, 
    0.12176374f, 0.03308531f, 0.05048649f, -0.08326637f, 0.03883966f, 0.01361279f, 0.00155153f, -0.03530472f, 
    0.03924039f, 0.07507293f, 0.13370483f, 0.07562978f, 0.30412331f, 0.22506444f, 0.05698859f, 0.08706988f, 
    0.03109907f, 0.06299768f, 0.02792597f, 0.07592475f, -0.01686551f, 0.02572121f, -0.09710957f, 0.14263463f, 
    -0.14361580f, -0.04241082f, -0.05601943f, -0.19577456f, 0.03699369f, -0.01025297f, -0.11480535f, 0.11546152f, 
    -0.11501499f, 0.02144803f, -0.07828731f, 0.08105826f, 0.10231521f, 0.04533575f, -0.25085154f, 0.06128687f, 
    0.05991764f, 0.08013704f, -0.01281874f, -0.09493098f, 0.04140616f, -0.07405970f, 0.09357262f, 0.05588036f, 
    0.08923206f, -0.01550476f, 0.09812918f, -0.08646097f, -0.06799658f, 0.03360455f, 0.08010088f, 0.10139212f, 
    -0.17361993f, 0.04471507f, 0.17172742f, 0.06678351f, 0.05706948f, 0.07050864f, 0.04829805f, 0.01231340f, 
    -0.05913275f, 0.03886300f, 0.20634827f, 0.08482808f, 0.16126713f, -0.05942384f, -0.05786772f, -0.02525191f, 
    -0.06642137f, 0.11565439f, 0.03072398f, 0.04501820f, 0.00793465f, 0.12534653f, 0.06765121f, 0.02119109f, 
    0.10400118f, 0.00346841f, 0.12220635f, 0.02559866f, 0.19533363f, -0.03078538f, -0.05662684f, -0.15507889f, 
    0.05235640f, 0.10182739f, 0.07804739f, 0.01040369f, -0.03136617f, -0.00439634f, 0.03573134f, -0.08661692f, 
    -0.31489694f, -0.04786209f, 0.10310838f, -0.13408718f, -0.07079886f, -0.05465347f, 0.08394726f, 0.04645619f, 
    -0.01980733f, -0.19836870f, 0.03929804f, 0.06753999f, -0.19875674f, -0.26957148f, 0.07094911f, 0.08171679f, 
    0.05693000f, -0.06167407f, 0.09110167f, -0.07319317f, -0.00558492f, 0.04454187f, 0.04063308f, 0.06798086f, 
    -0.14053428f, 0.06258154f, 0.23366839f, -0.06868347f, 0.00121614f, 0.12854704f, -0.13180065f, -0.04161918f, 
    -0.04525711f, -0.02707954f, 0.06286181f, 0.22197235f, -0.13232093f, -0.02139160f, -0.13387327f, -0.03062267f, 
    0.06897411f, -0.06544504f, 0.06052837f, -0.04324250f, 0.02849648f, 0.12522228f, -0.05493806f, 0.02772466f, 
    -0.26950854f, 0.08831613f, -0.03902133f, -0.18369049f, 0.06967455f, -0.04626460f, 0.12991419f, 0.01304963f, 
    0.09431344f, -0.05589854f, -0.01319514f, -0.10511982f, -0.07387979f, 0.02312144f, -0.14515918f, 0.22690082f, 
    0.13245258f, -0.09795867f, -0.00094527f, 0.16226861f, -0.07087165f, 0.09136298f, 0.03465972f, 0.16143589f, 
    0.45316741f, -0.02994337f, 0.28687549f, 0.33547992f, 0.02834760f, -0.05011490f, 0.04307972f, 0.05256796f, 
    -0.17576487f, 0.02117964f, 0.07620515f, 0.05620428f, 0.03017776f, 0.03828761f, -0.08287102f, 0.08376202f, 
    0.01513483f, -0.05792753f, -0.12907328f, 0.00971591f, 0.13348109f, 0.01447069f, 0.09355752f, 0.04248080f, 
    -0.08061444f, -0.15345231f, 0.04502693f, 0.22456971f, -0.01481240f, 0.08015237f, 0.07186305f, 0.13316669f, 
    0.02741173f, -0.10013327f, -0.01902352f, -0.15983900f, -0.05879498f, 0.06425061f, 0.06087500f, -0.05669931f, 
    0.00133277f, 0.06930210f, 0.09829498f, -0.16528833f, 0.08073594f, -0.06803071f, -0.06056260f, 0.05462351f, 
    0.15537591f, 0.16142070f, 0.15374637f, 0.16803195f, 0.09213290f, 0.20314455f, -0.00250377f, -0.02929570f, 
    0.03652964f, -0.15875109f, -0.03233356f, 0.03806362f, -0.03095807f, -0.01640424f, 0.36282611f, 0.13080329f, 
    0.09457409f, -0.09578887f, 0.07709107f, 0.26349378f, 0.03763924f, -0.02129952f, -0.16919132f, -0.01466893f, 
    0.08141561f, 0.20093800f, -0.18182144f, -0.13273570f, 0.05016128f, 0.07660373f, -0.02865755f, 0.04059471f, 
    0.10765643f, 0.11716845f, 0.13566586f, 0.08077662f, 0.09822412f, -0.00047779f, -0.02384420f, 0.04012362f, 
    -0.06078451f, -0.06438486f, 0.01022819f, 0.10700145f, -0.01685282f, -0.05040250f, -0.05609112f, 0.01145713f, 
    -0.26708466f, 0.30953139f, -0.00084212f, -0.11225600f, 0.07133080f, -0.11993060f, 0.10964923f, 0.17090414f, 
    0.07899889f, 0.10397837f, -0.00561461f, 0.05984579f, 0.24266665f, 0.03000211f, 0.27004826f, -0.36772558f, 
    -0.08840869f, 0.02360780f, -0.08714136f, 0.03182270f, -0.02976739f, 0.04349640f, -0.00376466f, 0.00293155f, 
    -0.16900630f, 0.04913307f, -0.00743955f, 0.13724335f, 0.00708116f, -0.11974132f, -0.01754540f, 0.06664755f, 
    0.01192193f, -0.26002374f, 0.04018297f, -0.08479781f, -0.06144460f, 0.02872360f, 0.26184636f, 0.28857461f, 
    0.02854351f, 0.03571417f, 0.09210547f, 0.10887856f, -0.04401721f, 0.08790503f, -0.04249818f, 0.11714330f, 
    0.03887956f, 0.08278271f, -0.08833041f, -0.01771684f, 0.13745448f, 0.01760500f, -0.03026677f, -0.08678640f, 
    0.19240823f, 0.03396863f, 0.10679754f, 0.11322340f, 0.11153390f, 0.08830079f, 0.09143636f, 0.04581939f, 
    -0.10372639f, -0.12270685f, 0.07845180f, 0.01818256f, 0.01176817f, 0.14281556f, 0.10480046f, -0.17571884f, 
    -0.03815687f, -0.09746984f, -0.11391222f, -0.16427431f, -0.00418466f, -0.05487943f, -0.04961653f, 0.00353070f, 
    0.03234450f, 0.03738564f, 0.11164883f, -0.01821616f, 0.16512689f, -0.12299450f, 0.14187387f, 0.27206737f, 
    0.07971946f, 0.02680818f, 0.05609620f, 0.10818356f, -0.02286958f, 0.02811818f, -0.05379345f, 0.02769128f, 
    0.23828147f, 0.18035267f, -0.03999546f, -0.05235551f, -0.00813311f, 0.01963119f, -0.05518224f, -0.04960287f, 
    -0.03905873f, -0.03184495f, -0.03586818f, -0.09265883f, 0.29516166f, 0.13101645f, 0.06742655f, -0.02010373f, 
    0.12152261f, 0.12301563f, -0.03735344f, 0.05538275f, -0.17134474f, -0.03927851f, -0.04640758f, 0.07511515f, 
    0.01617585f, 0.02024756f, -0.02635712f, 0.08679228f, -0.07301507f, -0.01613786f, -0.03902648f, 0.14658478f, 
    0.15825620f, -0.03716675f, -0.03120963f, -0.22248206f, -0.29157910f, -0.24577050f, -0.25433370f, 0.10618072f, 
    0.13284062f, 0.01065873f, -0.01653579f, -0.05477979f, 0.01796430f, 0.09038823f, -0.03340578f, -0.01573526f, 
    -0.23522799f, 0.15538482f, -0.14941858f, 0.26326701f, 0.13750125f, -0.02303628f, -0.04905604f, -0.08081248f, 
    -0.04176233f, 0.05740141f, 0.08605531f, -0.04532191f, -0.03056780f, -0.11513857f, 0.02212465f, -0.15098000f, 
    0.03583072f, -0.01484495f, -0.05042841f, 0.10607894f, -0.08414178f, -0.01696566f, -0.08142071f, -0.06107953f, 
    0.04424002f, -0.03960685f, -0.08464915f, -0.09503648f, -0.02316432f, -0.08478036f, -0.01316750f, -0.04127324f, 
    -0.07856486f, -0.01613749f, -0.02949147f, -0.06735572f, -0.01265792f, 0.07275751f, 0.03362192f, -0.08330087f, 
    -0.02718323f, -0.07091722f, -0.05293412f, 0.01026368f, 0.03477121f, -0.02005241f, -0.00466597f, 0.02426064f, 
    -0.04092427f, -0.03682411f, 0.01379002f, 0.02867235f, -0.02742930f, 0.00291759f, -0.02292691f, -0.04439927f, 
    -0.09149475f, -0.06185669f, 0.03726303f, -0.06818459f, -0.07616099f, 0.02058571f, 0.01169857f, -0.05230704f, 
    -0.03562587f, 0.05409780f, -0.04270777f, 0.03116191f, -0.07181239f, -0.09628145f, 0.05155870f, 0.03176441f, 
    -0.01073470f, -0.04124104f, -0.04829854f, 0.02200171f, -0.02489538f, -0.01435678f, -0.01729677f, -0.03039275f, 
    -0.03884961f, -0.07083136f, 0.02224088f, 0.00089997f, -0.08203626f, 0.05553022f, -0.00897402f, -0.07946276f, 
    0.03447295f, -0.02766429f, 0.05131901f, -0.05935105f, 0.01700424f, -0.06356227f, 0.00923532f, -0.04160266f, 
    0.02357623f, 0.03572267f, -0.03128466f, -0.05457314f, 0.01825669f, -0.01703092f, -0.00086793f, -0.04972863f, 
    -0.04519020f, 0.03494373f, -0.04645080f, -0.04243830f, -0.03028289f, 0.00116364f, -0.08411336f, 0.02704860f, 
    -0.07051632f, 0.03820129f, 0.03017791f, -0.04145475f, -0.00884041f, 0.03652494f, -0.05086268f, 0.02112705f, 
    -0.03919414f, 0.04205106f, 0.00916614f, 0.01467946f, -0.05316262f, -0.05932384f, -0.04153541f, -0.09399297f, 
    -0.09182539f, -0.03268353f, 0.02904192f, -0.04800137f, -0.05809765f, -0.03404781f, 0.02594191f, 0.00633815f, 
    0.02712724f, -0.07595393f, -0.02843028f, -0.01078211f, 0.01981011f, 0.06131590f, -0.05673552f, -0.02785009f, 
    0.02895233f, -0.02281652f, 0.06470639f, 0.00206843f, 0.02118642f, -0.08155235f, -0.02642348f, -0.05154235f, 
    0.01372469f, -0.08504874f, 0.00726458f, -0.01315011f, 0.01549646f, -0.07035479f, 0.04392156f, 0.06340227f, 
    0.01217369f, -0.04944773f, -0.04758709f, 0.04077033f, -0.07804232f, 0.00133577f, 0.05383297f, 0.02425214f, 
    0.01869595f, 0.01738036f, -0.04438879f, -0.01227811f, -0.05824572f, -0.04616572f, -0.04211457f, -0.00439721f, 
    0.05006933f, 0.03468094f, 0.03407596f, -0.00314903f, -0.01885821f, -0.07385651f, -0.01487206f, -0.05229348f, 
    -0.05653081f, 0.02298024f, 0.05514898f, -0.04612381f, -0.08475883f, -0.07432984f, 0.04563133f, -0.03984967f, 
    -0.05185709f, -0.04946180f, 0.07408040f, 0.05940960f, -0.00029438f, -0.04558244f, -0.04102700f, 0.02230348f, 
    -0.00930980f, 0.02655935f, 0.03677588f, -0.00214220f, -0.10026037f, 0.03694338f, -0.00000530f, 0.04820604f, 
    -0.05602396f, 0.03580314f, 0.06774097f, -0.00353472f, -0.07610244f, -0.04016863f, 0.00960516f, -0.05213631f, 
    0.18693067f, 0.17338900f, -0.07253910f, -0.10265335f, 0.10662953f, 0.05603364f, 0.03230158f, -0.05688254f, 
    -0.00612804f, 0.05193137f, -0.05718338f, 0.02599625f, -0.16693690f, -0.21952428f, 0.04256176f, -0.07630972f, 
    -0.06116820f, -0.03479167f, 0.17416584f, -0.01351181f, 0.09922273f, 0.04925999f, -0.03643401f, 0.04491427f, 
    0.28472808f, 0.06137093f, 0.09811387f, 0.03740637f, 0.00957762f, -0.09014995f, -0.06579398f, 0.02579569f, 
    0.12383381f, -0.00023912f, -0.05996696f, -0.03351160f, -0.04203469f, 0.01544325f, 0.05595487f, -0.14849524f, 
    -0.08849419f, 0.17645168f, 0.06448581f, 0.13354754f, 0.03617393f, -0.04755288f, 0.01437408f, 0.05803090f, 
    -0.00030715f, 0.15212165f, 0.07943512f, -0.03555756f, -0.05465802f, -0.13611968f, 0.00657148f, 0.06043030f, 
    -0.05132912f, -0.15529983f, -0.00172696f, 0.20459662f, -0.09710240f, 0.12064370f, 0.23202905f, 0.08218761f, 
    -0.15035997f, -0.01898531f, 0.13403487f, -0.08976239f, -0.04319439f, 0.02121492f, 0.01645642f, 0.05080965f, 
    -0.04267621f, -0.12553732f, 0.16253480f, -0.04429879f, 0.03901309f, -0.09671348f, -0.03834583f, 0.03606076f, 
    -0.05257228f, 0.11639715f, -0.09728770f, 0.11651792f, 0.19200762f, 0.17926246f, -0.05121485f, 0.19302270f, 
    0.09331672f, 0.00745929f, 0.04304387f, -0.08301912f, -0.05910971f, 0.14535430f, -0.00935307f, -0.11834807f, 
    -0.07759748f, -0.01590075f, -0.09235816f, -0.07817990f, 0.02268646f, -0.03052991f, 0.00193387f, 0.06776228f, 
    -0.07603864f, 0.01591389f, 0.01447997f, 0.03163287f, 0.10088913f, 0.24084184f, 0.07015977f, -0.02325771f, 
    -0.11564063f, -0.06790038f, 0.00382641f, 0.03597230f, 0.04426092f, -0.01920087f, 0.04558863f, 0.04711034f, 
    0.23460177f, 0.19063428f, -0.08393377f, -0.01381618f, 0.12361211f, 0.04112016f, -0.00922528f, 0.00634796f, 
    0.02972805f, 0.06974582f, 0.04280022f, 0.01786620f, 0.17960727f, 0.00987244f, 0.24459293f, 0.11191261f, 
    -0.02384030f, -0.04540846f, -0.05952731f, 0.22289960f, 0.02037458f, -0.10002940f, 0.12163942f, 0.01047435f, 
    -0.10448443f, -0.15994149f, -0.06106028f, 0.13153853f, -0.07343194f, -0.02685081f, 0.09433771f, -0.04634839f, 
    -0.12365763f, -0.11772333f, 0.06263409f, -0.18808076f, -0.05895825f, -0.06056819f, -0.01295639f, 0.16967669f, 
    0.00413132f, -0.02127463f, 0.03133995f, -0.05194540f, 0.01735813f, 0.08871453f, 0.01143374f, -0.07900921f, 
    0.18724507f, -0.08553322f, 0.12558100f, 0.18620872f, 0.15364496f, 0.04755099f, 0.05950789f, -0.11106702f, 
    0.06142496f, -0.09262778f, -0.00099083f, -0.16317618f, -0.16258709f, 0.06322330f, 0.18592776f, 0.09549648f, 
    0.01553624f, -0.09193614f, -0.02563128f, 0.12318595f, -0.07143364f, 0.05988131f, -0.18639836f, -0.03679344f, 
    -0.06071565f, 0.03656859f, 0.02217924f, 0.06053799f, 0.03536930f, -0.01294562f, 0.01578545f, 0.05478426f, 
    0.01806688f, 0.05493682f, 0.03290614f, 0.05722562f, -0.04747651f, -0.02721315f, -0.02278967f, -0.07084986f, 
    -0.01419829f, -0.05610653f, -0.01931356f, 0.05682752f, 0.01323434f, 0.02092263f, -0.07850771f, -0.06293669f, 
    -0.00042791f, -0.00945710f, 0.04012599f, -0.04639022f, -0.05423867f, 0.03921861f, 0.05693998f, -0.06826179f, 
    -0.06916977f, -0.05377648f, -0.03853465f, 0.02740364f, 0.03101174f, 0.02742142f, 0.05007483f, 0.04752158f, 
    -0.00153573f, -0.01413791f, 0.04054011f, -0.06398087f, -0.00940998f, 0.05699803f, -0.04465435f, -0.03616250f, 
    -0.06993590f, 0.01195737f, 0.01616209f, -0.01810372f, -0.07309752f, 0.04006322f, 0.03626639f, -0.05026299f, 
    -0.07035241f, 0.02215444f, 0.01359908f, -0.02854373f, -0.03186089f, -0.06714270f, -0.03508993f, -0.00214327f, 
    0.01034867f, -0.05287811f, 0.01812767f, -0.04125861f, -0.02238932f, -0.07667140f, 0.04128346f, 0.04171676f, 
    -0.07704005f, -0.05851097f, -0.06726571f, 0.03031850f, 0.04583895f, 0.05279842f, 0.02559995f, -0.07097203f, 
    0.00003602f, -0.04819373f, -0.03215780f, -0.05831601f, -0.03346864f, 0.03237334f, -0.04804000f, -0.01459315f, 
    -0.04734564f, -0.01847127f, -0.06712522f, 0.03979442f, 0.00949182f, 0.01740819f, 0.04494752f, -0.02764759f, 
    -0.03142374f, -0.08147270f, -0.06051785f, 0.04979126f, -0.00457852f, -0.05469901f, -0.01432918f, 0.04735137f, 
    0.01509957f, -0.06367514f, 0.05474614f, -0.07701589f, -0.00622412f, -0.05647792f, -0.06369080f, 0.01258552f, 
    0.04848944f, -0.06719805f, -0.00474363f, -0.03631762f, 0.02370540f, -0.02590950f, -0.06405574f, -0.05758484f, 
    0.03588953f, 0.04413452f, 0.01573224f, -0.02726866f, 0.04198635f, -0.00115645f, -0.03334807f, -0.01630809f, 
    0.03821156f, -0.06610198f, 0.04261782f, -0.03008630f, 0.02564377f, -0.06313849f, -0.02764321f, -0.05440318f, 
    0.00265859f, -0.07263599f, 0.04318039f, 0.00746208f, -0.05432214f, -0.01326035f, -0.06409074f, -0.01043588f, 
    0.05813309f, 0.03025905f, -0.02691901f, 0.01572889f, -0.04766566f, 0.02814021f, -0.04646383f, -0.04849769f, 
    -0.06738243f, 0.01383320f, 0.05954321f, 0.04704174f, -0.04731354f, -0.02933613f, -0.01432463f, 0.01043338f, 
    0.02024668f, -0.07352684f, 0.01649942f, -0.05202019f, -0.00567244f, -0.05679895f, -0.01026924f, -0.02555519f, 
    -0.01567699f, 0.02673944f, 0.03222647f, 0.02886678f, -0.03313853f, 0.06653177f, -0.03274716f, -0.05883069f, 
    0.04844454f, 0.02778847f, 0.02079704f, 0.01071209f, -0.02722775f, 0.03923579f, 0.05226048f, -0.07375642f, 
    -0.01641148f, -0.05938339f, -0.04587642f, 0.00556160f, 0.01354566f, 0.03093375f, -0.00600042f, -0.06779430f, 
    -0.06890173f, -0.05188129f, -0.00333134f, 0.00865064f, -0.07360608f, -0.06531630f, 0.01988486f, 0.05065105f, 
    -0.05159061f, -0.00690748f, 0.02490456f, -0.02274785f, 0.03053860f, 0.00095641f, 0.00824980f, 0.02804959f, 
    -0.00601601f, -0.06119588f, 0.01509220f, 0.03729038f, -0.07179863f, -0.07835391f, -0.01892899f, -0.05954468f, 
    -0.04662097f, -0.06112576f, -0.01551956f, 0.00409983f, -0.06618625f, -0.06476168f, -0.05421516f, 0.02189974f, 
    0.02119581f, -0.01968160f, -0.00981898f, 0.03293652f, -0.06325452f, -0.03944618f, -0.00276874f, 0.04742659f, 
    0.01331094f, 0.04134368f, -0.04061193f, -0.01284585f, -0.03970391f, -0.01524233f, 0.05012223f, -0.02707983f, 
    -0.07225125f, -0.01297264f, 0.00999606f, 0.01624054f, 0.00077094f, -0.07540426f, 0.00176309f, 0.02928987f, 
    -0.02424446f, -0.03666999f, 0.05070445f, 0.02416804f, -0.00863966f, 0.00450183f, 0.04834666f, 0.00025793f, 
    0.04928587f, 0.04812234f, 0.03762341f, 0.06237391f, 0.05078261f, 0.03149668f, 0.06203026f, 0.03422992f, 
    0.06846739f, -0.06510241f, 0.03899444f, 0.00753660f, -0.05470289f, -0.00942468f, -0.03671168f, -0.06640597f, 
    0.03626852f, -0.06209167f, 0.03575365f, -0.07339260f, -0.03034510f, -0.02496224f, -0.02371259f, 0.00340490f, 
    -0.00382415f, -0.04098270f, -0.01475439f, -0.01985586f, 0.00184968f, -0.04038852f, 0.00426586f, -0.05892605f, 
    0.03952566f, -0.02409954f, -0.04344919f, -0.02382831f, -0.02939003f, -0.03624101f, 0.06261841f, 0.04179255f, 
    0.01712659f, -0.01222027f, 0.05300528f, 0.01368326f, 0.03263010f, -0.02153524f, -0.06767269f, -0.07693554f, 
    -0.06492674f, 0.03314522f, 0.00919805f, -0.02719747f, 0.02426702f, 0.05925418f, -0.03652373f, 0.04207823f, 
    -0.01325453f, -0.05180139f, 0.01821463f, 0.00354221f, -0.01175034f, 0.04944557f, 0.03741797f, 0.02433001f, 
    0.03607640f, 0.03524463f, 0.06704535f, -0.07678080f, 0.03330517f, -0.01534716f, 0.04684618f, 0.01128621f, 
    -0.07473330f, 0.06221898f, -0.01252746f, -0.06494891f, -0.07033287f, -0.07332340f, -0.04953915f, -0.05133196f, 
    0.00022423f, -0.03586167f, -0.00701262f, 0.06163755f, -0.04650357f, -0.02731761f, -0.03634968f, 0.02002571f, 
    -0.03382207f, -0.00004512f, 0.01552451f, -0.05542291f, 0.01118340f, -0.07067981f, -0.00414332f, -0.05976433f, 
    -0.01075635f, 0.03652860f, 0.01940460f, 0.04713416f, -0.06890761f, -0.04977147f, -0.01713825f, 0.00249144f, 
    -0.02409908f, -0.04935486f, -0.06228389f, 0.04231828f, 0.02183287f, -0.02728738f, 0.06541763f, -0.07646824f, 
    -0.04559517f, 0.05997117f, 0.00408194f, -0.03818467f, 0.01734900f, -0.02975014f, 0.05890277f, 0.00261073f, 
    0.05055609f, 0.02724155f, 0.00322270f, -0.06773309f, -0.05219304f, -0.02055440f, 0.01128294f, 0.01453682f, 
    -0.06589343f, -0.03274462f, -0.03479816f, 0.03833102f, 0.01225176f, -0.04469723f, 0.04443765f, -0.09374781f, 
    -0.06621198f, -0.02592166f, 0.03152079f, 0.02869425f, -0.01335735f, -0.03291854f, 0.03565263f, -0.02903269f, 
    0.04515889f, -0.03405992f, 0.00126643f, -0.01607806f, -0.06037277f, 0.06417289f, -0.06734473f, -0.09579881f, 
    -0.03597416f, -0.02005935f, -0.00338826f, -0.03769465f, -0.09255140f, 0.01894940f, -0.08127048f, 0.02124954f, 
    0.04138509f, 0.02395314f, -0.00528325f, -0.06553002f, -0.06313899f, -0.06570631f, -0.05003021f, -0.01474938f, 
    -0.06009758f, -0.07812228f, -0.03807518f, -0.05763519f, -0.05565701f, -0.00675667f, -0.02727778f, -0.00920704f, 
    -0.05258391f, -0.01638869f, -0.03047450f, 0.00254611f, -0.01221580f, 0.01621990f, -0.02907519f, -0.03471736f, 
    -0.08886036f, -0.02618515f, -0.02316291f, -0.05194934f, -0.06825384f, -0.02640215f, 0.00827970f, -0.01065176f, 
    -0.00031434f, 0.01739740f, -0.07925140f, 0.02284314f, -0.01490904f, -0.03932027f, 0.02999550f, 0.00643841f, 
    -0.08985291f, -0.08881570f, -0.05050340f, -0.05823338f, -0.09129705f, -0.05363148f, -0.07715707f, 0.00589488f, 
    -0.07456779f, -0.03131688f, -0.08296352f, -0.06681295f, 0.01003629f, -0.07805739f, 0.01663621f, -0.02534434f, 
    -0.02714199f, -0.03594239f, -0.00356065f, -0.01933323f, -0.05269398f, -0.00622218f, -0.09108125f, -0.02824839f, 
    -0.00103649f, -0.02576820f, -0.02195730f, -0.02731541f, -0.04120331f, 0.05762555f, -0.01521989f, -0.01267420f, 
    -0.05403348f, 0.01497873f, 0.01956967f, -0.01169687f, -0.03368106f, 0.00782744f, -0.07920334f, -0.00593762f, 
    -0.02571558f, 0.02171328f, -0.00626496f, -0.02845050f, 0.04388282f, -0.00551755f, -0.09211261f, -0.02045681f, 
    0.00997931f, -0.03773904f, 0.01740058f, -0.08777037f, -0.02833904f, -0.03499594f, 0.02090127f, -0.05813628f, 
    -0.08161200f, -0.09403301f, 0.00189411f, -0.04970334f, -0.04878924f, -0.08913674f, -0.05483030f, -0.06513328f, 
    -0.06749071f, -0.02347498f, 0.02598424f, -0.09513867f, 0.02868409f, 0.03980302f, -0.04809145f, -0.05298934f, 
    -0.01835588f, -0.05724162f, -0.03082149f, 0.03029665f, -0.06994577f, -0.04839611f, -0.01737843f, -0.05819081f, 
    0.02557376f, -0.03238470f, 0.00605438f, -0.04534436f, -0.05324028f, -0.00236724f, 0.03649084f, -0.04675152f, 
    -0.05319897f, 0.03858452f, -0.05771815f, -0.03032983f, 0.02150176f, 0.03302586f, -0.06866590f, -0.01144942f, 
    -0.07883409f, -0.08807670f, -0.05300490f, -0.09516652f, -0.05391464f, -0.01402930f, 0.03857477f, -0.08781654f, 
    -0.07777613f, -0.07447648f, -0.05817016f, -0.09808029f, -0.01199163f, -0.09005278f, 0.03132377f, -0.00408361f, 
    -0.07664970f, -0.04226673f, -0.09767899f, -0.02164035f, 0.03602696f, -0.06782059f, -0.00589742f, -0.01684752f, 
    0.03205628f, 0.04912657f, -0.00749733f, 0.04302360f, 0.03269876f, -0.06089062f, 0.03812004f, -0.05435870f, 
    0.05954327f, -0.03650090f, -0.00856718f, 0.06357101f, -0.06251876f, 0.01772428f, -0.04356436f, -0.04095438f, 
    0.02833156f, 0.02647712f, 0.05486717f, 0.00990275f, 0.00036875f, 0.04266661f, 0.02306320f, -0.03841589f, 
    -0.05398511f, 0.03406473f, -0.06717301f, -0.04163590f, -0.01823213f, 0.00344518f, -0.05583297f, -0.01916335f, 
    -0.03390110f, -0.00063857f, 0.01281920f, -0.01404843f, 0.00563189f, -0.02674093f, -0.03951006f, -0.01927704f, 
    -0.04924973f, -0.05963094f, 0.03512790f, 0.02128056f, -0.02727626f, -0.00091698f, -0.06875149f, -0.05576759f, 
    -0.00954072f, -0.00830246f, 0.00609662f, 0.00231340f, -0.03944966f, -0.02519659f, 0.06982425f, 0.05066219f, 
    -0.06679682f, -0.03386832f, -0.03990210f, 0.01435943f, -0.04836043f, -0.01685382f, -0.07070161f, 0.00733518f, 
    0.04078370f, -0.06165479f, 0.03942517f, -0.05352739f, 0.04547910f, -0.04181333f, -0.00784707f, -0.03270547f, 
    -0.06545506f, -0.07197631f, 0.01238824f, 0.04924800f, 0.01007047f, -0.00024658f, -0.02307897f, -0.01423122f, 
    -0.07047916f, 0.07104357f, -0.05071180f, 0.02848947f, -0.02901701f, -0.04270525f, -0.04142115f, -0.07189625f, 
    -0.06168909f, -0.01500127f, -0.01594603f, -0.02731878f, -0.02457990f, 0.06964566f, -0.06736626f, -0.03487334f, 
    0.00030175f, -0.07192716f, 0.00836735f, -0.02807930f, -0.06714436f, -0.05070289f, -0.01085842f, 0.01119986f, 
    -0.01325991f, 0.02932441f, 0.02717780f, -0.01189208f, 0.01133370f, -0.02050053f, -0.02652726f, -0.03103298f, 
    -0.05631134f, 0.04713751f, 0.05101258f, -0.04436801f, -0.05656847f, 0.04176130f, -0.04630895f, -0.03379781f, 
    -0.04176429f, 0.07215248f, 0.05927508f, 0.02338092f, 0.04068795f, -0.00373558f, 0.05217144f, 0.00188917f, 
    -0.01614597f, -0.03299037f, -0.00187662f, 0.02903924f, -0.06630205f, 0.02984817f, 0.06491406f, 0.00769268f, 
    -0.01896229f, 0.06730717f, 0.02948031f, -0.02557699f, 0.00815631f, 0.00373212f, -0.02693283f, -0.06495053f, 
    0.05781696f, -0.00525181f, 0.05975134f, -0.01664395f, -0.03715131f, -0.01156213f, 0.01575550f, 0.00544793f, 
    -0.02604055f, -0.03763388f, 0.00345442f, 0.06339300f, 0.03301598f, -0.04783589f, 0.02665706f, -0.03159497f, 
    0.04634248f, -0.05739291f, -0.00104984f, 0.04582273f, -0.02739429f, -0.02128047f, -0.00286207f, -0.01999114f, 
    -0.05557078f, 0.05604507f, -0.02827826f, -0.04970057f, 0.04141631f, -0.01044466f, 0.06000754f, 0.06899856f, 
    -0.07128705f, -0.05052533f, -0.06002007f, 0.03700840f, 0.04564961f, -0.04433985f, 0.02171557f, 0.03786867f, 
    -0.06618372f, 0.00118893f, -0.00634175f, -0.05937708f, 0.04168097f, 0.02897567f, -0.05964702f, -0.04411375f, 
    -0.05135293f, -0.09591100f, 0.20098332f, 0.10169622f, -0.05225365f, 0.06495962f, 0.02590855f, -0.02464546f, 
    -0.05455028f, -0.06238274f, -0.01899370f, 0.01394942f, 0.31168774f, -0.03014684f, 0.10201615f, -0.09157433f, 
    -0.05667143f, 0.02681699f, -0.02288892f, -0.01709480f, -0.01169094f, -0.14209817f, 0.01652882f, 0.07738796f, 
    -0.20020954f, -0.24835420f, 0.00403631f, 0.05466184f, -0.03156008f, -0.07909776f, 0.03232666f, -0.01625950f, 
    -0.03591097f, 0.00830671f, 0.10966145f, -0.00868018f, -0.49174798f, 0.12333076f, -0.09366184f, 0.21118663f, 
    0.13589978f, 0.00690157f, -0.03778209f, 0.09702280f, 0.09235243f, -0.09919319f, -0.03147934f, -0.06560405f, 
    -0.20388022f, 0.23089433f, -0.01715572f, -0.19066139f, 0.03311205f, 0.21060523f, 0.04138253f, -0.01996952f, 
    0.07624778f, -0.01607385f, -0.09388328f, -0.01112078f, 0.11746787f, -0.09606498f, -0.15757701f, -0.13540338f, 
    0.11339825f, -0.08570781f, -0.10771850f, -0.02303321f, -0.07482409f, 0.01231267f, -0.12539707f, 0.09721727f, 
    0.34655893f, 0.14337410f, -0.06924000f, -0.11189434f, 0.00101630f, -0.05660292f, 0.02287149f, 0.00481045f, 
    -0.02132898f, -0.04529576f, -0.04146853f, -0.06553311f, -0.17444728f, 0.10040604f, -0.11354689f, 0.00190925f, 
    -0.02545507f, 0.01896585f, -0.05641878f, -0.00048163f, 0.03398341f, -0.04061966f, -0.13483469f, 0.02367074f, 
    0.18787237f, -0.00911244f, 0.12581912f, 0.26524952f, -0.06386425f, 0.00943480f, 0.10759373f, 0.04348943f, 
    0.07989923f, 0.06876173f, 0.02242082f, 0.12530805f, -0.37624818f, 0.27354258f, 0.00486957f, 0.00153876f, 
    0.11614247f, 0.06253199f, 0.06624624f, -0.04806369f, 0.11876573f, 0.03220407f, 0.02001053f, -0.06254636f, 
    -0.06054987f, 0.06610402f, 0.26705417f, 0.10706396f, -0.02139105f, 0.06447346f, 0.03345426f, -0.04190184f, 
    -0.00697716f, 0.19731367f, -0.02279219f, 0.02443084f, -0.11337931f, -0.10948043f, -0.10180722f, 0.10268719f, 
    0.07050266f, -0.02331513f, 0.04730667f, 0.06866551f, 0.09813202f, 0.03565434f, 0.12824944f, -0.05596123f, 
    0.21524566f, -0.08396722f, -0.11290386f, -0.18071744f, 0.08442126f, 0.09323011f, 0.10182046f, -0.09364073f, 
    0.00664235f, 0.03566861f, -0.01250583f, 0.06132995f, 0.35861233f, 0.04675320f, 0.15912034f, 0.28015724f, 
    -0.09577852f, 0.04212049f, 0.02689395f, 0.12020052f, -0.02590712f, -0.01244978f, -0.06572440f, 0.08223874f, 
    0.02132981f, -0.14021102f, 0.08069552f, 0.09901398f, 0.05436045f, 0.03901517f, -0.01079642f, 0.12708677f, 
    -0.02750688f, -0.00034141f, 0.00878259f, 0.10255747f, -0.26651031f, 0.20693929f, 0.03553986f, -0.00280710f, 
    0.18109655f, 0.00806045f, 0.03290823f, 0.01211890f, 0.01363371f, 0.01701069f, 0.06664706f, 0.07035982f, 
    0.00694824f, -0.07432947f, -0.06050146f, -0.04300733f, 0.02573678f, 0.04330201f, -0.00308731f, 0.03649117f, 
    -0.06532183f, -0.00086132f, -0.02298989f, 0.02505314f, 0.03801674f, -0.05011946f, -0.01376983f, -0.03537749f, 
    -0.07561009f, 0.05731800f, 0.06283517f, -0.06161777f, -0.06832748f, -0.05724598f, -0.01914924f, -0.03311124f, 
    -0.03429235f, 0.03130815f, -0.04687070f, 0.06362026f, -0.05783844f, -0.01603192f, 0.03706328f, -0.04344164f, 
    -0.00621573f, 0.00635881f, -0.04693697f, -0.02278240f, -0.03943031f, -0.02409560f, -0.00004865f, 0.05046087f, 
    -0.02306573f, -0.07792953f, -0.00622562f, -0.01101051f, -0.01946748f, 0.01614431f, -0.02192796f, -0.01447653f, 
    -0.05535555f, -0.05727166f, -0.05228171f, -0.06832124f, 0.00011326f, 0.02340901f, -0.05670327f, 0.01771906f, 
    0.06380649f, 0.04701694f, 0.05277738f, -0.02032840f, -0.05234586f, 0.06599702f, 0.02754155f, -0.00059834f, 
    0.01622127f, 0.01053107f, 0.00448507f, 0.02554508f, -0.06837656f, 0.02533866f, 0.00818587f, -0.06043642f, 
    0.06193780f, 0.01845986f, -0.03601383f, 0.01648898f, -0.02278814f, 0.04829326f, -0.00949131f, -0.00451612f, 
    0.02456517f, -0.01751885f, -0.01378897f, 0.03570538f, 0.01413498f, -0.03742205f, -0.06176334f, -0.00184252f, 
    0.00757266f, -0.07574760f, 0.01897823f, -0.01897235f, -0.03066724f, -0.04813419f, 0.05255477f, 0.05572044f, 
    -0.04377418f, 0.05650491f, -0.04913432f, 0.03042968f, -0.06183878f, -0.05975828f, 0.01039660f, 0.04314662f, 
    0.01720166f, -0.00266926f, -0.03137380f, 0.04011716f, 0.03121083f, -0.01194174f, 0.00459537f, -0.00105112f, 
    -0.05988737f, 0.01801165f, 0.03076024f, -0.04858616f, 0.00559684f, 0.06506734f, -0.04105635f, 0.06230284f, 
    -0.01154894f, -0.04081718f, -0.06160523f, -0.01985130f, 0.04298003f, 0.01621990f, 0.01371723f, 0.04688612f, 
    -0.01707130f, 0.01374219f, 0.03579767f, -0.00197399f, -0.07778002f, -0.06172837f, -0.04306662f, 0.03508867f, 
    -0.06516926f, -0.01036966f, 0.06131565f, 0.04318158f, -0.06705813f, 0.02782884f, -0.06134149f, 0.06827149f, 
    -0.02980347f, 0.05015660f, 0.05041253f, 0.02476089f, -0.04412927f, -0.04568494f, -0.04235776f, 0.00237748f, 
    -0.06150877f, -0.06666908f, -0.04974046f, 0.05718383f, 0.01314242f, 0.02465463f, -0.03070270f, -0.03954650f, 
    -0.01881527f, -0.05079237f, 0.00116555f, -0.02678440f, 0.01236224f, -0.06869510f, 0.03804213f, -0.00257571f, 
    -0.00547711f, 0.00633517f, -0.04714935f, -0.05362837f, -0.01130306f, -0.04314959f, 0.02709449f, 0.01499286f, 
    0.03165999f, -0.02873325f, -0.00072748f, 0.03266443f, 0.00038566f, -0.02059262f, -0.06018948f, 0.00639165f, 
    -0.05703916f, -0.00915882f, -0.02570661f, 0.03130117f, 0.02224731f, -0.02144813f, -0.01524476f, -0.00151120f, 
    -0.23076797f, -0.07062159f, 0.16270673f, 0.14128754f, 0.04196277f, -0.03968493f, -0.01664719f, -0.00772241f, 
    0.01742894f, -0.06795886f, 0.14732543f, -0.10550309f, 0.22639336f, 0.33310750f, -0.08356170f, -0.00042380f, 
    0.15045494f, 0.02811827f, 0.03945391f, 0.13037305f, -0.08163425f, -0.07732061f, 0.04705865f, 0.02866684f, 
    -0.30400467f, 0.12735407f, -0.02531982f, -0.18493550f, 0.02775452f, -0.04231798f, 0.01382043f, 0.11388241f, 
    -0.01573059f, 0.05831374f, -0.00168200f, 0.14139605f, 0.16741376f, 0.20624660f, 0.04912074f, -0.04258962f, 
    0.13658242f, 0.02243928f, -0.09594009f, -0.04390525f, 0.00843973f, -0.01224332f, -0.03333878f, 0.07668991f, 
    -0.00235951f, -0.01677660f, -0.13547316f, -0.00491008f, 0.01558399f, 0.00661315f, 0.10076734f, 0.09825739f, 
    -0.03294962f, -0.04603915f, 0.03670046f, -0.08603974f, -0.09715034f, 0.15036115f, -0.09156992f, 0.01638155f, 
    0.14155439f, 0.00276093f, -0.08931981f, 0.08250828f, -0.05872401f, -0.01934527f, -0.15302475f, 0.07188138f, 
    0.12208632f, 0.26435915f, -0.21553856f, -0.03437731f, 0.18451768f, -0.04977952f, 0.09687470f, 0.02970309f, 
    -0.02075478f, -0.12109483f, 0.10580757f, -0.09928577f, -0.00838315f, -0.16141284f, 0.08887607f, 0.00277257f, 
    -0.08622958f, 0.06576871f, 0.02511416f, -0.08742441f, 0.08090016f, 0.06031607f, 0.10087949f, 0.04268410f, 
    -0.03248153f, 0.09147308f, 0.04341466f, -0.14856793f, 0.09719233f, -0.05713004f, -0.02716564f, -0.11993531f, 
    0.02828087f, 0.11519413f, -0.00292416f, 0.07275542f, -0.24185336f, -0.18559882f, -0.05528204f, 0.24956281f, 
    0.21006298f, 0.01937717f, -0.04885274f, -0.06503937f, -0.00719722f, 0.12740839f, -0.06327339f, -0.06925765f, 
    -0.11730927f, -0.03844329f, 0.18596588f, 0.23722675f, -0.10844673f, 0.06169970f, -0.01711167f, -0.02738320f, 
    0.04645378f, -0.04289200f, -0.03226316f, 0.01718023f, -0.11358473f, -0.03786512f, -0.17475569f, 0.09281533f, 
    0.05179956f, 0.16001973f, 0.01740001f, -0.14296155f, -0.00951683f, -0.00041953f, 0.01267117f, 0.02129020f, 
    0.10593228f, 0.26204994f, 0.06580539f, -0.11238152f, 0.10218869f, -0.05084630f, -0.14258561f, -0.00588940f, 
    0.11137027f, 0.08385951f, -0.07211591f, 0.05237202f, -0.02451744f, -0.17595901f, -0.11016746f, -0.07152216f, 
    0.09376260f, -0.00822302f, -0.08009655f, -0.02868024f, -0.00120459f, -0.03698603f, 0.08738920f, -0.02524830f, 
    -0.36343956f, 0.20794664f, -0.17004758f, 0.08325900f, 0.03176816f, -0.10977002f, -0.01124865f, 0.02823254f, 
    0.07010547f, 0.13497931f, 0.08962585f, 0.11555623f, 0.28056064f, -0.15031837f, 0.02777782f, -0.00363493f, 
    -0.00049405f, 0.02734943f, 0.08179420f, 0.01889348f, -0.06417560f, -0.10349508f, 0.18201302f, 0.09688098f, 
    -0.31833294f, 0.12436193f, -0.04127257f, -0.22173488f, 0.04996531f, 0.02286878f, 0.06745756f, -0.09383375f, 
    -0.03624013f, -0.05396193f, -0.02415816f, -0.15909156f, -0.38817477f, -0.12546030f, -0.03107136f, -0.10940924f, 
    0.10522974f, -0.05709437f, 0.04371548f, 0.02512105f, -0.04994288f, -0.07837009f, -0.06888527f, 0.10956319f, 
    -0.03937707f, 0.07975435f, 0.00117423f, -0.00425646f, -0.05362945f, -0.03717837f, -0.06246530f, 0.07436624f, 
    -0.03787334f, 0.03745174f, -0.20317805f, -0.08178780f, 0.13718815f, 0.15151362f, -0.06027521f, 0.12199321f, 
    -0.08522701f, 0.12750579f, -0.00909799f, -0.07255114f, 0.07424098f, 0.03994335f, -0.02713070f, 0.08231699f, 
    0.13041939f, -0.05710540f, -0.17174308f, -0.13809061f, -0.03083259f, 0.00820048f, -0.01691807f, 0.00570813f, 
    0.04158570f, -0.01181475f, -0.02515283f, 0.04273243f, 0.09930142f, 0.03697784f, 0.22469321f, 0.02970098f, 
    -0.02064545f, 0.10315307f, -0.02034950f, 0.16130476f, -0.01466686f, 0.04064072f, -0.08322880f, 0.11579506f, 
    -0.04060661f, -0.11599557f, 0.10793485f, 0.08648337f, 0.04354294f, 0.03154622f, -0.05310518f, -0.08816284f, 
    0.02414577f, 0.11481870f, 0.03447616f, 0.00384348f, 0.37826163f, -0.17190978f, 0.07937998f, 0.21976201f, 
    0.06436301f, 0.02765022f, -0.03531203f, -0.02428338f, 0.08867169f, -0.03061219f, 0.00204316f, -0.04645031f, 
    -0.24269761f, 0.16873524f, -0.08341188f, 0.03985697f, 0.08720485f, -0.07588204f, -0.07753348f, 0.11368404f, 
    0.02949387f, -0.01711049f, 0.05016467f, 0.00290761f, 0.35930672f, -0.03526473f, -0.07767386f, 0.10230212f, 
    -0.02450740f, 0.13146864f, -0.13185085f, 0.07443010f, -0.04146697f, -0.02739458f, -0.16543284f, -0.00545190f, 
    0.07338236f, 0.23826650f, -0.10961976f, -0.11566430f, 0.06942836f, 0.14811037f, 0.01304944f, -0.06831983f, 
    -0.00575167f, 0.18763454f, -0.05288711f, -0.09359295f, 0.36821395f, 0.00602416f, 0.22584063f, 0.28933987f, 
    0.21573600f, 0.19900782f, 0.05822588f, 0.09690723f, -0.04604902f, -0.07430033f, -0.10827900f, 0.07247154f, 
    -0.12378938f, -0.11333314f, 0.14211483f, -0.06602062f, 0.09616144f, -0.08133277f, 0.06936295f, -0.00255674f, 
    -0.03692618f, 0.04713821f, -0.10410795f, 0.02090773f, -0.31787708f, -0.19788346f, -0.14458707f, 0.03452598f, 
    -0.01378127f, -0.04982103f, -0.06429902f, 0.04820476f, -0.02031480f, 0.07930443f, -0.03383202f, 0.03930175f, 
    -0.09368408f, 0.00351562f, -0.10931943f, 0.03004322f, 0.09336456f, -0.07816883f, 0.08807141f, 0.04794461f, 
    0.12007609f, 0.23113434f, 0.03007171f, 0.04934086f, 0.12330329f, -0.09014022f, -0.02657377f, -0.01487461f, 
    -0.02487423f, 0.13774118f, 0.02992576f, 0.05871651f, 0.02140270f, -0.02279991f, 0.14133002f, -0.04936727f, 
    0.05981933f, 0.02035692f, -0.01519750f, -0.04308798f, -0.04943076f, 0.04173447f, 0.05877453f, -0.07031514f, 
    -0.01551769f, -0.06202996f, 0.06072485f, 0.04277216f, -0.07909887f, 0.03951272f, -0.06327808f, 0.05466444f, 
    0.04444541f, -0.05289796f, -0.06417953f, -0.00504911f, -0.00755794f, 0.03061123f, 0.00004493f, -0.07790630f, 
    0.05454937f, 0.03573697f, -0.06092694f, -0.04041705f, -0.04501147f, 0.06015343f, -0.03274061f, 0.01505991f, 
    -0.04231715f, 0.02711670f, 0.02188629f, 0.04569593f, -0.04823269f, -0.00782803f, 0.03914900f, 0.00493938f, 
    -0.01952805f, -0.02908571f, -0.07563522f, 0.05028560f, 0.01034989f, 0.03441321f, -0.01876984f, -0.05860607f, 
    -0.00388279f, 0.01421076f, -0.07305001f, 0.05482452f, -0.00711797f, -0.02553684f, -0.05886577f, 0.03071198f, 
    -0.06574528f, -0.01490651f, -0.06096391f, 0.04538950f, 0.02960462f, 0.05990047f, -0.07335487f, 0.03985819f, 
    -0.00570845f, 0.02733972f, 0.02628942f, -0.08289126f, 0.01279537f, 0.03155748f, -0.01862943f, 0.00203521f, 
    0.02079297f, -0.06777735f, -0.00280771f, 0.04072619f, 0.02867729f, -0.07630188f, -0.04343243f, 0.04189984f, 
    0.02546932f, -0.03401739f, -0.04550914f, -0.06679616f, -0.07146143f, -0.00239002f, -0.06700476f, -0.00227950f, 
    0.04161164f, -0.04577603f, -0.02164774f, -0.01200264f, -0.02522123f, 0.03265274f, 0.04427333f, -0.02249878f, 
    0.05465601f, -0.04352821f, 0.03491690f, -0.05413995f, 0.01564650f, 0.04189367f, -0.02789838f, -0.00085393f, 
    -0.05200567f, -0.05198740f, 0.04788582f, -0.06460290f, 0.01719128f, -0.02620463f, -0.07194675f, 0.06256381f, 
    -0.00378783f, -0.01693444f, 0.04573941f, 0.01471715f, 0.00468547f, -0.03324488f, 0.06328856f, -0.03099437f, 
    -0.01927890f, 0.05259969f, -0.05482580f, 0.02896548f, 0.04211757f, 0.02077103f, -0.01094839f, -0.06230607f, 
    0.02133951f, -0.05584722f, -0.03366226f, -0.06782795f, -0.02307756f, 0.01614764f, -0.05460943f, -0.05467791f, 
    -0.07854780f, -0.02125373f, -0.02281613f, -0.05236538f, 0.00467168f, 0.04875260f, 0.02774503f, -0.02497912f, 
    0.00287846f, -0.05988450f, 0.00202891f, -0.01705018f, -0.05874562f, 0.03521248f, -0.06666434f, -0.01825843f, 
    0.02719320f, 0.05246243f, 0.05134879f, -0.07146087f, -0.04854853f, 0.01476960f, -0.03924773f, 0.06140536f, 
    0.00429673f, 0.05521043f, -0.03234746f, 0.01211473f, -0.04864464f, 0.04174132f, -0.05107587f, -0.02205137f, 
    -0.03868483f, -0.05324970f, 0.00539018f, -0.07534425f, -0.05632722f, -0.00373094f, -0.00690029f, -0.02710266f, 
    -0.05792322f, 0.05353509f, -0.08155423f, -0.01292371f, 0.01830957f, 0.03677647f, -0.03550022f, 0.02768982f, 
    -0.06339712f, -0.01268888f, 0.02409885f, -0.03842073f, -0.04760896f, -0.06786060f, 0.01704095f, -0.04484747f, 
    0.01421910f, -0.03106999f, 0.01393227f, 0.03283732f, -0.05829274f, -0.07579309f, -0.06506940f, -0.00090914f, 
    -0.01278894f, -0.08258051f, -0.01864327f, 0.04021835f, 0.05546895f, 0.04611974f, -0.04976306f, -0.06400009f, 
    -0.07077476f, 0.04336280f, -0.03967750f, 0.01198040f, -0.02430119f, -0.01507697f, -0.03919769f, 0.01840089f, 
    -0.02247998f, 0.00798576f, 0.07174402f, -0.02400395f, 0.02822198f, -0.01237856f, -0.07654450f, -0.02332301f, 
    -0.07703178f, 0.02520176f, 0.05694354f, 0.00650348f, 0.04786414f, -0.01094234f, -0.05533573f, -0.03081753f, 
    0.02420956f, -0.00755022f, -0.00116427f, 0.00541629f, -0.06041235f, -0.07581499f, 0.04663735f, -0.04599426f, 
    -0.01088882f, -0.08880659f, 0.03069180f, -0.01940701f, -0.02509392f, 0.03320420f, 0.01433329f, 0.03324400f, 
    -0.06434149f, 0.05018346f, 0.06298010f, 0.04886789f, 0.03623135f, -0.02285833f, 0.01603447f, -0.05611902f, 
    -0.02812234f, -0.06335409f, 0.02698934f, -0.07395047f, -0.03670632f, -0.04207063f, 0.04476190f, -0.02836881f, 
    0.05519082f, -0.01522772f, 0.04754893f, 0.02459206f, -0.04189680f, 0.00778726f, -0.04992293f, -0.08366368f, 
    0.01334807f, 0.05044469f, 0.03297758f, 0.03922186f, -0.07964121f, -0.03225398f, -0.07004902f, -0.07332960f, 
    -0.03928128f, -0.07040136f, 0.04819728f, -0.05993193f, -0.07480288f, 0.03728647f, -0.00989759f, 0.01456296f, 
    -0.00055422f, -0.00932105f, 0.00284727f, -0.07352152f, -0.06853621f, 0.05104541f, -0.06580196f, -0.07891094f, 
    0.04909893f, 0.05758497f, -0.00000740f, 0.02708454f, 0.04167120f, -0.05419602f, -0.06395002f, -0.02711594f, 
    0.02639210f, -0.05665722f, 0.02493814f, 0.00011549f, -0.03750947f, 0.03401550f, 0.02180672f, -0.05975919f, 
    -0.05708686f, -0.00909197f, 0.03056218f, -0.07959040f, 0.01647428f, -0.03675793f, -0.04730461f, 0.05899068f, 
    0.04269462f, -0.03444962f, -0.07566134f, -0.01157720f, -0.00160096f, 0.07777382f, 0.00418074f, 0.05824451f, 
    -0.03215879f, 0.01281410f, 0.06261839f, 0.02097088f, 0.03905064f, 0.06257793f, -0.04541031f, 0.01352372f, 
    -0.00168234f, -0.08229971f, 0.06868329f, 0.05699806f, -0.04098583f, 0.02588456f, -0.07189660f, -0.05131582f, 
    -0.02762296f, -0.06611245f, -0.01193408f, -0.01552919f, 0.03797732f, -0.03408626f, 0.00386504f, 0.06020513f, 
    -0.07732882f, -0.03820658f, -0.03886578f, -0.02675485f, 0.04077929f, -0.06021140f, 0.06124277f, 0.03451398f, 
    -0.05808172f, -0.02007176f, 0.04706050f, -0.04554956f, 0.00944630f, -0.02130347f, -0.03138817f, -0.06728473f, 
    -0.08160889f, -0.06537141f, 0.02172019f, 0.01595008f, -0.08086609f, -0.04517950f, 0.01757108f, 0.01993000f, 
    -0.08205733f, -0.00545607f, -0.03147717f, -0.06495854f, -0.06323547f, -0.01050013f, -0.03239871f, 0.04988240f, 
    -0.17089163f, 0.10315925f, -0.01720518f, 0.12302195f, 0.01303910f, 0.01366857f, 0.00309951f, 0.04513065f, 
    0.00564626f, -0.00691490f, 0.03399132f, 0.06319011f, 0.16866396f, 0.25919607f, 0.02902491f, 0.25264531f, 
    -0.07986375f, 0.00258121f, -0.10146432f, 0.10162147f, -0.03126639f, 0.02455147f, -0.07176838f, -0.13926914f, 
    -0.19409883f, 0.20932657f, -0.11226691f, -0.04499847f, 0.06187488f, 0.06154842f, -0.06080651f, 0.07686692f, 
    -0.02189973f, 0.11650600f, 0.02212518f, -0.04766796f, 0.22936890f, -0.02059996f, 0.10623440f, -0.13361624f, 
    0.01071616f, -0.12236486f, -0.07990371f, -0.12054397f, 0.00014640f, -0.08675500f, 0.02464725f, 0.10880056f, 
    -0.16327538f, -0.16108446f, -0.03925182f, 0.12939717f, 0.03677122f, 0.06245914f, 0.10778759f, -0.02221636f, 
    -0.01372640f, -0.02949973f, -0.03591926f, -0.06374468f, -0.00126762f, -0.17635708f, -0.01596742f, 0.05035192f, 
    0.04077603f, 0.00673197f, -0.03479885f, 0.11783697f, 0.06211448f, 0.12099095f, 0.16333005f, -0.14143687f, 
    0.15049402f, -0.01780635f, -0.14695174f, 0.16616340f, 0.16154234f, 0.01792982f, -0.10284157f, -0.05735513f, 
    -0.05575688f, -0.07618694f, 0.03356053f, 0.15992995f, 0.05839349f, -0.13532811f, 0.18319705f, -0.07061829f, 
    -0.06248225f, -0.01961103f, -0.02140807f, -0.04391319f, -0.00779745f, -0.05166141f, 0.03968319f, -0.10589117f, 
    0.18335982f, 0.05046406f, 0.07390593f, -0.01691499f, -0.01868526f, 0.04610406f, 0.03002687f, -0.05989168f, 
    -0.00805538f, -0.06444795f, 0.04014293f, -0.10598356f, 0.31389487f, -0.39234418f, 0.19069761f, 0.14303218f, 
    0.16687238f, 0.07360150f, -0.14211309f, -0.00858205f, -0.10235576f, -0.06381230f, 0.07922520f, 0.10236222f, 
    0.25676972f, -0.01728732f, -0.12716334f, 0.06005199f, 0.00158286f, 0.03752922f, -0.03602184f, -0.05520359f, 
    -0.01888118f, -0.06374875f, 0.01554326f, -0.13561536f, 0.06581067f, 0.30380690f, -0.03446358f, 0.11761537f, 
    0.20549001f, 0.09820135f, 0.03024556f, -0.08542692f, -0.05705606f, 0.06868251f, -0.21363053f, 0.14242075f, 
    -0.02417595f, 0.18915592f, -0.00378323f, 0.12920892f, 0.07591943f, 0.03572277f, -0.14713550f, 0.10337335f, 
    0.01459057f, 0.10607342f, 0.00602938f, -0.03495087f, 0.02495911f, 0.03582586f, -0.04788714f, 0.02528558f, 
    0.05014665f, 0.05498442f, -0.02370755f, -0.04560260f, 0.03100303f, 0.03160577f, 0.04196282f, 0.03856671f, 
    -0.23232909f, 0.22771218f, -0.11743802f, -0.04691442f, 0.10682040f, -0.12624303f, -0.07788335f, 0.02756911f, 
    -0.03884014f, 0.02736200f, -0.07425907f, 0.04487026f, 0.04743428f, -0.03972455f, 0.03635852f, 0.05237388f, 
    -0.04348117f, 0.03276897f, -0.04197247f, -0.00412968f, 0.05724931f, 0.00957564f, 0.00676179f, 0.00318738f, 
    -0.01379970f, -0.06136874f, -0.05791645f, 0.01142212f, -0.00137746f, -0.02165989f, -0.05451072f, 0.02729272f, 
    0.03390911f, -0.05916053f, -0.01289092f, -0.01061872f, -0.00638476f, 0.01714586f, 0.02095443f, 0.04201489f, 
    0.06356037f, 0.02166451f, -0.05604348f, -0.01915015f, 0.04425116f, 0.04786185f, -0.02879137f, -0.00265889f, 
    -0.03488438f, 0.02405649f, -0.06636044f, -0.01473702f, 0.01577300f, 0.06185687f, 0.03685125f, -0.03785594f, 
    -0.05425612f, -0.07331495f, -0.00308631f, -0.03005964f, -0.05722943f, 0.05664602f, -0.04306400f, -0.07413429f, 
    0.04418740f, -0.00538692f, 0.02528409f, -0.03684787f, -0.00234893f, 0.00252990f, -0.06708457f, -0.05669119f, 
    -0.00781192f, -0.05941351f, -0.07718254f, 0.03598981f, -0.04457093f, 0.00803887f, 0.02142514f, 0.05870388f, 
    0.00048629f, -0.03250754f, 0.05463581f, -0.03756591f, -0.06479780f, -0.01410507f, 0.00939135f, 0.04969609f, 
    -0.03038195f, -0.01369536f, 0.06479592f, -0.04656304f, -0.01358170f, -0.01201897f, 0.06407037f, 0.02105323f, 
    -0.00418046f, 0.02931454f, -0.02755029f, -0.07664417f, -0.02461530f, 0.02473037f, 0.03072156f, 0.02054404f, 
    0.02384975f, -0.00661268f, -0.07525904f, 0.04788512f, 0.05323415f, -0.07007066f, 0.02550981f, -0.04639317f, 
    0.06579102f, -0.02239718f, 0.02823965f, 0.05001023f, 0.04030586f, -0.05178198f, -0.04922966f, -0.01016220f, 
    0.01400843f, -0.01428794f, 0.00081717f, -0.00427705f, 0.06487770f, 0.04689525f, -0.00223109f, -0.06655441f, 
    -0.06986964f, -0.05904800f, 0.03394260f, 0.00738362f, -0.07115961f, 0.04345877f, -0.00437578f, -0.00115165f, 
    -0.02339977f, 0.06120385f, 0.03180097f, -0.01179315f, 0.01795817f, -0.00269815f, 0.02315000f, 0.01963079f, 
    -0.02003214f, -0.00086870f, 0.03646149f, -0.03639730f, -0.06955452f, 0.04062920f, -0.02693602f, 0.00983217f, 
    0.01865377f, -0.03617224f, -0.05031479f, -0.03189426f, -0.04994164f, -0.00020528f, 0.06379899f, 0.05415666f, 
    0.00428793f, -0.04855288f, -0.05270034f, -0.04589817f, -0.03900323f, 0.06453067f, 0.00431231f, -0.03212357f, 
    -0.04831786f, -0.07562211f, -0.04775740f, -0.03668740f, -0.05221028f, -0.01422326f, 0.01225842f, -0.03499105f, 
    0.01198649f, 0.04281343f, -0.00118817f, -0.05507126f, -0.02073702f, -0.02887661f, -0.04281112f, 0.02774841f, 
    -0.06305957f, -0.04034323f, -0.05283517f, 0.01026839f, -0.02902852f, 0.01413216f, -0.02735417f, -0.05912603f, 
    -0.05220902f, -0.02151252f, -0.00182397f, 0.01217707f, -0.04026866f, -0.05396534f, 0.06237936f, 0.04605493f, 
    -0.05810111f, -0.02174523f, -0.00429275f, -0.01995915f, -0.06134386f, -0.04861789f, 0.06570221f, 0.00344336f, 
    0.00564437f, -0.05797895f, 0.02355923f, 0.02696593f, 0.02390022f, -0.06939479f, -0.05663314f, 0.00495749f, 
    0.23261298f, 0.27426538f, -0.25800273f, -0.16914752f, 0.13467458f, 0.04437264f, 0.01572365f, 0.10212869f, 
    0.09527120f, 0.05438886f, 0.11312218f, 0.04443084f, -0.18844587f, -0.27053538f, 0.00467122f, 0.09821671f, 
    -0.07741972f, 0.07483101f, -0.06641540f, -0.04027494f, 0.00500985f, -0.06967174f, -0.03740536f, -0.03906964f, 
    -0.15379848f, 0.11870400f, 0.00123167f, -0.00670238f, -0.00303932f, -0.07014374f, -0.07669679f, 0.05011842f, 
    0.04294989f, 0.01104881f, 0.01227824f, 0.08342171f, 0.04940605f, -0.19667706f, 0.11894799f, -0.45734751f, 
    -0.03118640f, 0.07131022f, -0.02145248f, 0.06629343f, -0.09874941f, 0.03947791f, -0.06929763f, 0.13992307f, 
    -0.24172975f, 0.26056293f, -0.07669849f, 0.10645020f, -0.00317019f, -0.25223815f, 0.00852915f, -0.05724724f, 
    0.07367945f, -0.07631660f, 0.06972133f, 0.04193397f, -0.21715240f, 0.09705628f, 0.17760423f, 0.26922503f, 
    -0.17014648f, 0.09930654f, -0.00495889f, 0.00826006f, 0.06508306f, 0.14074542f, 0.03297899f, 0.07186700f, 
    -0.09537352f, -0.26835743f, 0.11067481f, 0.13600604f, -0.04950486f, 0.03969917f, -0.09462520f, -0.12713230f, 
    0.04428641f, 0.07545205f, -0.05453067f, 0.02125569f, 0.19479258f, 0.09842350f, 0.04565204f, 0.08122619f, 
    -0.00037069f, -0.07835406f, -0.01405188f, -0.09178178f, 0.03180881f, 0.16591661f, 0.08076463f, -0.03571500f, 
    0.15353538f, 0.01012376f, -0.01893366f, 0.07903844f, 0.04688525f, -0.14052428f, 0.05188943f, -0.02627273f, 
    -0.02083333f, -0.07739682f, -0.00604505f, -0.03357966f, -0.15373723f, 0.00127317f, -0.17689452f, -0.06572348f, 
    0.03831809f, -0.11477977f, -0.02399096f, 0.05214734f, 0.01143350f, -0.06817432f, -0.00903403f, 0.16474646f, 
    0.29926550f, 0.13977501f, -0.10407407f, -0.30941394f, 0.01379982f, 0.05677353f, -0.03255960f, 0.08553431f, 
    -0.02938676f, 0.13621387f, 0.04910612f, 0.01455794f, 0.03798294f, 0.00298335f, 0.34861043f, -0.03899786f, 
    0.09079244f, -0.08778787f, -0.03348834f, 0.33515704f, -0.08498898f, 0.03520516f, 0.00786135f, 0.10439904f, 
    -0.01052168f, 0.11558593f, -0.04329284f, 0.00876826f, 0.01230258f, 0.02530692f, -0.03274165f, 0.03051148f, 
    0.09560366f, -0.07360241f, -0.10824898f, -0.00468672f, -0.20737536f, -0.14835575f, -0.05189714f, 0.24463657f, 
    0.11964366f, 0.00360127f, -0.02232881f, -0.01379878f, 0.07772686f, 0.10520265f, -0.04173425f, -0.09817905f, 
    -0.05585284f, -0.08644699f, -0.11911983f, 0.12023412f, 0.12234718f, 0.00140967f, 0.04887240f, 0.01418063f, 
    0.13225716f, 0.03082223f, -0.02467567f, 0.07670439f, -0.19650878f, -0.07692426f, 0.19744867f, -0.05420526f, 
    0.07715907f, 0.06574241f, 0.03280665f, 0.02952206f, 0.03068637f, 0.06978556f, -0.00462205f, -0.09585276f, 
    0.31825933f, -0.08123624f, 0.05465316f, -0.26356450f, -0.07267058f, -0.12487748f, -0.04077329f, -0.15210050f, 
    -0.02036729f, -0.06385780f, 0.01196225f, -0.04955676f, 0.00883657f, 0.20938793f, 0.11034734f, -0.14658467f, 
    -0.02095401f, 0.09010342f, 0.15399247f, -0.24923228f, -0.00152706f, 0.02321973f, -0.17032883f, 0.00282084f, 
    -0.08634865f, 0.13479611f, -0.00153233f, 0.04917355f, 0.08703288f, -0.13980393f, -0.01057803f, 0.00961492f, 
    -0.03455404f, 0.04876480f, -0.07634497f, -0.04096007f, 0.07265747f, 0.08812704f, 0.05672150f, 0.01772070f, 
    0.10216721f, 0.09147936f, -0.08557678f, 0.23987155f, 0.04210049f, -0.04502880f, -0.11197820f, -0.03420157f, 
    -0.08770926f, 0.25054926f, 0.12780468f, -0.34161600f, 0.07425729f, -0.04252260f, -0.02063602f, -0.11658401f, 
    -0.01852330f, -0.17166919f, -0.06404953f, 0.18973084f, 0.05678672f, 0.09059563f, -0.16926649f, -0.15533979f, 
    0.06954392f, 0.21293442f, 0.22273551f, -0.06045802f, -0.12717821f, 0.14343978f, -0.06192446f, 0.14081579f, 
    0.30110404f, 0.06180885f, 0.08468785f, -0.03039414f, -0.10736030f, -0.12746662f, -0.01901667f, -0.15249373f, 
    0.07057909f, 0.04343111f, -0.04698540f, 0.02825667f, 0.05124324f, -0.00406100f, -0.11612529f, -0.02742194f, 
    0.12242711f, -0.07061152f, -0.04297760f, 0.12246942f, 0.12251107f, 0.00755658f, -0.03714851f, -0.14682090f, 
    -0.30481449f, 0.07553670f, -0.04966013f, -0.01734866f, 0.03150462f, -0.19945781f, 0.01298323f, -0.16406722f, 
    -0.02079038f, 0.00417188f, -0.05330931f, -0.08581365f, -0.43300492f, 0.53520525f, -0.13438611f, 0.03958730f, 
    0.09454725f, 0.10865700f, 0.15817644f, 0.13910177f, -0.10215696f, 0.21284315f, 0.20414370f, 0.21993588f, 
    0.08286956f, 0.22459020f, 0.28668368f, 0.22101626f, 0.01551545f, 0.03282168f, -0.05535709f, -0.12035138f, 
    -0.01502111f, 0.05083402f, -0.02276779f, 0.06218787f, 0.13129959f, -0.13842151f, 0.13147745f, 0.21473415f, 
    0.23186532f, 0.22168873f, -0.07756484f, 0.14376248f, 0.05114651f, -0.05431104f, 0.03669766f, -0.03572908f, 
    0.05216480f, -0.07907919f, -0.01444562f, -0.18931463f, -0.04372689f, 0.21613246f, -0.01493232f, 0.01808939f, 
    0.01921289f, -0.06335320f, -0.00753260f, -0.17240515f, 0.03642701f, -0.10307103f, -0.05360963f, 0.12665021f, 
    0.04933928f, -0.04899279f, -0.06708270f, -0.24626462f, -0.02533289f, -0.10569137f, 0.08461174f, -0.06063252f, 
    0.08039627f, 0.19674605f, 0.12859695f, 0.36819437f, 0.07372495f, 0.06613606f, 0.11128785f, -0.14068860f, 
    0.06444690f, -0.03165267f, 0.05597848f, -0.20785260f, -0.00333792f, -0.07286178f, 0.23219348f, -0.20996627f, 
    0.15230533f, -0.13209110f, 0.01671210f, 0.08817376f, -0.01444477f, -0.03114852f, -0.16812027f, -0.10570840f, 
    -0.04867668f, 0.02293012f, -0.05023563f, 0.04114096f, -0.03525381f, 0.01681568f, 0.05860662f, -0.01799835f, 
    -0.00921750f, -0.08005669f, -0.04883774f, -0.03561574f, -0.01564091f, -0.00746257f, 0.03163987f, -0.04259764f, 
    0.04708171f, -0.07634278f, 0.02410930f, -0.02467142f, 0.05532552f, 0.06101848f, -0.02358865f, 0.02592801f, 
    0.02897798f, -0.05231237f, 0.04929731f, -0.03356487f, -0.07269534f, -0.06322266f, 0.00183370f, -0.00845639f, 
    0.01522220f, 0.00616686f, -0.00007462f, 0.02731058f, 0.05507890f, -0.02427865f, 0.03702301f, -0.00561483f, 
    -0.03784309f, -0.01899419f, 0.04603351f, -0.02136992f, -0.01547425f, 0.02173825f, -0.07788540f, -0.04717251f, 
    -0.04795952f, 0.00858757f, -0.05866877f, 0.00476912f, 0.05891417f, -0.08052620f, -0.06449336f, 0.05416993f, 
    -0.06915236f, 0.00089813f, 0.00243774f, -0.00682662f, 0.00207690f, -0.04542969f, -0.00993819f, 0.02112974f, 
    0.03569794f, 0.03988275f, 0.00451787f, 0.06031432f, -0.06917253f, -0.04209748f, -0.05710941f, 0.04638815f, 
    -0.01838130f, -0.06811027f, 0.05741783f, -0.01256214f, 0.03028122f, -0.06963138f, -0.05105111f, 0.04708226f, 
    0.03801692f, 0.00060020f, -0.06456355f, 0.01876711f, -0.05936782f, -0.02686540f, 0.01158252f, -0.04919987f, 
    0.06117145f, 0.03520972f, 0.00453214f, -0.06572852f, -0.04332424f, 0.04154143f, -0.03055368f, -0.00529242f, 
    -0.04626724f, 0.02100505f, -0.07646599f, 0.05095250f, 0.05027339f, -0.02280446f, 0.00739736f, -0.05012668f, 
    -0.07867968f, -0.04993493f, -0.03501515f, 0.02066404f, -0.02791335f, -0.00820743f, 0.01260796f, 0.05239331f, 
    -0.00671558f, -0.05898857f, -0.01188343f, 0.02556338f, 0.03815017f, 0.00949838f, 0.00285159f, 0.04594478f, 
    0.04737770f, 0.01687408f, 0.04576258f, -0.06669174f, 0.02465190f, -0.05837126f, -0.06476752f, -0.06771462f, 
    -0.02672452f, 0.06182551f, 0.00713357f, 0.05075655f, -0.01758432f, -0.07735439f, 0.04686294f, 0.02625630f, 
    -0.00547158f, -0.07513041f, -0.02250018f, -0.01587627f, -0.02023049f, -0.04459852f, -0.03659897f, 0.04729663f, 
    0.00877837f, 0.00152861f, -0.04939830f, 0.04153324f, 0.03601419f, 0.00720592f, 0.00494318f, 0.02567785f, 
    -0.01136378f, 0.04539141f, 0.00102421f, -0.08101109f, -0.06980918f, 0.02184402f, 0.04031477f, 0.04779565f, 
    -0.05586451f, -0.06329727f, -0.03680804f, -0.00470543f, -0.00726743f, -0.00910367f, -0.04750286f, 0.01222613f, 
    -0.01797889f, 0.01666456f, 0.00716134f, 0.02401652f, 0.05073347f, -0.04591278f, -0.03747934f, -0.07824046f, 
    -0.06266693f, 0.02276196f, -0.04427514f, -0.00181759f, -0.05847264f, -0.00479806f, -0.05785824f, -0.03713264f, 
    -0.01090240f, -0.01641794f, -0.06230741f, 0.03027699f, -0.07741585f, 0.05311396f, 0.03916934f, -0.03600476f, 
    0.13508172f, -0.13786596f, -0.00848732f, -0.02481063f, -0.06702782f, 0.08366178f, 0.01164504f, 0.00470691f, 
    0.07702506f, -0.00476531f, -0.22173612f, 0.00383271f, 0.05995285f, -0.25926799f, -0.23832640f, 0.08248424f, 
    0.07502607f, 0.00094780f, -0.04627647f, 0.03724134f, 0.08064687f, 0.00448464f, 0.09813854f, 0.10451223f, 
    0.28864819f, -0.04650124f, 0.15510142f, 0.01299481f, 0.06128866f, 0.00326726f, 0.09693728f, 0.09788188f, 
    0.14496778f, 0.00796015f, -0.06787366f, -0.03957815f, -0.25279245f, 0.06105276f, 0.17117672f, 0.09111198f, 
    0.07610612f, 0.01584008f, 0.05728361f, 0.02191834f, -0.07903969f, 0.08802016f, 0.06409431f, 0.00102014f, 
    -0.05544994f, 0.25054511f, 0.15626451f, 0.14727433f, -0.04420471f, 0.08505627f, -0.00781756f, 0.04626948f, 
    0.02055640f, 0.14685246f, 0.02164498f, 0.00308357f, 0.17753321f, 0.12632768f, -0.12699817f, -0.16991572f, 
    -0.20343371f, 0.04105751f, 0.01987066f, -0.07723399f, 0.03748738f, -0.01316465f, -0.08114736f, -0.05610877f, 
    0.02674131f, -0.16112614f, 0.05713278f, -0.01120482f, -0.09875476f, 0.10049568f, 0.04298240f, 0.03849331f, 
    0.04774224f, 0.17785628f, -0.01355549f, -0.07618145f, -0.15405671f, 0.24298131f, -0.00663268f, -0.13240758f, 
    0.00874454f, -0.08628184f, 0.08652437f, -0.02125167f, 0.02975529f, 0.07061602f, -0.11111418f, 0.02778621f, 
    0.05593342f, -0.19852220f, 0.11682604f, -0.15795057f, 0.00142994f, -0.01467552f, 0.07322022f, -0.04333939f, 
    -0.00118050f, 0.04956958f, 0.18532273f, 0.00691997f, 0.06455071f, 0.13703233f, 0.29746523f, -0.04098015f, 
    -0.08131003f, 0.03955589f, 0.10210814f, -0.06418768f, 0.04563611f, 0.07518050f, -0.01971553f, 0.05457051f, 
    0.14780332f, 0.23380633f, 0.11904610f, 0.34213144f, -0.04138383f, -0.06706638f, -0.10779187f, 0.09659211f, 
    0.04853185f, 0.05679598f, -0.02695630f, 0.09503874f, 0.26866972f, 0.09112493f, -0.08806566f, 0.05258458f, 
    -0.17818350f, -0.06777584f, 0.00362195f, -0.02488357f, 0.08935852f, -0.09087946f, 0.04928600f, 0.06191980f, 
    -0.20227793f, -0.07833914f, -0.28956112f, -0.09462165f, -0.06355747f, 0.05713479f, -0.07326394f, -0.08216100f, 
    -0.04175216f, 0.15660217f, -0.00389326f, 0.00807649f, -0.01987303f, -0.06389625f, -0.13101576f, 0.10349713f, 
    0.03540594f, 0.13217363f, -0.06792973f, -0.09198861f, -0.00909828f, -0.01163620f, 0.10477015f, 0.09045006f, 
    0.32177907f, 0.07725391f, 0.16141626f, 0.07981609f, 0.00201065f, 0.06647715f, 0.07926738f, 0.01393922f, 
    0.04485053f, -0.02958142f, -0.08146034f, -0.05870607f, -0.21833611f, 0.21640302f, 0.16317047f, 0.12401696f, 
    0.05030883f, -0.05904944f, 0.01548102f, 0.00425288f, 0.00800210f, 0.13586980f, 0.02356395f, 0.03912903f, 
    0.09035853f, -0.25727999f, 0.16182768f, 0.05151118f, -0.03463643f, 0.10261291f, 0.02351961f, 0.00235366f, 
    -0.08559515f, -0.03946249f, -0.05988476f, 0.07548335f, -0.01640325f, 0.05714704f, -0.10048398f, 0.01657008f, 
    0.14001030f, -0.04181047f, 0.10466483f, -0.08309289f, 0.12785453f, 0.00124664f, 0.14192323f, 0.12488760f, 
    0.42206913f, -0.13967980f, 0.18280149f, -0.06031139f, 0.00286620f, 0.17912170f, 0.11417577f, -0.13529843f, 
    -0.02227329f, -0.06253957f, 0.00930018f, -0.05447771f, -0.04261469f, 0.02089808f, 0.00183579f, 0.01765928f, 
    0.11403955f, -0.04768053f, -0.00344715f, 0.02882410f, -0.01034082f, 0.15132335f, 0.02273020f, -0.12537092f, 
    0.03344483f, -0.15469532f, 0.00700140f, -0.04542945f, -0.01486469f, 0.11280823f, 0.14277236f, 0.07146037f, 
    0.03896593f, 0.08905002f, -0.00639317f, -0.05518098f, 0.33047131f, 0.11863176f, -0.23312910f, 0.04476057f, 
    -0.02030746f, -0.01781136f, 0.01199770f, -0.02914464f, 0.00406945f, -0.12734213f, 0.01314033f, -0.02945759f, 
    -0.12084660f, -0.00199702f, -0.09940976f, -0.12036582f, -0.07108658f, 0.08238599f, 0.17507820f, -0.05486418f, 
    -0.00031733f, -0.03559290f, 0.08815607f, -0.19160840f, -0.20396347f, -0.14926051f, -0.03731415f, -0.17744040f, 
    0.15302198f, 0.16499154f, -0.01958535f, -0.09055212f, 0.03510424f, -0.10922731f, 0.03479381f, 0.18457295f, 
    0.05423992f, -0.17329404f, 0.28591669f, -0.25112590f, -0.13396478f, -0.06572439f, -0.07210805f, 0.08371882f, 
    0.08482654f, -0.05441264f, -0.01730533f, 0.09078975f, 0.17501050f, 0.02594875f, 0.04904260f, -0.07014918f, 
    0.01327352f, 0.07361233f, 0.06635468f, 0.02826801f, 0.07909121f, 0.05067127f, -0.06963966f, -0.02194011f, 
    -0.09396206f, -0.30281371f, 0.16179341f, 0.25051466f, 0.07353909f, 0.01622131f, -0.09929327f, 0.11521680f, 
    -0.00275888f, 0.10779359f, -0.06033951f, -0.02055389f, -0.12002159f, 0.13578500f, -0.29012552f, -0.11614084f, 
    -0.11913689f, -0.12871902f, 0.06052273f, -0.16091371f, 0.04636187f, 0.01875193f, 0.03063530f, -0.13633546f, 
    -0.11904743f, 0.28177878f, -0.12544340f, 0.04255048f, 0.03879657f, -0.07977808f, 0.02974754f, -0.01101373f, 
    -0.08073196f, 0.09035365f, 0.06031796f, 0.11441051f, 0.07795544f, 0.14376058f, 0.07054001f, -0.10113166f, 
    0.06616741f, 0.01671954f, 0.01337576f, 0.01425253f, -0.01944626f, -0.03548528f, 0.03134460f, 0.12002494f, 
    0.10750563f, -0.01367466f, 0.13700099f, -0.18920426f, -0.01132399f, 0.03556904f, 0.02419065f, 0.03609977f, 
    -0.07217693f, -0.06169490f, -0.03529895f, 0.18072598f, 0.27359146f, 0.03442367f, -0.07689601f, 0.13672255f, 
    0.00327365f, -0.07047453f, -0.03053600f, 0.06295185f, 0.04996476f, -0.00219769f, 0.12936279f, 0.09218689f, 
    0.17170614f, -0.04836553f, 0.06047294f, -0.16751125f, -0.07859672f, 0.00284899f, -0.00366082f, -0.04994175f, 
    -0.06297640f, -0.11335095f, -0.11026731f, -0.08681224f, -0.04379424f, -0.07721446f, -0.07572284f, -0.00137385f, 
    -0.07476538f, -0.09930168f, -0.05190168f, 0.02270240f, -0.07314473f, -0.08203606f, 0.09809011f, 0.18277505f, 
    0.14724337f, -0.29172510f, 0.13997306f, 0.09830447f, -0.01436333f, 0.01705227f, 0.04594982f, -0.03504001f, 
    0.00678023f, -0.06333182f, 0.04710665f, -0.03773255f, -0.31442055f, 0.03822559f, -0.02324155f, 0.25714570f, 
    0.16321437f, -0.08907804f, 0.11163188f, 0.10660056f, 0.04200436f, 0.06551779f, 0.03097321f, 0.12330926f, 
    -0.11670882f, 0.20728177f, 0.01038768f, -0.05465671f, -0.06081837f, 0.11307883f, 0.04448720f, -0.01736545f, 
    0.04571985f, 0.25115401f, -0.11499808f, 0.07655586f, 0.42159420f, 0.13996474f, -0.11337502f, -0.18841855f, 
    -0.13712589f, 0.05866876f, -0.01742329f, 0.01716734f, -0.08409492f, -0.07409500f, -0.04027139f, 0.11293260f, 
    0.17787583f, -0.30410132f, -0.06403366f, -0.00278875f, -0.11118245f, -0.00991970f, 0.00718256f, 0.01959207f, 
    0.05493999f, 0.10078645f, -0.07642370f, -0.20657009f, 0.04000483f, 0.02434059f, 0.12768885f, -0.08804991f, 
    0.14527448f, -0.07573608f, -0.09215973f, 0.10672506f, 0.03205859f, -0.16062738f, -0.03788754f, 0.10891725f, 
    0.04411076f, 0.09518388f, 0.23375267f, 0.16605295f, -0.03515996f, -0.06546997f, 0.00883249f, 0.00394222f, 
    0.00358505f, -0.03948370f, 0.14650168f, -0.01225986f, -0.06395259f, 0.09833003f, 0.04995102f, -0.10673807f, 
    -0.16683245f, 0.18562953f, 0.09161308f, 0.03521255f, -0.05222094f, 0.05139702f, -0.10120419f, 0.04647303f, 
    0.08863240f, 0.32234797f, 0.05724046f, 0.05199500f, 0.02306475f, -0.06757675f, -0.07462596f, 0.03385429f, 
    0.12919396f, 0.15273142f, -0.01810974f, 0.06897756f, 0.10505995f, -0.07561191f, 0.12066756f, 0.31150061f, 
    0.21434735f, -0.06609146f, 0.06489755f, 0.11775741f, 0.06530059f, 0.07125133f, 0.04515622f, 0.08445404f, 
    0.03031685f, 0.12677221f, -0.15238738f, -0.21545729f, -0.03391066f, 0.03716099f, 0.01370362f, -0.01486392f, 
    -0.00098964f, 0.20397626f, -0.07710005f, 0.02546173f, -0.13989983f, -0.10361557f, -0.00820196f, 0.41351777f, 
    -0.06694417f, 0.01450203f, 0.02308534f, 0.03189791f, -0.01833464f, -0.06798738f, 0.02524255f, 0.04591165f, 
    -0.10263027f, -0.13722594f, 0.05864352f, -0.03115293f, -0.06553604f, 0.01984913f, 0.02880879f, 0.01087137f, 
    0.10799479f, 0.07217736f, -0.00318400f, 0.01785040f, -0.21660410f, 0.14948165f, 0.09261088f, 0.06653182f, 
    0.04667281f, -0.00266973f, -0.05286824f, -0.12193098f, 0.19821516f, 0.06636515f, 0.07574907f, 0.04847479f, 
    -0.11328942f, -0.12260532f, 0.07786787f, 0.12151565f, -0.09635987f, 0.06974850f, -0.02190498f, -0.05616317f, 
    -0.04556122f, -0.03722176f, -0.05994034f, -0.01850909f, -0.00695914f, -0.07205493f, -0.05693681f, 0.08164883f, 
    0.03306352f, 0.02369258f, -0.05953985f, 0.00435547f, 0.10898656f, 0.04066808f, 0.07419011f, 0.23592535f, 
    0.13258286f, -0.30078226f, 0.18854153f, -0.13141276f, -0.02949367f, 0.10874030f, 0.10727075f, -0.09460712f, 
    -0.01563070f, 0.03434469f, 0.05121288f, -0.03063496f, -0.38576135f, -0.02232443f, -0.11137670f, 0.17988798f, 
    0.04524096f, 0.02281675f, 0.00178889f, 0.07259779f, -0.04120602f, 0.02457846f, -0.10101891f, -0.03292452f, 
    -0.26974761f, 0.09495840f, -0.18737949f, 0.02248735f, 0.04143987f, 0.12064555f, 0.14753544f, -0.02496314f, 
    0.10864195f, 0.13256842f, -0.08615500f, -0.16366775f, 0.17936213f, 0.00279879f, -0.30700877f, -0.10547809f, 
    -0.00142270f, 0.00507156f, -0.00332762f, -0.04240276f, 0.03871393f, -0.04336705f, -0.03328777f, -0.07469966f, 
    0.07534407f, -0.04600284f, 0.07066346f, 0.11269284f, -0.05948357f, 0.04513499f, 0.09771171f, -0.01886922f, 
    0.06762677f, 0.03665089f, 0.07270601f, -0.28017598f, -0.28613925f, -0.09322553f, -0.14107807f, -0.15662920f, 
    0.20271966f, 0.19208832f, -0.00183924f, 0.13511814f, 0.14472428f, -0.13420944f, -0.07358418f, 0.25034979f, 
    0.31014836f, 0.06021761f, 0.28986377f, 0.05305712f, -0.07619362f, 0.04814396f, -0.11932486f, -0.00638755f, 
    0.09964894f, 0.18808542f, 0.09039330f, 0.09024080f, -0.16692370f, 0.06708767f, -0.17558289f, -0.25504085f, 
    0.11915468f, 0.13399321f, -0.11086939f, -0.06186441f, 0.10768341f, -0.06629043f, -0.18806890f, -0.11077925f, 
    -0.18289824f, -0.08678035f, 0.15145637f, 0.15254743f, 0.04829830f, -0.08805052f, -0.05119694f, 0.08670267f, 
    0.05298270f, -0.02215371f, 0.01585872f, 0.08893278f, -0.29821473f, 0.03389204f, -0.13685219f, 0.09001409f, 
    0.09590037f, -0.01439345f, 0.23573188f, 0.03555245f, -0.01521218f, -0.02579213f, 0.00813982f, 0.03509196f, 
    -0.05923032f, 0.14684752f, -0.12977840f, -0.02044058f, 0.05545847f, -0.06888552f, 0.04631260f, -0.21764593f, 
    0.01576356f, 0.10416542f, 0.03445975f, 0.10579222f, 0.11004159f, 0.27125624f, 0.18802293f, 0.13958694f, 
    -0.10102934f, -0.11845570f, -0.11978137f, 0.06706157f, 0.09917118f, 0.05198153f, 0.04540001f, 0.14319967f, 
    0.11411116f, -0.12002777f, 0.08933846f, -0.16080607f, -0.16966300f, -0.13665879f, -0.10191827f, 0.12381834f, 
    0.03639058f, 0.06795845f, -0.02480909f, 0.16345833f, 0.04901514f, 0.02979007f, -0.12656374f, 0.10481003f, 
    0.11838981f, 0.00873866f, -0.00858364f, -0.04314055f, 0.09861542f, 0.00884143f, 0.20691377f, 0.14769448f, 
    -0.00417644f, -0.04571558f, -0.03043549f, -0.00236815f, -0.03331595f, -0.06574090f, 0.03768397f, -0.02703561f, 
    0.00572982f, -0.07789402f, -0.06872771f, 0.01084464f, 0.03898080f, 0.00192149f, -0.05668003f, 0.01812056f, 
    0.01154699f, 0.01512585f, 0.02496224f, -0.06673468f, 0.03907394f, 0.04900572f, -0.06807955f, -0.01772408f, 
    0.01752732f, -0.04906863f, -0.07251862f, 0.02024368f, -0.01967047f, -0.03527730f, 0.06300023f, -0.02439521f, 
    -0.04997525f, -0.06906649f, -0.01427998f, 0.01757678f, 0.01349648f, 0.03765954f, -0.06587474f, -0.05740376f, 
    0.04510071f, 0.01547826f, 0.02925975f, 0.06456149f, 0.02049696f, 0.06282332f, -0.00959852f, -0.03783614f, 
    0.03627409f, -0.05185242f, 0.01021323f, 0.03295461f, 0.01621128f, -0.03918666f, -0.00523061f, 0.00799812f, 
    0.02515671f, 0.06332999f, -0.00599816f, -0.02360658f, -0.05182155f, -0.04716049f, -0.03819841f, -0.00467119f, 
    0.02330934f, -0.06739417f, 0.01825571f, 0.05343096f, -0.07193041f, 0.03954687f, -0.08257089f, -0.03728132f, 
    -0.06532688f, 0.02211136f, -0.01879653f, 0.05075230f, 0.05375663f, 0.06732436f, 0.01299462f, 0.02371364f, 
    0.04841416f, 0.04430507f, 0.04767738f, -0.05667291f, 0.05823033f, -0.01803719f, -0.06363965f, 0.04389115f, 
    0.03743875f, 0.01704713f, 0.01449389f, -0.07596695f, -0.05793571f, 0.02326262f, -0.04676344f, 0.00870758f, 
    0.01066093f, -0.06939976f, 0.03034953f, -0.04564312f, -0.00243927f, 0.03147136f, -0.05233815f, 0.01080793f, 
    -0.05484034f, 0.04453845f, -0.05257390f, -0.02215943f, 0.06152553f, 0.02167527f, 0.02281400f, -0.00108582f, 
    0.04734912f, -0.03313132f, 0.00664027f, -0.07274981f, -0.03769912f, -0.01192349f, -0.03459865f, 0.03133509f, 
    -0.03805222f, 0.03170407f, 0.05951981f, -0.06135730f, -0.06047050f, 0.01289254f, 0.04863299f, 0.02142475f, 
    0.02552357f, -0.07094685f, -0.03129805f, -0.04948282f, 0.04029207f, -0.06530543f, -0.04989870f, -0.03044389f, 
    -0.07176507f, -0.02405515f, -0.03527235f, 0.00950053f, -0.02159327f, 0.03517278f, -0.00281138f, -0.07782812f, 
    -0.02796170f, 0.03845556f, -0.04256483f, -0.05567191f, -0.00858658f, -0.00058999f, -0.00853088f, 0.05290547f, 
    -0.02548137f, 0.06338325f, 0.02407258f, -0.00487220f, -0.00087885f, -0.04632831f, 0.00513727f, -0.07684423f, 
    0.00266733f, 0.03023907f, 0.02182920f, -0.02131928f, -0.01572109f, 0.00090324f, 0.04372187f, -0.01552157f, 
    -0.00333904f, -0.03670500f, -0.06847428f, -0.07227799f, 0.00299265f, -0.01315458f, -0.02082966f, -0.06573433f, 
    0.00699386f, 0.02063922f, -0.02242710f, -0.06276371f, -0.03149971f, -0.06406090f, -0.00216903f, 0.01209220f, 
    0.06508262f, 0.02894406f, -0.00952426f, 0.02451124f, 0.02808805f, -0.04702181f, -0.01766675f, -0.04832297f, 
    0.24666618f, 0.17445089f, -0.01984439f, -0.06848057f, 0.02649221f, 0.04221648f, -0.00583737f, 0.08241706f, 
    0.00970662f, -0.06126076f, -0.02999382f, -0.15947686f, -0.25342262f, 0.03002371f, -0.09663331f, 0.07441585f, 
    0.11532909f, 0.00716830f, 0.10683718f, -0.02256858f, -0.02386905f, -0.12569433f, 0.07320180f, 0.06718082f, 
    -0.06578503f, -0.04079539f, 0.18410374f, -0.22155669f, -0.12245442f, 0.12485930f, 0.01758194f, 0.00057374f, 
    -0.11865225f, -0.01678518f, 0.04563894f, -0.01209329f, 0.00010206f, -0.05130779f, 0.07793269f, -0.21770257f, 
    -0.04939213f, 0.03030223f, 0.03474854f, -0.00066946f, -0.07917435f, 0.11110813f, -0.04262947f, 0.05709858f, 
    -0.23032655f, 0.05291671f, -0.07381383f, 0.01601123f, -0.05787484f, -0.09582222f, 0.05755500f, -0.07921679f, 
    0.06354640f, 0.03706138f, 0.03914458f, 0.03139611f, 0.00762408f, 0.27823776f, 0.11590759f, 0.38135746f, 
    -0.14699142f, 0.07308166f, 0.01669490f, 0.09028704f, 0.06252951f, -0.04132019f, -0.04097340f, 0.12046750f, 
    -0.14262149f, -0.29391456f, -0.07379469f, -0.04291116f, -0.03239834f, 0.11395408f, 0.08818447f, -0.00893516f, 
    0.12745295f, -0.00950290f, 0.05019902f, -0.14019483f, 0.13123657f, -0.16673109f, 0.14083411f, -0.00558340f, 
    -0.00013063f, 0.02485292f, 0.03001590f, -0.16833243f, 0.10533075f, 0.02501581f, 0.03201622f, 0.01199118f, 
    0.01925633f, 0.04257410f, 0.20837964f, -0.11072955f, 0.11991287f, -0.10006006f, 0.02347418f, 0.06605639f, 
    0.04121708f, -0.00008157f, 0.15463734f, -0.02939849f, -0.09976869f, -0.04914588f, -0.08359237f, -0.05969679f, 
    0.11380740f, 0.07630375f, 0.00676787f, -0.01474474f, 0.04388322f, 0.04570876f, -0.11481063f, 0.09343245f, 
    0.06800176f, -0.03181210f, 0.09024618f, 0.00153113f, 0.02544241f, 0.04340245f, -0.07090531f, 0.18331330f, 
    0.02469322f, 0.09328552f, -0.04536661f, 0.02097503f, -0.01056123f, 0.02261848f, 0.12920269f, 0.15560940f, 
    0.17843303f, -0.03615558f, 0.14489961f, 0.07605258f, -0.04891948f, -0.08314765f, 0.07628987f, 0.06831010f, 
    -0.01160025f, 0.45067006f, -0.01768897f, 0.09268612f, 0.04504555f, -0.11576909f, -0.00059697f, -0.05203191f, 
    -0.00920537f, 0.09411815f, -0.11920260f, 0.01306188f, -0.30616036f, -0.11552876f, -0.03869589f, 0.14150734f, 
    0.08967616f, 0.00268828f, -0.08749054f, -0.06288051f, 0.04177190f, -0.00089531f, 0.04221296f, 0.01444621f, 
    -0.36166272f, 0.04109571f, -0.13555010f, -0.06038389f, 0.14286204f, -0.09963802f, 0.10181107f, 0.04558645f, 
    -0.01207106f, 0.04625195f, -0.01838963f, 0.08551989f, 0.16277567f, -0.19085810f, 0.14888421f, 0.00085172f, 
    0.04264548f, -0.02384759f, 0.00942869f, -0.07830960f, 0.12556472f, 0.07026482f, 0.04482213f, 0.12606284f, 
    -0.12086838f, -0.01215070f, 0.12566240f, -0.04289488f, -0.00838348f, 0.11854167f, -0.00153636f, 0.02819078f, 
    -0.06658182f, 0.02486479f, 0.10934707f, -0.10915709f, -0.12285984f, 0.34077331f, 0.09626707f, 0.11889783f, 
    -0.06506573f, 0.16934903f, -0.04523139f, 0.06632806f, -0.00670416f, -0.01543198f, -0.00351025f, 0.09432187f, 
    -0.25180534f, -0.00880230f, -0.00167821f, -0.00390490f, -0.09356334f, 0.12124463f, 0.08591241f, -0.01504046f, 
    0.03691506f, -0.00934008f, -0.09038439f, 0.10082690f, -0.11114389f, -0.17029528f, -0.14486642f, 0.12012808f, 
    0.13321999f, -0.09944641f, 0.11142767f, 0.06168519f, -0.00612304f, -0.12107486f, -0.17754768f, 0.16254538f, 
    -0.34790316f, -0.06828094f, -0.26480809f, -0.24059300f, 0.09362111f, 0.02716304f, -0.06256404f, -0.03611673f, 
    -0.02731503f, 0.13125809f, -0.09736142f, -0.00025090f, -0.19232899f, -0.32080546f, -0.19679424f, -0.16618849f, 
    0.16509457f, 0.15728755f, 0.01047159f, 0.17517319f, 0.08200486f, 0.04410761f, 0.06868936f, 0.02219563f, 
    0.03269805f, -0.17583242f, 0.01405606f, 0.22729540f, 0.04549421f, 0.19697814f, 0.00038879f, -0.04724836f, 
    0.04966753f, -0.12645628f, 0.05407004f, 0.05067030f, -0.20421275f, -0.24056494f, -0.08546444f, -0.18888421f, 
    0.02804292f, 0.13606361f, -0.20269404f, 0.09011424f, 0.13142143f, 0.09534833f, 0.03163181f, 0.15421794f, 
    0.12630974f, 0.30297542f, 0.21549198f, 0.25735816f, 0.08008932f, 0.00528843f, -0.16236451f, -0.10802576f, 
    0.13172241f, 0.06596594f, -0.02699108f, 0.11685771f, -0.52286518f, -0.07527287f, -0.17977166f, -0.09460350f, 
    0.15977034f, 0.05752098f, -0.02571891f, 0.08869313f, -0.06856723f, -0.04620705f, 0.05804507f, -0.01654403f, 
    0.09078692f, -0.13559328f, -0.09045584f, -0.09516121f, -0.12164526f, 0.11098579f, 0.03700576f, 0.03892539f, 
    -0.10512968f, -0.05347710f, 0.05226041f, -0.10461307f, -0.51440573f, -0.17899071f, -0.17490652f, -0.09749111f, 
    0.35037035f, 0.13593999f, 0.18839487f, 0.03899035f, 0.11368672f, 0.02647796f, -0.06183415f, 0.11080101f, 
    0.08146907f, -0.03605447f, -0.04148955f, -0.05240539f, 0.05192018f, -0.09522964f, 0.14690554f, 0.16772009f, 
    0.06706628f, -0.00852195f, 0.05689533f, 0.06309303f, -0.06833547f, 0.15911385f, 0.41649219f, 0.06836129f, 
    -0.01556556f, -0.11505518f, -0.16051637f, -0.04470295f, 0.15459526f, 0.06868464f, 0.09201963f, 0.09506859f, 
    -0.02722479f, 0.28829113f, 0.00603396f, -0.22770070f, -0.11440911f, 0.02264531f, -0.06233864f, 0.25276983f, 
    0.15334190f, 0.08440281f, -0.02465441f, 0.14944173f, 0.06107372f, -0.12416388f, -0.09182834f, -0.12715358f, 
    -0.05067699f, 0.14800727f, 0.10692638f, -0.11529040f, 0.22903121f, 0.03706928f, 0.18327528f, 0.01698834f, 
    0.36818570f, -0.01096442f, -0.26150715f, 0.18386805f, 0.17661749f, -0.02611976f, 0.04572026f, 0.02917201f, 
    0.06698955f, 0.03682331f, -0.09628550f, 0.12142529f, 0.21328844f, -0.17586488f, -0.15833429f, 0.17699671f, 
    -0.04026547f, 0.06404424f, -0.09449611f, 0.03172415f, 0.07369457f, 0.01924409f, 0.11883084f, 0.01657315f, 
    0.10280957f, -0.05676260f, 0.07455635f, -0.20660430f, 0.22008735f, -0.09277073f, 0.06082502f, 0.00548829f, 
    0.02114126f, 0.01593159f, 0.05725805f, 0.06200797f, -0.22530524f, -0.16862994f, 0.14227298f, -0.20154227f, 
    0.03048610f, 0.07149304f, -0.03769392f, 0.01405931f, -0.02540063f, 0.08469544f, 0.04801402f, -0.05176029f, 
    -0.04820066f, 0.19609676f, 0.11078305f, 0.18321492f, 0.09176731f, 0.03804314f, -0.04168699f, 0.06809101f, 
    -0.11350414f, -0.07155792f, -0.00985151f, 0.04067065f, -0.07410123f, 0.22157469f, 0.03437398f, 0.11039998f, 
    -0.06840219f, -0.05192582f, -0.00715180f, -0.00943283f, -0.05066673f, 0.10837486f, 0.03507385f, -0.04683991f, 
    0.00838800f, 0.19858910f, -0.00436544f, -0.08369282f, 0.00571211f, -0.08132517f, 0.03111415f, 0.01836424f, 
    -0.01760045f, 0.10447529f, -0.02438320f, 0.05613286f, -0.24566166f, 0.14252359f, 0.01093046f, -0.00833932f, 
    -0.13612531f, 0.04302688f, 0.18994580f, -0.03984671f, -0.04572985f, 0.07766541f, -0.07260894f, -0.04073917f, 
    0.33252949f, -0.22332394f, -0.04251373f, -0.00541792f, -0.03181417f, -0.02916003f, 0.06180059f, -0.00252528f, 
    0.03467621f, 0.06191532f, 0.04384384f, 0.11127419f, -0.32592267f, 0.07324453f, 0.16500774f, -0.19284986f, 
    0.12015416f, -0.06947592f, 0.00651270f, -0.06607322f, 0.07024314f, -0.10899206f, 0.08563722f, 0.05685602f, 
    0.07627860f, 0.12954655f, 0.01831397f, 0.02358310f, 0.06755262f, 0.10060146f, -0.06042316f, 0.02980163f, 
    0.08645241f, -0.01802389f, 0.03230055f, 0.06854618f, -0.07355186f, 0.05067732f, 0.12583692f, -0.26470974f, 
    -0.14156240f, -0.11928761f, -0.01853970f, -0.02575108f, 0.00795890f, -0.06409218f, 0.03816149f, -0.05907318f, 
    0.03829508f, 0.14118226f, -0.23859572f, 0.01235506f, 0.03149202f, 0.15123813f, -0.13658294f, -0.01331073f, 
    0.07826944f, -0.12022958f, 0.01150000f, 0.02932306f, 0.21990557f, 0.08158348f, 0.00871305f, 0.26056099f, 
    0.07990364f, -0.03493426f, 0.02970529f, 0.04888764f, 0.11830349f, 0.11094455f, 0.08967681f, 0.01637538f, 
    0.15609352f, -0.02642621f, 0.05654998f, 0.14192951f, 0.09435728f, 0.10784300f, 0.01429134f, 0.01430907f, 
    -0.03890834f, -0.07363345f, -0.05988154f, -0.09868078f, -0.08214126f, 0.05511077f, -0.03625882f, -0.02215427f, 
    -0.01563133f, 0.00591072f, 0.01335447f, 0.01813256f, -0.04057822f, 0.03448328f, -0.05058053f, 0.09483071f, 
    -0.06588359f, -0.10382818f, 0.01936050f, 0.01444149f, 0.01194459f, 0.08938225f, 0.06897237f, -0.03632074f, 
    0.02305240f, -0.14630549f, -0.11712737f, -0.06558102f, -0.07160322f, -0.20471624f, -0.17187880f, 0.07671412f, 
    0.03724677f, 0.05150162f, 0.06660183f, 0.07795013f, 0.11659221f, 0.02674177f, 0.13250731f, 0.25860652f, 
    0.05604401f, -0.02378041f, 0.24672638f, -0.12208448f, 0.12600404f, -0.06096154f, 0.06037098f, -0.00860696f, 
    0.00544687f, -0.02306581f, -0.02357781f, 0.04172104f, -0.32956684f, 0.02741572f, 0.15762524f, 0.10589810f, 
    -0.00192604f, 0.09097830f, -0.06981343f, 0.10225964f, -0.07065247f, 0.08430562f, 0.00634444f, 0.02812920f, 
    -0.09118123f, 0.24567132f, -0.00500892f, 0.04492281f, 0.01934537f, -0.02228891f, 0.11400247f, 0.10763265f, 
    0.03453640f, 0.08885389f, -0.08925280f, -0.09099258f, -0.00727766f, 0.18199272f, -0.14833428f, -0.00710935f, 
    -0.07459834f, 0.03829472f, -0.04833592f, -0.12328562f, -0.03726661f, 0.02874047f, -0.03825565f, -0.02133149f, 
    0.11199521f, -0.04284039f, 0.05281030f, -0.03905703f, -0.05897490f, -0.00414968f, 0.00243429f, 0.00810103f, 
    0.09980921f, 0.09454796f, 0.03369279f, -0.22312586f, -0.21256682f, 0.23452449f, -0.02752907f, -0.07644299f, 
    0.06848930f, 0.07532746f, 0.08297549f, -0.09862380f, 0.07908074f, 0.14800008f, -0.02770511f, 0.02723970f, 
    -0.04153050f, -0.11571835f, 0.09693868f, -0.25229540f, -0.02896606f, -0.03815500f, 0.03786628f, -0.10995847f, 
    0.04390401f, -0.00600563f, 0.17651604f, 0.05805011f, -0.13041012f, 0.14242478f, 0.11005217f, -0.11428723f, 
    -0.06197102f, -0.04505625f, 0.02927000f, -0.00623757f, 0.02733740f, 0.08961581f, -0.04779837f, 0.02447149f, 
    0.12847744f, 0.18405253f, 0.34107661f, 0.48527896f, -0.02722523f, 0.06214618f, -0.12775286f, 0.01884556f, 
    -0.04461578f, 0.13827148f, 0.08520905f, -0.02139137f, 0.26174915f, 0.09471478f, -0.08387536f, 0.17488453f, 
    0.01960472f, -0.08351206f, 0.05077180f, 0.06662759f, 0.03817407f, -0.05414842f, 0.15085414f, -0.00702246f, 
    -0.15319955f, 0.01794322f, -0.16606584f, 0.06496006f, 0.12068217f, 0.00593596f, -0.14321406f, -0.07057361f, 
    -0.01942177f, 0.12564605f, -0.05490072f, -0.02944952f, -0.03487933f, 0.00291046f, -0.19631751f, 0.15818585f, 
    0.05796273f, 0.04722428f, 0.01666226f, -0.02794472f, -0.01411862f, 0.00740561f, 0.03213713f, 0.12288810f, 
    0.18873152f, -0.07513780f, -0.03300013f, 0.13911054f, 0.00413503f, -0.11489230f, 0.01259722f, 0.05663516f, 
    0.11004561f, -0.02486967f, 0.01287463f, -0.00633995f, -0.12105589f, -0.01076276f, 0.28146073f, 0.22122663f, 
    0.11257821f, 0.01146178f, 0.04097407f, -0.02383613f, 0.05009390f, 0.00530864f, 0.07977530f, 0.16238607f, 
    0.09738430f, -0.11598189f, 0.13082851f, 0.23872064f, 0.02997635f, 0.05238629f, 0.13759586f, -0.02934053f, 
    0.06549882f, 0.08365986f, -0.04806983f, 0.06857936f, 0.44308347f, -0.04668471f, 0.02549340f, 0.14773647f, 
    -0.02196765f, -0.03174729f, -0.05291778f, -0.04259394f, 0.00233510f, -0.01269091f, 0.06010650f, -0.11715204f, 
    0.12605482f, -0.02387610f, -0.18470412f, -0.21514167f, 0.06706864f, -0.04016194f, 0.03814880f, 0.06022972f, 
    -0.02105297f, 0.14000438f, -0.05874980f, -0.02103887f, -0.06277537f, 0.05233825f, 0.08618321f, 0.11672821f, 
    0.02330338f, -0.01400396f, -0.08534022f, -0.07178821f, 0.17071375f, -0.01373104f, 0.04105009f, -0.05112963f, 
    0.29891083f, -0.06853681f, 0.02093567f, 0.04855353f, 0.04149138f, 0.09937862f, -0.06208676f, 0.02355228f, 
    -0.01107256f, 0.09422031f, 0.01222797f, 0.03109885f, 0.22323489f, -0.01668414f, 0.06004227f, -0.03650428f, 
    0.09693408f, -0.19777676f, 0.04347439f, 0.06484871f, 0.04094383f, 0.01788476f, 0.00032392f, -0.09801073f, 
    0.28811741f, 0.28089309f, -0.26748845f, -0.19508679f, 0.12592189f, -0.12879246f, 0.02350237f, 0.00764997f, 
    -0.01731570f, 0.07187816f, 0.00619842f, 0.11988874f, 0.13468431f, 0.08120476f, 0.04961061f, 0.02700074f, 
    -0.17916340f, 0.07546893f, 0.03002639f, 0.06991343f, -0.03058445f, -0.11447987f, -0.06694917f, -0.09428000f, 
    0.29274967f, -0.14594933f, 0.08044210f, 0.17628449f, 0.02853770f, 0.09300099f, -0.02444780f, -0.03219586f, 
    -0.02845231f, 0.02272116f, 0.06039190f, 0.06476286f, 0.19098549f, 0.02230824f, 0.20012224f, 0.04094861f, 
    0.05005910f, 0.02880917f, 0.04100511f, -0.08666243f, 0.10182981f, 0.04776365f, 0.08975163f, -0.07001065f, 
    -0.26696202f, 0.00754394f, -0.14156507f, 0.03917439f, 0.00332197f, -0.06980371f, -0.02736731f, -0.16378343f, 
    0.09770309f, 0.04344048f, 0.00714656f, 0.02709230f, 0.00764191f, 0.04825487f, -0.03487464f, -0.22278620f, 
    -0.11709321f, -0.05328577f, -0.03019764f, -0.20882785f, -0.07362888f, 0.11236612f, 0.01644125f, -0.07630149f, 
    0.06081448f, -0.00543615f, 0.06410583f, -0.13438433f, 0.06932522f, 0.08895105f, 0.05331507f, -0.01944637f, 
    -0.04034800f, -0.01765708f, 0.10950483f, 0.02074859f, 0.38307643f, 0.22502407f, -0.06690722f, 0.20923914f, 
    0.05780246f, 0.04623717f, 0.11333956f, -0.00317737f, -0.05670523f, 0.05192296f, 0.02081514f, 0.07478218f, 
    -0.00593591f, -0.05599389f, 0.07837898f, 0.13916981f, 0.07995187f, 0.00163420f, -0.13135955f, -0.04978441f, 
    -0.14007026f, -0.03398218f, -0.02468772f, -0.11714923f, 0.14639135f, 0.05271900f, -0.29489779f, -0.00376762f, 
    -0.01692037f, 0.00412438f, -0.08891306f, -0.04415245f, -0.08124062f, 0.03787905f, -0.06962875f, -0.08320040f, 
    -0.26293519f, 0.07562450f, -0.03640548f, 0.01427371f, -0.10468898f, 0.06350230f, -0.00149827f, -0.02880977f, 
    -0.02218298f, -0.08989640f, 0.01985607f, -0.01250916f, -0.05183538f, 0.01161680f, 0.06538565f, 0.15794468f, 
    0.01053862f, -0.00161322f, -0.12934946f, 0.14064182f, -0.01847788f, -0.07635325f, -0.08016114f, 0.08632404f, 
    -0.31218576f, 0.05906680f, -0.00898822f, 0.16997994f, 0.12194563f, -0.05231834f, 0.02359855f, 0.12162417f, 
    -0.00644993f, 0.00824356f, 0.00042124f, 0.09339575f, -0.23162714f, 0.09027641f, -0.07539319f, 0.22714154f, 
    0.00620886f, 0.02275346f, -0.03650203f, -0.04859023f, -0.01191309f, -0.07133976f, -0.00002888f, 0.05941112f, 
    -0.20284098f, 0.10336646f, -0.01542222f, -0.08071423f, 0.04753768f, 0.05539616f, 0.01854140f, 0.10403237f, 
    -0.07589562f, 0.00570728f, 0.00402928f, 0.02128527f, -0.17961489f, -0.19808093f, -0.10672631f, -0.21310984f, 
    0.12734321f, 0.15020958f, -0.07185527f, -0.12975626f, 0.06445955f, 0.09909064f, 0.04283024f, -0.03452374f, 
    0.37675232f, 0.07508629f, 0.27808464f, 0.38012210f, 0.02267702f, -0.00990361f, -0.10533735f, 0.01636471f, 
    0.02550100f, 0.01281904f, -0.00696158f, -0.02176329f, -0.15404128f, 0.10856736f, -0.02146869f, -0.03902400f, 
    0.09664571f, -0.05598733f, 0.05153341f, 0.13383026f, 0.09914129f, 0.07793279f, 0.01823771f, -0.09383500f, 
    0.02124676f, 0.23415336f, -0.02597612f, 0.07424580f, -0.01479865f, 0.01923798f, 0.03897195f, 0.02387361f, 
    0.02322315f, 0.01898235f, 0.04526747f, -0.05667427f, -0.41363147f, 0.02895025f, -0.02026138f, -0.15045509f, 
    0.00106986f, 0.02636749f, -0.01708740f, -0.02531144f, 0.04796309f, -0.07141188f, 0.13868488f, -0.05529392f, 
    -0.17896242f, 0.22934715f, -0.00673166f, 0.10234872f, -0.05690673f, 0.10094100f, 0.07941291f, -0.07829059f, 
    0.00210913f, 0.02683736f, 0.09620666f, 0.01821399f, 0.10286017f, 0.03865676f, -0.08115376f, 0.21205364f, 
    0.05974022f, 0.19024171f, 0.00751401f, 0.06224515f, 0.05390366f, 0.12626182f, 0.06780528f, 0.03661927f, 
    0.23281024f, -0.18611930f, -0.03910090f, -0.02016715f, 0.04350779f, -0.03477778f, -0.17943060f, -0.16278960f, 
    -0.04989654f, 0.07174954f, -0.02962160f, -0.05811763f, 0.29283297f, 0.10852563f, 0.14548548f, -0.04998217f, 
    -0.07456126f, -0.03797162f, 0.03594286f, 0.16582954f, 0.06969664f, 0.04429805f, -0.06021483f, -0.06826750f, 
    0.14512230f, -0.00638954f, -0.10096806f, 0.17522986f, 0.04406939f, -0.06896291f, -0.06321925f, 0.12599839f, 
    0.17330664f, 0.00840534f, 0.06079125f, 0.00097448f, -0.27587840f, -0.01798772f, 0.30849546f, 0.13156761f, 
    -0.00716823f, 0.06726556f, 0.13655633f, -0.01091969f, 0.19486231f, -0.01506521f, 0.13479227f, 0.01091166f, 
    0.04543296f, -0.00983546f, -0.12090879f, -0.05948312f, 0.00634372f, 0.03734761f, -0.08641430f, 0.06401065f, 
    0.08592058f, 0.08306169f, 0.03019565f, 0.11849020f, -0.03284550f, 0.09422477f, -0.04405681f, 0.08263068f, 
    -0.01867752f, 0.01535973f, 0.11064355f, 0.01015845f, 0.05781246f, 0.12904364f, -0.07923518f, -0.03122740f, 
    0.05539759f, 0.19324005f, 0.12537317f, -0.00116073f, 0.16545820f, 0.02746215f, 0.03891117f, -0.06315108f, 
    0.12562016f, -0.01965157f, 0.09681464f, 0.14745532f, 0.22910349f, -0.09923861f, 0.18666509f, -0.14738271f, 
    0.06419781f, 0.13527165f, 0.04705695f, 0.02052042f, -0.16419129f, 0.05067507f, 0.02382371f, -0.03810042f, 
    -0.02229414f, 0.03636332f, 0.16903938f, 0.08549999f, 0.02737396f, -0.05023455f, 0.02410598f, 0.08289012f, 
    -0.03274063f, -0.08887227f, -0.01113995f, 0.00867323f, -0.36022532f, -0.03932852f, 0.02660322f, 0.06550036f, 
    0.00665369f, 0.00170819f, 0.17393516f, -0.10522686f, 0.03680985f, -0.00455832f, 0.01622131f, 0.05738831f, 
    -0.15648392f, 0.11214946f, 0.13225871f, 0.10695779f, 0.01523522f, 0.00401133f, -0.14131208f, 0.09055136f, 
    -0.04920188f, -0.02877655f, -0.02072077f, 0.21029150f, -0.29318261f, 0.00025448f, -0.03639590f, -0.05339854f, 
    -0.04676936f, 0.06428863f, 0.09743109f, 0.01499674f, 0.02028315f, 0.17568627f, -0.01862989f, -0.09759911f, 
    -0.16129310f, -0.04048673f, -0.15895309f, -0.26789865f, -0.00828882f, -0.03317989f, 0.06304651f, 0.05365770f, 
    -0.06978426f, 0.05268104f, -0.09798424f, -0.05980445f, -0.03527449f, 0.12545313f, 0.11210368f, 0.09532646f, 
    -0.00022662f, -0.07710852f, 0.07197829f, 0.06396775f, -0.00205342f, -0.02405553f, 0.14839374f, 0.06593481f, 
    0.23533303f, 0.00607595f, 0.25797117f, 0.33112729f, -0.00968473f, 0.04043234f, 0.09028497f, 0.05940487f, 
    -0.03232873f, -0.11416315f, 0.12906091f, 0.03038723f, 0.19626608f, 0.04630171f, 0.07092477f, -0.08786421f, 
    -0.10171881f, 0.02669329f, -0.10211760f, -0.13101694f, 0.04728550f, 0.01040887f, 0.02881874f, -0.10879581f, 
    -0.07798339f, -0.09682100f, -0.05278020f, 0.18655540f, -0.01520758f, 0.15595242f, 0.01629240f, 0.07382042f, 
    0.05411731f, -0.04816591f, -0.00759601f, -0.14266078f, -0.12587282f, 0.08738907f, 0.00086488f, -0.27094197f, 
    0.02723004f, -0.04239156f, 0.07188364f, -0.09748882f, -0.04173507f, -0.03568748f, 0.08002622f, -0.05323730f, 
    0.21401580f, 0.18138266f, 0.08993627f, 0.19427313f, 0.02777334f, 0.02854857f, 0.07324958f, 0.01493291f, 
    0.02003580f, -0.08093162f, 0.01940000f, -0.10589512f, -0.04979317f, -0.12613018f, 0.28159949f, 0.05344897f, 
    0.03612861f, -0.06098926f, 0.03807034f, 0.20343214f, 0.01529546f, 0.07302082f, -0.16246773f, -0.07186910f, 
    -0.04987252f, 0.07020113f, 0.05630609f, 0.07174219f, -0.05954450f, 0.03523953f, 0.05193342f, -0.07139159f, 
    -0.03348110f, -0.02413047f, -0.03267259f, -0.01249919f, -0.03001888f, -0.02538474f, -0.06915016f, -0.06859747f, 
    -0.04509974f, 0.00453795f, 0.04683346f, -0.04571713f, -0.03326968f, -0.03510602f, -0.03788767f, 0.01076473f, 
    -0.06131109f, 0.00377613f, 0.03623496f, -0.04282779f, 0.03511621f, 0.07124560f, -0.02412184f, -0.02264529f, 
    -0.06288277f, -0.06145045f, 0.06253052f, 0.03303301f, 0.05457816f, 0.00978542f, -0.03787620f, -0.01848468f, 
    -0.01075430f, 0.04995192f, 0.00428737f, -0.05060029f, 0.05628224f, 0.06349365f, 0.04877756f, 0.05243880f, 
    -0.02282694f, 0.03694723f, 0.06352467f, 0.02698337f, -0.07189304f, 0.00741576f, -0.02915580f, -0.05131782f, 
    -0.04354312f, 0.03085412f, 0.06360943f, 0.01837754f, -0.01758237f, 0.03154637f, -0.06126815f, 0.05621454f, 
    0.06530289f, -0.05312413f, -0.01004988f, -0.03923443f, -0.03845646f, -0.04661013f, -0.00874265f, 0.01571050f, 
    -0.04382082f, -0.06348092f, 0.05198815f, -0.04898060f, 0.07091630f, -0.03789525f, -0.00773562f, -0.04878256f, 
    0.01854319f, -0.05296968f, 0.04497104f, -0.04740006f, 0.03702702f, 0.03362526f, -0.02212025f, -0.07183729f, 
    0.01663791f, -0.06040682f, -0.00269168f, -0.06959991f, -0.03004664f, 0.00052167f, -0.00269853f, -0.06403682f, 
    -0.03151302f, 0.04138543f, -0.00890884f, 0.04777367f, -0.03490772f, -0.05074596f, 0.01253500f, -0.02117352f, 
    -0.04002183f, -0.02910213f, -0.06261629f, -0.02940552f, 0.06572758f, 0.06636304f, -0.02716975f, -0.03951106f, 
    -0.03723889f, -0.00494425f, 0.05247071f, 0.00710260f, -0.00128689f, -0.05563055f, -0.02546777f, 0.06330726f, 
    0.06083855f, 0.05496312f, 0.01510274f, -0.03559404f, 0.05978184f, -0.00099239f, 0.03940808f, -0.05730534f, 
    0.05440563f, -0.03563401f, -0.02280335f, 0.05666085f, -0.02450013f, 0.03518124f, 0.02050373f, 0.02465537f, 
    -0.05205620f, -0.03332916f, -0.03479217f, -0.01219136f, -0.06973781f, 0.04145034f, -0.07175013f, -0.06531309f, 
    -0.04822588f, -0.06018360f, -0.06879693f, -0.05900221f, -0.06035964f, -0.06774509f, -0.06001325f, -0.03614354f, 
    0.03044744f, -0.00115694f, -0.01784499f, -0.04642722f, -0.04483321f, 0.07045875f, -0.05692390f, -0.01902617f, 
    -0.04148510f, 0.05837169f, -0.02283292f, 0.06293672f, 0.06074343f, -0.05366134f, 0.06580237f, 0.00593962f, 
    -0.01205099f, 0.05815684f, -0.06004705f, 0.05030411f, 0.01214406f, 0.02087128f, 0.06495063f, -0.03638482f, 
    -0.06282826f, -0.06167118f, 0.00551672f, 0.06466912f, -0.04535134f, -0.06910378f, -0.02525104f, -0.07117638f, 
    0.06644958f, -0.06798075f, 0.01948566f, 0.03963413f, -0.00367249f, 0.03318270f, -0.06815983f, -0.06091987f, 
    0.19517253f, 0.09723946f, -0.11608506f, -0.41053331f, -0.14170304f, 0.07513528f, 0.07625521f, 0.05540694f, 
    0.17643590f, 0.09434893f, 0.01702878f, 0.19608212f, -0.11589270f, -0.22873145f, 0.21995874f, -0.28747195f, 
    -0.11473701f, -0.01700305f, -0.00588390f, -0.14094250f, 0.07435404f, 0.06752969f, 0.02144997f, -0.07066599f, 
    0.24674001f, -0.01500315f, -0.15280840f, 0.10811928f, 0.06770620f, -0.08752294f, -0.03320846f, 0.14666598f, 
    0.09139160f, 0.03283391f, 0.00525317f, -0.03984427f, 0.15594493f, -0.11291683f, 0.07676993f, 0.06357650f, 
    0.01872002f, 0.08963626f, -0.09661900f, -0.08894902f, 0.06054733f, 0.01167770f, -0.00260527f, 0.05448855f, 
    0.26668331f, 0.09500661f, -0.14573786f, -0.06658461f, 0.06780226f, 0.04096198f, -0.16337644f, 0.11484218f, 
    -0.11031498f, -0.10065962f, -0.03427958f, 0.32640675f, -0.06626184f, -0.07917926f, 0.27853289f, 0.00364848f, 
    0.04541187f, 0.02220982f, 0.20923685f, 0.10211477f, -0.05614921f, 0.00871134f, 0.02441622f, -0.06056544f, 
    0.20618828f, -0.00734733f, 0.04183738f, 0.00128534f, -0.08150601f, -0.03975824f, 0.04380030f, -0.16222684f, 
    -0.03729589f, 0.16943242f, 0.10242804f, 0.20428066f, 0.33802181f, 0.18170217f, -0.01711840f, 0.04229762f, 
    0.14124595f, -0.00686188f, 0.06575211f, 0.04366899f, -0.16078907f, 0.00620826f, -0.13826154f, -0.12692901f, 
    0.05589056f, -0.02096537f, -0.30433393f, 0.08598302f, -0.07785487f, -0.09183774f, -0.23218384f, -0.12860361f, 
    0.00263959f, 0.03316751f, -0.06087853f, -0.01121932f, 0.35547137f, 0.38502583f, -0.06179805f, -0.02104296f, 
    -0.02427443f, 0.02747027f, 0.12982115f, 0.13596922f, 0.11059137f, 0.03531412f, 0.21930614f, 0.17838617f, 
    0.02665439f, 0.25077340f, -0.06274866f, -0.29639193f, 0.06791858f, -0.10340808f, 0.04291397f, -0.15212534f, 
    0.13244645f, 0.10359717f, 0.07841684f, 0.03399309f, 0.19799638f, -0.13260178f, 0.24527808f, -0.15802355f, 
    0.00328799f, -0.02993766f, -0.06971082f, 0.11898667f, -0.02373426f, -0.02598698f, -0.03060834f, -0.09633651f, 
    0.00335974f, -0.32970589f, -0.02068831f, -0.01216822f, -0.20970145f, 0.11147384f, 0.12912028f, 0.07266823f, 
    -0.10103025f, -0.23955210f, 0.07261264f, -0.12897462f, 0.15104881f, -0.01273635f, -0.00539308f, 0.21397111f, 
    0.11749816f, -0.12680610f, -0.12993188f, -0.20939903f, -0.04640747f, 0.17000304f, 0.10499198f, 0.02655910f, 
    0.08004535f, -0.10044845f, 0.24061456f, 0.37934089f, 0.03952893f, -0.01719967f, 0.00253963f, -0.04221830f, 
    0.06159482f, 0.00688136f, -0.02053840f, -0.10560489f, -0.10352669f, 0.06036285f, -0.12074242f, -0.14282493f, 
    0.01437631f, -0.03881560f, 0.06403317f, -0.11651682f, -0.11539222f, 0.07847495f, -0.16014397f, -0.09617951f, 
    0.18717656f, 0.11751281f, -0.02528037f, -0.16295746f, 0.10263484f, -0.11165366f, 0.01253857f, 0.07958313f, 
    0.11921456f, 0.14877526f, 0.03214538f, 0.07040875f, -0.07435361f, 0.08495954f, 0.08811118f, -0.01791362f, 
    -0.07789526f, -0.03361571f, -0.03070031f, -0.10019679f, -0.07496548f, 0.10893913f, -0.04406789f, -0.15589827f, 
    0.20662330f, 0.17910765f, -0.09978648f, 0.15885802f, -0.04295148f, 0.05462637f, -0.07103666f, -0.03884363f, 
    0.05702894f, 0.02108149f, -0.00981838f, -0.11081816f, 0.48197430f, -0.20448531f, 0.06186058f, 0.02615057f, 
    -0.00593424f, 0.06898077f, 0.13254951f, -0.07305021f, 0.07665890f, -0.04288296f, 0.06319404f, 0.10459462f, 
    0.23378895f, -0.19273798f, -0.03961799f, 0.12474965f, -0.03806885f, -0.00596262f, -0.13889880f, 0.00630542f, 
    0.06800276f, -0.00139415f, 0.01484941f, 0.14050463f, 0.06622521f, -0.03012836f, 0.23048256f, 0.07546239f, 
    -0.00834687f, 0.05266352f, 0.03227937f, 0.14378062f, 0.10131220f, -0.00971969f, 0.06278446f, 0.05638929f, 
    -0.25127941f, -0.13784452f, 0.01822458f, 0.03135477f, -0.03353684f, 0.12060187f, -0.05906809f, -0.05658887f, 
    0.04120893f, 0.07873768f, 0.04945036f, 0.26047534f, 0.42260063f, -0.08718158f, 0.16272089f, 0.14392652f, 
    -0.05919025f, -0.02935440f, -0.01018185f, 0.12847145f, -0.14027424f, -0.03178079f, 0.07716951f, -0.00987128f, 
    0.10358161f, 0.07835596f, -0.14829206f, 0.16089727f, -0.04339164f, -0.02783226f, -0.09811391f, -0.02220654f, 
    0.06326791f, -0.08349139f, -0.02588023f, -0.00289108f, 0.69586480f, -0.15041088f, 0.15133668f, 0.14922087f, 
    -0.11685950f, 0.08988686f, -0.05952340f, -0.01633623f, -0.01415512f, -0.03326427f, -0.04410731f, 0.16223097f, 
    0.22376680f, 0.08797959f, -0.24759248f, -0.42493448f, 0.09219968f, -0.02383900f, 0.08902981f, -0.03669382f, 
    -0.00338032f, -0.02856821f, -0.01107119f, 0.02955480f, -0.03938278f, -0.07562377f, 0.29538763f, -0.10527457f, 
    0.01578558f, -0.03950354f, -0.01785024f, 0.04001097f, -0.03053294f, -0.01985844f, -0.08148856f, 0.09585582f, 
    -0.09812982f, 0.01808770f, 0.21311525f, -0.00388949f, -0.06772046f, -0.02050544f, 0.19519649f, 0.19331136f, 
    0.05860966f, -0.15498012f, 0.11444028f, 0.00732200f, -0.28340453f, -0.11421973f, 0.06901696f, -0.03034063f, 
    0.04055813f, 0.02262795f, 0.00387669f, -0.05255036f, 0.03428742f, -0.00595729f, 0.07411520f, -0.00300604f, 
    -0.13059057f, 0.14814231f, 0.02861225f, -0.03039847f, 0.02161049f, 0.16591957f, 0.04580556f, -0.05542507f, 
    -0.06613724f, 0.11024307f, -0.03068087f, -0.04888417f, 0.13391994f, -0.02112995f, -0.23595574f, -0.15058446f, 
    0.04361862f, 0.18493627f, 0.02424259f, -0.00933467f, 0.03504570f, 0.02407684f, -0.12119834f, -0.11347527f, 
    0.06129776f, -0.01927423f, -0.01760471f, 0.04499047f, -0.05263124f, 0.02629010f, -0.02584777f, 0.00906112f, 
    0.00152416f, -0.03445143f, 0.04302257f, -0.04403637f, 0.00703494f, -0.05805415f, 0.00267120f, 0.04914242f, 
    -0.06695957f, 0.06267410f, -0.06235271f, 0.00874130f, -0.02996818f, -0.06725528f, -0.01318241f, -0.01013364f, 
    0.02297651f, -0.04816370f, 0.02626769f, 0.02624089f, 0.00186293f, -0.04314734f, -0.03948002f, 0.00273353f, 
    0.01641977f, 0.02861525f, -0.04966513f, 0.00047467f, -0.02679144f, -0.00836165f, -0.05452939f, -0.04155260f, 
    0.02415826f, -0.00358863f, 0.00317796f, -0.02159519f, -0.04078660f, -0.02182531f, 0.03583173f, -0.06875286f, 
    0.03612258f, -0.02574877f, -0.06126929f, 0.02598220f, -0.05807764f, 0.05071469f, -0.01090834f, -0.03807350f, 
    -0.03989147f, 0.03290217f, -0.06339684f, -0.00717966f, 0.05480058f, -0.02491919f, 0.01221960f, 0.02195917f, 
    -0.01769070f, -0.04030164f, 0.02485426f, -0.00700281f, -0.07678960f, 0.03803755f, -0.06930760f, 0.00709951f, 
    -0.07408083f, 0.01277237f, -0.06531890f, -0.02378430f, -0.03069577f, -0.07681021f, -0.07367771f, -0.07295599f, 
    -0.05018902f, -0.03784595f, -0.02393838f, 0.02040947f, 0.05725171f, 0.05404925f, -0.07417305f, -0.01266384f, 
    0.06301431f, 0.01694811f, 0.01992285f, 0.05676935f, 0.03662533f, 0.03714994f, 0.05063063f, 0.00117352f, 
    -0.06709496f, -0.06921590f, 0.05656826f, 0.04563189f, -0.02190910f, -0.04309859f, -0.00290160f, -0.06480929f, 
    0.03401266f, -0.04659883f, 0.04861798f, 0.00521487f, 0.05890336f, -0.04342029f, 0.01716444f, -0.01211901f, 
    -0.02941069f, 0.04754279f, -0.01827290f, -0.04579328f, -0.03620412f, 0.04692507f, -0.02090317f, -0.03196325f, 
    -0.04873943f, 0.03430776f, 0.05214701f, -0.06735709f, -0.04882007f, -0.00643557f, 0.02784853f, 0.05719620f, 
    0.03949590f, 0.05482332f, 0.04239925f, 0.01402474f, -0.02437334f, 0.01184018f, 0.05133114f, -0.07379364f, 
    -0.07489392f, 0.01697992f, -0.06684525f, -0.07048736f, 0.02482559f, -0.05457452f, 0.04906477f, -0.01155036f, 
    -0.06778641f, 0.06246273f, -0.06156582f, 0.01745459f, -0.07513347f, 0.02148085f, -0.01480960f, -0.02320362f, 
    0.01419491f, 0.03095417f, 0.02350967f, -0.07522987f, 0.04150156f, 0.01482627f, -0.05385592f, -0.05467939f, 
    -0.03815958f, -0.02890569f, -0.07154733f, -0.04040956f, -0.01208131f, -0.05680351f, -0.01825322f, 0.03530452f, 
    -0.05518041f, -0.02192312f, 0.05859328f, -0.05079542f, -0.01762528f, 0.05156893f, -0.01105616f, -0.02089066f, 
    -0.02010605f, 0.02854090f, -0.06042483f, -0.04091065f, -0.01435161f, 0.02356758f, 0.00120243f, 0.04246499f, 
    0.00385683f, -0.05945897f, -0.03554182f, 0.06484232f, 0.06445538f, -0.04291011f, -0.04241699f, 0.03351792f, 
    0.12621382f, 0.10752392f, 0.16055579f, -0.06914144f, 0.05162387f, -0.11895470f, -0.04084753f, -0.10249636f, 
    0.00754574f, -0.01288060f, 0.19399805f, 0.02123656f, 0.04313252f, 0.28063479f, 0.15723610f, -0.23293874f, 
    0.04839908f, -0.14757848f, 0.03153750f, 0.04796857f, -0.07733008f, -0.00924538f, -0.01031409f, -0.11706837f, 
    0.01461608f, -0.12033751f, -0.05794182f, 0.04569123f, -0.20126875f, 0.03061283f, -0.05477076f, -0.02431752f, 
    -0.05436014f, 0.10168623f, -0.07140613f, -0.06058085f, 0.39367670f, 0.00891861f, 0.00602049f, 0.02657416f, 
    -0.02410440f, -0.01976402f, -0.04337694f, 0.03804940f, 0.11515243f, 0.06657135f, 0.04891977f, 0.09571540f, 
    0.35838389f, -0.17041937f, -0.01092536f, -0.09800252f, -0.02150661f, 0.02573380f, -0.07734636f, -0.11064699f, 
    0.00015169f, 0.13834628f, 0.07111499f, 0.04151271f, 0.34197202f, 0.15133567f, 0.05809850f, -0.00163422f, 
    0.01399497f, -0.10447092f, -0.10644250f, 0.14279163f, 0.03701473f, 0.05276761f, 0.01991119f, 0.02187868f, 
    -0.07023679f, 0.03942435f, -0.24492359f, -0.03520073f, 0.05974381f, 0.06766325f, 0.02229331f, 0.00120584f, 
    -0.10262581f, -0.13326876f, 0.07347600f, 0.05716207f, 0.34435371f, -0.20254435f, 0.14663947f, 0.19039455f, 
    -0.03947863f, -0.02323940f, -0.08163676f, 0.08745623f, -0.09122190f, -0.16256317f, 0.10603771f, -0.01681473f, 
    -0.12158646f, 0.02462943f, -0.01380678f, 0.15047228f, -0.00037870f, -0.02978317f, -0.04696805f, -0.14924300f, 
    0.04326596f, -0.11374164f, -0.02041526f, -0.05898605f, 0.37430313f, 0.04867939f, 0.12534247f, 0.30050269f, 
    -0.02371321f, 0.04284776f, 0.06785733f, 0.02925224f, -0.01553914f, 0.18623121f, -0.07466512f, 0.10433447f, 
    -0.00245553f, 0.04438081f, -0.14487892f, -0.17021944f, 0.19233571f, 0.01918395f, 0.05153956f, 0.01798497f, 
    0.01675810f, -0.09470068f, -0.02878767f, 0.01966287f, -0.00505948f, -0.12122591f, 0.24324426f, 0.03782983f, 
    0.15853602f, 0.01405756f, -0.03487498f, 0.00528059f, 0.00878780f, 0.07335971f, -0.06879292f, 0.06501131f, 
    0.03442019f, 0.19265018f, 0.20658611f, -0.17501649f, -0.01400350f, -0.15129802f, 0.11576007f, 0.10391852f, 
    0.03181047f, -0.00656381f, 0.08170465f, 0.10673132f, -0.15049970f, -0.24366046f, -0.05040251f, 0.01966909f, 
    0.04489582f, 0.01623081f, -0.04387114f, -0.02376115f, -0.11389334f, -0.04941685f, 0.05130583f, -0.10711236f, 
    -0.25294110f, 0.07245275f, 0.01967135f, 0.06092329f, -0.04975908f, -0.03420162f, -0.07574909f, -0.01119190f, 
    0.00763398f, 0.15818869f, 0.03283187f, -0.08286466f, 0.21535476f, -0.06826533f, -0.29348084f, -0.05240534f, 
    0.01936397f, 0.04575846f, 0.02685878f, -0.08223636f, 0.00396356f, 0.04725677f, -0.09482364f, -0.06032719f, 
    -0.36096001f, -0.17966409f, 0.02812490f, -0.05695271f, 0.02383710f, 0.01857577f, 0.00077295f, -0.02568740f, 
    0.06444726f, -0.13495158f, 0.13657926f, -0.13065214f, -0.03927674f, 0.15712203f, -0.03177496f, 0.01797861f, 
    0.25196993f, -0.07016445f, -0.06253167f, -0.03712108f, -0.01775306f, 0.06307885f, 0.08499765f, 0.07062877f, 
    -0.13481453f, 0.15601818f, -0.05858346f, -0.17980210f, 0.09612443f, -0.02171342f, 0.00624767f, 0.01102811f, 
    -0.10291163f, -0.05764331f, -0.00768126f, 0.15437029f, 0.04815630f, 0.21978948f, -0.05919525f, 0.24959747f, 
    0.00909820f, 0.06481843f, -0.08514646f, -0.00641371f, 0.01725869f, 0.12793350f, 0.05514228f, -0.05172093f, 
    0.25615156f, -0.27271718f, -0.04295298f, -0.03243538f, -0.01033740f, -0.05229016f, 0.08239067f, 0.09899168f, 
    -0.01249451f, 0.01852050f, 0.07120320f, -0.09565097f, -0.01941162f, 0.13649860f, -0.11161899f, -0.03730185f, 
    0.10438821f, -0.06807235f, -0.04369783f, 0.03468488f, 0.02733492f, -0.00210133f, -0.07934729f, -0.06388715f, 
    0.04241535f, 0.26700541f, -0.04183460f, 0.07419987f, 0.19503647f, 0.07629436f, 0.05594948f, 0.07491753f, 
    0.04526577f, -0.08645620f, 0.06303920f, -0.15420060f, -0.16558070f, -0.06227617f, -0.06033010f, 0.00025854f, 
    0.05527550f, 0.17022729f, 0.17763489f, 0.08083863f, 0.03609017f, 0.07900333f, 0.04384677f, 0.04226537f, 
    -0.22110407f, 0.11621637f, -0.04497317f, -0.40541556f, 0.12564699f, 0.09731992f, -0.10149342f, -0.00048487f, 
    -0.09907141f, 0.13798203f, 0.02293387f, 0.08855302f, -0.17207468f, 0.04732816f, -0.00648228f, -0.00516707f, 
    0.15581229f, 0.08529805f, -0.06250030f, 0.10611818f, 0.08824991f, 0.14974655f, 0.07294914f, -0.18603504f, 
    -0.34034136f, -0.05009376f, 0.05227861f, 0.26311064f, -0.06784952f, 0.00840154f, 0.03244356f, 0.00726548f, 
    -0.02359001f, -0.05108428f, 0.12303833f, -0.00432533f, 0.13243382f, 0.08655085f, -0.21560743f, 0.20121625f, 
    -0.00075974f, 0.14053665f, 0.16127495f, -0.20685913f, 0.08193602f, -0.06354494f, -0.03985427f, -0.15069801f, 
    0.01383718f, 0.01465253f, 0.13419771f, 0.07006775f, 0.23894417f, -0.11305588f, -0.15774527f, -0.06208379f, 
    0.05464952f, 0.04949404f, -0.01713800f, 0.08826528f, 0.13739932f, 0.01817380f, -0.15840642f, -0.29774103f, 
    0.08236428f, -0.07206167f, -0.09711236f, 0.07342829f, -0.08863886f, 0.02791455f, -0.02095918f, 0.08714029f, 
    0.02586448f, 0.08750226f, -0.11347897f, 0.11581271f, -0.02737064f, -0.18332000f, -0.08928204f, 0.07281725f, 
    0.10263301f, 0.10840686f, 0.15316211f, 0.07271294f, 0.23508079f, -0.03470378f, -0.07900494f, 0.01446553f, 
    -0.05942925f, 0.01511639f, 0.10074474f, 0.00041587f, -0.00028867f, 0.00367440f, 0.15294087f, 0.00365818f, 
    0.04517402f, -0.04605522f, 0.05288171f, 0.04657102f, 0.02112152f, -0.02538127f, 0.03945341f, -0.05623021f, 
    0.01309367f, -0.07338915f, -0.05331552f, 0.03072758f, 0.02555624f, -0.04485306f, -0.06722527f, 0.00985019f, 
    -0.00243974f, 0.00543496f, -0.04078509f, 0.00487079f, -0.02925245f, 0.00627596f, -0.08158515f, 0.03772350f, 
    0.00894171f, 0.04012236f, 0.05713013f, -0.04926920f, 0.03472890f, -0.05570742f, 0.05643916f, 0.00114646f, 
    0.00713801f, -0.04940684f, -0.06191313f, -0.05398685f, 0.00490741f, -0.07675442f, 0.00717531f, 0.04476245f, 
    -0.01803089f, 0.02448652f, -0.04036442f, -0.04637579f, 0.03137638f, -0.00913902f, -0.03383633f, 0.01038639f, 
    -0.01762963f, -0.06963425f, 0.01196229f, -0.05171051f, -0.03172717f, -0.00141202f, -0.02524008f, -0.00222075f, 
    -0.02924887f, 0.04086978f, -0.06459405f, -0.08100038f, 0.04696157f, -0.02955097f, -0.00906459f, 0.01515427f, 
    0.00319595f, -0.01238859f, 0.04492267f, -0.01541770f, -0.02670086f, -0.02075404f, 0.05301539f, -0.03109068f, 
    -0.08275820f, -0.06099661f, -0.07606711f, 0.03760456f, -0.01353766f, -0.00879720f, 0.01531199f, 0.01612981f, 
    0.00179667f, 0.01592793f, -0.07917208f, -0.03577730f, -0.05074912f, 0.03345622f, -0.06477288f, 0.03443694f, 
    -0.04461369f, -0.02473338f, -0.05280280f, 0.05366033f, 0.01635951f, -0.04289076f, -0.03181228f, 0.01007028f, 
    0.02669281f, 0.05846398f, -0.06440098f, 0.02781297f, -0.03446943f, 0.02483699f, -0.05606615f, 0.00635022f, 
    0.05171976f, -0.03702273f, 0.05073702f, -0.03084372f, -0.01155428f, -0.06155127f, 0.00625210f, -0.04408652f, 
    -0.06486101f, -0.04500657f, 0.04228404f, 0.02875256f, -0.07723886f, -0.00607732f, 0.04783862f, 0.00355311f, 
    0.05788723f, 0.05219873f, -0.02848518f, 0.00086113f, 0.01718555f, -0.03340982f, -0.02384541f, 0.05439153f, 
    0.01853578f, -0.05737568f, -0.04096117f, 0.03126760f, 0.01058919f, -0.01110812f, -0.00667713f, 0.02947403f, 
    -0.01465823f, -0.07359814f, 0.00404602f, -0.06138650f, -0.05889649f, 0.00855760f, 0.03839690f, 0.04370473f, 
    -0.04126410f, 0.02094549f, 0.03733200f, -0.07143036f, 0.04084005f, -0.03227352f, -0.01172215f, 0.03563490f, 
    0.02025999f, -0.03703143f, 0.00871092f, 0.03063423f, -0.00111347f, -0.05387824f, -0.06475366f, -0.02754480f, 
    0.03096255f, 0.01307549f, -0.02875735f, -0.03425560f, -0.03385121f, 0.04304719f, 0.01960929f, -0.04556472f, 
    0.03151866f, -0.04684940f, 0.04780181f, 0.02026191f, -0.04474920f, 0.00840572f, -0.05990884f, -0.01366424f, 
    -0.04789417f, 0.03264857f, 0.01625999f, -0.02310730f, 0.06134499f, -0.01440005f, -0.05264740f, -0.00150239f, 
    -0.03125222f, 0.03843036f, -0.06241109f, -0.01286918f, 0.03247827f, -0.01078878f, 0.06539284f, -0.04663041f, 
    -0.01586063f, -0.01506919f, 0.05312848f, -0.02929894f, -0.01586195f, -0.00549226f, 0.02027264f, -0.04431833f, 
    0.00603568f, -0.06443325f, 0.02342608f, -0.03114489f, -0.00127443f, -0.06593512f, -0.05151007f, -0.02071217f, 
    0.06224986f, -0.04108946f, 0.00224230f, 0.00982639f, 0.03103577f, 0.06232784f, -0.03883800f, 0.04770168f, 
    -0.05707155f, -0.08030022f, -0.01462907f, 0.04542221f, -0.08066510f, 0.03355746f, 0.04502657f, -0.07145549f, 
    -0.03942373f, 0.01776447f, -0.04751286f, -0.00148711f, 0.00149468f, -0.04467492f, 0.01623650f, 0.05583897f, 
    -0.06951939f, -0.05838159f, -0.07115681f, -0.00558777f, -0.06421390f, -0.06994494f, -0.05958448f, 0.01434229f, 
    -0.05409066f, 0.05104824f, 0.03944421f, 0.00847341f, 0.00028863f, 0.05142500f, 0.05111137f, -0.04473105f, 
    -0.06086069f, -0.01696324f, 0.05410268f, 0.01336823f, 0.06434371f, 0.01280047f, 0.02624013f, 0.03011872f, 
    -0.07714919f, 0.03156152f, -0.06251327f, 0.02534395f, -0.03600257f, -0.05065920f, -0.03561383f, 0.04966783f, 
    -0.03398250f, -0.02128245f, -0.00219778f, 0.00378644f, -0.06445526f, 0.02696653f, 0.01851138f, 0.05662203f, 
    -0.06041318f, 0.04102012f, -0.04944516f, 0.01122331f, -0.03167411f, -0.02345741f, 0.01518859f, -0.07332299f, 
    0.06573552f, 0.01617247f, 0.00493141f, 0.00310545f, -0.06280367f, 0.00916256f, 0.05585299f, 0.00679707f, 
    0.00021150f, 0.03580889f, 0.02977223f, -0.05704835f, 0.02250827f, -0.05280569f, 0.00052469f, -0.06632975f, 
    -0.06516066f, -0.00032344f, 0.01834201f, -0.01447724f, -0.01129645f, -0.07521101f, -0.06816176f, 0.02622531f, 
    -0.03009244f, -0.01810883f, 0.03436716f, -0.00913764f, 0.01233166f, -0.06303992f, -0.05612807f, -0.00229747f, 
    0.02268941f, 0.04978911f, 0.00425744f, 0.06237285f, 0.00953972f, 0.04340984f, -0.04213339f, -0.04421919f, 
    -0.02265737f, -0.06082715f, -0.06988163f, -0.06072829f, -0.03832521f, 0.05640838f, 0.04279460f, 0.06333189f, 
    0.01201129f, -0.04074502f, 0.05368432f, -0.07074095f, 0.04394211f, -0.00659105f, 0.05545490f, 0.01917114f, 
    -0.07439087f, -0.07148262f, -0.06671075f, 0.04776660f, 0.06163422f, -0.02139021f, 0.00156360f, -0.04239509f, 
    0.02333304f, -0.01510404f, -0.01727827f, 0.00721449f, 0.03974723f, 0.05714006f, -0.06380370f, 0.05674682f, 
    -0.06360333f, -0.04929137f, 0.01692310f, 0.03916988f, 0.05141697f, -0.04883171f, 0.06159441f, -0.05852897f, 
    -0.02873913f, -0.01224549f, 0.03599078f, -0.00059726f, -0.05461362f, 0.00091244f, 0.00869759f, 0.00063187f, 
    -0.05356241f, -0.07363261f, 0.01845073f, 0.02248573f, -0.06541178f, -0.00556395f, -0.05289978f, -0.04783884f, 
    -0.03987613f, -0.06573799f, -0.02911126f, -0.00847957f, 0.02175993f, 0.02016999f, -0.01532981f, 0.02885783f, 
    0.22653221f, 0.12422682f, -0.03674687f, 0.15587707f, -0.03696269f, -0.04364366f, 0.07011236f, 0.02389861f, 
    -0.09393551f, 0.04756149f, 0.10220620f, 0.08544963f, 0.03009554f, 0.11024875f, 0.15772673f, -0.11342338f, 
    -0.10246040f, 0.00391688f, 0.08893388f, 0.01336813f, -0.02813488f, 0.02567992f, -0.15670890f, -0.13533674f, 
    0.08026703f, -0.10274133f, -0.09213906f, 0.08465324f, -0.11180516f, 0.04078324f, -0.15582082f, -0.04105260f, 
    0.05239281f, -0.04466903f, 0.01641329f, -0.07933152f, 0.09748942f, -0.11716820f, -0.09361298f, -0.08451604f, 
    -0.08854786f, 0.03070186f, 0.05464187f, -0.06005318f, 0.04093340f, -0.09070114f, 0.02096145f, 0.00210156f, 
    -0.01131581f, -0.04929094f, 0.17691961f, 0.00409266f, -0.05309477f, 0.02614166f, -0.03110736f, -0.13264684f, 
    0.00624008f, -0.15375264f, 0.17801894f, 0.10361072f, -0.08990791f, 0.08334066f, 0.20113765f, 0.08959812f, 
    0.06962286f, 0.00804253f, 0.01497926f, -0.03488399f, 0.03883171f, 0.03796589f, 0.04655781f, -0.04623307f, 
    0.22993164f, 0.08079004f, 0.12149191f, 0.04911273f, -0.09373301f, -0.06805421f, -0.07875068f, -0.03608307f, 
    -0.09462667f, -0.00866790f, -0.05453786f, 0.10075163f, 0.28623000f, -0.07392939f, -0.03614032f, 0.17780574f, 
    0.00802570f, 0.06686218f, 0.03710879f, -0.00250573f, 0.03282060f, -0.07270043f, -0.00284717f, -0.01417991f, 
    0.27346548f, 0.21472017f, -0.04002310f, 0.27492401f, 0.04614753f, 0.16623181f, 0.05691958f, 0.07468414f, 
    0.05250389f, 0.08203992f, -0.00904126f, -0.01451837f, 0.06544571f, 0.12133525f, -0.04480303f, -0.15576768f, 
    -0.10757463f, 0.04648763f, 0.02963964f, -0.01929974f, -0.01519329f, -0.06806809f, 0.13909216f, -0.00072536f, 
    -0.23620121f, -0.17853543f, -0.12805054f, -0.23248035f, -0.06495471f, -0.02481917f, 0.19959217f, -0.10523846f, 
    0.03301867f, 0.04772387f, -0.06837855f, 0.09072917f, -0.16152139f, -0.03597007f, 0.17206445f, -0.10477842f, 
    0.09150138f, 0.03466340f, -0.05380108f, 0.04314578f, 0.05455827f, 0.11675367f, 0.00564941f, -0.01909896f, 
    0.19986112f, 0.06412062f, 0.13224451f, 0.01383784f, -0.10279299f, -0.05034883f, 0.18108265f, 0.00444008f, 
    -0.07542238f, -0.11064479f, 0.15048003f, -0.04241474f, 0.38460076f, 0.30742827f, 0.29621539f, 0.12008362f, 
    -0.06419634f, -0.01102225f, 0.14642233f, 0.11645710f, 0.08169653f, -0.00293373f, -0.12127796f, -0.06479689f, 
    -0.01085070f, -0.16589989f, -0.01558313f, 0.00770564f, -0.05247316f, 0.07325873f, 0.04660068f, -0.02448595f, 
    -0.02217019f, -0.09795172f, -0.00985159f, 0.00076841f, 0.06393018f, -0.12122694f, -0.02338163f, 0.05607546f, 
    0.04700358f, -0.08110582f, 0.03247762f, -0.13055944f, -0.04763598f, -0.00891074f, -0.15817277f, -0.14708829f, 
    0.12728353f, 0.13063520f, -0.07371273f, 0.12546402f, 0.05711515f, 0.06303786f, 0.03892786f, -0.01461449f, 
    -0.07164843f, 0.00262232f, -0.06684469f, -0.00473669f, 0.26288670f, -0.16693631f, -0.07199793f, 0.22696096f, 
    -0.09112211f, 0.07967920f, -0.01155713f, 0.01871303f, 0.07852686f, -0.18370928f, 0.02071457f, 0.13795514f, 
    -0.16082971f, 0.09868313f, 0.09379298f, -0.27033487f, 0.10864031f, -0.09114568f, 0.05443872f, 0.14305778f, 
    -0.00135959f, 0.01849661f, 0.05302916f, 0.13898668f, -0.40444046f, 0.09253293f, 0.16706105f, -0.27010152f, 
    -0.08269265f, 0.02689922f, -0.18479908f, 0.03762022f, -0.04796082f, 0.01542655f, -0.04604404f, 0.00679411f, 
    -0.21048173f, 0.24661906f, -0.05168714f, 0.13180859f, -0.00407418f, -0.00239362f, 0.14235285f, 0.08130299f, 
    -0.04175607f, -0.13922939f, -0.02543239f, -0.02444667f, -0.22781287f, 0.13186392f, 0.01963594f, 0.13033809f, 
    0.00057715f, 0.03009677f, -0.05338341f, -0.10426747f, -0.08752122f, 0.13912296f, -0.15288265f, -0.02001433f, 
    0.25241148f, 0.04694651f, -0.04254723f, 0.00490105f, 0.11049082f, -0.06640907f, -0.01595095f, 0.00481992f, 
    0.11949392f, 0.04591923f, -0.00036103f, -0.02486927f, -0.05601033f, 0.19034044f, 0.02038784f, -0.06420131f, 
    -0.07928096f, -0.00363068f, 0.00985268f, -0.06855505f, 0.10311146f, 0.14676031f, -0.07921602f, -0.16226214f, 
    0.25327656f, -0.05948608f, 0.09288315f, -0.06862753f, 0.00825082f, -0.01429721f, 0.03132718f, -0.02414044f, 
    -0.03589512f, 0.09280293f, 0.15454510f, -0.03499452f, -0.63088781f, -0.03218808f, 0.04464808f, -0.14096707f, 
    0.12184262f, -0.07116339f, 0.05297754f, 0.00052676f, -0.05635478f, -0.12929666f, 0.12365540f, 0.08670178f, 
    0.14213878f, 0.21045694f, 0.16868539f, 0.19330876f, -0.01258014f, 0.00025291f, -0.07888518f, 0.07156665f, 
    0.07780016f, 0.15015884f, 0.04324532f, 0.04116429f, 0.02616237f, 0.02645754f, 0.05050616f, 0.16585161f, 
    0.02649388f, 0.06028910f, -0.06803378f, 0.16099100f, 0.02410627f, -0.11016205f, 0.06021484f, -0.02480745f, 
    0.12551261f, 0.11346927f, -0.14252622f, 0.04174258f, 0.10548633f, -0.00616167f, -0.17346096f, -0.14706540f, 
    0.11401049f, 0.08268201f, -0.02332709f, -0.08154527f, 0.26995960f, -0.09146802f, -0.08541188f, 0.36547217f, 
    -0.03579520f, 0.11195240f, -0.01802365f, 0.04798055f, 0.03842575f, 0.01002642f, -0.07861089f, 0.01836483f, 
    -0.09776223f, -0.07915666f, -0.16181593f, 0.24158895f, 0.09478645f, -0.05157154f, -0.00748888f, -0.01433228f, 
    0.07447015f, -0.06767450f, 0.01418852f, 0.02845476f, -0.25791666f, 0.06000387f, 0.21361235f, 0.06961581f, 
    0.00801670f, -0.09111533f, 0.01433125f, -0.04908134f, -0.03503212f, -0.07121446f, 0.03931041f, 0.09437564f, 
    -0.28684381f, -0.09431881f, 0.22708787f, -0.07814950f, 0.01533917f, 0.10054456f, -0.00698053f, -0.04695679f, 
    0.02200990f, 0.02248046f, -0.03829270f, -0.09967580f, -0.04349069f, -0.15766145f, 0.16337891f, -0.16939341f, 
    0.02733887f, -0.12264235f, 0.05061203f, -0.08481366f, 0.00509383f, -0.04987360f, 0.02852211f, -0.00320024f, 
    0.06629936f, 0.10533066f, -0.12701274f, 0.13320991f, -0.06720440f, 0.13601410f, -0.04086353f, 0.02031980f, 
    0.01272776f, -0.05033576f, -0.02921236f, -0.05642756f, -0.03688011f, 0.12441053f, -0.31892955f, 0.09706374f, 
    -0.12871934f, 0.07918175f, -0.00032460f, 0.07608055f, 0.08514529f, -0.00182843f, 0.05356181f, 0.03025823f, 
    0.30290562f, -0.24226062f, -0.16460890f, -0.05788999f, 0.03013946f, 0.05235103f, 0.07151320f, 0.11735053f, 
    -0.00440435f, 0.06440631f, 0.07280655f, 0.03599742f, 0.21487305f, -0.27477658f, 0.02652571f, -0.11347244f, 
    0.02141591f, -0.15984796f, 0.08650932f, 0.18493477f, 0.10566048f, -0.17433429f, -0.00556425f, 0.00641506f, 
    -0.10432404f, 0.06183462f, 0.22998539f, 0.03122900f, 0.12049272f, 0.06817771f, 0.10616010f, -0.05629347f, 
    0.11119220f, 0.02278848f, 0.05714909f, 0.02323474f, 0.17743686f, 0.07175478f, -0.10727315f, -0.03612626f, 
    -0.02352162f, 0.02100063f, -0.07087380f, 0.12659381f, -0.02795833f, -0.01505881f, 0.05922318f, 0.05200809f, 
    -0.10812131f, 0.08572965f, -0.01355254f, -0.05602206f, 0.16704775f, 0.17253925f, -0.02259694f, 0.00347351f, 
    -0.06475438f, 0.00688095f, 0.01382886f, 0.12280233f, 0.25902829f, -0.01751920f, -0.23773107f, 0.17751278f, 
    0.00297000f, -0.04068140f, 0.10308807f, 0.00105384f, 0.05647725f, 0.11564154f, -0.05034928f, -0.07686424f, 
    -0.14649789f, -0.15147890f, -0.02298944f, -0.21283796f, 0.06901819f, 0.00982867f, -0.01546275f, -0.05926441f, 
    -0.04022972f, 0.09215342f, 0.02634121f, 0.04972403f, 0.03624065f, -0.02884888f, -0.15447727f, 0.04379298f, 
    -0.06479044f, -0.07138266f, 0.02717831f, 0.01219613f, 0.09454972f, 0.06253408f, 0.11377449f, 0.11527782f, 
    -0.04969208f, -0.23809163f, 0.22406092f, -0.03019253f, 0.07470807f, -0.10580254f, 0.12478343f, 0.03456913f, 
    -0.04940381f, 0.02913326f, 0.05491635f, 0.02154268f, 0.06704340f, 0.15012461f, 0.00053066f, -0.15669669f, 
    -0.05610317f, -0.02210194f, 0.13372773f, 0.05725094f, -0.03148551f, 0.00714522f, -0.10626040f, 0.15236767f, 
    0.11090565f, -0.01966874f, 0.06247304f, -0.15196411f, 0.09840990f, 0.00680351f, 0.05132677f, 0.13646647f, 
    -0.04860041f, 0.05369150f, 0.11677960f, 0.00790304f, 0.19480836f, 0.09182997f, -0.26481941f, 0.01572688f, 
    -0.01428073f, 0.15496343f, -0.07975399f, 0.08225007f, 0.00858025f, 0.08077656f, 0.08793435f, -0.01201924f, 
    0.00249105f, -0.01326351f, 0.01210479f, 0.00643138f, 0.01856291f, -0.02531506f, -0.04615609f, 0.06234082f, 
    0.05462618f, -0.02966005f, 0.04308882f, -0.00614955f, -0.01304998f, 0.06027116f, -0.04133495f, 0.01339964f, 
    -0.02267265f, -0.02352417f, -0.05518282f, -0.05307927f, 0.04611082f, 0.06409957f, 0.00764929f, -0.05769224f, 
    0.03283599f, 0.00706982f, -0.03634867f, -0.01034382f, -0.05308421f, -0.05523511f, -0.03067081f, -0.07390204f, 
    -0.07424899f, 0.06208127f, 0.00626170f, -0.07373277f, -0.03667107f, 0.04143011f, -0.05632022f, -0.05633409f, 
    -0.06202541f, -0.01092734f, 0.00590810f, 0.04600748f, -0.07873978f, -0.06265033f, -0.03382307f, 0.00185821f, 
    0.04372104f, 0.00916339f, 0.02781363f, -0.04418073f, 0.03771283f, 0.04947109f, -0.04832988f, 0.01798448f, 
    -0.00584660f, -0.03658007f, -0.00727448f, -0.04270264f, 0.00148827f, -0.01085631f, -0.00190809f, 0.00595112f, 
    0.05306823f, 0.05280992f, 0.03654648f, -0.07327096f, 0.00879515f, -0.06765373f, 0.03838975f, 0.02655726f, 
    -0.05993211f, -0.04194134f, -0.04198686f, -0.05769705f, 0.02808104f, 0.03980384f, -0.05916085f, -0.07408038f, 
    -0.02742549f, -0.05588406f, 0.01790684f, -0.00799150f, 0.01820480f, -0.06885244f, 0.00293560f, 0.06123177f, 
    -0.00770645f, -0.05532056f, -0.06073115f, -0.03172202f, -0.00692937f, -0.04975223f, -0.02974622f, 0.02052620f, 
    -0.00492329f, -0.05937753f, -0.01410928f, -0.06350244f, 0.02738295f, -0.03971751f, 0.02127136f, 0.04657041f, 
    -0.02682802f, -0.02877620f, 0.00366361f, 0.02574282f, -0.07834140f, -0.03348308f, 0.02091021f, -0.05400973f, 
    -0.05908858f, -0.02656796f, -0.06543020f, 0.00685095f, 0.02673358f, -0.06958820f, -0.07793900f, -0.02664780f, 
    -0.02983465f, 0.00542948f, 0.00085099f, 0.02840075f, 0.06098601f, -0.04993622f, 0.00229441f, 0.03153852f, 
    -0.03010802f, 0.01564894f, 0.05947145f, 0.05617170f, -0.03583594f, 0.06206410f, -0.00607424f, 0.04352354f, 
    -0.03904125f, 0.05230258f, -0.02097872f, 0.02669208f, -0.04597165f, -0.07822195f, -0.03668545f, -0.06750803f, 
    -0.07026406f, 0.04043320f, -0.00482526f, 0.01873763f, 0.02901416f, 0.02052330f, -0.04984618f, -0.03037035f, 
    -0.07386059f, -0.03605351f, 0.01018924f, -0.02605442f, -0.07792304f, -0.06137311f, 0.02386006f, 0.05138243f, 
    0.02644261f, 0.06185627f, -0.04011871f, 0.04997506f, -0.00667918f, -0.02491180f, 0.05849133f, -0.06179882f, 
    -0.00456587f, -0.03555759f, -0.04548158f, -0.06044414f, 0.05423041f, -0.04911283f, -0.07078665f, -0.05782184f, 
    -0.07406771f, 0.05426482f, -0.03123541f, 0.05707339f, -0.01223931f, -0.05393903f, -0.06069959f, -0.07009064f, 
    0.02951291f, 0.00649067f, -0.05446297f, -0.02703836f, -0.02107158f, 0.00305361f, -0.05146921f, 0.01469967f, 
    0.32653293f, 0.18239713f, -0.07559510f, -0.11191519f, 0.05270940f, -0.01970698f, -0.05985595f, 0.07924647f, 
    -0.00066660f, 0.14062519f, 0.09033522f, 0.11588871f, -0.08122189f, 0.16036285f, 0.08889282f, -0.08930246f, 
    -0.03454868f, 0.08261183f, 0.13004115f, -0.00118912f, 0.01474707f, -0.05217379f, -0.11292905f, 0.05298750f, 
    -0.04131092f, 0.14241779f, 0.03890199f, 0.13347109f, -0.09098686f, 0.06151419f, -0.13077310f, -0.07385991f, 
    -0.04742968f, 0.10271359f, 0.08669318f, 0.03971744f, 0.36333206f, -0.05409360f, -0.12196606f, -0.27265841f, 
    -0.01002067f, 0.15823610f, 0.12227614f, 0.11903872f, 0.03304461f, 0.04135218f, -0.01784959f, -0.07069220f, 
    0.01093756f, 0.03046812f, 0.03624366f, -0.00293279f, -0.10209933f, -0.07232617f, -0.06993899f, -0.07332355f, 
    0.06264222f, -0.13801035f, 0.08908968f, 0.04010781f, -0.27441913f, 0.03348955f, 0.22500278f, 0.22690567f, 
    0.04105839f, 0.09933887f, 0.13513023f, 0.13767819f, -0.04003111f, 0.02476171f, -0.02502244f, 0.17358923f, 
    -0.21861780f, -0.01916466f, 0.02065424f, -0.02539361f, 0.00355091f, -0.06115479f, -0.08242511f, -0.05519895f, 
    -0.03693333f, -0.02815778f, -0.04333936f, 0.11962337f, 0.31313401f, -0.12555227f, 0.00617169f, 0.25827774f, 
    -0.04528160f, 0.03884173f, 0.00386100f, -0.02187774f, 0.08764791f, 0.02959818f, 0.05356399f, -0.04985196f, 
    -0.28052443f, 0.06013755f, -0.25302339f, 0.02108042f, 0.03951916f, -0.01063838f, 0.01041915f, -0.01353997f, 
    -0.00227868f, -0.03402748f, -0.01313714f, -0.06962600f, -0.08305565f, 0.06177795f, -0.22161409f, 0.25318399f, 
    0.05300251f, -0.03932531f, 0.06806865f, 0.12328029f, -0.11502738f, 0.10065556f, 0.05396137f, 0.04379387f, 
    0.25582221f, 0.02031848f, -0.00202081f, -0.33928096f, 0.05374190f, 0.06722487f, 0.04354129f, 0.09021077f, 
    -0.01054206f, -0.15292552f, 0.02936313f, 0.02298206f, -0.14783269f, -0.18483271f, 0.28152841f, -0.01156045f, 
    0.09680601f, -0.00006525f, -0.11545485f, 0.13438031f, 0.02692459f, -0.01441701f, 0.07281490f, 0.08290245f, 
    0.02423039f, -0.04704222f, 0.18674679f, -0.04500198f, -0.09005419f, 0.06718780f, 0.10700122f, 0.12990460f, 
    0.07030577f, -0.11368337f, -0.11929457f, -0.01813474f, -0.29302642f, -0.16886377f, -0.00861172f, 0.05331801f, 
    0.05237039f, 0.00413056f, 0.11139129f, -0.11950655f, -0.01574126f, 0.05883217f, 0.08247759f, -0.14369750f, 
    -0.15166825f, 0.02023451f, 0.03746499f, 0.06709690f, 0.02293217f, 0.10314208f, 0.02476701f, 0.02597694f, 
    -0.03686740f, -0.01352947f, 0.08722049f, 0.06522369f, 0.12854806f, -0.05281607f, 0.05895021f, -0.18925774f, 
    -0.01290904f, 0.06281318f, -0.08144337f, 0.05998359f, -0.07798894f, 0.03345307f, -0.14147213f, -0.10610393f, 
    -0.17028114f, -0.21026957f, 0.13233736f, 0.15567735f, -0.05937820f, 0.01130739f, -0.03340999f, 0.04365744f, 
    0.12778127f, 0.03886583f, -0.07592334f, 0.02123041f, 0.34641713f, -0.01899659f, 0.05074462f, -0.04621272f, 
    0.11792230f, -0.02433660f, -0.07034410f, 0.05016858f, -0.02416430f, 0.13275857f, 0.10137575f, -0.09024590f, 
    -0.03738608f, -0.08856691f, -0.08955892f, -0.02488987f, 0.04227268f, 0.00923108f, -0.05156126f, 0.14411634f, 
    -0.02524751f, 0.06343934f, 0.03109701f, -0.03749020f, -0.10117616f, 0.14724287f, -0.03246654f, 0.19200173f, 
    -0.02537148f, 0.01018218f, -0.02885149f, -0.08785454f, 0.12081546f, 0.03005386f, 0.07295803f, 0.03756160f, 
    0.26639965f, -0.02358586f, -0.08400857f, 0.08925406f, 0.03312650f, 0.05388240f, 0.00564980f, 0.06920718f, 
    0.10066650f, 0.12548120f, -0.00609706f, -0.08217311f, 0.26508516f, -0.15025687f, -0.15929532f, -0.30646357f, 
    0.12607747f, -0.12044710f, 0.02123138f, 0.06297729f, 0.05650324f, 0.00471987f, 0.10527255f, -0.11395195f, 
    0.08957560f, 0.17678477f, -0.17709811f, 0.02702642f, 0.09993255f, 0.06772798f, 0.06560562f, 0.03671800f, 
    0.09063745f, 0.02928747f, 0.08515478f, -0.03610853f, -0.04610427f, 0.17445828f, 0.01170010f, -0.09659273f, 
    -0.18600048f, 0.02353094f, -0.01331048f, 0.06848481f, 0.00927676f, -0.11642637f, -0.02614842f, -0.00356088f, 
    0.05250873f, -0.00883938f, -0.01937014f, 0.00389435f, 0.04483593f, 0.06720208f, -0.07867478f, -0.01605210f, 
    -0.07023555f, 0.05178994f, 0.05928314f, 0.05632099f, 0.12076931f, -0.05272734f, 0.11186054f, 0.17606989f, 
    -0.05795379f, -0.00931520f, 0.00264796f, -0.05399277f, 0.01694423f, -0.03334958f, 0.02058882f, -0.16665834f, 
    -0.16851699f, -0.02267261f, -0.12622274f, 0.02267161f, -0.04328404f, 0.02431641f, 0.07490744f, -0.08323833f, 
    0.13162674f, 0.06245267f, 0.03300616f, 0.01733024f, -0.02927640f, -0.01708246f, -0.16422233f, -0.08559673f, 
    -0.07551020f, -0.06526653f, -0.04256674f, -0.14451450f, 0.04984837f, 0.08196849f, -0.04611052f, -0.00192589f, 
    0.10963064f, -0.12670323f, 0.10424463f, -0.18072821f, 0.09091297f, -0.05312533f, 0.06506050f, -0.03923047f, 
    0.02446009f, 0.04404812f, 0.08360731f, 0.06744556f, 0.27336618f, 0.01528989f, -0.05067436f, -0.04232785f, 
    -0.00324162f, -0.04425729f, 0.05727722f, 0.16489518f, 0.00118506f, 0.04196301f, 0.03094167f, 0.12701307f, 
    -0.01536928f, 0.00484545f, 0.10370085f, 0.05965453f, 0.03803935f, -0.05174087f, -0.10622151f, 0.08353484f, 
    -0.03008923f, 0.03981075f, 0.07367994f, 0.03559401f, 0.08005308f, 0.21319512f, -0.22662708f, 0.01409792f, 
    -0.01260976f, 0.04639544f, 0.10726008f, 0.00685777f, -0.09115236f, 0.04309669f, 0.14895974f, -0.05917999f, 
    -0.23548156f, -0.03774632f, -0.19287178f, 0.06299027f, -0.01450589f, 0.07637452f, 0.03769932f, -0.06309802f, 
    0.08201696f, 0.01762060f, -0.02910682f, 0.02067196f, -0.22119065f, -0.10321891f, -0.04802498f, 0.06162988f, 
    0.27779749f, 0.02828425f, -0.00168881f, 0.00649542f, 0.14949302f, 0.13713056f, 0.10095981f, 0.03205622f, 
    0.25509736f, 0.07009537f, -0.02987590f, 0.02465951f, 0.05905359f, 0.02816533f, 0.05299761f, 0.07760444f, 
    0.09585442f, -0.11395741f, -0.00319924f, 0.04860223f, -0.02890730f, -0.00460972f, 0.04014582f, 0.16043702f, 
    0.01229332f, -0.02583515f, 0.05348769f, -0.00396886f, -0.08342647f, 0.08724888f, 0.07876294f, -0.04577567f, 
    0.11483770f, -0.07382916f, 0.10479855f, -0.03145326f, -0.02482982f, 0.01951526f, 0.07290480f, 0.10297967f, 
    0.00278331f, 0.03529456f, 0.06035661f, -0.04217609f, -0.02978039f, 0.19189033f, -0.04450916f, -0.19802977f, 
    -0.02050738f, -0.01008235f, 0.14541663f, -0.08054455f, 0.10255902f, 0.06156814f, 0.05972653f, -0.15703538f, 
    0.08029415f, 0.11469495f, 0.13759162f, 0.13513519f, -0.05321268f, -0.05305247f, 0.00125299f, 0.11387371f, 
    -0.05533815f, -0.02474565f, 0.09657475f, -0.00909304f, -0.28742158f, 0.08527339f, -0.00847300f, -0.05982774f, 
    0.17293836f, 0.11777158f, 0.16008779f, 0.08379786f, 0.03190988f, 0.16201219f, -0.02692092f, 0.02415130f, 
    -0.01901932f, 0.02604711f, -0.12264672f, -0.17780954f, -0.08197025f, 0.14604867f, -0.03014641f, 0.07010927f, 
    -0.11214431f, -0.00577251f, -0.04993059f, 0.12164938f, -0.03885643f, 0.10785519f, 0.15221193f, -0.23157589f, 
    -0.12313764f, 0.01836155f, 0.01651830f, -0.02404069f, 0.11679374f, -0.07616130f, 0.20650585f, -0.20269383f, 
    -0.27022272f, -0.04689727f, 0.06983167f, 0.20403261f, -0.00749841f, -0.06787774f, 0.04391794f, 0.02003826f, 
    -0.09006517f, -0.08893415f, 0.12249351f, -0.00143679f, 0.12186028f, 0.06063313f, -0.05742678f, 0.10343625f, 
    -0.17535940f, 0.06481777f, 0.14357355f, -0.20544834f, 0.16866000f, 0.01711789f, -0.06701048f, -0.09141602f, 
    -0.03903044f, -0.07782311f, -0.08407047f, 0.09214091f, 0.11601301f, -0.07408325f, -0.05828987f, -0.05247723f, 
    -0.08725914f, -0.04468363f, -0.00599083f, 0.03644615f, 0.19314043f, 0.29952279f, -0.02291426f, -0.27865398f, 
    0.01432420f, -0.02345922f, -0.03561663f, 0.04024456f, -0.00273211f, 0.04111300f, -0.05202185f, 0.03200614f, 
    0.33764881f, 0.05041081f, -0.03212191f, -0.00936560f, -0.08563805f, -0.04208186f, 0.02247581f, 0.07765748f, 
    0.03853714f, -0.12738083f, -0.01879746f, -0.02826304f, 0.00622236f, 0.01303695f, 0.06045266f, 0.12121745f, 
    -0.06763674f, 0.01730556f, 0.01249873f, -0.01629311f, -0.02547149f, 0.09488688f, 0.01934621f, -0.07336937f, 
    -0.05510151f, -0.08095814f, -0.03186093f, 0.05997698f, 0.03680022f, -0.02286074f, 0.01022658f, -0.06142762f, 
    0.01519147f, -0.07944351f, 0.03739633f, 0.05571408f, 0.05723190f, -0.03443819f, -0.05519023f, -0.04083433f, 
    0.05947156f, -0.03153815f, -0.07005867f, -0.05394056f, -0.00953448f, -0.06342083f, -0.06475682f, 0.03263756f, 
    -0.01208642f, 0.02330624f, 0.04434771f, 0.03652359f, -0.00618363f, -0.01771379f, 0.01429652f, -0.07022344f, 
    0.05937485f, 0.00352546f, 0.03485199f, -0.01483589f, 0.05008981f, -0.03689134f, 0.06071374f, -0.03834134f, 
    0.01218294f, -0.05312365f, 0.02322206f, -0.06511280f, 0.03501029f, 0.06285507f, -0.04811155f, -0.03131760f, 
    0.06027721f, -0.04202585f, -0.01018995f, -0.02005110f, 0.05548758f, -0.04886983f, 0.00687587f, 0.05034644f, 
    0.01046499f, -0.00312596f, 0.00720503f, 0.02335330f, 0.06097041f, 0.03993205f, 0.02567312f, -0.07554441f, 
    0.03390029f, -0.02139967f, -0.04357420f, -0.00159554f, -0.05534324f, -0.07803854f, -0.02991856f, -0.05458695f, 
    -0.04861613f, -0.00022217f, -0.06530649f, -0.07753357f, 0.04903556f, -0.07375848f, 0.02613079f, -0.05451177f, 
    -0.05071655f, 0.02884775f, 0.03195714f, 0.01392028f, 0.03789322f, -0.05570294f, -0.07458500f, 0.03522947f, 
    0.04343771f, -0.03652005f, -0.02212662f, 0.03458166f, 0.02852612f, -0.05015522f, -0.07558426f, -0.01624587f, 
    -0.04393610f, -0.01523454f, 0.04787285f, -0.05576104f, 0.05938848f, 0.04377677f, -0.03912079f, 0.00958982f, 
    -0.04314403f, -0.02201692f, 0.05418918f, 0.02130753f, -0.06132784f, -0.06684060f, -0.05500754f, -0.03451683f, 
    0.03291000f, 0.01237638f, 0.03504562f, -0.01823053f, 0.00156639f, -0.04313685f, 0.00183481f, -0.04309667f, 
    0.00211125f, 0.04371140f, 0.02151520f, -0.04479804f, -0.06864019f, 0.00128059f, -0.03000920f, 0.02438070f, 
    -0.03514279f, -0.06018307f, 0.00603803f, -0.06762893f, -0.02013297f, 0.04360879f, 0.02766025f, 0.04688765f, 
    -0.00442501f, -0.03369448f, -0.03635633f, 0.04574300f, 0.05741490f, 0.02824352f, 0.02345375f, -0.05335986f, 
    -0.01007930f, 0.03014814f, 0.00140589f, 0.02364351f, -0.07305327f, -0.07915380f, -0.07126255f, -0.04552403f, 
    0.01734790f, 0.04075321f, 0.00783988f, 0.01857136f, -0.06993402f, -0.04750899f, -0.02512797f, 0.05613565f, 
    0.05403007f, -0.05264748f, 0.04443420f, 0.05300286f, 0.01083772f, -0.03013618f, 0.00185590f, -0.00003462f, 
    -0.05603524f, 0.01063766f, -0.06174817f, -0.05551114f, -0.03250424f, -0.00206497f, 0.00624217f, 0.05315638f, 
    0.04009143f, 0.05150617f, 0.05991128f, -0.01147540f, -0.01818083f, -0.03885277f, -0.06961317f, -0.03567984f, 
    -0.02203218f, 0.02732120f, -0.03088300f, -0.00174862f, -0.04475150f, -0.06315590f, -0.00432311f, -0.00753994f, 
    -0.02951674f, -0.03599111f, 0.01920564f, 0.01323829f, -0.05952786f, -0.05677380f, -0.01635609f, 0.04103504f, 
    -0.03162735f, 0.01566260f, -0.05523413f, 0.04647364f, -0.07452320f, -0.07634004f, 0.00920552f, -0.03267035f, 
    -0.09164991f, -0.07695463f, -0.05617497f, 0.05037345f, -0.05656350f, -0.05442039f, 0.02507064f, 0.03630805f, 
    -0.07624314f, 0.02900897f, 0.00101875f, 0.04383421f, 0.03397731f, -0.04489080f, -0.07990526f, -0.08126239f, 
    -0.07421535f, 0.00018351f, -0.00074348f, -0.03433491f, -0.08111575f, 0.02570554f, -0.05283141f, -0.04481824f, 
    0.00860321f, 0.02619744f, -0.07490449f, -0.01245466f, -0.07459600f, -0.03247062f, 0.00682328f, -0.05207249f, 
    -0.07533861f, 0.02474054f, -0.00463324f, -0.04969726f, -0.03489998f, 0.02539311f, -0.02031749f, 0.01818179f, 
    0.07282528f, 0.02008918f, 0.04402527f, 0.01573452f, -0.05806533f, -0.01689074f, 0.01499538f, 0.03780589f, 
    0.00716642f, 0.03933267f, -0.03902810f, -0.01469522f, -0.01591173f, -0.06502122f, -0.02908407f, -0.08862189f, 
    0.06955954f, 0.05768353f, -0.01724438f, 0.02065949f, 0.00201847f, 0.02633592f, 0.06751271f, -0.05086857f, 
    -0.01177712f, -0.03457193f, 0.01883415f, 0.02934854f, 0.05635430f, 0.02211826f, -0.05111865f, 0.03539100f, 
    0.04963896f, -0.04675781f, -0.00521859f, 0.05698369f, -0.06759162f, 0.04523566f, 0.01418031f, 0.03076188f, 
    -0.07825208f, -0.01636755f, -0.02445454f, -0.00872489f, -0.05450104f, 0.03300868f, 0.04181082f, -0.04482689f, 
    0.02455674f, 0.00402099f, -0.07978371f, -0.05167438f, 0.01621365f, 0.02848754f, -0.00899980f, 0.05889433f, 
    -0.01268286f, -0.01069018f, 0.00754734f, 0.05148791f, -0.03377335f, 0.01773323f, 0.05718153f, -0.01970544f, 
    0.05791320f, 0.03545943f, -0.06192295f, -0.03309805f, -0.05699033f, 0.06755130f, -0.03972592f, -0.00483532f, 
    -0.05024088f, -0.02031283f, 0.02213863f, 0.00520970f, 0.00289671f, -0.00789025f, 0.01006990f, -0.03218385f, 
    -0.01711177f, 0.04832783f, 0.00020964f, 0.00130958f, 0.00355146f, -0.03615118f, 0.03771636f, -0.10409062f, 
    0.04312732f, -0.01144161f, 0.05842240f, 0.01241874f, 0.01249172f, -0.00153418f, 0.01288472f, -0.07152352f, 
    0.03201900f, 0.00051330f, -0.08926882f, 0.00731040f, -0.00476038f, 0.03023916f, -0.05744135f, -0.07693985f, 
    -0.05986828f, -0.04640021f, -0.07298163f, -0.04783321f, 0.02297154f, 0.04641877f, 0.00149924f, 0.05153678f, 
    -0.07201254f, -0.06785930f, 0.01260102f, -0.05208448f, -0.00085961f, -0.06833096f, 0.03728693f, 0.00320877f, 
    -0.04279537f, 0.01901332f, -0.07630160f, 0.05109294f, 0.02383384f, 0.00442891f, -0.02061556f, -0.05195629f, 
    -0.01462860f, 0.04067285f, -0.07157436f, -0.06899549f, 0.05471367f, 0.04842559f, -0.09194784f, -0.02108273f, 
    0.13441810f, 0.00192502f, -0.11236744f, -0.13761517f, -0.06717168f, 0.02623283f, -0.12444859f, 0.04352154f, 
    0.11486721f, -0.01111559f, -0.13388632f, 0.01901191f, -0.11214767f, -0.33048618f, -0.17371218f, 0.07709619f, 
    -0.03971030f, 0.18423684f, -0.04893171f, -0.09449576f, 0.04509883f, -0.09603135f, 0.01299280f, -0.09117891f, 
    0.37837422f, -0.04110697f, -0.01281676f, 0.03171492f, 0.11870153f, 0.10642461f, 0.00039376f, -0.02690758f, 
    -0.05068119f, 0.01281447f, 0.03660258f, -0.02800978f, -0.09604049f, -0.12999409f, 0.03530576f, 0.07337919f, 
    0.05304026f, -0.04965033f, 0.01990487f, 0.00878696f, 0.09014327f, 0.06723791f, 0.07904339f, 0.12627369f, 
    0.18952245f, -0.02466286f, -0.13065821f, 0.13808239f, -0.05223674f, -0.23368445f, 0.09577357f, 0.08437000f, 
    0.06737243f, 0.08995824f, -0.03275373f, -0.00538822f, 0.30663288f, -0.07057249f, -0.08411959f, -0.12349155f, 
    -0.18534815f, -0.00445658f, -0.06197524f, 0.05975724f, 0.02829817f, 0.05246035f, 0.17299424f, -0.14729729f, 
    -0.33536240f, -0.37660074f, 0.14499705f, 0.02173204f, 0.11319447f, 0.25437766f, 0.09129802f, 0.06394062f, 
    -0.02296640f, 0.10681202f, 0.12173839f, -0.12507927f, 0.02141114f, 0.24469526f, -0.02508269f, -0.02761975f, 
    0.07936519f, -0.20734502f, 0.09049311f, 0.14676771f, -0.02723374f, -0.03809082f, 0.01020622f, 0.05707510f, 
    -0.01170783f, -0.25391385f, -0.06791230f, -0.01497293f, 0.02154656f, -0.07638402f, -0.16722979f, -0.01242334f, 
    -0.07135916f, -0.07461916f, -0.01703921f, 0.11340891f, 0.45077887f, -0.13095456f, 0.20987612f, 0.02351444f, 
    -0.13062748f, -0.06063257f, -0.07516330f, -0.08549829f, 0.04710371f, -0.01603120f, 0.06393209f, 0.15631187f, 
    0.30208537f, 0.24431121f, -0.10718820f, -0.37044004f, 0.13623808f, 0.06541010f, -0.00276763f, 0.00521878f, 
    0.07791483f, 0.11478558f, -0.01546790f, 0.10351419f, 0.12699378f, 0.18397304f, 0.10103247f, -0.32839021f, 
    -0.18111491f, -0.04380640f, 0.08313984f, -0.12113150f, -0.00630107f, 0.16907066f, -0.05309824f, 0.11920065f, 
    -0.11435610f, -0.03842267f, -0.02577323f, -0.19197819f, -0.13271657f, 0.09328843f, 0.06754136f, -0.00466659f, 
    0.02689789f, -0.00283669f, 0.02559690f, 0.17691801f, -0.38731641f, -0.14844047f, -0.07609686f, 0.05380311f, 
    0.16014734f, 0.16632599f, 0.04080963f, -0.00633565f, 0.00181350f, -0.06573196f, -0.05350528f, 0.13082337f, 
    0.15410848f, -0.12901941f, 0.14065135f, -0.02598470f, 0.02177778f, 0.04519418f, 0.11442126f, 0.00555104f, 
    -0.10910132f, 0.13740250f, 0.09424803f, 0.12056746f, -0.12349801f, 0.10423382f, -0.15323527f, -0.06330184f, 
    0.11085298f, 0.07711161f, 0.02750325f, 0.10200903f, 0.05471673f, 0.18459651f, -0.01902158f, 0.09196564f, 
    -0.03333649f, 0.23282948f, 0.07496230f, -0.23765922f, -0.01975970f, 0.00265189f, -0.02694741f, -0.03170000f, 
    -0.05369268f, -0.16754639f, 0.06244256f, -0.01801971f, -0.26014230f, 0.06750774f, 0.04411630f, -0.16034657f, 
    -0.03731641f, 0.03728101f, -0.03554583f, 0.12374617f, -0.01119668f, -0.02523936f, 0.00457964f, 0.18821236f, 
    -0.23643681f, -0.15193239f, 0.14515857f, 0.19214331f, 0.06293645f, -0.11811100f, -0.05355379f, 0.02576482f, 
    -0.02054286f, -0.04326398f, 0.00490399f, 0.12644987f, -0.05171928f, 0.08433883f, 0.08545189f, 0.28584662f, 
    0.14481519f, 0.02010656f, 0.11290868f, 0.07092837f, -0.04491770f, 0.04224322f, -0.13199611f, 0.10025237f, 
    -0.19925295f, 0.32759067f, 0.10295991f, -0.10897157f, 0.00803693f, 0.04948432f, -0.07567078f, -0.02289805f, 
    -0.03694323f, 0.03663711f, -0.07610283f, 0.09850749f, -0.02623307f, 0.15249258f, -0.09957211f, -0.19378375f, 
    0.01676724f, 0.15242784f, -0.10318069f, -0.09321588f, -0.03910850f, 0.02642143f, -0.06787986f, 0.12426448f, 
    0.17281960f, -0.18482903f, -0.01622263f, 0.22722900f, -0.07170946f, -0.05305667f, -0.06832191f, 0.11572941f, 
    0.06899178f, -0.03025545f, -0.06199656f, -0.07896709f, -0.03637903f, -0.00421661f, 0.06979096f, 0.00774586f, 
    0.15494746f, -0.10916234f, -0.00249788f, 0.05699481f, 0.04217608f, 0.07636445f, 0.03255400f, 0.02809859f, 
    -0.05199847f, 0.20596708f, 0.01314781f, 0.23328301f, -0.06295661f, -0.00822272f, -0.01050954f, -0.01367928f, 
    0.02619957f, 0.13176537f, 0.04455526f, 0.01838944f, -0.41180491f, 0.26838875f, 0.06680766f, -0.16129285f, 
    -0.00913397f, 0.10233261f, -0.03104382f, 0.00929280f, -0.01184885f, 0.09607265f, -0.07665238f, 0.05534700f, 
    -0.07023370f, 0.28485814f, 0.11951539f, 0.10818574f, -0.00662314f, 0.00695339f, -0.02300861f, 0.02143771f, 
    -0.06299376f, 0.02741208f, 0.02409314f, 0.02213689f, 0.11156368f, -0.09654495f, 0.16032213f, 0.40011388f, 
    0.18126573f, 0.14294343f, 0.09138046f, 0.28536355f, 0.07125055f, -0.05020309f, 0.09474332f, 0.02676179f, 
    0.24235535f, 0.03777691f, -0.13211836f, -0.08601397f, -0.03975664f, -0.05416847f, 0.00707666f, -0.02048287f, 
    0.03255015f, 0.13481729f, -0.09624474f, 0.06914463f, 0.04674838f, -0.09880209f, 0.03938914f, 0.11230507f, 
    -0.06628199f, -0.01575272f, -0.15983589f, 0.03838613f, -0.03111523f, -0.05610797f, 0.05091578f, -0.05298372f, 
    0.02355330f, 0.01395145f, -0.00475680f, 0.09534752f, -0.08314783f, -0.01628728f, -0.07430848f, 0.05658394f, 
    0.17450552f, -0.01624100f, -0.02116594f, 0.09777035f, -0.28238797f, -0.12473983f, 0.29336151f, 0.03151748f, 
    0.05522684f, -0.07990902f, 0.04247871f, -0.02963731f, 0.10812329f, -0.02995097f, 0.17161755f, 0.11791163f, 
    -0.24960102f, 0.01969097f, 0.12218843f, -0.12549028f, -0.13344833f, 0.02031137f, -0.05168531f, -0.00379318f, 
    0.01301497f, 0.09461636f, -0.06902937f, -0.12777734f, -0.08766976f, -0.15525372f, 0.16174918f, -0.08045051f, 
    -0.02453326f, -0.10010061f, -0.10676686f, 0.05340818f, 0.00071985f, 0.01189706f, 0.05235813f, -0.00886129f, 
    0.05344692f, -0.11510880f, -0.00744625f, 0.22092788f, -0.02057280f, -0.06516290f, -0.07143490f, 0.04949754f, 
    -0.00820786f, -0.07550028f, 0.01452131f, -0.09007431f, -0.05836054f, 0.04183869f, -0.13392057f, 0.30646366f, 
    0.02770011f, -0.02619713f, 0.11257245f, -0.01258503f, 0.06113460f, 0.04840056f, 0.05241645f, 0.08347836f, 
    0.16226323f, 0.00403557f, -0.07584532f, -0.06030255f, 0.02437832f, 0.02802190f, -0.06050347f, -0.06468552f, 
    0.11398795f, 0.21851191f, -0.07091695f, 0.10621420f, 0.32752961f, -0.11283810f, 0.03973467f, -0.27916974f, 
    -0.03031337f, -0.00118009f, 0.02164003f, 0.08519319f, 0.02661381f, -0.03976528f, 0.05951355f, -0.09481789f, 
    0.05218932f, -0.08545414f, 0.19407830f, 0.09569738f, 0.06590831f, 0.01810760f, 0.04352123f, -0.04976046f, 
    0.05289553f, 0.00776817f, -0.02585960f, 0.00430887f, 0.28709355f, 0.13225840f, -0.03970733f, 0.02387392f, 
    0.05495545f, 0.02215067f, -0.12827007f, 0.10938572f, -0.06920557f, -0.14665648f, 0.01610022f, 0.11507052f, 
    0.13954051f, 0.12366434f, -0.01566148f, 0.26185107f, 0.04006454f, 0.09091812f, 0.01555786f, 0.00612736f, 
    -0.01796086f, 0.04078339f, 0.07389255f, 0.09647025f, 0.25955880f, 0.00090647f, -0.10043367f, 0.03532824f, 
    -0.27084669f, 0.05481417f, 0.03058795f, -0.06975602f, 0.04065137f, -0.01815968f, -0.06299701f, -0.04816280f, 
    -0.19418177f, 0.12229825f, -0.21144755f, -0.36308736f, 0.01444962f, 0.09123594f, 0.05410431f, -0.09582331f, 
    0.07753459f, 0.12605622f, -0.05970408f, 0.06520811f, 0.00390236f, -0.13373852f, -0.01642211f, 0.02975754f, 
    0.04631786f, 0.02087660f, 0.08956538f, -0.01231606f, 0.01940022f, 0.09933367f, -0.00345822f, 0.13604377f, 
    0.01298894f, -0.30289203f, 0.11152793f, -0.22456497f, -0.02946378f, 0.01725137f, 0.19200921f, -0.03480459f, 
    -0.08573125f, 0.11452994f, -0.00405564f, 0.09088712f, -0.02000439f, 0.00769426f, 0.12577124f, -0.01795906f, 
    -0.05322863f, 0.04234640f, 0.02277203f, 0.08639351f, -0.02947115f, -0.02610684f, 0.05684703f, 0.02334665f, 
    0.04202392f, -0.05618037f, 0.16968375f, -0.04747148f, -0.09104751f, -0.05529687f, -0.05686052f, 0.08851029f, 
    0.00038097f, 0.04869315f, 0.12386898f, 0.00191997f, -0.08247971f, 0.10221043f, -0.15144956f, -0.00975502f, 
    0.00658687f, 0.11615106f, 0.00900102f, -0.01900215f, 0.01064325f, 0.11481050f, 0.06190402f, -0.05993034f, 
    0.06974629f, 0.00805237f, 0.02726531f, 0.07961210f, 0.04184659f, -0.02789202f, 0.10495498f, 0.07294394f, 
    -0.03258492f, 0.13267447f, -0.07130628f, 0.21989724f, 0.33795452f, -0.04545121f, 0.12956473f, 0.20057353f, 
    -0.24344665f, 0.12040571f, -0.06312668f, 0.00759769f, -0.05863350f, -0.00590296f, -0.05507915f, -0.10670968f, 
    -0.11342290f, 0.07903313f, -0.14570177f, 0.08170927f, 0.09929123f, -0.08197293f, 0.05442544f, 0.13362961f, 
    0.10155360f, 0.13440879f, 0.02974772f, 0.01583199f, -0.13274951f, 0.07955091f, 0.19937943f, -0.09198005f, 
    -0.00142270f, 0.01017446f, -0.05663961f, 0.02585130f, -0.06767761f, -0.12455357f, -0.02871431f, 0.01672439f, 
    -0.20001994f, 0.08312180f, 0.13536754f, 0.06536735f, 0.04629368f, -0.00404210f, -0.00684515f, 0.12021615f, 
    -0.08582126f, -0.13775367f, -0.04757693f, 0.01201784f, -0.17118016f, -0.19554093f, -0.01299812f, -0.14253268f, 
    0.09996519f, -0.04693977f, 0.08205644f, -0.07589905f, 0.04105532f, 0.08700292f, 0.02662089f, -0.06743930f, 
    0.26030135f, 0.19579364f, -0.01862624f, -0.01505298f, 0.03209580f, -0.08426887f, -0.01139575f, 0.04397599f, 
    -0.03971572f, 0.09145119f, -0.00625521f, 0.29122695f, -0.13644555f, 0.27240345f, -0.02915089f, -0.07563195f, 
    -0.06922756f, -0.06520625f, 0.10557593f, 0.01329197f, -0.01283833f, 0.06959201f, -0.09795856f, -0.19832820f, 
    0.13490950f, 0.00622701f, -0.16257446f, 0.03630667f, -0.07481252f, -0.00633857f, 0.08559425f, 0.03433983f, 
    -0.05105381f, -0.03368841f, 0.00255314f, -0.03301914f, -0.15522218f, 0.01786973f, 0.14763175f, 0.04157669f, 
    0.08291642f, -0.05376314f, -0.01206456f, -0.03813013f, -0.06725911f, 0.01478444f, 0.20047991f, 0.07772086f, 
    0.24578449f, 0.24662140f, 0.04134247f, 0.08797713f, -0.03118023f, -0.06719139f, 0.05629063f, -0.01249196f, 
    -0.06698723f, 0.05239940f, -0.03130122f, -0.05708999f, 0.14959845f, 0.10083034f, 0.04963818f, -0.04060060f, 
    -0.11698349f, 0.09225382f, -0.14074580f, 0.01557740f, -0.03868489f, -0.00514004f, 0.06210463f, -0.00468779f, 
    0.00452338f, -0.26228434f, -0.11836638f, 0.06032535f, -0.01731898f, 0.09604321f, -0.07743179f, 0.11193087f, 
    0.08958460f, -0.12533477f, 0.02500771f, -0.10335965f, 0.22550905f, 0.07149784f, -0.07465092f, 0.12932453f, 
    -0.14194070f, 0.00100795f, 0.08294814f, 0.05576357f, -0.01140540f, 0.07445034f, -0.07167053f, -0.05600157f, 
    0.06206608f, 0.06350524f, 0.11035150f, 0.29497221f, 0.01568182f, 0.14371340f, -0.00424433f, 0.00290135f, 
    0.04623667f, -0.05251747f, -0.03157491f, -0.19971001f, -0.33828768f, 0.09227185f, 0.27476877f, 0.10276876f, 
    0.13655752f, -0.07077274f, 0.07322773f, 0.05536778f, -0.00313957f, -0.07582399f, -0.07328855f, -0.00266569f, 
    -0.09267485f, -0.06264503f, -0.06956575f, 0.06396394f, -0.00059277f, -0.05858976f, 0.04294740f, 0.02472450f, 
    -0.04356173f, 0.00657232f, -0.08135939f, -0.03367518f, -0.01789214f, -0.04161805f, -0.03386255f, -0.11007424f, 
    0.02357056f, -0.05076402f, -0.07214803f, 0.01103852f, 0.04201470f, 0.03206994f, 0.04268844f, -0.09669171f, 
    -0.00601361f, -0.02697128f, 0.04736359f, -0.05939802f, -0.06528362f, 0.02150609f, -0.08235104f, -0.09304197f, 
    -0.05473563f, 0.02618860f, -0.00002538f, -0.00326329f, -0.08225979f, 0.01237108f, 0.03593569f, -0.03929551f, 
    -0.07106970f, -0.05636483f, 0.03416481f, -0.05751842f, -0.02022534f, -0.02947756f, -0.06792252f, 0.04573321f, 
    0.00978520f, -0.05309709f, 0.03708551f, 0.01569292f, -0.05275856f, -0.10335125f, -0.01275068f, -0.06286100f, 
    0.01717841f, 0.05763658f, -0.00059146f, -0.00418288f, -0.01648208f, 0.00892810f, 0.04291891f, -0.06983582f, 
    -0.05147974f, -0.06188251f, 0.01898215f, 0.00823754f, 0.00892075f, 0.04402858f, 0.04294889f, 0.00942440f, 
    0.02105459f, 0.01861716f, -0.05908555f, -0.06241867f, -0.08245930f, -0.04825636f, -0.09003859f, 0.06847733f, 
    -0.06382675f, 0.02373763f, -0.01028728f, -0.07328147f, -0.08661515f, 0.03826564f, -0.06012229f, -0.02525318f, 
    -0.04825544f, -0.07801498f, -0.08072414f, -0.01040558f, -0.00574486f, 0.01193257f, -0.06894168f, -0.00255956f, 
    -0.08470850f, -0.09458044f, -0.04621833f, -0.00917234f, -0.01822271f, -0.00534900f, -0.00593890f, 0.04930230f, 
    -0.06508695f, -0.03346873f, 0.02210227f, -0.06451354f, -0.07520884f, -0.05663256f, 0.03905565f, -0.05514531f, 
    0.01210342f, -0.12666118f, -0.11968765f, -0.03627127f, 0.03548755f, -0.06321573f, 0.01320646f, -0.05602423f, 
    0.03337835f, -0.00796187f, 0.00236261f, -0.06054409f, -0.02337821f, -0.08232319f, -0.05542905f, 0.03945822f, 
    -0.02155362f, -0.06650466f, -0.07214446f, -0.00552105f, -0.09465703f, -0.01135841f, -0.01481220f, -0.01789243f, 
    -0.08542372f, 0.00112036f, -0.03447089f, -0.06052153f, -0.08117587f, 0.05733392f, -0.02857357f, 0.05516543f, 
    -0.00451248f, -0.00480692f, -0.07735742f, -0.09166931f, -0.10047687f, 0.00338505f, -0.00352640f, -0.06522717f, 
    -0.12994365f, 0.04594585f, 0.03629955f, 0.01339228f, -0.01241273f, -0.02107708f, -0.14267716f, -0.00490781f, 
    -0.03218415f, 0.05106213f, 0.05823999f, 0.01612947f, 0.01016677f, 0.04641930f, -0.08013976f, -0.01075849f, 
    -0.02522308f, 0.00653892f, -0.07587212f, -0.08864363f, -0.04962493f, -0.04155566f, -0.03073926f, -0.04078001f, 
    0.04313369f, -0.12646106f, 0.04704568f, -0.05326980f, -0.09425873f, -0.04450422f, -0.01948607f, -0.04697699f, 
    -0.00783448f, 0.04830390f, -0.02453036f, -0.07283600f, 0.05090166f, -0.04778093f, 0.03937338f, -0.07259847f, 
    0.24540721f, 0.08599486f, 0.12394391f, -0.06913339f, -0.11544401f, 0.01181750f, -0.00304181f, 0.00535585f, 
    0.04749532f, 0.12504068f, -0.06152670f, 0.04871188f, 0.00516258f, 0.08750380f, 0.13748598f, -0.16301921f, 
    -0.13408449f, -0.05520302f, 0.03825746f, 0.01444371f, -0.11399224f, 0.02042021f, -0.03631614f, -0.07817004f, 
    0.14128375f, -0.21553755f, -0.07958023f, 0.21833387f, -0.10588504f, -0.02847635f, -0.10695841f, -0.08584020f, 
    0.01097060f, 0.11853299f, -0.00360085f, -0.15240750f, 0.15305492f, -0.07852346f, 0.11820126f, 0.13165946f, 
    0.03529129f, 0.02042228f, 0.16762704f, 0.04064959f, 0.11437087f, 0.00643052f, -0.06852742f, 0.09576821f, 
    0.23452756f, 0.08978711f, 0.12395099f, -0.01829242f, 0.04932680f, 0.03784455f, -0.22517633f, -0.06933735f, 
    0.08906637f, 0.19805861f, -0.10600125f, 0.17395774f, 0.31686488f, 0.09842283f, 0.09761674f, -0.26139718f, 
    0.02835884f, 0.04123247f, -0.06803147f, 0.06845973f, -0.06412880f, 0.08970974f, 0.00371362f, 0.08948894f, 
    0.07432371f, -0.13889311f, -0.09525955f, -0.18036680f, -0.12778501f, -0.08566605f, 0.03931080f, -0.03461828f, 
    -0.02989773f, 0.04879496f, -0.12165390f, 0.06604624f, 0.31564754f, 0.06495836f, -0.00074291f, 0.04829150f, 
    0.04128278f, -0.09807132f, -0.08918337f, 0.13741121f, 0.02292221f, -0.01814950f, -0.05310825f, 0.02077244f, 
    -0.02835460f, 0.14150208f, 0.00946469f, 0.42293301f, -0.00186751f, 0.04661539f, -0.01638369f, -0.06992433f, 
    0.06468157f, 0.00704792f, -0.05366275f, -0.02479587f, 0.21706808f, 0.11739369f, 0.10854720f, 0.01292005f, 
    -0.14320000f, 0.09951711f, 0.01879371f, -0.01146879f, 0.01667260f, 0.07907677f, -0.05820962f, -0.06449942f, 
    -0.00662971f, 0.22341761f, -0.11611235f, -0.19045526f, 0.07121379f, -0.00819714f, 0.08678292f, -0.06051455f, 
    0.07065950f, -0.01897589f, -0.03885788f, 0.01933878f, -0.08322722f, -0.06059480f, 0.20755629f, -0.07463746f, 
    0.04118751f, 0.01178094f, 0.00916440f, 0.06378986f, 0.02994739f, 0.07345978f, -0.09068514f, 0.00530438f, 
    -0.02230093f, -0.01317414f, -0.05839457f, -0.21857341f, -0.06277731f, 0.01474767f, 0.15031025f, 0.00568523f, 
    0.00172029f, -0.07130099f, -0.04225253f, 0.00646505f, -0.06968499f, -0.14938110f, 0.00567805f, 0.15754616f, 
    0.00459494f, 0.04448513f, -0.02586056f, 0.05112189f, 0.03904359f, -0.00136005f, 0.02512653f, -0.01251777f, 
    -0.07381745f, -0.14058077f, 0.15955162f, 0.04560146f, -0.14156424f, 0.11169194f, -0.05283576f, 0.00537590f, 
    -0.02752632f, 0.00861809f, 0.03092811f, -0.00910850f, -0.15828392f, -0.02382043f, -0.06926689f, -0.04629456f, 
    0.04389407f, 0.00774920f, -0.01055151f, -0.01669630f, -0.00256778f, 0.01928551f, -0.00713154f, -0.04843385f, 
    0.21826901f, -0.04193930f, -0.17158619f, 0.18582416f, 0.13569736f, -0.02661245f, -0.04237354f, 0.03075676f, 
    0.05140786f, 0.12383714f, 0.08315051f, 0.10710710f, 0.25506791f, 0.22059463f, -0.07271371f, 0.08854350f, 
    0.05823173f, 0.14878613f, -0.09314810f, -0.07732616f, 0.02195267f, 0.21123596f, 0.07264653f, -0.11010322f, 
    0.08885148f, 0.22485711f, -0.12942684f, -0.11603145f, 0.17307723f, -0.04965460f, 0.10263373f, 0.03447196f, 
    0.06223596f, 0.12020929f, -0.03882973f, 0.12117524f, 0.37432745f, -0.19117227f, 0.15744966f, -0.10323142f, 
    0.04003937f, 0.05349736f, -0.03544641f, -0.03032426f, 0.00221372f, 0.00511972f, 0.04261971f, -0.03613699f, 
    0.17467959f, -0.16437294f, 0.06195307f, 0.09569830f, 0.01723012f, -0.02197584f, 0.01133758f, 0.01641195f, 
    -0.13481216f, -0.04413178f, 0.05466769f, -0.09633202f, -0.23675795f, 0.11308207f, 0.03742777f, 0.10827596f, 
    0.03037656f, -0.04255001f, 0.11342708f, 0.02676374f, -0.01755492f, 0.14714418f, 0.04221432f, -0.04248927f, 
    -0.00021004f, 0.37021300f, -0.18772736f, -0.04644998f, 0.06079030f, -0.01643092f, 0.00939610f, -0.00656691f, 
    -0.06929572f, 0.05836207f, 0.10464741f, 0.25047079f, -0.11065469f, -0.03863464f, 0.13516730f, -0.03524344f, 
    -0.08920165f, 0.06437337f, 0.11972233f, -0.00913880f, -0.08225229f, 0.17032251f, 0.10839098f, -0.03220807f, 
    0.14032905f, -0.19941281f, -0.00375531f, -0.08255440f, 0.00708065f, 0.00614462f, 0.00509087f, -0.06094908f, 
    -0.04184777f, 0.03867494f, -0.08504201f, -0.06037900f, -0.08589978f, -0.06770758f, 0.17736761f, -0.09297346f, 
    0.13871124f, -0.01028492f, -0.08517707f, -0.00572458f, 0.07452759f, 0.06155959f, 0.10555719f, 0.02658847f, 
    -0.15173006f, -0.18213359f, -0.08194776f, 0.17127708f, 0.02331467f, 0.06588285f, 0.00295891f, 0.04347810f, 
    0.03541767f, -0.16058928f, 0.08498711f, 0.07653190f, -0.06480648f, -0.00934354f, 0.10375437f, -0.18322067f, 
    -0.19544679f, 0.07220725f, 0.05769697f, -0.20869929f, -0.10394585f, 0.01864587f, -0.05493624f, -0.07935199f, 
    -0.00629697f, 0.23586582f, 0.01576933f, 0.12634099f, 0.01523547f, 0.12550277f, -0.12262429f, -0.00226034f, 
    0.03204994f, -0.13934791f, 0.03342728f, -0.02801717f, 0.06459291f, 0.19432566f, -0.11903478f, -0.26748833f, 
    0.10784575f, -0.00728824f, 0.05655134f, -0.06428693f, -0.01464837f, 0.10390639f, 0.02917626f, -0.01924903f, 
    -0.18479337f, 0.05906646f, -0.18511166f, -0.03979492f, 0.06344155f, -0.04906574f, 0.06620643f, -0.03004708f, 
    -0.10410993f, -0.03840202f, -0.00450849f, -0.12677620f, 0.22266798f, -0.14727566f, -0.18675114f, -0.07322892f, 
    -0.05889473f, -0.06777642f, -0.02875209f, 0.02483846f, -0.07205303f, 0.03270330f, -0.07584748f, -0.03696301f, 
    -0.05230665f, -0.02285429f, 0.02824933f, -0.18598102f, -0.15159245f, 0.05373998f, -0.05196292f, 0.09079744f, 
    -0.02619980f, -0.13780132f, 0.14887480f, -0.10720295f, -0.22758983f, 0.07930515f, -0.15286711f, 0.00511979f, 
    -0.06109552f, 0.02408491f, 0.03532736f, 0.06688592f, -0.00224296f, -0.02497418f, -0.00717241f, 0.19167547f, 
    -0.10747771f, 0.18616773f, 0.19005333f, -0.08533909f, -0.02410756f, -0.01493354f, 0.10627812f, 0.00257105f, 
    0.03425952f, -0.05495476f, 0.00824307f, 0.13249120f, 0.16831672f, -0.00189584f, 0.03375629f, -0.19211259f, 
    0.15511727f, -0.02219189f, 0.09051937f, 0.12081148f, -0.09103759f, 0.12958661f, -0.00975939f, -0.00762157f, 
    -0.18009776f, 0.02693511f, 0.00115878f, -0.08245056f, 0.07793984f, -0.05197857f, 0.12497315f, 0.13064769f, 
    0.07600346f, 0.05677700f, -0.07228135f, -0.02709263f, -0.13944058f, 0.02186278f, -0.06930324f, 0.20239042f, 
    -0.07879510f, 0.18957336f, -0.11782766f, 0.05660610f, -0.05857944f, -0.00761044f, -0.03490772f, 0.19398813f, 
    -0.13923645f, -0.09000213f, -0.03807685f, 0.06127362f, -0.11284044f, 0.12881324f, -0.04065123f, 0.07808728f, 
    0.12403145f, -0.13276692f, 0.00365509f, -0.07595901f, 0.02619042f, -0.05572565f, 0.04105849f, -0.10749229f, 
    0.12291920f, 0.00484750f, 0.00735770f, -0.08086295f, 0.03944071f, 0.10291784f, 0.06853147f, 0.03940064f, 
    -0.33310360f, 0.05060756f, 0.02006527f, -0.18264051f, -0.04317537f, -0.04034815f, 0.07217951f, -0.00836114f, 
    0.03975644f, -0.05141407f, 0.09398332f, -0.07108179f, -0.01485981f, 0.01757092f, -0.01795589f, 0.08165688f, 
    0.09906822f, 0.12190714f, 0.03775763f, 0.13031471f, 0.05698940f, 0.05266080f, -0.09815679f, 0.03418510f, 
    0.33338198f, 0.05309908f, 0.18123636f, 0.11391780f, 0.02766095f, 0.04283994f, -0.08253713f, 0.16359064f, 
    -0.05913120f, -0.02679463f, -0.05501287f, 0.00083792f, 0.21672280f, -0.04291241f, 0.10180333f, 0.23253064f, 
    0.24230087f, 0.08179970f, 0.11358044f, 0.01745801f, 0.16773583f, 0.05651208f, 0.03209103f, -0.02119863f, 
    -0.06213912f, 0.17952301f, -0.10471796f, 0.13802449f, 0.09764107f, -0.08172778f, -0.22119862f, 0.09698216f, 
    0.05566721f, -0.03065150f, -0.16047008f, 0.04082217f, -0.48015648f, -0.28364512f, -0.09763471f, 0.02990664f, 
    -0.07354773f, -0.02861344f, -0.11800119f, -0.05255263f, -0.02113915f, -0.07940811f, 0.11546428f, -0.10471943f, 
    -0.05772517f, 0.21047978f, -0.20261209f, 0.02206124f, 0.01662345f, -0.08380544f, 0.12676273f, 0.07841430f, 
    0.07997141f, 0.12562443f, 0.02315253f, 0.08106501f, 0.15824197f, -0.01741583f, 0.09661090f, -0.08792487f, 
    -0.00067236f, 0.00544318f, 0.05202716f, 0.07796445f, 0.01469091f, 0.10328522f, 0.15201749f, 0.11208038f, 
    0.02513080f, 0.01747822f, 0.02170136f, -0.06734083f, -0.03453404f, -0.01170812f, 0.01214838f, -0.02560067f, 
    -0.02369903f, 0.03320708f, 0.00815791f, 0.05865530f, -0.07449993f, 0.01511213f, 0.05667750f, -0.05799196f, 
    -0.05522337f, 0.04710952f, -0.03182354f, 0.06140715f, 0.00881195f, -0.04577641f, -0.04856454f, -0.06832841f, 
    -0.01763264f, -0.02216638f, 0.06587783f, -0.04643983f, -0.04201666f, -0.05482708f, -0.06444983f, 0.00706433f, 
    -0.06357212f, -0.03384124f, 0.00158369f, 0.03352139f, 0.03037494f, -0.01145916f, 0.05228035f, -0.00079219f, 
    -0.00302105f, -0.03016616f, -0.05216008f, -0.05036280f, 0.02249775f, -0.01809889f, -0.05480883f, 0.05431036f, 
    -0.05417391f, -0.04191548f, -0.00431988f, -0.02266440f, 0.05966702f, 0.06068787f, 0.00736149f, 0.05799356f, 
    0.01698351f, -0.02525225f, 0.05735857f, 0.05107773f, 0.00858680f, -0.04182575f, -0.07892602f, 0.06127700f, 
    -0.02550057f, 0.00964964f, -0.02915614f, 0.00583101f, -0.04333843f, -0.05408180f, -0.00471011f, -0.02511857f, 
    -0.03777014f, -0.03937168f, -0.05264074f, -0.03798201f, 0.06226691f, -0.06537818f, 0.02386260f, 0.00297515f, 
    0.00660676f, 0.04669971f, -0.05971255f, 0.06098571f, 0.00381682f, -0.00650151f, 0.05998171f, -0.06708685f, 
    0.00173915f, 0.02577611f, 0.04605360f, -0.02664926f, -0.06571040f, 0.01583081f, 0.00084434f, -0.06503284f, 
    -0.06712902f, 0.05769489f, -0.04422202f, -0.05566569f, -0.03816960f, 0.02060030f, -0.04558191f, 0.01800257f, 
    0.06624515f, -0.03178538f, -0.06004025f, -0.06779753f, 0.02018624f, 0.00059971f, 0.00297993f, -0.01429031f, 
    0.03078158f, -0.00444244f, -0.00673407f, -0.04758425f, -0.04800275f, -0.02830208f, -0.07127145f, -0.02970455f, 
    -0.07171184f, 0.02348322f, -0.00740238f, 0.03272590f, 0.05309819f, -0.06526121f, 0.00365506f, 0.02481803f, 
    0.00881048f, -0.01332037f, -0.06903952f, -0.04783248f, -0.05784699f, -0.00134347f, 0.00984118f, 0.01757152f, 
    -0.01618764f, 0.02792414f, 0.02449713f, -0.05092212f, -0.00566599f, 0.01994820f, 0.01919385f, -0.06766227f, 
    -0.05975623f, -0.06600782f, -0.05790329f, -0.00911120f, -0.00994269f, 0.00866214f, 0.04203916f, -0.06453287f, 
    0.00836683f, -0.03225590f, 0.05250689f, -0.05314570f, 0.04935557f, 0.04874157f, 0.01190642f, -0.06524720f, 
    0.02640030f, 0.03962661f, 0.01461555f, -0.05139004f, 0.05659735f, 0.01027027f, -0.00003688f, 0.03839946f, 
    -0.03943423f, -0.07212732f, 0.00152434f, -0.02699840f, -0.03445829f, 0.02756845f, 0.04465354f, -0.03760057f, 
    -0.00639510f, 0.00612392f, 0.03973796f, -0.01248730f, -0.00865602f, -0.06172639f, -0.02525041f, -0.06804246f, 
    -0.04373655f, 0.03877689f, 0.03396739f, -0.04927334f, -0.03833254f, 0.03838428f, -0.00013935f, 0.01973866f, 
    -0.07461049f, -0.01480333f, -0.05121797f, 0.01472926f, -0.01457219f, -0.01484315f, 0.00149085f, -0.07038345f, 
    -0.02234387f, 0.01091638f, -0.03985848f, -0.05074315f, -0.03328717f, 0.00514458f, 0.01135881f, -0.04794421f, 
    0.00494505f, 0.03462764f, -0.07039809f, -0.00337634f, 0.00391742f, -0.05867500f, 0.04951438f, 0.04271226f, 
    -0.00611539f, -0.02131526f, 0.01341334f, 0.06107209f, 0.05748254f, -0.05050900f, -0.06780616f, 0.04298121f, 
    -0.04808576f, -0.05894307f, 0.00456122f, 0.05597719f, 0.04780157f, -0.05459066f, -0.06646776f, 0.04828449f, 
    -0.00749128f, 0.01868666f, 0.01691287f, -0.04060159f, -0.06093229f, -0.05475845f, 0.01196687f, 0.00257730f, 
    -0.06210449f, -0.05214944f, -0.02542334f, -0.03750427f, -0.05538426f, -0.05270913f, -0.04342503f, 0.00632301f, 
    0.01459325f, 0.05418861f, 0.02567978f, -0.00389298f, 0.02840568f, 0.05423973f, -0.02760310f, 0.04276440f, 
    -0.01547159f, 0.05577664f, 0.02452192f, -0.00016899f, 0.03188633f, -0.05067927f, -0.05461046f, 0.01650693f, 
    0.07159233f, -0.06343248f, 0.01134619f, -0.02403131f, -0.06027424f, 0.06026632f, 0.02123709f, -0.03256365f, 
    -0.05725447f, -0.07192490f, -0.04717111f, -0.05778170f, -0.06047630f, 0.02931600f, 0.01510392f, 0.05796276f, 
    -0.07264232f, -0.06959476f, -0.06233662f, -0.05675713f, 0.03443448f, -0.06848798f, 0.04778920f, 0.01303649f, 
    0.00842708f, 0.01354712f, 0.01751551f, -0.00418568f, -0.05464483f, -0.01955210f, 0.00056767f, -0.05471927f, 
    -0.02920922f, -0.00876190f, -0.04665934f, 0.03009657f, 0.03164101f, -0.04573494f, 0.01059914f, -0.00996968f, 
    -0.04100033f, -0.00102766f, -0.01477786f, -0.01405106f, -0.01773289f, -0.04530168f, -0.07390440f, 0.00667643f, 
    -0.06531043f, -0.03708963f, 0.01796232f, 0.04041481f, -0.02690109f, 0.01563352f, -0.00308814f, 0.05127137f, 
    -0.03124339f, -0.02690033f, -0.06379383f, 0.02056253f, -0.02865168f, -0.00113986f, -0.03856321f, 0.03492688f, 
    0.03698150f, -0.05207690f, -0.00732709f, -0.01862214f, 0.05209350f, 0.01014615f, -0.06723165f, -0.05353922f, 
    -0.05037370f, -0.07163151f, -0.07335182f, 0.03194968f, -0.05481017f, 0.06594782f, -0.06145503f, -0.00380246f, 
    -0.04587144f, -0.02466155f, -0.03227349f, -0.02234962f, -0.01247585f, -0.06120275f, 0.03085135f, 0.05305768f, 
    -0.00351816f, -0.01362613f, 0.02997122f, 0.03510919f, -0.05740459f, -0.01723955f, -0.05367873f, 0.00175383f, 
    -0.00841887f, -0.02571484f, 0.04570904f, -0.03567893f, -0.00258548f, -0.01387616f, -0.01569798f, 0.02478269f, 
    0.05599714f, -0.02157842f, 0.00875796f, 0.02640008f, -0.06507248f, -0.05913265f, 0.04731081f, 0.06414793f, 
    -0.07495297f, 0.05555758f, 0.04229719f, 0.01328614f, 0.01055921f, -0.06259573f, 0.06155229f, 0.03655130f, 
    0.00014232f, 0.01618387f, 0.01784218f, -0.00974607f, 0.06037308f, 0.02405718f, -0.00996483f, 0.01440637f, 
    -0.04731398f, 0.01221318f, -0.06779236f, -0.04800565f, -0.00383207f, -0.06500100f, -0.00623122f, 0.01178002f, 
    0.05176703f, 0.00255435f, 0.04717328f, -0.02437392f, 0.05852282f, -0.06248217f, 0.05116207f, 0.01836345f, 
    0.03939661f, 0.01279785f, -0.03673457f, 0.01629396f, -0.06949555f, -0.07001137f, 0.00287340f, -0.05488679f, 
    -0.00141090f, -0.06283557f, -0.08154127f, -0.07870694f, -0.04217314f, 0.01224639f, -0.05645837f, 0.06628468f, 
    -0.00054884f, -0.06555051f, -0.01163074f, 0.03175537f, 0.04451958f, 0.05688576f, -0.00347573f, 0.02710481f, 
    -0.05079770f, 0.06354021f, 0.06665079f, -0.07557731f, -0.02937831f, 0.05783080f, -0.06038358f, -0.05253286f, 
    -0.08162477f, -0.00819473f, 0.05487730f, -0.06117991f, -0.04771755f, 0.03672330f, -0.00345988f, -0.03928496f, 
    -0.04676434f, -0.04053816f, -0.06485377f, 0.06204100f, -0.02854202f, -0.05938021f, -0.07385680f, -0.04625474f, 
    -0.00184532f, -0.07472610f, -0.07474215f, -0.03255600f, -0.04978546f, -0.05132739f, -0.07124451f, -0.07626521f, 
    -0.05413746f, -0.04866998f, 0.04367927f, 0.03079486f, 0.02744193f, 0.02304701f, -0.01387606f, -0.01118138f, 
    -0.02526347f, -0.05116596f, 0.00218553f, 0.06092529f, 0.05082832f, -0.06253848f, 0.03544961f, 0.05135671f, 
    0.03776453f, -0.02130367f, -0.02483211f, 0.03987440f, -0.03290658f, -0.00736615f, -0.06020141f, 0.01294948f, 
    -0.00710414f, -0.02085236f, -0.01193741f, 0.03886643f, -0.03485869f, -0.03862155f, 0.02472918f, 0.01781336f, 
    -0.03867996f, 0.05235586f, -0.00295963f, 0.06247759f, -0.05544957f, -0.04230588f, -0.06613950f, -0.03500236f, 
    0.00112148f, -0.03876750f, 0.01170844f, -0.03521326f, -0.02659909f, -0.03375170f, -0.05882853f, -0.00226217f, 
    -0.02469814f, -0.08401767f, 0.02954516f, -0.06018521f, -0.03198576f, -0.06019242f, 0.04782799f, -0.07488959f, 
    0.02128890f, -0.02676428f, 0.01781296f, -0.03139016f, -0.07016473f, -0.08682103f, 0.04141746f, 0.03066304f, 
    -0.06319277f, -0.01021201f, -0.01908236f, -0.00913133f, 0.05074726f, 0.00754015f, 0.03255695f, 0.05543692f, 
    -0.07668871f, -0.01686428f, -0.06914859f, -0.05819495f, 0.02608994f, 0.04063339f, 0.01323467f, 0.00619371f, 
    0.01884742f, 0.03073371f, 0.02154178f, 0.04058743f, -0.05970976f, -0.02600043f, -0.00855579f, -0.00420699f, 
    -0.00695051f, -0.06486449f, -0.05853213f, 0.05904890f, -0.06807527f, 0.02321733f, -0.03507378f, -0.00026785f, 
    0.05638283f, 0.00269019f, -0.03162641f, 0.04742593f, 0.06432004f, 0.05716425f, -0.01290013f, 0.05982453f, 
    0.05620603f, -0.02514451f, 0.04044134f, -0.02508479f, -0.01483935f, 0.04065360f, -0.04150103f, 0.02547767f, 
    -0.09131198f, 0.06025646f, 0.10028601f, -0.01393618f, -0.10020161f, -0.11144117f, -0.01035794f, 0.08457164f, 
    -0.10235595f, -0.02334606f, -0.06367347f, -0.10381100f, -0.10560493f, 0.04103959f, -0.10148618f, -0.02921343f, 
    0.02120357f, -0.11681011f, -0.08692899f, 0.10022232f, -0.08275113f, -0.10362881f, -0.02271166f, -0.07824153f, 
    -0.14236066f, 0.06409977f, 0.18840151f, 0.12760751f, -0.11029674f, -0.00736224f, 0.03412014f, 0.03865421f, 
    -0.18407807f, -0.05533294f, 0.00343485f, 0.00367278f, 0.20915803f, 0.02359156f, 0.14998969f, 0.25549278f, 
    0.00434380f, -0.11890109f, 0.03357602f, 0.00965945f, -0.03462839f, -0.02906223f, 0.04580957f, 0.17287281f, 
    -0.11386068f, -0.10934793f, -0.02337635f, 0.00432520f, 0.04259136f, 0.02715197f, 0.05420485f, -0.09319583f, 
    -0.00593284f, 0.08418906f, -0.08170630f, -0.01449216f, 0.28150213f, 0.00659033f, -0.08536767f, -0.05638772f, 
    -0.01535359f, 0.12406822f, -0.00799674f, -0.00137169f, 0.02665566f, -0.02326884f, 0.06484287f, -0.02168361f, 
    -0.01292543f, -0.27794802f, 0.08023947f, 0.13101822f, -0.00180294f, 0.06348957f, -0.08747903f, -0.06535874f, 
    -0.05591606f, -0.07475632f, 0.09851401f, -0.05094137f, 0.19406104f, 0.06666509f, 0.13831086f, -0.10445637f, 
    0.19499053f, -0.02149268f, -0.09058868f, 0.15423602f, -0.15668453f, -0.06964593f, -0.18214914f, 0.02454789f, 
    -0.20065033f, -0.01425149f, -0.01563545f, 0.12231714f, 0.03285301f, 0.00751860f, 0.00216273f, 0.01529659f, 
    -0.04324554f, -0.11633913f, 0.10917282f, -0.03379639f, 0.46529818f, -0.11558958f, 0.21986127f, 0.28885913f, 
    -0.04262386f, 0.07153231f, -0.06441719f, -0.02001703f, -0.07240076f, 0.12692337f, -0.13052829f, 0.16759524f, 
    0.29368600f, 0.11064246f, 0.09698197f, -0.08427031f, 0.02748474f, 0.05996208f, 0.07404270f, -0.03895890f, 
    -0.16502997f, 0.10973523f, -0.09701173f, 0.02008509f, 0.28104386f, 0.21964097f, 0.11064715f, 0.20226666f, 
    0.11356061f, 0.01429447f, 0.11013510f, 0.00128994f, -0.16011299f, 0.09007250f, -0.08143528f, 0.13787591f, 
    -0.02114881f, -0.03010233f, -0.11634871f, -0.04193289f, -0.02431649f, 0.01759708f, 0.00074304f, 0.05792474f, 
    0.02514573f, 0.00450970f, -0.12395755f, 0.00978484f, -0.28000405f, -0.23542912f, 0.00856391f, -0.02265644f, 
    -0.00116858f, -0.05042642f, 0.00439582f, 0.03788166f, -0.06104407f, 0.03555053f, -0.04757285f, 0.12284633f, 
    0.05197332f, 0.12600419f, -0.08765075f, -0.07388421f, 0.06045561f, -0.00396376f, -0.02189359f, 0.05681243f, 
    -0.03798134f, -0.00367058f, 0.01765146f, -0.12654452f, -0.05089702f, 0.01232210f, 0.14128532f, -0.04185214f, 
    0.01300091f, 0.03528903f, -0.00176465f, 0.04637851f, 0.02665347f, 0.02195808f, -0.06031485f, 0.06795096f, 
    0.25245008f, 0.05436428f, 0.01444628f, -0.16868797f, 0.12116913f, -0.06432500f, -0.10428116f, 0.09373181f, 
    -0.00574323f, 0.00713318f, 0.08332296f, 0.01331121f, -0.23616616f, 0.20650092f, 0.12038315f, -0.11393052f, 
    0.21918169f, 0.00147509f, -0.03806324f, -0.05993319f, 0.21869268f, 0.04311544f, -0.13041396f, -0.10645169f, 
    0.11993423f, 0.14925937f, 0.07999281f, 0.16762577f, 0.07636794f, -0.15977578f, 0.22729373f, -0.00573399f, 
    0.10370031f, 0.00665182f, 0.01765991f, 0.05034177f, 0.53511739f, -0.10085477f, 0.13061927f, 0.05454945f, 
    0.04540581f, 0.03551066f, 0.02343238f, 0.02308604f, -0.12931980f, 0.03985412f, -0.10285027f, -0.08501166f, 
    -0.11811665f, -0.08858518f, 0.32608888f, -0.12400488f, -0.00675396f, -0.07857078f, 0.06453873f, -0.05101705f, 
    -0.03835098f, -0.18044801f, 0.09802621f, 0.09052438f, -0.22415230f, 0.09623669f, -0.14875712f, -0.00844068f, 
    0.08373465f, 0.12214223f, 0.15581904f, -0.05185459f, 0.01397775f, 0.01273722f, -0.11855729f, 0.09730925f, 
    -0.09773801f, -0.11542322f, 0.16134118f, 0.11636212f, -0.07167391f, 0.07856749f, -0.04232518f, -0.08404514f, 
    -0.01859288f, -0.12308715f, 0.14558291f, 0.17852204f, -0.21575417f, -0.07206328f, -0.06197079f, 0.03984589f, 
    0.13363747f, -0.07096998f, 0.11009862f, 0.03712024f, -0.09228613f, 0.09605334f, 0.03081388f, -0.04558222f, 
    -0.17270949f, 0.08333294f, -0.13091835f, -0.20975576f, 0.01552921f, -0.19232395f, 0.08412613f, 0.05324200f, 
    0.05079500f, -0.02119513f, -0.14127466f, -0.09198978f, -0.32807049f, 0.32059264f, -0.24652547f, 0.05704111f, 
    0.03155458f, 0.16225320f, 0.06832384f, 0.13126691f, -0.05436614f, 0.07388287f, 0.29302198f, 0.18857799f, 
    0.07073023f, -0.20921645f, 0.35591918f, 0.23072259f, -0.04863797f, -0.00668594f, -0.10979503f, 0.01204287f, 
    -0.16436630f, 0.04249622f, 0.17847633f, 0.18771751f, 0.22591116f, 0.05629027f, -0.03712783f, -0.00980669f, 
    -0.01200289f, -0.00945028f, -0.04437556f, -0.04264320f, 0.07296991f, -0.03354823f, 0.04809892f, -0.09043638f, 
    0.04546592f, 0.03920123f, -0.16092111f, 0.20848760f, -0.04293000f, 0.23768301f, 0.00314373f, 0.13061282f, 
    0.05530820f, -0.16234675f, -0.01745636f, -0.08873154f, 0.06118687f, 0.08892190f, 0.10588171f, -0.16842519f, 
    0.14077364f, -0.00346988f, -0.09062909f, -0.17598285f, -0.17988718f, -0.00319722f, 0.18446516f, 0.02996519f, 
    0.33052504f, 0.12741199f, 0.08706047f, 0.01681045f, 0.01188343f, 0.03456990f, 0.06931608f, -0.09421333f, 
    0.10518381f, 0.00084316f, 0.05791905f, -0.01723349f, 0.13569747f, -0.20033969f, 0.31267810f, 0.01302659f, 
    -0.00671558f, -0.27358541f, 0.03135076f, 0.07780039f, -0.02705902f, 0.06913208f, -0.25246298f, -0.04427023f, 
    -0.05115879f, 0.00614664f, -0.05882979f, 0.06558684f, 0.00762649f, -0.05665569f, 0.06507232f, -0.01610608f, 
    -0.03203148f, 0.02476832f, -0.02279979f, -0.00531811f, -0.06903669f, -0.01038946f, 0.04687482f, -0.04376806f, 
    -0.01296521f, -0.01432415f, -0.01136212f, 0.00739675f, -0.06765307f, -0.02647383f, -0.05857893f, 0.02870223f, 
    0.01313143f, 0.05240702f, -0.02142464f, -0.07169635f, -0.00277917f, 0.03616522f, 0.06629886f, -0.05899021f, 
    0.03065390f, -0.02229989f, -0.00079954f, -0.04580054f, 0.00246252f, 0.04262102f, -0.00697426f, -0.06020300f, 
    0.02372600f, -0.07563770f, 0.06335770f, -0.04464899f, -0.00593357f, 0.04831522f, 0.01018107f, 0.01804493f, 
    0.04416785f, -0.05735545f, 0.03104713f, -0.05237354f, 0.05827627f, 0.02270206f, 0.00248838f, -0.03754311f, 
    -0.00221420f, 0.04472451f, -0.04915155f, 0.00987936f, 0.02733718f, -0.04914083f, -0.05579370f, 0.06053686f, 
    -0.02563406f, 0.01675026f, -0.05473347f, 0.01091621f, -0.00015326f, -0.03507255f, -0.03947352f, -0.02501695f, 
    0.03717750f, -0.04380744f, 0.00224693f, 0.02704908f, -0.02699255f, 0.07070361f, 0.00572921f, 0.03533506f, 
    -0.05319912f, 0.02708936f, 0.05552370f, -0.01432601f, -0.03543394f, -0.06296852f, 0.05231670f, -0.03619616f, 
    -0.05607491f, -0.06647977f, 0.02319154f, -0.04391974f, -0.03028555f, 0.06590614f, -0.00127809f, -0.01723571f, 
    -0.02053012f, 0.06786337f, -0.02832471f, -0.04658065f, 0.03483296f, -0.02207938f, -0.00490390f, -0.00269540f, 
    -0.04360072f, -0.03136435f, 0.03883128f, 0.04086283f, -0.05885416f, 0.04102332f, -0.02501506f, 0.06050007f, 
    -0.01797676f, -0.07500125f, -0.04797192f, -0.00190607f, -0.01783938f, 0.04338575f, -0.02808691f, -0.07097876f, 
    -0.06917359f, 0.03802774f, 0.03361863f, -0.01946312f, -0.03398531f, -0.04518797f, -0.07332551f, -0.05989559f, 
    -0.05787531f, -0.04533463f, 0.02223280f, 0.02103717f, 0.03336735f, -0.04464233f, 0.04008545f, -0.03233491f, 
    -0.07203493f, 0.00472085f, 0.05227234f, 0.05238861f, -0.06353257f, -0.02114821f, 0.01823598f, -0.05379174f, 
    0.02287198f, -0.01033978f, 0.04488249f, 0.02836984f, 0.01069955f, -0.05610787f, -0.02316059f, -0.06399640f, 
    -0.03058743f, -0.04393848f, -0.04946784f, -0.03029206f, -0.01969011f, -0.03335377f, -0.04760490f, -0.00749294f, 
    0.02831893f, -0.01532864f, 0.05601643f, 0.02529707f, 0.05756905f, -0.00470680f, 0.03900062f, -0.00999039f, 
    -0.06326292f, -0.06196986f, -0.05920101f, -0.05141469f, -0.05987878f, 0.05511016f, 0.06666179f, 0.03123470f, 
    0.01152440f, -0.00638889f, 0.05025212f, -0.04798014f, -0.00813692f, 0.03131874f, 0.01196465f, -0.01144711f, 
    -0.00362225f, -0.01303335f, 0.03410249f, 0.01705198f, 0.02074585f, -0.01569821f, -0.00171383f, -0.05881241f, 
    -0.02009187f, -0.03913200f, 0.05461289f, 0.00642777f, -0.07359245f, 0.01665779f, -0.02442870f, -0.05677800f, 
    0.06485699f, -0.05174900f, -0.04699676f, -0.05928168f, 0.04195838f, 0.03687360f, -0.01652860f, 0.03792499f, 
    -0.03519434f, 0.02635659f, -0.05918185f, -0.03824493f, 0.03672194f, -0.06144116f, -0.06558663f, 0.02066828f, 
    -0.07171604f, 0.00223564f, 0.02415069f, 0.05492609f, -0.04022223f, 0.03851328f, -0.07431052f, 0.00347376f, 
    -0.01373210f, 0.00206149f, -0.04947321f, -0.06089948f, -0.07567411f, 0.04024567f, 0.02678675f, -0.04464839f, 
    -0.01868350f, 0.05395316f, 0.01492510f, 0.02163132f, -0.05572109f, 0.02939309f, 0.03520871f, 0.04458632f, 
    -0.04240682f, -0.05897623f, -0.03601860f, -0.07343280f, 0.03015633f, -0.00296416f, 0.02477546f, 0.05289401f, 
    -0.04421143f, 0.04976880f, -0.04955919f, -0.01650161f, 0.00853163f, -0.04690989f, -0.07276569f, -0.00174440f, 
    0.01893130f, 0.03454228f, 0.06096816f, -0.02193889f, 0.00914849f, -0.07424942f, -0.01101076f, -0.06779650f, 
    -0.00228624f, -0.05579280f, -0.02157854f, -0.05702419f, -0.05354090f, -0.07376647f, 0.01651055f, -0.06948030f, 
    0.06546417f, 0.01780041f, 0.03543613f, 0.06588628f, 0.03545595f, -0.03453417f, -0.01205725f, -0.07011336f, 
    -0.04920451f, -0.04692731f, -0.03634924f, 0.01281447f, 0.00353845f, -0.03529271f, 0.01490737f, -0.04571997f, 
    -0.01133447f, -0.06365837f, -0.01620553f, 0.04132807f, -0.02974365f, 0.04051861f, 0.00845220f, -0.05111336f, 
    -0.06710892f, -0.00913665f, 0.03765574f, 0.04101111f, -0.05171274f, -0.03751072f, 0.06234170f, -0.05004558f, 
    -0.00055871f, -0.02520536f, -0.04822545f, -0.00650542f, 0.05364196f, 0.01427053f, 0.00989644f, 0.05437002f, 
    -0.04135676f, 0.00700951f, 0.03136361f, 0.02676352f, -0.03516956f, 0.06258873f, -0.04307035f, 0.04177956f, 
    0.04427581f, -0.05065443f, -0.05259839f, 0.02920052f, 0.02458438f, -0.06411224f, -0.05831506f, 0.02652665f, 
    -0.03825270f, -0.00454810f, 0.02105884f, 0.04048736f, 0.00761320f, 0.02114677f, 0.04004651f, -0.06000262f, 
    -0.06133459f, -0.02627545f, -0.07139032f, -0.00488694f, -0.05474108f, 0.01104159f, -0.06688600f, -0.01516070f, 
    -0.02199635f, -0.01615446f, 0.05788932f, -0.07488709f, -0.06357751f, 0.01036860f, 0.00138833f, -0.03117645f, 
    0.06549327f, -0.00711292f, 0.00621771f, 0.06078567f, 0.00496199f, -0.05371938f, -0.04839307f, -0.00336242f, 
    0.01144506f, 0.03218712f, -0.07070759f, 0.06315149f, 0.05917820f, -0.04839642f, 0.01658815f, -0.03272241f, 
    0.06180242f, -0.07563341f, -0.05942192f, 0.03139429f, -0.06922889f, 0.01033749f, 0.00833817f, 0.02987174f, 
    0.06007815f, 0.01441221f, -0.02956169f, -0.07437760f, -0.05823146f, -0.03116516f, 0.01876835f, -0.03364202f, 
    0.01965035f, 0.12996922f, -0.25421989f, -0.05555647f, 0.07356810f, 0.11236879f, -0.06661728f, -0.05139378f, 
    0.03445816f, -0.03860256f, -0.04304926f, -0.13867751f, -0.44574660f, -0.19271372f, -0.10586200f, 0.05600814f, 
    0.12080129f, 0.06584502f, -0.05288433f, 0.06374457f, 0.13851115f, 0.08334736f, 0.06348193f, 0.08156937f, 
    0.23881482f, 0.02333923f, 0.19053893f, -0.07580075f, 0.04665298f, 0.07486950f, 0.08284578f, -0.08279223f, 
    0.07425021f, -0.20432228f, 0.03942827f, 0.12670939f, -0.12512767f, -0.13074523f, -0.05833566f, -0.00612278f, 
    0.06946604f, 0.05098662f, 0.09138439f, -0.05445454f, -0.11395583f, 0.09575559f, -0.06102536f, 0.07672695f, 
    -0.21293274f, 0.00033850f, 0.03020931f, 0.08687516f, -0.00402158f, -0.04141917f, 0.09274295f, -0.10622834f, 
    -0.03084725f, 0.07088246f, 0.01776411f, -0.00419391f, -0.02959166f, 0.24285679f, 0.00283847f, 0.16382058f, 
    -0.13710704f, 0.06667974f, 0.04015778f, -0.13256092f, 0.12538488f, 0.03362589f, 0.08915995f, 0.02809443f, 
    -0.14080131f, -0.15961222f, 0.21433970f, 0.21660735f, -0.09123143f, -0.04044620f, 0.01535790f, 0.00967462f, 
    0.03606430f, 0.00389181f, 0.06228722f, -0.11018766f, -0.16384400f, -0.02137383f, 0.11678648f, 0.05394847f, 
    0.18757984f, 0.13376045f, 0.06881764f, 0.02253430f, 0.02556436f, 0.03846245f, 0.05728497f, 0.06329816f, 
    0.16477036f, -0.02821694f, 0.14850897f, -0.08412142f, -0.03636869f, -0.05229050f, 0.03478127f, 0.12167462f, 
    -0.05876778f, -0.02634107f, 0.05264826f, 0.05321655f, -0.19952334f, 0.02657266f, -0.06859835f, -0.39483619f, 
    -0.02693399f, 0.00574478f, -0.00550677f, 0.01683369f, 0.09065506f, -0.01714262f, 0.09142800f, -0.03156918f, 
    -0.11536556f, -0.10148982f, 0.06751647f, 0.05015559f, -0.04217396f, -0.01856027f, -0.02041132f, 0.07541467f, 
    0.02158749f, 0.06566530f, 0.03657013f, 0.02510760f, 0.08679914f, 0.06904520f, 0.14481418f, 0.12926233f, 
    0.12204149f, -0.07243288f, 0.09173011f, 0.12184194f, 0.06339627f, 0.00434963f, 0.12081868f, -0.05202591f, 
    0.01972722f, 0.14585595f, -0.19149858f, 0.13672142f, 0.00364490f, -0.04903316f, 0.03773472f, -0.22034462f, 
    -0.01745586f, 0.08541797f, 0.01628128f, 0.09919623f, -0.12228859f, 0.17740840f, 0.10461312f, -0.09938013f, 
    0.10369133f, -0.10632297f, -0.03372744f, -0.04555440f, 0.04698130f, 0.03859611f, -0.03124176f, 0.02284058f, 
    0.21644013f, -0.14048141f, -0.12334298f, -0.11537648f, -0.09861541f, -0.11846533f, 0.05217770f, 0.05966345f, 
    0.05265009f, -0.06217518f, -0.02374236f, 0.18203031f, 0.07600427f, -0.01476697f, 0.17087346f, 0.08701349f, 
    -0.06240345f, -0.05087245f, 0.01697301f, -0.14050373f, 0.11071426f, 0.01049157f, 0.08614051f, 0.07125278f, 
    0.05109376f, -0.07183174f, 0.05566656f, -0.04476923f, 0.00775833f, -0.04345213f, -0.06830183f, -0.00910566f, 
    0.01435896f, -0.01623053f, -0.01953853f, -0.05940406f, 0.03135291f, -0.05543911f, -0.05250063f, 0.00343411f, 
    0.05566398f, 0.05131493f, -0.08023620f, 0.03812120f, 0.05412107f, -0.00518849f, -0.04872968f, 0.01853636f, 
    0.02591185f, -0.03472950f, -0.03380088f, 0.04478795f, 0.00520766f, 0.03501746f, 0.05953291f, -0.01620214f, 
    0.00454279f, 0.02838712f, 0.01065420f, -0.04155624f, -0.04601172f, 0.03504810f, 0.02840372f, -0.02949037f, 
    0.06157934f, 0.04682781f, -0.06176459f, -0.06759308f, -0.00622890f, -0.02919831f, -0.07704272f, -0.06827292f, 
    -0.04215040f, 0.05654874f, -0.03945128f, -0.02437477f, -0.02196770f, -0.04403516f, -0.06693954f, 0.03275105f, 
    -0.01872986f, -0.07529836f, 0.04565882f, -0.06721308f, 0.02948945f, -0.03372511f, -0.03012264f, 0.02143790f, 
    -0.04908443f, 0.05395331f, 0.02419504f, -0.05139745f, -0.00648605f, -0.00615921f, 0.02725086f, -0.05077425f, 
    0.02485309f, -0.01201214f, 0.04817255f, -0.05410368f, -0.02401936f, -0.02180567f, 0.00037906f, 0.02973967f, 
    0.00626640f, -0.02494143f, -0.00737123f, -0.05971801f, -0.07861875f, -0.07269315f, -0.00432551f, -0.07134006f, 
    -0.03290103f, -0.07687045f, -0.01984204f, 0.05159487f, -0.01586976f, 0.03981531f, -0.04853364f, -0.06316694f, 
    0.03748874f, -0.05907474f, 0.03157214f, 0.00275014f, 0.01576711f, 0.03508439f, 0.00447887f, -0.02939876f, 
    0.04631097f, 0.01526471f, 0.02049635f, 0.05068572f, 0.01806672f, -0.06649089f, -0.00348719f, -0.07462630f, 
    0.02653356f, -0.06215356f, -0.03535433f, 0.02953148f, 0.03928303f, -0.03511382f, 0.05687628f, -0.01949723f, 
    -0.06719170f, 0.03227898f, 0.06042942f, 0.05622831f, -0.07517831f, -0.04022116f, 0.00151717f, 0.02649778f, 
    0.00257559f, -0.07705612f, -0.03173955f, -0.07162937f, 0.01190860f, 0.01418159f, -0.05604863f, 0.02046181f, 
    -0.01714894f, 0.02752079f, -0.01255850f, -0.06712508f, 0.01178521f, 0.04677206f, 0.02235695f, 0.03225876f, 
    0.00407185f, -0.07297543f, -0.00651594f, -0.05722534f, 0.03775833f, -0.08083703f, 0.05258517f, 0.03968327f, 
    0.05946682f, -0.05196130f, 0.04881804f, 0.03165900f, -0.05868880f, -0.04072518f, -0.04521332f, 0.03692545f, 
    -0.01947937f, -0.04714233f, 0.03204603f, 0.06115458f, 0.01943978f, -0.07883876f, 0.01829570f, -0.06227711f, 
    -0.01478523f, -0.02611938f, -0.07864032f, -0.01847984f, -0.06406029f, -0.02531284f, 0.04186302f, -0.03909194f, 
    0.01920475f, -0.04799780f, -0.03667157f, -0.07906555f, -0.07472786f, -0.03204698f, 0.02713846f, 0.00681937f, 
    -0.04975226f, 0.04671001f, 0.01986953f, 0.04807429f, -0.01572465f, -0.04061983f, -0.03129615f, -0.06996417f, 
    0.05618948f, -0.03370874f, -0.06859421f, -0.02218551f, 0.01080558f, -0.00073662f, -0.06730099f, -0.00108785f, 
    -0.04498345f, -0.00963272f, -0.05303069f, -0.03918810f, 0.03692883f, 0.00270193f, 0.05741469f, -0.05965018f, 
    0.05043204f, 0.05670317f, 0.01818924f, -0.02342661f, -0.00402613f, -0.06367394f, -0.05028341f, -0.02397113f, 
    -0.01708903f, 0.06147717f, -0.02484910f, -0.04886967f, 0.03636660f, -0.03390134f, 0.02879428f, -0.05642769f, 
    0.00491535f, 0.06021268f, -0.03426567f, -0.06679459f, -0.08691648f, 0.05290743f, -0.03762161f, -0.02030592f, 
    -0.03237202f, 0.01827059f, -0.02830577f, 0.01191582f, 0.01555153f, -0.03223467f, -0.05560477f, -0.01004605f, 
    -0.03651467f, 0.02785899f, 0.03304252f, 0.01318971f, 0.00135904f, -0.06207395f, -0.02890914f, -0.04272518f, 
    -0.06991299f, 0.03989784f, 0.04429183f, -0.07326560f, 0.04742254f, 0.01108268f, -0.03448571f, -0.05288757f, 
    0.01375360f, -0.02915771f, 0.03314825f, 0.04716781f, -0.07347872f, 0.01832602f, -0.07596021f, 0.00365432f, 
    -0.04864654f, -0.00304286f, 0.02201731f, -0.03898216f, -0.07554461f, 0.00901518f, 0.05241804f, -0.06668887f, 
    0.06149440f, -0.07302705f, -0.01813192f, 0.03182977f, -0.04868030f, 0.05354776f, -0.06218784f, -0.00790376f, 
    0.05246980f, 0.02370857f, -0.02441163f, -0.00630661f, -0.06719995f, 0.04652192f, -0.05966398f, 0.00784830f, 
    0.02487967f, -0.04245063f, 0.03609591f, 0.03769696f, -0.04576007f, 0.01691505f, 0.04095444f, -0.00187588f, 
    -0.07576291f, 0.06104945f, 0.00894471f, -0.06807611f, -0.06707831f, 0.02384836f, 0.01570796f, -0.01938560f, 
    0.06591251f, -0.02988968f, -0.01707261f, -0.02889316f, 0.05010270f, -0.02164520f, 0.06917138f, 0.01025661f, 
    0.04431645f, -0.07649638f, 0.00645014f, 0.05716351f, 0.02582962f, -0.05259396f, -0.05342128f, 0.02232689f, 
    -0.07891041f, -0.04773567f, 0.02194740f, -0.02351979f, 0.01939508f, -0.06455833f, -0.04095393f, -0.04620976f, 
    -0.02638061f, 0.07642031f, 0.03116691f, -0.03223727f, 0.04631162f, -0.03845050f, 0.04106135f, 0.02020335f, 
    0.02603395f, 0.03496322f, -0.08752868f, -0.01620365f, 0.03946550f, -0.03814520f, -0.07115608f, -0.00693647f, 
    0.05970540f, -0.07669653f, -0.07724205f, -0.07640082f, 0.02158343f, 0.01670414f, -0.05994500f, -0.08391343f, 
    0.03578627f, 0.03492063f, -0.02355963f, 0.02042791f, -0.02679309f, 0.01651485f, -0.06175441f, 0.07345128f, 
    -0.01316460f, 0.00729461f, -0.01187724f, -0.07684990f, 0.06272230f, 0.01418750f, -0.00085665f, 0.01478588f, 
    -0.07100337f, -0.06704640f, -0.02590914f, 0.00956263f, -0.00679074f, -0.03980938f, 0.03807530f, -0.01480366f, 
    -0.06006710f, 0.01177725f, 0.02223570f, -0.04548804f, 0.01895453f, 0.01559060f, -0.00968371f, -0.06238412f, 
    -0.19217603f, 0.03605097f, -0.09092407f, -0.04805999f, 0.00604911f, 0.00249354f, 0.01996861f, 0.05274403f, 
    0.04311300f, -0.05960603f, 0.14143966f, 0.02251150f, -0.03481129f, 0.05393655f, 0.08691587f, -0.02878965f, 
    0.16702448f, 0.06960339f, 0.11631086f, -0.01408739f, 0.02592202f, -0.04171418f, -0.03835504f, 0.12103673f, 
    -0.36332932f, 0.15301195f, -0.07479055f, -0.03651854f, 0.09969948f, -0.07100781f, 0.06033924f, 0.03751055f, 
    0.05997743f, -0.00731719f, -0.11980604f, 0.25576681f, -0.19381034f, 0.06080930f, -0.05578690f, -0.13810316f, 
    -0.05822440f, 0.12552656f, -0.03663033f, -0.02793391f, -0.06672394f, 0.05141579f, -0.00444939f, 0.04543181f, 
    -0.11799624f, -0.03183086f, 0.05175528f, -0.07981670f, -0.00665024f, -0.09862774f, 0.12411525f, 0.07896379f, 
    -0.02446165f, -0.27623150f, 0.09090456f, 0.03538888f, -0.36768970f, -0.02479073f, -0.01681580f, -0.03655484f, 
    0.02184570f, 0.01390004f, -0.00365547f, -0.06690504f, -0.01201218f, 0.08214504f, 0.02580449f, 0.08434986f, 
    0.18553194f, 0.16225980f, 0.14253570f, 0.16474237f, 0.03321047f, -0.00241893f, -0.01042849f, -0.01047817f, 
    0.07652214f, 0.05463067f, 0.05893205f, 0.02877260f, -0.17666775f, 0.06934138f, -0.03830869f, 0.10119243f, 
    0.06700633f, 0.08588608f, 0.26482645f, -0.06096982f, 0.12378166f, 0.08454179f, -0.07785055f, -0.14567319f, 
    -0.16639744f, 0.14280422f, -0.19089600f, -0.21598022f, 0.05484020f, 0.13857780f, 0.04975974f, 0.10132962f, 
    0.04891073f, 0.05378427f, -0.00523749f, 0.10183770f, -0.75587040f, 0.16232684f, -0.24608470f, -0.14868672f, 
    0.16899945f, -0.13577266f, -0.06335888f, -0.03356266f, -0.05260842f, -0.05608775f, 0.24717569f, 0.06123948f, 
    -0.12604901f, -0.06025392f, 0.07400930f, 0.27264029f, -0.13106133f, 0.05891510f, -0.01413516f, 0.05259158f, 
    -0.04982725f, -0.01302666f, 0.11754122f, 0.03289636f, 0.12917082f, -0.08989020f, -0.09055159f, -0.00252731f, 
    -0.06576965f, 0.04811982f, -0.16496289f, 0.02977449f, -0.09162027f, -0.19245446f, -0.00684109f, -0.05359555f, 
    0.07475045f, -0.03328189f, 0.07252964f, 0.04707576f, 0.08689659f, 0.02133843f, -0.11412899f, -0.05081251f, 
    -0.01492144f, 0.03824924f, -0.03596501f, -0.06735503f, 0.16952202f, 0.03368544f, -0.03224301f, -0.24361455f, 
    0.08747817f, -0.04680886f, -0.02731147f, 0.01469951f, 0.08433022f, 0.03124782f, 0.00229057f, 0.06844828f, 
    0.12859085f, 0.03878395f, -0.19031170f, 0.23040980f, 0.13478667f, -0.03152084f, 0.04210089f, 0.07302549f, 
    0.08934756f, 0.00681833f, -0.00238849f, 0.05092721f, 0.12402628f, -0.05705648f, 0.20881510f, 0.13580589f, 
    0.01043847f, -0.01666135f, 0.02425038f, 0.12315296f, 0.02800421f, -0.06010800f, 0.04480593f, -0.05756642f, 
    -0.15426104f, -0.18730706f, 0.21837731f, -0.04095021f, -0.02563673f, -0.02097796f, 0.10596441f, -0.07749614f, 
    -0.05955517f, -0.13435546f, 0.00083627f, 0.05509577f, 0.17137979f, -0.05008952f, 0.08350275f, -0.14397822f, 
    0.06301855f, -0.11828517f, 0.12114163f, -0.09661487f, 0.00701850f, -0.05301093f, 0.05296312f, 0.17041963f, 
    0.05679170f, -0.32333946f, 0.00435350f, 0.09919623f, -0.04514010f, -0.02893902f, -0.04013326f, -0.03629693f, 
    -0.04584908f, -0.03627171f, 0.03847989f, 0.00241321f, -0.38464820f, 0.21547343f, -0.17802486f, 0.23352228f, 
    0.04947302f, -0.06959864f, 0.05484268f, 0.14938259f, 0.05914615f, -0.04659161f, 0.02237930f, -0.05097761f, 
    0.07458807f, 0.20507751f, -0.00841539f, -0.21148393f, -0.03876365f, 0.15202242f, -0.04448209f, -0.04048439f, 
    0.12559696f, 0.05016068f, -0.01084844f, -0.05008281f, 0.31521672f, 0.03327111f, -0.05544384f, -0.18922247f, 
    0.05886543f, -0.01765886f, 0.04748734f, -0.02065705f, 0.00677864f, -0.13627149f, -0.09499538f, -0.03705749f, 
    0.23477378f, 0.17329013f, 0.10489859f, -0.16686510f, -0.03176938f, -0.02587460f, 0.18380046f, 0.09412955f, 
    0.03883807f, 0.02639729f, -0.12589052f, -0.12414578f, 0.00066032f, 0.06748521f, -0.14438973f, 0.10775780f, 
    0.06579770f, 0.08467615f, -0.03053466f, 0.04386781f, 0.09769727f, -0.00657232f, -0.09963484f, 0.16353731f, 
    -0.07905880f, 0.07134509f, 0.06067408f, 0.19390608f, -0.00502556f, 0.07330281f, 0.03112208f, 0.06725495f, 
    0.01787626f, 0.13789438f, 0.01242438f, 0.10703100f, -0.23065107f, 0.37262592f, -0.23476024f, 0.06608438f, 
    0.03955799f, 0.04763201f, 0.15230316f, 0.09835185f, 0.04971664f, 0.08674277f, -0.03432401f, -0.01199794f, 
    -0.35147825f, 0.03654430f, 0.20091820f, 0.05336392f, -0.00278056f, -0.03429815f, 0.06465596f, -0.07241455f, 
    0.05921343f, 0.17417613f, 0.05830386f, 0.04072550f, -0.15947828f, -0.16527185f, -0.19340906f, -0.03604644f, 
    -0.01363004f, -0.03412348f, 0.07674479f, 0.05298243f, 0.12382365f, -0.03336785f, 0.17768334f, -0.09557218f, 
    0.21512541f, -0.10664206f, 0.11780383f, -0.15339360f, 0.05578648f, -0.09399590f, 0.06549821f, -0.00406594f, 
    -0.06156434f, 0.02483361f, 0.06763799f, 0.03242488f, 0.26780337f, -0.00362132f, 0.11711732f, 0.11110338f, 
    -0.06834223f, 0.00762458f, 0.03049962f, 0.00905479f, -0.03043198f, 0.00483670f, 0.03022384f, 0.08567735f, 
    -0.00771549f, -0.05801006f, 0.19474079f, 0.02503199f, 0.05332988f, 0.03074552f, -0.07528568f, 0.03974031f, 
    0.01871086f, 0.04498038f, 0.03028209f, 0.10415435f, -0.00486190f, 0.15958889f, -0.06008426f, 0.01129563f, 
    0.08086634f, 0.03073120f, 0.01493091f, -0.01909445f, 0.01490510f, -0.00559161f, 0.14494480f, 0.00674866f, 
    0.02988128f, 0.01872153f, 0.03950779f, 0.04221852f, -0.02497677f, -0.06846492f, 0.00340698f, -0.04696187f, 
    -0.02758133f, 0.00816217f, 0.00933054f, -0.02076082f, -0.03598779f, -0.00890733f, 0.05841524f, -0.00702484f, 
    0.00025206f, -0.04111917f, 0.02735238f, -0.01965704f, -0.03105083f, -0.07672033f, 0.06014182f, -0.00607660f, 
    -0.01483064f, -0.05778261f, 0.00954216f, -0.01683871f, -0.00919223f, 0.03669118f, -0.03994454f, 0.06823529f, 
    0.04906801f, -0.05467584f, 0.06739145f, -0.04279918f, -0.06937621f, 0.00486358f, 0.02822621f, -0.06100160f, 
    -0.01415445f, 0.05224610f, -0.02279264f, -0.05769363f, -0.05122155f, 0.02788166f, -0.06719685f, -0.05486709f, 
    0.02388929f, 0.04689688f, -0.04110215f, 0.00858356f, -0.05961666f, -0.07447378f, -0.07909179f, -0.07475106f, 
    0.01400268f, 0.02974080f, -0.04879760f, -0.01503768f, 0.06193013f, 0.02154111f, 0.05598420f, -0.06453437f, 
    0.01917353f, 0.01535817f, -0.03679341f, -0.01278184f, -0.05691264f, -0.00946715f, -0.01674634f, 0.02615802f, 
    0.02311913f, -0.05385082f, 0.02618063f, -0.07106285f, -0.00905162f, 0.06467909f, -0.05560599f, -0.02441066f, 
    -0.04469939f, -0.01761963f, 0.05954657f, 0.05334160f, 0.05661781f, -0.00701675f, 0.04212844f, 0.05451260f, 
    -0.07508612f, -0.06092665f, 0.02816478f, -0.01935040f, 0.00752469f, -0.02530050f, 0.01131956f, -0.02068499f, 
    -0.04245670f, 0.06105777f, -0.00909276f, -0.05907602f, -0.03877188f, 0.04842770f, -0.01361522f, -0.03084312f, 
    0.05840060f, -0.01573787f, -0.01782573f, -0.07180861f, -0.05566077f, -0.05952917f, 0.03370200f, -0.07679964f, 
    0.02674474f, 0.03254162f, -0.05176104f, -0.05435397f, -0.06353087f, -0.03529206f, -0.00608877f, -0.03555813f, 
    0.06450793f, 0.05362957f, -0.00490326f, -0.03948741f, 0.01410349f, -0.04236400f, 0.06682176f, -0.07033151f, 
    0.06492569f, -0.03534451f, 0.02842692f, -0.04579075f, 0.03382955f, 0.04366884f, -0.05589500f, 0.04388145f, 
    0.01550205f, 0.05388840f, -0.03533003f, 0.06055674f, 0.05497729f, -0.00834244f, -0.03928770f, 0.05489475f, 
    0.06178469f, 0.03446662f, -0.04682911f, 0.00826204f, 0.02667917f, 0.04599071f, -0.02502579f, -0.01523535f, 
    -0.07251360f, -0.00179874f, -0.02129651f, -0.04870557f, -0.00681414f, -0.07685915f, 0.03729694f, 0.00670030f, 
    0.01380854f, -0.01172358f, -0.02724500f, 0.00243666f, 0.01591450f, -0.02064466f, -0.05245920f, 0.02994572f, 
    0.06224861f, -0.06162205f, -0.03234484f, -0.01869995f, -0.06718713f, -0.06069793f, -0.04677319f, -0.06046854f, 
    0.00745354f, -0.05724165f, 0.04646170f, 0.04089126f, -0.02789156f, -0.06276717f, 0.04620964f, 0.02647744f, 
    0.05251738f, -0.01302359f, -0.07361685f, -0.00719118f, 0.06563640f, -0.07233281f, 0.03947806f, -0.03758423f, 
    -0.06097347f, 0.04685463f, 0.01652103f, -0.05372524f, 0.02031752f, -0.04657123f, -0.04113415f, -0.03220594f, 
    -0.07146338f, -0.03540040f, 0.02833261f, 0.01093934f, 0.06595348f, 0.03628541f, -0.02057196f, 0.06387467f, 
    0.00943147f, 0.01288541f, -0.07228112f, -0.00947206f, -0.00761453f, 0.04875144f, 0.00160511f, -0.00407280f, 
    0.01554086f, 0.02347887f, 0.04797364f, -0.01148434f, 0.02106884f, -0.05291771f, -0.05017662f, 0.04739563f, 
    -0.02287356f, -0.04416502f, 0.02803227f, -0.02324346f, -0.04680895f, -0.00384861f, -0.06215620f, -0.05633866f, 
    -0.00254139f, 0.02113144f, -0.06374629f, -0.00332717f, -0.04389670f, -0.04439572f, -0.03239748f, 0.00376508f, 
    0.00049422f, 0.04924863f, 0.00209251f, 0.03042626f, -0.04230722f, -0.06175068f, -0.05896339f, -0.03849258f, 
    -0.01530446f, 0.05945346f, -0.04031303f, 0.00233230f, -0.07193932f, 0.05177905f, -0.01370036f, -0.02813404f, 
    -0.01432698f, 0.05844574f, 0.04834574f, -0.06038861f, 0.05622099f, -0.07619867f, -0.04606266f, -0.06490774f, 
    0.06722008f, 0.03248674f, -0.04055956f, -0.06401434f, -0.03373490f, -0.03295017f, -0.05089184f, 0.06020272f, 
    -0.04070689f, 0.01977763f, -0.06314787f, 0.04376345f, 0.04027445f, -0.06689221f, -0.03991730f, 0.02254248f, 
    -0.05541871f, -0.04070050f, 0.05766445f, -0.00341391f, 0.00864710f, -0.04651706f, -0.03389719f, -0.02537848f, 
    0.06036938f, 0.00586594f, -0.01969809f, -0.06635344f, -0.07338276f, 0.03856011f, 0.01368498f, 0.04732935f, 
    0.04502281f, 0.03051710f, -0.02722312f, 0.03559238f, 0.00474823f, -0.07874302f, -0.04063923f, -0.01438042f, 
    0.01368685f, -0.03666181f, -0.03045236f, -0.04273681f, 0.01012494f, -0.03751922f, -0.04435661f, -0.00335174f, 
    0.00812506f, -0.06407631f, -0.01335648f, -0.06540544f, 0.06699584f, 0.01227467f, 0.04823626f, 0.03778247f, 
    -0.06238434f, -0.03583509f, 0.02092882f, 0.03548384f, 0.01478304f, -0.03942443f, -0.02009775f, -0.02920240f, 
    -0.01723484f, -0.02219009f, 0.00684847f, -0.00090172f, 0.02541182f, -0.01161041f, -0.08083957f, -0.06138632f, 
    0.02718487f, -0.05077704f, -0.00844943f, -0.01958409f, -0.06946465f, -0.03036661f, 0.01926264f, 0.03850101f, 
    -0.07035619f, 0.03086513f, -0.00292805f, -0.01630375f, 0.00772402f, 0.06764814f, -0.07085638f, -0.06925923f, 
    0.04248188f, 0.02005676f, -0.00475686f, 0.04937724f, 0.03232102f, -0.04703212f, -0.06317094f, -0.06445317f, 
    -0.01322199f, -0.03840786f, 0.05119810f, -0.04691327f, -0.00634516f, -0.05884564f, 0.03433649f, 0.05871127f, 
    -0.06814725f, 0.01358231f, -0.05761034f, 0.02570588f, 0.03414824f, -0.06576965f, 0.01025667f, 0.01230179f, 
    -0.01729711f, 0.00529130f, 0.03135465f, 0.03572966f, -0.04528282f, 0.00792883f, -0.02351706f, 0.00412889f, 
    0.15919407f, 0.24089937f, -0.01097416f, -0.09790578f, 0.09718935f, -0.07908262f, -0.04369667f, 0.02483231f, 
    0.02966070f, 0.03393893f, 0.09279615f, 0.01405257f, -0.09907534f, 0.30651990f, 0.14354093f, -0.03973235f, 
    0.02563140f, -0.00083713f, -0.03807317f, 0.06272499f, -0.04503906f, 0.06225266f, 0.01390979f, -0.11482102f, 
    -0.07063392f, 0.02614468f, -0.09387156f, -0.06341225f, -0.14676501f, 0.08794469f, -0.08808184f, -0.05964176f, 
    -0.00372509f, -0.03401315f, 0.07016786f, -0.02521586f, 0.46256542f, -0.16147576f, 0.06138136f, -0.21582618f, 
    -0.03473264f, 0.06141176f, -0.00401306f, -0.03054327f, 0.09561398f, -0.03259593f, 0.02857094f, 0.00389104f, 
    0.13488965f, -0.17899479f, 0.02948272f, 0.09493735f, 0.01427412f, -0.06081074f, -0.05015780f, -0.10052361f, 
    0.04654991f, 0.05222023f, 0.03963642f, 0.12228344f, 0.00106008f, 0.12080503f, 0.22154111f, 0.20298165f, 
    -0.02198228f, 0.03401751f, 0.00452199f, 0.18271242f, -0.01503282f, 0.02608509f, -0.02562923f, 0.09539100f, 
    -0.17552349f, -0.02014269f, -0.09848570f, 0.10846838f, -0.04305819f, 0.09122360f, -0.03400671f, -0.00950933f, 
    -0.09609111f, -0.04094197f, 0.12268322f, 0.10969967f, 0.26156446f, -0.25970042f, 0.12887326f, 0.13319835f, 
    -0.01801824f, 0.00913554f, -0.03789550f, 0.03417294f, -0.01751259f, -0.05765344f, 0.20434791f, 0.01834880f, 
    0.14170042f, 0.14168794f, 0.05196183f, 0.16597819f, 0.00191342f, -0.00671453f, -0.00690193f, -0.01465367f, 
    -0.01304037f, -0.03374805f, 0.00643203f, -0.04924941f, 0.19929709f, -0.22353511f, -0.13168034f, -0.02896593f, 
    0.07998118f, 0.02581874f, -0.01438880f, 0.08963965f, -0.05467446f, 0.05769276f, 0.03520892f, 0.04647102f, 
    -0.12667727f, -0.22439380f, -0.16770422f, -0.35186467f, 0.07999658f, -0.07136220f, 0.02265541f, 0.07212586f, 
    0.00445926f, -0.03662692f, -0.01259362f, 0.02608825f, -0.15666765f, -0.04609375f, 0.29877141f, 0.05624822f, 
    0.08556390f, 0.03835721f, 0.02565989f, -0.03186586f, 0.00018095f, 0.01026179f, -0.04880650f, -0.01935931f, 
    0.02321639f, 0.24767511f, 0.17555143f, 0.11804162f, 0.04453901f, 0.01269616f, 0.11524594f, 0.07703253f, 
    0.02657709f, -0.11057778f, -0.02843723f, -0.03035076f, -0.23658530f, -0.05237997f, 0.02115571f, -0.09700830f, 
    0.13785750f, 0.02751151f, -0.00748290f, 0.07801782f, 0.07178196f, 0.01980324f, 0.05504762f, -0.03528455f, 
    -0.28801680f, 0.08300414f, -0.19353227f, -0.14518724f, -0.01556412f, -0.01210158f, 0.07764374f, 0.09489202f, 
    0.01073828f, 0.13327502f, 0.09768514f, 0.06771129f, 0.20601584f, -0.12524872f, -0.17083928f, -0.09218120f, 
    -0.01276227f, 0.04168957f, -0.01760475f, -0.12631685f, 0.08131126f, -0.03049931f, -0.04592125f, -0.02284670f, 
    -0.20374277f, 0.14553720f, -0.13960640f, -0.08357313f, 0.03779039f, 0.04227363f, 0.04913713f, 0.23542678f, 
    0.18059768f, 0.02199557f, 0.14730783f, -0.11204360f, -0.10011097f, -0.12341214f, 0.03009654f, 0.12511440f, 
    0.12305885f, 0.13017233f, -0.06513777f, 0.09550058f, -0.02470482f, 0.01303518f, 0.02648425f, -0.05011824f, 
    -0.24617563f, 0.11894024f, 0.04662501f, -0.04786631f, 0.09830909f, 0.02846190f, 0.06803881f, 0.09098312f, 
    -0.02705478f, -0.03458293f, 0.08821241f, 0.14480083f, 0.01327709f, -0.06212313f, -0.12274431f, -0.10730191f, 
    -0.03333389f, 0.06716777f, -0.10244277f, -0.06558879f, 0.02049514f, 0.10438132f, 0.11869939f, 0.10459363f, 
    0.06032087f, -0.14946391f, -0.23587398f, 0.13244689f, -0.04650095f, -0.19025955f, 0.17011069f, 0.10326218f, 
    0.03971549f, -0.00195507f, -0.05637808f, -0.10900643f, -0.10676300f, -0.09671894f, 0.02019013f, -0.05259011f, 
    -0.04603294f, -0.00429371f, -0.01462310f, 0.16802774f, 0.04618984f, 0.01064343f, 0.03585522f, -0.03688838f, 
    -0.28935009f, -0.08502177f, 0.29615358f, 0.18124948f, 0.18752258f, 0.11929722f, 0.08787075f, -0.04340034f, 
    0.19228043f, 0.04861328f, 0.10074539f, 0.01593425f, -0.00393520f, 0.08546937f, -0.07116386f, 0.00492358f, 
    -0.06570645f, -0.01183244f, 0.09412976f, 0.06731135f, 0.06366904f, 0.00551962f, 0.21682888f, -0.03890510f, 
    -0.02124071f, 0.03853577f, -0.10276937f, -0.16418347f, 0.22662501f, -0.03672948f, -0.08664048f, 0.11328318f, 
    -0.01173114f, -0.06381223f, -0.01069322f, 0.00407005f, 0.03928890f, -0.17644364f, -0.17304347f, 0.09246937f, 
    0.11765793f, -0.00923474f, -0.07008772f, -0.03005460f, 0.00677353f, -0.09890741f, 0.01056216f, -0.01444166f, 
    0.22064258f, -0.03355486f, -0.12468667f, -0.13992216f, -0.05422674f, 0.10821541f, 0.02482054f, 0.07458499f, 
    -0.01687359f, 0.07042857f, 0.06546365f, -0.04312015f, -0.02878186f, -0.08713120f, -0.06123615f, -0.10038260f, 
    -0.05475520f, -0.08373066f, -0.01428264f, 0.00888385f, -0.03440203f, -0.01179459f, 0.03022498f, 0.11111818f, 
    -0.14456759f, -0.08244912f, 0.12030249f, 0.03668865f, 0.05810187f, 0.01104463f, -0.00818116f, -0.00988446f, 
    0.10440272f, 0.18734774f, -0.10114772f, 0.17391926f, -0.27862576f, -0.11694588f, -0.06146465f, -0.02044919f, 
    -0.00090686f, 0.11147778f, -0.07503115f, 0.03047796f, 0.17230302f, 0.01763722f, -0.00493834f, 0.06423457f, 
    0.10920262f, 0.22313158f, 0.01329359f, -0.09182795f, 0.13850765f, -0.02568777f, 0.04932138f, 0.17864764f, 
    0.05841196f, 0.19311583f, 0.09476890f, 0.10142647f, 0.09957139f, 0.09187010f, -0.12371977f, -0.04745774f, 
    0.00313700f, 0.17724441f, -0.03435115f, -0.01235402f, 0.06012746f, 0.08529797f, 0.11836550f, 0.05387167f, 
    -0.14573535f, -0.18007544f, -0.24678096f, 0.10343172f, 0.06704216f, 0.06082214f, 0.04104867f, -0.07711036f, 
    0.02425697f, 0.03458589f, -0.19116998f, 0.06273145f, 0.28181610f, -0.11495354f, -0.16567466f, 0.04658758f, 
    0.05631816f, 0.00476043f, 0.01428848f, 0.00266631f, 0.00420201f, 0.10803196f, 0.08946983f, -0.01004778f, 
    -0.13469392f, 0.16228271f, -0.03574377f, -0.21931067f, 0.09982644f, -0.05269511f, 0.03446259f, 0.10651622f, 
    -0.15394785f, 0.12922187f, -0.03764068f, 0.02072346f, -0.10877728f, 0.03420262f, 0.23357782f, 0.04341010f, 
    -0.03914518f, -0.02374895f, -0.09079679f, 0.06847473f, -0.06782986f, 0.09091707f, 0.13369788f, 0.02178705f, 
    0.04654656f, -0.03519351f, -0.00203102f, 0.20762622f, -0.12588257f, -0.05440899f, 0.10850038f, 0.27105361f, 
    0.03484827f, -0.04162820f, -0.01170694f, -0.19628231f, 0.30874288f, 0.13825659f, 0.08736805f, 0.06400166f, 
    0.03575407f, -0.13613454f, 0.01306399f, 0.02722820f, -0.02594570f, 0.00980745f, 0.03904060f, -0.16512698f, 
    -0.03298711f, 0.21919407f, -0.14166273f, -0.00609008f, 0.22625013f, 0.10122489f, 0.06348538f, -0.05220101f, 
    0.07200155f, 0.06309666f, 0.09651916f, 0.08587948f, -0.12508030f, 0.35841879f, 0.03682496f, -0.04492737f, 
    -0.18238732f, 0.02339793f, 0.00457843f, 0.14467362f, -0.10214354f, -0.05561422f, 0.01032935f, -0.08230939f, 
    0.07550986f, -0.29827121f, -0.28263521f, -0.13489784f, 0.08655343f, 0.02712819f, -0.04936543f, -0.15735656f, 
    -0.08976041f, 0.02079002f, 0.08472825f, 0.05241816f, 0.27958134f, -0.06672427f, 0.32192513f, 0.35435012f, 
    -0.07311675f, -0.04997543f, -0.08198938f, 0.08930344f, -0.09336112f, 0.01101445f, -0.03904838f, 0.04726367f, 
    -0.09656721f, 0.25606489f, -0.11665849f, 0.23836304f, 0.04388128f, 0.09116345f, -0.07262050f, -0.10600600f, 
    -0.08076077f, 0.00844291f, -0.03854552f, 0.02166926f, 0.32514444f, 0.15600741f, 0.08600370f, 0.07033923f, 
    -0.08651639f, 0.02888527f, -0.02522928f, -0.09978547f, -0.15152588f, 0.00329105f, -0.07909276f, 0.01241613f, 
    0.08923171f, -0.08477789f, 0.14560941f, -0.05940471f, 0.11584739f, 0.06518216f, -0.05802977f, 0.02352059f, 
    0.03098697f, 0.12879759f, 0.11749819f, 0.02094356f, -0.10582484f, -0.05638218f, -0.38227373f, -0.06720784f, 
    0.17765512f, 0.03497787f, -0.03450020f, -0.08901175f, 0.03039175f, 0.01930735f, -0.01595202f, 0.00106741f, 
    -0.17203876f, 0.15098479f, -0.01723276f, 0.27430531f, 0.14802971f, -0.09917716f, -0.11325536f, 0.07885583f, 
    -0.10636579f, 0.01739109f, 0.05117203f, -0.19768809f, 0.11328542f, 0.07974271f, -0.18603976f, 0.00278887f, 
    0.02517436f, 0.06271276f, -0.11565658f, 0.09323454f, -0.18497796f, -0.03687515f, 0.04515026f, 0.00646002f, 
    -0.32745132f, 0.16053337f, -0.17909260f, -0.18378341f, 0.09299345f, 0.05306276f, -0.06917029f, -0.03828214f, 
    0.21151398f, -0.12715930f, 0.08589703f, -0.13815738f, -0.21157874f, -0.03471259f, 0.07566804f, -0.20461950f, 
    0.28837326f, -0.10415798f, -0.08223082f, -0.03246328f, 0.02848155f, -0.06335834f, 0.05479090f, 0.11466975f, 
    -0.06707610f, 0.07421935f, -0.11878511f, -0.01917004f, 0.08495897f, -0.12012362f, -0.12612917f, 0.09261151f, 
    -0.02663947f, -0.02717983f, -0.07309919f, 0.11940178f, -0.09637824f, 0.13713613f, -0.11816648f, 0.15095045f, 
    0.03866126f, -0.03107495f, -0.11105167f, 0.06151824f, 0.06343049f, 0.09923267f, -0.05553325f, -0.00689000f, 
    0.12713359f, -0.05110511f, -0.02155839f, -0.04257771f, -0.10471989f, -0.16165541f, 0.06201361f, -0.02626547f, 
    0.09555963f, -0.01553503f, 0.06019124f, -0.00188918f, -0.18341222f, 0.22221504f, 0.06545269f, -0.03293741f, 
    0.02392609f, 0.11351860f, 0.05953003f, 0.05646154f, -0.07843361f, 0.00080214f, -0.02736472f, 0.01010843f, 
    0.11475067f, 0.04742483f, 0.16082947f, 0.16993989f, 0.06692377f, 0.00980081f, 0.00215612f, -0.08474737f, 
    0.00938966f, -0.01235440f, -0.04779581f, -0.09319010f, 0.04836185f, -0.03545057f, 0.04655879f, 0.11091462f, 
    0.01848619f, -0.00937170f, 0.07686383f, 0.05323087f, 0.10551284f, 0.08398443f, -0.03811271f, -0.02802174f, 
    -0.26370317f, 0.16799876f, -0.26319396f, -0.11371972f, 0.04969993f, -0.03624228f, 0.03166250f, 0.00300145f, 
    0.03268822f, 0.07579141f, 0.09575000f, 0.01474113f, -0.35255638f, 0.11686239f, -0.21877402f, -0.05210106f, 
    0.01608606f, 0.11330754f, 0.12335742f, 0.06388259f, 0.02291534f, 0.03476665f, 0.03531627f, -0.06019873f, 
    -0.19111776f, -0.01022232f, 0.13668090f, 0.13345575f, 0.04941295f, -0.09744811f, -0.10180539f, 0.01471748f, 
    -0.05289927f, -0.00273547f, 0.11081264f, 0.08233656f, 0.20336592f, -0.01656168f, 0.10414350f, 0.20375992f, 
    0.12622157f, 0.10738759f, -0.02695555f, 0.13282001f, 0.08307380f, -0.11602178f, -0.01463414f, -0.10956404f, 
    0.04280515f, 0.07356241f, 0.18190263f, 0.08757775f, 0.18705040f, -0.04142531f, -0.12536702f, -0.13572800f, 
    0.03350532f, 0.06599777f, -0.01565087f, 0.10407591f, 0.01170160f, -0.03766226f, -0.13313299f, -0.22864351f, 
    0.13465899f, -0.09118998f, -0.18394125f, -0.03773846f, -0.00294432f, 0.10052086f, 0.03077062f, 0.01436804f, 
    0.05759505f, 0.05383786f, -0.11191778f, 0.10958927f, 0.02877554f, -0.13559969f, -0.04285807f, 0.06968798f, 
    0.16457811f, -0.01083796f, 0.25166997f, 0.11185802f, 0.10828394f, -0.08131594f, 0.07280153f, -0.05281274f, 
    -0.03888083f, -0.10558632f, 0.03071722f, -0.03780534f, 0.02407561f, 0.08661095f, 0.12825750f, -0.02154417f, 
    -0.19042543f, 0.18174517f, 0.00462654f, -0.00206531f, 0.04693504f, 0.03109815f, 0.01450937f, 0.08708113f, 
    0.05680050f, -0.05528937f, -0.09193567f, -0.13984819f, 0.11881590f, -0.21183936f, 0.03859794f, 0.14336546f, 
    -0.02657569f, -0.02291720f, -0.04130198f, 0.09949011f, 0.00946606f, -0.00472451f, -0.06686871f, 0.08075372f, 
    -0.30319577f, 0.06557250f, 0.00130299f, -0.09230377f, 0.17601189f, -0.05304567f, 0.05604780f, 0.07370606f, 
    -0.08109811f, 0.02864641f, -0.03005326f, 0.13886708f, -0.46825865f, 0.19556069f, 0.04072958f, -0.14206316f, 
    -0.05288129f, 0.02186329f, -0.15465653f, -0.02032985f, 0.03549728f, 0.00949985f, 0.07577152f, 0.12119517f, 
    -0.21202080f, 0.28283510f, -0.25202191f, 0.16186291f, 0.00165904f, -0.11812643f, 0.20034388f, 0.13675061f, 
    -0.02646470f, -0.05510687f, 0.00651588f, -0.06636808f, -0.09195343f, -0.18129468f, -0.01839212f, -0.01416921f, 
    -0.02075529f, 0.11170139f, -0.03718163f, 0.03391213f, 0.05831675f, 0.09817421f, -0.00171812f, -0.03815052f, 
    0.16420385f, -0.00200737f, 0.14421965f, 0.14871407f, 0.10688465f, -0.01825768f, 0.02015009f, -0.03125482f, 
    0.15351966f, 0.14348261f, 0.01819387f, -0.04141283f, -0.04904730f, 0.35472471f, -0.10144594f, -0.07692248f, 
    -0.02479962f, -0.08838666f, -0.00034358f, 0.04617229f, 0.13711928f, 0.06504476f, 0.02912711f, 0.01443646f, 
    0.04121056f, -0.05155119f, -0.09221903f, 0.02359624f, 0.04619724f, -0.02095187f, -0.03844948f, 0.07680941f, 
    -0.01536540f, 0.05236503f, 0.09204374f, -0.02881557f, -0.32974258f, 0.05931234f, -0.08890775f, -0.02470132f, 
    0.06661209f, -0.10604485f, -0.01452114f, 0.00131233f, -0.07141229f, -0.00843748f, 0.03678495f, 0.02758816f, 
    0.16451588f, 0.21919952f, -0.06379946f, 0.03087703f, -0.14021578f, 0.18087141f, -0.02520671f, -0.02581018f, 
    -0.02553202f, 0.12794133f, -0.00395782f, -0.02920815f, 0.07779241f, -0.06693856f, -0.12856716f, 0.02919786f, 
    -0.05613590f, 0.08851294f, 0.02643123f, 0.22709577f, -0.04890944f, -0.04534546f, 0.15259233f, 0.14796351f, 
    0.12738290f, -0.12587903f, 0.09022685f, 0.01366392f, 0.17250875f, -0.03307840f, -0.17190664f, -0.11248275f, 
    -0.01059566f, 0.26346219f, -0.02984935f, 0.03672829f, 0.05996240f, -0.24433090f, -0.13718240f, 0.25951397f, 
    0.01583619f, 0.12667467f, -0.03072982f, 0.04846151f, 0.12966944f, 0.05002769f, -0.12160771f, 0.03707835f, 
    0.04351583f, 0.07959580f, -0.14375627f, 0.21716164f, 0.11052787f, -0.12066499f, 0.06580881f, 0.02167548f, 
    0.01184174f, 0.06126385f, 0.10521047f, 0.07551391f, -0.29777449f, 0.14705101f, 0.09569492f, 0.06183787f, 
    0.08306241f, 0.10887828f, 0.00928870f, 0.02153150f, -0.00587101f, -0.03233850f, 0.20923933f, 0.07668302f, 
    -0.03609782f, -0.03077312f, -0.06357862f, 0.05237578f, 0.05551076f, 0.04062043f, -0.06493964f, 0.05394746f, 
    -0.06496806f, 0.05230572f, -0.03679717f, -0.01694445f, -0.02828983f, -0.01948140f, 0.03617425f, -0.07492859f, 
    -0.02729827f, -0.06092303f, -0.00357363f, 0.05596611f, 0.03773723f, -0.05342963f, 0.01062262f, 0.01151575f, 
    -0.05455625f, 0.01632603f, 0.01798746f, 0.05310623f, -0.01263670f, 0.03607453f, 0.04949985f, -0.02304652f, 
    0.05627249f, -0.06846072f, -0.02244514f, 0.06143906f, 0.02437438f, -0.00531039f, -0.02345698f, 0.00973835f, 
    -0.03420589f, 0.02661566f, 0.03671149f, -0.06702424f, -0.01244787f, -0.04051913f, -0.02678865f, -0.02243824f, 
    -0.05707197f, -0.03121199f, -0.05227733f, 0.05621799f, -0.08329093f, 0.04994227f, -0.03996528f, -0.02816187f, 
    -0.08239958f, 0.01446258f, -0.01777167f, -0.06954248f, -0.03767397f, 0.01522334f, 0.03881655f, -0.00192403f, 
    0.05559410f, 0.01404150f, 0.03327898f, 0.05460399f, 0.00785625f, 0.05296575f, -0.07806748f, -0.03211673f, 
    0.01580041f, -0.07082045f, 0.03516482f, -0.02534732f, -0.02534761f, -0.01629355f, 0.00381421f, -0.02465972f, 
    0.01221557f, 0.01695314f, -0.03642510f, -0.04068073f, 0.00359475f, -0.07902745f, -0.05802223f, 0.01612347f, 
    0.00895836f, -0.04065345f, -0.03263812f, -0.02232845f, -0.04815715f, 0.05563183f, 0.05490469f, -0.02231372f, 
    0.03245653f, -0.05405004f, -0.03814419f, -0.02059432f, 0.05250007f, 0.06006753f, -0.07530985f, 0.00828737f, 
    -0.04317104f, -0.02703993f, 0.02422192f, 0.04651166f, -0.03766795f, -0.06128257f, 0.00880715f, 0.03910500f, 
    -0.01501477f, -0.02822007f, 0.01610610f, 0.05748622f, 0.05408137f, 0.05424009f, -0.03575581f, -0.05576850f, 
    0.05038192f, 0.04366104f, -0.04724874f, 0.01657886f, 0.04773265f, -0.04578049f, -0.05650630f, 0.02440338f, 
    -0.05905529f, -0.04354357f, -0.06014783f, -0.07279814f, -0.08042594f, 0.05900289f, -0.02349921f, 0.04787865f, 
    -0.03639269f, 0.05831130f, -0.03829410f, -0.01891843f, -0.06241747f, 0.04964836f, -0.03073556f, -0.03620094f, 
    0.02355413f, -0.02123117f, -0.02959651f, 0.03725491f, 0.01847643f, -0.00518232f, -0.05385290f, -0.04271471f, 
    -0.06222140f, -0.02484415f, -0.04595657f, -0.05566544f, 0.03602792f, 0.02354183f, 0.01716496f, -0.02813652f, 
    -0.07476448f, 0.00603660f, -0.06225833f, 0.00190250f, 0.01427964f, 0.01866789f, -0.07090941f, 0.03605936f, 
    -0.04282486f, -0.00520300f, -0.00611927f, -0.06747978f, -0.02780952f, -0.00881428f, 0.01417117f, -0.02212729f, 
    -0.02010276f, 0.05533624f, 0.01147447f, 0.03375930f, -0.07321696f, -0.06517509f, 0.05079973f, -0.07240543f, 
    -0.01454656f, 0.04671705f, -0.00975508f, -0.05027391f, -0.03585131f, -0.00570909f, 0.03077805f, -0.01134541f, 
    0.02391675f, 0.01768133f, -0.05854734f, -0.04495430f, -0.01927459f, -0.03570960f, 0.03098432f, 0.02290146f, 
    -0.01971606f, -0.07480149f, 0.01192169f, -0.07326771f, -0.03228678f, -0.06779006f, 0.03262148f, -0.01199608f, 
    -0.06684023f, -0.07575574f, -0.00601315f, 0.04903876f, 0.03105480f, -0.05218409f, -0.00552944f, 0.03242544f, 
    0.05704313f, 0.06464191f, 0.02988742f, -0.02862865f, -0.01872117f, 0.02465356f, -0.06412750f, -0.01581551f, 
    -0.08475445f, -0.00390625f, -0.02441843f, 0.02440504f, 0.00257582f, -0.03973358f, -0.08298762f, -0.07382637f, 
    -0.00137595f, 0.03411219f, 0.05749004f, -0.01946033f, -0.04498335f, -0.00406083f, -0.06081822f, 0.00170540f, 
    0.03840189f, 0.01456726f, 0.04426140f, 0.02243580f, -0.08102616f, -0.01627347f, -0.06476179f, -0.07652933f, 
    -0.06945779f, 0.00152670f, -0.04769309f, 0.01065854f, -0.01691294f, -0.05815741f, -0.04131395f, -0.03208003f, 
    -0.05848286f, -0.01776605f, 0.04429797f, -0.04643675f, 0.00014254f, 0.01662936f, -0.03550892f, -0.01421276f, 
    -0.01225131f, 0.03256993f, 0.01714693f, -0.05736731f, 0.06004173f, -0.04170874f, -0.00918373f, 0.02891920f, 
    0.04795821f, -0.02205515f, -0.05567950f, 0.01338981f, 0.06548470f, 0.03821305f, -0.00249819f, -0.02062428f, 
    0.04662044f, 0.02523152f, 0.00431246f, 0.05428221f, 0.03963464f, 0.00466000f, 0.03871293f, -0.08093391f, 
    0.06395037f, -0.01839032f, -0.04612231f, -0.07909074f, -0.05155646f, 0.02211235f, 0.03165243f, 0.02788382f, 
    -0.00671654f, -0.06175436f, -0.01161887f, -0.07348166f, -0.00332314f, 0.01308685f, -0.07029493f, -0.04043837f, 
    -0.03952404f, -0.02832206f, 0.00807925f, 0.01077345f, -0.00475537f, 0.01508611f, 0.02458912f, 0.01880061f, 
    -0.03473661f, -0.05464908f, 0.02496929f, -0.03071057f, -0.06099638f, -0.07093309f, -0.04786745f, 0.03368193f, 
    -0.02887358f, 0.00803962f, 0.01092214f, 0.05175693f, 0.02716776f, -0.02126383f, -0.07815664f, 0.05802811f, 
    -0.05057498f, -0.05765354f, -0.03649573f, -0.03703004f, 0.00296613f, -0.02912262f, 0.03336212f, 0.05216093f, 
    -0.06108303f, -0.02860465f, -0.03695726f, -0.07995660f, -0.06605079f, -0.06843986f, 0.02843022f, -0.07324123f, 
    -0.02894204f, 0.02181410f, -0.00222585f, 0.00156363f, 0.04712154f, 0.03580437f, -0.03622697f, 0.03189684f, 
    0.03671844f, -0.06460763f, 0.03304970f, 0.04241492f, -0.04452675f, -0.03594065f, -0.01215695f, -0.07820872f, 
    0.03218303f, -0.04186586f, -0.00565696f, 0.02204016f, -0.06064205f, -0.01568305f, 0.01005764f, 0.05998548f, 
    0.00373975f, 0.01565455f, -0.07668842f, -0.06001001f, 0.01700312f, 0.06124135f, 0.00377373f, 0.04504064f, 
    -0.00537343f, -0.02332168f, 0.04460642f, -0.06431583f, -0.02658228f, 0.03352778f, 0.02523623f, -0.03267166f, 
    0.08184735f, 0.15452531f, -0.28943208f, -0.13294326f, 0.07406046f, 0.02176608f, -0.00718602f, 0.24111535f, 
    0.09255945f, 0.11012919f, 0.00807791f, 0.06968492f, -0.05129850f, -0.08529157f, -0.00333931f, 0.13751240f, 
    -0.00925155f, 0.21678388f, -0.11404269f, 0.01442978f, 0.09579130f, 0.12493161f, -0.03248552f, -0.05375871f, 
    -0.04380558f, 0.11973053f, 0.05179807f, -0.13186757f, 0.23487338f, -0.02359478f, 0.02703636f, 0.01931066f, 
    0.14733480f, 0.01703841f, 0.07350229f, 0.11671113f, 0.00838327f, -0.32904670f, 0.11557882f, -0.03764161f, 
    0.00077931f, 0.03943849f, -0.00329776f, -0.02470636f, -0.05611857f, -0.01748086f, 0.01020227f, 0.03456838f, 
    0.04646754f, -0.03207628f, -0.07712473f, 0.38203457f, 0.10240129f, -0.15270092f, 0.15890782f, 0.00834091f, 
    0.04252218f, 0.02559722f, -0.05727976f, 0.03675747f, -0.14608109f, -0.02804939f, -0.03463046f, -0.01510322f, 
    -0.10660928f, 0.05025963f, 0.06379429f, 0.06196678f, 0.00336243f, -0.00801264f, 0.14310952f, 0.05398294f, 
    -0.38141480f, -0.17448904f, 0.22093628f, 0.17824204f, 0.02237337f, 0.09859578f, -0.01116713f, -0.08222044f, 
    0.16103373f, 0.16789268f, 0.05504088f, 0.14167963f, -0.21815056f, 0.21440192f, 0.07946337f, 0.00234693f, 
    -0.06121569f, 0.04590091f, 0.16906875f, 0.13034867f, -0.04336319f, 0.01227423f, 0.22998947f, -0.10730802f, 
    0.15909219f, -0.09557672f, -0.21243270f, -0.10239361f, 0.02780606f, -0.00076698f, -0.08612861f, 0.11350199f, 
    -0.04726991f, 0.03891765f, 0.01197029f, -0.00208423f, 0.10764002f, -0.21154924f, 0.01460333f, -0.04038882f, 
    -0.06064091f, 0.01902217f, -0.04808265f, 0.01090388f, 0.06204723f, -0.12466100f, 0.09156061f, 0.06768282f, 
    0.26584327f, 0.09163690f, -0.23533969f, -0.22141926f, 0.07128312f, 0.11187459f, 0.06087168f, 0.12941575f, 
    -0.08175249f, 0.03182520f, 0.07525174f, 0.02019479f, -0.00218631f, -0.01919801f, 0.06198126f, -0.35383433f, 
    -0.22224474f, -0.17171176f, 0.03084688f, 0.03446512f, -0.15552799f, -0.03312909f, -0.10914437f, 0.06664417f, 
    -0.09457453f, -0.02420519f, -0.04833914f, 0.05974014f, -0.07647971f, 0.06344651f, 0.06797799f, 0.11131499f, 
    0.07859777f, -0.09432979f, -0.00073327f, 0.13561410f, -0.27824813f, 0.09635279f, 0.01710128f, -0.09776672f, 
    0.07785614f, 0.01915396f, -0.07989460f, 0.03953268f, 0.08093979f, 0.07269657f, 0.00517731f, 0.05700548f, 
    0.23313394f, 0.15462387f, 0.04063874f, -0.14520508f, 0.10051478f, -0.00538228f, 0.07285161f, 0.11554863f, 
    -0.05585768f, 0.04162991f, -0.05127057f, 0.09289955f, -0.04926941f, 0.08262972f, -0.16539243f, -0.03835374f, 
    -0.01838120f, 0.19349805f, -0.05564426f, 0.04676282f, -0.01352466f, 0.10281932f, -0.02230135f, 0.06967182f, 
    0.01356536f, -0.03352623f, 0.04511517f, -0.03978360f, -0.07226025f, -0.05316659f, -0.00735860f, -0.00832228f, 
    0.04484551f, 0.04239196f, -0.03793762f, -0.03708741f, 0.05326167f, -0.00902476f, -0.04245629f, -0.00939190f, 
    0.02214703f, -0.05352180f, -0.06937742f, -0.03974632f, -0.07854367f, -0.07160206f, 0.00190844f, -0.02840396f, 
    -0.04975223f, 0.02332493f, 0.00391746f, 0.00130725f, -0.02737093f, -0.01084718f, 0.04387423f, -0.05433578f, 
    -0.06824403f, -0.07579717f, 0.05462755f, 0.06224893f, 0.01317381f, 0.02103550f, 0.03392874f, 0.01050537f, 
    -0.00662718f, -0.02332939f, -0.00835480f, 0.00222496f, -0.03653773f, -0.03248329f, -0.07130305f, 0.04537041f, 
    0.04450946f, -0.02579510f, 0.04229385f, 0.04173409f, 0.00063104f, -0.07268987f, 0.06060671f, 0.02567857f, 
    0.01236852f, 0.00751871f, 0.04323707f, -0.03614646f, 0.05708517f, -0.00247225f, 0.01492631f, -0.06083338f, 
    -0.07577531f, 0.04113910f, -0.03804152f, 0.00185013f, 0.06295455f, -0.04134771f, -0.02814870f, 0.02138708f, 
    0.01736839f, 0.00710324f, -0.07577847f, 0.02360261f, -0.02153101f, -0.03911728f, -0.03794906f, 0.00042751f, 
    -0.06069256f, -0.04114832f, 0.04104818f, -0.03562148f, -0.04760125f, 0.05925895f, -0.06463939f, -0.07742051f, 
    -0.03125517f, -0.02347723f, 0.03498065f, -0.04613745f, -0.00066894f, -0.05575815f, 0.05933586f, -0.01687059f, 
    -0.04433696f, -0.04503593f, -0.05020816f, -0.00610274f, 0.05946942f, -0.00664459f, -0.00541335f, -0.06793597f, 
    -0.02895396f, 0.04655160f, 0.05100014f, -0.07747462f, 0.05522693f, -0.05475793f, -0.07669129f, -0.03882819f, 
    -0.00840286f, 0.04118550f, 0.06208542f, -0.07015936f, 0.04160096f, 0.06396750f, 0.01205469f, 0.01536116f, 
    -0.05258827f, 0.03370507f, -0.03538806f, 0.00542492f, -0.03217139f, -0.04741554f, -0.01786271f, 0.00587496f, 
    0.01006593f, -0.07691851f, -0.06733336f, -0.06266401f, -0.01991078f, -0.03146917f, -0.02257889f, -0.07550534f, 
    0.02770875f, 0.00376112f, 0.02165238f, -0.07673126f, 0.05104875f, -0.02146402f, -0.03858742f, -0.01271763f, 
    -0.06453715f, -0.03463672f, 0.02315411f, 0.03476997f, -0.00056740f, -0.05262716f, 0.01758668f, 0.02403582f, 
    -0.07136404f, 0.03107971f, 0.02295332f, -0.06378910f, 0.02724063f, 0.02096509f, -0.04785139f, -0.02738524f, 
    -0.06650224f, -0.04122135f, -0.04271253f, -0.04234146f, -0.03966651f, 0.04887471f, -0.06772103f, -0.00289466f, 
    -0.05586509f, -0.01265545f, 0.03359909f, -0.05269540f, -0.06489757f, 0.00367513f, -0.00319264f, -0.03026546f, 
    -0.03070542f, -0.00007678f, -0.02805792f, 0.02515284f, -0.04443598f, 0.01540959f, -0.00381017f, 0.03671424f, 
    0.00198610f, -0.03079446f, 0.02405009f, -0.01414055f, -0.00314804f, -0.06122884f, 0.04576540f, 0.00311928f, 
    -0.02852411f, 0.03596331f, -0.06346925f, 0.01852866f, -0.04013295f, 0.01164167f, 0.03811635f, -0.06306516f, 
    0.03382211f, 0.04358499f, -0.01960567f, 0.05036512f, -0.04296061f, 0.02936068f, -0.06095425f, 0.04971088f, 
    0.05646028f, -0.02279676f, 0.04594691f, 0.00518134f, -0.04416871f, -0.06377031f, -0.00734072f, -0.01565580f, 
    -0.03671561f, 0.00686526f, 0.04975293f, -0.03712223f, 0.06447006f, 0.03154224f, -0.00945409f, 0.00331368f, 
    -0.03618390f, 0.00974085f, -0.01572421f, 0.00359878f, -0.01064137f, 0.05879626f, -0.03478678f, 0.03320898f, 
    -0.07365186f, -0.00998246f, -0.02912268f, 0.04831369f, -0.03088049f, -0.01306525f, 0.02361207f, -0.03324180f, 
    0.05867852f, -0.02604717f, -0.01803232f, -0.07873634f, 0.01776427f, -0.01952528f, -0.05805880f, -0.00529448f, 
    0.01735016f, 0.02180246f, 0.02206648f, -0.01051918f, -0.05562480f, -0.02710752f, 0.02737807f, -0.03770657f, 
    0.01454519f, 0.00475046f, 0.00465433f, 0.03315667f, -0.01971322f, -0.06007331f, -0.04470456f, -0.01763782f, 
    0.06511781f, -0.06898034f, 0.03148701f, 0.01446244f, -0.07699611f, 0.02656114f, -0.04347306f, 0.01396179f, 
    -0.06993166f, -0.04670607f, -0.03305369f, 0.04467289f, -0.04442103f, 0.04155452f, -0.01748610f, -0.06987615f, 
    -0.07305104f, 0.00524760f, 0.03945187f, 0.01963710f, 0.00719521f, -0.06440862f, -0.02911549f, 0.02190037f, 
    0.01713135f, 0.05998629f, -0.06659302f, 0.02451633f, -0.03453721f, 0.02543696f, 0.04579020f, 0.02294783f, 
    -0.06174614f, 0.05878105f, 0.01946271f, -0.02608150f, 0.04769098f, -0.06424908f, 0.00600616f, 0.05738326f, 
    -0.05158948f, -0.05342719f, -0.03495701f, 0.05787100f, -0.02315381f, -0.06535184f, -0.04787809f, -0.03862440f, 
    0.03421671f, -0.02344557f, -0.03562858f, 0.06294452f, -0.04277132f, 0.01435197f, 0.05970163f, -0.04517852f, 
    -0.00529095f, 0.01832028f, -0.06747949f, -0.05345461f, 0.00740771f, -0.02165419f, 0.01212196f, 0.04366184f, 
    0.01499314f, -0.05411073f, 0.02165835f, -0.00459020f, 0.00122144f, -0.03144734f, -0.02841146f, -0.00455559f, 
    0.01869548f, 0.06581808f, -0.00943446f, -0.01924219f, -0.04858738f, 0.05176853f, 0.02608921f, 0.01196032f, 
    0.05171126f, 0.03794985f, -0.03946501f, 0.04365664f, -0.07093401f, 0.00506119f, -0.02106031f, 0.03897650f, 
    0.05802663f, -0.04504796f, -0.02797485f, 0.04709721f, -0.02979616f, -0.07167690f, 0.01024085f, 0.06465407f, 
    -0.05255353f, -0.03584651f, -0.06330640f, -0.01633505f, -0.07434820f, -0.06717803f, 0.01126659f, 0.00663965f, 
    0.05741533f, -0.00606990f, 0.00002225f, -0.03016581f, 0.02257722f, -0.05018765f, 0.00524296f, -0.03692578f, 
    0.00445607f, -0.07980841f, -0.04551559f, -0.01693773f, 0.02434565f, 0.00203611f, 0.05086903f, 0.00089321f, 
    -0.34768903f, -0.03328178f, 0.07484282f, -0.03510686f, -0.09608189f, 0.09364018f, 0.05077042f, -0.10429014f, 
    -0.13345514f, -0.00840666f, -0.02401796f, -0.14463827f, -0.22510242f, 0.20698443f, -0.00158391f, -0.01351608f, 
    -0.02223650f, -0.18536270f, 0.02109902f, -0.03418440f, -0.17542318f, -0.01005276f, 0.02203521f, -0.04457365f, 
    0.14574590f, 0.07565832f, 0.13092792f, -0.10464517f, -0.21863998f, 0.11713807f, -0.08831759f, 0.05216614f, 
    -0.09350376f, -0.01942563f, -0.08690207f, -0.00674111f, 0.15329835f, 0.12166602f, -0.00792597f, 0.16620958f, 
    0.12110288f, -0.03918575f, 0.00709625f, -0.00601091f, 0.08465793f, -0.03857169f, 0.04665580f, 0.01600649f, 
    0.13069656f, -0.26445147f, 0.07995326f, -0.19013914f, -0.03498499f, 0.06178704f, 0.02165749f, 0.02057214f, 
    -0.02552240f, -0.06294055f, 0.06453020f, 0.05064512f, 0.06606303f, 0.07260637f, 0.10892153f, 0.15093695f, 
    0.17935070f, 0.06068156f, -0.00056551f, 0.10372175f, -0.06577275f, 0.07407399f, 0.06764936f, -0.09162615f, 
    0.10467770f, 0.14402504f, -0.11145340f, 0.02492228f, -0.17646325f, -0.11274203f, -0.08144554f, -0.01676147f, 
    -0.15742490f, 0.04667055f, 0.08972389f, -0.10563084f, 0.43490756f, -0.29522011f, 0.14442082f, 0.06421543f, 
    0.18647504f, 0.22009785f, -0.02057078f, -0.01017544f, -0.16802734f, -0.06309357f, 0.13668878f, 0.00916579f, 
    -0.21849392f, 0.16433595f, 0.06574892f, 0.02933611f, 0.05438484f, 0.01604176f, 0.02567712f, 0.00631322f, 
    0.05546141f, -0.00391541f, 0.05569524f, 0.07623168f, 0.32786140f, -0.03657943f, 0.13135150f, 0.16665088f, 
    0.09298369f, 0.22199562f, -0.06136235f, -0.04156438f, -0.02899117f, 0.03131571f, 0.00813785f, 0.03290839f, 
    0.01389753f, 0.06863981f, 0.00460746f, 0.01758426f, -0.04406188f, -0.06954563f, 0.04665763f, -0.12488469f, 
    -0.03684752f, -0.00742741f, -0.02385381f, -0.14075795f, 0.18267316f, 0.26387513f, 0.06220685f, 0.21028468f, 
    0.33415797f, 0.22802342f, 0.13797592f, -0.05463569f, 0.01109433f, 0.01706794f, -0.12375193f, -0.06790010f, 
    -0.05447224f, 0.14474639f, 0.09872846f, 0.02879483f, 0.02213102f, -0.18909021f, -0.11298242f, 0.07781645f, 
    -0.12656908f, 0.04119059f, -0.05894306f, -0.17824762f, -0.20967640f, -0.02136549f, 0.06891919f, -0.04662486f, 
    0.09194981f, -0.17067046f, 0.00622095f, -0.00493558f, -0.12298964f, 0.05465528f, -0.09317689f, 0.09910153f, 
    -0.11267709f, 0.00112323f, -0.00861737f, -0.15297754f, -0.06877121f, -0.11399350f, -0.05104964f, -0.04368113f, 
    -0.07905185f, 0.05652794f, -0.02131493f, -0.12122296f, 0.34252876f, -0.20969762f, -0.07310703f, -0.02343212f, 
    -0.10458732f, 0.04633465f, -0.06717656f, -0.02213965f, 0.04606877f, 0.02360874f, -0.08289464f, -0.13444485f, 
    0.03329577f, -0.00238036f, -0.05367344f, -0.01302096f, 0.03712255f, -0.07470004f, -0.00642752f, -0.07934131f, 
    -0.02822124f, -0.06783509f, 0.04253342f, 0.04338387f, 0.00547521f, -0.06053280f, -0.00242162f, -0.03091973f, 
    -0.05218060f, 0.00946858f, 0.06477834f, -0.03826347f, -0.02240685f, -0.03419722f, -0.04889412f, -0.04041614f, 
    0.04128034f, 0.00807035f, -0.02256160f, -0.03099134f, -0.06600375f, 0.02485794f, -0.01595159f, -0.04022523f, 
    -0.04514407f, -0.02977542f, -0.02693977f, -0.04197522f, 0.00448687f, 0.05400706f, 0.00956879f, -0.05290003f, 
    -0.04376740f, -0.00586729f, 0.04456447f, -0.06671067f, -0.03803934f, 0.05345603f, 0.03940549f, -0.01026129f, 
    -0.02624382f, -0.01231697f, 0.03350415f, -0.06987888f, 0.04823127f, -0.06710503f, 0.05280623f, 0.01047382f, 
    0.03050028f, -0.01518387f, 0.03816244f, 0.02840886f, 0.04519059f, -0.05209975f, -0.01795128f, -0.05943342f, 
    0.03300049f, -0.00611603f, -0.05737295f, -0.02802865f, 0.05616525f, -0.01661626f, -0.07457541f, -0.02553539f, 
    0.03301152f, -0.06491788f, 0.03343347f, 0.00320556f, 0.05755872f, -0.04748016f, -0.03368888f, -0.07894140f, 
    -0.02690625f, -0.03794061f, 0.02439115f, -0.01303069f, 0.01906599f, -0.07702637f, -0.03890451f, 0.02891340f, 
    0.00892774f, -0.03063047f, 0.02814983f, 0.00789769f, 0.01671839f, -0.04595109f, -0.01045867f, -0.07224002f, 
    -0.05167856f, 0.04089096f, 0.01432856f, 0.04407432f, -0.07031180f, -0.06140300f, -0.03194660f, -0.00666193f, 
    -0.00918615f, -0.07934428f, -0.03000129f, -0.03460592f, -0.05514612f, -0.05067937f, -0.02796258f, 0.03692864f, 
    -0.06554256f, 0.00391422f, -0.02837460f, -0.00773879f, -0.01105238f, 0.02933046f, -0.01677594f, 0.00777564f, 
    -0.01671467f, 0.02576837f, 0.04988278f, 0.03566268f, 0.04968851f, 0.04026261f, -0.07349455f, 0.00553050f, 
    -0.00971351f, 0.00224900f, 0.01028249f, -0.06034301f, -0.03641920f, 0.01522594f, 0.05838441f, -0.00821837f, 
    -0.05876737f, 0.00914752f, -0.06700150f, -0.07353137f, 0.02244670f, -0.03602107f, 0.04860920f, -0.01627306f, 
    -0.00304881f, -0.06229313f, 0.05443368f, 0.06734814f, -0.02067541f, -0.04594193f, 0.01208832f, 0.05012840f, 
    -0.00390796f, 0.03279931f, -0.03479268f, 0.02726155f, 0.03987774f, -0.00865757f, 0.04834193f, -0.00981340f, 
    0.00348664f, 0.01745180f, 0.06069850f, -0.05506331f, 0.00905933f, -0.01747404f, -0.06316663f, 0.03827194f, 
    0.01607786f, -0.07920757f, 0.04955408f, -0.06910176f, 0.00037991f, 0.03462732f, -0.05789140f, -0.07472487f, 
    0.05183438f, -0.00481888f, 0.02092386f, -0.04834815f, -0.02663111f, 0.04657119f, -0.07484362f, -0.03417983f, 
    -0.07284518f, 0.03992416f, 0.03014542f, -0.02220043f, 0.04456883f, -0.03837065f, -0.06487691f, -0.03783653f, 
    0.31321242f, 0.21592638f, -0.05280079f, 0.08627843f, 0.04765794f, 0.10110977f, 0.06232039f, -0.18709879f, 
    0.00972841f, 0.02484233f, -0.00594525f, 0.07197116f, 0.04510131f, 0.24562834f, 0.08798289f, -0.14323826f, 
    -0.00920174f, 0.04056442f, -0.00761148f, -0.04314051f, -0.11650338f, -0.01807322f, -0.01432787f, -0.00407190f, 
    -0.07649323f, -0.07070456f, -0.19531947f, 0.01278748f, -0.11983791f, -0.04630483f, -0.10701188f, 0.09862557f, 
    -0.15711667f, 0.08810967f, -0.09013838f, 0.05124113f, 0.03837520f, 0.09515139f, 0.07905778f, -0.04671719f, 
    0.10866959f, -0.01176374f, -0.00493307f, -0.02791748f, 0.05475114f, -0.02725082f, -0.00601334f, 0.06991307f, 
    -0.04125736f, 0.12537141f, 0.23378316f, -0.00584522f, -0.07436554f, -0.01833328f, -0.07099752f, -0.10549771f, 
    -0.09855390f, -0.02408833f, 0.02204850f, 0.10215872f, 0.03505943f, 0.28937459f, 0.19063471f, 0.12776691f, 
    0.16500272f, 0.04438401f, -0.06379481f, 0.01089129f, -0.04016499f, 0.16888693f, -0.07351821f, 0.07141192f, 
    0.40109658f, 0.10246014f, -0.17841625f, -0.06423426f, -0.08253875f, -0.17935072f, 0.02512089f, 0.12205663f, 
    -0.06589236f, -0.01103958f, -0.04685871f, 0.13225727f, 0.29429358f, -0.13570018f, 0.12908800f, 0.18079603f, 
    0.01780299f, -0.06510758f, -0.04913053f, -0.04674195f, 0.16709605f, 0.00100385f, -0.09019782f, 0.01767128f, 
    0.19494075f, 0.17815486f, -0.03197090f, 0.28298429f, 0.01168888f, -0.00007689f, 0.04481273f, -0.04588678f, 
    0.03708318f, -0.00618026f, 0.03525857f, 0.04687919f, -0.32928216f, 0.22219382f, -0.03533721f, -0.13442293f, 
    -0.05513446f, -0.00345602f, 0.06376395f, 0.02885028f, 0.03003975f, -0.00453044f, 0.02213302f, 0.00908895f, 
    -0.33908251f, -0.03719686f, -0.08411656f, -0.15148088f, -0.05864366f, -0.13636680f, -0.01990901f, -0.00685365f, 
    0.06849795f, 0.04876989f, -0.04048120f, -0.03571464f, -0.05374115f, 0.02241275f, 0.19147861f, 0.11803529f, 
    0.17183647f, -0.01295574f, 0.02011684f, 0.05490079f, 0.00209106f, 0.01848787f, 0.06748955f, 0.01151456f, 
    0.27243260f, 0.19048481f, 0.08053771f, -0.13235199f, 0.05917133f, 0.02337907f, 0.04508216f, -0.13234897f, 
    0.01797531f, -0.15992332f, 0.00243265f, -0.06117391f, 0.24355066f, 0.03625095f, 0.11690614f, 0.14219324f, 
    0.09199814f, -0.08033648f, -0.05419860f, 0.00608418f, -0.07661116f, 0.03160647f, 0.00627054f, -0.10612795f, 
    -0.26540962f, -0.17196159f, -0.09026304f, 0.15304402f, -0.12500316f, 0.00885928f, 0.03635245f, -0.04526846f, 
    0.10646396f, -0.08701062f, 0.10153542f, 0.06049097f, 0.05929925f, -0.17635015f, 0.02056290f, 0.00707496f, 
    -0.03480035f, -0.17227320f, 0.01635039f, -0.07409393f, 0.00454412f, -0.01251508f, -0.01142260f, 0.00702232f, 
    -0.10431203f, 0.02751386f, -0.15383892f, -0.10701938f, -0.03326821f, -0.00010707f, -0.06636067f, 0.03930943f, 
    0.08296680f, 0.16418982f, 0.10173824f, -0.00991027f, -0.24723583f, -0.07655886f, 0.12643120f, -0.16140114f, 
    0.15136716f, 0.07848885f, -0.05564804f, 0.01692890f, 0.07827879f, 0.19615166f, -0.00037528f, -0.09897131f, 
    0.22456789f, 0.06302761f, -0.05145924f, 0.19296893f, 0.06746127f, -0.04044384f, -0.09551431f, -0.05864051f, 
    0.06049065f, -0.02084809f, -0.07152434f, -0.05358266f, 0.12232941f, -0.13026960f, -0.11371884f, 0.18455085f, 
    -0.06772684f, 0.09433363f, 0.03316995f, -0.05151972f, 0.04973336f, -0.00865650f, 0.04012183f, -0.05537190f, 
    0.35227200f, -0.05696079f, 0.03648176f, 0.07140853f, -0.09906588f, 0.00196561f, -0.02014774f, -0.00335757f, 
    -0.03373335f, 0.04392992f, 0.02578881f, 0.12684403f, 0.03246572f, 0.16892546f, 0.11134284f, -0.14595479f, 
    -0.06746081f, -0.01010660f, 0.15429340f, 0.00619033f, 0.02718148f, 0.02411622f, 0.17459959f, -0.06975336f, 
    -0.13983124f, 0.04073868f, 0.15976885f, 0.06998085f, 0.05540157f, -0.01328838f, 0.01897941f, -0.01451739f, 
    -0.02454474f, 0.10830763f, -0.06913614f, 0.09218878f, 0.07033105f, 0.07134409f, -0.11147618f, 0.11155948f, 
    0.12371752f, 0.08247001f, 0.18265301f, 0.10948460f, -0.08097454f, 0.05642437f, 0.03387516f, -0.03173720f, 
    -0.01503131f, 0.06213148f, -0.27268684f, 0.13225029f, 0.00460566f, 0.12087313f, -0.04653601f, 0.09340666f, 
    -0.06072572f, 0.05119073f, -0.11654975f, -0.00858136f, 0.07405461f, 0.28607592f, 0.06651057f, -0.04239529f, 
    -0.14719389f, 0.01269503f, -0.02328224f, -0.00618974f, 0.12718849f, -0.08130611f, 0.09256044f, -0.15658863f, 
    -0.40680456f, -0.15203725f, -0.21247493f, -0.24541636f, 0.07430518f, 0.06587977f, 0.20910473f, 0.00680182f, 
    -0.03459650f, -0.05854164f, 0.11129218f, 0.09561320f, 0.03500982f, -0.12130469f, 0.02042329f, -0.21562420f, 
    -0.14162925f, 0.00130267f, 0.03812158f, -0.11309458f, 0.08873018f, 0.09523993f, -0.09003473f, -0.12632480f, 
    -0.02949630f, -0.13763201f, 0.07798717f, 0.12312489f, -0.07684511f, 0.01385173f, 0.09911165f, 0.00133230f, 
    -0.17900273f, -0.16902846f, 0.15007800f, 0.06377260f, 0.11642008f, 0.32982960f, 0.14187025f, -0.33001807f, 
    0.06599792f, -0.06454445f, -0.02109145f, 0.04732506f, 0.05824036f, 0.08133304f, -0.04490031f, 0.03628501f, 
    0.21994185f, -0.07130077f, 0.16864139f, -0.02366093f, -0.05419294f, 0.00780204f, 0.07862695f, 0.10917202f, 
    0.05923753f, -0.04000677f, 0.12510750f, -0.06258938f, 0.13066463f, 0.00095012f, -0.15546238f, 0.00091356f, 
    0.00755278f, 0.00281651f, 0.06648085f, -0.01261935f, 0.04774709f, 0.11684432f, -0.11317055f, -0.14969559f, 
    -0.04735358f, -0.11031493f, 0.23941396f, 0.10737169f, -0.20581119f, -0.01235833f, -0.01080310f, 0.05734973f, 
    -0.13784602f, -0.07800604f, -0.05186552f, 0.01667781f, 0.14522150f, 0.16206281f, 0.09605655f, 0.06827098f, 
    -0.13898700f, 0.01933401f, -0.03834715f, 0.13096058f, -0.02004206f, -0.04288996f, -0.00606774f, 0.04908999f, 
    -0.15200572f, -0.14631504f, 0.09811355f, 0.09101429f, 0.00603979f, 0.05229715f, 0.18012710f, 0.02145634f, 
    0.13556306f, -0.01822029f, 0.01894060f, 0.04823634f, -0.15370815f, 0.01173124f, 0.01126117f, 0.14293562f, 
    0.11539599f, -0.05567121f, 0.03273860f, 0.02677962f, -0.03730911f, -0.03401408f, 0.04931597f, 0.07491308f, 
    -0.27508524f, 0.08967466f, 0.01613613f, -0.13056497f, 0.11179470f, 0.19847603f, 0.06532148f, 0.06370303f, 
    -0.05858745f, 0.09856639f, -0.05838180f, -0.09859101f, 0.06499697f, -0.37016028f, -0.28860018f, -0.24902695f, 
    0.13161260f, -0.05750730f, -0.07200965f, -0.00264773f, 0.02285817f, -0.01239345f, 0.07652984f, 0.09176879f, 
    0.05597702f, 0.01056202f, 0.08231562f, -0.00155809f, -0.04886054f, 0.08421431f, 0.01581108f, -0.01834096f, 
    0.01578116f, -0.12692590f, 0.11056158f, -0.01385633f, -0.32446736f, 0.07938316f, -0.03898195f, -0.23565273f, 
    -0.00984833f, -0.04489326f, -0.11419735f, -0.04617520f, 0.00249140f, -0.00944763f, -0.07021711f, 0.04775437f, 
    0.05971845f, -0.05920032f, 0.26702917f, 0.02687494f, 0.04111749f, 0.03994843f, -0.04934020f, -0.02677089f, 
    0.02432554f, 0.03566606f, 0.00849721f, -0.05034607f, -0.15742162f, -0.11725694f, 0.00628091f, 0.10282143f, 
    0.04407566f, 0.05032079f, -0.00440140f, -0.04616804f, 0.06951462f, -0.02340275f, -0.11116124f, 0.06846241f, 
    0.20662688f, -0.00916224f, 0.17957306f, 0.29892382f, 0.00715315f, -0.04058157f, -0.05995601f, 0.09061737f, 
    -0.00756954f, 0.09732709f, -0.02142620f, 0.07108655f, -0.00594037f, 0.07535453f, -0.31604892f, -0.02249418f, 
    0.05593314f, -0.02387016f, 0.09980401f, -0.02504792f, 0.08464157f, 0.03562628f, -0.01980031f, -0.03890278f, 
    0.02939776f, -0.04516406f, -0.09604407f, -0.06524622f, 0.04723172f, 0.12992124f, -0.03374760f, 0.00829343f, 
    0.13169283f, 0.15900454f, 0.03351443f, -0.00916868f, 0.08556600f, 0.11491210f, 0.09415979f, 0.00435409f, 
    -0.12184048f, 0.05544920f, 0.04965726f, 0.02783468f, -0.03522705f, -0.03974032f, 0.09140403f, 0.14398608f, 
    0.14565009f, 0.16973847f, 0.08477586f, -0.12295642f, 0.05921712f, 0.08655482f, -0.02639295f, 0.10793278f, 
    -0.06012414f, -0.01831451f, -0.14497805f, 0.07089494f, -0.20885938f, 0.14253527f, 0.19096561f, 0.12622140f, 
    0.08108630f, -0.05299570f, 0.07210314f, 0.11459275f, 0.01303733f, -0.00525436f, 0.10320392f, 0.06438254f, 
    -0.00334170f, 0.00147395f, -0.14106619f, -0.04529127f, 0.07619110f, 0.05229703f, -0.04935625f, 0.09971412f, 
    0.05425760f, -0.00266210f, -0.02674526f, -0.10696857f, -0.01565092f, -0.19450083f, -0.13848743f, 0.07923373f, 
    0.19900766f, 0.03531918f, 0.02951004f, -0.00671925f, 0.03464920f, 0.06359389f, 0.05627352f, 0.15871818f, 
    -0.03873174f, 0.27012008f, 0.01869068f, -0.26482034f, 0.10698491f, 0.01640531f, 0.08468480f, 0.04505385f, 
    0.00156444f, -0.05243350f, 0.02609743f, 0.14819129f, -0.09902558f, 0.06535242f, 0.08159498f, -0.26775715f, 
    -0.14009185f, 0.07452417f, -0.10257936f, 0.02027483f, -0.05622391f, 0.12168243f, -0.01107750f, -0.04925242f, 
    0.01248911f, 0.00586830f, -0.01582618f, 0.06712785f, 0.00163790f, -0.11574306f, 0.02502330f, 0.10519498f, 
    0.00161375f, -0.05035463f, 0.06282249f, -0.10072871f, -0.12716623f, 0.25238144f, 0.11246799f, 0.25037634f, 
    -0.14876339f, 0.01793000f, 0.04468489f, -0.06354918f, 0.06230044f, -0.03913937f, 0.04456187f, -0.05336817f, 
    -0.14927933f, 0.00612874f, 0.12404601f, 0.04017484f, 0.04598843f, 0.05382802f, -0.02910774f, -0.07304965f, 
    0.16738243f, 0.05712789f, 0.03366196f, -0.08382836f, -0.07445370f, 0.09016787f, 0.12091514f, 0.06459992f, 
    -0.08749568f, 0.00183744f, 0.10465058f, -0.06638530f, -0.05587943f, 0.15094207f, 0.04542089f, -0.06774912f, 
    -0.03507711f, -0.07566095f, -0.09225329f, -0.34717759f, 0.08708075f, -0.05451984f, -0.02951979f, 0.00948262f, 
    0.03038309f, -0.02870699f, 0.13222469f, 0.03658924f, -0.14086165f, 0.01313213f, 0.09843564f, -0.09962475f, 
    0.14411575f, -0.08850470f, 0.01963879f, 0.00216383f, 0.02290201f, 0.06091266f, -0.02833994f, 0.02352744f, 
    0.15217040f, -0.07313406f, 0.13971046f, 0.27442381f, -0.00778973f, -0.00365279f, -0.06551772f, 0.04214477f, 
    0.04949727f, -0.02357337f, 0.12757336f, 0.05170020f, 0.27209961f, 0.12733500f, 0.08628113f, 0.05795388f, 
    -0.11816367f, -0.06962769f, -0.11197617f, 0.08116880f, -0.00683826f, -0.05830282f, 0.02144969f, 0.05712969f, 
    -0.09386678f, 0.19512488f, -0.03570950f, 0.13946046f, 0.07942247f, -0.00152312f, -0.12070410f, -0.05080753f, 
    -0.02958230f, 0.04146757f, 0.03227871f, -0.06841200f, -0.17470716f, -0.08924733f, -0.15317978f, -0.00773816f, 
    0.20909837f, 0.09068598f, -0.01546119f, -0.09610140f, 0.08974274f, 0.07236209f, 0.05382843f, -0.08634304f, 
    0.01665527f, -0.01571454f, -0.16874070f, 0.18005235f, 0.18050951f, -0.07168844f, 0.05840206f, -0.00801511f, 
    0.10600331f, 0.00685879f, 0.05606810f, 0.07554010f, -0.00774799f, -0.05478361f, 0.10034639f, -0.00106450f, 
    0.04228225f, -0.09345903f, 0.03574798f, 0.08759034f, 0.03288502f, 0.04636829f, 0.08067288f, 0.06371287f, 
    0.32712784f, 0.04084758f, -0.07126102f, 0.10482202f, 0.13496637f, 0.09829711f, -0.04456415f, 0.13307279f, 
    0.05219240f, 0.08837245f, 0.11628231f, 0.16064991f, 0.03787152f, 0.01517098f, 0.08890950f, 0.15612173f, 
    0.02072809f, -0.00191922f, 0.09308539f, -0.08426587f, 0.14653975f, -0.04240695f, -0.00533512f, 0.04871869f, 
    0.22290745f, 0.05508473f, 0.00744400f, -0.18253613f, -0.11141340f, 0.11714713f, 0.12917082f, -0.01434383f, 
    0.11342552f, -0.00974943f, 0.05513734f, -0.00385121f, 0.11724256f, -0.16882114f, -0.00856310f, -0.29381007f, 
    0.06744497f, -0.01186221f, 0.05114331f, 0.06289808f, 0.02736201f, 0.00995530f, -0.04574738f, -0.12066469f, 
    -0.01174448f, -0.11375605f, 0.03128711f, 0.03207353f, 0.04464414f, 0.03104295f, 0.04222161f, -0.04594311f, 
    -0.08899555f, -0.16935359f, 0.20699610f, 0.00617572f, -0.27275389f, 0.03067044f, 0.03459114f, 0.37885174f, 
    0.02258910f, 0.08940411f, 0.11694814f, 0.10314678f, -0.00572214f, 0.05103697f, -0.01948227f, 0.06169312f, 
    -0.18651515f, 0.13187747f, 0.05208674f, -0.10407998f, 0.05811130f, -0.08090969f, 0.03263298f, -0.04442741f, 
    -0.10836560f, 0.03363181f, 0.13372816f, 0.08477464f, 0.01204085f, -0.30454332f, 0.04816045f, 0.00745864f, 
    0.09121182f, 0.12322815f, 0.04858200f, -0.08097482f, -0.03282285f, -0.04295659f, -0.00049405f, -0.02220428f, 
    0.30606806f, -0.09629862f, 0.16986793f, -0.15690324f, 0.03165387f, 0.08319851f, 0.03104650f, 0.11507029f, 
    0.12624611f, -0.09654396f, 0.00508435f, -0.01930751f, 0.03414762f, -0.16507010f, -0.24195860f, -0.11576528f, 
    0.04424936f, -0.07356432f, -0.00693797f, -0.01339914f, 0.08042419f, 0.00512179f, 0.09903734f, 0.15038231f, 
    0.00023879f, -0.34964907f, 0.04643661f, 0.01107338f, -0.00724463f, -0.14515683f, -0.08321317f, -0.01372924f, 
    0.09255806f, 0.11439466f, -0.05035055f, 0.10591576f, -0.36013564f, 0.13424313f, 0.06960618f, -0.26503590f, 
    -0.11221609f, -0.14309505f, -0.01090324f, -0.12896013f, 0.02424725f, -0.05713100f, -0.01648051f, -0.07916190f, 
    0.00692248f, 0.27708223f, 0.00505682f, 0.23876894f, 0.01701789f, 0.09580125f, 0.17599106f, 0.02853368f, 
    0.00297035f, -0.05327215f, 0.09253632f, 0.05831603f, 0.04082479f, 0.28160787f, 0.11946595f, -0.04308797f, 
    0.04131974f, 0.06454775f, 0.04128619f, -0.09390407f, 0.06875512f, 0.09293745f, 0.01581559f, 0.14008364f, 
    -0.16431959f, -0.05453422f, -0.09636821f, -0.23937094f, 0.10415789f, -0.05289456f, 0.01167939f, 0.03235851f, 
    -0.12509254f, -0.09486111f, -0.07216377f, 0.13335148f, 0.26788640f, -0.13739949f, -0.04414437f, -0.04791864f, 
    -0.02431172f, -0.04202471f, -0.14076588f, 0.08655497f, -0.07065546f, -0.13173546f, -0.08445892f, -0.05707837f, 
    0.17334361f, 0.17463185f, 0.11377903f, -0.08670498f, 0.06571110f, 0.11164930f, -0.01631492f, 0.03828097f, 
    0.13752054f, -0.05733317f, -0.00471759f, -0.04259927f, -0.02471901f, -0.01004461f, 0.03732696f, -0.04860984f, 
    0.18169889f, 0.06187113f, -0.00643642f, 0.00228952f, -0.01585211f, -0.06278279f, 0.05226083f, 0.18148604f, 
    -0.02491531f, -0.29152960f, -0.07838897f, -0.04531494f, -0.06735535f, -0.00108305f, -0.12053657f, 0.00159542f, 
    -0.11023760f, 0.01485267f, 0.00844564f, -0.07032770f, 0.00496349f, 0.07155187f, -0.05144051f, 0.09911007f, 
    -0.07510762f, -0.11613469f, 0.01308462f, 0.09511679f, 0.16878106f, 0.08462330f, 0.09905189f, 0.12352890f, 
    0.40335327f, 0.09208120f, -0.21972232f, 0.07758112f, -0.01674174f, -0.13649365f, 0.02714825f, 0.08598528f, 
    0.06421801f, 0.17194684f, -0.10924780f, -0.09275921f, 0.32151526f, 0.13797873f, 0.19022267f, -0.00785147f, 
    -0.23841812f, -0.12343032f, -0.14930315f, 0.23280308f, 0.01328400f, -0.10274790f, -0.17328984f, -0.01980382f, 
    -0.06774868f, -0.12796500f, -0.12582476f, -0.13659494f, 0.10315344f, 0.10042319f, 0.23945519f, -0.03487482f, 
    0.18394631f, -0.06991952f, -0.03159115f, -0.06255250f, 0.46398702f, -0.01579293f, 0.02565015f, 0.16037560f, 
    -0.11504430f, -0.10572750f, -0.12122133f, 0.02791923f, -0.02223244f, -0.04257006f, 0.09231327f, 0.15674333f, 
    0.33605811f, 0.13263524f, 0.09896518f, 0.13145916f, 0.10890124f, 0.08548433f, -0.04746513f, -0.06258892f, 
    0.00659895f, 0.03898703f, 0.17023800f, 0.07119709f, 0.04264772f, -0.10604469f, -0.12462735f, -0.04011900f, 
    -0.12799934f, 0.00239307f, -0.10918034f, -0.00499825f, -0.12686822f, 0.12120891f, -0.11964192f, -0.08008719f, 
    -0.31883553f, -0.23806700f, -0.09014039f, -0.23098998f, -0.07661295f, -0.00436909f, -0.10462759f, -0.02257849f, 
    0.14896348f, 0.10227189f, -0.02694399f, 0.03850152f, -0.17253198f, -0.32774249f, -0.07863353f, -0.22127290f, 
    -0.12512253f, -0.21625616f, -0.14920747f, 0.01084395f, 0.01674821f, -0.05197348f, 0.08169945f, 0.02014422f, 
    0.12917803f, 0.20066494f, 0.20579526f, -0.23142523f, -0.00341386f, -0.09011891f, 0.05501924f, -0.00521283f, 
    0.11472726f, 0.22417408f, -0.19003284f, 0.06805565f, -0.18767619f, -0.12554631f, -0.05372698f, 0.22111113f, 
    0.11789379f, 0.03368849f, -0.04619532f, 0.11098225f, 0.00180695f, -0.09426700f, 0.02853542f, 0.12417879f, 
    -0.39271873f, -0.09469632f, -0.17522462f, 0.10307203f, 0.07226548f, -0.04154132f, -0.01814895f, 0.07382343f, 
    0.11598989f, 0.11234991f, 0.17530078f, 0.16519594f, 0.16879617f, 0.06455278f, -0.23911758f, -0.15364809f, 
    0.11142331f, 0.07669342f, -0.02121345f, -0.18000732f, 0.07362587f, -0.03674499f, 0.26488751f, 0.10386917f, 
    -0.00932340f, -0.11052315f, -0.01659390f, 0.03670446f, -0.05378776f, -0.03702589f, -0.19018596f, 0.16885820f, 
    0.11932696f, 0.12612379f, 0.01947725f, 0.20609599f, -0.11026333f, 0.31177530f, 0.03342221f, -0.08832190f, 
    0.05885649f, 0.16020906f, -0.10894306f, 0.07389171f, 0.15961798f, 0.21803094f, -0.09965155f, -0.16830669f, 
    -0.02752901f, 0.15080436f, 0.00952193f, 0.15884346f, 0.07643975f, -0.06347399f, 0.12735003f, -0.07440142f, 
    0.03820602f, -0.00588493f, 0.08783086f, 0.00776745f, 0.46016544f, -0.12483866f, 0.19173004f, 0.26532307f, 
    0.08710582f, 0.02776501f, 0.04256299f, 0.02698886f, -0.04564353f, 0.02874488f, -0.07640111f, 0.10644520f, 
    0.12310405f, -0.22469814f, 0.10098147f, 0.10765974f, 0.10712213f, -0.05286203f, -0.02291433f, -0.11187565f, 
    0.02295842f, -0.03747266f, 0.04121980f, 0.08823878f, -0.22101626f, 0.00698585f, -0.24317460f, -0.23322760f, 
    0.11969666f, 0.04988188f, 0.12104762f, 0.02417889f, 0.08530075f, -0.02294261f, 0.17401868f, 0.06629991f, 
    -0.20264177f, 0.15449245f, 0.04175043f, 0.14343821f, 0.08843652f, 0.15191948f, -0.00628686f, 0.07614136f, 
    -0.17681071f, -0.04305625f, 0.17523685f, 0.03264910f, -0.31013703f, -0.13203613f, 0.00691830f, -0.06514601f, 
    0.04079726f, 0.03098590f, 0.01198729f, 0.03006081f, -0.06511830f, 0.14503752f, 0.13213034f, -0.04406609f, 
    -0.06428402f, -0.02513815f, -0.14834762f, -0.06220588f, -0.06654926f, -0.09882990f, -0.03280567f, 0.01908300f, 
    -0.00751559f, 0.05961598f, -0.18255967f, -0.03438086f, 0.09976394f, 0.15830207f, 0.03536382f, 0.12304623f, 
    -0.07034351f, -0.00768760f, -0.05828059f, 0.00788473f, 0.02391111f, -0.06129233f, 0.15129241f, 0.03985170f, 
    -0.08801133f, -0.23390552f, 0.03713661f, 0.13795337f, 0.04188402f, -0.02551569f, 0.07560437f, 0.08858550f, 
    -0.12272672f, -0.23318203f, 0.00377589f, 0.04104480f, -0.04314120f, 0.03563252f, -0.16629358f, -0.22053985f, 
    -0.21515863f, -0.04722380f, 0.03533593f, -0.29683322f, 0.00963043f, 0.06214084f, -0.08184805f, -0.08577511f, 
    0.07794419f, -0.08004522f, -0.01327510f, 0.17740554f, -0.07868471f, 0.16467719f, 0.08821328f, 0.10398392f, 
    0.07637443f, -0.14033316f, 0.00613969f, 0.02697287f, 0.02221658f, 0.14782539f, 0.05426451f, -0.57971185f, 
    0.00510683f, -0.09623756f, 0.06780292f, -0.03532949f, -0.00160132f, -0.02444695f, 0.13266765f, -0.01576496f, 
    0.15946083f, 0.16246843f, 0.01334405f, -0.19076003f, -0.02279766f, 0.11038781f, 0.03967906f, 0.07572497f, 
    0.03815668f, -0.00961249f, -0.03542817f, -0.04780134f, 0.08625538f, -0.19090469f, 0.01100304f, 0.03405933f, 
    -0.01279237f, -0.00292030f, 0.07005195f, 0.09458774f, 0.01172915f, 0.05212247f, -0.19371179f, 0.07287925f, 
    0.24046844f, 0.10952058f, -0.16932541f, 0.10073203f, 0.04938118f, 0.11698730f, 0.13419533f, 0.00852971f, 
    -0.05748932f, 0.11488461f, -0.02682218f, 0.03441423f, -0.08116306f, -0.20614837f, -0.00500913f, 0.11295627f, 
    -0.02808398f, 0.01584360f, 0.06356847f, -0.08692260f, 0.06517483f, -0.00829035f, -0.05615402f, 0.05873020f, 
    0.25587684f, 0.15359032f, 0.12402826f, -0.03430594f, 0.03442705f, 0.08067175f, -0.04210663f, -0.04480262f, 
    -0.04798459f, -0.05536387f, -0.05621621f, 0.00700272f, -0.00730513f, -0.01409333f, 0.05988571f, -0.35318121f, 
    -0.07508624f, 0.08815733f, 0.01419847f, 0.03952227f, -0.06511267f, 0.06254684f, -0.04153873f, -0.07071182f, 
    -0.27953658f, -0.00587601f, 0.18180311f, 0.04810183f, 0.01742887f, -0.06156221f, 0.01659362f, -0.01236545f, 
    -0.11807524f, -0.23767352f, 0.15200499f, 0.09350721f, -0.32999635f, 0.08077632f, 0.12194642f, 0.25362998f, 
    -0.05498971f, 0.03297533f, 0.07769550f, -0.14153606f, 0.06397486f, 0.05805163f, 0.12063212f, 0.04560095f, 
    0.03667634f, -0.03026189f, 0.04549209f, 0.07016885f, -0.06802385f, -0.05970293f, -0.10721081f, -0.08585163f, 
    -0.05688966f, 0.03255875f, 0.00414455f, 0.03617225f, 0.15731300f, -0.08137190f, -0.03722787f, 0.05960213f, 
    0.14452656f, 0.01468101f, 0.02136844f, -0.11552180f, 0.06916322f, 0.14902869f, 0.01719282f, 0.03466716f, 
    0.21158828f, 0.01198503f, 0.18744867f, -0.03706038f, -0.07164539f, 0.01414324f, 0.14299779f, 0.01720245f, 
    0.06641775f, -0.02111436f, 0.04048184f, 0.01800667f, -0.07225797f, -0.00827790f, -0.06350964f, -0.28100461f, 
    -0.00841285f, 0.04197284f, -0.11090557f, 0.03818170f, 0.06531240f, -0.09165333f, 0.13544062f, 0.16001745f, 
    -0.02113828f, -0.08171839f, -0.02641345f, 0.05432305f, 0.07650435f, 0.03387817f, -0.05085601f, 0.02040823f, 
    0.02694656f, 0.15845653f, 0.09419172f, -0.02531941f, 0.15604283f, 0.25942913f, 0.11640874f, 0.10371292f, 
    0.11766528f, 0.02632598f, -0.03660446f, 0.17801723f, 0.07877675f, 0.06461017f, 0.03405549f, 0.00460035f, 
    0.06169572f, 0.18475440f, -0.14239842f, 0.24971104f, 0.03885598f, 0.04432408f, 0.04023636f, -0.02343185f, 
    -0.13454659f, 0.00220021f, 0.01497076f, -0.09219369f, 0.17256700f, 0.11009128f, 0.06069210f, 0.13769223f, 
    0.06698781f, 0.03537656f, 0.04581758f, -0.04878227f, 0.02120326f, 0.05074272f, -0.09889455f, -0.10051322f, 
    -0.04952235f, -0.14163032f, -0.19080554f, 0.00737019f, 0.10222177f, -0.05828801f, 0.08402404f, -0.02900439f, 
    -0.06059209f, -0.13559322f, -0.14309716f, -0.07496496f, -0.03728590f, -0.16755043f, 0.31319487f, 0.15414558f, 
    -0.02674109f, -0.12473694f, -0.07769003f, 0.01001150f, -0.00721056f, -0.06597739f, -0.13770138f, -0.06303148f, 
    -0.10176567f, 0.07746986f, 0.26801047f, 0.03218572f, -0.06615362f, -0.07082042f, -0.05815190f, -0.00874576f, 
    -0.06753234f, 0.00093975f, 0.16829383f, -0.02757036f, -0.01854053f, 0.41174218f, 0.31771445f, -0.05422646f, 
    0.04391757f, 0.00391462f, -0.01245966f, -0.01773070f, 0.00178685f, 0.03981276f, 0.04957788f, 0.02774402f, 
    -0.16875726f, -0.06367548f, -0.03693110f, 0.06588183f, -0.15612331f, 0.03862949f, 0.06442890f, 0.09330362f, 
    0.02858242f, 0.09357402f, -0.05693316f, -0.06455248f, 0.19244450f, -0.00422887f, -0.24887836f, 0.23429450f, 
    0.10400551f, -0.11946436f, 0.09493848f, 0.05672827f, 0.12030857f, -0.08967411f, -0.02410408f, 0.10348562f, 
    -0.03337646f, -0.23232290f, -0.17760895f, -0.17927419f, 0.02479972f, 0.05106693f, -0.00749784f, -0.04311591f, 
    -0.01679230f, 0.10867814f, 0.11381661f, 0.03428746f, 0.10154079f, -0.18000416f, -0.17556156f, -0.12207445f, 
    0.07045270f, 0.00625726f, 0.04598024f, 0.18852629f, -0.10249491f, 0.00237239f, -0.08855177f, 0.10902181f, 
    -0.02307429f, 0.13608025f, -0.11061714f, 0.20955002f, -0.09932809f, 0.00558023f, 0.05247340f, -0.02914869f, 
    0.05056528f, -0.13378443f, 0.10932851f, 0.09474389f, -0.08921779f, -0.41513649f, -0.18948039f, 0.04314106f, 
    0.10666356f, 0.05392109f, -0.09900487f, 0.13223854f, 0.03512600f, -0.01077178f, -0.02396334f, 0.20667006f, 
    0.09249057f, 0.32975337f, 0.05341048f, 0.28853679f, 0.13935645f, 0.02170901f, -0.07034592f, -0.10979207f, 
    0.12751426f, 0.01225585f, -0.09898968f, 0.00876272f, -0.38780558f, 0.10324242f, -0.33318257f, 0.14518796f, 
    0.09704830f, 0.08890587f, 0.03895779f, 0.08465794f, 0.08947716f, 0.12595500f, -0.05499123f, -0.03492507f, 
    -0.25888538f, -0.16574924f, 0.00078124f, 0.00184790f, 0.00466365f, -0.03868174f, 0.06907113f, 0.11167596f, 
    -0.02622268f, -0.14089406f, -0.04254381f, 0.02491503f, -0.60029936f, -0.30893284f, -0.22397290f, -0.04854211f, 
    0.24488848f, 0.16668876f, 0.14487292f, -0.07596393f, 0.04439105f, 0.10415041f, -0.15757321f, -0.09095662f, 
    0.16342519f, 0.13863875f, 0.15048620f, -0.13970755f, 0.09824462f, -0.09128287f, 0.16594477f, 0.09952766f, 
    0.08416919f, -0.08506060f, -0.03378569f, 0.09132971f, 0.22454284f, 0.12577783f, 0.33974129f, 0.01952089f, 
    0.01026397f, -0.08730830f, -0.09094092f, -0.00627550f, -0.04543871f, -0.03144338f, 0.05044799f, 0.06401619f, 
    -0.17224787f, 0.21892865f, 0.05682228f, -0.02613415f, -0.14099239f, -0.02900032f, 0.04463428f, 0.04800956f, 
    0.17407188f, 0.07285286f, 0.06239153f, 0.16331153f, 0.29380652f, -0.21592131f, -0.18323746f, -0.07307426f, 
    0.00145913f, -0.07083294f, 0.09431345f, 0.02684313f, 0.10953887f, -0.01841477f, 0.03996307f, 0.03772177f, 
    -0.00144009f, -0.00404560f, 0.05957200f, 0.03996894f, -0.03263208f, -0.01105989f, -0.06301559f, -0.07602827f, 
    0.02444809f, 0.03374024f, -0.03746691f, -0.02138645f, 0.04762841f, -0.04449384f, 0.03577424f, 0.00445448f, 
    0.01996286f, -0.01164954f, 0.04642567f, -0.04818637f, 0.06512427f, 0.04625428f, -0.06907788f, -0.02184089f, 
    0.00632275f, 0.01225904f, 0.04025066f, 0.06420915f, 0.03121682f, 0.03768732f, 0.05155976f, -0.04954235f, 
    -0.02341332f, -0.02574699f, -0.06857976f, 0.05454996f, -0.00610316f, -0.05285010f, 0.03982146f, 0.02812840f, 
    -0.07449508f, -0.03403236f, 0.06235614f, 0.05798227f, -0.06355248f, -0.03446242f, -0.01418771f, 0.06398284f, 
    -0.03118867f, 0.00862149f, -0.03278738f, 0.05059932f, 0.06880413f, 0.05553970f, 0.01057610f, 0.06156466f, 
    0.04929405f, 0.00338268f, -0.00163543f, -0.01541708f, 0.05505981f, -0.00633283f, -0.04758362f, 0.01054284f, 
    0.02679050f, -0.06527446f, -0.01552000f, 0.04219974f, -0.05843068f, 0.00647975f, -0.04515722f, -0.02803599f, 
    -0.00596435f, -0.06590863f, -0.06420171f, -0.04604854f, 0.00307963f, -0.07530357f, 0.01893019f, -0.07000834f, 
    0.04644733f, 0.00147769f, -0.06934761f, 0.06198623f, -0.00589795f, -0.03371834f, 0.03124437f, 0.06102319f, 
    -0.05080517f, 0.05165344f, -0.02908279f, -0.01145570f, -0.01295492f, -0.03173847f, -0.06235075f, -0.02118530f, 
    -0.06120047f, 0.02093350f, -0.01225843f, -0.05489256f, -0.06149478f, 0.06275868f, -0.05453469f, -0.04327887f, 
    -0.05187962f, -0.04300046f, -0.00032012f, -0.01567210f, -0.07094279f, -0.03104401f, -0.01946751f, 0.00808469f, 
    0.01927718f, -0.03958097f, 0.05043215f, -0.03410306f, 0.03594938f, -0.03773559f, 0.01587049f, -0.04131947f, 
    -0.05904905f, -0.06360963f, -0.06277390f, -0.05745133f, 0.00281598f, -0.02488630f, -0.06859554f, -0.05101297f, 
    -0.01740159f, 0.03695353f, 0.05767712f, 0.03860543f, 0.06138807f, 0.01207824f, -0.07267723f, 0.07451297f, 
    0.03438192f, -0.00477512f, -0.01106969f, -0.00113342f, -0.00537314f, 0.06061504f, 0.06138429f, -0.05735405f, 
    -0.03810407f, -0.00444789f, -0.03317965f, -0.06973325f, -0.06881920f, -0.07260576f, 0.04301338f, -0.04842267f, 
    0.05217369f, -0.03505043f, 0.00911776f, -0.05421749f, 0.06636323f, -0.04731390f, -0.04562422f, -0.04203171f, 
    -0.01276460f, -0.04127277f, -0.03212080f, -0.03092876f, -0.03265877f, -0.06868614f, -0.04810106f, 0.06143913f, 
    -0.02597168f, -0.02349395f, -0.01254476f, -0.01807257f, 0.06242478f, 0.02469071f, 0.06859957f, 0.07356424f, 
    -0.06153418f, 0.02769784f, -0.01251224f, -0.03590366f, 0.01203573f, -0.01407640f, -0.04575263f, 0.05479144f, 
    -0.02417931f, -0.05406779f, 0.01627080f, -0.07697169f, 0.00999583f, -0.05915821f, -0.04235725f, -0.03179566f, 
    0.01737470f, -0.03868973f, -0.00786548f, -0.04517882f, -0.00134979f, 0.00268034f, -0.05838613f, -0.05725969f, 
    0.03757480f, 0.02744310f, -0.05976498f, -0.02762685f, -0.05091587f, -0.05842723f, -0.01464927f, 0.02395875f, 
    0.01929549f, 0.02506988f, -0.06890070f, -0.04731981f, 0.01851281f, 0.02548264f, 0.04071572f, -0.07459550f, 
    0.00818244f, -0.01886842f, 0.01856529f, 0.05043250f, -0.05919005f, -0.01452259f, -0.04271796f, 0.02204817f, 
    -0.02298722f, -0.05780120f, -0.07279331f, -0.04805220f, -0.05270571f, 0.05769211f, -0.06893096f, -0.05327205f, 
    0.04069290f, 0.00465160f, -0.05648876f, -0.03533100f, -0.02342081f, -0.01182239f, -0.02417324f, 0.03558663f, 
    -0.00930266f, 0.03663426f, 0.02792964f, -0.07725828f, -0.07379676f, 0.03700687f, -0.04316396f, 0.03662419f, 
    -0.06217204f, 0.03748858f, 0.05055669f, 0.01846012f, -0.06115382f, -0.04350089f, -0.05734355f, -0.01646118f, 
    -0.01094766f, 0.00989222f, -0.05384139f, -0.01286541f, -0.06371995f, -0.03493063f, -0.04662791f, 0.00845487f, 
    0.00626969f, 0.02361827f, 0.04102381f, 0.01737636f, -0.05208693f, -0.05135730f, 0.03132203f, -0.03357833f, 
    -0.00173795f, 0.04740983f, 0.03683515f, 0.03155696f, -0.00778740f, 0.05340153f, -0.03837138f, 0.01104105f, 
    -0.07070524f, 0.04344678f, 0.00390944f, 0.00121040f, 0.03793619f, 0.04930772f, 0.00247305f, 0.00256915f, 
    -0.01153773f, -0.03669591f, 0.04989444f, 0.03938824f, 0.01552798f, 0.02469001f, 0.02947919f, -0.00102851f, 
    -0.04583500f, 0.04639910f, -0.05296381f, -0.04679932f, -0.01070464f, -0.03110431f, -0.04137740f, 0.02075736f, 
    0.01617709f, -0.02801898f, -0.05231728f, -0.03045160f, 0.03105125f, -0.02807317f, 0.03932063f, -0.03973034f, 
    0.01717498f, 0.05452507f, -0.04304764f, 0.06668448f, -0.05046130f, -0.00827207f, 0.03825501f, -0.05990762f, 
    0.03907439f, 0.05734387f, 0.00807885f, 0.01679824f, 0.03468568f, 0.02739577f, 0.05249425f, -0.00255492f, 
    -0.04508911f, -0.01810532f, 0.03999374f, -0.01927094f, -0.07364487f, -0.05756305f, 0.05115075f, -0.06767288f, 
    -0.05528116f, -0.02769491f, 0.04313859f, -0.06859467f, 0.06727637f, 0.06205614f, -0.02187896f, 0.00414762f, 
    -0.04470275f, -0.06252203f, 0.04341248f, 0.00170072f, 0.05118301f, -0.04194230f, -0.00450094f, -0.01866847f, 
    0.05330757f, -0.01480286f, 0.04943646f, -0.01478468f, 0.02980372f, 0.02268617f, -0.02889166f, -0.06176618f, 
    -0.04031358f, -0.06858530f, -0.05080537f, -0.00946310f, -0.08124401f, -0.04713783f, 0.02410014f, -0.02109674f, 
    -0.03293186f, -0.05211894f, -0.01565504f, 0.02467055f, 0.06535187f, 0.05507266f, 0.02111454f, -0.07232893f, 
    0.00781961f, 0.02902381f, -0.06666156f, 0.05209458f, 0.01932781f, -0.06151635f, -0.06020646f, -0.01069003f, 
    0.08371515f, 0.01618698f, -0.05505890f, 0.09943245f, -0.02022969f, 0.01127227f, 0.02086661f, 0.12125891f, 
    -0.02541917f, 0.00204064f, 0.14319257f, 0.15639713f, -0.03452687f, 0.38490599f, -0.07646887f, 0.08046707f, 
    -0.00707471f, 0.06250245f, -0.05052104f, 0.09455520f, 0.03947725f, 0.16089851f, 0.03303544f, -0.02429591f, 
    0.15634815f, 0.10792863f, 0.03829167f, -0.11707126f, 0.05947672f, 0.05970671f, 0.17960042f, 0.01725269f, 
    0.02929292f, 0.10923462f, 0.11690685f, 0.00638155f, 0.43358737f, -0.14002012f, 0.12575980f, -0.17944054f, 
    0.21626419f, 0.02283208f, 0.11636490f, -0.03388195f, -0.06097937f, -0.01549859f, 0.02038749f, 0.01792616f, 
    -0.12849067f, -0.13039070f, 0.17387353f, 0.09310084f, 0.06481379f, 0.05802664f, -0.00173842f, 0.00671994f, 
    -0.15270819f, -0.10359494f, 0.10179573f, -0.05089521f, -0.34100166f, 0.06251819f, -0.07439979f, 0.16884881f, 
    0.01142923f, 0.01252249f, 0.04376418f, -0.02167289f, 0.05632161f, 0.02397677f, 0.02516151f, 0.03074442f, 
    -0.13814767f, 0.01797350f, -0.12320869f, 0.06605016f, -0.03664237f, 0.07509746f, -0.00740183f, 0.06336857f, 
    -0.14198858f, -0.09735004f, 0.09553170f, 0.08879776f, -0.17021358f, -0.21504226f, 0.18454325f, -0.08504543f, 
    0.02706822f, 0.03693897f, -0.01013407f, -0.15715162f, 0.00172376f, 0.06188368f, 0.09612837f, -0.00679642f, 
    0.03149391f, -0.05337909f, 0.16748174f, -0.13823889f, -0.08638149f, 0.00436006f, 0.10180168f, -0.00690834f, 
    -0.00058794f, -0.05075878f, -0.07789589f, -0.10372602f, 0.09593537f, -0.30457643f, 0.03765063f, -0.09904257f, 
    0.17645292f, 0.07276879f, -0.11736558f, 0.02566829f, -0.04244618f, 0.01619530f, 0.02342404f, 0.12117344f, 
    0.01557285f, -0.24627954f, 0.14556859f, 0.32554543f, 0.02507776f, -0.07126851f, 0.01870860f, 0.11248744f, 
    -0.06344178f, -0.10614628f, 0.06020968f, 0.04447050f, -0.01089871f, 0.16576917f, 0.04375853f, 0.09841561f, 
    -0.05802792f, 0.06061748f, 0.05378263f, -0.28257373f, 0.00974946f, -0.04164746f, -0.07661717f, -0.07398362f, 
    -0.00668443f, 0.30671296f, -0.13479021f, 0.19355927f, -0.00058217f, 0.08039013f, -0.00413073f, 0.02222986f, 
    0.13020408f, -0.06715371f, 0.04855085f, -0.01680284f, 0.02792923f, 0.22982460f, 0.14725514f, -0.26814738f, 
    -0.02571628f, 0.01684061f, 0.08388190f, -0.01778350f, -0.01151060f, -0.03173120f, 0.02050761f, 0.00930767f, 
    -0.10821174f, 0.08841200f, -0.16123015f, -0.11486588f, -0.13492553f, -0.02508613f, -0.00888781f, -0.06933935f, 
    0.02693897f, -0.08653080f, -0.02861566f, -0.03415782f, 0.20066857f, -0.28855547f, 0.12601286f, 0.12270924f, 
    -0.04985443f, -0.11448116f, -0.06561154f, 0.00028171f, 0.01147442f, 0.00644447f, -0.15274970f, -0.05056336f, 
    -0.08533975f, -0.28726804f, 0.09308672f, 0.08640270f, -0.01843754f, 0.04141252f, 0.05982958f, 0.05891091f, 
    0.02567215f, -0.01880927f, -0.12132900f, -0.13455079f, 0.19456589f, -0.17454581f, -0.03963450f, 0.06861858f, 
    0.13226859f, -0.09086239f, 0.02308150f, -0.10680626f, 0.02252796f, -0.05941999f, 0.18269758f, 0.14950863f, 
    0.25205383f, -0.14344594f, -0.04778487f, -0.26992455f, 0.01075276f, 0.07949132f, 0.07483593f, -0.04414023f, 
    0.01034921f, 0.03506800f, -0.00113502f, -0.04436447f, -0.19335553f, 0.11041909f, -0.06768632f, -0.00685544f, 
    -0.07539351f, -0.07417542f, -0.08279470f, 0.05649118f, 0.04006418f, 0.07576706f, 0.09293935f, 0.00189734f, 
    0.14146900f, -0.12742779f, -0.13179676f, 0.01296698f, -0.03844224f, 0.07176567f, 0.11538608f, 0.13930190f, 
    0.13803220f, 0.09387206f, -0.05449970f, -0.08708318f, 0.42619461f, 0.11945166f, -0.04273077f, 0.00999777f, 
    -0.11238078f, -0.08668374f, 0.05493418f, 0.14541274f, -0.02376707f, -0.11173573f, -0.07420327f, -0.13741072f, 
    -0.04239151f, -0.05548551f, -0.00219490f, -0.23399816f, 0.07813779f, 0.01821737f, 0.15312420f, 0.00237664f, 
    0.13790594f, 0.05671864f, 0.11193022f, -0.18571299f, 0.15349677f, 0.05493499f, -0.02158508f, -0.03384101f, 
    0.00469405f, 0.08226742f, -0.07222914f, -0.03510337f, -0.05049121f, -0.09699880f, -0.02837955f, 0.06198579f, 
    0.05283045f, -0.15616111f, 0.16835234f, -0.16225654f, 0.09784320f, -0.06030102f, -0.05904433f, -0.05436365f, 
    -0.00404296f, 0.02306640f, 0.11434499f, 0.16888900f, 0.43119854f, -0.08297165f, 0.04346323f, 0.09800937f, 
    -0.07343256f, -0.03942354f, 0.08787009f, 0.05992057f, 0.06267788f, 0.00063607f, -0.21985686f, -0.05678276f, 
    0.02530865f, -0.05003530f, -0.01734989f, 0.16515106f, 0.08133972f, 0.07428851f, -0.03109258f, -0.06770150f, 
    0.08694874f, 0.17235442f, -0.13886738f, 0.00467789f, 0.20631462f, 0.06512479f, -0.03010049f, 0.13451968f, 
    -0.04174406f, -0.00236161f, 0.05469909f, -0.04056891f, -0.02716105f, -0.06918514f, 0.03333368f, 0.04988756f, 
    -0.19737953f, 0.11822770f, 0.08588384f, -0.04180055f, 0.06683446f, -0.02598375f, 0.06751738f, -0.04745062f, 
    0.05305853f, 0.17582038f, -0.08942413f, 0.05224423f, -0.08048882f, -0.11200839f, -0.17183040f, 0.18229440f, 
    0.16754453f, 0.08406325f, -0.01733335f, -0.10687390f, 0.02021039f, -0.06023620f, 0.07721604f, 0.24120016f, 
    -0.11471871f, 0.00733744f, 0.05100689f, -0.04024919f, 0.14236423f, -0.08904835f, -0.00340293f, -0.07851154f, 
    -0.09537753f, 0.16602796f, 0.10149435f, 0.10403895f, 0.18298985f, 0.19340876f, -0.24235909f, -0.05694808f, 
    0.00472579f, 0.01986057f, -0.03059427f, 0.03360114f, -0.09725004f, 0.13303684f, 0.05773643f, 0.14479773f, 
    -0.10595094f, -0.04038484f, 0.17584327f, 0.04004094f, -0.07599342f, -0.06302296f, 0.03959444f, 0.03008867f, 
    -0.14715481f, 0.10807436f, -0.02108307f, 0.15788378f, 0.07166214f, 0.10845597f, 0.10172287f, 0.13959748f, 
    -0.04290762f, 0.04633720f, 0.07701110f, 0.02426391f, 0.01226185f, 0.11654869f, -0.13220966f, -0.13457398f, 
    0.09949308f, 0.06783108f, 0.01972509f, 0.12081786f, 0.06159509f, 0.07401218f, 0.01635028f, 0.03606647f, 
    0.11481860f, 0.06604291f, 0.02307906f, -0.03767183f, 0.18547854f, -0.00749959f, 0.04594398f, 0.12413127f, 
    0.00712122f, -0.01945744f, 0.08095328f, -0.10084230f, -0.02691158f, -0.13241133f, 0.12316346f, 0.02506894f, 
    -0.12597117f, -0.11924584f, 0.02392895f, -0.00103370f, 0.11982509f, 0.03657038f, -0.01716885f, 0.11044622f, 
    -0.10321691f, -0.06197776f, -0.01799110f, 0.11827337f, -0.06727529f, -0.33922395f, -0.08925191f, -0.12443380f, 
    0.04721240f, -0.09498268f, -0.01322413f, 0.03798384f, 0.05236274f, -0.01114457f, 0.23862219f, -0.01807708f, 
    -0.15498939f, -0.11006537f, 0.16227891f, 0.15841414f, 0.09041230f, 0.15596288f, -0.11146141f, 0.05193399f, 
    -0.11052562f, -0.03565595f, 0.05794886f, 0.16986817f, -0.02246464f, 0.03885056f, -0.10812451f, -0.08704377f, 
    0.07970605f, -0.04946038f, 0.02026577f, 0.07026143f, -0.07515069f, -0.09402511f, 0.03531250f, 0.01661962f, 
    -0.13056718f, 0.10474677f, -0.09471275f, -0.06157359f, 0.03879625f, 0.03252829f, -0.00721914f, 0.05842445f, 
    0.07369834f, -0.06612667f, -0.03494937f, 0.01273751f, 0.49912190f, -0.18979354f, 0.09798013f, 0.33819950f, 
    -0.02559707f, -0.06964466f, -0.00678125f, -0.00620665f, 0.01811813f, 0.01993068f, 0.05899835f, 0.03094329f, 
    0.30667672f, 0.11477539f, 0.06399610f, 0.07785976f, 0.05968351f, 0.01300861f, 0.10590498f, -0.02896932f, 
    -0.12682296f, 0.01654552f, -0.03331080f, 0.04131782f, 0.10198671f, 0.07304288f, -0.00965695f, -0.02074690f, 
    -0.09161314f, -0.05545675f, 0.02443074f, -0.09963828f, 0.00614571f, 0.12757407f, -0.08375257f, 0.10377380f, 
    -0.07206847f, -0.23261049f, 0.05409233f, 0.10056139f, -0.08240670f, 0.12732975f, 0.09968213f, 0.20618579f, 
    0.05860822f, -0.00738561f, 0.01482978f, -0.09265067f, -0.09104431f, 0.09332108f, 0.06302784f, -0.13650486f, 
    -0.12245063f, 0.07632695f, 0.03247715f, -0.04538736f, 0.05447077f, -0.00564408f, 0.02307456f, 0.06756600f, 
    0.19745713f, 0.16918720f, 0.23361915f, 0.02762020f, 0.02845085f, 0.09816596f, -0.10854986f, -0.10683621f, 
    -0.00523745f, -0.04765091f, -0.00899664f, -0.04895243f, -0.24582943f, 0.05437731f, 0.19224738f, 0.02978695f, 
    -0.00223191f, 0.05621269f, 0.09987520f, 0.22488445f, 0.07446107f, 0.07742802f, -0.10963075f, -0.07400548f, 
    -0.04719332f, -0.03318126f, 0.01031368f, 0.06630600f, -0.02528411f, -0.04827802f, 0.00643631f, -0.05904955f, 
    -0.06974942f, -0.05029384f, -0.06592182f, -0.07219461f, 0.04441498f, 0.01679666f, 0.01031892f, -0.07364098f, 
    0.02313496f, 0.01826733f, 0.05198347f, -0.02265958f, 0.05406572f, -0.05013723f, 0.02343396f, -0.06803973f, 
    -0.06066248f, -0.05492882f, 0.05624428f, -0.03905708f, -0.05556724f, 0.00449320f, -0.05085306f, 0.04025016f, 
    0.01416516f, -0.07314717f, 0.05374404f, -0.00918796f, 0.03336865f, 0.04984786f, -0.05093362f, 0.05324452f, 
    -0.06601261f, -0.05910510f, -0.03179481f, -0.03253736f, -0.03600466f, -0.00480058f, -0.04078787f, -0.05809934f, 
    -0.06180540f, 0.03037629f, -0.06863772f, -0.07357898f, -0.04452248f, 0.06089981f, -0.02572262f, -0.07721740f, 
    -0.03375638f, 0.00877466f, -0.02543362f, -0.03561902f, 0.03214698f, 0.06892356f, -0.05740605f, -0.03158675f, 
    0.04752020f, -0.01629321f, 0.05064510f, -0.01393623f, -0.03829461f, -0.02827246f, 0.00863749f, 0.02211277f, 
    0.04689231f, 0.01046306f, -0.00172928f, 0.05189356f, -0.07253411f, -0.05759588f, 0.02707089f, 0.06650429f, 
    -0.04985015f, -0.05035605f, -0.00657300f, 0.00128568f, 0.05678106f, -0.03201289f, 0.04914192f, 0.04822914f, 
    -0.06587704f, 0.05984484f, -0.02370703f, -0.01168968f, -0.05298619f, -0.02470066f, 0.02105452f, -0.06867832f, 
    -0.00180853f, -0.04947713f, -0.00631567f, -0.01068514f, -0.01955087f, 0.01905982f, 0.01139212f, 0.01045544f, 
    0.04293243f, -0.05170800f, -0.03721895f, 0.05162679f, -0.06151728f, -0.06908701f, 0.04634864f, 0.01563005f, 
    -0.01735403f, -0.05392755f, -0.05851390f, -0.07127564f, -0.04722990f, 0.05917097f, -0.07083919f, -0.05487685f, 
    -0.06748526f, 0.02783528f, 0.02857248f, -0.00331319f, -0.05195261f, 0.06680888f, -0.04977568f, -0.00219999f, 
    -0.01672325f, 0.06508217f, -0.06380508f, -0.01237581f, -0.00978811f, 0.00770645f, -0.07090819f, 0.06231938f, 
    -0.01077343f, 0.01190588f, 0.06131377f, 0.06174214f, 0.06387903f, -0.03813576f, -0.00932576f, -0.06970292f, 
    -0.04234890f, -0.06091806f, -0.01324901f, -0.04344632f, 0.01316014f, -0.07461726f, 0.02267107f, 0.00533083f, 
    -0.01374430f, 0.02095432f, 0.00258580f, -0.06583363f, -0.06347129f, 0.02268845f, 0.01716271f, -0.02078567f, 
    0.04984456f, -0.02544147f, -0.01147560f, -0.00422989f, -0.01600479f, 0.04368194f, -0.05067351f, -0.02312127f, 
    0.01843356f, 0.01201945f, -0.03493869f, 0.06178341f, 0.06180405f, 0.05930389f, 0.05466148f, 0.03871566f, 
    0.06398887f, -0.00004363f, -0.06666435f, 0.02098916f, 0.02317170f, -0.00723170f, -0.02323906f, -0.03642887f, 
    0.01255287f, 0.01185566f, -0.01457213f, -0.04387681f, 0.05731917f, -0.06634028f, 0.01594884f, 0.04444241f, 
    0.03058084f, -0.03400080f, 0.06060640f, 0.03271500f, -0.03420480f, 0.03295226f, 0.02602713f, 0.06217853f, 
    -0.06485672f, 0.03399534f, -0.03831052f, -0.05847048f, 0.04888443f, -0.07257248f, 0.03585948f, 0.03290650f, 
    -0.04103443f, -0.02272063f, 0.02207905f, 0.06302656f, -0.02466607f, 0.00221222f, 0.06280455f, -0.03793112f, 
    -0.01288961f, 0.05710420f, -0.05903412f, -0.00990275f, -0.06710435f, 0.01695746f, -0.07854412f, 0.02593929f, 
    -0.03868835f, -0.05800574f, -0.07034421f, -0.04385081f, 0.03638557f, 0.02055009f, -0.03947025f, 0.05461654f, 
    -0.07205439f, -0.04790564f, -0.00921603f, 0.03657003f, -0.00907508f, 0.01582163f, -0.06859024f, 0.03499703f, 
    -0.00795696f, -0.00177890f, 0.02839912f, 0.02462344f, -0.02028891f, -0.03576664f, -0.07819397f, -0.03031538f, 
    -0.00489696f, -0.00771817f, -0.01505081f, 0.03756415f, 0.05121328f, 0.06473036f, -0.00016950f, -0.06165478f, 
    0.01096642f, 0.04588575f, -0.07394544f, 0.04224383f, -0.00949769f, -0.01532989f, 0.00316306f, 0.02373170f, 
    0.04063536f, -0.03055626f, -0.04129076f, 0.04371518f, -0.06728289f, 0.01370068f, -0.03779322f, 0.05225657f, 
    0.00658715f, 0.01813330f, 0.04152962f, -0.07005428f, 0.04924774f, -0.02721692f, -0.03011916f, 0.03919105f, 
    0.02931942f, 0.04623603f, -0.06150085f, -0.06538524f, -0.02735386f, -0.02261896f, -0.03662082f, -0.01261918f, 
    0.03687497f, -0.00312190f, -0.03842352f, -0.07211708f, -0.05582398f, 0.01973257f, -0.03559209f, -0.02917807f, 
    -0.01348176f, -0.00554362f, 0.03713024f, -0.07538486f, -0.06147014f, -0.02693859f, -0.07004386f, -0.05696369f, 
    0.00870561f, 0.01031945f, 0.02926872f, 0.04248069f, -0.06198052f, -0.03997223f, -0.00606386f, -0.02751241f, 
    0.05296927f, -0.06832208f, -0.02184891f, -0.04858199f, 0.02145119f, -0.07423507f, 0.03013148f, 0.03638449f, 
    -0.06551035f, -0.03773255f, -0.06731305f, -0.01409483f, -0.04797685f, 0.01563363f, 0.04687743f, -0.03385453f, 
    -0.07299419f, 0.05630198f, -0.07076225f, -0.04168010f, -0.03092387f, 0.05398985f, 0.00090193f, 0.02267962f, 
    0.04752369f, 0.06354899f, -0.01954185f, -0.03505616f, -0.02568987f, -0.03566116f, -0.01028392f, -0.07252467f, 
    0.02746696f, 0.00713134f, 0.05893502f, 0.02548996f, -0.06819922f, -0.05420596f, 0.02617145f, 0.04816032f, 
    -0.06098952f, 0.04872558f, -0.00388696f, 0.05541406f, -0.06797760f, 0.02917024f, -0.07196175f, -0.07305347f, 
    0.00601757f, -0.02863172f, -0.04472600f, -0.00533572f, -0.00296526f, 0.02661595f, -0.01384923f, -0.06335540f, 
    -0.01135297f, -0.06253285f, -0.05763543f, -0.00316852f, -0.04853513f, 0.01457797f, 0.06454629f, 0.04047266f, 
    -0.00998238f, 0.01307847f, -0.07760742f, 0.05724428f, -0.08032844f, 0.00976507f, -0.01094044f, 0.04388341f, 
    -0.27488154f, -0.05151396f, 0.16583605f, -0.02011765f, -0.12648295f, -0.04961689f, 0.08501741f, -0.16697943f, 
    0.05609413f, -0.03557233f, 0.13177210f, 0.05252990f, 0.07884399f, 0.31582066f, 0.13728806f, -0.23511207f, 
    0.05193301f, 0.05145012f, -0.03739263f, 0.09487643f, -0.05411458f, 0.01992167f, -0.06574538f, -0.10461600f, 
    -0.25840262f, 0.08206289f, -0.19654663f, 0.26855311f, -0.03804391f, -0.02380835f, -0.12804393f, 0.06369752f, 
    0.01769513f, 0.11625279f, -0.04942750f, 0.00221862f, 0.15551090f, 0.20311154f, -0.13208555f, 0.43072176f, 
    0.06225353f, 0.01791419f, 0.02621883f, -0.06640835f, 0.06257585f, -0.06819127f, 0.00731456f, 0.07787839f, 
    0.15302844f, -0.10072785f, 0.03770115f, -0.14142361f, 0.00258084f, 0.12116934f, -0.16609845f, -0.05701775f, 
    -0.01690978f, -0.02607438f, 0.05368747f, 0.03207544f, 0.20091477f, -0.03025334f, 0.01555447f, -0.26834878f, 
    0.19067948f, -0.09271511f, -0.04637691f, 0.05655485f, -0.05699657f, 0.03472204f, 0.05499638f, 0.04495910f, 
    0.22419669f, 0.27621067f, -0.06512515f, 0.13419387f, 0.09639668f, -0.02905928f, -0.04300353f, 0.11755477f, 
    0.00227561f, -0.07664808f, -0.01509980f, 0.10608476f, 0.07658829f, -0.04496443f, -0.11974453f, 0.12609065f, 
    0.06058208f, -0.08639216f, 0.02892360f, 0.22992975f, 0.07384314f, 0.06349664f, 0.02693713f, 0.02104499f, 
    -0.23993611f, 0.27470461f, -0.22850387f, 0.18787521f, 0.06836436f, 0.02414501f, -0.04130735f, 0.02677730f, 
    -0.00783119f, 0.09970754f, -0.14393906f, 0.00933451f, -0.23464322f, 0.26520634f, -0.08790153f, 0.15427285f, 
    -0.10433110f, -0.03316991f, 0.06665824f, 0.14731921f, 0.00946237f, 0.06779831f, 0.12409887f, -0.04524578f, 
    -0.53719074f, 0.00996986f, -0.06766941f, 0.04761383f, -0.00986059f, -0.04501419f, 0.13302906f, -0.10621069f, 
    -0.08821309f, -0.05809134f, 0.06448004f, 0.01469509f, -0.16543993f, -0.20182657f, -0.05704597f, 0.05350456f, 
    0.07045061f, 0.06692296f, 0.10232111f, -0.02868313f, 0.08542221f, 0.12879889f, 0.03955847f, -0.06648111f, 
    0.19997506f, -0.28203624f, 0.10757532f, -0.19907418f, -0.07659034f, -0.02355932f, 0.07839787f, 0.09956443f, 
    -0.08059256f, -0.13437551f, -0.00036544f, 0.03356212f, 0.12340559f, 0.12630340f, 0.10542964f, -0.21540701f, 
    -0.03546598f, 0.03183514f, 0.06685346f, 0.05604364f, -0.10737401f, 0.01092142f, -0.02505419f, -0.04772275f, 
    -0.00759551f, 0.07496820f, 0.05010191f, 0.21407840f, -0.05581228f, 0.03105978f, -0.08531137f, 0.00291428f, 
    0.04113527f, 0.06631526f, 0.11771187f, 0.01054788f, -0.04121560f, -0.02036144f, -0.08564030f, -0.04125917f, 
    0.00179865f, -0.00613765f, 0.05122529f, 0.09512477f, -0.05071162f, -0.04073977f, 0.04732290f, -0.05104671f, 
    -0.03805736f, -0.11861666f, 0.01499022f, 0.08802874f, -0.01155313f, 0.03835365f, 0.02774866f, 0.09349605f, 
    -0.06871507f, 0.03706192f, 0.01691247f, -0.12803787f, 0.03204058f, -0.09202670f, -0.01717763f, 0.08855642f, 
    -0.05033305f, 0.06476305f, 0.01219563f, 0.04177628f, 0.05888962f, -0.03467612f, -0.04953921f, -0.10763990f, 
    0.06150203f, -0.08548293f, 0.03840135f, -0.04167049f, 0.07339288f, -0.01670925f, -0.06296935f, -0.08377334f, 
    -0.08162782f, -0.13119777f, -0.03829889f, -0.06422090f, 0.05526819f, -0.03875482f, -0.03676934f, -0.06521821f, 
    0.03628703f, -0.02793630f, -0.08137669f, -0.01217673f, 0.01345137f, -0.03244659f, -0.07357858f, 0.06111217f, 
    -0.05877979f, -0.04807425f, -0.10358051f, 0.07394703f, 0.01479765f, -0.08555470f, 0.09044225f, 0.00325309f, 
    0.01013460f, -0.02998210f, -0.01271124f, -0.02461533f, -0.00816339f, -0.03027353f, 0.00927839f, -0.03818154f, 
    0.00048715f, -0.01860668f, -0.00969233f, -0.04052996f, -0.01040208f, 0.00477135f, -0.01693687f, 0.00047626f, 
    0.07111986f, -0.06374411f, -0.02802032f, 0.02072832f, 0.01560911f, -0.09166144f, 0.00939068f, 0.07130010f, 
    -0.01897687f, 0.07901572f, -0.02546563f, 0.03095704f, -0.00275901f, 0.06733403f, -0.04743063f, 0.03660517f, 
    -0.00368326f, 0.02294923f, 0.01177545f, -0.08728952f, -0.00292766f, -0.05568432f, -0.02106012f, -0.04422020f, 
    -0.05223135f, 0.02406621f, -0.00117200f, -0.03363507f, 0.06836393f, 0.01030162f, 0.05573841f, -0.03952532f, 
    0.02004178f, -0.00849046f, 0.02356000f, -0.00397834f, -0.07583159f, -0.09362330f, -0.07857998f, -0.06579089f, 
    -0.00051170f, -0.09459062f, 0.00472523f, -0.11801429f, -0.04894728f, -0.02896913f, 0.07205433f, 0.03999817f, 
    -0.03753860f, 0.06474435f, -0.07862356f, 0.01749349f, -0.04169365f, -0.07043703f, -0.06170454f, 0.05327227f, 
    0.03753575f, -0.05855906f, -0.06485194f, -0.02135533f, 0.00742609f, -0.03619594f, -0.07598940f, 0.00969937f, 
    -0.05927404f, -0.01732106f, -0.03827671f, -0.13764530f, 0.02726501f, -0.00995370f, -0.06332833f, -0.08892928f, 
    -0.07025459f, -0.02209217f, -0.06996465f, -0.01651535f, -0.12631361f, -0.03743590f, -0.10788702f, -0.04950485f, 
    -0.01862108f, 0.07827154f, 0.06238697f, -0.14491092f, -0.08381902f, -0.02101541f, 0.01423441f, -0.02212923f, 
    -0.11507173f, 0.02263306f, -0.01742491f, -0.03575680f, 0.07528180f, 0.04351998f, -0.05503742f, -0.06850185f, 
    -0.04253409f, -0.03438044f, 0.04162539f, 0.02852106f, 0.04945535f, 0.03144668f, 0.03320142f, -0.07906378f, 
    -0.12994950f, -0.05299832f, -0.08671822f, -0.00563653f, 0.04246646f, 0.05031916f, -0.03403097f, 0.02063499f, 
    -0.04095548f, -0.02465383f, -0.06990461f, 0.05403066f, -0.06009441f, -0.00168983f, -0.03118165f, -0.01235933f, 
    0.20253408f, -0.11695071f, -0.17247100f, 0.11803277f, 0.04019577f, -0.01550564f, -0.08006570f, 0.09678759f, 
    0.08890130f, 0.08390834f, 0.05715777f, 0.18878749f, 0.28870577f, 0.24162747f, -0.06459066f, -0.12370697f, 
    -0.04817998f, 0.16800918f, 0.04398485f, -0.06835245f, -0.02522696f, 0.10599578f, 0.00080256f, -0.02034817f, 
    0.00599303f, -0.05467389f, 0.01872987f, 0.08671609f, 0.03747466f, -0.07581240f, 0.03141533f, -0.02719685f, 
    0.03540096f, 0.14241293f, 0.07580001f, 0.05827731f, 0.19213638f, -0.13165674f, 0.09264957f, 0.07827982f, 
    0.03532307f, -0.03438787f, 0.05859763f, 0.03940471f, 0.10317373f, -0.01500215f, -0.03995993f, -0.10941840f, 
    0.13539714f, 0.04398540f, 0.11700626f, 0.09304821f, 0.12243092f, -0.07360720f, -0.15017982f, 0.04573166f, 
    -0.01151349f, -0.05276985f, -0.02184134f, 0.07758644f, -0.13578019f, 0.02722649f, -0.10793133f, -0.09340286f, 
    -0.00025570f, -0.03982728f, 0.08614156f, 0.04160912f, -0.03974318f, 0.07993705f, 0.02992344f, 0.09557524f, 
    -0.14788829f, 0.25900501f, -0.15929227f, -0.09477436f, 0.11571452f, -0.01420857f, 0.04901293f, 0.01078350f, 
    -0.10134059f, -0.01363979f, -0.00165472f, 0.18315959f, -0.24353853f, -0.02073810f, 0.04678469f, 0.06053260f, 
    -0.11445323f, 0.03658145f, -0.01099817f, 0.03119824f, -0.04974205f, 0.04984048f, 0.07213095f, -0.05939867f, 
    0.08126952f, -0.17568424f, -0.08908255f, -0.01662242f, -0.05002534f, -0.05700855f, 0.02115173f, -0.06326140f, 
    0.01852556f, 0.08924270f, -0.11496115f, 0.02739832f, -0.33211219f, 0.31065324f, -0.04366296f, 0.05735938f, 
    0.10538772f, -0.03145431f, 0.10896806f, 0.04890062f, 0.05568144f, 0.05482962f, -0.03495418f, 0.01291946f, 
    -0.16513123f, -0.05645399f, 0.17991510f, 0.07282742f, -0.06529120f, 0.00365358f, 0.06010301f, 0.05198926f, 
    -0.01683393f, -0.15180059f, -0.02121195f, 0.05908065f, -0.19460149f, -0.04570663f, -0.04338610f, -0.36546552f, 
    -0.19080804f, -0.14613184f, -0.05988051f, -0.13326676f, -0.06239178f, -0.10480774f, -0.06683833f, -0.08833405f, 
    0.05575532f, 0.02083348f, -0.00590467f, 0.00784478f, -0.06280053f, 0.11305862f, 0.11764107f, 0.04659639f, 
    -0.03043775f, -0.21042481f, 0.03639420f, 0.04295355f, 0.14053875f, 0.06029339f, -0.02674396f, -0.07247853f, 
    0.04255777f, -0.06596538f, 0.04082863f, 0.00782342f, 0.00965993f, -0.05719328f, 0.17123601f, 0.07076131f, 
    0.12439510f, 0.11939441f, 0.15627080f, 0.00193885f, -0.06221328f, 0.08659527f, 0.06827917f, 0.09941694f, 
    0.06421515f, -0.12157642f, 0.00113048f, -0.04604318f, 0.23341146f, -0.00697353f, -0.13386142f, -0.07982199f, 
    0.02541569f, -0.02398368f, 0.05131129f, 0.10479652f, 0.00071934f, 0.01320783f, -0.13716356f, 0.05421153f, 
    -0.07878371f, -0.13375370f, -0.03698639f, 0.10655528f, -0.05514574f, 0.07245848f, -0.03806686f, 0.06977985f, 
    -0.06289974f, 0.06309501f, -0.13035929f, 0.02614920f, -0.13506496f, -0.09444157f, -0.14437851f, 0.23491101f, 
    0.08210623f, -0.04145693f, 0.01162472f, 0.01567969f, 0.13046144f, 0.16923711f, 0.06422590f, 0.02132763f, 
    0.38748047f, 0.03881983f, 0.02171572f, -0.20880608f, 0.07907296f, 0.13526843f, 0.16598225f, -0.08502879f, 
    0.10523532f, -0.07293130f, 0.07102902f, -0.11263862f, -0.00522948f, -0.11734895f, -0.09811527f, -0.05989111f, 
    0.05309366f, -0.08129966f, 0.02813010f, 0.02036419f, -0.09732999f, 0.00022795f, 0.11070620f, -0.00339942f, 
    0.20557931f, -0.27436334f, -0.07855637f, 0.21320972f, -0.04204529f, 0.09018096f, 0.11380140f, 0.11098224f, 
    0.07875208f, 0.10174855f, 0.04309117f, -0.02632117f, 0.11499552f, 0.03879898f, -0.13759312f, 0.03314083f, 
    -0.11568051f, -0.11961260f, 0.11900637f, 0.09812390f, 0.14955942f, -0.12832569f, 0.19233900f, -0.04095108f, 
    -0.35949492f, -0.10709314f, 0.11347109f, 0.04673919f, 0.00206016f, 0.08406683f, 0.08907306f, -0.00068568f, 
    -0.05112525f, 0.01585774f, 0.08865009f, -0.05887489f, -0.07214846f, -0.03081516f, -0.05504065f, -0.12654625f, 
    0.07248746f, 0.10499080f, 0.10599022f, -0.06377559f, -0.07116771f, -0.08989131f, 0.05593039f, 0.13416699f, 
    0.20026873f, -0.16501921f, 0.26580849f, -0.26865497f, -0.07363265f, 0.06062784f, -0.09022123f, 0.10722727f, 
    0.00996867f, 0.00139808f, 0.08450507f, 0.07612883f, 0.31580150f, -0.21979441f, 0.02476960f, -0.17825724f, 
    -0.11143192f, -0.06857028f, -0.01281029f, -0.08206477f, 0.10436531f, -0.02155807f, 0.02924987f, -0.00379437f, 
    -0.01687025f, -0.30270302f, -0.04498683f, 0.13277298f, 0.02600903f, 0.02657570f, -0.03391322f, 0.05323758f, 
    0.01680755f, 0.09096216f, 0.01969377f, 0.04466776f, -0.00646920f, 0.05647592f, -0.15042043f, -0.12506519f, 
    -0.13388366f, -0.05243449f, 0.16332456f, -0.28455493f, 0.00898250f, 0.02125612f, -0.02401757f, -0.04670307f, 
    -0.33306131f, 0.14050348f, -0.10554896f, 0.23231429f, 0.05838371f, -0.05297978f, 0.03214721f, -0.00741359f, 
    0.07349104f, 0.03276250f, -0.01421985f, 0.09707065f, -0.00065212f, 0.25850323f, 0.11775566f, -0.15424563f, 
    0.07527223f, 0.02538446f, 0.12738894f, 0.07545371f, -0.02871195f, 0.02856079f, 0.11236151f, 0.24262467f, 
    0.10219718f, -0.09075287f, 0.01443522f, -0.33744940f, 0.06164937f, -0.03693150f, 0.13830882f, -0.03227266f, 
    -0.09735457f, -0.03558006f, -0.03564064f, 0.04826372f, 0.25523907f, -0.02568443f, -0.21166043f, 0.13590296f, 
    -0.02863910f, 0.10577569f, -0.04801489f, -0.02274744f, -0.05392892f, -0.01637538f, 0.10200390f, 0.03607649f, 
    -0.24489020f, -0.11866973f, 0.22768971f, 0.07569509f, -0.10596371f, 0.01628351f, 0.01438262f, -0.08199710f, 
    -0.11184873f, -0.03365628f, -0.06044808f, -0.05302718f, -0.26387411f, -0.03698738f, 0.03087675f, -0.00990297f, 
    0.05814920f, 0.00147293f, 0.02843266f, 0.03405327f, 0.00240408f, 0.02866510f, 0.02712445f, 0.02631363f, 
    0.31850946f, -0.06847838f, 0.12546864f, 0.06418798f, -0.08320357f, 0.12992467f, 0.00136116f, -0.14206687f, 
    0.08058729f, -0.13368407f, -0.00633410f, -0.14641710f, 0.09281239f, 0.05921750f, -0.11473303f, 0.25996846f, 
    0.19724217f, -0.05126496f, 0.11047324f, -0.06161756f, -0.00934035f, 0.06881408f, 0.15274002f, -0.04996671f, 
    0.08372329f, -0.19231182f, 0.06214751f, -0.12055138f, -0.00996486f, 0.21895722f, -0.01235803f, -0.00938311f, 
    0.08931672f, 0.25929865f, 0.06520894f, -0.05171003f, 0.23038030f, -0.05801773f, -0.22071263f, -0.22321412f, 
    0.03318343f, -0.04519980f, 0.05452512f, -0.03714195f, 0.05873920f, -0.07512616f, 0.12155791f, 0.00888948f, 
    -0.08926219f, -0.11645622f, 0.11224141f, 0.11217199f, 0.03035044f, 0.03578325f, 0.02711945f, -0.03021738f, 
    -0.14247140f, -0.14850895f, 0.07965866f, -0.07889080f, 0.01398308f, -0.02075724f, 0.03146641f, -0.10299572f, 
    0.14155708f, 0.04962694f, -0.09461123f, 0.03236543f, 0.03088937f, -0.17355677f, -0.05180588f, 0.08960126f, 
    -0.05955044f, 0.17312166f, 0.14002715f, -0.06491074f, -0.05403411f, 0.06353077f, 0.01002889f, -0.04864554f, 
    0.03339338f, -0.01008884f, 0.04983862f, 0.07910398f, 0.42513093f, -0.13071755f, 0.15835658f, 0.02996885f, 
    -0.13644040f, 0.10318986f, -0.07225358f, 0.02216882f, 0.05152139f, 0.00294196f, 0.04852599f, -0.13021791f, 
    -0.07675966f, -0.04742505f, 0.06049409f, 0.21847209f, 0.06848701f, -0.04466905f, 0.12703876f, 0.04465607f, 
    -0.03782533f, 0.04862801f, -0.05987570f, 0.00385120f, 0.12178207f, 0.10377664f, -0.20249097f, 0.03930048f, 
    0.09371234f, 0.03365690f, 0.05302803f, -0.16111711f, 0.14608815f, 0.05809618f, 0.00276190f, -0.05203753f, 
    -0.09284904f, -0.10713439f, -0.08145828f, -0.00590193f, -0.02924642f, -0.02698461f, 0.03401625f, -0.06739856f, 
    -0.04763811f, 0.13936894f, 0.04697347f, 0.04288868f, 0.00829911f, 0.28186172f, 0.08043779f, -0.25776172f, 
    -0.04359229f, 0.00766172f, 0.07581158f, 0.05451408f, -0.11830555f, -0.01301812f, 0.02928833f, 0.13151018f, 
    0.22963724f, -0.03640538f, 0.11508624f, -0.20367873f, 0.02371098f, 0.04772734f, 0.04350112f, 0.09594133f, 
    -0.04628134f, 0.01667214f, -0.16510965f, 0.07588536f, 0.09157543f, 0.01309549f, -0.01217987f, 0.03831457f, 
    -0.03691347f, 0.06367903f, 0.02900409f, -0.03344991f, 0.05593156f, 0.15362616f, 0.00796526f, -0.01428986f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10004453f, 0.03958575f, -0.01003713f, 0.09682318f, -0.01616872f, 0.04646720f, -0.00717238f, -0.02710289f, 
    0.01247683f, 0.05205489f, -0.00705824f, 0.04689110f, 0.04180206f, -0.02995792f, 0.13818640f, 0.05887130f, 
    -0.02249485f, 0.02944730f, -0.02089840f, -0.06455915f, 0.06633143f, -0.00547184f, 0.06818482f, -0.05534885f, 
    -0.01557932f, 0.02127923f, 0.02573454f, 0.05320744f, -0.05753843f, 0.06123840f, -0.06516068f, -0.06405763f, 
    -0.07070665f, -0.07660229f, -0.03934041f, -0.00685479f, 0.10273922f, 0.04935987f, 0.05169916f, -0.02051665f, 
    -0.02313111f, -0.01089113f, 0.01906873f, -0.03600177f, 0.05898313f, 0.02619510f, 0.01383408f, 0.05625379f, 
    0.03515242f, 0.08748807f, 0.11760277f, 0.04026965f, 0.04287560f, -0.05214820f, 0.11250391f, 0.07131841f, 
    0.04478290f, 0.03878508f, -0.05480273f, -0.06331382f, -0.00249078f, 0.05316025f, 0.04306405f, 0.00766327f, 
    -0.11776353f, -0.02727851f, 0.11150298f, -0.02958829f, -0.03523381f, 0.08361443f, -0.04210560f, -0.04340670f, 
    -0.01678994f, 0.11566070f, 0.05641243f, 0.01117340f, -0.00845747f, -0.01379816f, -0.06787080f, -0.00672786f, 
    0.02712505f, 0.02762213f, -0.07096842f, -0.05234044f, 0.11700337f, -0.01029468f, 0.00843296f, -0.00886756f, 
    0.06146569f, -0.00291235f, -0.03813862f, 0.06651677f, 0.05517027f, 0.04248941f, -0.01069416f, -0.00444139f, 
    0.17741439f, 0.04063234f, 0.00760095f, 0.14097895f, -0.07150954f, 0.02860131f, 0.15728378f, -0.04140959f, 
    -0.07550793f, -0.06792928f, -0.02425605f, -0.17446806f, -0.06200081f, 0.05645884f, 0.09295947f, -0.01437198f, 
    0.10324918f, -0.02313933f, -0.06885380f, 0.06273695f, -0.02424759f, -0.07046048f, 0.00555215f, 0.04064538f, 
    0.03966614f, 0.01933751f, -0.02761891f, -0.03032578f, 0.01056491f, 0.04640389f, 0.02643253f, 0.01326287f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.19906528f, 0.03415136f, -0.09171224f, -0.02132227f, 0.07044347f, -0.40022397f, 0.00035816f, 0.02261313f, 
    -0.13246006f, -0.67591280f, 0.07058261f, 0.15354355f, 0.05142969f, -0.12891828f, 0.08843057f, -0.38978457f, 
    0.07390196f, 0.06996003f, 0.06495294f, -0.26421666f, -0.46408799f, 0.04852642f, 0.05313354f, 0.10738066f, 
    -0.08279502f, -0.01712430f, -0.68442130f, 0.01471678f, 0.02099702f, 0.03457876f, 0.04758490f, 0.07258128f, 
    0.03359065f, 0.23264810f, -0.02949082f, -0.19157939f, -0.18453346f, 0.04731712f, -0.01671389f, -0.35268244f, 
    -0.07060981f, -0.44706616f, 0.36881992f, -0.02152720f, 0.07453361f, -0.07010849f, 0.17613380f, 0.04920619f, 
    -0.03851063f, -0.41571587f, 0.03413942f, -0.01070195f, 0.03879286f, 0.01106994f, 0.19341063f, 0.01489918f, 
    0.00351103f, 0.18240681f, -0.19333889f, -0.00772887f, -0.09855068f, -0.00336567f, -0.07802726f, -0.04844822f, 
    0.08101404f, -0.06751737f, -0.01183161f, 0.01115368f, -0.09848362f, 0.05579726f, 0.16493240f, -0.04052402f, 
    -0.04154424f, -0.27400750f, 0.24798290f, 0.17130539f, 0.10952664f, 0.05127778f, 0.22302429f, -0.20292100f, 
    -0.26656988f, -0.02894448f, -0.05618092f, -0.05602911f, -0.23296097f, 0.24366790f, -0.03613271f, -0.07767305f, 
    -0.02738943f, -0.08099011f, -0.01609349f, 0.05797953f, 0.24639876f, 0.06257433f, 0.00655374f, -0.30228770f, 
    -0.29286614f, -0.60805130f, 0.21157759f, -0.10934255f, -0.07688329f, -0.04862780f, -0.27542862f, 0.03254467f, 
    -0.08636523f, -0.40116683f, -0.07847459f, 0.16980752f, 0.17495801f, 0.09168213f, -0.36769289f, -0.34695667f, 
    -0.17401642f, 0.25280651f, -0.17845859f, 0.19606742f, 0.01611483f, -0.02095442f, -0.16032195f, -0.33269629f, 
    0.01321376f, 0.04961202f, -0.05921333f, 0.29505566f, 0.01974038f, 0.17165042f, -0.34941447f, 0.10306767f, 
    -0.08654636f, 0.03203826f, -0.00165406f, 0.09584279f, -0.33054319f, -0.34657189f, 0.08056154f, 0.14712234f, 
    0.22815304f, 0.42355078f, -0.00036742f, 0.10643493f, 0.03808841f, -0.01198205f, 0.46408862f, 0.15441002f, 
    -0.08264189f, -0.10108994f, 0.01426015f, -0.30643228f, -0.04593245f, 0.01593615f, 0.06027178f, -0.05934603f, 
    0.20225996f, -0.12586054f, -0.02875566f, -0.04068164f, -0.15269655f, -0.02778318f, 0.04679991f, -0.03511165f, 
    -0.05327011f, 0.15256217f, -0.08213115f, -0.04223411f, 0.08299989f, 0.02684203f, -0.01037240f, 0.18039896f, 
    -0.00723813f, -0.13189872f, -0.51159316f, 0.03725335f, -0.08264402f, -0.10699096f, 0.12657547f, 0.15322632f, 
    -0.01724366f, -0.15929408f, 0.19582626f, -0.14138883f, -0.11913187f, 0.15449116f, 0.11075822f, -0.39276809f, 
    0.02999739f, -0.03556018f, 0.04431149f, -0.08184367f, 0.07148193f, -0.13791914f, -0.00893569f, -0.06479565f, 
    0.05518958f, -0.02741525f, 0.14800248f, -0.06731464f, -0.28629962f, 0.19246306f, -0.15100849f, -0.02619286f, 
    0.02863341f, 0.13861084f, -0.05135539f, 0.28822789f, 0.04275394f, -0.04258461f, 0.09177107f, -0.26046029f, 
    -0.37442759f, -0.04041985f, -0.06793454f, -0.01820827f, 0.17565730f, -0.68885809f, -0.07760403f, -0.00733886f, 
    -0.21172841f, -0.07817943f, -0.04914811f, -0.28921735f, 0.09861588f, 0.00028470f, -0.07906526f, -0.03703064f, 
    0.00607335f, 0.33158106f, -0.28697020f, 0.08049939f, 0.00181313f, -0.01139209f, -0.10360733f, -0.03755007f, 
    0.04899941f, 0.15413199f, -0.05057715f, 0.02081798f, -0.07262966f, 0.10478671f, -0.32173640f, -0.14872681f, 
    0.12522261f, -0.41952795f, -0.17908728f, 0.14503616f, 0.03922315f, 0.01020475f, -0.29963595f, 0.11442116f, 
    0.07107881f, -0.01076659f, -0.04008586f, 0.08313671f, 0.02860748f, -0.18928665f, -0.06971836f, 0.13247639f, 
    0.23019928f, 0.01215749f, -0.19698977f, 0.09300439f, -0.34194559f, 0.06350992f, -0.07105014f, 0.08847123f, 
    0.13472494f, -0.49269000f, -0.17385298f, -0.11107137f, -0.15524685f, 0.12556040f, -0.36475217f, -0.04958483f, 
    -0.22408040f, -0.05396421f, -0.07492934f, -0.27169028f, -0.29182690f, 0.06932487f, 0.10401057f, 0.14521797f, 
    0.01619112f, 0.00958050f, 0.00329183f, -0.04714480f, 0.19539692f, -0.06482188f, -0.04092567f, 0.08728798f, 
    0.03584575f, -0.08636849f, 0.06075754f, -0.30514160f, 0.04951265f, 0.06567353f, 0.05005812f, -0.28655446f, 
    -0.01343639f, -0.04167691f, 0.08964913f, 0.04406206f, -0.12987341f, 0.19519503f, -0.13916647f, -0.24012981f, 
    0.04498965f, 0.04254862f, -0.61019200f, 0.02523739f, -0.23169295f, 0.23470432f, -0.53044051f, -0.12107614f, 
    -0.04278107f, 0.33410743f, 0.24399740f, -0.01863065f, 0.17229730f, -0.17613827f, 0.03559165f, -0.01237776f, 
    0.22197534f, -0.29034904f, 0.19548094f, 0.06410152f, 0.25780183f, 0.00020930f, -0.11499206f, 0.04000333f, 
    0.01646831f, 0.04211066f, -0.57042003f, 0.09630347f, -0.24730420f, 0.05332186f, 0.12355296f, 0.06214358f, 
    -0.41239229f, -0.07339610f, -0.07384899f, -0.03096686f, -0.35008323f, -0.03121872f, 0.03010766f, 0.01988368f, 
    -0.10818029f, -0.08165887f, -0.04602638f, -0.34113088f, 0.17534901f, 0.01484566f, 0.05505710f, 0.16647896f, 
    -0.13575266f, 0.03803625f, -0.16256185f, -0.38645390f, 0.02420175f, 0.05672805f, -0.15071173f, -0.05588374f, 
    0.02580760f, 0.08175951f, -0.06921770f, 0.15034892f, 0.18986383f, -0.39693993f, -0.05699698f, 0.32154307f, 
    0.15593746f, -0.32442304f, 0.10973994f, -0.04152105f, 0.01681824f, -0.08680908f, -0.16964878f, 0.30815855f, 
    -0.09988821f, -0.01961982f, -0.03040087f, -0.06347912f, -0.02949046f, 0.10253120f, 0.14014077f, -0.03490120f, 
    0.01018846f, -0.05702399f, 0.03071269f, -0.22498131f, -0.06757624f, 0.25481081f, 0.01886407f, 0.15693863f, 
    -0.62162411f, -0.20001127f, 0.12064588f, 0.06150081f, 0.19541091f, -0.26468116f, -0.53297883f, -0.10250748f, 
    -0.23139784f, -0.02858333f, 0.01911583f, 0.12671404f, -0.23686628f, 0.04776248f, 0.23076896f, -0.11629798f, 
    -0.29720965f, 0.21994619f, 0.24813202f, 0.08330180f, 0.12459490f, 0.04233801f, -0.03967691f, -0.08212850f, 
    -0.04605793f, -0.00325908f, 0.05258773f, -0.04855420f, -0.01153072f, 0.02329620f, 0.03565896f, 0.01431862f, 
    -0.02420979f, 0.19405164f, 0.26115265f, 0.04200638f, 0.16382059f, -0.09855620f, 0.12255646f, -0.48872128f, 
    -0.06458310f, 0.04259167f, -0.31014258f, 0.04191655f, 0.12893181f, -0.12641811f, -0.12836434f, 0.14920756f, 
    0.07403480f, 0.05553144f, 0.10175486f, -0.08148357f, -0.01199752f, -0.46310297f, 0.00783913f, 0.00571756f, 
    -0.39756432f, 0.10642933f, -0.04113805f, -0.04676394f, 0.21601172f, -0.10108329f, -0.40943831f, -0.08310144f, 
    -0.06571080f, 0.19742446f, -0.03536971f, -0.12584159f, 0.19173542f, -0.02666955f, 0.08161877f, -0.19062704f, 
    0.18789740f, -0.08853131f, 0.04024567f, -0.02038067f, 0.14941904f, 0.02977029f, 0.07211790f, -0.06482619f, 
    -0.37720159f, 0.03376581f, -0.00830581f, -0.30073568f, -0.12603782f, 0.00318278f, -0.02403261f, -0.16336972f, 
    0.06821720f, 0.07448086f, -0.42009994f, 0.10410167f, 0.03375842f, 0.01950580f, 0.07166260f, 0.04274172f, 
    0.02949904f, -0.37820524f, -0.06245764f, -0.34912169f, -0.43122897f, 0.17523600f, 0.04312257f, -0.22531672f, 
    -0.21014190f, -0.13666666f, -0.19233358f, -0.61857802f, 0.04383816f, -0.04686569f, -0.08845124f, 0.10456991f, 
    0.21139969f, -0.02839118f, -0.03228813f, -0.31813219f, 0.01988632f, -0.01762725f, -0.18136255f, -0.14149766f, 
    -0.25494769f, -0.01265308f, 0.27880025f, -0.13716820f, -0.06195045f, -0.05320476f, 0.03969242f, -0.02961971f, 
    0.09386132f, 0.13311602f, 0.20411137f, 0.16968369f, 0.02796532f, -0.08412168f, 0.17605035f, 0.04787491f, 
    -0.04264715f, -0.04024598f, 0.03889489f, -0.44219750f, 0.18343668f, -0.01188982f, 0.09418239f, 0.01998256f, 
    -0.17976430f, 0.09316064f, 0.13054328f, 0.07412931f, 0.19197851f, 0.06407284f, -0.08077238f, 0.02210838f, 
    0.04353255f, -0.03466187f, -0.06279732f, -0.17153907f, 0.15317635f, -0.03723447f, 0.04448123f, -0.01032796f, 
    -0.02327269f, 0.49136803f, 0.20129654f, 0.04765927f, -0.11034291f, -0.39924359f, -0.06054761f, -0.20320272f, 
    -0.07465080f, 0.15113062f, 0.01839587f, 0.03667224f, 0.00684918f, -0.25166470f, 0.17017642f, 0.06862814f, 
    -0.03487761f, 0.10126072f, -0.05808555f, -0.01383326f, -0.34350047f, -0.21060228f, -0.04373735f, 0.08491616f, 
    0.10083040f, 0.28381193f, -0.11732831f, -0.06125423f, 0.16338609f, -0.31867206f, -0.06248226f, -0.01946694f, 
    0.10101184f, -0.22683983f, 0.13023627f, -0.10664383f, 0.09950311f, -0.01452042f, -0.11981328f, -0.14859091f, 
    0.09614448f, 0.01844250f, -0.06397370f, -0.09303328f, -0.11103746f, 0.12402007f, 0.08574139f, 0.00245682f, 
    0.20709191f, -0.08355968f, 0.06841796f, 0.29579541f, -0.12993678f, -0.01376632f, -0.03895402f, 0.03855257f, 
    0.05522338f, -0.40299836f, 0.18297625f, 0.19962026f, -0.04644263f, -0.08172490f, 0.06697962f, 0.07361732f, 
    -0.07086252f, -0.11682194f, 0.01059446f, 0.14980628f, -0.04051221f, -0.13271625f, 0.09212179f, 0.02958365f, 
    -0.02167139f, -0.29015887f, 0.26839533f, -0.16788089f, 0.04050912f, 0.02933084f, -0.05076590f, -0.41356984f, 
    -0.05302486f, -0.07720038f, -0.07124500f, -0.16210137f, -0.03302488f, -0.17529111f, -0.31939310f, -0.28551355f, 
    0.10034224f, 0.07410461f, 0.01961789f, 0.12411011f, 0.10334039f, -0.02920951f, -0.06435128f, 0.01174630f, 
    0.05318912f, 0.00674688f, -0.00245372f, 0.00043568f, -0.31939852f, -0.02900995f, 0.32680801f, -0.02516544f, 
    0.15489875f, 0.06696348f, 0.00818317f, 0.80672449f, 0.15604123f, 0.06581020f, -0.49592796f, -0.30163828f, 
    -0.02517779f, 0.08479290f, -0.24900430f, 0.04478640f, -0.19054300f, -0.00478827f, 0.08715438f, 0.00087398f, 
    -0.05397490f, 0.16126308f, -0.02630780f, 0.27446735f, -0.02955421f, -0.09274759f, -0.07271275f, -0.06444148f, 
    -0.00158858f, -0.33114627f, 0.14241450f, 0.07974781f, -0.01526322f, 0.28030777f, 0.08796550f, 0.26139161f, 
    -0.01327279f, 0.20813039f, 0.14453943f, -0.15093902f, 0.15745439f, -0.15153955f, 0.06408387f, -0.08408393f, 
    0.03913321f, -0.67338187f, -0.42690477f, 0.01751020f, -0.18853648f, 0.18403177f, 0.01472420f, -0.08146317f, 
    -0.11895218f, 0.09676518f, 0.06853652f, -0.01776661f, -0.17249641f, -0.06510999f, -0.00347527f, 0.07107173f, 
    -0.04944424f, -0.48620602f, 0.05507114f, -0.10736034f, -0.19039240f, -0.00066239f, -0.38231489f, -0.19483678f, 
    0.15544628f, 0.05493971f, 0.00885613f, -0.06965216f, 0.11629067f, 0.05053824f, 0.03111066f, 0.04799750f, 
    0.14734173f, -0.08108003f, 0.02027826f, 0.15574279f, 0.16737300f, -0.07822128f, 0.00788596f, -0.09824075f, 
    -0.00983236f, -0.22104113f, 0.08809111f, 0.03108797f, -0.09229580f, 0.00467399f, -0.26407161f, -0.04260756f, 
    -0.08700087f, -0.01642053f, 0.01446991f, -0.04038371f, -0.22533515f, 0.19293614f, 0.02833722f, 0.07860367f, 
    0.12579213f, -0.15837172f, -0.01574481f, 0.16245514f, -0.07307424f, -0.04652352f, 0.04357285f, 0.15921901f, 
    -0.08542585f, 0.06561816f, 0.03719660f, -0.05595673f, 0.01790926f, -0.07729282f, 0.08216636f, 0.11678034f, 
    -0.01111430f, -0.06650144f, -0.01312913f, -0.03289947f, -0.13941579f, 0.14529365f, -0.00414459f, 0.10425850f, 
    0.14617868f, -0.34376138f, 0.14886817f, -0.01006584f, -0.36167786f, -0.01036526f, -0.35725862f, -0.21589458f, 
    -0.34244332f, 0.06743325f, -0.04376125f, -0.35960591f, 0.28312680f, 0.00984653f, -0.07480524f, 0.24483500f, 
    0.04573692f, 0.13686347f, -0.21302252f, -0.10441975f, -0.06528866f, 0.00551122f, -0.06533307f, 0.00604477f, 
    -0.02160850f, -0.10164066f, 0.07411250f, -0.22435446f, -0.58840871f, -0.04206297f, -0.00802090f, 0.16940947f, 
    0.03310033f, -0.14674439f, -0.46922830f, 0.04502155f, -0.01606885f, 0.18765734f, -0.30139700f, 0.02408898f, 
    -0.03883707f, -0.15986635f, 0.10261817f, 0.10362654f, -0.09010806f, 0.01134390f, 0.00514118f, 0.22215769f, 
    0.05359872f, -0.12170339f, 0.06222938f, 0.04653096f, -0.28919244f, -0.14675052f, 0.05341039f, 0.02914274f, 
    0.08624932f, -0.14049545f, -0.01407156f, 0.04322055f, -0.15151238f, -0.04765667f, 0.18462554f, -0.00688045f, 
    0.05043761f, 0.30187133f, -0.28203240f, -0.14690569f, 0.09868503f, -0.02542217f, -0.17191833f, 0.22311065f, 
    -0.20503680f, -0.05767945f, -0.09001397f, -0.00143487f, -0.02823154f, 0.21050325f, 0.03967085f, -0.09061228f, 
    0.13987331f, 0.05827616f, -0.00764183f, -0.06177076f, -0.22770204f, -0.06736305f, 0.02119355f, 0.00689428f, 
    -0.00483575f, -0.26924029f, -0.50574964f, -0.25196382f, -0.02907906f, -0.04893090f, 0.22043471f, -0.02351437f, 
    0.03734532f, -0.21084753f, -0.02338748f, -0.22534397f, 0.11550010f, 0.16151828f, -0.12241750f, 0.26272190f, 
    -0.73204094f, 0.40336022f, 0.11211944f, -0.01238464f, -0.02459902f, 0.06525957f, 0.34190708f, -0.24376014f, 
    0.22393629f, 0.07641644f, -0.07401317f, -0.19809978f, 0.04091067f, 0.16536897f, 0.29699427f, 0.19119209f, 
    -0.34583580f, -0.01948677f, -0.15730093f, -0.22893089f, 0.24545689f, 0.18143524f, -0.01553052f, -0.30902308f, 
    -0.09818056f, 0.18737160f, -0.39531428f, -0.17985421f, -0.14822675f, -0.16658416f, -0.14339973f, -0.32328627f, 
    0.12206516f, -0.04885924f, 0.06546046f, 0.13816121f, 0.14384182f, -0.02955872f, 0.00839142f, 0.16880862f, 
    -0.13504957f, -0.01740962f, 0.17515887f, 0.02598880f, 0.09886894f, 0.02744183f, 0.01411083f, 0.01146001f, 
    -0.01870490f, -0.36863318f, 0.05076918f, 0.14151537f, 0.21288005f, 0.04549690f, -0.04458173f, 0.21674888f, 
    -0.05722299f, -0.09677825f, 0.14309035f, 0.05224814f, 0.05119227f, 0.03045869f, 0.09752768f, -0.28777593f, 
    -0.06477946f, 0.18142559f, -0.38222960f, -0.18361707f, 0.11713839f, 0.01971470f, -0.08561567f, 0.06906801f, 
    0.02950078f, 0.05759870f, 0.10862002f, 0.06830911f, 0.14862567f, 0.09990714f, -0.00067611f, -0.06893315f, 
    -0.04957359f, -0.09044079f, -0.21442781f, -0.06638006f, -0.11250909f, -0.18505870f, 0.09947736f, 0.07588439f, 
    0.02482355f, -0.05847016f, 0.01880406f, -0.17019399f, -0.06579404f, 0.06461676f, 0.09284377f, 0.08650600f, 
    0.13775995f, 0.01874164f, -0.05619682f, 0.02792296f, 0.16636454f, 0.10069415f, -0.08372543f, 0.02256336f, 
    0.03529882f, 0.01115163f, 0.00650955f, -0.26547253f, -0.35647964f, -0.02920909f, 0.04732507f, 0.12572406f, 
    -0.36846390f, 0.12281634f, 0.04687737f, -0.40691164f, -0.02256464f, 0.00706061f, -0.44414961f, -0.05596556f, 
    0.00892405f, 0.43727097f, 0.03292232f, 0.14504689f, -0.14770314f, -0.19022675f, 0.07510565f, -0.09407750f, 
    -0.07564398f, -0.03953199f, 0.14678599f, -0.16853000f, -0.01898493f, -0.06589031f, 0.28808144f, 0.08977876f, 
    0.06067532f, -0.08274624f, -0.00911451f, -0.13880874f, 0.03811735f, -0.38617268f, -0.02689179f, 0.16656406f, 
    0.15549181f, 0.02676995f, -0.36367872f, -0.39829633f, 0.17556675f, -0.17672414f, -0.05038240f, -0.01635219f, 
    0.03612298f, -0.14446656f, -0.22340351f, 0.31108236f, 0.15470825f, 0.15887654f, -0.19336320f, 0.15041830f, 
    -0.29949832f, -0.06549755f, 0.07789649f, 0.01204567f, -0.07302519f, -0.00065148f, -0.25907379f, -0.36593488f, 
    0.09171174f, -0.48729590f, 0.03683451f, -0.06817151f, -0.22784440f, 0.06461719f, 0.08003873f, 0.02428435f, 
    -0.06325491f, -0.00941605f, 0.04180682f, 0.20123553f, -0.16664067f, -0.06296662f, -0.07876275f, 0.02890437f, 
    0.05842425f, 0.25645730f, -0.28074464f, 0.01755194f, 0.00035016f, 0.09249855f, 0.20663874f, 0.16674124f, 
    0.01560021f, 0.29543039f, 0.12941891f, 0.31893224f, 0.01252672f, 0.07630321f, -0.21724445f, -0.30389243f, 
    0.07762629f, -0.33586004f, 0.04715745f, 0.06359486f, 0.12319505f, -0.15439424f, 0.04619696f, 0.05604894f, 
    -0.08926302f, 0.19536261f, -0.32657561f, -0.04065595f, -0.01648056f, -0.02333049f, -0.23371296f, -0.07214912f, 
    -0.04324676f, 0.12067509f, 0.04047333f, -0.13012692f, -0.27391976f, 0.02235245f, 0.10383800f, 0.24881685f, 
    0.12910381f, 0.01754831f, 0.00534774f, -0.06919520f, -0.16637179f, -0.25013384f, 0.05873679f, 0.02114259f, 
    0.19581394f, -0.00226756f, 0.02882107f, -0.39208025f, -0.11984786f, -0.03357317f, 0.01730061f, 0.24324320f, 
    -0.01723769f, 0.05868815f, -0.01472709f, -0.05701882f, -0.04592720f, -0.04746934f, 0.16858189f, -0.02346216f, 
    -0.04260911f, -0.40381894f, -0.03964660f, 0.24761581f, -0.15518379f, -0.17097344f, 0.02952583f, 0.12124716f, 
    0.28126422f, -0.08757109f, -0.09464426f, 0.08861908f, 0.00840954f, -0.01992138f, 0.08858284f, 0.05238411f, 
    -0.54905599f, 0.07433155f, 0.02494737f, -0.50804371f, 0.02978153f, 0.19592679f, -0.00832203f, -0.30895725f, 
    -0.04196667f, 0.07014616f, 0.14199674f, 0.26932910f, -0.05583063f, -0.07200260f, -0.07703037f, -0.08226080f, 
    -0.07378332f, -0.14629410f, -0.11234502f, -0.50147474f, 0.23600113f, 0.32429269f, -0.26843756f, -0.10252707f, 
    0.23968601f, 0.05399017f, 0.01959409f, 0.15951924f, 0.07300739f, 0.05863874f, 0.04163583f, -0.08507907f, 
    -0.11614081f, 0.08009721f, 0.18253398f, -0.02332686f, -0.19197978f, 0.07408093f, -0.02995823f, 0.04430646f, 
    -0.05309710f, -0.24481459f, 0.07020044f, 0.34371465f, 0.20116988f, 0.03897509f, -0.01301701f, 0.13389626f, 
    -0.05381873f, -0.08574845f, 0.05004846f, 0.03968009f, -0.50990701f, -0.27088949f, -0.45066106f, -0.41653636f, 
    0.05200384f, -0.05534200f, 0.19783081f, -0.38462767f, -0.36988199f, -0.14722878f, -0.01667323f, 0.08054422f, 
    0.06964704f, -0.05282100f, 0.21489155f, 0.00227038f, 0.27562928f, 0.20962457f, 0.05976629f, -0.07144159f, 
    -0.01044890f, -0.38699251f, 0.10255261f, -0.07910363f, 0.29407218f, 0.00913983f, -0.14247799f, -0.04387221f, 
    -0.06478436f, -0.27000305f, -0.09066711f, -0.00080844f, -0.14779332f, -0.00827544f, -0.05505829f, 0.14576869f, 
    0.16797097f, -0.07414124f, -0.07652872f, 0.01584456f, 0.10373566f, 0.15417971f, 0.05350071f, 0.01198383f, 
    -0.28897598f, 0.04235049f, 0.00702988f, 0.15669087f, -0.12935902f, 0.03858324f, -0.08391916f, 0.31545046f, 
    0.15851726f, -0.04948221f, 0.18839839f, -0.13720873f, 0.00430544f, 0.00445562f, 0.00339682f, -0.08219560f, 
    -0.03903267f, 0.22302687f, -0.07331472f, 0.03013281f, 0.08600491f, -0.13556291f, -0.11622777f, -0.03898263f, 
    0.00527975f, 0.31303245f, -0.30930009f, 0.30467001f, -0.05194636f, -0.07396353f, 0.10213777f, -0.29635918f, 
    0.06475503f, -0.07328609f, -0.08723829f, 0.30341482f, -0.13731201f, 0.13640310f, -0.22946267f, -0.10119513f, 
    -0.37765560f, 0.03821264f, -0.40148953f, 0.13022852f, -0.07249585f, 0.10829993f, -0.00122767f, -0.30599883f, 
    -0.37334517f, -0.04949404f, -0.06799687f, -0.04033292f, 0.11850594f, -0.03057395f, 0.05769888f, 0.24386622f, 
    0.06476241f, 0.06270825f, -0.06887238f, -0.23180927f, -0.11807586f, 0.03198230f, 0.13407920f, 0.13868104f, 
    -0.14660844f, -0.09303987f, -0.08461966f, -0.07068068f, 0.04536258f, -0.02048218f, -0.08015159f, -0.08298613f, 
    -0.05199196f, -0.29821208f, -0.02405746f, -0.31131721f, 0.26700115f, -0.09866881f, -0.03262227f, -0.16643026f, 
    -0.02188806f, -0.03234218f, -0.37572590f, -0.03108272f, 0.18791756f, 0.09942443f, 0.06480749f, 0.09100383f, 
    -0.03043546f, -0.00411666f, -0.28954339f, -0.13742928f, 0.16945882f, -0.19984905f, 0.03190061f, 0.04903322f, 
    -0.02103757f, 0.00536358f, 0.05220143f, -0.05340660f, -0.12248208f, 0.22601505f, 0.06488574f, -0.01832586f, 
    -0.36360517f, -0.31094879f, 0.19572753f, -0.00968338f, -0.22758536f, 0.08251806f, 0.34401348f, 0.03479790f, 
    0.04580100f, 0.38872313f, -0.05485858f, 0.28525311f, -0.25296745f, 0.02804429f, -0.12410267f, -0.29469514f, 
    0.07588068f, 0.05815149f, -0.04813595f, -0.07769267f, 0.14862427f, -0.06078338f, -0.09632996f, -0.02766836f, 
    0.31036237f, 0.01674493f, -0.02947823f, -0.04420086f, -0.07264113f, -0.04206941f, 0.07923888f, -0.15270457f, 
    0.30877492f, 0.17082469f, 0.26352501f, 0.07868133f, -0.08371107f, -0.06669552f, 0.31932542f, -0.03221006f, 
    -0.07253733f, -0.14252688f, 0.07560407f, -0.71149904f, 0.28812084f, -0.10516970f, 0.13495019f, -0.41718641f, 
    0.18625948f, 0.06498851f, -0.28082865f, -0.63615930f, 0.02896050f, -0.06207656f, -0.32425255f, 0.21419846f, 
    0.07029033f, -0.00354700f, 0.04219398f, -0.19461361f, 0.05836652f, -0.21575464f, 0.27866766f, 0.27245632f, 
    0.09223228f, -0.01681558f, -0.01872782f, -0.42887729f, 0.03201040f, -0.09368472f, 0.07117176f, 0.03994128f, 
    -0.35342082f, -0.04142496f, 0.05156438f, -0.25799423f, -0.18420486f, 0.21081316f, -0.71577704f, 0.13047379f, 
    0.34249577f, 0.07319351f, -0.05213618f, 0.10563212f, -0.19743006f, 0.03921278f, 0.15359165f, 0.05623959f, 
    0.11914590f, 0.01051429f, 0.14941834f, -0.09448569f, -0.03035106f, 0.01945726f, 0.01995784f, 0.01360369f, 
    -0.06644382f, 0.11233490f, -0.04110962f, 0.30135983f, -0.27670118f, -0.02715688f, -0.07402012f, 0.07743173f, 
    -0.08243019f, -0.21453960f, -0.04812112f, -0.06910592f, 0.07301351f, -0.09226968f, -0.34317091f, -0.23667058f, 
    -0.01962389f, -0.25351113f, -0.50817144f, 0.26061431f, 0.15686916f, 0.28874570f, 0.15154251f, 0.14176111f, 
    0.05745508f, -0.00907229f, -0.37891778f, 0.06563140f, -0.36661047f, 0.31956264f, -0.05127665f, 0.00127605f, 
    -0.14981455f, 0.35735214f, 0.02650698f, 0.00442503f, -0.38574859f, 0.21712427f, 0.19868904f, 0.02008700f, 
    0.01174914f, -0.19232963f, -0.21117447f, -0.26178551f, 0.27474293f, -0.06436913f, -0.44727087f, 0.30513707f, 
    -0.19708361f, 0.05178040f, 0.06276733f, 0.01807527f, -0.32307878f, -0.11295374f, -0.02496571f, 0.00640523f, 
    -0.23678425f, -0.06818461f, 0.04268405f, 0.33250901f, 0.03712658f, 0.04529355f, 0.01325482f, -0.39352718f, 
    0.02848717f, 0.35575652f, 0.12258295f, 0.24585921f, -0.07735708f, 0.02057059f, -0.04902354f, -0.00250986f, 
    0.08737358f, -0.36201265f, 0.05126626f, -0.05824126f, -0.05075849f, 0.00878195f, 0.19084844f, -0.06431735f, 
    -0.20057867f, -0.00742423f, -0.03711852f, -0.41318819f, 0.03072223f, -0.00140140f, -0.00200937f, 0.06798749f, 
    -0.03415871f, 0.04634651f, -0.00019288f, 0.06353228f, 0.13251209f, 0.17414892f, -0.04804119f, -0.22985530f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12939520f, 0.03074703f, -0.01715511f, -0.01520452f, -0.02766328f, 0.01288477f, 0.05610194f, -0.08384247f, 
    -0.06420606f, -0.01225282f, 0.02032623f, -0.03302382f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
