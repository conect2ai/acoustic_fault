#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.47222996f, 0.78898346f, 0.84438199f, -0.63262773f, 0.67506528f, -0.24113338f, 0.34378797f, 0.10871289f, 
    0.07653850f, 0.13384430f, -0.28443462f, -0.50290906f, 0.45194131f, -0.46990302f, -0.78316504f, -0.12465484f, 
    -0.41662869f, -0.45524457f, -0.33535889f, -0.43255088f, -0.71957809f, -0.38596961f, 1.01307416f, -0.16524905f, 
    0.28477758f, 0.24077769f, -0.09662902f, 0.51437980f, 0.89404315f, -0.69320399f, -0.38289171f, -0.82008225f, 
    0.44005176f, 0.30476916f, -0.03756521f, -0.07495198f, 0.39468071f, 0.60661751f, 0.21427400f, -0.42043313f, 
    -0.86585492f, -0.38577551f, -0.40550503f, 0.51045227f, -0.43047261f, 0.34986663f, -0.98698300f, -0.53838223f, 
    -0.57499290f, -0.39309749f, 0.43268245f, -0.09986325f, 0.50000262f, -0.46322182f, -0.13447860f, -0.09599181f, 
    0.19729699f, 0.59951419f, -0.02756026f, 0.57609171f, 0.42981130f, 0.13891770f, -0.57500350f, 0.35858676f, 
    -0.25227123f, -0.26531583f, 0.78369600f, 0.76820546f, -0.21924216f, -0.00974547f, -0.03238559f, -0.36380267f, 
    -0.93392992f, -0.66552043f, 0.41205141f, 0.58108187f, 0.78397506f, 0.18229946f, -0.28466082f, 0.11066116f, 
    -0.46519795f, -0.57356173f, -0.24220879f, -0.64459771f, -0.55891442f, 0.11069334f, -0.76856697f, 0.19499011f, 
    0.25326246f, 0.33220574f, 0.68924367f, 0.44661617f, 0.44680694f, -0.30660895f, 0.37767485f, 0.58420932f, 
    0.02444334f, -0.41339266f, 0.20812304f, 0.86528057f, -0.28180486f, -0.44868842f, 0.26977685f, 0.24343613f, 
    -0.58260757f, 0.14300995f, 0.68142748f, -0.17823823f, 0.34829855f, -0.07421726f, 0.84345114f, -1.13404620f, 
    -0.81171983f, -0.67268002f, 0.31006172f, 0.31176770f, -0.26380011f, -0.61401474f, -0.59365755f, -0.72990912f, 
    -0.26920730f, -0.82441199f, -0.38903785f, 0.32129422f, 0.32474488f, 0.04808482f, -0.57769102f, -0.87348467f, 
    -0.27703714f, -0.75082886f, 0.12526150f, 0.45814076f, -0.18994384f, -0.30759060f, -0.38428745f, 0.03802771f, 
    -1.21340132f, 0.61021954f, 0.02314461f, 0.49306175f, -0.14688918f, 0.21438473f, 0.15292467f, 0.08736335f, 
    0.15803242f, 0.67248291f, 0.70747882f, 0.21797739f, 0.25102225f, 0.63872290f, 0.30068883f, -0.54552084f, 
    -0.55804187f, 0.36299989f, -0.65360492f, -0.10174027f, 0.83863276f, 0.47028261f, 0.45116869f, -0.17607905f, 
    0.15647011f, 0.29825020f, -0.99009025f, -0.08063211f, -0.11773951f, 0.38193515f, 0.85453421f, 0.43015164f, 
    0.06891261f, -0.21844719f, 0.35884672f, -1.05866849f, 0.70075709f, 0.79503500f, -0.69673204f, 0.57489818f, 
    -0.38035437f, 0.02489698f, -0.11821198f, 0.34136087f, -0.32417479f, -0.57828325f, -0.59701848f, 0.68657416f, 
    0.66676921f, -0.35540819f, -0.42498773f, -0.29882005f, 0.06201108f, 1.06286311f, -0.51871896f, 0.23949565f, 
    0.30307394f, -0.14135528f, -0.57168657f, -0.10341240f, -0.41887164f, -0.05404677f, 0.44522592f, -0.57658714f, 
    -0.67734361f, -0.48521191f, -0.03940880f, -0.33690265f, -0.57989097f, 0.17128016f, 0.28335568f, -0.42351857f, 
    -0.58852154f, -0.89250559f, -0.25203538f, 0.22233991f, -0.05324912f, 0.37406582f, -0.48676440f, -0.06264396f, 
    -0.71920782f, -0.78253216f, -0.52417862f, -0.05148555f, 0.03601069f, 0.70866674f, 0.01588558f, 0.09495053f, 
    0.17753115f, -0.03951791f, -0.87749767f, 0.88596630f, 0.70914900f, -0.40396866f, 0.59146011f, -0.13842441f, 
    -0.30134046f, -0.26434326f, 0.63673455f, 0.45358828f, -0.46556032f, 0.26438740f, 0.36782768f, -0.13744162f, 
    0.43618506f, 0.43664706f, 0.21867439f, 0.44119713f, 0.60762948f, 0.75826007f, 0.18697339f, -0.67373973f, 
    0.25281242f, -0.17311795f, 0.05853907f, 0.43096620f, -0.08734490f, -0.68935353f, 0.81128287f, -0.35863027f, 
    -0.79085201f, 0.29729402f, 0.00977022f, -0.39200398f, -0.14954355f, 0.32950157f, -0.83841020f, 0.17579862f, 
    -0.90867245f, -0.30631110f, -0.06577744f, 0.22546530f, -0.03070335f, 0.24331181f, -0.28295088f, -0.65348208f, 
    -0.53262907f, 0.26999831f, -0.14881808f, -0.58659124f, -0.35277230f, 0.03399180f, 0.11688475f, 0.72960728f, 
    1.09919453f, -0.11194824f, -0.37345284f, -0.13013721f, -0.43799251f, -0.11795474f, -0.00160755f, -0.06700943f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06382760f, 0.11320497f, 0.17503612f, -0.14203602f, 0.11400508f, 0.18492541f, -0.02460233f, 0.05678161f, 
    -0.10848797f, 0.38224608f, 0.06914260f, -0.10559186f, 0.19506055f, -0.02315132f, -0.11884384f, 0.18432638f, 
    0.00137870f, 0.33489203f, 0.08492238f, 0.13192748f, -0.00108161f, -0.00712905f, 0.22827487f, -0.02481842f, 
    0.10215765f, -0.06118987f, -0.14787018f, 0.00506090f, 0.01911190f, 0.14695030f, -0.02146153f, 0.13807184f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00557835f, 0.01224216f, -0.01318366f, -0.01844970f, -0.03452246f, -0.03026147f, -0.03650425f, 0.00211643f, 
    -0.00277552f, 0.01094008f, -0.02309800f, 0.01474434f, -0.02850310f, -0.01900572f, -0.01847196f, -0.04169111f, 
    -0.01107483f, -0.01237507f, 0.02135201f, -0.00384727f, -0.01497778f, -0.00465191f, 0.02471207f, -0.04272851f, 
    0.00423507f, -0.03193538f, -0.02323398f, -0.01335497f, -0.02035839f, 0.02070578f, 0.02472842f, -0.00839977f, 
    0.00385501f, -0.04178726f, -0.02600367f, 0.02099107f, -0.01054909f, -0.00272517f, 0.01831812f, 0.00479688f, 
    -0.03181968f, 0.02000947f, -0.00581923f, -0.03671826f, 0.01503136f, 0.00719064f, -0.04636651f, 0.01249929f, 
    0.02424425f, 0.01194295f, -0.03710021f, -0.00729216f, 0.00024572f, -0.01040254f, -0.02554667f, -0.03400398f, 
    0.01684539f, -0.00158357f, -0.00448518f, -0.02063639f, -0.01943914f, 0.03383467f, -0.02789667f, 0.02274986f, 
    0.03112898f, 0.02948897f, 0.01387151f, -0.04105577f, 0.00645799f, 0.02946505f, 0.01744351f, 0.01091714f, 
    -0.03624812f, 0.00074478f, 0.00914826f, 0.01099770f, -0.01915070f, -0.02079813f, 0.01606778f, -0.04600551f, 
    0.01230823f, -0.03124736f, -0.00657342f, -0.01634647f, -0.03301663f, 0.02340228f, 0.02103998f, 0.01403151f, 
    -0.03401129f, -0.03819284f, -0.02403984f, 0.01336797f, -0.03871800f, -0.01010412f, 0.02197162f, -0.00840480f, 
    0.01384452f, 0.00497634f, -0.03621735f, -0.02492599f, 0.02645128f, -0.01562718f, 0.02275674f, -0.02031042f, 
    0.02568480f, -0.02258757f, 0.01907869f, 0.02880273f, -0.04345932f, -0.01533103f, 0.01295644f, 0.01962866f, 
    -0.03079782f, 0.01863177f, -0.04168816f, -0.03095262f, 0.00804282f, -0.01852299f, 0.00975622f, -0.03167272f, 
    0.02587498f, 0.02117679f, -0.01435743f, 0.02065289f, 0.01079054f, 0.01529134f, -0.01694143f, -0.04536999f, 
    -0.03670608f, 0.02730985f, -0.04770659f, 0.00441864f, -0.00651808f, 0.01910424f, -0.04435593f, -0.00814458f, 
    0.02968894f, -0.01973076f, 0.03079218f, -0.03729871f, -0.02145197f, 0.03313097f, 0.00385983f, -0.02121076f, 
    -0.00375743f, 0.01128161f, 0.01726533f, -0.01793802f, -0.02576511f, -0.02863839f, -0.00418992f, -0.02100950f, 
    -0.04617185f, 0.00944501f, 0.01249821f, -0.02473452f, -0.03817433f, 0.00052871f, 0.04265959f, -0.00629803f, 
    -0.02408396f, 0.00160207f, -0.03575337f, -0.00962825f, -0.01379871f, -0.02149088f, -0.03001341f, 0.01758936f, 
    0.02547467f, -0.02747677f, -0.01814085f, -0.04752911f, -0.02524592f, -0.01163440f, -0.03818144f, -0.03494235f, 
    -0.02253151f, 0.02739020f, 0.00603281f, -0.02288628f, -0.00777263f, 0.01722235f, 0.01766707f, -0.01072447f, 
    -0.00708950f, -0.02952325f, -0.04047127f, -0.01214721f, 0.00705696f, -0.02583272f, -0.03638988f, -0.02766216f, 
    0.02008454f, 0.00716121f, -0.01845418f, -0.01039413f, -0.04591043f, 0.01773907f, -0.02688857f, 0.01242285f, 
    -0.03666825f, 0.01488432f, -0.02186075f, 0.02665160f, 0.02950074f, -0.02746577f, -0.02303760f, -0.02356476f, 
    -0.03103759f, -0.00771070f, -0.03131150f, 0.02048001f, 0.00377124f, -0.00293332f, 0.02182937f, 0.01023166f, 
    0.01750148f, 0.00941065f, -0.02732746f, 0.01900032f, 0.01340057f, -0.00602952f, -0.04085947f, -0.02261592f, 
    0.02520902f, 0.00248821f, 0.01771597f, -0.03736562f, -0.02802398f, 0.03344358f, -0.03669620f, 0.01659028f, 
    0.00654887f, -0.04641594f, -0.03149250f, -0.03925594f, 0.01922523f, -0.03523117f, -0.02718966f, 0.01946879f, 
    -0.01618149f, -0.04004629f, 0.00823651f, -0.04584049f, -0.03041010f, -0.04141544f, 0.02475751f, 0.01475589f, 
    0.00189821f, -0.04730354f, 0.01344791f, -0.01761602f, -0.00903884f, -0.00878768f, 0.00686171f, -0.04357477f, 
    0.00049960f, -0.01664278f, 0.01777264f, 0.01305353f, 0.02881698f, -0.00260076f, 0.02995562f, -0.03105711f, 
    -0.02085507f, -0.04162388f, -0.02785953f, 0.01531161f, 0.02641488f, 0.01222609f, -0.01056123f, 0.02638982f, 
    -0.00983356f, -0.03078484f, -0.01969003f, -0.03520288f, 0.02000945f, 0.01591446f, 0.03203275f, -0.01679105f, 
    0.00250710f, 0.02440915f, -0.03097316f, 0.01875006f, -0.04259343f, -0.03477738f, -0.02866095f, -0.02864257f, 
    -0.01887920f, -0.00725942f, -0.01325260f, 0.00982506f, -0.01532289f, -0.04150425f, -0.03914197f, 0.02745773f, 
    0.02879021f, -0.00951155f, 0.02218294f, -0.00691080f, 0.02754813f, -0.03365551f, 0.00177191f, 0.02692398f, 
    -0.00487169f, -0.02419729f, 0.03110057f, 0.02222078f, -0.04427641f, -0.02174757f, -0.01644968f, -0.03129279f, 
    -0.02075100f, -0.03608698f, -0.00583409f, 0.02188764f, 0.01923875f, 0.00504440f, -0.03801345f, 0.00865462f, 
    0.01400805f, 0.00513740f, 0.02536825f, -0.03387434f, 0.00748098f, -0.02969211f, 0.00066023f, -0.02626191f, 
    -0.03578443f, 0.02120866f, -0.01810943f, 0.01089430f, -0.04359891f, -0.04336640f, 0.00079391f, -0.02558479f, 
    -0.01885784f, 0.02267308f, -0.00904974f, -0.01124250f, 0.02150902f, -0.02398905f, 0.00782352f, 0.02652412f, 
    -0.02760412f, -0.03094075f, 0.02670627f, -0.01638578f, -0.02914273f, 0.00834315f, -0.02656165f, -0.03725639f, 
    -0.00902212f, -0.02246194f, 0.01897283f, -0.03377816f, 0.01290734f, -0.03789822f, -0.04072758f, -0.00569026f, 
    -0.03366146f, 0.03265576f, -0.00551432f, 0.03164930f, 0.01492978f, -0.02098248f, -0.01712261f, 0.02849699f, 
    0.02115676f, -0.00124623f, 0.02496775f, -0.01179268f, 0.01376221f, -0.01839572f, -0.01599504f, -0.01954237f, 
    0.02801491f, 0.02063585f, -0.02458667f, 0.01413577f, -0.04240937f, -0.03448626f, -0.03149178f, 0.02891614f, 
    -0.04133091f, 0.02377365f, -0.00807245f, 0.02542548f, 0.01676519f, 0.00584346f, -0.01913966f, 0.02137392f, 
    -0.00609676f, -0.04565282f, -0.00286029f, 0.01350787f, 0.00258204f, 0.00209898f, -0.02231509f, 0.02460293f, 
    0.00320777f, -0.01624175f, 0.01566285f, -0.03429528f, -0.02209650f, 0.01771784f, 0.00620162f, -0.01065884f, 
    0.01791942f, 0.00692121f, -0.04212886f, -0.00196746f, -0.01304947f, -0.03783172f, 0.00133064f, -0.01742046f, 
    -0.01526312f, -0.01737344f, 0.01484777f, -0.04545542f, 0.00497202f, -0.04127686f, -0.03288664f, 0.01902759f, 
    0.03156672f, 0.01542995f, 0.02240516f, 0.00488410f, -0.01278474f, -0.01688532f, 0.01928862f, 0.00326919f, 
    -0.04126931f, -0.00803776f, 0.01242437f, 0.00467606f, 0.00362540f, -0.01683532f, -0.02453816f, 0.02639899f, 
    -0.00169970f, -0.02862699f, 0.00993973f, -0.00718303f, -0.03555296f, 0.00858559f, -0.02871978f, -0.04640887f, 
    -0.03167417f, -0.03178391f, 0.02335183f, -0.01619911f, 0.03060987f, -0.04170743f, -0.01419078f, -0.00040106f, 
    -0.00279050f, 0.01009534f, 0.01431473f, -0.01659760f, -0.03408735f, 0.03237247f, -0.04002356f, 0.03073334f, 
    -0.01412060f, -0.01372495f, -0.02938965f, 0.02325752f, 0.01172086f, 0.01422362f, 0.02745008f, -0.00586644f, 
    -0.02804811f, 0.01014529f, -0.00019736f, -0.03836760f, -0.01779322f, -0.00939274f, 0.02259137f, 0.00338169f, 
    -0.04384449f, 0.00927166f, 0.01543852f, 0.02629018f, 0.01999935f, -0.04419250f, -0.00474705f, 0.01753617f, 
    -0.01770456f, -0.01817992f, -0.00247987f, 0.02799098f, -0.01050675f, 0.02772351f, -0.01785180f, -0.01885660f, 
    -0.00604170f, 0.02473776f, -0.01865036f, -0.02925362f, 0.00993758f, -0.03739647f, 0.00688599f, 0.01323354f, 
    0.00648419f, 0.03311360f, -0.00777991f, -0.00367648f, 0.01679650f, 0.01002902f, -0.01754782f, -0.03655807f, 
    -0.00652124f, -0.01570744f, -0.00339891f, 0.00077580f, -0.01892130f, -0.00068974f, -0.00963888f, -0.01307568f, 
    0.03345403f, 0.00415689f, -0.01223967f, 0.01166134f, 0.00214019f, 0.02968575f, 0.02894429f, 0.01891478f, 
    -0.03472651f, -0.02563985f, -0.00217931f, -0.03112463f, 0.02748396f, -0.00825771f, -0.03054517f, 0.00328093f, 
    -0.04151288f, 0.00189465f, 0.01413944f, 0.01459055f, 0.02449531f, -0.04375400f, 0.02418589f, 0.02611241f, 
    0.01364956f, 0.02883951f, -0.03149427f, 0.02914778f, -0.00275449f, 0.01064050f, -0.00686981f, 0.02949028f, 
    0.01469176f, -0.01167812f, -0.00652165f, -0.03894862f, -0.03405690f, 0.00416023f, -0.04482746f, -0.00168173f, 
    -0.00826031f, -0.04653850f, -0.02110822f, 0.02165584f, -0.03606680f, -0.00620536f, -0.02562072f, -0.03180185f, 
    -0.02392602f, -0.01414680f, -0.03063515f, -0.02740932f, -0.01441505f, 0.00066681f, -0.02936855f, -0.00079244f, 
    -0.02281411f, -0.03760169f, -0.01522006f, 0.00074381f, 0.02564520f, 0.02014213f, -0.01832481f, -0.02850353f, 
    0.00072847f, -0.02067728f, -0.01881911f, -0.01453132f, -0.00210868f, 0.01467273f, -0.01750390f, -0.03084589f, 
    -0.02605242f, 0.02761059f, -0.04194945f, -0.03066621f, 0.00182568f, 0.00551150f, -0.02573276f, 0.00115580f, 
    -0.02423776f, -0.04648107f, -0.00757297f, 0.02333122f, -0.02544166f, 0.01372009f, 0.02244737f, -0.04368936f, 
    -0.03929452f, -0.01881308f, 0.02216896f, -0.01119773f, 0.03495717f, 0.01214346f, -0.00640732f, -0.03597823f, 
    0.01493187f, -0.01108591f, -0.02664561f, -0.00843233f, 0.02224484f, -0.03721915f, -0.00100219f, 0.00960783f, 
    0.02565496f, -0.01516105f, -0.03557929f, -0.02159711f, -0.00957901f, -0.00961998f, -0.04518333f, -0.04251375f, 
    0.00943065f, 0.00019123f, 0.00063970f, -0.00368537f, 0.01883307f, 0.01270827f, 0.01137627f, 0.00421298f, 
    -0.00566332f, -0.03365569f, -0.02920671f, -0.02451180f, -0.03607556f, -0.02087580f, -0.01158382f, 0.01376847f, 
    -0.00808501f, 0.02307434f, 0.00415208f, 0.02857671f, 0.01716693f, 0.02870314f, 0.01784206f, -0.03730588f, 
    0.00875157f, 0.02914381f, 0.00861898f, 0.00013584f, -0.02541722f, -0.00388765f, -0.03114802f, -0.02548778f, 
    0.00763958f, 0.03170317f, -0.01072423f, 0.03363102f, -0.02508428f, -0.02428801f, -0.02155434f, 0.02031906f, 
    0.01411917f, 0.03305608f, -0.03185920f, -0.00289940f, -0.02976273f, 0.00907560f, -0.01755106f, -0.01879991f, 
    -0.01787598f, 0.01899192f, 0.00413024f, -0.02335623f, -0.01004430f, -0.03075297f, -0.03660528f, -0.01865811f, 
    -0.00420129f, -0.00329946f, 0.02439941f, -0.00527785f, -0.03958479f, 0.00985383f, -0.02487127f, -0.02841539f, 
    0.03380558f, -0.00947938f, -0.01890344f, -0.02767795f, -0.00839715f, -0.01456031f, -0.02384714f, -0.03589754f, 
    -0.02879551f, 0.01263335f, -0.01028413f, -0.03479376f, 0.00643354f, -0.01909998f, -0.00179825f, -0.00766878f, 
    -0.00973098f, 0.01566638f, 0.02008038f, -0.02776196f, -0.04430990f, 0.01056122f, -0.01731230f, 0.00626643f, 
    -0.00022769f, 0.03179551f, 0.00202088f, 0.01698814f, 0.02211264f, 0.02834815f, -0.03107276f, 0.03185161f, 
    0.03081692f, -0.01568720f, -0.03529064f, -0.01501769f, -0.00864095f, 0.03377905f, 0.00764472f, -0.01513674f, 
    -0.04237050f, -0.00536434f, -0.01510239f, -0.00790437f, -0.01018846f, -0.02055845f, -0.00456221f, -0.04343982f, 
    -0.00441591f, -0.01726749f, 0.02383500f, -0.02106317f, -0.00708634f, -0.03202605f, -0.01005148f, -0.03374976f, 
    -0.02698540f, -0.01799108f, -0.01829267f, -0.00092556f, -0.01321503f, -0.03631742f, -0.03881966f, -0.02364494f, 
    0.01219865f, 0.00219301f, -0.03142093f, 0.00443048f, -0.00053025f, -0.00013789f, -0.04340707f, -0.01051190f, 
    -0.00499871f, -0.03810065f, -0.02829394f, -0.04498627f, 0.03005516f, -0.02634376f, -0.01404388f, 0.02340676f, 
    -0.00439237f, -0.03632798f, 0.02557277f, -0.02588792f, -0.02177518f, 0.02564379f, -0.03437499f, -0.01526900f, 
    0.03250161f, -0.04063636f, -0.00728452f, -0.01874154f, -0.00450563f, -0.00914460f, -0.03184813f, 0.00483835f, 
    0.01560545f, -0.01234982f, 0.03515899f, 0.00519700f, -0.04079134f, 0.00659646f, -0.02470007f, -0.01921918f, 
    0.01232277f, 0.01793461f, -0.00294283f, -0.04062387f, 0.02546037f, 0.02140406f, -0.01998281f, -0.01655291f, 
    0.01726174f, 0.00903639f, -0.02727373f, -0.04207134f, 0.01046527f, 0.00868264f, -0.03787904f, 0.02807675f, 
    -0.01147952f, -0.02803212f, -0.04206408f, 0.00453641f, -0.02501243f, 0.00905599f, 0.00648019f, 0.01650296f, 
    -0.00903465f, -0.01632220f, -0.00277088f, -0.04063818f, 0.01467667f, 0.01288750f, 0.01109818f, 0.01662842f, 
    -0.03691221f, -0.01073098f, -0.03293936f, 0.03064697f, 0.00222918f, -0.03305472f, -0.00658485f, 0.03261688f, 
    -0.01937205f, -0.00723641f, -0.01572267f, -0.03078744f, -0.00595499f, 0.01432065f, 0.00078720f, -0.01384532f, 
    -0.03936618f, 0.00113080f, 0.02701564f, 0.00368827f, -0.03515123f, -0.00968270f, -0.01491773f, -0.02673578f, 
    0.01048959f, -0.01901606f, 0.00905530f, -0.00962486f, 0.02095960f, -0.01653509f, 0.02737712f, -0.02105862f, 
    0.00076559f, -0.01940808f, -0.02829950f, -0.01904793f, -0.04278512f, 0.02441201f, 0.01156231f, -0.02237185f, 
    0.01704995f, -0.04443740f, 0.00625129f, 0.03340318f, -0.00392953f, 0.02300223f, -0.03889666f, 0.02538766f, 
    -0.02880992f, 0.03060530f, -0.02462654f, 0.01389912f, -0.03306378f, -0.03605899f, 0.00733013f, 0.00619010f, 
    -0.01401968f, -0.01317781f, -0.03806886f, -0.01937768f, 0.00793548f, -0.00828199f, -0.02945323f, -0.00073054f, 
    -0.02352617f, 0.00180527f, -0.03701796f, 0.03313555f, -0.03089458f, -0.00752868f, -0.03103210f, -0.00239329f, 
    0.00083741f, -0.00650656f, -0.01887162f, -0.03482383f, 0.00732217f, 0.00804899f, -0.02359348f, 0.00563353f, 
    -0.04364543f, -0.02785989f, -0.02066612f, -0.01352305f, -0.00727092f, 0.03311101f, 0.01981528f, 0.00890799f, 
    0.00622658f, 0.02935646f, -0.00681599f, -0.01258344f, 0.00328331f, 0.00474198f, 0.03053697f, -0.04450652f, 
    -0.04410059f, 0.02141909f, -0.02195958f, 0.03394607f, -0.00425962f, -0.01741217f, 0.01573725f, 0.02305021f, 
    -0.02807602f, 0.02494540f, 0.02553763f, -0.00481260f, 0.00748436f, -0.01728204f, -0.02522885f, 0.01829042f, 
    -0.00766335f, 0.01022577f, -0.01172905f, -0.03291239f, -0.01054122f, -0.04160956f, 0.02578184f, 0.02799376f, 
    0.00929321f, 0.01365870f, 0.02104187f, -0.01064742f, 0.03243470f, -0.02924130f, -0.02414088f, -0.02473045f, 
    -0.00314008f, 0.02329784f, -0.03078164f, 0.00272506f, -0.03257621f, 0.02853006f, -0.04497463f, -0.01431075f, 
    -0.00133357f, -0.03372335f, -0.02034436f, -0.00028650f, 0.02112895f, -0.01363582f, -0.00828285f, 0.01348267f, 
    -0.00102624f, -0.02597253f, -0.03887026f, -0.02193703f, -0.03392813f, 0.02835489f, -0.03226971f, 0.00806046f, 
    -0.03608274f, -0.01023202f, 0.01830889f, -0.03570267f, -0.04303747f, -0.02338215f, -0.03578163f, -0.04242466f, 
    0.00202507f, -0.02883469f, -0.03756668f, 0.01061137f, -0.00802357f, 0.00383063f, -0.03574781f, 0.01153166f, 
    -0.04151453f, 0.01056637f, -0.03495637f, 0.02245012f, -0.04407084f, -0.03019166f, 0.00192061f, -0.00687400f, 
    0.02200507f, -0.02868416f, 0.02503543f, -0.03136962f, -0.02107465f, -0.00982658f, 0.01184452f, 0.00116971f, 
    0.02722507f, 0.02478866f, -0.03035830f, -0.02070847f, -0.00686500f, 0.00893767f, 0.01012112f, 0.01923893f, 
    -0.03178567f, -0.02226604f, 0.01397621f, -0.03400186f, 0.02357512f, -0.00620242f, -0.03570063f, 0.02088123f, 
    0.01073814f, -0.04066982f, -0.01557222f, -0.01090922f, -0.00661591f, -0.02225321f, -0.01436277f, -0.02188717f, 
    0.01087866f, 0.00817229f, -0.03697083f, -0.03605697f, 0.00339899f, 0.02348973f, -0.01196483f, -0.02111270f, 
    0.00454824f, -0.00914180f, 0.01486373f, -0.04392489f, 0.03347590f, -0.02142328f, -0.02456077f, 0.00085190f, 
    -0.03158427f, 0.01407921f, 0.01015008f, -0.01581569f, 0.01748080f, -0.00996816f, 0.02555590f, 0.01496440f, 
    -0.02988184f, -0.02870018f, -0.01894774f, -0.00833791f, 0.02721640f, 0.00458354f, -0.02272454f, 0.01322507f, 
    -0.02161996f, 0.00626534f, 0.02079056f, -0.01017766f, -0.01580862f, -0.02783225f, -0.03791006f, 0.00050254f, 
    0.00383722f, 0.03073794f, 0.00713615f, 0.00234179f, -0.03490876f, 0.03390786f, -0.03546748f, -0.04322737f, 
    -0.02435998f, -0.01770797f, -0.04245891f, 0.01539523f, -0.01918641f, -0.00149722f, 0.00640660f, -0.03679464f, 
    -0.03212060f, 0.02363491f, -0.04075928f, 0.03343353f, 0.01958505f, 0.00120673f, 0.00470182f, 0.02618087f, 
    0.00713453f, -0.00603564f, -0.00166132f, -0.02954284f, -0.00297544f, 0.02291058f, 0.00025918f, 0.00291681f, 
    0.00623387f, 0.03058150f, 0.02269308f, -0.03590645f, 0.02738366f, 0.02581183f, -0.04104435f, -0.00384852f, 
    -0.03652054f, -0.02880931f, -0.03819153f, 0.00085435f, 0.02246605f, 0.03094807f, -0.00496306f, 0.01983317f, 
    0.00944585f, 0.03194951f, -0.00770578f, -0.03395062f, -0.00870278f, 0.01309442f, -0.01970727f, 0.01323424f, 
    -0.02600774f, -0.01325898f, -0.00789896f, -0.00650253f, -0.00472528f, 0.01817145f, -0.03947486f, 0.01882353f, 
    -0.04343284f, 0.00466630f, -0.01419202f, -0.03664847f, 0.02095510f, 0.01952212f, 0.02865826f, 0.00666755f, 
    0.03220125f, 0.00188582f, 0.02749971f, 0.02929049f, 0.00944660f, -0.03428964f, -0.00758604f, -0.02319522f, 
    -0.01063475f, 0.01387368f, 0.02602116f, -0.00251082f, -0.01059662f, -0.00014759f, -0.01189809f, -0.00080563f, 
    -0.00148049f, -0.03841712f, 0.01275492f, 0.00738531f, 0.02786109f, 0.01034365f, 0.00156752f, -0.03095415f, 
    -0.03932410f, -0.03114199f, -0.03307693f, -0.01650927f, 0.02381677f, 0.01288443f, -0.00964700f, -0.00368721f, 
    -0.03712668f, -0.00800502f, 0.01619299f, -0.00077551f, 0.00916647f, -0.01538706f, -0.01309119f, -0.04260307f, 
    -0.02476756f, -0.01953671f, -0.00710660f, -0.02068608f, 0.02956280f, -0.02295362f, -0.03825676f, -0.00633590f, 
    -0.00073728f, -0.03665940f, -0.01646507f, -0.03210370f, -0.00434892f, -0.04121673f, -0.03115337f, -0.01632425f, 
    0.00936837f, 0.01093216f, 0.00006678f, 0.02568367f, -0.04174634f, -0.02998275f, -0.03222984f, 0.01445975f, 
    -0.00878982f, 0.01039182f, 0.02962629f, -0.02722247f, 0.03460606f, -0.03633450f, 0.02585076f, 0.00677158f, 
    -0.02540780f, 0.01973294f, -0.04022603f, 0.02949591f, -0.04192585f, -0.00762577f, 0.00003496f, -0.01952470f, 
    -0.01616967f, 0.00837848f, -0.02698646f, 0.03267289f, -0.03245005f, -0.03761413f, -0.03630821f, 0.00326775f, 
    0.01068281f, 0.01731857f, 0.01518830f, -0.00013485f, -0.03800723f, -0.02711014f, 0.00193619f, -0.04282879f, 
    -0.04140037f, -0.02080507f, 0.02948486f, -0.02320074f, 0.00276635f, -0.00099227f, -0.01317912f, 0.03165822f, 
    0.01980950f, -0.03083081f, 0.02623514f, 0.01358084f, 0.02087605f, -0.02660627f, -0.03220198f, 0.00855361f, 
    -0.01292919f, 0.00599249f, -0.03906998f, -0.02273812f, 0.01745144f, -0.04419231f, -0.00178252f, -0.03446673f, 
    -0.00923805f, -0.01205717f, -0.03178127f, 0.02230694f, -0.03859584f, -0.03999805f, -0.04201011f, -0.00633858f, 
    -0.44545710f, -0.33542544f, -0.07454853f, -0.05554566f, -0.13173561f, -0.11407564f, 0.07632367f, 0.06923922f, 
    -0.00915353f, -0.01943634f, -0.02331996f, 0.02271762f, 0.00488762f, 0.00613736f, 0.07380294f, 0.04648688f, 
    0.01357708f, -0.09233031f, 0.11271815f, 0.09819595f, 0.14048834f, 0.15561272f, 0.16505091f, 0.32158458f, 
    0.10520453f, -0.11629006f, 0.08463830f, 0.06287976f, -0.04097886f, 0.00031692f, 0.06610397f, 0.01090890f, 
    0.06704457f, 0.01787387f, -0.01020040f, 0.08461466f, 0.00016987f, 0.05703013f, 0.07465466f, -0.00052646f, 
    -0.12681353f, 0.24690939f, 0.18798007f, -0.02507859f, 0.02466549f, 0.03572533f, -0.05835236f, -0.00945688f, 
    0.01093513f, 0.02369933f, -0.04993983f, 0.08950386f, -0.10336379f, 0.09304429f, -0.08418623f, -0.07082745f, 
    0.00372700f, -0.03086703f, 0.21757406f, -0.07619171f, 0.10702504f, 0.02571662f, -0.19845201f, -0.01085216f, 
    -0.05454817f, 0.02072021f, -0.02747155f, 0.05518017f, -0.07388006f, 0.09848681f, 0.05135474f, 0.00972465f, 
    -0.06070445f, -0.03292754f, 0.01227621f, 0.02639215f, 0.09757798f, 0.00619140f, 0.00833755f, 0.08778471f, 
    0.06983867f, -0.16665149f, 0.05813711f, 0.20288226f, 0.10132654f, -0.08113877f, 0.00173368f, -0.02953673f, 
    0.02451666f, 0.02706457f, 0.01949105f, 0.00502015f, -0.04438602f, 0.02814403f, 0.06758040f, -0.03755486f, 
    0.03152245f, 0.03005819f, 0.04914125f, -0.07783653f, -0.03108858f, 0.15427423f, 0.01924932f, 0.03707463f, 
    -0.06798766f, 0.04961988f, -0.00766026f, -0.11914141f, -0.07166100f, 0.11488452f, 0.01743171f, 0.04716555f, 
    -0.05819440f, -0.03088170f, 0.06371185f, -0.04579015f, 0.01291338f, -0.07100220f, -0.01311060f, 0.01110442f, 
    0.09810244f, 0.05391482f, 0.03296781f, -0.00715780f, -0.00827628f, 0.04356794f, 0.08689584f, -0.02638195f, 
    -0.15490505f, 0.05107340f, 0.03858126f, -0.02632283f, -0.01416531f, 0.01730489f, -0.09725390f, 0.00431619f, 
    -0.05617100f, -0.05743754f, -0.00091954f, -0.12008069f, -0.29566887f, 0.32168791f, -0.00385640f, 0.00785293f, 
    -0.10669646f, 0.04065374f, -0.07805207f, 0.08262057f, -0.06915295f, -0.06985922f, -0.00003186f, -0.03141582f, 
    0.03683519f, 0.05967361f, 0.04103490f, -0.06895177f, 0.07282195f, -0.02514425f, 0.03407075f, 0.00418198f, 
    -0.16621605f, 0.30691379f, 0.11559977f, -0.04594875f, 0.13658263f, 0.11253078f, -0.03749609f, 0.02545063f, 
    0.16172013f, -0.12719963f, 0.08858719f, -0.06522361f, 0.00177904f, 0.01327100f, 0.05691385f, -0.04100316f, 
    0.12906738f, 0.04229362f, 0.14297867f, -0.03975464f, -0.06487175f, 0.09355768f, 0.07690521f, 0.00196803f, 
    -0.02110762f, 0.00737423f, 0.07283540f, 0.00883143f, 0.02838112f, -0.04269783f, 0.00019346f, 0.00402783f, 
    0.01979128f, 0.01914074f, -0.00019505f, 0.01493351f, -0.06268352f, 0.03801908f, 0.09482533f, 0.03441644f, 
    0.13103239f, -0.27246416f, -0.01748767f, -0.19815958f, -0.16579175f, -0.07056808f, 0.11404024f, 0.00099025f, 
    -0.07624701f, 0.00725986f, -0.00634502f, -0.07094614f, -0.02500490f, -0.00188528f, 0.08922306f, -0.00935136f, 
    0.06272323f, -0.09554622f, 0.02080154f, 0.06434510f, -0.16024283f, 0.20787315f, -0.09855504f, 0.16154721f, 
    0.02095562f, -0.06031116f, 0.01845573f, 0.02324573f, -0.01401743f, -0.00241283f, 0.07152196f, 0.02159930f, 
    0.03800709f, 0.00139799f, 0.15388955f, -0.14362580f, 0.00932674f, -0.07001562f, -0.03284970f, 0.01059181f, 
    0.08340682f, -0.01193319f, 0.00611240f, 0.24560301f, 0.16801725f, -0.01911489f, 0.04694553f, 0.01449623f, 
    -0.03979778f, 0.04807861f, -0.08390923f, 0.01766679f, 0.00272674f, -0.05582391f, 0.07028992f, -0.07601535f, 
    -0.09733561f, 0.11115256f, 0.10452192f, -0.03171759f, 0.16620724f, 0.11410885f, -0.04694417f, 0.07862306f, 
    0.15682951f, -0.02403263f, 0.04715920f, -0.05543423f, 0.03648662f, 0.05448631f, 0.05564741f, 0.02440833f, 
    0.01167842f, -0.07443350f, 0.01939868f, -0.01206184f, 0.05470699f, 0.08202925f, 0.03874623f, 0.05992505f, 
    -0.09985393f, 0.09114209f, 0.14957307f, 0.04817721f, 0.08013764f, 0.11230339f, 0.14912939f, 0.10250003f, 
    0.00431878f, 0.07602642f, -0.06783066f, 0.03839104f, 0.07868958f, -0.05935758f, 0.05184124f, -0.06369797f, 
    0.18673596f, 0.04002721f, 0.07343376f, -0.01181312f, -0.32859084f, 0.19086710f, 0.04369611f, -0.09424955f, 
    0.04705497f, 0.07037606f, 0.00916713f, -0.12267111f, 0.04722947f, -0.05836821f, -0.03922799f, 0.06324426f, 
    0.00524766f, 0.09865514f, 0.09390505f, -0.02769391f, 0.05691649f, -0.09713009f, 0.04497334f, -0.05161216f, 
    -0.10487237f, -0.25837106f, -0.06284190f, -0.08650737f, -0.12791175f, 0.03369944f, -0.04127332f, 0.02643042f, 
    -0.00514240f, 0.04129498f, -0.00175619f, 0.02132776f, -0.04160101f, 0.00377110f, -0.02962152f, 0.00456108f, 
    0.02846034f, -0.10482975f, 0.07518567f, 0.09094895f, -0.17538604f, 0.09191589f, -0.13052194f, -0.01298346f, 
    -0.09300652f, 0.08967745f, -0.02387108f, 0.04000897f, -0.04408539f, 0.02842769f, -0.06193013f, 0.09236220f, 
    0.03094750f, -0.02826933f, 0.05301833f, 0.08562488f, -0.05917554f, 0.07518861f, 0.00823432f, 0.03590275f, 
    -0.14192708f, 0.07437850f, 0.07240523f, 0.03931915f, 0.00076810f, 0.12284675f, -0.05240963f, 0.12011903f, 
    0.00375647f, -0.05083027f, 0.02723105f, 0.00990024f, 0.04239278f, 0.06503548f, -0.11368117f, -0.00237388f, 
    0.06739894f, -0.00146680f, 0.04635184f, -0.02139910f, -0.19147852f, 0.15021841f, 0.12943131f, 0.22745600f, 
    -0.13394806f, 0.06393256f, -0.02371305f, -0.03963963f, 0.12487360f, 0.00129277f, 0.03304911f, 0.08266287f, 
    -0.04439798f, 0.01947034f, 0.00027277f, 0.02415594f, -0.05134095f, -0.07401709f, 0.00757930f, 0.01415036f, 
    -0.18698066f, 0.12300089f, -0.02968318f, 0.11065301f, 0.11159924f, -0.04292911f, -0.01868295f, 0.15694469f, 
    -0.00135810f, 0.02786791f, -0.01770833f, -0.04263167f, 0.01218571f, 0.04007680f, -0.00558799f, 0.03652073f, 
    0.01924266f, 0.09089684f, 0.02176141f, 0.03312642f, -0.06026749f, 0.22804999f, -0.00734056f, 0.16199885f, 
    -0.07959994f, -0.01374312f, 0.05490796f, 0.04513213f, 0.06616333f, 0.09343874f, -0.00597749f, -0.08802087f, 
    -0.02884849f, 0.13709022f, -0.04897886f, -0.00667429f, 0.08881448f, 0.02989833f, -0.01895533f, -0.08875397f, 
    0.08212209f, 0.23735273f, 0.02366002f, 0.18775783f, -0.02759930f, 0.08895168f, -0.00901986f, -0.00789953f, 
    -0.04161859f, -0.00377894f, 0.08013400f, 0.09404824f, 0.02440910f, -0.03435349f, 0.07375576f, 0.06914439f, 
    -0.05221402f, 0.02105689f, 0.02699794f, 0.03965966f, -0.08335426f, 0.09539909f, -0.05359772f, -0.06227282f, 
    0.02862007f, 0.00573490f, 0.08258978f, 0.05204837f, 0.00403225f, -0.00684179f, -0.01367319f, -0.03629826f, 
    0.12600291f, 0.00415629f, -0.01662321f, 0.01929511f, -0.02886747f, 0.13394907f, 0.06956420f, 0.03908079f, 
    -0.01830821f, -0.00645118f, 0.07749333f, 0.05463379f, 0.17557511f, 0.10205193f, 0.05981268f, 0.00019803f, 
    0.00147284f, 0.01213067f, -0.02490338f, 0.08287814f, 0.06588265f, 0.00388070f, 0.03664960f, 0.00197517f, 
    -0.02374665f, 0.09308178f, 0.02531808f, -0.01953321f, 0.32673401f, -0.01500126f, -0.05349602f, -0.03892977f, 
    0.11804276f, 0.06692827f, -0.04409136f, -0.04511978f, 0.07449383f, -0.14999746f, -0.05328485f, -0.06424199f, 
    0.02984479f, 0.03551811f, -0.11532257f, 0.01231189f, 0.00186204f, -0.07397966f, -0.03260609f, 0.04023276f, 
    -0.24571113f, -0.00203330f, -0.06997396f, -0.03122916f, 0.09721409f, 0.01134437f, -0.03278046f, -0.05462233f, 
    0.09164849f, -0.03797492f, 0.03039059f, 0.02013813f, 0.01225854f, 0.05008220f, 0.03266650f, -0.00038764f, 
    0.00821767f, -0.00398479f, 0.01793602f, 0.01315124f, 0.02826613f, -0.37537089f, -0.15252016f, -0.08049038f, 
    -0.02448420f, 0.12608802f, 0.03076329f, -0.07056996f, -0.00705502f, -0.04836892f, 0.04192913f, 0.04672508f, 
    0.01234569f, 0.03238385f, -0.03663342f, -0.07128147f, 0.02568766f, 0.06519993f, 0.02126095f, 0.01481790f, 
    0.47532603f, -0.09433780f, 0.07276637f, 0.13078763f, 0.32826817f, -0.02630213f, 0.03360329f, -0.00190097f, 
    0.05110206f, -0.02218447f, -0.04836606f, 0.09095509f, -0.10079619f, 0.03220741f, 0.00227463f, -0.05838019f, 
    0.03782838f, 0.00079401f, -0.12899351f, 0.04259901f, 0.00687558f, 0.27138713f, 0.06990999f, 0.17035085f, 
    0.03341696f, -0.09250424f, 0.03206520f, -0.03992328f, -0.07563856f, 0.00444750f, 0.00444058f, -0.08595672f, 
    -0.01362579f, -0.01240596f, 0.00008091f, 0.03626502f, 0.05604786f, 0.01168868f, -0.06279758f, 0.09827305f, 
    0.03677738f, 0.09203567f, -0.01400911f, 0.16640343f, 0.00714038f, 0.03038746f, 0.03303830f, 0.02288265f, 
    0.03990898f, 0.09783837f, 0.04299572f, -0.02470872f, -0.01896083f, -0.01158531f, 0.00133926f, 0.09752443f, 
    -0.04692226f, 0.17049637f, 0.09598374f, 0.05988375f, -0.08414777f, -0.17938301f, 0.07772188f, -0.04270485f, 
    0.12591083f, 0.00088404f, -0.01050702f, 0.00116966f, -0.00113895f, 0.07510550f, -0.00826570f, -0.02416742f, 
    0.01698346f, -0.05302290f, 0.01185362f, -0.00811290f, 0.06628665f, -0.01826024f, 0.02687336f, 0.09754843f, 
    0.15706202f, -0.34314477f, -0.08484915f, -0.10533679f, -0.40456235f, 0.05308201f, 0.16986316f, -0.16071439f, 
    -0.04294121f, 0.01245053f, -0.02304246f, -0.04931347f, -0.07482757f, 0.10205715f, -0.04033524f, 0.08822834f, 
    -0.14592518f, 0.12199962f, -0.02249344f, 0.03943280f, 0.15523683f, 0.15124492f, -0.03662067f, -0.06004169f, 
    0.23229837f, 0.00140251f, 0.00240139f, -0.00215385f, 0.02791065f, 0.15395924f, -0.02243584f, -0.06211149f, 
    -0.07340241f, -0.10507718f, 0.03391564f, 0.15241159f, -0.04575735f, 0.03378175f, 0.04984680f, -0.07301981f, 
    0.38504380f, -0.22984158f, -0.02893721f, 0.14943406f, -0.11836010f, -0.01858687f, 0.07742617f, -0.03137090f, 
    -0.00056265f, 0.06161468f, 0.04778554f, 0.00097738f, 0.05747192f, -0.07896148f, -0.08583533f, -0.02535432f, 
    0.18354779f, 0.03544716f, -0.00383028f, 0.08309373f, 0.00965133f, 0.16887283f, 0.07495816f, -0.03584196f, 
    0.34319034f, 0.26663879f, 0.11248402f, 0.08344018f, 0.12036023f, -0.02731382f, 0.06491740f, -0.00082961f, 
    0.02809045f, 0.06815654f, -0.02003611f, -0.00950005f, 0.11968274f, 0.04595454f, 0.07042503f, 0.08437420f, 
    0.14465421f, 0.13725965f, -0.05605224f, -0.22555922f, -0.13484412f, 0.01331508f, 0.08202481f, -0.03916844f, 
    -0.03141773f, 0.05364170f, -0.06169518f, 0.09102919f, -0.05157917f, -0.02189703f, -0.11314353f, 0.04111196f, 
    0.03675976f, -0.07397320f, -0.03029515f, 0.04743123f, 0.32501709f, 0.09941161f, 0.24783380f, -0.11235405f, 
    0.17184216f, -0.00918477f, 0.04710482f, 0.07414965f, -0.00402049f, -0.07558235f, 0.11233623f, -0.06812575f, 
    0.06904344f, 0.04037384f, 0.13891740f, 0.03839596f, -0.03396372f, 0.04128033f, 0.14456904f, 0.05186113f, 
    0.12310538f, -0.02787055f, -0.09759601f, -0.02559023f, -0.09652095f, 0.03564385f, 0.02999997f, 0.02222340f, 
    0.08431070f, -0.05840836f, -0.04175257f, 0.19783019f, -0.00211720f, -0.01889849f, 0.11616464f, -0.13839066f, 
    0.14211400f, 0.15027030f, 0.06298623f, 0.02242112f, -0.07683399f, 0.00936415f, -0.28738585f, 0.03361848f, 
    -0.01129829f, 0.06236285f, 0.12135615f, 0.11098453f, -0.01382436f, 0.16958281f, 0.01994980f, 0.03645843f, 
    0.03846226f, -0.00629360f, -0.08137602f, 0.06192251f, 0.02871554f, 0.04783246f, 0.02271306f, 0.00497244f, 
    0.14759764f, -0.14315026f, -0.04037075f, 0.06775510f, -0.01677850f, 0.05669860f, -0.02560136f, 0.04044746f, 
    -0.02888916f, 0.10984939f, 0.02803191f, 0.10044616f, 0.14737822f, 0.01299747f, 0.04243268f, -0.08172844f, 
    0.05183868f, -0.01030603f, -0.10896793f, 0.12626974f, 0.20940994f, 0.24136184f, 0.02356235f, 0.00780086f, 
    0.17351048f, -0.06960369f, -0.05961505f, 0.08883936f, -0.00443712f, -0.01721002f, -0.04767686f, 0.00713252f, 
    -0.01241215f, -0.07475058f, -0.04275516f, 0.07851653f, 0.17976986f, 0.15789551f, 0.13828324f, 0.08239735f, 
    -0.37913629f, -0.26345283f, -0.14751595f, 0.12164482f, -0.26389128f, 0.02376468f, 0.03682366f, 0.06321666f, 
    -0.05495030f, -0.03500258f, -0.01829858f, 0.04938957f, -0.11077671f, 0.12395924f, -0.01129737f, 0.13464321f, 
    0.04918589f, 0.04369621f, -0.10527144f, 0.09728074f, -0.26889905f, 0.01460257f, -0.28594837f, 0.05114868f, 
    0.01872441f, 0.16154374f, 0.10107354f, -0.08690958f, 0.13722490f, 0.11153511f, 0.03470954f, 0.02438932f, 
    0.00362372f, 0.02725922f, 0.01824499f, 0.12155086f, 0.10066496f, 0.13289098f, 0.09939590f, 0.00827086f, 
    0.39134553f, 0.46452171f, 0.06936112f, -0.37402889f, -0.06360878f, 0.11492424f, -0.02683107f, 0.08607820f, 
    0.14674133f, 0.04990624f, -0.00353410f, 0.06393080f, 0.06848659f, 0.06144113f, -0.12954310f, -0.01479125f, 
    0.03868279f, -0.05715769f, 0.07716548f, 0.03063781f, 0.29072544f, 0.30262998f, 0.03419351f, -0.07947155f, 
    0.07130322f, -0.00546187f, -0.05798474f, 0.06459492f, -0.06656729f, -0.01118402f, -0.15198070f, -0.14393777f, 
    -0.06290062f, -0.11094181f, -0.03448613f, -0.02144810f, -0.00164818f, -0.16212611f, 0.05901223f, -0.11942890f, 
    0.50263494f, 0.11599565f, 0.22597718f, -0.01976250f, 0.06276651f, 0.04648924f, 0.03794026f, 0.02630063f, 
    -0.03205347f, -0.08040085f, -0.04740689f, -0.01974322f, 0.18921790f, 0.01313929f, 0.03805676f, 0.12786326f, 
    -0.04172458f, -0.10968889f, -0.01001510f, 0.10369083f, 0.49464232f, -0.02373826f, 0.06498498f, 0.18861990f, 
    0.27040842f, -0.03089820f, 0.15997651f, 0.12284416f, 0.05671705f, 0.13159354f, -0.04492133f, 0.05864746f, 
    0.06309908f, 0.10279074f, 0.04974843f, -0.04342407f, 0.03571197f, -0.01024732f, -0.04900168f, 0.07643195f, 
    -0.19809645f, -0.32590622f, -0.13637075f, -0.13786282f, -0.35949039f, 0.08595214f, 0.20206034f, -0.03944802f, 
    -0.00648261f, -0.01775181f, -0.02863083f, -0.01778125f, -0.10500464f, 0.06504879f, 0.03186652f, 0.05704987f, 
    0.03749967f, 0.02442048f, -0.06046665f, -0.02335715f, 0.17612524f, -0.26640031f, -0.00743183f, 0.03009148f, 
    0.00369767f, 0.01762940f, 0.07815541f, 0.04598991f, 0.07715676f, 0.03371016f, -0.08625035f, 0.00025985f, 
    0.02020100f, 0.06044012f, -0.01676151f, -0.14420138f, -0.01464141f, 0.03094220f, -0.00490849f, 0.08989365f, 
    0.31286079f, -0.09665854f, 0.00704107f, 0.10609206f, -0.14942972f, -0.01739130f, 0.01422420f, 0.02568008f, 
    0.06580041f, 0.02729217f, -0.04714209f, 0.13584012f, 0.00408854f, 0.04511226f, 0.10272765f, -0.09891377f, 
    -0.00551846f, 0.02792900f, -0.09779117f, 0.10808370f, 0.33933103f, -0.20024197f, 0.11679275f, -0.02477272f, 
    0.27590239f, -0.02358057f, -0.00780022f, -0.05837524f, 0.13395973f, 0.10474618f, -0.00817705f, -0.03685516f, 
    0.01901850f, 0.04484374f, -0.01929065f, 0.08886331f, 0.03749584f, 0.07010521f, 0.14790076f, 0.14070888f, 
    0.44566384f, 0.07978844f, 0.06517772f, 0.16841042f, 0.06102801f, 0.06765917f, 0.06937028f, 0.13767135f, 
    0.00654958f, 0.11467943f, -0.15602528f, -0.03217230f, 0.01790911f, 0.01192361f, -0.11362841f, 0.02416545f, 
    -0.00012274f, 0.01922397f, -0.04453352f, -0.02008917f, -0.26550624f, -0.15357935f, -0.42149115f, -0.05582240f, 
    -0.05572293f, 0.00608282f, 0.06572057f, 0.07607678f, -0.01690208f, 0.09236034f, -0.07032478f, 0.02213902f, 
    0.07026276f, -0.12972602f, 0.11144929f, 0.08996223f, 0.01672724f, -0.01846766f, -0.04986001f, 0.01764532f, 
    0.08246566f, 0.13215826f, 0.04360853f, -0.07485437f, 0.28707373f, 0.07149352f, 0.16183865f, 0.05022706f, 
    0.08444356f, 0.07776576f, -0.00216426f, -0.04666442f, -0.05565686f, 0.04013459f, 0.16276263f, 0.11104880f, 
    0.06188389f, 0.06383262f, -0.08071660f, 0.07649833f, 0.35338226f, 0.00128463f, 0.23950286f, -0.05671598f, 
    0.03600039f, 0.00104543f, 0.01290738f, 0.01198054f, -0.08824492f, -0.04713248f, 0.01183793f, 0.05608784f, 
    0.00680386f, -0.11432400f, -0.01852491f, -0.04476829f, -0.01018861f, -0.01109336f, 0.12086038f, -0.06782923f, 
    0.50420380f, 0.08122756f, 0.11099312f, 0.06616371f, -0.17652915f, 0.00295452f, -0.01564808f, 0.13936158f, 
    -0.18785886f, -0.10551085f, -0.08965270f, -0.02221180f, 0.02272638f, 0.00431485f, 0.01662924f, -0.14430882f, 
    0.02254675f, 0.03460236f, -0.02916245f, 0.00598365f, 0.40111372f, -0.13226484f, -0.02184365f, 0.02025136f, 
    0.29351002f, -0.02981161f, -0.06503525f, 0.00617027f, 0.06523710f, 0.22863518f, -0.09383117f, 0.04449551f, 
    0.11611896f, 0.02657238f, -0.04644268f, 0.05616789f, 0.01989211f, 0.03050961f, 0.07845442f, 0.02871116f, 
    -0.36149529f, -0.11316251f, -0.00076600f, -0.03244036f, -0.10428305f, 0.12538707f, 0.11225270f, -0.04076310f, 
    0.00176493f, 0.00380884f, 0.09109525f, -0.00012923f, 0.02608095f, 0.00782326f, -0.04744986f, -0.03025972f, 
    0.07430200f, 0.08682446f, 0.03183487f, 0.08450910f, -0.10300899f, -0.23798253f, -0.24852681f, -0.23525561f, 
    -0.43948230f, 0.05009838f, 0.02598086f, -0.00916626f, -0.05298785f, -0.01180814f, 0.03704780f, -0.05284122f, 
    -0.03066607f, 0.00783637f, -0.02869203f, 0.13411953f, -0.06474182f, -0.07100189f, -0.09169471f, -0.02769981f, 
    0.09082018f, 0.39231285f, 0.10245702f, -0.01113356f, 0.23077646f, -0.01156938f, -0.05681788f, 0.15334837f, 
    0.13370626f, 0.10436235f, -0.13985758f, 0.00720348f, 0.08903533f, 0.00312589f, -0.02171593f, 0.10566335f, 
    0.01270948f, -0.11520486f, 0.13898534f, -0.05276299f, 0.21941887f, 0.43032688f, 0.20559295f, -0.12169843f, 
    0.26189023f, -0.00130235f, 0.04738084f, 0.05603083f, 0.07128590f, 0.02007535f, -0.04082794f, 0.05352180f, 
    0.04000613f, 0.06340785f, 0.03521097f, 0.06710226f, 0.01914258f, -0.01498308f, 0.03865260f, 0.08152512f, 
    0.36035371f, 0.14790805f, 0.03703888f, -0.02536825f, 0.20883277f, 0.11375213f, 0.02193540f, 0.14723726f, 
    -0.07146744f, 0.01924303f, -0.06238353f, -0.04469919f, -0.05584904f, 0.03815035f, -0.01321926f, 0.03999690f, 
    -0.00783835f, -0.04064450f, -0.03196636f, 0.01904024f, -0.17196786f, 0.16010760f, -0.08154109f, -0.15930130f, 
    -0.13199832f, 0.14635241f, 0.07917334f, -0.09383183f, 0.01228071f, -0.08700538f, 0.02866641f, 0.06789204f, 
    -0.07725654f, 0.05084715f, 0.02281465f, 0.01145025f, -0.15772574f, 0.04692715f, -0.10585092f, -0.01867856f, 
    0.45870212f, -0.02619508f, -0.15296151f, -0.02117861f, -0.02414681f, 0.05377675f, 0.05283104f, 0.03236679f, 
    0.05982669f, 0.11013071f, 0.04114290f, 0.06891032f, 0.04898342f, 0.09165528f, -0.01126354f, 0.14809850f, 
    0.01144834f, 0.14293581f, 0.03832044f, 0.14228769f, -0.12583587f, -0.04714236f, -0.15171386f, -0.06453777f, 
    -0.06682501f, -0.01091404f, -0.05771020f, -0.04901406f, 0.08585854f, 0.01649593f, 0.08187751f, 0.01907425f, 
    0.01757762f, -0.01592708f, 0.03031289f, -0.11463678f, -0.01775656f, -0.18579431f, 0.12626588f, -0.04271528f, 
    -0.06160275f, -0.03650888f, -0.08643784f, 0.05559720f, 0.01891007f, -0.02575006f, -0.09647346f, 0.04076167f, 
    0.12229895f, -0.07351476f, 0.07526910f, -0.03538757f, 0.10996593f, -0.07161360f, 0.05394841f, 0.08001207f, 
    -0.09449855f, -0.12714563f, -0.08966065f, 0.06339472f, -0.18043126f, 0.32206756f, -0.17784660f, 0.03351001f, 
    -0.04640497f, 0.16343091f, 0.13771118f, -0.14945075f, 0.01566521f, -0.08968870f, -0.05149859f, 0.01323956f, 
    -0.07895052f, 0.17540652f, -0.06071368f, 0.00188851f, 0.05963857f, -0.10324985f, 0.08985893f, 0.08939172f, 
    0.00940540f, 0.02308884f, -0.17911172f, -0.17632346f, -0.12126410f, 0.11341635f, -0.03183844f, -0.01925687f, 
    -0.00420934f, 0.01208895f, 0.05442816f, -0.03093663f, 0.04686136f, 0.08414220f, 0.09490420f, -0.07269228f, 
    -0.00165164f, 0.13045922f, -0.03299602f, -0.05434676f, -0.29441223f, 0.08997107f, -0.10172066f, -0.01330982f, 
    0.17369828f, 0.09289115f, -0.01257665f, 0.00059392f, 0.09997184f, 0.10629062f, -0.04487086f, 0.08863971f, 
    -0.09398466f, 0.08375157f, -0.03541973f, 0.03867562f, 0.07997625f, 0.00774878f, -0.03446683f, 0.07596465f, 
    -0.12923895f, 0.09871215f, -0.08179341f, 0.12320402f, 0.03277617f, 0.00778995f, -0.00987061f, 0.02883337f, 
    0.06624837f, 0.08565310f, 0.01360833f, 0.05138490f, -0.14117847f, 0.01138502f, 0.01151695f, 0.09514302f, 
    0.05820473f, 0.25172052f, -0.07343636f, 0.06982606f, 0.26727256f, 0.03660525f, -0.04915777f, -0.03313906f, 
    -0.06254176f, -0.08254903f, 0.07089867f, -0.02226285f, -0.06472442f, 0.02092653f, 0.04574347f, -0.06530293f, 
    -0.01836590f, -0.06923289f, -0.00948172f, -0.02129501f, 0.10952235f, -0.06546328f, 0.10472461f, -0.02649641f, 
    -0.12894113f, -0.01224769f, -0.10354728f, 0.06909405f, 0.07012116f, -0.04793572f, -0.00639341f, -0.03692538f, 
    -0.11371656f, 0.03103743f, -0.03921193f, 0.08948070f, -0.06645156f, -0.11765388f, 0.04311965f, -0.05887708f, 
    -0.17303778f, 0.08319234f, 0.04587018f, 0.05439319f, 0.00940571f, 0.04586622f, -0.04193757f, -0.01407727f, 
    -0.01105427f, -0.13838130f, 0.03084648f, 0.01205499f, 0.01357306f, -0.01405650f, 0.04627984f, 0.06580026f, 
    0.15010980f, 0.11253095f, -0.01782279f, 0.04219767f, 0.03691084f, -0.20264030f, -0.21848720f, 0.03486126f, 
    0.16376516f, 0.18452735f, 0.02381048f, -0.04461435f, 0.03975740f, 0.06046405f, 0.11241345f, 0.01636294f, 
    0.00530964f, 0.17644399f, 0.06998542f, 0.09444392f, -0.03532980f, 0.06093473f, -0.10487424f, -0.00046998f, 
    -0.10262531f, 0.35316750f, 0.01232532f, 0.12311421f, 0.03314302f, 0.09908499f, -0.10913467f, 0.01197567f, 
    0.05224690f, 0.10248765f, 0.07374839f, -0.00451109f, -0.08712998f, 0.03089682f, 0.13903788f, -0.08491834f, 
    -0.07372843f, 0.07877669f, -0.08516502f, -0.01801827f, 0.09603581f, -0.08590811f, 0.01644748f, 0.05711736f, 
    0.00282428f, -0.16840392f, -0.15570232f, -0.24221469f, 0.10553827f, 0.04323986f, -0.09207018f, -0.05503189f, 
    0.13376261f, -0.05759311f, 0.04624991f, -0.05660667f, 0.02552799f, 0.17717461f, 0.16769896f, 0.00171317f, 
    0.12091312f, 0.03251140f, -0.26694769f, 0.05435989f, -0.00913060f, 0.11367495f, 0.12943140f, -0.11049084f, 
    0.01019224f, -0.09486412f, -0.00144791f, 0.08232813f, 0.02980842f, 0.05461442f, 0.03941024f, 0.08102471f, 
    0.05668283f, 0.10988162f, -0.07297422f, 0.06556768f, 0.00814228f, -0.11518694f, -0.16551833f, -0.08011796f, 
    -0.13432054f, 0.04332026f, 0.06179274f, -0.17280413f, 0.05146727f, 0.09194453f, -0.10798338f, -0.00366371f, 
    0.01923708f, 0.13134076f, 0.07733852f, -0.00197312f, -0.10455997f, 0.02949365f, -0.01469423f, -0.04406258f, 
    0.01978954f, 0.03848206f, -0.23379624f, -0.06417070f, -0.24891056f, 0.10570692f, 0.02401618f, 0.04298360f, 
    0.16923721f, 0.12729160f, 0.05303993f, 0.09304606f, 0.08796890f, 0.06097642f, 0.01600308f, 0.01313600f, 
    0.11398735f, -0.03035979f, 0.05057356f, 0.17118534f, -0.07061062f, 0.01947886f, 0.13318509f, -0.00840643f, 
    0.27087075f, 0.11764514f, 0.00653656f, 0.02188150f, -0.11096985f, 0.09917889f, 0.11700235f, -0.02742698f, 
    0.01707449f, 0.01946496f, 0.07248320f, -0.00716316f, 0.02479036f, -0.02003957f, -0.02048375f, -0.08132373f, 
    0.04442426f, 0.33212015f, 0.10853664f, -0.02539433f, -0.08212011f, -0.00828134f, 0.16801271f, 0.08429079f, 
    0.07037642f, 0.01194131f, -0.04817753f, 0.05996405f, 0.09409754f, -0.01381362f, 0.04482538f, -0.05357698f, 
    -0.00974983f, 0.04262010f, -0.09149714f, -0.03580476f, 0.04396496f, 0.07577112f, 0.11641003f, 0.02148934f, 
    -0.38406140f, -0.01490473f, 0.10207965f, 0.05727288f, 0.11278456f, -0.06186698f, 0.04059554f, 0.09334333f, 
    -0.14683856f, -0.02323759f, 0.00065814f, 0.01552775f, 0.04429800f, -0.13038479f, -0.02705286f, 0.00579817f, 
    -0.07026960f, 0.04936748f, -0.02532073f, 0.08701423f, -0.02376156f, -0.15537794f, -0.09740226f, -0.03712793f, 
    -0.04890653f, -0.02909236f, 0.00365946f, -0.06490120f, -0.00758464f, 0.06360038f, -0.01236596f, 0.09122050f, 
    0.10892742f, 0.06845936f, 0.10854829f, -0.03845411f, 0.04901320f, 0.00236610f, -0.00943123f, -0.00694823f, 
    0.03507570f, 0.12215500f, 0.09185494f, -0.06006541f, -0.06573056f, -0.05491365f, 0.03128032f, 0.02703605f, 
    -0.09135512f, -0.01164470f, 0.04851040f, -0.01956382f, 0.05271412f, -0.19057812f, 0.01031036f, -0.01812796f, 
    0.04240233f, -0.09021925f, 0.02758746f, -0.02311114f, 0.00001076f, 0.07502986f, -0.03811769f, 0.22125627f, 
    0.02396996f, 0.00721302f, 0.01083602f, 0.04967956f, -0.11030663f, -0.05395208f, 0.14488517f, 0.04144692f, 
    0.05956891f, -0.01790385f, 0.00702125f, -0.11437737f, 0.03124913f, -0.06944027f, 0.05913518f, -0.06834432f, 
    -0.15362982f, 0.02284755f, -0.08799998f, -0.00414453f, 0.00452423f, -0.03005203f, 0.07045598f, 0.04923666f, 
    0.11065897f, -0.03788812f, 0.09530928f, -0.01787037f, 0.07856343f, -0.01382425f, 0.10889072f, -0.10892468f, 
    0.07460418f, -0.09851929f, -0.07834950f, 0.07946750f, -0.04182469f, 0.01884604f, 0.17926486f, 0.04562875f, 
    0.04009363f, 0.02571646f, -0.01667056f, -0.08816927f, -0.01415363f, -0.07247749f, -0.04690389f, 0.05691395f, 
    -0.09820712f, -0.02057984f, -0.05125871f, 0.07268793f, 0.09519610f, -0.02108414f, -0.13460881f, 0.01596753f, 
    -0.27203268f, -0.02421122f, 0.11273251f, 0.04099480f, 0.07550757f, 0.02025191f, 0.00316319f, 0.20065230f, 
    0.00502356f, -0.06062871f, 0.07124827f, 0.00868871f, 0.00571016f, 0.06685977f, -0.07673927f, 0.05278234f, 
    0.16764194f, 0.03469852f, -0.05107239f, -0.02484205f, -0.40429550f, 0.05070867f, 0.14321694f, 0.05503609f, 
    0.06304122f, -0.06804980f, -0.09045538f, -0.02964684f, 0.04975096f, -0.00132144f, 0.09120119f, 0.08243810f, 
    -0.03012474f, -0.01746750f, -0.02558947f, 0.01663755f, -0.04008660f, 0.15158087f, -0.01963837f, -0.10499752f, 
    0.17961414f, 0.21544451f, -0.01085203f, 0.04580618f, 0.00251230f, 0.14202861f, 0.01569382f, 0.07337862f, 
    -0.05586864f, 0.18185353f, 0.08783581f, 0.02596333f, -0.02899949f, 0.08213761f, -0.05146108f, 0.03576165f, 
    0.04374825f, -0.03335558f, 0.04845541f, 0.13670094f, 0.22705975f, 0.16442817f, 0.04610026f, -0.00478422f, 
    -0.02417887f, 0.01802259f, -0.02736551f, -0.03620183f, 0.05829472f, 0.06424338f, 0.08056478f, -0.00458358f, 
    0.03922535f, 0.07274343f, 0.08400553f, -0.02247991f, -0.01596182f, 0.18218450f, 0.07623933f, 0.02542326f, 
    -0.37826443f, 0.00141790f, 0.08576433f, -0.20326565f, 0.16641416f, 0.04446176f, -0.05320286f, -0.12156826f, 
    0.03913917f, 0.07817880f, 0.10147322f, -0.03447569f, 0.20118511f, 0.04053915f, 0.04971079f, -0.00526577f, 
    -0.01807145f, 0.01448165f, -0.24910882f, -0.04908337f, -0.36409277f, -0.06010612f, -0.00112063f, -0.18926920f, 
    0.18472041f, 0.13553692f, -0.01208660f, -0.03710151f, 0.13141400f, -0.14436543f, 0.05895060f, 0.07818303f, 
    0.10504850f, 0.02995372f, 0.05679512f, -0.04127160f, 0.06110286f, 0.00321084f, -0.26884931f, 0.02011933f, 
    0.11433012f, 0.11322859f, 0.12440997f, 0.05106333f, 0.06176982f, -0.05791654f, -0.01094864f, 0.06963978f, 
    -0.07729884f, -0.00740225f, 0.04456849f, 0.12171528f, 0.02629274f, -0.02801046f, 0.03045665f, -0.09339462f, 
    0.12080283f, -0.16867146f, 0.09335670f, -0.11367961f, 0.09689713f, 0.12611023f, -0.11587004f, 0.28110501f, 
    -0.13911963f, 0.13068911f, 0.02438477f, -0.06498240f, -0.05308040f, -0.04807744f, -0.04724666f, 0.02026311f, 
    0.12276551f, 0.11654081f, 0.11608694f, -0.08644012f, -0.01879200f, -0.14130998f, 0.06910035f, -0.00485155f, 
    -0.06957923f, 0.24510984f, 0.37930357f, 0.25267106f, 0.06127400f, 0.01022198f, -0.10181236f, 0.07627825f, 
    0.02568380f, -0.01507027f, -0.03713644f, -0.09430697f, 0.07849101f, 0.08612051f, 0.00408612f, -0.05560309f, 
    -0.03164909f, -0.00352237f, -0.01363399f, -0.08007848f, -0.05136263f, 0.06003337f, -0.14886667f, -0.15613297f, 
    0.05358335f, 0.07740017f, 0.07330497f, 0.14601263f, 0.11736130f, 0.03553418f, 0.04408028f, 0.11247832f, 
    0.07903884f, 0.06572443f, 0.12841944f, -0.02008945f, 0.08350419f, 0.09962459f, -0.03927260f, 0.15878463f, 
    -0.37803882f, -0.12365223f, -0.12663922f, -0.01923523f, 0.02086108f, 0.10609992f, 0.01060725f, 0.07318769f, 
    0.10833536f, -0.04749262f, 0.10075250f, -0.00914462f, 0.05509923f, -0.01324688f, 0.06487598f, 0.01865174f, 
    -0.02782947f, -0.00000741f, 0.02677302f, 0.14053816f, 0.02624136f, -0.15129143f, 0.21343280f, 0.19817701f, 
    -0.04558907f, -0.20738633f, 0.02136540f, -0.10612471f, -0.03952457f, -0.03447252f, -0.03935282f, -0.07986560f, 
    0.01451487f, 0.11926441f, 0.04634660f, 0.09520015f, -0.05267274f, -0.02793925f, -0.04261930f, -0.03058730f, 
    0.03006016f, 0.16528589f, 0.12260903f, 0.06453126f, -0.06168222f, -0.05052314f, 0.03663543f, 0.13043746f, 
    0.04721193f, 0.04838835f, -0.07541744f, -0.04896095f, 0.05392247f, 0.05528516f, 0.11601587f, -0.01656992f, 
    0.04163620f, 0.06263550f, 0.03990547f, 0.04165733f, -0.06402939f, 0.00679964f, -0.13071807f, -0.02199649f, 
    0.11664122f, 0.05046999f, -0.02575019f, 0.01769529f, 0.02582426f, 0.00134235f, 0.08735919f, 0.04838175f, 
    0.03182520f, -0.06883041f, 0.03241203f, -0.06687177f, 0.10551912f, 0.11663778f, 0.00866995f, 0.06996124f, 
    -0.05275429f, -0.14815158f, -0.09729573f, 0.09469383f, 0.00695194f, -0.01622115f, 0.02802554f, 0.06598097f, 
    0.00981096f, -0.12646015f, 0.03961365f, -0.00107284f, 0.08351102f, 0.02385392f, -0.01919807f, 0.03027498f, 
    -0.00416141f, 0.04673494f, -0.01125146f, 0.15107176f, -0.09052645f, -0.12262795f, -0.14633510f, 0.00459800f, 
    0.04006081f, 0.15458623f, 0.04887314f, -0.13373061f, 0.02081691f, -0.00323687f, 0.08027803f, 0.08087176f, 
    -0.01286167f, -0.02397389f, 0.09492698f, 0.05220951f, 0.04617450f, -0.00152936f, -0.03443372f, 0.08871017f, 
    -0.09730903f, -0.12571795f, -0.16557300f, -0.04354896f, -0.23538163f, 0.04290001f, 0.05570597f, 0.04530500f, 
    -0.06027912f, 0.06061142f, 0.00623923f, -0.01160445f, 0.03282327f, 0.04955216f, -0.03406208f, 0.09056766f, 
    0.05505173f, 0.01060019f, -0.03749958f, 0.01339593f, -0.21351171f, 0.02303881f, -0.05182146f, 0.14108905f, 
    0.11837544f, -0.00841497f, 0.03662566f, 0.08522677f, -0.00013688f, 0.10021931f, 0.08835949f, 0.03743557f, 
    -0.00202740f, 0.08506112f, 0.04226137f, 0.03464571f, 0.01408341f, 0.00867081f, 0.06878459f, 0.04348686f, 
    0.08272869f, 0.21544567f, 0.18033114f, 0.14009586f, 0.09796976f, 0.00309111f, 0.04716647f, -0.00482481f, 
    0.04978143f, 0.01795269f, -0.02993690f, 0.00201389f, 0.12527093f, 0.05369866f, -0.01955131f, 0.10050935f, 
    0.06523836f, -0.00393823f, 0.13003576f, -0.01594094f, 0.16702339f, 0.00704656f, 0.01700380f, 0.07558264f, 
    0.03314139f, 0.01561009f, 0.02217634f, 0.06655807f, 0.02292920f, 0.03550275f, -0.02500189f, -0.06088685f, 
    -0.00257067f, 0.07076254f, -0.02369240f, -0.03831364f, 0.03599468f, 0.04190736f, 0.04690949f, 0.04269310f, 
    -0.13415286f, 0.01185901f, 0.10384788f, 0.10942440f, -0.13968714f, -0.01375202f, 0.08486605f, 0.06298052f, 
    0.01459143f, 0.11669838f, -0.07291135f, 0.00634459f, -0.05287156f, 0.01180895f, 0.08910946f, 0.05439355f, 
    0.03533258f, 0.02507927f, 0.08514193f, 0.02852223f, -0.17032284f, -0.04545229f, -0.07891794f, 0.10327376f, 
    0.05521081f, -0.03222242f, 0.06430249f, 0.05037879f, 0.03023458f, 0.01703367f, 0.07184394f, 0.05232037f, 
    0.02894949f, 0.11166677f, 0.07898805f, 0.02189846f, 0.02654636f, -0.03040325f, -0.01350534f, 0.06915098f, 
    -0.21456014f, -0.02132909f, -0.25014672f, -0.13109563f, -0.02097143f, 0.03781318f, -0.10084023f, 0.13655497f, 
    0.10215434f, 0.06800924f, -0.00160980f, 0.00225467f, -0.05937605f, 0.01164508f, -0.01204668f, 0.14607254f, 
    0.00566249f, 0.06249000f, -0.05248068f, 0.04140989f, 0.05626412f, 0.10264703f, -0.10760262f, 0.09288226f, 
    -0.10884447f, -0.00127024f, -0.09344853f, 0.01533077f, -0.00474866f, 0.02688763f, 0.03032139f, 0.08616240f, 
    0.07662553f, -0.04235601f, -0.08210261f, -0.01064006f, 0.01133476f, 0.13180725f, 0.02163813f, -0.02388271f, 
    0.15048529f, 0.18735471f, 0.03441142f, 0.24722670f, 0.03778908f, -0.05708379f, -0.14285125f, 0.04084755f, 
    0.08959094f, 0.03801568f, 0.05495288f, -0.06137510f, 0.07242143f, 0.04056030f, -0.03465410f, 0.11330058f, 
    0.03588303f, 0.04167944f, 0.05605550f, 0.05211979f, 0.06846938f, -0.13248603f, -0.04272014f, -0.03145817f, 
    -0.00636047f, 0.05875723f, 0.10279826f, -0.03223942f, 0.01120075f, -0.00429789f, 0.06224594f, 0.01350114f, 
    0.04185688f, -0.01298223f, 0.02768213f, 0.14630486f, 0.01581093f, 0.03497210f, -0.00655107f, -0.02206125f, 
    -0.18350738f, -0.07269426f, -0.26449880f, -0.08897620f, -0.13363244f, 0.03375982f, 0.05256120f, 0.10724375f, 
    -0.03430556f, 0.03961556f, 0.03400160f, 0.01723252f, 0.01392557f, 0.00848797f, 0.07265776f, 0.03099059f, 
    0.09769010f, 0.01533302f, 0.02031080f, 0.00627684f, 0.08055905f, 0.03424398f, 0.12719369f, 0.03065113f, 
    0.05737697f, 0.11564243f, -0.02539799f, 0.07725844f, -0.01092702f, -0.08469049f, -0.02589213f, 0.09196749f, 
    -0.03069086f, 0.02990426f, 0.06105239f, -0.02667804f, -0.01083698f, 0.06503203f, 0.01102759f, 0.02044822f, 
    -0.18162854f, -0.13176204f, -0.26141724f, -0.18445219f, -0.04367342f, 0.04428108f, 0.14529087f, -0.16092440f, 
    -0.00606390f, -0.01033704f, 0.08448310f, 0.08893768f, 0.05456175f, 0.04925306f, 0.15317184f, 0.17130582f, 
    0.13253962f, -0.02907193f, -0.07091747f, 0.07767127f, 0.32392392f, 0.19717935f, 0.07708533f, -0.04170540f, 
    0.27783799f, -0.05317172f, 0.08647338f, 0.03433998f, 0.13726549f, -0.03184921f, 0.03748677f, 0.01758374f, 
    0.08541436f, 0.04173533f, 0.02706129f, 0.11140832f, 0.03334331f, 0.10289732f, 0.08596136f, 0.12148201f, 
    -0.12820572f, -0.21993354f, -0.09479805f, -0.00792884f, 0.04645605f, 0.02835262f, -0.07640582f, 0.01080247f, 
    -0.04765755f, 0.02378074f, 0.03363432f, 0.00890823f, 0.06370756f, 0.08854149f, 0.02975529f, 0.08459038f, 
    -0.04881551f, -0.00404258f, 0.12474751f, 0.01386637f, -0.28863472f, 0.12318571f, -0.18277018f, 0.05393037f, 
    -0.04526721f, 0.00656617f, -0.07517819f, 0.14100751f, 0.04058192f, 0.07024823f, -0.01738576f, 0.01291493f, 
    -0.00077988f, 0.10290024f, -0.03131843f, -0.00931459f, 0.02737308f, -0.06053749f, -0.04333670f, 0.06772122f, 
    -0.18263139f, -0.03395980f, -0.30911013f, -0.19531304f, -0.08666646f, 0.03249922f, 0.06289264f, 0.06610461f, 
    0.07149597f, 0.03403563f, 0.03603028f, 0.06580480f, 0.01891280f, 0.02744672f, 0.04619063f, 0.07670589f, 
    0.07100166f, -0.03481374f, 0.07850329f, 0.05019034f, 0.07672892f, -0.02905350f, -0.00240371f, 0.03391802f, 
    -0.11723667f, 0.04286693f, 0.05929068f, 0.15794064f, -0.18729828f, -0.00213582f, 0.04652072f, 0.00215144f, 
    -0.10243981f, 0.11221823f, 0.13241997f, 0.01596132f, 0.06478053f, 0.06021504f, 0.03080723f, 0.04056903f, 
    0.09661891f, 0.01068438f, -0.06608381f, 0.19384381f, -0.01207557f, -0.09270751f, 0.03548926f, -0.01349819f, 
    -0.02380778f, 0.07798146f, -0.00725230f, -0.06037920f, -0.05508774f, 0.00459165f, -0.01602089f, -0.00670393f, 
    0.06069721f, -0.09799472f, -0.08870077f, -0.05559623f, 0.05939167f, 0.22560997f, 0.29920256f, 0.35008076f, 
    0.01519374f, -0.16203168f, 0.01469531f, 0.07975242f, 0.03660532f, 0.02519693f, -0.02214106f, 0.00479533f, 
    -0.01549657f, -0.06387573f, 0.03496722f, -0.01718130f, 0.00487383f, -0.01452147f, 0.08376427f, -0.02096567f, 
    0.08840672f, -0.14443618f, 0.08395035f, -0.07747367f, -0.13406095f, 0.14990257f, 0.02887388f, 0.09616496f, 
    0.05055448f, 0.06648245f, 0.04805841f, -0.03151232f, 0.02008577f, 0.06341244f, -0.01469773f, 0.12379050f, 
    0.03013140f, 0.11360765f, 0.13604426f, 0.11289375f, -0.17534490f, -0.20416500f, -0.06588940f, 0.07813521f, 
    0.01237720f, 0.00515967f, -0.00641457f, 0.08365572f, 0.07493228f, 0.04473905f, 0.09264393f, 0.01815979f, 
    0.02562085f, 0.04733767f, 0.01771690f, -0.00934163f, -0.03740822f, 0.00531725f, 0.05011225f, -0.06702539f, 
    -0.16073836f, -0.03171928f, -0.16048631f, -0.08958855f, 0.03891004f, 0.02175829f, 0.11724513f, 0.00988430f, 
    -0.03259326f, 0.05223703f, 0.15469626f, 0.15457323f, 0.11604508f, 0.04729823f, 0.09734938f, 0.03389711f, 
    0.10933311f, -0.03779788f, 0.08001445f, 0.10620027f, 0.08079226f, 0.06341536f, 0.15222773f, 0.27900946f, 
    -0.05372147f, 0.00175188f, 0.07836001f, 0.12575115f, 0.01128976f, 0.02453691f, -0.03917939f, -0.13454078f, 
    -0.00700248f, 0.06164541f, 0.04191175f, -0.00278410f, 0.01616877f, -0.03507851f, 0.01453482f, 0.03947089f, 
    -0.28917357f, -0.07488032f, 0.15986507f, 0.02762830f, -0.12686510f, -0.09094319f, -0.05991563f, 0.02188111f, 
    0.00803493f, -0.01094173f, -0.08698002f, -0.05778631f, 0.00596979f, -0.00137413f, 0.11974593f, -0.13860951f, 
    -0.07980423f, 0.03087794f, -0.00991824f, -0.01329377f, -0.00058289f, 0.14811374f, 0.09362358f, 0.12914328f, 
    0.11381103f, 0.00573942f, 0.02066889f, 0.05619061f, -0.02434840f, 0.03164126f, 0.03470586f, 0.07027123f, 
    -0.03228894f, 0.03962214f, -0.04065732f, 0.10378014f, 0.02171013f, 0.08189624f, -0.10542014f, -0.00233972f, 
    -0.11733093f, 0.12600686f, 0.17827113f, -0.09716075f, 0.00583461f, 0.04289873f, 0.04633407f, -0.01177846f, 
    -0.00524121f, 0.02277310f, 0.00494099f, 0.12702002f, -0.07120234f, 0.09834274f, 0.01089204f, -0.00706687f, 
    0.07869414f, 0.07733963f, 0.13259561f, -0.01918613f, 0.03763613f, -0.11551233f, 0.24068579f, -0.01973992f, 
    0.06263819f, -0.13647915f, -0.08173318f, 0.01346100f, -0.00581844f, 0.06889421f, 0.00805512f, -0.08636832f, 
    0.02007866f, -0.08796986f, 0.09913044f, 0.02371015f, 0.02429990f, 0.03479910f, -0.05552442f, -0.02666651f, 
    0.02929938f, 0.03188632f, 0.13070744f, 0.03754920f, 0.12356501f, -0.02726557f, -0.10087045f, 0.01717542f, 
    0.05687956f, -0.01797791f, -0.09629633f, 0.01132919f, -0.04980352f, -0.00161529f, 0.02944707f, -0.07177461f, 
    0.05552132f, -0.00725133f, 0.07954115f, 0.00112954f, 0.28092676f, -0.08831366f, 0.04213271f, 0.06244174f, 
    -0.14948419f, -0.08588112f, -0.03966980f, -0.05919135f, -0.06330609f, -0.05600662f, 0.06075354f, -0.11020610f, 
    0.06578758f, -0.06412964f, 0.05745499f, -0.02396436f, -0.05999164f, -0.00774183f, -0.11239512f, -0.02920895f, 
    0.21219701f, -0.03648239f, 0.06208758f, -0.07751087f, -0.10643610f, 0.00975244f, 0.10518157f, 0.08948568f, 
    -0.02409111f, -0.02876506f, 0.06164003f, 0.05395453f, 0.11592644f, 0.02592500f, -0.06291482f, 0.01022888f, 
    -0.00888908f, -0.12680148f, 0.11261136f, -0.05475185f, -0.19911908f, 0.13259652f, -0.00831799f, -0.00247991f, 
    0.07460763f, 0.09120149f, 0.01962170f, -0.04574300f, 0.07584997f, -0.08961035f, 0.08562867f, 0.09087488f, 
    0.06896558f, 0.04068273f, 0.05786607f, 0.11459310f, 0.08482987f, 0.10922704f, -0.00429202f, 0.01767564f, 
    0.05310502f, 0.16894177f, 0.17833419f, 0.03702943f, -0.19072525f, 0.13174979f, 0.01739415f, 0.09745096f, 
    0.04173208f, -0.02246205f, 0.08637458f, -0.10295379f, 0.02473693f, 0.05884268f, -0.10306527f, 0.11681431f, 
    0.15533499f, -0.01588471f, 0.04644803f, -0.03551439f, -0.11034682f, -0.03919147f, 0.10170709f, 0.08009891f, 
    0.06682279f, 0.02365201f, -0.10211926f, -0.03392189f, -0.00483942f, 0.04007027f, 0.02143598f, 0.00118048f, 
    -0.11565866f, 0.01147694f, -0.03855321f, -0.02633174f, -0.03573557f, 0.04743996f, 0.10301346f, 0.00795081f, 
    -0.05041760f, -0.09833165f, 0.06526748f, -0.05204772f, 0.00394969f, -0.06498221f, -0.11391135f, -0.03608911f, 
    -0.07922036f, -0.08918532f, -0.02250505f, -0.14034288f, 0.18053834f, -0.02111115f, 0.10184110f, 0.06477147f, 
    0.15096217f, -0.16140300f, 0.02189481f, 0.02999178f, -0.12404800f, -0.04748895f, 0.01607905f, 0.12998563f, 
    0.15129499f, -0.09607451f, -0.07521981f, 0.00311436f, 0.06100281f, 0.01021845f, -0.06265952f, 0.04599765f, 
    0.04697571f, -0.03818578f, 0.08027419f, 0.00625066f, 0.05935565f, 0.04102953f, 0.11807369f, -0.07566778f, 
    0.03460594f, 0.06648993f, 0.00163962f, 0.18571904f, -0.10516385f, -0.10898501f, 0.05895613f, 0.02388937f, 
    -0.04771819f, 0.06451439f, -0.11768375f, 0.04006242f, 0.05442175f, -0.05775433f, 0.00688272f, -0.00824749f, 
    -0.06911413f, 0.03644669f, 0.09598117f, -0.08803014f, -0.10769706f, -0.13616581f, -0.06125909f, 0.21008484f, 
    0.05996786f, 0.02609378f, -0.06817573f, -0.02614219f, -0.05019376f, 0.04859600f, -0.06614469f, -0.00748508f, 
    -0.02963490f, -0.05328321f, 0.08598857f, 0.04880472f, 0.06595416f, 0.08165430f, 0.05106633f, 0.08454367f, 
    -0.09369008f, 0.05096477f, -0.05662349f, 0.02698915f, -0.07570488f, -0.01554655f, 0.12364759f, 0.07826187f, 
    0.01978632f, -0.04320557f, -0.06223695f, 0.02181186f, 0.01653062f, -0.07636356f, -0.05326455f, 0.09857555f, 
    -0.01548474f, -0.07705289f, 0.07881349f, 0.11166582f, 0.12481417f, -0.01240260f, -0.00656163f, 0.02216093f, 
    -0.19514550f, -0.09523816f, -0.07424144f, -0.02683578f, -0.10987802f, -0.06761874f, -0.01548057f, 0.09680056f, 
    0.06838685f, 0.07982648f, -0.02256404f, -0.09862630f, 0.00554545f, 0.03905390f, -0.08518355f, 0.05211696f, 
    -0.17031878f, -0.03283622f, 0.06100447f, -0.01738362f, 0.04470796f, -0.03362529f, -0.15709755f, 0.07208957f, 
    0.00095944f, 0.06659821f, -0.02506123f, -0.00176294f, 0.00842283f, -0.05671411f, 0.09550516f, 0.14846909f, 
    -0.04713153f, -0.14728045f, -0.02572498f, 0.06203415f, 0.14531872f, 0.11600091f, -0.08302614f, -0.10084223f, 
    -0.07695714f, -0.04525662f, 0.05939000f, 0.01888770f, -0.05856787f, -0.02997924f, -0.06413899f, 0.08802126f, 
    0.08286237f, -0.03655768f, 0.05314393f, 0.07993259f, 0.05169018f, 0.03815114f, 0.04931587f, 0.07952718f, 
    0.29809800f, 0.04523923f, -0.03364581f, -0.11458548f, -0.17377171f, 0.04422784f, -0.07505580f, -0.07118767f, 
    0.09998249f, -0.06006411f, 0.07832617f, 0.02264795f, -0.07186074f, 0.05016609f, 0.05596193f, 0.04778681f, 
    0.09418275f, 0.00415273f, 0.07002592f, -0.02385209f, 0.11191665f, 0.02100915f, 0.26067534f, 0.10763440f, 
    -0.04352901f, 0.12889631f, -0.07581752f, -0.00843126f, 0.03640696f, -0.02057268f, 0.05119402f, 0.08683725f, 
    -0.06882611f, 0.00832883f, 0.03838195f, 0.02998702f, -0.07911927f, 0.10432462f, -0.02863435f, -0.02751465f, 
    -0.08047707f, 0.14954941f, -0.09346353f, -0.04296007f, 0.09697043f, -0.05695061f, 0.00446419f, -0.05235901f, 
    -0.00985891f, -0.15999605f, 0.07881559f, 0.01909819f, 0.00445741f, 0.09213831f, 0.05539791f, 0.07812823f, 
    0.07568834f, 0.04464871f, -0.03175531f, 0.06414876f, 0.10453475f, -0.06932480f, 0.03967706f, -0.00176305f, 
    0.12276573f, -0.02851135f, -0.04029054f, -0.01090247f, 0.15589792f, -0.01269047f, -0.14481819f, 0.00808506f, 
    -0.09014473f, 0.07160375f, 0.07779334f, 0.17423467f, -0.05041506f, 0.02641567f, 0.01090444f, 0.00649490f, 
    0.04276909f, -0.22570586f, 0.11016747f, 0.01620153f, 0.05171365f, 0.04943909f, -0.03944534f, -0.00349696f, 
    -0.10610344f, 0.09495579f, -0.04970772f, 0.03464037f, 0.07199230f, 0.01280253f, -0.11214523f, -0.02372693f, 
    -0.09690606f, -0.02403854f, 0.07569357f, -0.07445955f, -0.23761365f, 0.16602308f, -0.11065260f, 0.02115050f, 
    -0.04361929f, -0.05644161f, 0.04723484f, 0.07085723f, 0.09866733f, 0.04380589f, 0.07031440f, -0.03465463f, 
    0.03550497f, 0.13370736f, 0.09548479f, 0.06085774f, -0.00768672f, -0.02290424f, 0.01076898f, 0.01107630f, 
    0.06878826f, 0.00363751f, -0.09694603f, -0.16589536f, -0.09121502f, 0.04030865f, 0.07189491f, -0.09355339f, 
    0.05039602f, 0.00564289f, -0.03031028f, 0.09773887f, -0.04542811f, 0.00896102f, -0.01502065f, 0.00750436f, 
    -0.07293393f, 0.06497363f, 0.06738465f, -0.00024177f, 0.25720620f, -0.03365399f, -0.07733987f, 0.16228710f, 
    -0.13130546f, 0.07949183f, 0.09763149f, 0.09814341f, -0.05766341f, -0.02879014f, -0.03667263f, 0.00751245f, 
    0.05308493f, 0.02282028f, -0.00807498f, -0.00536127f, 0.00269647f, -0.00216379f, 0.03280946f, 0.05228136f, 
    -0.18739237f, -0.03543868f, -0.03834569f, 0.03769591f, 0.14619295f, -0.17690036f, 0.04863570f, -0.03115095f, 
    0.09937833f, -0.00467015f, 0.04646083f, 0.10581723f, 0.08699811f, 0.02253308f, 0.09471685f, 0.00929348f, 
    0.02778506f, 0.02712654f, 0.04837731f, -0.07375372f, -0.24605834f, -0.11047613f, 0.01297485f, 0.00404165f, 
    -0.03366409f, 0.04576726f, -0.03894426f, 0.03277748f, -0.03285541f, 0.01049112f, -0.08646544f, -0.02859987f, 
    -0.02615242f, -0.04116963f, 0.00644988f, 0.03014761f, -0.00572336f, -0.05122237f, -0.01011153f, 0.03794802f, 
    0.28480762f, -0.01807340f, -0.08637656f, 0.28920543f, -0.09750298f, -0.06554992f, -0.03836226f, 0.07931660f, 
    0.00244963f, 0.02348241f, -0.04432733f, -0.00521359f, -0.02691770f, -0.01406759f, -0.04289242f, 0.00881938f, 
    0.00012363f, 0.05741469f, 0.06834141f, 0.06055795f, 0.30286461f, -0.03485233f, 0.03084573f, 0.17829005f, 
    -0.15061158f, -0.07458980f, 0.03183443f, 0.03121395f, -0.05854810f, 0.13979602f, -0.05023987f, -0.10662303f, 
    -0.01674563f, -0.00355436f, 0.00853228f, 0.03990035f, -0.04650818f, -0.01893200f, 0.05252513f, 0.01143137f, 
    -0.15818015f, -0.00465388f, -0.09912243f, -0.02211502f, 0.00934515f, 0.02715614f, 0.08711742f, -0.03464299f, 
    -0.03727793f, 0.05485271f, 0.00852923f, 0.02670757f, -0.00791281f, -0.00114999f, 0.02258645f, 0.02633326f, 
    -0.01555446f, 0.00347083f, -0.06980418f, 0.00245028f, -0.16445430f, -0.09432387f, 0.09976549f, -0.18427721f, 
    0.21354933f, -0.09381256f, -0.01298832f, 0.04297259f, 0.05310261f, -0.00775295f, -0.00029275f, -0.05075297f, 
    -0.04575265f, 0.02771582f, -0.05751575f, 0.06938272f, -0.08249917f, 0.10966501f, 0.04289888f, 0.02233868f, 
    -0.46794009f, -0.05893864f, -0.11699879f, -0.05263069f, 0.10455228f, -0.03997566f, -0.02510886f, -0.00311318f, 
    0.01279172f, 0.15177211f, 0.09027188f, 0.16431823f, 0.08752426f, 0.06117328f, 0.12984663f, 0.12762654f, 
    0.07335334f, 0.03183421f, 0.06717061f, 0.15270641f, 0.02244025f, -0.12786546f, 0.10937958f, 0.13362634f, 
    -0.18102948f, 0.13082741f, -0.02315658f, 0.08507388f, -0.02200445f, -0.08242391f, 0.09662879f, 0.02192839f, 
    0.03457309f, 0.09571972f, 0.09781783f, -0.05588954f, -0.00830509f, -0.04436443f, 0.16445373f, 0.12291829f, 
    -0.26969105f, 0.08623102f, -0.11370088f, -0.00370330f, -0.03621911f, 0.04102593f, 0.00173977f, 0.06200397f, 
    0.05507919f, -0.03241495f, 0.09877449f, -0.02645587f, -0.06714920f, -0.02163571f, 0.01172307f, -0.02203681f, 
    0.00662642f, -0.03809296f, -0.07866830f, -0.06698474f, 0.05085530f, -0.14867771f, 0.00707678f, 0.21896085f, 
    0.00756913f, -0.10180796f, -0.05395949f, 0.08432339f, -0.10819519f, -0.05150261f, 0.01011610f, 0.02399910f, 
    -0.01932339f, 0.07630275f, 0.12740786f, 0.01863808f, 0.10585330f, -0.00834492f, 0.01541621f, 0.13481614f, 
    0.09941832f, 0.00400021f, 0.42554659f, 0.11931670f, -0.03420863f, 0.00144176f, 0.01939280f, -0.01760222f, 
    -0.00525275f, 0.06005444f, 0.05997213f, 0.03504095f, 0.09418672f, 0.08989828f, 0.12674725f, 0.03938907f, 
    -0.04298469f, 0.01490770f, -0.02921952f, -0.02103910f, -0.34743565f, -0.00546368f, -0.23299465f, 0.06959348f, 
    0.01301878f, 0.24951451f, 0.06603554f, -0.04004184f, -0.05700735f, 0.10389733f, -0.01793405f, 0.11649813f, 
    -0.02690122f, -0.00778330f, -0.05431028f, 0.05849072f, 0.09033269f, -0.03990630f, 0.01038558f, 0.13987820f, 
    0.00321086f, 0.03641656f, 0.10681853f, -0.08678191f, 0.16762885f, 0.15997589f, 0.10070093f, 0.05326533f, 
    0.02663014f, 0.16218714f, 0.04370533f, -0.01974239f, -0.03755337f, 0.04925238f, -0.05507709f, 0.14874128f, 
    0.07362496f, 0.07231177f, -0.11680944f, 0.04427048f, -0.05281247f, 0.10877823f, 0.07703833f, 0.05265201f, 
    -0.09276673f, 0.08022213f, 0.01649933f, 0.16632324f, 0.00509281f, -0.03679150f, 0.04752555f, 0.06921868f, 
    0.06883327f, 0.00540807f, 0.16587144f, -0.04732684f, 0.02020008f, 0.06809020f, 0.02261098f, -0.03462720f, 
    -0.24243075f, 0.12556121f, -0.21449740f, -0.05917998f, 0.09883972f, 0.00130350f, -0.03512968f, -0.10079835f, 
    0.11254184f, 0.04398276f, -0.02199340f, 0.00654068f, -0.15116057f, -0.07821811f, 0.01949347f, 0.00465273f, 
    -0.00576507f, 0.03129907f, -0.01315071f, 0.00671713f, 0.20934093f, 0.03913753f, -0.05233599f, 0.06691564f, 
    -0.12591948f, 0.07073430f, 0.16397759f, 0.01876929f, 0.05724729f, 0.00092269f, 0.08683258f, 0.09696158f, 
    0.13383898f, 0.12684071f, 0.03522330f, 0.01316004f, 0.07760705f, -0.08141202f, 0.00697564f, 0.11002964f, 
    0.11658490f, 0.15927801f, -0.04242403f, -0.18279520f, 0.00272192f, 0.05534235f, 0.14567478f, -0.02418486f, 
    0.04968595f, 0.15823534f, 0.12737092f, -0.00495345f, -0.00002535f, 0.01143793f, 0.18176720f, -0.05867520f, 
    -0.01222033f, 0.13104683f, 0.13423951f, 0.14337721f, -0.18111882f, -0.11736952f, 0.24145496f, -0.13575087f, 
    -0.06638633f, 0.21817210f, 0.05565169f, 0.11492783f, -0.09568322f, -0.03008515f, 0.25405860f, -0.02996040f, 
    0.00952591f, 0.04634075f, 0.06731839f, -0.02247864f, 0.06755665f, -0.06494347f, 0.06480447f, 0.07422485f, 
    0.05245717f, 0.03986667f, 0.37526843f, 0.22065127f, -0.02383542f, -0.06866144f, 0.01840699f, 0.02666791f, 
    -0.02228346f, 0.02944047f, 0.04946450f, 0.07197139f, 0.14579055f, 0.09252051f, 0.15609179f, 0.07617780f, 
    0.00884668f, 0.04204657f, -0.07807956f, 0.06338327f, 0.31147283f, -0.00929751f, -0.01159534f, -0.12288941f, 
    -0.13865575f, 0.12499578f, 0.01189356f, 0.12775068f, 0.11975678f, -0.05826607f, 0.17412342f, 0.03797263f, 
    0.07141946f, 0.09596388f, -0.06420711f, 0.00618358f, 0.06719239f, 0.06006539f, 0.06434918f, 0.22771567f, 
    -0.40741554f, -0.10247313f, -0.20288362f, -0.01700681f, 0.03633643f, -0.02320734f, 0.05312246f, -0.11444525f, 
    0.11331850f, -0.10121348f, 0.01654132f, 0.01278586f, -0.07396785f, 0.05087923f, -0.01412829f, -0.09299310f, 
    0.11316009f, 0.06218863f, 0.03866492f, -0.00949420f, -0.53777063f, 0.24747492f, -0.11907580f, -0.14478078f, 
    -0.14608186f, 0.31138253f, -0.00590070f, -0.06463024f, 0.20297354f, 0.02148603f, 0.01468977f, 0.04195105f, 
    0.00745407f, -0.04168729f, 0.09588906f, 0.21462165f, 0.00110508f, 0.04344446f, 0.08135458f, 0.08344283f, 
    0.14056057f, 0.13983187f, -0.06827768f, -0.13306916f, 0.00934734f, 0.05358540f, 0.06643134f, -0.06454477f, 
    -0.04971417f, 0.10252881f, -0.02175177f, 0.09692749f, 0.09893558f, 0.03177312f, 0.03424488f, -0.15530394f, 
    0.11226133f, 0.08752200f, 0.07765298f, 0.10682502f, -0.19240493f, 0.32057264f, -0.00626298f, 0.12635536f, 
    0.10602544f, 0.17160970f, 0.03219750f, 0.15163878f, 0.07574002f, 0.08361258f, 0.03721742f, 0.05377491f, 
    0.10004775f, 0.08174072f, -0.04004906f, 0.09410968f, -0.00825910f, 0.04612309f, 0.10074669f, 0.00042989f, 
    -0.30276862f, 0.25379801f, -0.21233810f, 0.00143145f, 0.21621668f, -0.07148615f, 0.05933981f, 0.12243164f, 
    0.06033996f, 0.02323982f, 0.02584108f, 0.04147233f, 0.04642149f, -0.01698307f, 0.00131075f, 0.04552984f, 
    0.06918764f, -0.02103720f, -0.01284644f, -0.01860762f, -0.44581112f, 0.43529889f, -0.12071396f, 0.10229728f, 
    0.04635319f, -0.08499610f, 0.07293543f, -0.03524169f, 0.03962194f, 0.05880776f, 0.09580804f, 0.10094492f, 
    0.10637697f, 0.03059182f, 0.16440693f, -0.00933982f, 0.01957029f, 0.00613695f, -0.00317011f, -0.06038222f, 
    -0.16594383f, -0.05182782f, -0.14422183f, 0.10542064f, -0.12712568f, -0.04075029f, -0.05886198f, 0.05760689f, 
    0.04592021f, 0.04598230f, 0.09290075f, -0.01250243f, 0.03402920f, 0.00322913f, 0.07095537f, -0.02503614f, 
    -0.02995170f, 0.02176478f, 0.03455685f, -0.06566681f, -0.27336922f, 0.03052402f, 0.50438279f, -0.01193461f, 
    -0.21919747f, 0.21536095f, -0.00369894f, 0.12500024f, -0.01722454f, 0.01061321f, 0.20059694f, -0.00861409f, 
    0.10085125f, 0.19083090f, 0.01070624f, -0.13548627f, 0.08802426f, 0.09352182f, 0.00209970f, -0.06591312f, 
    -0.14751182f, -0.12425464f, -0.12877588f, 0.31406993f, -0.11535414f, 0.03082122f, 0.00613825f, 0.03224635f, 
    0.04917346f, -0.11979026f, 0.09799466f, 0.07462411f, 0.09436882f, 0.03069357f, 0.06037560f, -0.06771753f, 
    0.06459281f, -0.04405592f, 0.09802089f, 0.04117479f, 0.03990555f, -0.06320795f, -0.11860972f, 0.11054971f, 
    -0.09735955f, 0.07583167f, 0.02761223f, 0.06968149f, 0.11141931f, -0.10377967f, 0.08756155f, -0.00056413f, 
    -0.03590579f, 0.08615079f, -0.02626444f, -0.01781831f, -0.00346489f, 0.10093049f, -0.04797170f, 0.05703785f, 
    -0.35065895f, 0.06986506f, -0.20241596f, -0.09134160f, 0.10264295f, 0.06619630f, 0.03848265f, 0.05785936f, 
    0.17961501f, 0.03127005f, 0.02279579f, 0.01260477f, 0.01248925f, 0.01987440f, -0.05942878f, 0.02002958f, 
    0.07040773f, 0.01807714f, 0.00469528f, 0.06449919f, -0.25033098f, 0.15089484f, 0.08663274f, -0.01814293f, 
    -0.12973581f, 0.11821722f, 0.06656773f, -0.06233203f, 0.12698908f, -0.15651190f, 0.12265540f, 0.00976715f, 
    -0.02082573f, 0.06267077f, -0.06320971f, -0.08174180f, 0.10104356f, 0.01286665f, -0.07390144f, -0.04859086f, 
    -0.08564055f, -0.13251586f, 0.02730953f, -0.15170285f, 0.13007572f, 0.23519263f, 0.06412439f, 0.11079112f, 
    0.10040964f, 0.09633549f, 0.15090238f, -0.08209021f, -0.08009429f, -0.03108938f, 0.02683365f, 0.14714210f, 
    0.03383197f, 0.06300195f, 0.09947005f, 0.13849348f, -0.03579166f, -0.08598449f, 0.30559134f, 0.07555598f, 
    0.17047414f, 0.03643401f, 0.05113943f, -0.07044592f, -0.06313075f, 0.09299465f, 0.12952507f, 0.10422193f, 
    0.06665827f, 0.16878398f, 0.11453322f, -0.01647385f, 0.04959006f, 0.07391532f, 0.01579600f, 0.08618153f, 
    -0.01184493f, 0.10618795f, 0.08848940f, 0.03217589f, 0.03540629f, 0.04332604f, 0.13429227f, -0.12743482f, 
    -0.05831607f, -0.00930084f, 0.12956154f, 0.09712436f, 0.08532907f, 0.03463664f, 0.08551582f, 0.02023369f, 
    0.11859465f, 0.00070183f, -0.08441920f, 0.03106883f, -0.39179817f, -0.19749655f, -0.02165945f, 0.04980069f, 
    -0.10042582f, 0.24813181f, 0.11796436f, 0.05172713f, -0.04320211f, -0.09135803f, 0.06319121f, -0.00623154f, 
    0.11765352f, -0.00679391f, 0.00909872f, 0.02839172f, 0.09839666f, 0.11879987f, -0.01523405f, 0.09913993f, 
    -0.03698640f, -0.06625861f, -0.08342637f, 0.26963374f, -0.29028496f, 0.01380288f, -0.07082148f, 0.04886949f, 
    0.06000474f, -0.01759041f, 0.12212749f, 0.02652792f, 0.05210710f, 0.03873770f, 0.02284592f, -0.02090506f, 
    -0.02773061f, 0.04005085f, 0.09085423f, 0.03104796f, 0.04336728f, -0.23245944f, 0.29109213f, 0.19986001f, 
    0.08965337f, -0.01581643f, -0.04645208f, 0.00212841f, -0.14104305f, 0.07582054f, 0.10052759f, 0.07631902f, 
    0.08321968f, 0.03649954f, 0.15188825f, -0.02355591f, 0.19608311f, -0.02468035f, 0.02118533f, -0.00532014f, 
    0.50656122f, 0.43194827f, 0.05455590f, 0.23049898f, 0.15304483f, 0.11195441f, 0.04909672f, 0.10235094f, 
    0.00561310f, -0.01003106f, 0.06177825f, 0.08957060f, -0.02919083f, -0.00272245f, 0.04002580f, 0.09501016f, 
    -0.01043360f, -0.04598484f, -0.04771654f, -0.08741087f, 0.12729472f, -0.19733219f, -0.20069438f, -0.13925844f, 
    -0.00196322f, -0.06159843f, -0.04750134f, -0.00878781f, 0.06655768f, -0.02931694f, 0.00480359f, 0.02240557f, 
    0.03131285f, -0.02388940f, -0.01268629f, -0.13035290f, 0.09471378f, 0.01049733f, 0.00256421f, 0.01593270f, 
    0.14060849f, -0.12740219f, -0.00136818f, -0.01748052f, 0.05449998f, 0.08425588f, -0.01441893f, 0.10215960f, 
    0.03329202f, -0.17503473f, -0.02141987f, -0.06799723f, 0.12570089f, -0.03659524f, 0.03279748f, 0.06035472f, 
    -0.04876728f, -0.00237418f, 0.01391664f, 0.12475295f, -0.01465014f, 0.39671403f, -0.07517502f, 0.10230262f, 
    -0.03917923f, 0.15125069f, 0.17454395f, -0.07094193f, -0.00202358f, 0.01047213f, 0.01154043f, 0.13717377f, 
    0.00316107f, 0.02517711f, -0.12187316f, 0.04729743f, 0.00520750f, -0.11431608f, 0.08543604f, 0.07314058f, 
    0.00654449f, 0.19872747f, -0.24555598f, 0.06047318f, -0.02924710f, 0.09244408f, 0.11678565f, 0.04232152f, 
    0.08910756f, -0.07749307f, 0.07640896f, -0.01660464f, 0.10759056f, 0.03684687f, -0.00764936f, 0.07149658f, 
    0.01531373f, 0.10270789f, 0.03949777f, 0.07488155f, -0.01954491f, 0.21195947f, 0.04198062f, -0.17648418f, 
    0.08070135f, 0.01759243f, -0.02587130f, 0.12786005f, 0.03457383f, 0.00148196f, 0.01574221f, 0.11018091f, 
    -0.02485380f, 0.06264615f, 0.01948210f, 0.00393203f, 0.02694773f, 0.06158913f, 0.18021911f, -0.06132920f, 
    -0.23400803f, -0.02137408f, -0.13025758f, 0.12706280f, 0.09687126f, -0.00895775f, -0.00286978f, 0.02555891f, 
    0.07966972f, -0.09264602f, -0.00327362f, 0.04413600f, -0.01934203f, 0.01331567f, 0.13613294f, 0.05770402f, 
    -0.09527433f, 0.04528647f, -0.12584285f, 0.04346198f, 0.19663037f, -0.37454876f, -0.00398611f, -0.02679599f, 
    0.07388788f, 0.00055219f, 0.03055233f, 0.05643374f, 0.04822889f, 0.13232587f, -0.00378519f, -0.01355521f, 
    0.00272579f, -0.02060990f, -0.01124715f, 0.02049235f, -0.00016874f, -0.07780655f, -0.11691236f, 0.03689449f, 
    -0.07124945f, -0.15692441f, -0.16670290f, 0.01041576f, -0.02255306f, -0.13440721f, 0.07803844f, 0.03942205f, 
    0.07346992f, 0.02393827f, -0.03378180f, 0.05229591f, 0.07486474f, 0.06454612f, 0.08714971f, 0.03884577f, 
    -0.08457923f, 0.01045596f, -0.02956113f, 0.02295837f, -0.07928012f, 0.06761217f, -0.04901249f, -0.20495464f, 
    0.04354869f, -0.00983634f, 0.01962826f, -0.05869677f, -0.09839170f, -0.03498844f, -0.00792922f, -0.00349905f, 
    0.08591805f, 0.03560477f, -0.07603800f, 0.04399313f, -0.02737034f, 0.07462484f, -0.01737878f, 0.03482489f, 
    -0.12023836f, 0.25141931f, 0.03391704f, 0.14267899f, 0.09296153f, 0.12294707f, 0.08031823f, 0.13789102f, 
    0.05109065f, 0.11213229f, 0.07729969f, 0.12278217f, -0.04124550f, 0.01561971f, -0.00486594f, -0.02601347f, 
    0.00278859f, 0.07961944f, 0.02802519f, -0.06251161f, 0.23024869f, 0.03000114f, 0.00641620f, -0.01348025f, 
    0.03350631f, 0.05604947f, 0.06920964f, 0.06169267f, -0.00195646f, -0.05186923f, -0.00271782f, -0.05654242f, 
    -0.03392240f, 0.00219669f, -0.08643564f, 0.08108495f, -0.05807124f, 0.08806083f, -0.13508412f, 0.11656993f, 
    0.09765334f, -0.01052264f, -0.13893519f, -0.04586604f, 0.27301168f, 0.12313680f, -0.01341422f, -0.01244058f, 
    0.07643625f, -0.04144654f, 0.03706291f, -0.08434799f, -0.08515650f, 0.03096222f, 0.08343219f, 0.06845832f, 
    0.06965285f, -0.01099098f, -0.01509303f, 0.06087663f, -0.05016324f, 0.00316472f, 0.01817262f, -0.25240684f, 
    -0.00876079f, -0.04649853f, 0.06051080f, -0.05188204f, -0.08474839f, -0.00866864f, 0.03628759f, 0.04738065f, 
    -0.00569943f, 0.08969946f, 0.01845991f, 0.01250475f, -0.14611939f, 0.08064339f, 0.03638114f, -0.08563286f, 
    0.04288236f, 0.22975540f, -0.06800851f, -0.22185729f, 0.06538235f, 0.04205424f, -0.16639636f, 0.08775006f, 
    -0.03716068f, 0.08748250f, 0.04559048f, -0.06902746f, 0.04058115f, 0.07502046f, 0.09032146f, 0.02373239f, 
    0.05099843f, 0.09068682f, 0.02705854f, -0.02715462f, 0.04782046f, 0.14057095f, 0.03019588f, 0.14353761f, 
    0.23409416f, -0.01912910f, 0.07740465f, -0.01675942f, 0.04778128f, 0.02379717f, 0.03440272f, -0.06072127f, 
    0.07960545f, -0.06886139f, 0.02279627f, 0.04434055f, -0.07077200f, 0.06830175f, 0.00693141f, -0.10022473f, 
    0.19819196f, -0.00853471f, 0.00005339f, 0.10155298f, -0.10994234f, -0.00207611f, 0.07615559f, -0.00757079f, 
    0.11274143f, -0.02051987f, 0.06984442f, 0.03293979f, 0.07207382f, 0.01971304f, 0.03056872f, 0.03595383f, 
    -0.03133852f, 0.03330652f, 0.00534843f, -0.05064749f, -0.13392456f, -0.26017642f, 0.19543570f, -0.02812041f, 
    0.17111683f, -0.00085639f, 0.00724059f, 0.00733192f, 0.07260596f, 0.05638407f, 0.00486797f, 0.01669768f, 
    -0.07405454f, -0.01684512f, -0.01772918f, -0.02181529f, 0.00198771f, -0.06720417f, -0.08607420f, -0.02139733f, 
    -0.26813981f, -0.15572923f, 0.00773786f, -0.08137006f, 0.05850318f, 0.06241613f, 0.00606929f, 0.11349916f, 
    -0.01308252f, 0.08752607f, 0.02184282f, 0.05536292f, 0.04692310f, 0.05927590f, 0.01840349f, -0.09303097f, 
    0.02043440f, -0.01505027f, -0.10247358f, 0.02937786f, 0.31740376f, -0.04145028f, -0.00945632f, 0.13424194f, 
    -0.13409755f, -0.02014887f, 0.04636690f, 0.03075460f, -0.07522720f, -0.04893711f, -0.03585790f, 0.07881449f, 
    -0.00097898f, 0.09510342f, 0.05747650f, -0.02599379f, 0.10521692f, 0.02477047f, 0.09213658f, 0.01331204f, 
    0.15401480f, -0.20758967f, 0.13883552f, -0.14202300f, 0.15169856f, 0.10088665f, 0.17311367f, 0.04667134f, 
    -0.02258675f, 0.07896408f, -0.02459418f, -0.02623209f, 0.04659346f, 0.00443895f, 0.03520138f, 0.04268122f, 
    0.06086881f, 0.00226779f, -0.04144447f, 0.09381709f, 0.17665642f, 0.08037705f, -0.18029787f, -0.00424963f, 
    0.36034563f, 0.02877584f, -0.01177359f, 0.05025636f, -0.04087486f, -0.05104179f, 0.04499468f, 0.06742086f, 
    0.04507382f, -0.07491168f, 0.00808785f, 0.05569320f, 0.05660368f, 0.11006287f, 0.02246599f, 0.05591608f, 
    -0.01906353f, 0.13875934f, -0.04843124f, -0.07103498f, -0.02264912f, 0.05768576f, -0.04458856f, 0.02324098f, 
    0.02283186f, -0.02691833f, 0.04944265f, 0.02803385f, 0.07009640f, -0.03156845f, 0.03785090f, 0.01456323f, 
    0.08681310f, 0.03330196f, 0.08455510f, 0.03889521f, 0.00069413f, -0.08759535f, 0.11418929f, -0.13711655f, 
    0.13537244f, 0.02079985f, -0.09428488f, -0.00705810f, -0.25523302f, -0.06542382f, -0.06909971f, -0.00226372f, 
    0.10059767f, -0.08700503f, -0.13723612f, 0.02206838f, 0.00618582f, -0.05911620f, 0.05569204f, 0.05377041f, 
    -0.14429349f, -0.00098228f, 0.02548407f, -0.13060214f, 0.11457927f, -0.01703019f, 0.03045932f, 0.03789588f, 
    -0.09704033f, -0.06432818f, 0.06122538f, 0.02519249f, 0.03926482f, 0.03068186f, 0.00197213f, -0.06530452f, 
    0.08966529f, 0.00133461f, 0.05071962f, -0.06173287f, -0.37856850f, -0.02124052f, 0.03416177f, -0.06268127f, 
    0.14661880f, -0.05667665f, -0.02813956f, -0.01540377f, 0.06991236f, 0.02679571f, -0.01018028f, 0.01485340f, 
    0.02255676f, 0.01133350f, 0.13487960f, 0.03327376f, 0.02562016f, -0.03252885f, -0.04116669f, 0.02667081f, 
    0.24583685f, 0.07517861f, -0.03844886f, 0.13669659f, -0.18133798f, 0.11555039f, 0.09439195f, 0.10059933f, 
    -0.07010702f, 0.13808081f, -0.08244932f, 0.01687445f, -0.02926609f, -0.04405125f, -0.05153627f, -0.04711962f, 
    -0.06157954f, -0.13702236f, -0.14908238f, 0.05663734f, 0.29191166f, 0.33226368f, -0.01053283f, 0.23538427f, 
    0.00780461f, -0.04290837f, 0.14796057f, 0.02263872f, 0.06936032f, 0.06902083f, 0.02749272f, 0.05245585f, 
    -0.01924218f, -0.03774997f, 0.07595760f, 0.06628507f, -0.01189901f, 0.01598343f, 0.09115153f, -0.08300810f, 
    -0.28017774f, -0.09129421f, -0.01753184f, -0.17120707f, 0.13171017f, 0.13281834f, 0.04756522f, 0.02251623f, 
    0.06689760f, 0.01193141f, 0.07286920f, -0.16202454f, 0.02541903f, 0.03872077f, -0.01328832f, -0.04455173f, 
    0.02870576f, -0.01097948f, 0.07851436f, -0.07129182f, 0.00625291f, 0.19404332f, -0.01013991f, -0.22351131f, 
    0.20196946f, 0.02941329f, -0.10717165f, 0.02559329f, 0.00520907f, 0.01010733f, 0.04229828f, 0.03714893f, 
    0.05511031f, -0.02788295f, 0.02757051f, -0.08480563f, 0.04812347f, 0.03330416f, -0.02917648f, -0.03642340f, 
    0.14665422f, -0.09390049f, 0.05947307f, -0.25850087f, 0.18395327f, -0.04006189f, 0.07796743f, -0.03666358f, 
    -0.03682671f, -0.08438187f, 0.08258042f, 0.06394848f, 0.00334372f, 0.02922601f, 0.03003041f, -0.09100427f, 
    0.13897192f, 0.06531071f, 0.05280448f, 0.03287159f, 0.22218165f, 0.33834031f, -0.24947199f, 0.21080159f, 
    -0.19650362f, 0.14662568f, 0.12543391f, 0.09969457f, -0.02332657f, -0.03636089f, 0.01873928f, -0.00182183f, 
    0.06870618f, 0.04033310f, 0.00521796f, 0.02211234f, -0.02478625f, -0.03379629f, 0.01578349f, 0.03216241f, 
    0.39395925f, 0.01962364f, 0.18255591f, 0.04163807f, -0.07010706f, -0.02088710f, -0.02250528f, -0.05378880f, 
    -0.00829999f, 0.04518086f, 0.00096087f, -0.00193861f, 0.04482993f, 0.04002610f, 0.04868340f, -0.18401921f, 
    -0.10852128f, 0.07071993f, 0.02829399f, -0.01118367f, -0.02529337f, -0.05914612f, -0.00583438f, -0.02641536f, 
    -0.01426780f, 0.08741076f, -0.00050065f, 0.05760936f, 0.02450970f, 0.04404834f, 0.08963178f, 0.17094044f, 
    0.05891140f, -0.03949685f, -0.06067145f, 0.04503466f, -0.00111024f, 0.11406621f, -0.03376166f, -0.03234946f, 
    -0.33356127f, -0.01774893f, 0.10457867f, -0.04013675f, -0.10558986f, 0.17115234f, 0.09051608f, 0.07794059f, 
    0.03172110f, -0.07055877f, 0.01498770f, 0.07813772f, -0.06387429f, -0.10439164f, 0.00202777f, -0.08501937f, 
    -0.04476865f, 0.09254453f, -0.08216721f, 0.05771006f, -0.02812976f, 0.04335387f, 0.50114590f, -0.07165482f, 
    0.11949789f, -0.16315356f, -0.11759637f, -0.09469089f, 0.01373544f, 0.00373523f, -0.06482954f, -0.01933211f, 
    0.09875907f, 0.05413806f, 0.06693098f, 0.09002578f, 0.04784030f, -0.10237245f, -0.07593974f, 0.06563780f, 
    0.23490164f, 0.21215144f, 0.14922526f, -0.08185004f, -0.05327975f, -0.11810022f, -0.17616975f, -0.05295836f, 
    0.06893720f, -0.02924655f, -0.09493063f, 0.05909759f, 0.06603510f, 0.05775875f, 0.05481970f, -0.06122927f, 
    0.08692861f, -0.02582984f, 0.08894952f, -0.01139214f, -0.01408663f, -0.13852485f, -0.06030032f, 0.00702477f, 
    -0.07108869f, -0.04976336f, -0.06922442f, -0.01782587f, -0.01567448f, 0.00768091f, 0.05649250f, -0.07418788f, 
    -0.02052840f, -0.14713475f, 0.06412114f, -0.05395126f, -0.04769047f, 0.11447121f, -0.03400311f, 0.05201998f, 
    0.03352761f, -0.01378129f, 0.05230433f, -0.02542276f, -0.14812979f, 0.00733230f, 0.13886143f, 0.14567265f, 
    0.08410693f, 0.04599409f, 0.07881421f, 0.05415927f, 0.08121534f, -0.02783180f, -0.01045680f, 0.06097715f, 
    -0.04051353f, -0.04189641f, 0.01745711f, 0.10870779f, 0.04365437f, 0.11661195f, 0.12433772f, -0.12201935f, 
    0.12332644f, 0.16100805f, 0.11937430f, -0.05502562f, -0.04428383f, -0.02058999f, 0.16911547f, 0.11132284f, 
    -0.00820700f, -0.03741637f, 0.07090390f, 0.04990765f, 0.06184810f, 0.05524640f, -0.12217336f, 0.02908170f, 
    -0.13659838f, 0.16449016f, 0.15276955f, 0.15302381f, -0.19436546f, 0.19673835f, 0.11303816f, 0.06341628f, 
    -0.11144929f, 0.04285395f, -0.03370532f, -0.06384882f, 0.00894102f, 0.03730727f, -0.10768909f, 0.09071136f, 
    -0.02198048f, -0.05401121f, 0.00879372f, -0.11363137f, -0.17984316f, -0.13465278f, -0.01476875f, 0.17077707f, 
    0.10680076f, 0.07151864f, -0.01498410f, 0.06329492f, 0.02043306f, 0.05272883f, -0.01005370f, 0.02921460f, 
    -0.08552194f, -0.05271123f, -0.08184852f, -0.04260457f, 0.02719946f, 0.02297920f, 0.07174973f, 0.07913601f, 
    0.09771274f, 0.18245493f, -0.00351434f, 0.06037966f, 0.12841186f, -0.04034313f, -0.06325511f, 0.01844584f, 
    -0.06630807f, -0.04034670f, 0.10267734f, 0.05988101f, 0.07121837f, -0.01375508f, -0.08440430f, -0.01518811f, 
    -0.03801926f, -0.08974309f, 0.00881155f, 0.08237167f, -0.08979867f, -0.11296370f, 0.12798184f, -0.07612479f, 
    0.13612483f, 0.13402990f, -0.06491803f, 0.16005619f, -0.03516509f, 0.06793418f, -0.05891479f, 0.07087830f, 
    0.06496391f, -0.13055588f, -0.08070076f, 0.03999648f, 0.08474583f, 0.13517967f, 0.09340280f, -0.08699792f, 
    0.30926374f, 0.04547485f, 0.10158248f, -0.06821268f, -0.00491258f, -0.26008719f, -0.07757011f, 0.00958277f, 
    0.07155222f, 0.02780532f, -0.04296245f, -0.07192919f, 0.05496753f, 0.00838609f, 0.10567215f, 0.00650571f, 
    0.02589381f, 0.03721133f, 0.03042440f, 0.03143125f, -0.28975549f, -0.32601839f, 0.03443008f, 0.23037064f, 
    -0.06501693f, 0.09287605f, -0.00390751f, 0.04399396f, 0.02936923f, 0.08181953f, 0.00848076f, 0.04957593f, 
    -0.02562672f, 0.01653579f, 0.10059983f, 0.10875778f, 0.01333211f, 0.01178117f, 0.09234824f, -0.03083634f, 
    -0.28543231f, 0.24859475f, -0.27775800f, 0.05009822f, -0.11698876f, 0.09810768f, 0.07802623f, 0.07359579f, 
    0.11569857f, 0.02141630f, -0.00111370f, 0.02107465f, -0.07106188f, 0.03777875f, -0.07963758f, 0.04202159f, 
    -0.09523825f, -0.03582871f, 0.05351499f, 0.04434427f, -0.12088910f, 0.05020555f, -0.12305508f, 0.04401687f, 
    -0.13325809f, 0.13147588f, -0.02158404f, 0.06147358f, -0.04768417f, 0.01799843f, -0.01564499f, 0.10148880f, 
    -0.02190395f, -0.01366243f, -0.05626914f, 0.00400301f, 0.00908331f, 0.09481836f, -0.00303403f, -0.02898143f, 
    0.17466342f, 0.11188780f, 0.00910289f, 0.08032074f, 0.04607832f, -0.16237943f, -0.15385301f, 0.00045174f, 
    -0.09539746f, 0.04867879f, 0.12865020f, 0.03588712f, 0.06831074f, -0.01043173f, 0.04317674f, 0.07511226f, 
    0.00580705f, -0.09756134f, -0.08920897f, 0.01789685f, 0.16148177f, 0.01152797f, 0.06062160f, -0.07410962f, 
    0.03211398f, 0.02374880f, 0.12309910f, -0.04464078f, -0.01130186f, -0.01929033f, 0.02403276f, 0.03128887f, 
    -0.02947548f, 0.00581451f, 0.07676583f, 0.00951580f, 0.09564021f, 0.06207858f, 0.00434639f, 0.05189946f, 
    0.07933999f, 0.06866923f, -0.07340251f, -0.09242122f, -0.15126249f, 0.15476766f, 0.11519144f, -0.04922741f, 
    0.08462291f, 0.02791888f, 0.09779314f, 0.03280011f, -0.02042797f, 0.01520090f, 0.10664885f, 0.04159911f, 
    0.03530470f, -0.01314265f, 0.02187316f, -0.01075517f, 0.22562884f, -0.19271338f, 0.10797430f, -0.02785710f, 
    0.03035471f, -0.05108380f, -0.03260295f, -0.05237481f, 0.01732197f, -0.07032556f, 0.02116541f, 0.12460805f, 
    -0.00934026f, -0.01257233f, 0.06231978f, -0.04768577f, -0.03004363f, 0.15663299f, 0.01402139f, 0.00159106f, 
    0.00937870f, 0.17182688f, 0.00044819f, -0.09723784f, -0.02746557f, 0.20320539f, 0.18988833f, -0.08749430f, 
    0.00802460f, -0.10493871f, 0.05400198f, -0.05117178f, -0.03642695f, -0.01331475f, 0.01431413f, 0.06290021f, 
    0.07917047f, 0.02564691f, -0.15956256f, 0.04368841f, 0.28823552f, -0.04533261f, 0.09219762f, 0.02966033f, 
    0.15698975f, -0.00955458f, -0.10057128f, -0.04719168f, 0.08500750f, -0.01195541f, -0.08621877f, 0.15397391f, 
    0.00776243f, 0.04697276f, 0.14489038f, 0.14798379f, -0.11166202f, 0.03601215f, 0.01440862f, 0.04038494f, 
    -0.22701117f, -0.30157140f, -0.07214838f, 0.01073907f, -0.03844952f, 0.04367065f, -0.03113419f, 0.09447113f, 
    -0.03884263f, 0.09584453f, -0.01762639f, 0.03922012f, 0.02737771f, 0.02885607f, -0.02099263f, -0.11871318f, 
    -0.08049896f, 0.02756035f, 0.07354465f, 0.03058414f, -0.38323364f, 0.14389537f, 0.07420482f, 0.12546623f, 
    -0.09083947f, 0.08473641f, 0.08812831f, 0.02592736f, 0.06575093f, 0.04536517f, -0.04991465f, -0.02054231f, 
    -0.05212206f, 0.03230611f, -0.07375170f, 0.08622369f, -0.01069146f, -0.05426507f, -0.02530650f, -0.06043694f, 
    -0.28117067f, 0.13631262f, -0.28149495f, -0.14328866f, -0.13875519f, 0.24404165f, 0.14079010f, 0.06389728f, 
    0.19738743f, -0.03524080f, -0.03325896f, 0.06224145f, -0.13779077f, -0.00021935f, -0.03402323f, 0.06166555f, 
    0.03749293f, 0.00954665f, 0.06059851f, 0.04377484f, 0.12856148f, 0.12436760f, 0.00582293f, 0.24264832f, 
    -0.26159826f, 0.08467467f, 0.09709658f, 0.06653889f, -0.05851642f, 0.07247487f, -0.03424010f, -0.05467122f, 
    -0.02071045f, 0.10157669f, -0.00297877f, 0.07962339f, 0.02467610f, 0.03237329f, -0.00778505f, 0.00707870f, 
    -0.12109851f, 0.02462249f, 0.08164999f, 0.00804584f, 0.11040857f, 0.05713522f, 0.16679153f, 0.04619876f, 
    0.02775924f, 0.08716675f, 0.02388914f, 0.11891083f, 0.03315404f, -0.04085684f, 0.02180675f, 0.00971684f, 
    -0.00508314f, -0.01818092f, -0.01182411f, 0.06406647f, 0.01317525f, 0.28735757f, 0.17151102f, 0.10600513f, 
    -0.11734079f, -0.16176708f, -0.00431999f, -0.00483166f, -0.02846402f, 0.06052431f, 0.00946229f, 0.01464300f, 
    -0.05399238f, 0.04740164f, 0.02523660f, 0.00038750f, 0.00138151f, -0.09892177f, 0.05750132f, 0.10161505f, 
    -0.00606540f, 0.02564108f, -0.20667571f, 0.11625419f, -0.16891287f, 0.02116425f, -0.07629769f, -0.01444284f, 
    0.10533382f, 0.10964821f, 0.11543503f, -0.14538151f, 0.08238966f, 0.06404882f, -0.00834312f, 0.08552331f, 
    -0.03962952f, 0.04450500f, 0.07416289f, 0.06231195f, 0.06699583f, -0.24322833f, -0.06002599f, 0.07825793f, 
    -0.12209109f, 0.04913065f, 0.00899782f, -0.07526710f, 0.01972754f, 0.05951069f, 0.01669668f, -0.09117898f, 
    -0.07341322f, 0.03239539f, -0.05746604f, 0.05920798f, -0.04897461f, -0.02909297f, 0.01314371f, -0.00502088f, 
    -0.20882063f, -0.07161891f, -0.02122342f, 0.03687874f, -0.09371687f, 0.18431498f, 0.15632552f, 0.11325496f, 
    -0.04211225f, 0.03391107f, -0.00892424f, 0.05256363f, 0.09627140f, -0.05069029f, 0.02038188f, -0.03651151f, 
    0.09342960f, -0.00808446f, 0.00062800f, -0.01901600f, 0.14820625f, 0.17295156f, 0.21612264f, 0.08148904f, 
    0.09706643f, -0.10841686f, -0.01826946f, 0.04351109f, 0.05630688f, -0.01473454f, -0.01754796f, -0.03823395f, 
    -0.00113262f, 0.02283678f, -0.02356530f, -0.01275573f, -0.07710505f, 0.06572284f, -0.00052890f, 0.06384028f, 
    -0.04238468f, -0.01310424f, 0.01479665f, -0.04152881f, -0.03041966f, 0.00696901f, -0.01916004f, 0.01728378f, 
    0.00447372f, 0.02992711f, 0.00983482f, -0.01092146f, -0.02800797f, -0.00688005f, -0.02097703f, -0.03887276f, 
    0.01371566f, 0.00895314f, 0.01901350f, -0.02975328f, 0.00132932f, -0.00781265f, -0.03705728f, -0.00221782f, 
    -0.00216237f, -0.03510093f, -0.00601552f, -0.03672821f, 0.03115360f, -0.03670188f, -0.01306660f, -0.03403812f, 
    -0.04450446f, -0.00582890f, -0.00710371f, -0.01822305f, 0.02978970f, 0.01808570f, 0.01266743f, -0.02779269f, 
    -0.01940133f, -0.02272909f, 0.03497700f, 0.00952454f, -0.01211996f, 0.00196772f, 0.00151556f, -0.01732768f, 
    0.00598335f, 0.02344943f, 0.03741920f, -0.01971184f, -0.00760373f, -0.01634418f, -0.02704665f, -0.04008154f, 
    -0.02092373f, 0.03539284f, -0.00799681f, -0.00140596f, 0.01605507f, -0.04418182f, 0.04176052f, -0.01540755f, 
    -0.00970215f, 0.02972896f, -0.01262063f, 0.03340690f, -0.03202376f, -0.00006060f, -0.03883061f, -0.04403164f, 
    -0.04013944f, 0.01257845f, 0.02827447f, 0.02312698f, 0.00196927f, -0.03470973f, -0.03112228f, -0.02879087f, 
    -0.02115496f, 0.00744678f, 0.00515702f, 0.02988578f, -0.03548447f, 0.00622156f, -0.02627175f, -0.03551664f, 
    0.00468978f, -0.04376598f, 0.01445465f, -0.01144933f, -0.04112001f, 0.02128772f, -0.03062024f, -0.00808068f, 
    -0.04304052f, -0.01421506f, 0.01408020f, 0.02921426f, -0.02608704f, -0.02206057f, 0.02429173f, -0.03831619f, 
    -0.03151080f, -0.04973542f, -0.03697587f, 0.00712551f, -0.03357209f, 0.02867507f, -0.02930843f, 0.02878161f, 
    -0.02296254f, 0.00963989f, 0.03259607f, -0.00959840f, 0.00924589f, 0.01687318f, -0.00458103f, -0.02469740f, 
    -0.00964013f, -0.00934805f, -0.00233127f, -0.01582733f, 0.01170087f, -0.03583829f, -0.02636973f, 0.01709197f, 
    -0.02777662f, 0.02016283f, -0.01845238f, -0.02599481f, -0.01174989f, 0.01995596f, 0.03241445f, 0.00688717f, 
    -0.02230234f, -0.00329460f, -0.02776919f, 0.01765398f, -0.02811382f, -0.02182428f, -0.02105632f, -0.03265335f, 
    0.00395081f, -0.02066644f, 0.02407302f, -0.04752058f, -0.00180892f, -0.03972078f, 0.01239967f, 0.00042929f, 
    -0.00577747f, -0.02964244f, -0.02176713f, -0.00518448f, 0.02317909f, 0.02190007f, -0.04543767f, 0.00511542f, 
    -0.00459997f, -0.01078078f, -0.02089036f, 0.01161031f, -0.01789269f, -0.01015658f, -0.03669263f, -0.01342428f, 
    0.01253092f, 0.02686663f, 0.01030858f, 0.03297458f, -0.00456842f, -0.04115388f, 0.01798677f, 0.00922190f, 
    -0.03000833f, 0.01763786f, 0.00578845f, 0.03014320f, -0.02841982f, -0.03662559f, -0.03563632f, -0.00020655f, 
    -0.02858745f, 0.03206378f, -0.00969009f, 0.00444233f, 0.02312061f, 0.02253267f, 0.03356363f, 0.00895607f, 
    0.02242112f, -0.02331420f, -0.00450943f, 0.00221858f, -0.01083375f, -0.01166738f, -0.01338965f, 0.01444151f, 
    -0.03104957f, -0.01734165f, 0.03967329f, -0.02917506f, 0.01864273f, 0.00182136f, -0.04708336f, -0.00588132f, 
    -0.00541597f, -0.02272723f, 0.01192776f, -0.01696757f, 0.02481826f, -0.03133236f, -0.00214410f, -0.00722299f, 
    0.01176862f, 0.01230118f, -0.00522136f, 0.02961348f, -0.03488018f, 0.00347754f, -0.03678017f, -0.03783061f, 
    0.02506000f, -0.02639634f, -0.01734967f, 0.02797433f, 0.01291274f, -0.04116387f, 0.02212271f, -0.04310790f, 
    0.00023169f, -0.01967357f, 0.01395033f, 0.02778794f, -0.01325502f, 0.03214037f, -0.01692159f, 0.01198788f, 
    0.03099102f, -0.00556951f, 0.01896025f, 0.02191667f, -0.00341358f, 0.00940528f, 0.02239134f, 0.01396157f, 
    -0.03149712f, 0.00664836f, -0.04120456f, -0.02201618f, 0.00842050f, -0.04041414f, -0.01537728f, 0.01747357f, 
    -0.01913281f, -0.02190349f, -0.00300486f, -0.01643096f, -0.05202623f, 0.02173343f, 0.02796818f, -0.03997931f, 
    -0.02945099f, -0.02586783f, 0.02174086f, 0.00766884f, 0.02718948f, -0.00127188f, 0.03974067f, -0.00234601f, 
    0.02044722f, -0.04604126f, 0.03636633f, -0.02098611f, 0.01068212f, 0.03317572f, -0.03216971f, 0.00884811f, 
    -0.02534193f, 0.02882588f, 0.02894042f, -0.02355712f, 0.00681716f, -0.00005620f, -0.02146197f, 0.00791531f, 
    -0.01788413f, -0.01793964f, -0.00440376f, -0.03957696f, 0.02827595f, 0.02716500f, -0.03808575f, -0.01815994f, 
    0.03150431f, -0.03758561f, -0.02566399f, -0.03253730f, -0.03865921f, 0.02484401f, -0.04941266f, -0.00166170f, 
    -0.03069510f, -0.02019426f, -0.01500672f, 0.00451263f, 0.02854344f, 0.01623587f, 0.00725096f, -0.02002392f, 
    -0.02867765f, -0.02598117f, -0.00668431f, 0.02249202f, -0.02730857f, 0.01971157f, -0.04355294f, -0.04884434f, 
    -0.00346131f, 0.03677991f, -0.00877628f, -0.04619400f, -0.00734806f, 0.01881010f, -0.02043820f, 0.03101999f, 
    -0.03295763f, -0.00035495f, 0.00784539f, -0.02480404f, 0.02882542f, -0.04714924f, 0.01190641f, -0.01414529f, 
    0.02208215f, -0.00079897f, -0.00718822f, 0.00445282f, 0.01082880f, -0.03544213f, -0.02337221f, -0.02057686f, 
    0.02556543f, -0.02957566f, 0.02328012f, -0.00024387f, -0.05098202f, -0.02792418f, -0.03068888f, -0.02373539f, 
    -0.03303618f, 0.01191411f, -0.00396218f, 0.00001838f, -0.00156919f, 0.02546321f, 0.01584947f, -0.01073649f, 
    -0.02559647f, -0.04405956f, -0.03370975f, -0.03333679f, -0.03020643f, 0.02918867f, 0.03552856f, -0.00420338f, 
    0.00140321f, -0.03110441f, -0.02480546f, 0.00788274f, -0.00263052f, -0.02473688f, 0.01560989f, -0.02796735f, 
    -0.03727950f, 0.01741105f, -0.01668683f, -0.03930131f, -0.02677371f, 0.01673035f, -0.02068296f, -0.00323779f, 
    0.02502604f, 0.00311078f, -0.03053933f, -0.03409334f, -0.04511698f, -0.03250779f, -0.04505919f, -0.01707453f, 
    0.03465526f, -0.02257410f, 0.02649870f, -0.04647121f, -0.00434613f, -0.03289603f, 0.02007820f, -0.00046738f, 
    -0.04616563f, -0.03906305f, -0.01340601f, -0.02525216f, -0.03090947f, -0.02731380f, 0.03144922f, 0.02771311f, 
    -0.04483987f, 0.01431761f, 0.01608983f, 0.00923876f, -0.03536253f, -0.00225006f, 0.01918852f, 0.02322922f, 
    0.00724315f, 0.02690058f, 0.02092747f, 0.02440682f, -0.02500688f, 0.00913284f, -0.02335076f, 0.00751465f, 
    -0.03142552f, -0.04294500f, 0.01526186f, -0.02168654f, -0.02234270f, -0.01623372f, 0.01500894f, 0.00298386f, 
    -0.00067109f, -0.01617160f, -0.04072272f, -0.04603945f, -0.01353153f, 0.02549364f, -0.01271322f, -0.01940799f, 
    0.01272333f, 0.01786868f, 0.02862781f, 0.01310318f, 0.00375385f, -0.00225313f, 0.01593657f, 0.02284260f, 
    0.03250651f, 0.02104209f, 0.00210123f, -0.03395230f, -0.02641910f, -0.02174906f, 0.01753776f, -0.01932664f, 
    -0.02650086f, -0.04000528f, -0.03654196f, 0.02210660f, -0.01469145f, -0.01989330f, -0.02961622f, -0.04328813f, 
    -0.02961690f, -0.03233434f, -0.01234069f, -0.02727016f, 0.01952948f, -0.01968341f, -0.02981097f, 0.01329466f, 
    -0.02946635f, 0.00954627f, -0.03869413f, -0.01607929f, -0.02559128f, -0.00397642f, -0.02460150f, 0.00178342f, 
    -0.03463600f, 0.01252720f, -0.02510257f, 0.02858626f, 0.02091789f, 0.02798673f, 0.00443644f, -0.03175320f, 
    0.00441805f, -0.01738584f, 0.03585594f, -0.04028243f, 0.01715501f, -0.02531943f, -0.01168497f, 0.01017506f, 
    -0.02111686f, -0.01306672f, 0.01107378f, -0.02223699f, 0.01161632f, 0.02272689f, -0.01120567f, 0.01192382f, 
    -0.01140052f, -0.00221742f, -0.03576152f, 0.01097762f, -0.02303695f, -0.04277185f, -0.02385736f, 0.01264981f, 
    0.02305084f, -0.04584168f, 0.02943595f, 0.03120806f, -0.04639097f, 0.00907394f, 0.02749698f, -0.00229456f, 
    -0.04516479f, -0.03392730f, 0.02826755f, -0.03059784f, 0.02435048f, 0.00266976f, -0.03706371f, -0.04168579f, 
    -0.03124739f, 0.00630273f, -0.01413920f, 0.03066257f, 0.00000261f, 0.02289935f, -0.00103792f, 0.00165088f, 
    -0.04157090f, -0.03397762f, 0.01028642f, -0.00936254f, 0.01131124f, 0.02063792f, -0.01210117f, -0.04091589f, 
    -0.00143199f, 0.01997068f, -0.03716435f, 0.02134279f, 0.02497103f, -0.00079782f, -0.03095734f, 0.00061015f, 
    -0.00559353f, -0.04570803f, 0.00639524f, 0.00731686f, 0.01902656f, 0.02097643f, 0.02143627f, 0.00705653f, 
    -0.00709078f, 0.01990561f, -0.00180389f, 0.01114392f, -0.04708343f, -0.02346494f, -0.02750038f, -0.00437497f, 
    -0.00745742f, 0.03404497f, 0.00806632f, -0.00394921f, 0.00251539f, 0.00997339f, -0.01688937f, 0.02611277f, 
    0.03059905f, -0.02397472f, 0.02090998f, 0.02558601f, 0.02080323f, -0.04729067f, 0.02841931f, -0.03928781f, 
    0.02813813f, -0.04165118f, -0.01610409f, 0.01166589f, -0.01080533f, 0.00815074f, -0.00631445f, -0.03082526f, 
    0.01952544f, 0.00620389f, -0.03388618f, -0.00723215f, -0.02471438f, -0.00083539f, -0.04115143f, -0.04406453f, 
    -0.04659774f, 0.02969904f, 0.00460602f, -0.00872270f, -0.02401918f, 0.03238023f, -0.02377304f, -0.01271363f, 
    -0.00240585f, 0.00083989f, 0.00111696f, -0.00236191f, -0.01202605f, -0.02591946f, -0.04154277f, 0.02796565f, 
    -0.02551218f, 0.02404390f, -0.02968000f, 0.01129871f, -0.02659739f, 0.04130869f, 0.04115858f, -0.01175787f, 
    -0.04518013f, 0.01135900f, -0.00120137f, 0.00086736f, -0.03858275f, -0.03689623f, 0.02148254f, -0.02877790f, 
    -0.05183070f, -0.04423245f, -0.04433205f, 0.02531517f, -0.02500721f, -0.01295161f, -0.00539422f, 0.02792769f, 
    -0.29614934f, -0.04849656f, -0.08761467f, 0.04952110f, 0.06811950f, -0.00148427f, 0.03340415f, -0.05083298f, 
    -0.03493929f, -0.09309337f, -0.10033566f, -0.04881831f, -0.01083754f, -0.12364288f, -0.00768012f, -0.10261024f, 
    -0.00227909f, -0.10657711f, 0.05340167f, -0.00170753f, -0.08973865f, 0.17072853f, 0.25963357f, 0.11091994f, 
    -0.08322300f, -0.04569047f, 0.06907153f, -0.01984907f, -0.03278936f, 0.04875161f, 0.05746144f, 0.06471600f, 
    0.01924277f, 0.06329700f, 0.02127734f, 0.05106091f, 0.09663723f, 0.11667778f, -0.04691366f, -0.05710639f, 
    -0.03799678f, 0.31851143f, 0.12035142f, -0.07726222f, 0.16267045f, -0.04158023f, -0.03711260f, -0.05188476f, 
    -0.02676327f, 0.09338164f, -0.01785013f, 0.11134408f, -0.12638710f, 0.20499170f, 0.11618099f, 0.03819042f, 
    0.05601186f, -0.01882584f, 0.10786397f, -0.04233264f, 0.03602926f, -0.06099710f, -0.00979480f, -0.11791509f, 
    -0.14199290f, -0.05181484f, -0.09227931f, 0.02333185f, 0.08145846f, 0.13205026f, 0.04931496f, -0.03219797f, 
    -0.00813442f, -0.09100865f, 0.06616378f, -0.02180100f, -0.05001472f, 0.07279979f, 0.00185230f, -0.12416576f, 
    -0.05779380f, -0.13052522f, 0.04828166f, -0.01225153f, 0.21453781f, -0.00962133f, -0.04911836f, -0.08234073f, 
    0.01983351f, 0.01759025f, -0.01301150f, 0.00348429f, -0.09607475f, -0.00434575f, 0.05004463f, -0.01123670f, 
    0.11125950f, 0.04126941f, 0.05416693f, -0.04388540f, 0.15884401f, -0.05189973f, 0.10469521f, 0.08663791f, 
    -0.26284140f, -0.10353481f, 0.02321151f, 0.02096913f, 0.02676701f, -0.05441368f, 0.03965089f, -0.00917763f, 
    -0.01922627f, 0.06543951f, 0.06301945f, 0.00553755f, 0.00226008f, 0.02664222f, -0.05913146f, 0.00922341f, 
    0.17983590f, 0.14055391f, 0.13060734f, -0.03898592f, 0.06445317f, -0.01252997f, -0.06506415f, 0.04345862f, 
    -0.11497851f, 0.06753500f, 0.02931972f, -0.04739827f, 0.04752154f, -0.00437092f, 0.05673314f, 0.00754331f, 
    0.04521895f, -0.15411513f, 0.06219865f, -0.15362176f, 0.04443559f, 0.33727986f, 0.03817469f, 0.07274664f, 
    0.14891803f, -0.05456885f, -0.06701963f, -0.10416412f, 0.06538220f, -0.02442117f, -0.00734596f, 0.04499576f, 
    0.03402056f, 0.12337503f, 0.09196898f, 0.01662018f, -0.01049961f, 0.03675401f, 0.00460326f, 0.03291344f, 
    0.22820728f, 0.14723128f, 0.32544723f, 0.03447543f, 0.04902026f, 0.05164420f, -0.08477253f, 0.15918626f, 
    0.11284085f, -0.04597021f, 0.03745576f, -0.07896040f, 0.03487244f, 0.03600946f, 0.00344530f, 0.08949178f, 
    0.09612986f, -0.06572970f, 0.22228561f, -0.04571085f, -0.06267807f, -0.01015452f, 0.07123342f, -0.01226479f, 
    -0.07809775f, 0.04652582f, -0.02428496f, -0.06682651f, 0.00046703f, -0.07633519f, 0.00636274f, 0.03954134f, 
    -0.01619712f, 0.03761930f, 0.01888054f, -0.01246758f, -0.06298572f, 0.07571892f, 0.02722277f, -0.02567579f, 
    0.17095639f, -0.19556025f, -0.00783470f, 0.02933572f, 0.15873437f, -0.02387357f, -0.05294245f, -0.04052426f, 
    -0.08350789f, -0.08962219f, -0.04912668f, -0.06938751f, 0.10466370f, -0.06245729f, 0.01116154f, 0.00324135f, 
    0.03552850f, -0.14766049f, 0.02549919f, -0.07450959f, 0.05145561f, 0.25010562f, 0.04362158f, 0.04919283f, 
    0.09891579f, -0.24588911f, -0.03418289f, 0.04217930f, -0.00740535f, 0.03127130f, -0.08465139f, 0.01975779f, 
    0.13084780f, -0.02102483f, 0.13005999f, -0.02088546f, 0.00395773f, 0.02200388f, 0.03554885f, 0.01683312f, 
    -0.11107268f, 0.02832025f, -0.00548216f, 0.10742940f, -0.07122312f, -0.03004236f, 0.05997913f, 0.04004016f, 
    -0.03900160f, 0.01857891f, 0.02091894f, 0.05301165f, 0.01685838f, -0.10459331f, -0.11136813f, -0.06900283f, 
    -0.00684724f, 0.06292524f, 0.08350584f, -0.07296628f, -0.23928684f, -0.07925862f, 0.02806074f, 0.16342746f, 
    -0.04930881f, 0.04216138f, -0.03952946f, -0.14673366f, -0.01108894f, -0.03300873f, -0.06835796f, 0.06683467f, 
    0.06570739f, -0.06602419f, 0.08240064f, 0.06140652f, 0.03168460f, 0.10480341f, -0.03290693f, 0.01898477f, 
    -0.04168567f, -0.08877790f, 0.12125752f, 0.11710519f, -0.07021208f, -0.00614323f, 0.18552603f, 0.08249792f, 
    0.01102868f, 0.06021013f, -0.02730218f, 0.06198639f, -0.01381317f, -0.03731548f, 0.00161838f, 0.00846540f, 
    -0.02855457f, 0.12067083f, 0.10054497f, 0.02419615f, 0.16119413f, -0.12871131f, 0.11304741f, -0.15731451f, 
    -0.10312100f, -0.10364434f, -0.09860098f, -0.00093559f, -0.08728469f, -0.08251436f, -0.02932358f, 0.08479530f, 
    -0.00976498f, 0.10048768f, 0.09703210f, -0.04246231f, 0.05893677f, -0.07179771f, 0.08239615f, -0.00609391f, 
    -0.17484549f, 0.06974978f, 0.05410384f, 0.14150293f, 0.29006118f, -0.00476235f, -0.14028716f, 0.02827867f, 
    -0.01145394f, 0.02128780f, 0.05444816f, 0.01876117f, 0.03697555f, -0.05715739f, -0.00691517f, 0.02311411f, 
    -0.03621358f, -0.22890827f, 0.03920742f, -0.03594013f, 0.17781256f, 0.32065174f, -0.08575511f, 0.04433371f, 
    -0.05376915f, -0.03697931f, 0.05292169f, -0.05633837f, -0.05295772f, -0.04939104f, -0.03765284f, 0.09457317f, 
    0.05668226f, -0.03009493f, 0.06998829f, 0.03109515f, 0.05482812f, 0.01787003f, -0.01675751f, 0.05748951f, 
    0.35816216f, 0.08621784f, 0.21352799f, 0.04885587f, 0.02920154f, 0.06356797f, -0.05367796f, -0.07606355f, 
    0.04231884f, -0.04011644f, 0.04443117f, -0.03567088f, -0.06488249f, 0.03148828f, 0.01176384f, 0.10543083f, 
    0.03338163f, -0.02866938f, 0.19883139f, 0.01634800f, 0.01698475f, 0.07004678f, 0.08062617f, -0.01418035f, 
    -0.08528926f, 0.09496092f, -0.02324650f, 0.05780839f, 0.09414339f, -0.04893139f, 0.04423736f, 0.01248857f, 
    -0.06221307f, 0.03474493f, -0.04980443f, 0.04503315f, -0.05361752f, -0.01412293f, -0.00454211f, 0.02248066f, 
    -0.11092000f, 0.19725099f, -0.06022210f, 0.04527267f, 0.07382825f, 0.00713368f, -0.09363763f, 0.02611854f, 
    0.13763833f, 0.02886233f, 0.06098212f, 0.05685657f, -0.01266758f, 0.01594046f, 0.07032555f, 0.05500040f, 
    -0.03721510f, 0.07014246f, -0.01850630f, 0.08850022f, 0.11476310f, 0.04554897f, 0.18509157f, 0.07831327f, 
    0.08548288f, 0.01196885f, 0.09683456f, -0.04816844f, 0.00982225f, -0.00468740f, -0.08940232f, 0.00725253f, 
    -0.02812585f, 0.03155620f, 0.05057825f, 0.02188412f, -0.01797893f, 0.01447610f, -0.00261912f, -0.01046278f, 
    0.13097328f, 0.05525508f, 0.06066772f, -0.00536609f, -0.20745042f, -0.05145245f, -0.03481794f, -0.04011229f, 
    -0.09936920f, 0.07963836f, -0.04471755f, 0.00996576f, 0.00966992f, 0.04677173f, -0.06253938f, -0.04550728f, 
    -0.08707921f, 0.05749708f, -0.01864070f, 0.00213523f, -0.22217979f, 0.03278696f, -0.02261531f, 0.03773701f, 
    -0.03395620f, -0.01523839f, 0.08949278f, 0.12551917f, 0.06352372f, 0.11206457f, -0.00452740f, -0.02312551f, 
    -0.02336692f, 0.13625076f, 0.19672313f, 0.05778515f, 0.05583940f, 0.14222373f, -0.06372297f, 0.02759508f, 
    0.01492077f, -0.14613800f, 0.14387554f, 0.10983016f, 0.12124802f, -0.03247562f, 0.01688845f, -0.09247068f, 
    0.05176686f, 0.02284609f, -0.05013410f, 0.03182210f, -0.00564124f, 0.04603013f, 0.13907288f, 0.08345139f, 
    -0.03637207f, 0.11215475f, 0.04095070f, 0.09247267f, 0.34820038f, 0.13918169f, 0.04356872f, -0.04664119f, 
    -0.03557877f, 0.02500741f, 0.01623929f, -0.00284103f, -0.02924001f, -0.04911267f, 0.03118757f, 0.01584634f, 
    0.04546700f, -0.01966980f, 0.03680111f, -0.01890272f, 0.05677232f, -0.00989071f, 0.05021865f, -0.01949106f, 
    0.11081896f, 0.23431723f, -0.12176640f, -0.02641930f, 0.14986472f, -0.15187225f, -0.06002127f, -0.04222827f, 
    0.03854067f, -0.05170577f, -0.06500331f, 0.11125576f, 0.13556200f, 0.06812622f, 0.14842217f, 0.04926940f, 
    -0.02557828f, 0.03693692f, 0.02755548f, -0.00547728f, -0.15482914f, -0.18277839f, -0.08432041f, 0.07995281f, 
    0.18742047f, 0.09075817f, 0.02706529f, -0.03343936f, -0.01612755f, -0.12017564f, -0.03637406f, 0.06596481f, 
    -0.03799105f, -0.03693768f, -0.05901936f, -0.04752384f, 0.05989175f, 0.01442025f, -0.05839736f, 0.05761499f, 
    0.32430872f, -0.12594208f, -0.00325777f, 0.19526191f, -0.16570026f, -0.02893278f, -0.00928505f, 0.04213219f, 
    -0.01276116f, -0.05494033f, 0.00600615f, 0.14499253f, -0.05000146f, 0.06349837f, -0.01070996f, -0.04369289f, 
    0.07903153f, 0.09893733f, -0.00428003f, 0.02560196f, 0.32726124f, 0.01276936f, 0.15386416f, 0.11310843f, 
    -0.30650502f, -0.12137940f, 0.07516006f, -0.06673032f, -0.08533030f, 0.05876277f, -0.01146295f, -0.02613704f, 
    -0.04368324f, 0.01297800f, -0.02462193f, 0.06254756f, 0.01838576f, 0.00798973f, 0.08166286f, 0.02205354f, 
    -0.24714148f, -0.00604527f, 0.06519993f, 0.00521140f, -0.11663663f, 0.05314438f, -0.01371135f, -0.02130482f, 
    0.10583789f, 0.06066559f, -0.04732960f, 0.06008405f, 0.04453921f, -0.03214076f, 0.07693257f, 0.07601339f, 
    -0.02238872f, 0.10800485f, -0.06945165f, 0.03495230f, -0.05426020f, -0.17517549f, 0.01532453f, -0.17651640f, 
    0.27191186f, -0.06999418f, -0.01205509f, -0.03044840f, 0.05668045f, 0.09736186f, -0.02578215f, -0.03472821f, 
    0.01937900f, -0.02995947f, -0.02335099f, 0.04966889f, -0.00171178f, 0.09030399f, 0.10330675f, 0.02407364f, 
    -0.20784837f, -0.03931927f, -0.26641774f, -0.10904605f, 0.10167192f, -0.18628164f, 0.14192592f, 0.06275647f, 
    0.00618998f, 0.03709133f, 0.09374869f, 0.00116184f, -0.04570843f, -0.07873102f, 0.00412388f, 0.06403045f, 
    0.11618987f, -0.05143665f, -0.10531722f, 0.13470237f, 0.01832670f, 0.05716730f, -0.03748778f, 0.03779103f, 
    -0.04039381f, 0.14132133f, -0.06447094f, -0.05265858f, -0.08643763f, 0.04588723f, 0.02900398f, -0.03986651f, 
    0.08293555f, -0.02867667f, -0.01493527f, 0.00875355f, -0.08183413f, -0.08223026f, 0.09317929f, -0.03371338f, 
    0.26738167f, 0.02248034f, 0.01503916f, 0.05623849f, 0.08036985f, -0.02992241f, 0.03230571f, -0.01262519f, 
    0.05514424f, 0.21125047f, 0.01081358f, 0.08187938f, -0.10984748f, -0.00148838f, -0.01788332f, 0.12911394f, 
    -0.01280970f, -0.04561571f, -0.01123528f, -0.02678133f, 0.06875043f, -0.10620263f, -0.15422727f, 0.00199869f, 
    0.04659392f, -0.05865451f, -0.09970886f, 0.07999717f, -0.01872440f, 0.06180715f, 0.05496315f, 0.01073508f, 
    -0.12291412f, 0.02111977f, -0.04267411f, -0.02894111f, -0.00708113f, 0.10941181f, 0.03877604f, 0.04759986f, 
    0.01467315f, -0.08119516f, -0.06632204f, 0.11640471f, 0.25563759f, 0.08311792f, -0.03778848f, 0.07037311f, 
    -0.04050362f, 0.00001561f, -0.07690749f, -0.02156862f, -0.01733092f, 0.06955028f, -0.02096101f, 0.04179390f, 
    0.01327010f, -0.02248145f, -0.03198002f, -0.06568092f, 0.03221633f, -0.07906251f, 0.13093470f, 0.22703634f, 
    -0.04563155f, 0.02368096f, 0.09609326f, -0.02547201f, 0.07674416f, 0.08726344f, -0.08744763f, 0.01146884f, 
    0.04532158f, 0.10123790f, -0.13330834f, 0.06583774f, -0.08593052f, 0.01797132f, -0.08881723f, 0.00254806f, 
    -0.09794356f, 0.14145011f, 0.17627466f, 0.03126625f, 0.00816223f, 0.03058664f, -0.02296871f, -0.07939754f, 
    -0.04943148f, 0.22795616f, 0.07261807f, -0.02293034f, -0.00461109f, -0.00939091f, -0.00525071f, 0.03093312f, 
    0.13486701f, -0.04553571f, 0.02372030f, -0.07395839f, 0.21349476f, 0.06133449f, 0.21540688f, -0.04426034f, 
    0.00283968f, -0.12238067f, -0.08905631f, 0.04237399f, -0.02764927f, 0.00300100f, -0.03814808f, -0.00028800f, 
    -0.03521623f, 0.06207489f, 0.03879810f, -0.09368771f, 0.06697058f, -0.10038477f, 0.07222796f, -0.00330452f, 
    0.11751695f, 0.50998473f, -0.00026701f, -0.04631319f, 0.15635233f, 0.00191543f, -0.03198759f, 0.07548378f, 
    0.09046014f, 0.03236818f, -0.00629228f, 0.06813748f, -0.06654160f, -0.11804755f, 0.06840402f, -0.11946153f, 
    -0.06318894f, 0.02547621f, 0.15730265f, 0.08291160f, 0.33127505f, 0.01255458f, 0.03053754f, 0.01540454f, 
    -0.05873710f, 0.10236545f, 0.00035060f, -0.06526113f, 0.11816118f, 0.12187836f, -0.02640011f, 0.05396749f, 
    0.19840303f, 0.03355040f, 0.06403278f, -0.00394459f, 0.00489808f, 0.02649753f, -0.01229392f, -0.01086421f, 
    0.03474370f, -0.07051841f, -0.09169528f, -0.11200305f, 0.04990831f, -0.11631662f, -0.04059510f, -0.00341106f, 
    -0.01753802f, 0.05794195f, 0.00960101f, -0.00294526f, -0.11581239f, 0.07282989f, 0.04273858f, 0.01648872f, 
    -0.08853088f, 0.11272760f, -0.06218036f, 0.10422562f, -0.02078168f, -0.23329723f, 0.14445452f, -0.03565192f, 
    0.11697598f, -0.02866983f, -0.07301559f, 0.01540489f, 0.05787968f, 0.09392471f, 0.02955593f, -0.00750981f, 
    -0.01045721f, -0.09298936f, 0.04988351f, -0.01549741f, 0.04300788f, -0.09987660f, -0.00493630f, 0.03396062f, 
    -0.01806696f, 0.12443950f, 0.02453173f, 0.22368518f, 0.18484078f, 0.02473667f, 0.07256958f, 0.01469085f, 
    0.06742861f, -0.05484712f, -0.00451841f, -0.13396180f, 0.02354116f, 0.07435691f, 0.00837745f, -0.00891191f, 
    0.08662250f, -0.12582640f, -0.10360325f, 0.02910539f, 0.31471089f, 0.16618907f, 0.06095435f, 0.05569616f, 
    0.04999655f, 0.16514963f, -0.03395003f, -0.03943512f, 0.05199246f, 0.10164770f, -0.07019874f, 0.00094453f, 
    0.15043500f, 0.00584280f, -0.08581746f, 0.09514432f, 0.06395224f, 0.06178302f, 0.00175411f, -0.02918265f, 
    0.33195794f, -0.06772301f, 0.10916033f, 0.32114717f, -0.01474298f, 0.09580429f, 0.17122395f, -0.07795778f, 
    0.09396544f, -0.02069777f, 0.03290039f, 0.07841767f, 0.02684976f, 0.08020777f, -0.09698852f, -0.10040507f, 
    -0.05369065f, 0.04683447f, 0.02723886f, -0.11458836f, -0.22813645f, 0.12980391f, 0.08641399f, -0.09103933f, 
    -0.01808665f, 0.00550370f, 0.10094228f, 0.05713923f, 0.11295851f, -0.02865147f, 0.10601521f, -0.06379910f, 
    -0.04944364f, -0.01637368f, 0.08603744f, 0.10903049f, 0.02290490f, -0.13175136f, 0.18330063f, 0.03012205f, 
    -0.16565385f, 0.04399597f, 0.00523177f, -0.10927714f, 0.13405366f, -0.04935183f, 0.02051111f, 0.01984231f, 
    -0.08177186f, 0.01961482f, -0.10395889f, 0.03970373f, 0.06222598f, 0.00690942f, -0.06793177f, -0.12177474f, 
    -0.04189122f, 0.05273885f, 0.01021011f, -0.04330160f, 0.01374745f, 0.24141952f, 0.06215248f, 0.04128350f, 
    -0.08380929f, -0.01673995f, 0.02288152f, 0.01711708f, 0.10769055f, 0.01200839f, 0.00366464f, -0.01535582f, 
    -0.04039042f, -0.05805227f, -0.07132790f, 0.07614584f, 0.00034483f, -0.00474652f, 0.06137523f, 0.09442766f, 
    -0.14258461f, 0.38135323f, 0.13558500f, 0.14665428f, 0.15956692f, -0.00124611f, 0.08890622f, 0.08663654f, 
    -0.00566646f, -0.14229468f, 0.00262762f, 0.05547196f, 0.04829459f, -0.05587627f, -0.07734357f, 0.07993349f, 
    -0.04234397f, -0.01240510f, 0.03949279f, 0.05079546f, -0.25507590f, 0.23483245f, -0.17631017f, -0.04979716f, 
    -0.18464409f, -0.03354725f, 0.06649630f, 0.01231811f, -0.05451768f, -0.03296949f, -0.00970765f, -0.10857832f, 
    0.09634025f, 0.10717602f, -0.08413026f, -0.01982686f, 0.02310074f, -0.11248250f, -0.03269345f, -0.07340021f, 
    0.08223200f, 0.30872768f, 0.03074256f, 0.16361861f, -0.05765469f, 0.05291998f, -0.12914068f, 0.11819189f, 
    0.19711289f, 0.06028464f, 0.01497088f, -0.02772394f, 0.13881910f, -0.09022108f, 0.03499752f, -0.10548650f, 
    0.01644601f, 0.06115204f, 0.06439438f, -0.02216021f, 0.00535708f, -0.21235280f, 0.09636281f, 0.04947832f, 
    -0.07909844f, 0.00900329f, 0.02095399f, 0.07463340f, -0.12671986f, 0.06912430f, 0.12587303f, -0.00447733f, 
    -0.03016134f, -0.00789393f, -0.04418856f, -0.16664867f, 0.00385248f, -0.17735809f, 0.01075616f, -0.10582899f, 
    0.40671292f, -0.02805485f, 0.17402120f, 0.06043529f, -0.03002634f, 0.00137520f, 0.12065895f, 0.05000718f, 
    0.07898880f, 0.05883640f, -0.08944392f, -0.02028240f, 0.07473595f, 0.02208754f, 0.02916052f, -0.06039339f, 
    -0.00933951f, 0.07988326f, -0.04777575f, -0.04293903f, 0.34233999f, -0.02278038f, -0.10185055f, 0.15548350f, 
    0.03151310f, 0.17357692f, 0.10998694f, -0.05135124f, 0.10121968f, 0.08813756f, 0.02088029f, -0.01507514f, 
    0.02434494f, 0.02466229f, 0.01745562f, 0.07731081f, -0.01025951f, 0.20948836f, -0.01661907f, 0.02185646f, 
    0.27955624f, 0.12240467f, 0.14657651f, 0.32115418f, 0.05263356f, 0.06775147f, 0.06969236f, 0.11602674f, 
    0.04395511f, 0.05183352f, -0.00497204f, 0.02535857f, 0.03133066f, 0.09098937f, -0.03838907f, 0.00491508f, 
    0.08137827f, 0.02961464f, 0.03325625f, 0.01579503f, -0.15849507f, 0.21196607f, 0.05182585f, 0.13256720f, 
    -0.12349273f, 0.02286817f, 0.04448102f, -0.05940041f, 0.04955136f, 0.10925049f, 0.12064889f, 0.11724210f, 
    0.01835780f, -0.12638770f, -0.02160906f, -0.01894454f, -0.03747389f, -0.05875530f, -0.03169638f, 0.00636270f, 
    0.18276474f, -0.16149352f, 0.15501913f, -0.19973759f, 0.00486215f, -0.05416532f, -0.13106503f, -0.01750887f, 
    0.00485937f, 0.07504027f, 0.05048411f, 0.00118264f, -0.10751095f, -0.01794999f, 0.06415212f, 0.00602076f, 
    0.02672240f, -0.07370000f, 0.11501291f, 0.05490305f, -0.01728090f, -0.20575008f, -0.17041351f, 0.02260658f, 
    0.25040361f, 0.08905184f, -0.02016618f, 0.08751027f, -0.00421637f, -0.03947955f, -0.02130523f, 0.00016596f, 
    -0.02043361f, 0.10810732f, -0.02882116f, 0.08273895f, -0.02001542f, 0.11054581f, -0.03551044f, 0.11013762f, 
    -0.02737635f, 0.19369778f, -0.08293161f, 0.19175623f, 0.09425858f, -0.04654413f, 0.03816181f, -0.09404807f, 
    -0.08581663f, 0.04123844f, 0.04476880f, 0.05459130f, 0.06858933f, 0.09127723f, 0.03038264f, -0.04809067f, 
    0.03739086f, -0.07478432f, -0.05092557f, -0.09960178f, 0.18541504f, 0.03685408f, 0.17796166f, 0.12575336f, 
    -0.07323693f, 0.07173522f, 0.11474459f, -0.05139998f, -0.01439856f, -0.07032584f, -0.00733540f, 0.02851083f, 
    0.02876216f, 0.02935206f, -0.00683429f, 0.06897382f, -0.04864748f, 0.08636485f, -0.01604963f, 0.02542225f, 
    0.16174024f, 0.13965280f, 0.00535947f, 0.24972482f, 0.02580492f, 0.14486709f, -0.01283533f, 0.07469762f, 
    0.13063332f, 0.20890819f, -0.05587742f, -0.03592849f, 0.12718874f, -0.02821233f, -0.03931459f, 0.01213456f, 
    0.02859833f, 0.07186959f, 0.04154718f, -0.05253599f, 0.13256150f, -0.17159496f, -0.03888612f, -0.14224465f, 
    0.33709961f, -0.14467919f, -0.13502733f, 0.04281473f, -0.03286911f, 0.12166552f, 0.02642164f, 0.04125566f, 
    0.00336026f, 0.06396542f, 0.01609394f, -0.00460078f, 0.07779536f, -0.10508361f, -0.07683556f, -0.04606981f, 
    0.02881913f, -0.02713681f, 0.01499571f, -0.03337928f, -0.00689330f, 0.01442599f, 0.02584330f, 0.02084699f, 
    -0.04233938f, -0.00164592f, -0.04127531f, 0.02397552f, -0.01073882f, -0.04579682f, -0.03491625f, -0.00675821f, 
    0.01971922f, -0.03717716f, 0.01048194f, -0.01816713f, -0.02905858f, -0.03030437f, -0.00382343f, -0.01462576f, 
    -0.01483471f, 0.01005832f, 0.00868386f, -0.02878481f, 0.00304066f, -0.04415055f, 0.00935287f, 0.01775502f, 
    0.00861986f, 0.01975269f, 0.01514502f, -0.03998964f, 0.02398637f, -0.03089837f, 0.00468659f, 0.01316905f, 
    -0.01036600f, 0.00726629f, -0.03312469f, -0.01113177f, -0.00587983f, -0.04550142f, 0.02383493f, -0.00147795f, 
    -0.00883435f, -0.00869812f, 0.03423988f, 0.01226800f, 0.01961611f, -0.03863989f, -0.00547118f, -0.01195733f, 
    0.01266095f, 0.02223311f, -0.02826955f, -0.03165495f, 0.03240028f, -0.02560486f, 0.02197251f, -0.00711140f, 
    0.01752657f, -0.01324793f, -0.01878231f, 0.02885845f, 0.02777272f, -0.01017553f, 0.00859105f, 0.00514452f, 
    0.00863110f, -0.02298976f, 0.02000409f, 0.00918375f, 0.00124725f, 0.03003523f, -0.01052817f, 0.02963432f, 
    0.00006984f, 0.01810929f, 0.02758459f, 0.00760245f, 0.01442935f, 0.01441843f, 0.01050040f, -0.01209772f, 
    -0.00855238f, 0.01597582f, -0.03533380f, -0.02462936f, -0.00151473f, 0.00262976f, 0.02850357f, -0.01770680f, 
    0.03065154f, -0.04257892f, 0.02866527f, -0.03323968f, -0.00716603f, -0.01877989f, 0.00674753f, 0.00259634f, 
    0.02354824f, 0.00480770f, -0.01604723f, 0.01410769f, 0.00341866f, -0.03588564f, -0.03316297f, -0.03160635f, 
    0.00595031f, 0.00919189f, -0.01346845f, -0.02143383f, 0.00443527f, -0.02305851f, 0.02365692f, -0.03451565f, 
    -0.02660846f, -0.04784487f, -0.03650258f, -0.03374643f, 0.03339509f, -0.01405593f, -0.01171091f, 0.02775999f, 
    -0.01706298f, 0.02112341f, 0.01717022f, 0.02628017f, -0.02124182f, -0.03370256f, -0.03474067f, 0.00592532f, 
    -0.03503746f, -0.01050827f, 0.02170889f, -0.03384835f, 0.01071142f, -0.03603837f, -0.01021528f, -0.00888913f, 
    0.00275818f, -0.00326905f, -0.02880460f, 0.01674711f, -0.02774836f, -0.01602496f, -0.00211439f, -0.01745708f, 
    -0.02567453f, 0.02136744f, -0.00528930f, -0.03033061f, -0.02428010f, -0.00301154f, -0.00208740f, 0.00523668f, 
    -0.03891943f, -0.01503169f, -0.03719589f, 0.02861364f, -0.01622514f, 0.02868761f, 0.02831675f, 0.00386875f, 
    0.02553807f, 0.01820686f, -0.01369174f, -0.00041167f, 0.00751609f, 0.01072213f, -0.03436296f, -0.01871742f, 
    -0.02995402f, 0.01352627f, -0.04237903f, 0.02706542f, -0.00208013f, -0.02264394f, -0.02857618f, -0.00906079f, 
    -0.01800228f, 0.03220488f, 0.01967299f, 0.01409492f, 0.01099980f, 0.01060782f, -0.00026728f, -0.03106805f, 
    -0.04022785f, 0.02010101f, -0.03099323f, 0.01150831f, 0.02641457f, -0.03857647f, 0.01575711f, -0.02940187f, 
    -0.04573672f, 0.01590670f, 0.01346159f, -0.04536109f, -0.03406451f, -0.03504804f, 0.00533466f, 0.00480261f, 
    0.01980742f, 0.02607897f, -0.01129081f, 0.01902100f, -0.03306677f, -0.00672764f, -0.00419684f, -0.04308921f, 
    -0.00395406f, 0.02786575f, 0.01729488f, 0.03029422f, 0.02259050f, 0.01528840f, -0.03539821f, 0.00673241f, 
    -0.01793760f, -0.00592072f, 0.01775292f, 0.03241938f, -0.02338878f, -0.00660084f, -0.02747472f, -0.01772298f, 
    -0.03563318f, 0.02314753f, -0.01320164f, -0.02266832f, -0.01253249f, 0.00690841f, -0.03692772f, -0.02599263f, 
    -0.01649597f, 0.02893042f, -0.00289548f, 0.00091191f, -0.00017982f, 0.00238256f, 0.02402815f, -0.00774424f, 
    0.02077337f, -0.03650354f, -0.03687210f, 0.00976441f, 0.01061988f, -0.00781548f, 0.02419447f, -0.02508497f, 
    0.01178353f, -0.04152375f, -0.03736839f, 0.00216126f, -0.01746042f, 0.02390473f, -0.01734063f, 0.01507651f, 
    0.03987889f, -0.03349209f, 0.01163779f, -0.03540209f, -0.00903863f, 0.00436974f, 0.00628905f, -0.04024183f, 
    -0.00231990f, -0.00984878f, -0.01388735f, 0.03413286f, -0.00973729f, -0.04624030f, -0.00875670f, 0.01049670f, 
    -0.01535163f, -0.03740959f, -0.03692367f, 0.01217894f, -0.03987891f, -0.03108986f, -0.02626850f, 0.00307770f, 
    -0.00957820f, 0.01363439f, 0.02332908f, 0.01300625f, -0.01373276f, -0.01397979f, 0.02645247f, -0.04387955f, 
    0.02569919f, 0.00080729f, 0.02724961f, -0.03305870f, -0.03462886f, -0.00713544f, -0.01944908f, -0.00895728f, 
    -0.02339863f, 0.02463921f, 0.03643185f, -0.02636415f, 0.01564914f, 0.01238034f, 0.02044084f, -0.04016639f, 
    0.02183879f, 0.02523782f, -0.03509114f, -0.03061493f, 0.00907813f, -0.03675280f, 0.02401234f, 0.03308750f, 
    -0.02826123f, -0.02743325f, -0.03766640f, -0.04255936f, -0.04237541f, -0.01755217f, -0.01252659f, -0.03845984f, 
    -0.04031664f, 0.00984007f, 0.01240976f, -0.00521643f, -0.03366623f, -0.00418849f, -0.04283263f, -0.02320423f, 
    -0.01834939f, -0.00193700f, 0.00199571f, -0.02606820f, 0.00824671f, -0.03228262f, 0.02805886f, -0.02147474f, 
    0.02369008f, 0.00987543f, -0.03772101f, 0.02295838f, -0.03984972f, -0.02416812f, -0.03100157f, 0.00941694f, 
    -0.02867626f, -0.00815922f, 0.01068120f, 0.00229223f, -0.03049547f, -0.02974488f, -0.03670314f, -0.00725600f, 
    -0.00212004f, 0.02549154f, -0.01612652f, 0.01156651f, -0.00487874f, 0.00035875f, 0.01779768f, -0.04340100f, 
    -0.02316576f, -0.02700570f, -0.02232829f, -0.01092927f, -0.00591406f, -0.03699807f, 0.00861508f, -0.02072074f, 
    -0.01438939f, -0.03415041f, 0.00771184f, 0.02445059f, -0.01845726f, -0.01279581f, 0.02952670f, -0.00777918f, 
    0.03310006f, 0.03425454f, 0.03256697f, 0.02709421f, 0.00816274f, -0.00909975f, -0.04528348f, -0.00151005f, 
    -0.02282182f, -0.01990430f, -0.01063167f, -0.03939493f, -0.02959987f, 0.00105436f, -0.02603385f, -0.03904067f, 
    -0.03289142f, 0.02894783f, -0.04370754f, -0.02103741f, -0.03936080f, -0.04209481f, -0.00251120f, 0.00321801f, 
    -0.00627304f, -0.00011064f, 0.02130820f, -0.02845450f, 0.01958669f, 0.02330124f, -0.03893306f, -0.00107287f, 
    0.02792591f, 0.00794114f, -0.02329651f, -0.00609302f, -0.00318371f, -0.03205518f, 0.01162646f, 0.00583600f, 
    0.03186949f, 0.00531547f, 0.01852658f, 0.00811702f, 0.01757554f, -0.00509590f, 0.02851291f, -0.04094118f, 
    -0.00605086f, -0.03392067f, -0.04752077f, -0.00496274f, -0.02437354f, -0.03443940f, 0.00834053f, -0.03707084f, 
    0.00247634f, -0.03712375f, -0.03258381f, -0.03407636f, -0.03409669f, 0.02066177f, -0.02628044f, -0.01488552f, 
    0.02733814f, -0.00396949f, 0.00351665f, -0.03932893f, -0.02053429f, 0.01196505f, -0.03437025f, 0.00383311f, 
    -0.01744299f, -0.04263052f, -0.01843269f, 0.01146246f, -0.00035179f, -0.00290123f, 0.00434313f, -0.03881716f, 
    0.00114249f, 0.02390992f, -0.04666909f, 0.01144966f, -0.03062515f, -0.03622797f, 0.02100688f, 0.03669904f, 
    -0.02416242f, -0.01501706f, 0.02414472f, 0.01137535f, -0.03895011f, -0.01196291f, 0.03051115f, 0.02414933f, 
    0.00480639f, -0.04673400f, -0.02136396f, -0.01176040f, 0.01919692f, 0.01287656f, 0.01226331f, -0.03659305f, 
    0.02233538f, -0.01641816f, -0.00339223f, -0.04246785f, 0.03272743f, -0.01260342f, -0.03558919f, -0.03318878f, 
    -0.03907416f, 0.00500878f, 0.00361041f, -0.01787272f, -0.03216231f, -0.01874866f, 0.01367785f, -0.00046970f, 
    -0.02282242f, -0.02839730f, 0.02645051f, 0.02656067f, -0.01293885f, -0.01135043f, 0.01372937f, -0.03055450f, 
    -0.02883641f, -0.00860731f, 0.02258209f, -0.00560655f, 0.03078331f, 0.01667459f, 0.02335154f, -0.03066427f, 
    0.01052275f, 0.00770580f, -0.03305623f, 0.00949283f, -0.03338091f, -0.01115799f, -0.01913925f, 0.01476749f, 
    -0.02989599f, -0.03754279f, -0.02659809f, -0.02435808f, 0.03320837f, -0.02116647f, -0.04586405f, 0.02384750f, 
    0.01321234f, -0.00409167f, 0.00699349f, 0.01675136f, 0.02922505f, -0.03479948f, -0.02321725f, -0.00216752f, 
    0.02070249f, -0.00634624f, 0.00143020f, -0.01041033f, -0.03026919f, -0.01003413f, -0.00108960f, -0.00404768f, 
    0.00864334f, 0.02091331f, 0.00763957f, -0.03080366f, -0.00129669f, -0.01640627f, 0.02962196f, -0.03155494f, 
    -0.00394824f, -0.04275719f, 0.00057089f, 0.02025232f, -0.00943221f, -0.04303520f, -0.00358600f, 0.02445690f, 
    -0.03257907f, 0.01081348f, 0.02819629f, -0.01536246f, -0.03882305f, -0.04040617f, -0.00050576f, -0.02127808f, 
    0.01105651f, -0.04169803f, 0.02603245f, 0.01863958f, -0.02448300f, -0.03112720f, 0.03377825f, 0.00129851f, 
    -0.03693753f, 0.01741750f, -0.03910682f, -0.04373469f, 0.00047514f, -0.04559521f, 0.01726253f, 0.00896069f, 
    0.01765342f, -0.00109563f, -0.04279206f, -0.01294129f, -0.01191878f, 0.03189769f, -0.04315322f, -0.02585409f, 
    0.03992416f, -0.02347585f, 0.00339308f, -0.03631048f, 0.00034246f, 0.02065003f, -0.01079652f, 0.03153892f, 
    -0.00276927f, 0.02881444f, -0.03832949f, -0.00103623f, 0.01788346f, -0.00568132f, 0.01979410f, 0.02067782f, 
    0.01962489f, 0.01925318f, 0.02881095f, -0.03831072f, -0.02877940f, -0.00570332f, -0.03443163f, 0.03239399f, 
    0.02694081f, -0.01951372f, -0.03271944f, 0.01433937f, -0.01012425f, 0.03136283f, 0.00392627f, -0.03483701f, 
    0.03118639f, -0.00096612f, -0.02867050f, -0.00314821f, -0.02454110f, 0.02311231f, -0.00470383f, -0.02054480f, 
    -0.15389918f, -0.15306827f, -0.24812686f, -0.13618407f, 0.05063254f, 0.03467409f, 0.01171590f, -0.06375175f, 
    -0.01267002f, 0.04738311f, -0.00356094f, 0.08931199f, -0.05535867f, -0.07324458f, 0.03504140f, 0.09430180f, 
    0.09581606f, 0.00224160f, 0.03706067f, 0.06470356f, 0.03864958f, -0.02021435f, 0.31685698f, 0.23305136f, 
    -0.07846592f, -0.04006010f, -0.03129827f, 0.01278685f, -0.06996875f, -0.07805335f, 0.00355622f, -0.05785874f, 
    -0.07663406f, 0.09575038f, -0.03178250f, 0.08508915f, -0.04555425f, 0.02056807f, 0.00824941f, -0.12973624f, 
    0.30713764f, 0.31047735f, 0.09720436f, 0.00335471f, 0.02727315f, -0.08419033f, 0.02817852f, -0.00382598f, 
    -0.06026768f, 0.07291725f, -0.02922662f, 0.00933816f, -0.03371328f, 0.06791846f, -0.04359369f, -0.02967800f, 
    0.11385218f, 0.01353743f, 0.01755007f, -0.08703630f, 0.04561276f, -0.01191931f, -0.21768840f, -0.06160495f, 
    0.08776302f, 0.09090941f, -0.00449220f, 0.05905535f, 0.02158583f, 0.00998261f, 0.06361862f, 0.11911131f, 
    0.00558391f, -0.10370194f, 0.11284094f, -0.05808800f, 0.03817829f, 0.11228087f, 0.02428893f, 0.00731035f, 
    -0.04677745f, -0.17198175f, 0.09547469f, 0.01100796f, 0.05782223f, 0.03995509f, -0.01262746f, -0.10157832f, 
    -0.05710711f, 0.04269204f, 0.13724631f, 0.05799059f, -0.01846450f, -0.03229135f, -0.02603442f, 0.06770566f, 
    -0.00827204f, -0.02150515f, 0.03188117f, 0.10226342f, 0.05478665f, 0.01950341f, 0.08757056f, -0.01697518f, 
    -0.02817885f, -0.01830495f, 0.05772119f, 0.06536961f, 0.04244561f, -0.01448798f, 0.00100369f, 0.00737037f, 
    0.01809187f, 0.12363136f, 0.06869798f, 0.09171671f, -0.02040550f, -0.06006929f, 0.05272055f, 0.04457595f, 
    0.04401980f, 0.03933547f, 0.12340508f, -0.07633308f, 0.05287641f, 0.06628518f, 0.01976935f, -0.03209490f, 
    -0.03865667f, 0.10949184f, -0.05271367f, -0.00294012f, -0.03553354f, 0.03458977f, -0.04088775f, -0.01300230f, 
    -0.02320171f, -0.02285188f, 0.01382089f, -0.12480550f, 0.07323861f, 0.10576709f, 0.12629396f, 0.06222021f, 
    -0.03128651f, -0.21497048f, -0.02652591f, 0.09193876f, 0.04120048f, -0.04862801f, -0.06973187f, -0.02040433f, 
    0.09708304f, 0.06310931f, 0.00391032f, 0.01143902f, 0.01332842f, 0.07341972f, 0.07063067f, -0.06994491f, 
    0.14168409f, -0.00340973f, 0.16663794f, -0.01970450f, 0.15073656f, -0.17224322f, -0.04365768f, -0.06850624f, 
    0.15505324f, -0.03178484f, 0.01633972f, 0.09558496f, -0.03770484f, 0.03714079f, 0.04481893f, 0.09355706f, 
    0.02338102f, 0.04716125f, -0.03496441f, 0.07257106f, 0.16040249f, 0.06938855f, 0.06546377f, -0.10311832f, 
    -0.12906416f, 0.10419847f, 0.06853577f, 0.03596555f, 0.06303786f, -0.08016597f, 0.06818534f, 0.00820712f, 
    0.00739698f, 0.02041286f, 0.04129965f, 0.04439948f, 0.04881492f, 0.05549612f, 0.09083527f, -0.05860288f, 
    0.05058480f, -0.16839123f, -0.15222178f, -0.16263926f, -0.00475802f, 0.01076388f, -0.03560383f, -0.05970189f, 
    -0.04974736f, -0.02902571f, 0.02885940f, -0.05764493f, 0.05798737f, -0.00550607f, 0.15704393f, -0.11865519f, 
    0.09462091f, -0.09118252f, -0.06343091f, 0.06456924f, -0.16741814f, 0.03403026f, -0.03176453f, -0.09539314f, 
    -0.02205653f, -0.04675225f, 0.06539761f, -0.09005777f, -0.01593288f, -0.02269922f, 0.15209505f, 0.09838209f, 
    0.02296409f, 0.02539763f, 0.07505064f, -0.00709980f, 0.01367692f, -0.01560079f, -0.00576605f, 0.00427102f, 
    0.00043166f, -0.00111290f, -0.00923019f, 0.02003299f, -0.02206571f, 0.10995766f, -0.00023150f, -0.04814666f, 
    -0.02017873f, -0.05103015f, 0.09616739f, 0.17429876f, 0.06728147f, -0.05887316f, -0.10801610f, 0.05956399f, 
    0.01514778f, -0.00021843f, 0.00306052f, -0.00647222f, 0.16749591f, 0.07962165f, 0.01393047f, -0.18384396f, 
    -0.03415888f, 0.04043816f, -0.03207852f, 0.05138960f, -0.00407293f, -0.10304096f, 0.03115064f, -0.04015180f, 
    -0.01138897f, -0.03454729f, -0.02609856f, 0.01178254f, 0.03334602f, 0.08614201f, 0.10769141f, 0.05827806f, 
    -0.02065311f, -0.10885317f, 0.21668914f, 0.07032264f, 0.01444679f, -0.07884541f, 0.02192781f, -0.14212668f, 
    -0.04233973f, -0.01735143f, 0.00182229f, 0.01581612f, 0.03322916f, -0.02970951f, 0.05883604f, -0.03467829f, 
    0.07033912f, -0.01999431f, 0.16562359f, 0.06824622f, -0.02305479f, -0.08659226f, 0.10162586f, -0.09159786f, 
    -0.05345633f, -0.03490070f, 0.03358322f, 0.05635395f, 0.02173471f, -0.02339151f, 0.03015958f, -0.04436162f, 
    -0.00766817f, 0.07203677f, 0.06318914f, 0.03564570f, 0.02693177f, -0.06246113f, -0.05094194f, 0.14891332f, 
    -0.10519036f, -0.12463424f, 0.04101842f, -0.16633986f, 0.15474238f, 0.10525174f, -0.00677751f, -0.01711623f, 
    -0.08609970f, 0.02451275f, -0.02241291f, 0.11820549f, -0.03347252f, 0.06457453f, 0.08100999f, -0.07203373f, 
    0.05135393f, -0.09620083f, -0.01334219f, -0.01030331f, -0.04681843f, 0.16953650f, -0.00586696f, 0.04114877f, 
    0.05128507f, -0.04849681f, -0.07840990f, 0.09236597f, -0.01919608f, -0.00629864f, 0.01739362f, -0.01826828f, 
    0.01435701f, -0.01785664f, 0.06810893f, -0.05135256f, -0.01068621f, 0.04313616f, -0.02097961f, -0.00313952f, 
    0.40152681f, 0.08559994f, 0.26361737f, 0.12166665f, 0.18543495f, -0.15113792f, -0.02360235f, -0.07948466f, 
    0.03572663f, -0.01654185f, -0.06385853f, -0.04682503f, 0.00627330f, 0.06107356f, -0.00417714f, 0.02683964f, 
    0.05151981f, 0.03500673f, -0.01978382f, 0.04083295f, -0.18418854f, 0.09298797f, -0.06725748f, 0.00176274f, 
    0.06576206f, 0.00497734f, 0.02568979f, 0.00818639f, 0.05370688f, 0.11948034f, 0.07566467f, -0.04021336f, 
    -0.01993458f, 0.02684386f, -0.03018865f, 0.06873233f, -0.01092117f, -0.08595635f, 0.02864106f, 0.05258875f, 
    0.15742730f, 0.08989534f, 0.20925613f, 0.20029113f, 0.05330207f, -0.17664082f, -0.19245705f, 0.08726071f, 
    0.04728988f, -0.04775598f, -0.02080099f, 0.02187837f, -0.04055507f, 0.10585489f, -0.05215797f, -0.05230994f, 
    -0.10957626f, 0.05821912f, 0.03876401f, -0.02690321f, -0.32360753f, -0.05221616f, 0.20667478f, 0.11536390f, 
    -0.22816487f, 0.12670143f, -0.02948140f, -0.01373315f, -0.04186232f, 0.00494954f, 0.00273029f, -0.07791258f, 
    0.00396894f, 0.04924971f, 0.00251809f, -0.04545822f, 0.02175875f, 0.07696510f, -0.01951935f, -0.05960350f, 
    0.08893712f, 0.18993555f, 0.05203250f, 0.02592382f, -0.04785813f, 0.01909480f, 0.11948510f, -0.00250634f, 
    0.02218714f, -0.07081815f, 0.05872726f, 0.05235159f, -0.06214764f, -0.07610840f, -0.00333277f, 0.04181432f, 
    0.09899353f, -0.02882787f, -0.06209594f, -0.03741881f, 0.23556533f, -0.06167507f, 0.15474109f, -0.07080763f, 
    -0.03981980f, -0.03201346f, 0.00431068f, -0.00497770f, 0.07693454f, -0.05652111f, 0.11824096f, -0.01835549f, 
    -0.04364887f, 0.06740540f, 0.03596544f, -0.05136557f, -0.02993801f, 0.05765874f, 0.06899353f, 0.04879221f, 
    0.06326829f, 0.07619785f, 0.31609476f, 0.07746805f, 0.08995212f, -0.09706815f, -0.02605296f, -0.06552172f, 
    0.00057038f, -0.00737875f, 0.01612310f, -0.08764865f, 0.03172373f, 0.01066288f, 0.01948139f, -0.01817930f, 
    -0.08951468f, 0.06444241f, -0.03836875f, -0.00315767f, -0.12634878f, -0.10724841f, 0.13337164f, -0.07814270f, 
    0.06337639f, -0.03305777f, 0.00024517f, -0.10323022f, 0.20968226f, -0.06666332f, -0.02176618f, 0.06313690f, 
    0.02019119f, -0.06511977f, 0.01486896f, -0.02524508f, 0.04269217f, 0.00802380f, -0.04838802f, 0.03058315f, 
    -0.15256156f, -0.07943020f, -0.22255999f, -0.05203240f, 0.07745335f, 0.02094826f, -0.06161384f, -0.06120227f, 
    0.03403802f, -0.08205830f, 0.08235478f, 0.04707040f, 0.11575284f, 0.01569172f, -0.00036879f, 0.05650517f, 
    -0.02206573f, 0.11569670f, 0.01529073f, -0.02027564f, -0.16395432f, -0.21530592f, -0.12231463f, -0.24385546f, 
    0.07604096f, 0.12423998f, -0.05433165f, -0.15870991f, -0.00325688f, -0.00302585f, 0.09541160f, 0.05554996f, 
    0.05606750f, 0.06103279f, -0.02987850f, 0.06316531f, 0.08527238f, 0.06215811f, -0.09634811f, 0.01279644f, 
    -0.02178217f, 0.03151136f, 0.10145614f, 0.15057217f, 0.06706548f, -0.07579079f, 0.03071512f, -0.05850215f, 
    -0.00891832f, -0.11701562f, -0.03242604f, 0.15879519f, -0.03140221f, 0.03584620f, 0.06253578f, -0.02148782f, 
    0.05425195f, 0.02010081f, 0.01910828f, -0.00894723f, 0.12010042f, 0.07561769f, 0.01543604f, -0.10634001f, 
    -0.17346470f, 0.04584605f, 0.12154233f, 0.12643114f, -0.03514616f, 0.00576794f, -0.08510652f, 0.01357007f, 
    0.08294398f, -0.02037769f, 0.05748929f, -0.02624030f, 0.08094181f, -0.00818450f, 0.13483761f, 0.08601374f, 
    0.15967415f, 0.03544069f, 0.15093723f, 0.10432038f, -0.13306716f, -0.07835060f, -0.10423232f, 0.02650860f, 
    0.05642292f, -0.08622334f, -0.01916485f, -0.11296442f, -0.06210203f, 0.02040576f, -0.03859339f, 0.00640102f, 
    -0.05275202f, 0.03626108f, -0.06550310f, 0.01094854f, -0.08590709f, -0.04141597f, -0.04067208f, -0.17796031f, 
    0.03067458f, 0.05505746f, -0.06658896f, -0.16932265f, -0.03418775f, 0.00639783f, 0.11035966f, 0.20022082f, 
    0.02561550f, -0.02239415f, 0.05912707f, 0.04700582f, 0.08151288f, 0.05887392f, 0.04712300f, 0.01756808f, 
    0.02376422f, 0.03399747f, 0.01920488f, 0.00602342f, -0.02774867f, 0.02290670f, -0.01272279f, -0.01689652f, 
    -0.00685676f, -0.01714149f, 0.02561425f, -0.03090235f, 0.00488548f, 0.02415040f, -0.00118482f, 0.02775680f, 
    -0.04228284f, -0.02780842f, 0.00376003f, -0.03676197f, 0.02524519f, 0.00919762f, -0.00079471f, 0.00433278f, 
    -0.01517174f, 0.01923123f, 0.00773161f, 0.02503399f, -0.00132622f, -0.01505719f, 0.01698983f, -0.03670400f, 
    0.02785308f, -0.04022289f, -0.03985869f, -0.02437553f, -0.00600466f, 0.03015625f, -0.00994276f, -0.01753056f, 
    -0.02185002f, 0.02368137f, 0.02309719f, -0.02220092f, -0.03790780f, -0.02313571f, -0.01134665f, 0.03263402f, 
    -0.00710647f, -0.04252008f, 0.00109176f, 0.01286142f, -0.02645320f, -0.03640823f, -0.01570217f, -0.04030352f, 
    -0.01872290f, -0.04431381f, -0.00564566f, 0.00905850f, -0.00514405f, -0.00045079f, -0.00369492f, -0.04098016f, 
    -0.00405025f, 0.03188747f, 0.00767350f, 0.00732219f, -0.04343972f, 0.01490761f, 0.00822899f, -0.01708629f, 
    -0.01780485f, -0.02024645f, -0.04329609f, -0.01900713f, 0.01811689f, -0.02993733f, 0.00834122f, 0.03077713f, 
    0.02399439f, 0.00316067f, 0.02951488f, -0.00384667f, -0.03502153f, -0.03440158f, 0.02496910f, 0.02627441f, 
    0.01069155f, -0.00702780f, 0.03242647f, -0.00903019f, 0.02468483f, -0.00232957f, 0.00502445f, -0.04006692f, 
    -0.00458241f, 0.01980622f, -0.02473701f, -0.03917861f, -0.03837469f, 0.02893320f, -0.04476943f, 0.00357936f, 
    -0.03434813f, 0.01948527f, -0.00042597f, -0.02955676f, -0.01604461f, -0.00416167f, 0.03284257f, -0.02320251f, 
    -0.03806620f, 0.02192173f, -0.03268689f, 0.01846113f, 0.00972610f, -0.00786231f, -0.00649104f, -0.00129780f, 
    0.00495734f, 0.00652277f, -0.01044587f, -0.01574775f, 0.00840853f, 0.01381414f, -0.00085461f, 0.00227602f, 
    -0.03895765f, -0.00923759f, -0.01616689f, 0.00018797f, 0.01417204f, -0.04002943f, 0.01535436f, 0.02806386f, 
    0.01209657f, -0.03525427f, 0.00832052f, 0.02713892f, 0.03002702f, -0.02610869f, -0.02819074f, 0.01972980f, 
    -0.03387107f, -0.03126380f, -0.02145970f, 0.00588838f, 0.01765582f, -0.03272244f, -0.02744289f, 0.00272540f, 
    -0.02447550f, 0.03720687f, -0.02130491f, -0.00450599f, -0.03072814f, 0.00494086f, 0.00052018f, -0.01707037f, 
    -0.04343898f, 0.03040517f, 0.01698397f, 0.00153240f, -0.00789888f, -0.02058081f, 0.01304724f, -0.04146345f, 
    0.00119421f, -0.02685185f, 0.00478000f, 0.03031932f, 0.02645535f, -0.04470303f, -0.01322673f, -0.04391932f, 
    0.01487282f, 0.01522908f, -0.01976880f, 0.00767636f, -0.00576789f, 0.01527731f, -0.03131793f, -0.01562872f, 
    -0.02864908f, -0.02561242f, 0.01393609f, 0.01479577f, -0.01972793f, -0.01747128f, 0.00951062f, 0.00740945f, 
    0.01157329f, 0.03261191f, 0.01374652f, 0.02888486f, 0.02127785f, 0.02127785f, -0.02508123f, -0.03050710f, 
    0.00391537f, -0.04271203f, -0.02335391f, -0.01955415f, -0.02775743f, -0.00487947f, 0.02785675f, -0.01962816f, 
    0.02838983f, 0.00161093f, 0.01523575f, -0.02667083f, -0.00773512f, -0.00699391f, 0.02803634f, 0.01412275f, 
    -0.04350068f, 0.00182357f, -0.00545775f, -0.01137706f, 0.00158189f, -0.03383717f, 0.02779785f, -0.01895276f, 
    -0.02552062f, -0.01348031f, 0.02199030f, -0.01073692f, 0.02960153f, -0.01489422f, -0.00054062f, -0.00751264f, 
    -0.04252051f, 0.03719875f, -0.02811878f, -0.00293120f, -0.01118260f, 0.02918587f, 0.01712174f, -0.00100929f, 
    -0.01186213f, -0.01306672f, -0.02254726f, -0.04311286f, 0.00427368f, -0.02655852f, 0.02039674f, 0.00277276f, 
    -0.02775790f, -0.02071475f, -0.01499649f, 0.00577999f, -0.00102521f, -0.03438267f, 0.00359033f, -0.04183172f, 
    0.00525734f, 0.01443629f, 0.01033547f, 0.00659790f, 0.00711239f, -0.00901603f, -0.01786255f, 0.00698883f, 
    0.00724962f, -0.00237845f, -0.03688836f, 0.01778109f, -0.01637479f, 0.03413806f, -0.01282991f, -0.03071586f, 
    -0.00928904f, 0.01850339f, 0.02268873f, -0.00500643f, -0.01052440f, -0.00929813f, -0.01594968f, -0.00252004f, 
    -0.01955272f, -0.01362896f, 0.03449254f, -0.04422573f, 0.00906328f, -0.04429307f, -0.01528046f, -0.02048608f, 
    -0.01206949f, -0.03671215f, -0.02043658f, -0.03377033f, 0.03403221f, 0.00997418f, -0.00330477f, -0.02868505f, 
    0.02384117f, -0.02125727f, -0.03742358f, -0.04425944f, -0.00506249f, -0.01958666f, 0.01878784f, -0.00262633f, 
    -0.00932705f, 0.03050366f, 0.01546680f, 0.01921488f, -0.03566290f, 0.01634129f, 0.02148899f, 0.03392275f, 
    0.02291010f, 0.02193276f, -0.00846669f, -0.03284224f, -0.02093520f, -0.04442433f, 0.02741358f, -0.04475571f, 
    -0.01644395f, -0.00804801f, -0.01501544f, 0.00263224f, 0.02711802f, 0.02695693f, -0.03827763f, 0.00223366f, 
    0.03320681f, -0.01231202f, -0.03570924f, 0.02319456f, 0.02600448f, 0.01072420f, -0.02974594f, 0.00302139f, 
    0.02806975f, 0.00612662f, -0.03085131f, 0.00297996f, -0.01513185f, -0.03217252f, -0.02888869f, -0.00988665f, 
    -0.02465805f, -0.01781390f, 0.03349413f, -0.00665997f, 0.00576640f, -0.02519053f, 0.01310766f, 0.01513664f, 
    -0.04025923f, -0.00326533f, 0.01407977f, -0.03917025f, 0.01200890f, -0.02553192f, -0.00143604f, -0.01527500f, 
    -0.01573227f, -0.00400867f, -0.02062315f, -0.03925656f, -0.03257518f, -0.00206548f, 0.01976747f, -0.03475957f, 
    -0.03633708f, -0.00511341f, 0.00043302f, -0.02185247f, 0.01894923f, -0.01247974f, -0.01389490f, -0.04096116f, 
    -0.04398168f, -0.02572273f, -0.00902489f, -0.00022903f, -0.02315830f, -0.04057152f, 0.01000194f, -0.01358430f, 
    0.02704709f, -0.01137323f, -0.01171507f, -0.01842707f, 0.01219381f, -0.00066366f, -0.00376219f, -0.02246369f, 
    -0.02999337f, 0.00908798f, 0.00720252f, 0.01996745f, -0.03117850f, 0.00221855f, 0.03152970f, 0.02392390f, 
    -0.01920281f, 0.00571995f, 0.02983893f, -0.00995586f, -0.02808942f, -0.00663795f, 0.02346788f, -0.04044934f, 
    -0.03715697f, -0.00868793f, 0.01955022f, -0.00207293f, -0.00566767f, -0.01514404f, -0.04115338f, 0.01988656f, 
    -0.03171783f, 0.02879673f, -0.02076481f, 0.01299222f, 0.01947891f, 0.00251301f, 0.02099525f, -0.01832307f, 
    0.00321605f, 0.02499374f, -0.03655850f, 0.00027964f, -0.00600225f, -0.00044946f, 0.02913172f, 0.00323017f, 
    -0.01545148f, -0.00809031f, 0.02097913f, -0.00909387f, 0.02500148f, -0.01679738f, 0.00109737f, 0.00285402f, 
    0.00347392f, -0.03035123f, -0.03182459f, -0.04041742f, 0.02037643f, -0.04104829f, -0.03317057f, -0.02810792f, 
    -0.00499367f, -0.03178181f, 0.01089690f, -0.00597315f, 0.00402808f, 0.00608379f, -0.00285483f, 0.00230103f, 
    -0.00484862f, 0.00105150f, -0.04428566f, -0.01964088f, -0.03064974f, -0.00159641f, -0.01400913f, -0.04335584f, 
    0.00711970f, 0.03109984f, 0.02335440f, 0.00282979f, -0.02891968f, -0.02368814f, -0.01845098f, -0.04459312f, 
    -0.01407609f, -0.03221472f, 0.00572854f, 0.03831535f, 0.00717396f, 0.01823169f, -0.02246474f, -0.01154973f, 
    -0.03434884f, -0.03976976f, 0.00933611f, -0.02515823f, 0.01195826f, 0.00288198f, -0.03731398f, -0.04054944f, 
    -0.04386226f, -0.02647990f, 0.01595144f, -0.01962945f, 0.02631385f, -0.04391659f, -0.01578152f, 0.00165215f, 
    -0.02408843f, -0.00509200f, -0.00797995f, 0.00655847f, -0.00839208f, -0.03664491f, -0.02637838f, -0.00014545f, 
    -0.00552098f, -0.02557946f, -0.00358418f, 0.02987825f, -0.04260585f, 0.00321171f, -0.01748468f, -0.01996045f, 
    -0.02826316f, -0.01976718f, 0.00600572f, -0.01045988f, 0.01686831f, 0.01045461f, -0.02010921f, -0.01869805f, 
    -0.03189760f, -0.02080936f, -0.02216682f, 0.00853676f, -0.04312736f, -0.03962016f, 0.02673279f, -0.03162344f, 
    -0.02437269f, -0.01583407f, 0.00509191f, -0.00720804f, -0.01788894f, -0.02063852f, 0.00356407f, 0.02589613f, 
    0.01278550f, 0.00322410f, -0.03266079f, 0.03355167f, -0.01232676f, -0.03159203f, 0.02230568f, -0.04279025f, 
    -0.02880339f, -0.02534402f, 0.01199365f, 0.03081899f, 0.02329839f, 0.01820929f, -0.02405904f, 0.03346736f, 
    -0.04256658f, -0.01661831f, -0.01958859f, -0.02025652f, 0.00038931f, 0.03212579f, 0.02764685f, 0.01797702f, 
    0.00869417f, -0.04316797f, 0.02592140f, 0.01326215f, 0.02348063f, -0.00272863f, 0.02035890f, -0.02719229f, 
    -0.02431047f, 0.01576190f, 0.00722374f, -0.01921825f, -0.02991888f, -0.02473821f, -0.02236105f, 0.03116780f, 
    -0.00560845f, -0.02351643f, 0.00026339f, -0.03831954f, 0.01045822f, -0.01252393f, -0.03483493f, 0.00166620f, 
    -0.03207488f, -0.04415702f, -0.02301225f, 0.03281823f, 0.02040187f, 0.01339444f, -0.01465489f, 0.01251556f, 
    -0.04405212f, -0.00663659f, -0.01188909f, 0.02822635f, 0.00474310f, -0.03481606f, 0.00550101f, -0.04434033f, 
    -0.03139954f, 0.02800849f, -0.04312261f, -0.02470658f, -0.03293129f, -0.02101407f, -0.01368145f, 0.01039527f, 
    0.00665128f, 0.03808694f, 0.01077439f, 0.03313213f, 0.00197946f, -0.01571750f, -0.04108060f, -0.00366825f, 
    -0.01499282f, -0.01239985f, -0.03666776f, -0.03048295f, -0.01007784f, 0.02174621f, -0.00986942f, -0.01660254f, 
    0.00225974f, -0.02198715f, 0.01095946f, -0.01562903f, -0.04182380f, 0.01927701f, 0.00867705f, -0.02622512f, 
    0.01393124f, 0.00087150f, -0.00417812f, -0.01392924f, 0.00492024f, -0.03615312f, -0.02868978f, 0.00357563f, 
    0.49522260f, 0.08577117f, 0.30945608f, 0.04152336f, -0.05631538f, 0.14630337f, 0.02259515f, 0.06507338f, 
    -0.03068245f, -0.10195939f, -0.04733185f, -0.03602199f, -0.01393412f, -0.01073158f, -0.01130131f, -0.06347245f, 
    -0.01672624f, -0.07612807f, 0.05758674f, -0.13557868f, -0.04186700f, 0.01767857f, 0.09261911f, -0.01181371f, 
    -0.00051685f, -0.08343177f, 0.08241384f, -0.01961383f, 0.06724300f, 0.00561307f, -0.04252111f, 0.05825546f, 
    0.08424946f, 0.03916199f, -0.06896415f, 0.04386268f, 0.08708652f, 0.10374553f, -0.11324939f, -0.01597441f, 
    0.02437793f, -0.05366077f, 0.27837715f, -0.01277239f, 0.07438583f, 0.13179655f, 0.10242530f, 0.04407370f, 
    0.06742006f, -0.03761562f, 0.02723890f, -0.08141500f, 0.09766532f, -0.05946753f, -0.02841157f, -0.07252867f, 
    -0.02087433f, 0.07585368f, -0.01860096f, 0.10983125f, -0.16934954f, 0.22869457f, 0.14342710f, -0.14206392f, 
    -0.24050134f, 0.15006255f, 0.00800957f, 0.03136760f, 0.02507474f, 0.08657482f, -0.03594756f, 0.09344043f, 
    0.21571599f, -0.06018516f, -0.01828058f, 0.09027644f, -0.04862408f, 0.01577279f, -0.01879128f, -0.03134442f, 
    -0.03665049f, 0.13828349f, 0.01577265f, -0.05374650f, -0.12931846f, -0.11467465f, 0.05178652f, -0.04320226f, 
    -0.02496330f, -0.03389921f, 0.04988346f, 0.07819694f, 0.14408784f, -0.04877445f, -0.02685305f, 0.09293875f, 
    0.15144143f, 0.05951816f, 0.06420109f, 0.01372934f, 0.27969107f, 0.17317729f, -0.03902254f, -0.07137994f, 
    0.01000557f, -0.05790522f, 0.05604388f, 0.08227066f, 0.07771514f, -0.03854463f, 0.06164011f, 0.06654284f, 
    0.00331743f, -0.02115091f, 0.10080433f, -0.00497807f, 0.00471486f, 0.07420436f, 0.17810154f, -0.02739972f, 
    0.08252329f, 0.08249048f, -0.06449913f, 0.06083589f, 0.03299629f, -0.12675630f, 0.00208248f, 0.03901879f, 
    0.12117659f, -0.07546166f, 0.01299053f, -0.03120544f, 0.07027247f, 0.02722097f, 0.08916910f, -0.02369676f, 
    -0.25376588f, -0.13351896f, 0.03480338f, 0.03458391f, -0.17175898f, 0.00397396f, 0.21929298f, 0.01173618f, 
    0.16081993f, 0.06165097f, -0.00707622f, -0.01874065f, 0.09948850f, 0.10265225f, 0.07696041f, 0.06654866f, 
    0.02211238f, -0.00617044f, -0.03656111f, 0.09771872f, -0.06089962f, 0.10687216f, -0.11509284f, -0.02291384f, 
    0.22804144f, -0.23727126f, 0.17475854f, 0.10767704f, 0.18676695f, 0.09270767f, 0.04717047f, 0.08528858f, 
    0.03913504f, 0.08663713f, 0.01849120f, -0.01299930f, 0.04645722f, 0.19347781f, 0.02420823f, 0.09485520f, 
    0.02859151f, -0.04013491f, -0.04839241f, -0.09157300f, -0.10184290f, -0.19968069f, 0.09129132f, -0.01968230f, 
    0.07099219f, 0.05447445f, 0.03748479f, 0.05680658f, -0.06741379f, -0.03585671f, 0.09780970f, -0.01548105f, 
    -0.14535907f, -0.06638227f, -0.08763812f, -0.01321906f, -0.03184544f, 0.15287443f, 0.10405584f, -0.00291927f, 
    0.04087736f, 0.11371395f, 0.04374636f, 0.05812002f, 0.01102838f, 0.07933047f, 0.02074208f, 0.12942128f, 
    -0.00161685f, -0.03943739f, -0.00886674f, 0.05321530f, 0.07009167f, -0.02907972f, -0.02841926f, -0.06077481f, 
    0.06792975f, -0.24746472f, -0.01049818f, -0.13215847f, -0.01472326f, 0.31369534f, -0.06174764f, -0.11077888f, 
    -0.11643697f, -0.01571988f, 0.04588212f, 0.06631315f, -0.05798349f, -0.07734501f, -0.04282909f, 0.05783880f, 
    0.04914954f, -0.05573816f, 0.00021978f, 0.06295181f, -0.00248125f, 0.15264371f, -0.04215493f, 0.03159337f, 
    0.10312831f, -0.16150779f, -0.04644863f, -0.14055349f, -0.03297364f, -0.07403336f, 0.03115428f, -0.06238212f, 
    -0.14422333f, -0.00862285f, 0.00502188f, 0.04718768f, 0.02351324f, -0.01573847f, -0.00627027f, 0.01968464f, 
    0.08509678f, 0.09927238f, 0.09339697f, 0.04624200f, -0.34457800f, -0.17399697f, 0.10124838f, 0.03644430f, 
    0.05371859f, -0.00834744f, 0.15764725f, -0.06729780f, -0.05956074f, -0.13145514f, 0.08755447f, 0.07538458f, 
    -0.06175844f, -0.05104161f, 0.08689900f, -0.07112100f, -0.13005690f, 0.13898896f, 0.19020680f, -0.00155643f, 
    0.24090552f, 0.25014701f, 0.05675353f, 0.09494789f, 0.14455087f, 0.04233273f, 0.02481774f, 0.08894528f, 
    -0.01388360f, 0.10255612f, 0.05327958f, 0.01884842f, 0.09531704f, 0.06509833f, 0.05358522f, 0.15777558f, 
    0.00558890f, -0.03588898f, 0.17326723f, 0.11455736f, 0.31189591f, -0.22873016f, 0.02542776f, -0.00877551f, 
    0.21909826f, -0.06220524f, 0.02916935f, 0.01467622f, -0.02005899f, 0.10922328f, -0.08717369f, 0.02682865f, 
    -0.06402107f, 0.06409375f, -0.04634730f, -0.00606494f, 0.02150676f, 0.01232286f, -0.04671183f, -0.05527850f, 
    0.25778514f, 0.00226130f, 0.00654230f, -0.00886041f, -0.02469408f, 0.01301528f, 0.05793661f, 0.05629409f, 
    0.05311731f, 0.02745821f, 0.11890047f, -0.02106972f, 0.00514324f, 0.07360341f, 0.11516032f, 0.11196329f, 
    -0.04335077f, -0.17789426f, -0.09573462f, -0.04519628f, -0.08817999f, -0.23678772f, 0.12763765f, -0.05954614f, 
    0.22137381f, -0.07010562f, 0.00047952f, -0.04009423f, -0.02162979f, 0.08986628f, -0.01562097f, 0.03205113f, 
    -0.03594490f, 0.04782296f, 0.07328504f, -0.14249296f, 0.03724379f, 0.00614982f, -0.08349690f, -0.04536394f, 
    0.36902630f, -0.27423164f, 0.05492189f, 0.05253303f, 0.14664328f, 0.06829122f, -0.02623703f, -0.10060938f, 
    0.17649698f, 0.22400315f, 0.01570291f, -0.03488702f, -0.04220983f, 0.08816669f, 0.08489855f, -0.09718023f, 
    0.02471096f, -0.05748747f, -0.02008842f, -0.01539218f, 0.59456873f, -0.36093482f, 0.04250618f, 0.07137360f, 
    0.01593231f, 0.05236271f, 0.00039911f, 0.01065795f, -0.05187160f, 0.06577057f, 0.00580157f, 0.03873460f, 
    -0.05869420f, -0.02443956f, 0.03779047f, 0.05970179f, 0.02874089f, 0.04070853f, 0.12057439f, 0.14564788f, 
    -0.08403961f, -0.12015053f, 0.42878276f, 0.02541824f, 0.37629101f, 0.05065703f, 0.14805783f, -0.16246204f, 
    0.06837177f, 0.15116611f, -0.00351158f, 0.00442513f, -0.13796704f, 0.12391406f, -0.01211236f, 0.05519115f, 
    0.07928818f, 0.03990911f, 0.01109415f, 0.11126117f, -0.00781477f, 0.23939642f, -0.22236572f, 0.04202770f, 
    0.16888066f, 0.01333169f, -0.04360209f, -0.09311827f, 0.09356232f, -0.06660596f, -0.17657924f, 0.04613182f, 
    0.07184318f, 0.04116875f, 0.06969982f, 0.18673797f, -0.02433783f, 0.20012233f, -0.04491926f, 0.12089880f, 
    -0.05853239f, 0.13911350f, -0.00137600f, -0.05867371f, 0.02976889f, 0.00672611f, -0.03451219f, -0.00062762f, 
    0.03117870f, 0.03173064f, 0.04841806f, 0.02944541f, -0.10181949f, 0.01972349f, -0.02037316f, -0.00063388f, 
    0.06095653f, 0.11172851f, 0.04130115f, 0.03720128f, -0.24896297f, 0.08227531f, 0.30743846f, 0.03029336f, 
    0.14712203f, -0.02804281f, 0.03422205f, -0.01958673f, 0.02327113f, 0.07032928f, 0.00671705f, -0.03105788f, 
    0.10894086f, -0.02169807f, -0.02231653f, 0.05749301f, -0.03097946f, -0.11349462f, 0.11785013f, 0.08314346f, 
    0.02369393f, -0.04025857f, 0.10725035f, 0.12159960f, 0.27227592f, 0.02845228f, 0.08228297f, -0.04129317f, 
    0.05631455f, 0.04309071f, 0.09301773f, 0.02503766f, -0.07088330f, -0.01115504f, 0.11369240f, 0.05785752f, 
    -0.05851443f, 0.02196703f, 0.01936515f, 0.00798235f, 0.13738576f, 0.06040404f, -0.15383133f, -0.11547292f, 
    0.28746915f, -0.08626219f, 0.01635729f, 0.00084076f, 0.03572327f, -0.02616413f, -0.14548892f, -0.09590668f, 
    0.02906848f, 0.13834253f, 0.05854492f, 0.08481076f, -0.02118849f, -0.08411550f, 0.00497205f, 0.04857130f, 
    -0.06745513f, 0.24384828f, 0.11057682f, -0.01550317f, -0.11119676f, -0.00521501f, 0.09837582f, 0.08753923f, 
    -0.10724745f, -0.11765962f, -0.07823814f, 0.06811966f, 0.18935299f, 0.00137898f, -0.02149696f, -0.09284230f, 
    -0.08942579f, 0.02759665f, -0.16760352f, -0.02731675f, -0.05443110f, 0.39244220f, 0.08639441f, -0.10924115f, 
    -0.16478157f, -0.05310009f, 0.14932950f, -0.05483190f, 0.02417281f, -0.06960521f, -0.01696602f, 0.02441061f, 
    0.01393854f, -0.05786899f, -0.02195597f, 0.02269758f, 0.01958635f, -0.18465616f, -0.03698743f, -0.01554725f, 
    0.07760955f, -0.11531201f, -0.27197105f, -0.05183044f, 0.02429012f, 0.05758509f, -0.05701720f, 0.06216437f, 
    0.03353585f, -0.07792602f, 0.01734556f, -0.06558315f, -0.04709544f, 0.02786888f, 0.00467889f, 0.13864164f, 
    -0.01683425f, 0.09764182f, 0.07823181f, 0.10269901f, 0.30769470f, 0.01265986f, -0.18933131f, -0.12384230f, 
    -0.07934407f, -0.08313281f, -0.05210306f, 0.03658434f, -0.02599648f, 0.16465142f, -0.06109688f, 0.00662750f, 
    -0.05424023f, 0.00653871f, 0.03128356f, -0.07687150f, 0.06365806f, 0.01055424f, 0.19881816f, -0.04623901f, 
    -0.22680017f, -0.05409899f, 0.24393524f, -0.08452339f, 0.21832220f, 0.03149756f, 0.11105604f, -0.06139410f, 
    -0.02347407f, -0.08652613f, 0.08638413f, 0.04066795f, -0.05027584f, 0.03048002f, 0.02289257f, 0.03911589f, 
    0.05077947f, 0.08377907f, 0.06854244f, 0.08443543f, -0.11353088f, 0.27487627f, 0.07387982f, 0.07968337f, 
    -0.16398114f, 0.11355601f, 0.00607440f, 0.00843521f, -0.01273711f, -0.08456627f, -0.03093151f, 0.04893488f, 
    -0.03839063f, -0.04180608f, -0.00903102f, 0.02724961f, -0.00097346f, 0.12742932f, -0.04083885f, 0.05107586f, 
    -0.00473879f, 0.03289454f, 0.01541947f, -0.01567627f, 0.02074041f, -0.04181488f, 0.03258137f, -0.05034293f, 
    -0.02448399f, 0.01499168f, 0.07705634f, -0.10480127f, 0.02967532f, 0.04252671f, -0.01095780f, -0.02343570f, 
    0.01903669f, 0.10381767f, -0.02512694f, 0.12323985f, -0.19749367f, -0.03499211f, -0.04814420f, -0.14814056f, 
    -0.14089453f, 0.20452546f, 0.03638843f, 0.00634885f, 0.04347824f, 0.08687560f, 0.06635557f, 0.07796618f, 
    0.04906465f, 0.01666886f, 0.01517583f, 0.02949266f, -0.08150646f, -0.06973735f, -0.05858219f, -0.00741089f, 
    0.09619154f, -0.14834467f, -0.06137750f, 0.01812415f, 0.14508577f, -0.01197555f, 0.11190287f, 0.00046881f, 
    0.04869264f, 0.12113401f, 0.12621462f, 0.03182229f, -0.00012272f, -0.01648073f, 0.11053660f, 0.05017130f, 
    0.03126803f, -0.01364044f, -0.15337335f, 0.01999003f, -0.25766939f, -0.25150594f, 0.25850382f, -0.02013556f, 
    0.02978587f, -0.14194764f, -0.20030072f, 0.02386697f, 0.02841875f, -0.09573500f, -0.07561056f, -0.09910118f, 
    0.06592111f, 0.16451180f, 0.01330547f, -0.00908346f, -0.01836788f, 0.06165646f, -0.04459959f, -0.09039319f, 
    -0.02583126f, 0.02884267f, 0.12800863f, -0.13436086f, -0.03012047f, 0.03424235f, -0.11995412f, 0.05485050f, 
    0.02606298f, 0.04614498f, -0.16451626f, -0.00268483f, 0.05717980f, 0.04786914f, -0.01854466f, -0.06529119f, 
    0.06545726f, -0.11978600f, -0.04638478f, -0.02883722f, 0.17683059f, -0.25810406f, 0.02573880f, 0.03991052f, 
    0.02157959f, -0.00553614f, 0.06182063f, 0.00959227f, 0.05651110f, -0.02505379f, -0.02713235f, -0.07634934f, 
    0.05066228f, -0.01850053f, -0.08414029f, -0.03258947f, 0.02064971f, 0.06087532f, -0.06618480f, 0.04506576f, 
    0.02044865f, 0.13293892f, 0.12895131f, -0.00906489f, 0.02149717f, -0.02490881f, 0.00587973f, -0.00612774f, 
    0.10496441f, 0.08045050f, 0.05397484f, 0.06149859f, 0.04318362f, 0.01066390f, 0.03113052f, 0.01345925f, 
    0.11496470f, 0.11172808f, 0.05057924f, 0.17535305f, 0.22196978f, 0.09199972f, 0.14410792f, -0.03142754f, 
    0.15118153f, -0.00570029f, -0.02679065f, -0.08612356f, -0.01635729f, -0.07251427f, 0.14565554f, 0.00458199f, 
    0.05989636f, -0.00986261f, 0.07301722f, 0.01140735f, 0.05789353f, 0.03897515f, 0.09436301f, 0.04617751f, 
    0.27209881f, 0.08572525f, -0.00269676f, 0.13389564f, -0.04107919f, 0.15369214f, 0.03685061f, 0.08788841f, 
    -0.19966055f, 0.11870737f, 0.04782606f, -0.02302367f, -0.11197338f, -0.05984240f, -0.07489435f, -0.01480686f, 
    -0.02914587f, 0.01211692f, 0.00426635f, -0.04230019f, 0.20287316f, -0.10164648f, -0.08975892f, 0.11430664f, 
    0.05834259f, 0.10270914f, -0.00944042f, 0.02665669f, 0.02436198f, 0.08725184f, -0.00484436f, 0.06437515f, 
    0.02303395f, 0.02084512f, 0.09207756f, -0.01482096f, 0.09400409f, -0.12163264f, -0.14318588f, 0.01188939f, 
    0.07119820f, 0.10258655f, 0.01164866f, 0.15421531f, 0.18507403f, -0.06710608f, -0.09951820f, -0.05187169f, 
    -0.02335033f, -0.03454550f, 0.04152504f, -0.03999744f, 0.03325633f, 0.01936796f, -0.12504344f, 0.03971328f, 
    -0.04004888f, 0.06985474f, 0.01068637f, 0.06949344f, -0.11111799f, -0.25357616f, 0.03361314f, -0.14352565f, 
    0.14539590f, -0.04726888f, -0.05933649f, 0.07423653f, 0.02073576f, 0.10591464f, -0.04691383f, -0.01868739f, 
    0.07852951f, -0.01945345f, -0.07652810f, 0.07936632f, 0.06077963f, 0.00894461f, 0.15269805f, -0.06633369f, 
    0.00100989f, 0.06877787f, 0.13375695f, -0.17372465f, -0.26764238f, -0.06095841f, -0.07156684f, -0.02715793f, 
    0.10701063f, -0.04274809f, 0.00363621f, -0.00653873f, 0.07642978f, 0.09863430f, 0.06809941f, -0.03617397f, 
    0.11026637f, -0.06820148f, -0.11990190f, 0.03956223f, -0.06455243f, -0.17778526f, 0.13859174f, 0.12989959f, 
    -0.14389382f, 0.16738199f, -0.06776156f, 0.05328492f, 0.09765502f, 0.01471857f, -0.05635406f, 0.00625567f, 
    0.12400577f, 0.07450085f, -0.07267599f, 0.08386139f, 0.05559466f, -0.12202459f, -0.07477608f, 0.04544711f, 
    0.19711688f, -0.12035727f, -0.11554281f, 0.08351021f, -0.10050603f, 0.04602485f, 0.14362609f, -0.07358777f, 
    0.19536306f, -0.06035046f, 0.05666703f, 0.08802035f, -0.03163946f, 0.08195151f, -0.12907183f, -0.01108522f, 
    -0.12660913f, -0.04400938f, -0.08916803f, 0.02525437f, 0.10203247f, -0.12018827f, -0.01256954f, -0.09319363f, 
    -0.13783130f, 0.01076817f, 0.07464785f, 0.10376072f, -0.03724162f, 0.07650843f, 0.07612458f, 0.00147644f, 
    -0.04560559f, -0.06908389f, -0.05079044f, 0.09060016f, 0.07282142f, 0.06480257f, 0.04667719f, 0.13089138f, 
    0.02382090f, 0.37372169f, 0.02795902f, 0.20561597f, 0.28795534f, 0.01703613f, -0.00595241f, 0.00136525f, 
    -0.07850412f, 0.01618039f, -0.00259056f, 0.02266489f, -0.02821390f, -0.01969255f, -0.04079146f, -0.10738082f, 
    -0.02470640f, 0.12898669f, 0.01520279f, -0.00683153f, 0.18296485f, 0.17685021f, 0.17603916f, 0.06877726f, 
    0.10449952f, -0.08725306f, 0.05778617f, -0.06502867f, 0.04994377f, -0.04518957f, 0.08712305f, -0.00247250f, 
    -0.01534062f, -0.01779608f, -0.03423253f, -0.05242851f, 0.06228279f, 0.03672475f, 0.10642173f, 0.09810881f, 
    0.21634479f, 0.14571698f, -0.12298445f, 0.08772977f, -0.01919567f, -0.01069473f, 0.07071533f, -0.09448727f, 
    -0.00226798f, -0.04759684f, 0.08740583f, 0.05357521f, -0.05293716f, -0.08870102f, 0.15371402f, 0.12479342f, 
    -0.01218444f, -0.00264717f, 0.03805617f, 0.03909888f, 0.10297849f, -0.12215638f, -0.06704096f, -0.23722476f, 
    0.00830474f, 0.02079833f, 0.01544717f, -0.04582397f, -0.07290298f, 0.01013601f, -0.00336886f, -0.02268202f, 
    0.09977227f, -0.04633059f, 0.12943290f, -0.05042397f, -0.05197614f, 0.09550923f, -0.02426684f, 0.02220297f, 
    0.03496283f, 0.17621899f, -0.02522573f, 0.03349257f, -0.01085845f, 0.01198826f, -0.03226495f, -0.11851043f, 
    0.04286069f, -0.05614569f, 0.09135675f, 0.05784334f, 0.05702996f, -0.08753111f, 0.04598636f, 0.02058092f, 
    0.03666741f, -0.02950104f, -0.00841278f, -0.11618714f, 0.01052636f, -0.22951962f, 0.16038829f, -0.08524804f, 
    0.02523386f, 0.03725863f, 0.03255343f, -0.00261150f, -0.00046266f, -0.03010372f, 0.00649887f, 0.11013637f, 
    0.04353328f, -0.08546977f, 0.03861490f, -0.05788632f, -0.09755464f, -0.13685897f, 0.06323466f, -0.04849335f, 
    0.00130655f, -0.35334668f, 0.07154195f, -0.10290581f, 0.05389631f, 0.01534897f, 0.14693812f, 0.08282838f, 
    0.10097656f, 0.11891969f, -0.10869414f, -0.09121108f, 0.02456333f, 0.04733798f, -0.02429880f, -0.18569139f, 
    -0.07186785f, -0.07346052f, 0.02581072f, -0.07661635f, -0.00144360f, 0.00599299f, -0.00133080f, 0.18906523f, 
    0.03178481f, 0.09442191f, 0.16548610f, -0.03044762f, 0.20232661f, 0.09928133f, 0.05665108f, 0.05148186f, 
    -0.04427756f, 0.13274562f, 0.08203391f, 0.04787274f, 0.07577753f, 0.00462369f, -0.13226128f, -0.03056952f, 
    0.03721921f, -0.01251825f, -0.10083418f, 0.06130069f, -0.05977070f, 0.11219089f, 0.08432312f, 0.13566336f, 
    0.17944948f, 0.01571831f, 0.01404080f, 0.01466672f, -0.12620740f, 0.02559975f, -0.06268553f, 0.06218896f, 
    0.09628072f, -0.02195678f, 0.02229764f, 0.15041208f, -0.15373728f, 0.28403807f, 0.10108976f, 0.23810938f, 
    -0.17340089f, 0.07435168f, 0.11524072f, 0.08998547f, -0.09841222f, 0.12416258f, 0.06591735f, 0.03235640f, 
    0.02923430f, -0.10196434f, 0.04381973f, -0.04844461f, 0.00272561f, 0.06311298f, 0.01132843f, -0.02259324f, 
    -0.04804309f, 0.04139213f, 0.16297801f, -0.06098199f, 0.11086208f, -0.17910443f, 0.02393090f, 0.01108130f, 
    -0.08904308f, 0.02274597f, 0.09272663f, 0.00087663f, 0.02628477f, -0.00914444f, 0.09197644f, 0.09960988f, 
    0.04795583f, 0.07590625f, 0.12810449f, 0.01940078f, -0.35218880f, 0.30055371f, 0.22225937f, 0.07299011f, 
    0.09396235f, -0.04565576f, -0.03332840f, 0.05930806f, -0.10486799f, 0.04520035f, -0.12412665f, -0.00757041f, 
    0.07214990f, 0.00234583f, -0.02658223f, 0.03079654f, -0.04796853f, 0.01185328f, -0.03552282f, 0.10360497f, 
    -0.12016130f, 0.17530940f, -0.13990837f, 0.06551152f, -0.38272277f, 0.01458328f, 0.03454799f, 0.02931536f, 
    0.01537067f, 0.07836169f, 0.05288149f, -0.01378765f, 0.16347392f, -0.02286158f, 0.00279746f, 0.05659160f, 
    -0.09255839f, 0.03032938f, -0.03647879f, 0.03259053f, 0.28173172f, -0.32131097f, 0.04977907f, -0.06683534f, 
    -0.25306368f, 0.10994928f, 0.15851480f, -0.00715731f, 0.02696058f, -0.04749175f, 0.05326689f, -0.01300286f, 
    -0.01150932f, 0.05248876f, 0.00404937f, 0.07688614f, -0.07863942f, -0.02656000f, -0.05314802f, -0.00460390f, 
    -0.26982066f, 0.00933629f, -0.03688971f, 0.10394888f, -0.06087958f, 0.18799077f, 0.07899732f, 0.12781866f, 
    0.03274235f, 0.03129358f, -0.05982186f, 0.02368453f, 0.02287052f, 0.01204650f, -0.04015447f, -0.08348101f, 
    0.05066679f, -0.13939473f, -0.02491112f, -0.10963102f, -0.07441757f, -0.09280510f, 0.17744508f, 0.04930628f, 
    0.19912918f, -0.19880231f, -0.10802080f, 0.02157412f, 0.04468663f, 0.03183188f, -0.04876744f, -0.00006348f, 
    0.04357389f, 0.04886219f, 0.00060293f, -0.03090612f, -0.06900948f, 0.03091631f, 0.01539658f, -0.16409408f, 
    0.02454801f, -0.04111638f, 0.02806118f, -0.02446140f, 0.00398695f, 0.03781132f, -0.00926283f, -0.01973648f, 
    0.02408618f, -0.03354405f, 0.02192140f, 0.00999439f, -0.04124260f, 0.03303837f, -0.00090010f, -0.04487761f, 
    0.03332179f, 0.01999120f, -0.00536439f, 0.02973447f, -0.04052973f, 0.00340497f, 0.00309320f, -0.00906307f, 
    0.01926276f, -0.00085781f, -0.03919083f, 0.00288783f, -0.02603360f, -0.02395229f, -0.01070489f, -0.01764006f, 
    -0.01293810f, 0.00267751f, -0.04129397f, 0.03244228f, 0.01107980f, -0.00976254f, 0.01567380f, 0.02793547f, 
    0.02921244f, -0.03835218f, 0.00269386f, -0.03424288f, 0.03047077f, 0.03376185f, -0.03344683f, 0.00627235f, 
    -0.01702569f, -0.03428946f, -0.01860294f, 0.01942288f, 0.02589515f, -0.01206309f, -0.01356516f, -0.00268973f, 
    0.01099302f, -0.02190914f, -0.00400098f, 0.02568861f, -0.02104512f, -0.00979903f, -0.00984389f, -0.02219620f, 
    0.03319213f, -0.00020468f, -0.01242153f, -0.03554840f, -0.03223059f, 0.00660374f, -0.02425752f, -0.01678368f, 
    -0.00514545f, -0.03350778f, 0.02953437f, 0.00073761f, -0.02788442f, 0.02487698f, -0.00562559f, -0.04526317f, 
    -0.01802414f, 0.02155953f, -0.02567683f, -0.03639429f, 0.02502335f, -0.01340940f, 0.01065542f, -0.01023131f, 
    -0.03061038f, -0.00458755f, -0.01523728f, -0.02071457f, 0.01080557f, -0.03558806f, -0.00854370f, 0.00627268f, 
    -0.01503043f, -0.01596444f, -0.00633316f, -0.00351219f, -0.00764913f, -0.03995839f, 0.00592028f, -0.01065225f, 
    -0.04045337f, -0.00522592f, -0.01753335f, 0.00050211f, -0.01661122f, -0.04136581f, 0.02380904f, 0.00555187f, 
    0.01769197f, -0.00847225f, -0.04307117f, -0.02574755f, 0.03012228f, 0.01079915f, 0.01002491f, 0.02058753f, 
    -0.00287668f, -0.02788431f, -0.00582909f, -0.03038933f, 0.02145042f, 0.02488411f, -0.00411273f, -0.00794214f, 
    -0.03035798f, 0.01053393f, 0.02482721f, 0.03130612f, -0.03204200f, 0.01083924f, 0.01967360f, 0.02936170f, 
    -0.02428302f, 0.03023175f, -0.03445509f, -0.04151026f, -0.00453597f, -0.01732765f, -0.04054805f, -0.01648874f, 
    -0.00103360f, 0.01543969f, -0.03394836f, 0.01580815f, -0.03715098f, -0.01042350f, 0.03297104f, -0.01448024f, 
    -0.02254148f, 0.03204124f, -0.03797020f, -0.03778279f, -0.02598823f, 0.01557662f, -0.03290701f, 0.01807011f, 
    -0.00008432f, 0.01114175f, 0.01410252f, 0.01971363f, 0.03613733f, 0.00991893f, -0.01139138f, -0.03523725f, 
    -0.02388554f, -0.02041156f, 0.01791958f, 0.02142654f, -0.02084338f, -0.01763461f, -0.04068441f, 0.02978480f, 
    -0.01109974f, 0.00440076f, -0.03293113f, 0.00072799f, 0.03113041f, 0.02409901f, 0.00659365f, -0.00340738f, 
    -0.03924476f, -0.01639628f, -0.03363569f, -0.03590318f, 0.00200638f, -0.01461006f, -0.02323362f, -0.01786327f, 
    -0.03943048f, 0.03312673f, 0.02688639f, -0.00754011f, -0.03026738f, -0.01800000f, -0.00393800f, -0.04371966f, 
    -0.04512364f, -0.00875170f, -0.01189393f, -0.01062361f, 0.00168389f, 0.01531983f, -0.03592660f, -0.00729246f, 
    -0.02674419f, 0.02139829f, -0.01236696f, 0.01309467f, 0.00096702f, -0.02771995f, 0.02273775f, 0.00346332f, 
    0.02963658f, 0.02891795f, -0.01467641f, 0.01292135f, -0.02918929f, 0.00792568f, 0.00662782f, 0.03904304f, 
    -0.04501937f, 0.02289245f, 0.02543885f, -0.01103822f, -0.00799082f, 0.02336159f, -0.02079928f, 0.01992022f, 
    0.02073203f, -0.00589497f, -0.00198070f, -0.01813301f, -0.02551612f, -0.02536119f, -0.03326958f, 0.02946501f, 
    0.00370039f, 0.01341727f, -0.03208305f, 0.00309181f, 0.03261334f, 0.00972902f, -0.01579425f, -0.02302177f, 
    0.00801865f, 0.02302376f, -0.02850179f, 0.00463671f, 0.02379973f, 0.02633827f, 0.00298131f, 0.00052413f, 
    -0.00214107f, 0.00458196f, -0.00407299f, 0.01202914f, 0.02124776f, -0.03250057f, 0.00488017f, -0.03292870f, 
    -0.01625868f, 0.01524729f, -0.00142007f, 0.01815932f, -0.03486297f, 0.02979955f, -0.02321489f, 0.00084295f, 
    0.02864149f, -0.00466585f, -0.04270961f, -0.03068747f, -0.00237999f, 0.00369703f, 0.01134173f, 0.00865864f, 
    0.01901451f, 0.00253148f, 0.00292353f, -0.01582230f, -0.03809593f, 0.00332757f, 0.03334285f, -0.00828990f, 
    -0.00039317f, 0.00012629f, -0.03682833f, 0.02434347f, -0.03698045f, 0.00022814f, -0.03657221f, 0.01868115f, 
    -0.01378028f, 0.02145505f, -0.03218048f, -0.03460906f, 0.02163791f, -0.04130145f, 0.02424865f, 0.01911967f, 
    0.01642441f, 0.01806566f, 0.00628192f, -0.01552996f, 0.01892430f, -0.02942728f, -0.01805085f, 0.03129403f, 
    -0.03707197f, -0.03299654f, -0.01795060f, 0.02463887f, -0.00794372f, 0.00861479f, -0.03112460f, -0.01453463f, 
    -0.03010563f, -0.04482780f, -0.01198980f, 0.01207442f, 0.01699073f, 0.01125978f, -0.03854020f, 0.03107259f, 
    0.00096385f, -0.01543696f, -0.01352409f, -0.00053756f, 0.01686530f, 0.02651375f, 0.02318536f, -0.02671213f, 
    -0.04241487f, 0.01644427f, 0.01031110f, -0.01518207f, -0.04449550f, -0.04490881f, 0.00296001f, 0.03132250f, 
    0.01114715f, -0.03931935f, 0.02309344f, 0.02515176f, -0.02224166f, 0.00784835f, -0.03384634f, 0.00231653f, 
    0.00564525f, 0.01158560f, -0.00964797f, -0.04514404f, -0.02060213f, -0.00178677f, -0.02784023f, -0.03549643f, 
    -0.03472254f, -0.00239787f, -0.01830631f, -0.02808195f, -0.00770791f, 0.00495868f, -0.02574576f, -0.02091986f, 
    -0.04231228f, -0.02747011f, -0.00633345f, 0.02519733f, 0.00151771f, -0.03120439f, -0.03750587f, 0.02770127f, 
    0.02263368f, 0.00121451f, -0.01765617f, -0.04053726f, 0.01555394f, -0.02535798f, 0.02614770f, 0.02677254f, 
    -0.03126710f, 0.01028327f, -0.03563786f, 0.01480967f, -0.03693794f, 0.01857004f, -0.02693883f, -0.02175994f, 
    0.01652056f, -0.03695580f, -0.02443304f, -0.02137135f, 0.01987432f, 0.01270689f, -0.02443894f, -0.02834848f, 
    -0.01166661f, 0.00922272f, 0.01076444f, -0.03180558f, -0.04374551f, 0.01826219f, -0.01467383f, -0.00362275f, 
    0.00998548f, -0.01554470f, 0.01408419f, -0.03711447f, 0.00276039f, -0.00657824f, -0.00687114f, -0.00080646f, 
    0.01222119f, -0.03067429f, -0.01132396f, -0.03987388f, -0.00543923f, -0.00078823f, -0.01922695f, -0.00272679f, 
    -0.03733585f, 0.01437630f, -0.00538414f, -0.00988664f, 0.01900940f, 0.01531051f, 0.00965689f, -0.03618506f, 
    0.02139513f, -0.02133283f, 0.02386710f, -0.03550193f, -0.01431014f, 0.02041426f, 0.00081894f, 0.01842156f, 
    -0.03433520f, -0.03378248f, -0.04452829f, -0.01097373f, -0.04450785f, -0.02324771f, 0.01304481f, -0.00971525f, 
    -0.04234147f, -0.03708676f, -0.01976912f, 0.02028852f, 0.01897129f, 0.01727437f, 0.00879859f, -0.03543721f, 
    0.01220541f, -0.04277696f, -0.03253857f, -0.03103012f, 0.02652973f, 0.01064515f, 0.00106021f, -0.03261397f, 
    0.01249465f, -0.00719388f, 0.00785212f, 0.01038827f, -0.02764354f, -0.01083491f, 0.00273647f, -0.03609744f, 
    -0.02018285f, -0.00763191f, 0.00095935f, 0.01419450f, -0.00916403f, 0.00348417f, 0.03012996f, -0.03290578f, 
    0.02897358f, 0.02399527f, 0.01110351f, -0.04428022f, 0.02855899f, -0.00125488f, 0.01823512f, -0.03355243f, 
    -0.00132752f, -0.02621069f, 0.00915381f, -0.01516358f, -0.02431222f, -0.04317060f, 0.01845049f, -0.00828395f, 
    -0.01954563f, 0.00399977f, -0.02486990f, -0.03869539f, -0.04410220f, 0.00413816f, -0.04374832f, -0.03906453f, 
    -0.01425460f, 0.02600294f, -0.02524378f, 0.03000990f, 0.03148070f, 0.02435353f, -0.04279090f, -0.02765368f, 
    0.02267624f, -0.02519045f, 0.01222451f, -0.03208571f, -0.01192438f, -0.02433972f, 0.03301121f, -0.04431323f, 
    0.00339913f, -0.01590246f, 0.01821461f, -0.03373098f, 0.02467292f, -0.04389914f, -0.03487459f, 0.00604376f, 
    0.02123397f, -0.03461198f, -0.02389358f, 0.00650394f, 0.02833486f, -0.02611846f, -0.00305675f, -0.01680922f, 
    -0.01091461f, -0.03637617f, -0.02219941f, 0.00531581f, 0.01272279f, -0.03453516f, -0.03735461f, -0.03686742f, 
    -0.03567568f, -0.01642415f, -0.03369516f, 0.00551584f, 0.01479710f, -0.01439226f, 0.00183676f, -0.03855398f, 
    -0.00572929f, -0.00485748f, 0.00971761f, 0.00471552f, 0.03233168f, -0.03897760f, -0.00311140f, -0.00335041f, 
    0.02895384f, -0.03297175f, 0.03549019f, -0.01209946f, -0.02516155f, -0.01928586f, 0.00010628f, 0.01720911f, 
    0.02732230f, 0.03526621f, 0.01759995f, 0.02162287f, 0.00148738f, -0.03211440f, -0.04390613f, 0.01604550f, 
    -0.01927365f, -0.03700769f, -0.02637047f, 0.00381776f, -0.03216337f, -0.03856894f, -0.04150527f, -0.03713497f, 
    -0.01078899f, -0.01393405f, -0.01895658f, -0.01282757f, 0.00888393f, -0.02628903f, -0.03927188f, -0.01779781f, 
    -0.01970888f, -0.01134869f, -0.00466580f, -0.04139710f, -0.01543042f, -0.03539116f, -0.02997495f, -0.01370274f, 
    -0.01175944f, -0.01919674f, 0.03123852f, 0.02065239f, 0.00271739f, -0.00536085f, -0.00769864f, -0.04452118f, 
    0.00408082f, -0.02137595f, 0.01386878f, 0.00528583f, 0.00327057f, -0.02784150f, 0.01687249f, 0.01304500f, 
    0.00230924f, -0.01868196f, -0.00040187f, -0.02390011f, 0.00448360f, 0.01825504f, 0.03078002f, -0.01611266f, 
    -0.01473911f, 0.00497276f, 0.01446311f, -0.03381912f, 0.02607037f, -0.00552154f, 0.02530328f, 0.02115727f, 
    -0.03415971f, 0.01616407f, -0.04322686f, -0.03962209f, 0.02620765f, -0.01931781f, -0.02845630f, 0.03292738f, 
    -0.04594329f, -0.02333392f, -0.02350213f, -0.00718095f, 0.02226113f, 0.02846285f, 0.01973269f, -0.02474328f, 
    -0.00765398f, 0.01336836f, 0.02953416f, 0.02878562f, -0.02432302f, 0.00689313f, 0.01635394f, -0.02446556f, 
    0.00361199f, 0.01750008f, 0.01844500f, -0.02903044f, 0.01930065f, -0.03191108f, -0.02184784f, -0.02019106f, 
    -0.00196123f, 0.02986656f, -0.00707045f, -0.00765469f, -0.02192087f, -0.03298788f, 0.00941638f, -0.01023278f, 
    0.02877444f, 0.01711753f, -0.04758571f, -0.01072848f, 0.00957674f, -0.02846950f, -0.02876474f, -0.04063964f, 
    0.00379567f, 0.00345461f, -0.02845480f, -0.04146250f, -0.01637919f, 0.01047924f, 0.02083421f, -0.01607798f, 
    0.01323984f, -0.04545435f, -0.03316398f, 0.02683460f, -0.01963254f, 0.00811187f, -0.01301793f, -0.02032671f, 
    -0.00763782f, -0.00741691f, -0.01092366f, -0.04532233f, -0.01703168f, -0.00426393f, -0.02018998f, 0.02932060f, 
    -0.01863837f, 0.00024042f, 0.02732324f, -0.02957474f, -0.02894727f, -0.02225779f, -0.02210651f, -0.03207556f, 
    0.01097311f, -0.00146882f, 0.00510917f, -0.02605112f, 0.00769251f, 0.00142850f, 0.02552449f, -0.01900087f, 
    0.03071669f, 0.00726617f, -0.03935648f, -0.02807794f, -0.01044535f, 0.00133965f, 0.01945201f, -0.00037778f, 
    0.02179569f, -0.03148873f, 0.02196432f, 0.01433734f, -0.01243728f, -0.04455216f, -0.02425837f, -0.01494909f, 
    -0.02944435f, 0.00089819f, -0.02294142f, -0.02065140f, -0.01429143f, -0.03757681f, -0.00474366f, 0.02820838f, 
    -0.04626720f, -0.01801512f, 0.02674276f, -0.02060611f, -0.04283046f, 0.00677069f, -0.04481057f, -0.03495865f, 
    -0.04624135f, -0.01153266f, 0.02593831f, -0.00863490f, -0.03498522f, -0.01879911f, -0.02300512f, -0.04604685f, 
    -0.04694318f, 0.01324036f, 0.01516904f, 0.00353851f, 0.01036796f, -0.04353930f, -0.01446411f, -0.02822615f, 
    -0.04695349f, -0.04275168f, -0.01578312f, 0.01024924f, -0.04069855f, -0.03056062f, 0.02510569f, -0.03724827f, 
    -0.00374353f, 0.01668219f, 0.02065627f, -0.03946823f, 0.02360172f, 0.01630611f, -0.00216022f, -0.00141856f, 
    -0.00303631f, -0.03843353f, -0.01385567f, -0.02635378f, -0.02920147f, 0.02247363f, 0.01561614f, -0.04373753f, 
    0.03065981f, -0.01140926f, 0.02504852f, -0.00807340f, -0.00613042f, -0.02892785f, -0.01499808f, 0.00587657f, 
    -0.00656533f, -0.00394280f, 0.01503336f, -0.00823077f, -0.03770958f, 0.00893948f, 0.02190222f, -0.04622909f, 
    0.00638405f, 0.02598657f, 0.00842401f, -0.01101800f, -0.04317410f, -0.00935457f, -0.02396315f, -0.02662770f, 
    -0.04050661f, -0.00778135f, 0.00209489f, -0.03386801f, 0.00773585f, 0.02971051f, 0.00660678f, 0.01257539f, 
    -0.03721794f, -0.03917312f, 0.01103360f, -0.02605519f, -0.01193583f, -0.00852151f, 0.02124727f, -0.01509276f, 
    -0.02616081f, 0.00753368f, -0.01527625f, -0.03549865f, -0.00118108f, 0.00912546f, -0.02119290f, 0.00583089f, 
    0.02949010f, -0.00547555f, 0.03034750f, -0.00496631f, -0.01248220f, -0.03971289f, 0.02607966f, -0.03784324f, 
    0.02168869f, 0.02158919f, 0.02277179f, -0.02225523f, 0.01180858f, 0.01263945f, -0.04119754f, -0.00052495f, 
    0.02323975f, 0.02668143f, -0.00190806f, 0.01829174f, -0.03500231f, 0.03099561f, -0.03256628f, -0.00031080f, 
    -0.02631249f, 0.02037499f, -0.01339073f, -0.02297767f, 0.00306646f, 0.02720388f, -0.03145443f, -0.01934004f, 
    -0.00615203f, 0.02837109f, -0.03011936f, -0.03516793f, 0.02643307f, -0.04390726f, -0.03908926f, 0.01158897f, 
    -0.02836975f, 0.01262796f, -0.03587742f, -0.00984889f, -0.04775403f, -0.00793363f, -0.04644916f, -0.01273512f, 
    -0.03962326f, -0.03955248f, -0.01031407f, 0.00535767f, -0.01634776f, -0.04298267f, -0.04774472f, 0.00942747f, 
    0.00499405f, -0.01190591f, 0.02888704f, -0.04441155f, -0.02450803f, 0.01528331f, 0.01073308f, -0.02503524f, 
    -0.02089822f, -0.00602356f, 0.01137106f, -0.00996796f, -0.02950715f, -0.00681085f, -0.00406521f, 0.00135338f, 
    -0.01225316f, -0.04499177f, 0.01888678f, -0.03408149f, 0.01975130f, 0.01051686f, -0.03001704f, 0.02273058f, 
    -0.00910548f, 0.00589047f, -0.02921647f, -0.02661799f, -0.01286972f, -0.02662398f, -0.03729279f, 0.02547876f, 
    0.03679505f, 0.00195141f, 0.02639375f, 0.01081096f, 0.00728852f, -0.00561777f, -0.00476158f, 0.01280640f, 
    0.00517310f, -0.00563198f, -0.03317520f, -0.00913369f, -0.00502353f, -0.00516893f, -0.01186879f, 0.00993444f, 
    0.01200347f, -0.01905787f, 0.01323290f, -0.01754803f, -0.02484409f, -0.00733038f, -0.02290851f, -0.00389129f, 
    -0.02638295f, -0.02915234f, -0.04183279f, -0.02468405f, -0.04600938f, 0.00978748f, 0.01495903f, 0.01077705f, 
    -0.02932034f, 0.00448876f, -0.04249685f, -0.03759452f, -0.03922762f, -0.02780023f, -0.01306810f, -0.04586628f, 
    -0.03890393f, -0.04725280f, -0.02513450f, -0.02720944f, 0.02988593f, 0.01097956f, -0.03391863f, -0.03469895f, 
    0.00823452f, -0.01609719f, -0.03609738f, -0.00308699f, 0.02483013f, 0.02893909f, -0.04344286f, 0.02502734f, 
    -0.04637590f, -0.02472199f, 0.01468248f, 0.02689461f, -0.00249038f, -0.03409700f, -0.04470657f, -0.00304731f, 
    0.01536585f, -0.03428766f, 0.00258367f, 0.01754066f, -0.01909984f, 0.01275853f, -0.01637710f, -0.03674945f, 
    -0.02566215f, 0.00561831f, -0.01108121f, 0.00074018f, 0.00123944f, -0.03547331f, -0.02993834f, 0.02523654f, 
    -0.02612191f, 0.01728369f, -0.04230416f, -0.04600347f, 0.03009131f, 0.00143740f, 0.01692780f, -0.03193527f, 
    -0.04778244f, 0.00538540f, -0.03417724f, -0.04246640f, -0.02391457f, -0.00442751f, -0.04102945f, -0.01460009f, 
    0.02185781f, -0.01677988f, -0.03400288f, -0.03250809f, -0.03845518f, 0.01535190f, 0.03092546f, 0.01615312f, 
    -0.00778593f, -0.01053742f, 0.02167389f, -0.00881468f, 0.02850197f, 0.00226645f, -0.03451326f, 0.00342322f, 
    0.01845077f, 0.02612897f, -0.02610327f, -0.04053349f, 0.00809147f, -0.01473505f, 0.02221124f, -0.01418923f, 
    -0.02501983f, -0.04746944f, 0.01958373f, -0.01244534f, -0.03550000f, -0.03751847f, 0.00883793f, -0.04698445f, 
    0.00129583f, -0.04013965f, -0.03092360f, 0.00810685f, -0.02455388f, -0.01996938f, -0.01837993f, -0.02230959f, 
    -0.02292151f, -0.03274928f, -0.04273717f, -0.01016337f, -0.03885714f, 0.02985285f, 0.00138626f, -0.00379320f, 
    0.01805319f, -0.02252135f, -0.00833345f, -0.02333045f, -0.02316311f, 0.03768894f, 0.01764238f, -0.00456891f, 
    0.03025966f, 0.01749265f, -0.03518187f, 0.00245037f, 0.02915297f, -0.03066796f, -0.04733687f, -0.02553386f, 
    -0.03464530f, -0.01869398f, 0.01941439f, -0.03021452f, 0.02416338f, -0.04153096f, -0.01145463f, -0.04072968f, 
    0.01550477f, 0.00432294f, -0.02671375f, 0.01651240f, -0.02395566f, -0.01472588f, -0.04385271f, -0.02107018f, 
    -0.03818278f, 0.01756711f, -0.03663475f, -0.01446755f, -0.00058235f, 0.00093204f, -0.04532063f, 0.00909339f, 
    -0.02862584f, -0.00610881f, -0.04656832f, -0.03278384f, -0.01884934f, -0.03445485f, 0.01997549f, -0.01937973f, 
    -0.03231961f, -0.04263312f, 0.01731122f, -0.02612302f, 0.01901224f, -0.02451382f, 0.02801828f, 0.00091844f, 
    0.00771213f, 0.01179995f, 0.00833691f, -0.03808603f, -0.02960834f, 0.01995819f, -0.04469066f, -0.02544599f, 
    -0.00184024f, 0.02816353f, -0.03749658f, 0.02861929f, -0.02987149f, -0.00843449f, 0.00391225f, -0.01643255f, 
    0.01582254f, -0.01295567f, -0.02268492f, 0.02701892f, -0.03053199f, -0.02588359f, 0.00356194f, -0.01695200f, 
    -0.00356768f, -0.03757158f, -0.03573744f, 0.01402087f, -0.02673073f, -0.00082823f, -0.01965535f, 0.02100955f, 
    0.00487532f, -0.01494395f, -0.00724889f, -0.01160108f, -0.04351739f, 0.02125986f, -0.02826923f, -0.04241385f, 
    -0.00261309f, 0.00697308f, -0.00232168f, -0.01905765f, 0.03082508f, -0.01844754f, -0.04103477f, 0.00250134f, 
    -0.01540993f, 0.00555362f, -0.03141093f, 0.01940960f, 0.03096824f, -0.02168359f, 0.00298298f, 0.00555019f, 
    -0.01577436f, -0.03076418f, -0.04310405f, -0.04375610f, -0.03532222f, -0.03704624f, 0.01949859f, 0.00180447f, 
    0.00603241f, 0.01885872f, 0.02157734f, -0.02338088f, -0.04228029f, 0.02275066f, 0.00113232f, -0.03580856f, 
    0.03581030f, 0.00064251f, 0.03081658f, -0.01737897f, -0.04121124f, -0.00301098f, 0.01222244f, -0.01949888f, 
    -0.00996369f, 0.00619001f, -0.03427773f, -0.00367154f, -0.02517048f, -0.00889323f, 0.02533517f, 0.01618413f, 
    0.01746313f, -0.00261498f, -0.03664982f, -0.03487376f, -0.04740448f, -0.03357595f, -0.02245512f, -0.03198126f, 
    -0.04512041f, -0.01437815f, 0.00736938f, -0.01053711f, -0.00858724f, -0.00243441f, -0.01989481f, -0.02481664f, 
    -0.00114942f, 0.02987646f, -0.02658059f, 0.02759170f, 0.01351439f, -0.00324555f, -0.00221698f, -0.03655206f, 
    -0.00109791f, 0.00369573f, -0.01765853f, -0.00055411f, 0.02631944f, -0.03810107f, -0.01185832f, 0.01552641f, 
    0.02711848f, -0.01016312f, -0.04716711f, -0.04254928f, 0.01114834f, 0.02738609f, -0.01481715f, -0.00430081f, 
    -0.00868916f, -0.03068838f, 0.02006856f, -0.01278453f, -0.00827981f, -0.01969128f, -0.02569223f, -0.03214477f, 
    -0.04098060f, -0.00312911f, 0.03070142f, -0.00575418f, -0.00525816f, 0.01192722f, -0.00119158f, -0.04502411f, 
    0.00641230f, -0.02938017f, -0.01775174f, 0.00478927f, -0.03263987f, 0.03785602f, -0.01869155f, -0.04021204f, 
    -0.05342008f, 0.20166574f, 0.08527906f, 0.11406437f, 0.31641373f, 0.10879650f, -0.09254051f, 0.03245058f, 
    0.01483331f, -0.11342422f, 0.13314962f, 0.01319301f, -0.01669332f, -0.03414801f, -0.10648184f, 0.12239853f, 
    0.18753901f, -0.07260674f, -0.07085432f, -0.04655981f, 0.06604303f, 0.10968739f, 0.10634974f, -0.18133479f, 
    -0.04044779f, -0.06330992f, 0.10069876f, -0.03516922f, -0.07240579f, -0.02295589f, -0.18033735f, -0.16574037f, 
    0.06119381f, -0.02726999f, 0.23905736f, 0.01958802f, 0.10859618f, 0.05099452f, 0.02505873f, 0.05686143f, 
    0.21277158f, -0.04947456f, -0.15945339f, 0.19624673f, 0.01888859f, -0.03089478f, 0.10821161f, 0.02391311f, 
    0.03812268f, 0.14784086f, -0.03722583f, -0.08642683f, 0.09084844f, -0.00657610f, 0.11441585f, 0.08835408f, 
    -0.04747864f, 0.06439633f, -0.02548649f, 0.11554863f, 0.20505211f, -0.26585689f, -0.27994922f, -0.10865150f, 
    -0.14851472f, -0.02650335f, -0.01352582f, 0.06954322f, 0.01069711f, -0.07990208f, 0.11122944f, 0.09477614f, 
    0.02668535f, -0.03900249f, -0.03216018f, -0.06004535f, -0.12457705f, 0.11306038f, 0.05560988f, -0.16985518f, 
    -0.14262091f, -0.16589773f, -0.05543511f, 0.12154499f, 0.04150694f, 0.02099281f, 0.17029192f, 0.03834042f, 
    -0.07593259f, 0.07050350f, 0.15460251f, -0.00760335f, 0.09870890f, -0.10082263f, -0.08298905f, 0.12173893f, 
    0.02245398f, 0.00877566f, -0.04740798f, 0.10601456f, -0.05750272f, 0.07003567f, 0.09559030f, 0.00415543f, 
    0.02298085f, 0.06996169f, 0.03589548f, 0.04492141f, 0.16655105f, 0.01364201f, -0.08666273f, 0.07700607f, 
    -0.00115590f, 0.15675037f, -0.11202194f, 0.07166275f, 0.00335323f, -0.02274438f, 0.13576864f, -0.00686767f, 
    -0.01503963f, -0.03716442f, -0.02428669f, 0.15250218f, 0.12662277f, -0.01782513f, -0.10749876f, -0.09122201f, 
    0.04364949f, -0.04045490f, -0.09617256f, -0.07032379f, -0.03028788f, 0.04461093f, 0.10759518f, -0.11700363f, 
    0.10212968f, 0.00600340f, 0.02202954f, -0.01204713f, 0.12085600f, -0.21851154f, 0.02505475f, 0.15236196f, 
    -0.07157915f, -0.03845024f, 0.01052119f, -0.04681905f, -0.01134856f, 0.08731735f, -0.16673908f, -0.05522669f, 
    0.03248160f, 0.07887948f, 0.07160772f, 0.00069198f, -0.06814444f, -0.06652081f, -0.02088285f, 0.01911060f, 
    0.18426645f, -0.31005278f, -0.13783498f, -0.02020775f, 0.22309120f, -0.08054426f, -0.07512446f, -0.07141282f, 
    0.06106934f, 0.09576660f, -0.00712741f, 0.14739579f, -0.05090321f, 0.12290744f, 0.12280822f, 0.00272991f, 
    -0.03548608f, 0.00721816f, -0.02220450f, 0.12369365f, -0.03814503f, 0.05840549f, -0.07160873f, -0.01871525f, 
    -0.06984615f, 0.06249618f, 0.11524300f, 0.14636922f, 0.06641904f, 0.00270602f, 0.05563692f, -0.10785516f, 
    -0.03917274f, -0.08240436f, 0.07533847f, 0.03147191f, 0.00798164f, 0.14275652f, 0.04759879f, -0.04109354f, 
    0.09646660f, 0.08650298f, 0.10592903f, 0.16889352f, 0.04553530f, 0.07703635f, 0.01411467f, -0.03255957f, 
    0.10217312f, -0.05862753f, 0.00241325f, 0.04302444f, -0.02979283f, 0.07867657f, -0.04587263f, 0.03372152f, 
    0.00330011f, 0.04630148f, -0.07061889f, -0.16702688f, 0.48198602f, 0.27304491f, 0.02391995f, -0.06154155f, 
    -0.35943601f, -0.08888005f, 0.04452610f, -0.03905175f, 0.02301055f, -0.11630283f, -0.09629415f, 0.03527670f, 
    -0.06694449f, 0.10061823f, 0.07219380f, 0.01464542f, 0.01379959f, 0.06031878f, -0.11371787f, 0.09377355f, 
    -0.40317118f, -0.16508332f, -0.04543629f, 0.07322965f, -0.16837643f, 0.19475555f, 0.13387491f, -0.03725091f, 
    -0.13380912f, 0.00182680f, 0.14340150f, 0.08298482f, 0.00549731f, -0.10113014f, -0.23873797f, 0.06819472f, 
    -0.00114902f, -0.00090757f, 0.10925508f, 0.10298885f, 0.01745341f, 0.35221106f, 0.01273258f, -0.00664153f, 
    0.01067258f, 0.02643473f, 0.13980609f, 0.01189178f, 0.07189290f, -0.03260073f, 0.01843134f, -0.01779379f, 
    0.01295712f, 0.04446308f, -0.10271108f, -0.01794018f, 0.02581351f, 0.01945387f, 0.04237819f, 0.04876208f, 
    0.18870945f, -0.32270852f, 0.20315450f, 0.13486725f, 0.01514521f, -0.11594856f, -0.17914851f, -0.09481280f, 
    0.06292022f, 0.02920330f, 0.02651103f, -0.08687470f, 0.03248989f, 0.08475614f, 0.14298230f, 0.03273017f, 
    0.09659308f, 0.06899583f, 0.19143271f, -0.04522960f, 0.29624495f, -0.18958810f, 0.05367705f, -0.02405880f, 
    0.04991337f, -0.03214165f, 0.00953962f, -0.00731216f, 0.04341732f, 0.02775369f, -0.00589301f, -0.09180038f, 
    -0.12362789f, 0.07029260f, -0.04493684f, -0.04926558f, -0.01648662f, -0.12221373f, 0.01776563f, 0.01450597f, 
    0.10820384f, 0.15980424f, 0.14519459f, 0.09327623f, 0.27297443f, 0.02965816f, 0.12735006f, 0.01782550f, 
    0.15140490f, -0.06319424f, -0.03745684f, -0.03739020f, -0.00324487f, 0.06436186f, -0.11260370f, 0.07047068f, 
    0.07584216f, 0.06549834f, -0.05162212f, 0.03536076f, 0.05363753f, -0.06541804f, -0.01102756f, 0.13887151f, 
    0.00195680f, 0.05164073f, 0.01929547f, 0.00286872f, 0.01419413f, 0.06548169f, 0.05782922f, -0.02263062f, 
    0.03559525f, 0.03740167f, -0.02919672f, -0.03611814f, -0.02687665f, -0.09537626f, -0.01830875f, -0.04429691f, 
    -0.04184327f, -0.04587150f, -0.04036261f, 0.18777698f, 0.20597838f, -0.02915304f, 0.05752577f, -0.08002995f, 
    -0.04752429f, 0.10821652f, -0.13968770f, 0.04740487f, 0.00513068f, 0.04160881f, -0.03774841f, -0.02964297f, 
    0.01089404f, -0.01441216f, 0.02811540f, 0.02795145f, -0.30030349f, 0.05590764f, -0.16063447f, -0.21738458f, 
    0.20959552f, 0.08009546f, 0.19139139f, 0.11518822f, 0.01656180f, -0.00883515f, 0.03965260f, -0.13115951f, 
    0.00204333f, 0.00243639f, -0.10277581f, 0.05943856f, 0.05458001f, -0.11897202f, 0.00149741f, -0.02273691f, 
    -0.10566046f, -0.26178327f, 0.02159534f, 0.15199807f, -0.12998419f, 0.02870686f, -0.14918660f, -0.04104934f, 
    0.03627917f, 0.22435324f, -0.07100602f, 0.12786938f, 0.04916937f, 0.03352310f, 0.02798016f, -0.06851984f, 
    -0.08369382f, 0.07998796f, 0.09436010f, -0.06180679f, 0.12504528f, 0.17763977f, 0.08171627f, -0.12084354f, 
    -0.23160279f, -0.01576043f, 0.10014272f, 0.01242618f, -0.04855914f, 0.02032266f, 0.02757025f, -0.10847846f, 
    0.10306241f, -0.02645108f, -0.02948725f, -0.08835773f, 0.16947131f, 0.06625301f, -0.01236364f, 0.10822912f, 
    0.12420796f, 0.28764036f, 0.03686716f, -0.11231346f, -0.11574494f, -0.04119148f, 0.01624838f, -0.05457555f, 
    0.08320267f, -0.05685763f, 0.00764425f, -0.05674244f, -0.10279521f, 0.06054037f, 0.07325869f, 0.14996418f, 
    0.08031113f, 0.23355347f, 0.02149661f, 0.05638620f, 0.45571479f, -0.09981458f, -0.10109618f, -0.00969240f, 
    -0.05483425f, 0.05981822f, -0.06651327f, -0.04051960f, 0.07936431f, 0.08116654f, 0.07833220f, 0.04027259f, 
    -0.01816926f, -0.02915566f, 0.09819715f, -0.05892091f, 0.04363916f, 0.06322814f, 0.10594187f, 0.14074580f, 
    0.37889737f, 0.02077679f, 0.22580510f, 0.29934824f, 0.00613786f, -0.09441533f, -0.16540219f, -0.09067033f, 
    -0.07504380f, 0.14985469f, 0.05797055f, -0.12255942f, 0.00427033f, 0.05040481f, 0.04907442f, 0.05244848f, 
    0.02328487f, -0.03534963f, 0.02404504f, 0.03069755f, 0.26642609f, -0.10083922f, -0.03704232f, -0.27853447f, 
    0.14744948f, 0.06624968f, 0.06538384f, 0.02786179f, 0.00280890f, 0.01736377f, 0.06597809f, 0.06832540f, 
    0.00255876f, 0.08756423f, 0.01247281f, 0.03571846f, 0.03178044f, -0.03239886f, 0.10946681f, 0.05991987f, 
    0.41581541f, 0.00953219f, 0.05286944f, -0.00129545f, -0.21932241f, -0.03892371f, -0.11556490f, -0.01891407f, 
    -0.07267632f, -0.15590091f, -0.12041482f, -0.00692216f, 0.01509644f, 0.04893158f, 0.02376052f, -0.12361684f, 
    -0.00908941f, -0.02749460f, -0.07782450f, -0.06587318f, 0.24847797f, -0.07367074f, -0.02410134f, 0.03676865f, 
    0.28486928f, -0.04971877f, 0.03206816f, 0.01748902f, 0.03802400f, -0.07462860f, 0.12038548f, 0.04860223f, 
    0.05119890f, 0.01761376f, -0.07229537f, 0.09340297f, 0.11734151f, -0.02421081f, -0.01748384f, -0.09895995f, 
    -0.03534282f, 0.01483634f, 0.16071098f, -0.32708076f, -0.05718603f, 0.03129948f, 0.12530373f, 0.03807360f, 
    -0.10916767f, -0.03799189f, -0.04039498f, 0.10889458f, -0.11962868f, 0.01042218f, 0.00646919f, 0.07445958f, 
    0.11233461f, -0.02590125f, 0.14977516f, -0.01351797f, -0.30181140f, 0.00042670f, -0.15993471f, -0.00025662f, 
    0.01395233f, -0.01414845f, 0.03609937f, 0.04912450f, 0.11831726f, 0.02574796f, -0.03163778f, 0.11944350f, 
    -0.00734001f, 0.06514717f, 0.08750707f, -0.01200008f, -0.07208857f, 0.02341170f, 0.22298786f, -0.09051128f, 
    0.13337563f, 0.05311627f, 0.14133762f, 0.02923018f, -0.03466585f, -0.05066685f, -0.07200427f, -0.05786933f, 
    0.09536488f, -0.00355223f, -0.03436941f, -0.07498696f, -0.03788036f, 0.08292884f, 0.06970200f, 0.07183533f, 
    -0.03403588f, 0.08389667f, 0.04806729f, 0.08323359f, 0.12345316f, -0.04346791f, -0.03439641f, -0.05758028f, 
    -0.08872727f, -0.03799137f, 0.09190895f, -0.01345599f, 0.04447323f, 0.04401803f, 0.09953712f, 0.08283328f, 
    0.02862873f, -0.03052075f, 0.01880807f, 0.03958584f, 0.11492778f, 0.05269477f, -0.05558933f, 0.02072063f, 
    -0.41488028f, -0.00642202f, 0.17213550f, 0.05973723f, -0.07030354f, -0.09850009f, -0.15333475f, 0.15063901f, 
    0.13025576f, 0.13269307f, -0.00303421f, 0.01533351f, 0.01677105f, 0.03310416f, 0.07087567f, 0.01645949f, 
    0.00931964f, -0.15604970f, 0.04564487f, -0.06301022f, 0.28050914f, 0.14880802f, 0.00057313f, 0.16391693f, 
    0.07131503f, -0.13484970f, -0.02084604f, 0.15990597f, -0.05787486f, -0.16320209f, -0.03062758f, -0.02152564f, 
    0.01145723f, 0.10087074f, -0.05251089f, -0.01279837f, 0.02962642f, 0.15319067f, -0.04886072f, 0.04263564f, 
    -0.21997929f, 0.18343410f, 0.21916910f, -0.04469894f, 0.09611586f, 0.13105175f, 0.02476489f, 0.08180933f, 
    -0.03382106f, -0.16076832f, -0.04002258f, -0.03158151f, -0.01590193f, 0.06382725f, -0.04249040f, -0.07557694f, 
    -0.01794410f, 0.08426652f, 0.09338231f, -0.03481483f, 0.16757450f, 0.11868459f, -0.16920547f, 0.17649165f, 
    -0.13961339f, -0.12279709f, 0.07744010f, -0.02204354f, -0.15037383f, 0.09872936f, 0.03886305f, 0.09175856f, 
    -0.04674237f, -0.07596887f, 0.02913494f, 0.10612508f, -0.04584270f, -0.06535079f, -0.04753807f, 0.05100859f, 
    0.04944840f, 0.09783310f, 0.10603306f, 0.26870963f, -0.01142304f, -0.12342226f, 0.03005444f, 0.03522767f, 
    0.06239264f, -0.03105514f, 0.11477020f, -0.05841585f, 0.04970943f, 0.01338018f, 0.02460366f, 0.06565141f, 
    -0.08513578f, 0.01497824f, 0.07139677f, 0.00019407f, 0.04268090f, 0.29459462f, 0.01310396f, -0.01147341f, 
    0.06204078f, 0.04196186f, -0.00463030f, -0.07141636f, 0.00092493f, 0.06483177f, 0.03392143f, 0.08508082f, 
    -0.00206567f, -0.05911206f, -0.00275922f, -0.06445461f, 0.01930198f, -0.04847870f, 0.02070672f, -0.07290387f, 
    -0.11779090f, -0.15001971f, -0.08822212f, 0.01699007f, 0.00765261f, 0.10603047f, 0.09831675f, 0.08124297f, 
    -0.05730830f, -0.10895056f, 0.02316080f, -0.02347041f, 0.03663851f, 0.02036395f, -0.08417426f, 0.01937834f, 
    -0.19364797f, -0.03797455f, -0.05396992f, -0.01545519f, -0.33771053f, -0.15335082f, -0.08044636f, 0.08462463f, 
    -0.05828737f, 0.05180512f, 0.03927422f, 0.07185277f, -0.04046135f, -0.01069703f, -0.07792987f, -0.00342819f, 
    -0.01093968f, 0.03027791f, -0.01750406f, -0.07057764f, 0.03353622f, 0.01974008f, -0.07730381f, -0.03931319f, 
    -0.26553491f, 0.10475941f, 0.01311701f, -0.02954867f, 0.08329687f, -0.03453165f, 0.10483205f, -0.02617615f, 
    0.16795172f, -0.10189743f, -0.00568700f, -0.00105857f, 0.06675487f, 0.16173372f, -0.03770789f, 0.05129458f, 
    0.10661945f, 0.06254221f, -0.08299343f, -0.04170778f, -0.15994333f, 0.10122721f, 0.15843068f, 0.03200442f, 
    0.11831331f, 0.10561774f, 0.09820962f, 0.01568395f, -0.00805102f, -0.09190186f, -0.02489028f, -0.05508521f, 
    0.01394296f, 0.03974566f, 0.02271163f, -0.00743017f, -0.08835053f, 0.06708663f, 0.15782626f, -0.09223559f, 
    -0.05327770f, -0.08659273f, 0.14258315f, -0.18948783f, -0.06295490f, -0.05865362f, 0.01897803f, -0.03779674f, 
    0.05304855f, 0.15303509f, -0.01426319f, 0.04343465f, 0.03584924f, -0.03944765f, 0.15143463f, -0.04545435f, 
    0.04862292f, -0.19298883f, 0.03963565f, 0.00283218f, 0.08429717f, 0.01799512f, -0.03440813f, 0.21253680f, 
    -0.06009387f, 0.06915660f, 0.06739140f, -0.02932091f, -0.03255725f, -0.11139831f, 0.01658339f, 0.01755892f, 
    -0.04720720f, 0.00533029f, 0.01428301f, -0.10595156f, -0.05970345f, 0.01739129f, -0.16091496f, 0.06572823f, 
    -0.02384394f, -0.14729716f, 0.01393893f, 0.35992980f, 0.16526079f, -0.06017511f, -0.03584255f, 0.05443067f, 
    -0.12181173f, 0.09979750f, -0.06124514f, 0.05105895f, -0.12115017f, -0.02987080f, 0.02614134f, 0.08789227f, 
    -0.15647361f, 0.10653687f, 0.17362444f, -0.00555430f, 0.15911341f, 0.15016535f, -0.11946251f, 0.06574822f, 
    0.29583061f, 0.00136222f, 0.11377420f, 0.02416969f, -0.02825579f, -0.04827085f, 0.10462994f, 0.00278940f, 
    -0.07154605f, -0.01482330f, 0.12564853f, -0.14116901f, -0.06255818f, 0.15174618f, 0.08035449f, 0.02175453f, 
    -0.13817728f, 0.25479719f, 0.07122161f, -0.08811428f, 0.20445549f, 0.11189489f, -0.07288304f, 0.08262724f, 
    0.00951314f, -0.02507101f, -0.08438934f, -0.07233524f, 0.03623282f, -0.02560004f, 0.01473526f, 0.06719605f, 
    0.19574207f, -0.00918704f, 0.12777410f, -0.01066979f, -0.20958197f, 0.27317041f, -0.04565948f, 0.00268920f, 
    0.12925449f, 0.08151484f, -0.06192485f, -0.04568414f, 0.05526936f, -0.04929289f, -0.02889242f, -0.00505130f, 
    0.00583679f, -0.00609498f, -0.04835011f, -0.08694845f, -0.05822558f, -0.00607471f, -0.11499804f, -0.07479892f, 
    -0.03856640f, -0.16065559f, 0.03378135f, -0.03580301f, -0.12529515f, -0.08910547f, -0.03754346f, 0.06109474f, 
    0.07757621f, 0.09645978f, 0.05569690f, -0.00498553f, -0.00971003f, -0.02294015f, 0.00865923f, 0.11242123f, 
    -0.03224823f, -0.14765063f, 0.07241758f, 0.13314217f, -0.26928848f, -0.21309003f, -0.16007845f, 0.00367360f, 
    0.03969613f, 0.07456613f, 0.00577595f, 0.07436111f, -0.09382505f, 0.01343262f, -0.02552072f, 0.04740445f, 
    0.03017590f, -0.01655410f, 0.07655309f, 0.07315100f, -0.05288026f, 0.01269025f, -0.08927439f, -0.09150548f, 
    -0.31174448f, -0.10634923f, -0.02698695f, -0.09240527f, 0.08983745f, 0.10397474f, -0.01898455f, 0.20858878f, 
    0.05478233f, 0.00134066f, -0.05743437f, -0.02997425f, 0.01187361f, 0.09284750f, -0.13010991f, -0.11272639f, 
    0.09670912f, -0.00571142f, 0.01574019f, -0.08538222f, -0.11132110f, 0.18405242f, 0.19958621f, 0.31084254f, 
    -0.06458331f, 0.06520358f, -0.07381164f, 0.06478830f, 0.02152973f, -0.01776701f, -0.00103377f, 0.11182013f, 
    -0.16763763f, 0.02035034f, -0.06770725f, 0.05447657f, 0.00571547f, -0.04314577f, -0.00481722f, -0.04111568f, 
    -0.17348093f, -0.15251026f, -0.03234883f, -0.01295731f, 0.19390260f, -0.00437662f, 0.08129304f, 0.06840224f, 
    -0.05301342f, -0.12112568f, 0.03892345f, 0.00053233f, -0.02763333f, 0.18509361f, 0.01832969f, -0.01492649f, 
    0.09973042f, 0.05507590f, 0.02691794f, 0.15554400f, 0.24889056f, 0.27184919f, -0.03462757f, 0.04887188f, 
    0.07346514f, -0.06538986f, -0.10072938f, 0.00132959f, 0.11205537f, -0.00824055f, 0.02249965f, -0.05694094f, 
    -0.01248520f, 0.15213540f, -0.00772632f, 0.07410525f, 0.00824351f, 0.13661057f, -0.03216966f, 0.06692722f, 
    0.18536010f, 0.28349018f, 0.11425098f, 0.13458383f, 0.05311515f, 0.06792291f, -0.07824840f, -0.12144884f, 
    -0.02269601f, -0.10415766f, 0.01277905f, 0.08838624f, 0.06647659f, -0.08429017f, 0.01946777f, 0.12956800f, 
    0.11160213f, -0.06452602f, 0.12096237f, -0.05081217f, -0.02591472f, 0.19831108f, -0.07602487f, -0.06720421f, 
    0.15807465f, -0.01489319f, -0.06009208f, 0.09194164f, -0.06406666f, -0.10149138f, 0.02595171f, -0.14608255f, 
    0.15197147f, 0.00457953f, -0.12454108f, -0.01907664f, -0.03414914f, -0.01830745f, 0.17792659f, 0.06849386f, 
    -0.15386146f, 0.18950422f, 0.02729303f, -0.08282629f, 0.18766187f, 0.07272116f, 0.07325116f, -0.02276153f, 
    -0.04334726f, -0.02377909f, 0.01908888f, 0.03129210f, 0.13076758f, -0.04946753f, -0.00135125f, -0.06161813f, 
    -0.02615312f, 0.01263119f, 0.08722235f, -0.06796633f, -0.07363129f, -0.26614353f, -0.06957357f, -0.03273118f, 
    0.15064436f, 0.01609636f, -0.03393958f, 0.08359361f, 0.07138141f, -0.15468968f, -0.10182951f, -0.00417787f, 
    -0.06145544f, 0.09751626f, -0.06642204f, 0.00026900f, -0.03670892f, -0.08475276f, -0.02168525f, 0.09542148f, 
    -0.13714698f, -0.24534103f, -0.18049297f, 0.09082603f, 0.06865797f, 0.11467672f, -0.04197120f, -0.00115093f, 
    0.08938447f, 0.04105313f, -0.01462872f, -0.02151869f, -0.04059572f, 0.05400091f, -0.03150806f, -0.02913961f, 
    0.08168581f, 0.05373475f, -0.15541126f, -0.00235060f, 0.04491063f, -0.07442994f, 0.06972975f, 0.08730167f, 
    -0.01361966f, -0.03698278f, -0.05620205f, -0.02013113f, 0.18214519f, 0.11106311f, 0.04334972f, 0.11495684f, 
    -0.01649845f, -0.05558688f, 0.04109843f, -0.02656311f, 0.01413837f, -0.07262057f, 0.09975618f, -0.03565568f, 
    0.21872008f, -0.18570782f, 0.10385177f, 0.00025513f, 0.24782506f, 0.08097445f, 0.00442258f, -0.01473322f, 
    0.01660872f, -0.01249261f, 0.01001887f, -0.02489201f, -0.14190696f, 0.03043764f, -0.01462236f, -0.04245964f, 
    0.04602222f, -0.01867625f, 0.09588249f, 0.05476056f, -0.11830361f, 0.17274544f, -0.03303616f, 0.11460651f, 
    0.20244402f, 0.00002362f, -0.12833333f, 0.05764873f, -0.05789070f, 0.12356679f, -0.01237113f, -0.04532806f, 
    -0.00282689f, -0.10749388f, 0.03492478f, -0.06696506f, 0.03106872f, 0.05033283f, 0.02653751f, -0.11353722f, 
    0.20675370f, 0.10706525f, 0.06826057f, -0.04544858f, 0.17880541f, -0.09532322f, 0.03898050f, 0.00337015f, 
    0.03085618f, -0.10794271f, 0.10893799f, 0.01701937f, 0.01509925f, 0.02113118f, 0.04763564f, 0.08847918f, 
    -0.05816892f, 0.14194588f, 0.09210543f, 0.16985665f, 0.01984227f, 0.13805240f, 0.08058116f, 0.14654051f, 
    -0.21147586f, 0.04854346f, 0.03085360f, 0.04602611f, 0.06095957f, 0.11082546f, 0.06211900f, 0.00597499f, 
    -0.06472309f, -0.05548390f, -0.01301927f, 0.11163555f, 0.04519062f, -0.03717845f, 0.02025290f, 0.13473170f, 
    -0.01281102f, 0.00840098f, -0.03412216f, -0.04424835f, 0.01290795f, -0.04698209f, 0.01753797f, -0.00708639f, 
    0.02300141f, -0.00886529f, 0.01353136f, -0.00510424f, 0.02989994f, 0.02495386f, -0.00235292f, -0.03554318f, 
    -0.02624517f, -0.03259354f, 0.02039290f, -0.00339294f, -0.02741081f, -0.04462817f, 0.01571288f, 0.01120348f, 
    -0.03398324f, 0.01344427f, -0.03110585f, 0.00119592f, 0.00059543f, -0.02867061f, -0.04260884f, 0.02373976f, 
    0.01203900f, -0.03748668f, -0.00179377f, -0.00663920f, 0.02813435f, 0.01270589f, 0.01684961f, 0.01094275f, 
    -0.03150185f, -0.04107128f, -0.01460723f, 0.01883622f, -0.01834194f, -0.04379829f, -0.03548458f, 0.01085956f, 
    0.02633372f, -0.00407636f, -0.04037898f, -0.00525928f, -0.02119344f, -0.02097709f, -0.01154450f, -0.00563136f, 
    0.01698837f, 0.00940712f, 0.02186418f, -0.02895389f, -0.02803341f, -0.04322970f, -0.02064079f, 0.00736565f, 
    0.00733792f, 0.02562292f, 0.00144666f, -0.02349207f, 0.01046921f, 0.00868216f, -0.02000619f, -0.01807963f, 
    0.00624345f, -0.02883179f, 0.03358648f, 0.00662394f, -0.00376412f, -0.01066206f, -0.02715079f, 0.02997373f, 
    0.02839328f, 0.00909845f, -0.00603992f, -0.02595932f, 0.02949303f, 0.01678835f, -0.03783289f, 0.00705492f, 
    -0.01321250f, 0.02225043f, -0.01299070f, 0.01346897f, -0.02545582f, -0.04413200f, -0.00965408f, 0.01774688f, 
    -0.03014028f, 0.01238940f, -0.00514076f, -0.00347305f, 0.00895069f, -0.03899036f, 0.01799565f, -0.03703350f, 
    -0.02773063f, 0.01547341f, -0.00893119f, -0.02571145f, -0.02191730f, 0.00417637f, 0.00244853f, 0.02284439f, 
    -0.00747456f, -0.00354553f, 0.00115519f, -0.02945330f, -0.04427072f, 0.02479388f, -0.00677478f, -0.02796751f, 
    0.02004515f, -0.02076675f, 0.02899511f, -0.02860556f, -0.03522890f, 0.01078716f, -0.03267693f, -0.03866856f, 
    0.01190940f, 0.01906747f, 0.00313732f, 0.00301492f, -0.02351199f, -0.01086719f, 0.02799813f, -0.03525405f, 
    -0.00888085f, -0.04555009f, -0.02588026f, -0.03481172f, 0.01440982f, -0.01133905f, -0.03332034f, -0.03740891f, 
    -0.04276102f, 0.01570585f, -0.02534029f, 0.00479019f, -0.02229276f, 0.01989058f, 0.01459316f, -0.03546573f, 
    -0.02214972f, -0.04140764f, -0.00871187f, 0.01345269f, 0.01179211f, 0.00129707f, -0.02391929f, -0.04351873f, 
    0.03027407f, 0.00011463f, -0.00534403f, 0.02637751f, 0.02057028f, 0.01165542f, 0.03370161f, -0.00580888f, 
    0.02791378f, 0.01263234f, 0.00794117f, -0.00571326f, 0.00443936f, 0.02519687f, -0.03301902f, -0.01345265f, 
    -0.00155474f, -0.03278470f, -0.03583047f, -0.04117353f, 0.01318895f, -0.04630338f, -0.02657596f, 0.01590209f, 
    -0.00420661f, -0.00816288f, 0.01156666f, 0.02023977f, 0.02133431f, -0.03854332f, -0.01869774f, -0.04664814f, 
    0.00117310f, -0.04561530f, -0.01266850f, 0.00468675f, 0.02921801f, -0.01280432f, -0.01757477f, -0.00179710f, 
    -0.02161455f, -0.01381573f, 0.01255420f, -0.04084563f, -0.00283862f, -0.02136482f, -0.01859665f, 0.02417282f, 
    -0.03132220f, -0.03390456f, 0.00527102f, -0.02515334f, 0.01057207f, -0.04568785f, -0.00052725f, 0.02265768f, 
    -0.02045917f, -0.03585687f, 0.02836659f, 0.00575742f, -0.03290212f, -0.04550949f, -0.02869929f, 0.01870603f, 
    -0.04430418f, 0.02526674f, -0.03286522f, 0.03054068f, -0.04223541f, 0.02334162f, 0.01656657f, -0.01196934f, 
    -0.01665627f, 0.00286563f, -0.00959676f, -0.03965084f, 0.00847105f, -0.03603726f, -0.02709154f, -0.01768319f, 
    -0.03782506f, 0.02431706f, -0.01472498f, -0.02158520f, -0.01034773f, -0.03606875f, -0.00389428f, -0.02075450f, 
    0.01202428f, -0.00498239f, 0.01336854f, -0.04223848f, 0.02253689f, 0.02013884f, 0.00594611f, 0.00162284f, 
    -0.04099100f, 0.00225164f, 0.03227488f, -0.00434155f, -0.03330154f, -0.02533361f, 0.02423880f, 0.02658887f, 
    -0.02184537f, -0.01694746f, 0.00362203f, -0.02638172f, -0.00895743f, 0.01073135f, -0.01535050f, -0.00495322f, 
    0.00034481f, 0.03220238f, -0.02744848f, -0.03978761f, -0.03725125f, -0.04308556f, 0.00684611f, -0.04449129f, 
    -0.02086254f, -0.04343481f, 0.00437701f, -0.02852206f, -0.01216535f, -0.03644496f, -0.01957287f, -0.04193849f, 
    0.01252104f, 0.01560846f, 0.03098296f, -0.02363339f, 0.00772399f, 0.00860383f, 0.02378839f, 0.00859402f, 
    -0.04047383f, -0.02680505f, -0.03600822f, -0.02590166f, 0.00741524f, 0.01137512f, 0.02399641f, 0.01430720f, 
    -0.01071951f, -0.03712539f, 0.02718439f, 0.01890271f, 0.00758922f, 0.02465571f, -0.02740579f, -0.04246956f, 
    -0.02389460f, -0.01186247f, 0.01115364f, -0.01779922f, -0.04070599f, -0.04640534f, -0.01114557f, -0.02567075f, 
    -0.02389318f, -0.03816243f, -0.02625178f, -0.00989742f, -0.01575524f, -0.01807891f, 0.02698075f, -0.04102324f, 
    -0.02567779f, -0.02887087f, 0.02082686f, -0.04386284f, -0.02831293f, -0.02604917f, -0.04647085f, 0.01907818f, 
    -0.04625688f, 0.03091943f, 0.02645050f, 0.00859565f, -0.02860195f, -0.00039588f, -0.03156771f, -0.01125296f, 
    0.01992934f, 0.02946720f, 0.00191860f, -0.00534678f, 0.01969408f, 0.01563630f, -0.00498569f, 0.02168083f, 
    -0.00558036f, -0.00445761f, 0.01090309f, -0.01450102f, -0.03243859f, 0.01088060f, 0.00311326f, 0.00485014f, 
    -0.03110185f, -0.01057405f, 0.02486519f, -0.04669008f, -0.01106571f, -0.01769102f, -0.02813953f, -0.03337339f, 
    0.02787660f, -0.03351673f, -0.02170489f, -0.01086830f, -0.00717093f, 0.02293671f, -0.04151577f, -0.04177693f, 
    -0.01301404f, -0.02484691f, 0.02068084f, -0.01598156f, 0.01792699f, 0.00333846f, -0.03470866f, 0.00236485f, 
    -0.00964723f, -0.00177525f, 0.00220883f, -0.00925733f, -0.04400134f, -0.02392582f, 0.02217536f, 0.02698096f, 
    0.00612599f, -0.01197689f, -0.04674873f, 0.02132001f, -0.02488114f, 0.03009807f, 0.00655369f, 0.01654163f, 
    0.01153680f, 0.00530568f, -0.03612789f, -0.00192835f, 0.00505612f, 0.01697884f, 0.02797002f, 0.02005919f, 
    0.02530856f, 0.01055323f, -0.00154340f, 0.00235092f, 0.01766502f, -0.00430911f, -0.00480780f, 0.01544623f, 
    0.01738864f, -0.00303371f, -0.03791646f, -0.02925911f, -0.00708147f, 0.01689988f, 0.02150358f, -0.03372790f, 
    0.01998723f, 0.00811336f, 0.00793308f, 0.02836969f, -0.02136781f, -0.02421614f, 0.00977864f, 0.02684948f, 
    -0.00161468f, -0.02926926f, -0.02397468f, 0.02693704f, -0.03081780f, 0.00844844f, -0.01758150f, 0.01475484f, 
    -0.02827388f, -0.00642239f, -0.01206291f, -0.00313142f, -0.00840297f, 0.00003954f, -0.02379130f, 0.00618661f, 
    0.01880251f, 0.02071873f, -0.04063415f, -0.02203465f, 0.00799880f, -0.04328214f, -0.03045863f, -0.03314455f, 
    -0.01940736f, 0.02569660f, -0.03468498f, -0.00193097f, -0.03516618f, 0.02730977f, -0.00177141f, 0.02791882f, 
    0.01194302f, 0.01703572f, -0.04637443f, -0.03764815f, 0.02136643f, -0.00949812f, -0.04625649f, 0.03419638f, 
    -0.02469704f, 0.02862149f, -0.01217264f, -0.03709479f, 0.02280226f, 0.00914279f, -0.01912683f, 0.03129595f, 
    -0.00567609f, 0.02478529f, -0.00093709f, -0.01257756f, 0.03094552f, -0.00895355f, 0.01578114f, 0.00467177f, 
    0.02905585f, -0.00798293f, 0.02466048f, -0.01191934f, -0.04595324f, 0.00413175f, 0.00098831f, 0.00660163f, 
    0.03365992f, -0.02564737f, -0.02316759f, 0.02737267f, -0.04189424f, 0.00735024f, 0.01275163f, -0.01460217f, 
    -0.02947343f, 0.02934098f, -0.04449824f, -0.04459970f, -0.03630731f, 0.01540012f, -0.02695029f, -0.03643433f, 
    -0.02646559f, -0.04211270f, 0.00844182f, 0.02101492f, -0.04207693f, 0.03075320f, -0.02125246f, -0.03399857f, 
    0.01805481f, 0.00774769f, 0.01146600f, -0.00736510f, 0.03179140f, 0.03316860f, 0.03812156f, -0.00669382f, 
    0.02432869f, -0.01941741f, -0.00721275f, 0.01114829f, 0.02778667f, -0.00686633f, -0.03144246f, -0.02034871f, 
    0.01743141f, -0.02184789f, -0.00184251f, 0.02385586f, -0.04680068f, 0.00878720f, 0.00236118f, 0.02279815f, 
    -0.02727443f, -0.00366141f, -0.02911905f, 0.00238465f, -0.03953707f, 0.02226345f, -0.03953757f, 0.02320138f, 
    -0.01862785f, -0.02987598f, -0.00319978f, 0.02387339f, -0.03242885f, 0.00597305f, 0.01361772f, 0.00555226f, 
    -0.02459429f, -0.01094327f, -0.03877861f, 0.00953359f, -0.01482425f, 0.02245862f, 0.03171570f, 0.01877033f, 
    -0.03351116f, 0.01131113f, -0.00774427f, 0.00315975f, -0.02043692f, 0.01921205f, -0.03260801f, 0.00105452f, 
    -0.01384166f, -0.04233209f, -0.04061047f, -0.03984697f, -0.02754408f, -0.01753281f, -0.01317798f, 0.02698156f, 
    0.03511727f, 0.00835541f, -0.00308173f, 0.02395448f, -0.02578229f, -0.00742367f, -0.02123977f, -0.00715210f, 
    0.01861025f, 0.01096975f, 0.00838155f, 0.01688901f, -0.03824301f, -0.03283153f, -0.00284585f, 0.01474492f, 
    -0.00787534f, -0.02100247f, -0.02386343f, -0.03475584f, -0.02989117f, 0.02201261f, -0.03353846f, -0.01331316f, 
    -0.01163580f, -0.04382269f, -0.03773390f, -0.01226412f, 0.02096096f, -0.00472425f, -0.03019098f, -0.01866816f, 
    -0.03390159f, -0.04059496f, 0.01856771f, -0.04131970f, 0.00101385f, 0.02084165f, -0.00725606f, -0.00131019f, 
    0.00331385f, 0.01238042f, 0.00313771f, -0.01689445f, -0.02992815f, 0.00343356f, 0.01294108f, 0.00938669f, 
    -0.02217784f, -0.04502864f, -0.00918963f, -0.01592811f, 0.02908497f, 0.03037428f, 0.00208657f, -0.01773728f, 
    0.20822234f, 0.27044609f, -0.34302172f, -0.13519099f, 0.27361244f, 0.04765561f, 0.02817214f, -0.04153470f, 
    -0.02569575f, 0.00251885f, 0.05380335f, 0.03540764f, -0.04274714f, -0.04494229f, 0.09182970f, -0.08112356f, 
    0.04622467f, 0.03399491f, -0.09975730f, 0.01477170f, 0.03551085f, -0.33801311f, 0.15991630f, -0.03441989f, 
    -0.03700701f, 0.09956941f, -0.06320699f, -0.07552464f, -0.00345190f, -0.04767874f, 0.01832923f, -0.05431892f, 
    -0.08448365f, 0.07416046f, -0.03870574f, -0.00912743f, 0.02714890f, 0.02652894f, -0.08528422f, -0.02463848f, 
    0.34599796f, 0.16825227f, -0.12951893f, -0.00624271f, -0.13139278f, -0.04685653f, -0.00131919f, -0.05358244f, 
    -0.07150760f, 0.11136591f, -0.04897801f, 0.04945516f, 0.07264671f, -0.00642633f, 0.04068555f, 0.10074200f, 
    0.05932323f, 0.03852461f, -0.07166762f, -0.01221680f, 0.25192741f, 0.06920083f, -0.00848009f, -0.06323420f, 
    0.36623776f, 0.09021126f, 0.07569353f, 0.07646479f, 0.10386508f, -0.06682155f, 0.09382416f, 0.07046983f, 
    0.07411212f, -0.11148412f, 0.01540626f, -0.09257957f, -0.03163307f, 0.02674622f, 0.01221175f, -0.03844000f, 
    0.06378132f, 0.07902471f, 0.00841155f, -0.09848094f, 0.11585638f, 0.14771345f, -0.02145094f, -0.06339452f, 
    0.02171893f, 0.05103913f, 0.12034287f, 0.07187182f, -0.01164400f, -0.04432394f, -0.03948792f, 0.08326000f, 
    -0.01099513f, 0.03276194f, -0.04120551f, 0.12872918f, 0.03890530f, -0.22735487f, 0.02802629f, -0.01278966f, 
    -0.10658652f, -0.06267558f, -0.02234407f, 0.10945705f, 0.03147023f, -0.05625457f, 0.01385557f, -0.11031348f, 
    0.10849839f, 0.03330365f, -0.00542091f, 0.14679232f, 0.01425146f, -0.03040580f, 0.05613493f, 0.00237957f, 
    0.02076744f, 0.02133640f, 0.18111092f, -0.11057328f, 0.05333137f, -0.05514604f, -0.04367614f, 0.00337877f, 
    0.00683256f, 0.08298887f, -0.06560587f, 0.03732681f, 0.01084742f, -0.04422873f, 0.02926129f, -0.00605695f, 
    -0.02128603f, 0.02998325f, 0.06030816f, -0.03265050f, 0.36286706f, -0.00304591f, 0.15845609f, -0.07041172f, 
    -0.02969877f, -0.06841328f, -0.02115189f, 0.09608000f, 0.11669533f, 0.10639647f, -0.02264299f, 0.00983770f, 
    0.02578989f, 0.05393088f, -0.05029482f, 0.04910114f, -0.01745399f, 0.08440205f, 0.00558049f, -0.01316313f, 
    0.08806018f, -0.04332450f, 0.08128349f, 0.01795190f, -0.14174731f, -0.12979771f, -0.00128816f, -0.07458112f, 
    0.11357813f, 0.00386155f, -0.03970053f, 0.04705394f, 0.01284942f, -0.04996874f, 0.02760048f, 0.08050971f, 
    -0.16150640f, -0.01098271f, -0.04962963f, 0.07247923f, 0.20436920f, -0.06326708f, -0.07956285f, -0.08998103f, 
    -0.12211264f, 0.06741520f, -0.06121086f, -0.01094828f, 0.03054107f, 0.00454502f, 0.04634600f, -0.01994471f, 
    -0.04517243f, -0.03067356f, 0.04218569f, 0.08695598f, 0.05650397f, 0.02631875f, 0.02123024f, -0.03235958f, 
    -0.09268255f, 0.09863129f, -0.25955826f, -0.01912191f, 0.17730932f, 0.07157870f, -0.11843925f, -0.00078894f, 
    0.02892158f, -0.07137195f, -0.03240953f, -0.01972781f, 0.08240440f, 0.01628164f, -0.00944448f, -0.05362966f, 
    0.02804316f, -0.03167608f, -0.06818347f, 0.01874950f, -0.00466117f, -0.19971569f, 0.24610491f, -0.27038899f, 
    0.09025395f, -0.05146763f, -0.03749166f, 0.01554226f, 0.06278342f, 0.08330634f, -0.00075738f, 0.04614715f, 
    0.05021760f, -0.00026135f, -0.00837480f, 0.08262149f, -0.02970309f, 0.00706604f, 0.04382229f, 0.01297839f, 
    0.11339911f, 0.21449865f, -0.04514468f, 0.00906870f, 0.03965644f, 0.08935092f, 0.02432972f, 0.01817642f, 
    0.04290279f, -0.10402095f, 0.19468249f, 0.07496263f, 0.04165047f, -0.05694878f, -0.07784192f, 0.09717023f, 
    0.05776753f, -0.01936292f, -0.04631022f, -0.00704634f, -0.04514422f, -0.17407598f, 0.04147609f, -0.12416826f, 
    -0.25589013f, 0.02280534f, -0.07649591f, 0.00172434f, -0.02496825f, 0.02375367f, -0.03192752f, 0.02852601f, 
    -0.04236437f, -0.05480418f, 0.04001045f, 0.15550663f, 0.03538786f, 0.01273150f, 0.09009635f, 0.01740123f, 
    -0.04799243f, -0.02878823f, -0.03648719f, 0.01772115f, -0.19853161f, -0.10165479f, -0.01718340f, -0.16096680f, 
    0.00610167f, -0.11297303f, 0.06258367f, 0.01708054f, -0.00164494f, 0.05809107f, 0.02270095f, 0.00851548f, 
    -0.06005051f, -0.01014942f, 0.07180879f, 0.08108441f, 0.18514536f, -0.12848966f, 0.10191657f, 0.05507211f, 
    -0.17894156f, -0.08848621f, 0.01806504f, 0.09463499f, -0.00686804f, 0.03370538f, 0.02374068f, -0.09228907f, 
    0.01753687f, -0.04930892f, 0.06646475f, 0.04405246f, 0.01040874f, -0.00089311f, -0.07646871f, 0.09177014f, 
    -0.11254445f, 0.08523696f, -0.02903376f, -0.09830558f, 0.28692263f, 0.05464346f, -0.00205862f, 0.01659709f, 
    0.05093653f, 0.02150354f, -0.06026421f, 0.11676144f, 0.05931826f, 0.01858346f, 0.13616493f, -0.02437714f, 
    0.06295191f, -0.07135735f, -0.03289387f, -0.01574938f, 0.15235342f, 0.23646781f, 0.01761175f, -0.02496735f, 
    -0.01676382f, -0.00846933f, 0.01816771f, -0.00013853f, 0.09415401f, -0.02116811f, -0.00555873f, -0.03554590f, 
    0.04175180f, -0.01922203f, -0.04515151f, -0.06739528f, 0.02151981f, -0.04425740f, -0.03561047f, 0.02300443f, 
    0.42354918f, 0.15962993f, 0.08160305f, -0.00249617f, 0.07251426f, -0.09290448f, -0.05360436f, -0.21040633f, 
    0.10455105f, -0.00516432f, -0.03780062f, -0.04970424f, 0.00290892f, 0.00824146f, 0.06520740f, 0.06288263f, 
    -0.07308610f, -0.00611025f, -0.01323616f, 0.06756625f, 0.02424546f, 0.11273531f, -0.23960191f, -0.05051969f, 
    0.21024702f, -0.02526698f, 0.06214095f, -0.02041325f, -0.00648602f, -0.00974687f, 0.01861373f, 0.01341614f, 
    0.05683986f, 0.00612160f, -0.04959925f, -0.01186222f, -0.01445942f, 0.05713455f, 0.09706622f, -0.01236452f, 
    0.38099277f, 0.04699023f, 0.05159818f, 0.05375140f, -0.17943060f, -0.01727547f, -0.17814568f, 0.01578074f, 
    0.00038721f, -0.07446609f, 0.01954698f, -0.01135818f, -0.02934403f, 0.04172817f, -0.01670057f, -0.03710443f, 
    -0.10106006f, 0.01800382f, -0.02775429f, -0.05429561f, -0.08502013f, -0.32180139f, 0.21651448f, -0.10041855f, 
    0.00319669f, 0.18767409f, -0.03734436f, -0.04027075f, 0.01787831f, 0.05938020f, 0.04215145f, 0.02332448f, 
    -0.07615304f, -0.03857808f, 0.01911221f, -0.01957705f, -0.00073645f, 0.01615181f, 0.06783421f, 0.02356200f, 
    -0.01644137f, -0.09892046f, 0.02933862f, -0.03386925f, -0.04037831f, -0.01839769f, 0.03547071f, 0.09983571f, 
    -0.07781980f, 0.00656919f, 0.01688109f, 0.09312665f, 0.01355728f, 0.00878909f, -0.08627001f, -0.00718089f, 
    0.11492731f, 0.01902657f, 0.02397033f, -0.06028452f, 0.29755127f, -0.11860805f, 0.08841262f, 0.03665783f, 
    -0.16173159f, -0.00333112f, -0.07941602f, -0.03389378f, -0.01379554f, 0.03978868f, 0.02878514f, 0.02072021f, 
    -0.08619449f, 0.02572884f, 0.09703994f, 0.01371102f, 0.06663775f, 0.00036470f, -0.05591374f, -0.01509809f, 
    0.10128077f, 0.08637566f, 0.05919059f, -0.03840828f, -0.19765663f, -0.15326756f, -0.10108689f, -0.15757473f, 
    0.03656257f, 0.03285258f, -0.01894084f, -0.04465926f, 0.07085411f, 0.05824434f, 0.03301990f, -0.04303897f, 
    -0.07996299f, 0.00285870f, 0.03702233f, 0.07562415f, -0.26359352f, 0.01918550f, 0.21482408f, -0.00938092f, 
    -0.21133232f, -0.02828518f, 0.07086615f, 0.01404862f, 0.11424309f, 0.05914464f, 0.02803730f, 0.06128362f, 
    0.05575552f, -0.14700992f, 0.04945458f, -0.05374628f, 0.08794044f, 0.04738081f, 0.06468554f, -0.02132643f, 
    0.17334473f, -0.05987667f, 0.02407019f, -0.10186614f, 0.02650187f, 0.00248897f, -0.02714630f, 0.09528340f, 
    0.07677869f, -0.00087533f, 0.04690118f, 0.05745336f, 0.09663307f, -0.01985198f, 0.04337295f, 0.12209474f, 
    -0.15952887f, 0.03335165f, 0.04733767f, -0.01066637f, 0.04786803f, 0.10683932f, -0.07363675f, -0.08640970f, 
    0.21614999f, 0.02521592f, -0.03801173f, -0.02105993f, -0.09173431f, -0.02163871f, 0.06841226f, 0.00221099f, 
    -0.05133057f, 0.02226862f, 0.02320295f, 0.06988185f, 0.02925303f, -0.03049187f, -0.07819356f, 0.02438836f, 
    -0.28645974f, 0.16681504f, -0.02877597f, 0.18652198f, -0.21210985f, -0.06022487f, 0.04752828f, 0.04026689f, 
    -0.03908397f, -0.04696520f, 0.05969103f, 0.02445469f, 0.06577262f, 0.00616657f, 0.02406032f, -0.00833374f, 
    0.03160509f, -0.01661761f, 0.18627992f, -0.08927680f, 0.22541934f, -0.17908548f, 0.08928970f, -0.03390837f, 
    -0.20387110f, 0.17242123f, 0.10462103f, 0.05853106f, -0.02574975f, -0.04402832f, 0.00679872f, 0.02460520f, 
    0.09083302f, -0.01448192f, 0.00462989f, 0.04493009f, -0.00044800f, 0.02243015f, 0.13244043f, 0.02365954f, 
    0.09155916f, -0.12913920f, 0.04079323f, -0.04831187f, -0.27499184f, 0.05741614f, -0.17598861f, -0.01456747f, 
    0.00166878f, -0.09095157f, -0.05987129f, -0.03960610f, 0.03879275f, 0.05782908f, -0.02494915f, -0.11195451f, 
    0.00432148f, 0.03573460f, -0.18254507f, -0.01652658f, 0.27628273f, 0.03204197f, -0.11263114f, -0.23157920f, 
    0.23858219f, -0.00877695f, 0.01936336f, 0.05123543f, 0.00663864f, -0.05645102f, 0.12074128f, 0.13872379f, 
    -0.00117782f, -0.02265588f, 0.02848539f, 0.04835581f, 0.05939791f, 0.14082380f, 0.02277109f, -0.06300188f, 
    0.00042806f, 0.01711197f, 0.02976117f, -0.03292947f, -0.02887909f, -0.03973655f, -0.04368737f, -0.01271263f, 
    -0.01852195f, -0.02696127f, 0.01467414f, -0.05637409f, 0.00101479f, 0.01601806f, -0.03388576f, -0.01898098f, 
    0.02179360f, 0.00884897f, -0.04686933f, -0.02867655f, 0.00959220f, 0.01773383f, -0.02151992f, -0.00586989f, 
    0.03518908f, -0.04553231f, 0.02747345f, -0.03153112f, -0.01355266f, -0.03720714f, -0.00398560f, 0.00376786f, 
    0.02288682f, 0.01813257f, 0.00019125f, 0.00980166f, -0.00137940f, -0.00306909f, 0.01961271f, -0.02579711f, 
    -0.04937042f, 0.00661369f, 0.00687707f, 0.02526345f, -0.00638445f, 0.02045562f, 0.02893542f, -0.04991984f, 
    -0.04016688f, -0.05655991f, -0.03600847f, -0.01607810f, -0.04016343f, -0.02688236f, -0.05198435f, -0.05194906f, 
    0.00652844f, 0.00735702f, -0.03565070f, -0.02934741f, -0.03468933f, -0.02179815f, -0.00077324f, -0.02869521f, 
    -0.03390824f, -0.03723627f, -0.01652917f, -0.02610725f, 0.03841204f, -0.00004652f, -0.01238048f, -0.02269074f, 
    -0.04227653f, -0.03944685f, -0.01497925f, 0.00628049f, 0.01566687f, -0.03161440f, -0.00947247f, -0.03684644f, 
    0.00418345f, -0.03245458f, -0.01562701f, -0.05002378f, -0.03204277f, -0.04353354f, 0.02828980f, -0.00473983f, 
    -0.00907196f, -0.03065471f, -0.05069060f, -0.02020676f, -0.03642312f, -0.02894705f, 0.02893849f, 0.02102145f, 
    -0.05441751f, -0.02625938f, 0.03278914f, 0.01983441f, 0.02037029f, 0.03342664f, -0.03341199f, -0.01778823f, 
    -0.04145916f, 0.01578379f, 0.01429380f, -0.02639151f, -0.02595329f, 0.01710500f, -0.02729673f, -0.04878142f, 
    0.01545533f, -0.00128193f, -0.02141747f, -0.05865364f, -0.02805690f, 0.00307418f, -0.00445379f, 0.02870215f, 
    0.01907908f, 0.00450654f, -0.05593009f, 0.03814657f, 0.02661908f, 0.01235857f, 0.03249555f, 0.01172709f, 
    -0.00216841f, -0.05805243f, -0.01178818f, -0.00672265f, -0.03561842f, -0.03547590f, -0.05091566f, 0.00027836f, 
    0.00038443f, -0.01051026f, -0.01015240f, -0.03837404f, 0.00634024f, -0.03651765f, -0.04213441f, 0.02525573f, 
    0.00552563f, -0.02997878f, -0.03695939f, 0.01578102f, -0.00693371f, 0.00788679f, 0.00862339f, 0.01809669f, 
    0.01277884f, -0.01183179f, -0.00063025f, -0.02727505f, -0.03709139f, -0.04457112f, 0.06166202f, -0.01777154f, 
    0.01083586f, 0.00187308f, -0.01483530f, 0.01331350f, -0.03352509f, 0.02922648f, 0.00340740f, 0.01749452f, 
    0.01314893f, 0.00653284f, 0.00019267f, -0.04302882f, -0.04688271f, 0.02365910f, 0.01112240f, 0.01672639f, 
    0.01880356f, -0.01273948f, -0.04490527f, -0.05565568f, -0.04488176f, -0.03023378f, 0.00450419f, -0.04464191f, 
    -0.02855267f, -0.00179144f, 0.01151433f, -0.04676340f, -0.00586797f, -0.02966681f, -0.03951021f, 0.00956198f, 
    -0.02843235f, -0.00659448f, -0.03180404f, 0.01566270f, -0.03176464f, 0.00718783f, -0.05971276f, -0.01933824f, 
    -0.02453282f, -0.04755663f, -0.00292134f, 0.03839310f, -0.01487893f, -0.01621034f, -0.01453157f, 0.00789742f, 
    -0.00111015f, -0.04342392f, 0.04707886f, 0.00420784f, -0.02476405f, -0.00602249f, -0.03079064f, 0.00899722f, 
    -0.02972429f, -0.01777602f, -0.02887610f, -0.03561887f, -0.05003730f, -0.00471532f, -0.01333452f, -0.00875797f, 
    -0.02654862f, -0.01443495f, 0.01927810f, -0.01993041f, 0.00614321f, -0.01932992f, 0.00330628f, 0.03635299f, 
    -0.01645759f, 0.03312226f, -0.00715022f, -0.03486706f, 0.00401284f, -0.00371547f, 0.02199161f, 0.02113491f, 
    0.00311658f, -0.03084400f, -0.01201399f, -0.02264976f, -0.04131919f, -0.02404366f, 0.03501154f, -0.00970469f, 
    0.02983120f, 0.01696529f, -0.04898969f, -0.06100420f, -0.01083672f, -0.03368291f, -0.02176845f, -0.00583014f, 
    0.03404798f, -0.00957857f, 0.01721253f, -0.02325223f, -0.00791618f, 0.00177781f, -0.02289432f, -0.02631212f, 
    -0.01391551f, 0.02155956f, -0.01655068f, -0.01342204f, 0.01797010f, 0.02903525f, -0.05004900f, 0.00078686f, 
    0.05566842f, 0.00418510f, -0.03210291f, -0.01680874f, -0.01562418f, 0.00999236f, -0.05977618f, -0.03368688f, 
    0.01528512f, 0.03094779f, 0.01908402f, -0.05682544f, -0.04570429f, -0.04128022f, -0.01515410f, 0.00947134f, 
    -0.00997706f, -0.02788613f, 0.02976712f, -0.06393564f, -0.00677477f, 0.02242051f, 0.03770031f, -0.00953302f, 
    0.01653589f, 0.01466583f, -0.01137268f, -0.03774849f, 0.00606497f, -0.03753726f, -0.03484586f, -0.02625242f, 
    -0.02689270f, -0.01392432f, 0.00776602f, -0.02981094f, -0.05475667f, -0.01086391f, 0.02444713f, -0.04208340f, 
    -0.00889267f, -0.05074209f, -0.02497181f, 0.02557343f, -0.01377898f, 0.00894425f, 0.00970566f, -0.00511809f, 
    -0.03307315f, -0.01198354f, 0.01183625f, 0.03102266f, 0.00326154f, -0.03551229f, -0.04158756f, -0.02670023f, 
    -0.01982979f, -0.00280589f, 0.01958560f, -0.06010851f, -0.06317922f, -0.05115166f, 0.01134962f, 0.01269353f, 
    -0.04071566f, -0.03234598f, 0.03212672f, 0.01059884f, -0.01148491f, -0.00818487f, 0.01273286f, 0.00830639f, 
    -0.00345934f, -0.01601134f, 0.03851441f, -0.00091410f, -0.02579221f, 0.00025623f, 0.03519519f, -0.00976095f, 
    0.02014972f, -0.05884952f, -0.04846125f, 0.01428086f, -0.02516954f, -0.02444647f, -0.02630693f, 0.00124892f, 
    0.00474317f, -0.06130166f, -0.00173906f, -0.05926943f, 0.00177368f, 0.00174689f, -0.01595726f, 0.01347045f, 
    -0.00888544f, 0.00083449f, 0.00740752f, -0.00210712f, 0.01184013f, -0.04213863f, -0.03602039f, -0.02636909f, 
    0.00501444f, 0.03841281f, 0.02720929f, 0.03491848f, 0.00088811f, 0.00037917f, -0.03158171f, -0.02988875f, 
    -0.04315783f, 0.01311263f, -0.02454347f, -0.00432899f, -0.02486912f, 0.02283907f, 0.03685365f, -0.06252608f, 
    0.00753491f, -0.02021408f, -0.01509211f, 0.00440232f, -0.03914567f, 0.03791235f, -0.03830174f, 0.01238170f, 
    -0.00664394f, -0.03942317f, 0.02349387f, -0.05477895f, -0.03125075f, -0.00926201f, 0.03661506f, -0.03650340f, 
    -0.00430405f, -0.02437248f, 0.00277237f, -0.01956670f, 0.02890490f, 0.03229401f, -0.02077583f, 0.01552230f, 
    -0.01579319f, 0.02809143f, 0.05606445f, -0.03771014f, 0.01687935f, -0.02983547f, 0.00556338f, -0.00531320f, 
    0.02405116f, -0.02101030f, -0.00148520f, 0.01204311f, -0.01712066f, 0.02686757f, 0.01694697f, 0.01373980f, 
    0.01433817f, -0.03488538f, -0.00332379f, -0.03053030f, -0.02709208f, -0.06021240f, 0.02415664f, 0.04437186f, 
    -0.04922856f, -0.03544476f, -0.01740418f, -0.05719735f, -0.01722157f, -0.00147372f, 0.00678450f, -0.05595753f, 
    0.01839683f, 0.02222098f, -0.03462561f, -0.01027303f, 0.02256392f, -0.03417631f, 0.01006136f, -0.00137721f, 
    -0.00057177f, -0.05259604f, -0.02389606f, -0.01867957f, -0.04952335f, -0.02454804f, -0.02066326f, -0.00147784f, 
    -0.01110453f, -0.01633406f, -0.00950576f, 0.00692680f, -0.03479325f, -0.04393167f, -0.04764174f, -0.03153079f, 
    -0.02893499f, 0.00660075f, -0.01447057f, -0.00332741f, 0.00586124f, 0.02029107f, 0.02922727f, 0.04213212f, 
    -0.00795582f, -0.00576170f, -0.01003390f, 0.01455867f, 0.01382834f, -0.01396034f, -0.00168751f, 0.01225282f, 
    -0.05364183f, -0.02632420f, 0.00485471f, -0.03323022f, 0.00018560f, 0.02584514f, -0.01121545f, -0.02794413f, 
    -0.00387331f, 0.02733902f, -0.05412477f, -0.00318415f, -0.00755957f, -0.01246521f, 0.01380912f, -0.02988725f, 
    -0.00238047f, 0.02169436f, -0.03593629f, 0.03372801f, -0.02059739f, 0.03146986f, 0.03303631f, 0.01910976f, 
    -0.03778914f, -0.05599064f, -0.03422821f, 0.00342553f, 0.00520716f, -0.00154583f, 0.02871925f, -0.02101585f, 
    -0.04991227f, -0.03967639f, 0.00186911f, -0.01240881f, 0.00195301f, 0.02687247f, 0.01548669f, -0.04712451f, 
    0.01681679f, -0.02619427f, 0.00405066f, -0.01235614f, -0.04278840f, 0.01815804f, 0.01192706f, -0.02637737f, 
    0.01889629f, -0.01016399f, 0.00801075f, -0.06255546f, 0.01925180f, -0.03720543f, -0.03239991f, -0.00904013f, 
    -0.05335016f, 0.02777187f, -0.02290199f, 0.04582952f, 0.03297367f, -0.03005811f, -0.02979877f, -0.02722606f, 
    0.01186438f, -0.02289087f, -0.05075447f, -0.03753778f, -0.03438605f, -0.00583161f, 0.01810366f, -0.01523349f, 
    -0.04176189f, -0.00013090f, 0.01263764f, -0.03703781f, 0.00996301f, 0.02036114f, -0.02650779f, 0.03693487f, 
    0.00794642f, 0.00664563f, 0.01833259f, -0.02788174f, -0.02457721f, -0.02324792f, -0.02191665f, 0.00275524f, 
    -0.01926124f, -0.01804815f, -0.03383685f, -0.03257414f, -0.02984822f, -0.00749956f, -0.04213883f, -0.02011663f, 
    0.01292731f, -0.05180842f, -0.02278876f, -0.01730942f, -0.00646625f, -0.02532698f, 0.02220948f, -0.04673149f, 
    -0.01065722f, -0.00882719f, -0.03574481f, -0.05135029f, -0.02381599f, -0.01658451f, -0.05189053f, -0.00243187f, 
    0.04305727f, 0.01868512f, 0.00169351f, -0.01419690f, 0.03851594f, -0.01878013f, 0.02330434f, -0.01874439f, 
    -0.04571704f, 0.01125898f, -0.06266075f, -0.00878440f, -0.03785861f, -0.02409267f, 0.01921835f, -0.04439274f, 
    -0.04175646f, -0.05102726f, -0.01610423f, 0.04407807f, -0.00878873f, 0.01192253f, -0.00828174f, 0.02524022f, 
    -0.03502460f, 0.03040965f, -0.02531170f, -0.00264541f, 0.01479404f, -0.00718342f, -0.02231291f, -0.05866772f, 
    -0.04316733f, -0.01601466f, -0.01127149f, -0.03773173f, 0.01177084f, 0.01074338f, 0.01980247f, -0.03257696f, 
    -0.06381348f, 0.33791503f, -0.07772786f, -0.04954540f, 0.19686639f, -0.06638749f, -0.14224474f, -0.00763838f, 
    0.01205410f, 0.03785500f, 0.11397815f, -0.04947382f, 0.00086545f, 0.00165447f, 0.04067630f, 0.03389130f, 
    0.04868889f, 0.02958149f, -0.15175031f, -0.02994430f, 0.07298151f, -0.10739572f, -0.10700178f, -0.18282187f, 
    0.10370326f, 0.09287405f, -0.04553383f, 0.06506854f, -0.04660819f, -0.00312023f, -0.11061895f, -0.06835973f, 
    -0.05152442f, -0.03819460f, 0.04208355f, -0.04261291f, 0.02341565f, 0.01112706f, -0.03263959f, 0.08875979f, 
    0.26923957f, -0.12442592f, -0.22823265f, 0.11540959f, -0.03985065f, -0.05862631f, 0.03608542f, -0.00602954f, 
    -0.05702401f, 0.07463253f, -0.01489359f, -0.04408648f, 0.03242995f, -0.06161040f, 0.08937071f, 0.11007336f, 
    0.10586485f, 0.10387049f, -0.07531820f, 0.06911907f, 0.18179643f, -0.18557963f, 0.01639600f, 0.11820276f, 
    0.33847380f, -0.05649796f, 0.06039954f, -0.01077729f, 0.04172365f, -0.11287457f, 0.03221086f, 0.01481545f, 
    -0.03552132f, 0.05017655f, 0.02957146f, -0.07667089f, -0.02910255f, -0.00657707f, -0.03216378f, -0.02723396f, 
    0.03385008f, 0.09352611f, -0.00087738f, -0.00149291f, 0.01596989f, 0.05611642f, -0.00463287f, 0.07304004f, 
    0.00302550f, 0.05425590f, 0.07257090f, -0.03390695f, 0.01718426f, 0.02836108f, -0.06684225f, 0.12207852f, 
    -0.03223076f, -0.06899719f, -0.06164560f, 0.13944417f, 0.11090364f, -0.19700234f, 0.13114862f, 0.00984505f, 
    0.14071314f, 0.03850677f, -0.00338167f, 0.04913114f, 0.06095819f, -0.03693928f, -0.02514706f, -0.05211135f, 
    0.12508105f, 0.01504981f, -0.07310861f, 0.02776512f, 0.00676946f, 0.03942638f, -0.01874044f, 0.00341711f, 
    -0.10341454f, -0.19227795f, 0.03331156f, 0.02361503f, -0.02461887f, -0.05509820f, 0.00654243f, 0.03111167f, 
    0.05460761f, 0.01108142f, -0.07098556f, 0.10608651f, 0.01111719f, -0.02139484f, 0.01173474f, -0.09503553f, 
    0.12613040f, 0.11955070f, 0.05568563f, 0.10902196f, 0.26221496f, -0.39427584f, -0.13332747f, -0.03441383f, 
    -0.05150763f, -0.04735690f, 0.05374766f, -0.01045623f, 0.03944495f, 0.04482477f, -0.01896391f, 0.00107325f, 
    0.02891464f, 0.02090983f, -0.04603344f, 0.00163645f, 0.02108383f, -0.00326803f, -0.01989345f, 0.01666479f, 
    -0.00052690f, -0.12081884f, -0.13694267f, -0.01480897f, -0.22359833f, -0.06427360f, 0.08968706f, -0.04188890f, 
    -0.03220018f, 0.04990895f, 0.00507083f, 0.15104069f, -0.00087193f, -0.01865467f, -0.00537753f, -0.03461674f, 
    -0.13409948f, 0.03503384f, -0.11464425f, 0.11740766f, 0.09438748f, 0.11422359f, -0.06555487f, 0.04016200f, 
    0.05705437f, 0.02256316f, -0.05974011f, 0.06660447f, -0.00221739f, 0.10363251f, -0.01311894f, -0.11840344f, 
    0.03319420f, -0.03485774f, 0.09573757f, 0.09024058f, 0.07633429f, -0.01555197f, 0.02644706f, -0.05211707f, 
    -0.14374737f, 0.14158177f, 0.01860506f, 0.09742333f, 0.09006212f, -0.02606465f, -0.12571785f, -0.04189504f, 
    0.08267550f, -0.06176746f, -0.03192147f, -0.02537604f, -0.00638234f, 0.07530326f, 0.01528724f, 0.07443129f, 
    0.05851782f, 0.08103340f, -0.07569045f, 0.01010911f, 0.24063152f, -0.41141883f, 0.06450476f, -0.00519285f, 
    0.07040662f, 0.06184473f, -0.04836113f, -0.07285684f, 0.09251546f, 0.11204079f, -0.01382027f, 0.03812355f, 
    -0.08525330f, 0.09117786f, -0.09162419f, 0.05951928f, 0.01649168f, 0.05060836f, 0.02328704f, 0.00606085f, 
    -0.04072867f, 0.18498330f, -0.01751272f, 0.10672242f, -0.03585119f, 0.17726341f, -0.01647463f, 0.03169374f, 
    0.06963873f, 0.00057286f, 0.02264946f, 0.07108192f, -0.07307159f, 0.01529026f, -0.07297838f, 0.12721689f, 
    0.00021638f, -0.14197652f, 0.03505828f, 0.05000007f, 0.19827256f, 0.11973963f, 0.00964509f, -0.05753385f, 
    -0.01133138f, 0.11081541f, -0.08606915f, 0.10411560f, 0.02832148f, 0.06551550f, -0.11611494f, -0.07534805f, 
    0.00265682f, 0.03257110f, 0.02576590f, 0.05209959f, 0.00705970f, -0.09468169f, 0.01922906f, -0.04968120f, 
    0.09323355f, -0.09834593f, -0.04268596f, -0.03396725f, -0.07647595f, -0.06059081f, -0.10509554f, -0.09824891f, 
    0.06689740f, -0.11184955f, 0.03699067f, -0.04209618f, -0.00270787f, -0.02255066f, -0.05661477f, 0.03901491f, 
    -0.03820792f, -0.01396829f, -0.02361037f, 0.06630274f, 0.21079688f, 0.03947272f, 0.02950701f, 0.15954939f, 
    -0.08658762f, -0.10884052f, -0.02190562f, 0.09564331f, 0.02450818f, 0.00656846f, 0.11352426f, -0.07501022f, 
    -0.03170454f, -0.02479916f, 0.00227287f, 0.00160995f, 0.00372721f, 0.10058994f, -0.07804277f, 0.02912162f, 
    -0.16373965f, 0.12953015f, 0.06454934f, 0.04301338f, 0.16906510f, -0.05962279f, -0.04219260f, 0.05786835f, 
    0.06397413f, 0.03813577f, -0.13413481f, 0.02640857f, -0.01359843f, 0.02564703f, -0.00102708f, 0.05699980f, 
    0.03002865f, 0.02125116f, -0.00997754f, 0.02745503f, 0.21166195f, -0.14359751f, -0.03884286f, -0.02667123f, 
    -0.02923149f, 0.00624137f, 0.08311927f, 0.04977226f, 0.07677788f, -0.02400985f, 0.03939617f, -0.04757092f, 
    0.05830752f, 0.05380896f, -0.09033164f, -0.00244120f, 0.00697714f, -0.06832865f, -0.03897315f, 0.00256062f, 
    0.06125846f, 0.10003194f, -0.11176892f, -0.04239035f, -0.08828807f, -0.06016992f, 0.08378442f, -0.02813874f, 
    -0.03517144f, -0.10850714f, -0.07313427f, 0.02587423f, -0.02108087f, 0.05099094f, 0.11488342f, 0.01554919f, 
    0.01838181f, 0.00571981f, -0.05596814f, 0.05431509f, -0.12560585f, 0.10756570f, -0.03729134f, -0.14111815f, 
    0.23669112f, -0.00854779f, 0.09956722f, 0.06823569f, -0.02454855f, 0.02494340f, -0.04333211f, -0.05013854f, 
    0.01764505f, -0.01625359f, -0.02570025f, 0.01704377f, 0.02008671f, 0.02269235f, 0.02917902f, -0.00383458f, 
    0.27573791f, -0.07760131f, -0.21108840f, 0.01508124f, -0.20418195f, -0.02951844f, -0.08067033f, -0.02716286f, 
    -0.01791535f, -0.16523832f, -0.03889079f, 0.02456839f, 0.08071127f, 0.00373432f, -0.01493618f, -0.02598929f, 
    -0.01435676f, -0.03137086f, 0.01243423f, -0.03100043f, 0.15481745f, -0.30538949f, 0.10668503f, -0.14940573f, 
    0.05708401f, 0.00123786f, -0.02167392f, -0.00630142f, -0.04132724f, 0.02667985f, 0.05138038f, 0.00584822f, 
    0.04553131f, -0.09055166f, 0.03306246f, -0.01679270f, 0.02995979f, -0.10570633f, 0.08378197f, 0.11701937f, 
    0.12032219f, -0.24184261f, 0.09024123f, -0.08113199f, 0.13163936f, -0.02255428f, 0.05216559f, 0.07052477f, 
    0.06518312f, 0.01025330f, -0.11287529f, -0.00117894f, 0.04263220f, 0.03324208f, -0.02364530f, 0.04276716f, 
    0.10911993f, -0.00233495f, 0.00882707f, -0.07122323f, 0.36243412f, 0.05279499f, -0.14359668f, 0.05433638f, 
    -0.04987346f, 0.03616277f, -0.08113038f, 0.05004660f, -0.03557600f, -0.00838468f, 0.07320316f, -0.00080521f, 
    -0.09509727f, -0.00635794f, -0.00266281f, -0.06281482f, 0.06211764f, -0.03863898f, -0.01501201f, 0.00748019f, 
    0.21746169f, 0.17372972f, -0.03342241f, -0.04726046f, -0.30466264f, -0.03136603f, -0.09895067f, 0.02112984f, 
    -0.03128740f, 0.01447109f, -0.03168413f, -0.05223243f, 0.07452871f, 0.00810845f, -0.02868215f, -0.01259676f, 
    0.08117819f, -0.03938164f, 0.02426075f, 0.01335028f, -0.25792229f, -0.14133485f, 0.08848979f, 0.06562850f, 
    -0.18366100f, -0.01167332f, 0.13718501f, 0.15297182f, -0.03908139f, 0.29271334f, 0.04972854f, 0.12186927f, 
    -0.02396967f, -0.04461190f, 0.10653885f, 0.01892475f, 0.03718466f, 0.00843394f, 0.11491291f, 0.01766953f, 
    0.15814720f, -0.27994958f, -0.00868716f, 0.06312874f, 0.01277279f, -0.10198983f, -0.04786113f, 0.02099209f, 
    0.08525095f, 0.01799801f, -0.01212590f, -0.02864287f, -0.09849015f, -0.03746333f, 0.05801869f, -0.07114734f, 
    -0.00660171f, -0.04144181f, -0.01112818f, -0.05534698f, 0.06881060f, 0.16950682f, 0.06657165f, 0.08346043f, 
    0.07732619f, -0.18335769f, -0.11872151f, 0.07448035f, 0.01615633f, 0.15525796f, 0.03245663f, -0.07778662f, 
    -0.00468186f, 0.04783029f, 0.03989621f, 0.13489293f, 0.04471039f, 0.00557606f, -0.01826497f, -0.05060704f, 
    -0.37183118f, 0.16371857f, 0.14957960f, -0.03958016f, -0.19283430f, -0.05435540f, 0.04300665f, 0.01663173f, 
    -0.01199025f, 0.08359832f, -0.04543834f, 0.04154873f, -0.01598736f, 0.01183493f, -0.00811889f, 0.02870974f, 
    -0.07890245f, -0.09966320f, 0.28819361f, -0.10677007f, -0.03766943f, -0.11194831f, 0.03384686f, 0.00697891f, 
    0.16080691f, 0.10429243f, 0.02901209f, 0.15043417f, 0.08820281f, -0.01126886f, -0.02968741f, 0.14569029f, 
    0.08775627f, 0.00181830f, 0.02218430f, 0.04613768f, -0.06516260f, -0.01907024f, 0.07060676f, -0.10467976f, 
    0.22122051f, -0.00323586f, -0.13370387f, -0.05270942f, 0.02969107f, 0.03723974f, -0.09935682f, 0.11309469f, 
    0.01393480f, -0.03756807f, -0.04927042f, -0.09384521f, 0.00205985f, 0.08958732f, -0.05553925f, -0.02282130f, 
    0.08016037f, -0.08810940f, -0.07520137f, -0.01908596f, 0.17698599f, 0.09291729f, -0.08789419f, -0.10997863f, 
    0.01552253f, -0.06161734f, 0.02039162f, 0.03642758f, 0.07327549f, 0.04357836f, 0.10949323f, 0.05961012f, 
    0.06063118f, 0.06172344f, -0.01886246f, 0.02413060f, 0.00785730f, -0.04256347f, -0.02021654f, -0.05565181f, 
    0.03429731f, 0.02400215f, 0.03737538f, 0.02455529f, -0.00677358f, -0.02271804f, 0.01311968f, -0.03250035f, 
    0.04323864f, -0.00833393f, 0.03493132f, 0.00158832f, -0.01213158f, 0.00257790f, -0.03008625f, 0.01652418f, 
    0.03115011f, -0.01085776f, -0.01650966f, -0.01776070f, 0.01352342f, -0.03981720f, -0.03713349f, 0.00346782f, 
    0.02630200f, 0.03078225f, 0.00222096f, 0.00711106f, 0.00630779f, -0.04262606f, 0.02834523f, -0.02644242f, 
    0.02162856f, 0.01979534f, -0.02886896f, -0.02557871f, 0.03190531f, 0.00102678f, -0.03865963f, 0.00034987f, 
    0.00469394f, -0.02435178f, -0.03992438f, -0.02574177f, -0.00049626f, -0.00242659f, 0.00030568f, -0.02710613f, 
    0.00543108f, -0.00025732f, -0.02118213f, -0.03072057f, 0.03388704f, 0.00105717f, 0.03278860f, 0.01672141f, 
    0.02082980f, 0.03930764f, -0.02938811f, -0.00213365f, 0.01703071f, -0.01974658f, -0.00723808f, 0.00768970f, 
    0.02402072f, -0.03485779f, 0.00183739f, -0.03965772f, 0.00834745f, 0.02249680f, 0.02698535f, 0.04334614f, 
    -0.02892340f, 0.02917125f, -0.03281335f, 0.03230888f, 0.02838973f, -0.04436926f, -0.00353339f, -0.02190370f, 
    -0.01308171f, 0.01988646f, -0.00579102f, -0.04915281f, -0.05218760f, -0.03043181f, -0.02958336f, 0.03548539f, 
    -0.03154551f, -0.02634446f, -0.02725548f, 0.01602501f, -0.01229108f, -0.00013023f, 0.00621856f, 0.00996201f, 
    0.02766206f, -0.02852348f, -0.04109960f, -0.02412253f, -0.02040941f, -0.02265183f, -0.04442197f, 0.01572505f, 
    -0.02998540f, -0.04247592f, -0.01955668f, -0.00967357f, -0.01363282f, -0.02266817f, 0.03761379f, 0.00660253f, 
    -0.00508693f, 0.02392633f, 0.01247193f, 0.02554012f, -0.00956748f, 0.01865544f, -0.03749825f, 0.00854387f, 
    0.02971945f, 0.02161988f, 0.00643364f, 0.03255695f, -0.02602670f, -0.00671300f, -0.02836851f, -0.03664144f, 
    0.00246775f, 0.01177653f, 0.00553982f, 0.00566522f, 0.01915146f, -0.05067535f, 0.00811940f, 0.01028325f, 
    -0.00374430f, -0.02249820f, 0.02007670f, 0.03387154f, -0.01799945f, 0.01079683f, -0.02158855f, -0.03016533f, 
    -0.01841125f, -0.02657444f, 0.01911602f, 0.01429093f, 0.00860407f, -0.00871768f, -0.01300567f, 0.00179188f, 
    0.01210914f, 0.02754544f, 0.02068095f, -0.00705486f, 0.02058065f, -0.00316273f, -0.00694501f, -0.00682037f, 
    -0.00844205f, 0.01186615f, -0.03838025f, -0.03268870f, 0.02190284f, -0.04182890f, -0.01911089f, -0.02278599f, 
    0.01122217f, -0.02561346f, -0.03271554f, 0.01594654f, 0.03484120f, -0.04706130f, 0.01192746f, -0.02512254f, 
    -0.02587854f, 0.01859669f, 0.02954240f, -0.01757724f, -0.00366775f, 0.00018291f, 0.01491745f, 0.01959274f, 
    -0.03389182f, -0.00981017f, -0.00097963f, -0.01376581f, -0.02943037f, -0.03956015f, -0.02649088f, 0.01776145f, 
    0.01027181f, 0.03243425f, 0.02839914f, 0.02385865f, -0.00591910f, 0.01748368f, 0.00143441f, -0.03737440f, 
    0.00578205f, -0.01696317f, 0.03871231f, 0.01579194f, -0.02534558f, -0.02798857f, -0.00015674f, 0.02569893f, 
    0.03283443f, 0.02679591f, -0.00657234f, 0.01228377f, 0.00063152f, -0.02025292f, -0.03645312f, 0.01435317f, 
    -0.01543345f, -0.03100661f, 0.03671768f, -0.00499284f, 0.00072476f, -0.04651083f, -0.03008600f, -0.03499009f, 
    -0.00147512f, 0.03587937f, -0.02132691f, -0.03006428f, 0.00495875f, 0.00977748f, -0.03421741f, 0.02131885f, 
    0.02944965f, 0.02120360f, 0.00715495f, -0.01777428f, -0.00601165f, -0.04692631f, -0.03476233f, 0.03104240f, 
    -0.02059270f, -0.03589038f, -0.04409081f, -0.05070539f, -0.05197495f, 0.02571236f, 0.02917647f, -0.03744879f, 
    0.02681453f, 0.03241824f, 0.02500794f, -0.01834104f, -0.03743475f, 0.03318045f, -0.01505713f, -0.00276760f, 
    -0.01799369f, -0.04600464f, 0.00703988f, 0.00820092f, 0.04299240f, -0.04884550f, -0.04462229f, 0.00090988f, 
    0.00803779f, 0.02436464f, -0.03275084f, -0.04293114f, -0.00500809f, -0.03926796f, -0.00232933f, -0.02341137f, 
    -0.02424394f, -0.00831303f, 0.02784014f, -0.00270382f, 0.00883943f, -0.04556927f, 0.02741225f, -0.03460770f, 
    -0.03981046f, -0.01055435f, -0.00951412f, 0.00560170f, 0.00646787f, -0.00496658f, -0.03154930f, -0.03021005f, 
    -0.01836900f, -0.03556756f, 0.03982070f, 0.01316909f, 0.03205477f, -0.01366315f, -0.01722654f, -0.03234908f, 
    -0.02898728f, -0.03137347f, 0.01755035f, 0.02411399f, -0.01147297f, 0.02571334f, -0.03017031f, -0.01867670f, 
    0.03115152f, 0.00296870f, 0.02229124f, -0.02693451f, -0.01606038f, 0.00086576f, -0.01752108f, -0.00305637f, 
    0.02688789f, 0.01147622f, -0.00688236f, 0.02998473f, -0.02408498f, -0.03334825f, 0.02602976f, 0.02968048f, 
    -0.00078915f, -0.01274384f, 0.01407671f, -0.00398479f, -0.04765637f, 0.01865275f, 0.00840877f, -0.01030640f, 
    0.01266301f, -0.00509071f, -0.02401910f, -0.01773189f, -0.01059639f, -0.01202741f, 0.01961017f, -0.03553554f, 
    -0.02795170f, 0.02190173f, -0.03257557f, 0.02965415f, -0.00611317f, 0.01385505f, 0.01640487f, -0.04018065f, 
    -0.02684126f, -0.02759650f, 0.02686932f, 0.02485218f, 0.03113134f, 0.01054994f, -0.01901260f, 0.00936466f, 
    0.00452473f, -0.04662196f, -0.03844816f, -0.02165199f, 0.00289372f, -0.03005182f, -0.01208484f, 0.03142143f, 
    0.01662549f, -0.01447977f, 0.01032224f, 0.00322248f, 0.01150857f, -0.02110067f, 0.02762906f, -0.04166036f, 
    -0.00847774f, -0.02023768f, 0.00388727f, -0.01476861f, 0.02312445f, 0.00075812f, 0.03267514f, 0.02194316f, 
    0.03068692f, -0.04000286f, 0.02855752f, -0.00910565f, 0.01422823f, -0.01879362f, 0.02444174f, 0.01023460f, 
    0.00579934f, -0.01109675f, -0.00195459f, 0.00903187f, 0.03340847f, -0.02484642f, 0.00712862f, 0.02923252f, 
    0.00831481f, 0.01541203f, -0.01150777f, -0.03490598f, 0.01411096f, 0.02207234f, 0.03390669f, -0.04175619f, 
    0.01851005f, -0.03899666f, -0.01407720f, 0.02711601f, 0.00314968f, -0.03850293f, 0.02587484f, 0.00071533f, 
    -0.03430640f, -0.03705291f, -0.02836256f, -0.00433375f, 0.02824422f, 0.01314496f, 0.01841822f, 0.02990981f, 
    0.00830479f, -0.02566628f, -0.02459480f, -0.02278799f, 0.02293853f, 0.01668225f, -0.04473192f, -0.03717275f, 
    -0.03103782f, -0.02812873f, 0.01518889f, -0.02139019f, 0.00588998f, 0.03909507f, -0.03794964f, 0.00159011f, 
    0.00390693f, -0.03567591f, -0.03947008f, 0.02269155f, -0.00566239f, -0.03689381f, -0.04306442f, -0.00131188f, 
    -0.02456822f, -0.05580506f, -0.00790435f, -0.01568483f, 0.01903289f, -0.02455365f, -0.03221528f, -0.01510373f, 
    -0.03686967f, -0.02686235f, -0.02185878f, -0.00314541f, -0.02273685f, -0.00038951f, -0.00580058f, -0.00698169f, 
    -0.02264385f, -0.01284613f, -0.01114185f, 0.02969895f, 0.04134280f, 0.01403487f, -0.04772053f, 0.01341782f, 
    -0.00002484f, -0.01389228f, 0.02465657f, -0.01259384f, -0.03785860f, 0.00991794f, -0.00586971f, -0.00382325f, 
    0.02155223f, 0.01735856f, 0.00245318f, -0.04282918f, -0.01874531f, -0.02904930f, -0.00298125f, -0.04376286f, 
    0.01730194f, 0.02226402f, -0.00068375f, 0.01715976f, 0.02495272f, 0.00244426f, 0.02707453f, 0.02860290f, 
    0.01501479f, 0.00912683f, -0.03598651f, -0.02834086f, 0.01221030f, -0.03027522f, -0.02481970f, 0.03347870f, 
    -0.00871717f, 0.02405592f, 0.01274365f, -0.04899942f, -0.01175151f, -0.01510606f, -0.04660787f, -0.02700214f, 
    0.01598717f, 0.00301550f, 0.02415587f, 0.01423906f, 0.01593038f, 0.03703029f, -0.02862012f, -0.01875411f, 
    0.02781335f, -0.02266655f, 0.03519205f, -0.02601013f, 0.02173863f, 0.00956171f, -0.03610151f, 0.01048095f, 
    0.02615648f, -0.01003129f, -0.00057171f, 0.04607931f, -0.00992137f, -0.00558456f, 0.03670190f, -0.00951205f, 
    -0.04189623f, 0.00224555f, 0.02776679f, 0.02941800f, 0.02468120f, 0.00634562f, -0.00465012f, -0.04403955f, 
    -0.04462795f, 0.01274447f, -0.01241288f, -0.02738346f, -0.03250793f, 0.01381396f, 0.02866976f, 0.03066612f, 
    0.00944872f, -0.03440620f, 0.01617814f, 0.04661272f, -0.01264197f, 0.04553708f, 0.00372323f, -0.02929490f, 
    -0.03189679f, 0.01787194f, 0.03303603f, -0.01465528f, 0.03446023f, 0.01642853f, 0.01695168f, -0.02750855f, 
    0.02166665f, 0.01778322f, -0.00936348f, 0.00366401f, -0.00429600f, 0.02018773f, -0.02385711f, 0.00687785f, 
    -0.01670972f, -0.03853550f, -0.00113703f, 0.03161044f, -0.01270815f, 0.03217706f, 0.01595675f, 0.03097284f, 
    -0.02612720f, 0.01938531f, -0.04014497f, -0.04434133f, 0.01776902f, 0.02075050f, -0.02787735f, 0.00334578f, 
    0.00781485f, -0.01828620f, 0.02555012f, 0.00183522f, -0.00994616f, 0.01500228f, -0.01483558f, -0.00593353f, 
    0.01154439f, -0.01355534f, -0.03876761f, -0.03342164f, -0.03189291f, -0.01885068f, -0.01667532f, -0.01282992f, 
    -0.01982093f, -0.00861907f, -0.05169206f, -0.04575269f, 0.00195089f, -0.00400281f, -0.01711024f, -0.03647279f, 
    0.00557220f, 0.01801192f, 0.00382071f, -0.03722809f, -0.04187958f, -0.00298736f, -0.02513018f, -0.02271396f, 
    0.02941308f, 0.01886296f, 0.02590316f, -0.02830812f, -0.00526298f, 0.03269428f, -0.03328691f, 0.00386221f, 
    -0.01394287f, 0.03863748f, -0.01352668f, -0.02428833f, 0.03397222f, 0.00402744f, 0.01446274f, 0.01277393f, 
    0.01739176f, -0.01195195f, -0.01498981f, -0.00876547f, -0.02059831f, 0.02791348f, -0.00061389f, -0.02036663f, 
    0.03058359f, 0.05993350f, -0.33024421f, 0.05548362f, 0.06446397f, -0.08118447f, -0.08904601f, -0.07509421f, 
    -0.01113169f, 0.03500500f, 0.05920956f, 0.07167152f, 0.05542858f, 0.01893931f, 0.09840389f, -0.02428935f, 
    0.10344329f, 0.02423534f, -0.08580599f, 0.03244367f, 0.19466713f, 0.06830943f, -0.02522400f, 0.18357942f, 
    0.08295649f, 0.03174235f, -0.10455190f, 0.08449323f, 0.02515826f, 0.03814596f, 0.06160771f, 0.04785904f, 
    -0.00650207f, -0.00315057f, -0.01880212f, -0.01416971f, 0.00672821f, 0.05915422f, 0.08601455f, -0.05862185f, 
    -0.08250412f, 0.23269936f, -0.12121203f, -0.12541127f, -0.03607593f, -0.02266882f, -0.05190592f, 0.02942898f, 
    -0.03764822f, -0.00510241f, -0.01715429f, 0.08264122f, -0.09259954f, 0.09626143f, 0.03989464f, 0.15130965f, 
    0.03723612f, -0.05557828f, 0.09731892f, 0.00112600f, 0.23284939f, 0.29113141f, -0.18128385f, 0.22644876f, 
    0.30748361f, -0.02543926f, 0.01514358f, -0.26794958f, -0.00030804f, 0.01092358f, 0.09516038f, -0.02702756f, 
    -0.12492503f, 0.04578837f, 0.05995379f, 0.03326450f, 0.03965919f, -0.09691092f, 0.01963490f, 0.09819270f, 
    0.15178761f, 0.01805963f, -0.16913550f, 0.14758737f, 0.31752586f, 0.13709907f, -0.19507833f, -0.11394232f, 
    0.03100324f, -0.00017824f, 0.06435416f, -0.04431209f, -0.09147778f, 0.12928036f, 0.04551274f, -0.00192001f, 
    -0.01072288f, 0.11823837f, 0.12045176f, -0.00547009f, -0.24709584f, -0.07412617f, 0.20972511f, 0.01116439f, 
    0.06382526f, -0.01721829f, -0.04147540f, -0.05213819f, 0.02665389f, 0.04864614f, -0.01197266f, -0.00596530f, 
    -0.05866233f, 0.03747752f, 0.06570023f, 0.04212403f, -0.00664866f, -0.00220487f, -0.07469255f, 0.09852798f, 
    -0.12346415f, -0.03474934f, 0.00636716f, -0.07044639f, -0.28168339f, 0.06740573f, -0.05497339f, 0.05899689f, 
    -0.16662848f, 0.09143462f, -0.00111253f, 0.08301183f, -0.02175241f, 0.01830830f, -0.00926327f, 0.06119358f, 
    0.07802757f, 0.08116916f, -0.05148764f, -0.05083954f, 0.33600974f, 0.06987980f, -0.17289646f, -0.14129847f, 
    -0.13575909f, -0.18597418f, -0.02467421f, -0.03920214f, -0.04640028f, -0.13664182f, -0.05343490f, -0.01993801f, 
    -0.03856030f, 0.13108951f, 0.05065495f, 0.01608869f, 0.12470500f, -0.12039740f, 0.05632006f, 0.05092400f, 
    -0.30359569f, 0.32931086f, 0.18911254f, 0.01335657f, -0.33580890f, 0.01353456f, 0.06992941f, -0.03021406f, 
    0.07834461f, -0.16710322f, 0.03777194f, 0.02799003f, 0.01438287f, -0.13303038f, -0.00558155f, -0.00418366f, 
    -0.04915687f, 0.03898418f, 0.13967827f, 0.08109992f, -0.19286531f, 0.19408533f, 0.05509347f, -0.05788739f, 
    -0.04903970f, 0.03485130f, -0.11542221f, -0.04938634f, 0.04063210f, 0.06939959f, -0.03738837f, 0.00679829f, 
    0.15840863f, 0.13867989f, -0.06093993f, 0.05253476f, -0.02978647f, -0.05583218f, -0.09466884f, 0.00158625f, 
    0.10328592f, -0.01041798f, 0.00309689f, -0.11987424f, 0.17587666f, -0.06027762f, -0.06473655f, -0.18097790f, 
    -0.03288185f, 0.00047641f, 0.12188312f, 0.03551034f, -0.01507061f, 0.01360869f, 0.01620058f, -0.01129490f, 
    0.07501218f, 0.18718514f, -0.02397783f, 0.17136291f, -0.00722200f, -0.20822276f, -0.07967468f, 0.07062266f, 
    0.33145356f, -0.12639219f, 0.01924942f, -0.10070584f, 0.01932161f, 0.09953884f, -0.02953789f, -0.07769868f, 
    -0.10019833f, 0.01749732f, -0.03292428f, -0.12109807f, 0.07805230f, -0.01167395f, 0.06027658f, 0.07875541f, 
    0.11889111f, 0.10359757f, -0.18002440f, 0.26658204f, 0.31869757f, 0.09931724f, -0.13839930f, 0.01633110f, 
    0.12795506f, -0.05472264f, 0.03761403f, -0.03429208f, -0.06630309f, 0.11605499f, 0.04027404f, 0.13944326f, 
    -0.00359059f, -0.05877579f, -0.03750989f, -0.07312538f, -0.01246163f, 0.11731073f, 0.00372057f, -0.06271605f, 
    0.04746114f, -0.02131868f, -0.09279276f, 0.09423283f, 0.05298613f, 0.17121474f, -0.08488206f, 0.01638456f, 
    0.01357770f, 0.11212815f, 0.02157510f, 0.13876341f, 0.04631227f, 0.00863900f, -0.04216841f, -0.08723214f, 
    -0.44089833f, -0.01064068f, 0.14138710f, -0.09939145f, -0.02959557f, 0.21762240f, 0.04345877f, 0.03934135f, 
    0.03821487f, 0.00209700f, 0.07584075f, 0.01820547f, -0.14080825f, -0.06069234f, -0.00272879f, -0.05713667f, 
    0.00459565f, 0.07726517f, -0.11406926f, 0.02046295f, -0.38910773f, 0.23741230f, 0.09960274f, 0.13261361f, 
    -0.04470952f, 0.06506319f, 0.01814815f, 0.07792379f, -0.02231402f, -0.04525553f, 0.07346409f, 0.04546968f, 
    0.11097177f, 0.01377329f, 0.09550115f, -0.02652217f, -0.04117012f, 0.02532401f, 0.07164390f, 0.02457738f, 
    -0.06106151f, -0.01492594f, 0.02244563f, 0.04806271f, 0.02584831f, -0.06281881f, -0.16828838f, -0.05970579f, 
    -0.02995121f, 0.01289044f, -0.03322223f, 0.05099051f, 0.07863387f, -0.05244995f, 0.00592857f, -0.04218956f, 
    0.04659136f, 0.07650382f, 0.09142724f, 0.06612900f, 0.12570447f, 0.12360895f, -0.12008763f, -0.17545216f, 
    -0.22625698f, -0.04241058f, 0.05323493f, -0.00384836f, -0.01036166f, -0.02723551f, 0.03753093f, 0.04294128f, 
    -0.02424815f, -0.00828741f, 0.01576082f, 0.10405655f, 0.07950176f, -0.00724758f, 0.02629634f, -0.03527634f, 
    -0.38293576f, 0.14639243f, 0.26098746f, -0.15723388f, -0.24463706f, 0.05615957f, 0.15699616f, 0.12278574f, 
    -0.02888275f, -0.16305749f, 0.02519352f, 0.00693149f, 0.03114363f, -0.01715628f, 0.00487866f, 0.05280340f, 
    0.05386307f, 0.06317975f, 0.03162577f, 0.06248871f, -0.24649440f, 0.14579661f, 0.17208049f, 0.09035403f, 
    -0.07967450f, 0.08499134f, -0.08570907f, -0.00100550f, 0.04078780f, 0.00788089f, 0.04406458f, 0.08772220f, 
    -0.01855695f, 0.12946299f, 0.02902752f, 0.02245459f, 0.10492910f, -0.01673442f, 0.01263044f, -0.03431562f, 
    0.26810876f, 0.36191455f, -0.23530681f, -0.18107237f, -0.30370164f, -0.01500251f, 0.08457147f, 0.20884413f, 
    -0.06070901f, -0.22128579f, 0.10105175f, 0.01984096f, 0.10375508f, -0.08964429f, 0.06541563f, 0.02032788f, 
    0.11090706f, -0.04297629f, -0.01564783f, 0.03686370f, 0.31587619f, -0.16745041f, 0.13000171f, 0.29970387f, 
    0.32551479f, -0.13727482f, -0.05022775f, -0.02148098f, -0.11238200f, 0.00053449f, 0.12944029f, 0.12463740f, 
    -0.00565524f, 0.05234506f, -0.01086391f, -0.01392840f, -0.05856556f, -0.09271480f, 0.12368617f, -0.14208965f, 
    0.10070521f, -0.06760266f, 0.16482206f, 0.11323988f, 0.06770860f, -0.01430348f, 0.00924809f, 0.10117676f, 
    -0.03546250f, 0.01765134f, -0.02883225f, 0.03388535f, 0.14009812f, 0.03227865f, 0.01528415f, 0.00480772f, 
    0.01600985f, -0.06574906f, 0.03175313f, -0.01303029f, -0.20850532f, 0.24320783f, -0.00689248f, -0.07026772f, 
    -0.03624657f, 0.16336021f, 0.05613630f, 0.11453211f, -0.06317713f, -0.01199917f, -0.02111962f, -0.03378643f, 
    -0.07474964f, 0.06989248f, -0.00072696f, 0.04747652f, 0.01632363f, 0.16957323f, -0.02717147f, -0.03750142f, 
    -0.33069944f, -0.02138661f, 0.11083145f, -0.17100167f, -0.18400002f, 0.15762658f, 0.11555183f, 0.23851091f, 
    -0.00370238f, -0.05647318f, 0.03555348f, 0.08454042f, 0.03463106f, 0.07939330f, -0.08243291f, 0.03013649f, 
    0.11624686f, 0.04788741f, -0.00300994f, -0.00734691f, -0.29458603f, -0.11299656f, 0.15383512f, 0.26886049f, 
    -0.40508589f, -0.04757539f, -0.01457274f, -0.03559766f, -0.03508298f, 0.06129739f, 0.03813991f, 0.06434562f, 
    -0.02633784f, -0.08999167f, 0.00699920f, -0.02990529f, -0.07411543f, 0.08838344f, -0.02765245f, -0.05167357f, 
    0.06847861f, -0.09134712f, -0.32706833f, 0.06335084f, 0.16535275f, 0.01814160f, -0.04669558f, -0.04673686f, 
    0.10673866f, 0.16746210f, 0.02446104f, 0.00321023f, -0.09605315f, 0.02723735f, 0.05621380f, -0.06887373f, 
    0.10825361f, -0.07797852f, 0.02809026f, -0.00344255f, 0.29121453f, -0.15766974f, -0.07809009f, 0.20473203f, 
    0.11555093f, -0.02666376f, -0.24398105f, -0.08157642f, -0.05170927f, 0.01200847f, 0.03278386f, -0.02536356f, 
    -0.01524258f, 0.06358200f, 0.07896111f, 0.04174874f, 0.04740131f, 0.14391239f, 0.06380296f, 0.00883047f, 
    -0.19490074f, -0.10697436f, 0.22386783f, 0.21705960f, 0.16148664f, -0.07572976f, -0.06309610f, -0.13091649f, 
    0.10970253f, 0.10263430f, 0.03565539f, 0.03483206f, -0.02118780f, 0.03465354f, 0.03003702f, -0.06661426f, 
    0.04559075f, -0.06500045f, -0.04322539f, 0.00005131f, -0.18433876f, 0.05701121f, 0.25888371f, 0.05295945f, 
    0.17069517f, 0.01748020f, -0.03865267f, -0.01441211f, 0.07165585f, -0.04556208f, 0.05280423f, 0.03748237f, 
    0.07182201f, 0.02817869f, 0.02386981f, 0.10839611f, 0.02757111f, 0.04598813f, -0.11703679f, 0.01538968f, 
    0.17633602f, 0.19775544f, -0.05694925f, 0.00219397f, -0.00277937f, -0.00943588f, 0.04141819f, 0.19564301f, 
    -0.01230367f, 0.04394714f, -0.03246954f, -0.03128573f, 0.03703374f, -0.04881737f, -0.01225819f, 0.01815224f, 
    0.08453383f, 0.07057252f, -0.02452670f, -0.08985452f, 0.31384909f, 0.12111495f, -0.22552164f, 0.08933525f, 
    0.27307123f, -0.05399403f, -0.05451057f, -0.15433036f, 0.01734124f, -0.00398507f, 0.10336750f, 0.01928891f, 
    0.10523337f, 0.14239198f, 0.02580943f, 0.08944325f, 0.00050918f, -0.17650151f, 0.11963218f, -0.00670637f, 
    0.00878856f, 0.00440420f, -0.02381704f, 0.02485510f, 0.01392150f, -0.02603989f, -0.01725679f, -0.02041726f, 
    -0.00051111f, 0.00739240f, 0.00016164f, -0.04128072f, 0.01194441f, 0.02271749f, -0.02286049f, 0.02904483f, 
    -0.03641524f, -0.01303301f, 0.01856535f, 0.01107424f, 0.02694148f, -0.04522163f, -0.01073120f, 0.04504845f, 
    -0.04416209f, 0.02054295f, 0.01532698f, -0.03907204f, -0.01095481f, -0.02171614f, 0.00121038f, 0.03102578f, 
    -0.03765526f, -0.03781937f, -0.00476350f, 0.03413474f, 0.00211335f, 0.01957026f, 0.00918659f, -0.02625886f, 
    -0.02943070f, 0.02613911f, -0.03319932f, 0.02784172f, 0.02764753f, 0.01593710f, -0.03244157f, 0.03542949f, 
    -0.02288128f, 0.01449277f, -0.03559401f, 0.01793367f, -0.00172503f, -0.02037798f, -0.04146331f, 0.00376362f, 
    0.02220443f, -0.02681199f, 0.03098166f, -0.00906420f, -0.03932158f, -0.00695060f, 0.00893029f, -0.03809978f, 
    -0.02157792f, -0.01209719f, -0.01108255f, -0.04166552f, 0.00974811f, 0.02664408f, 0.02360260f, -0.03844516f, 
    -0.04262205f, 0.03286858f, 0.00879969f, -0.03910444f, -0.01987525f, 0.02010592f, 0.01206302f, -0.02426102f, 
    0.00674810f, -0.04742537f, -0.01094741f, -0.04234785f, 0.01107060f, 0.01012742f, -0.02529594f, -0.03473945f, 
    0.02272664f, -0.00608622f, 0.00509174f, -0.03497262f, 0.02663464f, 0.00290119f, 0.00970335f, 0.02234242f, 
    -0.00707596f, -0.02835428f, -0.02014068f, 0.01057299f, -0.01192840f, -0.01199056f, 0.01338924f, -0.01615421f, 
    -0.02961958f, -0.02390806f, 0.01404753f, -0.00464832f, 0.01820468f, -0.01387557f, -0.00487540f, -0.03714514f, 
    -0.03884689f, 0.03659512f, -0.01510961f, -0.03335068f, -0.00871379f, -0.01169609f, -0.03418404f, 0.00435651f, 
    -0.03824652f, -0.00394618f, -0.03162261f, -0.02153958f, -0.00905502f, 0.03081843f, 0.00492257f, -0.04273548f, 
    -0.01851871f, 0.02981204f, -0.02772331f, 0.00377343f, -0.04652282f, -0.03811061f, -0.02712303f, 0.01450006f, 
    0.01321166f, 0.03302920f, -0.04030887f, -0.02156165f, -0.02596893f, 0.02162180f, -0.00389240f, -0.03187899f, 
    0.01714381f, -0.02935180f, 0.00349182f, 0.01294056f, 0.00187337f, -0.03331910f, -0.01489713f, -0.04040403f, 
    0.01767979f, 0.01158086f, -0.01202998f, 0.01595287f, -0.03868936f, -0.00120714f, -0.01757257f, -0.01643503f, 
    -0.03372063f, 0.00188004f, -0.03690930f, 0.02520860f, -0.02849746f, -0.00919077f, 0.00833436f, -0.01777825f, 
    -0.00912416f, -0.01974761f, -0.00304385f, -0.02111385f, -0.01924572f, -0.00942153f, -0.03167955f, 0.03056256f, 
    0.01516816f, 0.01310660f, -0.01881229f, -0.02771299f, 0.02414084f, -0.00136316f, -0.00748184f, -0.01017892f, 
    0.00150532f, 0.02310713f, -0.04610643f, -0.00981134f, -0.01383277f, -0.00942166f, -0.02771197f, 0.01848311f, 
    -0.01931629f, 0.01081948f, -0.03506621f, 0.00686237f, 0.00110821f, 0.01755284f, 0.04554807f, 0.00446139f, 
    -0.00602944f, -0.03099813f, -0.02070566f, 0.00356484f, 0.02723579f, -0.00897993f, 0.01172280f, -0.04595271f, 
    -0.00646910f, 0.02290616f, -0.01442417f, -0.00540688f, -0.00637783f, -0.01564304f, 0.01318639f, -0.03407706f, 
    0.03533277f, 0.00101066f, 0.03223214f, -0.01918176f, 0.00038159f, 0.02504529f, -0.00603551f, -0.02928880f, 
    0.01809964f, 0.01637459f, -0.04172973f, 0.02410317f, -0.00638905f, -0.02812740f, 0.00084920f, 0.00622763f, 
    -0.00218232f, -0.03069962f, -0.00378330f, -0.02182501f, -0.00056829f, -0.02965921f, 0.00203519f, -0.04473881f, 
    0.01426219f, -0.01454701f, -0.00967545f, -0.03909336f, -0.03017738f, 0.02998261f, 0.02783675f, -0.04049793f, 
    -0.01039113f, -0.02457473f, 0.02729379f, -0.04259354f, -0.01734354f, 0.02990669f, 0.00482069f, -0.01802275f, 
    -0.03766115f, -0.00933965f, -0.01936593f, -0.01334742f, -0.01574749f, 0.01252798f, -0.01912520f, 0.00025631f, 
    -0.00508941f, 0.00311305f, -0.04708914f, 0.02267115f, -0.00409956f, 0.03485911f, -0.02488600f, -0.02238212f, 
    0.00826654f, 0.02538350f, -0.00085595f, 0.02060870f, 0.01299966f, 0.04292523f, 0.00620458f, -0.00128095f, 
    -0.02433897f, -0.03873713f, 0.01682827f, 0.01146644f, 0.03261891f, -0.00876366f, 0.02713956f, 0.00605753f, 
    -0.01281662f, 0.02877452f, 0.00753536f, -0.01895432f, 0.02149506f, -0.03190524f, 0.02090182f, 0.00925789f, 
    -0.00046042f, 0.01355115f, -0.02403245f, 0.03793252f, -0.01890818f, 0.02942977f, 0.01917485f, -0.04177285f, 
    0.00106766f, -0.00535155f, -0.02641356f, -0.00950922f, -0.02699197f, 0.02915321f, 0.00174172f, -0.01150077f, 
    -0.01671458f, -0.01852664f, -0.00299549f, -0.01697279f, -0.00450004f, -0.03249938f, 0.01024111f, 0.03179475f, 
    -0.03189377f, 0.02485297f, -0.00810506f, -0.03501049f, 0.00957489f, 0.02587329f, 0.01354803f, -0.01880462f, 
    -0.02136715f, -0.01535604f, 0.02385231f, -0.01635608f, 0.01231347f, -0.02988569f, 0.01161546f, 0.01271763f, 
    0.00519679f, -0.02502699f, -0.02202568f, 0.00065830f, 0.03127910f, -0.01645422f, -0.00137508f, 0.00827841f, 
    -0.02238474f, 0.02956114f, -0.00565374f, -0.01320880f, 0.01315832f, -0.01570101f, 0.02963413f, -0.02019226f, 
    -0.00238839f, 0.00332141f, 0.02539903f, 0.01812693f, -0.00147359f, 0.02332528f, -0.02517438f, -0.04383488f, 
    0.00124471f, -0.03423404f, 0.02944613f, 0.02196879f, -0.00808339f, 0.02760782f, -0.03678057f, -0.01126598f, 
    0.01506218f, 0.02904841f, 0.00213004f, -0.03528799f, 0.02259618f, -0.02854388f, -0.02003726f, -0.00901782f, 
    0.02865855f, 0.02487533f, -0.01709807f, -0.01865425f, -0.03679376f, -0.02926891f, -0.01119387f, -0.02164698f, 
    -0.03477919f, -0.01871421f, -0.01089004f, -0.03053838f, -0.01363115f, -0.01782256f, -0.03115196f, -0.02051856f, 
    0.02656449f, -0.00107004f, 0.03114509f, 0.00379268f, 0.04152057f, 0.01279565f, -0.03655363f, -0.03624618f, 
    0.02619265f, 0.01387132f, 0.00796782f, -0.02505659f, -0.03138920f, -0.01061678f, -0.02083899f, -0.03593774f, 
    -0.03602391f, -0.02523051f, -0.01570957f, 0.01975073f, 0.03244494f, 0.00952888f, 0.01158640f, 0.01363450f, 
    0.00474528f, 0.01989162f, -0.03862942f, -0.00302949f, -0.01879443f, -0.00279607f, -0.01861534f, -0.02994534f, 
    -0.03971044f, -0.03278991f, -0.01297542f, -0.03089834f, -0.00123058f, -0.03019199f, -0.00312238f, 0.02859824f, 
    -0.01000980f, 0.03510268f, -0.00005728f, 0.03119884f, 0.01972737f, -0.00921047f, -0.02239448f, 0.02241952f, 
    0.01663026f, -0.03408219f, 0.00391015f, -0.02591532f, -0.00027330f, -0.04570366f, 0.02340462f, -0.00477623f, 
    -0.02440792f, -0.03764967f, -0.04505704f, -0.04234938f, 0.02186917f, 0.00540826f, -0.02210613f, -0.01784070f, 
    0.00405488f, -0.02542163f, 0.01932695f, -0.00699827f, -0.04666106f, 0.02702460f, 0.02340258f, 0.02386967f, 
    0.01789776f, -0.00807361f, -0.00068181f, 0.00970508f, 0.02811318f, 0.02107813f, -0.04111175f, -0.00750835f, 
    -0.03570872f, 0.02373976f, -0.04456888f, 0.00320124f, -0.03118357f, -0.02928427f, -0.01757582f, -0.03267344f, 
    -0.02868835f, 0.02722170f, 0.02660764f, -0.03501748f, -0.02475168f, 0.01265364f, -0.01426896f, -0.02298403f, 
    -0.02333788f, 0.00682173f, -0.00930341f, -0.01289082f, 0.01686789f, 0.00955873f, 0.00816546f, 0.02281820f, 
    0.03408530f, 0.01065408f, -0.00202954f, 0.01231594f, -0.00536316f, 0.02269217f, -0.01294774f, 0.00753332f, 
    -0.01524093f, -0.03401663f, 0.01432880f, -0.00277814f, -0.01773626f, 0.00385168f, -0.04404111f, 0.00822141f, 
    0.00753542f, 0.00655369f, 0.01038115f, -0.01385035f, -0.01709490f, -0.04023245f, 0.01127826f, -0.03004680f, 
    0.01820223f, -0.02988787f, 0.00805891f, 0.00108331f, 0.01128713f, -0.02612920f, -0.02617427f, -0.00938947f, 
    -0.04190423f, 0.00882082f, 0.02240467f, 0.02730115f, 0.01790631f, 0.00497628f, 0.00475614f, -0.02365665f, 
    0.01699889f, -0.01898525f, -0.01754281f, -0.01394092f, 0.00186099f, -0.03868549f, 0.02573819f, -0.03489009f, 
    -0.00175084f, -0.02141667f, -0.02498911f, 0.01645786f, 0.02885884f, -0.00688200f, -0.03264232f, 0.01848551f, 
    0.01213583f, 0.02486009f, 0.02453191f, 0.02343477f, -0.03480648f, 0.01102162f, -0.01550363f, -0.01569036f, 
    0.00406433f, 0.00786988f, 0.00406805f, -0.03180703f, 0.01703542f, -0.03292136f, -0.03921031f, 0.00872555f, 
    0.03173373f, -0.01379801f, -0.03687621f, -0.03530099f, -0.02310229f, 0.02307994f, -0.01353333f, 0.02500799f, 
    -0.00615486f, -0.01335704f, 0.02987481f, 0.02386966f, -0.02217297f, -0.00701046f, -0.02154468f, -0.00033224f, 
    -0.00171599f, -0.03649092f, 0.00967561f, 0.02710553f, -0.00586706f, 0.01323191f, -0.02946546f, -0.01606376f, 
    -0.04108397f, -0.00861687f, 0.03315314f, -0.01060442f, -0.02623367f, 0.04555130f, 0.00933782f, -0.01492092f, 
    -0.03146649f, 0.00074905f, -0.02450461f, 0.04361057f, -0.02453942f, -0.01689504f, -0.00548426f, 0.00229159f, 
    -0.00698687f, -0.01958852f, -0.03288643f, 0.02219156f, -0.01981880f, -0.03000147f, -0.01689734f, 0.03301749f, 
    -0.03883752f, 0.02959185f, -0.02935129f, 0.00972645f, -0.03094560f, -0.01186081f, -0.01140842f, -0.03636353f, 
    0.02093250f, -0.01922460f, 0.00959741f, -0.04509128f, 0.02160375f, -0.04403963f, 0.03066308f, 0.00136316f, 
    -0.02302999f, 0.00293027f, 0.02344934f, 0.01184964f, -0.01909628f, 0.01192070f, 0.02352598f, -0.03452002f, 
    0.03261156f, -0.01546353f, 0.01865584f, 0.01975496f, 0.03289746f, 0.03328976f, -0.02547639f, 0.00389203f, 
    -0.03811786f, -0.02459337f, 0.01443257f, -0.03578053f, 0.00898010f, -0.02803406f, 0.01404057f, -0.00714439f, 
    -0.01086188f, 0.00479663f, 0.00126592f, -0.00787466f, 0.01868285f, 0.01332488f, 0.02017372f, -0.00073072f, 
    -0.02140438f, 0.01894812f, -0.03964521f, 0.01875148f, -0.01619290f, 0.02792270f, -0.04010528f, -0.01338568f, 
    0.02867257f, -0.03591945f, 0.01085493f, 0.02317154f, -0.03475036f, -0.01328957f, -0.00439165f, -0.03298440f, 
    -0.00754725f, -0.01184803f, 0.02716152f, 0.01041663f, 0.00240007f, -0.00335127f, 0.02905018f, -0.04296064f, 
    -0.03283504f, 0.00565749f, -0.01487310f, -0.02437560f, -0.00363559f, -0.00150669f, 0.00019112f, 0.01246268f, 
    -0.03979234f, -0.00809151f, -0.01653304f, -0.01585096f, 0.00716505f, 0.01447141f, -0.03855809f, -0.03129667f, 
    0.02363330f, -0.02918704f, -0.02382466f, -0.01032279f, 0.02851293f, -0.01544221f, 0.02126171f, 0.00934024f, 
    -0.00947355f, 0.00909803f, 0.00328555f, -0.01184314f, 0.00816631f, 0.03270163f, -0.00623548f, 0.01200689f, 
    0.00361462f, -0.02501184f, 0.02434732f, 0.01644502f, -0.01800951f, -0.04272541f, -0.04463923f, -0.01081300f, 
    0.01088975f, 0.01636941f, 0.01095384f, -0.01677556f, -0.01790780f, 0.00311682f, -0.01585316f, 0.02778241f, 
    -0.03084002f, -0.04119871f, 0.02888770f, 0.00530704f, 0.02345080f, 0.01838443f, 0.02421530f, 0.00789788f, 
    0.01205715f, 0.00196599f, -0.04298853f, -0.00374524f, 0.00278937f, -0.01186732f, -0.01841379f, 0.00691791f, 
    0.01362136f, -0.01754178f, -0.04004553f, -0.03140674f, -0.03740192f, -0.00053714f, -0.00555401f, 0.01875616f, 
    -0.00640843f, 0.00389776f, -0.01234028f, -0.01662561f, -0.01404890f, 0.00126584f, -0.03915470f, -0.03453765f, 
    -0.01436060f, 0.00647386f, 0.02923854f, -0.02010261f, -0.03286848f, -0.02371530f, -0.02171350f, -0.01642940f, 
    -0.02609188f, -0.00116436f, -0.03247013f, 0.01407186f, -0.01305427f, -0.04120008f, -0.01482156f, -0.01590224f, 
    -0.00192549f, -0.02755225f, -0.02561801f, 0.00789449f, -0.01980018f, -0.03788565f, -0.02743546f, -0.00595198f, 
    -0.03412340f, 0.03526803f, -0.02789621f, 0.01102951f, 0.00022475f, -0.04489153f, -0.03857574f, -0.04533688f, 
    0.03307671f, -0.03341864f, -0.03891202f, -0.02693875f, -0.03126147f, -0.02198745f, -0.02617565f, -0.02125116f, 
    0.01668783f, 0.03260710f, -0.04341207f, -0.00350774f, 0.00995461f, -0.02744808f, 0.00085210f, 0.02683282f, 
    -0.04304222f, -0.00095472f, 0.03121583f, -0.02460335f, -0.03325924f, 0.01918786f, -0.01699655f, 0.00705055f, 
    0.00303077f, 0.02417901f, 0.02104944f, -0.04333270f, -0.02999325f, -0.02090337f, 0.01048118f, -0.01298872f, 
    -0.00241871f, 0.00464019f, -0.03364803f, -0.03363063f, -0.02952006f, 0.00342713f, -0.02979531f, 0.01490599f, 
    0.02159964f, -0.02631607f, 0.04382795f, -0.01373589f, 0.00362349f, -0.01663173f, 0.02484912f, -0.01251862f, 
    -0.00505361f, -0.01572959f, 0.02437908f, -0.04026643f, -0.01023829f, 0.00267215f, -0.03293509f, -0.00307510f, 
    -0.02360919f, 0.01011887f, 0.02718840f, 0.02471992f, -0.03795188f, -0.00121970f, 0.01565857f, -0.01114872f, 
    -0.03778284f, 0.01557287f, -0.04414541f, -0.02344210f, 0.02588577f, -0.03923989f, -0.03202566f, 0.01654865f, 
    -0.03712277f, 0.00186797f, -0.02562105f, 0.00101043f, 0.01077207f, -0.00300292f, 0.01991078f, -0.03418768f, 
    0.00422219f, -0.03685137f, 0.00330475f, -0.04000585f, -0.04458770f, 0.03082782f, -0.00040748f, 0.02546465f, 
    -0.04108865f, -0.00006911f, -0.03840903f, -0.01128833f, 0.02354351f, -0.02646778f, 0.01462255f, -0.00008063f, 
    -0.04290408f, 0.01565732f, -0.00429850f, 0.00104758f, -0.00828326f, -0.03812298f, -0.03165640f, 0.03256682f, 
    -0.04396367f, 0.01156974f, 0.00984816f, 0.01379950f, 0.03357712f, 0.02811917f, -0.01250222f, -0.00136123f, 
    -0.03087725f, -0.02495060f, 0.01273440f, 0.00673357f, 0.01328014f, -0.03192534f, 0.01020885f, -0.02566228f, 
    0.03216883f, -0.01068000f, 0.02224453f, -0.04477199f, -0.01132544f, 0.01652558f, 0.02434643f, 0.02286416f, 
    -0.04446977f, 0.01087811f, -0.00652364f, -0.01384388f, 0.00202154f, 0.01124720f, -0.03390608f, 0.00460205f, 
    -0.00259392f, -0.03864432f, 0.03333733f, 0.01470951f, -0.03791192f, -0.00384696f, -0.00141543f, 0.02776309f, 
    -0.02434638f, 0.02117426f, -0.02541114f, -0.03829923f, -0.03303462f, 0.00286620f, -0.02663265f, -0.02237972f, 
    -0.00426996f, -0.02533434f, 0.00490179f, -0.01027254f, -0.02445333f, -0.03316341f, -0.00553168f, 0.02716368f, 
    -0.03897786f, 0.01157436f, -0.02126625f, -0.03477139f, -0.01055473f, -0.02116234f, 0.01790169f, -0.03363364f, 
    -0.03745074f, 0.01319792f, 0.02673669f, -0.01012747f, -0.02565226f, -0.01135426f, 0.02665010f, 0.03171062f, 
    0.00074599f, -0.02425897f, 0.02946923f, 0.01394985f, 0.00137916f, -0.04449074f, 0.03219111f, -0.02831617f, 
    -0.03095451f, -0.02814381f, 0.00664638f, 0.03104133f, -0.02869025f, -0.03993335f, 0.02686757f, 0.00334044f, 
    -0.03718187f, -0.02190840f, -0.02001230f, -0.04357306f, -0.02999194f, -0.04161968f, -0.04462078f, -0.03356110f, 
    0.03318633f, 0.00753309f, 0.02842332f, 0.01909085f, -0.04305965f, -0.03498237f, -0.01002067f, 0.01384940f, 
    -0.04005175f, -0.01315369f, -0.03136278f, -0.01807473f, 0.03178419f, 0.03318377f, -0.00006193f, -0.01207321f, 
    0.01160209f, 0.01913251f, -0.03751707f, 0.02753382f, 0.01288583f, 0.01375209f, 0.02900389f, -0.02534790f, 
    -0.03555226f, 0.04160235f, -0.03794650f, -0.00699265f, -0.01621435f, -0.00975460f, -0.04135805f, 0.02765035f, 
    -0.00527481f, 0.01139005f, 0.01663815f, -0.00277486f, -0.04171980f, -0.03811924f, -0.01181242f, 0.01870398f, 
    0.00662278f, -0.04011232f, -0.02978773f, 0.00624587f, 0.00469076f, 0.02892176f, 0.02179875f, 0.00619910f, 
    -0.02868867f, -0.03564329f, 0.02621642f, -0.03742095f, 0.00936006f, -0.00719622f, 0.00466874f, -0.03771512f, 
    0.00593248f, 0.03016405f, 0.01113645f, -0.03986567f, -0.04473728f, 0.00683544f, -0.00329679f, 0.01604671f, 
    0.01602519f, -0.01843159f, 0.02959737f, 0.00998762f, 0.01473960f, -0.00665541f, 0.02170712f, -0.00900108f, 
    -0.04205754f, -0.02052279f, 0.00717108f, -0.03410172f, 0.01872110f, 0.02524268f, -0.02741304f, -0.03987214f, 
    -0.00460893f, 0.03174570f, -0.01068198f, -0.01675976f, 0.00777523f, 0.01429760f, 0.00847350f, 0.02409548f, 
    -0.01076522f, -0.02658144f, -0.00915475f, -0.03993254f, 0.02286910f, 0.01505837f, -0.01404279f, 0.01008305f, 
    0.00580170f, -0.02338106f, -0.01152012f, -0.00787533f, -0.04517461f, -0.03470249f, -0.02485815f, 0.02302172f, 
    -0.00132014f, 0.01289570f, -0.02355275f, 0.02040437f, -0.03841259f, -0.03841405f, -0.00685952f, 0.00585344f, 
    -0.02542970f, -0.03087755f, 0.02306887f, -0.03575468f, -0.04048088f, -0.01148547f, 0.01312501f, -0.01955856f, 
    -0.02691443f, -0.01190964f, 0.03247173f, -0.04075728f, 0.00830731f, -0.03592870f, 0.01691036f, 0.00074466f, 
    0.03264788f, 0.01423471f, 0.03859749f, 0.01972863f, 0.00409203f, 0.02146378f, -0.00601722f, 0.01294614f, 
    -0.03964391f, -0.00069068f, -0.02852636f, 0.00844087f, 0.01547158f, -0.02499404f, -0.02025471f, -0.03009910f, 
    -0.04205114f, 0.02652091f, -0.03406700f, 0.02185784f, 0.02644037f, 0.00857498f, -0.03851771f, 0.00528583f, 
    0.01164836f, -0.01895378f, 0.01353554f, 0.01360486f, 0.01712904f, 0.00302084f, -0.03930436f, 0.01588727f, 
    0.00711779f, 0.01874607f, 0.03155470f, -0.01721545f, 0.00318336f, 0.00113079f, -0.01846819f, -0.04552027f, 
    0.02314654f, -0.01600828f, -0.02474059f, -0.00038862f, 0.03696537f, 0.02744553f, -0.00115419f, -0.03783714f, 
    0.00862037f, -0.04381679f, 0.02504302f, -0.02735231f, 0.02442350f, 0.00137243f, 0.01815371f, -0.02713139f, 
    -0.00400373f, -0.00724070f, -0.02790638f, 0.00713344f, -0.03623228f, 0.02385279f, 0.02352364f, -0.03232613f, 
    0.00185092f, -0.02572869f, -0.01619815f, -0.03847178f, 0.01167152f, 0.04020969f, 0.02759324f, 0.01898273f, 
    -0.00487608f, -0.00561045f, 0.00109729f, 0.01326616f, -0.04348485f, 0.03642588f, -0.02037960f, 0.01941992f, 
    -0.02183016f, -0.02227742f, 0.03152545f, 0.01577212f, 0.00216422f, -0.01375529f, -0.00819126f, -0.00802191f, 
    -0.02267690f, -0.01647488f, -0.02912040f, -0.02256116f, -0.01182180f, -0.02239854f, 0.02134215f, -0.01836798f, 
    -0.00471174f, 0.02378806f, -0.00105013f, 0.01758388f, 0.03505294f, -0.01451768f, -0.04479315f, -0.01451305f, 
    0.02488088f, 0.03263620f, -0.01677231f, -0.01162158f, -0.04200111f, -0.03583718f, -0.00831752f, 0.03100771f, 
    -0.00519667f, -0.00065820f, -0.02174200f, -0.00835883f, 0.02306854f, 0.01706355f, 0.03097889f, -0.03336519f, 
    -0.02301378f, 0.03297646f, 0.02097954f, -0.03000326f, -0.01014245f, 0.01294510f, 0.02745260f, 0.02162660f, 
    -0.00247850f, -0.02788729f, 0.02235690f, -0.01446473f, 0.02220416f, 0.02064555f, 0.00963285f, -0.02295861f, 
    -0.04523143f, -0.01650350f, 0.01666317f, -0.02289194f, 0.01704363f, 0.00099623f, -0.03893350f, 0.01224518f, 
    -0.02250680f, -0.02482486f, -0.02653752f, -0.00896827f, -0.00799694f, 0.00508132f, -0.04180031f, -0.03169288f, 
    -0.10020525f, -0.30535054f, 0.20331949f, -0.18715952f, -0.30638936f, 0.04863407f, 0.06496940f, -0.10017353f, 
    -0.03826976f, 0.01247625f, -0.02064895f, 0.05360270f, 0.02236489f, 0.10827796f, 0.00172202f, -0.00688483f, 
    -0.12710719f, 0.04070155f, 0.11883205f, 0.15919225f, -0.00860511f, 0.07073262f, 0.08477563f, 0.04806927f, 
    0.07617707f, 0.00317349f, 0.06107155f, 0.03047978f, -0.06156444f, 0.10520568f, -0.02373964f, 0.05095140f, 
    0.01369367f, -0.00332217f, 0.13488445f, 0.12996486f, 0.04032123f, 0.01429624f, 0.06434529f, 0.00633560f, 
    -0.24635860f, -0.06050346f, -0.00356345f, 0.16630684f, -0.17184654f, -0.00663607f, 0.00002727f, -0.07618446f, 
    0.01767091f, 0.10218623f, 0.04642431f, -0.01233488f, -0.05640944f, 0.01674391f, 0.00847347f, -0.12532128f, 
    0.09565034f, -0.04170744f, -0.01735317f, -0.04685951f, 0.12594377f, -0.33405766f, 0.22886562f, -0.01227720f, 
    0.06348020f, 0.00225552f, -0.05416626f, 0.18819930f, 0.03238598f, -0.00393988f, 0.08169204f, -0.03243369f, 
    0.06644337f, 0.07551749f, 0.09722169f, -0.01700392f, 0.05957393f, 0.14246172f, -0.00806500f, -0.04208000f, 
    0.14853770f, -0.08891603f, 0.31986967f, -0.07049723f, -0.18090886f, -0.08167635f, 0.12233751f, -0.02847909f, 
    -0.13110898f, 0.08706346f, -0.02021790f, 0.06597858f, 0.07100294f, -0.02031802f, 0.08923142f, 0.03316594f, 
    0.05562560f, 0.04341536f, -0.00883742f, -0.03189265f, -0.15115596f, 0.03485797f, -0.22014648f, 0.07763524f, 
    0.00583479f, 0.04533469f, -0.00405580f, 0.01443857f, -0.02193280f, 0.02248585f, 0.01807844f, 0.03684587f, 
    -0.00547439f, -0.03286999f, 0.06859199f, 0.07712388f, 0.01392026f, 0.01284365f, 0.07647673f, 0.03318090f, 
    0.26153234f, -0.01039844f, -0.05831848f, -0.12086801f, -0.01263728f, 0.05289025f, 0.07797297f, 0.02738055f, 
    0.13018283f, 0.05479940f, -0.01293982f, 0.00265435f, -0.01618278f, 0.05862791f, -0.01526575f, -0.07192169f, 
    0.09773593f, -0.01645022f, 0.02339760f, -0.04195328f, -0.39661551f, 0.21000800f, -0.11267240f, 0.06917471f, 
    -0.10592388f, 0.26592568f, 0.10962271f, 0.01121623f, -0.05258212f, 0.12535180f, 0.06549068f, 0.02015465f, 
    0.01930370f, -0.12824458f, 0.05855105f, 0.02471197f, -0.03928787f, 0.08141379f, -0.00534596f, 0.05399354f, 
    -0.06327600f, -0.16255783f, -0.14746481f, -0.03242550f, 0.09565838f, 0.11068986f, -0.10033955f, -0.10151248f, 
    -0.02816143f, 0.14266066f, 0.00067952f, -0.02641089f, -0.05574429f, 0.06000819f, -0.00842461f, 0.01811427f, 
    0.09157676f, -0.11149688f, -0.01403315f, -0.05489801f, 0.02628328f, -0.05669311f, -0.05359004f, 0.20236091f, 
    0.11790320f, -0.00855942f, 0.12773298f, 0.14075868f, 0.05871304f, 0.02392810f, 0.02622063f, 0.04924854f, 
    -0.04560318f, -0.04594498f, 0.04550719f, 0.04899793f, 0.15593177f, 0.05658973f, 0.12706074f, 0.13596919f, 
    0.08160928f, -0.05618933f, -0.08007582f, -0.02547891f, -0.28025731f, 0.04339207f, 0.17697558f, 0.03864740f, 
    -0.00811832f, -0.04053488f, 0.01195701f, -0.00426927f, 0.00737860f, 0.10830161f, 0.04431694f, 0.09528505f, 
    -0.02797766f, -0.02217951f, 0.06723039f, 0.06329734f, -0.12523970f, 0.21620400f, -0.00939365f, 0.06280240f, 
    -0.20833695f, 0.17030336f, 0.01618235f, 0.06182317f, -0.01632049f, 0.01370143f, 0.10899493f, 0.08160604f, 
    0.11182373f, 0.04752234f, 0.16367806f, 0.05633214f, 0.05716919f, 0.01372179f, 0.03872667f, 0.01206405f, 
    0.03128244f, 0.07880907f, 0.32860625f, -0.17957708f, -0.19264692f, -0.11652717f, 0.07458162f, 0.03729016f, 
    -0.05984342f, 0.05116966f, 0.07608904f, 0.12705065f, 0.16321276f, -0.04242556f, 0.03501171f, -0.03431751f, 
    0.09122391f, 0.09903035f, 0.07708829f, -0.05388139f, 0.17194603f, 0.04879423f, -0.09287325f, 0.21298157f, 
    0.00117498f, -0.01896593f, 0.07930811f, 0.00846932f, 0.02170361f, -0.11628801f, 0.09663083f, -0.05854814f, 
    -0.03945639f, -0.01357968f, -0.12092996f, 0.00040845f, 0.14547868f, -0.05854371f, 0.09099098f, 0.11506724f, 
    -0.04845789f, -0.05133041f, -0.12443326f, 0.17310791f, -0.00799263f, -0.15201189f, -0.03055299f, -0.05609702f, 
    0.02552971f, -0.02075348f, -0.05184259f, -0.05367751f, 0.05113269f, 0.02345917f, 0.00137728f, 0.00855803f, 
    0.02864565f, 0.04487963f, 0.04016948f, 0.04684790f, 0.06411076f, -0.08061252f, -0.14800468f, -0.02728277f, 
    -0.04450350f, 0.14069390f, -0.02773327f, -0.04135362f, 0.03144934f, 0.15281731f, -0.14596470f, 0.08540534f, 
    -0.00526961f, 0.15337811f, 0.02757874f, 0.05282924f, 0.02115032f, 0.01302208f, 0.04891184f, 0.05699288f, 
    0.07641143f, -0.11625724f, -0.11986193f, -0.19210050f, -0.20463707f, 0.05999446f, 0.11995987f, -0.04245469f, 
    -0.00301564f, -0.03078696f, 0.02158815f, 0.02970074f, -0.12339406f, 0.02415559f, 0.05644511f, 0.02177099f, 
    0.14216037f, 0.04449139f, 0.04827364f, 0.05621472f, 0.06770086f, 0.10670312f, -0.11078259f, 0.15712795f, 
    -0.06098857f, 0.24286582f, 0.01506945f, 0.13446978f, 0.01178734f, 0.19139385f, -0.00765198f, 0.02403779f, 
    0.04960969f, 0.03406909f, 0.05327699f, -0.03345471f, -0.04877030f, 0.04696969f, 0.01984082f, 0.02604362f, 
    0.12539630f, 0.03174674f, -0.28333718f, 0.11493465f, -0.02407979f, 0.05604458f, -0.04413935f, -0.06073627f, 
    0.10712786f, 0.09648208f, -0.00059783f, 0.04562547f, 0.01501159f, 0.00037274f, 0.03212845f, -0.00693082f, 
    -0.10093233f, -0.03125985f, -0.02622644f, -0.03446506f, 0.01001612f, 0.03052185f, -0.02765302f, -0.10553137f, 
    0.28857774f, -0.00232886f, -0.00946598f, -0.06305538f, 0.07545092f, 0.10677180f, 0.09168921f, -0.07444581f, 
    0.07723920f, 0.02492629f, 0.06430005f, 0.08186200f, -0.05578151f, -0.01414709f, -0.00905347f, 0.05775661f, 
    -0.27192095f, -0.12007396f, -0.11427500f, 0.23148042f, -0.08894813f, 0.05920057f, -0.08595454f, -0.06573672f, 
    -0.00216911f, 0.22035322f, -0.03948874f, 0.03183000f, 0.01218390f, -0.05902625f, -0.04509648f, -0.04256633f, 
    -0.15263392f, -0.03371885f, 0.02099370f, -0.08199093f, -0.25989673f, 0.10978829f, 0.03300853f, -0.06498492f, 
    -0.39339319f, 0.15856099f, 0.09059389f, 0.01433629f, 0.10381896f, 0.04315964f, 0.01989316f, -0.05483917f, 
    0.07265066f, 0.06144105f, 0.12556668f, 0.08010063f, 0.13689370f, 0.08481201f, -0.11241747f, 0.05585751f, 
    -0.34650555f, -0.00580238f, -0.18821187f, 0.17506213f, 0.02406162f, 0.00251799f, -0.00154414f, -0.02120204f, 
    -0.01801144f, 0.02646356f, 0.05009547f, 0.01761274f, -0.02631326f, 0.04691719f, 0.09126437f, 0.10724045f, 
    -0.00809765f, 0.09975335f, -0.01943805f, 0.07993607f, 0.08349566f, -0.15811622f, -0.05921140f, 0.08965072f, 
    -0.12155725f, -0.05358407f, -0.04516073f, 0.01780964f, 0.13923921f, -0.00449742f, 0.04847898f, 0.02061739f, 
    -0.01153197f, 0.00997343f, 0.02659063f, -0.05677389f, 0.06875430f, 0.00768575f, 0.04425638f, -0.00794620f, 
    0.14480540f, 0.03484370f, -0.20934169f, 0.07223537f, -0.03256670f, -0.02474048f, -0.10258723f, -0.11956935f, 
    0.02940118f, 0.11723989f, -0.03723451f, 0.03248418f, -0.00513946f, -0.00742038f, 0.03607418f, 0.01539826f, 
    -0.02813469f, 0.08347525f, -0.09566005f, 0.03406854f, 0.46805331f, 0.01934060f, -0.25542781f, -0.21380267f, 
    0.04065999f, 0.10895301f, -0.06009476f, -0.00921568f, 0.07567617f, -0.03726699f, -0.01576713f, -0.14442840f, 
    0.06477422f, 0.19588095f, -0.05595261f, 0.04156310f, 0.06210866f, -0.02485085f, 0.11703791f, -0.03365548f, 
    -0.13531527f, 0.04301801f, 0.19692200f, -0.19237953f, -0.05461026f, 0.18032798f, 0.10792360f, 0.03409442f, 
    -0.03330681f, -0.03043834f, 0.05260361f, -0.02207955f, 0.07481457f, -0.03386753f, 0.02571206f, 0.02213773f, 
    -0.02068122f, 0.09475537f, 0.04676030f, 0.12383635f, 0.00528332f, -0.26353934f, 0.03515067f, -0.25242993f, 
    -0.29046825f, 0.06517221f, 0.17259091f, -0.01060668f, -0.09480456f, -0.04280436f, 0.08060882f, -0.00610759f, 
    0.01248882f, 0.06439739f, 0.00436321f, -0.01843254f, -0.04413684f, -0.07472888f, -0.07464837f, 0.02625649f, 
    0.24568115f, 0.12931816f, 0.03248676f, 0.00459677f, 0.00544922f, -0.01619497f, -0.01986222f, 0.12148080f, 
    -0.01514862f, -0.05762232f, -0.04263188f, 0.07820981f, 0.07504947f, 0.01779402f, 0.06084323f, 0.13306610f, 
    0.05857671f, 0.11214039f, 0.04392863f, 0.07260765f, -0.32558787f, -0.00204256f, -0.23045564f, 0.17528152f, 
    -0.02128426f, 0.04696212f, 0.07855166f, 0.03797188f, 0.03972377f, 0.08262966f, 0.02790620f, -0.02493147f, 
    -0.06741349f, 0.01783207f, 0.05247510f, 0.03223367f, 0.05262586f, 0.03078013f, 0.09646644f, 0.15465955f, 
    -0.00365212f, -0.09743498f, -0.12136368f, 0.23291937f, -0.05388587f, 0.00613665f, -0.05324554f, -0.02011296f, 
    -0.06717856f, 0.09643736f, 0.01166858f, 0.02133198f, 0.04822127f, -0.01397064f, 0.05081660f, 0.15095748f, 
    -0.04635247f, -0.02414534f, 0.01881964f, 0.04168535f, -0.02999165f, -0.27088067f, 0.29389575f, -0.06098274f, 
    -0.02665965f, 0.04332691f, 0.02773310f, -0.04990235f, -0.04776216f, 0.00466762f, 0.02446012f, 0.01433027f, 
    -0.06870168f, -0.01433677f, 0.10169193f, 0.00245841f, 0.07990389f, 0.15609108f, -0.10174035f, 0.10785371f, 
    -0.00587119f, -0.00522621f, 0.00170413f, -0.04481971f, -0.01525314f, -0.02397291f, 0.00057144f, -0.01784871f, 
    -0.03018008f, -0.03321305f, -0.02305342f, 0.01744791f, 0.02985450f, -0.00615875f, -0.03226012f, -0.03381091f, 
    -0.00047825f, -0.00581343f, -0.03502261f, -0.01308886f, -0.01221517f, 0.00319952f, 0.02864308f, 0.01829056f, 
    -0.01697683f, 0.01325714f, 0.02734467f, -0.00156832f, -0.00560820f, -0.02901350f, 0.00178753f, 0.02443739f, 
    -0.02643933f, 0.03505418f, -0.01493839f, -0.01093998f, -0.04045100f, -0.00607319f, -0.00841821f, -0.00435197f, 
    0.02100416f, 0.00490567f, 0.02508443f, -0.02094193f, -0.01453365f, -0.02524130f, 0.01103932f, -0.00727393f, 
    -0.02341437f, 0.00479817f, 0.01192012f, -0.00816834f, -0.03552651f, 0.03129023f, -0.01621351f, -0.00072011f, 
    0.01734829f, 0.00975687f, -0.00175505f, 0.02061960f, -0.03114641f, 0.01475783f, 0.03085099f, -0.01586846f, 
    -0.00958874f, -0.03271299f, 0.02508399f, 0.00389392f, 0.00637446f, 0.00085377f, 0.01427231f, 0.00430746f, 
    0.00405368f, -0.03099360f, -0.04322984f, -0.03626822f, -0.00146674f, 0.02843989f, -0.02919313f, -0.00723044f, 
    0.02890925f, -0.02188071f, 0.02176283f, 0.01461445f, 0.01905979f, -0.03639050f, -0.01675278f, 0.02778753f, 
    -0.00456422f, -0.04087358f, -0.02880544f, 0.01381165f, -0.01792998f, -0.01492481f, -0.02098674f, 0.03738655f, 
    0.00718369f, -0.02547728f, 0.00058183f, -0.00470314f, -0.00087431f, -0.04485427f, -0.01862103f, 0.02789757f, 
    0.03110776f, 0.00410606f, 0.02405283f, -0.01849540f, -0.00737134f, -0.01268909f, -0.00777198f, -0.03978372f, 
    -0.04710313f, -0.00198106f, -0.00410927f, -0.03568702f, 0.01490653f, 0.02433733f, 0.00850969f, -0.01233582f, 
    -0.05622955f, -0.04658272f, -0.01020200f, 0.01799248f, -0.03686139f, -0.01239778f, 0.00562935f, 0.02752755f, 
    -0.04720201f, 0.01585863f, -0.01061730f, -0.03277659f, 0.00939503f, 0.00291609f, -0.02581729f, -0.02675127f, 
    0.01931355f, 0.01021193f, -0.02313434f, -0.03366380f, -0.00294859f, 0.01772279f, -0.02896886f, 0.01053094f, 
    -0.03202469f, -0.03480874f, 0.02663865f, -0.02750259f, -0.02306589f, 0.02765496f, 0.02510882f, 0.00794286f, 
    0.03126406f, -0.02662388f, 0.00097035f, 0.00001905f, 0.02768327f, -0.01241929f, 0.03054821f, -0.02156368f, 
    -0.01216631f, 0.01412721f, -0.04340863f, 0.03324062f, -0.01948120f, -0.02648051f, -0.00518724f, 0.02212326f, 
    0.01965137f, -0.00114223f, -0.04698602f, -0.04015932f, -0.00147080f, 0.02835103f, -0.03978436f, -0.03416539f, 
    0.00223097f, -0.03863009f, -0.02159731f, -0.00484851f, -0.00095837f, -0.02651250f, -0.03423224f, -0.00657150f, 
    0.01938052f, 0.00594082f, 0.03206958f, 0.01728076f, 0.01433081f, -0.04213727f, -0.03743077f, 0.02235616f, 
    -0.03756835f, -0.04781853f, 0.00226031f, 0.02490261f, 0.01835392f, -0.02630970f, -0.03419827f, -0.03870913f, 
    -0.02591970f, -0.01443785f, -0.03324984f, 0.01760371f, -0.00132783f, -0.03558196f, 0.00592494f, -0.04164410f, 
    -0.01021593f, -0.04765381f, -0.00235739f, 0.01957152f, 0.02962054f, 0.02769242f, 0.03229402f, 0.00298406f, 
    0.01184872f, -0.02897812f, -0.03065479f, -0.02740915f, -0.01478051f, -0.01148951f, -0.00712921f, 0.00525122f, 
    0.00708888f, -0.00405258f, -0.00171832f, -0.02802757f, -0.01958610f, -0.03707602f, 0.00152801f, 0.02904624f, 
    -0.02229759f, 0.02470409f, -0.03286718f, 0.00334780f, -0.00197694f, -0.04530873f, -0.00004131f, -0.04565379f, 
    -0.01845318f, 0.02551577f, 0.01439665f, -0.00072880f, 0.00559376f, -0.00591779f, -0.00245491f, -0.02782976f, 
    -0.03274171f, 0.01546709f, 0.00546584f, 0.03543739f, 0.02900540f, -0.03519849f, 0.02315601f, -0.00781109f, 
    -0.01323313f, 0.01948424f, -0.00533892f, -0.00107977f, 0.01260497f, 0.02876078f, -0.00505306f, -0.02005143f, 
    -0.02802971f, -0.01987032f, 0.03240262f, -0.03730813f, 0.00988747f, 0.02555918f, 0.02312579f, 0.03236965f, 
    0.00090510f, -0.01043327f, -0.02148100f, 0.03174438f, -0.01754514f, -0.00674951f, 0.01946751f, 0.01650357f, 
    -0.02129978f, 0.00769390f, 0.01159237f, 0.00326292f, -0.03002332f, 0.03492054f, 0.01126293f, -0.03598198f, 
    0.02720084f, -0.02926132f, -0.00426317f, 0.01268517f, 0.03322883f, -0.01245611f, -0.02505334f, 0.02187980f, 
    -0.04428656f, -0.03179018f, -0.03369288f, -0.02516347f, 0.01569859f, -0.04133082f, 0.00872860f, -0.01910299f, 
    0.02919549f, 0.01982569f, 0.03425324f, 0.03509291f, 0.01374113f, 0.01006418f, 0.01426914f, 0.00085656f, 
    -0.01449335f, 0.00601314f, -0.02189230f, -0.02155701f, -0.00538320f, -0.01541219f, -0.00512079f, -0.03181382f, 
    0.01376648f, 0.03347095f, -0.02202765f, -0.03471886f, 0.01667935f, -0.03636990f, 0.00147334f, -0.00795541f, 
    -0.00484991f, -0.01318894f, 0.00798089f, 0.01490317f, 0.00232810f, -0.03693841f, -0.02364632f, 0.01560725f, 
    0.03249497f, -0.01306753f, 0.02165380f, -0.03859267f, -0.03513683f, -0.03550112f, -0.04426711f, 0.00721374f, 
    -0.00573478f, 0.00028347f, 0.00145866f, -0.03276663f, -0.00951960f, -0.01474859f, -0.00921139f, -0.02154668f, 
    -0.03691209f, 0.01032600f, -0.03070818f, 0.02312805f, -0.03731832f, -0.00302678f, 0.00720135f, 0.00909839f, 
    -0.05204415f, -0.02508740f, 0.03875386f, 0.01997433f, 0.03455399f, -0.03346191f, 0.00157320f, -0.02553032f, 
    0.01120876f, 0.02359459f, 0.02127088f, 0.02771042f, -0.00460548f, -0.03347263f, 0.01622135f, 0.00279845f, 
    -0.00534114f, -0.02660408f, -0.01217538f, 0.01768081f, 0.01158443f, -0.01624740f, 0.03951225f, -0.01991263f, 
    -0.02656810f, 0.01937721f, 0.02291015f, -0.00905437f, -0.01122274f, -0.03874658f, -0.02334104f, -0.02495852f, 
    -0.02872495f, 0.00058997f, 0.03188932f, -0.00067046f, -0.03742446f, -0.02838759f, -0.01446184f, 0.02715103f, 
    -0.03108401f, -0.01857652f, -0.00831704f, 0.02457376f, -0.03304249f, -0.02598616f, 0.00873728f, -0.04126373f, 
    -0.04348382f, -0.02488520f, -0.01846843f, -0.03883523f, -0.03075816f, -0.03780541f, 0.02332244f, -0.00940873f, 
    0.00391061f, 0.01566743f, 0.02570505f, 0.02225375f, 0.03082484f, 0.02819389f, 0.01920949f, -0.03378418f, 
    -0.03426981f, 0.00294617f, -0.03421637f, -0.03128714f, 0.01815360f, -0.01935765f, 0.03111901f, -0.03297106f, 
    -0.01342313f, -0.01335213f, -0.04050451f, -0.02228560f, 0.00203814f, 0.02235178f, -0.00632037f, -0.00964157f, 
    0.00934740f, 0.03240329f, -0.01280624f, -0.01915903f, 0.02231075f, 0.01566635f, -0.01727586f, 0.02245019f, 
    0.01699841f, 0.00662728f, -0.03428459f, -0.02474812f, 0.01543733f, 0.00706397f, 0.02015629f, -0.00394609f, 
    -0.01566236f, -0.00368167f, 0.02450067f, 0.00790913f, -0.00923098f, 0.00566803f, 0.00604718f, 0.00396090f, 
    0.00915003f, -0.02032918f, -0.00735602f, 0.02151978f, -0.04643253f, -0.02356844f, 0.00129870f, -0.02673529f, 
    -0.03268760f, -0.01272471f, 0.00088472f, -0.02424875f, -0.02047981f, 0.00996598f, -0.00611779f, -0.02392437f, 
    -0.04166326f, -0.01863412f, -0.00810176f, -0.01447918f, 0.01503368f, -0.02245483f, 0.02469541f, -0.02084515f, 
    0.03003435f, -0.01782732f, -0.04317705f, 0.02489571f, 0.02506190f, -0.00191184f, -0.04626495f, 0.01284955f, 
    -0.01214573f, 0.00883683f, 0.01068637f, 0.02243350f, -0.01067198f, 0.00803480f, 0.00356768f, -0.01360660f, 
    0.02803951f, -0.01051448f, -0.00058620f, 0.00329332f, -0.03018867f, 0.00212017f, -0.00062230f, 0.02101770f, 
    -0.02467208f, 0.02840565f, -0.01374113f, 0.03936895f, 0.01825143f, -0.02675692f, 0.01990165f, -0.00465647f, 
    -0.00149091f, -0.01970714f, -0.01598677f, -0.01909929f, -0.02098258f, 0.02827895f, 0.02144734f, -0.01990360f, 
    0.01163220f, -0.03318430f, -0.03643509f, 0.00957856f, -0.01611895f, -0.00233943f, 0.01941784f, -0.03935763f, 
    -0.03821476f, 0.02460507f, -0.03678054f, -0.05031227f, 0.00563943f, -0.02014952f, 0.01706480f, -0.00236094f, 
    -0.02498810f, -0.03922032f, -0.04704966f, -0.00010747f, 0.00505618f, 0.01888525f, 0.00984195f, 0.02913717f, 
    0.01730421f, 0.02233964f, 0.02614783f, -0.03997375f, -0.02115480f, -0.02465312f, -0.03941439f, 0.01481395f, 
    -0.03293079f, 0.01083171f, 0.00367359f, 0.02824277f, -0.01343594f, 0.00746199f, 0.02473743f, -0.03611721f, 
    0.01693054f, 0.00888615f, 0.00477397f, -0.00249827f, 0.02905856f, -0.04450354f, -0.00182217f, -0.00241115f, 
    -0.02504734f, 0.03004029f, 0.01823845f, -0.04150372f, -0.03175896f, -0.00088401f, -0.03081096f, -0.03739687f, 
    0.00693083f, -0.00949837f, -0.04240121f, 0.01199577f, -0.01382810f, -0.03040737f, -0.02064762f, 0.01959349f, 
    -0.01941557f, 0.01965747f, 0.03117590f, -0.03434099f, 0.00615791f, -0.02802174f, 0.02633596f, -0.01824508f, 
    0.02937148f, -0.01845956f, -0.01950060f, -0.00390745f, -0.01855241f, 0.01924138f, 0.04843193f, -0.00000427f, 
    -0.01011312f, 0.03937450f, 0.00585905f, 0.03316192f, 0.00420680f, 0.00332350f, -0.03928505f, -0.02923710f, 
    -0.04155385f, 0.01209209f, 0.03299291f, 0.01337523f, 0.03562266f, 0.01612258f, 0.02951028f, -0.02412116f, 
    -0.03577340f, 0.01752708f, -0.02050551f, -0.03133859f, 0.02308429f, -0.00964189f, -0.00788114f, 0.02269129f, 
    0.02200396f, -0.03228635f, -0.03593894f, 0.02473685f, 0.02880780f, 0.01830647f, 0.02074326f, -0.01912672f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02421572f, 0.01471470f, -0.00184802f, 0.02648945f, 0.10924394f, 0.07718051f, -0.05521300f, 0.14102057f, 
    0.03280648f, 0.00010244f, -0.00293019f, -0.04588931f, 0.00636065f, 0.00131177f, -0.01818001f, -0.01675429f, 
    0.00403679f, 0.00650538f, 0.02203965f, -0.02950508f, 0.07979493f, 0.01270239f, 0.00217546f, 0.01727230f, 
    -0.02269433f, 0.01464446f, -0.02651835f, 0.04634989f, -0.03671239f, 0.00939417f, 0.07646103f, 0.00769104f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.03226821f, 0.17114204f, 0.34018540f, 0.29268405f, -0.26681358f, -0.16221465f, 0.05393084f, -0.09915360f, 
    0.09895094f, 0.08971046f, 0.15185443f, 0.15257646f, 0.32210386f, 0.08985824f, -0.16048031f, 0.07309987f, 
    -0.14360055f, 0.02792942f, 0.16985217f, 0.03797096f, -0.20868985f, 0.06898303f, 0.00247956f, -0.31614813f, 
    0.14944132f, -0.19066077f, -0.10551955f, 0.14946225f, -0.05878892f, -0.09695177f, -0.26535729f, 0.09304652f, 
    0.01021560f, 0.00310596f, -0.08193012f, 0.29361254f, 0.42341363f, 0.26494828f, -0.22596020f, -0.04070677f, 
    0.09072741f, -0.11267169f, 0.07286639f, -0.09926171f, -0.23090914f, -0.10658064f, -0.00062667f, 0.09297614f, 
    0.02920943f, 0.19416739f, -0.05185150f, 0.12178690f, 0.15527378f, -0.32976028f, 0.17311174f, -0.29514202f, 
    0.13639332f, 0.00045388f, 0.11458001f, 0.07336058f, -0.10308765f, 0.11467268f, 0.16235602f, -0.07577121f, 
    -0.05258813f, -0.14785798f, 0.40887019f, -0.03964108f, -0.01115331f, -0.00249737f, 0.21954551f, 0.08686104f, 
    -0.05316571f, 0.27418175f, -0.15483594f, 0.09062876f, 0.08012240f, -0.00784073f, 0.09891146f, 0.12272228f, 
    0.21186051f, -0.11603265f, 0.18222746f, 0.10389721f, -0.27189127f, 0.28700942f, -0.13561998f, -0.29813120f, 
    -0.14170499f, -0.48703039f, -0.04406701f, 0.08039387f, -0.09821804f, -0.16367908f, 0.31528473f, 0.06680219f, 
    0.01798480f, 0.01982152f, -0.00098147f, -0.16684289f, -0.09242161f, 0.10249016f, -0.15502301f, -0.19572838f, 
    0.08086593f, -0.20763531f, -0.14610392f, -0.17250805f, -0.07369551f, -0.06046431f, 0.01291514f, 0.00121941f, 
    -0.02393688f, 0.08261051f, 0.07417314f, -0.05980420f, 0.10865293f, 0.04416350f, 0.09632125f, 0.11631478f, 
    0.15867615f, -0.18399149f, -0.14950679f, 0.10919646f, -0.13043705f, 0.11921754f, -0.07466779f, -0.15728538f, 
    -0.10816445f, -0.10897277f, 0.22394788f, 0.26797614f, 0.09822597f, -0.28107822f, -0.22728430f, 0.05750085f, 
    0.03246018f, -0.31524765f, -0.14205137f, -0.02504450f, 0.27937850f, -0.09695693f, 0.33044040f, 0.03015932f, 
    -0.21189079f, -0.54661977f, -0.14676175f, 0.05139101f, 0.11454838f, 0.08695445f, 0.16006956f, 0.00680308f, 
    -0.01385167f, -0.02235006f, -0.13583407f, 0.26620805f, -0.00402486f, -0.11926995f, 0.29159352f, 0.15739028f, 
    0.06441414f, 0.07792619f, 0.16605964f, 0.11306909f, 0.07617652f, -0.00036854f, 0.25511122f, 0.14715390f, 
    -0.38725555f, 0.04734324f, 0.14695640f, 0.16110507f, 0.14290912f, 0.09911562f, -0.05104400f, -0.10300770f, 
    -0.26025721f, 0.28013411f, -0.02683697f, 0.09632859f, -0.06519908f, -0.16296734f, -0.04676538f, -0.03806215f, 
    0.03449887f, -0.00160549f, -0.15464436f, -0.09940276f, 0.07331310f, 0.07693861f, 0.39553273f, 0.16067910f, 
    -0.04369154f, 0.09282009f, 0.03645947f, -0.38570794f, 0.23906429f, 0.15386921f, -0.02978008f, 0.18994039f, 
    0.12537412f, 0.30676448f, -0.08660812f, 0.30583498f, 0.20794772f, -0.11278971f, -0.25204241f, -0.15815529f, 
    -0.21980192f, 0.20376888f, 0.15036127f, -0.03462744f, -0.17060265f, -0.27729771f, 0.11033355f, 0.01695206f, 
    -0.06202613f, -0.18966709f, -0.04074492f, 0.32611817f, 0.08456016f, 0.08736771f, -0.20804565f, -0.07698869f, 
    0.04628084f, 0.04861699f, 0.11558799f, -0.19210771f, -0.23825338f, -0.03592419f, 0.03938675f, 0.26677421f, 
    0.04830805f, -0.12613241f, -0.08177560f, 0.30127281f, 0.17256856f, 0.05074832f, 0.30080298f, -0.13240810f, 
    -0.14739534f, -0.11621263f, 0.05829636f, -0.12863789f, 0.02854259f, -0.20892361f, -0.14569513f, 0.48928440f, 
    -0.10495640f, 0.01775304f, -0.00231279f, 0.11836112f, -0.01226844f, 0.01950417f, 0.13340421f, -0.14119692f, 
    0.16479594f, -0.08842803f, 0.03481039f, 0.01261496f, 0.17313652f, 0.02929801f, -0.10594228f, 0.32421172f, 
    -0.00275685f, 0.20595416f, 0.01460859f, 0.04472131f, -0.23885426f, -0.05048487f, 0.23359603f, 0.04979745f, 
    -0.08130940f, -0.10071829f, -0.08448148f, 0.14901479f, 0.01958077f, 0.21733624f, -0.09940088f, 0.17411216f, 
    0.01357879f, -0.09237839f, -0.08684441f, 0.10824742f, 0.12644240f, -0.12112685f, 0.01338011f, -0.01445052f, 
    -0.04975538f, -0.03654391f, -0.23123132f, 0.17127611f, 0.29878095f, -0.00461114f, -0.36133569f, -0.06207775f, 
    0.36414745f, 0.11297823f, 0.00739106f, -0.28493205f, 0.10254047f, 0.09913224f, -0.13578822f, -0.11515297f, 
    0.11053031f, -0.14330566f, 0.01338770f, 0.01786276f, 0.13027400f, -0.04824059f, -0.12714936f, 0.25152317f, 
    0.14081982f, 0.21519326f, 0.17087877f, -0.00611247f, 0.09037821f, 0.07401838f, -0.16395186f, 0.05874777f, 
    -0.00195308f, 0.06371617f, -0.05863012f, -0.04421362f, -0.01748947f, -0.02259014f, 0.16648448f, -0.12475810f, 
    -0.13697231f, -0.15741384f, -0.01743034f, -0.13118927f, -0.06775641f, -0.04608526f, -0.06479891f, -0.06590768f, 
    -0.14502007f, 0.08828355f, 0.08503634f, -0.15763834f, -0.16698159f, -0.12055446f, -0.09516596f, -0.15262695f, 
    0.01339119f, -0.09660140f, -0.02907928f, -0.01650454f, -0.13066347f, -0.06424570f, -0.15641397f, -0.12233152f, 
    0.11190929f, -0.03616539f, 0.05117321f, 0.35363790f, 0.31300366f, -0.10747874f, -0.34894589f, 0.05543698f, 
    0.16024381f, -0.12777239f, -0.05998442f, 0.05313180f, 0.01917886f, 0.06113328f, 0.12326988f, -0.05404257f, 
    0.24081737f, -0.08558915f, 0.17085141f, -0.05517655f, -0.06040515f, -0.31637838f, 0.05922479f, 0.15885556f, 
    0.10608172f, -0.41933653f, 0.15556027f, -0.32912797f, 0.05115018f, 0.15326202f, 0.26589948f, 0.12345025f, 
    -0.15841529f, -0.01702724f, 0.21340637f, 0.07098933f, -0.23685090f, 0.35347116f, 0.18617587f, -0.09558525f, 
    0.33038953f, 0.20969754f, 0.02044073f, -0.04666929f, -0.19401656f, 0.01604517f, -0.24806499f, -0.00128934f, 
    0.44407830f, -0.28953838f, 0.17059711f, -0.03661878f, 0.25047532f, 0.28039220f, 0.11267129f, -0.14803001f, 
    0.06821042f, -0.13645914f, -0.12540634f, -0.11860057f, -0.12763068f, -0.12423757f, 0.17917858f, 0.09086128f, 
    -0.11236732f, -0.15272091f, -0.10521013f, 0.18655765f, 0.36654875f, 0.27543756f, 0.13456579f, 0.06736241f, 
    0.36610764f, 0.13586898f, 0.08151700f, -0.24816918f, -0.05020647f, -0.15739864f, -0.38447478f, 0.14058653f, 
    0.27994043f, -0.10077034f, 0.12633988f, -0.14651383f, -0.35471404f, 0.29295686f, 0.09250909f, -0.38834253f, 
    0.16242857f, -0.03107473f, 0.07221413f, 0.31617460f, -0.17418541f, 0.15573467f, -0.17720267f, 0.07652609f, 
    -0.00050823f, 0.13689597f, -0.29665464f, -0.24486694f, -0.15096073f, 0.30174375f, 0.02255685f, 0.04426146f, 
    0.05319497f, 0.00235446f, -0.09406836f, 0.15963750f, 0.16728364f, -0.13106477f, -0.01984133f, -0.17320044f, 
    0.10717454f, 0.22027928f, -0.00780374f, -0.11377977f, 0.09688623f, 0.13350940f, -0.06775313f, 0.13202636f, 
    -0.09905770f, 0.37333864f, 0.13326831f, 0.12276501f, 0.12218683f, 0.11589769f, -0.28571728f, -0.09428043f, 
    0.11800683f, 0.03316981f, 0.21055013f, -0.14776278f, 0.25565171f, 0.30729628f, -0.05420316f, 0.29065624f, 
    0.01916553f, 0.07662386f, -0.16316672f, -0.00987474f, 0.14687230f, -0.10188613f, -0.17630960f, -0.13767268f, 
    -0.23501177f, -0.02915400f, -0.05342742f, -0.14694127f, -0.22967416f, 0.16852374f, 0.09909881f, -0.22345062f, 
    0.04439599f, -0.30451292f, -0.08175369f, 0.01118882f, 0.08509279f, -0.04517073f, 0.03185733f, 0.12242601f, 
    -0.05057991f, 0.01665045f, -0.18370561f, 0.01871740f, -0.01387019f, 0.01334814f, -0.08044812f, 0.29443038f, 
    -0.21154988f, 0.26770720f, -0.15482940f, -0.20519923f, 0.12510732f, 0.16715646f, -0.07516653f, 0.06472936f, 
    0.16626093f, 0.47864980f, 0.00311096f, -0.03601950f, -0.13350303f, -0.26242235f, 0.16782403f, -0.06061989f, 
    0.04296830f, -0.05495599f, -0.12148236f, -0.16070984f, 0.02323858f, -0.09608013f, 0.40780839f, -0.08292467f, 
    0.12179238f, 0.10906343f, 0.37409982f, 0.09997141f, -0.30194977f, 0.15554443f, 0.43921188f, -0.05865260f, 
    -0.42918798f, -0.03637923f, -0.01087642f, 0.24045943f, 0.05104762f, 0.03814545f, 0.10257605f, -0.15984312f, 
    -0.18455587f, 0.01938768f, 0.11318052f, 0.01972240f, -0.01397848f, 0.02780792f, 0.14395459f, 0.07043605f, 
    -0.02285624f, 0.01820506f, 0.15277213f, 0.39888045f, -0.04561129f, -0.02663254f, -0.00655591f, -0.12893623f, 
    -0.11742330f, -0.05417452f, -0.31759673f, 0.32878730f, -0.17946494f, 0.09947417f, 0.09310687f, -0.11937878f, 
    -0.11519047f, 0.22647642f, 0.02684488f, 0.16602074f, 0.18384036f, -0.12042780f, -0.06903780f, 0.02361201f, 
    -0.07234100f, 0.16534071f, -0.15638131f, 0.01006304f, 0.21136813f, -0.37166455f, -0.13441166f, 0.17464694f, 
    -0.05748978f, 0.53390199f, -0.00772080f, -0.04334532f, -0.02654032f, -0.03925428f, 0.11552587f, -0.08581087f, 
    0.13048100f, 0.03560429f, -0.05525706f, -0.26254001f, 0.39229599f, 0.01164310f, -0.37990177f, 0.12319043f, 
    0.09498931f, 0.08835180f, -0.15574069f, -0.05851183f, 0.05018489f, 0.15963310f, -0.09560877f, 0.03778803f, 
    -0.04590787f, -0.07397076f, -0.05603361f, -0.05404261f, 0.34189123f, -0.30420423f, -0.14743444f, 0.05985210f, 
    0.00775583f, -0.19567707f, -0.02858541f, 0.32110968f, 0.08328580f, -0.12806059f, 0.03751809f, -0.01879339f, 
    0.05581161f, -0.11015266f, -0.01654676f, -0.01062711f, -0.05940355f, -0.15944767f, 0.10171331f, -0.09520015f, 
    0.04788907f, -0.04467298f, -0.02309663f, -0.19412053f, 0.12247995f, 0.11269151f, -0.12588298f, 0.09773401f, 
    0.10247048f, -0.01717948f, -0.12347242f, -0.17605226f, -0.13674206f, -0.01913677f, 0.05565566f, -0.04402493f, 
    0.06245141f, -0.02427396f, -0.07319790f, 0.05531230f, -0.11739393f, -0.01977057f, -0.07733407f, -0.15956825f, 
    0.15119998f, -0.14501515f, -0.10705962f, 0.14251608f, 0.03862574f, -0.06773179f, 0.01237892f, 0.09822589f, 
    -0.18565044f, -0.02499583f, 0.03563559f, 0.08232868f, -0.08380258f, 0.02259804f, -0.16050386f, -0.02036673f, 
    0.03711724f, 0.02730074f, 0.10048304f, -0.06091284f, -0.06681863f, -0.16959651f, 0.03991353f, -0.09434892f, 
    -0.15579486f, 0.05884558f, -0.04047199f, -0.11839274f, -0.11291680f, 0.11988431f, -0.11848982f, -0.14617974f, 
    0.06357901f, -0.14636189f, 0.26009208f, 0.15812026f, -0.30914378f, 0.06135952f, -0.03504901f, 0.13344485f, 
    0.05808173f, -0.12059335f, -0.06335761f, -0.05445886f, 0.06721059f, -0.00703765f, 0.29689899f, -0.00856668f, 
    -0.02587358f, -0.27611086f, 0.01625356f, -0.13730936f, 0.18124665f, 0.46813172f, 0.05727578f, -0.05672675f, 
    0.05030153f, 0.22561100f, 0.17601156f, -0.04846431f, -0.06138559f, 0.14725336f, -0.00498891f, -0.00172488f, 
    0.06031111f, 0.11715789f, 0.04627210f, 0.03244210f, 0.04851035f, 0.04437295f, -0.16791855f, -0.11495308f, 
    -0.12414046f, -0.03076581f, 0.00750231f, 0.09041175f, -0.07941363f, 0.08930714f, 0.05302486f, -0.15916716f, 
    -0.05281125f, -0.11647890f, 0.01361078f, 0.05860201f, -0.03591025f, -0.12790817f, -0.06588125f, 0.16688250f, 
    0.13374463f, 0.07320525f, -0.14849988f, -0.10394623f, 0.03169867f, 0.06034923f, -0.01287853f, 0.10854679f, 
    -0.04486908f, 0.00971926f, 0.29731277f, 0.16165534f, -0.22209607f, -0.27464283f, 0.01652800f, 0.17141412f, 
    -0.14719999f, -0.25103420f, 0.06387043f, 0.16404758f, 0.24320310f, -0.15631700f, 0.45029604f, 0.02674848f, 
    0.20284393f, -0.00950174f, -0.04006618f, 0.07474176f, 0.38493577f, -0.05951338f, -0.14709856f, 0.04150910f, 
    -0.13792907f, -0.34361264f, -0.10846204f, -0.26583818f, 0.06200738f, 0.03701566f, 0.18759936f, -0.06600228f, 
    -0.12561083f, 0.11531270f, -0.11500355f, 0.17726351f, 0.10880335f, -0.28748000f, 0.18162033f, -0.16932863f, 
    0.11660010f, 0.11577794f, 0.05462470f, 0.23501754f, 0.17300633f, -0.08399510f, 0.36898187f, 0.12942919f, 
    0.25136951f, 0.29289865f, -0.10170620f, 0.02352183f, -0.29525125f, -0.23813075f, -0.03155404f, 0.32564658f, 
    -0.13288748f, -0.09033688f, -0.10609295f, 0.17063582f, -0.00710160f, -0.02549342f, -0.33610678f, 0.17106929f, 
    0.16684072f, 0.05645454f, 0.29556012f, -0.14242017f, 0.27375269f, -0.18261573f, -0.22398709f, -0.14388764f, 
    0.02383844f, -0.19779199f, 0.17790997f, 0.26842752f, 0.24461086f, 0.12861173f, 0.17834292f, -0.06481025f, 
    0.15264307f, -0.30797052f, 0.10693872f, 0.04224109f, 0.33182478f, 0.40906245f, -0.16834076f, -0.34261963f, 
    0.13058291f, -0.16950060f, -0.12793942f, 0.25537774f, -0.07819438f, 0.18238185f, -0.12791987f, 0.14704898f, 
    0.11188554f, 0.14940616f, -0.16717845f, -0.00872912f, -0.09905501f, 0.01815718f, -0.17144352f, 0.11031960f, 
    0.05349246f, -0.12426508f, 0.07151441f, -0.17291342f, -0.16193324f, 0.12199295f, -0.01117451f, 0.14652766f, 
    0.09455127f, -0.18431062f, 0.04543101f, -0.06426558f, 0.04513807f, -0.16916613f, 0.08150173f, -0.03255876f, 
    -0.04752314f, 0.16382927f, -0.16134056f, 0.00709736f, -0.07792982f, 0.07987309f, -0.10408443f, -0.08247061f, 
    -0.11876042f, -0.06300796f, -0.04552167f, 0.00126394f, 0.21566121f, 0.04738064f, -0.12083328f, 0.23732430f, 
    0.18229394f, -0.17619033f, 0.04845498f, -0.24673088f, 0.14245488f, -0.02513795f, 0.02718826f, -0.00796443f, 
    -0.39515281f, 0.08712863f, -0.16734916f, -0.12929821f, 0.18705536f, 0.07432000f, 0.11720075f, 0.05669125f, 
    -0.02406072f, 0.45148861f, 0.10479277f, 0.26511446f, -0.09561733f, 0.11286309f, 0.04406893f, -0.04865770f, 
    0.05608046f, 0.14166392f, -0.16371347f, -0.14912234f, 0.28868484f, -0.01302182f, -0.24772482f, 0.04267467f, 
    -0.00565503f, -0.17238151f, 0.12172807f, 0.06050683f, 0.29453605f, 0.05355091f, 0.10971505f, -0.05273904f, 
    0.04795207f, 0.31931746f, 0.07997081f, -0.00097713f, 0.39587882f, -0.15405156f, -0.11245665f, -0.06711233f, 
    -0.10747563f, -0.00910071f, -0.03305717f, -0.25208515f, -0.08223104f, 0.11546909f, -0.16198878f, 0.04543924f, 
    -0.17020208f, -0.05162515f, -0.13111584f, -0.08423444f, -0.33076027f, 0.34110993f, 0.25332576f, -0.02374544f, 
    0.11670160f, 0.31273773f, -0.12619270f, 0.35827202f, -0.17974134f, 0.02787940f, -0.20338452f, -0.00404823f, 
    0.40718251f, 0.08428818f, -0.15957259f, -0.04627707f, 0.19099507f, 0.05014144f, 0.09368045f, 0.05866216f, 
    -0.00650667f, -0.16843420f, -0.03146897f, -0.12664789f, -0.01507766f, -0.02658716f, 0.28362548f, 0.13181947f, 
    -0.13863337f, 0.08588029f, 0.00621971f, 0.05342706f, 0.16135070f, -0.11864076f, -0.10059884f, 0.13294370f, 
    -0.00241779f, 0.23532708f, 0.04697833f, -0.27242264f, 0.27423409f, 0.13591512f, 0.12168378f, 0.01465290f, 
    -0.17968138f, 0.07285975f, 0.09185121f, 0.10708899f, -0.12259775f, -0.10163891f, -0.12145103f, 0.38542670f, 
    -0.07721974f, 0.49462947f, -0.06749666f, 0.25975391f, -0.17781296f, 0.05000321f, -0.10918722f, 0.10438600f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.16717014f, -0.00046418f, 0.10886929f, -0.07074063f, -0.03167651f, 0.14891540f, 0.07897609f, -0.13168083f, 
    0.19297129f, 0.21903728f, -0.06702097f, -0.08248988f, 0.22157811f, 0.01511739f, 0.06982195f, 0.22996454f, 
    0.13869232f, 0.15877977f, 0.02118222f, 0.10768224f, 0.11858029f, -0.05447885f, 0.24676840f, -0.07968881f, 
    0.02534883f, 0.08209520f, 0.07520284f, 0.00960387f, 0.02923292f, -0.12297082f, -0.06190449f, -0.02361144f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.56391764f, -0.39698696f, 0.08139963f, -0.14054796f, -0.41117972f, 0.11969449f, 0.16492482f, 0.18696544f, 
    0.15191092f, -0.33762515f, -0.16101727f, -0.65605175f, -0.04727029f, -0.12281834f, 0.22367522f, -0.22970337f, 
    -0.03767818f, 0.41178253f, 0.17561355f, -0.33392495f, 0.06118736f, -0.09497904f, -0.14870851f, 0.17526497f, 
    -0.28788865f, 0.38875356f, -0.44884172f, 0.08501529f, -0.19827543f, -0.23868638f, 0.08062971f, 0.09945033f, 
    0.08196940f, 0.05452409f, -0.58755171f, -0.04834219f, -0.01295361f, 0.05860839f, 0.12025911f, -0.17620601f, 
    -0.21326792f, 0.16272354f, -0.10762499f, -0.42226189f, -0.04793316f, -0.15566455f, 0.27907455f, -0.16525145f, 
    0.22829406f, -0.10175923f, 0.38305077f, 0.19144987f, 0.11789618f, -0.11935922f, -0.12973475f, 0.07320043f, 
    -0.20709108f, -0.22411206f, 0.13839415f, -0.00558918f, 0.30430767f, 0.25787011f, -0.07950722f, 0.10856312f, 
    -0.29715705f, -0.27933720f, -0.31789851f, -0.19398837f, -0.27483359f, -0.16782141f, -0.12871306f, 0.23986515f, 
    -0.27631849f, 0.08795394f, 0.08288051f, 0.29695147f, -0.01403383f, -0.30744028f, 0.17691487f, -0.56654918f, 
    0.21177447f, -0.55065888f, 0.16150272f, -0.35376182f, -0.00419268f, 0.01232128f, -0.20788738f, -0.10307574f, 
    0.25704560f, 0.40342394f, -0.55098993f, 0.00000803f, -0.24275142f, 0.23701346f, 0.10967848f, -0.09839712f, 
    0.07184331f, -0.30176136f, -0.14551219f, 0.09137291f, 0.31110641f, 0.17719433f, -0.10298631f, 0.24222820f, 
    -0.10436492f, -0.34771588f, 0.16110769f, -0.26918811f, 0.05133770f, -0.21955344f, -0.02052099f, -0.08120099f, 
    -1.02761078f, 0.39486572f, 0.00120895f, -0.21495114f, 0.06281836f, -0.01918254f, 0.17634049f, 0.09529663f, 
    0.07634874f, -0.31273317f, 0.14685111f, -0.14248936f, 0.14441486f, -0.43576482f, -0.10693629f, -0.15193430f, 
    -0.24707253f, -0.32243860f, 0.24199656f, 0.00357241f, -0.14198369f, 0.01488367f, -0.08565719f, -0.04325037f, 
    0.20382461f, -0.41596323f, 0.01401463f, -0.30681515f, 0.19201736f, -0.08898630f, 0.13451910f, 0.25500479f, 
    0.08320802f, -0.00893885f, -0.49403995f, 0.00879297f, -0.17412670f, 0.05214665f, 0.23244107f, 0.05111593f, 
    0.04629792f, -0.61828381f, 0.21232028f, -0.03657139f, -0.01788938f, 0.30797258f, -0.00107708f, -0.32430646f, 
    0.45067480f, 0.06185179f, 0.19491188f, 0.03436577f, -0.42226762f, 0.12975930f, 0.29283997f, -0.19182335f, 
    -0.08364520f, -0.07670456f, 0.01141324f, -0.04625358f, 0.06278780f, 0.31122887f, 0.01305129f, 0.43605551f, 
    0.10621447f, 0.12134971f, -0.23829935f, 0.03281238f, -0.11027101f, -0.00392754f, -0.33966967f, 0.07756639f, 
    -0.66996837f, -0.11073993f, -0.15772264f, 0.09408708f, -0.00068395f, -0.02781717f, -0.08074363f, -0.11270382f, 
    -0.85818619f, 0.29607511f, -0.15119103f, 0.01030635f, -0.49358377f, -0.45244792f, -0.45279530f, -0.25998202f, 
    0.17285173f, 0.09066915f, -0.11566425f, -0.16005126f, 0.34305653f, 0.36164480f, 0.21781701f, -0.18928845f, 
    -0.21943088f, -0.22363763f, 0.10650664f, -0.71388686f, 0.14224523f, -0.13976033f, 0.18827824f, -0.13902286f, 
    -0.39013791f, -0.00231164f, -0.16974525f, 0.07086002f, -0.13114810f, -0.38372013f, 0.26574057f, -0.27156577f, 
    0.42877805f, -0.13041183f, 0.22370031f, -0.18439892f, 0.07356244f, -0.07753024f, -0.29714134f, -0.36384186f, 
    -0.46037194f, -0.06388619f, 0.15196221f, 0.03657828f, 0.04499744f, 0.03522371f, -0.40966704f, -0.47815502f, 
    -0.16038953f, 0.21812616f, -0.29166079f, -0.17009120f, -0.05114805f, -0.14814529f, 0.02849038f, -0.17010412f, 
    0.27836460f, 0.31658575f, 0.25190666f, -0.06771979f, -0.45900032f, 0.12137839f, -0.29126525f, -0.23672040f, 
    -0.37283131f, 0.41545090f, -0.27395648f, -0.09814647f, 0.07447103f, -0.33613390f, 0.30689666f, -0.02465247f, 
    0.23018965f, 0.02396694f, 0.08798399f, 0.26771194f, -0.31249908f, -0.19828579f, 0.07560784f, -0.10083026f, 
    -0.39561155f, -0.32147318f, -0.30047193f, 0.48083371f, 0.10974135f, 0.07418010f, -0.41864204f, -0.16070932f, 
    0.09503613f, 0.22113480f, 0.37021405f, -0.02379943f, 0.04574532f, 0.21381180f, -0.19495264f, -0.16662198f, 
    0.07002348f, 0.17709915f, 0.21950111f, -0.12227847f, -0.09665614f, 0.31902522f, -0.56684339f, -0.20455985f, 
    -0.02759701f, -0.25683820f, 0.05146541f, 0.31992051f, 0.26195335f, -0.19024916f, -0.28614122f, -0.25126192f, 
    0.29906902f, 0.01878981f, 0.27444747f, -0.04471236f, -0.01531677f, -0.02259869f, -0.18688726f, 0.09241515f, 
    0.04802829f, -0.35373488f, -0.38677764f, -0.02904113f, -0.58671659f, -0.25912333f, 0.25690532f, -0.55237341f, 
    -0.19751434f, 0.21149860f, -0.02019561f, -0.03988542f, 0.20452385f, 0.35025302f, -0.48965704f, 0.02349463f, 
    0.19643392f, -0.18223409f, -0.13769507f, 0.14509311f, -0.45905402f, -0.14921464f, -0.24757671f, -0.04267462f, 
    0.31571814f, 0.13337725f, 0.14915913f, -0.59230530f, 0.13196485f, -0.06064552f, 0.03623141f, 0.06297433f, 
    0.03621114f, 0.05947156f, -0.32858622f, 0.13730049f, 0.31052294f, -0.08958692f, -0.73560143f, 0.17724437f, 
    -0.39455423f, -0.15770273f, -0.09080119f, -0.01975601f, 0.32744557f, -0.46546301f, -0.40180093f, -0.05842722f, 
    0.22808138f, 0.49216416f, 0.13028425f, 0.13116428f, 0.15461469f, 0.12833720f, -0.15832211f, -0.18648976f, 
    -0.22648737f, -0.42028302f, -0.23377725f, 0.08993223f, 0.08321854f, -0.13821287f, 0.17977177f, -0.06857118f, 
    -0.22017133f, -0.10114253f, 0.00351820f, -0.07452094f, 0.15461262f, -0.37062532f, -0.29662597f, 0.24116105f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.00146458f, -0.05686326f, 0.01483646f, -0.00834687f, -0.02274728f, 0.12391020f, 0.02347280f, -0.18761469f, 
    -0.16487259f, 0.08277164f, 0.04770944f, 0.13786112f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
