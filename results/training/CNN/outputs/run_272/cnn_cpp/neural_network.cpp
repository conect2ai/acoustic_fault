#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.22963515f, 0.74944305f, 0.10616585f, -0.77361256f, 0.13824786f, 0.01633177f, -0.09790200f, -0.84990370f, 
    -0.78893822f, -0.95872569f, -0.32863864f, 0.62952203f, 0.34919021f, -0.27950689f, 0.23519410f, 0.38298830f, 
    0.17485601f, 0.20364335f, 0.27423707f, 0.24749266f, 0.40218234f, 0.45972857f, 0.11240499f, 0.06157165f, 
    0.28209031f, -1.30632842f, 0.50407165f, 1.31710124f, -0.74034256f, 0.37767300f, 0.83218032f, -0.65883934f, 
    0.58295512f, -0.67377818f, -0.82653785f, -0.33361739f, -0.00394794f, 0.11048867f, 0.17326157f, -0.48478681f, 
    -0.00264167f, 0.16699637f, 0.03816967f, -0.30338931f, -0.03171992f, 0.18582134f, -0.04595587f, 0.01766713f, 
    -0.03622305f, 0.02705007f, -0.18117468f, -0.74205542f, -0.15197136f, 0.46387896f, 0.04975578f, -0.38787103f, 
    -1.06711245f, -0.40236551f, 0.05087961f, -0.44400388f, 0.41380146f, 0.57187903f, 0.33035398f, 0.32862580f, 
    -0.18841553f, 0.15686725f, 0.22592495f, 0.02015870f, 0.40263003f, 0.51770496f, 0.30000731f, 0.07508132f, 
    -0.40143114f, -0.01740355f, 0.41867265f, 0.42006561f, -0.56594229f, 0.93551785f, 1.28296578f, -0.43261606f, 
    0.31384784f, -0.55205697f, 0.34055007f, 0.27891064f, -0.42241043f, -0.05706118f, -0.51879865f, -0.33811817f, 
    -0.25552201f, -0.08912885f, -0.01972997f, 0.17261578f, 0.16574115f, -0.10303752f, -0.05900598f, 0.09769819f, 
    -0.29497287f, -0.20720397f, -0.34127069f, -0.50642151f, 1.33278906f, 0.05925031f, -0.80705738f, -1.36743104f, 
    -0.00506483f, 0.63932109f, -0.37945274f, 0.16604307f, -0.09504590f, 0.28847879f, -0.39597923f, 0.36119539f, 
    -0.01886060f, 0.27565801f, -0.29334337f, -0.01460636f, 0.05362689f, 0.08612909f, 0.36008823f, 0.48821300f, 
    0.10365733f, 0.18505934f, -0.22316593f, -0.42480582f, 0.10698175f, 0.86418676f, 0.20802626f, 0.11263120f, 
    0.91803068f, 0.96598911f, -0.55628717f, -0.52896047f, -0.16051202f, -0.25876489f, -0.04972452f, 0.63967925f, 
    0.37405640f, 0.00890866f, -0.31335333f, 0.05651407f, 0.56264567f, -0.32430214f, 0.03495931f, 0.02372222f, 
    0.55866510f, -0.40191308f, -0.37749010f, 0.19794831f, -0.27782795f, -0.13569115f, -1.45831323f, -0.16501893f, 
    -0.42006075f, 0.73530120f, -0.48396936f, 0.91022187f, 0.52220243f, -0.10945591f, -0.35087529f, -0.45866877f, 
    0.10215916f, 0.21429045f, -0.01977971f, 0.23053847f, 0.40179682f, 0.02302759f, -0.21900108f, -0.46376523f, 
    -0.51882565f, -0.16528758f, 0.36501214f, 0.09330289f, 0.45409259f, -0.12204414f, -0.24420345f, 1.39809525f, 
    0.85295033f, -0.88936436f, 0.22255297f, -0.59079295f, -0.03827608f, 0.63997287f, -0.26712918f, 0.82026047f, 
    0.22324117f, 0.35703528f, 0.20927013f, -0.08404192f, -0.26337838f, -0.11787563f, -0.14516203f, -0.39359295f, 
    -0.31263921f, -0.12483268f, 0.05673282f, -0.29368135f, 0.21266104f, -0.04185997f, 0.05264124f, -0.25670424f, 
    0.49199823f, 1.41402292f, -0.92470759f, -0.13081931f, -0.37824196f, 0.10093205f, -0.57937956f, 0.25807053f, 
    -0.38231418f, -0.39273965f, 0.39399520f, 0.25816080f, 0.18673995f, 0.56811416f, 0.03810357f, 0.43004847f, 
    -0.49010217f, -0.07741379f, 0.01873554f, -0.14521924f, -0.04481136f, 0.00173152f, -0.13478453f, 0.06991433f, 
    0.09356941f, 1.04650056f, 0.82386559f, 0.49062201f, -0.34931910f, -0.56176674f, -0.92065483f, -0.61553848f, 
    -0.65935069f, -0.03700200f, 0.08038016f, 0.09699690f, 0.14612447f, -0.13703068f, 0.19819179f, -0.02702457f, 
    -0.38071969f, -0.43977374f, 0.17215960f, -0.36005574f, 0.05613074f, -0.20866790f, 0.48109215f, 0.00286160f, 
    -0.37756830f, -0.15784028f, 0.66660571f, 0.12501989f, 0.16009529f, 0.89163905f, 0.26129612f, 0.31105772f, 
    0.35702604f, 0.37058368f, 0.34118435f, 0.75047225f, -0.52386463f, 0.26985270f, 0.48961160f, -0.44436806f, 
    0.45704809f, -0.34545025f, -0.23753679f, 0.02875513f, -0.46072981f, -0.20759878f, 0.44921049f, -0.43662485f, 
    -0.21690553f, -0.14147636f, -0.03923457f, -0.22555941f, -0.83933604f, -0.49136889f, -0.39258096f, -0.67570114f, 
    0.83518499f, 0.39998421f, 0.60907835f, -0.19883555f, -0.17136076f, -0.44008854f, -0.17543286f, 0.41038430f, 
    0.48066628f, -0.39474189f, -0.31552464f, -0.11827081f, 0.17511491f, -0.41744637f, 0.05526034f, 0.04203020f, 
    -0.13648894f, 0.12999558f, 0.04818463f, 0.29069331f, 1.10672414f, -0.59921712f, -1.15295470f, -0.42490819f, 
    0.64588505f, 0.35965830f, 0.19396421f, -0.49003917f, 0.49696034f, 0.34992522f, -0.45013094f, 0.01071220f, 
    -0.01273618f, 0.02088842f, 0.16767398f, -0.22088777f, -0.09302668f, -0.16631551f, -0.36626342f, -0.36340055f, 
    0.03784405f, 0.05347642f, 0.39082754f, 0.12638089f, 0.02762516f, -0.83076078f, -0.35486335f, -0.48270294f, 
    0.46311146f, 0.49230796f, -1.00810933f, 0.02621672f, -0.62868011f, 0.22023156f, -0.39907610f, 0.64497501f, 
    0.41192850f, 0.01701899f, -0.40128398f, -0.46965486f, -0.02098139f, -0.15385447f, -0.39584666f, -0.18207391f, 
    -0.23116660f, -0.11679962f, 0.04044025f, -0.09971279f, -0.08684055f, -0.24341463f, -0.32947201f, 0.36227840f, 
    -0.18976419f, -0.97542560f, -0.89991647f, -0.34793803f, -0.85784507f, 0.30623332f, 0.52982402f, -0.13419916f, 
    -0.06879874f, 0.31081125f, -0.11674716f, 0.14436422f, -0.31551817f, -0.29066592f, 0.37023488f, 0.10817391f, 
    -0.11815716f, -0.08453609f, -0.15254748f, 0.24054082f, 0.22709477f, 0.08578297f, 0.28525466f, 0.95084018f, 
    0.73542351f, 1.02312791f, 1.00269890f, 0.48502839f, 0.03695930f, 0.10388207f, -0.89011228f, -0.39115548f, 
    0.27186477f, 0.26123762f, 0.39718756f, 0.02911946f, 0.18820874f, -0.51950437f, -0.07738683f, -0.23613825f, 
    0.46718970f, 0.21962331f, -0.13494326f, -0.05587651f, 0.48395583f, -0.15226974f, -0.07042708f, 0.13250627f, 
    0.85321331f, -0.62343216f, -0.24868397f, -0.11461289f, -0.15670401f, 0.79915267f, 0.28511745f, 0.32250777f, 
    -0.63407433f, -0.69158876f, 0.29614052f, 0.51927954f, -0.02533851f, -0.19899240f, -0.44362333f, 0.28743589f, 
    0.01836648f, -0.70545357f, -0.12547757f, -0.33339402f, -0.00920727f, -0.47013766f, 0.27255610f, 0.24892445f, 
    0.11472405f, 0.89619869f, 0.94230753f, 1.16084921f, 0.30278689f, 0.06917682f, 0.39468953f, -0.01729845f, 
    -0.21980149f, -0.49925846f, 0.26006645f, 0.40274435f, 0.15196870f, -0.21642086f, 0.24751586f, 0.33499861f, 
    0.00636675f, 0.27800757f, 0.24174283f, 0.46188426f, 0.15037462f, 0.28756124f, -0.30388826f, -0.11305638f, 
    0.22344387f, 0.35894287f, 0.42886680f, -0.07268742f, 0.48456150f, 1.05121255f, -0.89777660f, -1.11409295f, 
    -0.49223235f, -0.37061715f, 0.06765890f, -0.19562210f, -0.05723088f, -0.00638293f, -0.00985956f, -0.58433872f, 
    -0.61365402f, -0.68191272f, -0.39887863f, -0.01814296f, 0.17489861f, -0.15713142f, 0.40163845f, 0.12123212f, 
    -0.16579357f, 0.12393726f, 0.18223198f, -0.32155627f, 1.00432801f, 0.82864475f, 0.51672852f, 0.65797359f, 
    -1.50497890f, 0.44946295f, -0.26150340f, -0.68758583f, -0.32510948f, -0.04042128f, -0.12391482f, 0.03377192f, 
    0.17672062f, 0.41448572f, 0.24553151f, -0.00025341f, 0.01940667f, -0.10450512f, -0.08045016f, -0.11398330f, 
    -0.06745064f, 0.02156416f, -0.05196733f, -0.16886683f, -0.22676073f, -1.37660682f, 0.00109833f, 1.24988437f, 
    -0.12269197f, -0.73125476f, 1.24328804f, -0.04599871f, 0.53000152f, -0.29925090f, 0.38150293f, -0.00278780f, 
    0.15729351f, -0.01459173f, -0.01969900f, -0.60387826f, -0.11056352f, 0.09950483f, -0.20007187f, -0.14562023f, 
    -0.02289850f, 0.31884542f, -0.12733127f, 0.14165379f, 0.03236784f, -0.10936560f, -1.45959330f, -0.23537669f, 
    -0.25896946f, 0.45277211f, 0.67034698f, -0.80130363f, 0.70269209f, 0.73916829f, 0.09914187f, -0.11298978f, 
    0.18350179f, -0.25230965f, 0.53408152f, -0.16070807f, 0.04280773f, 0.11175932f, 0.35271776f, -0.06358425f, 
    -0.07103582f, 0.08893418f, 0.08510301f, 0.09717482f, -0.19235793f, -0.02260035f, -0.59907138f, -0.96323997f, 
    0.52275491f, -0.29804260f, -0.85286170f, 0.17236644f, -0.67620194f, 0.15628673f, -0.61689615f, -0.20625848f, 
    0.02208011f, -0.28074044f, -0.14508292f, -0.44954109f, -0.20169540f, 0.31508440f, 0.49543324f, -0.41321898f, 
    -0.12731852f, -0.10573175f, 0.32815817f, 0.27141818f, 0.29674393f, 0.23910223f, -0.20386919f, -0.72403318f, 
    -0.00991166f, -0.54554313f, -0.96041429f, -0.88011289f, 0.58318865f, 0.37989342f, 0.76189876f, 0.86700010f, 
    -0.11306061f, -0.39725098f, -0.03169330f, -0.77968150f, -0.45884380f, -0.17451687f, 0.57630467f, -0.21242639f, 
    -0.29055816f, -0.01573735f, 0.25532702f, -0.25647545f, -0.43900618f, 0.10212885f, -0.26502654f, 0.23810185f, 
    0.96555251f, 0.53590733f, 1.09352934f, 0.49071851f, 0.79383719f, 0.58986855f, 0.06228184f, 0.20423153f, 
    -0.34674409f, -0.02341013f, 0.02120291f, 0.00915450f, -0.46340233f, -0.23856175f, 0.12391624f, -0.21381821f, 
    -0.04722816f, 0.13176981f, -0.10620762f, -0.24630359f, 0.20330201f, 0.37184435f, 0.34877378f, -0.08037125f, 
    0.35394099f, -0.97741276f, 1.10675550f, 0.44586295f, -1.02602911f, 0.26017511f, -0.21756494f, -0.12135050f, 
    -0.11830955f, -0.48462793f, -0.63250589f, -0.08514936f, 0.17553589f, -0.56708479f, 0.02753081f, 0.05596618f, 
    -0.47557098f, 0.39886853f, -0.39510486f, 0.09235781f, 0.20563976f, -0.27196130f, 0.06881017f, 0.48237246f, 
    0.36472270f, -0.20734541f, -0.41797152f, -0.69570082f, -0.47805926f, -0.14769132f, 0.46086121f, 0.42411077f, 
    0.42784885f, 0.62165463f, 0.48719892f, -0.33840367f, 0.22445846f, 0.32170269f, -0.19757673f, -0.05736003f, 
    0.69926322f, 0.19165011f, 0.36784500f, -0.17566879f, 0.04141602f, 0.31578764f, -0.03956221f, -0.45564795f, 
    -0.68985158f, -0.15748914f, 0.18399830f, 1.22382748f, 0.44100931f, -0.23149022f, 0.99063766f, 1.16679382f, 
    0.52162206f, 0.50937498f, 0.59005219f, 0.77515483f, -0.20416082f, -0.41534960f, 0.05820988f, -0.13460280f, 
    0.06945536f, 0.11114064f, 0.18835169f, 0.01329508f, 0.36992258f, 0.13349299f, 0.20164657f, 0.28830403f, 
    -0.01352682f, -0.11874919f, 0.11346454f, 0.13170294f, -0.49675089f, -1.25660408f, -0.90139723f, -0.66416675f, 
    -0.56986034f, -0.46701968f, 1.06784832f, 0.65283889f, -0.11374430f, 0.62130976f, -0.18473369f, 0.25976825f, 
    -0.19300744f, 0.02303166f, -0.23208207f, -0.19992778f, 0.26353231f, -0.01615429f, -0.12739399f, 0.16196771f, 
    0.10048307f, -0.05626810f, 0.03498293f, 0.00026032f, 0.28149804f, 0.33250234f, 0.68314421f, 0.32178256f, 
    0.71073753f, 0.01142933f, 0.60864413f, 0.49560097f, 0.68716979f, 0.52070576f, 0.50734764f, -0.45477670f, 
    -0.05210156f, -0.34029701f, -0.08034457f, -0.15759476f, -0.15203995f, -0.01667366f, -0.26597407f, 0.00506604f, 
    -0.16642871f, -0.50944668f, -0.22620183f, -0.51720709f, 0.35886437f, 0.32689101f, -0.87009448f, -0.74320316f, 
    -0.86621821f, -0.23153014f, -0.29734933f, 0.17068198f, -0.83991599f, -0.11188131f, 0.29846415f, 0.03089230f, 
    0.39590704f, 0.06197734f, 0.09546603f, 0.06372993f, -0.07836858f, 0.12682186f, 0.68882155f, -0.09821543f, 
    -0.20855990f, 0.26039901f, -0.39601630f, 0.01714592f, 0.14128979f, 0.34665546f, 0.43840915f, -0.25217482f, 
    0.55550861f, -0.13112693f, -0.28236833f, 1.07995558f, -0.02221256f, -0.05318318f, 0.21630439f, 0.09326810f, 
    -0.12171882f, -0.47165966f, -0.39842802f, -0.02699850f, 0.00515325f, 0.28822491f, 0.41021854f, 0.27940300f, 
    0.58035046f, 0.34988844f, 0.58565700f, -0.43900940f, -0.20689492f, -0.54049134f, -0.24365720f, 0.21428625f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.35777956f, 0.41037771f, 0.14870276f, -0.02509564f, 0.13883850f, 0.06849086f, 0.17527275f, 0.04700761f, 
    0.06459869f, 0.40333214f, 0.33522654f, 0.04238556f, 0.28450409f, 0.35956910f, 0.36529130f, 0.07728257f, 
    0.14860027f, 0.23616980f, 0.22192089f, -0.05130716f, 0.16067427f, 0.30458939f, 0.26593584f, 0.05250639f, 
    0.35990912f, 0.23459084f, 0.18823896f, 0.21392538f, 0.28119755f, 0.28628659f, 0.25166151f, -0.08191831f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.29840156f, 0.27363411f, 0.24876545f, -0.34205967f, 0.00346927f, 0.10459635f, 0.04649414f, -0.05476629f, 
    -0.05475696f, -0.11402920f, -0.10484410f, 0.05090570f, -0.90932101f, -0.00986126f, 0.22358216f, -0.15751076f, 
    -0.03449556f, 0.02829169f, 0.06305612f, -0.07048801f, -0.00374695f, -0.04147815f, -0.00945057f, -0.09117894f, 
    0.00342715f, -0.38792700f, 0.07408416f, 0.15333898f, -0.01293117f, 0.12316246f, 0.06906052f, 0.05410085f, 
    0.13771887f, -0.07190634f, -0.00601647f, -0.04415471f, 0.23881567f, -0.13844854f, -0.23774478f, 0.53955615f, 
    -0.02543160f, 0.14912300f, 0.18119660f, 0.00712429f, -0.06339159f, -0.17626093f, -0.00070482f, 0.01711877f, 
    0.42385161f, -0.37658828f, 0.17019784f, -0.92848885f, 0.04150660f, -0.11646295f, 0.09134743f, -0.00589104f, 
    -0.09553232f, 0.01156270f, -0.05588458f, 0.17847702f, 0.30065078f, -0.08619906f, 0.01592790f, 0.23310019f, 
    -0.33736026f, 0.07078085f, -0.05779700f, 0.26646703f, 0.09424458f, 0.00817383f, 0.03073816f, -0.07601134f, 
    0.27069682f, 0.15208384f, 0.11665516f, -0.04566661f, 0.14662355f, 0.10684521f, -0.16137946f, -0.04466506f, 
    0.12140048f, 0.10253797f, 0.23489220f, -0.14528871f, -0.28548470f, -0.00243583f, -0.09551094f, 0.03024034f, 
    -0.06650639f, -0.04986206f, -0.12316884f, 0.05554704f, -0.11360358f, 0.08228861f, 0.11221070f, -0.01418152f, 
    0.20403782f, -0.02258301f, 0.18472917f, -0.42049813f, -0.30254805f, -0.13823147f, -0.03269319f, -0.06005513f, 
    -0.08501079f, 0.04409112f, -0.05559622f, 0.04585321f, -0.01336128f, 0.07536837f, -0.04136980f, 0.03823608f, 
    0.01007168f, -0.07416087f, -0.13139421f, 0.05403949f, -0.09554443f, -0.02570271f, -0.07033417f, 0.01567861f, 
    -0.00713070f, -0.19339828f, -0.29350397f, 0.18354192f, -0.09757609f, -0.06559216f, 0.16363867f, -0.03911878f, 
    -0.07251694f, 0.03185300f, 0.01273193f, -0.04287167f, 0.03673943f, 0.19955622f, -0.07465316f, -0.37819499f, 
    0.12051053f, 0.13541363f, -0.11004683f, 0.05563321f, -0.07461370f, 0.11413476f, -0.15619805f, 0.10342622f, 
    0.07112838f, 0.01790150f, 0.21827747f, -0.11531220f, -0.03156942f, 0.09927292f, 0.14886367f, -0.01737761f, 
    -0.18687284f, 0.14872308f, 0.12890092f, -0.12573464f, -0.20579970f, 0.00324456f, -0.26786506f, 0.09837595f, 
    -0.01008033f, -0.12713060f, -0.09073913f, 0.06386562f, 0.06945723f, 0.06516091f, -0.04977378f, 0.06195931f, 
    -0.18074736f, -0.11855237f, -0.14612478f, -0.07579241f, -0.00202133f, -0.00709773f, 0.03525767f, -0.13412797f, 
    -0.11975261f, -0.09157118f, -0.00823714f, -0.10609130f, 0.16655813f, 0.13354324f, -0.23325883f, 0.24754344f, 
    -0.20103163f, -0.16084167f, -0.03187542f, 0.05658148f, -0.01590900f, 0.11528539f, -0.33034003f, 0.05306274f, 
    -0.25554809f, 0.19636345f, 0.01906338f, -0.01303293f, -0.14851785f, 0.03499666f, -0.05031792f, -0.03176713f, 
    -0.08452970f, 0.10759393f, 0.18824646f, -0.15007286f, 0.01355208f, 0.09326373f, -0.05185791f, -0.22410443f, 
    -0.21276869f, -0.24467747f, 0.12155436f, -0.04509818f, 0.16215883f, -0.07936946f, -0.10537519f, 0.04327614f, 
    0.09254532f, 0.01269165f, -0.19604875f, 0.37498298f, -0.02156737f, -0.04936848f, -0.12364908f, -0.30273786f, 
    0.04816303f, -0.04517497f, -0.04285933f, 0.08610191f, 0.08686719f, 0.15508936f, -0.09625423f, 0.07090393f, 
    -0.14960387f, -0.14009079f, -0.03983136f, -0.02704102f, 0.01131200f, 0.07957333f, 0.09088513f, -0.09894349f, 
    -0.18707593f, 0.36309448f, -0.20737325f, 0.30139470f, -0.04037488f, 0.01531245f, 0.07155021f, -0.02001331f, 
    0.08263024f, -0.08027492f, -0.13241409f, 0.13712434f, 0.29549822f, -0.00057542f, 0.11794442f, -0.12721720f, 
    0.05764111f, 0.08527030f, -0.03850998f, -0.03912479f, -0.16257612f, -0.04830024f, -0.11351465f, -0.05945969f, 
    -0.47659349f, -0.13128197f, -0.00033699f, 0.00521695f, -0.10560082f, 0.15824339f, 0.01273525f, 0.00622521f, 
    -0.17813392f, 0.15918310f, 0.01738435f, -0.08404592f, 0.45943421f, 0.20052032f, 0.12124096f, -0.34964934f, 
    0.05231577f, 0.11999469f, 0.06424239f, -0.01426353f, -0.02819811f, -0.04103434f, 0.09993996f, -0.08815754f, 
    0.19560686f, -0.02015722f, 0.07057734f, -0.09718227f, -0.34029946f, -0.13710223f, 0.06848160f, -0.00758138f, 
    0.00189930f, 0.00835770f, -0.05489988f, -0.08404016f, -0.50418496f, 0.27687350f, -0.07872073f, 0.01638266f, 
    0.24664633f, 0.12614930f, -0.01068965f, -0.01470123f, -0.05978207f, -0.25065508f, 0.03343884f, -0.09697535f, 
    -0.23497286f, 0.22522442f, 0.07268906f, -0.08674114f, 0.06048224f, 0.13981989f, -0.03457051f, 0.09557042f, 
    0.15183876f, -0.05473071f, 0.03619540f, 0.01292217f, 0.16325594f, 0.17496394f, -0.11641084f, 0.26388371f, 
    -0.13439269f, 0.01538268f, -0.10246355f, 0.08960604f, -0.06127376f, 0.09598560f, 0.05797879f, -0.06949715f, 
    -0.36727282f, 0.07611679f, 0.01965635f, -0.53260463f, -0.05571004f, 0.08295964f, -0.00513291f, 0.14206630f, 
    -0.00078053f, 0.00952048f, -0.01147185f, 0.05528992f, 0.09340645f, 0.03619698f, -0.14537404f, 0.20536514f, 
    -0.07305429f, 0.01880272f, 0.06927554f, -0.10763504f, -0.14024682f, -0.04021859f, -0.06931242f, -0.04743802f, 
    -0.04394698f, -0.38310596f, -0.35348076f, -0.07913191f, 0.06127257f, 0.09436350f, 0.01042210f, 0.20909168f, 
    -0.06369936f, 0.09349520f, 0.04008416f, -0.12137998f, 0.02965230f, 0.02439647f, 0.13372746f, -0.19260858f, 
    -0.04594680f, -0.01467317f, 0.08796027f, 0.13826716f, 0.16809945f, 0.07389881f, -0.08757622f, 0.19571142f, 
    -0.09526319f, 0.04742216f, -0.18621792f, -0.25096077f, -0.01309674f, 0.06409951f, 0.00855249f, -0.12217405f, 
    0.08459421f, 0.20461962f, 0.05253627f, 0.06983510f, 0.35301065f, 0.07658064f, -0.24346073f, -0.17572649f, 
    -0.11034188f, -0.03895279f, 0.05554252f, -0.12649108f, -0.04676653f, 0.05298296f, 0.02297113f, 0.04026932f, 
    -0.29262900f, -0.09971216f, -0.00920141f, -0.02022913f, -0.17371202f, 0.07068416f, -0.07446095f, 0.19200486f, 
    -0.16378500f, 0.21855243f, 0.03579267f, 0.08412194f, -0.15452701f, 0.12826525f, -0.18523768f, 0.05500554f, 
    -0.00752315f, -0.06519689f, -0.09890272f, -0.03594583f, -0.07004628f, 0.05831882f, -0.06673431f, 0.02023735f, 
    0.29881111f, -0.28413159f, 0.31474555f, -0.72315168f, 0.17522486f, -0.03480903f, -0.00792054f, 0.05431508f, 
    -0.09633943f, -0.00418330f, 0.12190585f, -0.02882246f, -0.12125324f, -0.09452288f, 0.07722847f, 0.07806372f, 
    0.04134780f, -0.19901027f, -0.04918621f, -0.14470419f, -0.00065599f, 0.03271078f, -0.05823098f, 0.12443835f, 
    -0.33961648f, 0.15653703f, -0.39236534f, 0.12001269f, -0.01650359f, -0.01108723f, -0.05762801f, -0.12523879f, 
    -0.05886629f, -0.01077659f, -0.24397388f, 0.05463505f, 0.55928630f, -0.16060957f, 0.06981600f, -0.01689385f, 
    -0.04846032f, -0.19289780f, -0.03237320f, -0.00682027f, -0.03440349f, -0.01039133f, -0.31817281f, 0.04381457f, 
    -0.04934960f, -0.37155280f, -0.03521003f, -0.08974519f, -0.14043984f, -0.00920201f, -0.04009421f, -0.01030384f, 
    0.11241204f, 0.16959852f, -0.13256828f, 0.11546329f, 0.24312428f, -0.00078670f, -0.31927022f, -0.14352606f, 
    0.06316978f, 0.00253903f, 0.19822657f, 0.03064045f, -0.11464107f, -0.11474230f, -0.01256431f, 0.07005674f, 
    0.24855226f, 0.21599288f, 0.15735526f, 0.12210627f, -0.09811565f, 0.11407570f, -0.07524712f, -0.04510464f, 
    0.03078603f, -0.12861636f, 0.10420461f, -0.16560698f, -0.08872432f, -0.31171060f, -0.17478345f, -0.01115262f, 
    -0.01213196f, -0.09399153f, 0.02823344f, -0.00400387f, -0.00704575f, -0.01237722f, 0.09504869f, -0.13359283f, 
    0.39801776f, -0.41632780f, 0.05367801f, -0.35890055f, -0.01532605f, -0.07131917f, -0.13485771f, -0.05452797f, 
    -0.09951417f, -0.14178781f, -0.12194082f, 0.08327501f, 0.15851560f, -0.10037479f, -0.46746153f, 0.03120498f, 
    0.00307908f, 0.06632622f, 0.07501710f, 0.09375326f, -0.04595850f, -0.31342739f, -0.10743002f, -0.25049445f, 
    -0.26991057f, -0.27651632f, -0.03086609f, -0.37418810f, -0.12518670f, 0.01370156f, 0.07205696f, 0.10519604f, 
    0.10837093f, -0.08669441f, 0.06057804f, -0.02288021f, 0.31912211f, 0.01855346f, 0.39393282f, 0.16547920f, 
    -0.14963481f, -0.10061284f, 0.01699235f, -0.00711248f, 0.06088363f, -0.14287303f, 0.14268129f, -0.17799746f, 
    0.24374454f, -0.37764674f, -0.04668605f, -0.03912191f, -0.04260423f, 0.03169603f, 0.13687921f, -0.00460723f, 
    0.00485899f, -0.09750956f, -0.21223931f, 0.09136385f, 0.09809837f, 0.09624282f, 0.14028500f, 0.14262940f, 
    -0.20552889f, 0.09867978f, -0.02321640f, 0.01965307f, 0.00150147f, 0.13169259f, -0.01353845f, 0.06917620f, 
    -0.21189705f, -0.18163368f, -0.47196478f, 0.01262947f, -0.14590269f, 0.12404736f, 0.06002165f, 0.10186666f, 
    -0.07741980f, -0.08893175f, -0.16534719f, -0.24150981f, -0.07648064f, 0.13029727f, -0.10794687f, -0.01446913f, 
    -0.08265959f, 0.12062493f, -0.02365813f, -0.04375041f, 0.09504251f, -0.15184212f, 0.00885626f, 0.19429506f, 
    0.11897445f, -0.42380860f, -0.21184842f, 0.21798497f, -0.05222158f, 0.02846583f, -0.02448136f, 0.12575027f, 
    0.00559382f, -0.06470860f, -0.06559635f, -0.05182387f, 0.24590537f, -0.12346996f, 0.00068686f, -0.18739037f, 
    0.04380457f, 0.11059028f, -0.00507738f, 0.12660755f, 0.14128065f, -0.02567865f, 0.15028125f, 0.04877427f, 
    -0.13771182f, 0.09856958f, 0.16097526f, 0.45699662f, -0.10349173f, -0.15780288f, 0.01753082f, 0.04214378f, 
    0.25772971f, -0.00735909f, -0.19448552f, 0.03085537f, -0.40062523f, -0.14969940f, -0.13637938f, -0.28947264f, 
    -0.01184259f, 0.01066069f, 0.03851576f, 0.05645210f, 0.20091447f, 0.14760828f, -0.15029410f, 0.01950852f, 
    0.16267890f, -0.01975334f, 0.15226351f, 0.29550934f, -0.07754007f, 0.06481712f, 0.10317998f, 0.05523005f, 
    -0.07110997f, -0.14302933f, 0.07275784f, 0.06515968f, -0.18895063f, 0.10313993f, -0.10408320f, -0.35873443f, 
    -0.20332128f, 0.12062784f, 0.10050641f, -0.08112790f, 0.12184874f, 0.34648874f, -0.11158276f, -0.08793929f, 
    0.16770639f, -0.08975426f, 0.00579413f, 0.08092055f, 0.14015211f, 0.07832302f, -0.16091236f, 0.00822107f, 
    -0.10421043f, -0.00963178f, 0.05642283f, -0.00684528f, 0.34205395f, -0.06210262f, 0.00479961f, 0.31000078f, 
    -0.00302098f, -0.06317934f, -0.24610250f, 0.04575516f, -0.02024202f, 0.14099725f, -0.11863448f, 0.08072887f, 
    0.21219321f, -0.17962477f, -0.11679247f, -0.02446318f, 0.03414879f, -0.06132306f, 0.02774112f, -0.02215715f, 
    0.07097733f, -0.10135162f, 0.02478365f, -0.10227830f, 0.24412785f, 0.15272595f, 0.04977299f, 0.16628645f, 
    0.03438316f, -0.03044294f, -0.03138658f, -0.00382829f, -0.01703779f, 0.08438553f, 0.01566568f, -0.05361557f, 
    0.03366036f, 0.26473984f, 0.11411219f, -0.06704807f, 0.15033039f, -0.08529511f, 0.13249259f, 0.03393915f, 
    0.07663462f, 0.00391268f, 0.01092426f, 0.17566979f, 0.18081009f, -0.00125780f, -0.16694459f, -0.18341991f, 
    0.31229696f, 0.17721845f, -0.10799174f, 0.11759274f, -0.02544197f, -0.00077791f, -0.09156947f, 0.00222820f, 
    -0.18363304f, -0.01343337f, -0.15340427f, -0.35174221f, -0.06090608f, -0.04124373f, -0.06029148f, -0.03939519f, 
    -0.14196426f, -0.08071002f, -0.00727423f, -0.10972761f, 0.20343670f, 0.19677494f, -0.27269834f, 0.05861382f, 
    -0.08208843f, -0.08550608f, 0.10332917f, -0.03354738f, 0.01570864f, 0.02275647f, 0.00365694f, -0.03041744f, 
    -0.10599580f, -0.22369123f, -0.21064831f, -0.05322247f, 0.02212789f, -0.00501675f, 0.08331727f, -0.12420470f, 
    0.00710050f, -0.04560011f, -0.09310590f, -0.19778191f, -0.70648730f, 0.05272244f, -0.22007348f, 0.01567307f, 
    -0.07744738f, 0.19078861f, -0.17877690f, 0.07696746f, 0.14643411f, 0.02104133f, 0.00812175f, -0.14764810f, 
    -0.39429247f, -0.00540762f, 0.09233066f, -0.17098203f, -0.11176729f, -0.06973811f, 0.20578280f, -0.02378426f, 
    -0.10682087f, -0.09030716f, -0.09864238f, 0.07394995f, 0.29264545f, 0.15501897f, -0.12971097f, 0.11668218f, 
    0.02553387f, 0.14459072f, -0.06312487f, -0.13272597f, -0.03948001f, -0.14020638f, 0.06015056f, -0.21607752f, 
    0.53993821f, -0.03817615f, -0.11684437f, -0.08635747f, -0.10298479f, 0.04081078f, -0.24407370f, 0.08234057f, 
    0.17662875f, -0.18645799f, -0.09308449f, -0.12809293f, 0.50758904f, 0.07749110f, 0.02832532f, -0.11579997f, 
    0.11404143f, 0.01290880f, 0.12368950f, -0.01437407f, -0.05288301f, 0.07630859f, 0.12571803f, -0.04022492f, 
    -0.12873550f, -0.01451738f, -0.20051368f, -0.17241099f, 0.05038575f, -0.01716407f, 0.17058158f, -0.11426505f, 
    -0.05477154f, 0.12283254f, 0.02914678f, -0.04426197f, -0.44062769f, 0.03986397f, -0.03273644f, -0.29740921f, 
    0.02971699f, 0.11399028f, 0.00886759f, -0.09908170f, 0.00483481f, 0.06857613f, -0.19542164f, -0.02337568f, 
    0.04734080f, -0.03070284f, 0.01900944f, -0.05579068f, 0.14425512f, 0.02897819f, -0.02080999f, -0.03015843f, 
    0.00464974f, 0.07422711f, -0.02929047f, 0.03317286f, -0.08595555f, 0.28122839f, 0.17024401f, 0.01693157f, 
    -0.13615620f, -0.20586206f, -0.10664980f, 0.06377595f, 0.11096796f, 0.01080444f, -0.07710674f, -0.06757094f, 
    -0.23875909f, -0.17931667f, 0.04188138f, -0.01441288f, 0.04927449f, 0.14371392f, 0.09016866f, 0.00043158f, 
    0.02007491f, -0.00390086f, -0.00117853f, 0.06955635f, 0.44496936f, -0.28571644f, -0.16386157f, -0.16944413f, 
    -0.03010977f, 0.07086447f, -0.15017319f, -0.11515552f, -0.08230650f, 0.14992315f, 0.03615528f, -0.11111324f, 
    -0.72878283f, 0.05455291f, 0.16168147f, -0.04040414f, 0.07532869f, -0.07985508f, 0.00487753f, 0.05781789f, 
    -0.07884357f, -0.01298203f, 0.04531047f, -0.00017935f, 0.05288414f, 0.12281638f, 0.01583358f, -0.01061175f, 
    -0.00765802f, 0.18107921f, 0.03025204f, 0.00799196f, -0.09539289f, 0.15361577f, -0.10733408f, -0.02043126f, 
    -0.39351574f, -0.17920342f, -0.00707247f, -0.29544538f, 0.02097985f, -0.14533825f, 0.01035721f, 0.06796817f, 
    -0.12973739f, -0.07219100f, -0.13568069f, -0.11134987f, 0.01665587f, 0.01121355f, 0.10945591f, -0.00236484f, 
    0.08610979f, 0.18725748f, 0.15247849f, 0.01268216f, -0.00144888f, -0.12432959f, -0.00112184f, -0.15214446f, 
    -0.39077425f, 0.09706920f, -0.29529199f, -0.10851215f, -0.01463411f, -0.03192568f, 0.05094007f, -0.08195952f, 
    0.11195078f, 0.26455432f, 0.01258044f, 0.07188534f, 0.36245778f, 0.01793574f, -0.44510877f, 0.04730045f, 
    0.24258804f, 0.16061482f, -0.14187983f, -0.18177424f, 0.03768541f, 0.02848514f, -0.25916284f, -0.09571351f, 
    0.64879221f, -0.01269962f, -0.03435567f, 0.03591800f, -0.10068437f, -0.03691332f, -0.01950567f, -0.04492886f, 
    0.13377982f, 0.01062115f, 0.05537503f, 0.00727614f, -0.34584552f, 0.12737468f, 0.05774763f, 0.26556113f, 
    -0.09370112f, 0.05433807f, -0.12838739f, 0.05250021f, 0.01693810f, -0.03406511f, -0.14217028f, -0.01052494f, 
    -0.37721118f, -0.25645873f, -0.14984187f, -0.59745973f, -0.12585002f, 0.00430633f, -0.02259641f, -0.10776508f, 
    0.06219733f, -0.12451847f, 0.12983903f, -0.00859744f, 0.14251478f, 0.24104002f, -0.00703709f, 0.48219791f, 
    -0.01041712f, -0.04326466f, 0.02726606f, 0.29425812f, -0.01278747f, -0.05756814f, 0.02622151f, -0.04888455f, 
    -0.08309376f, 0.10400139f, 0.10109307f, -0.11827300f, 0.13358268f, 0.04805854f, -0.04671346f, -0.02535786f, 
    0.05815276f, 0.05093701f, 0.07988476f, 0.09533508f, 0.29478776f, -0.05429769f, -0.47716382f, -0.17061198f, 
    -0.04069736f, -0.00446909f, 0.00984195f, 0.01305889f, -0.05427617f, -0.09320360f, 0.17922232f, -0.01101961f, 
    0.10378675f, 0.19755049f, 0.08131176f, 0.00490907f, 0.00243930f, 0.00495797f, 0.11401261f, 0.01741185f, 
    -0.01982010f, -0.08785298f, -0.03104991f, 0.01231111f, -0.02255207f, 0.02757497f, 0.06343826f, -0.12911762f, 
    0.23965956f, -0.12817512f, 0.04440247f, 0.02234486f, 0.03395726f, -0.14993103f, 0.01720830f, -0.02666982f, 
    0.62425870f, 0.18553689f, 0.12717308f, 0.31961203f, -0.24989446f, -0.22595952f, -0.02287490f, 0.12473733f, 
    0.07256877f, -0.05417563f, -0.01439597f, 0.07605775f, 0.04139048f, 0.03267050f, -0.09300213f, 0.01578233f, 
    -0.01898607f, 0.05073521f, -0.03793651f, 0.06277201f, -0.04112639f, 0.11870731f, 0.03301118f, -0.12367383f, 
    -0.12382939f, -0.14928667f, 0.06574528f, 0.00498801f, -0.15526344f, -0.19870518f, -0.23594779f, -0.02145084f, 
    -0.12323523f, -0.02738641f, 0.07152628f, -0.14104325f, -0.13604367f, -0.28562707f, -0.07256860f, 0.11908587f, 
    0.01546440f, 0.07939716f, -0.00514074f, -0.10507942f, -0.16379191f, -0.21910602f, -0.29463860f, 0.06896634f, 
    0.24278437f, -0.01292177f, 0.15371846f, 0.11502588f, -0.05998560f, 0.06360369f, -0.06786422f, 0.10958922f, 
    -0.08782602f, 0.08263433f, -0.16057153f, -0.05621777f, 0.32170671f, -0.17647715f, 0.05329833f, -0.00071517f, 
    0.16575672f, -0.05176947f, 0.08634244f, 0.07360903f, 0.01968652f, -0.02214820f, -0.12651695f, -0.06995398f, 
    0.10043238f, 0.01932224f, -0.00934759f, 0.19691654f, 0.01984961f, -0.05018437f, -0.00906830f, -0.16544446f, 
    -0.12265315f, -0.09083652f, -0.06147125f, -0.19193037f, 0.34328130f, -0.26075244f, -0.01385904f, 0.26074964f, 
    0.02539375f, 0.11549397f, 0.12372650f, 0.05817693f, 0.06015285f, 0.16820478f, 0.13343988f, -0.00076216f, 
    -0.21366425f, 0.19815619f, -0.13236275f, 0.06517340f, -0.11485834f, 0.04525778f, 0.00338968f, 0.12068386f, 
    -0.04042593f, 0.09298930f, -0.11973190f, 0.07768624f, 0.31513986f, -0.11651526f, 0.09760655f, 0.13343351f, 
    0.06554592f, 0.00467150f, 0.17929308f, -0.00743156f, 0.04723230f, -0.02210994f, -0.10315761f, -0.21564533f, 
    -0.03705002f, 0.23943003f, -0.05756706f, -0.10948943f, 0.09375977f, -0.05173682f, 0.01508932f, 0.07396030f, 
    -0.03986118f, 0.13587557f, 0.12328508f, 0.01178026f, 0.19802655f, -0.39890972f, -0.27708578f, -0.05845533f, 
    -0.19536838f, 0.18939307f, -0.03004230f, 0.08138692f, -0.11332896f, 0.05423178f, 0.09014555f, -0.01066089f, 
    0.48758444f, -0.01943743f, -0.01188719f, 0.03527620f, -0.20155561f, -0.02467074f, 0.07281926f, 0.32568789f, 
    0.11365406f, -0.04775044f, 0.07218434f, -0.15314882f, -0.06007902f, 0.05658570f, -0.21384171f, 0.03652773f, 
    -0.04215511f, 0.07974341f, -0.07891868f, 0.11218087f, 0.09796556f, -0.00465024f, 0.03703498f, -0.03646560f, 
    -0.01715547f, -0.34325147f, -0.31566137f, -0.11156762f, -0.08019565f, -0.05698026f, 0.10871597f, -0.13694935f, 
    0.13279913f, 0.05768622f, 0.00171366f, 0.02309157f, 0.11584297f, -0.19956920f, -0.10841490f, -0.10716120f, 
    0.01002950f, 0.01797509f, 0.01172007f, -0.05243233f, -0.15990065f, 0.01152154f, 0.00777732f, 0.04039269f, 
    0.09254819f, 0.20655416f, 0.19677614f, 0.14849724f, 0.09681621f, 0.16492379f, -0.02940973f, 0.01229993f, 
    -0.02766784f, 0.10855475f, 0.11314709f, -0.04625111f, -0.11922220f, 0.23617248f, 0.04043798f, 0.12712947f, 
    0.06675675f, 0.12614277f, 0.03210609f, 0.03105889f, -0.05557413f, 0.13375063f, -0.08149042f, -0.01559406f, 
    -0.11309167f, -0.05780958f, -0.02417123f, -0.00430231f, -0.20399600f, 0.03190013f, -0.08929437f, 0.05711320f, 
    -0.00557800f, 0.13334040f, -0.11018028f, 0.06495342f, -0.40187889f, -0.48583341f, -0.22293298f, 0.36361912f, 
    -0.06353123f, -0.02203698f, -0.09755770f, -0.04020045f, -0.01725951f, -0.05423112f, -0.02873898f, 0.06433622f, 
    0.14058366f, -0.11389434f, 0.12719868f, 0.12476533f, -0.08623824f, 0.01881966f, 0.07894737f, 0.18344833f, 
    -0.08888023f, -0.01765857f, 0.11386923f, 0.09822191f, -0.35077083f, -0.57570398f, -0.17535250f, 0.21590161f, 
    -0.20908436f, -0.09236511f, 0.04649780f, -0.04696115f, -0.07834812f, -0.19937432f, 0.04799787f, -0.09549598f, 
    0.22968952f, 0.11806142f, 0.06978039f, 0.16532072f, 0.03467215f, 0.02772751f, -0.08763501f, -0.03941697f, 
    -0.01959964f, 0.07599634f, -0.11859740f, 0.05584965f, -0.80390579f, 0.22287528f, 0.24773899f, 0.02988684f, 
    0.09511843f, 0.01159688f, 0.04568092f, 0.00901787f, -0.09677611f, -0.05231331f, -0.12158016f, -0.15927799f, 
    -0.08516649f, 0.13189036f, -0.03794527f, 0.12674814f, -0.02005937f, 0.04959602f, 0.05125367f, 0.05244925f, 
    -0.13826399f, 0.03397412f, -0.05606606f, -0.01026706f, 0.13703518f, 0.18925269f, -0.13524187f, 0.04481741f, 
    -0.09363207f, 0.10472071f, -0.15657629f, -0.03580623f, -0.02234805f, 0.14455846f, -0.04151170f, -0.01183578f, 
    0.30007049f, -0.10397714f, 0.08286938f, -0.19388427f, -0.00559724f, 0.08017793f, -0.09532744f, 0.13690725f, 
    -0.05345135f, -0.04687778f, 0.11044151f, -0.11396484f, -0.38708612f, -0.12299945f, 0.04959440f, -0.24209574f, 
    -0.04133140f, 0.11593947f, -0.08221347f, -0.06610080f, -0.18278304f, -0.02199931f, 0.08694869f, -0.04870613f, 
    -0.81884974f, -0.83428371f, -0.26932672f, 0.01674920f, -0.12038974f, -0.00657444f, -0.10740877f, -0.08125960f, 
    0.03421104f, -0.18098754f, 0.02782111f, -0.00889544f, 0.39288634f, 0.29284176f, 0.27715439f, -0.09302366f, 
    0.22311138f, 0.04687557f, -0.13612212f, 0.08408482f, 0.04059306f, -0.03440692f, -0.01999165f, -0.04581011f, 
    -0.08036588f, 0.01323577f, 0.09241291f, -0.04946617f, -0.02832031f, -0.13581963f, -0.03093381f, -0.19556974f, 
    0.02331636f, -0.11096871f, 0.06220226f, 0.16574863f, -0.34067068f, -0.33329377f, -0.08560966f, -0.30915672f, 
    -0.10582734f, -0.02007028f, 0.00448444f, -0.07006442f, -0.05707351f, -0.20357622f, 0.15646121f, 0.00044928f, 
    0.12030827f, -0.04475012f, 0.07677177f, -0.11583376f, -0.14796250f, -0.08423436f, -0.03628483f, -0.00182822f, 
    -0.20474687f, 0.01330259f, 0.01420262f, 0.07293440f, -0.63306063f, -0.31989709f, -0.12652923f, -0.08098139f, 
    -0.15054387f, -0.15252510f, 0.10545696f, 0.18573835f, 0.01577324f, 0.04863438f, 0.11384948f, 0.03391663f, 
    0.10702799f, -0.00149022f, -0.20328981f, -0.08261802f, -0.10634313f, -0.14051719f, -0.14445849f, -0.01640488f, 
    0.11530741f, -0.11690030f, 0.04608500f, -0.04014439f, -0.00684926f, -0.00826789f, -0.05539417f, 0.16208221f, 
    -0.22017086f, -0.02610784f, 0.03115325f, -0.16184814f, 0.20863079f, -0.02836405f, 0.11826248f, 0.10653612f, 
    -0.22931132f, 0.11569721f, 0.28457338f, -0.02927818f, 0.01825464f, -0.01144121f, -0.02536974f, 0.02439771f, 
    0.04324123f, -0.11647692f, -0.07432052f, 0.08531853f, 0.49973837f, 0.34574917f, -0.07630622f, -0.37202504f, 
    -0.07490510f, -0.01733433f, -0.02305995f, 0.04044696f, -0.05686662f, 0.06370311f, 0.07561841f, -0.01463146f, 
    -0.17792778f, 0.02319869f, -0.11666702f, 0.30722418f, 0.08524004f, -0.01768424f, -0.18249196f, 0.08820315f, 
    0.13336343f, -0.12794839f, 0.00779841f, -0.19043338f, -0.09159583f, 0.20078816f, 0.04928923f, -0.53584898f, 
    0.01261394f, 0.13668004f, 0.16637743f, 0.07581346f, 0.15490410f, 0.04178284f, -0.10556941f, 0.20586035f, 
    -0.15724362f, -0.41562930f, -0.06704400f, 0.24710374f, -0.02127288f, 0.15065125f, 0.03404868f, 0.01508642f, 
    0.02167127f, -0.09099860f, -0.03378819f, -0.12511246f, -0.16066551f, -0.22015615f, -0.09375449f, 0.13491149f, 
    -0.04137553f, 0.07146460f, 0.03940082f, -0.06338148f, 0.02095717f, -0.05054700f, 0.02838515f, -0.17537248f, 
    -0.56611961f, -0.01334043f, -0.12779900f, -0.52236956f, 0.07036426f, -0.05943498f, 0.13174219f, 0.10935224f, 
    0.01096611f, -0.07631160f, 0.06303489f, 0.22577347f, -0.21289870f, -0.00481324f, -0.06238955f, -0.00247696f, 
    -0.12725295f, 0.10226622f, 0.03672817f, -0.05890073f, -0.05262984f, -0.09021908f, -0.00717863f, 0.03638151f, 
    -0.13136336f, -0.04662621f, -0.35011196f, -0.04089745f, -0.19587663f, -0.23271906f, 0.10146653f, -0.17747931f, 
    -0.04750045f, 0.08810633f, 0.09907220f, -0.08210779f, -0.22494695f, -0.44498727f, 0.18317664f, 0.14142631f, 
    -0.19272782f, 0.00211327f, -0.00039070f, -0.08241668f, 0.03320573f, 0.01006042f, 0.08023366f, -0.01709568f, 
    0.08747221f, -0.13942027f, -0.02315468f, 0.18544091f, -0.11749357f, -0.06345036f, 0.14794898f, -0.06084244f, 
    -0.02593107f, 0.06114069f, 0.02263396f, 0.08471248f, -0.44596753f, -0.09036858f, -0.08950114f, 0.18926978f, 
    0.05551840f, -0.14244342f, -0.01803259f, 0.00747966f, -0.05421251f, 0.03384971f, 0.01163771f, 0.03053812f, 
    -0.02582683f, -0.05759078f, -0.21755864f, 0.13641426f, 0.00340822f, -0.05147008f, -0.02415959f, 0.03076485f, 
    -0.14191592f, 0.00507812f, -0.04399661f, -0.03384333f, -0.20243636f, -0.01317424f, 0.26684880f, 0.10870165f, 
    0.13874854f, -0.00612272f, 0.02495059f, 0.04336276f, 0.12073059f, 0.13365589f, 0.05038415f, 0.13494577f, 
    0.53438640f, -0.00541005f, -0.05399227f, -0.13252971f, -0.10352988f, 0.07424069f, 0.13659780f, 0.12216543f, 
    0.01282144f, 0.13089439f, -0.02833776f, 0.14400724f, -0.37422705f, 0.06001775f, 0.03774917f, 0.07344440f, 
    -0.12083500f, 0.12235943f, -0.07423493f, 0.10094708f, 0.06918883f, -0.16072620f, -0.09392439f, 0.05736743f, 
    -0.19886403f, 0.45768785f, -0.04467087f, -0.15180472f, 0.03758426f, 0.15676190f, 0.05476875f, -0.06466535f, 
    -0.07611321f, -0.08419852f, 0.13262102f, -0.06500372f, -0.25136530f, -0.05182736f, 0.07628456f, -0.18273836f, 
    0.07718422f, -0.03085556f, -0.15919885f, 0.09329290f, 0.09519469f, -0.05420625f, 0.05848512f, -0.14968494f, 
    -0.12102384f, -0.33250403f, 0.27391079f, 0.09047319f, -0.09834538f, 0.13983564f, 0.01661850f, -0.08946111f, 
    -0.03579522f, -0.02711817f, 0.13517196f, -0.05440197f, -0.43361235f, 0.11355612f, 0.22561713f, 0.29726031f, 
    -0.19942397f, 0.12356577f, 0.04185411f, -0.06105370f, -0.10347474f, 0.09968600f, -0.06150698f, -0.01406550f, 
    -0.72657442f, 0.27069968f, -0.14894897f, -0.19163302f, 0.08809499f, 0.18426469f, -0.07049552f, -0.11053932f, 
    -0.07710209f, -0.09297079f, -0.11205292f, 0.06869757f, -0.34222287f, -0.04997730f, -0.21956186f, 0.12805934f, 
    -0.02954678f, -0.05242833f, 0.03932045f, -0.12120125f, 0.12642318f, -0.11327287f, -0.13620551f, -0.11233830f, 
    0.21255490f, -0.22569911f, 0.10325096f, -0.21508919f, 0.09873374f, 0.19369616f, -0.15260841f, 0.05521537f, 
    0.00592223f, 0.04567264f, -0.01623162f, 0.18437186f, 0.04550582f, -0.18136621f, 0.07123837f, 0.18527307f, 
    -0.08273681f, -0.03195463f, -0.00240581f, -0.08178032f, -0.01920872f, 0.00550286f, 0.07112929f, 0.16294651f, 
    0.06131850f, 0.05565953f, -0.00383572f, 0.04161319f, 0.04414320f, -0.01792284f, -0.09720539f, 0.05021256f, 
    0.13582031f, 0.02506449f, 0.01001346f, -0.02739167f, 0.27008697f, 0.07023074f, 0.15401714f, -0.08426080f, 
    0.09275985f, -0.23540573f, -0.02197721f, -0.19648695f, -0.10784691f, -0.16749199f, 0.14723051f, 0.05980508f, 
    -0.13469844f, 0.08789103f, -0.10264476f, 0.05890388f, -0.09307049f, -0.17423749f, 0.10092822f, 0.16197976f, 
    -0.08300120f, -0.19974180f, 0.09281784f, -0.02610668f, 0.43694824f, -0.08499921f, -0.26748049f, 0.03709014f, 
    -0.18979648f, -0.10585164f, 0.17824681f, 0.00646769f, 0.08498051f, -0.02947690f, -0.08490364f, -0.08894725f, 
    -0.70030522f, 0.11159999f, 0.23074505f, 0.28366679f, 0.13590820f, 0.01215115f, 0.05881817f, 0.19090189f, 
    -0.05293531f, -0.02230504f, 0.03549204f, 0.00858140f, -0.03381176f, -0.04696981f, 0.07878531f, 0.12375754f, 
    0.15793438f, -0.01783428f, 0.07575948f, 0.08812476f, -0.08872257f, 0.06369249f, 0.02421281f, 0.00597584f, 
    0.06676062f, -0.05348281f, 0.01332985f, 0.24332637f, 0.13853441f, 0.12366267f, 0.01124533f, 0.11128223f, 
    0.06093445f, 0.08302481f, 0.00344875f, -0.15334260f, 0.15079026f, 0.21602494f, -0.35227057f, -0.16041648f, 
    -0.00301069f, -0.12200544f, 0.18182559f, -0.02397101f, -0.07196510f, 0.11585685f, 0.08795985f, -0.00675425f, 
    0.04531270f, 0.03860743f, 0.06133015f, 0.22345534f, 0.02902966f, -0.13707860f, -0.09680273f, 0.05346088f, 
    -0.03129194f, 0.17234235f, 0.28595811f, -0.03523997f, -0.64038336f, -0.72675806f, 0.34295195f, 0.33720437f, 
    0.14904556f, 0.00185078f, -0.05764111f, -0.02356078f, 0.10074228f, -0.03450082f, 0.00148181f, -0.05913772f, 
    0.07439455f, -0.11601228f, -0.10440700f, 0.03579992f, -0.02777561f, -0.11967923f, 0.13985762f, -0.19283681f, 
    -0.00964720f, -0.01603705f, 0.23764490f, 0.40641582f, -0.11087617f, -0.09574009f, 0.04614152f, 0.12151541f, 
    -0.00450158f, -0.23599459f, -0.29617345f, 0.04801271f, -0.01050359f, 0.06726626f, -0.05743840f, -0.05282487f, 
    -0.00613943f, 0.06888150f, 0.01651338f, 0.02672529f, -0.02023277f, -0.15670675f, -0.23719364f, 0.00105910f, 
    0.09053514f, 0.04326382f, -0.00004791f, -0.05762328f, 0.05261261f, -0.09016664f, -0.09196340f, -0.04974589f, 
    0.10425860f, -0.00577027f, -0.06769754f, 0.01747085f, 0.07059480f, -0.19936764f, -0.09154122f, 0.26535639f, 
    -0.65608269f, -0.09673737f, 0.18295340f, -0.10907301f, 0.00277982f, 0.11074775f, 0.13584825f, 0.04290422f, 
    -0.07749803f, 0.10139574f, 0.00296536f, 0.07424326f, 0.10139376f, 0.01885433f, -0.08855244f, -0.16952839f, 
    -0.01982625f, -0.27722803f, -0.03083921f, -0.09888327f, -0.15769598f, -0.08186898f, -0.04679165f, -0.15600650f, 
    -0.26503736f, 0.38607815f, 0.07798155f, 0.20920087f, -0.01597927f, 0.24532220f, -0.05117130f, -0.10475605f, 
    0.02876856f, -0.25684583f, 0.08409094f, 0.06965739f, -0.04960178f, 0.24115536f, -0.01132255f, 0.18050303f, 
    -0.08647811f, -0.20079745f, -0.01738280f, 0.08014310f, 0.00471483f, -0.10472339f, 0.03154333f, -0.19724354f, 
    0.17883094f, 0.07036901f, 0.15809655f, -0.21406522f, -0.12342876f, -0.03231582f, -0.13081306f, 0.16274175f, 
    -0.06148769f, -0.03608663f, -0.13041621f, -0.14401190f, -0.15451659f, -0.11509193f, -0.13597618f, -0.04712325f, 
    0.07001325f, -0.04871023f, 0.11040197f, -0.09336957f, -0.06076348f, 0.15743808f, 0.29654446f, -0.07996254f, 
    0.03070888f, -0.04785036f, -0.18561199f, -0.10807285f, -0.11436222f, 0.03788051f, 0.06759658f, -0.00135313f, 
    0.20691949f, -0.11909990f, -0.00556005f, -0.01198360f, 0.19989111f, 0.04245726f, 0.12537515f, -0.23951007f, 
    -0.05165953f, 0.06039353f, -0.04155171f, -0.10371255f, -0.02308725f, -0.01220460f, -0.03482844f, 0.16061045f, 
    -0.09325630f, 0.05121087f, -0.01568773f, 0.24012606f, 0.23431188f, -0.08388094f, 0.02142176f, -0.08201344f, 
    0.02867291f, -0.16581622f, -0.05712927f, 0.05927329f, -0.04354749f, -0.09969472f, 0.01643867f, 0.00737005f, 
    -0.01246279f, -0.07210555f, 0.05410318f, 0.03336278f, -0.05673172f, -0.09494672f, 0.10926423f, 0.16303100f, 
    -0.11749869f, 0.04443729f, 0.26638037f, 0.16544181f, 0.08602387f, 0.05611107f, -0.15899500f, -0.05289792f, 
    0.19144104f, -0.04314790f, -0.13285336f, -0.05229504f, 0.06936389f, 0.11182076f, 0.04943598f, 0.20913233f, 
    0.01564432f, 0.28032431f, 0.01494588f, 0.08469637f, -0.11176895f, 0.09845187f, 0.07178808f, 0.12335519f, 
    0.04761678f, 0.13635986f, 0.21998183f, 0.19091879f, -0.16095908f, -0.18183085f, 0.04550632f, 0.30846122f, 
    0.01284011f, -0.11411092f, 0.08486373f, -0.09703746f, 0.31224445f, -0.11266375f, -0.00932748f, 0.04421071f, 
    -0.09761164f, -0.13396026f, 0.05549693f, -0.00748333f, -0.09895966f, 0.00399985f, 0.18393739f, 0.09975035f, 
    -0.83996814f, 0.14264527f, 0.04205064f, -0.20176293f, -0.02285967f, -0.06469526f, -0.15854789f, 0.15507312f, 
    0.06430913f, -0.10073819f, 0.16765109f, -0.25385514f, -0.69419700f, -0.10384382f, -0.22614177f, 0.14727823f, 
    0.12649518f, -0.08826812f, 0.02283704f, -0.06552274f, 0.13650118f, -0.05480359f, -0.07132562f, -0.00737819f, 
    -0.13079782f, -0.14392793f, -0.23260283f, 0.06959257f, 0.10290395f, -0.07768697f, 0.25923723f, 0.00633141f, 
    0.09572574f, 0.12451219f, -0.10893124f, -0.00389049f, 0.39058703f, 0.10456367f, -0.24445872f, -0.08379337f, 
    0.18110265f, -0.05013685f, -0.05405426f, -0.33727902f, -0.06592804f, 0.05464061f, -0.35236296f, 0.05066314f, 
    -0.08636820f, -0.06685486f, 0.15409105f, 0.20230664f, -0.11602961f, 0.01090980f, -0.04615724f, 0.10877939f, 
    0.06998152f, 0.00207407f, 0.12213356f, -0.03000979f, -0.13781834f, -0.18284200f, 0.05483698f, 0.16339776f, 
    -0.01787477f, -0.16994584f, 0.21512510f, 0.13741638f, 0.06129998f, 0.06622411f, -0.21272528f, -0.06073381f, 
    -0.35297903f, 0.21401820f, -0.14761738f, -0.24455766f, 0.11027192f, 0.18859304f, -0.12969016f, -0.32691127f, 
    -0.07317782f, 0.12666260f, -0.23979993f, 0.23380764f, -0.03313787f, 0.21213834f, 0.30138782f, -0.33703825f, 
    0.12319258f, 0.12422427f, -0.01974717f, -0.09253607f, 0.09374833f, -0.08474739f, 0.14071606f, 0.12743029f, 
    -0.25437132f, -0.20408970f, -0.61542416f, -0.10210934f, 0.15127718f, -0.02392203f, -0.00904635f, 0.03962307f, 
    0.03804930f, 0.05888092f, -0.08017704f, 0.12631235f, 0.05373256f, 0.10455483f, 0.13570510f, -0.08561552f, 
    0.02090223f, 0.17296766f, -0.09404407f, -0.18958327f, -0.02097395f, -0.07038783f, 0.00824093f, -0.06345665f, 
    -0.33281329f, -0.14643817f, -0.03503694f, 0.07435033f, -0.00107274f, 0.17843185f, 0.11096054f, -0.25860703f, 
    0.08030722f, -0.09534426f, -0.14109637f, 0.12136261f, 0.18886559f, 0.04249069f, 0.30279505f, -0.29794148f, 
    0.06414057f, -0.09420132f, -0.00468320f, -0.20812824f, -0.03677228f, 0.06422294f, 0.23082493f, 0.12372721f, 
    0.05700392f, -0.29685855f, -0.23727195f, 0.10033659f, 0.04967482f, 0.09867053f, 0.00424012f, -0.07124570f, 
    -0.06366754f, -0.22197765f, -0.16372038f, 0.01541712f, 0.11629139f, -0.15006775f, -0.00388922f, 0.22812995f, 
    -0.08905183f, -0.01326519f, 0.01180584f, -0.03396298f, 0.01164031f, 0.07323608f, -0.07587379f, 0.06781785f, 
    -0.04672104f, 0.08402140f, -0.07500753f, -0.23196763f, 0.09509282f, 0.02609628f, -0.01984843f, -0.16334189f, 
    -0.01999094f, -0.24184532f, -0.17003168f, -0.28278297f, 0.06384155f, -0.07659101f, 0.10762509f, -0.45087761f, 
    0.04209855f, 0.18625449f, 0.18268980f, 0.05801337f, -0.11957845f, -0.05518037f, -0.14787361f, 0.07358076f, 
    -0.05598671f, -0.12865499f, -0.32247722f, 0.35116291f, -0.13101819f, 0.08244749f, 0.23754510f, 0.07802339f, 
    0.09484686f, -0.24197817f, -0.00717071f, -0.12974018f, 0.11678841f, 0.45224920f, 0.32901275f, -0.43435019f, 
    -0.21588925f, 0.08525910f, 0.05317113f, 0.09768083f, -0.09183796f, 0.09673579f, -0.05170902f, -0.04122984f, 
    0.56041390f, 0.00755934f, 0.26388621f, 0.10880292f, -0.05233801f, 0.02775966f, -0.11355045f, -0.00587927f, 
    0.03207604f, -0.06639378f, 0.06965163f, -0.27112380f, -0.79655856f, 0.17134672f, 0.13486022f, 0.34343135f, 
    0.14263773f, 0.27788866f, 0.06871063f, 0.11051291f, -0.03539806f, 0.10245649f, 0.13380566f, 0.13335314f, 
    0.13157588f, 0.05916565f, -0.11897047f, 0.28411037f, 0.05527370f, -0.02823551f, -0.09049381f, 0.01095307f, 
    -0.20150360f, -0.09535469f, -0.14409341f, 0.03616660f, -0.27123886f, 0.11034176f, -0.13735431f, 0.19451609f, 
    0.02291759f, 0.03791053f, -0.00297893f, 0.17529365f, -0.11334024f, 0.05903692f, -0.07594013f, 0.17444661f, 
    -0.26397568f, -0.04415352f, 0.27540821f, -0.13059901f, -0.08628992f, -0.01070824f, -0.13831361f, 0.01738347f, 
    -0.11122057f, -0.05900426f, 0.09315652f, 0.17930038f, 0.08519857f, -0.42483374f, -0.19579452f, -0.08318017f, 
    -0.07547349f, 0.26759326f, 0.05221356f, -0.21624847f, -0.07032340f, 0.02973276f, -0.11708061f, 0.26482373f, 
    -0.28081587f, -0.19220303f, 0.08507872f, -0.26854333f, 0.09538060f, -0.04882077f, -0.07889814f, -0.03540310f, 
    -0.00912387f, -0.01755802f, 0.08716182f, 0.11190354f, 0.05629270f, 0.17048575f, 0.05512396f, 0.13346602f, 
    0.08666079f, 0.00185136f, 0.05297007f, -0.12919049f, -0.08108556f, -0.03653799f, 0.19902828f, -0.08735932f, 
    -0.20221157f, -0.07179425f, -0.15775017f, 0.32045165f, 0.11905237f, -0.11932092f, 0.01801580f, 0.00534938f, 
    -0.00136825f, 0.03754285f, 0.04833670f, -0.13732654f, 0.06037024f, 0.20024881f, 0.17484064f, -0.31556484f, 
    0.05453641f, 0.07071485f, 0.04443023f, -0.02705400f, 0.02950827f, 0.02258215f, -0.05900941f, -0.06360184f, 
    0.36955777f, -0.24788989f, -0.10686204f, -0.01769620f, -0.11487120f, 0.02932339f, 0.07892504f, -0.02704307f, 
    -0.05164447f, 0.10844093f, -0.00453325f, 0.07075425f, 0.00366313f, 0.24472009f, 0.03370509f, -0.08303200f, 
    0.01078543f, -0.13296783f, -0.10543358f, 0.02398644f, 0.16797543f, -0.09605071f, -0.13733688f, -0.05044654f, 
    0.05335256f, -0.09476388f, 0.09462941f, -0.60800844f, 0.20545909f, -0.02423271f, 0.08696825f, -0.07643133f, 
    -0.12313198f, -0.02610115f, -0.13295794f, 0.20869693f, 0.12518020f, 0.24723238f, 0.23243828f, -0.34872174f, 
    0.08142397f, -0.11436805f, 0.15327324f, 0.10348501f, 0.02356650f, 0.00071890f, -0.13560481f, -0.04831067f, 
    0.81221342f, -0.25429088f, 0.25989321f, -0.10375325f, 0.02763114f, 0.06327010f, 0.19921730f, -0.19420193f, 
    0.07375024f, -0.06671198f, 0.23814815f, 0.10121652f, -0.49027166f, -0.19631200f, 0.29604587f, -0.27654645f, 
    0.03869812f, 0.01367699f, 0.10995503f, -0.07825469f, -0.08544946f, 0.14256963f, 0.03011798f, -0.03853887f, 
    -0.21443436f, 0.11820245f, -0.06812844f, -0.23392981f, -0.15441450f, -0.06890932f, -0.18441430f, -0.04168157f, 
    -0.10374037f, -0.06028705f, 0.14384127f, -0.04686771f, -0.35589814f, -0.24508794f, -0.28150880f, 0.08055923f, 
    -0.10908187f, -0.07210134f, 0.08461778f, 0.02393970f, -0.01900432f, -0.04188997f, 0.09889568f, 0.18493094f, 
    -0.09128781f, 0.32175347f, 0.18012403f, -0.04488737f, -0.09645299f, -0.10678121f, -0.07316610f, 0.19722158f, 
    -0.07489480f, 0.14525816f, 0.09095170f, 0.14067374f, -0.00194389f, -0.02636286f, 0.02792180f, -0.11132501f, 
    -0.08626239f, 0.16284244f, -0.11098360f, 0.00131350f, 0.10389084f, -0.01695990f, 0.16160022f, 0.07390387f, 
    -0.02064858f, -0.43463910f, -0.02038070f, 0.06511419f, -0.10889962f, 0.02585021f, -0.15310214f, 0.04920818f, 
    0.08431636f, 0.16692993f, 0.07650845f, -0.14401710f, -0.28189203f, 0.01273475f, 0.11785485f, -0.25379735f, 
    -0.04386438f, 0.09357682f, 0.12158472f, 0.11593998f, -0.05400800f, -0.12691088f, -0.13768192f, -0.12065651f, 
    -0.09602172f, -0.30967581f, -0.24005005f, -0.25816321f, 0.01782791f, 0.08139311f, -0.00295240f, -0.32652852f, 
    -0.03327417f, -0.02889355f, 0.15010583f, 0.04451612f, -0.00569375f, 0.10021190f, 0.07184486f, -0.04425720f, 
    -0.16455314f, -0.09242849f, 0.10756458f, 0.06739504f, 0.17025383f, -0.00775228f, 0.05178732f, 0.04969006f, 
    -0.06788573f, -0.05700221f, -0.16536587f, -0.25947979f, -0.20618699f, -0.09185460f, -0.15751342f, -0.11415470f, 
    0.04022616f, 0.05382914f, -0.12159922f, -0.06734641f, -0.22962922f, -0.09863172f, 0.03543698f, 0.15715100f, 
    -0.03835613f, 0.08504727f, 0.00975526f, 0.16269037f, 0.27161211f, -0.07933996f, -0.27877802f, -0.24654886f, 
    0.13436428f, -0.17515455f, -0.04397502f, 0.23548967f, -0.18511593f, -0.14837840f, -0.08336350f, -0.10894617f, 
    -0.03150854f, -0.04013481f, -0.09976212f, -0.06659321f, 0.18853144f, 0.12838027f, 0.09712565f, 0.15491246f, 
    0.01184008f, -0.03727769f, 0.04410483f, -0.00332755f, 0.02335311f, -0.06183496f, -0.16865768f, -0.10800096f, 
    0.20040521f, 0.15456122f, -0.03500925f, 0.01503979f, -0.08443715f, -0.02691095f, 0.00349877f, -0.06547808f, 
    -0.04373005f, -0.04445035f, -0.14490472f, -0.01186069f, 0.21758029f, 0.19867963f, 0.02049149f, -0.01411416f, 
    -0.15197290f, -0.00133105f, 0.04253981f, -0.01940795f, -0.04514433f, -0.04455173f, -0.01347967f, -0.09628005f, 
    0.01766516f, 0.17916314f, -0.29746044f, 0.14445141f, 0.12524687f, -0.04770583f, -0.17102505f, -0.02441639f, 
    0.01954082f, -0.02070769f, 0.03778223f, -0.11512326f, -0.23178256f, 0.08187482f, -0.22377956f, -0.06706066f, 
    -0.07985357f, -0.02982473f, -0.00916556f, -0.05358678f, -0.11688121f, -0.20465796f, -0.01429603f, -0.13751344f, 
    0.20567979f, -0.19620542f, 0.23719165f, 0.08021994f, 0.01426460f, -0.06987538f, 0.08676079f, -0.04487083f, 
    -0.08383933f, 0.08653868f, 0.01920037f, 0.06332143f, -0.40862527f, 0.18985771f, -0.15188462f, -0.05212054f, 
    0.02152936f, 0.06342680f, -0.02567405f, 0.04854997f, 0.02682516f, 0.01967220f, 0.02583505f, -0.03304304f, 
    -0.64556229f, 0.14109369f, 0.00958019f, 0.02338044f, -0.01128262f, -0.13370118f, -0.00297719f, 0.08814675f, 
    -0.04710164f, -0.00597082f, 0.00792295f, -0.02588351f, -0.09478997f, -0.29505888f, -0.22470787f, 0.07588053f, 
    -0.13011055f, -0.06419942f, -0.18123180f, -0.03924282f, -0.29938108f, 0.08062577f, 0.13260707f, -0.13935541f, 
    -0.35858193f, 0.16728242f, -0.16453198f, -0.16364014f, -0.02707792f, 0.07292321f, -0.15394042f, -0.12879549f, 
    -0.14795010f, -0.12905297f, -0.04401137f, -0.12554190f, 0.05319934f, 0.19474728f, 0.15459633f, 0.29987916f, 
    -0.08224605f, 0.06309895f, 0.04088448f, -0.02008339f, 0.06934331f, 0.04607742f, -0.10698927f, 0.06088093f, 
    -0.02903968f, 0.08068240f, -0.25403529f, 0.22673182f, -0.04183874f, 0.06135092f, -0.13814135f, -0.02512770f, 
    -0.12676848f, 0.04768504f, -0.07854269f, -0.12751676f, -0.03714566f, -0.28764486f, 0.06314629f, -0.07580708f, 
    -0.03449354f, -0.00334747f, -0.10363968f, -0.04955688f, -0.06227801f, 0.02635415f, 0.02018459f, -0.03350698f, 
    0.14072621f, 0.24796569f, 0.00454971f, 0.35754427f, 0.13364039f, -0.10782124f, -0.01355474f, -0.07579083f, 
    -0.00387346f, 0.10186942f, -0.04512258f, -0.13917854f, -0.28995663f, -0.14933293f, -0.27694741f, -0.15839206f, 
    -0.14080724f, -0.03305588f, 0.01393378f, -0.05608248f, -0.21956401f, -0.02990739f, -0.05534733f, 0.02346556f, 
    -0.10268702f, 0.08820859f, 0.11732562f, -0.00371904f, -0.18862824f, 0.05269618f, -0.06520072f, 0.08549317f, 
    -0.10052948f, -0.03458384f, -0.08253906f, 0.00144737f, -0.12933667f, -0.27777773f, -0.30602065f, -0.41747841f, 
    -0.00510735f, -0.02653311f, 0.06704505f, -0.02730038f, -0.02542404f, -0.08513934f, -0.06276680f, -0.06476495f, 
    0.27891219f, -0.05745624f, -0.15236439f, -0.04847015f, -0.08925814f, -0.14550371f, -0.09336697f, -0.22798659f, 
    -0.10777732f, -0.03054621f, 0.07545735f, -0.11382638f, 0.16008154f, -0.75694275f, 0.19185507f, 0.01303203f, 
    -0.09409027f, 0.00614592f, -0.03105756f, -0.01412449f, -0.04928191f, 0.11155811f, -0.00240353f, -0.01869176f, 
    0.34384650f, -0.08730369f, 0.23732245f, -0.27849606f, -0.07369513f, 0.05290993f, -0.04928989f, -0.14006366f, 
    -0.03033050f, 0.16577092f, -0.04500610f, -0.00884612f, -0.01460251f, 0.06465434f, 0.08953962f, 0.04921458f, 
    -0.04358818f, 0.07791889f, 0.01251019f, -0.04709994f, -0.08143485f, -0.06890002f, -0.06833815f, -0.09633276f, 
    0.16585629f, 0.18781491f, 0.18280792f, 0.33093947f, 0.20372741f, 0.05881756f, 0.08161723f, -0.03358145f, 
    -0.07779537f, -0.03936593f, 0.04863336f, -0.09722951f, 0.22330178f, 0.24222329f, 0.13861816f, 0.26022351f, 
    0.12667806f, -0.00620397f, 0.11520185f, 0.07958379f, 0.08025019f, -0.01698557f, 0.10454150f, -0.07079946f, 
    -0.23258209f, -0.05931361f, -0.30718258f, -0.14198707f, 0.01287118f, -0.02846595f, 0.02230671f, -0.06205815f, 
    -0.20049065f, -0.01859362f, -0.10396485f, -0.04684093f, 0.16994803f, -0.06211190f, 0.21456330f, 0.34784880f, 
    0.03450926f, -0.00035920f, -0.09468888f, -0.05878185f, -0.17772360f, -0.07630120f, -0.06897154f, -0.01319515f, 
    -0.00485229f, -0.04270639f, 0.08570407f, -0.12477221f, 0.05823977f, 0.00034706f, -0.03296612f, 0.02910233f, 
    0.14716926f, 0.00355003f, 0.03480768f, 0.02243250f, 0.05339355f, 0.16304672f, 0.04861022f, 0.00408748f, 
    -0.09308821f, 0.04417457f, -0.03284016f, -0.18462676f, 0.00480863f, 0.05161617f, -0.02689914f, -0.12705612f, 
    0.23192587f, 0.19353166f, 0.31056398f, 0.13558000f, 0.07229882f, 0.11628414f, 0.13549933f, -0.06592490f, 
    0.01815144f, 0.02289346f, -0.01832773f, 0.01387418f, -0.00032597f, 0.03520265f, -0.04339625f, -0.19136889f, 
    -0.05266611f, -0.03555752f, -0.06078619f, -0.05513154f, 0.01794964f, -0.06445809f, -0.16638571f, -0.11758780f, 
    0.00105066f, 0.28575146f, 0.05823389f, 0.20759200f, 0.18198399f, 0.03723542f, -0.00821323f, -0.00357080f, 
    -0.14464784f, -0.01076319f, -0.06830977f, -0.14531547f, -0.13386534f, 0.21480851f, 0.07008173f, 0.14490929f, 
    -0.04309204f, 0.02584020f, 0.00808132f, -0.08820762f, 0.02088536f, 0.02847506f, -0.01471403f, 0.00962042f, 
    -0.03733714f, -0.05672378f, -0.30787548f, -0.10964494f, -0.06936129f, -0.05238913f, -0.02355152f, 0.07587349f, 
    0.18038107f, 0.03981643f, 0.04722510f, 0.05235035f, 0.17135260f, 0.04866630f, 0.09739797f, -0.36480761f, 
    -0.00479524f, -0.08537941f, -0.26989242f, -0.05044609f, 0.03166514f, 0.03275079f, -0.04398261f, -0.14502744f, 
    -0.13372472f, -0.19504860f, 0.30321991f, -0.20117311f, -0.03753450f, -0.22456390f, -0.05049142f, 0.12772563f, 
    -0.02680411f, 0.05729223f, 0.05805567f, 0.12328671f, -0.10034022f, -0.11667319f, 0.12423620f, 0.22968318f, 
    -0.01493882f, -0.33201021f, -0.06791308f, -0.05335200f, -0.04922915f, 0.04463497f, 0.07428207f, 0.04171268f, 
    -0.18131363f, 0.35549232f, -0.33823922f, 0.01156538f, -0.25216007f, 0.01240464f, -0.51227897f, 0.08880627f, 
    0.12916717f, 0.16804415f, 0.06688862f, 0.01577778f, -0.11557645f, -0.20324998f, -0.08019090f, 0.10851446f, 
    0.11645386f, -0.09294407f, 0.01648222f, -0.09097390f, -0.12000702f, 0.20107111f, -0.13709991f, 0.02566365f, 
    -0.03545569f, -0.36919284f, 0.10012521f, -0.13039954f, 0.01719604f, -0.16545817f, 0.09221730f, -0.16541179f, 
    0.00717124f, 0.04061275f, -0.24585953f, -0.02474671f, 0.26673111f, 0.07253969f, -0.22395478f, 0.16254824f, 
    0.09570951f, -0.11944148f, -0.14432250f, -0.06212747f, 0.03321729f, 0.02846073f, -0.03880938f, -0.09107853f, 
    0.04318045f, 0.34214327f, -0.46126702f, -0.02061241f, 0.25813237f, -0.06837176f, -0.12107374f, 0.06045098f, 
    0.02947222f, -0.00191000f, 0.17038442f, 0.11970337f, 0.02259448f, -0.26905873f, -0.40140128f, -0.45719332f, 
    0.06557721f, 0.03025907f, -0.02001597f, 0.00188250f, 0.15566126f, 0.13105005f, 0.01213011f, -0.09003640f, 
    0.32678452f, 0.01233577f, 0.04318027f, 0.16176350f, 0.08368032f, 0.02585452f, 0.00038157f, -0.02823362f, 
    0.01497313f, 0.06107440f, -0.09191556f, -0.23031649f, -0.15930676f, 0.10346721f, 0.25949052f, -0.35521689f, 
    -0.04406082f, 0.04063252f, 0.04788305f, 0.02264783f, 0.02314472f, 0.00727624f, 0.12467311f, -0.29709211f, 
    -0.08498222f, 0.32371166f, 0.18025899f, -0.10826407f, -0.03496417f, 0.00538963f, -0.03719880f, -0.04880873f, 
    0.04875378f, 0.07328449f, -0.18500459f, -0.13021658f, -0.40582025f, -0.23116258f, 0.13348873f, -0.22487281f, 
    -0.03383690f, 0.08013283f, -0.25320616f, -0.14999104f, -0.07200355f, -0.01316973f, -0.16692130f, 0.16034782f, 
    -0.06051342f, 0.23041463f, -0.01183394f, -0.14841922f, -0.02402719f, -0.06540275f, -0.05656175f, 0.10469721f, 
    -0.09259550f, -0.15758544f, 0.13146760f, 0.03681070f, 0.10461751f, -0.21839026f, 0.03317333f, 0.30393243f, 
    0.28052166f, 0.08152630f, -0.05072612f, -0.06516809f, 0.07637982f, -0.12806244f, 0.25046444f, -0.08890475f, 
    -0.04034055f, 0.23344004f, -0.11962924f, -0.14099592f, 0.03841306f, -0.02460460f, 0.14289746f, -0.15732315f, 
    0.11974818f, -0.07325920f, 0.01765135f, 0.21247777f, 0.10130166f, 0.08306344f, -0.14354423f, 0.20116124f, 
    0.08115152f, -0.01565147f, -0.01106657f, -0.00671298f, -0.06059365f, 0.06094250f, 0.08067932f, 0.09804724f, 
    -0.07336567f, -0.29725292f, 0.17243072f, -0.02191342f, -0.00952522f, -0.14584678f, -0.05163191f, 0.09646267f, 
    0.06074933f, -0.08548621f, 0.02156454f, -0.14968848f, -0.10432335f, -0.11482735f, -0.21711907f, 0.29551294f, 
    0.04342337f, -0.12465896f, -0.04913210f, -0.01030438f, 0.06983615f, 0.15518643f, 0.12809253f, 0.06824743f, 
    0.22620957f, -0.45441288f, 0.14543371f, -0.06452738f, 0.04605862f, -0.14432111f, -0.03470192f, -0.07752263f, 
    -0.00987058f, 0.00915570f, -0.03799634f, -0.06493871f, -0.41948166f, 0.07210806f, 0.29934213f, 0.13083738f, 
    -0.16585271f, -0.05612841f, -0.09355490f, -0.02825168f, -0.07672294f, 0.00229997f, 0.01166011f, 0.04275986f, 
    -0.21828125f, -0.09795278f, -0.03562473f, -0.42488602f, 0.08665868f, -0.24846822f, 0.29089269f, 0.07876217f, 
    0.07466982f, -0.13058572f, -0.29724693f, 0.14097625f, 0.02571889f, 0.04622541f, 0.13265258f, -0.00176001f, 
    -0.00887630f, 0.06072493f, -0.05998145f, -0.09656210f, -0.09441302f, -0.03960240f, -0.16116360f, 0.06297383f, 
    0.23527801f, 0.17446919f, -0.03510773f, 0.25569174f, 0.16787125f, 0.07602581f, -0.06728522f, -0.03857270f, 
    0.11548460f, 0.05499106f, -0.22779870f, -0.08037886f, 0.01049315f, -0.08431938f, -0.18596186f, -0.28498283f, 
    0.17185935f, 0.05388236f, 0.01737595f, 0.00440934f, -0.06841772f, 0.00541931f, -0.17772344f, 0.00695836f, 
    -0.19250146f, -0.11687143f, 0.05625634f, 0.08723401f, -0.14217100f, -0.03462229f, -0.06010624f, 0.02881609f, 
    0.09175919f, 0.10840960f, -0.14960599f, 0.07332577f, 0.24577972f, -0.10449653f, 0.16308793f, 0.14541088f, 
    -0.00884271f, -0.03895623f, 0.08986434f, -0.04668238f, -0.01963347f, 0.03960563f, 0.11585380f, 0.04943683f, 
    -0.09501278f, 0.02411412f, 0.17801464f, 0.11240314f, -0.08017696f, 0.00711669f, -0.13781302f, -0.09772711f, 
    0.05008555f, -0.01112941f, -0.08054909f, 0.06183118f, 0.34246591f, -0.04823400f, -0.02964782f, 0.05033287f, 
    0.00751272f, -0.03770065f, -0.05126670f, -0.11702797f, -0.01798955f, -0.13437097f, -0.12165402f, -0.02928954f, 
    -0.34013200f, 0.05110997f, 0.28093258f, -0.06988380f, -0.24568550f, 0.11074247f, -0.02583442f, -0.29486945f, 
    -0.02421228f, -0.06321301f, 0.06044538f, 0.15786514f, -0.08614093f, -0.16523270f, 0.09699649f, 0.09671463f, 
    0.01499761f, -0.12124033f, -0.20790426f, -0.26326597f, -0.01613447f, 0.09728410f, 0.12326930f, 0.01999895f, 
    0.01690523f, -0.07464551f, 0.00346683f, -0.31357038f, -0.01944480f, -0.09970658f, 0.18162754f, -0.07338308f, 
    -0.06326631f, 0.03368236f, 0.00577024f, -0.13390194f, 0.03558939f, -0.13639218f, -0.40103281f, -0.13337025f, 
    0.08460671f, -0.09763745f, -0.11886382f, 0.01555685f, 0.03962529f, -0.03935522f, -0.00628412f, 0.17718989f, 
    0.00724865f, 0.00284527f, -0.02359160f, -0.00752844f, -0.02764229f, -0.12612547f, -0.01876196f, -0.16486987f, 
    0.06575027f, 0.01639988f, -0.17685115f, -0.18151884f, 0.34065968f, 0.19065274f, -0.01166761f, 0.06133216f, 
    0.04642912f, 0.00162180f, 0.03458796f, -0.00785924f, 0.11102026f, -0.06195307f, 0.12816034f, -0.06520557f, 
    -0.20453472f, 0.49441454f, 0.16769360f, 0.21861173f, -0.07802438f, 0.13039169f, -0.03292831f, 0.12263168f, 
    -0.13307089f, 0.08133444f, -0.04733965f, 0.00490292f, -0.46485096f, 0.26168168f, 0.03553206f, -0.27962509f, 
    -0.03885077f, 0.05811283f, 0.05676983f, -0.03462796f, 0.10786876f, 0.04442850f, 0.12915435f, 0.02088197f, 
    -0.17791633f, -0.10925642f, -0.24800465f, 0.39312348f, 0.03139115f, -0.00610382f, 0.05085298f, -0.05031176f, 
    0.04709277f, 0.02242375f, -0.06739413f, -0.04967184f, -0.33122760f, 0.36342067f, 0.31508857f, -0.21598592f, 
    0.02886117f, 0.10065498f, 0.05386457f, -0.08122080f, 0.22065549f, 0.04879240f, 0.10455738f, 0.02149816f, 
    0.07250974f, -0.23243354f, 0.57584178f, -0.14561240f, 0.07810535f, 0.14859910f, 0.11276439f, 0.10982636f, 
    -0.09891460f, -0.08933262f, 0.02056762f, -0.13075826f, 0.22034292f, -0.12478066f, 0.28446361f, -0.10360098f, 
    0.02510181f, 0.11136489f, 0.13177526f, -0.16568829f, -0.14630993f, -0.05758856f, -0.01842480f, 0.08175023f, 
    -0.16213353f, 0.08364834f, -0.14314082f, -0.17459770f, 0.16108742f, 0.02312507f, 0.10399013f, -0.15179400f, 
    0.09837294f, 0.16830084f, 0.01676576f, 0.11450347f, 0.17218322f, 0.20026267f, 0.26676756f, 0.09730587f, 
    0.14114140f, 0.02430262f, -0.15696143f, 0.10950045f, 0.13842288f, -0.08506806f, -0.03295489f, -0.01593750f, 
    -0.45677355f, 0.69725376f, -0.00995325f, 0.25054565f, 0.04745390f, -0.08129196f, -0.17318836f, 0.13178030f, 
    0.07522398f, 0.00294373f, 0.17354110f, 0.10853911f, -0.26478997f, -0.26843759f, -0.06661246f, 0.13905410f, 
    -0.22448398f, 0.05999741f, 0.05445443f, 0.07918911f, 0.08460663f, 0.09467012f, -0.01240656f, -0.09274473f, 
    -0.03391180f, -0.19836070f, 0.28031319f, -0.05858872f, 0.01353546f, -0.02731539f, -0.07329109f, 0.02026806f, 
    -0.02485883f, 0.19565962f, -0.02328947f, 0.22818816f, -0.38335600f, 0.30486026f, 0.02729769f, -0.53411227f, 
    0.00556088f, -0.04524679f, -0.05989388f, -0.05025718f, -0.08656486f, 0.27621341f, -0.16322744f, -0.11386207f, 
    0.19318688f, 0.11069481f, -0.13519748f, 0.08331089f, -0.00418518f, -0.11308315f, -0.03065247f, 0.10775786f, 
    -0.07527009f, 0.10387924f, 0.33548865f, 0.02628977f, 0.01933949f, 0.05929584f, 0.15805516f, -0.01210364f, 
    0.02025394f, 0.03316536f, 0.00822820f, -0.07815076f, -0.28009182f, -0.07292401f, -0.07921613f, -0.14013605f, 
    -0.24390736f, 0.12587084f, -0.08261381f, -0.18071179f, -0.26516739f, -0.06423395f, -0.05602427f, -0.06300039f, 
    -0.07141134f, 0.08588506f, 0.04948368f, 0.16172096f, 0.23760441f, -0.55461830f, 0.00762417f, -0.51821792f, 
    -0.05855695f, 0.02142726f, -0.05644481f, 0.09886561f, 0.04930072f, -0.03201223f, 0.12330500f, -0.03834161f, 
    -0.18249378f, -0.02962251f, 0.11406694f, 0.08312856f, -0.08535077f, 0.00308159f, -0.09177230f, 0.05448688f, 
    -0.10950586f, 0.14478281f, -0.10192427f, 0.17449328f, 0.64047313f, -0.12756290f, -0.28582504f, 0.00719403f, 
    -0.12046716f, -0.08921108f, -0.04187310f, -0.08524069f, 0.05007018f, -0.04758856f, 0.12063413f, 0.09338276f, 
    0.36264080f, 0.15702561f, -0.25122601f, -0.05120914f, 0.10106383f, -0.01466503f, -0.01892190f, 0.00470931f, 
    -0.16264327f, 0.00846444f, 0.09656178f, 0.03156989f, -0.31466785f, -0.07844435f, 0.03644089f, 0.13430043f, 
    0.09142026f, 0.01521004f, -0.06644021f, 0.31580833f, 0.06425814f, -0.12468360f, 0.21242319f, -0.11443090f, 
    -0.16510285f, 0.23488183f, -0.22811295f, -0.32173023f, 0.13450851f, 0.09443387f, 0.02161600f, -0.11496610f, 
    -0.26182011f, -0.05639836f, -0.25978869f, -0.04749601f, -0.01751570f, -0.41738936f, -0.24824935f, -0.01958654f, 
    -0.14395659f, 0.04611596f, -0.04008149f, 0.07039910f, -0.06479723f, -0.04910965f, 0.16378230f, 0.15610552f, 
    0.27705395f, 0.04004133f, -0.44888660f, 0.10961791f, -0.08274740f, -0.11137266f, 0.25264555f, -0.03580497f, 
    0.06674222f, -0.18351385f, 0.04914258f, -0.13911414f, -0.49321836f, 0.44920009f, -0.42975077f, 0.01816047f, 
    0.20164953f, 0.01364448f, 0.04658491f, -0.04159600f, -0.05721246f, -0.02596508f, -0.01324109f, -0.02672062f, 
    -0.33010763f, -0.52161866f, -0.08267627f, -0.10233253f, -0.01918708f, 0.00656981f, -0.08041682f, 0.05868274f, 
    -0.04735484f, 0.03753444f, -0.11502514f, -0.05727087f, -0.18157741f, -0.06575725f, -0.01816003f, -0.09640726f, 
    0.01165014f, -0.06842175f, -0.14919853f, -0.11884432f, 0.21065523f, 0.07143943f, 0.07007165f, 0.17583352f, 
    -0.23684022f, -0.41358444f, -0.03047549f, 0.12791909f, 0.01286216f, -0.16858771f, -0.04227350f, 0.14376125f, 
    -0.15548195f, -0.07877907f, 0.09001575f, -0.18218555f, 0.17500906f, -0.23966354f, -0.10235920f, 0.09994628f, 
    -0.21568610f, -0.02967243f, 0.09188254f, 0.08894949f, 0.09991809f, -0.04945109f, -0.14942038f, -0.16796678f, 
    0.09387440f, 0.07433055f, -0.02935802f, -0.16283283f, 0.12010664f, 0.12625830f, 0.05132135f, 0.04561298f, 
    0.06370720f, 0.10311792f, 0.14849730f, 0.10226133f, -0.27461994f, 0.23588769f, 0.02454327f, -0.14199765f, 
    0.08347388f, 0.05633771f, 0.03862953f, 0.08425447f, 0.12457947f, -0.01079146f, 0.15049623f, -0.02577058f, 
    0.40102997f, 0.33650067f, 0.08252837f, -0.25333515f, 0.00739208f, -0.06443826f, 0.08060419f, 0.14423269f, 
    0.03174541f, 0.19330929f, 0.24455066f, 0.21619317f, -0.69424522f, -0.06622315f, 0.00301150f, -0.06159760f, 
    0.00446650f, -0.28521231f, -0.09801763f, -0.11622734f, -0.08151305f, -0.02081333f, -0.12124433f, -0.06861702f, 
    -0.41330877f, -0.44256455f, -0.10931938f, 0.14031731f, 0.03038513f, 0.12422345f, -0.14982657f, 0.01122267f, 
    0.09812939f, -0.04248985f, 0.11998378f, 0.03522333f, -0.19093615f, -0.04987805f, -0.09673712f, -0.16961209f, 
    0.12295620f, -0.16433825f, -0.07490139f, -0.05454487f, 0.04330710f, 0.10047601f, -0.00965257f, 0.22822259f, 
    0.24660379f, -0.00596328f, -0.09417402f, 0.21094091f, -0.24050340f, -0.20856285f, 0.09254247f, 0.00895027f, 
    0.07636721f, -0.04097574f, -0.11291096f, -0.00486822f, -0.77689981f, -0.60307956f, -0.03380822f, -0.01846033f, 
    0.04417011f, -0.00285870f, 0.02495512f, -0.08903286f, 0.27195448f, -0.12158002f, -0.20832141f, -0.07419106f, 
    -0.38833079f, -0.39482242f, 0.02346222f, -0.02722206f, 0.11659141f, -0.01142517f, -0.15095499f, -0.03350475f, 
    0.03513171f, 0.01274668f, -0.09267768f, 0.11524308f, -0.20387068f, 0.06657936f, 0.39397779f, 0.16678505f, 
    0.17453484f, -0.06074201f, -0.01930181f, -0.04837969f, 0.02526368f, 0.06940707f, -0.19140264f, 0.01189185f, 
    -0.14932293f, -0.12326638f, -0.12699904f, 0.01833867f, 0.07356462f, 0.01580068f, -0.05043387f, 0.11868625f, 
    0.01012377f, -0.14508149f, 0.00249228f, 0.06255047f, 0.28819209f, 0.09588182f, -0.03210799f, -0.09775714f, 
    -0.17504178f, -0.17152528f, 0.10846978f, -0.02715489f, 0.15415527f, -0.09959985f, 0.04604586f, -0.14871335f, 
    -0.21874990f, -0.37262961f, 0.04129248f, 0.20253748f, -0.01963539f, -0.02194484f, 0.00961016f, 0.05854337f, 
    0.12508824f, -0.08345050f, -0.03233501f, -0.02249654f, 0.46294668f, 0.14120707f, 0.12326977f, 0.11136541f, 
    0.16817603f, 0.01562268f, -0.01021778f, 0.09800065f, -0.07599194f, -0.19639511f, -0.15947615f, 0.08167344f, 
    0.04865874f, 0.10567512f, 0.08366644f, -0.09454337f, 0.15733454f, 0.08418109f, -0.05031902f, -0.12838605f, 
    0.00153300f, 0.07535006f, 0.06370797f, -0.15170832f, -0.47706598f, -0.32909420f, -0.17721236f, -0.37122756f, 
    0.13905174f, 0.07732467f, -0.00303454f, 0.03746810f, 0.06000184f, 0.10923062f, 0.11931873f, -0.06956562f, 
    -0.10473534f, -0.02166714f, 0.02779866f, 0.04689258f, 0.07730182f, -0.15611096f, -0.09576821f, -0.15664627f, 
    0.02715324f, -0.01729804f, -0.02641399f, 0.00832770f, -0.80462217f, -0.20093146f, -0.13125323f, -0.10078640f, 
    0.17897490f, 0.02175189f, -0.02915173f, 0.00324425f, 0.02028784f, 0.11160677f, 0.18136270f, 0.22329247f, 
    -0.07005636f, 0.19972721f, 0.17146549f, -0.00817626f, 0.10256768f, 0.09484030f, 0.06170613f, 0.08566009f, 
    -0.01761930f, 0.00156323f, 0.00429052f, -0.05588104f, -0.47977257f, 0.12693860f, -0.29086471f, -0.06043357f, 
    0.05804799f, 0.04635017f, -0.08706826f, 0.09502731f, 0.08520958f, -0.00640791f, 0.03396493f, 0.19381613f, 
    0.15449350f, -0.07462569f, -0.08704846f, 0.05797403f, 0.03797845f, 0.00272393f, -0.06671672f, 0.13371363f, 
    -0.10725699f, 0.05711002f, -0.10166181f, -0.04650199f, 0.13306019f, 0.21273902f, 0.05790458f, -0.11856531f, 
    0.11398939f, -0.05131996f, 0.06601644f, 0.14335094f, 0.02752199f, 0.04067558f, -0.01239798f, 0.04689505f, 
    -0.22263387f, 0.03458323f, -0.05345640f, 0.22977428f, 0.09263653f, -0.02686974f, 0.03143473f, -0.12882313f, 
    0.06683930f, -0.07329353f, 0.04163968f, 0.03299655f, 0.32730147f, -0.09205229f, 0.16387722f, -0.25301570f, 
    -0.36808479f, 0.03819674f, -0.05270190f, -0.18068774f, 0.01423564f, 0.01011124f, -0.20515405f, -0.17388566f, 
    -0.62510931f, -0.19333063f, -0.08337499f, -0.45095196f, 0.04994709f, 0.07661673f, 0.00015083f, 0.05199626f, 
    0.03754737f, -0.04287349f, 0.04944785f, 0.19076502f, -0.31668723f, 0.08217981f, -0.10869487f, -0.00151281f, 
    0.08246194f, 0.07268936f, -0.03022222f, -0.00543395f, 0.10448857f, 0.24448861f, -0.22939436f, -0.13788584f, 
    0.34254664f, 0.01598385f, 0.11711950f, -0.03727951f, -0.01841421f, 0.04770729f, -0.09841744f, 0.09622113f, 
    -0.06604041f, -0.08814211f, -0.18309945f, 0.06411257f, -0.45048240f, -0.34469923f, -0.27038741f, -0.12322387f, 
    -0.07118636f, -0.01661642f, 0.00813594f, 0.05549601f, 0.02399691f, 0.17664598f, 0.11556806f, 0.16730095f, 
    0.31577757f, 0.04249725f, -0.09578411f, -0.19230248f, -0.15497835f, -0.08225922f, -0.02182366f, -0.09765766f, 
    0.12901546f, 0.02277514f, 0.01006341f, -0.04254883f, -0.24652790f, 0.01017587f, -0.14802743f, -0.21229132f, 
    0.07456947f, 0.16987994f, -0.07138923f, -0.14373514f, 0.06032760f, -0.12087031f, -0.15170906f, -0.00959231f, 
    0.10775764f, 0.08814590f, 0.15457813f, -0.12604643f, 0.06245498f, -0.00707883f, 0.18676089f, -0.08057889f, 
    0.12510231f, 0.03514817f, 0.07919838f, 0.08458986f, -0.09749284f, 0.04085850f, 0.07112961f, -0.09013412f, 
    0.08300553f, -0.10260694f, -0.11962056f, 0.15469785f, -0.10484391f, 0.25884387f, 0.01857844f, 0.00497703f, 
    0.11967932f, 0.01013855f, -0.06158521f, 0.42476237f, -0.12012371f, -0.00072669f, 0.06528965f, 0.06370316f, 
    -0.12324782f, -0.17906290f, -0.06345841f, -0.17599098f, -0.43275201f, -0.04304685f, 0.20087132f, 0.21201630f, 
    -0.23179699f, 0.12906671f, 0.05348011f, -0.00638486f, -0.10502534f, 0.04327353f, 0.06875220f, 0.16656502f, 
    -0.16859719f, 0.07583555f, -0.08955289f, -0.19953075f, 0.00236338f, 0.06952754f, 0.10422647f, 0.06548854f, 
    0.08551408f, -0.10820683f, -0.14428622f, -0.14837117f, -0.02926801f, -0.12539464f, 0.15817273f, -0.51835012f, 
    0.03944618f, -0.09981582f, -0.07699643f, 0.02075899f, -0.08512213f, -0.12323847f, 0.04578200f, 0.11456399f, 
    0.13186108f, 0.11970197f, -0.22280394f, 0.25223908f, 0.09072706f, -0.15656251f, -0.04366832f, -0.26891306f, 
    -0.05175288f, 0.06775492f, -0.06403701f, -0.00071294f, 0.01130143f, -0.08421375f, -0.11802047f, 0.09675112f, 
    0.10532487f, 0.03285946f, 0.04022584f, 0.06279684f, -0.17671232f, -0.03609398f, 0.11662344f, -0.05950928f, 
    0.03555604f, -0.24421299f, 0.26022595f, 0.08383989f, 0.01802108f, 0.02278094f, -0.01977994f, -0.02843063f, 
    -0.16137221f, 0.02332398f, 0.13703065f, 0.16927527f, -0.06416395f, 0.01422807f, 0.02853510f, -0.12270839f, 
    0.09296457f, 0.11898399f, -0.04728519f, -0.04180314f, -0.00718182f, 0.01492162f, 0.11939278f, -0.00506710f, 
    0.25851360f, -0.15688267f, -0.05457364f, 0.01916247f, 0.30078182f, -0.02835943f, 0.05632574f, 0.01120691f, 
    0.07483218f, 0.03009883f, 0.00840399f, 0.00725102f, 0.62818629f, 0.14729668f, 0.04033029f, -0.11737035f, 
    -0.00667171f, 0.08845512f, -0.09961496f, 0.08556455f, 0.31400034f, 0.09092000f, 0.12142986f, -0.00975643f, 
    -0.39163452f, -0.02059972f, -0.08219401f, -0.13729234f, 0.10316452f, -0.01106163f, 0.05204367f, 0.10790228f, 
    0.17329763f, -0.11738120f, -0.08497920f, 0.06803028f, -0.21444179f, -0.19835007f, 0.06476199f, 0.10754627f, 
    -0.02844971f, 0.11363420f, -0.10808060f, 0.04101784f, 0.09952842f, -0.21731006f, -0.12668021f, 0.02161194f, 
    0.04756297f, 0.09361253f, -0.15765850f, 0.03819279f, 0.10649467f, -0.03345744f, 0.02489312f, 0.07505168f, 
    0.10909931f, 0.13112767f, 0.01233315f, 0.08359086f, -0.10262994f, 0.16557302f, -0.22544317f, -0.46608245f, 
    -0.13262707f, -0.05824864f, 0.22323287f, 0.02686899f, 0.11245989f, 0.03601632f, 0.04907677f, 0.01214091f, 
    0.14029248f, 0.07153907f, 0.06387894f, -0.10158387f, -0.17501584f, 0.10857097f, -0.18432094f, -0.14314382f, 
    -0.01713612f, 0.06543943f, -0.12608106f, -0.07143782f, 0.60102969f, -0.11447793f, -0.46503446f, -0.09645647f, 
    0.04928533f, -0.16405651f, 0.03837235f, -0.03607059f, 0.08044613f, -0.09306468f, -0.04268392f, 0.10253147f, 
    -0.22474690f, -0.35532302f, 0.00412076f, 0.13384384f, 0.09769370f, -0.17948689f, -0.03798189f, 0.01039478f, 
    0.01945594f, 0.15630084f, -0.13891238f, -0.17292811f, 0.56868494f, -0.31225285f, -0.21103691f, -0.00969294f, 
    0.02492725f, -0.05608866f, -0.01741077f, 0.01747935f, -0.07061945f, -0.00899778f, -0.01987604f, -0.01547689f, 
    0.27987996f, 0.36513397f, -0.09813539f, -0.28920868f, 0.27030939f, -0.06236415f, -0.11727001f, 0.05380246f, 
    0.13664997f, -0.04790657f, 0.13963413f, -0.02531392f, 0.10248592f, 0.03011129f, -0.30322939f, 0.04623549f, 
    0.03998498f, -0.05682658f, -0.11442722f, 0.02824385f, -0.04686961f, -0.01551193f, -0.06771545f, 0.05537835f, 
    -0.58140653f, 0.17079544f, 0.07293838f, -0.10145093f, 0.10285999f, -0.08575116f, 0.06531947f, -0.00256920f, 
    -0.00383082f, 0.08172543f, 0.04958096f, -0.16041115f, 0.21474965f, 0.04845484f, -0.12500958f, 0.00704653f, 
    0.04979112f, -0.01962133f, -0.11891389f, 0.15252273f, -0.04144339f, 0.03723057f, 0.00177433f, 0.00449470f, 
    -0.32399774f, 0.08352137f, 0.06239198f, -0.01357381f, -0.31345928f, -0.09371600f, -0.07651984f, 0.07352401f, 
    0.04927887f, -0.00044562f, 0.03130244f, -0.17388850f, -0.42483154f, 0.03383249f, -0.08676215f, -0.03812935f, 
    -0.05004949f, 0.10533628f, -0.11454567f, 0.01431516f, -0.12925006f, 0.00260312f, 0.16336145f, -0.17800798f, 
    0.47162592f, -0.35168183f, -0.22762376f, -0.12567189f, -0.06895718f, -0.06942910f, 0.09245449f, -0.05986162f, 
    0.03946947f, 0.05923591f, -0.04994952f, -0.03295252f, -0.18134043f, -0.08174738f, 0.04024261f, 0.50049978f, 
    -0.09065751f, 0.00962458f, -0.12644410f, 0.11101180f, -0.03210749f, -0.09592728f, 0.09026244f, 0.01064277f, 
    0.05598561f, -0.07218345f, 0.21065859f, 0.07087956f, -0.02816544f, 0.03059386f, 0.02817027f, 0.00537292f, 
    -0.20753701f, 0.00352036f, -0.01212047f, -0.14222226f, -0.31402549f, -0.19514988f, 0.04526779f, 0.03206582f, 
    0.07247659f, 0.06060872f, 0.05812326f, -0.05001950f, -0.01496496f, -0.16166823f, -0.18382233f, 0.00354365f, 
    -0.25070602f, 0.21878082f, -0.06293648f, 0.09365326f, -0.06451778f, -0.02726608f, 0.06343634f, -0.12102564f, 
    0.04998266f, -0.02985423f, 0.10517229f, -0.12328068f, -0.37462616f, -0.27371153f, -0.05137055f, -0.34330216f, 
    0.02218141f, -0.04260752f, 0.13940363f, 0.12960322f, 0.01554483f, -0.00406737f, -0.16269952f, -0.10919187f, 
    0.47188663f, 0.08112012f, -0.03053006f, -0.07230235f, -0.16434126f, -0.01883605f, 0.00658482f, 0.04231762f, 
    -0.06389365f, -0.03979839f, -0.14030816f, -0.06338312f, -0.18829118f, 0.06923489f, 0.08123492f, 0.40064779f, 
    -0.05428480f, 0.03323978f, -0.01816121f, 0.04442734f, -0.26411450f, -0.15538985f, -0.11019013f, -0.03376146f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09658834f, 0.09332003f, -0.02941428f, -0.02993348f, -0.02053571f, 0.04139243f, 0.06599321f, -0.12963665f, 
    -0.00120636f, 0.00733392f, 0.12054401f, 0.09269054f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
