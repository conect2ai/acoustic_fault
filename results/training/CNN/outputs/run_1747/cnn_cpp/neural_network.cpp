#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -2.18327212f, -0.29770014f, -0.85281461f, -0.22060712f, 0.46262741f, 0.53450209f, 0.76132989f, -0.39727643f, 
    0.60578161f, 0.39084291f, 0.16685396f, 0.25109136f, 0.07180303f, -0.08178405f, -0.53682840f, 0.05177324f, 
    0.28648135f, -0.50959849f, -0.01477417f, 0.11424767f, 0.00831600f, -0.13179459f, -0.34617838f, -0.16145535f, 
    -0.34296623f, -0.84748077f, 0.88737541f, 0.56959635f, 0.03492590f, -0.67406303f, 0.03693265f, -0.27112418f, 
    0.17058723f, 0.92069113f, -0.28717005f, -0.68724519f, -0.43465906f, -0.02093801f, 0.05014038f, -0.03210668f, 
    0.93185306f, 0.63962483f, -0.29553521f, -0.01183512f, 0.04228855f, -0.17714761f, -0.12938042f, -0.21592845f, 
    -0.17923905f, -0.04472090f, 1.37236238f, 1.31089187f, 0.69062817f, -0.76452410f, -1.14359152f, -0.41179502f, 
    0.47301671f, -0.19097976f, -0.06482869f, -0.04546161f, -0.04031942f, 0.18749051f, -0.26507095f, -0.33994985f, 
    0.33531690f, 0.00047945f, -0.16076367f, 0.14650233f, -0.17553930f, 0.09011447f, 0.02699134f, 0.03843723f, 
    -0.01192013f, -0.22436920f, 0.06664570f, 0.82967663f, -0.43739751f, 0.07662950f, -0.17402561f, 0.51401615f, 
    -0.33902431f, 0.54055130f, -0.96677333f, -0.44384837f, 0.07093865f, 0.13581479f, 0.32871246f, -0.17561832f, 
    0.03538457f, 0.36436996f, 0.56218058f, -0.27163827f, 0.26212198f, 0.04929895f, -0.22384191f, -0.23221989f, 
    0.46246588f, 0.31276935f, -0.18038657f, 0.25891683f, 0.00430443f, 0.17659530f, 0.28075203f, -0.03252915f, 
    -0.82051265f, -1.00699604f, -0.53331786f, -0.33377847f, -0.38709107f, -0.50592715f, -0.01766226f, -0.60629809f, 
    0.67143649f, -0.19633131f, -0.54788727f, 0.40247563f, 0.00995610f, -0.03830471f, -0.21034218f, -0.33745953f, 
    0.31489113f, 0.43460846f, 0.11188332f, 0.21799290f, 0.49751964f, -0.99001533f, -0.05837588f, -0.31009170f, 
    0.58741224f, 0.59555662f, -0.11485184f, -0.25918618f, 0.11202937f, 0.85798913f, 0.45874828f, -0.13165732f, 
    0.29516065f, 0.07474013f, -0.62824059f, 0.23628670f, -0.27906764f, 0.08110326f, 0.08447239f, -0.47489244f, 
    -0.42545325f, -0.09053911f, -0.13076238f, 0.39017776f, 0.35744533f, 0.29242370f, 0.93521184f, 0.06725092f, 
    -0.37603378f, -0.31652057f, -0.36888856f, 0.32682574f, 0.38271573f, 0.52198154f, -0.20599599f, -0.19498369f, 
    -0.19043890f, 0.92985135f, -0.26575482f, -0.74563098f, -0.19474670f, -0.51004809f, -0.14795572f, -0.01690368f, 
    -0.21465680f, 0.02104186f, 0.22368048f, 0.25264636f, -0.27531853f, 0.03924023f, 0.40080857f, 1.10839117f, 
    -1.76230812f, 0.04218989f, -0.35388455f, -0.12362801f, -0.13399732f, -0.29702857f, -0.13763162f, 1.23616862f, 
    -0.14968857f, 0.27520597f, -0.36519217f, -0.48518872f, -0.15749225f, -0.01253111f, -0.23775068f, 0.19647817f, 
    0.12926555f, 0.13283461f, 0.31790763f, -0.00870848f, -0.18622820f, 0.09697951f, -0.00740179f, 0.23792580f, 
    0.71032602f, -0.32531261f, 0.02974325f, 0.48578432f, 0.66278970f, 0.32921219f, 0.05317727f, 0.10823052f, 
    -0.48514497f, -0.55960709f, -0.06104422f, -0.44859502f, 0.40261170f, -0.17345735f, 0.02233260f, 0.23335020f, 
    -0.04991048f, 0.33588296f, 0.04637862f, -0.33906448f, 0.15565559f, -0.17894468f, -0.27952394f, -0.44762784f, 
    -0.35015401f, 0.87765998f, 0.72657400f, 0.87228036f, 0.09367937f, 0.62490493f, -0.35486445f, 0.06096669f, 
    0.42625919f, 0.30679029f, -0.06090938f, 0.04092593f, 0.02387882f, 0.02745096f, 0.09433978f, 0.37492308f, 
    0.16049348f, 0.21101207f, -0.14525503f, -0.25195503f, -0.32595029f, -0.08497626f, -0.03149240f, 0.09465239f, 
    0.02120632f, 0.07418648f, -0.22586054f, -0.76639330f, -1.09842253f, -0.70360351f, -0.06671673f, -0.93660212f, 
    -1.21200466f, -0.80596387f, -0.90430093f, -0.63841349f, 0.28370970f, 0.24067248f, 0.52707219f, -0.34509292f, 
    0.28926611f, 0.00791886f, 0.32445997f, 0.23488154f, -0.01819923f, 0.48253855f, 0.01139316f, -0.33909506f, 
    0.01768904f, 0.02775389f, 0.16330513f, -1.76187408f, -0.49269751f, -1.17253768f, -1.04632008f, -0.11326823f, 
    0.28423151f, -0.19040641f, -0.62153280f, -0.05597413f, 0.18261839f, -0.55479419f, -0.84539795f, -0.64099157f, 
    -0.39745957f, -0.28738073f, 0.17288323f, -0.13980770f, -0.08733164f, 0.02773605f, -0.34198946f, -0.08394536f, 
    -0.16495667f, -0.19907044f, -0.07635250f, -0.33113277f, 0.64416355f, 0.80071068f, 0.18075946f, 0.71862125f, 
    -0.57130557f, -1.16643000f, -1.19807982f, 0.05260297f, 0.74134976f, 0.45426187f, 0.30572322f, 0.02038093f, 
    0.06685246f, 0.14517239f, -0.57868665f, -0.28893098f, 0.42643869f, 0.40179512f, -0.30758786f, -0.40062627f, 
    0.14275123f, 0.11203565f, 0.08194010f, -0.03411917f, 0.04232948f, 0.38840276f, 0.07983801f, 0.10972847f, 
    0.28042293f, -0.10025024f, 0.37080228f, 0.20739351f, 0.03190377f, 0.17744212f, 0.28146139f, -0.27915007f, 
    0.34507090f, 0.02971775f, -0.36426806f, -0.22243820f, -0.30470294f, -0.17939003f, -0.19479229f, -0.20502955f, 
    -0.40736434f, -0.33602896f, -0.36835042f, -0.40877920f, -0.79472131f, -0.70416158f, -1.08617580f, -0.93837506f, 
    1.03578329f, 0.26143897f, 0.51263350f, 0.37025759f, 0.04014451f, 0.95644546f, -0.94666880f, -0.67632401f, 
    -0.44607219f, 0.23821618f, 0.04290222f, -0.05032464f, 0.00699937f, -0.35755333f, 0.20555566f, -0.20814425f, 
    0.02840330f, 0.44475353f, 0.04028428f, -0.20978925f, -0.33322293f, 0.08767760f, 0.15711817f, 0.08047406f, 
    0.89887774f, -0.04218940f, -0.63380474f, -0.92218184f, -1.14622223f, -0.98151165f, -0.42958331f, -1.05641913f, 
    -1.36716962f, -0.03037136f, -0.23353939f, 0.83459836f, -0.46835908f, 0.14127338f, -0.25860325f, -0.39409423f, 
    -0.12059642f, 0.25563431f, -0.39993033f, 0.08719929f, -0.18891478f, -0.15281324f, -0.17321531f, 0.16680519f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.45853490f, 0.19441739f, 0.79731745f, 0.33406687f, 0.45513925f, 0.85148877f, 0.64382672f, 0.48870370f, 
    0.28420427f, -0.21046850f, -0.18552417f, 0.15295349f, 0.60004431f, 0.24090016f, 0.50187749f, 0.12782976f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.38249761f, 0.32573348f, -0.20836201f, -0.29289258f, 0.03267695f, 0.25848338f, 0.22099143f, -0.06131722f, 
    -0.00026344f, 0.06189675f, -0.07840020f, -0.12002747f, -0.64444381f, -0.13056251f, 0.22820532f, 0.03960962f, 
    -0.15853611f, 0.01922093f, -0.25349361f, 0.31962588f, 0.05478851f, 0.04474689f, 0.05291829f, -0.22098407f, 
    -0.42699304f, -0.86447561f, -0.22407067f, 0.44360355f, 0.07439471f, 0.06300527f, -0.20038889f, -0.03762394f, 
    -0.17561226f, 0.02330219f, -0.00433202f, 0.00557730f, 0.02250104f, 0.15483239f, -0.10369949f, 0.03146587f, 
    -0.13667841f, -0.28262773f, 0.04670538f, -0.67213565f, -0.02779736f, 0.12474864f, -0.05680037f, -0.21675044f, 
    0.32248577f, 0.21334472f, -0.04505049f, -0.57146412f, -0.02787243f, 0.11463097f, 0.10631881f, 0.07233401f, 
    0.01561824f, -0.03916851f, -0.07499939f, -0.04645215f, -0.35067049f, 0.16364551f, 0.23874621f, -0.13888016f, 
    -0.04017608f, 0.07898185f, 0.15327081f, -0.00736181f, -0.06833041f, -0.30798891f, -0.05826229f, -0.46266058f, 
    -0.37359077f, -0.65653473f, -1.29810226f, 0.15486091f, 0.03412042f, -0.02788040f, -0.16298389f, -0.00519950f, 
    -0.18059018f, -0.06289271f, -0.17936008f, -0.41220129f, 0.29352340f, -0.04055785f, -0.06272973f, -0.63640928f, 
    0.15399022f, -0.25753412f, 0.40589222f, 0.00805864f, 0.06913774f, 0.15621114f, 0.07212300f, -0.08847211f, 
    -0.30157048f, -0.74276292f, 0.21082397f, 0.11411560f, -0.02034329f, -0.11123672f, -0.01468390f, -0.01350130f, 
    0.01701319f, 0.05769826f, -0.21687827f, -0.03014626f, -0.12590690f, -0.01467671f, 0.04147917f, 0.23660140f, 
    0.09076655f, 0.07821648f, 0.06607120f, 0.09266967f, 0.04271951f, 0.15396827f, 0.08083890f, 0.07883789f, 
    0.75338835f, 0.42395261f, -0.26230699f, -0.28655726f, 0.26779675f, 0.13646796f, 0.00382747f, -0.06603371f, 
    -0.06670403f, 0.08636022f, 0.10611913f, -0.00733173f, 0.45891821f, 0.37180018f, 0.02694544f, -0.22818570f, 
    0.11435139f, 0.41071159f, 0.09213077f, 0.05695421f, -0.11377386f, -0.02889985f, -0.15272102f, -0.08359656f, 
    -0.25806504f, -0.41808131f, 0.43202025f, -0.80991888f, -0.15189411f, 0.11872984f, -0.16707486f, 0.11697607f, 
    -0.08614916f, -0.17034024f, -0.02274110f, 0.11457690f, -0.53733838f, -0.27811849f, -0.10110966f, 0.22360311f, 
    0.02389626f, 0.02648441f, 0.07015462f, 0.00281311f, -0.21478434f, 0.19919431f, -0.12197939f, 0.14772314f, 
    0.65048397f, -0.24926747f, 0.05369731f, -0.21181865f, -0.31520084f, -0.32458085f, 0.04985643f, -0.22886954f, 
    -0.23990756f, -0.33661371f, -0.03982820f, -0.22798640f, 0.32204476f, 0.19044362f, -0.27585125f, -0.11195109f, 
    0.24120562f, -0.17464489f, -0.01252249f, 0.18824573f, 0.07842582f, -0.02908069f, -0.10482796f, -0.07249299f, 
    0.06008895f, 0.00876718f, -0.56627214f, -0.04394358f, -0.02513758f, -0.05344456f, 0.04857378f, -0.00429160f, 
    -0.08197268f, -0.23216465f, -0.21531135f, -0.08277839f, -0.47298875f, -0.05443721f, 0.14377262f, -0.10924768f, 
    0.09226838f, -0.19984800f, -0.08348936f, 0.07787792f, 0.12103894f, 0.03247766f, -0.38853550f, -0.15050642f, 
    0.65428638f, -0.33705914f, 0.28868839f, -0.25705966f, -0.09644461f, -0.10241638f, 0.09130456f, -0.04474590f, 
    -0.06397457f, 0.00861004f, -0.07063270f, -0.13611583f, 0.11247559f, -0.12411232f, -0.08013234f, -0.08485216f, 
    -0.06303658f, 0.00085519f, -0.07180052f, 0.13648531f, -0.18839537f, 0.12483066f, 0.00180831f, 0.09696802f, 
    -0.00582126f, 0.27828526f, 0.08529443f, -0.16952242f, -0.14724502f, 0.00301007f, 0.07784412f, 0.18558602f, 
    -0.08685887f, 0.07192343f, 0.04308959f, 0.08434287f, -0.43814227f, 0.10915997f, 0.11779483f, -0.00671176f, 
    -0.11317779f, 0.11913654f, 0.02103952f, -0.04196434f, 0.05891605f, 0.13078871f, 0.08277930f, 0.29529232f, 
    1.13544250f, 0.30603546f, 0.01766277f, -0.06119979f, 0.05907499f, 0.03754794f, -0.02131600f, 0.10209091f, 
    -0.02333582f, 0.02812060f, -0.23575392f, 0.30264789f, -0.05428363f, 0.24904944f, -0.31895700f, 0.33648339f, 
    -0.03901692f, 0.07072296f, -0.15522674f, -0.10274224f, -0.01711345f, -0.04027507f, -0.09202530f, -0.19542089f, 
    0.33117950f, 0.08334748f, -0.21411331f, 0.08651564f, 0.00531882f, -0.14390324f, -0.02203759f, 0.03444231f, 
    0.07856064f, -0.04920986f, 0.10277945f, 0.14204355f, 0.28002223f, 0.15642500f, 0.27772647f, 0.21123654f, 
    -0.10230450f, -0.06137387f, -0.13851357f, -0.14417160f, 0.06227848f, 0.14264885f, -0.02945830f, 0.04790573f, 
    -0.03691507f, 0.17258765f, -0.10202524f, 0.35421848f, -0.07589227f, 0.16259778f, 0.13174215f, -0.33547175f, 
    -0.03044978f, -0.06715746f, -0.09527580f, 0.07320537f, 0.19695434f, 0.36898354f, 0.10724089f, 0.15767674f, 
    0.27502608f, -0.16164868f, -0.16041897f, 0.01989416f, 0.03836269f, 0.09135763f, -0.18378530f, -0.32582942f, 
    -0.66289312f, 0.02617266f, 0.56597614f, -0.22971003f, 0.20711261f, -0.07976358f, -0.28343838f, 0.03182422f, 
    -0.04072141f, -0.10009135f, -0.09381796f, 0.04707261f, 0.36201239f, 0.17890038f, 0.25753704f, 0.01291926f, 
    -0.06481943f, 0.06416618f, -0.05529853f, 0.00581864f, -0.21704011f, -0.18030998f, -0.24818698f, -0.45322654f, 
    -0.30168971f, -0.48757198f, -0.23445280f, 0.01290300f, -0.07225669f, -0.14691314f, 0.13704012f, -0.01522567f, 
    0.39649761f, 0.21944498f, 0.15545887f, -0.05088416f, -0.01098841f, -0.12167959f, -0.31450027f, -0.17157243f, 
    -0.28413254f, -0.06384599f, -0.14991398f, -0.13617873f, -0.15725775f, 0.06011846f, 0.01648956f, 0.17685467f, 
    0.29347423f, 0.06969489f, 0.31942412f, 0.75729966f, 0.10373793f, -0.15225403f, 0.13167031f, 0.21362920f, 
    0.18048105f, -0.00638877f, 0.00400842f, 0.27217206f, 0.10619877f, -0.04665351f, -0.39262530f, -0.04468293f, 
    -0.02344278f, 0.17397875f, -0.03679246f, -0.06333525f, -0.03865292f, 0.20018668f, -0.00908780f, -0.06254727f, 
    -0.27634650f, -0.09964414f, 0.67754686f, -0.82718086f, 0.03460230f, -0.09666711f, -0.22134994f, 0.07780956f, 
    0.12612806f, 0.15725531f, -0.08854470f, 0.11067908f, -0.26831415f, -0.13326994f, 0.08014119f, 0.06833193f, 
    -0.38453397f, -0.12325917f, -0.38609979f, 0.44223070f, 0.21549530f, -0.08645540f, -0.11006069f, -0.07467332f, 
    -0.07217171f, -0.46587074f, -0.49049851f, -0.55015993f, 0.09790306f, 0.19071355f, -0.05361378f, -0.09049623f, 
    0.02659253f, -0.13014732f, -0.01253955f, -0.10453933f, -0.11688694f, -0.28597516f, -0.25238699f, 0.18116321f, 
    0.06299505f, -0.07707761f, 0.00491281f, -0.02707735f, -0.15570457f, 0.00006044f, -0.10220005f, -0.02517776f, 
    -0.30256152f, 0.31780690f, 0.12742807f, -0.48790476f, 0.00471455f, -0.01569848f, -0.16847399f, 0.16653185f, 
    0.17505848f, -0.16720234f, -0.20198670f, -0.02806560f, -0.31923369f, 0.52572054f, 0.07108213f, 0.17142415f, 
    -0.07431599f, 0.10920353f, -0.03113883f, -0.07698720f, -0.04483582f, 0.19698016f, -0.04890500f, -0.04279261f, 
    -0.13421333f, 0.17487848f, -0.15601186f, -0.02626017f, 0.02955624f, -0.07065362f, 0.02897138f, 0.19761392f, 
    0.06445039f, 0.10109289f, 0.20438555f, 0.03124094f, -0.36252615f, -0.52335596f, 0.00137770f, 0.05242414f, 
    -0.03077509f, 0.02885486f, 0.00114184f, 0.01031594f, 0.05640212f, 0.03089706f, -0.08052041f, -0.01009322f, 
    -0.62593746f, -0.68419343f, -0.30098805f, 0.05075479f, -0.07154676f, -0.00529665f, 0.05431223f, -0.05649973f, 
    -0.06428865f, 0.09676053f, 0.01536403f, -0.06617687f, -0.44127861f, 0.25456381f, 0.78298426f, 0.84661943f, 
    -0.02975779f, -0.05984492f, 0.09047977f, 0.02555528f, -0.03599956f, -0.00014550f, 0.09794084f, -0.05514961f, 
    -1.00372207f, 0.03473579f, 0.40460700f, -0.12649962f, 0.08132144f, 0.26273978f, -0.11230353f, 0.17174511f, 
    0.12557232f, -0.14732262f, 0.02455295f, 0.04624112f, -0.10278311f, -0.13550849f, -0.29054222f, -0.09058267f, 
    0.00819726f, -0.05257969f, 0.03562953f, 0.03144363f, 0.03978981f, 0.13237451f, 0.23655678f, 0.25014997f, 
    1.05368638f, 0.36394164f, -0.64268523f, -0.21874303f, -0.05253967f, 0.04834131f, -0.02479256f, 0.07017029f, 
    -0.01634455f, 0.16059241f, 0.10859624f, -0.10647755f, -0.75917715f, -0.58192354f, 0.03780212f, -0.74074697f, 
    0.32004988f, 0.02611754f, -0.09713272f, -0.35747427f, 0.00418770f, -0.13285716f, 0.03238219f, -0.09283577f, 
    0.45423061f, -0.11359306f, -0.24017435f, -0.26300722f, 0.36351287f, 0.18751803f, 0.10497251f, -0.05768544f, 
    -0.29916573f, 0.05510258f, -0.05537685f, 0.04809093f, 1.35843801f, 0.48007441f, 0.67725146f, -0.12962426f, 
    -0.55578697f, 0.23352532f, -0.04791637f, -0.13244693f, -0.17556357f, -0.01936066f, 0.17058678f, 0.18617497f, 
    -0.62446874f, 0.11520997f, 0.33378920f, 0.01097443f, -0.28608713f, -0.23254417f, -0.24396779f, -0.06771414f, 
    -0.04690638f, -0.11958587f, -0.04396282f, -0.00806507f, -0.27785724f, 0.23359653f, -0.60105544f, 0.50691372f, 
    -0.10000085f, -0.06414657f, -0.19989188f, -0.10590265f, -0.08876872f, -0.19492555f, 0.05309526f, 0.09510509f, 
    0.25685298f, 0.03224314f, 0.15143104f, 0.36067367f, 0.03180082f, -0.04503521f, -0.03488949f, 0.06166293f, 
    -0.04674078f, 0.14823535f, -0.10373954f, -0.28244212f, 0.35976765f, -0.06281392f, -0.10249253f, -0.82802409f, 
    0.27877876f, -0.08482805f, 0.04334334f, -0.06105093f, -0.18717922f, 0.35362050f, -0.39488095f, 0.04229131f, 
    -0.12495228f, 0.02857801f, -0.29298469f, 0.37706381f, 0.00344141f, -0.19603741f, -0.00287520f, -0.07806461f, 
    -0.04555925f, 0.10130380f, -0.18507344f, -0.00034739f, -0.96449560f, 0.17412411f, -0.12786570f, -0.16199733f, 
    -0.12982427f, 0.08368881f, -0.02353400f, -0.18565664f, -0.55881888f, -0.07368972f, -0.06054092f, 0.02769105f, 
    -0.35927829f, 1.27862358f, -0.12356245f, 0.53757632f, 0.09254990f, 0.19044560f, 0.16238169f, 0.14437376f, 
    0.04461882f, 0.45393214f, 0.29626864f, 0.26426199f, -0.82859540f, -0.79920238f, -0.12121840f, 0.00031408f, 
    -0.16905320f, -0.13540611f, -0.18967994f, 0.00412200f, -0.00447021f, 0.15356539f, 0.09304795f, 0.06053791f, 
    -0.06129790f, -0.22817005f, -0.27438059f, 0.25741538f, 0.11801003f, 0.06451381f, 0.07027138f, 0.05213662f, 
    0.06335918f, 0.12004728f, -0.13171065f, 0.07069141f, 0.33592993f, -0.18933316f, -0.20342562f, 0.19568421f, 
    0.02803299f, -0.05874133f, -0.01052181f, -0.11146798f, -0.04396437f, 0.15976062f, 0.10884219f, 0.30111858f, 
    0.13119678f, -0.19296010f, 0.20908166f, -0.41225749f, -0.12997593f, -0.02542813f, -0.30406785f, 0.02356103f, 
    0.09052625f, 0.19752964f, -0.23975000f, -0.04769832f, -0.18149859f, -0.01490328f, -0.15233673f, -0.02978369f, 
    -0.25775144f, 0.09505493f, -0.08675433f, -0.06650275f, 0.08289945f, -0.02542348f, -0.19889160f, 0.00375034f, 
    -0.91729403f, 0.99558347f, -0.18692689f, -0.42237055f, 0.03516410f, 0.10769963f, -0.19707827f, 0.03557293f, 
    -0.29845810f, -0.34522781f, -0.04437122f, 0.14955345f, 0.06676283f, -0.08166441f, 0.20313103f, 0.30239654f, 
    -0.05539566f, 0.11203688f, -0.08335752f, 0.21321243f, -0.05080027f, -0.05987879f, 0.06137987f, -0.11416221f, 
    0.23019899f, -0.45032904f, 0.08066447f, 0.17198300f, -0.35930115f, -0.00883399f, -0.11635527f, -0.10192004f, 
    -0.00648997f, 0.04530691f, -0.04406309f, 0.03551088f, 0.20842619f, -0.19495663f, -0.57490098f, -0.11926158f, 
    0.01812161f, -0.14461946f, 0.04719518f, 0.00283768f, 0.00858688f, 0.06463749f, 0.14753169f, 0.09724766f, 
    -0.09826013f, 0.07623307f, -0.58331037f, 0.22231084f, 0.17723848f, 0.09550323f, 0.00282043f, -0.01483685f, 
    0.02129824f, 0.11571635f, 0.06333294f, 0.04511200f, 0.14723477f, -0.12254855f, -0.02970790f, 0.02408496f, 
    0.15800275f, -0.14836308f, 0.10153128f, 0.07442837f, 0.01375976f, -0.12980156f, -0.23084578f, -0.11699059f, 
    -0.08611219f, 0.02577562f, 0.16946985f, 0.15464534f, -0.03453902f, 0.11270808f, -0.18462779f, 0.16207853f, 
    0.02297994f, -0.13864052f, -0.05656195f, -0.21674691f, 0.10896996f, 0.16850634f, -0.28686956f, 0.02045931f, 
    -0.03657770f, -0.02667462f, 0.07989798f, 0.03219936f, -0.36540380f, -0.53995132f, -0.31205055f, -0.34971067f, 
    -0.33230087f, 0.00513374f, -0.18437228f, -0.49788246f, 0.19541535f, -0.06056610f, 0.10031471f, -0.02498800f, 
    -0.04393290f, -0.08194993f, -0.11129192f, -0.39534292f, -0.10947862f, -0.27038744f, 0.06636640f, -0.07779560f, 
    0.01796864f, 0.06743009f, -0.11952033f, 0.27010572f, 0.07477314f, 0.13396072f, -0.21189263f, 0.11758937f, 
    0.14914887f, -0.39618504f, 0.51410872f, 0.00365349f, 0.14444466f, 0.06406090f, 0.09531469f, 0.06871752f, 
    0.13784611f, -0.19637202f, 0.10797524f, 0.09734306f, -0.01269551f, 0.11251752f, -0.01103947f, 0.01557415f, 
    0.08411108f, 0.17414217f, 0.08520769f, 0.02437105f, 0.10196299f, -0.02984830f, -0.00573578f, 0.00018070f, 
    0.21568094f, 0.36900368f, 0.48380485f, 0.24945122f, -0.26813501f, -0.13734740f, -0.04175411f, 0.03227011f, 
    0.08648710f, -0.00249109f, 0.01751464f, 0.04068964f, -0.25260359f, -0.20942451f, -0.02952705f, 0.13182449f, 
    -0.06261180f, 0.14592788f, -0.26133680f, -0.09004120f, -0.05812494f, -0.01223422f, 0.09416470f, 0.17678551f, 
    -0.13735493f, -0.20496331f, -0.37518400f, 0.38970664f, -0.30973643f, -0.19086723f, 0.08468198f, 0.10101943f, 
    0.06749140f, -0.09800368f, 0.04072488f, -0.10593575f, 0.06503604f, -0.26262334f, -0.13374807f, -0.10519320f, 
    0.07170422f, -0.06877206f, 0.15528527f, -0.01049933f, 0.09975237f, 0.07487339f, 0.08210484f, 0.43404704f, 
    0.01384915f, -0.87617648f, 0.19219503f, -0.03889441f, 0.05071349f, 0.01120519f, -0.04023476f, -0.10828789f, 
    -0.23743699f, -0.00877301f, -0.05121084f, -0.28133014f, 0.11728943f, 0.43828341f, 0.23119526f, 0.24251987f, 
    0.11680655f, 0.03459913f, 0.30932406f, 0.30587414f, -0.00062865f, -0.09631166f, 0.02932645f, -0.12166607f, 
    -1.32950687f, -0.01185874f, 0.02749103f, -0.54991573f, -0.01533696f, -0.06522185f, -0.02211241f, 0.21242167f, 
    0.01227058f, -0.02893846f, 0.06192254f, 0.07944990f, -0.16733223f, -0.21368742f, -0.23304825f, 0.14008877f, 
    0.13265407f, 0.17467137f, -0.15065360f, -0.15925513f, -0.30379286f, -0.29371098f, 0.04919638f, 0.01395871f, 
    -0.17737891f, 0.09672842f, -0.92533737f, 0.28129059f, 0.13755442f, -0.01320598f, 0.02919129f, -0.04030345f, 
    0.15025957f, -0.19826154f, -0.08674984f, -0.02331176f, -0.12158813f, -0.04038919f, 0.02746384f, -0.21723561f, 
    0.09707057f, 0.16184597f, 0.27660054f, 0.08827385f, 0.25159875f, -0.28349760f, -0.02488309f, 0.17917788f, 
    0.04847576f, 0.21034446f, -0.07167742f, 0.05321131f, 0.17830275f, 0.02370476f, 0.13420089f, 0.03595024f, 
    0.19571097f, -0.02447877f, 0.19573015f, 0.28648686f, -0.21638265f, -0.27564025f, 0.24372202f, 0.43570420f, 
    -0.32508954f, -0.10176647f, -0.16372173f, 0.00695594f, 0.23815826f, 0.04901767f, 0.24487850f, 0.28572083f, 
    -0.40651909f, -0.41553518f, -0.28492332f, 0.08414105f, 0.07226208f, 0.08744404f, -0.06552370f, -0.18581747f, 
    0.30853269f, -0.21581404f, 0.40310231f, 0.11748195f, 0.70126927f, -0.37606788f, -0.17215168f, -0.28979513f, 
    0.02568713f, 0.06406458f, -0.08621897f, -0.13123555f, 0.11908965f, -0.08666185f, 0.25195724f, 0.16089556f, 
    -0.04362277f, -0.11919145f, 0.03540923f, -0.14713575f, -0.10569772f, -0.04445418f, 0.05287133f, -0.18697885f, 
    -0.15653500f, 0.09132366f, -0.10709809f, -0.23302273f, -0.30247349f, -0.17558837f, 0.09686153f, 0.17543209f, 
    0.03483329f, 0.10295823f, -0.14291069f, 0.02623937f, -0.06212488f, -0.21925513f, 0.04507688f, -0.07152031f, 
    0.11668523f, -0.04231157f, 0.17693445f, -0.29356027f, 0.30540264f, 0.23599187f, -0.17327818f, 0.04312581f, 
    -0.05485460f, -0.05828249f, 0.10465509f, 0.01110374f, -0.25215721f, 0.19434020f, 0.27747038f, -0.42255443f, 
    -0.05857498f, -0.16371769f, 0.15711226f, 0.16394237f, 0.01465972f, -0.14452220f, -0.04649629f, -0.05625809f, 
    0.62280613f, 0.07515170f, -0.43140844f, 0.36303174f, 0.03375479f, -0.14624265f, -0.03543060f, -0.01197853f, 
    0.01414024f, 0.14007726f, 0.05944410f, -0.09291203f, 0.20253652f, -0.38880241f, -0.23387663f, 0.16396505f, 
    0.13957028f, -0.00623095f, 0.10537054f, 0.08911417f, 0.04796279f, -0.61419076f, 0.12222380f, -0.59605736f, 
    0.22705568f, 0.21753918f, -0.15079084f, 0.50033635f, 0.09105173f, -0.10059638f, 0.01042891f, 0.17275730f, 
    0.01800543f, 0.03994372f, -0.19966052f, 0.11849968f, 0.06057229f, 0.28310144f, -0.01806243f, 0.13034046f, 
    0.22321576f, 0.24558511f, -0.20482387f, -0.45282775f, -0.02062582f, -0.04870646f, 0.05185207f, 0.00961220f, 
    -0.45412385f, 0.20474851f, 0.78545052f, 0.23214053f, 0.01378387f, -0.14657918f, 0.05244020f, 0.16373233f, 
    0.15531969f, 0.19699031f, 0.26996145f, -0.06789188f, 0.02259330f, -0.03278206f, 0.17474428f, -0.24970576f, 
    -0.03432310f, 0.26302078f, 0.26637024f, 0.15581146f, 0.07100541f, 0.11119617f, 0.11980662f, -0.01709730f, 
    0.81300193f, -0.42871320f, 0.12771799f, -0.26249251f, -0.02499461f, -0.01076426f, 0.34982511f, -0.14916973f, 
    -0.06444082f, 0.04951388f, 0.03922340f, 0.15123849f, 0.02285505f, -0.20413040f, -0.18929355f, 0.27368897f, 
    0.00356254f, 0.05163736f, -0.12720059f, 0.14528379f, -0.01354421f, -0.10283667f, -0.13526334f, -0.00502334f, 
    -0.67139155f, -0.35569602f, -0.82629120f, -0.59437501f, 0.03241903f, -0.34049752f, 0.05059066f, -0.42367905f, 
    -0.06290486f, 0.04474821f, -0.23834726f, -0.21233477f, 0.02494534f, -0.09153530f, 0.04656493f, 0.23799248f, 
    -0.08515315f, -0.06266356f, -0.16462404f, 0.32552984f, 0.03031298f, 0.13829920f, 0.17422354f, -0.03246776f, 
    -0.04928115f, 0.34120905f, 0.10452157f, -0.00318730f, 0.21011576f, -0.22318144f, 0.18566824f, -0.22431643f, 
    0.18578184f, 0.07251170f, -0.08496148f, 0.08363890f, -0.49699283f, 0.33436331f, -0.41619772f, 0.91100645f, 
    0.01017013f, -0.02289684f, 0.27398548f, 0.24240947f, 0.07006134f, 0.10683551f, 0.06268872f, 0.05371337f, 
    -0.22696958f, 0.03713347f, -0.09362413f, 0.18782003f, 0.19627073f, 0.08927654f, 0.09953064f, 0.02327641f, 
    0.04613275f, 0.03935301f, 0.05585358f, 0.10424753f, 0.17122908f, -0.28624529f, -0.27696931f, -0.31162024f, 
    -0.00331354f, 0.16769709f, 0.11008801f, 0.07808924f, -0.17712556f, -0.19881698f, -0.10825396f, -0.03776556f, 
    -1.32524335f, -0.50059211f, -0.06251187f, -0.17677677f, -0.47865388f, -0.19105521f, -0.26948556f, -0.10610019f, 
    0.11948197f, -0.08538642f, -0.00292761f, 0.00082592f, -0.34027758f, -1.35759938f, -0.28219578f, 0.32394609f, 
    -0.27452388f, 0.13348944f, -0.13900428f, 0.02775394f, -0.05814315f, 0.01375793f, 0.08777595f, 0.07081901f, 
    0.43265611f, -0.39281321f, -1.08135903f, -0.48894772f, -0.08257273f, 0.27698272f, 0.23688972f, -0.29717794f, 
    -0.01176886f, 0.16898213f, -0.16798598f, -0.16728543f, -0.02743468f, 0.10016637f, -0.04964826f, -0.13443165f, 
    -0.03209523f, 0.05867536f, 0.15383491f, 0.07563192f, -0.00860063f, 0.32410842f, 0.21069556f, 0.27556932f, 
    -0.79531556f, 0.00621124f, 0.22118224f, 0.38023317f, -0.07394666f, -0.04891760f, -0.11538324f, -0.17169732f, 
    -0.29366785f, 0.06744582f, 0.03693301f, 0.09045216f, -0.38080743f, -1.58107805f, -0.47942248f, -0.46899542f, 
    -0.08719193f, -0.04169756f, 0.21946022f, -0.29676655f, 0.00746789f, -0.11560871f, -0.16779906f, 0.10441378f, 
    1.15209508f, 0.01421633f, -0.51419598f, -0.53779042f, 0.05001553f, 0.04638295f, -0.41062331f, 0.08451449f, 
    0.04580293f, 0.03080095f, -0.05444296f, -0.09703217f, 0.10158248f, 0.32668385f, -0.03587667f, 0.39556834f, 
    -0.02099541f, 0.20324990f, 0.02173497f, -0.30451480f, -0.24709301f, 0.06886782f, -0.20687185f, 0.27160913f, 
    -0.23752554f, 0.34637380f, -0.09503593f, 0.05317567f, -0.01015368f, 0.02293524f, -0.05078785f, -0.02480279f, 
    0.05915416f, 0.06808659f, 0.11418445f, -0.06864180f, -0.10752915f, 0.01910475f, 0.30555636f, -0.13671516f, 
    -0.20232870f, -0.26283962f, 0.04728387f, -0.33991131f, 0.14265439f, -0.02676841f, 0.02139010f, -0.01756379f, 
    -1.39941192f, -0.34488550f, -0.19548766f, 0.71734494f, 0.07905532f, 0.11046750f, -0.15341263f, -0.21689498f, 
    -0.02646641f, -0.07309671f, 0.00618554f, 0.08762058f, 0.53344333f, -0.13775380f, -0.07503565f, -0.47782090f, 
    0.03904733f, -0.05698758f, 0.03590661f, 0.00207285f, 0.07112342f, -0.13319340f, -0.04945116f, -0.67112976f, 
    -0.19357762f, 0.05756642f, 0.16713718f, 0.13737874f, -0.08298647f, 0.02661580f, 0.17503314f, -0.04900730f, 
    -0.02417146f, 0.08919368f, 0.03769284f, -0.22328459f, -0.20098664f, -0.54516244f, 0.40054142f, -0.54383528f, 
    -0.20155829f, 0.11738281f, 0.26221317f, -0.16513997f, -0.12435406f, 0.03853045f, -0.16565184f, 0.08576206f, 
    0.16323130f, -0.04673855f, 0.01593768f, -0.09177188f, 0.03243999f, -0.19510491f, -0.01378112f, -0.03047930f, 
    0.07527968f, 0.05720998f, 0.00851120f, 0.06501578f, 0.00082569f, 0.03497919f, -0.03568508f, 0.08499862f, 
    -0.02497418f, -0.07913093f, -0.06172067f, -0.07643329f, 0.07442911f, -0.03259869f, 0.05101862f, -0.10338599f, 
    -0.93073565f, -0.64963305f, -0.28231776f, -0.01383706f, 0.11891188f, 0.02333425f, 0.05553500f, 0.35572097f, 
    0.02649503f, 0.02928190f, -0.08649293f, 0.09790472f, 0.15591609f, -0.77911574f, -0.09842349f, -0.63770235f, 
    -0.08581875f, -0.09264497f, 0.01527197f, 0.32292056f, 0.02897282f, -0.17632119f, -0.08586355f, 0.03367270f, 
    -0.23183013f, -0.51554596f, 0.14646699f, 0.07194293f, -0.10152883f, 0.08871875f, -0.31686142f, -0.08003131f, 
    0.04481316f, 0.03775521f, 0.05887404f, -0.02109090f, 0.06485412f, 0.16777121f, 0.11803538f, -0.05262114f, 
    0.06486508f, -0.01732075f, -0.02514486f, 0.01594322f, 0.23025629f, 0.00833937f, 0.11093303f, -0.03713262f, 
    0.05969453f, 0.22596203f, -0.74320447f, -0.34266028f, -0.02471827f, -0.15000546f, -0.07715999f, -0.18447326f, 
    -0.09310022f, 0.21288784f, 0.00107513f, -0.22505032f, -1.19923389f, 0.62797725f, -0.01843251f, 0.75042063f, 
    -0.15940858f, -0.12003435f, 0.07406496f, 0.07451487f, -0.00712807f, -0.09439969f, -0.01430935f, -0.02381203f, 
    -0.06259237f, -0.44229311f, -0.64966172f, -0.41106072f, 0.00331363f, 0.27214739f, 0.44045869f, 0.02928716f, 
    -0.05279193f, -0.18643117f, -0.07768753f, -0.30771986f, -0.26928085f, -0.06074509f, 0.24019866f, 0.06505276f, 
    0.15679179f, -0.16302867f, 0.02096048f, 0.05255767f, -0.09060436f, -0.10841479f, 0.20189092f, -0.19658962f, 
    -1.06952775f, 0.32251313f, 0.22105230f, 0.43536639f, 0.11605088f, -0.22718759f, -0.30489621f, 0.08271956f, 
    -0.19345318f, -0.22537929f, 0.00279892f, 0.01894852f, 0.15845190f, -0.05001215f, 0.10358661f, 0.04143185f, 
    -0.02625434f, 0.13681452f, -0.19881144f, -0.10105836f, 0.13488501f, 0.43511957f, 0.18148907f, 0.15801160f, 
    -0.14132185f, -0.61984688f, 0.24160962f, 0.42974934f, 0.03339183f, -0.07425660f, 0.00350312f, -0.06750041f, 
    -0.11220350f, 0.30136263f, 0.05544079f, 0.20699430f, 0.40835392f, -0.24930222f, -0.26300025f, -0.45658734f, 
    -0.06109602f, -0.09656915f, -0.00283418f, -0.07526741f, 0.33835891f, 0.19330642f, 0.31026265f, 0.38425866f, 
    -0.55428052f, -0.04035967f, 0.25781858f, 0.29925588f, -0.26642334f, 0.01151058f, 0.09385843f, -0.10602015f, 
    0.13170570f, 0.10025446f, 0.33440739f, 0.26534417f, 0.41501984f, 0.10252313f, 0.00675955f, -0.18362655f, 
    0.14734884f, -0.13684507f, -0.14300519f, -0.02609162f, 0.00119201f, -0.07828467f, -0.08803186f, 0.18580307f, 
    -0.28133741f, 0.06778055f, 0.00528201f, -0.17308372f, -0.23883779f, -0.10693935f, -0.12423444f, -0.39617667f, 
    -0.31152436f, -0.41836494f, -0.40864792f, -0.20507754f, -0.44721568f, 0.23189837f, 0.15740019f, -0.14749061f, 
    0.06004025f, -0.19683267f, -0.18379202f, -0.00827388f, -0.09545822f, -0.12967077f, 0.05209624f, 0.07046012f, 
    -0.22565308f, -0.58056086f, -0.36365336f, -0.00153481f, 0.04422778f, 0.05799064f, 0.18254076f, -0.08359481f, 
    -0.08756258f, -0.12013227f, 0.00272879f, -0.01333164f, 0.40118563f, -0.37045729f, -0.70126945f, -0.16889437f, 
    -0.03137762f, -0.03890042f, 0.25698587f, 0.03740230f, 0.03805264f, 0.11166793f, -0.08144455f, -0.08230554f, 
    0.29425290f, 0.79051226f, -0.21122655f, 0.16266243f, 0.37126115f, -0.18493988f, -0.11423851f, -0.00456656f, 
    0.01834030f, 0.09802946f, 0.09516665f, 0.24468561f, -0.44719213f, 0.06136594f, 0.10936204f, -0.18896608f, 
    -0.02958503f, -0.12003054f, -0.13454133f, 0.00888586f, 0.06711011f, -0.00501284f, -0.32784915f, -0.30713621f, 
    0.31610328f, 0.08405833f, -0.53546429f, -0.42988148f, -0.05330704f, -0.05712674f, 0.04478290f, 0.06098102f, 
    0.16666287f, -0.05525248f, 0.05693711f, 0.15919808f, -0.32501477f, -0.56416118f, -0.03288732f, 0.10953305f, 
    -0.17671783f, 0.05448930f, -0.08004097f, 0.13555098f, 0.04782836f, 0.14578465f, 0.15039244f, 0.15190834f, 
    -0.22496435f, 0.23693018f, 0.38318253f, 0.53147167f, -0.02359493f, -0.03264395f, -0.50157750f, -0.43138197f, 
    0.07735328f, -0.09250060f, 0.02575137f, 0.24719015f, -0.66752571f, 0.25624466f, -1.14709401f, 0.22660108f, 
    0.21985742f, -0.30933517f, 0.25283530f, -0.24147713f, 0.38929617f, -0.00872452f, 0.07315733f, 0.16397548f, 
    -0.40666556f, 0.55445552f, -0.76593399f, -0.16715492f, -0.09862252f, 0.24869786f, 0.27287817f, 0.04488549f, 
    0.01860009f, -0.15193641f, 0.07388556f, 0.08063444f, 0.26763943f, -0.45580125f, 0.06493212f, -0.46639296f, 
    0.43942684f, 0.07217585f, -0.05004430f, -0.09648073f, 0.10645337f, -0.26362774f, -0.31803963f, -0.31794250f, 
    -0.36702415f, 0.26147121f, -0.77953827f, -0.38254556f, -0.05254706f, -0.16128422f, 0.11861994f, -0.00157175f, 
    -0.01810679f, 0.00529304f, -0.16789058f, -0.14180957f, 0.13306606f, 0.24919157f, 0.40454489f, 0.41515744f, 
    0.18958753f, -0.12174464f, -0.24141181f, -0.12148539f, 0.07827949f, 0.07556988f, -0.10531274f, -0.04699451f, 
    -0.01933563f, -0.04481562f, 0.20527528f, -0.62887931f, 0.02536801f, 0.06183163f, 0.04817815f, 0.06752512f, 
    0.03594702f, 0.16905294f, -0.20005922f, -0.00720457f, -0.02530563f, -0.64500183f, 0.24851249f, -0.52562070f, 
    -0.10991935f, -0.22634764f, -0.07488704f, -0.13451587f, -0.01349331f, -0.12730530f, 0.22341655f, 0.03498163f, 
    -0.02428302f, -0.46487096f, 0.16624503f, -0.02432670f, 0.12277885f, 0.14907637f, 0.24956462f, 0.14113618f, 
    -0.03042391f, 0.05947793f, -0.11735158f, 0.09909308f, -0.27945313f, 0.12851235f, -0.53333831f, -0.00538726f, 
    0.21483321f, 0.04107044f, 0.26902756f, -0.06076344f, 0.10048950f, -0.19973953f, 0.18704776f, 0.05639139f, 
    -0.58463401f, 0.14524701f, 0.26127499f, -0.32332215f, -0.12959462f, -0.38663089f, 0.30086440f, 0.19592437f, 
    -0.03238157f, 0.02518220f, 0.00506723f, -0.00157465f, -0.08990577f, -0.12141847f, 0.17291971f, 0.09599327f, 
    0.07651591f, 0.07045791f, -0.02047922f, -0.04045479f, 0.09682102f, 0.12412097f, 0.07080178f, 0.03867400f, 
    -0.17401229f, 0.25631818f, -0.94096690f, 0.51293421f, -0.02862084f, 0.13959858f, 0.25590244f, -0.13479109f, 
    0.12352567f, 0.04506724f, -0.16421692f, 0.01302198f, 0.02139970f, -0.19472012f, 0.34685525f, 0.15231340f, 
    0.04714579f, 0.04789303f, 0.12856737f, -0.00316826f, 0.08153284f, 0.24313237f, 0.16002509f, 0.10803440f, 
    -1.10447347f, 0.11782815f, -0.27354544f, -0.05115995f, -0.01021377f, 0.12843361f, -0.32837066f, 0.00405706f, 
    0.09111757f, -0.03627167f, -0.06803637f, -0.00348447f, -0.12599604f, 0.77465141f, -0.75241983f, -0.27917051f, 
    -0.14336582f, -0.28397983f, 0.25688407f, 0.12297684f, -0.01395582f, 0.05358528f, -0.03365383f, -0.03268493f, 
    0.20307745f, 0.35796642f, 0.35404494f, -0.43367070f, 0.03745459f, -0.12695275f, -0.32513121f, -0.22349423f, 
    -0.24611570f, -0.01053767f, -0.07975665f, -0.51208586f, 0.77285278f, -0.13407975f, 0.09373602f, -0.21086545f, 
    -0.38731137f, 0.32627788f, 0.05732777f, 0.00265169f, -0.01180138f, -0.11683750f, -0.27722865f, -0.13749810f, 
    0.18075082f, -0.49317223f, 0.40766528f, 0.06783954f, -0.22001328f, -0.23944947f, 0.11550611f, 0.03853904f, 
    -0.10188581f, 0.03503705f, 0.21058021f, -0.00333381f, -0.47364011f, 0.36664435f, 0.26320204f, 0.10607766f, 
    0.19769898f, -0.05264411f, 0.40607852f, 0.11979182f, -0.27336663f, 0.10831618f, 0.39080977f, 0.21004288f, 
    -0.07407957f, -0.06571939f, 0.35519743f, 0.22051504f, -0.18560435f, 0.11211143f, 0.01134778f, 0.21011262f, 
    0.07133492f, 0.23076926f, 0.09915772f, 0.29603314f, -0.35255778f, 0.30388609f, 0.05771204f, -0.32013980f, 
    -0.35778394f, 0.02234773f, 0.16527575f, -0.18308766f, -0.03205032f, -0.17442338f, 0.14505714f, 0.15424092f, 
    0.20671558f, -0.11101050f, 0.61877507f, 0.33428857f, -0.08610930f, 0.02802436f, 0.07340873f, 0.13267261f, 
    0.17387371f, -0.39903885f, 0.41840550f, 0.24192126f, -0.69353044f, 0.87027711f, 0.00456960f, 0.15558966f, 
    0.20715560f, -0.00543989f, 0.01462120f, 0.29792452f, -0.24960518f, 0.10773202f, 0.01406164f, -0.22689424f, 
    -0.32958075f, 0.06377409f, -0.33978730f, -0.02193761f, -0.40547469f, 0.16264968f, -0.34537026f, 0.15844724f, 
    -0.05840505f, -0.46117362f, 0.01176880f, -0.03359561f, -0.15521203f, -0.96032816f, -0.91893470f, -0.92555809f, 
    0.11134108f, -0.31027430f, 0.08384567f, 0.10468549f, -0.20944427f, 0.17618714f, -0.15240096f, -0.31539202f, 
    -0.55917180f, 0.22238509f, -0.11042719f, 0.14310603f, 0.11854067f, 0.06856425f, -0.32921293f, 0.01882449f, 
    -0.14933483f, 0.08569697f, 0.04613204f, -0.04080588f, -0.13388936f, -0.29196274f, -0.55339634f, -0.16852373f, 
    -0.12969910f, 0.00837115f, 0.15217838f, -0.12677453f, -0.08550612f, 0.07054055f, -0.14722382f, -0.37195534f, 
    -0.25765175f, 0.31979534f, -0.67021763f, -0.10375544f, -0.33800736f, -0.02408339f, 0.24938419f, 0.01226236f, 
    -0.11180159f, 0.15361048f, 0.10218047f, 0.18799302f, -0.23290704f, 0.28355283f, -0.09470752f, -0.41946545f, 
    0.02704777f, -0.09378502f, -0.05595142f, 0.21653442f, -0.11558625f, -0.29152843f, -0.42678806f, -0.21811455f, 
    0.22145739f, -0.48875284f, 0.69779336f, 0.48095602f, -0.10834073f, -0.03968863f, 0.32323983f, 0.25017229f, 
    -0.02790513f, -0.04826517f, 0.11126582f, 0.04967874f, -0.02627795f, -1.05790102f, 0.45632511f, 0.10396994f, 
    -0.27995285f, -0.10051028f, 0.10298079f, -0.03032420f, 0.12503466f, 0.14093651f, -0.03625029f, 0.00912934f, 
    -0.73448098f, -0.35728756f, -0.48351616f, -0.00074176f, 0.08981415f, -0.03871495f, 0.00756409f, -0.01644311f, 
    0.12511346f, -0.15006746f, 0.07331331f, 0.10579034f, 0.38118735f, -0.56900835f, 0.51223266f, -0.19843771f, 
    0.03858117f, -0.16110030f, -0.01388491f, 0.36318004f, 0.11335207f, 0.04044178f, 0.24335818f, 0.17592239f, 
    0.10851917f, 0.02038095f, 0.39432886f, 0.06076683f, -0.19052769f, 0.08513881f, -0.02655186f, -0.11069560f, 
    -0.22831012f, 0.04288720f, 0.04920347f, 0.00650076f, 0.07341234f, 0.51991570f, -0.42199165f, 0.35508740f, 
    -0.04467542f, 0.14855903f, -0.17672502f, -0.03353711f, -0.25368425f, -0.05550337f, -0.07143507f, -0.45460790f, 
    0.21337953f, -0.20475921f, 0.54585505f, 0.01022902f, -0.04699697f, -0.27266777f, -0.25057873f, -0.37828600f, 
    0.01037033f, -0.07403576f, -0.03453974f, -0.22166555f, -0.43514293f, -0.26831234f, -0.32698143f, 0.18396083f, 
    0.30761907f, 0.02048444f, -0.11899185f, 0.05637588f, -0.10543555f, 0.15474997f, -0.15822971f, -0.30367488f, 
    -0.27927101f, -0.29547438f, -0.32992294f, 0.47960287f, -0.37391174f, 0.20976904f, -0.00431322f, 0.30323279f, 
    -0.43421194f, 0.11748658f, 0.10370706f, -0.22339179f, 0.19432618f, -0.41804665f, 0.55168551f, 0.70357883f, 
    0.10445292f, 0.02525294f, -0.00530533f, -0.11896149f, -0.15483326f, -0.19004211f, -0.02370396f, 0.09564667f, 
    0.03034399f, 0.18832210f, -0.10064046f, -0.34761745f, -0.23603295f, 0.12526330f, 0.06984813f, -0.00614206f, 
    -0.12767120f, 0.24695845f, 0.03932695f, -0.19067281f, 0.69855005f, 0.22911470f, -0.03151936f, -0.39328474f, 
    -0.20939660f, 0.18204728f, -0.13975433f, 0.15046287f, -0.35780105f, 0.02945931f, -0.08916309f, -0.19618435f, 
    -0.35883167f, -0.62559360f, -0.18222824f, -0.12839475f, -0.26321033f, -0.37692249f, -0.07813749f, -0.12238140f, 
    0.01091212f, 0.10018795f, -0.13880244f, -0.16458142f, -0.07152532f, -0.26573771f, 0.06243223f, -0.20930985f, 
    -0.22291403f, -0.02970547f, 0.17843363f, -0.02420369f, 0.02261152f, 0.14937036f, 0.17893182f, 0.14112848f, 
    0.61018401f, -0.14729926f, 0.76666492f, 0.12682717f, 0.11238152f, -0.08898786f, 0.09246941f, -0.06492859f, 
    -0.17270593f, -0.02626954f, 0.00607743f, -0.13149960f, -0.09558988f, 0.06442329f, -0.33189377f, 0.00053457f, 
    0.01076014f, 0.00513380f, -0.15305266f, -0.09360807f, 0.03303776f, 0.34940165f, 0.06091166f, 0.20872864f, 
    -0.51219827f, 0.16254307f, 0.90698284f, -0.42171171f, 0.30589581f, 0.68280751f, 0.19188011f, -0.22041334f, 
    -0.01371366f, 0.05270701f, 0.08697370f, 0.30727321f, 0.08994592f, -0.64593524f, 0.79307693f, -0.12034098f, 
    -0.10270408f, -0.07645173f, -0.33529383f, 0.17405874f, 0.03488078f, 0.05400761f, 0.00859193f, 0.05333655f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.30606455f, 0.13484137f, 0.16001563f, -0.13586101f, -0.10502070f, 0.17407502f, 0.08986445f, -0.30712959f, 
    0.14455779f, 0.13742007f, 0.08415382f, -0.13763329f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
