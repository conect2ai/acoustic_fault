#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.75655156f, 1.04413152f, 0.76464885f, 0.48339900f, 0.58718276f, -0.80092782f, 0.46576059f, -0.12465720f, 
    -0.08414949f, 0.19192989f, 0.25627989f, 0.52730876f, -0.33874464f, 0.03160119f, -0.11950916f, 0.33093876f, 
    0.22207974f, -0.21081838f, 0.22911274f, 0.45383197f, -0.40459311f, 0.15813251f, 0.32794008f, -0.16312571f, 
    -0.10652106f, 0.16351329f, -0.64901721f, 0.62134111f, 0.63510662f, -0.97380251f, -0.09603696f, -0.23380445f, 
    0.51807207f, -0.44798088f, -0.60862094f, -0.46075940f, -0.39166677f, -0.26465285f, -0.05307798f, -0.31940356f, 
    -0.51594913f, 0.14181389f, -0.12333617f, 0.08675230f, -0.60595685f, 0.14542322f, -0.20391929f, -0.40772149f, 
    -0.09431196f, 0.13275643f, 0.94280475f, 0.64223272f, 0.51198936f, 0.83458453f, 0.92315573f, 0.53306895f, 
    0.60441393f, 0.69938082f, -0.56879359f, -0.38780591f, -0.24364936f, -0.39738613f, -0.31690142f, 0.27804065f, 
    -0.07425313f, -0.33699712f, -0.15889476f, 0.08161373f, -0.10037702f, -0.05096370f, -0.07917869f, -0.12756267f, 
    -0.13857689f, -0.10984571f, 0.02303967f, -1.00258636f, 0.38570833f, 0.64039189f, 0.12843707f, 1.20202720f, 
    1.31495845f, -0.33176860f, -0.77383912f, -0.10088744f, -0.74471402f, 0.33106741f, 0.35465685f, 0.25433767f, 
    0.26575536f, -0.24915674f, -0.12661722f, -0.12604123f, 0.15988785f, -0.40991548f, 0.31902111f, 0.01068975f, 
    -0.12588133f, -0.09788624f, 0.06378225f, -0.06635495f, 1.01796544f, 0.87647235f, -0.02320681f, 0.63646561f, 
    0.30861044f, -0.99330306f, -1.19456983f, -0.41768175f, 0.11555951f, -0.56930482f, 0.36400154f, 0.37851939f, 
    0.12915403f, -0.06050728f, -0.10175139f, 0.07629866f, -0.16100691f, 0.29893327f, -0.10418113f, 0.25686571f, 
    0.45183700f, 0.31479722f, 0.25503299f, 0.17802379f, -0.14707354f, 0.08784923f, -1.00121570f, -0.98628938f, 
    -0.52525842f, 0.06143293f, 0.54265040f, 0.59701103f, -0.07970758f, 0.63780648f, 0.85169011f, -0.58724999f, 
    -0.04178103f, -0.01576827f, 0.35592663f, 0.12149329f, -0.70316982f, 0.02184134f, 0.39385238f, 0.31114939f, 
    -0.26970181f, -0.07138638f, -0.34260535f, -0.21272133f, -0.38051492f, 0.15989317f, -0.52775300f, 0.66694379f, 
    -0.51553601f, -0.09309085f, 0.23478509f, -0.76348060f, -0.84141427f, -0.70314330f, -0.42857292f, -0.27896097f, 
    0.18245833f, -0.31705898f, 0.14012365f, 0.26963198f, 0.22616141f, -0.33893654f, -0.32847396f, -0.66757071f, 
    -0.12097896f, 0.33715650f, 0.37173450f, 0.27408358f, 0.31830633f, -0.05390296f, 0.05748826f, 1.23089778f, 
    -0.51565772f, 0.16806521f, 0.05140828f, 0.82784706f, 0.73481590f, -0.28387877f, -0.15072533f, -0.25702640f, 
    0.15856284f, -0.24942343f, 0.05545678f, -0.46339732f, 0.30974737f, 0.28031746f, -0.03602539f, -0.38522550f, 
    0.27962786f, 0.42871431f, 0.21782966f, -0.23883560f, -0.14661665f, -0.21226157f, -0.32680348f, -0.11378628f, 
    -0.02871995f, 0.77858490f, 0.17067166f, -1.13423193f, 0.08613051f, 0.87848979f, -0.94187677f, 0.22422725f, 
    -0.80781841f, -0.36059648f, 0.19347219f, -0.18724921f, 0.34798512f, 0.01407197f, -0.38070452f, -0.03536082f, 
    0.36474872f, -0.15924682f, -0.00770360f, -0.06376182f, 0.13048559f, 0.09104933f, 0.06565206f, 0.06227805f, 
    0.06563034f, -1.20011926f, 0.93227774f, -0.77819455f, -0.41167858f, 0.24625053f, -0.51769757f, 0.90137827f, 
    0.55669916f, 0.15540996f, 0.25223494f, -0.11798081f, -0.07018431f, 0.43396407f, -0.05370622f, 0.24870287f, 
    0.27158132f, -0.30264884f, -0.12004906f, -0.40387329f, -0.43772179f, 0.21279302f, 0.44090423f, 0.14462748f, 
    0.33824006f, 0.18347543f, 1.47010410f, 0.95884675f, -0.22852816f, 0.01248007f, -0.95575523f, -0.21073277f, 
    0.44302127f, -0.06769914f, 0.27783892f, 0.68619406f, 0.50759083f, 0.28622752f, -0.11446095f, -0.24478281f, 
    0.04842040f, -0.08186761f, 0.01154916f, 0.06072791f, -0.00602140f, 0.21167658f, -0.10302895f, 0.09513555f, 
    0.17811808f, 0.10428153f, -0.10233997f, -0.98485333f, -1.12821162f, -0.65318155f, -0.51075494f, -0.40938023f, 
    -0.56013089f, -0.21801060f, -0.27688959f, -0.05115417f, 0.35917023f, 0.47315434f, 0.20150483f, -0.05406577f, 
    0.32598105f, 0.09080373f, -0.11975615f, 0.16040599f, 0.19159761f, -0.19122642f, 0.36691698f, -0.01957448f, 
    0.18941556f, -0.16985118f, 0.26298848f, -0.05020671f, 0.88459176f, 0.78470618f, 1.18594408f, 0.70584315f, 
    0.23502880f, 0.21412662f, -0.44464529f, -0.38584578f, 0.07846906f, 0.31689799f, 0.03555268f, 0.04340619f, 
    -0.16302226f, -0.14302625f, 0.05609046f, -0.09142247f, 0.17374331f, -0.13036484f, -0.30513269f, -0.21084416f, 
    0.08573262f, 0.20519930f, -0.09356251f, -0.55179656f, 0.10964070f, -1.30314696f, 1.17035246f, 0.31690758f, 
    -1.04595494f, -0.43200591f, 0.27167580f, 0.65845835f, -0.39470309f, 0.50121832f, 0.66015399f, -0.30939892f, 
    0.07736293f, -0.27141032f, 0.07378566f, -0.18756174f, -0.11339195f, -0.06434041f, -0.15554135f, -0.00915531f, 
    -0.24405323f, -0.21302281f, -0.18877582f, 0.17166141f, -0.18263020f, 0.14807464f, -0.89515036f, -0.52663690f, 
    0.12773429f, -0.27272627f, -0.07570516f, -0.79035068f, -0.50413400f, -0.16098349f, -0.81618065f, -0.17577118f, 
    0.01949781f, 0.04688877f, 0.17582858f, -0.28849578f, -0.36030367f, 0.30018240f, 0.08172518f, 0.25003889f, 
    -0.23463605f, -0.58153063f, -0.08856752f, -0.38370940f, 0.35903829f, 0.33891118f, -0.15410320f, 0.22206958f, 
    0.16962115f, 0.16595337f, 0.76556909f, 0.77495790f, -0.19524121f, -0.16042171f, 0.16498050f, -0.19981907f, 
    0.55438113f, 0.00523687f, -0.42884067f, -0.41393521f, -0.23568822f, -0.15335463f, -0.17331608f, -0.18941687f, 
    0.10136104f, 0.34703633f, 0.29526654f, 0.85858738f, 0.46468937f, 0.37725142f, 0.25264129f, 0.07447293f, 
    -0.96716648f, 0.54491746f, 0.58247107f, -0.46809316f, -0.75089967f, -0.09907012f, -0.27639189f, 0.38808668f, 
    0.53322935f, -0.64029193f, -0.25940314f, 0.36812779f, -0.19321670f, -0.22102743f, 0.15702567f, -0.09213594f, 
    0.27855480f, 0.06012063f, 0.22590668f, 0.21797673f, 0.03892992f, 0.07419340f, 0.15629491f, 0.50586802f, 
    -0.13849249f, 1.15317214f, 1.07655585f, 0.57027674f, -0.68376821f, -0.78695953f, 0.09200551f, -0.33557335f, 
    -0.47521576f, -0.34293351f, 0.43453032f, 0.05352105f, -0.07380559f, -0.00212935f, 0.23974375f, 0.11937460f, 
    -0.09099780f, -0.20645435f, 0.26814929f, 0.34442186f, -0.24692264f, 0.20018628f, -0.10154072f, 0.18969066f, 
    -0.31999454f, 0.23769271f, -1.01644957f, -0.16993329f, -0.23835355f, 0.01114890f, 0.59569687f, -0.13401756f, 
    0.47400799f, -0.21653441f, -0.41736940f, -0.60424417f, 0.51043057f, 0.18107927f, -0.37858191f, -0.34582809f, 
    -0.07432549f, -0.32928696f, 0.19399436f, -0.06668428f, 0.03621178f, 0.23253736f, -0.16733739f, 0.28843629f, 
    0.35905775f, 0.04821878f, 0.45494553f, -0.02172402f, 1.25969446f, -0.61272854f, -0.89309418f, -0.20702015f, 
    0.00771897f, -0.54393899f, -0.39146751f, -0.38653401f, -0.43455577f, -0.13251311f, -0.01938839f, -0.26913804f, 
    0.48337477f, -0.25355080f, 0.18476012f, 0.25216815f, 0.58663559f, 0.11524978f, -0.19787167f, -0.30172026f, 
    -0.23822406f, -0.39877692f, -0.27664730f, 0.27572641f, 1.27344465f, 0.55903745f, -0.50073409f, 1.25087130f, 
    1.10622180f, 0.36188585f, 0.25536308f, 0.02593349f, 0.90728754f, 0.14805323f, -0.29149222f, -0.04200417f, 
    0.12787613f, -0.14008766f, -0.18389413f, 0.05627060f, -0.08004575f, 0.13489234f, -0.11936656f, 0.02755598f, 
    0.21032292f, -0.03608633f, 0.15755865f, -0.04926253f, 0.26268646f, -0.17939346f, 0.16745751f, -0.56497324f, 
    -0.79639083f, -0.19553041f, -0.21682315f, 0.54686010f, -0.02196125f, -0.90068692f, 0.04703983f, 0.10805485f, 
    0.24567439f, 0.04500208f, 0.20622957f, 0.20661730f, 0.40656874f, -0.17016444f, -0.34073386f, -0.05010910f, 
    0.22305784f, -0.32306570f, 0.01614022f, 0.54864681f, -0.13691814f, 0.39650121f, 0.71169293f, -0.27988324f, 
    0.96622479f, -0.56384063f, -0.71838355f, 0.65134972f, -0.57489765f, 0.40289778f, 0.26863039f, 0.04432359f, 
    0.67941153f, 0.13939090f, 0.12083398f, 0.53336716f, -0.58072388f, -0.13827735f, -0.07070020f, 0.04839984f, 
    -0.50039858f, -0.12985021f, -0.01342165f, 0.17369516f, 0.26433492f, -0.01746829f, 0.10107737f, -0.42545059f, 
    -0.72063959f, -0.19480422f, -0.69354880f, -0.39884907f, -0.09079978f, -0.20825799f, 0.31708944f, 0.32279372f, 
    -0.43668091f, 0.32744589f, -0.61507154f, 0.32098910f, 0.15659720f, 0.29592082f, -0.53409803f, -0.04162700f, 
    -0.06061953f, -0.45793128f, -0.01533533f, -0.16732812f, -0.16417190f, -0.12519300f, -0.40969479f, -0.34987131f, 
    -0.40322199f, -0.28700241f, -0.84626013f, -1.12366450f, -0.68552369f, 0.17336933f, -0.09456369f, 0.52959269f, 
    0.75548983f, 0.16001594f, -0.43592489f, -0.24965855f, 0.03305539f, -0.11499558f, -0.38105312f, 0.44912118f, 
    0.00636839f, 0.23657286f, 0.18971279f, 0.27001897f, -0.31900197f, 0.24544808f, -0.22917177f, -0.20413516f, 
    0.05315949f, -0.83517981f, -1.38532889f, 0.71815288f, 0.81027132f, -0.03830948f, 0.78109229f, 0.57890034f, 
    0.69811583f, 0.28484771f, -0.22365838f, -0.25818449f, -0.15535861f, -0.18332843f, 0.54629868f, -0.22093689f, 
    0.16344230f, 0.24448898f, 0.11646789f, -0.22788440f, 0.04519874f, -0.10990106f, -0.02563862f, 0.04451608f, 
    -0.21720046f, -0.30078390f, -0.58468401f, -1.60492420f, -0.67916441f, 0.39054358f, 0.37987119f, -0.70364624f, 
    1.06370771f, 0.70312470f, -0.64949930f, 0.02083651f, 0.29321197f, -0.11657603f, -0.15975824f, -0.27218679f, 
    0.09036340f, -0.33727100f, 0.03549954f, -0.36069319f, 0.00816012f, -0.24171793f, -0.01501022f, -0.13762654f, 
    -0.11348838f, 0.14176665f, 0.00182296f, -0.16881011f, 0.42120543f, 1.03697121f, -0.93144184f, -0.87154615f, 
    -0.24574928f, -0.28491056f, 0.25426957f, -0.21463656f, -0.02549065f, 0.45796826f, 0.37608573f, -0.20340167f, 
    0.39071727f, 0.22308792f, 0.39340422f, 0.19479239f, 0.27879745f, 0.16802564f, 0.25981194f, 0.34636840f, 
    0.30847466f, 0.36924642f, -0.20217399f, 0.14241490f, 0.17009458f, 0.95613867f, 0.21982597f, -0.22745660f, 
    1.03576005f, 0.09923957f, -0.50428277f, 0.23186691f, 0.16397244f, 0.13544345f, 0.06720367f, -0.17410435f, 
    0.38404152f, 0.26830435f, 0.26350653f, 0.67647475f, 0.28926885f, -0.22847399f, 0.00573427f, 0.04491574f, 
    0.13521251f, -0.32506546f, -0.26881063f, 0.36532545f, 0.39997524f, -0.79095483f, -0.45735669f, -0.77250272f, 
    -0.10282967f, -0.73574615f, 0.78433543f, 0.92928123f, -0.43862864f, 0.37668887f, -0.01474894f, -0.19266330f, 
    -0.26590011f, -0.35496345f, -0.37997258f, 0.22148623f, -0.16745201f, 0.30380246f, -0.43945837f, -0.17994335f, 
    -0.16534013f, 0.17311887f, 0.10858135f, 0.28018430f, 0.03329815f, -0.13694695f, -1.54089522f, 0.06800923f, 
    0.78159273f, -0.53297108f, -0.71969754f, 0.59346402f, 0.55697429f, -0.41981587f, 0.09310817f, -0.52986705f, 
    -0.17531006f, 0.44683123f, -0.18819062f, 0.28216153f, 0.31288037f, -0.36950248f, -0.17676541f, -0.35162687f, 
    -0.18213284f, -0.41289994f, 0.19304013f, 0.03914050f, 0.02159329f, 0.10401726f, 0.35917836f, -1.32378733f, 
    0.37815514f, 0.86081332f, 0.12981075f, 0.04803260f, 0.73566622f, 0.67552119f, 0.23148023f, 0.77075827f, 
    0.49187595f, 0.00514861f, -0.33318549f, 0.54012930f, -0.22527121f, -0.37234557f, -0.01810679f, -0.29560718f, 
    -0.06439806f, -0.26808539f, -0.17934532f, 0.10716444f, 0.05783619f, -0.28379163f, 0.11627871f, -0.28354418f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04984136f, -0.09724397f, 0.23098013f, 0.17604588f, 0.15675716f, 0.19167456f, 0.33287886f, 0.16141279f, 
    0.21256481f, 0.21225631f, 0.25917369f, 0.29055882f, 0.27823201f, 0.07053492f, 0.32347196f, 0.20791180f, 
    0.32189623f, 0.27076414f, 0.34282503f, 0.09401149f, 0.15525968f, 0.35955995f, 0.17927888f, 0.03973072f, 
    0.30511442f, 0.35607824f, 0.16697417f, 0.31670952f, -0.04071530f, 0.10963710f, 0.06333519f, 0.01595549f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.21948580f, -0.09246100f, -0.00725201f, -0.02200331f, -0.05037171f, -0.06410755f, -0.03330243f, 0.10591284f, 
    0.04744903f, -0.07161570f, -0.01182673f, -0.15045702f, -0.10364073f, -0.12451037f, -0.02828050f, 0.39895806f, 
    -0.00046097f, -0.14613321f, 0.14958042f, -0.09524263f, 0.00277254f, 0.01472317f, -0.07143564f, 0.02367904f, 
    0.17576411f, 0.03119510f, 0.10370594f, 0.03380918f, -0.25157908f, -0.01826176f, 0.02815766f, 0.16974185f, 
    -0.10364803f, -0.03013547f, 0.03409253f, -0.05675953f, -0.37760726f, -0.23000251f, 0.19607149f, -0.00664595f, 
    -0.04160717f, -0.09031951f, 0.02861442f, -0.19147830f, 0.09247169f, 0.01390787f, -0.06678978f, 0.02186628f, 
    0.20091888f, 0.24270909f, 0.18339106f, -0.00388854f, -0.05532236f, -0.06971065f, -0.07592499f, 0.09399752f, 
    0.07364322f, -0.08221326f, -0.09833602f, -0.02670671f, 0.06281295f, -0.09175871f, 0.03272006f, -0.19907409f, 
    0.08501013f, -0.00478477f, 0.13163826f, -0.04638103f, -0.03691920f, 0.02303493f, -0.07047532f, 0.18050615f, 
    -0.06494693f, 0.06654526f, 0.16478957f, 0.01418625f, -0.00661628f, -0.02095816f, 0.00341729f, -0.03080029f, 
    0.01855508f, -0.13625734f, 0.04431587f, -0.01926466f, 0.36613274f, -0.31457326f, 0.23147073f, 0.13714872f, 
    -0.12572263f, -0.00295572f, 0.03905740f, 0.15161613f, -0.00997919f, -0.01674777f, -0.17914741f, -0.00072838f, 
    -0.43024299f, 0.12237961f, 0.25914702f, -0.40566075f, -0.03530376f, -0.04705749f, 0.17934334f, -0.14161590f, 
    -0.05381823f, -0.00798257f, 0.01371181f, -0.04762959f, 0.17132832f, 0.27869856f, -0.01288680f, -0.26008862f, 
    0.02728099f, -0.10145422f, -0.10132600f, -0.01811738f, -0.00627970f, 0.05252258f, -0.03185917f, -0.00255910f, 
    -0.24734296f, -0.09888981f, -0.01166696f, -0.07974501f, 0.01751640f, -0.11605267f, -0.06038228f, 0.09576314f, 
    -0.02533377f, 0.02332634f, 0.04309268f, 0.00341863f, -0.50019282f, -0.23771130f, -0.28293294f, 0.04781039f, 
    -0.20885520f, 0.00392423f, -0.02828849f, -0.05422850f, -0.06053510f, -0.06722699f, -0.06719540f, 0.00498326f, 
    0.13016136f, -0.07860196f, -0.13436191f, 0.11384789f, -0.18623048f, -0.10700781f, 0.01127816f, -0.02460139f, 
    -0.06961168f, 0.05168259f, -0.11969760f, -0.04070717f, 0.52366221f, -0.16138141f, 0.02286242f, -0.11747739f, 
    0.04656569f, 0.15381217f, 0.12199659f, -0.06567258f, 0.06038364f, -0.07593761f, 0.04979717f, 0.05833607f, 
    -0.51313406f, -0.35103491f, -0.17560537f, 0.12349819f, -0.15738805f, -0.04260732f, -0.08686088f, 0.00736695f, 
    0.11530958f, 0.13875933f, -0.04130905f, -0.02499225f, 0.08615856f, 0.01391136f, 0.20930220f, 0.21536702f, 
    0.01223550f, 0.03204880f, -0.18405519f, -0.02743274f, -0.02792420f, -0.05969142f, 0.03044380f, 0.01476010f, 
    -0.18839993f, 0.38812611f, 0.03777603f, 0.31608233f, -0.00972468f, 0.11510997f, -0.00031413f, -0.09246434f, 
    -0.04339106f, 0.08711008f, -0.01894090f, -0.05258640f, -0.20898148f, 0.07603507f, 0.08129729f, -0.46583849f, 
    -0.00809361f, -0.17165720f, -0.01050967f, -0.05068028f, -0.09467095f, -0.05186060f, -0.10307878f, -0.07681878f, 
    -0.40994275f, -0.02040059f, 0.12436783f, 0.01993985f, 0.13919571f, -0.02858819f, 0.03341870f, 0.07132751f, 
    -0.03900655f, -0.09717637f, -0.08623754f, -0.04492420f, -0.22940263f, 0.28128886f, 0.19883098f, -0.43845457f, 
    -0.05310287f, 0.04558584f, 0.12432577f, -0.06211341f, -0.01500046f, 0.10343236f, -0.27015960f, -0.05680044f, 
    0.10318752f, 0.05624334f, -0.03144132f, 0.44586933f, -0.25598523f, 0.07236627f, -0.01278103f, 0.01596253f, 
    -0.07588007f, 0.09622492f, -0.00107567f, -0.19665220f, -0.27452892f, -0.10816769f, 0.20641805f, -0.47378051f, 
    -0.00139571f, -0.07805816f, 0.08106814f, 0.05980675f, -0.02625236f, 0.00601263f, -0.09084850f, -0.06712501f, 
    0.01530347f, -0.17853965f, -0.09385059f, -0.14022750f, -0.03616602f, 0.02258088f, -0.06412224f, -0.34918541f, 
    -0.18039051f, 0.15273677f, -0.19095851f, 0.15135494f, -0.20730476f, -0.25488266f, 0.04422966f, -0.08842788f, 
    -0.03455766f, 0.01125122f, 0.04734094f, 0.07752657f, -0.02796648f, -0.02336438f, -0.02392694f, 0.01889419f, 
    0.24755530f, 0.07493612f, -0.20162781f, -0.57902104f, -0.01647948f, -0.01058699f, 0.09722970f, -0.00571245f, 
    -0.07711829f, 0.03206212f, 0.05298465f, -0.03651378f, -0.39137080f, 0.06360285f, -0.00723833f, 0.21900953f, 
    0.04570998f, 0.08594510f, 0.13231401f, 0.10139855f, 0.00154087f, -0.06486592f, -0.05228097f, -0.13351116f, 
    -0.56869036f, 0.33094722f, -0.07709618f, 0.10451794f, -0.03177321f, 0.03375879f, -0.07276707f, -0.08248654f, 
    0.06600875f, -0.05018462f, -0.02811997f, 0.08667871f, -0.50513631f, 0.14620443f, -0.12123174f, -0.03729796f, 
    -0.01736221f, 0.03901518f, -0.02704076f, -0.09964415f, 0.10520764f, -0.03913092f, 0.10753649f, 0.04474964f, 
    0.03407039f, -0.04494618f, 0.38846824f, -0.30081090f, -0.03971538f, -0.04583261f, 0.06461554f, -0.00074560f, 
    0.17012547f, 0.04209706f, 0.08156157f, -0.07476816f, 0.37641561f, 0.17376861f, 0.21570100f, -0.27397093f, 
    0.03769142f, 0.09179907f, -0.16040407f, 0.03153512f, -0.04077269f, -0.03251230f, -0.02542672f, 0.03814581f, 
    -0.11653788f, 0.30924973f, 0.40406987f, 0.13307333f, -0.03105694f, 0.09151538f, 0.03539634f, 0.02481752f, 
    0.10562959f, 0.10990788f, 0.10160319f, 0.01692177f, 0.43820545f, 0.07725988f, 0.08619370f, 0.25904655f, 
    -0.14201650f, 0.02384611f, 0.03699945f, -0.07310329f, -0.06145225f, -0.00432013f, 0.00661065f, -0.06645892f, 
    0.28499472f, 0.13507389f, 0.12333062f, 0.15951164f, -0.03399697f, -0.16353574f, 0.11150964f, -0.01917580f, 
    0.06475085f, -0.04532250f, -0.04530658f, 0.18050964f, -0.30402470f, -0.05714331f, -0.28155732f, 0.15631148f, 
    -0.06484558f, 0.14422365f, -0.22394988f, -0.04875193f, 0.10823822f, 0.03079521f, 0.00888160f, -0.28548881f, 
    0.35916558f, 0.00858193f, 0.11063977f, 0.29217729f, -0.16137712f, 0.01541969f, 0.02340555f, 0.06343833f, 
    0.02156231f, 0.02667551f, -0.04186307f, 0.01362824f, -0.00038749f, -0.07009725f, -0.09353597f, -0.06953096f, 
    -0.04961203f, -0.01556152f, -0.08165772f, -0.05081365f, -0.15366098f, -0.04527021f, -0.01060682f, -0.10090952f, 
    -0.04825554f, -0.44135141f, -0.03010522f, 0.31647393f, -0.11182582f, 0.05903337f, 0.12756798f, 0.11715313f, 
    0.00326031f, 0.12026040f, -0.11643337f, 0.08518580f, 0.42216122f, -0.16784611f, 0.08969755f, -0.25510296f, 
    0.05417192f, -0.11735985f, -0.11892011f, 0.13513403f, -0.17672519f, 0.01549534f, 0.07749352f, -0.17255367f, 
    -0.16623506f, -0.18706524f, -0.17128411f, -0.39790940f, 0.14559786f, -0.01467113f, 0.03585116f, -0.07800481f, 
    -0.11518949f, 0.02468967f, -0.11062994f, -0.03660360f, 0.41793513f, -0.33925542f, 0.05793260f, -0.06689163f, 
    0.04800015f, -0.04517787f, -0.10786706f, -0.05565537f, -0.04136487f, -0.05243134f, -0.02830569f, 0.00323749f, 
    0.21319425f, -0.04197046f, 0.01018370f, -0.20901652f, -0.06795041f, -0.09737026f, 0.07030690f, 0.01435406f, 
    0.05729885f, 0.11736108f, 0.07998113f, 0.12424929f, 0.14366360f, 0.03188343f, -0.20078333f, -0.32912490f, 
    0.15685040f, 0.13520283f, -0.06308887f, 0.07705296f, 0.12025236f, -0.16051583f, -0.15592244f, -0.03127966f, 
    0.74354231f, -0.00520570f, 0.07372846f, -0.09476824f, -0.16880828f, -0.15579085f, 0.11837107f, -0.04365715f, 
    -0.12158711f, 0.08617400f, -0.08587847f, 0.11326911f, 0.22582093f, 0.11935706f, 0.06576334f, -0.00194597f, 
    0.10040399f, 0.06783267f, 0.03485709f, 0.10123634f, 0.04612270f, -0.08189827f, 0.05085442f, 0.21111314f, 
    0.15230924f, 0.10006294f, 0.15043254f, 0.21248561f, -0.13230510f, -0.18509659f, 0.06995657f, 0.00924874f, 
    -0.01411973f, -0.13765827f, 0.13170037f, -0.06788401f, -0.78496015f, 0.12493607f, -0.08203623f, -0.20504948f, 
    -0.06237654f, -0.12906145f, 0.07042759f, -0.05248353f, 0.07799915f, 0.08627640f, 0.05076437f, -0.11408176f, 
    0.11822202f, -0.04366872f, 0.10626649f, -0.02113683f, 0.07795132f, -0.04645326f, -0.02481815f, 0.08518710f, 
    0.07557461f, -0.14688289f, 0.04566134f, 0.10337895f, 0.17924169f, 0.12394620f, -0.06012282f, 0.22023474f, 
    -0.07353870f, 0.06658611f, 0.13217282f, 0.07978464f, 0.10049407f, 0.07394319f, -0.04550285f, 0.24804315f, 
    -0.53281587f, -0.14486946f, -0.12443563f, -0.29779968f, 0.04652854f, -0.19200434f, -0.00728169f, -0.03106285f, 
    0.03033592f, -0.00042041f, -0.14276443f, -0.01131306f, 0.23543423f, 0.00483893f, -0.00570134f, -0.10016257f, 
    0.02476889f, -0.09890037f, 0.06853145f, -0.00881876f, -0.01486476f, -0.03684638f, 0.06926081f, 0.07074317f, 
    -0.01494209f, 0.08452519f, -0.29865289f, -0.22430074f, -0.18464833f, 0.12639591f, 0.03094084f, 0.00349362f, 
    -0.01308079f, 0.01391937f, 0.10303658f, -0.19391182f, -0.00189401f, -0.05967867f, -0.16468845f, -0.38324541f, 
    -0.02237254f, 0.24455443f, -0.04122351f, -0.06984562f, 0.06354746f, -0.14739318f, 0.15135588f, -0.03895528f, 
    0.37561789f, -0.13703330f, 0.12395895f, 0.30186412f, -0.03314136f, -0.01803040f, -0.10736451f, 0.05120357f, 
    -0.07456690f, -0.05029160f, -0.03186706f, 0.04728269f, 0.08241720f, 0.00549080f, -0.08387427f, -0.44112366f, 
    0.01134600f, -0.07137097f, 0.00926476f, -0.12105104f, -0.02712894f, 0.05336772f, 0.00564910f, 0.04602050f, 
    -0.17480570f, 0.27556926f, -0.00106306f, -0.03772250f, 0.00659561f, 0.05520527f, 0.08377296f, 0.06693703f, 
    0.05695577f, -0.09951790f, 0.05349161f, -0.07040252f, -0.04216864f, 0.14950871f, -0.01337919f, 0.05390754f, 
    -0.00846745f, -0.06406940f, -0.16282828f, -0.09881839f, 0.05143612f, -0.11130724f, -0.12756100f, -0.00062006f, 
    -0.10811567f, -0.05219549f, 0.04783087f, -0.34418967f, 0.11226219f, -0.08041397f, 0.03717141f, 0.09514629f, 
    0.13633370f, 0.06266242f, 0.05001836f, -0.00358186f, 0.08062641f, 0.28340825f, -0.22070844f, 0.07909299f, 
    -0.05796403f, 0.11290392f, 0.02552612f, -0.10159219f, 0.01787849f, 0.12025668f, 0.02454232f, 0.09073119f, 
    0.49624652f, -0.15742154f, -0.08980817f, 0.15266107f, -0.20822279f, 0.02687149f, -0.05213354f, 0.01611383f, 
    0.03626078f, -0.10881593f, -0.00091919f, -0.04493175f, -0.41791660f, 0.12322491f, -0.30491203f, -0.05490454f, 
    0.15277077f, 0.00640817f, 0.03466863f, 0.09460257f, 0.08556316f, 0.06723908f, 0.08947167f, 0.03108623f, 
    0.20844151f, 0.12050160f, -0.03064178f, -0.02988060f, -0.12091013f, -0.02819426f, -0.09432919f, 0.04425592f, 
    -0.02061554f, -0.01117678f, -0.20310163f, 0.28384221f, -0.23708393f, -0.04800744f, -0.39524823f, -0.08220604f, 
    0.12631144f, -0.18687893f, -0.01217696f, -0.09695645f, 0.11789849f, 0.07901353f, -0.25879747f, -0.02547425f, 
    -0.79380691f, 0.09735507f, -0.28103435f, 0.02240452f, -0.21178737f, -0.00848380f, 0.08494976f, 0.21783380f, 
    -0.01471996f, -0.07475580f, -0.25581062f, -0.01312828f, -0.35405546f, 0.11354847f, -0.00458728f, 0.05834235f, 
    0.22170050f, 0.10651775f, 0.04925327f, -0.11273213f, -0.06220198f, -0.02565525f, 0.22858627f, -0.05827988f, 
    0.07788550f, 0.20453791f, 0.00894784f, 0.08913588f, 0.04946409f, 0.00680574f, 0.01722337f, -0.03526160f, 
    -0.15980636f, -0.21877919f, -0.00124259f, -0.06342917f, -0.56519800f, -0.07016446f, -0.39895898f, -0.15475529f, 
    -0.12463742f, -0.00646001f, 0.07348703f, 0.09262908f, 0.12153005f, 0.09795864f, 0.00481908f, -0.09156865f, 
    -0.25901073f, -0.07357749f, 0.12578841f, -0.27221692f, 0.18099378f, -0.00707530f, 0.07433690f, 0.01334750f, 
    0.06039161f, -0.08545763f, 0.02124381f, 0.08154285f, 0.18789728f, -0.04900819f, 0.04707130f, 0.17015313f, 
    -0.01981084f, 0.00613545f, 0.04311826f, -0.10474038f, -0.15509856f, -0.01796074f, -0.12718549f, 0.00932315f, 
    -0.05649905f, 0.09700143f, -0.00308184f, -0.19586095f, 0.13046408f, -0.17015921f, 0.06982680f, -0.06101114f, 
    0.04538389f, 0.10702491f, 0.03199700f, -0.07309661f, 0.13189289f, 0.06543899f, 0.04685438f, 0.27164003f, 
    -0.15567030f, 0.03481077f, -0.03677749f, -0.01509419f, -0.07130557f, -0.08378536f, -0.15986654f, -0.00388396f, 
    -0.34379229f, 0.16816971f, -0.15540533f, -0.32195419f, 0.05723717f, 0.06289661f, 0.00566177f, -0.17424929f, 
    -0.03294307f, 0.06165172f, 0.00469370f, -0.02749881f, -0.50134373f, 0.02987999f, 0.17666298f, -0.18219744f, 
    0.17178255f, 0.02867961f, -0.07143667f, 0.06218104f, -0.18349034f, -0.06858169f, -0.01172811f, -0.10499279f, 
    -0.31706157f, 0.12087111f, 0.00032493f, -0.09035806f, 0.13331784f, 0.06149324f, 0.01925143f, -0.03077099f, 
    -0.12044852f, -0.07518137f, -0.09948540f, -0.08205057f, 0.19452140f, 0.11425353f, -0.12496606f, 0.20244429f, 
    -0.10729549f, 0.10912694f, -0.13412639f, -0.17772265f, -0.02154972f, -0.05468506f, 0.01008767f, -0.08700781f, 
    0.30598342f, 0.11018685f, 0.12069628f, -0.15979919f, -0.12649341f, -0.02034723f, 0.03923346f, 0.04264739f, 
    -0.10699303f, -0.03753964f, 0.12751804f, -0.00753281f, 0.29358974f, -0.39346030f, 0.13670759f, -0.05781748f, 
    -0.21072409f, -0.12770234f, -0.13840768f, 0.09450148f, 0.01403855f, -0.00969264f, 0.02382745f, -0.09275258f, 
    -0.13781020f, 0.09757047f, -0.07894834f, -0.07362580f, 0.04462518f, 0.04247352f, 0.08541515f, -0.08266652f, 
    0.12440766f, 0.10452078f, -0.07146726f, 0.04140518f, 0.54148155f, 0.08739702f, -0.16529058f, -0.11492052f, 
    -0.06052333f, 0.04887355f, 0.04488226f, 0.05837820f, -0.19274056f, 0.01463193f, 0.04723479f, -0.10753050f, 
    0.15324628f, -0.30985358f, -0.30993652f, -0.14162715f, -0.06568769f, 0.02240860f, -0.27188540f, -0.08620894f, 
    0.02693545f, 0.00097398f, 0.09770969f, -0.17058486f, -0.06386091f, -0.00207288f, -0.03446447f, -0.01551978f, 
    0.03102726f, 0.00878723f, -0.00813932f, -0.15584140f, -0.06498918f, -0.02603476f, 0.07515945f, 0.00430447f, 
    0.08917246f, 0.10862006f, -0.29364556f, -0.13568787f, -0.17899331f, 0.07768504f, -0.06660301f, 0.04816433f, 
    -0.05701063f, -0.01256454f, 0.08763390f, -0.05295882f, -0.21405460f, -0.06572349f, 0.03946187f, -0.36773297f, 
    0.01452295f, 0.08394506f, 0.07050850f, -0.09071445f, -0.10367382f, 0.00890085f, -0.05227951f, -0.14831871f, 
    0.09665140f, -0.13350150f, -0.12943785f, -0.02777522f, 0.05517692f, -0.09726533f, -0.09815214f, -0.29188836f, 
    0.04720866f, 0.04020718f, -0.00660018f, -0.10325672f, -0.56754583f, -0.13524927f, -0.34866491f, -0.32914424f, 
    0.09296871f, -0.16321547f, 0.14404267f, -0.01884987f, -0.08773923f, 0.06793379f, -0.01983819f, -0.12148815f, 
    0.30580014f, -0.17073989f, -0.13911937f, -0.02341036f, 0.11212771f, -0.08090472f, 0.08190034f, 0.07562862f, 
    -0.02777755f, 0.12077377f, -0.04745175f, -0.03286324f, -0.00833711f, 0.08243215f, -0.10156099f, -0.18143624f, 
    -0.05116180f, -0.07386610f, -0.01744422f, 0.03501531f, -0.02401382f, 0.05065604f, -0.02544113f, 0.06340420f, 
    -0.44208381f, 0.23262036f, 0.00102148f, -0.00677795f, -0.00833186f, 0.10489380f, -0.00924565f, 0.01073842f, 
    -0.04865612f, 0.15352948f, -0.04901920f, -0.05246243f, -0.15616222f, 0.18301183f, -0.06516517f, -0.03011892f, 
    -0.24764957f, -0.00403546f, 0.11483622f, 0.06529187f, 0.08636012f, 0.05150512f, -0.07295404f, 0.00417088f, 
    -0.09891128f, 0.22728391f, 0.06713371f, 0.42375571f, -0.09552310f, -0.11385752f, 0.07051726f, 0.05663578f, 
    -0.09614694f, -0.02132127f, -0.12858741f, -0.00538820f, 0.11554921f, -0.03048042f, 0.00564107f, -0.04124099f, 
    -0.10245413f, 0.03112677f, -0.06656607f, -0.04558652f, 0.13961880f, 0.08691280f, -0.04418090f, -0.04664443f, 
    0.63454801f, -0.12279637f, 0.05005304f, 0.17103046f, -0.10539385f, 0.13942844f, -0.13468099f, 0.03006388f, 
    0.06127744f, 0.03842220f, 0.12808593f, -0.01600064f, -0.16570881f, -0.00687158f, -0.06394082f, -0.13970748f, 
    -0.10252357f, 0.00465388f, 0.00501538f, -0.03854124f, -0.08068176f, -0.21163855f, 0.01851434f, 0.00137364f, 
    -0.02370917f, 0.10075482f, -0.09181643f, 0.10234133f, 0.16645634f, 0.04244971f, 0.14626092f, -0.21548033f, 
    0.02082390f, -0.05912992f, 0.00310776f, -0.08334824f, 0.40020087f, -0.09510160f, 0.26462808f, 0.04906121f, 
    -0.02230432f, -0.13409357f, -0.09991012f, 0.05781591f, 0.03470473f, -0.01601876f, 0.11931509f, 0.04396780f, 
    0.63912183f, -0.01514817f, -0.21481818f, -0.35927168f, -0.01430831f, -0.05187768f, -0.04877842f, -0.03356354f, 
    0.08018352f, 0.04821785f, -0.01595693f, -0.09424554f, 0.45244649f, 0.18508196f, 0.06230354f, 0.07036390f, 
    -0.15233172f, -0.12629414f, 0.08885606f, -0.02243469f, -0.09437375f, 0.22031666f, 0.07295924f, 0.01161869f, 
    -0.82540876f, -0.13478395f, -0.11424699f, 0.09548461f, -0.04883592f, 0.07047044f, 0.06379531f, 0.14036317f, 
    -0.00315896f, -0.08853018f, -0.06254996f, -0.03473069f, 0.15324537f, 0.01456908f, 0.17223202f, 0.01046212f, 
    0.00132598f, 0.04634294f, 0.03300545f, -0.03559079f, -0.01214976f, -0.03516775f, 0.02004101f, 0.03901183f, 
    -0.59012759f, -0.75312275f, 0.16423625f, 0.07097250f, -0.18588771f, -0.02837735f, 0.13130641f, -0.04316511f, 
    0.08045597f, -0.16251914f, 0.13816914f, -0.06448159f, 0.73572665f, 0.03579587f, 0.27430823f, 0.30408061f, 
    0.16387561f, 0.03971987f, -0.01617396f, 0.15747905f, -0.04098949f, 0.08220071f, -0.14574604f, -0.16574283f, 
    0.31842110f, -0.51112354f, -0.21754670f, 0.12844771f, 0.12883121f, 0.06440205f, -0.13005124f, -0.05820394f, 
    -0.04472236f, -0.01509062f, -0.11907739f, -0.35187984f, -0.12526394f, -0.00487220f, -0.06304633f, -0.11104223f, 
    -0.10985731f, -0.13921763f, -0.10422251f, -0.05484129f, -0.08881032f, -0.00885762f, 0.01739179f, 0.05303165f, 
    0.33840135f, 0.34488693f, 0.08178291f, -0.13313545f, 0.02014942f, -0.04967462f, -0.07373913f, -0.03582015f, 
    0.17138471f, -0.02301313f, 0.13359478f, -0.09783025f, -0.29863930f, -0.00515044f, 0.09948856f, 0.18303584f, 
    0.00777261f, 0.25066197f, 0.02706393f, -0.06584175f, 0.05926387f, -0.24051224f, 0.15338787f, 0.13932185f, 
    0.42441028f, 0.09367723f, -0.01015196f, 0.06000318f, 0.08074031f, 0.02258647f, -0.01212601f, 0.04332849f, 
    -0.00521207f, -0.05659957f, -0.12441816f, -0.06348702f, -0.38213435f, 0.40876466f, 0.02850068f, 0.11717501f, 
    0.11567833f, -0.03921365f, 0.04463242f, -0.04781555f, 0.01366332f, 0.17396133f, -0.07703294f, -0.06192814f, 
    -0.13540348f, -0.55037057f, -0.64770281f, 0.08792962f, -0.25609282f, 0.11068566f, -0.18375158f, 0.17058985f, 
    -0.01250279f, 0.00776841f, -0.06304344f, 0.04655024f, 0.14130871f, 0.08156480f, -0.06598201f, -0.00199746f, 
    -0.22226854f, -0.15137684f, -0.21114518f, -0.04939836f, -0.03326551f, -0.21620020f, 0.04385838f, 0.05960543f, 
    -0.06225918f, -0.61560285f, -0.44358295f, 0.35010919f, -0.09434164f, 0.03002246f, 0.11290988f, 0.06729989f, 
    -0.01936541f, 0.06074544f, 0.02347569f, 0.07391199f, -0.11833946f, 0.35555312f, 0.21172926f, -0.29594538f, 
    -0.06895899f, 0.06769311f, -0.07780939f, 0.12651962f, -0.05549034f, -0.08310078f, -0.01096574f, 0.10191443f, 
    0.12049106f, -0.00669774f, 0.11644110f, 0.11153426f, 0.05088644f, -0.17805201f, -0.19974220f, 0.00706577f, 
    -0.02915161f, 0.09502563f, -0.04949460f, -0.12047888f, -0.56987303f, -0.14982352f, 0.06624009f, 0.13256846f, 
    -0.02581281f, 0.04711579f, -0.02857065f, -0.19754578f, -0.00399993f, -0.07848261f, 0.09460412f, -0.06889559f, 
    -0.21746676f, 0.10226802f, 0.09416735f, -0.20152257f, -0.02661107f, 0.07830434f, -0.05783264f, 0.11713935f, 
    -0.02032654f, -0.04632097f, 0.01519693f, 0.12383924f, -0.14107294f, -0.09350640f, -0.19381583f, 0.07111065f, 
    -0.10069694f, -0.00884515f, -0.05431251f, -0.03466958f, -0.01935936f, 0.04876527f, 0.06239486f, 0.00009201f, 
    -0.00191015f, 0.25326338f, 0.25024906f, 0.08645572f, 0.01798416f, -0.14679950f, 0.03397565f, 0.15588175f, 
    0.09709265f, -0.05281847f, -0.00239046f, 0.04236562f, 0.26794463f, 0.21868268f, 0.15397443f, 0.03812553f, 
    -0.03408670f, 0.02277703f, 0.03738308f, 0.08267986f, 0.12897019f, 0.01563301f, 0.07652856f, 0.00463211f, 
    0.07681722f, -0.34694815f, -0.27694970f, -0.31816071f, -0.10232078f, -0.07104434f, 0.00828028f, -0.11531644f, 
    0.05029959f, -0.08363340f, -0.07243539f, 0.01114311f, -0.06122551f, 0.06141838f, -0.03678896f, 0.07407538f, 
    0.06624618f, -0.10166813f, 0.00014635f, 0.12910910f, -0.04166911f, 0.03527538f, 0.00409328f, 0.00023134f, 
    -0.02500280f, -0.33252585f, 0.04461948f, -0.08990391f, -0.05996534f, -0.01035312f, 0.05505721f, 0.11758491f, 
    0.07270887f, 0.19965100f, 0.04833344f, 0.04099447f, 0.06399813f, -0.06076268f, -0.16195536f, 0.02346236f, 
    -0.08075079f, 0.09795999f, -0.05953827f, -0.01886028f, -0.02144328f, 0.11815937f, 0.07499830f, 0.12722112f, 
    -0.16884957f, -0.05924360f, -0.08382486f, -0.11237284f, -0.19648436f, 0.02625091f, 0.08238669f, -0.05020707f, 
    0.00434511f, -0.02712739f, -0.06572822f, 0.11117841f, 0.02787754f, -0.21917278f, -0.00562322f, -0.03282437f, 
    -0.01618139f, -0.11350946f, -0.01156869f, 0.06883679f, -0.01031126f, 0.01721802f, 0.01757542f, -0.02813235f, 
    0.02026726f, -0.00010980f, 0.11711451f, 0.11750975f, 0.07726249f, -0.04872436f, 0.15544803f, -0.02503021f, 
    -0.07795191f, 0.11327510f, -0.03819332f, 0.03774122f, -0.15994069f, -0.14952354f, 0.01185311f, -0.04759816f, 
    0.06771484f, -0.09277915f, -0.06640200f, -0.07942583f, 0.05319560f, -0.01576161f, -0.01749943f, -0.10872181f, 
    0.06324110f, 0.06249829f, -0.20585862f, -0.06998631f, -0.19854887f, -0.10284460f, 0.01333233f, -0.07920212f, 
    0.05272027f, 0.06232800f, -0.10698011f, -0.04795903f, -0.05619362f, 0.05207154f, -0.10785884f, -0.01493959f, 
    -0.11122672f, 0.07111797f, 0.10958758f, 0.10884979f, 0.01592763f, -0.15984260f, 0.13818887f, -0.03608866f, 
    0.15517411f, 0.37267298f, 0.22750624f, 0.00851390f, 0.05520881f, -0.02395890f, -0.00209915f, 0.00082712f, 
    -0.06452514f, 0.00518257f, -0.05459522f, -0.00746621f, -0.52851593f, 0.08983779f, -0.12263642f, -0.25114077f, 
    -0.04180820f, -0.05789516f, 0.01428417f, 0.05033231f, 0.19192709f, -0.07272842f, -0.02494131f, -0.08801297f, 
    -0.36306524f, 0.02607129f, 0.07453118f, -0.01192599f, -0.13105328f, 0.05641663f, 0.14531490f, 0.03660160f, 
    0.06259690f, 0.13745674f, 0.03159942f, -0.17120509f, -0.09155199f, 0.10281956f, 0.15151720f, -0.25722980f, 
    0.05262445f, 0.10435558f, 0.02713000f, -0.08385293f, -0.17116737f, -0.10905458f, 0.06741512f, 0.15054348f, 
    0.43166122f, 0.17210248f, -0.08584023f, 0.02907813f, -0.02241094f, -0.16101246f, 0.07233180f, 0.09651048f, 
    -0.04338649f, 0.01060804f, 0.14006926f, -0.05247717f, -0.12868337f, 0.53280151f, -0.20288305f, -0.54079115f, 
    -0.02203892f, 0.04663547f, 0.00339539f, 0.07049651f, 0.01011621f, -0.09237053f, 0.12786022f, 0.02371914f, 
    -0.27812502f, -0.30213204f, 0.16112480f, 0.40858778f, -0.27536911f, -0.04957765f, -0.06550922f, -0.25553596f, 
    0.08020765f, 0.02763590f, -0.03532494f, -0.17583905f, -0.55317438f, 0.10614900f, 0.13819501f, 0.33350110f, 
    -0.03847362f, -0.19242373f, 0.16280390f, -0.06789282f, 0.00491484f, -0.02501664f, -0.17966560f, 0.13292953f, 
    -0.15865347f, -0.17115311f, 0.08606035f, 0.09065462f, 0.04853301f, -0.03026792f, -0.02844502f, -0.02949676f, 
    -0.02578126f, -0.07365724f, 0.04414788f, 0.04733420f, -0.16908489f, 0.07509381f, -0.09816784f, -0.04212942f, 
    0.02290829f, -0.00867078f, 0.05935245f, 0.08831885f, 0.16315453f, -0.03315862f, 0.05132025f, -0.05015132f, 
    0.13042837f, 0.05060522f, -0.04708878f, 0.12792079f, 0.01382076f, 0.03836446f, -0.11966439f, 0.05442398f, 
    -0.15992847f, 0.11915149f, 0.00962617f, -0.11538389f, -0.05977998f, 0.04465925f, -0.04591426f, -0.00878321f, 
    0.02891508f, -0.06161369f, 0.16427262f, -0.16236210f, -0.00423457f, 0.01124592f, -0.06086434f, -0.00106765f, 
    -0.45757124f, -0.38270330f, 0.00443716f, -0.10767558f, -0.13917716f, 0.01855699f, -0.00192554f, -0.05093353f, 
    0.01154664f, -0.09817994f, -0.10857572f, -0.08850461f, 0.04546482f, 0.11804324f, 0.03014474f, 0.20178008f, 
    0.04794865f, -0.01149611f, -0.00850233f, 0.40647525f, 0.16641580f, -0.00868029f, 0.09888770f, -0.07449421f, 
    -0.30143511f, -0.05831326f, 0.16652034f, 0.09017494f, -0.10902616f, 0.00671825f, -0.05383544f, 0.11888494f, 
    0.07705451f, 0.01406852f, -0.00748341f, 0.07523454f, 0.22859569f, 0.06306259f, 0.19325012f, 0.11067881f, 
    0.02230570f, -0.01704348f, 0.04507023f, 0.10953687f, 0.08442821f, 0.15002908f, -0.05532279f, 0.13265237f, 
    0.08053445f, -0.07979089f, 0.14980493f, 0.02652958f, 0.02867659f, -0.05529951f, 0.03463470f, 0.05525200f, 
    0.03735710f, -0.01673733f, -0.10969175f, 0.05308032f, 0.19695151f, 0.08567861f, -0.06262176f, 0.08410944f, 
    -0.13641307f, 0.09698460f, 0.07328541f, 0.00289797f, 0.09305210f, -0.09896279f, 0.18785322f, -0.17989683f, 
    0.41671714f, 0.09459622f, -0.20477416f, -0.19236654f, 0.08450260f, -0.03557400f, 0.08295953f, -0.07532872f, 
    -0.07350844f, -0.01060127f, 0.04362402f, -0.00816324f, -0.29889148f, -0.33826414f, 0.03930444f, -0.05739004f, 
    -0.11238793f, 0.04843866f, -0.01950039f, -0.06586360f, 0.07573219f, -0.06004238f, -0.00193294f, -0.03718598f, 
    -0.19313955f, 0.07357436f, -0.02239625f, -0.25801358f, -0.00447677f, -0.04896031f, 0.02052549f, -0.08848179f, 
    0.01005855f, -0.02887231f, 0.05614594f, -0.01149106f, 0.15601268f, -0.04293353f, 0.06380579f, 0.01605340f, 
    -0.12694538f, -0.03427196f, 0.19788377f, 0.20991403f, 0.03989687f, -0.00361925f, 0.12534319f, -0.01311860f, 
    0.40363404f, -0.08863546f, -0.10020715f, 0.08619267f, -0.13151982f, -0.03629147f, 0.08451393f, 0.04049103f, 
    -0.08436272f, 0.04003315f, -0.01005781f, 0.08405177f, -0.17855164f, -0.05651537f, -0.00199602f, 0.27628079f, 
    0.08205851f, -0.06259172f, 0.11237799f, 0.06312296f, -0.11530832f, -0.09041886f, -0.04561305f, 0.05495347f, 
    -0.09368335f, 0.11627039f, -0.01865193f, -0.32210687f, 0.02438698f, 0.08896364f, -0.24314721f, 0.07619724f, 
    -0.00539529f, 0.12896311f, 0.01981872f, 0.03623502f, 0.22153512f, 0.11682181f, 0.02540164f, -0.01304823f, 
    0.02867267f, -0.10984443f, -0.01763561f, -0.00717205f, -0.02943692f, 0.01226867f, 0.01433522f, 0.15972473f, 
    -0.03095594f, -0.08374736f, 0.07451349f, 0.42076859f, -0.03293640f, -0.00657377f, -0.01165335f, 0.06967919f, 
    -0.01251352f, 0.05600182f, 0.15403566f, 0.05005655f, -0.38907951f, 0.05228984f, -0.24152145f, -0.20991427f, 
    -0.04486266f, 0.04507678f, 0.04361293f, 0.16849500f, 0.13155249f, 0.00962016f, -0.13543747f, 0.05561437f, 
    -1.02607691f, 0.06003401f, -0.25702357f, -0.07625611f, 0.12333813f, 0.02594116f, -0.01893407f, -0.00458393f, 
    -0.01656292f, -0.06890164f, 0.04367550f, 0.07500479f, 0.39251536f, -0.15382034f, 0.06437644f, -0.28656304f, 
    -0.16080220f, -0.08553043f, 0.04560620f, 0.01536573f, -0.10119444f, -0.00920405f, -0.12715246f, -0.10710489f, 
    0.12197810f, -0.15133330f, -0.22434939f, 0.05913412f, -0.28548783f, -0.00898889f, 0.01044301f, 0.06368997f, 
    0.05201802f, 0.09352974f, 0.02074046f, -0.33848476f, -0.43578702f, -0.18271604f, 0.04292683f, 0.11546092f, 
    0.06025600f, 0.01754991f, -0.02974136f, 0.20263797f, -0.04417979f, -0.10972759f, 0.08889840f, 0.11641493f, 
    0.37393001f, 0.08168256f, -0.31590813f, -0.70333833f, -0.03816563f, -0.17317770f, -0.04863056f, -0.15163934f, 
    0.03321839f, -0.11890346f, -0.12116276f, 0.00585370f, -0.09875019f, 0.41365755f, -0.09799455f, 0.07253776f, 
    0.14057653f, 0.07292176f, 0.20826247f, 0.13058908f, 0.09078536f, 0.06002125f, -0.06798150f, 0.02684647f, 
    0.07272944f, -0.10297866f, 0.11404574f, -0.01833591f, -0.18249395f, 0.03728705f, 0.03304864f, -0.06495328f, 
    0.09246492f, 0.04421827f, -0.03103462f, 0.18901344f, 0.21724801f, 0.15450676f, -0.14994881f, 0.00138424f, 
    0.08045281f, -0.01724951f, -0.14058772f, 0.16500208f, -0.21677217f, -0.17891857f, -0.13985986f, -0.25505194f, 
    -0.05896369f, 0.13650483f, 0.24006729f, 0.18738443f, 0.02241044f, 0.07661920f, -0.03325477f, -0.12771632f, 
    -0.03616237f, -0.00363683f, 0.02707248f, -0.03945857f, -0.25857458f, -0.36371690f, 0.35796830f, 0.17631744f, 
    -0.12594518f, 0.13999294f, 0.02316254f, -0.01173387f, -0.08313382f, 0.14184336f, -0.03781476f, 0.17343552f, 
    0.05124039f, 0.01451066f, 0.09806073f, -0.01498637f, -0.06461063f, -0.02497638f, -0.02083063f, 0.09593059f, 
    -0.04287841f, -0.14035681f, 0.13123143f, 0.28167003f, -0.10872015f, 0.05612129f, -0.41223890f, -0.16483590f, 
    0.13493116f, 0.21843843f, -0.11628758f, -0.06406482f, 0.09059447f, -0.02906980f, 0.20280953f, -0.22020683f, 
    0.11283486f, -0.04354037f, 0.18911618f, 0.41012833f, 0.02871774f, -0.15102962f, 0.14192806f, 0.13561176f, 
    -0.21059160f, 0.12495346f, -0.03770222f, 0.04772208f, -0.12908928f, 0.22489384f, 0.01404571f, -0.03512548f, 
    -0.05934023f, 0.01164057f, -0.12596336f, -0.16928466f, -0.02038872f, 0.04191172f, 0.12810712f, 0.07430285f, 
    -0.39757738f, -0.16115595f, 0.25893867f, 0.28861633f, 0.15153614f, -0.02105566f, -0.01704352f, -0.00819107f, 
    0.20984210f, -0.08218462f, -0.05171663f, -0.06325103f, -0.42719930f, -0.19818616f, -0.09263803f, 0.11457261f, 
    -0.15114613f, 0.04959135f, 0.23944752f, 0.04603169f, 0.24220458f, 0.05484577f, 0.00804888f, 0.02964478f, 
    0.15616778f, 0.13811417f, -0.06840517f, -0.00431751f, 0.08981720f, -0.07745799f, 0.02259639f, -0.08843023f, 
    -0.03387449f, -0.02474178f, 0.02704472f, -0.14740685f, -0.72203153f, -0.28433749f, -0.19726269f, 0.16106565f, 
    0.26563817f, 0.03455387f, 0.09316719f, -0.06085346f, -0.00818978f, 0.25927955f, -0.01297713f, 0.05954732f, 
    0.18599325f, 0.01747022f, 0.10768595f, 0.09587644f, 0.06673651f, -0.00042619f, -0.00050310f, -0.05177239f, 
    -0.02576987f, 0.04172733f, -0.10050961f, 0.12808737f, -0.00622226f, -0.39321882f, -0.04345774f, 0.00338819f, 
    0.09418519f, -0.04149185f, -0.13596778f, -0.17504944f, 0.00028109f, -0.08200401f, 0.02927221f, -0.04690467f, 
    0.07892857f, 0.00298937f, 0.04559328f, 0.02637957f, 0.03392106f, -0.01286087f, 0.09210344f, -0.15342075f, 
    0.09545165f, -0.17157064f, 0.15311499f, 0.11106300f, -0.19744579f, -0.04239473f, 0.05548412f, -0.25719574f, 
    -0.07555112f, -0.04847309f, -0.08202613f, 0.20130020f, 0.07981840f, 0.13811748f, -0.04196121f, -0.22370447f, 
    -0.21180631f, -0.23246203f, 0.08665046f, 0.26816472f, 0.08759152f, -0.08083540f, 0.01501563f, 0.07629012f, 
    0.07259264f, -0.05298492f, 0.15959950f, 0.16037104f, -0.05139586f, 0.12059217f, -0.06349277f, -0.03753625f, 
    0.02305601f, -0.03156433f, 0.08332238f, 0.10281286f, -0.00278547f, 0.00581829f, 0.06181528f, 0.00797243f, 
    0.06285047f, -0.14427131f, 0.04990065f, -0.18897176f, 0.05447458f, -0.01220105f, 0.04403489f, -0.13363636f, 
    0.00729211f, -0.01760049f, -0.17942511f, 0.19331731f, -0.07079045f, -0.12461998f, 0.01161589f, 0.20518780f, 
    -0.10212334f, -0.04257002f, -0.13644731f, 0.06286006f, -0.02724089f, 0.01660449f, 0.18181828f, 0.18603902f, 
    0.04578450f, 0.18655981f, 0.22568434f, -0.55716407f, 0.06961209f, -0.06080960f, 0.05908891f, -0.16737328f, 
    0.15121534f, -0.05955311f, -0.06368175f, 0.09927881f, -0.28062522f, -0.28724986f, 0.12592931f, 0.08659990f, 
    -0.02505790f, 0.08515022f, -0.01394572f, 0.10656537f, 0.09694417f, 0.18765232f, 0.12251895f, 0.04366780f, 
    -0.29027969f, -0.11882912f, 0.07985806f, 0.23488955f, -0.24568795f, -0.06917537f, 0.06159904f, -0.07866906f, 
    0.19528748f, -0.27212548f, -0.00934373f, 0.03610381f, -0.36139825f, -0.50948697f, -0.15218113f, 0.11742701f, 
    0.12395971f, 0.14558221f, -0.05493801f, -0.06106614f, -0.22932893f, 0.09821546f, 0.07913466f, -0.07076816f, 
    0.16122067f, -0.18513943f, -0.14020941f, -0.01160537f, 0.10436603f, 0.12658234f, -0.20810921f, -0.09959660f, 
    -0.08724730f, -0.04591574f, -0.14781235f, 0.05789218f, -0.54574060f, 0.18776059f, 0.12084056f, 0.07723983f, 
    0.17503656f, -0.21284810f, 0.09036966f, -0.32716677f, 0.02247031f, 0.00213339f, -0.05728601f, 0.03699304f, 
    -0.68052566f, 0.22424094f, -0.04718931f, -0.53764606f, 0.19322266f, 0.09373467f, 0.00970466f, -0.04593828f, 
    -0.01133352f, 0.08424997f, -0.10446568f, -0.19258897f, -0.13806510f, -0.00049944f, 0.13241850f, -0.05122254f, 
    -0.10450435f, -0.23721385f, 0.07285981f, 0.15704070f, 0.11169045f, 0.22534861f, -0.07195719f, 0.08164226f, 
    0.03362746f, 0.12723710f, 0.21400304f, 0.14139609f, 0.21640228f, 0.14510773f, -0.02657403f, -0.10604573f, 
    -0.14945169f, 0.01026766f, 0.06812655f, 0.25646749f, -0.32724851f, 0.18716481f, -0.16916712f, -0.19208974f, 
    0.04057068f, 0.27102751f, 0.12798573f, 0.01543553f, 0.07946993f, -0.02441534f, -0.04596186f, -0.21591534f, 
    -0.61874330f, -0.44090018f, 0.09627650f, 0.25822872f, -0.08022902f, 0.02137864f, -0.08887113f, 0.08115181f, 
    -0.09694500f, 0.03298588f, 0.08758417f, -0.10872998f, -0.24280721f, -0.09976651f, 0.17863746f, 0.01054186f, 
    -0.02961688f, -0.10317093f, -0.04648846f, -0.05420888f, 0.11025980f, -0.18866590f, -0.17699674f, -0.18409175f, 
    -0.28406328f, 0.28087878f, 0.19840875f, -0.23056382f, 0.03872327f, 0.09075385f, 0.04981333f, 0.08385513f, 
    -0.14327298f, 0.01301391f, 0.00702745f, -0.06563386f, 0.03558663f, -0.31762433f, 0.12892784f, -0.35850900f, 
    0.10812767f, -0.15654017f, 0.13221203f, -0.01781207f, 0.13469937f, 0.19351842f, 0.07522369f, 0.24731968f, 
    -0.06936135f, 0.03506363f, 0.13968426f, -0.14785914f, -0.01880351f, 0.00037247f, 0.00757338f, 0.12801827f, 
    0.08720233f, 0.05950766f, -0.00073943f, 0.15781263f, 0.23947163f, -0.32414851f, -0.20899530f, -0.02273103f, 
    -0.09623944f, 0.09859602f, 0.07324319f, 0.00623876f, 0.29185620f, -0.08474158f, -0.18499768f, 0.14876145f, 
    -0.19617248f, 0.23189087f, -0.07784808f, -0.25605243f, 0.08278634f, 0.11855476f, -0.04991467f, -0.15529384f, 
    -0.09628988f, -0.07867542f, -0.12144340f, 0.07419341f, -0.26867759f, -0.23364247f, 0.00509753f, -0.41855484f, 
    -0.09686729f, -0.02563291f, 0.06134192f, -0.02617058f, -0.03061650f, 0.09494019f, -0.03196784f, 0.21980350f, 
    -0.17031828f, 0.03647083f, -0.11084878f, -0.02129902f, -0.06112643f, 0.00711494f, -0.01203191f, -0.00932732f, 
    0.00623947f, -0.08663560f, 0.07710940f, 0.08046739f, 0.28107738f, 0.11654907f, 0.08883448f, -0.13443111f, 
    -0.23078515f, -0.03436286f, 0.04115507f, 0.09539763f, -0.00670504f, -0.04802291f, -0.26535478f, 0.03183782f, 
    0.11521933f, -0.07982104f, -0.22984634f, 0.11451250f, 0.00231731f, 0.02954641f, 0.07070910f, 0.02116043f, 
    -0.15709753f, -0.10676169f, 0.03254223f, -0.03107366f, -0.31993908f, -0.09590899f, 0.27350846f, 0.04675079f, 
    0.06780568f, -0.23903453f, -0.01959848f, -0.19552791f, -0.12995635f, -0.16868997f, -0.04990733f, -0.03676573f, 
    -0.60956287f, 0.16697007f, 0.10616872f, 0.40004453f, 0.03171779f, 0.10413174f, -0.13140461f, 0.06886429f, 
    0.07038689f, 0.08164795f, -0.00031287f, -0.09319311f, -0.24504365f, 0.19087249f, -0.26513940f, -0.37053961f, 
    -0.12923063f, 0.00347593f, 0.01241653f, -0.07239422f, -0.15512699f, -0.05050427f, -0.09744258f, -0.01000792f, 
    -0.14640783f, 0.40856555f, 0.10639306f, -0.18367514f, 0.06266353f, 0.10765196f, 0.04413728f, 0.09209388f, 
    0.04006534f, 0.05736107f, 0.16669011f, -0.07018734f, -0.04655070f, -0.11899436f, -0.12874827f, 0.27480352f, 
    -0.20460752f, 0.04889601f, -0.09526000f, 0.03778636f, -0.17794605f, 0.10183161f, -0.08681628f, 0.07091031f, 
    -0.09647042f, 0.09293451f, -0.24665599f, -0.46750119f, -0.07409977f, 0.01342390f, -0.05145936f, 0.16048025f, 
    -0.01235462f, 0.16123562f, -0.06215076f, 0.08758598f, 0.23012440f, 0.06603315f, 0.11431301f, -0.28939798f, 
    0.03087781f, -0.09457492f, -0.06933590f, -0.06608177f, -0.18332154f, -0.00040377f, -0.07030617f, -0.02494127f, 
    0.14929619f, -0.16443811f, 0.07382442f, -0.03554736f, -0.12230109f, -0.01748925f, 0.03359814f, -0.11823955f, 
    0.14056817f, 0.03793129f, -0.00216756f, -0.04642656f, -0.19383736f, 0.33998004f, 0.00478856f, 0.38053176f, 
    -0.02288029f, 0.08856000f, -0.17776084f, 0.07834245f, 0.06873985f, 0.01004805f, -0.22037305f, 0.00199584f, 
    0.39995700f, -0.06427275f, -0.17201640f, 0.28311476f, -0.03472633f, -0.14332278f, -0.00233118f, 0.18888769f, 
    0.05133599f, 0.02839334f, -0.01831980f, -0.06255318f, 0.22470044f, -0.09373007f, -0.04169499f, 0.30305728f, 
    0.17149097f, -0.18481617f, 0.03586381f, 0.01580802f, 0.13588421f, -0.00010355f, -0.17226274f, -0.03671413f, 
    -0.51845312f, 0.28274351f, 0.10127895f, -0.19105272f, -0.13590468f, 0.09432074f, 0.10225952f, 0.08460014f, 
    0.01992044f, 0.03610408f, -0.05299253f, -0.07051450f, 0.06273537f, -0.00177668f, -0.41104257f, -0.00452309f, 
    0.04084333f, 0.10850939f, 0.03168533f, -0.19498181f, 0.01874633f, -0.03756685f, -0.10056917f, -0.01238422f, 
    -0.25735471f, 0.11196874f, -0.21226102f, 0.40203539f, 0.09150825f, 0.13683115f, 0.15292908f, -0.00883759f, 
    -0.19549170f, 0.07999032f, -0.04341992f, -0.10546187f, -0.15426739f, 0.10706022f, -0.08983190f, -0.13767089f, 
    -0.00729944f, 0.03806936f, -0.15663554f, -0.07155132f, 0.00370535f, -0.07560179f, 0.07553322f, 0.08352874f, 
    -0.25208643f, -0.25818074f, -0.17753880f, -0.04080031f, -0.09868161f, 0.00967176f, 0.14859360f, -0.02539716f, 
    0.14846158f, -0.09543994f, 0.04092844f, -0.00211914f, 0.11273370f, -0.76412034f, 0.01039165f, -0.16946742f, 
    0.00458340f, 0.11505228f, 0.09385913f, 0.03762620f, -0.08408126f, -0.02547288f, -0.04676633f, -0.03533920f, 
    0.33888105f, -0.29180533f, 0.08868513f, -0.12927108f, -0.00785231f, 0.01163324f, 0.19874875f, 0.05291896f, 
    0.14734519f, -0.08827615f, 0.17729938f, 0.15888992f, -0.16577429f, -0.06183856f, -0.19278345f, 0.32306248f, 
    0.04333453f, 0.21511969f, 0.08378589f, -0.11003330f, -0.01654022f, -0.15610652f, -0.08805624f, -0.28061503f, 
    -0.14951256f, 0.19583808f, 0.14801414f, -0.14318538f, -0.09875350f, -0.14317447f, 0.19253178f, -0.11159881f, 
    0.11611916f, 0.04248863f, 0.05934273f, -0.46909851f, 0.55299687f, -0.17794235f, 0.09013829f, -0.01902235f, 
    -0.02821713f, 0.01920418f, -0.02615874f, -0.13237806f, -0.12095286f, 0.02883859f, 0.03335318f, 0.24561477f, 
    0.33313471f, -0.20314811f, -0.07801455f, -0.00849959f, 0.12951064f, 0.11809956f, -0.01839261f, -0.10040572f, 
    -0.13023263f, 0.14699413f, 0.09276293f, -0.00811641f, 0.47282279f, -0.49341527f, 0.01304247f, 0.06347972f, 
    -0.16387732f, 0.06172279f, 0.05685095f, 0.02398136f, -0.17150673f, 0.15166374f, 0.05423097f, 0.21319298f, 
    0.08440633f, -0.21985409f, -0.12078438f, -0.12936001f, 0.00614542f, 0.17974640f, -0.09815434f, 0.02615556f, 
    -0.17877732f, -0.15429020f, 0.06535412f, -0.15521578f, 0.21933509f, 0.10237753f, 0.13669568f, 0.27624467f, 
    -0.12832205f, -0.12223611f, 0.13798450f, -0.08625492f, -0.11369890f, 0.06066162f, 0.05420412f, 0.02465453f, 
    -0.12563865f, 0.05623625f, -0.07497226f, -0.08657467f, -0.13798517f, 0.00151231f, 0.03101327f, -0.11946344f, 
    0.01395163f, 0.01940843f, -0.03202957f, -0.11258736f, -0.57613760f, 0.19732511f, -0.10694826f, -0.07239381f, 
    -0.07206135f, -0.10433381f, -0.00401711f, -0.16931292f, -0.10549305f, 0.00496485f, 0.07876279f, -0.08232071f, 
    -0.22276483f, 0.17722541f, -0.38398272f, -0.04511836f, -0.13073294f, -0.05194406f, -0.19195111f, -0.11908440f, 
    -0.21383566f, 0.02784556f, 0.16160466f, -0.14605615f, -0.08125671f, 0.14995542f, 0.00000924f, 0.01693587f, 
    -0.08332042f, 0.11820988f, 0.12954719f, -0.09220033f, -0.09887868f, -0.01096810f, -0.00881129f, -0.15063843f, 
    -0.06442822f, -0.04261421f, -0.03021219f, 0.15703748f, 0.01590082f, -0.26770055f, -0.13748667f, -0.08339813f, 
    -0.08389010f, -0.23452367f, -0.01753093f, -0.05043384f, -0.09034979f, 0.13763160f, -0.22874111f, 0.11343338f, 
    -0.12787585f, -0.04995913f, 0.06184424f, -0.11673240f, -0.27026406f, -0.07019369f, -0.12832138f, -0.12179693f, 
    0.01834376f, 0.03936359f, 0.00167240f, 0.22105992f, 0.12803060f, -0.14064848f, -0.11955469f, 0.12126921f, 
    -0.08955297f, -0.03479238f, -0.03745978f, -0.05326634f, -0.08006044f, -0.20047055f, 0.08176468f, 0.09821945f, 
    0.10366706f, -0.04051010f, -0.09502606f, 0.02025256f, -0.04952233f, -0.03157396f, -0.01480854f, 0.05659176f, 
    -0.54616636f, 0.12321768f, 0.08253368f, -0.21616812f, -0.15737726f, 0.00242426f, -0.07955590f, -0.07952680f, 
    0.00174521f, 0.00563011f, 0.00492858f, -0.09754819f, 0.03200734f, 0.26405591f, 0.17600720f, 0.20972654f, 
    0.12945426f, 0.10345390f, 0.01132592f, -0.11310376f, -0.03531297f, 0.04026507f, -0.05607455f, -0.05199660f, 
    -0.23847035f, -0.02576515f, -0.22466978f, -0.23493905f, 0.00710174f, 0.05434109f, -0.02470483f, -0.06803414f, 
    -0.14343955f, -0.00588244f, -0.00535386f, -0.14413199f, 0.24398780f, 0.01690629f, 0.09186910f, 0.13607642f, 
    0.16409665f, -0.03968148f, 0.02913865f, -0.03713964f, 0.03837970f, -0.09297011f, -0.04129962f, 0.01386169f, 
    0.16960080f, -0.02156735f, 0.09000821f, 0.15352714f, 0.03946766f, 0.00256456f, -0.04043586f, -0.14088686f, 
    -0.06458765f, 0.05215085f, -0.11744134f, -0.10574380f, -0.07056944f, -0.12459485f, -0.16934019f, -0.31150618f, 
    0.13406560f, -0.01719152f, -0.16226004f, -0.12810074f, -0.00795691f, 0.00814337f, 0.11391030f, -0.10714345f, 
    0.31360793f, -0.05358991f, 0.03253531f, 0.16944385f, 0.10727457f, -0.02530268f, 0.08237806f, -0.07111923f, 
    -0.06152489f, 0.01694655f, -0.03480688f, -0.21121523f, -0.22260496f, -0.19427401f, -0.32260996f, -0.09588777f, 
    0.06465421f, -0.18511805f, 0.04601208f, -0.02749833f, 0.01095710f, 0.00851914f, -0.00580959f, -0.02238814f, 
    0.05434400f, -0.19076592f, 0.21766505f, -0.04895559f, 0.06335055f, 0.02060008f, -0.12584811f, 0.01233603f, 
    -0.10199904f, -0.00275042f, 0.03307212f, -0.10655981f, -0.08026839f, 0.09912994f, -0.03519037f, 0.22916077f, 
    0.11398522f, -0.09676419f, -0.09348943f, 0.06014803f, -0.06040730f, 0.05584868f, 0.01749269f, -0.03458009f, 
    -0.22253628f, 0.32152724f, 0.04612206f, -0.14698777f, -0.07448534f, -0.02136484f, -0.07962434f, -0.11178960f, 
    -0.05287648f, -0.02415612f, -0.01293786f, -0.11859767f, 0.21409787f, 0.08197288f, 0.21193606f, 0.16325438f, 
    -0.12631881f, 0.08238930f, -0.03142570f, -0.00876194f, -0.01174904f, -0.16926767f, 0.00859410f, -0.02612488f, 
    -0.02695240f, -0.17137992f, 0.02036999f, -0.07125774f, -0.06081072f, -0.14778984f, -0.01169441f, 0.01515628f, 
    -0.03352915f, 0.00996797f, -0.02496504f, -0.05769011f, 0.03955283f, 0.17467797f, 0.00385710f, 0.14691395f, 
    -0.00117626f, 0.03370005f, -0.02747130f, 0.01888323f, -0.06200051f, -0.09300256f, -0.12258437f, -0.00510924f, 
    0.15686171f, 0.25537959f, 0.07854188f, 0.26390341f, 0.18517944f, 0.10365434f, 0.06771149f, -0.05044972f, 
    -0.01773766f, 0.04004730f, -0.00009912f, -0.16685511f, -0.04698161f, -0.22907178f, 0.11767154f, -0.04182714f, 
    0.06031910f, -0.00700928f, -0.00183336f, -0.03819477f, -0.05709755f, 0.06770567f, 0.04921326f, -0.01726795f, 
    0.38507563f, -0.22823498f, 0.22798696f, -0.28668755f, 0.01159805f, 0.01805936f, -0.06845008f, -0.04010231f, 
    -0.05169781f, 0.20448382f, -0.08038069f, -0.01365102f, 0.42049342f, -0.09538989f, -0.07427880f, 0.21890667f, 
    0.06820419f, -0.07837824f, -0.04555076f, -0.09817281f, -0.01450083f, -0.05302830f, -0.00918258f, -0.12705468f, 
    -0.23174091f, -0.04353129f, -0.08256569f, 0.15939425f, 0.24464989f, -0.04071409f, -0.04292807f, 0.01071536f, 
    0.04055120f, -0.03939467f, 0.16458495f, -0.07741562f, -0.03067186f, 0.23972039f, 0.21207263f, 0.21954183f, 
    0.12800883f, -0.05650386f, 0.09866876f, 0.13515557f, -0.07895440f, -0.01845277f, 0.04572711f, 0.02240812f, 
    0.50431484f, 0.09550580f, 0.18182053f, 0.17078230f, 0.31248125f, 0.00286621f, 0.09887680f, 0.04642722f, 
    0.02481237f, -0.08002502f, -0.00686601f, 0.01142286f, -0.12955816f, -0.01706202f, 0.00937227f, -0.11624156f, 
    0.13246728f, -0.03947151f, -0.01908012f, -0.07853539f, -0.06205576f, -0.05405956f, 0.06016778f, -0.11988718f, 
    0.06191768f, -0.06797010f, -0.24304661f, 0.15946758f, 0.20249566f, -0.00753265f, 0.00965130f, -0.06723429f, 
    -0.13596940f, 0.12370798f, -0.13306928f, 0.32010010f, -0.27976441f, 0.01922694f, -0.12076974f, -0.10141478f, 
    -0.05635647f, -0.01718184f, -0.14396623f, 0.12402876f, 0.11894792f, -0.21350572f, -0.14998429f, 0.07200909f, 
    0.28056914f, 0.09005991f, 0.05795508f, 0.25553682f, 0.10056568f, 0.01940725f, -0.15669711f, -0.10278771f, 
    0.07324960f, -0.12716043f, 0.12437399f, -0.04470612f, -0.02753063f, -0.16730089f, 0.13590562f, 0.03285499f, 
    0.06217182f, -0.05775846f, -0.10550528f, -0.02723166f, 0.16340022f, 0.07105853f, 0.01380402f, 0.07445500f, 
    -0.16622007f, -0.30161658f, -0.24262497f, -0.13518693f, 0.20792699f, -0.05374588f, 0.08399953f, 0.13180208f, 
    0.14136213f, 0.08870953f, 0.13283527f, 0.05604566f, -0.14843768f, 0.17033060f, 0.23702431f, 0.08801408f, 
    -0.11723590f, 0.07875520f, -0.22295381f, -0.07924094f, 0.01586468f, -0.04567372f, 0.05505564f, -0.27599481f, 
    -0.20041689f, 0.03882369f, -0.07252736f, -0.48289388f, -0.00920015f, 0.02395363f, -0.06690441f, 0.11979400f, 
    0.17998698f, 0.17509878f, 0.04009135f, -0.04214034f, -0.29039738f, 0.12550743f, 0.07266359f, 0.13114375f, 
    -0.07984436f, 0.02806560f, -0.00718912f, -0.15707499f, 0.08895445f, 0.07811195f, 0.14505917f, -0.09537579f, 
    0.10143725f, 0.38161898f, -0.23111610f, -0.30615711f, -0.06602214f, -0.11607672f, -0.21144845f, 0.03136279f, 
    0.09907144f, -0.02059187f, 0.01962367f, 0.03021267f, 0.05703765f, 0.19084685f, 0.07028329f, 0.10360321f, 
    -0.07678507f, 0.06001707f, -0.06050665f, -0.02445426f, 0.02054011f, 0.09113599f, 0.02185409f, -0.03501308f, 
    0.20804816f, 0.05536361f, -0.34812421f, 0.11588614f, 0.15473217f, 0.05003532f, -0.01882428f, -0.15134373f, 
    -0.05180142f, -0.12086577f, -0.02251115f, 0.09636010f, -0.24965942f, -0.06112705f, 0.34320259f, -0.20114899f, 
    -0.00347284f, -0.04884091f, -0.03726585f, -0.19110258f, 0.07326012f, 0.08332689f, -0.02503100f, 0.13477187f, 
    -0.06920595f, -0.07137343f, 0.10804866f, 0.15959749f, 0.16265962f, -0.04858297f, -0.10474388f, -0.02473288f, 
    0.01991585f, 0.04353708f, -0.06149637f, -0.09072858f, 0.17640175f, 0.15050417f, -0.12340240f, 0.19177617f, 
    0.03652199f, -0.12672867f, 0.05157431f, -0.04698615f, -0.02942463f, -0.03328619f, -0.05973551f, -0.01808967f, 
    -0.42734540f, -0.18285961f, -0.07910451f, -0.21176583f, -0.02586132f, -0.01716693f, 0.17363064f, -0.28446829f, 
    -0.00701654f, -0.04718269f, 0.00900536f, 0.07826632f, -0.00294665f, -0.08372480f, 0.02712100f, 0.19841431f, 
    -0.01396709f, -0.07413466f, 0.18977956f, 0.12117466f, 0.06119268f, 0.09254508f, -0.03413584f, -0.06324624f, 
    0.12677987f, -0.09578248f, 0.00669667f, -0.20255457f, 0.11887369f, 0.01263618f, 0.02793175f, 0.05224506f, 
    0.07766110f, -0.07303803f, -0.02559385f, 0.14060016f, 0.17378506f, 0.22922395f, -0.38294736f, -0.03558392f, 
    -0.06580829f, 0.02015402f, 0.02810500f, -0.09336585f, 0.07663307f, -0.05103267f, 0.10484514f, -0.05295699f, 
    -0.27021047f, -0.22364581f, -0.06720938f, -0.32822964f, -0.04338409f, 0.11576030f, -0.07866270f, -0.14413306f, 
    0.04479222f, -0.06685272f, -0.21945179f, 0.16886236f, -0.37774876f, 0.05690959f, -0.49406329f, -0.32434678f, 
    0.04911658f, -0.01593970f, -0.58529574f, -0.03347524f, -0.14476506f, -0.11123462f, 0.19555905f, 0.00445209f, 
    0.30074766f, -0.23308660f, 0.12707207f, 0.22408697f, 0.11012432f, -0.07561060f, -0.10290757f, -0.03695304f, 
    -0.02819682f, -0.06353376f, 0.08239547f, -0.10291898f, -0.00796997f, 0.23036674f, -0.20468904f, -0.06297924f, 
    0.01985192f, 0.00007681f, 0.05098716f, -0.12364998f, -0.02197888f, 0.09213823f, 0.11755707f, 0.09408275f, 
    0.34340286f, 0.27104232f, 0.00109636f, -0.07253639f, 0.01743639f, 0.04620425f, -0.04556700f, -0.11285751f, 
    0.02306405f, 0.09793856f, 0.14571717f, 0.02062729f, -0.08804279f, -0.05369532f, 0.01816444f, -0.32763714f, 
    0.15432552f, -0.17831837f, 0.16448899f, -0.03072142f, -0.05933464f, 0.13739754f, 0.10068270f, -0.20516156f, 
    -0.31464592f, 0.16371217f, 0.16752426f, -0.05055933f, -0.13435274f, 0.01886609f, -0.12264360f, 0.03118937f, 
    0.05423523f, -0.08123250f, -0.04414617f, -0.14015885f, 0.02425208f, -0.17268495f, 0.29114881f, 0.01831582f, 
    -0.15531334f, -0.26221561f, 0.02126544f, -0.06080208f, -0.18893193f, -0.03300545f, -0.05380438f, 0.06023704f, 
    -0.32249489f, -0.01373742f, 0.15841515f, -0.04375372f, -0.06217251f, -0.09828912f, 0.07061525f, -0.12158040f, 
    0.09175247f, -0.08056580f, -0.22301057f, -0.09853115f, 0.20398761f, 0.15129401f, -0.03267093f, -0.16103418f, 
    -0.05776438f, 0.07657363f, 0.05656278f, -0.02116487f, -0.04419221f, 0.02493541f, 0.07999928f, 0.06670791f, 
    -0.20365369f, -0.10433796f, -0.16828370f, -0.00750326f, 0.05989343f, 0.00651151f, -0.21161558f, -0.00544576f, 
    -0.05014361f, 0.10641292f, 0.02844637f, 0.07293901f, 0.06233030f, -0.17310826f, 0.07872036f, -0.10880337f, 
    -0.05615357f, -0.21766502f, -0.02072123f, -0.07647515f, -0.01616124f, -0.15864238f, -0.25122172f, -0.20965260f, 
    0.18678968f, -0.36242786f, 0.07133093f, -0.21574560f, 0.00622989f, 0.10055539f, 0.06054446f, 0.05150550f, 
    0.10681740f, 0.02402779f, -0.00709437f, -0.07791267f, 0.19280127f, -0.21374339f, 0.13262554f, 0.12484708f, 
    -0.01025422f, -0.07442097f, -0.07329077f, -0.04772804f, 0.04885711f, -0.27173391f, 0.07696233f, -0.14730358f, 
    -0.04752124f, -0.12388588f, 0.26401415f, -0.11105243f, 0.15764607f, 0.02674084f, -0.15884739f, -0.08407434f, 
    0.20770355f, -0.04685268f, 0.03977704f, -0.25919688f, 0.38878459f, 0.08668948f, -0.16542576f, -0.07203051f, 
    0.01874153f, -0.11591571f, -0.02586108f, -0.10172027f, -0.15743168f, 0.00593430f, 0.06732431f, 0.19438562f, 
    -0.40109381f, 0.19303353f, -0.57803530f, -0.13791050f, 0.16679363f, -0.00991873f, 0.08528048f, 0.02444371f, 
    -0.06075360f, 0.15668721f, -0.18993016f, 0.02161691f, -0.36882326f, 0.31489074f, -0.51500368f, -0.20536913f, 
    0.07028275f, -0.19605900f, -0.06171829f, 0.13787647f, 0.01738540f, 0.11433811f, 0.04978198f, -0.17090097f, 
    -0.21264158f, 0.10628593f, 0.26813188f, -0.58921802f, -0.09415656f, -0.10891719f, 0.13629685f, -0.12745006f, 
    -0.02908931f, -0.02621975f, -0.04576255f, -0.19065231f, -0.20725569f, -0.05378174f, 0.02459064f, -0.06947763f, 
    0.16995725f, 0.05431573f, -0.14671385f, 0.11279390f, 0.16769312f, 0.10879581f, -0.07529801f, 0.13681059f, 
    -0.07744917f, -0.46170226f, 0.06831305f, -0.13493168f, -0.14067158f, 0.02883621f, 0.05163772f, 0.04314002f, 
    0.08355919f, -0.10661034f, 0.07228460f, 0.04046142f, -0.05346194f, 0.41658330f, -0.43597007f, -0.02838841f, 
    -0.04036867f, -0.04372657f, 0.18739304f, 0.05066471f, -0.09590425f, 0.05359688f, 0.02853060f, 0.09565216f, 
    -0.01863504f, -0.14693744f, -0.03879772f, -0.30228424f, -0.16176696f, 0.01390992f, 0.07127377f, 0.02605574f, 
    0.01678948f, -0.07297798f, 0.02557703f, 0.08520342f, 0.55970079f, -0.70102841f, 0.04531102f, 0.14685021f, 
    -0.08994727f, -0.07339891f, -0.01778812f, 0.22742784f, -0.21271631f, 0.04950660f, 0.04921800f, 0.02945518f, 
    0.00341339f, 0.30816141f, 0.29344770f, -0.01643912f, -0.02502721f, 0.12361128f, 0.11896175f, 0.08019338f, 
    0.03455585f, -0.03068797f, -0.01762591f, 0.01813630f, -0.07398982f, -0.72607803f, -0.04693970f, 0.03939158f, 
    0.05288345f, 0.17445783f, 0.02712343f, -0.24710101f, -0.04376671f, -0.13557838f, -0.07596097f, -0.18165101f, 
    -0.09157819f, 0.07692238f, 0.09373832f, -0.37385756f, 0.10374486f, 0.13267554f, 0.02839893f, 0.02795077f, 
    -0.12494096f, -0.09151961f, 0.02009645f, -0.04800723f, -0.11592121f, -0.48241821f, 0.23473872f, -0.15544258f, 
    0.06016789f, -0.06905145f, 0.00196716f, 0.02372990f, 0.00308590f, -0.00464492f, 0.14152457f, 0.08980813f, 
    0.11541314f, -0.00862650f, -0.13230948f, 0.05419208f, 0.15291885f, 0.19569418f, 0.06380646f, 0.05573862f, 
    -0.15076643f, 0.00415845f, 0.07569957f, -0.08224054f, -0.15307033f, 0.03085749f, -0.02463290f, -0.20038889f, 
    0.06958908f, -0.18481712f, -0.26024321f, -0.35947379f, -0.09664661f, -0.08867744f, -0.24221314f, -0.01697526f, 
    0.04162163f, -0.14478408f, 0.06959120f, 0.13202830f, 0.05608984f, -0.03263552f, -0.03986988f, 0.14880776f, 
    -0.10908793f, -0.13600139f, 0.12550434f, 0.01369503f, 0.24387114f, 0.05157711f, 0.35519737f, 0.00481346f, 
    -0.06339280f, 0.15359418f, -0.10217541f, -0.02148077f, -0.08403720f, 0.02890877f, -0.00667150f, 0.03963612f, 
    -0.01843295f, -0.27230713f, -0.28561980f, 0.20276587f, -0.02383180f, 0.10377583f, 0.00237701f, 0.08617540f, 
    -0.04576477f, -0.08064637f, 0.15325737f, 0.02844365f, -0.15056084f, -0.14440402f, 0.27060512f, -0.17609575f, 
    -0.09696133f, 0.01384705f, -0.03754581f, 0.10085363f, -0.17066070f, 0.08410703f, -0.28178281f, -0.07697344f, 
    -0.62794310f, 0.43467668f, -0.14230491f, -0.08950730f, 0.09171388f, 0.04399920f, -0.14935131f, -0.17438661f, 
    0.10542180f, -0.00882587f, 0.06806147f, 0.08402770f, -0.20967351f, -0.18944199f, 0.05780705f, 0.21086155f, 
    -0.01309799f, -0.04090690f, -0.12252320f, 0.02614907f, 0.10273637f, -0.08756651f, 0.10686786f, -0.06953359f, 
    0.69342405f, -0.03863493f, 0.13641478f, -0.19233197f, 0.03863879f, 0.03579531f, 0.08334044f, -0.03372977f, 
    0.13321900f, 0.07831208f, 0.04325897f, 0.04299957f, 0.05733895f, -0.20087278f, -0.12205806f, 0.18267648f, 
    0.07148830f, -0.09094559f, 0.04936600f, 0.15081756f, 0.16182762f, -0.03575659f, -0.05923449f, -0.06580166f, 
    -0.18117312f, -0.23884028f, 0.13899252f, -0.04161967f, 0.02517861f, -0.03260012f, -0.03595277f, 0.23520462f, 
    -0.10491695f, -0.06766901f, -0.09982453f, 0.06312440f, 0.79666913f, 0.14482723f, -0.10809943f, 0.12222486f, 
    0.16039649f, 0.05414550f, -0.07717890f, 0.08924681f, 0.01762904f, 0.00095826f, 0.02833586f, 0.10294621f, 
    0.09691244f, -0.21914470f, -0.06720876f, 0.25250542f, -0.04469046f, 0.07853399f, -0.09509385f, 0.00973700f, 
    -0.05906955f, 0.11729684f, 0.10604051f, 0.00860072f, 0.14278348f, -0.12905641f, 0.22006002f, -0.11662983f, 
    0.06650661f, 0.07305468f, -0.14160693f, 0.01519438f, -0.12457779f, 0.11977989f, 0.02149516f, -0.00829836f, 
    0.12566786f, -0.11981913f, -0.17776349f, -0.20502268f, -0.11532836f, -0.10557481f, -0.02726466f, 0.05470707f, 
    -0.12566583f, -0.20943744f, 0.28301963f, -0.18893053f, -0.61687976f, -0.24355567f, -0.04072288f, 0.16854100f, 
    0.14488670f, 0.06894614f, -0.08578733f, -0.07503971f, 0.04614793f, 0.00314756f, 0.15268148f, 0.01321670f, 
    -0.18643169f, -0.20448355f, 0.34642985f, 0.10316274f, 0.19647872f, -0.13645060f, 0.09481306f, -0.19765693f, 
    -0.08354944f, -0.14642143f, 0.14551714f, 0.20440346f, 0.03832886f, -0.28731132f, 0.08406891f, -0.09797414f, 
    -0.00812598f, 0.16550680f, -0.03503186f, -0.15598468f, 0.10988185f, 0.06611402f, 0.09543911f, 0.09379491f, 
    -0.72430080f, -0.18862203f, -0.31872770f, -0.32371968f, 0.15203027f, -0.08798774f, 0.00227509f, -0.17601979f, 
    -0.01937304f, 0.13150567f, -0.07606631f, 0.15945616f, -0.18463391f, -0.10223461f, 0.12598373f, 0.17774241f, 
    0.00618521f, 0.03812320f, -0.16552728f, -0.08707231f, 0.14704669f, -0.08283263f, -0.06317074f, -0.21268778f, 
    -0.44753602f, -0.05115701f, -0.40335262f, -0.34120816f, 0.08448622f, 0.11924499f, -0.17234759f, 0.01829540f, 
    -0.13250983f, -0.01234525f, -0.12664661f, -0.10011584f, 0.02029796f, 0.19348566f, -0.09958775f, -0.30087930f, 
    0.07980839f, -0.08953071f, -0.01600042f, 0.14228925f, 0.09703879f, -0.05209426f, 0.06280184f, 0.08587362f, 
    -0.10199030f, 0.14793858f, 0.25844249f, -0.07804718f, 0.05741021f, -0.00834867f, 0.07105071f, 0.17567739f, 
    -0.02602679f, 0.12538478f, 0.17543529f, 0.21404351f, 0.32616836f, 0.03506687f, -0.21382149f, 0.17491315f, 
    -0.14372641f, 0.02410872f, 0.09197686f, 0.06622256f, 0.06016466f, 0.09768554f, -0.00885281f, -0.10048444f, 
    0.39679095f, 0.12340423f, -0.00577837f, 0.07104319f, 0.02405999f, 0.16269225f, 0.02337802f, 0.08847029f, 
    0.02109948f, 0.14370908f, -0.12472468f, 0.13686396f, -0.41347662f, -0.45195606f, 0.11293492f, -0.09432331f, 
    0.02457157f, -0.03269130f, -0.06419291f, 0.01202985f, 0.01188245f, 0.17021136f, -0.05655955f, -0.14220940f, 
    -0.25544551f, 0.00830641f, -0.02028810f, -0.05407771f, 0.24049333f, 0.00651026f, 0.12512365f, -0.02359740f, 
    0.18733712f, 0.11159483f, 0.08433189f, 0.00733482f, 0.15201645f, -0.06309251f, -0.03284085f, -0.07577268f, 
    -0.15890391f, 0.04800660f, 0.02175658f, 0.01669656f, 0.03708030f, 0.10506479f, 0.08672709f, 0.10564857f, 
    -0.88443136f, -0.45759150f, 0.07798528f, 0.09949178f, 0.24975073f, -0.04900362f, 0.17203847f, -0.16883999f, 
    0.21841456f, 0.01828448f, 0.05801449f, 0.17203638f, 0.14880408f, 0.06936561f, 0.06024579f, -0.16835603f, 
    0.08849952f, -0.00799717f, 0.08766176f, -0.08933746f, 0.08844335f, 0.15570773f, 0.05863535f, 0.05284961f, 
    -0.73301607f, -0.19758891f, -0.09387439f, -0.16096382f, 0.22866789f, 0.01640717f, -0.16992733f, -0.23173110f, 
    -0.01523712f, -0.17901561f, -0.09756117f, 0.03251826f, -0.46428576f, 0.15476841f, -0.26230401f, 0.01980755f, 
    -0.00001323f, -0.12011879f, -0.16286097f, -0.03620704f, 0.00542332f, 0.01638074f, -0.05768977f, -0.18910718f, 
    0.19644049f, 0.19255792f, 0.04136477f, -0.01312175f, -0.05954422f, 0.11371113f, 0.19884753f, 0.06787460f, 
    -0.01398884f, -0.10678456f, 0.06105012f, 0.09928983f, 0.17074645f, 0.16494051f, -0.14964306f, -0.09497967f, 
    -0.02049106f, -0.07947759f, 0.14351952f, 0.29001370f, 0.08500723f, 0.20980820f, 0.09442263f, 0.20065530f, 
    0.03279090f, 0.06520728f, 0.03914572f, 0.05725798f, 0.01978628f, 0.02789185f, 0.12817471f, -0.12176359f, 
    0.11117874f, 0.17003737f, -0.04668645f, 0.05531291f, -0.65933931f, -0.18942288f, 0.18865275f, 0.12958476f, 
    0.23178872f, -0.07515872f, 0.04274600f, -0.00649250f, 0.08577410f, -0.09142584f, 0.05437908f, 0.10624244f, 
    0.11383806f, 0.17260978f, -0.07013005f, 0.21421652f, 0.13562703f, 0.14929755f, 0.00621708f, -0.02964077f, 
    0.06155328f, 0.10323802f, -0.15956108f, 0.08856876f, -0.06687105f, -0.24960849f, -0.05651823f, -0.05435432f, 
    -0.00434690f, -0.03374201f, -0.10640230f, -0.19337879f, -0.21878082f, -0.05977573f, -0.04105625f, -0.02057307f, 
    -0.64012986f, -0.62320769f, -0.36769122f, -0.00701339f, 0.04244953f, 0.06145660f, 0.00275412f, 0.03308598f, 
    0.09293820f, -0.06790312f, 0.03888054f, 0.11302706f, 0.28855556f, -0.03041795f, 0.02739847f, -0.11720935f, 
    -0.05028097f, 0.10455631f, 0.02515349f, -0.12399271f, 0.17394869f, 0.09430948f, 0.08062406f, -0.00087117f, 
    -0.37649062f, -0.00937888f, 0.21955889f, 0.09532236f, 0.08490710f, 0.02416676f, -0.11048197f, 0.05777801f, 
    -0.08904085f, 0.04986772f, 0.01145211f, 0.03654638f, 0.18301143f, -0.11861271f, 0.10679521f, -0.29005319f, 
    -0.10620136f, -0.06350085f, 0.13279539f, -0.04083477f, -0.10249906f, -0.14099018f, -0.16616993f, -0.23631907f, 
    0.22572553f, 0.06815774f, 0.05198623f, -0.29716876f, -0.17197871f, 0.04452089f, -0.03927289f, -0.20509598f, 
    -0.05551045f, -0.02053057f, 0.04081529f, -0.02956622f, 0.13843973f, 0.21185280f, -0.01485713f, 0.03750989f, 
    -0.07616441f, -0.13652876f, -0.01863070f, 0.05666991f, -0.05645557f, 0.01258784f, 0.08234719f, -0.07681052f, 
    0.21898969f, -0.01155442f, -0.11321153f, 0.19041963f, -0.16441737f, -0.06258680f, -0.13566798f, 0.14098486f, 
    -0.04539389f, -0.11068039f, -0.20328374f, -0.04254983f, -0.08197436f, 0.10627112f, 0.05350191f, -0.01610228f, 
    0.01902395f, -0.05172213f, 0.06183110f, 0.09921277f, -0.00356050f, 0.21827240f, 0.11544754f, 0.22917026f, 
    -0.37221572f, -0.38514757f, 0.00923998f, -0.18211956f, 0.21908544f, 0.04836137f, -0.11590797f, 0.06874827f, 
    0.03867723f, -0.01050390f, -0.01719592f, 0.24454916f, 0.29659611f, 0.09797625f, 0.01294501f, 0.00924183f, 
    -0.25981322f, -0.28807035f, 0.05010199f, 0.03273976f, 0.17726524f, 0.12806477f, -0.14746456f, -0.17153792f, 
    -0.25469440f, 0.06636938f, -0.32541549f, 0.03612893f, -0.08605173f, -0.06071808f, -0.03973767f, 0.11150751f, 
    0.14835897f, 0.05055562f, 0.04502283f, -0.25311178f, 0.09995281f, 0.07179534f, -0.15455665f, -0.17555322f, 
    0.12787835f, -0.07395245f, -0.20648766f, -0.02040480f, 0.01716227f, -0.08826048f, -0.04111975f, -0.02047854f, 
    0.63007194f, 0.09521480f, -0.48017317f, 0.07045760f, -0.00192536f, -0.01181669f, -0.07857603f, 0.00489252f, 
    -0.03120086f, -0.07096849f, 0.13544385f, -0.12574898f, -0.03757763f, -0.05930971f, 0.13793479f, -0.11484010f, 
    -0.02125916f, -0.12439384f, -0.05533757f, -0.00813699f, 0.03730001f, 0.06915273f, 0.22508739f, 0.08616816f, 
    -0.10462330f, -0.42834571f, -0.13528401f, -0.35315830f, 0.13483611f, -0.01002128f, 0.11756773f, -0.09088245f, 
    0.06081376f, 0.09556121f, -0.00335725f, 0.06579704f, 0.13624601f, -0.24037127f, 0.13839437f, 0.44186297f, 
    0.08236449f, 0.01943200f, 0.10794514f, -0.07686171f, -0.05316945f, -0.04489308f, 0.15974414f, -0.00874706f, 
    0.29906923f, 0.39485958f, -0.29648504f, -0.02189894f, 0.21092156f, 0.02991833f, -0.03562228f, 0.00608390f, 
    0.11228895f, 0.01672976f, -0.14142053f, -0.15677223f, 0.17132264f, -0.14758919f, -0.02461789f, 0.04859436f, 
    0.00541539f, -0.04257574f, 0.02029259f, 0.04534759f, 0.19103053f, -0.01043452f, -0.10241593f, 0.05515715f, 
    0.11524475f, 0.08742913f, -0.14892787f, 0.12775835f, -0.01483280f, 0.07535163f, -0.01408604f, 0.02801631f, 
    0.09931779f, -0.09493585f, -0.03163407f, -0.09613440f, -0.05022898f, -0.31825668f, -0.15707172f, 0.30307344f, 
    -0.08814871f, -0.10561951f, -0.00946606f, -0.04509598f, -0.02240869f, 0.03974343f, -0.05139147f, 0.09765016f, 
    0.07792204f, -0.39577466f, -0.11674717f, 0.17616478f, -0.17253371f, 0.07982936f, -0.03786185f, -0.02141329f, 
    0.05755013f, 0.07082330f, -0.05800531f, 0.02468582f, -0.44248268f, 0.15576312f, -0.00149707f, -0.00188923f, 
    0.04207060f, 0.07596075f, -0.08159505f, 0.12708583f, -0.10868299f, 0.00536685f, 0.16264591f, 0.04558048f, 
    0.25598133f, 0.08213022f, 0.12507884f, -0.07942079f, 0.19721940f, -0.00472137f, -0.11264664f, -0.01767753f, 
    0.03899071f, 0.04122299f, 0.05852314f, 0.09724434f, 0.18825437f, 0.23849988f, -0.16788884f, -0.26390997f, 
    -0.12570125f, 0.04038447f, -0.08461066f, -0.10584994f, -0.02512428f, -0.14051093f, -0.06329406f, -0.23512538f, 
    0.60092610f, 0.07710884f, -0.10235801f, -0.35995921f, -0.07404868f, -0.05584072f, -0.03400521f, 0.10021807f, 
    0.06569135f, 0.01649562f, 0.01517601f, 0.07855611f, -0.40354466f, 0.08188231f, -0.01265428f, 0.14804384f, 
    -0.01784260f, 0.10058071f, -0.01749391f, 0.07603785f, 0.02993112f, 0.05696836f, -0.01718936f, 0.11771943f, 
    -0.27467173f, 0.20324764f, -0.10543434f, -0.09822863f, -0.12053753f, -0.01209154f, 0.09315713f, 0.03097352f, 
    -0.04079757f, -0.04776146f, -0.03558489f, -0.07748215f, 0.11452167f, 0.01578907f, -0.16266112f, -0.19883303f, 
    0.13422401f, 0.01400539f, 0.02962558f, -0.06022167f, -0.12602732f, -0.19865479f, 0.00716459f, -0.19101699f, 
    -0.19338042f, 0.20457070f, 0.06740195f, 0.04724549f, -0.12681124f, 0.23699346f, -0.21142812f, 0.02390864f, 
    -0.11098566f, 0.06461769f, -0.15907519f, -0.18175076f, 0.64316785f, 0.05224301f, -0.09779973f, 0.08826336f, 
    -0.07079359f, -0.13367757f, -0.08438543f, -0.11190023f, 0.03970863f, 0.12160689f, -0.04007064f, 0.04797307f, 
    -0.10795132f, 0.03015189f, 0.07466099f, -0.07316892f, -0.09407830f, -0.02763882f, -0.05801479f, -0.02844100f, 
    -0.01731726f, 0.04348333f, 0.13442768f, -0.02586737f, 0.11454402f, -0.12274344f, -0.25319394f, 0.30647030f, 
    0.20924348f, -0.04587338f, 0.08971214f, -0.14628962f, 0.13522078f, -0.00638919f, -0.05623229f, 0.05990797f, 
    -0.22464000f, -0.10174099f, -0.08985368f, -0.28548992f, 0.16908552f, 0.06470874f, 0.07587743f, 0.07928150f, 
    0.02958336f, 0.03006085f, 0.01438343f, 0.06881141f, 0.14740287f, -0.00260682f, -0.15365760f, 0.18660145f, 
    0.14557116f, -0.05799991f, -0.11125288f, 0.11316606f, -0.00880084f, -0.20227797f, 0.08249004f, -0.12768599f, 
    0.21739507f, -0.46723926f, -0.17810985f, -0.02543420f, 0.17269851f, -0.07125320f, -0.19732846f, 0.10374855f, 
    -0.01510934f, -0.09519287f, -0.03628024f, -0.06651543f, -0.08846442f, -0.06747497f, 0.08528956f, 0.03310686f, 
    -0.04133164f, -0.07524816f, 0.17113484f, 0.01005314f, 0.09560775f, -0.03173505f, 0.22048721f, 0.02809587f, 
    0.01043401f, 0.08518924f, -0.10784879f, 0.09153920f, -0.00965208f, -0.12373771f, -0.04298519f, -0.17699939f, 
    -0.19616503f, -0.04510356f, 0.01199626f, -0.12388175f, -0.24302790f, -0.04946579f, 0.12548178f, -0.33137983f, 
    -0.03231754f, 0.03562509f, -0.09075670f, 0.04677320f, -0.12925003f, -0.01506309f, 0.07042917f, 0.00806525f, 
    -0.40136746f, 0.14603394f, 0.06729718f, 0.04315080f, 0.17973393f, -0.16094296f, 0.17852311f, -0.05988843f, 
    0.05012404f, -0.02947962f, 0.03124211f, -0.04197693f, 0.16085190f, -0.01834004f, 0.09379238f, 0.17308441f, 
    -0.11988572f, 0.03244208f, -0.12488347f, 0.00936419f, 0.04110864f, -0.13562962f, -0.08984391f, -0.07033711f, 
    -0.02959558f, -0.23473643f, -0.19273686f, 0.44180006f, -0.00195248f, 0.05892097f, -0.09981211f, 0.19501621f, 
    -0.08191989f, -0.01253386f, -0.23022084f, 0.06262521f, -0.01914795f, -0.30475354f, 0.03483069f, -0.10405754f, 
    -0.07475955f, -0.00903521f, 0.03264268f, -0.11791590f, -0.17240240f, 0.00085490f, 0.14288391f, -0.04374177f, 
    -0.21228796f, -0.23382781f, -0.07389329f, 0.19276837f, -0.14579378f, 0.09232751f, -0.16067275f, -0.07378700f, 
    0.04926494f, 0.11814450f, 0.15068531f, 0.17217822f, -0.75605875f, -0.20061980f, -0.15226139f, -0.21296452f, 
    -0.06119526f, 0.08014838f, 0.00300110f, 0.21162300f, -0.02281540f, 0.06666257f, -0.11469925f, 0.18426257f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06942906f, 0.04630185f, -0.02038939f, 0.02214185f, -0.03609310f, 0.04636418f, -0.03323789f, -0.11305809f, 
    0.00560430f, 0.03829793f, 0.09146041f, 0.03171646f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
