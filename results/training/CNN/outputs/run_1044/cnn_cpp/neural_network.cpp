#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.62375522f, 0.45738813f, 0.35626021f, -0.84451646f, 0.41322756f, 0.24456258f, -0.15262079f, -0.04198291f, 
    0.34983909f, -0.36188835f, -0.37071431f, -0.26706332f, -0.71795356f, -0.35381037f, 0.43028370f, -0.64478350f, 
    -0.62298405f, -0.68368089f, 0.54676706f, -0.28104949f, -0.58699095f, -0.03638420f, 0.19643146f, -0.15848200f, 
    0.05773495f, 0.30731821f, 0.10634876f, 0.22791931f, 0.75083208f, -0.25814590f, -0.36590683f, -0.48313233f, 
    0.24743709f, -0.28171027f, -0.06635597f, 0.51926851f, 0.13204114f, -0.48210320f, 0.26064751f, -0.47508612f, 
    0.12446412f, 0.30485114f, -0.13920975f, 0.44545653f, -0.31364983f, -0.82584107f, 0.04969782f, -0.56547934f, 
    0.45831454f, 0.29003578f, -0.01057150f, -0.03388268f, -0.03385483f, 0.15897356f, 0.29313484f, 0.01530464f, 
    0.15900448f, -0.20754720f, -0.30045611f, -0.44935712f, 0.22021784f, 0.12498836f, 0.56599236f, -0.62270838f, 
    -0.47706741f, -0.70397866f, -0.20287743f, 0.25703600f, 0.58164716f, -0.00513403f, 0.43443283f, -0.13529417f, 
    0.21666491f, -0.13423225f, -0.59178990f, 0.77655536f, -0.47774562f, 0.22623982f, -0.48079869f, 0.50131613f, 
    -0.58271855f, -0.17660548f, -0.88041699f, -0.46154919f, 0.26122743f, 0.28015354f, -0.12187235f, -0.10356309f, 
    -0.07991034f, 0.69147855f, 0.18981715f, 0.23418322f, 0.30731332f, -0.19609028f, -0.16555071f, 0.32657033f, 
    -0.32412255f, 0.34775519f, -0.04166846f, -0.68356574f, -0.52241528f, -0.10319981f, -0.41649696f, -0.78649241f, 
    -0.74939084f, 0.05870783f, -0.13493645f, 0.65797997f, -0.89332205f, 0.32181743f, -0.70333242f, 0.39756355f, 
    0.55501390f, 0.33230883f, 0.24593878f, -0.17309672f, -0.41376698f, -0.27713624f, -0.49049139f, -0.27528587f, 
    -0.40303418f, 0.67922109f, -0.63645583f, -0.20752555f, -0.20108482f, -0.06259251f, 0.54815191f, 0.55222678f, 
    0.69395834f, -0.52505815f, -0.60422283f, -0.46915853f, -0.13801397f, 0.07807963f, -0.17866504f, -0.73084402f, 
    -0.58543593f, -0.35243636f, 0.30270022f, -0.10654431f, -0.21184207f, -0.44187313f, -0.13959347f, -0.51838386f, 
    -0.62434983f, 0.33814564f, 0.37527019f, -0.35393730f, 0.66160649f, -0.04288610f, -0.08635568f, -0.61811000f, 
    -0.42271948f, 0.03198171f, 0.34321126f, 0.05276258f, 0.05172215f, 0.02559264f, 0.38264388f, -0.30748484f, 
    -0.29764485f, -0.06433074f, -0.61010522f, -0.96495551f, 0.58213395f, -0.25620273f, -0.37137765f, 0.54295748f, 
    0.32458439f, 0.16011003f, -0.05641713f, 0.02622313f, 0.72266823f, -0.44354770f, -0.03348190f, 0.33409032f, 
    -0.27563575f, -0.47122544f, 0.62236494f, -0.22670466f, -1.07873118f, -0.32740325f, 0.97609985f, -0.28657910f, 
    0.58081156f, -0.28863057f, -0.16228381f, -0.41672859f, -0.40540957f, 0.76321387f, -0.67945004f, -1.06792665f, 
    0.49615437f, 0.76407719f, -0.04241779f, -0.17171630f, -0.13421850f, -0.02141992f, -0.42697477f, -0.68638116f, 
    -0.20122187f, -0.29684576f, -0.13315287f, 0.05284411f, 0.01219026f, -0.01787218f, -0.38160279f, -0.80629599f, 
    -0.85909402f, -0.01939256f, 0.67788434f, 0.63362020f, 0.08971409f, 0.07044326f, -0.34261781f, -0.08013470f, 
    0.78341275f, -0.17782202f, -0.61242568f, -0.66040730f, -0.20349967f, 0.56885016f, -0.34664539f, -0.43196484f, 
    0.09012224f, 0.43887135f, 0.17011224f, -0.26391390f, 0.07271916f, -0.10122401f, 0.24401228f, 0.09921794f, 
    0.26541978f, -0.29279032f, 1.03944075f, -0.39462969f, -0.77655232f, 0.71684068f, -0.00601093f, -0.52107722f, 
    -0.01169063f, 0.26724857f, -0.12711039f, -0.09904055f, 0.20757945f, 0.03729909f, 0.18016282f, -0.15804018f, 
    0.28166521f, 0.23127852f, -0.14116335f, -0.05256049f, -0.41268435f, -0.16262770f, -0.65748847f, 0.09313853f, 
    0.32370350f, 0.25875422f, 0.08609493f, 0.01588784f, 0.30434641f, 0.32379681f, 0.17253762f, 0.18424982f, 
    -0.09452153f, 0.19244409f, 0.04211133f, 0.08173424f, 0.09270773f, 0.04057450f, 0.24932860f, 0.20619254f, 
    0.16273677f, -0.59611493f, 0.15415598f, 0.08629587f, 0.05896379f, 0.19992717f, 0.16812018f, 0.20198905f, 
    0.24212313f, -0.06969956f, 0.09969641f, -0.59610176f, -0.23745961f, 0.35215655f, 0.30612293f, -0.12491257f, 
    -0.20229670f, 0.02895509f, -0.11920418f, -0.67044097f, -0.41413638f, -0.67888570f, 0.21531627f, 0.49466377f, 
    -0.24494921f, 1.05535555f, -0.50448555f, -0.18624981f, 0.47614148f, 0.12520982f, -0.67310923f, -0.33101118f, 
    -0.14923729f, -0.05164465f, 0.35639629f, 0.90309161f, 0.02302433f, -0.73556733f, 0.00020914f, -0.41846031f, 
    0.06354696f, 0.43866479f, -0.23599255f, 0.23929636f, -0.38453525f, -0.44452301f, -0.35839474f, 0.12708989f, 
    -0.36780459f, -0.40867245f, 0.26147717f, 0.33770326f, 0.48982248f, -0.59720534f, -0.84186137f, 0.54666382f, 
    0.07438824f, 0.13715079f, -0.29502755f, 0.51913124f, -0.44693717f, 0.39523262f, -0.18185084f, -0.09256944f, 
    -0.36621714f, 0.13221760f, 0.24868016f, 0.38799486f, -0.20031348f, -0.35581678f, 0.00350540f, 0.18284711f, 
    0.13003598f, -0.06823501f, 0.15754600f, 0.39247251f, -0.01806433f, -0.15981032f, 0.23982748f, -0.37179449f, 
    -0.16647837f, 0.37977237f, 0.20220305f, -0.65405536f, 0.25469714f, -0.24176814f, -0.03258533f, 0.43860179f, 
    -0.29155153f, 0.06169906f, -0.59649050f, -0.52110815f, -0.38082725f, -0.57758951f, 0.16446552f, 0.52436167f, 
    -0.11665418f, 0.62816536f, -0.33525991f, -0.26817536f, 0.23464707f, 0.00671925f, -0.21383733f, 0.31683636f, 
    -0.47518381f, 0.19080289f, 0.67403245f, -0.75772339f, 0.02348659f, 0.10999449f, -0.26395577f, 0.34674188f, 
    0.13443257f, -0.12166832f, -0.15717867f, -0.09681817f, -0.35868287f, -0.07224013f, -0.29255217f, -0.75179523f, 
    -0.69449937f, -0.02751738f, -0.36028305f, -0.58043438f, -0.85656118f, -0.52985996f, 0.15886709f, 0.17706071f, 
    0.52337974f, 0.28877315f, 0.02539546f, -0.38638440f, 0.09537764f, 0.59176397f, 0.35722068f, -0.62321472f, 
    0.03369014f, -0.19397339f, -0.29093882f, 0.21605612f, 0.21500923f, -0.07875765f, 0.27689385f, -0.28184190f, 
    -0.38581157f, 0.07903414f, 0.44116250f, -0.54124480f, 0.17994720f, 0.30485290f, -0.03528794f, -0.33099613f, 
    -0.43921080f, 0.59555024f, 0.38653409f, -0.57432705f, 0.14158775f, 0.25949848f, 0.18140784f, -0.22999480f, 
    0.74394846f, -0.41256735f, -0.30309081f, -0.01709089f, -0.14672290f, -0.11056017f, -0.46812376f, -0.13802780f, 
    -0.48721123f, 0.13868381f, -0.03066976f, -0.14157405f, -0.37649029f, 0.53983390f, -0.30042040f, -0.41816339f, 
    0.27566889f, 0.45728505f, 0.50908822f, -0.30184180f, -0.69434828f, 0.37818015f, 0.47961289f, 0.55059004f, 
    -0.46292999f, -0.24322289f, -0.22647986f, -0.33951420f, -0.65493268f, 0.74514067f, 0.19634552f, -0.46839139f, 
    -0.97907573f, -0.27230051f, -0.08570655f, -0.60588604f, 0.78506649f, -0.75902909f, -0.19548178f, 0.30648005f, 
    0.38494116f, -0.04203330f, -0.52523595f, -0.20857970f, 0.28910029f, 0.10238143f, 0.51170665f, -0.20827316f, 
    0.07006159f, 0.67681783f, -0.41035205f, 0.00015552f, -0.15808864f, 0.03337171f, 0.69071567f, -0.24282037f, 
    -0.61783594f, 0.07630356f, -0.42323056f, 0.32976255f, 0.05953698f, 0.37325889f, -0.11076277f, -0.19704054f, 
    -0.33401287f, 0.41654575f, 0.40253359f, 0.53557307f, 0.34516671f, -0.14312357f, -0.01330356f, -0.49002311f, 
    0.21062194f, 0.11525819f, 0.05970144f, 0.06527485f, -0.18196881f, 0.42432219f, 0.42351371f, -0.15094396f, 
    -0.40422201f, -0.42189118f, -0.45810902f, -0.11976808f, -0.70792603f, -0.50259298f, -0.51636827f, -0.26428559f, 
    0.10507008f, -0.15069935f, -0.02761515f, 0.27763721f, 0.07740362f, 0.43874922f, 0.20652542f, -0.46192762f, 
    -0.16635735f, 0.19915497f, -0.06901673f, -0.22728156f, -0.26160553f, -0.03539522f, -0.20839354f, 0.34269002f, 
    -0.03017792f, -0.47250652f, 0.57025856f, -0.24174644f, 0.44810784f, -0.79454327f, 0.00725136f, -0.37414145f, 
    -0.35590532f, -0.33754107f, 0.54180431f, 0.24325940f, 0.24453688f, -0.23106939f, -0.75417989f, -0.56534576f, 
    0.63219380f, -0.06917160f, 0.40055504f, 0.44203058f, -0.19123325f, -0.23744406f, 0.16729027f, -0.81380546f, 
    -0.16937950f, 0.25879905f, -0.77447170f, -0.75793868f, -0.09984316f, 0.44979548f, 0.21376637f, -0.38104630f, 
    -0.60690856f, -0.12524018f, 0.31168836f, 0.03516169f, -0.39908677f, 0.02354755f, -0.26574987f, -0.24107751f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22369239f, -0.33026907f, -0.04143639f, 0.08228607f, 0.09160247f, 0.21851453f, -0.04901488f, -0.19414419f, 
    -0.14772646f, 0.15095054f, 0.21677177f, -0.26500031f, -0.00892274f, -0.45618090f, 0.12872648f, -0.20391715f, 
    -0.02588413f, 0.37142125f, 0.03465971f, 0.10980513f, -0.09033201f, 0.10967094f, 0.04491320f, -0.13074636f, 
    0.03411637f, 0.19774450f, 0.21114951f, 0.31263393f, 0.12193915f, -0.13914897f, -0.00884367f, 0.03015731f, 
    -0.00379554f, 0.08129325f, 0.08855933f, 0.18802117f, -0.08411039f, 0.11291087f, -0.20719644f, 0.14186031f, 
    -0.11056802f, 0.12203830f, 0.11421417f, -0.09710140f, -0.08706275f, 0.11181870f, 0.13876535f, 0.02286813f, 
    0.00375879f, 0.03687241f, 0.02526784f, -0.12410642f, 0.07876628f, 0.05377867f, -0.15957870f, -0.16614304f, 
    -0.15017106f, -0.33100617f, 0.10891745f, 0.11307289f, 0.14408833f, 0.12694529f, 0.18278360f, 0.06614625f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.39290252f, -0.16420820f, 0.33368781f, 0.05691608f, -0.00037582f, -0.14482349f, -0.21387771f, 0.09441300f, 
    0.09764522f, -0.05703111f, -0.09138284f, 0.03276845f, -0.07903161f, -0.11468342f, -0.06032807f, -0.14200366f, 
    -0.08595406f, -0.01406789f, -0.14907436f, -0.20134491f, 0.16113220f, 0.16539957f, 0.29940566f, -0.06589215f, 
    -0.09289134f, 0.02633187f, 0.13142844f, 0.08929087f, 0.04826679f, 0.02885302f, -0.02969471f, -0.01311570f, 
    -0.00669908f, -0.19274677f, -0.26923883f, 0.05311986f, -0.03614804f, -0.06996071f, 0.06465130f, 0.01283395f, 
    0.04891102f, 0.07730278f, -0.11533213f, 0.04889395f, 0.01771733f, 0.06290913f, 0.00928125f, 0.02713537f, 
    0.07563862f, -0.04810382f, -0.06526601f, -0.04599182f, -0.06458993f, -0.02937571f, 0.00797887f, -0.04450712f, 
    -0.04469028f, 0.02127121f, -0.01140928f, 0.04879125f, -0.26614964f, -0.23707040f, 0.08346788f, -0.02099909f, 
    -0.24883015f, 0.00154556f, -0.19978864f, -0.13156573f, -0.07889573f, -0.01896656f, 0.00957198f, 0.00101358f, 
    -0.04203584f, 0.06250643f, 0.02703915f, -0.09731580f, -0.07458352f, -0.01826434f, -0.00641425f, -0.13871223f, 
    -0.20767088f, 0.00161204f, 0.12549520f, -0.02834376f, 0.00464145f, -0.20738718f, -0.22825353f, 0.10062136f, 
    -0.06925262f, -0.10925484f, -0.13455756f, -0.04569784f, -0.17801775f, -0.08742938f, -0.13311301f, 0.00726593f, 
    -0.22943494f, 0.01866496f, -0.07972328f, -0.07220209f, 0.10404272f, -0.00871972f, -0.29144007f, -0.00776689f, 
    0.06913432f, 0.04331463f, 0.06436419f, 0.04092902f, -0.06081866f, -0.02941973f, -0.08058886f, -0.07290789f, 
    -0.05124625f, -0.02942950f, 0.01359688f, -0.02721599f, 0.01946005f, -0.01095290f, 0.01723024f, -0.02576089f, 
    0.08771936f, 0.06300841f, -0.02010955f, -0.04653162f, -0.05310936f, -0.10589796f, -0.03934858f, -0.12850860f, 
    0.04099026f, -0.01171355f, 0.03102366f, 0.01621852f, -0.00350642f, -0.03792419f, -0.05491950f, -0.02562565f, 
    -0.04660076f, 0.00839834f, -0.04208784f, -0.12980418f, 0.35481545f, 0.17832604f, 0.02280318f, -0.00429754f, 
    0.01407028f, 0.18775778f, 0.17683655f, 0.19266966f, -0.03757371f, -0.24288262f, -0.03638979f, -0.04114296f, 
    0.00870484f, 0.07276337f, 0.04461320f, 0.03411594f, 0.00768572f, -0.00478636f, 0.03793972f, 0.03699503f, 
    -0.02074262f, 0.09942036f, -0.15089355f, -0.13987193f, 0.07675353f, -0.20120034f, 0.06119240f, 0.07419448f, 
    -0.19909000f, 0.03532123f, -0.09070065f, 0.07145215f, 0.05838935f, -0.05163728f, 0.11598329f, -0.02187847f, 
    -0.02939491f, -0.05867627f, 0.03599615f, 0.06291674f, 0.24185875f, 0.22662061f, -0.17073143f, 0.02120019f, 
    0.10169306f, 0.08048324f, 0.10940111f, 0.11881543f, -0.20152007f, -0.11101076f, -0.09053313f, -0.09500746f, 
    -0.04642751f, -0.01899487f, 0.03317040f, -0.05366512f, 0.05998511f, -0.00126272f, -0.00498575f, 0.03138540f, 
    -0.20689768f, -0.14444533f, -0.01310578f, 0.02535714f, 0.04968333f, 0.03269989f, -0.01729781f, 0.02534169f, 
    0.04103029f, 0.04379463f, 0.02493057f, 0.00406336f, 0.04992997f, -0.01472087f, 0.00525670f, -0.12237655f, 
    -0.03495629f, -0.04126483f, -0.00900087f, -0.03171660f, 0.31860352f, 0.31247237f, 0.05152787f, -0.42554453f, 
    -0.10233900f, 0.02825403f, 0.13305202f, 0.08029759f, -0.00509238f, 0.06418988f, 0.01550252f, -0.03606559f, 
    0.01889316f, 0.02327373f, 0.03342414f, -0.04065147f, -0.01872516f, -0.00135040f, 0.00119709f, -0.07156764f, 
    0.17433849f, -0.23399696f, -0.28190267f, 0.04218764f, 0.02776453f, 0.06193867f, 0.08080208f, 0.02805037f, 
    0.02065886f, -0.04993125f, -0.00140521f, -0.03151191f, 0.00903319f, -0.05006447f, -0.03441963f, -0.00151315f, 
    0.08108592f, 0.02120292f, 0.02379178f, 0.00953706f, 0.31097910f, 0.12732652f, 0.08524556f, -0.11795161f, 
    -0.13343740f, 0.17094077f, 0.03352728f, 0.23133205f, -0.14015700f, 0.12681727f, -0.03863133f, 0.01608911f, 
    -0.02638562f, 0.00100159f, -0.05945120f, -0.05982155f, -0.06529100f, -0.15510720f, 0.03654556f, 0.07696931f, 
    -0.28679708f, 0.37213895f, -0.11247154f, -0.24370597f, -0.09614560f, -0.01024162f, -0.11466675f, -0.25993079f, 
    -0.05170870f, 0.07774548f, -0.00345554f, 0.01461270f, 0.04135181f, 0.04554806f, 0.01291476f, 0.08736205f, 
    0.10894072f, 0.03290423f, -0.03992949f, -0.01936332f, 0.24419484f, 0.12779042f, 0.09053353f, -0.17821297f, 
    -0.03731621f, 0.06103219f, 0.11584719f, 0.14229192f, 0.02090676f, 0.06579452f, -0.03562238f, -0.00340439f, 
    -0.04528530f, -0.06465213f, 0.00060546f, 0.03586997f, -0.11255586f, 0.03430883f, -0.05504411f, 0.01810377f, 
    0.01491980f, -0.13249323f, 0.24043313f, -0.00933452f, 0.10739646f, -0.02640593f, -0.05418890f, -0.02400381f, 
    0.07138448f, 0.06201907f, 0.05330933f, 0.02245887f, -0.00985302f, 0.02853152f, 0.01397935f, 0.03802053f, 
    -0.01267255f, -0.03801779f, -0.05498064f, -0.07383219f, -0.39853793f, -0.16297568f, -0.01497095f, -0.09813135f, 
    -0.06123881f, 0.04873221f, -0.00170777f, 0.02482470f, 0.01322948f, 0.02981316f, 0.04060493f, 0.02121492f, 
    0.03526440f, -0.01775293f, -0.02805006f, -0.14128914f, -0.05726625f, -0.04110920f, -0.01457541f, -0.05799980f, 
    0.37727380f, 0.23290098f, 0.33817965f, -0.32475635f, 0.02033697f, 0.08045179f, 0.08292849f, 0.25177190f, 
    -0.09123877f, -0.09974119f, 0.03126663f, -0.09589719f, -0.16547507f, 0.02900483f, 0.00920194f, 0.02861876f, 
    -0.04403963f, -0.01124536f, -0.02593036f, -0.00866276f, -0.55173051f, -0.60565776f, -0.43133521f, 0.11534473f, 
    -0.36495876f, 0.07193843f, 0.00225520f, -0.00234557f, 0.00023903f, 0.15229703f, -0.05401863f, 0.05604258f, 
    -0.08556055f, -0.14444427f, -0.03158664f, -0.27874568f, 0.11194078f, -0.20155634f, -0.09063813f, 0.02495142f, 
    0.35716173f, 0.01159198f, 0.09165544f, -0.18468846f, 0.08093617f, -0.23239784f, -0.08628481f, 0.07790294f, 
    0.06612463f, -0.02060639f, 0.03372891f, 0.02599275f, -0.06527334f, 0.02844286f, -0.16322687f, 0.08309663f, 
    0.01688306f, -0.01745138f, 0.12805569f, 0.08328641f, 0.13698095f, -0.37306732f, -0.96751469f, 0.17115369f, 
    0.01898920f, 0.11530496f, 0.04227040f, 0.02681688f, -0.07389908f, 0.02655546f, 0.00668668f, 0.02593848f, 
    -0.18925068f, -0.12140859f, 0.01934239f, -0.01314880f, 0.06452741f, -0.10593564f, -0.00951876f, 0.02305330f, 
    0.19783546f, 0.11821913f, 0.08797108f, -0.12692700f, -0.09086222f, 0.11868273f, 0.07426939f, 0.16171452f, 
    0.00475369f, -0.02560485f, -0.01938984f, -0.02819293f, -0.03650853f, 0.00117233f, 0.01257022f, 0.01134110f, 
    -0.04038987f, -0.06665874f, -0.03500785f, -0.03796080f, 0.38257703f, -0.04797399f, -0.31289297f, -0.03431967f, 
    0.01636956f, 0.08463534f, 0.08806632f, 0.11257611f, -0.02738457f, 0.04990466f, 0.00153321f, 0.04181510f, 
    -0.03512561f, -0.01364216f, 0.01237233f, 0.02312365f, 0.09568105f, 0.06648682f, 0.04709380f, 0.02347169f, 
    -0.07117217f, 0.08471543f, 0.19590898f, -0.12276681f, -0.24644704f, -0.07672238f, -0.05932441f, -0.16889617f, 
    -0.06470115f, -0.08855046f, -0.03673156f, -0.04043119f, -0.04886052f, -0.04093738f, 0.05243886f, 0.00165354f, 
    0.00161473f, -0.02947662f, 0.11566371f, -0.12290076f, -0.09025554f, -0.07771709f, -0.09399983f, 0.05279450f, 
    -0.00770614f, 0.00122219f, -0.00470152f, 0.00501622f, 0.05904976f, 0.01493867f, -0.02858202f, 0.04703474f, 
    -0.05890301f, -0.04577512f, -0.02738536f, -0.03996721f, -0.09791876f, -0.02082350f, -0.02335739f, -0.00261786f, 
    -0.08401002f, -0.06035284f, -0.61112529f, 0.21657535f, 0.03981434f, -0.00865248f, -0.05861684f, -0.07396184f, 
    -0.10675622f, -0.07137591f, -0.07713143f, -0.11707183f, -0.03623044f, -0.01687994f, -0.02420551f, -0.08934586f, 
    -0.01884763f, -0.03154568f, -0.09646814f, 0.03032115f, -0.08557837f, -0.06434388f, -0.02629334f, 0.00364169f, 
    0.00395441f, 0.00045757f, -0.03157327f, -0.01902261f, -0.01021694f, 0.04754156f, -0.08804319f, -0.03341617f, 
    -0.15474840f, -0.07017759f, -0.06608211f, -0.03186475f, -0.03002461f, -0.01711899f, -0.02793639f, 0.00915732f, 
    0.15168901f, 0.09270465f, -0.09157834f, 0.06502499f, 0.10269406f, 0.07205261f, 0.06272701f, 0.03293961f, 
    -0.07029504f, -0.10413289f, -0.07371075f, -0.04727140f, -0.03015762f, -0.04844043f, 0.01442572f, -0.00295312f, 
    0.03415960f, -0.02441106f, 0.00771452f, 0.01375757f, -0.03107269f, -0.00636827f, 0.00520151f, 0.03396496f, 
    0.00995986f, 0.04043507f, 0.07580746f, 0.01102890f, 0.03076914f, 0.05153315f, -0.07727997f, 0.01447068f, 
    0.07186636f, -0.00483506f, -0.01442817f, -0.12930861f, -0.22699061f, -0.01942789f, -0.02367263f, -0.00065189f, 
    -0.03739556f, 0.00085962f, 0.06170455f, 0.05357988f, 0.00326246f, -0.08367728f, -0.03819750f, 0.04963179f, 
    0.01528073f, 0.00199803f, -0.02164376f, 0.02642630f, -0.01375948f, -0.00764826f, 0.01618226f, -0.02151167f, 
    -0.08604870f, -0.01193496f, -0.06374272f, -0.02337249f, 0.02823337f, -0.00637113f, -0.07899507f, 0.02691838f, 
    -0.01585446f, -0.07982352f, -0.01780474f, -0.22773115f, 0.06608739f, -0.02666457f, -0.02101649f, 0.03588504f, 
    0.02733601f, -0.01512714f, -0.06004246f, -0.02956169f, 0.01234252f, -0.01311202f, -0.10145047f, -0.13900371f, 
    0.22311726f, 0.24343622f, -0.04124812f, -0.28579968f, -0.20409550f, -0.03289810f, 0.01365315f, -0.15655234f, 
    0.08045939f, 0.06557892f, 0.02954481f, 0.02464532f, -0.03918661f, 0.00452089f, 0.01095762f, -0.00133205f, 
    -0.03834047f, -0.04937561f, 0.00969898f, 0.02244895f, -0.02890369f, -0.26964313f, -0.30221185f, 0.20871352f, 
    0.07319622f, -0.09506204f, -0.10218648f, 0.00654522f, -0.01801164f, 0.03207049f, -0.03303057f, -0.04856810f, 
    0.02229154f, 0.05722365f, 0.04205700f, -0.10773700f, 0.07320251f, 0.12213686f, -0.13899237f, 0.07127153f, 
    -0.03197202f, -0.05076453f, -0.36490589f, -0.11763914f, -0.21315627f, 0.00680364f, -0.10934996f, -0.15407409f, 
    -0.11325099f, 0.03503025f, -0.00421932f, 0.03070162f, 0.03122053f, 0.03248618f, 0.03820542f, -0.02827137f, 
    0.01636139f, -0.19290853f, -0.16410223f, -0.04912088f, 0.08194809f, 0.18242554f, -0.02333140f, -0.08755618f, 
    -0.19668703f, 0.01605860f, -0.03763447f, 0.09193088f, -0.18412352f, -0.01607189f, -0.05890046f, -0.02341762f, 
    -0.02660322f, -0.01991035f, 0.02210710f, -0.07965136f, -0.04132692f, -0.03792891f, 0.00420420f, -0.07068183f, 
    0.11720674f, -0.08924340f, -0.27823278f, -0.02289392f, 0.04261276f, 0.09525906f, 0.05339968f, 0.07485753f, 
    -0.12924372f, 0.15606987f, -0.02842280f, 0.06926929f, 0.01755921f, -0.02669408f, -0.08728687f, 0.05144506f, 
    0.01546285f, -0.06070163f, -0.03890655f, 0.04770123f, 0.03864159f, -0.08082753f, -0.07567634f, -0.05312844f, 
    -0.19104432f, -0.03703831f, -0.00945621f, -0.07719769f, -0.06561399f, 0.02494620f, -0.05337178f, -0.01212739f, 
    -0.01937536f, 0.00835183f, 0.10381038f, -0.12245686f, -0.17655207f, -0.00836824f, -0.05743247f, 0.01817699f, 
    -0.05998380f, -0.06063888f, 0.05686348f, 0.04085575f, 0.05921380f, 0.04965736f, 0.05103074f, 0.04116584f, 
    0.03301884f, 0.05377987f, -0.07971414f, -0.00104307f, 0.02769160f, -0.16012512f, -0.10482480f, -0.00038626f, 
    -0.11029887f, 0.03741583f, -0.02586792f, -0.00923361f, -0.00329980f, -0.01342485f, 0.15078256f, -0.08703627f, 
    0.08204193f, -0.17624678f, 0.08002621f, -0.04186044f, -0.08164777f, -0.11158939f, 0.05711154f, -0.25798869f, 
    0.01726511f, -0.07040327f, -0.09396376f, -0.09541944f, -0.09296183f, -0.02815935f, -0.01491358f, -0.07506029f, 
    0.30120292f, 0.26681194f, -0.06299442f, -0.28654754f, -0.25418940f, 0.04963775f, 0.00772103f, -0.06099611f, 
    0.01661205f, 0.00831902f, 0.03346267f, -0.02190799f, 0.03082351f, 0.02949955f, 0.02394799f, -0.01831852f, 
    -0.00528695f, -0.02694546f, -0.00147149f, 0.14815070f, -0.12758462f, -0.12620077f, -0.33534250f, -0.00561855f, 
    -0.09439966f, -0.17522010f, -0.04275019f, -0.04575246f, 0.04382860f, -0.07720723f, -0.11487095f, 0.05870496f, 
    -0.18106520f, -0.12402465f, -0.05893974f, -0.06775233f, -0.03403591f, -0.01964370f, -0.07172809f, -0.05793836f, 
    0.00847831f, -0.28777674f, -0.31889194f, -0.07872255f, -0.03451119f, -0.02999385f, -0.09762333f, 0.05925710f, 
    -0.04321489f, -0.01008302f, -0.00520488f, -0.03905380f, -0.17906027f, -0.13533252f, -0.04691969f, 0.00920534f, 
    0.02537475f, -0.06189476f, -0.04355985f, -0.06129328f, 0.20339702f, 0.19725271f, 0.06174763f, -0.30306622f, 
    -0.06795203f, 0.10359282f, 0.07628179f, 0.04066454f, 0.02355671f, 0.12229753f, -0.01908017f, -0.03737298f, 
    -0.04060065f, -0.02620802f, -0.11229222f, -0.08442581f, -0.09522659f, 0.02696642f, 0.04444382f, 0.15313840f, 
    0.25181568f, -0.09324495f, -0.05557331f, -0.11005937f, 0.04224131f, 0.08901642f, 0.04701051f, 0.14202148f, 
    0.05331435f, -0.02674138f, -0.03806179f, 0.04630245f, 0.02806431f, -0.05643800f, -0.08111727f, -0.02210638f, 
    0.08397173f, 0.06460432f, 0.03614035f, 0.00973601f, 0.03058833f, -0.01037889f, -0.20834789f, 0.05016694f, 
    -0.06253435f, -0.12623025f, -0.11235316f, -0.18089539f, 0.09352244f, 0.01225726f, -0.05716972f, -0.04136553f, 
    -0.02823110f, -0.03497252f, -0.01417336f, -0.04692751f, -0.04909621f, -0.08378282f, -0.07849880f, -0.12003831f, 
    0.11083283f, 0.13879022f, -0.20614611f, 0.07436305f, -0.01140541f, 0.05326825f, -0.00809008f, -0.00072662f, 
    -0.14566636f, -0.00151847f, -0.00411712f, -0.09975123f, -0.07239647f, -0.01359065f, -0.02821584f, -0.01530515f, 
    -0.01696226f, -0.08680563f, -0.03751017f, 0.04243885f, 0.04827112f, 0.04983451f, 0.27046186f, -0.12965390f, 
    0.05350086f, -0.01088831f, 0.03589682f, 0.02714675f, -0.03815656f, 0.04682639f, 0.09879865f, 0.00731850f, 
    -0.00209796f, -0.02039552f, -0.04697851f, -0.01488505f, -0.02633550f, -0.00562016f, -0.19312617f, 0.01769968f, 
    -0.03760239f, -0.02182820f, 0.19227234f, -0.10181890f, -0.07223990f, -0.03083871f, -0.07381953f, -0.01086673f, 
    -0.08321719f, -0.02911181f, -0.03330676f, -0.03354741f, -0.06233360f, -0.01787040f, -0.00450327f, 0.04554921f, 
    -0.00137684f, 0.12675948f, 0.06561635f, 0.11235200f, -0.05980528f, 0.02733102f, -0.01251266f, 0.03390534f, 
    -0.06744537f, 0.07053606f, -0.05201508f, -0.00275073f, -0.09503219f, 0.04623342f, -0.04563892f, 0.01746682f, 
    -0.04786891f, -0.09102934f, 0.03678346f, -0.08220450f, -0.01779906f, 0.02467384f, -0.11641334f, -0.05672672f, 
    0.09000989f, -0.20637241f, -0.40849999f, 0.15186404f, -0.12715115f, 0.04184799f, 0.08755482f, 0.01202235f, 
    0.01859244f, 0.06564806f, 0.03872151f, 0.08802761f, -0.06101394f, 0.07976016f, -0.14447172f, 0.03025984f, 
    0.11263718f, 0.05305478f, 0.05840904f, -0.04787378f, 0.37015671f, 0.20434257f, -0.12520404f, -0.43146470f, 
    0.11086595f, 0.09035724f, -0.02008683f, 0.09918211f, 0.04130815f, 0.10016773f, -0.00931378f, -0.02289586f, 
    -0.07404470f, 0.00263081f, -0.06790955f, 0.08267569f, -0.09701034f, 0.01096740f, 0.01334262f, 0.11452504f, 
    -0.18959881f, -0.43055132f, 0.11429591f, 0.08789481f, -0.05466176f, 0.02689996f, 0.00745977f, 0.03197932f, 
    -0.01092129f, 0.01913461f, 0.05120160f, 0.05576194f, -0.03113856f, -0.04956667f, -0.05144599f, -0.06108650f, 
    0.22177592f, -0.10900098f, -0.07710615f, 0.00906939f, -0.12065939f, -0.12954476f, -0.03265727f, 0.04803053f, 
    0.04899892f, 0.00651427f, 0.01087933f, 0.00865415f, 0.01673276f, 0.02639645f, -0.04170880f, 0.03544240f, 
    -0.03614010f, 0.09983087f, -0.02283778f, -0.17588601f, -0.10006534f, 0.00849475f, -0.05476194f, -0.01389965f, 
    0.06719345f, 0.04400089f, -0.15052275f, 0.02641418f, 0.04861125f, 0.01544799f, -0.02114342f, -0.02726187f, 
    0.12075191f, -0.12124964f, -0.14701660f, 0.12719220f, 0.03284790f, 0.05204410f, 0.01513986f, 0.01135654f, 
    -0.10989649f, 0.01567573f, 0.00616406f, -0.00719970f, -0.06298047f, -0.07390136f, -0.19926564f, -0.00940687f, 
    0.03572619f, 0.01882805f, -0.00737370f, 0.08725732f, 0.03439485f, 0.05750671f, 0.02210606f, -0.02006597f, 
    0.00601950f, 0.09470063f, -0.02355571f, 0.02960656f, 0.02787017f, 0.08502445f, -0.01446931f, 0.05890374f, 
    -0.08895688f, -0.11324932f, -0.10539593f, 0.00389350f, -0.06270412f, -0.00423864f, 0.02588535f, -0.02099631f, 
    0.05837582f, 0.00124081f, -0.05580480f, -0.02220434f, 0.00693454f, 0.08006189f, 0.05610995f, -0.06083624f, 
    -0.12279634f, 0.04801548f, -0.03289132f, 0.00516291f, 0.27371481f, 0.23213263f, 0.07548274f, -0.25916326f, 
    -0.11170467f, 0.11800598f, 0.12790899f, 0.15924260f, 0.00204825f, 0.04515990f, -0.00871602f, -0.01983696f, 
    -0.03670760f, 0.00369202f, -0.00627488f, -0.02257977f, -0.05730423f, -0.10680233f, 0.14941949f, -0.05667805f, 
    -0.07176143f, -0.08249541f, -0.10923342f, 0.04527082f, -0.00044302f, 0.04280928f, -0.01153236f, 0.01903671f, 
    0.02438619f, 0.00982519f, -0.10187058f, -0.04263727f, 0.06123398f, 0.02542206f, -0.03477930f, -0.22002381f, 
    -0.03291044f, -0.06413026f, 0.02679634f, -0.00816969f, 0.06748356f, 0.04901406f, -0.01681666f, -0.08700366f, 
    -0.05972996f, -0.02375939f, -0.00397981f, 0.10547758f, -0.03660505f, 0.01192034f, -0.10923709f, 0.05126787f, 
    -0.01863316f, -0.12831016f, -0.09449387f, -0.05132740f, -0.00789481f, -0.05625345f, 0.04490084f, 0.04663113f, 
    0.23243541f, 0.23045285f, -0.00124719f, -0.21901180f, 0.01161051f, -0.13662381f, -0.01887821f, -0.08419666f, 
    0.01482518f, -0.05720383f, -0.00017631f, 0.11367677f, -0.02681161f, 0.02982390f, 0.03187461f, -0.01929381f, 
    -0.01790909f, -0.03870218f, -0.05992761f, 0.07154477f, 0.26279214f, -0.21930662f, -0.15528762f, 0.00872216f, 
    0.02216364f, 0.06022450f, 0.09482344f, 0.04458595f, -0.10812815f, 0.03021826f, -0.03532486f, -0.04713592f, 
    0.00910282f, -0.00231479f, 0.05730367f, 0.05025578f, 0.03269692f, 0.07113565f, 0.00020614f, -0.00206723f, 
    0.31467569f, 0.26336741f, -0.14190812f, -0.18319440f, -0.04854147f, 0.03684131f, -0.04939852f, 0.02953655f, 
    -0.15443897f, -0.03175688f, 0.02551746f, -0.04099238f, 0.02980564f, -0.01080603f, 0.04656824f, -0.01849231f, 
    0.02583228f, -0.05193911f, 0.08184920f, 0.06029427f, 0.25035721f, 0.05509630f, -0.00162290f, -0.21526714f, 
    -0.07620215f, 0.05304349f, 0.07144052f, 0.05633565f, -0.03224902f, 0.03148784f, 0.00891046f, -0.05014824f, 
    -0.02366440f, -0.03559710f, 0.00398627f, 0.01532890f, -0.04473535f, -0.01761189f, -0.05289078f, -0.00430874f, 
    0.04861905f, -0.13911788f, -0.01967908f, -0.04564552f, 0.15120816f, -0.03124534f, 0.00259074f, -0.08476918f, 
    -0.01882090f, 0.05705504f, 0.07545542f, -0.06320509f, 0.05831695f, 0.05757073f, -0.01790931f, -0.01401639f, 
    0.00475231f, 0.03022309f, 0.05768600f, 0.04193275f, -0.23278344f, 0.37016264f, 0.19752245f, 0.05785614f, 
    -0.15648292f, 0.09962194f, -0.02467342f, -0.03576294f, -0.02604972f, 0.01857086f, 0.01730291f, 0.04027184f, 
    0.03781254f, -0.04981860f, 0.12145481f, -0.06787328f, -0.28483951f, 0.13971333f, -0.08497783f, -0.06034545f, 
    0.15632039f, -0.05294292f, -0.10646090f, -0.06309032f, -0.12395591f, -0.01485448f, 0.02223648f, 0.03798857f, 
    -0.05822752f, 0.05898717f, 0.11689122f, 0.11343492f, -0.00187873f, 0.03121254f, 0.06881276f, -0.05929689f, 
    -0.02451332f, -0.04352765f, 0.02737736f, 0.06971851f, -0.06308281f, -0.15423064f, 0.12126522f, -0.02613333f, 
    -0.03284705f, 0.13180989f, -0.02356614f, -0.05307608f, -0.10817164f, 0.10130294f, -0.04801183f, 0.00803919f, 
    0.05885958f, 0.09767245f, -0.10466252f, -0.09609885f, 0.11273268f, -0.11237004f, 0.10802151f, 0.09645523f, 
    -0.24511835f, 0.08162366f, -0.04813941f, -0.03612325f, 0.23557912f, -0.01231128f, 0.19780388f, -0.01479729f, 
    -0.08510587f, 0.08948500f, -0.05334761f, 0.01820339f, -0.01888514f, -0.02854387f, -0.05909800f, 0.01014501f, 
    0.18914209f, -0.00137764f, 0.04695099f, 0.22946319f, -0.13688734f, -0.12860969f, 0.02590067f, -0.07556093f, 
    -0.06735306f, 0.01004067f, 0.00027114f, 0.04624236f, -0.00940017f, -0.19444630f, 0.09231530f, -0.01439467f, 
    -0.03794647f, -0.08985598f, -0.04618567f, 0.06249309f, 0.01013451f, -0.02152937f, 0.03276950f, 0.01155566f, 
    -0.10102700f, -0.01078646f, -0.08695585f, -0.04778883f, -0.01014202f, 0.08995643f, 0.04726095f, -0.04833126f, 
    0.06112179f, 0.01586932f, -0.06196607f, -0.01192392f, 0.13310018f, 0.10104103f, 0.04352092f, -0.02919013f, 
    0.00508054f, -0.05244394f, 0.08078212f, 0.00711172f, -0.36146489f, 0.04380337f, -0.09654995f, 0.16230266f, 
    -0.05933332f, -0.15235782f, 0.03799099f, 0.08722936f, -0.23504819f, -0.11984178f, -0.03400300f, 0.00721165f, 
    -0.12848935f, -0.02559085f, -0.03918087f, 0.00129935f, 0.02941976f, -0.02665509f, -0.00507974f, 0.04023505f, 
    0.41282248f, 0.40017584f, -0.38123542f, -0.37516412f, -0.21226668f, -0.12816255f, 0.09681502f, -0.07068417f, 
    0.16115588f, -0.03739056f, 0.00360208f, 0.01655425f, -0.15351951f, -0.07632493f, -0.06669178f, -0.07318244f, 
    0.07195543f, 0.05309994f, 0.04496360f, 0.06575944f, -0.10804403f, -0.16156578f, 0.00782690f, 0.03223507f, 
    -0.11761934f, 0.04402360f, 0.09826900f, 0.21934615f, -0.02890258f, -0.30159819f, -0.03954959f, -0.20770243f, 
    0.10673290f, -0.00706334f, -0.06002609f, 0.02162737f, 0.02496147f, 0.02513378f, 0.03146095f, 0.01816778f, 
    0.19111674f, 0.09250343f, 0.11066094f, 0.02698327f, 0.13594283f, 0.01441753f, -0.01006495f, 0.01496545f, 
    -0.01225446f, -0.01447093f, 0.03746635f, -0.02519210f, 0.02942427f, 0.02329818f, -0.00968118f, -0.00671244f, 
    0.17489129f, 0.04132491f, 0.00626192f, -0.01714924f, -0.36015886f, 0.14863034f, -0.06741208f, 0.35166988f, 
    0.03997406f, -0.08095603f, -0.01489955f, 0.08599275f, -0.05600135f, -0.23910919f, -0.04990413f, -0.03570396f, 
    0.02752797f, -0.02694295f, -0.01402055f, -0.01288907f, 0.04881906f, 0.04699154f, -0.27000257f, 0.02823234f, 
    -0.26705709f, -0.22050394f, 0.12478450f, -0.03331187f, -0.18057044f, 0.04627768f, -0.02839778f, -0.02597198f, 
    -0.04659496f, -0.00133895f, 0.03042307f, -0.05442804f, -0.00806674f, -0.01633347f, 0.12298232f, 0.02345238f, 
    -0.05680474f, -0.13082625f, 0.04442451f, -0.00478143f, 0.32750437f, 0.15792942f, 0.12219444f, -0.11135048f, 
    0.03857513f, -0.08797351f, -0.12043724f, -0.09760509f, 0.08829565f, -0.03618490f, 0.01981875f, -0.00444717f, 
    -0.00647900f, -0.01770755f, -0.03452143f, -0.04583328f, -0.01752589f, -0.18252116f, -0.17161129f, -0.00728736f, 
    0.38163576f, -0.02855320f, -0.09976081f, -0.18472184f, -0.15432516f, 0.00056560f, -0.15745208f, -0.27344817f, 
    -0.05999896f, -0.06689525f, -0.02025326f, 0.00666524f, 0.04884244f, -0.00048476f, 0.00946594f, 0.03341755f, 
    0.03287898f, -0.22646889f, 0.02729984f, -0.01732505f, 0.13172172f, 0.19367346f, 0.22810365f, 0.08126048f, 
    0.01836587f, 0.00008678f, -0.05085211f, -0.06062901f, 0.18212877f, 0.02068201f, 0.04850966f, 0.00837513f, 
    0.00148533f, -0.05375073f, -0.00358403f, -0.01155392f, 0.02468952f, -0.05967383f, -0.00578069f, 0.03156891f, 
    0.06123784f, -0.57035536f, 0.06337527f, -0.15655670f, 0.27032012f, -0.05760295f, -0.02367886f, 0.03550243f, 
    -0.07171247f, 0.02888393f, 0.06283312f, 0.08619003f, 0.02191284f, -0.04607709f, -0.00808068f, 0.17169590f, 
    -0.13326274f, -0.08323681f, -0.02066100f, -0.04861844f, 0.13739599f, 0.07531510f, 0.09545940f, 0.11455330f, 
    0.16572921f, -0.05412678f, -0.00783514f, -0.01842042f, -0.03169933f, -0.01733447f, -0.00466445f, 0.02037033f, 
    0.02069865f, 0.03330199f, 0.00116679f, 0.17685555f, -0.02139067f, 0.02108079f, 0.07643916f, 0.01802799f, 
    -0.96667188f, 0.02273847f, -0.35006553f, -0.03711401f, 0.20622678f, -0.24033152f, 0.06732410f, 0.12433146f, 
    0.06083110f, 0.03572289f, -0.10409567f, 0.08217568f, -0.08506805f, -0.00370383f, -0.12966143f, 0.04881558f, 
    0.06383596f, 0.01028618f, -0.07516484f, 0.00504415f, -0.02560502f, -0.02140317f, 0.01668371f, -0.04787848f, 
    -0.12434539f, -0.01338174f, -0.06999274f, -0.05989571f, -0.01309968f, -0.03998372f, -0.02974379f, 0.01244102f, 
    -0.07250786f, 0.07958978f, -0.07892454f, -0.24041849f, 0.12867129f, -0.12223888f, 0.17479511f, 0.04056176f, 
    -0.04691667f, -0.36644176f, -0.04832822f, -0.31618536f, 0.31246164f, 0.07907861f, -0.04173864f, -0.01506797f, 
    -0.14301842f, 0.00277137f, 0.11696463f, 0.01885159f, 0.11527377f, -0.02688210f, -0.00217013f, 0.02672252f, 
    -0.23085192f, -0.07300877f, -0.05474024f, -0.35708696f, 0.90154427f, -0.27969790f, -0.15690753f, 0.08094680f, 
    -0.23451725f, 0.05298049f, 0.05376594f, -0.03756925f, -0.03359692f, -0.05859479f, 0.19436194f, -0.23546226f, 
    0.06662606f, -0.12849371f, -0.03646258f, 0.05446392f, -0.03783764f, -0.17301117f, -0.00255567f, 0.01565006f, 
    -0.04718687f, 0.21170187f, 0.11899782f, 0.05758825f, 0.10909626f, -0.11724766f, 0.01662813f, -0.01520998f, 
    -0.02269576f, -0.06749344f, -0.03994705f, 0.02604812f, 0.00721967f, -0.01015825f, 0.00045075f, 0.06330790f, 
    0.01328465f, 0.02101461f, -0.07391647f, 0.02674012f, 0.19167751f, -0.19911018f, 0.09028276f, 0.03870685f, 
    -0.02911189f, 0.00251258f, 0.02468351f, -0.01487423f, -0.05980537f, -0.13676108f, 0.14391956f, -0.09005284f, 
    0.03702090f, -0.10520672f, -0.05287275f, 0.05284102f, -0.05043403f, -0.04365899f, 0.01441202f, -0.03772019f, 
    0.18282604f, 0.21982177f, -0.01747346f, 0.23749897f, -0.43704072f, -0.04967866f, 0.04548957f, 0.13530017f, 
    -0.15659849f, 0.14143677f, -0.02740939f, 0.06847297f, 0.01023332f, 0.03562533f, -0.05630016f, -0.06536112f, 
    -0.21719597f, -0.12497095f, -0.13203353f, -0.13243118f, 0.12933056f, 0.01974072f, 0.12980185f, 0.03188932f, 
    0.01178012f, -0.00427967f, 0.00028563f, 0.03509925f, 0.02078050f, -0.02517638f, -0.01511830f, -0.02458558f, 
    0.01004592f, 0.09921505f, -0.05446025f, -0.11214905f, -0.03248371f, 0.05687535f, 0.01184537f, -0.00024653f, 
    0.57657421f, 0.02141066f, -0.33626083f, -0.01397184f, -0.20606756f, 0.03467242f, -0.08751827f, 0.00357387f, 
    0.10043141f, -0.02463076f, 0.05438322f, 0.21226716f, 0.03650098f, -0.04069822f, 0.15542768f, 0.03729175f, 
    -0.04585260f, 0.12691304f, 0.17022502f, 0.17742102f, 0.05218730f, 0.05279360f, 0.06096605f, 0.05096196f, 
    0.07243413f, -0.00229921f, -0.00256408f, 0.05531828f, -0.03547497f, -0.04515219f, -0.00360847f, 0.02607198f, 
    0.01182494f, 0.03168052f, 0.07827970f, 0.00773778f, -0.07887005f, 0.00829887f, 0.04021889f, -0.00347781f, 
    -0.11298599f, -0.24532314f, -0.09540825f, -0.03327051f, -0.08916102f, -0.02986992f, -0.00968118f, 0.05471733f, 
    -0.01397331f, -0.15318115f, -0.00114841f, 0.02204048f, -0.00590762f, 0.00517126f, -0.03149953f, -0.00530727f, 
    0.03580153f, -0.02587966f, 0.01032851f, -0.00047331f, 0.10890742f, 0.06036088f, 0.05433373f, 0.10682708f, 
    0.10585259f, -0.05082293f, -0.01872573f, -0.04636914f, -0.01965935f, -0.02377293f, 0.01173408f, 0.03104886f, 
    0.04797612f, 0.04396183f, -0.00245759f, -0.10443821f, 0.02124161f, -0.05144347f, 0.00417675f, -0.02251847f, 
    0.09470764f, 0.02207168f, 0.04107571f, -0.00213535f, 0.03125426f, -0.01775691f, 0.01189915f, -0.03679127f, 
    -0.02486630f, 0.03274658f, 0.00123260f, -0.03543348f, 0.05323827f, 0.05478238f, 0.01972099f, 0.02314080f, 
    0.00183281f, -0.03780826f, 0.05734407f, 0.01932451f, -0.08612052f, -0.05019506f, 0.05970688f, -0.04733130f, 
    -0.02512660f, 0.09715265f, -0.04328373f, -0.03078870f, 0.06847481f, -0.02265162f, -0.06854795f, -0.11556922f, 
    0.05606508f, 0.10957132f, 0.09112345f, -0.04529137f, -0.02986202f, 0.00021666f, 0.02313532f, -0.02516400f, 
    -0.13915178f, 0.01838152f, -0.10872828f, -0.05440694f, 0.05111902f, -0.08285531f, -0.01789996f, -0.17633095f, 
    0.08542211f, -0.17434706f, -0.02051133f, 0.01934873f, -0.02836819f, 0.08363651f, 0.04470444f, -0.02118848f, 
    0.00786014f, 0.04126305f, 0.04803181f, -0.04497749f, 0.67764050f, 0.00903699f, -0.36091813f, 0.08649460f, 
    -0.29977480f, 0.04548008f, -0.02083101f, -0.03140802f, -0.04965398f, -0.07539826f, -0.06271070f, 0.08680934f, 
    -0.03423511f, 0.03305461f, -0.05043136f, 0.17827860f, -0.13050644f, -0.08470950f, 0.11832298f, 0.01259794f, 
    0.01755248f, -0.13138402f, 0.04137040f, -0.09879965f, -0.09365617f, -0.01167020f, -0.02325628f, -0.27186078f, 
    0.09994885f, -0.00466197f, 0.01275449f, -0.03502941f, -0.03543108f, 0.04485041f, 0.01416718f, -0.03712182f, 
    0.10265392f, -0.15405287f, 0.14381444f, 0.07616752f, -0.04592074f, -0.04888125f, -0.14925079f, 0.03384170f, 
    -0.18255365f, 0.04822263f, 0.15149595f, -0.09246838f, 0.01404608f, 0.09627260f, 0.04346552f, -0.02814865f, 
    0.02466355f, 0.06040203f, 0.00105570f, -0.03412763f, 0.01696230f, -0.04877891f, 0.05710086f, 0.06232561f, 
    0.57589543f, 0.06113902f, -0.23537877f, -0.13692763f, -0.22071403f, -0.17857742f, 0.02805780f, -0.02294073f, 
    0.08181167f, 0.17947519f, 0.03928751f, -0.01454985f, -0.08920632f, -0.09402967f, -0.08273461f, -0.06856488f, 
    0.01399392f, -0.05836540f, 0.04280941f, 0.05018946f, 0.04980789f, 0.28169850f, 0.06496168f, 0.11583944f, 
    0.05455696f, 0.04948967f, 0.00301429f, 0.12906845f, -0.10763036f, 0.06273194f, -0.00380641f, 0.01858948f, 
    -0.00639576f, 0.03111724f, -0.06361771f, 0.09619891f, -0.00555640f, 0.10460187f, -0.10540918f, -0.10432407f, 
    0.07971619f, 0.08254319f, 0.15263468f, 0.09226229f, 0.08369782f, -0.00906938f, -0.02913133f, 0.01039493f, 
    -0.06433612f, -0.03947299f, 0.00029719f, -0.04214618f, -0.03920512f, 0.09135945f, 0.04338557f, -0.10770576f, 
    -0.07818110f, -0.05941020f, -0.03795626f, -0.03093556f, -0.44722036f, 0.03750488f, -0.01671470f, 0.01807604f, 
    -0.04293726f, 0.04060079f, 0.04931982f, 0.04371334f, 0.02869032f, -0.02226829f, -0.09336172f, 0.07417694f, 
    0.06953701f, 0.00788118f, 0.00349482f, -0.10245143f, 0.10520263f, 0.06040537f, -0.07835342f, 0.06572378f, 
    -0.14933249f, -0.01203587f, -0.12427617f, 0.15118130f, 0.05492598f, -0.14338882f, 0.03217195f, -0.22594859f, 
    -0.03833038f, -0.01906712f, -0.01578299f, 0.02729570f, -0.03096926f, 0.04755958f, 0.02013254f, -0.00376418f, 
    0.00927892f, -0.03031125f, -0.00912751f, -0.01177521f, 0.17674445f, 0.26190057f, 0.01811443f, -0.04294367f, 
    -0.10457421f, -0.15085289f, 0.05875014f, -0.00809667f, 0.00772991f, -0.13905130f, 0.02374217f, 0.08986697f, 
    0.25595015f, -0.01631396f, -0.14640100f, -0.01870609f, -0.00467365f, 0.02480071f, 0.08492023f, -0.08799383f, 
    0.38195556f, 0.45199516f, -0.31801820f, 0.08008441f, -0.06545211f, -0.07525805f, 0.07044011f, -0.09091040f, 
    -0.07478379f, 0.06183552f, 0.00969214f, -0.03703787f, -0.11949091f, 0.13601685f, 0.03907769f, -0.10370115f, 
    0.07854364f, -0.03976254f, -0.12455780f, 0.17241362f, -0.01486178f, 0.13466045f, -0.14305870f, -0.01991408f, 
    -0.05775602f, 0.12589623f, -0.12495735f, -0.09489007f, -0.04093480f, -0.06128021f, 0.00108613f, 0.04298786f, 
    0.09855130f, 0.05549163f, 0.15049790f, -0.02934244f, -0.01210075f, 0.04319150f, -0.24077044f, -0.13963665f, 
    -0.08956490f, -0.30158347f, 0.08000881f, 0.04467250f, -0.02684063f, 0.01081886f, 0.04355905f, 0.00046921f, 
    -0.07440687f, -0.14280808f, 0.10723647f, -0.04677963f, 0.02129095f, -0.04066672f, 0.03532053f, 0.05730682f, 
    0.00604948f, -0.02778687f, 0.01760488f, -0.04792913f, -0.09794168f, -0.01695163f, -0.01090483f, 0.03672850f, 
    -0.14751321f, 0.01620168f, -0.05538082f, 0.00656837f, 0.03867886f, -0.06334770f, 0.02868498f, -0.01304450f, 
    -0.02366211f, 0.11731047f, 0.09377365f, 0.03483122f, -0.03831990f, 0.09117113f, 0.10654870f, 0.02960694f, 
    0.11434909f, -0.08891262f, -0.16210510f, -0.04125305f, -0.10806833f, -0.02259226f, 0.02830360f, 0.04219197f, 
    0.05972027f, 0.04094578f, 0.01695720f, -0.00404256f, -0.01190483f, 0.03922758f, 0.04619322f, -0.01561343f, 
    -0.01497899f, 0.03967095f, 0.06641404f, 0.03875487f, -0.07626902f, -0.03549007f, -0.04422682f, -0.12432818f, 
    0.03388190f, -0.05261378f, -0.04056403f, 0.01345500f, 0.12860940f, 0.02651192f, -0.12677972f, 0.07464197f, 
    0.01668512f, 0.10100688f, -0.09452628f, -0.06555384f, 0.02378926f, -0.00924580f, -0.01709966f, 0.04169321f, 
    0.36597547f, 0.27128151f, -0.19238792f, -0.11817021f, -0.30848238f, 0.01063535f, 0.05496930f, -0.02347093f, 
    -0.07511920f, 0.02855369f, 0.01443321f, -0.00638007f, -0.03356042f, -0.02332082f, 0.03846049f, -0.13923007f, 
    -0.26649430f, -0.11163179f, -0.20172687f, -0.11611300f, 0.06256194f, -0.08459900f, -0.08574109f, -0.01343945f, 
    -0.06806193f, -0.03419559f, 0.07167978f, 0.10552509f, 0.00690294f, 0.11331039f, 0.08136717f, 0.04577954f, 
    0.09136496f, 0.06673068f, 0.05462232f, -0.04869451f, 0.02130473f, -0.07988177f, 0.05301046f, 0.05454424f, 
    0.82703257f, 0.12249970f, 0.25610167f, 0.25125325f, -0.25995803f, -0.06584851f, -0.01935911f, 0.00932309f, 
    -0.01339564f, -0.02593166f, 0.09085320f, -0.10115565f, -0.17245476f, -0.21194895f, -0.09106755f, 0.09804012f, 
    -0.00688705f, -0.21786918f, -0.00389305f, -0.00582242f, -0.05707992f, -0.08279360f, -0.21866448f, -0.07191812f, 
    0.01175268f, 0.19822422f, -0.11016970f, -0.16796890f, 0.11765891f, -0.03495896f, 0.09495562f, -0.02060089f, 
    0.07446705f, -0.02186290f, 0.08849389f, -0.14537963f, -0.09811369f, -0.40089145f, -0.29830182f, -0.32837641f, 
    0.82059354f, -0.00058461f, 0.25523850f, 0.19301721f, 0.01960429f, -0.00894514f, -0.00694930f, 0.00874070f, 
    -0.00431968f, -0.03914201f, -0.01148882f, -0.16540883f, 0.14286384f, 0.02594281f, -0.23222959f, 0.18220834f, 
    0.13448475f, -0.05781830f, 0.00477786f, 0.08477544f, 0.06132488f, 0.11794525f, 0.04425161f, 0.05805713f, 
    0.06010502f, -0.09039380f, 0.03209659f, -0.02690711f, -0.01184169f, -0.00512056f, -0.06049591f, 0.01336392f, 
    0.05822804f, -0.04789841f, 0.05278461f, 0.12365557f, -0.05444460f, -0.09226716f, 0.00788183f, -0.01391367f, 
    0.18837452f, 0.01215563f, 0.05729655f, -0.15726712f, -0.06978559f, -0.05418127f, 0.02782837f, 0.01148480f, 
    -0.06713492f, 0.00472446f, 0.05889517f, -0.01564347f, -0.14416260f, -0.02154044f, -0.00089816f, -0.09862517f, 
    -0.00293494f, 0.02371055f, -0.08470043f, 0.05648812f, 0.04992462f, -0.06862357f, 0.08606414f, 0.16855538f, 
    0.08492505f, -0.06825247f, -0.00652260f, -0.01504545f, -0.02833355f, 0.00329440f, 0.16363147f, 0.05695674f, 
    0.07952622f, -0.03522647f, 0.04409136f, -0.01494433f, -0.11039669f, -0.09520826f, 0.06360571f, -0.09178248f, 
    0.13484000f, 0.14639673f, 0.07362009f, 0.09779374f, 0.06471395f, -0.01104362f, 0.00912649f, -0.01932671f, 
    -0.05904023f, 0.01643220f, 0.01189869f, 0.00496239f, -0.03560553f, 0.06000708f, -0.01069732f, -0.09877024f, 
    -0.05851889f, 0.02739478f, 0.03739989f, -0.11561756f, -0.07538977f, 0.19642542f, -0.03142754f, 0.12073799f, 
    0.14898124f, -0.23440039f, -0.00626429f, -0.10197141f, 0.00899470f, -0.12813824f, 0.00673785f, 0.03579798f, 
    0.00811956f, 0.04230513f, 0.02604462f, 0.05574701f, 0.01829692f, 0.06166548f, -0.16246276f, -0.08493302f, 
    0.06706149f, 0.10229702f, -0.00219238f, 0.05143896f, 0.12484222f, -0.00539941f, 0.01060909f, 0.02181018f, 
    0.02619169f, -0.00377581f, -0.03307087f, 0.01804848f, -0.02002779f, 0.01274902f, 0.06034329f, 0.10771317f, 
    -0.02131337f, 0.03848114f, -0.00687513f, -0.04807655f, -0.30336571f, 0.04123794f, -0.03922106f, -0.25374234f, 
    -0.01622769f, -0.22632088f, 0.06690640f, -0.20967562f, 0.10988823f, 0.15490699f, 0.04719977f, -0.01065086f, 
    -0.07178727f, 0.04850243f, 0.01139774f, -0.02875504f, -0.00881895f, -0.11160261f, 0.12192217f, 0.01379414f, 
    -0.34993324f, 0.00354977f, -0.14713889f, 0.01110542f, 0.03295500f, -0.12297580f, 0.18411642f, 0.15627688f, 
    0.00295137f, 0.01802537f, -0.00335632f, -0.05684949f, 0.05288384f, 0.08245105f, 0.01889492f, -0.01238139f, 
    -0.05473771f, 0.02133681f, -0.00645645f, 0.07185394f, 0.00251564f, 0.06705424f, -0.35472244f, -0.09914764f, 
    -0.21035023f, -0.06944646f, -0.00982725f, 0.05418504f, -0.06066720f, 0.01668844f, 0.02138712f, -0.05455210f, 
    0.04667385f, -0.00158182f, -0.04526084f, 0.01010062f, -0.00102445f, 0.01204197f, -0.03760517f, 0.00658133f, 
    -0.26971570f, 0.01974593f, -0.21237771f, 0.19439571f, -0.05687941f, 0.09063214f, 0.13461378f, -0.15275109f, 
    0.00027419f, -0.05817412f, -0.05262540f, -0.03316826f, 0.01987351f, -0.00910240f, -0.03175081f, -0.05348375f, 
    0.04798797f, 0.01756715f, -0.04420809f, 0.08140640f, 0.12249706f, 0.12853251f, 0.07103796f, -0.01241164f, 
    -0.02295464f, 0.06683374f, -0.05250712f, -0.08525275f, 0.07370429f, -0.03569964f, 0.06630839f, -0.02955848f, 
    0.05270207f, -0.09603614f, -0.03651910f, -0.00719602f, -0.00789711f, 0.01555165f, -0.06410877f, 0.00714147f, 
    0.13437349f, 0.03896528f, -0.18163113f, -0.11227115f, 0.12122761f, -0.00802063f, 0.01730060f, -0.07214837f, 
    -0.05401484f, 0.10708260f, -0.06349733f, -0.01495725f, -0.03134124f, -0.01700324f, -0.01564588f, 0.15889895f, 
    -0.02698365f, 0.00934679f, 0.06280607f, 0.02298349f, -0.15707785f, -0.34387761f, -0.34836602f, 0.21298008f, 
    0.04090178f, -0.08079270f, 0.02319846f, -0.01661834f, -0.15679090f, 0.02558315f, 0.01648379f, -0.00352731f, 
    0.06637479f, 0.08616021f, -0.03202133f, -0.00017996f, 0.07302424f, -0.14932252f, -0.10468232f, 0.09794134f, 
    -0.09658766f, 0.05037732f, -0.00846704f, -0.01537525f, 0.05831799f, -0.01908437f, -0.02833669f, -0.06229981f, 
    0.04359908f, -0.10482630f, -0.04683399f, -0.13455197f, 0.03560236f, -0.02463821f, 0.04400809f, -0.01893339f, 
    -0.00045610f, -0.04398416f, 0.03894377f, -0.06407133f, -0.16968249f, -0.14707747f, 0.04981539f, -0.08105949f, 
    0.06937855f, -0.12658618f, 0.03138401f, 0.07761606f, -0.10683300f, -0.06081537f, -0.00935651f, -0.01266952f, 
    0.03329946f, 0.01332165f, -0.01682177f, 0.02294723f, -0.03790682f, -0.07588194f, 0.02389817f, -0.10292174f, 
    0.18508351f, 0.01039354f, -0.09928304f, -0.11291981f, 0.13437560f, -0.15901226f, 0.05861861f, -0.06487291f, 
    0.00497221f, 0.08238929f, 0.02070681f, 0.13265574f, -0.14682199f, 0.05622240f, -0.02644204f, 0.06504807f, 
    -0.09731766f, -0.01417490f, -0.01223523f, 0.12497592f, 0.05848246f, -0.16130294f, 0.37315574f, 0.19405986f, 
    0.13354419f, 0.06898230f, -0.01048646f, 0.03511300f, 0.05122905f, -0.12809688f, 0.04060275f, 0.05953501f, 
    0.06531919f, 0.04052583f, 0.03145730f, 0.02096320f, -0.00123176f, -0.02681347f, 0.04095763f, -0.03280720f, 
    -0.19234253f, 0.00554272f, 0.07534441f, -0.03502735f, 0.06118356f, -0.01735751f, -0.10062499f, -0.21547823f, 
    -0.17043710f, 0.09886788f, 0.06528655f, -0.01415997f, 0.00559181f, 0.01449156f, -0.06152901f, -0.01413956f, 
    -0.02507399f, -0.02135349f, -0.18518573f, -0.02239892f, -0.05059564f, 0.34012905f, 0.37357295f, 0.06162589f, 
    0.27213448f, -0.16507231f, -0.08338092f, 0.07010107f, 0.10891277f, 0.12181961f, 0.02229489f, 0.08493003f, 
    -0.07088754f, 0.05607465f, 0.01041605f, 0.02670241f, -0.02316261f, -0.01504903f, -0.01640709f, -0.02687194f, 
    -0.37546417f, -0.08169532f, 0.09401312f, 0.04755905f, -0.52424896f, 0.01609216f, -0.21868795f, -0.11420692f, 
    -0.03011436f, 0.05447213f, 0.01855990f, 0.02181745f, -0.22288752f, 0.06426286f, 0.13952850f, 0.06112426f, 
    0.04206399f, -0.07412883f, 0.11598294f, -0.06696919f, 0.18818480f, -0.07334717f, 0.30933443f, 0.23832615f, 
    0.03881117f, -0.04987275f, -0.03760968f, 0.07749818f, 0.01492643f, -0.14074947f, 0.05904710f, 0.07098908f, 
    0.10798388f, -0.04448123f, 0.01646881f, -0.00330803f, -0.04713017f, 0.02235790f, 0.01416560f, -0.08197636f, 
    -0.01947792f, -0.03437306f, -0.02630301f, -0.17330980f, 0.03305887f, -0.05431759f, -0.00083433f, -0.00252276f, 
    0.06383818f, 0.07435827f, 0.01699788f, 0.00751670f, -0.03399601f, 0.05699171f, 0.01869764f, -0.10208470f, 
    -0.04728237f, 0.03312210f, 0.02918696f, -0.02584817f, -0.26363900f, -0.85372287f, -0.52797395f, 0.21149260f, 
    -0.44712007f, -0.00059320f, -0.09179510f, -0.03603898f, -0.02615419f, -0.05855940f, -0.01639168f, 0.01727398f, 
    0.01876340f, -0.03929158f, -0.04651245f, 0.00391206f, 0.00305947f, 0.04160155f, -0.17271048f, -0.13431208f, 
    -0.08127144f, -0.08564450f, 0.41697168f, -0.02557033f, 0.23998396f, 0.00333736f, -0.00767795f, 0.04389327f, 
    -0.03733503f, -0.10559520f, -0.01298246f, 0.04208712f, -0.11078341f, -0.03685451f, 0.00654174f, 0.05515547f, 
    -0.00172676f, -0.01901684f, 0.01265040f, -0.01539313f, -0.28575566f, -0.76569796f, -0.10180930f, -0.20844431f, 
    -0.39540273f, 0.00696679f, 0.00723569f, -0.04343873f, 0.08149556f, -0.12937663f, 0.00422778f, -0.04116019f, 
    -0.00628001f, -0.02458030f, 0.03107000f, -0.00849665f, 0.02474673f, -0.15484546f, 0.10018022f, -0.01359896f, 
    -0.81942332f, -0.19325064f, 0.36092600f, -0.29724008f, -0.12329859f, -0.08997454f, 0.08581362f, -0.00066171f, 
    0.05740441f, 0.04338013f, 0.01878933f, -0.02109311f, 0.01637136f, 0.00552088f, -0.01738783f, -0.01384426f, 
    -0.08295496f, 0.04732960f, -0.00430216f, 0.01506389f, -0.10591377f, -0.15265723f, 0.33436310f, 0.28617027f, 
    0.13216597f, 0.01669209f, -0.01895993f, -0.02048736f, 0.04294899f, -0.04648824f, 0.03321901f, -0.01049386f, 
    -0.02725180f, 0.08764814f, -0.03612056f, -0.01433471f, 0.01675645f, -0.08151030f, -0.08981214f, -0.04941636f, 
    0.02032749f, 0.01485137f, -0.16112058f, -0.07144032f, 0.07790722f, 0.07378605f, 0.03988206f, 0.00338941f, 
    0.02629520f, -0.01071794f, -0.06122700f, 0.00261898f, 0.01168766f, 0.00813668f, 0.01247267f, 0.12080781f, 
    0.09487703f, -0.02893448f, 0.13686192f, 0.05761547f, -0.03171173f, -0.09819312f, -0.08098306f, -0.15515171f, 
    -0.07560355f, 0.04110933f, 0.02508957f, 0.00066043f, 0.00366749f, 0.03960560f, 0.01112872f, -0.00715203f, 
    0.02335798f, 0.04141283f, 0.03141658f, -0.02417661f, 0.04229958f, 0.09849018f, 0.06036267f, -0.07682067f, 
    0.33264032f, 0.22622943f, -0.24127425f, 0.05925251f, 0.31481877f, -0.13914950f, 0.08521396f, -0.21949203f, 
    0.05146557f, 0.10573944f, -0.01826981f, 0.02010404f, 0.03403270f, 0.05016264f, -0.04428325f, -0.02445917f, 
    -0.01851956f, 0.03104410f, -0.14184642f, 0.04825515f, 0.29325199f, -0.34617200f, -0.09849834f, -0.35179698f, 
    -0.04260755f, -0.01888163f, -0.09388509f, -0.06490950f, 0.01330708f, 0.01947007f, 0.02288524f, -0.06025347f, 
    -0.03453063f, 0.10715400f, 0.09599983f, 0.09296505f, -0.04726290f, -0.28948119f, 0.09267114f, 0.04857961f, 
    0.36007100f, 0.18587394f, 0.02743646f, 0.14165393f, 0.31574300f, 0.01500706f, 0.08548579f, -0.13485581f, 
    0.06892129f, -0.07925025f, -0.01447118f, -0.02384929f, 0.02236211f, 0.03407840f, 0.05418472f, 0.05083549f, 
    0.10868212f, 0.05470104f, 0.00409779f, 0.09605350f, -0.23768796f, 0.17662865f, 0.68132389f, -0.12723635f, 
    0.01042537f, -0.03776203f, -0.04738224f, 0.08189730f, -0.07169680f, 0.10680313f, 0.02281087f, -0.04632122f, 
    -0.00288266f, -0.10029279f, 0.00833586f, -0.00200759f, 0.03248483f, -0.02023501f, 0.09634084f, -0.10412721f, 
    -0.03153024f, 0.07344146f, 0.16737114f, 0.12787771f, 0.19383723f, 0.06485738f, 0.04530482f, -0.02239283f, 
    0.09177046f, 0.06646634f, -0.03724479f, 0.00303381f, -0.00089875f, 0.01302313f, -0.00998890f, -0.02044281f, 
    -0.00266382f, 0.01683702f, -0.00346478f, 0.03535019f, -0.14233644f, -0.20797543f, 0.55775964f, 0.15457213f, 
    0.25748697f, -0.02423147f, 0.01449880f, 0.04225963f, 0.14728722f, -0.19289978f, -0.00206262f, 0.04886086f, 
    0.08805518f, -0.15966001f, 0.07326519f, 0.02728040f, -0.02425351f, 0.02980606f, -0.01633654f, -0.03507877f, 
    -0.22161122f, 0.25972083f, 0.04642062f, 0.37212893f, -0.16947559f, -0.02046761f, -0.02785686f, 0.04115761f, 
    -0.07917085f, 0.20806845f, 0.05248003f, 0.02005635f, 0.02745974f, -0.00869523f, -0.09174433f, 0.02874380f, 
    -0.00311036f, 0.00816259f, 0.00151365f, 0.05704071f, -0.10236062f, 0.01690872f, 0.02832035f, -0.02490315f, 
    0.02413206f, -0.02413703f, -0.03561471f, -0.02206474f, 0.01524514f, 0.06824334f, 0.04582083f, -0.00635052f, 
    -0.08692482f, 0.13184190f, 0.05448371f, 0.05596324f, -0.05117463f, 0.04266389f, 0.03600825f, -0.05159656f, 
    -0.19578262f, 0.19563441f, 0.03896339f, -0.18174669f, -0.22128738f, 0.07935417f, -0.21016523f, -0.17488010f, 
    -0.07294166f, -0.04047180f, -0.03227426f, -0.04119559f, -0.12169624f, -0.03518803f, -0.07653789f, 0.01527908f, 
    -0.01301762f, -0.08545846f, 0.16539137f, -0.11851119f, 0.02223249f, -0.09677844f, -0.04186193f, -0.05239081f, 
    0.05027777f, 0.00829723f, -0.03812994f, 0.02068252f, 0.01441195f, 0.01723906f, 0.01054439f, 0.00512185f, 
    -0.02006168f, 0.08452100f, 0.00869713f, 0.03593533f, 0.02157731f, 0.06169697f, 0.01576932f, -0.01281160f, 
    0.04320693f, 0.12431123f, 0.20841473f, 0.11253192f, 0.11250664f, 0.00236396f, -0.00259774f, 0.10597451f, 
    0.02898985f, -0.10011830f, -0.02480147f, -0.03858722f, 0.07919541f, -0.02622292f, 0.11192197f, -0.02306779f, 
    -0.03523937f, -0.03524516f, 0.00451942f, -0.05962111f, -0.16190502f, -0.09417272f, 0.02367429f, -0.03856171f, 
    0.01870314f, -0.01826705f, -0.02988752f, 0.01022824f, 0.02283988f, 0.03738166f, -0.00689012f, -0.02444096f, 
    -0.05199450f, 0.03207764f, -0.04670060f, -0.12064751f, -0.10689884f, -0.03844015f, 0.03176207f, 0.01795506f, 
    -0.15055746f, -0.04131754f, -0.00431787f, -0.01837881f, 0.01470791f, -0.01887793f, 0.00767590f, -0.04702874f, 
    -0.01945569f, 0.08082768f, 0.00749428f, -0.02698897f, -0.01592266f, 0.07806700f, -0.06578428f, 0.01106076f, 
    -0.09390376f, -0.01054291f, -0.03827170f, -0.00033315f, -0.18362711f, 0.04100307f, 0.08273584f, -0.08497952f, 
    -0.04941331f, 0.02540294f, -0.15352036f, -0.25560269f, -0.04992037f, 0.06564289f, 0.03924645f, 0.00326997f, 
    0.02159914f, 0.04796118f, -0.04305753f, 0.01388178f, -0.03618049f, -0.07154025f, -0.05619480f, 0.05964081f, 
    -0.19038032f, -0.51097876f, -0.28711995f, -0.03430521f, -0.23094295f, 0.16521810f, 0.10896168f, -0.07201061f, 
    0.03957770f, -0.12227213f, -0.01957474f, 0.03942795f, -0.03368715f, 0.02338059f, -0.05457618f, 0.02606185f, 
    0.01774039f, 0.01547415f, -0.05879048f, 0.11804909f, -0.59043878f, 0.52027309f, -0.10866392f, -0.08335532f, 
    -0.46928850f, 0.09721874f, -0.02204646f, -0.02688190f, -0.07672252f, 0.06546131f, -0.01281114f, 0.04301464f, 
    0.03447136f, -0.11849562f, 0.06922714f, 0.14411773f, 0.04425892f, 0.00859728f, 0.17414278f, 0.04310782f, 
    -0.21694818f, -0.35580552f, 0.31135842f, -0.34907213f, -0.09558336f, 0.00356346f, 0.04757354f, -0.15289433f, 
    -0.16240101f, 0.09148701f, 0.04959792f, -0.02764229f, -0.01450899f, 0.06473663f, -0.02622673f, 0.04821381f, 
    -0.20496711f, -0.25377446f, -0.01336375f, -0.01788626f, 0.14253524f, -0.18715215f, -0.12946029f, 0.04473947f, 
    -0.01404876f, -0.04926792f, 0.08370823f, 0.00358565f, 0.06120660f, -0.09766851f, 0.07062630f, 0.05270754f, 
    0.02727456f, -0.00331064f, 0.02090470f, 0.02209645f, 0.04941619f, -0.05274333f, 0.10045607f, -0.01788757f, 
    -0.13346224f, 0.03559927f, 0.34334773f, 0.04143196f, 0.06666529f, -0.08731833f, -0.13510688f, -0.02588680f, 
    0.05021504f, -0.04520386f, 0.03620829f, 0.01896418f, -0.12926151f, 0.09307943f, 0.11044505f, 0.03923041f, 
    -0.03597365f, 0.07561801f, 0.07321540f, -0.04991879f, -0.15011750f, 0.08726038f, -0.00811310f, 0.03106558f, 
    0.08325741f, 0.04638067f, -0.00954970f, -0.00174561f, -0.04542723f, 0.11018686f, 0.04463142f, 0.04877451f, 
    -0.04844225f, 0.09258656f, -0.06195311f, 0.08004344f, 0.04385648f, 0.07037603f, 0.16137503f, -0.07116803f, 
    -0.12956633f, -0.14252035f, -0.07662608f, 0.02099379f, 0.02386693f, 0.02851581f, -0.02231589f, 0.04140662f, 
    0.00621056f, 0.00831580f, -0.00660963f, -0.04939998f, -0.00197774f, 0.06754062f, 0.08601373f, -0.00486514f, 
    0.08114669f, 0.02495662f, 0.03337251f, -0.00953266f, 0.22907850f, 0.14005330f, -0.24798322f, 0.11032876f, 
    0.13123098f, -0.03947049f, -0.05375693f, -0.00126307f, 0.03171477f, -0.00723600f, -0.11081570f, 0.05916651f, 
    0.04625519f, -0.02526599f, -0.01455431f, 0.00882842f, -0.07014585f, 0.06089761f, -0.01280519f, -0.05313677f, 
    -0.09889693f, -0.43210056f, -0.42583966f, -0.00721123f, -0.24167864f, 0.11892655f, 0.06782389f, -0.01898556f, 
    0.05948302f, -0.19063783f, 0.01851415f, 0.02717284f, -0.01111242f, 0.02512725f, -0.02550208f, 0.02963900f, 
    -0.03399513f, -0.04693860f, 0.02710148f, -0.00450883f, -0.19598630f, 0.16750118f, -0.00857105f, -0.22301005f, 
    -0.20508833f, 0.03954545f, -0.11346990f, -0.00116107f, -0.04247031f, 0.07466798f, 0.03497759f, -0.06420191f, 
    0.04116534f, -0.08090500f, 0.02305100f, 0.04129210f, 0.01192096f, -0.14006586f, 0.07638273f, 0.01938556f, 
    -0.19487564f, 0.34768519f, -0.16815661f, 0.16145256f, 0.03044579f, -0.03871894f, -0.04618843f, -0.11180032f, 
    -0.05513101f, 0.09711189f, 0.06853911f, 0.06792293f, 0.05165500f, -0.02775764f, -0.05443159f, -0.02376081f, 
    -0.03838036f, 0.07014599f, -0.02690131f, -0.04120006f, -0.51167744f, -0.47700775f, -0.23668310f, -0.02720119f, 
    -0.41377103f, -0.02657184f, -0.01266071f, -0.01581050f, 0.08677806f, -0.10640948f, -0.01332099f, -0.01067230f, 
    0.00495534f, -0.03767071f, -0.02472368f, -0.03089838f, 0.03207325f, 0.04351524f, 0.04569347f, 0.12651929f, 
    -0.01082902f, -0.14999846f, 0.32175291f, 0.06859300f, 0.23982754f, -0.05653922f, 0.07715464f, 0.06315701f, 
    0.07611337f, -0.10434045f, -0.01838326f, -0.00904015f, 0.07563940f, -0.08269973f, 0.08774409f, -0.01159550f, 
    0.02340787f, 0.02011722f, -0.01887284f, 0.01725352f, -0.20106153f, 0.02617041f, 0.16920134f, -0.07905135f, 
    -0.05922500f, -0.00068566f, -0.14268613f, -0.32537937f, -0.11418767f, 0.02640091f, 0.03493623f, 0.02240084f, 
    0.01067344f, 0.03859954f, -0.00107323f, 0.07229803f, 0.01084160f, -0.15584300f, -0.03444345f, 0.04937724f, 
    0.02533604f, -0.00847366f, 0.04373150f, -0.05620984f, 0.03460176f, 0.00500213f, -0.08497091f, -0.02241373f, 
    0.15021548f, -0.11937173f, -0.03434662f, -0.08066404f, 0.00039433f, 0.01810810f, 0.02908022f, 0.04749875f, 
    -0.05065347f, -0.13988791f, 0.06489544f, -0.08184925f, 0.20949231f, 0.05871877f, -0.18478543f, 0.01021308f, 
    0.08610044f, 0.03707189f, -0.06889917f, -0.05786516f, 0.07470421f, 0.00087466f, -0.04994506f, -0.08906388f, 
    0.00024376f, 0.05045962f, -0.04995624f, -0.01364398f, -0.01013141f, -0.00301325f, 0.00990902f, 0.00726835f, 
    -0.11372549f, 0.20980014f, 0.11319596f, 0.24129957f, -0.25134733f, -0.00984115f, -0.03063259f, -0.00647948f, 
    -0.02193996f, 0.09819352f, 0.05756038f, -0.00434093f, 0.02124905f, -0.06524140f, -0.03017387f, 0.18042138f, 
    0.06928890f, 0.12193312f, 0.13851967f, 0.11373679f, 0.06635553f, -0.01894589f, -0.03006822f, -0.03226718f, 
    0.09638007f, -0.02630404f, -0.00553712f, -0.00180613f, 0.03713912f, -0.05285333f, -0.06743392f, 0.00545825f, 
    0.00703489f, 0.04587288f, 0.06357104f, 0.01756518f, -0.03855637f, -0.10907916f, 0.05647488f, -0.10275187f, 
    -0.35166332f, -0.00913753f, 0.45982420f, -0.03790902f, -0.02179233f, 0.01852151f, -0.04708026f, 0.00928657f, 
    -0.02982838f, 0.07230089f, 0.05310989f, -0.05438968f, -0.02705766f, -0.05842909f, 0.06596465f, -0.02468603f, 
    0.06288166f, 0.16321373f, 0.04646828f, -0.09473009f, 0.01061860f, -0.05304165f, -0.06877729f, 0.04800453f, 
    -0.20952328f, -0.02722210f, -0.20023203f, -0.13691133f, 0.04690709f, -0.09220582f, -0.00802768f, 0.00146924f, 
    0.00220838f, -0.07096789f, 0.00974106f, -0.12630358f, 0.09059823f, 0.09312191f, 0.03733021f, -0.01871903f, 
    -0.26396361f, 0.25782001f, -0.00910418f, -0.16587324f, -0.29570258f, 0.02737305f, -0.06640392f, -0.00983338f, 
    -0.03816515f, 0.05216782f, 0.04416980f, 0.07271492f, 0.00535518f, -0.10582902f, -0.04180299f, -0.07618705f, 
    0.02603104f, 0.10392588f, 0.21129948f, -0.15732020f, 0.11607639f, -0.28196594f, -0.07717929f, -0.27578795f, 
    0.06983459f, 0.07319327f, -0.06986506f, -0.04437847f, -0.00668536f, 0.05765404f, -0.03822602f, -0.07456481f, 
    0.06024624f, -0.06610040f, 0.08083232f, 0.09463601f, -0.04058888f, -0.23438568f, 0.09392612f, -0.00642115f, 
    -0.19738154f, 0.19013676f, -0.00877320f, 0.08231454f, 0.03570000f, -0.02336219f, 0.02943421f, -0.05868211f, 
    -0.12798584f, -0.09370876f, -0.02724366f, 0.00187543f, -0.18878031f, 0.02350162f, 0.04995777f, -0.00357643f, 
    -0.04523036f, -0.06137849f, -0.09612527f, -0.07134593f, -0.06120101f, -0.17568393f, -0.00826865f, -0.02935814f, 
    0.11239944f, -0.03737366f, -0.01338608f, -0.02803066f, 0.00651430f, -0.00262513f, -0.03689019f, -0.04267173f, 
    -0.01567503f, -0.02443125f, 0.05998651f, 0.00371863f, 0.04482251f, 0.06758277f, -0.02788658f, -0.00675836f, 
    -0.15556334f, -0.28998765f, -0.07656343f, -0.06274887f, 0.07640329f, 0.01614865f, -0.02272858f, 0.06200656f, 
    -0.02341035f, 0.06972680f, 0.04189517f, 0.09196595f, -0.09280137f, 0.06777036f, -0.11348043f, 0.08614179f, 
    0.06605702f, 0.15300751f, 0.00994817f, -0.09741933f, -0.39071184f, -0.72164023f, -0.53309977f, -0.04085127f, 
    -0.42042992f, -0.16072270f, 0.02009093f, -0.03838074f, 0.03478940f, -0.04411317f, -0.02709092f, 0.02020594f, 
    -0.00418567f, -0.01519978f, -0.02986526f, -0.01584725f, 0.00822854f, 0.00305503f, -0.13601367f, 0.12122366f, 
    0.01754546f, -0.04274728f, -0.06612349f, -0.25270081f, 0.07048465f, 0.06446750f, -0.04043880f, -0.03510204f, 
    0.05226016f, 0.06171095f, -0.02898548f, -0.03153171f, 0.08989779f, -0.05581146f, 0.08314177f, 0.03565308f, 
    0.02633523f, -0.04418816f, 0.06414726f, 0.04958860f, 0.22047834f, -0.03188688f, 0.09547193f, 0.00100907f, 
    0.05521099f, -0.07762381f, 0.04283034f, 0.03775184f, 0.08653776f, 0.12736419f, 0.02979914f, 0.00985221f, 
    -0.03867675f, 0.10294233f, 0.02720790f, 0.07303243f, -0.04006960f, -0.11702851f, 0.03103401f, 0.03093671f, 
    -0.18988170f, 0.09703388f, -0.13298737f, 0.06772056f, -0.02168199f, -0.01542235f, 0.07364723f, -0.12022997f, 
    -0.03665516f, -0.20109014f, 0.01807416f, 0.05011986f, 0.00606820f, 0.02315711f, -0.01458152f, 0.03097981f, 
    0.01594224f, -0.01262431f, -0.01251253f, 0.02554587f, -0.16497988f, 0.05468825f, 0.25772890f, 0.04451918f, 
    0.19739400f, 0.01848101f, -0.04028533f, 0.06775521f, 0.11335028f, -0.07582510f, -0.00077496f, 0.07505361f, 
    0.01420562f, -0.02045470f, 0.04614506f, -0.00274244f, -0.02119982f, 0.07276025f, 0.00067138f, -0.03001678f, 
    -0.15849110f, -0.02780560f, -0.22104524f, 0.05364509f, -0.29580671f, -0.01246626f, 0.07456580f, -0.01960384f, 
    0.01523002f, -0.24242611f, 0.00651559f, 0.12395994f, -0.01933711f, -0.02333544f, -0.07760023f, 0.00407679f, 
    -0.02667532f, 0.07412551f, 0.11826844f, -0.07633840f, -0.02330330f, -0.04628139f, 0.37413812f, 0.28542143f, 
    0.14403093f, 0.04025650f, 0.02721289f, 0.02413013f, 0.08709712f, -0.02666654f, -0.00736975f, 0.01170199f, 
    0.01287918f, 0.00907599f, -0.01484302f, -0.02948615f, 0.04701459f, 0.03751056f, -0.02914348f, -0.00643042f, 
    0.51430613f, 0.51139212f, -0.01442070f, -0.47722095f, -0.45682392f, -0.13532451f, -0.18167081f, 0.04543904f, 
    -0.22751215f, -0.05554392f, 0.00874053f, -0.03778107f, 0.06585616f, -0.08927003f, -0.01623074f, -0.03967285f, 
    -0.07458899f, -0.26226231f, 0.07047354f, 0.07756809f, 0.13524929f, -0.04719532f, -0.17602192f, -0.22415335f, 
    0.14896315f, -0.06530073f, 0.00715329f, 0.09686793f, 0.12349662f, 0.04425119f, -0.04911029f, -0.01647680f, 
    0.03444218f, -0.03561020f, -0.00152692f, -0.04084884f, 0.08700644f, 0.05603357f, -0.08343719f, -0.04896328f, 
    -0.05224419f, 0.18564114f, -0.12536630f, 0.44519144f, 0.26857334f, 0.02774853f, -0.02132979f, 0.00973600f, 
    -0.10160092f, 0.01043322f, 0.05078374f, 0.06176382f, 0.17405874f, -0.13825630f, -0.04961810f, 0.13510010f, 
    -0.00180667f, 0.14188589f, -0.00257196f, -0.15177630f, -0.10347389f, 0.15087357f, 0.32751966f, -0.06814983f, 
    0.30140993f, -0.05724879f, -0.04621720f, -0.13234343f, -0.09774009f, -0.13213547f, 0.16809157f, 0.07240626f, 
    0.06785242f, -0.04582439f, 0.06738941f, -0.00934038f, 0.04781341f, 0.10616910f, -0.06505222f, -0.13676290f, 
    -0.10121723f, 0.03022158f, -0.13194470f, -0.28720155f, -0.17883420f, -0.09205263f, -0.04454907f, 0.03388313f, 
    -0.18753260f, 0.01317661f, -0.07536170f, -0.02742708f, -0.08253670f, -0.08455024f, -0.06628826f, 0.03918516f, 
    -0.05897234f, 0.15044019f, -0.02337401f, -0.00481560f, 0.04168432f, -0.05858171f, -0.13107465f, -0.03513799f, 
    0.11773986f, 0.12630539f, 0.08441042f, -0.06217786f, -0.00925063f, -0.07068865f, -0.16712627f, 0.02006567f, 
    0.05395300f, 0.01900651f, 0.01137021f, -0.09416418f, 0.02239370f, 0.00719536f, 0.04629898f, -0.01534729f, 
    0.02081318f, -0.07484966f, 0.19598739f, 0.07974099f, 0.12505002f, 0.06316965f, 0.01680637f, 0.07963768f, 
    -0.00477290f, 0.06957954f, 0.14154078f, -0.03747490f, -0.08147337f, -0.00996748f, 0.02120983f, 0.00539322f, 
    0.00115698f, 0.11603512f, 0.01779676f, -0.24580510f, 0.15062009f, -0.19105430f, -0.19439974f, 0.05476622f, 
    0.27673158f, 0.04740859f, -0.11634561f, 0.10471079f, -0.13322882f, -0.16029121f, -0.10431214f, 0.08409750f, 
    0.03994533f, 0.07609756f, 0.08289871f, 0.07409429f, 0.07540818f, 0.04845490f, 0.02032106f, 0.16491690f, 
    0.20721704f, -0.30313927f, 0.13532853f, -0.02082158f, 0.16384105f, 0.06951158f, 0.01779408f, -0.00997149f, 
    0.15421247f, -0.19722785f, 0.01295354f, 0.02559744f, 0.16061720f, 0.02637186f, -0.14766836f, -0.09928416f, 
    0.05426669f, 0.24232909f, 0.08253106f, 0.01328786f, -0.26154375f, 0.20562282f, -0.21614376f, -0.05403879f, 
    0.28775376f, 0.16097389f, 0.00216064f, 0.01121203f, -0.08161449f, 0.09588484f, -0.08114150f, 0.06458385f, 
    -0.01479621f, -0.02600482f, 0.07094053f, 0.03476891f, -0.03226322f, 0.03873598f, 0.09147830f, -0.02668563f, 
    -0.29061639f, 0.04734750f, 0.25988510f, -0.34040952f, -0.29772931f, -0.21631956f, -0.08246941f, -0.05089751f, 
    -0.05258455f, -0.13062042f, 0.01607144f, -0.01175335f, 0.01149075f, 0.04046683f, -0.00633291f, 0.02338377f, 
    0.02874985f, 0.06436798f, -0.07977130f, -0.07534913f, -0.00054909f, -0.12164380f, -0.31626335f, 0.01660864f, 
    0.18671344f, 0.23080936f, 0.02959694f, -0.01673273f, 0.10939446f, 0.10792200f, -0.02391132f, 0.03222911f, 
    -0.18046394f, -0.00829797f, -0.10214820f, 0.04498028f, -0.01904777f, 0.12426354f, -0.12218255f, 0.02503353f, 
    0.37658861f, -0.13324678f, -0.25192729f, 0.01437132f, 0.06146345f, 0.23140129f, -0.00809617f, 0.03968877f, 
    -0.05250967f, 0.01341667f, -0.15504907f, -0.07785041f, 0.08324161f, -0.00287155f, 0.00162512f, -0.12781419f, 
    -0.03594371f, -0.15269563f, -0.00350645f, 0.04275447f, -0.13929281f, 0.10510804f, -0.06833039f, 0.03069744f, 
    0.13471302f, 0.07306781f, 0.00576349f, -0.00195746f, 0.01349900f, 0.13619018f, 0.03063167f, 0.09185497f, 
    -0.03219623f, -0.04385157f, -0.07333466f, 0.13724357f, 0.05574612f, 0.05588947f, 0.05227617f, 0.02406777f, 
    -0.14207473f, -0.34292957f, 0.48441705f, -0.03175696f, 0.23581634f, -0.29490393f, 0.01600228f, 0.16481569f, 
    0.01791349f, -0.02219730f, 0.14011066f, 0.04508413f, -0.01838476f, 0.07423825f, 0.14494856f, -0.05915052f, 
    0.01025440f, 0.08255899f, -0.04293073f, -0.00267125f, -0.04720982f, -0.00508157f, -0.19792514f, 0.00648628f, 
    0.22850315f, 0.02804606f, -0.02699269f, 0.02033379f, 0.00846261f, -0.00142505f, -0.07144061f, 0.11635625f, 
    0.00578157f, 0.08718979f, 0.09176149f, -0.02718144f, -0.00350125f, 0.15956174f, -0.00876845f, 0.04742029f, 
    0.40653801f, 0.21223591f, 0.02269909f, -0.25893578f, -0.27720094f, 0.05169292f, 0.13865437f, 0.05502602f, 
    0.02302376f, 0.12160862f, 0.03320103f, -0.09368683f, 0.21562575f, -0.02861317f, 0.03404653f, -0.03052237f, 
    -0.01375518f, -0.09284515f, -0.01486384f, 0.12066849f, 0.19082579f, -0.14209343f, 0.14402904f, -0.12067629f, 
    -0.35141122f, -0.08797624f, 0.04396234f, 0.04261646f, 0.10520320f, 0.01922346f, 0.08880866f, -0.00517176f, 
    0.10785013f, -0.00955499f, -0.08101483f, 0.06176218f, -0.08710635f, -0.02511300f, -0.08868221f, -0.03756983f, 
    -0.15447912f, 0.24764921f, -0.13025141f, -0.32734033f, 0.16725944f, 0.17584951f, 0.18627118f, -0.18622676f, 
    -0.07538497f, -0.21213375f, -0.13922092f, 0.09144829f, -0.12955268f, 0.04797465f, 0.02943985f, 0.07951548f, 
    -0.03256183f, 0.13422640f, -0.07343389f, -0.03899238f, -0.07624144f, 0.11525414f, 0.42179844f, -0.09910039f, 
    -0.03787982f, -0.08597131f, -0.02432811f, -0.26378092f, -0.05368474f, -0.20350240f, -0.09678125f, -0.14523521f, 
    -0.02382897f, 0.11137611f, -0.00342949f, 0.01088760f, -0.05600685f, 0.01239325f, -0.09997346f, 0.01528698f, 
    0.15002561f, 0.48709244f, 0.10888639f, -0.35153633f, 0.06384333f, 0.13802004f, 0.11473455f, -0.16374877f, 
    -0.09136054f, 0.05377723f, -0.01457136f, -0.00144019f, 0.08308679f, -0.05103848f, 0.10912552f, 0.05228496f, 
    0.06996287f, -0.03561106f, 0.06113421f, 0.01593380f, 0.06365664f, 0.69132441f, -0.16993578f, 0.18670543f, 
    0.22694652f, 0.16036834f, -0.04504959f, -0.03739048f, -0.06108143f, 0.06901078f, -0.03292102f, -0.04101865f, 
    0.08765467f, -0.02137725f, 0.10665918f, 0.01487756f, -0.12832052f, 0.00903009f, 0.06530119f, -0.06404918f, 
    -0.04828583f, -0.00539616f, -0.12727971f, -0.10037165f, 0.15042537f, 0.00186155f, -0.01340721f, -0.03298641f, 
    0.01071415f, -0.04418904f, -0.02312838f, 0.01925536f, 0.08885980f, 0.05826701f, 0.07388262f, -0.02601890f, 
    -0.04344803f, 0.14602070f, -0.03704935f, 0.05076183f, -0.41275954f, 0.48336485f, -0.04959271f, -0.13534734f, 
    0.16995314f, 0.26172760f, 0.04196784f, -0.02079731f, -0.02349705f, 0.00516894f, -0.19786789f, -0.00467337f, 
    0.02167959f, 0.03110884f, 0.10482979f, -0.07021735f, 0.13588762f, -0.19524199f, 0.04821689f, 0.04795460f, 
    -0.04800313f, -0.07725588f, -0.10954230f, 0.27351072f, 0.20048784f, -0.15417202f, -0.10505931f, -0.04810779f, 
    -0.03166331f, -0.17490299f, -0.04575418f, 0.02574098f, -0.06234435f, -0.06439455f, 0.02795628f, -0.20224780f, 
    -0.02310075f, -0.11438970f, 0.01782921f, 0.01048595f, -0.34241077f, -0.00994751f, -0.02758248f, 0.06123938f, 
    -0.18940435f, -0.00925937f, -0.10743791f, -0.11523370f, -0.13767388f, -0.19486865f, -0.00528275f, 0.02490861f, 
    -0.01357316f, 0.04690481f, -0.10797168f, 0.02634865f, -0.00147652f, 0.03290471f, -0.10774241f, -0.05194132f, 
    -0.32086626f, -0.03948091f, 0.16663836f, 0.08362776f, 0.26974350f, -0.02239472f, -0.06440721f, -0.13287632f, 
    -0.16785935f, -0.05091243f, 0.01583567f, 0.05567292f, 0.04011998f, 0.01556509f, -0.10668910f, -0.04782042f, 
    -0.03606290f, -0.05156209f, 0.06372824f, -0.04175045f, -0.06028447f, -0.10170593f, -0.03548174f, -0.23307909f, 
    -0.43682545f, 0.03440759f, 0.01155984f, -0.01682276f, 0.01034970f, -0.13626553f, 0.00199922f, 0.00593135f, 
    -0.00673695f, -0.12344693f, -0.09344631f, -0.09574716f, -0.05185572f, 0.03743975f, -0.17207414f, -0.12745777f, 
    0.07264955f, -0.07813380f, -0.07161623f, 0.05342127f, 0.15775585f, 0.14407334f, -0.01401551f, 0.02404877f, 
    -0.16591713f, -0.02661434f, -0.05928994f, 0.04424864f, -0.02375740f, -0.07867716f, 0.00700000f, 0.02609563f, 
    -0.03903767f, -0.00446762f, 0.04703261f, 0.01163923f, -0.28613177f, -0.41173011f, -0.31530488f, -0.09637499f, 
    -0.43344504f, -0.08624589f, -0.17425509f, -0.04641322f, -0.05252482f, -0.08324936f, 0.01809543f, 0.08220722f, 
    0.00917913f, -0.04124765f, -0.09602779f, 0.07674263f, 0.09361935f, -0.10944254f, -0.20810331f, -0.09454889f, 
    -0.28293237f, -0.17289728f, 0.05676437f, -0.08843333f, -0.21063463f, -0.11394128f, -0.18990669f, -0.04416978f, 
    -0.05484068f, -0.14714001f, 0.01445385f, 0.02589185f, 0.01385811f, -0.03144561f, 0.09414095f, -0.06159674f, 
    0.03506036f, -0.12510374f, 0.07731867f, -0.07010743f, -0.14300764f, -0.12572934f, 0.06327208f, -0.03528762f, 
    0.14637415f, 0.05834258f, 0.11453199f, 0.03094792f, 0.09368055f, -0.01203410f, 0.08558907f, 0.06127521f, 
    -0.16161670f, 0.08455822f, 0.03315992f, 0.06218940f, -0.11943009f, 0.06229018f, -0.08699860f, 0.07694863f, 
    0.07857499f, -0.05085371f, -0.16821077f, -0.03911418f, 0.18812668f, 0.06477927f, 0.03909687f, 0.04847026f, 
    0.09473827f, 0.02212073f, 0.07526959f, -0.08496737f, 0.02117308f, 0.00618666f, -0.04395602f, -0.06683818f, 
    -0.06519815f, -0.03423424f, -0.10898844f, 0.08139023f, -0.60762703f, 0.23766758f, -0.25201571f, 0.38341239f, 
    -0.19014968f, 0.01819815f, -0.11759266f, 0.11502173f, -0.01768821f, -0.03732340f, -0.05443363f, 0.08774640f, 
    -0.09389990f, -0.06437194f, -0.00884976f, 0.02277490f, 0.00732586f, -0.02208781f, -0.00460817f, -0.03875672f, 
    -0.29593959f, -0.06224880f, 0.63198686f, -0.02477760f, 0.34561837f, -0.19947985f, -0.00314254f, -0.19427453f, 
    0.09993710f, -0.14360325f, 0.03071073f, -0.04297877f, -0.00247348f, -0.00417210f, 0.09989972f, -0.06718378f, 
    -0.05177841f, -0.19863619f, 0.07677617f, 0.04447554f, -0.02911807f, -0.01853719f, -0.07994712f, 0.08544099f, 
    0.10061111f, -0.04999595f, -0.09365718f, 0.11370654f, 0.00096388f, 0.03913661f, 0.04705101f, 0.00109760f, 
    -0.06263393f, -0.04641418f, -0.04069739f, -0.04867700f, -0.04416227f, 0.06377853f, -0.07851338f, -0.05523756f, 
    -0.02290907f, 0.04050808f, 0.03626828f, 0.05860576f, 0.21519488f, 0.01283846f, 0.02279928f, 0.06175559f, 
    -0.02711489f, -0.01215968f, -0.04969503f, 0.08562579f, 0.24806793f, 0.02110497f, 0.03118411f, -0.01851426f, 
    0.06451907f, 0.07000446f, 0.08047933f, 0.03872335f, -0.26600203f, 0.07194529f, 0.01709398f, -0.03823455f, 
    -0.17184569f, -0.02223932f, -0.01733171f, 0.03079898f, -0.07362846f, -0.02932684f, -0.07031809f, 0.11812691f, 
    -0.01811369f, -0.07159128f, -0.15230939f, -0.12718910f, 0.06224693f, -0.05700553f, 0.01909985f, 0.02033310f, 
    -0.37270164f, -0.31689042f, -0.28610322f, -0.05571609f, -0.53666264f, 0.21696639f, 0.08128384f, -0.00488606f, 
    0.03938441f, 0.04288862f, 0.11662436f, -0.03984756f, 0.20926686f, -0.06132204f, -0.05763121f, 0.03041793f, 
    0.06695887f, -0.17026711f, -0.17353299f, -0.06888995f, -0.07207552f, 0.13962767f, -0.06884026f, -0.38887906f, 
    0.06885509f, 0.01871308f, -0.07094914f, -0.00462714f, 0.01590183f, -0.23915665f, -0.01460117f, -0.01224470f, 
    -0.15987392f, -0.08232141f, 0.03138164f, -0.06316673f, -0.06265121f, 0.18609554f, -0.12715968f, -0.33025032f, 
    0.11332827f, -0.13599394f, -0.20863569f, -0.00050763f, 0.24580607f, 0.12399398f, 0.04253328f, 0.07545690f, 
    0.08494000f, 0.04107605f, 0.13052808f, -0.09221249f, 0.03077629f, -0.07824627f, -0.01028407f, -0.03550469f, 
    -0.00288246f, 0.00629192f, -0.08453659f, 0.10717599f, -0.60494292f, 0.00855588f, -0.12085302f, 0.11678464f, 
    -0.00693478f, 0.01243292f, -0.09361360f, -0.02924571f, -0.11624882f, 0.01215911f, -0.00685004f, -0.07754234f, 
    -0.01934433f, -0.00021803f, -0.06636640f, 0.01616763f, 0.18249218f, 0.06831263f, 0.00663159f, -0.20333378f, 
    -0.84847087f, 0.28383082f, 0.22489192f, -0.18880299f, 0.13910370f, -0.02921874f, 0.00606650f, 0.05105150f, 
    -0.16218181f, -0.09803134f, -0.23005921f, 0.05826486f, -0.13512307f, 0.10360546f, 0.06153737f, 0.03180453f, 
    0.11848972f, 0.14838789f, -0.18037064f, -0.09574616f, -0.05096054f, -0.10723813f, -0.08917747f, 0.06961623f, 
    0.20706126f, -0.02108492f, 0.11782426f, 0.07374007f, 0.00884285f, 0.03899860f, -0.03976760f, -0.01486072f, 
    -0.05706633f, -0.10363637f, 0.00707038f, 0.01941201f, -0.06479419f, 0.06283298f, -0.10379799f, -0.03557208f, 
    -0.04442845f, 0.41240317f, 0.06088385f, -0.11855038f, 0.09753829f, 0.22615102f, -0.01396234f, -0.08353782f, 
    -0.02754934f, -0.01544595f, -0.18942708f, -0.03466396f, 0.09591565f, -0.01254522f, 0.04855292f, -0.11261243f, 
    0.08836913f, -0.22522414f, 0.06340307f, 0.00722828f, -0.33728141f, 0.07267419f, 0.24239258f, 0.27904963f, 
    0.31623057f, 0.01719995f, 0.04347441f, -0.01797254f, -0.02711124f, -0.02361265f, 0.01814460f, 0.00201973f, 
    -0.09399492f, 0.01388065f, -0.06995983f, 0.00484932f, 0.02520545f, 0.07072333f, -0.04035834f, 0.04992277f, 
    -0.17454624f, 0.08749661f, -0.27679801f, 0.02892624f, 0.19850214f, 0.08843899f, -0.06346183f, 0.03772774f, 
    -0.05212416f, 0.05303731f, -0.04112599f, 0.00924275f, 0.13155448f, -0.01623867f, -0.09859703f, 0.08202262f, 
    0.03885255f, -0.02055441f, 0.04393814f, -0.13317673f, -0.22890627f, 0.40671656f, -0.13349308f, -0.27135819f, 
    -0.05871357f, 0.08249891f, 0.04312576f, 0.03286508f, 0.05743693f, -0.23271632f, -0.09801526f, 0.05799177f, 
    -0.15985344f, 0.02104788f, -0.05736403f, 0.03861181f, 0.03429037f, 0.01006127f, -0.07300482f, -0.13294815f, 
    -0.17842312f, 0.04128067f, -0.05457655f, 0.19386184f, 0.02383310f, -0.08099947f, 0.01691878f, 0.01910968f, 
    0.03395283f, -0.01634875f, 0.01365247f, 0.06025206f, 0.02362121f, -0.06888853f, -0.00107129f, 0.01551495f, 
    0.06137472f, -0.02402066f, 0.01681729f, 0.03530444f, -0.16684411f, 0.10373780f, 0.00893808f, -0.09888968f, 
    -0.07949616f, 0.00044220f, -0.22594614f, 0.06877900f, 0.01347528f, -0.00074119f, -0.07292983f, -0.00872660f, 
    -0.07736479f, 0.02613499f, -0.00779332f, -0.07165541f, -0.08401044f, 0.02747411f, -0.04421610f, -0.07848520f, 
    0.35588172f, 0.37671006f, 0.00509208f, 0.17958668f, 0.03421445f, 0.17083496f, 0.04720589f, -0.00859430f, 
    0.14517507f, 0.06826137f, -0.01482296f, -0.01538154f, 0.01162676f, -0.02846604f, 0.12018053f, -0.05311175f, 
    -0.02407596f, -0.06803089f, -0.00868933f, 0.02147593f, -0.34186795f, 0.20648399f, -0.01852623f, 0.22190249f, 
    0.25654027f, -0.06632229f, 0.07060564f, -0.01246701f, -0.06163077f, 0.03200952f, -0.11954418f, 0.07229293f, 
    -0.05046888f, -0.02579173f, 0.02100011f, 0.04950172f, -0.12368625f, 0.18100907f, -0.10338949f, 0.01581860f, 
    -0.78371453f, 0.88777488f, -0.49228439f, 0.20474119f, -0.24680357f, 0.12746271f, -0.00336789f, 0.09562220f, 
    0.00136735f, 0.06552620f, 0.02096222f, -0.12912436f, -0.11384932f, -0.14560665f, -0.00329088f, -0.04249402f, 
    -0.09846891f, -0.09578366f, -0.13903235f, -0.07307407f, -0.83026701f, -0.00600022f, -0.31975985f, -0.00069097f, 
    -0.40663770f, 0.20710428f, 0.07275716f, -0.10128389f, 0.14490810f, 0.13042635f, -0.05999862f, -0.14907162f, 
    0.09109949f, -0.16907121f, 0.01711130f, -0.02474258f, -0.11262866f, -0.01979152f, 0.15309952f, -0.08205286f, 
    -0.22573173f, -0.05577117f, 0.22438461f, 0.26733035f, 0.16678622f, 0.02226654f, 0.02576987f, 0.11562836f, 
    -0.09804608f, 0.02957151f, -0.03689169f, 0.01665666f, 0.00408390f, -0.01119839f, -0.03554586f, 0.22801299f, 
    -0.00538740f, 0.23115607f, 0.04646561f, -0.01314737f, -0.20060985f, 0.13143131f, -0.19574998f, -0.08094901f, 
    -0.36762798f, 0.29662973f, 0.10535938f, 0.12780657f, 0.02411480f, 0.09358531f, -0.21811956f, -0.19014217f, 
    -0.04184726f, -0.05248272f, -0.04974364f, -0.09188586f, 0.05184777f, -0.19944599f, 0.17607819f, -0.03776144f, 
    -0.25197631f, -0.01521563f, -0.13809153f, -0.07581522f, -0.15293817f, 0.09057764f, 0.02617351f, 0.03504913f, 
    -0.07840487f, -0.06924126f, -0.05479639f, 0.11090629f, -0.08350503f, 0.04916826f, -0.12395685f, -0.18655336f, 
    -0.02834071f, 0.09610556f, -0.36385450f, -0.05632647f, 0.02356790f, -0.08251870f, -0.22047918f, 0.02461459f, 
    0.18780385f, 0.00347571f, -0.02628056f, 0.03530833f, 0.05349280f, 0.09342052f, -0.08830862f, -0.00409217f, 
    -0.04495250f, -0.00629716f, -0.10539679f, -0.04647140f, 0.01734144f, 0.13359334f, -0.17694500f, 0.03998262f, 
    -0.39068505f, 0.39421207f, -0.11830237f, -0.06409002f, -0.38196710f, 0.04139379f, 0.08066125f, -0.09754694f, 
    -0.02025125f, 0.02153076f, -0.07943311f, -0.08717770f, -0.05296044f, -0.06070973f, 0.01019891f, -0.15102063f, 
    -0.14047888f, -0.00540765f, 0.08078863f, -0.16458173f, 0.00690086f, 0.03427289f, -0.16033454f, -0.07281318f, 
    0.06469980f, -0.11340509f, -0.07223703f, -0.00933627f, -0.03246530f, -0.07357641f, -0.12614964f, -0.08126026f, 
    -0.08297645f, 0.00660479f, 0.03089095f, -0.04014478f, 0.08126478f, 0.04431624f, -0.08716915f, 0.08178537f, 
    -0.12044764f, -0.06840565f, -0.14947310f, 0.12732479f, 0.04636532f, 0.05384449f, 0.04252526f, 0.08409586f, 
    0.04285966f, 0.08116368f, -0.03875679f, 0.07255737f, -0.02149920f, -0.06153164f, -0.04148875f, 0.06723224f, 
    -0.02693570f, 0.17738943f, -0.09897334f, -0.07964038f, -0.18512329f, 0.15102877f, 0.06552175f, -0.13161607f, 
    0.24409026f, 0.19392416f, -0.05152424f, -0.04300231f, -0.09552113f, 0.00609246f, -0.10626814f, 0.02380751f, 
    0.09302440f, 0.07617041f, 0.08183155f, -0.01984897f, 0.04725602f, 0.13675679f, -0.04520933f, -0.00100810f, 
    -0.16128093f, -0.15396200f, -0.22872867f, 0.04238117f, 0.17613353f, 0.02888260f, -0.04897331f, 0.19698663f, 
    0.04037398f, 0.07835797f, -0.04658038f, -0.05553454f, -0.20360862f, 0.00198371f, -0.08123943f, -0.04682551f, 
    -0.16208754f, 0.23798625f, -0.11312486f, 0.00942216f, -0.15185209f, 0.10958175f, -0.09480213f, -0.04107215f, 
    0.22919881f, 0.00122102f, -0.04079129f, -0.03088939f, -0.05259767f, 0.01618135f, -0.03175922f, 0.10750277f, 
    -0.02832356f, 0.11595996f, 0.09555148f, -0.01595943f, -0.06602213f, 0.07598210f, -0.00757951f, 0.04108243f, 
    -0.15231681f, -0.04312281f, -0.10432920f, -0.01759426f, -0.12957755f, 0.14135015f, 0.02964829f, -0.10765316f, 
    0.04716766f, -0.04978920f, 0.21658744f, -0.27288994f, -0.11134206f, -0.08199710f, 0.14746682f, -0.03865293f, 
    -0.04007977f, 0.02439048f, -0.10984550f, -0.12684689f, -0.23448387f, -0.05540254f, -0.05783089f, 0.03673721f, 
    0.05935575f, -0.09097610f, 0.09666129f, -0.06732392f, -0.06963623f, 0.03366467f, 0.01121730f, 0.02112840f, 
    -0.02922510f, 0.15069327f, 0.14563224f, 0.08578351f, 0.18276413f, 0.05976795f, 0.06015620f, 0.21633886f, 
    0.14568323f, -0.06413236f, 0.09901822f, -0.01100867f, 0.02683651f, 0.07229520f, 0.01449870f, 0.08016014f, 
    -0.10213249f, -0.01196429f, -0.03753393f, -0.11907518f, 0.09189492f, 0.00850438f, -0.02284756f, 0.08239998f, 
    -0.06328411f, -0.05538401f, -0.04974138f, -0.07757067f, 0.02322176f, 0.00823406f, -0.09830954f, -0.06609972f, 
    0.13785280f, -0.24696942f, -0.10575346f, -0.11343208f, 0.12851888f, -0.06152282f, 0.02555686f, -0.06358665f, 
    -0.07394629f, -0.11741314f, -0.00651108f, -0.24260004f, -0.11732822f, -0.05656884f, 0.00857534f, -0.06184098f, 
    -0.23827648f, -0.12196973f, 0.04513047f, -0.03560869f, -0.09508774f, -0.01530337f, -0.06770670f, -0.09746288f, 
    0.00894710f, -0.18968046f, 0.10466983f, -0.09770285f, 0.08289721f, -0.12986948f, 0.05714433f, -0.02406023f, 
    -0.13627398f, -0.08053064f, -0.23023593f, 0.03798833f, 0.14667626f, -0.14625725f, 0.21018948f, 0.05833327f, 
    0.02269230f, -0.13261899f, -0.08310080f, -0.09545953f, -0.02065145f, -0.01003277f, 0.02539199f, -0.04450779f, 
    0.01295376f, 0.01477344f, 0.04777984f, 0.00988439f, 0.02927565f, -0.02119749f, -0.05465720f, -0.04090197f, 
    -0.00598083f, 0.04791741f, 0.01650367f, 0.00650475f, 0.15478843f, 0.10393140f, 0.08264311f, 0.01143031f, 
    0.02709979f, 0.10937965f, -0.02262386f, 0.03926783f, -0.00855619f, -0.02744011f, 0.01501625f, 0.04035005f, 
    -0.10129625f, -0.13947792f, -0.10202461f, -0.12945154f, 0.06426232f, 0.07575723f, 0.21520099f, 0.04902576f, 
    0.17763713f, -0.15952069f, -0.03403595f, -0.11405493f, 0.02433359f, 0.17784637f, 0.10270349f, 0.02229824f, 
    0.01386554f, -0.00830094f, 0.07725868f, -0.02742816f, -0.02463477f, 0.04474630f, 0.00512929f, 0.00337387f, 
    -0.31895006f, -0.01394937f, 0.21022935f, 0.16404133f, -0.25710917f, -0.06650243f, 0.06206369f, -0.06956984f, 
    -0.02033687f, 0.04228898f, 0.07093494f, -0.02933424f, -0.13837940f, -0.10675272f, 0.13523574f, -0.03495319f, 
    0.04697797f, -0.11179308f, -0.13614704f, 0.02299079f, 0.18435293f, -0.14713334f, 0.12613824f, -0.01079878f, 
    0.05742386f, -0.10666887f, -0.04961515f, -0.12732865f, 0.00310962f, -0.08214691f, -0.00602487f, -0.04037549f, 
    -0.00488086f, 0.06602593f, 0.08116499f, 0.02433440f, 0.03167135f, 0.00810774f, -0.04292462f, -0.08151226f, 
    0.01877627f, -0.04222369f, -0.15904640f, -0.03575364f, 0.04935874f, 0.08157181f, 0.02681304f, 0.04169086f, 
    0.04266898f, 0.01629240f, 0.04199400f, 0.01744753f, -0.02485343f, -0.04988488f, 0.07371755f, -0.01684643f, 
    -0.01049674f, -0.04474018f, -0.05150484f, 0.00116618f, 0.15492544f, 0.23788024f, 0.24602899f, 0.26640266f, 
    0.18753648f, -0.24196300f, 0.01747894f, 0.08597971f, 0.10929354f, 0.20007753f, -0.00565780f, 0.04003023f, 
    0.04221387f, 0.01643936f, 0.09166459f, -0.02560316f, -0.04450557f, -0.11271269f, 0.06392373f, -0.15148336f, 
    -0.02477260f, -0.29385406f, 0.09130042f, -0.03555324f, -0.06289717f, -0.06838882f, -0.07771554f, -0.04941143f, 
    0.06278041f, 0.16571660f, -0.02822297f, -0.01908821f, -0.08033884f, -0.00764256f, -0.07966031f, 0.03739765f, 
    0.04087310f, 0.08468549f, -0.00720353f, 0.02964200f, -0.08458842f, -0.01528319f, 0.02527615f, 0.25506461f, 
    0.24633001f, -0.09724470f, 0.13359788f, 0.02104501f, 0.04940483f, -0.14023399f, 0.00432008f, -0.00061022f, 
    0.03294902f, 0.07983046f, 0.14117603f, 0.03684514f, 0.07945915f, 0.18172298f, -0.14409561f, -0.12158261f, 
    0.20971066f, 0.06661881f, -0.26372212f, 0.25953326f, 0.33551303f, -0.06025955f, 0.04064034f, 0.15090245f, 
    0.12481525f, 0.22182605f, 0.02153379f, 0.01009766f, 0.01544119f, -0.03533594f, 0.03382560f, 0.04352513f, 
    -0.03126413f, -0.02406973f, 0.16056077f, 0.04323350f, -0.08217076f, -0.12222020f, 0.06503282f, 0.11875612f, 
    0.07958139f, -0.08516836f, 0.03244658f, -0.04654967f, -0.11382589f, -0.12839919f, 0.00131960f, 0.02701187f, 
    -0.03677993f, 0.00467113f, -0.06615796f, 0.00776279f, 0.06088328f, -0.02210260f, 0.07266514f, 0.10728525f, 
    -0.07474123f, -0.11731416f, -0.23789591f, -0.00911238f, -0.39829561f, 0.07420092f, 0.00948531f, 0.08983955f, 
    -0.03188454f, 0.02910866f, 0.07575330f, -0.06630406f, -0.03043173f, 0.02333859f, -0.03897468f, 0.02125358f, 
    0.18859057f, 0.13166821f, 0.02201901f, 0.15899087f, 0.08177558f, 0.03981255f, -0.22996897f, -0.06721056f, 
    -0.32508606f, 0.05074942f, 0.01903663f, -0.00941034f, 0.04473286f, 0.02620606f, 0.03852011f, 0.00268457f, 
    -0.01520113f, -0.02438347f, 0.04476598f, 0.01344439f, 0.15115030f, 0.02007655f, -0.05632631f, 0.15357982f, 
    0.06708916f, -0.17065780f, 0.07935058f, 0.14365759f, 0.07655804f, -0.21795486f, -0.20655523f, -0.03475301f, 
    -0.16283925f, -0.14807999f, 0.02198119f, 0.05298582f, 0.05459416f, 0.05610923f, 0.01344864f, -0.02528534f, 
    -0.08081089f, -0.06251325f, 0.06114024f, -0.01483497f, 0.11457243f, -0.05481519f, -0.34041676f, -0.01152390f, 
    -0.11808583f, 0.10657349f, -0.03387632f, 0.07557181f, 0.04989157f, 0.08816428f, -0.04784462f, 0.09367524f, 
    0.04717913f, -0.19308656f, 0.03089258f, 0.11053131f, -0.19324608f, -0.02133688f, -0.18386053f, -0.00764087f, 
    -0.33754030f, -0.36297902f, -0.04316717f, 0.17240001f, -0.09968945f, -0.06664965f, -0.07217105f, 0.15616715f, 
    -0.32868013f, -0.03858806f, -0.07424431f, 0.01552852f, -0.03235874f, 0.02256732f, -0.09265012f, -0.10959110f, 
    0.03212126f, 0.07043469f, -0.12646796f, 0.06803362f, -0.43209201f, -0.37394941f, 0.10369131f, -0.05174408f, 
    -0.05585715f, -0.09500190f, 0.02849546f, -0.18714769f, 0.05828218f, -0.01297290f, -0.00294871f, -0.02124944f, 
    -0.01506497f, 0.19344074f, -0.01988478f, -0.04146656f, 0.04362911f, 0.01669698f, -0.04859979f, -0.10245955f, 
    -0.02971363f, -0.02182262f, 0.05248534f, 0.06174697f, 0.11948483f, -0.08776426f, 0.02068496f, -0.12101984f, 
    -0.14264679f, -0.01931053f, -0.01370522f, 0.00172583f, -0.00646226f, 0.04341108f, 0.00592496f, 0.02233242f, 
    0.02738355f, -0.02376223f, 0.03681032f, 0.12494591f, -0.06207954f, -0.29807198f, 0.21433711f, 0.04501685f, 
    0.00226107f, -0.21026073f, -0.06931504f, 0.03143211f, -0.07093111f, 0.17291865f, -0.07251506f, 0.02330720f, 
    -0.06435125f, -0.02517007f, -0.05019250f, 0.00060995f, 0.01777210f, 0.00529159f, -0.01890456f, 0.03004821f, 
    -0.18030746f, -0.05930567f, -0.06455857f, -0.39762351f, 0.06317307f, -0.10352311f, 0.08939524f, 0.01087915f, 
    -0.00996750f, -0.19780032f, -0.05582201f, -0.05768739f, 0.00422457f, 0.00387418f, 0.00210090f, -0.02002688f, 
    0.00652527f, 0.03325057f, -0.03655392f, -0.05906219f, -0.03136838f, -0.03092336f, -0.04266370f, -0.09801533f, 
    0.00765739f, 0.07903763f, 0.02147779f, 0.05112238f, -0.00573378f, -0.01931720f, 0.02254337f, -0.00424408f, 
    0.06897664f, -0.11863387f, 0.04556068f, 0.12258469f, 0.05417432f, -0.03557141f, -0.08228533f, 0.05011055f, 
    0.11880881f, -0.10807135f, 0.14842071f, -0.11944445f, -0.14157271f, 0.02142431f, 0.00761651f, -0.03096836f, 
    -0.11791630f, -0.13304304f, 0.03048198f, -0.07588480f, -0.00335258f, 0.07613325f, -0.18048313f, 0.02311140f, 
    -0.07801892f, -0.23845798f, -0.17388664f, -0.08815815f, 0.04332335f, -0.01247586f, -0.07475579f, -0.07325064f, 
    -0.06899992f, 0.03184697f, -0.01849060f, -0.00429520f, 0.03095102f, 0.04738313f, 0.00010674f, -0.10954902f, 
    -0.00546448f, -0.05288941f, -0.02437734f, 0.07522123f, 0.04390111f, -0.05341844f, 0.03583759f, 0.02593640f, 
    0.06624027f, -0.02085549f, 0.11200830f, 0.02362072f, 0.02726925f, -0.06413350f, -0.01983634f, -0.04889721f, 
    0.08320279f, -0.01531509f, 0.06225010f, -0.09395143f, -0.00236662f, 0.02257948f, 0.00837946f, 0.03230651f, 
    0.00820209f, 0.03697764f, -0.05139087f, -0.04572300f, 0.05113046f, 0.00098004f, -0.01362694f, 0.01397415f, 
    0.04244982f, 0.10141476f, 0.06756896f, 0.04120746f, 0.00189260f, 0.03894367f, 0.11020213f, 0.10421169f, 
    -0.00902900f, 0.03192771f, 0.10105738f, 0.10946888f, 0.02064380f, 0.00497446f, -0.01294713f, 0.05987463f, 
    -0.01103449f, 0.00838166f, -0.02229846f, 0.01992881f, 0.05033486f, 0.09167109f, 0.08745593f, -0.00414123f, 
    -0.02069024f, 0.06487734f, 0.10722498f, 0.02871730f, 0.01381966f, -0.04326415f, 0.04892730f, -0.03592326f, 
    -0.06305587f, -0.04856954f, -0.01046068f, -0.00083641f, -0.01804242f, 0.08226928f, -0.01627483f, -0.04727263f, 
    0.08685224f, 0.07338462f, 0.06697620f, 0.05312690f, -0.05983200f, 0.07896523f, -0.01896790f, 0.01724635f, 
    0.05243964f, -0.05349280f, -0.00038489f, 0.02355264f, -0.04290375f, -0.11036462f, -0.03172658f, -0.12799390f, 
    0.01886860f, 0.14651231f, 0.23958185f, 0.24327914f, 0.16939501f, -0.00338379f, -0.02990848f, 0.13176546f, 
    -0.02435970f, 0.18373613f, -0.01509764f, -0.05862471f, 0.06293761f, -0.03472122f, 0.00381002f, 0.00284159f, 
    -0.06253594f, -0.08291692f, -0.04542085f, -0.06856476f, 0.12229837f, 0.05890170f, 0.31040534f, -0.60336369f, 
    0.17649119f, 0.08608345f, 0.07457753f, -0.03062190f, 0.06949683f, -0.03164864f, 0.02241585f, 0.00558914f, 
    -0.01118812f, 0.06749543f, -0.05808578f, -0.20165971f, -0.13064757f, -0.18462303f, -0.03771866f, -0.00969885f, 
    0.07363806f, 0.09986120f, -0.21538524f, 0.28281847f, 0.21609975f, 0.07903483f, -0.07073646f, 0.15167299f, 
    -0.17596892f, 0.02808267f, 0.09504509f, -0.00109331f, 0.06444681f, -0.05809904f, 0.03149803f, -0.06267303f, 
    0.07310595f, 0.05539341f, -0.12008046f, -0.02642393f, 0.16400653f, 0.01631238f, 0.19528995f, 0.00935557f, 
    0.17067455f, -0.00508646f, 0.01479693f, 0.00683956f, 0.03853451f, 0.03178326f, -0.07911691f, -0.01785911f, 
    0.02892395f, -0.01160481f, 0.02755044f, 0.01501052f, -0.05686484f, -0.02353724f, -0.09069685f, -0.10048866f, 
    -0.07897887f, -0.00534283f, 0.16107912f, 0.15415506f, -0.01799688f, -0.19929321f, -0.01265535f, -0.23752192f, 
    -0.13652751f, -0.08907707f, 0.06104358f, -0.05546249f, -0.08417792f, -0.00301241f, 0.02472149f, -0.00276443f, 
    0.03664182f, -0.05245179f, -0.07273534f, -0.01469794f, -0.11630237f, -0.06831104f, 0.02205703f, -0.33571443f, 
    -0.21225090f, -0.02101692f, -0.08618773f, -0.00350279f, 0.20407505f, -0.13412631f, 0.02306688f, -0.05073839f, 
    -0.03189067f, -0.10055510f, -0.00193664f, 0.09302747f, 0.03392110f, -0.06253645f, -0.05060162f, -0.02787259f, 
    0.05110073f, 0.04410405f, -0.04868454f, -0.02330495f, 0.01374937f, 0.06988090f, 0.02971202f, -0.00475568f, 
    0.06978933f, 0.11486380f, 0.04612193f, -0.06343266f, -0.08972685f, -0.08911721f, 0.08283268f, 0.05617811f, 
    -0.04735578f, -0.01695177f, 0.04889146f, 0.02099100f, -0.14635843f, 0.02170978f, -0.00713551f, -0.06342360f, 
    -0.15155432f, -0.05524364f, -0.10157908f, 0.08960111f, 0.10642865f, -0.02249708f, -0.01703628f, -0.03785461f, 
    -0.03341998f, 0.01121263f, 0.01625662f, -0.14201294f, -0.20098706f, -0.07494761f, 0.02443582f, -0.19122539f, 
    0.09569471f, 0.22432919f, 0.31561899f, 0.19517010f, 0.17485356f, -0.04056533f, -0.10124180f, -0.00601852f, 
    -0.02171532f, 0.24644063f, 0.02744769f, 0.00025134f, 0.07886414f, 0.01179951f, -0.00980117f, -0.00198515f, 
    -0.06810857f, -0.03716186f, -0.00633849f, -0.16875060f, 0.17393301f, -0.23691928f, 0.12708941f, -0.11050353f, 
    -0.07180206f, 0.10485692f, -0.00844567f, -0.05015906f, -0.01364777f, -0.13144439f, 0.00499985f, -0.11009306f, 
    -0.04105352f, -0.01687948f, -0.10980386f, -0.24640851f, -0.13760941f, -0.24098361f, -0.08924133f, -0.17583622f, 
    -0.00650937f, -0.30229121f, 0.07009210f, -0.28423887f, -0.08734434f, 0.00355800f, 0.00687852f, 0.02440546f, 
    0.15490109f, -0.24425381f, -0.00691790f, -0.03731526f, -0.06317513f, -0.05882937f, -0.06712153f, -0.02932304f, 
    -0.05717339f, -0.07907315f, 0.04765325f, -0.01218565f, 0.06874559f, 0.05825871f, 0.22019099f, 0.06756037f, 
    0.05773924f, -0.04806433f, 0.06992418f, -0.01877932f, 0.08283634f, 0.12810405f, -0.04713877f, 0.01026656f, 
    -0.04559372f, -0.03723776f, -0.01906235f, 0.04960445f, 0.07183063f, -0.23475027f, 0.17962204f, 0.18849280f, 
    -0.04287199f, -0.29262733f, 0.00576680f, -0.04561415f, -0.00631970f, -0.23381868f, -0.12890996f, 0.03068409f, 
    -0.02113601f, 0.13663284f, -0.08607639f, -0.05994650f, -0.08216131f, 0.00149785f, -0.03197951f, -0.05188926f, 
    0.02921961f, -0.02247543f, -0.03602085f, -0.01600797f, -0.03993024f, -0.01707671f, -0.01647845f, -0.16779633f, 
    0.04154448f, 0.09936413f, 0.09993570f, 0.15880115f, -0.09285336f, 0.04712088f, 0.01354372f, 0.02120236f, 
    0.11477619f, -0.06553891f, -0.11052182f, -0.03674531f, -0.00973766f, -0.13995434f, -0.03084173f, -0.06760307f, 
    0.16901205f, -0.10647706f, 0.13446444f, 0.12178881f, -0.00182011f, 0.00140668f, -0.02391016f, 0.00428364f, 
    -0.05529287f, -0.02969258f, 0.03207127f, -0.02334428f, 0.06273806f, 0.01363968f, 0.03475298f, 0.01994726f, 
    -0.08278549f, -0.00536761f, -0.09488072f, -0.04950374f, 0.00468254f, -0.03607994f, -0.11210022f, 0.09776215f, 
    -0.08242522f, 0.08260296f, -0.03115161f, 0.01843382f, -0.08246262f, -0.04502281f, -0.08339855f, 0.15370789f, 
    -0.11755610f, -0.09405275f, -0.01563538f, 0.07811861f, -0.05932349f, 0.01058123f, 0.04544210f, -0.04914388f, 
    -0.05812902f, 0.03302858f, -0.06618414f, -0.26523390f, 0.09149928f, -0.05095580f, 0.04211950f, -0.03244548f, 
    0.06189400f, -0.04655870f, 0.00457509f, -0.00958072f, 0.00211025f, 0.09260479f, 0.00017791f, 0.04090535f, 
    0.13735732f, -0.02876535f, 0.04212743f, 0.20808442f, 0.11402380f, -0.03248464f, 0.05938234f, -0.03825499f, 
    0.02940013f, 0.06956773f, -0.04069017f, 0.03653788f, -0.01429800f, -0.03719034f, -0.07582217f, -0.05878218f, 
    0.02620028f, -0.06427763f, 0.01087199f, 0.06681363f, -0.17567831f, 0.00816654f, -0.09848163f, -0.16535786f, 
    -0.68531185f, -0.12980358f, -0.03120823f, -0.45337936f, -0.07782345f, 0.07504801f, 0.09138789f, -0.06456797f, 
    0.04446812f, 0.11770426f, -0.03558133f, -0.04211249f, 0.03503148f, 0.12877528f, 0.02826365f, -0.08984358f, 
    0.06248964f, -0.04396837f, -0.09616234f, 0.09913433f, 0.02868997f, -0.15246353f, 0.13935070f, 0.06631155f, 
    0.00582962f, 0.04946625f, 0.16482504f, 0.04226152f, -0.12154661f, -0.03591385f, -0.07165753f, -0.02779491f, 
    -0.01977143f, 0.05416280f, -0.05515870f, 0.09500324f, 0.11222801f, -0.02660915f, 0.11313555f, 0.23685555f, 
    -0.14747950f, -0.33779848f, -0.02833203f, -0.41407394f, -0.21275216f, 0.03600577f, 0.08312061f, -0.02139435f, 
    0.05479858f, 0.02166132f, -0.08108445f, -0.03396523f, -0.04123883f, 0.09724801f, 0.04437120f, -0.23239179f, 
    -0.04539753f, -0.05197822f, -0.11193211f, -0.25991833f, 0.12671247f, 0.03604972f, -0.04253258f, -0.03537831f, 
    -0.17038414f, 0.12098689f, 0.02937577f, 0.04589292f, 0.07240106f, 0.08977357f, 0.07401599f, 0.02184101f, 
    0.00598789f, 0.01785820f, -0.01805736f, -0.12068550f, 0.11598777f, 0.06126005f, -0.13691674f, 0.01054159f, 
    0.08706654f, -0.03601728f, 0.13875608f, -0.02527348f, -0.04598416f, 0.03305097f, 0.02583886f, 0.09103338f, 
    -0.20150685f, -0.02010585f, 0.12186709f, -0.22495122f, 0.13372153f, -0.00612893f, -0.08699385f, 0.03552219f, 
    -0.00817335f, -0.06983086f, -0.09277953f, 0.01027627f, 0.13790643f, 0.10093968f, 0.09166961f, -0.13554963f, 
    -0.04481661f, 0.09001278f, 0.07357863f, 0.07302472f, 0.03679832f, 0.10651112f, 0.01932661f, 0.01465691f, 
    -0.02994975f, -0.16729452f, -0.07613811f, 0.02552554f, 0.02927462f, 0.02667795f, -0.01225672f, 0.06594628f, 
    0.08300451f, 0.03154012f, -0.02169013f, -0.14121853f, -0.08213988f, 0.04616515f, -0.02852664f, 0.04041905f, 
    0.11569517f, -0.01008910f, 0.08233605f, 0.06341813f, 0.00299885f, -0.15936665f, -0.00397015f, 0.12859161f, 
    0.03479705f, -0.20406599f, 0.01283404f, 0.16553183f, -0.01904366f, 0.04717720f, 0.25246894f, 0.20173511f, 
    0.13029528f, -0.11070369f, 0.04573947f, 0.01101438f, 0.04679939f, 0.18507056f, 0.03157514f, 0.02172866f, 
    0.06590144f, 0.03020032f, 0.03006903f, -0.01080280f, -0.05088891f, -0.01182157f, 0.02564334f, 0.11541150f, 
    0.16565391f, -0.12784773f, -0.05878464f, -0.02327602f, -0.11687884f, 0.06957448f, 0.02808413f, 0.05369661f, 
    0.00259004f, 0.04378564f, 0.01624688f, 0.03405573f, -0.04391582f, -0.00306981f, -0.03569068f, 0.01849619f, 
    -0.02142370f, 0.01070791f, -0.05810874f, -0.00159082f, 0.02894629f, -0.04664582f, 0.16398773f, 0.10860556f, 
    0.01935377f, 0.01981086f, 0.02572035f, -0.00331691f, -0.19069573f, -0.06728931f, -0.00772200f, -0.06632518f, 
    0.01972330f, -0.13199820f, 0.04924937f, -0.09535456f, -0.14380914f, 0.05706375f, -0.07651352f, -0.04658318f, 
    0.12778442f, -0.01272821f, 0.29207337f, -0.01144221f, 0.07667972f, 0.03228889f, -0.10534873f, -0.07930063f, 
    0.03611966f, 0.01385466f, 0.07902226f, 0.01970197f, 0.01005878f, -0.02302738f, 0.02911764f, 0.00183164f, 
    -0.06942689f, -0.12445445f, -0.09508093f, -0.25038016f, 0.07852923f, 0.04648189f, 0.11862379f, 0.10868524f, 
    0.00736262f, -0.11417225f, -0.01714650f, -0.08531600f, -0.02136208f, -0.10824794f, 0.01121715f, 0.04267179f, 
    -0.25551704f, -0.00738467f, -0.12182616f, 0.03515041f, 0.03994025f, -0.04058385f, 0.02784731f, -0.01356965f, 
    0.19239855f, 0.10272482f, 0.32863462f, -0.00726478f, 0.12380467f, 0.00547540f, -0.04891833f, 0.05608785f, 
    0.08392340f, 0.11916984f, 0.01033297f, 0.03413450f, 0.00019688f, 0.06570136f, -0.00982400f, 0.06225668f, 
    -0.02990628f, -0.10929203f, -0.10382928f, -0.17705654f, -0.02956013f, -0.02602085f, 0.01498758f, 0.09366390f, 
    0.10714875f, -0.12299280f, -0.02344568f, -0.06514642f, -0.15127902f, -0.12514688f, -0.06497863f, 0.02602246f, 
    0.03728746f, -0.00931786f, -0.08316471f, 0.02050332f, 0.06045966f, -0.08855588f, 0.01098915f, 0.08486973f, 
    -0.31386214f, -0.17332122f, -0.03553177f, 0.20619020f, -0.02437745f, 0.03335213f, -0.08914398f, -0.08342765f, 
    0.10578593f, 0.00234199f, -0.08481443f, 0.18147667f, 0.00219681f, 0.06134797f, -0.01398791f, 0.10857558f, 
    -0.01866253f, 0.13781536f, 0.00321550f, 0.21558179f, 0.19570923f, -0.08507592f, 0.05219355f, 0.13771762f, 
    -0.08989866f, -0.05472083f, -0.23430048f, -0.05042541f, -0.06492888f, 0.02369740f, 0.08471508f, 0.05160058f, 
    -0.01454463f, -0.03116611f, -0.01215632f, -0.09360448f, -0.06262523f, -0.20662224f, -0.15072919f, -0.30756432f, 
    0.05864487f, -0.05366081f, -0.04519562f, -0.14789270f, 0.04125947f, 0.02952160f, -0.03868644f, 0.05891047f, 
    0.00932215f, 0.00626569f, -0.00838943f, -0.04392701f, -0.04079636f, 0.01835693f, -0.08434848f, 0.04039666f, 
    0.08175399f, 0.08595742f, -0.01008078f, -0.00167154f, 0.35158548f, 0.08478593f, -0.18858790f, 0.10645303f, 
    -0.02230002f, -0.01102983f, 0.23312360f, 0.11624775f, -0.04996174f, 0.18394962f, -0.00523689f, 0.02105643f, 
    0.09734081f, -0.02606141f, 0.07039028f, 0.28413767f, -0.00845560f, 0.15030532f, -0.18812796f, 0.08323874f, 
    0.37945986f, -0.47455081f, 0.04549400f, 0.22103901f, -0.13741654f, 0.17117567f, -0.11502384f, 0.05335689f, 
    0.13992405f, -0.01659925f, 0.09844376f, -0.00277646f, 0.09628543f, 0.15838608f, 0.07572907f, -0.07778178f, 
    0.05326407f, -0.05493949f, 0.05131091f, -0.24115951f, -0.46846768f, 0.30440545f, -0.16524379f, -0.17113648f, 
    -0.12516285f, 0.01140915f, -0.01611728f, 0.02573550f, -0.01729899f, 0.22014689f, 0.00078629f, 0.02867380f, 
    -0.00186532f, 0.00998577f, -0.04735022f, -0.04233801f, -0.07416595f, 0.03081614f, -0.00138333f, 0.01656698f, 
    0.05332389f, -0.03167539f, 0.04559171f, -0.05384358f, -0.01834120f, -0.18943307f, -0.06291533f, 0.09515052f, 
    -0.01184726f, -0.06285074f, -0.03461163f, -0.08437190f, -0.04772187f, -0.09139317f, 0.00767485f, 0.03173520f, 
    0.08897690f, 0.08244211f, -0.09766341f, 0.14361183f, -0.27949175f, -0.04261224f, -0.17141071f, -0.01701654f, 
    -0.30339167f, 0.14017096f, -0.06860651f, 0.03018099f, -0.05416302f, 0.12917295f, -0.01395811f, -0.10434306f, 
    0.04866571f, 0.01589217f, -0.11453532f, -0.02217103f, 0.02180016f, 0.03171724f, -0.04519339f, -0.01782555f, 
    -0.29234874f, 0.01054204f, -0.01385634f, -0.21502289f, 0.13772099f, 0.10151734f, -0.06949579f, -0.05254481f, 
    -0.15280710f, -0.13699649f, 0.01649835f, -0.07188924f, 0.16332543f, 0.02514446f, -0.01984718f, -0.09738454f, 
    -0.32108054f, -0.33623183f, -0.00690911f, -0.12505697f, -0.04600815f, -0.07243947f, 0.00340106f, -0.20989493f, 
    -0.15771410f, -0.02161752f, -0.01718837f, -0.16492045f, -0.01836363f, 0.36333656f, 0.08366099f, 0.22245687f, 
    -0.07661618f, -0.02330060f, -0.05189165f, -0.01500383f, -0.01270719f, 0.02300687f, -0.01005904f, 0.16744524f, 
    -0.21874095f, -0.20303282f, -0.23071031f, 0.19784755f, -0.01577994f, 0.00344412f, 0.02495927f, -0.07546436f, 
    0.01654270f, 0.00294184f, -0.09750473f, 0.01003362f, 0.06656694f, -0.01798428f, 0.00132165f, 0.05069127f, 
    -0.15238060f, -0.01051875f, 0.04975226f, 0.01461510f, 0.11699127f, -0.12215003f, 0.29485363f, -0.11723510f, 
    -0.18978606f, 0.19845149f, 0.06398917f, -0.16365416f, 0.02071141f, -0.14585175f, 0.09666003f, -0.03027332f, 
    0.05278539f, 0.04121507f, 0.01942544f, 0.04030138f, 0.03216761f, -0.01215437f, 0.16629532f, 0.22929129f, 
    -0.45522273f, 0.61979514f, -0.54437453f, -0.16475099f, 0.04243246f, -0.13328665f, 0.00836206f, 0.02257588f, 
    -0.08487153f, -0.08363705f, 0.09679119f, 0.04135259f, -0.07107181f, 0.08023311f, 0.05156581f, -0.13115458f, 
    -0.02185101f, 0.17330018f, -0.03170884f, -0.08984821f, -0.19070117f, 0.01028447f, 0.15605918f, 0.05667162f, 
    -0.15027270f, 0.10385292f, -0.09737675f, -0.07607844f, -0.07822160f, 0.08541739f, 0.06436389f, 0.00703903f, 
    0.02143447f, 0.06912846f, 0.01085071f, 0.03851678f, -0.00221332f, 0.07725567f, 0.12217067f, -0.00912399f, 
    -0.38048947f, -0.04335698f, -0.04415732f, 0.12516558f, -0.16432099f, 0.06707694f, 0.06329823f, -0.12819341f, 
    0.10708303f, 0.05138137f, 0.01312095f, 0.06792449f, -0.02285211f, -0.03147077f, 0.00805890f, -0.08661803f, 
    0.04304331f, 0.15927958f, -0.04184457f, -0.05942361f, -0.15399250f, 0.00835744f, 0.06261104f, -0.08577691f, 
    -0.18646146f, 0.11675233f, -0.05263786f, -0.01024234f, -0.15456989f, -0.00562995f, -0.00204357f, 0.00335188f, 
    0.02218183f, 0.02157106f, 0.02092507f, -0.00899379f, -0.07031813f, -0.11294013f, -0.08321940f, -0.11279969f, 
    -0.33929214f, 0.40691867f, 0.02197045f, 0.20899461f, 0.00636290f, 0.08736309f, -0.05783956f, -0.02958667f, 
    0.04612084f, -0.05443469f, -0.06286553f, -0.04587571f, -0.04852492f, 0.02168068f, 0.02890598f, -0.17031832f, 
    -0.09708641f, 0.06823166f, -0.14568840f, -0.23127201f, -0.02028983f, -0.02870356f, -0.09969030f, 0.01040924f, 
    0.10829104f, 0.03266416f, -0.01949791f, -0.03058277f, -0.03912035f, 0.04014078f, 0.03131202f, -0.02377533f, 
    -0.00513882f, 0.00552625f, 0.03467091f, -0.17818242f, -0.08168013f, 0.00654340f, 0.01831155f, -0.00279527f, 
    0.19345738f, -0.29662529f, -0.06134709f, 0.16190860f, -0.46331951f, 0.13569784f, -0.06766731f, 0.07246935f, 
    -0.01980246f, 0.12977760f, 0.11155917f, -0.13050327f, 0.01604414f, -0.12763020f, 0.13717164f, -0.06807901f, 
    0.06908886f, 0.10459693f, -0.00385184f, 0.04375960f, 0.29524165f, 0.21797311f, -0.27800459f, 0.07188586f, 
    0.20306197f, -0.02712788f, -0.05035608f, -0.04484057f, -0.11250747f, -0.06155523f, 0.11145609f, -0.09849474f, 
    0.09261492f, 0.04879245f, -0.02912602f, 0.31167111f, -0.19936958f, 0.08424636f, 0.13219090f, -0.16251285f, 
    -0.27468994f, 0.13125089f, 0.14523092f, 0.18254967f, -0.38939944f, 0.05926879f, -0.16041411f, 0.03552278f, 
    0.18962862f, -0.07479128f, -0.03984961f, -0.02926831f, -0.16490145f, -0.13434419f, 0.15950632f, -0.03096828f, 
    -0.08216202f, -0.09495691f, -0.13872069f, 0.07129470f, -0.33820432f, 0.20488602f, -0.33560222f, -0.52558780f, 
    -0.04718563f, -0.06165405f, -0.08143445f, 0.08998486f, -0.06145892f, 0.04575280f, -0.09062500f, 0.15208510f, 
    -0.07049205f, -0.09681063f, 0.00676522f, 0.00052459f, -0.01504134f, 0.15385066f, -0.02220683f, 0.05880756f, 
    0.07502850f, -0.03566868f, 0.03702246f, 0.08476892f, -0.15349373f, 0.07046761f, 0.07173037f, 0.08387196f, 
    0.02780926f, 0.04490109f, 0.02204614f, -0.02054299f, 0.00950412f, -0.02134284f, 0.00233912f, -0.07721171f, 
    0.04609956f, 0.00717610f, 0.02146020f, -0.12317565f, -0.44115236f, 0.09733611f, -0.28343955f, -0.19470498f, 
    -0.21161188f, 0.01290472f, -0.04620817f, -0.00409058f, -0.04069548f, -0.03605489f, 0.00721594f, 0.02831105f, 
    -0.15323459f, 0.10073577f, 0.01358028f, -0.05215862f, -0.03347445f, 0.01181437f, -0.00165433f, 0.03549297f, 
    0.26493675f, -0.04801640f, 0.11005326f, -0.21171308f, 0.03573331f, 0.05918350f, 0.00366187f, -0.15982074f, 
    0.04970835f, 0.20936613f, 0.08876485f, 0.01472977f, 0.05063605f, 0.00322457f, -0.05627520f, -0.06569219f, 
    0.06537160f, 0.01133930f, 0.05331295f, 0.18146330f, 0.06057903f, -0.07207867f, -0.26449075f, -0.03196535f, 
    0.08512247f, 0.07798204f, 0.02956488f, -0.11933001f, -0.04981919f, 0.08177763f, 0.04201028f, -0.00581015f, 
    0.00896650f, -0.03731028f, 0.07298382f, -0.04542241f, 0.02543079f, -0.07339337f, 0.06620307f, 0.00872192f, 
    -0.10024822f, 0.09186614f, 0.02394428f, -0.36646798f, 0.05126465f, -0.00854400f, 0.14099883f, 0.15761574f, 
    -0.07909998f, -0.06476782f, 0.06189651f, -0.06627908f, -0.02098755f, -0.11464777f, -0.03508162f, 0.05929967f, 
    0.04634077f, -0.10181066f, -0.00606966f, -0.09596419f, -0.12669706f, -0.03760132f, -0.18926899f, -0.01228437f, 
    0.03383958f, 0.07166512f, 0.01787541f, -0.09244124f, -0.00206024f, 0.06087491f, 0.00852942f, -0.05077133f, 
    0.03786819f, 0.08112518f, 0.00485356f, -0.03326644f, 0.02573293f, 0.11069908f, 0.00630564f, 0.01001565f, 
    -0.24811703f, 0.06734522f, -0.18228400f, -0.09056505f, -0.07174651f, 0.01708228f, -0.00950007f, 0.02910063f, 
    0.05291463f, 0.26728702f, 0.02807826f, -0.04177697f, -0.03477372f, 0.04826385f, -0.08417368f, -0.05480842f, 
    -0.01643936f, 0.08484697f, -0.03805955f, 0.10320672f, -0.05039647f, -0.04399957f, -0.07170375f, 0.05552762f, 
    0.03879232f, 0.03832592f, 0.03339603f, 0.01816322f, -0.00880494f, -0.01848919f, 0.06582225f, -0.04192378f, 
    -0.00936523f, 0.02317909f, 0.04476233f, 0.03162157f, 0.04130407f, 0.04234392f, -0.03251262f, 0.01172492f, 
    -0.05984140f, -0.13320120f, -0.12428006f, 0.06774327f, 0.02129296f, 0.10302918f, -0.09493181f, -0.03188730f, 
    0.01641280f, 0.00259623f, -0.05733467f, 0.00699716f, 0.01811523f, -0.02486853f, -0.03704467f, 0.06763612f, 
    0.06696880f, 0.14339724f, -0.07011836f, -0.00537668f, 0.11535404f, 0.14288959f, -0.04209876f, -0.12544595f, 
    0.02855421f, -0.08639178f, -0.06071483f, -0.00368038f, -0.06018986f, 0.06847565f, 0.06543980f, 0.09266058f, 
    -0.05690144f, -0.06615014f, -0.04015905f, 0.07758125f, 0.08177028f, -0.02075125f, -0.02266875f, 0.07124292f, 
    0.10510062f, 0.08557039f, 0.26658008f, 0.03885686f, -0.15289262f, 0.04675206f, 0.00415514f, 0.03800207f, 
    -0.09487571f, -0.03829749f, -0.05539150f, -0.03538697f, -0.02585167f, 0.03537774f, 0.02595037f, 0.00504002f, 
    0.02897090f, 0.05069859f, -0.05875122f, -0.02261975f, 0.00292942f, 0.19193532f, 0.05220425f, -0.54582679f, 
    0.19963743f, -0.10151793f, 0.08078886f, -0.07184102f, -0.06850414f, 0.09382570f, 0.13995834f, -0.01382747f, 
    -0.06973299f, -0.07777151f, 0.08489728f, -0.14785951f, -0.00676420f, -0.06516995f, 0.08929447f, 0.00347840f, 
    0.08221874f, 0.12837158f, -0.21795268f, 0.10614111f, 0.09570597f, 0.10265777f, -0.22013220f, 0.07953535f, 
    -0.02355987f, -0.05831894f, -0.06594669f, 0.05197309f, -0.04861877f, -0.02798194f, -0.02448137f, 0.09481373f, 
    -0.10751326f, 0.25704631f, -0.08928509f, -0.19802044f, 0.12138598f, 0.10425522f, 0.20924495f, 0.04953174f, 
    -0.00975541f, 0.06974638f, -0.04380426f, -0.05710195f, 0.00842879f, 0.04217127f, 0.06097139f, 0.01747125f, 
    -0.00160868f, 0.03531061f, -0.03433725f, 0.05228322f, 0.01382723f, 0.03712883f, -0.00990039f, 0.09637182f, 
    -0.37197468f, 0.00291801f, -0.00101153f, -0.29745129f, -0.10342610f, 0.15951143f, -0.04086470f, 0.04003676f, 
    -0.07684500f, -0.27310297f, 0.01882700f, -0.04654855f, 0.07635983f, -0.15283954f, 0.00473630f, -0.02740042f, 
    -0.06691629f, 0.02503253f, -0.03442118f, -0.04371324f, 0.25622681f, -0.30789837f, 0.02066261f, 0.09405615f, 
    0.17775352f, 0.00848426f, -0.00112746f, -0.18833020f, -0.03744695f, 0.01546875f, -0.00729501f, 0.00844601f, 
    -0.04700902f, 0.05981763f, 0.02231405f, -0.10742538f, -0.03903498f, -0.01844289f, 0.17166717f, 0.00117179f, 
    0.01490563f, -0.08564896f, -0.09940460f, 0.05451621f, 0.03761160f, -0.01083125f, 0.00041564f, -0.02670532f, 
    -0.03085686f, 0.01466313f, -0.00916084f, -0.00178720f, -0.03146410f, 0.04611269f, -0.08196677f, -0.02891318f, 
    0.18204936f, 0.11557958f, -0.00420129f, 0.06733823f, 0.17071307f, -0.22378026f, 0.17826585f, 0.08731059f, 
    -0.08523712f, 0.06192732f, -0.03160910f, -0.10222926f, -0.03509898f, 0.21040305f, 0.14982791f, 0.06620879f, 
    -0.04679377f, 0.00644103f, 0.08960896f, 0.23311649f, 0.01029938f, -0.06953885f, 0.10448850f, 0.26175091f, 
    0.02800520f, 0.05225191f, 0.20209613f, 0.02964676f, -0.09836967f, 0.12903059f, 0.08613411f, 0.18209416f, 
    -0.08522615f, -0.09318730f, -0.06896863f, -0.02094989f, -0.00960193f, 0.02260317f, 0.03605466f, 0.00094904f, 
    0.05132380f, 0.01857761f, 0.03924476f, 0.04996334f, 0.10864622f, -0.05384515f, -0.03192489f, -0.22015592f, 
    0.15026033f, 0.02004551f, 0.04911986f, 0.00739747f, -0.13760692f, 0.19853108f, 0.04347571f, -0.05036269f, 
    -0.17648533f, 0.12815210f, 0.25038332f, 0.18664519f, -0.02655874f, 0.07403354f, 0.09239484f, 0.27764112f, 
    0.22204228f, -0.29377764f, 0.23337561f, -0.07628331f, -0.02780265f, 0.04596269f, 0.00396829f, 0.00942148f, 
    0.01176197f, 0.04182539f, 0.09096545f, -0.02405315f, 0.15051366f, -0.13866450f, 0.01860093f, 0.01503719f, 
    -0.12682711f, 0.01478282f, 0.25024569f, -0.03842033f, 0.05331555f, 0.04644075f, 0.27744412f, 0.02154025f, 
    -0.12380818f, -0.04545535f, 0.01765873f, 0.06622955f, 0.06140606f, -0.08042812f, 0.08524799f, 0.02678407f, 
    -0.02508032f, 0.02403725f, 0.01727610f, 0.02563585f, 0.00152808f, -0.12196591f, -0.11518561f, -0.26979071f, 
    -0.37381807f, 0.11881119f, -0.15190920f, -0.00506535f, -0.11397972f, 0.04497954f, -0.08697911f, -0.07185430f, 
    0.05334764f, -0.03438482f, 0.06123761f, 0.04689246f, -0.11021215f, 0.05686630f, -0.00066680f, -0.04692753f, 
    -0.07582727f, 0.06236447f, -0.04294729f, 0.03450703f, 0.34885904f, 0.08047467f, -0.10951162f, -0.33463159f, 
    0.16639403f, 0.00731210f, 0.11529981f, 0.00133590f, -0.07462716f, 0.00955028f, 0.03614366f, 0.01248676f, 
    -0.12825081f, -0.05928833f, -0.02667230f, 0.00182658f, 0.09525061f, -0.09974203f, -0.07686576f, -0.01820439f, 
    -0.00599815f, 0.02179755f, 0.16597085f, -0.30385730f, -0.02523907f, 0.04756151f, 0.03423249f, -0.00170878f, 
    0.00347216f, -0.02128573f, 0.09439594f, 0.04422726f, -0.08872508f, -0.02873209f, -0.05891212f, 0.03697414f, 
    0.08730277f, 0.07941219f, 0.05707587f, 0.02568748f, 0.06110145f, -0.00551091f, 0.08224427f, 0.14106615f, 
    -0.07795863f, -0.08886920f, 0.05015444f, -0.01852418f, -0.08312036f, 0.05240899f, 0.15735428f, -0.20276399f, 
    0.06693378f, 0.00452025f, 0.16145501f, 0.02030948f, 0.06326512f, 0.08703264f, 0.05830488f, -0.02509796f, 
    0.04509887f, -0.00862324f, 0.12380370f, 0.02046647f, 0.18532081f, 0.04900936f, -0.01157423f, -0.10570922f, 
    0.04148831f, -0.00269119f, 0.04050060f, 0.01969261f, 0.09447963f, -0.04225009f, -0.01087913f, -0.18215284f, 
    -0.05171771f, -0.18416889f, -0.00710003f, -0.31293285f, 0.04610389f, -0.05422392f, -0.05916742f, 0.05374238f, 
    0.03496889f, 0.02852833f, -0.10922032f, -0.08364606f, 0.01427722f, -0.07192507f, 0.08118180f, -0.09645405f, 
    -0.02531848f, 0.00850131f, -0.10954043f, 0.13616036f, 0.04396961f, 0.05615625f, 0.02839578f, 0.22926715f, 
    -0.23829783f, 0.02590090f, -0.29289028f, -0.33271435f, 0.12246453f, -0.03154834f, -0.05618858f, 0.00636265f, 
    -0.02471536f, -0.05590253f, -0.10453399f, 0.00468327f, 0.10082971f, -0.10903630f, 0.03514489f, -0.16614622f, 
    -0.12441387f, 0.06115168f, -0.03006239f, -0.10885309f, 0.02085806f, 0.02686800f, 0.38352343f, -0.13194044f, 
    -0.34681273f, -0.07676689f, 0.01472543f, 0.03303813f, 0.02518116f, 0.05666834f, 0.00527230f, -0.01180777f, 
    0.01267450f, -0.01426961f, 0.04558702f, -0.04136842f, 0.01085832f, -0.02112181f, 0.00623296f, -0.17951411f, 
    -0.08242065f, -0.03619690f, -0.31740275f, -0.04677102f, 0.14305063f, -0.12618901f, -0.10297567f, -0.09923620f, 
    -0.14060582f, 0.09580894f, 0.06864406f, 0.14266613f, -0.10484609f, -0.15370829f, 0.10080703f, -0.04229217f, 
    -0.33133823f, 0.12847547f, 0.08782280f, 0.20445985f, 0.09950485f, 0.04595220f, -0.35749903f, -0.15378334f, 
    0.16260284f, -0.04223088f, -0.05969183f, -0.06938305f, -0.07466583f, -0.05979576f, 0.14257497f, 0.00650532f, 
    -0.06902001f, 0.05688001f, -0.00059292f, -0.11620228f, 0.01675154f, -0.01532516f, 0.10937784f, -0.00683265f, 
    0.00229328f, -0.07555266f, -0.14327057f, -0.05921484f, 0.08994751f, 0.01655670f, 0.03945591f, 0.01489426f, 
    -0.06728708f, 0.11556347f, 0.00736343f, 0.02490749f, 0.00901164f, -0.02046391f, -0.04234590f, 0.05798088f, 
    0.08359652f, -0.05394055f, 0.17048208f, -0.00838434f, 0.01085638f, -0.04547479f, -0.06492620f, -0.10909099f, 
    0.05139412f, 0.03405218f, -0.04313865f, -0.01577330f, -0.03802872f, -0.02137309f, -0.11562775f, -0.03721515f, 
    -0.16331170f, 0.03353275f, 0.05942639f, -0.05061724f, 0.07880379f, 0.12998442f, 0.01085684f, -0.05243548f, 
    -0.19674662f, -0.16817608f, -0.14354014f, 0.03632080f, 0.08163373f, 0.06653805f, -0.00874184f, -0.13826202f, 
    -0.02722199f, 0.06074107f, -0.00766650f, -0.05174389f, 0.06840228f, 0.05237514f, 0.08217054f, 0.00237622f, 
    0.00316995f, -0.01868387f, 0.05682603f, 0.01277576f, 0.01751048f, -0.05178197f, 0.27605379f, 0.05489998f, 
    -0.21922703f, 0.31024233f, 0.06942560f, 0.05789643f, -0.05960336f, -0.19040026f, 0.03430903f, 0.00677288f, 
    0.01577059f, 0.05652392f, 0.06655754f, -0.00275412f, 0.03795988f, -0.04554151f, -0.15264815f, -0.05468579f, 
    -0.13014644f, -0.12638895f, -0.13843814f, 0.01382281f, 0.01515565f, -0.07400209f, -0.05294331f, -0.03973975f, 
    -0.08154476f, -0.08790316f, 0.19855936f, 0.02997395f, 0.01357781f, 0.00730174f, -0.08623610f, 0.02567930f, 
    -0.01930763f, -0.08782718f, 0.05723004f, 0.09895549f, 0.03830264f, -0.00104106f, 0.04882723f, 0.19488382f, 
    -0.10178465f, 0.18866545f, -0.08602317f, 0.03850219f, -0.04088895f, -0.15708014f, 0.03955343f, -0.04072122f, 
    0.06291202f, 0.11368444f, 0.00063667f, 0.09424033f, 0.03677369f, 0.03760711f, -0.06595393f, -0.01245699f, 
    0.28555164f, -0.02733994f, 0.14847790f, -0.10028071f, -0.20924991f, 0.12688692f, -0.01333397f, -0.02409673f, 
    -0.14867508f, 0.05827305f, -0.02528043f, -0.04364094f, -0.06183921f, -0.01994413f, -0.01961825f, -0.03044066f, 
    0.07513111f, 0.03246943f, 0.07414754f, 0.15971155f, -0.16624650f, -0.09092250f, -0.21150532f, -0.15534362f, 
    -0.04359942f, -0.07601119f, 0.11208832f, 0.03020801f, -0.07993191f, 0.01332664f, 0.04241084f, -0.04338280f, 
    0.01973854f, -0.06145056f, 0.02537164f, -0.04573931f, -0.02133419f, 0.01425443f, 0.03852623f, 0.02242811f, 
    0.16382809f, 0.03449127f, 0.21698853f, -0.14153576f, -0.08768892f, 0.06519268f, 0.10647117f, -0.06319658f, 
    -0.10536301f, 0.00453337f, 0.09535024f, 0.06623137f, 0.03614828f, 0.00424766f, 0.02868888f, 0.04964920f, 
    0.03447713f, -0.05010400f, 0.15393355f, 0.15784799f, -0.06878630f, 0.03399454f, 0.12621546f, -0.01935616f, 
    -0.08229563f, 0.05350719f, 0.06003022f, 0.06446510f, -0.00564683f, 0.07376482f, 0.02110018f, -0.02084501f, 
    -0.04972380f, 0.10747871f, 0.00706426f, -0.04490366f, -0.05332796f, -0.13902526f, 0.06777458f, -0.07094738f, 
    -0.07363767f, -0.06940678f, -0.09374027f, -0.12246688f, 0.23286533f, -0.07259955f, 0.13751972f, 0.12901863f, 
    -0.00984193f, 0.10506035f, 0.03575699f, 0.02745795f, -0.05531246f, 0.03738087f, 0.06464510f, -0.08162668f, 
    0.00632361f, -0.09659044f, 0.05773749f, -0.05839875f, -0.18722682f, -0.41045475f, -0.68687594f, -0.56532419f, 
    0.28043264f, -0.14023794f, -0.06208137f, 0.04713358f, -0.07654119f, -0.10294450f, -0.00966798f, -0.02554677f, 
    0.00313845f, 0.01806349f, -0.05192556f, 0.05941475f, 0.08732843f, -0.03231575f, 0.16543448f, -0.02759941f, 
    0.01008249f, 0.20695230f, 0.03652798f, -0.05625389f, -0.00012550f, -0.02093588f, -0.00330158f, -0.06508941f, 
    -0.09675521f, -0.04903996f, -0.10067633f, -0.12230954f, -0.11119147f, 0.00867983f, 0.02936599f, 0.05443392f, 
    -0.09212856f, 0.00473675f, -0.12319873f, -0.06565756f, 0.20809872f, -0.03141411f, -0.30249119f, -0.08347707f, 
    0.25462580f, -0.09628526f, 0.03075758f, 0.17036878f, 0.22450693f, -0.07698553f, 0.00250369f, -0.08224736f, 
    -0.05711636f, -0.03611645f, 0.03116380f, -0.02724171f, 0.03261899f, -0.02791537f, 0.08309093f, 0.06830437f, 
    -0.08567757f, 0.20123424f, -0.00375073f, -0.00281430f, 0.07520327f, -0.06329973f, -0.10919196f, 0.01464082f, 
    -0.06754601f, 0.11769222f, 0.15226933f, 0.07203240f, 0.08060964f, 0.04854155f, 0.02899334f, -0.07023031f, 
    0.01651302f, -0.04280566f, 0.12693532f, -0.04060238f, -0.33649883f, 0.20528540f, 0.40055636f, -0.02728617f, 
    0.18004707f, -0.01227203f, -0.04768258f, 0.08906375f, -0.03560722f, 0.16493084f, 0.02108981f, 0.05029402f, 
    -0.01303150f, 0.12084693f, 0.01094375f, 0.00093458f, 0.02119151f, 0.02130285f, -0.00540271f, 0.04410068f, 
    0.15368457f, -0.06757261f, -0.13003360f, 0.01266487f, 0.12992410f, -0.09135668f, -0.09703644f, 0.00528719f, 
    0.07484519f, -0.13596711f, 0.06474929f, 0.01558225f, -0.22101317f, -0.03831675f, 0.00970087f, -0.01591274f, 
    -0.00570836f, 0.07500198f, -0.03268947f, -0.10747915f, -0.58164519f, 0.23549648f, 0.31393737f, 0.09048243f, 
    0.12470347f, -0.24534492f, -0.05772018f, -0.08981881f, 0.04551830f, 0.22034882f, 0.03310227f, 0.02517581f, 
    0.02506782f, 0.01040995f, 0.05059834f, -0.01846862f, -0.03472282f, -0.04305823f, 0.03811644f, -0.03387984f, 
    -0.11336584f, -0.24923068f, -0.05910157f, 0.08115909f, 0.15410055f, 0.11493555f, 0.03179349f, 0.01765840f, 
    0.04566282f, 0.06137138f, -0.01676777f, 0.07777382f, 0.02423140f, 0.14710982f, -0.04955403f, 0.04934825f, 
    0.08350048f, 0.15709566f, -0.10706048f, 0.00189020f, -0.51999241f, 0.56397820f, 0.27827331f, -0.14550315f, 
    0.06154994f, -0.04868001f, -0.07149324f, -0.10140894f, 0.07943998f, 0.06538980f, 0.08291274f, 0.08516795f, 
    -0.04187999f, 0.11142716f, -0.00693438f, 0.01867990f, -0.04021046f, -0.03468131f, -0.03343059f, 0.02300204f, 
    0.01268074f, 0.04332169f, -0.07315022f, -0.11394221f, 0.07515556f, 0.02701637f, 0.03450143f, 0.06465630f, 
    -0.02220744f, 0.07311850f, -0.05412807f, -0.09066392f, -0.04947308f, -0.04305755f, 0.04211207f, -0.04153265f, 
    -0.04298409f, -0.17362332f, 0.01369444f, 0.06512931f, -0.66600144f, -0.62823075f, -0.22158632f, -0.35995951f, 
    -0.14987415f, -0.16568314f, -0.19864486f, -0.21803144f, -0.21165444f, -0.53487903f, -0.02080081f, -0.01337868f, 
    -0.07570234f, 0.00208443f, 0.00572838f, 0.01584550f, -0.00804394f, 0.03228932f, 0.06890506f, 0.03666755f, 
    -0.33227023f, -0.01065398f, 0.24510357f, 0.07033277f, 0.18695967f, -0.03782485f, -0.05107046f, -0.03096694f, 
    0.09482408f, 0.03920028f, -0.01458939f, 0.05921099f, 0.01834720f, 0.03379058f, 0.05074378f, 0.02108120f, 
    0.01049661f, -0.01211185f, 0.02223566f, -0.01108574f, -0.28932610f, -0.29791051f, -0.63738728f, 0.06242716f, 
    -0.23012435f, -0.13502456f, 0.03215893f, -0.03099925f, -0.09299706f, -0.18380372f, 0.00954302f, -0.00456311f, 
    0.00933832f, 0.03367890f, 0.01833791f, -0.08004028f, -0.02936527f, -0.02411238f, 0.02308674f, -0.06941758f, 
    0.06026265f, -0.78145951f, -0.79100388f, -0.22539955f, 0.20004778f, -0.08979004f, 0.18491733f, 0.27268225f, 
    -0.07419769f, -0.20041858f, -0.02819647f, -0.00890585f, -0.00424424f, -0.00058864f, 0.03464158f, -0.07188690f, 
    -0.01148248f, -0.00317916f, 0.10101729f, 0.04391603f, -0.16901116f, -0.45359448f, -0.57994682f, -0.05716490f, 
    0.11788107f, 0.05560332f, -0.14098082f, -0.09523668f, -0.09312331f, 0.06164242f, -0.00405486f, 0.04268789f, 
    0.03603611f, -0.03031529f, -0.16823055f, -0.01376456f, -0.05192497f, 0.09119545f, 0.05039441f, -0.04055546f, 
    -0.18902816f, -0.01077790f, 0.05920643f, -0.14735754f, -0.03722158f, -0.00769487f, 0.00683916f, 0.00838243f, 
    0.01163727f, 0.04106152f, -0.02165270f, -0.06166522f, 0.06425827f, 0.06985781f, 0.02357105f, 0.03538401f, 
    0.03138784f, -0.00677497f, 0.01859846f, 0.01961648f, -0.05796108f, 0.07045745f, 0.02802963f, -0.10506590f, 
    0.06229225f, 0.00449858f, 0.00470094f, 0.02582768f, -0.03864143f, 0.01472828f, -0.04504182f, -0.05980626f, 
    0.01209661f, -0.01750212f, -0.01872808f, 0.06188919f, -0.01051099f, -0.07739390f, 0.01631387f, 0.06812458f, 
    -0.51630884f, -0.10958813f, 0.04725780f, 0.00384879f, -0.36828524f, -0.26377040f, -0.07775734f, -0.21885306f, 
    -0.11484921f, 0.20437859f, -0.11776718f, -0.01448001f, 0.10770132f, -0.02429866f, 0.06688851f, -0.00256611f, 
    -0.00410758f, -0.09617575f, 0.12354646f, -0.05173675f, -0.01708046f, -0.03430680f, 0.25849885f, -0.01445241f, 
    0.00019195f, 0.12661684f, 0.02067859f, -0.01154397f, 0.05026934f, -0.06337953f, -0.00253885f, -0.01569413f, 
    0.02727392f, -0.04917737f, -0.04045719f, -0.07037991f, 0.10134259f, 0.09230755f, -0.02480226f, 0.01098083f, 
    -0.09577048f, -0.16080076f, -0.14767036f, -0.27224809f, 0.20549411f, -0.06298771f, 0.02878195f, -0.07612100f, 
    -0.03798995f, 0.15690987f, -0.06010103f, 0.01087536f, 0.07200690f, 0.08284512f, -0.05421982f, -0.03299242f, 
    0.07096066f, -0.03208795f, 0.14575697f, -0.01256742f, -0.25612181f, 0.39317033f, 0.03244441f, 0.02435107f, 
    0.34333965f, 0.00231485f, -0.03572546f, -0.03928765f, 0.03224459f, -0.08445890f, 0.10938444f, 0.10702057f, 
    0.13765766f, 0.08559556f, 0.04432506f, 0.02303575f, 0.01862895f, -0.00667635f, -0.02116308f, 0.01727659f, 
    -0.44482735f, -0.48497674f, -0.22472790f, -0.01546752f, -0.13225591f, -0.16331856f, -0.02753050f, -0.01688354f, 
    -0.08147405f, -0.08108496f, 0.01372141f, 0.00981798f, 0.03762468f, -0.03204047f, -0.04245765f, -0.02088579f, 
    -0.04091302f, 0.01484589f, 0.10731114f, -0.05415202f, -0.29299963f, 0.11745343f, 0.35221380f, -0.09841672f, 
    0.28451213f, -0.03879622f, -0.10972234f, -0.04036306f, -0.12661676f, 0.20462716f, -0.09896493f, 0.06987173f, 
    0.05430441f, 0.01548571f, -0.12150424f, -0.00190513f, 0.02435210f, -0.01896453f, 0.02640719f, 0.03288996f, 
    0.02428335f, 0.10768580f, -0.02440183f, -0.34440663f, -0.05941867f, -0.20831461f, -0.04947026f, 0.07871538f, 
    0.12995422f, -0.02359662f, 0.08197033f, -0.01020315f, 0.00085120f, 0.01713233f, 0.00572368f, 0.01792657f, 
    0.16232637f, -0.01596338f, 0.08641043f, 0.06789239f, 0.14868741f, 0.02418263f, -0.02154989f, -0.04422420f, 
    -0.03179161f, 0.05100824f, 0.01421648f, 0.04068276f, 0.01282136f, -0.00984275f, 0.01999796f, -0.02703961f, 
    -0.03687218f, -0.10475069f, -0.02343377f, -0.00332792f, -0.00594370f, -0.19407403f, -0.04128469f, 0.03170729f, 
    0.05940511f, 0.28858405f, -0.01537953f, 0.05774168f, -0.17990384f, 0.13202623f, 0.00467243f, 0.02552212f, 
    -0.03177490f, -0.28404146f, -0.05664292f, -0.03613859f, 0.03152711f, 0.06769004f, 0.08263090f, 0.09961524f, 
    -0.00739715f, 0.06469424f, -0.25595224f, -0.02858695f, 0.05016782f, 0.07234889f, 0.04359486f, 0.04766358f, 
    0.03191318f, 0.01064967f, 0.00114654f, -0.06036504f, 0.00817240f, 0.06192124f, -0.02007951f, -0.01859764f, 
    0.04416422f, -0.01735321f, 0.00590673f, -0.00454579f, 0.00427168f, -0.06434891f, -0.05379735f, -0.02615221f, 
    -0.32382217f, 0.33131400f, 0.23452231f, -0.03161260f, 0.14888287f, -0.05235603f, -0.00645814f, -0.05112676f, 
    -0.05912632f, 0.17499165f, -0.06123414f, 0.02581437f, -0.01250689f, 0.03114551f, 0.02517607f, 0.00930567f, 
    -0.06780066f, -0.07317221f, -0.00446276f, 0.01185172f, 0.12024797f, -0.09083756f, -0.09274288f, -0.09449622f, 
    -0.01576310f, -0.03187963f, -0.03867134f, 0.03060409f, -0.02585985f, 0.03933867f, -0.10937030f, -0.09854217f, 
    -0.16463146f, -0.19352229f, -0.07940218f, -0.17768878f, -0.17668749f, -0.07907098f, -0.00540550f, 0.01329506f, 
    0.11983347f, -0.03242663f, -0.13603233f, -0.09390540f, 0.07866977f, -0.01589129f, -0.03685196f, 0.09472852f, 
    -0.00613013f, 0.04342041f, -0.03865952f, -0.02868397f, -0.09401388f, -0.09368029f, 0.01505123f, -0.07372421f, 
    -0.09328893f, -0.11047154f, 0.00698048f, 0.02198351f, 0.17689058f, -0.15766667f, -0.11443578f, 0.02593705f, 
    0.06255658f, 0.03420390f, 0.08216722f, 0.01589319f, -0.06165056f, -0.07435118f, 0.11422558f, -0.00428939f, 
    -0.01116977f, -0.11248518f, 0.06980524f, -0.00248208f, 0.02444563f, -0.03357601f, 0.00723184f, -0.01206535f, 
    -0.55172110f, -0.64161855f, -0.44443259f, 0.02855983f, 0.16407959f, -0.08130828f, 0.10365643f, -0.06171456f, 
    -0.13228004f, -0.34217325f, 0.04965508f, -0.04560135f, -0.01221989f, -0.05863366f, 0.02336532f, 0.00020420f, 
    0.00871600f, 0.06024425f, 0.14159442f, -0.02293623f, -0.28263512f, -0.40145802f, -0.03715558f, 0.13685851f, 
    -0.50181890f, 0.05070511f, 0.04944386f, 0.05019558f, 0.04171295f, -0.09375726f, 0.03206617f, -0.01275954f, 
    -0.02099617f, 0.07961424f, 0.08917765f, 0.12336239f, 0.09258171f, 0.11399873f, -0.15731573f, -0.02148177f, 
    0.25341511f, -0.41537639f, -0.34496582f, -0.16572191f, 0.11369514f, -0.01013546f, 0.06483211f, 0.31665891f, 
    0.09932815f, -0.15777634f, 0.02429004f, -0.02798675f, -0.02707839f, -0.05850040f, 0.01844795f, -0.00303865f, 
    -0.02106651f, 0.14562957f, 0.09050445f, 0.04804699f, -0.45165378f, 0.07287935f, -0.31915247f, -0.04173676f, 
    -0.05465315f, -0.06928796f, 0.12649326f, -0.10783746f, -0.03925057f, -0.13412662f, 0.03756090f, 0.04086771f, 
    -0.04628437f, -0.01014262f, -0.00895475f, -0.00167281f, -0.00114915f, 0.08193818f, -0.11276903f, -0.05921468f, 
    -0.28858379f, 0.11676186f, 0.13783951f, 0.27690437f, 0.20641258f, 0.10679502f, 0.05757758f, 0.06419926f, 
    -0.04270266f, -0.06141314f, -0.00161761f, 0.05459516f, 0.04549575f, 0.00128494f, -0.09443911f, 0.03275384f, 
    -0.01706770f, 0.04961809f, -0.06412432f, 0.01119196f, 0.07736966f, 0.20397414f, -0.21429619f, -0.00810179f, 
    -0.01678528f, 0.06012464f, -0.01723659f, 0.03394947f, 0.03550573f, 0.02731176f, 0.10390084f, 0.04526058f, 
    0.05140699f, -0.01594305f, -0.03191063f, -0.07672793f, 0.10153040f, -0.02483410f, 0.11487041f, 0.15103662f, 
    0.02909091f, 0.06977926f, -0.11023978f, -0.05557230f, -0.00844969f, 0.00606921f, -0.01147621f, -0.04244712f, 
    -0.00322925f, 0.01123704f, -0.21443273f, -0.01733194f, -0.09829621f, -0.06058974f, 0.02029859f, -0.01548085f, 
    -0.01206751f, -0.05044110f, -0.00934734f, -0.00665206f, -0.09633156f, 0.01250881f, -0.10295695f, 0.13188644f, 
    0.08759139f, -0.01472194f, 0.06213416f, -0.03848574f, 0.08115204f, 0.08664350f, 0.02969138f, -0.03447453f, 
    -0.02125835f, 0.12262874f, 0.05612249f, 0.01359053f, -0.00470873f, -0.02379234f, 0.09895802f, 0.02559105f, 
    -0.58939767f, -0.57136637f, -0.29502288f, -0.06311529f, -0.14612931f, -0.23078069f, -0.03164718f, -0.14970316f, 
    -0.06096749f, -0.26038828f, 0.01612658f, -0.02183683f, -0.01954553f, -0.03349811f, -0.01072710f, -0.00015369f, 
    -0.03293529f, 0.09229521f, 0.06515310f, -0.06545858f, 0.07572687f, 0.18633763f, 0.00461568f, -0.02816564f, 
    0.08982681f, 0.10068236f, -0.01417040f, 0.01788191f, 0.06784000f, 0.02403509f, 0.05907820f, 0.04138872f, 
    -0.04786125f, 0.01518191f, 0.09375421f, 0.04303555f, 0.11471611f, -0.04646784f, -0.15685651f, -0.02721322f, 
    -0.09849038f, 0.33718666f, -0.04232595f, -0.02110174f, 0.06538405f, 0.01604890f, 0.03801694f, 0.11356506f, 
    0.10850712f, 0.09783603f, 0.09071705f, -0.03092514f, 0.10406370f, -0.01745691f, 0.05044781f, -0.00335701f, 
    0.12989041f, -0.00442793f, 0.16342798f, 0.07048177f, -0.45828828f, -0.41068095f, -0.71662408f, 0.04760073f, 
    0.01317597f, -0.04318506f, 0.03372028f, -0.07180209f, -0.15561625f, -0.34911802f, 0.00963414f, -0.03445951f, 
    -0.02305130f, 0.04439008f, 0.03273778f, -0.02736314f, -0.01625155f, 0.18297212f, 0.16741893f, 0.13117622f, 
    -0.25381717f, 0.10909561f, 0.27842551f, 0.06172986f, 0.18079682f, -0.05916342f, -0.00035932f, -0.00015189f, 
    -0.14401174f, 0.24604428f, -0.05509018f, 0.01833162f, 0.04304313f, 0.05887571f, -0.09064572f, -0.00907837f, 
    -0.00151960f, -0.03159781f, 0.09348054f, 0.03550924f, 0.28399679f, -0.00045435f, -0.13079681f, -0.04427159f, 
    -0.06276147f, 0.10509247f, 0.02315046f, 0.06382956f, 0.01853066f, -0.17240272f, 0.08525553f, 0.00712420f, 
    -0.08011334f, -0.08728128f, 0.05924084f, -0.01121862f, -0.05220354f, 0.08398949f, -0.11390378f, -0.06305566f, 
    -0.13179724f, 0.12100087f, 0.22899228f, 0.11784494f, -0.09287000f, -0.00478221f, -0.00352212f, -0.05494134f, 
    -0.11214742f, -0.13908447f, -0.10535654f, 0.00714781f, -0.05082238f, 0.04746766f, 0.03632315f, 0.05026887f, 
    -0.02761289f, 0.05810422f, -0.10117117f, -0.08806315f, -0.12636505f, -0.00963695f, 0.10271131f, 0.12598604f, 
    -0.04639335f, 0.00991625f, 0.10547453f, -0.04502352f, 0.00202918f, 0.10868529f, 0.04776517f, 0.07392107f, 
    0.06134906f, -0.02890945f, 0.04175828f, -0.04141248f, 0.05455046f, -0.06260349f, 0.00937539f, -0.05563840f, 
    -0.26236802f, -0.25977787f, 0.11208553f, -0.09036654f, -0.12484824f, -0.02174723f, 0.03499038f, 0.07538716f, 
    0.03482628f, -0.03231383f, 0.05080796f, -0.04205535f, 0.04236876f, 0.03309544f, 0.00440552f, 0.06565302f, 
    0.10162416f, 0.16333450f, 0.10197837f, 0.08184888f, -0.05460843f, 0.09220916f, 0.02184430f, 0.03779876f, 
    0.08234043f, -0.00915849f, 0.01172429f, -0.02948759f, -0.02322976f, 0.01960974f, -0.05902987f, 0.04737329f, 
    -0.03459122f, 0.01882250f, -0.02762916f, 0.01609374f, 0.01463867f, 0.02131495f, -0.09370252f, -0.09643745f, 
    -0.18626411f, 0.03369523f, 0.12150580f, -0.19653496f, 0.34780958f, -0.00982748f, 0.01003271f, -0.02127202f, 
    0.03464949f, -0.05013315f, 0.08501413f, 0.06907763f, 0.13343593f, 0.00022121f, -0.07335322f, -0.01503377f, 
    0.07604326f, 0.08010069f, 0.09219602f, 0.04898167f, -0.30399981f, -0.64092582f, -0.67505318f, 0.09196606f, 
    -0.07420953f, 0.01582080f, 0.12355599f, -0.15249330f, -0.10722744f, -0.21960600f, -0.01894504f, -0.01177037f, 
    -0.04469441f, 0.04463909f, 0.01658480f, 0.03898997f, 0.05990240f, 0.17404895f, 0.24886757f, 0.06451448f, 
    -0.29777050f, 0.06649239f, -0.01364273f, -0.05309552f, 0.26404834f, -0.03647186f, -0.01804054f, 0.01063296f, 
    0.02959926f, -0.07322336f, 0.03974374f, 0.06153684f, -0.02900500f, 0.07525074f, 0.08513511f, 0.13532574f, 
    -0.05905506f, -0.01566854f, -0.04457046f, 0.13808025f, -0.05766291f, -0.12169915f, 0.13381493f, 0.07499570f, 
    -0.05629340f, -0.02191374f, -0.01227343f, 0.06835017f, 0.00943528f, -0.07456875f, -0.01566502f, -0.06376684f, 
    -0.07964555f, 0.00752691f, -0.02664110f, -0.05656850f, -0.02794036f, 0.08972052f, -0.06339973f, 0.00744617f, 
    0.14813285f, 0.27516863f, -0.07229947f, -0.06109333f, -0.02830405f, -0.03257462f, 0.04395244f, -0.11690656f, 
    0.04029892f, 0.06027704f, 0.06851768f, -0.16678424f, 0.06383224f, -0.03364658f, 0.03888180f, 0.04802100f, 
    -0.08890143f, -0.02366566f, 0.05298645f, -0.07347807f, -0.01140859f, 0.04988046f, 0.00934613f, 0.03327801f, 
    0.05747459f, -0.01503418f, -0.00808201f, -0.07717071f, -0.03549831f, 0.06113616f, -0.10159323f, 0.07577382f, 
    0.11223259f, 0.10562982f, -0.03642801f, 0.01486489f, 0.03687402f, -0.00181259f, -0.03692679f, 0.07364039f, 
    0.06669484f, 0.15943387f, -0.08837544f, 0.03811356f, -0.01406155f, 0.01982353f, -0.03352969f, -0.06232490f, 
    0.00347533f, -0.00442263f, -0.02579086f, -0.04355436f, 0.03249939f, -0.08827312f, -0.10952009f, -0.09003829f, 
    0.06159255f, -0.29177541f, 0.02375534f, 0.05572771f, -0.50581825f, -0.37859717f, -0.41267848f, -0.47884622f, 
    0.31573963f, -0.09769940f, -0.12844512f, -0.07447813f, -0.17557296f, -0.23553844f, -0.01201206f, -0.00679713f, 
    -0.05390766f, -0.00406519f, -0.00525147f, -0.01442074f, -0.03393727f, 0.04853662f, 0.21494929f, 0.15546378f, 
    -0.01536094f, -0.08830038f, 0.10005927f, 0.00553396f, -0.08356385f, -0.00655995f, 0.08696883f, 0.00735555f, 
    -0.04561242f, 0.01262825f, 0.00498342f, -0.03522656f, -0.02713022f, 0.03443319f, -0.09898890f, -0.04814852f, 
    -0.01457301f, 0.03033089f, -0.01300474f, -0.00915468f, -0.11349744f, -0.11917786f, 0.35587606f, 0.20049584f, 
    0.20754303f, 0.03751520f, -0.00300506f, 0.00973615f, -0.09499972f, 0.06302338f, 0.02909642f, 0.02937631f, 
    -0.00130415f, 0.02766739f, -0.02662733f, -0.03699566f, -0.00448886f, 0.03334927f, -0.01001432f, -0.02013396f, 
    -0.11738300f, 0.06773176f, -0.11904621f, -0.15031426f, 0.00335893f, -0.06788640f, 0.03207488f, -0.19247714f, 
    -0.10114048f, -0.09384184f, 0.01083324f, -0.07781672f, -0.05835072f, -0.02541777f, 0.05301341f, -0.04024586f, 
    0.01760137f, 0.08317375f, -0.00224910f, -0.21767691f, -0.35661808f, 0.29466590f, 0.23478879f, -0.04636129f, 
    0.18600793f, -0.06367133f, -0.03773613f, -0.00308589f, 0.05518953f, 0.15777364f, -0.02604303f, 0.02160628f, 
    0.08400472f, -0.01710355f, 0.05947302f, 0.02204116f, 0.02398823f, -0.05758705f, -0.00510209f, 0.02112856f, 
    -0.74990445f, -0.40657821f, -0.44044510f, -0.14620888f, -0.37346321f, -0.07589671f, -0.00193282f, -0.19500127f, 
    -0.05299065f, -0.41738415f, 0.05159966f, -0.02590252f, -0.05899969f, 0.03781259f, -0.00724150f, -0.04084902f, 
    0.00331128f, 0.09560521f, -0.12969546f, -0.02677237f, -0.22674459f, -0.48233747f, -0.22688970f, -0.03197667f, 
    -0.07548891f, -0.05151508f, -0.08770928f, -0.04059627f, -0.04003246f, -0.06049510f, 0.00851052f, 0.00326352f, 
    0.02764470f, -0.00345658f, -0.11008558f, -0.02946034f, 0.01291453f, 0.09761894f, 0.05607350f, -0.02050718f, 
    0.18232353f, 0.18765777f, -0.23733528f, 0.04848303f, -0.25248620f, 0.01824958f, 0.08496821f, 0.15899996f, 
    -0.14368217f, -0.08834308f, -0.22362240f, 0.06577903f, 0.10463849f, 0.05633757f, -0.06275367f, -0.04989822f, 
    -0.15929273f, 0.05765131f, -0.08347050f, -0.10193785f, -0.20128614f, -0.29832420f, -0.43285093f, 0.03646798f, 
    -0.12643704f, 0.17365208f, 0.06507888f, -0.08176510f, -0.00477835f, 0.02163482f, -0.00171767f, -0.00032420f, 
    -0.09621323f, -0.03058346f, -0.08126617f, -0.09911385f, 0.08501246f, 0.06112994f, 0.08942736f, 0.07207932f, 
    -0.14222020f, -0.07461387f, 0.04685241f, -0.01113808f, 0.06265900f, 0.02568196f, 0.01520114f, 0.02433777f, 
    0.03823670f, 0.01025578f, -0.16824909f, 0.05473716f, 0.09242527f, 0.06354942f, 0.02017723f, 0.02172293f, 
    0.02153704f, 0.00010890f, -0.02962181f, -0.02421767f, -0.14334849f, 0.12939447f, -0.18131664f, 0.09231639f, 
    -0.15238592f, 0.04706578f, 0.03283588f, 0.00648326f, -0.08574764f, -0.08398616f, 0.08827078f, -0.00205560f, 
    0.02340060f, -0.01752825f, 0.01379190f, 0.01935740f, -0.15286747f, -0.01393205f, -0.02154872f, 0.09136394f, 
    -0.00656318f, 0.13214558f, -0.07636300f, -0.01088891f, -0.12684721f, -0.03213146f, -0.08889063f, 0.03426013f, 
    -0.05386036f, 0.09088022f, -0.03001794f, 0.04686353f, -0.02108313f, -0.05723454f, 0.01798793f, -0.00703518f, 
    -0.06417500f, 0.01865472f, -0.00236097f, -0.03174944f, 0.53596622f, -0.24350770f, -0.30626243f, -0.14060307f, 
    -0.18408978f, -0.12905864f, -0.08056226f, -0.10960534f, -0.01230664f, -0.20214690f, -0.04304115f, -0.04215428f, 
    -0.00611832f, -0.00782126f, -0.03294392f, 0.00437664f, 0.03565997f, -0.04687285f, 0.00418644f, -0.01733503f, 
    -0.13806000f, -0.06741314f, 0.03885956f, 0.09342114f, -0.04977882f, 0.00627479f, 0.04854417f, 0.04578445f, 
    0.01196263f, 0.05087301f, 0.02857915f, -0.00428361f, -0.01530155f, -0.00521236f, -0.06027522f, 0.02082979f, 
    0.02450646f, -0.09964184f, 0.02857454f, 0.05083931f, 0.55736691f, -0.44571888f, -0.30816954f, -0.21111520f, 
    -0.36122754f, 0.09662537f, -0.12638153f, 0.00020574f, 0.13369739f, -0.06034401f, -0.00911878f, -0.01673744f, 
    0.06431830f, 0.00763418f, 0.00895380f, 0.03141718f, -0.00892965f, 0.03850436f, 0.04095118f, 0.01613325f, 
    -0.02037927f, -0.28645310f, 0.51251793f, -0.38881755f, 0.23877561f, 0.04787534f, -0.05302811f, 0.17753693f, 
    0.15781879f, 0.00317064f, 0.02852146f, -0.05464210f, 0.00325189f, -0.04295677f, -0.01335360f, -0.15305486f, 
    -0.13980922f, -0.00303573f, 0.03152438f, 0.02385171f, 0.24412027f, -0.59432602f, -0.00702575f, -0.30936888f, 
    -0.08137546f, -0.09598611f, -0.02039966f, 0.01945012f, 0.14123537f, -0.24454778f, -0.03073032f, 0.02072226f, 
    0.02738657f, 0.03584323f, 0.07546856f, -0.00652940f, -0.01857690f, 0.02168538f, 0.01871476f, 0.00349141f, 
    -0.01123291f, 0.08842795f, 0.01251047f, 0.00572021f, -0.09036347f, -0.01383969f, 0.00815013f, -0.00121249f, 
    -0.05824775f, -0.05544264f, 0.04002992f, 0.02672984f, 0.03010922f, -0.02247773f, -0.03527033f, -0.25685623f, 
    -0.24615121f, 0.09000307f, 0.01512843f, 0.04136436f, 0.33761322f, -0.43801194f, 0.20179926f, 0.11737449f, 
    -0.02096928f, 0.05264990f, 0.18668614f, -0.00496653f, 0.06629476f, 0.11434467f, 0.02831657f, -0.01482100f, 
    0.02875464f, -0.05506208f, -0.02284609f, 0.02829702f, 0.01207455f, -0.01724078f, 0.10002832f, 0.01406987f, 
    0.49004912f, -0.01731836f, -0.17152371f, -0.14105161f, -0.13673194f, 0.05923352f, -0.02068478f, -0.00342531f, 
    0.01658742f, 0.03192901f, 0.04359456f, -0.00984168f, -0.02645390f, -0.06674131f, -0.11280282f, 0.05286492f, 
    0.03494985f, -0.03633427f, 0.04835238f, 0.02875323f, -0.08201678f, -0.24169041f, 0.09113996f, -0.33968011f, 
    -0.00054781f, 0.10477431f, 0.00010176f, 0.15774833f, 0.18120907f, 0.03606381f, -0.02398812f, 0.02771208f, 
    -0.01300342f, -0.11223327f, -0.07037377f, 0.01834137f, -0.05451444f, 0.05981499f, 0.02332275f, -0.06069758f, 
    -0.31815597f, 0.11560714f, -0.05950307f, 0.02757217f, -0.11289723f, 0.06705043f, -0.01215640f, -0.16086249f, 
    -0.18289573f, -0.01536461f, 0.06026334f, 0.02121224f, 0.04726539f, 0.00655436f, 0.01343614f, 0.07579627f, 
    0.02257235f, -0.11690108f, -0.05254377f, -0.00953302f, 0.23870558f, -0.34816656f, -0.08802739f, -0.35128373f, 
    -0.14334646f, 0.01271262f, 0.00524315f, -0.12424418f, 0.22107325f, 0.01587112f, 0.01090302f, 0.03798382f, 
    -0.04382061f, -0.05482119f, 0.02409314f, -0.04788960f, -0.00265251f, -0.09751184f, 0.04685090f, -0.05534216f, 
    0.00608393f, 0.14175189f, -0.03883069f, 0.12170734f, -0.31507483f, 0.00907369f, 0.09595146f, -0.03093677f, 
    0.00815417f, 0.01375210f, -0.11543354f, 0.02656728f, -0.02621863f, -0.00580219f, -0.02499166f, -0.04183538f, 
    0.01606608f, -0.08078544f, -0.00165139f, 0.10654660f, -0.02489907f, 0.02684086f, -0.06966998f, 0.00662002f, 
    -0.06525600f, 0.04596742f, 0.04937286f, 0.04042403f, -0.02425093f, -0.04378443f, 0.00960090f, -0.00600506f, 
    0.04251130f, 0.01292231f, -0.02536403f, -0.11900458f, -0.12338686f, -0.07683090f, -0.06435975f, 0.00112676f, 
    0.50181043f, -0.24608032f, -0.22418910f, 0.01936802f, -0.06688695f, 0.12234345f, -0.01526107f, -0.12976153f, 
    0.14237396f, -0.10560442f, 0.12447769f, 0.10958432f, 0.04765575f, -0.02209136f, 0.04613907f, 0.00694354f, 
    -0.03034565f, 0.02015788f, 0.06011982f, -0.08682386f, -0.01579850f, 0.18168691f, 0.06829631f, -0.01431990f, 
    -0.04324807f, -0.02959593f, -0.02778362f, 0.08173173f, -0.07272657f, -0.11495987f, 0.04145966f, -0.05601374f, 
    0.08037418f, -0.07239592f, -0.06365072f, -0.07866853f, -0.29163080f, 0.15965278f, -0.23531628f, 0.04367692f, 
    0.26777095f, -0.27810234f, -0.33943883f, 0.13221985f, -0.24454285f, -0.09004556f, -0.03507666f, -0.11867589f, 
    0.03996231f, 0.08965017f, -0.03046740f, 0.05525045f, -0.10292049f, -0.06247913f, -0.16824929f, -0.01672029f, 
    0.01664070f, -0.05298597f, 0.09219406f, 0.10340258f, -0.25540525f, -0.18981823f, 0.32193577f, 0.00121118f, 
    0.15318321f, 0.03869614f, -0.01726856f, 0.13197522f, 0.01624553f, 0.02697706f, -0.07417503f, 0.07933474f, 
    -0.00925785f, 0.05929487f, 0.02523382f, 0.00325725f, 0.02026418f, -0.00869367f, 0.05174177f, 0.06758379f, 
    0.23118602f, -0.28500465f, -0.29329407f, -0.27094108f, -0.09849568f, 0.02706587f, -0.01421516f, -0.02832768f, 
    0.09957217f, 0.06661341f, 0.01480117f, -0.00836057f, -0.00064755f, -0.05499130f, -0.00644741f, -0.08016427f, 
    -0.01708418f, -0.02344338f, -0.03791165f, -0.05625676f, 0.40614599f, -0.30716741f, -0.57304639f, -0.17718367f, 
    -0.19386654f, 0.14270554f, -0.03253167f, -0.14921241f, 0.10938120f, -0.02323489f, -0.01791932f, 0.04198291f, 
    -0.02848775f, -0.03874968f, 0.08288258f, 0.00349701f, 0.04562765f, 0.00067158f, 0.05672849f, 0.06952538f, 
    -0.38460529f, 0.16861585f, -0.09813529f, 0.13261950f, 0.24060655f, 0.20012242f, 0.00867385f, 0.06630626f, 
    -0.13503401f, -0.06475862f, -0.00705582f, 0.04685783f, -0.03394514f, 0.03160139f, 0.02123975f, 0.08243610f, 
    0.08984111f, 0.12942272f, -0.07318883f, -0.00322102f, 0.01495624f, 0.02465967f, 0.00418432f, -0.03373517f, 
    -0.03061269f, -0.00725690f, -0.01118374f, 0.01439162f, -0.02801933f, -0.01678746f, 0.04990276f, -0.04685086f, 
    0.00032767f, -0.03634184f, -0.00988751f, 0.03911959f, -0.10078330f, 0.00117901f, -0.00257253f, -0.01120966f, 
    -0.30144653f, -0.16247340f, 0.29603204f, -0.25781876f, 0.31393009f, -0.17190871f, 0.08704796f, 0.05486622f, 
    0.00732593f, 0.05850222f, 0.01792528f, -0.02668295f, 0.00864158f, 0.05542160f, -0.05410258f, -0.07341675f, 
    0.02264779f, 0.04644223f, -0.00917005f, -0.03343140f, 0.05627323f, 0.07260409f, 0.04324948f, -0.06640964f, 
    -0.04679480f, -0.00329927f, 0.03155915f, -0.03368200f, -0.04288651f, -0.07056707f, -0.02778092f, -0.08577844f, 
    -0.07989005f, -0.15621805f, -0.07540812f, -0.00504691f, -0.04804501f, -0.01490229f, 0.01674666f, -0.00500613f, 
    0.30743730f, -0.06275035f, -0.19557193f, -0.17507084f, -0.15859418f, 0.02535173f, -0.08894875f, -0.02117586f, 
    -0.04403982f, -0.06447724f, -0.04321233f, -0.00661296f, 0.00557201f, 0.04338321f, -0.01008260f, 0.03947865f, 
    -0.00194496f, 0.05287469f, -0.00051289f, -0.00479589f, -0.00083357f, 0.08552600f, 0.03239695f, -0.00882689f, 
    -0.07869636f, 0.01364935f, 0.02043019f, -0.02490615f, -0.02161830f, -0.05197122f, 0.01793424f, -0.00433578f, 
    0.00196487f, -0.01553295f, -0.04455069f, -0.00364013f, -0.08187961f, 0.00869147f, 0.01900994f, 0.03701188f, 
    -0.02147279f, 0.00768974f, -0.03946467f, 0.02481746f, -0.09232559f, 0.04020165f, 0.02721659f, 0.02227666f, 
    -0.03685023f, -0.04307423f, 0.01578879f, 0.04398470f, 0.01826257f, 0.03718149f, -0.00376839f, -0.05098015f, 
    -0.03118927f, 0.04180254f, -0.01986632f, 0.01003799f, -0.09064776f, -0.06797466f, 0.02332268f, 0.04897839f, 
    -0.03106331f, 0.05819488f, 0.00034749f, 0.06265763f, -0.00306730f, 0.03157168f, 0.01421584f, -0.01939786f, 
    0.05727216f, -0.03610379f, 0.00368937f, -0.00456464f, 0.07093739f, -0.12033099f, 0.04063524f, -0.00519834f, 
    -0.26560149f, -0.35166964f, -0.23062439f, 0.32522619f, 0.08911224f, -0.00545359f, 0.04005047f, 0.01521019f, 
    -0.05171293f, 0.15647633f, 0.02207021f, -0.03395017f, 0.00028812f, -0.05521045f, 0.01168837f, 0.02919695f, 
    0.03386689f, -0.07748225f, 0.00151173f, -0.12233402f, 0.19017169f, -0.22252657f, 0.38320723f, -0.25907618f, 
    0.28907084f, 0.08601547f, 0.02985844f, 0.16247201f, -0.02174632f, -0.04566638f, 0.01400353f, -0.03753953f, 
    0.02717074f, 0.05667447f, -0.10956182f, 0.10600546f, -0.09107991f, -0.01870277f, -0.22700194f, -0.20713393f, 
    -0.14943381f, 0.08846039f, -0.05702354f, -0.02172704f, -0.16675533f, 0.02423000f, 0.04879887f, -0.08476096f, 
    0.00622819f, 0.01714579f, 0.03213434f, 0.03013181f, 0.03113176f, 0.03203913f, -0.01931769f, 0.01608917f, 
    -0.00953365f, 0.01556377f, -0.03478039f, 0.01001417f, -0.43500230f, -0.31650403f, 0.14410765f, -0.20962293f, 
    0.13362662f, -0.03084376f, -0.00120861f, 0.10664117f, 0.05722118f, -0.04312305f, -0.01572584f, -0.00371052f, 
    0.00063764f, -0.04006897f, -0.02587190f, 0.01546800f, 0.01221448f, -0.01365899f, -0.11397076f, 0.04884645f, 
    -0.37796476f, -0.50097781f, -0.14496303f, -0.18190743f, -0.00308419f, -0.00488469f, 0.08894352f, 0.07094531f, 
    0.13732076f, -0.07248173f, -0.01325586f, 0.03578123f, 0.03708773f, 0.06787226f, -0.02265679f, -0.06630270f, 
    -0.01568105f, -0.03510785f, 0.05458925f, 0.02907475f, 0.02793030f, -0.02203098f, 0.03913788f, 0.00079203f, 
    0.02533275f, -0.01996092f, 0.09101415f, 0.09925845f, -0.07035603f, -0.07850742f, -0.02580846f, 0.03231928f, 
    0.02514852f, -0.03148494f, 0.03671400f, -0.05805928f, -0.00137703f, -0.06048184f, 0.03021936f, 0.01224298f, 
    0.03051187f, 0.09094965f, -0.05238384f, 0.02026341f, -0.13789496f, -0.00642843f, 0.03594121f, 0.02378245f, 
    0.00044107f, -0.01981009f, -0.04115630f, -0.09639200f, -0.03509275f, -0.07335801f, -0.05402094f, 0.01937257f, 
    -0.05830781f, 0.02212297f, -0.01305479f, -0.01192854f, 0.15271889f, 0.00111005f, -0.08010327f, -0.02388800f, 
    0.02735880f, -0.06384948f, 0.08680396f, -0.04167255f, -0.05229438f, -0.12806077f, -0.06578512f, -0.07025503f, 
    0.04489108f, -0.03343120f, -0.04486053f, 0.01911683f, -0.02310422f, 0.02557687f, -0.10971523f, -0.04402679f, 
    -0.09395905f, -0.28632757f, -0.26552272f, 0.12420119f, 0.02225373f, 0.07056035f, 0.06637297f, 0.00213454f, 
    -0.01650586f, 0.15488270f, 0.04503691f, -0.01581169f, 0.04111879f, -0.00633588f, 0.01023889f, -0.00227126f, 
    0.02774304f, -0.02898068f, -0.09023130f, -0.11582004f, -0.02694342f, -0.13976729f, 0.17967010f, -0.15408699f, 
    0.18905228f, 0.01967279f, -0.00520778f, 0.10351712f, -0.06044568f, 0.00452367f, 0.09859096f, -0.06904782f, 
    -0.06124526f, -0.06174790f, -0.03205304f, -0.05378228f, -0.06132546f, -0.13094778f, 0.01702001f, -0.04693608f, 
    0.04059876f, -0.41547936f, 0.07745491f, -0.16970883f, 0.19855839f, 0.04589077f, 0.05065031f, 0.10789263f, 
    -0.17329985f, -0.03398812f, -0.08033164f, 0.02685615f, -0.04783234f, 0.07170875f, -0.05432009f, 0.06935417f, 
    -0.02819712f, -0.03533163f, -0.03974686f, -0.04285102f, -0.47556105f, -0.47161832f, 0.30286947f, 0.26274535f, 
    0.11606206f, -0.02901290f, 0.12408052f, -0.04136664f, 0.10013410f, 0.18030480f, -0.01478349f, -0.04494879f, 
    -0.07198673f, -0.07234754f, -0.07043441f, -0.01825896f, 0.04669812f, -0.00517223f, 0.02176143f, -0.07224492f, 
    0.40265432f, 0.06701429f, -0.46720263f, -0.16229349f, -0.27655491f, 0.16322748f, 0.01162982f, -0.14258055f, 
    -0.06259013f, 0.05733748f, -0.01798328f, 0.05604291f, -0.00873782f, -0.07039607f, 0.02361256f, 0.02460746f, 
    0.03946757f, 0.00971082f, 0.03181563f, 0.00403311f, -0.13880651f, -0.06079508f, 0.09528428f, -0.01638519f, 
    0.03344966f, 0.02499032f, -0.06284656f, 0.00224168f, 0.00190254f, 0.07113919f, 0.04695183f, -0.02208339f, 
    0.04896920f, -0.00983089f, 0.00932952f, 0.03396273f, -0.04205025f, -0.08010538f, 0.06511825f, -0.02973832f, 
    -0.16984223f, -0.03718617f, 0.09557962f, -0.11359994f, 0.04393661f, 0.02532368f, 0.03179872f, 0.00918818f, 
    0.02625571f, 0.01774644f, -0.03678768f, -0.01928277f, 0.05398024f, 0.03620359f, 0.00946344f, -0.02118118f, 
    0.02645766f, -0.02237246f, -0.00871983f, -0.01188447f, 0.04690487f, -0.04042603f, 0.05500011f, -0.07817934f, 
    0.01274978f, 0.03644962f, 0.06491359f, -0.07802302f, 0.02205081f, -0.00505046f, 0.00978958f, 0.08190987f, 
    -0.04369096f, -0.08614218f, 0.06500208f, -0.00411040f, 0.00933015f, 0.02570996f, -0.00710670f, -0.09115432f, 
    -0.14814533f, -0.08748466f, 0.17073180f, 0.03543452f, 0.17535873f, 0.00663083f, -0.03077744f, 0.10062630f, 
    -0.11537258f, -0.01811846f, -0.01248845f, 0.00153934f, 0.00533258f, 0.05323765f, -0.03278288f, 0.12574475f, 
    0.03651572f, 0.01800803f, -0.02566750f, -0.02878519f, -0.06950856f, 0.04695742f, 0.05819584f, 0.03085080f, 
    -0.02999090f, -0.08210056f, 0.07604355f, 0.01848774f, 0.01257584f, -0.03509473f, -0.07117663f, -0.08467554f, 
    0.00908538f, -0.07221954f, -0.06941880f, -0.00619490f, -0.04444389f, 0.06060404f, -0.13821909f, -0.00120814f, 
    -0.16407168f, -0.10020909f, -0.31401923f, 0.17926729f, -0.01496190f, 0.04575691f, 0.04386011f, 0.16616325f, 
    -0.02467399f, 0.02816650f, -0.07464014f, 0.08903822f, -0.07630076f, 0.09111885f, 0.05268068f, -0.01674790f, 
    -0.05577980f, -0.00678927f, 0.08335549f, 0.18651919f, -0.20302513f, -0.47641921f, 0.40088260f, 0.15552855f, 
    0.32405719f, -0.04658524f, 0.04673679f, -0.20454268f, 0.19085646f, 0.06941866f, -0.03152126f, 0.00378246f, 
    -0.08705129f, -0.01504959f, -0.04892901f, 0.10049707f, 0.08472706f, -0.05984578f, 0.10049143f, 0.09727088f, 
    -0.08712823f, -0.12032035f, 0.18767053f, 0.01473744f, 0.08080924f, 0.07704712f, 0.08358844f, 0.18320675f, 
    -0.04478287f, -0.03101786f, -0.08330045f, 0.03300581f, 0.00305860f, 0.00271440f, 0.01356781f, -0.14321250f, 
    0.00382536f, -0.14983398f, -0.11746602f, 0.09055910f, 0.01128761f, 0.09712210f, 0.04348601f, 0.04745037f, 
    -0.04435266f, 0.00837854f, -0.00632097f, 0.01118357f, -0.03036562f, -0.05588270f, 0.07215681f, -0.03051797f, 
    0.05034221f, -0.02814393f, -0.04283776f, -0.02650920f, -0.01209791f, 0.01311728f, -0.03194971f, 0.01007130f, 
    -0.05642467f, -0.08333682f, -0.07937086f, -0.05241837f, 0.03043444f, 0.00291453f, -0.02689385f, 0.08179131f, 
    0.03069905f, 0.09153750f, -0.16746958f, 0.13172622f, 0.13330393f, 0.08667113f, 0.04450952f, 0.08833365f, 
    0.01873400f, 0.03111136f, -0.00187372f, -0.03588288f, 0.04192085f, 0.07139805f, 0.01516943f, -0.01147792f, 
    -0.10808116f, 0.02243139f, 0.00516670f, 0.01025874f, 0.01403906f, 0.00113149f, -0.05840138f, -0.09532871f, 
    -0.13808493f, -0.19766928f, -0.15526861f, 0.05067050f, -0.01093932f, -0.04379951f, 0.02792927f, 0.01967830f, 
    0.05129666f, 0.02134592f, 0.04212974f, -0.02690418f, -0.03194821f, -0.01042293f, 0.02661742f, 0.00338370f, 
    -0.00465650f, -0.02224112f, 0.10954298f, 0.00687943f, 0.00830569f, -0.04979879f, 0.04593249f, 0.08923124f, 
    -0.07829122f, -0.03134897f, 0.03924785f, 0.01910691f, -0.04314029f, -0.25143731f, -0.17067982f, 0.25969970f, 
    -0.05588358f, 0.09355517f, 0.00791403f, -0.03651480f, 0.08560433f, 0.14989820f, 0.01580170f, -0.02739212f, 
    -0.01381143f, -0.08912916f, -0.08135248f, -0.03515260f, -0.01535815f, -0.04512338f, 0.09916588f, -0.04632747f, 
    0.02929899f, 0.07670036f, 0.01892073f, -0.03639144f, 0.02427327f, 0.02070946f, -0.03160674f, -0.02562429f, 
    0.03841407f, -0.06852163f, -0.02686749f, -0.01034383f, 0.02636210f, -0.04401832f, -0.04540128f, -0.08528627f, 
    0.00325452f, -0.00907492f, -0.02546065f, -0.00553213f, 0.04995856f, -0.33451959f, -0.28863236f, -0.33541900f, 
    -0.16395712f, 0.10479646f, -0.08875080f, 0.05859865f, 0.04246843f, -0.00587443f, 0.00182569f, 0.00880975f, 
    0.02600187f, -0.10944369f, -0.08411663f, -0.03997441f, -0.06882267f, 0.05435957f, -0.06521250f, -0.04295982f, 
    -0.29352105f, -0.32543236f, -0.07201055f, 0.21737657f, 0.19204104f, 0.12796228f, 0.00137783f, 0.07045728f, 
    -0.04578376f, -0.02146406f, 0.01832499f, 0.05337832f, 0.01219832f, 0.03548767f, 0.03575950f, 0.01374932f, 
    0.03872147f, -0.00707620f, -0.06893146f, -0.12436903f, 0.28286687f, -0.46190485f, -0.34420824f, -0.17309707f, 
    -0.03381095f, -0.00815336f, -0.13728209f, -0.00841421f, 0.12784062f, -0.07633057f, 0.01337423f, 0.04902693f, 
    -0.05903766f, 0.00289018f, 0.05563786f, 0.03206352f, -0.01298691f, -0.03425233f, 0.04297506f, 0.00339970f, 
    -0.89432597f, -0.63314444f, 0.61583292f, -0.20739114f, 0.27896380f, -0.16145848f, 0.05792086f, 0.08159785f, 
    0.01180567f, -0.01789103f, -0.02375491f, -0.01466331f, 0.02795812f, -0.00201450f, 0.03183993f, 0.01944377f, 
    -0.01588547f, -0.06778222f, -0.02301535f, -0.02668146f, 0.08710930f, -0.40007907f, -0.07411081f, -0.37827015f, 
    -0.01913520f, -0.07378478f, 0.00890771f, -0.00360204f, 0.16034886f, -0.02023562f, -0.01172970f, 0.00895211f, 
    -0.04163012f, -0.06018292f, 0.03016644f, -0.00857982f, -0.03700893f, -0.13694009f, 0.06945951f, -0.03559378f, 
    0.31342664f, 0.13558392f, -0.08098160f, -0.05238282f, -0.15047540f, -0.04274049f, 0.17308360f, 0.05980090f, 
    0.06289071f, -0.10711241f, 0.08248120f, 0.01618306f, 0.02496933f, 0.00980360f, 0.00580972f, 0.05380044f, 
    0.14734374f, -0.03354245f, 0.11475968f, -0.02259458f, 0.20736061f, -0.18609960f, -0.42038894f, -0.18330052f, 
    0.06412081f, 0.09559122f, 0.10989747f, 0.04310511f, 0.16539221f, 0.01208529f, 0.02925202f, 0.00669087f, 
    0.00826642f, 0.03438076f, 0.03324978f, 0.09732831f, -0.07945658f, -0.07234856f, -0.16300330f, -0.27121195f, 
    -0.18004063f, -0.13707031f, -0.07135604f, 0.00597605f, 0.00320932f, -0.07339552f, 0.01717548f, -0.04628005f, 
    -0.04922272f, 0.01389897f, 0.03173456f, 0.07023392f, -0.04374536f, 0.00294945f, -0.02652612f, -0.01680705f, 
    0.10938495f, 0.02178470f, 0.11613888f, 0.09896281f, -0.08935416f, 0.03093949f, 0.05419324f, 0.10773019f, 
    -0.11619172f, 0.08269396f, 0.05155174f, 0.00108956f, 0.09853897f, -0.11611502f, -0.03736750f, 0.00489262f, 
    0.03040525f, -0.02569629f, 0.05757931f, 0.07580659f, -0.02334445f, 0.00942260f, 0.14560650f, 0.03458700f, 
    0.39105955f, 0.22147089f, -0.04772487f, 0.05087088f, -0.08455351f, 0.00329505f, 0.12243959f, 0.00493294f, 
    0.04240782f, 0.07534041f, 0.12522596f, -0.07652625f, -0.02588267f, 0.05919743f, 0.03274364f, -0.06163113f, 
    0.13886130f, 0.02039498f, 0.00083236f, -0.15324165f, 0.08965581f, -0.20650004f, -0.37317151f, 0.00302763f, 
    0.07735065f, -0.06008141f, 0.03809387f, 0.12957469f, 0.08789989f, 0.12609081f, 0.05214640f, -0.00553771f, 
    -0.02408369f, -0.00196095f, -0.04847286f, 0.02307730f, 0.03557733f, 0.00067201f, 0.00636082f, -0.01613550f, 
    0.11831165f, -0.00276917f, 0.01777136f, 0.02203848f, -0.14029233f, -0.01163982f, -0.09263729f, -0.17270739f, 
    -0.07105064f, -0.09420266f, -0.04846985f, 0.07216053f, 0.11806563f, -0.02011221f, 0.04239305f, 0.03322859f, 
    0.11789623f, 0.19984958f, 0.15963529f, 0.21084248f, -0.33339456f, -0.64449972f, -0.56480396f, -0.33122340f, 
    0.00608946f, -0.08761160f, 0.27292776f, 0.18086517f, 0.04088077f, -0.01048387f, 0.02958748f, -0.07981107f, 
    -0.05457343f, -0.06088532f, -0.06140577f, 0.01552198f, 0.03965667f, -0.05194471f, 0.04395513f, -0.03317565f, 
    0.09637871f, -0.03101389f, -0.19019593f, 0.20983422f, 0.23858842f, 0.03413234f, -0.07525105f, 0.08374204f, 
    -0.01867370f, 0.08154813f, 0.04274012f, 0.01892153f, 0.09667664f, -0.08537062f, 0.00791373f, 0.03275417f, 
    0.22151597f, -0.25857008f, -0.29738069f, -0.05771300f, 0.10180233f, -0.51082486f, -0.37065238f, 0.04644234f, 
    0.09962761f, 0.03136653f, 0.11139004f, 0.13806589f, 0.04170728f, 0.09371549f, 0.04422254f, -0.14603566f, 
    -0.06363997f, -0.00390044f, -0.06561466f, 0.02971461f, 0.04877061f, 0.03628976f, 0.01414572f, -0.02126516f, 
    -0.14505148f, 0.14286883f, 0.14498216f, -0.00660192f, -0.14784241f, -0.01102671f, -0.03517704f, -0.02553292f, 
    0.00919279f, -0.02601502f, -0.06481644f, -0.06278271f, -0.02259710f, -0.01912027f, -0.00115886f, 0.02052498f, 
    0.04691027f, -0.05014652f, 0.02389391f, -0.00601220f, -0.23763558f, -0.58192092f, -0.56876564f, -0.20636235f, 
    -0.26582614f, 0.02377130f, -0.09704213f, 0.07403043f, -0.02853074f, -0.10457075f, -0.08164463f, 0.03182974f, 
    -0.04570192f, -0.02797710f, 0.04205037f, 0.01722122f, 0.03389501f, 0.07926550f, 0.02742440f, 0.13002294f, 
    0.08374524f, -0.37109920f, -0.03001463f, -0.12600084f, 0.02197598f, -0.10216118f, 0.07964818f, 0.10803857f, 
    0.10767666f, -0.00370924f, -0.02132408f, 0.07578693f, 0.04079852f, -0.04771682f, -0.04593419f, 0.01737543f, 
    -0.04673810f, -0.07544884f, -0.02734214f, -0.05519161f, -0.05444127f, -0.34430167f, -0.32166469f, -0.22972588f, 
    -0.09852510f, -0.23994105f, 0.05268883f, 0.02252802f, 0.03966506f, -0.29472536f, 0.03689887f, -0.03975452f, 
    -0.03175554f, -0.01040326f, 0.06326758f, 0.07636953f, 0.00684430f, -0.08743362f, -0.07595739f, 0.00394664f, 
    -0.04311139f, 0.29466426f, 0.29095867f, 0.12362449f, -0.14905067f, 0.17016719f, -0.16247250f, -0.12701201f, 
    -0.07678016f, -0.19548759f, -0.04183655f, -0.04268018f, -0.01742559f, -0.04142651f, -0.01508605f, -0.11506648f, 
    -0.07551861f, -0.09479311f, -0.25201601f, -0.31653377f, 0.06697312f, -0.06634688f, -0.46063277f, -0.20025037f, 
    0.04165650f, -0.00594455f, -0.00958349f, 0.20018369f, -0.04959866f, -0.14458090f, -0.00748930f, -0.03568392f, 
    -0.06154551f, 0.00349750f, 0.03478217f, 0.06390447f, 0.00601280f, 0.04727442f, -0.02526540f, -0.10107328f, 
    0.14021613f, 0.20642826f, 0.14069112f, -0.05194981f, -0.22227642f, -0.06913055f, -0.06924481f, -0.13152267f, 
    0.03962834f, -0.05343163f, -0.01809984f, 0.03747539f, -0.01988049f, -0.03199351f, 0.03183609f, -0.13701041f, 
    -0.15253970f, -0.18541674f, -0.08884948f, -0.19234385f, -0.17694879f, 0.09325358f, 0.15974766f, 0.04600012f, 
    -0.02427814f, -0.03196534f, -0.03954788f, -0.04011624f, -0.04193885f, -0.04742540f, -0.05904863f, -0.07790748f, 
    0.01070053f, -0.03977412f, 0.03307339f, -0.07098405f, -0.06537670f, -0.09940261f, -0.12377434f, -0.08858448f, 
    0.22692457f, -0.40679565f, -0.46459591f, -0.40297225f, -0.01871477f, 0.05389760f, -0.01092644f, -0.01377743f, 
    0.07146901f, 0.07936126f, 0.07348879f, -0.12060267f, 0.06689487f, 0.03435531f, -0.04001832f, 0.02792549f, 
    0.01298526f, -0.06245049f, 0.05038738f, -0.01342729f, -0.36634165f, 0.06117314f, 0.16712525f, 0.07750099f, 
    -0.10279558f, -0.02957119f, 0.08620164f, 0.06086560f, 0.00349667f, -0.06302884f, -0.07578813f, -0.00129191f, 
    -0.00753347f, 0.03796070f, 0.02031978f, -0.00926778f, 0.14372990f, -0.02953663f, 0.19382258f, -0.05365016f, 
    0.17962927f, 0.27675554f, -0.13054009f, -0.15140140f, -0.27582255f, -0.02677169f, 0.03270925f, -0.04562287f, 
    0.17366736f, -0.03023896f, 0.09276307f, 0.03216068f, 0.01455124f, 0.16122623f, 0.10978670f, -0.09915002f, 
    -0.05781410f, -0.03103281f, -0.15224877f, -0.26230139f, -0.36556053f, -0.50982624f, 0.12659454f, 0.12618209f, 
    0.19640630f, -0.09584966f, 0.10534138f, 0.09396975f, -0.03628147f, -0.04460677f, -0.02249818f, 0.00872691f, 
    -0.04205822f, 0.02728673f, 0.00857935f, -0.02235459f, -0.01705872f, -0.07503426f, 0.01377149f, -0.01280321f, 
    -0.05860760f, -0.21000388f, -0.45083356f, -0.27574793f, -0.00404404f, 0.04390833f, 0.05194099f, -0.00595641f, 
    0.02699975f, -0.04152472f, -0.00135537f, -0.03830525f, -0.02428374f, 0.03912576f, 0.05594020f, 0.04205507f, 
    -0.03699204f, 0.00883157f, -0.04611247f, 0.03453705f, 0.03555045f, -0.23141021f, -0.49687889f, -0.15779388f, 
    -0.01088728f, -0.12245080f, 0.05286915f, 0.13812825f, 0.11971115f, 0.04942541f, 0.11341894f, -0.05186069f, 
    -0.05407677f, -0.04095876f, -0.04954201f, 0.00087398f, -0.01968280f, -0.00297251f, -0.06274895f, -0.03944226f, 
    0.04965555f, -0.20950696f, 0.00265397f, 0.15682980f, 0.32013440f, 0.19063687f, 0.13336094f, 0.02040722f, 
    -0.03903006f, 0.05309977f, 0.06447988f, -0.01932285f, 0.08488439f, 0.00207748f, 0.00602245f, 0.02460729f, 
    -0.10424359f, 0.02676970f, -0.15998469f, -0.05338535f, -0.25268918f, 0.05624776f, 0.08549469f, -0.00710058f, 
    -0.03781084f, -0.06988008f, -0.00695441f, -0.02354099f, -0.00044338f, 0.03813183f, -0.00354500f, -0.02332056f, 
    0.00954592f, 0.08257543f, 0.02556481f, -0.00411265f, 0.04717582f, 0.06075376f, 0.03176436f, 0.06008022f, 
    -0.37400308f, -0.35004008f, -0.05584688f, 0.17947099f, 0.11863075f, 0.06125861f, 0.04882561f, -0.01168009f, 
    0.00093055f, 0.15816420f, 0.07821096f, 0.01190706f, 0.07396752f, 0.03567041f, 0.11948039f, -0.03707300f, 
    0.11228102f, 0.02504713f, 0.00064554f, 0.15543419f, -0.02715225f, 0.04304305f, 0.02171293f, -0.06213443f, 
    -0.02425266f, -0.04779051f, 0.03875880f, 0.03416191f, -0.01238924f, -0.03431470f, -0.01953999f, 0.06760193f, 
    0.06790545f, 0.06101958f, 0.08856609f, 0.02804752f, 0.00682478f, -0.04729154f, 0.04554617f, 0.01877926f, 
    -0.04784049f, -0.39117888f, -0.27748308f, -0.11035883f, 0.01408326f, -0.06929831f, 0.10759363f, 0.04835359f, 
    0.09515567f, 0.07295226f, 0.08505883f, -0.03610400f, -0.00678915f, -0.06574805f, -0.06966826f, 0.02068110f, 
    0.04327158f, 0.00360112f, 0.04939425f, -0.03099672f, -0.17564785f, 0.02948554f, -0.00756592f, -0.04735740f, 
    -0.12328260f, -0.08584855f, -0.01240037f, -0.04041140f, -0.04685279f, -0.07547370f, -0.08539782f, -0.03996506f, 
    -0.03465192f, 0.02144428f, 0.05320503f, 0.00081127f, 0.10308778f, 0.01424049f, 0.02135301f, 0.04159389f, 
    -0.06637054f, 0.10003128f, 0.00026440f, 0.00931051f, -0.08826487f, -0.07956790f, 0.01407113f, -0.03242378f, 
    -0.03678332f, -0.04011084f, -0.03262344f, -0.01033692f, 0.01267787f, 0.04297399f, 0.06378189f, -0.00039897f, 
    0.12379260f, 0.09388496f, 0.10424432f, 0.03726733f, -0.02213890f, 0.05290303f, 0.02007825f, 0.01844958f, 
    -0.06458953f, -0.03063655f, -0.05054091f, -0.04720469f, -0.00913782f, -0.11318529f, -0.05648254f, 0.00446604f, 
    0.01464208f, -0.06033397f, 0.07401923f, -0.05961044f, 0.07695722f, 0.16573071f, 0.10654195f, 0.15490654f, 
    0.11375865f, -0.11532208f, -0.19350828f, -0.05921812f, -0.09450164f, -0.00897101f, 0.01123972f, 0.05469558f, 
    -0.02046110f, -0.05879705f, -0.08377676f, 0.05891940f, 0.04812828f, -0.01693860f, 0.03371448f, 0.03940499f, 
    0.06660151f, 0.10519868f, 0.10655452f, 0.03490371f, -0.03271459f, -0.53287464f, 0.16086426f, 0.19703218f, 
    0.10627563f, 0.02158318f, -0.03082165f, -0.02077832f, -0.05819254f, 0.02407232f, 0.03245026f, -0.04358561f, 
    0.08275169f, 0.05861409f, 0.02283707f, 0.02237681f, -0.20029192f, -0.07184427f, -0.28849962f, -0.01527427f, 
    -0.28422299f, 0.22906497f, 0.08849182f, 0.06929304f, -0.19239411f, 0.03180540f, -0.01606009f, 0.02157342f, 
    -0.01704146f, -0.14224814f, -0.05702504f, 0.01807743f, 0.05476126f, 0.00412605f, -0.02863185f, -0.08385387f, 
    0.02096708f, 0.15041040f, 0.09271871f, 0.03339493f, 0.16530128f, -0.44859067f, -0.28661579f, 0.06695613f, 
    0.07198289f, 0.06304766f, 0.12371023f, 0.08081523f, 0.03127721f, -0.09186029f, 0.02004389f, -0.02333464f, 
    -0.00093238f, -0.02339553f, 0.00473414f, -0.00011148f, 0.06023015f, 0.05390415f, 0.13784939f, 0.00327304f, 
    0.01450478f, -0.27249530f, -0.15417357f, 0.08375803f, 0.25435361f, 0.00893006f, 0.11094774f, 0.20161676f, 
    -0.02174809f, 0.15578842f, -0.02715985f, -0.07657301f, 0.01220419f, -0.03453148f, -0.00365941f, -0.03971219f, 
    0.05449016f, -0.08145505f, -0.02741287f, -0.02347977f, 0.12261689f, 0.13338527f, 0.10144299f, -0.06308427f, 
    0.05542482f, -0.03169170f, 0.07219884f, -0.02440425f, 0.03095041f, 0.03976571f, 0.05758735f, -0.07127842f, 
    0.03236894f, 0.00261638f, -0.02487951f, -0.02173019f, -0.02233989f, 0.14532690f, -0.14267313f, -0.02935039f, 
    -0.11398972f, -0.00141595f, -0.01809332f, -0.06392486f, -0.17836976f, -0.06243579f, -0.00985875f, -0.00541223f, 
    -0.00696875f, -0.07388753f, -0.03347865f, 0.01770712f, 0.03049505f, 0.06389246f, 0.05648121f, 0.04704795f, 
    0.03847208f, 0.00331602f, 0.07294129f, -0.01027475f, 0.22721590f, -0.03628498f, -0.09990823f, -0.00479737f, 
    -0.14483757f, 0.06772799f, -0.06690161f, 0.02141897f, 0.00030693f, 0.07044691f, -0.03623611f, 0.13645951f, 
    0.01640205f, 0.07544199f, -0.01085026f, 0.04109013f, 0.08059601f, -0.02240833f, 0.07787142f, 0.12515543f, 
    -0.06292678f, -0.24153356f, -0.34628436f, -0.08304769f, -0.05955692f, -0.08215144f, -0.04159017f, 0.02209188f, 
    0.03146266f, -0.06274790f, -0.04243382f, 0.02569738f, -0.03107507f, -0.02016802f, -0.00710316f, 0.00013837f, 
    0.06268799f, 0.08980015f, 0.08386648f, 0.07018477f, -0.06356058f, -0.09653220f, -0.03710486f, 0.16395077f, 
    0.18632615f, 0.17547706f, 0.08104261f, -0.02327796f, 0.02316615f, -0.02145053f, 0.02452865f, 0.02475293f, 
    0.01982260f, 0.03673757f, 0.08244331f, -0.04613097f, -0.02785636f, 0.14651638f, -0.18339905f, 0.15996769f, 
    0.34753814f, 0.01158972f, -0.02324609f, 0.00794768f, 0.10581519f, 0.10446583f, -0.03711647f, -0.00053838f, 
    0.03658738f, 0.06079730f, 0.10658333f, 0.06367469f, -0.00811016f, 0.06609928f, -0.03362859f, -0.10342639f, 
    -0.00078869f, -0.00343001f, -0.12065827f, -0.03569046f, 0.13070607f, -0.17128928f, -0.22899544f, -0.14131913f, 
    -0.18655208f, -0.07455925f, -0.28522554f, -0.03060958f, -0.17385763f, -0.40363598f, -0.00751259f, 0.02952252f, 
    0.03104377f, 0.03964102f, 0.03841171f, 0.07405671f, 0.04092652f, 0.11592549f, -0.10401249f, -0.31695634f, 
    0.04278283f, -0.24434304f, -0.44480473f, -0.27452037f, -0.06336020f, -0.08477934f, 0.08478836f, 0.12365887f, 
    0.15516572f, 0.08086479f, 0.11850554f, -0.02773902f, -0.02259239f, -0.06416604f, -0.04250082f, 0.03158928f, 
    -0.04172621f, 0.01051370f, 0.00479265f, -0.08296780f, -0.28658304f, -0.04608142f, 0.03306681f, 0.10658661f, 
    0.05661417f, -0.03393276f, -0.09705704f, -0.04702604f, -0.04979839f, -0.03341294f, -0.03072898f, -0.04205548f, 
    0.05473166f, 0.00806302f, 0.06064243f, -0.04196577f, 0.06033856f, 0.19871219f, 0.10541628f, 0.16710691f, 
    -0.11797870f, -0.17219660f, -0.10813989f, 0.14990588f, -0.04591124f, -0.07558452f, 0.04330574f, 0.03475834f, 
    0.00276677f, 0.12678799f, 0.04542988f, 0.00966210f, -0.02343578f, -0.04565756f, 0.01428493f, -0.06368645f, 
    0.10014378f, 0.01597772f, 0.07532880f, 0.08188724f, 0.03106250f, -0.04280663f, -0.16843688f, -0.14646544f, 
    0.05261209f, 0.03538634f, 0.01970265f, -0.04210772f, 0.02936395f, 0.00971185f, 0.05714438f, -0.00190476f, 
    0.16091967f, 0.02794111f, 0.00149411f, -0.07550079f, 0.09432059f, -0.00390259f, 0.11098692f, 0.11195477f, 
    0.09471254f, -0.29366484f, 0.04483384f, 0.09528096f, 0.19469056f, 0.06306004f, 0.03672950f, 0.00255340f, 
    -0.01379064f, 0.03513831f, 0.03446546f, 0.01310996f, 0.02651079f, 0.03012703f, 0.01943072f, -0.14526084f, 
    -0.09320220f, -0.07022892f, -0.19556129f, -0.22520041f, -0.03043823f, -0.11990850f, -0.06325261f, 0.11025581f, 
    -0.10255288f, -0.03558991f, 0.13064282f, 0.00433953f, -0.00910755f, 0.03197336f, 0.01661105f, 0.02060084f, 
    -0.05466875f, 0.06651980f, -0.01492808f, 0.04805269f, 0.20872818f, -0.00359167f, 0.19385058f, 0.02121911f, 
    -0.19502617f, -0.34358227f, 0.23604152f, 0.01708778f, 0.19893014f, -0.09673513f, -0.01519186f, -0.05485853f, 
    -0.07754253f, -0.11082504f, 0.04339147f, 0.02121125f, 0.02454018f, 0.03840887f, 0.01118545f, -0.01474130f, 
    -0.08062316f, -0.06528035f, -0.06746087f, -0.13265565f, 0.36506757f, 0.07823201f, -0.05529016f, -0.21080224f, 
    -0.13375254f, -0.15366295f, -0.29626584f, -0.12103266f, -0.07223902f, -0.18377897f, 0.01932697f, 0.01271843f, 
    0.00694818f, 0.05360493f, 0.04326909f, 0.09233416f, -0.01322337f, -0.18915635f, -0.20834094f, -0.57976437f, 
    -0.06264991f, -0.48392424f, 0.07688645f, 0.10201403f, 0.22422032f, -0.03547076f, 0.00980970f, -0.06270742f, 
    -0.09399953f, 0.00278673f, -0.06113543f, 0.03342602f, -0.03457418f, 0.11200996f, 0.01661784f, 0.16488585f, 
    -0.03336962f, 0.05053927f, -0.05749551f, -0.07565014f, -0.33967298f, 0.04510305f, 0.10012733f, 0.07178145f, 
    -0.16506369f, -0.11274078f, 0.00066319f, -0.03823823f, 0.03171656f, -0.06287911f, -0.08341522f, 0.02347253f, 
    0.03816790f, -0.01410093f, 0.05249485f, 0.05246444f, -0.03510286f, -0.05683477f, 0.04298639f, 0.03705088f, 
    -0.28355134f, -0.08124032f, -0.11068689f, 0.04844936f, 0.02948733f, 0.00329335f, 0.02090303f, -0.02698210f, 
    0.02794138f, 0.04473557f, 0.06139738f, 0.07486010f, 0.04273988f, 0.05620969f, -0.01192211f, -0.04265733f, 
    0.17932883f, 0.04445719f, 0.00650116f, 0.13104856f, -0.10625564f, -0.00463489f, -0.02117869f, -0.07601489f, 
    -0.26143116f, -0.08007870f, -0.02813783f, -0.07405461f, -0.00524594f, -0.06905872f, 0.12437218f, 0.04776804f, 
    0.08552326f, 0.08314255f, 0.05030536f, -0.00982427f, 0.01701744f, -0.03309658f, -0.04711642f, 0.01000252f, 
    -0.11614317f, 0.09243536f, 0.00646752f, -0.06393668f, -0.05665156f, -0.04895720f, 0.01699959f, 0.00565843f, 
    -0.00810299f, -0.02512693f, -0.05484037f, -0.04432567f, -0.01426146f, 0.00431248f, 0.03480655f, 0.01493034f, 
    0.00356077f, -0.03274941f, 0.03657601f, -0.00892712f, 0.01164445f, -0.30708966f, -0.44718504f, -0.25097075f, 
    -0.17527191f, -0.06593806f, -0.16665110f, -0.14598127f, 0.04469478f, -0.43029958f, -0.01221250f, 0.01314205f, 
    -0.03729795f, -0.00975206f, 0.02085687f, 0.04812073f, 0.07239126f, 0.06857756f, 0.00312522f, -0.06832375f, 
    -0.17050810f, 0.01919367f, 0.05776998f, 0.01753455f, -0.13720453f, -0.04541296f, -0.05596390f, 0.05686741f, 
    0.05668515f, -0.01063714f, -0.05221706f, -0.03133087f, -0.03770574f, 0.03149525f, 0.00647880f, 0.06395314f, 
    0.04152843f, 0.01090856f, -0.03863579f, 0.06254349f, 0.27646872f, 0.02052977f, -0.14681602f, 0.05228327f, 
    0.07695901f, 0.14784877f, 0.24194767f, 0.21124873f, 0.05010924f, -0.00138196f, 0.05239677f, -0.00796975f, 
    -0.00895949f, -0.01770403f, 0.03557024f, 0.03569023f, 0.07689372f, -0.02362368f, 0.06798274f, -0.11875622f, 
    0.53257227f, -0.20534350f, -0.18149474f, -0.00781269f, -0.00921852f, -0.02485241f, -0.15352495f, -0.20374937f, 
    -0.02237648f, 0.10362895f, -0.09092578f, 0.01191483f, 0.01817549f, -0.03220584f, 0.03866945f, -0.03684568f, 
    0.08963335f, 0.11804779f, 0.08440746f, 0.13413268f, 0.01932252f, -0.35092908f, -0.42431596f, -0.04339756f, 
    0.16081721f, -0.00866542f, 0.01976854f, 0.17170927f, 0.17859228f, 0.09022454f, 0.11976275f, -0.10101742f, 
    -0.07888629f, 0.02452794f, -0.03685537f, -0.03507710f, 0.01307260f, -0.00140113f, -0.07241250f, -0.04202112f, 
    0.55085337f, -0.49883163f, -0.34376442f, -0.00034921f, -0.03307939f, -0.00256951f, -0.00373781f, -0.05431766f, 
    0.09696786f, 0.15103589f, 0.00030498f, -0.01169033f, -0.00251848f, -0.03540863f, 0.04287076f, 0.01638479f, 
    0.10157751f, 0.08135535f, 0.08311038f, -0.02199366f, 0.13079402f, -0.10825124f, -0.40288284f, -0.10817643f, 
    0.01818732f, 0.04888345f, -0.00113841f, 0.17007481f, 0.05663087f, -0.04128195f, -0.00061549f, -0.04606063f, 
    -0.00384735f, 0.03954485f, 0.05165404f, 0.04270484f, 0.00543083f, 0.04172860f, -0.02199051f, -0.02603910f, 
    -0.55797768f, 0.14816478f, -0.22276199f, 0.03749905f, -0.02311014f, 0.11762869f, -0.08022610f, -0.05461431f, 
    -0.05544459f, -0.14374104f, 0.02699124f, 0.00396802f, -0.04690901f, -0.02675554f, -0.03402675f, -0.01968853f, 
    -0.13204411f, -0.09890600f, 0.02016809f, 0.00440906f, 0.01046577f, 0.15713876f, -0.06000901f, 0.39988637f, 
    -0.30549034f, 0.13096641f, -0.25393549f, -0.00366814f, 0.00781160f, 0.02499392f, 0.01572552f, -0.01877324f, 
    0.04253778f, 0.08083876f, 0.13217592f, -0.04623208f, 0.01043872f, 0.13694170f, 0.08380406f, 0.22967885f, 
    0.01509080f, 0.15649249f, 0.48390445f, -0.12947635f, -0.06433726f, -0.00958824f, -0.11562710f, -0.05778605f, 
    0.05953842f, -0.00084119f, -0.00393177f, 0.09465517f, 0.01610017f, 0.05338109f, 0.02490681f, -0.06118518f, 
    0.01745304f, -0.09732522f, -0.05608297f, -0.03065048f, -0.56523758f, 0.38623434f, -0.53626543f, -0.01662179f, 
    -0.25789484f, 0.10694797f, -0.15253745f, 0.07838414f, -0.16487142f, 0.04470866f, 0.01249455f, 0.03699739f, 
    -0.10708172f, -0.03071107f, -0.01777005f, -0.09480657f, 0.06538383f, -0.02280465f, 0.00633650f, -0.06305825f, 
    -0.22125748f, 0.02258572f, 0.03394565f, -0.02222197f, -0.03205058f, 0.10657922f, -0.01400411f, -0.09098439f, 
    -0.06507955f, -0.15851918f, -0.01280536f, -0.05607911f, -0.05305681f, -0.01231141f, 0.08456615f, 0.06266356f, 
    -0.02986011f, -0.09430607f, -0.02402855f, -0.10367676f, 0.04374216f, 0.10957653f, 0.07463437f, 0.19955105f, 
    -0.12663969f, -0.09124871f, 0.06928968f, -0.22348541f, -0.07033801f, -0.09578847f, 0.06321754f, -0.02416419f, 
    0.03945345f, 0.04203136f, 0.06529274f, 0.02960447f, 0.00144625f, -0.00375967f, -0.02424283f, -0.02645062f, 
    0.13653269f, 0.16465938f, -0.16228136f, -0.00937322f, -0.08703371f, 0.09496891f, 0.14514150f, 0.14823601f, 
    0.01449800f, -0.01456784f, 0.03258097f, -0.03554699f, -0.01417744f, -0.09828825f, -0.01924097f, -0.00225453f, 
    -0.10407278f, -0.07692360f, 0.00379142f, -0.08591535f, -0.10051408f, -0.17576286f, 0.11633310f, 0.22636501f, 
    -0.57763672f, 0.24411695f, -0.29807106f, -0.24701706f, 0.00699302f, -0.12254977f, 0.01900786f, -0.01111830f, 
    0.03575248f, 0.04838233f, 0.04604026f, -0.00580491f, -0.01020284f, -0.00022820f, 0.00165978f, 0.02142946f, 
    0.24595238f, -0.16034301f, -0.31919193f, -0.40156499f, -0.27666920f, 0.06380552f, -0.08436797f, 0.12397044f, 
    0.03590536f, -0.08105231f, 0.02585115f, 0.00592164f, -0.00776020f, -0.14684461f, -0.04189385f, 0.16185965f, 
    0.02942337f, 0.07112343f, -0.08166313f, 0.14199629f, 0.02273600f, -0.00457535f, 0.01789982f, 0.16162820f, 
    -0.20732749f, -0.10250232f, 0.09672747f, -0.28456968f, -0.09966031f, -0.14347008f, -0.03451803f, -0.01420281f, 
    -0.03517812f, 0.04581717f, 0.05721579f, -0.03818477f, 0.02583273f, 0.00556657f, -0.04819741f, -0.03932129f, 
    -0.17695548f, -0.01600857f, -0.19544306f, 0.01034078f, 0.01005408f, 0.11189663f, 0.03878556f, 0.12387036f, 
    -0.03712987f, -0.06877823f, 0.06334999f, -0.04936500f, -0.01499911f, 0.01272602f, -0.07487340f, 0.12939170f, 
    0.12642257f, -0.01191301f, 0.01456784f, 0.06647354f, -0.35558730f, -0.32494405f, -0.13312551f, 0.17278352f, 
    -0.28291065f, -0.27845860f, 0.04809536f, 0.15476048f, 0.07341590f, 0.15648121f, 0.03182271f, 0.04320735f, 
    -0.01800374f, -0.05565959f, -0.02053791f, 0.03656526f, -0.01183501f, 0.05181609f, 0.02589218f, -0.26733890f, 
    0.12431199f, 0.17242129f, 0.28153980f, 0.35124686f, -0.17818888f, 0.11860285f, -0.06387149f, -0.18835180f, 
    -0.18045785f, -0.16581722f, 0.10219443f, -0.01254806f, 0.10222286f, -0.07481108f, -0.00601055f, 0.05964008f, 
    0.03472110f, -0.09751912f, -0.02860426f, 0.05771846f, -0.30941007f, -0.34496796f, -0.22571194f, -0.22757727f, 
    -0.27971870f, -0.14012498f, -0.02157462f, -0.16953908f, 0.06104219f, 0.09915698f, 0.06587689f, 0.01228652f, 
    0.07082387f, -0.00303547f, -0.08659092f, -0.04486542f, 0.09435825f, 0.01438337f, 0.03694421f, 0.07117720f, 
    0.13911286f, 0.16669996f, -0.66436768f, 0.13439943f, -0.03301338f, 0.12869076f, 0.17749931f, 0.23655185f, 
    0.04078445f, 0.19924553f, -0.01636974f, -0.02326059f, -0.03356203f, -0.03031844f, -0.06791026f, -0.03339569f, 
    0.02401128f, -0.02094942f, 0.01138672f, 0.03991125f, -0.00001614f, -0.03372103f, -0.06680250f, 0.18268214f, 
    -0.34816852f, -0.13612601f, 0.00218240f, -0.04122066f, 0.04109610f, 0.05599391f, 0.07906224f, -0.01453542f, 
    0.06548228f, 0.03892025f, 0.08265633f, -0.00378353f, 0.11266752f, 0.09490959f, 0.09774844f, 0.02542539f, 
    -0.15182257f, -0.01029282f, -0.19680431f, 0.13172312f, 0.12196217f, 0.06974411f, 0.02772318f, 0.03816105f, 
    0.06403789f, 0.01877106f, 0.01712241f, 0.00099754f, -0.01682268f, -0.00189802f, -0.01976898f, 0.02477409f, 
    0.05192802f, 0.05122611f, 0.09084973f, 0.13498902f, -0.05064351f, 0.03156353f, -0.18856002f, 0.07128630f, 
    0.09450445f, 0.02393117f, 0.01695929f, 0.12654144f, -0.00283294f, 0.01912270f, -0.03158890f, 0.02167982f, 
    0.02086382f, 0.03257610f, -0.04647315f, 0.02240892f, 0.12949608f, 0.14672494f, -0.00695726f, 0.14144513f, 
    -0.54168516f, 0.15945317f, 0.20037764f, 0.55910528f, -0.53469741f, 0.08013518f, -0.17549887f, -0.14563069f, 
    -0.09584631f, -0.23165399f, 0.07036426f, -0.04469828f, 0.09503759f, -0.01493548f, 0.06832838f, 0.01228828f, 
    -0.04058919f, -0.16505140f, 0.02894128f, 0.04019644f, -0.23743208f, -0.02714583f, -0.15099190f, -0.55121952f, 
    0.05066070f, -0.03731329f, 0.10048192f, 0.00876566f, 0.03488652f, 0.12880158f, 0.05096494f, -0.00530633f, 
    -0.11783443f, -0.09436899f, 0.04372418f, 0.14537354f, 0.17265287f, -0.03865067f, -0.10654394f, 0.05484650f, 
    -0.83441263f, 0.01632718f, -0.20395234f, 0.32622337f, -0.29449129f, 0.01098667f, 0.07452104f, -0.17166466f, 
    0.14439489f, -0.00856294f, 0.10248797f, 0.00319882f, 0.03199756f, -0.03250428f, -0.07834458f, 0.12184916f, 
    -0.04386434f, -0.01594114f, 0.08090672f, 0.09209465f, 0.05659890f, -0.19544460f, 0.11631519f, -0.19624239f, 
    -0.31052095f, -0.08706336f, -0.15095350f, -0.12552540f, 0.08155740f, -0.14353426f, -0.08148539f, 0.05778403f, 
    -0.07664549f, -0.00240266f, -0.07730117f, 0.04018668f, 0.07440712f, 0.03797205f, -0.07034936f, 0.05677383f, 
    -0.08777698f, 0.01594083f, 0.23388447f, 0.27527344f, -0.32791930f, 0.12546098f, -0.15107802f, 0.04310208f, 
    0.05328082f, 0.12495242f, 0.05208603f, 0.01993347f, 0.01869711f, 0.03534703f, 0.00921211f, -0.01963810f, 
    0.07101797f, 0.02934017f, 0.03000434f, 0.01551733f, -0.04333419f, 0.14986403f, 0.06091747f, 0.48326930f, 
    -0.25558612f, -0.10326995f, 0.04655563f, -0.35087126f, 0.00568242f, -0.17994975f, 0.07609477f, -0.09986252f, 
    0.10660768f, 0.10406909f, 0.06494153f, 0.07545976f, 0.05864064f, 0.03632833f, -0.00901804f, 0.04750195f, 
    -0.15972804f, -0.32823956f, -0.48918274f, -0.16968980f, -0.01971363f, 0.17801870f, -0.20562588f, 0.07794978f, 
    0.02053712f, 0.00481645f, -0.04293844f, 0.03228835f, -0.05581015f, -0.04103349f, 0.09351826f, 0.01549842f, 
    -0.00971573f, 0.05113583f, 0.09253306f, 0.08083303f, -0.04855921f, 0.00767176f, -0.05131865f, -0.09679496f, 
    0.07759593f, -0.04174579f, 0.06015414f, 0.03122370f, 0.07407083f, 0.00859583f, 0.05137254f, 0.00633388f, 
    0.04594590f, -0.12671115f, 0.02876765f, 0.06283257f, 0.06425489f, -0.05438589f, -0.01358641f, -0.02334047f, 
    0.10230777f, -0.18903878f, 0.25339046f, -0.20074533f, -0.02807127f, -0.18848428f, 0.02361111f, -0.09938169f, 
    0.14832433f, 0.21580566f, -0.06028882f, 0.06015482f, 0.01435681f, 0.03358427f, 0.06912206f, -0.02336114f, 
    0.09194107f, 0.08017167f, -0.06812268f, -0.04412762f, -0.05344594f, 0.00848510f, -0.04431082f, 0.03797278f, 
    0.10974066f, -0.03767198f, 0.04657852f, 0.08486984f, -0.06367262f, -0.07844362f, 0.05614929f, 0.06403469f, 
    0.00647101f, -0.04003698f, -0.02750854f, 0.05046180f, 0.04317429f, -0.03765570f, -0.06640165f, 0.06147644f, 
    0.14246638f, 0.14703938f, 0.18029091f, 0.20887393f, -0.17467703f, 0.08626074f, -0.13041474f, -0.20763691f, 
    -0.11490361f, -0.13070945f, 0.05573693f, 0.01455041f, 0.04976473f, 0.03504493f, 0.03591550f, 0.00881997f, 
    -0.00462991f, 0.00363323f, -0.04524974f, -0.00197031f, -0.13460517f, -0.04210472f, -0.11726920f, -0.13137075f, 
    0.01946267f, 0.04960056f, 0.09145221f, 0.14405417f, 0.06736296f, -0.01258834f, 0.10676324f, 0.07242636f, 
    0.04144413f, -0.03915174f, -0.07074278f, 0.21687520f, 0.09732591f, 0.03903376f, 0.03388151f, 0.03118441f, 
    -0.13449076f, 0.04735930f, -0.08746817f, -0.05311336f, 0.03912106f, 0.07102358f, 0.10131945f, 0.14939362f, 
    0.03328840f, -0.07787426f, 0.11451015f, 0.00004554f, -0.04980613f, -0.03600302f, -0.06926637f, 0.07095873f, 
    -0.00616966f, -0.13425796f, 0.02544645f, -0.03877260f, 0.10603578f, -0.00868030f, -0.22594303f, 0.05108044f, 
    -0.06458925f, -0.01701934f, 0.15246630f, 0.18879898f, 0.01142436f, 0.07127797f, 0.03029024f, -0.04629069f, 
    -0.14889815f, -0.03097196f, -0.09954148f, 0.03715594f, -0.01981739f, -0.08421134f, 0.01743237f, -0.11900935f, 
    -0.04156372f, -0.01140830f, 0.09872809f, -0.14514357f, -0.16964772f, -0.08110028f, -0.17108633f, 0.09722861f, 
    0.02438632f, 0.16925234f, -0.02400665f, 0.03186680f, -0.01697321f, -0.02055269f, -0.05444193f, 0.02967385f, 
    0.01693337f, -0.00101240f, -0.00501366f, -0.05982989f, 0.17716096f, -0.85837847f, -0.05471830f, -0.23134200f, 
    0.24003915f, -0.09774748f, -0.08080149f, 0.00916222f, 0.05539334f, 0.12124469f, 0.00438746f, -0.01575569f, 
    0.02987812f, -0.02582362f, -0.07576635f, -0.13389553f, 0.10179261f, 0.08077011f, -0.00516561f, 0.04436726f, 
    -0.16331512f, 0.23125203f, -0.53924876f, -0.27435145f, 0.06614950f, -0.03661021f, 0.20543744f, 0.22383495f, 
    0.07629451f, 0.16662833f, 0.08958562f, -0.01552335f, -0.11654970f, -0.05833155f, -0.07779784f, 0.05676192f, 
    0.08247823f, -0.09562531f, -0.01878979f, 0.00882527f, -0.15547104f, 0.02279590f, 0.28170338f, -0.21640475f, 
    -0.16144316f, -0.12896572f, -0.14503096f, 0.01847267f, -0.01543692f, -0.01988341f, -0.05445275f, -0.00229188f, 
    0.02115269f, -0.01263761f, -0.00445616f, -0.03235328f, -0.01618923f, 0.01148707f, -0.05996792f, -0.03882370f, 
    0.13606867f, -0.05473332f, 0.19469185f, -0.31469998f, -0.30282193f, 0.03073966f, -0.17739497f, -0.15199289f, 
    0.23855960f, -0.07595565f, 0.00565110f, 0.04125752f, -0.03196898f, 0.05888243f, 0.08339263f, 0.07477650f, 
    0.06857444f, -0.00509894f, 0.01229605f, 0.05141571f, -0.08243845f, -0.28874469f, -0.04793355f, -0.10871280f, 
    0.03129555f, -0.07307477f, 0.01809107f, 0.05998624f, 0.06330539f, -0.08023530f, -0.04272421f, 0.00010366f, 
    -0.03551602f, -0.14021522f, 0.06174133f, 0.10992081f, 0.05679455f, -0.13393028f, -0.00738550f, 0.04407348f, 
    -0.18498729f, 0.02484011f, -0.01191977f, 0.05682034f, 0.01105652f, 0.00629351f, -0.08133915f, 0.14520916f, 
    -0.04015617f, -0.13083915f, 0.13969305f, 0.21238136f, 0.08732172f, -0.00420663f, -0.13463654f, 0.02177512f, 
    0.01561632f, -0.04543664f, 0.03203481f, 0.08696427f, -0.02975485f, 0.07530905f, -0.22932705f, -0.00746595f, 
    -0.08107407f, -0.18960132f, 0.06071194f, -0.01486353f, -0.04793559f, -0.07259582f, 0.06145050f, -0.05988030f, 
    -0.02972193f, -0.04581583f, -0.02035161f, -0.01084203f, 0.00604102f, 0.00651514f, -0.04260994f, -0.06427015f, 
    -0.21604034f, -0.06406217f, 0.26106861f, -0.19923095f, -0.12049288f, 0.01304821f, -0.16474842f, 0.02550049f, 
    0.05590319f, 0.16832073f, -0.06317765f, 0.02929678f, 0.04910034f, -0.04007214f, -0.04717238f, 0.02311871f, 
    0.06825194f, -0.01663420f, -0.02559447f, -0.10560903f, 0.09485982f, -0.17968567f, -0.00560226f, -0.24009404f, 
    -0.09181182f, -0.04396769f, -0.04772323f, 0.01639878f, 0.04700235f, 0.07935854f, 0.02727370f, 0.03211353f, 
    -0.09485174f, -0.02634164f, 0.00021724f, -0.00965112f, -0.00440765f, 0.16146508f, -0.06502614f, -0.11976023f, 
    -0.19669379f, -0.37157828f, 0.06231555f, -0.07895875f, -0.22621647f, -0.03409665f, -0.07316332f, -0.08380984f, 
    0.03195005f, -0.13284577f, -0.06734023f, 0.00920636f, 0.09089674f, -0.06736439f, 0.02176796f, 0.11618084f, 
    -0.03074757f, -0.00958342f, -0.05580064f, -0.02984130f, 0.09410997f, -0.32698014f, -0.17235820f, 0.14148059f, 
    -0.09604900f, -0.11933403f, -0.09527093f, 0.03452229f, 0.01386906f, 0.21393989f, 0.02519891f, 0.04989351f, 
    0.01008184f, 0.05505315f, 0.00211711f, -0.00046822f, 0.08786561f, 0.01777225f, 0.13781713f, 0.13193907f, 
    -0.08907841f, 0.22251682f, 0.05588806f, 0.45899525f, -0.25372362f, -0.01631599f, -0.03420269f, -0.26030317f, 
    -0.02007276f, -0.16257587f, 0.10956644f, -0.02729390f, 0.09876674f, -0.02957905f, 0.02034152f, 0.07779081f, 
    0.04505771f, -0.01377316f, -0.03956670f, 0.02751022f, 0.08755884f, 0.13434039f, 0.04426014f, -0.11102634f, 
    -0.10059533f, -0.12086469f, 0.06842130f, 0.02643592f, 0.12378944f, 0.16253471f, -0.02618651f, 0.03276675f, 
    -0.06250000f, -0.11028568f, -0.00877102f, 0.01652890f, 0.05817056f, -0.05007684f, -0.00278371f, -0.12296788f, 
    0.12652208f, 0.06283633f, 0.21108872f, -0.24692012f, -0.07713687f, -0.03999818f, -0.00292998f, -0.15580918f, 
    0.01026274f, 0.03745013f, 0.00946094f, 0.06252614f, 0.02806164f, 0.01584498f, 0.00850746f, -0.06368062f, 
    -0.00069631f, -0.12744072f, -0.07358784f, 0.06940579f, -0.03098776f, -0.02546791f, 0.07917692f, 0.12672308f, 
    0.06298654f, -0.08242292f, 0.06372064f, -0.13637556f, -0.12041702f, -0.14026277f, 0.04266576f, -0.04766081f, 
    0.06451359f, -0.02647314f, 0.00334349f, 0.04941499f, -0.01715259f, -0.16013908f, -0.07811487f, 0.04371472f, 
    0.21590458f, -0.37368739f, -0.21073565f, -0.14658596f, 0.02731822f, 0.07218197f, -0.12945373f, 0.06795511f, 
    0.10239520f, 0.05796750f, -0.06269439f, 0.01557022f, 0.02737765f, -0.03737282f, 0.01453558f, 0.06236130f, 
    0.04088009f, 0.07650318f, 0.04718246f, 0.10649188f, -0.07758658f, 0.13722320f, 0.11678842f, -0.23256466f, 
    0.02134059f, 0.01572291f, -0.06270042f, -0.05226451f, 0.00180510f, -0.10783679f, 0.07604159f, 0.01796458f, 
    0.00395147f, 0.06627019f, 0.05188546f, -0.10673299f, -0.10146955f, -0.05130372f, -0.06433639f, -0.02916981f, 
    0.07980750f, -0.05328373f, -0.09591279f, -0.01813110f, -0.13618298f, 0.02258207f, -0.15738951f, 0.00944822f, 
    0.04674213f, -0.12716670f, -0.14608657f, 0.06268194f, 0.00756804f, 0.03679207f, -0.03445562f, 0.14990982f, 
    0.08694316f, 0.10118981f, -0.04591094f, 0.19796933f, -0.27680334f, -0.60061389f, -0.27278867f, 0.17573224f, 
    -0.10625419f, -0.27389172f, 0.07605528f, -0.09554484f, 0.00301127f, 0.05897007f, 0.02337718f, 0.00952241f, 
    0.03392073f, 0.04466905f, 0.00342717f, -0.01667596f, 0.06315817f, -0.02516085f, 0.09018152f, 0.19969554f, 
    -0.09179969f, -0.21935914f, -0.08176453f, -0.31815195f, -0.06933145f, 0.02642481f, -0.07632764f, 0.00653732f, 
    -0.07687675f, -0.07752681f, -0.05218959f, 0.06248576f, -0.06266610f, 0.15292804f, -0.12835819f, -0.04520021f, 
    0.04083320f, 0.00535729f, -0.04788709f, -0.00677738f, -0.11733000f, -0.08869293f, -0.05091149f, -0.28836951f, 
    0.13902572f, -0.00402404f, 0.02643362f, 0.13760322f, -0.06581416f, 0.08392490f, -0.13406895f, 0.17024040f, 
    -0.10256917f, 0.03925140f, -0.05260327f, 0.05972737f, 0.07083999f, 0.11706768f, -0.14308009f, 0.02138193f, 
    -0.17949098f, 0.03403104f, 0.46328449f, -0.13750662f, -0.20131591f, 0.13251899f, -0.16490741f, -0.07943743f, 
    0.16499092f, -0.04227009f, -0.04761622f, -0.01516647f, 0.01302171f, -0.07817328f, 0.00315522f, 0.02196669f, 
    0.00836726f, -0.11735685f, -0.09833691f, -0.08153234f, -0.11037627f, 0.12078484f, 0.03818509f, 0.18515381f, 
    0.17403597f, -0.05064410f, 0.05128975f, -0.17120017f, 0.00186562f, -0.16167513f, 0.12589481f, -0.00375268f, 
    0.05763432f, -0.09866057f, -0.02189444f, 0.07315866f, 0.02863609f, -0.02394156f, -0.00143806f, 0.07207453f, 
    -0.18002875f, -0.17046899f, -0.18978418f, -0.06052860f, 0.09667870f, -0.14123487f, 0.09707765f, 0.07830808f, 
    0.01114745f, -0.12329206f, -0.06722311f, 0.07106213f, -0.05871178f, -0.15153432f, 0.02998727f, 0.03589377f, 
    0.15383963f, -0.06962373f, -0.05622780f, 0.09275889f, -0.30024344f, -0.15931575f, -0.09331506f, 0.08174671f, 
    -0.11490583f, 0.03089798f, -0.39309657f, 0.07955886f, -0.00011330f, 0.25161934f, 0.02707354f, 0.00756334f, 
    0.08462997f, -0.01349628f, -0.03993957f, -0.00273553f, 0.06664331f, 0.14267093f, 0.09955845f, 0.03534770f, 
    -0.08026221f, -0.17846069f, -0.00067677f, -0.04248561f, 0.13439336f, 0.02938221f, 0.04719597f, 0.06963128f, 
    -0.03462447f, 0.07010131f, 0.00346772f, 0.05812123f, -0.07491069f, 0.04024627f, -0.01902051f, 0.06129712f, 
    0.09266131f, 0.03857534f, -0.11201853f, 0.01491045f, -0.12319805f, 0.09332448f, -0.03492160f, -0.17903328f, 
    -0.07902639f, 0.02174400f, -0.12719947f, -0.08486487f, -0.01047808f, -0.01111971f, -0.02726378f, 0.03298287f, 
    -0.00487335f, 0.03308567f, 0.00875336f, 0.06429544f, -0.01639319f, 0.09558880f, 0.02022313f, -0.04430259f, 
    0.10703389f, 0.00089961f, 0.34177586f, -0.02202043f, -0.18754068f, 0.04565818f, -0.06368047f, 0.06523525f, 
    0.02015107f, 0.05598527f, -0.01366678f, -0.10626504f, 0.01314660f, -0.08643198f, -0.05917384f, 0.04506861f, 
    -0.01744165f, -0.09335685f, -0.08272537f, -0.19748311f, 0.19183645f, 0.03296901f, 0.35644612f, 0.28995177f, 
    -0.27788731f, 0.13054994f, -0.06250246f, -0.27797285f, 0.04082261f, -0.12904200f, 0.06656813f, 0.00419093f, 
    0.09851802f, 0.07051445f, 0.03442708f, 0.06334397f, -0.02414495f, -0.01831468f, 0.00995090f, 0.01763430f, 
    0.03171856f, -0.28605017f, 0.24555621f, -0.06760706f, -0.14792500f, -0.21797296f, -0.07362738f, 0.12611911f, 
    -0.03646551f, 0.10692936f, -0.06882930f, -0.00931360f, 0.00773178f, -0.03232929f, -0.00480506f, 0.05244580f, 
    -0.00729611f, 0.00749715f, -0.16931225f, -0.19991983f, -0.09602862f, -0.05948284f, -0.07294437f, 0.16345899f, 
    -0.33709046f, -0.10796947f, 0.03516639f, -0.08255034f, 0.09037350f, 0.09134858f, 0.04090197f, -0.03510746f, 
    0.03066223f, 0.05164900f, 0.03947400f, -0.00102041f, 0.09465067f, -0.03525278f, 0.04642615f, 0.05075286f, 
    0.13386679f, -0.46931931f, 0.29773635f, 0.04096827f, -0.03754200f, -0.18833806f, 0.11191446f, 0.02047005f, 
    0.05463888f, -0.01076214f, -0.08508134f, 0.03111643f, -0.01079411f, 0.08007366f, 0.05458826f, -0.08957218f, 
    0.16753002f, 0.02590189f, 0.10822794f, -0.08851842f, -0.29098108f, -0.11006136f, 0.00475089f, 0.00720725f, 
    -0.00738599f, -0.14170763f, 0.12937236f, -0.08439928f, 0.04427759f, -0.05200462f, -0.02484741f, 0.06768597f, 
    -0.04280248f, 0.04494400f, -0.04150874f, 0.12151632f, -0.11012830f, 0.00772697f, -0.12687919f, -0.15367939f, 
    -0.15996793f, -0.01920144f, 0.01861543f, 0.09505752f, 0.01042466f, -0.00661857f, 0.06237538f, -0.09374820f, 
    0.08896355f, 0.11481069f, -0.07650566f, -0.25301614f, -0.05104714f, -0.00294774f, 0.03983095f, 0.06311520f, 
    -0.01861044f, 0.00753897f, 0.10939709f, 0.15780815f, -0.13018891f, -0.18180788f, 0.02737669f, 0.10322577f, 
    -0.03753975f, 0.01636976f, -0.01168424f, 0.14898396f, -0.02654736f, -0.04604504f, -0.16377306f, -0.00800570f, 
    -0.02617333f, 0.09159028f, -0.02187080f, 0.05831458f, -0.03845352f, 0.08579756f, 0.09883938f, -0.02897660f, 
    -0.31917283f, 0.03477792f, 0.14452739f, -0.02661526f, -0.11212116f, 0.07729398f, -0.03052550f, 0.09222229f, 
    0.13073123f, 0.02309853f, -0.09371267f, 0.02318596f, 0.14209574f, -0.00686849f, 0.08657945f, 0.04974307f, 
    0.05501707f, 0.03401429f, 0.05462516f, -0.06579586f, 0.16683644f, 0.02048892f, 0.02923615f, -0.02691154f, 
    0.02848795f, 0.10376177f, 0.04809876f, 0.03617077f, 0.04495564f, 0.04154221f, -0.08097906f, 0.07269238f, 
    -0.01025372f, -0.14576928f, -0.12844193f, 0.04352563f, 0.01366866f, 0.00296408f, 0.04345721f, -0.00081139f, 
    -0.32877988f, -0.27244276f, 0.03053671f, 0.10199854f, -0.07847523f, -0.00216099f, 0.00908303f, 0.03134410f, 
    0.06371413f, -0.01889689f, -0.02980826f, 0.01104380f, 0.02943612f, 0.08557817f, -0.03189487f, 0.10187189f, 
    0.03992465f, 0.11211199f, 0.21859904f, 0.22122921f, -0.14604950f, -0.12259714f, 0.06233732f, -0.16507623f, 
    -0.15957958f, -0.06186572f, 0.01147266f, -0.45952031f, 0.21585126f, -0.07624198f, -0.00076932f, 0.01977388f, 
    -0.07021528f, -0.14309560f, -0.15163337f, -0.01703921f, -0.01448507f, 0.06761062f, 0.12873328f, -0.05128647f, 
    -0.08638027f, 0.10098360f, 0.12706524f, 0.29502699f, 0.15697624f, -0.00761510f, 0.08815994f, 0.08921712f, 
    -0.22761822f, 0.04907348f, -0.12403219f, 0.02917787f, 0.15638241f, -0.01374739f, -0.22168733f, -0.07556900f, 
    -0.01664568f, -0.22400299f, -0.02139205f, 0.00873592f, -0.27951530f, 0.16198172f, -0.02820563f, 0.03246425f, 
    0.03170781f, 0.00242791f, 0.04387272f, -0.12198314f, 0.09316085f, 0.06398946f, -0.01209403f, 0.07425997f, 
    0.08961840f, 0.01509167f, -0.03006333f, 0.09007428f, 0.07727547f, -0.14090523f, 0.10268565f, -0.01541656f, 
    -0.09760644f, -0.26660955f, 0.06721557f, 0.01762954f, -0.00349663f, -0.07360528f, -0.10579002f, -0.01268585f, 
    0.02759283f, -0.00318724f, -0.07704166f, 0.10390683f, 0.06729189f, 0.03141193f, 0.02446020f, 0.03792837f, 
    0.08328642f, 0.02720419f, 0.06915490f, 0.00761087f, -0.32819828f, -0.07227513f, 0.01988572f, -0.09607232f, 
    0.17913552f, -0.07845663f, -0.06464606f, -0.11270031f, -0.15773292f, -0.02758111f, -0.02781035f, 0.10428773f, 
    0.06274512f, 0.08240925f, 0.06403265f, 0.05211657f, -0.00881122f, -0.19825390f, 0.08895834f, 0.00377886f, 
    0.28384671f, -0.19695650f, 0.07561957f, 0.05003310f, -0.07046110f, 0.04984079f, 0.03007833f, 0.02476067f, 
    0.10704553f, 0.02711730f, -0.01795140f, 0.03480587f, -0.14299600f, -0.08618391f, -0.13364999f, -0.05734816f, 
    -0.06229883f, 0.11317321f, -0.02735160f, -0.03396369f, -0.37086639f, 0.02463843f, 0.21079969f, 0.20799881f, 
    0.11266157f, -0.06466101f, 0.05155063f, -0.17362411f, 0.00493217f, -0.22274478f, -0.01953270f, 0.05189218f, 
    0.07498262f, -0.07314282f, 0.04331192f, -0.04621305f, -0.05753736f, 0.12517042f, -0.10011843f, -0.05560873f, 
    -0.17520532f, -0.34715259f, -0.03945963f, -0.03234375f, 0.17895338f, -0.04172914f, -0.15529785f, 0.10370532f, 
    -0.06944917f, -0.13099280f, -0.05664007f, 0.07955945f, -0.02352725f, -0.02900371f, 0.02721925f, 0.07618234f, 
    -0.10513419f, -0.16121714f, -0.06811990f, -0.01578902f, -0.18827590f, 0.04658666f, -0.28216323f, 0.04907620f, 
    -0.01864869f, -0.08105804f, 0.00477519f, -0.00842545f, 0.01372301f, -0.00935046f, -0.03902637f, 0.06727584f, 
    0.06181901f, -0.06647402f, -0.01412366f, 0.01217358f, -0.00912066f, -0.07954063f, -0.00951704f, -0.08157364f, 
    0.12951110f, -0.10407069f, 0.22354138f, 0.03047801f, 0.01985134f, -0.04499348f, 0.01773295f, 0.04591276f, 
    0.05265317f, -0.07141336f, -0.04141920f, -0.03783904f, -0.05050958f, 0.03603552f, -0.03610950f, -0.06099016f, 
    -0.09427301f, 0.02882176f, -0.15277331f, -0.21825731f, -0.03273406f, -0.10253614f, 0.04522556f, 0.05643234f, 
    -0.08608279f, -0.09170416f, 0.01719558f, 0.00181381f, -0.04362069f, -0.05461799f, 0.01334175f, 0.01469320f, 
    -0.04745880f, 0.04306154f, -0.02124848f, 0.01047906f, -0.09970582f, -0.00630904f, -0.11243600f, -0.14124528f, 
    -0.29823780f, 0.18144923f, 0.25571588f, -0.21707271f, 0.01259778f, -0.16314818f, -0.02813154f, 0.06123680f, 
    0.18396582f, -0.01200863f, -0.08128309f, -0.07911951f, -0.07333649f, 0.05806532f, -0.01563633f, 0.08286887f, 
    -0.03085536f, 0.06025901f, 0.07476714f, 0.07086954f, 0.03881698f, 0.05229614f, 0.35503820f, 0.13396275f, 
    -0.04866796f, -0.02450093f, 0.08775841f, 0.13993098f, 0.11037645f, 0.04712696f, -0.01453354f, -0.09012859f, 
    0.12858340f, 0.01489938f, 0.01854946f, -0.22393930f, 0.03030209f, 0.17422907f, -0.00560065f, -0.00621548f, 
    0.16873588f, 0.03275954f, 0.20866431f, 0.04642532f, 0.01251044f, 0.08238040f, -0.02038330f, 0.09213116f, 
    0.07582212f, -0.02784542f, -0.09481041f, -0.06205944f, -0.04061653f, -0.03547244f, -0.05993029f, -0.07724353f, 
    -0.15662266f, -0.04609013f, -0.15564248f, -0.14800128f, 0.00401370f, 0.28920761f, 0.06867882f, 0.08973684f, 
    0.03247111f, 0.10349531f, -0.07168011f, 0.08378932f, -0.01583517f, 0.03810467f, -0.00706030f, -0.04960678f, 
    -0.03495612f, 0.00622084f, -0.03565310f, -0.00776674f, -0.07307700f, 0.04421192f, 0.03632140f, -0.08419391f, 
    -0.22873449f, 0.04826067f, -0.11814751f, 0.02891409f, -0.01435626f, -0.03636077f, -0.05854702f, -0.13167624f, 
    0.04289386f, -0.00915816f, -0.03954293f, 0.01146027f, -0.00484772f, -0.07347335f, -0.00634394f, 0.00318894f, 
    0.01269879f, -0.05028810f, -0.00954274f, -0.09064950f, 0.17970908f, 0.09461296f, -0.01588069f, -0.12065135f, 
    0.00656812f, 0.07753812f, -0.06480117f, -0.02932980f, -0.02649980f, -0.02122471f, -0.15787742f, 0.09884644f, 
    -0.16528714f, -0.04448082f, -0.09204822f, -0.01663535f, -0.04490791f, -0.01624448f, -0.04123874f, -0.04242610f, 
    -0.23296255f, 0.04587609f, -0.15037808f, 0.01902759f, 0.04996243f, -0.03416087f, 0.00373199f, -0.05692957f, 
    0.09038795f, -0.12021755f, -0.04800440f, 0.08848643f, -0.05004518f, 0.06273683f, 0.08525044f, 0.09833393f, 
    -0.08738340f, -0.13676777f, -0.22154236f, -0.16674602f, 0.01000606f, -0.14852999f, 0.01818198f, 0.01407231f, 
    -0.09587201f, -0.03437421f, -0.04358894f, -0.04049374f, 0.00276333f, 0.05426225f, -0.02833013f, 0.05736773f, 
    0.06528091f, -0.00907686f, 0.10553253f, -0.00592260f, -0.06568855f, 0.03211122f, 0.03657290f, 0.15949032f, 
    0.02221724f, 0.20704643f, -0.05248099f, 0.15848002f, 0.10583820f, 0.01653181f, -0.01554999f, 0.01882979f, 
    0.05709457f, 0.18281688f, -0.06435484f, -0.02755188f, 0.01292019f, 0.04063933f, -0.02216473f, -0.03832386f, 
    0.08388857f, -0.12559314f, 0.04512908f, 0.08695289f, 0.02635057f, -0.17989025f, 0.09454107f, 0.11555974f, 
    -0.04613980f, -0.10918978f, -0.02040794f, 0.03550080f, -0.02665572f, 0.04603896f, -0.00641432f, 0.01305955f, 
    -0.10233257f, 0.07434256f, 0.09223376f, -0.04353869f, -0.02658970f, 0.07940657f, 0.05266500f, 0.12541580f, 
    0.07401428f, -0.08729661f, 0.03668302f, -0.06973853f, 0.00334404f, -0.00219630f, 0.02980348f, -0.08058495f, 
    0.02820088f, -0.00038263f, 0.01926827f, 0.04068121f, 0.00170381f, -0.01302009f, -0.07795922f, 0.00648849f, 
    -0.00722740f, 0.00170939f, 0.05681066f, 0.03007652f, -0.20415995f, -0.48430756f, -0.28074327f, -0.40447772f, 
    -0.29595116f, -0.07431573f, -0.13178171f, -0.13494267f, 0.06141926f, -0.04924425f, -0.13092673f, 0.03640194f, 
    -0.00310634f, -0.09985711f, -0.00803709f, 0.11901253f, 0.02214654f, 0.04986317f, 0.10663792f, 0.00493708f, 
    -0.21527745f, -0.42780250f, -0.02364960f, -0.12747416f, -0.13270922f, -0.05114230f, -0.05649772f, 0.02451032f, 
    0.06265020f, -0.06384680f, -0.16379739f, 0.01992678f, -0.03473193f, -0.06420010f, 0.03759578f, 0.05599747f, 
    0.09379437f, 0.11686791f, 0.12591961f, 0.03751053f, -0.13217540f, -0.20618112f, -0.03058476f, -0.00775938f, 
    0.06811324f, -0.03668692f, -0.04722924f, 0.12331644f, -0.00420440f, 0.02245695f, -0.05357614f, 0.01653757f, 
    0.09387680f, 0.02945183f, 0.03719049f, -0.00930589f, -0.03932009f, 0.14796811f, 0.02067261f, 0.14625317f, 
    -0.25071362f, 0.00879483f, 0.13023074f, -0.04267178f, 0.03679020f, 0.05482792f, -0.03409523f, 0.08588441f, 
    -0.00263433f, -0.12031907f, -0.00021275f, 0.06182607f, 0.09417301f, 0.04040141f, -0.03058047f, 0.12128504f, 
    0.04647280f, 0.02983341f, -0.00859399f, 0.03263882f, -0.31602877f, 0.31529799f, -0.00636366f, 0.13438280f, 
    0.02411446f, -0.01795633f, -0.00876063f, -0.11849762f, 0.17294040f, 0.08285190f, -0.04573027f, -0.07147585f, 
    -0.09623360f, -0.03915010f, 0.03481153f, -0.17383015f, 0.16511515f, -0.34465244f, -0.06840169f, -0.11194422f, 
    -0.18232739f, -0.40368766f, 0.26819324f, 0.03480798f, 0.00168865f, 0.05356677f, -0.11909970f, 0.20138331f, 
    -0.03182115f, -0.20290756f, -0.11266726f, 0.02145965f, 0.06866466f, -0.09257101f, 0.04972909f, 0.03022091f, 
    0.00972138f, 0.20366198f, -0.11919729f, 0.01742746f, -0.27446151f, 0.10564952f, 0.02073579f, 0.12615746f, 
    0.08295966f, -0.00263635f, 0.05629744f, -0.08691005f, -0.02165608f, -0.03390825f, -0.02947421f, 0.00383057f, 
    -0.04995530f, 0.02302601f, -0.03301575f, -0.00782791f, 0.09599803f, -0.08819249f, 0.01480224f, 0.00146969f, 
    -0.13360177f, 0.15665115f, 0.02012884f, 0.17754172f, 0.04049341f, 0.14003623f, 0.00520763f, -0.03753579f, 
    -0.03785748f, -0.00149946f, -0.12036684f, -0.03350407f, 0.05505884f, -0.04111144f, -0.12630647f, -0.06037684f, 
    -0.03422244f, -0.15731414f, -0.05977805f, -0.01901401f, -0.02288927f, -0.03860258f, -0.00425867f, 0.11198071f, 
    0.03029009f, 0.08989991f, -0.00699758f, -0.09604704f, 0.06392903f, 0.11757482f, -0.11972751f, -0.00005193f, 
    0.00971751f, -0.03162025f, 0.06969878f, 0.03373662f, -0.08078935f, 0.02893673f, -0.16432291f, -0.06104967f, 
    -0.14190945f, -0.46410629f, 0.06854296f, -0.28521517f, -0.20295168f, -0.02272982f, -0.26793495f, -0.01435374f, 
    -0.08814810f, -0.01250634f, 0.03983371f, 0.04525472f, -0.04872605f, 0.09716547f, 0.10145271f, 0.18811472f, 
    0.01612146f, 0.07792480f, 0.09656956f, -0.13479717f, 0.00212586f, -0.17435959f, 0.19181967f, 0.19022995f, 
    0.08231152f, 0.01744957f, -0.04328495f, -0.00924990f, 0.06219767f, 0.03266634f, -0.03547458f, -0.04747551f, 
    -0.02541142f, 0.08023049f, -0.02485551f, 0.11003784f, 0.10604281f, 0.03964616f, 0.12991692f, 0.07014786f, 
    -0.20184553f, -0.04719396f, 0.10731047f, -0.08994783f, -0.00403006f, -0.03347560f, 0.01145091f, 0.13475664f, 
    0.07607128f, -0.22187452f, -0.01967561f, 0.06348833f, 0.08786937f, 0.02890594f, -0.01543481f, 0.06582674f, 
    0.03300195f, 0.04759357f, 0.00587373f, 0.05589282f, 0.06239418f, 0.14738506f, -0.25308341f, 0.36966252f, 
    0.11603809f, -0.03546229f, -0.09464139f, -0.01307718f, 0.14381383f, 0.09443738f, -0.12147977f, -0.00035431f, 
    -0.00234913f, 0.03878552f, 0.17202917f, 0.08745135f, -0.00166304f, -0.17433302f, 0.12467996f, 0.11184524f, 
    -0.37241507f, 0.11851867f, 0.04068905f, 0.18863921f, 0.16962495f, 0.03457237f, -0.05024769f, -0.04482952f, 
    0.18465433f, 0.07126868f, -0.04180218f, -0.04929706f, -0.08015626f, -0.14349487f, 0.02529762f, 0.04326631f, 
    -0.08168686f, -0.07482050f, 0.07237754f, 0.10458015f, -0.24597418f, -0.02183989f, -0.49351555f, -0.05115402f, 
    -0.00655111f, 0.11865451f, -0.06267079f, 0.03772778f, -0.11985051f, -0.02994866f, 0.01760374f, 0.03745619f, 
    0.02323598f, 0.01805306f, -0.02798295f, 0.07820541f, -0.06420287f, -0.15197515f, -0.16487077f, -0.22196873f, 
    0.19792165f, 0.02220759f, 0.05239727f, -0.10050696f, -0.01267778f, 0.05886523f, -0.09940358f, 0.02633554f, 
    0.02505920f, 0.00408323f, -0.14091086f, 0.10486867f, -0.15574092f, -0.01621675f, -0.08747176f, -0.05356809f, 
    -0.05235408f, -0.01936191f, -0.03422356f, -0.04433909f, -0.01557082f, -0.17708325f, 0.00804596f, 0.08883759f, 
    -0.10042138f, -0.01638738f, -0.09757321f, 0.08712026f, 0.00849500f, -0.01235528f, -0.05204654f, -0.05812037f, 
    0.12009564f, 0.03480423f, 0.11597098f, 0.02099310f, -0.07713669f, 0.18499812f, 0.01996304f, 0.15913628f, 
    0.01602961f, 0.15682800f, 0.16416299f, 0.11523382f, 0.06401151f, 0.01221158f, 0.01244765f, -0.03616359f, 
    -0.05079451f, 0.04752021f, -0.10197746f, -0.02796501f, 0.00862745f, -0.04209021f, -0.00377208f, 0.03805302f, 
    -0.02885786f, 0.15819183f, 0.04672225f, 0.17587942f, -0.01151765f, 0.13683698f, 0.07148943f, 0.15111032f, 
    0.11297084f, -0.08308107f, 0.03853819f, 0.13944332f, -0.08660118f, 0.06395476f, -0.10453414f, -0.06902144f, 
    -0.05630014f, -0.05036105f, 0.03998604f, -0.04348886f, -0.02410581f, 0.07729922f, 0.07129411f, 0.20046353f, 
    -0.23366034f, 0.12808223f, -0.27509710f, 0.17610286f, -0.02201173f, -0.02472387f, -0.00866906f, -0.07950518f, 
    0.06754572f, -0.00205367f, 0.01278269f, 0.06508879f, -0.06746835f, 0.00871691f, -0.00866771f, -0.06636718f, 
    -0.06057783f, -0.26106149f, -0.27033499f, -0.13530846f, -0.20644550f, -0.05187876f, 0.14117327f, 0.06261776f, 
    0.01034527f, 0.03003287f, 0.08569772f, -0.15688722f, 0.01265030f, 0.06041714f, -0.00568497f, -0.09050886f, 
    -0.03386612f, 0.01145473f, 0.00459828f, 0.00943462f, 0.18942732f, 0.05235964f, 0.13722721f, 0.14689544f, 
    -0.23311217f, 0.08657476f, -0.11464331f, 0.04050981f, -0.13560455f, 0.00625197f, 0.03829929f, 0.04016832f, 
    -0.05110011f, -0.03537156f, 0.09418350f, 0.02868623f, -0.09072112f, 0.06201461f, -0.12317978f, -0.03848993f, 
    -0.11791563f, -0.03228991f, -0.09424192f, -0.19650385f, -0.16428311f, 0.02663237f, -0.26957509f, 0.19327158f, 
    0.02730250f, 0.06783415f, -0.05505525f, 0.14510094f, -0.09309950f, -0.04801545f, 0.04577540f, 0.07553826f, 
    0.05477268f, 0.02036530f, 0.03986193f, 0.00162273f, -0.10883250f, -0.21605234f, -0.27960843f, -0.19229907f, 
    -0.46507025f, 0.25266892f, -0.08812175f, 0.01402458f, -0.08554134f, -0.00266657f, -0.04227147f, -0.07453697f, 
    0.26560581f, -0.00229030f, 0.03229551f, 0.04111894f, 0.04707506f, 0.06991772f, 0.05280175f, -0.11778773f, 
    0.11623266f, -0.09456147f, 0.23353319f, -0.15546970f, 0.00739237f, -0.35182577f, 0.34044430f, 0.02749145f, 
    -0.36795372f, -0.02963248f, -0.13088539f, 0.07361596f, -0.00438888f, -0.18812075f, 0.12222906f, -0.04523848f, 
    -0.09420718f, 0.13569696f, -0.02487363f, 0.03580757f, 0.15686144f, 0.10127553f, -0.11190654f, 0.07274346f, 
    -0.34335434f, -0.26713353f, -0.03508954f, 0.18304341f, 0.12194633f, -0.06771389f, -0.00615429f, -0.20054303f, 
    0.10949283f, 0.14315411f, -0.03941764f, -0.06024134f, 0.05168416f, -0.04460608f, 0.10569112f, 0.02173849f, 
    0.01713717f, -0.11934479f, 0.05961042f, 0.11571179f, 0.09541550f, -0.22074251f, 0.08733071f, -0.04409427f, 
    -0.27246067f, 0.09802816f, -0.09372971f, -0.03441994f, 0.00586878f, -0.06226743f, -0.01897478f, 0.02463727f, 
    -0.03540153f, -0.03942112f, -0.05232134f, -0.03854038f, -0.12506865f, -0.01369762f, -0.03795944f, -0.16981749f, 
    -0.02890191f, -0.21622908f, 0.06577235f, 0.05327280f, -0.05000735f, -0.05140664f, -0.09794486f, -0.15658103f, 
    0.03290483f, 0.03834248f, -0.04938480f, -0.03758602f, -0.07176227f, 0.04829001f, 0.14916129f, 0.01803135f, 
    -0.13796397f, 0.04297775f, -0.09171840f, 0.20094362f, -0.31210962f, -0.01654946f, -0.30494899f, 0.03561736f, 
    0.02123500f, -0.08033812f, -0.02580688f, -0.18993735f, -0.01504577f, -0.08344482f, -0.07185775f, 0.16282599f, 
    0.00131746f, 0.03158228f, -0.04266309f, 0.02892881f, 0.00817659f, -0.16312326f, -0.00283887f, -0.17663492f, 
    0.07341781f, -0.22699559f, 0.13011838f, 0.07566720f, -0.18618821f, -0.05412167f, -0.04476139f, -0.02900959f, 
    -0.06253850f, -0.02900333f, 0.08016596f, -0.00850861f, 0.04416273f, 0.11277864f, 0.02895830f, -0.10405786f, 
    0.08296908f, -0.03283962f, -0.01219564f, 0.02814516f, -0.15128711f, 0.11347349f, 0.13307996f, 0.14342947f, 
    0.02240960f, 0.01316999f, 0.06030489f, -0.10463999f, 0.03148538f, -0.02819550f, -0.08338872f, 0.02936207f, 
    0.06655192f, -0.04760544f, -0.03591027f, -0.02415395f, 0.02701295f, 0.04238377f, 0.04274644f, -0.01211498f, 
    -0.44266924f, 0.09889267f, -0.39879239f, 0.07790098f, 0.01369317f, -0.02795486f, 0.01566170f, -0.01664693f, 
    0.11485411f, 0.07050925f, -0.10542496f, -0.02917648f, -0.07223094f, -0.00137206f, 0.03084866f, 0.08155053f, 
    0.03259009f, -0.10079294f, 0.13963857f, 0.25864419f, -0.05005215f, 0.08053791f, 0.00409093f, 0.18209416f, 
    0.15537921f, -0.01726360f, 0.04975690f, -0.09547377f, -0.03279654f, 0.02329086f, -0.05747613f, -0.00647025f, 
    -0.03023125f, -0.12852284f, -0.05029470f, 0.00576010f, -0.06366917f, -0.02318871f, 0.00722264f, 0.06320867f, 
    -0.52516925f, 0.16977093f, -0.22867566f, 0.05780946f, 0.12665322f, -0.00055378f, -0.08921532f, 0.03812083f, 
    0.07857961f, 0.09208536f, -0.05974667f, -0.00998440f, 0.07810245f, 0.01659606f, -0.02442145f, -0.03878857f, 
    0.02643044f, -0.30646902f, 0.05114271f, 0.15509737f, -0.16250233f, 0.08183984f, -0.15019603f, 0.02733261f, 
    0.08443589f, 0.06258543f, -0.02809330f, 0.03182887f, -0.08325648f, -0.03501404f, -0.01595034f, 0.02151205f, 
    0.02016005f, -0.06596085f, 0.01509840f, -0.01314140f, -0.01377583f, -0.11507574f, -0.04527832f, -0.08631155f, 
    0.12544274f, -0.05102579f, 0.22955205f, 0.05058242f, 0.23044166f, 0.11829594f, 0.13159983f, -0.07203150f, 
    0.00065678f, 0.00539195f, -0.03480512f, 0.06249556f, 0.06014453f, 0.01528263f, -0.08771846f, -0.06378718f, 
    0.13950725f, -0.05241309f, -0.10803498f, 0.04323373f, 0.13190393f, -0.43656087f, 0.34301606f, -0.38695034f, 
    0.00309675f, -0.06321461f, -0.01683362f, -0.03835485f, -0.04064707f, -0.19190788f, -0.07269028f, -0.02231930f, 
    0.04327981f, -0.02702582f, -0.07002728f, 0.14152557f, 0.12291430f, -0.04520157f, 0.04909106f, -0.04264823f, 
    -0.14870800f, -0.19238949f, -0.18706465f, 0.29318324f, 0.13852169f, -0.15576236f, 0.10235130f, -0.00187917f, 
    0.14256054f, -0.09874064f, -0.04907644f, 0.02784531f, -0.01014620f, -0.16253279f, 0.05131103f, -0.16141023f, 
    -0.07214803f, 0.03476807f, -0.11922357f, -0.08177610f, 0.50128293f, -0.21089368f, 0.47897074f, -0.17789207f, 
    -0.01943501f, 0.10668805f, 0.09723016f, -0.20849705f, 0.23323281f, 0.09057899f, -0.06600284f, 0.04505470f, 
    -0.04103622f, 0.01018499f, 0.01332822f, -0.13619374f, 0.17041498f, -0.00873435f, 0.05800056f, -0.08114653f, 
    0.15937950f, 0.01393175f, -0.09798164f, 0.17699546f, 0.00691868f, 0.09459411f, 0.19440456f, -0.00171405f, 
    0.18769380f, -0.13369991f, -0.10543365f, -0.00518342f, -0.05421730f, -0.00300289f, -0.02216913f, 0.04697544f, 
    -0.00610512f, 0.15927178f, 0.01937821f, 0.05546563f, -0.30148026f, 0.03368429f, -0.15611941f, 0.14210771f, 
    -0.13141946f, 0.06894415f, -0.05300556f, -0.04813842f, -0.00919614f, 0.07886568f, -0.03405600f, -0.05212209f, 
    -0.03237746f, -0.04392381f, -0.01230092f, 0.02372756f, -0.02712808f, -0.04864369f, 0.02362051f, 0.04995499f, 
    0.21568646f, 0.14584750f, 0.21319315f, 0.03448462f, -0.11114196f, -0.05925683f, -0.04722994f, -0.05517095f, 
    -0.13149941f, -0.09927712f, -0.05023004f, 0.01591984f, -0.01667367f, 0.04863019f, 0.03213925f, -0.10444354f, 
    -0.11970492f, -0.05487243f, -0.13395147f, -0.14533167f, -0.07695846f, -0.06835213f, -0.11418872f, -0.19040118f, 
    -0.30806401f, 0.05704965f, 0.07589656f, -0.15479724f, -0.03527086f, -0.12769809f, 0.03069603f, -0.05885874f, 
    0.05251253f, -0.02750169f, 0.00836916f, 0.04142859f, -0.02639322f, 0.05401471f, -0.09673104f, 0.02232116f, 
    -0.32853302f, 0.18096344f, -0.06987026f, 0.33564359f, -0.03534432f, 0.09523513f, 0.05044395f, -0.00286867f, 
    -0.05736282f, 0.10122010f, -0.03301480f, -0.14138323f, -0.08369808f, 0.09409504f, 0.09873292f, 0.22199692f, 
    -0.05867162f, 0.15414979f, 0.22013775f, -0.00238553f, -0.16744010f, -0.01713404f, -0.08942495f, 0.25038332f, 
    -0.22116272f, -0.02869703f, -0.15836766f, -0.09549593f, 0.06100247f, 0.10187858f, -0.00902374f, -0.09146011f, 
    -0.13331385f, -0.16309389f, -0.05241382f, 0.02990913f, -0.04860187f, -0.02911177f, -0.08866283f, -0.06233484f, 
    0.15227765f, -0.09513144f, 0.07521676f, 0.00325491f, -0.07619429f, -0.05821614f, 0.05748163f, -0.12052492f, 
    0.07275602f, -0.04988003f, -0.09983434f, 0.04231649f, -0.01994911f, -0.10223419f, -0.09947512f, 0.08961234f, 
    0.02522518f, 0.04432042f, -0.13262284f, -0.01762450f, -0.06033866f, -0.21770854f, -0.15371816f, -0.11060949f, 
    -0.14822628f, 0.06170141f, -0.39536613f, -0.11946874f, -0.20370236f, 0.00383684f, 0.00465229f, -0.00977312f, 
    -0.00504641f, -0.06097412f, -0.13361618f, 0.00217047f, -0.02628314f, -0.00555683f, -0.10284073f, -0.11596392f, 
    -0.52026320f, 0.14115204f, -0.31230262f, -0.02652373f, -0.17249580f, 0.05883872f, 0.06530294f, -0.04707106f, 
    0.03837620f, 0.09009924f, -0.14407313f, -0.04205126f, 0.05861351f, 0.03410682f, -0.06493106f, -0.03976605f, 
    -0.01019093f, 0.04663607f, 0.02585015f, 0.08579291f, -0.23005708f, -0.18039675f, -0.26093069f, 0.25824213f, 
    -0.22041072f, -0.03045069f, -0.08137231f, 0.04067654f, -0.11226392f, 0.01483684f, -0.02690269f, 0.10260142f, 
    0.01678334f, -0.00488495f, -0.09640889f, 0.06960595f, -0.06577789f, 0.05989403f, 0.06774893f, 0.13148907f, 
    0.60428709f, 0.10306335f, 0.48711082f, 0.07533707f, -0.20189966f, 0.01196515f, -0.13675100f, -0.05050841f, 
    -0.00510436f, -0.15977131f, -0.07844175f, 0.01321905f, -0.02514147f, -0.01387960f, -0.01514261f, -0.02881255f, 
    -0.00843333f, -0.00260280f, 0.01862686f, 0.12586558f, -0.07126412f, -0.10995815f, -0.10933750f, -0.17982399f, 
    -0.24645035f, -0.06412976f, 0.04361149f, 0.01442339f, -0.06269065f, -0.00379359f, -0.04000131f, -0.02125461f, 
    0.09707252f, 0.13339402f, 0.03066783f, 0.06141124f, 0.06311131f, 0.00855844f, 0.06841672f, 0.04924826f, 
    -0.05989924f, -0.13826771f, -0.15670097f, 0.14274973f, 0.30297998f, 0.02180506f, 0.04382756f, 0.06838415f, 
    -0.09394599f, -0.06740712f, 0.03619339f, 0.03651535f, -0.02310767f, -0.04867469f, -0.02333321f, -0.02746559f, 
    0.03708359f, 0.09252683f, 0.15734293f, -0.02966320f, 0.10842358f, -0.12442329f, 0.01227617f, -0.12345315f, 
    0.03498062f, -0.05908705f, 0.00192347f, -0.06409308f, 0.00549844f, -0.06467585f, -0.04973258f, 0.05114224f, 
    -0.04078329f, -0.06011754f, -0.05784746f, 0.06348974f, 0.03034233f, -0.00542235f, 0.02297081f, -0.10322411f, 
    0.06379710f, -0.50067723f, 0.36543101f, 0.13734446f, 0.01769514f, 0.23767917f, 0.22847483f, 0.03695161f, 
    -0.06031911f, -0.06943533f, 0.03953300f, 0.03317069f, -0.00626965f, -0.00341171f, -0.06350843f, -0.00769797f, 
    0.02405036f, 0.15586735f, -0.05818263f, -0.05484522f, 0.07038856f, -0.09038533f, -0.21504679f, 0.28915712f, 
    0.45465636f, -0.11258338f, 0.25655457f, -0.16030195f, 0.06678000f, 0.16567963f, 0.12018177f, 0.11873666f, 
    0.01341732f, 0.14661454f, 0.08032674f, -0.00017487f, -0.01537946f, -0.00451445f, -0.12365323f, 0.02370031f, 
    -0.33705419f, -0.39327055f, -0.31507984f, 0.19817026f, 0.37014624f, 0.01835151f, 0.21654247f, 0.17883469f, 
    -0.11492561f, 0.02549118f, 0.08448078f, -0.00162358f, 0.00725690f, 0.08211277f, 0.10571102f, -0.05479810f, 
    0.14488438f, 0.11902082f, 0.10738896f, 0.07131217f, -0.76849556f, 0.08417580f, -0.40985864f, 0.29162455f, 
    -0.03506532f, 0.01417450f, 0.13067120f, -0.01891483f, 0.09863468f, 0.04840256f, -0.15543810f, -0.03636489f, 
    0.05047696f, 0.03184621f, 0.01743009f, 0.00423733f, 0.02936365f, -0.00739018f, -0.08288773f, 0.15180962f, 
    0.08190600f, -0.00783297f, -0.08737817f, -0.25984219f, -0.18099809f, 0.02646952f, -0.07245648f, -0.03803544f, 
    -0.00718342f, -0.05009669f, 0.03618037f, 0.03798129f, 0.08299084f, -0.03499409f, -0.03157859f, 0.01809635f, 
    -0.00746960f, 0.00653689f, 0.05550620f, 0.03883280f, -0.53797609f, -0.02209193f, -0.37229753f, 0.07608845f, 
    -0.41781417f, 0.12927561f, -0.01026848f, 0.05203108f, -0.09469633f, 0.04304172f, -0.07016660f, -0.10218595f, 
    0.05174230f, 0.07936354f, -0.01596500f, -0.00650857f, -0.01177205f, -0.00915925f, 0.02536026f, 0.01376243f, 
    0.32048136f, -0.42287940f, 0.16884774f, 0.07146575f, -0.02089420f, -0.08462950f, 0.04927812f, -0.08251987f, 
    0.09315003f, -0.23648819f, -0.09880347f, -0.12816802f, 0.08603798f, -0.00412973f, 0.00042477f, 0.18082280f, 
    -0.03387659f, 0.08854497f, 0.13980123f, -0.05615402f, 0.04280442f, -0.01771415f, -0.03448942f, 0.14676204f, 
    -0.02205482f, -0.06363726f, 0.05254889f, 0.00750505f, 0.07624592f, 0.01940588f, -0.15357853f, -0.04862494f, 
    -0.00188789f, 0.02449239f, -0.05168427f, -0.04992335f, -0.00675062f, 0.11124066f, -0.11921270f, -0.04608404f, 
    -0.48006555f, -0.14242937f, -0.07158838f, 0.32733318f, 0.14942169f, -0.08541529f, 0.07917574f, 0.11256333f, 
    0.18028423f, 0.14821620f, -0.07545526f, -0.04431691f, -0.04039348f, 0.00956756f, 0.00250884f, -0.01397404f, 
    0.09674908f, 0.16867223f, 0.02533844f, -0.05048592f, -0.02669807f, -0.04441899f, -0.00534872f, 0.01298758f, 
    -0.06796042f, 0.00256861f, -0.01293696f, 0.02199599f, 0.06283898f, -0.01442824f, -0.01070991f, 0.06036485f, 
    -0.01002168f, 0.02737357f, -0.01604741f, -0.00390032f, -0.04210258f, -0.00571079f, -0.08778768f, -0.05335356f, 
    -0.17833854f, -0.10771890f, -0.08796682f, 0.14587088f, -0.09486457f, -0.04222876f, -0.02414566f, -0.06508561f, 
    0.04880361f, 0.01932116f, -0.01147364f, -0.00278312f, -0.01709263f, -0.07941347f, -0.02047894f, -0.00285146f, 
    -0.04363228f, -0.02403927f, -0.04150793f, -0.00978954f, 0.11426905f, 0.03238332f, 0.05274113f, -0.06717066f, 
    -0.08617400f, -0.04241636f, 0.00443246f, -0.03750644f, 0.02700707f, -0.01923447f, -0.13670538f, -0.01057423f, 
    0.02575671f, -0.05340166f, -0.10738169f, -0.00603766f, 0.01115083f, 0.03764195f, -0.11296334f, -0.01958176f, 
    0.24743338f, 0.12356236f, 0.15105340f, 0.01765846f, -0.00445098f, -0.02068764f, 0.13316353f, -0.07804172f, 
    0.00359038f, -0.05899531f, -0.17009462f, -0.00457857f, 0.01136594f, -0.04817032f, -0.03738102f, 0.01729210f, 
    -0.04137599f, -0.05039416f, -0.04234033f, -0.00593922f, 0.16773435f, 0.14061730f, 0.08927182f, 0.14922677f, 
    0.00486004f, -0.15234993f, -0.00141752f, -0.02486298f, -0.07257116f, -0.10712969f, -0.09834570f, 0.04623554f, 
    -0.05804038f, 0.09372210f, -0.02412688f, -0.01636752f, -0.09100474f, 0.14783862f, -0.07880924f, -0.02236741f, 
    -0.03899353f, -0.21805510f, -0.12648827f, 0.04552199f, 0.11901613f, -0.21375744f, -0.16230045f, 0.04820872f, 
    -0.04695355f, -0.12713692f, 0.05872427f, 0.07622921f, -0.03511901f, 0.01809350f, 0.00497816f, 0.03926546f, 
    -0.05498894f, 0.01210755f, 0.02914602f, 0.02888960f, -0.38954091f, 0.15863107f, -0.07570300f, 0.25914297f, 
    -0.03638276f, 0.03049485f, 0.07334758f, 0.09116062f, 0.01847880f, 0.02121259f, -0.13506858f, 0.01447381f, 
    0.03468530f, -0.05451404f, -0.00457407f, 0.16195087f, 0.01953578f, 0.21231970f, 0.11613435f, -0.13637292f, 
    0.51997602f, 0.10042641f, 0.30681252f, 0.21792206f, 0.01219861f, -0.13196063f, 0.08505452f, -0.18417968f, 
    0.02189186f, 0.08636267f, -0.09250093f, 0.04513535f, -0.03667937f, 0.02488953f, 0.05469448f, -0.01973662f, 
    -0.04069936f, -0.11055315f, 0.01296706f, 0.14351420f, -0.07013107f, -0.05127590f, -0.05328830f, 0.07227857f, 
    0.01882865f, -0.07234655f, -0.16700727f, -0.04502014f, 0.01062227f, -0.06357004f, 0.01556984f, 0.04454564f, 
    -0.03059600f, -0.03628073f, 0.06591645f, 0.05548284f, -0.04357563f, 0.09865094f, 0.04648382f, 0.00532836f, 
    -0.32793629f, 0.15002425f, -0.41340709f, 0.33045807f, -0.24876179f, 0.11339046f, 0.06753964f, -0.06268841f, 
    0.01282016f, 0.08453774f, -0.05084835f, -0.09654317f, -0.04143424f, 0.09619818f, 0.06259056f, 0.06634259f, 
    0.00564165f, 0.19657561f, -0.00490018f, 0.05886259f, -0.01462569f, -0.03240196f, -0.00844715f, 0.17572615f, 
    0.00479431f, -0.09494098f, 0.05561499f, 0.02892648f, 0.08579313f, -0.08946388f, 0.00935981f, -0.14231202f, 
    0.08929273f, 0.00932716f, -0.01695927f, 0.00122715f, -0.02446599f, 0.05788329f, 0.06092829f, 0.02830222f, 
    0.05414535f, -0.17313601f, 0.10869855f, -0.17982382f, 0.03982905f, 0.02772158f, 0.06706746f, 0.00609194f, 
    0.04653615f, -0.04365305f, 0.01470028f, -0.04947148f, 0.00962091f, -0.13286477f, -0.05868842f, 0.01363833f, 
    0.02948439f, 0.00398374f, -0.12514372f, -0.07853092f, 0.06425397f, -0.15473215f, 0.16097838f, 0.00270204f, 
    0.01073545f, 0.14384915f, 0.04126601f, 0.07510667f, 0.03885547f, 0.00101829f, 0.09910944f, -0.04532598f, 
    0.00506913f, 0.05462335f, 0.03601349f, -0.00240979f, 0.00253350f, -0.13170183f, -0.01023848f, -0.13425013f, 
    -0.14970967f, -0.18246832f, -0.16772048f, 0.03635745f, 0.07530747f, -0.06972489f, -0.21598944f, -0.05281172f, 
    -0.10315942f, -0.09619406f, 0.04933375f, 0.06463929f, -0.11949930f, -0.01312359f, 0.00205918f, 0.03246846f, 
    -0.05473592f, 0.01178430f, 0.05345855f, -0.09865854f, -0.18058860f, -0.11425183f, 0.08767910f, 0.18799299f, 
    -0.21804073f, -0.04531429f, 0.08609374f, 0.04720659f, -0.02593281f, 0.04017157f, -0.15405463f, 0.02637797f, 
    0.12131421f, 0.08906531f, -0.03758548f, 0.03026484f, -0.01503805f, 0.12193294f, 0.00232225f, -0.06013547f, 
    -0.16235314f, -0.27201033f, 0.13562702f, 0.35926709f, -0.24017526f, 0.05670762f, -0.00685656f, 0.00815332f, 
    0.05716742f, -0.11109192f, -0.12319962f, -0.08947847f, -0.00244414f, 0.12644811f, 0.02105790f, 0.02342962f, 
    0.02074286f, 0.06475493f, -0.03246450f, -0.00240300f, 0.26733562f, -0.22080724f, -0.20072892f, -0.07965565f, 
    0.10744267f, -0.11342254f, -0.19120266f, -0.03546352f, -0.18110912f, -0.09585883f, 0.02542406f, 0.02042151f, 
    0.01665918f, -0.02432581f, -0.02271587f, 0.07540665f, -0.09284684f, -0.02820094f, 0.01847444f, 0.04873945f, 
    -0.26755175f, -0.03894912f, -0.11409064f, 0.05179892f, -0.14709425f, 0.02516996f, 0.11899982f, 0.06573112f, 
    -0.04556356f, 0.05355048f, -0.02847788f, -0.06231567f, 0.07473720f, 0.05177944f, -0.01235943f, -0.05684005f, 
    -0.03257115f, 0.04409595f, 0.00128335f, 0.01038249f, 0.15626372f, -0.03879672f, 0.11335470f, 0.31445712f, 
    0.02319932f, -0.09434993f, 0.08214260f, -0.00387688f, 0.02613729f, 0.02970430f, -0.08531361f, -0.00857385f, 
    0.00533372f, 0.09000966f, 0.02910128f, -0.11592124f, 0.06930807f, 0.03831302f, 0.03193020f, -0.05041505f, 
    -0.23710348f, 0.02541420f, -0.33922639f, 0.26567724f, 0.11615077f, -0.09313907f, 0.05572336f, -0.01376314f, 
    0.08250041f, 0.00944873f, 0.00683027f, -0.04745237f, -0.06400231f, -0.04697263f, 0.00243110f, -0.00390203f, 
    -0.02997006f, -0.06271841f, -0.10117135f, -0.03699223f, -0.14607003f, -0.03100142f, 0.05290924f, 0.14832380f, 
    -0.06201902f, 0.06847581f, -0.12136248f, 0.15064539f, -0.08485366f, -0.00499670f, 0.02921041f, -0.03238665f, 
    -0.10593744f, 0.06519157f, -0.04248776f, 0.09760226f, -0.09250277f, 0.07961493f, -0.13940051f, -0.00400474f, 
    -0.16605636f, -0.26102665f, -0.19863960f, 0.19815721f, -0.02765923f, 0.06922556f, -0.02684174f, 0.00873134f, 
    -0.00041540f, -0.09285268f, -0.08067824f, 0.04656751f, 0.03329310f, 0.05311272f, 0.01724907f, 0.14667472f, 
    -0.06535959f, 0.12459011f, 0.11003985f, -0.06181978f, 0.15208521f, 0.08449923f, 0.01201722f, 0.10155185f, 
    0.11917911f, -0.08291399f, 0.04836206f, -0.08635957f, 0.03897927f, -0.03089738f, 0.02468271f, 0.12987272f, 
    0.00817874f, -0.01081426f, 0.00989841f, -0.11946840f, -0.08606261f, 0.02357262f, -0.09593473f, -0.12919867f, 
    -0.37198800f, 0.05467989f, -0.19958639f, 0.05706040f, -0.01576372f, -0.03656729f, 0.11866231f, -0.07182647f, 
    -0.03925308f, -0.07314155f, -0.18792853f, -0.03607425f, 0.16174553f, 0.09118064f, 0.09649109f, 0.03741593f, 
    -0.08124836f, -0.03340578f, -0.03047522f, 0.02101140f, -0.18657988f, -0.37718263f, -0.27412534f, 0.21807370f, 
    -0.00603491f, 0.02973672f, -0.13884507f, 0.21836767f, -0.25979790f, -0.08371920f, 0.06401742f, 0.07088013f, 
    0.04170232f, 0.06259193f, 0.08266147f, 0.06868118f, -0.07930044f, 0.17796047f, -0.02401133f, 0.13993184f, 
    -0.35172835f, 0.09177195f, -0.30419356f, 0.07271512f, -0.16097315f, -0.06705067f, 0.08995686f, -0.05000409f, 
    0.10012936f, -0.05943396f, -0.15161872f, -0.10050052f, 0.02621893f, 0.02006012f, 0.12818740f, 0.19878052f, 
    0.02928884f, 0.09219712f, -0.06592492f, -0.07918588f, 0.03737187f, -0.06054084f, -0.11006970f, 0.14039241f, 
    0.14335328f, 0.01940920f, 0.13027094f, -0.11515511f, 0.00465996f, 0.03985453f, -0.13079791f, 0.09862697f, 
    -0.05594725f, -0.09213188f, -0.06275896f, 0.13703413f, 0.06681767f, 0.02529407f, 0.05943834f, -0.15226778f, 
    -0.13440616f, -0.47250563f, -0.02104010f, 0.33421567f, 0.03880878f, -0.00338927f, 0.05184538f, 0.06004331f, 
    0.15968040f, -0.23648372f, -0.05771390f, -0.00240103f, -0.08376098f, 0.09275639f, 0.05286726f, -0.23058954f, 
    -0.11170928f, 0.18514726f, -0.02170275f, -0.22443368f, -0.30181748f, -0.08624637f, -0.18582101f, -0.08743181f, 
    -0.05673403f, 0.05724701f, 0.01968979f, 0.06762642f, -0.11670132f, -0.04319091f, 0.03196148f, -0.04197456f, 
    -0.00176119f, 0.17155635f, 0.10211077f, -0.00304264f, 0.03041300f, 0.01741094f, -0.08590139f, 0.01577034f, 
    0.00173976f, -0.04996705f, 0.05785347f, 0.13518909f, -0.10280602f, -0.10106999f, -0.05715289f, 0.04616778f, 
    0.05682181f, 0.02044179f, -0.05077056f, -0.09129307f, 0.08707786f, 0.06719921f, -0.05395842f, 0.01027797f, 
    -0.04043525f, 0.11396420f, -0.01330244f, -0.06659260f, 0.11185218f, -0.19791183f, -0.27420461f, -0.32670939f, 
    -0.07220050f, -0.00223968f, -0.14904459f, -0.02824057f, -0.06204157f, -0.11390418f, -0.03039373f, 0.01339455f, 
    -0.00348599f, -0.05998417f, 0.00903428f, 0.00466103f, -0.04261599f, 0.02494799f, 0.05188808f, -0.04069740f, 
    -0.02272164f, 0.02142653f, -0.02071441f, 0.02699930f, 0.08312874f, -0.04696214f, 0.11341553f, -0.00899858f, 
    -0.06419764f, 0.05061493f, -0.10363801f, 0.04998213f, -0.09491707f, 0.04596029f, 0.00489182f, 0.03577853f, 
    0.06277742f, 0.08404441f, 0.03078855f, -0.06820229f, 0.08462001f, 0.10347991f, -0.27845678f, 0.06014709f, 
    -0.05395159f, -0.04335061f, 0.06674624f, -0.08210603f, 0.05941872f, 0.02395917f, 0.03443344f, 0.04720252f, 
    -0.03590938f, -0.03056742f, 0.06449115f, 0.04185940f, -0.04964318f, 0.13662004f, -0.04608792f, 0.09084367f, 
    -0.13756472f, -0.18732733f, -0.15079618f, 0.26622054f, -0.01902841f, -0.11067902f, -0.20964652f, 0.04503225f, 
    0.01200207f, -0.16276947f, -0.00724002f, 0.01405554f, -0.02748653f, -0.06692944f, -0.05676897f, 0.07016744f, 
    -0.10496528f, 0.01028517f, 0.00643816f, -0.20042719f, -0.26683655f, -0.01838906f, -0.00949256f, 0.15155482f, 
    -0.47946274f, 0.01975581f, 0.01325288f, -0.00460140f, 0.01774735f, 0.05516811f, -0.12645955f, -0.03918067f, 
    0.12975673f, 0.07715403f, -0.07587201f, -0.04391167f, -0.02606993f, 0.05206231f, 0.03129695f, -0.01478320f, 
    -0.24875216f, -0.11333282f, -0.14974505f, 0.40714636f, -0.13099138f, 0.00031954f, -0.28800032f, 0.05836340f, 
    -0.09768751f, -0.04664647f, -0.04359351f, 0.04651547f, -0.07973114f, -0.03539681f, 0.05871514f, 0.10575240f, 
    -0.00364728f, 0.12147741f, -0.04196135f, -0.13378641f, -0.07510586f, 0.01844943f, -0.01573809f, 0.05457747f, 
    -0.14879613f, 0.04366989f, -0.00040860f, 0.02638677f, -0.06038472f, 0.03098479f, -0.03139217f, 0.02456537f, 
    0.10970153f, 0.06850817f, 0.01102069f, 0.06541647f, 0.00529052f, 0.12018177f, 0.04920366f, 0.04135941f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14988045f, 0.11891706f, 0.04648495f, -0.07596596f, -0.07029305f, 0.00986358f, 0.02935972f, -0.05021801f, 
    0.06731266f, 0.01722155f, -0.01437746f, -0.02193476f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
