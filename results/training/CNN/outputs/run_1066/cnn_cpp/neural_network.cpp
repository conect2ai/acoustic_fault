#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.33512950f, -0.51750851f, -0.23986623f, -0.40677729f, -0.23698227f, -0.29577681f, -0.17688514f, -0.43715301f, 
    -0.18535893f, 0.01400485f, -0.00787258f, 0.15282759f, -0.09691892f, -0.26608264f, -0.45282322f, 0.14256671f, 
    -0.02392221f, -0.11367098f, 0.17153044f, 0.09469306f, -0.23759294f, -0.22348060f, -0.33080116f, 0.17013142f, 
    -0.23519769f, -0.64903015f, -0.16537003f, -0.13928103f, 0.53445607f, 0.43523335f, -0.55006069f, -0.50371504f, 
    0.00808204f, 0.10473154f, 0.19703026f, 0.22165847f, -0.01248872f, -0.16048221f, 0.31620327f, -0.05344633f, 
    0.28594753f, -0.00053714f, 0.23510912f, -0.11562122f, -0.32937893f, -0.25327364f, 0.03264971f, 0.01021087f, 
    -0.07294212f, 0.21274805f, 0.40267664f, -0.19459163f, -0.06140626f, -0.29516444f, -0.67151338f, -0.76824927f, 
    0.30199787f, -0.71369040f, -0.60129458f, -0.56653780f, 0.04910101f, -0.18214649f, 0.33676177f, -0.24460070f, 
    0.12363231f, -0.10156975f, -0.41217709f, 0.10023314f, 0.08452477f, -0.09430547f, -0.08038106f, 0.15729152f, 
    -0.12847430f, -0.15477911f, 0.25752705f, 0.25304583f, 0.33775267f, 0.53689158f, -0.99445146f, -0.76384765f, 
    -0.21354093f, 0.02016930f, -0.21827675f, -0.07304163f, 0.57273632f, -0.01423158f, -0.00473846f, 0.30051541f, 
    0.08180792f, 0.27737981f, -0.15685986f, -0.17620194f, 0.05516959f, -0.17440955f, -0.11719540f, 0.00397370f, 
    0.08210619f, 0.27589792f, -0.08478286f, -0.04842288f, -0.74744725f, -0.21459395f, -0.30503070f, -0.48065159f, 
    -0.50791836f, 0.18003529f, -0.19162329f, -0.50096744f, 0.00976228f, -0.06526157f, -0.44804034f, -0.13795921f, 
    -0.05056320f, -0.36578000f, 0.17124923f, 0.02732180f, 0.13865618f, 0.03980407f, -0.09744252f, 0.20012930f, 
    -0.09659403f, 0.25919834f, 0.08225319f, -0.05893543f, 0.10692514f, 0.59249580f, 0.29295924f, 0.19471753f, 
    -0.29136062f, 0.27360085f, -0.55467564f, -0.27875891f, 0.74325293f, -0.47333899f, -0.83976865f, -0.37813494f, 
    -0.09649155f, 0.28976440f, 0.00677934f, -0.21209811f, 0.31209788f, -0.17737149f, -0.07775451f, 0.09015701f, 
    0.01152444f, -0.19391486f, -0.03961373f, 0.15211180f, -0.13845414f, 0.37770492f, 0.46001631f, -0.18737508f, 
    -0.65377188f, -0.61235213f, -0.22441936f, 0.17546909f, 0.24437484f, 0.21237139f, -0.14672016f, -0.30601248f, 
    -0.05652903f, -0.15685259f, -0.19256972f, -0.31576505f, -0.07546686f, -0.35016400f, -0.13142858f, 0.21579814f, 
    -0.07320303f, -0.37350884f, 0.27269676f, 0.27727890f, 0.39040679f, 0.21520831f, 0.44955578f, 0.42571583f, 
    0.63661289f, 0.30691317f, -0.54732394f, -0.31666005f, -0.43953791f, 0.03690576f, 0.00543125f, -0.03686442f, 
    0.09819785f, 0.06410737f, 0.31082612f, -0.13777408f, 0.21901166f, 0.04482054f, -0.11239079f, 0.07092557f, 
    -0.13143477f, -0.05993091f, -0.24058045f, 0.07170197f, -0.02884554f, -0.04786278f, -0.09489883f, 0.15363799f, 
    0.45073503f, 0.52705669f, 0.33345884f, -0.50951350f, -0.33278036f, -0.23732625f, -0.17533380f, -0.19530770f, 
    0.34386617f, -0.04268491f, -0.28395143f, -0.06898991f, -0.10344975f, 0.07007712f, 0.14890859f, 0.01222871f, 
    -0.02952459f, 0.27809191f, -0.33674476f, 0.22986832f, 0.18370692f, -0.15135980f, 0.07720108f, -0.22003533f, 
    0.03016391f, 0.40511808f, -1.20351052f, -0.07543516f, 0.40865469f, 0.23407517f, 0.35366106f, 0.40389749f, 
    -0.40077978f, 0.06594760f, 0.31913260f, -0.01298509f, 0.13983475f, -0.19067253f, -0.04940783f, 0.20208207f, 
    -0.04874012f, -0.10808878f, 0.17760462f, -0.04158159f, -0.37310991f, 0.24175969f, -0.29285890f, -0.18468998f, 
    0.21760888f, -0.06819347f, -0.70244366f, -0.61364555f, -0.21752875f, 0.51898462f, 0.38811761f, -0.15917157f, 
    0.50193864f, -0.68031085f, -0.69917554f, -0.41787833f, -0.24716952f, -0.17170732f, -0.25775465f, 0.14334783f, 
    -0.23964329f, 0.10638934f, -0.17461623f, 0.15460819f, 0.14718921f, -0.01105197f, 0.20533578f, 0.06557141f, 
    0.14937158f, 0.13998398f, -0.07930290f, 0.88984865f, -0.20249267f, -0.02409883f, -0.02966709f, 0.06380197f, 
    0.24921095f, -0.07701567f, 0.00221329f, 0.32117212f, 0.24321638f, -0.29390886f, 0.23982376f, -0.00437937f, 
    -0.20305020f, -0.16692682f, -0.04553644f, 0.05788109f, 0.18621682f, -0.08328927f, -0.32139635f, 0.14216077f, 
    0.15448259f, 0.27298403f, -0.21654187f, -0.26657051f, -0.52870727f, -0.04720164f, 0.30350810f, 0.33974305f, 
    0.15684994f, -0.57491356f, -0.51444530f, 0.28663906f, -0.14113024f, -0.25557512f, -0.24660680f, 0.36078450f, 
    -0.32249242f, 0.43198836f, -0.21224853f, 0.02058395f, -0.18602456f, -0.26763195f, -0.15261216f, 0.06219753f, 
    -0.13533278f, -0.33083063f, -0.19614772f, 0.11373334f, -0.32379228f, 0.25783631f, -0.08642723f, 0.15616354f, 
    0.25666258f, 0.31540394f, -0.46380776f, -0.21101490f, 0.22226901f, 0.01894286f, -0.31397399f, -0.44347447f, 
    -0.37239584f, 0.44923651f, -0.15799788f, 0.29101574f, 0.15866520f, 0.29368845f, 0.18331495f, -0.23351631f, 
    -0.31943455f, -0.17251185f, -0.08770563f, -0.34992123f, -0.07155616f, 0.17143121f, -0.87970436f, 0.03060090f, 
    -0.07373326f, 0.51566708f, 0.31748131f, 0.40602618f, -0.67080146f, -0.61506009f, -0.01230109f, 0.02280524f, 
    -0.22363971f, 0.00373390f, -0.27433118f, -0.13060503f, -0.13174504f, 0.07067548f, -0.17328505f, -0.29346949f, 
    -0.06129715f, -0.10496522f, 0.23539738f, 0.02818366f, -0.39860418f, 0.04779659f, -0.28288949f, -0.26170778f, 
    0.02428118f, 0.43176615f, 0.52712429f, -0.15368862f, -0.23635747f, -0.11227372f, -0.10709114f, -0.15149604f, 
    0.00640417f, -0.08269931f, -0.36048201f, -0.04645335f, 0.34739122f, -0.09315663f, 0.24709049f, 0.28092512f, 
    0.18591006f, -0.06561086f, -0.28212956f, 0.10388992f, -0.20036609f, -0.06912600f, -0.04803295f, -0.30026442f, 
    -0.88076550f, -0.42036000f, -0.16555776f, -0.11797107f, 0.10248812f, 0.33932996f, 0.16703857f, -0.19741601f, 
    0.30254117f, 0.18243998f, -0.03837865f, 0.10261438f, 0.40359983f, 0.39568982f, -0.28227729f, -0.21068442f, 
    -0.06837384f, -0.27595344f, -0.15024112f, -0.18575081f, 0.33553943f, 0.34270841f, 0.38013270f, 0.03239004f, 
    0.16725491f, -0.34433046f, -0.46607929f, -0.51107246f, 0.08947337f, 0.48612341f, -0.35502791f, -0.29014990f, 
    -0.67667150f, -0.63951588f, -0.85384125f, 0.17459683f, 0.22139178f, 0.26677275f, -0.43779776f, -0.34738654f, 
    -0.17873172f, -0.44234017f, -0.21664231f, -0.13442491f, -0.07853884f, -0.04442716f, -0.16644235f, 0.19378249f, 
    -0.05429710f, -0.14902656f, 0.10268859f, 0.46355313f, 0.39204794f, -0.38298395f, -0.02041638f, 0.28923279f, 
    -0.60773116f, -0.37175703f, -0.34090522f, -0.71285212f, 0.26309159f, -0.35519943f, -0.32208508f, 0.40852937f, 
    -0.26023987f, 0.22955835f, 0.22823106f, -0.17220536f, -0.32863399f, -0.34271803f, -0.43303069f, 0.19938709f, 
    0.03690052f, -0.25765064f, -0.18549858f, -0.20629516f, -0.16078049f, -0.14312549f, 0.55019283f, 0.33667776f, 
    0.62101394f, 0.40867302f, -0.35979661f, -0.35555214f, -0.02295762f, -0.31898740f, -0.12766601f, -0.02663760f, 
    0.22893353f, -0.03813267f, -0.10789862f, -0.13236932f, -0.00426208f, 0.21177125f, 0.17769875f, -0.06203537f, 
    -0.24882828f, 0.27534950f, -0.13862510f, -0.18390206f, 0.23113133f, 0.27577010f, 0.28256020f, 0.08914327f, 
    -0.42338470f, -0.15896447f, 0.26605976f, -0.05920961f, -0.15592492f, -0.08704877f, 0.52859032f, -0.27934727f, 
    -0.17493722f, -0.34647197f, -0.10376636f, 0.08283518f, 0.18160522f, -0.02517623f, 0.06333176f, 0.00743504f, 
    0.17245804f, -0.28896704f, -0.41484526f, 0.32012632f, -0.03575869f, -0.84009486f, -0.44414794f, -0.33865404f, 
    -0.53386605f, -0.54385799f, 0.72117895f, 0.33810094f, 0.18860222f, 0.36073044f, 0.63308430f, 0.14252150f, 
    0.00174593f, -0.08419675f, 0.13678987f, -0.07403205f, -0.06389737f, -0.06469588f, -0.11899227f, -0.28503805f, 
    -0.18061459f, -0.09420818f, -0.19237621f, 0.13095465f, 0.10700127f, -0.19000147f, 0.64529115f, 0.07734519f, 
    -0.22664298f, -0.18779419f, 0.36502662f, 0.16598663f, 0.36979070f, -0.15995380f, -0.31611362f, -0.53709209f, 
    -0.10781913f, 0.22511639f, -0.12705900f, -0.24033681f, -0.17294215f, -0.30884740f, 0.24648970f, 0.20404290f, 
    -0.03945569f, 0.09911627f, -0.05642938f, -0.25814974f, -0.30831796f, 0.02811122f, 0.18739042f, -0.00307468f, 
    -0.56190228f, 0.33426061f, 0.20641106f, 0.13738495f, -0.15763620f, 0.52369744f, -0.12342700f, -0.19686356f, 
    -0.19651090f, -0.22452047f, -0.13076746f, 0.14434583f, -0.18707485f, -0.26268855f, -0.02729927f, -0.02095359f, 
    -0.15982948f, 0.34499896f, 0.16956435f, -0.09761655f, -0.33618817f, -0.08686030f, 0.23545304f, 0.34179887f, 
    0.40168741f, 0.18438305f, 0.06049909f, -0.28318781f, 0.12382229f, 0.16564843f, 0.47281682f, -0.40662551f, 
    -0.45657206f, -0.01475140f, 0.19359900f, 0.29632121f, -0.09761690f, -0.13190067f, -0.10426218f, -0.31950074f, 
    -0.32094812f, -0.11338342f, 0.13618021f, 0.26443523f, 0.33614093f, -0.01972911f, 0.08273262f, 0.07579263f, 
    -0.23620671f, -0.35326526f, -0.36582878f, -0.17656496f, 0.18230690f, 0.50111544f, -0.54722017f, -0.19521433f, 
    0.57963794f, -0.27930987f, 0.48276415f, 0.26225170f, -0.13465691f, -0.02871840f, -0.11155208f, -0.08146030f, 
    0.28747541f, -0.17467953f, -0.33868432f, 0.28329790f, -0.03462899f, -0.05232932f, -0.13218231f, 0.39628351f, 
    0.01840491f, 0.03802884f, -0.10274442f, 0.35363844f, 0.04527747f, 0.22443762f, 0.27616918f, 0.18518248f, 
    0.11363291f, -0.12509568f, -0.22344285f, -0.07611445f, 0.17859715f, 0.03923418f, -0.03141943f, -0.12703937f, 
    -0.00917319f, 0.04784008f, -0.04120918f, -0.18796562f, 0.11929957f, 0.10800740f, 0.04287693f, -0.21783558f, 
    -0.10254400f, -0.15559165f, -0.29312724f, -1.09437597f, -0.59865892f, -0.79136914f, -0.17049721f, 0.58115059f, 
    0.60276592f, 0.66704953f, 0.02424644f, 0.19832949f, 0.10228937f, -0.33268163f, -0.43408895f, -0.43155274f, 
    -0.25435254f, 0.10694530f, -0.20758289f, -0.17295837f, 0.33829847f, 0.11211275f, -0.22363947f, 0.15936686f, 
    -0.16749020f, -0.21802941f, 0.04377723f, -0.17007750f, -0.14934959f, 0.15319493f, 0.17050885f, 0.05834553f, 
    0.43848169f, -0.39777780f, -0.42372552f, -0.47065797f, -0.46091792f, -0.37824652f, 0.38878980f, 0.20218842f, 
    0.00088005f, -0.01590334f, 0.11828952f, 0.12045105f, 0.17889962f, 0.12296224f, -0.04442586f, 0.15529719f, 
    -0.09862152f, -0.04087191f, 0.00704364f, 0.00316004f, -0.04268542f, 0.13308299f, 0.04879634f, 0.36921868f, 
    -0.21689296f, -0.51836783f, -0.09974883f, -0.20084029f, 0.24059960f, 0.31840307f, 0.07631684f, 0.12142238f, 
    -0.39662695f, -0.04086773f, -0.20844157f, -0.13401043f, 0.06045766f, -0.05755410f, -0.07873075f, -0.16494796f, 
    -0.27077249f, -0.26364315f, -0.49989504f, -0.43734449f, -0.69142014f, -0.60683769f, 0.68683213f, -0.02075347f, 
    -0.56586319f, -0.58084959f, -0.74829715f, 0.49216342f, 0.06763247f, 0.11752003f, -0.09065937f, 0.20285209f, 
    0.06803171f, 0.14004609f, -0.17049594f, -0.15736943f, 0.17910498f, -0.14642733f, 0.10272190f, -0.00068055f, 
    -0.18808965f, 0.19408567f, 0.38737562f, -0.17798051f, -0.17732482f, -0.07166156f, -0.08651008f, 0.40308288f, 
    0.31084380f, 0.20471349f, 0.39665109f, 0.13635439f, -0.22117727f, -0.12518066f, 0.01565828f, -0.18952535f, 
    -0.10994259f, 0.20269404f, 0.00923187f, 0.14933744f, 0.23848280f, 0.04020386f, -0.00764483f, -0.00062123f, 
    0.06542532f, -0.23581029f, 0.11241458f, 0.08502714f, -0.02580366f, 0.23273784f, 0.26984739f, -0.28602087f, 
    0.44575489f, -0.06306850f, -0.15362965f, -0.32273898f, -0.05388439f, 0.17482093f, -0.35317916f, 0.08782955f, 
    0.24890569f, -0.09512754f, 0.28498611f, -0.02998773f, -0.09515097f, 0.12062287f, -0.00885262f, -0.11759338f, 
    -0.09518502f, 0.29210475f, -0.32270458f, -0.15464161f, 0.09693311f, -0.24154846f, 0.26209685f, 0.11898053f, 
    0.21136843f, -0.17059317f, 0.29494327f, 0.07296944f, 0.00671697f, 0.04582784f, 0.14484090f, 0.18924275f, 
    -0.00992061f, 0.14188112f, 0.33201265f, 0.07109489f, 0.00705728f, -0.10410322f, 0.28023991f, 0.07470760f, 
    -0.05320753f, -0.12239666f, 0.09619802f, 0.07093468f, -0.11635395f, 0.07491071f, 0.01884592f, -0.09016433f, 
    0.29743007f, -0.21112588f, 0.84083641f, -0.42582875f, -0.37933192f, -0.05402782f, -0.37598881f, 0.49263427f, 
    0.18200943f, 0.35361624f, 0.11130679f, 0.15329015f, -0.07179444f, 0.25716975f, -0.07320056f, 0.09525367f, 
    -0.14678985f, -0.02090379f, -0.24264464f, 0.26776960f, -0.08479916f, 0.04467906f, 0.01235421f, 0.00581258f, 
    0.02108346f, -0.18573350f, 0.19285502f, -0.13134600f, 0.53430331f, 0.54743689f, -0.16783696f, -0.26335955f, 
    -0.67370945f, -0.24097951f, 0.24566330f, 0.37214753f, -0.11500686f, -0.26975492f, 0.05200295f, 0.49735212f, 
    -0.27437371f, -0.29217052f, -0.27314040f, 0.14035521f, 0.05231491f, -0.10472406f, 0.22104847f, -0.17808381f, 
    0.33254087f, -0.12257267f, -0.25470886f, 0.11694095f, 0.32173148f, 0.31724072f, -0.08463042f, -0.42164326f, 
    0.23132932f, -0.05901929f, 0.11511946f, -0.19800217f, 0.00266946f, 0.13212052f, -0.12569301f, 0.07686602f, 
    0.17117736f, -0.08053993f, 0.00039326f, 0.08842396f, -0.26571006f, 0.23190334f, -0.08905753f, -0.28811094f, 
    -0.04115383f, 0.10793919f, 0.16573913f, 0.16604127f, -0.12018710f, -0.66311342f, -0.58959985f, -0.17279746f, 
    0.53510398f, 0.50893521f, -0.39096183f, -0.36109054f, -0.28596020f, 0.31760645f, 0.64791709f, 0.26494849f, 
    -0.28331327f, -0.00863474f, 0.21353106f, -0.08635495f, -0.19213000f, -0.24519330f, 0.12217725f, 0.28999382f, 
    -0.39998391f, 0.04113296f, -0.02628700f, -0.00853462f, 0.23431380f, 0.40032983f, 0.44310778f, 0.03949960f, 
    -0.16157562f, -0.49175552f, -0.33808228f, -0.08277477f, -0.39955026f, -0.17425063f, 0.15202360f, -0.07263165f, 
    0.34526888f, 0.18382493f, 0.34551758f, 0.13567302f, -0.02679340f, 0.05570878f, -0.06551740f, -0.12375029f, 
    0.07151624f, -0.22035144f, -0.22078952f, -0.20188671f, -0.00355120f, -0.25910011f, -0.40776455f, -0.69325960f, 
    -0.58103353f, 0.20340623f, 0.00022729f, 0.30201328f, -0.28579855f, -0.09866893f, -0.01574105f, 0.51141167f, 
    0.15209055f, 0.22147118f, -0.32100976f, -0.33302581f, -0.03849741f, 0.01270554f, -0.25194147f, -0.18364811f, 
    -0.31400380f, -0.10124609f, -0.16832426f, 0.11686123f, -0.15964486f, -0.18761918f, -0.14044067f, 0.23155595f, 
    -0.01654893f, -0.65269351f, 0.38520852f, 0.65081292f, -0.23242614f, 0.43635118f, 0.15203713f, -0.33350369f, 
    -0.34201285f, -0.18657880f, -0.26855356f, -0.05770914f, -0.12592758f, 0.14855561f, 0.28794143f, -0.15610707f, 
    0.20660448f, -0.03393907f, 0.03881472f, -0.13289292f, 0.06112185f, -0.44145134f, -0.16858172f, -0.36339700f, 
    -0.85350990f, 0.37061229f, 0.24546556f, 0.28240836f, 0.24105196f, -0.37771538f, -0.57293928f, -0.45753589f, 
    -0.42143485f, -0.14675052f, -0.40035161f, -0.12168568f, 0.26570845f, 0.00806430f, 0.20378660f, 0.24520345f, 
    -0.08252362f, -0.04857378f, 0.12200634f, 0.31225210f, 0.08985988f, -0.17464848f, -0.13995537f, -0.01779126f, 
    -0.31583208f, -0.00217602f, 0.33277699f, 0.45261893f, -0.10133854f, -0.31745771f, 0.11889235f, -0.15576558f, 
    0.07842942f, -0.19034730f, -0.16767482f, 0.09405690f, -0.13955654f, 0.31132588f, 0.06704167f, 0.02283787f, 
    -0.31321824f, -0.17884441f, -0.10550367f, 0.16444933f, -0.14301339f, 0.23183282f, 0.29146153f, -0.26124340f, 
    -0.13021804f, 0.21699958f, -0.25464383f, -0.80738384f, -0.99512899f, -0.26699629f, 0.41192561f, 0.76439202f, 
    -0.18406259f, -0.53850800f, -0.02960870f, 0.22921023f, 0.19957389f, -0.14686692f, 0.18227489f, 0.40198803f, 
    -0.26362911f, 0.21401776f, 0.31834283f, -0.08547238f, 0.15197766f, -0.07919109f, -0.06870831f, 0.12785532f, 
    -0.23607711f, -0.03062321f, -0.13538784f, 0.28349620f, 0.69910067f, -0.16427474f, -0.75505334f, -1.02685940f, 
    -0.42139697f, -0.27697599f, 0.13547303f, 0.35816807f, 0.15898083f, 0.11908412f, 0.26626551f, 0.13870217f, 
    0.16365653f, -0.02166561f, 0.16006446f, 0.19659239f, 0.16416740f, -0.19376771f, -0.11417894f, -0.10550258f, 
    -0.08897591f, 0.02047298f, -0.38638407f, 0.00090315f, 0.04103272f, 0.75768530f, 0.78115463f, 0.16199198f, 
    -0.73371124f, -0.53919840f, 0.11189581f, -0.00305813f, 0.29303601f, 0.07278336f, -0.61569911f, -0.16590032f, 
    0.15890823f, -0.04520779f, -0.17898509f, 0.12826210f, 0.03216664f, 0.33038762f, -0.12948270f, 0.08696013f, 
    -0.25444883f, 0.00498678f, -0.06850775f, -0.26294926f, -0.14066134f, -0.16367394f, -0.58218807f, -0.51547176f, 
    -0.20738938f, -0.00825485f, -0.09849780f, -0.24223660f, -0.76867360f, -0.71258634f, -0.00646510f, 0.15682784f, 
    -0.01826501f, -0.22359951f, -0.22053632f, -0.22955139f, -0.40042144f, -0.34622326f, -0.18976089f, -0.26582077f, 
    -0.40264770f, -0.59639949f, -0.21845828f, -0.13931035f, -0.17390399f, -0.09310086f, -0.31236994f, 0.90607846f, 
    0.17090800f, -0.35615462f, -0.40575743f, -0.34773800f, 0.01672754f, -0.31210673f, -0.09329911f, -0.79119492f, 
    -0.74954385f, -0.12795439f, 0.66962838f, -0.56454372f, 0.03750375f, -0.14163385f, 0.00283372f, -0.17597541f, 
    0.01683732f, -0.17378528f, -0.38842624f, -0.12541679f, -0.10657568f, 0.14077267f, 0.33000475f, -0.07781129f, 
    -1.54824781f, 0.16015935f, 0.40746757f, -0.83316314f, -0.78021264f, 0.04588535f, 0.68368852f, -0.08180277f, 
    0.00954864f, 0.24718839f, -0.15186480f, -0.23123544f, -0.02016419f, -0.54866999f, -0.14520435f, 0.26197034f, 
    0.27253413f, -0.15884934f, 0.26607332f, -0.09778841f, -0.00924188f, 0.03474322f, -0.13392089f, -0.31818968f, 
    -0.12195154f, -0.49728930f, -0.32620394f, 0.12669079f, 0.04037597f, 0.26418433f, -0.26099733f, -0.37701052f, 
    0.02543622f, -0.24814159f, 0.25102925f, -0.28536406f, 0.38493496f, -0.19981472f, -0.19502850f, -0.06847170f, 
    0.25239053f, 0.15605372f, 0.18575247f, -0.09487745f, 0.17302997f, 0.49758217f, -0.24886462f, -0.27456149f, 
    -0.35437962f, 0.13056359f, -0.08687876f, 0.47360551f, -0.31080544f, -0.39842358f, -0.18215142f, 0.16582744f, 
    0.52798891f, 0.31673375f, -0.50100929f, -0.49253261f, -0.06956267f, 0.20947468f, -0.03259567f, 0.45836163f, 
    -0.19931549f, -0.38805997f, -0.45341003f, -0.31213483f, 0.00871003f, 0.02279009f, 0.31906065f, 0.14929163f, 
    -0.32811204f, 0.11982685f, 0.15777509f, 0.30468914f, 0.23615354f, -0.44899866f, 0.20088880f, -0.26903066f, 
    -0.38530633f, -0.15417700f, 0.25777408f, 0.44550374f, 0.31341892f, -0.06170288f, 0.24458930f, -0.13190477f, 
    -0.02577565f, -0.18286087f, -0.16941550f, -0.14814653f, 0.46692458f, -0.21441317f, -0.17465177f, -0.12676938f, 
    0.19472525f, 0.09930093f, 0.07523934f, -0.04580281f, -0.30382493f, -0.02250791f, 0.06326660f, 0.12278513f, 
    0.26470953f, 0.00198417f, 0.22129379f, 0.16363041f, 0.06767577f, 0.24646522f, 0.07901489f, 0.12930785f, 
    -0.03498778f, -0.37340981f, 0.04174715f, -0.14339183f, -0.09547275f, 0.06930704f, 0.12067679f, 0.11507484f, 
    -0.01808832f, -0.26246750f, 0.09206741f, -0.16420296f, -0.23278779f, -1.14467406f, -0.37273574f, -0.40958971f, 
    -0.46921679f, -0.31148052f, 0.21452507f, -0.05437049f, 0.17125791f, 0.29330319f, -0.24119920f, -0.11461018f, 
    0.19143522f, 0.22730441f, 0.36408624f, 0.08366512f, 0.06242413f, -0.33124587f, -0.25982389f, -0.20316689f, 
    -0.03042657f, -0.14462763f, 0.50300813f, 0.22890861f, 0.00529065f, -0.21543594f, -0.17208251f, -0.53651422f, 
    -0.64584446f, -0.61920971f, -0.71633023f, 0.15937455f, 0.03819772f, 0.32241344f, -0.09009960f, -0.30730146f, 
    0.14334460f, 0.00856534f, 0.07980011f, 0.13290325f, 0.00425426f, -0.12651004f, -0.00577601f, -0.05556899f, 
    -0.05225326f, -0.16643545f, -0.36234722f, -0.33212572f, 0.04026265f, -0.04294442f, -0.29402667f, -0.25890204f, 
    -0.07691538f, -0.27108166f, -0.09419122f, 0.28710693f, 0.51325327f, -0.25086677f, -0.46791628f, -0.61897850f, 
    -0.14680628f, -0.21197106f, -0.25120080f, -0.11749827f, 0.27189520f, -0.25798330f, 0.00821072f, -0.06222199f, 
    0.07950810f, -0.01249982f, -0.49476627f, -0.25192338f, -0.27477801f, -0.31326452f, 0.29818219f, 0.57592845f, 
    -0.67805153f, 0.06760829f, -0.49606371f, -0.15880674f, -0.70601183f, 0.19631866f, -0.44801739f, 0.14468756f, 
    0.39475042f, 0.19689722f, -0.37981707f, -0.36731017f, 0.48384145f, -0.55735993f, -0.29274079f, 0.09794653f, 
    -0.12009144f, -0.17388864f, -0.09929391f, 0.36323351f, 0.00711097f, 0.12099078f, -0.12047929f, -0.09927154f, 
    0.10055521f, -0.16581216f, -0.32037535f, -0.33691999f, -0.03833140f, -0.31365368f, -0.65735912f, -0.69349295f, 
    -0.43507415f, -0.42038265f, -0.55645478f, 0.36404410f, 0.37409133f, -0.12476970f, 0.04373247f, 0.26463687f, 
    0.21136992f, 0.17339560f, 0.03220218f, -0.16148119f, -0.28428712f, -0.21466750f, 0.15778138f, 0.11961679f, 
    -0.03503327f, 0.18290301f, 0.66081280f, 0.11511963f, -0.24843176f, 0.07899210f, -0.20462619f, -0.21787071f, 
    -0.07780614f, -0.16096103f, -0.11108790f, -0.37187102f, 0.21006303f, 0.10413227f, 0.12294675f, -0.03343036f, 
    0.14823107f, 0.18671913f, -0.02779035f, -0.29840428f, 0.05488366f, 0.01815031f, 0.01677204f, 0.26311669f, 
    -0.17100635f, 0.17311242f, 0.21931669f, -0.14210907f, -0.31817931f, -0.75635207f, -0.39977708f, -0.14752789f, 
    -0.36972436f, -0.33182177f, -0.27439934f, 0.19793308f, -0.51817280f, 0.23876797f, 0.22365150f, 0.08820669f, 
    -0.14190052f, 0.27065381f, 0.11494935f, -0.19962971f, -0.04081574f, 0.13424073f, 0.10127684f, 0.20629008f, 
    -0.06699960f, -0.01629210f, -0.01479484f, -0.13204233f, 0.34640318f, -0.12579027f, 0.06943334f, 0.04182669f, 
    -0.21589291f, 0.28979599f, 0.25867474f, -0.00963268f, -0.30877796f, -0.08292125f, 0.16846165f, -0.05228275f, 
    0.00255327f, -0.16410051f, 0.14254360f, -0.03680791f, 0.04280013f, 0.09226799f, 0.02724700f, 0.07664573f, 
    -0.43154380f, -0.13439962f, 0.00371151f, 0.21967512f, 0.22935782f, -1.02998304f, -0.47697455f, 0.17026927f, 
    0.64376998f, 0.45884275f, 0.44795647f, 0.65736061f, -0.37117088f, -0.27993834f, 0.27191851f, 0.27787006f, 
    0.08188817f, 0.24751927f, -0.44301179f, -0.33971161f, 0.09752171f, 0.08013222f, 0.02430804f, -0.27508587f, 
    -0.07151280f, 0.10693505f, -0.02086899f, -0.16599686f, -0.05342466f, 0.21763560f, -0.41152915f, -0.16035539f, 
    -0.19435920f, -0.36658153f, -0.73928869f, -0.21862064f, -0.35626811f, 0.01818608f, 0.67787874f, -0.13203602f, 
    0.25334868f, -0.23937298f, 0.08466166f, -0.23113281f, -0.01683004f, 0.05265467f, 0.15669431f, 0.00172334f, 
    0.24372703f, 0.17537813f, -0.19778322f, 0.17620917f, -0.08820520f, -0.10616146f, -0.25332162f, -0.26226160f, 
    -0.42527783f, -0.10825108f, 0.28613135f, -0.18538018f, -0.05415596f, -0.28855470f, 0.10389490f, 0.05811470f, 
    -0.19616005f, 0.27028909f, 0.39018548f, -0.13840835f, 0.28270784f, 0.17612745f, 0.04919215f, -0.01569979f, 
    0.07528751f, 0.23292907f, 0.26523057f, -0.04872604f, -0.14934622f, -0.07770881f, -0.00392039f, -0.28033224f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.30220380f, 0.04969313f, -0.21086438f, 0.37841412f, -0.44778118f, 0.05064396f, 0.00420769f, 0.19302046f, 
    0.34231675f, 0.20277570f, -0.06596020f, 0.12958077f, 0.07934344f, 0.17851578f, 0.29375315f, 0.06050089f, 
    0.03579691f, 0.00547451f, -0.03905688f, 0.20510843f, 0.07520466f, 0.01681902f, 0.07898997f, 0.07898472f, 
    0.26296353f, 0.14109664f, -0.09363801f, 0.13770513f, 0.22970070f, -0.15837221f, 0.41013089f, 0.06761324f, 
    0.29885286f, 0.05522561f, 0.11365381f, 0.26366180f, 0.08838607f, 0.39431709f, -0.13760667f, 0.24728021f, 
    -0.16517876f, -0.01267967f, 0.02499273f, 0.15622593f, 0.38183954f, 0.25653890f, -0.29794046f, -0.04720570f, 
    0.04257687f, 0.17931730f, 0.14086185f, 0.35776699f, -0.24281424f, -0.07061048f, 0.03784835f, -0.15992501f, 
    -0.10966703f, 0.15291817f, 0.11686595f, -0.27062345f, 0.18569551f, 0.31737930f, 0.03440534f, -0.08496600f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.21809268f, 0.16017739f, 0.00952863f, -0.05905404f, 0.16719340f, 0.15618831f, 0.12258295f, 0.08642395f, 
    -0.00303829f, -0.02780257f, -0.03698813f, -0.00536463f, 0.02172960f, 0.28311211f, 0.23371609f, -0.26588821f, 
    -0.15177074f, -0.01365181f, 0.05186440f, -0.14390792f, -0.00046089f, -0.01879083f, -0.19026411f, -0.01009171f, 
    0.23604468f, 0.11078960f, -0.12997355f, -0.19636381f, 0.16283633f, -0.08623460f, 0.16197763f, -0.02688989f, 
    0.00230484f, 0.00504951f, -0.01571964f, -0.05242462f, 0.13206504f, -0.21392223f, -0.13343827f, -0.02541255f, 
    -0.06523170f, -0.01871923f, -0.00891405f, -0.15062730f, -0.10887001f, -0.20161568f, 0.02341950f, -0.00211633f, 
    0.20502260f, 0.24759217f, 0.02988685f, -0.15222999f, -0.00146723f, 0.22882159f, -0.02679668f, -0.05626572f, 
    -0.00378932f, -0.00449152f, 0.04003982f, 0.02767067f, -0.08693244f, 0.01241434f, 0.10526704f, -0.11823007f, 
    -0.05322612f, 0.01929100f, -0.07156706f, -0.00038812f, 0.01138786f, 0.05434816f, 0.01395237f, -0.03032241f, 
    0.09998963f, -0.03233622f, -0.23705812f, 0.02472003f, 0.11463615f, 0.13968691f, -0.04507647f, -0.08950915f, 
    0.00383513f, -0.06173513f, -0.08426580f, 0.01906339f, -0.01986969f, -0.51300687f, -0.12560984f, 0.09222995f, 
    -0.00007143f, 0.07128748f, -0.05250388f, -0.00069699f, -0.10317010f, -0.00018586f, -0.02116016f, -0.02815528f, 
    -0.30429572f, -0.06338537f, -0.07500854f, 0.07661937f, 0.01859113f, 0.09600250f, -0.25225806f, -0.03242509f, 
    -0.02431114f, -0.09547339f, -0.00820576f, -0.06858221f, 0.00093399f, 0.08473852f, -0.14502953f, 0.00814210f, 
    0.04865838f, 0.00239670f, 0.02040982f, -0.03698497f, -0.02957927f, -0.00497324f, -0.07981334f, 0.05567420f, 
    0.43272346f, 0.07200532f, -0.10560787f, -0.22431287f, 0.13486204f, -0.06096045f, 0.14102225f, -0.16127697f, 
    -0.01425616f, -0.01813854f, -0.04029745f, -0.01738034f, -0.29827255f, -0.37042093f, -0.32799992f, -0.03984740f, 
    0.07183398f, -0.04798371f, 0.03985696f, -0.00088519f, -0.02548531f, -0.06252215f, 0.04714727f, 0.00421232f, 
    0.10082073f, 0.07909625f, 0.08618566f, -0.23421198f, 0.00014452f, -0.10129885f, -0.13244702f, 0.00840684f, 
    0.00231711f, -0.01821357f, -0.17166199f, 0.02439672f, -0.42779908f, -0.25929666f, 0.25690055f, -0.06031280f, 
    -0.01205632f, -0.05510137f, 0.05115811f, 0.00757960f, 0.02947844f, -0.05615583f, 0.00797783f, 0.00837958f, 
    0.27772659f, 0.23682155f, -0.04304771f, -0.08634666f, -0.11319771f, -0.00838515f, 0.03206795f, 0.05060544f, 
    -0.06710967f, -0.02634001f, -0.04543751f, -0.14234148f, -0.04401142f, -0.08409385f, 0.16511071f, -0.18338972f, 
    0.05120425f, -0.08771788f, -0.16438402f, 0.04165638f, 0.06004297f, -0.04592757f, -0.08502613f, 0.11257775f, 
    0.08944687f, 0.21510527f, 0.04254684f, -0.08315195f, 0.05775424f, 0.05177833f, 0.08723128f, -0.08757570f, 
    -0.18076923f, -0.10062983f, -0.09760159f, -0.09061322f, 0.33940265f, 0.21114618f, -0.20081794f, -0.12402415f, 
    0.11477729f, -0.07603177f, 0.01607531f, 0.05677525f, -0.00734279f, -0.03552676f, 0.03083755f, -0.10392553f, 
    0.15861908f, 0.06389374f, -0.14639330f, -0.05643465f, -0.02960611f, 0.09555744f, -0.06028609f, 0.00298376f, 
    -0.09364294f, 0.01949080f, -0.00389360f, 0.02786757f, 0.25613317f, -0.25098920f, -0.19258690f, -0.04060874f, 
    0.04141213f, -0.05430793f, 0.06416622f, -0.05260409f, 0.01928869f, -0.09879003f, 0.08360634f, 0.05723137f, 
    -0.22529779f, -0.11397001f, -0.10522151f, -0.13715339f, -0.04785267f, 0.01744472f, -0.09782108f, -0.04521275f, 
    -0.02967540f, -0.05415019f, 0.05274258f, 0.06936892f, -0.04624492f, -0.30032012f, -0.02006424f, 0.04481412f, 
    0.08735005f, 0.06989045f, -0.01732239f, 0.08462981f, 0.01203236f, 0.07454242f, -0.03248980f, 0.05561266f, 
    -0.07669845f, -0.50226057f, -0.34432903f, 0.13546009f, 0.00332612f, -0.04716381f, 0.01624736f, -0.02128478f, 
    -0.00407487f, 0.01401643f, 0.06232395f, 0.00529112f, 0.26707563f, -0.01244822f, -0.10060877f, -0.19826683f, 
    -0.05055310f, -0.05049506f, 0.09757921f, 0.03417445f, -0.08559698f, 0.04037708f, -0.01945424f, -0.00836854f, 
    -0.52857578f, -0.01577645f, -0.30850524f, 0.10471905f, -0.12086559f, -0.07028551f, 0.03886910f, -0.05482551f, 
    -0.04436444f, -0.00229520f, 0.00491346f, -0.00643365f, 0.13651149f, 0.36427975f, 0.01109425f, -0.24284483f, 
    0.01312846f, -0.06259351f, 0.01895066f, -0.04618821f, -0.13637684f, -0.17410082f, -0.13761890f, -0.01412088f, 
    -0.03193865f, -0.03460813f, -0.02417567f, 0.07328860f, 0.07187645f, 0.01613955f, 0.04575307f, 0.02789117f, 
    -0.20397508f, 0.00920862f, 0.16009197f, 0.16067104f, 0.34013969f, 0.07595862f, -0.10436876f, -0.06824202f, 
    -0.03780387f, 0.05970608f, 0.05517688f, -0.13910049f, 0.04872240f, 0.03216530f, -0.02843012f, 0.07836157f, 
    0.08239671f, 0.12758984f, -0.16547923f, -0.03530591f, 0.09299543f, -0.13644220f, -0.12441084f, 0.00210167f, 
    0.04523000f, 0.02026236f, 0.02491005f, -0.03956479f, -0.34056419f, -0.27070788f, 0.09777922f, 0.01270236f, 
    -0.00542376f, 0.05516437f, -0.00381400f, 0.02567760f, -0.06485283f, 0.01088314f, 0.20604356f, 0.09085035f, 
    -0.10725293f, -0.16091362f, -0.25439125f, 0.05712587f, -0.01211625f, -0.00287684f, -0.11904895f, -0.04312555f, 
    -0.14022672f, -0.01230990f, -0.01251716f, -0.09746855f, -0.08445643f, -0.05724145f, 0.00045090f, 0.03438441f, 
    -0.00652065f, -0.02322944f, -0.00782446f, 0.02593593f, -0.03701553f, 0.04060207f, -0.03641866f, 0.04172369f, 
    0.03309868f, -0.23923184f, -0.26929942f, -0.02677127f, -0.06182170f, -0.03018097f, -0.08532695f, -0.12838520f, 
    -0.01587369f, -0.09483819f, -0.17779540f, -0.11013445f, -0.01852364f, 0.00658288f, 0.04594746f, 0.04587464f, 
    0.00815668f, -0.04307291f, -0.00227657f, -0.00852626f, -0.21570703f, -0.27232784f, -0.21670873f, -0.22932103f, 
    -0.09448765f, -0.02187014f, -0.01851702f, 0.07484515f, 0.01358490f, -0.04576256f, -0.03458090f, 0.02087764f, 
    -0.05236911f, -0.08386516f, -0.33922601f, -0.21693723f, -0.55097991f, -0.33201876f, 0.16199744f, -0.04084228f, 
    0.01312099f, -0.00366213f, -0.12726033f, -0.07530756f, 0.02372108f, -0.06097236f, 0.02178889f, -0.02823105f, 
    -0.11533546f, -0.03152952f, -0.07440611f, 0.02358793f, -0.02521519f, -0.01075737f, 0.03513964f, -0.02116233f, 
    -0.07470164f, -0.07137505f, -0.04235919f, 0.03342935f, 0.03955273f, 0.24948020f, 0.21375105f, -0.21768537f, 
    0.01867228f, 0.06122217f, 0.04950262f, -0.17302571f, 0.04933337f, -0.13611299f, -0.12032920f, -0.15969618f, 
    0.11718418f, -0.03382462f, -0.07419337f, 0.04822729f, -0.03860151f, -0.02866068f, 0.02970943f, 0.07896167f, 
    -0.07543585f, -0.02139312f, -0.07119971f, 0.02329266f, 0.23252240f, 0.07298609f, 0.11997484f, -0.14565565f, 
    -0.06540919f, 0.04365903f, 0.06422433f, 0.04828909f, -0.13882725f, -0.05687534f, 0.03420706f, -0.09115881f, 
    0.13843411f, -0.06061823f, -0.04538406f, -0.13890600f, -0.01337119f, -0.07501774f, -0.00081005f, -0.00678765f, 
    -0.03321713f, -0.06612971f, 0.07028439f, 0.18267009f, 0.07525151f, 0.09953000f, 0.06178255f, -0.20464255f, 
    -0.00119466f, 0.00558256f, 0.04015379f, 0.07430618f, 0.02142678f, 0.07579902f, 0.00541191f, 0.02356202f, 
    -0.39945868f, -0.03381302f, -0.52166009f, 0.12808105f, 0.10544909f, 0.03022216f, 0.02057042f, -0.09066828f, 
    -0.02660510f, -0.04212134f, 0.03506757f, 0.03232089f, 0.29797643f, 0.34250903f, 0.15987436f, -0.16245624f, 
    -0.02926127f, 0.02670910f, 0.12300138f, -0.18361609f, -0.02632141f, -0.07903404f, -0.04349283f, -0.02320695f, 
    0.15897629f, 0.03387795f, -0.05050676f, 0.03126653f, 0.03795629f, -0.01423744f, -0.20739475f, -0.07722118f, 
    -0.18757157f, 0.01212354f, 0.00909473f, -0.00224836f, -0.11904620f, -0.49692136f, -0.28162608f, 0.18699472f, 
    0.00514595f, 0.05126015f, -0.27015269f, -0.00493408f, -0.03418444f, 0.04277837f, -0.15044084f, -0.03375371f, 
    0.28409755f, 0.25043589f, 0.16790804f, -0.15979160f, 0.03413830f, 0.07107915f, 0.01054641f, -0.04946381f, 
    -0.27346528f, -0.22926383f, -0.07502031f, 0.05059573f, 0.15342119f, 0.00707071f, -0.29117423f, -0.09247975f, 
    -0.02445548f, -0.11403171f, -0.10164192f, -0.07184733f, -0.04431508f, 0.05749368f, -0.09018259f, -0.03343164f, 
    0.11917128f, 0.34065849f, 0.08464780f, -0.18391493f, 0.01828126f, 0.31768414f, 0.10745211f, 0.20383286f, 
    0.01022280f, 0.06633294f, -0.03923100f, -0.04884605f, 0.16054480f, 0.19975224f, 0.00336894f, -0.22317395f, 
    0.11277091f, 0.07858400f, -0.01380288f, 0.13529423f, -0.00130534f, 0.03037534f, -0.01126881f, -0.04038095f, 
    0.02814592f, -0.03406240f, -0.52704382f, 0.03754776f, 0.07496329f, 0.02864438f, -0.22161807f, -0.12591700f, 
    -0.05159050f, -0.08985294f, -0.11646434f, -0.19209909f, -0.39916632f, -0.38544518f, -0.09846461f, -0.01104258f, 
    -0.00014699f, 0.04781538f, -0.04562269f, -0.00939684f, -0.11227957f, -0.13483769f, -0.22278371f, -0.14780568f, 
    0.00731667f, -0.00489359f, 0.04611615f, 0.01138089f, 0.06264395f, -0.01352363f, 0.00120196f, -0.02234394f, 
    0.00640455f, -0.02166120f, 0.23802875f, 0.12278815f, 0.23535594f, 0.12165147f, 0.00743192f, -0.12091059f, 
    0.06858052f, 0.15068088f, -0.00261860f, -0.15875171f, -0.15758419f, -0.05221136f, -0.02310172f, 0.09014657f, 
    0.17698786f, -0.05758772f, -0.15071584f, -0.09583697f, 0.15190433f, 0.04177463f, -0.12347178f, 0.02801113f, 
    -0.09066670f, -0.04256647f, 0.01717084f, 0.02687230f, 0.22642261f, 0.14803968f, -0.27192906f, -0.05907539f, 
    0.04336171f, -0.13610305f, -0.05942701f, 0.06974708f, -0.04917484f, -0.14899646f, -0.00963800f, -0.08555380f, 
    0.04360151f, 0.23877016f, 0.16501023f, -0.20747526f, 0.14004363f, 0.16852720f, 0.04866978f, -0.07268434f, 
    0.03565103f, 0.04003111f, 0.04696464f, -0.03222339f, 0.24791811f, 0.14916730f, -0.07833300f, -0.17051357f, 
    -0.09929231f, -0.05398513f, -0.10916157f, 0.01260888f, 0.00211884f, 0.02973874f, 0.00486563f, 0.01728756f, 
    0.08053368f, 0.01677667f, -0.11426622f, -0.01310165f, -0.28130165f, -0.06267234f, -0.03924794f, -0.19655710f, 
    -0.06283428f, 0.04555048f, 0.00370136f, -0.03956038f, 0.26598778f, 0.11675886f, -0.13125786f, -0.15376683f, 
    0.06405664f, -0.01644609f, 0.12127828f, 0.04971850f, -0.00149892f, 0.00692113f, 0.04080713f, 0.02087446f, 
    -0.03208262f, -0.01507090f, -0.04558571f, 0.03597036f, -0.03609012f, 0.02428720f, -0.02391242f, -0.12774001f, 
    -0.15419979f, -0.06328016f, 0.00991177f, -0.01165607f, 0.21124615f, -0.02331281f, 0.09521990f, -0.14941846f, 
    -0.06044379f, -0.06865306f, 0.12133651f, 0.01158562f, -0.19308290f, -0.13213383f, 0.03173273f, -0.19747087f, 
    0.17160448f, 0.10809236f, 0.12476676f, -0.17522411f, 0.04934669f, 0.20722219f, -0.05724938f, -0.02333866f, 
    -0.01033907f, 0.03303690f, 0.03261942f, 0.02907544f, 0.09683318f, 0.11067918f, 0.11146808f, -0.05344522f, 
    -0.01359670f, -0.03790630f, 0.01495755f, -0.06149861f, 0.02183673f, 0.08354946f, -0.02764078f, 0.06103375f, 
    0.25763267f, 0.20417017f, 0.02583156f, 0.19913808f, -0.08577972f, -0.05217076f, -0.06303371f, -0.09643768f, 
    0.06102781f, -0.00048814f, -0.05923005f, 0.00273986f, -0.39904082f, 0.03635519f, -0.15694535f, -0.07232772f, 
    0.07516572f, -0.13654068f, 0.07788530f, 0.01777572f, 0.05197119f, 0.04430678f, -0.07534312f, 0.08152868f, 
    0.21895687f, 0.05069301f, 0.14944379f, -0.17408621f, -0.29860425f, 0.11903721f, -0.33506793f, 0.06988499f, 
    -0.01396102f, 0.00794303f, 0.06001939f, 0.07190125f, -0.00768458f, -0.36379060f, 0.00789254f, -0.17817903f, 
    0.04909596f, 0.08729517f, -0.23050736f, 0.11859991f, 0.03695226f, 0.13385881f, -0.00074344f, -0.00375276f, 
    0.16596082f, 0.45011118f, 0.16337408f, 0.16722046f, 0.02559982f, 0.09877668f, -0.16463573f, -0.02434062f, 
    -0.03023317f, 0.02319167f, -0.04271684f, -0.02196034f, 0.35205570f, 0.11697080f, -0.20442103f, 0.03797429f, 
    -0.42870519f, -0.01622578f, 0.22184505f, -0.38941580f, -0.02746809f, 0.01484852f, -0.00395315f, 0.01456247f, 
    0.32460263f, 0.21102543f, 0.14294335f, -0.23705299f, 0.07798900f, 0.15902165f, 0.20106533f, 0.09802669f, 
    -0.01412207f, 0.01863520f, -0.03772198f, -0.17055970f, 0.16651584f, -0.19838931f, 0.10966910f, -0.15516365f, 
    -0.04297663f, 0.06859120f, -0.03182049f, 0.03607458f, 0.11219331f, -0.04710059f, -0.00819779f, 0.05392218f, 
    0.28987956f, -0.08799285f, 0.10333659f, -0.16950648f, 0.07239836f, -0.04269824f, 0.14731707f, 0.06018805f, 
    0.02535756f, -0.00180703f, -0.05522489f, -0.03382452f, 0.40458795f, -0.01135988f, -0.00271238f, -0.00311485f, 
    -0.11111021f, -0.03883222f, -0.01262053f, -0.03903687f, -0.06814729f, -0.07490329f, 0.10765694f, 0.14166011f, 
    0.08886309f, -0.10608582f, 0.23753418f, -0.20307468f, 0.00243151f, -0.02288225f, 0.21876538f, 0.12118029f, 
    0.03777435f, -0.05572412f, 0.02323145f, -0.03672536f, 0.49226949f, 0.20362632f, 0.18858701f, 0.03567108f, 
    -0.02933882f, -0.03348526f, -0.02938755f, 0.01200022f, -0.08124893f, 0.03673859f, -0.01574056f, -0.02617218f, 
    -0.18235204f, -0.40226462f, -0.13693200f, -0.39865789f, -0.00707075f, -0.02717749f, 0.08145351f, 0.07280265f, 
    -0.02067307f, -0.00325034f, 0.08524482f, -0.02048091f, 0.01039973f, 0.06533849f, 0.01808969f, 0.04061218f, 
    0.03638138f, -0.03134592f, 0.06358626f, -0.03190855f, 0.06774424f, 0.13682435f, -0.05347730f, 0.02199826f, 
    -0.16081637f, -0.01367937f, -0.28827536f, 0.07652546f, 0.07703868f, -0.28286031f, 0.00402484f, 0.13852717f, 
    0.05927671f, -0.03223611f, 0.00343885f, -0.09181611f, -0.07454672f, 0.04680389f, -0.00212156f, -0.09685811f, 
    0.08453712f, 0.10462989f, 0.10438336f, 0.05879908f, -0.03325126f, 0.16145128f, -0.05111402f, -0.06223613f, 
    -0.29240587f, -0.03358971f, -0.00184288f, 0.03851832f, -0.05539347f, 0.00697615f, 0.10531363f, 0.17721255f, 
    -0.16097640f, -0.10099526f, 0.07511061f, -0.02020078f, -0.08675793f, -0.16477275f, -0.08688368f, 0.24959886f, 
    -0.13466355f, 0.02936141f, 0.17650302f, -0.03734101f, -0.04027934f, 0.04972499f, -0.04731504f, 0.07212353f, 
    0.13677543f, -0.17274520f, -0.24331944f, -0.03454735f, 0.18537532f, -0.25722882f, 0.18391500f, 0.28875816f, 
    -0.02808050f, 0.17836645f, -0.21642536f, -0.02282965f, 0.14000082f, 0.05835620f, 0.12051756f, 0.17930257f, 
    -0.02386917f, 0.02607433f, -0.05803626f, 0.07250784f, -0.01041363f, 0.18510300f, 0.09746256f, -0.04604441f, 
    0.15438804f, -0.02780639f, 0.14257826f, -0.11599232f, -0.11160388f, -0.05096166f, 0.15076208f, -0.10600000f, 
    0.06280984f, -0.12198415f, 0.02643841f, 0.05098186f, 0.28636131f, -0.02167619f, -0.23694953f, -0.27122009f, 
    -0.00208697f, -0.04303151f, -0.04143919f, -0.07255401f, -0.04393236f, -0.15439633f, -0.02268214f, -0.01810087f, 
    0.36788565f, 0.02879904f, -0.01704559f, 0.16112103f, -0.06444690f, -0.09100824f, -0.03437144f, -0.19143803f, 
    0.10406406f, 0.10275294f, -0.03603594f, 0.10362080f, 0.01795058f, 0.02422209f, -0.04365324f, 0.01203524f, 
    -0.23279603f, 0.06734660f, 0.07489622f, -0.12725124f, 0.10157668f, -0.04935951f, 0.04841240f, -0.06996667f, 
    0.41607228f, 0.03773406f, 0.03417275f, 0.03643419f, 0.01404309f, -0.12178454f, -0.04129833f, 0.07009581f, 
    -0.03206627f, -0.02438543f, -0.03189867f, 0.00017854f, -0.23735397f, -0.10236804f, -0.19059595f, 0.16757733f, 
    0.17363520f, 0.15081578f, 0.15124774f, -0.19174722f, -0.01741062f, 0.10216632f, -0.01901287f, 0.15140608f, 
    0.11981809f, 0.09925395f, 0.10945929f, 0.09642716f, 0.01611672f, -0.04705942f, -0.04313759f, -0.01205338f, 
    0.04444657f, -0.00839675f, -0.00752447f, -0.09043840f, 0.19395529f, -0.06463713f, 0.00732786f, -0.19303830f, 
    0.00508598f, 0.07489697f, -0.06631990f, 0.02924243f, 0.17381062f, -0.02531072f, -0.12606332f, -0.18651475f, 
    -0.07468717f, 0.02724633f, -0.17024119f, -0.04020768f, -0.14209470f, -0.03416852f, -0.00958643f, 0.05195520f, 
    -0.05740435f, 0.09047217f, -0.05251065f, 0.11219517f, -0.03205827f, -0.05516500f, 0.07347663f, -0.12568912f, 
    0.00811987f, -0.00570514f, -0.07219224f, -0.05146846f, -0.53335607f, -0.23773636f, -0.31805009f, -0.24600103f, 
    0.34203616f, -0.33450624f, -0.09897746f, -0.13463515f, -0.00550233f, 0.06179608f, -0.00821476f, -0.03017682f, 
    0.03446116f, -0.00441423f, 0.00468946f, 0.02419398f, 0.12464238f, 0.11979427f, 0.06210079f, -0.00614386f, 
    -0.00918542f, 0.00307670f, -0.05170804f, -0.06674292f, -0.03779265f, -0.01286797f, 0.01536376f, 0.02613986f, 
    0.10207637f, 0.10215012f, 0.00658817f, -0.03299673f, -0.05843588f, 0.01563506f, 0.07920564f, 0.11451528f, 
    0.06081634f, -0.01251934f, -0.02995134f, -0.02746908f, 0.07679453f, 0.11694160f, 0.06618938f, 0.08147443f, 
    -0.01563597f, -0.06742798f, -0.00578757f, -0.01153172f, 0.10261652f, -0.20165506f, 0.05628302f, 0.02342730f, 
    0.55551094f, 0.03841579f, 0.07375795f, -0.00896347f, -0.02595619f, 0.00340882f, -0.00664035f, -0.09036079f, 
    0.04670156f, 0.12767154f, -0.01583385f, 0.03293898f, 0.07515493f, 0.08156793f, 0.08533163f, -0.13054810f, 
    0.07777184f, 0.05812323f, -0.10273334f, -0.12954554f, -0.00160380f, 0.02721966f, -0.02668535f, 0.05103238f, 
    0.11877664f, 0.05488051f, 0.06710579f, -0.02146049f, 0.05530467f, -0.08270651f, 0.03906860f, -0.00259097f, 
    -0.01307778f, -0.00196389f, 0.00814467f, -0.05790393f, -0.45501369f, 0.26930803f, -0.16907339f, -0.05057603f, 
    0.01204087f, 0.11603059f, 0.03725924f, 0.02853205f, 0.00187560f, 0.01000478f, 0.09820787f, -0.10868448f, 
    -0.16134860f, -0.18179563f, -0.06527758f, -0.11428932f, 0.00070743f, 0.01959763f, -0.02208491f, 0.04889153f, 
    0.01610519f, -0.07894893f, -0.05198412f, 0.01911316f, -0.24458852f, 0.03009643f, -0.27868861f, -0.14632522f, 
    0.00768040f, 0.01785521f, 0.02571113f, 0.03291546f, 0.01207100f, 0.07974804f, -0.25317207f, -0.18601510f, 
    -0.06689785f, 0.02306968f, 0.05983663f, -0.14343207f, 0.00354789f, -0.02305485f, 0.03303923f, -0.01218206f, 
    -0.24950491f, -0.38914260f, 0.14956014f, -0.40360019f, 0.00717248f, -0.01136134f, -0.07875942f, -0.32226560f, 
    -0.13714598f, -0.11321580f, -0.16819336f, -0.22722383f, -0.07056394f, -0.04091726f, 0.09335503f, 0.01963987f, 
    0.15839411f, 0.04784887f, 0.08607434f, 0.23187502f, 0.06811313f, -0.02037740f, -0.05338054f, -0.01793452f, 
    0.04261767f, -0.03833963f, -0.01375251f, 0.06594303f, -0.57446718f, 0.00263935f, -0.19132687f, 0.12248840f, 
    -0.18582438f, -0.10564555f, 0.16226591f, 0.04510335f, 0.09238740f, -0.15159342f, 0.01599498f, 0.04949254f, 
    0.01408432f, -0.21601352f, -0.10758749f, -0.02221454f, 0.00093402f, 0.14616139f, -0.04208756f, -0.11695568f, 
    0.25589204f, 0.04511094f, -0.16680141f, 0.01831490f, 0.26439047f, -0.21437061f, 0.19493420f, -0.17791815f, 
    0.05018264f, 0.00971412f, 0.07835931f, -0.04790222f, -0.10591482f, 0.06667825f, -0.22129579f, -0.01312653f, 
    0.12690285f, 0.13264534f, -0.16635628f, 0.10404874f, 0.05597070f, -0.02711706f, 0.04036156f, 0.25318748f, 
    0.01768488f, -0.04000840f, -0.00315117f, -0.18690407f, 0.38076097f, -0.18749556f, -0.20554557f, -0.17673483f, 
    -0.26662582f, 0.00584863f, 0.01814921f, 0.10389601f, -0.04625684f, 0.02407259f, -0.18371949f, 0.14139087f, 
    0.14739051f, 0.00955910f, 0.04333118f, -0.13462749f, -0.03710481f, 0.08377460f, -0.26530340f, -0.20534402f, 
    0.00625290f, -0.00261779f, -0.18236515f, 0.04835666f, -0.30494037f, 0.08711759f, -0.05293617f, -0.04726781f, 
    -0.05245996f, -0.08718069f, 0.11719480f, -0.00519123f, -0.02352979f, -0.05995190f, -0.07134821f, 0.07152884f, 
    0.23721461f, -0.47735313f, 0.06044921f, -0.03846076f, -0.03060836f, -0.03886510f, 0.04789162f, 0.07844954f, 
    0.04410737f, -0.10113557f, 0.07048137f, 0.14843251f, -0.23309688f, 0.09903717f, 0.37529907f, -0.17007555f, 
    -0.05013194f, 0.04717124f, -0.00594650f, 0.00254736f, 0.08058447f, -0.06360973f, -0.03250088f, 0.15879682f, 
    0.05146428f, 0.07540187f, 0.07499246f, 0.06111205f, -0.03276366f, -0.04650286f, -0.05648927f, 0.01028954f, 
    -0.16613081f, -0.16279037f, -0.02267219f, -0.03174466f, -0.44042721f, 0.09746259f, 0.07225504f, 0.09892822f, 
    0.03749285f, 0.09114590f, 0.05271463f, 0.08708175f, -0.13855241f, 0.00205093f, 0.07948900f, -0.04027730f, 
    0.10694590f, -0.05572536f, 0.01016604f, -0.07912715f, 0.03818023f, 0.10904305f, 0.04697621f, -0.14917958f, 
    0.23736402f, 0.07622143f, 0.02619505f, -0.04470370f, 0.04892117f, -0.23719667f, 0.11092686f, 0.43398294f, 
    0.33473921f, -0.06990440f, 0.12990765f, -0.17807972f, 0.14674798f, 0.02542800f, -0.02083140f, -0.06218656f, 
    -0.13643059f, 0.45648986f, -0.16593809f, -0.05220038f, -0.11998010f, 0.11883677f, -0.14807670f, -0.11389506f, 
    -0.05575773f, -0.00133989f, -0.05608879f, -0.10736442f, -0.21684635f, 0.05043119f, -0.10453770f, 0.00148230f, 
    -0.21565488f, 0.05306899f, 0.03496888f, -0.00945685f, -0.03967763f, 0.02003617f, -0.04368206f, 0.05340745f, 
    0.05462929f, -0.02943110f, -0.07878163f, -0.02021164f, 0.04796213f, 0.01174263f, 0.01413162f, -0.01771564f, 
    -0.10083209f, -0.08353898f, 0.01205518f, 0.05610182f, 0.02343599f, 0.08280794f, 0.07412107f, 0.21431075f, 
    -0.13536485f, 0.23053113f, -0.29452765f, -0.20901765f, -0.04107922f, -0.00606767f, -0.00008200f, 0.02563603f, 
    0.11441596f, 0.03295793f, -0.03326644f, 0.06012208f, -0.07442837f, 0.03507202f, -0.00938246f, -0.07337049f, 
    0.22585358f, -0.00383716f, 0.03244228f, -0.01324386f, 0.17202598f, 0.02148138f, 0.02077123f, 0.17890853f, 
    -0.05689350f, 0.02483627f, 0.03372821f, -0.05919909f, 0.07504082f, -0.04142209f, -0.16087183f, 0.17415771f, 
    -0.10051123f, 0.13325679f, 0.09245698f, -0.05733792f, -0.15826914f, 0.14185786f, -0.17778522f, -0.22127363f, 
    -0.02535557f, -0.01916333f, -0.05425938f, -0.04330237f, -0.16201739f, -0.08891907f, -0.09982886f, -0.08085639f, 
    -0.09599387f, 0.11825839f, 0.24693094f, 0.09821956f, -0.08865760f, -0.10511815f, 0.01634220f, 0.00381796f, 
    -0.31756169f, -0.02149816f, -0.11975972f, 0.06398439f, -0.04637261f, -0.01602048f, 0.10229938f, 0.08353392f, 
    0.01680496f, 0.02036154f, 0.01855543f, 0.01529781f, 0.01923830f, -0.11160824f, -0.15308532f, 0.19529115f, 
    0.07104788f, -0.02355665f, -0.18081020f, -0.09223478f, -0.09024129f, -0.06609262f, 0.05322752f, 0.04975539f, 
    -0.79330468f, -0.41149738f, -0.07096171f, -0.24700189f, 0.12115949f, 0.16293508f, -0.13898185f, 0.00853929f, 
    0.01876821f, -0.07052939f, -0.00696099f, -0.04572970f, 0.05516241f, -0.04471213f, 0.18319294f, 0.05199786f, 
    0.06043743f, 0.01050780f, -0.15155116f, -0.21479778f, 0.06387063f, 0.01807025f, -0.03342872f, 0.04619205f, 
    -0.48970467f, -0.40754431f, -0.04266201f, 0.41565382f, -0.10453815f, 0.00354526f, -0.08979837f, 0.04332362f, 
    -0.03108234f, 0.02731218f, -0.04931260f, 0.00241066f, -0.05033425f, -0.24364537f, -0.14932917f, 0.14525539f, 
    -0.28382352f, 0.11114061f, 0.00998145f, -0.15584911f, -0.01080085f, -0.04693004f, 0.06838547f, 0.00488405f, 
    -0.26290229f, 0.02257741f, 0.26456219f, -0.12424560f, -0.11688959f, 0.18853007f, -0.05161747f, -0.06773730f, 
    0.01247010f, -0.10052802f, -0.07378399f, -0.11425126f, -0.07556705f, -0.14464222f, 0.21980217f, -0.15250629f, 
    0.01149485f, -0.04651280f, -0.08701064f, -0.02412417f, 0.00533323f, 0.00628602f, -0.12656865f, 0.20351270f, 
    -0.20301554f, 0.01990402f, 0.27793691f, -0.17058972f, 0.04759693f, -0.02358732f, -0.00182369f, 0.08770051f, 
    -0.01250056f, 0.05831049f, -0.04152450f, -0.01366168f, -0.06520162f, 0.01020680f, 0.14287139f, -0.07116937f, 
    0.01315599f, 0.00934843f, 0.00809184f, 0.07438767f, -0.08934294f, -0.11838906f, 0.08796698f, 0.03568304f, 
    -0.15715182f, -0.22196421f, -0.06118929f, -0.00852443f, 0.03148865f, -0.13463049f, 0.15896109f, 0.07359457f, 
    -0.01886699f, -0.05067792f, -0.02937689f, -0.06521121f, -0.43779045f, -0.02939793f, 0.13833091f, 0.03870009f, 
    -0.00771497f, -0.00995442f, 0.01271048f, -0.00587336f, -0.00696653f, -0.07663319f, 0.03119704f, 0.04224468f, 
    -0.03549222f, 0.07874455f, -0.27324092f, 0.11311564f, -0.03146146f, 0.00716570f, 0.03917666f, 0.08122294f, 
    -0.06420303f, -0.00897559f, -0.04370306f, 0.07719596f, -0.03576153f, 0.09378023f, -0.19718285f, 0.09104595f, 
    0.01720401f, 0.01534910f, 0.04765173f, 0.02953410f, 0.00163731f, 0.02489555f, 0.12270344f, -0.11754969f, 
    0.01676261f, 0.26064804f, -0.08787522f, 0.15150650f, 0.11497332f, -0.04529679f, -0.08121666f, 0.07432759f, 
    -0.04853714f, -0.02017217f, 0.02059051f, 0.01337016f, -0.00520423f, 0.02557269f, -0.08430718f, 0.00326896f, 
    0.06616603f, 0.01285278f, -0.10908838f, -0.01914291f, 0.00266192f, -0.18334979f, 0.13665865f, -0.00271963f, 
    -0.04132410f, -0.29300970f, 0.00575384f, 0.22173829f, 0.10003053f, 0.03308746f, 0.03023520f, 0.01325670f, 
    0.12022804f, -0.27983686f, -0.03762439f, -0.08152988f, -0.35302863f, -0.03329809f, -0.24613638f, -0.18298909f, 
    0.05708777f, -0.05804902f, 0.10217103f, 0.05026681f, 0.01355889f, -0.05088606f, 0.06162368f, -0.10772268f, 
    -0.29679787f, -0.15720031f, 0.16354738f, -0.44301933f, 0.10814258f, -0.22700392f, -0.22596069f, -0.10558303f, 
    -0.03488143f, -0.00705895f, -0.00699421f, 0.10342559f, -0.01539459f, 0.16150627f, -0.17727201f, -0.14249431f, 
    0.02221821f, -0.01748161f, 0.08414346f, 0.05110313f, -0.04174436f, 0.05599537f, 0.05469748f, -0.14018333f, 
    -0.03340533f, 0.03692216f, 0.08065507f, -0.26409772f, 0.11080543f, -0.02741802f, 0.06960450f, 0.10737640f, 
    -0.00370827f, -0.06341008f, -0.02567199f, 0.05221084f, 0.07207465f, 0.36645520f, 0.46923387f, 0.24752232f, 
    0.00495628f, 0.01557360f, 0.10136437f, -0.02869371f, -0.06436747f, -0.11002288f, 0.04692701f, 0.08611925f, 
    -0.07656083f, 0.00894292f, -0.13567054f, -0.18492694f, -0.01950478f, -0.06188566f, 0.03276946f, 0.02576786f, 
    -0.02097658f, -0.03267687f, 0.02779350f, 0.01723485f, 0.03491782f, 0.15994400f, -0.22857174f, -0.10387095f, 
    -0.08543944f, -0.00885605f, -0.01716455f, 0.06012587f, -0.12017719f, -0.01173959f, 0.08633297f, -0.15099949f, 
    0.05261519f, -0.15286592f, 0.01210308f, -0.41044807f, 0.02756093f, -0.08386280f, 0.01720865f, 0.13736740f, 
    0.03421624f, 0.00885323f, 0.02560385f, -0.01615956f, 0.07738500f, -0.06799228f, -0.25827417f, 0.12086490f, 
    0.10816035f, 0.06979705f, 0.04830351f, -0.03493845f, -0.04198964f, -0.03231943f, 0.09739093f, 0.09541087f, 
    0.03422881f, -0.03392940f, -0.07221498f, -0.04987811f, -0.05507593f, -0.10046045f, 0.01444097f, 0.07476492f, 
    0.00410712f, -0.04365212f, 0.01817725f, 0.08466514f, -0.20599279f, -0.07896917f, 0.61864179f, 0.26992559f, 
    -0.02475421f, -0.05635694f, 0.04277022f, 0.10030735f, 0.05659083f, 0.01088400f, 0.02258571f, -0.24399675f, 
    -0.23282446f, -0.01356149f, 0.09472712f, -0.04298434f, 0.03326453f, -0.00102063f, -0.07826030f, 0.08167686f, 
    0.00847002f, -0.00129139f, -0.02478451f, -0.01421776f, -0.07169057f, 0.13771564f, -0.11996688f, -0.00101161f, 
    -0.04350783f, 0.00112164f, 0.03784627f, -0.10476492f, 0.18679942f, 0.18623151f, 0.05753956f, 0.21305192f, 
    -0.01704013f, 0.30126554f, 0.13329133f, 0.04446955f, 0.02222265f, 0.04471059f, -0.09454310f, 0.04834105f, 
    0.14899644f, 0.11736811f, -0.24025705f, 0.08802229f, -0.17402475f, -0.02767376f, -0.00050396f, 0.01451423f, 
    -0.06745350f, -0.10554049f, 0.00396292f, 0.03553355f, -0.01634583f, -0.03991269f, 0.04468708f, 0.02237911f, 
    -0.35759497f, 0.16660994f, 0.00860612f, -0.06401982f, 0.03436127f, 0.04513566f, 0.04950399f, -0.07023077f, 
    0.03839225f, 0.09150856f, 0.03494091f, 0.08738175f, -0.02026640f, -0.06538740f, 0.04767608f, 0.01792160f, 
    0.01666362f, 0.06757510f, 0.02564212f, 0.04371442f, -0.16637951f, -0.06154752f, 0.11910173f, 0.01925518f, 
    -0.22468798f, 0.30644730f, 0.12568873f, 0.01429637f, -0.01087627f, 0.04059614f, 0.03878827f, 0.01091722f, 
    -0.16753368f, -0.08910883f, 0.03711594f, 0.04320951f, -0.00439653f, 0.05256742f, 0.06532206f, -0.11334442f, 
    -0.02013696f, 0.09799714f, -0.09410919f, 0.05202591f, 0.05162126f, -0.03001958f, 0.00265752f, -0.03545791f, 
    0.02208562f, -0.15482602f, 0.06987041f, -0.00780423f, -0.04702910f, -0.01895250f, 0.02403503f, -0.00544643f, 
    -0.05621860f, 0.01578617f, 0.03405206f, -0.05033303f, -0.13906376f, -0.05663517f, -0.25200298f, 0.11685668f, 
    0.02238938f, 0.15240152f, -0.03978748f, 0.11467656f, -0.02187783f, -0.09716853f, 0.07422247f, -0.01996269f, 
    -0.10454142f, 0.14778116f, -0.07390418f, 0.01271200f, -0.00595144f, -0.02562380f, -0.00325236f, -0.30905992f, 
    0.18813080f, 0.02712652f, 0.29020679f, 0.07465024f, 0.05660413f, 0.11221138f, -0.05831937f, 0.09527058f, 
    0.02021055f, 0.00023181f, -0.03643047f, 0.12335479f, 0.05261423f, 0.02265489f, -0.10469134f, -0.02357044f, 
    0.08164185f, 0.09570981f, -0.00971573f, -0.10549449f, 0.03575415f, -0.09895780f, -0.07643579f, 0.04523863f, 
    0.16987632f, 0.17809875f, -0.00106895f, -0.00301963f, -0.27562821f, -0.06955740f, 0.08798134f, -0.14393321f, 
    0.06711029f, -0.02550569f, -0.18168090f, -0.27924183f, 0.03607919f, 0.00810678f, 0.04146056f, -0.04102953f, 
    -0.00642011f, -0.12225863f, 0.05104957f, -0.10087024f, -0.02977456f, -0.10207731f, 0.04451672f, 0.14450189f, 
    0.01347595f, -0.01200001f, 0.00557827f, 0.03290405f, 0.13248880f, -0.07407406f, -0.24573904f, 0.24296160f, 
    -0.07884681f, 0.11441918f, -0.09222601f, 0.14259270f, -0.05492752f, 0.03726931f, -0.02689167f, 0.03340965f, 
    -0.06498674f, 0.25661111f, 0.14017075f, 0.02975396f, -0.05607166f, -0.01195883f, 0.05506615f, 0.10801710f, 
    0.03679785f, 0.12171981f, -0.03710547f, 0.08443612f, -0.06307686f, 0.01832821f, 0.17524643f, -0.25216842f, 
    0.00248155f, -0.07084361f, -0.16080679f, -0.08531810f, -0.00563151f, 0.04238911f, -0.07402530f, 0.08751277f, 
    -0.38870424f, -0.16329412f, -0.02525960f, -0.00885018f, 0.00823383f, 0.01413441f, -0.07895227f, -0.00317241f, 
    0.00238412f, -0.02763510f, -0.12133220f, 0.01614261f, -0.83900672f, -0.15360317f, -0.08670971f, -0.50045371f, 
    -0.10396118f, -0.08927111f, -0.10809638f, -0.37769794f, -0.00044327f, -0.02490509f, -0.08950444f, 0.03827416f, 
    0.54716969f, 0.17492570f, 0.32539606f, 0.26960704f, -0.01603111f, -0.04682819f, -0.14298560f, 0.09722121f, 
    0.03252630f, 0.03282287f, 0.02258492f, 0.02677482f, 0.03740495f, -0.14715002f, -0.09441316f, 0.06852498f, 
    0.02020383f, 0.14254552f, -0.06681595f, 0.12184859f, 0.01018998f, 0.04691579f, -0.03947833f, 0.01354368f, 
    0.17143171f, -0.09244549f, -0.03414272f, -0.20773764f, 0.00555395f, -0.06284107f, -0.01091783f, 0.05455782f, 
    -0.09406675f, -0.01432213f, -0.10514478f, -0.24785273f, -0.15071253f, 0.25687674f, -0.01272167f, 0.02763240f, 
    0.03009678f, 0.02326402f, -0.00668023f, -0.04787147f, 0.03090922f, 0.00723104f, 0.14179265f, 0.01850194f, 
    -0.00599011f, -0.09549050f, -0.02836430f, 0.05736336f, -0.05984263f, 0.01578361f, 0.04542020f, 0.01431090f, 
    -0.01095518f, 0.06407350f, -0.01878473f, -0.05742600f, 0.01567926f, 0.22833787f, 0.21746533f, 0.40338501f, 
    0.01016421f, -0.10074976f, 0.12341372f, 0.04420633f, 0.02187416f, -0.07423718f, -0.02111576f, 0.03151755f, 
    -0.00103597f, 0.28089672f, 0.28840518f, -0.00244383f, -0.18530512f, -0.10648608f, 0.22150435f, -0.16652298f, 
    -0.10457934f, -0.00170695f, 0.03001736f, 0.00576500f, -0.03482578f, -0.16085805f, 0.03440939f, -0.06358092f, 
    0.06291530f, 0.05225939f, 0.03446582f, -0.02519734f, -0.09811904f, -0.10932217f, 0.11695037f, -0.08019199f, 
    -0.18879855f, 0.36882883f, -0.01769745f, 0.67418176f, -0.01723245f, 0.05263932f, -0.03772628f, -0.04640953f, 
    -0.05067757f, -0.00221823f, 0.01738951f, -0.01602816f, -0.36674023f, -0.38024649f, -0.29162359f, -0.08842807f, 
    0.02556181f, 0.07776837f, 0.01218274f, -0.15209986f, 0.01410163f, 0.02297448f, -0.00999832f, 0.02645207f, 
    -0.25612795f, -0.01940090f, 0.09133405f, -0.01412289f, -0.07097072f, -0.14701325f, -0.20820077f, -0.04017077f, 
    0.08980025f, -0.01705196f, -0.00067099f, 0.02840321f, -0.68607551f, 0.13736564f, -0.07987875f, -0.09749391f, 
    -0.09814849f, -0.10022007f, 0.06852833f, 0.00894979f, 0.01385733f, -0.01187656f, -0.01839085f, -0.01311973f, 
    -0.10099321f, 0.01820082f, -0.00173705f, -0.09220139f, -0.01535348f, -0.02272393f, -0.01811122f, 0.00775755f, 
    0.00681452f, 0.04637484f, -0.04488563f, -0.03206878f, -0.05130767f, -0.21192509f, -0.11413200f, 0.03485163f, 
    0.07658406f, -0.04082272f, -0.02703455f, 0.12467993f, -0.01533057f, 0.03709912f, -0.08138663f, -0.04007002f, 
    -0.05605732f, 0.27590832f, -0.14675738f, 0.15852225f, 0.02196602f, -0.01011450f, 0.10508215f, 0.02350461f, 
    0.07322808f, 0.03615575f, 0.02069262f, 0.04383788f, 0.00778218f, 0.00742721f, -0.01513795f, 0.07422177f, 
    -0.01546801f, -0.12513798f, -0.08421081f, -0.01182129f, 0.02696595f, 0.07860304f, -0.00562082f, 0.03248558f, 
    -0.17929086f, -0.06181568f, -0.07564305f, 0.07475003f, -0.02741015f, 0.00420319f, 0.03666278f, -0.09922137f, 
    -0.04941738f, 0.02238467f, 0.05231176f, 0.01935740f, 0.51298618f, 0.06544072f, -0.36665729f, -0.02245202f, 
    0.01262341f, -0.08761853f, -0.02970957f, 0.00985532f, -0.13725884f, 0.03700667f, 0.15245543f, -0.01176920f, 
    -0.12265484f, -0.08087949f, 0.00475667f, 0.20450817f, 0.01783348f, 0.07527725f, -0.00343916f, 0.10911866f, 
    -0.13287164f, -0.01996589f, 0.03133941f, -0.16654663f, 0.14390965f, -0.01543629f, -0.00674883f, 0.23765938f, 
    -0.05513019f, -0.03804757f, -0.04426437f, -0.01028917f, -0.06490181f, -0.20149210f, -0.06632213f, -0.04562547f, 
    0.20305941f, -0.17855689f, -0.03054813f, 0.07583395f, -0.07375424f, -0.03720501f, -0.06845473f, 0.08172704f, 
    0.07959886f, 0.09499140f, -0.16832133f, -0.02302700f, 0.12692946f, -0.13623911f, 0.19117919f, 0.24945277f, 
    -0.04836497f, 0.07976578f, -0.28987792f, -0.07375573f, 0.12688577f, -0.06971987f, 0.22118138f, -0.14581159f, 
    0.07514600f, 0.20161133f, 0.08142959f, 0.30914161f, 0.03776430f, -0.16018417f, -0.04998425f, -0.12148643f, 
    -0.00428010f, 0.00599258f, 0.12115072f, 0.11652019f, -0.35878274f, 0.22097819f, 0.14658776f, -0.11696889f, 
    -0.14914164f, -0.07798200f, -0.27177843f, -0.02810799f, -0.06552090f, -0.06887107f, -0.08722828f, -0.11953505f, 
    0.07108753f, -0.11879316f, 0.34247869f, -0.28602409f, -0.31218848f, -0.01664514f, -0.01222501f, 0.05089383f, 
    -0.03134456f, 0.03382255f, -0.19265297f, -0.12210670f, -0.70887059f, 0.52334732f, -0.07770254f, -0.19028085f, 
    0.26546872f, 0.03569589f, -0.02110391f, -0.23154709f, -0.16392241f, 0.09539090f, 0.01914115f, -0.05248530f, 
    -0.14567041f, 0.23180161f, -0.38526052f, 0.09005853f, 0.08537260f, -0.00617135f, -0.10477462f, -0.01261011f, 
    0.03449648f, -0.07905385f, 0.00158036f, 0.15202515f, -0.48498696f, 0.04126819f, -0.19695918f, -0.04319094f, 
    0.02522538f, 0.20100492f, 0.14031495f, -0.05934855f, 0.01672621f, 0.04611315f, -0.10320815f, 0.01361883f, 
    -0.01704119f, 0.21985328f, -0.06959020f, -0.12504752f, -0.26595432f, -0.00377059f, -0.00985835f, -0.00701931f, 
    -0.06893751f, 0.03515479f, -0.06414431f, 0.09489994f, -0.09134769f, 0.23118384f, -0.23111655f, 0.08444522f, 
    -0.13987535f, -0.25406688f, -0.09958135f, 0.03756057f, -0.02557406f, 0.26578379f, -0.12994187f, -0.07617876f, 
    -0.03027716f, 0.17401707f, -0.15532890f, -0.06853925f, 0.00038052f, 0.08042986f, -0.01320479f, 0.07432609f, 
    -0.12251025f, -0.04312094f, -0.12543553f, 0.11759761f, 0.26594853f, 0.39594564f, 0.18981569f, 0.29335681f, 
    -0.22470468f, -0.13707845f, 0.02861262f, -0.00410075f, -0.04966767f, 0.06072420f, 0.11804052f, 0.16375998f, 
    0.01344863f, -0.06665242f, -0.05765856f, 0.00612695f, 0.14840688f, 0.06687620f, -0.10931789f, 0.03370437f, 
    -0.03836719f, 0.16203238f, 0.03012790f, 0.03601509f, -0.05008041f, 0.02607007f, -0.08684029f, 0.12536645f, 
    0.09045690f, 0.12966272f, 0.08164551f, 0.03715201f, 0.00552737f, -0.10084820f, -0.00339424f, -0.05757406f, 
    -0.00094716f, -0.19987918f, 0.24040112f, 0.08844249f, -0.07191411f, 0.15174079f, -0.13091029f, 0.06696924f, 
    0.08924183f, 0.09391584f, 0.18309882f, 0.07364656f, -0.13038555f, 0.64377606f, -0.33564180f, -0.13515779f, 
    0.07667565f, 0.12496274f, -0.01624930f, 0.06246768f, -0.18431564f, -0.11068165f, 0.04707831f, 0.04229964f, 
    0.02962180f, -0.05018188f, 0.17217226f, 0.05866091f, -0.17038128f, -0.21830268f, -0.01243174f, 0.07810915f, 
    0.07441336f, 0.25249127f, 0.09469184f, -0.11803173f, 0.21840681f, -0.29122344f, 0.12148406f, 0.09875759f, 
    0.16653328f, 0.11653478f, 0.13164903f, -0.14423554f, -0.15860477f, 0.04211782f, -0.05422008f, -0.00207296f, 
    -0.00793551f, 0.39923617f, 0.28630507f, 0.38992378f, -0.05146929f, -0.20988367f, 0.11277869f, -0.02984981f, 
    0.10510948f, 0.00936196f, -0.08975952f, 0.07347018f, -0.65692335f, 0.47231436f, -0.26685044f, -0.00190996f, 
    0.16537316f, -0.15442799f, -0.02658804f, -0.08769756f, -0.04444442f, -0.25832477f, -0.00757229f, -0.10738662f, 
    -0.26748919f, 0.14341715f, -0.13796102f, 0.05073171f, -0.06180749f, -0.14340270f, -0.09253293f, -0.11388076f, 
    -0.08435481f, -0.19513917f, 0.06237394f, 0.09340246f, 0.07180738f, 0.06384221f, -0.32899743f, -0.24930233f, 
    -0.00166531f, 0.10016741f, -0.04027172f, -0.25232399f, -0.08388316f, 0.03813376f, 0.00108726f, 0.01644026f, 
    -0.06918804f, 0.00660436f, -0.02800667f, 0.04122596f, -0.08652577f, 0.05176441f, 0.04156553f, -0.06072887f, 
    0.11639789f, 0.02273108f, 0.09061984f, 0.07724669f, 0.21144515f, 0.23941731f, -0.15669882f, -0.03373707f, 
    0.23779111f, -0.00298857f, 0.07218535f, -0.05326723f, -0.18670551f, -0.01035784f, 0.09326050f, -0.04333898f, 
    0.14600231f, -0.05302094f, 0.09225391f, 0.03427033f, 0.00103760f, 0.12536334f, -0.01827073f, 0.00879961f, 
    0.05982517f, -0.00889243f, -0.04011814f, 0.13142917f, 0.20346318f, -0.08609678f, 0.12340476f, -0.08331133f, 
    -0.03604014f, 0.12206380f, -0.10759309f, 0.02819106f, -0.04311025f, 0.18066846f, 0.01549872f, -0.14289676f, 
    -0.24892099f, -0.02424845f, 0.05614836f, 0.28529233f, -0.05917868f, 0.04732532f, -0.07998985f, -0.12072787f, 
    -0.03577386f, -0.00609085f, -0.05783379f, 0.10104933f, -0.22898580f, -0.24939017f, -0.14166586f, -0.10109530f, 
    -0.13180609f, -0.16642019f, -0.03241508f, -0.11284522f, 0.10482325f, -0.00823257f, -0.01015851f, 0.08452593f, 
    -0.26505369f, -0.04353087f, 0.10572102f, 0.04515721f, 0.05718122f, -0.02635849f, 0.08248957f, -0.10597012f, 
    -0.14642020f, 0.10186252f, 0.04002652f, -0.08833534f, -0.20449555f, -0.10673261f, -0.43019760f, -0.18585494f, 
    0.14021704f, 0.16000031f, -0.02680007f, -0.07888973f, -0.14849046f, -0.18518424f, 0.02844638f, -0.02400686f, 
    -0.19308420f, -0.09885313f, -0.06980866f, 0.01538286f, 0.22493465f, 0.15894914f, -0.03758343f, -0.02898750f, 
    0.02495149f, 0.04135815f, 0.19025414f, -0.16463470f, 0.46008801f, -0.17404404f, 0.08736078f, -0.30307636f, 
    -0.25265330f, -0.20236433f, -0.16025233f, 0.01150525f, -0.07304391f, 0.00739722f, -0.15780061f, -0.01299294f, 
    -0.07950920f, 0.16955750f, -0.18532050f, 0.03926060f, 0.07391853f, -0.16255780f, -0.25471330f, -0.13297960f, 
    -0.07762318f, -0.03387732f, -0.00561802f, -0.15674317f, 0.07241650f, -0.02389654f, -0.04935503f, -0.08307185f, 
    -0.06614070f, -0.09307101f, -0.03966680f, -0.19750971f, 0.00004544f, -0.05744246f, 0.07053596f, -0.14479230f, 
    -0.15204969f, -0.03489000f, -0.09240438f, 0.04586598f, 0.03406461f, 0.08983666f, 0.06287433f, 0.05082561f, 
    0.00382929f, 0.03671999f, 0.04233808f, 0.21196061f, -0.03885934f, 0.01131574f, -0.05529856f, -0.13397546f, 
    -0.03507396f, 0.00634519f, -0.12096620f, -0.07548305f, -0.09006699f, 0.01001919f, 0.01537204f, -0.06231859f, 
    -0.24593282f, 0.33392674f, -0.02171201f, 0.47377974f, 0.02716873f, 0.10597961f, 0.04091433f, -0.08842020f, 
    -0.07898135f, 0.00911620f, 0.01654542f, 0.09379684f, -0.02102401f, -0.18637943f, 0.02733790f, 0.12965117f, 
    -0.02901036f, 0.20446824f, -0.08965680f, -0.09844986f, 0.12142097f, -0.09340470f, 0.02145186f, 0.04828197f, 
    -0.04942530f, 0.17169140f, 0.39075583f, -0.29910874f, -0.16249318f, -0.05754619f, 0.00504536f, -0.08289716f, 
    0.01261814f, 0.10850045f, 0.00565516f, 0.19694982f, -0.22799522f, 0.35460222f, -0.46511677f, -0.47642207f, 
    0.13165465f, 0.01954082f, -0.01017955f, -0.03180548f, 0.15158589f, 0.02052270f, -0.20298295f, -0.02883007f, 
    -0.16816604f, -0.06229301f, -0.03520242f, 0.36051264f, -0.06679048f, 0.08622433f, 0.01484583f, -0.06405890f, 
    -0.14538255f, 0.00407173f, -0.13707300f, 0.05770458f, -0.08838557f, -0.05451746f, 0.37400180f, 0.15653555f, 
    -0.12622549f, -0.05095485f, -0.12109649f, 0.05581068f, 0.06146999f, 0.05694357f, -0.08720104f, 0.12952326f, 
    -0.07205938f, -0.02441942f, -0.10434384f, 0.06954967f, -0.00700391f, 0.01613675f, -0.01960968f, -0.04453117f, 
    -0.02617568f, 0.08892097f, -0.07173005f, -0.06190908f, -0.14028224f, -0.12438907f, 0.13620363f, 0.23654534f, 
    0.11511269f, -0.04390357f, 0.25911671f, 0.07760645f, 0.04265605f, -0.03253645f, 0.04309383f, -0.01969970f, 
    0.57289946f, -0.14930506f, 0.18944955f, 0.06608664f, 0.10782629f, -0.06184232f, -0.22980569f, -0.05671499f, 
    -0.06924184f, 0.02768084f, 0.15146610f, 0.04970061f, 0.04188953f, -0.02420657f, -0.09548228f, -0.10673659f, 
    -0.10318290f, 0.05974748f, -0.05000148f, -0.11814306f, -0.07699830f, 0.04259523f, -0.22093396f, 0.04587101f, 
    0.19066870f, -0.00724468f, -0.07126231f, 0.33252949f, 0.08165623f, -0.06874260f, 0.18197358f, -0.00129325f, 
    -0.08566856f, 0.02656725f, 0.15306273f, -0.21085013f, -0.06323653f, -0.06993947f, -0.00988323f, 0.02071423f, 
    -0.05928769f, -0.08947374f, -0.02975508f, -0.06439511f, -0.04738130f, 0.15155077f, -0.01464195f, -0.08137873f, 
    -0.07363936f, -0.06710424f, -0.13797686f, -0.22555327f, 0.15652451f, 0.00947752f, 0.16303138f, -0.03657704f, 
    0.01788662f, 0.13980669f, -0.11312772f, -0.05402188f, 0.17974526f, -0.12793697f, -0.04753316f, 0.18632454f, 
    0.01010256f, 0.00534156f, -0.02289755f, 0.04972528f, -0.06181445f, 0.02552663f, 0.05816156f, 0.04789563f, 
    -0.17122960f, -0.19763809f, -0.04001708f, 0.23566112f, 0.07064230f, 0.00029780f, 0.07830239f, -0.06917515f, 
    0.02071829f, 0.03787053f, 0.00287321f, 0.06044919f, -0.07492857f, -0.02813212f, -0.03896917f, 0.10443509f, 
    0.00037227f, -0.08250722f, 0.00160205f, -0.09057253f, -0.18119484f, 0.01234335f, 0.00512732f, -0.05403539f, 
    0.32903573f, -0.13368860f, -0.11167266f, 0.09150846f, -0.06405660f, -0.05679245f, -0.12709250f, 0.11493827f, 
    -0.05307446f, 0.08421913f, 0.03820182f, 0.16834188f, 0.03386381f, -0.21576560f, -0.16512460f, 0.04688912f, 
    0.07539316f, 0.10304437f, -0.00325831f, 0.09291113f, 0.10005806f, -0.06209954f, -0.05080868f, -0.05996961f, 
    -0.24531636f, 0.00528771f, 0.08862252f, 0.24205008f, 0.12096275f, 0.00646705f, -0.11005731f, 0.03592530f, 
    -0.02951390f, -0.06476757f, -0.03836586f, -0.13966206f, -0.02331340f, -0.11906743f, -0.17420223f, 0.06233157f, 
    0.03346262f, 0.04080116f, 0.06785455f, 0.16182412f, 0.03580011f, -0.08889300f, 0.14884041f, -0.11112945f, 
    -0.35640514f, 0.08256941f, -0.11804001f, 0.18169688f, 0.08542654f, -0.32283661f, -0.05864304f, -0.07007540f, 
    -0.02223482f, -0.06933189f, -0.29137594f, -0.13213503f, -0.40566176f, 0.49513620f, -0.27590254f, -0.75659114f, 
    0.22379331f, 0.02820779f, -0.10083278f, 0.03763278f, -0.25762534f, 0.04266088f, -0.06655727f, -0.03472134f, 
    0.20239776f, -0.18923385f, 0.01590466f, 0.02197625f, -0.01150802f, -0.05768113f, 0.05304665f, 0.03684008f, 
    -0.05024872f, 0.01453137f, -0.07797495f, 0.08203107f, 0.10738087f, 0.14411706f, -0.17648152f, 0.17049266f, 
    0.12190378f, 0.04157690f, 0.06212547f, 0.05819053f, 0.03055272f, -0.34170875f, 0.07181934f, -0.04412039f, 
    -0.03431434f, 0.00429470f, 0.00034858f, 0.12112898f, -0.03442351f, -0.11473175f, -0.02122133f, 0.05711405f, 
    -0.00466643f, 0.02507442f, 0.05183952f, 0.01408823f, -0.09960208f, -0.01360595f, 0.14018081f, -0.04779670f, 
    -0.18347532f, 0.01961873f, -0.28782275f, 0.03308022f, -0.14397629f, -0.04533306f, -0.09022661f, -0.10406369f, 
    0.00781535f, 0.14921576f, 0.15642582f, 0.05369041f, -0.11981439f, -0.03075767f, 0.04608029f, 0.09827460f, 
    0.01828369f, -0.02008973f, 0.00202585f, -0.01342503f, -0.34374961f, 0.10917848f, -0.15963508f, 0.09520111f, 
    0.07410211f, -0.01647219f, -0.18913884f, -0.15804479f, -0.09509747f, -0.08178542f, -0.00749849f, -0.06294621f, 
    -0.02402199f, -0.06990070f, 0.01690164f, 0.08605615f, -0.04734613f, -0.11794931f, 0.05780634f, -0.12418156f, 
    0.00619167f, -0.05995689f, 0.00415901f, 0.04835867f, -0.01537422f, 0.23890951f, 0.09745737f, -0.16166340f, 
    0.06881665f, -0.02868304f, -0.12734073f, 0.12071948f, 0.00252311f, -0.04030122f, 0.00873251f, -0.04739647f, 
    -0.06509620f, -0.03770298f, 0.03191696f, 0.10976455f, 0.00066464f, 0.02490947f, -0.13206936f, -0.06282976f, 
    -0.00436530f, 0.00497942f, 0.00603124f, -0.02540349f, -0.12661639f, -0.17167185f, -0.33362532f, 0.18583371f, 
    0.04103969f, 0.03312994f, 0.02895109f, -0.05448559f, 0.00332102f, 0.05468446f, 0.04008451f, -0.03988184f, 
    -0.06447864f, -0.04269114f, -0.30574012f, 0.07428022f, 0.00489152f, 0.01875094f, -0.17397498f, -0.08347340f, 
    0.07362415f, -0.03356864f, -0.00149538f, 0.03795344f, 0.04161444f, -0.25113794f, -0.21111779f, 0.14847267f, 
    -0.08150138f, 0.00873875f, 0.01684823f, 0.02431506f, -0.05292765f, -0.15353376f, -0.21446644f, -0.09039678f, 
    -0.05425073f, -0.16213429f, 0.22878253f, 0.14556465f, -0.05684734f, 0.10616063f, -0.06847536f, -0.15671934f, 
    0.01596299f, -0.01223369f, -0.03161665f, -0.04192476f, 0.15762292f, 0.12728715f, -0.17967829f, -0.22819459f, 
    0.07464724f, 0.04456078f, 0.04213000f, 0.00379257f, 0.04863840f, -0.01886115f, -0.00022698f, -0.03584111f, 
    0.07122174f, -0.04403309f, 0.12782530f, 0.22128986f, -0.16370888f, 0.17232300f, -0.13538922f, -0.02126461f, 
    -0.10684618f, 0.04540767f, 0.04201552f, 0.15489559f, 0.13371544f, 0.02905801f, 0.19422153f, -0.24543472f, 
    -0.03227210f, 0.01860999f, -0.07520182f, -0.00626500f, 0.00583457f, -0.02114667f, 0.04180870f, 0.05607598f, 
    0.07734708f, -0.27756339f, 0.04485670f, 0.10338098f, 0.02883785f, -0.05237374f, -0.19577308f, -0.08863799f, 
    -0.05037349f, -0.01079441f, -0.00534288f, 0.09977555f, -0.00563830f, -0.05617778f, -0.00579224f, 0.15908694f, 
    -0.18321043f, -0.05294609f, -0.02081548f, -0.19321741f, 0.08710372f, -0.12812757f, -0.07213421f, 0.06731018f, 
    0.28860483f, 0.10486908f, -0.12942696f, 0.07213140f, -0.07082551f, 0.01226197f, -0.05265281f, -0.13625692f, 
    0.21848883f, -0.16922866f, -0.04765739f, -0.03216476f, 0.03482301f, -0.00266814f, 0.24472579f, 0.02455873f, 
    0.04795767f, -0.14362903f, -0.13156518f, -0.01626554f, -0.07861356f, 0.03591893f, 0.00637481f, 0.04813647f, 
    0.20237267f, 0.26117069f, -0.01042405f, 0.16546243f, 0.13167565f, -0.05638471f, -0.02969589f, -0.06777537f, 
    0.04439828f, -0.10154337f, -0.06826712f, -0.10620761f, -0.04974466f, -0.35104710f, 0.37023553f, -0.04202847f, 
    0.05711876f, 0.05155497f, 0.04061127f, -0.00515188f, -0.05695729f, 0.06587096f, -0.08046965f, 0.14431500f, 
    -0.04799305f, 0.08465968f, -0.06169520f, 0.15288521f, 0.03098074f, 0.02799824f, -0.16330473f, 0.20981206f, 
    -0.00107240f, 0.00360651f, -0.09679583f, 0.01090816f, 0.17335498f, 0.42018369f, 0.02604236f, 0.09372075f, 
    -0.04408146f, -0.05573867f, 0.07564867f, 0.09694970f, 0.09108645f, -0.09904884f, 0.00487398f, 0.10760196f, 
    0.11959822f, -0.07952961f, -0.16752626f, -0.24304435f, 0.07446333f, 0.06782144f, -0.05371996f, 0.13969827f, 
    0.01190245f, 0.02580996f, 0.06822614f, -0.14711654f, -0.10688791f, -0.27918670f, 0.17233577f, -0.09996632f, 
    -0.20524432f, 0.02289558f, -0.03597533f, 0.10990157f, -0.09610569f, -0.04571829f, -0.09808097f, -0.08298306f, 
    0.00469618f, 0.16386434f, -0.39825654f, 0.05643858f, 0.09724867f, 0.03688580f, 0.06739353f, -0.11227199f, 
    -0.04110033f, 0.06010668f, -0.05213567f, -0.00301567f, -0.12820588f, -0.19287440f, 0.14029402f, -0.23931181f, 
    -0.26654774f, -0.11633767f, -0.02477809f, 0.11889827f, 0.06306086f, -0.05450255f, -0.08836616f, -0.19215807f, 
    0.01546112f, -0.01896776f, -0.01130818f, 0.03944974f, 0.01087468f, -0.00909281f, -0.01961618f, -0.00067506f, 
    -0.00887085f, 0.19703709f, 0.05715916f, 0.21659628f, -0.32640499f, -0.44263032f, -0.11331309f, 0.06032880f, 
    -0.03059342f, 0.05969459f, -0.14211069f, 0.05295544f, -0.10366827f, 0.02146335f, -0.13015866f, -0.05928084f, 
    0.00173255f, 0.17087653f, 0.18181767f, 0.16680630f, 0.00418167f, 0.03499668f, 0.08121695f, 0.09148439f, 
    -0.00755568f, -0.05094462f, -0.00396511f, -0.01374408f, -0.05488791f, 0.19814868f, -0.11141775f, 0.02151486f, 
    -0.02042486f, -0.05943696f, 0.06157910f, -0.08110069f, 0.18505950f, 0.07076743f, 0.11906457f, 0.44069359f, 
    -0.07269832f, 0.07744563f, -0.01642129f, -0.02819041f, 0.04824486f, -0.09797937f, -0.14716901f, -0.09864426f, 
    -0.10029845f, -0.05117122f, -0.00774105f, 0.08946733f, -0.02144877f, 0.04644779f, 0.04427490f, 0.06501088f, 
    0.08262587f, 0.10100536f, -0.00296859f, 0.04863023f, 0.04341134f, 0.04812678f, 0.05160104f, -0.02823154f, 
    0.00822265f, -0.06335642f, 0.11172371f, 0.08549517f, -0.00738264f, -0.06180398f, -0.00328943f, -0.02539914f, 
    -0.15430671f, -0.13095444f, -0.14163269f, -0.13027039f, 0.08196958f, -0.01667961f, -0.02030456f, 0.00503490f, 
    0.07930299f, 0.00356705f, 0.02832484f, 0.05137492f, 0.06135212f, 0.02834037f, -0.13271120f, 0.09483707f, 
    -0.04959354f, 0.03377404f, 0.02572344f, -0.00301874f, -0.04168227f, -0.00664499f, 0.02171771f, 0.09864374f, 
    -0.08626766f, -0.11985107f, -0.10229602f, 0.16515066f, 0.00878303f, -0.11843231f, -0.24082863f, -0.06893943f, 
    -0.14294979f, -0.08717834f, 0.11905325f, -0.04033901f, 0.10146711f, -0.10214733f, 0.03097823f, -0.11973249f, 
    0.05055144f, 0.03020119f, -0.04204712f, 0.06555632f, 0.03045159f, 0.09774552f, -0.02232924f, 0.01091817f, 
    0.03017296f, -0.07343247f, -0.02511902f, -0.08450752f, 0.01828839f, 0.07590298f, -0.07334905f, 0.00257449f, 
    -0.11574920f, -0.11950229f, -0.12353859f, 0.00000253f, -0.27025461f, 0.04207202f, -0.27432176f, -0.03560756f, 
    0.01381867f, 0.05296657f, 0.10502423f, 0.16308752f, 0.08679022f, 0.03854921f, 0.02094689f, -0.12049039f, 
    0.23995468f, 0.07691094f, 0.04826563f, 0.06701091f, -0.09436627f, 0.07409298f, -0.02868256f, 0.06613094f, 
    -0.06648123f, -0.06578976f, -0.02229427f, -0.11361288f, -0.15791422f, 0.02414726f, -0.07042540f, 0.03986056f, 
    0.03332196f, -0.03249320f, 0.05337604f, -0.06436519f, -0.07563591f, -0.11482602f, 0.01296036f, 0.03251319f, 
    0.40423188f, 0.10033546f, -0.06029040f, 0.36373729f, 0.08934367f, 0.10502107f, 0.15917820f, 0.24294314f, 
    0.10000332f, 0.05217749f, 0.10036297f, 0.11078919f, 0.12763818f, -0.02097441f, -0.02705717f, -0.04479017f, 
    -0.01855761f, -0.05791496f, -0.63934302f, 0.27650118f, 0.07610851f, -0.01382021f, -0.11624721f, -0.08042394f, 
    0.09407756f, 0.05615982f, -0.02797093f, -0.05536572f, 0.18050995f, -0.16410893f, 0.11595163f, -0.00889595f, 
    -0.10862518f, -0.04593668f, -0.27676371f, -0.05870967f, -0.36093888f, -0.02798978f, -0.01365982f, -0.01904501f, 
    -0.00087988f, -0.10352696f, 0.05424190f, -0.05336958f, -0.01328366f, 0.01731690f, -0.00687964f, -0.06788379f, 
    -0.08089588f, -0.10870587f, 0.04905131f, -0.05867646f, 0.14664811f, 0.27041191f, -0.37879053f, -0.01568512f, 
    0.05707445f, 0.00082656f, -0.10327378f, -0.21622173f, 0.02643299f, -0.08415718f, 0.17610595f, -0.09206259f, 
    0.03036856f, 0.00564274f, 0.02173427f, 0.13643473f, 0.09382056f, 0.08991404f, -0.00687906f, -0.08573212f, 
    0.01550810f, -0.05038057f, 0.16642527f, 0.07329800f, 0.02091799f, 0.25497863f, 0.03732008f, 0.15495518f, 
    0.12680420f, -0.06426541f, -0.01922585f, -0.05836135f, -0.04462585f, -0.05224659f, 0.11464575f, -0.13998854f, 
    -0.19554497f, -0.25277176f, -0.11478592f, 0.13178924f, -0.16292357f, -0.21196230f, 0.06894352f, -0.09999001f, 
    0.04151899f, 0.00737973f, -0.00874931f, 0.02599873f, -0.01525062f, -0.06243004f, 0.15222229f, 0.16963729f, 
    -0.12649283f, -0.04229511f, -0.05835412f, -0.17142081f, 0.05528490f, -0.00673375f, -0.00424505f, -0.11087374f, 
    0.01897454f, -0.04745496f, -0.03072500f, -0.15867099f, -0.01473747f, -0.09736092f, 0.01333254f, 0.00536328f, 
    -0.05736056f, -0.07502677f, -0.18502574f, -0.20967156f, -0.23643087f, 0.03662031f, -0.18961580f, -0.08398635f, 
    0.05266637f, -0.06449938f, 0.06106413f, 0.06732842f, -0.16699408f, -0.09166393f, -0.06000303f, -0.19971247f, 
    0.00134933f, 0.02431946f, 0.00354236f, 0.02808477f, 0.05219990f, -0.00384571f, -0.01077496f, -0.00387973f, 
    -0.01893973f, 0.03102202f, 0.06582548f, 0.09531157f, 0.19918458f, 0.09212093f, 0.14094511f, 0.16699867f, 
    -0.07039405f, -0.10977436f, -0.06185227f, 0.02199753f, 0.16799012f, -0.04043031f, -0.05731520f, 0.02822107f, 
    0.01929634f, 0.17900634f, 0.17066804f, 0.17162918f, -0.04115161f, -0.12801842f, 0.00203039f, 0.00139997f, 
    -0.02123818f, 0.03810281f, 0.07420429f, 0.10661609f, -0.02190048f, 0.03299559f, 0.13549642f, 0.05941314f, 
    0.00592905f, 0.07357716f, -0.09409929f, 0.07475074f, -0.09283274f, 0.04673012f, -0.08938833f, -0.15306486f, 
    -0.02497078f, -0.06462514f, -0.05299559f, -0.05260933f, -0.16780514f, -0.09650502f, 0.04230339f, 0.06946050f, 
    0.00588061f, -0.13022204f, 0.00015413f, -0.12169335f, 0.13768406f, 0.24068719f, 0.35970801f, 0.16838829f, 
    -0.06346417f, -0.08065997f, 0.12898959f, 0.05146142f, 0.05599335f, -0.03549419f, 0.03067448f, -0.02093101f, 
    0.09949856f, 0.06123663f, 0.10721469f, -0.04237918f, -0.04351843f, -0.03064845f, 0.07410350f, 0.18281206f, 
    0.01147025f, 0.00864742f, -0.02973106f, -0.07779636f, 0.07404692f, 0.03049075f, 0.28040799f, 0.11547246f, 
    -0.01613626f, -0.11545447f, -0.22285011f, 0.04560431f, 0.10147764f, 0.03289481f, -0.04446983f, 0.05358579f, 
    0.03622609f, 0.04107113f, -0.01991650f, 0.02330084f, 0.07451418f, 0.06983089f, -0.01274934f, 0.08618660f, 
    -0.14952086f, 0.07551862f, 0.08069716f, -0.11969540f, 0.20167001f, -0.02248658f, -0.14359401f, 0.05203353f, 
    -0.00436119f, 0.04431271f, 0.00363672f, -0.05513017f, -0.16116732f, 0.08902410f, -0.10760155f, -0.08846410f, 
    -0.12906489f, -0.02158599f, 0.06720632f, 0.11450453f, 0.02007727f, -0.07494690f, -0.17168808f, 0.00423359f, 
    0.03463645f, 0.00088272f, 0.02796900f, -0.00806870f, 0.07063732f, 0.00683177f, 0.10806751f, 0.11249803f, 
    0.08799160f, 0.00473386f, -0.23711881f, -0.05568960f, 0.04641359f, 0.01051306f, -0.04959731f, 0.05213157f, 
    -0.05088359f, -0.03531427f, 0.10624539f, -0.11691339f, 0.02139249f, 0.13672227f, -0.10541204f, 0.02371482f, 
    0.02303748f, -0.02243422f, 0.03056019f, 0.02452831f, -0.05724654f, -0.23971425f, 0.28247583f, 0.17699063f, 
    0.05961559f, 0.14824805f, -0.00391908f, -0.02659311f, 0.04591934f, -0.10621753f, 0.18898432f, 0.08375116f, 
    0.12902348f, 0.09785233f, -0.07964176f, 0.10119031f, 0.26312006f, -0.06665411f, -0.05350712f, -0.21414277f, 
    0.07028709f, 0.03497968f, 0.03760884f, 0.06634171f, -0.23105897f, 0.10905299f, -0.07115468f, -0.12778391f, 
    -0.06077289f, -0.10913178f, 0.18163973f, 0.14292271f, 0.13050997f, 0.10435888f, -0.01981015f, -0.10504048f, 
    -0.17215168f, 0.02051593f, 0.01461357f, -0.04681522f, 0.24333137f, 0.01423922f, 0.15282825f, -0.00578948f, 
    0.00221639f, 0.01646563f, 0.06934443f, 0.02218081f, -0.09210189f, -0.09285863f, -0.20581308f, 0.02939822f, 
    0.31042254f, 0.05200318f, -0.05714130f, 0.08730848f, 0.06293070f, 0.04853313f, -0.02255550f, 0.07266930f, 
    0.02396154f, -0.04734876f, -0.04689949f, -0.11406313f, -0.04802788f, -0.05483209f, -0.01806563f, -0.04367534f, 
    0.08165194f, 0.00545819f, 0.09597452f, 0.08105791f, -0.10759618f, 0.17067762f, -0.32801613f, 0.29892775f, 
    0.04585087f, -0.04853842f, -0.03902364f, 0.03528445f, -0.02720718f, 0.05047681f, -0.03101093f, -0.02123494f, 
    -0.07864292f, 0.11221420f, -0.19028983f, 0.27817360f, -0.06576565f, -0.01707333f, 0.07677332f, 0.10896694f, 
    -0.04920322f, 0.04634211f, 0.06935589f, 0.01416399f, -0.04787830f, -0.22232626f, 0.26766670f, -0.11076736f, 
    -0.01835136f, -0.05375532f, -0.00206386f, 0.03614982f, 0.20920250f, 0.05298264f, -0.03652393f, -0.13320364f, 
    -0.10798104f, 0.19135493f, 0.02222520f, -0.06747945f, 0.12019894f, -0.02328049f, 0.01016928f, 0.18367855f, 
    0.05069933f, 0.04496180f, -0.02554854f, 0.09087715f, -0.00699327f, -0.10246978f, 0.06578125f, 0.03225427f, 
    -0.00501223f, 0.03333229f, -0.14122142f, -0.01646362f, 0.06456494f, -0.09436905f, 0.16111736f, -0.06111640f, 
    -0.00108283f, 0.04425728f, 0.22204936f, 0.30888084f, 0.07544202f, -0.14426248f, 0.05458312f, -0.19175953f, 
    0.03455367f, 0.02012241f, 0.02213023f, -0.35966131f, -0.02953390f, -0.35123742f, 0.04653142f, 0.31604725f, 
    0.01985943f, 0.07052823f, -0.13541430f, -0.02539513f, -0.07106149f, -0.09715631f, 0.21426773f, 0.06613842f, 
    -0.21350248f, 0.12204029f, 0.38701731f, -0.11834300f, -0.14034830f, 0.15359330f, 0.06614532f, -0.09229040f, 
    0.06154363f, -0.02596645f, -0.02264096f, -0.03313335f, -0.09023730f, -0.16236256f, 0.09243359f, 0.06476201f, 
    -0.03982677f, 0.03610284f, -0.21973085f, 0.05745545f, -0.00017025f, 0.05164614f, 0.15282929f, -0.18273947f, 
    -0.18592066f, -0.16354194f, 0.06984849f, -0.14356977f, 0.00859248f, -0.07094342f, -0.01445092f, -0.13354170f, 
    0.13064817f, 0.17028819f, 0.04575373f, 0.01526773f, 0.17436744f, 0.27449137f, 0.09653141f, -0.19853762f, 
    0.00993290f, 0.02321804f, 0.06883046f, 0.01337285f, 0.05688842f, -0.08493166f, -0.03957244f, 0.06018278f, 
    -0.17089175f, 0.05043382f, 0.06132002f, -0.12288345f, -0.05086884f, 0.06388775f, 0.17202863f, -0.22457716f, 
    0.00479436f, -0.10331510f, 0.07089601f, -0.07673454f, -0.09203815f, 0.05003289f, -0.04649771f, -0.13057725f, 
    -0.09997530f, -0.04314024f, -0.00665830f, -0.02532972f, 0.16063705f, -0.13811702f, -0.17833467f, -0.25580734f, 
    0.05131261f, 0.00373136f, -0.32146764f, 0.10205949f, 0.28251612f, 0.00848749f, -0.03417036f, -0.00528880f, 
    0.02366989f, 0.04844483f, -0.02858462f, -0.05211360f, -0.84488797f, -0.41284889f, -0.38355216f, -0.24601255f, 
    -0.01540699f, -0.02762296f, -0.07910375f, 0.01668969f, 0.04478376f, 0.06013836f, 0.04163306f, -0.02241325f, 
    -0.13767312f, -0.01722841f, -0.25304329f, -0.22854552f, 0.07411696f, -0.04063063f, -0.00219706f, 0.11680893f, 
    -0.03293202f, -0.12653899f, -0.00169755f, 0.02782440f, 0.15774798f, -0.03445229f, 0.01066263f, 0.04619549f, 
    0.01450953f, -0.09674820f, -0.07751709f, -0.04316092f, 0.02468665f, 0.10993683f, -0.05136084f, 0.16471674f, 
    -0.21940097f, -0.16469331f, -0.15387808f, -0.05773362f, 0.04320691f, 0.06255200f, 0.02766258f, 0.13009298f, 
    0.16604958f, -0.03145295f, -0.04334718f, -0.04058366f, -0.13722676f, -0.03720153f, 0.39354670f, 0.02471681f, 
    0.05782208f, -0.10427657f, -0.03022730f, 0.07633077f, 0.11773444f, -0.01909962f, -0.04103703f, -0.08876522f, 
    -0.02266538f, -0.00259422f, -0.00058937f, -0.04144436f, 0.05969808f, 0.06586054f, -0.03605790f, 0.05025751f, 
    0.02597666f, -0.12485699f, -0.19309370f, -0.32975820f, -0.37931642f, 0.27011266f, 0.09109932f, -0.21284758f, 
    -0.13849543f, -0.12271155f, 0.09956122f, -0.08408216f, -0.09526769f, -0.09228915f, -0.07388736f, 0.06925412f, 
    0.02472661f, -0.03403193f, 0.11908560f, -0.23815714f, 0.16857645f, -0.13340200f, 0.04450025f, -0.01959395f, 
    -0.02712705f, -0.03080784f, 0.04187902f, -0.03336070f, 0.04818707f, -0.17126729f, -0.16014446f, -0.02369704f, 
    0.05513620f, 0.07000087f, 0.00373451f, 0.07491887f, 0.13101193f, -0.44496119f, -0.49633580f, -0.41045523f, 
    -0.08007988f, -0.02061928f, -0.14439026f, -0.22782573f, 0.00809498f, 0.00773750f, 0.01827359f, 0.19965181f, 
    0.12111718f, 0.00619641f, 0.05419434f, -0.09265327f, -0.08703116f, -0.20535149f, -0.04486497f, 0.00748994f, 
    0.08327957f, -0.00985669f, -0.01806162f, 0.05211438f, -0.01448225f, 0.00710748f, -0.01145706f, -0.04778505f, 
    0.02423555f, -0.00868527f, -0.17912687f, -0.10208714f, -0.12872873f, 0.14075947f, -0.08839125f, -0.08981717f, 
    0.07101844f, -0.05310719f, 0.14461851f, 0.11067251f, -0.19400828f, -0.11113226f, 0.02157896f, 0.03380286f, 
    0.01677224f, 0.01916393f, -0.01593637f, -0.02875975f, 0.01603638f, 0.32839641f, 0.01467487f, -0.01713299f, 
    -0.31781891f, -0.25612012f, -0.20919633f, -0.03426308f, 0.00875380f, 0.02863423f, -0.01516908f, 0.02142039f, 
    0.08281554f, -0.10411678f, 0.04860651f, -0.02322330f, -0.32473651f, -0.07219327f, -0.18266582f, 0.43820426f, 
    0.06198066f, -0.10063279f, 0.06886276f, 0.09904313f, 0.04889084f, -0.02489771f, 0.02284269f, 0.05037011f, 
    -0.04606850f, 0.03935498f, -0.17839919f, -0.08403248f, 0.01917888f, 0.15336980f, -0.08549739f, 0.02339636f, 
    0.07050774f, 0.07594746f, -0.07367264f, 0.19957539f, -0.01995159f, -0.30498883f, 0.33597529f, -0.03115974f, 
    -0.05710733f, -0.08686747f, 0.09571455f, 0.10303444f, 0.11863538f, -0.00613552f, 0.02860466f, 0.15700264f, 
    0.09867407f, 0.07141440f, -0.00934935f, -0.18093202f, -0.02664558f, 0.00120753f, -0.03926490f, -0.03196589f, 
    -0.30030912f, -0.13091539f, -0.01293970f, -0.34540555f, -0.03495277f, -0.20204420f, 0.12145343f, 0.12408187f, 
    -0.03878181f, 0.02205284f, 0.04174061f, 0.04801079f, 0.02732306f, -0.12570225f, -0.08384808f, 0.06361894f, 
    -0.00762493f, -0.08752149f, 0.05876600f, 0.04220005f, -0.00825285f, 0.06363469f, -0.05892810f, -0.03838873f, 
    -0.21271114f, 0.04716118f, -0.20227166f, -0.40895581f, -0.04408969f, 0.01908662f, -0.08781251f, 0.20675735f, 
    -0.05832176f, -0.06455398f, 0.07048360f, 0.10437638f, -0.10159352f, 0.03074418f, -0.01045323f, -0.05583067f, 
    0.08706973f, -0.09704938f, -0.12645523f, -0.23417865f, -0.08538599f, 0.07912157f, -0.08298926f, 0.14407398f, 
    -0.04095666f, -0.11426456f, -0.02376084f, -0.20226948f, 0.13676655f, -0.20949000f, 0.40325734f, -0.09779782f, 
    0.23534226f, 0.04627886f, -0.03187753f, 0.08718304f, 0.05521668f, 0.02884651f, 0.00243900f, 0.10193145f, 
    0.06725056f, -0.01449466f, -0.20727836f, -0.10857992f, 0.09113106f, -0.10257749f, 0.00397644f, 0.14646333f, 
    -0.00898145f, -0.19675085f, 0.06235165f, 0.00816487f, 0.03868056f, 0.12954479f, -0.38437629f, 0.00147168f, 
    -0.02692647f, 0.12478378f, -0.11213308f, 0.10214551f, 0.09564105f, -0.18892610f, 0.01396844f, -0.10058299f, 
    -0.04951456f, -0.00362262f, 0.25610325f, -0.12552802f, -0.13499492f, -0.11234421f, 0.03852629f, 0.01444377f, 
    0.11632941f, -0.04639639f, -0.05590602f, 0.06744225f, 0.08490691f, 0.22741573f, -0.05301538f, -0.19357504f, 
    0.11352224f, 0.10149410f, -0.07283791f, 0.09936798f, 0.00703487f, -0.05632260f, 0.04699180f, 0.03326404f, 
    -0.58276284f, 0.22357480f, -0.05438267f, -0.09463367f, 0.11382021f, -0.17738950f, 0.06247940f, 0.12527090f, 
    -0.04504206f, -0.05624190f, 0.09429689f, -0.00976599f, 0.10712043f, -0.01790029f, 0.13249144f, 0.08060110f, 
    0.24654956f, -0.03497789f, -0.19539256f, 0.22226587f, -0.07646790f, -0.01106850f, 0.25936791f, -0.01378022f, 
    -0.13409673f, 0.26496089f, -0.45923895f, -0.03693984f, 0.00628688f, 0.12695895f, -0.20698047f, -0.13133004f, 
    -0.06347557f, 0.11874204f, -0.02193609f, 0.03914720f, 0.59474170f, -0.15902722f, -0.33483413f, 0.16473201f, 
    0.01779360f, -0.03985294f, -0.12904303f, 0.04207655f, 0.08001997f, -0.03014858f, 0.13926120f, 0.02654939f, 
    -0.08314064f, -0.03717890f, -0.05359849f, 0.04390788f, 0.00025004f, -0.03675992f, -0.04941165f, 0.04763580f, 
    -0.04104804f, -0.11810173f, 0.03309670f, -0.00250651f, -0.13534909f, -0.04989209f, -0.14804745f, -0.23759411f, 
    0.07309699f, 0.00399031f, 0.11776114f, -0.13817796f, 0.16972683f, 0.01899042f, -0.12785240f, -0.08223949f, 
    0.09730171f, 0.08278920f, -0.19559610f, -0.17365234f, 0.09136061f, 0.04529101f, -0.12751597f, 0.05677581f, 
    -0.10743754f, -0.22138642f, -0.16246521f, -0.05833798f, -0.01163748f, 0.26895574f, -0.04089428f, -0.39405698f, 
    -0.16061285f, 0.06968594f, -0.17908520f, 0.00300154f, 0.05852323f, -0.07750810f, -0.03824319f, 0.35611323f, 
    0.02590987f, -0.24142447f, 0.18522114f, 0.08579261f, 0.16766037f, -0.03938676f, 0.11913799f, 0.00906893f, 
    -0.04702562f, -0.00594890f, 0.01551780f, 0.18303421f, 0.10940725f, 0.14434826f, 0.16195345f, 0.01856340f, 
    0.22038223f, 0.04662666f, -0.04325771f, -0.11505673f, 0.01825402f, -0.02410536f, 0.05727775f, 0.04357673f, 
    -0.00907925f, -0.11364750f, -0.09232697f, -0.05221524f, 0.06733277f, 0.18189538f, 0.13602644f, -0.06103029f, 
    0.06380834f, 0.06415384f, -0.05977236f, 0.06972579f, 0.03192827f, 0.02969998f, -0.03730529f, -0.00197083f, 
    0.10153008f, 0.06197435f, 0.19356045f, -0.10327727f, -0.03695533f, 0.00284789f, 0.04064793f, -0.01549707f, 
    0.01502018f, -0.09998269f, -0.12400160f, -0.12153815f, 0.17161563f, 0.00281949f, -0.03021943f, -0.03252614f, 
    0.07318189f, -0.10169273f, -0.09947389f, 0.19047433f, -0.20155136f, 0.03243912f, 0.04070100f, 0.12809816f, 
    0.01578308f, -0.13749613f, -0.08770803f, 0.03262275f, 0.21569967f, -0.12399967f, 0.10510894f, 0.25135458f, 
    -0.00499394f, -0.05869208f, -0.14961632f, -0.03131586f, 0.10388959f, -0.09004589f, 0.14427041f, 0.24400190f, 
    -0.04925720f, -0.00742427f, 0.08574600f, 0.01389151f, 0.09502626f, 0.02648482f, -0.03856032f, 0.00342772f, 
    0.03100954f, -0.02778566f, -0.02282737f, -0.02714094f, 0.04320058f, 0.10406061f, 0.08262541f, -0.02133656f, 
    -0.24943317f, -0.50860786f, -0.16391565f, -0.05094831f, -0.12798582f, 0.12683301f, -0.02338022f, -0.02031755f, 
    -0.02137762f, 0.06375580f, -0.04966207f, -0.04989219f, -0.09042159f, -0.10458271f, -0.16623679f, -0.10360495f, 
    -0.18997061f, -0.21407963f, -0.02140002f, 0.14865816f, -0.03077800f, 0.00825100f, 0.04268804f, -0.08017880f, 
    -0.55780679f, -0.55303460f, -0.66977018f, 0.05167741f, -0.12182075f, -0.13950685f, 0.11751071f, -0.18160443f, 
    0.01205500f, -0.02617497f, -0.10011335f, 0.03289029f, 0.62924433f, -0.12869206f, -0.20328370f, 0.24953648f, 
    0.02535392f, -0.04166153f, 0.12096024f, 0.24005237f, -0.05753702f, -0.00525893f, -0.05902110f, 0.05022956f, 
    -0.40521097f, -0.27708673f, -0.31191891f, -0.43726590f, 0.15954641f, -0.07452641f, -0.11273642f, -0.02616682f, 
    -0.02180381f, -0.02311090f, -0.03560039f, -0.00354410f, -0.75994349f, -0.24529858f, 0.00660829f, -0.47419414f, 
    0.06277692f, 0.11806085f, 0.17449479f, 0.07564694f, -0.00150363f, -0.04006758f, -0.01984929f, 0.03552168f, 
    -0.49655452f, -0.23203205f, -0.00916993f, -0.13982348f, -0.14726569f, -0.29458889f, 0.03096543f, 0.06304802f, 
    0.03677285f, -0.00683204f, -0.00448411f, -0.03210985f, 0.34717503f, 0.02407924f, -0.25143537f, -0.12143872f, 
    0.03912147f, -0.01035955f, 0.10657992f, 0.08296070f, -0.02512143f, 0.00930173f, -0.03381842f, -0.13533767f, 
    0.37130114f, -0.19748777f, -0.01132509f, -0.17484632f, -0.04648943f, 0.03829028f, 0.17915995f, 0.04328907f, 
    0.00936727f, -0.06123716f, 0.05435441f, 0.00881490f, -0.08397061f, 0.00677528f, -0.02211213f, 0.10557222f, 
    0.01300774f, 0.02379034f, 0.03008964f, 0.08172295f, 0.18029431f, 0.05719227f, 0.07287364f, -0.13483846f, 
    -0.29346564f, -0.39528394f, -0.45064008f, 0.41154066f, 0.01429618f, -0.18177494f, -0.08326428f, -0.31347832f, 
    -0.06198280f, -0.00470116f, 0.00001137f, 0.00966883f, -0.15578872f, -0.07278416f, -0.30488828f, -0.34986416f, 
    -0.05856778f, 0.05574922f, -0.03495521f, -0.01405178f, -0.02976460f, 0.00191426f, -0.08181278f, -0.01546133f, 
    -0.27569807f, -0.28713149f, -0.33030194f, -0.04269356f, -0.01936674f, 0.07706919f, 0.02266993f, 0.05407826f, 
    0.00198764f, -0.03297607f, 0.14703634f, -0.00220934f, -0.07400680f, -0.02919194f, -0.20765513f, -0.08202395f, 
    -0.07164653f, 0.04894740f, 0.07404073f, 0.06919345f, -0.06303980f, 0.00482093f, -0.13777727f, 0.12735115f, 
    0.02638304f, -0.56241095f, -0.31155410f, 0.14310823f, 0.00594659f, 0.07375427f, 0.07070293f, -0.04442967f, 
    0.08686385f, 0.07416104f, 0.11203403f, 0.04179177f, -0.03311850f, -0.09210088f, -0.19033507f, -0.09729009f, 
    -0.07522619f, 0.20881860f, 0.01512446f, -0.12707916f, -0.02846939f, -0.01060175f, -0.10848363f, 0.02327875f, 
    -0.36876053f, 0.10283858f, 0.32170805f, -0.05736006f, -0.01339740f, -0.13373761f, -0.14555840f, 0.00071854f, 
    -0.12058861f, 0.14214696f, -0.00759063f, 0.08179971f, -0.63991886f, -0.60706639f, -0.24779664f, 0.15921350f, 
    0.00722290f, -0.02981126f, -0.25291571f, -0.29623851f, 0.00715612f, 0.08410104f, 0.04635272f, -0.01609812f, 
    -0.21484825f, -0.52050853f, 0.23067655f, -0.19591770f, -0.04728336f, 0.16024967f, -0.01077094f, -0.12629159f, 
    0.03029730f, -0.03596818f, 0.04672412f, 0.04656902f, -0.15874578f, -0.07783781f, 0.01118580f, 0.09000506f, 
    0.08594843f, 0.03835648f, -0.04778139f, 0.09552391f, -0.01901525f, -0.02993940f, -0.03512284f, 0.17471330f, 
    0.13344191f, -0.06709554f, 0.08001915f, -0.02717545f, 0.16217640f, -0.07244058f, 0.14424443f, -0.09829563f, 
    -0.05165197f, 0.04216965f, -0.01364002f, -0.03644346f, -0.12402594f, 0.14095762f, 0.28294551f, 0.19992158f, 
    -0.03733871f, -0.03063201f, -0.04641081f, 0.09808459f, 0.02545866f, 0.10957063f, 0.00465581f, 0.01940327f, 
    -0.44725364f, -0.18598774f, 0.02899328f, 0.02621141f, 0.14591292f, 0.06169535f, 0.05966522f, -0.12641816f, 
    0.00758369f, -0.00582242f, -0.03610398f, 0.06620088f, -0.03998407f, -0.06761664f, 0.02110555f, 0.19811077f, 
    0.07101789f, -0.00760246f, -0.01192531f, -0.00356278f, -0.09115039f, -0.07092100f, -0.04724855f, 0.04271211f, 
    -0.08452678f, -0.14181709f, 0.01835302f, 0.20866111f, 0.12181145f, 0.10383836f, 0.07245101f, -0.14389564f, 
    -0.01784235f, -0.04518384f, 0.04613047f, 0.02614095f, 0.14362597f, -0.07890649f, -0.07871516f, 0.08364850f, 
    0.01446810f, -0.23488846f, -0.07328769f, 0.43316025f, 0.03959019f, 0.16203129f, 0.03678865f, -0.11440171f, 
    -0.09031710f, -0.17987561f, -0.00693827f, -0.04026243f, 0.06025900f, 0.03512519f, 0.09516222f, -0.02230121f, 
    -0.00700047f, -0.04616788f, 0.05175918f, -0.12889025f, -0.14937149f, 0.01148160f, 0.04992486f, -0.09332761f, 
    -0.10481984f, 0.01069970f, 0.09446945f, 0.00367984f, -0.00230414f, 0.09463302f, 0.14857589f, 0.19888741f, 
    -0.26169187f, -0.36770546f, -0.25540811f, 0.10373567f, 0.03439592f, 0.04574562f, -0.02529051f, -0.21625930f, 
    -0.00130568f, -0.01973713f, 0.01059416f, 0.02283631f, 0.18739329f, 0.07558450f, -0.02771360f, 0.03899233f, 
    -0.00128855f, -0.03274591f, -0.00763547f, 0.02300107f, 0.12612453f, 0.24184790f, 0.23217770f, 0.07399089f, 
    0.36513966f, 0.18843742f, 0.00728520f, 0.18176946f, 0.05672916f, 0.06109683f, -0.05875274f, 0.07159907f, 
    0.05400662f, 0.01934787f, 0.10469437f, 0.04477883f, -0.01533176f, -0.15205038f, -0.08715498f, 0.01639976f, 
    -0.06501926f, 0.04656478f, 0.03880745f, -0.01044613f, -0.04200866f, -0.08444055f, -0.10334628f, -0.04945281f, 
    0.15960348f, 0.13254915f, -0.00514746f, 0.01227151f, 0.10944860f, -0.00611957f, 0.03866851f, 0.09507498f, 
    0.10990576f, 0.14244856f, -0.12103759f, -0.04475780f, -0.02175181f, -0.04813037f, -0.06497996f, -0.01866340f, 
    -0.02825557f, 0.00586342f, 0.01680111f, 0.08532540f, 0.04226130f, 0.06233428f, -0.08879828f, 0.07053806f, 
    -0.05871917f, 0.21686645f, -0.01278442f, 0.11372799f, 0.00204045f, -0.03776186f, 0.01280487f, 0.06511865f, 
    -0.00765288f, -0.06692150f, 0.01783384f, 0.08521707f, 0.04092074f, -0.07697392f, -0.18065783f, -0.25920916f, 
    0.00896981f, 0.11460447f, 0.17752734f, 0.01083928f, -0.11653202f, 0.05777341f, -0.03795239f, 0.00211283f, 
    0.06319666f, 0.01015096f, -0.15931065f, -0.07111443f, 0.03486783f, -0.03454107f, -0.00147281f, 0.05372057f, 
    -0.06919200f, -0.01589106f, -0.12876549f, -0.02348635f, -0.16517246f, -0.29239538f, 0.06237837f, 0.17601739f, 
    -0.05915343f, -0.23619765f, 0.06427193f, 0.14210403f, 0.07934264f, 0.07788465f, -0.06540454f, 0.03567393f, 
    0.14413506f, 0.17518687f, -0.07778405f, -0.08038890f, -0.01858166f, 0.05813374f, -0.03039014f, 0.03125826f, 
    0.15355799f, 0.08897936f, -0.08310920f, 0.06621218f, 0.01922300f, 0.12233667f, -0.00838614f, -0.01280313f, 
    -0.08477242f, -0.05143952f, 0.00312892f, 0.01726909f, -0.10267477f, -0.04235534f, 0.28163409f, 0.15554543f, 
    -0.12386809f, -0.11135013f, -0.04336162f, 0.15874046f, 0.01041669f, 0.13179074f, 0.05210738f, 0.00025005f, 
    0.06992827f, 0.06297027f, 0.02911991f, -0.02405421f, -0.01042885f, -0.24330430f, -0.29569617f, -0.09710911f, 
    0.05770264f, 0.14925130f, 0.21407138f, -0.20519136f, 0.03751617f, -0.09761120f, -0.04220384f, 0.09936114f, 
    -0.03394768f, -0.14225014f, 0.08872086f, -0.08129141f, -0.02266925f, 0.03681542f, 0.05661108f, -0.06531370f, 
    0.03945169f, 0.10462574f, -0.01451811f, 0.00280914f, -0.25104690f, -0.00668295f, 0.20176986f, 0.16948910f, 
    -0.14028028f, -0.15404181f, 0.10001428f, 0.11512896f, -0.01509809f, -0.05614595f, 0.03431005f, -0.02992749f, 
    0.35591447f, 0.40972668f, -0.12139434f, 0.01939651f, -0.05765550f, -0.03337048f, -0.00895323f, 0.15081519f, 
    0.18934193f, 0.08333382f, 0.06886910f, -0.13619721f, 0.34565470f, 0.02542832f, 0.15506083f, -0.34286952f, 
    -0.01389380f, 0.00159321f, 0.24286403f, -0.04032968f, 0.07083698f, 0.13443504f, 0.16031808f, 0.06963059f, 
    -0.36144054f, -0.71704042f, -0.48026940f, -0.38350374f, -0.11970597f, -0.11176140f, -0.01545596f, -0.01120173f, 
    -0.06701297f, 0.06973331f, 0.09257872f, -0.00245882f, -0.12168910f, -0.62534678f, 0.07857829f, -0.54484445f, 
    0.03753921f, 0.10369159f, -0.01113553f, -0.26417059f, 0.04558195f, 0.05682076f, 0.02213502f, -0.06004265f, 
    -0.68337893f, -0.45250526f, 0.17973731f, 0.11655562f, -0.09099726f, 0.08335380f, 0.20630588f, -0.08377019f, 
    0.01197071f, 0.04480127f, -0.01296577f, -0.02655799f, 0.01819864f, -0.12278993f, -0.27743718f, 0.36854592f, 
    -0.03098136f, -0.08221780f, 0.22272380f, -0.05538526f, 0.00303571f, 0.03251753f, 0.06138091f, 0.03028956f, 
    -0.20801719f, -0.00466536f, 0.33335060f, -0.30514207f, 0.00450187f, -0.04303697f, 0.09344058f, -0.11466100f, 
    0.02155763f, 0.10271446f, 0.03372178f, 0.11894242f, 0.10689385f, 0.15618543f, -0.14745194f, 0.17873648f, 
    -0.03366781f, -0.00936181f, 0.04865692f, 0.11690878f, 0.01588483f, 0.20692652f, -0.16007657f, -0.03777469f, 
    -0.01840866f, -0.00986745f, 0.00172589f, 0.01563489f, -0.00962952f, -0.01457431f, 0.02099233f, -0.02995386f, 
    0.12839764f, 0.03577327f, 0.03439870f, 0.09204028f, -0.72423857f, 0.12973136f, 0.29411206f, -0.50243193f, 
    -0.01170016f, -0.04784925f, -0.26797804f, -0.04636220f, -0.05635891f, 0.00454816f, -0.01447124f, -0.03822515f, 
    -0.37434438f, 0.22404729f, 0.19845241f, -0.15030481f, -0.10355671f, 0.03996367f, -0.06167850f, 0.00358385f, 
    0.02303132f, -0.01504223f, -0.00162309f, 0.04049554f, -0.14350392f, -0.52658802f, -0.08385107f, -0.19084403f, 
    -0.18455370f, -0.22772679f, 0.01425219f, -0.04079225f, -0.07751489f, 0.04693172f, -0.06262932f, 0.05356873f, 
    -0.28565124f, -0.45268103f, 0.29868215f, 0.40238908f, 0.07018625f, -0.10271274f, 0.04502147f, -0.06390614f, 
    -0.02036810f, 0.01132989f, 0.01756815f, 0.13338314f, -0.48020902f, -0.44557372f, -0.47172165f, -0.32944113f, 
    -0.24155694f, -0.21858843f, -0.16850041f, -0.19786230f, 0.04242745f, -0.06162564f, 0.01691977f, -0.04760061f, 
    0.31708726f, 0.15034720f, -0.09782613f, -0.03187748f, 0.01956573f, -0.08255759f, 0.11499880f, -0.11050627f, 
    0.06002712f, -0.02958641f, 0.00199216f, -0.09048831f, -0.45137581f, -0.14388251f, -0.13624699f, -0.24293678f, 
    -0.17999488f, 0.11699752f, -0.08719086f, -0.28773546f, 0.01710150f, -0.00952265f, 0.03342657f, -0.02678011f, 
    -0.02971944f, 0.04768419f, 0.03983247f, 0.02485537f, 0.01352100f, -0.02244756f, 0.07039482f, -0.00269334f, 
    -0.16947313f, -0.06579498f, -0.03224054f, -0.05176812f, -0.11379413f, -0.24592407f, 0.42246071f, -0.00408799f, 
    -0.00495304f, -0.10316963f, 0.05386265f, 0.00024456f, 0.12682313f, 0.08434695f, 0.06955085f, -0.07798585f, 
    -0.43690205f, -0.27481380f, -0.05636999f, 0.29833338f, -0.01569195f, 0.12761702f, 0.04884835f, -0.08442356f, 
    0.02100023f, 0.07325585f, -0.00820470f, -0.04233885f, -0.17984730f, -0.00506205f, -0.03893254f, 0.01132170f, 
    -0.18823738f, 0.05267878f, -0.15900245f, -0.20781600f, 0.03791907f, -0.17013818f, -0.02872715f, -0.02787277f, 
    -0.17931701f, -0.18033001f, -0.07687119f, -0.16258295f, 0.03742902f, -0.00143167f, 0.08307711f, 0.18878521f, 
    -0.05779248f, -0.10503112f, -0.00006234f, 0.02661455f, 0.27277991f, -0.15812543f, 0.02091765f, 0.03611059f, 
    -0.01386206f, 0.16566211f, 0.16787970f, -0.25128263f, -0.17265701f, 0.04642148f, 0.00061571f, -0.07049274f, 
    -0.39234841f, -0.12497462f, 0.40927714f, 0.28457305f, 0.10188993f, -0.04270762f, 0.07372923f, -0.01774948f, 
    -0.03779101f, -0.05233177f, -0.08015198f, -0.03421744f, -0.31186298f, -0.15029168f, -0.06131940f, 0.14495361f, 
    -0.02743462f, 0.09089143f, 0.03817305f, 0.01590510f, -0.04264401f, -0.06473860f, 0.09200277f, -0.01228867f, 
    -0.21150047f, -0.19392397f, -0.18989035f, -0.25707668f, 0.00540830f, -0.06023284f, -0.05520778f, 0.07539911f, 
    0.02494835f, 0.00646515f, -0.01942081f, -0.02382986f, -0.39976174f, 0.40669358f, -0.49864969f, 0.02067303f, 
    0.12413511f, -0.20223485f, 0.05425786f, 0.05504504f, 0.01165132f, 0.05237056f, -0.00962565f, 0.02265196f, 
    -0.29439914f, 0.11217471f, -0.13025257f, -0.04817725f, -0.11624756f, -0.08749674f, 0.19357051f, 0.03379446f, 
    0.00594068f, 0.03392541f, -0.00265379f, 0.02161189f, -0.15402612f, 0.06396244f, -0.11758086f, 0.07398662f, 
    0.00476116f, -0.01089814f, -0.00645142f, -0.02415696f, 0.02445474f, -0.07268569f, -0.01037862f, -0.16271220f, 
    -0.17494373f, 0.14397827f, -0.05966277f, 0.01915546f, -0.05531254f, 0.08961027f, -0.04064514f, -0.05822503f, 
    0.05824935f, 0.03916191f, 0.08693746f, -0.02156545f, 0.04784511f, -0.23407960f, 0.10689071f, -0.34180492f, 
    0.01573626f, 0.04848292f, -0.00168477f, -0.03679724f, -0.06111375f, -0.01604346f, -0.19915478f, -0.21751557f, 
    -0.03125064f, -0.38804889f, 0.25530663f, -0.42962345f, -0.05010523f, -0.17050515f, -0.11807043f, 0.07243063f, 
    0.02293417f, 0.02326746f, -0.01836776f, -0.02511351f, 0.00969794f, -0.11678565f, 0.16272856f, -0.04122841f, 
    0.03273224f, -0.06798343f, 0.01122695f, -0.02020394f, 0.06854054f, -0.05642029f, 0.03629749f, -0.00298782f, 
    -0.10234134f, 0.06222333f, -0.12216265f, 0.04100619f, -0.13165776f, -0.06173557f, 0.09802719f, -0.05712683f, 
    0.04260668f, 0.07078502f, -0.09445492f, 0.11426276f, 0.04715595f, -0.04689792f, -0.09805536f, 0.04563633f, 
    0.00599754f, -0.05479934f, -0.00686546f, -0.11294155f, -0.01355028f, 0.01709601f, -0.04759863f, -0.07405905f, 
    0.06691514f, -0.38839835f, 0.32288522f, -0.15487626f, -0.13511600f, 0.05861830f, -0.03450286f, -0.00149993f, 
    -0.10071965f, 0.00296845f, -0.03112917f, 0.00577247f, 0.06907155f, -0.04904799f, -0.05832037f, -0.05299354f, 
    -0.06705917f, 0.03530832f, 0.06067663f, -0.04302083f, -0.09772170f, -0.01090787f, -0.01767492f, 0.08754549f, 
    0.40994993f, -0.09086867f, 0.04667488f, -0.14527872f, -0.06739733f, 0.03025476f, -0.03699462f, 0.10823733f, 
    0.03848180f, 0.07034550f, 0.09588193f, 0.03287937f, -0.38244221f, -0.07179846f, 0.39978105f, 0.07565512f, 
    0.10056597f, 0.03463071f, 0.03064519f, 0.13050318f, -0.02906740f, -0.04508780f, -0.08078972f, -0.02685208f, 
    -0.39951500f, 0.27549860f, -0.05974785f, 0.10759582f, -0.19264299f, -0.03963092f, -0.04458361f, -0.01692959f, 
    -0.01907334f, -0.08819124f, 0.12061005f, -0.00865125f, 0.10057002f, -0.06120564f, -0.01959926f, -0.03646656f, 
    0.01543405f, -0.02665845f, 0.00977107f, -0.06788933f, -0.02430795f, 0.05945402f, 0.05136603f, -0.05710991f, 
    -0.03108313f, 0.08956902f, 0.13351572f, -0.01375024f, -0.11307692f, 0.13396814f, -0.09781364f, -0.02216631f, 
    -0.03282845f, -0.01810139f, -0.00873281f, 0.06904787f, 0.39104757f, -0.34485576f, -0.23056340f, -0.24704760f, 
    -0.07833986f, 0.01052354f, -0.02026285f, -0.02140835f, 0.16535823f, 0.02322698f, -0.09327279f, 0.03806081f, 
    0.04919706f, 0.12547627f, 0.05940801f, -0.03313667f, -0.00677218f, -0.02415078f, -0.01897963f, -0.01350528f, 
    -0.02620771f, -0.00861116f, 0.06903253f, 0.03088416f, 0.01189260f, 0.00805216f, -0.12628111f, -0.09227799f, 
    -0.04784197f, 0.11926126f, 0.01266296f, -0.11547328f, -0.08798915f, 0.05907650f, -0.01985857f, -0.03105488f, 
    -0.22589996f, 0.08130336f, 0.10372537f, 0.02694470f, -0.00474043f, 0.02096885f, -0.00342986f, 0.01673375f, 
    0.07744208f, 0.02976380f, 0.02346946f, -0.09678401f, 0.31945795f, -0.08715770f, -0.28972685f, -0.05397171f, 
    -0.14309178f, -0.03846077f, -0.01188426f, -0.04921273f, -0.07564003f, 0.06920531f, -0.03821994f, -0.06197942f, 
    0.13212046f, 0.10521557f, -0.01653729f, -0.07814518f, -0.02366515f, 0.03800871f, 0.06309272f, -0.01392331f, 
    -0.01641089f, 0.00714531f, 0.02121099f, 0.01063522f, 0.25262585f, -0.60954672f, -0.34614307f, -0.58795846f, 
    -0.05697583f, -0.06794745f, -0.11905192f, 0.23459221f, 0.02066165f, 0.01933692f, 0.06845808f, -0.06411806f, 
    -0.17782186f, -0.10477588f, -0.05844846f, 0.11871278f, -0.08091973f, 0.03440933f, 0.05675768f, 0.05158026f, 
    0.00586857f, -0.03967022f, 0.05152813f, 0.00235626f, -0.00179007f, -0.12530391f, 0.10708133f, 0.07216132f, 
    -0.02247559f, 0.01147180f, -0.02285824f, -0.00270133f, 0.11674394f, 0.13026461f, 0.03786387f, 0.09850760f, 
    -0.21592180f, -0.00051150f, -0.09375346f, -0.00006715f, -0.08231555f, -0.04084426f, 0.09409142f, -0.08333625f, 
    -0.03902980f, -0.12755504f, -0.04156808f, -0.09934240f, 0.02166169f, 0.02562673f, 0.02081925f, -0.03733771f, 
    -0.02745343f, -0.02011548f, -0.01745441f, 0.02170101f, 0.02811694f, -0.02160646f, 0.04234869f, -0.00950632f, 
    0.07278028f, 0.01353500f, 0.03581528f, 0.01049589f, 0.05376389f, 0.00914295f, -0.01970105f, -0.04456200f, 
    -0.03530889f, -0.02319990f, 0.01113367f, -0.01062367f, 0.12053871f, 0.07186370f, 0.02999231f, -0.04945111f, 
    -0.01525088f, 0.04780161f, -0.04573490f, -0.02654874f, -0.12492213f, -0.11249412f, -0.08569767f, -0.08617106f, 
    -0.00637419f, 0.00236787f, -0.01244153f, -0.08478955f, 0.02673198f, 0.03140770f, 0.08452775f, -0.02146601f, 
    -0.18794572f, -0.11675654f, -0.09404512f, -0.06148133f, -0.10401574f, 0.07203548f, -0.26591164f, 0.09105165f, 
    -0.04177751f, 0.07927328f, -0.05610023f, -0.12277430f, 0.06176104f, 0.12020034f, 0.06696097f, -0.03593073f, 
    0.00235638f, -0.00253405f, 0.05842625f, 0.03158174f, 0.01024214f, -0.05466256f, 0.00693848f, -0.02083968f, 
    0.06489795f, -0.09481689f, 0.06695943f, -0.04023200f, 0.40295967f, -0.28844401f, -0.02285666f, -0.06410874f, 
    -0.04112690f, 0.08831548f, -0.09294853f, -0.01443594f, -0.04804576f, 0.03655057f, -0.00909896f, -0.05962139f, 
    -0.08118150f, -0.07264989f, -0.11137339f, -0.00438936f, 0.00702034f, -0.03206161f, 0.06203086f, 0.04328149f, 
    0.06740896f, 0.22837776f, 0.05623305f, 0.01566702f, 0.21222474f, -0.13640137f, 0.05127054f, -0.10189781f, 
    -0.03123416f, 0.00333374f, -0.06934701f, -0.03141389f, -0.01714205f, 0.13783962f, -0.05337407f, 0.00691211f, 
    0.11029852f, -0.14485790f, -0.00400134f, -0.16876388f, 0.00222609f, -0.03530699f, 0.04701573f, 0.01265125f, 
    -0.04746816f, 0.20365725f, 0.15582436f, 0.04059234f, -0.10119525f, -0.01156707f, -0.16475250f, 0.02677763f, 
    -0.05666771f, -0.11808126f, 0.04049476f, 0.11857688f, -0.02723087f, 0.07313620f, 0.04818912f, -0.00590084f, 
    -0.11253936f, 0.13906133f, 0.00100666f, 0.05309043f, -0.05498185f, -0.07537501f, 0.03065475f, 0.02009670f, 
    0.03196940f, 0.06120568f, 0.08446014f, 0.00034339f, 0.55017197f, -0.37150019f, 0.15391193f, -0.10994605f, 
    -0.06291194f, 0.19172464f, -0.05632028f, -0.05168370f, 0.03013924f, 0.13632348f, -0.00053177f, -0.13036393f, 
    -0.18206514f, -0.07669219f, -0.19501334f, 0.02090128f, -0.04000927f, -0.09487303f, 0.06148354f, -0.21540381f, 
    -0.21067092f, 0.08215230f, 0.00390400f, 0.02021584f, -0.25299770f, 0.24186006f, -0.25550577f, 0.27326137f, 
    -0.01552345f, -0.01831792f, 0.18176968f, 0.03040070f, 0.11404611f, 0.05740359f, 0.01987404f, -0.20465966f, 
    0.14270763f, -0.37418008f, 0.37695599f, 0.38323644f, -0.11307406f, -0.06769341f, -0.06531259f, 0.10861378f, 
    -0.01655384f, -0.10457877f, 0.02757706f, 0.07824337f, -0.63268095f, 0.64198345f, 0.17909087f, 0.28041777f, 
    -0.04120775f, -0.02538855f, 0.09855613f, -0.02098437f, 0.02200211f, -0.08937756f, 0.02361676f, -0.08595759f, 
    -0.02997039f, -0.38490915f, -0.45481813f, -0.06825900f, -0.00337813f, 0.13749354f, 0.00768431f, 0.09605432f, 
    0.05909869f, -0.04641174f, -0.10881370f, 0.04273088f, -0.04764698f, -0.28870901f, -0.05907026f, -0.16182418f, 
    0.08697761f, -0.06912687f, 0.06734737f, -0.01911389f, 0.05655725f, -0.03950099f, -0.05669986f, 0.01396380f, 
    -0.17645596f, 0.41174629f, -0.03732741f, 0.37818107f, 0.02807713f, -0.01109756f, 0.06392384f, 0.07846767f, 
    -0.08357517f, -0.00148904f, 0.00399134f, 0.14973587f, 0.00312755f, -0.14153764f, 0.06661041f, -0.19551392f, 
    -0.00495726f, -0.00164935f, -0.03235266f, -0.03038804f, -0.05343238f, -0.14535619f, 0.04432300f, -0.18841302f, 
    0.12376516f, 0.08491329f, 0.02435048f, -0.03580699f, 0.03362114f, -0.00036506f, -0.00305873f, -0.06308265f, 
    -0.10632094f, -0.00099224f, 0.00461660f, -0.10518733f, 0.45761961f, -0.44881091f, -0.33930448f, -0.41231388f, 
    0.02434818f, -0.07211468f, -0.01939579f, 0.01291162f, 0.03367375f, 0.06040099f, 0.07658781f, 0.03726967f, 
    -0.37821609f, -0.28691596f, -0.31004333f, -0.07651029f, -0.00406134f, -0.10918789f, -0.00026446f, 0.02810386f, 
    0.10842454f, 0.04138188f, -0.00198130f, -0.01025507f, 0.00991733f, -0.08509374f, 0.50189930f, -0.16888359f, 
    -0.12601444f, -0.04105075f, -0.03794687f, 0.11652052f, -0.14181162f, 0.01530745f, -0.06972058f, 0.06693841f, 
    -0.09727323f, -0.21206334f, -0.32225400f, -0.40715653f, -0.06405773f, 0.03428801f, -0.02808995f, 0.07461877f, 
    0.06904798f, -0.06998836f, -0.04715178f, 0.02261796f, -0.30981627f, -0.27270836f, -0.16548362f, 0.28015146f, 
    0.07253913f, 0.08924710f, -0.02238437f, -0.04304112f, 0.02647805f, 0.03040306f, 0.00308407f, -0.03466108f, 
    -0.14280775f, 0.10774650f, 0.07406463f, -0.05965514f, -0.11645075f, -0.15462385f, -0.10369342f, 0.05462117f, 
    -0.03218598f, 0.02930245f, 0.01302783f, -0.00096869f, -0.22969556f, -0.17499150f, -0.20819081f, -0.08448002f, 
    0.07602734f, 0.09065514f, 0.08614273f, 0.05158814f, -0.02283534f, -0.02391068f, -0.03714992f, -0.02715717f, 
    0.05469049f, 0.10478227f, 0.02813513f, -0.04283261f, -0.08738393f, 0.03217221f, 0.03175506f, 0.00354649f, 
    -0.08752959f, -0.00531463f, 0.00978512f, 0.01402508f, 0.18983307f, 0.15025061f, 0.08775873f, -0.18009114f, 
    0.03387362f, 0.01941987f, 0.00824331f, -0.00533714f, -0.01483050f, -0.12219172f, -0.07258879f, -0.25245380f, 
    -0.08771103f, -0.11041459f, -0.11673972f, -0.01720272f, -0.06381429f, 0.03621071f, -0.03642410f, 0.01472723f, 
    0.00255968f, -0.04713424f, -0.06540551f, -0.02380549f, 0.08635968f, 0.02807705f, -0.02335304f, 0.00719178f, 
    0.15886013f, -0.04491457f, -0.08415118f, 0.03965729f, 0.03620181f, 0.09469216f, 0.05771216f, 0.08771580f, 
    0.07860059f, -0.17063610f, -0.19517426f, -0.18324268f, -0.08091932f, -0.06914940f, -0.04058074f, -0.15031649f, 
    -0.05681247f, -0.05228515f, -0.00997907f, -0.05248830f, 0.28808370f, 0.04145619f, -0.09378827f, -0.08445233f, 
    0.08707312f, -0.01353241f, 0.07708438f, -0.06564651f, 0.17635378f, 0.08469331f, 0.03447248f, 0.05655328f, 
    -0.09426646f, -0.56733298f, -0.08107352f, -0.06230225f, -0.06785826f, 0.05106671f, -0.12918581f, -0.18062024f, 
    -0.06117164f, 0.06932984f, 0.04765640f, 0.08066291f, -0.26014817f, -0.14313725f, 0.03297133f, 0.22556640f, 
    0.04729434f, 0.04657964f, 0.01584076f, 0.13781086f, -0.09523608f, 0.07433688f, 0.06283218f, 0.04905763f, 
    -0.10865901f, -0.35004809f, -0.37477687f, -0.04242584f, 0.00951254f, -0.08086105f, 0.07858720f, -0.07976465f, 
    -0.03231922f, -0.02204410f, 0.01518363f, 0.04023240f, -0.24963492f, -0.08051226f, 0.08219497f, 0.18330675f, 
    0.12978521f, 0.01018919f, 0.09026302f, -0.11449695f, 0.00267038f, -0.09763686f, 0.05294815f, 0.05919314f, 
    -0.38096863f, -0.33600339f, 0.00691630f, 0.19761603f, -0.02115810f, 0.05737425f, 0.02192073f, 0.03134684f, 
    0.03979520f, 0.05537970f, 0.06512741f, 0.24086265f, -0.27963114f, 0.20537788f, 0.00817332f, 0.08996587f, 
    0.10286543f, -0.03730443f, -0.04830039f, 0.03202957f, -0.00400211f, -0.01365239f, 0.13323823f, 0.04741578f, 
    -0.56771064f, 0.10165643f, 0.09755129f, 0.20011219f, 0.24643256f, -0.04162856f, -0.10588025f, 0.06800885f, 
    -0.08514657f, -0.05545025f, 0.05167123f, -0.00221725f, 0.15428537f, -0.19921164f, -0.13836060f, -0.13411500f, 
    -0.07295457f, -0.06269516f, 0.02743526f, 0.02647367f, 0.04016409f, -0.07214640f, 0.14419720f, -0.06246844f, 
    0.26385251f, 0.05139958f, -0.13753548f, -0.17093486f, -0.16604738f, 0.08966257f, -0.01004800f, 0.02442177f, 
    -0.04042791f, 0.03089630f, -0.00743677f, 0.11989470f, -0.34886622f, 0.18682137f, 0.09593302f, 0.00213032f, 
    -0.01944429f, -0.07874083f, -0.12207586f, -0.15129866f, 0.05019959f, 0.14391686f, -0.13936576f, 0.13684136f, 
    0.50611180f, 0.17477801f, -0.12794931f, -0.01378864f, 0.13782114f, 0.02303532f, 0.00155684f, 0.00100080f, 
    0.03083641f, 0.03550979f, 0.02989901f, -0.03062794f, 0.00683345f, -0.02833130f, 0.03779650f, 0.07473829f, 
    0.07698882f, -0.01157571f, -0.05126730f, -0.04964378f, 0.00092763f, -0.16112822f, -0.08361783f, -0.02360369f, 
    0.47570300f, 0.23696443f, 0.05115726f, -0.37344387f, 0.05304221f, -0.11172348f, 0.10206442f, -0.09179547f, 
    -0.05239297f, 0.10076180f, -0.04404629f, 0.03415957f, -0.01244824f, 0.02571333f, 0.01418951f, -0.06403470f, 
    0.05261469f, -0.03871360f, 0.03857547f, -0.06866933f, -0.09338307f, 0.02795120f, -0.10219748f, -0.02732337f, 
    -0.11475918f, -0.30895075f, -0.32455525f, -0.13885714f, -0.04212123f, 0.14318103f, 0.09264546f, -0.02674276f, 
    -0.04092629f, 0.12383041f, 0.07378753f, 0.10732518f, 0.29250804f, -0.31436557f, -0.45135796f, -0.26116902f, 
    -0.32847273f, -0.05304315f, 0.02291309f, -0.21271464f, 0.02907537f, 0.06701589f, 0.06730115f, 0.06534728f, 
    -0.37230432f, 0.22448663f, -0.07663439f, -0.17746207f, 0.17508321f, -0.19141181f, -0.13244143f, 0.04879208f, 
    -0.03861541f, -0.00513717f, 0.01527489f, -0.04479134f, 0.15812267f, 0.11695086f, 0.05085606f, -0.14524396f, 
    -0.10503563f, -0.09589256f, 0.02341694f, -0.02653854f, -0.00808888f, -0.17843105f, -0.03083332f, 0.08114326f, 
    -0.17301184f, 0.07849093f, 0.04023921f, 0.12196506f, 0.02946177f, 0.03806690f, -0.10013850f, -0.07739543f, 
    -0.02651988f, 0.01897091f, -0.01430711f, -0.04399673f, -0.49988687f, -0.35774338f, -0.09491222f, -0.01446515f, 
    -0.01062252f, 0.05171909f, 0.00095331f, 0.06436856f, 0.04718477f, 0.08604689f, -0.01176135f, -0.16355853f, 
    -0.30478743f, 0.13076027f, 0.05329353f, 0.10374489f, -0.12007391f, -0.02472296f, 0.01916042f, -0.13247441f, 
    -0.05726803f, -0.09306499f, 0.02275826f, -0.04384326f, 0.29962251f, 0.10483879f, 0.12158126f, 0.03249213f, 
    -0.06529468f, -0.04666784f, -0.04100367f, 0.03008368f, 0.12533592f, -0.04650464f, 0.14843060f, 0.04325581f, 
    -0.05652437f, -0.03011131f, 0.11536726f, -0.04976263f, -0.15531856f, -0.02708014f, 0.10172431f, 0.00026651f, 
    -0.09079862f, 0.07819463f, 0.04173570f, -0.01144481f, 0.27042091f, 0.07834938f, -0.30397642f, -0.05016804f, 
    -0.14625318f, 0.10188746f, -0.02887409f, 0.03644197f, 0.03560400f, 0.13638240f, 0.20569073f, 0.00652184f, 
    -0.15501167f, -0.14368272f, -0.04576628f, -0.20644785f, -0.09475646f, -0.01813246f, -0.04252836f, -0.09989978f, 
    -0.28066227f, -0.06062813f, -0.30511665f, -0.26479751f, 0.16108918f, 0.14724906f, -0.27275434f, -0.00875354f, 
    -0.01529952f, -0.03294031f, 0.12954648f, 0.06245025f, -0.00064288f, -0.00163142f, 0.03991891f, -0.06024680f, 
    0.08806226f, 0.16976547f, 0.07377837f, -0.06667318f, 0.02879050f, -0.06500273f, -0.01322121f, -0.23709626f, 
    0.03606684f, 0.09149063f, -0.03458603f, -0.00632869f, -0.16801737f, 0.03782298f, -0.03982935f, 0.00558501f, 
    0.05340807f, 0.02901163f, -0.00553643f, 0.02509092f, -0.20235503f, -0.00737417f, -0.05252149f, -0.44422185f, 
    -0.26397371f, -0.10060484f, 0.16228189f, 0.24451700f, 0.02207785f, 0.05831454f, 0.07185672f, -0.00753411f, 
    -0.08359389f, -0.00128918f, 0.12277376f, -0.06809996f, -0.05420820f, 0.09521385f, -0.00940506f, -0.08309438f, 
    -0.06331151f, -0.06910983f, -0.05448937f, -0.07078790f, 0.04520405f, 0.04422630f, 0.03395997f, 0.02418563f, 
    -0.15671526f, -0.00870084f, -0.00629403f, -0.00624331f, 0.07446624f, -0.00809851f, -0.01279587f, 0.07677246f, 
    0.09743129f, 0.05400201f, 0.06036858f, 0.14707941f, -0.05100007f, -0.05032150f, -0.07606748f, -0.09076164f, 
    -0.05778412f, 0.00950106f, -0.02202787f, 0.01408004f, 0.06585611f, 0.09458374f, 0.10056328f, 0.11878927f, 
    -0.18154384f, 0.01988646f, -0.00571608f, 0.03311364f, -0.00366215f, 0.04806499f, 0.02304918f, -0.01648991f, 
    0.12322897f, 0.09368086f, -0.03364762f, 0.08503917f, 0.14516287f, 0.22833370f, -0.03568258f, 0.19723435f, 
    0.08882277f, -0.01819201f, 0.06040684f, 0.10061541f, 0.02136097f, 0.00584418f, -0.03693243f, 0.12112325f, 
    -0.21801886f, -0.02544404f, 0.01893777f, 0.00207117f, -0.01657801f, -0.02978694f, -0.00354778f, 0.00649901f, 
    0.09837568f, 0.06746273f, 0.03501859f, 0.10770670f, 0.29783511f, -0.09948076f, -0.42720246f, -0.21654685f, 
    0.19978863f, -0.01139964f, 0.02712790f, 0.05528938f, 0.08997093f, -0.02813097f, 0.15580477f, 0.18829150f, 
    -0.11260695f, -0.09396283f, -0.08366685f, -0.02591364f, 0.06136331f, 0.02584453f, -0.06044438f, 0.08376081f, 
    -0.25350705f, -0.31110194f, -0.30097970f, -0.29100323f, 0.01097453f, -0.10494830f, -0.10670704f, -0.27646571f, 
    0.06772802f, 0.02165116f, 0.00482437f, 0.09141547f, 0.17409414f, -0.02079613f, 0.27971736f, 0.00212531f, 
    0.01561020f, -0.02914662f, -0.02729287f, -0.05063139f, -0.03129919f, -0.03820819f, 0.00852300f, -0.02210245f, 
    -0.03309415f, -0.17387281f, -0.22903076f, -0.30249742f, -0.07100085f, 0.00913576f, 0.10630070f, 0.07066424f, 
    0.19988994f, 0.00893369f, -0.12111292f, -0.02808679f, -0.04255628f, -0.08721454f, -0.00327549f, -0.01895719f, 
    -0.13355674f, 0.00902728f, 0.11704634f, 0.01669459f, -0.02698167f, -0.06393522f, 0.09283518f, -0.03592516f, 
    -0.14187807f, -0.05936269f, -0.09398618f, 0.03303106f, 0.29367238f, 0.03259045f, -0.31638932f, -0.17635089f, 
    0.04020441f, -0.09276046f, -0.03972549f, -0.12016336f, 0.01194152f, 0.08749489f, -0.00039628f, -0.01102745f, 
    -0.18656880f, -0.20370567f, -0.07800820f, -0.06357469f, 0.03533776f, 0.04257003f, 0.09196151f, 0.08454990f, 
    -0.02008779f, -0.08923361f, 0.03455971f, -0.01264601f, -0.50302672f, -0.07645463f, 0.20473948f, 0.22136576f, 
    0.06049694f, 0.03504212f, -0.09501503f, 0.08818197f, -0.20526682f, -0.07604600f, -0.11871770f, -0.06092891f, 
    -0.00365939f, -0.32355225f, -0.24316053f, -0.49017364f, 0.11007775f, -0.01039107f, 0.06713794f, 0.03645549f, 
    0.05879880f, 0.02412825f, -0.10875957f, -0.19539843f, -0.84342563f, -0.06217442f, -0.27871609f, -0.01930019f, 
    0.08441305f, 0.01546357f, 0.00500681f, -0.05975226f, 0.07587463f, 0.01585801f, 0.04452278f, 0.04828379f, 
    -0.04866233f, -0.04643136f, -0.22167125f, 0.10415474f, 0.03349842f, 0.11410233f, 0.03108164f, 0.18041624f, 
    -0.02190858f, -0.00708201f, -0.10298110f, -0.15927866f, 0.13046318f, 0.16745092f, 0.01553298f, 0.08404801f, 
    -0.02074714f, 0.04125754f, 0.01928511f, -0.13015045f, -0.00325062f, -0.01788143f, -0.01990395f, -0.04396398f, 
    -0.28547245f, -0.20313977f, 0.14333148f, -0.10391738f, -0.20707494f, 0.01717865f, 0.15981606f, 0.04633645f, 
    -0.01038590f, 0.08220063f, 0.17152816f, 0.16848037f, -0.09641409f, 0.15140018f, -0.05741768f, 0.10881325f, 
    0.05129356f, 0.01130991f, 0.04579955f, -0.03084731f, 0.04762984f, 0.06840661f, -0.00200785f, 0.25180608f, 
    -0.03442262f, -0.09608921f, -0.07053559f, -0.14213733f, -0.04015072f, -0.03173260f, -0.06807794f, -0.01322206f, 
    0.05874249f, -0.03364184f, -0.00898502f, -0.09541360f, -0.30417389f, -0.69702804f, -0.47876853f, -0.19194272f, 
    0.03587781f, 0.28589752f, 0.15667550f, 0.13637789f, -0.11514705f, 0.09181693f, -0.06305175f, 0.07572320f, 
    -0.09586331f, -0.24989577f, -0.20502040f, 0.08759790f, 0.12885606f, 0.13987359f, 0.08016070f, 0.11144069f, 
    -0.19230439f, -0.12132991f, -0.10944660f, -0.11341137f, -0.05794986f, -0.15733865f, -0.06859092f, -0.10140437f, 
    -0.06256811f, -0.04171762f, 0.15190336f, -0.00721681f, 0.15222321f, 0.02386744f, 0.17774349f, 0.02765432f, 
    0.11996048f, -0.11441734f, -0.32590422f, 0.17701316f, 0.20704786f, -0.04706420f, 0.07475555f, -0.09192513f, 
    0.00384116f, -0.05313360f, -0.00111634f, -0.01527599f, -0.09565867f, -0.11540675f, -0.05521605f, -0.07152738f, 
    0.06525417f, -0.02651194f, 0.04521908f, 0.15032806f, -0.01267819f, 0.02923653f, 0.00195671f, 0.01565844f, 
    -0.19756098f, -0.06122873f, 0.07938987f, -0.01737595f, 0.00449900f, 0.04834512f, -0.12443743f, -0.01140922f, 
    0.02088864f, 0.06034566f, 0.13789344f, 0.03497380f, -0.04843593f, -0.41482350f, -0.17038509f, -0.03782009f, 
    0.00288564f, 0.09181990f, 0.03357248f, -0.04160434f, -0.08192132f, -0.05670635f, -0.00306412f, -0.06791876f, 
    -0.09188499f, 0.01204282f, 0.02303362f, 0.01307938f, -0.00795472f, -0.01286637f, -0.02376799f, 0.05449377f, 
    0.06148532f, 0.04455074f, 0.11083622f, 0.07126091f, 0.00189958f, -0.08323483f, -0.13842900f, -0.17916320f, 
    -0.13173869f, -0.08035538f, 0.03160333f, 0.02296138f, 0.11147413f, 0.08779286f, 0.14006628f, 0.07572041f, 
    -0.10317340f, -0.22268060f, -0.09481096f, 0.01837029f, 0.23225667f, 0.03018002f, 0.07839496f, 0.15461408f, 
    -0.08090119f, -0.02723770f, -0.06202250f, -0.07727658f, -0.01802704f, -0.07228690f, -0.08703702f, -0.11982405f, 
    -0.07447685f, -0.00706076f, 0.10895268f, 0.09061052f, 0.03231950f, -0.15728800f, -0.02187114f, -0.04472405f, 
    -0.20636927f, 0.02025102f, 0.30617803f, -0.17482677f, -0.01166508f, -0.14672485f, 0.01555934f, 0.01657986f, 
    0.04089044f, 0.07330299f, 0.03027862f, -0.01481395f, -0.10674791f, -0.11120820f, 0.07018773f, 0.23831177f, 
    0.18159746f, -0.10988547f, -0.03617908f, 0.01229307f, 0.12685698f, 0.02957336f, -0.04149330f, -0.08876658f, 
    0.19819945f, 0.37609833f, -0.13505550f, -0.64120466f, -0.03148222f, -0.08257153f, 0.11315912f, 0.17034301f, 
    0.07008435f, 0.00367911f, 0.03531777f, -0.03268402f, -0.02168347f, 0.51571804f, -0.06643894f, -0.62819171f, 
    -0.16679206f, -0.05998730f, 0.08805121f, -0.07049391f, 0.13571736f, -0.00237493f, -0.03343710f, 0.12043646f, 
    -0.09794630f, -0.07735599f, -0.10335530f, -0.32641056f, -0.31617612f, -0.02198936f, 0.02499044f, 0.05891392f, 
    0.07307343f, -0.05725603f, 0.05885087f, 0.05336667f, -0.58011371f, -0.09353940f, -0.51486653f, 0.12248391f, 
    0.12422559f, -0.30205646f, 0.06048642f, 0.05916592f, -0.08241625f, 0.03605863f, 0.03122058f, -0.01668314f, 
    0.20167707f, -0.21548001f, 0.05026888f, -0.32718620f, 0.07670776f, -0.16958740f, 0.04529111f, 0.00321371f, 
    -0.06552291f, -0.00904409f, -0.06625035f, -0.02321896f, -0.20347923f, 0.29236072f, -0.14131990f, -0.14270511f, 
    -0.07438454f, -0.04470685f, 0.10170662f, -0.00395477f, 0.11889990f, -0.01555952f, 0.01546323f, -0.02112260f, 
    -0.12509018f, 0.23700523f, -0.56833255f, -0.04711207f, 0.00371223f, -0.06898569f, 0.14088933f, -0.18569988f, 
    0.09925900f, -0.00223395f, -0.08312608f, 0.11802679f, 0.26292539f, -0.21109593f, 0.22924684f, 0.13207512f, 
    -0.06904916f, 0.02647093f, -0.12809667f, -0.16657820f, -0.12191564f, 0.04148542f, 0.03408076f, 0.07821231f, 
    -0.36790168f, -0.53997052f, 0.11405320f, -0.19029357f, -0.10480493f, 0.12437610f, -0.29689351f, 0.18487278f, 
    0.05146268f, -0.08743210f, -0.05344998f, -0.04412672f, 0.14993760f, -0.33772349f, -0.14328901f, 0.01556492f, 
    0.10200807f, -0.03118906f, 0.09272167f, -0.01901381f, 0.08541251f, -0.08317434f, 0.04881563f, -0.01303215f, 
    -0.15843633f, -0.01180168f, -0.42612654f, 0.02787942f, 0.13180012f, -0.06633458f, 0.09576892f, 0.00493353f, 
    0.02518899f, 0.00338261f, 0.00118801f, -0.03751677f, -0.19483671f, -0.04830420f, -0.22721128f, 0.00663365f, 
    0.17175095f, -0.10039896f, 0.12794559f, 0.05440112f, -0.02383214f, -0.19070479f, -0.09816713f, 0.00932145f, 
    -0.29959682f, -0.40783140f, -0.04643348f, 0.07849137f, -0.06769602f, 0.03316778f, -0.02581708f, -0.02074386f, 
    -0.00471228f, -0.03926404f, 0.00793358f, -0.06774319f, -0.02031138f, 0.02630453f, -0.34637004f, 0.08629770f, 
    0.14622892f, 0.03345225f, 0.04637250f, 0.25932878f, 0.08516327f, 0.10637297f, -0.06087936f, -0.02658726f, 
    0.08803299f, 0.17518847f, -0.00962908f, 0.14927751f, -0.05562628f, -0.02105660f, -0.33915341f, 0.03767814f, 
    -0.08033317f, -0.21740803f, -0.07625595f, -0.06069403f, -0.18585102f, -0.30227003f, 0.16273771f, -0.20680007f, 
    -0.06783585f, -0.08267079f, -0.06124754f, 0.17631096f, 0.02448042f, 0.00828612f, 0.07183049f, -0.03733434f, 
    -0.14457142f, -0.06860463f, -0.40439934f, 0.15916896f, -0.04015703f, 0.00113396f, 0.04027474f, 0.19459014f, 
    -0.00933618f, -0.01614707f, -0.02351862f, -0.11441091f, 0.00766974f, -0.31402138f, 0.14446042f, -0.01088953f, 
    0.11313350f, 0.07514273f, -0.15322606f, 0.05075110f, 0.01917795f, -0.05788361f, 0.02892397f, 0.07367884f, 
    -0.22293818f, -0.15543573f, -0.33808312f, -0.08824605f, -0.13419138f, 0.13666156f, 0.10519447f, -0.11405776f, 
    0.01566570f, 0.11234982f, -0.09553935f, -0.03603118f, 0.28634048f, 0.22088777f, 0.11430386f, 0.08342304f, 
    -0.06483243f, -0.04891678f, -0.06622823f, -0.18376276f, -0.04140515f, 0.05835473f, 0.04850688f, 0.02601891f, 
    0.09983922f, -0.38208705f, 0.03253117f, -0.12256524f, 0.03729253f, -0.02198684f, 0.13886116f, 0.13836056f, 
    -0.09267529f, 0.03907116f, -0.05369288f, 0.00189863f, -0.41333404f, -0.34791186f, -0.07264949f, -0.18789566f, 
    0.27995911f, 0.02008307f, 0.01181913f, 0.14502136f, 0.03627961f, -0.00206285f, -0.08139335f, -0.04950027f, 
    0.09290379f, -0.13601694f, 0.05919033f, -0.36317927f, -0.03169414f, 0.12239996f, -0.06455968f, -0.04598702f, 
    0.12033394f, 0.03670214f, -0.07487660f, -0.01510535f, -0.27880982f, -0.13882847f, 0.17075866f, 0.22330055f, 
    0.05337625f, 0.05536366f, -0.21510716f, -0.10839884f, -0.08978657f, -0.16802441f, 0.14798081f, -0.08440689f, 
    -0.01442560f, -0.11197973f, 0.06603823f, -0.02323559f, 0.03144837f, 0.23527701f, -0.01723084f, 0.02481896f, 
    0.06404348f, 0.10175967f, 0.09135130f, 0.04486524f, 0.17325975f, -0.05187644f, 0.18719599f, 0.41297206f, 
    0.10982136f, -0.00162757f, -0.07764057f, -0.01895029f, -0.00604015f, -0.05657513f, 0.00746163f, 0.13746160f, 
    0.28554738f, -0.09733023f, -0.18479705f, -0.03850305f, 0.04208165f, 0.07606021f, 0.08367573f, 0.00297617f, 
    -0.09681912f, -0.00932034f, -0.06607225f, -0.06926140f, -0.00802022f, 0.06083040f, -0.01579062f, 0.01757549f, 
    -0.03480701f, -0.00263174f, 0.05868360f, 0.03123999f, 0.06142309f, 0.13487743f, 0.18240297f, 0.15147527f, 
    -0.08051946f, 0.11095671f, 0.31602663f, -0.54574150f, -0.03516134f, -0.00135536f, 0.11941704f, -0.08949817f, 
    -0.00127255f, 0.00320454f, 0.05362973f, 0.01631537f, 0.14081807f, -0.05186060f, -0.06445943f, 0.06659456f, 
    0.17321025f, 0.14294896f, 0.07180934f, 0.00160740f, 0.12755527f, -0.06189310f, -0.05048661f, -0.02591908f, 
    0.11109885f, -0.09247521f, 0.12065958f, -0.04598594f, 0.05136813f, -0.13702857f, 0.00468845f, -0.08300674f, 
    -0.09106932f, 0.04642732f, -0.00918332f, -0.04924169f, 0.03345564f, 0.07073294f, 0.01539484f, 0.09865176f, 
    0.01690639f, 0.02046050f, -0.00065637f, -0.07212390f, 0.06187802f, -0.06801023f, 0.02451930f, -0.10322180f, 
    0.18528846f, -0.15583318f, 0.23825686f, -0.18718135f, 0.08133378f, -0.12012917f, -0.07158112f, 0.01215470f, 
    -0.09690084f, 0.07716872f, 0.02374292f, -0.06620190f, -0.54773885f, 0.10782995f, -0.80954987f, 0.05543077f, 
    0.01096514f, -0.12148301f, 0.04786592f, 0.07231149f, 0.09597423f, -0.15333228f, -0.15089910f, -0.07998286f, 
    -0.12807693f, 0.01922884f, 0.02484615f, -0.08245716f, 0.08967379f, -0.12538382f, 0.15384041f, -0.10934761f, 
    0.09934153f, -0.06476471f, -0.18151489f, -0.15584207f, 0.07388440f, -0.22965837f, 0.23632009f, 0.18149641f, 
    0.08492511f, -0.09661096f, -0.00071830f, -0.06589136f, 0.00132679f, -0.02334617f, -0.06682613f, 0.05431671f, 
    0.10446183f, 0.18971391f, 0.29445231f, -0.12658556f, -0.14521138f, -0.07789480f, 0.09565834f, -0.02402787f, 
    -0.02753568f, 0.16391152f, 0.02844145f, 0.01183895f, -0.06158696f, 0.19890824f, 0.22737263f, 0.32977274f, 
    0.05642034f, -0.11420911f, -0.10196472f, -0.10183465f, 0.05797270f, 0.07557330f, 0.06911699f, 0.03917381f, 
    0.11437605f, -0.11500505f, 0.04669043f, -0.09784953f, -0.01975174f, 0.07319120f, -0.03525628f, 0.06115291f, 
    0.00243517f, 0.02776197f, 0.07771680f, 0.16820635f, 0.34348199f, 0.24891715f, -0.26936668f, -0.13929343f, 
    -0.03326016f, -0.04723046f, 0.03624133f, 0.17497672f, -0.00998262f, 0.01414152f, -0.03338284f, 0.04134765f, 
    0.04284764f, 0.12371575f, -0.00251961f, -0.36911371f, 0.06971391f, 0.02412074f, 0.16917054f, -0.02707974f, 
    0.05819172f, 0.00693906f, -0.18877633f, 0.01054090f, -0.25991076f, -0.16737181f, 0.20198084f, 0.26192451f, 
    -0.05494749f, -0.19141474f, 0.06040996f, -0.07380686f, 0.12747759f, 0.09006961f, -0.08369639f, -0.06295895f, 
    -0.24415192f, 0.12402754f, 0.51682729f, -0.30021545f, 0.12992404f, -0.13433313f, 0.09276040f, -0.14834730f, 
    -0.08950058f, 0.00128122f, 0.11106353f, 0.04386378f, -0.42004108f, 0.16803287f, -0.23313041f, -0.10266339f, 
    0.08327017f, -0.05804443f, 0.17524946f, 0.07832916f, 0.02135312f, 0.03144672f, -0.03290948f, 0.07403072f, 
    -0.07433068f, -0.21289630f, 0.08523749f, 0.24482095f, -0.08866967f, 0.10073437f, 0.08044999f, 0.02330605f, 
    0.09086364f, 0.12722699f, 0.03088377f, 0.11718345f, 0.31446737f, -0.15630405f, -0.00777797f, -0.11241039f, 
    -0.08926276f, -0.00986329f, 0.02221286f, 0.15483294f, 0.11749833f, 0.05780060f, -0.05912559f, -0.06944196f, 
    -0.70203424f, 0.04647481f, -0.30895233f, -0.11624334f, 0.01530051f, 0.00533252f, -0.09653155f, -0.00523343f, 
    0.14667392f, -0.01237005f, 0.01962367f, -0.00355666f, -0.15789440f, 0.00976659f, 0.01073860f, -0.14931703f, 
    0.01073281f, -0.03426092f, -0.03427956f, -0.16924180f, 0.06783336f, 0.02700217f, -0.08911717f, -0.01483354f, 
    -0.28974032f, 0.09538794f, 0.03545874f, -0.25371879f, 0.07321505f, -0.07353897f, -0.12969524f, -0.04016710f, 
    0.10418686f, -0.02773686f, -0.03309789f, -0.00443615f, 0.06043837f, -0.07869102f, 0.16696490f, -0.15956295f, 
    0.01370480f, -0.03613814f, -0.00901415f, -0.16028838f, 0.13498276f, 0.06677005f, -0.17704514f, -0.02399971f, 
    -0.07516130f, -0.04652558f, 0.19097611f, 0.09786079f, -0.03428018f, 0.08809651f, -0.04512887f, -0.05921230f, 
    -0.02649286f, 0.02898918f, 0.01712521f, -0.03073799f, -0.16327873f, 0.17031719f, -0.13468131f, -0.00699677f, 
    -0.10024891f, -0.21282737f, -0.12073637f, -0.07165384f, 0.08211733f, -0.12538716f, -0.00026756f, 0.07360230f, 
    0.07721663f, 0.07772616f, 0.09961653f, -0.10786571f, 0.00630069f, -0.11207151f, -0.02706140f, 0.06579116f, 
    -0.01648469f, 0.08013072f, 0.10744385f, 0.10730190f, -0.00371664f, -0.15925458f, -0.03175968f, 0.00728931f, 
    0.01371735f, 0.11906673f, 0.11132748f, 0.07111321f, 0.02287823f, 0.04228970f, -0.01522174f, -0.19635554f, 
    -0.29103434f, 0.12519649f, -0.42920586f, -0.56763202f, -0.11104567f, -0.10880089f, -0.15346628f, -0.00256220f, 
    0.12095680f, 0.00515899f, -0.08512086f, -0.03450725f, 0.16952719f, 0.05248398f, 0.11253902f, -0.05738994f, 
    0.00755055f, -0.07472935f, 0.12292272f, 0.26510972f, -0.09228984f, 0.03764401f, -0.05838995f, -0.06313471f, 
    0.05844453f, 0.04537953f, -0.08882088f, -0.08857162f, -0.01822422f, -0.00989700f, 0.05532894f, 0.08738470f, 
    0.01701237f, -0.04118476f, -0.05201532f, -0.11014871f, -0.23025304f, -0.11675999f, 0.19105838f, -0.35652998f, 
    0.07786307f, -0.19830146f, 0.08049884f, 0.14797661f, -0.02653633f, 0.01953233f, 0.02649355f, 0.00302649f, 
    0.11764793f, -0.25810668f, -0.02322874f, -0.09002837f, 0.03952471f, 0.10952462f, 0.07689642f, 0.09010819f, 
    0.04922137f, -0.07821398f, -0.05868733f, 0.06865785f, -0.12845449f, -0.28206518f, -0.01363861f, 0.32177487f, 
    0.03485554f, 0.13084410f, -0.17690413f, 0.00166424f, -0.02923236f, 0.13687538f, 0.00159252f, -0.08131255f, 
    -0.03021894f, -0.00697890f, 0.09501916f, -0.29316720f, -0.02393362f, -0.07726891f, -0.05794810f, -0.05193438f, 
    -0.00702977f, -0.00051076f, 0.06029547f, 0.04695430f, 0.17237510f, 0.05221827f, 0.09404969f, 0.01839754f, 
    -0.05535302f, -0.09251550f, 0.01315813f, 0.05290192f, -0.02743281f, 0.03933608f, 0.06365754f, 0.02946912f, 
    -0.16494787f, -0.20087485f, -0.02916173f, -0.08630197f, 0.00945658f, -0.14409301f, -0.09799653f, -0.17733762f, 
    0.00463135f, 0.05106616f, -0.07536172f, -0.08067966f, -0.45793548f, 0.32741570f, -0.10019950f, -0.14168514f, 
    0.05802118f, 0.20058030f, 0.19087936f, 0.21449427f, -0.14518510f, 0.02891343f, -0.29721084f, -0.05964894f, 
    -0.33420911f, -0.32735148f, 0.29929191f, 0.20337732f, -0.04847984f, 0.07679595f, 0.02277447f, 0.14365238f, 
    0.01311314f, 0.05922030f, 0.02078493f, 0.08344106f, 0.04176389f, 0.11022497f, 0.26751024f, 0.04956616f, 
    0.05174722f, -0.10505099f, 0.10716473f, -0.02204911f, -0.11550558f, 0.02114919f, 0.08938092f, 0.23650301f, 
    -0.14186461f, -0.21158418f, -0.01638925f, 0.01860343f, -0.08992121f, 0.05762828f, 0.05929942f, 0.16526540f, 
    -0.03224669f, 0.12343351f, 0.12269983f, 0.09344704f, -0.18456477f, -0.33774227f, -0.02317070f, 0.03823490f, 
    -0.15329857f, 0.13164626f, 0.03332352f, 0.38079870f, -0.05954657f, 0.08665876f, -0.01177639f, 0.05383543f, 
    0.03323462f, 0.09841747f, -0.00251038f, 0.19359729f, -0.02055875f, -0.03460168f, 0.01163976f, 0.06284723f, 
    0.14372222f, 0.08146270f, -0.00511118f, 0.25424111f, 0.01230335f, -0.35261434f, 0.20406619f, -0.14781506f, 
    -0.10857681f, -0.07848683f, 0.13425733f, 0.01405506f, -0.18598747f, -0.00230197f, 0.14577845f, 0.14656477f, 
    0.03398997f, 0.08187333f, -0.08251848f, 0.10562225f, -0.03474325f, -0.23614120f, 0.01476160f, 0.03222465f, 
    -0.03343095f, -0.01079344f, 0.13440195f, 0.16275148f, -0.68753093f, 0.44106939f, -0.00280426f, -0.02755224f, 
    0.06635889f, 0.14742304f, -0.14936301f, 0.07368214f, -0.01882127f, -0.00672407f, 0.06136575f, 0.07231690f, 
    -0.42556614f, 0.07462287f, 0.04896478f, 0.26107475f, -0.08737098f, 0.07770456f, -0.25713795f, 0.11281876f, 
    -0.01105120f, 0.07408500f, 0.05118416f, 0.10978942f, -0.45783892f, 0.25130367f, -0.49313492f, 0.05391596f, 
    -0.12019052f, -0.21697417f, 0.00981310f, 0.13931212f, -0.08641408f, 0.12874840f, 0.10977670f, 0.05675465f, 
    -0.05120440f, 0.42533413f, 0.48529533f, 0.13901336f, -0.05267788f, 0.11931986f, -0.07377867f, 0.05394916f, 
    -0.04153067f, 0.00215707f, 0.00419593f, -0.17972630f, -0.28028101f, 0.05161078f, 0.19739214f, 0.01732458f, 
    -0.06294595f, 0.11458258f, -0.06688821f, 0.09105471f, -0.14233421f, -0.29066542f, 0.00115402f, 0.03020533f, 
    -0.14490639f, -0.17179486f, -0.31490344f, -0.04808605f, -0.09937994f, 0.11795473f, 0.08630000f, 0.03968492f, 
    -0.01203666f, -0.03926342f, -0.04276190f, -0.11551840f, -0.04963293f, 0.05573955f, -0.14272355f, -0.17949228f, 
    -0.14916101f, 0.11020177f, -0.09014386f, 0.11079224f, -0.20882203f, -0.05586620f, -0.18501203f, -0.08313359f, 
    0.07238825f, 0.37677768f, 0.04970759f, -0.22364157f, 0.00416929f, 0.04908451f, 0.15303795f, 0.03156776f, 
    -0.10091923f, 0.24159877f, 0.14846696f, 0.06393678f, -0.28407288f, -0.33176118f, -0.11103949f, 0.12138791f, 
    -0.08961868f, 0.04147921f, -0.12428038f, 0.03317083f, 0.14561725f, 0.07996479f, 0.01675121f, 0.00130515f, 
    0.07511041f, 0.27570280f, -0.27521601f, 0.18971306f, -0.19609757f, -0.04972899f, 0.03411460f, 0.00296295f, 
    -0.01458316f, 0.03552558f, -0.23409401f, -0.01450860f, -0.28758121f, 0.00175964f, 0.03481805f, 0.02406412f, 
    -0.03072859f, 0.09862565f, -0.00344186f, -0.21371737f, 0.11364164f, 0.00107864f, -0.17621091f, -0.05633985f, 
    0.06058792f, -0.35138422f, 0.12254100f, 0.15529232f, -0.10849977f, -0.04126032f, -0.10567939f, -0.29150972f, 
    0.00447591f, 0.01746607f, -0.04932122f, 0.08270448f, 0.22832258f, 0.18601409f, -0.17691061f, -0.08928495f, 
    0.08322754f, -0.08625928f, -0.16021554f, 0.01819853f, -0.16913024f, 0.00099511f, -0.11074179f, -0.33904964f, 
    0.01049436f, 0.14082396f, 0.16801096f, 0.05744706f, 0.08173628f, 0.02714489f, -0.18316993f, -0.01825301f, 
    -0.09013968f, -0.11223558f, 0.02076824f, -0.06536172f, -0.01075687f, -0.21588863f, 0.37648773f, 0.10443339f, 
    -0.09752667f, -0.02170575f, 0.04686263f, 0.10207411f, 0.01890004f, 0.00981135f, 0.21255735f, 0.04503588f, 
    -0.00638410f, -0.04502831f, 0.24323460f, 0.00274607f, 0.03820780f, 0.09690823f, 0.06295626f, 0.00567045f, 
    -0.03050918f, -0.08523390f, -0.08294555f, -0.09402557f, -0.24082801f, 0.05542490f, 0.33195099f, 0.09077897f, 
    -0.17471389f, 0.03947430f, 0.06093795f, 0.15410683f, 0.03032207f, -0.00310461f, -0.00617718f, 0.19208959f, 
    -0.02186502f, -0.27965575f, -0.13105053f, -0.20614052f, -0.15476599f, -0.03334782f, -0.07931534f, -0.04237036f, 
    0.07070477f, -0.25324443f, -0.39882398f, -0.22282620f, -0.07293988f, 0.02502885f, -0.01138100f, -0.04918767f, 
    -0.00764248f, -0.01206795f, 0.05381425f, -0.06082714f, 0.00443816f, 0.08259238f, 0.01482345f, -0.28674027f, 
    -0.18841538f, -0.29507861f, -0.12878938f, -0.06988019f, -0.08125701f, -0.00460662f, 0.09760092f, -0.05298048f, 
    -0.02284905f, 0.05458145f, 0.00749736f, -0.03103846f, 0.02873410f, 0.03589604f, 0.06634329f, 0.07643446f, 
    -0.02344244f, -0.12004195f, -0.02746871f, 0.02005552f, -0.24821211f, -0.30946371f, -0.33239189f, -0.27481452f, 
    0.03813278f, 0.11332060f, 0.18460038f, 0.23939954f, 0.00888459f, -0.08790583f, 0.02669932f, 0.08059651f, 
    -0.15079430f, -0.02846968f, -0.12351901f, -0.25740463f, -0.20717593f, -0.36551273f, -0.12757885f, -0.15363856f, 
    -0.10731675f, 0.04765327f, -0.02619772f, -0.06658994f, -0.04525906f, 0.08105115f, 0.07727014f, 0.05957766f, 
    0.02398698f, 0.02038575f, -0.12614861f, 0.10734842f, -0.06612667f, -0.10527834f, 0.03713810f, 0.11195495f, 
    0.06620181f, 0.05228294f, 0.13280989f, 0.19126309f, -0.08087669f, 0.02070964f, 0.05066730f, -0.10007332f, 
    0.04543946f, 0.06988046f, -0.00798728f, 0.04652270f, -0.00098370f, 0.15577592f, -0.01713033f, 0.01059629f, 
    -0.32304126f, 0.10241237f, -0.12007162f, 0.29824018f, -0.08496470f, -0.13390511f, 0.04941904f, -0.05575294f, 
    0.05240633f, 0.00774214f, 0.08207122f, 0.02124502f, -0.02989646f, 0.05450386f, 0.34549049f, 0.09064528f, 
    -0.13874987f, -0.01880363f, 0.05127959f, 0.02992903f, 0.01696241f, -0.01638967f, 0.08732927f, 0.11919243f, 
    0.00725120f, 0.14420636f, 0.00729559f, -0.00637074f, -0.00691318f, 0.19079240f, 0.14408949f, 0.04860768f, 
    -0.09135638f, 0.16003905f, 0.10617933f, 0.18652362f, -0.44643053f, 0.12866201f, -0.16554810f, -0.00767321f, 
    -0.04876662f, 0.06909531f, 0.02933049f, -0.04368810f, 0.05188119f, 0.03530032f, -0.05203355f, 0.13287713f, 
    -0.02365166f, -0.05733252f, -0.21906179f, 0.11082705f, 0.06897707f, -0.19665739f, 0.01427954f, 0.07884869f, 
    -0.11745341f, -0.30246240f, -0.54558444f, -0.19819203f, -0.04900179f, 0.21285971f, -0.06149107f, -0.18425374f, 
    -0.10153688f, -0.00687358f, 0.04613579f, 0.00065293f, 0.07604193f, -0.16617972f, -0.09027992f, -0.24002844f, 
    -0.05531735f, 0.08529428f, -0.10824808f, -0.14360970f, -0.09139060f, 0.16712946f, 0.03723357f, 0.03066807f, 
    -0.07057513f, -0.12516724f, -0.08628795f, -0.42925104f, -0.25700819f, -0.09239990f, -0.02295737f, -0.13458902f, 
    0.00876415f, -0.03525688f, -0.08244804f, -0.16022526f, -0.04871971f, 0.03640495f, -0.00902433f, -0.14887686f, 
    0.02967983f, 0.08838840f, 0.41428998f, 0.05292729f, -0.02822866f, -0.06088122f, 0.02390476f, -0.10321273f, 
    -0.09616273f, -0.02889746f, 0.13816938f, -0.08098944f, -0.76938426f, 0.08468580f, 0.00987785f, 0.06602796f, 
    -0.13183747f, 0.18253094f, -0.14125760f, 0.11387312f, -0.09755034f, -0.12446730f, 0.13826400f, -0.04540488f, 
    -0.04850361f, -0.08648507f, 0.05495036f, 0.26030326f, -0.06964761f, -0.01268991f, -0.05087086f, 0.11056888f, 
    0.04798548f, -0.03902249f, 0.01613456f, -0.10627487f, 0.12751450f, -0.10891718f, 0.00551524f, 0.12070212f, 
    0.07372756f, -0.13540137f, -0.03276795f, 0.08339216f, -0.31079540f, -0.10468675f, -0.10544851f, -0.17176820f, 
    -0.29377109f, -0.07725328f, -0.51364940f, -0.23821779f, 0.01864145f, 0.12701230f, -0.00051223f, 0.05594954f, 
    -0.03941728f, 0.01604520f, -0.19298710f, -0.17460810f, -0.21428107f, -0.46431729f, 0.51354164f, 0.07029431f, 
    0.08841882f, 0.11605579f, -0.25051755f, 0.04439942f, 0.00610552f, -0.00898342f, 0.14857906f, -0.02399550f, 
    0.43847534f, -0.55644894f, 0.28427315f, -0.05875204f, -0.00855114f, -0.10424004f, 0.02952943f, 0.04422976f, 
    -0.21855512f, -0.04672166f, -0.02473931f, -0.15078866f, -0.14581533f, -0.12727797f, 0.08108313f, 0.02083308f, 
    -0.06230276f, 0.10542764f, -0.18845002f, 0.15987206f, -0.21190760f, -0.06104818f, 0.04135302f, -0.06309921f, 
    0.39149061f, -0.10227352f, 0.43850765f, 0.02784064f, -0.07324682f, 0.24607466f, 0.21210976f, 0.12359660f, 
    0.17809518f, 0.04361152f, 0.04788898f, -0.10717441f, -0.03958383f, 0.16625340f, -0.01820707f, -0.12639910f, 
    -0.06752291f, 0.18625769f, 0.13436753f, -0.01148862f, -0.03179669f, -0.23322383f, 0.21930227f, 0.13768566f, 
    -0.14238299f, -0.12801406f, 0.07507662f, -0.21656644f, -0.04371417f, -0.01829582f, -0.12445031f, -0.02886217f, 
    -0.00839386f, -0.17056628f, -0.20341308f, -0.04910573f, 0.25129431f, 0.19853181f, 0.01414192f, -0.06230035f, 
    -0.02547599f, -0.08926495f, 0.10742197f, 0.08279307f, -0.21268809f, 0.18297103f, -0.00324108f, -0.09175140f, 
    -0.03822969f, -0.19139187f, -0.08766891f, 0.13886803f, 0.03576304f, -0.06876588f, -0.16091350f, 0.06505842f, 
    -0.00404855f, 0.01570644f, -0.13120149f, -0.22557725f, 0.03157971f, 0.15625086f, -0.21172129f, 0.17674585f, 
    -0.06359804f, 0.16141683f, 0.07861487f, -0.04038315f, 0.18063916f, 0.13707720f, 0.06862704f, -0.03186524f, 
    -0.05522473f, -0.40601620f, 0.46920267f, -0.03602841f, -0.17794259f, 0.30440050f, 0.13444419f, 0.05126297f, 
    -0.03677759f, 0.12636068f, -0.03263826f, -0.19831562f, -0.24343261f, -0.06266638f, -0.07703359f, 0.02112813f, 
    0.05888290f, -0.05688879f, 0.00828445f, 0.01377073f, -0.03180341f, 0.10316858f, -0.00875626f, 0.04442514f, 
    -0.09011275f, -0.05722322f, 0.00828696f, 0.12981327f, -0.04438833f, 0.12380628f, 0.09689639f, 0.04625056f, 
    -0.09571126f, 0.08018308f, 0.06234446f, 0.03664751f, -0.19223209f, 0.07630573f, -0.01942369f, 0.09589971f, 
    -0.05728538f, -0.10646863f, -0.11351226f, -0.04548503f, 0.02035266f, 0.09935375f, -0.00977971f, -0.02184114f, 
    0.04897229f, 0.05140671f, 0.17848524f, 0.09784813f, -0.05348172f, -0.01409702f, -0.15469609f, 0.03129584f, 
    -0.09600187f, 0.11784784f, 0.08421855f, 0.10303684f, -0.13323563f, -0.23756181f, 0.19369744f, -0.04855824f, 
    0.00049903f, 0.04297205f, -0.02256281f, 0.01059445f, 0.01682206f, -0.19920401f, -0.02384203f, 0.04633561f, 
    -0.04054184f, 0.22125877f, 0.07567723f, -0.00184808f, -0.01672384f, -0.01509098f, 0.04537416f, -0.04075408f, 
    -0.03937476f, 0.10629371f, -0.17495681f, -0.04506487f, -0.47067553f, 0.16695489f, -0.01594263f, -0.12122268f, 
    -0.03071116f, 0.23936620f, -0.06348245f, -0.00123520f, -0.23405157f, 0.13867448f, 0.00178045f, -0.07150091f, 
    -0.01006260f, -0.09223492f, -0.12988468f, -0.15570146f, 0.00816414f, -0.15573622f, -0.00562420f, 0.00314850f, 
    0.02414673f, 0.03086216f, -0.03341985f, 0.00001958f, 0.26353824f, -0.15919918f, -0.09997635f, 0.15537399f, 
    0.00882522f, 0.06609504f, -0.17620771f, 0.04575916f, 0.05476015f, 0.11279251f, 0.14595020f, -0.15555513f, 
    -0.13726296f, -0.24513942f, -0.29351035f, 0.24134718f, -0.24789995f, -0.04317904f, 0.00367324f, -0.04247934f, 
    -0.01989096f, 0.00860237f, 0.02515458f, -0.09833054f, -0.18483821f, 0.15358685f, 0.24147679f, -0.16408761f, 
    -0.00348071f, 0.08820079f, 0.18926322f, -0.27550083f, 0.02739634f, 0.07098958f, -0.15197882f, 0.05572928f, 
    0.01559090f, 0.07226653f, 0.19967362f, -0.36849967f, -0.13867351f, 0.04714980f, 0.18380791f, -0.07870417f, 
    0.05638496f, -0.01056351f, -0.10408915f, -0.09980392f, 0.66541940f, 0.15642542f, 0.53073853f, -0.29379562f, 
    -0.20514767f, 0.01606135f, -0.38096690f, 0.01477949f, -0.06953565f, 0.03381625f, -0.12390602f, -0.04218108f, 
    -0.11053782f, 0.00953728f, -0.31178901f, -0.28311503f, -0.10329011f, 0.17765538f, -0.16563161f, -0.00418458f, 
    -0.18106841f, -0.09865340f, -0.00930925f, -0.22051103f, 0.24791831f, -0.09849034f, 0.35763201f, -0.07582190f, 
    -0.05635153f, 0.11236658f, -0.05006351f, -0.00514342f, -0.15278068f, -0.02080532f, 0.06875496f, 0.05593201f, 
    0.34659582f, -0.28685427f, 0.37912434f, 0.03881261f, 0.07518508f, 0.04263286f, 0.01485315f, -0.07774918f, 
    -0.02451569f, -0.05038102f, -0.04236553f, 0.02967106f, -0.68283838f, 0.17142759f, -0.40223867f, 0.40852678f, 
    0.12583393f, -0.15250783f, 0.08982126f, 0.12169170f, -0.00105685f, 0.04457366f, 0.03505754f, 0.15637188f, 
    -0.21804713f, -0.02628601f, -0.17820369f, 0.23291148f, -0.06562029f, 0.01055336f, 0.05840524f, -0.15731771f, 
    -0.02820379f, -0.04459631f, -0.01469341f, -0.10579471f, 0.06765429f, -0.05002286f, 0.08572051f, 0.34757146f, 
    -0.00240350f, 0.03091881f, 0.00564407f, 0.06574806f, -0.13248579f, 0.05007151f, 0.03463678f, -0.16347948f, 
    0.18892932f, -0.28917691f, 0.24988641f, -0.18832752f, 0.11445430f, 0.04711510f, 0.00706183f, 0.08126395f, 
    0.01804873f, 0.07057112f, 0.04541652f, 0.19767499f, 0.36230543f, 0.16293614f, 0.17193566f, -0.30844241f, 
    -0.04338089f, 0.00005725f, 0.00218739f, 0.09431542f, 0.08397608f, 0.18321720f, 0.04142239f, -0.03412177f, 
    -0.23966001f, -0.05758020f, 0.07942203f, 0.20459574f, 0.07681969f, -0.04385942f, 0.00636284f, -0.02911270f, 
    0.04923130f, 0.02988672f, 0.02680565f, 0.06142769f, 0.15673295f, -0.03470895f, 0.14698794f, 0.01756788f, 
    0.07723442f, -0.11880193f, 0.22561714f, 0.10949427f, 0.11872991f, -0.01685739f, 0.16688848f, -0.03469361f, 
    -0.37375417f, -0.27418309f, -0.21417350f, 0.16428769f, 0.04602646f, -0.13739258f, -0.01476325f, 0.00520106f, 
    -0.00820610f, -0.13959651f, -0.20853046f, -0.19611365f, -0.20120768f, -0.25466490f, 0.09342981f, 0.16496217f, 
    -0.26179394f, 0.09400780f, -0.13714822f, -0.10294700f, -0.05361800f, 0.03908282f, -0.02661905f, -0.09139886f, 
    -0.10557195f, -0.18290237f, 0.38298017f, 0.03124036f, -0.13429925f, 0.09041154f, -0.10429376f, -0.13944954f, 
    0.09177912f, 0.06846753f, 0.10082320f, 0.10315911f, -0.20742086f, 0.14064759f, -0.29421851f, -0.00117929f, 
    0.00751793f, 0.01692166f, 0.11333054f, -0.01398412f, -0.03936937f, 0.04874019f, -0.01142555f, 0.09403358f, 
    0.06919134f, 0.11915466f, 0.08201777f, 0.02635508f, -0.10201774f, -0.05522530f, 0.08348051f, 0.15819702f, 
    -0.05483121f, -0.07939680f, 0.15490580f, -0.10310129f, -0.54036766f, 0.07911517f, -0.27591318f, -0.12588179f, 
    -0.04520329f, -0.06893956f, 0.02102977f, -0.06900254f, -0.20350954f, -0.04751905f, -0.03512489f, -0.02548615f, 
    -0.01010352f, 0.12117250f, 0.01743185f, 0.09050177f, -0.14258337f, 0.12851949f, -0.15372716f, 0.02644412f, 
    -0.02666983f, 0.11613021f, -0.04581650f, -0.02080781f, -0.04616313f, 0.08213615f, -0.10459334f, 0.18667638f, 
    0.17670874f, 0.04764859f, -0.02141540f, -0.04198522f, -0.14301658f, -0.01426539f, -0.23851408f, 0.08329341f, 
    0.02629858f, 0.21668729f, 0.04028858f, 0.11120213f, -0.14219636f, 0.06213249f, -0.03013826f, -0.10578551f, 
    -0.05583953f, 0.03573664f, 0.06272979f, 0.11262681f, -0.06355026f, 0.10615937f, 0.22771841f, -0.01149591f, 
    0.01202672f, 0.06337181f, 0.01079708f, -0.07015140f, 0.03280763f, -0.00067406f, -0.01126768f, -0.03473898f, 
    -0.11432971f, 0.07457483f, -0.17097802f, -0.14136747f, -0.08112708f, -0.02100662f, 0.04648698f, 0.04331656f, 
    0.01995657f, 0.06195049f, 0.01447848f, 0.08218810f, -0.27266967f, 0.02728072f, -0.14974761f, 0.17415769f, 
    0.12523365f, 0.02726930f, 0.10494231f, -0.02274178f, -0.08985966f, 0.01272215f, 0.21761806f, 0.15129314f, 
    0.18200414f, 0.04737288f, 0.10438583f, -0.12244211f, -0.23645598f, 0.01350213f, -0.04630418f, -0.03758061f, 
    -0.05314642f, -0.06843891f, -0.03708288f, -0.09262153f, -0.00910053f, 0.01657542f, 0.02900427f, -0.02872235f, 
    0.05944597f, -0.05818665f, 0.01961250f, 0.00386140f, 0.05541037f, 0.10911520f, 0.11205351f, 0.01945685f, 
    -0.26263022f, 0.05326430f, -0.03586115f, 0.03040106f, -0.03239043f, -0.04158800f, 0.08105686f, 0.00787449f, 
    -0.05539636f, 0.10134399f, -0.15885437f, 0.06751974f, 0.33427447f, 0.17171949f, 0.11933392f, -0.18388000f, 
    -0.03638465f, -0.00646724f, 0.03795038f, 0.04912097f, -0.11726575f, 0.03610236f, 0.00804596f, -0.00670918f, 
    0.08864661f, -0.19007190f, 0.18213767f, 0.14271879f, 0.06250512f, 0.06333017f, -0.01402911f, 0.01347189f, 
    -0.14588477f, -0.02307502f, -0.07178128f, -0.12711790f, -0.07111554f, -0.05749517f, -0.08395419f, -0.06849579f, 
    0.06377049f, -0.03061160f, 0.03441882f, 0.04837221f, 0.01646947f, 0.20917742f, -0.07438145f, -0.00767337f, 
    -0.30122685f, -0.07586561f, -0.02075192f, 0.11660526f, -0.08749939f, 0.03539457f, -0.02351377f, 0.11299172f, 
    -0.06933834f, -0.04888136f, 0.06622050f, -0.01175761f, 0.41942891f, -0.08388887f, 0.48249489f, -0.13601963f, 
    0.06466642f, 0.11329636f, -0.05213736f, 0.10112107f, -0.18379734f, 0.09430113f, -0.00833413f, -0.08703171f, 
    0.19390267f, 0.03722494f, 0.13635379f, 0.01667083f, -0.09978871f, 0.18604258f, -0.13835652f, 0.17668977f, 
    -0.08759641f, 0.04253370f, -0.12583660f, -0.18144579f, -0.06241769f, -0.16743641f, -0.42433387f, 0.20846990f, 
    0.24391033f, -0.14557460f, 0.05687308f, -0.01691359f, 0.02138298f, 0.08910085f, 0.04982603f, -0.07348772f, 
    -0.01436276f, -0.24604744f, 0.08610034f, -0.07281069f, -0.02452379f, 0.02324793f, -0.01723149f, -0.02162279f, 
    -0.04760044f, 0.00950213f, 0.14021476f, 0.08742169f, -0.06504034f, -0.64449394f, -0.13515289f, -0.06234678f, 
    0.08927535f, 0.02576153f, 0.07223433f, -0.05561563f, 0.02285313f, 0.01634189f, 0.16093305f, 0.14626163f, 
    -0.19318345f, 0.12433600f, -0.10570688f, 0.13523634f, 0.06963298f, -0.13640261f, 0.11184284f, 0.10958415f, 
    0.09820066f, 0.05109660f, 0.03651615f, 0.20810601f, 0.21460250f, -0.08476824f, 0.12942594f, 0.12510788f, 
    -0.02836423f, -0.15573750f, -0.13689193f, 0.10464014f, -0.03968798f, 0.03701263f, -0.00079895f, 0.09536451f, 
    0.22211303f, -0.06807889f, 0.17262292f, 0.12913772f, -0.03517002f, 0.16697530f, -0.05240571f, 0.03436786f, 
    -0.08172056f, 0.18635549f, 0.04802488f, 0.06352693f, -0.14649238f, -0.20235488f, -0.16256467f, 0.27050516f, 
    0.22223036f, -0.00466230f, -0.03001484f, -0.07108790f, -0.01567132f, 0.10595275f, 0.15778641f, -0.11586527f, 
    -0.16945435f, -0.24347824f, 0.17241877f, -0.19965668f, -0.11505999f, 0.01703436f, -0.08756889f, 0.12278689f, 
    -0.10083181f, 0.02196679f, 0.03721935f, -0.08568645f, 0.07618836f, -0.10154440f, 0.21394499f, 0.00560527f, 
    -0.10068008f, 0.10704888f, -0.06872647f, 0.01565706f, 0.04945447f, 0.04767299f, 0.17528887f, 0.14903677f, 
    -0.23413973f, -0.42604008f, -0.39832938f, 0.03976419f, 0.06122268f, -0.05739997f, -0.13730627f, -0.32041156f, 
    -0.00105318f, 0.06752475f, 0.03845488f, 0.02219692f, 0.07464848f, -0.15060574f, -0.09738189f, 0.27153459f, 
    -0.23453133f, 0.01011785f, -0.01427524f, -0.02101430f, -0.04126412f, 0.11363075f, 0.06314564f, 0.00708616f, 
    0.09345056f, 0.12299025f, -0.22945695f, -0.17409188f, -0.07408070f, 0.22498021f, 0.25716314f, -0.16617928f, 
    -0.00375177f, 0.02534686f, 0.11716433f, 0.05602968f, 0.13726522f, 0.04376343f, 0.07286122f, -0.04609023f, 
    -0.26767325f, 0.00908679f, 0.13231139f, 0.01164259f, 0.04212920f, -0.04844271f, 0.06624539f, 0.04624893f, 
    -0.25420311f, -0.13733318f, 0.17952840f, 0.02989139f, -0.11056021f, 0.08808714f, -0.06181293f, 0.04247593f, 
    0.03154216f, -0.06927131f, 0.00952789f, 0.16813761f, 0.21517859f, -0.16557796f, 0.03535039f, 0.28233173f, 
    0.00201210f, 0.03654251f, -0.01253155f, 0.05092655f, -0.17286436f, -0.00864709f, 0.10575198f, -0.10292577f, 
    -0.10093236f, 0.01496052f, -0.25231040f, -0.07358809f, -0.04123729f, -0.00796746f, 0.05192587f, -0.02479435f, 
    0.13795939f, 0.22784333f, -0.09339440f, -0.00299829f, -0.06969085f, -0.59968889f, 0.37790111f, -0.34280396f, 
    -0.11961322f, -0.16732177f, -0.23103304f, -0.02203701f, -0.05514416f, -0.06903451f, -0.00410965f, -0.08082681f, 
    -0.26862565f, -0.25837311f, 0.01466222f, -0.26440841f, -0.12933309f, -0.05407814f, -0.02242793f, 0.09330204f, 
    -0.01266776f, 0.04863024f, -0.01345129f, 0.04644072f, -0.04800817f, 0.05112875f, 0.00169671f, 0.09098914f, 
    -0.08937075f, 0.03006235f, -0.03844693f, 0.06756678f, -0.05330452f, 0.05864354f, -0.00154534f, 0.06709331f, 
    0.06534592f, -0.05263786f, 0.00574795f, -0.73863649f, 0.12012603f, -0.12395354f, 0.00207478f, 0.03178575f, 
    0.11416667f, 0.09029870f, 0.06766377f, -0.09965873f, -0.09762039f, -0.12192545f, -0.04657608f, 0.03851241f, 
    -0.20709702f, -0.00132299f, -0.10271438f, -0.21505663f, -0.08353861f, -0.08526548f, -0.05317218f, -0.04911000f, 
    0.08691188f, 0.01695047f, 0.08790144f, -0.02199130f, 0.00557680f, 0.06688721f, -0.06072756f, 0.09656429f, 
    -0.15260021f, -0.02935980f, -0.07037133f, -0.04196924f, 0.04055658f, -0.31615961f, 0.04013570f, -0.17888463f, 
    -0.00740694f, -0.19645213f, -0.09362430f, 0.04663764f, -0.01158306f, 0.07448159f, -0.02397026f, -0.08744314f, 
    -0.18100362f, 0.09331997f, 0.00478011f, 0.00018118f, -0.00080352f, -0.05862259f, 0.07793394f, 0.02256978f, 
    -0.06080692f, 0.03887706f, 0.02938821f, -0.10584095f, -0.60288304f, 0.07382073f, -0.42225149f, 0.10207317f, 
    0.03727904f, -0.00396730f, 0.10197187f, -0.03093982f, 0.00640385f, 0.01621465f, 0.06620476f, -0.20277837f, 
    0.30569807f, -0.08487997f, 0.20428997f, -0.05305008f, -0.01765936f, -0.18604609f, 0.12207270f, -0.08273937f, 
    0.08478768f, 0.05490491f, 0.05040320f, 0.01700008f, 0.02343200f, -0.11252755f, 0.06972870f, 0.15014562f, 
    0.06492383f, -0.07585046f, -0.03865488f, -0.09607376f, 0.10777038f, 0.06077610f, -0.14683649f, -0.03773876f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14779021f, 0.03673078f, 0.09768350f, -0.08506919f, -0.08940366f, 0.06590641f, 0.03930734f, -0.11178747f, 
    0.04708320f, -0.02940466f, -0.00983743f, -0.04800539f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
