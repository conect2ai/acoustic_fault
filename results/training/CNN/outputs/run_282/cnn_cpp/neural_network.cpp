#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.05553995f, -0.60907722f, -0.64046222f, 0.21829259f, -0.29716194f, -0.20482960f, -0.76359075f, -0.38797620f, 
    0.23616664f, -0.44642320f, -0.30187738f, 0.06083278f, 0.18349971f, 0.05989328f, -0.13504973f, -0.02221730f, 
    0.18898451f, -0.20951748f, 0.03223496f, 0.21487617f, -0.02450509f, -0.04753766f, 0.24324746f, 0.05508718f, 
    -0.14023143f, 0.16228454f, -0.49913356f, -0.19149318f, 0.63553667f, 0.26379263f, 0.54428416f, 0.13751800f, 
    -0.49477953f, 0.07322913f, -0.28037563f, -0.25402015f, 0.14727272f, 0.27176657f, -0.23323408f, -0.46327665f, 
    -0.09315501f, 0.11813930f, -0.25538632f, -0.06035606f, 0.14058018f, 0.05320003f, -0.32789201f, -0.09954132f, 
    -0.25098774f, -0.16228552f, 0.24163403f, 0.50984859f, 0.44978732f, 0.08560772f, -0.64965069f, -0.86617988f, 
    -0.46100137f, 0.03911963f, -0.28240374f, -0.37973386f, 0.11849092f, -0.14209446f, -0.35321587f, -0.15075107f, 
    -0.06289633f, 0.08431336f, -0.09351849f, -0.11460718f, -0.21192721f, -0.04991004f, 0.24093963f, 0.20811428f, 
    0.01595254f, 0.09415513f, -0.15772502f, -0.22684993f, -0.69680303f, -0.38485798f, -0.39128551f, -0.39010707f, 
    -0.41900393f, -0.42721403f, 0.01863081f, 0.18251139f, 0.20478167f, -0.23479101f, 0.14720710f, -0.12243508f, 
    0.03249824f, -0.18031159f, 0.03756471f, 0.03237267f, 0.04902283f, 0.17585900f, -0.01742292f, -0.18640548f, 
    0.08477860f, -0.15149893f, 0.16844317f, -0.05924739f, 1.02799213f, -0.38053730f, 0.00040506f, 0.11058787f, 
    -0.15827842f, -0.23163196f, -0.46953890f, 0.35021254f, 0.14997318f, 0.00719251f, -0.22586861f, -0.21624888f, 
    -0.14209269f, -0.10009025f, -0.18871014f, -0.03386997f, 0.06466726f, 0.16278800f, -0.16417120f, -0.04115979f, 
    0.03658853f, 0.06469180f, 0.15855888f, -0.23693551f, -0.07744848f, 0.82044739f, 0.94046491f, 0.30531803f, 
    -0.29508489f, -0.59523922f, -0.16884880f, -0.11183567f, -0.06354209f, -0.17969459f, 0.38768262f, 0.13451856f, 
    0.27629152f, -0.24288829f, 0.04252826f, 0.13619389f, -0.12893030f, -0.04325743f, -0.05324189f, 0.08092885f, 
    -0.17948036f, -0.19582157f, 0.06230342f, 0.05433725f, -0.11865564f, 0.13949485f, 0.18072933f, 0.34009889f, 
    0.66049826f, -0.59240985f, -0.50223869f, 0.31693691f, -0.35411093f, -0.69848478f, -0.15886639f, -0.12464284f, 
    0.22854339f, 0.47365329f, -0.09555268f, -0.14811765f, -0.23401511f, -0.29352304f, 0.13683744f, -0.32738149f, 
    -0.20045610f, -0.27868065f, 0.11674783f, -0.02532434f, -0.00285530f, 0.09599376f, -0.15298690f, -0.59546816f, 
    -0.33738881f, -0.27577522f, -0.15945394f, 0.26090524f, -0.38868719f, -0.15136275f, 0.51204580f, 0.14699490f, 
    0.29767191f, 0.24460760f, 0.00266600f, 0.37027758f, -0.17348355f, 0.67077684f, -0.20828691f, -0.16306835f, 
    -0.00832169f, -0.10335991f, 0.00496665f, -0.09057730f, 0.03743843f, -0.33500019f, -0.26562995f, -0.09428105f, 
    0.17453088f, -0.51303446f, 0.28257024f, 0.78908879f, -0.34699970f, -0.18033583f, 0.68303853f, 0.42891073f, 
    0.32778677f, -0.11064135f, -0.22422509f, -0.19101730f, 0.12194365f, 0.07262924f, -0.15875465f, -0.29457638f, 
    0.00254170f, 0.26670390f, -0.27251771f, -0.06790904f, -0.09002490f, 0.15286341f, 0.00650198f, 0.24120057f, 
    -0.23513927f, -0.16957243f, -0.74363405f, -0.62680602f, -0.47459665f, -0.51511341f, 0.11701451f, 0.45633179f, 
    -0.00393040f, 0.27227864f, 0.32574877f, -0.15412003f, 0.37134099f, -0.15790549f, 0.07308599f, 0.00366532f, 
    0.15063341f, -0.00602240f, -0.02266417f, 0.16703430f, -0.07085732f, -0.01536115f, 0.04149306f, 0.20568953f, 
    0.04519090f, 0.35296163f, 0.61360711f, 0.66813284f, 0.48607048f, 0.47608912f, 0.70184708f, 0.11409371f, 
    -0.13769545f, -0.54892904f, 0.21236782f, -0.35015956f, 0.13717379f, 0.08167281f, 0.07565127f, -0.00681341f, 
    -0.12090931f, -0.01150695f, 0.00814184f, 0.21810305f, -0.16611160f, -0.04105345f, -0.14243741f, 0.20479351f, 
    0.14377405f, 0.03427318f, 0.16132389f, -0.32173458f, -0.40111467f, -0.53849894f, -0.33610764f, -0.42220521f, 
    0.51753974f, 0.56793356f, -0.28575987f, 0.21974179f, 0.27274793f, -0.30431429f, -0.28118291f, 0.14742260f, 
    0.13447873f, -0.12979874f, -0.38489136f, -0.16210666f, -0.00857677f, 0.16058533f, -0.35606748f, -0.11522939f, 
    -0.07391667f, -0.22082996f, 0.02977827f, 0.24253285f, 0.60211128f, -0.26958981f, -0.67102557f, -0.67222136f, 
    0.39553741f, 0.23581655f, -0.03487062f, 0.47075796f, 0.34288880f, 0.32883787f, -0.58419263f, -0.08811469f, 
    -0.11067954f, -0.10505819f, 0.07416070f, -0.15055211f, -0.22121398f, 0.08418852f, 0.08289887f, -0.27246505f, 
    -0.16962123f, 0.11771306f, -0.19303158f, 0.30074748f, -0.23574530f, 0.65889400f, 0.38526744f, -0.32882449f, 
    0.26713446f, 0.04634736f, 0.01000648f, 0.14193170f, -0.34630600f, 0.39096525f, 0.30259749f, 0.22951227f, 
    0.39157644f, -0.02663600f, -0.19978149f, 0.05798895f, -0.32636487f, -0.49848858f, -0.20434923f, -0.02311618f, 
    -0.16810340f, 0.11282919f, 0.26351586f, 0.27050698f, 0.13703078f, -0.04874404f, -0.31248179f, -0.85044616f, 
    -0.22216232f, 0.12055705f, -0.06649122f, -0.70785266f, 0.23925920f, 0.37946102f, -0.12596442f, -0.24916017f, 
    0.40535587f, -0.07312410f, -0.11977246f, 0.10799608f, 0.30696237f, 0.29874933f, 0.39140570f, 0.05466244f, 
    -0.09071217f, 0.15555103f, 0.13628757f, -0.24604687f, 0.02475319f, -0.22055268f, 0.01181577f, 0.74346507f, 
    0.25158131f, -0.35388136f, 0.46860552f, -0.29154783f, -0.10203812f, 0.45730078f, 0.23530790f, 0.32926676f, 
    0.36661699f, 0.14659852f, -0.03788942f, -0.08282404f, -0.39659497f, -0.20926331f, 0.17257294f, -0.15634152f, 
    -0.10749014f, -0.03491633f, 0.19321619f, -0.27637234f, -0.35208389f, 0.13028723f, -0.06609821f, -0.25221637f, 
    -0.68289644f, -0.72029352f, -0.72604138f, 0.14573243f, 0.13243203f, 0.34666261f, 0.66677612f, 0.31280676f, 
    0.17948814f, 0.22160836f, -0.23107599f, -0.11058938f, -0.12932469f, 0.21792696f, 0.13168594f, 0.11098198f, 
    -0.06897236f, 0.12276287f, -0.18503937f, -0.00284245f, 0.07992869f, 0.24760193f, 0.06729286f, -0.19259997f, 
    -0.05514971f, 0.37549311f, 0.96084666f, -0.39713383f, -0.34789923f, -0.18551503f, -0.12120071f, 0.13261896f, 
    -0.45246127f, 0.10148235f, 0.45716894f, 0.08635460f, -0.29239663f, 0.21253322f, -0.04796372f, 0.05737257f, 
    -0.17377172f, 0.19017532f, -0.06978405f, -0.26152340f, -0.21236767f, -0.08615326f, -0.22168440f, -0.00157789f, 
    -0.14462909f, 0.09574436f, -0.37518573f, -0.40402734f, 0.07337502f, 0.45252720f, -0.14381914f, -0.40462390f, 
    -0.16737705f, -0.34484407f, 0.00168397f, 0.34806836f, 0.27014157f, 0.33240244f, -0.36797166f, 0.27782294f, 
    -0.39471757f, -0.18317215f, 0.43727264f, 0.34499612f, -0.26198453f, -0.06832110f, 0.10333337f, -0.08339147f, 
    -0.00614972f, -0.01329331f, -0.00071909f, 0.35721076f, 0.47985232f, 0.34491497f, 0.33857486f, 0.38004297f, 
    -0.45674074f, -0.05514296f, -0.52260768f, -0.26465529f, -0.22914353f, 0.17912595f, 0.26774457f, 0.17754835f, 
    0.21098478f, 0.11171407f, -0.27569392f, 0.31682456f, -0.14777820f, 0.07601494f, 0.40153050f, -0.02767858f, 
    0.33236974f, 0.27003959f, -0.01937142f, 0.20384513f, 0.01743475f, 0.47809538f, 0.01969051f, 0.13573347f, 
    0.19235899f, -0.34207138f, 0.62098145f, 0.08714086f, 0.28906688f, 0.47744143f, -0.45277229f, 0.36040762f, 
    0.27045059f, -0.44668764f, -0.12359511f, 0.10386105f, -0.32598296f, -0.23911718f, 0.12944254f, -0.17169583f, 
    -0.15060484f, -0.18147342f, 0.01632374f, 0.13766332f, 0.01098202f, -0.83627063f, 0.42964327f, -0.01714995f, 
    -0.63659382f, -0.06399924f, 0.20115194f, 0.31059638f, 0.23353036f, 0.32008424f, 0.07707493f, 0.50061446f, 
    0.01035276f, -0.24555056f, -0.32699436f, -0.22141388f, 0.20143183f, -0.13896231f, 0.27157819f, 0.08024737f, 
    -0.17633508f, -0.36171618f, -0.12457607f, -0.07426682f, -0.16360989f, 0.05596671f, -0.51596248f, -0.16599342f, 
    -0.11711673f, 0.57103950f, 0.48149183f, -0.14240700f, 0.53073519f, 0.53736490f, -0.28400633f, -0.27899981f, 
    -0.27922428f, -0.27188468f, -0.46228257f, -0.14280708f, -0.05163792f, 0.39581719f, -0.09054103f, 0.24168274f, 
    0.37722626f, 0.14445741f, -0.17015371f, -0.00350314f, -0.27869466f, 0.02005563f, -0.38614592f, -0.25057358f, 
    -0.33833730f, 0.41655514f, 0.55097866f, -0.03771394f, 0.31971550f, 0.13599364f, -0.38242930f, 0.38380039f, 
    0.01151079f, 0.51712179f, 0.19884267f, 0.21737733f, 0.22983073f, 0.14467876f, 0.25896567f, 0.06693914f, 
    0.10932997f, 0.34738094f, 0.13745712f, -0.12322867f, -0.16183880f, 0.38006526f, 0.01538216f, 0.35598421f, 
    0.15123890f, -0.16848850f, 0.48726901f, 0.69442719f, 0.55507028f, 0.18638673f, 0.06316744f, 0.16196272f, 
    -0.37096730f, 0.40878278f, 0.12195224f, -0.06489892f, -0.03090691f, 0.08077071f, 0.00079182f, -0.11281846f, 
    -0.20874844f, -0.10375585f, 0.08007601f, -0.04095756f, 0.20589420f, 0.24049161f, -0.07266258f, 0.18044807f, 
    -0.24965584f, 0.50257915f, -0.43225178f, -0.50381732f, -0.12895727f, -0.14517786f, 0.00292972f, -0.11889705f, 
    -0.23809893f, -0.17782658f, 0.13630335f, -0.05960173f, 0.49390048f, -0.01455767f, -0.07641386f, 0.22597328f, 
    0.01554245f, -0.42625576f, 0.09329136f, -0.13075545f, -0.02132050f, 0.39339489f, -0.25899234f, -0.22976427f, 
    -0.07118435f, 0.23327583f, 0.70526868f, 0.57366973f, 0.26435944f, 0.61180985f, -0.14305328f, -0.22526257f, 
    -0.32948747f, -0.19103102f, 0.04752478f, -0.29889697f, -0.16724095f, -0.09563659f, 0.02204257f, 0.32956979f, 
    0.27192929f, 0.09048962f, -0.22282694f, 0.06940517f, 0.24722509f, 0.26252472f, -0.08054937f, -0.18072717f, 
    -0.23446020f, -0.26568499f, -0.15501404f, -0.68651408f, 0.29371235f, 0.07560248f, -0.05748388f, 0.62262475f, 
    -0.70071661f, 0.13901809f, -0.08780867f, -0.81383008f, -0.33251616f, -0.07381587f, 0.36694294f, 0.60133433f, 
    0.22372171f, 0.22611965f, 0.16542937f, 0.20414677f, -0.02254773f, 0.36852303f, -0.02302471f, 0.15225393f, 
    -0.01795122f, -0.17539969f, 0.00185885f, -0.13640887f, 0.01611612f, 0.17228065f, 0.12615108f, -0.13686422f, 
    -0.16469307f, 0.50356930f, -0.52891117f, -0.44088534f, -0.54468435f, -0.62228972f, -0.33105463f, -0.38250884f, 
    -0.24347268f, -0.01287652f, -0.27954346f, 0.23495564f, 0.13985887f, -0.31792170f, 0.24472815f, -0.32563719f, 
    0.26664031f, 0.07093995f, 0.19637567f, -0.10197335f, 0.12712915f, 0.68782282f, 0.26618662f, 0.21883109f, 
    0.60610372f, 0.46298075f, 0.31273937f, -0.27955920f, 0.18551445f, -0.14609301f, 0.35838050f, -0.33877289f, 
    -0.28225312f, 0.04355825f, 0.05857106f, -0.15776145f, 0.11449415f, 0.18801080f, 0.27048624f, -0.03972912f, 
    -0.13395448f, 0.14600790f, -0.02015326f, 0.06878918f, -0.17446585f, -0.06703344f, -1.02613187f, 0.29871270f, 
    -0.21175572f, -0.03884524f, -0.02408688f, -0.08795511f, 0.65303814f, -0.22816490f, 0.15530781f, 0.25838390f, 
    -0.22079395f, 0.05678747f, 0.18146579f, -0.30497119f, 0.03804146f, -0.01208347f, 0.18696398f, 0.14875460f, 
    -0.14323185f, -0.11648360f, 0.03251554f, -0.12123812f, -0.05251019f, 0.10663345f, 0.05014847f, 0.04841896f, 
    -0.46887746f, 0.54479879f, 0.58248228f, -0.50251991f, 0.02958873f, -0.06409840f, 0.46905541f, -0.23567700f, 
    -0.23544677f, -0.26782835f, -0.12088842f, 0.04702922f, -0.02282240f, -0.09250223f, -0.16225497f, -0.17603263f, 
    -0.12184020f, -0.25747317f, -0.22536801f, -0.05266041f, -0.18137330f, -0.17762423f, -0.13315906f, 0.05750718f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10896316f, 0.03027266f, 0.10142869f, 0.20163392f, 0.04354373f, 0.04102363f, 0.03432250f, 0.08539050f, 
    0.15532057f, 0.09665680f, 0.21280555f, 0.05668575f, 0.14420494f, -0.01217323f, 0.21971270f, -0.02237215f, 
    0.01967957f, 0.13872476f, 0.17086808f, 0.13723066f, -0.01585469f, 0.03446835f, -0.05211633f, 0.23134209f, 
    0.30506548f, 0.27414703f, 0.06720760f, -0.04572893f, 0.01047363f, 0.12585264f, 0.05283568f, 0.01118220f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00169631f, 0.20052923f, 0.01629930f, -0.00856754f, -0.02381212f, -0.01471368f, -0.03381688f, -0.04493940f, 
    0.06513226f, 0.04135122f, -0.06246993f, 0.09046260f, 0.01364235f, 0.25621232f, 0.15309326f, -0.11196342f, 
    -0.03735563f, 0.00863962f, 0.00251686f, 0.03979800f, 0.06892053f, -0.07371625f, 0.00930621f, -0.02551299f, 
    0.12011100f, -0.12322213f, 0.28554606f, -0.12922561f, 0.12080263f, 0.04532421f, 0.10077897f, 0.12867077f, 
    0.07432920f, 0.07731384f, 0.00456655f, 0.04247457f, -0.10002008f, 0.12872006f, -0.05074865f, 0.07923809f, 
    0.11253887f, 0.03030269f, -0.12097959f, -0.00785797f, 0.06921007f, 0.07836073f, 0.04919653f, -0.03599901f, 
    -0.20708448f, 0.20847374f, -0.01562318f, -0.15632632f, 0.09707908f, -0.01536363f, 0.11466787f, -0.06650943f, 
    0.04803868f, -0.02211115f, 0.09676267f, 0.14912941f, 0.29420915f, 0.07516482f, -0.03336181f, 0.28397939f, 
    0.05732082f, 0.04208935f, -0.14737144f, -0.08277966f, 0.15720157f, -0.06350248f, -0.04140044f, 0.04974614f, 
    0.57475781f, -0.12758404f, -0.08957135f, 0.22109199f, 0.16902731f, 0.04134857f, -0.09708073f, 0.03042995f, 
    0.11362261f, 0.00790338f, 0.03398247f, 0.26630449f, -0.14717482f, -0.26572782f, 0.16931073f, 0.00499679f, 
    0.05189611f, 0.06477866f, 0.15894946f, 0.06682368f, 0.08054536f, 0.08752628f, 0.12946910f, -0.08434704f, 
    0.08057936f, -0.06803981f, 0.30013803f, -0.26134664f, 0.20653005f, -0.03494149f, -0.04639716f, 0.12328763f, 
    -0.03337200f, 0.04604175f, 0.00503757f, 0.05220638f, -0.30397111f, 0.10958344f, -0.07779163f, 0.22990528f, 
    -0.01916751f, 0.04470575f, 0.02399031f, -0.07112084f, -0.00273892f, 0.06930046f, -0.10802925f, -0.07640116f, 
    -0.18662815f, 0.21240070f, 0.02350915f, -0.15444018f, 0.12240791f, 0.12030599f, -0.08448379f, -0.03777823f, 
    0.01130175f, 0.03587480f, -0.04679337f, 0.01169718f, -0.16404504f, -0.21065450f, -0.06467615f, 0.07024614f, 
    -0.02510085f, 0.07023641f, -0.01016394f, -0.19880970f, 0.01426697f, 0.03253597f, 0.02646363f, -0.00663140f, 
    -0.23369804f, 0.07897398f, -0.14366457f, 0.24194768f, -0.04430322f, 0.00763079f, -0.02195083f, 0.22242096f, 
    0.08816849f, 0.00079017f, 0.06107958f, -0.00326636f, -0.16278060f, 0.18281972f, -0.03226154f, -0.11742193f, 
    0.04212043f, 0.13681884f, -0.00571680f, -0.01125934f, 0.05267698f, -0.09066436f, -0.10613156f, -0.02291526f, 
    -0.30115211f, 0.00178131f, 0.04768159f, -0.21406466f, 0.17337428f, -0.03413888f, 0.08476060f, 0.01800658f, 
    0.05740933f, -0.00251811f, 0.02946923f, -0.01647578f, -0.19362432f, 0.09395098f, 0.08726621f, -0.03660454f, 
    0.20226355f, -0.02553193f, -0.07792170f, -0.08979714f, 0.02834077f, 0.05488094f, -0.00527653f, 0.04740495f, 
    -0.32339653f, -0.15851437f, 0.07106859f, -0.06371693f, 0.06854942f, -0.03509384f, 0.03252362f, 0.03864014f, 
    -0.06037718f, -0.06036327f, 0.03434959f, -0.04549622f, -0.07678634f, 0.12522501f, -0.08593537f, 0.37769747f, 
    0.15907338f, 0.07217579f, -0.08113026f, -0.01151355f, -0.06369765f, 0.00552349f, -0.07279883f, 0.16246964f, 
    0.14070745f, 0.07032084f, 0.18526803f, -0.35596985f, 0.08764173f, -0.01081643f, -0.09691034f, 0.00347552f, 
    0.04059697f, 0.10393627f, 0.06759457f, 0.11227119f, -0.04552961f, 0.07918108f, -0.13727675f, 0.01939444f, 
    0.03054190f, 0.04003593f, 0.10468411f, 0.06891263f, -0.03658473f, -0.02545433f, 0.00446118f, 0.05512780f, 
    -0.15540251f, -0.03052302f, 0.07088806f, 0.17177306f, -0.04648228f, -0.05540477f, 0.05629056f, -0.08446760f, 
    0.05095894f, 0.11552291f, -0.08673750f, 0.11084709f, -0.17678662f, -0.13419470f, 0.09849697f, 0.37923822f, 
    0.12895495f, 0.03894735f, -0.03445770f, 0.00261830f, -0.02529812f, 0.09923761f, 0.02377820f, 0.03855003f, 
    0.11696164f, -0.08455113f, -0.09147497f, 0.02871197f, 0.03569366f, -0.19632460f, 0.07700817f, 0.00237021f, 
    0.03750215f, 0.00456008f, -0.06511434f, -0.01293110f, 0.05341312f, -0.09408236f, 0.09646989f, -0.16482070f, 
    0.08661231f, 0.00638161f, 0.06450851f, -0.08720361f, 0.07041669f, -0.00498249f, 0.03920545f, -0.01613249f, 
    0.19241576f, -0.00120090f, 0.05259795f, -0.20861974f, 0.11365279f, -0.13869202f, 0.07541860f, 0.07464883f, 
    0.03643896f, -0.06236109f, -0.04653027f, 0.04275521f, -0.16100630f, 0.32363045f, -0.10298644f, 0.12356161f, 
    0.03808750f, 0.06376541f, 0.08434447f, -0.05787103f, 0.16792190f, 0.03667651f, -0.01213487f, 0.01815613f, 
    -0.08606418f, 0.03345553f, 0.16376856f, 0.01626104f, 0.05400470f, 0.11986534f, 0.03139947f, -0.09274735f, 
    -0.00425203f, 0.04108691f, 0.09340363f, -0.00697548f, 0.09062666f, -0.15694860f, -0.17439713f, 0.03796433f, 
    -0.03819749f, -0.11346640f, 0.04208266f, -0.01808086f, 0.02944404f, -0.03892134f, 0.14001194f, 0.05570953f, 
    0.03830777f, -0.08433642f, 0.03485311f, 0.13044496f, -0.12944935f, 0.19457416f, 0.02811119f, -0.01453123f, 
    0.07605374f, -0.03976939f, 0.11655178f, 0.02810397f, 0.03718903f, 0.18574995f, -0.04021541f, -0.22260374f, 
    0.15839460f, -0.02510195f, -0.00390923f, -0.02150624f, -0.02490691f, -0.00770685f, 0.10994297f, 0.02545973f, 
    -0.22872396f, -0.29788324f, 0.03945796f, 0.18963766f, -0.08487571f, -0.11688101f, 0.10092412f, -0.00447566f, 
    -0.06480357f, 0.09065761f, 0.00854452f, 0.08015609f, 0.25057957f, -0.10523114f, 0.23575602f, -0.24620900f, 
    0.12829626f, -0.16006564f, -0.11556061f, 0.12612608f, -0.06817532f, 0.00934102f, 0.04176882f, 0.23224147f, 
    -0.11066321f, -0.06030447f, -0.05849352f, 0.19484492f, 0.01425962f, 0.17596576f, 0.00636419f, 0.05884584f, 
    -0.00184438f, -0.13677004f, -0.08624829f, -0.06427795f, -0.15198113f, 0.41240886f, -0.06929836f, 0.12750389f, 
    0.06623662f, 0.01366755f, -0.02407482f, 0.03362629f, -0.00975285f, -0.03824802f, -0.04703498f, -0.00416204f, 
    -0.20659731f, -0.46852747f, -0.07248642f, 0.15538715f, -0.12876098f, -0.00577148f, 0.08064501f, -0.17230244f, 
    0.03250059f, 0.13179146f, -0.04392320f, -0.14688061f, -0.00173545f, -0.21846208f, 0.10346678f, 0.14520919f, 
    -0.03831686f, 0.11435772f, 0.12828733f, 0.24536699f, -0.06405726f, 0.05496000f, 0.05159680f, 0.09046160f, 
    0.47163334f, -0.15388781f, 0.07312731f, 0.12852678f, -0.23396830f, 0.14580990f, 0.01711069f, -0.03014631f, 
    -0.05287097f, 0.06039173f, -0.08646998f, -0.03304188f, -0.49694937f, -0.22552612f, 0.07621174f, -0.03089564f, 
    -0.06136909f, 0.03253211f, 0.14301825f, 0.04880125f, -0.04951207f, -0.04324397f, -0.01574293f, -0.06148623f, 
    -0.24135821f, 0.14814265f, 0.15387751f, -0.20109323f, -0.05676016f, -0.02167580f, 0.00134648f, -0.03053676f, 
    -0.10543579f, 0.03256676f, -0.03404490f, 0.01697539f, 0.12946072f, -0.05913007f, -0.19995624f, 0.10243611f, 
    0.06128411f, -0.05265132f, -0.04768961f, -0.05171300f, 0.00309897f, -0.00978375f, 0.03445606f, 0.16625658f, 
    0.13055918f, 0.11946716f, -0.13004833f, 0.33533123f, -0.15381850f, 0.08997050f, 0.06113437f, -0.02287511f, 
    -0.02988008f, 0.07354565f, -0.04084310f, 0.20238367f, -0.11150458f, 0.07117134f, 0.15932444f, 0.05352840f, 
    0.06335497f, 0.09954176f, 0.13391601f, 0.16964757f, -0.11709201f, 0.04192674f, 0.04108894f, 0.11600113f, 
    -0.03155981f, 0.14982216f, 0.21870266f, 0.27562112f, -0.18873771f, -0.06963246f, -0.04190329f, 0.13389498f, 
    0.03955666f, -0.00195024f, -0.10762770f, 0.06262311f, -0.15054263f, 0.13052076f, 0.17164120f, 0.04606155f, 
    0.14430416f, -0.02671367f, 0.03025110f, 0.17319655f, -0.09155922f, 0.00999265f, 0.02002381f, 0.13714194f, 
    0.18171078f, -0.02511661f, 0.10529874f, -0.15766187f, -0.11557725f, 0.07200148f, 0.06777545f, -0.10697001f, 
    -0.14419019f, -0.00178686f, -0.02357242f, 0.09035324f, -0.10230792f, 0.13290659f, 0.03656704f, 0.20927843f, 
    -0.14533876f, 0.03327572f, -0.04436748f, -0.05773206f, -0.13370198f, 0.08093680f, 0.09696770f, 0.03515599f, 
    0.10851700f, -0.27779311f, -0.11655831f, 0.11258439f, -0.09970064f, 0.01366502f, 0.10107745f, 0.18701026f, 
    -0.02994259f, 0.08229958f, -0.01407080f, -0.03532780f, 0.16721678f, 0.11911760f, 0.09312955f, 0.30236119f, 
    -0.12479239f, 0.15094379f, -0.02932167f, 0.05537982f, 0.07729478f, 0.01869068f, 0.15319549f, -0.02710135f, 
    -0.31855658f, 0.10260105f, -0.02743423f, 0.02070842f, 0.06916795f, 0.14606687f, 0.01023106f, 0.05803606f, 
    0.12450433f, 0.00049270f, 0.04731030f, 0.12206829f, -0.11278147f, -0.12015912f, 0.06655261f, -0.08129692f, 
    -0.09590471f, 0.06295686f, 0.11720847f, 0.06905780f, 0.04369807f, 0.04165542f, 0.01028724f, -0.08325219f, 
    -0.07207674f, -0.26736361f, 0.00387518f, 0.19017819f, -0.10325775f, -0.05123958f, -0.00200298f, 0.05936771f, 
    0.04226732f, 0.24896741f, -0.05118921f, -0.08693922f, -0.40070355f, -0.14535135f, 0.19508424f, 0.10631340f, 
    -0.12914786f, 0.01278252f, -0.08219507f, 0.01953421f, 0.06291676f, -0.14328998f, -0.02388189f, -0.00305533f, 
    0.14952797f, -0.06219074f, 0.14887761f, -0.00602607f, -0.03802506f, 0.01002760f, -0.04282781f, -0.05384446f, 
    -0.05664182f, 0.04518615f, 0.13249908f, -0.07882155f, 0.29269448f, 0.31506395f, -0.01955648f, -0.04390060f, 
    0.12680718f, 0.02907898f, 0.17183246f, 0.06766446f, 0.11123537f, -0.01290130f, 0.09916412f, 0.02950963f, 
    0.17219067f, -0.01214002f, 0.08431242f, 0.11124543f, -0.01181204f, 0.15477730f, 0.16807270f, 0.03207348f, 
    0.04083330f, 0.14653489f, 0.10016624f, 0.03116854f, -0.08768169f, 0.09713597f, 0.03552416f, 0.03526701f, 
    -0.05764486f, -0.06667019f, -0.08682651f, -0.09340306f, 0.03057765f, 0.00874196f, -0.03003714f, -0.15001088f, 
    -0.18511875f, 0.22751385f, 0.06413196f, 0.24883711f, -0.04213567f, 0.03760099f, -0.09225353f, -0.09965541f, 
    0.00777643f, -0.13870497f, 0.08322831f, -0.16111505f, -0.01079880f, -0.11190901f, 0.07618551f, -0.08191690f, 
    -0.12855797f, -0.00087264f, -0.02779382f, -0.04346059f, -0.09547623f, -0.10328585f, 0.10431746f, -0.06466383f, 
    0.11290648f, -0.06062255f, 0.09906558f, 0.23769104f, -0.04479878f, 0.03120522f, 0.13787861f, 0.04096064f, 
    0.07372315f, -0.01235592f, -0.00141494f, -0.01714026f, -0.26735038f, -0.09105089f, 0.26441330f, 0.10708344f, 
    0.00758409f, 0.06307989f, -0.05316453f, -0.12368051f, 0.09875248f, 0.06671317f, -0.17962638f, -0.02791364f, 
    -0.08452225f, 0.26405770f, 0.15637794f, -0.09472986f, 0.15310924f, 0.07325287f, -0.06642848f, 0.22670238f, 
    -0.11823522f, -0.01781576f, -0.01901715f, 0.22413087f, 0.27577108f, 0.03742304f, 0.08942764f, 0.40817672f, 
    -0.21070872f, 0.14756991f, 0.04523328f, 0.03321851f, 0.12410910f, 0.05615499f, -0.07971115f, 0.04734597f, 
    0.12086789f, 0.13454144f, 0.14663440f, -0.05431134f, 0.16070662f, 0.07520491f, -0.13790271f, 0.05592632f, 
    0.10131819f, 0.10862550f, 0.01453002f, 0.08955993f, 0.17387769f, 0.13344213f, -0.05120211f, 0.04711422f, 
    0.10190228f, 0.09955573f, 0.15028405f, -0.07223549f, -0.08507010f, 0.06265812f, -0.02761867f, 0.04225641f, 
    -0.03993474f, 0.01581419f, 0.02074747f, 0.01974073f, 0.02766203f, 0.04889935f, 0.03390966f, -0.05249286f, 
    -0.04593238f, -0.03268806f, -0.04796842f, -0.03947300f, -0.02304858f, -0.00509855f, -0.06438369f, -0.00093450f, 
    0.01513236f, -0.03010646f, -0.03812192f, 0.02480109f, 0.01934014f, -0.05675671f, -0.03831102f, -0.04416597f, 
    -0.02777625f, -0.04079830f, 0.02774470f, -0.05469221f, 0.00882794f, -0.04170304f, -0.02040858f, -0.05157531f, 
    -0.04782639f, -0.02440687f, -0.00737344f, -0.04459013f, 0.01083080f, 0.00449991f, -0.00596312f, -0.05279540f, 
    -0.00676464f, -0.04633868f, -0.05597404f, -0.03844556f, -0.02318711f, 0.00009561f, -0.00923850f, -0.04855210f, 
    -0.01377562f, -0.03945516f, -0.04487880f, 0.01302484f, 0.03085844f, -0.01763860f, -0.00588584f, -0.00418500f, 
    -0.05146391f, 0.02568484f, -0.06138350f, -0.00960372f, -0.04452767f, -0.03829652f, 0.03553688f, -0.04237237f, 
    -0.00785538f, 0.01348880f, -0.02972543f, -0.00137880f, 0.01222982f, -0.05222096f, -0.01037336f, -0.04762489f, 
    -0.00738481f, -0.06043360f, -0.01661236f, -0.02648704f, 0.01745648f, -0.04883578f, 0.00208507f, 0.02776709f, 
    -0.05075746f, -0.03696470f, -0.05676743f, 0.00201486f, 0.02294871f, 0.00645922f, -0.01983153f, -0.05399092f, 
    -0.06289049f, -0.05972494f, -0.06016322f, -0.04088055f, 0.02961398f, 0.01493548f, 0.01192469f, -0.06253167f, 
    0.02005591f, 0.01756477f, -0.04776898f, -0.02797135f, 0.02038888f, 0.01719015f, -0.02672747f, 0.03001652f, 
    -0.05445886f, -0.02357666f, -0.02985838f, -0.05580756f, -0.04944483f, -0.02712662f, -0.02197191f, 0.01522152f, 
    -0.01391257f, -0.05059710f, -0.05777523f, -0.02046513f, -0.00027608f, -0.00746223f, -0.04282998f, -0.03461770f, 
    -0.02199637f, -0.05779609f, 0.01114507f, -0.00860006f, -0.02663186f, 0.03620125f, 0.02411078f, -0.06026841f, 
    -0.02204425f, 0.00449153f, -0.03774652f, -0.03782649f, -0.05091039f, -0.02718973f, -0.01672604f, -0.01031905f, 
    0.02895980f, -0.04731216f, -0.01821368f, 0.01499293f, -0.04104569f, -0.03823848f, 0.00431561f, -0.02219886f, 
    -0.05948978f, 0.02437424f, -0.06084890f, -0.02976022f, 0.02898230f, -0.04145331f, 0.02416215f, -0.01153817f, 
    -0.05327505f, -0.03668711f, -0.00165644f, 0.02787901f, -0.02571520f, 0.02887709f, -0.03067684f, 0.01184824f, 
    -0.03599946f, -0.06099642f, -0.01579253f, -0.03505401f, -0.05051875f, -0.03304948f, -0.03031991f, 0.00966593f, 
    -0.05364417f, -0.06138153f, -0.04391129f, -0.05971601f, -0.05858511f, -0.02339953f, -0.00076403f, -0.03758021f, 
    0.02818010f, -0.00209898f, 0.03041432f, -0.06092850f, -0.03352944f, -0.02921147f, -0.00440810f, -0.00437325f, 
    0.01650934f, -0.03972645f, -0.04968205f, -0.00948693f, 0.01121332f, -0.05712383f, 0.00723578f, -0.02874098f, 
    0.03318938f, -0.00050158f, -0.01429396f, -0.04144990f, 0.02523667f, 0.00980570f, -0.01989660f, -0.02118589f, 
    -0.00266143f, -0.00617515f, 0.01852437f, -0.02772372f, -0.03087663f, -0.03123427f, 0.01991448f, -0.04431532f, 
    0.00570371f, 0.03439587f, -0.00029403f, -0.01424993f, -0.01869180f, 0.00819943f, -0.00409235f, -0.02131582f, 
    0.00751943f, 0.00709544f, -0.04811225f, 0.02637542f, 0.01551210f, -0.06302352f, -0.00202904f, -0.05393426f, 
    -0.03413315f, -0.02249029f, 0.01314139f, -0.04232962f, 0.02884260f, -0.05513515f, 0.02576603f, -0.03391428f, 
    0.02093003f, 0.01503620f, -0.01217758f, -0.03388823f, 0.01530662f, -0.01407094f, -0.00230403f, -0.06013247f, 
    0.02208208f, -0.05960227f, -0.01942663f, 0.01933720f, -0.05850278f, -0.00983449f, -0.04813594f, -0.01654866f, 
    -0.03008939f, 0.00274381f, -0.03955843f, 0.02296529f, 0.03700628f, 0.02719504f, -0.03312391f, -0.02195384f, 
    -0.00035119f, 0.03588143f, -0.04513235f, -0.05593654f, -0.05976266f, 0.01069799f, 0.00693884f, -0.01703495f, 
    -0.05174885f, 0.03664298f, -0.01736654f, 0.01153444f, 0.02677654f, -0.06405611f, 0.03502946f, -0.02651858f, 
    0.00880472f, 0.01744341f, -0.03434115f, -0.02755517f, -0.03160176f, 0.02631392f, 0.00413686f, 0.01502559f, 
    -0.06154857f, -0.04681038f, -0.04543170f, 0.02817340f, -0.02701974f, -0.05381338f, -0.04739761f, 0.01699287f, 
    0.02554893f, 0.02164702f, -0.00761918f, -0.03940165f, 0.03444417f, -0.06288819f, -0.01213685f, -0.03644498f, 
    -0.05999041f, -0.04685228f, 0.01376656f, -0.04010871f, -0.04657388f, -0.05923084f, -0.05057767f, -0.00094977f, 
    0.01875543f, -0.01201103f, -0.01722144f, -0.05268470f, -0.00361617f, 0.02392315f, -0.03760200f, -0.05370578f, 
    -0.06085162f, -0.03587735f, 0.03371887f, 0.00329815f, -0.03623931f, -0.03852526f, 0.03382706f, -0.00199571f, 
    0.00898734f, -0.02651159f, -0.04818834f, -0.05004366f, 0.01230782f, -0.02785780f, 0.00326862f, -0.02287866f, 
    -0.04722013f, -0.04837844f, -0.04487099f, 0.02224218f, -0.04823664f, 0.01389464f, -0.03204661f, -0.01108852f, 
    -0.00377240f, -0.02029625f, 0.02732362f, -0.05607631f, -0.02306243f, -0.02004554f, 0.00221107f, 0.02768296f, 
    0.00396965f, 0.01525783f, -0.01594084f, 0.04191745f, -0.03422112f, -0.03151795f, 0.02676218f, 0.03300134f, 
    -0.01351838f, 0.00005318f, 0.03112552f, -0.02151585f, -0.06102028f, -0.02248479f, -0.00291156f, 0.02974738f, 
    0.00198842f, 0.03609518f, 0.03659701f, 0.01047207f, -0.00340134f, -0.03614036f, -0.05095126f, -0.00847975f, 
    -0.03763990f, -0.00423906f, 0.01697622f, -0.01684255f, -0.01261744f, -0.03916916f, 0.02112573f, -0.04909712f, 
    -0.04676821f, 0.01778117f, -0.04739783f, 0.01166701f, -0.05227999f, -0.03081215f, 0.02266910f, -0.02482457f, 
    0.18972389f, 0.24966465f, -0.06209048f, 0.24254918f, -0.13815749f, 0.00308594f, -0.04141788f, -0.10814228f, 
    0.01265433f, -0.07120351f, -0.03654594f, -0.03615781f, 0.01234388f, 0.39272121f, 0.02630580f, -0.15447937f, 
    -0.08986616f, 0.08548943f, 0.05632767f, -0.03023397f, 0.11187205f, -0.04038603f, -0.02644224f, 0.08483424f, 
    0.06095830f, -0.13635471f, 0.13201368f, 0.08964082f, 0.08124481f, -0.02873974f, -0.08904411f, 0.00142646f, 
    -0.01489983f, 0.03034060f, -0.02202272f, -0.13070367f, 0.09033964f, 0.04140332f, -0.12847881f, 0.00323303f, 
    -0.09459193f, -0.02244191f, -0.05774517f, 0.05013268f, -0.02899439f, 0.01754075f, -0.03203497f, -0.11961156f, 
    0.12108989f, 0.10107756f, -0.00169334f, 0.00306136f, 0.05523375f, 0.15489566f, -0.04841268f, 0.10835676f, 
    -0.16743466f, 0.04018804f, -0.03296839f, 0.11507343f, -0.06069825f, 0.10766225f, 0.00188307f, 0.27500150f, 
    0.00527942f, 0.01198658f, -0.06294920f, 0.07893101f, 0.07496728f, 0.00659885f, -0.10554556f, -0.02139921f, 
    0.29051915f, -0.00712338f, -0.09175679f, 0.29255179f, -0.02331384f, 0.02942511f, -0.09365883f, 0.09713476f, 
    -0.12288078f, 0.10062356f, -0.01417719f, 0.12898475f, -0.39096594f, -0.19167347f, -0.02501364f, 0.07017139f, 
    0.07953823f, 0.05601638f, 0.04879507f, 0.00848830f, 0.20268025f, -0.04813360f, 0.09179384f, 0.05987827f, 
    0.13287114f, 0.02220195f, 0.12653627f, -0.14310814f, 0.24950318f, 0.05167719f, 0.03124400f, 0.00949160f, 
    -0.03499765f, 0.02829527f, -0.09177876f, 0.11183241f, -0.04412527f, 0.10165548f, -0.12405138f, -0.06101185f, 
    -0.10860647f, 0.01594817f, -0.02204636f, -0.14821197f, -0.05745377f, -0.00415980f, -0.02736717f, -0.12187377f, 
    -0.22678635f, 0.22307074f, -0.01677002f, -0.26669073f, -0.05138639f, 0.04804799f, -0.02659918f, 0.09373357f, 
    -0.01948964f, 0.06329598f, -0.03776414f, -0.05965476f, 0.01663363f, 0.10184742f, -0.07256673f, -0.03435218f, 
    0.02090279f, 0.08104438f, -0.00132737f, -0.21760464f, 0.07717624f, 0.14651580f, 0.02841649f, 0.25494379f, 
    -0.02867609f, 0.04021676f, -0.05012166f, -0.05511826f, -0.03614118f, 0.03548789f, 0.01887285f, 0.06300922f, 
    -0.01745829f, 0.03600664f, 0.08543584f, 0.05014662f, -0.26041767f, 0.25256768f, -0.11706754f, -0.14407818f, 
    -0.10114937f, 0.04452329f, -0.00654538f, 0.05881292f, -0.15589122f, -0.09326118f, 0.10189080f, 0.04488489f, 
    -0.20265731f, 0.05498603f, 0.06509956f, -0.11544287f, -0.00722433f, -0.01844015f, 0.05934672f, -0.02893263f, 
    0.08242897f, -0.00835818f, -0.02652573f, -0.19412372f, -0.32899237f, 0.21494752f, 0.08620031f, -0.10037569f, 
    0.11313038f, 0.14393337f, -0.05714070f, 0.04359633f, 0.07288610f, 0.11332051f, 0.10611929f, -0.07213219f, 
    -0.37955984f, -0.10017571f, 0.07314575f, -0.17664856f, 0.05079737f, 0.03609938f, 0.04464640f, -0.03471394f, 
    -0.03032634f, -0.10878406f, 0.04807767f, 0.03498270f, -0.16629964f, 0.22975369f, 0.12870868f, 0.28509730f, 
    0.10444267f, 0.02163565f, 0.07698680f, 0.16459867f, -0.00687625f, 0.09269096f, -0.00927044f, 0.09296151f, 
    0.12017842f, 0.16798167f, 0.02771037f, -0.18839449f, 0.01718968f, 0.02275294f, -0.03687511f, -0.09321985f, 
    0.04074250f, 0.24967603f, -0.00413181f, -0.00567917f, -0.14445478f, 0.07334001f, 0.00541077f, -0.06834588f, 
    0.00455327f, 0.06915802f, 0.00523370f, 0.11992130f, -0.08637772f, -0.15180820f, -0.02894016f, -0.08202707f, 
    -0.37123156f, -0.12495895f, 0.00906488f, -0.12232273f, -0.00005888f, -0.09643777f, 0.09625114f, 0.03446327f, 
    0.01636184f, 0.11083606f, -0.02925153f, 0.10346556f, -0.09352031f, -0.12032641f, 0.03002293f, 0.23207630f, 
    0.07915954f, -0.00415186f, 0.10471947f, 0.00190333f, 0.11760160f, 0.11164854f, 0.08686678f, 0.03433632f, 
    -0.00525714f, -0.03442042f, 0.19264595f, -0.05836356f, -0.04757130f, -0.03026311f, 0.05658089f, -0.00601001f, 
    0.14724040f, -0.01288780f, 0.11206592f, 0.00975560f, -0.12876479f, 0.08722122f, 0.08566541f, -0.01554668f, 
    -0.05413165f, 0.04484709f, -0.01955888f, -0.09050210f, 0.13507919f, -0.06978281f, -0.02314511f, -0.15158036f, 
    0.19911474f, -0.02408593f, 0.01421777f, -0.27863666f, -0.04713001f, -0.02472486f, 0.03827414f, 0.05185644f, 
    -0.07856488f, -0.06262025f, -0.03293250f, -0.01482298f, 0.03769612f, 0.07010534f, -0.04298706f, 0.04350998f, 
    -0.05271308f, -0.06182810f, 0.09299032f, -0.12724462f, 0.02816370f, 0.01750010f, 0.06290618f, -0.06541197f, 
    0.18445446f, 0.36453494f, 0.08917198f, -0.08713273f, -0.07019057f, 0.05397911f, 0.15965147f, 0.07072902f, 
    -0.02769975f, -0.08238839f, 0.04988613f, -0.02558977f, -0.12036390f, -0.23889151f, 0.06585306f, 0.17841205f, 
    -0.05095663f, 0.00121313f, 0.02188538f, 0.09420332f, 0.04658242f, -0.14468403f, -0.04762640f, 0.02204787f, 
    0.03408631f, 0.06634649f, 0.08669931f, 0.20412961f, -0.10325029f, 0.06063276f, -0.07492046f, 0.00077998f, 
    -0.18057002f, -0.03813270f, 0.16780825f, 0.10916795f, 0.07250653f, 0.07741948f, 0.07738494f, -0.15259381f, 
    -0.03218932f, 0.11123109f, 0.12750253f, 0.02389119f, -0.01081379f, 0.11839236f, 0.01693305f, -0.01525322f, 
    0.03457264f, -0.11560865f, 0.15750077f, 0.14462405f, 0.06468154f, -0.04395929f, 0.10491157f, 0.08126362f, 
    -0.09173550f, 0.07440236f, -0.14544876f, 0.17099592f, 0.27858612f, -0.05122427f, 0.17501357f, -0.05866634f, 
    0.13825184f, -0.06667003f, 0.11275416f, 0.07573075f, -0.14039689f, 0.02362584f, 0.01762161f, 0.22688264f, 
    -0.04620245f, 0.01005944f, -0.03832153f, 0.01346461f, -0.04717361f, -0.01898619f, -0.03577987f, 0.04366502f, 
    0.00612029f, 0.04303588f, -0.03850535f, -0.03700080f, -0.04722536f, 0.03337440f, 0.00789254f, 0.02224500f, 
    0.04009849f, -0.02766913f, 0.02010093f, -0.00260297f, -0.02882132f, -0.03229484f, -0.01496491f, 0.04171601f, 
    -0.02175755f, -0.01086889f, -0.04493468f, -0.03432230f, -0.03751535f, -0.00541211f, 0.04598130f, -0.05002788f, 
    0.05095690f, 0.05148181f, -0.03924865f, 0.01740440f, 0.00406499f, 0.02968667f, 0.01304586f, -0.02864179f, 
    0.00168612f, -0.01373319f, 0.02881703f, -0.00707062f, 0.00121963f, -0.00675464f, -0.00831021f, -0.02545563f, 
    0.03037752f, 0.02069921f, -0.04017956f, 0.02022512f, -0.02774874f, -0.04359202f, -0.01933185f, 0.04007734f, 
    -0.01386975f, 0.03141308f, -0.02290400f, 0.00258009f, -0.03283791f, 0.04987732f, 0.01954266f, -0.00089015f, 
    -0.00660295f, -0.04376874f, 0.04478176f, -0.00130890f, 0.02805029f, -0.01811431f, -0.03770330f, -0.01578529f, 
    0.02249848f, 0.04438392f, 0.00665994f, 0.03193330f, 0.03054845f, 0.03264412f, -0.01712244f, -0.04145944f, 
    -0.03736853f, -0.03863379f, -0.02775460f, -0.03025210f, 0.03872086f, 0.03388375f, -0.00229137f, 0.00249591f, 
    -0.04608007f, -0.02834583f, 0.04637950f, -0.03102292f, 0.00956309f, 0.04241976f, -0.01338219f, 0.01512888f, 
    0.01030646f, -0.04427610f, -0.02112998f, 0.03893802f, 0.04652869f, -0.03090080f, 0.03778778f, 0.03534782f, 
    -0.01658423f, -0.00975014f, -0.05020861f, 0.01943786f, -0.02107707f, -0.05072734f, 0.01119193f, -0.02773717f, 
    0.02401064f, -0.02041902f, 0.00388561f, 0.02201295f, -0.01361807f, -0.04209094f, -0.01046191f, 0.02038348f, 
    0.00714416f, 0.02133203f, 0.00132764f, 0.00261915f, 0.00852525f, -0.04444767f, 0.01020551f, -0.04898221f, 
    -0.04406484f, 0.03727335f, 0.00628678f, -0.01833800f, 0.02091930f, 0.02104055f, 0.04009829f, -0.03410747f, 
    0.03564681f, -0.02227513f, 0.00054262f, -0.01411944f, 0.04257476f, -0.04425592f, -0.03882054f, 0.01746917f, 
    0.03628922f, -0.02307301f, -0.00595716f, -0.05528345f, -0.02802332f, -0.04786709f, 0.04261303f, 0.00230168f, 
    -0.00385640f, -0.03321355f, -0.04928152f, 0.01647677f, 0.02146989f, -0.00938552f, -0.03100589f, -0.00709140f, 
    -0.02979802f, 0.01178038f, 0.04466906f, -0.05205195f, 0.04382196f, -0.01398470f, -0.01165189f, -0.02904109f, 
    0.01390377f, 0.04562232f, -0.01223910f, -0.01481634f, 0.00184203f, 0.04975995f, -0.02395050f, -0.04805251f, 
    0.04686293f, -0.00973262f, -0.03056481f, -0.05580300f, -0.04815461f, 0.01539251f, -0.03264017f, 0.03984264f, 
    -0.02425341f, -0.04718335f, 0.02182690f, -0.03895591f, -0.04730228f, 0.04812307f, -0.03467725f, -0.01761087f, 
    -0.01840847f, 0.04476848f, -0.00138687f, -0.00295981f, 0.00451054f, 0.02510837f, -0.02832238f, 0.01275568f, 
    0.03643808f, -0.02357108f, -0.01712854f, 0.03287760f, -0.01892304f, 0.01045575f, -0.00811855f, -0.04246767f, 
    0.00976187f, -0.00367048f, -0.02285175f, 0.01806999f, 0.04000970f, -0.05887604f, -0.03632131f, 0.00791578f, 
    -0.03961459f, -0.04017277f, -0.01844626f, 0.03741935f, -0.02661170f, 0.02408311f, 0.00193908f, 0.02180172f, 
    -0.05394355f, -0.04822596f, -0.00498870f, -0.04462409f, 0.01876655f, -0.05379678f, -0.00450635f, -0.00694808f, 
    0.03265966f, -0.05341324f, -0.02186583f, 0.04773953f, -0.03120374f, 0.00747225f, 0.01473217f, 0.02169316f, 
    -0.02766042f, 0.00852658f, 0.02530762f, -0.03892601f, 0.02797420f, 0.04006836f, 0.03170128f, -0.04101049f, 
    0.04582097f, 0.03131108f, -0.02848344f, -0.03654648f, -0.01049453f, -0.01506216f, -0.00822965f, 0.01325473f, 
    0.03731564f, 0.05412553f, 0.00056704f, -0.00486023f, -0.05264774f, 0.00919117f, 0.01442325f, -0.03797359f, 
    0.01685550f, -0.02977367f, 0.00103621f, 0.04171276f, -0.04404286f, 0.02821012f, 0.04206827f, -0.01143034f, 
    -0.04843066f, 0.00597488f, -0.01914725f, -0.04924262f, -0.05420968f, 0.02674164f, 0.02292313f, -0.02482392f, 
    0.00648234f, -0.05416346f, 0.02814491f, -0.04577200f, 0.02034805f, 0.02599198f, 0.01004948f, 0.04452395f, 
    -0.00898939f, 0.04502418f, -0.03905075f, 0.04113767f, 0.02087223f, -0.04686664f, 0.01682293f, -0.01157339f, 
    -0.02693901f, -0.03569524f, -0.05066923f, -0.02801847f, -0.04816523f, -0.05314307f, -0.02995095f, -0.00259699f, 
    -0.03335342f, 0.02668571f, -0.02683516f, -0.04539671f, 0.00736592f, -0.00858405f, -0.01593112f, -0.04399551f, 
    -0.05229699f, -0.00135298f, 0.00460104f, -0.02868067f, 0.00020230f, -0.00074557f, 0.01036138f, -0.00971170f, 
    0.02441343f, -0.04065993f, -0.01206648f, 0.04633033f, 0.02660844f, -0.01714686f, -0.00330278f, -0.02627480f, 
    -0.02415537f, -0.04382781f, -0.00223792f, -0.01714159f, 0.02970535f, -0.02355517f, 0.04301780f, 0.00993165f, 
    0.00637163f, -0.00850981f, 0.01727378f, -0.00686059f, 0.04176329f, -0.00670604f, -0.03514279f, 0.02724686f, 
    0.01039729f, -0.04754897f, 0.01247905f, -0.01083753f, -0.02352127f, 0.04486488f, 0.04582065f, 0.02201209f, 
    0.04643784f, -0.03858297f, -0.00305417f, -0.00758238f, -0.04768897f, -0.00660441f, -0.01998171f, -0.01675588f, 
    -0.04248031f, 0.02034898f, -0.05247228f, 0.03527928f, -0.00910746f, -0.03277051f, -0.01609397f, 0.02953640f, 
    0.00131266f, 0.01436839f, 0.01139848f, -0.00641272f, 0.00347250f, -0.00320158f, -0.03772878f, -0.02656491f, 
    -0.05146538f, -0.01365429f, -0.01402627f, -0.00761295f, -0.01244344f, 0.00738264f, -0.04765103f, 0.00661175f, 
    -0.09612294f, -0.26324788f, 0.16877030f, -0.16633354f, 0.05273712f, -0.13125873f, 0.09687172f, 0.01851122f, 
    -0.01342830f, 0.17608050f, 0.07653492f, 0.18646254f, 0.02914203f, -0.28104156f, 0.21008222f, 0.02472328f, 
    0.04566463f, 0.00691587f, 0.06273317f, -0.02481550f, -0.01195679f, 0.08821741f, 0.10516492f, 0.00446920f, 
    0.01529887f, 0.43633553f, 0.04430662f, 0.01145442f, 0.11932670f, 0.08561882f, -0.09285659f, 0.23952883f, 
    0.00132575f, -0.06016520f, 0.06927506f, 0.12674013f, -0.09431273f, 0.00592602f, -0.09003660f, -0.15076610f, 
    0.13068976f, 0.04887667f, -0.02992532f, -0.06704155f, 0.07545656f, -0.10961825f, 0.05821361f, 0.02329103f, 
    -0.16966519f, -0.07595143f, -0.01023678f, 0.07626496f, 0.08159972f, -0.04573227f, 0.00918303f, 0.04087229f, 
    0.14866827f, -0.04806417f, 0.14633986f, 0.02839143f, 0.30744103f, 0.22966085f, -0.02531679f, 0.00103519f, 
    0.17578250f, 0.07048231f, 0.05647366f, 0.03886873f, -0.12468436f, 0.00124109f, 0.13533834f, 0.15253310f, 
    -0.06848826f, 0.16528687f, 0.07071834f, 0.09034660f, 0.15326357f, 0.00965552f, 0.06702083f, 0.00325022f, 
    0.11022285f, -0.04321272f, -0.01806438f, -0.04953799f, 0.02444588f, 0.06889953f, 0.06993424f, -0.07802267f, 
    -0.00282085f, 0.01846816f, -0.08558268f, 0.03730848f, -0.05972001f, -0.02784084f, -0.03202069f, -0.00937193f, 
    0.03563233f, 0.04406173f, 0.06411985f, 0.09833948f, -0.00189125f, 0.03449248f, 0.00038403f, -0.00888807f, 
    0.03833618f, -0.02077732f, 0.10491473f, -0.11160854f, 0.12647253f, -0.17248324f, -0.14795454f, -0.09155015f, 
    0.03920249f, 0.04460994f, 0.01846151f, 0.01410136f, 0.19123086f, -0.05680005f, -0.07393506f, 0.04614904f, 
    0.18454134f, -0.16582783f, 0.04213306f, 0.17295919f, 0.27828065f, 0.05148526f, 0.12609850f, -0.03843442f, 
    -0.03958954f, 0.05310043f, 0.10096840f, 0.07496262f, 0.17570552f, -0.05515880f, -0.07504185f, -0.09400800f, 
    -0.02123427f, 0.11473292f, 0.00210299f, 0.03348102f, 0.01974188f, -0.05633926f, 0.05739211f, -0.19960225f, 
    0.09597246f, 0.09966976f, 0.05930909f, -0.09597818f, 0.12133601f, 0.04252245f, -0.01762859f, -0.00064930f, 
    0.08171803f, -0.01783393f, 0.05816336f, -0.08838960f, 0.23287305f, -0.22332740f, 0.00023478f, 0.05503260f, 
    0.12092107f, -0.06742886f, 0.02024177f, 0.13392197f, 0.18146601f, 0.00931293f, -0.07495391f, -0.06485261f, 
    -0.06938074f, 0.10536296f, -0.00742216f, 0.04973087f, 0.13257419f, 0.09046904f, -0.04062730f, 0.02870832f, 
    0.17693971f, 0.10866491f, 0.06833831f, 0.19225302f, 0.32746181f, -0.00334603f, 0.00986906f, 0.07475302f, 
    0.00639403f, -0.14859904f, 0.09494001f, -0.07153931f, -0.05366769f, 0.01752187f, -0.12418499f, 0.11329360f, 
    0.29640654f, 0.13796514f, -0.11496861f, -0.01840881f, 0.03347121f, -0.06220970f, 0.09349565f, 0.02324536f, 
    0.03327044f, 0.15494578f, -0.04229886f, -0.14392261f, 0.21630257f, 0.08534162f, -0.03890260f, -0.12036467f, 
    -0.02371578f, 0.04630939f, -0.11260606f, -0.06289500f, 0.02280041f, -0.07326465f, 0.03510566f, 0.10984576f, 
    0.01036819f, 0.16199988f, -0.06675752f, 0.12983067f, 0.16064601f, 0.01682367f, 0.13159813f, -0.00309942f, 
    0.03824724f, -0.20993730f, 0.10611854f, 0.19112018f, 0.32247606f, 0.16434316f, 0.05395614f, 0.04878189f, 
    0.07491640f, 0.01334804f, 0.06847904f, -0.00331840f, -0.02620749f, 0.17180628f, 0.12662312f, 0.19003542f, 
    0.23064338f, 0.05217473f, -0.05761151f, 0.04523414f, 0.09372235f, 0.07532042f, 0.07191415f, 0.03071794f, 
    0.11386793f, 0.05512224f, 0.04458591f, 0.17185585f, -0.07693572f, -0.16602279f, 0.07572717f, -0.06314924f, 
    -0.00256081f, 0.00088984f, -0.21710047f, -0.05325189f, 0.02378190f, -0.11118165f, -0.01692741f, 0.04832970f, 
    -0.09161672f, 0.16933787f, 0.12778631f, -0.12143220f, -0.02996099f, -0.04970929f, -0.08201795f, -0.03587853f, 
    -0.02601530f, 0.04875445f, -0.03517921f, 0.00048196f, 0.05925372f, 0.00973690f, 0.02630152f, 0.00938765f, 
    0.02873510f, 0.06814574f, 0.07865480f, 0.06802040f, 0.09951852f, 0.05143234f, 0.16524002f, 0.25537345f, 
    0.00896930f, -0.04494545f, 0.19608341f, 0.18314698f, 0.17011218f, 0.02747241f, 0.03549076f, 0.08326569f, 
    0.01873055f, 0.10181353f, 0.06055416f, 0.10365235f, 0.04611092f, 0.02690011f, 0.06665098f, 0.11924467f, 
    0.01577138f, 0.11812130f, -0.02205300f, 0.18226115f, 0.13990037f, 0.00325333f, 0.06677311f, 0.18427302f, 
    0.03119735f, -0.03147126f, 0.02122634f, 0.10297462f, 0.06861469f, 0.00049133f, -0.07657206f, 0.00790326f, 
    -0.07513402f, 0.11207702f, 0.14933302f, 0.09132857f, 0.24341798f, 0.17111674f, -0.06510037f, -0.15013734f, 
    0.15336800f, 0.05740895f, -0.01846934f, 0.01187902f, -0.13378930f, 0.14297950f, 0.25952101f, 0.05341234f, 
    0.00013755f, -0.12023069f, -0.07866842f, 0.09112322f, -0.02454428f, 0.02484974f, 0.16943049f, -0.02887027f, 
    0.26258546f, 0.12735687f, 0.03795534f, -0.07570161f, -0.05760643f, -0.03072375f, 0.08815562f, 0.04973359f, 
    0.18736932f, -0.11685774f, -0.06068192f, -0.00633993f, 0.09277206f, -0.08635700f, 0.15366881f, 0.07082002f, 
    -0.12179727f, -0.01113319f, -0.13497525f, 0.02335885f, -0.06618450f, 0.03334089f, 0.03532900f, -0.04504090f, 
    0.10677691f, -0.09920084f, 0.09122661f, -0.13389847f, -0.13573623f, -0.07386929f, -0.06499194f, 0.17247319f, 
    -0.04316088f, 0.07027004f, -0.14237787f, 0.05108751f, 0.01062965f, -0.08035819f, -0.04928413f, -0.16586764f, 
    0.31263700f, 0.07302998f, -0.03523701f, 0.03882687f, 0.05409811f, 0.06358016f, 0.13090868f, 0.15013370f, 
    0.01007765f, 0.03312191f, 0.01310590f, 0.02029195f, 0.32886332f, -0.17219885f, -0.18821692f, 0.05682533f, 
    -0.12501872f, -0.04745818f, 0.02961890f, 0.08803730f, 0.12403201f, -0.14119069f, 0.07065574f, -0.01315523f, 
    -0.24604356f, -0.00334462f, -0.05965635f, 0.12423306f, 0.03500555f, -0.02832318f, 0.06696086f, -0.10150084f, 
    -0.07323577f, 0.03397756f, 0.03190439f, 0.11822723f, 0.13006476f, 0.22952150f, 0.10141534f, -0.02404227f, 
    -0.06735006f, -0.00802876f, 0.08950862f, 0.00882482f, 0.06810217f, 0.01240846f, 0.14100343f, 0.04905472f, 
    0.13020469f, -0.03317180f, 0.05822726f, -0.03173672f, -0.00958176f, 0.03337290f, 0.11266729f, -0.04663147f, 
    -0.07968879f, 0.18264633f, -0.14563769f, 0.05684123f, -0.40881267f, -0.01143008f, -0.11011249f, -0.01780332f, 
    -0.00883408f, -0.09824535f, -0.04039879f, -0.06550036f, 0.01715712f, 0.01385799f, 0.02866487f, 0.03386458f, 
    -0.08848977f, 0.04089284f, -0.00434295f, 0.09537307f, 0.03606403f, -0.01177562f, 0.09772771f, 0.01894779f, 
    -0.02987819f, 0.11373091f, -0.02843200f, -0.09848288f, -0.02644400f, 0.22649811f, 0.01976256f, 0.18839979f, 
    0.05971330f, 0.06646443f, 0.05723405f, 0.09582756f, -0.00807000f, -0.05668772f, -0.01110787f, 0.07329628f, 
    0.14224577f, -0.13062352f, -0.00850765f, 0.05275108f, -0.09376270f, -0.06381403f, 0.08887223f, -0.04949753f, 
    0.03623394f, -0.03484396f, 0.05859306f, 0.01521159f, 0.41514492f, 0.15413682f, -0.02846688f, -0.22697754f, 
    -0.03577309f, -0.01373605f, 0.06990641f, -0.07281782f, -0.12009913f, 0.03413019f, 0.16680250f, -0.04076253f, 
    0.11009308f, -0.06804703f, 0.14330953f, 0.02085619f, -0.12297305f, -0.07211164f, -0.06184986f, 0.09690698f, 
    0.00406364f, 0.05702377f, 0.03759751f, 0.03411133f, 0.51279879f, 0.14622401f, -0.08550740f, -0.18727468f, 
    -0.10472849f, -0.01810953f, 0.04788887f, 0.02482259f, -0.08024587f, -0.02066801f, -0.04991571f, 0.13787825f, 
    0.22054367f, -0.29277414f, 0.14696124f, -0.20335454f, 0.06099183f, -0.04462996f, 0.17667517f, -0.15005998f, 
    0.04515356f, 0.12005939f, -0.08258695f, 0.04860778f, 0.11223464f, -0.28419352f, 0.01145935f, 0.19938564f, 
    0.07648876f, 0.05040627f, -0.07282855f, 0.03487774f, -0.03437636f, -0.00673219f, -0.04797586f, 0.12200392f, 
    -0.06200682f, 0.17468871f, 0.24644153f, 0.02929610f, -0.06814241f, 0.04535417f, 0.02735101f, 0.07624798f, 
    -0.13791630f, 0.08225263f, -0.02829482f, -0.00830484f, -0.03175644f, -0.19892453f, -0.02460040f, 0.08423628f, 
    -0.08400974f, -0.02143088f, 0.05128318f, -0.05852961f, -0.02900504f, 0.05934132f, 0.08170547f, 0.11451605f, 
    0.33947447f, -0.06207614f, 0.02065419f, -0.08676046f, 0.02460729f, 0.03490857f, -0.05525559f, 0.05182715f, 
    -0.00902428f, 0.11659637f, 0.04997264f, 0.05038119f, -0.11198699f, 0.12099414f, -0.13828272f, 0.06305751f, 
    0.16306815f, 0.10423990f, -0.07517350f, 0.13559751f, 0.19532283f, 0.13009194f, 0.01835155f, -0.05848535f, 
    0.05254941f, 0.06191102f, -0.12689646f, 0.13569929f, 0.04258123f, -0.01433683f, 0.00331034f, 0.04255464f, 
    -0.06828500f, -0.11590092f, 0.00797043f, 0.08212277f, -0.00781317f, -0.10982605f, 0.00391386f, 0.11542463f, 
    -0.05987677f, -0.04772881f, -0.02680277f, 0.01827262f, 0.13909571f, 0.04910090f, 0.01643044f, -0.10139779f, 
    -0.35141289f, 0.12499876f, -0.12272745f, 0.08368090f, 0.04716940f, -0.01928953f, -0.03626537f, 0.05061623f, 
    0.02088188f, -0.03696826f, 0.07471855f, 0.15683685f, 0.00189048f, 0.54464197f, -0.10193701f, -0.35189411f, 
    -0.07379483f, -0.03202714f, 0.10316457f, -0.03535284f, 0.13024724f, 0.00933546f, -0.04962894f, 0.06160763f, 
    -0.20314531f, -0.11019410f, 0.13407645f, 0.09115227f, 0.06193408f, 0.09714136f, 0.04301668f, 0.17252085f, 
    0.05860453f, 0.13945076f, -0.09016722f, 0.06561645f, -0.22347240f, -0.13369480f, 0.00215436f, 0.11583407f, 
    -0.12683862f, -0.02195731f, -0.05735258f, -0.01691983f, 0.04341205f, 0.04271116f, -0.02848824f, -0.10607713f, 
    0.08838440f, -0.17655461f, 0.00506103f, 0.29511875f, -0.11448123f, -0.08617894f, 0.03401701f, 0.03120634f, 
    0.04055982f, -0.02209761f, 0.14924420f, -0.15693782f, 0.35601953f, -0.04520816f, -0.01677894f, -0.00801620f, 
    -0.05553938f, -0.03683608f, -0.02810802f, 0.05795193f, -0.07289581f, -0.09160285f, 0.07454449f, 0.06602777f, 
    0.04805702f, 0.09123714f, 0.02873610f, 0.09908586f, 0.02206635f, -0.10554375f, -0.04646416f, 0.06905054f, 
    0.09471015f, -0.04294278f, -0.08113852f, 0.05716317f, -0.47284839f, 0.23467489f, 0.15147056f, 0.10546970f, 
    -0.02513904f, 0.07794897f, 0.08205937f, 0.02836190f, 0.05494873f, -0.01106880f, -0.17793462f, -0.03499835f, 
    0.13408092f, 0.10372800f, 0.06748771f, 0.06617442f, 0.06745860f, 0.01321162f, -0.01222968f, -0.02066597f, 
    -0.03212840f, 0.02767701f, 0.02819367f, -0.01546383f, 0.20138299f, -0.07230026f, 0.12305331f, 0.06972429f, 
    -0.17992607f, 0.11900832f, 0.01356251f, 0.03295510f, 0.08576005f, 0.05151434f, -0.04774277f, 0.02736282f, 
    -0.12365296f, 0.34019488f, -0.11844171f, -0.12514481f, -0.01269375f, 0.04617151f, -0.01240259f, 0.11402629f, 
    0.02743985f, 0.02332743f, -0.02214574f, 0.03406852f, -0.13892178f, 0.00180595f, 0.01587355f, 0.10655762f, 
    -0.10046004f, -0.02075315f, 0.09588253f, 0.01381654f, 0.15817235f, 0.01933968f, 0.16691673f, -0.01287042f, 
    -0.03210409f, -0.04490587f, -0.05342527f, -0.03281879f, -0.04717908f, 0.04282886f, 0.03209031f, -0.00288327f, 
    0.00067769f, 0.00495910f, 0.00653092f, -0.03941586f, 0.00037664f, -0.04630902f, -0.00978625f, -0.05131384f, 
    -0.04141294f, -0.04327026f, -0.00030533f, -0.01244659f, 0.02476168f, -0.05185392f, 0.04379890f, -0.04269585f, 
    -0.02207819f, -0.02817487f, -0.00843916f, -0.00564548f, 0.02928176f, -0.04262858f, 0.00831541f, -0.03929573f, 
    -0.00117504f, -0.04359977f, -0.05575164f, 0.01607714f, -0.00416800f, -0.05027784f, 0.01192612f, 0.00309494f, 
    -0.04949567f, 0.03744260f, 0.02504592f, -0.05552422f, -0.04386814f, 0.01364376f, 0.01378741f, 0.02903683f, 
    0.01945476f, -0.00689211f, 0.01117043f, 0.02429572f, -0.05255877f, 0.03141270f, 0.03359106f, 0.01430211f, 
    -0.03423186f, 0.00881935f, -0.05035204f, 0.01100451f, -0.05456694f, -0.04205785f, -0.00003673f, -0.04853619f, 
    0.01703751f, -0.04529183f, -0.01831124f, -0.00808447f, -0.05323266f, 0.02413611f, 0.00919229f, -0.01142510f, 
    0.01258246f, -0.00839954f, 0.04339766f, -0.05290988f, 0.03090939f, -0.04175344f, -0.01234707f, -0.03360809f, 
    -0.04905722f, -0.02468171f, -0.02198045f, -0.01131778f, -0.00189062f, -0.03901207f, 0.02007853f, -0.01502113f, 
    0.03453359f, -0.02415888f, -0.01326488f, -0.02988114f, 0.00356428f, -0.04785245f, 0.02976700f, 0.01429985f, 
    -0.04484410f, 0.01652499f, -0.00515835f, -0.03466781f, -0.04598875f, -0.03940128f, -0.00619184f, -0.03716489f, 
    0.04050417f, -0.04117134f, 0.02984803f, -0.01768816f, 0.02555377f, 0.03427941f, -0.01920400f, -0.04357984f, 
    0.01650938f, -0.03350087f, -0.02207221f, -0.00599902f, -0.03531275f, -0.05054661f, 0.04129025f, 0.02881264f, 
    0.02152524f, 0.02164131f, -0.00630648f, -0.04068833f, -0.03521412f, 0.01150360f, -0.00364292f, -0.04459456f, 
    -0.03755300f, 0.04021119f, -0.04684398f, -0.03948070f, 0.02606436f, 0.00393737f, -0.00464782f, 0.03000938f, 
    0.02061936f, -0.01858123f, -0.02197760f, -0.00029740f, 0.02354824f, 0.03473244f, 0.03548090f, 0.00694120f, 
    -0.01800062f, -0.05625365f, 0.01692305f, -0.04638847f, -0.02408248f, -0.04942270f, 0.00424554f, 0.04422971f, 
    -0.01789923f, 0.03424671f, 0.01491265f, -0.04907928f, -0.00099624f, -0.02474474f, -0.03582489f, -0.02383422f, 
    0.04200669f, -0.02318817f, -0.00178279f, 0.00552525f, 0.04009969f, 0.01321676f, -0.01421183f, -0.04279619f, 
    0.03199535f, -0.00455261f, -0.04581883f, 0.03010907f, -0.05320645f, -0.01351725f, -0.00413148f, 0.01326286f, 
    -0.05059348f, 0.03897449f, -0.00768306f, -0.03755173f, -0.01565493f, -0.04814838f, -0.05379094f, -0.05109404f, 
    0.03109681f, 0.03478251f, 0.02394786f, -0.05459774f, -0.03046839f, 0.00904931f, 0.02874579f, -0.02361338f, 
    0.02435047f, 0.00071420f, 0.01460292f, 0.02485906f, 0.03129727f, 0.01029825f, -0.00206816f, 0.03579389f, 
    -0.02180541f, -0.02371434f, 0.02490236f, -0.01473835f, -0.02939101f, 0.00597648f, -0.02293735f, 0.02204916f, 
    -0.04165404f, -0.03950080f, 0.00398221f, 0.02154333f, 0.04078578f, -0.01595113f, 0.00972214f, -0.04105556f, 
    -0.00120071f, 0.02747284f, 0.01784498f, -0.04900177f, -0.01468720f, 0.00876947f, 0.02954548f, 0.02661362f, 
    -0.03155323f, -0.00884043f, -0.01597083f, -0.03164315f, 0.02305720f, -0.00436065f, 0.00919704f, -0.05139371f, 
    0.03460887f, 0.00696850f, -0.05524164f, 0.00157312f, -0.05109208f, -0.02571410f, -0.02609382f, 0.00430112f, 
    0.02171209f, -0.03102775f, -0.02328608f, -0.01604804f, 0.00225861f, -0.00152414f, -0.00365391f, -0.00768512f, 
    -0.04502836f, -0.02587395f, -0.01358259f, 0.01938900f, -0.05359080f, 0.00637557f, -0.00703546f, 0.02034377f, 
    -0.00750319f, -0.03488739f, 0.04226846f, 0.00809859f, 0.03037476f, 0.00901381f, -0.03647998f, -0.04635504f, 
    0.02960855f, -0.05492353f, 0.01839965f, -0.01080243f, 0.03835453f, -0.00053969f, 0.02374668f, 0.01019663f, 
    0.04490758f, -0.00723218f, 0.02961722f, 0.01741411f, -0.02573208f, 0.01936475f, 0.03070855f, 0.03152182f, 
    0.01628196f, 0.00548809f, -0.00529396f, -0.02813073f, 0.00742314f, 0.02615788f, -0.05089649f, -0.02918004f, 
    -0.01442748f, 0.01841314f, -0.02497668f, -0.04161997f, -0.02277447f, 0.00126195f, 0.01432953f, -0.05207112f, 
    0.02693530f, 0.03026160f, -0.04679825f, -0.05314209f, -0.04889226f, 0.03127638f, -0.05431981f, 0.00640870f, 
    0.02675225f, -0.01575635f, 0.03995024f, 0.04003002f, 0.04052819f, 0.00705237f, 0.00027771f, -0.03273176f, 
    -0.03290485f, -0.01069531f, 0.01143600f, -0.03743124f, 0.01687333f, 0.00303027f, 0.04228770f, -0.03864143f, 
    -0.05641005f, -0.02652042f, -0.02538988f, 0.00305212f, 0.02343955f, -0.02031258f, -0.01667704f, 0.03760484f, 
    -0.05233643f, 0.02784396f, 0.02671270f, -0.03782133f, -0.02761524f, -0.05325714f, 0.01421685f, -0.01230250f, 
    0.02990907f, 0.00530779f, -0.03034372f, 0.03022562f, -0.00092353f, 0.02093040f, 0.00426094f, -0.02995529f, 
    -0.05069783f, -0.05224618f, -0.01061565f, 0.01606684f, -0.03816991f, 0.02235356f, -0.03897521f, 0.04275301f, 
    -0.04600126f, 0.02344339f, -0.03176823f, 0.02868664f, 0.00902435f, -0.02654672f, 0.02870340f, -0.02571028f, 
    -0.00768959f, 0.01550174f, -0.00607011f, -0.00162807f, -0.04617529f, 0.02165101f, 0.03083191f, -0.02515489f, 
    0.01858111f, -0.03126357f, 0.00097634f, -0.05192968f, -0.03654581f, 0.01222313f, -0.02355279f, 0.02209312f, 
    -0.03946204f, -0.05617371f, 0.01359301f, -0.03241754f, -0.01994089f, -0.05594934f, -0.02793546f, 0.02430733f, 
    0.01178750f, -0.03620291f, 0.02049348f, -0.04435818f, 0.03856579f, -0.02804302f, -0.00702750f, -0.04415184f, 
    -0.04824167f, 0.01957245f, -0.02605524f, -0.01833948f, -0.01919207f, -0.03439090f, -0.03916477f, -0.02741223f, 
    0.03639767f, -0.04143658f, -0.04159126f, 0.02570860f, -0.01953826f, 0.02604897f, 0.01055907f, 0.02018080f, 
    0.03091174f, -0.00017383f, -0.00953025f, -0.02983529f, 0.03329680f, 0.03326406f, -0.00070549f, 0.04305017f, 
    0.03098354f, 0.03991840f, -0.04224833f, -0.04476603f, 0.00260772f, 0.01724323f, -0.01286745f, -0.00706220f, 
    -0.02316543f, -0.05393266f, -0.02645128f, 0.00059258f, -0.00563078f, -0.04732301f, -0.02886662f, -0.02967780f, 
    0.05012594f, 0.00875250f, -0.02772781f, -0.03931074f, -0.03597617f, 0.03950687f, -0.00441178f, 0.01235495f, 
    -0.01968653f, -0.05429195f, -0.03124616f, 0.03634565f, 0.05585802f, 0.05322515f, -0.03351574f, 0.05085827f, 
    -0.03950911f, -0.02994294f, -0.01501085f, 0.04206911f, -0.03125662f, 0.03347009f, -0.04997409f, -0.01526725f, 
    0.04076234f, 0.03774324f, -0.01356264f, 0.04226986f, -0.03028751f, -0.02387129f, 0.02157413f, -0.00918005f, 
    0.03813580f, 0.04280163f, 0.04385071f, -0.03248978f, -0.00190373f, -0.05051923f, 0.01298766f, 0.01955695f, 
    0.02607943f, -0.00859613f, -0.00915368f, 0.03864023f, -0.05363165f, -0.02423697f, -0.04415245f, 0.01654729f, 
    -0.02960992f, -0.02295353f, 0.03375787f, -0.01467227f, -0.02625857f, -0.01590360f, 0.02426273f, 0.04226636f, 
    0.01633840f, -0.01040955f, -0.02115269f, 0.00146851f, 0.03658150f, 0.04019965f, -0.01622249f, -0.03685258f, 
    -0.01152022f, -0.01994661f, -0.03802149f, -0.02767142f, -0.02498325f, 0.03599209f, 0.00269133f, 0.02534597f, 
    0.01352244f, -0.04165114f, 0.04552639f, 0.03353168f, 0.02579284f, -0.02055663f, -0.03407953f, 0.01551726f, 
    -0.04326857f, 0.01347084f, -0.03876217f, 0.01287910f, 0.01666040f, 0.03220845f, -0.02552704f, 0.05256058f, 
    0.02449733f, 0.02567547f, 0.02601483f, 0.04414875f, 0.00621265f, -0.05479842f, -0.00539038f, -0.02071145f, 
    0.01402203f, 0.03294047f, 0.01756989f, -0.03687672f, -0.01517452f, -0.00542361f, 0.01299110f, 0.04991627f, 
    0.02823186f, -0.03437816f, -0.03173118f, -0.02198003f, 0.02316444f, -0.04089069f, 0.04223172f, 0.03093852f, 
    -0.03010407f, -0.00025591f, -0.00228795f, -0.03397034f, 0.02132422f, 0.04001836f, -0.01470149f, -0.03884970f, 
    -0.00533290f, -0.04247405f, -0.03844014f, 0.01114495f, -0.05005826f, 0.03452735f, 0.03367313f, -0.04383716f, 
    0.03152002f, 0.00979283f, 0.03068331f, 0.04307557f, 0.00596757f, -0.00430031f, 0.02767142f, -0.05787413f, 
    0.00513054f, 0.04092718f, -0.01969299f, -0.02378586f, -0.04299173f, 0.04275162f, -0.03686799f, 0.02783526f, 
    -0.02186861f, 0.03449423f, 0.03253337f, -0.02107140f, -0.05601533f, 0.00958605f, -0.03081430f, -0.01037415f, 
    0.01923883f, 0.01901763f, -0.04242469f, -0.02584812f, -0.04358134f, -0.02270593f, 0.00881581f, 0.01937844f, 
    -0.00789574f, 0.01958497f, -0.04034166f, -0.00060210f, -0.01498574f, 0.03649492f, -0.04812617f, 0.04578688f, 
    -0.00904906f, 0.02161186f, -0.05282576f, -0.05679332f, 0.01708798f, -0.00854610f, 0.01176261f, 0.04053478f, 
    -0.01845653f, -0.02991127f, -0.01545986f, -0.01323386f, -0.04855970f, -0.01597734f, -0.00161036f, -0.04545449f, 
    -0.01662639f, 0.01363099f, -0.00944990f, 0.00036932f, -0.02735845f, -0.03652372f, -0.01125204f, -0.02823817f, 
    -0.04304151f, -0.00024762f, 0.02169882f, -0.00604857f, -0.00401267f, 0.02586362f, -0.00613385f, -0.01648323f, 
    0.01854668f, -0.04363841f, 0.03572483f, -0.02154908f, 0.00966410f, 0.01292502f, -0.02740203f, -0.05484447f, 
    0.02459238f, 0.02331067f, -0.02244846f, -0.01313252f, -0.01248010f, 0.02665916f, 0.01686124f, -0.04216035f, 
    0.05418654f, -0.00862474f, 0.02187107f, 0.01543547f, 0.02636573f, -0.02776982f, 0.00118887f, -0.01077776f, 
    0.00011908f, -0.01791545f, 0.02803757f, 0.02159031f, 0.04873370f, 0.02320308f, -0.04128290f, -0.05376393f, 
    0.02351963f, 0.00712757f, -0.00242618f, -0.03936789f, -0.03176952f, 0.02467747f, -0.02520098f, -0.04366350f, 
    -0.01894735f, -0.05619265f, -0.00924551f, 0.03910096f, -0.05772525f, -0.04953453f, -0.04245302f, 0.04410351f, 
    -0.01991997f, -0.05122237f, 0.00153971f, -0.00717456f, -0.02306047f, -0.03108798f, -0.00515789f, -0.03816681f, 
    -0.01814893f, 0.04170636f, -0.00460994f, -0.00724441f, 0.03847560f, -0.03843470f, -0.01418897f, -0.03391463f, 
    0.05184963f, 0.02286370f, 0.04851967f, -0.04879164f, -0.04971770f, -0.02779836f, 0.02456604f, -0.02461840f, 
    -0.03090020f, -0.01007865f, 0.01505215f, -0.03804397f, -0.04285930f, 0.03581237f, -0.02056740f, 0.00043256f, 
    -0.03530031f, 0.00947647f, 0.01290675f, -0.01338184f, 0.02303374f, 0.03685821f, -0.04846031f, -0.01685647f, 
    0.01268339f, 0.02536937f, -0.05695275f, -0.02233426f, 0.00780146f, 0.03992606f, 0.02253690f, -0.01213384f, 
    -0.05439286f, 0.03223604f, -0.02256406f, -0.02988183f, -0.03181138f, -0.03304879f, -0.02180527f, 0.01184474f, 
    -0.03717256f, -0.04267946f, 0.05037407f, -0.02491270f, -0.04094990f, -0.03446841f, 0.02880192f, 0.01810487f, 
    0.03948949f, -0.04675246f, -0.02900979f, -0.00756597f, 0.03396123f, 0.00548281f, -0.00647801f, 0.02226916f, 
    0.01244199f, 0.02099280f, -0.00905284f, 0.03375039f, 0.00357955f, 0.03617469f, -0.03120869f, -0.02288613f, 
    0.04610699f, -0.04879295f, 0.00021965f, -0.00368595f, -0.00218058f, -0.01374877f, -0.04174059f, -0.03965976f, 
    -0.20131181f, -0.24067195f, -0.00444042f, 0.17048597f, 0.05856429f, 0.01687888f, 0.08300041f, -0.02280369f, 
    0.07496960f, 0.12302579f, 0.04589590f, 0.16533938f, -0.20112427f, 0.04768085f, -0.08543396f, 0.00797252f, 
    0.19816905f, 0.07274739f, 0.05477921f, -0.13019910f, -0.01771680f, 0.19976768f, 0.17224906f, 0.02233514f, 
    -0.01752015f, 0.15142490f, 0.00351251f, 0.22794028f, -0.00161023f, -0.06535500f, 0.04091460f, 0.07220526f, 
    0.08170553f, 0.03171572f, -0.00239051f, 0.02681608f, -0.03003734f, -0.26273099f, 0.03280555f, 0.23088969f, 
    0.07568157f, 0.15769307f, 0.09409310f, 0.09543981f, -0.11696016f, -0.00607715f, 0.08867192f, 0.00892664f, 
    0.09349753f, -0.30135629f, -0.04460071f, 0.16461037f, -0.11440022f, -0.13535382f, 0.06252903f, -0.03427690f, 
    0.06657179f, -0.07225126f, 0.05387375f, 0.01405179f, 0.13268921f, 0.01654057f, 0.21587630f, -0.14110574f, 
    0.01728505f, 0.03892387f, 0.08559317f, 0.03000042f, -0.09133664f, -0.11021852f, 0.13783683f, 0.04822450f, 
    -0.51383334f, 0.03713578f, 0.23015262f, -0.01583907f, 0.01726002f, 0.02376024f, -0.07091153f, 0.03463021f, 
    0.10086592f, -0.04348451f, 0.04918178f, -0.02109135f, 0.10352322f, 0.02680351f, -0.10358604f, -0.15423785f, 
    0.04881807f, -0.12458484f, -0.03876293f, 0.00491468f, -0.07757146f, -0.05400968f, -0.04666105f, 0.04903470f, 
    -0.25604552f, 0.29716384f, -0.17954642f, 0.28002018f, -0.05661454f, 0.06078446f, -0.05698894f, -0.01709667f, 
    0.07572211f, -0.02156657f, 0.08606272f, 0.00220169f, -0.21461932f, -0.30429724f, -0.14844945f, -0.02641771f, 
    0.16323648f, 0.07069593f, 0.06103111f, 0.12319338f, 0.05663117f, 0.04729510f, -0.11161295f, 0.05508381f, 
    0.11901844f, -0.01577173f, 0.13972190f, 0.14607990f, -0.00514645f, -0.07422700f, 0.04329381f, 0.04198874f, 
    -0.07458448f, -0.02448260f, 0.03890368f, 0.08717649f, -0.33271453f, -0.18938595f, -0.05685429f, 0.02076641f, 
    0.05510217f, 0.01697728f, 0.05122727f, 0.16431373f, 0.04824154f, -0.01544110f, 0.10418819f, -0.17115277f, 
    0.14774701f, -0.20073593f, 0.10301404f, -0.14315598f, 0.13081890f, 0.01752914f, -0.03964703f, -0.01997852f, 
    -0.03597312f, -0.11532716f, 0.12192385f, -0.05082190f, 0.20222488f, -0.09185287f, 0.12269477f, -0.03745085f, 
    -0.07838167f, -0.09266292f, 0.02318287f, 0.02947956f, 0.06487328f, -0.08390733f, -0.13430811f, -0.05198899f, 
    -0.06661224f, -0.06976083f, -0.29420409f, 0.32225817f, 0.09495155f, 0.08935910f, -0.00508737f, 0.11739390f, 
    0.11170167f, 0.11209317f, -0.02489448f, 0.13932401f, 0.41784719f, 0.06441234f, 0.07481469f, 0.11424275f, 
    -0.00004459f, -0.06953762f, 0.02134113f, -0.08928754f, 0.04746356f, -0.04412775f, -0.13620456f, 0.02378325f, 
    -0.04835000f, 0.26934847f, -0.34342736f, 0.00194649f, 0.17538317f, -0.04641122f, 0.12615924f, 0.03319047f, 
    0.08421940f, 0.08707554f, -0.09329221f, -0.06697837f, 0.29241249f, -0.26183516f, 0.13079637f, -0.22001731f, 
    -0.17989863f, 0.07021559f, 0.00241156f, -0.12610099f, -0.04415586f, -0.13970181f, 0.07250527f, -0.03132579f, 
    -0.17166190f, 0.03902548f, -0.35981959f, 0.26353258f, 0.12163378f, 0.03185679f, 0.04660513f, 0.12210746f, 
    0.02225900f, -0.02567527f, 0.03691959f, -0.00187249f, 0.01316443f, -0.02339227f, 0.30217102f, -0.00505593f, 
    -0.03173659f, -0.16731389f, 0.00319259f, -0.10649784f, -0.03170980f, 0.01187676f, 0.08342295f, 0.12441478f, 
    0.25931317f, -0.03100815f, 0.13572523f, -0.14530855f, -0.07769186f, 0.04132590f, -0.02419999f, 0.02578765f, 
    0.08499558f, 0.02171704f, 0.09364665f, -0.12249748f, 0.12018664f, -0.19578658f, -0.09141609f, -0.13140097f, 
    0.05266493f, -0.02590371f, -0.00572587f, -0.01011295f, -0.01885453f, 0.02400919f, 0.00887232f, 0.09807733f, 
    0.15898269f, 0.37080666f, -0.23892996f, -0.18924347f, 0.03665662f, 0.02887079f, 0.00539373f, 0.01502481f, 
    -0.14191677f, -0.02721733f, 0.02154407f, -0.05991542f, -0.17482148f, 0.32263660f, -0.04097440f, 0.06548540f, 
    0.20006703f, 0.01457717f, 0.06498852f, 0.05766895f, 0.05620212f, 0.02466615f, 0.03502811f, 0.13687769f, 
    -0.11528653f, 0.27922422f, 0.15499486f, 0.04219408f, 0.13670816f, 0.16596009f, -0.09118754f, 0.08890692f, 
    -0.01940736f, 0.11958209f, 0.05755233f, 0.18027009f, 0.07550017f, -0.26677540f, 0.04412336f, 0.10601914f, 
    0.08985507f, 0.08535518f, -0.04849254f, 0.10980642f, -0.01913535f, 0.02951754f, -0.01149430f, 0.05806489f, 
    0.14780222f, -0.01917702f, 0.06242827f, -0.00119420f, -0.01566175f, -0.04741902f, 0.02648693f, 0.01672937f, 
    -0.06632307f, -0.01000640f, 0.05351715f, 0.08974460f, 0.12391617f, 0.06468482f, -0.03846656f, -0.20444167f, 
    0.02342540f, -0.01910059f, -0.04823067f, -0.00776776f, -0.04738835f, 0.21935348f, 0.16737817f, 0.10434393f, 
    -0.03569774f, 0.18791226f, 0.14469180f, 0.08232579f, 0.07831725f, 0.13162085f, 0.18328643f, -0.00224591f, 
    0.14733255f, 0.20673086f, -0.04174852f, 0.09563585f, 0.14674440f, -0.04400024f, 0.05504136f, 0.11016382f, 
    0.10459160f, -0.12688991f, 0.05365221f, 0.02208747f, 0.12451190f, -0.10614886f, 0.09481171f, 0.05574926f, 
    -0.25470197f, -0.07376646f, -0.04452034f, -0.10254648f, 0.06780408f, 0.09217133f, -0.06699075f, -0.01385280f, 
    0.04474308f, -0.07137023f, 0.15654214f, -0.08696280f, -0.25438350f, 0.14654443f, -0.11572274f, 0.15369920f, 
    -0.09453271f, 0.04337554f, -0.05986223f, 0.10634017f, -0.15502040f, 0.08156368f, -0.12933135f, -0.16672279f, 
    -0.13609272f, 0.06610838f, 0.00196993f, -0.14201081f, 0.13923481f, 0.13384154f, 0.11098607f, 0.06701300f, 
    -0.00564003f, 0.19189988f, 0.02742271f, 0.13166647f, 0.12644809f, -0.15741888f, 0.01036177f, 0.11337557f, 
    -0.02809726f, 0.00264039f, -0.12389559f, 0.15619002f, 0.02800581f, -0.08783919f, 0.11275871f, -0.02092040f, 
    -0.39616412f, 0.06296365f, 0.21341966f, -0.09818371f, 0.13293780f, 0.12144176f, 0.10657305f, 0.01403742f, 
    -0.08749130f, 0.00994217f, 0.15216748f, 0.23966883f, 0.06591670f, 0.08960988f, 0.10084087f, 0.02428130f, 
    0.01948868f, -0.01527424f, 0.12133000f, 0.00855522f, 0.07514211f, 0.07407885f, -0.01209330f, 0.14339042f, 
    -0.28968737f, 0.09032687f, 0.02607132f, 0.14106730f, 0.11962386f, 0.10701976f, 0.15645579f, -0.08174238f, 
    0.15399420f, 0.07523438f, 0.09104811f, 0.05810975f, -0.32826084f, -0.02855580f, 0.14856710f, 0.05983275f, 
    -0.00955273f, 0.10438918f, 0.06602999f, -0.04862528f, 0.14091973f, 0.01745094f, -0.02906077f, 0.07259741f, 
    -0.13475299f, 0.00728331f, 0.08176049f, -0.41595954f, 0.10429014f, 0.07381609f, 0.07307720f, 0.02776875f, 
    0.06631029f, 0.00557724f, 0.11709920f, 0.00554820f, 0.50374281f, 0.11794360f, -0.02554402f, 0.10868569f, 
    0.05741637f, 0.08164862f, 0.19263840f, 0.25657403f, -0.06050879f, 0.06533830f, -0.06977712f, -0.13271567f, 
    0.21418822f, -0.21102405f, -0.00028137f, -0.05694731f, -0.07752228f, 0.05337412f, 0.10128459f, 0.11271556f, 
    0.06397763f, 0.11321452f, 0.16246468f, 0.20550950f, 0.28534701f, 0.13551140f, 0.29239759f, 0.20808038f, 
    -0.03353566f, -0.08502422f, -0.02798816f, 0.18242881f, 0.08211081f, -0.01430875f, 0.15667242f, 0.13917434f, 
    -0.18763305f, -0.00337105f, 0.01615614f, -0.10767991f, 0.19686006f, 0.01008907f, -0.03262121f, -0.04830370f, 
    0.07310281f, 0.07508761f, 0.16096294f, 0.07284852f, 0.44770437f, 0.14649324f, 0.22011508f, 0.13884464f, 
    -0.10878579f, -0.08163080f, -0.05898484f, 0.14673789f, -0.02418875f, 0.08531467f, 0.04356830f, 0.07242694f, 
    -0.01501431f, 0.14170524f, 0.04132990f, 0.30064413f, -0.01933837f, 0.13523640f, 0.09225034f, 0.19473389f, 
    0.10432277f, 0.01213807f, -0.03950854f, 0.08494734f, 0.02833639f, 0.01499396f, 0.14981414f, 0.08043907f, 
    0.11503980f, 0.07392722f, 0.13843793f, -0.01274588f, 0.11665232f, 0.22761539f, 0.08199342f, 0.11438474f, 
    0.60192430f, -0.10472539f, 0.07302579f, -0.02181952f, -0.06031657f, 0.07833216f, 0.08239911f, 0.06612311f, 
    -0.03017471f, 0.03578565f, 0.20124631f, 0.12350450f, -0.05321745f, -0.12407673f, -0.01782762f, 0.02925846f, 
    0.08697637f, 0.07208508f, 0.23628590f, 0.06162335f, 0.03193518f, -0.02432470f, 0.11230807f, 0.20639785f, 
    0.58758354f, -0.10956787f, 0.16616946f, 0.25749806f, -0.22880319f, 0.02542559f, -0.09599654f, 0.15963002f, 
    0.02447132f, 0.04816399f, 0.05473832f, 0.17306484f, -0.15577611f, -0.05753419f, -0.02249249f, 0.08078992f, 
    0.14170071f, 0.07786912f, 0.05811942f, -0.02100018f, 0.00568350f, 0.10632070f, 0.15103744f, 0.07020466f, 
    0.31401238f, -0.15383480f, 0.21583094f, 0.14096926f, -0.03418127f, 0.10018862f, 0.01646744f, 0.08183369f, 
    0.03055235f, 0.00666759f, 0.05039309f, 0.06997814f, -0.01356783f, 0.22166309f, -0.06309390f, -0.03251474f, 
    0.12743194f, 0.12492304f, 0.04438882f, -0.09153570f, 0.13843037f, 0.19176964f, 0.03049747f, -0.00214969f, 
    0.18759623f, 0.11057778f, -0.08319844f, 0.19032186f, 0.05284216f, 0.20985839f, 0.13673626f, 0.05818086f, 
    0.03995268f, -0.01141368f, 0.08412505f, 0.07246104f, 0.20661856f, 0.13782357f, -0.11863144f, 0.05229257f, 
    -0.00803520f, 0.01168268f, 0.09824667f, 0.16859826f, -0.09718224f, 0.11594080f, 0.00847049f, -0.07248027f, 
    0.28427193f, -0.17590940f, -0.28383705f, 0.08512411f, -0.03918084f, 0.07098158f, -0.09629459f, 0.14634711f, 
    -0.07513218f, 0.08213795f, -0.11526675f, 0.11395471f, 0.34921825f, -0.11786820f, -0.01887305f, 0.03483683f, 
    -0.06674735f, 0.05501373f, 0.01283966f, 0.08332083f, 0.00907339f, 0.16662759f, 0.06005454f, -0.02405694f, 
    0.17623295f, 0.09303427f, -0.02299573f, 0.08169352f, 0.03848184f, -0.02644078f, 0.08169537f, -0.04653860f, 
    0.12072086f, 0.05977542f, 0.13391346f, 0.04802509f, -0.01323065f, 0.15864581f, 0.12862685f, -0.10079705f, 
    0.09140605f, 0.06875073f, 0.01667127f, 0.07371058f, 0.07645061f, -0.03229810f, 0.14217880f, 0.03242535f, 
    -0.47080159f, -0.23112199f, 0.05130035f, 0.06044720f, 0.18428661f, -0.01849426f, 0.02796156f, -0.01119072f, 
    0.05676332f, -0.00445609f, -0.12359217f, -0.02921250f, 0.43402588f, 0.15952897f, -0.11610819f, -0.08918262f, 
    0.06797729f, 0.09633980f, 0.02355404f, 0.04578671f, 0.08139447f, -0.01264079f, -0.10301879f, -0.01524534f, 
    -0.12559770f, 0.10341731f, 0.01556685f, -0.29107097f, 0.26802781f, -0.01579668f, -0.07143942f, 0.10314760f, 
    -0.05201735f, -0.00911495f, 0.06989305f, 0.00162456f, -0.15926799f, 0.02667948f, -0.04000894f, 0.04117895f, 
    0.10391267f, -0.00146999f, -0.04132046f, -0.04246327f, -0.06741738f, 0.07791977f, -0.03156141f, -0.07824052f, 
    0.36120605f, -0.04668945f, -0.14943814f, 0.09147950f, 0.05866742f, 0.12510699f, 0.05869972f, 0.09880187f, 
    0.04745782f, 0.12176748f, 0.11783603f, -0.00097711f, -0.10306803f, 0.00637695f, -0.03580340f, -0.12219715f, 
    0.05847192f, 0.14782843f, -0.11780783f, -0.07352176f, 0.29654080f, 0.07750231f, 0.05448420f, 0.05788745f, 
    0.11630792f, 0.14216791f, 0.07543713f, 0.14531870f, -0.03650219f, -0.13365677f, 0.09918227f, 0.02140103f, 
    -0.04447106f, -0.04792606f, 0.04318821f, 0.04322142f, -0.17956027f, 0.00975860f, -0.25359002f, -0.05476694f, 
    -0.07781877f, 0.01421832f, 0.03853459f, -0.02660828f, -0.09197838f, -0.01571717f, 0.15391023f, 0.06111844f, 
    0.02181461f, -0.23433249f, -0.24276087f, -0.13161631f, 0.12273808f, -0.00452265f, 0.09920341f, 0.11965781f, 
    -0.15766077f, 0.17563097f, -0.10315461f, -0.02282780f, 0.07288533f, 0.16758798f, 0.36816648f, 0.27464002f, 
    0.06973217f, -0.09675173f, 0.04020908f, 0.15460214f, -0.10701910f, 0.05575522f, 0.14051838f, 0.10710289f, 
    0.32378238f, -0.02673502f, -0.08045959f, -0.18570417f, -0.12173787f, 0.09666259f, 0.19913478f, -0.01561266f, 
    -0.13197702f, 0.05390716f, 0.00020526f, -0.14644389f, 0.23101339f, 0.02108071f, -0.19874634f, -0.16462083f, 
    -0.02966242f, 0.09778196f, 0.03480707f, 0.03883698f, -0.00827811f, -0.14545116f, -0.04426920f, 0.01821822f, 
    0.05855313f, 0.10384326f, -0.11370048f, -0.16636053f, -0.02798577f, 0.10159181f, 0.04972190f, -0.01016722f, 
    -0.07519384f, 0.03003658f, -0.04477710f, 0.11821816f, -0.04013399f, -0.01211906f, 0.13408460f, 0.12474064f, 
    0.02099561f, 0.02305587f, -0.16547208f, -0.23706940f, -0.09222703f, -0.21941198f, 0.00988449f, 0.09160055f, 
    0.07359836f, -0.22218525f, 0.13726898f, 0.11484940f, -0.08392797f, -0.10391826f, 0.05986778f, 0.04807701f, 
    0.06905602f, -0.02160743f, 0.03756299f, -0.12499381f, 0.13040227f, 0.20986187f, 0.14703076f, 0.12351505f, 
    0.01177787f, -0.00585466f, -0.06603223f, 0.00171705f, -0.00382885f, 0.11993479f, 0.05381838f, 0.01598574f, 
    0.00805735f, -0.01098832f, -0.16041540f, -0.05148703f, 0.06789503f, 0.10944124f, 0.00613671f, 0.06668796f, 
    -0.06999990f, -0.12183063f, -0.04336689f, -0.11835372f, 0.13701080f, 0.09744976f, 0.14653575f, 0.10882446f, 
    -0.03887548f, 0.13693984f, -0.05745151f, 0.03082981f, 0.01342188f, 0.14440709f, 0.05796148f, 0.06223351f, 
    0.13974015f, 0.06814946f, 0.09731981f, -0.05253494f, 0.05246530f, 0.05897406f, -0.23457697f, -0.12909435f, 
    0.00824342f, -0.06919820f, 0.05114044f, 0.00997180f, 0.05857715f, 0.17764892f, -0.07624036f, 0.05439840f, 
    -0.05307364f, -0.02941650f, -0.04915762f, 0.03740814f, -0.07759957f, -0.07419074f, -0.18689297f, -0.05492568f, 
    0.15464868f, 0.11167172f, 0.13473396f, 0.14175268f, 0.08416918f, -0.01100242f, -0.09567109f, 0.09812704f, 
    -0.15186645f, -0.01881498f, -0.01994020f, -0.01466479f, 0.28384662f, 0.04529269f, 0.02444811f, 0.04424550f, 
    -0.16437793f, -0.00243650f, 0.02618165f, -0.03644242f, -0.09475666f, -0.02684488f, -0.15703957f, -0.02379755f, 
    0.09987781f, 0.03694055f, 0.17149998f, 0.07686034f, -0.01871282f, 0.16471066f, 0.02779300f, -0.10939188f, 
    0.11007535f, -0.06319700f, 0.00882501f, 0.08283847f, 0.09164461f, 0.12475502f, -0.12644544f, -0.09886771f, 
    0.02934101f, -0.02309821f, -0.15909359f, -0.00858245f, 0.01453820f, 0.04636258f, -0.10992879f, 0.11808789f, 
    0.02696104f, 0.05124575f, 0.09896407f, 0.02165515f, 0.07847853f, -0.01026231f, 0.01615835f, -0.05976373f, 
    -0.11947374f, -0.14629172f, -0.04256726f, -0.09874386f, -0.03316231f, -0.24452223f, -0.18368967f, -0.19022560f, 
    0.07269785f, -0.06165094f, -0.01615875f, -0.04052407f, 0.00110198f, -0.02637186f, -0.11018222f, -0.13865471f, 
    -0.08459432f, -0.11610915f, 0.07323774f, 0.07067670f, -0.00217860f, 0.01672391f, 0.07506609f, 0.03199833f, 
    0.02058999f, -0.14127325f, -0.16399375f, 0.01467796f, 0.21234879f, 0.04586994f, 0.04680044f, 0.12208736f, 
    0.16563223f, -0.06873721f, -0.01374273f, -0.13938402f, -0.04228555f, -0.00526582f, -0.05227789f, 0.10810764f, 
    0.08646027f, -0.12487032f, 0.01321384f, -0.12611212f, -0.03127161f, 0.00172013f, 0.06514895f, 0.00739005f, 
    -0.05474997f, 0.06601152f, -0.12165812f, -0.05691872f, -0.12031789f, -0.13914669f, 0.00103758f, -0.07850816f, 
    0.02078375f, -0.04827796f, -0.01527895f, -0.16179807f, 0.06335878f, -0.02975098f, -0.07236093f, -0.16458492f, 
    -0.08810785f, -0.08955948f, -0.05317464f, -0.00246202f, 0.08196672f, 0.04148473f, 0.04123981f, 0.09570652f, 
    -0.01810718f, -0.06029859f, 0.07552510f, -0.05563232f, 0.19010182f, 0.17754304f, 0.04562433f, 0.12135799f, 
    -0.24204400f, -0.02879155f, 0.06007658f, 0.01041347f, -0.15601936f, -0.03410788f, -0.04187804f, 0.01779461f, 
    0.18825828f, -0.08289302f, -0.23155397f, -0.17976242f, 0.03076278f, 0.01279722f, -0.00153331f, 0.01760581f, 
    0.03421964f, -0.01290082f, -0.02147498f, -0.01565955f, -0.09182634f, -0.27212748f, -0.02562365f, -0.00298367f, 
    0.08598518f, -0.08515611f, -0.15213922f, -0.31333506f, -0.12516806f, -0.01962993f, -0.02589185f, -0.00710477f, 
    -0.03579345f, 0.06607357f, 0.05846342f, 0.09454650f, -0.09689268f, -0.01660496f, 0.03298450f, 0.16056696f, 
    -0.05354693f, 0.08490700f, 0.16802482f, -0.00154915f, 0.09280150f, -0.01968175f, -0.11536872f, 0.09770918f, 
    0.02848213f, 0.04258331f, 0.00716661f, -0.01439619f, -0.02787502f, -0.06696410f, -0.07084899f, -0.22510587f, 
    0.14810309f, -0.02492823f, 0.11499164f, 0.00678787f, 0.12954740f, -0.01263206f, -0.05858163f, 0.05614251f, 
    -0.00185737f, -0.05340045f, -0.06061496f, 0.07875236f, 0.10472511f, -0.11313843f, -0.07535232f, 0.01113357f, 
    -0.09217739f, -0.15480149f, 0.04088940f, 0.00597724f, -0.06196932f, 0.03769275f, 0.21297565f, -0.06838331f, 
    -0.03870122f, -0.00645858f, -0.03605016f, -0.04741092f, -0.03167376f, 0.03681444f, 0.01170097f, -0.04719440f, 
    -0.05292562f, -0.00768077f, 0.03778202f, -0.00470080f, 0.04458159f, -0.01541399f, -0.02444559f, -0.05258803f, 
    -0.02590018f, 0.04280105f, 0.00817421f, -0.04874038f, -0.03556055f, -0.02443010f, 0.03438988f, 0.00674533f, 
    -0.00439059f, 0.03404228f, -0.02424102f, -0.05517218f, 0.00317362f, -0.04845078f, 0.00314163f, -0.03444045f, 
    -0.01450703f, 0.01969109f, -0.01358436f, -0.05078109f, -0.03334017f, -0.01191553f, 0.03866505f, 0.02559354f, 
    0.03841832f, -0.02189844f, -0.05144572f, 0.02300766f, 0.01589578f, -0.03446899f, 0.04378381f, -0.05410103f, 
    -0.00646745f, -0.05233584f, 0.04097355f, 0.04112433f, 0.02806407f, -0.00703364f, 0.02167206f, -0.00856892f, 
    0.01760373f, 0.03996373f, 0.04124420f, -0.03753000f, 0.02676915f, -0.03099778f, -0.04388193f, 0.01081845f, 
    0.03563773f, -0.04570416f, -0.01679025f, 0.01369455f, -0.01287694f, -0.01641685f, 0.02301779f, -0.03328128f, 
    -0.01746609f, 0.01473268f, 0.01303750f, -0.01096614f, 0.03498291f, -0.00808547f, -0.05689977f, 0.03953725f, 
    -0.00315826f, 0.00035640f, 0.03940933f, -0.04620795f, 0.02249284f, -0.03657551f, -0.05279603f, -0.02682640f, 
    -0.02998439f, 0.03963479f, 0.03244063f, 0.02374214f, -0.00490266f, 0.01502253f, -0.01914026f, 0.01790225f, 
    -0.03411412f, -0.05415146f, -0.03535796f, -0.01357305f, 0.01272795f, -0.04264951f, -0.03398665f, -0.00053629f, 
    0.01108914f, 0.02608005f, 0.01778544f, -0.04657479f, 0.02988602f, -0.00023642f, 0.01565304f, 0.01439461f, 
    -0.01496723f, -0.04973990f, -0.00716345f, -0.05649409f, 0.02995396f, -0.01250244f, 0.02669552f, 0.03910699f, 
    -0.02597705f, -0.04747176f, -0.01552820f, 0.01064157f, -0.00353963f, 0.04144178f, -0.02795967f, 0.01207683f, 
    -0.01107414f, -0.01090811f, -0.05329600f, -0.04952143f, 0.00569397f, -0.03938890f, 0.01177646f, -0.00426683f, 
    0.02071471f, 0.04436452f, -0.02105289f, -0.04321095f, 0.02129707f, -0.02388047f, -0.03532308f, -0.04113280f, 
    -0.04604068f, -0.01557262f, -0.01088378f, -0.03846706f, -0.01862487f, 0.01786508f, 0.01494107f, 0.03047796f, 
    0.01189097f, 0.02771758f, -0.00822998f, -0.03310524f, 0.02997034f, -0.02216143f, 0.02404656f, -0.01904420f, 
    -0.00709344f, -0.00180229f, -0.02380509f, 0.00604380f, -0.01497141f, -0.01912938f, -0.05090650f, 0.01363450f, 
    -0.04431720f, -0.00816298f, -0.00269606f, -0.01710189f, -0.01464748f, -0.00639467f, -0.01811152f, 0.03649108f, 
    0.00284548f, 0.00213421f, -0.02520473f, 0.00799173f, 0.02377473f, 0.01338537f, 0.01613631f, 0.03363186f, 
    -0.01044448f, -0.04797547f, -0.05315042f, 0.02085499f, 0.01900272f, -0.05068834f, 0.04127635f, 0.02093467f, 
    0.00727280f, -0.05405536f, -0.00263276f, -0.04704043f, -0.00332066f, 0.00310095f, 0.04117741f, -0.00871221f, 
    0.00919088f, -0.01765995f, 0.02497860f, -0.01033793f, -0.01947094f, 0.00003072f, -0.01800524f, -0.02123788f, 
    -0.03193145f, 0.04322935f, 0.01493943f, -0.03161378f, -0.03252789f, 0.00784115f, -0.00468681f, 0.04058053f, 
    0.01039381f, -0.00519130f, 0.03884456f, -0.00138536f, 0.03227457f, 0.04065804f, -0.01081097f, 0.00739941f, 
    -0.01769415f, -0.02237608f, -0.05596969f, 0.04079832f, -0.03451225f, 0.00843838f, -0.03359129f, -0.05585990f, 
    0.01155362f, -0.01336467f, 0.02304283f, -0.05492550f, 0.02492125f, 0.03046243f, 0.01631531f, -0.02591735f, 
    -0.00712059f, -0.03037788f, 0.02134509f, -0.00233093f, -0.01268610f, -0.04854028f, -0.04780617f, 0.00039041f, 
    0.00744422f, -0.03349623f, 0.03015072f, -0.05476603f, -0.00630853f, 0.02274475f, -0.01335160f, -0.02784944f, 
    -0.02586365f, 0.01911350f, 0.01479722f, -0.00095455f, 0.00045436f, -0.05032011f, 0.01161610f, 0.00019428f, 
    0.04167463f, -0.01907897f, -0.02169498f, -0.04118781f, -0.01637565f, -0.04878837f, -0.02955610f, -0.02697141f, 
    -0.03886127f, -0.04195088f, -0.05589095f, -0.03479988f, 0.04259053f, -0.05033796f, -0.03692806f, -0.01046198f, 
    0.01296750f, -0.03051705f, -0.01729003f, -0.01791881f, -0.04290824f, -0.03981772f, -0.00983509f, -0.05113607f, 
    -0.02447958f, -0.04011168f, -0.04440321f, -0.04827172f, 0.02727667f, 0.01286776f, -0.00252649f, 0.02684406f, 
    -0.04638600f, 0.03255800f, 0.01315211f, 0.03122317f, -0.00830666f, 0.00544114f, -0.02026942f, 0.01312792f, 
    0.01477767f, -0.00610567f, 0.00511043f, -0.05590999f, -0.02099486f, 0.01527209f, 0.02196533f, -0.00050066f, 
    0.03940978f, 0.03798574f, -0.01599782f, 0.02576080f, 0.04431773f, 0.03564331f, 0.01842260f, -0.03674166f, 
    0.03095380f, 0.02181334f, 0.01248226f, 0.02168785f, -0.02139434f, -0.05701639f, 0.02231788f, 0.02997102f, 
    -0.02361505f, -0.00963089f, -0.01434290f, -0.05552860f, 0.00465714f, -0.05633461f, 0.00506239f, 0.01652019f, 
    -0.02656535f, -0.02255851f, -0.03748680f, -0.02337700f, 0.00440337f, 0.04275771f, -0.03310825f, 0.01630931f, 
    0.04254756f, -0.04372480f, 0.01440543f, -0.01838893f, 0.02843445f, 0.02000522f, 0.01219205f, 0.03232819f, 
    -0.00994996f, -0.04282577f, 0.02282990f, 0.03671041f, -0.03102805f, 0.02707027f, -0.05244195f, -0.05491634f, 
    0.01571562f, -0.05008624f, 0.03449985f, -0.02292495f, 0.02543160f, -0.03736422f, -0.00059076f, 0.00497832f, 
    0.00599532f, 0.04021278f, -0.01604038f, 0.03838917f, -0.04198982f, 0.03491044f, -0.02123378f, -0.03444096f, 
    0.02131702f, 0.03530280f, 0.03361904f, -0.00940007f, -0.04805246f, -0.01388918f, -0.02963496f, -0.05563494f, 
    0.34988841f, 0.17289652f, 0.00720115f, 0.18916541f, -0.06313500f, 0.01985350f, -0.11685550f, -0.02804804f, 
    0.08910338f, -0.02716148f, 0.00303908f, -0.04978048f, 0.03596774f, 0.22055139f, 0.09587802f, -0.03652634f, 
    0.16126004f, -0.03421697f, 0.00224139f, 0.11877866f, -0.05837768f, 0.11137575f, 0.06877374f, 0.06238677f, 
    0.36017773f, -0.09440128f, 0.14201221f, 0.12994333f, 0.02420574f, 0.03449977f, -0.02703501f, -0.02524056f, 
    0.07283537f, 0.03171554f, -0.04678712f, -0.01511206f, 0.19476575f, 0.10280965f, 0.10210473f, 0.21705492f, 
    -0.01257657f, 0.09637491f, -0.08162589f, 0.09909222f, 0.03237632f, 0.08301950f, -0.00518294f, -0.01070147f, 
    -0.00948088f, 0.17156921f, -0.06420596f, -0.14104840f, 0.06835783f, -0.02114839f, 0.07949723f, 0.08355242f, 
    0.00169229f, 0.08960576f, -0.06499144f, 0.12661113f, -0.04572266f, -0.39769444f, -0.02670825f, -0.07555301f, 
    0.07162385f, 0.08004800f, 0.00126312f, -0.02461306f, 0.06185198f, 0.11625905f, 0.09114344f, -0.02304366f, 
    0.26070863f, -0.13997433f, 0.00297323f, 0.25245506f, 0.02225942f, 0.00229838f, 0.02959436f, 0.18044052f, 
    -0.00852249f, -0.02563459f, -0.05323862f, 0.05289870f, 0.00406190f, -0.01330264f, -0.02255600f, -0.09614383f, 
    0.02785186f, 0.10217837f, 0.11735319f, -0.24879739f, 0.03100375f, 0.06767684f, -0.07464350f, -0.00839011f, 
    -0.19527565f, 0.14353822f, 0.04094152f, -0.18970884f, 0.08072831f, -0.02429887f, -0.04421509f, 0.21737160f, 
    0.01097840f, 0.09161571f, -0.12597367f, -0.10654904f, -0.04950649f, 0.22895215f, 0.15872519f, 0.27746269f, 
    -0.00109325f, -0.02874704f, -0.00627647f, 0.06594820f, -0.00016287f, 0.10300723f, -0.07568442f, -0.09215951f, 
    0.00684130f, -0.07680370f, -0.14589152f, -0.10300104f, 0.00489946f, 0.13594085f, -0.06135760f, -0.06621654f, 
    -0.00673820f, -0.00621402f, -0.03205397f, -0.03073300f, -0.19230308f, 0.03113970f, 0.00140700f, 0.22013943f, 
    0.04651231f, -0.03460079f, 0.06215277f, 0.00383607f, 0.08223545f, -0.08840740f, 0.12993765f, 0.00661326f, 
    0.01452636f, 0.08730714f, -0.07264386f, 0.20458868f, -0.01042095f, -0.03015779f, -0.00653205f, 0.02695302f, 
    -0.03712428f, 0.02672157f, 0.17113586f, -0.12395488f, -0.10391372f, 0.04550121f, -0.11987078f, -0.15745050f, 
    0.02559784f, 0.11543823f, 0.05088801f, 0.00667027f, -0.06787923f, -0.08401617f, 0.11352957f, -0.06986196f, 
    -0.06052845f, 0.05951079f, 0.06344385f, 0.03239266f, 0.05313102f, -0.09400596f, -0.00711979f, 0.01746716f, 
    -0.01438423f, 0.07010701f, -0.11516622f, 0.00730927f, -0.13972566f, 0.01972437f, -0.08840019f, -0.35881662f, 
    0.07863769f, 0.06908785f, 0.01896410f, 0.05542792f, 0.06333218f, 0.03969919f, -0.03033739f, -0.11008390f, 
    -0.25590321f, 0.12711914f, -0.00586227f, 0.04358327f, 0.07068617f, 0.02078548f, 0.13780347f, -0.05258233f, 
    -0.01199202f, -0.02849255f, 0.02165137f, 0.04691397f, -0.04783398f, -0.06407372f, 0.07731804f, 0.18232223f, 
    -0.04852586f, 0.05360793f, -0.00285149f, 0.05149107f, -0.01443985f, 0.03241300f, 0.07032729f, 0.06533079f, 
    0.06346204f, 0.16575986f, 0.10125854f, -0.12191239f, -0.00953067f, 0.08765144f, -0.14051515f, 0.05406782f, 
    0.05153568f, 0.07042451f, 0.00014310f, 0.05927660f, -0.19484158f, -0.20494315f, -0.06768507f, 0.06047846f, 
    0.03737972f, 0.04910407f, 0.02737088f, -0.00889477f, -0.05291425f, -0.14558738f, -0.05403520f, -0.04062515f, 
    -0.02911199f, -0.09598658f, -0.06204336f, -0.20425150f, -0.06195678f, -0.03824904f, -0.02811176f, 0.17159690f, 
    0.02445949f, 0.02149275f, -0.07311418f, -0.02520216f, -0.00143466f, 0.28062460f, 0.26297322f, 0.21139766f, 
    0.05418909f, 0.07041723f, 0.07871224f, 0.11123175f, 0.03005552f, 0.17859904f, 0.11992375f, 0.04678763f, 
    0.03915346f, 0.08366040f, 0.15144154f, -0.04478693f, 0.04960507f, -0.05903151f, 0.09473280f, -0.01320375f, 
    0.02424278f, 0.02545653f, 0.10025670f, -0.02651974f, -0.16453567f, 0.11947786f, 0.06170505f, -0.04565099f, 
    0.16732776f, 0.02279392f, 0.00946078f, 0.04048489f, -0.01189579f, -0.06331368f, -0.00892253f, 0.00757549f, 
    -0.27792934f, -0.00915128f, -0.12070945f, -0.27411672f, 0.16042231f, 0.05695894f, 0.02120061f, -0.03314060f, 
    0.12672213f, 0.01615540f, -0.03160556f, 0.06127459f, 0.10453337f, 0.11649426f, -0.03353467f, 0.26754913f, 
    0.01040767f, -0.00745056f, 0.00273263f, -0.10007347f, -0.04379815f, 0.00327103f, -0.03627674f, 0.10159682f, 
    0.05623328f, -0.13733147f, -0.05906307f, -0.09198081f, 0.05221516f, 0.12333970f, 0.16103312f, -0.06696291f, 
    0.05577508f, -0.02427637f, 0.11316217f, -0.01383676f, -0.13707431f, -0.19052604f, 0.11823123f, 0.22346574f, 
    -0.02478361f, -0.06372438f, 0.08832201f, 0.05503892f, 0.05617361f, -0.04978441f, -0.09537578f, 0.11654504f, 
    0.17884588f, 0.05596239f, 0.16311295f, 0.32589316f, 0.10228651f, 0.09459992f, -0.01608318f, -0.00327892f, 
    0.03262763f, 0.09520055f, 0.08172701f, 0.05275753f, -0.00040391f, -0.08517249f, -0.26871347f, -0.11536793f, 
    0.00720011f, 0.02156381f, 0.10884897f, -0.01233811f, -0.04513612f, -0.02749917f, 0.03650654f, 0.08526155f, 
    -0.21588945f, 0.22590159f, 0.18280452f, 0.21367389f, -0.02673616f, -0.12578717f, 0.06257334f, 0.11702154f, 
    -0.05794033f, 0.04185680f, 0.01150676f, 0.06602318f, 0.19184774f, 0.03398460f, 0.12217260f, -0.16961083f, 
    0.02851787f, -0.08075095f, 0.05579852f, 0.05819070f, -0.07021950f, 0.07985831f, 0.04321827f, 0.14370532f, 
    -0.04885091f, 0.03918080f, 0.00242088f, -0.02083036f, -0.02496301f, -0.00337881f, 0.00683665f, -0.02289423f, 
    0.00343207f, 0.02458581f, -0.03782585f, -0.05733266f, -0.04593455f, -0.03717743f, -0.04456454f, -0.00992234f, 
    0.01672105f, -0.05330545f, -0.05747736f, 0.03946036f, 0.01240770f, 0.00241199f, 0.01970711f, -0.01454834f, 
    0.03216945f, -0.05654097f, 0.03012029f, 0.01129774f, 0.01865494f, -0.05109925f, -0.00499551f, 0.03536585f, 
    -0.00803998f, -0.02847325f, 0.01569732f, -0.05740657f, 0.03760572f, 0.01631652f, -0.02737263f, -0.00744379f, 
    -0.02721714f, -0.04452091f, -0.05314710f, -0.03713743f, 0.02145902f, 0.01171714f, -0.04045185f, 0.02694915f, 
    -0.02404268f, 0.03615146f, 0.04388641f, 0.02994901f, 0.03263019f, -0.03222591f, 0.02835239f, -0.05671041f, 
    -0.04482554f, -0.02777148f, -0.04191556f, 0.03296815f, 0.03946357f, -0.02852233f, -0.04053853f, 0.03679482f, 
    0.00298806f, -0.03522149f, 0.03540563f, 0.01961004f, 0.00712728f, -0.05017902f, 0.04046627f, 0.01945701f, 
    -0.00159332f, -0.00278842f, -0.05458835f, -0.03856872f, 0.02509320f, 0.03586037f, -0.01713561f, 0.01693164f, 
    0.01919681f, 0.02860705f, -0.05379768f, -0.05491411f, 0.03238157f, 0.04385480f, 0.00580588f, 0.02634959f, 
    0.04058759f, 0.01147511f, 0.02844231f, -0.00273369f, -0.05820180f, -0.00254840f, -0.02492265f, -0.00090945f, 
    0.04121717f, 0.03535138f, 0.01892763f, -0.02365185f, 0.02080507f, -0.04887611f, 0.04181700f, -0.02940387f, 
    -0.04714197f, -0.02477893f, 0.00886182f, 0.02922499f, -0.02852087f, 0.01518402f, 0.02393819f, -0.01939999f, 
    -0.01298978f, -0.03383549f, -0.02737284f, -0.02921097f, 0.01991985f, -0.03870063f, 0.01412889f, 0.02773464f, 
    -0.05648305f, 0.03429907f, -0.00194837f, -0.02029173f, -0.05256564f, -0.03544633f, -0.01361323f, 0.02789314f, 
    -0.03451059f, 0.03341307f, -0.02898674f, -0.03731550f, 0.03143907f, -0.02526018f, 0.02030570f, -0.00455399f, 
    0.04292868f, 0.01977877f, -0.04732974f, 0.00100361f, -0.00266394f, 0.00479689f, 0.01720113f, 0.00384963f, 
    -0.04233289f, 0.03481564f, -0.00189916f, -0.00180134f, -0.05285658f, -0.03249623f, -0.04814234f, 0.03822095f, 
    -0.05116360f, -0.04294658f, 0.01899912f, 0.01179182f, -0.02281779f, 0.00378932f, -0.01330823f, -0.04227380f, 
    -0.00181359f, 0.03841272f, 0.01141262f, 0.00031904f, 0.02179032f, -0.05556170f, -0.04671135f, -0.04805455f, 
    0.00317281f, -0.04008994f, 0.02084413f, -0.03849896f, -0.00834025f, -0.02883721f, -0.04349998f, -0.04778960f, 
    0.01618885f, 0.01819659f, -0.03514182f, -0.04440217f, 0.00141914f, -0.01434298f, -0.02305136f, -0.04361277f, 
    -0.05435047f, -0.00274651f, -0.03692506f, -0.01908983f, -0.03691503f, -0.05502139f, 0.01358334f, -0.03344177f, 
    0.02438752f, -0.05021006f, 0.02921627f, 0.04204964f, -0.04673505f, -0.02427555f, -0.04889754f, -0.03029220f, 
    0.02691214f, 0.04437130f, -0.00296569f, 0.00444607f, 0.03971465f, -0.03346121f, -0.04449635f, -0.03991573f, 
    0.03955431f, -0.00577816f, -0.04530173f, -0.00696079f, 0.00036023f, 0.00983447f, 0.03077938f, 0.03188184f, 
    0.02785117f, -0.05152377f, 0.04005584f, -0.01883965f, 0.03136164f, 0.02043239f, -0.03518130f, -0.03214522f, 
    -0.04122820f, 0.02715451f, -0.00938378f, 0.02500788f, 0.01340302f, 0.00458488f, -0.02027166f, 0.01359740f, 
    -0.03658199f, 0.00552043f, -0.05654078f, -0.00359894f, -0.03700696f, -0.04114636f, -0.04564506f, -0.05280410f, 
    -0.03996478f, 0.02765408f, -0.01952982f, 0.03246381f, -0.00788026f, 0.00167236f, -0.03839123f, -0.03260948f, 
    -0.04111905f, -0.01570227f, -0.04379862f, 0.03569336f, -0.01306819f, -0.05403910f, -0.00965944f, -0.01641301f, 
    -0.04691694f, -0.03243491f, 0.01076867f, 0.03008400f, -0.03249615f, -0.00388795f, 0.01772540f, 0.00567204f, 
    -0.00630428f, -0.02379386f, 0.03726995f, -0.03732147f, 0.01696254f, -0.00357685f, -0.04557388f, -0.03178785f, 
    -0.00458233f, -0.00247378f, -0.03298863f, 0.02891069f, -0.03681701f, -0.00290714f, -0.05684464f, 0.02170629f, 
    0.00695840f, 0.00239529f, -0.05151312f, 0.00594979f, -0.00094605f, 0.00206229f, -0.05170691f, -0.00784982f, 
    -0.04239953f, 0.01174823f, 0.02927634f, -0.05052781f, 0.03086094f, -0.05633725f, -0.03303154f, 0.03714453f, 
    0.03930390f, -0.04689441f, -0.05501400f, 0.02907889f, -0.03424669f, -0.00194673f, 0.04000197f, 0.01882184f, 
    0.01463189f, 0.02255243f, 0.03500052f, -0.00222599f, -0.03396879f, 0.00006359f, -0.01415273f, 0.04294406f, 
    0.04323423f, 0.03563738f, 0.00463529f, 0.00853023f, 0.02885788f, 0.04080838f, 0.03606848f, -0.03407309f, 
    -0.01048684f, 0.00975980f, -0.05122350f, -0.03352112f, -0.05651262f, 0.00052099f, 0.03524767f, -0.02609336f, 
    -0.03142776f, -0.00193443f, -0.05803577f, -0.04991548f, -0.02470088f, -0.01769625f, 0.03131680f, 0.00739059f, 
    -0.05648174f, -0.03217418f, 0.00550203f, -0.05258298f, 0.00610084f, -0.05298217f, 0.01496121f, -0.02103225f, 
    -0.05208341f, 0.01604938f, -0.04812608f, 0.02711425f, -0.00909887f, -0.00730424f, -0.02761365f, -0.04885723f, 
    0.00245887f, 0.01335642f, 0.00741092f, 0.01619639f, -0.01228051f, -0.04010328f, 0.00709474f, 0.00864634f, 
    -0.05701748f, -0.00862493f, 0.01483103f, 0.03295289f, 0.01437812f, 0.02275099f, -0.04880202f, -0.05540135f, 
    -0.03987485f, 0.03648880f, 0.01145720f, -0.00546053f, 0.02248517f, -0.04886173f, 0.00068972f, -0.01618128f, 
    -0.01266918f, 0.00136109f, 0.02029353f, 0.00215037f, 0.00691799f, -0.04471163f, -0.01370252f, 0.03075394f, 
    0.03778147f, -0.03389440f, -0.05345818f, -0.01147381f, -0.02448789f, 0.00593008f, 0.03662126f, -0.04535779f, 
    -0.00424675f, 0.02304977f, 0.00939346f, 0.02645807f, 0.00725004f, -0.01990122f, -0.05410707f, -0.02172931f, 
    0.00595481f, -0.00852796f, -0.02396218f, -0.00053217f, -0.03211365f, 0.01310092f, -0.03484336f, 0.01473240f, 
    0.03122910f, -0.03793768f, -0.01824664f, 0.01845563f, 0.01932128f, 0.01391051f, -0.04437082f, 0.00366892f, 
    -0.02703987f, -0.01628494f, -0.01245091f, -0.01631526f, -0.04649352f, -0.03071673f, -0.03994660f, -0.00245405f, 
    0.00118116f, -0.05541674f, 0.01430459f, 0.00730549f, -0.02301970f, -0.02244538f, -0.04359205f, -0.02371412f, 
    -0.02406122f, 0.02881305f, -0.01230802f, 0.01999972f, -0.05242209f, 0.03142799f, 0.01994188f, 0.03000620f, 
    -0.01821785f, 0.03485941f, -0.03728814f, -0.05562716f, 0.00028343f, -0.01686226f, 0.00606479f, 0.00173023f, 
    0.00513214f, -0.01332579f, -0.04553976f, -0.00886636f, -0.04504908f, 0.00086922f, -0.03097063f, -0.04665388f, 
    -0.03601214f, -0.02958700f, -0.04016297f, -0.04015489f, -0.03012443f, 0.00115151f, -0.05392852f, 0.05022016f, 
    0.02088774f, 0.01118616f, -0.01217261f, -0.04744059f, -0.00194224f, 0.03022194f, -0.00649577f, -0.02344154f, 
    -0.05292230f, -0.00866333f, 0.01444728f, -0.01912477f, 0.02486921f, -0.04407133f, 0.03706347f, -0.00810371f, 
    -0.02636955f, -0.04094479f, -0.01470787f, -0.00237837f, -0.00988544f, 0.01273274f, -0.03518413f, 0.01632551f, 
    -0.03631696f, -0.02708723f, 0.01933408f, -0.03196838f, -0.03675681f, -0.05452258f, 0.00780456f, -0.01822187f, 
    -0.02769022f, -0.04521399f, -0.01281698f, -0.00582915f, 0.02788189f, -0.04012356f, -0.04658615f, -0.03085141f, 
    -0.01099980f, -0.02665612f, 0.04058959f, 0.00807474f, 0.04276292f, -0.01821545f, 0.03124542f, 0.01993952f, 
    -0.01530263f, 0.00107301f, -0.00525258f, -0.03383771f, -0.00509951f, 0.03206763f, 0.00528513f, 0.03945933f, 
    -0.05489636f, 0.00749464f, 0.02099266f, -0.04939017f, -0.01662069f, -0.03980626f, -0.04809776f, -0.01900824f, 
    -0.05623473f, 0.02103551f, 0.03756384f, -0.05533728f, -0.02213635f, 0.04205790f, 0.01164713f, 0.01797119f, 
    -0.02854455f, 0.04139543f, 0.03785779f, -0.04393587f, -0.01086436f, 0.03602166f, 0.02560785f, -0.02304200f, 
    -0.05890070f, 0.00999640f, -0.04097195f, 0.00080547f, -0.01614355f, -0.01208262f, -0.04091946f, 0.01939546f, 
    0.01075017f, -0.01553854f, -0.01435889f, 0.01199607f, 0.02425073f, -0.03125314f, -0.04238148f, -0.04478841f, 
    0.02135904f, -0.05348067f, 0.03144822f, -0.00081436f, 0.00650836f, 0.03284055f, 0.04011357f, -0.00773594f, 
    0.03812600f, 0.01399358f, -0.05769192f, -0.04682322f, 0.01143985f, -0.00816140f, 0.00271697f, 0.04557869f, 
    -0.01234245f, 0.00929913f, -0.01920435f, 0.02877484f, -0.04477027f, 0.03948813f, 0.01553024f, -0.05478546f, 
    -0.02947683f, 0.02983339f, -0.04513751f, 0.00855666f, -0.00666899f, -0.03584700f, -0.00597096f, -0.04484217f, 
    0.03725327f, 0.02271626f, -0.02319843f, 0.02062640f, 0.00088988f, -0.00379257f, -0.00764062f, -0.01026379f, 
    -0.01197805f, -0.03199676f, -0.03009217f, 0.00165506f, -0.05247296f, 0.01757708f, -0.03122404f, -0.05287844f, 
    -0.04476170f, 0.01872742f, 0.04404793f, -0.00436356f, 0.02012385f, -0.03921690f, 0.03457116f, 0.01344975f, 
    0.04120309f, -0.03585361f, -0.03497215f, 0.03205360f, -0.02871241f, 0.03377280f, 0.04260229f, 0.03302248f, 
    -0.05504723f, -0.05761887f, 0.01795227f, 0.02429475f, -0.03329192f, -0.05016571f, 0.01349800f, -0.00784776f, 
    0.03843930f, -0.00575311f, 0.03536225f, -0.04597561f, -0.03483377f, -0.02791547f, -0.00836370f, 0.00858450f, 
    -0.03586289f, -0.00553699f, -0.03805801f, 0.01576074f, -0.04747561f, -0.03460087f, -0.05014361f, -0.01890494f, 
    0.01447937f, -0.00890417f, -0.02095960f, 0.02805185f, 0.03798339f, 0.04121081f, 0.04215457f, 0.02081984f, 
    -0.05291900f, -0.01860740f, -0.00628342f, 0.01449578f, -0.04361648f, 0.01832545f, -0.02084343f, -0.00771238f, 
    0.01147982f, -0.03555121f, -0.00964031f, -0.03487583f, 0.00525369f, -0.00070288f, -0.00693070f, -0.05319770f, 
    0.02374048f, 0.00700129f, 0.00774548f, 0.01562056f, -0.01098380f, -0.04890843f, 0.03852668f, -0.01997527f, 
    -0.02763459f, -0.03850013f, -0.02948479f, 0.03420206f, 0.00099100f, 0.04015520f, 0.04058474f, -0.03941011f, 
    -0.03429523f, 0.00393314f, -0.04376869f, -0.05152741f, -0.03497806f, 0.01982868f, 0.04061317f, -0.00614823f, 
    -0.05706064f, -0.05640970f, -0.02661877f, 0.04216834f, 0.00501855f, 0.02654119f, 0.01955804f, -0.01717708f, 
    0.00317794f, -0.02112707f, 0.02357531f, -0.04659239f, 0.02590116f, 0.03935126f, 0.00219638f, 0.00179591f, 
    -0.00837050f, 0.03888476f, 0.03771099f, -0.05407824f, 0.02448079f, 0.01251162f, -0.04825260f, -0.00695528f, 
    -0.01555510f, 0.04183249f, 0.02001036f, -0.00596534f, -0.00488016f, 0.00339826f, 0.01731739f, -0.04207417f, 
    -0.01613491f, -0.03404574f, 0.01006710f, -0.00980278f, 0.03856973f, 0.03228513f, 0.01471089f, -0.01002956f, 
    0.01538597f, -0.04244973f, -0.00919249f, 0.00416727f, -0.00528358f, 0.04528223f, 0.01883947f, -0.03444776f, 
    -0.04579908f, -0.04194992f, 0.00138360f, 0.00262304f, -0.02719609f, 0.02489897f, -0.01255348f, -0.01071631f, 
    0.03092691f, 0.00099367f, -0.03151184f, 0.03043661f, -0.04451846f, 0.00239196f, -0.00426790f, 0.03483767f, 
    -0.01140155f, -0.05639995f, 0.01709413f, 0.03519299f, -0.01769867f, -0.05458526f, -0.04826959f, -0.00749033f, 
    0.04208924f, 0.00234735f, -0.02603475f, -0.03935384f, 0.01400216f, 0.02972603f, -0.02103853f, -0.05162928f, 
    0.03000155f, -0.04093203f, -0.00159960f, -0.01340042f, 0.02804690f, -0.00308523f, 0.01752212f, 0.03282133f, 
    0.03251635f, -0.04460121f, -0.04107963f, 0.01367509f, -0.00585111f, 0.01134201f, -0.02106916f, 0.00499428f, 
    0.01271637f, -0.05285624f, -0.02838082f, 0.00891912f, 0.00142854f, 0.03191779f, 0.03915002f, -0.02141339f, 
    0.00676369f, -0.01346892f, 0.01451250f, 0.02392241f, -0.03027505f, -0.02388024f, -0.00511304f, 0.03472766f, 
    0.03021216f, -0.00008068f, 0.03890989f, -0.01203810f, -0.03219901f, -0.00957795f, 0.01429110f, -0.04019577f, 
    0.02445909f, -0.02189575f, -0.02106951f, -0.01190504f, 0.01844429f, 0.04406684f, 0.04575796f, -0.00543323f, 
    0.03820213f, -0.05029038f, 0.02606614f, 0.02702878f, 0.01283947f, 0.02341693f, 0.02419632f, -0.04887224f, 
    -0.02929156f, 0.01269039f, 0.01053904f, -0.02348027f, -0.05222655f, 0.00704630f, -0.02019245f, -0.00869332f, 
    -0.01568338f, 0.01635878f, 0.01678000f, -0.04071854f, -0.05445262f, 0.00476379f, 0.02281816f, -0.03568861f, 
    -0.01509282f, 0.03621112f, 0.02418347f, -0.00699649f, -0.00888352f, 0.03959531f, -0.02022956f, 0.01958913f, 
    -0.02717532f, 0.02755190f, -0.01261207f, 0.03760124f, -0.01131347f, -0.03457898f, 0.00022578f, -0.00965009f, 
    -0.00788627f, -0.01728173f, -0.01444331f, 0.02830465f, -0.04768489f, 0.01614472f, -0.02037284f, -0.04292155f, 
    -0.03139042f, -0.02148993f, -0.04474993f, -0.01247286f, -0.02330068f, 0.00745166f, 0.03433799f, -0.04936847f, 
    0.03332589f, 0.00996071f, 0.02422499f, -0.03810771f, 0.01770905f, 0.00213783f, -0.00444005f, -0.01929382f, 
    -0.02173078f, -0.02016763f, 0.03727380f, -0.01024740f, -0.03625651f, 0.01063077f, 0.04236515f, -0.00655608f, 
    -0.00820883f, -0.00863526f, -0.02753854f, -0.05299385f, -0.03114236f, -0.04841968f, -0.04175764f, 0.01407739f, 
    -0.03445425f, 0.02278880f, 0.04226869f, 0.01650413f, 0.03493913f, -0.02242389f, -0.01470593f, -0.01941661f, 
    -0.02645657f, -0.02931952f, -0.02568167f, 0.02436570f, -0.05193028f, -0.04905425f, -0.03400935f, -0.02722733f, 
    -0.03452585f, -0.00331606f, -0.02064758f, -0.03476791f, -0.02989310f, 0.02258758f, -0.02094249f, 0.03836376f, 
    0.00376280f, -0.02712070f, -0.05422881f, -0.00516925f, -0.01252237f, -0.03237153f, 0.03067133f, -0.02196427f, 
    0.00915941f, -0.04155843f, 0.04458840f, 0.04314260f, -0.01397852f, 0.02169776f, -0.02773033f, -0.01513229f, 
    0.02319060f, 0.00120794f, -0.03647331f, -0.03698116f, -0.01762392f, 0.00475147f, 0.03108904f, 0.02256458f, 
    0.02545298f, 0.03330945f, -0.02801975f, -0.02149349f, 0.00658855f, -0.04169204f, 0.02191786f, -0.04353938f, 
    0.02579835f, 0.00126194f, -0.00626247f, -0.04392118f, 0.04291118f, -0.03155290f, -0.05385457f, 0.00117685f, 
    0.00453967f, -0.01177819f, 0.02447566f, 0.00598558f, -0.01275085f, -0.04973286f, -0.04433156f, 0.04380272f, 
    -0.03608919f, -0.05178174f, 0.03489533f, -0.05231819f, 0.03859357f, 0.01618535f, 0.02266681f, -0.05604002f, 
    -0.04636312f, 0.02575248f, -0.04571025f, 0.01670282f, -0.03493775f, -0.02427221f, -0.01235890f, 0.01300078f, 
    -0.00520562f, 0.02732953f, -0.04969008f, -0.00312358f, 0.03712835f, -0.04721468f, -0.00352270f, -0.01363887f, 
    -0.01897768f, -0.01052077f, -0.00354506f, 0.01901006f, -0.05189318f, -0.04426397f, 0.00637198f, 0.00851832f, 
    0.01791334f, -0.02904666f, 0.00547167f, 0.04510740f, -0.04289731f, -0.03725714f, 0.04536931f, -0.03174750f, 
    -0.05529625f, -0.04053019f, 0.01512542f, -0.04290086f, -0.01380262f, 0.03901819f, -0.01603981f, 0.02236424f, 
    -0.04406923f, -0.03317672f, -0.02706814f, -0.04717237f, -0.01621997f, 0.04235994f, 0.02745235f, -0.01844633f, 
    -0.05301531f, -0.02031675f, -0.00470171f, -0.03907694f, 0.00129506f, 0.00957590f, -0.03310787f, 0.04233653f, 
    0.00255577f, -0.02133679f, 0.03216143f, -0.02344730f, -0.00710622f, 0.02111403f, -0.00421287f, -0.01060454f, 
    -0.01531525f, 0.02529063f, -0.05551016f, -0.04007053f, -0.03694068f, -0.04992601f, 0.00840777f, -0.03400130f, 
    -0.03709831f, -0.01797897f, 0.00639363f, 0.02008058f, -0.01107707f, 0.01211056f, 0.02111312f, -0.00202648f, 
    -0.04162162f, -0.03596940f, 0.04084858f, -0.00411912f, -0.03544711f, -0.04045733f, 0.04223887f, 0.02261155f, 
    0.02721046f, -0.02240496f, -0.02798190f, -0.04930559f, -0.03379949f, -0.03790570f, 0.00648162f, -0.01166790f, 
    0.01836194f, 0.03305892f, -0.04704268f, -0.00789575f, 0.00781092f, 0.02524391f, 0.02680333f, -0.03604361f, 
    -0.03908864f, -0.00248345f, 0.02434142f, -0.05113266f, -0.03811558f, -0.02139477f, -0.00164240f, 0.00075319f, 
    -0.00292327f, -0.01509086f, 0.01691760f, -0.05297883f, -0.04478556f, 0.00224302f, -0.02603328f, -0.01766959f, 
    0.01127958f, -0.00445879f, -0.03291368f, 0.00014411f, -0.05049778f, -0.01780391f, 0.03458370f, -0.01911671f, 
    -0.02368900f, -0.02710562f, -0.01645240f, 0.00397551f, -0.00378963f, 0.03893526f, -0.01086983f, -0.01525509f, 
    0.01417595f, 0.03951281f, -0.05453921f, -0.03236908f, -0.00824141f, -0.02102545f, -0.01106949f, -0.05033979f, 
    -0.00197721f, 0.01417255f, -0.04037996f, -0.05337658f, -0.03357396f, -0.01058682f, 0.03819083f, -0.02232534f, 
    -0.03178373f, 0.03339234f, 0.01808871f, -0.01265209f, 0.00116647f, -0.01123952f, 0.01687979f, -0.01633232f, 
    0.00275931f, 0.01262485f, -0.05546845f, 0.01161913f, 0.04572003f, 0.03292969f, -0.00955282f, -0.02940860f, 
    0.04064882f, 0.02729741f, -0.06399823f, 0.14991997f, -0.01242585f, -0.02173304f, -0.15913928f, 0.00226824f, 
    -0.01178391f, -0.07245342f, -0.08964671f, -0.09719025f, -0.08477902f, 0.20531653f, -0.03902412f, 0.14834134f, 
    0.05121681f, -0.03939161f, -0.06987032f, 0.08889641f, 0.06067332f, 0.09359409f, -0.03899031f, 0.14373924f, 
    0.06870066f, -0.11553286f, 0.08238675f, 0.05101437f, 0.01499449f, 0.01493266f, -0.01887920f, -0.22305198f, 
    -0.05335717f, 0.14105552f, 0.09592261f, -0.05382046f, 0.11315511f, -0.18144819f, -0.04094708f, -0.01130741f, 
    -0.13967164f, -0.02502618f, 0.04377497f, 0.16218311f, -0.18766083f, 0.06412067f, 0.01285394f, 0.12564132f, 
    0.40124568f, -0.05443001f, -0.01592076f, 0.00787819f, -0.00666501f, 0.13554738f, -0.00048011f, -0.05277591f, 
    -0.02496712f, 0.18994164f, 0.08582634f, 0.09859660f, 0.12071265f, -0.15921809f, 0.25205979f, 0.07638983f, 
    -0.02462374f, 0.11318150f, -0.02550895f, -0.00991376f, 0.04159852f, 0.07115988f, -0.07706948f, -0.04074061f, 
    0.20583151f, 0.08080823f, 0.09467430f, -0.16983169f, -0.18311232f, -0.00068723f, -0.02062594f, 0.08027948f, 
    -0.06219449f, 0.06400721f, 0.04217389f, 0.16899675f, 0.13866073f, -0.07906627f, -0.22113399f, -0.10194422f, 
    -0.11018445f, 0.01455781f, 0.13561983f, -0.04174212f, 0.10287695f, -0.14130181f, -0.03742357f, -0.07547072f, 
    -0.10131620f, 0.04792231f, -0.16279580f, 0.14953579f, 0.09405252f, 0.07452633f, 0.08253495f, 0.07215799f, 
    -0.00880274f, 0.08504838f, -0.07256707f, 0.12537770f, 0.00529605f, -0.08468789f, 0.12221916f, 0.08301837f, 
    -0.04769686f, -0.18178783f, 0.05430347f, 0.16627905f, -0.01708029f, -0.01939937f, 0.07352147f, -0.09464387f, 
    0.05977314f, 0.03940885f, -0.02017412f, -0.11110777f, -0.01406849f, -0.01574412f, -0.22393295f, -0.04451293f, 
    0.03568001f, -0.00857374f, -0.01056025f, 0.05553754f, -0.03581452f, -0.00844564f, 0.19201593f, -0.07283890f, 
    -0.00768212f, -0.08363065f, 0.00965387f, 0.05250999f, 0.05200857f, 0.12350671f, 0.01139950f, 0.29486194f, 
    -0.06676803f, 0.20905086f, -0.18409663f, 0.01838931f, 0.01093311f, 0.02108604f, 0.14647265f, 0.07835668f, 
    -0.04938716f, 0.08383831f, 0.03670352f, 0.14456606f, -0.00609490f, 0.21838941f, -0.03313538f, -0.03651345f, 
    0.01849458f, 0.17426476f, 0.04192547f, -0.26819897f, -0.00512861f, 0.03255008f, 0.20124115f, 0.12678391f, 
    0.15458155f, -0.00839148f, -0.10738391f, 0.12426572f, -0.02068425f, 0.01820368f, 0.03406230f, -0.09875178f, 
    -0.12161657f, -0.06257012f, -0.00325847f, -0.24362563f, -0.20274439f, 0.05877240f, -0.13773037f, -0.09354679f, 
    0.10688260f, 0.13567644f, 0.03167761f, 0.01759496f, 0.17033514f, 0.07499174f, 0.26247233f, -0.06390193f, 
    -0.02101098f, -0.11452720f, -0.07289794f, 0.13099635f, 0.07141824f, 0.12393817f, 0.11608700f, -0.00582231f, 
    -0.03916604f, -0.17907669f, -0.00242926f, 0.19542809f, 0.19412011f, -0.19769947f, 0.09060715f, 0.00699177f, 
    -0.08123609f, -0.04747310f, 0.05596405f, 0.08372646f, 0.08216344f, 0.06178001f, -0.04837646f, 0.14886865f, 
    -0.07866076f, -0.14937760f, 0.16973874f, -0.10471723f, -0.00616619f, -0.00173080f, -0.04452843f, -0.00815016f, 
    -0.05299064f, 0.20273985f, -0.27638957f, -0.12254482f, -0.13946411f, -0.03494235f, 0.00821608f, -0.11082654f, 
    -0.04003629f, -0.05424923f, -0.02055708f, -0.01469392f, 0.00517200f, -0.22876191f, -0.15004946f, -0.10925268f, 
    0.03820571f, -0.13306777f, -0.03953806f, -0.07864313f, 0.01295963f, 0.03099219f, 0.06421122f, 0.05596137f, 
    -0.04689745f, 0.00761415f, -0.08029254f, -0.04926653f, 0.07384045f, -0.10174131f, 0.01567450f, 0.03724546f, 
    -0.02071105f, 0.04252913f, 0.13333096f, 0.20006631f, -0.07562532f, 0.06824213f, 0.03992889f, -0.18287505f, 
    0.02659584f, -0.05124309f, -0.03186452f, 0.18945324f, 0.06339956f, -0.00665920f, 0.09268415f, -0.02268051f, 
    0.04094179f, -0.11698981f, 0.19905828f, 0.06237357f, 0.16565314f, 0.07935428f, -0.09230977f, -0.09457820f, 
    0.19477011f, -0.19318864f, -0.19688648f, 0.05339606f, -0.12009615f, -0.07469882f, -0.09905060f, -0.34379762f, 
    -0.04997131f, 0.03006634f, -0.08997961f, -0.02977038f, 0.01241806f, 0.05051577f, 0.02677167f, -0.03299048f, 
    -0.06098516f, -0.00651615f, 0.02429815f, 0.02049354f, -0.00627071f, 0.02943901f, 0.06661050f, -0.02373096f, 
    0.04589957f, -0.07447655f, 0.17087467f, -0.12022614f, -0.00452732f, 0.13221179f, -0.06627792f, 0.00203536f, 
    0.18647859f, -0.00329519f, -0.04094515f, 0.06801791f, -0.03028535f, 0.10586005f, 0.03768429f, -0.08335774f, 
    0.14687429f, -0.16926755f, 0.08954565f, -0.01810549f, 0.13126852f, -0.05109148f, 0.02499024f, 0.04855533f, 
    -0.08085596f, 0.00885679f, 0.02689308f, -0.00108871f, 0.04847255f, -0.05243645f, -0.27684498f, -0.08457465f, 
    0.09509467f, -0.00517459f, 0.10987321f, -0.13554071f, 0.00235052f, -0.06316799f, -0.10891147f, 0.04132666f, 
    -0.13887045f, -0.07139983f, 0.02040586f, 0.09496936f, 0.03832531f, 0.02691406f, -0.13012500f, 0.03006821f, 
    0.03091248f, 0.00431111f, 0.08604691f, -0.06419501f, -0.07999450f, 0.12835845f, -0.06031529f, -0.01195588f, 
    0.44102362f, 0.00765104f, 0.01005517f, 0.01156370f, -0.09255008f, 0.06787625f, 0.03505046f, 0.13702829f, 
    -0.12811612f, 0.02886295f, -0.16626832f, 0.09501057f, 0.23035336f, 0.02955973f, -0.07858774f, -0.14912418f, 
    0.09561114f, -0.03977301f, 0.08675165f, -0.05138719f, 0.02621107f, 0.19385707f, 0.13004227f, 0.14385381f, 
    0.01633028f, -0.05066318f, -0.04255167f, 0.02237224f, -0.01649762f, -0.05764064f, -0.04301933f, -0.04201213f, 
    0.02308982f, -0.04739657f, -0.04449408f, -0.04434219f, -0.04045972f, -0.00358683f, -0.02883693f, -0.02948042f, 
    0.03406906f, -0.00044597f, -0.02782771f, -0.03387448f, -0.04477520f, 0.04160785f, 0.00974808f, 0.02865537f, 
    0.03672403f, 0.03623486f, 0.00262275f, -0.04132821f, 0.00122550f, -0.02484047f, -0.04254132f, -0.03181766f, 
    0.00916739f, 0.04432745f, -0.05262610f, -0.02183083f, -0.00258529f, -0.01099936f, -0.02411980f, -0.01317012f, 
    -0.01826792f, -0.04008076f, 0.00091406f, -0.02674998f, 0.00135246f, 0.00006991f, -0.02079707f, -0.00067663f, 
    0.01625233f, 0.04417858f, -0.02153798f, -0.00437551f, -0.03063634f, 0.00581056f, -0.00562926f, -0.01936956f, 
    -0.04042137f, -0.02634574f, 0.02418496f, -0.04613238f, -0.02212794f, 0.01919511f, -0.00400839f, -0.04128470f, 
    0.03913156f, 0.03101898f, -0.02883161f, 0.00264100f, 0.01411424f, 0.00884937f, -0.05060093f, -0.01502688f, 
    0.02956984f, -0.00148919f, -0.01993822f, -0.01226959f, 0.00590812f, -0.04150259f, -0.01229259f, 0.00411397f, 
    -0.03748279f, -0.01040220f, -0.02867745f, 0.00856402f, 0.00368042f, -0.01910401f, -0.01074163f, -0.00964606f, 
    0.02203212f, -0.00173207f, 0.02591262f, 0.03527435f, -0.03055198f, 0.02450110f, 0.00593381f, -0.05588539f, 
    0.02044126f, -0.03171629f, 0.00978553f, 0.00069669f, -0.03103135f, -0.00663918f, 0.02253655f, -0.01526090f, 
    0.03116268f, -0.03889775f, 0.01468290f, -0.02048021f, -0.05580008f, 0.02691991f, 0.03499928f, 0.03141521f, 
    0.04354591f, -0.01919296f, 0.03217352f, 0.01772651f, -0.04351368f, -0.01688490f, -0.04890186f, 0.01691261f, 
    0.01077280f, 0.01598990f, -0.03857849f, 0.01780551f, 0.03124801f, 0.05321751f, 0.01550390f, -0.02855343f, 
    -0.04507542f, -0.03204702f, 0.00157611f, -0.02066630f, -0.02142863f, -0.05471044f, -0.05085469f, -0.04653831f, 
    0.00184555f, 0.02419826f, -0.00700397f, -0.01302819f, -0.03334690f, -0.03753984f, 0.02494046f, 0.00562681f, 
    0.04312310f, 0.02866033f, 0.01908015f, 0.00706074f, -0.03025248f, -0.01152122f, -0.02213639f, -0.04157900f, 
    -0.04457779f, 0.01970105f, 0.02932293f, -0.02765386f, 0.03317745f, -0.01350084f, -0.04186997f, 0.02801331f, 
    0.04365474f, 0.04151258f, 0.02646683f, -0.01012973f, -0.02752434f, 0.01533521f, 0.00669350f, -0.03940685f, 
    0.01458475f, 0.03763230f, -0.02900784f, -0.01602983f, 0.04140021f, 0.00619362f, -0.02760799f, -0.01298318f, 
    -0.02101458f, -0.01452190f, -0.05612343f, 0.04347631f, -0.03504955f, 0.01015622f, -0.03391345f, -0.03067289f, 
    0.02170383f, 0.03662878f, 0.01437520f, -0.03389297f, -0.01993959f, -0.00330738f, -0.05890319f, -0.02897928f, 
    0.00098163f, 0.05010526f, -0.04571298f, -0.00931002f, -0.01232860f, 0.00886744f, 0.02012844f, 0.00051758f, 
    0.01898922f, -0.00251045f, 0.03701501f, -0.04159096f, -0.01275619f, 0.04599665f, 0.04344289f, -0.04226829f, 
    0.02505847f, -0.01053190f, -0.04519842f, -0.03481164f, -0.00024494f, -0.03682292f, -0.01007630f, -0.05503339f, 
    -0.02467589f, 0.01071644f, 0.01290586f, 0.01125269f, -0.05001182f, -0.00637913f, -0.01745797f, 0.01292057f, 
    0.01554435f, 0.00939742f, -0.05463030f, 0.05313996f, 0.02799026f, 0.04721756f, -0.02477771f, 0.01795261f, 
    0.03660567f, -0.03148368f, 0.01860614f, -0.01320416f, -0.04111606f, -0.01716208f, 0.02974817f, 0.01747208f, 
    -0.02586797f, -0.02172443f, -0.02200196f, -0.00348330f, -0.02939102f, 0.02403165f, 0.02117511f, -0.03868380f, 
    0.02468539f, 0.01081729f, 0.05127704f, 0.00490504f, -0.05050897f, 0.01872961f, -0.02892906f, 0.01289291f, 
    0.03128343f, -0.04067441f, -0.03054454f, -0.00799857f, -0.00224461f, 0.00465650f, -0.01691887f, -0.04866176f, 
    0.04441894f, 0.00749339f, -0.05222319f, 0.03776555f, -0.02038258f, -0.04320359f, 0.04438905f, -0.05365711f, 
    -0.00530994f, 0.00230192f, 0.04804714f, 0.01517667f, -0.04115144f, -0.04769738f, -0.00144704f, -0.04200953f, 
    -0.02091241f, 0.03385016f, -0.02953854f, -0.00073799f, -0.03190811f, -0.00189269f, -0.02031208f, -0.03456672f, 
    -0.03924319f, -0.02794646f, -0.04367501f, -0.02585739f, -0.01594186f, -0.02015804f, 0.00263003f, -0.00814721f, 
    0.02586888f, -0.04976106f, 0.01086186f, 0.01553514f, 0.00397932f, -0.00167120f, -0.02099549f, -0.00810399f, 
    -0.02310873f, -0.03993263f, 0.01432912f, -0.04484205f, -0.03526466f, 0.03920431f, -0.01325873f, 0.03239878f, 
    -0.03949694f, -0.03937188f, 0.02390114f, 0.03024357f, -0.01407095f, -0.03934276f, 0.00649304f, -0.00261710f, 
    0.03512176f, -0.03267352f, 0.04819929f, -0.03267194f, -0.01815146f, 0.03293691f, -0.01101717f, -0.01681077f, 
    0.04363182f, -0.03466671f, -0.01540741f, -0.00930220f, 0.03135250f, 0.03337893f, 0.03499179f, 0.01115774f, 
    -0.03556552f, -0.00378171f, 0.03621173f, -0.05512194f, 0.03653581f, -0.04244460f, -0.02783224f, 0.03087811f, 
    0.00361176f, -0.01591043f, -0.01630513f, -0.01610366f, 0.02030810f, -0.00448136f, 0.00801098f, -0.01519662f, 
    -0.01292336f, -0.00514735f, -0.02548767f, -0.01855673f, 0.01841836f, 0.03603946f, 0.00825186f, -0.00455025f, 
    -0.03421132f, 0.00419589f, 0.03921942f, -0.02872279f, 0.00299486f, 0.04212210f, -0.03852475f, -0.02013957f, 
    0.04290574f, 0.02263078f, -0.04651751f, 0.01680230f, 0.01401385f, 0.01424882f, 0.03954374f, -0.00957596f, 
    0.00032578f, 0.05034915f, -0.01414085f, -0.02409990f, 0.02179154f, 0.03708964f, 0.03284119f, -0.03004898f, 
    -0.24270236f, -0.09220967f, -0.06165278f, -0.07628088f, 0.03544051f, 0.02451528f, 0.02399605f, 0.18240780f, 
    0.05485067f, -0.07436399f, -0.00516022f, 0.06421160f, -0.05284745f, -0.24068801f, -0.22796021f, -0.04843634f, 
    0.00064087f, 0.09512782f, 0.10586728f, -0.08208679f, 0.10776060f, 0.01719262f, -0.02258001f, 0.12910105f, 
    0.02297617f, -0.00766089f, -0.20867008f, 0.04719762f, -0.03159455f, -0.04073340f, 0.12112760f, -0.04619647f, 
    0.13925149f, 0.08131055f, -0.10191309f, -0.04408460f, -0.06269722f, -0.06231573f, 0.00895681f, 0.08476931f, 
    -0.13221925f, -0.09411348f, 0.08669478f, 0.05778381f, 0.01368696f, 0.13008273f, 0.18369709f, 0.03100419f, 
    0.21341692f, -0.11693984f, 0.06533264f, -0.01422516f, 0.04351904f, -0.11005636f, -0.02725085f, 0.13915136f, 
    -0.11545893f, 0.07452775f, 0.07369969f, 0.07929590f, 0.58271539f, 0.12489483f, 0.16314720f, 0.03175732f, 
    -0.20596190f, -0.08335336f, -0.01590646f, 0.02203363f, -0.03714259f, 0.00992277f, 0.08562215f, -0.05377058f, 
    0.18793114f, 0.06745690f, 0.04264330f, 0.04107957f, -0.15759258f, 0.01041338f, -0.00131106f, -0.13074134f, 
    0.05033644f, 0.04488925f, 0.06237067f, 0.13922627f, -0.12298691f, 0.18592450f, -0.00181096f, 0.14502744f, 
    -0.07379245f, 0.00407942f, 0.06683450f, 0.05563830f, 0.16726038f, 0.05753847f, 0.15979247f, 0.08840428f, 
    -0.26702103f, -0.09154615f, -0.00390102f, 0.16345277f, 0.15465082f, 0.13245986f, 0.04335241f, -0.02967244f, 
    -0.08502802f, -0.09434612f, 0.00682545f, 0.09806862f, -0.18414667f, -0.12358544f, -0.08002404f, -0.11190249f, 
    0.01264628f, -0.02521786f, 0.09486734f, -0.02611808f, -0.18484737f, -0.00414917f, 0.13836189f, -0.05292136f, 
    0.65144283f, 0.22395496f, 0.28425917f, 0.36143300f, -0.19402434f, -0.09976812f, 0.06300293f, 0.06580877f, 
    0.05894538f, 0.01092892f, -0.12181576f, -0.09812477f, -0.12113957f, -0.37510750f, 0.05596580f, -0.13416778f, 
    0.03503631f, 0.05340252f, -0.03346954f, 0.06245051f, 0.00369950f, 0.14017056f, -0.03823584f, 0.18501629f, 
    -0.15382434f, -0.27129844f, -0.00419997f, -0.22681320f, 0.25399017f, -0.04553895f, 0.16782382f, -0.00499962f, 
    -0.04805622f, 0.12893255f, -0.01528409f, 0.22042559f, 0.34107757f, 0.01135774f, 0.19651236f, 0.15315299f, 
    0.03431116f, 0.02100120f, -0.04011119f, 0.04407520f, -0.08550852f, -0.05561229f, -0.09463379f, 0.18882269f, 
    -0.10913097f, 0.20686835f, -0.16857699f, 0.14053656f, 0.02999931f, 0.05232328f, 0.02444430f, 0.06618877f, 
    -0.01672635f, -0.07151061f, -0.08597343f, -0.17673615f, 0.16978607f, -0.00928676f, 0.16757531f, 0.32141367f, 
    0.04186793f, -0.02138044f, 0.03814663f, 0.08514529f, 0.02308504f, 0.17781487f, 0.19940421f, -0.01305933f, 
    -0.15736607f, 0.00875440f, -0.12850633f, -0.02080545f, 0.15725276f, 0.09509438f, 0.04255162f, 0.02998558f, 
    0.08390079f, -0.02929249f, -0.01136663f, 0.08248138f, 0.56380194f, -0.00935906f, 0.07082666f, 0.02552576f, 
    -0.17817366f, -0.07981007f, 0.11436826f, 0.10619988f, 0.15152851f, 0.01298939f, -0.03686859f, 0.00592817f, 
    -0.16693515f, 0.06889143f, -0.22258571f, -0.04118812f, 0.01493875f, 0.01227606f, 0.09532926f, 0.04011293f, 
    -0.07482287f, 0.03840299f, -0.19118528f, -0.08510060f, 0.22724253f, 0.04154357f, 0.20771827f, 0.17881799f, 
    -0.11926503f, -0.09465770f, -0.01790689f, 0.08040525f, 0.02024619f, -0.00323424f, 0.01977652f, -0.17107071f, 
    -0.18467742f, 0.16067313f, 0.23430403f, 0.16587219f, 0.14396913f, -0.09527269f, -0.01981368f, 0.03525545f, 
    -0.09550694f, -0.12257252f, 0.18278605f, -0.18399711f, 0.04022914f, -0.06584135f, -0.17529894f, -0.17003803f, 
    -0.17410912f, 0.01969148f, 0.04086083f, 0.10524650f, -0.00964378f, 0.08424930f, 0.09673122f, -0.07676884f, 
    -0.34130070f, 0.17522904f, -0.18062668f, 0.21361394f, 0.23533769f, 0.09670678f, 0.00148493f, 0.00457421f, 
    -0.03151207f, 0.04795008f, -0.00675084f, -0.00436303f, 0.12921613f, -0.00551968f, 0.11075030f, 0.02308930f, 
    0.07686239f, -0.04912591f, -0.04423127f, 0.06204888f, 0.00116552f, -0.02358829f, -0.17723155f, -0.14001518f, 
    0.18415466f, 0.05919469f, 0.20655429f, 0.13089675f, -0.03969472f, 0.03749953f, 0.01548678f, 0.11734576f, 
    -0.04826421f, -0.01713976f, 0.09423367f, -0.06845844f, 0.11711122f, -0.13115266f, -0.00662872f, -0.10029905f, 
    0.07035998f, -0.00493664f, 0.11053696f, -0.13121204f, 0.05560393f, 0.00452569f, -0.07271574f, -0.04111394f, 
    0.50421429f, 0.38226846f, -0.03042361f, 0.23278482f, -0.09324326f, 0.05046676f, -0.04110963f, 0.11514711f, 
    0.16106556f, -0.10510286f, -0.05205765f, 0.01702726f, -0.49136576f, 0.24296823f, 0.11125732f, -0.02290344f, 
    -0.07829762f, 0.11523143f, 0.03600555f, 0.03279151f, -0.01573575f, -0.06493766f, -0.03681315f, -0.14808683f, 
    0.24250129f, -0.11715213f, 0.02287883f, -0.29125643f, -0.14980327f, 0.07704870f, 0.01533866f, -0.01482879f, 
    -0.00078563f, -0.07984777f, 0.04126401f, 0.13337733f, 0.45878527f, 0.05050251f, 0.21368407f, 0.18605931f, 
    -0.04325959f, 0.14703493f, 0.03522882f, 0.07290215f, 0.09664233f, 0.16199471f, -0.06052103f, -0.02901267f, 
    0.03568279f, -0.01415904f, -0.12527789f, -0.18266071f, -0.11649794f, 0.06472992f, 0.02710837f, -0.01216235f, 
    -0.04997255f, 0.03921422f, -0.08794788f, 0.09260000f, -0.37193227f, -0.00249780f, 0.01465414f, -0.05368713f, 
    -0.01292729f, 0.00219061f, 0.00909464f, 0.04619322f, 0.04584761f, 0.00126228f, 0.11896587f, 0.08787952f, 
    -0.00373283f, -0.01349362f, -0.03742487f, -0.01546583f, -0.00367301f, 0.02684303f, 0.00887700f, 0.03435889f, 
    0.04118722f, -0.04947228f, 0.02210678f, 0.01384444f, -0.00689342f, 0.00690396f, -0.01450758f, 0.00575538f, 
    -0.03172314f, -0.00789504f, 0.02348622f, -0.00487365f, -0.00402314f, -0.02298927f, -0.03092765f, 0.00307525f, 
    0.01902309f, -0.04027470f, -0.00686149f, -0.03760721f, 0.01294163f, 0.04491627f, 0.02734942f, 0.04670274f, 
    -0.03601045f, 0.03356513f, -0.03002823f, -0.00620258f, 0.00980492f, 0.01034963f, -0.00212202f, -0.01457325f, 
    0.03522120f, 0.01220103f, -0.02062998f, 0.01031572f, 0.02064622f, -0.04211112f, 0.03035947f, 0.03774829f, 
    0.04630944f, 0.02040087f, -0.03014419f, -0.02607197f, -0.01314874f, 0.00090850f, -0.05245084f, -0.03604688f, 
    0.00403654f, 0.04567297f, -0.04656729f, -0.05578813f, 0.00963271f, -0.00376321f, 0.04023314f, 0.04019697f, 
    0.04288410f, 0.02714086f, 0.03500277f, -0.00914274f, 0.02254461f, -0.03756709f, -0.00001614f, -0.05447757f, 
    -0.03067162f, -0.05624621f, -0.04364162f, -0.00239931f, 0.01056748f, -0.04388437f, -0.02893174f, -0.00258270f, 
    -0.01287475f, -0.03696961f, -0.00853695f, -0.02161450f, -0.04785358f, -0.03161824f, -0.01649990f, -0.04227309f, 
    0.04492597f, -0.04344905f, 0.04391393f, 0.01036324f, -0.03096137f, -0.04396195f, 0.02251434f, 0.02229099f, 
    -0.03858908f, -0.01404794f, -0.00006197f, 0.02384978f, -0.04816663f, -0.04761724f, 0.01195239f, -0.00142061f, 
    -0.01318357f, 0.03109919f, -0.00560695f, 0.01358735f, -0.04172901f, 0.02343913f, -0.03953285f, 0.01265064f, 
    -0.02267331f, -0.04172898f, -0.00520795f, -0.00547319f, 0.01057224f, 0.02216917f, -0.05107605f, -0.03736134f, 
    -0.05538086f, 0.04171236f, -0.04576477f, -0.03101935f, -0.04972568f, 0.00260659f, -0.02115568f, -0.02959092f, 
    0.00831618f, -0.04848350f, -0.01845924f, 0.03263531f, -0.00480974f, -0.02728989f, 0.02739068f, 0.01368064f, 
    0.01362177f, -0.02628261f, -0.05410346f, -0.04627920f, 0.04597902f, -0.01013054f, 0.00012525f, -0.04342780f, 
    0.03389933f, -0.03157102f, -0.02967212f, -0.02788431f, -0.01858593f, 0.02964627f, -0.03076331f, 0.02688339f, 
    -0.00136710f, 0.04449023f, -0.04945226f, -0.05359378f, -0.03541578f, -0.01079412f, -0.01732130f, 0.01532834f, 
    -0.03134452f, -0.03451604f, 0.02437077f, -0.02839935f, 0.03112557f, -0.01745309f, 0.01360142f, -0.02576333f, 
    -0.00003695f, -0.01799902f, -0.02582610f, -0.02107639f, -0.01824223f, -0.00628241f, 0.00825015f, -0.05178245f, 
    0.03806817f, 0.04240974f, 0.04336787f, 0.04335725f, -0.04336653f, -0.01866894f, 0.02394636f, -0.01786633f, 
    -0.05227130f, 0.01034415f, 0.01544912f, -0.01674625f, 0.03030930f, 0.01035209f, -0.01160654f, 0.03099881f, 
    0.04592146f, 0.00047249f, -0.03500571f, -0.03254713f, 0.04403220f, 0.04544756f, -0.03717250f, -0.03915351f, 
    -0.03672507f, -0.04137963f, 0.00333055f, 0.04435588f, -0.00529652f, 0.02864750f, 0.03524547f, 0.02351611f, 
    0.03699400f, 0.02063044f, -0.03880133f, -0.03725487f, -0.04789977f, -0.03102360f, -0.04070200f, 0.01093363f, 
    0.03310196f, -0.00143146f, -0.00149803f, -0.05374542f, 0.00468600f, -0.01550450f, -0.04273815f, -0.04472790f, 
    0.01222920f, 0.00713961f, -0.00283704f, -0.02863022f, 0.00384286f, 0.01236959f, 0.05219586f, 0.00305147f, 
    0.01243915f, -0.02461057f, -0.03589016f, -0.04476997f, -0.02277990f, 0.02532983f, 0.02474658f, -0.03661825f, 
    0.04142369f, -0.03929528f, 0.04718513f, -0.04345433f, -0.04703448f, -0.04236124f, 0.04239984f, -0.01215810f, 
    0.01805192f, 0.00577040f, -0.05012301f, 0.04200115f, -0.04132015f, -0.05167008f, 0.00980424f, -0.03511253f, 
    0.04664442f, 0.04743144f, 0.03047116f, 0.01482911f, -0.00280533f, 0.02811505f, -0.03732122f, 0.03064896f, 
    0.03067456f, -0.00950454f, -0.04365892f, -0.03572590f, -0.01286785f, 0.00215197f, -0.04323656f, 0.00126763f, 
    -0.01852839f, 0.01698542f, -0.00273279f, -0.02377883f, -0.02390921f, -0.03191744f, 0.01169097f, -0.01219940f, 
    -0.05247574f, -0.01830632f, -0.01404565f, 0.03653895f, 0.02150426f, -0.03249282f, 0.02816967f, -0.01575761f, 
    -0.01128798f, -0.01893388f, -0.01698549f, 0.00584899f, -0.01041802f, 0.02915752f, 0.02726447f, -0.04236271f, 
    -0.00793191f, 0.01865617f, -0.03405670f, 0.01920035f, -0.01794868f, 0.03175772f, 0.04150432f, 0.00430711f, 
    0.01870436f, -0.03187993f, -0.04954627f, 0.02826702f, -0.02138156f, 0.02848732f, 0.01446255f, -0.04338435f, 
    0.00755104f, -0.04969673f, 0.01957059f, 0.02562987f, -0.00529307f, -0.01105153f, -0.00189962f, 0.01022792f, 
    0.00470528f, 0.00222987f, 0.03090482f, 0.04011713f, -0.03498340f, -0.03408225f, -0.03783157f, 0.04187190f, 
    0.02924280f, 0.01188613f, 0.02345084f, -0.01949916f, -0.00966125f, 0.05265002f, -0.00945001f, -0.03940110f, 
    -0.00848008f, -0.00102932f, -0.03721747f, 0.02018815f, 0.01309218f, -0.02430832f, -0.04797843f, 0.03573156f, 
    -0.04984371f, 0.00058276f, 0.03212937f, -0.04211418f, 0.02963031f, -0.02132920f, 0.00202288f, 0.00422742f, 
    -0.01571891f, -0.01043681f, 0.02060474f, -0.01922948f, 0.01409967f, -0.03988495f, -0.05203903f, 0.02038484f, 
    -0.03389551f, 0.00921497f, -0.04766380f, 0.04130561f, -0.03851753f, 0.02234828f, -0.04758750f, -0.05525983f, 
    0.04381882f, -0.01081285f, 0.01800878f, 0.04151637f, -0.01637629f, -0.02642686f, 0.02495222f, 0.01538834f, 
    -0.00880731f, 0.04709849f, 0.03934280f, 0.00843431f, -0.04979950f, 0.00126492f, 0.02382770f, 0.02851966f, 
    0.26834375f, 0.24831690f, -0.08231741f, 0.14086513f, -0.05772839f, 0.11180433f, -0.02900153f, -0.06195171f, 
    0.12719774f, -0.00474046f, -0.05644980f, 0.08638536f, 0.18325458f, 0.11182280f, 0.10415339f, -0.20594752f, 
    0.00433643f, 0.01571270f, 0.12104748f, 0.02665766f, 0.05894852f, -0.02776525f, 0.04914376f, -0.04176603f, 
    0.06834671f, -0.19089158f, 0.03664734f, 0.12126046f, -0.11245508f, -0.04376095f, 0.08849501f, -0.06551835f, 
    0.05193061f, 0.02264283f, -0.03591087f, 0.00347986f, 0.08918162f, 0.17116389f, 0.15950084f, 0.38044563f, 
    0.06791247f, 0.08400687f, -0.06749544f, -0.00349520f, -0.01042843f, 0.00261736f, 0.12927942f, -0.03736177f, 
    -0.07308798f, 0.20062600f, 0.02510067f, -0.15636495f, -0.00080275f, -0.00222956f, 0.07395551f, -0.12402972f, 
    -0.03184012f, 0.03588185f, -0.08287916f, 0.11703435f, -0.26132953f, -0.19467257f, -0.22791213f, -0.18682773f, 
    0.02195780f, 0.00672457f, 0.02104552f, -0.06478322f, 0.11280683f, -0.03105049f, 0.04506066f, 0.02248542f, 
    0.06052123f, -0.15758222f, -0.01064543f, 0.15748984f, 0.14420806f, -0.06252166f, 0.01693705f, 0.00644379f, 
    0.03878911f, 0.00689593f, -0.13046750f, 0.03772502f, -0.08279319f, -0.02214840f, 0.02153212f, 0.01680412f, 
    0.07581181f, 0.09211648f, 0.04022097f, -0.07167971f, -0.03538381f, 0.01688359f, -0.09157762f, 0.10495128f, 
    -0.00918175f, 0.04987267f, 0.06063989f, -0.17074513f, -0.09616826f, -0.09480552f, -0.10348654f, 0.15762036f, 
    -0.01246711f, 0.06263942f, -0.02713091f, -0.08395813f, -0.11785637f, 0.33666909f, 0.07953368f, 0.23727873f, 
    0.03441964f, 0.14311713f, 0.04307579f, 0.01546436f, -0.16075550f, 0.04524149f, -0.11552817f, 0.04291148f, 
    0.04700821f, 0.04733239f, 0.10714434f, 0.32518235f, 0.00851731f, 0.01778386f, -0.00737820f, -0.05180048f, 
    0.00415469f, 0.02599058f, 0.04025708f, 0.13763487f, -0.13398068f, 0.08914332f, -0.21381998f, 0.17963937f, 
    0.01998843f, 0.02474556f, 0.16018574f, -0.06485496f, -0.08926994f, -0.08110153f, -0.00896449f, -0.04859827f, 
    0.07319510f, -0.26163521f, 0.04422350f, 0.02485707f, 0.01710625f, -0.03360776f, -0.06356286f, -0.16570929f, 
    -0.08995130f, 0.00936162f, 0.03389465f, -0.06678956f, 0.03730555f, -0.09568738f, -0.02557748f, 0.00943792f, 
    -0.03577891f, -0.00122688f, -0.09513991f, 0.03467547f, 0.01150021f, -0.14085156f, -0.10070141f, -0.04252396f, 
    -0.24977683f, 0.01456407f, 0.05970326f, -0.22371799f, 0.07234147f, -0.09679718f, 0.00315683f, 0.17779684f, 
    -0.03837319f, 0.11017013f, -0.18329842f, 0.10758448f, 0.14498413f, -0.06351157f, 0.01195821f, -0.04833252f, 
    0.00086798f, 0.04570380f, 0.08203082f, -0.12657923f, -0.11021992f, 0.03529185f, -0.14748351f, -0.09996792f, 
    -0.30257580f, 0.13854741f, -0.02043854f, -0.14019239f, 0.09676309f, 0.03780630f, 0.05310663f, 0.06248252f, 
    0.05142015f, 0.02485289f, 0.04329459f, -0.07755746f, -0.17958146f, -0.03410972f, -0.23254374f, 0.23329444f, 
    0.18037625f, 0.05426298f, -0.06048354f, -0.00872103f, 0.05520375f, 0.06455716f, 0.01453035f, -0.01586136f, 
    0.16412820f, 0.01466031f, 0.00292498f, -0.04428732f, 0.10111842f, 0.04335121f, -0.15045945f, 0.03482843f, 
    -0.02169603f, 0.00008622f, 0.10116991f, 0.07685382f, -0.13853660f, -0.08041302f, 0.11016564f, 0.24958952f, 
    0.04254902f, -0.04131737f, -0.04280673f, -0.11201876f, 0.04586446f, -0.03655357f, 0.00374312f, 0.03723428f, 
    -0.17516704f, 0.03186806f, -0.01842359f, 0.09601794f, -0.03126528f, 0.04824300f, -0.05725430f, 0.01346237f, 
    -0.10136510f, 0.09996819f, 0.07169100f, -0.04104827f, 0.11522768f, 0.49495259f, 0.11828244f, 0.05677962f, 
    0.09387737f, 0.00888922f, 0.15590392f, -0.10252478f, -0.02415867f, 0.08313086f, 0.11347806f, 0.16499124f, 
    0.01106998f, 0.04865961f, 0.05958322f, -0.09361396f, 0.09132690f, -0.06911428f, 0.11684041f, -0.01238974f, 
    0.05987405f, 0.23077318f, -0.03367556f, -0.01845991f, -0.21947142f, 0.08501135f, 0.23249178f, 0.07617809f, 
    0.00888614f, 0.12729922f, -0.00085451f, -0.07611702f, 0.02178041f, -0.05697642f, -0.00815243f, -0.01922225f, 
    -0.01482865f, -0.13139093f, 0.07411247f, 0.05850802f, 0.11848117f, -0.11582984f, -0.01842399f, 0.06901149f, 
    0.09760786f, 0.03703956f, -0.06416018f, -0.04847110f, 0.09138674f, 0.15207970f, -0.14436860f, 0.08439744f, 
    -0.10183318f, 0.03035061f, -0.03661683f, -0.03688115f, -0.00977263f, -0.07315349f, 0.05798759f, 0.05999296f, 
    0.05297296f, 0.03399619f, 0.08331391f, 0.17622790f, 0.06575660f, -0.00334008f, -0.04442345f, 0.02529558f, 
    -0.01882768f, -0.05349038f, 0.09669764f, 0.02589673f, -0.38073847f, -0.00930311f, 0.10554332f, 0.34631437f, 
    0.01693249f, -0.09913555f, 0.07897808f, -0.06138067f, -0.00130055f, -0.01609146f, -0.06290153f, 0.10279826f, 
    0.03593469f, 0.16574863f, 0.18875673f, 0.26927802f, -0.09126964f, 0.10302018f, -0.03449491f, 0.00495872f, 
    0.08517813f, -0.00449101f, 0.14509004f, 0.14940952f, 0.24086773f, 0.06208077f, 0.09179616f, 0.02835839f, 
    0.00755760f, 0.07927200f, 0.05359323f, 0.07796298f, 0.01643848f, -0.04248329f, 0.01713859f, 0.17845088f, 
    -0.42171070f, 0.20399134f, 0.11838028f, 0.02351532f, 0.09064994f, -0.15661176f, -0.05622202f, 0.01273184f, 
    0.06229525f, 0.00794393f, -0.01513638f, 0.06095115f, -0.09694351f, -0.04775112f, 0.01923071f, -0.06544186f, 
    -0.11999279f, -0.00991928f, -0.02199558f, 0.15026663f, -0.10236962f, 0.00409774f, 0.09276272f, 0.07914243f, 
    -0.03157402f, -0.04128074f, -0.03935909f, 0.00557880f, 0.02097961f, 0.02270814f, -0.02362132f, -0.05040226f, 
    0.01544358f, -0.01744006f, -0.04659633f, -0.03010633f, -0.02161413f, -0.03983960f, -0.00330357f, -0.00360595f, 
    -0.01785182f, 0.01993822f, -0.02890562f, -0.01109631f, -0.04651659f, -0.01561768f, -0.00723863f, -0.03069731f, 
    0.02254600f, 0.00091786f, 0.01491966f, -0.04237271f, 0.00529891f, 0.01272874f, -0.03987148f, -0.03399337f, 
    -0.02801130f, 0.01082099f, -0.03336426f, 0.03548919f, -0.00114603f, 0.01449896f, -0.03212583f, -0.03785923f, 
    0.04138608f, -0.02329618f, -0.02009389f, -0.03967853f, -0.03902704f, 0.03761113f, -0.03690118f, 0.00810573f, 
    -0.02826435f, -0.00173638f, 0.04256502f, -0.03421587f, -0.01329178f, -0.04904684f, 0.02200275f, 0.00278536f, 
    -0.00000165f, 0.02177763f, 0.00341002f, -0.03673115f, -0.04109379f, -0.04383598f, 0.04275606f, -0.05532499f, 
    -0.00017205f, 0.01256634f, 0.03386519f, -0.00857423f, -0.04583242f, -0.00609430f, 0.01048208f, 0.01741549f, 
    0.00968084f, 0.02400819f, 0.00642642f, 0.02028797f, -0.00847889f, 0.03507245f, 0.03829255f, -0.05442761f, 
    -0.00705878f, 0.02768525f, -0.05044791f, -0.00911295f, -0.04794913f, -0.01923715f, -0.04111768f, 0.00420712f, 
    -0.02025400f, 0.04235664f, -0.02059896f, -0.01749756f, -0.02717989f, 0.03340917f, -0.03590586f, 0.04139833f, 
    -0.04364040f, 0.00414016f, 0.02766610f, -0.03857908f, -0.02983844f, -0.04792969f, 0.02817453f, 0.00870113f, 
    0.00402903f, -0.01451277f, 0.01713151f, 0.02116737f, 0.01971789f, 0.03011868f, 0.04040621f, -0.02862172f, 
    0.01077324f, -0.05162984f, 0.02808979f, -0.04322248f, -0.03841749f, 0.02114575f, -0.03778251f, 0.00527513f, 
    -0.02788310f, -0.02800027f, 0.01827172f, -0.00942230f, -0.04746058f, -0.03674517f, 0.04450572f, 0.02193240f, 
    -0.01089827f, 0.01440756f, 0.03136116f, -0.02961037f, -0.03640462f, 0.01229096f, -0.03088990f, -0.01102770f, 
    -0.00228121f, -0.02031184f, 0.00356177f, -0.04883449f, 0.00551692f, 0.00291228f, -0.03910737f, -0.04281528f, 
    0.04361516f, 0.01436972f, 0.01185729f, 0.01999819f, -0.05331900f, 0.04170990f, -0.01109691f, -0.03895563f, 
    0.01727628f, 0.02852502f, -0.02330166f, 0.04188059f, -0.03901520f, -0.03158521f, -0.02408047f, -0.00918656f, 
    -0.01316886f, 0.01515636f, -0.00090859f, -0.04506620f, -0.05028505f, 0.03369328f, 0.04660923f, -0.04520382f, 
    0.02353621f, 0.03685234f, 0.00921660f, 0.00240758f, -0.03919508f, 0.01090319f, 0.00215369f, -0.04587371f, 
    0.03207005f, -0.04099661f, 0.03178808f, -0.00204429f, -0.02726881f, -0.02584051f, -0.00137447f, 0.00896625f, 
    -0.04247288f, 0.04428663f, -0.01679537f, -0.00387188f, -0.03847133f, -0.01666762f, -0.04125420f, 0.03040429f, 
    -0.03491175f, 0.04052024f, -0.02520786f, 0.04412878f, 0.00206987f, 0.00257063f, 0.00775944f, -0.01382844f, 
    -0.03410742f, -0.00685879f, -0.00640679f, 0.02602725f, -0.01753076f, 0.03630315f, -0.04514997f, 0.02569517f, 
    0.03536762f, -0.03477780f, 0.01314584f, -0.05555206f, -0.04870299f, 0.02482820f, 0.03162962f, 0.03099210f, 
    -0.03340122f, -0.01358998f, -0.02158416f, -0.00084465f, -0.01498800f, -0.03134918f, 0.01406135f, -0.03547907f, 
    0.03983747f, 0.04541679f, 0.00725484f, -0.03022018f, 0.03498161f, 0.03887342f, 0.00259602f, 0.00088649f, 
    0.01612392f, -0.03443680f, 0.01379684f, 0.03533163f, 0.01262538f, -0.05082715f, 0.02294418f, 0.00732042f, 
    0.00370547f, -0.03836351f, -0.05330410f, 0.01194899f, -0.02442510f, -0.05049600f, -0.01466126f, -0.01593404f, 
    0.00252554f, -0.02452101f, 0.01116603f, -0.03385531f, -0.03372350f, 0.01281283f, -0.01697014f, -0.01122166f, 
    0.01104381f, 0.00899760f, 0.03347210f, 0.01211704f, -0.00176365f, -0.03787682f, -0.01187683f, -0.01976459f, 
    -0.00285821f, 0.03442733f, -0.04895137f, 0.01068579f, 0.03231133f, 0.00984876f, -0.04417483f, 0.02167409f, 
    0.02464041f, 0.02678069f, -0.03096773f, 0.03056908f, 0.01613142f, -0.05086331f, 0.00140354f, 0.01585671f, 
    -0.02257540f, -0.02318558f, -0.01813404f, -0.00239358f, -0.00141464f, -0.03281562f, -0.01206486f, -0.02121126f, 
    -0.00300270f, -0.00883347f, 0.02343855f, -0.03738266f, 0.03261153f, -0.04350823f, -0.05214385f, -0.05607433f, 
    0.03567113f, 0.02530420f, -0.04575545f, -0.00056819f, 0.04330794f, -0.04061840f, -0.03758542f, -0.01652020f, 
    -0.00678344f, -0.02064639f, -0.02372220f, -0.03022853f, -0.01036116f, -0.05121981f, -0.04265252f, -0.02644931f, 
    0.00999667f, -0.04931902f, -0.01652875f, 0.01162275f, 0.01893797f, -0.02633551f, -0.03631487f, 0.03468521f, 
    -0.03535419f, 0.00926805f, -0.04365101f, -0.02726192f, 0.02169899f, 0.01304430f, -0.01096058f, -0.00043393f, 
    -0.05053384f, -0.00888408f, -0.02377810f, -0.00995971f, -0.01398223f, -0.03539764f, -0.03321860f, 0.01241144f, 
    0.01715276f, -0.02627756f, 0.01546534f, 0.00043887f, -0.01488896f, -0.05466570f, -0.01241751f, -0.00377154f, 
    -0.01105832f, 0.04289335f, -0.03406026f, -0.01469674f, 0.02838762f, 0.02794793f, -0.02041377f, -0.04759712f, 
    -0.00156675f, -0.01019249f, -0.04258088f, -0.00249656f, 0.02700350f, -0.03451322f, -0.02527938f, -0.00571938f, 
    -0.03556272f, -0.05000085f, -0.02640532f, -0.03494205f, 0.00516627f, -0.01728697f, 0.03693303f, 0.01263046f, 
    0.03640082f, 0.02691345f, -0.05011586f, -0.01150135f, 0.00146751f, -0.01257271f, 0.04162133f, -0.00650586f, 
    0.00657564f, -0.04107090f, 0.02483656f, 0.00381776f, -0.05497238f, 0.01047862f, 0.02356606f, -0.05234840f, 
    -0.01055116f, 0.00272042f, 0.01395116f, -0.01877623f, -0.02827264f, 0.03190318f, -0.02037533f, 0.01596644f, 
    -0.01270519f, 0.01882697f, 0.02324010f, -0.02574198f, 0.01752565f, 0.02959088f, 0.01378752f, 0.02855532f, 
    -0.02428745f, -0.02607451f, 0.01828874f, 0.01144309f, -0.04095830f, 0.00711042f, -0.00474713f, -0.00348253f, 
    0.02448163f, -0.01097781f, 0.01828752f, 0.03716950f, 0.00788870f, -0.01198725f, 0.00254103f, 0.04551743f, 
    -0.01749630f, -0.02046046f, 0.04367573f, 0.03404252f, -0.01592365f, -0.02002283f, -0.04486986f, -0.01405178f, 
    -0.02172227f, -0.02747633f, -0.03005690f, 0.01655033f, -0.03396921f, 0.02321199f, -0.04771437f, -0.03128104f, 
    -0.05253173f, 0.00041508f, 0.01376670f, 0.02148427f, 0.02186729f, 0.03363455f, -0.00487874f, -0.00198810f, 
    0.01476006f, -0.00832427f, -0.02944582f, 0.01602273f, -0.05008804f, 0.01987706f, 0.04850968f, -0.03396692f, 
    0.03706769f, -0.01607006f, -0.02794060f, -0.01699702f, -0.04007389f, -0.03344042f, 0.01787574f, -0.05487471f, 
    0.01325888f, 0.03444903f, -0.01828265f, -0.03043902f, 0.00842529f, -0.04202514f, -0.00139578f, -0.00905707f, 
    0.01530195f, -0.05671023f, 0.04189290f, -0.00548463f, 0.03161850f, 0.03221885f, -0.03976413f, 0.04594547f, 
    0.03741160f, 0.00251997f, -0.02205092f, 0.01134360f, -0.05074676f, 0.03133162f, -0.02780084f, 0.01379318f, 
    0.02290311f, -0.01752283f, 0.02322996f, 0.04718012f, -0.00245017f, 0.00126263f, 0.04972709f, 0.04152907f, 
    -0.06108282f, 0.03250246f, -0.00008892f, 0.01576784f, 0.03543901f, 0.02675727f, -0.03960538f, -0.00126911f, 
    -0.02431568f, 0.02738964f, -0.05941517f, 0.02527968f, -0.03220013f, -0.01467567f, -0.05838618f, 0.02374172f, 
    0.03656119f, 0.02276896f, -0.02806581f, -0.05418857f, 0.04003946f, 0.02456005f, -0.04769132f, -0.03127989f, 
    0.04152964f, -0.03321251f, 0.03195843f, 0.03782479f, -0.02019412f, 0.00433860f, -0.03419259f, -0.01610999f, 
    -0.00011999f, 0.03745196f, 0.00733819f, -0.03614914f, -0.00448142f, 0.01571626f, -0.00699031f, 0.04270290f, 
    -0.04871580f, -0.04105429f, 0.01727333f, 0.03531675f, 0.03028745f, -0.03527807f, 0.02802518f, -0.03144848f, 
    0.00200902f, -0.00535724f, -0.03459431f, -0.05514196f, -0.00513132f, -0.05511532f, -0.00769695f, 0.01026769f, 
    0.02033003f, -0.00568983f, 0.02304841f, -0.01541112f, -0.00751690f, 0.04781882f, -0.04527524f, 0.03781004f, 
    0.00095901f, -0.04944956f, 0.03157933f, 0.00670545f, -0.04703913f, -0.00425040f, -0.01006842f, 0.01447368f, 
    -0.04822259f, 0.01137242f, -0.03086543f, -0.04198076f, 0.04920232f, 0.01689949f, -0.05174968f, -0.04763835f, 
    0.01273762f, 0.01478956f, 0.03690122f, -0.04709205f, -0.03034241f, -0.00990804f, 0.04109306f, 0.01378982f, 
    0.02861378f, 0.03178003f, 0.00648829f, -0.03708969f, -0.02089898f, -0.02890988f, -0.02491475f, -0.00622793f, 
    -0.04422013f, 0.04315986f, 0.00238120f, -0.03154434f, 0.00985556f, -0.05735573f, -0.02168248f, 0.00711216f, 
    0.03548115f, -0.01975882f, 0.01404765f, -0.03874764f, -0.00025600f, 0.00816802f, 0.01140374f, -0.02531331f, 
    0.00839865f, 0.01809476f, -0.02126150f, 0.01754200f, 0.00512099f, -0.04299590f, -0.05323855f, -0.05770617f, 
    0.01682634f, 0.01784715f, 0.01316376f, -0.04442308f, 0.02213467f, -0.01524800f, -0.02467359f, 0.01668926f, 
    -0.02896816f, -0.00849584f, -0.02420336f, 0.02448918f, -0.03492697f, 0.02853915f, -0.01720513f, -0.04123124f, 
    0.02097283f, -0.01964174f, 0.04498481f, 0.02152215f, 0.03453888f, 0.03551597f, -0.01711540f, 0.04434643f, 
    -0.05546175f, -0.03903169f, 0.01735812f, -0.02705305f, -0.04338060f, 0.01039425f, 0.02757784f, 0.00980970f, 
    0.02074627f, 0.01712881f, -0.00674003f, 0.04302150f, -0.05091523f, 0.04244845f, 0.00278668f, -0.01270319f, 
    -0.03850983f, -0.02245927f, 0.00478609f, -0.02745381f, 0.01366893f, -0.04659041f, -0.01367993f, -0.04503984f, 
    -0.03094446f, -0.04200260f, 0.00598418f, -0.01092501f, -0.03448987f, 0.01862434f, -0.04013702f, -0.02306251f, 
    -0.01748413f, 0.00950624f, -0.01949877f, -0.00556850f, -0.03144512f, 0.03130556f, 0.03829040f, -0.04633057f, 
    -0.01504123f, -0.03523178f, 0.01951849f, 0.00606987f, -0.05649424f, -0.02316032f, -0.00896268f, -0.00767823f, 
    -0.00807658f, 0.02518277f, -0.01243305f, 0.03898687f, 0.00159997f, -0.04526971f, -0.04711289f, -0.02854343f, 
    0.03874520f, -0.03974684f, -0.02627559f, 0.02684085f, 0.01841941f, -0.03245512f, 0.01919241f, -0.02784402f, 
    0.02355091f, -0.04716223f, 0.03225951f, 0.01050721f, -0.03554566f, 0.02493954f, -0.00269610f, -0.02083088f, 
    0.03978754f, -0.01939062f, 0.00818137f, -0.01109976f, -0.02571052f, -0.03144427f, 0.01286358f, 0.02871819f, 
    -0.03380101f, -0.04628402f, -0.03097020f, -0.01129951f, -0.00042452f, 0.02356544f, -0.03210142f, -0.05080666f, 
    0.00819159f, -0.01463968f, -0.00501212f, 0.01023569f, 0.00415653f, 0.01966899f, -0.01423486f, -0.01036595f, 
    0.02968572f, 0.00311632f, 0.02947889f, 0.00977329f, 0.02840667f, 0.00232335f, -0.02086604f, 0.04204207f, 
    0.02638827f, 0.04545481f, -0.01852598f, 0.01851976f, 0.03044455f, -0.01439699f, 0.03272469f, -0.03004148f, 
    -0.00360967f, -0.01965368f, -0.02661591f, -0.03503240f, -0.05454050f, -0.01496982f, 0.01401241f, 0.02787326f, 
    -0.01852591f, -0.03750174f, 0.03545343f, -0.02540464f, -0.01640512f, 0.00065132f, -0.01732805f, -0.02952212f, 
    0.00660562f, -0.03426567f, -0.04883485f, -0.03393294f, 0.03759419f, -0.03201048f, -0.01425716f, 0.02715976f, 
    0.44453794f, -0.10307658f, 0.10249523f, 0.15458749f, -0.02360591f, -0.03534555f, 0.10632104f, 0.01312164f, 
    0.04848288f, 0.00299130f, -0.00634781f, 0.09660964f, 0.13523532f, 0.14967653f, 0.09748036f, 0.00556622f, 
    0.03002885f, 0.01951619f, 0.16078041f, 0.07567281f, 0.00483224f, 0.04539024f, 0.10135575f, 0.01224774f, 
    -0.06095743f, 0.13651526f, 0.06043685f, 0.16315442f, 0.01080787f, 0.01928617f, -0.02577276f, 0.02423752f, 
    0.04199284f, 0.04634340f, -0.04556866f, -0.00270505f, -0.01549501f, -0.07364378f, -0.08940524f, -0.02173013f, 
    -0.05997261f, 0.00777910f, 0.00104343f, 0.00281734f, 0.00401062f, -0.04969823f, 0.08321346f, 0.00058964f, 
    0.06177523f, -0.21421422f, 0.09445883f, 0.15079957f, 0.02680401f, -0.02512603f, -0.04740595f, 0.04543293f, 
    -0.00812911f, -0.00473588f, -0.09707037f, 0.10998655f, -0.38439226f, -0.07599746f, -0.15288326f, 0.07400831f, 
    0.07890955f, -0.00975018f, 0.07579132f, -0.00057523f, 0.01639509f, 0.03411559f, 0.04611334f, 0.02231915f, 
    -0.25551429f, 0.02755309f, 0.16097613f, 0.29483494f, 0.00486420f, -0.06265261f, 0.12004315f, 0.08808609f, 
    -0.00317902f, 0.04151267f, -0.16149086f, -0.05178759f, -0.22541961f, 0.11704483f, -0.04137317f, -0.00654282f, 
    0.13598362f, -0.04277369f, -0.12566316f, -0.11111200f, -0.03276251f, -0.06661075f, -0.00946554f, 0.23386039f, 
    -0.00021510f, 0.07873293f, 0.01946857f, 0.13164504f, 0.00584181f, -0.07298945f, -0.02826674f, 0.00622896f, 
    0.01479163f, -0.01833240f, 0.00079278f, -0.12282028f, 0.00011334f, -0.09366240f, -0.24204379f, -0.15145025f, 
    -0.05312351f, 0.12541252f, -0.03696530f, -0.02557238f, 0.07698208f, 0.01035022f, -0.00218556f, 0.02805557f, 
    0.01710824f, -0.25252080f, 0.10760283f, 0.03199324f, 0.00582103f, 0.03231678f, 0.00021965f, 0.09700241f, 
    0.06221754f, 0.04195570f, 0.04772316f, 0.04641833f, -0.06005320f, 0.01677090f, -0.29781833f, -0.14419037f, 
    -0.07321031f, 0.04190985f, 0.15617968f, -0.01431077f, 0.06553482f, -0.06854520f, 0.04611145f, -0.08796799f, 
    0.16115017f, -0.19815740f, 0.05204792f, -0.23878920f, 0.00884417f, -0.01914594f, 0.02134898f, -0.11377410f, 
    -0.05331616f, 0.07582742f, 0.08992474f, 0.00570323f, -0.00795662f, -0.30157745f, -0.06727913f, 0.08816659f, 
    0.01458054f, -0.02668180f, -0.12581748f, 0.15577605f, 0.06738687f, -0.03211217f, -0.05783929f, -0.12325743f, 
    -0.34243885f, 0.09928884f, 0.05568664f, 0.04364891f, 0.02418523f, -0.04547265f, 0.04148588f, 0.07371317f, 
    0.07088737f, 0.10123400f, -0.00955860f, 0.17580871f, 0.03030400f, -0.13036901f, -0.07856061f, 0.03418829f, 
    -0.05098227f, 0.01390808f, -0.03141741f, -0.16651100f, 0.02438739f, 0.05551879f, -0.01683534f, 0.00607598f, 
    -0.12924227f, 0.20822613f, -0.27160335f, -0.17178014f, 0.13207780f, -0.11864366f, 0.07316830f, -0.02761938f, 
    0.05966963f, 0.06343782f, 0.04478395f, -0.05386498f, -0.13061841f, 0.04501920f, -0.08622463f, 0.11704862f, 
    -0.04853661f, 0.11452977f, -0.07967873f, -0.00302185f, 0.05134440f, -0.00041985f, -0.00009589f, -0.00544327f, 
    0.01683949f, 0.24169134f, -0.00705480f, 0.07470183f, 0.09711698f, 0.03128436f, 0.07059211f, 0.01814968f, 
    -0.00457605f, -0.01918660f, 0.13043843f, 0.13722700f, -0.09587247f, -0.17349969f, 0.09701772f, 0.02858018f, 
    -0.01185260f, 0.07759443f, 0.05664203f, 0.09144995f, -0.04934396f, 0.02608812f, 0.00024579f, 0.16569996f, 
    -0.26399568f, -0.06284146f, -0.17352690f, -0.14040029f, -0.00324779f, -0.03232047f, -0.00538339f, 0.03151957f, 
    0.07105438f, 0.17006633f, -0.07888713f, 0.10099982f, -0.04724661f, 0.14190698f, 0.15961136f, -0.27398467f, 
    -0.05604520f, -0.03680073f, 0.00428912f, -0.10697908f, 0.14179109f, -0.07394029f, -0.01457272f, 0.25698051f, 
    -0.21292609f, 0.13559216f, 0.36303455f, -0.11896765f, -0.04954567f, -0.07200918f, 0.13691017f, 0.03883543f, 
    0.09185588f, -0.01157058f, 0.06058717f, 0.03262507f, -0.33623767f, 0.13740873f, 0.03361519f, 0.14487424f, 
    0.07308651f, 0.02588983f, 0.01678614f, 0.00112579f, 0.12083943f, -0.07607268f, 0.12461011f, 0.13443230f, 
    -0.11116607f, -0.05251694f, 0.15996878f, 0.11369197f, 0.14469911f, 0.03420461f, -0.06337496f, 0.04559284f, 
    0.02579512f, 0.02977154f, -0.01336170f, 0.03967946f, 0.16619858f, -0.14230996f, -0.09491273f, 0.26006803f, 
    -0.08179208f, 0.02076822f, -0.03039038f, 0.02926717f, -0.02400630f, 0.01688704f, 0.00552943f, 0.17285360f, 
    0.09336402f, -0.04194693f, 0.07244109f, 0.09782100f, -0.01856956f, -0.07036383f, -0.04488849f, 0.01559603f, 
    -0.09829279f, 0.05217131f, 0.10795189f, 0.04949951f, -0.21254632f, 0.14078633f, 0.12717490f, 0.02281901f, 
    0.04807797f, 0.04510418f, 0.03517322f, -0.11427867f, -0.10329014f, 0.08484871f, 0.15078948f, 0.20217821f, 
    0.07759560f, 0.07840453f, 0.14086492f, 0.35674036f, 0.01858650f, 0.10493666f, 0.08223174f, 0.00160010f, 
    0.14339955f, 0.05549010f, 0.05560802f, 0.07388294f, -0.00322657f, -0.11615213f, 0.06731185f, 0.22542864f, 
    0.01949924f, -0.02208199f, 0.06186036f, 0.07042206f, 0.16540867f, -0.01676205f, 0.05385992f, 0.08377381f, 
    -0.34582311f, 0.32380167f, 0.01098709f, -0.02199910f, 0.00892786f, 0.03497856f, -0.00668656f, -0.06971467f, 
    0.09072865f, 0.01487086f, -0.07181779f, -0.04915212f, 0.02396961f, -0.06838772f, 0.05646949f, 0.24833100f, 
    0.01536818f, 0.04264990f, 0.01404785f, 0.12755467f, -0.17582433f, -0.00803608f, -0.04218474f, -0.01828763f, 
    -0.17526954f, -0.28251886f, 0.12969245f, -0.12616456f, -0.02478116f, -0.10850397f, 0.16329019f, 0.02759220f, 
    -0.05857805f, -0.04530992f, 0.09134902f, 0.06286689f, 0.05231420f, -0.09900256f, 0.14703454f, 0.15624541f, 
    -0.05283007f, 0.04394560f, 0.08498254f, -0.10872236f, 0.06492875f, 0.11076145f, 0.03148645f, 0.04801485f, 
    -0.08525924f, 0.19264302f, -0.17058416f, 0.01384203f, 0.17946532f, 0.09461492f, -0.00833938f, 0.19643758f, 
    0.06230561f, 0.01439703f, 0.01143560f, 0.01549537f, -0.32545534f, -0.07828807f, -0.12848893f, -0.23122831f, 
    -0.05995344f, -0.00063190f, 0.06749919f, -0.06298378f, 0.09795509f, -0.03608930f, 0.03658513f, 0.06111072f, 
    0.13107224f, -0.09199598f, 0.04990881f, 0.00599511f, 0.13352744f, 0.08925150f, -0.06058388f, 0.19026449f, 
    -0.02160236f, 0.01188142f, 0.10843980f, 0.02530351f, 0.29470214f, 0.38039920f, -0.05634223f, 0.27358615f, 
    0.05427913f, -0.01194929f, -0.05008257f, 0.05932708f, -0.08756644f, -0.01434425f, 0.02455405f, -0.00326508f, 
    0.19728652f, 0.20601942f, -0.04899777f, 0.17788011f, -0.03322669f, 0.01070744f, 0.05040782f, 0.04231086f, 
    -0.03465132f, 0.12099986f, 0.05471103f, 0.08021816f, -0.27499142f, 0.02426800f, 0.16404404f, 0.04047915f, 
    -0.08073420f, -0.06609799f, -0.09820697f, 0.05109995f, 0.04475012f, 0.00854604f, 0.08834971f, 0.04856484f, 
    0.18010516f, -0.16922794f, 0.20345336f, 0.08066811f, 0.09637322f, 0.09180929f, 0.11569696f, -0.08229584f, 
    -0.01471027f, -0.00207772f, 0.05598556f, 0.02135484f, -0.06692655f, -0.26342478f, -0.22794224f, -0.24946854f, 
    -0.01300089f, 0.06389109f, -0.00798753f, -0.12812278f, 0.04726936f, 0.01323103f, 0.05416975f, 0.06418187f, 
    0.27750805f, 0.01155322f, 0.20172362f, 0.20879102f, 0.04992005f, 0.03809573f, 0.04780775f, 0.01874228f, 
    -0.01799577f, 0.03937232f, 0.05680211f, 0.01460460f, 0.01802604f, -0.12962009f, -0.07622108f, -0.32010725f, 
    0.01731090f, 0.17480277f, 0.03582391f, -0.07795900f, 0.01663943f, 0.12710074f, 0.04072814f, 0.04341105f, 
    -0.16291107f, 0.08778853f, 0.07262342f, -0.23888800f, 0.01992008f, 0.00072889f, 0.04474423f, 0.00729799f, 
    0.14483120f, 0.14464775f, 0.03716431f, 0.00764959f, 0.15130125f, -0.02788262f, 0.01705616f, 0.03176467f, 
    0.08571915f, 0.01737496f, -0.01423581f, 0.04986743f, 0.04205848f, -0.10168322f, 0.00744187f, 0.07888041f, 
    -0.18575086f, 0.06079004f, 0.04125914f, 0.06198110f, 0.06140748f, -0.02728487f, 0.13217914f, 0.01284065f, 
    -0.01364132f, 0.03347027f, 0.02717663f, -0.04196889f, 0.24265668f, 0.01509481f, 0.06099769f, 0.22237673f, 
    0.00746807f, -0.13534863f, -0.01386762f, -0.00626068f, -0.02763180f, 0.08449446f, 0.04963907f, 0.10755834f, 
    -0.11124826f, -0.06714694f, -0.05248873f, -0.09896289f, -0.03402637f, -0.10249427f, 0.04225242f, -0.00989117f, 
    -0.00904429f, 0.01961789f, -0.02932522f, -0.17025016f, 0.28739846f, 0.29180485f, -0.05162624f, 0.05019120f, 
    0.00402027f, 0.04264917f, -0.03547026f, 0.01510695f, 0.03660797f, -0.02473086f, 0.02406575f, 0.09630691f, 
    -0.18281049f, 0.08406620f, -0.04224100f, -0.01456905f, 0.05765514f, -0.03542552f, 0.19599652f, -0.01993448f, 
    -0.00650472f, 0.01297505f, -0.00339220f, -0.01160882f, 0.17111388f, 0.06536102f, 0.12729232f, -0.04484213f, 
    0.04610838f, 0.01719788f, 0.04434221f, 0.01446418f, -0.04644009f, 0.00655618f, 0.04571890f, -0.01402611f, 
    -0.01585178f, 0.08918732f, 0.00473971f, 0.07416687f, 0.09614090f, -0.04878234f, 0.07811411f, -0.08966365f, 
    0.01719533f, 0.07393424f, -0.01622468f, 0.27192482f, -0.22641024f, -0.28565294f, -0.04591921f, -0.11023741f, 
    -0.04565403f, -0.06099910f, -0.08889110f, -0.06434810f, 0.15435189f, -0.08760810f, 0.03029286f, 0.09676883f, 
    -0.21611786f, 0.08981866f, 0.19015376f, 0.08224340f, -0.00409471f, -0.05053943f, 0.04212885f, -0.02980633f, 
    0.01711823f, -0.01914264f, 0.01586554f, -0.01674371f, 0.04739160f, -0.05990029f, 0.05869684f, -0.05802404f, 
    -0.05937076f, 0.03783590f, 0.02927988f, 0.05373388f, 0.06694890f, 0.01924838f, 0.00442405f, 0.01756298f, 
    0.24433485f, -0.09481838f, 0.25351325f, 0.14801119f, -0.02962717f, 0.04465252f, 0.01026628f, 0.07857712f, 
    -0.01473888f, 0.06984901f, 0.11016187f, -0.01523150f, 0.02277805f, 0.02905827f, 0.00006890f, -0.05346921f, 
    0.01043053f, -0.02277324f, 0.09624750f, 0.10415658f, 0.08677626f, 0.02930479f, 0.06898359f, 0.03594607f, 
    0.22057581f, 0.18510932f, 0.11243240f, 0.15225492f, 0.00199182f, 0.01861827f, 0.00921878f, 0.10141402f, 
    -0.12122675f, 0.00103235f, 0.04829889f, 0.05828788f, 0.01217410f, 0.10478877f, -0.03329684f, -0.08888315f, 
    0.03886193f, 0.17626663f, 0.07779080f, -0.10336544f, -0.00785668f, 0.08306881f, 0.14916971f, -0.01903952f, 
    0.09815265f, -0.15447073f, -0.20376822f, 0.05929514f, -0.17205206f, 0.00677544f, -0.01319795f, 0.02417133f, 
    0.07473877f, 0.02397500f, -0.05563323f, -0.04519599f, 0.04829852f, 0.13432598f, 0.25380793f, 0.17273724f, 
    -0.06004785f, -0.00354649f, -0.02692803f, -0.00058175f, 0.14480297f, 0.11973665f, 0.10574407f, 0.00192635f, 
    -0.09080825f, -0.13178325f, -0.13971026f, -0.08720612f, -0.09694374f, 0.13454151f, 0.10105226f, -0.04749659f, 
    0.10269054f, -0.00673607f, 0.02882270f, 0.06369699f, 0.06676394f, -0.10210896f, 0.08674946f, 0.09479696f, 
    0.01534495f, -0.01037424f, -0.04220786f, 0.02795433f, -0.00307330f, 0.00755373f, 0.02461566f, 0.11676240f, 
    0.08701421f, -0.17544368f, 0.09471174f, -0.18200123f, 0.06584239f, -0.08364628f, -0.13500291f, 0.09684938f, 
    0.00448509f, 0.07027097f, 0.15870316f, -0.00352728f, 0.00653433f, -0.46284464f, 0.09998125f, 0.21523285f, 
    0.05830355f, 0.03804083f, 0.08282504f, 0.07253136f, -0.02402031f, 0.14397857f, -0.06253227f, 0.09336622f, 
    0.24046364f, 0.12331814f, -0.07307881f, -0.14816689f, 0.08626725f, 0.09714545f, 0.00695317f, 0.04749142f, 
    0.06381242f, 0.06600990f, -0.03229707f, 0.10339306f, -0.03578574f, 0.16541415f, 0.05244851f, -0.02296285f, 
    -0.08215550f, -0.14164899f, -0.04490741f, 0.06196243f, 0.11358739f, -0.04033230f, -0.00720449f, 0.12129819f, 
    -0.19515401f, 0.06887261f, -0.05997669f, -0.20832928f, 0.18804596f, -0.04631033f, -0.01046550f, 0.17431255f, 
    0.20609728f, 0.04114513f, 0.04129840f, -0.03394091f, 0.49609604f, -0.14306957f, 0.01654324f, -0.11949579f, 
    -0.00906446f, -0.03045445f, -0.05492972f, -0.05205530f, 0.02982674f, 0.08051698f, 0.18044163f, 0.09920190f, 
    0.44780692f, -0.05105302f, -0.02261130f, -0.10438705f, -0.08114838f, 0.04166684f, 0.07667823f, -0.06159751f, 
    0.14292204f, 0.05347118f, 0.01005624f, -0.02324819f, 0.34401235f, 0.27561736f, 0.16448021f, 0.00086462f, 
    -0.18320289f, 0.04872281f, 0.06640992f, -0.11975833f, 0.05698289f, 0.10752828f, 0.03067494f, -0.12574241f, 
    -0.25717691f, -0.07997857f, 0.00432679f, -0.02185226f, 0.01068145f, 0.04219474f, -0.00427618f, 0.06830492f, 
    -0.08184402f, 0.03370126f, -0.08926186f, -0.10045182f, 0.01979571f, 0.09015115f, 0.16106644f, 0.24410954f, 
    -0.10867818f, -0.10609218f, -0.06864625f, 0.11540917f, -0.05759389f, 0.01316873f, 0.06160460f, 0.00653208f, 
    0.43945849f, -0.20756283f, -0.03618339f, 0.36561072f, 0.09816572f, 0.10108304f, -0.05756572f, -0.08198970f, 
    0.10891162f, -0.03236734f, 0.02003776f, -0.05397564f, -0.00376655f, -0.22495331f, 0.05914613f, 0.15222292f, 
    -0.06943300f, -0.09902507f, 0.00406954f, 0.01217236f, -0.00833534f, -0.06621777f, 0.02572039f, 0.03041005f, 
    -0.29548267f, 0.23451075f, -0.10308886f, 0.18424989f, 0.00307540f, -0.08016403f, 0.01265845f, 0.07794076f, 
    -0.01321308f, 0.10223421f, -0.00196932f, -0.00079216f, 0.45815045f, -0.09257489f, -0.00257174f, -0.00152374f, 
    0.18293485f, 0.12173534f, 0.04640224f, 0.01710373f, 0.05133853f, -0.02310486f, -0.00967415f, -0.03986157f, 
    -0.03919522f, 0.16968055f, 0.04758051f, -0.12198187f, 0.01532189f, -0.15277973f, -0.02585848f, -0.04304845f, 
    -0.08839482f, -0.06280805f, -0.06545632f, 0.02166436f, 0.15631145f, -0.23827241f, -0.09973700f, -0.09353220f, 
    -0.02838942f, -0.04423504f, 0.09452028f, 0.12387193f, -0.00441910f, 0.08558232f, -0.01421748f, 0.00884393f, 
    0.19090383f, 0.03092373f, 0.02894448f, 0.26961049f, -0.11146767f, -0.01270884f, 0.09819755f, 0.02456197f, 
    -0.04898948f, -0.06207449f, -0.00782364f, -0.08075828f, 0.34267640f, -0.07825584f, -0.08051366f, -0.13488391f, 
    -0.19943836f, -0.03770360f, -0.07216080f, -0.01684020f, 0.07126505f, 0.06758614f, 0.04064094f, 0.14327019f, 
    -0.27149251f, -0.03577790f, 0.07542942f, -0.09979627f, 0.01486226f, -0.06276758f, -0.07074606f, 0.06092426f, 
    0.00598213f, -0.05823665f, -0.08173814f, 0.04603551f, 0.17616889f, -0.08641260f, -0.11046059f, 0.14294450f, 
    0.14868051f, 0.07301087f, 0.11305819f, -0.01411992f, 0.05019319f, 0.11256452f, -0.05513486f, -0.13133363f, 
    0.20472778f, 0.16607662f, -0.16798387f, 0.13909559f, 0.08917803f, -0.00326312f, -0.01720822f, 0.10895161f, 
    -0.08060680f, -0.09601280f, 0.06634746f, 0.00688017f, -0.15759584f, 0.22208165f, 0.10243299f, -0.14590918f, 
    -0.17557774f, 0.02837949f, -0.07619542f, 0.17872487f, -0.05582833f, 0.05976989f, 0.05727962f, -0.05596266f, 
    -0.36811563f, 0.01823642f, -0.05157669f, 0.17284937f, 0.04486601f, -0.09450530f, 0.07581109f, -0.05330871f, 
    -0.02740738f, -0.01719191f, -0.06561838f, 0.03280227f, 0.20447731f, -0.13604987f, -0.02207711f, -0.11147293f, 
    0.14886534f, 0.00491838f, -0.04630585f, 0.11228373f, -0.13314044f, -0.04645206f, -0.03211257f, 0.08613002f, 
    -0.10419962f, -0.09449629f, -0.04391745f, 0.08910656f, 0.09059921f, -0.04050088f, 0.03418939f, -0.05590910f, 
    0.11026246f, 0.08826374f, 0.00511563f, -0.00554603f, 0.10270724f, 0.17599536f, 0.06182708f, 0.05469261f, 
    0.06128364f, -0.01602007f, -0.01176646f, 0.04381673f, 0.05093388f, 0.09628575f, -0.06851402f, 0.13806626f, 
    0.19664136f, -0.22818902f, -0.20516947f, 0.13004786f, 0.11287109f, 0.09787241f, -0.06158731f, 0.01090729f, 
    0.02942510f, 0.05331606f, 0.07450675f, 0.04357527f, -0.13387214f, 0.05783490f, 0.08199706f, 0.04406175f, 
    0.03203366f, -0.06090929f, 0.04297233f, 0.11783379f, 0.00655581f, -0.02202848f, -0.14557235f, -0.08327900f, 
    0.24886134f, -0.37264228f, -0.18309596f, -0.08084213f, 0.00589062f, 0.01174758f, -0.03217404f, 0.04521157f, 
    0.10830297f, -0.01507781f, -0.07070994f, -0.14176691f, 0.08078408f, -0.16907176f, -0.22621308f, 0.08996768f, 
    0.06690150f, -0.01092955f, -0.02348225f, -0.04523235f, 0.04625011f, -0.09155092f, -0.03724952f, -0.03843705f, 
    -0.06909311f, 0.19468747f, -0.06538680f, -0.02254237f, -0.17099088f, -0.05991899f, -0.01179108f, 0.02541224f, 
    -0.06952431f, -0.10097834f, -0.04263578f, 0.01351169f, -0.08871952f, -0.03895793f, 0.06180927f, -0.14088315f, 
    0.00789912f, -0.02021370f, -0.07954808f, 0.05199187f, 0.10044863f, 0.10999468f, 0.06093246f, 0.08042212f, 
    -0.09254698f, -0.01804740f, 0.01546285f, 0.15697399f, 0.02963878f, -0.04858173f, -0.08734850f, -0.06428505f, 
    0.04577581f, -0.08959345f, -0.01265111f, -0.08457834f, -0.16791058f, 0.35213491f, -0.01612863f, 0.09771652f, 
    0.06589232f, 0.05448944f, -0.09526880f, -0.05204384f, 0.06914033f, 0.07161347f, -0.06961022f, 0.10476413f, 
    -0.02005309f, 0.09255581f, 0.09132147f, 0.06278017f, 0.06428162f, 0.00699728f, -0.01574090f, -0.07780240f, 
    0.04501802f, 0.07070771f, 0.09874701f, -0.17219453f, 0.12814723f, -0.19844824f, -0.17107858f, -0.16357251f, 
    -0.05372481f, 0.06944513f, -0.03785507f, 0.07471762f, -0.05164033f, -0.00850664f, -0.04744201f, 0.07799983f, 
    0.16278812f, -0.13844277f, 0.05518810f, 0.23135091f, -0.00438383f, 0.02026077f, -0.07493580f, 0.07121307f, 
    -0.07018325f, -0.03263811f, 0.13729420f, -0.03750560f, -0.06873106f, -0.01066462f, 0.22061452f, 0.12941533f, 
    0.07465309f, 0.07410827f, 0.07786429f, 0.17967097f, -0.03972243f, 0.02815195f, -0.12296603f, -0.10266567f, 
    -0.07708766f, 0.10474358f, 0.13297531f, -0.10551182f, -0.07893887f, 0.02224979f, -0.02405824f, 0.02656357f, 
    -0.04621338f, 0.03393126f, 0.09748435f, 0.07878905f, -0.03997822f, -0.06719034f, -0.11473635f, -0.09470884f, 
    -0.01999174f, -0.03578444f, 0.04865307f, 0.00610298f, 0.04624022f, -0.01053916f, 0.12666327f, 0.01007937f, 
    -0.11993194f, 0.14130487f, -0.07251673f, 0.07463741f, 0.11062697f, 0.17610936f, 0.05621839f, 0.05375355f, 
    0.05286138f, 0.06001854f, -0.07544047f, 0.15903364f, -0.06891619f, -0.16830891f, -0.03449162f, -0.02066442f, 
    -0.02229386f, -0.05805583f, 0.00456707f, 0.03354460f, 0.14494012f, -0.00395209f, 0.07544262f, 0.02077568f, 
    -0.15571471f, 0.07740948f, -0.09398324f, -0.36683545f, -0.03113842f, -0.07804160f, -0.00261607f, 0.12798980f, 
    0.07049501f, -0.03734367f, -0.07205088f, 0.00142156f, -0.08606717f, 0.13293095f, 0.07291450f, -0.04864761f, 
    0.02710988f, -0.01704323f, -0.03427482f, -0.07220698f, 0.09941643f, 0.12935899f, -0.00615845f, 0.17956039f, 
    0.05697854f, 0.13398714f, -0.02112381f, 0.00142288f, 0.00486902f, 0.13174669f, 0.02773820f, 0.08395912f, 
    -0.00032413f, -0.00682052f, 0.01860975f, 0.14464642f, -0.17658696f, 0.16137215f, -0.01808776f, -0.14564051f, 
    -0.08746228f, 0.08511499f, 0.10632139f, -0.01660579f, -0.04201806f, 0.08075035f, 0.14911769f, 0.00936907f, 
    0.17673229f, 0.02775617f, -0.17247367f, 0.22491556f, -0.02368286f, 0.08510007f, -0.01823958f, -0.10692679f, 
    0.06636934f, -0.06875695f, 0.11470909f, -0.12421627f, -0.33044127f, 0.08658500f, -0.00665745f, -0.09071714f, 
    0.09670242f, 0.13285062f, -0.05335511f, 0.16556707f, 0.14022225f, -0.01870142f, 0.16070053f, -0.01801874f, 
    -0.16342218f, -0.01056283f, -0.06063062f, 0.06319490f, 0.04987082f, 0.01921112f, 0.03140757f, -0.03587475f, 
    0.02251983f, -0.08913798f, 0.05271720f, 0.10958692f, 0.04560594f, -0.08448922f, 0.22279139f, -0.03420683f, 
    -0.02835104f, -0.01716664f, 0.13982806f, 0.07492312f, -0.01809119f, -0.06024881f, -0.00863334f, 0.06456388f, 
    0.01379964f, 0.01238633f, 0.04987473f, 0.03063743f, -0.08479868f, -0.02230034f, 0.07249095f, -0.03925047f, 
    0.10284170f, 0.18702132f, -0.00971050f, -0.03589651f, -0.07118994f, 0.09304724f, -0.00505649f, -0.20545240f, 
    0.00721158f, 0.05030185f, 0.04537923f, 0.10891210f, -0.07421634f, -0.08106919f, -0.02169564f, 0.01059663f, 
    0.06751074f, -0.15692544f, 0.05408665f, -0.07801893f, 0.03079885f, -0.02995722f, 0.06506981f, 0.01593304f, 
    0.03990190f, 0.08861054f, -0.04774098f, -0.02967189f, 0.12863380f, -0.42691353f, 0.02302506f, 0.18685710f, 
    -0.06562215f, -0.06435227f, 0.01699889f, 0.03047570f, 0.03411248f, 0.01129988f, 0.02508981f, -0.08023643f, 
    0.02246724f, 0.04845948f, -0.01031277f, 0.06822830f, -0.03428491f, 0.07508738f, -0.00289028f, -0.00102552f, 
    0.01978243f, -0.18708974f, 0.13288702f, 0.02625013f, 0.11848885f, 0.13650443f, -0.00954873f, 0.05479245f, 
    0.07752386f, -0.01381131f, 0.01538361f, 0.00695514f, 0.05750278f, -0.00632326f, 0.06154062f, -0.11514734f, 
    -0.07208154f, 0.20015600f, 0.01053309f, -0.10998160f, 0.07024687f, 0.15822758f, 0.04547729f, -0.02300664f, 
    -0.10557006f, -0.08541161f, 0.01185549f, 0.06685512f, -0.15535265f, -0.04819414f, 0.06768937f, 0.00146544f, 
    0.00502016f, 0.01209470f, 0.09318757f, -0.05963927f, 0.01783022f, 0.05584438f, 0.05460386f, -0.09061516f, 
    0.00347673f, 0.08660007f, 0.05929027f, -0.12254620f, -0.01280898f, 0.01411873f, 0.09155003f, -0.02386934f, 
    -0.04217866f, -0.02932435f, 0.00361996f, -0.06893310f, 0.31882465f, -0.07170889f, 0.00022610f, -0.08323134f, 
    0.03717946f, 0.00477614f, 0.02216285f, 0.08036189f, -0.00590270f, -0.06997972f, 0.02341071f, 0.08101585f, 
    -0.01299931f, 0.03394531f, 0.01543371f, -0.19208525f, 0.13509217f, -0.08708953f, -0.01507463f, 0.01895799f, 
    -0.14603436f, -0.01227489f, 0.05110229f, 0.02304693f, -0.17761561f, 0.03051402f, -0.03099077f, -0.02361534f, 
    -0.01745746f, 0.01817103f, 0.12505275f, 0.08004695f, -0.07231446f, 0.14937969f, -0.03628793f, -0.08240725f, 
    0.42723668f, -0.19031341f, 0.08679962f, 0.05092268f, 0.07794196f, 0.05670203f, 0.01595844f, 0.04645004f, 
    -0.00274282f, 0.08404244f, 0.01945253f, 0.01150097f, 0.22272679f, 0.06078371f, -0.00396149f, 0.03792419f, 
    0.13722987f, 0.08286390f, 0.20351188f, -0.06955789f, 0.05509480f, -0.00384187f, -0.00267743f, 0.05369807f, 
    0.37607285f, -0.06324669f, 0.10523169f, 0.12838832f, 0.07380322f, 0.06315356f, -0.06550847f, -0.02197150f, 
    0.04690211f, 0.04499352f, 0.03132218f, -0.13381879f, 0.11968296f, 0.00251375f, -0.06089238f, 0.14132440f, 
    0.03766613f, 0.01523674f, 0.07956816f, 0.08534653f, -0.04857077f, 0.11348904f, -0.04379341f, 0.06598993f, 
    0.33081442f, 0.35134044f, 0.06730729f, 0.04950213f, 0.08134078f, 0.02963457f, -0.15972385f, -0.09402484f, 
    -0.05798072f, 0.01301172f, 0.04360822f, 0.00886875f, 0.25994074f, -0.10559647f, 0.08591053f, -0.11445711f, 
    0.07498521f, 0.12031522f, 0.10487498f, 0.01287950f, 0.06699985f, 0.03776030f, -0.03309017f, 0.02722676f, 
    0.19485477f, -0.06588472f, 0.10768177f, 0.15576638f, 0.00320025f, 0.08574115f, -0.12772495f, 0.07838555f, 
    -0.00975832f, 0.13118115f, -0.04925032f, -0.02129765f, -0.06960534f, -0.12447866f, -0.00205267f, -0.02969385f, 
    0.12028823f, -0.08690371f, 0.04329057f, -0.05707842f, -0.05984182f, 0.08038297f, -0.08415307f, 0.18327899f, 
    0.02253434f, 0.23288831f, 0.11237123f, 0.00159328f, -0.08546932f, -0.11200467f, 0.14416552f, 0.04712502f, 
    -0.09211597f, 0.02723715f, -0.07010799f, 0.00469309f, -0.11185291f, 0.14052258f, -0.11660716f, -0.11788444f, 
    -0.00005633f, 0.05101345f, 0.01450115f, -0.12671699f, 0.00418402f, -0.01583268f, -0.04383205f, -0.00453330f, 
    -0.18930911f, 0.16969635f, -0.23198594f, 0.16538769f, 0.01382073f, -0.00075997f, -0.03444128f, -0.04295075f, 
    -0.05514000f, 0.03289736f, -0.16627850f, -0.14294988f, 0.26125610f, -0.06050234f, 0.08366689f, -0.12316869f, 
    0.08979757f, 0.11291651f, 0.05028092f, 0.01359192f, 0.20933250f, 0.02144992f, 0.11791493f, -0.02620114f, 
    0.14664526f, -0.18430434f, -0.07533141f, -0.11447795f, -0.03052060f, -0.17674346f, -0.18243283f, 0.00488671f, 
    0.07951332f, -0.10399912f, -0.03678040f, -0.00204132f, 0.20783880f, 0.16213749f, -0.02620004f, -0.12548454f, 
    0.00759980f, 0.06145639f, 0.17399445f, 0.11983640f, 0.14986409f, -0.07074487f, -0.05107732f, 0.10553421f, 
    0.33491740f, 0.22177844f, -0.12292875f, -0.03223617f, 0.04447805f, 0.01438801f, 0.08017953f, -0.07781394f, 
    -0.11715844f, -0.00749793f, 0.07747409f, -0.12975429f, 0.03444310f, -0.13956010f, -0.07721645f, -0.00514228f, 
    0.04536678f, 0.01259996f, -0.05442079f, -0.19061412f, -0.00235814f, 0.14884451f, 0.08486215f, -0.08375623f, 
    -0.01373746f, 0.11448969f, 0.08027187f, 0.17564572f, -0.09622379f, 0.07957240f, 0.07882348f, -0.12351751f, 
    -0.05421380f, 0.07049096f, 0.01783407f, 0.05715937f, -0.19585636f, -0.17109852f, -0.22637871f, -0.15574948f, 
    0.02150199f, -0.00713594f, -0.09050761f, -0.05435764f, 0.08148964f, -0.13843197f, 0.12691900f, -0.14884332f, 
    0.18539411f, 0.20748131f, -0.05852551f, 0.07447838f, 0.15183641f, 0.02198305f, 0.17201786f, 0.00271044f, 
    -0.11718610f, -0.01887812f, 0.09277854f, 0.06021799f, 0.07251751f, -0.09563411f, 0.08161636f, -0.23517875f, 
    -0.01510912f, 0.00310503f, -0.08468205f, -0.05509529f, 0.12118211f, 0.03056160f, -0.05011435f, 0.03583919f, 
    -0.05931412f, -0.03299435f, 0.07572869f, 0.07019494f, 0.00360558f, 0.00127298f, -0.00964645f, -0.04325311f, 
    -0.02439270f, 0.11555131f, -0.15972027f, -0.01987588f, 0.05610740f, -0.11851948f, -0.09535350f, 0.07095459f, 
    0.01362151f, 0.06008751f, -0.08157600f, 0.07335529f, 0.06060558f, -0.07079532f, -0.16117591f, -0.01153677f, 
    0.03780274f, -0.23251978f, -0.29782611f, -0.15878506f, 0.05033632f, -0.07225947f, -0.08864149f, 0.15308258f, 
    0.04324611f, 0.02665613f, 0.08623321f, -0.07112177f, 0.24206275f, 0.05103385f, 0.16428816f, -0.15366369f, 
    -0.05415230f, -0.03185544f, -0.03669560f, 0.04387243f, 0.04251823f, 0.02558504f, -0.07369857f, -0.06760710f, 
    -0.22908686f, 0.17419215f, 0.27864826f, 0.11794278f, -0.03163067f, -0.09784134f, 0.05495699f, -0.00903704f, 
    -0.00309349f, -0.12840553f, 0.15058520f, 0.02934999f, -0.15919490f, 0.00031487f, -0.17593870f, 0.02346151f, 
    0.10316828f, -0.08325099f, -0.03041646f, 0.13610435f, 0.03992447f, 0.07167719f, 0.03933546f, 0.03423646f, 
    -0.18815477f, -0.13562961f, -0.09896982f, -0.05368630f, 0.08330271f, -0.06982385f, -0.08264811f, -0.07940049f, 
    -0.03125030f, 0.03624143f, 0.08346540f, 0.04420503f, 0.05047085f, -0.18986474f, -0.03475332f, 0.18140714f, 
    0.03965731f, 0.02825008f, -0.05415211f, -0.12709007f, 0.04010164f, 0.09421862f, -0.09401551f, 0.04150611f, 
    0.16098641f, -0.10452120f, -0.02572691f, -0.01449404f, -0.10068913f, -0.03146630f, -0.09665857f, -0.08137023f, 
    0.03456365f, 0.01829296f, 0.09548973f, 0.01752106f, -0.07346404f, 0.00791660f, 0.02867296f, 0.01123178f, 
    0.02996215f, -0.05614132f, 0.09473238f, 0.17939322f, -0.09500541f, 0.02548543f, -0.10614394f, 0.04332072f, 
    0.14724734f, 0.03660655f, 0.02672249f, -0.01180865f, 0.14633937f, -0.09349570f, 0.02745914f, 0.01744476f, 
    0.04083687f, 0.04850734f, -0.01733261f, 0.01576863f, 0.01035260f, -0.25693581f, -0.13891637f, 0.14580186f, 
    -0.12976091f, -0.16879389f, 0.01411042f, -0.08174097f, -0.00819505f, -0.04633768f, 0.03154945f, -0.03997574f, 
    0.44159377f, 0.35858649f, 0.09472106f, 0.19903789f, -0.06290427f, 0.01907593f, 0.05122465f, -0.00754613f, 
    -0.08327805f, 0.04610207f, -0.06937257f, -0.06436721f, 0.10942034f, 0.12655251f, -0.04471130f, 0.23753458f, 
    0.12002249f, 0.11236425f, -0.03359289f, -0.02659057f, -0.02154074f, -0.00500432f, 0.00975850f, -0.09733193f, 
    0.29590216f, 0.33276731f, -0.08187848f, 0.17240722f, 0.02366141f, 0.11253987f, -0.11928643f, -0.05498987f, 
    0.09330104f, -0.01465212f, 0.00580434f, -0.05572834f, 0.01202486f, 0.30269390f, -0.06239741f, -0.10514779f, 
    0.06365401f, -0.01370474f, -0.04126910f, 0.09139758f, 0.04353349f, -0.10049020f, -0.03563686f, 0.02486479f, 
    0.14221920f, 0.02778290f, 0.38754392f, -0.01984612f, -0.07414300f, 0.01487240f, 0.03007359f, -0.15329750f, 
    0.09076097f, -0.02149483f, 0.02902809f, -0.06066285f, 0.26507556f, 0.03886319f, -0.00323958f, 0.12672774f, 
    -0.04335351f, 0.02183717f, -0.05860595f, 0.02051388f, -0.00006878f, 0.06956823f, 0.01193104f, -0.02677362f, 
    -0.18618597f, 0.08783716f, -0.02628385f, 0.07560492f, 0.10696286f, -0.07970200f, 0.01193329f, -0.01400227f, 
    -0.05044539f, 0.04219304f, -0.03871133f, 0.11836805f, -0.14302857f, -0.19877729f, 0.12486299f, -0.06327930f, 
    0.02306831f, 0.00449562f, -0.00725652f, -0.05549618f, 0.16037537f, 0.06400505f, -0.00155298f, 0.00039042f, 
    0.04960930f, -0.16701978f, 0.06196603f, 0.02131691f, -0.05258843f, 0.00048951f, -0.05667502f, 0.05561190f, 
    -0.04971010f, -0.01989119f, 0.06125662f, 0.12824874f, -0.10759576f, 0.01431208f, -0.07472698f, 0.06322272f, 
    0.13155930f, 0.08369664f, 0.12342717f, 0.02342213f, 0.10678964f, 0.04746838f, 0.02229936f, -0.03220209f, 
    -0.22521658f, 0.20019050f, -0.03255101f, -0.16192247f, 0.18977357f, -0.01091881f, -0.09013718f, 0.13594630f, 
    0.00909712f, 0.05621176f, -0.07716273f, -0.05814609f, -0.03020823f, 0.17492573f, 0.10225587f, 0.16864781f, 
    -0.00687083f, -0.03343697f, -0.01910160f, -0.00557532f, 0.03822479f, 0.01950677f, -0.00713831f, -0.04609535f, 
    -0.17926820f, 0.03458164f, -0.07855996f, -0.24315514f, -0.07366274f, 0.00166021f, 0.01279888f, 0.05802076f, 
    0.14994198f, 0.01939311f, -0.08351541f, 0.00741964f, 0.05016035f, 0.03286741f, -0.02695373f, 0.19921415f, 
    0.04507668f, 0.00305658f, 0.07207534f, -0.06545197f, 0.11013704f, -0.06704955f, 0.05285871f, 0.13707076f, 
    0.13797563f, -0.01442212f, -0.17559652f, 0.20410790f, 0.07003490f, 0.00528299f, 0.04302892f, -0.01630220f, 
    -0.12174220f, 0.01571879f, 0.01942364f, 0.01653114f, -0.24543804f, 0.03001346f, 0.01466161f, -0.07946121f, 
    0.00453791f, 0.10719431f, 0.05885607f, 0.02080286f, -0.01974463f, 0.08600838f, 0.03787975f, 0.01306962f, 
    -0.12063927f, 0.19306743f, -0.05100686f, -0.06786263f, 0.04619869f, -0.02864661f, 0.06058084f, 0.05446608f, 
    0.04250742f, -0.03915001f, -0.01941416f, -0.00748548f, -0.43496150f, -0.00712925f, 0.02582212f, -0.16419907f, 
    0.13394427f, 0.20153861f, -0.06195673f, -0.00725002f, 0.08849141f, 0.05813634f, 0.07591677f, -0.08120666f, 
    -0.14198597f, 0.05211872f, 0.05306667f, -0.03506251f, 0.11483353f, 0.02826133f, 0.03310106f, 0.08249970f, 
    0.02315936f, -0.06873042f, 0.04760622f, 0.09000058f, -0.19240679f, -0.10323626f, 0.13153630f, 0.22384916f, 
    0.04968908f, 0.06375288f, 0.12169684f, 0.03202929f, 0.01867182f, 0.10033516f, -0.04325452f, 0.05607008f, 
    0.15480763f, 0.08000458f, 0.01304561f, -0.10192487f, 0.00517679f, 0.07428234f, -0.07762133f, 0.03970126f, 
    0.03952773f, 0.09924784f, 0.03917430f, 0.07312326f, -0.07469074f, -0.06624106f, -0.14082471f, 0.01375610f, 
    -0.00611941f, 0.09858315f, -0.02981201f, 0.02061106f, 0.04373724f, -0.07587939f, -0.05127805f, 0.01863390f, 
    -0.31768930f, -0.12563954f, 0.02712017f, -0.11762659f, 0.00977854f, 0.01561541f, -0.06790368f, 0.11669500f, 
    -0.01868839f, 0.07901169f, 0.04612890f, -0.21969058f, 0.16097556f, 0.09661821f, 0.17344120f, 0.16278881f, 
    -0.02240760f, 0.05253436f, 0.21640383f, 0.03609235f, -0.06930505f, 0.09532590f, 0.05590106f, -0.05215500f, 
    -0.06600334f, 0.09800544f, -0.01973394f, -0.01382600f, 0.00020657f, -0.01248715f, -0.07740536f, 0.01356419f, 
    0.03876119f, -0.02872815f, 0.08846495f, 0.07501294f, -0.04472557f, 0.10820343f, -0.04640638f, 0.07870381f, 
    0.04123911f, 0.06812704f, -0.01820105f, 0.08468793f, 0.01453224f, -0.02208887f, 0.02372101f, -0.05781773f, 
    0.00684536f, 0.00138410f, -0.11646321f, -0.18817601f, 0.15311816f, -0.09461898f, 0.00112411f, 0.05731762f, 
    0.08040741f, -0.02379837f, -0.05028544f, 0.04998083f, -0.08197304f, -0.01205122f, -0.08418290f, 0.07907259f, 
    0.14915566f, -0.00383962f, 0.04993473f, -0.11709672f, 0.05424579f, 0.06349448f, -0.00864555f, 0.01714600f, 
    -0.05402654f, 0.12674008f, 0.07951673f, -0.20500152f, -0.04156053f, 0.02511072f, 0.06537873f, -0.05883675f, 
    0.11913211f, -0.06085617f, 0.06076586f, -0.08055586f, -0.22505629f, -0.12552007f, -0.03674661f, 0.20167892f, 
    -0.00725513f, -0.12661019f, 0.08100621f, 0.13138947f, 0.03198890f, -0.10010254f, -0.04159220f, 0.13390853f, 
    -0.01570941f, 0.09962296f, 0.33879504f, -0.02371993f, 0.02665209f, 0.07525691f, 0.05130021f, 0.02227176f, 
    -0.05348780f, -0.02822538f, 0.13206173f, 0.04059774f, 0.01378015f, -0.05662622f, -0.21346703f, -0.18865137f, 
    0.06501499f, -0.00429238f, 0.02689506f, 0.05372935f, -0.04302587f, 0.12324006f, -0.11135720f, 0.00598764f, 
    0.10950629f, 0.13140310f, 0.10192257f, 0.17680322f, 0.01373541f, -0.14740872f, 0.04931173f, 0.09178197f, 
    -0.01462472f, 0.02500916f, -0.01164584f, -0.04812478f, -0.07000156f, 0.06262182f, 0.10295976f, -0.00773034f, 
    0.06551068f, -0.03071380f, 0.03473154f, 0.06910273f, -0.03864704f, 0.05114750f, 0.03910922f, 0.10045796f, 
    -0.26319930f, -0.02794885f, 0.00630529f, -0.08717075f, 0.03970253f, -0.01456707f, 0.05364196f, 0.00723793f, 
    0.10259452f, -0.03921013f, -0.04085356f, 0.13649555f, -0.05298100f, 0.04122885f, 0.00610254f, -0.23860154f, 
    -0.00673417f, 0.05567108f, 0.00959090f, -0.16729741f, 0.18743899f, -0.00187944f, 0.10227747f, -0.00875077f, 
    0.04917084f, 0.30099684f, 0.16183317f, -0.01415408f, -0.06026648f, -0.06504317f, -0.00178103f, 0.04429372f, 
    0.11334990f, -0.06401293f, -0.00440166f, -0.00983540f, -0.06178472f, -0.04750836f, -0.19525525f, -0.03119754f, 
    0.11993562f, 0.05918010f, -0.01238758f, -0.02143760f, -0.03786469f, 0.08994406f, 0.10533734f, -0.09425627f, 
    -0.22845399f, -0.04654188f, 0.07472924f, 0.07153543f, 0.02445267f, -0.11311337f, 0.01025006f, -0.12846610f, 
    0.01171262f, -0.13312116f, 0.19938506f, 0.07816507f, 0.47080195f, 0.33161616f, 0.25036630f, 0.06566717f, 
    -0.07795335f, -0.10210542f, 0.00253861f, 0.01922239f, 0.07774013f, -0.08245441f, 0.08171572f, 0.01199505f, 
    -0.11478527f, 0.00560046f, 0.11081053f, 0.05867590f, 0.03526374f, 0.01599021f, -0.10177302f, -0.16545933f, 
    0.09505677f, 0.08560124f, 0.17583725f, 0.12466412f, -0.23069805f, -0.04552840f, -0.12504798f, -0.00454915f, 
    0.18007384f, 0.12017249f, 0.07397155f, 0.25951821f, 0.07997465f, -0.07490052f, 0.04333096f, -0.02645496f, 
    -0.27716655f, 0.11704628f, 0.01115120f, 0.07929945f, 0.25597849f, 0.06245142f, -0.03904852f, -0.02873504f, 
    -0.01857752f, -0.01974170f, 0.07289784f, 0.11644669f, -0.31040028f, -0.15173557f, -0.29833043f, -0.16094005f, 
    0.19468346f, 0.01601526f, 0.07839159f, -0.01270074f, -0.00323556f, -0.05301704f, -0.04301334f, -0.03160689f, 
    0.29451045f, 0.24464849f, 0.15818155f, -0.02663769f, -0.14552572f, -0.12159454f, 0.00955752f, 0.05323262f, 
    0.12505345f, 0.08579996f, 0.03199286f, 0.02798639f, -0.07822133f, -0.32384294f, -0.17964023f, -0.10428860f, 
    0.15194026f, 0.11867763f, 0.04220303f, -0.01580489f, 0.00835661f, 0.11758808f, -0.03142242f, -0.06563211f, 
    -0.00208582f, -0.26675487f, -0.00992657f, -0.15407813f, 0.24664672f, 0.04007502f, 0.09035346f, 0.10512082f, 
    0.15112278f, -0.11011578f, 0.02148212f, 0.19246125f, 0.02657904f, -0.07042825f, 0.18334703f, 0.00161579f, 
    -0.03512302f, -0.04709824f, -0.06008221f, 0.05030047f, 0.06690528f, -0.02649606f, -0.10792330f, 0.10150742f, 
    -0.30951655f, 0.11126837f, -0.18502201f, 0.12205632f, 0.23020282f, 0.16084689f, 0.07600563f, 0.03933479f, 
    0.16590384f, -0.04755190f, 0.00243061f, -0.08146717f, -0.03732016f, 0.16702983f, 0.14225587f, 0.28890291f, 
    0.11649110f, -0.01942991f, 0.04102172f, 0.07701376f, -0.04059795f, 0.01353719f, 0.07213031f, 0.09817556f, 
    -0.12343749f, 0.00177218f, -0.16975419f, -0.03640364f, 0.15295291f, 0.09309956f, 0.04937811f, 0.12846129f, 
    0.14958426f, 0.01869661f, -0.07922959f, -0.00038820f, 0.35963660f, -0.11911125f, 0.14071004f, 0.11761037f, 
    0.01044103f, 0.01359204f, 0.16771880f, -0.07701258f, -0.00827761f, -0.07515638f, -0.04030198f, -0.01017600f, 
    0.05205891f, 0.11982453f, -0.24814960f, 0.07612852f, 0.15949954f, 0.02206532f, 0.09266919f, 0.07031790f, 
    -0.07838910f, 0.05614940f, 0.03512803f, -0.05549653f, 0.31874546f, 0.28224310f, 0.19916065f, 0.01522587f, 
    -0.08345803f, -0.11640281f, 0.05098582f, -0.02404480f, 0.04547867f, 0.05954588f, 0.08726557f, 0.08356249f, 
    -0.18815534f, 0.06640976f, 0.11278287f, -0.03400933f, -0.00094559f, 0.03226362f, 0.01271204f, -0.01802517f, 
    0.04649585f, 0.09978734f, 0.06576680f, -0.16266650f, 0.00200201f, -0.40752280f, -0.18506272f, 0.00119556f, 
    0.02720539f, -0.03185167f, 0.05485398f, 0.01050362f, -0.08934189f, 0.10566395f, 0.00254351f, -0.05148604f, 
    0.12489790f, 0.23620532f, -0.29794866f, -0.00767590f, 0.19301963f, 0.05874052f, -0.12769261f, 0.05466134f, 
    -0.02778061f, 0.02624891f, -0.07204478f, -0.02703268f, -0.05549880f, 0.08999596f, 0.04709394f, 0.12621991f, 
    0.09461591f, 0.06067326f, 0.07396324f, 0.00854691f, 0.06682380f, 0.09454575f, -0.09272473f, 0.06920822f, 
    0.28675601f, 0.26157367f, 0.10385025f, -0.03692409f, 0.01800516f, 0.01149811f, -0.05143277f, 0.21143365f, 
    -0.04707541f, 0.03361623f, 0.09590194f, 0.12776972f, -0.10060519f, -0.12933338f, 0.04573816f, -0.12079416f, 
    0.16311789f, 0.01401659f, 0.15517008f, 0.00303136f, 0.16820210f, -0.03065885f, 0.00641800f, -0.05356506f, 
    0.21005692f, 0.41168475f, 0.23225906f, 0.05055960f, -0.21009937f, -0.10739718f, -0.15260684f, 0.00279304f, 
    0.02077386f, -0.08539880f, -0.03501613f, 0.10625916f, -0.10017508f, 0.11512818f, -0.08647046f, -0.06648059f, 
    -0.08103978f, 0.14149569f, 0.06863324f, -0.00350340f, -0.00672681f, -0.05731211f, 0.28636101f, -0.03401103f, 
    -0.02978838f, 0.06100073f, 0.19080833f, -0.16986418f, -0.22552390f, 0.12815557f, 0.02248436f, -0.20171085f, 
    -0.02884840f, -0.03699325f, 0.00828714f, 0.11865815f, 0.22861893f, 0.09750680f, 0.21291986f, -0.17277813f, 
    0.09008984f, -0.05761967f, -0.03992049f, 0.14923374f, 0.01240875f, 0.16146503f, 0.11861582f, 0.03402509f, 
    -0.01005301f, -0.35858068f, -0.13893467f, -0.11789308f, -0.02793645f, 0.13659108f, 0.16688603f, 0.00460791f, 
    -0.03782838f, -0.00717513f, -0.02265788f, -0.07528038f, -0.40896335f, 0.01211568f, -0.03240837f, 0.03177034f, 
    -0.08385447f, -0.08259960f, -0.16274685f, 0.07958938f, -0.00259166f, -0.01667732f, -0.02202589f, 0.08120892f, 
    0.02862672f, -0.01702728f, 0.01402577f, 0.01883639f, 0.00765262f, -0.00453261f, 0.00758433f, 0.01512607f, 
    0.00380200f, -0.03534586f, 0.01804104f, -0.05447358f, -0.03115772f, 0.02435247f, -0.04284559f, 0.01456702f, 
    -0.00080943f, -0.04677212f, 0.03337376f, 0.00940036f, -0.01881505f, 0.03914721f, 0.01760207f, -0.03653266f, 
    0.00569001f, -0.04393185f, 0.04710782f, -0.05781246f, -0.05398255f, 0.02533752f, -0.03116480f, 0.03936836f, 
    0.00992941f, 0.05206162f, -0.04804728f, 0.04350511f, -0.03059571f, 0.04794560f, 0.02187384f, 0.02055890f, 
    -0.03302354f, 0.03781892f, 0.00441472f, 0.04032442f, -0.05570558f, 0.04045101f, 0.02136101f, -0.01515615f, 
    -0.03636611f, 0.02587225f, -0.03338486f, 0.03844850f, -0.03913498f, 0.04310866f, 0.01442493f, -0.02177866f, 
    -0.02029637f, -0.03194105f, -0.04202292f, -0.03561800f, 0.00087156f, -0.04764983f, 0.01951515f, 0.03775967f, 
    -0.03247908f, 0.00373745f, -0.01439393f, -0.01246403f, -0.03167158f, 0.03182331f, -0.04810238f, -0.04358062f, 
    -0.04555906f, -0.01582868f, 0.02109374f, 0.02777992f, 0.01306655f, 0.03367722f, 0.03834419f, -0.01008538f, 
    -0.02053460f, -0.00607646f, -0.01662110f, -0.05282262f, -0.04543537f, -0.03599457f, -0.01130304f, 0.02042535f, 
    -0.02534628f, -0.04643471f, -0.03055489f, 0.01025728f, -0.04673981f, -0.05238349f, 0.01095373f, -0.00141318f, 
    0.03212810f, -0.02488412f, -0.01848140f, -0.01278003f, -0.03602721f, 0.01636391f, -0.00428108f, -0.03112240f, 
    -0.02725614f, -0.03296524f, -0.05053224f, -0.01505132f, -0.05317404f, -0.01246136f, -0.03419952f, -0.03364118f, 
    0.03623564f, -0.03822486f, -0.03982673f, 0.02787563f, -0.04558001f, 0.02130155f, -0.04114180f, 0.01984774f, 
    -0.00092559f, -0.05876272f, -0.01353803f, 0.02075985f, 0.02543146f, -0.05140515f, 0.01511677f, -0.00888831f, 
    -0.03162142f, 0.04816280f, -0.02403928f, -0.03837317f, 0.01708498f, 0.01398317f, 0.03515298f, 0.03698109f, 
    0.02169663f, -0.00387369f, -0.01506522f, -0.00038398f, -0.01273369f, -0.04244436f, -0.02048317f, -0.02503748f, 
    0.02900879f, 0.02599477f, 0.02744588f, -0.00244560f, -0.03571561f, 0.03755573f, -0.01818641f, 0.04422881f, 
    0.03016130f, 0.01851159f, 0.03948306f, 0.03385727f, -0.03936698f, 0.04246326f, -0.00341835f, 0.00905563f, 
    0.02408284f, -0.02162222f, -0.00335205f, -0.01647522f, -0.02818899f, 0.03751239f, -0.00665409f, -0.00632285f, 
    0.03175958f, -0.03135144f, 0.02958861f, -0.00049723f, -0.04690003f, -0.02348650f, -0.02678239f, 0.00627724f, 
    -0.00902433f, -0.04037116f, 0.01792747f, -0.05890657f, -0.02598112f, -0.02711260f, -0.03913503f, 0.01757010f, 
    -0.01482188f, 0.00809537f, 0.00826749f, 0.02739434f, 0.00053376f, -0.05412493f, 0.02025271f, -0.01283735f, 
    -0.05630225f, 0.00350312f, -0.00960174f, 0.01517278f, 0.01169571f, 0.03789720f, 0.00962707f, -0.02241486f, 
    0.01363335f, 0.03331756f, -0.05136615f, -0.02366404f, -0.00277436f, -0.05497826f, 0.00302503f, 0.05468582f, 
    0.01161144f, -0.02193290f, 0.02969659f, -0.04813510f, 0.03692069f, -0.01469281f, 0.02570381f, -0.02506034f, 
    -0.04552984f, -0.02274000f, -0.03822400f, -0.05758217f, -0.02472910f, -0.00810892f, -0.02344781f, -0.04500822f, 
    0.04734572f, -0.04667367f, 0.01276368f, -0.01050960f, -0.01646365f, -0.01333923f, -0.02015831f, -0.00123952f, 
    -0.00825700f, -0.04862741f, 0.02761557f, -0.01022208f, -0.01309033f, -0.05460009f, 0.01151762f, -0.05403632f, 
    -0.05201237f, -0.02631018f, -0.00909555f, -0.02182650f, 0.01352883f, 0.03353876f, 0.02950172f, -0.01643805f, 
    -0.04128522f, -0.05156813f, 0.02582912f, -0.03149260f, -0.02949585f, 0.00610214f, -0.02731192f, -0.01882865f, 
    -0.02565737f, 0.00165068f, 0.03647871f, 0.03248014f, 0.02335708f, 0.02332707f, -0.04168929f, 0.04025920f, 
    0.02894399f, -0.01837201f, 0.02027624f, -0.02400099f, -0.02598462f, -0.01627962f, 0.01491258f, 0.03830300f, 
    -0.01167639f, -0.03259154f, -0.00811680f, -0.04672956f, 0.02309210f, 0.01052339f, -0.00480207f, -0.04197564f, 
    0.02279345f, -0.02800451f, 0.00435560f, -0.00801174f, -0.03465278f, -0.01184439f, -0.04219576f, -0.00997126f, 
    0.03409373f, 0.01800794f, 0.01263108f, 0.00431589f, 0.03883888f, -0.02993295f, -0.00290321f, 0.02203439f, 
    0.04097249f, 0.02184074f, -0.00273435f, -0.02285876f, -0.00202447f, 0.04323650f, 0.00689667f, 0.01392122f, 
    -0.00723826f, -0.00235546f, -0.00545092f, -0.01476963f, 0.02813531f, -0.00307709f, 0.04016494f, -0.03829927f, 
    -0.04139698f, -0.00294214f, -0.00281714f, -0.02579935f, -0.05163755f, -0.01430403f, -0.02710382f, -0.00001387f, 
    0.02740191f, 0.00047384f, -0.03988220f, 0.02341136f, -0.04055111f, 0.03428646f, 0.00371581f, -0.02846138f, 
    -0.00066300f, -0.05676992f, 0.04004263f, 0.02297258f, -0.04506884f, 0.00619706f, 0.03553668f, -0.03701818f, 
    0.04475915f, 0.00573892f, 0.02833383f, 0.03292498f, -0.03980987f, -0.04256307f, -0.00751972f, 0.01492502f, 
    0.01324368f, -0.04369004f, -0.05324990f, 0.02318489f, 0.00334555f, -0.02358790f, 0.01234018f, 0.00376316f, 
    0.03923441f, -0.05411546f, 0.04314115f, -0.03819878f, 0.04311466f, -0.03941763f, -0.01666575f, -0.00134761f, 
    0.00354252f, 0.01355694f, 0.02478746f, -0.05974859f, -0.04526901f, -0.02153586f, 0.01555436f, -0.00542553f, 
    0.02232414f, 0.01827094f, 0.03907014f, 0.01520928f, -0.05263142f, 0.02182639f, -0.02312992f, 0.02460937f, 
    -0.00772934f, 0.03217790f, -0.01440833f, -0.04669360f, -0.01534738f, 0.01785995f, 0.01579555f, -0.02025537f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07079253f, -0.05956408f, -0.06401769f, 0.00244789f, -0.02025378f, 0.08279733f, -0.02952957f, 0.03897457f, 
    0.03686695f, 0.00590594f, 0.11289722f, 0.01939420f, -0.05135768f, 0.01171587f, 0.00472249f, 0.03876332f, 
    -0.01980711f, -0.04535639f, 0.02921712f, 0.02052395f, 0.03093660f, 0.08332214f, -0.05053761f, -0.03975606f, 
    0.10425174f, 0.00227844f, 0.04855044f, -0.02380069f, -0.03332772f, 0.03461951f, 0.11699050f, -0.03881881f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.72542578f, 0.13025010f, 0.06765183f, 0.65916961f, -0.07394681f, -0.18019499f, -0.17083079f, 0.06547377f, 
    0.10948744f, -0.14940776f, 0.02856965f, 0.14578474f, 0.01331775f, 0.35713524f, -0.17075412f, -0.04427034f, 
    0.08206788f, 0.13227834f, -0.10339109f, 0.02374806f, -0.06822200f, 0.43514952f, 0.06336088f, -0.11843441f, 
    0.15443455f, 0.12412606f, -0.17358194f, -0.04503549f, -0.37916246f, -0.03968267f, 0.00787159f, 0.16106737f, 
    0.17330433f, -0.44306046f, 0.08957820f, -0.11783780f, 0.05040121f, 0.20021968f, 0.24954866f, -0.04716285f, 
    0.06776867f, -0.24919143f, 0.10768242f, 0.04128755f, -0.13386303f, 0.04659989f, 0.13875864f, 0.08633071f, 
    0.07182807f, -0.26549646f, 0.04738931f, 0.20789558f, 0.11241195f, 0.02417162f, -0.05888045f, 0.02875301f, 
    -0.25922108f, 0.13751137f, 0.46297324f, -0.40412241f, -0.19845288f, -0.09620683f, 0.24628890f, -0.14085977f, 
    0.19120038f, -0.10275511f, -0.12291174f, 0.11667408f, 0.15757895f, -0.13613750f, 0.24157730f, 0.01153477f, 
    0.04260800f, -0.02646722f, 0.02298871f, 0.03470932f, 0.01470710f, 0.41655731f, 0.02997983f, -0.09311349f, 
    -0.00980841f, 0.01414305f, -0.09586271f, -0.19855542f, 0.17342331f, 0.15723807f, -0.03233289f, -0.14459106f, 
    0.01537370f, -0.22678612f, 0.33224282f, -0.22368608f, 0.16659029f, 0.24888383f, -0.03750945f, -0.17607772f, 
    0.28545263f, 0.31370124f, -0.05068880f, 0.30120298f, -0.02598428f, -0.17646936f, 0.03461921f, 0.04491320f, 
    -0.12751110f, -0.03498128f, -0.03361107f, -0.25296989f, -0.11676687f, 0.33545065f, -0.10755537f, 0.12255751f, 
    -0.02717826f, 0.23414594f, -0.14904131f, -0.04751094f, -0.04416876f, 0.30864194f, -0.08550736f, -0.12022314f, 
    0.28170490f, -0.18443005f, -0.33015776f, 0.20629750f, -0.17770696f, 0.37120175f, 0.02046371f, -0.10199220f, 
    0.00339744f, 0.21277229f, 0.02591595f, -0.06200116f, -0.17564091f, -0.14150868f, 0.18421066f, 0.11653772f, 
    0.06806718f, 0.15862159f, 0.02363344f, 0.43244752f, 0.08237596f, 0.18096931f, 0.02074713f, -0.12642020f, 
    -0.07793443f, -0.05126982f, -0.16050088f, 0.00042216f, -0.14741863f, 0.40105614f, 0.01979918f, -0.16463900f, 
    -0.06253222f, -0.19644836f, 0.04181111f, -0.19440013f, -0.17074811f, 0.02755214f, -0.11253380f, 0.18143858f, 
    0.02234019f, 0.09039050f, 0.09176003f, -0.07719782f, -0.05128266f, -0.12569872f, -0.15437280f, 0.00728810f, 
    0.09635928f, -0.06357804f, -0.12976907f, -0.15792897f, 0.07217346f, 0.07514993f, -0.03686243f, 0.12740472f, 
    0.03679907f, -0.07839198f, 0.01282644f, 0.00752414f, 0.07341307f, -0.09490851f, -0.13547133f, -0.01623940f, 
    -0.11045987f, -0.10994979f, 0.11305383f, -0.16210045f, 0.15976319f, -0.18031867f, 0.04154611f, 0.17086634f, 
    0.31892616f, -0.05924591f, -0.00956877f, 0.26277569f, 0.06944145f, 0.10400172f, 0.11483237f, -0.04191202f, 
    0.09132346f, -0.09171529f, -0.23753983f, -0.15395479f, 0.03614596f, 0.18570884f, -0.03785592f, 0.16011629f, 
    0.04528787f, 0.21921822f, -0.13846344f, 0.06832574f, -0.13463223f, -0.09675085f, -0.16642335f, -0.12645669f, 
    0.32873458f, 0.29660925f, 0.40235403f, -0.14113234f, 0.21791442f, 0.14057989f, -0.08985481f, 0.16632624f, 
    0.23091660f, -0.00159373f, -0.18253900f, 0.06375943f, 0.00228609f, 0.02095955f, 0.25490251f, 0.09879190f, 
    0.15725565f, -0.28582716f, 0.38245642f, -0.04492953f, 0.07974423f, -0.26558226f, -0.11819034f, -0.00138383f, 
    0.02302813f, -0.31843281f, -0.07017617f, -0.27183965f, -0.03469535f, 0.08929957f, -0.17011130f, -0.04994044f, 
    -0.02988526f, 0.01175870f, -0.22715572f, -0.21466184f, -0.34007865f, 0.15202491f, 0.10789555f, -0.17337711f, 
    -0.21643364f, 0.05470318f, 0.04134990f, 0.36393857f, 0.09946324f, 0.01518993f, 0.32206845f, -0.15761031f, 
    -0.04392411f, -0.10472221f, 0.34354302f, 0.07507534f, -0.07413562f, 0.37320638f, -0.12679739f, -0.16280645f, 
    -0.07141320f, -0.03761840f, -0.15214482f, -0.33311450f, -0.04330499f, 0.05185359f, -0.08194091f, -0.07890693f, 
    0.03928766f, -0.08594981f, -0.25208476f, -0.06003059f, 0.19670700f, -0.08680627f, -0.46144289f, 0.08550505f, 
    0.22603644f, -0.15712419f, 0.05030570f, 0.28273657f, -0.04039640f, -0.24862637f, 0.11969802f, 0.02784646f, 
    -0.10508446f, -0.04462982f, 0.19098136f, -0.27327073f, -0.08788894f, 0.09958790f, 0.10216663f, 0.06745219f, 
    -0.13864015f, 0.26531413f, 0.02570189f, 0.08676717f, -0.16721359f, -0.03645230f, -0.06397027f, -0.10186109f, 
    0.02334075f, -0.31618249f, -0.18872705f, 0.21358344f, 0.18328826f, 0.46114549f, 0.19680658f, -0.03956611f, 
    -0.29853082f, -0.04450513f, -0.03546201f, -0.44323555f, -0.12167176f, 0.33166558f, 0.41716173f, -0.15510298f, 
    0.09381283f, 0.11035070f, 0.29925025f, -0.02901984f, 0.12478822f, -0.17806837f, 0.01820825f, 0.03551966f, 
    -0.06653402f, -0.24669504f, 0.12808065f, 0.24394524f, 0.05408289f, -0.15872547f, 0.13415116f, 0.02913035f, 
    0.36642605f, 0.17628594f, 0.37159207f, -0.17116342f, 0.09556520f, -0.18057792f, 0.16172475f, 0.06691577f, 
    0.18532109f, 0.17005162f, -0.08281212f, 0.30500644f, 0.06982344f, 0.07050820f, 0.09930803f, 0.13478310f, 
    0.09779497f, -0.21924543f, -0.04422899f, 0.29619473f, 0.14506811f, -0.12388144f, 0.07471865f, -0.07863130f, 
    -0.02713627f, 0.50633144f, -0.12880403f, 0.48116228f, -0.10583976f, 0.06367625f, 0.06674642f, -0.09593600f, 
    -0.38150337f, 0.34556493f, 0.46602634f, -0.18754643f, -0.35429981f, 0.08085511f, 0.16773340f, 0.00348692f, 
    0.30447629f, 0.20319125f, -0.12051331f, 0.07471060f, -0.10701268f, 0.05838640f, -0.27117649f, -0.07313576f, 
    0.11567548f, 0.45007309f, -0.19396734f, -0.01880229f, 0.07097834f, 0.03931029f, 0.03972899f, -0.04852609f, 
    -0.03221760f, 0.08679784f, 0.08768304f, 0.31633872f, -0.06282298f, -0.09244050f, 0.01098492f, -0.04312645f, 
    -0.07528340f, 0.23069574f, -0.22952609f, 0.14738256f, -0.27124760f, 0.00982838f, 0.47706458f, -0.16210569f, 
    0.05360229f, 0.09434586f, -0.04689976f, -0.11211295f, -0.12828799f, 0.02222001f, -0.09652086f, 0.16986096f, 
    -0.15588410f, -0.02337630f, 0.22103377f, -0.34120977f, -0.12700292f, 0.33714098f, 0.14360099f, -0.14808056f, 
    0.09875879f, 0.12842523f, 0.03599960f, -0.10154632f, -0.02166808f, 0.12320319f, -0.02459844f, 0.05738135f, 
    -0.27375332f, -0.44203174f, 0.14096682f, -0.08397803f, 0.07373630f, 0.30915430f, -0.01451932f, 0.00540911f, 
    -0.41525805f, 0.46753436f, 0.12932493f, -0.40022594f, -0.05447927f, -0.11003827f, 0.16383062f, -0.10246638f, 
    -0.01171381f, 0.32147944f, 0.16416773f, 0.32956731f, -0.09229145f, 0.13627607f, -0.02391554f, -0.03399575f, 
    -0.02661666f, 0.20727135f, 0.03302146f, 0.19515985f, 0.02694140f, 0.26532474f, -0.10252340f, 0.01360767f, 
    -0.11382661f, -0.25635830f, 0.22001356f, -0.23430330f, 0.20670204f, 0.05926783f, 0.01342016f, -0.07450866f, 
    -0.24525277f, 0.27536485f, 0.00861094f, -0.23693745f, 0.09491164f, 0.04950590f, 0.25019273f, -0.05666151f, 
    0.14362544f, 0.17690608f, 0.04070961f, 0.44776177f, -0.04494205f, -0.25303569f, -0.12202895f, 0.17816006f, 
    0.07441542f, -0.20898089f, -0.16098022f, 0.23820996f, -0.00570868f, 0.26647830f, 0.06792937f, -0.06373771f, 
    -0.03964201f, 0.22454612f, -0.04356346f, -0.12687750f, -0.41039190f, -0.22828966f, 0.15369007f, -0.07062978f, 
    0.00614535f, 0.02648671f, 0.06784199f, -0.14515066f, -0.08717840f, -0.17186545f, 0.12691420f, 0.04990233f, 
    0.10945345f, -0.08504447f, -0.14382502f, -0.09881922f, 0.06981561f, -0.02597469f, -0.16432476f, 0.08833475f, 
    0.06636756f, 0.02001148f, -0.10100393f, -0.06233551f, -0.14430733f, -0.07675656f, 0.03831332f, -0.02156756f, 
    0.12152496f, -0.01057721f, -0.11302257f, -0.05695762f, -0.02501358f, -0.02190819f, 0.04575187f, 0.08808628f, 
    -0.41664609f, 0.35165471f, 0.14549839f, 0.17863098f, 0.11897708f, 0.07533515f, 0.39587557f, 0.10021292f, 
    -0.05282038f, -0.17720185f, -0.02002389f, -0.11511693f, 0.00408473f, -0.00084345f, -0.09256048f, -0.14865001f, 
    0.16774632f, -0.27822888f, -0.04883226f, -0.03997663f, -0.16761971f, 0.20884623f, -0.11082617f, -0.02008565f, 
    0.40322873f, -0.09288242f, -0.50534707f, 0.12088613f, 0.47624150f, 0.27270058f, -0.00547888f, 0.02369724f, 
    -0.13098636f, -0.07157545f, -0.16254458f, 0.34566772f, -0.12485727f, -0.04502193f, 0.40970200f, 0.14613201f, 
    0.09827390f, -0.06158001f, -0.18736656f, -0.20925057f, 0.15076669f, 0.30272070f, 0.13053849f, -0.09397292f, 
    0.02856687f, 0.01031523f, 0.17568757f, 0.14252970f, -0.15293634f, 0.38746497f, 0.06714472f, 0.17599694f, 
    0.27813432f, 0.09905434f, 0.00682546f, -0.20982890f, 0.37505129f, 0.36926115f, -0.02389009f, 0.10389056f, 
    -0.01410524f, 0.32281959f, -0.11347681f, 0.07319644f, -0.14738117f, 0.13281132f, 0.07432574f, 0.01948988f, 
    0.09334602f, -0.19450875f, 0.34475270f, 0.19185002f, 0.15367343f, -0.31034976f, 0.15124038f, -0.17283049f, 
    0.12638512f, 0.38543472f, 0.05324542f, -0.00130025f, -0.01472580f, -0.27928641f, 0.10781505f, 0.14127398f, 
    -0.45225206f, 0.03216764f, -0.05903677f, 0.03922649f, -0.34496751f, -0.08758909f, 0.04177362f, 0.05994029f, 
    0.19766435f, 0.21709086f, 0.06670519f, 0.01588444f, -0.10324465f, -0.01757732f, -0.19332646f, -0.07856660f, 
    -0.09117421f, -0.17563692f, 0.23426379f, -0.33029619f, -0.09691746f, 0.38796589f, 0.04845225f, -0.08495666f, 
    0.17542112f, 0.53021580f, 0.11420891f, -0.17449521f, 0.16678295f, 0.08043417f, 0.03608409f, 0.06993401f, 
    -0.09011608f, -0.14571179f, 0.32947901f, 0.25607827f, 0.38247055f, 0.27151927f, -0.18489642f, 0.07121290f, 
    0.05998624f, -0.32837474f, 0.13772982f, 0.22038847f, -0.14303531f, -0.10102950f, -0.01723698f, 0.13536566f, 
    0.10747670f, -0.09538196f, 0.17938495f, -0.24559155f, 0.07943571f, 0.01644945f, 0.16547731f, -0.15201123f, 
    0.03893439f, 0.59014773f, -0.11637311f, 0.28824189f, -0.15778875f, -0.33378929f, -0.13018413f, 0.09967050f, 
    -0.28347272f, -0.00880812f, 0.19888835f, 0.38196900f, -0.02945380f, 0.18574291f, 0.22820665f, 0.06170374f, 
    -0.31984314f, 0.31688112f, -0.09462961f, 0.07645336f, -0.03670464f, -0.08067472f, -0.07255148f, -0.01483702f, 
    0.03730089f, 0.40474787f, 0.16220234f, -0.08920688f, 0.03693464f, -0.20521356f, -0.14791420f, 0.14359796f, 
    -0.12996599f, 0.43015692f, 0.10297270f, 0.07556188f, -0.07279342f, -0.41630414f, -0.07720108f, 0.17474721f, 
    -0.00942503f, 0.18175279f, -0.37457621f, 0.50133425f, 0.30778351f, 0.04131447f, 0.29674301f, -0.00828470f, 
    -0.00826990f, -0.15106034f, 0.01238284f, -0.21146618f, 0.06813308f, 0.40432584f, -0.14627561f, -0.06241088f, 
    0.17463537f, 0.04596612f, 0.19524558f, -0.15472609f, -0.06405181f, 0.11630497f, -0.15095225f, 0.15795322f, 
    0.03625543f, 0.19070774f, -0.14402162f, -0.28297728f, -0.15584299f, -0.29077536f, -0.12539263f, -0.04038030f, 
    -0.05102248f, 0.23514399f, 0.27933013f, 0.12428954f, 0.45582661f, -0.13243295f, -0.14624795f, -0.12058978f, 
    0.48857069f, -0.26656950f, -0.02572728f, 0.31688386f, -0.12745905f, 0.17345227f, 0.05387824f, -0.11918140f, 
    0.06262581f, -0.07493389f, 0.11171817f, -0.10448900f, 0.12579772f, 0.12994660f, 0.02400939f, -0.16335589f, 
    -0.01704827f, -0.24276099f, 0.08595241f, -0.25412428f, -0.09881154f, 0.15369868f, 0.07977347f, -0.15264097f, 
    -0.13989034f, 0.11630776f, -0.30998996f, -0.01259526f, -0.28598383f, 0.24318111f, 0.13779354f, -0.16193192f, 
    0.01729316f, 0.14021881f, 0.04494696f, 0.09740677f, -0.06475948f, -0.01435992f, 0.18886882f, 0.05843852f, 
    -0.07543354f, -0.30750382f, 0.06511611f, -0.37733486f, -0.11628772f, -0.29640797f, 0.16087075f, 0.10919769f, 
    0.12654656f, 0.39150214f, -0.05891883f, 0.17626710f, -0.06982978f, -0.20171936f, -0.16329110f, -0.09979010f, 
    -0.19661029f, 0.27380067f, 0.26792690f, -0.10701362f, 0.30322054f, 0.15495083f, -0.11348620f, -0.00086443f, 
    -0.00628912f, -0.02399399f, -0.05989541f, -0.61118662f, -0.14482908f, 0.08740572f, -0.07220247f, -0.13561180f, 
    0.02105566f, 0.17516258f, 0.34040758f, -0.40199935f, 0.11593156f, 0.07642559f, 0.02256679f, -0.06214599f, 
    0.09239392f, -0.29180512f, -0.14228015f, -0.09633580f, -0.11818334f, 0.20022376f, -0.16291499f, -0.08564889f, 
    -0.01328015f, 0.03196997f, 0.29943171f, -0.15938613f, -0.12039685f, -0.11157517f, -0.05965704f, -0.05132371f, 
    0.21427336f, -0.12679055f, 0.08375073f, 0.20741093f, -0.04438901f, 0.36973506f, -0.34160301f, -0.05743037f, 
    0.06000596f, 0.19167764f, 0.19936343f, 0.14942345f, -0.05917367f, -0.09603573f, 0.08070466f, -0.10982566f, 
    -0.08247354f, -0.21896081f, 0.06367708f, -0.02692805f, -0.10811023f, -0.27813342f, 0.00228967f, -0.12949269f, 
    -0.14338365f, 0.12532224f, -0.34093618f, 0.31637537f, 0.08812769f, 0.06810305f, 0.31080008f, -0.16283247f, 
    -0.02796591f, -0.22182281f, -0.04473586f, -0.16610295f, 0.16019599f, 0.33087245f, -0.13187130f, 0.10143095f, 
    0.10099704f, 0.34029448f, 0.08646630f, -0.00350785f, 0.14048596f, -0.00067688f, -0.13410082f, 0.00529343f, 
    0.12918583f, -0.53454548f, 0.07903676f, 0.01873051f, -0.07492306f, 0.15483919f, 0.03997828f, 0.16391943f, 
    0.30349079f, -0.04076543f, 0.08205140f, -0.17500855f, -0.15675196f, 0.09213628f, 0.06839883f, 0.00103639f, 
    0.11110981f, 0.03079609f, 0.11196221f, 0.08973913f, 0.00582951f, 0.15463255f, 0.35464287f, 0.04100428f, 
    -0.05787735f, 0.12827021f, 0.01445735f, 0.21713577f, 0.02963114f, -0.22713621f, -0.12839407f, -0.02840200f, 
    0.09795724f, -0.49866608f, -0.02636824f, 0.06809623f, 0.00668689f, 0.11396407f, -0.06756632f, -0.03078326f, 
    0.35950255f, 0.23518687f, -0.27635732f, -0.27425772f, -0.17724016f, -0.25755706f, 0.12257300f, -0.12975693f, 
    0.24111171f, -0.15233782f, -0.06517150f, -0.13230570f, -0.17080873f, 0.24886659f, -0.17955786f, -0.03093629f, 
    0.11329459f, 0.17642583f, -0.16079374f, -0.24053447f, 0.12088469f, 0.04417725f, -0.03149123f, -0.14891636f, 
    0.09732642f, -0.45043012f, -0.11693795f, 0.04986498f, -0.08028508f, 0.30884182f, -0.09079996f, 0.03671337f, 
    0.11431672f, -0.09646846f, 0.26361093f, -0.19844279f, 0.17216566f, 0.20010568f, 0.19184524f, -0.05700692f, 
    -0.35677090f, 0.15746249f, -0.13598472f, 0.10969341f, 0.09637630f, 0.23196164f, 0.09085275f, -0.17107315f, 
    0.10590121f, 0.25200394f, -0.28842804f, -0.01976407f, 0.16511200f, 0.29637143f, -0.12954929f, 0.10305768f, 
    0.03566752f, 0.06432521f, -0.11619849f, 0.00775000f, -0.10971627f, 0.22649229f, -0.17041713f, -0.09364308f, 
    0.19475396f, 0.02238437f, 0.13319075f, -0.02781044f, 0.31532475f, -0.01526649f, 0.13329171f, -0.15993626f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.09807163f, -0.04389849f, -0.02560262f, -0.06819037f, 0.06615909f, 0.14418873f, -0.05889474f, 0.10379490f, 
    -0.09934226f, 0.05311002f, 0.06910355f, -0.20538612f, -0.03279147f, 0.08233135f, -0.10844312f, 0.19924560f, 
    0.05054241f, 0.03070083f, 0.07346785f, 0.09697454f, 0.09096345f, 0.16171470f, 0.12489928f, 0.21211374f, 
    0.00016858f, -0.02917957f, 0.06569032f, -0.03109014f, 0.10429303f, -0.01202865f, 0.19222519f, -0.07671658f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.44101772f, -0.37018120f, -0.63464779f, -0.13236673f, -0.36783376f, 0.14070360f, -0.04938773f, -0.41683656f, 
    -0.07337690f, 0.04629714f, 0.10895513f, -0.00114385f, -0.08023527f, -0.36930946f, 0.23867038f, 0.04969803f, 
    0.03722971f, 0.42905468f, 0.15775405f, 0.02319100f, -0.09067103f, -0.04669991f, 0.31351519f, -0.00576368f, 
    -0.67408496f, 0.46342564f, -0.22940220f, 0.03534195f, -0.27347410f, 0.09863896f, -0.20094192f, 0.19318588f, 
    -0.35508981f, 0.15711746f, 0.07314956f, -0.34342158f, 0.27358860f, 0.13078329f, -0.21551372f, -0.14919992f, 
    0.15006207f, -0.57102281f, 0.29938617f, 0.00752811f, 0.22759606f, -0.17059101f, 0.25258282f, 0.38216633f, 
    0.06110689f, -0.16465400f, -0.19962429f, -0.00813314f, -0.42816123f, -0.25988829f, -0.00066029f, -0.10589013f, 
    -0.23168491f, -0.31629375f, 0.14768438f, 0.00035087f, 0.16238584f, 0.33393297f, -0.03615038f, 0.01722931f, 
    -0.33336112f, -0.04647849f, -0.45886531f, -0.35554194f, -0.24463934f, -0.16029379f, -0.53355658f, 0.16222690f, 
    0.11193429f, -0.07567623f, 0.15095513f, 0.06150459f, -0.27696255f, 0.37182835f, 0.34223759f, -0.01030427f, 
    0.08477850f, -0.47262603f, -0.66338891f, 0.31965196f, 0.26879573f, 0.23624775f, 0.05813215f, 0.26647323f, 
    -0.25685412f, -0.04644870f, 0.34565368f, 0.08100054f, -0.00247043f, -0.33013180f, -0.46930081f, -0.19175594f, 
    0.12075193f, -0.23592101f, 0.10286147f, 0.17264177f, -0.02308416f, 0.07215888f, 0.36533606f, -0.32186040f, 
    0.23933914f, -0.22661360f, 0.12177750f, -0.04360845f, -0.68404490f, -0.19796145f, 0.02366094f, -0.43358412f, 
    0.17558961f, 0.07434808f, 0.25112778f, -0.73637021f, 0.24359715f, -0.13955562f, -0.18030830f, 0.18681464f, 
    -0.26005322f, 0.17994617f, -0.04496720f, -0.35500202f, -0.11876982f, -0.04775015f, -0.33228436f, 0.23752232f, 
    0.23276897f, -0.33088714f, 0.05373643f, 0.33619487f, 0.25780374f, -0.16499722f, -0.14787367f, 0.00230804f, 
    -0.21618767f, 0.22086112f, -0.21892825f, 0.11986226f, 0.10689899f, 0.18051733f, 0.26361656f, 0.07950887f, 
    0.04992983f, -0.10510366f, 0.10540979f, -0.02104749f, 0.12843277f, -0.06448004f, -0.01313829f, -0.61465633f, 
    -0.05306162f, -0.31263441f, -0.00246175f, -0.19483036f, -0.12471999f, -0.07980815f, 0.00687538f, -0.00562485f, 
    0.20581007f, -0.29048538f, -0.50207293f, -0.00622740f, -0.06438514f, 0.08276620f, 0.09751573f, -0.21718663f, 
    -0.30523741f, -0.19747770f, -0.11602028f, -0.16852850f, 0.22755899f, -0.38584399f, -0.22052102f, -0.05143872f, 
    -0.07588013f, 0.07357233f, 0.02645962f, -0.37133899f, -0.23905431f, -0.20633715f, 0.00477785f, 0.10472097f, 
    0.24300632f, -0.83851629f, -0.02926631f, 0.25659028f, 0.31079543f, 0.17434591f, 0.42877179f, 0.33224228f, 
    0.28649613f, 0.07283463f, -0.32274112f, 0.13948920f, -0.13592921f, 0.15660582f, -0.09957425f, 0.40347156f, 
    0.17029765f, 0.14933260f, -0.13816078f, 0.27312389f, 0.06509414f, -0.59239054f, -0.64238733f, 0.08589960f, 
    -0.06163096f, -0.03460703f, 0.08893352f, 0.27609944f, -0.29066190f, 0.24193241f, -0.02636382f, -0.44098240f, 
    0.34400600f, 0.05956069f, -0.65047520f, 0.11567947f, -0.33558097f, 0.26235133f, -0.44067892f, -0.39457801f, 
    0.23841229f, -0.27446458f, 0.18745975f, 0.25263706f, 0.28234375f, 0.09589425f, -0.20361312f, 0.06897578f, 
    0.40078333f, 0.10528279f, -0.57913089f, -0.23555902f, -0.28711116f, 0.20545077f, 0.18874040f, 0.01107952f, 
    -0.11135583f, 0.26817003f, 0.24074395f, 0.20578878f, 0.14998692f, -0.43633953f, -0.32395110f, -0.37950087f, 
    0.20060314f, -0.27444887f, -0.26532510f, -0.15820551f, -0.40596008f, -0.17820267f, -0.38423339f, -0.01860745f, 
    0.20784856f, 0.36879250f, -0.04438730f, -0.42508170f, -0.00323733f, 0.06374902f, 0.12530161f, 0.29438069f, 
    -0.12550148f, -0.59674257f, 0.08905031f, 0.21446319f, -0.32510638f, -0.12937407f, -0.10101968f, -0.07310601f, 
    0.05703801f, -0.48503193f, -0.22694868f, 0.16244255f, -0.01803495f, -0.43109441f, -0.63514358f, 0.26957962f, 
    0.05320241f, 0.35294083f, 0.36373997f, -0.03773494f, 0.00410586f, 0.16836868f, 0.19716592f, -0.44673419f, 
    0.08248102f, -0.33153191f, -0.05938981f, 0.09418729f, -0.64089948f, 0.08460540f, 0.07410745f, -0.37403545f, 
    -0.01543305f, 0.15518616f, -0.27536401f, 0.04227380f, 0.20444512f, -0.01885426f, -0.14241560f, -0.60309416f, 
    -0.11085292f, -0.41005707f, -0.39135680f, 0.30755267f, 0.27385509f, 0.31065181f, 0.28975034f, 0.33415818f, 
    -0.05680507f, -0.05430754f, -0.24845569f, 0.22319523f, -0.24889694f, -0.51763391f, -0.36290461f, -0.21750742f, 
    -0.33550736f, -0.16678619f, 0.16221111f, 0.07980935f, -0.29073825f, 0.16908422f, -0.26230055f, 0.54651088f, 
    0.24409953f, 0.28505641f, 0.13377492f, -0.75884366f, -0.55944228f, 0.19427362f, -0.14629652f, -0.50872976f, 
    0.14181633f, 0.21963941f, 0.10703778f, 0.00655376f, 0.01991275f, -0.16519177f, -0.08828028f, 0.22130795f, 
    0.33392429f, -0.26290005f, 0.30667728f, 0.10687415f, 0.20414490f, 0.09166362f, 0.14238153f, -0.24418627f, 
    -0.08323047f, 0.46725726f, 0.17215329f, -0.14537992f, -0.38318908f, 0.06774028f, 0.25005364f, -0.37907460f, 
    -0.23767094f, 0.09831979f, 0.01275785f, 0.19441348f, -0.19864583f, -0.02922260f, -0.08727730f, -0.51898617f, 
    0.09159242f, -0.40788534f, 0.27127323f, -0.58695984f, 0.10764904f, 0.35991517f, -0.34932262f, -0.05756024f, 
    0.05651902f, 0.17565948f, -0.00714906f, -0.00461356f, 0.06027539f, -0.34592381f, 0.35493949f, 0.07791827f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.06944360f, -0.09703334f, -0.12149121f, 0.13941942f, -0.10924342f, -0.07429063f, -0.16442390f, -0.16215552f, 
    -0.02302352f, -0.00720224f, 0.05483785f, -0.02456674f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
