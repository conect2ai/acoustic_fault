#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.02606079f, -1.88418055f, 0.75001442f, 1.08091378f, -0.78450519f, 1.08607876f, -0.16473579f, -0.15723352f, 
    -0.32372350f, -1.45285594f, 1.68452621f, -1.19754171f, 0.95446724f, -0.81537390f, -0.86588442f, 0.08172669f, 
    -0.26943061f, 0.08405058f, 1.11539078f, -1.13871861f, -0.98918658f, -0.07483798f, -0.46024910f, -0.98932213f, 
    -0.87591076f, 0.42192370f, -0.57939434f, 0.03510186f, -1.40392089f, -0.67176968f, 1.20425606f, -0.12790169f, 
    -1.00438535f, -0.33229741f, -0.50622618f, -0.13214983f, -0.70096594f, -1.45382512f, -0.02272767f, -0.86455685f, 
    -0.62554067f, 0.91925395f, -0.09276172f, -0.32332212f, -0.20884392f, -1.15650010f, -1.76134348f, -0.88986045f, 
    -0.01276169f, 1.28316462f, 0.67258012f, -0.00242151f, -0.33246708f, -0.41694748f, 1.18760598f, -0.51422739f, 
    -1.19918466f, 0.63887632f, -1.08894634f, -0.51164788f, -0.47772980f, -0.76306707f, 0.85109836f, 1.82269859f, 
    0.85859048f, -0.12230373f, -0.21624708f, 0.80268949f, 0.15032391f, 0.00558623f, 0.47829953f, 0.76178402f, 
    1.53707361f, 1.08593833f, 1.37842238f, 0.29299894f, 0.05348422f, 0.06001441f, 0.60728657f, 0.33388910f, 
    -0.61480570f, 0.09528591f, -1.44347167f, -0.83120424f, 0.16985272f, 1.65046000f, -0.47872072f, 0.63216627f, 
    0.79393935f, -0.32803950f, 1.38201761f, -0.36717412f, 1.43074059f, -0.53667498f, 0.32314649f, 0.66567230f, 
    -0.91141647f, -0.45581421f, -0.65297598f, -1.11014426f, -0.80251324f, 0.00144340f, -0.94287223f, -0.58583772f, 
    -1.54208338f, 0.66883445f, 0.20812418f, 0.12537678f, 0.83855146f, -0.92640728f, -0.19649412f, 1.14075661f, 
    1.22655702f, 1.22178137f, -0.76397038f, -0.06014961f, -0.75667995f, 0.54379070f, 1.46396005f, 1.53910148f, 
    -2.13251162f, 0.16083841f, -0.95046622f, 0.00657189f, 0.33114788f, -0.31859818f, -2.08343983f, 0.88571632f, 
    1.29519379f, 0.50196236f, 0.66919708f, 0.77858371f, 0.22593230f, 0.48867205f, -0.25826594f, -1.08638966f, 
    0.39116153f, -0.62864649f, -1.62678456f, 0.36884743f, 0.48293194f, 0.75414783f, 0.42921057f, 0.21382473f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08155029f, -0.01993666f, 0.42749685f, 0.10617236f, 0.34397623f, 0.43680000f, 0.34959686f, 0.58425772f, 
    0.26163244f, 0.68925560f, 0.08913974f, 0.30825639f, -0.06228680f, 0.01865930f, 0.40221617f, 0.52757728f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.36246800f, -0.03519791f, -0.00277837f, -0.03919849f, -0.85175711f, 0.07663117f, 0.21732536f, 0.12167878f, 
    0.10729944f, 0.03039028f, -0.04832237f, -0.04535379f, -0.06829704f, -0.03138601f, -0.05245775f, 0.02339845f, 
    0.09046590f, 0.15303607f, 0.00036389f, 0.07354338f, 0.85185450f, -0.18235590f, 0.08897715f, -0.00747491f, 
    0.12510426f, -0.14965135f, -0.23684879f, 0.09067437f, -0.08261456f, -0.07602471f, 0.14830312f, 0.13239501f, 
    -0.08111473f, 0.13335529f, 0.08158545f, 0.02978489f, -0.11173676f, 0.19795290f, -0.19592769f, -0.19982253f, 
    0.12845780f, -0.82887042f, 0.25514030f, 0.08590402f, -0.10290056f, 0.00750986f, -0.12640463f, -0.01838879f, 
    -0.08805974f, 0.06843477f, -0.25853065f, 0.08454214f, 0.06311019f, -0.03049985f, 0.06908480f, -0.12108663f, 
    -0.03830642f, -0.08677782f, 0.01647751f, 0.10643335f, 0.00833974f, -0.35406062f, 0.18648337f, 0.23222013f, 
    -0.13288261f, 0.03901618f, -0.09071834f, 0.17080672f, 0.01243190f, -0.08458697f, 0.02691248f, 0.04124956f, 
    0.01879382f, 0.11583140f, 0.10116395f, 0.11716538f, 0.09856608f, 0.11642507f, -0.17084338f, 0.04892424f, 
    -0.26320693f, 0.02662727f, -0.19560848f, 0.19773720f, -0.55883670f, -0.10363154f, 0.01690837f, -0.16632958f, 
    0.10885818f, 0.13296433f, 0.16733040f, -0.11556146f, -0.06204658f, -0.05410448f, -0.03663208f, -0.04951073f, 
    -0.03653635f, -0.16432515f, 0.06110376f, 0.15295099f, -0.24947008f, 0.33998346f, 0.04193041f, -0.49868464f, 
    -0.82553583f, 0.13355775f, 0.21301189f, -0.00436555f, 0.19130096f, 0.02425752f, 0.05942883f, -0.18647112f, 
    0.00885188f, 0.15845308f, -0.12138160f, 0.00304998f, -0.00323959f, -0.01898118f, -0.03264034f, -0.05416398f, 
    0.14372981f, -0.73277760f, 0.21464644f, 0.27313241f, 0.01256107f, -0.00854488f, 0.22649965f, 0.03060428f, 
    0.07630458f, -0.06640137f, -0.21993273f, 0.06503902f, -0.03388411f, 0.07070379f, -0.08479224f, 0.16246144f, 
    0.01796838f, -0.00664922f, -0.09673855f, -0.13131028f, -0.10624372f, -0.08428101f, -0.08916100f, -0.31367305f, 
    0.31220898f, -0.16152388f, -0.13707022f, -0.17438549f, 0.24442157f, -0.02530453f, -0.07087383f, 0.04020096f, 
    0.06121913f, -0.03218034f, -0.09573334f, -0.07870355f, 0.00188930f, -0.07529148f, -0.00745189f, 0.01700447f, 
    0.27788699f, 0.08523252f, -0.11151388f, -0.29390967f, 0.37222663f, -0.35024974f, -0.27686843f, -0.00301591f, 
    0.14055245f, 0.00985499f, -0.03598675f, 0.13890100f, -0.13445449f, 0.05227275f, 0.03389058f, -0.08028288f, 
    -0.15973757f, 0.12551430f, 0.08250911f, 0.12073209f, -0.39851511f, 0.18052171f, -0.08500323f, -0.17565571f, 
    -0.27009746f, -0.20775910f, -0.00058348f, 0.01794175f, -0.04371942f, 0.02491330f, -0.07732967f, 0.24969460f, 
    0.00609640f, 0.01590824f, -0.02390986f, -0.01283597f, -0.00625648f, 0.15133248f, 0.02562268f, -0.11040799f, 
    0.49043268f, -0.07421892f, -0.21441184f, 0.31934008f, -0.06449973f, -0.30770469f, -0.15082245f, 0.04038415f, 
    0.15058178f, -0.08712281f, 0.02497754f, 0.13145493f, 0.20375256f, -0.18300155f, 0.04296742f, 0.15634367f, 
    0.11657242f, 0.04505508f, 0.02347386f, 0.21886979f, -0.55430639f, -0.96708024f, -0.16373789f, 0.23926257f, 
    -0.16120529f, -0.01577707f, -0.16212209f, -0.09721453f, 0.13745666f, 0.10429743f, 0.00523359f, 0.14173505f, 
    -0.21206290f, -0.11990046f, -0.00633504f, 0.15942501f, -0.21420260f, -0.03908344f, 0.25120589f, -0.02101690f, 
    0.21928778f, 0.39951059f, -0.01014351f, -0.02448849f, 0.01746470f, 0.07980353f, 0.17923628f, 0.04937345f, 
    -0.03322482f, -0.25586435f, -0.01318399f, 0.00837895f, 0.16847308f, -0.06052327f, -0.03946532f, 0.18875934f, 
    0.17791799f, -0.06545397f, -0.11275874f, 0.12081619f, 0.13754845f, 0.10203353f, -0.08863509f, -0.00006311f, 
    0.23638368f, -0.20947903f, -0.16566166f, -0.29805249f, -0.01946758f, 0.15789607f, -0.02295932f, -0.03434641f, 
    -0.15177013f, -0.10100995f, 0.04370145f, -0.10024808f, 0.11652850f, -0.01014071f, 0.01455292f, -0.11325173f, 
    -0.16408920f, 0.00087945f, 0.50383550f, 0.22389460f, 0.15872847f, -0.01956937f, -0.12514092f, 0.14483051f, 
    -0.05699399f, -0.11187749f, 0.11257171f, -0.09029944f, 0.02266255f, -0.00852374f, 0.02303164f, 0.02702196f, 
    -0.13675040f, -0.17166376f, 0.03600260f, -0.09157050f, -0.60312259f, -0.04974147f, -0.05358050f, 0.11494494f, 
    -0.10518344f, -0.05423141f, -0.20871851f, -0.07427757f, 0.02202265f, -0.16335072f, -0.07663696f, 0.01800852f, 
    0.02991963f, 0.06150680f, 0.12689885f, -0.10090404f, -0.02133307f, 0.15170835f, -0.21423987f, -0.26398095f, 
    -0.25654116f, 0.10368256f, -0.01596275f, 0.02742245f, -0.51185519f, 0.11106667f, 0.12457927f, 0.11165123f, 
    -0.01020505f, 0.30633128f, 0.16469635f, 0.10967522f, 0.05658661f, 0.01996913f, 0.18056248f, -0.00786600f, 
    0.16608916f, -0.05559741f, 0.01310431f, -0.02553847f, -0.65103239f, -0.33723560f, -0.18751921f, -0.36491224f, 
    0.40327716f, 0.05387511f, -0.03500243f, 0.09991515f, -0.13181424f, -0.04809766f, 0.07933118f, 0.08364325f, 
    0.09813504f, -0.23885030f, 0.04365576f, -0.09756041f, -0.08644524f, -0.15843976f, 0.06597117f, 0.03047409f, 
    0.27606067f, -0.45282695f, 0.17172176f, -0.40059474f, 0.04604992f, 0.01272197f, 0.07409902f, 0.10941642f, 
    0.03789515f, 0.03445181f, -0.12127018f, -0.10144257f, 0.04914666f, 0.14000016f, -0.21514344f, -0.02045621f, 
    0.00007028f, -0.28640124f, -0.10788404f, -0.00762097f, 0.24120019f, -0.07310668f, -0.22351414f, -0.22322056f, 
    -0.50187856f, 0.24129388f, -0.11366035f, -0.20217949f, 0.07146045f, -0.05632919f, -0.10416405f, -0.19280837f, 
    0.04730508f, -0.10517246f, -0.02128906f, -0.04918121f, 0.04635007f, -0.26992527f, 0.06111939f, 0.07032499f, 
    -0.12043621f, -0.00763276f, 0.00600567f, 0.23026618f, -0.33711013f, -0.19399700f, -0.15225542f, 0.09045085f, 
    0.14862731f, 0.10142868f, -0.10035431f, -0.00752841f, 0.01338324f, 0.06402194f, -0.12560385f, 0.05006738f, 
    -0.07412949f, 0.00472201f, -0.09402656f, -0.20707068f, 0.47743320f, -0.00057569f, -0.40893313f, 0.06596293f, 
    -0.36475813f, -0.21256620f, -0.03346236f, 0.00685630f, -0.11847264f, 0.02071372f, -0.02740302f, 0.07495575f, 
    -0.13302633f, -0.10093044f, 0.10851821f, 0.05972856f, 0.05657487f, -0.00321931f, -0.13501926f, 0.12171870f, 
    -0.16669090f, -0.14553379f, 0.15342094f, -0.40042040f, 0.13033973f, -0.03725498f, -0.13919675f, 0.14854822f, 
    -0.05661920f, 0.05291844f, -0.02877581f, -0.08454317f, 0.00694627f, -0.01694509f, -0.04514069f, -0.18221249f, 
    -0.01705187f, -0.29266047f, 0.19010985f, -0.23780362f, 0.71791136f, 0.27282816f, 0.29361567f, 0.09255019f, 
    -0.07530527f, -0.08829202f, -0.30707356f, -0.02769069f, 0.01022490f, -0.02334234f, 0.05206970f, 0.03900250f, 
    -0.05430076f, 0.03564632f, 0.02031600f, -0.00029666f, 0.00444829f, 0.09405286f, -0.06721454f, -0.03805684f, 
    0.15731330f, 0.20311438f, 0.38977239f, 0.24783896f, 0.20824967f, -0.24618110f, -0.03082114f, 0.09657764f, 
    -0.01110778f, -0.02287364f, -0.13335800f, -0.13890626f, 0.08254264f, 0.10581145f, -0.14244740f, -0.04192812f, 
    0.16026586f, -0.02063262f, -0.10450093f, -0.02666982f, 0.50919050f, -0.61370021f, -0.17611392f, 0.05323450f, 
    -0.10297287f, -0.11807197f, -0.03508083f, -0.05194049f, -0.00094771f, 0.10566598f, -0.01591233f, -0.11212310f, 
    -0.04521633f, 0.02907626f, -0.05939364f, 0.24402528f, 0.03985807f, -0.06174218f, -0.08408084f, 0.15505289f, 
    0.33745494f, 0.28697044f, 0.07267046f, 0.21114865f, 0.14126587f, -0.05079023f, -0.12055424f, -0.05113251f, 
    -0.09654421f, 0.01686989f, -0.00603301f, -0.00098497f, -0.20816243f, -0.06563548f, -0.13424760f, 0.13461500f, 
    -0.04714635f, 0.08348719f, 0.15130150f, 0.03541629f, -0.19437352f, 0.01583723f, -0.07039475f, 0.01227681f, 
    -0.32044783f, 0.09369190f, -0.11139183f, 0.14018477f, -0.04502311f, 0.08506506f, 0.00214602f, -0.06966577f, 
    0.24105114f, 0.09427443f, -0.13658570f, -0.00423573f, 0.19594525f, -0.22726583f, -0.32293966f, -0.20108519f, 
    0.41472551f, -0.39648890f, 0.14616041f, -0.01280218f, 0.08870366f, -0.04324155f, 0.06652302f, -0.09850407f, 
    0.07113055f, -0.07944942f, 0.18477648f, 0.09606788f, -0.07686642f, 0.10058233f, -0.21726677f, -0.10540150f, 
    -0.07343633f, -0.03781559f, 0.15098625f, -0.02750146f, -0.10511152f, 0.16621216f, -0.51076972f, -0.03234334f, 
    0.17727022f, 0.04724995f, 0.02034870f, 0.12670556f, -0.01387070f, 0.06089847f, 0.13529389f, 0.01980287f, 
    0.02271752f, 0.20958783f, -0.10114832f, -0.03284750f, 0.03608477f, -0.04381893f, -0.24421173f, 0.00512608f, 
    -0.64873308f, 0.22458136f, -0.07230876f, -0.07157435f, -0.00928648f, -0.15447994f, 0.11235272f, -0.08170393f, 
    0.04094597f, 0.07978461f, -0.03025260f, 0.10233790f, -0.08444696f, -0.21062224f, -0.07176942f, 0.11351523f, 
    -0.05268269f, 0.25234583f, 0.11579380f, 0.13554053f, 0.29529950f, 0.14750101f, -0.33942479f, -0.10581983f, 
    0.11586901f, -0.02449811f, 0.06222669f, -0.13333002f, 0.15359631f, 0.13921949f, 0.02404004f, -0.27175015f, 
    0.10632581f, 0.07196680f, 0.07034548f, 0.13522640f, 0.00479323f, 0.08996940f, 0.00267625f, 0.03155380f, 
    -0.62894022f, 0.33008152f, 0.15261419f, 0.06953899f, 0.24349073f, -0.23668703f, -0.14337926f, -0.22055161f, 
    -0.10328843f, 0.00528406f, 0.05233308f, 0.01735740f, -0.00479588f, -0.19002144f, 0.22523510f, -0.11907965f, 
    0.16438906f, -0.21092936f, 0.06700742f, 0.07201573f, 0.02878479f, 0.70158404f, -0.07144281f, -0.15548044f, 
    -0.12505461f, 0.15355492f, 0.01073659f, 0.04479868f, 0.05247122f, -0.03449897f, -0.37009236f, 0.00100424f, 
    -0.14003216f, 0.24063770f, -0.14703593f, 0.08652315f, -0.08585828f, 0.36412489f, 0.06607223f, 0.07680850f, 
    -0.63638991f, -0.55417061f, -0.12120647f, -0.39639956f, -0.38173234f, -0.02419080f, 0.03101148f, 0.03416071f, 
    0.01103712f, -0.04601023f, 0.03479151f, 0.09842941f, -0.15915997f, -0.02757650f, -0.07865490f, 0.08053961f, 
    -0.03223336f, 0.03515392f, 0.01239722f, -0.13776024f, -0.30879965f, -0.71854377f, 0.30362844f, 0.06822075f, 
    0.15456539f, -0.14126334f, -0.00964933f, -0.16312902f, -0.07583937f, 0.09073349f, -0.03015226f, -0.04286436f, 
    -0.04181913f, -0.00666675f, 0.01619156f, -0.07957747f, -0.12576897f, -0.19786713f, -0.05130863f, -0.03131332f, 
    0.54909599f, -0.19337663f, -0.24109739f, 0.15770932f, -0.37484816f, -0.26877180f, -0.02853413f, -0.12813841f, 
    -0.00762899f, -0.05500039f, 0.10150393f, 0.12804997f, 0.14786866f, 0.01110531f, -0.05582135f, -0.04974544f, 
    -0.13118409f, -0.03615282f, 0.13813737f, 0.04549464f, 0.48478392f, -0.16709521f, 0.26996267f, 0.22416954f, 
    0.37617368f, -0.18165605f, 0.03339191f, -0.11036742f, -0.00592681f, 0.00553736f, 0.22724923f, -0.01911496f, 
    -0.06695770f, 0.08264691f, -0.07212217f, -0.03702887f, -0.15508044f, 0.08582820f, -0.02110406f, -0.06058202f, 
    -0.53478116f, -0.57518506f, 0.03654812f, -0.19552679f, -0.48261264f, 0.05981598f, -0.22579257f, -0.01724884f, 
    -0.06926169f, 0.06021527f, -0.21595062f, -0.01131439f, -0.01308106f, 0.16340679f, -0.06997908f, -0.05199057f, 
    -0.05016503f, 0.08408669f, -0.13376823f, -0.06553206f, 0.20952792f, 0.25028142f, 0.08996517f, -0.26901576f, 
    0.00284430f, -0.03254739f, 0.03045581f, 0.21778445f, -0.08540361f, -0.06659736f, -0.17457071f, -0.03143973f, 
    -0.03717838f, -0.08979538f, -0.00964843f, -0.04863801f, -0.16983543f, -0.08823128f, 0.10581632f, 0.10001038f, 
    -0.02818065f, 0.02490649f, 0.05861094f, -0.25735614f, 0.08680291f, 0.17506276f, 0.02213365f, 0.16262195f, 
    0.10470714f, -0.15348285f, -0.03651941f, 0.03432890f, 0.09526316f, 0.00097108f, -0.02768815f, 0.13340852f, 
    -0.07167056f, -0.15060920f, 0.03358182f, -0.06406783f, 0.45131961f, -0.30157906f, 0.43733269f, -0.12414644f, 
    0.06013707f, -0.20598054f, -0.10972799f, 0.09825373f, -0.06476024f, 0.00510692f, 0.13862656f, -0.15636107f, 
    0.14316501f, 0.01229390f, -0.02769126f, 0.08923811f, -0.09532437f, 0.07603952f, -0.11888899f, -0.02111170f, 
    -0.50108248f, 0.10204997f, -0.22262636f, -0.33231497f, 0.02413368f, 0.07443257f, -0.01469633f, 0.13365692f, 
    0.20744875f, -0.13805890f, -0.12357573f, 0.06003381f, -0.05276509f, 0.11855429f, 0.01778144f, -0.22069667f, 
    -0.02658909f, 0.01531348f, -0.08193295f, -0.21852458f, 0.41273943f, -0.37273964f, -0.06953751f, -0.04050790f, 
    -0.51242018f, 0.02384038f, -0.12003186f, -0.37411505f, 0.09356326f, -0.08810111f, -0.02336364f, 0.01711998f, 
    0.07898664f, -0.19615713f, -0.07366416f, -0.00001339f, -0.07469434f, 0.16618311f, 0.10282398f, -0.16667612f, 
    0.17177930f, 0.15666859f, 0.27253529f, 0.26262370f, 0.20270990f, 0.13431092f, -0.18827653f, 0.00673855f, 
    0.28076956f, 0.14344175f, 0.01705392f, -0.01236184f, 0.05779267f, 0.11010634f, -0.04002973f, -0.18487988f, 
    -0.07418007f, -0.02467197f, -0.08586249f, 0.00436815f, 0.25990266f, 0.36407289f, -0.48232022f, -0.36422470f, 
    -0.12132666f, 0.13621303f, 0.23102932f, 0.07836464f, -0.14033122f, -0.14802900f, 0.00936583f, -0.00958515f, 
    -0.14084809f, -0.11288153f, -0.05091205f, 0.15269464f, 0.17826124f, -0.10363697f, -0.12827052f, 0.01769383f, 
    0.60963565f, 0.17654502f, -0.11751002f, -0.07857839f, 0.11374279f, -0.16183051f, -0.04178783f, 0.07676145f, 
    0.08820710f, -0.08498940f, -0.21566880f, 0.04792469f, -0.06834991f, -0.06340925f, -0.01982101f, 0.05884352f, 
    -0.10360248f, -0.29450408f, 0.09390218f, -0.11028777f, 0.47331059f, -0.01929719f, -0.09095712f, -0.17201778f, 
    -0.36124164f, 0.19676389f, 0.36350262f, -0.00543442f, -0.10676280f, 0.07232621f, -0.11833942f, 0.07256802f, 
    -0.11865798f, 0.05775121f, -0.00419883f, -0.07292475f, -0.02706502f, 0.01084140f, 0.08206774f, 0.02703704f, 
    0.39896223f, 0.06924196f, 0.08989744f, -0.08628061f, -0.06689905f, -0.03012790f, -0.01845573f, -0.10467935f, 
    -0.04152174f, 0.17357120f, 0.02822952f, 0.05653568f, 0.09355139f, -0.11449917f, -0.16941205f, 0.01755661f, 
    0.12287379f, -0.14218524f, 0.08550760f, -0.00690443f, 0.94195408f, 0.53911853f, -0.27570903f, 0.11403956f, 
    0.05441643f, 0.06166929f, -0.06601971f, -0.04224030f, 0.14628193f, 0.07951687f, -0.12219943f, -0.03186934f, 
    -0.35926479f, 0.04507031f, -0.01492943f, -0.08974891f, -0.00885030f, 0.02282926f, 0.03271797f, 0.02273978f, 
    0.04204215f, 0.21422915f, 0.04649951f, 0.29447177f, -0.05884483f, -0.07416515f, 0.18172564f, 0.01363385f, 
    -0.10428482f, 0.07996625f, 0.08248036f, 0.00733115f, -0.05870423f, -0.02396597f, -0.14366321f, 0.16604033f, 
    -0.07396864f, 0.03305484f, 0.16654350f, 0.03761002f, 0.05777481f, 0.03847938f, -0.36623868f, 0.04027673f, 
    0.07339653f, -0.11654006f, -0.02980564f, -0.13908477f, 0.04316948f, 0.00839961f, -0.05811080f, -0.01254624f, 
    -0.26809824f, -0.09979575f, 0.09184603f, -0.02549181f, -0.01750547f, 0.12563390f, -0.12047661f, -0.10498068f, 
    0.32951298f, -0.10001498f, 0.37375110f, 0.01714223f, -0.00598127f, -0.13594653f, -0.09111311f, -0.04940242f, 
    -0.07413906f, -0.05735204f, -0.16374458f, -0.18948443f, -0.02458955f, -0.04928663f, 0.10187087f, -0.07326323f, 
    0.15689728f, 0.10324953f, 0.03458603f, 0.08334852f, -0.05395145f, -0.25647384f, 0.01877694f, 0.03996648f, 
    -0.00999826f, -0.12742144f, -0.44756871f, 0.13896769f, 0.07228107f, 0.06421695f, -0.06127824f, 0.00597240f, 
    0.03380825f, -0.08852255f, 0.00248230f, -0.03669099f, -0.02657443f, 0.12649289f, 0.31583220f, -0.02600404f, 
    0.22807769f, 0.27343580f, -0.00726874f, 0.12183653f, -0.10306656f, 0.01005240f, 0.15503187f, -0.12394261f, 
    -0.02932391f, -0.03048730f, 0.05808841f, 0.07876315f, -0.01092561f, -0.04114485f, -0.11405136f, 0.01629623f, 
    0.12312198f, -0.07136208f, -0.09572582f, 0.02178814f, -0.00644696f, -0.89205360f, -0.50845408f, 0.02534423f, 
    -0.07232922f, -0.20475480f, -0.20288949f, 0.01467862f, 0.11372358f, -0.16912985f, -0.01488849f, 0.10627189f, 
    0.00245842f, -0.05910370f, 0.10495891f, 0.01908419f, -0.00360222f, -0.06438325f, -0.07805295f, -0.07188143f, 
    -0.89368534f, -1.03464878f, -0.38859776f, 0.14038685f, 0.03979037f, -0.18497749f, -0.02634408f, -0.01185548f, 
    0.18629825f, -0.15678567f, -0.00540206f, 0.08678632f, -0.03880711f, -0.24148671f, 0.06319948f, -0.17803918f, 
    -0.00562124f, 0.06601586f, -0.09442889f, -0.17320184f, 0.06878701f, 0.04526469f, -0.21327649f, 0.04852163f, 
    -0.05361981f, -0.07401148f, -0.24144770f, 0.02678950f, 0.05094783f, 0.13397592f, -0.16887087f, 0.05939927f, 
    -0.07341344f, 0.19052877f, 0.01944898f, -0.06040817f, 0.13362607f, -0.22144228f, 0.02865060f, 0.01717727f, 
    -0.43587309f, -0.17358996f, -0.31251365f, 0.01771250f, -0.07584289f, 0.07794440f, 0.05191712f, 0.23880509f, 
    0.00215840f, -0.14248715f, -0.05543214f, -0.10232753f, 0.04391148f, 0.15990941f, -0.10030005f, 0.00101304f, 
    -0.09867170f, 0.05166426f, 0.10247989f, 0.07783949f, -0.28790554f, 0.37777182f, 0.06233209f, 0.14488436f, 
    -0.06926427f, -0.03814847f, 0.02522847f, -0.07558518f, -0.08857401f, 0.10186380f, -0.17112756f, -0.07030222f, 
    0.04493649f, -0.17811552f, -0.14800695f, -0.07435238f, 0.02133779f, 0.26699737f, 0.05652725f, -0.02758009f, 
    -0.26493827f, -0.19756559f, -0.22939891f, -0.22399920f, -0.55849385f, -0.02932091f, -0.06373867f, 0.01900992f, 
    0.02242732f, 0.07922741f, -0.05891655f, 0.01579434f, 0.13657072f, -0.06265100f, 0.08904088f, 0.07225663f, 
    0.07916178f, -0.05477633f, -0.17172623f, 0.13412234f, -0.72831017f, 0.50360900f, -0.37763605f, 0.23895381f, 
    0.61950552f, 0.03956372f, 0.26847911f, 0.18888116f, 0.09594026f, 0.15393361f, -0.05277995f, -0.00611943f, 
    -0.05484943f, -0.09138982f, 0.01870858f, -0.05543724f, 0.13866994f, 0.02065125f, 0.20002417f, 0.15977703f, 
    -0.40018043f, 0.17208490f, 0.24026075f, -0.19569074f, -0.11044506f, 0.06646983f, -0.07695249f, -0.09214652f, 
    0.01363442f, -0.09585170f, 0.08384898f, 0.03207798f, -0.00027593f, 0.09501535f, -0.15002830f, -0.04976540f, 
    -0.01051416f, -0.24221990f, 0.07830440f, 0.08423780f, -0.51794124f, 0.25018924f, 0.03912871f, -0.01183273f, 
    -0.17145331f, -0.03815177f, 0.03357891f, 0.04062836f, 0.10098815f, -0.12605862f, -0.00387697f, -0.08182973f, 
    -0.10795014f, -0.00102088f, 0.06047513f, -0.06131014f, 0.09990664f, -0.05297158f, 0.25266287f, -0.03944533f, 
    -0.48658416f, -0.35526863f, -0.07701708f, -0.16225220f, 0.19078548f, 0.05463121f, -0.03227882f, -0.16119076f, 
    0.08956221f, -0.01817764f, 0.01057491f, -0.08454812f, -0.17325208f, -0.05186796f, -0.10017169f, -0.00363201f, 
    -0.16111603f, -0.26325241f, 0.03800103f, 0.10161705f, 0.25547326f, -0.26957753f, 0.13725008f, -0.23004861f, 
    -0.41342017f, 0.14617930f, -0.02309527f, 0.03144654f, -0.01628924f, 0.04402272f, -0.06533918f, -0.15219952f, 
    0.06894264f, 0.07210455f, 0.06291430f, -0.02929157f, 0.09830800f, -0.00547439f, -0.03505667f, 0.14412920f, 
    0.06912881f, 0.40146697f, -0.20727634f, 0.30611315f, -0.15537657f, -0.06983075f, -0.00801520f, -0.03906690f, 
    0.03328125f, -0.15804467f, 0.03361676f, 0.08358485f, -0.01785417f, 0.03770060f, -0.04214212f, 0.14163625f, 
    -0.12331577f, -0.07043072f, -0.02216874f, -0.01414914f, -0.43303514f, 0.31532511f, 0.02860021f, 0.13464323f, 
    0.01842360f, -0.01209312f, -0.07611353f, -0.00553816f, -0.08163238f, -0.06252635f, -0.04017400f, -0.11159249f, 
    0.00223754f, 0.07506520f, 0.04768242f, -0.01585120f, -0.17505720f, 0.27851737f, -0.11103804f, 0.22837751f, 
    -0.12517796f, -0.28580725f, -0.02966197f, -0.10056775f, 0.28272998f, 0.13072783f, -0.00706798f, -0.09045625f, 
    0.09126456f, 0.08531147f, 0.04486075f, 0.21833034f, 0.01596579f, -0.03050363f, -0.03012451f, -0.13812834f, 
    0.09439745f, -0.03188787f, 0.13797162f, -0.10882898f, -0.95010912f, 0.03874624f, 0.00752114f, 0.04527564f, 
    0.38294241f, 0.09657692f, 0.08792917f, -0.01058086f, 0.15413159f, 0.12373061f, 0.00747317f, -0.09235680f, 
    0.14309615f, -0.00627552f, 0.03809883f, -0.07094999f, 0.20247239f, 0.21321236f, 0.17459750f, -0.07284389f, 
    0.12905115f, 0.11744512f, -0.02829926f, 0.13326907f, -0.32598802f, -0.10627581f, -0.15682334f, -0.00583334f, 
    0.05319565f, -0.11452127f, -0.01176725f, 0.00690758f, 0.08644059f, -0.01552209f, 0.08992445f, -0.15742540f, 
    0.01097574f, 0.13771529f, 0.09603247f, 0.20587006f, 0.42464694f, -0.37837398f, 0.03367443f, -0.15945297f, 
    -0.19159624f, -0.20018400f, -0.01534712f, -0.08004291f, 0.06682073f, -0.09600291f, -0.00998073f, 0.13051130f, 
    -0.00613722f, -0.03563191f, 0.16577294f, -0.13765867f, 0.07065626f, -0.18678644f, 0.10035922f, -0.06067182f, 
    -0.41333216f, -0.19120383f, 0.12352572f, -0.22135344f, 0.07403409f, -0.02179032f, 0.00694883f, -0.10259172f, 
    0.10838077f, 0.19036679f, 0.16578463f, 0.00322463f, -0.10579418f, -0.04199577f, 0.07656550f, 0.05724996f, 
    0.00764681f, -0.18062049f, 0.03816963f, 0.00377602f, -0.60979152f, 0.44710344f, 0.13513887f, -0.04794554f, 
    0.00876907f, -0.04452472f, -0.03369123f, -0.03888059f, -0.00027168f, -0.15763980f, -0.02505162f, 0.12314044f, 
    0.01356810f, -0.00833917f, -0.11807410f, -0.08801778f, -0.02640571f, 0.02387902f, -0.03324301f, -0.12309510f, 
    -0.13271073f, 0.33090296f, 0.36555934f, -0.28388691f, -0.00918778f, 0.07683824f, 0.12924680f, 0.00073346f, 
    0.05173244f, 0.14004710f, 0.19310217f, 0.00525089f, 0.07886369f, -0.04017161f, -0.04982222f, -0.00653554f, 
    -0.01359629f, 0.09430017f, -0.05226162f, 0.06822938f, 0.00513590f, -0.17049092f, 0.19691773f, -0.03755774f, 
    -0.03722958f, 0.16717321f, 0.20658967f, -0.05390442f, -0.03591971f, 0.04224645f, 0.11802340f, -0.05240902f, 
    0.00809129f, 0.03421586f, 0.01049552f, -0.00432020f, -0.14974855f, 0.13171703f, 0.03546959f, 0.22891605f, 
    -0.75400746f, 0.08820117f, -0.06015122f, 0.28836313f, 0.04385972f, 0.04967217f, -0.06128988f, 0.05854174f, 
    -0.09559198f, 0.16053142f, -0.05270956f, 0.07051039f, 0.03506670f, 0.09704734f, 0.12647676f, 0.06824908f, 
    0.02805862f, 0.00229922f, -0.01471779f, -0.13155793f, -0.80895740f, -0.10660365f, 0.34342179f, 0.39288795f, 
    -0.07687701f, -0.22938785f, -0.15711138f, 0.19174902f, -0.18048713f, -0.10679820f, 0.09334599f, 0.04002089f, 
    0.08254353f, -0.18366253f, -0.08253746f, 0.05206411f, -0.08897874f, 0.00537320f, 0.01447414f, -0.02323620f, 
    0.59996557f, 0.50966412f, -0.33269492f, -0.32202503f, 0.05556725f, -0.19346341f, 0.03495239f, 0.08259496f, 
    0.08263738f, -0.09616489f, -0.16078569f, -0.11804783f, 0.00779164f, -0.01697318f, 0.01612927f, 0.04577450f, 
    -0.03032621f, -0.30238852f, -0.09352981f, -0.05915673f, -0.06436542f, -0.07201717f, -0.24293047f, 0.10031410f, 
    0.07782395f, 0.02943405f, 0.13498348f, 0.09929947f, -0.03552859f, 0.03119333f, 0.02787830f, 0.15258563f, 
    -0.15827771f, 0.02256552f, 0.02367553f, -0.03520528f, -0.14492348f, -0.09739297f, -0.04261326f, -0.08215898f, 
    -0.70383465f, 0.06156598f, -0.40216222f, 0.24635227f, -0.25947616f, 0.11810112f, -0.10190728f, 0.08595213f, 
    -0.01340290f, -0.00021640f, 0.06393778f, 0.15389152f, 0.03564965f, -0.04398015f, -0.12524657f, 0.12358516f, 
    -0.14260121f, -0.00882954f, -0.01055750f, -0.06978257f, -0.34824428f, 0.01902143f, 0.37286824f, 0.29734367f, 
    -0.42931506f, -0.11871136f, 0.10968254f, 0.15733807f, -0.11007543f, 0.02273145f, -0.05408639f, -0.01677128f, 
    -0.02082291f, -0.19604488f, -0.24929765f, -0.00085972f, 0.04161806f, -0.32424057f, -0.04519468f, 0.04916754f, 
    -0.09855171f, -0.19127853f, -0.15359057f, 0.10915425f, 0.28654879f, 0.19205263f, -0.12222754f, -0.05681844f, 
    0.07055375f, 0.24396925f, -0.07382916f, 0.02342908f, 0.19841515f, -0.02638802f, 0.13075137f, -0.38904437f, 
    0.01136379f, 0.04808253f, -0.06346780f, -0.28248084f, -0.28082865f, 0.04203502f, -0.67272872f, -0.11611988f, 
    0.17439310f, 0.09640676f, 0.31364396f, 0.11746537f, -0.02531699f, 0.08322866f, 0.10335375f, 0.23301366f, 
    0.00630298f, -0.14700364f, 0.06292161f, 0.09448723f, 0.15645586f, -0.25205803f, 0.18704240f, -0.04829643f, 
    -0.56992489f, -0.10089193f, -0.44252035f, 0.00197987f, 0.04363327f, 0.24627984f, 0.14361666f, 0.15155548f, 
    -0.10911709f, 0.03353634f, -0.02488665f, 0.02281256f, -0.18581858f, -0.11932240f, -0.07159131f, -0.09577589f, 
    0.05281855f, 0.11321018f, -0.31483966f, 0.10228512f, -0.43184686f, 0.24268843f, -0.56957150f, -0.27896151f, 
    -0.13398007f, 0.22918874f, 0.10333914f, 0.16301392f, -0.12503150f, -0.12238170f, 0.02047054f, -0.10718080f, 
    -0.10697611f, 0.02463499f, 0.00484015f, 0.21484429f, -0.16142921f, -0.05866428f, 0.02271233f, -0.01348925f, 
    0.02706612f, -0.14762522f, -0.12254474f, -0.15810929f, 0.17168561f, -0.00855364f, -0.21872041f, -0.03065773f, 
    0.07013837f, 0.07879545f, 0.10691943f, 0.07852799f, 0.06527189f, -0.05311240f, -0.06604598f, 0.11025435f, 
    -0.17625806f, -0.18622802f, 0.03033206f, 0.11369877f, -0.02563230f, 0.08173057f, 0.12008760f, 0.08507500f, 
    0.28850383f, 0.02722969f, -0.01046698f, 0.13703427f, -0.14042276f, 0.12216542f, -0.02934043f, -0.21271482f, 
    -0.01821438f, -0.03952384f, -0.08154848f, 0.18146983f, -0.08386724f, 0.05087295f, 0.14184408f, 0.11587719f, 
    0.02987386f, 0.05908570f, 0.10309795f, 0.32810959f, -0.02502275f, -0.07314343f, 0.11228935f, -0.03469152f, 
    -0.04065259f, -0.04158789f, -0.07952345f, -0.00811291f, 0.21718141f, 0.05555215f, 0.17061251f, 0.05570425f, 
    0.20870657f, 0.19351135f, -0.02729238f, -0.06453429f, -0.70944148f, -0.12800357f, -0.11349113f, -0.07346268f, 
    0.17854144f, 0.14159860f, -0.09155314f, 0.04657922f, 0.07519407f, -0.05283845f, 0.05975999f, -0.14692162f, 
    0.00101049f, 0.02374741f, 0.02415776f, -0.11397857f, 0.10944024f, -0.12069537f, 0.10615496f, 0.03856119f, 
    -0.06737445f, 0.08651006f, 0.20546508f, 0.22093551f, -0.11656961f, -0.16584802f, 0.00906223f, -0.15645792f, 
    -0.09649807f, 0.29488578f, -0.04146859f, 0.04198718f, 0.14553328f, -0.01137678f, 0.01690115f, -0.05459127f, 
    -0.14686243f, 0.08850916f, -0.01738781f, -0.04131343f, 0.03694653f, -0.02993850f, 0.14029232f, 0.07679077f, 
    0.35587212f, 0.04356969f, 0.00044533f, -0.04712219f, 0.07652979f, 0.00387480f, -0.05632613f, 0.08466175f, 
    0.25292575f, 0.26089400f, 0.24170850f, 0.04681690f, 0.16331157f, 0.00511099f, -0.42040238f, -0.04536106f, 
    0.10269079f, 0.38605902f, 0.04935012f, -0.21672858f, -0.09940816f, -0.10431861f, -0.00920859f, -0.07304091f, 
    -0.05454049f, -0.26747772f, -0.05749482f, 0.05098410f, -0.19224285f, -0.07038628f, -0.04141452f, -0.01277789f, 
    -0.07362267f, 0.14489309f, 0.21419144f, 0.01011964f, 0.17788365f, 0.03835150f, -0.04112820f, 0.20413971f, 
    -0.08914990f, -0.23939916f, -0.05160483f, -0.05180163f, 0.07571594f, -0.03533422f, -0.05880777f, -0.17855014f, 
    0.20969409f, 0.10066724f, 0.32188052f, -0.24396738f, -0.07938559f, -0.05436488f, 0.02908073f, -0.10312891f, 
    -0.50790340f, -0.30693263f, 0.07512619f, 0.09487160f, -0.34206182f, 0.04939997f, -0.02029863f, -0.02084861f, 
    0.02213962f, -0.18068236f, 0.18145466f, -0.11657584f, 0.03655342f, 0.16923749f, -0.01170919f, -0.12954806f, 
    0.14926292f, 0.25864765f, 0.08294603f, 0.01414056f, 0.06331601f, -0.29435566f, 0.11507928f, 0.16734898f, 
    0.14732462f, -0.05086661f, -0.23158579f, -0.03853694f, 0.02288196f, 0.01859310f, 0.15016137f, 0.15703455f, 
    -0.16991377f, 0.15995489f, -0.05549986f, -0.00377767f, -0.10265983f, -0.02077230f, -0.38000292f, 0.07024499f, 
    -0.13696730f, -0.67364532f, 0.08861385f, -0.22341433f, 0.22342338f, -0.05604573f, 0.17104690f, 0.04161303f, 
    -0.15465532f, -0.08556332f, -0.12777382f, -0.02188771f, 0.01766621f, 0.17408744f, 0.25667807f, -0.14304580f, 
    -0.00131827f, 0.15522531f, 0.10301131f, 0.02935715f, 0.31758317f, 0.15971017f, 0.12689355f, 0.37669119f, 
    0.29554516f, -0.07659264f, 0.02060436f, 0.00611731f, 0.18821394f, -0.04672481f, -0.00237871f, 0.09048843f, 
    0.05633912f, 0.20493078f, 0.04316229f, 0.07753119f, 0.07004645f, 0.21679145f, 0.11785273f, 0.01227563f, 
    -0.06255148f, -0.02633003f, -0.34328964f, -0.46720874f, 0.09555011f, -0.07735725f, -0.01587830f, 0.00139498f, 
    0.15855619f, -0.13514870f, 0.04798449f, -0.18316062f, -0.24138762f, -0.00542904f, 0.01049990f, 0.08340494f, 
    0.02027780f, 0.20802552f, 0.22501794f, 0.26021391f, -0.09764839f, -0.07369562f, -0.29167867f, -0.55675560f, 
    0.36395624f, -0.30817094f, -0.04096735f, -0.03984047f, 0.12254277f, -0.22599436f, 0.03353246f, -0.01308847f, 
    0.07114750f, 0.05445077f, 0.04077655f, -0.13865355f, 0.05685467f, 0.09065813f, -0.17182086f, 0.04390027f, 
    -0.18576123f, -0.16022711f, 0.03630785f, -0.48121452f, -0.01833002f, 0.07893213f, -0.08731897f, 0.07757896f, 
    -0.16475365f, -0.14315544f, -0.00649740f, -0.29758358f, -0.01201623f, 0.04144441f, 0.07755476f, 0.14378084f, 
    -0.13833083f, 0.00156411f, 0.28552255f, -0.08823758f, 0.25475526f, -0.55647248f, 0.02709575f, -0.48179436f, 
    0.13936870f, -0.01374112f, 0.00764228f, -0.05401088f, -0.05238263f, -0.06171864f, 0.01642192f, 0.00473448f, 
    0.19143888f, 0.16249141f, 0.00078600f, -0.04236484f, 0.03028708f, 0.00872484f, -0.11572789f, 0.09038308f, 
    0.03811248f, -0.01917117f, -0.42325908f, -0.07373165f, 0.09510822f, -0.03740283f, 0.20852886f, -0.00357962f, 
    -0.15173492f, -0.00835007f, 0.09860101f, 0.03850517f, 0.01995393f, 0.04844508f, -0.12310935f, 0.04983333f, 
    0.01621519f, 0.22828826f, 0.12997673f, -0.01558274f, -0.65426695f, 0.27255496f, 0.03125643f, 0.26615050f, 
    -0.17033033f, -0.09940811f, 0.07006522f, -0.09417180f, -0.02452332f, 0.12170533f, -0.11738137f, 0.06150898f, 
    0.13655786f, 0.04513072f, -0.09675390f, -0.10016819f, -0.05064711f, -0.09642745f, -0.08657815f, -0.30113670f, 
    -0.31671897f, 0.46249965f, 0.02432742f, 0.23074566f, -0.28805783f, -0.10675409f, -0.24322249f, -0.08736538f, 
    0.17784415f, 0.04821604f, -0.00257135f, 0.06684629f, -0.03063732f, -0.00468239f, -0.03805381f, -0.16436677f, 
    -0.10715441f, -0.10125686f, 0.01511553f, -0.06051038f, 0.36702919f, -0.17479889f, -0.00346260f, -0.03714057f, 
    -0.00575400f, 0.18567692f, 0.18441848f, 0.06422698f, -0.00545657f, -0.16807909f, 0.07410223f, 0.00337970f, 
    0.01260216f, -0.09536058f, 0.05513310f, -0.00947409f, -0.05039977f, 0.16339457f, -0.14038709f, 0.11593114f, 
    -0.00004682f, -0.02024302f, 0.13135172f, -0.01494799f, 0.25682214f, 0.14886166f, 0.05585608f, 0.09695701f, 
    0.09443060f, -0.13673458f, -0.19389746f, -0.08584525f, 0.01817350f, 0.13613501f, 0.17016737f, -0.05390304f, 
    0.17267092f, -0.32230029f, 0.07351132f, -0.17204376f, 0.08002248f, -0.02646644f, -0.44901296f, -0.26725411f, 
    0.15564749f, -0.05169572f, 0.07826843f, -0.11139037f, -0.17583279f, 0.02003719f, 0.02429639f, -0.05510560f, 
    -0.09957610f, -0.12080731f, -0.03068668f, -0.09112208f, -0.01688312f, -0.02889582f, 0.07777090f, -0.09341720f, 
    -0.18796416f, -0.64933079f, -0.09998707f, -0.22321807f, 0.34617758f, 0.05359633f, -0.08454846f, -0.10932801f, 
    0.17832419f, 0.02306433f, -0.00447345f, -0.15187864f, 0.03959375f, 0.24125338f, 0.16863467f, 0.08068940f, 
    -0.05708292f, -0.13850676f, -0.26742381f, -0.06109911f, -0.02219336f, 0.26932973f, 0.36203972f, -0.25528389f, 
    -0.53954506f, 0.36249086f, 0.05100019f, 0.16391641f, -0.00903247f, -0.02333235f, -0.14126427f, 0.09628145f, 
    -0.17861296f, -0.08656484f, -0.20569684f, 0.10536873f, -0.02962036f, 0.04062825f, 0.09564116f, -0.02794950f, 
    0.51293629f, -0.50471246f, -0.12120822f, 0.24606410f, 0.06748078f, -0.12178992f, -0.06894035f, 0.05696410f, 
    0.01561959f, 0.05379847f, 0.11671162f, -0.04579414f, -0.14720058f, -0.03849807f, 0.13325910f, 0.04269676f, 
    -0.03523260f, -0.06177974f, -0.26579767f, -0.04524412f, -0.39066789f, -0.17624933f, 0.16037041f, 0.14036220f, 
    0.11291211f, 0.14316879f, -0.01959462f, 0.09784402f, -0.32509735f, -0.18123318f, 0.00217751f, -0.14631407f, 
    0.13389680f, -0.17031316f, -0.00513341f, -0.04769232f, 0.11873331f, -0.03126227f, 0.13138407f, -0.02283541f, 
    0.22500008f, 0.01201376f, 0.01478657f, 0.33145571f, 0.31317919f, 0.00905016f, -0.01023948f, -0.13128820f, 
    0.16353390f, -0.01830283f, 0.07480957f, 0.02388816f, -0.06981843f, -0.10570623f, -0.07236107f, -0.06309317f, 
    -0.23989528f, 0.04432175f, -0.05664206f, -0.01630031f, -0.34767288f, 0.38583481f, -0.05783355f, 0.20260817f, 
    -0.10135893f, 0.24032906f, -0.22865517f, -0.21371259f, 0.15433678f, 0.03382365f, -0.11567587f, 0.10426315f, 
    0.11451078f, -0.03915214f, 0.01875655f, 0.04234793f, -0.01772694f, 0.03354755f, -0.01927222f, -0.06502291f, 
    0.00315463f, 0.16199362f, 0.09127285f, 0.28171271f, 0.40364841f, -0.08300021f, 0.07648326f, -0.08536851f, 
    0.03451626f, -0.00293802f, -0.05978069f, 0.02620593f, -0.26633430f, -0.16403790f, -0.14453627f, 0.11713901f, 
    -0.04627885f, 0.14616355f, -0.16128308f, -0.14163946f, -0.17059065f, 0.24986449f, 0.30985156f, 0.14984572f, 
    0.28921703f, -0.00710747f, 0.24872391f, -0.02136691f, -0.05262832f, 0.03473506f, -0.06921292f, 0.02130624f, 
    -0.00779708f, 0.02156020f, -0.24129708f, 0.07366493f, 0.08141655f, -0.03593696f, 0.02503605f, 0.13330019f, 
    0.29749858f, -0.09228616f, 0.20134003f, 0.18428008f, 0.39899117f, 0.21362394f, 0.07644281f, -0.04205185f, 
    -0.06087680f, 0.04903173f, -0.05902507f, 0.20146334f, -0.08442754f, -0.10713433f, -0.16687146f, -0.05655205f, 
    0.00148056f, -0.11218552f, 0.02052177f, -0.11501019f, 0.12774223f, 0.16231136f, 0.39178815f, 0.11247843f, 
    0.27370745f, 0.17415814f, 0.19221181f, -0.09778900f, 0.02164378f, -0.05223324f, -0.08662796f, 0.06566927f, 
    0.12681808f, -0.08214562f, -0.23779130f, -0.06674518f, -0.06513359f, -0.05444547f, 0.09002569f, -0.09206701f, 
    0.09985412f, 0.40788087f, -0.11669776f, 0.01900353f, 0.07394782f, -0.07644210f, 0.11640952f, -0.19166785f, 
    -0.07518591f, -0.08025046f, -0.26640719f, 0.04587302f, 0.03543658f, 0.03752638f, -0.14903665f, 0.00334629f, 
    -0.01411399f, 0.15499254f, -0.12054198f, -0.07527477f, -0.53321183f, -0.02975033f, -0.03340182f, -0.29150331f, 
    -0.37310159f, -0.11417328f, 0.12253837f, -0.13923132f, -0.10866385f, -0.09962973f, 0.04571872f, -0.13727017f, 
    0.03906320f, -0.03472245f, 0.02728621f, 0.01466489f, 0.08821794f, -0.05415590f, -0.11043482f, 0.06656605f, 
    -0.47980988f, -0.23755425f, -0.24502507f, -0.37735695f, -0.23299895f, 0.00506634f, -0.11337800f, 0.05705099f, 
    -0.06799456f, -0.18771629f, -0.01792975f, -0.08271951f, -0.10591450f, 0.12787449f, -0.06032249f, -0.04783434f, 
    -0.11429542f, -0.04554276f, 0.00694807f, 0.16513319f, -0.03556307f, 0.14903095f, 0.25000176f, -0.06061149f, 
    0.13507630f, -0.26900893f, 0.11325958f, -0.06387199f, -0.01019915f, -0.11168551f, -0.04730023f, 0.04778463f, 
    -0.27962452f, -0.00876718f, -0.02959919f, -0.08510751f, -0.14811409f, 0.01554796f, 0.02575799f, -0.12899154f, 
    0.09290211f, -0.18671720f, -0.14329322f, -0.28581128f, 0.05196816f, -0.22298762f, -0.18537214f, -0.06290904f, 
    -0.06662597f, -0.11303221f, 0.05463100f, 0.02394045f, -0.06280440f, -0.06741197f, 0.17916960f, 0.03017139f, 
    -0.23717166f, -0.12167230f, -0.08723377f, -0.10515159f, 0.03628024f, 0.07659473f, 0.26536226f, 0.01594406f, 
    0.19740853f, 0.00427554f, 0.13829231f, -0.05298162f, -0.08738984f, 0.06883738f, -0.01896737f, -0.03582704f, 
    -0.14528853f, -0.14812034f, 0.03017119f, 0.04796709f, -0.15600677f, -0.00897291f, 0.19178335f, 0.13152671f, 
    -0.12772217f, -0.14522207f, 0.17140420f, -0.10868943f, -0.04421478f, -0.12004922f, 0.07726057f, -0.03181803f, 
    -0.03833441f, -0.04991534f, -0.00020937f, 0.01652329f, -0.02915397f, -0.06464262f, 0.03853332f, -0.02814399f, 
    -0.05702894f, 0.14934632f, -0.04734661f, 0.08356383f, 0.16522159f, -1.04671907f, 0.00087217f, -0.01671677f, 
    -0.02126420f, 0.10331182f, -0.13695498f, -0.06701078f, 0.04228617f, -0.07019471f, -0.17060471f, 0.09095731f, 
    -0.08955835f, -0.01779941f, -0.10161744f, -0.04303396f, 0.09001175f, -0.14662100f, 0.06520771f, -0.06653816f, 
    0.35599729f, -0.16074166f, 0.06593303f, -0.02062821f, -0.20815109f, 0.27073956f, -0.03985802f, 0.04054641f, 
    -0.20563021f, 0.14586037f, 0.02535333f, -0.09526468f, -0.12169131f, -0.18403333f, -0.07483982f, -0.07241748f, 
    0.15932949f, -0.05960906f, 0.05105554f, -0.09707438f, 0.18962124f, -0.39736992f, 0.23715849f, -0.07648364f, 
    -0.10779001f, 0.09623706f, -0.01598676f, -0.00923449f, -0.03790225f, 0.09550476f, 0.01629555f, 0.11740822f, 
    -0.06584306f, 0.01003465f, -0.25178030f, -0.22055636f, -0.00510442f, -0.07621713f, 0.02140767f, -0.04189093f, 
    -0.37033352f, 0.10067960f, 0.25468895f, -0.16913472f, 0.26916024f, -0.21176499f, -0.14388166f, -0.10085695f, 
    0.03496754f, -0.18947588f, 0.12339284f, 0.02917434f, 0.03179367f, -0.03856898f, 0.03994999f, -0.14044198f, 
    -0.00388285f, 0.12276662f, -0.21653314f, -0.08825147f, -0.37788090f, -0.04134690f, -0.31655446f, -0.30621618f, 
    -0.43713951f, 0.02448898f, -0.20485017f, -0.59802848f, 0.14323682f, 0.01183916f, 0.18651770f, 0.01398752f, 
    0.13751151f, -0.14332627f, 0.22089817f, -0.10218313f, 0.11790924f, -0.15448193f, 0.11987752f, -0.06159953f, 
    -0.05827772f, 0.30905154f, 0.07079669f, -0.33933282f, -0.24770242f, -0.14062910f, -0.01668461f, -0.12655824f, 
    -0.08569390f, -0.21235897f, 0.18323514f, 0.00478299f, -0.00564183f, 0.03189833f, 0.00113122f, -0.21945536f, 
    -0.10743542f, -0.30740589f, -0.11027205f, -0.00374145f, -0.24163929f, -0.03680421f, 0.49412379f, -0.13738337f, 
    -0.24597652f, -0.11139190f, -0.06778038f, 0.10652983f, 0.06544426f, 0.01643380f, 0.06272584f, 0.08345597f, 
    -0.18007232f, -0.08051342f, 0.00803366f, -0.06945138f, 0.02959143f, -0.26743421f, 0.03858783f, -0.23764330f, 
    -0.54601425f, -0.17015515f, 0.26063839f, -0.18530351f, 0.15158427f, 0.07012996f, 0.03415328f, -0.00378220f, 
    -0.02619662f, -0.05538068f, 0.04767444f, 0.01422242f, 0.02032826f, 0.12835202f, 0.08656196f, -0.06520300f, 
    0.12059718f, 0.19315103f, -0.63844806f, 0.01179825f, -0.31766939f, -0.30076233f, 0.31514275f, 0.04899488f, 
    0.27461141f, -0.07101224f, -0.06290126f, 0.03138240f, -0.18287112f, 0.08828215f, 0.04987721f, -0.09774476f, 
    -0.18421474f, -0.03961754f, 0.08845154f, 0.02492860f, 0.03225981f, 0.03527803f, 0.15952972f, 0.07241149f, 
    -0.35668558f, 0.08209862f, -0.11481383f, -0.11275351f, -0.51106715f, -0.16458634f, -0.03760938f, 0.04636124f, 
    0.11450326f, -0.02153081f, 0.16594546f, 0.07872486f, -0.03740212f, 0.05977054f, 0.09400507f, -0.27520537f, 
    0.07869295f, -0.23933400f, 0.05982324f, -0.04702926f, 0.19193064f, 0.09297018f, -0.31178638f, 0.19072534f, 
    0.10782807f, 0.07289208f, -0.07675652f, -0.01155620f, -0.14609210f, 0.03662331f, 0.08157252f, 0.02867111f, 
    0.00960405f, 0.13479428f, -0.06519821f, -0.12475146f, 0.00875768f, -0.01195682f, 0.14283970f, 0.02342680f, 
    0.28366959f, 0.14306098f, -0.20711277f, 0.19844563f, 0.29837978f, 0.29787236f, -0.00056453f, -0.13710944f, 
    -0.08780429f, -0.05033726f, 0.03079242f, -0.09950142f, -0.10587870f, 0.06617429f, -0.11415724f, -0.08161793f, 
    0.06607813f, 0.10039741f, 0.09299706f, -0.12288426f, 0.12432909f, 0.18204100f, -0.04864717f, 0.06598663f, 
    -0.05659820f, -0.15552580f, -0.02213213f, -0.18274513f, -0.03531435f, 0.15511051f, 0.01164717f, -0.12284868f, 
    0.04723425f, 0.05467464f, 0.14108095f, 0.11022346f, 0.02344212f, -0.13837764f, 0.17889409f, 0.11017937f, 
    0.11427449f, -0.06350201f, 0.19527711f, 0.14397487f, 0.10989043f, 0.08363276f, 0.07026176f, -0.26862556f, 
    -0.21435651f, -0.10328331f, 0.09467544f, 0.07856490f, 0.00223328f, -0.00777283f, -0.03861068f, -0.28168720f, 
    -0.01874487f, 0.19335604f, -0.08337346f, -0.06255745f, -0.36784297f, -0.31860638f, -0.01199030f, -0.56773150f, 
    -0.34003049f, -0.11869520f, -0.08496126f, -0.00384964f, -0.11208718f, -0.11063707f, -0.03209350f, 0.10445166f, 
    -0.03011398f, 0.03162717f, -0.01652802f, 0.00520983f, -0.07397261f, -0.09135294f, -0.39085642f, 0.00026137f, 
    0.30744621f, 0.43288204f, -0.00145729f, 0.05536020f, 0.14340360f, -0.17338802f, -0.19807199f, -0.05433302f, 
    -0.11741731f, -0.09841256f, 0.18211262f, -0.00570147f, -0.08127742f, -0.14312924f, 0.04465745f, 0.01885520f, 
    -0.05313447f, 0.09168950f, 0.15055685f, -0.10194684f, -0.09261853f, -0.24659629f, -0.50842595f, -0.08228281f, 
    0.20447710f, 0.10920887f, 0.02553728f, -0.07353424f, -0.07591438f, -0.04499236f, 0.14858659f, 0.01042927f, 
    0.03297557f, 0.09745637f, 0.19551066f, -0.00407607f, 0.03384187f, 0.02936864f, 0.13909331f, -0.05296733f, 
    0.22684017f, 0.12226001f, 0.10152348f, 0.20041174f, 0.14271900f, -0.13685988f, -0.14732938f, -0.09059154f, 
    -0.14350422f, 0.06031715f, -0.08021355f, -0.04560310f, -0.14835279f, -0.00687391f, 0.03043704f, 0.01740009f, 
    -0.05160787f, 0.11663877f, 0.03043078f, 0.16518073f, -0.09915327f, 0.26041964f, 0.06061859f, -0.12361626f, 
    -0.07097687f, -0.04519106f, -0.00838570f, -0.07060371f, -0.06117644f, -0.13453776f, 0.04605290f, 0.03981714f, 
    0.13455418f, 0.28255942f, -0.09709467f, 0.10773951f, -0.08092116f, -0.08119500f, -0.04631501f, 0.19360514f, 
    1.07529783f, 0.05666238f, -0.31383914f, -0.21393844f, 0.11601499f, 0.13571675f, -0.18254241f, -0.01609455f, 
    0.01627050f, -0.22165465f, -0.06544956f, -0.15483294f, 0.09373540f, 0.13293229f, -0.16162147f, 0.05248938f, 
    0.07131156f, 0.01542657f, 0.05396154f, -0.02819195f, -0.53107667f, -0.69532925f, 0.11247698f, -0.49273816f, 
    -0.02181184f, -0.11165457f, 0.19784684f, -0.05289942f, 0.04657158f, 0.12867047f, -0.23612978f, -0.20224425f, 
    -0.04706137f, 0.01452924f, 0.08600110f, -0.05514922f, 0.03476335f, 0.11696676f, -0.05044409f, -0.04184574f, 
    -0.27584538f, 0.28633726f, 0.00715749f, 0.10020648f, -0.37514091f, -0.00185896f, 0.17054367f, 0.01261474f, 
    0.03712333f, 0.02640973f, -0.05718324f, 0.04480312f, 0.13673654f, 0.12568159f, 0.13414618f, 0.13442010f, 
    -0.02860067f, 0.04830403f, 0.01138313f, 0.01004304f, -0.11146720f, -0.23174691f, 0.05197558f, 0.21263580f, 
    -0.11351337f, 0.12275309f, -0.03623274f, -0.03403316f, -0.06455117f, 0.35799345f, -0.07665391f, -0.02260250f, 
    -0.01259121f, 0.13993412f, -0.04449864f, 0.01803570f, -0.05061508f, 0.13603272f, -0.05699678f, -0.19057074f, 
    0.65163350f, 0.04176832f, -0.13543759f, 0.10234710f, 0.02948801f, -0.20288487f, -0.01975659f, 0.01094228f, 
    -0.04361733f, -0.04235262f, -0.13200201f, 0.06190917f, 0.17969343f, -0.04582565f, 0.16235805f, 0.21190889f, 
    0.00360302f, -0.02770366f, 0.05614386f, 0.12468607f, 0.01847310f, -0.41060501f, -0.02828442f, 0.33266160f, 
    -0.06574753f, -0.06194326f, -0.03829114f, -0.12925170f, -0.06229670f, 0.17787719f, -0.10809649f, 0.01713757f, 
    -0.13644308f, -0.04186385f, 0.05625754f, -0.05467530f, -0.08803138f, -0.05747703f, 0.13358933f, -0.07475936f, 
    -0.56411511f, 0.15585919f, 0.19515374f, 0.02990662f, -0.02159485f, 0.13316080f, 0.23920120f, -0.17021458f, 
    0.04442488f, -0.01314375f, -0.12701495f, -0.19236137f, -0.03572470f, -0.00788928f, 0.20861065f, 0.13948125f, 
    0.06316090f, 0.04838499f, -0.15095390f, 0.12904832f, -0.42119285f, -0.05221764f, 0.07769543f, -0.02159860f, 
    -0.28358215f, 0.16396549f, 0.11003323f, 0.04555632f, -0.16930534f, -0.18001144f, -0.04228421f, -0.06435467f, 
    -0.13212629f, -0.04482784f, 0.06266019f, 0.03859818f, -0.00610652f, 0.15198314f, -0.09398647f, -0.00975051f, 
    0.14561909f, 0.08400370f, 0.24612775f, -0.11782040f, -0.35488996f, 0.05451571f, 0.28360477f, 0.04237591f, 
    -0.22619498f, -0.04946949f, -0.12997948f, 0.09293528f, -0.04435708f, -0.12958063f, 0.11625296f, -0.01433989f, 
    -0.04626123f, -0.03495378f, -0.06607219f, -0.08400192f, -0.56523663f, -0.08028995f, -0.11506546f, 0.26828989f, 
    0.13036919f, 0.12014154f, 0.07814755f, -0.15732947f, -0.06113303f, 0.07314572f, 0.05136527f, 0.13125712f, 
    0.07024638f, 0.07817944f, 0.03220057f, 0.07335412f, -0.14489987f, 0.06057814f, -0.06189485f, -0.04365555f, 
    0.36881691f, -0.42032465f, 0.09416867f, 0.19658399f, -0.43813780f, 0.15542524f, 0.05528511f, -0.05892472f, 
    -0.05975666f, -0.13980840f, 0.06146861f, -0.10380565f, -0.07225037f, 0.10627942f, -0.10082567f, 0.11756469f, 
    0.23657288f, -0.16282079f, 0.04423604f, -0.02914629f, -0.18052557f, -0.09025918f, -0.16587485f, 0.28739601f, 
    0.28994772f, -0.15752926f, -0.00866591f, 0.00768980f, -0.16037573f, -0.01330578f, -0.00323595f, 0.07274215f, 
    -0.14574282f, -0.15334789f, -0.02798675f, -0.05801035f, -0.01188997f, 0.01246060f, 0.16752902f, 0.00393699f, 
    -0.16603461f, 0.21083263f, -0.21259992f, 0.26113451f, -0.02862839f, 0.17190394f, 0.10815643f, -0.00273769f, 
    -0.02645901f, 0.11596304f, -0.00886190f, -0.04979260f, 0.03710439f, -0.02396368f, 0.12251602f, 0.06553540f, 
    0.04502251f, 0.08479467f, -0.18037301f, 0.13217765f, -0.04393136f, -0.48118910f, 0.46868530f, -0.64531451f, 
    -0.46400005f, -0.12758161f, 0.09088811f, -0.09002418f, 0.09010614f, 0.12188948f, -0.01212507f, -0.06072561f, 
    0.04194130f, -0.07749353f, -0.10319004f, 0.01446709f, -0.04148943f, 0.18027736f, 0.07316554f, -0.03527034f, 
    0.02968981f, -0.34505680f, -0.11374277f, 0.18162519f, 0.03433976f, 0.20577608f, 0.03998014f, -0.06560072f, 
    -0.14302394f, 0.06703918f, -0.10995898f, -0.10392170f, 0.15929015f, 0.10951439f, 0.13841660f, -0.08930139f, 
    0.02419874f, -0.30214560f, -0.03209667f, -0.09905666f, 0.22139303f, -0.68861824f, 0.17116985f, 0.20189844f, 
    -0.20103326f, -0.14012520f, -0.04938233f, 0.01001952f, 0.24242499f, 0.08166775f, 0.02589874f, -0.04424092f, 
    0.15789466f, -0.24693194f, -0.01634420f, -0.07504717f, 0.09752729f, -0.05115049f, 0.20587204f, 0.05913251f, 
    -0.08596536f, 0.05895456f, 0.19735165f, 0.01602817f, -0.07657520f, -0.14498882f, -0.09477823f, 0.12496838f, 
    0.10186457f, 0.19616182f, -0.06567832f, 0.12916757f, -0.02634127f, -0.08166276f, -0.06589005f, -0.18261467f, 
    -0.00761370f, 0.08493886f, -0.13478146f, 0.02789507f, -0.38804203f, -0.17997497f, -0.35527492f, 0.20140933f, 
    0.23811136f, 0.00206588f, 0.09068219f, 0.03924449f, -0.12692404f, -0.01307621f, 0.07481077f, 0.05301044f, 
    -0.01969497f, -0.12749991f, 0.08147528f, 0.00497685f, -0.03100000f, -0.21269411f, -0.17485628f, 0.13376373f, 
    -0.16977006f, -0.12797473f, 0.15978971f, -0.08711094f, -0.04816800f, 0.09077948f, 0.03571441f, -0.06399415f, 
    0.03517002f, -0.05475827f, 0.04041863f, -0.06680112f, 0.08066853f, -0.06197658f, -0.09583335f, -0.07815409f, 
    0.01412692f, -0.33457288f, -0.05786752f, 0.07037140f, 0.14446525f, 0.28275546f, 0.01141053f, 0.04829280f, 
    -0.22262475f, 0.05761794f, -0.23072490f, 0.11259520f, 0.03564294f, 0.01482482f, 0.16115437f, 0.21452731f, 
    0.15868369f, 0.03171906f, -0.18519327f, -0.00390515f, -0.12289007f, -0.03227638f, 0.05617290f, -0.14969133f, 
    -0.12171004f, 0.02295067f, 0.03434454f, -0.17693299f, 0.01074601f, 0.11158629f, 0.08356164f, 0.03837553f, 
    -0.06159347f, 0.03747991f, -0.06933060f, 0.11222532f, -0.01771874f, 0.05176451f, -0.07231411f, -0.04458931f, 
    0.04831456f, -0.21324329f, -0.32503501f, 0.13618040f, 0.40554219f, -0.10282184f, -0.11771090f, 0.06030918f, 
    -0.06743661f, -0.23024641f, -0.25374213f, -0.05754145f, -0.12604250f, -0.12673008f, 0.11865037f, 0.05698409f, 
    -0.15684479f, -0.06605148f, -0.15434164f, -0.00761007f, -0.00797925f, -0.12340963f, -0.21497989f, 0.03094961f, 
    -0.19700640f, -0.27344072f, 0.11994512f, 0.02932533f, 0.24856952f, 0.16006657f, 0.01929654f, 0.08370050f, 
    -0.09516327f, 0.10568318f, 0.12840925f, -0.00415670f, -0.16329125f, 0.04059203f, 0.14185169f, 0.07547358f, 
    -0.00036707f, -0.24434686f, 0.11938417f, 0.00612922f, -0.99725980f, -0.71171814f, -0.20151681f, 0.03167653f, 
    0.23637214f, 0.10943273f, 0.09583458f, -0.04034000f, -0.10031966f, -0.02648914f, 0.24389973f, -0.05176330f, 
    -0.03083733f, 0.16141762f, -0.02894757f, 0.07354692f, 0.08555727f, 0.18422562f, 0.09682440f, 0.06831799f, 
    -1.14772010f, -0.60453349f, -0.33892220f, -0.40421137f, -0.51567310f, 0.19205964f, 0.05961814f, -0.08241635f, 
    -0.22306274f, 0.07911734f, -0.03464007f, 0.14276330f, -0.01783335f, 0.16876379f, 0.00634431f, -0.05109939f, 
    -0.05034422f, 0.02617860f, 0.06815935f, 0.04467812f, 0.30129188f, 0.07557794f, -0.25840089f, 0.01212910f, 
    -0.19366537f, -0.09827183f, -0.14408126f, 0.11130943f, 0.07465309f, 0.06230637f, 0.08275899f, -0.01610696f, 
    -0.01224563f, -0.09785976f, -0.04593370f, 0.16499130f, 0.13066879f, 0.05090880f, 0.12633309f, 0.06729366f, 
    -1.18625462f, -0.57167011f, -0.04038677f, -0.23599677f, -0.21800266f, -0.11188453f, 0.10489926f, -0.15888752f, 
    -0.15637691f, -0.04058265f, 0.07572016f, -0.06474862f, 0.13161191f, -0.07735884f, 0.17403720f, -0.10606825f, 
    -0.06168977f, 0.12316713f, -0.11919144f, 0.12383598f, 0.66698384f, 0.45010149f, 0.02124964f, -0.02013996f, 
    -0.08524065f, 0.02190821f, -0.00869024f, 0.24901615f, 0.04663214f, 0.13178901f, -0.06094319f, -0.13005726f, 
    0.09182197f, 0.08509900f, -0.00489620f, 0.17394327f, 0.09658825f, -0.17898804f, -0.19336078f, -0.04357884f, 
    0.23837098f, 0.01054649f, -0.30419454f, -0.10848640f, 0.02132070f, -0.20195472f, 0.01752658f, 0.00697742f, 
    0.02947887f, -0.07067315f, 0.02094696f, -0.07083741f, -0.07511344f, -0.30662352f, -0.00504550f, -0.23689047f, 
    0.11829982f, 0.14581308f, 0.15307726f, -0.01047435f, -0.45789281f, -0.00720065f, 0.27477187f, -0.11056878f, 
    -0.18783070f, 0.10026225f, 0.09200144f, -0.05767887f, 0.10750528f, 0.06800150f, 0.01798335f, 0.10478514f, 
    0.04290442f, 0.27262548f, -0.03010613f, 0.17418098f, -0.17416202f, 0.01645973f, -0.16480255f, -0.00084102f, 
    -0.50745690f, 0.10667402f, -0.50919878f, -0.11882243f, 0.03170221f, 0.05509059f, 0.08502883f, -0.20960832f, 
    0.01997288f, 0.09952269f, 0.04329946f, 0.07160873f, -0.02318057f, -0.11165734f, 0.09975468f, -0.02098884f, 
    0.12948331f, 0.32692495f, 0.01458981f, 0.13459201f, 0.27018121f, 0.21395798f, 0.14066426f, 0.02729692f, 
    0.14986210f, 0.21564521f, 0.15984960f, 0.03122574f, 0.17606109f, 0.04762639f, -0.11441312f, -0.07257715f, 
    0.14176942f, 0.01089484f, 0.04178460f, 0.17727232f, 0.18228957f, 0.24489492f, 0.03547940f, 0.11619449f, 
    -0.08624440f, -0.05733660f, 0.07782132f, -0.27891713f, 0.12931889f, -0.24390683f, -0.05874540f, -0.01186321f, 
    0.11702842f, -0.03075093f, -0.06365073f, -0.06873488f, 0.16872689f, -0.02126844f, -0.10588771f, 0.13404673f, 
    -0.17626646f, 0.13625768f, -0.23253265f, -0.15271913f, -0.07421177f, -0.40068904f, -0.25432202f, 0.21147592f, 
    0.28486314f, -0.07013237f, 0.27682638f, -0.05391343f, -0.07082479f, -0.22148339f, 0.17704928f, 0.03692299f, 
    0.00893929f, 0.06685947f, 0.00706967f, 0.21172945f, -0.05036390f, 0.06436693f, -0.03143262f, -0.07106216f, 
    -0.02981668f, 0.02891122f, -0.14116071f, -0.02336831f, 0.29723796f, 0.11887508f, -0.12598838f, 0.06561748f, 
    -0.04395185f, -0.16883408f, 0.12585671f, 0.19793046f, -0.11490976f, 0.01912200f, 0.04798393f, 0.09947552f, 
    0.22734825f, 0.09355315f, 0.02986470f, 0.09207701f, 0.52416062f, -0.40978813f, 0.16445954f, 0.07940795f, 
    0.03670742f, -0.12090719f, -0.02805226f, 0.06748085f, 0.01648795f, -0.16792700f, -0.12593074f, -0.10365807f, 
    -0.12856361f, 0.14134030f, -0.23412776f, -0.27191490f, 0.01369968f, -0.18478636f, 0.03614565f, 0.17225438f, 
    -0.19954458f, 0.60603791f, -0.13765615f, -0.33577839f, 0.08968797f, -0.09947050f, -0.03620780f, -0.13448164f, 
    -0.10695764f, -0.06735267f, 0.18906857f, 0.00441360f, 0.06480417f, 0.05179597f, 0.12326904f, 0.01722680f, 
    -0.08153126f, -0.05335691f, -0.07518973f, -0.04519303f, -0.11676687f, 0.21820459f, 0.08353582f, 0.02629177f, 
    0.03196763f, -0.01217838f, -0.17158610f, -0.00340319f, -0.05601411f, -0.28367126f, 0.05937950f, 0.06614552f, 
    0.03755452f, 0.03670001f, 0.00378972f, -0.02053612f, -0.04493910f, -0.01279532f, -0.02027656f, 0.09676285f, 
    0.27669173f, 0.10750312f, -0.23062132f, 0.10229481f, 0.11682584f, 0.08725105f, -0.36311585f, -0.08469303f, 
    0.11463232f, 0.06812715f, 0.03977684f, 0.14455289f, 0.05244043f, -0.02213146f, 0.00504276f, -0.15406050f, 
    0.13073155f, 0.02312123f, -0.22585449f, 0.01270516f, -0.12746738f, 0.14300747f, -0.16599968f, 0.03950724f, 
    -0.14170532f, 0.20944104f, 0.10594011f, -0.08117339f, 0.08502036f, 0.07652080f, 0.07388049f, 0.12596050f, 
    -0.03655493f, 0.02888405f, 0.28506687f, -0.05356243f, -0.01130285f, 0.16046804f, -0.31324181f, 0.14375365f, 
    0.86009675f, -0.24468254f, -0.65570968f, -0.28500989f, -0.14720081f, 0.17674015f, -0.06006666f, 0.00398359f, 
    -0.05334678f, 0.16122293f, 0.22615860f, -0.00311965f, -0.02273552f, 0.01750926f, -0.15845615f, 0.12943785f, 
    -0.09828225f, -0.18075109f, -0.09826883f, 0.00901149f, -0.00416168f, 0.07597859f, 0.03736461f, -0.00210703f, 
    -0.10916323f, 0.15476924f, 0.07598543f, 0.09573403f, -0.17038059f, 0.01338929f, 0.00186301f, -0.06645621f, 
    0.04010822f, -0.13632385f, -0.11103792f, -0.12440781f, 0.01930486f, -0.12377722f, -0.09484196f, -0.01747554f, 
    -0.64795828f, 0.02039244f, -0.26989791f, -0.47986540f, 0.16610068f, 0.08791992f, -0.06690563f, 0.14895883f, 
    0.08981299f, 0.24920851f, -0.02425636f, -0.04848019f, -0.14896454f, 0.10004499f, 0.03005618f, -0.00563614f, 
    -0.02093284f, -0.08750292f, -0.07128606f, -0.02551880f, 0.05928016f, 0.23082858f, -0.13889648f, -0.11941537f, 
    0.07521114f, -0.10411794f, -0.14301115f, 0.12859939f, 0.20782390f, -0.22035497f, 0.13487947f, -0.16162302f, 
    -0.01463354f, 0.00415356f, -0.01512838f, -0.03686731f, -0.22734971f, 0.02250545f, 0.24547924f, 0.11563634f, 
    -0.60052234f, -0.40611994f, -0.19963430f, 0.00890571f, -0.19378194f, 0.04212638f, 0.08716040f, 0.22495791f, 
    0.01917911f, 0.13703698f, -0.16775011f, -0.05625300f, 0.02033862f, 0.01267302f, -0.14624240f, -0.11316384f, 
    0.03319743f, -0.10547593f, -0.22768107f, -0.03533986f, 0.92308468f, 0.12069719f, -0.37693575f, -0.03842621f, 
    0.20000364f, -0.26211640f, -0.05504243f, -0.01295626f, 0.08998864f, -0.06768698f, 0.15325627f, 0.08102780f, 
    0.00225708f, -0.00944850f, 0.02647068f, 0.05184151f, -0.03539276f, 0.04752623f, 0.11126080f, 0.10891666f, 
    -0.63644373f, 0.07842358f, -0.02366912f, -0.06735814f, 0.12438426f, 0.07611427f, 0.22498375f, 0.05189149f, 
    0.13777162f, -0.15075648f, -0.19232237f, 0.15560894f, 0.13071619f, 0.11984555f, 0.04303875f, -0.09020350f, 
    0.06639010f, -0.00161202f, -0.25356728f, -0.13248371f, -0.36013418f, 0.30190897f, -0.16475938f, -0.33495933f, 
    -0.06826019f, -0.23852505f, 0.11790765f, 0.06140665f, -0.12657532f, 0.10104197f, -0.09509227f, 0.09197795f, 
    -0.06227525f, -0.24994020f, 0.08181940f, 0.00253953f, 0.01238208f, -0.03336155f, 0.14081486f, -0.10259960f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11172488f, 0.04182647f, -0.03775751f, 0.00552102f, -0.01286646f, 0.11700734f, 0.00471616f, -0.10324761f, 
    0.01057920f, 0.02752447f, 0.21769731f, -0.01246017f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
