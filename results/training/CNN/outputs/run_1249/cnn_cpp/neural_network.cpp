#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.97894901f, -0.19611219f, -0.32541853f, 0.07441878f, 0.30555871f, 0.04400590f, 0.52775806f, -0.07382675f, 
    0.00366482f, 0.16990063f, 0.47782689f, -0.32701570f, 0.03335072f, 0.14596596f, -0.19207403f, 0.04383525f, 
    -0.03078507f, -0.11571711f, 0.08924869f, -0.25701717f, 0.00228919f, -0.19312051f, 0.25531641f, 0.15716235f, 
    0.17687853f, 0.11632569f, -0.03949546f, -0.52187616f, -0.60395789f, -1.08346057f, 0.66625607f, 0.15641771f, 
    -0.26993722f, -0.06024215f, 0.29434726f, -0.17361651f, 0.93917710f, -0.67595857f, 0.02642102f, -0.33376673f, 
    -0.28648067f, -0.39955831f, 0.24972616f, -0.36556461f, 0.13931045f, 0.14558600f, -0.28869817f, -0.21132116f, 
    0.26275113f, 0.21018885f, 0.26953611f, -0.41565400f, -0.25034356f, -0.21935219f, -0.78074253f, -0.43121734f, 
    -0.33861095f, -0.57262719f, -0.50557870f, -0.41195399f, 0.18411817f, -0.08104894f, -0.16098319f, -0.39571273f, 
    0.27555740f, 0.03234735f, 0.18931761f, 0.02034398f, -0.17974150f, -0.16070957f, -0.42648745f, -0.31891105f, 
    -0.24392216f, 0.07928869f, -0.26171595f, 0.59592861f, -0.61323386f, -0.60293424f, -0.50869691f, -0.70694464f, 
    0.35070926f, 0.70870268f, 0.08906542f, -0.27692667f, -0.55161357f, 0.37613255f, 0.16299854f, 0.30388159f, 
    -0.10179324f, -0.30823553f, -0.22888660f, -0.20274097f, -0.17944922f, -0.05452380f, 0.26987943f, -0.18702465f, 
    -0.00887700f, 0.06252103f, -0.35280445f, -0.65061831f, -0.23471530f, -1.07488906f, -0.43915763f, 0.73091233f, 
    0.44705528f, -0.14629354f, 0.20036799f, -0.76288861f, -0.72923845f, -0.43595490f, -0.36765099f, -0.16996081f, 
    -0.04885067f, -0.30810869f, -0.15333836f, -0.04359544f, -0.22003536f, -0.20722879f, 0.33056012f, 0.14460710f, 
    0.07110161f, -0.08366769f, -0.23930539f, -0.03098544f, -0.12079623f, 0.31319928f, 0.16218238f, 0.07892777f, 
    -0.15043189f, 0.42373192f, -0.32284045f, -0.35640877f, -0.47977731f, -0.28119406f, -0.01108303f, -0.07925082f, 
    0.05350543f, -0.14260229f, -0.27047190f, 0.65428209f, 0.00348894f, 0.38598639f, -0.37132129f, -0.36016282f, 
    -0.17142099f, -0.20628366f, -0.30109242f, -0.14920878f, 0.00770212f, -0.30591810f, -0.00749009f, 0.38204464f, 
    0.32883292f, 0.37564453f, -0.36776540f, 0.28539705f, -0.62713885f, -0.62194544f, -0.15235224f, 0.19213481f, 
    0.10308655f, -0.05428825f, -0.00105105f, 0.06504313f, -0.13017340f, -0.01482993f, 0.07668079f, 0.05750538f, 
    0.03422125f, -0.14911783f, -0.13752176f, -0.40788186f, 0.05915942f, -0.40951401f, -0.43524668f, 0.87575680f, 
    0.15012723f, 0.14818035f, -0.52991384f, -0.17155614f, 0.30812523f, 0.41866454f, 0.07157878f, -0.53849673f, 
    0.08317820f, 0.03310902f, -0.04342177f, -0.21701685f, -0.36067489f, -0.20600222f, 0.07945224f, -0.03291158f, 
    0.03289788f, -0.15993646f, -0.10859037f, 0.15708801f, -0.35925719f, -0.42305279f, -0.29831824f, -0.29739952f, 
    0.68655521f, 0.11521247f, 0.44358012f, 0.25933596f, 0.46601099f, 0.19232480f, 0.22979136f, 0.02012104f, 
    -0.02685308f, -0.06195486f, -0.00876157f, -0.09856012f, -0.02241500f, 0.01849810f, -0.13684417f, -0.03738792f, 
    0.02638041f, 0.08765437f, 0.10703882f, -0.10900959f, -0.12307691f, -0.18672922f, -0.28470218f, -0.24960953f, 
    -0.30923843f, 0.29118478f, 1.06740797f, 0.16379386f, -0.38368830f, -0.04661268f, -0.59134233f, -0.11380612f, 
    -0.15423743f, 0.09795109f, -0.07549359f, 0.08896851f, -0.27158627f, -0.31274739f, -0.33144006f, 0.23697972f, 
    0.34812984f, 0.03625326f, 0.04504145f, 0.02451385f, 0.09233120f, 0.26758879f, -0.19665505f, -0.45706198f, 
    -0.06591373f, -0.07976939f, -0.93158942f, -0.43649668f, -0.19111189f, 0.20497137f, 0.39039898f, 0.23499766f, 
    -0.79507136f, -0.94454056f, -0.29574072f, -0.07859229f, -0.20115963f, 0.10858811f, -0.22620489f, -0.43947595f, 
    -0.57485169f, -0.24165240f, -0.30342126f, -0.06172369f, -0.26310900f, -0.14043945f, -0.21219444f, 0.08001000f, 
    -0.08737236f, -0.24336717f, -0.35443062f, -0.96911585f, -0.41496721f, 0.60100216f, 0.76313961f, 0.32389173f, 
    -0.43908226f, -0.32279187f, 0.42326033f, 0.00559699f, -0.02016198f, -0.54225910f, -0.59097993f, 0.43736255f, 
    -0.37079307f, -0.01642851f, 0.08746827f, 0.32745001f, -0.01806508f, -0.19390629f, 0.13697439f, 0.30715185f, 
    -0.25072229f, -0.23308276f, 0.01555031f, 0.23127876f, 0.02536232f, -0.44061157f, -0.21164428f, -0.10867959f, 
    -0.57221419f, -0.67880374f, -0.73450851f, -0.65955889f, 0.07851118f, -0.49006027f, 0.47566646f, 0.51390797f, 
    0.24353401f, 0.09591820f, 0.23313388f, -0.04868322f, -0.18285981f, 0.07268059f, -0.04470414f, -0.18380141f, 
    0.00069317f, 0.13424011f, -0.18677664f, -0.10442583f, 0.20457922f, 0.53905648f, -0.89111650f, 0.04212042f, 
    0.53601623f, 0.23026165f, -0.33538240f, -0.03442309f, 0.26736790f, -0.60690212f, -0.18029593f, 0.03825785f, 
    0.08448661f, 0.23115289f, 0.01067075f, 0.15171885f, 0.10709441f, 0.19210757f, -0.30057338f, -0.10759534f, 
    0.42018434f, -0.11169983f, -0.32344171f, -0.17038059f, 0.23557416f, 0.19974424f, -0.28736278f, -0.50260192f, 
    -0.51955509f, -0.43779245f, -0.29771367f, -0.29594803f, -0.29968831f, 0.39425436f, -0.31979975f, -0.19478306f, 
    -0.13062067f, -0.41412789f, 0.40956178f, 0.28251725f, -0.24347632f, 0.08144961f, 0.00970701f, -0.31935799f, 
    -0.42302629f, -0.23155449f, 0.23719841f, 0.36491030f, 0.55723649f, 0.29376993f, 0.44809791f, -0.10176460f, 
    -0.49684253f, 0.21787718f, 0.26325604f, -0.23669554f, -0.65672523f, -0.69334364f, -0.47305885f, 0.17252965f, 
    0.21396817f, 0.08423626f, -0.25907519f, 0.05024265f, 0.49849886f, -0.06350816f, -0.07663918f, 0.02459950f, 
    -0.22442295f, -0.43508092f, -0.63295650f, -0.33598635f, -0.15632907f, -0.21492584f, -0.16763899f, -0.44675013f, 
    -0.79201621f, 0.22436367f, 0.24914955f, 0.26953962f, -0.13743995f, -0.23331028f, -0.06935389f, 0.22405456f, 
    0.20129581f, -0.00316735f, -0.25586018f, 0.54073870f, -0.35263470f, 0.43082646f, -0.29834676f, -0.37465504f, 
    -0.31240588f, -0.07791031f, 0.17153980f, 0.39860994f, 0.28836817f, 0.01892883f, 0.14212489f, 0.17575720f, 
    -0.26640785f, -0.11506160f, 0.36201233f, -0.40338552f, 0.17892048f, -0.03740311f, -0.69451308f, -0.37721622f, 
    0.38195559f, -0.54179561f, -0.54426533f, 0.08620220f, 0.20882629f, 0.35106283f, 0.13022953f, -0.34661126f, 
    0.05128139f, 0.21031664f, -0.01001689f, 0.03424398f, -0.45723087f, -0.32793692f, -0.13330299f, -0.09944624f, 
    -0.34625566f, 0.70909756f, 0.04930279f, -0.08460656f, -0.60843855f, -0.43975520f, 0.11502974f, 0.38858908f, 
    0.70182610f, 0.17665252f, 0.26690176f, -0.43969706f, -0.23983623f, -0.11245608f, -0.40267769f, -0.22657865f, 
    -0.07180039f, 0.18643937f, 0.44559401f, 0.33820665f, 0.15977013f, -0.19339836f, 0.15724909f, -0.11871368f, 
    -0.38407236f, -0.22765517f, 0.44708073f, -0.10526446f, -0.36464825f, 0.08995719f, 0.30299357f, 0.57848608f, 
    0.54531038f, 0.13850509f, 0.09827883f, 0.09786828f, -0.14198755f, 0.27595624f, -0.31962451f, 0.10391674f, 
    -0.37353384f, -0.09622476f, 0.14691079f, -0.24636227f, -0.37118396f, 0.24296370f, 0.11035889f, -0.34052363f, 
    0.10955405f, 0.30568019f, -0.14028372f, -0.27185377f, -0.13110347f, -0.41537946f, -0.46611479f, -0.40217546f, 
    0.48305869f, -0.00753092f, 0.17329212f, 0.09355363f, -0.57575804f, -0.24651906f, 0.44848511f, 0.17647067f, 
    0.04676919f, 0.20982489f, -0.23145071f, 0.35794684f, 0.29114160f, -0.00192328f, 0.10873553f, -0.30192021f, 
    -0.23773433f, -0.48581052f, 0.07931506f, -0.02648799f, -0.45878929f, 0.27286643f, 0.76789230f, 0.11598232f, 
    0.63351929f, 0.06069574f, -0.40605626f, 0.34563848f, -0.27159825f, -0.63859314f, -0.65226597f, 0.03156344f, 
    -0.04065148f, -0.00961510f, -0.02917478f, 0.23948443f, -0.19024822f, -0.20886013f, -0.01929607f, -0.28480262f, 
    0.38242552f, 0.01388986f, 0.02997964f, 0.14868428f, 0.19763522f, -0.30419973f, 0.10744959f, 0.71296698f, 
    0.50305426f, -0.47299227f, -0.49966612f, -0.36775002f, 0.17575295f, -0.06072083f, -0.10049174f, -0.03198965f, 
    0.23052345f, 0.07760246f, -0.04526901f, -0.09601450f, 0.11992452f, 0.22795959f, 0.29069951f, 0.07198802f, 
    0.21057786f, -0.19401667f, -0.19719280f, 0.60213357f, -0.30142999f, -0.33197796f, -0.07647516f, -0.48946074f, 
    -0.33320835f, -0.10029463f, 0.01744724f, 0.36306271f, -0.63519818f, -0.54229021f, -0.35178363f, 0.14607923f, 
    -0.52819723f, 0.15236838f, 0.54741901f, -0.01557218f, -0.44514513f, 0.17877884f, -0.18905273f, 0.02110144f, 
    0.30002925f, -0.50893420f, 0.03474437f, -0.13025425f, 0.12748584f, 0.09548291f, 0.02757335f, 0.39145795f, 
    -0.66537660f, -0.48868564f, -0.79708904f, -0.97350430f, -0.42766944f, 0.54743868f, 0.07577215f, 0.09773706f, 
    -0.08352550f, 0.15961280f, -0.21117076f, -0.08610567f, -0.21332285f, 0.05109813f, 0.43444481f, -0.10430210f, 
    -0.17413121f, -0.11761314f, 0.03762762f, -0.33587512f, 0.06177392f, -0.05074153f, -0.30980337f, -0.05631763f, 
    -0.37906945f, -1.31689942f, -0.11313476f, 0.40760741f, -0.92187351f, -0.66368651f, 0.33452702f, 0.53297818f, 
    0.26658982f, 0.28311530f, 0.51751131f, -0.03317255f, -0.08791237f, 0.10705828f, 0.15982877f, -0.23848444f, 
    -0.05580362f, -0.02258030f, -0.07188353f, -0.10869490f, -0.27871028f, -0.03519526f, 0.15664569f, 0.34450188f, 
    0.14084461f, -0.48068675f, 0.12826458f, -0.41990808f, 0.08866341f, 0.36857393f, 0.55271667f, 0.24413726f, 
    0.01481233f, -0.45773891f, -0.13581559f, 0.45725590f, -0.26367781f, 0.00438903f, 0.11614456f, 0.08613709f, 
    -0.30962610f, -0.28518313f, -0.22404580f, 0.12713605f, -0.27426943f, -0.61310446f, -0.03876957f, -0.12458012f, 
    0.00508098f, 0.38814190f, 0.55564296f, 0.65213245f, -0.25377133f, -0.27513793f, 0.44675118f, 0.36387745f, 
    -0.04947911f, 0.16019261f, 0.13287330f, -0.04011347f, 0.24712107f, -0.09447729f, -0.17652486f, -0.09379198f, 
    -0.24799302f, 0.50646526f, -0.13846406f, 0.01400289f, 0.05641951f, 0.10580593f, -0.21341872f, -0.36077476f, 
    -0.06736044f, 0.03404192f, -0.31128219f, -0.35478908f, 0.89072061f, -1.28274119f, -1.01360965f, -0.53394622f, 
    -0.14057228f, 0.30381319f, 0.04529761f, 0.61217415f, 0.55167294f, 0.19295123f, 0.00193430f, 0.37798378f, 
    0.19919653f, -0.37861007f, 0.24369060f, 0.26724499f, -0.10188770f, -0.16602188f, -0.21430190f, -0.20858018f, 
    -0.17099021f, -0.01245633f, -0.12021330f, 0.30494264f, 0.09835795f, -1.10215521f, 0.08284108f, -0.37155351f, 
    -1.15647972f, -0.77262288f, 0.50276041f, -0.04945577f, 0.04362264f, 0.14009002f, 0.28251281f, -0.26658759f, 
    -0.41672689f, -0.30992138f, -0.50815886f, -0.30761001f, 0.10486037f, -0.04442651f, -0.09939110f, 0.11649580f, 
    -0.08118517f, -0.18755648f, 0.11006062f, 0.05372648f, -0.19942708f, 0.07378452f, 0.35240880f, 0.31194156f, 
    -0.48648608f, -0.25777638f, -0.09615496f, -0.04536851f, 0.06995547f, 0.21672557f, 0.06336748f, -0.07301702f, 
    0.37298986f, -0.27030671f, -0.20801713f, 0.26477867f, -0.05499458f, -0.01809441f, -0.14425263f, -0.40613741f, 
    0.12163728f, 0.13158366f, 0.18636522f, -0.01473980f, 0.00541265f, 0.25666213f, 0.36363557f, 0.32273090f, 
    0.94781846f, 0.51045007f, -0.73401093f, 0.09776808f, -0.13983867f, -0.29563031f, 0.12972169f, -0.19224350f, 
    -0.51160842f, -0.24507198f, -0.07768501f, 0.41826510f, 0.17697997f, 0.10957733f, 0.43415880f, -0.35985571f, 
    -0.35394979f, 0.34484309f, 0.20522532f, 0.01112611f, 0.31225458f, 0.10237330f, -0.25751188f, 0.25770921f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06554697f, 0.42072222f, -0.33845693f, 0.30719578f, -0.00946902f, -0.01537851f, -0.19108588f, 0.10213794f, 
    -0.25673652f, 0.30854836f, -0.15266657f, -0.03321562f, 0.16193667f, 0.07511509f, -0.23540668f, -0.11929053f, 
    0.29547641f, 0.28119540f, -0.24614364f, 0.14533052f, -0.01875313f, 0.09056721f, 0.38601899f, 0.30825910f, 
    0.02615708f, 0.26619902f, 0.04896902f, 0.18573935f, 0.20132855f, -0.09991054f, 0.29183140f, 0.28862184f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01227828f, 0.07433645f, -0.02508990f, 0.12690409f, -0.04031929f, -0.09201838f, -0.10093806f, 0.07404812f, 
    -0.03916046f, -0.21707888f, 0.03601968f, 0.06672008f, 0.12361789f, 0.27189416f, -0.00496003f, -0.40041927f, 
    -0.21216017f, -0.01841478f, -0.01191844f, 0.16705146f, 0.21210258f, 0.00962830f, -0.24879506f, 0.02255930f, 
    0.14590296f, 0.25033703f, 0.12063733f, -0.17405891f, -0.14286767f, 0.02209774f, -0.02838744f, 0.04648470f, 
    -0.01135627f, 0.04498665f, -0.10489322f, -0.08107231f, 0.18660545f, 0.13969472f, 0.08703940f, -0.26716679f, 
    -0.11796749f, -0.09121377f, 0.15943569f, 0.08048141f, 0.13132280f, 0.22194971f, 0.30293089f, 0.23002061f, 
    -0.13765009f, -0.17743590f, 0.33690920f, -0.22283076f, -0.04329981f, -0.01036558f, -0.01594910f, 0.28622326f, 
    0.02302930f, -0.05353999f, -0.08645256f, -0.13329500f, 0.15097202f, 0.12541804f, -0.01827451f, -0.09851620f, 
    0.13415797f, 0.07439305f, -0.08860984f, 0.07441162f, 0.00934737f, 0.11484785f, 0.01515395f, -0.04918418f, 
    -0.01822798f, -0.09975678f, 0.04795656f, -0.20753604f, 0.09928413f, -0.06734841f, 0.03017981f, -0.00802112f, 
    0.05834737f, 0.07036576f, 0.27015224f, -0.10263921f, 0.36019263f, 0.04331179f, 0.09549335f, -0.06763180f, 
    0.05035711f, 0.02927321f, 0.03079122f, 0.08624054f, 0.05381302f, -0.04840326f, 0.12017831f, 0.26236111f, 
    0.29380459f, 0.18541162f, 0.09826806f, 0.11361007f, -0.05199206f, 0.05092916f, -0.09717192f, 0.01364199f, 
    0.19537844f, 0.08295267f, 0.06843411f, 0.06495240f, 0.33464995f, 0.30154592f, -0.06007506f, -0.01384971f, 
    0.12697123f, -0.04724205f, 0.10416505f, 0.16770184f, 0.03776892f, 0.03160667f, 0.03553595f, 0.19033878f, 
    -0.12970823f, -0.19778666f, 0.32089877f, 0.20417881f, -0.15565586f, -0.15442389f, 0.04864236f, 0.02111102f, 
    0.10277730f, 0.04130294f, -0.00104079f, -0.12400549f, -0.37746847f, -0.47046953f, -0.08444618f, 0.16080123f, 
    0.15132914f, 0.21858720f, 0.10302661f, -0.07950965f, 0.30306447f, 0.02172343f, 0.03164902f, -0.04013738f, 
    -0.27564526f, -0.02932668f, 0.29313314f, 0.13014808f, -0.13893254f, 0.00215207f, -0.07551618f, -0.04345064f, 
    0.09074976f, 0.04049197f, -0.02350648f, 0.05837942f, 0.04727789f, -0.14987949f, 0.08431615f, -0.32811186f, 
    0.04823778f, 0.41167843f, 0.19952884f, 0.11848692f, -0.08755511f, 0.12603389f, 0.01360558f, 0.08585577f, 
    -0.08336440f, -0.00887249f, 0.19173776f, -0.17803045f, -0.07711727f, -0.03382290f, 0.17904499f, -0.01132066f, 
    0.08246312f, -0.05570547f, 0.06989463f, -0.15878330f, -0.20758395f, -0.05120398f, -0.07706487f, 0.18017697f, 
    0.08879392f, 0.00974274f, 0.08985385f, -0.04276625f, 0.17499568f, -0.07511888f, 0.07227491f, 0.14379239f, 
    -0.01325698f, -0.11773324f, 0.04720577f, 0.25844663f, 0.23078823f, -0.12175706f, 0.14960283f, -0.00335204f, 
    0.16958569f, 0.01849731f, -0.06629509f, 0.09599771f, 0.00321776f, -0.03739727f, 0.06662364f, -0.07808593f, 
    0.08159216f, -0.04282647f, 0.13916647f, -0.05777971f, -0.02978577f, -0.22938985f, -0.01455027f, 0.08965997f, 
    -0.23672885f, -0.15524605f, 0.00973473f, -0.18795717f, -0.08428916f, 0.04052209f, -0.14389716f, -0.07354181f, 
    0.04819101f, -0.07424764f, -0.24545896f, 0.05699930f, 0.39543208f, 0.08764291f, -0.10672173f, 0.43671447f, 
    0.07954559f, 0.06284021f, -0.00090701f, 0.01070769f, 0.11960419f, 0.07070935f, 0.06615500f, -0.00143236f, 
    -0.05923157f, -0.07725233f, 0.14433235f, -0.15155163f, -0.09137122f, 0.01659260f, 0.10122708f, 0.01248783f, 
    0.30791953f, 0.10156329f, -0.00482813f, 0.05230418f, 0.65099829f, 0.59422815f, -0.12020078f, -0.11519015f, 
    -0.01348573f, -0.26841456f, 0.00876021f, -0.03667932f, -0.13923322f, 0.07315183f, -0.12387032f, 0.00625385f, 
    0.02418844f, 0.15418960f, -0.00496953f, -0.06331210f, 0.26411545f, 0.01735974f, 0.17842868f, 0.03036031f, 
    0.04754929f, -0.05341280f, 0.07031418f, 0.05441647f, -0.27818596f, 0.01645999f, -0.02805014f, 0.34150860f, 
    0.01056782f, 0.03500898f, 0.06380368f, -0.05154199f, -0.05352319f, 0.09967235f, 0.03507737f, -0.07549015f, 
    -0.11902715f, 0.14426413f, 0.38874733f, -0.03803147f, -0.18768638f, -0.10788178f, -0.09014131f, 0.16612490f, 
    0.16077885f, -0.03676037f, -0.09368638f, -0.04988959f, -0.36237293f, 0.36749610f, -0.26055446f, -0.19789189f, 
    0.00823441f, -0.22308834f, 0.06272979f, -0.10033115f, -0.07052714f, -0.23350479f, 0.06053064f, 0.04383302f, 
    0.10682322f, 0.21175094f, 0.40143195f, 0.17277773f, 0.00932219f, 0.01897313f, -0.00862880f, -0.00813656f, 
    -0.02762010f, -0.08330868f, -0.03235854f, -0.11054908f, 0.41451761f, 0.13556287f, 0.21825720f, 0.26752025f, 
    0.04055852f, 0.00367176f, 0.00292578f, -0.05687737f, 0.07850651f, 0.01855627f, 0.24465840f, 0.12575150f, 
    0.57038647f, -0.31319726f, 0.24133989f, -0.13458702f, -0.18244377f, -0.10800908f, -0.03594766f, 0.07722533f, 
    -0.04839635f, 0.07344943f, 0.00212984f, -0.24049237f, -0.39533705f, 0.39378521f, 0.21021473f, -0.15204598f, 
    -0.11622255f, -0.04382798f, 0.09277474f, 0.01930352f, -0.01267991f, -0.06345417f, -0.09782226f, -0.10639135f, 
    0.18265349f, 0.03109952f, 0.09869779f, 0.01927197f, 0.03378325f, 0.13681273f, 0.04347955f, 0.05903137f, 
    -0.12527716f, -0.09847290f, -0.11286458f, -0.00173637f, 0.25728816f, 0.10975757f, -0.00774391f, -0.03292881f, 
    -0.03147408f, 0.00319424f, 0.10571022f, -0.08914892f, -0.10289452f, -0.03037923f, -0.08619310f, 0.01716131f, 
    0.01438996f, -0.05601679f, -0.05674538f, -0.01827084f, 0.00428407f, -0.04968983f, 0.00708775f, -0.03983691f, 
    -0.01588362f, 0.04467624f, 0.03969467f, -0.03657269f, -0.00699613f, -0.03748141f, 0.01745650f, -0.05550067f, 
    0.02642564f, 0.03388193f, -0.04476699f, -0.01814516f, -0.05147850f, -0.05502195f, -0.04803213f, -0.00118547f, 
    0.01154999f, 0.03078191f, -0.00194470f, 0.03459180f, -0.04442467f, -0.03702654f, -0.01148931f, 0.04227846f, 
    -0.00004621f, -0.04188762f, -0.02382683f, -0.01159079f, -0.01599925f, 0.00101933f, 0.04158732f, -0.02296487f, 
    0.02032262f, 0.04848153f, -0.03870624f, -0.03750551f, -0.03651846f, -0.02016169f, -0.05054349f, -0.04246077f, 
    -0.00921183f, 0.00620497f, -0.03528406f, 0.04116042f, -0.01447372f, -0.02499909f, 0.00451651f, -0.04487837f, 
    -0.00626721f, 0.03145896f, -0.04078139f, -0.02519401f, 0.01917961f, 0.02603723f, -0.04767919f, 0.00623532f, 
    -0.03279513f, -0.05163772f, 0.04114196f, 0.04336116f, -0.03160011f, 0.01523397f, 0.03916120f, -0.01157332f, 
    0.03966574f, 0.00472449f, 0.00077315f, -0.01524025f, 0.03592490f, 0.02172590f, 0.04636896f, -0.00595499f, 
    0.01924117f, 0.02327005f, 0.02859798f, 0.00826304f, -0.01794215f, -0.05080606f, 0.03625608f, -0.03020451f, 
    0.00983595f, -0.02625757f, 0.04200250f, 0.03946413f, -0.02338263f, -0.03144585f, 0.01175686f, 0.03503912f, 
    -0.02798911f, -0.02618525f, -0.02643219f, 0.02178308f, 0.02813728f, 0.00291340f, 0.01784126f, 0.01035387f, 
    -0.05030501f, -0.04142926f, -0.03212116f, 0.01759310f, 0.00739138f, 0.05086366f, 0.00300759f, 0.00434956f, 
    -0.01416014f, -0.02506273f, -0.01065920f, 0.04498278f, -0.02225590f, -0.05095002f, -0.03186996f, 0.02038463f, 
    0.01514648f, 0.02595730f, 0.04371569f, -0.04865958f, -0.03040220f, -0.05559298f, 0.03010152f, 0.00637578f, 
    -0.03891723f, 0.02565062f, 0.01893236f, 0.00705360f, 0.01221583f, 0.00118401f, 0.00086466f, -0.02265809f, 
    0.01435600f, -0.02110171f, 0.02368083f, 0.00800786f, -0.02179795f, -0.04348923f, -0.02072278f, 0.01168617f, 
    -0.02423728f, -0.00320772f, 0.01432302f, 0.01741114f, -0.00276363f, 0.02713533f, 0.02284873f, -0.01249808f, 
    -0.03204796f, 0.03599744f, -0.05344554f, 0.01978740f, -0.00386283f, -0.04054791f, 0.00830474f, -0.02878277f, 
    0.01398919f, -0.04665621f, -0.02399212f, -0.00924981f, 0.02521791f, 0.02712669f, -0.04415353f, 0.03825425f, 
    -0.04833885f, 0.00330065f, 0.01109915f, 0.00071984f, -0.00573966f, -0.01616531f, -0.02425793f, 0.02984884f, 
    0.00713917f, -0.04017458f, -0.01972732f, 0.04424199f, -0.03429494f, 0.02578538f, 0.04680623f, 0.02465017f, 
    -0.04766260f, -0.03104195f, -0.03750109f, 0.00857662f, -0.00848040f, -0.02800457f, -0.04580894f, -0.03162049f, 
    -0.00155563f, -0.01659849f, -0.00892941f, 0.00335718f, 0.02312851f, 0.01480664f, 0.00273207f, 0.01335038f, 
    0.00983876f, 0.04075851f, -0.01733853f, 0.01685915f, -0.02907870f, -0.02056002f, 0.03041227f, 0.03045843f, 
    -0.04785647f, -0.03092497f, -0.02500186f, -0.02138497f, 0.02769892f, -0.01134289f, 0.03855963f, -0.02672838f, 
    0.00427668f, -0.01215772f, 0.01696685f, 0.02181322f, -0.03929199f, -0.03014689f, 0.03186151f, 0.03336576f, 
    0.03995252f, 0.01412368f, -0.03377578f, -0.00158099f, 0.03637761f, 0.02676640f, 0.01456241f, -0.02929400f, 
    -0.03921739f, 0.00341025f, -0.01658493f, 0.01191663f, -0.03165107f, -0.02105540f, -0.00345124f, -0.04120775f, 
    0.02252125f, -0.04214856f, 0.02901969f, -0.02445306f, -0.03614895f, 0.04121843f, -0.02360131f, -0.01497738f, 
    -0.00884144f, -0.04923280f, -0.05099743f, 0.00543623f, 0.01026217f, -0.03877772f, 0.03876530f, 0.01930525f, 
    0.01557072f, 0.00372212f, -0.01056126f, -0.02624830f, -0.01990456f, 0.01665695f, 0.00132865f, 0.00557704f, 
    -0.04806006f, -0.00061251f, -0.01675106f, 0.02158294f, -0.03602890f, -0.05466027f, -0.00343583f, 0.00620220f, 
    0.02415890f, -0.03975881f, 0.00714117f, -0.05564681f, 0.00811853f, -0.03106886f, 0.02823518f, -0.00993440f, 
    -0.00858030f, -0.01677732f, 0.04243873f, 0.02755818f, -0.00648429f, 0.03058921f, -0.02653600f, 0.03323339f, 
    0.03044899f, -0.01964624f, 0.01194329f, -0.05071739f, 0.03932701f, -0.01158006f, -0.04083302f, -0.02438545f, 
    0.01749684f, -0.00473566f, 0.03372898f, -0.05098762f, 0.04273421f, -0.00092593f, 0.02210948f, -0.04991421f, 
    -0.04818666f, 0.04279497f, -0.01923223f, 0.02484095f, -0.04522516f, 0.01629291f, 0.01246902f, -0.01285352f, 
    -0.04343857f, -0.02640591f, 0.04013195f, 0.02654014f, -0.03678913f, -0.03615187f, -0.05510389f, 0.00559520f, 
    0.00310901f, 0.01503044f, 0.03115860f, -0.00025462f, -0.02111409f, 0.00883514f, 0.01755521f, -0.03928532f, 
    0.02431108f, -0.04397123f, 0.02140152f, -0.05549544f, 0.02932995f, -0.03819037f, -0.03515109f, -0.00454478f, 
    0.03469877f, -0.04589488f, -0.04056629f, -0.05405239f, -0.04229952f, -0.01296138f, -0.00280454f, 0.01567198f, 
    -0.01131610f, -0.03343707f, -0.02111987f, 0.01154021f, 0.04095438f, -0.03804649f, -0.03880722f, -0.05486816f, 
    -0.02106831f, 0.02669865f, -0.04133169f, -0.01065340f, -0.05399972f, 0.03579143f, 0.01607317f, -0.03859387f, 
    -0.04707487f, -0.01208210f, 0.01084639f, 0.03153191f, -0.03442709f, 0.04123870f, 0.03867393f, -0.03399022f, 
    -0.03139462f, 0.00569785f, -0.00486111f, -0.00972863f, -0.02209876f, -0.00590199f, 0.02688682f, -0.02373776f, 
    -0.03147538f, 0.02144782f, -0.02988040f, -0.01230842f, -0.00173849f, -0.05044140f, 0.04166773f, -0.02181040f, 
    0.38149464f, 0.15517852f, -0.21070489f, -0.23938562f, -0.06440882f, 0.05629907f, 0.00383129f, 0.01527255f, 
    0.14336483f, 0.06738531f, -0.06566568f, -0.07674049f, -0.06897181f, -0.50087404f, -0.46664461f, -0.01926705f, 
    -0.09553975f, 0.24188079f, 0.12779461f, -0.09802931f, 0.06446831f, -0.13649264f, 0.23263256f, -0.09692808f, 
    0.28562182f, 0.18043290f, 0.12630175f, 0.15662903f, 0.31357408f, 0.08632279f, 0.03950218f, 0.00729319f, 
    -0.01679833f, -0.06604397f, 0.06240595f, 0.08712294f, 0.05939704f, -0.17261781f, -0.32298845f, -0.04938176f, 
    0.13737309f, 0.11436747f, -0.05604059f, 0.18918614f, 0.10751240f, -0.14011677f, -0.01820571f, -0.07728047f, 
    0.57163411f, 0.34305131f, 0.26211518f, -0.39069286f, 0.15825708f, -0.07904918f, 0.07769994f, -0.17198734f, 
    -0.10137311f, 0.00853488f, -0.00547530f, 0.01596196f, -0.12385382f, -0.01255166f, 0.11852993f, 0.02635179f, 
    -0.11411188f, -0.08958527f, -0.06064474f, -0.07393150f, -0.01564385f, -0.06875389f, 0.22770730f, 0.10702191f, 
    -0.03213283f, 0.02348063f, 0.00120201f, -0.03692809f, 0.00375956f, -0.18688066f, -0.17108695f, 0.17195386f, 
    0.07515929f, -0.02270116f, 0.15533815f, 0.11215580f, -0.06014865f, -0.12185380f, -0.03556350f, 0.12682970f, 
    -0.05473901f, -0.01333483f, -0.01689265f, -0.04468763f, 0.17635949f, -0.09775309f, -0.10269281f, -0.23282550f, 
    -0.03668998f, 0.05905053f, 0.06276697f, 0.11745117f, 0.04689089f, 0.00531424f, -0.06331082f, -0.13817818f, 
    0.24218485f, 0.12719510f, 0.12511142f, 0.21107069f, -0.33439642f, 0.14328055f, 0.04635639f, 0.16363244f, 
    0.11786871f, -0.00223941f, -0.31583279f, -0.07702492f, 0.09950513f, 0.11742002f, 0.11163714f, -0.05858601f, 
    0.34186190f, 0.44974348f, 0.34303582f, -0.21615438f, -0.09283406f, -0.09147917f, 0.10041104f, 0.25760961f, 
    0.06634656f, -0.04327429f, -0.12760180f, 0.14091788f, 0.61871016f, 0.22084862f, 0.23477155f, 0.07016277f, 
    0.13152155f, -0.30025128f, -0.10035049f, -0.04209493f, -0.12123693f, 0.05708633f, -0.07568767f, -0.00880219f, 
    0.49269527f, 0.19442539f, 0.15319517f, 0.10924722f, -0.10421413f, 0.13863833f, -0.02157033f, 0.06664242f, 
    0.02096121f, -0.04659503f, 0.05509929f, 0.02332301f, 0.15087032f, 0.01248904f, -0.09095074f, 0.15050611f, 
    0.01959039f, -0.17196196f, 0.25843409f, -0.15574370f, 0.04199223f, -0.03378147f, -0.07876147f, 0.08323585f, 
    0.10249401f, 0.04742775f, 0.10656887f, 0.22941847f, 0.29971474f, 0.18804514f, 0.12978722f, 0.00458909f, 
    -0.04084053f, 0.10919949f, -0.01683345f, -0.00602753f, 0.36494800f, 0.13922976f, 0.49678549f, -0.09747525f, 
    -0.06142063f, -0.03175680f, -0.02107198f, 0.02569073f, 0.01930657f, 0.00634025f, -0.04951070f, -0.10311454f, 
    0.20104831f, -0.21150978f, -0.04155013f, -0.00270852f, -0.13834980f, -0.04558176f, -0.00820349f, 0.03952832f, 
    -0.21881364f, 0.02893069f, -0.05114449f, -0.07694811f, 0.13390197f, 0.39114675f, -0.10524312f, 0.25434741f, 
    -0.21802101f, -0.07398241f, -0.09186646f, 0.03497634f, -0.00853156f, 0.03642950f, 0.02620946f, 0.12526934f, 
    0.11884011f, -0.00863397f, -0.38111362f, 0.06846114f, -0.08221577f, 0.14116879f, 0.07661922f, -0.08314819f, 
    -0.04327048f, -0.03813162f, -0.18390878f, 0.12554890f, 0.32207793f, 0.01714281f, 0.28453875f, -0.27663037f, 
    -0.00687140f, -0.11745075f, 0.11204942f, 0.05306057f, 0.04497395f, 0.04551873f, -0.13992986f, -0.11130276f, 
    0.04159598f, 0.07324890f, -0.27301836f, -0.01580887f, 0.01649541f, 0.05194240f, 0.22052750f, -0.00614404f, 
    -0.09021556f, -0.08423626f, -0.17533500f, -0.01667316f, -0.14022194f, 0.04866724f, 0.00298517f, 0.39062288f, 
    -0.15602295f, 0.00029843f, -0.18030217f, 0.01253455f, -0.01133918f, 0.02057238f, 0.05683106f, 0.03505382f, 
    -0.11580973f, 0.08410100f, -0.00704093f, 0.14339551f, 0.20818613f, 0.14167444f, -0.04519644f, 0.17716971f, 
    0.04988535f, 0.09966356f, 0.13024740f, -0.02273735f, 0.33243033f, 0.08423904f, 0.14531177f, -0.03946202f, 
    0.09455106f, -0.13957447f, -0.00049251f, -0.08116202f, 0.05502114f, 0.12871718f, 0.00296812f, 0.04323089f, 
    0.09112872f, -0.10991449f, -0.32183513f, -0.14481394f, 0.20654733f, 0.28067484f, 0.04385103f, -0.00325552f, 
    -0.08894672f, -0.14996478f, -0.15505268f, -0.09372443f, -0.10299359f, -0.48824561f, -0.23334947f, -0.18304023f, 
    -0.00954219f, 0.09829252f, -0.16608866f, 0.28733113f, 0.18016204f, 0.12018660f, 0.05762592f, -0.18834135f, 
    0.22660820f, -0.12206960f, 0.22084032f, 0.02194335f, 0.03607230f, -0.01651962f, -0.00075384f, 0.03822133f, 
    0.10648361f, 0.00822749f, -0.03659008f, 0.20847291f, -0.05794025f, -0.23195998f, 0.12351998f, -0.15773477f, 
    0.00032360f, -0.04806926f, -0.03215556f, -0.05007732f, -0.13347438f, -0.01098132f, -0.28709972f, -0.10363255f, 
    0.22482584f, -0.51245385f, -0.43135595f, -0.04607815f, 0.08520747f, 0.13077506f, 0.14892574f, -0.01056862f, 
    0.28555176f, 0.03123544f, -0.06626652f, -0.05942074f, 0.05656455f, -0.00652928f, -0.23028363f, -0.10270153f, 
    -0.00904590f, 0.02237704f, 0.03870220f, 0.08071145f, -0.08986366f, -0.06460196f, -0.02432376f, 0.08319272f, 
    -0.13194543f, 0.06247516f, 0.07875360f, 0.10448759f, 0.04756723f, 0.09158816f, -0.10077092f, -0.07452240f, 
    0.04666856f, 0.04200453f, 0.05247561f, 0.03441608f, -0.23878810f, 0.13087466f, -0.10564554f, 0.18670654f, 
    0.03470132f, 0.01229804f, -0.01353312f, -0.07001419f, -0.00205613f, 0.09648087f, 0.01023152f, 0.00648027f, 
    -0.02343526f, -0.05466215f, -0.01766459f, -0.00070884f, -0.02506307f, -0.00932105f, 0.04208441f, 0.00463649f, 
    0.01193246f, -0.03648778f, -0.03321417f, 0.02385487f, -0.03429263f, -0.05423494f, -0.03239061f, -0.01605959f, 
    -0.02730852f, 0.01265389f, 0.00887298f, 0.03533356f, -0.01549914f, -0.00662969f, 0.04258326f, -0.01301915f, 
    0.03436438f, 0.02190161f, 0.04754696f, -0.03011165f, -0.00717265f, -0.05903543f, -0.01672695f, 0.01025137f, 
    -0.01111396f, -0.00635460f, 0.00889727f, 0.01333188f, -0.02438879f, -0.04309038f, -0.00456292f, -0.03601241f, 
    -0.05695151f, 0.03704093f, 0.01877184f, 0.01791891f, 0.01351290f, -0.01389108f, -0.03766586f, -0.01659867f, 
    -0.00170228f, 0.00419063f, 0.00163879f, -0.00059317f, -0.04179211f, -0.02102723f, 0.03072372f, 0.00191295f, 
    0.01190068f, -0.03776546f, -0.03743149f, 0.01805468f, 0.03069970f, 0.00259115f, -0.01571621f, 0.01142631f, 
    -0.05279378f, 0.03508530f, -0.01833531f, 0.01000838f, 0.03966474f, 0.03319421f, -0.01803356f, 0.02017240f, 
    -0.04440470f, -0.04648271f, 0.03700378f, 0.04944119f, 0.03427812f, 0.00441559f, -0.02166784f, 0.00266704f, 
    -0.00429897f, -0.04893336f, 0.01729183f, 0.01647554f, 0.01618024f, 0.00686817f, -0.05507742f, -0.01066432f, 
    0.01665698f, 0.00834068f, -0.04482445f, -0.01320336f, 0.03971821f, 0.03574423f, 0.03793704f, -0.00405878f, 
    -0.02477001f, 0.01295005f, 0.03304764f, -0.03690512f, 0.00559138f, -0.04483139f, 0.01453370f, -0.01058208f, 
    -0.00879100f, -0.06158356f, 0.01460248f, 0.01907974f, -0.03126084f, -0.04162946f, 0.01605035f, -0.01929967f, 
    0.03384631f, -0.05254906f, -0.04457008f, -0.04907749f, -0.04598811f, -0.02656461f, 0.03856226f, 0.01672658f, 
    0.01974533f, -0.00414398f, -0.05139462f, -0.03671440f, -0.00978000f, -0.02497373f, 0.03527995f, 0.03719032f, 
    0.01940565f, -0.02810642f, -0.00788655f, 0.04194276f, 0.05531032f, 0.03937475f, 0.03965729f, -0.05870032f, 
    -0.00244170f, -0.01393118f, -0.04498787f, 0.03039127f, -0.03162173f, 0.04456212f, -0.04372357f, -0.02696091f, 
    -0.03244063f, 0.00382136f, -0.02347448f, -0.02366961f, 0.03818844f, -0.01610054f, 0.01193081f, 0.03224951f, 
    -0.00117855f, 0.04118416f, 0.03066861f, 0.02459256f, 0.02255623f, 0.00772015f, -0.00997656f, 0.02737917f, 
    0.02579909f, 0.02202849f, 0.02584439f, 0.00536789f, -0.01898801f, 0.00876279f, 0.00293442f, -0.02643429f, 
    -0.04177754f, -0.02402314f, -0.00909666f, -0.03328815f, -0.02472059f, -0.05641504f, 0.03864160f, -0.02662668f, 
    -0.03017183f, -0.02122248f, 0.00277291f, 0.02237721f, -0.03750720f, -0.01018038f, 0.01448471f, -0.00209120f, 
    0.03688828f, 0.02307668f, -0.00387840f, 0.03454434f, 0.03051141f, 0.01906185f, 0.02341628f, 0.01547888f, 
    0.01557376f, 0.03977110f, -0.02085780f, 0.03944306f, -0.04598036f, -0.01738438f, 0.02927168f, -0.02355221f, 
    -0.03730107f, -0.03122823f, 0.03730363f, -0.04295678f, -0.00562887f, -0.03359975f, -0.01197883f, 0.03750016f, 
    -0.01621147f, 0.01014696f, 0.02644699f, -0.02783576f, 0.00810849f, 0.00620249f, 0.02563716f, 0.02903518f, 
    -0.03025712f, -0.00426357f, -0.02547618f, -0.02570281f, -0.00864924f, 0.00072589f, -0.04640493f, -0.01582797f, 
    -0.05628481f, -0.04655521f, 0.00741758f, -0.04590783f, -0.00637550f, -0.04679606f, -0.03035289f, -0.03531380f, 
    -0.03130425f, -0.03583896f, -0.04170129f, 0.01354925f, 0.00859256f, 0.01625588f, 0.04129795f, 0.00762367f, 
    -0.04082352f, -0.02482500f, 0.02031856f, 0.01972100f, -0.03404151f, 0.00103479f, -0.04963641f, 0.04039713f, 
    0.03162611f, 0.01179178f, 0.02934673f, 0.02373606f, 0.00576851f, 0.00628554f, -0.01128472f, -0.00812958f, 
    -0.00276017f, 0.03443573f, -0.01071397f, -0.04311300f, 0.00059283f, -0.01267464f, -0.04704954f, -0.01663398f, 
    0.03893645f, 0.01618477f, 0.02569326f, 0.01015454f, 0.02889356f, -0.02227050f, -0.03229089f, -0.04348207f, 
    -0.04868227f, -0.01468851f, 0.03077486f, 0.02427158f, -0.02787781f, 0.02632660f, 0.00293493f, 0.04266558f, 
    -0.05233536f, 0.01300880f, -0.01596384f, -0.01444703f, 0.00345954f, -0.02707480f, -0.03713723f, -0.04088753f, 
    -0.05715040f, -0.05217901f, 0.00969431f, -0.01292171f, 0.02128772f, 0.03409540f, 0.00590720f, 0.01517511f, 
    -0.02558572f, -0.02985712f, 0.03672297f, -0.03608128f, 0.02437410f, -0.05225497f, 0.00631311f, 0.02780758f, 
    -0.05150302f, 0.03714227f, -0.05196775f, -0.02459543f, -0.04969886f, -0.05741658f, -0.02620874f, -0.04657569f, 
    0.02642167f, 0.03165380f, -0.00948821f, 0.02880129f, 0.04465723f, -0.04561565f, 0.04111765f, -0.04823780f, 
    -0.05193697f, -0.05594515f, -0.01389918f, -0.04630164f, -0.05771562f, -0.01300931f, -0.02200406f, -0.02294187f, 
    -0.01985649f, -0.02693377f, 0.01834490f, 0.03012338f, 0.02154134f, 0.02925423f, 0.03607430f, -0.04562737f, 
    -0.04300535f, -0.00148021f, 0.02001184f, 0.02112788f, 0.03582589f, -0.05221947f, -0.01007564f, -0.03765523f, 
    0.00065535f, 0.02303891f, -0.03930627f, 0.02305829f, 0.01143019f, 0.00485010f, 0.03207380f, 0.02166704f, 
    -0.01774650f, 0.01356523f, 0.00777376f, -0.03665951f, -0.00124687f, 0.03169725f, 0.04750047f, -0.00119023f, 
    0.00719010f, -0.02706251f, 0.04125692f, 0.00304776f, 0.00230640f, -0.02146949f, 0.01600955f, -0.03217612f, 
    0.03470674f, -0.04263566f, -0.05479552f, 0.00981839f, 0.01205853f, 0.00320309f, 0.01481816f, 0.01609164f, 
    0.00095723f, 0.01379005f, -0.01270400f, 0.02353275f, -0.05908080f, 0.03541445f, -0.04265435f, -0.05857669f, 
    -0.02454706f, -0.18653056f, -0.13029951f, -0.23490976f, -0.03617984f, 0.23093706f, 0.18710446f, 0.01829471f, 
    0.19365387f, -0.05777702f, 0.21640043f, 0.15767127f, 0.14757696f, -0.11057998f, -0.01570391f, 0.07628943f, 
    0.00983798f, 0.27929974f, 0.17026430f, 0.21916750f, 0.20101421f, -0.00807712f, -0.04898693f, 0.12272678f, 
    0.00142687f, -0.16218016f, 0.01944529f, 0.04057283f, 0.09199509f, -0.01175532f, -0.02538255f, -0.13797912f, 
    -0.01859157f, 0.00091645f, -0.14548624f, 0.09338566f, 0.24062979f, -0.27027068f, -0.19069947f, 0.19375670f, 
    -0.05141288f, -0.05057743f, 0.15326943f, 0.27735233f, -0.05123126f, 0.05562426f, -0.10145719f, -0.12539540f, 
    0.31857228f, 0.36844516f, -0.24827915f, 0.06686039f, -0.01386179f, -0.12314803f, 0.15136199f, 0.09626649f, 
    0.05559262f, -0.00246558f, 0.07460172f, -0.05454915f, -0.17594746f, -0.11287405f, 0.13149656f, 0.04861751f, 
    0.04021758f, -0.15190683f, -0.01585592f, 0.03717560f, -0.06906058f, 0.13652654f, -0.23228538f, 0.08919109f, 
    -0.36288613f, 0.36593747f, 0.16705978f, -0.15069191f, 0.02501974f, -0.08823379f, -0.05813139f, 0.05824899f, 
    -0.16055299f, -0.05727091f, -0.06414051f, -0.13250601f, 0.01014159f, -0.07214382f, 0.14434479f, 0.05432916f, 
    -0.09458951f, -0.00977336f, -0.22986217f, 0.02425950f, -0.11581282f, -0.27977425f, -0.04390328f, 0.00977927f, 
    -0.07760003f, 0.03921692f, 0.03791562f, 0.10788047f, -0.15983948f, -0.15545291f, -0.25666022f, -0.18959461f, 
    -0.23405911f, -0.23494302f, 0.07678942f, -0.08047909f, -0.34075284f, -0.21394120f, 0.67573333f, -0.03832215f, 
    -0.00610830f, -0.06489635f, -0.10622480f, 0.09070025f, -0.15855503f, -0.00335058f, -0.07331141f, 0.03912710f, 
    0.11210149f, 0.37282440f, -0.39804992f, -0.04432077f, 0.08671183f, -0.09835400f, 0.16049896f, 0.22252391f, 
    0.02632255f, 0.01267716f, -0.16012594f, -0.07954306f, 0.04743680f, 0.49379042f, 0.09455352f, 0.05818542f, 
    0.24775925f, -0.03820137f, -0.10012182f, -0.00765585f, 0.07357582f, 0.12013593f, -0.07374987f, -0.04255513f, 
    -0.07011929f, -0.04466173f, -0.26646250f, -0.04806944f, 0.22990255f, 0.34574121f, 0.06132408f, 0.26300833f, 
    -0.06999613f, 0.07092194f, 0.00200289f, 0.09408481f, -0.05356090f, 0.16189218f, -0.36725295f, 0.15534081f, 
    -0.03617174f, 0.00478077f, -0.03283722f, -0.01052449f, 0.29932928f, 0.01128764f, 0.03727886f, -0.03205457f, 
    0.16310991f, 0.15358774f, 0.09585464f, 0.35385245f, -0.01037725f, 0.28926051f, 0.30879894f, -0.14571711f, 
    -0.04296977f, -0.02562270f, 0.07115776f, -0.02162367f, -0.10779095f, 0.03655705f, 0.13157022f, -0.21047032f, 
    0.14830227f, -0.10638328f, 0.01496627f, 0.18248214f, -0.08740599f, -0.06897849f, -0.06202966f, -0.12992349f, 
    0.19521180f, 0.08798616f, -0.16447219f, -0.39889151f, 0.02367933f, -0.22712414f, 0.12578724f, 0.16234738f, 
    0.04442980f, 0.04882932f, 0.06755677f, -0.05516234f, 0.14120738f, 0.07548647f, 0.03047870f, 0.17495511f, 
    0.04113865f, 0.29192498f, 0.14804856f, -0.14724323f, 0.12139154f, 0.12198220f, 0.06969155f, 0.17602161f, 
    0.36382672f, 0.19568320f, -0.08792188f, -0.12896208f, -0.06640019f, 0.02603775f, -0.08015113f, -0.03631671f, 
    0.09772015f, -0.07366686f, -0.14494352f, -0.00383336f, 0.07739218f, 0.03074035f, -0.23475352f, 0.09266710f, 
    -0.12981774f, -0.24011931f, 0.12461489f, -0.12546007f, -0.07791675f, 0.08944244f, 0.16503178f, 0.13093552f, 
    0.00039364f, -0.28516847f, -0.19919281f, 0.02719793f, 0.04115935f, 0.13870893f, 0.36336386f, 0.06748144f, 
    -0.00578248f, -0.08772250f, -0.12434595f, 0.15911460f, -0.09480940f, 0.04753318f, 0.13676365f, -0.16852537f, 
    -0.16332321f, -0.25909793f, -0.14991876f, 0.04688273f, -0.16697384f, -0.00168458f, -0.05715400f, -0.02479026f, 
    -0.30208719f, -0.11764630f, 0.22975741f, -0.09515363f, -0.02270802f, 0.19601269f, -0.11121660f, 0.11790258f, 
    -0.06510635f, 0.12635864f, -0.06871090f, 0.13898253f, 0.24434404f, 0.16853596f, -0.23080936f, 0.08854243f, 
    0.17611992f, 0.29846105f, 0.07794074f, 0.28853208f, 0.01386709f, 0.26411235f, -0.01376063f, 0.13304235f, 
    0.20343406f, 0.17906366f, 0.12406310f, 0.24754007f, 0.17452991f, 0.17459291f, 0.10518434f, 0.09831598f, 
    -0.14519522f, 0.00179517f, -0.05474344f, -0.05090408f, 0.57031083f, -0.07826640f, 0.19817407f, 0.04202323f, 
    0.00479504f, 0.07544941f, 0.03128721f, 0.06042590f, 0.01895131f, 0.00291020f, 0.06744855f, 0.05480387f, 
    -0.03279964f, 0.56335497f, 0.04320609f, 0.36714223f, -0.18291488f, -0.06304989f, 0.00107358f, -0.18511741f, 
    0.09720276f, -0.12346447f, 0.16656461f, 0.13838458f, -0.12503500f, -0.01848433f, 0.09270543f, 0.12593150f, 
    -0.11419678f, 0.00823334f, -0.13253409f, -0.29339406f, -0.10698175f, 0.05511609f, -0.24647662f, -0.13090934f, 
    0.14876078f, -0.05862336f, -0.22303414f, 0.02634199f, -0.04433978f, 0.08989020f, 0.11634891f, -0.23087265f, 
    0.08931240f, 0.19853558f, -0.19141902f, 0.10400719f, 0.49467006f, 0.39983386f, 0.05365868f, 0.27025846f, 
    0.11866498f, 0.26704115f, 0.10233350f, 0.02463644f, 0.03634547f, 0.10024986f, -0.16538054f, 0.07645290f, 
    -0.20353167f, -0.10217945f, -0.03098522f, 0.07137547f, -0.11830960f, 0.03112600f, 0.06169011f, -0.15283217f, 
    0.18089749f, 0.04637468f, 0.12962219f, 0.12522559f, 0.03027817f, -0.17479910f, 0.02462193f, -0.01314263f, 
    -0.04968793f, -0.11301743f, -0.04042411f, 0.04464256f, -0.01368659f, -0.00490235f, 0.16096102f, -0.00626753f, 
    -0.50358337f, -0.06938899f, -0.07716393f, 0.09734643f, 0.25408280f, -0.03605538f, 0.00949816f, 0.03498590f, 
    -0.03393370f, -0.08237599f, 0.11741358f, -0.10769913f, -0.01574190f, 0.23808943f, -0.34912741f, -0.06115789f, 
    0.02049903f, 0.12525514f, -0.08358882f, 0.14634152f, 0.13485223f, 0.15750372f, -0.09693713f, 0.16307631f, 
    0.08373138f, 0.01699234f, 0.12721446f, -0.10537988f, -0.16960001f, -0.03171885f, -0.04840158f, -0.03998769f, 
    0.08356616f, 0.11676324f, -0.04593888f, 0.05103230f, 0.15751798f, 0.27917495f, -0.25204068f, 0.05153206f, 
    0.00873144f, 0.01090941f, 0.06549699f, -0.16117342f, -0.10336233f, 0.27980009f, 0.29598826f, 0.21739839f, 
    -0.19729924f, 0.29578784f, 0.05897056f, 0.18232086f, -0.08151949f, 0.01043136f, 0.19629851f, 0.01142334f, 
    0.11708623f, 0.02868488f, -0.07043664f, -0.02447408f, 0.25048926f, -0.01855572f, 0.04321571f, -0.00708777f, 
    -0.11995529f, -0.03756065f, 0.00336038f, 0.06336414f, -0.00395822f, 0.16306503f, 0.07395046f, 0.10292169f, 
    -0.08553664f, 0.07117512f, 0.12172068f, 0.04924412f, 0.00538888f, -0.04024123f, -0.07296251f, -0.00685913f, 
    0.10885753f, -0.04082710f, 0.19447312f, -0.03842822f, 0.11520256f, -0.04657427f, -0.22670159f, -0.18601032f, 
    -0.04155469f, 0.06579286f, 0.02953040f, -0.04335588f, 0.07738198f, 0.05784092f, 0.20896862f, 0.08938866f, 
    0.00589557f, -0.06035027f, -0.18337211f, 0.00403942f, -0.02230170f, 0.07014215f, -0.08401934f, -0.04784985f, 
    0.09993312f, 0.03420664f, 0.08469997f, 0.08351571f, 0.50433487f, 0.01085504f, 0.18290420f, -0.20775917f, 
    -0.00711989f, -0.01295375f, -0.12557611f, 0.19922838f, 0.10902832f, 0.07697474f, -0.00432813f, 0.00333050f, 
    -0.32492512f, 0.12442749f, 0.21689793f, 0.14414234f, -0.06292712f, -0.06382323f, -0.03316420f, -0.11208379f, 
    0.03032331f, 0.00746667f, -0.02001238f, -0.03770362f, -0.33100343f, -0.05402962f, 0.09831208f, -0.08739384f, 
    0.08105902f, -0.00837683f, 0.03612517f, -0.06820564f, 0.06422817f, 0.03994548f, -0.06632198f, -0.01524366f, 
    0.18690211f, 0.14325438f, 0.09454053f, -0.02488964f, 0.02732871f, 0.14747699f, -0.11243961f, -0.03470439f, 
    0.00928146f, 0.01052277f, -0.04119787f, -0.00389648f, 0.14250426f, 0.08853511f, -0.05322858f, 0.05928890f, 
    -0.02689032f, 0.01298441f, 0.25685516f, 0.13845833f, -0.00980652f, 0.07657937f, -0.11600873f, 0.04590968f, 
    0.18605638f, 0.16701010f, 0.34458101f, 0.20182091f, -0.03857673f, -0.03776349f, 0.22732662f, -0.28839254f, 
    0.05205074f, -0.13613993f, -0.09922283f, -0.16021298f, -0.28254718f, -0.19660340f, 0.09898644f, 0.02459507f, 
    0.03225728f, 0.01626807f, 0.04977300f, 0.00289211f, 0.15604213f, -0.08106973f, 0.19727066f, 0.34460878f, 
    -0.26479557f, -0.24676950f, -0.17780031f, -0.03071177f, 0.19298738f, 0.01205469f, 0.01408688f, -0.06380826f, 
    -0.01126022f, 0.01626079f, -0.20937864f, 0.01156449f, 0.46181482f, 0.03282652f, 0.29491872f, -0.11256855f, 
    0.05250069f, 0.00038343f, -0.04696937f, -0.11988643f, 0.05182807f, -0.10164797f, -0.03595348f, 0.07017402f, 
    -0.00562597f, 0.14328027f, 0.01069723f, -0.12329048f, 0.01765960f, -0.09698116f, -0.05445475f, -0.20891100f, 
    0.01325367f, -0.10069821f, -0.08894601f, 0.18940407f, -0.14346282f, -0.07246445f, -0.29897135f, 0.12948529f, 
    0.00538969f, 0.01934345f, 0.01172473f, 0.00593775f, -0.07996754f, -0.12067425f, 0.22937325f, 0.13267912f, 
    0.08516447f, 0.18264489f, -0.12795316f, -0.12657861f, 0.06246050f, -0.02381304f, 0.27163383f, -0.27952871f, 
    -0.03286726f, 0.18320696f, 0.06589586f, 0.04870332f, 0.20466633f, 0.41191733f, -0.27945909f, 0.13398950f, 
    0.22095257f, -0.37232700f, -0.14581151f, 0.09192170f, -0.10527686f, 0.00153768f, 0.00195344f, 0.01138498f, 
    0.12939855f, 0.00451531f, -0.02668336f, -0.08268095f, 0.10341509f, 0.02678385f, 0.12747031f, -0.01885467f, 
    0.07375637f, -0.04126421f, 0.12921125f, -0.01502124f, 0.00143580f, 0.16516894f, -0.05222971f, 0.19759312f, 
    0.11188128f, 0.27259681f, 0.08316297f, 0.01057729f, -0.13004732f, 0.03399199f, -0.11800917f, -0.09503485f, 
    -0.13570458f, 0.32922789f, 0.37805939f, -0.04560448f, 0.14554402f, 0.01522544f, -0.01576218f, -0.04116498f, 
    0.06279125f, 0.08791888f, 0.07296815f, 0.13819620f, -0.21591778f, 0.02125894f, -0.10225574f, -0.07282829f, 
    0.19441596f, -0.00568952f, 0.07360707f, -0.13359797f, -0.08768280f, -0.16843303f, -0.00949503f, 0.03508496f, 
    -0.19456734f, 0.30214846f, 0.02891997f, 0.05963593f, -0.09840421f, -0.16355662f, -0.04431407f, 0.02225092f, 
    -0.16100784f, -0.16892207f, -0.15449123f, -0.18946694f, 0.06631599f, -0.11655595f, -0.21214516f, 0.15530637f, 
    0.02725376f, -0.00124585f, -0.07730179f, 0.06212866f, 0.18414135f, 0.12277050f, 0.04473121f, 0.02147794f, 
    0.10736807f, -0.01190049f, -0.03873255f, 0.12238666f, -0.02594824f, 0.08701453f, 0.01097078f, -0.01833027f, 
    -0.02968699f, 0.04651744f, -0.09133606f, 0.01707224f, 0.04521691f, 0.52656657f, 0.16922294f, -0.10984472f, 
    -0.02652908f, -0.09437047f, -0.04358805f, -0.09322921f, -0.00919213f, 0.02936092f, 0.03676204f, 0.03607997f, 
    0.20096900f, -0.16482343f, -0.02524688f, -0.02134539f, 0.19488069f, 0.16220465f, -0.10071607f, 0.09697963f, 
    -0.03024426f, -0.19819237f, -0.10075803f, -0.01169471f, 0.32473713f, -0.11782001f, 0.11058786f, -0.22298856f, 
    0.13246346f, 0.13629764f, -0.07537445f, -0.08867780f, -0.01367276f, -0.07131401f, -0.02836541f, -0.01757316f, 
    0.03765428f, -0.03120375f, -0.03239532f, -0.01312875f, 0.00132952f, 0.01148257f, -0.01540835f, 0.02737044f, 
    0.01321186f, -0.02855356f, 0.03680843f, -0.04337857f, -0.04296922f, 0.01430590f, -0.05704326f, 0.00029275f, 
    -0.02910256f, 0.03397551f, -0.04262183f, -0.01543889f, -0.04446217f, -0.04361039f, -0.00576815f, 0.02595665f, 
    0.00562530f, -0.00100714f, -0.05244089f, 0.00234213f, 0.03622882f, -0.00278061f, 0.00547937f, 0.00614158f, 
    -0.05840592f, -0.05458578f, 0.02179422f, 0.03993315f, 0.00990464f, -0.01286820f, 0.03611337f, -0.03822424f, 
    -0.03383675f, -0.03351138f, 0.02049659f, 0.00037108f, 0.02813615f, 0.03298987f, -0.04534832f, -0.05313716f, 
    0.02293486f, -0.03634890f, -0.00814169f, 0.01829033f, -0.00691705f, -0.02479568f, 0.03157339f, 0.01630050f, 
    -0.04563502f, -0.02370744f, 0.00859568f, -0.02554063f, 0.00671564f, -0.05383493f, 0.04456895f, 0.01500582f, 
    -0.01196077f, -0.04276189f, 0.00264031f, 0.00469235f, 0.01914922f, -0.05121553f, -0.04945695f, 0.04509484f, 
    -0.00528069f, 0.03734561f, -0.00964448f, -0.01993693f, -0.05844746f, 0.00724828f, 0.04210551f, -0.00599142f, 
    -0.01205358f, -0.03622419f, 0.01726750f, 0.04706170f, -0.01960178f, -0.03093548f, -0.02615770f, -0.05648035f, 
    -0.00390055f, -0.00982647f, 0.01380233f, 0.00459598f, -0.01390977f, -0.01933106f, 0.01365448f, 0.03583253f, 
    0.01850100f, -0.04674796f, -0.04440327f, -0.04097291f, -0.03460382f, -0.03800477f, -0.04253859f, 0.03959554f, 
    0.03474962f, -0.01957459f, -0.04057069f, 0.03964316f, 0.02105675f, 0.03015156f, -0.04085811f, -0.05892562f, 
    0.02666022f, -0.02271031f, -0.05913735f, -0.00777461f, -0.03182852f, -0.01992715f, -0.03118339f, -0.00016246f, 
    -0.02934757f, -0.05462111f, -0.01263289f, -0.00519035f, -0.02980968f, -0.02573768f, 0.01397312f, -0.03727858f, 
    -0.02538029f, -0.04623587f, 0.04914223f, 0.00827583f, 0.00868798f, -0.05150044f, -0.00848164f, -0.04023456f, 
    -0.01200684f, -0.05537665f, -0.04342844f, 0.01260337f, -0.00412840f, 0.04436602f, 0.02115908f, 0.02904601f, 
    -0.01579224f, 0.01898133f, -0.00122072f, -0.02026926f, -0.04099420f, 0.05040029f, 0.03762424f, -0.02786075f, 
    0.04078577f, -0.06636358f, 0.03396536f, -0.04009828f, -0.02356470f, -0.05742222f, -0.03922920f, 0.03169274f, 
    0.00797316f, -0.04985458f, -0.01422437f, 0.04090242f, -0.04583055f, -0.04245774f, 0.01836886f, 0.00291524f, 
    0.00141309f, -0.05777137f, -0.03558932f, -0.04526887f, 0.00055042f, -0.03918213f, -0.00991276f, -0.01717300f, 
    0.04053747f, -0.03929217f, -0.05467082f, -0.01284980f, -0.01699325f, 0.02282905f, -0.00080804f, -0.00977589f, 
    -0.01026698f, -0.03692717f, -0.02792414f, 0.00505026f, 0.01838510f, -0.04460897f, -0.01729640f, -0.03505687f, 
    0.01702370f, -0.04038982f, 0.00885096f, -0.04600401f, -0.03416344f, 0.00471825f, 0.03374335f, -0.02265908f, 
    0.01914743f, 0.02545133f, 0.02995639f, -0.04429828f, 0.00608359f, -0.02102301f, -0.02488763f, -0.04139417f, 
    -0.01896424f, -0.00815443f, 0.04457003f, 0.04901087f, 0.02956648f, -0.00011183f, -0.03430283f, -0.00518907f, 
    -0.01293551f, 0.01201981f, 0.01510447f, -0.03106052f, -0.02682600f, -0.02368206f, 0.02220893f, -0.01803793f, 
    -0.04861085f, -0.01745210f, -0.04657963f, 0.02043096f, 0.00987596f, 0.01764314f, 0.02667930f, -0.03894360f, 
    0.05395021f, -0.04246718f, 0.03143020f, -0.01357468f, 0.03265544f, -0.00910721f, -0.03358240f, 0.00653645f, 
    -0.03601173f, -0.01987795f, 0.02125255f, 0.03176274f, -0.01336901f, -0.04385458f, -0.03945304f, -0.03537574f, 
    0.04595744f, -0.04312622f, 0.03860929f, 0.00836427f, -0.05214038f, 0.01473309f, 0.00724263f, -0.05088435f, 
    -0.04161129f, -0.04660929f, 0.01558049f, 0.03034780f, -0.05727129f, 0.02382125f, 0.03544318f, -0.02221631f, 
    0.03943404f, -0.02225889f, -0.01733732f, -0.02621950f, 0.00574359f, -0.01308846f, 0.00735266f, 0.02831874f, 
    0.02730642f, 0.02338499f, 0.02624393f, 0.03794855f, -0.03814724f, 0.02118657f, 0.03313022f, -0.04163942f, 
    -0.01206134f, 0.03362410f, 0.00810847f, 0.02361376f, -0.04565960f, -0.06540438f, 0.01759692f, -0.04286816f, 
    -0.06116359f, -0.01054875f, -0.01283212f, 0.02542390f, -0.00054099f, -0.01447454f, -0.01675355f, 0.00067987f, 
    0.00561275f, -0.04622003f, -0.01671911f, 0.04347339f, 0.01157717f, -0.01648732f, 0.00090782f, -0.00512222f, 
    -0.02619435f, -0.05634965f, -0.01259694f, -0.03768498f, 0.02194148f, 0.03538504f, -0.00508313f, -0.02703030f, 
    0.00332401f, 0.02386782f, -0.05749134f, 0.02403501f, -0.02003007f, -0.01045742f, -0.01515531f, -0.04273823f, 
    0.01720914f, -0.03774171f, -0.00093728f, 0.01083452f, -0.00710927f, -0.00011924f, 0.02699375f, -0.03616011f, 
    -0.01545546f, -0.00735180f, 0.01781467f, -0.01987388f, 0.02844768f, 0.03372405f, -0.00302432f, 0.00384507f, 
    0.03797796f, 0.00224303f, -0.01194720f, -0.01608214f, -0.05451621f, 0.04531462f, -0.04462349f, -0.01586683f, 
    0.00261973f, -0.05633018f, -0.02542973f, 0.00528446f, -0.03815749f, -0.02507769f, 0.01523546f, -0.01694499f, 
    0.00652355f, 0.03297025f, -0.01804278f, -0.03529596f, -0.04737376f, 0.02034357f, -0.02613788f, -0.04307460f, 
    0.03026420f, -0.00112284f, 0.02033394f, 0.01913648f, 0.04532802f, 0.02071388f, -0.03055114f, -0.04770590f, 
    0.02910395f, 0.03391537f, -0.01603012f, -0.02025658f, -0.05233360f, 0.04446071f, -0.01715458f, -0.03008734f, 
    -0.02067850f, 0.00681558f, -0.02857131f, -0.02765866f, -0.01471838f, -0.03708038f, 0.03398067f, -0.03777820f, 
    0.14863470f, 0.10956246f, -0.20130028f, 0.15094903f, -0.19127224f, 0.00812571f, 0.12361884f, 0.14278805f, 
    0.17519364f, 0.05456562f, -0.07081430f, 0.09610010f, 0.15207270f, -0.03085564f, 0.03074577f, 0.03082829f, 
    0.00078733f, 0.10829526f, 0.14598612f, 0.11461132f, -0.01558582f, -0.21504071f, 0.06418313f, -0.04663283f, 
    0.29564869f, 0.30718955f, 0.14617178f, 0.01913827f, -0.01820584f, -0.05108969f, -0.17054673f, -0.03231183f, 
    -0.01501772f, -0.04524802f, 0.03366467f, 0.01891886f, 0.19664922f, -0.26654410f, -0.01652991f, 0.01608038f, 
    0.05964548f, -0.02073802f, -0.04490329f, 0.20017226f, -0.12313763f, -0.04850938f, -0.14247392f, -0.09101830f, 
    0.26371413f, -0.16234098f, 0.17859910f, -0.18557164f, -0.08705942f, 0.08561101f, -0.12026688f, -0.09271318f, 
    -0.03580441f, 0.07719839f, -0.02522127f, -0.01221932f, 0.08004997f, 0.37699714f, 0.02959930f, -0.03193970f, 
    0.04925215f, 0.10803350f, -0.09384602f, -0.01028583f, -0.01831204f, -0.16747190f, 0.12435190f, -0.00669383f, 
    0.00462439f, -0.11137521f, -0.19143263f, -0.02064962f, 0.00329869f, -0.17705455f, -0.02337224f, -0.07626770f, 
    -0.13967492f, 0.01166001f, 0.01307633f, -0.01228289f, -0.18153305f, -0.19425917f, -0.01116560f, 0.12651618f, 
    -0.01128602f, -0.15472570f, -0.06456167f, -0.02627025f, 0.00658450f, -0.10830095f, -0.07342419f, 0.03797356f, 
    -0.20359866f, -0.16066308f, -0.03343832f, -0.08460044f, -0.00435483f, -0.01204128f, -0.13275558f, -0.07270701f, 
    0.02299389f, -0.06430443f, -0.10155673f, -0.04903821f, -0.20828241f, 0.29257205f, -0.26137918f, 0.22787514f, 
    0.05262987f, 0.02544045f, 0.09172056f, -0.11191461f, 0.01868458f, -0.03015103f, 0.00504085f, -0.06074911f, 
    0.24756731f, 0.08280165f, 0.13020837f, -0.05845603f, -0.00036284f, -0.01004915f, -0.00675295f, -0.07794818f, 
    0.06667759f, 0.01312588f, -0.04666039f, 0.07632961f, 0.32748905f, -0.26394728f, 0.46891922f, -0.12482376f, 
    -0.00497410f, -0.04208143f, 0.11100922f, -0.02186230f, 0.06257933f, -0.10805602f, 0.04830456f, -0.15801808f, 
    0.21643083f, 0.18905619f, 0.33426920f, 0.07327336f, -0.10454484f, -0.05268469f, -0.02645266f, 0.01634592f, 
    -0.04415103f, 0.05116246f, -0.01390464f, 0.03402991f, 0.17320371f, -0.16506226f, 0.20460574f, -0.22755992f, 
    0.11161353f, 0.16507405f, -0.02555522f, 0.19992287f, -0.09224761f, 0.05343511f, 0.07681274f, -0.00283725f, 
    0.09854255f, 0.12697099f, 0.15744899f, -0.00234987f, 0.16522656f, 0.01455496f, -0.04982306f, 0.15797701f, 
    -0.08779094f, 0.01809908f, -0.03073393f, 0.03030414f, 0.10408095f, 0.22200133f, 0.12682231f, -0.18553723f, 
    0.13634902f, 0.04532263f, 0.02142281f, -0.07271881f, 0.00988622f, 0.04206798f, -0.07539044f, 0.01991312f, 
    0.00807850f, -0.03903684f, 0.25033349f, 0.03775831f, -0.08583659f, 0.09792471f, 0.10482319f, 0.08968901f, 
    0.05698445f, 0.01868715f, 0.06013070f, 0.09074748f, 0.21573643f, 0.20737238f, 0.17005189f, 0.06554691f, 
    -0.02445974f, -0.00702321f, 0.06949283f, 0.21382651f, 0.01852046f, 0.13963804f, 0.02989529f, 0.08393241f, 
    -0.31043708f, -0.10109890f, 0.02164915f, 0.09274580f, -0.01984812f, 0.06692415f, -0.14980160f, -0.04876859f, 
    0.00136309f, 0.04652536f, 0.12292036f, -0.06644597f, 0.19545463f, -0.15026610f, 0.17671551f, -0.10954124f, 
    -0.15046868f, -0.07946187f, 0.02909364f, -0.08499669f, -0.06287888f, 0.11371117f, -0.14525068f, 0.21733041f, 
    0.06509172f, -0.00410472f, -0.00476257f, -0.02510534f, -0.04853702f, -0.02529328f, -0.15197130f, 0.22107364f, 
    -0.12273709f, -0.05777800f, -0.08377386f, -0.02319891f, 0.18265387f, 0.02273301f, -0.03121668f, -0.23601232f, 
    -0.07627720f, 0.18312718f, 0.07441480f, -0.10908072f, -0.01992488f, 0.01308883f, -0.02301404f, -0.01957458f, 
    -0.15345608f, -0.03346544f, -0.05744634f, 0.20564385f, 0.16460028f, 0.06029820f, 0.13871035f, -0.05422202f, 
    -0.04531266f, 0.01673528f, -0.04187752f, -0.04441591f, 0.21503215f, 0.27414703f, 0.24574912f, 0.12088144f, 
    -0.11058026f, -0.11897887f, 0.05941603f, -0.03687824f, 0.05455723f, -0.02700333f, 0.07159881f, 0.10623936f, 
    0.11063145f, 0.04184119f, -0.11357008f, -0.08832571f, -0.00159049f, 0.03965125f, -0.03682745f, 0.13963917f, 
    0.04547816f, -0.01693074f, -0.12118127f, -0.11404279f, -0.38408834f, 0.02118459f, -0.06907156f, -0.15389280f, 
    -0.04365938f, -0.00793663f, 0.17668438f, 0.14177285f, 0.10761741f, 0.11633558f, 0.07627353f, -0.16301313f, 
    0.03030495f, -0.04867736f, -0.09177762f, 0.06594446f, -0.08189166f, 0.00817862f, -0.02350636f, 0.00376867f, 
    0.10300495f, 0.01081914f, 0.03562590f, 0.03602043f, -0.11956107f, -0.21582215f, -0.06648713f, -0.24409257f, 
    -0.02492679f, -0.02895917f, -0.01295901f, -0.07632301f, -0.02927110f, -0.14301644f, 0.01968105f, 0.10773870f, 
    0.28237069f, -0.42951202f, -0.18628536f, -0.05256234f, 0.03414262f, 0.04132773f, -0.14118116f, 0.17461404f, 
    0.18605343f, -0.03919310f, 0.05843819f, 0.10853785f, -0.10538908f, 0.01419352f, 0.04578260f, -0.10339607f, 
    -0.01275029f, 0.04984644f, 0.08976904f, 0.00380626f, 0.00673064f, -0.04064630f, -0.00619798f, -0.12892118f, 
    -0.10265413f, -0.04647202f, -0.00445670f, -0.03047176f, -0.07454650f, -0.01528304f, -0.08185644f, -0.04346582f, 
    0.07223421f, 0.06297706f, -0.00507152f, 0.12653741f, -0.06951361f, -0.13509794f, -0.29191133f, 0.01495371f, 
    -0.06076238f, 0.05866284f, 0.09616446f, 0.12565458f, -0.02028442f, 0.11614177f, -0.05145233f, -0.04019554f, 
    -0.01745090f, 0.00211280f, -0.01972071f, -0.00960997f, -0.02189900f, -0.05335355f, -0.05053392f, 0.03332238f, 
    -0.02806327f, -0.04308981f, 0.02915231f, 0.04403596f, 0.00390086f, -0.02460126f, -0.00049368f, 0.01697717f, 
    -0.00061950f, -0.02360621f, -0.03843379f, -0.05080988f, -0.04032757f, -0.04718008f, 0.00933692f, 0.02043834f, 
    0.04078737f, -0.03640905f, 0.02698830f, 0.01260968f, 0.00098039f, -0.04991985f, -0.03143774f, -0.01509209f, 
    0.02155318f, -0.01993818f, 0.01327478f, -0.04956310f, -0.01531720f, 0.04092566f, -0.05357187f, 0.00381992f, 
    0.04315261f, -0.01740272f, -0.05413546f, -0.04789617f, 0.03852173f, 0.00897270f, -0.00684289f, 0.02307569f, 
    -0.05491395f, 0.00129856f, -0.02059858f, 0.01065735f, -0.05553470f, 0.00985621f, -0.03112143f, -0.04466565f, 
    -0.04808310f, -0.05825815f, -0.05250997f, 0.04237429f, 0.04841989f, -0.02216384f, -0.03425670f, 0.03821482f, 
    -0.04559146f, 0.00562327f, 0.02885665f, -0.04409860f, 0.00123306f, 0.00511957f, 0.03642716f, 0.01415785f, 
    -0.04639232f, 0.03904900f, -0.03438565f, -0.05324125f, -0.05198572f, 0.04227205f, -0.03122734f, 0.03306676f, 
    -0.05481946f, -0.02294326f, -0.01568619f, -0.04461234f, 0.02004953f, -0.03721066f, 0.04291994f, -0.03151857f, 
    0.03323207f, -0.03163194f, 0.00116540f, -0.00764192f, -0.00597345f, -0.05808447f, 0.02616761f, -0.00089998f, 
    -0.01568989f, -0.01168868f, -0.04132155f, -0.04600133f, -0.05268435f, -0.03441324f, 0.02990109f, -0.01118125f, 
    -0.01881321f, -0.02775048f, -0.03664456f, 0.02342881f, -0.03830133f, -0.04403032f, -0.04755694f, 0.01253308f, 
    0.00271932f, -0.00637873f, 0.01759000f, -0.01300580f, 0.02835271f, 0.00403604f, 0.01899694f, 0.02527083f, 
    -0.01147926f, -0.01389188f, 0.03267296f, -0.02707177f, 0.03926302f, 0.01502816f, 0.00250392f, -0.00830484f, 
    -0.02194408f, -0.00418304f, 0.03871676f, 0.02553648f, -0.01156024f, -0.03221283f, -0.01232952f, -0.05650341f, 
    -0.00540731f, -0.05098203f, -0.01317582f, -0.03576040f, 0.00180211f, 0.00502557f, 0.00949301f, 0.00326992f, 
    0.03741712f, -0.01746041f, -0.01334340f, -0.03121335f, -0.03597618f, -0.01650145f, -0.00775687f, -0.02653718f, 
    0.00853973f, 0.03333152f, -0.04518036f, -0.01948201f, -0.03306629f, 0.03320792f, -0.00522192f, -0.05504277f, 
    -0.00270242f, 0.01564249f, -0.04041307f, 0.02480526f, -0.03952728f, -0.00784207f, -0.04974353f, -0.02306449f, 
    -0.05149166f, 0.00110358f, 0.03411539f, -0.04406129f, -0.01666428f, -0.00524992f, -0.00660298f, -0.05630860f, 
    -0.03935888f, -0.05599393f, -0.01431377f, 0.03699308f, -0.03751857f, -0.03753239f, 0.02882872f, 0.04773559f, 
    -0.01501481f, -0.02567882f, -0.05673502f, 0.02619613f, -0.04649965f, -0.05157515f, -0.02836277f, -0.01410422f, 
    -0.01738439f, 0.00285348f, -0.02420607f, 0.04181901f, -0.04244537f, 0.01547539f, 0.00919393f, -0.01682458f, 
    -0.04455100f, -0.04738901f, 0.02565904f, 0.03924855f, -0.05195356f, -0.01648810f, -0.01741683f, 0.01933864f, 
    -0.01943356f, -0.04283842f, -0.05378767f, 0.03252244f, 0.00518981f, 0.01776744f, 0.01908804f, 0.01166280f, 
    -0.04846100f, -0.05176681f, -0.05035178f, 0.02556190f, -0.02410187f, -0.02090437f, -0.05184323f, 0.00791812f, 
    0.01895927f, -0.04562681f, -0.04831184f, 0.02835833f, -0.02761145f, 0.02281286f, -0.04340043f, -0.00425815f, 
    -0.04047655f, 0.02328941f, -0.03077370f, 0.00409596f, -0.03708283f, 0.02488801f, 0.00905184f, 0.02434640f, 
    -0.02252312f, -0.00312273f, 0.02953516f, -0.04407039f, 0.00432325f, 0.02603220f, -0.05640853f, -0.03812098f, 
    0.00908376f, 0.03848581f, 0.02819502f, 0.00334111f, -0.02680789f, 0.00777546f, 0.03776368f, -0.04515694f, 
    -0.05796131f, -0.03709811f, 0.03267754f, -0.02622389f, -0.01593882f, -0.05559586f, -0.04229401f, 0.02971202f, 
    -0.03959815f, 0.01725120f, -0.05154578f, -0.03792871f, 0.01257884f, -0.01823246f, -0.01542584f, 0.00469232f, 
    -0.00393346f, 0.00239407f, 0.01296839f, -0.03439841f, -0.05715599f, -0.00376325f, 0.04706300f, 0.01080219f, 
    0.02256118f, -0.03065514f, -0.05097657f, -0.05579121f, -0.05029573f, 0.02753299f, -0.04845184f, -0.03988278f, 
    0.01692314f, -0.05575540f, -0.02294137f, -0.01723648f, -0.03109385f, 0.03338588f, 0.03348281f, -0.01739363f, 
    -0.04122960f, 0.00476513f, -0.00539191f, -0.04186404f, -0.05838709f, -0.05790331f, 0.02312403f, -0.05360971f, 
    -0.04844722f, 0.00796768f, -0.00285347f, -0.00408497f, -0.04437269f, 0.02301850f, 0.03282356f, -0.00341985f, 
    -0.02936364f, 0.00162102f, -0.00851049f, 0.00888420f, -0.03617221f, -0.02270075f, 0.00099381f, 0.02603090f, 
    0.02909422f, -0.05643444f, 0.03268934f, -0.03549563f, -0.01254302f, 0.04043198f, -0.01498556f, -0.05043278f, 
    0.03519741f, 0.03906828f, -0.02514919f, -0.04164829f, -0.04415650f, 0.04092861f, 0.02705104f, -0.01101552f, 
    0.02661110f, 0.03954021f, 0.01057375f, -0.02687521f, -0.04210589f, -0.03752083f, 0.04181788f, 0.01551094f, 
    0.00825148f, -0.05903297f, 0.02708562f, 0.00537422f, -0.05280564f, -0.01940360f, -0.02041692f, -0.01733733f, 
    -0.03909895f, -0.02415152f, 0.00889555f, 0.00856431f, 0.00580150f, 0.01616902f, -0.05263788f, 0.00945364f, 
    0.02108398f, -0.00853949f, 0.00684493f, -0.03678767f, -0.01932487f, -0.01297401f, -0.01886509f, -0.02823663f, 
    -0.04030642f, 0.03317278f, -0.03061114f, 0.01306049f, 0.03457977f, 0.03485688f, -0.01993895f, 0.01574823f, 
    0.00285788f, 0.03447299f, -0.01501786f, 0.00899440f, 0.02019724f, 0.04053513f, -0.01176249f, 0.03600779f, 
    0.04030595f, 0.27140248f, -0.06874495f, 0.49363574f, 0.09318450f, 0.00073360f, 0.04332079f, -0.19943140f, 
    -0.00066262f, 0.12982942f, -0.12179559f, -0.07777103f, 0.17453806f, -0.00664366f, 0.02820809f, -0.31170335f, 
    0.02057498f, -0.03416271f, -0.02105973f, 0.10794523f, -0.10945803f, -0.03736755f, -0.00071256f, -0.05377532f, 
    0.47381833f, 0.41999948f, 0.17254798f, 0.19178472f, -0.02589744f, -0.11843610f, -0.02019887f, 0.42520821f, 
    -0.08459903f, 0.06702159f, 0.03285990f, 0.03092260f, -0.01150516f, -0.18739441f, 0.01810962f, 0.10090146f, 
    -0.02127438f, -0.07755019f, -0.09412478f, 0.13252178f, -0.04879127f, -0.01676815f, -0.09069756f, 0.00757202f, 
    0.10422497f, -0.22358315f, -0.01154359f, -0.04696747f, -0.01867525f, -0.00177246f, -0.09293649f, -0.05213099f, 
    0.02704369f, -0.03807087f, 0.01187378f, 0.03947969f, 0.33958688f, 0.42659169f, -0.13903227f, -0.06925979f, 
    0.02615431f, 0.10601539f, 0.03232017f, 0.03330215f, -0.00798897f, 0.02084931f, 0.11785620f, -0.02796786f, 
    0.13224232f, -0.01342761f, -0.10312342f, 0.26801124f, -0.02731006f, 0.01091222f, 0.14756048f, -0.08067363f, 
    -0.04853612f, 0.08843730f, -0.03365097f, 0.22892843f, -0.10968540f, -0.03958056f, -0.03340046f, 0.16482987f, 
    -0.15166856f, 0.02457401f, 0.05696717f, -0.02320843f, -0.08371246f, 0.02717604f, -0.02484493f, 0.14801471f, 
    -0.07167704f, -0.13645604f, -0.17353521f, -0.06824981f, -0.04561007f, 0.00548504f, -0.00763625f, -0.03543128f, 
    0.19511279f, 0.20316072f, -0.09389000f, 0.04360676f, -0.07000283f, 0.20140162f, -0.37640321f, 0.10020970f, 
    -0.24468930f, -0.04065299f, 0.05211213f, 0.05752820f, -0.02582610f, -0.02080344f, 0.01701355f, -0.15281850f, 
    0.21355464f, -0.03436960f, -0.02950671f, 0.07057810f, 0.16587104f, 0.12092310f, 0.11157469f, -0.02187536f, 
    0.10555933f, 0.06368094f, 0.05202195f, 0.11116287f, -0.21282227f, -0.16894744f, 0.45085731f, -0.12370391f, 
    0.02607742f, -0.04387654f, -0.02426926f, -0.01263975f, 0.10349428f, -0.22535621f, -0.09879466f, -0.18893553f, 
    0.40852293f, 0.25974524f, 0.52922827f, 0.10721857f, -0.01034374f, -0.13062385f, 0.11901288f, 0.12108942f, 
    -0.02798048f, 0.00204588f, 0.01538067f, -0.11545780f, 0.15919715f, -0.18974078f, 0.19360949f, -0.28188699f, 
    0.05865127f, -0.14100058f, -0.16051629f, 0.19044045f, -0.06052614f, -0.01422004f, 0.08073522f, -0.09633346f, 
    0.36144537f, 0.28512797f, 0.26813588f, 0.01550814f, 0.01509072f, -0.03152747f, 0.02933080f, 0.35715851f, 
    0.13026646f, 0.02374146f, -0.02757976f, -0.00592161f, 0.15324284f, 0.25652796f, -0.00388421f, 0.10735248f, 
    0.19138177f, -0.05192121f, -0.03967905f, 0.06658127f, -0.05414817f, 0.10828822f, 0.06846236f, 0.16012044f, 
    -0.26025712f, 0.02714048f, 0.23481800f, -0.05572243f, 0.00088566f, 0.11841241f, 0.03335362f, 0.06965863f, 
    0.05099520f, -0.03837625f, 0.00521774f, 0.12518086f, 0.22441758f, 0.01567221f, 0.20491441f, 0.11507980f, 
    -0.00520629f, 0.06125772f, -0.05881304f, 0.33871680f, -0.05462361f, 0.06376501f, -0.05490322f, -0.09686380f, 
    0.30933535f, -0.04480790f, -0.10585210f, 0.24343161f, -0.04485216f, 0.14512312f, 0.09212374f, 0.06350195f, 
    -0.26208794f, 0.06450480f, 0.18337438f, -0.03442305f, -0.19410045f, -0.03127031f, 0.13999756f, 0.14513093f, 
    -0.02560951f, 0.13388130f, -0.14832672f, -0.13594727f, -0.12451723f, -0.09927133f, -0.06741739f, 0.10614950f, 
    0.04736216f, 0.02450823f, 0.04826973f, 0.19910428f, -0.06785294f, 0.15405482f, -0.23480542f, 0.14643948f, 
    -0.12593243f, 0.07939959f, 0.01509131f, 0.00654935f, 0.69464028f, -0.06671267f, 0.16621211f, 0.00448255f, 
    -0.06646986f, 0.18643224f, -0.04932464f, -0.09492803f, 0.09572127f, 0.06458808f, 0.03571025f, -0.14183651f, 
    -0.14177538f, 0.06976654f, -0.03642939f, 0.03436160f, -0.18365672f, 0.15809925f, 0.11236487f, -0.14418171f, 
    -0.16666682f, 0.09474269f, 0.00499519f, -0.13611831f, 0.06205336f, 0.40111640f, 0.39597732f, -0.03952730f, 
    -0.01874750f, -0.20093723f, 0.17468439f, -0.00511769f, 0.08674072f, 0.03024299f, -0.14900948f, -0.05877556f, 
    0.34653565f, -0.12249107f, -0.24932800f, 0.00630246f, 0.00122526f, 0.02222077f, -0.01138023f, -0.00351507f, 
    -0.11356167f, 0.03682559f, 0.01248657f, 0.05948235f, 0.00189835f, 0.05876965f, -0.09820809f, -0.10336218f, 
    0.03404225f, -0.04475530f, 0.11286364f, 0.00112655f, -0.08579215f, -0.01563134f, -0.12391768f, 0.00648540f, 
    -0.06253123f, 0.15260205f, -0.02468042f, 0.40641701f, -0.00374732f, -0.07977469f, 0.07805835f, -0.16389950f, 
    -0.09317889f, 0.03081442f, -0.22862004f, -0.15070072f, -0.15143377f, -0.00159200f, -0.16584274f, -0.12489180f, 
    -0.03656614f, -0.04416374f, -0.06666647f, 0.01622891f, 0.09223765f, 0.07298005f, 0.03152572f, 0.12090755f, 
    -0.07888243f, -0.31951836f, 0.22501726f, 0.04252392f, 0.19009639f, -0.15669025f, -0.22144093f, -0.09096471f, 
    -0.12611680f, 0.02108235f, 0.01029388f, 0.01451684f, 0.35908815f, -0.18707609f, 0.00179048f, -0.28544652f, 
    0.04424788f, 0.13876557f, 0.01455795f, 0.02141303f, 0.00216228f, 0.00630541f, 0.04367575f, -0.02805015f, 
    -0.00349929f, -0.12223749f, 0.00051875f, -0.05848058f, 0.08079909f, 0.06665461f, 0.02507178f, 0.04073549f, 
    -0.06899054f, -0.07137386f, -0.04552507f, 0.07651679f, 0.24433683f, -0.21266055f, -0.13528471f, -0.10829334f, 
    -0.04310301f, 0.06771407f, -0.01324669f, 0.09341393f, 0.03575530f, -0.00595020f, -0.01132564f, -0.18549614f, 
    -0.17717306f, 0.01585259f, 0.11588570f, 0.22884843f, 0.07738371f, 0.00190214f, -0.14637215f, 0.04080377f, 
    0.02469300f, 0.06162746f, -0.12078138f, 0.07052917f, 0.07286416f, 0.33575222f, 0.19802144f, -0.27118865f, 
    -0.18868221f, -0.04992577f, -0.15193391f, -0.11716762f, 0.10461885f, -0.02175335f, 0.27474627f, -0.02141384f, 
    0.07836948f, 0.29559162f, 0.04673593f, -0.08391205f, 0.04605211f, 0.03238241f, -0.05805427f, -0.03877685f, 
    -0.00756569f, 0.02620813f, 0.21182145f, 0.13820918f, 0.11417430f, 0.07630614f, 0.10367564f, -0.15134579f, 
    0.09273166f, 0.00909413f, 0.01650364f, -0.04424722f, 0.07341403f, 0.12448660f, 0.03245764f, 0.04692307f, 
    -0.02216132f, -0.21890014f, 0.28707966f, -0.19181474f, 0.05407761f, 0.05514294f, -0.11864624f, 0.09676350f, 
    -0.00816448f, 0.10527926f, 0.00882170f, 0.03926702f, -0.15810224f, 0.28440258f, 0.10945518f, -0.05003927f, 
    -0.13325882f, 0.10852687f, 0.10127361f, -0.05933172f, -0.06219035f, -0.06581528f, 0.27884102f, 0.07098918f, 
    0.22376721f, -0.15478669f, -0.24056251f, 0.12826538f, 0.06997966f, -0.04715543f, 0.09807047f, -0.11672868f, 
    -0.07858962f, -0.00832209f, -0.01916886f, -0.23901843f, -0.03213736f, 0.04206961f, -0.01975938f, -0.11963682f, 
    -0.01255428f, 0.01912792f, 0.19312452f, 0.02878407f, 0.01860712f, -0.03000077f, 0.01121611f, 0.03510645f, 
    -0.10245601f, -0.10969193f, -0.07532579f, -0.04889927f, 0.03464601f, 0.04839371f, 0.02700908f, 0.01724299f, 
    0.04999523f, 0.02841484f, -0.11525583f, -0.10139699f, -0.13508165f, 0.24143209f, -0.38318819f, 0.03180569f, 
    0.17671312f, 0.04041054f, -0.06164479f, -0.14742871f, 0.08795673f, 0.02083226f, -0.03145456f, -0.00285458f, 
    0.06750091f, -0.09683778f, 0.23160516f, -0.09142856f, -0.10505667f, 0.05523877f, -0.01918048f, -0.14360517f, 
    0.07107008f, 0.08639508f, 0.17156687f, 0.13165890f, 0.05236907f, -0.45889091f, 0.21999055f, 0.28629819f, 
    -0.00322384f, 0.01137248f, 0.01753939f, 0.24944003f, -0.07729877f, -0.18425822f, 0.17484492f, -0.06673606f, 
    0.07299722f, 0.22266588f, 0.18121068f, -0.08187233f, -0.07128902f, -0.05722620f, 0.05985094f, -0.06173149f, 
    0.05403214f, 0.09465989f, -0.03641342f, 0.02373985f, 0.01758951f, -0.26793367f, 0.23083217f, -0.13615958f, 
    0.07201724f, 0.19440936f, -0.26477653f, 0.44081751f, -0.20165749f, 0.03398503f, 0.04636004f, -0.10044741f, 
    -0.01289511f, 0.06180958f, -0.00379005f, -0.16146849f, 0.07622480f, -0.04482334f, -0.18917748f, -0.02067986f, 
    0.11903775f, -0.03001875f, -0.01842248f, 0.03519371f, -0.03494479f, 0.16670786f, 0.19021848f, 0.05781130f, 
    0.06411517f, 0.11235969f, 0.08809306f, -0.06668676f, -0.02517687f, 0.03860431f, -0.12359025f, 0.19679835f, 
    -0.16754009f, -0.19181029f, 0.20920959f, 0.18707654f, 0.02960099f, 0.25244445f, -0.17298949f, 0.14807372f, 
    0.07224008f, 0.02782233f, -0.11827090f, -0.04595900f, 0.03038542f, 0.05178898f, 0.05039520f, 0.07338732f, 
    0.09422795f, -0.04401197f, 0.04846249f, 0.14927422f, 0.00597050f, -0.00626918f, 0.05272372f, -0.07801393f, 
    -0.23845376f, -0.07443626f, 0.14852200f, -0.38051137f, -0.03990645f, -0.01194640f, -0.13244280f, -0.03000868f, 
    -0.05849407f, 0.14240712f, 0.13001430f, -0.08686377f, -0.10260959f, -0.12202916f, 0.03781459f, 0.20619690f, 
    -0.00591780f, 0.06271134f, 0.01787357f, -0.07885034f, 0.12024888f, -0.12711714f, -0.05485589f, 0.11960081f, 
    0.13578580f, 0.03558693f, 0.31796849f, -0.12135120f, 0.02426013f, -0.07114077f, -0.17670147f, 0.18118994f, 
    -0.15586369f, -0.01075351f, 0.15307413f, -0.03626538f, -0.13050942f, -0.12731844f, -0.16677414f, -0.05061346f, 
    0.12108849f, 0.17039147f, 0.03038631f, 0.19317105f, 0.02988986f, -0.02161650f, -0.06830809f, -0.04737782f, 
    -0.01952126f, 0.04778466f, -0.18581621f, -0.01645637f, 0.31673434f, -0.14259526f, 0.08859481f, -0.02231341f, 
    0.11190977f, 0.14795110f, -0.01780625f, -0.07516464f, 0.04206198f, 0.18067519f, 0.22607489f, -0.00701853f, 
    -0.02642784f, -0.14632727f, 0.15596311f, -0.13366546f, 0.03673969f, -0.04755663f, 0.11383355f, 0.00295945f, 
    -0.14240776f, 0.18226522f, 0.19209670f, -0.01564824f, -0.19746989f, -0.15340382f, -0.04444497f, 0.05943655f, 
    0.05721131f, 0.01788398f, -0.04232155f, -0.04687849f, -0.56861758f, 0.39022878f, 0.09677999f, 0.15285376f, 
    0.01332129f, -0.10499287f, 0.07133584f, -0.24182324f, 0.13087635f, -0.01740104f, 0.01463706f, -0.11202288f, 
    -0.26857778f, -0.11315220f, 0.13547079f, 0.07461777f, -0.03912422f, 0.03967624f, -0.00673714f, 0.07320751f, 
    -0.09469676f, -0.04406493f, 0.21869427f, -0.06451356f, -0.03958910f, -0.15025438f, 0.02530845f, -0.00630613f, 
    -0.02921635f, 0.06191260f, 0.07557424f, 0.08046913f, -0.13540022f, -0.08579594f, -0.02951041f, 0.11572529f, 
    0.14440490f, 0.17866944f, 0.34583461f, 0.04322948f, -0.04353245f, -0.11972544f, -0.07159808f, 0.13501714f, 
    -0.07283704f, -0.02475474f, 0.07427617f, 0.14223786f, -0.44579554f, 0.08591930f, 0.20599185f, -0.11400636f, 
    -0.11841717f, -0.03238657f, 0.07372593f, 0.03218556f, -0.00107262f, -0.02351265f, 0.09535515f, 0.12453276f, 
    -0.01123426f, -0.12346856f, -0.04829486f, -0.09549619f, -0.09890884f, -0.02468501f, -0.21432331f, 0.00463748f, 
    0.02499780f, 0.06005409f, -0.18756281f, 0.08657567f, -0.13904540f, -0.04688101f, -0.22464572f, 0.04899023f, 
    0.08343236f, 0.13533928f, 0.06510824f, 0.15286031f, 0.04742113f, 0.06595740f, -0.17114589f, 0.09718321f, 
    -0.37583417f, 0.05165011f, 0.01182798f, -0.03934938f, -0.00131648f, -0.11433069f, 0.16944951f, -0.04357983f, 
    -0.08511150f, 0.12245407f, 0.19935605f, 0.00887249f, 0.16567974f, 0.11679263f, 0.06164765f, 0.69857299f, 
    0.13326512f, -0.08239969f, -0.02729326f, 0.19874908f, 0.19698365f, 0.13013990f, -0.00875868f, -0.09084136f, 
    0.02326820f, 0.12751551f, 0.03893553f, 0.29992780f, -0.17053197f, -0.11269402f, -0.16592658f, -0.24039876f, 
    0.12875244f, -0.00061637f, -0.05367106f, 0.10444906f, 0.01342384f, -0.14332888f, -0.03275435f, 0.16118129f, 
    -0.08442257f, 0.03063806f, -0.06155796f, -0.10822465f, 0.02423221f, 0.00801251f, -0.11144139f, -0.08263122f, 
    -0.24442315f, 0.02880815f, -0.25122145f, 0.57972252f, -0.06478009f, 0.18809469f, -0.06160472f, -0.22892480f, 
    -0.02810823f, -0.00579274f, -0.05995474f, 0.06992558f, 0.12986508f, 0.11130982f, 0.03847672f, 0.09791557f, 
    -0.01829376f, 0.08600430f, 0.33092695f, 0.22361724f, -0.08768047f, 0.03096914f, -0.02580005f, 0.10852399f, 
    -0.15996785f, 0.19640134f, 0.04364969f, 0.15657409f, 0.00697426f, 0.18071437f, 0.15174034f, -0.07182974f, 
    0.00272098f, 0.05448739f, -0.14251183f, 0.05938379f, 0.36075777f, 0.19357671f, 0.01522052f, -0.03248009f, 
    0.03311568f, -0.05235084f, -0.05951947f, -0.00337725f, -0.00838182f, -0.09513779f, 0.02322944f, 0.10164486f, 
    0.00540683f, 0.01897807f, -0.04779980f, 0.05089594f, -0.04409692f, -0.02830425f, -0.12578468f, 0.03804734f, 
    0.01306747f, 0.02743591f, 0.03743968f, -0.04040851f, 0.40507719f, -0.17628765f, 0.26697621f, 0.19332272f, 
    -0.03774526f, -0.05610602f, 0.17754725f, 0.12256809f, -0.07344246f, -0.05387562f, 0.04151446f, -0.09350321f, 
    -0.14595190f, -0.03440125f, -0.43122086f, 0.21351886f, 0.13799454f, 0.12688276f, 0.07848991f, 0.08516002f, 
    0.02875477f, 0.16880667f, 0.13948649f, 0.18310091f, -0.28521201f, -0.09399995f, 0.42688876f, -0.17690958f, 
    -0.26579228f, 0.01663299f, 0.12255262f, -0.04109531f, 0.01147368f, -0.18731682f, -0.01123459f, 0.03636922f, 
    -0.34083736f, -0.11838166f, 0.00209509f, -0.06722307f, -0.07709754f, 0.09047518f, -0.12501785f, -0.00462702f, 
    0.08631373f, -0.09163769f, -0.04662404f, 0.01720731f, -0.17555007f, 0.16476929f, 0.13969673f, 0.25064346f, 
    -0.08360979f, 0.18320769f, 0.06856522f, 0.09093056f, 0.03164080f, -0.08340402f, 0.11121266f, 0.07812896f, 
    0.16290237f, 0.11518884f, 0.22964059f, 0.36430013f, -0.09280938f, -0.10775308f, 0.06557975f, 0.00348480f, 
    0.01200202f, -0.01049593f, 0.02018749f, -0.00399070f, -0.13985449f, 0.30286467f, -0.21619776f, -0.18158081f, 
    0.11359482f, 0.07347999f, 0.17866041f, 0.20674507f, -0.06330140f, 0.16503985f, 0.04324537f, 0.06900328f, 
    -0.20311348f, 0.09359151f, 0.29394826f, -0.02179589f, 0.11673520f, 0.05143628f, 0.05534704f, -0.07210319f, 
    -0.04640944f, -0.01639106f, -0.02217634f, -0.00035299f, 0.18924049f, -0.07676948f, 0.24767041f, -0.13222738f, 
    -0.07291266f, 0.24238132f, -0.02429537f, -0.18591049f, 0.08096422f, 0.20416440f, 0.05018983f, 0.12212640f, 
    0.15936571f, 0.25468713f, 0.04154423f, 0.04247850f, 0.19351402f, 0.10310512f, -0.03100104f, -0.09171329f, 
    -0.10849507f, -0.14091223f, 0.00370253f, -0.08039391f, 0.08461308f, 0.03897125f, 0.06491873f, 0.09851339f, 
    -0.06707198f, 0.05515701f, -0.14065944f, 0.01492934f, -0.14988109f, -0.06182989f, 0.06411319f, 0.14403029f, 
    -0.23063485f, 0.09956896f, -0.17436661f, 0.03960525f, 0.04848195f, 0.05159427f, 0.06612886f, 0.10831515f, 
    0.03821994f, 0.21389481f, -0.01847727f, -0.01544025f, 0.09094398f, 0.04632990f, 0.29971716f, 0.29696587f, 
    0.15365900f, 0.11848363f, 0.09782850f, -0.18189679f, -0.12332101f, -0.12681013f, -0.00586485f, 0.02428782f, 
    0.23698646f, -0.20395486f, 0.11871032f, 0.06279733f, 0.04916454f, 0.05884820f, 0.06008808f, -0.02590705f, 
    0.00551861f, -0.03028080f, -0.07667457f, -0.08009155f, -0.08431505f, 0.05056273f, 0.23920557f, -0.06841003f, 
    -0.13821147f, 0.19371413f, -0.06980652f, 0.01774865f, -0.05176562f, -0.01507516f, 0.02655208f, 0.01647945f, 
    0.09591283f, 0.12786338f, 0.01127377f, 0.29352307f, -0.00707731f, -0.06835604f, 0.08105956f, -0.00420041f, 
    0.07777628f, 0.18115060f, 0.07866152f, -0.06863207f, 0.21874252f, -0.08276627f, 0.32177040f, -0.16011615f, 
    0.18203640f, -0.09809577f, 0.15661944f, 0.00831769f, -0.19757318f, 0.02881345f, -0.01957492f, 0.08422732f, 
    -0.21616170f, 0.36656931f, -0.25779015f, 0.21364994f, -0.13734339f, -0.07290668f, -0.04798631f, -0.07315154f, 
    -0.07456889f, -0.04259596f, -0.10472912f, 0.06736240f, -0.11286449f, 0.31570148f, -0.12398651f, 0.03622850f, 
    -0.01591699f, -0.02913833f, -0.07977542f, 0.08025297f, 0.05578490f, 0.08365037f, 0.10025565f, 0.06116794f, 
    -0.10066265f, 0.47256750f, -0.51891834f, 0.06416724f, -0.07436460f, 0.04189472f, -0.08191045f, 0.23193225f, 
    0.13177378f, 0.07934062f, -0.07295363f, -0.01676393f, 0.48549551f, -0.22329564f, 0.02520974f, 0.24960996f, 
    0.12780449f, 0.00726865f, -0.02194843f, -0.21484831f, -0.08481633f, 0.01517104f, -0.06439790f, -0.11506993f, 
    0.11760689f, -0.00405300f, 0.05672876f, 0.09667582f, 0.06665087f, -0.06433982f, -0.02577605f, -0.01257923f, 
    0.08378450f, -0.16925953f, -0.03883792f, -0.09671678f, 0.32901862f, -0.26927277f, 0.14641225f, -0.08932502f, 
    0.02582886f, 0.17823026f, -0.10962550f, -0.06322467f, -0.09351742f, -0.16274957f, 0.01307913f, -0.12257030f, 
    0.02060299f, 0.03085956f, -0.02601506f, 0.03938406f, 0.04043865f, 0.02961280f, 0.03432199f, -0.02537240f, 
    -0.04606511f, 0.01662133f, 0.03396568f, -0.03894877f, 0.03303078f, 0.01016509f, -0.01505556f, -0.04020397f, 
    -0.05284643f, 0.02593106f, 0.03483948f, 0.02047132f, -0.03881514f, 0.01015778f, -0.00591923f, 0.01678257f, 
    -0.02484908f, 0.03305623f, -0.02684829f, 0.01213986f, -0.02785491f, 0.04057466f, -0.02697756f, 0.00306074f, 
    0.00404260f, 0.02231600f, -0.01969040f, 0.03074165f, -0.01825501f, -0.05247892f, 0.03877791f, 0.01222183f, 
    -0.02230505f, -0.03155953f, -0.01623925f, -0.02989746f, -0.02130483f, 0.03677570f, 0.01783751f, 0.01318339f, 
    -0.02091334f, -0.01876286f, -0.00318245f, 0.02750673f, 0.04055407f, -0.01836481f, 0.00248273f, -0.04872802f, 
    -0.05144869f, 0.00460383f, -0.05561476f, 0.04569335f, 0.00229224f, -0.03734297f, -0.03037101f, -0.00066038f, 
    -0.04382157f, -0.00513934f, -0.04339310f, 0.01897460f, -0.01473771f, -0.04657960f, 0.03072769f, -0.05133278f, 
    0.02739148f, -0.01181987f, 0.03944527f, 0.02661442f, -0.01485662f, -0.01639698f, -0.05145930f, 0.02503957f, 
    0.03421390f, -0.02999852f, -0.01975373f, 0.03088048f, 0.01288189f, 0.04939009f, 0.03152324f, -0.03025435f, 
    -0.03999930f, 0.01842774f, -0.00146265f, 0.02398680f, 0.01489470f, -0.04697041f, 0.02383388f, 0.01464987f, 
    -0.03100276f, 0.02951932f, 0.00024183f, 0.02435795f, 0.01593226f, 0.01491013f, -0.01168143f, 0.01748639f, 
    -0.04885525f, 0.00674184f, 0.00632628f, -0.03165159f, -0.04658348f, -0.03353859f, -0.03005480f, 0.00088820f, 
    -0.00538926f, -0.01280061f, -0.03221858f, 0.02011462f, 0.04282124f, 0.03566648f, -0.05255954f, -0.02752506f, 
    -0.02075593f, -0.00368104f, -0.02713948f, -0.05781946f, 0.00160202f, -0.03676137f, 0.03690998f, 0.04510279f, 
    -0.03693598f, -0.04709192f, 0.03248127f, -0.04933830f, 0.02162828f, 0.02645499f, -0.04867640f, 0.02635360f, 
    -0.03991795f, -0.03886295f, 0.01908957f, -0.02795361f, 0.03260301f, 0.04674983f, 0.00664286f, 0.04297460f, 
    -0.03468511f, -0.00339942f, 0.01742529f, -0.05602966f, -0.02535593f, 0.03774696f, 0.02381571f, -0.05073041f, 
    -0.04577012f, -0.00445692f, 0.00819962f, 0.04272563f, -0.01611692f, -0.01674504f, -0.04456228f, -0.03105246f, 
    0.02928362f, 0.03671184f, -0.00806693f, -0.03063116f, 0.01823706f, 0.00845589f, -0.05027187f, -0.04767176f, 
    0.01098380f, 0.01173656f, -0.04100774f, -0.04441759f, -0.00661888f, -0.03666315f, -0.03511430f, -0.03597381f, 
    -0.03257623f, -0.01039661f, -0.05346679f, -0.05202161f, -0.02761452f, -0.01420786f, -0.03830120f, -0.03516508f, 
    -0.02509251f, -0.03451135f, -0.00861764f, -0.01828501f, -0.02294902f, -0.00969038f, 0.01559540f, -0.05125924f, 
    -0.00469430f, 0.02715760f, -0.02376584f, 0.03167736f, -0.03340026f, 0.03407041f, -0.02185303f, 0.04688817f, 
    -0.01274654f, -0.00041183f, -0.03764742f, -0.01400238f, -0.03419149f, -0.05636710f, -0.03385485f, 0.03716576f, 
    0.02228235f, -0.03287406f, -0.03371181f, 0.01919711f, 0.02339029f, -0.03214764f, -0.03694062f, 0.03979045f, 
    0.03129558f, -0.01720768f, 0.01740032f, 0.01400383f, -0.01151577f, -0.03937934f, 0.03187177f, 0.04019686f, 
    -0.00353237f, -0.00421121f, 0.01293235f, -0.03602345f, -0.04432325f, -0.03508692f, 0.02034430f, 0.04128031f, 
    -0.02782496f, -0.04408899f, -0.01283341f, 0.02676403f, 0.00258289f, -0.04383009f, -0.01444918f, -0.03757157f, 
    0.00187670f, 0.03273157f, -0.05595997f, -0.00299138f, -0.05474835f, 0.03308115f, -0.00565480f, -0.00310844f, 
    0.04368768f, -0.00461758f, 0.02880308f, -0.05462268f, -0.04385892f, 0.04224850f, 0.02468959f, 0.03240428f, 
    -0.01455834f, -0.00251927f, 0.03414413f, 0.00572455f, -0.02987689f, -0.01650707f, -0.01737334f, -0.04047242f, 
    -0.01189418f, -0.04284421f, 0.03696528f, 0.01472585f, -0.05066828f, -0.05118411f, -0.04131215f, -0.02045687f, 
    -0.00808628f, 0.04154419f, -0.05282521f, 0.02718639f, -0.02739064f, -0.04231780f, 0.01569484f, -0.04671020f, 
    0.00306669f, 0.00566312f, -0.01234987f, -0.02491347f, 0.00672915f, -0.01177155f, -0.01273348f, -0.03751387f, 
    0.02353824f, -0.05251791f, -0.04144785f, 0.01923299f, 0.02242082f, 0.03277452f, -0.03427933f, -0.00885464f, 
    0.02968875f, -0.04554114f, 0.03346319f, -0.01669273f, 0.00469141f, -0.01287500f, -0.01630270f, -0.05224291f, 
    0.02619960f, -0.05287926f, -0.04738125f, 0.03198073f, -0.00406479f, -0.04067924f, -0.01811298f, 0.02077046f, 
    -0.04663588f, 0.04124867f, -0.00321527f, -0.02905196f, -0.03096409f, -0.02894050f, 0.00519364f, 0.03791986f, 
    0.00733801f, 0.02303572f, 0.04449534f, -0.02163201f, 0.02606324f, -0.04867079f, -0.04012847f, -0.03061249f, 
    -0.00879774f, -0.03298072f, -0.00779668f, -0.02140471f, -0.04144133f, 0.02635845f, 0.00797506f, -0.02142125f, 
    0.03804461f, 0.00967713f, -0.02349447f, -0.00483743f, -0.05789631f, -0.02459338f, -0.04783854f, -0.03127663f, 
    0.02032101f, 0.03822282f, -0.02302688f, -0.00603003f, 0.01466096f, 0.01728374f, -0.01581711f, -0.01677975f, 
    0.00692842f, -0.03281559f, -0.01975926f, 0.02940743f, 0.01207558f, 0.02951295f, 0.00358333f, -0.02859356f, 
    0.04270998f, -0.03454460f, -0.03285269f, 0.00509710f, -0.00778538f, 0.01020960f, 0.02712944f, -0.01311507f, 
    -0.02471963f, -0.03632874f, 0.01766405f, 0.00420357f, 0.02229425f, 0.00324411f, 0.00603173f, -0.04252333f, 
    -0.03314417f, 0.01109141f, -0.01180958f, 0.01239415f, 0.04087474f, -0.00001886f, 0.03874700f, 0.00768078f, 
    0.01372707f, 0.09050565f, 0.20093724f, 0.25314718f, 0.04231523f, 0.01691030f, -0.18637578f, -0.08157306f, 
    0.01100667f, -0.14909647f, -0.17489085f, -0.10047681f, 0.29487357f, 0.15179920f, -0.02675684f, -0.38380966f, 
    -0.00923584f, -0.08027011f, 0.01304971f, -0.05543736f, -0.12656780f, 0.10763213f, -0.03796802f, 0.21575752f, 
    0.24256457f, 0.16298571f, 0.02582777f, -0.12443148f, 0.12024942f, -0.03457581f, 0.15582323f, 0.20892966f, 
    -0.03263505f, 0.06913769f, 0.21825781f, 0.07792518f, 0.25336921f, 0.13010013f, 0.25107530f, -0.27738017f, 
    -0.01136931f, -0.22450571f, -0.05689226f, -0.04018671f, 0.19943485f, 0.02417887f, 0.13578834f, 0.21766381f, 
    0.23469162f, -0.18759854f, 0.07700225f, -0.43605301f, 0.14970361f, 0.10006525f, 0.03704988f, -0.02933090f, 
    -0.12190872f, -0.10160738f, -0.00638554f, 0.04749862f, 0.15356487f, -0.03107287f, -0.08083062f, -0.05484566f, 
    0.02210349f, 0.05264043f, -0.01458498f, -0.03467713f, 0.09702877f, -0.06735415f, 0.02231633f, 0.01406616f, 
    0.21818678f, -0.26410854f, -0.18289769f, 0.06728882f, 0.08576863f, 0.05113643f, 0.01145971f, 0.03573759f, 
    0.06691042f, 0.13372706f, 0.12772259f, 0.12598981f, 0.14123827f, -0.25287846f, 0.10432231f, -0.14059786f, 
    -0.09602399f, -0.11976641f, 0.21434757f, 0.04536268f, 0.09003550f, 0.22254473f, 0.00046635f, 0.26294154f, 
    -0.07886501f, -0.18689844f, 0.17594941f, 0.25214753f, 0.13287456f, 0.12922685f, 0.23467571f, -0.03792003f, 
    0.21432573f, 0.10523587f, 0.06548635f, 0.42405659f, -0.39813501f, 0.16673370f, -0.56920010f, 0.13703737f, 
    0.06641635f, 0.15583463f, 0.19393057f, -0.01355145f, 0.28472081f, 0.09984338f, 0.04729173f, -0.04058849f, 
    0.28606164f, 0.01509755f, 0.00719319f, -0.03686444f, 0.04389377f, 0.04902704f, 0.10316815f, -0.00110237f, 
    0.10645606f, -0.01046235f, -0.02383825f, 0.13156968f, -0.12789731f, 0.09526454f, -0.16674025f, 0.09807681f, 
    0.01249231f, 0.15428552f, 0.06225973f, 0.03179404f, 0.14008260f, -0.04252035f, -0.17825423f, -0.15133891f, 
    0.32671332f, 0.23769608f, 0.23650514f, -0.30708522f, -0.16372946f, -0.14085470f, 0.08822217f, 0.03846712f, 
    0.10551558f, 0.08691760f, 0.06068627f, -0.06606922f, 0.13138479f, -0.51937872f, -0.24885166f, -0.22640581f, 
    0.01964853f, -0.04413538f, 0.03978468f, -0.22404684f, -0.05825194f, -0.08234672f, 0.04608851f, -0.09926837f, 
    0.03345233f, 0.17037563f, -0.09136220f, -0.21013430f, 0.02476327f, 0.08101961f, -0.01165488f, 0.14280145f, 
    -0.04691273f, -0.16203098f, 0.11716194f, -0.15215716f, 0.19559574f, 0.16749890f, 0.19080353f, -0.14079359f, 
    -0.02422877f, -0.03126421f, -0.19750549f, -0.03966305f, 0.12178653f, 0.05760080f, 0.08101629f, 0.18389080f, 
    -0.28276020f, -0.04489062f, -0.30097282f, 0.17148107f, 0.08693466f, -0.03185075f, 0.04486769f, 0.07734001f, 
    -0.03715208f, -0.12647122f, -0.16889432f, 0.03831370f, -0.21185447f, -0.01226677f, -0.16157357f, -0.10351296f, 
    -0.01719654f, -0.07690174f, 0.20917903f, 0.14205563f, -0.12773752f, 0.00375698f, -0.04599527f, -0.09722224f, 
    0.14281449f, -0.29999983f, -0.07554680f, 0.00995728f, -0.01437110f, 0.01264255f, 0.02229444f, 0.06565418f, 
    0.04358961f, 0.03518260f, -0.09448486f, -0.05126238f, 0.10361276f, -0.01091744f, 0.30513486f, 0.30434784f, 
    0.01850620f, -0.11212382f, 0.08621219f, -0.03452008f, 0.06331970f, 0.03804230f, 0.02604052f, 0.12579426f, 
    0.19583172f, -0.20431389f, 0.12601539f, -0.02638520f, 0.08332933f, -0.13688362f, -0.05774443f, -0.13394424f, 
    -0.01823664f, 0.07054032f, 0.17486902f, 0.12293189f, -0.00291801f, -0.45062697f, 0.05310706f, 0.09128769f, 
    0.26366329f, 0.21988019f, 0.02599639f, 0.04487638f, -0.11604254f, -0.10496346f, -0.00472982f, -0.03699403f, 
    -0.04963576f, 0.14251880f, -0.41767639f, 0.04378890f, 0.13058585f, 0.13929200f, 0.07383079f, 0.03341679f, 
    0.12715966f, 0.13481084f, -0.04434662f, 0.04814587f, -0.03445552f, 0.02192276f, -0.05145022f, -0.26515356f, 
    0.20473944f, -0.17144315f, 0.09580990f, -0.03493615f, 0.00576457f, -0.15533210f, -0.10614333f, -0.09999622f, 
    0.01440591f, -0.07998563f, 0.11687838f, -0.03403405f, 0.05453521f, 0.25765866f, -0.17788281f, -0.10860182f, 
    0.07546243f, -0.05509403f, 0.14448024f, 0.10695761f, -0.27433676f, 0.25381720f, 0.12895578f, 0.22698462f, 
    -0.20342897f, -0.01833405f, -0.07728624f, -0.11417829f, 0.11442781f, -0.06214627f, -0.03140214f, 0.05668638f, 
    -0.05172056f, -0.25822493f, 0.20678422f, 0.31861216f, 0.04982159f, 0.07843935f, 0.00047446f, -0.20449778f, 
    -0.08547033f, 0.00258468f, -0.21567589f, -0.23683287f, 0.12380932f, -0.41197288f, 0.33580360f, 0.04826143f, 
    -0.02933687f, -0.05670973f, -0.04985710f, -0.21011223f, 0.03442692f, -0.03517281f, 0.02905985f, 0.21344970f, 
    0.52529377f, 0.16475530f, 0.68908781f, 0.00358299f, 0.06372312f, -0.08940828f, -0.10471838f, -0.29779971f, 
    -0.01247912f, 0.02370611f, 0.04242765f, 0.03424970f, -0.23325792f, 0.09602349f, 0.06030693f, -0.13033000f, 
    -0.12588637f, 0.04294592f, -0.02926726f, -0.03196378f, -0.01151623f, -0.04483718f, 0.16021901f, 0.14426716f, 
    -0.05504990f, 0.05368391f, -0.05679424f, -0.06459248f, 0.12170489f, 0.06246696f, 0.09219544f, 0.08337319f, 
    -0.22439401f, -0.10786641f, -0.15483825f, -0.29340774f, -0.19870923f, 0.02619006f, -0.41176668f, 0.26551479f, 
    0.11522830f, -0.05437305f, 0.17361806f, -0.00421084f, -0.03269214f, -0.18739074f, -0.05016635f, -0.29016450f, 
    0.34115860f, 0.31645581f, 0.17860162f, -0.26164570f, -0.12921797f, -0.09868439f, -0.15538834f, 0.17970179f, 
    -0.08355464f, -0.06842251f, -0.00439705f, -0.33300194f, 0.04115503f, 0.06260568f, 0.11150915f, 0.32107958f, 
    0.10149606f, 0.04070258f, 0.09287042f, -0.08770117f, -0.08836652f, 0.24324672f, -0.08418316f, 0.12180000f, 
    -0.13607740f, -0.15797859f, -0.21447983f, 0.00491957f, 0.10953751f, 0.12856157f, 0.14314851f, 0.13018960f, 
    -0.03089963f, 0.18940100f, 0.05520971f, -0.03078502f, -0.19774944f, 0.29012179f, 0.06119569f, 0.26884758f, 
    -0.01341998f, -0.00925126f, 0.21426815f, 0.04152293f, 0.13480334f, 0.00227767f, 0.03233050f, 0.08186476f, 
    0.06764504f, 0.06756824f, -0.32671246f, 0.06129234f, 0.20216098f, 0.12497629f, 0.10433222f, 0.00962969f, 
    -0.10260560f, -0.11490853f, -0.11521475f, -0.04402522f, 0.00667607f, 0.01316024f, -0.01176316f, 0.10965843f, 
    0.02768964f, 0.03524451f, 0.04181661f, 0.05163533f, 0.06830215f, 0.17290851f, 0.10217664f, 0.03301870f, 
    0.13636452f, -0.07088675f, 0.04739215f, 0.14718623f, 0.02577287f, 0.21561797f, 0.07001252f, 0.03412260f, 
    0.18300778f, 0.23146981f, 0.17904399f, 0.38491362f, -0.28588328f, 0.10157079f, -0.01057602f, 0.09546736f, 
    -0.02687915f, -0.03904242f, 0.09774236f, -0.16212541f, 0.21274982f, 0.30243006f, 0.21279939f, 0.20579578f, 
    -0.27667251f, -0.22528167f, -0.22228241f, -0.21523479f, 0.04102031f, -0.23301692f, 0.05015318f, -0.03137627f, 
    0.10924061f, 0.30097100f, 0.13424870f, 0.33469141f, -0.16634929f, -0.22343218f, 0.19184411f, 0.01676290f, 
    -0.05278241f, 0.21734063f, 0.04013445f, 0.02875960f, 0.08261531f, 0.07772645f, 0.10425452f, -0.10236973f, 
    0.10373486f, 0.05899760f, -0.19552737f, -0.09134100f, 0.15776801f, 0.12728576f, -0.05906307f, 0.02434572f, 
    -0.06684712f, 0.06633324f, 0.15873426f, 0.02170885f, 0.45321774f, 0.28231648f, -0.11927539f, -0.05493929f, 
    0.00168716f, -0.01673374f, 0.05319936f, 0.08942683f, -0.12274663f, 0.06829334f, 0.09172130f, 0.10490327f, 
    0.15471993f, -0.10437597f, -0.21135069f, -0.16050041f, 0.03763631f, -0.11802372f, -0.04668514f, -0.08933170f, 
    0.25670528f, 0.01968632f, -0.02830617f, -0.15341194f, -0.10941609f, 0.21524423f, -0.20278676f, 0.13920465f, 
    0.02934588f, -0.20706487f, 0.10374239f, -0.02091827f, -0.07341784f, 0.25038844f, -0.10279792f, -0.26352879f, 
    -0.05476345f, 0.00274114f, -0.19900729f, -0.13998903f, 0.06986455f, 0.05542533f, -0.11070603f, -0.01927218f, 
    -0.13107190f, -0.11121115f, -0.24301448f, -0.16366073f, 0.11414687f, 0.02140649f, 0.05801222f, -0.02657255f, 
    -0.11552239f, -0.00975319f, -0.14374697f, -0.08898700f, 0.13399419f, 0.11255009f, 0.22864690f, 0.27308813f, 
    0.17115901f, 0.38626355f, 0.10727696f, -0.09791715f, -0.07733698f, -0.01843160f, -0.12986615f, -0.05625701f, 
    -0.17790316f, -0.25102895f, -0.13746476f, -0.13192125f, 0.03011532f, 0.11458408f, 0.01244994f, -0.03187757f, 
    0.03497470f, -0.05263951f, -0.00662299f, 0.16969153f, -0.02697334f, 0.13821429f, 0.10397169f, -0.23629400f, 
    0.02184430f, 0.08785644f, -0.04870896f, 0.06151362f, -0.04921507f, 0.03487148f, 0.24063714f, 0.30915591f, 
    -0.26975143f, -0.10981935f, 0.20850365f, 0.03470701f, -0.00973435f, 0.29785010f, -0.04579319f, -0.36804745f, 
    0.08466225f, -0.05339930f, -0.15611345f, 0.04537213f, 0.14497583f, -0.00156688f, 0.22928445f, 0.12526864f, 
    0.21240811f, 0.07818397f, -0.14880650f, 0.11395927f, -0.00840815f, 0.08176806f, -0.09299760f, -0.01164605f, 
    0.13956572f, 0.19718489f, 0.04271318f, 0.04759620f, -0.33605808f, 0.07639756f, 0.23241195f, 0.20024435f, 
    0.18631923f, -0.01472367f, 0.13719971f, 0.03356239f, -0.12068921f, -0.13025089f, -0.17372991f, -0.00987097f, 
    0.07095474f, -0.15074660f, -0.01297161f, -0.02482284f, 0.01239691f, 0.00935441f, -0.01791957f, -0.05754560f, 
    0.11109909f, 0.10348515f, 0.04443352f, 0.07723085f, 0.09879817f, -0.07428622f, -0.11387067f, -0.28267467f, 
    0.00689902f, 0.03761572f, -0.08546469f, 0.01781577f, -0.04287042f, -0.19449309f, -0.08935681f, -0.40172294f, 
    0.12999444f, 0.00332937f, -0.05912280f, 0.15273754f, 0.11685104f, 0.12971646f, 0.07542328f, -0.01492826f, 
    0.10780537f, 0.10178734f, 0.04349019f, 0.20579165f, 0.58217645f, 0.07023536f, 0.34627116f, 0.27972367f, 
    -0.10806014f, 0.21421629f, -0.05602830f, 0.13773097f, 0.05265593f, 0.08818364f, -0.00667415f, 0.10672363f, 
    0.16051479f, 0.08039042f, 0.03744568f, -0.18512765f, 0.39456981f, -0.18920717f, -0.22171906f, -0.02788494f, 
    -0.38959795f, -0.16057210f, 0.15308759f, -0.26615891f, -0.22353053f, -0.01073786f, -0.25509092f, -0.05886868f, 
    -0.05872530f, -0.20477217f, 0.11183276f, -0.07083078f, 0.21915601f, 0.32751971f, 0.13854815f, 0.40465870f, 
    -0.41488203f, 0.54413056f, -0.16767032f, 0.23114178f, -0.21882297f, -0.07827479f, 0.18982816f, 0.00410015f, 
    -0.08104402f, 0.20364179f, 0.00067763f, -0.06856944f, 0.14469695f, -0.19741368f, -0.16900314f, 0.10962061f, 
    0.11801121f, 0.08039653f, 0.01899655f, 0.28394097f, 0.06254227f, -0.02734895f, 0.07839397f, 0.07674062f, 
    -0.29613853f, 0.07511234f, -0.18516736f, 0.04141276f, 0.09188126f, -0.12915620f, -0.12414303f, -0.07645091f, 
    -0.22380969f, -0.24377988f, -0.17293572f, -0.53381515f, -0.47067142f, 0.15910460f, 0.10241491f, -0.01863414f, 
    0.27458340f, 0.16564003f, -0.09372694f, -0.01218570f, -0.24128360f, -0.28030327f, -0.02991884f, -0.31840184f, 
    -0.03481806f, 0.01344315f, 0.01891361f, -0.04935427f, -0.05255733f, -0.02505175f, -0.02029401f, -0.02175197f, 
    0.02622040f, -0.00402297f, 0.01342007f, 0.04338113f, -0.05697449f, -0.05074637f, 0.04618382f, 0.01058776f, 
    0.00761817f, -0.03363127f, 0.03175256f, -0.02886779f, -0.03102176f, 0.04281832f, -0.00386634f, 0.00943032f, 
    0.03532614f, -0.05004679f, -0.04995630f, -0.05456088f, 0.00207635f, -0.05722002f, 0.02033119f, -0.01060160f, 
    -0.04247697f, -0.01271886f, -0.02823794f, 0.04194443f, 0.04037442f, 0.02551005f, 0.03416323f, -0.04427610f, 
    -0.02123841f, -0.03632344f, -0.02415638f, -0.00375819f, -0.04602798f, 0.03231997f, 0.01478084f, 0.03214209f, 
    -0.02992270f, -0.04408829f, -0.01981215f, -0.03808823f, -0.01090878f, -0.03601657f, -0.04533938f, -0.00727360f, 
    -0.05701555f, -0.02774321f, -0.04283196f, 0.02783354f, -0.04578038f, 0.03052471f, 0.03547364f, -0.05115911f, 
    0.04068791f, 0.01131848f, -0.02715557f, -0.04900743f, -0.02715659f, 0.01573450f, -0.04544702f, 0.02338955f, 
    -0.00332233f, -0.00887217f, 0.03470529f, 0.03680139f, -0.01993367f, -0.00009267f, 0.02738645f, 0.00268878f, 
    0.01916710f, 0.02593147f, -0.01956693f, 0.02999982f, -0.03049167f, 0.00035932f, 0.02713083f, 0.00742230f, 
    -0.02867663f, -0.05802527f, -0.03723262f, -0.01045245f, -0.02168445f, -0.02274973f, 0.03517429f, -0.04164573f, 
    0.03679539f, -0.00281921f, 0.01408710f, 0.03890100f, -0.04227481f, 0.00542022f, 0.02042438f, -0.01275806f, 
    -0.02226663f, -0.03875016f, -0.02167751f, -0.05271450f, 0.02060939f, -0.00510401f, -0.00925345f, -0.05700902f, 
    -0.02352230f, 0.03282482f, 0.00606513f, -0.05077346f, 0.03307747f, 0.00291458f, -0.02184737f, 0.00844064f, 
    -0.00626595f, -0.03605152f, -0.04992516f, -0.00429129f, -0.03038136f, -0.00380448f, 0.02086103f, 0.02690836f, 
    -0.03279005f, 0.00310724f, 0.01825431f, -0.02151552f, -0.00697199f, -0.02794287f, 0.00898025f, 0.03358869f, 
    -0.04773509f, 0.03793389f, -0.05803059f, 0.02167260f, -0.01699095f, -0.04300595f, 0.04175060f, 0.03827116f, 
    0.01020845f, -0.02566528f, -0.04980622f, -0.01733273f, -0.04739552f, -0.02022475f, -0.01772484f, 0.04302230f, 
    -0.02873317f, 0.00650714f, -0.01212801f, 0.02138531f, -0.02530038f, -0.00796722f, 0.02265486f, -0.02158322f, 
    0.02325697f, 0.01353010f, -0.02603156f, 0.03444608f, -0.05201749f, -0.02132116f, -0.02650718f, 0.03509187f, 
    0.02700838f, -0.01191168f, -0.00703681f, -0.01085956f, -0.03838683f, -0.00057877f, -0.02578200f, -0.05017114f, 
    -0.02328565f, -0.03882245f, 0.03064532f, -0.00692907f, -0.02464858f, 0.02125330f, -0.03934487f, 0.00749752f, 
    0.02844074f, 0.00864312f, -0.02931662f, -0.02200159f, -0.04353381f, 0.02559334f, 0.02461382f, -0.00067233f, 
    -0.02059617f, -0.02665826f, 0.01277106f, 0.01363591f, -0.01066943f, -0.04117222f, -0.02700618f, 0.02215246f, 
    0.00653757f, -0.03455551f, -0.05709062f, -0.03016982f, -0.00499127f, -0.01807272f, -0.01826049f, -0.01409494f, 
    -0.03970918f, 0.00632839f, -0.01074064f, -0.05734381f, 0.02900342f, 0.04094565f, -0.01652779f, 0.02082898f, 
    -0.01785545f, 0.01021346f, -0.01806972f, -0.03511526f, -0.05398196f, -0.05393817f, 0.01547971f, 0.04277985f, 
    0.03838088f, -0.05464058f, 0.03982357f, 0.00920897f, -0.02175212f, 0.00598780f, -0.03042140f, 0.00578701f, 
    -0.01159816f, 0.03081895f, 0.03393666f, -0.02427974f, -0.00223358f, -0.02177498f, -0.01417162f, -0.05891819f, 
    -0.01704480f, 0.01234863f, -0.05652640f, 0.03482325f, -0.00692282f, 0.00740890f, -0.02609662f, -0.03838836f, 
    0.03414883f, 0.00347547f, 0.04176321f, -0.04488993f, 0.01592694f, -0.01180484f, 0.02713845f, 0.00296504f, 
    0.04027102f, 0.00506291f, -0.03893344f, -0.01544575f, -0.01886969f, 0.00270814f, -0.00822145f, 0.03269637f, 
    0.01740030f, -0.03522599f, -0.05054625f, 0.02028516f, -0.03141351f, -0.02235986f, -0.04604910f, 0.03544593f, 
    -0.01398507f, -0.00089113f, 0.02946315f, -0.03434158f, 0.03127623f, 0.00008770f, 0.01208551f, 0.02823288f, 
    -0.04626776f, -0.00391677f, 0.04724396f, -0.03092567f, -0.04045152f, -0.02226193f, 0.01478302f, 0.04258079f, 
    0.02092495f, -0.03035049f, -0.02731705f, 0.03636267f, -0.04592383f, -0.03431941f, -0.04793796f, -0.03772266f, 
    -0.04118360f, -0.01544823f, -0.01917339f, 0.00645037f, -0.00163095f, -0.00813807f, 0.01172596f, -0.02697236f, 
    0.04412499f, -0.03833819f, -0.04184740f, 0.02165077f, -0.03768649f, -0.04972567f, 0.04076729f, -0.03867292f, 
    -0.00861866f, -0.05234291f, -0.00742541f, -0.00034358f, 0.01790491f, 0.01540801f, -0.00042171f, -0.02837447f, 
    0.01996554f, 0.03385658f, 0.03204861f, -0.03494056f, 0.04037203f, 0.01111520f, -0.00303741f, -0.00401445f, 
    -0.01329600f, 0.02455857f, -0.01268865f, -0.02051020f, 0.03612864f, 0.01930026f, 0.01242373f, -0.03504560f, 
    -0.04076830f, -0.05707870f, 0.01422082f, 0.01935566f, -0.02752114f, -0.00905302f, 0.01889254f, -0.02505289f, 
    -0.05411109f, 0.04100098f, -0.03875147f, -0.01431241f, 0.03256726f, 0.02954047f, 0.01233500f, 0.04227325f, 
    -0.05198386f, 0.02769917f, -0.02340544f, -0.05295006f, -0.05161182f, -0.05046261f, -0.00736973f, 0.00881528f, 
    0.01157657f, -0.00852808f, -0.00456751f, 0.01611405f, -0.04956200f, -0.05419447f, -0.01002559f, -0.04664893f, 
    0.01319706f, -0.04613865f, -0.05509317f, 0.02852861f, 0.02297609f, -0.04729163f, 0.03303348f, -0.00489789f, 
    -0.00584601f, 0.03550582f, -0.05925305f, -0.05400261f, 0.01747140f, -0.02714828f, 0.00870102f, -0.00780547f, 
    -0.37365195f, 0.05021414f, -0.01110533f, 0.21644968f, -0.01772807f, 0.01609639f, 0.03147652f, 0.09872504f, 
    0.07464420f, 0.06295152f, -0.11479212f, 0.08624697f, 0.03762048f, -0.02687677f, -0.13071278f, 0.05208320f, 
    0.12568530f, 0.19601454f, 0.09283025f, 0.10809094f, -0.08322089f, 0.12702924f, 0.10160892f, -0.09662376f, 
    0.28995967f, 0.19609134f, -0.00388688f, -0.21594545f, 0.08207150f, -0.05232757f, -0.17113076f, -0.03169636f, 
    -0.10485901f, -0.02147024f, 0.12048563f, 0.09208531f, 0.25256968f, -0.13866511f, -0.34318224f, 0.05540253f, 
    -0.06553628f, 0.23352632f, -0.04615546f, 0.13062990f, -0.21779394f, 0.18215977f, 0.03870594f, 0.06830776f, 
    0.36442086f, 0.12133864f, -0.07778662f, -0.07154725f, 0.04313122f, 0.04446970f, 0.17484856f, -0.16385420f, 
    -0.09964918f, -0.03852944f, -0.01623796f, 0.03862983f, 0.08890095f, 0.36845741f, -0.01128026f, -0.03553144f, 
    0.09654358f, 0.00414286f, -0.06277506f, 0.00350488f, -0.08051893f, 0.00507357f, 0.11015507f, 0.04342461f, 
    -0.14456908f, -0.00187710f, -0.17489623f, -0.00303398f, 0.00118632f, -0.04479091f, 0.00613859f, -0.03603849f, 
    -0.24145328f, -0.10918290f, -0.09195760f, -0.01383909f, -0.23722640f, -0.04807315f, -0.02455300f, 0.01685089f, 
    -0.20901057f, -0.06016838f, -0.03639297f, 0.05238395f, -0.06613842f, -0.10826389f, 0.02934600f, -0.02277413f, 
    -0.09769740f, 0.04315308f, -0.02338110f, 0.04637764f, 0.01987334f, 0.01439137f, -0.08502995f, -0.10200237f, 
    -0.07897025f, -0.03897505f, -0.14728890f, -0.13077292f, -0.12265123f, 0.09433579f, -0.13370481f, 0.21662031f, 
    0.11413465f, -0.03714955f, -0.02129127f, 0.07337812f, -0.11644582f, -0.04136313f, 0.03158511f, -0.25180560f, 
    0.24554169f, 0.29275623f, -0.00246932f, -0.19633135f, -0.11166868f, 0.07011021f, 0.14777969f, -0.24344246f, 
    0.00290375f, 0.01251462f, -0.05139570f, 0.06195303f, 0.26164845f, -0.09387550f, 0.58911651f, -0.18629518f, 
    0.18700521f, -0.09996784f, 0.09511099f, 0.11400517f, 0.05658927f, -0.17802216f, 0.16442439f, -0.02441650f, 
    0.43527195f, 0.04194646f, 0.02644247f, -0.26204431f, 0.04150650f, 0.06337040f, 0.06481337f, 0.06433038f, 
    -0.01864242f, 0.00506670f, -0.05388844f, -0.06625144f, 0.19023067f, -0.11001199f, 0.18266152f, 0.01651726f, 
    0.19623943f, -0.05898405f, 0.03608781f, 0.10656904f, 0.21453939f, 0.08496490f, 0.09094885f, -0.08476215f, 
    0.06112956f, 0.13919102f, 0.07085171f, -0.30769998f, 0.13475870f, -0.09534233f, -0.09802111f, -0.09184805f, 
    -0.18250945f, -0.11852995f, -0.16507378f, -0.08981898f, 0.07216449f, 0.11393555f, 0.15218866f, -0.42173943f, 
    0.21186808f, -0.09096947f, 0.04367571f, -0.02927417f, 0.11583182f, -0.07691678f, 0.07617904f, 0.00581811f, 
    -0.10323653f, -0.23725712f, 0.37665772f, 0.01216078f, -0.11722653f, 0.10681374f, 0.16883437f, 0.03693640f, 
    0.15174173f, -0.03953795f, -0.03385471f, -0.06115286f, 0.29591978f, 0.01133183f, 0.15926887f, -0.05827636f, 
    0.25446677f, -0.09060202f, -0.02667810f, 0.20006259f, 0.12895624f, 0.22717148f, 0.01126937f, 0.30501899f, 
    -0.25099444f, -0.15593879f, -0.20888203f, -0.03902437f, -0.18898901f, -0.03090160f, -0.14612830f, -0.11407722f, 
    -0.20040940f, 0.05251242f, 0.12983833f, 0.29820868f, 0.09238522f, 0.07804296f, 0.02444693f, 0.12371189f, 
    -0.07910808f, 0.00553450f, 0.04507179f, -0.08175298f, 0.10365043f, 0.01321223f, 0.19787641f, 0.34641302f, 
    -0.05433835f, 0.00395002f, -0.31036019f, -0.06111336f, -0.04543137f, 0.19423971f, -0.05067872f, 0.17685150f, 
    -0.13617538f, 0.03239529f, 0.03508059f, 0.01312524f, 0.24176529f, -0.14644557f, -0.01400794f, -0.06001898f, 
    0.01920887f, 0.07687358f, 0.11251971f, -0.08162958f, -0.11157619f, 0.04886674f, -0.13207537f, 0.01270915f, 
    -0.19136500f, -0.08247378f, 0.03224936f, 0.11711562f, 0.12736221f, 0.07709684f, 0.10892293f, 0.08461829f, 
    -0.13382408f, 0.13778090f, 0.08675997f, -0.04182962f, 0.33683664f, 0.23033836f, 0.02554201f, -0.08974672f, 
    -0.03529977f, 0.05581489f, 0.03520591f, 0.02989900f, 0.11300813f, -0.04083203f, 0.03869692f, 0.08746430f, 
    0.03889761f, 0.16149686f, -0.24710286f, -0.24952392f, 0.12130699f, 0.10590426f, -0.04340675f, 0.02801891f, 
    -0.14878410f, -0.01159970f, -0.06843814f, -0.03602715f, -0.88599437f, -0.29415458f, -0.10740876f, -0.10088789f, 
    -0.01781560f, 0.01079038f, 0.05304591f, 0.04308095f, 0.02584594f, 0.18528529f, -0.06691358f, -0.09936637f, 
    -0.11259113f, 0.39597359f, -0.12586443f, 0.33371237f, 0.01063896f, -0.03248920f, 0.05564206f, -0.04961593f, 
    0.05751066f, -0.02193522f, 0.12597772f, 0.08967592f, -0.08814211f, -0.01941123f, -0.14717121f, 0.01938765f, 
    -0.12139361f, -0.04372814f, 0.00475235f, 0.09778441f, 0.08273447f, -0.13684645f, -0.07670707f, -0.05866789f, 
    0.07210781f, -0.34891117f, -0.13822734f, 0.08110189f, 0.07896245f, -0.02098007f, -0.12064063f, 0.09506369f, 
    -0.02006823f, -0.02962497f, 0.03972986f, -0.07366449f, -0.03466157f, 0.17404570f, -0.07231466f, -0.27242917f, 
    0.04840913f, 0.21810734f, 0.08984121f, 0.05584108f, -0.16166846f, 0.02176941f, -0.03804827f, 0.02814659f, 
    -0.01658335f, -0.11552159f, 0.12408420f, 0.02402056f, 0.02045676f, 0.17697638f, -0.14762989f, -0.02534874f, 
    0.06580003f, -0.04357858f, -0.03837586f, 0.15174733f, 0.17110646f, -0.23350434f, 0.08665059f, -0.03565000f, 
    0.26617357f, 0.09633800f, 0.21664506f, 0.05321415f, 0.02124249f, 0.08036758f, -0.02475860f, 0.04520761f, 
    0.00537838f, -0.01809217f, -0.00685422f, -0.04087309f, -0.03979581f, 0.01016057f, -0.00736555f, 0.04382253f, 
    -0.04428335f, -0.02073254f, -0.05072109f, -0.03510208f, -0.02234055f, 0.04893885f, 0.02792820f, 0.00106428f, 
    -0.02893680f, -0.04417655f, -0.04466458f, 0.02639648f, -0.04281262f, 0.02006696f, 0.02201458f, -0.03972688f, 
    0.03971217f, 0.01468097f, -0.01024757f, -0.03998409f, 0.01152260f, -0.00835855f, 0.04968324f, 0.03792430f, 
    -0.01095910f, 0.03121760f, 0.04639245f, -0.03397272f, -0.04375241f, -0.03507648f, -0.03371041f, -0.00044776f, 
    -0.04981324f, 0.01345452f, -0.01820833f, -0.01067165f, 0.00769182f, -0.00957690f, -0.03189488f, -0.00473690f, 
    -0.02655985f, 0.04537397f, 0.03553670f, -0.03293367f, -0.03957666f, -0.01554864f, -0.02429268f, -0.01554138f, 
    0.01369807f, 0.01133143f, 0.03782867f, -0.04867488f, -0.03583442f, 0.02022056f, -0.03455097f, -0.02643531f, 
    -0.00945259f, 0.04495024f, -0.03183239f, -0.02089045f, -0.00112792f, 0.00997194f, 0.03183324f, 0.02468889f, 
    0.01817860f, 0.02021037f, 0.01913274f, 0.02446522f, -0.00826888f, -0.03382718f, -0.04252103f, -0.02739782f, 
    -0.03265730f, 0.01021512f, -0.05035017f, 0.00511064f, 0.03144272f, 0.00894815f, 0.03729516f, 0.01206374f, 
    0.03140951f, -0.02753165f, 0.03371722f, -0.00061940f, 0.02608211f, -0.01925989f, -0.03123321f, -0.00589645f, 
    0.00348663f, 0.02670586f, 0.02480289f, -0.04466580f, -0.01453358f, -0.03953804f, 0.04135686f, -0.02235581f, 
    -0.03346399f, -0.03722268f, 0.00485162f, 0.03047095f, 0.01400128f, 0.02712124f, -0.00513550f, 0.02135280f, 
    0.02960645f, 0.00717130f, -0.04487469f, -0.02869402f, -0.03442859f, 0.02021058f, -0.00450097f, -0.00889137f, 
    -0.03881323f, -0.00735905f, 0.01240565f, -0.03408817f, -0.04414120f, 0.00265412f, -0.05293848f, -0.02204151f, 
    -0.04372620f, -0.04524031f, 0.03807175f, -0.02795980f, 0.01997708f, -0.02290675f, -0.02702755f, -0.04634424f, 
    -0.03765636f, 0.00927669f, 0.03856678f, 0.03398345f, 0.02435421f, -0.04795382f, -0.04095000f, -0.02593957f, 
    -0.02041416f, -0.00664664f, 0.01293695f, -0.01591199f, 0.02519896f, -0.04827068f, 0.04363519f, 0.04039535f, 
    0.03888232f, -0.04698278f, -0.02796932f, 0.02829615f, -0.03576652f, 0.03465765f, -0.03928586f, 0.01166643f, 
    -0.02077066f, 0.03218304f, -0.02761525f, 0.00441682f, -0.01435282f, 0.02896095f, -0.03133237f, 0.03635584f, 
    0.04481913f, -0.04256992f, -0.00849244f, -0.02030746f, -0.04428384f, -0.01194807f, -0.02779807f, 0.01761620f, 
    -0.03546101f, 0.01154539f, -0.05223830f, -0.05624383f, 0.04399288f, 0.01118090f, 0.04709203f, -0.01206240f, 
    -0.00283378f, -0.00981143f, 0.00554955f, -0.02406842f, -0.04459426f, 0.00866810f, -0.03876184f, -0.03401273f, 
    -0.04739279f, 0.03003214f, 0.00272241f, -0.00614402f, 0.01229049f, 0.02029563f, -0.02537716f, -0.00300242f, 
    -0.02433026f, -0.03663269f, -0.03829846f, 0.04229118f, 0.01276182f, -0.04669022f, 0.00675587f, -0.00240747f, 
    -0.00891219f, 0.05007066f, 0.02454835f, -0.00246107f, 0.02122860f, 0.00218137f, 0.00406960f, -0.05345658f, 
    -0.03483212f, 0.00055710f, -0.03670233f, -0.04221096f, -0.00782199f, -0.00058320f, -0.04896597f, -0.00272691f, 
    0.04329331f, -0.02342841f, -0.00912486f, -0.04965660f, -0.04566583f, 0.01551837f, 0.03713450f, 0.03000067f, 
    -0.05267227f, 0.02727162f, -0.05260900f, -0.02788434f, -0.01778051f, -0.03060833f, -0.03378073f, -0.00588581f, 
    0.00420903f, -0.02583245f, 0.03363738f, -0.03410610f, -0.03914506f, -0.04137782f, -0.05351079f, 0.03483547f, 
    -0.01722423f, -0.01463230f, 0.00115416f, 0.03670770f, -0.02496580f, -0.04119452f, -0.01973083f, -0.03502591f, 
    -0.02350630f, 0.04019770f, 0.04365271f, -0.04378099f, 0.02244725f, -0.01502028f, -0.03588669f, 0.00043298f, 
    0.01575272f, 0.02563851f, -0.03676599f, 0.04353438f, -0.01118899f, -0.04368582f, -0.00215567f, 0.02316290f, 
    -0.02496495f, -0.00869701f, -0.02394821f, -0.04651647f, 0.01148419f, -0.05316760f, -0.00015112f, -0.05498126f, 
    -0.01684463f, 0.03163030f, 0.01677460f, 0.02829165f, -0.04683385f, -0.02934812f, -0.05001516f, 0.02895409f, 
    -0.03917238f, 0.04949117f, 0.00733601f, -0.03289370f, 0.00128179f, -0.02697353f, 0.01612659f, 0.02294946f, 
    -0.03280161f, 0.02087127f, -0.04925320f, -0.02530628f, 0.02881480f, -0.03317620f, 0.03727144f, -0.03984251f, 
    -0.04631838f, 0.03080696f, 0.02320652f, 0.00588410f, -0.02519323f, 0.02697801f, -0.00336645f, -0.01680016f, 
    0.02827383f, 0.01570200f, -0.02103277f, 0.00233822f, -0.00532163f, -0.00415143f, 0.00639644f, -0.02867597f, 
    -0.01410794f, -0.03851726f, 0.01169288f, 0.01489156f, -0.01848276f, -0.05096454f, -0.00617700f, 0.03719722f, 
    -0.05019455f, 0.01990874f, -0.00087618f, 0.02946686f, -0.03320600f, -0.05145625f, 0.03973011f, -0.01132064f, 
    0.00777192f, -0.04808258f, 0.01623698f, 0.01144865f, -0.00638671f, 0.01436421f, -0.00499914f, 0.00551489f, 
    -0.01732044f, 0.01478704f, -0.01151269f, -0.05652528f, -0.00465478f, 0.01133941f, -0.02537092f, -0.00527382f, 
    0.02314165f, -0.04491105f, -0.00088999f, 0.03222205f, -0.04544029f, 0.01103552f, -0.01631526f, 0.00469595f, 
    0.00390665f, 0.01552632f, 0.01278746f, -0.05457773f, -0.00023706f, 0.00305582f, -0.02127515f, 0.00906687f, 
    0.03786815f, 0.02856030f, -0.00856054f, 0.01688505f, 0.00043950f, -0.04124795f, -0.03323109f, 0.01704318f, 
    -0.01063303f, -0.05077045f, -0.02891330f, -0.00153624f, 0.01491995f, -0.03391346f, -0.03896267f, -0.04513218f, 
    0.06427271f, -0.00458386f, -0.20926292f, -0.11279456f, 0.06172125f, -0.00194047f, 0.00873753f, -0.02557368f, 
    -0.06396621f, 0.31402624f, 0.29070762f, -0.03950872f, -0.33859724f, -0.01964914f, 0.04422515f, 0.36489698f, 
    0.11719717f, 0.07243463f, 0.20421678f, 0.06040240f, -0.02294521f, 0.16315840f, 0.09997939f, 0.07298030f, 
    -0.35476029f, -0.31140012f, -0.08696621f, 0.13988507f, -0.01381885f, 0.00368544f, 0.21356618f, 0.04286591f, 
    -0.02036987f, -0.09698417f, -0.03930565f, -0.06298498f, -0.40815616f, 0.21636309f, 0.06040708f, 0.16839920f, 
    -0.13405392f, 0.20704766f, 0.17418967f, 0.05991431f, 0.03970581f, 0.23806383f, 0.13499993f, 0.19407246f, 
    -0.22293611f, 0.18322939f, -0.04460547f, 0.28569353f, -0.01169371f, 0.02939807f, 0.12837951f, 0.19019605f, 
    -0.03675592f, 0.02761906f, -0.02165513f, 0.08059993f, 0.13245672f, -0.11735148f, 0.26626113f, 0.19997883f, 
    0.13714574f, 0.14413822f, 0.16175394f, 0.06162297f, -0.01450387f, 0.02619407f, 0.03013039f, 0.04612145f, 
    -0.03572283f, 0.06608854f, 0.11811422f, 0.25218540f, 0.02834441f, 0.06150183f, 0.01945257f, 0.14671166f, 
    0.23511639f, 0.14348988f, 0.08407532f, 0.27960506f, -0.28219298f, 0.13818876f, 0.21147893f, 0.25684232f, 
    -0.03083102f, -0.08760782f, -0.06965386f, -0.04447370f, 0.16020298f, 0.08636780f, 0.15200691f, -0.03895572f, 
    -0.05507074f, 0.02175721f, -0.01176732f, -0.09500176f, -0.07427493f, -0.13429284f, 0.00134147f, -0.04218448f, 
    -0.11001481f, -0.09086566f, 0.00537637f, -0.04728990f, 0.16519144f, -0.09894326f, 0.26061738f, -0.21997924f, 
    -0.18771940f, 0.20810601f, 0.05163252f, 0.31478462f, 0.00475194f, 0.06494146f, 0.03707087f, -0.09185465f, 
    -0.30601117f, -0.17041115f, 0.10162763f, 0.03538457f, 0.12389452f, 0.07630936f, -0.04318256f, 0.01152190f, 
    0.00727443f, -0.00886378f, 0.09194643f, 0.08025683f, 0.21478608f, 0.36758327f, -0.24706942f, -0.06718828f, 
    0.14365855f, 0.06057144f, -0.19935186f, -0.09084617f, -0.13901807f, 0.20051835f, 0.05738040f, 0.07397063f, 
    -0.27032804f, -0.41687849f, -0.26166570f, 0.10523551f, 0.26488939f, 0.10838134f, 0.19154520f, 0.23288244f, 
    0.03644673f, 0.02881788f, 0.06924050f, 0.00502488f, 0.07749656f, 0.08934739f, 0.05720693f, 0.07999367f, 
    0.29907250f, 0.05120724f, 0.18492800f, 0.32944560f, 0.32843593f, 0.01059974f, -0.11907759f, 0.03351965f, 
    -0.21449941f, -0.31007236f, -0.27956444f, 0.04190437f, 0.08830456f, 0.08647931f, 0.09551620f, 0.25542217f, 
    0.11936570f, 0.09142074f, -0.01078665f, 0.05343553f, 0.00909183f, -0.36785731f, -0.06916554f, 0.28204423f, 
    0.15046917f, 0.02388110f, -0.06428150f, 0.09530830f, 0.15779459f, 0.17830256f, 0.25015697f, 0.06400186f, 
    0.49631435f, 0.05747494f, -0.21393612f, -0.03972181f, 0.00830516f, 0.09195228f, -0.17931129f, 0.01420867f, 
    -0.00398681f, 0.06905375f, -0.01637059f, -0.01964039f, -0.05628732f, 0.06539833f, 0.06321281f, 0.22661604f, 
    0.13626540f, 0.17130730f, -0.01660636f, 0.10792739f, 0.01292933f, 0.09890543f, 0.07152569f, 0.01724851f, 
    0.02324006f, 0.06862780f, 0.04413896f, 0.13517889f, 0.13180032f, -0.00342856f, 0.24520701f, 0.07304720f, 
    0.05792709f, -0.02607155f, 0.00332474f, 0.38844627f, -0.05560792f, 0.13339384f, 0.05647501f, -0.16580552f, 
    0.06331585f, -0.02274413f, -0.03645245f, -0.11012217f, 0.22782919f, -0.06760567f, 0.01334435f, -0.04327919f, 
    -0.15007955f, 0.05868098f, 0.09788446f, -0.08350167f, 0.07566785f, -0.17125989f, 0.17281307f, 0.01666544f, 
    0.06498723f, 0.19259994f, 0.18022454f, -0.06203067f, -0.01616314f, 0.20822895f, 0.10948075f, 0.03069413f, 
    0.09954742f, 0.21602249f, 0.01923500f, 0.25192580f, 0.07559656f, -0.12655140f, -0.01627969f, -0.01965085f, 
    0.00378688f, 0.00888626f, 0.00944270f, -0.06281541f, -0.16472539f, 0.10318471f, 0.14565478f, 0.40401018f, 
    0.16778573f, -0.12623231f, 0.18070848f, 0.04658000f, 0.14164178f, -0.28084320f, -0.05377553f, 0.00275530f, 
    0.14246508f, 0.27273786f, 0.08800936f, 0.27980131f, 0.01958524f, 0.06544106f, -0.02721833f, -0.10031643f, 
    -0.06126690f, -0.12734924f, -0.07666532f, -0.03612044f, 0.02772664f, -0.07701597f, 0.45943445f, 0.11300877f, 
    0.14654808f, 0.03520966f, 0.10480896f, 0.15741917f, 0.50022489f, -0.09807605f, -0.11450280f, 0.16782278f, 
    0.02048306f, 0.11369956f, -0.12171104f, -0.16038677f, 0.00637249f, 0.14931750f, 0.18903358f, 0.19576840f, 
    0.32208377f, -0.03565197f, -0.17169201f, -0.40979004f, 0.19547531f, -0.13743384f, -0.09995757f, -0.08241607f, 
    -0.03317784f, 0.02099813f, -0.09971042f, -0.07722071f, 0.11794002f, 0.02494263f, -0.04919399f, -0.06537414f, 
    -0.02608611f, -0.10596929f, -0.08807416f, -0.03353627f, 0.11155100f, 0.12012425f, 0.12856850f, -0.14823000f, 
    -0.50049484f, -0.14595574f, -0.02714775f, 0.07979013f, 0.02419086f, -0.04515318f, 0.05644505f, 0.02296776f, 
    0.06656769f, 0.12202184f, 0.14851473f, 0.11769542f, 0.11189988f, -0.27662981f, -0.09936979f, 0.12832321f, 
    0.15223411f, -0.08245964f, 0.05731134f, 0.12259235f, 0.03239179f, -0.03281625f, -0.05649860f, 0.05959979f, 
    -0.03215091f, 0.01359415f, -0.04918725f, -0.04815255f, 0.13864316f, 0.12228621f, 0.10804150f, 0.00262595f, 
    0.11382363f, 0.03655219f, 0.16954434f, 0.00242299f, -0.08537091f, 0.11696545f, 0.11296074f, -0.18850489f, 
    0.17469658f, 0.22724687f, 0.12005947f, 0.11154439f, 0.07623709f, -0.02719601f, -0.00477472f, 0.04237909f, 
    -0.08994250f, -0.07219959f, 0.24940166f, -0.11254827f, -0.00122366f, 0.05887840f, 0.06773487f, -0.03774340f, 
    0.11091132f, -0.22367448f, 0.08461072f, -0.02486447f, 0.41696414f, 0.24809499f, 0.16818757f, 0.26640752f, 
    0.06790181f, -0.17798287f, -0.09049757f, 0.14738485f, -0.06752921f, 0.07560451f, -0.30274859f, 0.08143599f, 
    -0.01375630f, 0.11686452f, 0.13703962f, 0.07830929f, 0.05918219f, 0.13377953f, 0.07732751f, 0.03562849f, 
    0.00560614f, 0.04813596f, -0.05023057f, 0.05691855f, 0.07814983f, 0.00304456f, 0.16431633f, 0.04231336f, 
    -0.06127429f, -0.21726729f, 0.01888556f, -0.23127259f, 0.15875936f, -0.19043006f, -0.09953793f, -0.05932241f, 
    -0.16756217f, -0.25080997f, -0.08875377f, 0.13239995f, 0.11342897f, 0.19375768f, -0.01092955f, -0.12989157f, 
    -0.03337190f, -0.04927619f, -0.05024069f, 0.01470119f, 0.04284887f, 0.12149473f, -0.21081200f, 0.04988267f, 
    -0.00662546f, -0.08852983f, -0.03702525f, 0.09119322f, 0.00838355f, 0.04023227f, -0.24130802f, 0.03137789f, 
    0.04875812f, 0.13093729f, -0.09535878f, -0.05073118f, -0.11114243f, 0.03434892f, 0.01803143f, -0.14227407f, 
    0.03311617f, 0.17332278f, -0.01480545f, -0.02538190f, 0.22586592f, -0.04403227f, -0.13117877f, -0.21384771f, 
    0.04642466f, -0.04951831f, -0.01660440f, 0.09665882f, -0.21037334f, 0.06532908f, 0.00806150f, 0.27433127f, 
    -0.05294370f, -0.06578121f, -0.06949537f, -0.04283688f, -0.00228590f, 0.06056888f, 0.02120562f, 0.10069369f, 
    0.02252487f, -0.00296608f, 0.03985929f, 0.07203921f, 0.06598234f, -0.16223755f, -0.00721764f, 0.03998288f, 
    -0.10374248f, -0.06236374f, 0.30674747f, -0.18221942f, 0.12643060f, -0.04378854f, 0.02376176f, 0.04725949f, 
    0.14312740f, -0.14125711f, -0.28693104f, 0.20825049f, 0.12413169f, 0.11610290f, 0.08679540f, 0.18958265f, 
    -0.07237811f, -0.03607146f, 0.08090504f, -0.13781075f, -0.30903473f, -0.19493730f, -0.18404822f, 0.02094930f, 
    -0.23481295f, 0.16897863f, 0.25423753f, 0.08530328f, 0.12881143f, -0.10588270f, -0.04584548f, 0.00014888f, 
    -0.14963447f, 0.16601427f, 0.15057640f, 0.06593959f, -0.17632803f, -0.05889712f, -0.03545925f, -0.10413213f, 
    0.06093128f, 0.01673710f, -0.06889987f, 0.05536633f, -0.08705568f, 0.10438146f, -0.00953298f, 0.02388449f, 
    -0.35662353f, -0.12468594f, -0.06377745f, -0.33172247f, 0.00856270f, 0.05207396f, 0.20082082f, -0.04090049f, 
    0.25843042f, 0.24098378f, 0.21713609f, 0.21839678f, -0.20777993f, -0.01502736f, 0.05838447f, -0.06907791f, 
    -0.04147967f, -0.12364751f, 0.08936793f, 0.05604985f, -0.09964484f, 0.20248018f, -0.22157991f, 0.02947570f, 
    -0.13411023f, 0.10828595f, 0.04186761f, 0.05603694f, -0.27857834f, -0.01135072f, 0.11146224f, 0.19828662f, 
    -0.35261035f, 0.30495670f, -0.19494706f, -0.17272627f, 0.12787786f, -0.13460235f, 0.20266189f, 0.05784422f, 
    0.05790262f, -0.13194847f, 0.08521622f, 0.06659221f, -0.17055835f, -0.12432060f, -0.01694155f, -0.27270904f, 
    0.04130548f, 0.04109239f, 0.16605771f, -0.08194609f, 0.06417611f, -0.09434293f, 0.01780868f, -0.11481398f, 
    0.04660999f, 0.17880028f, 0.26943749f, 0.05800672f, 0.09987595f, 0.07701482f, -0.08131716f, 0.12284885f, 
    0.00650959f, 0.02690258f, 0.23049104f, -0.57424539f, -0.08305432f, -0.13867919f, -0.13988964f, 0.24994946f, 
    0.05870730f, 0.11802170f, 0.03939110f, 0.05676208f, -0.22062933f, 0.08690057f, 0.17063935f, 0.04565477f, 
    0.11116347f, -0.02029298f, 0.02541993f, 0.20616007f, 0.04710697f, 0.05240259f, -0.18074977f, -0.09609236f, 
    -0.05471965f, -0.05289674f, 0.10729994f, 0.14762932f, -0.13573280f, -0.02823295f, 0.13005617f, 0.03506622f, 
    0.14841400f, -0.17016578f, 0.05811319f, -0.04451643f, 0.00399399f, 0.05319500f, 0.00201900f, 0.06465458f, 
    0.15513417f, -0.08805162f, 0.06023679f, -0.00498241f, -0.15859382f, 0.02116133f, -0.27064359f, -0.44122687f, 
    0.11049221f, 0.08802063f, -0.13932966f, 0.02761233f, -0.21486104f, 0.13797499f, 0.08904615f, 0.04884508f, 
    -0.04264196f, 0.01612066f, -0.05804420f, -0.01936587f, -0.12057543f, -0.10352448f, -0.04552628f, -0.01942708f, 
    0.10170784f, 0.10037814f, 0.24705851f, 0.31023541f, -0.06981852f, 0.00991539f, -0.14443688f, -0.10183500f, 
    -0.01217170f, 0.09219101f, 0.14410713f, 0.18278109f, 0.52885944f, 0.30891076f, 0.33143538f, 0.15029155f, 
    0.04087462f, -0.08504029f, 0.06425772f, 0.16172241f, -0.02849078f, -0.14570564f, -0.16348457f, 0.17669408f, 
    -0.39627433f, -0.10318145f, -0.06330790f, 0.12433866f, 0.02830281f, 0.07111615f, 0.01945551f, 0.00702751f, 
    -0.06205577f, -0.00223250f, 0.06366379f, -0.14258091f, -0.13547392f, 0.11712965f, -0.12930866f, -0.00948669f, 
    0.02137750f, 0.03976593f, 0.02659438f, 0.08524723f, -0.06934700f, -0.05347795f, 0.14224017f, 0.23803149f, 
    0.07462571f, 0.58024526f, 0.19635776f, 0.15557964f, -0.08682293f, 0.10241470f, 0.02071990f, -0.15654422f, 
    -0.07995956f, -0.02744236f, -0.13759133f, 0.05763251f, 0.20317592f, 0.08654349f, 0.16925597f, 0.32370284f, 
    -0.05575510f, 0.07889221f, -0.07794842f, -0.02886385f, -0.01026207f, 0.02232654f, 0.00199382f, -0.11233351f, 
    0.05260664f, -0.00950204f, -0.02090195f, -0.01799658f, -0.05316696f, -0.06816119f, 0.09824922f, 0.08399493f, 
    -0.08935671f, -0.07180015f, -0.09716160f, -0.11927500f, 0.16792378f, -0.19619513f, -0.01317252f, 0.01965047f, 
    -0.16518822f, 0.00883119f, -0.06734508f, 0.04492452f, 0.04815828f, 0.00102255f, 0.06361622f, -0.06984704f, 
    0.21141972f, 0.26548713f, 0.23074813f, 0.10599400f, 0.12573555f, -0.05267312f, 0.01632198f, -0.03448558f, 
    -0.03781824f, 0.13852981f, 0.02155059f, -0.04964229f, 0.05626738f, 0.27552423f, 0.15355994f, 0.07993480f, 
    -0.09956754f, -0.06537540f, -0.20201533f, -0.06905488f, -0.04330768f, 0.05074146f, 0.10487017f, 0.04260995f, 
    -0.14537242f, 0.04260474f, 0.02373116f, 0.25384882f, 0.10491513f, 0.15015107f, 0.07852412f, 0.19081978f, 
    0.04679742f, 0.13652165f, 0.06752038f, 0.04895226f, -0.23152731f, 0.11673852f, 0.17502493f, 0.04189442f, 
    0.08507454f, -0.14311479f, -0.07384343f, -0.06877539f, 0.08789625f, -0.16997424f, -0.15524969f, -0.10021069f, 
    -0.35125840f, -0.03416822f, -0.10219212f, 0.26944751f, 0.09887034f, -0.01083104f, -0.22766784f, 0.04299841f, 
    0.02508130f, -0.07616980f, -0.04327102f, -0.06101090f, -0.14655176f, -0.00677183f, 0.05146867f, 0.19411060f, 
    -0.26225856f, 0.02633187f, 0.11960172f, 0.01772032f, 0.01574522f, -0.00498228f, 0.00756761f, 0.01722606f, 
    0.16914950f, 0.06765917f, -0.07953443f, 0.39580196f, -0.00839256f, 0.10730555f, 0.05309085f, -0.10035049f, 
    0.15115990f, 0.05962738f, -0.01338803f, 0.23017265f, 0.02535748f, 0.03178982f, -0.15297432f, -0.12214451f, 
    -0.00091391f, -0.13797012f, 0.10715668f, -0.15133530f, 0.26943082f, 0.15263858f, -0.04902304f, 0.14747463f, 
    -0.27969989f, -0.27628708f, -0.34993604f, -0.10974904f, -0.09916836f, -0.13805452f, 0.03018340f, 0.02009152f, 
    0.20552590f, 0.31800133f, 0.07102609f, 0.11170451f, 0.10412995f, -0.15382378f, -0.10773035f, 0.07437069f, 
    -0.22171304f, 0.03663838f, -0.07310636f, -0.04279561f, 0.11645635f, 0.05741530f, 0.00738478f, 0.00494461f, 
    -0.22212698f, -0.07337649f, -0.08761121f, 0.04665571f, 0.20196669f, 0.15536822f, -0.14595480f, 0.07623417f, 
    0.02141680f, 0.04909343f, -0.03402944f, 0.14082998f, -0.12851706f, -0.07481112f, -0.05763742f, 0.29980135f, 
    -0.43010804f, 0.08518640f, -0.02330540f, 0.12823917f, -0.15602905f, -0.03700054f, -0.16073668f, -0.02375950f, 
    -0.20815016f, 0.08590948f, 0.08766395f, 0.05647906f, -0.00655069f, 0.01040255f, 0.12138257f, 0.02709100f, 
    0.13679029f, 0.05131733f, 0.01524627f, -0.05216406f, -0.22102144f, 0.06123263f, 0.16376539f, 0.22626467f, 
    -0.02908001f, -0.03927813f, -0.29286397f, 0.21617188f, -0.17719519f, 0.12331907f, 0.01912677f, -0.05705212f, 
    0.18584386f, 0.05349592f, -0.02529762f, 0.27843657f, -0.13138598f, 0.03776729f, -0.14478466f, 0.01062117f, 
    0.14806832f, -0.01999659f, 0.02790631f, 0.18847451f, -0.08260385f, 0.16638318f, 0.03190451f, 0.25782049f, 
    -0.02860775f, 0.09856986f, -0.05595319f, -0.04077040f, -0.07622796f, 0.22922392f, -0.06224213f, 0.13231310f, 
    0.02071344f, 0.42240429f, 0.12260295f, -0.00682331f, 0.03259712f, 0.01880652f, -0.22467974f, 0.03274626f, 
    -0.02738411f, 0.05034233f, -0.05765644f, -0.03741313f, -0.02610750f, -0.03842511f, 0.10513047f, 0.14626773f, 
    -0.10753035f, 0.20696346f, 0.00370153f, 0.10517459f, -0.13910751f, -0.02003757f, 0.07464507f, -0.20976974f, 
    0.29218736f, 0.24553607f, 0.21866131f, -0.01235976f, 0.16180065f, 0.11101497f, -0.06853303f, 0.21787757f, 
    -0.27207679f, -0.00147637f, 0.23933262f, -0.07146754f, -0.32642698f, 0.02957052f, 0.04813534f, -0.17280655f, 
    0.01184025f, 0.09197131f, -0.17552350f, -0.01540016f, -0.08769371f, -0.17056991f, -0.00465578f, 0.06722604f, 
    0.03262702f, -0.00049127f, 0.26219940f, 0.06610001f, 0.20240822f, 0.01298989f, -0.08622944f, 0.10786975f, 
    -0.02069807f, 0.02723242f, 0.05543377f, 0.12953588f, -0.21968490f, -0.00627259f, 0.36849838f, 0.36091995f, 
    0.13198900f, 0.01661862f, 0.04125460f, 0.15055649f, 0.10850295f, -0.16758545f, -0.07541660f, -0.07026976f, 
    0.13497271f, -0.03213028f, -0.09551304f, 0.04610820f, -0.05999333f, 0.03535881f, -0.00109442f, -0.13915081f, 
    0.09068867f, 0.05469257f, 0.03029029f, 0.08461094f, -0.13331705f, 0.09128320f, 0.24108973f, -0.12903453f, 
    0.00070643f, 0.01676807f, 0.09814567f, -0.04457367f, -0.02120727f, -0.04546419f, -0.11591311f, -0.14149113f, 
    0.06902304f, -0.11703403f, 0.03900998f, 0.32674596f, -0.03449536f, -0.05821180f, -0.02490543f, -0.04949670f, 
    0.15989812f, 0.06510234f, 0.00369704f, 0.04891042f, 0.74500203f, 0.42783403f, 0.24822633f, 0.15675384f, 
    0.03207322f, -0.09798253f, 0.11375396f, 0.05389958f, -0.12779677f, -0.05103773f, 0.01807200f, 0.18055074f, 
    -0.23338129f, 0.07925161f, 0.03588289f, 0.12585823f, 0.13248730f, -0.05146427f, -0.10353569f, 0.01508026f, 
    -0.23703262f, -0.04390706f, 0.00787950f, -0.08106280f, -0.34802482f, -0.04352866f, -0.21502939f, -0.09917141f, 
    -0.09759777f, -0.15427262f, -0.11834120f, 0.05479052f, 0.22314334f, 0.26529244f, 0.04463455f, 0.15337370f, 
    -0.39604530f, 0.64342117f, 0.16088824f, 0.03816847f, -0.10526471f, -0.09695824f, 0.04388887f, 0.16563828f, 
    -0.00264857f, 0.02338102f, -0.06053586f, 0.07848919f, 0.19562577f, -0.36110353f, 0.07927714f, 0.28667060f, 
    0.04590872f, -0.06677945f, -0.09891339f, -0.01522132f, 0.05278961f, -0.06638975f, 0.03478465f, 0.07146597f, 
    0.05133908f, -0.04712182f, -0.18374650f, 0.02631086f, 0.03176852f, -0.15000139f, 0.02900705f, 0.02275633f, 
    0.02557465f, -0.01211614f, -0.06842751f, -0.07455949f, -0.13879463f, -0.09236795f, -0.08079775f, -0.05619326f, 
    -0.03568056f, 0.02514927f, -0.18632483f, 0.10097381f, -0.00273141f, -0.06251391f, 0.04622708f, -0.22916946f, 
    -0.17219023f, -0.06232491f, -0.10127746f, 0.18711813f, -0.08656584f, 0.11633856f, -0.08261647f, 0.08196042f, 
    0.02321589f, -0.03750456f, 0.02560213f, 0.00391984f, -0.32766858f, 0.15466614f, 0.01918702f, 0.25532672f, 
    0.06588538f, 0.03545788f, 0.17039913f, -0.12958385f, -0.16968782f, 0.11973227f, 0.11414904f, 0.06538612f, 
    -0.11919995f, -0.18184271f, 0.05944154f, 0.19568630f, -0.06651904f, -0.06996088f, 0.17234179f, 0.00212734f, 
    -0.06438717f, -0.01439583f, -0.00264681f, -0.09089594f, -0.32104814f, 0.26098499f, 0.13179827f, 0.01169748f, 
    0.07447618f, 0.24776754f, -0.08731500f, -0.08955278f, 0.11604876f, 0.05095546f, 0.03335847f, -0.00474237f, 
    -0.15222065f, 0.02062821f, 0.14325956f, 0.06271578f, -0.16646977f, 0.00345455f, -0.16022778f, 0.12871577f, 
    0.04215918f, 0.07304486f, -0.05079430f, 0.14800075f, 0.03689693f, -0.06933101f, 0.32637304f, 0.18732099f, 
    0.04073645f, 0.15366940f, 0.04174255f, 0.01552058f, -0.03177814f, -0.02954565f, 0.05296692f, -0.03609834f, 
    0.08009317f, -0.17982720f, 0.08389120f, 0.33295086f, 0.03432584f, 0.02262342f, -0.00521737f, -0.17408970f, 
    0.09422387f, -0.07841438f, -0.09529413f, -0.10296318f, -0.50578022f, 0.18364963f, 0.04080847f, -0.11004908f, 
    -0.08651139f, 0.05524690f, 0.11921529f, -0.09199086f, 0.16914316f, 0.21213329f, 0.08548535f, -0.12241612f, 
    -0.37941498f, -0.26877567f, -0.23947477f, -0.28719792f, 0.10500205f, -0.00094392f, 0.01016080f, -0.07726200f, 
    -0.02839308f, 0.05513128f, -0.01692572f, -0.05041785f, 0.04279550f, 0.07184900f, -0.05336829f, 0.07259662f, 
    -0.01965610f, 0.09599575f, -0.15832900f, 0.02282549f, -0.01852643f, -0.07408483f, -0.05431433f, -0.15162224f, 
    -0.33822295f, -0.21407974f, 0.45214409f, -0.17269492f, -0.14899229f, 0.00400186f, -0.09095462f, -0.20134760f, 
    0.08012690f, 0.06675948f, 0.12685345f, 0.15590394f, 0.36749843f, 0.04430315f, 0.02333428f, 0.07538389f, 
    0.11094389f, -0.16472365f, -0.02090799f, 0.15061358f, -0.08981988f, -0.03761681f, 0.24641490f, 0.13892518f, 
    0.21589351f, -0.00066796f, 0.19030578f, 0.23139055f, 0.12818047f, -0.10692206f, 0.11117537f, 0.13935342f, 
    -0.18781136f, -0.04672159f, -0.04689907f, -0.15884958f, 0.22291419f, -0.08452536f, 0.23882440f, 0.30009323f, 
    0.25194964f, -0.22645897f, -0.02901052f, 0.10039996f, 0.05481712f, 0.07801048f, -0.15279850f, 0.10649711f, 
    -0.01720124f, -0.22298543f, -0.03071933f, 0.05117762f, 0.09886947f, 0.00353516f, -0.24416272f, 0.01300683f, 
    0.13519065f, 0.08097987f, -0.03769908f, 0.12155134f, 0.18586335f, -0.17972545f, 0.16752914f, 0.30211729f, 
    0.07230733f, 0.10138478f, 0.07124587f, -0.04300515f, 0.18819723f, 0.16901313f, -0.03170639f, 0.01489685f, 
    0.24311166f, 0.03324201f, 0.07105178f, 0.26330221f, -0.09886006f, 0.07986161f, -0.06023753f, -0.00234356f, 
    0.08143451f, -0.03014063f, 0.04394503f, -0.10241926f, 0.20674075f, 0.03550540f, 0.14659745f, 0.36769262f, 
    -0.05356216f, 0.00846999f, -0.13823408f, 0.30373064f, -0.01686815f, -0.06797314f, 0.12753758f, -0.07702666f, 
    -0.17704846f, 0.01263358f, -0.13375543f, -0.08432805f, 0.04918747f, -0.13992369f, -0.10852098f, -0.01203592f, 
    -0.29922614f, -0.08213098f, 0.16728836f, 0.20109276f, -0.12470559f, 0.12796520f, -0.04037506f, -0.27931198f, 
    -0.03812065f, -0.01122187f, -0.22165212f, -0.09850405f, 0.11584692f, -0.10700240f, 0.06097537f, 0.09788436f, 
    -0.06153991f, 0.12972997f, 0.07134132f, -0.19639213f, -0.04882667f, -0.08072297f, -0.12215663f, -0.02419899f, 
    0.13244031f, -0.10796666f, 0.06527077f, -0.01721541f, 0.12929071f, 0.30703041f, 0.04760269f, 0.36830816f, 
    0.40621427f, 0.26280400f, -0.06437062f, 0.04639115f, -0.03738046f, -0.15887225f, -0.19168375f, -0.06068585f, 
    -0.27412271f, 0.17799231f, -0.18668385f, 0.06169445f, 0.13835739f, 0.05986289f, 0.02674876f, 0.14099632f, 
    0.02754983f, -0.01111425f, 0.07608330f, -0.07548436f, 0.37283546f, -0.09997137f, 0.21290570f, -0.00014776f, 
    0.02523505f, -0.06717325f, 0.12738639f, 0.03410558f, 0.17607582f, -0.01363252f, 0.00703202f, -0.07098621f, 
    -0.11587264f, -0.22548459f, -0.11923575f, -0.08624592f, -0.04368886f, -0.17332287f, 0.22812897f, 0.04250551f, 
    0.09873720f, 0.03710542f, -0.03024218f, 0.09193495f, -0.37519950f, 0.06503628f, -0.16506329f, 0.33976653f, 
    0.01509514f, -0.05372711f, 0.09000609f, -0.05274373f, 0.06849067f, 0.14464024f, 0.10662629f, 0.08615766f, 
    0.19775467f, -0.00022116f, 0.17131297f, -0.07503326f, 0.24898382f, -0.12875925f, -0.10324490f, 0.11641733f, 
    -0.07047057f, 0.11062407f, 0.16759074f, 0.15574485f, -0.11545447f, -0.16159371f, -0.16723904f, -0.23059785f, 
    0.06886958f, -0.04032313f, 0.11835135f, 0.19959679f, -0.01362944f, 0.09407859f, -0.03419153f, 0.03920453f, 
    -0.28953454f, -0.29836777f, 0.34949324f, 0.13648336f, 0.03472298f, -0.16522425f, 0.03668464f, 0.15146478f, 
    0.06258176f, 0.04305698f, 0.08329717f, -0.09863208f, -0.20691998f, -0.36573383f, -0.13567981f, -0.00772921f, 
    0.00263947f, -0.16868737f, 0.11251833f, 0.09270659f, -0.07256719f, -0.09456663f, 0.11650848f, 0.19249485f, 
    -0.15882409f, -0.06631628f, -0.05488624f, -0.07506326f, 0.06362405f, 0.04543804f, -0.24710321f, -0.11606517f, 
    -0.07390565f, 0.09536961f, 0.11416797f, 0.00721660f, -0.37173462f, -0.00210196f, 0.04318174f, -0.03076201f, 
    0.29687473f, 0.15345356f, -0.09557488f, -0.05795094f, -0.10625125f, -0.02543171f, 0.00661866f, -0.00006946f, 
    0.18753643f, -0.04579319f, -0.07686227f, -0.01676288f, 0.10889588f, 0.00906784f, -0.18111062f, -0.16395426f, 
    0.02047440f, -0.30588767f, -0.02712482f, -0.19842914f, 0.24464463f, 0.12177691f, -0.13176285f, -0.52937305f, 
    0.00744441f, -0.01776711f, 0.02456834f, -0.00508470f, -0.11935969f, 0.10515546f, -0.15022402f, 0.04687333f, 
    0.31305841f, 0.21460702f, 0.33232006f, 0.11836704f, 0.24447119f, 0.10273289f, 0.22561297f, 0.38745385f, 
    0.02163913f, 0.13256915f, 0.06015752f, 0.08582553f, 0.10303891f, 0.13647197f, 0.09964912f, -0.07732414f, 
    0.14509781f, -0.23998173f, 0.08764853f, 0.00637394f, 0.13131815f, 0.09466647f, 0.12907058f, -0.00711677f, 
    0.19337074f, 0.13709983f, 0.51197076f, -0.47011212f, 0.04665554f, 0.02571073f, 0.09653701f, 0.12352849f, 
    0.02059720f, -0.09074857f, 0.08436810f, 0.02528488f, 0.09318707f, -0.09846164f, 0.02848056f, -0.02286892f, 
    0.00285290f, -0.08796373f, -0.18092193f, -0.12889324f, -0.06235498f, 0.01038301f, -0.09876417f, -0.06159745f, 
    0.08119635f, 0.13783489f, 0.12026209f, 0.00782555f, 0.05920897f, -0.04754637f, -0.14088327f, 0.02155537f, 
    -0.01828636f, 0.02255124f, 0.15695895f, -0.02516756f, -0.03070510f, -0.32618272f, -0.07604799f, -0.01097184f, 
    -0.00117500f, 0.03470661f, 0.01806903f, -0.11161949f, 0.08154489f, 0.18741331f, 0.00580014f, 0.22723274f, 
    -0.29828575f, -0.24086164f, 0.04169211f, 0.08110765f, 0.09773357f, -0.03939714f, 0.03495222f, -0.14851026f, 
    0.09815156f, 0.08257388f, 0.09383187f, 0.36660159f, -0.44635954f, 0.09507097f, -0.17253135f, -0.23685730f, 
    0.03382692f, 0.05216450f, -0.06204692f, 0.04214080f, 0.19918273f, -0.08188384f, 0.00972902f, 0.04695893f, 
    0.22229029f, 0.15338655f, 0.38589790f, 0.07387785f, -0.05691726f, 0.09915312f, -0.00386386f, 0.09444573f, 
    0.06460268f, -0.02523245f, 0.07716939f, 0.01774239f, -0.23149993f, 0.19520265f, -0.22086495f, 0.08246047f, 
    0.08837587f, 0.02118419f, -0.06610893f, 0.00804488f, 0.06511043f, 0.05173600f, -0.08428205f, -0.01124234f, 
    0.40656647f, 0.30535579f, 0.34799916f, 0.12408585f, -0.08337959f, -0.03568146f, 0.07739075f, 0.14735897f, 
    -0.03239221f, 0.09738943f, 0.00851957f, -0.01069072f, 0.16872001f, -0.10229709f, -0.25768417f, -0.20117690f, 
    0.04363591f, -0.08041731f, 0.10252792f, -0.12177920f, -0.11380707f, 0.04255340f, -0.12066393f, -0.05010429f, 
    0.27602550f, 0.26700628f, 0.20944558f, 0.35189342f, -0.03929951f, 0.02996351f, 0.17584684f, -0.07019249f, 
    -0.00749153f, -0.06549505f, 0.05202978f, -0.18135919f, 0.13249539f, -0.00811492f, 0.28650713f, 0.34602022f, 
    -0.02906022f, 0.11460394f, -0.04290628f, 0.05883506f, 0.07344371f, -0.09550268f, 0.06614842f, 0.19089267f, 
    -0.12911041f, -0.05426979f, -0.73993623f, -0.16912164f, 0.04815465f, -0.09776916f, -0.14739862f, -0.02805160f, 
    -0.17171924f, -0.07940596f, -0.14158782f, 0.07116893f, -0.06711677f, 0.22550936f, 0.19311957f, 0.20747229f, 
    -0.01753885f, -0.06113489f, 0.08870044f, 0.07993019f, -0.13385525f, -0.15335649f, 0.06922575f, -0.05637163f, 
    0.41187140f, 0.00025163f, -0.09774873f, -0.10107193f, 0.14916065f, -0.05062294f, 0.08778861f, 0.11401168f, 
    0.12511422f, 0.12681900f, -0.11354122f, -0.13618405f, -0.34816337f, -0.09335341f, -0.01843888f, -0.13727255f, 
    0.01740043f, -0.13266693f, 0.12354235f, 0.01692732f, 0.03002100f, 0.07867182f, 0.10444777f, 0.04293986f, 
    0.35251510f, -0.06353430f, 0.01997425f, 0.11989347f, 0.16242860f, -0.08670644f, 0.09405915f, -0.05601592f, 
    -0.04351475f, 0.09162240f, 0.22670300f, 0.04959390f, -0.02479536f, 0.28783470f, -0.24834485f, 0.08953944f, 
    0.10511656f, -0.28106174f, -0.12431387f, 0.10336941f, -0.02935233f, -0.06822799f, -0.09533377f, 0.09573029f, 
    -0.30124688f, 0.20186698f, -0.06638591f, 0.02557364f, 0.11152788f, 0.10026309f, -0.08916050f, -0.05583519f, 
    0.18820056f, -0.08950526f, -0.04801523f, 0.04071188f, 0.20995112f, 0.15464064f, 0.08557943f, 0.11763143f, 
    0.11487415f, -0.03876479f, 0.04631669f, 0.08050983f, -0.13476272f, 0.06209497f, -0.20860635f, -0.05336839f, 
    0.16938867f, -0.07285624f, 0.36692506f, 0.29623434f, 0.07099336f, 0.17420392f, -0.03866217f, 0.02733762f, 
    0.06972743f, -0.11084204f, 0.08180554f, 0.11014756f, 0.14471860f, 0.18120210f, -0.08826235f, 0.17792208f, 
    -0.07444567f, 0.01450311f, -0.01706827f, -0.04327215f, 0.06900099f, -0.08569447f, -0.01995260f, 0.12588668f, 
    -0.08426124f, -0.30153939f, 0.34003812f, 0.08738744f, 0.16570982f, 0.04406059f, 0.01771290f, -0.00452055f, 
    -0.14334394f, -0.13987029f, -0.04742015f, -0.26203108f, -0.00489457f, -0.47118071f, 0.03750851f, -0.09039962f, 
    0.06665790f, -0.04805905f, -0.09219294f, -0.20828256f, 0.02557537f, 0.02082723f, -0.01331607f, 0.07857366f, 
    0.37519908f, -0.40747875f, 0.40348148f, 0.12619488f, 0.00741073f, -0.05781193f, 0.03470799f, -0.27530450f, 
    -0.02038457f, 0.20351397f, -0.08315068f, 0.09513876f, -0.01023361f, 0.52712238f, 0.22535118f, 0.06861018f, 
    -0.06343088f, 0.09789953f, -0.02177980f, 0.09478919f, 0.00577376f, 0.01844288f, 0.06926212f, 0.13075498f, 
    -0.24505298f, -0.16865170f, -0.09409241f, 0.04478447f, 0.11272942f, -0.04070367f, 0.04477610f, -0.00740477f, 
    -0.18504985f, -0.10894560f, -0.01787928f, -0.18288410f, -0.25229371f, 0.18456638f, -0.26579437f, 0.06361489f, 
    -0.01604422f, -0.10869134f, 0.02892464f, 0.08719467f, 0.04313994f, -0.12960279f, -0.11148202f, -0.09276632f, 
    0.02540030f, 0.00900414f, 0.00176325f, -0.03242204f, 0.03163053f, -0.00158449f, -0.02689673f, 0.00274810f, 
    -0.04672553f, -0.01860740f, 0.01131308f, -0.02474419f, -0.00937608f, 0.02527444f, 0.04924363f, -0.02602402f, 
    0.01101308f, -0.03129140f, 0.00621019f, -0.01059787f, -0.03484509f, 0.02436493f, 0.01499795f, 0.00219434f, 
    0.00150111f, -0.02817880f, -0.05402235f, 0.00975675f, 0.00246071f, -0.03024656f, -0.01488501f, 0.03234078f, 
    0.00484937f, -0.05001843f, -0.02264766f, -0.01787298f, 0.04397641f, 0.02565460f, -0.01694806f, 0.00544175f, 
    0.00256332f, 0.01612958f, 0.00784471f, -0.04870859f, -0.04798741f, -0.00966558f, 0.02745133f, 0.00815235f, 
    0.02659262f, -0.02965398f, 0.02439727f, 0.00733315f, -0.00130221f, 0.02841812f, 0.04442690f, -0.01940333f, 
    -0.05590672f, -0.00325902f, -0.03857837f, -0.05146845f, 0.02354420f, -0.04653094f, 0.02312564f, -0.02928902f, 
    -0.02143638f, -0.03587967f, -0.02639574f, 0.04372853f, -0.00777102f, 0.01788737f, 0.03214711f, 0.02841983f, 
    -0.03225974f, -0.01540788f, 0.03405415f, -0.02586707f, 0.02863802f, 0.03050994f, -0.00763152f, 0.02081348f, 
    -0.01125005f, -0.01046072f, -0.03180574f, 0.02695676f, 0.03617569f, 0.03500535f, -0.00746836f, -0.02554754f, 
    0.03068189f, 0.04508519f, 0.00498127f, -0.01592815f, 0.00470026f, -0.00601335f, -0.01312257f, -0.04862555f, 
    0.02792297f, -0.01855147f, -0.04598645f, 0.00404348f, -0.00214075f, -0.04407782f, 0.03597916f, -0.04952515f, 
    -0.03431212f, 0.02116947f, -0.05357774f, -0.00612177f, -0.04077915f, 0.02989509f, -0.03184630f, 0.00172347f, 
    -0.05009458f, 0.03612870f, -0.02417222f, -0.02023975f, -0.05063827f, 0.03824724f, 0.04041205f, 0.02542439f, 
    0.00495846f, 0.01145843f, 0.04465472f, -0.05270411f, -0.03385432f, 0.03561227f, 0.00007952f, 0.03890858f, 
    -0.03063101f, 0.03741941f, -0.00868239f, 0.02168064f, -0.01850534f, 0.05460058f, 0.02734752f, 0.00834415f, 
    0.00083395f, 0.01994521f, 0.01933024f, -0.04394834f, -0.02528034f, -0.04878806f, -0.01847920f, 0.00248423f, 
    -0.02769483f, 0.02052061f, -0.00619135f, -0.03350580f, -0.03849730f, -0.03079898f, -0.04506525f, -0.02960648f, 
    0.03569757f, 0.01328670f, 0.00718707f, -0.01400666f, -0.04542989f, -0.03746741f, -0.02780657f, -0.00331610f, 
    -0.05078367f, -0.02575254f, -0.03338218f, 0.03032428f, 0.04644959f, -0.04931649f, 0.02753612f, -0.01530205f, 
    0.04376346f, 0.04649931f, -0.01634509f, -0.04633838f, -0.03997227f, -0.02148902f, 0.00090605f, -0.01190650f, 
    -0.02058452f, -0.04703743f, -0.03262763f, 0.01884425f, 0.02187495f, 0.04284700f, 0.00758265f, 0.03825144f, 
    0.02506780f, -0.03640823f, 0.00755674f, 0.00040015f, 0.02743887f, 0.00485779f, -0.03491228f, 0.00088164f, 
    0.03484089f, 0.02367943f, 0.00437702f, 0.02924356f, -0.00797717f, -0.03577869f, 0.00213633f, 0.03448059f, 
    -0.03093372f, -0.00074008f, -0.04908434f, 0.00052786f, -0.01809684f, 0.01221571f, -0.03347731f, -0.01946127f, 
    -0.02942775f, -0.05179074f, -0.00923887f, -0.01383132f, 0.02604711f, -0.01805538f, -0.01778945f, -0.04915359f, 
    -0.00714927f, 0.04258260f, -0.03281168f, -0.01531101f, -0.02708253f, -0.01158182f, 0.03738218f, 0.01234014f, 
    -0.02553780f, -0.03631048f, -0.05526957f, -0.00540027f, 0.02003484f, -0.04015254f, -0.01346256f, -0.02511082f, 
    -0.04216762f, -0.00092556f, 0.01488413f, 0.02658437f, 0.04610446f, 0.00452066f, -0.03839644f, 0.00373304f, 
    -0.01292550f, -0.01809650f, 0.01467217f, 0.03108323f, 0.02354540f, 0.00549732f, -0.03472077f, -0.00220692f, 
    -0.01870564f, -0.02770461f, -0.02875777f, -0.05399366f, -0.03223582f, -0.03902538f, 0.03500024f, -0.02591471f, 
    -0.03402901f, -0.03111689f, 0.01638063f, 0.01370250f, -0.00628847f, 0.03464634f, -0.05483862f, 0.00303308f, 
    0.00674190f, 0.03852903f, 0.03798713f, 0.04182475f, -0.00502553f, -0.03146563f, 0.00570637f, 0.01255591f, 
    0.02181010f, -0.03018440f, -0.02802598f, -0.03458593f, 0.03046032f, 0.02578441f, -0.05221634f, 0.00998590f, 
    -0.05112832f, 0.03255104f, -0.02297009f, -0.00454584f, 0.02756849f, 0.01625408f, -0.01002479f, -0.04553354f, 
    -0.00524371f, 0.04772751f, 0.02882192f, 0.01311873f, 0.02677464f, -0.04725330f, 0.04548163f, 0.01429288f, 
    -0.01155290f, 0.01852835f, -0.03597078f, -0.01373585f, -0.05013030f, -0.02115080f, -0.00776375f, -0.02399749f, 
    -0.00631387f, 0.03906499f, -0.05389142f, -0.01569742f, -0.01762361f, -0.01931285f, -0.00811245f, -0.00085219f, 
    -0.01986058f, 0.00724698f, -0.05559232f, -0.04385571f, 0.01468158f, 0.00550059f, -0.00984292f, 0.02076258f, 
    -0.01318884f, -0.02617375f, 0.01844052f, -0.05210275f, 0.00272475f, -0.02186490f, -0.03881266f, -0.03771048f, 
    -0.00397488f, 0.01760644f, 0.01795740f, 0.00304785f, -0.01852155f, -0.01746848f, -0.03165767f, -0.00558995f, 
    -0.02622174f, 0.01437658f, -0.00471525f, -0.01065684f, 0.01461411f, -0.05118120f, -0.04630563f, -0.02982503f, 
    -0.04218964f, -0.02599678f, -0.00853578f, -0.02329866f, -0.02345428f, -0.00750217f, 0.00118466f, -0.00315468f, 
    -0.02507260f, 0.04043525f, -0.04905925f, 0.00025234f, 0.00313719f, 0.00564824f, 0.04388410f, 0.00432245f, 
    0.04204560f, -0.04534878f, -0.00939809f, 0.00570798f, -0.02851084f, -0.04571329f, 0.03052007f, -0.00841462f, 
    0.00518945f, 0.01386169f, 0.03524353f, 0.01735607f, 0.01411198f, -0.03921811f, -0.02267521f, 0.03940178f, 
    0.00458070f, 0.01672844f, -0.02975748f, -0.02769194f, 0.01980220f, -0.01116383f, -0.02047371f, 0.01103754f, 
    -0.18662387f, 0.12138844f, 0.43071771f, -0.11500746f, -0.16916575f, 0.05922898f, 0.05239065f, 0.26597357f, 
    0.14627448f, 0.16219196f, 0.13105579f, 0.21887448f, 0.01758270f, 0.18750066f, 0.37123564f, 0.14186883f, 
    -0.01974247f, 0.08973806f, 0.09954675f, -0.02830472f, 0.21957533f, -0.07118475f, 0.12048446f, -0.08677181f, 
    -0.10387959f, 0.05157899f, -0.01127904f, -0.05225084f, 0.18111938f, 0.08819518f, -0.12932830f, -0.32639030f, 
    -0.09999746f, -0.09397169f, 0.03506622f, 0.03416267f, 0.18818893f, 0.18873730f, -0.01623317f, -0.08848327f, 
    0.09619480f, 0.16111863f, -0.09956253f, 0.00590964f, -0.12502007f, -0.00755969f, -0.05209886f, -0.07827868f, 
    -0.03608558f, 0.22319123f, 0.15167955f, 0.02709122f, 0.14371549f, -0.02400168f, 0.01616250f, 0.09205982f, 
    0.03517300f, 0.07570651f, 0.04810914f, 0.00237558f, -0.24955718f, -0.04845520f, 0.07440308f, -0.03600440f, 
    0.07157325f, -0.13695465f, 0.11123461f, 0.06373525f, -0.09721588f, -0.06937478f, 0.05831886f, 0.02916308f, 
    -0.29761851f, -0.15114284f, -0.16623630f, -0.15192132f, -0.08016380f, 0.01947124f, 0.03062000f, -0.01479508f, 
    -0.08627143f, -0.24768002f, -0.15451974f, -0.34093952f, 0.04017071f, -0.01767799f, -0.12553516f, -0.05514139f, 
    -0.00245080f, -0.04570855f, -0.08457219f, 0.08127667f, 0.20554583f, -0.20604376f, 0.00018769f, -0.19206323f, 
    -0.14990306f, -0.12628828f, -0.18806584f, -0.24229449f, -0.07327904f, 0.03041493f, -0.04976013f, -0.20150812f, 
    -0.15822472f, -0.22384633f, -0.03416063f, -0.24482287f, -0.11757009f, 0.01507717f, -0.11454415f, -0.03386562f, 
    0.09313264f, -0.11817066f, 0.10316575f, -0.08775485f, 0.10764962f, -0.05988329f, -0.04218053f, -0.03109995f, 
    -0.10653668f, 0.16985554f, 0.19871108f, -0.14005104f, 0.01855473f, -0.06977133f, 0.00478348f, 0.02355325f, 
    0.03318582f, 0.04798119f, 0.08812976f, 0.08033299f, 0.16211541f, -0.29902631f, 0.31184494f, 0.33223790f, 
    -0.12880348f, 0.14023785f, -0.16054398f, 0.09472724f, -0.19958240f, -0.01002324f, 0.21386914f, -0.10629115f, 
    -0.14291662f, -0.01752740f, -0.16195904f, -0.03497455f, 0.18005282f, 0.19784473f, 0.05151368f, -0.00761438f, 
    -0.16549358f, -0.14389718f, -0.13031273f, 0.15097515f, -0.23171613f, -0.37194788f, -0.00143336f, 0.03430348f, 
    0.27467647f, 0.31299129f, -0.16480514f, 0.15583946f, 0.03008883f, 0.10329729f, 0.10185359f, 0.03255393f, 
    -0.17667435f, 0.09797043f, 0.05655937f, 0.06942337f, 0.25157884f, 0.12627243f, -0.05028213f, 0.10480756f, 
    -0.16091336f, 0.01473303f, -0.08535019f, 0.09923398f, -0.00579208f, 0.11212116f, 0.13192600f, -0.13066149f, 
    0.11097974f, 0.13339461f, 0.11747769f, -0.08253141f, -0.04592166f, 0.02017478f, -0.29833990f, -0.29202795f, 
    -0.07961182f, -0.01411429f, 0.36179534f, 0.33933598f, -0.04679791f, 0.24850456f, -0.07229756f, -0.00404586f, 
    0.25331700f, 0.11196232f, 0.19336013f, -0.20440397f, 0.01687728f, 0.19889234f, -0.15108031f, 0.08076259f, 
    0.08548341f, 0.23601413f, 0.05040521f, 0.04636659f, 0.12860663f, -0.01245009f, 0.05105136f, 0.16321006f, 
    -0.53534919f, 0.10360031f, 0.12880015f, -0.21038797f, 0.00416848f, -0.13694312f, -0.01761582f, -0.08373796f, 
    0.02765449f, -0.02072194f, 0.02546830f, 0.16449536f, 0.14172620f, -0.13197869f, -0.18618096f, 0.00093213f, 
    -0.03783866f, -0.14692278f, 0.09101611f, -0.09460242f, -0.00571144f, 0.03915508f, -0.08935072f, 0.06779939f, 
    -0.28968161f, -0.00083131f, -0.01077197f, -0.35429493f, -0.04693753f, 0.04366227f, 0.02760428f, 0.17902632f, 
    -0.04687670f, 0.08263232f, 0.06041712f, 0.08784222f, -0.64361489f, -0.52944756f, -0.21027435f, -0.02004361f, 
    0.16045576f, 0.13859542f, -0.01836230f, -0.10184792f, -0.08089189f, -0.15953694f, -0.17096327f, -0.16021611f, 
    -0.04092945f, -0.21362521f, -0.24178728f, 0.03390950f, 0.18798575f, -0.10286351f, 0.26433000f, 0.22803332f, 
    0.08354960f, 0.11318520f, 0.12235567f, 0.02755944f, 0.05848717f, 0.08880307f, 0.15651911f, 0.01244168f, 
    0.03498661f, 0.21991575f, 0.24297206f, 0.07321803f, 0.08269579f, 0.06379511f, 0.12662520f, 0.23159327f, 
    -0.12192944f, 0.34265658f, 0.12821391f, 0.00147042f, 0.05423942f, -0.07874385f, 0.03624556f, 0.23310265f, 
    0.02102459f, -0.03539658f, -0.13836142f, -0.10078999f, -0.50173390f, 0.02121310f, 0.17720437f, 0.03439248f, 
    -0.02962107f, -0.05065140f, -0.02647147f, -0.03887016f, 0.11492924f, 0.19621523f, 0.14393681f, -0.01306557f, 
    0.00970913f, -0.07227732f, 0.11578463f, -0.10557558f, -0.33474523f, 0.10700148f, -0.01749369f, 0.14621398f, 
    0.30844063f, -0.09551726f, 0.14767267f, 0.27761164f, -0.06047650f, -0.06617302f, 0.10627954f, -0.03352192f, 
    0.06726287f, -0.03348207f, 0.02758559f, -0.01749691f, -0.06356643f, -0.05270121f, -0.08943607f, -0.11781114f, 
    0.01485699f, 0.39406475f, -0.11769358f, -0.10885957f, -0.09265894f, -0.11636476f, 0.01278866f, 0.15147299f, 
    0.26647326f, -0.02461473f, 0.07024682f, 0.14627872f, -0.27092683f, 0.03678099f, 0.10598800f, 0.11603857f, 
    0.03800067f, -0.01076636f, 0.24326798f, 0.21664332f, -0.04308359f, 0.00615990f, -0.14751296f, -0.06002316f, 
    0.03448363f, 0.10346335f, 0.06258310f, 0.01998156f, -0.09803207f, -0.04020308f, -0.03050887f, -0.14830236f, 
    0.32797664f, 0.13530198f, -0.06097054f, 0.15513632f, -0.33584633f, -0.09275778f, -0.32331076f, 0.07939879f, 
    0.05874421f, 0.12507455f, 0.17555033f, 0.01982312f, 0.00736516f, 0.20106328f, 0.03510758f, 0.07507823f, 
    0.04062205f, 0.01302580f, 0.19059259f, -0.13294570f, -0.04813408f, -0.06087139f, -0.13872468f, -0.15518045f, 
    -0.08197667f, 0.00400900f, 0.03128684f, -0.11124495f, 0.01656935f, -0.16728887f, 0.11153524f, -0.20055068f, 
    0.05402500f, -0.17905356f, 0.10445816f, 0.14187539f, 0.01539987f, 0.19411843f, 0.04856417f, -0.03045512f, 
    -0.08477972f, -0.26535881f, 0.04936343f, 0.14570162f, -0.00240395f, -0.10021711f, 0.08195695f, 0.15302382f, 
    -0.00470878f, -0.05530772f, 0.11501412f, 0.03675988f, 0.12576218f, 0.17691521f, 0.28171030f, -0.13988256f, 
    0.12179496f, 0.06310987f, -0.06420849f, -0.04946223f, 0.14055164f, -0.14456864f, 0.11147854f, 0.04749249f, 
    -0.15964365f, -0.11477736f, -0.12480216f, -0.08491785f, 0.13482825f, -0.06917378f, 0.02380708f, 0.05399890f, 
    -0.08470348f, 0.02942104f, 0.09372877f, 0.09116696f, 0.18122150f, -0.38725293f, -0.17451911f, 0.05895993f, 
    0.00885988f, 0.02285826f, 0.34260535f, 0.13715047f, -0.06065003f, -0.07168102f, 0.14193545f, 0.00362511f, 
    0.08536246f, -0.20564745f, -0.04737500f, 0.03221510f, -0.13372052f, 0.27683872f, 0.13285084f, 0.15737219f, 
    0.19123732f, 0.02886221f, 0.06082162f, 0.05088295f, 0.25038302f, -0.15527329f, 0.16907753f, 0.06681268f, 
    -0.06466384f, -0.05070711f, 0.09381661f, 0.04679311f, 0.08494459f, 0.18872528f, 0.08171915f, 0.10025554f, 
    -0.00679193f, -0.07987336f, 0.02827571f, -0.04392039f, -0.05639329f, -0.04395223f, 0.06883048f, 0.04480697f, 
    0.17362015f, 0.11212801f, 0.08200645f, 0.07573353f, 0.06457835f, -0.10578752f, -0.21232796f, 0.05053021f, 
    -0.30259898f, -0.07258466f, 0.37200701f, -0.07144590f, -0.00362309f, 0.04036224f, 0.11035130f, -0.03430399f, 
    0.01584017f, -0.19973247f, -0.15711240f, 0.11538141f, -0.03005712f, 0.20269586f, 0.02581734f, 0.29066449f, 
    0.00785112f, 0.05825616f, 0.11514287f, 0.00324205f, -0.24507853f, 0.34647694f, -0.26405603f, 0.06431568f, 
    -0.15008643f, -0.02171523f, 0.11702127f, -0.02728947f, -0.01940591f, -0.01905688f, -0.15411869f, 0.06105475f, 
    -0.01143498f, -0.01969918f, -0.19382513f, -0.14121252f, 0.03998326f, -0.13307762f, -0.00999292f, 0.03542443f, 
    -0.03931189f, -0.03703006f, 0.01948885f, -0.01123859f, -0.42482066f, -0.05308414f, -0.20318273f, -0.09547324f, 
    0.18293309f, 0.03430917f, 0.13290974f, 0.02982016f, -0.05242911f, -0.15527806f, -0.10524713f, -0.02264280f, 
    -0.19112267f, -0.12865664f, -0.24251236f, -0.19868796f, -0.14660105f, -0.27669179f, -0.08652546f, 0.13236819f, 
    -0.11956115f, 0.03408262f, -0.02652559f, -0.03695564f, 0.21367775f, -0.03388891f, -0.22398943f, 0.07307972f, 
    -0.04020828f, 0.18091711f, 0.10983343f, 0.13857964f, -0.05223135f, 0.02219856f, 0.02142961f, -0.05114684f, 
    -0.22881125f, 0.20097581f, 0.16464522f, 0.00752046f, 0.10260088f, -0.01391666f, -0.01583195f, -0.12370326f, 
    0.17736162f, 0.00176720f, 0.05666448f, 0.09721722f, -0.48080036f, -0.03473029f, -0.43368217f, -0.12344661f, 
    -0.00455900f, -0.02617077f, 0.27091831f, 0.00805326f, -0.06321155f, 0.16522332f, -0.08295710f, 0.10457532f, 
    0.20853741f, -0.13064423f, -0.09753732f, -0.08276977f, 0.21452133f, -0.07447292f, 0.31903854f, 0.22417636f, 
    -0.11096308f, -0.06369898f, -0.16667704f, -0.11524288f, 0.00468803f, -0.07472395f, 0.19082285f, 0.03622433f, 
    0.08679613f, 0.15299715f, -0.22540389f, 0.05922779f, 0.03004774f, 0.04162646f, -0.04339166f, -0.15226454f, 
    -0.13411969f, -0.02811938f, 0.05612937f, 0.02239410f, 0.10325833f, 0.03951069f, 0.09419966f, 0.14242087f, 
    0.25062490f, 0.19882989f, -0.09181082f, -0.09160672f, 0.10815711f, -0.53142011f, 0.28967795f, 0.08668096f, 
    -0.04580524f, 0.16720374f, 0.04566860f, -0.11745977f, -0.01018421f, -0.05204973f, 0.07038239f, -0.01344531f, 
    0.19738299f, -0.04150212f, -0.14810550f, -0.12955499f, -0.04674941f, 0.16651103f, 0.20908941f, 0.10408408f, 
    0.12869208f, 0.13506231f, 0.08609606f, 0.01228619f, -0.40429005f, -0.32853913f, -0.17666841f, -0.27880844f, 
    0.07522096f, -0.29225630f, -0.00872437f, 0.05326179f, -0.06158418f, -0.16554904f, -0.05192329f, -0.00617280f, 
    0.22082111f, -0.16124380f, -0.28703246f, -0.05777859f, -0.06360123f, 0.04425665f, 0.04800993f, -0.01228313f, 
    -0.04061821f, 0.02982522f, 0.11250761f, 0.22989535f, 0.25465351f, -0.18102114f, 0.06713490f, -0.04557761f, 
    -0.14323112f, 0.00289376f, -0.19040672f, -0.04273436f, 0.11226480f, 0.09161057f, 0.17065199f, 0.15073809f, 
    0.33543491f, -0.33759028f, 0.29974490f, 0.16506702f, -0.11725795f, 0.05343781f, -0.01161694f, -0.07367816f, 
    0.04646282f, 0.09310435f, -0.21471241f, 0.10720249f, 0.02930692f, 0.04091761f, 0.13721652f, -0.09215733f, 
    -0.00887519f, 0.02503877f, -0.00449195f, 0.02632545f, 0.20710774f, 0.12666893f, 0.21461698f, 0.16163483f, 
    0.30259693f, 0.36963210f, 0.10678761f, -0.24338685f, 0.01795331f, -0.16574940f, -0.06899074f, -0.02899392f, 
    0.21275660f, 0.06583519f, 0.22002812f, 0.07333784f, 0.06862161f, -0.39417502f, -0.27061138f, -0.11054566f, 
    -0.04334374f, -0.19596112f, -0.00194297f, 0.08589146f, 0.01571918f, 0.02785579f, 0.06520864f, 0.01848993f, 
    0.09573452f, 0.18645625f, -0.11424410f, -0.00862594f, 0.05822628f, -0.10889424f, 0.16858828f, -0.01402574f, 
    0.17387602f, 0.03375068f, 0.04835144f, -0.11833802f, 0.00627861f, 0.13559900f, -0.17554535f, 0.13412727f, 
    0.10978377f, 0.01435614f, 0.29788050f, -0.05437830f, 0.02364756f, -0.07981873f, 0.05758849f, -0.05206349f, 
    -0.01880827f, 0.04306765f, 0.03618233f, -0.02008796f, -0.01714372f, 0.02949769f, 0.02114735f, -0.00683568f, 
    -0.02400400f, -0.05348473f, -0.03311788f, 0.02199075f, -0.02116078f, 0.01723940f, -0.03470290f, -0.01248638f, 
    -0.01065683f, 0.00106153f, 0.02528217f, 0.00033197f, -0.05532940f, 0.03068968f, -0.04265862f, -0.03004439f, 
    0.00909082f, -0.02070015f, -0.04057180f, -0.05415387f, -0.01919252f, 0.02717443f, -0.01407592f, 0.03474521f, 
    0.00385188f, -0.02954613f, -0.04646648f, -0.03046441f, -0.04995954f, 0.02069753f, -0.05511536f, 0.01585644f, 
    0.04414857f, 0.03053075f, 0.01706324f, -0.02789818f, 0.01779408f, 0.03693010f, -0.02495102f, -0.01512640f, 
    0.02597811f, 0.00928520f, 0.02960894f, -0.04456880f, -0.05518606f, -0.04564909f, -0.02758773f, -0.01762589f, 
    -0.00686160f, 0.02068970f, 0.02835860f, 0.01645394f, -0.03505419f, 0.03470736f, -0.00876901f, -0.02263877f, 
    -0.05642389f, -0.01662251f, -0.03911511f, -0.01177883f, 0.01964113f, 0.04279791f, -0.00900345f, -0.01318604f, 
    -0.03007120f, 0.03260723f, -0.03329805f, 0.01314898f, 0.00916106f, 0.03688309f, -0.01474602f, 0.03602856f, 
    -0.03126387f, -0.01326338f, -0.01121957f, 0.03573070f, 0.00728947f, -0.03402900f, 0.03668638f, -0.01567569f, 
    -0.00908159f, -0.05656132f, -0.05457738f, -0.04466100f, -0.05586911f, -0.05339367f, -0.01396253f, 0.04406326f, 
    0.04500574f, 0.02821671f, -0.05042023f, -0.02713639f, 0.02372367f, -0.01369909f, -0.01698998f, 0.04491665f, 
    -0.03846079f, 0.01926511f, 0.00955018f, 0.03907284f, -0.03487127f, -0.02622765f, -0.03944252f, 0.01832607f, 
    0.04474315f, -0.03164280f, -0.00572524f, -0.01956820f, -0.02340591f, -0.04399374f, -0.02283422f, -0.02067730f, 
    -0.03256365f, -0.03757690f, 0.01587688f, 0.00976613f, -0.05622169f, -0.03469462f, -0.03204753f, 0.04344228f, 
    -0.00827493f, -0.01121051f, -0.00602295f, -0.04271200f, 0.01113324f, 0.01581578f, -0.02631977f, 0.04243955f, 
    0.03255834f, -0.05282955f, 0.03530463f, 0.01619576f, 0.01339551f, -0.02030547f, -0.05535399f, -0.02420707f, 
    0.00831962f, -0.02221202f, 0.04463814f, 0.01030220f, -0.02614782f, 0.02871274f, -0.03097486f, 0.04170766f, 
    0.00193236f, -0.04862951f, -0.01790113f, -0.00879814f, -0.05374270f, -0.01372871f, -0.02262321f, -0.00975507f, 
    -0.00546951f, 0.00392539f, -0.00523471f, 0.00068792f, 0.02915768f, 0.00955460f, -0.02734709f, 0.01748111f, 
    -0.02721453f, 0.01105827f, 0.04234893f, -0.03314336f, -0.02289839f, 0.03311116f, -0.03935054f, -0.04651660f, 
    0.02165336f, 0.00268777f, -0.04012609f, -0.05590417f, -0.04016883f, 0.01613938f, 0.01134231f, 0.00720852f, 
    -0.04119665f, -0.04602443f, 0.00060500f, -0.02081676f, 0.00087770f, -0.01153182f, 0.02149871f, -0.03076296f, 
    -0.04322100f, 0.03143345f, -0.02174078f, -0.05651281f, -0.01681266f, 0.03846175f, -0.03257501f, 0.00302139f, 
    0.01161051f, 0.02589067f, 0.02238072f, -0.00099596f, 0.00470378f, -0.00135086f, 0.00478906f, -0.02416863f, 
    -0.04381039f, -0.04983863f, -0.02782710f, 0.03218843f, -0.03380378f, -0.00012664f, 0.02639121f, -0.04335517f, 
    0.02958523f, -0.05558643f, -0.01392290f, -0.01792797f, -0.00411298f, 0.01223048f, -0.04137879f, 0.03508168f, 
    -0.05275717f, -0.01393813f, -0.05453076f, -0.00017980f, -0.00714190f, -0.00306227f, -0.00593821f, -0.03263893f, 
    -0.00441085f, -0.03529586f, 0.03308082f, -0.04315848f, -0.00229423f, -0.01422623f, -0.04810627f, -0.05020478f, 
    0.02286063f, 0.01790474f, -0.03449222f, 0.03789769f, 0.01303528f, 0.01285871f, 0.04349227f, -0.01051704f, 
    -0.02485282f, 0.04123412f, 0.00883111f, -0.01692010f, 0.02466382f, -0.02708283f, 0.00321550f, -0.00344593f, 
    -0.05346058f, 0.04144870f, -0.00366284f, -0.02558411f, -0.04059289f, -0.02064222f, 0.01989990f, 0.01106315f, 
    -0.01318600f, 0.00352513f, -0.01989521f, -0.03766407f, -0.03327206f, -0.02347185f, 0.02235650f, 0.00180896f, 
    -0.00260711f, -0.05699073f, -0.04231774f, 0.02383194f, -0.01762332f, 0.04118869f, 0.00906255f, -0.04838148f, 
    -0.04668768f, 0.00356942f, 0.01505461f, 0.00224211f, -0.03824948f, -0.04224752f, 0.03407609f, 0.02559907f, 
    -0.05437540f, -0.02395200f, -0.04627289f, 0.01065630f, -0.04208653f, -0.05498700f, -0.04053115f, 0.04071344f, 
    0.01611836f, 0.03332213f, -0.03630704f, -0.00015281f, 0.00119559f, 0.04129910f, 0.01112026f, -0.04118369f, 
    0.00298526f, 0.00387202f, -0.02178223f, 0.02894191f, 0.03378575f, 0.00546824f, 0.01897237f, -0.04643513f, 
    0.02984566f, 0.02359580f, -0.05635521f, 0.00672526f, 0.03106028f, 0.00808550f, -0.00720080f, 0.03020379f, 
    -0.03086667f, -0.01009335f, 0.03870410f, 0.04386693f, -0.00957242f, -0.02741038f, 0.01976304f, 0.00287160f, 
    -0.03008735f, -0.03901584f, -0.04356449f, -0.03566935f, -0.00854474f, -0.05530438f, -0.02240871f, -0.03786526f, 
    -0.02529427f, 0.00419602f, -0.05267439f, -0.05051710f, -0.04246295f, 0.00177236f, -0.04208925f, 0.01498000f, 
    -0.03884204f, 0.04060373f, -0.03690033f, 0.04013096f, -0.00362567f, -0.02933742f, 0.03108926f, 0.00912798f, 
    -0.04384789f, 0.01513391f, -0.01190913f, -0.00607500f, 0.00539266f, 0.00767147f, 0.00709076f, -0.01858594f, 
    -0.00946379f, 0.01435098f, 0.01679503f, -0.00138695f, 0.00137869f, -0.00614064f, -0.03413960f, 0.03728702f, 
    0.04272613f, -0.05618869f, 0.00494085f, -0.05455313f, -0.01675832f, 0.02278832f, -0.00721710f, -0.01941523f, 
    0.01015916f, 0.00178254f, -0.04397605f, -0.03193232f, -0.03283663f, 0.01751275f, 0.01891696f, -0.05209811f, 
    -0.20715417f, 0.02276739f, 0.35258088f, 0.07234218f, -0.07570721f, 0.03023167f, 0.04318664f, 0.11834768f, 
    -0.00216863f, 0.03651091f, 0.05160468f, -0.00322779f, 0.19268836f, -0.08948589f, 0.25364587f, -0.39972594f, 
    0.03109557f, 0.15789004f, 0.19118269f, 0.09022998f, 0.14961939f, -0.00964457f, -0.04200068f, -0.00838368f, 
    0.04201313f, 0.00880233f, -0.05667411f, -0.23048419f, 0.03350999f, -0.06368928f, -0.17752546f, -0.14754273f, 
    0.02759916f, -0.03211709f, 0.04407794f, -0.03922476f, 0.32868728f, 0.14628763f, -0.10107353f, -0.22326687f, 
    0.11794417f, 0.12854238f, -0.06403363f, 0.06910106f, -0.02725841f, 0.14283967f, 0.11441544f, 0.13118626f, 
    0.22787578f, 0.03559548f, -0.02734451f, -0.10189144f, 0.09797829f, -0.08740290f, 0.13673501f, 0.05458890f, 
    -0.02915027f, 0.13996845f, 0.12047953f, -0.00001103f, 0.03104736f, -0.22434837f, -0.21125433f, -0.14602353f, 
    0.26562926f, 0.05074114f, 0.15093675f, 0.13018838f, 0.05682816f, -0.04046973f, -0.10275251f, -0.20304340f, 
    -0.06660793f, -0.15408210f, -0.04683286f, -0.37464675f, 0.05447326f, 0.29570314f, 0.13202000f, 0.24920866f, 
    -0.13369682f, -0.03692788f, -0.10701329f, -0.23089847f, 0.46212846f, -0.02450724f, 0.19832256f, 0.12867486f, 
    -0.00268824f, 0.02471059f, -0.05476760f, 0.02596576f, -0.10510959f, -0.06145740f, -0.01931155f, -0.05195447f, 
    0.00391558f, -0.00293479f, 0.03489316f, 0.00102508f, 0.00532547f, 0.01562092f, -0.01006683f, -0.05477947f, 
    -0.04571731f, -0.06108017f, 0.02660000f, -0.07549284f, -0.08287364f, -0.11120573f, -0.12710361f, 0.09599026f, 
    0.09444746f, -0.02023212f, 0.36123613f, 0.00618145f, -0.01724074f, -0.03288708f, 0.07450413f, -0.06588512f, 
    0.10169476f, 0.19804914f, -0.03990672f, -0.02768363f, -0.21509621f, -0.16534892f, 0.17515475f, -0.00785059f, 
    0.05635779f, 0.15445957f, -0.09448553f, -0.07755655f, -0.40634397f, 0.18308118f, 0.18471564f, 0.29958481f, 
    0.13052130f, 0.07861335f, 0.18927556f, 0.02813848f, 0.19383344f, 0.04630507f, -0.09809183f, 0.09560642f, 
    0.04720629f, 0.11940974f, -0.20717318f, -0.22681573f, 0.07859612f, 0.01612723f, 0.05915254f, 0.00836600f, 
    0.02027426f, 0.03482973f, 0.02530586f, 0.09153002f, -0.18073058f, -0.11041661f, -0.21578977f, -0.05188265f, 
    0.22144239f, 0.23511662f, 0.32251751f, -0.21659350f, -0.00437601f, -0.00637145f, 0.03635147f, 0.10827775f, 
    -0.22820950f, 0.06835288f, -0.06037141f, -0.25372627f, 0.07984858f, 0.03576081f, 0.02932115f, 0.18909191f, 
    -0.13306724f, -0.00549128f, -0.01016423f, -0.02911115f, 0.06590319f, 0.03187243f, -0.03879016f, -0.32164210f, 
    0.00465099f, -0.10062680f, 0.14775708f, 0.11601061f, 0.16552864f, -0.14883512f, -0.06641699f, -0.25758645f, 
    -0.30002111f, -0.22381547f, 0.23380336f, 0.36202151f, -0.03506320f, 0.18738647f, 0.03845625f, 0.03830316f, 
    0.27286190f, -0.02802006f, 0.26568758f, 0.17197005f, -0.26222962f, 0.03616166f, -0.28515527f, -0.03814698f, 
    0.17654572f, 0.04009107f, 0.16436574f, -0.03650475f, 0.01160465f, 0.27127591f, -0.05306084f, 0.23580521f, 
    0.03819532f, -0.07862049f, -0.17580341f, -0.08515564f, 0.03585199f, -0.14353056f, 0.25597689f, -0.17237678f, 
    0.10732632f, -0.02531741f, -0.23908724f, 0.26655266f, 0.11171602f, -0.06149175f, 0.12717904f, 0.24144489f, 
    -0.07528828f, -0.03758455f, 0.03514769f, -0.03178055f, -0.02038515f, 0.04328684f, 0.14883037f, 0.15305889f, 
    -0.05126920f, -0.11657906f, -0.09270105f, -0.07928862f, -0.08769999f, 0.20028540f, 0.15875562f, 0.32543463f, 
    0.24738583f, 0.25995958f, -0.07291475f, -0.05926819f, 0.16254398f, -0.68776172f, 0.01920048f, -0.30018353f, 
    0.09770790f, 0.08331639f, -0.08914043f, -0.15500911f, -0.10635729f, -0.08078465f, -0.01484762f, -0.03132613f, 
    0.04024271f, -0.13220546f, -0.15053864f, -0.00512723f, 0.21594197f, 0.00995898f, 0.16217990f, 0.33428267f, 
    0.05909803f, 0.07799514f, -0.00293700f, 0.01591017f, -0.14953670f, -0.02827131f, -0.22198713f, 0.05244551f, 
    0.18544894f, 0.05234926f, 0.08950709f, 0.02104731f, -0.06700903f, -0.00071614f, 0.00603673f, 0.16190769f, 
    0.06519441f, 0.20593841f, -0.04491328f, -0.24828896f, 0.05493888f, 0.13620450f, -0.13810784f, 0.07293335f, 
    0.15002966f, -0.03977052f, 0.00031732f, -0.06677786f, -0.51266617f, -0.16530517f, 0.06644953f, -0.07620357f, 
    -0.02959156f, 0.08019762f, -0.24146721f, 0.10306931f, 0.10044847f, 0.24038985f, 0.09347590f, 0.00995870f, 
    0.19591193f, -0.26157296f, 0.18340951f, 0.27437967f, -0.16778517f, 0.00193361f, -0.00310904f, -0.01392577f, 
    0.04070588f, 0.03458967f, -0.13224739f, 0.22462258f, 0.09088267f, -0.01559520f, 0.16661294f, 0.07932869f, 
    -0.02625378f, 0.07083923f, 0.00449016f, 0.01873637f, -0.07941355f, 0.03122317f, 0.11567482f, 0.10043012f, 
    0.61721963f, 0.22885253f, 0.15952751f, -0.28037483f, -0.01512600f, -0.06471895f, 0.01759880f, -0.11812102f, 
    0.16774809f, 0.20372507f, 0.30164117f, -0.01149894f, -0.03645651f, 0.26418415f, -0.01804882f, -0.15456136f, 
    -0.02901335f, 0.09382422f, 0.13571848f, 0.09676698f, 0.02914752f, 0.00393837f, -0.02593451f, -0.13420129f, 
    0.01036941f, 0.06265306f, 0.03198982f, -0.02358193f, -0.03636375f, -0.08825626f, 0.20522329f, -0.05333565f, 
    0.08321226f, 0.09251301f, 0.15506959f, 0.05562408f, -0.03661494f, -0.02085448f, -0.14956807f, 0.10617624f, 
    0.23118292f, -0.24986877f, 0.30882815f, -0.09480958f, -0.03305990f, -0.05540015f, 0.00509650f, 0.05650977f, 
    -0.11681403f, -0.29699272f, -0.15055285f, -0.04005394f, 0.01783336f, -0.11594366f, 0.13826422f, 0.08365099f, 
    0.02341081f, -0.09746033f, 0.01292588f, -0.00577790f, 0.18946429f, 0.17952344f, -0.00153289f, 0.18653734f, 
    0.00882876f, -0.10238013f, 0.14895494f, 0.31268427f, 0.19363490f, -0.05660016f, -0.16599971f, 0.13654557f, 
    -0.16084507f, -0.03225993f, 0.05121113f, -0.06396260f, -0.21830592f, -0.00054637f, 0.00120125f, -0.13321225f, 
    0.14898027f, -0.06414099f, -0.12775418f, -0.07682331f, 0.00871719f, -0.04155285f, 0.27726731f, -0.03996107f, 
    -0.14541188f, -0.15687399f, 0.06099484f, 0.00516192f, 0.26992583f, 0.09659857f, 0.07090273f, 0.13330452f, 
    -0.21488193f, -0.35856855f, -0.00131623f, 0.04488534f, -0.18610829f, 0.08843667f, -0.01032111f, 0.01332281f, 
    0.08398238f, -0.09489894f, 0.01754336f, -0.05020269f, -0.00971889f, -0.02642830f, -0.01098248f, 0.05265273f, 
    0.11882015f, 0.16577640f, 0.15343650f, 0.02707497f, 0.02860036f, -0.02284915f, -0.09002383f, 0.12866083f, 
    -0.01465375f, -0.07954235f, 0.01696052f, -0.14817393f, 0.02532251f, -0.02535608f, -0.04655290f, -0.09355831f, 
    0.19440323f, 0.29556066f, 0.13967022f, 0.02475942f, 0.46926028f, 0.18391745f, 0.41344640f, -0.15189227f, 
    -0.10365964f, -0.12572646f, -0.17764552f, 0.03843852f, -0.06890030f, 0.12967484f, 0.13147296f, 0.28941441f, 
    -0.03027565f, 0.11208858f, 0.02835411f, -0.09952276f, -0.08775145f, -0.00095282f, -0.09465211f, 0.00177099f, 
    0.11404244f, 0.22155355f, 0.08218848f, 0.11671080f, 0.31065848f, 0.02454028f, 0.31526846f, 0.08914075f, 
    0.13495985f, 0.09685654f, 0.10008938f, 0.22117628f, -0.07876395f, -0.11288401f, 0.00014652f, 0.09925698f, 
    -0.13710624f, -0.29140738f, -0.13875580f, 0.18919566f, 0.15239376f, -0.02045252f, 0.05351021f, 0.02389216f, 
    0.06021886f, 0.16327676f, 0.01300865f, 0.10430718f, -0.32155028f, -0.07987653f, -0.50453794f, 0.00919464f, 
    0.06272715f, 0.04777131f, 0.21125206f, -0.15269284f, 0.27027756f, -0.00817010f, -0.13214333f, 0.01186250f, 
    -0.28134832f, -0.16787152f, 0.03791310f, 0.08737024f, -0.10440633f, -0.00363493f, -0.07858887f, 0.05018611f, 
    0.05135845f, 0.08207821f, -0.06620304f, -0.03387555f, 0.14934622f, 0.23403148f, -0.02628026f, 0.04022660f, 
    -0.19396082f, 0.31333831f, 0.21295959f, -0.08425855f, 0.12298285f, -0.25707582f, 0.06433052f, 0.02384380f, 
    -0.09954613f, -0.18727477f, 0.05388219f, 0.06279723f, -0.14274271f, -0.02884294f, 0.18771566f, 0.06067955f, 
    -0.08709878f, -0.23890406f, -0.10510618f, -0.13869445f, -0.12898871f, 0.01693695f, -0.23751287f, 0.07884011f, 
    0.06109833f, -0.03278467f, 0.09475115f, 0.04584646f, 0.09707070f, 0.10632547f, 0.18489678f, 0.20918933f, 
    0.16073224f, 0.07356266f, -0.08041289f, 0.08710515f, 0.41059932f, -0.00160664f, 0.20715603f, 0.06588557f, 
    0.06348836f, -0.07585066f, 0.02283465f, 0.28594825f, -0.05858496f, -0.09786490f, 0.08886831f, -0.21685556f, 
    0.05861907f, 0.07092836f, 0.24318251f, -0.16538204f, -0.01277885f, -0.00388539f, 0.11161878f, 0.04612599f, 
    -0.17215061f, -0.09837310f, 0.14132167f, 0.17553671f, 0.02411751f, 0.08143098f, 0.01223152f, -0.10934208f, 
    0.05632813f, -0.08352115f, -0.08323810f, -0.21396670f, 0.17363077f, 0.06332877f, -0.04682960f, 0.13945171f, 
    -0.07056815f, 0.03795215f, -0.12041686f, 0.08685523f, 0.18093896f, 0.16411482f, 0.27121544f, 0.17167918f, 
    -0.31913558f, -0.14933337f, 0.15286244f, -0.01328318f, -0.11833856f, -0.13201872f, 0.06551478f, 0.05271896f, 
    0.23076707f, -0.04758852f, -0.02267938f, -0.11223669f, 0.40389943f, 0.66930336f, 0.24231903f, -0.12643649f, 
    -0.10064368f, -0.13897027f, -0.02229690f, -0.15667494f, -0.13346262f, 0.00501054f, -0.04061656f, 0.12103192f, 
    0.12823252f, 0.04933697f, 0.21915743f, -0.01216838f, 0.20259103f, 0.24328330f, -0.04827705f, 0.00131934f, 
    0.20460922f, -0.01460657f, -0.06653256f, -0.06316725f, -0.23170565f, -0.09755885f, -0.21600184f, 0.20326068f, 
    -0.11483748f, 0.02176587f, -0.01950528f, 0.00719925f, -0.17015009f, 0.04643255f, -0.07815411f, -0.00444442f, 
    -0.12136156f, -0.05898013f, 0.29260710f, 0.21078905f, -0.16938630f, 0.01607310f, 0.02636700f, 0.09096858f, 
    0.01411868f, 0.07431771f, 0.06499441f, 0.00042233f, 0.08097797f, 0.36110818f, 0.16361594f, 0.04493536f, 
    -0.05660081f, -0.09503114f, 0.09825263f, 0.11152969f, -0.02593903f, 0.01575123f, 0.10546191f, 0.18717228f, 
    0.23791291f, 0.02426900f, -0.16519269f, 0.11576908f, -0.20723093f, -0.05838227f, -0.14176075f, 0.00169496f, 
    -0.13760386f, 0.11363548f, -0.07217812f, -0.18812941f, 0.05756925f, 0.23069680f, -0.05964265f, 0.02964208f, 
    -0.05554733f, 0.08661258f, -0.11963014f, -0.05563219f, 0.22322752f, 0.07429844f, 0.36558399f, 0.21273428f, 
    0.39858159f, 0.16977163f, 0.05010483f, -0.04622016f, -0.21168864f, 0.05564981f, -0.10983474f, 0.16280900f, 
    0.19338535f, 0.09387232f, 0.08691216f, -0.01224259f, -0.15203381f, 0.16868614f, 0.17437801f, 0.19424671f, 
    -0.12906520f, -0.08323999f, -0.06259761f, -0.11980817f, -0.11941712f, -0.07539294f, -0.01822146f, -0.12299696f, 
    0.08088166f, 0.00773202f, 0.17061009f, 0.02928364f, 0.09300351f, -0.04024795f, 0.05212229f, 0.15856247f, 
    -0.22092648f, -0.06511135f, 0.08601913f, -0.11765905f, 0.54321581f, 0.02573662f, 0.29768294f, -0.07289876f, 
    0.04823368f, 0.07554273f, -0.01836269f, -0.05298887f, -0.19934757f, -0.18804094f, -0.06597824f, 0.02019663f, 
    0.53089124f, 0.23961079f, -0.11687791f, 0.24249899f, 0.01146284f, -0.00692926f, -0.09123103f, 0.03071549f, 
    0.06893268f, -0.00896730f, -0.12071215f, -0.02413187f, -0.22857213f, 0.03833233f, 0.02351834f, -0.52630550f, 
    -0.12836669f, 0.02590616f, -0.18872401f, -0.11114317f, 0.09480987f, -0.07738252f, -0.05981390f, -0.00482684f, 
    0.13366653f, 0.22116981f, 0.08915626f, 0.25398916f, 0.21296072f, 0.02553907f, 0.02009874f, 0.38000715f, 
    -0.10039894f, 0.03971978f, 0.06056592f, 0.02028325f, 0.05450228f, -0.00198517f, -0.14869103f, -0.03177027f, 
    0.21017683f, -0.11674923f, 0.02297280f, 0.09874274f, 0.05224850f, 0.06084240f, -0.07415107f, 0.03771798f, 
    -0.22825222f, 0.22342804f, 0.38192898f, -0.19072571f, 0.23054446f, -0.14579119f, -0.10090028f, 0.28897300f, 
    -0.07624590f, 0.12939967f, -0.10387485f, 0.00706237f, -0.05075945f, 0.29519346f, 0.10678819f, 0.02158165f, 
    -0.07205682f, -0.04668710f, -0.15045370f, 0.05011678f, -0.03130151f, -0.05375676f, 0.04389172f, -0.06601015f, 
    0.07534584f, 0.10045683f, 0.12682207f, -0.00317847f, -0.06201372f, -0.00821318f, 0.09742537f, 0.07339854f, 
    -0.01078613f, -0.13382822f, 0.12682746f, 0.12603600f, 0.01059947f, 0.15143658f, -0.10562932f, 0.28846961f, 
    0.04508786f, -0.02045991f, 0.17914413f, 0.06984875f, 0.06530655f, -0.10959178f, 0.04186057f, -0.10687811f, 
    0.14208236f, 0.01471072f, 0.05759558f, 0.10398006f, 0.02272470f, 0.05814380f, 0.18824072f, 0.09891465f, 
    0.11341860f, 0.04646942f, 0.06520785f, 0.09579468f, -0.11982690f, 0.42330518f, -0.31071118f, -0.05145591f, 
    0.04518024f, -0.11810879f, 0.06318540f, 0.02291446f, 0.11525239f, -0.01827951f, -0.07798004f, 0.06428099f, 
    -0.08739163f, 0.16452949f, 0.60095847f, -0.04310113f, -0.08897172f, -0.02917037f, -0.16212507f, 0.13961805f, 
    0.06952658f, -0.16072695f, -0.01929791f, -0.15678400f, 0.18857907f, -0.56188530f, 0.43094760f, 0.13757345f, 
    0.16296852f, 0.20107466f, -0.11110325f, -0.00187799f, -0.27315930f, -0.14251721f, 0.07729486f, -0.02466237f, 
    0.11795896f, 0.02410055f, 0.26231056f, 0.32501554f, 0.15706153f, 0.12447676f, 0.19707178f, 0.11347254f, 
    -0.09176198f, 0.05090228f, -0.08400750f, -0.03517227f, -0.05596999f, -0.34955427f, 0.28089741f, -0.38993928f, 
    0.24211287f, -0.07028930f, -0.09199601f, 0.35636628f, -0.12136744f, 0.36914483f, -0.12087619f, -0.11292692f, 
    0.06176363f, 0.07357523f, 0.13711621f, 0.09772989f, 0.27072811f, 0.21687900f, 0.01794929f, 0.07911299f, 
    -0.01023654f, 0.00469505f, -0.02592533f, 0.05906390f, 0.03043794f, 0.00928293f, 0.31608027f, 0.34612310f, 
    0.01500387f, 0.10113903f, -0.02541251f, -0.16476066f, -0.05672460f, 0.10468782f, -0.00365884f, 0.00463841f, 
    -0.03682257f, 0.04287533f, 0.15216625f, -0.01607868f, -0.15494272f, 0.08965245f, -0.14588299f, -0.00815950f, 
    -0.02763462f, 0.09193473f, -0.10465118f, -0.17325291f, 0.12669829f, 0.19407637f, 0.25637180f, 0.32407302f, 
    -0.03520992f, 0.06535771f, -0.16943900f, 0.29548451f, -0.10892460f, -0.09574250f, 0.02958638f, -0.05252675f, 
    -0.32008016f, -0.20283367f, -0.13881935f, -0.24676311f, -0.09439441f, -0.22426473f, -0.04614773f, 0.03757658f, 
    -0.21102065f, 0.04160149f, 0.13621441f, 0.23380239f, 0.06707008f, 0.15736108f, 0.11129709f, 0.06898194f, 
    -0.04454269f, -0.02685517f, -0.00472188f, -0.19509298f, -0.05591401f, -0.14030728f, -0.11943684f, -0.05832284f, 
    0.14721438f, 0.12304738f, 0.00681790f, -0.13691361f, 0.13669097f, -0.03618463f, 0.00078188f, 0.04723658f, 
    -0.04544311f, 0.07332766f, 0.27192673f, 0.23621282f, 0.11662652f, 0.26458317f, -0.16446048f, 0.14181986f, 
    0.11711453f, 0.01600372f, 0.06764583f, 0.26544058f, 0.16049455f, -0.03150409f, -0.08843974f, -0.19396317f, 
    -0.35200134f, 0.07052882f, -0.23810416f, 0.04533831f, 0.06228397f, -0.16689923f, 0.24465626f, 0.02328283f, 
    -0.06083092f, -0.01580384f, 0.15010279f, 0.12266858f, 0.03315851f, 0.10154832f, 0.41282368f, 0.11650295f, 
    0.11754519f, 0.05802639f, 0.24124873f, 0.09119510f, -0.03719062f, -0.05257753f, -0.10731638f, -0.15215892f, 
    -0.02828309f, -0.01079546f, -0.18941678f, -0.26873416f, 0.03755606f, -0.10553569f, -0.03865280f, 0.03710257f, 
    0.26674977f, -0.03081100f, -0.16176166f, 0.02204823f, 0.23779412f, 0.11119532f, -0.35502329f, -0.16374221f, 
    0.00310919f, -0.10134774f, -0.02438191f, -0.18677600f, 0.08715902f, -0.04375319f, -0.07090905f, -0.13337111f, 
    0.12967825f, 0.14441630f, 0.32340455f, 0.08150511f, 0.01710066f, -0.01406846f, -0.02133485f, -0.02309122f, 
    -0.01783841f, -0.08058748f, -0.10174248f, 0.12536100f, 0.22122890f, -0.00154613f, 0.18329631f, -0.00285601f, 
    0.05148625f, -0.13502771f, -0.00718352f, -0.01555076f, -0.08997727f, 0.07848091f, -0.09184796f, 0.06190580f, 
    -0.01958002f, -0.63561398f, 0.09567355f, -0.24058737f, -0.00578767f, -0.17525002f, -0.05927963f, -0.17031045f, 
    0.00858029f, -0.05823501f, -0.10194918f, 0.02247137f, -0.26620406f, -0.16872697f, -0.05454678f, -0.24295221f, 
    0.07989784f, -0.00532154f, 0.09582276f, 0.24631327f, 0.06753036f, -0.07103624f, 0.06691939f, 0.06539061f, 
    0.01680798f, -0.04187145f, -0.16786639f, -0.02790323f, -0.09084604f, -0.02374207f, -0.10209157f, -0.21570700f, 
    0.00893177f, 0.06918330f, -0.29947382f, 0.11265361f, -0.48610070f, 0.27758974f, -0.36909899f, 0.15906350f, 
    -0.02440428f, 0.06115488f, 0.10189795f, 0.11305789f, 0.01098419f, 0.09201297f, -0.09065305f, -0.03916845f, 
    -0.00972421f, 0.01289226f, -0.05552135f, 0.00229593f, 0.01052885f, -0.05761353f, -0.04304949f, 0.03501360f, 
    0.01665692f, 0.01980004f, -0.02515738f, -0.03924909f, -0.03384316f, -0.04959942f, 0.01473314f, -0.04378552f, 
    0.01569938f, -0.00124658f, 0.03883324f, 0.03136506f, -0.02824871f, -0.00051162f, -0.01553649f, -0.04345170f, 
    0.01142322f, -0.01185288f, 0.04469325f, 0.00003957f, 0.00213240f, 0.01093363f, -0.00307864f, 0.03247169f, 
    0.01971890f, -0.04705342f, 0.02926937f, -0.04575296f, -0.01421689f, -0.03428169f, -0.01654183f, -0.04656728f, 
    0.02653113f, -0.01516203f, -0.04819723f, -0.03244625f, -0.04760284f, 0.02001619f, 0.03559093f, -0.03419976f, 
    -0.04011967f, -0.04840511f, 0.02413374f, 0.02153234f, -0.05627435f, -0.01705226f, -0.04218129f, -0.01518644f, 
    0.02104970f, 0.00548874f, 0.03347287f, 0.03182153f, 0.05009400f, -0.05116306f, 0.02079731f, -0.01476789f, 
    0.01105422f, 0.00570467f, 0.03894192f, -0.00818444f, -0.00535425f, -0.03941255f, 0.02313107f, -0.04767906f, 
    0.05459301f, -0.01249221f, -0.04498515f, 0.01809017f, -0.05700305f, -0.00747207f, 0.04086616f, 0.03918414f, 
    0.02968170f, 0.02759007f, -0.01588193f, 0.04250424f, -0.00161017f, 0.01015327f, 0.01293879f, -0.00302144f, 
    0.01441216f, 0.00027478f, -0.02995104f, 0.03954034f, 0.00365596f, -0.04297835f, -0.03641797f, 0.02587873f, 
    -0.03715527f, -0.04818147f, 0.03016655f, -0.03695435f, 0.01763310f, -0.01669805f, 0.02255709f, -0.03035804f, 
    0.03344990f, 0.03880567f, -0.01885890f, -0.00637756f, 0.00494792f, 0.04096085f, -0.03540309f, -0.01722423f, 
    0.02820120f, 0.03939938f, 0.03913938f, 0.02563906f, -0.01336005f, 0.00738931f, -0.00224946f, -0.04935940f, 
    0.00433875f, 0.04526430f, 0.03412376f, 0.00361253f, 0.03131936f, -0.02201322f, -0.00735661f, 0.04592918f, 
    -0.01626073f, 0.04897615f, 0.02918748f, -0.03279911f, 0.02560618f, -0.03627613f, -0.01356642f, 0.00224441f, 
    -0.01897654f, 0.04556697f, 0.01308263f, -0.02355217f, 0.04986619f, -0.01673875f, -0.04560895f, 0.00726224f, 
    0.03500515f, -0.03182956f, -0.02168943f, -0.03721486f, -0.02436473f, -0.01376821f, 0.02305073f, -0.01052311f, 
    0.01811681f, -0.00594573f, -0.05329183f, -0.00723224f, 0.02387947f, 0.00965546f, 0.03723119f, -0.02556282f, 
    0.03046248f, -0.01042984f, -0.01593158f, 0.01730726f, -0.01828157f, 0.02216276f, -0.04417697f, 0.01182672f, 
    -0.02075557f, 0.00060847f, -0.01122627f, -0.04253869f, 0.03763590f, -0.00969085f, -0.04449063f, -0.03388447f, 
    -0.03880743f, -0.03906029f, -0.01119175f, -0.00826557f, -0.00205162f, -0.01374521f, -0.00728038f, 0.01804256f, 
    0.01373570f, 0.01405362f, 0.00789615f, -0.02779800f, -0.05024916f, 0.00812992f, -0.00504312f, -0.05201994f, 
    -0.01813353f, 0.04314149f, -0.02673877f, 0.01883327f, 0.03543314f, -0.01519292f, -0.03571481f, 0.04107299f, 
    0.00843190f, -0.00405590f, -0.05706810f, -0.04906857f, 0.00537786f, 0.02855358f, 0.01782660f, 0.00616320f, 
    -0.00774937f, -0.04438071f, 0.01836640f, 0.00789738f, 0.01473451f, 0.00415967f, -0.03410031f, -0.04100171f, 
    -0.03774692f, -0.02685239f, -0.00945503f, -0.01461155f, -0.01517670f, 0.03367842f, -0.01016669f, -0.01434502f, 
    -0.05332188f, -0.03395329f, -0.00731846f, 0.03201335f, -0.05224247f, 0.03433715f, -0.02277202f, -0.03770982f, 
    0.04242596f, -0.03005236f, 0.02913093f, -0.00316059f, -0.03395604f, 0.01596826f, 0.00135379f, -0.02535854f, 
    0.04053468f, 0.01456577f, -0.01205729f, -0.02395464f, -0.05342211f, -0.00445965f, -0.02007130f, -0.01544839f, 
    -0.02938676f, -0.03154254f, -0.03236039f, -0.02987829f, 0.02619459f, -0.05631832f, 0.01391748f, 0.02297876f, 
    0.03450720f, 0.02278588f, 0.02649119f, 0.02082384f, 0.03875212f, -0.04561069f, -0.03185940f, 0.01902690f, 
    0.03650476f, 0.01589315f, 0.02190727f, 0.01434417f, -0.04607416f, -0.01698820f, -0.01806580f, 0.01475889f, 
    -0.03573947f, 0.03649041f, -0.02598727f, 0.01577463f, -0.03765138f, 0.02643066f, 0.01474831f, 0.02289459f, 
    0.01477914f, 0.03326805f, -0.01529043f, -0.03511625f, -0.02598591f, 0.02130564f, -0.02156643f, 0.03044312f, 
    -0.02441289f, 0.04247297f, -0.02118272f, 0.02380683f, -0.00429820f, 0.03511067f, -0.00563582f, -0.00360623f, 
    -0.02253330f, -0.05319524f, 0.02761809f, 0.01681560f, -0.05035730f, 0.00582488f, -0.04414961f, 0.01516997f, 
    -0.01340927f, 0.01358330f, -0.01857008f, 0.03754302f, -0.00511821f, 0.02938772f, -0.02440039f, -0.01605770f, 
    0.02034883f, 0.03466715f, -0.01529042f, 0.00874002f, 0.01532367f, -0.04041100f, -0.04509512f, -0.02305892f, 
    -0.05416879f, 0.03785813f, -0.00609291f, 0.03880367f, -0.00859333f, -0.01952960f, -0.02641078f, -0.03581329f, 
    0.03188562f, -0.00141209f, -0.02679325f, -0.03813935f, 0.01175244f, -0.05229168f, 0.02019754f, -0.04986375f, 
    -0.01408427f, 0.00609496f, -0.03682217f, 0.00225137f, 0.00928475f, -0.01957067f, 0.01344398f, -0.03306697f, 
    0.01687144f, -0.01767102f, -0.04884250f, 0.02966411f, 0.03635953f, 0.02389978f, 0.04203629f, -0.05263167f, 
    -0.05514485f, 0.04286182f, 0.02019718f, 0.01504880f, 0.03263984f, -0.04785600f, 0.02239466f, -0.03865984f, 
    -0.02857514f, 0.04384627f, 0.02060431f, 0.00442053f, -0.02947980f, 0.04095758f, -0.03767166f, -0.00905357f, 
    -0.04656579f, 0.03339283f, 0.01523583f, -0.00699014f, -0.01460104f, 0.00904195f, -0.02400550f, 0.03389926f, 
    0.04270910f, -0.02993224f, -0.00910155f, 0.00608893f, -0.05971346f, -0.04755308f, -0.05330681f, 0.03433663f, 
    -0.02283695f, -0.01763492f, 0.00322041f, -0.01637757f, 0.03124183f, 0.01111606f, -0.04629000f, -0.04788424f, 
    0.02347484f, 0.00031005f, 0.01209114f, 0.02368294f, -0.05261216f, -0.02730668f, 0.02464003f, -0.03775030f, 
    0.03467338f, -0.03660300f, 0.00835654f, -0.03657832f, 0.03820307f, -0.05637328f, -0.03634564f, 0.03709279f, 
    0.04901259f, 0.01750726f, -0.00792746f, -0.05636617f, 0.01532999f, 0.02292278f, 0.03882838f, -0.01289166f, 
    -0.04404398f, 0.00543508f, -0.03415186f, -0.05194305f, -0.01683912f, -0.05403279f, -0.04443467f, 0.02399609f, 
    -0.00477830f, 0.02208989f, -0.00746853f, 0.01295540f, -0.00103069f, 0.04093401f, -0.00855852f, -0.01123827f, 
    -0.00822133f, -0.00250772f, 0.00430337f, -0.05155788f, 0.00928992f, 0.03155046f, 0.03721932f, 0.04150429f, 
    -0.01930342f, -0.04896910f, 0.02831653f, -0.00906620f, -0.02093318f, 0.02440859f, 0.00940683f, 0.00873517f, 
    0.03911605f, -0.04300687f, -0.04954745f, -0.03716068f, -0.01918967f, -0.01096912f, 0.00385588f, -0.04140907f, 
    -0.01955842f, 0.02933229f, -0.04435832f, -0.00627806f, -0.00208897f, 0.04140512f, -0.01382879f, 0.02854265f, 
    -0.01002873f, 0.00076955f, -0.04824759f, 0.02898898f, 0.01588077f, 0.02996536f, -0.03820820f, -0.00640434f, 
    0.04465435f, -0.03234262f, 0.00101824f, -0.02516447f, -0.02149231f, 0.04098238f, 0.02209696f, -0.01485456f, 
    0.00552523f, -0.01885301f, 0.02938732f, -0.01902073f, 0.00843499f, -0.03482939f, -0.02053051f, 0.02325306f, 
    -0.04512899f, 0.00912559f, -0.00580417f, -0.05176163f, 0.00528437f, 0.00491628f, -0.03123684f, 0.01406444f, 
    -0.05469984f, 0.02926895f, -0.01609084f, -0.02101390f, -0.00780436f, -0.04418176f, -0.04841077f, -0.00895278f, 
    0.02530721f, -0.03157914f, -0.02481415f, 0.01863958f, -0.05492855f, -0.04145224f, -0.05263646f, -0.01688060f, 
    -0.03477388f, -0.05440094f, 0.04229853f, -0.03124810f, -0.03873267f, -0.03559739f, -0.01192750f, -0.00606163f, 
    -0.02683768f, 0.04501532f, -0.05148491f, 0.03440825f, 0.03635725f, -0.01192290f, -0.03525875f, 0.01843167f, 
    -0.01605583f, 0.00560189f, -0.03546770f, -0.02830249f, -0.04311542f, 0.02224047f, -0.00810472f, -0.05612431f, 
    0.01385185f, -0.04753716f, -0.01754320f, -0.03816083f, 0.03241460f, -0.05266489f, 0.03983271f, -0.04394905f, 
    -0.03549211f, -0.02315038f, -0.03667782f, 0.01516854f, 0.03679435f, 0.00446410f, -0.00168507f, -0.01547726f, 
    0.02836217f, 0.04405228f, 0.01424676f, -0.00192090f, -0.05406820f, -0.01168665f, -0.02260220f, -0.01031237f, 
    -0.03556427f, -0.01963088f, 0.01656315f, -0.02370468f, -0.02155111f, 0.00497222f, -0.02944362f, 0.01360178f, 
    -0.03626373f, -0.01204227f, 0.00901018f, 0.00390360f, -0.01661777f, 0.01132813f, -0.01989458f, -0.01324921f, 
    0.03772990f, -0.00024668f, -0.00615343f, -0.05138317f, 0.01354968f, -0.05659860f, -0.00720324f, -0.03338793f, 
    0.00552850f, 0.03838794f, 0.02893867f, -0.02869868f, -0.03912142f, -0.00910950f, -0.03028782f, 0.02987012f, 
    -0.05201086f, -0.00019209f, -0.02641912f, 0.01622914f, 0.01735363f, 0.04262045f, -0.05349489f, -0.05169003f, 
    -0.04690384f, -0.04189959f, -0.04606365f, -0.05239005f, -0.01059381f, -0.03010233f, 0.02083384f, -0.02953170f, 
    -0.05060778f, -0.02874944f, 0.02586602f, 0.00211762f, -0.04255137f, 0.00599706f, 0.01039089f, -0.00015607f, 
    0.00702362f, -0.04008522f, 0.02494938f, -0.02912148f, -0.02339544f, -0.04762201f, -0.03712400f, -0.01630382f, 
    -0.02228764f, 0.03622212f, 0.04198560f, 0.00900929f, 0.03274357f, 0.00617475f, -0.02340477f, -0.02544495f, 
    -0.00678899f, -0.00268224f, -0.01846384f, -0.01551890f, 0.02660226f, -0.01269678f, -0.03878493f, -0.00941244f, 
    -0.04397818f, 0.00283327f, 0.03268886f, -0.04629518f, 0.01688937f, 0.02827447f, -0.01471822f, -0.01374776f, 
    0.02466754f, 0.02173200f, 0.00150267f, 0.00222461f, -0.01437586f, -0.05632616f, 0.02742634f, 0.02520837f, 
    0.02936890f, 0.03334058f, 0.02817399f, 0.00652463f, -0.02825037f, -0.04042863f, -0.00687401f, -0.01349665f, 
    0.04185493f, -0.02580811f, -0.00886919f, 0.00678920f, -0.03069808f, -0.04668976f, 0.02654214f, 0.00583828f, 
    -0.05332756f, -0.01857147f, -0.00365618f, -0.03790060f, -0.03707069f, -0.02368058f, 0.02322178f, -0.02051166f, 
    -0.04675034f, 0.03567700f, -0.02305456f, 0.00474114f, 0.01631116f, -0.02041534f, -0.03947972f, 0.01663447f, 
    -0.01580914f, -0.02615325f, -0.00127920f, 0.01434527f, 0.03642276f, 0.01857706f, 0.03279760f, 0.01245319f, 
    -0.00989847f, 0.00766034f, 0.01816799f, 0.00889432f, 0.04229099f, -0.02810644f, -0.02991261f, -0.04277067f, 
    -0.02539705f, 0.01648249f, 0.04044784f, -0.03532663f, 0.02807323f, -0.05246928f, 0.00501784f, -0.04872667f, 
    0.00583808f, 0.03035517f, 0.02651650f, -0.05412712f, 0.00453903f, 0.00403540f, 0.00465288f, -0.03750636f, 
    -0.04700689f, 0.01582573f, -0.04479386f, 0.00456785f, -0.02022215f, -0.02943176f, -0.02876928f, -0.01550481f, 
    -0.00849903f, -0.04942944f, 0.03618936f, -0.00328623f, -0.00205932f, 0.00056070f, -0.02748425f, -0.04910326f, 
    -0.03412770f, -0.00319897f, 0.00180091f, -0.03167072f, 0.03511851f, 0.01407174f, -0.02459816f, -0.00581881f, 
    -0.02314896f, -0.02269480f, -0.02923258f, 0.00315098f, -0.00037746f, -0.05197570f, 0.02176339f, 0.01069950f, 
    -0.04016332f, 0.04238602f, 0.00452157f, -0.05335549f, 0.02736720f, -0.04268526f, -0.00240026f, -0.00418194f, 
    -0.04103786f, -0.00650527f, 0.03770355f, 0.01097132f, -0.01179256f, 0.03445670f, -0.00874537f, -0.00559504f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.17820665f, -0.01273149f, -0.06025055f, -0.03619054f, 0.14088508f, 0.07609085f, 0.00620561f, 0.11763980f, 
    -0.01043986f, -0.03468798f, 0.10521201f, 0.06905587f, 0.02929307f, -0.04669575f, -0.06032629f, -0.00920205f, 
    0.11697948f, 0.03145570f, 0.07311732f, -0.04502816f, -0.03720578f, 0.02362079f, -0.04623643f, -0.04193822f, 
    0.15626968f, 0.10859951f, 0.00856685f, 0.23373522f, 0.21445182f, -0.06136976f, -0.02211769f, -0.01521995f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.35959482f, -0.07100412f, 0.29716888f, 0.06028845f, 0.17367907f, -0.02461386f, -0.03597857f, 0.21847838f, 
    -0.05171397f, 0.15478788f, 0.03464063f, -0.11961336f, 0.10936714f, 0.39311257f, 0.34663424f, 0.08637629f, 
    0.38426626f, -0.04013231f, -0.39357755f, 0.14450519f, -0.12095876f, -0.60090411f, 0.13495854f, 0.02819878f, 
    -0.19006398f, -0.21025494f, -0.09999736f, -0.03244353f, -0.60958618f, 0.07324225f, 0.07112819f, 0.02389626f, 
    0.22994950f, -0.18264875f, 0.11176939f, -0.15886769f, 0.39137158f, 0.31076273f, -0.01750565f, 0.04521538f, 
    -0.07360824f, -0.07698493f, -0.13774581f, 0.13809790f, 0.06543734f, -0.15411109f, -0.96707690f, -0.07561512f, 
    0.03624459f, -0.16391674f, -0.15716152f, 0.07500882f, -0.38004115f, -0.90110254f, 0.12538539f, -0.08335854f, 
    -0.06964153f, 0.22564355f, 0.16131483f, 0.13924314f, 0.33075443f, -0.17703775f, -0.15552442f, 0.03271748f, 
    0.07045662f, -0.06856413f, -0.33565983f, -0.04420943f, 0.34726453f, 0.17733450f, 0.17353819f, -0.42962998f, 
    0.00045548f, -0.91160607f, 0.21687035f, -0.23299341f, 0.10512107f, -0.09012106f, 0.35014451f, 0.07974651f, 
    -0.56130999f, -0.13438001f, -0.00147285f, 0.36644369f, 0.24625967f, -0.15362017f, 0.04747349f, -0.02380582f, 
    0.04725406f, -0.37006330f, 0.13654153f, -0.01207717f, 0.23133342f, -0.43022659f, 0.16242200f, -0.16311914f, 
    -0.51964056f, 0.13106182f, 0.07025635f, -0.04411157f, 0.24661152f, 0.16744323f, -0.12737368f, -0.24605663f, 
    0.07225292f, 0.01041952f, -0.47043464f, 0.26761302f, -0.05568836f, -0.27481166f, 0.25897923f, 0.14080116f, 
    -0.21902803f, 0.16927242f, 0.18437667f, 0.05905416f, 0.31110278f, 0.15568329f, 0.07189658f, 0.07051878f, 
    -0.33328226f, -0.01954704f, 0.04721867f, -0.35462943f, -0.24297889f, 0.01091286f, -0.16336659f, -0.03792485f, 
    0.15220568f, -0.01299998f, 0.17243680f, -0.08009528f, -0.40247941f, 0.11435299f, -0.17435783f, 0.17814390f, 
    0.07990640f, 0.19603416f, 0.20994180f, 0.06051624f, 0.02262284f, 0.26561829f, -0.07420259f, -0.14225142f, 
    -0.13720101f, -0.15505229f, -0.15917861f, 0.14956215f, 0.17654058f, 0.18030941f, 0.18957122f, -0.12791292f, 
    -0.29137385f, -0.71030766f, -0.15526631f, -0.35018924f, 0.07822251f, 0.17196718f, 0.08988841f, 0.16867203f, 
    0.07605757f, 0.01119156f, 0.29229778f, -0.01212252f, 0.00716621f, 0.22584838f, -0.14105490f, 0.10759456f, 
    -0.03939319f, -0.15916505f, 0.19319241f, -0.08382123f, 0.13942587f, -0.14932030f, -0.55752653f, -0.03603372f, 
    0.19238612f, -0.03770324f, 0.00186115f, -0.29885098f, -0.28666782f, 0.28509057f, 0.01537540f, -0.12861596f, 
    0.46030611f, -0.38664284f, 0.01984865f, 0.17485276f, -0.35282019f, 0.40293917f, 0.01857125f, 0.05630367f, 
    -0.08634505f, -0.08052631f, -0.40349764f, -0.14238454f, -0.78285962f, -0.09784672f, -0.06328492f, -0.57885021f, 
    -0.13123409f, -0.48249599f, 0.00641799f, 0.26670474f, 0.13499764f, -0.04357274f, 0.37925750f, 0.03821308f, 
    -0.16975346f, 0.13171861f, 0.13007678f, 0.23086718f, 0.07456644f, -0.05257552f, -0.89248782f, -0.08634202f, 
    0.13637085f, 0.34994754f, -0.07469311f, 0.20228674f, 0.14415307f, -0.90232480f, 0.13977796f, -0.12068471f, 
    0.17330669f, -0.11904795f, 0.26399699f, -0.06823678f, -0.29418957f, -0.43662357f, 0.12931663f, -0.25017741f, 
    -0.04706469f, -0.40250531f, -0.48183855f, -0.44741178f, 0.14002612f, -0.37267661f, 0.40539414f, 0.02685376f, 
    -0.52757359f, 0.09197766f, 0.32792383f, -0.31802452f, -0.24266161f, -0.01126074f, 0.28913659f, 0.12210643f, 
    -0.23402597f, 0.08988594f, 0.13652104f, -0.09527449f, -0.05125733f, 0.54974681f, -0.01776324f, 0.02238316f, 
    -0.38906944f, -0.11119269f, 0.27930146f, 0.00627442f, 0.39025804f, -0.89320165f, -0.11804941f, 0.32942593f, 
    0.04745179f, -0.30879214f, -0.27954406f, -0.05929125f, 0.03681049f, -0.32433271f, -0.18492910f, 0.14072774f, 
    0.24700195f, -0.14972626f, 0.27477479f, -0.40040812f, -0.70314211f, 0.51798308f, -0.40360826f, 0.08168991f, 
    0.00025769f, -0.02017092f, 0.10238622f, 0.13574626f, 0.13806565f, -0.59132236f, 0.08677529f, -0.15915927f, 
    0.18815711f, 0.15190250f, -0.55625981f, -0.09837496f, -0.47431219f, -0.35130864f, -0.08550309f, -0.11157855f, 
    0.02367759f, 0.43915969f, 0.29815623f, -0.47474715f, -0.11313029f, 0.61677927f, -0.02822247f, 0.00728879f, 
    -0.20915768f, -0.14824472f, -0.08840849f, 0.08327954f, 0.08197010f, 0.11262935f, 0.35008934f, 0.12903331f, 
    -0.45365161f, 0.24258047f, 0.02483406f, 0.23138128f, -0.00999755f, -0.06911013f, 0.05674824f, 0.15336980f, 
    -0.14747731f, -0.03687317f, -0.45252347f, 0.01398311f, 0.19818202f, -0.45908606f, -0.15972809f, 0.26575956f, 
    -0.13630047f, 0.25011963f, 0.13098033f, 0.49030587f, 0.17329206f, -0.90498352f, -0.22637029f, 0.14951299f, 
    0.03485406f, -0.08037306f, -0.13277879f, 0.23916736f, 0.38021240f, -0.27808055f, -0.76876634f, 0.10145789f, 
    0.40646946f, 0.02556878f, 0.01939160f, 0.07170146f, -0.00384528f, 0.16720136f, -0.04644074f, -0.04983007f, 
    0.23632635f, -0.11503118f, -0.63730460f, 0.15022393f, -0.21334656f, 0.52002853f, 0.00506945f, -0.10396905f, 
    0.15343802f, 0.30913725f, -0.05406925f, 0.16601840f, 0.04982573f, -0.65865529f, -0.07493474f, 0.09958685f, 
    0.36321872f, 0.04730087f, 0.24884088f, -0.21199350f, -0.21126778f, 0.32451257f, -0.36455193f, -0.13912413f, 
    -0.70822966f, -0.34800494f, -0.16041382f, -0.13213915f, 0.25991017f, -0.16229840f, 0.08931603f, 0.05902329f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.41265014f, -0.07533509f, 0.20098008f, -0.01657307f, -0.19080293f, 0.01763663f, 0.12217689f, 0.10254806f, 
    -0.11344846f, 0.04268275f, -0.11083917f, -0.06855249f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
