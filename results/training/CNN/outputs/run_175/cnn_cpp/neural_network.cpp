#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.48840377f, -0.68032694f, -0.48763105f, -0.25725049f, -0.45290211f, -0.02040701f, 0.73763639f, 0.65710413f, 
    0.21859643f, 0.55588585f, -0.16856477f, -0.26198623f, -0.21207707f, -0.39683649f, -0.07131506f, -0.24745436f, 
    -0.29218215f, 0.14843588f, -0.12718663f, -0.11177944f, -0.16913725f, -0.10755260f, 0.01763743f, -0.07986344f, 
    0.07701631f, 0.22565272f, -0.28267428f, 0.37743571f, 0.63069922f, 0.17084326f, 0.35406664f, 0.54744577f, 
    0.32532904f, -0.13933060f, 0.53049952f, -0.25319958f, -0.22089005f, 0.08633124f, -0.12218282f, -0.18223523f, 
    -0.19700584f, -0.12988591f, -0.09538547f, -0.04834184f, -0.27460134f, 0.21518211f, -0.07601289f, 0.07474653f, 
    -0.01517901f, -0.23082094f, -0.98088121f, 0.71060890f, 0.41705656f, -0.25129020f, -0.11602239f, 0.01937588f, 
    0.32486731f, 0.12073147f, -0.19077224f, -0.49472293f, -0.18436535f, -0.09176861f, 0.12136577f, 0.01128330f, 
    0.12343035f, -0.00895547f, 0.20643322f, -0.00910088f, -0.17028625f, -0.08456899f, 0.01176705f, 0.12005025f, 
    -0.24131989f, 0.10070338f, -0.18795845f, -0.07965034f, -0.02200958f, -0.49116474f, -0.61262542f, -0.53968292f, 
    0.50416416f, -0.16979036f, 0.03985850f, 0.24579059f, 0.19379455f, 0.17017363f, 0.21185338f, -0.29971534f, 
    -0.00349255f, -0.26017532f, -0.01541468f, 0.03856659f, 0.17033413f, -0.14885095f, -0.20517160f, -0.01383954f, 
    0.00874779f, -0.26390412f, -0.00822613f, 0.33637220f, -0.42655298f, -0.65748584f, -0.06108453f, -0.20583102f, 
    -0.52881241f, -0.43105116f, -0.23228782f, 0.40258756f, -0.04253257f, -0.32604906f, 0.04175388f, 0.16573161f, 
    0.04587918f, -0.06119704f, 0.05703013f, 0.04567690f, -0.07050529f, 0.04692139f, -0.32599038f, 0.07258146f, 
    0.02070831f, -0.03957732f, -0.15136389f, 0.23141150f, 0.22966400f, 0.66264254f, 0.51814628f, 0.46393123f, 
    0.32336429f, 0.26192054f, 0.03844035f, 0.10452423f, 0.20088878f, 0.01207464f, -0.40500352f, 0.02509712f, 
    0.03803540f, -0.19315888f, 0.34397036f, 0.08426511f, -0.19521005f, -0.02039720f, -0.08864318f, 0.03363894f, 
    -0.08182259f, 0.03720738f, 0.29727867f, -0.16127349f, 0.24420404f, 0.11907230f, 0.78955102f, 0.15166597f, 
    -0.45691627f, 0.30788368f, -0.08396614f, 0.18706661f, 0.39236543f, 0.04694971f, 0.47916681f, 0.07588528f, 
    0.18939193f, 0.36323702f, -0.16911539f, -0.25063160f, -0.27719200f, -0.11841102f, -0.18412741f, -0.44226539f, 
    0.07685407f, -0.20020860f, -0.03765012f, 0.16308379f, 0.14578184f, -0.12315077f, -0.07913120f, 0.31091949f, 
    0.31868279f, 0.61123526f, 0.77756870f, 0.44437355f, -0.06355737f, 0.13183977f, -0.05930642f, 0.20016168f, 
    0.04722155f, -0.08874483f, -0.41552690f, 0.01707892f, 0.31310391f, 0.07044572f, 0.04080861f, 0.15017222f, 
    0.22473155f, 0.25565666f, 0.22577146f, 0.36493769f, -0.06423383f, 0.01010949f, 0.16841492f, 0.07364199f, 
    -0.12125774f, 0.35511968f, 0.25731412f, -0.07614053f, 0.23113862f, -0.33917046f, -0.48868826f, -0.76200831f, 
    -0.53494292f, -0.19010760f, -0.36249769f, 0.13876536f, 0.32472804f, -0.02066390f, 0.37949967f, 0.13122523f, 
    -0.08053975f, -0.00635429f, 0.29081887f, -0.02417586f, 0.13121121f, 0.05737252f, -0.09235856f, -0.22982615f, 
    0.22116359f, -0.00466144f, 0.18860057f, -0.51115686f, -0.15198089f, 0.09481558f, 0.09124530f, -0.55150074f, 
    0.05539937f, 0.04059265f, -0.13774200f, -0.20660067f, -0.15463400f, 0.02776928f, 0.15099046f, 0.17145242f, 
    0.20576608f, 0.31275001f, -0.29965401f, -0.37179723f, -0.24369954f, 0.25121316f, 0.23819889f, 0.11061531f, 
    -0.14210190f, 0.20238498f, 0.46711624f, -0.42723438f, 0.20183247f, 0.20558053f, 0.40442151f, 0.69825262f, 
    -0.51000154f, 0.05850885f, 0.05049212f, -0.05362041f, -0.20188130f, 0.08906110f, 0.14911169f, 0.10959373f, 
    0.15047371f, 0.05324522f, 0.26431414f, 0.29544890f, 0.27731493f, -0.18427019f, 0.43596795f, 0.34604946f, 
    -0.01527357f, -0.04204433f, -0.16381241f, -0.33803126f, 0.09467950f, 0.28569129f, -0.46133408f, -0.10484834f, 
    0.24187618f, -0.11865912f, -0.66870409f, -0.07127874f, -0.44329232f, 0.04053234f, -0.00946982f, 0.00161843f, 
    0.10763858f, 0.32564414f, -0.47482300f, -0.07966501f, -0.35659578f, -0.31183234f, 0.44580412f, 0.26597196f, 
    0.12209462f, 0.24631786f, -0.08962056f, -0.10527615f, 0.13095090f, 0.47156474f, 0.62281591f, 0.27660656f, 
    0.21025257f, -0.06081764f, -0.41340166f, 0.11087753f, -0.03845385f, 0.32171118f, 0.27626747f, 0.09371072f, 
    -0.33096388f, -0.05737346f, 0.14978729f, 0.24505758f, -0.10225584f, -0.27524963f, 0.22126167f, 0.12370948f, 
    0.41514784f, 0.14647514f, 0.33086199f, -0.10446117f, 0.36059955f, 0.10829695f, 0.03634139f, 0.43563312f, 
    -0.04104567f, -0.06281817f, -0.00208417f, -0.15791368f, 0.50360972f, 0.55498564f, 0.24850605f, -0.36342660f, 
    -0.24620695f, -0.05633490f, -0.45221081f, 0.14600970f, 0.18539588f, 0.25882113f, -0.13949446f, 0.24501348f, 
    0.18523093f, -0.04122162f, -0.40123913f, -0.14957789f, -0.35347652f, 0.10409887f, -0.45907071f, -0.70623785f, 
    -0.64386284f, -0.00985361f, -0.05928451f, 0.80546397f, 0.28695348f, 0.33963591f, 0.56435978f, 0.20612249f, 
    0.11913994f, -0.22327171f, -0.11001573f, 0.29412642f, 0.41341242f, -0.00551291f, 0.22736551f, 0.25025377f, 
    -0.01693290f, 0.17725021f, -0.00728806f, -0.26950911f, -0.14887090f, -0.21086986f, 0.05725526f, 0.61940676f, 
    0.73110944f, -0.18174146f, 0.01403695f, 0.50042528f, 0.50094670f, -0.16226685f, -0.52616858f, 0.14298873f, 
    0.14115883f, -0.28561857f, 0.01841211f, 0.02704377f, 0.03165169f, -0.10331146f, -0.08823375f, 0.08354989f, 
    0.18922484f, -0.08574678f, -0.08578677f, 0.42915565f, 0.11068475f, -0.02344975f, -0.11654951f, 0.11507267f, 
    -0.14891006f, -0.20701675f, -0.19921783f, -0.35343561f, -0.11233810f, -0.42010957f, -0.41278383f, -0.44913548f, 
    -0.39809778f, -0.41744408f, 0.03532915f, 0.10964310f, 0.24563198f, 0.36431298f, -0.03185560f, 0.32122174f, 
    -0.06136715f, 0.35032779f, 0.30012411f, -0.12942518f, 0.08347063f, -0.11860333f, -0.16790508f, 0.11831418f, 
    0.17436494f, -0.07902700f, -0.29307154f, -0.55991524f, -0.63687992f, 0.37756068f, -0.03996592f, 0.42443863f, 
    0.32947510f, -0.08817279f, 0.09505629f, 0.03088273f, 0.01158362f, 0.19388795f, -0.36603904f, -0.38077831f, 
    0.27178749f, -0.05497271f, 0.27430436f, -0.09560512f, -0.38919324f, -0.22014575f, 0.01328813f, -0.10190330f, 
    0.03280477f, -0.14613600f, 0.01309417f, -0.98865324f, 0.26376453f, 0.32420769f, 0.11863620f, -0.61266762f, 
    0.72865653f, 0.42398834f, -0.30674961f, -0.25354880f, 0.07328941f, 0.40804851f, 0.17930490f, 0.00449443f, 
    0.23558128f, -0.34357220f, 0.13759232f, -0.27900749f, 0.06425954f, -0.00734735f, -0.00020522f, 0.10908557f, 
    -0.08064882f, 0.07095851f, 0.03671613f, 0.81303614f, 0.41688159f, 0.77448332f, 0.42206240f, 0.20914613f, 
    0.23635411f, -0.19519922f, -0.29995602f, -0.51497495f, 0.12609164f, 0.25281334f, 0.49496287f, -0.12137256f, 
    0.09524919f, -0.09630966f, -0.03972505f, -0.13915940f, -0.06549922f, 0.00469063f, -0.39735475f, -0.06655710f, 
    0.11806043f, 0.10272808f, 0.02400926f, 0.27341202f, 0.38305664f, 0.70819986f, 0.76363099f, 0.44474971f, 
    -0.27720612f, 0.02278497f, -0.21680056f, -0.25875005f, 0.06814148f, 0.42573729f, -0.04077236f, 0.24761461f, 
    0.02493802f, -0.15973255f, -0.08492348f, -0.13613166f, -0.02991365f, 0.08473209f, -0.02289430f, -0.00561366f, 
    -0.22741665f, -0.13828456f, 0.10109084f, -0.03299021f, -0.14959426f, 0.63188702f, 0.00135830f, -0.33266601f, 
    0.05686197f, -0.13081779f, 0.33213511f, 0.60609001f, -0.24007893f, -0.03140178f, 0.35158235f, -0.22605743f, 
    -0.28849095f, -0.33409387f, -0.14876945f, 0.16026486f, -0.30245292f, -0.11788633f, -0.10865333f, -0.04254367f, 
    -0.24291717f, -0.01830119f, 0.00627965f, -0.06876550f, -0.12120216f, 0.13593805f, -0.16669399f, -0.13048290f, 
    -0.68368495f, -0.25538492f, -0.00317509f, -0.22802573f, 0.39953634f, 0.29840964f, -0.32188258f, -0.40438816f, 
    0.10781765f, -0.29990003f, 0.21303581f, 0.19253471f, 0.38845202f, 0.08886897f, 0.12068900f, 0.12839779f, 
    0.06387742f, -0.08056973f, 0.11768688f, -0.37217128f, -0.19145189f, 0.01638627f, 0.27710012f, -0.37302163f, 
    -0.45773488f, -0.48140046f, 0.49366763f, -0.03165882f, 0.09069607f, 0.67249227f, -0.28328454f, 0.37047765f, 
    0.25090763f, -0.07013556f, 0.25504786f, -0.08685840f, 0.10934909f, -0.20343183f, -0.28248230f, 0.13179061f, 
    -0.17972381f, 0.09414995f, -0.08911885f, 0.25528550f, 0.08408234f, 0.07715327f, -0.09400480f, 0.29996151f, 
    -0.21857893f, 0.80906475f, 0.49123347f, -0.41491854f, 0.07138095f, -0.92945719f, 0.19912808f, -0.07620861f, 
    -0.64038426f, -0.62891871f, 0.15846837f, 0.15464808f, -0.22498515f, 0.09818265f, -0.12384767f, 0.27822864f, 
    -0.28725740f, -0.01314916f, -0.18623890f, -0.05252591f, -0.09813092f, -0.12424685f, 0.26022428f, 0.12639199f, 
    0.14500491f, 0.62835354f, 0.54934675f, -0.70713818f, -0.81047481f, -0.36233222f, 0.40822014f, 0.04620209f, 
    0.14773773f, -0.12826388f, 0.05152916f, -0.11282700f, 0.12357808f, 0.13416886f, 0.13717009f, -0.06950171f, 
    0.01033963f, -0.05413163f, -0.16613081f, -0.01867712f, 0.08484304f, -0.00947978f, -0.17091116f, 0.12007160f, 
    -0.23885396f, 0.10152650f, -0.06286060f, -0.38977632f, -0.52311033f, -0.56280220f, 0.37926534f, -0.26171586f, 
    0.08317786f, 0.13213086f, 0.03509160f, 0.07144363f, -0.46672219f, 0.10220587f, 0.04215127f, 0.01560161f, 
    -0.32812864f, -0.01181489f, -0.09296586f, -0.08887850f, 0.47854611f, 0.33365837f, -0.02942704f, -0.07979450f, 
    -0.22841787f, -0.30369565f, 0.04963652f, 0.16053277f, -0.23011304f, 0.82026523f, 0.30387011f, -0.40164885f, 
    -0.34007186f, -0.25614953f, -0.19550379f, -0.43482062f, 0.11547844f, 0.04160368f, -0.26634490f, -0.29243553f, 
    0.37508857f, 0.21707875f, -0.33989921f, -0.22093634f, 0.06461055f, -0.24129322f, 0.20033324f, 0.08066939f, 
    -0.12773994f, -0.03194214f, -0.19947384f, 0.21425380f, -0.93697840f, 0.85034782f, 0.01174194f, -0.25284702f, 
    0.13152894f, -0.06284785f, 0.85220993f, -0.37280655f, 0.23634784f, 0.33071649f, -0.19489564f, -0.01230534f, 
    0.22192548f, -0.39405093f, 0.13275778f, 0.11184198f, -0.10396969f, -0.04336859f, -0.07402712f, -0.15632385f, 
    0.11934767f, 0.18373235f, 0.12892213f, 0.17447247f, 0.22428028f, -0.00231104f, 0.11076394f, -0.27284688f, 
    0.43230084f, 0.04288835f, -0.39502561f, -0.77794111f, -0.47165662f, -0.34697708f, 0.20929278f, -0.18191800f, 
    0.19481818f, -0.41719925f, -0.36735091f, -0.02347404f, 0.12136281f, -0.37311801f, 0.22775751f, -0.23416698f, 
    0.14548230f, 0.09431676f, 0.20626201f, 0.01393059f, -0.33446106f, -0.36671475f, 0.29103419f, -0.43258810f, 
    -0.59060019f, -0.11394959f, -0.20008104f, -0.24395642f, -0.58368146f, -0.01799341f, 0.24194883f, -0.42650425f, 
    -0.28585249f, -0.33265674f, -0.12445199f, 0.08700327f, 0.10531526f, 0.04908360f, 0.29958397f, -0.21927004f, 
    0.19840804f, 0.05433375f, 0.06517919f, 0.14048378f, -0.00357723f, 0.30797094f, -0.21759038f, -0.13240139f, 
    -0.56704003f, 0.32942447f, 0.22176600f, -0.37800011f, -0.33798444f, -0.00516524f, 0.69869155f, -0.24002801f, 
    -0.21095368f, 0.19194771f, -0.21549670f, -0.32225981f, -0.21916960f, -0.31539205f, 0.19642672f, 0.03805856f, 
    0.00618141f, -0.04256834f, -0.26305601f, -0.19959535f, -0.13614745f, -0.12533741f, 0.03219499f, -0.07684562f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09142723f, 0.05770600f, -0.06651562f, 0.11176659f, 0.27163103f, 0.16578996f, 0.06196201f, 0.10113955f, 
    0.22136648f, 0.26671892f, 0.11363655f, 0.13136843f, 0.13951898f, -0.03971680f, -0.04160526f, 0.13423400f, 
    0.15141471f, -0.15229991f, 0.02681340f, 0.24739054f, 0.10631615f, 0.12885624f, -0.03249773f, 0.24255288f, 
    0.01973311f, 0.05282159f, 0.02154844f, 0.20756294f, 0.00467956f, 0.22041494f, -0.07260361f, 0.00406320f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00327431f, 0.03219957f, 0.02977932f, 0.05158058f, 0.07202496f, 0.06153653f, -0.02580212f, 0.05115417f, 
    0.01968052f, 0.08960661f, 0.06334596f, -0.01791530f, 0.11025412f, -0.15806119f, 0.02779661f, -0.22843775f, 
    0.06444212f, 0.07870310f, 0.01058656f, -0.07988529f, -0.01153928f, -0.00343380f, 0.03030775f, 0.13840634f, 
    0.23739053f, -0.35223523f, -0.01909164f, 0.23852058f, -0.00336409f, 0.06708352f, -0.01740492f, -0.04301458f, 
    -0.04581941f, -0.09289533f, 0.02500981f, 0.13495545f, 0.01197652f, 0.14116260f, 0.08486646f, 0.10276714f, 
    0.05517820f, -0.04492569f, 0.00316043f, 0.03844592f, -0.04225205f, 0.03111554f, 0.00556866f, -0.16998351f, 
    0.01374029f, 0.12015870f, 0.06973147f, 0.09112096f, 0.02995567f, 0.04253468f, -0.00450278f, -0.00119364f, 
    -0.06836118f, 0.00308014f, -0.05702958f, -0.09721284f, -0.03856485f, -0.03150632f, -0.00272376f, 0.00834822f, 
    0.16350733f, 0.08439881f, 0.07939140f, -0.05171755f, -0.01529442f, 0.00861140f, 0.02636184f, 0.08326788f, 
    -0.26628485f, 0.20094171f, 0.00334660f, -0.10051149f, 0.06266497f, 0.06837277f, 0.08619212f, -0.05341276f, 
    -0.03128560f, -0.02469535f, 0.10942276f, 0.04192730f, 0.00937089f, -0.11495066f, 0.11799832f, -0.24393171f, 
    0.08378707f, 0.04118814f, 0.02421359f, 0.00810514f, -0.13367236f, -0.01683118f, -0.12523468f, 0.00645582f, 
    0.09695676f, -0.05742519f, -0.20545074f, -0.00974917f, -0.03608226f, -0.08601514f, 0.03005409f, 0.00203456f, 
    0.03099481f, -0.03999420f, -0.05097814f, -0.06909597f, -0.18506566f, 0.01085612f, -0.03372762f, -0.01063405f, 
    0.04008336f, 0.04542219f, -0.00844012f, 0.11315936f, -0.04807111f, -0.16820684f, -0.03094610f, 0.07648858f, 
    0.08503401f, 0.11391014f, -0.00780114f, -0.12240005f, -0.11341299f, 0.02368571f, -0.09687158f, 0.01775245f, 
    -0.09182356f, -0.04625878f, -0.07575531f, -0.07339371f, 0.10964653f, -0.05070838f, 0.01239759f, 0.25149587f, 
    -0.03458143f, 0.02409310f, -0.02061648f, -0.03285302f, -0.00726525f, 0.00844817f, 0.02969604f, 0.09007956f, 
    0.29105484f, -0.04297317f, -0.00622363f, -0.19085631f, 0.04677843f, 0.11841082f, -0.02783382f, -0.04915902f, 
    -0.02319613f, -0.04244511f, 0.00200995f, 0.07995328f, -0.03608420f, 0.17085981f, 0.06299308f, -0.05964814f, 
    -0.07835594f, -0.01757977f, 0.06687292f, 0.13273820f, 0.07355846f, -0.00042061f, -0.00359205f, -0.01938123f, 
    -0.05627513f, -0.02607598f, 0.20539421f, -0.02180712f, 0.00971383f, 0.08762833f, -0.02564598f, 0.07710117f, 
    -0.11628103f, -0.07581154f, -0.00992640f, -0.10047229f, -0.09039750f, 0.42614657f, -0.03972275f, 0.01072429f, 
    0.08879966f, 0.11593226f, -0.05622517f, -0.03333069f, 0.01756194f, 0.05138767f, 0.04141998f, 0.02431670f, 
    -0.02335037f, -0.04212303f, -0.19029118f, 0.10260557f, -0.00038217f, -0.04965769f, -0.07002827f, -0.05572597f, 
    -0.08294912f, -0.14426756f, -0.11497010f, -0.05105202f, 0.01125295f, -0.20817991f, -0.04877551f, 0.23422097f, 
    0.20531189f, 0.00131983f, 0.07372365f, 0.06467377f, 0.01533069f, 0.01684659f, -0.05618848f, 0.07509732f, 
    0.20076008f, -0.11682247f, 0.01855578f, -0.05128638f, 0.04050151f, 0.03406122f, 0.02058788f, 0.02554124f, 
    -0.11209098f, 0.01868008f, -0.00840575f, 0.07887413f, 0.32889146f, 0.05207113f, -0.10157051f, -0.14237960f, 
    0.12492319f, 0.01885582f, 0.03908891f, -0.07331599f, -0.04494989f, 0.05877244f, 0.06367251f, 0.07565709f, 
    0.47166136f, 0.18010753f, 0.12692457f, -0.26284656f, 0.09820099f, 0.09728840f, 0.02728099f, -0.03991630f, 
    0.05384054f, -0.02382664f, 0.06367919f, -0.02224120f, 0.04959258f, 0.11338963f, -0.08048428f, 0.02389525f, 
    0.14581896f, -0.03744173f, 0.01373690f, 0.02001302f, 0.07138240f, 0.04927993f, -0.00177288f, 0.11073723f, 
    0.12557721f, 0.03494159f, 0.05166746f, 0.10821703f, 0.13851734f, -0.01691786f, -0.03762671f, -0.10429261f, 
    -0.07334536f, -0.05277280f, -0.01356211f, -0.11129421f, -0.03834088f, -0.16111483f, 0.11330376f, -0.02954780f, 
    0.11537255f, -0.04362211f, -0.01875270f, -0.12072794f, 0.08525751f, 0.00035371f, -0.05986367f, 0.00562494f, 
    0.38375780f, -0.43532467f, -0.10958127f, 0.18027554f, 0.02835496f, 0.06777518f, -0.01351951f, -0.13649443f, 
    -0.03814402f, -0.00334652f, 0.11971179f, 0.00945861f, 0.03227898f, 0.22173326f, 0.06681076f, 0.28140309f, 
    0.15385279f, -0.02519255f, -0.06519025f, -0.00203644f, 0.10819045f, -0.02459437f, 0.01504384f, 0.07111906f, 
    0.08244649f, 0.01299003f, -0.02897609f, 0.18263391f, 0.07583877f, 0.07319567f, -0.02213462f, -0.05255235f, 
    -0.04933343f, 0.08372764f, -0.04581275f, 0.00897583f, 0.37085366f, -0.14482065f, -0.06985925f, -0.08249749f, 
    -0.04425421f, -0.11616081f, 0.03363197f, 0.01963632f, 0.08529040f, 0.06595511f, 0.04877814f, 0.04340943f, 
    0.13156384f, -0.26059407f, 0.04861425f, 0.14697251f, 0.08042100f, 0.00424702f, -0.03816194f, 0.17295334f, 
    -0.09201594f, -0.05482906f, 0.05476642f, 0.08360781f, -0.06358671f, 0.07221386f, -0.08479957f, -0.17617036f, 
    0.03791730f, 0.00234241f, 0.04895652f, -0.00470831f, 0.00508595f, 0.07333199f, -0.06517132f, 0.01996446f, 
    0.12720916f, 0.29906416f, -0.03990356f, -0.08523343f, -0.03942645f, -0.06739374f, -0.04716795f, 0.03806157f, 
    -0.00614682f, -0.10210942f, -0.00973866f, -0.09595230f, 0.20740183f, 0.13764355f, -0.04877999f, -0.00075944f, 
    -0.01699804f, -0.02551402f, 0.05824437f, 0.07804397f, 0.06728213f, -0.00567947f, 0.01590122f, -0.05684847f, 
    -0.30298904f, -0.10718555f, -0.28464651f, -0.18186300f, 0.13666357f, 0.15475826f, 0.10990722f, 0.03319951f, 
    -0.03887978f, 0.02281123f, 0.00864762f, 0.10884082f, 0.16714264f, 0.21207878f, -0.00627236f, -0.14629228f, 
    0.05951515f, 0.01458907f, -0.12878123f, -0.07516820f, -0.07613816f, 0.00282595f, 0.00098593f, 0.10408033f, 
    0.09642343f, -0.23389526f, -0.06963913f, 0.09929033f, -0.04695930f, -0.04528178f, 0.03157897f, 0.01908707f, 
    0.07762500f, 0.04427653f, 0.04855178f, 0.05511501f, -0.14834104f, -0.17252977f, -0.02430627f, -0.05229445f, 
    0.10532536f, 0.07469960f, 0.02733829f, 0.12503119f, 0.05074624f, -0.00321320f, 0.04869656f, 0.02513131f, 
    -0.23268951f, -0.05373739f, -0.09881473f, 0.14651729f, 0.08256105f, 0.07266662f, 0.17586528f, 0.00205716f, 
    -0.07396235f, 0.04578724f, -0.10048416f, 0.11120553f, 0.09432492f, 0.21555826f, 0.15876323f, 0.02191232f, 
    0.05679872f, 0.05174539f, 0.04900235f, 0.03911301f, -0.05451085f, -0.10133225f, 0.00487601f, 0.04076648f, 
    -0.28980267f, 0.14528887f, -0.04243361f, -0.15319923f, -0.02172615f, -0.05477388f, 0.04972502f, -0.10607789f, 
    0.02949568f, -0.05960009f, -0.03401542f, 0.09610077f, 0.11635895f, 0.14379880f, 0.25984904f, -0.19406438f, 
    0.05138279f, -0.00844347f, 0.00228296f, -0.03128738f, 0.04263774f, 0.08874414f, -0.04965739f, 0.03140945f, 
    0.13105229f, 0.01650178f, 0.12433482f, -0.01027595f, -0.07437205f, -0.03388932f, 0.03422946f, -0.04582854f, 
    -0.01793344f, 0.08572178f, 0.12105191f, 0.10053903f, -0.06193798f, -0.09528280f, 0.15019681f, 0.08178855f, 
    -0.01803645f, 0.06056599f, 0.10407405f, 0.03948075f, 0.07898007f, -0.04332247f, 0.05003374f, 0.05130454f, 
    0.23958789f, 0.09721835f, -0.11337170f, -0.08406662f, 0.09166961f, -0.14001991f, -0.02129281f, 0.05910980f, 
    0.18883733f, 0.17311618f, 0.14374624f, 0.06950292f, -0.28445730f, -0.10311742f, 0.06082995f, 0.12819810f, 
    -0.06505544f, 0.11489448f, 0.09600587f, 0.04083747f, -0.09801278f, 0.02850962f, 0.03187434f, 0.02442047f, 
    0.03483378f, 0.10918455f, 0.30472365f, 0.01141221f, 0.04624070f, -0.03169949f, -0.07057983f, 0.02788081f, 
    0.01673003f, 0.04791454f, 0.00413044f, 0.07836034f, 0.24224010f, -0.15233827f, 0.15872632f, -0.08611000f, 
    0.15606804f, 0.01097171f, -0.07020675f, -0.01662808f, 0.09786020f, 0.04620822f, 0.01718614f, 0.06811228f, 
    -0.21850201f, -0.28457239f, -0.26311192f, -0.12248256f, 0.14711554f, 0.07904788f, 0.09505899f, 0.00594408f, 
    0.09813752f, -0.00500822f, -0.05311439f, 0.04268350f, -0.33603403f, 0.22192252f, 0.26612523f, 0.03285160f, 
    -0.09255257f, 0.11442190f, -0.06619158f, 0.02929147f, 0.04671812f, -0.00035142f, 0.05708078f, -0.06272873f, 
    0.03844233f, -0.16323991f, 0.08472810f, 0.05407849f, -0.00903180f, -0.08330099f, -0.03442675f, 0.01299926f, 
    0.07254741f, 0.05529714f, 0.12599765f, 0.08638820f, -0.13969858f, -0.22829936f, -0.31041518f, -0.12003223f, 
    0.11805938f, 0.06965365f, 0.05849972f, 0.17784962f, 0.00964712f, -0.01227366f, -0.01572549f, -0.04041062f, 
    -0.30690643f, -0.11627512f, -0.13981882f, -0.10177454f, 0.07598179f, -0.00731130f, 0.01248528f, 0.07010124f, 
    -0.09386884f, -0.01682853f, 0.11174748f, 0.02103993f, 0.14715253f, 0.31748044f, 0.20600706f, -0.10974605f, 
    0.00269332f, 0.00252155f, 0.04257628f, -0.03361992f, -0.01457714f, -0.04349269f, 0.05764876f, 0.12395094f, 
    0.12897965f, 0.24885105f, 0.25777277f, -0.11239253f, -0.03715669f, -0.00466043f, -0.07889850f, -0.05066771f, 
    -0.01673386f, -0.02452392f, 0.05642059f, 0.01124561f, 0.00703917f, 0.15827973f, 0.01601934f, -0.05802224f, 
    0.05579279f, 0.00363671f, 0.02020667f, -0.00190768f, 0.09659653f, 0.01009699f, 0.03237175f, 0.06246618f, 
    -0.20504186f, -0.11436337f, -0.03459642f, 0.09305086f, 0.19333452f, 0.09934227f, 0.10594241f, 0.02669628f, 
    0.12449961f, 0.03050420f, 0.14488971f, -0.12782660f, -0.28522024f, -0.16802017f, -0.03319272f, -0.00310316f, 
    0.18421064f, 0.07842835f, 0.01480115f, 0.03350735f, 0.02391002f, -0.00855651f, 0.03373017f, -0.04901578f, 
    0.02700719f, -0.15692413f, 0.11684220f, 0.04545978f, -0.11789494f, 0.01527669f, -0.07470863f, -0.11326469f, 
    -0.00959293f, 0.07236939f, 0.03538748f, 0.08235136f, -0.16221304f, 0.00400109f, 0.15619245f, 0.07791341f, 
    -0.12027058f, 0.12399664f, -0.01739310f, 0.02421154f, 0.13690646f, -0.06179377f, -0.01551661f, 0.05144434f, 
    0.06369138f, -0.24657191f, -0.10308557f, 0.04996703f, 0.09855440f, 0.07175330f, -0.02472777f, 0.12589318f, 
    -0.00581400f, 0.04759265f, -0.00210801f, -0.09074887f, 0.05913099f, 0.01074036f, 0.07073317f, -0.05779001f, 
    0.03913064f, -0.00146704f, -0.00060091f, -0.07441595f, -0.04026645f, 0.03134403f, -0.04574520f, 0.05639039f, 
    -0.06827458f, -0.25001180f, 0.16402821f, 0.06920599f, 0.02878067f, 0.10470343f, -0.00946867f, -0.08529094f, 
    0.00803929f, -0.00125578f, 0.00483945f, -0.04850313f, -0.22061042f, 0.05885527f, 0.17351329f, 0.06979248f, 
    -0.06417970f, 0.00471632f, 0.05307941f, 0.04283041f, -0.02011790f, 0.08132854f, -0.03169973f, 0.03967035f, 
    -0.03819725f, -0.06501730f, -0.04546704f, 0.06835430f, 0.00484516f, -0.00214532f, 0.01088967f, 0.05791078f, 
    0.09375691f, 0.00281345f, -0.02350795f, -0.06068753f, 0.05793390f, 0.00482695f, -0.19331761f, -0.06092803f, 
    0.05546262f, 0.05856249f, 0.08991002f, 0.08060125f, 0.06545604f, -0.00919580f, 0.01612170f, 0.08522062f, 
    -0.05680549f, -0.04148085f, -0.02171150f, 0.01611384f, -0.05604582f, 0.03143298f, -0.03831667f, -0.03008663f, 
    -0.04153455f, -0.04389317f, -0.01001642f, 0.00527814f, 0.01033917f, -0.02891446f, -0.03249995f, 0.00150661f, 
    -0.05585274f, 0.02494923f, 0.03749286f, 0.02828569f, -0.03873293f, -0.00888355f, -0.03708599f, -0.00539216f, 
    -0.03351252f, -0.03934022f, 0.00542865f, 0.01747950f, 0.00010917f, 0.04252042f, 0.03071184f, 0.02972037f, 
    0.01317737f, 0.04708705f, -0.00127687f, 0.00995532f, -0.05157494f, -0.03430315f, -0.01980317f, -0.05036955f, 
    -0.03346052f, 0.02118496f, 0.00783170f, -0.05324717f, 0.02782683f, -0.03071454f, -0.00154811f, 0.01979348f, 
    0.02701206f, 0.00063574f, -0.01821391f, -0.05269838f, -0.02719727f, 0.04000363f, -0.00857847f, 0.02958747f, 
    -0.01968465f, -0.02364739f, -0.00193022f, -0.01119644f, 0.03609116f, -0.02092257f, 0.01394407f, -0.01117096f, 
    -0.05052862f, 0.03431959f, -0.04740052f, -0.01391704f, 0.02217576f, -0.04541171f, 0.02268552f, -0.03206561f, 
    -0.05597492f, 0.02974092f, 0.03222264f, -0.03412827f, 0.03491228f, 0.02391994f, -0.04852569f, -0.00607436f, 
    0.03831079f, -0.01654905f, 0.01289580f, 0.00463575f, -0.05043378f, 0.02380365f, 0.04263574f, 0.02992607f, 
    -0.01207236f, -0.01380250f, 0.04288824f, -0.00036853f, 0.04139471f, 0.00235315f, 0.02994118f, 0.00567049f, 
    -0.00325904f, 0.03934235f, -0.04298442f, 0.01668626f, 0.01242714f, 0.01777128f, -0.00337415f, -0.00019635f, 
    -0.02311600f, 0.04059591f, -0.00661932f, -0.02877894f, -0.05227783f, 0.03223670f, -0.04995447f, 0.02663729f, 
    0.03340801f, -0.03931987f, 0.01475065f, -0.00630916f, -0.00126699f, 0.03262044f, 0.03221304f, -0.00506580f, 
    0.04742602f, 0.03571748f, -0.02629639f, 0.01169317f, -0.03746189f, 0.03102102f, -0.02342714f, 0.02905997f, 
    -0.04367031f, 0.02600042f, 0.04005590f, -0.03301517f, -0.02431825f, -0.04940762f, -0.00370898f, 0.01414442f, 
    -0.05069159f, 0.00715941f, 0.02648866f, -0.03348867f, -0.05699080f, -0.02863922f, -0.03697143f, 0.01969108f, 
    0.03096691f, -0.02140415f, 0.03297057f, 0.01093799f, -0.02514427f, 0.03653257f, 0.01632269f, -0.04873296f, 
    0.00250827f, -0.04980772f, 0.01445864f, 0.02980064f, -0.00151908f, -0.03263104f, -0.02494960f, 0.03648780f, 
    0.00608535f, 0.01741207f, -0.04055187f, -0.00209398f, -0.04023299f, -0.00888054f, -0.00177968f, 0.03001006f, 
    -0.00703325f, -0.02357308f, 0.04435888f, 0.03896563f, -0.04441221f, -0.05817633f, 0.02263260f, 0.02771636f, 
    -0.01763064f, 0.03762258f, -0.03349351f, -0.02522875f, -0.01367429f, -0.04182906f, 0.00353668f, -0.01888550f, 
    0.01675922f, 0.00632108f, 0.01851556f, -0.02462818f, 0.00607328f, -0.03885432f, -0.05629689f, 0.02707912f, 
    -0.03209796f, 0.02905629f, -0.04768338f, 0.03636367f, -0.04546145f, -0.00497013f, 0.00808269f, -0.00127383f, 
    0.03434826f, -0.00314238f, 0.02948452f, -0.02869894f, 0.03552364f, -0.00300146f, 0.03375949f, -0.02491979f, 
    -0.00552392f, 0.02239675f, 0.04026208f, 0.01208627f, 0.03961410f, -0.03509856f, 0.03397997f, -0.00449499f, 
    0.03219231f, -0.05718431f, 0.03924351f, 0.02361321f, -0.02659932f, -0.02262128f, 0.02170617f, 0.02501851f, 
    -0.05733205f, -0.01388998f, -0.01438611f, -0.03672092f, 0.04542792f, -0.04477810f, -0.03558797f, 0.03891708f, 
    -0.01539755f, 0.03859321f, 0.03558351f, -0.01238159f, -0.04220812f, 0.01416513f, 0.00019296f, 0.02510343f, 
    0.01826540f, 0.02398130f, -0.00053578f, -0.02019027f, -0.05509354f, -0.02694415f, 0.03464120f, -0.01484302f, 
    -0.00663034f, -0.02286863f, -0.04189050f, 0.01802892f, -0.05452753f, 0.01642701f, -0.05325241f, 0.00765703f, 
    -0.01184715f, -0.00588033f, 0.01553668f, -0.04339023f, 0.02120324f, -0.05394960f, -0.04788077f, 0.03159616f, 
    0.01921866f, 0.04045115f, 0.03559466f, -0.00945017f, -0.01821125f, 0.02954304f, 0.04254557f, -0.03319173f, 
    0.01933291f, 0.01760104f, -0.03710253f, 0.01369133f, -0.00027000f, 0.03569529f, -0.00545107f, -0.00530231f, 
    -0.01847751f, -0.00874232f, -0.01382424f, -0.04702440f, -0.02830311f, 0.02569140f, 0.03188125f, 0.04112953f, 
    0.02281334f, 0.03279172f, -0.05253517f, -0.02907629f, -0.01858286f, -0.04516149f, 0.03450538f, -0.04287710f, 
    0.04183337f, 0.02873115f, -0.04783949f, 0.01960392f, -0.04169797f, 0.00862401f, 0.02366406f, 0.03813655f, 
    -0.05050085f, 0.02246618f, 0.00097325f, -0.05147629f, 0.02975142f, -0.02763931f, -0.02474072f, 0.03503288f, 
    -0.01150056f, -0.05919094f, -0.02795152f, -0.02255638f, 0.04197128f, 0.02936113f, 0.04111435f, -0.00075886f, 
    -0.00168941f, 0.00426630f, -0.03261667f, 0.02530010f, -0.03919934f, -0.05107114f, 0.01691777f, 0.01083680f, 
    0.00260744f, 0.03076116f, -0.03165421f, 0.01582156f, -0.00118544f, -0.02753640f, -0.03599406f, 0.02696632f, 
    0.03047726f, 0.02887167f, -0.04001008f, -0.04872200f, -0.02350671f, 0.03209278f, -0.03914954f, -0.00127562f, 
    -0.01119768f, -0.05306667f, -0.04627058f, -0.00980850f, 0.03530938f, 0.01578393f, -0.00385404f, 0.01912769f, 
    -0.03123282f, -0.03458818f, 0.04503329f, -0.00506048f, 0.00671851f, -0.01243784f, -0.01219572f, -0.02860395f, 
    -0.01797454f, -0.04750634f, -0.04126990f, -0.05674742f, -0.04899918f, -0.04962752f, -0.04132085f, 0.01959255f, 
    0.02301824f, -0.02109604f, -0.05144744f, -0.02664257f, 0.03039909f, 0.00122169f, -0.04252454f, 0.03631109f, 
    -0.01244561f, -0.00786730f, 0.01828764f, 0.00135383f, 0.02303427f, 0.03171723f, 0.03548909f, -0.01312240f, 
    -0.11454556f, -0.04027566f, -0.01930794f, -0.12621695f, -0.01734020f, 0.03830431f, 0.03419529f, 0.01492910f, 
    0.00036149f, 0.06406613f, 0.16749290f, 0.02762850f, -0.28663760f, -0.17194872f, -0.02528101f, -0.14928187f, 
    0.06129124f, 0.04972776f, 0.04566023f, -0.01866156f, -0.03309428f, -0.05578776f, 0.02755682f, 0.15998486f, 
    -0.01149979f, 0.00305366f, -0.00047479f, 0.08536607f, -0.11558036f, 0.02745419f, 0.03056081f, 0.04749996f, 
    0.01179115f, 0.01574551f, -0.01224122f, 0.09393463f, 0.05116393f, -0.09849846f, -0.10664044f, -0.00654193f, 
    -0.02629754f, -0.09394605f, 0.10203738f, -0.12265090f, 0.04789953f, 0.11683984f, -0.06123612f, -0.13782252f, 
    0.01187931f, 0.11248383f, -0.09855563f, -0.15829188f, -0.01580336f, -0.04885822f, -0.03656030f, -0.10945607f, 
    -0.00681649f, 0.03554768f, 0.01941610f, -0.15310757f, -0.09184592f, -0.00499368f, 0.03235225f, -0.11965975f, 
    0.01372299f, 0.00259256f, -0.05126351f, 0.00367350f, 0.02808175f, -0.02989940f, -0.01026218f, -0.03405806f, 
    -0.35148811f, 0.04194266f, 0.00185440f, -0.10029481f, -0.01049794f, 0.16273393f, 0.11509780f, -0.00126597f, 
    -0.03295958f, 0.11606728f, 0.24515373f, 0.03114716f, -0.08480272f, 0.04135083f, 0.12757757f, -0.22741699f, 
    0.02240947f, -0.01134983f, 0.01661452f, 0.05898379f, -0.05850698f, -0.03634338f, -0.07262610f, 0.06055642f, 
    0.08038667f, 0.03933584f, 0.09928034f, 0.23037070f, 0.06758251f, 0.12894762f, -0.04846758f, 0.07064745f, 
    0.05813286f, 0.02843988f, -0.13183266f, -0.00461580f, 0.19587825f, 0.05860258f, 0.03328716f, 0.10409582f, 
    -0.03351564f, -0.03889677f, 0.04182960f, -0.01496389f, -0.10672634f, 0.05737968f, 0.18699045f, -0.11108223f, 
    0.10295776f, -0.07571848f, -0.09441198f, 0.04610788f, 0.01080860f, 0.09994951f, 0.03813436f, -0.01045193f, 
    -0.16831978f, -0.03000449f, 0.04476176f, -0.03660199f, 0.26625955f, 0.04939076f, -0.10402272f, 0.15106604f, 
    -0.06008692f, -0.01527417f, -0.01855301f, -0.03954695f, 0.08968160f, -0.07657039f, 0.17065832f, 0.08433159f, 
    -0.02625212f, 0.06534533f, -0.04932016f, -0.07517887f, -0.02056437f, 0.10256280f, -0.02090156f, 0.03692554f, 
    0.05198146f, 0.04583390f, 0.08028565f, -0.08415905f, -0.26334959f, 0.08314603f, 0.07892200f, -0.05476345f, 
    -0.00491277f, 0.04467478f, 0.03902202f, 0.08504054f, 0.05396213f, 0.07379775f, 0.03740852f, 0.02897787f, 
    0.14870456f, -0.20788559f, -0.08117417f, -0.06902135f, -0.05372371f, -0.01691573f, 0.01510547f, -0.04790520f, 
    0.01344331f, -0.10241429f, 0.02663561f, 0.00030378f, -0.01439894f, 0.13712494f, -0.06335662f, 0.06243015f, 
    0.10344711f, 0.09134205f, -0.01396378f, 0.02966497f, 0.00424703f, 0.01358171f, -0.03649729f, -0.00537560f, 
    0.09598694f, -0.05911734f, -0.01593231f, 0.05516013f, 0.01459600f, -0.02563383f, -0.02386930f, -0.04267182f, 
    0.04573792f, -0.10493286f, -0.12794718f, -0.05470976f, -0.13619490f, 0.04413476f, -0.05947018f, 0.17553195f, 
    -0.09027926f, -0.13190424f, 0.06208231f, 0.05415194f, -0.00788122f, 0.06908212f, 0.09037872f, 0.07909697f, 
    0.00844654f, 0.14400166f, 0.08589130f, 0.04091084f, -0.05896850f, 0.00740198f, 0.12157300f, 0.10499045f, 
    -0.00963667f, -0.02908874f, 0.02954477f, 0.09798194f, 0.18530412f, -0.00081268f, 0.02805031f, -0.03626795f, 
    0.05335725f, -0.03352641f, -0.00216628f, 0.03937369f, 0.04613077f, 0.15826938f, -0.01946517f, 0.02725936f, 
    -0.10516968f, 0.25711420f, 0.07594129f, -0.01005976f, -0.01040729f, -0.00027180f, 0.02793711f, 0.10336837f, 
    0.14736229f, 0.11678741f, -0.12958576f, 0.08545348f, -0.20330508f, -0.11368093f, 0.00483592f, 0.08066114f, 
    -0.04021249f, 0.11199229f, 0.14716110f, 0.04840416f, 0.07431635f, 0.06370977f, 0.10471657f, 0.11857928f, 
    -0.05525970f, -0.07979877f, 0.15534294f, 0.13313976f, -0.04732930f, -0.07125556f, 0.01049761f, -0.00988158f, 
    0.00433787f, -0.09769420f, -0.11689076f, 0.03732605f, 0.10421094f, 0.10983597f, 0.10089599f, -0.02327054f, 
    -0.03107099f, -0.08812792f, 0.11268125f, -0.01877501f, -0.00774612f, 0.11187012f, 0.07976491f, 0.10269991f, 
    0.02436775f, 0.00364413f, 0.12176985f, 0.07849146f, 0.04530058f, -0.01035888f, 0.02596002f, 0.07137736f, 
    -0.03213324f, -0.05229242f, 0.03077040f, -0.17421003f, -0.12229303f, -0.22033681f, -0.06697687f, 0.36779830f, 
    -0.00176135f, 0.07338622f, 0.02743350f, 0.06253246f, 0.12235242f, -0.08613175f, 0.04074372f, 0.00105456f, 
    -0.02794372f, 0.07769316f, -0.20315219f, 0.17329825f, -0.06311598f, -0.03974235f, 0.06755010f, -0.06262703f, 
    0.04648979f, 0.00659810f, 0.03916545f, 0.02942781f, 0.15249480f, 0.03442869f, 0.18429860f, 0.05769946f, 
    0.15521735f, -0.06851542f, 0.05215900f, -0.03203278f, 0.06186546f, 0.01715167f, -0.08107465f, 0.11735713f, 
    0.06164640f, 0.04718935f, 0.07696593f, 0.13856247f, 0.03906914f, 0.00378285f, -0.01278130f, 0.13600792f, 
    -0.10004436f, 0.03599088f, -0.13247661f, 0.04946114f, 0.25207546f, 0.15361305f, 0.00537493f, 0.06562842f, 
    0.04151363f, 0.08419706f, 0.05267185f, -0.08893166f, -0.04965848f, 0.00021450f, 0.05139145f, 0.03440400f, 
    0.13999321f, -0.00839740f, -0.03758040f, 0.09643926f, 0.00797625f, -0.01123995f, -0.03207333f, -0.14392877f, 
    -0.02930135f, -0.01359785f, -0.00582277f, -0.01141552f, 0.04262282f, 0.04195253f, 0.03522516f, -0.05589067f, 
    -0.02771901f, 0.00634882f, 0.04146178f, 0.06229389f, -0.01220967f, 0.07244058f, -0.00569775f, -0.07656032f, 
    -0.25880498f, 0.03156975f, -0.04676738f, -0.00276087f, 0.03429851f, 0.10083756f, 0.03620037f, 0.03689660f, 
    0.11342937f, 0.04043616f, 0.08136403f, 0.02873679f, -0.27820462f, -0.03572644f, -0.02164723f, -0.09261003f, 
    0.00532336f, 0.00776521f, 0.08073236f, 0.04302344f, -0.13218454f, -0.13704103f, -0.01861391f, 0.23271576f, 
    -0.01404356f, -0.06626485f, -0.16500123f, -0.07741308f, -0.11222176f, 0.02574602f, 0.05966216f, -0.05304310f, 
    0.02624086f, -0.03000881f, 0.05385917f, 0.08917886f, 0.12246391f, -0.17613512f, -0.01171004f, -0.07065020f, 
    0.05845712f, -0.01291037f, 0.13625100f, -0.11061936f, 0.01186038f, 0.07483488f, 0.07436195f, -0.05390338f, 
    -0.08192895f, 0.14527918f, -0.07854374f, -0.08298595f, 0.11881156f, 0.16053367f, 0.04028918f, -0.10981237f, 
    0.01411057f, 0.12102800f, -0.05086508f, -0.05047065f, 0.07423294f, 0.14247034f, 0.00177989f, -0.22773616f, 
    0.05964413f, -0.04434717f, -0.10609352f, 0.04764619f, -0.03537190f, -0.03542434f, 0.01094895f, -0.01221911f, 
    -0.50791186f, 0.13133253f, 0.03124495f, -0.08967999f, -0.02734454f, 0.13626954f, 0.15873399f, 0.00625903f, 
    0.06638566f, 0.01449133f, 0.18772186f, 0.12709022f, -0.06460589f, 0.06152045f, 0.09131116f, -0.27396920f, 
    0.02208403f, 0.00686866f, -0.02917430f, 0.11752145f, -0.03753799f, -0.00393173f, -0.13820642f, 0.05593292f, 
    0.04001832f, 0.07522440f, 0.09995453f, -0.01610862f, 0.05258173f, 0.09454269f, 0.03945491f, 0.10372479f, 
    0.09137557f, -0.05586085f, -0.01381558f, -0.05142376f, 0.26227352f, -0.17740282f, 0.15471047f, 0.11932866f, 
    0.05585435f, 0.05862632f, 0.05498135f, 0.08092362f, -0.02551760f, -0.07366808f, 0.08609737f, 0.05264928f, 
    0.15012981f, 0.00260761f, -0.10433533f, -0.07761078f, 0.03515685f, 0.05886828f, 0.03687428f, 0.02098425f, 
    -0.03323344f, 0.06917634f, 0.04145446f, 0.00983350f, -0.05863818f, -0.01624290f, -0.12797080f, -0.04244178f, 
    0.05030726f, 0.00297756f, -0.07538461f, -0.04152489f, 0.10333302f, -0.10218492f, 0.06756309f, 0.20312224f, 
    0.05475006f, 0.16502525f, 0.16081265f, -0.20713408f, 0.05291947f, -0.05841411f, -0.07931057f, 0.10068456f, 
    0.13931336f, 0.00901216f, 0.09949977f, 0.00864266f, -0.06802479f, -0.12474810f, 0.06077709f, -0.02735746f, 
    0.03901593f, 0.03012625f, 0.06542334f, 0.09816844f, 0.06619386f, -0.01194156f, -0.00680364f, 0.09453530f, 
    0.14994954f, -0.20540234f, -0.03345067f, 0.03941074f, -0.00788855f, -0.05242105f, 0.16949010f, 0.09960156f, 
    -0.01736129f, -0.14685079f, 0.02992404f, 0.08114190f, -0.23186432f, 0.15706851f, 0.17712983f, 0.15671222f, 
    -0.00757532f, 0.16977540f, 0.02891347f, 0.02083050f, 0.07905517f, 0.08712796f, -0.10982130f, 0.07518702f, 
    0.18655062f, -0.10023511f, 0.03674502f, 0.01176308f, 0.01030163f, 0.01111804f, 0.08286829f, -0.01046978f, 
    0.11973988f, -0.02257319f, -0.05860273f, -0.06144482f, -0.13504365f, 0.04502883f, -0.28660017f, 0.05646272f, 
    -0.08835720f, -0.01934646f, 0.10244426f, 0.13079050f, -0.09398863f, 0.09346767f, 0.05496541f, -0.04093423f, 
    -0.24973199f, 0.07400522f, -0.20600829f, -0.06817973f, 0.03489298f, 0.04208295f, -0.00906112f, 0.11650425f, 
    -0.05871638f, -0.02138655f, 0.03387941f, -0.02315787f, 0.11715108f, 0.12769483f, 0.07497776f, -0.31874433f, 
    -0.08774971f, -0.09155675f, -0.09167729f, 0.04082375f, 0.05429436f, 0.09079059f, 0.05651858f, 0.07988873f, 
    0.05394538f, 0.26014560f, 0.24174194f, -0.17308825f, 0.01772218f, -0.00726565f, -0.11072210f, 0.06513283f, 
    0.12134078f, 0.04941148f, -0.07252658f, 0.11173484f, -0.30558887f, 0.09589670f, 0.06559426f, 0.14193973f, 
    0.12710252f, 0.05068942f, 0.14485125f, -0.01585520f, 0.20241992f, -0.00407297f, 0.07265573f, 0.12851177f, 
    -0.06784003f, -0.04751167f, 0.11692147f, 0.14942160f, -0.01756657f, -0.00359440f, 0.03808895f, 0.05759309f, 
    -0.00133165f, -0.05286381f, -0.04169256f, -0.04474724f, -0.05786408f, 0.10197502f, 0.12173224f, 0.05072140f, 
    0.05641859f, -0.00953135f, 0.00038302f, 0.02911778f, 0.14027697f, 0.07916449f, -0.04178444f, 0.08742503f, 
    0.07312483f, -0.08349303f, 0.06971712f, -0.12117702f, -0.06888530f, -0.00214690f, 0.00474090f, -0.05197238f, 
    -0.03227844f, -0.01012045f, 0.00181694f, -0.16406099f, -0.10464458f, -0.23541953f, 0.05118407f, 0.27248067f, 
    0.06219481f, 0.10718831f, 0.01848629f, -0.01821246f, 0.18505645f, -0.10324336f, 0.02130569f, 0.06206983f, 
    -0.00728303f, -0.05806186f, -0.14001079f, 0.15428542f, -0.04129898f, 0.04776052f, 0.02970063f, 0.08367524f, 
    0.10373709f, -0.04722836f, -0.04907472f, -0.01048638f, 0.13342665f, -0.02085308f, 0.23247163f, -0.04407674f, 
    0.11207751f, -0.03726540f, -0.07830475f, -0.04808433f, 0.08552475f, 0.02630017f, -0.11267594f, 0.12204828f, 
    0.23180372f, -0.22003782f, 0.16277589f, 0.13640314f, -0.04629037f, -0.00884539f, 0.03731350f, -0.03773000f, 
    -0.03522231f, 0.01471028f, -0.04086506f, 0.06259912f, 0.04771242f, 0.07848414f, 0.26464802f, 0.02670096f, 
    -0.04246960f, 0.20239492f, 0.18418010f, -0.02707505f, -0.03949011f, 0.02041129f, -0.03045768f, 0.07278266f, 
    0.00184705f, -0.01865701f, -0.11252761f, 0.18698917f, 0.05463097f, 0.05970961f, -0.04588396f, -0.02798704f, 
    -0.02192151f, 0.00860662f, -0.03553023f, -0.09511069f, 0.01884471f, 0.05346538f, -0.14341143f, -0.02814331f, 
    0.02401051f, 0.04715292f, 0.08286831f, -0.01293956f, 0.11987215f, 0.12438951f, 0.08431721f, -0.01444090f, 
    0.25154561f, 0.03498802f, -0.10296149f, -0.06123644f, 0.15542077f, -0.07322589f, -0.02975084f, -0.00938310f, 
    0.14204057f, 0.07980198f, 0.02272875f, 0.03097082f, 0.14946133f, 0.07635541f, 0.02754533f, 0.15644135f, 
    0.01389782f, 0.05095619f, 0.12954536f, 0.00954238f, 0.09506159f, 0.06074157f, 0.12103719f, 0.05534991f, 
    -0.31922150f, 0.00182800f, 0.05075496f, 0.10322226f, -0.15340102f, 0.15622748f, -0.06955703f, -0.00506514f, 
    0.04730115f, -0.05847390f, 0.10490217f, -0.01421719f, -0.01280555f, -0.14641024f, -0.06546118f, -0.13637878f, 
    -0.02522308f, 0.04087164f, 0.03280075f, 0.00001850f, 0.04193690f, -0.00198083f, 0.03901574f, -0.08030541f, 
    -0.19688918f, 0.11988775f, 0.05658397f, 0.03816643f, -0.03544817f, 0.08113958f, -0.07502636f, -0.00627712f, 
    0.12880944f, 0.06293157f, 0.05045578f, 0.00113894f, 0.21175015f, 0.06257473f, 0.06736954f, 0.08531691f, 
    -0.04240207f, -0.01698321f, 0.03014036f, 0.07925118f, 0.03210384f, 0.07839429f, -0.02372387f, 0.01776331f, 
    0.07707184f, -0.17882955f, 0.04687391f, 0.06156043f, 0.22506621f, 0.03257310f, -0.05270756f, 0.08730648f, 
    0.07209385f, -0.07588975f, -0.05616723f, 0.02612727f, 0.32416493f, 0.05803544f, -0.13739310f, 0.11388360f, 
    -0.00277263f, -0.02809415f, -0.01270168f, 0.04957131f, 0.02919414f, -0.04890621f, -0.02114357f, 0.03391394f, 
    0.15845382f, 0.26768062f, -0.02319869f, -0.06757973f, 0.01555832f, 0.05820424f, 0.09987037f, 0.02382794f, 
    0.06490196f, 0.01426498f, -0.07315298f, 0.09640180f, -0.05944588f, 0.04234770f, 0.04138334f, -0.04865860f, 
    0.00544726f, -0.03014482f, 0.03768774f, 0.03156312f, 0.09653823f, 0.02897650f, 0.01552847f, -0.07560158f, 
    -0.01242095f, -0.22405042f, 0.22523886f, 0.08719359f, -0.00326402f, 0.00503365f, -0.02510427f, -0.04115903f, 
    0.04500656f, 0.05233335f, 0.15306404f, 0.07954781f, -0.05874358f, 0.02113072f, 0.05228844f, 0.15439820f, 
    -0.02728773f, 0.13467447f, 0.02277969f, 0.11686691f, 0.06617454f, 0.13929766f, 0.01673839f, 0.00693106f, 
    0.21308754f, 0.15599830f, -0.00922361f, -0.02076835f, 0.08101386f, 0.07641274f, 0.09705143f, 0.13219441f, 
    0.09348234f, -0.04490954f, -0.01300853f, 0.21467361f, -0.04991243f, 0.18508473f, -0.10245666f, 0.00854708f, 
    0.03924926f, -0.01127022f, -0.06604789f, 0.07620744f, 0.09180396f, -0.12136642f, -0.04401586f, -0.13477950f, 
    0.34658596f, 0.02316221f, 0.03396080f, -0.08791228f, 0.27051148f, 0.07628102f, -0.05044087f, 0.17953575f, 
    0.09450261f, 0.14354582f, 0.02780844f, 0.01663692f, 0.14246003f, -0.04545862f, 0.05679574f, 0.04990356f, 
    0.01107019f, 0.00158611f, 0.08351634f, 0.07672385f, 0.15867493f, 0.04870959f, 0.15677178f, 0.08295736f, 
    -0.00758998f, 0.10559501f, 0.01128947f, 0.00556393f, 0.02990210f, 0.19201516f, 0.12874876f, 0.05495303f, 
    0.02257535f, 0.16272980f, -0.00570130f, 0.07248288f, 0.11855573f, 0.12737432f, -0.01234187f, -0.35487896f, 
    0.13664709f, 0.10546380f, 0.02355588f, 0.03731935f, 0.00735340f, -0.08445261f, 0.10443383f, -0.00840034f, 
    0.24445456f, 0.03152617f, -0.01804194f, 0.21844064f, -0.01548339f, 0.08026447f, 0.00208483f, 0.01966832f, 
    0.20959358f, 0.04609755f, 0.05919209f, -0.02307180f, 0.48520499f, 0.16550392f, -0.01851426f, 0.06988255f, 
    -0.10272543f, 0.03037527f, 0.11628938f, 0.04118849f, -0.01986877f, 0.11450982f, -0.00122531f, -0.01534453f, 
    0.47359401f, 0.20660768f, 0.03632655f, 0.15005133f, -0.02787481f, -0.05628077f, 0.01296705f, -0.02768922f, 
    0.02666375f, -0.02101681f, 0.01566009f, 0.04764919f, 0.24785128f, -0.06292153f, 0.10554598f, 0.02221677f, 
    0.01947212f, 0.03673558f, 0.12101816f, 0.05668131f, 0.01437365f, 0.06587178f, 0.05815583f, -0.00135578f, 
    0.00110368f, 0.11503530f, 0.06691266f, 0.11457150f, 0.04735036f, 0.04089947f, -0.05280353f, 0.01328657f, 
    -0.05259700f, 0.05962900f, 0.07972732f, -0.03588723f, 0.14581248f, -0.03524952f, -0.10815131f, 0.09622218f, 
    0.08801451f, 0.15429375f, 0.06355014f, 0.07368737f, 0.14864652f, 0.04853841f, 0.04061152f, 0.13033479f, 
    0.18729083f, 0.15230240f, -0.34491217f, -0.00740017f, 0.10564492f, 0.04726734f, -0.04198430f, 0.13642731f, 
    0.01536699f, 0.04918076f, -0.01361326f, 0.01367568f, 0.28788188f, -0.11599180f, 0.08672120f, -0.32203737f, 
    0.09907862f, -0.01291492f, 0.19849333f, -0.03192405f, -0.11018262f, 0.08378477f, 0.03081897f, 0.08290119f, 
    0.13454859f, 0.05886751f, 0.06777529f, -0.21634333f, 0.08066251f, 0.02398277f, 0.06285382f, 0.10553626f, 
    0.02576325f, -0.01977164f, -0.03931993f, 0.11382727f, 0.09870173f, 0.19645505f, -0.05667946f, 0.15199853f, 
    0.02532857f, -0.01315377f, 0.06507056f, 0.10764083f, -0.02913540f, -0.01121580f, 0.07948977f, 0.10636469f, 
    0.16393547f, -0.02417754f, -0.03755305f, -0.07021895f, 0.01321438f, 0.06166018f, 0.08985124f, 0.05814705f, 
    0.06361324f, 0.10029660f, 0.20446149f, 0.04972969f, 0.13345484f, 0.19163266f, -0.07902163f, -0.10536543f, 
    0.06965840f, -0.07403741f, -0.02358014f, 0.00753852f, -0.08365811f, 0.08089044f, 0.00809883f, 0.11217279f, 
    -0.01664900f, -0.15736616f, -0.03312704f, 0.01344270f, -0.04783196f, 0.03421906f, 0.07987966f, 0.01902328f, 
    0.13275284f, 0.02856819f, -0.02448190f, -0.01703365f, -0.35559523f, 0.13309345f, -0.11066076f, 0.12576893f, 
    -0.10284746f, 0.03028643f, 0.03556116f, -0.04909959f, -0.01195014f, 0.06551949f, 0.01252371f, 0.03850789f, 
    0.19811754f, 0.09725060f, -0.22136308f, -0.13813092f, 0.10119829f, 0.03028462f, -0.00035182f, -0.05356042f, 
    -0.03327439f, -0.05396727f, -0.05695615f, 0.01344937f, 0.18964535f, 0.23703633f, 0.05820414f, 0.06962881f, 
    0.02551968f, -0.02732414f, 0.00637165f, 0.00389665f, 0.11000760f, -0.00607498f, 0.00068887f, -0.09196874f, 
    -0.43415540f, -0.20812729f, 0.16402739f, 0.36478263f, 0.09491537f, -0.04501430f, -0.04874627f, 0.06505617f, 
    0.11986480f, -0.01329154f, 0.03426969f, -0.11496092f, -0.01834581f, -0.14126562f, -0.20424102f, -0.02082771f, 
    0.12254876f, 0.11724011f, -0.09638472f, -0.09747558f, 0.15426861f, 0.00877272f, -0.01441851f, -0.00205814f, 
    -0.15084462f, -0.02021437f, -0.01033454f, 0.27251512f, -0.00083603f, 0.08447344f, 0.13913497f, 0.07728644f, 
    0.00475186f, 0.04604854f, 0.04473919f, 0.07914747f, 0.07897290f, 0.12710564f, 0.11270350f, 0.12557325f, 
    -0.16998872f, 0.11131110f, 0.04306153f, 0.01627758f, 0.02568904f, -0.02191456f, 0.01223622f, 0.05023891f, 
    0.13171224f, -0.07963777f, 0.03664411f, 0.04895750f, 0.01164491f, -0.10463715f, -0.04187053f, -0.08713740f, 
    0.04887286f, -0.14298098f, -0.16951112f, -0.04067314f, 0.17233147f, 0.06349751f, 0.01873269f, -0.06888508f, 
    0.02762683f, -0.02668132f, 0.01992327f, -0.03015936f, 0.03199777f, -0.02756843f, 0.05587137f, 0.12546565f, 
    0.18571658f, 0.08272361f, 0.05976277f, 0.03574114f, -0.04528519f, -0.07225293f, 0.01808554f, 0.00333077f, 
    -0.19907251f, 0.07170089f, 0.08505493f, 0.08524575f, -0.06157017f, 0.00125337f, 0.14610702f, 0.01708737f, 
    0.00676094f, 0.13023061f, 0.05883803f, 0.00820186f, 0.04542494f, 0.04402290f, 0.03033028f, -0.02540039f, 
    0.11607240f, -0.12038589f, 0.04675617f, 0.04004558f, 0.08926386f, -0.06592597f, -0.00539549f, 0.02582972f, 
    0.07674465f, 0.06054597f, 0.08840320f, 0.18434662f, -0.25146386f, -0.02972639f, 0.17796944f, 0.35148495f, 
    -0.07194939f, 0.10152058f, 0.05483095f, 0.08448062f, -0.11108737f, 0.03105132f, 0.04528789f, -0.02016178f, 
    0.13434704f, 0.11698713f, -0.01867236f, -0.00660935f, 0.08700862f, 0.01161834f, 0.02491409f, 0.07853503f, 
    -0.02015743f, 0.05534260f, -0.15133953f, 0.21190134f, 0.29331097f, 0.16746859f, -0.00586921f, -0.02901131f, 
    0.14514534f, -0.00325764f, -0.14387415f, -0.02839360f, 0.16989677f, 0.01043882f, -0.03128158f, -0.04883845f, 
    0.03059921f, 0.14341201f, -0.26878360f, -0.16249812f, 0.22491270f, 0.13720109f, -0.06979141f, -0.07697506f, 
    0.12797146f, 0.14921373f, 0.02112859f, 0.00867488f, -0.02504382f, -0.03421440f, 0.05016258f, -0.01931958f, 
    -0.14466833f, -0.13700724f, 0.06790966f, 0.10841072f, 0.07842937f, -0.03947804f, 0.13896473f, 0.06388194f, 
    -0.02571110f, 0.00140479f, -0.02194516f, 0.10400176f, -0.02113571f, 0.06496222f, -0.07188319f, 0.09664900f, 
    -0.02457189f, 0.06711156f, 0.17031865f, 0.15772633f, 0.32485273f, -0.06176843f, 0.12256199f, -0.27907428f, 
    0.11373544f, 0.18622422f, -0.05128333f, 0.10337075f, -0.00089022f, -0.00725177f, 0.03387732f, -0.06003422f, 
    -0.20429382f, -0.04518789f, -0.00561385f, 0.15369278f, -0.03198773f, 0.03454568f, -0.07737064f, 0.06351186f, 
    0.04406702f, 0.08375592f, -0.03722697f, -0.09169536f, 0.17084171f, 0.03342323f, 0.04843769f, 0.22118638f, 
    -0.15633076f, 0.00116490f, 0.16554201f, 0.01892196f, -0.04803557f, -0.02102337f, -0.08106101f, 0.11161880f, 
    0.25011092f, 0.05906063f, 0.03106007f, 0.12014385f, -0.00117148f, -0.10076529f, 0.03917143f, -0.04284120f, 
    -0.05524777f, 0.01259786f, 0.00863612f, -0.03173316f, 0.25528437f, -0.05675723f, 0.06424226f, -0.04327713f, 
    -0.16205816f, 0.02265742f, 0.01012035f, -0.00563701f, -0.05510430f, -0.01004413f, -0.03651746f, -0.10929333f, 
    -0.09307937f, 0.03698321f, 0.05102066f, 0.09347948f, 0.11154351f, 0.11813045f, -0.09500699f, 0.04876795f, 
    0.07458013f, 0.05546897f, 0.07720490f, 0.08924578f, -0.07851282f, -0.04712610f, -0.16337208f, -0.07200877f, 
    0.03784993f, 0.13750240f, 0.14760628f, 0.10117631f, 0.02368547f, -0.04374717f, 0.05008870f, -0.05475315f, 
    -0.00353331f, 0.03595170f, -0.05300791f, 0.16034225f, -0.11737444f, -0.00453169f, -0.05628281f, 0.13110386f, 
    0.04217874f, -0.03577457f, 0.02666746f, 0.11276569f, 0.13936873f, -0.20883153f, 0.21434380f, -0.25158054f, 
    -0.01837467f, -0.01481199f, 0.11693100f, 0.06577922f, -0.04284021f, 0.07529659f, -0.03274823f, -0.03458111f, 
    0.38348213f, -0.06552964f, 0.09475492f, -0.23695630f, 0.12715986f, 0.05338172f, -0.01903492f, 0.04774354f, 
    -0.03264813f, 0.02013155f, 0.05100848f, -0.00721341f, 0.09786676f, 0.21010211f, -0.08451974f, 0.16643873f, 
    -0.04556423f, -0.01828137f, 0.01413586f, 0.08694129f, -0.12592648f, -0.07816555f, 0.15587877f, 0.02483678f, 
    -0.20930365f, -0.12466381f, 0.08853706f, -0.12181939f, -0.03245133f, -0.00724463f, -0.01926313f, -0.10355958f, 
    0.15326770f, -0.00764133f, 0.15971066f, -0.01223578f, 0.11919840f, 0.13502733f, -0.04226003f, 0.01253712f, 
    0.03060084f, -0.05552386f, -0.01910280f, 0.09764414f, -0.14017290f, 0.02743844f, 0.00283513f, -0.06302103f, 
    0.18982643f, -0.17037506f, 0.03997452f, 0.03970714f, -0.01326049f, 0.00703026f, 0.04234607f, -0.05436886f, 
    0.08010979f, 0.06023391f, -0.07935471f, -0.06428120f, -0.18872692f, 0.28164658f, -0.14317647f, 0.15554307f, 
    -0.06683202f, -0.04890926f, -0.04476609f, 0.06982616f, -0.01305703f, 0.00109255f, -0.05593596f, -0.05257853f, 
    0.21162863f, 0.19508092f, 0.04513185f, -0.04012610f, 0.01698753f, 0.08574642f, 0.15554237f, -0.01503246f, 
    -0.03863939f, -0.00872869f, -0.06919280f, -0.07757716f, -0.14601251f, 0.05824516f, -0.06043943f, -0.15363851f, 
    -0.12939517f, -0.05689260f, -0.10548129f, -0.05250430f, 0.06893484f, 0.01410823f, 0.07376616f, -0.01034658f, 
    0.07284089f, -0.05850960f, 0.08461642f, 0.07581820f, 0.19296446f, 0.10185952f, 0.02628257f, -0.01788248f, 
    -0.06210703f, 0.00572318f, -0.02125646f, -0.08552516f, 0.08714783f, 0.20218828f, -0.07211261f, 0.16688494f, 
    0.19702786f, 0.16730973f, 0.05999523f, 0.00899181f, 0.06616808f, -0.00450504f, 0.03400144f, 0.01509617f, 
    0.40878990f, 0.01156279f, 0.08521115f, 0.22832969f, 0.18829827f, 0.08886757f, 0.01073692f, 0.08570395f, 
    -0.04754788f, 0.04937598f, 0.07797214f, 0.05557428f, -0.22583055f, -0.22080328f, -0.03912889f, -0.01480160f, 
    -0.16000403f, -0.00395713f, 0.00946512f, -0.00233099f, 0.03900468f, 0.09392763f, 0.05489210f, 0.01279564f, 
    -0.03583835f, -0.11463211f, -0.09995148f, 0.02281310f, -0.13508707f, -0.07884694f, -0.00303158f, -0.10337343f, 
    0.02426368f, -0.06626309f, 0.08151893f, 0.01775240f, -0.20222057f, -0.06737119f, -0.01452970f, -0.13522443f, 
    -0.06491651f, -0.05756722f, 0.04074266f, 0.03595716f, 0.06276646f, -0.05750730f, 0.00537625f, 0.02235978f, 
    0.23139815f, -0.02029427f, 0.01532799f, 0.11484458f, -0.02244531f, -0.18343845f, -0.03131427f, 0.00361085f, 
    0.08792135f, -0.00900530f, -0.04075137f, -0.01984869f, 0.13736543f, 0.04748044f, 0.15813261f, 0.04575261f, 
    0.06629783f, 0.02539110f, -0.08905771f, -0.06508844f, -0.03471671f, -0.02181087f, 0.02746324f, 0.04907335f, 
    -0.21111555f, 0.06777710f, -0.06681881f, -0.03758986f, -0.01568514f, -0.04767365f, 0.01090680f, 0.00783354f, 
    0.02896390f, -0.02061156f, 0.01115999f, 0.00973569f, 0.16855326f, 0.31972879f, 0.12227721f, 0.08112466f, 
    0.04062294f, -0.14706850f, 0.05488675f, -0.07800865f, -0.12030808f, -0.05747698f, -0.07084277f, -0.03999714f, 
    -0.23921105f, -0.08629112f, -0.11307375f, -0.05146360f, 0.01117571f, -0.06536802f, -0.01874275f, -0.07092658f, 
    -0.16518511f, 0.08379191f, -0.05334795f, 0.11212124f, 0.21647564f, -0.07370971f, -0.05745225f, -0.17194739f, 
    -0.10243928f, 0.02475540f, 0.05125415f, -0.07080721f, -0.02370333f, 0.01372711f, -0.05590788f, 0.15183148f, 
    -0.02975292f, 0.12713118f, -0.04469162f, 0.05024712f, -0.01347314f, 0.14201424f, 0.02284973f, -0.00980386f, 
    -0.00168134f, 0.01048801f, 0.08085202f, -0.05612517f, -0.01214165f, 0.02608887f, -0.22465694f, -0.15768215f, 
    -0.09984291f, -0.12921168f, -0.00980681f, 0.02111475f, -0.02925977f, -0.08537199f, 0.00539792f, 0.02257167f, 
    0.24705112f, 0.21556619f, 0.13768753f, 0.11900395f, 0.12885006f, -0.01540306f, -0.02036557f, -0.10724357f, 
    0.01202326f, -0.10348098f, 0.00040116f, -0.10901219f, 0.21596864f, -0.01717987f, 0.13993400f, 0.28345969f, 
    -0.00211109f, 0.10765611f, 0.06024930f, -0.08755848f, -0.03093321f, 0.06828161f, -0.09658433f, -0.06843780f, 
    -0.07564285f, -0.08782697f, 0.12477032f, -0.07926330f, -0.11151603f, 0.04037182f, -0.00586755f, 0.04039342f, 
    -0.06919051f, 0.13248155f, -0.10785418f, 0.02898225f, -0.42440495f, -0.23843080f, -0.04561245f, -0.02188034f, 
    -0.01013659f, -0.01235910f, -0.03643998f, -0.00639648f, -0.01817117f, 0.01013669f, 0.01224290f, 0.04032600f, 
    -0.48552734f, -0.22261438f, -0.14646654f, -0.10640751f, -0.08003899f, -0.06455600f, -0.02772406f, 0.07716533f, 
    0.01693976f, -0.03403286f, -0.06266806f, -0.02782477f, -0.12763411f, 0.02781391f, -0.16781673f, -0.02152805f, 
    -0.04248558f, -0.03630581f, -0.01298641f, -0.11568661f, 0.05168154f, -0.08048167f, -0.02141426f, -0.03189630f, 
    0.13194466f, -0.05155455f, 0.04847170f, -0.01577251f, 0.01945451f, 0.20830350f, 0.04322314f, 0.02742189f, 
    0.06024722f, 0.01629179f, -0.04164213f, 0.01993797f, -0.13285440f, 0.09554428f, -0.06739497f, -0.06556285f, 
    -0.01410703f, -0.00686619f, -0.00073614f, 0.08955807f, -0.09404089f, -0.06402592f, 0.00993801f, -0.02798893f, 
    0.01613159f, 0.07882652f, 0.29556724f, 0.11269430f, -0.04493991f, -0.02377222f, 0.00915999f, -0.00126873f, 
    -0.05678575f, -0.02452775f, -0.07837587f, 0.14561342f, -0.10930233f, 0.08292361f, -0.10299321f, 0.15317954f, 
    -0.10179213f, -0.04006550f, -0.05227563f, 0.10750612f, -0.03968716f, 0.04082932f, -0.03634254f, -0.01956988f, 
    0.27753091f, 0.12319353f, 0.21762159f, 0.13345535f, 0.12136594f, 0.04469907f, 0.03341126f, 0.02225262f, 
    0.01399088f, 0.12099293f, 0.02215014f, 0.00452040f, 0.11656051f, 0.02931535f, 0.09890802f, 0.07924637f, 
    -0.06342187f, 0.05677014f, -0.01921022f, 0.00242282f, -0.03430437f, 0.04616791f, -0.06232852f, -0.06283563f, 
    -0.33172354f, 0.06619791f, -0.05714758f, -0.01170045f, 0.13812564f, -0.01697652f, -0.09955601f, 0.01753563f, 
    0.09604681f, 0.02871589f, -0.07965103f, 0.09115389f, 0.27783665f, 0.12056387f, 0.14544131f, 0.24785678f, 
    0.06540761f, -0.01777045f, -0.11370362f, 0.05806826f, 0.01278431f, -0.05503911f, -0.03090413f, -0.02897909f, 
    0.22784871f, 0.29842666f, 0.19971719f, 0.18461500f, 0.07006565f, 0.00803845f, -0.08042184f, -0.04703431f, 
    -0.11750582f, -0.00548571f, -0.03313790f, -0.09101634f, 0.32565644f, 0.04991307f, 0.28674367f, 0.05667249f, 
    0.15517931f, 0.06659950f, -0.01522666f, 0.08902093f, -0.00926128f, -0.00081533f, -0.05887404f, -0.02138989f, 
    -0.52326888f, -0.04106602f, 0.11967164f, 0.20017411f, -0.04005824f, 0.16676418f, 0.11628466f, 0.14616710f, 
    -0.02436303f, -0.01177330f, 0.08160199f, 0.04991774f, -0.05023263f, -0.00911979f, -0.00881182f, -0.11389224f, 
    0.05631730f, -0.04876751f, -0.03987188f, 0.10818991f, -0.01365042f, 0.01478654f, -0.02024593f, 0.02078266f, 
    0.29203895f, 0.19485046f, 0.00544113f, -0.21703348f, 0.11229605f, -0.03122520f, 0.06404627f, 0.06819607f, 
    0.02679704f, 0.17605714f, 0.02679880f, 0.12366964f, 0.15317588f, 0.25359741f, 0.05147474f, 0.24295634f, 
    0.03573117f, 0.14482087f, 0.05028449f, 0.10795766f, -0.03880031f, 0.06346424f, 0.08833459f, 0.15980724f, 
    0.19885381f, 0.02917336f, 0.05970036f, -0.10885972f, 0.12302712f, 0.01320866f, 0.05617927f, 0.00510755f, 
    0.02018118f, 0.07971113f, 0.08225746f, 0.05470113f, 0.11734471f, 0.01072575f, 0.08614883f, 0.11594451f, 
    0.07204883f, 0.06618352f, -0.04671701f, -0.00735678f, 0.08381817f, -0.00398284f, 0.07518535f, 0.04415247f, 
    0.08645283f, 0.07311785f, 0.03188260f, -0.02014147f, -0.11367315f, 0.08146659f, 0.19152327f, 0.04477894f, 
    -0.05905350f, 0.11024432f, 0.07962243f, -0.03138398f, -0.01105430f, -0.00281204f, 0.12906167f, 0.13734578f, 
    -0.01314772f, -0.01109002f, -0.00663325f, -0.04199345f, 0.04280182f, 0.06485566f, 0.09141828f, 0.08384676f, 
    -0.04242397f, -0.10930996f, 0.12291636f, 0.27274430f, 0.06250262f, 0.08545689f, -0.02999059f, 0.11547542f, 
    0.20284212f, 0.02265970f, 0.13392489f, 0.01130930f, 0.27043599f, 0.07832364f, -0.03241602f, 0.08795515f, 
    0.01472117f, 0.07698132f, 0.02802699f, 0.02469555f, 0.01054675f, 0.13145769f, 0.07023857f, 0.09383524f, 
    -0.01814655f, 0.08226252f, -0.01231284f, 0.00671730f, 0.07209035f, 0.11104316f, 0.09437355f, 0.15551114f, 
    0.06161970f, -0.06133697f, -0.15198401f, -0.06926593f, 0.25347823f, 0.03853111f, 0.06910755f, -0.14186050f, 
    0.06131446f, -0.03259926f, 0.00605335f, -0.10516085f, 0.02967290f, -0.01783530f, 0.03154769f, 0.04808680f, 
    -0.02026802f, -0.03885045f, 0.00347484f, 0.27094460f, 0.04447830f, -0.01061941f, -0.01804404f, -0.02579503f, 
    0.04837544f, 0.12414882f, 0.02131556f, -0.17911358f, 0.01292372f, -0.10177212f, 0.04940662f, -0.03511289f, 
    -0.06403316f, 0.09656411f, 0.08198706f, -0.09625972f, -0.11915332f, 0.12144927f, 0.08837332f, 0.17919481f, 
    -0.37742057f, -0.15641841f, 0.18861084f, 0.17517151f, -0.08957303f, -0.04589249f, 0.12460392f, 0.01187874f, 
    -0.04515028f, -0.03623620f, 0.09675605f, 0.02258244f, 0.19215693f, 0.00689886f, -0.11358888f, 0.22779784f, 
    0.00729294f, 0.12908167f, 0.00466656f, -0.01464020f, 0.06223366f, 0.03873153f, -0.03426508f, 0.04593599f, 
    0.06862402f, -0.06834187f, 0.08439541f, 0.10655499f, 0.03864803f, -0.04794436f, 0.03001277f, -0.05787933f, 
    0.13457990f, -0.12061895f, 0.05981291f, -0.04912834f, -0.25012451f, 0.18841648f, 0.00091425f, 0.34036693f, 
    0.01485100f, -0.09089035f, 0.09173754f, -0.08485810f, 0.13051234f, 0.13519347f, 0.07472410f, 0.13324142f, 
    -0.37634832f, 0.16052765f, 0.12088961f, -0.17088102f, 0.09743788f, 0.00393569f, 0.05747944f, 0.04634030f, 
    -0.10666896f, 0.02202810f, -0.03538103f, 0.03029222f, -0.17690368f, -0.14931035f, 0.12232525f, 0.19777334f, 
    0.24162753f, 0.03162591f, -0.06013279f, -0.06255108f, 0.23627043f, 0.05147704f, 0.11126740f, 0.07028757f, 
    -0.16498299f, -0.15490247f, 0.06248702f, 0.05185578f, 0.13330357f, 0.09000459f, -0.05126296f, 0.06375917f, 
    0.14679489f, 0.06216559f, 0.05333849f, 0.10128824f, -0.07522461f, 0.08040901f, -0.04439725f, 0.06657681f, 
    0.08998448f, 0.08070945f, 0.00563541f, -0.01095764f, 0.09771479f, 0.01860666f, 0.07593483f, 0.10002377f, 
    -0.00188237f, 0.00861496f, 0.05082512f, -0.10123961f, 0.10584918f, 0.00650507f, 0.17709869f, 0.04452944f, 
    -0.01109626f, -0.09230440f, 0.06604125f, 0.03256379f, -0.00163374f, 0.27540284f, 0.18498842f, 0.01251476f, 
    0.05549101f, 0.01577232f, 0.08715104f, 0.04357267f, -0.04784650f, -0.02550075f, 0.04473785f, 0.01348722f, 
    0.02527405f, 0.17777212f, 0.36793751f, 0.28969920f, 0.01102685f, -0.03585660f, 0.10701231f, -0.04570564f, 
    -0.00118450f, 0.08208504f, 0.00388400f, 0.09883004f, -0.06386446f, 0.16402379f, -0.29362044f, 0.38046348f, 
    0.06004402f, 0.12972640f, 0.00876616f, 0.05654217f, 0.14896049f, 0.00783083f, -0.03841775f, -0.09798678f, 
    -0.17997174f, 0.07616055f, -0.10313316f, 0.32790297f, 0.08491983f, -0.08173866f, 0.00620165f, 0.06454665f, 
    0.19254386f, 0.04206205f, 0.12296735f, -0.04027068f, 0.01061543f, -0.14942646f, 0.28180784f, -0.06635783f, 
    0.14886135f, 0.07761580f, -0.04425709f, -0.02672534f, 0.08396098f, 0.07001269f, 0.01765531f, -0.04435344f, 
    -0.20523837f, 0.27040830f, -0.14931072f, 0.19281651f, -0.01446474f, 0.03738964f, -0.04696436f, 0.07350630f, 
    0.00175968f, 0.00269878f, -0.10886468f, -0.00141632f, 0.12292930f, -0.06185407f, 0.09088473f, 0.29927814f, 
    0.02024256f, 0.07227527f, 0.02368632f, 0.10049091f, 0.29302141f, -0.07242853f, 0.09083448f, 0.04143712f, 
    0.03385358f, 0.29943919f, 0.10400249f, 0.10003144f, 0.13014627f, 0.06611265f, 0.01647043f, -0.00920768f, 
    0.00233827f, 0.13259350f, -0.00178126f, 0.10334958f, 0.24476868f, -0.18756667f, 0.28225884f, -0.21808888f, 
    0.16118085f, 0.12649080f, 0.04672165f, 0.13735296f, 0.00594690f, 0.01326933f, 0.05032844f, 0.08815310f, 
    0.07857241f, -0.27061671f, -0.04560183f, -0.04607372f, -0.05322859f, -0.06577307f, -0.00455663f, -0.01186579f, 
    -0.01507025f, -0.00428405f, -0.04461352f, 0.07243071f, 0.18525293f, 0.01055869f, 0.06655084f, 0.23217368f, 
    0.00002401f, -0.08329748f, -0.03837089f, 0.04868340f, 0.18885849f, 0.00121072f, 0.09184784f, -0.01328148f, 
    -0.16379815f, 0.08363012f, -0.16888948f, -0.22693953f, -0.01072164f, 0.14671724f, -0.05092483f, -0.00880929f, 
    0.01693350f, -0.04443852f, -0.00611488f, -0.04661094f, -0.11033312f, 0.00745954f, -0.06870490f, -0.05821590f, 
    -0.11014161f, 0.01947975f, 0.00512101f, 0.10933356f, 0.09281036f, 0.10332717f, 0.05154767f, 0.10963958f, 
    0.07493255f, -0.04790636f, 0.05059886f, -0.07400250f, -0.08103403f, -0.06092250f, 0.10227548f, 0.11310004f, 
    -0.10759210f, -0.08613393f, 0.09492677f, 0.16220240f, -0.15774028f, -0.02910562f, 0.14492194f, 0.20598014f, 
    -0.01084467f, 0.06554729f, 0.03379638f, 0.06435070f, 0.14379556f, 0.07546129f, -0.00203296f, 0.06396428f, 
    0.33008510f, -0.19396180f, 0.07807764f, 0.13915859f, 0.07213256f, -0.00754135f, -0.00718186f, -0.00145079f, 
    0.07843429f, -0.10802900f, -0.23569043f, 0.02246383f, 0.00380514f, 0.05064398f, 0.05105279f, 0.08557221f, 
    -0.01166340f, -0.06751072f, 0.02526150f, 0.00155906f, 0.04491759f, -0.00117692f, 0.10871371f, 0.08036706f, 
    0.11722155f, -0.23126797f, -0.03335405f, 0.05054869f, 0.01869373f, 0.05849531f, 0.07272372f, 0.05688396f, 
    0.09750082f, 0.00305100f, 0.10536584f, 0.13856086f, 0.13291636f, 0.04080785f, -0.04251986f, 0.06565358f, 
    -0.11871444f, 0.01488681f, 0.00618974f, -0.06813382f, 0.08959709f, -0.05570077f, -0.01996801f, 0.01498483f, 
    -0.02449647f, 0.07520939f, 0.09422273f, 0.05002945f, -0.01672281f, -0.06447026f, 0.07893481f, -0.06923845f, 
    0.05092262f, 0.00283471f, 0.01221575f, 0.02287714f, -0.10371759f, -0.01303363f, 0.12004528f, -0.05713619f, 
    0.12446796f, 0.07662239f, 0.04493207f, 0.03426736f, -0.07909979f, 0.14603546f, 0.06257553f, -0.08677820f, 
    -0.08392120f, 0.06706325f, 0.00748390f, 0.12329946f, 0.06716879f, 0.01797919f, 0.05382112f, 0.02124161f, 
    -0.15721637f, 0.01456747f, -0.06814361f, 0.02036447f, 0.03553946f, -0.05441653f, 0.01456539f, -0.02516519f, 
    0.11341155f, 0.02886705f, 0.01526550f, -0.14135641f, -0.08286121f, -0.07164730f, -0.03288988f, 0.06162682f, 
    0.19071060f, 0.03550511f, -0.14800406f, 0.01379842f, 0.08342040f, -0.01934265f, -0.02130820f, 0.05927877f, 
    -0.08582646f, 0.14596128f, -0.01881084f, -0.06692839f, 0.04791576f, -0.19157718f, -0.01632348f, 0.04496150f, 
    -0.07253459f, -0.07601713f, -0.06154983f, -0.03810548f, -0.01517291f, -0.10034148f, 0.03326862f, 0.03709245f, 
    0.12091678f, -0.08226205f, 0.00461059f, -0.07492658f, 0.05751387f, 0.15465376f, 0.12970577f, -0.00301492f, 
    -0.05859096f, 0.11786699f, 0.14479199f, 0.03956962f, 0.22906350f, -0.02209364f, -0.06982440f, -0.04352909f, 
    -0.03255564f, -0.05357433f, -0.01533036f, 0.06075498f, 0.02567882f, 0.01757119f, 0.10413643f, -0.09284812f, 
    -0.20738831f, 0.05748267f, 0.10104960f, -0.02066992f, -0.06951329f, 0.00285420f, -0.05988217f, -0.08198999f, 
    0.03721483f, 0.12107304f, 0.00678475f, -0.07632368f, -0.20879519f, -0.09333313f, 0.04174130f, 0.21918488f, 
    0.11057793f, 0.13273782f, 0.04381190f, 0.02059450f, 0.09538142f, -0.06646526f, 0.03711951f, 0.02509086f, 
    -0.16504268f, -0.17467712f, 0.02298000f, 0.07846052f, 0.09857138f, 0.04275138f, 0.03970632f, -0.04568066f, 
    -0.09342642f, -0.09595606f, 0.05838042f, 0.01321324f, 0.05198128f, -0.13237244f, -0.04433516f, 0.02841430f, 
    -0.03323003f, 0.04600943f, -0.04723698f, -0.05066190f, 0.02387127f, -0.10363113f, -0.04210548f, -0.03480457f, 
    0.26802209f, -0.16337757f, -0.03341030f, -0.06651598f, -0.14669216f, 0.14980638f, -0.01373135f, 0.01498360f, 
    0.02406253f, 0.10239293f, 0.06033004f, -0.06300005f, 0.15245752f, -0.01336810f, -0.22787540f, 0.07944538f, 
    0.06040513f, -0.00502120f, 0.08254622f, 0.03525953f, 0.04653589f, 0.04769615f, 0.10537221f, 0.09624960f, 
    -0.29289824f, 0.40999404f, 0.06963059f, -0.12523517f, 0.01012784f, 0.08044121f, 0.04300059f, 0.05179220f, 
    0.05154520f, 0.03154214f, 0.03005236f, 0.17022830f, 0.01542446f, -0.11219259f, 0.07209460f, -0.17984442f, 
    -0.03189874f, -0.04471596f, -0.02343776f, 0.03511699f, -0.01153360f, 0.12994169f, 0.10275993f, -0.05651069f, 
    0.12220222f, -0.04720827f, 0.11433350f, -0.08743664f, 0.02538268f, -0.21431851f, 0.09350895f, 0.11514986f, 
    -0.01277466f, 0.08460343f, 0.11646753f, 0.05223549f, -0.36273703f, 0.01683298f, 0.08336630f, 0.07706996f, 
    0.02414511f, 0.12222812f, -0.00516203f, 0.09160113f, 0.06007470f, -0.10567683f, 0.17484191f, 0.02859352f, 
    -0.41640663f, 0.27937368f, -0.16915722f, -0.05856362f, 0.02269866f, 0.00936966f, 0.03167052f, 0.09625553f, 
    0.17492954f, 0.03904095f, 0.10158015f, 0.02078017f, 0.03366288f, -0.00945181f, -0.09532943f, 0.11230466f, 
    0.08316939f, -0.04069312f, 0.10800527f, 0.15277220f, -0.02157994f, -0.02855641f, 0.07782837f, 0.07925905f, 
    0.03752507f, -0.10469781f, 0.07631384f, -0.07288204f, -0.09321409f, 0.05353545f, 0.02846016f, 0.10225075f, 
    0.05462859f, 0.07392848f, -0.02626543f, 0.02039962f, -0.23520498f, 0.04870356f, 0.01282256f, 0.05324348f, 
    0.03937281f, -0.04379940f, -0.05211057f, -0.03398588f, -0.10447087f, -0.07827403f, -0.06738731f, 0.13534065f, 
    0.44059971f, -0.01899997f, 0.15629707f, 0.02667934f, -0.05253005f, -0.07869551f, 0.00016978f, -0.11916986f, 
    0.08398287f, 0.02947935f, -0.09331661f, 0.05823757f, 0.40851414f, -0.09961683f, -0.03828280f, 0.18033549f, 
    -0.09758753f, 0.03884701f, -0.00703810f, -0.04042795f, 0.07401201f, 0.07088493f, 0.11699094f, 0.02128800f, 
    -0.18181691f, -0.06492760f, -0.08041821f, -0.09952807f, -0.02366538f, 0.17206086f, -0.10814989f, -0.13081114f, 
    -0.05606973f, -0.09394019f, -0.02118217f, -0.02638715f, -0.08157652f, 0.23926297f, -0.02474833f, -0.10236268f, 
    -0.10299545f, -0.02122108f, -0.02866678f, 0.15578081f, -0.09896459f, -0.07532794f, 0.06772932f, -0.01556736f, 
    0.00039648f, 0.11965678f, 0.27283731f, -0.17199312f, -0.00351402f, 0.08046967f, -0.01274267f, -0.00213542f, 
    0.06126191f, -0.05015416f, 0.03288164f, 0.00974739f, -0.11209012f, -0.04308383f, -0.07805209f, 0.02664636f, 
    0.01872667f, -0.02454788f, -0.03733518f, 0.04051706f, -0.00359336f, 0.12572876f, 0.01508528f, 0.09147963f, 
    0.19574782f, -0.17401418f, 0.01145745f, 0.20375746f, 0.16504359f, -0.05750598f, -0.03466687f, 0.07091089f, 
    0.12179434f, -0.07426635f, -0.05601073f, -0.00874331f, 0.05568081f, -0.13534699f, -0.02410031f, 0.09321506f, 
    -0.05473572f, -0.02998201f, -0.08426080f, 0.07974976f, -0.06545126f, -0.02716942f, 0.02225721f, -0.07058311f, 
    -0.02503485f, 0.05637171f, -0.18083969f, -0.19441625f, -0.02836393f, -0.04336265f, 0.06423754f, -0.04766762f, 
    0.15284710f, -0.01202212f, 0.00730533f, -0.08119522f, -0.16010518f, 0.13255833f, 0.00088117f, 0.00952038f, 
    0.01060782f, -0.07804072f, -0.07189374f, -0.02601106f, 0.02233762f, -0.06968875f, 0.00084287f, -0.05121249f, 
    -0.11894542f, -0.09770292f, 0.14207807f, -0.04676119f, -0.11678071f, -0.10418399f, -0.05221096f, -0.08195484f, 
    -0.07379980f, 0.10768121f, 0.06542775f, -0.13915174f, 0.04146759f, 0.05110858f, -0.00831587f, 0.03340325f, 
    0.12333313f, 0.01739232f, 0.10233719f, 0.09428784f, 0.12590757f, 0.11923984f, -0.01482627f, -0.03953502f, 
    0.01902399f, 0.11409641f, 0.02311040f, -0.03961971f, 0.09708013f, 0.01325546f, 0.12990820f, 0.06369501f, 
    0.06522983f, -0.02808566f, 0.00183733f, 0.15308131f, -0.26323521f, 0.08195911f, -0.06720357f, 0.07763649f, 
    0.08911191f, 0.00473691f, -0.03598038f, 0.09552003f, 0.02044218f, -0.11811740f, -0.10707308f, -0.11686558f, 
    0.27722105f, 0.01804244f, 0.22852507f, 0.02761067f, -0.05064386f, 0.03603445f, -0.08574823f, 0.15531039f, 
    -0.12931427f, 0.09179600f, -0.08413322f, -0.05598602f, -0.10409392f, 0.06777210f, -0.03455999f, 0.00576452f, 
    -0.01210237f, -0.08713984f, -0.05155912f, -0.00256061f, 0.09320602f, -0.01772533f, 0.15880246f, 0.03417694f, 
    0.03370009f, 0.08533253f, -0.09943482f, -0.20448728f, 0.01543835f, 0.13131595f, 0.07819918f, 0.04831937f, 
    -0.07512065f, 0.05296250f, 0.06261402f, -0.05832780f, 0.11334316f, 0.14327709f, 0.08593657f, -0.08222874f, 
    0.05095808f, -0.01759315f, 0.06278866f, -0.00582516f, 0.08329027f, -0.14169994f, 0.15357792f, -0.04641667f, 
    0.46964619f, -0.12072731f, 0.01551108f, 0.04369733f, 0.04851578f, 0.10647631f, 0.00935620f, -0.10775566f, 
    0.13271113f, 0.01721697f, 0.04908675f, -0.01623514f, 0.04201719f, 0.07261625f, -0.11173702f, -0.02489052f, 
    0.09215512f, 0.01048249f, 0.02525329f, 0.01736418f, -0.03276369f, 0.09971060f, -0.02999711f, 0.00035754f, 
    0.12703654f, 0.00700743f, 0.01073083f, 0.08236161f, 0.01168918f, -0.12250549f, -0.01744868f, -0.14498666f, 
    -0.01671606f, 0.03792696f, 0.09750107f, 0.01897789f, 0.14988470f, 0.07096787f, 0.01252870f, 0.05953546f, 
    -0.01439404f, 0.02616487f, 0.04852877f, 0.02040195f, 0.08393327f, -0.01340473f, -0.05726082f, 0.05481789f, 
    0.20982704f, -0.03577388f, -0.03980551f, -0.06542128f, -0.25181913f, 0.12651916f, -0.09627130f, -0.07515144f, 
    -0.04258456f, 0.07961809f, 0.07099327f, -0.08431007f, 0.27565280f, -0.17551222f, -0.04287812f, 0.19635998f, 
    0.04042587f, 0.02945444f, -0.11467148f, 0.09786218f, 0.10007789f, 0.01225250f, -0.00935989f, 0.15981998f, 
    0.01910824f, 0.13869098f, -0.29065478f, -0.15927449f, 0.20759626f, 0.07783280f, -0.05041555f, 0.03877567f, 
    0.07122418f, 0.03588000f, -0.02749878f, 0.08984002f, 0.09121503f, 0.24504527f, -0.02007140f, -0.15811642f, 
    0.08957566f, 0.04913725f, -0.00007451f, 0.03020747f, -0.05521801f, -0.04731810f, 0.00862104f, 0.13959028f, 
    0.00400359f, 0.14482367f, 0.28886801f, -0.14187784f, -0.08852068f, 0.01864998f, 0.11188754f, 0.07051212f, 
    -0.05144314f, 0.04148161f, -0.05117565f, 0.05837883f, -0.07012179f, 0.02083638f, -0.03844535f, 0.07091937f, 
    -0.03806155f, -0.08219020f, 0.00621672f, 0.10374051f, 0.08723008f, 0.04061059f, 0.07768468f, 0.02319890f, 
    0.08180453f, 0.01600890f, -0.16331185f, 0.04795951f, 0.16601571f, 0.06100458f, 0.04991394f, 0.08008301f, 
    -0.03582057f, -0.03586059f, 0.13625693f, 0.03684545f, -0.02051442f, 0.10818841f, -0.09474333f, -0.26988739f, 
    0.10976067f, -0.12380937f, 0.00682897f, 0.10096654f, 0.00140457f, 0.04666623f, 0.04050016f, -0.01325071f, 
    -0.15603767f, -0.05785886f, 0.08419734f, -0.13961886f, -0.05392246f, 0.04497093f, 0.05407490f, 0.10373700f, 
    0.07811972f, -0.01521741f, -0.04189476f, 0.03832727f, -0.20618507f, 0.12829171f, 0.00677915f, -0.00401314f, 
    -0.05634536f, -0.01724517f, 0.04461670f, -0.08311173f, -0.04824233f, -0.01378032f, 0.02068844f, 0.07178870f, 
    0.04611735f, -0.00843091f, 0.01764941f, -0.01090805f, -0.03545652f, -0.05330008f, 0.03330539f, -0.02411014f, 
    -0.05307188f, -0.05174026f, 0.00049762f, 0.01865585f, -0.05614303f, -0.02627524f, -0.05437336f, -0.00509490f, 
    -0.02321692f, 0.02809991f, -0.04791798f, 0.03418124f, -0.03029774f, 0.01202937f, 0.02508698f, -0.03241517f, 
    -0.02591109f, -0.00990469f, 0.04140868f, -0.03336203f, 0.00762767f, 0.00876985f, -0.00767295f, -0.03879423f, 
    -0.00342708f, -0.03501168f, -0.04902224f, 0.00134952f, -0.02155895f, 0.03165252f, -0.05522822f, -0.04530652f, 
    -0.00477399f, 0.04612197f, 0.00903004f, -0.03550770f, -0.03045033f, 0.04122323f, -0.05300429f, -0.02165983f, 
    0.02176405f, -0.01409971f, 0.02029454f, 0.00422012f, 0.02447576f, 0.03971820f, 0.04325955f, 0.02103911f, 
    0.04599991f, 0.03947339f, -0.02193552f, 0.00547667f, 0.02403379f, -0.04851164f, 0.00440237f, -0.00707844f, 
    0.02661660f, -0.02031250f, 0.02292069f, 0.01516098f, -0.04164227f, -0.03685078f, 0.02933488f, 0.01969936f, 
    0.05032083f, -0.02440584f, -0.05061422f, -0.00113688f, -0.02104875f, -0.00867165f, -0.02893575f, -0.03437969f, 
    -0.00424206f, -0.02218466f, -0.01197200f, -0.01166227f, 0.03004067f, -0.06085974f, 0.00040822f, 0.02819663f, 
    -0.02592826f, -0.03846199f, -0.00480805f, -0.01836512f, -0.04397658f, -0.02917781f, 0.02095737f, -0.02612569f, 
    0.02888755f, 0.04042704f, -0.00302782f, -0.01458439f, -0.03033339f, 0.00661334f, 0.02851658f, 0.00852883f, 
    0.02476445f, -0.02702088f, -0.02241457f, -0.03605433f, -0.01764110f, -0.03415571f, -0.03867239f, 0.03794897f, 
    0.02188707f, -0.05219224f, -0.01702137f, -0.00181480f, -0.03615365f, -0.00480840f, -0.01889997f, 0.01261840f, 
    -0.05197983f, 0.00851397f, -0.04199442f, 0.02312338f, 0.00456018f, -0.00337959f, -0.00422825f, 0.02896040f, 
    0.02080181f, 0.03051514f, 0.04478425f, 0.02640431f, 0.02611885f, -0.02129922f, 0.03934663f, -0.03428648f, 
    0.04116336f, -0.03090566f, 0.03683674f, 0.03214895f, 0.01624487f, 0.01477109f, -0.00738718f, -0.00439448f, 
    0.00669178f, -0.02353377f, 0.00828633f, -0.04772585f, -0.01237717f, -0.00222845f, -0.05235935f, 0.01598184f, 
    0.03246620f, 0.01580151f, -0.00015547f, -0.02629783f, 0.01449602f, -0.04049157f, 0.03356864f, -0.00807403f, 
    -0.05877087f, -0.00833818f, 0.00079022f, 0.01108181f, -0.04743974f, -0.00252409f, -0.00608477f, -0.05572990f, 
    -0.05113221f, -0.00000330f, -0.02535240f, -0.02466628f, -0.02008027f, 0.00490451f, 0.03425251f, 0.00499257f, 
    -0.01227934f, 0.00763222f, -0.01653714f, 0.03524688f, 0.02671132f, -0.01248159f, -0.00900570f, 0.02018222f, 
    -0.03094208f, -0.03292434f, 0.02185912f, -0.02191612f, -0.03090896f, -0.04525517f, 0.00139251f, -0.02659676f, 
    -0.05623375f, -0.01215796f, 0.01449963f, -0.03437259f, -0.05106436f, 0.00767729f, -0.04483127f, 0.02887835f, 
    0.03267277f, -0.03291267f, 0.04658231f, 0.02533892f, 0.06138367f, -0.03105361f, 0.04397405f, 0.02075232f, 
    0.02097779f, 0.01425036f, -0.00841436f, 0.00050214f, -0.01605077f, 0.01573916f, 0.00088183f, -0.01159844f, 
    0.00045960f, 0.01614134f, -0.03038734f, -0.03402316f, -0.00240744f, -0.04758383f, 0.03194346f, 0.03828070f, 
    0.01367410f, 0.02389647f, -0.02048405f, -0.00154054f, -0.00733567f, -0.04060492f, -0.02073077f, -0.05227191f, 
    -0.04015385f, -0.02629814f, -0.05362437f, 0.01149689f, -0.01457476f, -0.05325711f, -0.03693368f, 0.01302098f, 
    -0.00823460f, 0.02040194f, -0.01698104f, -0.04602458f, -0.02709011f, -0.03105254f, 0.04384601f, 0.01603542f, 
    -0.00891529f, 0.00351987f, 0.03018761f, 0.04011644f, -0.03489950f, -0.05168144f, 0.01962131f, -0.05526889f, 
    0.01467005f, -0.01285944f, 0.03509558f, -0.05543965f, -0.06078090f, 0.00745180f, -0.03700264f, -0.00127488f, 
    -0.04642053f, -0.05764995f, -0.00855815f, -0.02125458f, 0.02735826f, -0.05985791f, 0.00025643f, 0.04434324f, 
    -0.04863075f, -0.00461354f, 0.03777286f, -0.01216123f, 0.00374173f, -0.04205526f, 0.00478494f, -0.02173135f, 
    -0.01740381f, 0.03736307f, -0.02932362f, 0.04328098f, -0.04547416f, -0.00078805f, 0.04177611f, -0.02889358f, 
    -0.03817946f, 0.02732896f, 0.01570299f, 0.02891287f, 0.03151292f, -0.02745487f, -0.03949773f, -0.04129035f, 
    -0.00275791f, -0.05984335f, -0.02746177f, -0.01454342f, 0.01723853f, 0.03240655f, -0.00309751f, -0.00065814f, 
    0.04566708f, 0.00259359f, -0.00314182f, -0.03664686f, 0.00833444f, 0.02648115f, -0.02076713f, -0.05209836f, 
    0.00660190f, -0.03766902f, 0.03000022f, 0.03697579f, 0.03414948f, 0.01657631f, -0.00840369f, 0.00709967f, 
    0.04222011f, -0.01402902f, -0.03769340f, -0.03229626f, 0.00203281f, -0.00615882f, 0.00132406f, 0.04339153f, 
    -0.03476754f, 0.03820764f, -0.00944923f, -0.04596607f, 0.03341604f, -0.00917993f, -0.01093321f, -0.01440671f, 
    0.00038122f, 0.03560814f, -0.04263907f, -0.00150626f, -0.00101107f, -0.02071811f, 0.03399000f, 0.02177811f, 
    -0.04988380f, -0.02282020f, -0.05548986f, -0.05576706f, 0.04445544f, -0.02957904f, -0.04300162f, -0.05049021f, 
    0.02585679f, -0.02242256f, -0.00408378f, -0.03549076f, -0.02916560f, -0.03430811f, 0.00055395f, -0.01533226f, 
    -0.01457330f, 0.00153162f, -0.00533806f, 0.01085015f, -0.03870707f, -0.00869685f, 0.03337216f, 0.03619251f, 
    -0.02168542f, -0.02925242f, 0.01931463f, -0.01054806f, 0.04702676f, -0.04958565f, -0.01794921f, -0.03699600f, 
    0.01140727f, -0.00423413f, -0.00729902f, 0.03347910f, 0.04497466f, -0.00765771f, -0.01016066f, 0.02972539f, 
    0.30548376f, 0.08594586f, 0.04818217f, -0.03167675f, -0.13713759f, -0.10091455f, 0.06378153f, -0.00999746f, 
    -0.06155455f, -0.00404358f, -0.06393775f, -0.08703586f, -0.24122156f, -0.15129243f, -0.08458970f, -0.08784210f, 
    0.09370578f, -0.04772812f, 0.01573054f, -0.09350244f, 0.03474747f, -0.01415408f, -0.06744493f, 0.00466257f, 
    -0.30326313f, -0.05563472f, 0.01698466f, -0.04055954f, -0.05817594f, 0.10828649f, -0.06195964f, 0.09639333f, 
    0.05331535f, 0.00259937f, -0.05428418f, -0.01851074f, 0.06815059f, 0.10272200f, 0.07917349f, -0.02653015f, 
    -0.07134452f, -0.08106055f, 0.05103849f, -0.03032657f, -0.01928106f, -0.01174065f, -0.05143062f, -0.05735739f, 
    0.10180706f, 0.04223165f, -0.03610886f, -0.07793657f, 0.08048149f, 0.10788742f, -0.00479766f, -0.06753985f, 
    0.01772128f, 0.02180905f, -0.05432090f, 0.02485903f, -0.20285168f, -0.12672488f, -0.13459364f, -0.24032833f, 
    -0.05547202f, 0.05998414f, -0.05825013f, -0.07609929f, 0.04472227f, -0.01674979f, 0.00081155f, -0.02664161f, 
    -0.31586727f, -0.06989533f, -0.05366419f, -0.02464454f, -0.02011500f, 0.09719536f, 0.02114634f, 0.03527157f, 
    0.00463733f, -0.02377718f, 0.15265180f, 0.08626518f, -0.29333031f, -0.13393964f, -0.14535607f, -0.24414955f, 
    -0.04593636f, -0.05156478f, -0.02991880f, 0.08418912f, 0.07054155f, 0.00126654f, 0.07524494f, 0.11813795f, 
    0.10499275f, 0.05655296f, -0.02021685f, 0.06562924f, 0.07873778f, 0.01813611f, -0.03129590f, 0.08301190f, 
    0.00408892f, 0.10769265f, -0.01183973f, -0.04662640f, 0.18592960f, 0.02490410f, 0.09464701f, 0.02896166f, 
    0.09172152f, 0.04389892f, 0.00697793f, 0.05348162f, -0.10461708f, 0.01227059f, 0.06658404f, 0.01336200f, 
    -0.07544012f, -0.09208742f, -0.07311163f, 0.04654552f, 0.12204099f, 0.02366475f, 0.02778964f, 0.06357212f, 
    -0.13585670f, 0.13723254f, 0.19402383f, 0.00056166f, 0.16263276f, 0.15230793f, -0.05080197f, 0.07693310f, 
    0.11299229f, -0.04342521f, 0.02276867f, 0.09211485f, 0.15437438f, 0.07711468f, 0.02225534f, 0.06156734f, 
    -0.09660330f, 0.12326580f, -0.08289391f, -0.19841808f, 0.16817021f, -0.02618763f, 0.03212991f, -0.00969734f, 
    0.05099189f, 0.03380568f, 0.11516429f, 0.15270925f, -0.20768268f, 0.02564165f, -0.06209101f, -0.03520454f, 
    -0.03516763f, 0.03199728f, -0.05075901f, 0.03095848f, -0.03653917f, 0.01992291f, 0.00679246f, 0.17451565f, 
    0.31487697f, 0.01667200f, 0.03795070f, -0.05468890f, -0.10213993f, -0.08745845f, 0.07554255f, -0.03362607f, 
    -0.07752959f, -0.01883328f, -0.01047276f, -0.00460341f, -0.11930293f, -0.02493782f, -0.03168776f, -0.00300107f, 
    0.15603350f, 0.08808576f, 0.04270743f, 0.04814826f, -0.03046644f, 0.10859957f, 0.04617465f, 0.06548750f, 
    0.20142172f, 0.03947308f, -0.10386118f, -0.07237976f, 0.04356625f, 0.11487817f, 0.00956300f, -0.02110188f, 
    -0.01791501f, 0.00002625f, 0.01634549f, -0.01591438f, -0.04104124f, 0.04336820f, 0.09190913f, 0.15486647f, 
    -0.13061322f, -0.05089066f, 0.04733149f, -0.02061836f, -0.17533547f, -0.00785936f, 0.04546801f, -0.06835804f, 
    0.18460800f, 0.06537426f, -0.04986760f, 0.02459032f, 0.03355122f, 0.04226520f, 0.10611878f, 0.04899620f, 
    0.07325834f, 0.01773576f, 0.02036089f, 0.04208658f, -0.11091791f, -0.18464211f, -0.18880613f, -0.18526423f, 
    0.08896790f, -0.03810465f, -0.01412691f, -0.02373858f, -0.06396226f, 0.13762788f, 0.06161806f, 0.03850773f, 
    -0.24824288f, -0.04003718f, -0.04360671f, -0.06230680f, 0.08160942f, -0.05600818f, -0.04519390f, 0.00050537f, 
    0.00473379f, 0.03604905f, -0.05312107f, 0.08460946f, -0.27578950f, -0.02754650f, 0.04666209f, 0.06003683f, 
    0.01984195f, 0.09516073f, 0.16178052f, 0.01498630f, 0.05865974f, 0.03546138f, 0.04324204f, 0.03062686f, 
    0.09006614f, -0.06039424f, 0.11349632f, -0.01855176f, -0.28728330f, 0.04912768f, 0.06635850f, -0.06488088f, 
    -0.13450395f, 0.15460898f, -0.01951584f, 0.07748668f, 0.15223892f, 0.13840468f, 0.00452630f, 0.06222241f, 
    -0.10921715f, -0.09402799f, 0.07239671f, 0.18400605f, 0.08615938f, 0.02184476f, 0.02057984f, 0.13292834f, 
    0.06199300f, 0.13284339f, 0.12877350f, -0.13269478f, 0.10546066f, 0.03202149f, 0.05240968f, 0.11654264f, 
    -0.02115062f, -0.06196785f, -0.00788458f, -0.01985053f, -0.21511024f, -0.12844029f, 0.02323997f, 0.11800727f, 
    0.04556109f, 0.08604739f, -0.06695222f, 0.10314351f, 0.03717805f, 0.04610651f, -0.02169137f, 0.07543312f, 
    0.01103117f, 0.15146938f, 0.00740978f, 0.07142740f, -0.01429158f, -0.05924300f, 0.00957616f, 0.06241224f, 
    -0.00938195f, 0.01220666f, -0.04449373f, -0.02556342f, -0.03252176f, 0.08183862f, 0.12009529f, 0.25277898f, 
    0.06084179f, -0.07746536f, 0.01833602f, 0.05828033f, 0.09230392f, 0.03369677f, -0.06379234f, 0.06789023f, 
    0.13129407f, -0.03961413f, 0.04983718f, -0.00556182f, -0.04708382f, -0.01549769f, -0.01918040f, 0.04925648f, 
    -0.02854420f, 0.06065124f, 0.01736623f, 0.07822651f, 0.24464771f, 0.15994030f, 0.12772068f, 0.19249709f, 
    0.01639209f, -0.05465609f, 0.02851429f, -0.11045989f, -0.06087455f, 0.06215669f, 0.01608164f, -0.10230141f, 
    0.00123937f, -0.08528476f, 0.10602554f, 0.05793356f, 0.11141229f, 0.00369844f, -0.06536823f, 0.00622714f, 
    0.00907584f, -0.05992070f, -0.01159049f, -0.16644150f, 0.04418552f, 0.10098113f, 0.18513732f, -0.03908930f, 
    -0.01413265f, 0.02395817f, 0.05779428f, -0.09816426f, 0.01795379f, 0.02783165f, -0.03359753f, 0.00744233f, 
    0.09816512f, -0.07312810f, 0.05164129f, 0.07531265f, -0.01077584f, 0.00037761f, 0.01101129f, -0.02439884f, 
    0.10080489f, 0.01977940f, 0.02043693f, 0.06055390f, 0.29764900f, 0.08234868f, 0.13964629f, 0.19656684f, 
    -0.09761187f, 0.07715503f, 0.09501506f, -0.05755995f, -0.00796666f, 0.08020370f, 0.13492581f, 0.10353628f, 
    0.44191507f, 0.02342758f, -0.20647486f, -0.11214231f, -0.04076891f, -0.04553593f, 0.04365987f, -0.05079085f, 
    -0.05080163f, -0.00615088f, -0.10521208f, 0.09543879f, -0.09523103f, 0.05838943f, 0.13464639f, -0.00298172f, 
    -0.00627869f, 0.03958428f, -0.02812408f, 0.20882061f, -0.02476995f, -0.04143420f, 0.01928093f, 0.02116987f, 
    -0.10567918f, -0.10533069f, 0.05166099f, -0.03892998f, 0.04488611f, -0.05663876f, 0.05309045f, -0.03404877f, 
    -0.01527372f, 0.03764177f, -0.03344556f, 0.08549928f, -0.02257569f, 0.14595830f, 0.02353384f, 0.14755139f, 
    0.17212044f, -0.08701374f, 0.04825213f, 0.07233032f, -0.05868895f, 0.02935517f, -0.03415909f, 0.10097136f, 
    0.19230980f, 0.12385990f, -0.00371496f, 0.16745143f, 0.01824006f, -0.05123521f, 0.04542587f, 0.00232231f, 
    0.05480359f, 0.04567402f, 0.05847661f, 0.06710824f, 0.10202479f, 0.06272493f, 0.10108506f, 0.15291300f, 
    0.07868682f, 0.05757042f, 0.05284680f, 0.07912645f, -0.00064893f, 0.10556729f, -0.04095676f, -0.08717331f, 
    -0.11708854f, -0.02348688f, 0.01031515f, -0.30159977f, -0.02732632f, 0.03572824f, -0.01575887f, -0.03788652f, 
    -0.00189618f, 0.02699131f, -0.00903040f, -0.05781276f, -0.26782051f, -0.02741870f, -0.00100214f, -0.08070910f, 
    -0.03648473f, 0.03837395f, -0.03185678f, 0.09424005f, 0.01283537f, -0.12064026f, -0.04651959f, 0.01235900f, 
    0.04769733f, 0.18728141f, -0.01892125f, -0.18475787f, -0.09049427f, 0.03980735f, 0.00396376f, -0.05133590f, 
    0.10705884f, 0.06481691f, 0.01282367f, -0.09784830f, -0.15046881f, -0.09159562f, -0.01603459f, -0.22107072f, 
    0.02768576f, 0.04374352f, 0.07715347f, 0.01990900f, -0.06773841f, 0.02832434f, 0.03714540f, -0.03299678f, 
    0.06207456f, -0.00732780f, 0.20631300f, 0.03159127f, 0.01969218f, 0.03602619f, -0.01558567f, 0.00452147f, 
    0.04306858f, 0.01196833f, 0.12658136f, 0.00988256f, 0.06327523f, -0.07967859f, 0.10911016f, 0.15923801f, 
    0.06235982f, -0.00690638f, -0.00531501f, 0.05429266f, -0.00730201f, 0.01751234f, 0.02994598f, -0.08011548f, 
    -0.01219212f, 0.03575266f, 0.11304577f, 0.08108780f, 0.02153016f, 0.06163742f, 0.03477824f, 0.10875976f, 
    0.00906726f, 0.03511861f, 0.01912686f, 0.01992184f, -0.16821051f, 0.21003892f, 0.20901753f, -0.07602520f, 
    0.02880837f, 0.07233739f, -0.05041619f, -0.02350416f, 0.03353246f, -0.05199161f, 0.09061088f, 0.01756687f, 
    -0.16575891f, 0.05737220f, 0.02494395f, -0.08447473f, 0.06071975f, 0.06936199f, 0.02182701f, -0.00948955f, 
    -0.02970073f, 0.05727313f, -0.00043679f, -0.03483270f, -0.00669448f, -0.07727250f, -0.11442006f, -0.01841296f, 
    0.06627508f, 0.03316544f, -0.06666079f, 0.08963166f, 0.12066038f, -0.07521509f, -0.06050310f, 0.01243961f, 
    0.26136932f, -0.19296393f, 0.03587515f, 0.01482295f, 0.06634261f, 0.00684502f, 0.01622456f, -0.03770691f, 
    0.07195130f, 0.02682452f, 0.07178892f, 0.01067715f, -0.06825395f, 0.22098599f, 0.08051572f, -0.09287547f, 
    0.01502890f, 0.09457367f, -0.01809757f, -0.02842748f, -0.01737559f, 0.01027362f, 0.09350191f, 0.02792436f, 
    0.05179533f, 0.14953008f, 0.10673101f, 0.02706544f, -0.07828592f, 0.10275541f, -0.00604555f, -0.02255407f, 
    0.01030508f, 0.01170720f, 0.03813506f, -0.00591668f, 0.19122741f, 0.22442590f, 0.05518024f, 0.00665452f, 
    0.11524250f, -0.00992364f, -0.06309730f, 0.06079427f, -0.00218495f, -0.02312758f, -0.00330950f, 0.10678741f, 
    0.05136793f, -0.06062342f, -0.10306747f, -0.06136215f, -0.00311499f, 0.01356579f, -0.05204124f, 0.00303372f, 
    0.11374713f, 0.05090633f, 0.10603786f, -0.18214147f, 0.08402727f, -0.28657833f, 0.01816355f, 0.14964683f, 
    0.04180087f, 0.03472463f, -0.14291967f, -0.01776420f, 0.08963530f, 0.04296008f, -0.04339305f, -0.04104533f, 
    -0.07400716f, -0.25810724f, -0.11827753f, -0.25220722f, 0.01582524f, 0.02786060f, 0.00248592f, -0.12501882f, 
    0.00505569f, 0.12145527f, -0.02953358f, 0.03645243f, 0.07647073f, 0.20447877f, 0.12640080f, -0.03411283f, 
    -0.03219654f, 0.04165735f, -0.01542405f, -0.04501187f, -0.00210917f, -0.09817918f, 0.08342562f, 0.00062405f, 
    -0.09443761f, -0.15041251f, 0.06227123f, -0.02217765f, -0.03927986f, 0.10201036f, 0.08589631f, 0.11790369f, 
    0.02545404f, 0.03325809f, -0.06339052f, 0.02671719f, -0.09638594f, -0.04274061f, -0.14015558f, -0.23761024f, 
    0.00017293f, 0.00808089f, -0.00171486f, -0.02271701f, 0.02831331f, 0.06575473f, 0.09446725f, -0.01842166f, 
    0.29331636f, -0.17610815f, 0.12582797f, 0.04608446f, 0.05528601f, -0.03231698f, 0.04271786f, 0.04780630f, 
    0.00755373f, -0.08383420f, 0.03742668f, 0.00018925f, -0.40413934f, -0.08397161f, -0.07420761f, -0.21765015f, 
    0.00310526f, -0.01973646f, -0.01809528f, 0.04429128f, -0.02219425f, 0.09266336f, 0.01153798f, 0.01161137f, 
    -0.22133595f, -0.07233209f, -0.06280258f, -0.06224540f, 0.00479755f, 0.05747798f, 0.04971010f, 0.13886937f, 
    -0.00094699f, -0.02512171f, 0.07080115f, 0.12841465f, 0.04812001f, -0.06671021f, -0.15778390f, 0.01779709f, 
    0.01697218f, -0.05055859f, 0.01564110f, 0.00345910f, 0.05627269f, 0.01530984f, 0.01430049f, 0.02271595f, 
    0.06934677f, 0.01834937f, 0.03259728f, 0.17130381f, -0.14762445f, -0.04765444f, -0.02106731f, 0.00064397f, 
    -0.01305993f, -0.00790560f, -0.17526335f, -0.14321244f, 0.35814738f, -0.04052206f, -0.07991961f, -0.05471816f, 
    0.04788785f, -0.03520906f, -0.10116623f, 0.06474265f, 0.10055485f, -0.02361108f, -0.03887159f, -0.13897111f, 
    -0.31204018f, -0.17631295f, -0.14543463f, -0.13516816f, -0.04912704f, 0.04514860f, -0.16176091f, -0.09310803f, 
    0.02429237f, -0.05085649f, 0.06067304f, -0.01101160f, -0.00629354f, 0.22774629f, 0.03174317f, 0.00688222f, 
    -0.02703702f, 0.00029323f, -0.03391637f, 0.04886283f, -0.02383178f, -0.11340612f, 0.11214604f, 0.11167257f, 
    -0.08746453f, 0.06078470f, 0.12020018f, -0.10040030f, 0.02601827f, 0.10556389f, 0.04416984f, 0.10901108f, 
    -0.03611211f, 0.00837673f, 0.04974565f, 0.11067116f, -0.00733582f, -0.18350007f, -0.00822388f, 0.03923972f, 
    0.16013904f, 0.13774471f, -0.06180159f, -0.01461176f, 0.13663715f, 0.06952114f, 0.14216578f, 0.07538322f, 
    0.14431673f, -0.15483430f, -0.04157905f, 0.01514328f, -0.02382539f, -0.05145720f, 0.04205225f, 0.08007150f, 
    0.01412581f, -0.08945318f, -0.07083304f, -0.00918102f, -0.00155956f, -0.13635068f, 0.04983695f, 0.00595651f, 
    0.02274026f, 0.00607189f, -0.04071544f, 0.04817514f, 0.02265552f, 0.06648204f, 0.10041737f, 0.07061527f, 
    0.08397900f, -0.11785128f, -0.22091569f, -0.02277989f, 0.07938449f, -0.11124457f, 0.04618306f, 0.02952508f, 
    0.21022163f, -0.05620304f, 0.22046167f, 0.00893010f, -0.14637892f, 0.05896274f, -0.01176429f, 0.01105128f, 
    0.02152887f, -0.00765665f, 0.05428289f, -0.05391569f, 0.17991938f, -0.05965645f, -0.12465664f, 0.08100262f, 
    -0.20322184f, -0.00534902f, 0.26712346f, 0.06247213f, -0.00390737f, -0.07503173f, 0.01427332f, 0.10631946f, 
    0.12800017f, 0.06932394f, 0.06918382f, 0.01558946f, 0.11095554f, -0.05388132f, -0.01788298f, 0.11331871f, 
    0.11211111f, -0.00380158f, 0.03415102f, 0.03874293f, 0.07359762f, 0.10801203f, -0.06523272f, -0.15159374f, 
    0.04644634f, 0.08117182f, -0.04441946f, 0.04644449f, 0.09354656f, 0.05855173f, 0.07899261f, -0.02804827f, 
    -0.07463984f, 0.00686908f, -0.08901934f, 0.13364917f, -0.10663471f, 0.02754804f, 0.02703043f, -0.13207677f, 
    -0.05055144f, 0.04651165f, -0.03767296f, -0.10221786f, -0.09950932f, -0.14281054f, -0.04783372f, -0.05644364f, 
    0.07712819f, 0.01064715f, 0.24882652f, 0.08012912f, -0.11495073f, -0.00565693f, 0.07266471f, 0.04247440f, 
    -0.14631574f, 0.09272595f, -0.09562231f, -0.05544715f, -0.02535811f, -0.19578081f, -0.09164389f, 0.02850181f, 
    0.12325163f, 0.03099457f, -0.01115993f, 0.01516322f, 0.13436292f, -0.00360069f, 0.16769674f, 0.07820994f, 
    0.09100358f, 0.00353761f, -0.21515527f, -0.17153840f, -0.01987641f, -0.04520260f, 0.02112602f, -0.00013633f, 
    -0.07062031f, -0.06988049f, 0.21084519f, -0.00623381f, -0.00454594f, 0.09441885f, -0.03258802f, 0.04355969f, 
    -0.10976037f, -0.01656026f, 0.15745202f, -0.11276100f, 0.09668655f, -0.10275771f, 0.16284440f, 0.02117435f, 
    -0.04256104f, -0.02146349f, -0.02398734f, -0.14321984f, 0.10652459f, 0.05926581f, 0.11835150f, 0.05016331f, 
    0.02055134f, 0.07475593f, -0.03302125f, -0.09062184f, -0.02594328f, -0.07846101f, -0.10658821f, 0.10982466f, 
    0.13481568f, 0.07887016f, 0.09638058f, -0.08397833f, 0.08106351f, 0.04729087f, 0.02475232f, 0.06632206f, 
    0.10090113f, -0.18850186f, -0.02580770f, -0.04234008f, 0.13649276f, -0.03008938f, -0.13313065f, -0.15395889f, 
    -0.07327010f, -0.01673674f, 0.05047657f, 0.05290069f, 0.11546911f, 0.01101316f, -0.11084558f, -0.06300785f, 
    0.05015107f, 0.04650066f, 0.03683553f, -0.02332326f, 0.05521505f, -0.02062641f, -0.01684333f, -0.00151294f, 
    0.13196327f, -0.01078516f, -0.01182986f, -0.07966687f, -0.04149432f, 0.09076565f, 0.02836076f, 0.03746115f, 
    -0.12181218f, 0.00887004f, 0.08069056f, -0.01106696f, 0.16342902f, -0.08039834f, 0.07610444f, 0.06754994f, 
    0.06675287f, 0.04930343f, -0.00914706f, 0.11124725f, 0.09237627f, -0.12353589f, 0.02840519f, 0.01802307f, 
    0.29072312f, 0.16729306f, -0.15474923f, 0.17850772f, -0.01534278f, -0.02560524f, -0.04231689f, -0.09802883f, 
    0.03596320f, 0.08380623f, 0.02131304f, 0.13512006f, -0.05753367f, 0.27275223f, -0.17740409f, -0.00913324f, 
    0.09756804f, 0.01765433f, -0.09969930f, -0.12438799f, -0.04799616f, 0.06476447f, 0.01934228f, 0.01120465f, 
    -0.04268445f, 0.18495007f, 0.01542971f, 0.03849764f, 0.04692404f, -0.05946919f, -0.12832098f, -0.00668939f, 
    0.01190612f, 0.06248565f, -0.02237271f, -0.12259438f, -0.12001922f, -0.01699112f, 0.02141847f, 0.11817156f, 
    -0.01704918f, 0.00947166f, -0.16756028f, 0.09622978f, 0.14243776f, 0.02273969f, 0.11349519f, -0.07441790f, 
    -0.20584013f, 0.10522560f, -0.19573317f, 0.15856445f, 0.11575349f, 0.05905933f, -0.01701496f, 0.09983841f, 
    0.06249945f, 0.09781338f, 0.11582665f, -0.03976496f, 0.00169119f, -0.05044596f, -0.04454618f, -0.05971224f, 
    0.06480226f, -0.21751420f, 0.02846102f, 0.12637630f, 0.12223299f, 0.05830972f, 0.03580565f, 0.03802191f, 
    -0.24134946f, 0.04985741f, -0.02433039f, -0.25653535f, -0.00762733f, -0.00605263f, -0.10604997f, 0.06766182f, 
    0.05005499f, 0.00440957f, 0.02750671f, -0.01762590f, -0.33876878f, 0.05602089f, -0.01136717f, -0.16037695f, 
    0.01670838f, 0.03597983f, -0.05908042f, -0.09172168f, 0.01760455f, -0.04828593f, 0.00070486f, 0.05543788f, 
    -0.01119923f, -0.00009808f, -0.03078705f, -0.01072471f, -0.03795703f, 0.01675559f, -0.03503639f, -0.00174720f, 
    0.00756370f, 0.02155593f, 0.02822510f, 0.00792708f, 0.03920184f, -0.05442126f, -0.02364345f, -0.01948326f, 
    0.02341093f, 0.03761325f, -0.02270828f, -0.01941351f, -0.04524910f, 0.03629221f, 0.04449242f, 0.04492300f, 
    0.02013206f, 0.02892718f, -0.02398771f, -0.00604800f, -0.03706673f, -0.01313332f, 0.01689770f, 0.00690488f, 
    -0.05046381f, 0.04113301f, -0.01448945f, -0.05228360f, -0.04050561f, 0.03697431f, 0.00812123f, 0.00036945f, 
    0.01685365f, 0.00663981f, 0.03467724f, -0.02090246f, -0.01358538f, 0.01821949f, 0.03587516f, -0.03143779f, 
    0.00732869f, -0.02901535f, 0.04240044f, 0.00152322f, -0.02861255f, 0.02897707f, 0.04363417f, 0.03087653f, 
    0.02805401f, -0.00316564f, 0.01067068f, -0.00503683f, -0.00585245f, -0.01200857f, 0.02901249f, 0.00453190f, 
    -0.05530947f, 0.00360627f, -0.00290004f, -0.03576387f, 0.02083727f, -0.02510544f, -0.02837816f, -0.01131320f, 
    -0.03117524f, -0.03855568f, 0.03682621f, -0.04935109f, 0.02000914f, -0.05233638f, 0.02701858f, 0.01901902f, 
    -0.00234806f, 0.02592995f, -0.05240470f, 0.03795901f, 0.01575982f, -0.02137045f, -0.01170579f, -0.05582975f, 
    0.00101792f, 0.03181377f, 0.03233198f, -0.04507274f, 0.04190876f, 0.00462850f, 0.03184874f, -0.02703198f, 
    0.02946816f, -0.03578046f, -0.03032781f, 0.01252427f, 0.00774263f, 0.02266866f, 0.00938648f, -0.01498495f, 
    -0.02404767f, -0.02774046f, -0.03724139f, -0.03061455f, -0.04461085f, 0.02000478f, 0.01559991f, -0.02511601f, 
    0.02357167f, 0.03235219f, -0.04626324f, 0.00384863f, -0.05369265f, -0.01412691f, 0.01732201f, -0.04586067f, 
    0.00174334f, -0.04144403f, -0.04776052f, 0.04132896f, -0.04420947f, -0.03531141f, -0.02031249f, 0.03196334f, 
    0.03887060f, -0.00276210f, -0.00962398f, -0.00135293f, -0.03898494f, 0.02152917f, 0.02677909f, 0.04449137f, 
    0.01518036f, -0.01073576f, 0.02763867f, -0.03993409f, -0.05285039f, -0.00444283f, -0.03787885f, -0.01440231f, 
    0.04176703f, -0.01393403f, -0.04819940f, 0.04358787f, 0.03967277f, -0.04704713f, 0.00310067f, 0.00004409f, 
    -0.03571006f, -0.01487707f, -0.02050496f, 0.03001577f, -0.01123805f, -0.01547049f, -0.00894364f, -0.03820809f, 
    0.03985623f, -0.04023437f, 0.00213360f, -0.03181983f, 0.02563935f, -0.00605491f, -0.04319486f, -0.04112427f, 
    -0.01510344f, -0.01657632f, 0.00520690f, -0.05416854f, 0.01090324f, -0.02394887f, 0.03537794f, -0.01413150f, 
    -0.03818334f, 0.02492184f, -0.01413493f, 0.01699761f, 0.03643398f, -0.02253328f, 0.02439894f, -0.03148730f, 
    -0.05217386f, -0.00731106f, 0.04282013f, -0.02555680f, 0.02167147f, 0.01682895f, -0.03209074f, -0.05220288f, 
    0.02522570f, 0.03544096f, -0.02710325f, -0.02590376f, -0.03685075f, 0.03753766f, 0.01264845f, 0.01689743f, 
    0.01609786f, -0.04511667f, 0.03010159f, 0.01289335f, 0.00249032f, 0.00860582f, 0.02571561f, -0.05057041f, 
    -0.04779521f, 0.01863783f, -0.01157900f, 0.03964560f, 0.04307135f, -0.03136471f, 0.02640586f, 0.01575293f, 
    -0.02116690f, -0.04459118f, -0.02574220f, -0.00976048f, -0.02988502f, -0.00693894f, -0.02517352f, 0.03133333f, 
    0.04343151f, -0.02026877f, 0.03074931f, -0.00140265f, -0.00812438f, -0.03036408f, -0.01516292f, -0.04857327f, 
    -0.01366097f, 0.02668288f, 0.01078225f, 0.02616220f, -0.04066312f, 0.04397618f, -0.03530702f, 0.03340830f, 
    0.02019052f, -0.03429815f, 0.03084074f, -0.03437494f, 0.03990557f, 0.00561287f, -0.02473608f, 0.00838472f, 
    0.00754964f, 0.00376482f, 0.00790309f, -0.04103661f, 0.00706909f, 0.00039625f, 0.03188484f, -0.05256827f, 
    -0.02984800f, -0.05563135f, -0.04309703f, -0.05386695f, -0.03979866f, -0.04507137f, -0.00598686f, -0.04124443f, 
    -0.04759544f, -0.04245609f, 0.02337799f, 0.02964980f, -0.03809969f, 0.00984706f, -0.05157605f, -0.05115806f, 
    0.05013336f, 0.02106596f, -0.04210981f, -0.03601678f, -0.02445685f, -0.05298144f, -0.03927590f, 0.02436204f, 
    -0.01474227f, -0.03316673f, -0.05477085f, 0.00835512f, -0.03369348f, -0.04391206f, 0.02008647f, 0.03202540f, 
    -0.04632846f, -0.01831434f, 0.01629668f, -0.04312168f, -0.05038865f, 0.00175407f, -0.00534815f, 0.02524038f, 
    -0.00691586f, -0.04040161f, 0.02084137f, 0.02053479f, -0.00871042f, -0.01121754f, -0.05578630f, -0.04114234f, 
    -0.02761136f, -0.04978995f, 0.02344058f, -0.00060985f, 0.04286827f, 0.01855089f, 0.00788158f, -0.03408141f, 
    0.04139565f, -0.02790906f, -0.00584139f, -0.01928081f, -0.02421579f, -0.00934449f, -0.03923755f, -0.00306603f, 
    -0.04581800f, 0.02413386f, -0.01001579f, -0.01447225f, -0.01312134f, -0.00839689f, 0.04450353f, -0.02685836f, 
    -0.03686358f, 0.01202278f, 0.03048051f, -0.02426950f, -0.04492303f, -0.02845954f, 0.02167993f, 0.01961838f, 
    -0.00393741f, -0.02946914f, 0.02025811f, 0.03607647f, 0.00040530f, -0.01397287f, -0.02623385f, 0.02968185f, 
    -0.05630038f, 0.01098602f, -0.01779810f, -0.00738575f, -0.01808008f, 0.03004587f, -0.03199901f, -0.01650269f, 
    -0.04418798f, -0.01993760f, 0.01073899f, -0.02643053f, 0.04074564f, 0.01273763f, 0.00599939f, -0.03187413f, 
    -0.01791413f, -0.00402472f, 0.01341577f, 0.01051666f, 0.00400416f, 0.03526838f, -0.02849059f, -0.04688605f, 
    -0.05489801f, -0.05102123f, 0.01981925f, 0.01327840f, -0.04264142f, -0.02907004f, -0.05052907f, 0.00607887f, 
    0.04162316f, -0.03630568f, -0.02585461f, -0.04643225f, 0.03753206f, -0.04465844f, -0.05557664f, -0.03060671f, 
    -0.03471589f, -0.01094489f, 0.17887567f, 0.08380289f, 0.05948013f, -0.01384527f, -0.00307659f, 0.12485878f, 
    -0.00322739f, 0.12375456f, 0.11313551f, 0.01935498f, -0.23508148f, -0.18925606f, 0.00675578f, -0.11078207f, 
    0.02773083f, 0.13399430f, 0.08577628f, -0.11571235f, -0.05874778f, 0.11480022f, 0.05628056f, 0.12838729f, 
    0.46792084f, 0.07838429f, -0.05438475f, -0.00923432f, 0.01117062f, 0.08231460f, 0.12541318f, 0.04062381f, 
    -0.04904012f, 0.06263085f, -0.02379018f, 0.09950262f, 0.02261684f, 0.08482100f, 0.20197806f, 0.04265141f, 
    -0.03528785f, -0.01300360f, 0.01058153f, 0.03064386f, -0.08841836f, 0.08120635f, -0.06153620f, -0.08311905f, 
    0.20209102f, 0.14065455f, 0.02203932f, 0.02396202f, -0.00700744f, -0.12582533f, -0.14460084f, 0.00004081f, 
    -0.04261715f, 0.00893388f, -0.06373780f, -0.13801806f, -0.07934315f, -0.02583217f, -0.06725875f, -0.07012340f, 
    0.06458770f, -0.11640767f, 0.07075813f, -0.06838781f, -0.03558133f, -0.03303183f, -0.01489895f, 0.01579260f, 
    -0.15225498f, 0.20235172f, 0.04882945f, 0.04846989f, 0.04987538f, 0.15016440f, 0.05749157f, -0.02778106f, 
    0.01033482f, 0.15542260f, 0.24297237f, 0.03200687f, -0.03618190f, -0.04905596f, -0.06677768f, -0.05104593f, 
    0.05002172f, 0.08173978f, 0.01629654f, -0.02681599f, -0.04881701f, -0.10133280f, -0.12372909f, -0.12330921f, 
    -0.02740413f, -0.05415680f, 0.04233962f, -0.14207648f, -0.07245034f, 0.05763604f, 0.01518319f, -0.00425844f, 
    0.03217070f, -0.01885984f, -0.25983784f, -0.08097208f, 0.00956576f, 0.06923138f, -0.06413121f, -0.05553268f, 
    -0.01963206f, -0.01384710f, -0.04339697f, 0.04774898f, -0.06074155f, -0.11915863f, -0.00028288f, 0.01239890f, 
    0.05735803f, 0.11126269f, -0.09579261f, -0.03481777f, -0.07626534f, 0.16416731f, -0.01926532f, -0.09847245f, 
    -0.18995988f, -0.14721452f, -0.14044076f, -0.08700754f, 0.14716208f, -0.00827092f, -0.08535760f, -0.08144853f, 
    -0.06773168f, -0.03036010f, -0.03072777f, -0.04571600f, 0.11856934f, -0.15841563f, 0.08757436f, 0.06960727f, 
    0.11248874f, -0.19693632f, -0.02524220f, -0.08120947f, -0.10023971f, 0.11094947f, -0.04892536f, -0.08146980f, 
    0.01581090f, -0.04667163f, 0.11615966f, -0.18614590f, -0.14846629f, 0.03512293f, 0.02537577f, 0.06481601f, 
    -0.12046362f, 0.01355807f, 0.20800759f, 0.13006598f, -0.01836740f, 0.05200583f, -0.01267022f, 0.03813172f, 
    0.13549720f, -0.04208514f, 0.19775200f, 0.04699896f, 0.00354637f, -0.02894091f, 0.07770986f, 0.06891929f, 
    -0.02817184f, -0.13692473f, 0.10945413f, -0.04930465f, -0.01497852f, 0.32322714f, -0.00571873f, 0.03828364f, 
    0.05385504f, -0.00173654f, 0.05306342f, -0.03915004f, -0.07875954f, -0.01993057f, -0.13901408f, -0.02786072f, 
    -0.06425407f, 0.07459851f, -0.06642333f, -0.02517451f, 0.07620288f, 0.05373935f, 0.03900557f, -0.05200033f, 
    0.08820047f, -0.04174510f, -0.25403935f, -0.13802259f, 0.00244827f, -0.02493161f, -0.03919489f, 0.34507471f, 
    0.07364134f, -0.01520101f, -0.00245851f, 0.10980825f, -0.11401314f, 0.17837618f, -0.07364261f, 0.01358001f, 
    0.31718346f, -0.01456245f, 0.08343471f, 0.07925553f, 0.05474865f, -0.04808154f, 0.07164896f, -0.04934172f, 
    -0.01333605f, 0.03917028f, -0.00362498f, 0.07898152f, 0.09670693f, 0.01943921f, -0.13574141f, -0.21230383f, 
    0.04715203f, -0.00645641f, -0.01473373f, 0.02399651f, -0.02164325f, 0.02636106f, 0.02695308f, -0.09368188f, 
    0.10575069f, 0.06928843f, -0.01099344f, -0.07648989f, -0.04456435f, 0.09214641f, 0.01980450f, 0.12471365f, 
    0.11873304f, 0.06366778f, 0.00598539f, -0.01594710f, -0.25112483f, 0.04773102f, 0.01966577f, 0.07386343f, 
    0.15104724f, -0.06099760f, 0.04134603f, 0.01784622f, 0.04390495f, 0.03421581f, 0.04674820f, 0.10512143f, 
    0.14002821f, -0.00057367f, 0.09099418f, 0.08816479f, 0.04209035f, -0.07784716f, 0.06657683f, -0.00343364f, 
    -0.04871775f, -0.02428606f, -0.17405543f, -0.09664102f, 0.03429437f, -0.08142377f, 0.14028350f, 0.00314947f, 
    0.01759751f, -0.07766481f, -0.06486814f, -0.07611343f, 0.05112974f, 0.09734572f, -0.12576844f, 0.05848456f, 
    0.13417479f, -0.28513172f, 0.01423653f, -0.04485404f, 0.07037027f, 0.08277120f, 0.04315426f, 0.05117361f, 
    -0.06056669f, -0.04832920f, 0.09995501f, -0.21377036f, -0.03795278f, 0.08889832f, 0.22844373f, 0.22567247f, 
    0.08092265f, -0.02900362f, 0.04466074f, 0.11709287f, 0.08018673f, 0.01991236f, -0.03117503f, 0.04991563f, 
    -0.06227963f, 0.03901537f, 0.03026372f, 0.22840704f, -0.05899133f, 0.01662597f, 0.03726676f, -0.13021472f, 
    -0.06300279f, 0.01223739f, -0.09327779f, 0.04250894f, 0.19809620f, -0.08083760f, -0.08324136f, -0.13906014f, 
    0.03916983f, -0.01379622f, 0.15291388f, -0.01404930f, 0.13260964f, 0.00685821f, -0.02502317f, 0.02951224f, 
    0.38370094f, -0.11151841f, 0.08481120f, 0.01836971f, 0.04590064f, -0.04997973f, 0.04185047f, 0.17793784f, 
    -0.12333928f, -0.05350623f, -0.05490603f, 0.09624819f, -0.00816790f, 0.00140281f, 0.02885570f, -0.14233549f, 
    -0.02019506f, 0.12381793f, 0.01552122f, -0.10029488f, 0.01605607f, 0.00331998f, 0.02508141f, 0.02739943f, 
    0.10093110f, 0.25727895f, 0.04676675f, 0.07129300f, -0.00269185f, -0.04303293f, 0.03536494f, 0.01473214f, 
    0.00851653f, -0.08341312f, 0.12709287f, 0.11377929f, 0.37953079f, 0.00941038f, 0.09340014f, 0.17311914f, 
    0.01414641f, 0.01540239f, 0.17043088f, 0.03186739f, 0.01343996f, 0.05162495f, 0.13524936f, -0.05614911f, 
    0.00329966f, -0.00592720f, 0.00687149f, 0.04437025f, 0.00228736f, -0.00614951f, 0.02012151f, 0.03069306f, 
    0.02134230f, 0.03848562f, -0.02204276f, -0.05998531f, 0.03987811f, -0.00793691f, -0.00725474f, -0.00533351f, 
    0.00999075f, 0.02636363f, -0.03242603f, -0.02538158f, -0.01550322f, -0.04146754f, -0.00651498f, -0.01292219f, 
    0.03553283f, 0.01301853f, 0.01475561f, -0.01981107f, -0.00056190f, -0.03103172f, 0.02598366f, -0.05145455f, 
    0.01321896f, 0.03369642f, 0.04025774f, -0.05457237f, 0.03162197f, -0.01575212f, -0.04884814f, -0.03924957f, 
    -0.02502003f, -0.01741750f, 0.03266301f, 0.00279770f, 0.00764156f, 0.03643029f, -0.05354889f, -0.01322566f, 
    0.00187974f, -0.05880608f, 0.02215180f, -0.05557673f, -0.03110446f, 0.01154666f, 0.03264643f, 0.04093574f, 
    -0.01833398f, 0.04185906f, 0.01753256f, -0.04827257f, 0.02878594f, -0.02044482f, 0.04627050f, -0.03884557f, 
    0.01017844f, -0.01186657f, -0.05380498f, -0.00381568f, 0.00144591f, -0.02953266f, -0.03558540f, 0.03994498f, 
    -0.02501218f, -0.04663017f, 0.02469554f, 0.04682293f, -0.00450005f, 0.04014704f, -0.04237062f, -0.00340157f, 
    -0.01972348f, 0.02237951f, -0.05429229f, -0.02201537f, 0.00062271f, 0.02392744f, -0.02950642f, 0.01503613f, 
    -0.04567188f, -0.01141097f, -0.01366578f, -0.04113255f, 0.01829458f, -0.06025768f, -0.00407244f, -0.02678878f, 
    0.02953195f, 0.01611265f, -0.05437334f, 0.02801350f, -0.00902378f, 0.02321547f, 0.01437200f, 0.03816258f, 
    -0.00705402f, 0.03633894f, 0.05642761f, -0.02673235f, -0.01695734f, 0.00886774f, 0.02563488f, -0.00438763f, 
    0.00318167f, -0.01713595f, -0.02362482f, -0.05464268f, -0.04271779f, -0.03610919f, -0.01007533f, -0.00532779f, 
    0.05478152f, -0.04555608f, 0.03366939f, -0.03264333f, -0.02318852f, -0.06126680f, -0.05171346f, 0.00847532f, 
    0.00597272f, -0.04587532f, 0.00180731f, -0.01995118f, -0.03953810f, -0.05248620f, 0.02369807f, -0.06097957f, 
    -0.05194421f, -0.05448238f, -0.00439517f, 0.03037593f, 0.04732550f, -0.01789666f, 0.02284683f, -0.04423941f, 
    -0.05683262f, 0.00353966f, -0.02488794f, 0.00339122f, -0.02381774f, -0.02359060f, 0.00744779f, 0.04321805f, 
    -0.02887199f, 0.01108318f, -0.02792513f, 0.04245773f, -0.01773797f, 0.00520147f, -0.02240324f, -0.02462928f, 
    -0.02824564f, 0.01628998f, 0.03069026f, -0.00001979f, -0.04100098f, 0.03418874f, 0.04211384f, -0.00957092f, 
    0.02204797f, 0.02531963f, 0.01712478f, -0.02759738f, 0.00896571f, 0.02065369f, 0.00909107f, 0.01380523f, 
    -0.01550825f, 0.02925410f, -0.00631198f, -0.04770593f, -0.05982605f, 0.03057120f, 0.01799884f, 0.04378748f, 
    0.02829912f, 0.00052091f, 0.03897899f, -0.01376732f, -0.04496610f, -0.02009927f, -0.03378177f, -0.00792497f, 
    0.02467567f, 0.03300513f, -0.05729644f, 0.00538879f, 0.03220946f, -0.06579390f, 0.02658504f, -0.02725806f, 
    0.01825943f, -0.02899556f, -0.00624079f, -0.00216284f, -0.03457659f, 0.01030129f, -0.04547731f, -0.01432443f, 
    0.02284964f, -0.00787425f, 0.03406828f, -0.04215416f, 0.01453706f, 0.01555921f, 0.00402489f, 0.01804228f, 
    -0.05301172f, 0.00310787f, 0.03979310f, -0.04582829f, 0.00868978f, -0.03327864f, 0.02931848f, 0.02308211f, 
    0.00679516f, -0.03457029f, -0.04579775f, -0.03439839f, 0.03198428f, 0.02388872f, -0.02259142f, 0.02302189f, 
    0.05009178f, 0.01831309f, 0.01814703f, -0.01239936f, -0.01351476f, -0.04517784f, -0.05272398f, -0.04255364f, 
    0.03558562f, 0.01251122f, 0.00751915f, 0.01814826f, 0.03496981f, 0.02268429f, -0.01685752f, 0.01598859f, 
    -0.01726944f, -0.00243620f, -0.05177851f, -0.05942774f, 0.01960699f, 0.00970390f, -0.02387215f, -0.01154210f, 
    0.00015956f, -0.04004884f, 0.02323069f, -0.04050770f, 0.03353412f, -0.02854155f, -0.05092186f, -0.00462926f, 
    -0.05879336f, -0.00371555f, -0.04445337f, -0.03531046f, -0.02856499f, 0.03620332f, -0.02706207f, -0.04853326f, 
    0.01174298f, -0.04976435f, -0.01786927f, -0.02251654f, -0.03842594f, 0.01105972f, -0.00427464f, -0.01970872f, 
    -0.01841097f, -0.01153465f, 0.00514071f, 0.05471662f, -0.02480069f, -0.05430521f, -0.04610247f, 0.03049845f, 
    -0.04894946f, -0.04693762f, -0.00762474f, -0.06564712f, -0.05936875f, -0.03749005f, -0.02403939f, 0.04262893f, 
    -0.01555014f, -0.03371039f, 0.02315612f, 0.05069047f, -0.03921264f, 0.04959371f, 0.03839910f, 0.01141631f, 
    -0.03388666f, 0.04430665f, -0.02473964f, -0.02822199f, -0.03779911f, -0.03007420f, -0.00899754f, -0.05170354f, 
    0.04042336f, 0.02018976f, -0.00042118f, 0.03816484f, 0.04161824f, 0.02825938f, 0.03313616f, 0.02525807f, 
    0.03226797f, 0.02417282f, -0.05026655f, 0.04118325f, -0.01808923f, -0.02986877f, 0.03995022f, -0.02837965f, 
    -0.03066193f, 0.02775451f, 0.02232290f, -0.03033357f, -0.03960544f, -0.01798103f, 0.03889586f, -0.01832523f, 
    -0.04733981f, 0.02940722f, -0.01287932f, 0.02432737f, -0.01291390f, -0.04184429f, -0.04156946f, 0.04138228f, 
    0.02557558f, -0.05477336f, -0.05213494f, 0.02313853f, 0.01624565f, 0.00748420f, -0.04112716f, 0.03896776f, 
    0.04039200f, 0.02080299f, 0.02948177f, 0.00413044f, 0.02832434f, 0.03947767f, -0.03690095f, 0.03147565f, 
    0.01816387f, 0.02099846f, -0.00526711f, 0.00146805f, 0.02276099f, -0.05437012f, -0.03561901f, -0.04409159f, 
    -0.04979957f, 0.01383579f, 0.00769568f, -0.04886845f, 0.00350661f, -0.03896254f, -0.02968142f, -0.02821718f, 
    0.03589202f, -0.05145222f, 0.00075686f, -0.03295535f, -0.02191668f, -0.04046860f, 0.00256621f, -0.01679109f, 
    0.11528503f, -0.01809800f, -0.14071675f, -0.07297357f, 0.01107219f, -0.05289986f, 0.04241266f, -0.06384363f, 
    0.03490945f, 0.00141230f, -0.11467546f, -0.00950559f, 0.27336794f, 0.14450787f, 0.10860396f, 0.10274313f, 
    0.02928373f, -0.06197663f, -0.12065496f, 0.10679689f, 0.09338800f, -0.00748112f, 0.03063958f, -0.06691441f, 
    -0.27361503f, -0.14195763f, 0.11217773f, 0.12687741f, 0.11880226f, 0.00798842f, -0.10254990f, 0.00794957f, 
    0.02318466f, 0.03701518f, 0.02659427f, -0.08833732f, -0.07217073f, -0.00242627f, -0.16850325f, -0.02178625f, 
    0.07126560f, 0.02524978f, -0.04691624f, 0.00138687f, 0.14143892f, -0.08635297f, 0.06316190f, 0.08259159f, 
    0.00070386f, -0.09390297f, -0.03262557f, 0.10661372f, -0.00304622f, 0.03901849f, 0.17787752f, 0.13140479f, 
    0.01731759f, 0.07481511f, 0.04168736f, 0.15709136f, -0.04888033f, 0.05880115f, 0.14118788f, 0.15695095f, 
    -0.06608421f, 0.15709716f, 0.04705903f, 0.08371967f, 0.06267416f, -0.01958474f, 0.02379070f, 0.01914760f, 
    0.23166502f, -0.11547726f, 0.10537655f, 0.10269435f, -0.01536572f, -0.09565027f, -0.07841462f, -0.05610916f, 
    0.04890834f, -0.07897723f, -0.29556298f, 0.03153187f, 0.04915149f, 0.09304477f, 0.03938212f, 0.00305679f, 
    0.07942725f, -0.03135795f, -0.02476701f, -0.00514788f, 0.06684496f, 0.09672205f, 0.17140912f, 0.13086738f, 
    0.07866181f, -0.05037303f, 0.00540245f, 0.04778362f, 0.02868737f, 0.01204931f, 0.10355003f, 0.07302158f, 
    -0.04324768f, 0.08300945f, 0.19240792f, 0.06792203f, -0.04937573f, 0.03533487f, 0.08174241f, 0.03508860f, 
    0.00781521f, 0.06862428f, 0.07272035f, -0.01024471f, 0.10456061f, 0.07770509f, -0.01987557f, 0.09009582f, 
    -0.00171038f, -0.03548638f, 0.10120311f, 0.02211132f, 0.08102632f, -0.07375769f, 0.03313199f, 0.01807733f, 
    0.18399429f, 0.10249497f, 0.15281093f, 0.04898661f, -0.14224321f, 0.00994524f, 0.15213884f, 0.13641030f, 
    0.07628306f, 0.05525529f, 0.10274292f, 0.11609328f, -0.11791235f, 0.13650419f, 0.01131775f, -0.11560822f, 
    -0.07953645f, 0.07225659f, 0.07862353f, 0.07868892f, 0.11521380f, 0.01291092f, 0.01150082f, 0.03959914f, 
    -0.04910804f, 0.07068340f, -0.10788456f, 0.16853765f, 0.21875620f, -0.01324069f, 0.01236838f, 0.00764199f, 
    0.08740771f, 0.02570447f, -0.07106630f, -0.10274334f, 0.00564069f, 0.01363276f, 0.03158199f, 0.05637556f, 
    -0.12754487f, 0.07416832f, -0.14998376f, -0.06486312f, 0.09789751f, 0.11382817f, -0.06214998f, -0.05842067f, 
    0.04037457f, 0.10051201f, -0.05206132f, 0.06098093f, -0.10841063f, -0.20048226f, 0.06004856f, 0.02591055f, 
    -0.04619909f, -0.03998910f, -0.02049891f, 0.09745699f, 0.08368576f, -0.03890573f, 0.11780599f, -0.01495602f, 
    0.15653336f, -0.05007605f, 0.08627939f, -0.01311640f, -0.02880805f, 0.01544544f, 0.03640021f, 0.06888332f, 
    -0.02976809f, 0.00249905f, 0.17003819f, 0.07192311f, 0.17190063f, -0.08166670f, 0.04984064f, -0.16718417f, 
    -0.03998850f, 0.08450814f, 0.00769777f, 0.06315286f, 0.11925842f, -0.05180384f, 0.04475057f, 0.00440229f, 
    -0.26714095f, -0.04277801f, 0.05885810f, 0.05159469f, 0.00765380f, 0.03269679f, -0.05699661f, 0.04901421f, 
    -0.04478544f, 0.03578635f, 0.02796032f, -0.05957702f, -0.16366239f, 0.02745304f, 0.11550682f, 0.17638443f, 
    0.06496064f, 0.09202805f, 0.08221777f, -0.02557356f, 0.04397137f, -0.13267176f, -0.05790721f, 0.03464180f, 
    -0.10924243f, -0.12266250f, 0.08985668f, 0.14553173f, 0.06634663f, -0.00032217f, 0.05696940f, -0.08162034f, 
    -0.05462358f, -0.06181502f, 0.01484314f, -0.02015898f, 0.20470972f, 0.00167410f, -0.07676656f, 0.03660507f, 
    -0.06491968f, 0.03847330f, -0.04125592f, 0.01591758f, 0.07165250f, -0.09631384f, -0.01640531f, -0.00790132f, 
    -0.01734941f, -0.01955198f, -0.09306376f, 0.02931715f, 0.03450919f, 0.11965295f, -0.04971218f, 0.06771423f, 
    0.12563401f, 0.13455382f, 0.09993108f, 0.05718609f, -0.00993112f, -0.05681789f, -0.07051571f, -0.01378361f, 
    0.06542342f, 0.02603445f, 0.03368266f, 0.14073253f, 0.00005941f, -0.05117130f, 0.10041080f, -0.02474495f, 
    -0.17787829f, 0.20998122f, 0.13518378f, 0.07879411f, -0.02560104f, 0.00086249f, 0.00373869f, 0.03701252f, 
    0.11269352f, 0.09044110f, -0.05642137f, 0.21451366f, 0.02208838f, 0.02914421f, 0.02470768f, -0.16578403f, 
    -0.04203837f, 0.03887350f, -0.00210879f, 0.02824055f, 0.01224024f, 0.04878306f, 0.00719264f, -0.00993191f, 
    0.21001445f, -0.04275854f, 0.05622094f, -0.22773109f, 0.16072242f, -0.00734231f, -0.01814088f, 0.06246626f, 
    -0.01955176f, 0.13398132f, 0.07576290f, -0.05037376f, -0.16123594f, 0.05700019f, -0.00261495f, 0.13858114f, 
    -0.04053277f, 0.03944293f, -0.01236999f, 0.04415761f, -0.01193934f, 0.01927804f, 0.16028537f, 0.02675920f, 
    -0.32142666f, 0.09218788f, -0.06097794f, 0.05537664f, -0.00083703f, 0.04252940f, 0.03968422f, -0.12261252f, 
    0.11159707f, 0.07614944f, 0.18693629f, -0.02234187f, 0.02712141f, 0.04102867f, -0.00815876f, 0.10269286f, 
    0.01568562f, -0.05894282f, 0.02101823f, 0.12669282f, -0.00203446f, 0.06282322f, 0.01057644f, -0.00092172f, 
    -0.00480111f, -0.13785006f, 0.09221635f, -0.05200699f, -0.03152981f, 0.04644642f, 0.09161556f, 0.02017882f, 
    0.04733830f, 0.03801147f, -0.09825768f, -0.01130339f, -0.14229338f, 0.06841435f, -0.09501044f, -0.06505409f, 
    0.05992271f, 0.00475797f, -0.08586517f, 0.06035855f, 0.03900053f, -0.09914549f, -0.02311180f, 0.03742537f, 
    0.03531507f, 0.02745821f, 0.04661876f, -0.05041514f, 0.00045181f, 0.01850280f, -0.00738359f, -0.04618296f, 
    0.00797057f, 0.03259223f, -0.03729672f, -0.03344651f, 0.01206603f, 0.04192574f, 0.02025092f, -0.00020282f, 
    0.02181686f, -0.00856560f, -0.03153956f, 0.01425186f, -0.02053911f, 0.01773067f, -0.00554173f, -0.05165156f, 
    0.03865147f, 0.01171086f, -0.00646608f, 0.04156972f, -0.01662663f, -0.05426974f, 0.03441824f, 0.03259815f, 
    -0.04390012f, -0.00559572f, -0.02438556f, 0.00805528f, -0.05090987f, -0.04738885f, 0.01599623f, 0.01021538f, 
    -0.01922063f, -0.02341228f, -0.05099926f, -0.01396697f, -0.05106200f, 0.02450602f, 0.00349075f, -0.04794320f, 
    -0.00261845f, -0.04914728f, -0.02349155f, -0.03038258f, -0.04458107f, 0.01620849f, 0.02792145f, -0.04387996f, 
    -0.00061082f, -0.01759252f, -0.02087944f, -0.01376480f, -0.03661750f, -0.03873857f, 0.01983631f, -0.00034182f, 
    0.02637106f, 0.00091503f, 0.00695482f, -0.02883641f, -0.01284319f, 0.02067937f, -0.00230307f, 0.02269047f, 
    -0.02893808f, 0.00247054f, -0.00599619f, 0.04489715f, -0.02139342f, 0.04189857f, -0.04674467f, -0.01684101f, 
    -0.04664059f, 0.04210416f, -0.00649208f, 0.03159556f, -0.00178217f, -0.03636555f, -0.00484885f, -0.01813264f, 
    -0.05771158f, -0.02116629f, -0.05182344f, -0.01926353f, -0.04899485f, 0.00643268f, 0.01832997f, 0.03770589f, 
    -0.02969262f, -0.00704984f, -0.04805408f, -0.05382368f, -0.02283312f, -0.00613229f, -0.04435817f, -0.03265340f, 
    0.03368567f, -0.03002162f, 0.00843481f, -0.03578248f, -0.02774709f, -0.06003930f, -0.02317935f, -0.00230960f, 
    -0.02996005f, 0.03702333f, -0.00650820f, 0.02368370f, -0.02920376f, -0.02587378f, -0.00117221f, 0.00123317f, 
    0.03162464f, -0.02747573f, 0.00529442f, -0.00960091f, 0.02099526f, -0.04791336f, 0.03833624f, 0.00633108f, 
    -0.03309834f, 0.02539686f, -0.04199578f, 0.00616630f, -0.02879455f, -0.04517078f, -0.05140081f, 0.00245359f, 
    0.03284430f, -0.02639661f, 0.03352530f, -0.00364527f, 0.03273493f, -0.02434668f, -0.05265960f, -0.05293864f, 
    -0.01813545f, 0.02606099f, -0.03401229f, 0.00233442f, 0.03901067f, 0.03983076f, -0.00841466f, -0.03750254f, 
    0.02912156f, 0.02061393f, 0.00046829f, -0.05182171f, -0.05951364f, -0.03314902f, -0.02842149f, -0.01190207f, 
    -0.04142278f, 0.01835310f, 0.01942925f, -0.01102492f, -0.02448684f, -0.00554722f, -0.03132278f, -0.01321550f, 
    -0.00060036f, -0.01534821f, -0.01240227f, -0.04357057f, -0.05231873f, -0.03242408f, -0.03255717f, -0.03154555f, 
    -0.03482057f, -0.03635274f, -0.04850649f, 0.03695060f, -0.02528661f, 0.03401655f, -0.03848630f, -0.05726642f, 
    -0.01374779f, -0.05221594f, -0.03838870f, -0.04658853f, -0.03659843f, 0.01552359f, -0.00339397f, 0.00505674f, 
    0.00798863f, -0.02259876f, 0.02712782f, 0.03201900f, -0.03771327f, 0.01791956f, -0.01771173f, -0.05418460f, 
    -0.04471326f, -0.03058222f, -0.02067509f, -0.01522216f, -0.03385328f, 0.03562908f, 0.04341531f, -0.01198513f, 
    0.00027677f, -0.00991590f, 0.03511221f, -0.04439923f, -0.02176237f, 0.00885193f, -0.01535039f, -0.01089549f, 
    0.01370971f, -0.04514421f, -0.05826321f, 0.00132058f, 0.00718394f, -0.00093038f, 0.04054227f, -0.01063361f, 
    0.02291172f, -0.05149872f, -0.03231062f, -0.04951617f, 0.01675203f, -0.04317303f, 0.02826466f, -0.01502013f, 
    -0.01952367f, 0.00515759f, 0.01754933f, -0.03117783f, -0.05816730f, 0.03952594f, -0.01607161f, 0.00701947f, 
    -0.03388365f, 0.03729367f, -0.02071484f, -0.03747547f, -0.04376592f, 0.04057979f, 0.00640820f, 0.02989164f, 
    0.03996956f, 0.01562650f, -0.05289956f, 0.02960161f, 0.01777451f, 0.00746848f, -0.00771741f, -0.03255771f, 
    -0.01224754f, -0.01939874f, 0.00308039f, -0.00820303f, 0.03652553f, 0.02408329f, -0.00228789f, 0.01649568f, 
    0.02084190f, 0.02912737f, 0.03408536f, -0.04215125f, 0.02363121f, 0.01486922f, 0.03571961f, 0.01083826f, 
    0.02564650f, 0.00020465f, -0.00970022f, -0.02299816f, -0.00342825f, -0.01128758f, -0.03674438f, -0.05222701f, 
    -0.06055615f, -0.01572004f, 0.04155626f, 0.01231291f, -0.02995629f, -0.03966248f, -0.00671336f, -0.03537408f, 
    0.01754520f, -0.05457335f, -0.01015680f, 0.02781531f, 0.02044134f, -0.03284193f, 0.02122767f, 0.01633134f, 
    0.03682678f, -0.02689683f, 0.01068732f, 0.04587870f, 0.00030703f, -0.04968957f, 0.01037326f, -0.02930385f, 
    -0.00620538f, -0.00097907f, 0.02554130f, 0.01884594f, 0.03011713f, -0.04876255f, 0.01885377f, -0.02352915f, 
    -0.02035972f, 0.00812266f, -0.01074437f, -0.01853089f, 0.00551533f, -0.02713113f, -0.00333385f, -0.00947417f, 
    0.03918365f, -0.02993364f, -0.02090257f, -0.03580153f, -0.04195250f, 0.00766842f, 0.01070818f, 0.01165362f, 
    -0.01230820f, -0.00770057f, 0.02585803f, 0.03155753f, -0.00785697f, 0.03753509f, 0.00798968f, -0.00725656f, 
    -0.00515725f, -0.00523985f, -0.01425739f, -0.02655597f, -0.02588005f, -0.01531052f, 0.02371789f, 0.03376249f, 
    -0.02618015f, -0.04935718f, 0.02240856f, -0.05705024f, 0.00366946f, 0.02553181f, -0.05463245f, 0.00447749f, 
    -0.02653841f, -0.05897837f, -0.03096127f, 0.01385793f, 0.03332286f, 0.03298466f, -0.05344668f, -0.02910663f, 
    0.03146885f, -0.02570715f, -0.05689340f, -0.04274309f, 0.00523222f, -0.04964374f, -0.01228100f, 0.03710767f, 
    -0.02096400f, -0.02047286f, -0.01563539f, -0.05834684f, -0.00680998f, -0.05710918f, 0.02459815f, 0.03824243f, 
    -0.04552421f, -0.04761463f, -0.04073193f, -0.05697513f, -0.01777689f, 0.02502876f, 0.01519163f, -0.01039150f, 
    -0.05847711f, -0.00192820f, -0.03196704f, 0.01869684f, -0.03037979f, -0.01594892f, -0.02841840f, 0.02809483f, 
    -0.03930498f, -0.01840857f, -0.05117485f, -0.00317593f, -0.00572282f, 0.00026165f, -0.03562830f, -0.02416961f, 
    0.03463754f, 0.00491705f, 0.00785310f, -0.04949120f, -0.04336593f, 0.01563802f, -0.02248295f, 0.03484669f, 
    -0.02441489f, -0.00425086f, -0.05361138f, -0.01732467f, 0.03639074f, -0.05247095f, 0.02517274f, -0.05329039f, 
    0.01711884f, -0.00059820f, -0.05644793f, 0.01211351f, -0.03781720f, -0.03097969f, -0.05300726f, 0.00366022f, 
    0.01392184f, -0.01143264f, 0.02933240f, -0.05110613f, -0.01279160f, -0.04997292f, 0.01769404f, -0.01274769f, 
    0.02435887f, -0.05294500f, -0.00652069f, -0.05035878f, -0.03992037f, 0.02724701f, -0.00273600f, 0.04050909f, 
    0.00532073f, -0.05694624f, -0.01474523f, 0.04135823f, 0.03664512f, -0.04069156f, -0.04275379f, 0.02948338f, 
    -0.00303002f, -0.02372808f, 0.02918203f, 0.01552655f, 0.02400130f, -0.03209288f, 0.02497627f, 0.02234535f, 
    -0.04170766f, -0.01478914f, 0.00315779f, -0.03476540f, -0.03372144f, 0.02931434f, -0.02420574f, 0.02728684f, 
    0.03522177f, 0.03436333f, -0.04969946f, -0.01613137f, 0.00412100f, 0.00635175f, -0.02356315f, 0.00216395f, 
    -0.03800119f, -0.04347498f, -0.04116761f, 0.04553793f, 0.01233025f, 0.00876555f, 0.02427610f, 0.00449196f, 
    0.01361292f, 0.02159601f, 0.00690676f, -0.02160709f, 0.00026690f, 0.04027703f, 0.02429709f, -0.04917082f, 
    -0.05853597f, -0.00746316f, 0.03070669f, -0.01801045f, -0.01160123f, -0.05431563f, 0.01159242f, -0.03523219f, 
    -0.05165820f, -0.03339821f, 0.02262572f, -0.04618100f, -0.04932305f, -0.00597298f, 0.00987670f, -0.02272166f, 
    -0.02188459f, -0.03653902f, -0.00400805f, 0.02614440f, -0.03517909f, -0.03444883f, 0.02112747f, -0.00908440f, 
    -0.04148318f, -0.02760963f, -0.03985339f, -0.01530425f, 0.02508176f, -0.04792760f, -0.05316438f, -0.05971821f, 
    -0.01639240f, 0.01795688f, -0.02201515f, 0.01868481f, -0.05467661f, 0.01313548f, 0.00359119f, -0.03114032f, 
    0.01522982f, 0.03520761f, 0.02925764f, 0.02199868f, -0.01002709f, 0.03998135f, 0.03029063f, -0.02041178f, 
    0.00566098f, 0.00293802f, 0.03306115f, 0.03527771f, -0.04031194f, -0.03131331f, -0.01728710f, -0.04917166f, 
    0.02246438f, -0.02891105f, -0.00643424f, -0.03434042f, 0.02781818f, 0.01937016f, 0.00151820f, 0.00709482f, 
    0.01728331f, 0.01324284f, -0.00837436f, 0.00468643f, -0.00212368f, -0.05191385f, -0.03009326f, 0.02482639f, 
    -0.05645427f, -0.02561041f, 0.00905754f, -0.05349494f, -0.01428412f, -0.04309473f, -0.05515104f, -0.05689065f, 
    -0.01174354f, -0.00716092f, 0.00425972f, 0.01916805f, -0.02586087f, 0.02918646f, -0.05570837f, -0.00126434f, 
    0.05096620f, -0.00676914f, 0.01611155f, 0.04124099f, 0.04219341f, -0.05590314f, 0.02103362f, -0.03379927f, 
    -0.05770335f, -0.00534649f, 0.01085007f, 0.01955270f, -0.00611598f, 0.00210650f, 0.03517116f, -0.05102053f, 
    -0.03552692f, 0.02287157f, 0.03884105f, 0.02711390f, -0.00273794f, 0.01216488f, -0.04994517f, -0.01837580f, 
    -0.04355841f, -0.01464240f, -0.00471878f, -0.00208032f, -0.02965744f, -0.04213503f, -0.05355733f, -0.02622715f, 
    -0.04305153f, 0.02094884f, 0.01718862f, -0.00584072f, 0.02916461f, -0.01719398f, -0.03910711f, -0.03375033f, 
    -0.04734895f, 0.03888313f, -0.02484878f, -0.04114312f, -0.01102926f, -0.02650565f, 0.02429723f, -0.02240334f, 
    -0.01035873f, 0.02276397f, 0.04102769f, -0.03634034f, -0.05284633f, -0.02545036f, -0.03097757f, -0.04647848f, 
    0.00792250f, -0.02133468f, -0.00371346f, -0.05358721f, -0.01783899f, 0.02203129f, -0.02305327f, -0.00686271f, 
    -0.03289345f, 0.02497778f, -0.02937310f, -0.01636287f, 0.00694000f, 0.02198377f, -0.01451349f, -0.00186835f, 
    -0.04834630f, 0.04069247f, 0.00379064f, 0.00768301f, -0.04818100f, 0.02528973f, -0.04232192f, 0.03275522f, 
    -0.02029201f, 0.00583548f, -0.01793504f, -0.04593179f, -0.05076256f, -0.04536882f, -0.01656268f, 0.02933086f, 
    0.04574885f, -0.02402643f, 0.03716803f, -0.00218785f, -0.00037064f, -0.00994904f, -0.02270206f, 0.01309588f, 
    -0.02555400f, 0.03778644f, -0.00245913f, -0.00239654f, 0.00141274f, -0.05339948f, 0.02431317f, -0.01996704f, 
    0.00317206f, 0.04140685f, 0.03659370f, 0.03132142f, -0.02847211f, 0.02437885f, 0.00911432f, 0.02564445f, 
    0.02078310f, -0.00518350f, 0.00026781f, -0.05187843f, 0.03634689f, 0.01690783f, -0.03958887f, 0.03079234f, 
    0.03787936f, 0.01223929f, -0.02352492f, -0.03359486f, 0.00636824f, -0.04671458f, 0.00831173f, -0.04000149f, 
    0.00963458f, 0.03166487f, -0.01478089f, -0.01561038f, -0.04182455f, 0.03626101f, -0.00668685f, -0.00861695f, 
    0.00233378f, 0.00895127f, -0.03507785f, -0.00854847f, -0.04308134f, -0.00831407f, -0.02913968f, 0.03988525f, 
    -0.01340995f, 0.02528884f, 0.00824202f, -0.02411162f, -0.05195805f, 0.03044870f, -0.01305675f, 0.01297720f, 
    0.04120333f, 0.03395806f, -0.03205612f, 0.00100569f, -0.02654283f, -0.05522511f, -0.03922350f, -0.00094280f, 
    -0.00589081f, 0.00720282f, -0.00907927f, 0.01887810f, -0.00290437f, 0.01045291f, 0.00635026f, 0.01056242f, 
    -0.03533754f, -0.04661390f, 0.02668090f, 0.01902238f, 0.03715720f, -0.02294154f, -0.03805931f, -0.00696995f, 
    -0.04506891f, 0.04461635f, 0.04201604f, -0.03891039f, -0.00554325f, -0.01589249f, -0.01789190f, -0.00802446f, 
    0.03990339f, 0.02578889f, -0.02858624f, 0.01632515f, -0.03294626f, -0.01419017f, 0.00899835f, 0.03919525f, 
    0.34215084f, -0.16668729f, 0.02094198f, 0.05143656f, -0.04262060f, -0.02544026f, 0.06378371f, 0.07587368f, 
    -0.01119022f, -0.03850486f, 0.02715746f, 0.10749716f, 0.05235894f, -0.08307454f, -0.00501399f, 0.08566444f, 
    -0.05531472f, 0.10447431f, 0.05869824f, 0.06578809f, 0.07864330f, 0.15290953f, 0.20511714f, 0.15198301f, 
    0.26641670f, 0.14863119f, -0.46423614f, -0.23265395f, -0.04276211f, 0.14189129f, 0.02520823f, -0.00901003f, 
    -0.04524104f, 0.01509922f, -0.08532207f, -0.00809522f, -0.33088720f, 0.01630825f, 0.14786443f, 0.04728765f, 
    -0.01998581f, -0.11561012f, 0.11046155f, 0.07514189f, -0.05989976f, 0.04558793f, 0.03817170f, -0.03814773f, 
    0.17554139f, -0.12496763f, 0.05719779f, -0.12169675f, 0.08043084f, 0.03300193f, -0.06963010f, -0.02996596f, 
    0.06220267f, 0.00895390f, 0.06760003f, 0.02072476f, -0.27230117f, 0.05276096f, 0.02363242f, 0.01361394f, 
    0.08606189f, -0.07157136f, -0.07790133f, -0.10920794f, -0.03189902f, 0.10392501f, 0.01533690f, 0.07088210f, 
    0.15347530f, -0.11266297f, 0.04124869f, 0.05469680f, 0.09931013f, -0.07600332f, 0.05692183f, 0.10201154f, 
    0.08796180f, 0.06770501f, 0.13396558f, 0.00744069f, -0.00286893f, 0.07038916f, 0.03540179f, 0.11291096f, 
    0.06502043f, 0.05069765f, -0.02654150f, -0.01727512f, 0.06449458f, 0.06037724f, -0.03824797f, -0.11169236f, 
    -0.05686191f, 0.25461099f, -0.00832928f, -0.16232459f, -0.04022546f, 0.06479047f, -0.03515974f, -0.07525671f, 
    0.06546970f, 0.02645005f, -0.09407626f, -0.09730235f, -0.10958122f, 0.03182428f, -0.17847399f, 0.01350171f, 
    0.02342184f, -0.13262790f, -0.05810505f, -0.06590872f, -0.01218426f, -0.05419893f, -0.00012188f, -0.05776661f, 
    -0.20324130f, 0.06970199f, 0.08881764f, -0.05392645f, 0.00233781f, -0.02302784f, 0.02945979f, -0.12320543f, 
    -0.08141407f, -0.00833232f, -0.01722249f, -0.12857148f, 0.10055403f, 0.04810821f, -0.06727903f, -0.27870420f, 
    0.07471710f, 0.00059162f, 0.05942097f, 0.05707209f, 0.14740969f, 0.04745117f, 0.00047304f, -0.00042984f, 
    -0.03772466f, 0.14689673f, 0.04473185f, -0.01665963f, -0.04745503f, 0.06356306f, 0.00600084f, 0.00128975f, 
    0.12403438f, -0.00107145f, 0.17468354f, 0.06917560f, -0.20317167f, 0.15404001f, 0.01581068f, 0.10382351f, 
    -0.03593800f, 0.03686850f, 0.12944582f, 0.14546333f, -0.03927225f, -0.01905789f, 0.03663280f, -0.09668599f, 
    0.16967741f, 0.00246961f, 0.05663690f, 0.01075753f, 0.04175918f, -0.00202577f, 0.05976600f, 0.15535298f, 
    -0.10300674f, 0.05731151f, -0.04828767f, -0.03969790f, -0.00292845f, -0.13017765f, 0.15618275f, -0.06548894f, 
    0.09981313f, -0.02903611f, 0.05203626f, -0.10871897f, -0.05018531f, -0.03406763f, 0.04952573f, 0.01201315f, 
    0.17323831f, 0.24360166f, -0.08488365f, -0.17829935f, 0.01166494f, 0.15599766f, 0.06243970f, 0.03687529f, 
    -0.01546324f, 0.15351017f, -0.12173100f, -0.14385583f, 0.06348231f, -0.11172741f, -0.05067819f, -0.04859664f, 
    -0.00396104f, -0.00213673f, -0.10679169f, 0.02082345f, 0.00243263f, -0.08299679f, -0.03604737f, 0.03231357f, 
    0.72704083f, -0.11371010f, 0.11613937f, 0.08691189f, -0.04940019f, 0.07038406f, 0.05974536f, -0.05796033f, 
    0.06740557f, -0.02523424f, 0.06349861f, -0.00849143f, -0.26665589f, 0.09958485f, 0.10706748f, -0.02096926f, 
    0.06455076f, 0.11532204f, -0.02642121f, -0.02629107f, 0.07907950f, 0.09360037f, 0.02273984f, -0.06219251f, 
    -0.20701928f, 0.08338030f, 0.03013839f, 0.00069075f, -0.07938185f, 0.04870394f, 0.06759724f, -0.08733914f, 
    0.02445540f, 0.00448580f, 0.00354466f, -0.06774637f, -0.02427369f, -0.07857830f, 0.09734413f, -0.06177872f, 
    0.06443588f, -0.04652338f, -0.02894194f, 0.04364036f, 0.00792047f, -0.04718896f, -0.02341866f, 0.12568147f, 
    0.21860239f, -0.20800866f, -0.18205534f, 0.03058236f, -0.12060403f, 0.01933178f, -0.05912801f, -0.03157588f, 
    -0.05291610f, 0.04570785f, 0.00716506f, -0.06436873f, 0.27432093f, -0.27035227f, -0.07397035f, 0.10754900f, 
    -0.02164687f, 0.04772299f, -0.08253822f, 0.07009839f, 0.07836784f, 0.07615124f, -0.06816546f, 0.13048971f, 
    0.04116672f, 0.22770488f, -0.21061406f, -0.26078299f, 0.12391001f, 0.08812191f, 0.03912700f, 0.00302786f, 
    -0.08158851f, 0.03261901f, 0.04012486f, 0.03433502f, -0.26506788f, 0.02806712f, 0.06357308f, 0.07526075f, 
    0.03543793f, -0.02623159f, 0.12399712f, 0.00572087f, -0.08895456f, -0.10448885f, -0.01093418f, 0.02527465f, 
    -0.14552462f, 0.10559972f, 0.11579388f, 0.02662703f, -0.04632328f, 0.10818568f, 0.21295963f, 0.09997405f, 
    -0.05747433f, 0.02884141f, -0.01963317f, 0.14469858f, -0.18497840f, 0.10145215f, -0.12205530f, 0.05404116f, 
    -0.01577456f, 0.15435806f, 0.02419795f, 0.00719511f, 0.03074549f, 0.12818421f, 0.07052181f, -0.00458754f, 
    0.22628699f, 0.05321253f, -0.09982253f, -0.21089286f, 0.00709751f, -0.02708600f, 0.01133540f, 0.07946669f, 
    -0.06148317f, 0.02178233f, 0.04549688f, 0.02353257f, -0.04211556f, 0.04282904f, -0.04412904f, -0.13689318f, 
    0.02196997f, 0.00508841f, -0.02420716f, -0.12122393f, 0.01302921f, -0.00848921f, 0.03330761f, 0.07008505f, 
    -0.30531582f, -0.20902106f, -0.09281670f, 0.09276206f, -0.04130976f, 0.00139683f, 0.02986477f, -0.07411532f, 
    0.04740065f, -0.02028407f, 0.11422680f, 0.19449183f, 0.10604289f, -0.05475931f, 0.07622967f, 0.06202845f, 
    -0.04096701f, -0.04231426f, -0.04078605f, -0.11172041f, -0.05481280f, 0.09330611f, 0.08352481f, -0.03786035f, 
    -0.18781234f, -0.16438188f, -0.03189955f, -0.06471533f, 0.02562308f, 0.12810662f, -0.02139680f, 0.04463207f, 
    -0.00299804f, -0.04245709f, 0.10259730f, 0.17827916f, 0.05178890f, 0.06957883f, 0.23282059f, 0.10304905f, 
    0.00155377f, 0.05861510f, -0.02663335f, 0.17390843f, 0.02113347f, 0.04852230f, 0.07637813f, 0.05477399f, 
    0.14982864f, 0.33086786f, 0.04078713f, 0.05560012f, -0.01330499f, -0.08533932f, 0.09288543f, 0.06603440f, 
    0.01751705f, 0.09342449f, 0.01466093f, -0.04251835f, 0.08368083f, -0.16741841f, -0.19737558f, 0.07574991f, 
    -0.04433910f, 0.00306157f, 0.04086918f, -0.02970041f, -0.00313319f, 0.05494067f, 0.02093683f, 0.01919753f, 
    -0.15482849f, -0.04049877f, -0.03702801f, -0.05253356f, -0.03391741f, -0.04727295f, -0.00394255f, 0.02099215f, 
    0.12301466f, -0.03549990f, 0.15320934f, -0.07817888f, 0.18684706f, 0.26712212f, 0.19857220f, 0.25696456f, 
    -0.08834422f, -0.08870957f, 0.00793890f, 0.01079932f, -0.08553110f, 0.02838369f, 0.04896602f, 0.04916029f, 
    0.43703556f, -0.07310347f, 0.13954803f, 0.00805496f, -0.01239357f, -0.02952248f, -0.01484291f, 0.05227352f, 
    -0.06442025f, 0.06441201f, -0.00685188f, -0.06789367f, 0.31726739f, 0.18644230f, 0.24069436f, 0.26980516f, 
    0.01120415f, 0.04136929f, 0.01487447f, 0.02042750f, 0.01974078f, 0.09045286f, -0.00852182f, -0.13030393f, 
    -0.04792617f, 0.12700063f, 0.14267762f, 0.09485374f, 0.01558429f, 0.13250756f, -0.04805909f, 0.07960714f, 
    -0.00659953f, -0.06881639f, 0.00264093f, 0.10487324f, 0.02788937f, 0.06335031f, -0.04317634f, 0.09052889f, 
    -0.05170995f, -0.07553832f, -0.06538641f, -0.05750205f, 0.01209807f, 0.16094780f, 0.11804723f, -0.13170163f, 
    -0.04026607f, -0.11015511f, 0.16223814f, 0.11768544f, -0.04097846f, 0.15927552f, -0.02170140f, 0.01241605f, 
    0.00607288f, -0.08930571f, -0.06383920f, -0.00110340f, 0.13187440f, -0.02664183f, 0.05430273f, -0.20874070f, 
    -0.09614114f, -0.00162045f, -0.02120237f, 0.03801985f, -0.01696425f, -0.06006284f, 0.08074106f, -0.03990766f, 
    0.00038120f, 0.11141393f, 0.03166080f, 0.26583329f, -0.14781323f, 0.02412711f, 0.07209237f, 0.07133123f, 
    0.08924609f, 0.02297027f, 0.06203461f, -0.24219278f, -0.13896222f, 0.16533947f, 0.10757595f, 0.21803187f, 
    0.12663954f, 0.03597582f, 0.11502608f, 0.01006860f, 0.06171257f, 0.01728810f, 0.04362828f, -0.07494851f, 
    -0.31133395f, -0.04031923f, -0.07895070f, -0.13169497f, 0.03248442f, 0.09322916f, -0.00550400f, 0.03932537f, 
    0.17442568f, 0.10902970f, 0.09492648f, -0.00380459f, 0.37191644f, -0.19997630f, 0.03173025f, 0.18947537f, 
    -0.10383909f, -0.02193109f, 0.03705003f, -0.04590028f, -0.01021079f, -0.06282018f, -0.07646782f, -0.00780528f, 
    -0.14319146f, 0.18097223f, 0.12433666f, 0.04680619f, -0.02815851f, -0.01678719f, -0.06252962f, -0.01345578f, 
    0.06783315f, 0.01200362f, -0.11452492f, 0.04327154f, -0.15708452f, 0.14658192f, 0.02880144f, -0.24790373f, 
    0.06696834f, -0.05353132f, -0.13039571f, -0.09309090f, 0.17129961f, 0.06949788f, -0.01424478f, 0.18904598f, 
    0.12436772f, 0.12114304f, 0.20570382f, 0.06618975f, 0.06014553f, -0.00130992f, 0.00014775f, -0.03445536f, 
    0.03952347f, 0.00735388f, 0.04742408f, 0.02046686f, 0.06409306f, 0.12210947f, 0.16100842f, 0.36396056f, 
    -0.11765447f, 0.00852674f, -0.03158911f, 0.13338485f, 0.09687736f, -0.04023236f, 0.01903895f, -0.01054292f, 
    0.01325507f, 0.28539062f, 0.07864206f, 0.46701941f, -0.08450536f, -0.05247849f, 0.16643634f, 0.13252506f, 
    0.04447901f, 0.09712285f, 0.00566521f, -0.00691725f, 0.31794807f, -0.04427051f, 0.11143365f, -0.02359610f, 
    -0.09620731f, 0.03018343f, -0.08711560f, 0.04232525f, -0.11562848f, 0.00333206f, 0.00198401f, 0.00773894f, 
    -0.21795519f, 0.04782454f, -0.19470721f, 0.10296752f, 0.17099670f, -0.07579766f, -0.02800309f, 0.11169987f, 
    0.15413345f, -0.05702099f, -0.01199896f, 0.06953461f, 0.24630961f, 0.03223899f, 0.07275693f, -0.04720870f, 
    0.00851094f, 0.14220019f, 0.09396761f, -0.11158192f, -0.15914090f, -0.02445468f, 0.12923893f, 0.01705573f, 
    -0.06506023f, 0.31367710f, -0.06373709f, 0.10709708f, 0.07947264f, -0.00037340f, 0.08526437f, 0.07919063f, 
    -0.04501002f, 0.06038570f, -0.09232143f, -0.13793163f, 0.22637251f, -0.15740430f, -0.27731219f, 0.09160887f, 
    -0.01841443f, -0.06478087f, 0.13941760f, -0.05455927f, -0.09061593f, -0.00970958f, -0.01609395f, -0.07530188f, 
    -0.19434395f, 0.04113486f, -0.09589982f, -0.21405034f, 0.01238882f, 0.09091909f, 0.16527566f, 0.05065772f, 
    0.10058672f, -0.08953000f, 0.13029929f, 0.09783441f, -0.04446225f, 0.06767704f, -0.00730370f, -0.06314248f, 
    0.06872244f, 0.17412032f, 0.00770612f, 0.01902533f, -0.09851039f, 0.05666442f, 0.05078857f, -0.04948916f, 
    -0.14235210f, 0.32704845f, -0.02803749f, 0.01820157f, -0.07013533f, 0.08409373f, 0.11920793f, -0.03844468f, 
    -0.00125910f, 0.02080122f, -0.19958980f, -0.01507360f, 0.08246571f, 0.02991953f, -0.09191012f, -0.06104266f, 
    0.00488342f, 0.05924017f, 0.00472902f, 0.05639829f, 0.02562855f, -0.10284048f, 0.02345494f, 0.08417760f, 
    -0.00172310f, -0.15365575f, -0.07846920f, -0.07000498f, 0.01893080f, -0.02002005f, 0.13858524f, -0.09430815f, 
    0.10139628f, 0.05626498f, 0.05754948f, 0.09809199f, -0.03330855f, -0.21703309f, 0.04425242f, -0.03671911f, 
    -0.00892807f, 0.03853671f, -0.04937577f, 0.06404158f, 0.00962509f, 0.06408574f, -0.04001692f, 0.00274981f, 
    -0.02278142f, -0.01148476f, -0.00993146f, -0.02946268f, -0.03126661f, 0.03933940f, -0.02374361f, -0.05454436f, 
    -0.03429063f, -0.04582074f, -0.03565051f, -0.02691753f, -0.05580951f, -0.02268244f, -0.02237905f, 0.03427756f, 
    -0.01827169f, -0.03088991f, -0.00621026f, -0.00682415f, -0.04742308f, 0.01023587f, -0.00112663f, 0.06550916f, 
    0.00794119f, -0.04179064f, 0.02071710f, 0.03304587f, 0.02520614f, 0.01987019f, -0.01473644f, -0.04054531f, 
    -0.02057085f, 0.00156408f, -0.03586261f, 0.03224532f, -0.00507159f, -0.00070866f, 0.01290290f, -0.04080461f, 
    0.00129121f, -0.01471518f, -0.03488249f, -0.02372226f, 0.02480632f, -0.03882503f, -0.02751946f, -0.05076931f, 
    0.00489190f, 0.01628753f, 0.03328342f, 0.01501810f, -0.03419125f, 0.02484415f, 0.01857340f, -0.01440273f, 
    0.00178027f, -0.01441307f, -0.00787452f, -0.05831906f, -0.04693297f, 0.03177838f, -0.05869579f, -0.03576271f, 
    0.00473159f, 0.00734843f, -0.01981192f, -0.05490725f, -0.01243701f, -0.01753490f, -0.01143195f, 0.03256727f, 
    -0.01560964f, -0.03447150f, -0.02079697f, -0.02693356f, 0.02854068f, 0.03603001f, -0.03839147f, -0.04587894f, 
    0.01814332f, -0.01493659f, 0.02212272f, 0.00324505f, -0.06006016f, -0.02478522f, -0.01515021f, 0.03611140f, 
    0.00004784f, 0.02006268f, 0.00920402f, -0.01975149f, -0.02517431f, 0.03461542f, -0.02499538f, -0.02022884f, 
    0.03016220f, 0.03273425f, -0.03631418f, -0.05697047f, -0.01126398f, -0.03568668f, -0.03345235f, -0.01981885f, 
    -0.06023068f, -0.00332644f, -0.05216492f, -0.02264769f, -0.00212093f, -0.00143173f, -0.04668769f, -0.01703925f, 
    -0.05040601f, 0.02376992f, -0.01908619f, 0.02237878f, -0.01419728f, -0.03870615f, 0.02578937f, 0.03150561f, 
    -0.05230574f, 0.00889461f, 0.00464359f, 0.02175423f, -0.01082222f, -0.01203986f, -0.05173095f, -0.00047009f, 
    -0.05104251f, 0.01990896f, -0.06019795f, -0.01483362f, -0.01570069f, -0.02999368f, 0.03241528f, 0.02185331f, 
    -0.06389801f, -0.03003880f, -0.01993008f, 0.04432693f, -0.03934838f, -0.02339856f, -0.01140587f, -0.00686201f, 
    -0.01009441f, -0.05040275f, -0.03362001f, -0.04891706f, -0.06119598f, -0.00293456f, 0.01822619f, -0.02948608f, 
    -0.01384538f, 0.03157032f, 0.02168593f, -0.02147724f, -0.05916506f, -0.05485183f, -0.04697607f, -0.01260231f, 
    -0.01994539f, 0.03031528f, 0.00443432f, 0.04686375f, 0.02085834f, -0.05828452f, 0.06523246f, -0.02005525f, 
    -0.03443478f, 0.00518033f, 0.01059141f, -0.05644656f, -0.05396782f, 0.01962390f, -0.00715650f, 0.04743150f, 
    0.02278747f, -0.00961693f, -0.02057112f, -0.00745167f, -0.02212874f, 0.02358609f, -0.01335317f, 0.03173644f, 
    -0.03107600f, -0.05635093f, -0.03110892f, 0.00710536f, 0.04765122f, -0.02604075f, 0.02125453f, 0.01904107f, 
    -0.01053922f, 0.03349454f, 0.03493055f, -0.05803477f, -0.01939408f, -0.06036749f, 0.03199608f, 0.03374540f, 
    0.00204383f, -0.04485446f, -0.04183275f, 0.01595946f, -0.02521589f, -0.01228622f, 0.05680226f, -0.03306954f, 
    0.03802404f, 0.00648519f, -0.04551186f, 0.04626028f, -0.01502072f, -0.01669829f, 0.03487295f, -0.01689318f, 
    0.02054597f, 0.01780829f, 0.02450042f, 0.00286865f, -0.00947242f, -0.04555455f, -0.02800071f, 0.01232624f, 
    -0.02034268f, 0.00143465f, -0.04392349f, -0.01696996f, 0.03541914f, -0.02736262f, 0.03209049f, 0.00230110f, 
    -0.02569404f, 0.04451494f, -0.05209157f, 0.01292579f, 0.03500203f, -0.05208284f, -0.03870348f, -0.02897984f, 
    -0.01491569f, -0.00078904f, -0.04088502f, 0.00359494f, -0.00417330f, 0.03165907f, 0.03986037f, -0.01779745f, 
    0.03172411f, -0.04565300f, 0.01803917f, 0.00806244f, 0.00571180f, -0.00025752f, -0.04891498f, -0.06337680f, 
    -0.02323707f, -0.01907094f, 0.01624114f, -0.05944006f, -0.02581306f, 0.03370302f, 0.03956263f, 0.00749584f, 
    0.00547003f, -0.03048779f, -0.05082666f, 0.02747431f, -0.05989468f, 0.00422187f, -0.00368217f, -0.03486646f, 
    -0.00363368f, -0.06640562f, -0.05993725f, 0.02040635f, 0.05120320f, -0.01500298f, 0.02003745f, -0.05141460f, 
    -0.05954910f, -0.02966701f, -0.06213323f, -0.01709591f, -0.03492041f, 0.03115518f, -0.04047847f, 0.00108642f, 
    -0.05312664f, -0.02393119f, -0.03586461f, 0.02096998f, -0.03443030f, -0.03280275f, 0.00234795f, 0.00593452f, 
    -0.02863408f, -0.03573133f, -0.01707060f, -0.01621804f, 0.04861604f, 0.00625814f, 0.03934917f, 0.03224840f, 
    -0.02856630f, -0.01676450f, 0.01530458f, 0.02663448f, -0.03899526f, 0.01975734f, 0.00936943f, 0.02084753f, 
    -0.03917886f, 0.03663602f, -0.03671949f, -0.02784657f, -0.04635378f, 0.02248648f, -0.05522478f, 0.04388835f, 
    0.03432820f, -0.04312187f, -0.02322763f, -0.03485833f, -0.00917277f, 0.01669779f, -0.02114350f, -0.04379558f, 
    -0.03939414f, 0.02050616f, -0.00181130f, 0.03547021f, 0.03577466f, 0.00776152f, -0.04993924f, 0.00338999f, 
    -0.03078076f, -0.00719569f, -0.00780028f, 0.02245485f, 0.04951279f, -0.03519324f, 0.01090345f, -0.03763858f, 
    0.03183836f, -0.05443260f, -0.00687225f, 0.04492497f, -0.00405470f, -0.00486648f, -0.01963268f, -0.04411061f, 
    0.04227940f, -0.01540174f, 0.04870716f, -0.02123460f, -0.04191925f, -0.00857863f, -0.06117387f, 0.01373242f, 
    -0.00075731f, -0.01638939f, 0.03136248f, -0.00554227f, 0.01496539f, 0.05157188f, 0.01933804f, 0.02793904f, 
    -0.05621707f, -0.02874709f, -0.03730433f, -0.02832574f, -0.02166300f, 0.00601813f, -0.00203489f, -0.01146277f, 
    -0.04528168f, 0.02660071f, -0.01313613f, -0.00794627f, -0.03557030f, -0.02038388f, -0.02625176f, 0.03716261f, 
    -0.06715313f, 0.04406358f, 0.02353033f, 0.35177976f, -0.10534027f, -0.09546953f, 0.04621586f, 0.19309759f, 
    -0.00042005f, 0.04990701f, -0.07792076f, -0.19280329f, 0.09268955f, 0.12567119f, -0.01807739f, -0.11755361f, 
    0.04370775f, -0.02456259f, -0.06449675f, -0.02876477f, 0.04682657f, -0.03067997f, -0.04260193f, -0.05591650f, 
    0.18743275f, -0.09156361f, -0.16704445f, -0.13398647f, 0.00835285f, 0.03768406f, -0.00013403f, 0.02690930f, 
    0.08693311f, -0.03898870f, 0.05334411f, 0.09014864f, -0.07041761f, 0.04517868f, 0.27896971f, 0.04544865f, 
    0.04919329f, 0.01467546f, 0.02589592f, 0.06282611f, 0.04039937f, -0.03613632f, 0.04422792f, 0.08932947f, 
    0.05725199f, -0.08015651f, -0.12535396f, 0.11635515f, 0.00217861f, -0.02326863f, 0.04100478f, 0.03186415f, 
    -0.09540470f, 0.07485316f, -0.08383615f, 0.13014108f, -0.01876220f, -0.05582591f, -0.01229420f, -0.02082168f, 
    0.29375452f, 0.23002151f, 0.06773268f, -0.02005028f, 0.06616149f, -0.09903369f, 0.03498659f, -0.01988362f, 
    0.05531182f, 0.25824788f, 0.08763967f, -0.04394373f, 0.00029317f, 0.04773210f, 0.17376146f, -0.03286828f, 
    0.08999633f, -0.02998423f, 0.01139831f, -0.01367232f, -0.13243985f, -0.10607009f, -0.11514963f, 0.05841355f, 
    0.10627490f, 0.07466485f, 0.01609291f, -0.06547017f, -0.04931405f, -0.00277511f, -0.03744737f, 0.10425011f, 
    -0.00513592f, -0.25811139f, -0.13529667f, -0.10162795f, -0.01915223f, -0.06602706f, 0.03518979f, 0.02024775f, 
    0.04112685f, 0.07510233f, 0.06307869f, -0.04646861f, -0.11780214f, -0.17551456f, -0.05969979f, -0.02904166f, 
    -0.01106448f, 0.09942575f, 0.06992757f, -0.00283572f, 0.06531861f, -0.14121221f, -0.17277494f, 0.19765675f, 
    -0.08796709f, 0.29062027f, -0.06424179f, -0.07934237f, 0.06631366f, -0.09917060f, -0.00078395f, 0.04427091f, 
    0.14774866f, -0.00144384f, -0.09707320f, 0.12419263f, -0.19329149f, -0.06782602f, -0.08724692f, -0.00639082f, 
    0.08337475f, 0.00129679f, -0.00443453f, -0.07418641f, -0.00062300f, 0.09961087f, -0.00565933f, 0.02237382f, 
    0.14061487f, -0.13046899f, -0.07145070f, -0.06856532f, 0.07920954f, 0.09160037f, 0.01125547f, -0.04039205f, 
    -0.07224491f, -0.06334601f, 0.00285435f, 0.14918725f, 0.18815301f, -0.05043926f, 0.03518441f, -0.08317347f, 
    -0.11562408f, 0.03451668f, 0.02776065f, -0.00803564f, -0.06619278f, -0.00939436f, 0.03171126f, 0.15312745f, 
    0.04321832f, 0.21371230f, 0.24146362f, 0.26578286f, -0.12343993f, -0.11025508f, 0.04251936f, -0.01003343f, 
    -0.08071699f, -0.04714338f, 0.06392701f, 0.00471431f, -0.10649970f, 0.09497651f, 0.04410611f, -0.04106046f, 
    0.11539011f, 0.00375494f, 0.01047454f, -0.05046934f, 0.00240757f, 0.01476763f, -0.00446030f, 0.11003549f, 
    -0.01665813f, -0.26273048f, -0.18413587f, -0.10331114f, 0.12219074f, -0.07525843f, -0.04835008f, 0.01011498f, 
    0.05049418f, -0.06278052f, 0.10651517f, 0.07566375f, 0.07509468f, -0.13858077f, -0.13547686f, 0.30939135f, 
    0.05831869f, -0.04995762f, 0.07319999f, 0.06445324f, -0.02182051f, -0.04468477f, 0.03304613f, -0.06628142f, 
    -0.15027165f, 0.10539353f, -0.13109732f, -0.24770711f, 0.04514468f, -0.08971801f, 0.03210434f, 0.11132769f, 
    -0.13324095f, 0.05358001f, -0.10721077f, 0.00388250f, -0.11916101f, 0.09240904f, 0.08401043f, -0.19402403f, 
    0.23503450f, 0.18733478f, 0.05080280f, -0.08287069f, -0.00873801f, -0.05042177f, 0.09458584f, 0.02506771f, 
    0.06588617f, -0.23635508f, 0.06532627f, -0.28870693f, 0.14086840f, 0.27019039f, -0.07432249f, 0.01653187f, 
    -0.05441188f, -0.05336124f, 0.11621799f, 0.02245463f, -0.03546166f, 0.18075646f, 0.05340919f, -0.03117623f, 
    0.21884601f, -0.05569165f, 0.01626065f, 0.01281251f, 0.04708191f, 0.02820105f, -0.01132549f, 0.04148625f, 
    0.31408411f, -0.11847202f, 0.00271411f, -0.10571814f, 0.00356636f, -0.01578566f, 0.13429342f, 0.05591643f, 
    -0.00284875f, 0.07647939f, 0.02893203f, -0.04485349f, -0.11476644f, -0.11452194f, 0.04550613f, -0.04667839f, 
    0.04103752f, -0.09443381f, -0.11952277f, -0.01567838f, 0.07484908f, 0.06746531f, -0.05544885f, -0.11654406f, 
    0.13924466f, -0.24098846f, 0.04791316f, -0.01624303f, -0.01583471f, 0.00231256f, -0.00926679f, -0.10019166f, 
    -0.00598293f, -0.00982243f, 0.08634327f, 0.19984557f, -0.20766081f, 0.16250859f, 0.28560457f, -0.02473865f, 
    -0.01148893f, -0.01749998f, -0.10863715f, -0.02783832f, 0.13783069f, 0.10136219f, 0.03198003f, 0.03638239f, 
    -0.00159977f, -0.10833610f, -0.00306883f, 0.35111851f, 0.02925969f, -0.06728669f, -0.06056032f, 0.03623620f, 
    -0.02957638f, 0.12012372f, -0.01404809f, -0.10391734f, -0.04967412f, -0.23658624f, -0.02251471f, -0.12192649f, 
    0.05053536f, 0.09231500f, 0.00446846f, 0.01660148f, 0.12359761f, 0.03433613f, 0.05671890f, -0.01169894f, 
    0.21341664f, -0.21097641f, -0.04265747f, 0.01855311f, 0.04400398f, -0.04586429f, -0.03573243f, 0.08573908f, 
    0.12156850f, 0.00031379f, 0.15305121f, 0.07857244f, -0.42483139f, -0.30756927f, 0.13115095f, 0.04231402f, 
    0.04256611f, 0.08131079f, 0.10580795f, 0.05861070f, 0.07219927f, 0.02522880f, -0.01006364f, -0.02791540f, 
    -0.23053688f, 0.22188058f, -0.08247145f, -0.05079802f, 0.01549116f, 0.06528648f, -0.13484505f, 0.07831142f, 
    -0.00896319f, 0.02317836f, 0.06174902f, 0.03368025f, 0.27287382f, 0.04532546f, -0.12228767f, -0.03448797f, 
    0.11808012f, 0.05988061f, -0.03803333f, 0.05493373f, 0.03907162f, 0.01259527f, 0.09005930f, -0.00032682f, 
    0.10569168f, 0.02250235f, -0.11048588f, -0.33722344f, 0.06072101f, 0.16622694f, -0.02917304f, 0.02707841f, 
    -0.03990657f, 0.09553675f, 0.06269560f, 0.19827062f, -0.06551666f, -0.16387962f, 0.09627139f, -0.10184269f, 
    -0.02475502f, -0.02670316f, 0.01390718f, -0.12262293f, 0.00047427f, 0.07950635f, 0.03327611f, 0.05674182f, 
    0.41386640f, -0.14508457f, 0.30505341f, 0.27518055f, 0.06063557f, -0.03444789f, 0.02022726f, 0.21265541f, 
    0.02382592f, 0.01958116f, 0.01328508f, 0.17450343f, 0.08246732f, -0.00563452f, -0.05851842f, 0.00084396f, 
    0.04213627f, -0.10146840f, 0.09957487f, 0.07268505f, -0.02818707f, 0.12317610f, -0.12420448f, -0.04247156f, 
    0.14418119f, -0.05599281f, -0.03512108f, 0.12864164f, 0.04721345f, -0.18765661f, 0.00893778f, -0.03893815f, 
    0.04876199f, 0.06169659f, -0.04489182f, -0.01234804f, -0.09946628f, 0.06688630f, -0.06611883f, -0.12772812f, 
    0.02331078f, 0.01928020f, -0.06689335f, -0.13460092f, -0.10538455f, -0.11033105f, 0.04788028f, -0.03749123f, 
    -0.04940210f, 0.18253990f, -0.13214116f, -0.11218336f, 0.12140346f, 0.02489126f, -0.01918826f, -0.03623123f, 
    -0.02794220f, 0.08652060f, 0.12823167f, 0.00978675f, 0.04079589f, -0.01239864f, 0.14189173f, -0.05126183f, 
    0.09013730f, -0.03908192f, -0.07804454f, -0.09393585f, -0.00070194f, -0.02750652f, -0.10718632f, -0.05599196f, 
    0.03444750f, -0.02876711f, 0.08697663f, -0.10529550f, 0.10286828f, 0.09443240f, -0.06785525f, 0.03861237f, 
    -0.13287021f, -0.05801805f, -0.19051540f, -0.00924005f, -0.01463994f, 0.04210749f, 0.01873848f, 0.08713837f, 
    0.05434372f, -0.03937915f, 0.02803897f, 0.00275609f, -0.09205050f, 0.07417136f, 0.15443920f, -0.09432396f, 
    0.18741050f, 0.05902480f, -0.15496315f, -0.09576714f, -0.10624284f, 0.10363282f, -0.20310795f, -0.02748545f, 
    -0.05660255f, -0.09507540f, -0.09363373f, 0.02255729f, 0.24547458f, -0.02174486f, 0.06121195f, 0.01110950f, 
    -0.22509748f, -0.02115986f, 0.04508337f, 0.01648398f, 0.14911158f, -0.12071029f, 0.17224260f, 0.18521553f, 
    -0.22087689f, -0.05970579f, 0.00302918f, 0.09457733f, -0.01152798f, 0.00669397f, -0.20594788f, -0.08356916f, 
    0.07418672f, -0.12264591f, 0.07071096f, -0.11583790f, 0.05468844f, 0.08065184f, -0.01246348f, 0.23232481f, 
    0.06806147f, 0.06170414f, -0.00139365f, 0.00954915f, 0.13220304f, 0.07060375f, 0.08596545f, -0.02348922f, 
    -0.04761183f, -0.13508202f, -0.16429205f, -0.40191811f, -0.09854474f, 0.02569857f, 0.05661299f, -0.15623784f, 
    0.10886405f, -0.10563279f, -0.00207526f, 0.04737955f, 0.06759382f, 0.27755204f, 0.08422802f, -0.12970871f, 
    0.06339555f, 0.03617371f, -0.02958735f, -0.12492882f, -0.00449335f, -0.01931315f, -0.08607573f, 0.00867389f, 
    -0.13180049f, 0.09480625f, -0.04037059f, -0.04540133f, -0.01602825f, -0.09754354f, -0.01399699f, -0.08660743f, 
    0.03308792f, 0.00819408f, -0.18410748f, -0.00713773f, -0.08787562f, 0.01839465f, 0.11188766f, 0.15471645f, 
    0.02583552f, 0.04091821f, -0.02213766f, 0.15730962f, 0.00180523f, 0.20724145f, -0.08717433f, 0.07905509f, 
    0.44618899f, 0.08884998f, 0.06001283f, 0.15482928f, -0.00740793f, -0.01011468f, 0.02878651f, 0.07798048f, 
    0.00743261f, -0.07658808f, -0.01675433f, 0.08455023f, 0.03613939f, -0.00368752f, -0.03977248f, -0.02677308f, 
    0.04238478f, -0.04486980f, -0.08900013f, 0.03007943f, -0.14661983f, -0.01572572f, -0.05755392f, -0.12790179f, 
    -0.06715278f, 0.20126206f, -0.01372567f, 0.25268099f, 0.01842021f, 0.11733804f, -0.02206933f, -0.01455852f, 
    0.07064687f, 0.10652553f, -0.12660012f, 0.00491111f, -0.14403211f, 0.09195946f, 0.02553477f, -0.06179515f, 
    -0.11664622f, 0.08682083f, -0.00547035f, -0.05832149f, 0.12915289f, 0.03105959f, 0.10012531f, 0.05978461f, 
    -0.23460768f, -0.05637960f, -0.00821893f, 0.04265358f, 0.01470614f, -0.05736067f, 0.03080896f, -0.03194651f, 
    0.20053187f, 0.02770052f, -0.18478172f, -0.02519149f, -0.02088584f, -0.09915332f, 0.16347508f, -0.15266019f, 
    -0.02215010f, -0.02146494f, 0.03113373f, -0.09462392f, -0.03525120f, 0.08683569f, -0.00790415f, 0.03107693f, 
    -0.10452044f, -0.19926389f, 0.08768556f, 0.00662654f, 0.08843097f, 0.05665976f, -0.13562593f, 0.09008241f, 
    -0.06372739f, -0.05864485f, 0.04117152f, -0.05831721f, 0.00974115f, 0.06599415f, 0.09001623f, 0.13272934f, 
    0.01814512f, 0.06681801f, 0.02943127f, 0.04341225f, 0.21169138f, -0.02691251f, 0.05399243f, 0.06362605f, 
    -0.11636049f, 0.04424284f, -0.05426281f, -0.04364348f, -0.18243071f, 0.13431208f, 0.11407229f, -0.01345472f, 
    0.00784565f, -0.07591825f, 0.07091837f, 0.09376530f, 0.24880792f, 0.01695231f, -0.02102172f, -0.03820845f, 
    0.02294322f, -0.07987271f, 0.06540411f, -0.03293941f, -0.04804747f, 0.06812288f, -0.00762284f, 0.20027496f, 
    0.44294468f, -0.19172399f, 0.18659218f, -0.04605295f, -0.01976161f, 0.04059440f, -0.12383827f, -0.04615971f, 
    -0.10125478f, -0.02994543f, -0.06961099f, 0.10153908f, 0.02397792f, 0.22441100f, 0.03619318f, 0.10395213f, 
    -0.01605382f, 0.14063227f, 0.00266560f, 0.04307659f, 0.00063035f, 0.10045816f, -0.06830681f, -0.00340915f, 
    0.08622390f, -0.11208785f, 0.06809812f, 0.14420678f, -0.10422229f, -0.02844495f, -0.01957013f, -0.03122416f, 
    0.04517948f, -0.06664663f, -0.00063351f, 0.18206766f, 0.38632992f, -0.10965326f, 0.05042157f, 0.18994878f, 
    0.09835967f, -0.07140505f, 0.12552097f, 0.13010542f, 0.06764195f, 0.02404824f, 0.07408296f, -0.02626421f, 
    -0.20246099f, 0.14596252f, 0.12938271f, 0.11865392f, 0.13168263f, 0.07825562f, 0.00822394f, 0.09161630f, 
    -0.04199559f, 0.06886189f, 0.09299002f, 0.00109377f, -0.38062850f, 0.25589937f, 0.03422631f, 0.06168419f, 
    -0.06438888f, 0.12457993f, 0.06504472f, 0.06725457f, -0.03298270f, 0.10987911f, -0.00814853f, 0.03110374f, 
    0.30255276f, 0.33586228f, 0.03434250f, 0.00574447f, 0.06099908f, -0.01765746f, 0.26418149f, -0.00311531f, 
    0.03988132f, 0.08406544f, 0.01172476f, 0.08752127f, 0.03464452f, 0.01712722f, 0.18940420f, 0.02009070f, 
    0.15212730f, 0.04909776f, 0.07754349f, 0.07844446f, -0.01595280f, 0.08769510f, 0.04323355f, -0.00071771f, 
    0.16881742f, 0.04317279f, -0.07550082f, 0.16211718f, 0.07566240f, 0.03814324f, -0.03448430f, 0.00319075f, 
    -0.10316092f, -0.02430901f, -0.01140522f, 0.00611770f, 0.13976133f, 0.15151460f, 0.01920417f, 0.04271901f, 
    -0.15269901f, -0.13337943f, 0.06180918f, -0.04627621f, 0.02176027f, 0.03549001f, 0.00540158f, -0.01762507f, 
    -0.03480279f, 0.22394171f, 0.04502037f, 0.02403375f, -0.09457383f, 0.12211858f, 0.07373507f, 0.01812905f, 
    -0.06978134f, 0.06357244f, 0.13573907f, 0.08599496f, -0.03651385f, 0.13785346f, -0.07307521f, 0.13314444f, 
    -0.11599481f, 0.11221730f, 0.13793403f, -0.01411633f, 0.03874746f, -0.01703024f, -0.00115965f, -0.07211394f, 
    -0.23701420f, -0.04874038f, 0.25549051f, -0.00351744f, -0.15367950f, -0.02380783f, -0.07595561f, 0.03246444f, 
    0.04621362f, 0.01458262f, -0.12789010f, 0.07026599f, 0.18878932f, -0.13801467f, 0.04732641f, -0.01111811f, 
    -0.03249979f, 0.01608259f, 0.07557458f, 0.02800141f, -0.03921986f, -0.03964851f, -0.00944302f, 0.05076218f, 
    0.15440895f, 0.13787022f, -0.24231604f, -0.07304104f, 0.02898168f, 0.13115726f, 0.12302570f, -0.04254016f, 
    -0.08093459f, -0.07779172f, -0.11688182f, 0.01771946f, -0.24643531f, 0.09886319f, -0.00165173f, -0.12309445f, 
    0.02528009f, 0.04011927f, -0.01923675f, -0.12274703f, -0.06443729f, -0.21067995f, -0.06512078f, 0.10842690f, 
    0.02076767f, -0.11654212f, 0.04632029f, 0.05465850f, -0.05945890f, -0.09376012f, -0.02424709f, -0.09565236f, 
    -0.02463885f, 0.07000683f, 0.05000637f, -0.14523640f, 0.35062134f, -0.20319523f, -0.01160925f, 0.00323804f, 
    -0.06599590f, -0.07168864f, 0.08003381f, -0.07276920f, 0.09439736f, 0.08160557f, 0.14564651f, 0.14232932f, 
    0.02558246f, 0.13987736f, -0.06818428f, 0.11534873f, 0.12049046f, 0.00781123f, 0.01306223f, 0.01161476f, 
    0.10556279f, -0.09349790f, 0.11435408f, 0.10647366f, 0.10894735f, 0.14431773f, 0.03690173f, -0.00926205f, 
    -0.08937847f, -0.02505731f, 0.01655970f, -0.00718793f, -0.19427602f, 0.03520808f, -0.17889892f, 0.01774393f, 
    -0.09158473f, 0.03120479f, 0.26300049f, 0.10811355f, 0.14138196f, 0.05618846f, 0.04441517f, 0.09191766f, 
    0.06338051f, 0.03213714f, -0.10339130f, -0.06968044f, -0.04516930f, 0.02892553f, 0.19420712f, 0.06711143f, 
    0.08864734f, 0.06454497f, -0.00539908f, -0.01082055f, -0.08104846f, 0.12231439f, -0.08304162f, -0.09313470f, 
    -0.24936783f, 0.05500931f, -0.06186058f, -0.02217203f, -0.01164590f, -0.01554551f, -0.04559918f, -0.02365015f, 
    -0.03409423f, 0.00301817f, -0.05580048f, 0.02582833f, -0.19057849f, 0.04146578f, 0.20243503f, -0.04040317f, 
    -0.11194637f, -0.06484126f, -0.05944200f, 0.05054533f, -0.02804255f, -0.07999132f, -0.00554367f, 0.07020032f, 
    -0.23777921f, -0.00093936f, 0.03000990f, -0.11964073f, -0.25172672f, 0.04079082f, 0.07621595f, 0.13384214f, 
    0.06244244f, -0.02318777f, -0.00613336f, 0.02643142f, -0.08900476f, -0.00461780f, 0.16893451f, 0.05848920f, 
    -0.11995795f, -0.09667398f, 0.01273370f, -0.02055051f, -0.17344137f, 0.04499622f, -0.09250894f, 0.01467290f, 
    0.03853143f, 0.06882959f, 0.15705930f, -0.01320837f, 0.10070764f, -0.04695873f, 0.12502699f, 0.08848146f, 
    0.06110089f, -0.05411429f, -0.11599001f, -0.01418409f, -0.27430058f, 0.12340876f, -0.00065081f, -0.03849650f, 
    0.02011714f, -0.03112449f, -0.01519859f, -0.05680485f, -0.09223498f, 0.11942920f, -0.12053554f, -0.06741403f, 
    -0.26320487f, -0.18611985f, 0.23849550f, -0.06959492f, -0.09099485f, -0.02251397f, 0.00618338f, -0.03212900f, 
    0.00647200f, 0.05657655f, 0.05628483f, -0.09738009f, 0.09313226f, -0.17122215f, 0.30448136f, -0.06448743f, 
    -0.15190452f, -0.05315962f, 0.12510099f, 0.14790283f, 0.00903730f, 0.05533537f, -0.01703240f, -0.00223943f, 
    0.14333683f, -0.08591538f, 0.08865060f, 0.14334796f, 0.02692224f, 0.03524229f, 0.03624983f, -0.02483826f, 
    -0.02963555f, -0.04365193f, -0.02371932f, -0.03442993f, 0.01530642f, 0.00345720f, 0.00964217f, -0.03771171f, 
    -0.07649524f, 0.10094903f, 0.01074527f, -0.18748391f, -0.01330800f, -0.01023150f, -0.12998374f, 0.07474557f, 
    0.11623890f, -0.08462184f, 0.12533592f, -0.10200289f, -0.00328640f, -0.08346963f, 0.05481651f, -0.08836051f, 
    0.06653182f, -0.02471068f, -0.11408687f, 0.07555071f, -0.00068498f, -0.16142485f, 0.14266153f, 0.19977173f, 
    -0.06385795f, 0.08805175f, -0.02040101f, -0.05285335f, -0.06242021f, -0.05875998f, 0.04799214f, -0.00337308f, 
    0.21763891f, 0.27992678f, 0.09839502f, 0.23380470f, 0.11348923f, 0.09082191f, 0.02829021f, -0.00144459f, 
    -0.15373662f, 0.02233852f, 0.07307634f, 0.04457098f, 0.27540281f, -0.00983947f, 0.10407374f, 0.14925717f, 
    0.00700244f, 0.07377123f, 0.03955640f, -0.00570580f, -0.02657994f, 0.14418159f, 0.00185748f, -0.03154089f, 
    -0.00205176f, 0.02276316f, -0.04390913f, -0.01148598f, -0.03307576f, 0.00304106f, 0.02639730f, -0.01805048f, 
    -0.03995154f, 0.01720466f, 0.01339462f, 0.01740959f, 0.00498942f, -0.01707667f, -0.01259749f, -0.03440361f, 
    -0.02552827f, -0.05646882f, -0.01734538f, 0.02492709f, -0.01946225f, 0.01196343f, 0.00208288f, 0.00974366f, 
    0.00504571f, 0.02016523f, 0.02099783f, -0.04161973f, -0.02076815f, 0.01017040f, 0.04724699f, 0.01501811f, 
    0.03445723f, -0.05112817f, 0.03024975f, -0.03136005f, -0.00556956f, -0.05450929f, -0.04739050f, 0.03274632f, 
    0.03191545f, -0.02245666f, 0.02965801f, -0.02383000f, 0.00529679f, -0.03994009f, -0.02910130f, 0.00342108f, 
    -0.01447498f, -0.04097056f, -0.00139191f, 0.03560049f, 0.00500070f, -0.00565011f, 0.00126049f, -0.03083099f, 
    -0.01695756f, 0.02957384f, 0.03912987f, 0.00320996f, 0.03693485f, 0.02355054f, -0.01961436f, -0.00922193f, 
    -0.00194286f, 0.00808131f, 0.02810453f, -0.04796000f, 0.02508521f, -0.01287061f, 0.00211371f, -0.03604568f, 
    0.03347817f, -0.05223794f, 0.03572232f, 0.00915325f, -0.00756503f, 0.02129244f, 0.04349984f, -0.04276673f, 
    -0.04180149f, -0.01151498f, -0.01399873f, -0.00339336f, 0.03909114f, -0.01371777f, -0.03903287f, 0.05481808f, 
    -0.04613346f, -0.04488134f, 0.00405429f, -0.04977557f, -0.00491807f, -0.02174320f, -0.00020401f, -0.02041038f, 
    -0.05845340f, -0.04047601f, -0.01754587f, -0.04312000f, -0.01411028f, -0.04076200f, -0.05700904f, -0.00228238f, 
    0.03794309f, 0.02234612f, 0.02171401f, -0.00367426f, 0.03250344f, 0.01145078f, -0.05159924f, -0.01730430f, 
    0.02251179f, -0.04595910f, 0.03166145f, -0.03836714f, -0.00199325f, 0.02988359f, -0.01666140f, -0.02864984f, 
    -0.03278550f, 0.03779060f, 0.04998794f, 0.03880545f, 0.02245412f, -0.02094811f, 0.01824294f, -0.03382224f, 
    -0.04199272f, -0.01828367f, 0.00253602f, -0.04810956f, 0.02649320f, -0.05818685f, 0.03104498f, -0.01211057f, 
    0.04573595f, -0.03691310f, -0.04353985f, 0.02656634f, 0.01982292f, 0.03118590f, 0.00918271f, -0.05375809f, 
    -0.02029426f, 0.04147923f, -0.02893998f, -0.03592591f, 0.03650291f, -0.04166459f, -0.03537517f, -0.00756505f, 
    -0.02714645f, -0.02418333f, -0.03194871f, 0.01975240f, -0.05294747f, 0.02384768f, -0.03394470f, 0.02597104f, 
    0.03450060f, 0.02327481f, -0.05020550f, 0.02820721f, -0.00292726f, 0.02125025f, 0.00121532f, -0.03779361f, 
    0.02508453f, -0.01914924f, -0.02689321f, -0.01968339f, -0.01858845f, 0.03988429f, 0.01387160f, -0.01759231f, 
    -0.02497079f, 0.05006613f, -0.01912134f, 0.00187544f, -0.05728913f, 0.03126808f, -0.03553079f, 0.04196226f, 
    -0.03708104f, -0.04636709f, 0.01596907f, -0.03897134f, 0.01761225f, 0.02883105f, -0.00950654f, -0.01599213f, 
    0.02772792f, 0.03580226f, -0.00424810f, -0.01791696f, -0.00280310f, 0.02902519f, -0.05014633f, -0.04776866f, 
    0.02561756f, -0.00011196f, -0.05090204f, 0.03200569f, -0.02150682f, 0.02388283f, -0.00624238f, 0.03664830f, 
    -0.03952192f, -0.05365560f, 0.04203629f, -0.03071970f, -0.01282567f, -0.04464092f, 0.01843165f, -0.00465519f, 
    -0.03949008f, 0.00311743f, 0.02268079f, 0.01992471f, -0.01228376f, -0.00292533f, 0.02740738f, 0.01202597f, 
    0.02265693f, -0.03126769f, -0.03300767f, -0.01353507f, -0.02297047f, 0.03352815f, -0.00865871f, -0.03683700f, 
    0.01637731f, 0.01315845f, 0.03598728f, -0.04438716f, -0.00282532f, -0.03781328f, -0.02512961f, -0.03933330f, 
    -0.01589376f, -0.03260452f, 0.03255436f, 0.04327273f, -0.02542937f, 0.01474904f, -0.03825426f, 0.02368242f, 
    0.04484957f, -0.01685053f, -0.04394872f, 0.02926526f, 0.01516767f, 0.04095949f, 0.04187735f, 0.02573289f, 
    -0.00882234f, -0.00607786f, -0.01273188f, -0.02767619f, 0.01167812f, 0.01760713f, -0.00007955f, -0.00667973f, 
    0.00147540f, 0.04012517f, -0.05448207f, 0.00274138f, -0.05713863f, 0.03153419f, 0.00334962f, 0.01780858f, 
    0.04505121f, -0.00479961f, -0.00448239f, 0.04004991f, -0.04232417f, -0.03237787f, 0.01134814f, -0.00642892f, 
    -0.01336112f, -0.01197733f, -0.00637863f, -0.02625548f, -0.01681702f, -0.00154888f, 0.03925450f, -0.00389501f, 
    0.02727215f, 0.01307452f, 0.01020160f, 0.00189877f, 0.00018114f, 0.01114043f, -0.04221217f, -0.01775517f, 
    -0.00182836f, -0.02525216f, 0.04091672f, -0.02149532f, -0.01500997f, 0.03512709f, -0.03346050f, -0.01672056f, 
    -0.00836550f, -0.02388151f, 0.02047212f, -0.01626183f, -0.00387261f, 0.00638049f, 0.00345700f, -0.01378457f, 
    -0.01395090f, 0.01416291f, 0.02123914f, 0.02105631f, 0.00539440f, -0.02093776f, 0.03251066f, -0.00987944f, 
    -0.05401002f, 0.03180366f, 0.01468267f, -0.03327944f, -0.00181599f, 0.03642294f, 0.03652841f, -0.02775496f, 
    -0.01959416f, -0.03927010f, 0.02716436f, 0.02371808f, 0.01697315f, -0.02016893f, 0.03771520f, 0.02454162f, 
    -0.04553271f, -0.04655956f, -0.00339739f, 0.04758167f, -0.00615957f, -0.04980307f, -0.02977442f, -0.04494029f, 
    -0.02349746f, 0.00589412f, -0.05825271f, 0.01977296f, -0.01689631f, -0.03682588f, -0.02328547f, -0.00983176f, 
    0.00026019f, -0.06118075f, 0.02087749f, 0.00910760f, -0.00900734f, -0.05701493f, -0.05692089f, 0.00287052f, 
    0.01469591f, 0.02248075f, -0.03950443f, -0.05337507f, 0.02669585f, -0.00516697f, 0.03102095f, -0.00372115f, 
    0.02219975f, -0.05106075f, -0.05034909f, -0.00190556f, 0.00425908f, 0.03201380f, -0.03366382f, 0.02903934f, 
    -0.04070294f, -0.04697018f, 0.04309783f, -0.03904327f, -0.03834990f, -0.00958391f, -0.03206172f, -0.01153620f, 
    -0.04088079f, 0.00450238f, -0.04742474f, 0.03212161f, 0.02951325f, -0.04463633f, 0.00076772f, -0.01231970f, 
    -0.03653055f, 0.03514504f, 0.04163890f, 0.00514858f, 0.03229816f, -0.00930892f, 0.04347025f, -0.01508109f, 
    -0.01793516f, 0.02238412f, -0.03619345f, -0.03678788f, 0.04201879f, 0.02176833f, 0.03638734f, -0.01516660f, 
    0.03464553f, -0.04042013f, -0.05410239f, -0.03445219f, -0.02493301f, 0.00019304f, -0.04382374f, 0.00210933f, 
    0.03751934f, -0.00371142f, -0.00006976f, -0.03437382f, 0.04954006f, -0.02847924f, 0.02062856f, -0.02857781f, 
    0.03795969f, -0.01470141f, -0.00976231f, -0.03773462f, 0.00060415f, 0.01001745f, 0.02132917f, 0.02741120f, 
    -0.00547808f, 0.02746052f, 0.02786882f, 0.03317729f, -0.04139080f, 0.00798237f, -0.04001134f, -0.01887321f, 
    0.02128802f, -0.01412502f, -0.04785996f, -0.03034600f, -0.00473160f, 0.02816357f, 0.00213330f, 0.05150221f, 
    -0.05795502f, -0.02081407f, 0.03130401f, -0.00561133f, 0.00144798f, -0.04799364f, -0.00188147f, 0.01262246f, 
    0.04529129f, -0.00093652f, -0.01782517f, 0.01794751f, -0.06006471f, 0.03858608f, -0.02866635f, -0.04525115f, 
    -0.00181591f, -0.02546345f, -0.01983188f, 0.03779979f, 0.02325588f, -0.00804216f, -0.03775851f, 0.00397705f, 
    -0.02374454f, -0.03207750f, -0.00590007f, -0.03218006f, -0.05889772f, 0.00220161f, 0.04323082f, 0.02227256f, 
    -0.05780142f, -0.01372198f, 0.02507095f, -0.04131887f, -0.00248381f, -0.01969875f, 0.04055534f, -0.00413173f, 
    0.04433568f, -0.04053593f, -0.02137067f, 0.00121723f, -0.03027107f, -0.00187374f, 0.02622063f, 0.03873777f, 
    -0.03105222f, -0.04363444f, -0.03613907f, -0.05437148f, -0.02012226f, -0.04750365f, 0.02452447f, -0.03618536f, 
    -0.00631164f, -0.00766538f, 0.00929919f, -0.02907025f, -0.00320316f, 0.00198622f, -0.03570206f, 0.03992597f, 
    -0.05062635f, -0.00315345f, -0.04942981f, 0.03077550f, 0.00602257f, -0.00949224f, 0.00362717f, -0.05011491f, 
    0.00561002f, 0.02909928f, -0.02464280f, -0.02951707f, -0.04316942f, 0.02045299f, 0.00380209f, -0.05466572f, 
    -0.05031569f, -0.03180482f, 0.03672457f, 0.00311614f, 0.01785982f, 0.04570284f, 0.04682453f, -0.00937487f, 
    -0.01463693f, -0.02903395f, -0.01669246f, -0.03794526f, 0.01797850f, -0.00945611f, 0.00357521f, 0.00302468f, 
    -0.00220222f, -0.02580123f, -0.05125573f, 0.00777464f, 0.00728091f, -0.04725600f, 0.00990703f, -0.02579886f, 
    -0.01525090f, -0.04484760f, 0.00064012f, 0.00502432f, -0.03826091f, -0.04527289f, 0.03420075f, 0.02641577f, 
    -0.02705996f, 0.01981930f, -0.01944221f, 0.02220855f, 0.02556700f, 0.03681628f, 0.02594748f, -0.02292179f, 
    -0.04308253f, 0.02176394f, -0.04771721f, 0.01657217f, 0.00586942f, 0.04039339f, 0.03195640f, -0.01783222f, 
    -0.00611557f, -0.05728732f, 0.01806808f, -0.00574958f, 0.01871338f, 0.03788986f, -0.03767065f, -0.01892977f, 
    -0.02253111f, -0.02105548f, 0.04104920f, 0.03947254f, -0.03037960f, -0.01187313f, -0.01446107f, -0.05327931f, 
    0.01316601f, 0.00315602f, 0.03191253f, -0.02509787f, -0.01002857f, 0.01704504f, 0.03602616f, 0.03452792f, 
    0.03272527f, 0.02641057f, -0.04245034f, 0.02757058f, 0.04298862f, 0.03185493f, 0.01398916f, -0.01852978f, 
    -0.04721119f, -0.01700844f, -0.02141759f, 0.00823058f, 0.02622572f, 0.03327620f, 0.02750889f, -0.01709607f, 
    -0.01292285f, -0.03939264f, 0.03686279f, -0.05290259f, 0.00126560f, -0.04800862f, 0.03570273f, -0.04614262f, 
    -0.01123163f, 0.04721404f, -0.03224738f, 0.00003323f, -0.03734775f, 0.02131993f, -0.03607824f, 0.01297628f, 
    0.00858992f, 0.01772124f, 0.04070311f, -0.02309855f, -0.02717581f, 0.03399421f, 0.03560397f, -0.00811677f, 
    -0.02178850f, 0.03682831f, -0.01220312f, -0.03239673f, -0.04190195f, -0.03145108f, -0.04698946f, -0.05442230f, 
    -0.02278165f, -0.01889069f, 0.04149554f, -0.01894616f, 0.00494051f, 0.01095952f, 0.01125866f, 0.03968644f, 
    -0.00179804f, -0.01174667f, 0.01545073f, 0.01204801f, -0.04259576f, -0.00932128f, 0.00836386f, 0.01961984f, 
    0.02401375f, 0.02311746f, -0.00887340f, -0.00704850f, -0.02781871f, 0.03402538f, -0.01965210f, 0.01704776f, 
    -0.05406322f, 0.03996489f, 0.04286463f, 0.02520809f, -0.00999446f, 0.04039441f, 0.00789763f, 0.04476957f, 
    -0.04061351f, 0.00167759f, 0.03736586f, -0.02815532f, -0.04657135f, 0.03136583f, 0.00601360f, 0.04147548f, 
    -0.00095217f, -0.04001464f, 0.00239961f, -0.01831452f, -0.01941161f, -0.01639924f, 0.03343055f, 0.05091657f, 
    -0.03881723f, -0.04522151f, -0.02685122f, -0.00350475f, -0.02056599f, -0.03123216f, -0.01694262f, 0.03356087f, 
    -0.01807321f, 0.03960808f, -0.02991729f, 0.01154586f, -0.04275753f, -0.00645566f, -0.05317649f, 0.01442875f, 
    -0.01547964f, -0.04891913f, -0.02399372f, -0.03484717f, 0.00916375f, -0.00254041f, 0.00419772f, 0.01255563f, 
    -0.04807996f, -0.01134097f, 0.03459603f, -0.00784118f, 0.02630026f, -0.04565444f, -0.04949062f, -0.02994007f, 
    -0.04857653f, -0.02205362f, 0.00265069f, -0.00528305f, -0.04598623f, 0.03504224f, 0.01615232f, -0.04326525f, 
    0.02663905f, -0.00598538f, 0.01467882f, -0.04931663f, -0.04939962f, -0.02981692f, -0.00127471f, -0.00282146f, 
    0.02378645f, 0.03476817f, 0.02158467f, 0.03269300f, -0.03842974f, 0.03914492f, -0.04280842f, 0.03927419f, 
    -0.03986427f, -0.00259562f, 0.02305258f, -0.00214512f, 0.02419257f, 0.03096010f, 0.02847650f, 0.04334327f, 
    0.00098563f, -0.05280285f, 0.01885304f, -0.02786756f, 0.00197351f, 0.02920657f, -0.05056467f, 0.01800951f, 
    0.04463766f, 0.05600959f, 0.12409989f, 0.14330584f, 0.03839366f, 0.04340878f, 0.07870018f, 0.24289167f, 
    0.09741986f, -0.01767737f, 0.01903271f, -0.04548228f, -0.22975212f, 0.10194560f, -0.17448966f, 0.20722407f, 
    0.08353002f, 0.09682056f, 0.00854751f, 0.04912185f, 0.03306102f, 0.08749895f, 0.05408144f, 0.04698662f, 
    -0.14927900f, 0.32998800f, 0.01579643f, -0.27017057f, -0.10421300f, 0.08021488f, 0.15388483f, 0.03219703f, 
    -0.04821845f, 0.04221029f, 0.02977994f, 0.07399876f, 0.16370435f, -0.27784923f, 0.24339148f, -0.28981650f, 
    -0.00936276f, 0.15788643f, 0.13623658f, -0.01166789f, -0.02503075f, 0.04015608f, 0.01735984f, 0.07600912f, 
    0.03129099f, 0.04714029f, 0.07731517f, -0.07784858f, -0.05211397f, 0.02398686f, -0.14107504f, 0.00078819f, 
    0.05028462f, -0.05162617f, 0.06830993f, 0.00077636f, 0.33183730f, -0.04177111f, -0.12068358f, -0.05340865f, 
    -0.17635894f, -0.19717246f, -0.17569217f, -0.21963325f, 0.01542283f, 0.00480650f, -0.02981490f, 0.02483237f, 
    0.10583119f, -0.07027937f, -0.09163616f, -0.04803810f, 0.06222064f, 0.09237397f, 0.04009948f, 0.01797787f, 
    -0.01811055f, 0.01382721f, 0.12867284f, 0.00830172f, 0.13931768f, 0.02225244f, -0.34175166f, 0.35779548f, 
    -0.07072916f, -0.05100603f, 0.02056757f, -0.10238939f, 0.00119528f, -0.00768366f, 0.04197576f, -0.15347590f, 
    -0.14248523f, 0.07712763f, 0.16159661f, 0.07638329f, -0.10705920f, 0.02250920f, -0.09112802f, 0.01446110f, 
    0.16642779f, -0.05507122f, -0.15246564f, 0.09462988f, 0.20403354f, -0.16878425f, -0.05635051f, -0.12837197f, 
    -0.02799606f, -0.00198565f, 0.09465475f, 0.04180877f, 0.00034246f, 0.14286378f, 0.04271603f, -0.02894187f, 
    0.04712486f, -0.12412789f, 0.05462414f, 0.03299772f, 0.02151542f, 0.04315019f, 0.00169182f, -0.06602118f, 
    0.03335784f, -0.14933670f, -0.17381862f, 0.09761263f, -0.22004832f, -0.03471825f, 0.05777211f, -0.14560787f, 
    0.10602351f, 0.04709811f, -0.03787926f, -0.01092051f, 0.16902947f, -0.04613628f, 0.00407586f, 0.11197200f, 
    0.16549139f, -0.13686265f, -0.10919552f, 0.03660473f, -0.06168383f, -0.17158662f, -0.10737942f, -0.04330885f, 
    0.08773220f, -0.07526989f, 0.12135711f, -0.06068064f, 0.15807727f, -0.06889904f, -0.03906477f, 0.09151423f, 
    0.00935285f, 0.00970475f, -0.01677571f, 0.07457936f, 0.01918365f, 0.10974409f, 0.12888925f, 0.09330521f, 
    0.42292958f, 0.07820952f, -0.04622333f, 0.07980745f, 0.18254471f, 0.01325976f, 0.12420604f, 0.16227336f, 
    -0.00430031f, -0.19082084f, -0.02735296f, -0.00678035f, 0.34965011f, -0.28168967f, 0.05175871f, -0.04712224f, 
    -0.11884171f, -0.03147380f, 0.01860379f, -0.18097089f, -0.04220522f, -0.00541437f, -0.06357660f, 0.08466403f, 
    -0.08044349f, 0.10345796f, 0.22355920f, -0.00015082f, -0.02966159f, 0.06196471f, 0.09598853f, 0.01496484f, 
    0.10528231f, 0.13333285f, -0.17155367f, -0.08011045f, -0.18099891f, 0.34173205f, 0.03278081f, -0.17525674f, 
    0.03657732f, -0.12110457f, -0.04506107f, -0.05596304f, -0.09048296f, -0.00369533f, -0.05550762f, -0.01922088f, 
    -0.21039200f, 0.21204366f, -0.28094867f, 0.13164780f, 0.02250198f, 0.02719502f, -0.01831797f, -0.08551614f, 
    0.02848968f, -0.01092194f, -0.00325088f, 0.08323427f, 0.13021794f, -0.05158135f, 0.04327283f, -0.01605309f, 
    -0.12957825f, 0.00112207f, -0.11058448f, 0.00105718f, 0.03433553f, 0.00840897f, -0.04759962f, 0.00068313f, 
    0.06262162f, -0.02830393f, -0.10132841f, 0.10011093f, -0.13609858f, -0.00344964f, -0.08181497f, 0.00601598f, 
    0.07412989f, -0.06697742f, -0.00038488f, 0.09805474f, 0.10552832f, -0.10858461f, 0.14839521f, 0.08126114f, 
    0.01256365f, -0.03559539f, 0.09125443f, -0.00504831f, -0.11773796f, 0.11480859f, 0.11889490f, 0.08655655f, 
    -0.01932671f, 0.17511015f, -0.01405236f, -0.09426669f, 0.03932207f, -0.17048770f, 0.12625103f, 0.13213500f, 
    -0.02364722f, -0.00574235f, -0.08349577f, 0.00749416f, 0.07021570f, 0.23487730f, -0.23827542f, 0.11518745f, 
    -0.02068025f, -0.05608117f, -0.03253807f, 0.05611938f, 0.06761419f, 0.11804119f, -0.08173722f, 0.11869028f, 
    -0.21459590f, 0.26781148f, -0.08360680f, -0.11353402f, 0.07713538f, 0.00500258f, -0.09086966f, 0.03408426f, 
    0.01238993f, -0.04063775f, 0.07015904f, -0.14480914f, 0.20975329f, -0.29419470f, 0.07009435f, -0.43447104f, 
    -0.00525035f, -0.01240257f, 0.21565834f, 0.04606094f, -0.09392491f, 0.00913348f, -0.08553221f, 0.09763547f, 
    -0.03564115f, 0.09547620f, -0.04322870f, -0.02762883f, -0.05231263f, -0.07263217f, 0.10488573f, 0.09546571f, 
    0.07318132f, -0.08923008f, 0.05151399f, 0.06572015f, -0.06627479f, 0.01725928f, 0.05524637f, 0.08874182f, 
    0.07387278f, 0.04571892f, -0.09033492f, -0.12615046f, 0.05031877f, -0.07321205f, -0.03958290f, 0.09900286f, 
    0.35228068f, 0.01674971f, -0.15554109f, -0.32933453f, -0.02946243f, 0.02816321f, -0.08052418f, -0.09000107f, 
    0.09104708f, 0.02226466f, -0.08258663f, 0.09580424f, 0.15136644f, -0.09343674f, 0.15539095f, 0.07313104f, 
    0.09705107f, 0.03035053f, -0.05049917f, -0.11101008f, 0.11504198f, -0.00387220f, 0.13596280f, -0.00413289f, 
    0.09149252f, -0.04698528f, 0.14806932f, 0.28060600f, 0.02007248f, 0.00256015f, 0.05752955f, -0.08236492f, 
    0.03695974f, 0.01034752f, 0.08383064f, -0.01344231f, -0.28321335f, 0.02716464f, -0.00014051f, 0.15992913f, 
    -0.00857565f, 0.05712452f, 0.00516342f, -0.05255498f, 0.00006110f, 0.22929399f, 0.10557878f, 0.01467196f, 
    0.31369320f, 0.25221130f, -0.08416405f, 0.03283213f, -0.07369155f, -0.04704579f, 0.03063761f, 0.13167840f, 
    0.01079621f, -0.10021891f, -0.01441747f, -0.01117510f, -0.08485078f, 0.20460683f, 0.04771697f, -0.03930493f, 
    0.07174457f, 0.05501739f, -0.05142294f, 0.02594025f, -0.04901407f, 0.03098008f, -0.07401139f, -0.12918960f, 
    0.06024124f, 0.15095975f, 0.01535804f, 0.03055414f, 0.05274286f, -0.03765875f, 0.06809048f, 0.19132422f, 
    0.22059909f, 0.08943185f, -0.03353198f, -0.04812886f, -0.00162316f, -0.20383056f, 0.08745621f, 0.17632771f, 
    0.01733064f, -0.06309715f, 0.05356349f, 0.00550351f, 0.06828840f, -0.07719757f, 0.05175551f, 0.03826402f, 
    0.07719975f, -0.26509744f, -0.27418286f, 0.07013302f, 0.02563009f, 0.01497668f, 0.00723349f, 0.04237390f, 
    0.09782075f, 0.04179844f, 0.01302455f, 0.01519940f, -0.18856999f, 0.10202147f, 0.02029083f, -0.01440293f, 
    0.09595941f, 0.10299709f, 0.03986959f, -0.03971005f, -0.07427216f, -0.07196912f, 0.04351403f, 0.00417039f, 
    0.16485311f, 0.02053956f, -0.00092179f, -0.19619866f, 0.07001951f, -0.16105321f, 0.07381818f, 0.05165356f, 
    0.03996823f, 0.04072365f, 0.12565076f, -0.07918883f, -0.07472534f, 0.04125531f, 0.04415788f, 0.18045662f, 
    0.19534405f, 0.12677404f, 0.09834145f, -0.06292433f, 0.03689845f, 0.16681537f, 0.12365364f, 0.08080912f, 
    -0.03265880f, 0.22209179f, 0.14560133f, -0.06709372f, 0.11388076f, 0.04234876f, -0.04276288f, 0.10657178f, 
    -0.29123172f, 0.07516741f, 0.02794699f, 0.08315217f, -0.04813056f, -0.12198903f, -0.03270402f, -0.07707001f, 
    0.07138919f, -0.09994108f, 0.13744518f, -0.01517469f, 0.06114528f, 0.14158954f, 0.02477858f, 0.01793553f, 
    -0.15572681f, -0.00207349f, 0.08627731f, 0.07685993f, 0.20786978f, 0.09051850f, -0.02330493f, 0.04619132f, 
    0.00438199f, -0.05393090f, 0.04018529f, 0.13226064f, -0.04460000f, 0.01375646f, -0.03948392f, -0.15882011f, 
    -0.09474234f, -0.02900759f, 0.00965847f, 0.11862065f, 0.02197630f, 0.03984036f, 0.03683563f, -0.03976616f, 
    -0.07957792f, 0.02512706f, 0.00981058f, 0.20247635f, -0.05771405f, 0.05609638f, -0.02954584f, -0.13383076f, 
    0.16226238f, -0.02809578f, 0.02693925f, 0.09702021f, 0.14916281f, 0.15348776f, -0.06088540f, 0.24011846f, 
    0.07102469f, -0.01165717f, -0.02778864f, 0.04632565f, 0.05204575f, 0.09862356f, 0.05222019f, 0.12579872f, 
    -0.03407697f, 0.21761179f, -0.13834727f, -0.00963948f, -0.02573580f, -0.06029626f, 0.01607007f, 0.07113388f, 
    0.12496842f, -0.02305359f, 0.02756594f, 0.08683702f, 0.02727771f, -0.28806147f, 0.16028002f, -0.16621833f, 
    0.12657954f, 0.03416555f, 0.13614428f, -0.04662834f, -0.04430510f, 0.01189576f, 0.07112495f, -0.04716654f, 
    -0.03852616f, 0.18254447f, -0.02066236f, -0.13198245f, -0.01406587f, -0.09050297f, -0.15741286f, -0.01131905f, 
    -0.06286184f, 0.10155223f, 0.04315392f, 0.11902887f, 0.05082324f, -0.05554232f, 0.00506158f, -0.08942932f, 
    -0.13940796f, 0.09293722f, -0.09336899f, -0.08705378f, -0.08039621f, 0.04492895f, -0.09675067f, 0.08913659f, 
    0.38331094f, 0.27017564f, -0.04938996f, 0.04373989f, 0.05405585f, 0.06715806f, 0.03659982f, 0.05326263f, 
    0.06084964f, -0.03677855f, -0.02273576f, -0.02505634f, -0.24041669f, 0.05887155f, 0.16908444f, 0.06855764f, 
    0.01004799f, 0.28838199f, 0.07448062f, 0.07863283f, -0.13677724f, -0.00359198f, 0.03561854f, -0.06200643f, 
    -0.27218688f, -0.01386947f, -0.10971177f, 0.13189399f, 0.01121269f, 0.19509305f, 0.05166487f, 0.07246870f, 
    -0.05027403f, 0.04816395f, -0.05682586f, -0.04474353f, 0.06162417f, -0.05304813f, 0.18895654f, -0.11891629f, 
    0.01601888f, 0.00839263f, -0.03562989f, 0.13088804f, -0.04157981f, 0.10114356f, 0.07078783f, -0.13038346f, 
    -0.10207605f, 0.05679923f, -0.13397570f, -0.05072359f, -0.03835916f, -0.21009839f, -0.00330129f, 0.19509894f, 
    0.17161858f, 0.16835222f, -0.05151337f, 0.14268251f, 0.02899494f, -0.09647579f, 0.02409033f, -0.13442905f, 
    -0.08895583f, 0.03475565f, 0.06103671f, 0.04800421f, 0.03405769f, 0.10590800f, 0.04644788f, -0.04556629f, 
    -0.04202929f, 0.20342647f, -0.04777655f, -0.00747286f, 0.03600602f, 0.00683597f, -0.02485816f, 0.00302666f, 
    -0.05947552f, -0.02973773f, 0.02608919f, 0.04891779f, -0.17800182f, -0.07614103f, 0.14034265f, -0.11853455f, 
    -0.09407322f, -0.16542342f, 0.18798849f, 0.08245160f, -0.01435369f, -0.00191715f, -0.01033986f, 0.00306891f, 
    0.03732781f, -0.05597305f, -0.14060119f, -0.01907607f, -0.02686148f, 0.19178239f, 0.03628619f, 0.10376313f, 
    0.10901708f, 0.03296592f, -0.09865836f, 0.04916554f, -0.08434443f, 0.09801903f, -0.05579880f, 0.01515996f, 
    0.01665578f, 0.16293587f, 0.01205447f, 0.02908170f, -0.09943368f, 0.15639779f, 0.01710312f, 0.01919243f, 
    0.29504243f, -0.11926388f, 0.05311973f, -0.20809166f, -0.08200044f, 0.02424693f, 0.07205577f, -0.14171760f, 
    0.12046185f, -0.01186696f, -0.00245780f, 0.07291191f, -0.08234248f, -0.05998377f, 0.02208076f, 0.11221380f, 
    0.01410517f, 0.01847101f, 0.05930451f, -0.04424832f, 0.03951845f, 0.01317341f, 0.00823986f, -0.02057000f, 
    -0.15808186f, -0.44260278f, -0.14240058f, 0.04729353f, 0.15398178f, -0.04840905f, -0.04054047f, -0.03016828f, 
    0.05705793f, 0.09417439f, 0.06645866f, 0.11049252f, 0.21705645f, -0.07855926f, -0.11246999f, -0.03836323f, 
    -0.03427666f, -0.01702280f, -0.01607592f, 0.10536053f, 0.07925824f, 0.12875572f, 0.03894902f, -0.07677302f, 
    -0.16026136f, 0.04165407f, 0.00539342f, -0.05982694f, 0.02129079f, 0.06816679f, 0.07894153f, 0.04014897f, 
    -0.06473849f, -0.01490152f, 0.01993065f, -0.08254151f, -0.06753375f, -0.12992273f, -0.07761066f, -0.31564179f, 
    0.15352726f, -0.05665706f, -0.03274401f, -0.00300944f, -0.03857270f, -0.08999164f, -0.16535597f, -0.01147818f, 
    -0.44487733f, -0.30299443f, 0.21719895f, 0.19824532f, -0.00464113f, -0.02855996f, -0.12638751f, 0.12472094f, 
    0.02880183f, 0.07969347f, 0.09499899f, -0.01599367f, 0.20778203f, 0.01903987f, -0.17594007f, 0.14493299f, 
    0.01601354f, 0.04890720f, 0.02619074f, -0.19321597f, 0.06497625f, -0.01455700f, -0.04453539f, -0.03348625f, 
    -0.11795172f, 0.11647014f, 0.06233262f, 0.02947868f, 0.01578196f, 0.08360433f, 0.03665938f, -0.04881229f, 
    0.04370560f, 0.07559147f, 0.06531249f, -0.06948479f, 0.04229999f, -0.10324776f, -0.01381685f, -0.15314974f, 
    -0.01302014f, 0.07854393f, -0.04158816f, 0.04154775f, 0.06961850f, -0.07211749f, 0.01029020f, -0.01609714f, 
    -0.23577057f, -0.05994129f, -0.09544695f, -0.20325319f, 0.00177831f, 0.00618457f, -0.01623284f, -0.04683538f, 
    0.01857519f, -0.00442597f, 0.04050734f, -0.08270889f, -0.07559256f, -0.07271140f, 0.11730225f, -0.26381746f, 
    0.02247857f, 0.05310697f, -0.05776873f, 0.01089048f, -0.09103760f, -0.02244961f, -0.01969216f, 0.17981593f, 
    0.25158170f, -0.04201643f, -0.09758691f, 0.26587173f, 0.13407198f, 0.03135221f, 0.01794992f, 0.08540836f, 
    -0.02051339f, 0.02274364f, 0.08038985f, 0.01351737f, 0.14946830f, 0.12310793f, 0.10450158f, 0.11664350f, 
    0.06587084f, 0.04362491f, 0.02369073f, -0.01657098f, 0.01292209f, 0.14970779f, 0.00887119f, 0.00372310f, 
    -0.06118499f, -0.13779370f, 0.05710740f, 0.13245963f, 0.13581938f, 0.07600460f, -0.10072783f, 0.17458789f, 
    -0.02002007f, -0.05886362f, 0.04732990f, 0.02271806f, 0.24434799f, 0.03846893f, 0.07501911f, 0.31146657f, 
    -0.06172958f, -0.03293512f, -0.02262742f, 0.00422194f, 0.08546241f, -0.03142042f, 0.00678955f, 0.05386597f, 
    0.11295960f, 0.01218425f, -0.22492394f, -0.10949410f, 0.03188398f, 0.05075628f, 0.00099142f, 0.10918359f, 
    0.01583559f, 0.03885195f, -0.09760974f, 0.00915160f, -0.08185265f, 0.16619693f, 0.02092091f, -0.19323838f, 
    -0.12278353f, 0.03245057f, -0.05508571f, -0.04456158f, -0.05022451f, -0.03925861f, -0.00897663f, 0.04354813f, 
    -0.09134058f, -0.10861371f, 0.04806215f, -0.08720008f, -0.05570327f, -0.00488821f, -0.02646042f, -0.05611972f, 
    -0.02703204f, -0.07542664f, 0.00216136f, -0.06195914f, 0.14816839f, -0.04494744f, -0.12645847f, 0.12218133f, 
    0.09918123f, 0.08607823f, 0.00315776f, 0.05195550f, 0.13135317f, 0.08137449f, 0.07619857f, -0.02918214f, 
    0.09555858f, -0.06476030f, -0.13723852f, 0.11685921f, -0.05317564f, -0.08132767f, -0.08870158f, -0.06838787f, 
    -0.04025840f, -0.22706307f, 0.06858699f, 0.03615419f, -0.07025662f, 0.01387767f, 0.02830977f, 0.15641691f, 
    -0.08397990f, -0.03985913f, 0.06732007f, -0.05357342f, 0.03748093f, 0.07452643f, 0.06969553f, 0.00080164f, 
    -0.21103911f, 0.17963007f, 0.07244302f, -0.06419493f, 0.02367822f, -0.03702612f, 0.03353305f, 0.15880039f, 
    -0.06893237f, 0.03485676f, 0.00807487f, 0.03347310f, 0.31164667f, -0.19796307f, -0.09201452f, 0.07012085f, 
    0.07300028f, -0.00011271f, 0.13718629f, -0.03127699f, 0.03396531f, 0.09570622f, 0.01254755f, 0.08020692f, 
    0.21888895f, 0.01261770f, 0.00561240f, -0.00416616f, 0.11227738f, 0.00975478f, -0.00983224f, 0.00397746f, 
    0.08390143f, 0.01355895f, 0.01393579f, 0.11627141f, -0.05758332f, -0.09294028f, -0.10466885f, -0.01130669f, 
    -0.00775590f, 0.12017149f, 0.09515808f, -0.04555291f, 0.07586430f, 0.10539226f, 0.16721506f, -0.07544971f, 
    -0.10022648f, 0.03783167f, 0.12177314f, 0.07395656f, 0.06007446f, -0.01900432f, 0.04982328f, -0.04380995f, 
    -0.10923178f, -0.05763828f, -0.02281342f, 0.09968838f, 0.06117822f, 0.21764806f, 0.09379005f, -0.08531710f, 
    -0.05903060f, -0.02730256f, 0.11677535f, 0.01293791f, 0.01739722f, -0.09152911f, 0.11547705f, 0.01031725f, 
    0.31572294f, -0.01092090f, 0.00716199f, 0.35140595f, -0.06113591f, -0.05471749f, 0.04302295f, 0.07405034f, 
    -0.05523582f, -0.01888755f, -0.05124786f, -0.02859187f, -0.05350685f, 0.02507637f, -0.31731442f, 0.21310465f, 
    0.15486391f, 0.04487567f, -0.03814195f, -0.09309088f, 0.07222907f, 0.00485258f, -0.05602512f, -0.00182797f, 
    0.03623547f, 0.16937396f, -0.26028374f, 0.20040451f, -0.02228668f, -0.02990970f, -0.11411170f, -0.01832510f, 
    0.05865936f, 0.05618042f, 0.01041176f, -0.10687097f, 0.28266051f, -0.03983172f, 0.15669245f, 0.19046469f, 
    0.08044133f, -0.05326422f, 0.02451066f, 0.03928282f, 0.03093127f, 0.02819248f, -0.09392184f, 0.01589788f, 
    -0.16767451f, 0.04209875f, -0.02361647f, 0.18169115f, -0.07353224f, 0.10971808f, -0.00354087f, -0.00473503f, 
    -0.06893030f, 0.04883884f, -0.03268139f, -0.03489564f, 0.33141732f, 0.15541151f, 0.02414520f, 0.09204540f, 
    0.02236658f, 0.01205072f, 0.07217429f, 0.00104342f, 0.06256517f, 0.02815328f, 0.03091519f, -0.02223511f, 
    0.15594265f, 0.12368567f, -0.02587479f, -0.06968773f, 0.12767074f, -0.12881301f, -0.08922090f, -0.05732062f, 
    -0.04839715f, -0.00506049f, -0.06875335f, -0.10194999f, -0.12444758f, 0.09380014f, 0.12045206f, -0.11323732f, 
    0.04373753f, 0.00845880f, -0.02421854f, 0.07148142f, 0.07166539f, 0.03849498f, -0.00025860f, -0.01457637f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05749375f, 0.07386657f, 0.02571400f, 0.01483441f, 0.02418510f, 0.05288760f, 0.06232282f, 0.03134643f, 
    0.07664000f, 0.08603963f, 0.03324578f, 0.02056386f, 0.03433463f, -0.03192599f, 0.10117229f, -0.01599308f, 
    -0.09991520f, -0.05571148f, 0.09079074f, 0.01398768f, -0.01652272f, 0.01049528f, -0.02012876f, -0.03139502f, 
    0.05870315f, 0.01403230f, -0.01204528f, -0.05286113f, -0.03691781f, -0.04184569f, 0.01514658f, 0.01269549f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.09338969f, -0.46886635f, -0.17235452f, 0.18321325f, -0.04615057f, 0.20304747f, -0.22326918f, 0.00887787f, 
    0.21920341f, 0.07606052f, 0.39743429f, 0.15492117f, 0.41949573f, -0.19526705f, 0.52685821f, -0.13904309f, 
    0.15704173f, 0.00038372f, -0.14697976f, -0.14084707f, -0.15468268f, 0.59936923f, -0.00563210f, -0.09803094f, 
    -0.05014011f, -0.22896443f, -0.26915437f, -0.15973055f, -0.09532287f, 0.04145815f, 0.05520528f, 0.28215218f, 
    0.46312559f, 0.44057128f, 0.15856415f, 0.32770291f, 0.43172944f, -0.08894764f, -0.09033155f, -0.06594263f, 
    0.14507298f, -0.33242044f, -0.15437555f, -0.12271792f, -0.31108716f, 0.10114474f, -0.08554271f, 0.15914620f, 
    0.06471306f, -0.07446897f, 0.02969311f, 0.08692648f, 0.16967921f, -0.12660956f, 0.15504941f, -0.02268392f, 
    0.04008721f, 0.04513430f, -0.12027485f, 0.01901542f, 0.16092096f, -0.30887681f, -0.15425494f, 0.11145335f, 
    0.17969427f, 0.03584846f, 0.01407170f, 0.28140262f, 0.15906398f, -0.02508734f, -0.18315685f, 0.08414281f, 
    0.31644839f, 0.00724665f, -0.25985754f, -0.13494082f, 0.00790746f, 0.05267657f, -0.14452569f, 0.16890654f, 
    0.24178654f, 0.07457707f, -0.04366250f, -0.11350647f, 0.15222424f, -0.35856357f, -0.01796032f, 0.13968740f, 
    0.17349152f, 0.05017157f, 0.16226681f, -0.15941566f, -0.11791068f, 0.09399851f, -0.25717500f, 0.22847092f, 
    0.11424422f, 0.27736890f, -0.05581214f, 0.05691139f, 0.01268403f, 0.07075929f, 0.37059292f, 0.44312432f, 
    -0.00663474f, -0.11885869f, -0.22904894f, 0.11113827f, -0.23497017f, 0.04506811f, -0.16701169f, -0.07847446f, 
    -0.24238980f, 0.11362229f, 0.24515367f, 0.10500356f, 0.11169665f, -0.21379319f, -0.18650877f, -0.04720555f, 
    0.21690398f, -0.08229783f, 0.30183837f, -0.12217237f, 0.10890741f, -0.22259349f, 0.07902117f, 0.05327289f, 
    0.00061512f, -0.29649159f, 0.04932269f, 0.14786534f, -0.32225251f, 0.12467104f, 0.20397349f, -0.18451203f, 
    -0.00847216f, -0.19723319f, -0.13681255f, -0.14752269f, -0.12009318f, -0.03159210f, -0.27756935f, 0.01411141f, 
    0.35044172f, 0.02727075f, -0.08795770f, -0.07738888f, -0.15032434f, -0.11949448f, 0.26274928f, -0.03175217f, 
    -0.29211086f, 0.56857663f, 0.30647007f, -0.13842328f, 0.08280108f, 0.28906319f, 0.16276303f, 0.14387056f, 
    -0.14948960f, -0.17008448f, -0.15408513f, 0.13984208f, 0.03517169f, 0.02129181f, -0.06677759f, -0.06483161f, 
    0.15056446f, 0.06798714f, 0.20438091f, -0.11710031f, 0.32023719f, -0.01526431f, 0.17734870f, 0.07053767f, 
    -0.30479959f, -0.07799365f, 0.23623562f, 0.04046471f, 0.06544434f, 0.08863305f, 0.18135977f, 0.10644042f, 
    -0.53502011f, 0.24855629f, -0.25513959f, -0.14926364f, -0.07057150f, -0.12194509f, 0.17559271f, 0.27753091f, 
    0.27301952f, -0.07450306f, 0.15874536f, -0.04352508f, 0.16058387f, 0.05007274f, 0.09857456f, 0.55901229f, 
    -0.04373809f, -0.06610797f, 0.00603318f, -0.10466509f, 0.39147872f, -0.14268525f, 0.06437486f, -0.15931024f, 
    0.33925959f, 0.03003032f, 0.06532314f, -0.14226852f, 0.09849977f, -0.30114356f, -0.38280371f, 0.14436431f, 
    0.37140852f, 0.02526524f, 0.19728206f, 0.00620368f, 0.15225178f, -0.13607875f, -0.10373166f, 0.02205394f, 
    0.16893643f, -0.05148419f, 0.05310253f, -0.02900588f, 0.05107067f, -0.12513742f, -0.26413688f, 0.51888573f, 
    0.29983804f, 0.21714908f, -0.14523548f, 0.10719953f, 0.02279885f, 0.15717371f, 0.08918529f, 0.16520196f, 
    0.32727033f, -0.05288805f, 0.10190734f, 0.15562043f, -0.03571831f, 0.48616311f, -0.03797437f, 0.05542166f, 
    0.67868578f, -0.00545995f, 0.19925916f, -0.02688975f, -0.09677792f, -0.08005383f, 0.15104027f, -0.10923325f, 
    0.19187947f, -0.11419257f, -0.13431168f, 0.06597415f, 0.04154357f, 0.17249469f, -0.12179526f, -0.27530786f, 
    -0.10726416f, 0.02155294f, 0.27046984f, -0.04812967f, -0.00332362f, 0.29084575f, -0.40110406f, 0.17430183f, 
    0.40259510f, -0.11730951f, -0.16763969f, -0.14546987f, -0.08796198f, 0.39839822f, 0.01552536f, 0.02860100f, 
    -0.17615305f, 0.35868004f, 0.12101407f, -0.10405627f, -0.08981700f, 0.38377419f, 0.07248875f, -0.35428262f, 
    -0.37951776f, 0.11083500f, 0.02596629f, -0.28662995f, -0.10326060f, 0.22435936f, 0.31046599f, 0.02755022f, 
    0.08457287f, 0.20487496f, 0.12717092f, -0.08837604f, -0.16328020f, 0.05666724f, 0.17033015f, -0.06710619f, 
    -0.30714527f, 0.16036165f, 0.28733447f, 0.09720670f, 0.07313839f, -0.09154139f, 0.23335122f, 0.06248968f, 
    -0.15700589f, -0.56853634f, 0.17027727f, 0.09159193f, 0.02765762f, 0.21171270f, 0.09067810f, -0.13757437f, 
    -0.19338149f, -0.29946604f, -0.09277817f, 0.31458288f, -0.05543561f, 0.33844209f, 0.28409141f, -0.32283095f, 
    -0.01396416f, 0.27804586f, 0.00999326f, 0.14696853f, 0.14100382f, -0.28029412f, 0.03597680f, -0.10703607f, 
    -0.02616997f, -0.07629418f, 0.10576243f, 0.13439950f, -0.10052230f, 0.02949860f, 0.05086041f, -0.12255020f, 
    -0.38608047f, -0.15277542f, -0.17604484f, 0.16507560f, -0.12526423f, 0.66125739f, -0.02087311f, 0.15083963f, 
    -0.15510534f, -0.11916392f, -0.05423417f, -0.29736137f, 0.01802720f, -0.06824299f, 0.01573873f, -0.15525950f, 
    -0.08023745f, 0.42609912f, 0.27048013f, -0.09839675f, -0.20973627f, 0.23744966f, 0.32705632f, -0.16625467f, 
    0.01484084f, 0.06259333f, 0.14974253f, 0.04623096f, -0.03459935f, 0.38733909f, 0.20624878f, 0.13797846f, 
    0.34207034f, -0.56091404f, -0.11434305f, 0.02773580f, 0.14130186f, 0.20297727f, 0.21837786f, -0.45080093f, 
    -0.19495250f, -0.14461413f, -0.10937186f, 0.25813001f, 0.33248314f, 0.01047521f, -0.05635145f, -0.31283969f, 
    0.14679754f, -0.28409356f, -0.11050904f, -0.11504809f, 0.39571482f, -0.08876643f, -0.44101605f, 0.01662050f, 
    0.19579385f, -0.13475586f, 0.08800940f, -0.07146731f, -0.11086252f, 0.21593554f, 0.19879040f, -0.05659050f, 
    -0.41592851f, 0.23580545f, 0.17855372f, -0.10789081f, 0.16922942f, 0.12037361f, 0.23568505f, -0.03590471f, 
    -0.23986153f, 0.28398705f, -0.03119985f, -0.05050597f, -0.07157180f, 0.00244508f, 0.36383614f, 0.43073353f, 
    0.03824287f, 0.46190158f, -0.07181387f, 0.05155612f, 0.04996051f, -0.04978777f, -0.01123424f, -0.16103204f, 
    -0.28138626f, -0.01342895f, 0.26929364f, 0.06240086f, -0.11739393f, -0.10613252f, 0.08902135f, 0.08724377f, 
    -0.19467834f, 0.19106215f, 0.05696693f, 0.10222521f, -0.18285303f, -0.26808608f, 0.02803170f, 0.03716541f, 
    0.03884543f, 0.33912539f, -0.14848118f, 0.15405406f, 0.28787583f, 0.25431663f, -0.02811075f, -0.25110888f, 
    -0.13707775f, 0.17275472f, 0.52060384f, 0.09867831f, 0.23333943f, 0.27342352f, 0.08700471f, -0.00067148f, 
    0.01738803f, -0.06943996f, 0.07429123f, -0.10442645f, 0.02045074f, 0.20038642f, -0.27180788f, 0.11945237f, 
    -0.16841795f, -0.07049159f, -0.09159511f, 0.03765444f, -0.02932351f, -0.07201285f, -0.24079706f, -0.18827926f, 
    -0.13000421f, -0.06750335f, 0.04601233f, -0.03893478f, 0.19302243f, 0.04715415f, 0.06978986f, 0.24964146f, 
    0.16630401f, 0.11124025f, -0.15426199f, -0.06828821f, 0.25465727f, -0.19291969f, -0.00788713f, -0.05096374f, 
    -0.16697690f, 0.11172096f, 0.05480041f, -0.07014507f, 0.12715645f, -0.18675531f, -0.09250579f, 0.09487231f, 
    -0.15271595f, -0.13266827f, 0.24323910f, 0.08711589f, -0.06496891f, 0.56518853f, -0.08495750f, 0.12181478f, 
    0.42545572f, -0.09891868f, -0.03858345f, 0.07912626f, 0.11423635f, 0.23556700f, 0.05560775f, -0.68139875f, 
    -0.07368743f, -0.38461679f, 0.22267485f, 0.05435105f, 0.02841805f, 0.16001068f, 0.29514164f, -0.16756783f, 
    0.05446839f, -0.14148353f, -0.19382346f, 0.12226426f, -0.08550497f, 0.04318193f, 0.06983054f, -0.13131568f, 
    -0.13412210f, 0.15385194f, -0.27796179f, 0.14098765f, -0.08742385f, -0.07109784f, 0.08131944f, 0.31302339f, 
    0.20248863f, 0.47949597f, 0.08762112f, -0.05386930f, 0.41714641f, 0.12723887f, 0.37732792f, -0.49353459f, 
    -0.01872573f, -0.32143351f, -0.31991896f, -0.05059803f, -0.28040138f, 0.00644023f, -0.20952514f, 0.14296745f, 
    0.08309237f, 0.10303611f, 0.08047679f, -0.00429016f, 0.14948295f, -0.51039350f, 0.14023939f, 0.05321592f, 
    0.01106112f, 0.07334378f, 0.00529800f, 0.01387480f, -0.14983656f, 0.30644286f, 0.06155542f, 0.27331448f, 
    0.21084103f, -0.07164826f, 0.16367738f, -0.09987275f, -0.40359360f, 0.00423731f, 0.09923120f, 0.36525527f, 
    0.27233085f, 0.18062705f, 0.22092256f, 0.13170101f, -0.29226318f, 0.18598834f, 0.12142713f, 0.10141952f, 
    0.08276933f, 0.15374295f, 0.16609520f, 0.04171471f, -0.14811042f, -0.06477496f, 0.27788177f, 0.00250403f, 
    -0.40128276f, 0.22487134f, -0.05384533f, -0.10560571f, 0.16335437f, -0.50944483f, -0.18974462f, -0.05653076f, 
    -0.17811745f, 0.04869247f, -0.03034401f, 0.10504702f, 0.20086634f, 0.01761338f, -0.01663576f, 0.27606645f, 
    0.07940736f, -0.00989606f, -0.37979084f, 0.14277963f, 0.01189960f, 0.12737910f, -0.45649257f, -0.08245899f, 
    -0.10173638f, -0.13894810f, -0.02861237f, 0.00948608f, 0.17658468f, -0.04355524f, 0.18338479f, -0.17902319f, 
    0.11153363f, 0.16620766f, 0.49559322f, -0.14248870f, -0.01371209f, 0.61613137f, 0.32363230f, -0.35148171f, 
    0.19363545f, 0.13249797f, 0.08305042f, 0.35945830f, 0.20315106f, 0.21449704f, 0.31489700f, 0.02987343f, 
    -0.14079157f, 0.29442734f, -0.19012091f, 0.11776715f, -0.02463693f, -0.31900629f, 0.00048153f, 0.10853168f, 
    -0.20141195f, 0.00713440f, 0.19358368f, -0.00118247f, 0.13628133f, -0.24553080f, 0.20741621f, 0.09947100f, 
    -0.29388013f, -0.19092819f, -0.08603463f, -0.04018037f, -0.13336293f, -0.32438260f, -0.15415238f, 0.40534496f, 
    0.24038398f, 0.37451378f, -0.01124066f, -0.05893748f, 0.04550244f, 0.15039183f, 0.12749611f, -0.41090491f, 
    -0.13023070f, -0.32100907f, -0.08516759f, -0.06879774f, -0.10196818f, 0.32114190f, -0.22926298f, -0.08285159f, 
    0.14266132f, -0.12804717f, -0.01533077f, -0.13087185f, 0.08695951f, 0.30690572f, 0.09113617f, -0.17724389f, 
    0.14043540f, 0.48013526f, 0.01376198f, 0.03055560f, 0.07132731f, -0.27788606f, 0.32585952f, -0.27182025f, 
    -0.10528819f, -0.11353992f, -0.17085291f, -0.04758679f, -0.11670023f, 0.06006989f, 0.13437051f, -0.13559537f, 
    -0.11255665f, 0.13187870f, -0.19428496f, 0.13773894f, -0.10625312f, -0.15849437f, -0.16905051f, -0.00522716f, 
    -0.08372696f, 0.03976575f, 0.01190537f, 0.04050712f, 0.10451267f, -0.04469398f, -0.11433569f, -0.12575650f, 
    -0.09995221f, -0.01910760f, 0.12387682f, 0.06698629f, -0.11556136f, 0.00543817f, -0.03040953f, 0.01727561f, 
    0.14310548f, 0.02975139f, 0.05773655f, -0.39446297f, -0.29992121f, 0.25693893f, 0.27794835f, -0.08254553f, 
    -0.14788161f, 0.27280080f, 0.23688635f, -0.15253519f, -0.24333775f, 0.11549848f, 0.04077301f, 0.08774986f, 
    -0.16461331f, 0.01270211f, 0.23278835f, -0.04139230f, -0.05679012f, 0.26178440f, 0.07590503f, -0.11037754f, 
    0.01130624f, -0.17894523f, 0.01141776f, 0.09063295f, 0.11929564f, 0.01605177f, 0.12558493f, -0.16873702f, 
    0.04608122f, -0.01418218f, 0.09036569f, -0.13575856f, -0.11197238f, 0.04947749f, -0.05095092f, 0.03435954f, 
    -0.11138175f, 0.10496049f, -0.13969401f, 0.08395275f, 0.03744693f, -0.04786877f, 0.12930946f, 0.08132194f, 
    -0.05552744f, -0.09163920f, 0.01696004f, -0.03284733f, 0.14046058f, -0.13856922f, -0.12189079f, -0.16179909f, 
    0.01156701f, -0.16947109f, -0.01309176f, 0.13869476f, 0.04719562f, 0.05715511f, -0.03283012f, -0.16546595f, 
    -0.17271884f, 0.10527007f, -0.17326421f, 0.44124979f, 0.16296938f, -0.06773930f, 0.00161409f, 0.24047972f, 
    0.25267088f, -0.01353812f, -0.34704086f, -0.10337412f, 0.32910037f, -0.27961817f, -0.03142383f, -0.12029268f, 
    -0.12751433f, -0.09155467f, 0.02257139f, -0.07274683f, 0.08744776f, -0.24162988f, 0.10091806f, -0.13378052f, 
    -0.01196689f, 0.44799614f, -0.10468049f, 0.08440140f, 0.04362779f, -0.29098091f, 0.19662449f, 0.33887035f, 
    0.34413958f, 0.12877496f, -0.06373332f, 0.32888961f, 0.35161892f, -0.16615285f, -0.18211155f, -0.06495290f, 
    0.19523817f, 0.12799786f, -0.16768067f, -0.01892011f, 0.22633456f, 0.11897118f, -0.05948158f, 0.02885258f, 
    0.32484844f, -0.14666262f, -0.22515027f, -0.03203951f, 0.03014363f, 0.19840845f, -0.20410506f, 0.02726848f, 
    0.31380236f, 0.29490066f, 0.21620828f, -0.16007894f, -0.10351654f, -0.22415173f, 0.07856411f, 0.10394666f, 
    -0.11643437f, 0.23412070f, -0.14503306f, -0.24680080f, -0.08320189f, 0.11432429f, 0.04862699f, 0.04990469f, 
    0.23135203f, 0.20497705f, -0.14437863f, 0.12362625f, -0.21465081f, 0.10487723f, 0.32735834f, -0.03305501f, 
    -0.29369974f, -0.17686012f, 0.26851347f, -0.00495177f, 0.02420720f, -0.05512812f, 0.06726923f, 0.11659501f, 
    0.42314523f, -0.15353072f, -0.25318077f, -0.09934311f, 0.10014039f, -0.19869807f, 0.15255007f, 0.16637996f, 
    0.40551153f, -0.08908494f, -0.12811963f, -0.11853579f, 0.00938327f, 0.06587818f, 0.09548854f, 0.12502296f, 
    0.08790801f, -0.10945261f, 0.30063260f, 0.01897180f, 0.29438818f, -0.10615616f, 0.41541132f, 0.14408851f, 
    0.00560078f, -0.00098256f, 0.08336736f, -0.01599915f, -0.13484439f, -0.26193818f, -0.37074238f, 0.07987478f, 
    0.58159924f, -0.06127468f, -0.13217232f, -0.17381354f, -0.15475453f, -0.19075969f, -0.02491304f, 0.32949448f, 
    -0.16519669f, -0.02569084f, -0.12376871f, 0.10647954f, -0.13962547f, -0.14051378f, -0.07936391f, 0.00857586f, 
    0.03858535f, -0.19673125f, -0.06390420f, 0.00229237f, 0.11252965f, 0.00907890f, -0.10527147f, 0.04891213f, 
    -0.01331295f, -0.00653131f, 0.08399643f, -0.06558724f, 0.09144598f, 0.14441201f, 0.11698121f, -0.06634557f, 
    -0.04327857f, -0.16514710f, 0.04639376f, 0.11417548f, 0.10256191f, -0.17727120f, -0.05966626f, -0.15450394f, 
    -0.06448376f, 0.25101632f, -0.08777463f, -0.01316526f, 0.15459335f, 0.16961254f, -0.27709854f, -0.39412001f, 
    0.29280147f, 0.00363627f, -0.03015820f, -0.11455832f, -0.33829919f, 0.03583838f, -0.10235403f, -0.02664248f, 
    0.04868115f, -0.13335535f, -0.15614562f, -0.08797498f, -0.09584338f, 0.07288891f, 0.40596119f, -0.04389419f, 
    -0.28058219f, -0.14545073f, 0.31699494f, 0.07430022f, 0.03424450f, 0.23676039f, -0.19557478f, 0.01036297f, 
    0.06259556f, -0.07640240f, -0.11839332f, 0.06420842f, 0.05124212f, -0.01294534f, -0.17875798f, 0.11543486f, 
    0.27589351f, -0.07337894f, -0.17359869f, -0.13391168f, -0.32597342f, 0.05406520f, 0.43044886f, -0.10627165f, 
    -0.10253175f, 0.00060397f, -0.10188764f, -0.10256103f, -0.06565179f, -0.32401261f, 0.19438758f, -0.00865918f, 
    0.25111532f, -0.28717867f, -0.05350780f, 0.08972151f, 0.07582840f, 0.18558820f, -0.00421504f, 0.07788072f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12263306f, 0.15974168f, -0.01350157f, -0.07153719f, -0.12244032f, 0.00747412f, -0.03892005f, 0.05109405f, 
    0.12624700f, -0.02913105f, 0.02701787f, -0.02835616f, -0.16256794f, 0.22753866f, -0.11147738f, -0.12909119f, 
    0.11429302f, 0.19248301f, 0.06696294f, 0.08822461f, -0.11104996f, 0.14644936f, -0.04384074f, -0.02063946f, 
    -0.07908146f, 0.08195740f, -0.01067993f, 0.01471936f, 0.16942447f, -0.17924541f, 0.06416274f, -0.05629450f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.19110411f, -0.35975191f, -0.23276795f, -0.13365315f, 0.34314972f, 0.05865399f, -0.50135416f, -0.32479340f, 
    0.34614205f, 0.06747013f, 0.28620937f, -0.18828230f, 0.28422630f, -0.13217774f, 0.09259401f, 0.26070520f, 
    0.15338150f, 0.21766306f, -0.29250580f, 0.29642588f, -0.15240000f, 0.09249957f, 0.15124342f, -0.01821710f, 
    -0.09741380f, -0.28317437f, -0.38090438f, -0.32133791f, -0.48159307f, -0.17003618f, 0.22725028f, -0.39145690f, 
    -0.08944591f, -0.23489319f, -0.31795314f, 0.08489540f, -0.07565295f, -0.21643209f, 0.12206668f, -0.02982659f, 
    0.16076165f, 0.26332533f, 0.17602366f, 0.36345902f, -0.34451154f, 0.17490450f, 0.16023257f, -0.09473623f, 
    -0.17515978f, -0.07296105f, 0.17821756f, 0.00785127f, 0.14918323f, -0.07430337f, -0.07942171f, 0.38302174f, 
    -0.04610715f, -0.55199033f, -0.43212989f, 0.03886700f, -0.29452720f, -0.05037257f, 0.10520615f, -0.10366343f, 
    0.27981281f, -0.28458178f, -0.37884039f, -0.51798320f, 0.19288638f, -0.04034555f, -0.38898978f, 0.23501551f, 
    0.33324715f, -0.16367273f, 0.08421233f, 0.15631799f, 0.10081141f, -0.66745061f, -0.15336098f, -0.49013934f, 
    0.40204617f, -0.17839044f, -0.44088653f, 0.10067207f, -0.46210760f, 0.24245667f, -0.10179336f, 0.24045834f, 
    0.06265582f, -0.32710862f, 0.00290662f, -0.02725097f, -0.09329019f, -0.06941149f, 0.03056948f, -0.12026773f, 
    0.12210571f, -0.55695868f, 0.01631319f, -0.38340977f, 0.24527514f, 0.30156749f, -0.09801289f, 0.17853956f, 
    0.17848562f, -0.26712227f, 0.26727664f, -0.58765280f, 0.08458368f, 0.18276846f, -0.68821651f, 0.05307925f, 
    -0.48395389f, -0.43284410f, 0.19421226f, 0.12354868f, 0.04738253f, -0.56210423f, -0.15245941f, -0.24738565f, 
    0.01873234f, 0.26503506f, -0.01576751f, -0.07026515f, -0.21114859f, -0.15294020f, -0.06415658f, 0.10447805f, 
    -0.15029943f, 0.09976413f, 0.28969231f, 0.06886956f, -0.13671660f, -0.18763946f, -0.18563104f, 0.22357203f, 
    -0.18550803f, 0.07771455f, -0.22287244f, 0.24263093f, 0.08347847f, -0.06145739f, -0.38512811f, 0.27787915f, 
    -0.42408207f, 0.03670039f, -0.17725086f, 0.28856233f, -0.16413222f, -0.27017656f, -0.03882675f, -0.34305254f, 
    0.13429764f, -0.04896129f, 0.16382356f, 0.02618951f, -0.34326673f, -0.07359251f, 0.38299090f, 0.55967814f, 
    -0.32215706f, -0.02147800f, -0.21276677f, 0.36748904f, -0.04929634f, 0.12534773f, -0.15906319f, -0.07931062f, 
    -0.52540493f, 0.06978921f, -0.16082673f, -0.22697388f, -0.18683887f, 0.30786043f, -0.30155712f, -0.17969491f, 
    0.01485255f, 0.19202933f, 0.03401484f, 0.02951433f, 0.25821713f, 0.12152627f, -0.02377780f, 0.11589143f, 
    0.09787206f, 0.12358538f, -0.24022356f, 0.28869843f, 0.09759508f, 0.10189065f, -0.13131483f, 0.12174492f, 
    -0.00699324f, 0.26797208f, -0.13607763f, -0.30809459f, 0.00827717f, 0.20447554f, -0.81384146f, -0.18723044f, 
    0.19964948f, -0.25328147f, -0.15967657f, -0.38271475f, 0.24571142f, -0.06215805f, 0.24883945f, -0.54837358f, 
    0.29650843f, 0.05144797f, 0.26431221f, -0.15103295f, 0.21197020f, 0.19869956f, 0.16422887f, -0.26244506f, 
    -0.17674240f, -0.02508860f, 0.09511941f, -0.23697808f, -0.41793433f, 0.05221160f, 0.25938174f, -0.27620077f, 
    0.05861935f, -0.11306109f, 0.14456955f, 0.34438175f, 0.15793845f, -0.26625150f, 0.28105307f, 0.22312155f, 
    -0.01613283f, -0.40027261f, -0.63133794f, -0.21693572f, -0.13328195f, 0.01868132f, -0.11550384f, 0.08529786f, 
    -0.05859173f, -0.53279388f, 0.34454808f, -0.00663356f, -0.00620563f, -0.03889123f, 0.13280895f, -0.08670329f, 
    -0.07207792f, 0.02359556f, 0.17588837f, -0.40578398f, 0.30458501f, -0.03467623f, -0.38691196f, -0.12077317f, 
    0.17670691f, -0.12047562f, -0.10170046f, -0.36193100f, -0.41775262f, 0.14943704f, -0.04009061f, 0.09845833f, 
    -0.22143549f, 0.09834756f, -0.32973316f, 0.20460123f, -0.58191657f, -0.04846618f, 0.09441292f, -0.23485793f, 
    0.23195292f, -0.35486785f, 0.46583968f, -0.42908016f, -0.38495061f, -0.21122992f, 0.07407618f, 0.17788796f, 
    0.16027996f, -0.47905406f, -0.28172633f, 0.34255648f, 0.17063053f, -0.00837873f, 0.16138937f, 0.48675153f, 
    -0.32516357f, 0.12891954f, 0.15081933f, 0.01654485f, -0.13191375f, -0.40878281f, 0.28375709f, 0.19287832f, 
    0.31024465f, -0.39428419f, -0.42731321f, -0.27363399f, -0.07798331f, -0.14605126f, 0.33405647f, -0.13242471f, 
    -0.06153875f, 0.25502712f, -0.45699251f, 0.13638283f, -0.31310052f, 0.25353053f, -0.13743162f, -0.27003428f, 
    -0.07417742f, -0.07087646f, 0.31533664f, -0.05237165f, 0.08812862f, -0.09158735f, -0.02904251f, -0.29104948f, 
    0.30098185f, -0.42375648f, -0.19438653f, -0.03737864f, -0.57880920f, 0.25279465f, 0.17493416f, 0.00391952f, 
    -0.34483743f, 0.10955285f, 0.13039351f, 0.21653183f, -0.06938849f, 0.19943672f, 0.43519676f, 0.25581986f, 
    -0.14188579f, -0.47776690f, -0.37684751f, -0.04336792f, 0.15401252f, -0.40609369f, -0.15857966f, -0.15184589f, 
    -0.12785193f, 0.09319047f, -0.00495030f, -0.00463718f, 0.18943553f, -0.00206938f, -0.48018953f, -0.34721971f, 
    0.21131301f, 0.05472970f, 0.19213004f, -0.24725677f, 0.02919372f, -0.09580623f, 0.02491442f, -0.20971759f, 
    -0.20649752f, -0.23376007f, 0.35078907f, -0.45732602f, -0.21551976f, -0.40517578f, 0.03599878f, 0.17889132f, 
    0.50392061f, 0.27796081f, -0.32964483f, -0.24302880f, 0.33057284f, -0.46716541f, -0.07004401f, -0.36539412f, 
    -0.10968359f, -0.03315950f, 0.01659179f, -0.16123118f, 0.24912304f, 0.09750890f, 0.11345364f, 0.38162744f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.16901636f, -0.01427628f, 0.12079348f, -0.00908059f, 0.11281425f, 0.01855642f, -0.17690875f, -0.06734891f, 
    -0.07034559f, -0.07065690f, 0.27149719f, 0.06309146f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
