#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.52944934f, -0.19229174f, 0.43842629f, -0.24005957f, 0.12875293f, 0.10332807f, -0.04989711f, 0.25943002f, 
    -0.24711764f, -0.55500358f, -0.10440045f, -0.38484421f, -0.41098699f, 0.31867641f, 0.15800515f, 0.35458073f, 
    0.26734164f, 0.33112645f, -0.19700845f, -0.26552749f, -0.07786044f, -0.29230002f, 0.36742577f, 0.18263900f, 
    -0.07495330f, -0.49493527f, -0.49990687f, -0.18268548f, -0.16402952f, -0.27091488f, 0.24432041f, -0.08604806f, 
    -0.48496103f, -0.36947748f, -0.22376084f, -0.14228791f, 0.04986898f, 0.14580630f, 0.35260478f, -0.12524633f, 
    -0.06237259f, 0.10139231f, -0.00008684f, -0.20311049f, 0.03885078f, -0.31971368f, 0.19379888f, 0.04065843f, 
    0.29372352f, -0.12042329f, 0.11640854f, -0.09869895f, -0.23316504f, 0.28042978f, 0.01413888f, -0.39901537f, 
    -0.63269955f, 0.44163954f, 0.03484448f, -0.44717377f, -0.57320368f, -0.25506508f, -0.52885395f, -0.18829204f, 
    -0.03857473f, -0.20194946f, -0.19438329f, -0.24725479f, -0.03670831f, 0.09071863f, 0.06966654f, 0.09588740f, 
    0.04711007f, -0.22491762f, -0.31305420f, -0.65490180f, 0.25038484f, 0.56821853f, -0.25316894f, -0.06634047f, 
    -0.74226731f, -0.00675811f, -0.19666667f, -0.07970472f, -0.63056546f, -0.21581094f, 0.41544515f, -0.18032029f, 
    0.28043005f, 0.25485590f, 0.05241130f, -0.39257079f, -0.01833641f, 0.02863777f, -0.12960951f, -0.07080345f, 
    0.22722960f, 0.07491384f, 0.23328637f, 0.16165896f, 0.94275856f, 0.62496072f, -0.60809809f, -0.29916227f, 
    -0.34254715f, 0.25643313f, -0.00273156f, 0.08323342f, 0.06265523f, 0.14540641f, 0.09464333f, 0.40990144f, 
    -0.24600498f, -0.07005479f, 0.04649779f, 0.15656984f, -0.16914682f, -0.18181567f, -0.36408305f, 0.07307656f, 
    -0.28744966f, -0.00760207f, -0.02404140f, -0.11655843f, 0.01140825f, -0.70095944f, 0.39160854f, 0.57455093f, 
    -0.63320911f, 0.43859872f, 0.19191296f, 0.62862504f, 0.33802998f, 0.14079918f, 0.25481242f, 0.18450399f, 
    0.09224176f, 0.36916864f, 0.18219765f, 0.17285028f, 0.40216169f, -0.20006001f, -0.11255627f, 0.09753633f, 
    0.17385925f, -0.12860987f, 0.12174121f, 0.18180645f, -0.01935296f, 0.13699415f, 0.41192111f, 0.75585186f, 
    0.33553043f, 0.32853472f, 0.09836801f, -0.26663214f, 0.45390710f, -0.59108496f, 0.64400887f, 0.31251135f, 
    -0.15350354f, -0.14639243f, 0.20057577f, 0.15564048f, -0.09869045f, -0.00191555f, 0.26662564f, -0.03350511f, 
    0.02519641f, -0.02265746f, -0.31896001f, -0.20630448f, -0.23204419f, -0.10142800f, 0.12026660f, -0.24174570f, 
    0.14379545f, -0.27334625f, 0.11622119f, -0.17450263f, -0.71109766f, -0.66048306f, -0.32971057f, -0.22715098f, 
    -0.05637290f, -0.05687357f, 0.07518747f, -0.08767243f, 0.34213513f, -0.21493521f, -0.04215282f, 0.19774207f, 
    0.15694129f, 0.03021167f, -0.35158351f, 0.25339967f, 0.00854506f, 0.31789464f, 0.22394438f, 0.16990003f, 
    -0.41232887f, -0.63715518f, 0.14156252f, 0.27424693f, 0.38425153f, -0.26456150f, 0.62874264f, 0.59913987f, 
    0.02513225f, 0.52848870f, -0.08062955f, 0.02873907f, -0.04539706f, -0.22065377f, -0.39598495f, -0.01419452f, 
    0.06010452f, 0.16735955f, 0.27683982f, 0.19501767f, 0.25101882f, -0.37246910f, 0.19362475f, -0.10285442f, 
    -0.44872114f, 0.53325284f, 0.74443823f, -0.05530674f, -0.73392409f, -0.72120583f, -0.33596694f, -0.15974712f, 
    0.04715597f, -0.43836528f, -0.20348170f, 0.31783438f, 0.19636005f, -0.02775899f, -0.12622353f, -0.05050034f, 
    0.01071832f, 0.05068338f, -0.36042228f, -0.03826994f, -0.06861847f, -0.01016023f, 0.04486068f, 0.27120671f, 
    -0.08220735f, 0.16553678f, -0.58303404f, 0.53240043f, -0.57993060f, -0.24011852f, -0.36421704f, 0.49513990f, 
    -0.46059105f, -0.67234343f, 0.01819774f, -0.20753686f, 0.09969912f, 0.03700260f, 0.43206844f, 0.32536861f, 
    -0.24714535f, 0.28942522f, -0.03842063f, 0.32163733f, -0.01768545f, 0.00759290f, 0.16287474f, -0.38401511f, 
    -0.09832087f, -0.02807106f, 0.25917628f, 0.63955092f, 0.25406301f, -0.02544142f, 0.69999242f, 0.94336116f, 
    0.51555568f, -0.25266463f, 0.06380865f, -0.29725143f, -0.17363574f, 0.07172488f, 0.13572155f, -0.07422510f, 
    -0.12870064f, -0.07972997f, 0.27981979f, -0.07878245f, 0.26419517f, 0.19294615f, -0.08758447f, 0.26300558f, 
    0.22079419f, 0.05017736f, 0.12904292f, 0.11664268f, 0.01758507f, -0.48302886f, -0.49301487f, -0.25265583f, 
    -0.37392807f, 0.17107955f, 0.24735400f, -0.62013352f, 0.42223221f, 0.55803150f, 0.33450401f, 0.04180489f, 
    -0.09592840f, 0.07885675f, 0.38718250f, -0.17467445f, -0.12107845f, -0.01323240f, 0.11095142f, 0.15668164f, 
    -0.14616889f, 0.14664562f, 0.31885615f, 0.09071112f, -0.02825352f, -0.02458428f, 0.86531049f, 0.11927017f, 
    -0.17926995f, 0.13573912f, -0.37323749f, 0.17583734f, 0.32167709f, -0.33608219f, -0.48340812f, -0.02846879f, 
    -0.27656931f, -0.09927854f, 0.13478166f, 0.65923858f, 0.28565976f, 0.04653618f, 0.30555299f, 0.11301263f, 
    0.21013303f, 0.40263766f, -0.24272685f, -0.11941860f, -0.03421538f, 0.26134318f, 0.28207636f, 0.72906125f, 
    0.38604164f, -0.16460542f, 0.59306782f, -0.96396011f, 0.41615710f, -0.03590526f, -0.27106145f, 0.22761501f, 
    -0.14920446f, -0.32286352f, -0.04991541f, -0.05470920f, 0.11238173f, -0.00216261f, -0.09270354f, -0.24516694f, 
    0.02145857f, 0.03754541f, 0.12084143f, -0.25742191f, 0.06731266f, 0.24219231f, 0.05845188f, 0.88090557f, 
    0.52072006f, 0.76239634f, -0.35949731f, -0.39828056f, -0.08043129f, -0.75959206f, -0.37859666f, -0.28550753f, 
    0.16534747f, 0.15656744f, -0.38094389f, 0.02036129f, -0.13910455f, -0.13582537f, -0.25404319f, -0.04711602f, 
    -0.08784878f, -0.26486406f, -0.36682099f, 0.02442771f, 0.15404201f, 0.10755969f, -0.07522020f, -0.06516308f, 
    0.05405828f, -0.28658631f, -0.58002943f, -0.50740618f, 0.44870809f, -0.20970331f, -0.26673350f, 0.16199690f, 
    0.16369136f, -0.19348587f, -0.63119972f, -0.15544023f, 0.27535057f, 0.01666977f, -0.47854564f, -0.08931573f, 
    -0.33299619f, 0.25382188f, -0.04621542f, -0.18329339f, -0.12002164f, 0.03862391f, -0.15983279f, 0.21194629f, 
    0.06023620f, 0.00394113f, 0.47761190f, 0.38325343f, 0.27731916f, 0.65670013f, -0.62278211f, 0.14153756f, 
    -0.21781069f, -0.48385015f, -0.49002627f, 0.19920464f, -0.06308862f, 0.43608111f, 0.17315429f, -0.02550075f, 
    0.26123396f, 0.45194033f, 0.48044482f, -0.07187763f, -0.00868615f, -0.37437740f, -0.20718889f, -0.17612965f, 
    0.00450527f, -0.03418349f, -0.38440645f, -0.40453145f, 0.14096630f, 0.47642285f, 0.66598856f, -0.84620512f, 
    -0.65567386f, -0.57267642f, -0.43802449f, 0.03419702f, -0.15598355f, 0.21672496f, 0.13575447f, -0.00232307f, 
    -0.28423044f, 0.02265838f, -0.09893076f, 0.20782600f, 0.00815596f, 0.15818895f, -0.26327974f, -0.05204510f, 
    0.04011028f, 0.03868485f, -0.01368122f, -0.80865622f, -0.75411135f, -0.20010330f, 0.83772576f, 0.24794967f, 
    -0.14713284f, 0.52873617f, 0.44069371f, 0.14007191f, -0.46010196f, 0.51474541f, -0.21919900f, -0.06267187f, 
    0.08918721f, 0.15460867f, 0.23255639f, 0.39369792f, -0.11133195f, -0.14111716f, 0.05112990f, 0.00957153f, 
    0.13493453f, 0.01260067f, 0.18881565f, -0.03434195f, -0.04739756f, -0.41840926f, -0.28292370f, 0.32713637f, 
    -0.20396586f, 0.77114624f, 0.92837834f, -0.06240202f, 0.47673050f, 0.41158703f, -0.09758705f, -0.06016402f, 
    0.01357173f, 0.05755717f, 0.05053100f, -0.41286644f, -0.30222905f, -0.17345661f, -0.16028498f, 0.06976130f, 
    0.00965203f, -0.15287176f, 0.45965907f, -0.08513399f, -0.14882477f, 0.12934989f, 0.44780281f, 0.26396114f, 
    0.70486754f, -0.20281902f, -0.06599407f, 0.13675156f, -0.76527685f, -0.80418915f, -0.20305949f, 0.17606613f, 
    0.07033054f, 0.28461516f, 0.32863018f, -0.08173185f, -0.19884995f, -0.39613935f, 0.17251381f, -0.06005855f, 
    -0.05811354f, -0.09683870f, 0.23267938f, 0.02484948f, 0.04780509f, -0.06877470f, -0.41867378f, 0.83447629f, 
    -0.21102026f, -0.31428838f, -0.51489425f, 0.51019728f, 0.01634229f, -0.32089394f, -0.32415587f, -0.18799421f, 
    -0.18826596f, -0.23837927f, -0.33425599f, 0.01871100f, -0.07930616f, -0.28648594f, 0.22307208f, -0.09749653f, 
    0.00213083f, -0.25302735f, -0.24585201f, -0.11554489f, 0.04155437f, -0.15114783f, 0.06587050f, 0.95410752f, 
    0.65445715f, 0.40090016f, 0.67213392f, 0.70055717f, -0.22548687f, -0.19862352f, 0.01650005f, 0.00586544f, 
    0.02685528f, 0.14718121f, -0.15541480f, -0.03780236f, -0.12856016f, -0.03128472f, -0.07450251f, -0.04041748f, 
    0.05192427f, -0.08404610f, 0.03899564f, 0.21932633f, -0.01640918f, 0.36491057f, -0.00821609f, 0.22781859f, 
    -0.18579368f, -0.59953976f, -0.39790088f, -0.22479798f, -0.48359275f, -0.09438599f, 0.20074880f, 0.37901020f, 
    0.41176873f, -0.05541631f, -0.34221673f, 0.02592799f, 0.40176758f, -0.18314491f, -0.57077849f, 0.14856088f, 
    0.12094326f, 0.09295265f, -0.29968593f, 0.10431518f, 0.02116363f, -0.02522133f, 0.14379275f, -0.13016106f, 
    0.01355027f, 0.86895120f, 0.22722150f, -0.44792980f, 0.76273435f, -0.31405279f, 0.00632717f, 0.22280169f, 
    0.45398575f, 0.30120748f, 0.57040793f, -0.24368522f, -0.34767574f, 0.15218258f, -0.22386384f, -0.19361101f, 
    -0.19647580f, 0.00181392f, -0.09706048f, -0.03849712f, 0.16355596f, 0.32989952f, 0.04784295f, -0.16305801f, 
    0.14589614f, -0.19157422f, -0.68396449f, -0.97049212f, -0.38589856f, 0.08641297f, 0.21443240f, 0.66813308f, 
    0.79775995f, -0.12670815f, 0.15820074f, -0.16014773f, 0.04852112f, 0.42784822f, 0.24488273f, 0.32897121f, 
    0.01187513f, -0.17461939f, 0.31279463f, 0.32367492f, -0.03651331f, -0.07621645f, 0.12046273f, -0.16399112f, 
    -0.15440248f, -0.05479113f, 0.12025273f, -0.82264912f, 0.35039315f, -0.12744173f, -0.75333244f, -0.49586767f, 
    0.53106594f, 0.53917587f, 0.17314076f, 0.52655935f, 0.36874586f, -0.02120648f, -0.18202612f, -0.26470396f, 
    -0.21790132f, -0.29754615f, 0.09271063f, -0.09791532f, -0.01498968f, -0.01537656f, 0.01888712f, -0.10682591f, 
    -0.07375789f, -0.10177355f, 0.08806543f, 0.13077420f, 0.54021525f, 0.65646046f, 0.38344276f, -0.05863885f, 
    0.18030871f, 0.14839023f, 0.42798451f, 0.16621400f, -0.14737077f, 0.31243950f, 0.05601383f, 0.04438205f, 
    -0.30942023f, -0.33521935f, -0.09271194f, -0.08814127f, -0.02679737f, 0.00752103f, 0.03096144f, -0.04415154f, 
    0.14181286f, 0.24050611f, 0.40247080f, -0.00138015f, 0.11846973f, 1.02401912f, -0.04199542f, 0.38771960f, 
    0.62885970f, 0.62935585f, 0.43005216f, 0.35560405f, -0.42171022f, 0.35726130f, 0.11167249f, -0.19970413f, 
    0.36920506f, -0.03784906f, 0.47358125f, -0.14120710f, 0.04549426f, 0.09362877f, -0.14386235f, 0.00575945f, 
    -0.35418949f, 0.12121215f, 0.08308876f, -0.16855159f, -0.18670392f, -0.03835487f, -0.62196130f, -0.41730165f, 
    -0.42197987f, -0.37984332f, -0.17679819f, -0.31595114f, 0.92965722f, -0.03112620f, 0.11999375f, 0.49448210f, 
    -0.08652551f, -0.03247552f, 0.04594748f, -0.15233824f, -0.13618372f, -0.06620301f, 0.13994211f, 0.16134949f, 
    0.03936755f, -0.09123481f, -0.15064423f, 0.17035666f, -0.23135306f, -0.05143608f, 0.16087271f, 0.60933912f, 
    0.39310223f, -0.43039367f, -0.61640579f, -0.83957511f, -0.02158061f, 0.40747577f, -0.07312969f, -0.28681180f, 
    0.04866859f, -0.00822503f, -0.06749552f, -0.03262648f, 0.11228125f, 0.04138155f, -0.09302752f, 0.02914613f, 
    0.37973639f, 0.22483189f, 0.06212548f, 0.33497533f, -0.01789884f, 0.25585496f, 0.10309771f, -0.06060729f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08687766f, -0.03393207f, 0.12043983f, 0.34777564f, -0.00585988f, -0.02243382f, 0.07612930f, 0.02629281f, 
    -0.06772008f, 0.16521166f, 0.22464500f, 0.12257817f, 0.31165406f, 0.02853923f, 0.03821288f, 0.29214349f, 
    0.11098458f, 0.17189516f, 0.20623194f, 0.37918672f, 0.18092929f, 0.10458000f, 0.10781940f, 0.07997280f, 
    -0.00488123f, 0.04670080f, 0.17265211f, 0.07010242f, 0.20117782f, -0.10575633f, 0.33303347f, 0.04838590f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.21330813f, 0.09122171f, -0.34773156f, -0.00190477f, 0.11564849f, 0.10346100f, 0.03812214f, -0.02523533f, 
    0.00374986f, 0.19682442f, -0.08027987f, 0.12063970f, 0.00515049f, -0.01405650f, 0.25429139f, 0.10430166f, 
    0.11339890f, 0.05134574f, 0.01352448f, 0.13652153f, 0.08461545f, 0.06845875f, -0.01576925f, 0.01973271f, 
    0.12728679f, 0.02943705f, 0.05445992f, 0.03229201f, -0.12420969f, -0.06181088f, 0.01305759f, -0.12193654f, 
    -0.05837069f, 0.04271042f, 0.08533759f, -0.05662606f, -0.31662109f, -0.29523468f, -0.05714509f, 0.07193100f, 
    0.03185754f, -0.03789494f, 0.10876498f, -0.07548200f, -0.07736269f, 0.05620406f, -0.01800591f, -0.17871833f, 
    0.23834105f, 0.18959378f, 0.22860181f, -0.06874343f, -0.19216633f, 0.02887377f, -0.00015783f, 0.16418977f, 
    -0.02229548f, -0.07953501f, 0.08477429f, -0.01647411f, 0.03676306f, -0.30827919f, 0.04768468f, -0.01818868f, 
    -0.02352460f, -0.04549683f, 0.02012947f, -0.09748877f, -0.02452705f, -0.05394495f, -0.02667203f, -0.02524901f, 
    0.01193440f, 0.10343431f, 0.20591551f, 0.09199852f, -0.08475997f, -0.08265104f, 0.12277213f, 0.09541069f, 
    0.11086243f, 0.04005905f, 0.11161074f, 0.00777116f, -0.31464764f, -0.26620409f, 0.13972019f, 0.00095454f, 
    -0.04127593f, 0.06373998f, 0.14531562f, 0.08188658f, 0.03034390f, 0.27519315f, 0.03280654f, -0.01264014f, 
    0.10861515f, -0.13696618f, 0.17134793f, 0.22942865f, 0.08315270f, 0.20764396f, -0.09685240f, 0.03331354f, 
    -0.00816238f, 0.08571246f, -0.06477957f, 0.07248392f, -0.14270829f, -0.20438600f, 0.01553930f, -0.07639705f, 
    -0.13993451f, -0.00191966f, 0.07396902f, 0.02643348f, -0.13357078f, -0.05891300f, 0.12067098f, 0.00173774f, 
    -0.14550805f, -0.07143211f, 0.34478420f, -0.07075058f, 0.07076713f, -0.00515018f, 0.10756470f, 0.17210184f, 
    0.01560208f, 0.06315134f, -0.13649747f, -0.13137969f, -0.01577934f, 0.25305977f, -0.15542737f, 0.07362955f, 
    -0.09575642f, 0.05772549f, -0.13859402f, 0.08522881f, -0.07809415f, 0.07524655f, 0.04544736f, -0.05932291f, 
    -0.07263757f, 0.01211087f, -0.08839381f, -0.15894374f, -0.01695394f, 0.00119181f, 0.03393102f, -0.04186644f, 
    -0.03152733f, -0.04524766f, 0.01728923f, 0.13688585f, 0.23281881f, -0.01825796f, -0.12097812f, -0.09047133f, 
    -0.06219602f, -0.12502520f, 0.09874944f, -0.01609964f, -0.03695007f, 0.10894214f, -0.05298433f, -0.10414600f, 
    0.18737139f, -0.33392051f, 0.24015112f, -0.09810834f, -0.13533413f, 0.02204886f, -0.04726347f, -0.03283468f, 
    0.05536033f, -0.20448467f, 0.04511217f, 0.06170093f, -0.05981009f, -0.03508401f, -0.01270522f, -0.16084969f, 
    -0.09560136f, 0.08596983f, 0.15688927f, 0.02214835f, -0.15424338f, -0.02963251f, 0.01179683f, 0.04638209f, 
    -0.09855771f, -0.16359925f, 0.04257894f, -0.33087799f, 0.01247904f, 0.08375987f, 0.00182261f, 0.12758552f, 
    -0.02167236f, -0.03872831f, -0.11744216f, 0.07569206f, 0.16269314f, 0.09215724f, 0.04128277f, -0.20667847f, 
    -0.10934354f, 0.04720723f, 0.02496678f, 0.11353437f, 0.17171745f, -0.03805477f, -0.07849400f, -0.07543814f, 
    -0.28813609f, -0.35707617f, 0.28728160f, -0.08386456f, -0.11540417f, 0.06710453f, 0.05060376f, -0.04016035f, 
    0.02589728f, -0.03135838f, 0.04875679f, 0.00213796f, 0.23311295f, 0.17687343f, -0.29922259f, 0.39495465f, 
    0.01690741f, 0.10736051f, -0.02433381f, 0.04933808f, -0.01067443f, -0.04376848f, 0.06441418f, -0.10567383f, 
    -0.18134071f, 0.08707730f, 0.05187491f, 0.14175445f, 0.05189817f, 0.10898177f, -0.15586674f, -0.14570983f, 
    0.05091366f, 0.08730628f, 0.06537789f, 0.15631324f, -0.26972586f, 0.23099402f, -0.14845647f, -0.26603615f, 
    -0.08963757f, 0.07808622f, -0.00178973f, 0.09527850f, -0.00970309f, 0.04084570f, -0.00789891f, -0.04051203f, 
    0.16723888f, 0.06615865f, 0.31208482f, -0.15253825f, -0.06535455f, 0.01266671f, 0.13826321f, 0.12717931f, 
    0.00468094f, 0.06247476f, 0.03933442f, 0.04033092f, 0.05813891f, -0.01182919f, 0.28612715f, 0.27400976f, 
    -0.11759016f, 0.04943956f, 0.03026527f, 0.13368313f, -0.05463027f, -0.03029119f, -0.09057432f, -0.06483800f, 
    0.16052036f, 0.10642389f, -0.06597482f, -0.07362249f, 0.16682322f, 0.17491743f, 0.01476670f, 0.21996556f, 
    -0.00880015f, 0.17339660f, 0.09745353f, 0.06834453f, -0.10632857f, 0.17015411f, 0.20606343f, 0.31676278f, 
    -0.04789701f, 0.07325041f, 0.06516564f, -0.03587347f, 0.00246138f, 0.03383031f, 0.02639745f, 0.10809867f, 
    0.04587231f, 0.06580953f, -0.19880919f, 0.14215200f, 0.13746278f, -0.00355165f, -0.02557421f, 0.11736681f, 
    0.08415584f, 0.16444054f, -0.14569044f, 0.05381840f, 0.16679260f, -0.02125437f, 0.19742703f, 0.03298947f, 
    0.08126932f, -0.02440654f, 0.05669311f, -0.03977893f, 0.04386467f, 0.05944062f, 0.14265253f, 0.15047392f, 
    0.01914563f, 0.24066520f, 0.18689302f, 0.09375743f, -0.00210864f, 0.01029713f, 0.01675270f, -0.05196001f, 
    -0.04439694f, -0.01883829f, -0.03755996f, 0.03488551f, 0.28422910f, 0.49573511f, 0.01023581f, 0.07701822f, 
    -0.10374570f, 0.03772628f, -0.04131386f, 0.03759559f, -0.06214397f, 0.10539379f, 0.03015281f, 0.04072853f, 
    0.12920669f, -0.17817511f, 0.09741793f, -0.05544196f, 0.13370213f, 0.04924561f, 0.09451500f, 0.05358446f, 
    -0.02935223f, 0.12285433f, -0.08171816f, 0.16475515f, -0.06774489f, 0.04264270f, 0.15184286f, -0.07743674f, 
    0.19435906f, 0.03274752f, -0.02782431f, 0.08968420f, -0.09044006f, -0.04388873f, 0.19743292f, 0.06576040f, 
    0.03244176f, -0.11087569f, -0.14210336f, 0.10305764f, -0.02764667f, 0.17776681f, 0.12365043f, -0.07309160f, 
    0.06004320f, -0.06551480f, 0.04477186f, 0.07345487f, -0.11301449f, -0.03941267f, -0.25889707f, 0.17010532f, 
    -0.04553439f, -0.10366689f, 0.14866491f, -0.08037257f, 0.11921559f, 0.12687592f, 0.03467277f, -0.01007376f, 
    -0.27253273f, 0.16632487f, -0.07673492f, 0.05688939f, 0.08941460f, -0.15541275f, -0.05774519f, 0.19629976f, 
    0.04665055f, 0.16888863f, -0.08056853f, 0.03720386f, 0.06519920f, 0.00184522f, -0.04619469f, 0.10584445f, 
    -0.03481393f, 0.16447987f, -0.01404342f, 0.08872431f, 0.07727952f, 0.06590894f, 0.02805775f, 0.19526361f, 
    0.18109161f, 0.12224550f, 0.33277783f, -0.08722137f, 0.22032453f, -0.02674730f, 0.02061535f, -0.14754818f, 
    0.10407850f, 0.12241320f, -0.11037108f, 0.10791820f, -0.27279526f, -0.02915793f, 0.12867689f, -0.15674950f, 
    0.08138051f, 0.04720859f, 0.11054054f, -0.14777914f, -0.06001539f, 0.14088596f, 0.17027862f, -0.00193422f, 
    0.33042181f, -0.17174390f, 0.24318099f, -0.08801519f, 0.07933529f, 0.03624202f, -0.03823098f, -0.04578580f, 
    -0.08341119f, 0.05138138f, 0.00441340f, 0.06324989f, -0.08914321f, 0.11370795f, 0.01188267f, -0.08789822f, 
    -0.07707907f, 0.04995777f, 0.07748157f, -0.00444376f, 0.07594493f, -0.15587901f, 0.18149292f, 0.11583655f, 
    0.23917070f, -0.07065575f, -0.19188167f, 0.12104151f, 0.16241242f, 0.02765963f, -0.01384805f, -0.03773559f, 
    -0.02229730f, -0.09795018f, -0.03187800f, 0.02276460f, 0.48514703f, 0.11619980f, 0.11208506f, -0.01917866f, 
    0.12241654f, 0.01693812f, -0.03763311f, 0.06494401f, 0.04311979f, 0.18988970f, 0.09399515f, 0.14590606f, 
    -0.27204758f, -0.23728904f, -0.01558862f, 0.03266409f, 0.04792634f, 0.12415501f, 0.09438873f, 0.11667234f, 
    0.03046456f, 0.01153836f, 0.09814484f, 0.02278302f, -0.19975057f, 0.14672440f, -0.02467059f, 0.04961686f, 
    0.21524782f, 0.02042506f, 0.03929345f, -0.02365205f, -0.01185328f, 0.04855715f, 0.10755590f, 0.02316177f, 
    0.09269645f, -0.25088507f, 0.06517339f, -0.04267105f, 0.14483672f, -0.08871604f, 0.12433111f, 0.08076216f, 
    0.14853714f, 0.00532490f, -0.13142049f, -0.04578949f, 0.06242260f, -0.21630138f, -0.14409144f, 0.18615119f, 
    -0.02239024f, 0.18070051f, -0.15554054f, 0.10468154f, 0.10992912f, 0.05432376f, 0.02601071f, 0.01795597f, 
    0.23016188f, -0.04276839f, -0.24464643f, -0.03783771f, 0.08109195f, 0.17405632f, 0.08194982f, 0.03594186f, 
    -0.00155319f, 0.11090623f, 0.01880665f, 0.12322690f, 0.42409995f, 0.12647140f, 0.09175131f, 0.05220413f, 
    0.13644260f, -0.00805446f, 0.11064286f, 0.08503029f, 0.08360622f, -0.04195228f, 0.06360280f, 0.13634823f, 
    -0.10920380f, 0.00840237f, -0.05003658f, -0.04683057f, -0.01914950f, 0.08538035f, -0.07178646f, 0.16276094f, 
    0.14197852f, -0.00971111f, 0.08480363f, -0.01374881f, 0.11468079f, -0.02547142f, -0.08448385f, -0.11017402f, 
    0.02502504f, 0.12402846f, -0.00687037f, -0.10111998f, -0.09113199f, 0.01602735f, 0.25088492f, 0.14430919f, 
    0.04929280f, 0.23798443f, -0.15814635f, -0.19932146f, 0.12174203f, -0.11702349f, -0.04143864f, 0.17294063f, 
    -0.00496420f, 0.09312956f, 0.14613762f, 0.03195736f, 0.20758222f, 0.19546019f, -0.02359500f, 0.06688019f, 
    -0.06851042f, 0.01915881f, -0.07217654f, -0.02825790f, -0.00808684f, 0.07262569f, 0.01633425f, 0.03993382f, 
    0.17471613f, -0.12002388f, -0.00470293f, -0.00138109f, 0.13498281f, 0.04342234f, 0.01527061f, 0.02230287f, 
    0.04843411f, 0.09974498f, 0.01278937f, -0.10542360f, 0.36383983f, -0.06927846f, -0.10616578f, 0.02305891f, 
    0.04759299f, 0.02127792f, 0.14934248f, 0.03445489f, 0.07140733f, 0.04262414f, 0.08088263f, -0.00615175f, 
    -0.49761719f, -0.26163679f, 0.17649037f, -0.23124711f, -0.15108560f, -0.00778193f, -0.12496422f, -0.06488218f, 
    0.03258484f, 0.01763080f, -0.05349468f, -0.08844160f, -0.18847442f, 0.09812815f, -0.17795047f, 0.00342095f, 
    0.10771272f, 0.04371656f, 0.02287388f, -0.04938239f, -0.03095604f, -0.03848052f, -0.03902012f, 0.23662817f, 
    -0.07800242f, -0.11030318f, 0.06461943f, -0.05594593f, 0.09675797f, 0.02074411f, 0.01100845f, 0.12317940f, 
    -0.00401964f, -0.12458342f, 0.02590705f, -0.04883366f, -0.07394743f, 0.08646841f, -0.06612562f, -0.06778542f, 
    0.12230208f, -0.17669083f, 0.08999611f, 0.12888442f, 0.25500539f, -0.05321924f, -0.07655120f, 0.12407356f, 
    0.40865523f, 0.03908620f, -0.16437465f, 0.17734337f, 0.10870791f, 0.06941657f, -0.08503175f, 0.16727808f, 
    -0.08442508f, -0.11540043f, 0.11732318f, -0.00101906f, -0.41483721f, -0.36973107f, -0.08602684f, -0.17297791f, 
    -0.04357236f, 0.02427445f, -0.06781922f, 0.12269178f, 0.08685101f, -0.07608248f, -0.05294687f, 0.02815010f, 
    0.26273167f, -0.00692822f, -0.08425321f, 0.04666495f, -0.02430806f, 0.11717982f, 0.09634566f, 0.02828939f, 
    -0.02324274f, 0.06959748f, 0.09368350f, -0.01263495f, -0.08264208f, 0.22035484f, 0.15002029f, -0.14012790f, 
    0.06070869f, 0.09077936f, -0.11198888f, -0.07962928f, 0.12745431f, -0.11275164f, 0.06177998f, 0.11089541f, 
    0.33451095f, -0.27846187f, -0.29673946f, -0.05020632f, 0.05156291f, -0.10885361f, 0.05508053f, 0.05566102f, 
    0.10133776f, 0.18441422f, 0.07459578f, -0.00464085f, 0.28610891f, 0.04659795f, 0.08402818f, 0.04196719f, 
    -0.06573167f, 0.12103775f, 0.12153345f, 0.23956321f, 0.05017137f, -0.05162536f, 0.09668705f, 0.23901381f, 
    -0.05789018f, 0.11118423f, 0.18793617f, 0.19053020f, -0.03062809f, 0.00040695f, -0.02442461f, 0.13948275f, 
    -0.00520428f, 0.01193903f, 0.07384387f, 0.02588638f, 0.30071646f, 0.07646605f, 0.07402571f, 0.12062941f, 
    -0.00948793f, -0.04919172f, -0.12799707f, 0.16369821f, -0.01365872f, -0.06086403f, 0.02557746f, -0.05182844f, 
    0.37720877f, -0.06266951f, 0.29031375f, 0.29453310f, 0.03074226f, 0.11980180f, 0.03813082f, 0.03748872f, 
    0.08245743f, -0.00522357f, 0.05598410f, 0.03570234f, -0.02862448f, 0.37123799f, 0.03976611f, 0.06117943f, 
    0.12877439f, -0.04089366f, 0.01241611f, 0.01930042f, 0.04183848f, 0.00040735f, 0.05018998f, -0.01830326f, 
    0.03607578f, -0.35882056f, 0.10752278f, -0.06533769f, -0.14838640f, 0.01664193f, 0.10998396f, 0.19039060f, 
    0.10212293f, 0.07773163f, 0.11817814f, -0.09697735f, 0.03016124f, 0.29208618f, 0.05575916f, 0.00312961f, 
    0.00203808f, -0.03488126f, -0.12276054f, 0.05739117f, 0.20019414f, -0.00300961f, -0.05248999f, 0.05310205f, 
    -0.24551643f, -0.24354941f, -0.27602074f, -0.01104361f, -0.06461547f, -0.13600518f, 0.00250791f, 0.10218194f, 
    -0.00314912f, 0.09353696f, 0.01093134f, 0.07227024f, 0.21770772f, 0.20207117f, 0.20533407f, 0.12618986f, 
    0.21399422f, 0.18332364f, 0.06093099f, -0.03141972f, 0.12679377f, -0.06469223f, -0.04732608f, 0.04996749f, 
    -0.12674712f, 0.04885090f, 0.14007191f, -0.10898911f, -0.05611463f, 0.04537560f, -0.14920262f, 0.12790370f, 
    0.01780476f, 0.15574411f, 0.02159184f, -0.08325134f, -0.11629305f, -0.13409546f, 0.05318737f, -0.01424401f, 
    0.01179437f, 0.03243487f, 0.00572056f, 0.04576877f, 0.01024558f, 0.09309279f, -0.03875183f, -0.06775527f, 
    0.47670266f, 0.32876903f, -0.03059301f, -0.08958000f, 0.10771501f, -0.06316710f, 0.08843160f, 0.05503659f, 
    -0.08427440f, 0.13752951f, 0.05587909f, -0.11277825f, -0.14315067f, -0.27248809f, -0.11595494f, 0.23543426f, 
    0.08782276f, 0.04380312f, -0.02174046f, 0.02568031f, 0.01452259f, -0.06242603f, 0.08529425f, 0.01627744f, 
    0.23236111f, 0.07916719f, 0.03879819f, -0.06566996f, -0.16867584f, 0.01815015f, -0.05835897f, -0.03587596f, 
    0.15048937f, -0.10545360f, 0.16726699f, 0.09409636f, -0.30700475f, 0.11768116f, 0.06480322f, -0.32224527f, 
    -0.06715099f, 0.03414719f, 0.15038916f, 0.11866660f, -0.07620475f, 0.06257804f, 0.02861576f, 0.07379654f, 
    -0.24201873f, -0.08228039f, -0.12076949f, -0.04126767f, 0.09709265f, 0.02944562f, -0.00689853f, 0.05383830f, 
    -0.02541404f, -0.02800292f, 0.00080923f, 0.08806115f, 0.01631550f, -0.31185400f, -0.13117550f, -0.08984686f, 
    0.11619917f, 0.03722685f, -0.01088644f, 0.05199030f, -0.05302238f, 0.05604702f, -0.08124724f, 0.05833178f, 
    0.07044838f, 0.09353531f, 0.23682265f, 0.28400344f, -0.01702943f, -0.07056211f, 0.08265451f, 0.07146657f, 
    -0.07382245f, 0.16374454f, 0.04919267f, -0.00130093f, -0.42999366f, -0.20415242f, 0.01416271f, 0.16787343f, 
    0.11403988f, 0.07819936f, 0.02415670f, -0.04245732f, 0.00558638f, 0.13060340f, -0.07789101f, -0.13478273f, 
    0.05069425f, 0.11270794f, 0.16394089f, 0.38486657f, 0.16612090f, 0.04643276f, 0.09336224f, 0.00636932f, 
    0.05792607f, 0.00634187f, -0.05045804f, -0.04005531f, 0.22961102f, 0.12620345f, 0.11161699f, 0.09506879f, 
    -0.04269320f, -0.07433318f, 0.04338220f, 0.02731244f, -0.03946969f, -0.00927069f, 0.02818706f, 0.03380320f, 
    0.16053706f, 0.26689747f, -0.06028661f, 0.04943148f, 0.04016641f, -0.00707215f, -0.02260882f, 0.00421401f, 
    0.03275001f, 0.10906735f, 0.21643277f, 0.08488204f, -0.22700654f, -0.09898301f, 0.01662264f, 0.12296033f, 
    0.06971380f, 0.09736882f, -0.00345557f, 0.07155436f, 0.07677460f, 0.07301605f, -0.05505300f, -0.10718083f, 
    0.08132252f, 0.22032394f, -0.17715868f, -0.07005335f, 0.07392565f, -0.00415846f, 0.10512987f, 0.13762970f, 
    0.02258017f, -0.01500286f, -0.00439921f, 0.04034229f, -0.12011945f, -0.35752487f, -0.19427414f, 0.01815850f, 
    0.07869293f, -0.00241010f, -0.04410725f, 0.00690605f, -0.07788958f, -0.03054288f, 0.00883725f, 0.02104767f, 
    0.26234812f, 0.16836812f, 0.08852021f, -0.07146535f, -0.15315963f, -0.03639573f, 0.05178686f, -0.01015098f, 
    -0.04570164f, 0.08595263f, 0.04262346f, -0.06099974f, -0.00921556f, -0.22238754f, -0.16963376f, -0.03462500f, 
    0.07931197f, 0.18590720f, 0.11022255f, -0.08112769f, -0.04905624f, -0.00525203f, -0.00034991f, 0.05847668f, 
    0.37841496f, 0.18451320f, 0.09182087f, 0.06470352f, -0.06630386f, -0.21210323f, 0.02088285f, 0.04125835f, 
    -0.05387624f, -0.01769029f, 0.08949504f, 0.06632108f, -0.03187629f, 0.47731739f, 0.09629776f, -0.27152267f, 
    -0.07799762f, -0.01168066f, 0.05680299f, 0.07733618f, -0.00991871f, 0.01773327f, 0.05500380f, 0.05291656f, 
    -0.32102647f, -0.27684727f, -0.07252204f, -0.06545171f, 0.16871822f, -0.00833414f, 0.06084222f, -0.06769871f, 
    0.12016891f, -0.01130010f, -0.09116903f, 0.11457421f, -0.13354048f, -0.38757026f, -0.26186237f, 0.12368540f, 
    0.11183756f, -0.04130287f, 0.04412370f, -0.05198449f, -0.01279281f, 0.02209635f, -0.06877644f, -0.08238218f, 
    0.18956472f, 0.40251899f, 0.09428542f, 0.05856388f, -0.14619857f, -0.08015271f, -0.07635899f, 0.08024314f, 
    -0.00486162f, -0.03485455f, -0.12589331f, 0.01767397f, -0.13596754f, -0.05657559f, 0.06565180f, -0.11964520f, 
    -0.14454398f, 0.05101047f, 0.01417772f, -0.05117843f, 0.02517118f, 0.13108851f, 0.03861573f, 0.13545242f, 
    0.04241213f, 0.01392329f, 0.03323955f, 0.03953655f, 0.01011157f, -0.00210889f, 0.03934801f, -0.02416095f, 
    0.04005634f, -0.01729427f, -0.03680782f, 0.03818822f, -0.02721170f, -0.03128550f, -0.00252767f, -0.00997625f, 
    0.02096155f, 0.01911324f, 0.00317315f, -0.00646563f, -0.01863077f, -0.02956948f, -0.01212741f, 0.02382723f, 
    0.00195272f, 0.03323521f, -0.02896377f, -0.03097200f, -0.03138280f, -0.04225645f, 0.03941876f, -0.03504014f, 
    -0.05314292f, -0.04964385f, -0.02681834f, 0.01209725f, 0.02754430f, 0.03440149f, 0.03985716f, 0.04153326f, 
    -0.01558388f, 0.03472548f, -0.04237423f, 0.01061619f, -0.01899106f, 0.00989095f, 0.01900143f, -0.03485985f, 
    -0.03884216f, -0.01182112f, 0.04329734f, 0.04037531f, 0.02073397f, 0.01389589f, 0.02696307f, -0.03141420f, 
    -0.00626483f, -0.00007229f, -0.03360657f, -0.03594746f, -0.04789950f, -0.02578535f, 0.04657309f, 0.01769850f, 
    0.03529450f, 0.03403778f, -0.03193909f, 0.03431403f, 0.03337697f, 0.00422908f, -0.04288030f, -0.04678944f, 
    0.02735703f, -0.01601333f, -0.03667706f, 0.02407280f, -0.01606505f, -0.01612326f, 0.02935087f, -0.01315276f, 
    -0.02361862f, -0.00714669f, 0.00184058f, 0.02223054f, -0.03664177f, -0.04590669f, 0.01292094f, 0.02856589f, 
    0.02989786f, 0.03059094f, 0.02954777f, 0.02568299f, 0.00499626f, -0.03777020f, 0.03883987f, -0.00529551f, 
    0.03836036f, -0.01537054f, -0.04223488f, 0.01788872f, 0.02984195f, -0.03050858f, 0.02317700f, 0.00695718f, 
    0.00887986f, 0.01844581f, 0.02156764f, 0.00381139f, -0.02888766f, -0.02009840f, 0.00402031f, -0.04428764f, 
    0.01765197f, 0.03572182f, -0.00036932f, -0.05411140f, -0.02242402f, -0.03370791f, 0.04007800f, -0.01118658f, 
    0.04405572f, 0.03778379f, 0.03654987f, 0.02326549f, -0.04636709f, -0.02793919f, 0.00422520f, -0.03165229f, 
    0.02446607f, 0.02760659f, -0.05162117f, 0.02591009f, 0.02781201f, -0.04957524f, 0.03159384f, 0.03197768f, 
    0.02815034f, 0.00108526f, -0.03942890f, 0.04120817f, -0.00138294f, 0.03439523f, 0.00125543f, 0.01912768f, 
    -0.02884151f, 0.00071000f, -0.00857730f, -0.04119790f, -0.01025245f, 0.00243345f, -0.04467839f, 0.02125259f, 
    -0.03069088f, 0.01887302f, 0.00986233f, 0.02618901f, 0.02138503f, 0.03736396f, -0.05390079f, 0.00321145f, 
    0.04199165f, -0.04962068f, 0.00616399f, -0.01843290f, -0.03052382f, -0.04535164f, 0.03691758f, 0.04590632f, 
    0.04348658f, -0.03251174f, 0.03345658f, 0.00850950f, -0.01836397f, -0.01353239f, 0.00529268f, 0.00758159f, 
    0.03022615f, -0.04950724f, -0.01657750f, -0.01183687f, -0.04837542f, 0.02366709f, -0.01734964f, -0.05331164f, 
    -0.00325617f, -0.02061141f, -0.00351025f, 0.01948387f, -0.01341010f, -0.01911018f, -0.03062342f, -0.01846419f, 
    0.01193507f, 0.03178682f, 0.02150068f, 0.00895740f, -0.01067154f, -0.01711204f, 0.01789267f, -0.00002956f, 
    0.02894292f, -0.03005004f, -0.04698770f, 0.00322000f, -0.03153175f, 0.02012450f, -0.03754008f, -0.05458696f, 
    -0.02469278f, -0.03049574f, 0.04101568f, -0.02202697f, -0.01148278f, -0.01480465f, -0.01701688f, -0.03276380f, 
    -0.01198421f, -0.01803225f, 0.00574020f, -0.00902230f, -0.04386828f, -0.01275915f, -0.01718578f, 0.01963485f, 
    -0.04807393f, 0.04288184f, -0.01608455f, -0.02047370f, 0.00114089f, -0.04431169f, 0.00746415f, 0.04406932f, 
    -0.01499221f, -0.04773069f, -0.01988927f, -0.04066723f, 0.01749690f, 0.03989944f, -0.03017199f, 0.04119676f, 
    0.03475716f, -0.02186840f, -0.04655154f, -0.05585877f, 0.00310816f, -0.00823204f, 0.00261698f, -0.03449366f, 
    0.00424634f, -0.01151392f, -0.02217839f, -0.04997554f, 0.03248692f, 0.02145071f, 0.02916128f, -0.04743305f, 
    -0.04036130f, 0.03953707f, 0.02242470f, -0.04546850f, -0.02839330f, 0.04541820f, -0.02048382f, 0.04125348f, 
    0.00073953f, -0.04294791f, -0.03428103f, -0.01694116f, -0.03454224f, 0.04117725f, -0.03201183f, 0.03009827f, 
    -0.00899556f, -0.01820826f, 0.04169226f, -0.01659474f, -0.02357457f, 0.02543052f, -0.02863893f, -0.01961658f, 
    -0.00465514f, -0.01878854f, -0.04326546f, -0.03734272f, -0.05351083f, 0.01603229f, 0.04101027f, -0.01052914f, 
    0.00900175f, -0.02735194f, 0.02243972f, -0.01932329f, -0.00447340f, 0.04012559f, -0.00099944f, -0.04381597f, 
    0.01645888f, 0.02120437f, 0.02843018f, 0.04080814f, -0.02095044f, -0.02474882f, -0.03889210f, -0.05322250f, 
    0.02509838f, 0.01819477f, 0.02557378f, -0.03866724f, -0.05587709f, -0.04933173f, -0.05523437f, -0.03129492f, 
    0.03489469f, -0.03155566f, -0.02022927f, -0.02400742f, -0.00108428f, 0.03698706f, -0.01181543f, -0.01382092f, 
    -0.04053578f, -0.05489706f, 0.01247434f, 0.03887937f, 0.01357953f, -0.04645088f, 0.00728926f, -0.04313144f, 
    -0.01515904f, -0.04532101f, 0.00462657f, 0.03156397f, -0.03481691f, 0.00634319f, -0.05108779f, -0.03571799f, 
    0.03792657f, -0.05260835f, -0.00437097f, -0.05483821f, -0.04824627f, 0.01703089f, -0.03808226f, -0.04354520f, 
    0.04015613f, -0.04682821f, 0.04266301f, -0.02339738f, -0.03809984f, 0.02053185f, 0.02860630f, 0.00045461f, 
    -0.05565329f, -0.04428979f, 0.01578116f, -0.04963664f, -0.00430149f, -0.02865353f, -0.05062710f, -0.02975694f, 
    0.03740006f, -0.01296061f, -0.04175020f, 0.00792736f, -0.04239183f, -0.01255638f, 0.03956490f, -0.05350638f, 
    -0.00968079f, -0.05418415f, -0.02474167f, -0.04606174f, -0.03223214f, -0.01001495f, -0.02063896f, 0.03256234f, 
    -0.01356772f, -0.01000518f, -0.00638207f, 0.00626041f, -0.02663220f, 0.00703477f, 0.00962932f, -0.00137162f, 
    -0.10869817f, -0.06548053f, 0.35216215f, 0.03865811f, -0.06809261f, -0.01101233f, 0.02826324f, -0.02086826f, 
    0.00850238f, -0.00239701f, 0.05745712f, -0.06469049f, 0.14169373f, 0.19984770f, -0.09613410f, 0.11313885f, 
    -0.02651875f, 0.05117368f, 0.17355999f, -0.12129243f, 0.05246533f, 0.08184086f, 0.02163303f, 0.02579871f, 
    -0.14241390f, 0.10276279f, -0.01056902f, -0.06854780f, 0.06420460f, -0.05992689f, 0.02109427f, 0.03705250f, 
    -0.06842475f, 0.07659060f, -0.10786737f, -0.10812531f, 0.07064434f, 0.01712111f, 0.00853571f, 0.00391881f, 
    0.06809070f, 0.11241214f, -0.07927611f, 0.16047944f, 0.03785076f, 0.10424973f, -0.03963939f, 0.15200098f, 
    -0.14462151f, 0.23781760f, -0.09109866f, 0.12274873f, 0.24097489f, 0.03617835f, -0.06473053f, -0.20574172f, 
    0.06815992f, -0.01413152f, -0.18505353f, 0.18805593f, -0.21749243f, 0.08932142f, 0.06106139f, 0.16376667f, 
    -0.06375806f, 0.12813385f, 0.17634819f, -0.07279209f, 0.05768470f, 0.08763288f, 0.06460192f, 0.07808956f, 
    -0.00736987f, 0.09648719f, 0.11031098f, 0.04819686f, 0.21709932f, 0.05035811f, -0.08518068f, -0.20584585f, 
    0.00589464f, -0.04460607f, -0.04402504f, 0.02025645f, 0.12501116f, 0.23652805f, -0.09355196f, -0.07522634f, 
    0.10517602f, -0.06158362f, -0.07063026f, -0.05437360f, -0.00106087f, -0.11902831f, 0.10119225f, 0.00133289f, 
    0.10932790f, -0.17246550f, -0.05268473f, -0.09248562f, 0.08614653f, -0.19028717f, 0.04133439f, -0.10741065f, 
    -0.01101719f, -0.04334873f, 0.09530038f, 0.12736611f, 0.28705332f, 0.14412704f, -0.07115259f, 0.14384860f, 
    0.17809868f, -0.01283705f, -0.08631904f, 0.03797103f, 0.07827493f, -0.07185045f, -0.09061566f, 0.15514700f, 
    0.02644472f, -0.08291376f, -0.05631034f, 0.27991912f, 0.00701848f, 0.00994344f, 0.01271983f, -0.04330216f, 
    0.00451616f, 0.04114391f, 0.09486002f, 0.10055897f, -0.02204728f, -0.14538930f, 0.07360812f, -0.22243428f, 
    0.01597485f, 0.00927805f, 0.09020524f, 0.10576966f, 0.01644631f, 0.05735389f, 0.03986637f, 0.17098804f, 
    -0.05788449f, 0.12766568f, -0.02461540f, 0.03292371f, 0.02602870f, -0.06796239f, 0.11304714f, -0.04033948f, 
    0.11701617f, 0.10849608f, -0.03955468f, -0.00792520f, -0.16759036f, -0.16171403f, 0.13965650f, 0.18887815f, 
    0.07762300f, 0.23655348f, -0.11364135f, 0.09920941f, 0.16172013f, -0.01696914f, 0.09166836f, 0.05304179f, 
    -0.06255148f, 0.04718364f, -0.01657713f, 0.10693910f, 0.00706450f, 0.01481111f, 0.07913683f, 0.04939988f, 
    -0.06229586f, 0.16925617f, -0.10557279f, 0.08060347f, 0.07294421f, 0.18260238f, -0.07182666f, 0.17436855f, 
    0.21103525f, 0.00224381f, 0.01876011f, 0.02153252f, 0.05052608f, 0.03688898f, 0.02868402f, -0.07900283f, 
    0.34219193f, 0.15298820f, 0.18904755f, 0.06635826f, 0.09895962f, 0.08916519f, 0.02259725f, 0.00541492f, 
    0.15978691f, -0.13418369f, 0.01113691f, -0.09559005f, -0.02509327f, -0.09595128f, -0.06746613f, -0.05466695f, 
    -0.07704224f, -0.03386623f, 0.05727359f, -0.06052970f, 0.00231666f, 0.02191702f, 0.19573423f, 0.12572363f, 
    0.28939980f, 0.26825497f, -0.37773025f, -0.24501975f, 0.13946712f, 0.05277016f, -0.03080177f, 0.18798865f, 
    -0.05425603f, -0.03536777f, -0.00000399f, -0.00341580f, 0.03418300f, -0.18855083f, 0.26621616f, -0.15089633f, 
    0.04776264f, -0.03250524f, 0.10401893f, -0.04450718f, -0.02016697f, 0.12498958f, 0.04917103f, 0.07354203f, 
    0.24045414f, -0.22989015f, 0.07436896f, -0.12448464f, -0.13129880f, -0.07254287f, 0.12226238f, -0.03374504f, 
    0.04772111f, 0.01161195f, -0.02185206f, -0.15746751f, 0.32127187f, -0.22487804f, 0.04319153f, 0.08456860f, 
    -0.03945614f, -0.02445184f, -0.03871522f, 0.01492213f, -0.07328699f, 0.01663915f, 0.14562391f, -0.05102636f, 
    -0.17394263f, 0.10412616f, -0.04244703f, 0.34966555f, -0.06629491f, -0.00041941f, -0.16935158f, -0.08816928f, 
    -0.03433527f, -0.09418850f, -0.06359587f, -0.17134349f, -0.27114803f, 0.11008905f, -0.14075197f, -0.31377468f, 
    0.05392508f, 0.05539282f, -0.03663775f, 0.03213635f, -0.05172720f, 0.03161405f, -0.02226333f, 0.14954263f, 
    0.04019957f, -0.02762580f, 0.27400678f, -0.10914014f, -0.03862481f, -0.07834359f, 0.09344041f, -0.20991234f, 
    0.05599204f, -0.16869284f, -0.00094336f, 0.05390856f, -0.09869993f, 0.06489465f, 0.04393277f, -0.29813200f, 
    -0.04112333f, -0.14333357f, -0.19720483f, 0.09675130f, 0.10002512f, -0.02343625f, -0.14260308f, -0.07623614f, 
    0.03986784f, 0.07234636f, -0.00362678f, 0.02981099f, -0.05836513f, 0.22180568f, 0.07915788f, -0.16586307f, 
    0.01078878f, -0.04418385f, 0.06285537f, 0.06413437f, -0.25885683f, -0.09062331f, -0.15743358f, -0.01444594f, 
    -0.04216972f, -0.00232494f, -0.02872142f, -0.07612704f, 0.08617678f, -0.05044945f, -0.08329996f, -0.08296680f, 
    -0.00598431f, -0.06305993f, -0.13075095f, 0.03932020f, -0.03978731f, 0.09961721f, -0.01906024f, 0.11127055f, 
    -0.01784638f, 0.06445093f, 0.10865252f, 0.03343675f, -0.23067503f, -0.15714933f, 0.15669964f, -0.15874438f, 
    -0.07304633f, -0.01655406f, -0.07566847f, -0.00994217f, -0.02997779f, -0.19743240f, 0.12579216f, -0.00668351f, 
    0.09009708f, 0.09894252f, -0.08395081f, -0.11207356f, 0.00914828f, 0.04184870f, 0.05241092f, -0.15056175f, 
    0.05633452f, 0.05205324f, 0.11061516f, -0.00280605f, 0.36798817f, 0.03572175f, -0.24775699f, 0.09798943f, 
    -0.00485297f, 0.05173550f, 0.04342441f, 0.06591817f, 0.24969412f, 0.07517052f, -0.00171971f, -0.03578063f, 
    0.02394251f, -0.04739142f, -0.00889377f, 0.03273851f, -0.01706718f, 0.02778989f, 0.03850160f, 0.00270987f, 
    -0.00621411f, 0.04301378f, 0.01407620f, -0.04917441f, 0.03020504f, -0.01620611f, 0.01802810f, 0.01048910f, 
    0.02872143f, 0.02733665f, 0.04014184f, -0.01771906f, 0.00878039f, -0.03133652f, -0.01993457f, -0.00144082f, 
    0.00752698f, -0.03215601f, -0.02399619f, 0.03862232f, -0.05113463f, -0.03968569f, 0.03413311f, -0.04233535f, 
    -0.01413914f, 0.00584958f, -0.00543761f, -0.00606686f, 0.00882012f, -0.03824143f, -0.01604175f, -0.02522651f, 
    0.02551029f, -0.01387965f, -0.01679007f, 0.00855473f, -0.01082525f, -0.01458279f, -0.05787532f, 0.03791527f, 
    0.03243150f, 0.03135002f, 0.00783980f, -0.03601453f, -0.04371499f, -0.00209873f, 0.03883576f, 0.01085348f, 
    -0.03613447f, 0.01018603f, 0.01193388f, -0.05700195f, 0.01580774f, -0.04981013f, 0.00839839f, 0.01765035f, 
    -0.04430279f, 0.00820160f, 0.00049679f, -0.00636074f, -0.02847146f, 0.00329372f, 0.01683969f, -0.02536005f, 
    -0.05242931f, 0.01769404f, -0.01275604f, -0.00038401f, 0.01529816f, -0.01743240f, -0.01689945f, 0.03626315f, 
    0.02652787f, 0.03175027f, -0.01091553f, -0.03690723f, -0.04675708f, -0.03982532f, 0.02569285f, 0.03357447f, 
    -0.00743388f, 0.02298600f, 0.03172957f, -0.00200824f, 0.03412092f, 0.01060725f, -0.02213487f, 0.03105324f, 
    -0.03078877f, -0.03671478f, 0.02241018f, 0.01557607f, -0.04360565f, -0.04984492f, 0.00350084f, -0.04257105f, 
    0.02601296f, -0.02542524f, -0.03867292f, 0.00334574f, 0.03163775f, -0.01014355f, -0.04526837f, -0.01286989f, 
    0.02809365f, 0.00309488f, -0.04248555f, 0.02512566f, -0.04428839f, -0.00600428f, 0.00239568f, 0.03857796f, 
    0.03415331f, -0.04444993f, -0.05864233f, -0.04976009f, -0.04352764f, 0.01387611f, -0.00060988f, -0.02387212f, 
    -0.05107369f, 0.02831428f, -0.01487219f, 0.03761780f, 0.02205492f, -0.00499336f, 0.02183845f, -0.03088946f, 
    -0.04116122f, -0.00283116f, 0.01128826f, -0.04805653f, 0.01565287f, -0.05374025f, -0.04280575f, 0.01101163f, 
    0.03257422f, 0.00053991f, 0.00840348f, -0.00024621f, -0.04198885f, 0.02700157f, -0.00218481f, -0.04957718f, 
    -0.04439063f, -0.03416235f, -0.00297769f, 0.00951578f, -0.02732827f, 0.01774636f, -0.02712828f, -0.03829753f, 
    0.00276430f, -0.00452170f, 0.00771671f, -0.01742255f, -0.04083997f, 0.02662398f, -0.00710375f, -0.00890378f, 
    0.02178005f, 0.04001015f, -0.01254358f, -0.00650844f, -0.01625828f, -0.05166511f, 0.00387763f, 0.02386376f, 
    0.03123208f, -0.02986168f, 0.03433343f, -0.01283527f, 0.00432912f, -0.01983941f, 0.01132394f, -0.05679936f, 
    0.01827630f, -0.01891862f, 0.03805292f, 0.00354101f, 0.01078276f, 0.01859334f, -0.02508321f, 0.00812124f, 
    -0.04189201f, 0.01044481f, -0.00488320f, -0.04930328f, -0.03676713f, -0.04203793f, 0.03297584f, -0.03771590f, 
    -0.00062769f, 0.00791660f, -0.01962810f, 0.02150570f, -0.03542525f, -0.02302083f, 0.03319218f, -0.03148683f, 
    -0.05006340f, 0.01175432f, 0.00125405f, -0.05854985f, 0.03520024f, -0.01213956f, -0.00960890f, -0.03008763f, 
    0.01976231f, 0.03120423f, 0.03046582f, -0.05227445f, 0.01836397f, -0.01252259f, -0.00844257f, 0.03464568f, 
    0.04486041f, -0.02430489f, -0.02243341f, -0.01666526f, -0.00847053f, -0.04087315f, -0.02814543f, -0.04005190f, 
    0.01454603f, -0.02392837f, 0.00568932f, -0.04078228f, 0.01700827f, -0.03249475f, -0.00149316f, 0.03751819f, 
    0.02672038f, -0.01203365f, -0.04745417f, 0.03158001f, -0.02943134f, -0.00666311f, 0.03122436f, 0.01098387f, 
    0.02549092f, 0.00687985f, 0.00762744f, 0.00664811f, -0.01435026f, -0.01907080f, -0.02634726f, -0.05210243f, 
    -0.02622970f, 0.04043590f, -0.01259242f, -0.03098790f, 0.00839467f, -0.01973432f, -0.02899948f, 0.01027122f, 
    0.02023715f, -0.04072088f, -0.03581502f, 0.00529527f, 0.00716247f, 0.04079142f, -0.04005613f, -0.01677222f, 
    0.01270798f, 0.00870182f, -0.01290932f, -0.01783809f, -0.04184825f, -0.00021364f, 0.02239748f, 0.00690820f, 
    -0.05700033f, -0.01531011f, 0.02400832f, -0.01835986f, 0.00786953f, -0.05794291f, -0.02028675f, -0.01750632f, 
    -0.03698437f, 0.01081734f, 0.00380380f, -0.00660127f, 0.01315286f, -0.00679662f, 0.03320532f, -0.04473430f, 
    0.00120781f, -0.01108245f, -0.01633694f, -0.03127233f, -0.02512165f, -0.00036241f, 0.00817586f, -0.02311050f, 
    0.03788379f, -0.04211529f, 0.03594322f, 0.04021176f, 0.02254979f, -0.00326218f, -0.02078279f, -0.01791278f, 
    -0.03726985f, -0.00348471f, 0.01285772f, 0.01157865f, -0.05307863f, -0.00130785f, -0.04245158f, 0.02510317f, 
    -0.03669448f, 0.00936048f, -0.02695428f, -0.04409507f, 0.04104064f, -0.02626989f, 0.04069899f, -0.05268366f, 
    0.01305360f, -0.00471972f, -0.01950398f, -0.00725791f, 0.03828528f, 0.01668166f, -0.05379067f, -0.02589250f, 
    -0.01948661f, -0.03165926f, 0.02649947f, 0.03717011f, 0.01901799f, -0.02807479f, -0.05979815f, 0.03603136f, 
    -0.03835891f, 0.03243143f, 0.03009527f, -0.00640805f, 0.01430962f, 0.00997302f, 0.01685416f, -0.01978934f, 
    0.02383834f, 0.03413942f, -0.01897356f, -0.05563955f, -0.04938668f, 0.01221164f, -0.02005563f, 0.02766900f, 
    -0.01969196f, 0.03157129f, 0.01524021f, -0.04475466f, 0.01470196f, 0.01620285f, -0.05905692f, 0.00433694f, 
    -0.05701990f, -0.00733807f, -0.03961054f, -0.03414783f, -0.00793925f, -0.00500080f, 0.01013903f, 0.03468698f, 
    -0.03964624f, -0.04088482f, -0.04393874f, -0.03560038f, 0.02532450f, -0.01454941f, 0.01020259f, -0.03830257f, 
    -0.01872677f, 0.00956156f, -0.05079146f, 0.02221740f, -0.01284781f, -0.02933245f, 0.03705946f, 0.02890450f, 
    0.01968599f, -0.05581819f, -0.04586558f, -0.05570641f, -0.02302665f, -0.00499273f, 0.03471520f, -0.01150568f, 
    -0.01972504f, 0.04115330f, 0.04231625f, -0.03393900f, -0.00813861f, 0.02632536f, 0.00777624f, 0.00692435f, 
    -0.04348414f, 0.00501153f, 0.01197306f, 0.01150873f, 0.03836896f, 0.01016583f, -0.01911555f, -0.01018209f, 
    0.04329688f, 0.02323331f, -0.02267268f, -0.00853917f, -0.01842033f, 0.01630315f, -0.02458095f, 0.02093644f, 
    0.03896083f, -0.02134414f, 0.03066538f, -0.01595708f, -0.04672283f, -0.03950153f, -0.03499874f, -0.02156504f, 
    0.00864209f, 0.03316682f, -0.05495197f, -0.00115855f, -0.01101096f, -0.01819839f, -0.03947469f, -0.01629259f, 
    -0.02590263f, 0.00981553f, -0.04118421f, 0.04231147f, 0.03169248f, -0.02801885f, -0.03267447f, -0.01231606f, 
    -0.03908155f, -0.04488562f, 0.02923685f, -0.00447679f, -0.04313831f, -0.04120670f, 0.00086824f, -0.01092778f, 
    -0.01163446f, 0.01696179f, -0.03914381f, 0.01868677f, 0.01398734f, 0.01745648f, 0.03717085f, 0.00757991f, 
    -0.00260051f, 0.00720170f, 0.00740344f, -0.01718033f, 0.02998870f, 0.02877470f, 0.00443650f, -0.01523300f, 
    -0.01725318f, -0.05507081f, 0.00809640f, 0.03603577f, -0.03155240f, -0.01717628f, -0.04575866f, 0.02413954f, 
    -0.01111072f, 0.04826666f, 0.03671393f, 0.03343576f, -0.02272906f, 0.02158656f, -0.01447414f, -0.02031066f, 
    0.02896941f, -0.00438944f, -0.01078925f, 0.00314796f, 0.00260491f, -0.02602166f, -0.01793551f, 0.00211380f, 
    -0.05373577f, -0.00824756f, 0.03472477f, 0.01669920f, -0.05048931f, -0.03720452f, -0.00276837f, -0.00559537f, 
    -0.04816449f, -0.01080433f, -0.01023965f, 0.00942091f, -0.03127826f, 0.02165581f, -0.05033497f, -0.03049588f, 
    -0.00153643f, -0.03845365f, -0.02496436f, 0.02814999f, -0.03285555f, 0.02915784f, 0.01929772f, 0.00543712f, 
    0.00426336f, -0.02485923f, 0.00226886f, 0.00047409f, 0.03290755f, -0.01688211f, 0.00976365f, 0.02753487f, 
    -0.01704189f, -0.05231763f, 0.00542724f, 0.00813874f, -0.03819907f, 0.00591505f, -0.02381179f, 0.02673459f, 
    0.02271827f, -0.02999517f, -0.02677528f, -0.03447042f, -0.00796835f, -0.02568902f, -0.01226354f, 0.00960515f, 
    0.02305955f, 0.00658410f, -0.02912111f, -0.00388891f, -0.00926310f, 0.01697647f, -0.01249218f, 0.03933431f, 
    -0.02589999f, 0.02596638f, -0.00203509f, -0.04678512f, 0.00685381f, -0.00170355f, -0.03030965f, -0.04800368f, 
    -0.00781036f, 0.01850234f, -0.05033218f, -0.03346926f, -0.05385107f, 0.01203800f, 0.01708941f, 0.04147337f, 
    0.02146798f, -0.04220141f, 0.00821822f, -0.01900007f, 0.01036845f, -0.01902299f, 0.04016671f, -0.00862218f, 
    -0.03425676f, 0.00825940f, 0.03296403f, -0.02364298f, 0.02764586f, -0.02855726f, -0.02722670f, -0.00354837f, 
    -0.01834009f, 0.03797873f, 0.03245592f, -0.01071002f, -0.04797845f, 0.02796925f, 0.02663256f, -0.03769220f, 
    0.02127299f, 0.02553594f, 0.03145247f, -0.01211704f, 0.03746675f, -0.01280805f, 0.00363236f, -0.04503383f, 
    -0.00289403f, 0.03194274f, 0.01658227f, 0.02224859f, -0.03477454f, -0.01528939f, -0.01003989f, 0.00526344f, 
    -0.00915256f, -0.02315176f, -0.00352292f, -0.05113420f, -0.01286636f, -0.05138889f, -0.03573996f, 0.02213125f, 
    0.01716097f, -0.04225653f, 0.04451961f, -0.01948206f, -0.04569611f, -0.04555366f, 0.01327270f, -0.04198473f, 
    -0.03732811f, -0.02637962f, -0.04193797f, 0.01591290f, -0.00530376f, 0.02483933f, -0.02123417f, -0.03628176f, 
    0.03565473f, -0.03057157f, -0.04940286f, 0.00700324f, 0.01957564f, -0.04329917f, -0.04214961f, -0.02879809f, 
    -0.00861175f, -0.01123821f, -0.04977397f, -0.03814111f, -0.02548720f, -0.03044485f, 0.00646830f, -0.00378165f, 
    0.04504604f, 0.00228163f, -0.00174228f, -0.00977798f, -0.02637244f, 0.03246492f, 0.02357908f, -0.03383364f, 
    -0.04029708f, -0.00168021f, -0.00228724f, 0.03498829f, -0.02668445f, 0.02720220f, -0.00065000f, 0.02719611f, 
    -0.02636206f, -0.04254873f, 0.03080379f, -0.00539087f, -0.05141550f, 0.01380943f, 0.02487059f, 0.02113238f, 
    -0.00021081f, -0.01289798f, -0.05560539f, 0.03669528f, 0.01706547f, 0.02147790f, -0.03733764f, 0.01585414f, 
    -0.02646388f, -0.02564273f, -0.01653886f, -0.00713820f, -0.00747190f, -0.04439892f, -0.01655459f, -0.05148705f, 
    0.02600753f, -0.04567327f, 0.01012229f, -0.00626684f, 0.03980393f, -0.05219673f, 0.00705955f, 0.03173899f, 
    -0.03425952f, 0.04356415f, -0.01445752f, -0.04382012f, -0.03686836f, 0.00920216f, -0.00699320f, -0.03341136f, 
    0.00568382f, -0.02637542f, -0.03449849f, 0.04077552f, 0.00480836f, -0.01023485f, -0.05294548f, 0.03951885f, 
    -0.00801008f, -0.02008625f, 0.04123555f, 0.00758998f, 0.03536683f, -0.04096425f, -0.00171588f, -0.03529661f, 
    -0.00701781f, -0.01718699f, -0.04691035f, -0.01175035f, 0.02383658f, -0.02259863f, -0.04950562f, 0.01179455f, 
    0.02380091f, -0.01974232f, -0.01048234f, -0.02665075f, -0.01087634f, 0.04151925f, -0.01211435f, -0.02018355f, 
    -0.00134972f, -0.04630899f, 0.00480847f, 0.01770051f, 0.03499184f, -0.03605046f, 0.00882190f, 0.00730746f, 
    -0.03060202f, 0.01830070f, -0.00768396f, -0.05580746f, -0.01104056f, 0.00655680f, -0.05303736f, -0.05154580f, 
    0.03187869f, -0.03561557f, -0.04401607f, 0.02657259f, -0.01759045f, 0.03199371f, -0.05213958f, -0.03113074f, 
    -0.03790610f, -0.03994697f, -0.05161537f, -0.03208922f, -0.03503739f, -0.01798002f, 0.00001675f, 0.00268208f, 
    0.06241291f, -0.05254427f, -0.10176530f, -0.23678434f, -0.10724761f, 0.00664113f, -0.04328915f, -0.04774611f, 
    -0.20678076f, 0.05332826f, -0.10020271f, 0.14792795f, 0.04870054f, -0.04954832f, 0.12858403f, -0.30637982f, 
    -0.06547958f, 0.02978920f, 0.10996518f, -0.09356527f, -0.06605542f, 0.03251968f, 0.05917564f, -0.00308265f, 
    -0.28876111f, 0.01659292f, -0.32556114f, -0.21095064f, 0.18385425f, -0.08351701f, 0.09634181f, 0.07524113f, 
    0.05856746f, 0.08655215f, 0.07685841f, 0.09370710f, 0.19993147f, -0.23015839f, -0.12533349f, -0.25908700f, 
    0.03293426f, 0.03034452f, 0.03852881f, -0.11618915f, 0.10465585f, 0.02060535f, -0.02267795f, 0.13889682f, 
    0.07304090f, 0.25408909f, -0.07719382f, 0.29306322f, 0.20089635f, 0.02601899f, 0.04756243f, -0.09264419f, 
    0.04686353f, 0.05582290f, 0.08792299f, 0.03202155f, 0.12029297f, -0.04219562f, -0.14076836f, 0.24645075f, 
    0.02991948f, -0.02666827f, 0.07267679f, 0.04002982f, -0.13608488f, -0.00651751f, -0.04752606f, -0.11361817f, 
    0.36374649f, 0.25569448f, -0.07379513f, -0.02429220f, 0.10537810f, 0.02437341f, 0.13581423f, 0.02273912f, 
    0.01200650f, 0.00872678f, 0.02409316f, -0.05580240f, -0.32872662f, -0.08426561f, -0.23691265f, -0.27782807f, 
    -0.03636701f, -0.03833956f, -0.05866985f, 0.03953492f, 0.02388766f, -0.08020651f, 0.06484333f, -0.03967827f, 
    0.18416600f, -0.24868636f, 0.07560049f, 0.18282479f, 0.00232460f, 0.02668787f, 0.19915943f, -0.03898380f, 
    -0.06352489f, -0.04941655f, 0.03235504f, 0.19954430f, 0.31184223f, 0.14892825f, -0.19011046f, -0.18438332f, 
    0.04451296f, 0.15996192f, -0.10643252f, -0.10472971f, 0.05113940f, 0.15154846f, 0.02829666f, -0.05466698f, 
    -0.23801099f, -0.15657398f, -0.07823143f, -0.00024680f, 0.14320569f, 0.01508202f, -0.00158280f, 0.06856904f, 
    -0.07354948f, 0.07054895f, -0.00667230f, -0.07889482f, -0.15267180f, 0.16612318f, 0.09647411f, 0.05358473f, 
    0.01333526f, 0.00633740f, -0.01151037f, 0.02282245f, 0.04729131f, 0.07370444f, 0.00923469f, -0.13375644f, 
    0.09428331f, 0.13030232f, 0.19856222f, 0.11960260f, 0.07549954f, -0.00768900f, -0.04674054f, 0.07730025f, 
    -0.12231697f, 0.13532048f, 0.00146524f, -0.10105385f, 0.06834313f, -0.12632181f, 0.00375461f, 0.20384626f, 
    0.30375725f, 0.08833381f, -0.05139300f, -0.05701569f, 0.03588207f, -0.13401502f, -0.07205588f, 0.12350247f, 
    0.02384659f, 0.17477660f, -0.00450568f, 0.36137462f, 0.28913069f, -0.07085291f, 0.07166553f, -0.10709208f, 
    0.01456760f, 0.13709781f, -0.03532936f, 0.11127049f, -0.06225111f, 0.06517597f, -0.08924984f, -0.00674091f, 
    0.02311692f, 0.09741643f, 0.07983473f, -0.02541082f, 0.14455061f, 0.16580124f, 0.09172949f, 0.00392147f, 
    -0.07730579f, -0.02754629f, -0.26942590f, 0.01879433f, -0.14915752f, -0.07221706f, 0.00113661f, 0.01869711f, 
    0.05731355f, -0.02415962f, -0.15445319f, 0.05446192f, 0.15495336f, 0.11208143f, -0.06809572f, -0.05052996f, 
    0.00396413f, 0.11165237f, -0.07519032f, 0.01191923f, -0.05830125f, -0.00394533f, -0.06055364f, -0.01044873f, 
    -0.27400371f, -0.02426833f, -0.31577969f, -0.15176602f, 0.01663811f, 0.13957429f, -0.00862901f, 0.00285275f, 
    -0.08265047f, -0.04597045f, -0.05744778f, -0.08484022f, 0.29547372f, -0.30769309f, 0.11499752f, -0.06964190f, 
    -0.11422310f, -0.08744477f, -0.06925127f, -0.03708337f, -0.07931969f, -0.02983576f, 0.00341109f, -0.01574348f, 
    0.16179316f, -0.43840057f, 0.24412420f, 0.14846584f, -0.05035646f, -0.09665517f, -0.09189164f, 0.06672000f, 
    0.02131599f, -0.05968607f, -0.11872630f, 0.16172656f, 0.18046503f, -0.14390945f, -0.11844467f, -0.02363768f, 
    0.19394876f, 0.00975356f, 0.00751463f, -0.03937412f, 0.02603202f, -0.01040260f, -0.00929442f, 0.01560897f, 
    -0.03135433f, 0.07511333f, 0.03778500f, 0.02113377f, -0.15297844f, -0.08348260f, -0.05921923f, -0.12927333f, 
    -0.02526292f, -0.04047577f, 0.06014997f, 0.12277804f, 0.01262577f, 0.35277492f, 0.07719570f, 0.19380377f, 
    0.21002908f, 0.07275795f, 0.05529430f, -0.02579465f, -0.02253979f, 0.09947214f, 0.08681279f, 0.01586834f, 
    -0.24049814f, -0.04384483f, 0.28200191f, 0.23984592f, -0.11971024f, -0.23149391f, -0.04587970f, 0.07058932f, 
    0.12529811f, -0.01385920f, -0.03918844f, 0.07604597f, 0.15209995f, 0.17998676f, 0.03513975f, 0.04727579f, 
    -0.02719305f, -0.10800034f, 0.17816997f, 0.15321518f, 0.02299847f, 0.12158471f, -0.02195567f, 0.08449132f, 
    0.17676723f, -0.34721830f, 0.27554831f, 0.06276907f, -0.12509584f, 0.10245840f, -0.02109148f, 0.19238064f, 
    -0.02765660f, -0.00188711f, 0.00269194f, 0.10819291f, -0.25951925f, -0.12310810f, -0.01007115f, 0.37183177f, 
    -0.12005428f, -0.03226299f, 0.01701434f, 0.06919061f, -0.00675385f, 0.03484279f, 0.09212402f, 0.03820631f, 
    0.26684621f, 0.24645439f, -0.04808744f, 0.15907501f, 0.01240701f, 0.07223220f, 0.08152883f, 0.02957182f, 
    -0.02175277f, -0.04289560f, 0.11935726f, -0.04154355f, 0.07695196f, 0.18999821f, 0.16492280f, -0.06338520f, 
    -0.15398958f, 0.08763120f, -0.06547093f, 0.02555285f, 0.03209569f, -0.00654409f, 0.12959580f, -0.01348415f, 
    -0.01208542f, -0.13558541f, 0.13496692f, 0.29910827f, -0.03632063f, -0.03033176f, 0.10336949f, -0.08825383f, 
    0.00681883f, 0.02736228f, 0.09133189f, -0.00484826f, 0.26806977f, 0.01708808f, -0.05113443f, 0.16860221f, 
    -0.02236374f, -0.12022613f, 0.09540202f, -0.06641303f, -0.01073049f, -0.01936054f, -0.06116197f, -0.04560713f, 
    0.11901420f, 0.19427225f, -0.11894048f, -0.01533329f, 0.05070841f, 0.06874214f, -0.10167520f, 0.16544501f, 
    -0.20135367f, -0.08375146f, 0.12710853f, 0.02073205f, 0.17044125f, 0.07260191f, 0.13018051f, 0.01260429f, 
    -0.01055867f, 0.05977459f, -0.11001784f, -0.02546036f, -0.02509844f, -0.06094317f, 0.02181881f, 0.08480015f, 
    0.15263426f, 0.13375345f, 0.01180447f, 0.07120651f, 0.10790627f, 0.04518509f, 0.03018565f, -0.13637371f, 
    0.15640895f, -0.13050891f, 0.18982734f, 0.07158454f, 0.23166908f, -0.08156256f, 0.01080226f, 0.10568868f, 
    0.00812125f, -0.07851031f, 0.10005461f, -0.08786316f, 0.08215004f, -0.20171347f, 0.07966262f, 0.00930436f, 
    -0.08296400f, -0.21141858f, 0.17028610f, 0.08177700f, 0.02691036f, 0.03497046f, 0.15211454f, 0.16701509f, 
    0.12832214f, 0.03344794f, 0.27119946f, -0.17075101f, 0.13937616f, 0.12054300f, -0.21570615f, 0.14797962f, 
    0.01858010f, 0.08868168f, -0.16082138f, 0.28184652f, -0.02944193f, -0.05885834f, -0.01323930f, -0.18597189f, 
    -0.16724925f, 0.05107798f, -0.15776476f, -0.18921746f, -0.05136698f, -0.08755053f, 0.08331168f, 0.27750313f, 
    0.04793375f, 0.07663524f, -0.00006588f, -0.03081791f, 0.05870971f, -0.01122423f, -0.11149076f, -0.08877980f, 
    -0.02554910f, 0.10683047f, -0.02512713f, 0.01817793f, 0.00344439f, 0.17030075f, -0.10396226f, -0.05975852f, 
    -0.25305039f, -0.07605447f, -0.20930636f, -0.00409806f, 0.10566679f, 0.20082846f, 0.08787716f, 0.13356504f, 
    -0.01074098f, 0.09446343f, -0.05224152f, 0.15175986f, -0.12425416f, -0.15759268f, 0.11104901f, -0.07406512f, 
    -0.09695473f, 0.08330548f, -0.01303470f, -0.24260461f, 0.06207074f, 0.07569779f, 0.18367334f, -0.19847453f, 
    0.26277524f, -0.04494354f, -0.06639746f, 0.04265745f, 0.09568164f, 0.03341159f, 0.08552656f, 0.01295188f, 
    -0.04966167f, 0.00987002f, -0.26850849f, -0.05899094f, 0.03053276f, -0.03776826f, -0.16925240f, 0.05439510f, 
    0.17763031f, -0.10234533f, -0.10038520f, -0.04906138f, -0.10774263f, -0.03074695f, 0.04208943f, -0.19170468f, 
    0.33921021f, 0.00414481f, 0.21222071f, 0.06093232f, 0.10533305f, 0.10122184f, -0.10063291f, 0.05118456f, 
    -0.01822249f, -0.01602191f, -0.00122964f, -0.06497691f, 0.00690123f, 0.20390627f, -0.07132691f, -0.00611527f, 
    0.12886056f, 0.02723464f, 0.16365090f, -0.01084059f, -0.10602195f, -0.19313945f, -0.13415976f, -0.09504691f, 
    0.23950939f, 0.11772481f, -0.13153937f, 0.05000429f, 0.09672309f, -0.13577487f, -0.13247754f, 0.05020221f, 
    0.06630100f, -0.02996395f, 0.01047837f, 0.07276084f, 0.41138765f, 0.05321116f, 0.04984510f, -0.22729953f, 
    -0.15417483f, 0.00752280f, -0.10911620f, -0.06796982f, 0.10241044f, 0.23840399f, 0.09418987f, 0.16364728f, 
    0.03666232f, 0.14531493f, -0.08524132f, 0.33558714f, -0.10211100f, -0.19043218f, 0.08422381f, -0.03849766f, 
    0.02301373f, 0.24811439f, -0.01077554f, 0.18040460f, 0.08109438f, 0.12433702f, -0.03875294f, 0.06575742f, 
    0.00089307f, -0.01596058f, -0.04197395f, 0.03592616f, 0.05479288f, 0.10449617f, -0.14351112f, -0.16354494f, 
    -0.15925972f, -0.05470037f, -0.03524682f, 0.27389058f, 0.03105495f, -0.01616453f, 0.05138757f, -0.00012732f, 
    0.00730585f, 0.04695942f, -0.06453197f, -0.09871653f, 0.40037853f, 0.05455065f, -0.03424256f, -0.01451070f, 
    0.00507652f, -0.11020119f, -0.07595168f, 0.00323810f, -0.07707435f, -0.07563049f, 0.03575534f, -0.07748865f, 
    -0.16481714f, -0.14046793f, -0.01000156f, 0.05623672f, 0.06071712f, 0.05661527f, -0.07238881f, 0.14161822f, 
    -0.03007507f, -0.07313031f, 0.05450668f, 0.33678263f, 0.07032304f, -0.06685741f, -0.09566880f, 0.03382409f, 
    0.09753352f, 0.05442858f, -0.06248017f, -0.06917670f, 0.19115070f, -0.04074247f, -0.09835409f, 0.03918128f, 
    0.21061738f, -0.22596078f, -0.11895527f, 0.11549352f, 0.02056709f, 0.01949804f, 0.13506298f, 0.04048008f, 
    0.05112008f, 0.14355750f, 0.09049485f, 0.16958761f, 0.31362477f, 0.13689208f, -0.05676562f, -0.18046507f, 
    0.09249261f, -0.02114115f, -0.02057782f, -0.01227617f, -0.02439910f, 0.05876036f, 0.00419028f, -0.09332825f, 
    -0.00809941f, 0.36896095f, 0.13979648f, 0.20628197f, -0.03694291f, -0.08363980f, -0.03409466f, 0.02998691f, 
    0.08048627f, 0.17842801f, 0.04992151f, -0.12979564f, -0.48036292f, 0.12405774f, -0.17492782f, 0.12197026f, 
    0.14693604f, 0.17343095f, 0.28260288f, -0.10550164f, 0.02651862f, -0.04733591f, 0.19581994f, -0.00684168f, 
    0.35450596f, 0.03359441f, 0.18874031f, 0.04081964f, -0.03873101f, -0.16501942f, 0.04730565f, 0.08048926f, 
    0.03213610f, 0.12413570f, -0.04031981f, 0.07270520f, 0.04522183f, 0.06157103f, 0.05626754f, 0.14604589f, 
    -0.17871287f, 0.04875305f, 0.16298066f, 0.24445967f, -0.05626435f, 0.16021486f, 0.09431910f, 0.08901470f, 
    0.05313724f, 0.00169732f, -0.05500799f, -0.06148300f, 0.22848734f, 0.01751287f, 0.03069407f, -0.09328721f, 
    -0.11345622f, -0.09592387f, 0.00414665f, 0.08061379f, 0.11226736f, 0.00709957f, -0.27246401f, -0.21582207f, 
    0.06344818f, 0.00921243f, 0.06569611f, 0.12428065f, -0.04330923f, 0.18212564f, -0.01996096f, 0.02249817f, 
    0.07145877f, 0.21963482f, 0.22236423f, 0.27275410f, -0.02494502f, 0.03377422f, 0.01063253f, 0.09295631f, 
    -0.15993503f, 0.02427284f, -0.08785931f, -0.08407209f, -0.32913727f, 0.09394567f, 0.13892104f, 0.13881665f, 
    0.06410024f, -0.01607712f, -0.07451072f, -0.27047923f, -0.19096957f, -0.07492092f, -0.04394479f, 0.07589164f, 
    0.01828269f, -0.01395761f, -0.02272139f, -0.01415493f, -0.03737990f, -0.00215574f, -0.05605825f, -0.01709399f, 
    -0.03516235f, -0.04882819f, -0.03318899f, -0.03424976f, 0.02926076f, -0.02205502f, 0.02528211f, -0.00606287f, 
    -0.02019587f, 0.01710732f, 0.04000587f, 0.04656335f, 0.00064371f, -0.02584941f, 0.02563888f, 0.04064396f, 
    -0.01712488f, 0.03359855f, -0.04496297f, 0.03247028f, -0.03470966f, -0.03313027f, -0.03970453f, 0.02832504f, 
    -0.04568325f, 0.01985569f, -0.04423869f, -0.05526331f, -0.02682511f, 0.03804900f, -0.05027916f, 0.04182776f, 
    0.04052487f, 0.00235850f, -0.03320765f, 0.00424361f, -0.03907842f, 0.03358727f, -0.02446856f, -0.05633096f, 
    0.04056785f, -0.05441113f, -0.05442230f, -0.03690451f, -0.02858299f, 0.03995124f, -0.01118808f, -0.00123244f, 
    0.00472508f, -0.01454903f, -0.05270659f, -0.03457880f, -0.00157344f, -0.04714103f, -0.01636886f, -0.01125854f, 
    -0.01908173f, -0.00069309f, 0.00788940f, 0.02423752f, -0.05687429f, -0.05858880f, -0.02038212f, -0.01987458f, 
    0.03698141f, -0.02400295f, 0.00168565f, -0.04249008f, 0.02093608f, -0.00297122f, -0.01057017f, -0.03145900f, 
    0.03932719f, 0.02956382f, -0.04892329f, -0.01375184f, 0.02985425f, 0.03630284f, -0.01086622f, 0.04785958f, 
    -0.05798777f, 0.00557488f, 0.03194474f, -0.03142280f, 0.03761167f, -0.05101024f, 0.00083142f, -0.03232370f, 
    -0.02086327f, 0.01204109f, 0.01705078f, -0.01880313f, 0.00647436f, -0.00844156f, -0.00192369f, 0.02794039f, 
    -0.02530306f, 0.04363979f, 0.02195758f, 0.03935497f, -0.05037645f, 0.02991724f, -0.04730221f, -0.05148775f, 
    -0.00570089f, 0.04211261f, 0.00906861f, 0.02849355f, -0.04029696f, 0.00787791f, -0.03967033f, -0.00003217f, 
    0.00378415f, -0.03431587f, 0.01938149f, 0.01413901f, 0.03292895f, 0.00299447f, -0.02554998f, 0.04248320f, 
    -0.02542782f, -0.02247516f, 0.02730801f, 0.00110078f, -0.02755922f, 0.03178889f, -0.03389528f, -0.04666614f, 
    -0.00709302f, -0.04874191f, 0.00602646f, -0.02234656f, -0.02729603f, 0.01039934f, -0.03793505f, 0.00472151f, 
    -0.00009088f, 0.04201163f, 0.04075366f, 0.03848478f, -0.03762492f, 0.04298285f, -0.02866466f, -0.04937444f, 
    0.01838325f, -0.05690688f, 0.03264591f, 0.02008460f, 0.02369113f, 0.02758531f, -0.00738071f, 0.04031995f, 
    0.02848087f, 0.00691985f, 0.02581738f, 0.02482875f, -0.00278622f, -0.02712716f, 0.00167273f, 0.01329755f, 
    -0.04382553f, 0.03231406f, -0.04625757f, 0.01080298f, 0.00648731f, -0.05858595f, 0.03371388f, 0.01413284f, 
    -0.05202739f, -0.04956523f, -0.04427556f, -0.04291420f, 0.02604627f, 0.03346984f, 0.00706110f, -0.01262646f, 
    -0.05056539f, -0.00779190f, 0.03390998f, 0.02378529f, 0.02084029f, -0.05320466f, 0.03687577f, -0.04566831f, 
    0.02602000f, -0.00386232f, -0.05172635f, 0.03082542f, -0.03870731f, 0.04287784f, -0.02071938f, 0.02742642f, 
    -0.05206931f, -0.00771687f, -0.04027590f, -0.03451462f, 0.02566296f, -0.01459565f, 0.04160276f, 0.00680745f, 
    -0.02391672f, -0.01718759f, 0.02702162f, 0.00227981f, -0.05201442f, 0.02894365f, -0.03680884f, -0.02933675f, 
    0.00796963f, -0.03244044f, -0.03697669f, -0.03525622f, -0.02012764f, -0.03097844f, 0.03859755f, 0.00053546f, 
    0.02157133f, 0.04049136f, 0.00099222f, -0.04886797f, -0.04274178f, -0.04648042f, 0.02603304f, -0.03648084f, 
    -0.03156560f, -0.01228545f, 0.00555123f, -0.01446273f, -0.03953970f, 0.02083937f, 0.01825491f, -0.03454629f, 
    -0.02872857f, 0.01755772f, 0.03934369f, -0.04947571f, -0.04773596f, -0.05671022f, -0.01712360f, 0.01391549f, 
    -0.00339155f, -0.02005920f, -0.00892698f, 0.00176428f, 0.02566481f, -0.04403477f, 0.01806448f, -0.01301559f, 
    -0.00544982f, 0.01032685f, -0.01441930f, 0.00470634f, 0.01989414f, 0.04198944f, -0.03908862f, -0.05400800f, 
    0.00374618f, -0.02026127f, -0.05442179f, -0.00774023f, -0.04891829f, -0.03224150f, -0.01294806f, -0.01200873f, 
    -0.03959658f, -0.03813072f, 0.03229557f, 0.02264871f, 0.01909540f, -0.05455231f, 0.04240828f, -0.02424917f, 
    -0.02816413f, -0.04677397f, 0.02540941f, -0.00157835f, 0.02416913f, -0.05493975f, 0.03094280f, -0.03430793f, 
    -0.05792041f, 0.02039618f, 0.00790949f, 0.04136150f, 0.03243696f, -0.00489225f, 0.03804049f, 0.01890003f, 
    -0.05740295f, -0.02732548f, -0.05468537f, -0.00602068f, -0.03579525f, -0.04794791f, 0.03398970f, -0.04922901f, 
    -0.01539931f, 0.00493359f, -0.04838664f, 0.03323781f, -0.04604111f, -0.00626441f, -0.01243036f, -0.04307796f, 
    0.04514869f, -0.00574691f, 0.00971545f, -0.04685779f, 0.00858545f, -0.01606394f, 0.00816994f, -0.01200675f, 
    0.02052804f, 0.02833594f, 0.03772160f, 0.03040639f, -0.04919331f, -0.02481745f, -0.00110554f, 0.00616072f, 
    -0.05242093f, 0.03296295f, -0.03992973f, 0.03125881f, 0.01941964f, -0.00504484f, -0.03117314f, -0.03367833f, 
    0.03817407f, -0.01955059f, -0.00063885f, -0.05624842f, 0.03543253f, 0.00009691f, 0.02129947f, -0.02258822f, 
    0.01442832f, -0.02576125f, -0.02674678f, 0.00585614f, -0.00260159f, -0.03443106f, 0.02282004f, 0.00944964f, 
    0.00726356f, -0.04958146f, 0.02832735f, 0.01612855f, 0.00271369f, 0.00479035f, -0.00974129f, 0.01692023f, 
    0.02820092f, 0.00869420f, 0.00889613f, -0.05391796f, -0.05610991f, 0.03106306f, -0.05633975f, 0.01654551f, 
    0.01164495f, -0.02742803f, -0.04269021f, -0.05416281f, -0.05459927f, 0.02533721f, -0.05030442f, 0.01282848f, 
    -0.04416381f, -0.04766766f, 0.01452519f, 0.00698859f, 0.00378443f, -0.00332955f, 0.01255751f, -0.04385713f, 
    -0.00568240f, -0.03122094f, -0.19190641f, -0.11094672f, 0.02757305f, 0.09200902f, 0.01403753f, -0.06756103f, 
    0.06614216f, 0.07248534f, -0.03348824f, -0.06452055f, 0.09339274f, 0.03575424f, -0.04721856f, -0.21614826f, 
    -0.04186161f, 0.02452799f, 0.01181889f, -0.17689361f, -0.02717837f, 0.09520186f, 0.03056625f, -0.05610243f, 
    -0.30624190f, 0.09786721f, -0.15170254f, -0.10267839f, -0.04556748f, -0.01360899f, 0.08612023f, 0.15537414f, 
    0.01884687f, 0.16347753f, 0.06387824f, -0.01102542f, 0.34496364f, -0.08461054f, -0.20278877f, -0.15125833f, 
    0.06453291f, 0.10188278f, 0.04237553f, 0.05281376f, 0.05647928f, 0.08884096f, -0.05843593f, 0.08263817f, 
    0.13601141f, 0.06360040f, -0.02539920f, -0.11234678f, -0.01474128f, -0.08258361f, 0.07770925f, 0.02759868f, 
    0.12189782f, -0.01651693f, 0.05002363f, 0.03605228f, 0.28114617f, -0.12385852f, 0.00261534f, -0.02878604f, 
    -0.02240451f, -0.07262864f, 0.00411703f, -0.18324924f, -0.01668686f, 0.06171686f, -0.11292815f, 0.01100760f, 
    0.27440599f, -0.05586776f, 0.14353976f, 0.08357891f, 0.08275749f, 0.06432359f, -0.01818111f, -0.10458787f, 
    -0.08772334f, 0.04603351f, 0.01063856f, 0.00743702f, -0.17186336f, 0.05226335f, -0.00384574f, -0.09867962f, 
    0.06912776f, 0.00315396f, -0.09793285f, -0.07612254f, -0.01786678f, -0.06731398f, 0.11408023f, 0.05698694f, 
    0.52160287f, -0.21611258f, 0.07503051f, 0.15641937f, -0.05967154f, -0.05625944f, 0.08292421f, -0.11223339f, 
    -0.10396523f, -0.00809551f, -0.02500326f, 0.11432196f, -0.01712006f, 0.27749661f, -0.02635029f, -0.13525367f, 
    0.17974174f, -0.00573918f, 0.00204128f, 0.07950921f, -0.02664007f, 0.05615924f, 0.11815863f, 0.12314501f, 
    -0.28828302f, 0.16341659f, 0.03715735f, 0.00564372f, 0.16073683f, -0.00928203f, 0.01167428f, 0.06671542f, 
    -0.09192039f, 0.07535007f, 0.05672951f, 0.03988716f, -0.24713039f, 0.10757270f, 0.14225383f, -0.06148579f, 
    0.05300967f, 0.01913521f, 0.03441751f, 0.05321372f, -0.01046509f, 0.10644168f, 0.05670111f, 0.05686997f, 
    0.05502391f, 0.01245587f, 0.24515612f, -0.01710640f, -0.06389518f, 0.01084538f, 0.01392702f, 0.09756906f, 
    0.01671788f, 0.11957736f, -0.01214472f, -0.02311811f, -0.15316147f, -0.07107309f, -0.23636353f, 0.06355029f, 
    0.09974380f, 0.07865755f, -0.17823108f, 0.01925099f, 0.00333821f, 0.01547515f, 0.02924405f, 0.12843369f, 
    -0.01291322f, 0.07194427f, -0.06980067f, -0.05751964f, 0.16549253f, 0.10413630f, 0.04451237f, -0.05128755f, 
    -0.00535431f, 0.03012696f, 0.00241269f, 0.09085294f, -0.51389372f, 0.07337110f, 0.08934041f, 0.05533381f, 
    0.04556384f, 0.11238552f, 0.08082274f, -0.02501888f, 0.05304543f, 0.03843214f, -0.02907953f, -0.03236382f, 
    -0.14277707f, -0.09945265f, 0.04390342f, -0.08252326f, 0.09123167f, 0.19125725f, 0.02158711f, -0.00685440f, 
    0.05843012f, 0.00704178f, -0.05687969f, 0.12781122f, 0.19784886f, 0.12673023f, -0.13669881f, -0.05015885f, 
    0.11308590f, 0.05679248f, 0.04728781f, -0.02086752f, -0.09371343f, -0.05679322f, 0.06424874f, 0.03838038f, 
    0.33875540f, 0.05172600f, -0.10476476f, -0.07847920f, -0.04709933f, 0.05629140f, -0.06329576f, -0.03800192f, 
    -0.10817685f, -0.04603132f, 0.04481768f, 0.00820698f, 0.29484338f, -0.24181387f, 0.00258427f, 0.10192429f, 
    -0.13108620f, 0.08422829f, 0.00121289f, 0.02613173f, 0.02378606f, 0.00145427f, 0.02590365f, 0.04488785f, 
    0.38110065f, -0.07748112f, 0.13969271f, -0.04713024f, -0.15929018f, 0.00258225f, -0.05583835f, 0.07536826f, 
    0.12710688f, 0.05345192f, -0.10972869f, 0.05296021f, 0.01358702f, 0.15318777f, -0.05198755f, -0.22357093f, 
    0.06816667f, 0.04778337f, 0.13052176f, 0.03525783f, -0.03401519f, 0.09400325f, -0.08778198f, -0.12561119f, 
    -0.25588328f, 0.16690978f, 0.00598318f, -0.28929624f, 0.02751561f, -0.02957557f, -0.15534782f, -0.03032608f, 
    -0.05869042f, -0.04971536f, -0.08679307f, -0.07162900f, -0.33110821f, 0.13872860f, -0.06413595f, 0.14004330f, 
    0.04858641f, -0.03829240f, 0.04222814f, -0.01734268f, -0.06266797f, -0.00818170f, 0.12413210f, 0.13771157f, 
    0.00983229f, -0.06554654f, 0.12089466f, -0.02480707f, 0.00101103f, -0.06988618f, 0.21100236f, 0.13691390f, 
    0.03073670f, -0.01959314f, -0.11239821f, 0.08617758f, 0.24271926f, -0.14139631f, -0.07207661f, 0.00355941f, 
    0.01757975f, -0.19012123f, 0.11273358f, 0.15608953f, -0.01864278f, 0.05293669f, -0.04412774f, 0.18611777f, 
    0.37759700f, -0.22792600f, 0.08861154f, 0.03820388f, -0.11227335f, 0.01265598f, 0.03453037f, 0.19503979f, 
    0.00074198f, -0.13706610f, 0.03016729f, -0.00780193f, 0.20352109f, -0.09496759f, -0.05698774f, 0.15750378f, 
    0.00670695f, -0.04188558f, -0.00116229f, 0.07054683f, 0.01155500f, -0.05702018f, -0.01810003f, -0.06300288f, 
    0.20763075f, 0.11430731f, -0.01313565f, -0.05600656f, 0.01358961f, -0.05383659f, 0.04610867f, -0.00232786f, 
    -0.01163272f, 0.02740283f, 0.06950510f, 0.05421308f, -0.18814723f, 0.02375793f, 0.24388340f, -0.00781234f, 
    -0.00809430f, 0.10703685f, -0.01134301f, -0.00728628f, 0.01516938f, -0.05415515f, 0.05556022f, -0.01935948f, 
    0.32738841f, -0.28210536f, -0.01817014f, 0.02691519f, -0.06687489f, -0.02536643f, -0.01582486f, 0.03551900f, 
    0.07632322f, 0.04497910f, 0.07183377f, 0.10910074f, 0.11544414f, 0.21124302f, -0.04683693f, -0.12180676f, 
    -0.06170978f, -0.08708837f, 0.13416588f, 0.06405874f, 0.03726038f, -0.08046118f, 0.07238369f, -0.02809071f, 
    -0.00205283f, -0.04496101f, -0.00477716f, 0.01535334f, -0.04627287f, -0.05008669f, -0.00041116f, -0.03806862f, 
    0.01781552f, -0.02288681f, 0.00629081f, -0.01585557f, -0.04274151f, -0.04108215f, 0.01505687f, 0.02564071f, 
    -0.02836875f, 0.03959730f, 0.02305506f, -0.04902483f, -0.03432629f, 0.01707151f, -0.05005591f, 0.04308084f, 
    0.02365267f, -0.00335183f, 0.03325183f, -0.03464738f, -0.01407411f, -0.02211313f, -0.01603885f, -0.00645489f, 
    0.00238086f, -0.03808071f, -0.04481721f, -0.03808865f, -0.04703077f, 0.00772174f, -0.01798974f, -0.02338168f, 
    0.02971200f, 0.01449455f, 0.01618163f, 0.01359032f, 0.02067968f, 0.03394197f, 0.01464387f, -0.01976088f, 
    -0.02746183f, 0.04797957f, -0.03194214f, -0.03669276f, -0.00636948f, -0.05432927f, -0.01910926f, 0.03605427f, 
    0.00560758f, -0.04417054f, -0.04910449f, -0.00871395f, 0.01744130f, 0.01174234f, -0.04808784f, -0.01681201f, 
    -0.03398957f, 0.00821492f, -0.01315465f, -0.00922767f, -0.02991258f, 0.00569360f, -0.04163248f, 0.04056840f, 
    0.02388400f, 0.03746837f, 0.01490827f, -0.04967925f, -0.03866817f, 0.00713590f, -0.02201552f, 0.01932874f, 
    -0.05266638f, -0.05278551f, 0.00713426f, -0.01019045f, -0.03619342f, 0.01431053f, -0.04061253f, 0.03185939f, 
    -0.01456174f, -0.02018735f, -0.02834590f, -0.02389587f, -0.03086134f, 0.03419432f, 0.01934615f, -0.04197481f, 
    -0.05943184f, -0.05386002f, -0.02548252f, 0.04180468f, -0.04308368f, -0.00811325f, -0.04921032f, 0.02768798f, 
    0.03953657f, 0.01788992f, -0.06074994f, 0.00853360f, 0.02453041f, -0.03777868f, -0.02507774f, 0.03164905f, 
    -0.00293849f, -0.04466132f, 0.03189629f, -0.03919881f, -0.01157553f, -0.03074339f, -0.00182064f, 0.04279874f, 
    -0.02810427f, -0.04932079f, -0.01091646f, 0.02642071f, 0.01077772f, -0.02802834f, 0.00863693f, 0.00237620f, 
    -0.00412885f, 0.03193692f, -0.02364677f, -0.01842252f, 0.02747463f, -0.04267297f, 0.02875339f, -0.00562462f, 
    -0.02707249f, 0.03940258f, 0.02072783f, -0.01407278f, -0.02276479f, 0.01705455f, 0.02267535f, -0.05202770f, 
    -0.05512420f, 0.01131770f, -0.04994437f, -0.06224044f, -0.05615754f, 0.02381101f, 0.01323573f, 0.01262295f, 
    -0.00979658f, 0.01646711f, -0.00364013f, 0.02777996f, -0.05031984f, 0.03316587f, 0.00015022f, -0.05950805f, 
    -0.03501856f, 0.02225318f, -0.01161579f, -0.02005010f, 0.02567239f, -0.02267859f, 0.03364157f, -0.05881413f, 
    -0.03306878f, 0.00964665f, -0.01423078f, -0.03445687f, 0.03186993f, 0.02609262f, 0.00425326f, 0.01231173f, 
    0.02410577f, 0.03390752f, 0.00394551f, 0.02125951f, 0.01216866f, 0.04033830f, 0.03443393f, 0.03520844f, 
    0.01808780f, -0.02170770f, -0.01154907f, 0.04514202f, 0.02242104f, 0.00087645f, -0.03661961f, -0.00631555f, 
    -0.02838023f, -0.03190737f, 0.04524472f, 0.02160960f, -0.03341987f, -0.05005118f, -0.04854583f, 0.04133499f, 
    -0.02656142f, -0.05301742f, -0.04269361f, 0.00777421f, 0.00554749f, -0.03234060f, 0.02962368f, -0.05677498f, 
    -0.02110787f, -0.03230496f, 0.03876890f, -0.00722100f, -0.04613707f, -0.04484405f, 0.00990429f, 0.03354646f, 
    0.02188322f, 0.01196896f, -0.03083864f, -0.04171802f, -0.05098304f, 0.00001106f, 0.00359799f, -0.03798650f, 
    0.02306065f, -0.06056536f, 0.03731262f, 0.00773071f, 0.01538166f, -0.00237941f, 0.01174203f, 0.01190943f, 
    -0.01276854f, -0.04219931f, 0.02887085f, 0.01027944f, -0.01180843f, -0.01732050f, -0.02879069f, -0.03660099f, 
    0.02808389f, 0.02353949f, -0.05090164f, -0.02417228f, 0.01339955f, 0.01240565f, 0.02648612f, 0.02449069f, 
    -0.02706226f, 0.00644894f, -0.03382899f, 0.01389881f, -0.05379608f, -0.03583534f, -0.00904332f, -0.02835347f, 
    0.02281600f, -0.01827048f, -0.00224741f, 0.04715190f, -0.03396562f, -0.05260644f, -0.00789936f, -0.00176481f, 
    0.01547119f, 0.00019162f, 0.03801221f, -0.02130309f, 0.00542180f, -0.05977106f, 0.01004421f, -0.04526582f, 
    -0.03640448f, -0.02025576f, -0.04948371f, -0.01575740f, 0.03083755f, -0.00373673f, -0.00412220f, 0.00485851f, 
    -0.05232862f, -0.05596873f, 0.02181231f, -0.01861234f, 0.02816720f, 0.00484537f, -0.00572519f, 0.02688058f, 
    0.02083039f, -0.00937645f, 0.01364869f, -0.04289843f, 0.02023633f, -0.00408386f, -0.00407667f, -0.02501631f, 
    0.00824562f, 0.03378625f, -0.04957437f, 0.01571400f, -0.04360757f, -0.02068715f, -0.00077819f, 0.00251366f, 
    -0.05154087f, -0.05058690f, -0.02272564f, -0.05258609f, 0.02103992f, -0.02871821f, -0.03155981f, 0.02376730f, 
    -0.03018312f, 0.00643947f, 0.00199457f, -0.00844232f, 0.00666926f, 0.00206057f, -0.03012387f, -0.01097955f, 
    0.02713748f, 0.01044831f, -0.03213901f, -0.00470578f, -0.02836491f, -0.02493262f, 0.01038158f, -0.00768814f, 
    0.01414034f, -0.05285743f, -0.04569357f, 0.01643993f, -0.03656098f, 0.03769124f, -0.02192839f, -0.05086837f, 
    -0.00093871f, 0.02619038f, -0.00383077f, -0.03512855f, -0.00051766f, 0.01513933f, -0.02910784f, -0.03524864f, 
    -0.01016694f, -0.02447857f, -0.03233131f, 0.00986429f, 0.02560399f, 0.02472416f, -0.04248852f, -0.04256111f, 
    0.02614184f, -0.00256115f, -0.04351348f, -0.01718292f, 0.01392597f, 0.00490808f, -0.00034574f, 0.02232517f, 
    -0.02725930f, -0.01668596f, 0.02073121f, -0.00385327f, 0.02186276f, 0.02617722f, -0.04751745f, -0.00874748f, 
    0.02130584f, -0.05260856f, -0.04163491f, 0.03343952f, 0.05031011f, -0.00420193f, -0.04776484f, 0.02004804f, 
    -0.03353327f, -0.02747009f, 0.02738824f, -0.00549384f, 0.00713096f, -0.03853952f, -0.04577136f, -0.00517851f, 
    0.25698695f, 0.09092681f, 0.24250503f, 0.10839663f, 0.06053080f, -0.04387100f, -0.01876316f, 0.14012074f, 
    0.02047531f, 0.06431909f, 0.11858897f, 0.14224160f, 0.13179071f, 0.04413959f, 0.09495851f, 0.19254743f, 
    0.07300014f, 0.17931008f, -0.01539811f, 0.07665925f, 0.04562808f, 0.10563856f, -0.01744543f, 0.19093508f, 
    0.26081964f, 0.05688960f, 0.16671777f, 0.03587233f, 0.05945505f, 0.12926726f, 0.07779554f, -0.12033720f, 
    -0.00268688f, -0.00917626f, 0.02673656f, 0.17141834f, -0.01845387f, -0.07194919f, 0.18179889f, 0.17166284f, 
    -0.01601858f, -0.08857281f, 0.10502568f, -0.10518590f, -0.01864957f, -0.05942720f, 0.07142641f, 0.06183558f, 
    -0.18494809f, 0.16402672f, -0.02130429f, 0.34027326f, 0.08449650f, 0.22180815f, 0.04140526f, 0.11553444f, 
    0.01282247f, 0.05837419f, 0.07083029f, -0.03895817f, -0.11253538f, -0.01818347f, -0.06210744f, 0.18829533f, 
    0.00287161f, 0.08184684f, 0.03449233f, 0.15149671f, 0.04596792f, -0.07600749f, 0.01124102f, -0.05360603f, 
    -0.24960695f, 0.28057483f, 0.07648157f, -0.01799321f, -0.02221964f, -0.02523096f, 0.07584928f, 0.10665371f, 
    0.19238193f, 0.08149001f, 0.07684534f, 0.07375281f, 0.17208855f, -0.02939804f, -0.01248151f, 0.12577860f, 
    0.05804587f, -0.04670602f, 0.04393101f, 0.02038863f, 0.03451845f, 0.12602836f, -0.09978770f, 0.06992877f, 
    -0.20514701f, 0.04317806f, -0.05660944f, -0.14106420f, 0.14955269f, 0.11425603f, 0.05491503f, 0.09577301f, 
    0.04260870f, 0.11964153f, 0.10503244f, -0.08024479f, 0.06487256f, -0.24948597f, -0.04787283f, 0.29337621f, 
    -0.09728955f, 0.00656032f, -0.00118200f, -0.04228438f, 0.04519571f, 0.04825902f, -0.03843393f, -0.08680677f, 
    0.38323075f, -0.02978997f, 0.14065124f, 0.17976923f, 0.01992770f, -0.01023085f, 0.07354583f, 0.04584974f, 
    -0.01017050f, -0.06338411f, -0.11724530f, 0.02410498f, 0.21152258f, 0.02759239f, -0.07605972f, -0.18846020f, 
    0.00479601f, 0.07579129f, 0.02616782f, 0.04527623f, -0.05353722f, -0.00775834f, -0.01123805f, -0.06398624f, 
    -0.09500701f, 0.06750987f, -0.13820784f, -0.07707649f, 0.03954394f, 0.09222963f, 0.03744521f, 0.02952207f, 
    -0.00626545f, -0.05689278f, 0.04667787f, 0.07261096f, 0.21843113f, -0.01128917f, 0.28289244f, 0.23386070f, 
    0.14526695f, 0.05589182f, 0.22721204f, -0.06165011f, 0.06610312f, -0.10965832f, -0.02402094f, -0.15730910f, 
    -0.05084042f, -0.00477032f, 0.18903807f, 0.09906771f, -0.04010990f, 0.00461314f, 0.01178524f, 0.04221141f, 
    -0.10532386f, -0.07982090f, 0.06952372f, 0.09178764f, 0.32634062f, 0.01837107f, -0.11602117f, 0.13640916f, 
    -0.03479650f, 0.10857329f, -0.02108695f, 0.05871501f, 0.03312073f, 0.12418125f, 0.15665293f, 0.05072488f, 
    0.36091462f, 0.15723674f, 0.07469491f, 0.24342076f, -0.04740572f, -0.09131095f, 0.08993856f, 0.10248232f, 
    0.07917432f, 0.16446185f, 0.04696529f, 0.08911800f, 0.04180208f, 0.05117268f, 0.23466422f, 0.01995513f, 
    -0.05304594f, 0.02351259f, 0.06584632f, 0.18278119f, 0.20555368f, 0.10374671f, -0.06275813f, -0.03346086f, 
    -0.16823502f, 0.05701911f, 0.16318470f, 0.02317477f, 0.05387023f, 0.07962644f, 0.10503013f, -0.03514603f, 
    0.09487415f, 0.05533697f, -0.05146725f, 0.06736565f, 0.02718967f, 0.02850811f, 0.06605734f, -0.10422628f, 
    0.12020729f, -0.03094677f, 0.11622113f, 0.10040446f, 0.01867479f, 0.05414842f, 0.06552839f, -0.12086760f, 
    -0.33100116f, -0.02245820f, -0.05129323f, -0.06754748f, 0.06406470f, 0.08226638f, 0.02692660f, 0.06323959f, 
    -0.00927274f, -0.05640652f, 0.14857112f, 0.09829035f, -0.00071622f, -0.09232042f, 0.10364424f, 0.11473125f, 
    0.04465808f, -0.06759362f, -0.05244895f, 0.00041273f, -0.01484411f, -0.02473939f, 0.03112082f, 0.13269383f, 
    0.31316942f, 0.01597496f, 0.15645546f, 0.49257866f, -0.07109063f, 0.07556289f, 0.09760126f, 0.22509959f, 
    0.13821764f, 0.16510187f, 0.11041691f, 0.19866870f, 0.04123300f, 0.14958519f, 0.15288453f, -0.28810015f, 
    -0.07855666f, 0.00345081f, -0.01211930f, 0.00389953f, 0.05048778f, 0.01712347f, 0.02867019f, -0.00885071f, 
    0.06034953f, 0.00273129f, -0.01828579f, 0.07599749f, 0.05394467f, 0.10383609f, -0.08600856f, 0.07986061f, 
    0.03218718f, 0.14914735f, 0.11100163f, 0.13975149f, -0.32079118f, 0.25952882f, 0.14293668f, -0.07219717f, 
    0.09658636f, 0.17188971f, 0.02839314f, -0.07268956f, 0.01340203f, 0.07970024f, 0.07062615f, -0.06583096f, 
    -0.22149870f, 0.06074100f, -0.10320221f, -0.07901378f, 0.10960110f, 0.01828979f, 0.13112065f, -0.06886309f, 
    0.08373111f, 0.21625654f, -0.08909987f, 0.03376746f, -0.07108180f, -0.10028910f, -0.04415769f, -0.03427524f, 
    0.02537726f, 0.08122019f, 0.07171817f, 0.09099216f, 0.06624234f, 0.06271207f, 0.12314105f, 0.17626005f, 
    -0.23616260f, 0.01876581f, -0.00240546f, 0.10697874f, 0.01070362f, -0.01749912f, -0.05030799f, 0.07014574f, 
    0.05219559f, 0.03151768f, 0.06493397f, -0.00825638f, 0.03768674f, 0.29355097f, -0.11166328f, -0.18779966f, 
    -0.01356505f, 0.01047338f, 0.05047003f, 0.10722734f, -0.01739437f, 0.07074160f, -0.00105136f, 0.10899428f, 
    -0.16481318f, 0.02736652f, 0.04456903f, -0.08071937f, 0.13100660f, 0.15557891f, 0.09129991f, 0.08251292f, 
    0.00438717f, 0.02376864f, -0.00440421f, 0.10660241f, -0.08044850f, -0.17820328f, 0.00892802f, 0.36649069f, 
    0.16701584f, 0.01944181f, -0.11908006f, -0.03606874f, 0.04526170f, 0.06252693f, -0.04451036f, 0.06650079f, 
    0.10649520f, -0.10901210f, 0.23274453f, -0.00244825f, -0.02510216f, -0.10767411f, 0.04691128f, 0.05512820f, 
    0.10110243f, -0.08357818f, 0.10779476f, -0.07418991f, 0.03703763f, 0.06873633f, -0.01700084f, -0.00391254f, 
    -0.07692856f, 0.09413873f, -0.00140133f, 0.09280234f, -0.04588430f, -0.06419341f, -0.04524970f, 0.05291430f, 
    0.08526948f, -0.04988129f, -0.00812437f, -0.06322473f, 0.03434808f, 0.09976611f, 0.06064354f, -0.01053888f, 
    -0.02469763f, 0.04931439f, -0.06737372f, 0.07540035f, 0.34446710f, 0.07540558f, 0.08171168f, -0.04509723f, 
    0.02696517f, -0.05885101f, -0.04867750f, -0.08635141f, -0.01963818f, -0.09332399f, 0.08791987f, 0.08778702f, 
    -0.27064171f, -0.01422678f, -0.18194194f, 0.10711107f, -0.07244493f, 0.07711326f, -0.02379769f, -0.12520044f, 
    0.03084666f, 0.03495144f, -0.03036058f, -0.00737476f, 0.27246419f, 0.35839388f, -0.06752890f, 0.11783928f, 
    -0.04030430f, -0.03211356f, -0.01598726f, 0.02467963f, 0.01085728f, 0.02752331f, -0.01847526f, 0.08224852f, 
    -0.21504276f, 0.09459158f, -0.13799718f, -0.01868910f, 0.16135123f, 0.19121353f, -0.11727758f, -0.02260010f, 
    0.03318107f, -0.00594117f, -0.11664776f, 0.02867087f, 0.25771454f, 0.03853619f, 0.00202289f, 0.06257425f, 
    0.06664851f, 0.02142289f, -0.08734796f, -0.01406429f, 0.07240319f, -0.02714784f, 0.02159243f, 0.04619256f, 
    -0.04155977f, 0.17082995f, -0.00021346f, -0.12596059f, -0.06433514f, -0.06532119f, 0.00736250f, -0.11420520f, 
    0.01954776f, 0.07586089f, 0.17885856f, -0.12551810f, -0.17790942f, -0.01733821f, 0.11149131f, 0.13285810f, 
    0.04095484f, -0.12320607f, 0.10296127f, -0.05600389f, 0.07948349f, -0.06015909f, -0.11799926f, 0.02273538f, 
    -0.04548241f, 0.17565013f, -0.13031346f, -0.01699262f, 0.03298090f, -0.03031478f, -0.05760045f, -0.10273930f, 
    -0.07201744f, -0.01397195f, 0.15869120f, 0.12218675f, -0.02312109f, -0.01872418f, 0.13160241f, -0.13496406f, 
    0.09439449f, -0.03846763f, 0.08857287f, 0.01447064f, 0.09459631f, -0.07949743f, 0.02007232f, 0.00563002f, 
    -0.21752858f, 0.24195372f, -0.00542791f, 0.21769285f, -0.06010421f, 0.09376889f, 0.01780322f, 0.14623328f, 
    -0.04300414f, -0.01413797f, 0.05079949f, 0.00470247f, 0.03508307f, -0.12934652f, 0.13665047f, 0.09878363f, 
    0.16443302f, 0.02457241f, 0.03596139f, 0.03155621f, 0.11626630f, 0.06224700f, 0.02091125f, 0.11554787f, 
    -0.27557287f, 0.04920552f, 0.01414303f, 0.21506982f, 0.00658604f, -0.13924432f, -0.03795917f, -0.03522526f, 
    -0.04522712f, 0.09445716f, -0.01544616f, 0.00150107f, -0.35782868f, -0.16597566f, 0.07120191f, 0.19835433f, 
    0.06961966f, 0.01693091f, 0.01867850f, -0.11962393f, 0.14673276f, 0.01554850f, -0.02752276f, -0.10887629f, 
    0.18021169f, -0.02231565f, 0.01182010f, 0.42488050f, 0.09456231f, 0.07641292f, 0.01969684f, 0.01055002f, 
    -0.02055812f, -0.07250747f, 0.15084606f, -0.06935941f, -0.21558647f, -0.16491491f, 0.07797429f, 0.17326599f, 
    0.10005797f, -0.01865114f, 0.03836485f, -0.00536482f, -0.05088592f, 0.08590224f, 0.02300625f, 0.15210930f, 
    0.00789774f, 0.01956193f, -0.03109025f, 0.18476349f, 0.01763714f, 0.06581280f, 0.07994041f, -0.01784218f, 
    0.05287435f, 0.07743586f, 0.07692918f, 0.08839264f, -0.22764488f, -0.23892654f, 0.11044166f, -0.33213603f, 
    0.06105259f, 0.00532275f, 0.03883936f, 0.10637939f, 0.02853182f, 0.04423599f, 0.07492255f, 0.13903292f, 
    -0.12537104f, 0.13993566f, -0.03327759f, -0.05950265f, -0.10617764f, -0.14453839f, 0.11049309f, 0.13080673f, 
    -0.02881618f, -0.10076674f, -0.04010417f, -0.15089154f, -0.35984161f, -0.14348555f, 0.24993983f, 0.04069645f, 
    -0.00856555f, 0.04632717f, -0.02419754f, -0.03909732f, -0.09702149f, -0.03608167f, 0.07501470f, 0.09151982f, 
    0.03562502f, 0.02783533f, -0.06709395f, 0.32731685f, 0.11512861f, -0.02655609f, 0.08080288f, 0.04748360f, 
    -0.05835364f, -0.05989165f, 0.11286373f, 0.02102123f, -0.05370577f, -0.03604820f, -0.07465530f, -0.13951705f, 
    0.08997514f, -0.00446475f, -0.05234307f, -0.03751200f, 0.12905709f, 0.01831180f, 0.07260316f, -0.07051088f, 
    -0.09603813f, 0.06211486f, 0.02599204f, 0.22054616f, -0.01777113f, -0.05181266f, -0.07091158f, -0.09940519f, 
    -0.01941560f, 0.02721607f, 0.04495932f, 0.06850504f, 0.29249680f, 0.00337157f, 0.09802525f, -0.22396976f, 
    -0.13134520f, 0.02246144f, -0.05864487f, -0.03311194f, -0.12461778f, 0.02177028f, 0.03092445f, -0.12816668f, 
    -0.36140656f, 0.05796857f, 0.19910946f, -0.16420877f, -0.11555457f, 0.01865776f, -0.00845639f, -0.18631800f, 
    0.02644788f, 0.05102943f, 0.08426453f, -0.04869410f, 0.10008059f, 0.23779571f, 0.06886284f, 0.18065855f, 
    0.11349741f, -0.08549363f, 0.09904321f, -0.00412255f, -0.04506066f, -0.02747057f, 0.03747471f, -0.07887796f, 
    -0.06370395f, -0.13969588f, 0.04943565f, -0.04575450f, 0.08139107f, -0.01829801f, -0.09059359f, 0.05893772f, 
    0.14364785f, 0.09436353f, -0.03442861f, -0.00071609f, -0.13153289f, -0.05507363f, -0.04081260f, -0.00091861f, 
    0.17426343f, -0.02611535f, 0.02769417f, 0.01196961f, 0.03277321f, -0.00051374f, 0.00420298f, 0.07704078f, 
    -0.31144300f, 0.11188554f, 0.22885965f, 0.20746258f, 0.00222123f, 0.04614465f, -0.02212584f, -0.00323561f, 
    0.02276322f, -0.05509134f, 0.03381348f, -0.03379280f, -0.16284478f, 0.02109063f, -0.03348158f, 0.08091050f, 
    0.05274672f, -0.02707439f, 0.04652918f, -0.08636048f, 0.15249382f, 0.00440926f, -0.10634882f, -0.16312848f, 
    0.00974260f, 0.04193217f, 0.02963861f, 0.01928348f, -0.03528682f, -0.03631349f, -0.00417751f, -0.05605389f, 
    0.00267702f, -0.00109660f, -0.04387505f, -0.03264583f, 0.04462945f, -0.01044956f, -0.00837627f, 0.02755335f, 
    -0.02387756f, -0.01523570f, -0.03319628f, 0.02613942f, -0.05919734f, -0.03203535f, 0.02374429f, -0.04707364f, 
    0.02206597f, 0.01954672f, -0.04892209f, -0.00955449f, -0.04814650f, 0.03078551f, 0.01714190f, 0.02616756f, 
    -0.01912786f, 0.00498484f, -0.03988676f, -0.05384301f, 0.01819085f, 0.04405251f, -0.03968590f, -0.04204533f, 
    -0.01012421f, -0.03626593f, -0.03642571f, 0.02357264f, 0.03723443f, 0.01001079f, 0.00837488f, 0.01270706f, 
    0.00077430f, -0.02060573f, 0.02492301f, -0.03388973f, 0.03160852f, -0.00322688f, -0.04090747f, -0.03319408f, 
    0.01011205f, -0.05637333f, 0.01865637f, -0.04831273f, 0.02610462f, -0.00013911f, -0.05679988f, 0.01024573f, 
    -0.03488861f, -0.03458228f, 0.01872265f, 0.01957904f, 0.01878469f, -0.00823499f, 0.01246456f, 0.00361424f, 
    0.00639846f, -0.02049746f, 0.00595452f, 0.00102774f, 0.01665568f, -0.04646178f, -0.00225113f, -0.01639630f, 
    -0.03970046f, 0.01928223f, -0.05023806f, 0.00398839f, 0.03223699f, 0.03901727f, -0.04085132f, 0.01504245f, 
    0.00054478f, -0.00167681f, -0.03258210f, 0.01648840f, -0.04356336f, -0.05003536f, -0.00548258f, -0.00040040f, 
    0.03378705f, -0.02511390f, -0.02653160f, -0.03835794f, -0.05514500f, -0.02689977f, -0.05632085f, -0.00515919f, 
    0.03561076f, -0.01418020f, -0.02796105f, 0.00307993f, 0.02067952f, 0.02553375f, -0.02137029f, -0.00980921f, 
    -0.05049385f, -0.00569062f, -0.00397977f, -0.02849984f, -0.00479212f, -0.02073219f, -0.02107547f, -0.05762242f, 
    0.03911312f, 0.02870908f, -0.03937574f, 0.02704646f, -0.01351913f, 0.02756877f, 0.04071596f, -0.04717653f, 
    -0.04886350f, -0.01180682f, 0.01279647f, 0.02113380f, 0.04338182f, 0.01569621f, 0.00140650f, -0.04601740f, 
    0.00859766f, 0.02691821f, -0.02570184f, 0.03816422f, -0.03153848f, -0.00380459f, -0.01009730f, -0.05366844f, 
    -0.02225834f, 0.00507202f, 0.01682387f, -0.00050057f, 0.03943394f, -0.02300389f, 0.00500690f, 0.03210927f, 
    -0.02001704f, 0.01813191f, -0.01973655f, 0.03897496f, 0.01875037f, -0.01305941f, 0.04087767f, -0.01625194f, 
    0.02464603f, 0.01194669f, -0.05107412f, -0.02788706f, -0.03987782f, 0.01724971f, 0.04018717f, 0.01020806f, 
    0.00290381f, -0.05458900f, 0.01130231f, 0.03427253f, -0.04913586f, -0.05407504f, -0.03066131f, 0.04175826f, 
    0.04211501f, 0.02872809f, 0.03084939f, -0.01241607f, 0.01463075f, -0.05205462f, 0.03111473f, -0.03790314f, 
    0.02549560f, -0.00636836f, -0.02305687f, 0.02043842f, -0.00121191f, 0.03447950f, -0.02218819f, 0.00601946f, 
    -0.01515593f, 0.01746421f, 0.01406736f, -0.01773807f, -0.01014243f, 0.02556165f, -0.03252957f, 0.03164108f, 
    -0.01092366f, 0.00122207f, 0.03458872f, 0.04228152f, -0.01292566f, -0.00307467f, -0.03556910f, -0.02210991f, 
    -0.04127031f, -0.05583902f, 0.03884269f, -0.01334091f, -0.01239740f, 0.01335063f, -0.03540860f, -0.05758615f, 
    -0.05059040f, 0.02409822f, -0.01584973f, 0.02173882f, -0.04118631f, -0.00019058f, 0.03790684f, -0.03966893f, 
    -0.01213636f, 0.04164927f, 0.00322046f, -0.05014683f, 0.00837601f, 0.04309696f, 0.00489722f, -0.01748418f, 
    -0.02628986f, -0.00179768f, 0.01181424f, -0.04226984f, -0.00843426f, 0.01790299f, -0.02406095f, -0.00003305f, 
    -0.02300300f, -0.02512955f, 0.01816307f, -0.01025012f, 0.02662547f, 0.02150713f, 0.04145436f, 0.02268539f, 
    0.02060407f, -0.03895706f, -0.01469478f, 0.03068784f, -0.01150555f, -0.01919237f, -0.04828182f, -0.03400430f, 
    -0.01552298f, 0.03805556f, -0.02557163f, -0.04326800f, 0.03633688f, -0.05396362f, -0.04068876f, -0.05690721f, 
    -0.00138564f, -0.03317171f, 0.04022292f, -0.01131112f, -0.04922692f, -0.01773670f, -0.02051223f, 0.00945399f, 
    -0.03656092f, -0.00465530f, -0.00055687f, 0.01878599f, -0.04491330f, -0.01668798f, 0.00125961f, 0.00898960f, 
    0.00387200f, -0.05202224f, 0.02854015f, -0.00558203f, 0.01103992f, -0.03747411f, 0.00653564f, -0.02899140f, 
    -0.00878384f, -0.02406179f, -0.01117929f, -0.00468167f, 0.01543093f, -0.03008611f, 0.01355182f, -0.00421293f, 
    0.02469524f, -0.00322702f, 0.03977970f, 0.00740305f, 0.00455704f, -0.00456036f, 0.03102603f, -0.04068501f, 
    -0.04646850f, -0.00185993f, 0.00216080f, -0.02501765f, 0.01059267f, -0.02528600f, -0.00690339f, 0.01986301f, 
    -0.01438250f, -0.02987723f, 0.03340745f, -0.04545207f, -0.05078450f, -0.00571165f, -0.01281268f, -0.05248241f, 
    0.00968940f, 0.01142804f, -0.02173016f, -0.00821066f, 0.01361263f, 0.01452138f, -0.02841639f, -0.05729086f, 
    0.00005862f, 0.00606711f, 0.02389940f, -0.02601530f, -0.03340159f, 0.01801513f, -0.04434715f, 0.03958653f, 
    -0.04510884f, -0.04524447f, -0.01794282f, 0.03133677f, -0.03035521f, 0.01330428f, -0.02752535f, -0.04867646f, 
    -0.01098821f, -0.03075223f, 0.00477465f, 0.00852511f, -0.03487912f, -0.01300866f, 0.01266134f, 0.00097396f, 
    -0.04390168f, -0.01764657f, -0.05022141f, 0.01809154f, 0.00164838f, 0.03295824f, 0.04246885f, -0.05281897f, 
    0.04362296f, -0.02662564f, -0.00796229f, -0.02345528f, 0.02442792f, -0.02419220f, 0.03843535f, -0.04715287f, 
    -0.00384673f, 0.00590482f, 0.03854882f, 0.03537625f, -0.01762674f, 0.01557195f, 0.00154948f, -0.04177272f, 
    -0.01820771f, -0.01061051f, -0.02712513f, -0.03618649f, -0.03614867f, -0.05221705f, -0.05922162f, -0.02738316f, 
    0.25942501f, -0.06289758f, -0.05173777f, 0.09007668f, 0.04013338f, 0.02858338f, 0.02971579f, 0.13393438f, 
    0.16211271f, -0.12696305f, 0.20981960f, -0.08189592f, 0.00300791f, 0.05878447f, -0.08588021f, 0.21364163f, 
    0.02759548f, 0.07984477f, -0.03369700f, 0.04945970f, 0.02287960f, -0.01581693f, -0.06646843f, 0.05314092f, 
    0.08338207f, 0.10769009f, 0.00333751f, 0.16653785f, -0.05481401f, 0.03354354f, 0.00763897f, -0.06067640f, 
    0.01239557f, 0.08780014f, -0.00117841f, -0.11818005f, 0.34337792f, -0.02705070f, -0.00136947f, 0.13831075f, 
    0.02471461f, -0.00821071f, 0.00357357f, -0.00148282f, -0.10808723f, -0.00363519f, 0.06717613f, 0.00254587f, 
    -0.22766408f, 0.02860269f, 0.01907874f, -0.08029006f, -0.06064184f, 0.03666486f, 0.04172560f, -0.02596858f, 
    0.06104599f, -0.04222018f, -0.00868482f, -0.04327320f, 0.36207637f, 0.09169597f, 0.04649768f, -0.06023541f, 
    0.06364711f, -0.04832432f, 0.01044584f, -0.06840041f, 0.03290998f, 0.02133772f, 0.08865659f, 0.18391651f, 
    -0.21084176f, -0.17268762f, 0.16607390f, -0.03293444f, 0.13679789f, 0.19650918f, -0.05707327f, 0.02447709f, 
    -0.01759418f, -0.01799943f, -0.08731890f, 0.05279569f, 0.31427416f, 0.01335954f, 0.16584063f, 0.04604213f, 
    0.05777343f, -0.00217510f, -0.03697020f, -0.13279793f, 0.00629868f, 0.02505301f, 0.03107895f, 0.07183204f, 
    0.18181299f, 0.08919607f, -0.03799713f, -0.05558744f, 0.10428588f, -0.01975801f, 0.04028027f, -0.10701577f, 
    0.06861345f, 0.03663755f, 0.08021144f, -0.10866608f, -0.30624390f, 0.05601570f, 0.39550364f, 0.21182734f, 
    0.08638348f, -0.10679816f, 0.10670411f, -0.02469180f, -0.00977133f, -0.12655547f, -0.12690859f, 0.09813979f, 
    -0.25334370f, 0.14082019f, -0.02006389f, -0.09143416f, -0.02444609f, 0.03848467f, -0.06258000f, -0.06345239f, 
    -0.05191813f, -0.06326552f, 0.06290381f, 0.04333791f, -0.10239725f, 0.23100202f, -0.01072051f, -0.21008350f, 
    0.12087288f, -0.11876950f, 0.09595336f, 0.03503239f, -0.02034155f, 0.01235853f, 0.09687244f, 0.05742516f, 
    -0.27477697f, 0.07356083f, 0.04764979f, -0.00092564f, 0.05282780f, 0.04074970f, 0.11322041f, 0.14682010f, 
    0.10689915f, -0.02295697f, -0.01817723f, 0.06456742f, 0.16236502f, -0.27834994f, -0.08697023f, 0.03198252f, 
    -0.01459532f, 0.06304462f, 0.06963009f, 0.00639915f, 0.02108843f, 0.06346807f, -0.04217564f, 0.03319060f, 
    0.04769654f, -0.29086930f, -0.01859432f, -0.09122532f, 0.02926550f, -0.03186546f, 0.01502068f, -0.04142137f, 
    0.02947899f, 0.00727772f, 0.10170271f, -0.05122836f, -0.24211198f, -0.13413040f, 0.25979862f, 0.04368551f, 
    0.03686891f, 0.00066159f, -0.06235392f, -0.09380660f, -0.02299272f, -0.11489806f, -0.05698542f, -0.03103973f, 
    0.14589480f, 0.00713467f, -0.01715966f, 0.37024441f, 0.04345262f, 0.21256018f, 0.01962370f, 0.07935721f, 
    0.04678391f, 0.01136805f, 0.13246766f, 0.01523561f, 0.01438470f, -0.16980997f, -0.02944931f, 0.07489853f, 
    0.05079455f, -0.03870580f, 0.01814975f, 0.06493125f, -0.06791343f, 0.09255910f, 0.09840450f, 0.16310163f, 
    0.22974084f, 0.10101208f, 0.09850932f, 0.02548146f, -0.01945049f, -0.07834298f, 0.11185158f, 0.04409052f, 
    0.09208808f, 0.16382381f, 0.12060659f, 0.12867787f, -0.06959268f, -0.06215821f, -0.04569586f, -0.02569543f, 
    0.04274223f, 0.03234075f, 0.06042815f, 0.22156054f, 0.06889021f, 0.04128859f, 0.10030314f, 0.13273244f, 
    -0.21494842f, 0.34328482f, 0.02118119f, -0.09670565f, -0.00601257f, -0.00481111f, 0.01321013f, 0.10747907f, 
    0.03933526f, 0.00067220f, 0.04762947f, -0.14308721f, -0.26042977f, 0.08095384f, 0.08170008f, -0.18745984f, 
    -0.05593881f, 0.04529831f, -0.02750462f, 0.05324234f, -0.17830522f, 0.02203379f, -0.02671341f, 0.03567800f, 
    -0.09534006f, -0.04996122f, 0.16185440f, 0.14395888f, 0.19296490f, 0.06228404f, -0.01258674f, 0.09195568f, 
    -0.07533725f, -0.06728169f, 0.11291729f, -0.01131698f, -0.29237351f, -0.09533364f, -0.05704430f, -0.19504321f, 
    0.01052646f, -0.04156269f, -0.03738774f, -0.02466567f, 0.08272754f, -0.00497993f, 0.02718316f, -0.03859822f, 
    0.18950775f, 0.13840853f, -0.12418273f, 0.21265891f, 0.18503535f, 0.13578066f, 0.02026507f, 0.02898219f, 
    -0.08086710f, 0.03324709f, -0.05665611f, 0.03803424f, 0.00941531f, 0.04972937f, 0.08186131f, -0.17087328f, 
    0.05986157f, 0.03139026f, 0.01087967f, -0.02774439f, -0.02250127f, -0.01211864f, 0.07306562f, 0.00315926f, 
    -0.08759274f, 0.24685273f, 0.01157729f, 0.03254183f, 0.09085046f, 0.00934102f, -0.04565351f, -0.13125671f, 
    0.07719949f, 0.09450171f, -0.08151128f, -0.09873655f, 0.36421281f, 0.05059793f, -0.00523765f, 0.15542258f, 
    0.12663719f, 0.01793980f, -0.05840521f, 0.07491019f, -0.03797723f, -0.00185319f, 0.07123396f, -0.08423515f, 
    -0.05301136f, -0.14395452f, -0.00017506f, -0.02211252f, 0.12747397f, 0.01045675f, -0.01512042f, 0.00988630f, 
    0.08484797f, 0.19799255f, -0.07288229f, 0.05619490f, -0.38078749f, 0.33794361f, -0.15232095f, -0.05607024f, 
    0.26876980f, 0.07076734f, 0.08194260f, -0.01485509f, -0.06978768f, 0.00142402f, 0.00591244f, 0.05143358f, 
    0.04063367f, -0.17008176f, 0.09111640f, 0.09786061f, 0.09259648f, 0.08594461f, -0.05940936f, 0.05969711f, 
    0.02295116f, 0.08940160f, 0.05507890f, 0.07085819f, -0.40246221f, 0.06055199f, 0.13924919f, 0.07508896f, 
    0.06452896f, 0.00414807f, 0.05941732f, 0.04740568f, 0.13643594f, -0.05988035f, 0.06693673f, -0.05794261f, 
    0.03690745f, -0.04636574f, -0.02654949f, -0.01248690f, -0.05117231f, -0.02992918f, -0.03893964f, 0.03758986f, 
    -0.01475126f, -0.05651512f, -0.03504520f, -0.00178611f, -0.04683916f, -0.03126973f, 0.02147799f, 0.00201563f, 
    0.03466348f, -0.03437058f, 0.01184991f, -0.01559746f, 0.00828513f, 0.01857467f, -0.02156359f, 0.00560007f, 
    -0.02598177f, -0.00701451f, 0.02431122f, -0.04422691f, -0.00853914f, 0.02198311f, -0.04710988f, 0.01251044f, 
    -0.05537479f, 0.03161564f, -0.01892566f, 0.04341698f, -0.04380128f, -0.00020834f, -0.04204218f, 0.00394276f, 
    0.01113707f, -0.00360146f, 0.01137063f, -0.04038247f, -0.02617224f, 0.00999988f, 0.03084589f, 0.00857660f, 
    0.00091621f, 0.04002172f, -0.04672457f, -0.00788872f, -0.00873239f, 0.03902056f, 0.04356727f, 0.03982089f, 
    -0.00072340f, -0.03360813f, 0.02887037f, -0.05393673f, -0.02777421f, 0.02186932f, -0.00723624f, -0.04367657f, 
    -0.00286429f, 0.00908383f, -0.02138204f, 0.03810708f, -0.03197595f, -0.05389523f, 0.03398371f, -0.02629210f, 
    -0.03467856f, -0.03552678f, 0.00609031f, 0.00566063f, 0.01818486f, -0.04440004f, -0.05275051f, -0.05071471f, 
    0.02011340f, -0.02482363f, -0.01207187f, -0.00720285f, -0.01044708f, -0.01993879f, -0.01618920f, -0.05383444f, 
    -0.03869377f, -0.01427311f, 0.02090770f, -0.02208047f, -0.03100767f, 0.02396516f, 0.01506497f, -0.02182344f, 
    0.03640581f, 0.02560823f, 0.02505601f, 0.00507779f, 0.03060042f, 0.00801365f, -0.00802510f, -0.04640035f, 
    -0.02021553f, 0.03804330f, -0.00272836f, -0.05293132f, -0.05416350f, 0.03518093f, -0.00509585f, -0.04729602f, 
    0.00537698f, 0.01972331f, 0.04429559f, -0.04217418f, 0.00375131f, 0.01760118f, 0.04119328f, -0.00329334f, 
    -0.00038570f, -0.01227536f, 0.03227218f, -0.01962476f, 0.00533232f, -0.02409021f, -0.02788088f, 0.03504279f, 
    -0.03053220f, 0.02748628f, -0.00130510f, -0.03802843f, -0.01193498f, 0.01990693f, -0.05992030f, -0.05852768f, 
    -0.04775376f, 0.01539162f, 0.03996570f, 0.01959979f, -0.05204820f, -0.01089183f, 0.02488380f, -0.02085343f, 
    0.00004105f, -0.03064247f, -0.03516544f, -0.03338148f, -0.00133899f, -0.03823970f, -0.04593625f, 0.01688603f, 
    0.00436941f, 0.02891741f, 0.00418113f, -0.03936428f, 0.00052546f, -0.04209099f, 0.02413014f, -0.03653717f, 
    0.00746849f, -0.04170093f, -0.05738049f, -0.02911274f, 0.02681812f, -0.01869632f, -0.04587384f, 0.00999486f, 
    0.00883815f, -0.02425565f, 0.04170568f, -0.04986873f, -0.02856712f, -0.04831317f, -0.00021655f, 0.01602752f, 
    0.00259341f, -0.00459954f, 0.03196786f, -0.00261049f, 0.01985467f, -0.00135080f, 0.03133336f, -0.03287486f, 
    0.03849091f, 0.02597004f, 0.02507831f, 0.02077188f, -0.02799538f, -0.00194939f, -0.01670252f, -0.04955684f, 
    0.01139974f, 0.01674209f, 0.01878382f, -0.01788854f, -0.02793613f, -0.02685259f, 0.01970872f, -0.02450456f, 
    -0.00531411f, 0.00872381f, -0.05605764f, -0.00521008f, -0.02872243f, 0.03092517f, 0.01761918f, -0.05343198f, 
    -0.05800733f, -0.03429479f, 0.03537348f, -0.02614937f, 0.03418701f, -0.05874775f, 0.04848348f, 0.04157859f, 
    -0.04431928f, -0.00333550f, 0.04063294f, -0.04455360f, -0.01674701f, 0.01932199f, 0.01689119f, 0.03666668f, 
    -0.03123993f, -0.05827364f, 0.00542617f, 0.00374430f, 0.00461173f, -0.01864010f, 0.02548909f, -0.03638296f, 
    0.01388251f, 0.01527588f, -0.03198385f, 0.03191799f, 0.02810250f, -0.00971794f, -0.03626846f, -0.02491103f, 
    -0.04282454f, -0.03277536f, 0.00508859f, -0.01220070f, -0.01523030f, 0.03000607f, 0.04185945f, 0.03766929f, 
    0.02774616f, 0.02332371f, -0.04153926f, 0.00560543f, 0.04359266f, 0.00895630f, 0.00904723f, -0.02549677f, 
    -0.04809665f, 0.04578737f, 0.02409359f, 0.01478061f, -0.06107030f, 0.01943108f, 0.03349656f, -0.00947206f, 
    0.02951863f, -0.02415993f, 0.03676512f, -0.02758623f, 0.02428027f, 0.02431597f, -0.03110694f, -0.04534650f, 
    -0.04372323f, -0.03201254f, -0.00188679f, 0.03456206f, -0.05212955f, -0.01074182f, -0.05661233f, -0.06111781f, 
    -0.01449840f, 0.01669580f, -0.04528519f, -0.05282420f, -0.04638048f, 0.03869931f, -0.05385565f, -0.04208632f, 
    -0.00485491f, 0.01960108f, -0.04709596f, -0.04227144f, 0.03435403f, 0.02468175f, -0.04619537f, -0.01581459f, 
    -0.01230124f, -0.03827229f, -0.02709965f, 0.03288756f, 0.00809368f, 0.04306817f, 0.00783182f, -0.02699203f, 
    0.00670085f, -0.00122041f, 0.02334871f, -0.05315457f, -0.02397779f, -0.02936156f, 0.02725428f, 0.01589559f, 
    -0.03234455f, -0.04341695f, -0.00966368f, 0.02427319f, -0.03074144f, 0.00101817f, -0.03998230f, -0.04689566f, 
    0.01187066f, -0.05694494f, -0.01079348f, 0.03777290f, -0.02682606f, -0.02210277f, -0.03370087f, 0.03111832f, 
    -0.00373539f, 0.01489092f, -0.04250289f, 0.04312804f, 0.00141319f, -0.03971333f, -0.00828450f, 0.00994531f, 
    0.03692988f, -0.00380026f, 0.00817128f, -0.04024343f, -0.05257015f, -0.04070790f, -0.05317738f, -0.04755618f, 
    0.01591088f, -0.05733219f, -0.01650732f, -0.00948735f, -0.04908116f, 0.02414241f, 0.01859745f, 0.01006521f, 
    -0.04379624f, -0.01831729f, -0.00159327f, -0.01578380f, -0.01397722f, -0.04226285f, 0.00189137f, 0.01980436f, 
    -0.04604535f, -0.02680107f, 0.00440679f, 0.01675102f, -0.04054010f, 0.03007783f, -0.03540722f, 0.02020246f, 
    0.01694771f, 0.01339318f, -0.03352651f, -0.03599964f, 0.04473125f, 0.02494555f, 0.01665433f, -0.00847518f, 
    -0.01427283f, -0.04094040f, 0.03816145f, 0.02735590f, 0.04279644f, -0.00070379f, 0.00641681f, 0.00444086f, 
    0.03527747f, -0.04064727f, 0.03984828f, 0.03966886f, -0.02469532f, 0.03240877f, 0.02379326f, -0.01489374f, 
    -0.03822098f, 0.03840029f, 0.00888502f, -0.04886109f, -0.01508761f, 0.03857846f, 0.00023961f, 0.04555237f, 
    0.05070477f, 0.02448805f, 0.00189533f, -0.02424592f, -0.03311898f, 0.01443067f, -0.03917759f, 0.03804087f, 
    -0.03004811f, 0.03143529f, -0.01193622f, 0.02144559f, -0.01040930f, 0.02137120f, -0.03873773f, 0.00614726f, 
    -0.05403039f, -0.03549838f, 0.05243771f, 0.01269610f, -0.00252216f, -0.02233156f, -0.03217674f, 0.02461963f, 
    0.03149528f, -0.01982946f, -0.02406857f, -0.00500143f, 0.02248712f, -0.06298216f, -0.00454659f, -0.04020709f, 
    -0.06517348f, -0.00596665f, -0.00737439f, -0.02826439f, -0.00351791f, -0.00936871f, 0.03335175f, 0.02903413f, 
    -0.03447421f, -0.05991218f, -0.02015250f, -0.02561479f, 0.00154368f, -0.02736043f, -0.01468887f, -0.06495482f, 
    0.04215194f, -0.03101387f, -0.00147905f, 0.03130131f, -0.03529545f, 0.01865871f, -0.00211010f, -0.05688424f, 
    -0.06076206f, -0.06846490f, -0.01450937f, 0.01669415f, 0.03308924f, -0.01660659f, 0.00636515f, -0.01843548f, 
    -0.00310549f, -0.02466075f, -0.00837477f, -0.03816744f, 0.03597129f, -0.03446460f, 0.02661237f, 0.02588865f, 
    0.02020749f, -0.04687764f, -0.02679221f, -0.04634278f, -0.03054063f, -0.00261209f, -0.05168891f, 0.00813340f, 
    0.01124004f, -0.02367367f, -0.04174417f, 0.02196120f, 0.00379410f, 0.01130854f, -0.04607888f, -0.04679217f, 
    -0.03011446f, 0.03715700f, -0.04363340f, 0.02350943f, -0.06657586f, -0.00408842f, 0.03509704f, -0.00681431f, 
    0.02513051f, -0.00990858f, 0.01475921f, 0.03019643f, 0.03342958f, -0.01018520f, -0.03558570f, -0.03798431f, 
    0.04723912f, 0.02924904f, 0.02969102f, 0.00659728f, -0.00626227f, 0.02026081f, -0.01606057f, 0.04386183f, 
    0.02265244f, -0.00053655f, 0.00286375f, -0.03587370f, -0.04469597f, 0.04265366f, -0.00159312f, -0.02162657f, 
    -0.04563016f, 0.01480461f, -0.01580369f, 0.00128965f, 0.02405643f, -0.05541659f, 0.00425309f, -0.00348682f, 
    0.01733701f, -0.01278850f, -0.04090850f, -0.01157771f, 0.00897722f, -0.00997100f, -0.02112661f, -0.03198883f, 
    0.02737365f, -0.04175539f, -0.03854713f, -0.02159131f, 0.02006057f, -0.00457037f, 0.01884379f, -0.06150370f, 
    -0.04635632f, 0.02476926f, 0.03169665f, -0.05062619f, 0.01573432f, -0.05702065f, -0.05255174f, -0.00151072f, 
    0.02361883f, -0.01172066f, -0.01512145f, -0.07499363f, -0.02851176f, -0.04130434f, -0.00468312f, 0.03492846f, 
    -0.03080956f, 0.04262033f, 0.00907377f, -0.02425796f, 0.00381850f, 0.03867697f, -0.01975624f, 0.01050990f, 
    -0.07360511f, -0.04785436f, -0.03675639f, -0.05619739f, -0.03204598f, 0.01022921f, -0.00078847f, -0.05281938f, 
    -0.04670978f, -0.03932866f, 0.02796741f, -0.01464138f, -0.05424204f, 0.01167468f, 0.00107321f, 0.01143721f, 
    -0.03213416f, -0.02716654f, -0.04038483f, -0.04359958f, -0.02329047f, 0.02053746f, -0.03369757f, -0.00684888f, 
    -0.07031005f, -0.00153935f, -0.06691110f, 0.01595079f, 0.01069046f, -0.00583601f, 0.03803882f, 0.04236627f, 
    0.01141963f, -0.01121919f, 0.01930001f, 0.01507583f, -0.04006973f, -0.05896113f, 0.01727771f, 0.00127038f, 
    -0.01066634f, 0.00138202f, -0.02067044f, -0.00398547f, -0.06655091f, -0.03623091f, 0.01230380f, -0.02553699f, 
    0.02526111f, 0.02410979f, 0.02592362f, -0.02429753f, -0.00289818f, -0.01232527f, -0.05226810f, 0.01804168f, 
    0.02228381f, -0.04048818f, 0.01411065f, -0.01628033f, 0.03287881f, 0.01588493f, -0.04748498f, 0.02339670f, 
    0.00948811f, 0.01376899f, 0.02075683f, -0.01797718f, 0.00855668f, 0.05343835f, -0.03538022f, 0.02048312f, 
    0.01451649f, 0.01633681f, -0.06073648f, -0.02644988f, 0.00272674f, -0.02682843f, -0.00919609f, -0.01166154f, 
    -0.05472331f, -0.01307455f, 0.03904312f, 0.01579051f, -0.00652650f, -0.02819172f, -0.04527904f, 0.01515722f, 
    0.02913482f, -0.00844506f, -0.01506139f, -0.01073638f, -0.02404531f, 0.04879969f, -0.00657705f, -0.05265328f, 
    0.00598531f, 0.01900308f, -0.06021971f, 0.02180844f, 0.01792530f, -0.04125147f, -0.04517309f, -0.03361579f, 
    0.00102978f, -0.00490430f, -0.04589275f, 0.03063105f, -0.01186417f, -0.02627338f, -0.01753260f, -0.06278071f, 
    0.03276181f, -0.04571635f, 0.02628009f, 0.00210307f, -0.01953243f, 0.02548557f, 0.00434799f, -0.07247127f, 
    0.01328963f, -0.03638522f, -0.06562481f, -0.00296202f, -0.02698084f, 0.01016872f, -0.01443125f, -0.03169703f, 
    -0.05233259f, -0.06486106f, -0.00046366f, -0.04350900f, 0.03928431f, -0.00595938f, 0.01474460f, -0.00956022f, 
    -0.06092171f, -0.00789105f, -0.03236233f, 0.00913777f, -0.01378772f, 0.01298915f, -0.06266593f, -0.00033780f, 
    0.04119511f, 0.03165192f, -0.01972881f, -0.01032994f, 0.00861281f, -0.04335998f, -0.00203117f, -0.04252220f, 
    0.01178550f, 0.03062519f, 0.00709934f, -0.05056839f, 0.00201126f, -0.04273785f, -0.03914851f, -0.03690354f, 
    -0.04453617f, -0.00029502f, -0.05574149f, -0.04690191f, -0.02721387f, -0.02956184f, -0.03812423f, -0.04416911f, 
    0.03063376f, -0.04627476f, -0.06270399f, -0.04869075f, 0.00065723f, -0.00598598f, -0.02012140f, -0.01492171f, 
    -0.06113911f, 0.00692591f, -0.05815902f, -0.03024208f, 0.04171879f, 0.03410155f, -0.04171901f, -0.01859797f, 
    -0.02685817f, -0.01146435f, 0.02736088f, 0.03282730f, 0.02238802f, -0.02117808f, -0.02454958f, 0.04407309f, 
    0.04854967f, 0.01946564f, -0.06025707f, 0.00731590f, 0.00044038f, 0.02756406f, -0.03933394f, -0.04244765f, 
    0.01539378f, -0.05379754f, 0.01529172f, -0.03952412f, -0.04240811f, -0.02655202f, -0.01492891f, 0.01314257f, 
    -0.02035446f, 0.02755059f, 0.00974367f, -0.04355717f, -0.01424607f, -0.01263660f, -0.02708612f, -0.02652728f, 
    0.03223015f, -0.05540112f, 0.01189490f, 0.01094043f, -0.05225444f, -0.01598274f, 0.02027365f, -0.03188294f, 
    0.02016861f, 0.03265207f, -0.01613743f, -0.01037356f, -0.01529839f, -0.05571299f, 0.03195144f, -0.04219214f, 
    0.04070941f, -0.04128781f, 0.03453876f, -0.04556893f, 0.03971403f, -0.01288972f, 0.04154868f, -0.04913871f, 
    0.03054451f, -0.00117589f, 0.02761113f, -0.05227761f, -0.04427941f, -0.04384775f, -0.02130865f, -0.04280710f, 
    -0.02810977f, -0.04698209f, -0.01243205f, 0.00650204f, -0.02224904f, 0.01633737f, -0.00889248f, 0.00844895f, 
    0.00751718f, 0.00630667f, 0.03862646f, -0.03112813f, -0.00567373f, -0.00923440f, -0.02383912f, 0.00193495f, 
    -0.04970009f, -0.00653259f, 0.01627162f, -0.04420643f, -0.05292413f, -0.00911988f, 0.02325717f, -0.00134226f, 
    0.03016925f, 0.01335004f, -0.05525180f, 0.03445892f, -0.03326806f, -0.00124622f, -0.02891554f, -0.02806727f, 
    -0.05088639f, -0.03235863f, -0.01800324f, -0.02743553f, -0.04627642f, 0.03980576f, -0.03378686f, -0.02460521f, 
    -0.04392637f, 0.04056415f, 0.01260287f, 0.03931634f, -0.02478212f, 0.01745431f, 0.01983769f, -0.05284974f, 
    0.03544128f, 0.03656385f, 0.03079557f, -0.03343586f, 0.01275346f, -0.02290679f, 0.03451757f, -0.03054872f, 
    -0.04226579f, 0.03444105f, -0.02699200f, -0.03839137f, 0.01756226f, 0.03449060f, -0.04744689f, -0.05532085f, 
    0.00490844f, -0.01648232f, -0.02081700f, 0.00414894f, 0.02284648f, -0.00137488f, -0.03487634f, -0.03695028f, 
    -0.03025698f, -0.05280663f, 0.01798895f, -0.00336342f, 0.00839250f, 0.01589929f, -0.03992409f, -0.04327107f, 
    -0.01398063f, 0.04497576f, 0.01098376f, 0.01556187f, 0.02178599f, -0.03593870f, -0.01073128f, -0.05446139f, 
    -0.05312645f, -0.03647621f, -0.01478597f, 0.04307161f, -0.02882959f, -0.00470513f, -0.02035926f, -0.01949119f, 
    0.03535483f, -0.02652497f, -0.05314352f, -0.02772400f, -0.02267018f, 0.00342133f, 0.03068502f, -0.04873209f, 
    0.02100201f, -0.00675303f, 0.00546324f, -0.00609142f, 0.02014959f, 0.02390126f, 0.01722698f, 0.02405278f, 
    -0.05541570f, -0.03431141f, -0.03611193f, 0.00951765f, -0.04775876f, 0.00800821f, -0.04891927f, 0.01693288f, 
    -0.04509438f, 0.02417266f, -0.01184448f, 0.01770380f, -0.02482477f, 0.03219992f, -0.04702778f, -0.02751459f, 
    -0.04442792f, 0.02714779f, -0.01227255f, -0.02448341f, 0.00198720f, 0.01867668f, 0.00445837f, -0.03894451f, 
    -0.05605253f, -0.02254315f, 0.03590987f, 0.03973147f, 0.01075456f, 0.04488140f, -0.04966215f, -0.03458752f, 
    -0.04099816f, 0.01209475f, -0.02647161f, -0.02439437f, -0.00870986f, 0.02785632f, -0.02995745f, 0.00986714f, 
    -0.00743742f, 0.04462230f, -0.04449562f, 0.01184344f, 0.03145881f, 0.04096581f, -0.03702292f, -0.05652361f, 
    -0.03622074f, 0.02255316f, 0.02403893f, 0.01160590f, 0.03717830f, 0.04441278f, 0.02009912f, 0.01904722f, 
    0.00081364f, -0.05097972f, -0.00101807f, -0.04756931f, -0.05447265f, -0.01145067f, -0.01007941f, 0.04489155f, 
    0.00916631f, 0.03646023f, 0.00747414f, -0.02205501f, -0.03437474f, 0.01918171f, -0.05054355f, -0.00235231f, 
    -0.04221357f, -0.05364000f, -0.05470870f, -0.01750667f, -0.03104303f, 0.00647567f, 0.04033868f, 0.00715486f, 
    0.02272114f, -0.03880459f, -0.00223322f, 0.00334622f, 0.04416719f, -0.03883632f, 0.01455467f, 0.01585245f, 
    0.03513109f, 0.00765894f, 0.00722692f, 0.02044848f, -0.04182377f, 0.03469488f, 0.02575452f, -0.04238567f, 
    -0.00606615f, -0.00586281f, -0.05171157f, -0.01642120f, -0.03624674f, 0.00605298f, -0.00395852f, 0.04144160f, 
    0.02383211f, 0.03616195f, -0.04513548f, -0.05307567f, 0.00264535f, -0.01307406f, -0.01453421f, 0.01459411f, 
    0.01350415f, -0.02274544f, -0.03475272f, -0.02137203f, 0.03137291f, 0.02043405f, -0.01546119f, -0.02957475f, 
    0.03087513f, -0.02301525f, -0.00461189f, 0.00239452f, -0.00999719f, 0.03100613f, 0.04041413f, -0.02588227f, 
    0.01093668f, -0.04278667f, 0.03277836f, 0.02756096f, -0.02976175f, -0.01737295f, 0.03534399f, 0.00874117f, 
    -0.02949817f, -0.04985471f, -0.01670605f, 0.01686790f, -0.01999048f, 0.03389397f, 0.04325213f, -0.02748968f, 
    0.02999459f, 0.02370249f, -0.00350011f, 0.02641798f, -0.04669683f, 0.04191339f, -0.00590341f, -0.05437322f, 
    -0.01730303f, 0.04204748f, -0.00089561f, -0.04384581f, -0.02541459f, -0.04749484f, -0.04009270f, 0.01482986f, 
    -0.04249297f, -0.02911961f, -0.01516273f, -0.04229137f, 0.02245326f, 0.01972993f, -0.03263440f, -0.02463567f, 
    -0.03037433f, -0.00382171f, -0.04457296f, -0.02334936f, -0.01874875f, -0.04261922f, 0.03886260f, -0.00695528f, 
    -0.02244326f, 0.00763078f, -0.00572544f, -0.03708305f, -0.03388781f, 0.01166336f, 0.01229844f, 0.00394099f, 
    0.00215279f, -0.02158726f, 0.03382866f, 0.01861029f, -0.01173376f, 0.03101739f, 0.02498924f, 0.01192209f, 
    -0.02669386f, -0.00253357f, -0.02711331f, -0.03095132f, -0.00344032f, 0.02157570f, -0.05303536f, -0.03284292f, 
    0.02024482f, -0.05362363f, -0.04359218f, 0.04027987f, 0.03122365f, -0.00786461f, -0.01698880f, -0.02581779f, 
    0.01844962f, -0.00112540f, 0.00638139f, 0.01445521f, -0.04747726f, -0.00382697f, 0.03784552f, 0.03073252f, 
    -0.02644526f, 0.00891333f, 0.00291786f, 0.04197713f, -0.01701633f, 0.02732762f, 0.02655073f, -0.03861098f, 
    0.02572804f, -0.04552923f, 0.00232891f, -0.01008961f, -0.03707678f, -0.02766873f, 0.02279084f, 0.02154044f, 
    0.03965015f, -0.03563674f, 0.02632049f, -0.03435947f, -0.00923895f, -0.05532094f, -0.03453608f, 0.02134075f, 
    0.01348290f, -0.02414062f, -0.01270403f, 0.02859404f, 0.00425268f, 0.04140383f, -0.05295979f, -0.05408200f, 
    -0.04384532f, -0.01245305f, 0.02830521f, 0.00733799f, -0.01351484f, -0.03648316f, -0.05529501f, 0.03484499f, 
    -0.05576231f, 0.03756298f, -0.05346666f, 0.04182101f, 0.03875828f, 0.01180451f, -0.02906021f, -0.01758779f, 
    -0.00567455f, -0.03188809f, -0.00832327f, -0.03699146f, -0.02954630f, -0.02069374f, 0.02963055f, -0.02493709f, 
    -0.00034898f, -0.03493989f, -0.01591078f, -0.00695995f, -0.00568621f, -0.02067142f, 0.00128367f, -0.03251797f, 
    0.02637557f, -0.00090362f, -0.04490001f, -0.01751408f, -0.04849775f, -0.01738579f, 0.00313128f, -0.02124257f, 
    -0.03817206f, -0.05375999f, 0.00745959f, 0.02243260f, -0.01913474f, -0.03366941f, -0.01930275f, 0.03768059f, 
    -0.01931976f, 0.02113318f, 0.00443353f, -0.05161469f, 0.00976199f, -0.04234694f, 0.02297825f, -0.02542565f, 
    0.03278856f, -0.03212766f, -0.00215968f, 0.03357689f, 0.04142503f, 0.01896663f, 0.04036307f, -0.04278749f, 
    -0.01254639f, 0.02612347f, 0.01947709f, -0.03504101f, -0.05378278f, -0.04688248f, -0.05298274f, 0.02985542f, 
    -0.01995142f, 0.01359575f, -0.02746891f, -0.01183984f, -0.04811310f, 0.02100632f, -0.04854001f, 0.01282356f, 
    0.00730143f, -0.04476738f, 0.02341554f, 0.03133949f, -0.04369878f, -0.04484705f, -0.01687532f, -0.01487353f, 
    -0.04942151f, -0.01057517f, 0.04405287f, -0.02510946f, -0.00550268f, 0.00079852f, -0.03511749f, -0.01027547f, 
    0.04332300f, -0.00836817f, 0.01180376f, -0.00091287f, -0.03997364f, -0.00907970f, 0.03861615f, 0.01299611f, 
    -0.05492012f, -0.04938911f, 0.01101992f, -0.00153897f, 0.02519026f, -0.05389572f, -0.01757914f, -0.02021196f, 
    -0.02757918f, 0.02978482f, 0.00229633f, -0.03302361f, -0.05303998f, -0.02707358f, -0.01893632f, 0.02950501f, 
    0.00854089f, -0.04437618f, 0.01154312f, -0.01328812f, -0.04663293f, -0.00549340f, 0.03504461f, -0.00244661f, 
    0.03517332f, -0.04693105f, 0.04054897f, -0.05086710f, -0.02226167f, 0.03417294f, -0.03735724f, 0.04234736f, 
    0.01978635f, 0.03372492f, -0.03662639f, -0.04408127f, -0.03822051f, 0.00005791f, 0.00154389f, -0.02481017f, 
    -0.01646785f, 0.02978700f, -0.03582748f, -0.02603851f, 0.02722827f, 0.00108854f, 0.01545189f, -0.05271292f, 
    -0.01196859f, -0.03401312f, 0.02303291f, 0.03175795f, 0.03651188f, -0.00505540f, 0.03018416f, 0.02764969f, 
    0.03674946f, 0.03523118f, -0.00064324f, -0.01118521f, -0.01217981f, -0.05473841f, 0.02487450f, -0.02669373f, 
    -0.00955123f, -0.05526738f, -0.00448971f, -0.00884788f, -0.01369246f, -0.03938239f, 0.00426612f, -0.04307802f, 
    -0.02182992f, -0.03604106f, 0.01585849f, -0.02748761f, -0.00567509f, -0.04766122f, -0.02611703f, 0.03805833f, 
    0.00967919f, 0.01765475f, 0.02924644f, -0.04644469f, -0.02682552f, 0.01156938f, -0.00459100f, -0.00172851f, 
    -0.05347786f, 0.02194905f, 0.01793425f, -0.02587627f, 0.00987631f, -0.01195983f, -0.03630495f, -0.05096141f, 
    -0.01609780f, -0.00524423f, -0.03833999f, -0.01784636f, 0.02538737f, 0.00388176f, 0.02797925f, 0.02528336f, 
    -0.00410742f, -0.03231433f, -0.02444796f, 0.01869165f, 0.01866503f, -0.01908578f, -0.02880732f, -0.00353725f, 
    0.02328392f, 0.00981726f, 0.03909654f, 0.04549856f, -0.04953164f, -0.00259898f, 0.02938164f, 0.01863860f, 
    -0.02295871f, -0.05053521f, 0.04441310f, 0.04430317f, -0.04356882f, 0.00981965f, 0.00006215f, 0.04026331f, 
    -0.02692766f, -0.00094237f, -0.03266818f, 0.00018874f, -0.01314982f, -0.02825449f, -0.00194423f, 0.00897823f, 
    -0.04619241f, -0.04209154f, -0.01037495f, -0.01948098f, 0.04416057f, -0.01560934f, 0.01645586f, -0.04081957f, 
    0.01484422f, -0.00643990f, -0.05112579f, 0.04298957f, 0.02865448f, -0.03280400f, 0.01700900f, 0.02333979f, 
    -0.03857451f, 0.00282277f, 0.00243860f, -0.02181041f, -0.02444758f, -0.04693667f, -0.03036932f, -0.03336059f, 
    -0.03770432f, -0.04544494f, -0.01444469f, 0.03942387f, -0.05555257f, -0.04289941f, 0.01616915f, -0.04928808f, 
    -0.04046709f, 0.04093541f, -0.00211915f, -0.03704449f, -0.05356315f, 0.01120715f, -0.02214357f, 0.03493230f, 
    -0.03494877f, 0.01696111f, -0.04089990f, -0.00932284f, 0.02390980f, -0.01561972f, 0.03761056f, 0.01890023f, 
    -0.00738408f, 0.02475093f, 0.00096778f, -0.05184825f, 0.04438243f, 0.02553370f, 0.01964730f, 0.02203896f, 
    -0.02336512f, 0.04308740f, -0.02813407f, -0.00844482f, -0.05553865f, -0.01261905f, 0.02586619f, -0.05630982f, 
    -0.04572555f, -0.05257869f, -0.03651791f, 0.02402691f, 0.04416395f, -0.02162519f, 0.03866096f, -0.02980510f, 
    -0.00116990f, -0.00941724f, -0.03148809f, -0.02168850f, 0.01825262f, 0.00003781f, -0.05413770f, 0.03263333f, 
    -0.04355449f, -0.04100548f, 0.02226312f, -0.04864750f, 0.03482381f, -0.03571440f, 0.01583166f, -0.02059969f, 
    -0.04006812f, -0.00123704f, -0.04786073f, -0.01704850f, -0.00498634f, -0.04275246f, -0.02439650f, -0.01725067f, 
    0.03573592f, -0.00776934f, 0.01328176f, -0.04592695f, -0.00598776f, 0.03614033f, 0.03469828f, -0.02716896f, 
    0.03403573f, -0.01963358f, 0.01722914f, -0.05571190f, -0.03579281f, 0.04017756f, -0.04919815f, -0.03387423f, 
    -0.02803219f, -0.01139371f, -0.04443561f, -0.01763055f, -0.05499040f, -0.03293128f, -0.00353480f, 0.01989219f, 
    0.02393546f, -0.03938156f, 0.01218113f, -0.00584270f, -0.03789539f, 0.03373532f, -0.05060140f, -0.01882285f, 
    0.02422498f, -0.00966431f, -0.04607848f, 0.01698918f, 0.01457255f, 0.01282542f, -0.01072413f, -0.04400459f, 
    -0.02364578f, -0.01725341f, 0.00309897f, -0.05073855f, 0.00562540f, 0.01320073f, -0.02022996f, 0.04467453f, 
    -0.01312730f, -0.02182358f, -0.01953213f, 0.02740473f, 0.00964531f, -0.00642452f, -0.01969845f, -0.04826975f, 
    0.02770791f, -0.03060144f, -0.05574558f, -0.01946682f, 0.00694669f, -0.00256485f, 0.01345771f, 0.01725427f, 
    -0.04252210f, 0.00157267f, 0.00979910f, 0.04160708f, -0.04449551f, 0.00454808f, -0.02118110f, 0.01810176f, 
    -0.02730037f, -0.01574776f, 0.01158252f, -0.02937247f, -0.02209478f, -0.01057427f, -0.03719187f, 0.01371205f, 
    0.04179486f, 0.00549052f, 0.03525427f, -0.00061260f, -0.03081880f, -0.02408457f, 0.02206725f, -0.02915419f, 
    -0.03439888f, -0.04749619f, -0.03416046f, 0.00546097f, -0.04714572f, -0.05151686f, -0.04119058f, -0.01636934f, 
    -0.03035029f, 0.01194841f, 0.00177524f, -0.02634824f, -0.05166673f, 0.04470753f, -0.00153198f, 0.00495884f, 
    0.02809708f, 0.02761588f, 0.00585425f, -0.00957299f, 0.01112424f, -0.00686889f, -0.01165881f, -0.02631360f, 
    0.02945693f, 0.02337997f, -0.01546786f, 0.03794022f, -0.05064669f, 0.04387876f, 0.03268923f, 0.00797880f, 
    -0.01664137f, -0.04572063f, -0.04185986f, 0.04312379f, 0.03242911f, -0.01663005f, 0.04413621f, -0.02490282f, 
    -0.02782075f, -0.05680323f, 0.01923398f, 0.03032159f, -0.02543207f, 0.01581169f, -0.04622314f, 0.01012591f, 
    0.01300356f, 0.00679745f, -0.03535859f, 0.03108427f, -0.01044618f, 0.03426833f, 0.04486583f, 0.03452130f, 
    -0.01243190f, -0.02560076f, -0.01286244f, -0.02899409f, -0.00413263f, 0.01971538f, 0.03568514f, -0.03063326f, 
    -0.02703673f, -0.05278994f, -0.04909682f, -0.01294752f, -0.05589192f, -0.00049096f, -0.00284442f, 0.03083015f, 
    -0.02406557f, -0.04844134f, -0.05428011f, 0.03835090f, -0.03346607f, 0.03435340f, -0.00746323f, -0.04615438f, 
    -0.02183595f, -0.05394801f, 0.03941705f, -0.05566363f, 0.04083670f, -0.01390917f, 0.01118711f, -0.02412004f, 
    0.01330325f, -0.01660083f, 0.02144953f, -0.05534807f, -0.01554573f, -0.00187521f, -0.02820059f, 0.01757790f, 
    0.04393267f, -0.04486629f, -0.04773493f, 0.04387811f, -0.01118949f, 0.02950373f, -0.05279468f, -0.05037882f, 
    0.03078976f, -0.01334897f, 0.04099115f, -0.01678320f, -0.02677685f, 0.04276293f, 0.02001739f, 0.00641874f, 
    0.03232071f, -0.04370840f, -0.05575336f, 0.01465287f, -0.04576991f, -0.00303669f, -0.05668370f, 0.02876870f, 
    -0.01280566f, -0.03554988f, 0.01033774f, -0.02117165f, -0.02478888f, -0.05495056f, 0.00731082f, -0.01826009f, 
    -0.02886545f, 0.02512610f, -0.00377762f, -0.02161619f, -0.00020168f, -0.03613205f, 0.03361963f, -0.01792706f, 
    0.03082136f, -0.04532521f, 0.01592330f, -0.01339089f, -0.01420286f, 0.02234186f, -0.04246546f, 0.02569635f, 
    -0.04410845f, -0.05166573f, -0.00910729f, 0.01052728f, 0.02677336f, -0.01615145f, 0.02554735f, 0.01670286f, 
    -0.00675335f, -0.01040150f, -0.03178013f, 0.02332185f, 0.02319080f, -0.03999161f, -0.03363688f, -0.05615455f, 
    0.03753607f, -0.04797573f, -0.02963256f, -0.02657577f, -0.04946407f, 0.01381368f, 0.04057816f, -0.01227637f, 
    0.01821078f, -0.00511490f, 0.02997185f, -0.01397403f, -0.04639976f, -0.00167193f, -0.00840830f, -0.04073029f, 
    0.03937170f, 0.03410958f, -0.04677048f, -0.00874470f, 0.04298915f, -0.02756329f, -0.00161087f, -0.04322528f, 
    -0.02704508f, -0.01299495f, 0.01677249f, 0.02832459f, -0.01460063f, -0.05158938f, -0.03198501f, -0.04885316f, 
    0.00914725f, 0.03197420f, 0.00924418f, -0.00269354f, 0.04049268f, 0.04071184f, 0.01947723f, -0.02457770f, 
    0.02579793f, -0.02861146f, 0.04179596f, -0.02744119f, -0.04028737f, -0.05492607f, 0.03095986f, -0.01527703f, 
    -0.01743682f, -0.03925714f, 0.04384074f, -0.02341368f, -0.04828326f, 0.01505902f, 0.02118658f, -0.02297573f, 
    0.03593608f, -0.00339731f, -0.02324162f, 0.03393515f, -0.02270032f, -0.01762708f, -0.00829271f, -0.03100503f, 
    -0.04391905f, 0.04136701f, -0.00156298f, -0.00282299f, -0.00716529f, 0.00627945f, -0.05301078f, 0.02951197f, 
    -0.04554389f, -0.04904743f, 0.01749066f, -0.04971410f, -0.00131212f, -0.01705206f, 0.02289830f, 0.03800658f, 
    -0.03353932f, 0.02781729f, 0.00272867f, -0.00222457f, -0.05264128f, 0.01181413f, -0.03709596f, -0.03368650f, 
    -0.05592012f, 0.04122499f, 0.00991474f, -0.04721972f, -0.05569569f, -0.02606606f, 0.03721203f, 0.02714806f, 
    0.03552832f, -0.03813411f, -0.04376403f, -0.05419616f, 0.00282035f, 0.02450133f, 0.00140096f, 0.00345215f, 
    -0.04036209f, 0.03059712f, 0.01125162f, 0.04496196f, -0.01382094f, -0.05383537f, -0.04522414f, 0.03747816f, 
    0.00075540f, -0.02706488f, -0.00683963f, -0.03648615f, -0.01799694f, -0.00653340f, 0.00234772f, -0.02816897f, 
    0.04261044f, -0.05551805f, 0.03839281f, -0.04482464f, 0.02225406f, -0.04446827f, -0.00190148f, -0.04957922f, 
    0.04115975f, 0.01249305f, -0.01858546f, -0.03459407f, 0.02174352f, 0.02601137f, -0.01236054f, -0.01051253f, 
    0.01569802f, -0.01897000f, 0.01160573f, -0.00655355f, -0.04288710f, 0.04268103f, -0.05302652f, 0.04190682f, 
    -0.01021476f, 0.02013935f, -0.03813656f, -0.03514076f, -0.04436100f, 0.01926018f, 0.00783726f, 0.00539272f, 
    0.01987751f, -0.02115291f, -0.03043404f, 0.01096996f, 0.03942520f, -0.00719907f, 0.01827907f, 0.03940258f, 
    -0.27345657f, 0.07283393f, -0.01790215f, 0.01708170f, -0.06516861f, 0.20198023f, 0.05139986f, -0.05506828f, 
    0.11182529f, -0.07379574f, 0.03104067f, -0.03497617f, -0.11425658f, 0.14951992f, 0.01200369f, 0.02948059f, 
    0.07821263f, -0.09773301f, 0.14094375f, -0.06317111f, -0.01590869f, -0.07198304f, 0.09082088f, -0.08739919f, 
    -0.20698394f, 0.05809999f, 0.01696577f, 0.16944011f, 0.01180167f, 0.03732144f, -0.01874815f, 0.10948256f, 
    0.02121373f, -0.14376348f, 0.00590809f, -0.14701624f, -0.01726525f, 0.23720495f, -0.10519005f, 0.04272705f, 
    0.02098594f, 0.09610911f, -0.01203000f, 0.16887589f, 0.08221824f, 0.05441908f, 0.00100117f, -0.05868372f, 
    0.20708880f, -0.42724428f, 0.08773904f, -0.37046745f, 0.07114813f, -0.10279477f, -0.00248282f, -0.09725573f, 
    -0.01282757f, 0.00754493f, -0.06003962f, 0.06427409f, -0.05466049f, 0.15741003f, 0.16784522f, -0.18038982f, 
    0.00834113f, 0.09378787f, -0.11480045f, -0.00878287f, 0.00598871f, 0.13338596f, 0.11475018f, 0.20161362f, 
    0.10472671f, -0.21602978f, -0.17117448f, 0.03334854f, 0.00568667f, -0.07829393f, -0.06218080f, 0.00634672f, 
    -0.14104405f, -0.08964489f, -0.06419059f, -0.03850031f, 0.13836382f, 0.13872200f, 0.06675961f, -0.02919896f, 
    -0.01505239f, 0.08325105f, 0.06173131f, 0.14518490f, -0.01036089f, -0.07271859f, 0.10580370f, 0.02678358f, 
    0.01604581f, 0.16788417f, -0.01004508f, 0.00229818f, -0.10820393f, 0.04134995f, -0.00516916f, 0.04100585f, 
    0.02687124f, -0.02198002f, 0.02458225f, 0.05760950f, 0.00824760f, 0.20535855f, 0.11966733f, -0.28119478f, 
    0.13101502f, -0.03140575f, 0.08345578f, 0.00371538f, -0.06253748f, 0.03010883f, 0.08302266f, 0.09814759f, 
    -0.08409129f, -0.00736060f, -0.10527454f, -0.00807963f, 0.03301851f, 0.06484916f, 0.02724950f, -0.03504156f, 
    0.09756652f, 0.11000776f, 0.17072077f, -0.02437006f, -0.01346093f, -0.10371616f, 0.07078788f, 0.17055772f, 
    0.08067743f, 0.06151383f, -0.06222267f, 0.01446292f, 0.08786497f, 0.05952382f, 0.08384041f, 0.11703663f, 
    0.31205201f, -0.04448983f, 0.17989375f, 0.11704011f, 0.08976261f, -0.05577550f, 0.04886686f, 0.03202168f, 
    0.00755387f, -0.01349853f, 0.03699245f, -0.05187133f, -0.20538117f, 0.09709571f, -0.27399585f, -0.18746898f, 
    -0.12399573f, 0.00652567f, -0.06330974f, 0.07261969f, 0.03485047f, 0.15244384f, 0.08906472f, 0.23590501f, 
    0.22090968f, 0.17701328f, -0.21034791f, -0.06256030f, -0.05853173f, 0.07231166f, 0.07646873f, -0.00304349f, 
    0.05361924f, 0.03918242f, 0.00082077f, -0.07821277f, 0.12134159f, 0.09208431f, 0.18343832f, -0.18520987f, 
    0.08087050f, -0.09214645f, 0.04530762f, 0.00566741f, 0.03189515f, -0.07636600f, -0.04101112f, 0.03940124f, 
    -0.10129636f, 0.02425993f, 0.02945864f, -0.08539391f, 0.10831688f, -0.00454300f, 0.01172707f, -0.09666611f, 
    -0.04182687f, -0.09305016f, 0.02893081f, -0.06044298f, -0.11713769f, -0.10563022f, -0.27618736f, 0.06749453f, 
    0.15729532f, 0.00275211f, 0.03461976f, -0.11586908f, -0.08119494f, -0.03004116f, 0.17759508f, 0.08272308f, 
    0.17574905f, -0.11760770f, -0.20615818f, 0.04151563f, -0.02222570f, -0.20124927f, 0.03049924f, 0.20496880f, 
    -0.05686284f, 0.04197383f, 0.13392037f, 0.02412499f, -0.20536301f, 0.22260658f, 0.00119675f, 0.01763583f, 
    -0.04184303f, 0.06386747f, -0.11597265f, 0.00845713f, 0.01119322f, 0.08646224f, -0.05804922f, 0.14203434f, 
    0.18272102f, 0.11599343f, 0.07144867f, 0.12155953f, 0.01487051f, 0.04126928f, 0.09033627f, 0.07918978f, 
    -0.00540217f, 0.08266057f, -0.01357113f, -0.02664407f, 0.12858401f, 0.06507803f, 0.03593912f, 0.10736930f, 
    -0.10694948f, 0.08958876f, 0.05805494f, -0.08215928f, 0.13236402f, 0.03703976f, 0.04760630f, -0.07804538f, 
    -0.17074527f, 0.02460528f, -0.30350929f, -0.28161681f, 0.16527164f, 0.03233799f, -0.06700863f, -0.11446418f, 
    -0.06942815f, -0.02114567f, -0.10279681f, -0.20515850f, 0.26718313f, -0.12255034f, -0.10141256f, 0.12737481f, 
    0.03330895f, -0.06695352f, 0.07607184f, 0.09826683f, -0.02469352f, -0.04550744f, -0.01120597f, 0.08731578f, 
    0.06323878f, 0.16833685f, 0.05296378f, -0.05409908f, 0.02056614f, -0.07232729f, 0.10873223f, -0.16001889f, 
    0.06365526f, -0.08554809f, -0.06492965f, -0.13924578f, 0.13747965f, -0.13772540f, -0.12913340f, 0.14884292f, 
    0.03157447f, -0.05003959f, -0.07766941f, 0.16757402f, 0.11002258f, -0.04825021f, 0.03126884f, 0.02437851f, 
    0.23095253f, 0.20816903f, 0.17885782f, 0.10541132f, -0.01936799f, -0.05312976f, -0.07010478f, 0.11082327f, 
    -0.00214639f, -0.13466184f, 0.17991345f, -0.04394561f, 0.15453440f, 0.25264272f, 0.18905824f, 0.02295245f, 
    0.05458225f, -0.00367954f, -0.01992835f, -0.01285557f, 0.01229570f, 0.00809534f, -0.08011349f, -0.09610682f, 
    0.29467958f, -0.07082819f, 0.01315810f, -0.07805620f, 0.02393220f, 0.11934001f, 0.12854542f, -0.06358266f, 
    0.06215515f, 0.01409749f, 0.02479689f, 0.03051118f, 0.07974090f, -0.40140393f, -0.00320589f, 0.27811769f, 
    0.10981550f, 0.07009631f, -0.05544081f, -0.01242357f, 0.12360071f, -0.06776155f, -0.02896291f, -0.02935390f, 
    0.30080083f, 0.39520553f, 0.01845273f, 0.09354607f, -0.02835003f, -0.11100940f, -0.04079929f, -0.00460217f, 
    0.06179651f, -0.01522092f, 0.00331028f, -0.14869703f, 0.19105347f, 0.24535409f, -0.01177607f, -0.30093327f, 
    -0.11886627f, 0.12867905f, 0.07718751f, -0.09444341f, 0.04286361f, 0.07635389f, 0.04665355f, -0.01616647f, 
    0.03552425f, -0.01493910f, 0.03573562f, -0.03705598f, -0.04352923f, 0.02809178f, 0.04292950f, 0.01256622f, 
    -0.01177793f, 0.03411079f, -0.02512164f, -0.02615236f, 0.01638836f, 0.01041999f, -0.01295797f, -0.04034426f, 
    0.00005807f, -0.02230844f, -0.03238519f, 0.04750304f, 0.02387477f, -0.02238264f, -0.02968577f, -0.05715941f, 
    -0.04979501f, 0.01162255f, -0.00839631f, 0.02376676f, -0.04914656f, 0.00666443f, -0.03499834f, 0.02357331f, 
    -0.00759348f, 0.01998930f, 0.04031735f, -0.04768356f, 0.03860625f, 0.02726125f, 0.00322547f, 0.03021999f, 
    0.03820629f, 0.01796124f, -0.01440052f, 0.04066508f, -0.00396231f, 0.03283953f, -0.05098286f, 0.02658162f, 
    -0.00805339f, 0.02776588f, -0.01685394f, -0.03248267f, 0.01680834f, 0.00269547f, 0.00253324f, -0.04461629f, 
    -0.01096983f, -0.03174606f, -0.02982024f, 0.04391290f, -0.02076796f, 0.02311854f, 0.01923884f, -0.03090456f, 
    -0.00469248f, 0.01382894f, 0.00993670f, 0.03865863f, -0.03065761f, -0.02219648f, -0.02572141f, -0.05129061f, 
    -0.00349355f, 0.04913003f, -0.02873699f, -0.02556761f, -0.03111972f, 0.03124500f, -0.02031904f, 0.03725217f, 
    0.01175701f, -0.00759052f, 0.02233279f, 0.04175999f, 0.00140579f, 0.01699313f, 0.04320252f, -0.01386134f, 
    -0.03346187f, -0.01724160f, -0.01139516f, -0.01414066f, -0.01193970f, 0.01218385f, 0.01401166f, 0.02092212f, 
    -0.02722149f, -0.04789853f, 0.02527327f, -0.00798902f, -0.00670719f, 0.01049565f, -0.00830328f, -0.02880562f, 
    0.03598722f, -0.02803485f, -0.03051692f, -0.02428946f, 0.04102118f, -0.02287158f, -0.02137982f, -0.00636971f, 
    0.01271783f, 0.01083364f, -0.03041452f, -0.03575619f, 0.00723314f, 0.01066769f, 0.00681591f, -0.05018262f, 
    0.00871500f, -0.03174926f, -0.03261286f, 0.00769789f, 0.03238991f, -0.01482993f, -0.04660336f, -0.03923807f, 
    -0.02565929f, -0.03491978f, 0.01440912f, -0.05171697f, -0.00906950f, -0.00965194f, -0.05282507f, -0.05493649f, 
    0.00179869f, 0.00777236f, 0.02761585f, -0.00673948f, -0.02975240f, -0.01354941f, -0.02455349f, 0.03120838f, 
    0.00102368f, 0.04483853f, 0.01479345f, 0.02438897f, 0.03597179f, -0.01437117f, 0.02253175f, -0.04089224f, 
    -0.01290130f, -0.03241346f, -0.04723940f, -0.01733460f, 0.04093650f, -0.04593315f, 0.05003975f, 0.01715607f, 
    -0.00964382f, 0.03529747f, 0.01032252f, 0.03033946f, -0.00367836f, -0.04420736f, -0.00742118f, -0.01800491f, 
    -0.03106290f, 0.00437073f, 0.02386403f, 0.01276863f, -0.01169433f, -0.06161332f, -0.00183925f, 0.04636606f, 
    -0.03237347f, 0.01746476f, -0.02046006f, 0.03063248f, 0.03017093f, 0.02717142f, 0.00880317f, -0.00090387f, 
    -0.01086586f, 0.00737407f, -0.01847565f, 0.00071152f, -0.02697136f, -0.02118144f, -0.01098627f, 0.02123945f, 
    -0.01174603f, 0.02392024f, -0.02827936f, 0.00565241f, 0.03164743f, 0.02152822f, -0.02797004f, 0.01201085f, 
    -0.02156402f, 0.04200625f, -0.01445568f, -0.01348929f, -0.00258829f, -0.02731845f, -0.01615108f, 0.03864110f, 
    0.02400862f, -0.00711104f, 0.04286958f, -0.02266809f, -0.00769622f, 0.03545484f, -0.04352809f, -0.04336225f, 
    -0.02948398f, -0.03426218f, 0.02840174f, -0.00035422f, 0.01121279f, -0.05821762f, -0.04670646f, -0.01634653f, 
    0.03315216f, 0.00448063f, -0.02920095f, 0.00035349f, 0.02670470f, -0.00193912f, 0.00076875f, -0.04955784f, 
    0.00229185f, 0.03509877f, -0.03622094f, -0.02272356f, -0.04886001f, 0.05053726f, 0.01213082f, 0.03333886f, 
    -0.00102738f, -0.00823131f, -0.04224778f, -0.03726283f, -0.01917157f, 0.04843413f, 0.00929282f, -0.02763957f, 
    -0.02213070f, -0.05853447f, -0.04281909f, 0.01896606f, 0.03872180f, 0.00261737f, 0.03521290f, 0.00175400f, 
    -0.05669601f, 0.04047234f, -0.04333562f, 0.03332124f, -0.04481889f, 0.00772541f, 0.03942996f, -0.00880449f, 
    0.00074677f, 0.01299270f, -0.03278999f, 0.00088079f, 0.02937468f, 0.04243384f, -0.04756182f, 0.03976746f, 
    -0.02115842f, -0.00981075f, 0.04599498f, -0.00209898f, -0.03991553f, 0.01442712f, 0.03479457f, 0.00827668f, 
    0.02100417f, 0.01579469f, -0.03382657f, 0.01580455f, -0.04815270f, 0.00210076f, -0.00093436f, 0.03143960f, 
    -0.00510018f, -0.04228180f, 0.02697168f, 0.00392991f, -0.02051446f, 0.00453567f, -0.02316517f, -0.01121684f, 
    -0.01533328f, 0.00972642f, 0.00203223f, -0.00410385f, 0.00382977f, 0.01979630f, 0.00265461f, 0.01208717f, 
    0.02018315f, -0.04679525f, 0.02587843f, 0.00850044f, 0.00912411f, -0.03578085f, -0.03689578f, -0.05702182f, 
    0.01782342f, 0.03724143f, 0.01920353f, -0.04164529f, -0.00230094f, -0.03564123f, 0.00670780f, -0.01336285f, 
    -0.01212286f, 0.01021143f, -0.04766390f, 0.03020125f, -0.01020867f, -0.00880389f, -0.02343512f, 0.00014770f, 
    -0.01484120f, -0.01988059f, -0.03632107f, -0.03082018f, 0.00605663f, -0.04011446f, -0.00269256f, -0.00281089f, 
    0.02185099f, 0.00820830f, -0.03212960f, -0.01651018f, 0.03197462f, 0.02837100f, -0.01346642f, -0.04372298f, 
    0.01593857f, 0.01061708f, 0.05105382f, 0.04016618f, -0.05248719f, -0.04473193f, -0.05096453f, 0.02032808f, 
    0.03964954f, 0.01934506f, 0.03772326f, -0.04200307f, 0.01519430f, -0.05153904f, -0.01371877f, -0.02100287f, 
    -0.02582558f, -0.01646530f, 0.00137202f, -0.01796842f, -0.00909987f, -0.02186428f, -0.02596835f, -0.01544730f, 
    -0.05340068f, 0.01301707f, -0.04592785f, -0.03197154f, -0.01582167f, -0.03327176f, -0.02046547f, -0.04691400f, 
    -0.02235874f, 0.04115469f, -0.04787901f, -0.02228895f, 0.02520483f, -0.04742992f, -0.00618811f, 0.04303536f, 
    0.02542534f, -0.04317064f, -0.02104184f, -0.02411625f, 0.02084038f, 0.00431366f, -0.04598410f, 0.00709639f, 
    -0.04083601f, -0.03340835f, 0.03995110f, -0.00460587f, -0.02171434f, 0.01673561f, -0.00154482f, 0.01768469f, 
    0.04223949f, 0.02869567f, -0.03678443f, -0.01253757f, -0.02612512f, 0.00064251f, -0.00811372f, -0.04510370f, 
    0.00194889f, 0.01967476f, -0.01289206f, 0.04443454f, -0.01019914f, -0.01567972f, 0.02033672f, -0.03862203f, 
    -0.05331335f, -0.00091132f, 0.00139833f, -0.05163148f, -0.01196675f, -0.00033848f, 0.01085409f, 0.02774554f, 
    0.03981912f, -0.00949498f, -0.03319448f, 0.04057013f, 0.00067252f, -0.01665549f, -0.01376235f, -0.05462817f, 
    -0.00117756f, -0.00725199f, -0.04673811f, -0.00624411f, 0.02078537f, 0.00458666f, -0.03574128f, -0.04102962f, 
    0.04000399f, -0.03821478f, 0.01687681f, -0.02550946f, -0.00634896f, 0.04339267f, 0.00102916f, 0.00136747f, 
    0.02193254f, -0.03297777f, -0.02313787f, -0.00069975f, 0.02308247f, -0.03913131f, -0.02672583f, -0.03615802f, 
    -0.05488179f, -0.03199782f, 0.01544896f, -0.03823400f, -0.02241633f, 0.03337143f, -0.03844293f, -0.05342008f, 
    -0.01196869f, -0.01749372f, 0.04469533f, 0.03419188f, -0.04942390f, -0.04520180f, -0.02356878f, -0.04942870f, 
    -0.00777906f, 0.03597523f, -0.04974001f, -0.02404207f, -0.01468084f, -0.03811697f, 0.02837827f, 0.00717321f, 
    -0.05437771f, -0.04464210f, 0.00265834f, 0.01247766f, -0.00684826f, 0.04112760f, -0.04097782f, 0.01509701f, 
    0.01160175f, -0.03798100f, 0.02132598f, 0.02180447f, -0.03702991f, -0.01534421f, -0.04356917f, 0.01725988f, 
    -0.02651707f, 0.03138434f, 0.01226768f, -0.01844361f, 0.03869809f, 0.02380518f, -0.00833875f, 0.03651879f, 
    0.01971541f, -0.04707821f, 0.00644291f, -0.01497811f, -0.02038043f, 0.02593998f, -0.05439289f, -0.04645449f, 
    -0.02337195f, -0.03474564f, 0.03467871f, 0.01484821f, 0.01581228f, 0.02386094f, 0.01087004f, -0.05230334f, 
    -0.03288974f, 0.00613232f, 0.00589983f, -0.01171819f, 0.00435927f, 0.02428852f, -0.01838223f, -0.01546783f, 
    -0.01123486f, -0.01344171f, 0.02282424f, -0.04854141f, 0.04404685f, -0.02865006f, -0.04097487f, -0.02286934f, 
    0.00725683f, -0.03589242f, 0.03551159f, 0.02142038f, 0.01401258f, -0.00754769f, 0.02027328f, -0.05286343f, 
    -0.01992961f, 0.00839870f, -0.03148670f, 0.02020680f, -0.02365542f, 0.04807577f, 0.01885040f, -0.02987406f, 
    -0.00630811f, -0.03317399f, 0.03725697f, -0.02081206f, 0.03572204f, -0.02779350f, -0.00714699f, -0.03927740f, 
    -0.01862865f, -0.04310083f, 0.00718252f, 0.03326957f, 0.01430937f, -0.00314469f, 0.00395717f, 0.03111602f, 
    -0.03147852f, -0.03480471f, -0.02266097f, -0.04256491f, -0.00958742f, -0.01694362f, -0.02922030f, -0.01967152f, 
    0.02413167f, 0.03193865f, -0.02462014f, -0.04752876f, -0.02799088f, 0.01299904f, 0.04748495f, -0.02843288f, 
    -0.02313824f, -0.04920870f, -0.04674590f, -0.03905921f, -0.00485303f, 0.03420953f, 0.03944373f, -0.05415367f, 
    0.02960992f, -0.00194596f, 0.01246374f, -0.03713282f, -0.03238321f, 0.04511197f, 0.01119205f, -0.03483349f, 
    -0.01876698f, -0.01175110f, 0.03801787f, 0.02532955f, 0.00728219f, 0.01682448f, 0.00308607f, -0.04853570f, 
    -0.04216539f, 0.01485118f, 0.02768156f, -0.00494935f, 0.00945303f, -0.04027545f, -0.04546323f, 0.01696036f, 
    0.03752873f, -0.01453098f, -0.02507614f, -0.00617815f, -0.04953299f, 0.03575455f, -0.03580120f, 0.03163515f, 
    0.00483637f, -0.02846204f, 0.01462540f, -0.02085225f, -0.04757803f, -0.05035610f, -0.03713435f, 0.00516921f, 
    -0.01706811f, 0.02390149f, -0.04431922f, 0.02541567f, -0.04878685f, 0.00899795f, 0.00804956f, 0.01457307f, 
    -0.05112869f, -0.03603442f, -0.03206234f, -0.01658256f, -0.02103158f, 0.02630751f, 0.04117058f, 0.01306349f, 
    0.02442920f, 0.03578305f, 0.01378798f, 0.00099476f, 0.04223837f, 0.03334388f, -0.02578539f, -0.04213050f, 
    -0.03187291f, -0.05236805f, -0.02618385f, -0.05146530f, -0.04484993f, 0.04156821f, 0.03750901f, -0.01597787f, 
    0.02344602f, 0.02613055f, -0.01681358f, -0.04552950f, -0.01218676f, -0.02396596f, 0.00835461f, 0.00822854f, 
    -0.01501264f, 0.01019620f, -0.01894365f, 0.04181843f, 0.00010112f, 0.03516597f, 0.00818681f, 0.00172220f, 
    -0.02108613f, -0.01467880f, -0.04195829f, 0.00361793f, 0.04191196f, -0.00116076f, -0.02514469f, 0.00948007f, 
    -0.04653305f, -0.00449232f, 0.00495151f, -0.00971630f, 0.04066234f, -0.00846453f, -0.00346137f, -0.01732456f, 
    0.03156900f, -0.03948411f, -0.03000697f, 0.00644333f, -0.00307607f, 0.02192487f, -0.05249277f, -0.04924339f, 
    -0.00193942f, 0.03966513f, -0.04404346f, -0.03346219f, -0.04511351f, -0.05485942f, -0.03627659f, -0.04873095f, 
    -0.00763505f, 0.04544187f, 0.03067052f, 0.02017369f, -0.01698244f, -0.03741197f, 0.02937317f, 0.03248120f, 
    -0.03332384f, 0.03068250f, 0.02096767f, -0.04760317f, 0.00672812f, 0.02632659f, 0.03107783f, 0.04266260f, 
    -0.02558505f, -0.04845433f, -0.04638404f, 0.00663613f, 0.03844478f, -0.05581203f, 0.03876618f, 0.01794595f, 
    0.00012322f, -0.05208108f, -0.02041516f, 0.03354404f, -0.00345683f, 0.02139327f, -0.02613094f, 0.02784061f, 
    -0.05571062f, -0.05478495f, -0.01385151f, -0.05474431f, -0.04051739f, -0.02174140f, -0.05629118f, 0.01896230f, 
    -0.05173352f, -0.03672970f, -0.04387012f, -0.05397670f, -0.00558541f, 0.04451038f, 0.04037492f, -0.02423371f, 
    -0.01520251f, -0.00361175f, -0.03751412f, -0.00064707f, 0.00718694f, -0.02950593f, -0.03922530f, -0.04863111f, 
    -0.01327062f, -0.03411376f, 0.04463345f, -0.03827189f, -0.00232897f, -0.00284536f, 0.00937574f, 0.02760810f, 
    0.00789792f, -0.02888275f, -0.01966511f, -0.01323499f, 0.00085306f, 0.01818068f, 0.01817692f, -0.02391644f, 
    -0.03919370f, -0.03246142f, -0.05040314f, 0.02490702f, 0.03036955f, -0.04027728f, -0.03145775f, 0.00500907f, 
    0.01081136f, -0.03778028f, 0.01216030f, -0.03415307f, 0.01640568f, -0.02586836f, -0.02013938f, -0.05119116f, 
    -0.02802048f, 0.04611438f, -0.01886179f, -0.01023313f, -0.00369946f, 0.02640876f, -0.05546968f, 0.04447649f, 
    -0.02870754f, -0.02800190f, 0.02656370f, -0.05452223f, -0.03074354f, -0.00261309f, -0.03757068f, -0.00793055f, 
    -0.04030572f, -0.00951256f, 0.01459435f, 0.03768751f, 0.00116539f, -0.02736028f, -0.01931030f, 0.01714054f, 
    0.03870019f, -0.01681637f, 0.04011993f, -0.03808949f, -0.00905899f, 0.00725461f, 0.00596534f, 0.00544868f, 
    -0.02849997f, 0.02086931f, -0.02185428f, -0.02449740f, 0.04451282f, -0.05115205f, 0.04440782f, 0.01707263f, 
    -0.01921478f, -0.03388461f, -0.02411029f, -0.03792047f, -0.01916827f, -0.01211923f, 0.01479341f, 0.03989143f, 
    -0.02749111f, -0.02500506f, -0.05216422f, -0.01887055f, -0.05079339f, -0.04755824f, 0.00926963f, -0.03988554f, 
    -0.00177372f, 0.03842597f, -0.03948319f, -0.04555570f, -0.01320480f, -0.00591891f, -0.04165665f, -0.04887528f, 
    -0.05042547f, -0.00957375f, 0.00274709f, 0.02818380f, -0.00197193f, 0.03682993f, 0.01333922f, 0.02229173f, 
    -0.02848839f, 0.00740291f, 0.00307729f, 0.03727486f, 0.02726199f, -0.01334519f, -0.01715288f, 0.01889284f, 
    -0.02850022f, 0.04438836f, 0.00650070f, -0.02970440f, -0.05622474f, 0.01393858f, 0.02484360f, -0.05220058f, 
    0.03718880f, 0.03930937f, 0.03903889f, 0.00623383f, -0.04085035f, 0.04154469f, -0.01866416f, -0.03830751f, 
    -0.03188585f, -0.01230217f, 0.00455550f, -0.04347122f, 0.05011955f, 0.04473815f, -0.01066029f, -0.01010211f, 
    0.00309202f, -0.00918604f, 0.00059442f, 0.04323357f, 0.03490346f, -0.00603971f, 0.01821964f, -0.03209047f, 
    0.00995295f, 0.00138068f, -0.00842543f, 0.03457811f, -0.03710871f, -0.02075321f, 0.01392660f, 0.01373454f, 
    -0.00547507f, 0.01361567f, -0.00347170f, 0.00365494f, 0.01633223f, -0.05518740f, 0.03814311f, -0.00296731f, 
    0.03949022f, -0.04937112f, -0.01365061f, -0.03472944f, 0.02437972f, -0.00583585f, 0.03221038f, 0.03621752f, 
    0.03884400f, -0.04029826f, -0.02633372f, -0.04316273f, 0.00131974f, -0.01328039f, -0.00683457f, -0.03308704f, 
    -0.02944334f, -0.01907434f, -0.03480226f, -0.01817900f, 0.04021184f, 0.00783012f, -0.01648424f, -0.02993211f, 
    -0.02316730f, -0.03805561f, 0.01249354f, -0.04620312f, -0.02132683f, 0.01539352f, -0.03716876f, -0.03804072f, 
    0.01934856f, -0.04561580f, -0.04278919f, -0.01560034f, -0.04890326f, -0.05497566f, 0.01145720f, -0.00620266f, 
    0.04090432f, 0.04742595f, -0.02903795f, -0.00202180f, 0.03796408f, 0.00316570f, 0.04322219f, -0.00386543f, 
    0.03503732f, -0.05655333f, 0.03152436f, -0.03011760f, -0.05343494f, -0.01045377f, -0.03388750f, -0.00612502f, 
    0.02652619f, -0.00437511f, -0.05150713f, -0.01372110f, 0.02120739f, 0.00880237f, -0.02665293f, -0.05245755f, 
    -0.02889306f, -0.03806455f, 0.00336106f, -0.05746681f, -0.03885628f, 0.01284548f, -0.00459858f, 0.03953318f, 
    -0.01612568f, 0.02843067f, -0.02908039f, -0.04719451f, -0.02259184f, -0.00411720f, -0.04918779f, -0.02387710f, 
    -0.03996773f, 0.00468370f, -0.05459709f, 0.04458144f, -0.04688632f, 0.03596935f, 0.00581119f, 0.03772646f, 
    0.01154692f, 0.03637387f, -0.03270520f, -0.02472624f, 0.01556635f, -0.04535269f, -0.03190428f, -0.04434137f, 
    -0.05151028f, 0.02516661f, 0.01215937f, -0.03990557f, 0.01518972f, -0.03796577f, -0.04240753f, -0.02641542f, 
    0.02288575f, 0.01206817f, -0.04856908f, 0.00199092f, 0.03530230f, 0.04137174f, -0.04895524f, -0.04170502f, 
    0.01581583f, 0.02087058f, -0.03718593f, 0.01683944f, 0.03833877f, -0.00394712f, -0.05084447f, -0.01367776f, 
    0.00251144f, 0.00842443f, -0.05769007f, -0.00708796f, -0.03187262f, 0.04312181f, -0.04218151f, 0.01876555f, 
    -0.04320781f, 0.00727452f, 0.03585210f, 0.03878623f, -0.00128096f, 0.01358388f, -0.04341566f, 0.01784038f, 
    0.04336629f, 0.01013929f, 0.01288516f, -0.01599385f, -0.03336600f, -0.05476297f, -0.04898280f, 0.02329045f, 
    0.00815746f, 0.00916727f, -0.00109847f, -0.03667263f, -0.05024701f, 0.00296975f, 0.01418172f, -0.00088687f, 
    0.03060325f, 0.04459713f, 0.04296202f, 0.04803559f, -0.02933011f, -0.01521586f, 0.00579983f, -0.03945627f, 
    -0.03749638f, 0.02550482f, 0.04073286f, -0.00066771f, 0.02152604f, -0.03306950f, -0.00044863f, -0.04316770f, 
    -0.00421283f, -0.04392058f, -0.02779796f, -0.04024210f, 0.03753167f, 0.01624165f, 0.03911456f, 0.04013909f, 
    0.02225998f, 0.04366251f, 0.01106705f, -0.02316539f, -0.01475993f, -0.00123754f, -0.03332410f, -0.02660116f, 
    0.02747907f, 0.03560813f, -0.01663117f, -0.03555244f, -0.03489473f, 0.00652952f, 0.02566499f, -0.04547270f, 
    0.00280997f, -0.04563649f, 0.01964858f, -0.00176054f, 0.02837003f, 0.00422389f, -0.05433270f, 0.01151333f, 
    0.01513893f, 0.04130472f, -0.03974956f, -0.02549809f, -0.03258014f, 0.03912858f, 0.01385902f, 0.00119525f, 
    0.01951509f, 0.01314503f, -0.03448993f, -0.00689454f, 0.03841963f, 0.04448338f, 0.00178477f, 0.03576275f, 
    -0.02141655f, -0.00478973f, 0.01607193f, -0.00535469f, -0.02219909f, 0.01303745f, -0.02033508f, 0.00087985f, 
    -0.18601593f, -0.18890037f, 0.27255285f, 0.00881539f, -0.10553504f, -0.09903738f, 0.09395868f, -0.08312060f, 
    0.02257541f, 0.12906262f, -0.14201429f, 0.17444271f, -0.12097075f, -0.13035603f, 0.04441086f, -0.11780290f, 
    -0.04717208f, -0.18388808f, 0.05455424f, 0.22330393f, -0.05227536f, 0.05165457f, 0.09393136f, 0.03982528f, 
    0.01650841f, -0.23570587f, -0.00485742f, 0.01219207f, 0.08940154f, -0.01631347f, 0.03315217f, 0.21178173f, 
    0.06431749f, 0.02238852f, -0.01818867f, 0.13730751f, -0.20670958f, 0.37127078f, 0.10016669f, -0.08851315f, 
    0.10630409f, -0.01448828f, -0.03682158f, 0.03313686f, 0.06286319f, 0.10995401f, -0.03289504f, 0.08537640f, 
    0.15612093f, 0.00589111f, -0.04148497f, 0.14026619f, 0.00435077f, -0.00730746f, -0.14831997f, -0.11405392f, 
    -0.07071186f, 0.15330724f, -0.19218038f, 0.19191448f, -0.34424400f, 0.22676064f, 0.03256125f, -0.14653105f, 
    0.01381977f, -0.08488027f, 0.05898539f, 0.11605629f, -0.01445993f, 0.11399981f, -0.00434492f, -0.01905645f, 
    0.33415282f, 0.07087152f, -0.28625375f, -0.01092081f, -0.04935912f, -0.07511717f, 0.00514781f, -0.09380633f, 
    -0.00830517f, -0.07043668f, 0.19942053f, 0.12277418f, 0.03797893f, 0.08928724f, 0.04708865f, 0.06490391f, 
    0.01078930f, -0.05421023f, 0.00012857f, 0.20770375f, 0.17412752f, -0.21520543f, 0.07189042f, -0.01691950f, 
    -0.17366141f, 0.24278776f, 0.20427568f, 0.05759442f, -0.18775110f, -0.05427052f, 0.02222154f, 0.03950486f, 
    0.06638263f, 0.08273521f, -0.01212485f, -0.02688100f, 0.36696595f, 0.20108908f, -0.20452504f, -0.24002247f, 
    -0.00384396f, 0.16691107f, 0.01285581f, 0.14428759f, 0.16035455f, 0.20328532f, -0.01260365f, 0.01556068f, 
    0.25323984f, 0.10848031f, -0.08428854f, -0.11895087f, 0.02900277f, 0.01415507f, 0.01620161f, 0.05992950f, 
    0.09645451f, -0.00402099f, 0.32439452f, -0.00382578f, 0.09549332f, -0.17368288f, 0.14300057f, 0.49478665f, 
    -0.11427546f, 0.06295339f, -0.00711105f, 0.01292334f, 0.21668616f, 0.01997762f, -0.11376449f, 0.06248111f, 
    0.05095916f, 0.03612476f, -0.05243010f, 0.14873293f, 0.00682745f, 0.03711734f, -0.12734073f, -0.04084760f, 
    -0.01650783f, -0.02781884f, 0.19567430f, 0.06071493f, -0.13053241f, 0.20226949f, 0.17976923f, -0.06086574f, 
    0.01903921f, 0.01794554f, -0.01404153f, 0.07316404f, 0.11393485f, 0.05840445f, 0.10245197f, 0.11540104f, 
    -0.36418712f, 0.33361518f, -0.05784751f, 0.27895027f, 0.03115497f, 0.02078780f, 0.14880636f, -0.01586680f, 
    0.04666380f, 0.15959525f, 0.01184988f, 0.05885508f, 0.27828470f, -0.11239951f, -0.24813305f, 0.16277285f, 
    0.05159382f, 0.06563615f, 0.06384560f, 0.05992305f, 0.14265861f, 0.00386250f, 0.08177988f, -0.01005964f, 
    -0.28648025f, 0.00265596f, -0.05913058f, -0.05101665f, -0.05239598f, -0.17350353f, 0.09497548f, -0.00374158f, 
    -0.09921305f, -0.01017823f, 0.07206839f, -0.06640402f, -0.22912580f, -0.06875396f, 0.16955142f, 0.17780715f, 
    0.13420755f, 0.13782868f, 0.10047638f, -0.04593827f, 0.06902898f, 0.03058155f, -0.04714893f, 0.06628012f, 
    -0.29987362f, 0.07432707f, 0.10017790f, 0.20966806f, 0.15187699f, 0.03170668f, -0.00303017f, 0.03350556f, 
    0.07782697f, 0.02942731f, -0.01140544f, 0.00042983f, -0.28976637f, 0.02549861f, 0.10981391f, -0.15731250f, 
    0.05905570f, -0.14231583f, 0.07905951f, -0.11364084f, -0.00394492f, 0.09390625f, -0.10663533f, 0.07632627f, 
    0.08028260f, -0.10303774f, -0.12242755f, 0.01971812f, 0.09701743f, -0.04463261f, 0.15788299f, -0.05519700f, 
    -0.05719609f, -0.02831037f, 0.01892781f, -0.08191038f, 0.13599184f, -0.16818042f, 0.11251521f, 0.35944757f, 
    0.19784972f, 0.01611782f, 0.04868072f, 0.00834837f, 0.05207555f, -0.05572644f, 0.14039475f, 0.05699818f, 
    0.12172276f, 0.19448882f, -0.14481984f, -0.19327971f, -0.02539379f, 0.02638645f, 0.04591154f, 0.03761063f, 
    0.07026222f, 0.01780002f, -0.01305558f, 0.08505974f, 0.35862783f, -0.14046301f, 0.03370376f, 0.45436189f, 
    0.13577147f, 0.07421880f, -0.01218261f, 0.02101409f, 0.05801979f, -0.06418680f, 0.05972943f, 0.06418029f, 
    -0.27036443f, -0.38042361f, -0.01510497f, -0.03058439f, -0.20513813f, -0.16621874f, -0.03973604f, -0.00572677f, 
    -0.01523804f, -0.06115289f, 0.10742822f, -0.05311357f, 0.60267520f, -0.15140255f, -0.06413343f, 0.10641278f, 
    -0.15229018f, -0.01906717f, -0.11009548f, 0.02015940f, 0.04655514f, 0.12418592f, -0.00354899f, -0.03673459f, 
    -0.20947242f, -0.15123524f, -0.01245341f, -0.03810494f, -0.10235133f, 0.06579283f, 0.06883332f, 0.05120366f, 
    -0.10512718f, -0.15456316f, 0.19599484f, 0.07132149f, -0.44735566f, 0.04174960f, 0.10723981f, -0.15319821f, 
    -0.03201852f, -0.04391224f, 0.01196708f, 0.02907818f, -0.03474809f, -0.07360591f, -0.04040581f, 0.01252005f, 
    0.05718324f, 0.10942467f, 0.02831893f, 0.09424168f, -0.04980695f, 0.06030590f, 0.02682878f, 0.00191113f, 
    0.11082937f, -0.07472745f, 0.03960084f, -0.04865225f, 0.34900102f, -0.41196379f, 0.06204137f, 0.28486663f, 
    -0.07052901f, 0.01355339f, -0.09198809f, -0.02626781f, 0.10887045f, -0.07716382f, -0.02856826f, -0.01934218f, 
    -0.30569363f, 0.16639945f, -0.01047029f, 0.05987763f, -0.04935246f, -0.05872438f, -0.00256772f, -0.05525491f, 
    0.10486189f, -0.13745682f, -0.04133850f, 0.00641668f, 0.36220720f, -0.14544462f, 0.03797648f, -0.18295787f, 
    -0.14314532f, 0.11339341f, 0.05595896f, -0.02752669f, -0.02725403f, 0.12630080f, 0.00313704f, 0.03306822f, 
    0.04075520f, -0.04943801f, -0.03257507f, 0.03981164f, 0.01975144f, -0.03612346f, 0.03215279f, -0.00879004f, 
    0.03835411f, -0.04283298f, 0.02023972f, -0.03774235f, 0.01799896f, -0.03095970f, 0.01476393f, 0.01720181f, 
    0.03119492f, -0.01311869f, -0.00945523f, -0.02068403f, -0.00743160f, -0.00904216f, -0.01279631f, -0.00065322f, 
    0.02979174f, -0.04246403f, 0.04573666f, -0.03078447f, 0.03770116f, -0.03533258f, 0.04132953f, -0.05019954f, 
    0.01786723f, -0.00619460f, -0.02622968f, 0.03604707f, 0.00509026f, 0.01837605f, -0.05387335f, 0.00553879f, 
    0.00373918f, -0.05150834f, 0.00764295f, 0.01725767f, -0.02384861f, -0.04794087f, 0.03265342f, -0.01262006f, 
    -0.04357716f, -0.01388714f, -0.05483342f, 0.01966509f, 0.02527828f, -0.00315678f, -0.05027908f, -0.03505037f, 
    -0.04446890f, 0.00203182f, 0.01054844f, 0.01396426f, 0.01713191f, -0.02627905f, 0.00233190f, -0.02804414f, 
    -0.01927728f, -0.02257596f, 0.04051353f, -0.01210186f, 0.00437135f, 0.04084416f, -0.02887177f, -0.02898521f, 
    0.04815017f, -0.02226780f, 0.02832876f, -0.03443659f, 0.04675824f, -0.04382228f, 0.02648198f, -0.00577792f, 
    0.01770899f, 0.01437593f, -0.04276196f, 0.00183181f, -0.01068250f, -0.03759422f, -0.05083182f, -0.01067754f, 
    0.00394090f, -0.00670733f, 0.05234010f, -0.03298228f, -0.02428334f, -0.03102177f, -0.01243227f, -0.04768159f, 
    0.03909023f, -0.03893374f, -0.04636842f, 0.01664141f, -0.05629735f, -0.00368524f, -0.01232766f, 0.00986531f, 
    0.01485462f, -0.02145880f, 0.02424882f, 0.00146146f, 0.03020906f, -0.01761079f, -0.04314229f, -0.03950077f, 
    0.03074265f, 0.02841002f, 0.04285518f, 0.00902088f, 0.03215194f, -0.00375870f, -0.05197334f, -0.00777634f, 
    0.01181057f, -0.04927959f, 0.00284990f, 0.02759264f, 0.02841396f, 0.00098200f, -0.00603417f, 0.03000186f, 
    -0.04903064f, 0.03311795f, -0.01435466f, -0.02122514f, 0.02596634f, 0.02537548f, 0.01635171f, -0.02535713f, 
    -0.02890317f, -0.02929314f, 0.00371435f, 0.03737039f, -0.04213103f, -0.01951221f, -0.01462538f, 0.01195508f, 
    0.01678777f, -0.04346319f, -0.05113288f, -0.00058538f, 0.03265227f, 0.04560719f, -0.01962339f, -0.02666326f, 
    -0.02793154f, -0.00963246f, -0.00899751f, 0.02345453f, -0.04490522f, 0.01807439f, 0.03173386f, -0.03320693f, 
    -0.04883121f, -0.02117030f, -0.00782942f, 0.01120645f, 0.04255014f, 0.04334781f, 0.01700001f, -0.04777525f, 
    0.03475927f, -0.01724226f, 0.03786575f, -0.01039001f, -0.02073671f, 0.02303802f, -0.04143640f, 0.02094271f, 
    -0.01398512f, 0.02384810f, -0.05747448f, 0.03373762f, 0.02432321f, 0.01091452f, -0.04060795f, -0.01279705f, 
    0.03247225f, -0.03050070f, -0.02796978f, -0.04543064f, 0.01343872f, -0.01784038f, 0.00030503f, -0.01921352f, 
    -0.03901300f, -0.03480386f, -0.06127991f, 0.02585096f, -0.02832473f, 0.02718097f, 0.03091867f, 0.00402569f, 
    -0.04869572f, 0.02541500f, 0.02172747f, -0.02439531f, -0.01553647f, -0.00071699f, -0.03421753f, 0.00547110f, 
    -0.00301953f, -0.04153349f, -0.03933068f, -0.01200968f, -0.02349645f, -0.04700128f, 0.00975667f, 0.00865099f, 
    -0.04904339f, -0.01604263f, 0.01553367f, -0.02468332f, 0.03313581f, 0.01751726f, -0.04706728f, 0.01967105f, 
    0.00407096f, -0.03216407f, -0.02516405f, -0.05325153f, 0.01218467f, -0.01826316f, -0.03624210f, 0.03231768f, 
    0.01317490f, 0.03642831f, -0.00169255f, -0.04427454f, 0.00230985f, -0.02853651f, -0.04231573f, -0.00251231f, 
    -0.00432384f, 0.00198184f, 0.02373476f, 0.02149587f, 0.00329847f, -0.05522966f, -0.00904077f, -0.00582800f, 
    0.03461540f, 0.04137921f, 0.00336192f, 0.00405324f, 0.01757067f, -0.02470658f, -0.01720498f, 0.01845084f, 
    0.04566738f, 0.04835615f, -0.03399297f, -0.01008602f, -0.03133429f, 0.02377811f, -0.05429390f, 0.03836699f, 
    -0.04750918f, -0.03689641f, -0.01646804f, 0.02898031f, -0.03246715f, -0.01598933f, 0.03787785f, -0.03858590f, 
    0.00577135f, -0.03358934f, 0.00351578f, -0.03552553f, 0.03091853f, -0.02524954f, 0.02942840f, -0.03250624f, 
    0.04013094f, 0.04327014f, 0.03757561f, -0.04458743f, -0.03349930f, -0.05049593f, -0.04426711f, -0.00801364f, 
    -0.00786397f, 0.00844285f, -0.01480884f, -0.04031077f, -0.04017175f, 0.03664852f, 0.01708888f, -0.03745034f, 
    0.03715460f, 0.02309276f, -0.00265689f, -0.04325998f, -0.00762162f, -0.02938993f, 0.01603889f, -0.02059608f, 
    0.03488832f, -0.03915049f, -0.00796531f, 0.03462099f, -0.04559605f, 0.04783043f, -0.01732014f, 0.04223553f, 
    0.00892625f, 0.03157880f, 0.01354628f, 0.01129189f, 0.01881694f, -0.02425789f, -0.01318497f, -0.04630189f, 
    -0.00342784f, -0.03700270f, 0.00441915f, -0.05097885f, 0.03112319f, 0.00617380f, 0.01779893f, -0.00778567f, 
    0.03238880f, -0.03524218f, 0.02643072f, 0.02516708f, 0.01924210f, 0.03156597f, 0.03817806f, 0.00731596f, 
    -0.00348947f, 0.02592743f, -0.01437022f, -0.03172695f, 0.04055810f, -0.03614987f, -0.00225058f, 0.02741019f, 
    -0.01556478f, 0.02037858f, -0.05078307f, 0.01165456f, 0.04974217f, -0.00170597f, 0.04543554f, 0.02984342f, 
    -0.00894840f, -0.02230440f, -0.01708705f, -0.02507021f, -0.05504691f, 0.01152632f, 0.00843066f, -0.05232207f, 
    -0.03860181f, 0.02034878f, 0.03486536f, 0.02394496f, -0.00904820f, -0.01092835f, 0.00186265f, -0.01053357f, 
    0.02372312f, -0.04530794f, -0.00846597f, -0.01759503f, -0.01499496f, -0.05153842f, -0.00466335f, -0.00973465f, 
    -0.01591635f, 0.04288202f, -0.01613230f, -0.03775939f, -0.02789042f, -0.02561843f, -0.01579926f, -0.00458674f, 
    -0.00701007f, 0.00023982f, -0.03023981f, -0.01164775f, 0.02024785f, -0.00658349f, -0.02822361f, 0.02444759f, 
    -0.02490360f, 0.02673241f, -0.04593422f, 0.01142312f, 0.00204740f, -0.03004851f, 0.03911136f, -0.05387843f, 
    -0.00601667f, 0.01383822f, 0.00414590f, 0.00920853f, -0.01507144f, -0.05089543f, -0.04388015f, -0.05447481f, 
    0.03141264f, 0.03988733f, -0.00009864f, -0.01675345f, 0.02362422f, -0.04655209f, 0.01089489f, -0.05216105f, 
    -0.05546995f, -0.01672819f, -0.01745772f, 0.04231842f, 0.00130068f, 0.03761118f, 0.04265303f, -0.00782596f, 
    0.03940653f, -0.03148615f, -0.05490093f, 0.03370094f, 0.00611683f, -0.05415826f, -0.03002601f, 0.00468274f, 
    0.01292798f, -0.00523533f, -0.00954805f, 0.02182642f, 0.02083744f, -0.00770296f, 0.03092761f, 0.02515821f, 
    -0.04673425f, -0.01089736f, -0.04330349f, 0.01002963f, 0.03051570f, 0.01349068f, 0.01922472f, -0.04134897f, 
    0.03156878f, 0.01867809f, -0.01659684f, -0.02927957f, -0.01789605f, -0.02898749f, 0.03697414f, -0.04408633f, 
    -0.04364362f, 0.04155933f, 0.01935147f, 0.00157722f, 0.01161420f, 0.00088552f, -0.02290493f, -0.05594007f, 
    0.00122673f, -0.00400297f, -0.03611992f, -0.01265771f, 0.04414221f, -0.05015437f, -0.04610851f, 0.00334913f, 
    -0.01232592f, 0.02222731f, -0.02552680f, -0.02747688f, -0.05533115f, 0.04162135f, -0.01153734f, -0.01484268f, 
    -0.04966915f, -0.01293442f, -0.03035196f, 0.01046869f, -0.04848226f, 0.01500546f, -0.01585164f, 0.00235163f, 
    -0.01920127f, -0.02080597f, -0.01071229f, -0.05476948f, -0.04408366f, 0.01615956f, 0.00306675f, -0.04304076f, 
    -0.01032639f, -0.03942439f, 0.03255484f, -0.01434736f, 0.01778837f, 0.02006076f, 0.03789501f, -0.05442062f, 
    -0.02812721f, 0.02975950f, -0.02280893f, 0.01088174f, -0.02737443f, -0.03413967f, 0.00772144f, -0.02569873f, 
    0.03137137f, 0.01229196f, 0.00499249f, -0.01416715f, -0.04136324f, -0.03465788f, -0.04081747f, 0.03316307f, 
    0.03173064f, -0.02947974f, -0.00049123f, -0.02540056f, 0.01767445f, -0.04849577f, -0.02980188f, 0.01484691f, 
    0.01319561f, 0.01866463f, -0.04873738f, -0.03157817f, -0.03712482f, 0.00875320f, -0.03498884f, 0.02355249f, 
    -0.00387492f, -0.03993739f, 0.02498481f, -0.03510975f, 0.03563288f, 0.03388989f, -0.00783821f, -0.00116378f, 
    0.00471519f, -0.04769006f, -0.00545016f, 0.03884944f, -0.03146004f, -0.03180993f, -0.03531552f, 0.02479306f, 
    0.03068110f, 0.03464288f, -0.03891641f, 0.01571923f, 0.00355327f, -0.02654964f, -0.00245793f, -0.03174290f, 
    -0.04299955f, 0.04152706f, -0.01728220f, -0.02538124f, -0.04272877f, 0.04419669f, -0.01879737f, -0.00239334f, 
    0.02583177f, 0.02419916f, -0.00383168f, -0.01832332f, 0.03184277f, -0.03617530f, -0.00743757f, -0.05464996f, 
    0.02083456f, 0.01973703f, 0.00603200f, 0.03266465f, -0.01578574f, -0.04987933f, -0.04344606f, -0.05654636f, 
    -0.05483014f, 0.02821962f, -0.03418482f, 0.01910276f, -0.00286107f, 0.03284292f, 0.02529098f, -0.04389919f, 
    0.03811426f, -0.01472182f, 0.00464898f, -0.04904366f, -0.04807421f, 0.00414822f, 0.03448136f, -0.01061114f, 
    0.02524157f, -0.04893401f, 0.02583144f, -0.02685324f, 0.01900922f, 0.01773165f, -0.01097060f, -0.05103824f, 
    -0.01028137f, 0.02612799f, 0.02103274f, -0.04171691f, -0.05277608f, 0.01440898f, -0.01292905f, 0.04155910f, 
    -0.02374468f, 0.04463388f, 0.02903471f, -0.00622942f, -0.01177487f, -0.02083279f, 0.03703688f, 0.02068234f, 
    -0.02867331f, -0.00023320f, 0.03502780f, -0.01702171f, -0.00861033f, -0.01082374f, 0.02400932f, -0.02752958f, 
    -0.04664322f, -0.01403713f, -0.04266134f, -0.00122054f, -0.03647798f, -0.02863781f, -0.02711857f, -0.05655228f, 
    0.03141392f, -0.04645987f, -0.05169789f, -0.00963155f, -0.03388920f, 0.03955361f, -0.00113556f, -0.03790247f, 
    -0.05540140f, -0.04178052f, -0.01276214f, -0.04464429f, -0.02962401f, -0.04795369f, -0.04256299f, 0.01446659f, 
    0.01997489f, 0.01839242f, 0.02667681f, 0.02356865f, -0.02816181f, 0.01932278f, -0.03161486f, -0.05063846f, 
    -0.03025631f, -0.02650025f, 0.03924371f, 0.03746080f, 0.00592475f, -0.00355734f, -0.01576318f, -0.04758060f, 
    -0.02932201f, -0.02677536f, 0.03368036f, -0.03554808f, 0.00265939f, 0.02058592f, 0.01351708f, -0.04786520f, 
    -0.05150728f, 0.01789576f, -0.01239016f, -0.01601874f, -0.04157820f, 0.01191952f, 0.04080500f, -0.00075465f, 
    0.03003515f, -0.02392667f, -0.02206382f, 0.00111232f, -0.02825274f, -0.04633393f, 0.03918007f, -0.00677797f, 
    0.01502272f, -0.05180263f, -0.00674620f, -0.02274258f, -0.05380702f, 0.03516527f, -0.05312435f, -0.00144728f, 
    -0.04772964f, 0.00344539f, -0.01699458f, 0.01334537f, -0.00858620f, 0.04028353f, -0.04666007f, -0.05465152f, 
    0.01585454f, -0.03791119f, 0.02790544f, 0.00192528f, -0.04141756f, -0.04958009f, 0.00610023f, 0.00294941f, 
    0.00668054f, 0.02091042f, 0.02547027f, 0.00925662f, 0.01925391f, -0.05279462f, 0.03150181f, 0.04450867f, 
    -0.01453083f, 0.00860742f, 0.00276562f, -0.04556007f, 0.01242904f, 0.01690134f, -0.01791558f, -0.02190289f, 
    -0.02502008f, 0.03929080f, -0.03645067f, 0.03341649f, -0.01220886f, 0.03624214f, 0.00726615f, 0.00160776f, 
    -0.01029143f, 0.00732297f, 0.02980457f, 0.02489328f, -0.02085230f, 0.04299033f, -0.01251457f, -0.03295109f, 
    0.00303382f, 0.01799322f, -0.02834797f, -0.01861478f, 0.02169345f, -0.01627426f, -0.04182026f, -0.04687858f, 
    -0.04359771f, -0.02717396f, -0.01783617f, -0.01795180f, 0.04207498f, 0.00304265f, -0.01206448f, 0.01921295f, 
    -0.04660135f, 0.00013539f, -0.06507643f, -0.03472086f, 0.06855109f, 0.05406358f, 0.13438077f, -0.02780234f, 
    0.20384847f, -0.07573765f, 0.07562121f, -0.06770997f, -0.47026184f, -0.04327826f, 0.03734441f, -0.02726670f, 
    0.07260972f, 0.00185654f, 0.11646900f, 0.06568835f, 0.07301840f, -0.06228128f, -0.00442069f, 0.07258382f, 
    -0.21795642f, -0.01289631f, -0.16322559f, 0.00222645f, 0.10071650f, 0.04612145f, -0.00626190f, 0.07206924f, 
    0.09681685f, -0.07082322f, -0.04699338f, -0.03806655f, -0.14759995f, 0.08210088f, 0.04817739f, 0.17156406f, 
    -0.05394529f, -0.02367306f, 0.00558643f, 0.18147384f, -0.06557643f, 0.05190727f, 0.05215025f, -0.02611542f, 
    0.21314879f, -0.21228172f, 0.01020906f, -0.26093355f, 0.02639536f, 0.00473783f, 0.00909843f, -0.16124278f, 
    -0.12808867f, 0.05174485f, -0.06364736f, 0.10723789f, 0.02478421f, 0.07808809f, 0.03282323f, -0.22305380f, 
    0.05956779f, 0.01617803f, -0.05141647f, 0.19875944f, -0.08126920f, 0.11147400f, 0.15912303f, 0.15080142f, 
    0.32880706f, -0.06196918f, -0.01311302f, 0.04616287f, -0.02283124f, 0.11403169f, -0.12281471f, -0.02499251f, 
    -0.00760297f, -0.07248420f, -0.05191853f, -0.01399719f, 0.03166785f, -0.12077823f, -0.02148903f, 0.19161898f, 
    -0.12302696f, 0.00510407f, 0.13813210f, 0.16328369f, 0.03351695f, 0.03342266f, -0.05577537f, 0.06533824f, 
    -0.17593504f, 0.43170223f, -0.08736296f, 0.04346475f, -0.01119621f, -0.01994311f, 0.08942516f, 0.07535689f, 
    0.16187772f, -0.10975049f, 0.05082544f, -0.06284295f, -0.01919819f, 0.27291200f, 0.28736866f, -0.09906558f, 
    -0.03758449f, -0.01790662f, 0.16529058f, -0.03758086f, -0.06778897f, -0.11099242f, 0.09998415f, 0.04963706f, 
    -0.25507584f, -0.12421126f, -0.04561665f, -0.11291862f, -0.03631552f, 0.24040380f, -0.12617213f, -0.06224702f, 
    0.21481699f, -0.02143108f, 0.14674057f, 0.15216412f, 0.35297358f, 0.07430710f, 0.25064942f, 0.26102570f, 
    0.02114184f, -0.03958068f, -0.00426318f, 0.02946056f, 0.16413282f, 0.00979405f, -0.03741436f, 0.11984963f, 
    0.12769635f, -0.22869879f, 0.06349845f, 0.15683150f, 0.09194066f, 0.06995771f, 0.07440409f, 0.15890639f, 
    -0.08824471f, -0.11008044f, 0.00256452f, 0.05770386f, 0.24481964f, 0.17422426f, -0.07945494f, 0.09405033f, 
    -0.21260192f, -0.12447654f, 0.06115865f, -0.06608947f, -0.00580100f, 0.17063379f, 0.11848900f, 0.15867479f, 
    0.32014915f, 0.29995990f, 0.04414773f, 0.03302914f, -0.12290490f, -0.00971511f, 0.00816377f, -0.04795343f, 
    0.06524860f, 0.04850423f, 0.01727675f, -0.15392892f, 0.28529596f, 0.20199929f, 0.31214839f, 0.01635355f, 
    -0.09643725f, -0.01256116f, 0.01215679f, -0.12036499f, 0.16603851f, -0.13373099f, 0.01297158f, 0.02396912f, 
    -0.27787542f, -0.08334783f, -0.27490079f, -0.22389056f, 0.18189418f, 0.08146110f, 0.11573184f, -0.06569752f, 
    0.05779366f, -0.05721277f, 0.16497976f, 0.00919255f, 0.10713957f, 0.14194793f, -0.06529226f, 0.19423690f, 
    0.04743064f, -0.03792311f, 0.05543726f, -0.06393617f, -0.02650610f, -0.02896471f, 0.12618248f, 0.22823381f, 
    -0.03078097f, -0.10238947f, -0.02995645f, 0.13507770f, -0.12549929f, -0.11901109f, 0.05246984f, 0.10374064f, 
    0.16961700f, 0.24004240f, 0.21540515f, 0.29653794f, -0.74385357f, 0.37961459f, -0.18118548f, -0.10526814f, 
    0.20482229f, 0.19072752f, -0.03691701f, 0.02510853f, 0.21565086f, 0.06981754f, -0.04368295f, 0.17630965f, 
    -0.14733203f, 0.24031323f, -0.06012660f, 0.00560241f, 0.14519162f, 0.05808280f, 0.18340991f, 0.09520864f, 
    -0.10102103f, -0.00870490f, -0.08459590f, -0.00383528f, 0.16220765f, 0.33796337f, 0.17195529f, 0.16167964f, 
    -0.04849217f, 0.06603913f, 0.07443101f, -0.06596657f, -0.00951180f, -0.09677821f, 0.16633533f, 0.09653188f, 
    0.14030336f, -0.13717040f, 0.00766693f, -0.19753544f, 0.20972188f, 0.19254071f, 0.08119839f, 0.04739273f, 
    0.03070141f, 0.08064090f, 0.09075252f, -0.09219030f, 0.62934148f, 0.07182284f, 0.13173038f, 0.32079506f, 
    0.03949733f, -0.09375271f, 0.02021956f, 0.01723392f, 0.21206550f, 0.01797440f, -0.04816273f, 0.02364586f, 
    -0.39015540f, -0.01045134f, -0.36447474f, 0.12421077f, 0.22225696f, 0.16615017f, 0.03273205f, -0.08393641f, 
    0.10195025f, -0.03278538f, -0.03094043f, -0.01845255f, 0.48931357f, -0.07527456f, 0.04813643f, 0.25051630f, 
    0.03744327f, 0.01388352f, -0.11414707f, 0.08596981f, -0.00827861f, -0.12478793f, 0.12528110f, -0.09420349f, 
    -0.56004149f, 0.07617598f, -0.02184294f, -0.14412288f, 0.10857520f, 0.02911274f, -0.01646371f, -0.10566264f, 
    0.10891677f, 0.03460704f, 0.02363578f, -0.06680317f, 0.42606312f, -0.11274971f, 0.12833673f, 0.03109455f, 
    0.12482256f, 0.09787767f, -0.05548712f, -0.04409160f, -0.03310357f, 0.11982127f, -0.03862090f, -0.05899343f, 
    0.35875174f, 0.06886655f, 0.17719482f, 0.04061686f, 0.01604241f, 0.01181940f, 0.06699613f, 0.03191525f, 
    0.12713203f, 0.03229353f, 0.00357194f, -0.00255845f, 0.42624000f, -0.14121442f, 0.05862278f, 0.33659354f, 
    0.15203339f, 0.01636106f, 0.03216625f, 0.07632317f, 0.11096266f, 0.12338909f, -0.05831748f, 0.03878826f, 
    -0.23829126f, 0.03117887f, -0.03946119f, 0.04646058f, 0.09208900f, 0.06031615f, 0.01702900f, 0.13456780f, 
    0.06397099f, -0.09364267f, -0.03469302f, -0.04829323f, 0.00702460f, 0.05104849f, 0.09843563f, -0.11435591f, 
    0.00536152f, 0.11243979f, 0.11742093f, 0.07540021f, 0.04756170f, -0.03940400f, -0.03102565f, -0.14940070f, 
    -0.13801423f, 0.01158637f, -0.11511283f, -0.05112489f, 0.05502674f, 0.08785914f, -0.00420452f, -0.09242886f, 
    0.12153986f, 0.21337648f, -0.12378056f, -0.07299599f, 0.03935332f, 0.01723214f, -0.15673383f, -0.13343665f, 
    0.00800045f, -0.01507388f, 0.14171083f, -0.12403783f, 0.07209463f, 0.04216448f, 0.19799756f, -0.00098584f, 
    -0.12469458f, -0.02496267f, -0.00754407f, -0.13465221f, 0.00061033f, 0.07028217f, 0.06078205f, 0.06754060f, 
    0.00911516f, -0.01461997f, 0.06680490f, 0.07337196f, -0.28904462f, 0.29498962f, -0.19531019f, 0.03868651f, 
    0.00512038f, 0.11344646f, 0.01975528f, 0.23408505f, -0.00499806f, 0.11944424f, -0.02750068f, -0.00568345f, 
    0.28864464f, -0.38396984f, 0.03234234f, -0.03875101f, -0.19651935f, -0.04690252f, 0.18530445f, 0.04684678f, 
    0.04478575f, -0.07386078f, -0.12345661f, 0.03876600f, -0.25629866f, -0.16537230f, 0.00802532f, -0.10569499f, 
    -0.06780402f, 0.05493360f, 0.11050227f, 0.14458042f, 0.06204622f, 0.07218138f, -0.16135879f, 0.13337901f, 
    0.09130360f, 0.17144562f, 0.21370640f, 0.22192013f, -0.12061153f, 0.01333371f, 0.05469987f, -0.05490419f, 
    0.02012463f, 0.05724512f, 0.09416691f, -0.00882958f, 0.04092553f, 0.05404788f, -0.07197132f, 0.18311188f, 
    0.06856551f, -0.00413748f, -0.00607756f, 0.10576309f, -0.15656415f, 0.08108812f, -0.00554183f, 0.07213017f, 
    0.18134572f, -0.03597753f, 0.01385500f, -0.12610060f, -0.01310762f, -0.10972279f, -0.06411409f, 0.16373841f, 
    0.05381044f, -0.00736908f, -0.02602345f, 0.10919794f, -0.24420117f, -0.04633018f, -0.04108962f, 0.13759649f, 
    0.08073287f, 0.04118955f, 0.13934481f, 0.10666477f, -0.03301458f, -0.00887354f, 0.06645669f, 0.10859159f, 
    0.18483309f, 0.03237714f, 0.05470772f, 0.16306524f, 0.01001908f, 0.02552965f, 0.04142003f, -0.06673051f, 
    0.06433421f, 0.11513934f, 0.09533658f, 0.15458810f, 0.35818118f, -0.22002140f, 0.43478099f, -0.15592778f, 
    -0.20539623f, 0.03981284f, 0.04341525f, 0.19351324f, 0.11692027f, 0.06240051f, 0.01484967f, 0.17927375f, 
    0.12991850f, -0.25572431f, -0.09685076f, -0.09013858f, -0.01452821f, 0.02024791f, 0.09291553f, -0.06222301f, 
    0.01752773f, 0.07507093f, -0.02582097f, 0.05142428f, -0.19997917f, 0.38759199f, 0.05214886f, 0.02774641f, 
    -0.20086429f, -0.10308663f, -0.12656650f, 0.05800842f, 0.11176980f, 0.07818741f, 0.11622164f, 0.04793423f, 
    -0.11899479f, 0.38514760f, 0.27506411f, -0.35101107f, -0.07352369f, 0.23383965f, 0.02027522f, 0.00526399f, 
    0.00826494f, -0.01475846f, 0.01354156f, 0.02970277f, -0.37247336f, 0.20498562f, 0.07244650f, 0.16952758f, 
    0.03562568f, 0.00500612f, 0.12757570f, 0.06335012f, -0.08687265f, -0.02099141f, -0.00890269f, 0.03063439f, 
    -0.17288648f, -0.19925191f, 0.07621181f, -0.41280866f, 0.22180252f, 0.11023171f, 0.12274599f, -0.00481954f, 
    0.03555622f, -0.12417255f, -0.08496890f, 0.02930607f, 0.09882829f, 0.48551980f, 0.18351661f, 0.03002205f, 
    -0.09355875f, -0.00002099f, 0.10738493f, 0.01659773f, 0.03807542f, -0.05516720f, 0.01708890f, 0.03312466f, 
    0.50558859f, 0.07415710f, -0.03072765f, -0.05930045f, -0.03798111f, 0.05254661f, 0.00325946f, 0.02504956f, 
    -0.11807371f, -0.09279300f, 0.06787005f, 0.17257179f, -0.05251586f, 0.11884283f, -0.09235281f, 0.14499050f, 
    0.16813479f, 0.22982042f, 0.03034600f, 0.02841174f, 0.12613234f, -0.05430214f, 0.00962490f, 0.08987275f, 
    0.46455038f, -0.10429075f, -0.00688241f, -0.11517069f, -0.05448036f, 0.07717126f, 0.06982132f, -0.06239454f, 
    0.06529634f, 0.16040446f, 0.04722506f, 0.11057791f, 0.02801817f, 0.33660507f, 0.26649410f, 0.05457758f, 
    -0.04160261f, 0.12423513f, 0.03499724f, 0.06337688f, 0.07986265f, 0.04153998f, 0.01815537f, -0.04244374f, 
    0.01930372f, 0.08149073f, 0.01081441f, -0.00301377f, -0.04321098f, 0.04393033f, 0.08166181f, 0.01881140f, 
    0.11615688f, 0.07605425f, -0.10157165f, -0.07464071f, 0.13430098f, 0.15541670f, 0.30238217f, 0.15385632f, 
    -0.20464844f, -0.02746788f, 0.13737589f, 0.09236223f, 0.01400734f, 0.07358090f, 0.12349465f, 0.07975971f, 
    -0.18994097f, -0.24355109f, -0.25377229f, -0.26537743f, -0.10974143f, -0.09791291f, 0.10390126f, -0.15497343f, 
    0.06354144f, 0.00107536f, 0.09922018f, 0.06147049f, 0.11968245f, -0.21067625f, 0.09380461f, 0.18978921f, 
    0.00124682f, -0.11315394f, -0.06427338f, 0.15587954f, -0.03937305f, 0.07005464f, -0.05582404f, 0.10997655f, 
    0.03314047f, -0.09623061f, -0.26082233f, -0.09397724f, -0.03563917f, 0.14245073f, 0.07386715f, 0.09073367f, 
    0.06381302f, -0.06944233f, 0.07151107f, -0.02976619f, 0.28556359f, -0.08283062f, -0.22796249f, -0.14784345f, 
    0.01020879f, 0.01650107f, -0.09821128f, -0.17881136f, 0.09253765f, 0.06057885f, -0.11471281f, -0.05749179f, 
    -0.15759395f, 0.15864116f, 0.18671404f, -0.02143131f, -0.12173082f, 0.00655579f, 0.00816693f, 0.08203118f, 
    0.10418215f, 0.04126677f, 0.10222632f, 0.06701018f, 0.26320377f, -0.38464212f, 0.43296051f, 0.08171365f, 
    -0.06864052f, -0.03753857f, -0.01142399f, 0.08184646f, 0.17918777f, -0.01653825f, 0.02098930f, -0.02318092f, 
    0.13715860f, -0.11210447f, -0.25950068f, -0.28509450f, -0.05706115f, -0.03027490f, 0.07381915f, -0.04612359f, 
    0.12501864f, 0.01238864f, 0.07294305f, 0.09521089f, 0.19353649f, -0.19843189f, -0.02585504f, -0.02044438f, 
    0.07826653f, 0.08103167f, 0.03147609f, 0.07120559f, 0.06876564f, 0.16862953f, -0.00532038f, -0.08550891f, 
    0.03610371f, -0.03508665f, 0.01474142f, 0.00392417f, -0.00651124f, 0.01814178f, -0.04103717f, -0.01914505f, 
    -0.01832832f, 0.04135408f, -0.01635378f, -0.03074829f, 0.00237071f, 0.02871213f, 0.02973757f, -0.01584760f, 
    0.01774668f, -0.01967516f, 0.04348126f, 0.03332257f, -0.02952858f, 0.03951884f, -0.04546903f, -0.03078596f, 
    0.04250696f, 0.01926465f, 0.03209465f, 0.02522025f, -0.01025064f, -0.00291149f, 0.04419348f, -0.01009195f, 
    0.01643569f, -0.02148824f, -0.04258329f, 0.01055304f, 0.03752979f, 0.03151140f, -0.04847050f, 0.02219601f, 
    -0.04160588f, 0.03841873f, -0.02335329f, 0.02397877f, 0.04181935f, 0.03511802f, -0.00678723f, -0.05354736f, 
    -0.03858538f, -0.00312976f, -0.05733790f, 0.01940547f, -0.05573504f, -0.00724031f, -0.05109633f, 0.03191605f, 
    0.04159776f, 0.02897542f, 0.01902366f, -0.05517038f, 0.00320898f, -0.03932380f, -0.00863647f, -0.00798606f, 
    -0.03116208f, -0.01573801f, 0.03399290f, -0.00699609f, -0.01739300f, -0.02313920f, 0.03238740f, -0.01497140f, 
    0.01104947f, -0.00932531f, -0.01552533f, 0.01320226f, -0.01770091f, -0.04813567f, -0.01757443f, -0.01700998f, 
    -0.03866742f, 0.03662392f, -0.02208002f, -0.00460650f, -0.02730040f, 0.01551313f, -0.00644066f, -0.00412693f, 
    -0.02318413f, 0.03474653f, 0.00892427f, -0.04668959f, -0.00942180f, 0.00514388f, -0.05521690f, -0.03317330f, 
    -0.02590984f, 0.03110647f, -0.04156527f, 0.02040823f, -0.00270247f, 0.01900797f, 0.03061553f, -0.00166469f, 
    0.01074913f, -0.00962755f, -0.01155390f, -0.02690113f, 0.02949147f, -0.01646390f, -0.02480339f, -0.03326307f, 
    0.00619209f, 0.04656184f, -0.04407953f, -0.01829740f, -0.00629937f, -0.05103574f, 0.01515401f, -0.01299216f, 
    -0.03625114f, -0.05108183f, -0.03305031f, 0.03579042f, -0.01989994f, 0.04612245f, 0.00787724f, -0.02998519f, 
    -0.04080118f, -0.04234898f, -0.00981626f, -0.01693239f, 0.01876534f, -0.02559094f, -0.01459248f, 0.02875610f, 
    -0.03853391f, -0.02097838f, 0.03842188f, -0.00938724f, -0.04347004f, -0.01331321f, -0.00681377f, -0.01898127f, 
    -0.00190647f, 0.01331557f, -0.04588615f, 0.03251025f, 0.01243363f, 0.00297209f, 0.02644906f, 0.01288002f, 
    -0.04044686f, 0.04313720f, 0.00732904f, 0.02677138f, -0.03591496f, 0.01335754f, 0.04250957f, 0.03512383f, 
    -0.01626355f, -0.04705675f, -0.05283005f, 0.04166165f, -0.04686258f, -0.05256095f, -0.00812443f, 0.01790054f, 
    0.00804380f, 0.01828154f, -0.03115573f, 0.01096979f, -0.03546290f, 0.02012840f, 0.00048463f, 0.02432657f, 
    0.02948312f, 0.04152538f, -0.02610284f, -0.01594524f, 0.01005683f, 0.03090543f, -0.01241378f, -0.04387588f, 
    -0.02021386f, 0.01964835f, 0.02440054f, -0.02410853f, 0.01807598f, 0.03059953f, -0.00915844f, -0.04346009f, 
    -0.04922856f, 0.01416201f, 0.04243635f, 0.02006195f, -0.01291002f, 0.02744643f, -0.04656353f, -0.03395402f, 
    0.02703763f, 0.04097141f, -0.00415402f, -0.04260031f, -0.01795692f, -0.00249182f, -0.00041312f, 0.00589497f, 
    -0.05392544f, -0.05102668f, -0.01770873f, 0.03814956f, -0.01166587f, -0.01796787f, -0.04996424f, -0.03548097f, 
    -0.04261407f, -0.03489011f, 0.04237621f, -0.00003294f, 0.02707874f, -0.01670755f, -0.03839586f, -0.03762374f, 
    -0.02668780f, -0.00235927f, 0.01423330f, -0.05267991f, -0.00250340f, 0.02130129f, 0.03941843f, -0.02799175f, 
    0.03437283f, 0.02891743f, -0.03435453f, -0.01127814f, 0.01447459f, 0.00331140f, 0.01485663f, 0.00243024f, 
    -0.00754878f, -0.03113297f, -0.05132946f, -0.02460573f, 0.02114528f, -0.02833076f, -0.03113141f, 0.02740950f, 
    0.04190791f, 0.02292816f, -0.00667413f, -0.03016344f, 0.03378482f, -0.01315472f, 0.04283820f, 0.03011302f, 
    0.01870934f, 0.04047000f, -0.05241130f, 0.02208351f, 0.04480730f, 0.00454924f, 0.00744873f, -0.04962548f, 
    -0.02107879f, -0.01689647f, -0.01905341f, -0.00436344f, 0.02654846f, 0.03438072f, -0.05115687f, -0.01549939f, 
    0.01773960f, -0.01629179f, -0.03183138f, -0.02608408f, -0.02216815f, -0.00561976f, 0.01157716f, 0.00532981f, 
    0.01894863f, -0.02918167f, 0.04758963f, 0.03475400f, 0.01814496f, -0.01589544f, 0.01876965f, 0.03878926f, 
    -0.04334150f, -0.03841807f, -0.03086077f, -0.01411182f, -0.03784878f, -0.00509811f, 0.04662859f, 0.04887693f, 
    0.00165563f, 0.00835170f, -0.02977609f, -0.02696556f, -0.03223929f, 0.03706887f, -0.04531687f, 0.02165005f, 
    -0.03405515f, 0.01676786f, -0.02686493f, -0.01833342f, -0.04023255f, 0.00915195f, 0.02675557f, 0.01970782f, 
    -0.04874368f, -0.01741353f, 0.02081279f, -0.01940845f, 0.04195933f, -0.02011404f, -0.04947469f, -0.04481428f, 
    -0.04674477f, 0.03818836f, -0.04491156f, 0.01955372f, -0.00655441f, -0.02177562f, -0.03027757f, -0.00794918f, 
    0.03382305f, -0.04774166f, -0.04440900f, -0.04918952f, -0.04065205f, -0.04321743f, 0.04383576f, -0.01773381f, 
    -0.04150927f, 0.04113518f, 0.01325096f, 0.00696819f, 0.00399860f, -0.04787731f, -0.05308060f, -0.02473630f, 
    -0.03555128f, 0.02928829f, -0.02577825f, -0.05326945f, -0.01957477f, -0.02728810f, -0.02187249f, 0.00274893f, 
    0.00432829f, 0.01037976f, 0.02963535f, 0.00660524f, -0.02921772f, 0.03077558f, 0.03643730f, -0.02773073f, 
    -0.04865349f, 0.01982155f, -0.00860391f, -0.04947756f, 0.00042592f, -0.03929118f, -0.01529222f, -0.05027510f, 
    0.00968463f, 0.02594435f, -0.05715237f, -0.03545436f, 0.00257484f, 0.00805055f, 0.03312930f, -0.02732264f, 
    0.00393930f, -0.02528969f, 0.00628963f, -0.03747943f, 0.04602125f, -0.04905669f, -0.02964051f, 0.04359298f, 
    0.03049411f, 0.03499563f, -0.03001034f, -0.02435062f, -0.02217152f, -0.05649313f, -0.05932701f, -0.02715330f, 
    0.03649175f, 0.00136644f, 0.03033269f, -0.00148563f, -0.05536661f, -0.04154760f, -0.04510994f, -0.03100355f, 
    -0.00939861f, 0.01422704f, -0.05405739f, -0.04349628f, -0.02829111f, -0.02630984f, 0.00536837f, 0.00200276f, 
    -0.04359660f, -0.04468232f, -0.04233540f, -0.06095636f, -0.02348034f, -0.04333722f, 0.02000856f, -0.00180206f, 
    -0.00491834f, -0.00117248f, -0.01976869f, -0.02991574f, -0.01082714f, -0.05173910f, -0.04703829f, 0.01041108f, 
    -0.02920937f, 0.03141753f, -0.05454357f, -0.04141697f, 0.04100678f, 0.04088259f, -0.03420177f, -0.03025328f, 
    0.01723912f, -0.04591542f, 0.02577907f, -0.00477349f, -0.05106335f, -0.00171204f, 0.01168800f, -0.03474963f, 
    0.03643253f, 0.03473426f, -0.03422403f, 0.00270496f, 0.00252723f, -0.01298752f, -0.03404287f, -0.03166084f, 
    -0.05609300f, 0.03331446f, -0.05851250f, -0.00450799f, 0.01292797f, 0.04157938f, -0.00382159f, -0.00465221f, 
    0.02111171f, -0.04193780f, -0.05285758f, -0.04523779f, 0.02581696f, -0.03688361f, -0.00799669f, -0.01907980f, 
    0.03079696f, -0.01284776f, 0.02834143f, -0.02188713f, 0.01878314f, 0.02854058f, -0.05510911f, 0.02365528f, 
    -0.04461057f, -0.02234063f, 0.03771142f, 0.00822066f, -0.03579269f, 0.04449288f, 0.00950337f, 0.02616958f, 
    -0.01778611f, -0.01394358f, 0.03099716f, -0.02771902f, -0.00497267f, -0.01361204f, -0.02292389f, 0.01458614f, 
    0.01583235f, 0.03527101f, 0.02184759f, -0.04766356f, -0.01297175f, -0.02654680f, 0.03095546f, -0.04653016f, 
    0.00255357f, -0.03655991f, 0.00408491f, -0.03008294f, -0.02782458f, -0.04355266f, -0.05302456f, 0.03594963f, 
    0.00218416f, 0.02633434f, 0.00227578f, -0.02487420f, 0.00738227f, 0.02278358f, 0.03921746f, -0.01135237f, 
    -0.05294757f, -0.04294067f, -0.01652298f, -0.01839726f, 0.02570445f, 0.00935071f, 0.03697793f, -0.03531276f, 
    -0.04630854f, -0.03859604f, 0.02023337f, 0.02975086f, 0.02331510f, -0.02702729f, -0.02946036f, 0.02082325f, 
    -0.01656947f, -0.02984849f, -0.05081141f, 0.02225884f, -0.02563427f, 0.00234982f, -0.00251436f, -0.00287987f, 
    0.03241396f, 0.02582700f, 0.00570398f, 0.02324996f, 0.01436390f, -0.01410296f, -0.00035185f, -0.04575450f, 
    -0.00096343f, -0.00068462f, 0.02292166f, 0.01371768f, -0.06003458f, 0.00911343f, -0.01760602f, -0.02446684f, 
    0.04396554f, -0.00529287f, -0.04151596f, -0.00322154f, 0.00497588f, -0.03381654f, -0.04296719f, -0.05505377f, 
    0.03174257f, -0.03432183f, 0.00248533f, -0.00325559f, 0.04058444f, -0.03501829f, 0.00139694f, -0.03771059f, 
    -0.03222462f, -0.05588367f, -0.03338715f, -0.03022950f, -0.05919812f, 0.03510086f, -0.05453335f, 0.03331969f, 
    -0.04297905f, -0.00524221f, 0.01036708f, -0.00277572f, -0.00140770f, -0.05555931f, -0.00095168f, 0.01298998f, 
    -0.01853134f, 0.01010676f, 0.04283180f, 0.00365141f, 0.00328177f, 0.03905933f, 0.03174790f, 0.00827202f, 
    -0.04458471f, -0.03871191f, 0.02414328f, -0.03754165f, -0.05529530f, 0.03916632f, 0.03441547f, 0.00783140f, 
    -0.01853349f, -0.03097866f, 0.02728843f, -0.00501362f, -0.03968677f, 0.03913293f, 0.02887048f, 0.01494073f, 
    -0.03611548f, -0.01579220f, -0.03746034f, -0.04766218f, 0.03693727f, 0.00656206f, -0.05294233f, 0.00000670f, 
    0.02925739f, -0.02768932f, 0.02814277f, 0.04031253f, -0.04880970f, -0.00315073f, 0.00293149f, 0.03498263f, 
    0.00780849f, 0.04017272f, -0.02281556f, 0.03907294f, 0.04011625f, 0.02914108f, -0.03642986f, -0.05354927f, 
    -0.04304166f, 0.00801941f, 0.00115509f, 0.01718923f, -0.03174742f, 0.03597961f, -0.01312003f, -0.05532556f, 
    -0.01055881f, -0.01777212f, 0.03297870f, 0.03940091f, -0.02873138f, -0.03908364f, -0.05633208f, -0.01459730f, 
    -0.05032153f, -0.02548615f, -0.04143972f, -0.03706193f, 0.01824940f, 0.03076099f, 0.00776043f, -0.05917210f, 
    -0.00945056f, -0.02109595f, 0.03457196f, -0.04200209f, 0.02663514f, 0.03243549f, 0.02837411f, 0.03019872f, 
    0.03748835f, 0.01191739f, 0.00482230f, -0.01902913f, 0.00997432f, 0.01719580f, -0.03066899f, 0.00618451f, 
    0.04101893f, -0.02991762f, 0.01360106f, -0.00883863f, -0.05360929f, -0.04890477f, 0.03261651f, 0.02697567f, 
    0.03209735f, 0.00463697f, 0.01365512f, -0.01238815f, -0.01665650f, 0.00462956f, -0.03579472f, -0.00769239f, 
    0.00727286f, -0.02840583f, 0.04186625f, 0.01585316f, 0.00273724f, 0.03194555f, -0.00205198f, 0.01843524f, 
    -0.04793463f, -0.03762944f, -0.00323114f, 0.02508098f, -0.00887393f, 0.01330445f, -0.04703978f, -0.00120237f, 
    -0.03468846f, -0.03796566f, -0.04559263f, 0.00013598f, 0.04000581f, -0.04815849f, -0.04595169f, 0.02254620f, 
    -0.02298894f, 0.01534577f, 0.03269773f, 0.03543539f, -0.04092096f, 0.02431807f, 0.00078574f, -0.05322930f, 
    -0.01290533f, -0.00073618f, 0.01820831f, 0.01320915f, 0.00602611f, 0.02819155f, 0.02479928f, 0.01629143f, 
    0.00719002f, -0.03293363f, 0.02975210f, -0.00324119f, -0.04448445f, -0.04352357f, -0.02645480f, 0.02999187f, 
    0.01409878f, 0.02947480f, -0.05147644f, -0.04953903f, -0.01876029f, -0.00395959f, -0.03093489f, -0.02396897f, 
    -0.04458886f, 0.02971241f, 0.00868404f, -0.01548715f, -0.03743699f, 0.03346559f, 0.00773658f, 0.01555265f, 
    -0.05020731f, 0.02705018f, -0.04653374f, -0.00614915f, -0.01770678f, -0.04947017f, -0.05029477f, -0.03546962f, 
    -0.05453986f, -0.00232039f, -0.02589731f, 0.01353048f, 0.01024453f, -0.03471366f, -0.02153544f, 0.02608425f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07150982f, 0.14953730f, 0.00313590f, -0.02454596f, 0.11816089f, -0.00691018f, -0.03236670f, 0.03555989f, 
    -0.03122006f, 0.02880733f, -0.03319908f, -0.04522840f, 0.10952834f, 0.08119313f, -0.01117159f, 0.02065991f, 
    0.03000307f, -0.05080101f, -0.03827565f, -0.00507885f, -0.03747440f, 0.03284140f, -0.00877570f, -0.00219974f, 
    0.03539500f, 0.05756567f, 0.00985921f, -0.00468206f, 0.02026632f, 0.08665571f, 0.03052280f, -0.03855192f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.36199218f, 0.18156075f, -0.16433296f, 0.01233033f, -0.47595531f, -0.15966138f, -0.05079373f, 0.00836178f, 
    0.24428213f, -0.12668973f, 0.07560136f, 0.03096992f, 0.02214765f, -0.48609340f, -0.07114564f, -0.12322141f, 
    -0.03194144f, 0.13248931f, -0.01396132f, 0.10576785f, -0.02011420f, 0.16699684f, -0.03808437f, 0.15716210f, 
    -0.06954711f, -0.04285821f, -0.00297632f, 0.15330553f, 0.32604238f, 0.04763805f, 0.09879473f, 0.17309086f, 
    0.33181542f, 0.18503658f, 0.02486485f, -0.11118986f, -0.31671530f, -0.10727677f, -0.14546379f, -0.25014159f, 
    0.18686689f, -0.09807337f, -0.15784296f, -0.09237307f, 0.23847958f, -0.60013390f, 0.04507096f, -0.34890094f, 
    -0.08092196f, -0.17017439f, 0.03962096f, 0.12401932f, 0.08470393f, 0.01741779f, -0.02536277f, -0.03268913f, 
    -0.02153037f, 0.15080036f, -0.05656992f, 0.09875514f, 0.07892294f, 0.48462141f, -0.09219432f, -0.00867395f, 
    0.08618262f, 0.30551368f, -0.01826135f, 0.12388553f, -0.11160888f, -0.09472156f, -0.05260630f, 0.40553990f, 
    -0.14144111f, 0.16196120f, 0.05731242f, -0.03764163f, -0.26844835f, -0.00449101f, 0.12104444f, -0.25091806f, 
    0.01791537f, -0.18061143f, 0.16981076f, -0.16178966f, -0.03397312f, 0.42298585f, -0.14573340f, -0.12766850f, 
    0.04378749f, 0.43466386f, -0.04178754f, 0.04883981f, 0.19911465f, -0.24069236f, 0.09949297f, 0.10698549f, 
    0.02755704f, 0.26362619f, 0.18962948f, -0.12431617f, 0.05795452f, -0.06054626f, 0.00714916f, -0.40889838f, 
    -0.29729357f, -0.06537741f, -0.32336783f, 0.01690844f, 0.35218620f, 0.02603163f, 0.07649015f, 0.22861369f, 
    0.01323933f, -0.15867724f, 0.04724864f, -0.16838545f, 0.11287254f, -0.30434179f, -0.14895964f, 0.01026697f, 
    -0.07828099f, 0.33389795f, 0.06996395f, -0.07867970f, 0.12467047f, 0.03998784f, 0.16363063f, 0.13564089f, 
    0.07284308f, 0.19040203f, -0.09077690f, 0.06130613f, 0.27663985f, -0.10553936f, -0.00271763f, 0.21441706f, 
    0.07915605f, 0.00439640f, -0.14328119f, 0.08731431f, 0.34519914f, 0.26051253f, 0.13155633f, 0.50356054f, 
    -0.05199301f, 0.13767129f, -0.10196583f, 0.18161230f, 0.16320568f, -0.21698166f, 0.08614358f, 0.06781023f, 
    -0.10175626f, -0.25670525f, -0.07767461f, -0.10529684f, -0.05240007f, -0.45415255f, -0.06592296f, -0.12888174f, 
    -0.13742532f, 0.11246622f, -0.15649712f, -0.15988362f, 0.40644166f, -0.07468322f, 0.13469937f, -0.17813312f, 
    0.03716359f, -0.11415894f, -0.47808647f, 0.09146561f, 0.26900998f, 0.42360273f, 0.15724660f, 0.32118535f, 
    0.07043690f, 0.11172373f, 0.17336211f, 0.16047512f, -0.06429751f, 0.12017830f, 0.18598431f, 0.16105701f, 
    0.02254406f, 0.13127933f, -0.17116156f, 0.06627024f, 0.09962093f, -0.14062577f, 0.00554662f, 0.10449813f, 
    0.21944697f, -0.29400015f, -0.14860429f, 0.05109211f, 0.00505509f, -0.15043700f, 0.11115169f, 0.32960466f, 
    0.11063648f, 0.03295456f, 0.15596628f, 0.08624828f, 0.27451876f, 0.44903702f, -0.03899311f, 0.20791779f, 
    0.10933265f, -0.07243674f, -0.06683955f, 0.00167622f, -0.15914397f, -0.23503506f, -0.01513356f, 0.13386752f, 
    -0.16339941f, -0.20884679f, 0.04634330f, -0.10653992f, 0.01587554f, -0.13674907f, -0.08856308f, -0.01854621f, 
    -0.13802537f, 0.18889943f, -0.39572108f, -0.06447838f, 0.28480059f, -0.12501355f, 0.14251731f, 0.42459959f, 
    -0.35310382f, -0.02593930f, 0.15179548f, -0.12129387f, 0.17180754f, 0.54459208f, -0.06175661f, -0.00969434f, 
    0.05407082f, -0.03860973f, -0.00869937f, 0.00347055f, -0.04120715f, -0.38830012f, -0.08513108f, -0.14059304f, 
    -0.00975320f, 0.35110182f, -0.08752409f, -0.16517143f, 0.09945935f, -0.03068158f, 0.10733233f, 0.13639140f, 
    -0.35209247f, -0.24584253f, -0.10611323f, 0.03102191f, 0.05125326f, 0.13367860f, 0.07138554f, 0.42880690f, 
    0.18332161f, -0.14034735f, 0.15529141f, 0.03039732f, -0.08986060f, 0.48384541f, -0.04956928f, -0.24888691f, 
    0.12860976f, 0.02021396f, -0.00832858f, -0.17118260f, -0.10122935f, 0.11605810f, 0.03339123f, 0.16076358f, 
    -0.14134465f, 0.63148111f, 0.00075849f, -0.04315246f, 0.27531797f, 0.25433111f, -0.09790923f, -0.05011427f, 
    0.15988094f, 0.42023480f, -0.20575742f, -0.14925292f, 0.30111936f, 0.02066149f, -0.03141075f, 0.15150271f, 
    -0.24782890f, -0.17619963f, 0.37098768f, 0.02940220f, -0.07351177f, -0.41471782f, -0.11156338f, 0.12791589f, 
    0.15056849f, 0.04236780f, -0.12879060f, -0.18171012f, -0.06409150f, -0.14593078f, 0.14981194f, 0.12671719f, 
    0.07647742f, -0.08682684f, 0.10408959f, -0.14692542f, 0.18802200f, 0.37124941f, 0.02899556f, 0.04926959f, 
    0.33890855f, -0.32014823f, 0.19156948f, 0.07849588f, -0.29643917f, -0.03410254f, -0.14335367f, -0.36305964f, 
    -0.16450815f, 0.06165643f, -0.02072765f, 0.03450789f, 0.23061985f, 0.24763985f, -0.13250773f, 0.15148781f, 
    0.00161400f, -0.06192199f, 0.00401822f, 0.13303883f, -0.03425562f, -0.12905151f, 0.05274571f, -0.11799777f, 
    -0.15048572f, 0.15971699f, 0.15029134f, -0.01416248f, 0.17530055f, 0.31170437f, 0.12378076f, 0.01418724f, 
    0.26255903f, 0.05515826f, 0.02169573f, 0.09730638f, -0.65121108f, 0.16298890f, -0.14240462f, -0.07456514f, 
    0.34502202f, 0.08780587f, -0.15155594f, -0.06186483f, -0.03824334f, -0.24339622f, -0.08482093f, 0.12249036f, 
    0.15360907f, 0.10194179f, 0.09724245f, 0.09562773f, 0.07721035f, 0.20165491f, 0.05439368f, 0.16927189f, 
    -0.04468280f, 0.03609606f, -0.01521628f, 0.03510003f, 0.26977846f, -0.09228592f, -0.09485664f, -0.00319726f, 
    -0.20952073f, -0.01274907f, 0.47441745f, 0.02449022f, 0.44602054f, -0.04017500f, 0.08092193f, -0.03302116f, 
    0.22503160f, 0.04451268f, 0.22289740f, -0.00498889f, 0.04454495f, -0.00265519f, -0.10279551f, 0.05455075f, 
    0.08948310f, -0.13522370f, 0.05550958f, 0.01475129f, 0.10753486f, 0.37810278f, 0.16678463f, -0.01466236f, 
    0.04753629f, -0.18389432f, -0.12964191f, -0.13545062f, -0.30522534f, -0.14726515f, -0.03415988f, -0.01952182f, 
    0.08860017f, -0.21061033f, 0.13585702f, 0.12104239f, 0.08833371f, -0.00946958f, -0.15499739f, 0.31295800f, 
    0.20531772f, -0.00420940f, -0.02566431f, 0.09746516f, 0.09014979f, -0.00779200f, -0.03012494f, -0.17182647f, 
    0.07588568f, -0.15602274f, 0.00351106f, -0.09497221f, 0.12869081f, -0.11230599f, 0.00516404f, -0.09949364f, 
    -0.00621742f, -0.02496446f, 0.01239627f, -0.12107961f, -0.18565881f, 0.35818824f, 0.06491572f, -0.13426350f, 
    -0.00892697f, 0.04509827f, -0.06701929f, -0.15691358f, 0.03855791f, 0.05340377f, 0.00494151f, -0.18987617f, 
    0.62664014f, 0.09779872f, -0.01955898f, 0.10555299f, 0.31142354f, 0.10268723f, 0.16086458f, 0.35681841f, 
    -0.10418785f, 0.02621887f, -0.06392536f, -0.06218802f, 0.06362800f, -0.03011434f, -0.14638478f, -0.05757700f, 
    0.14584178f, -0.43261844f, 0.08319835f, -0.04345685f, 0.05632777f, -0.03672284f, 0.03056839f, -0.08970268f, 
    -0.39309311f, 0.32112280f, -0.27140361f, 0.02836365f, 0.39813727f, -0.06103602f, -0.16621713f, 0.52973974f, 
    0.17251839f, -0.03915636f, 0.27682722f, -0.07091273f, -0.05209333f, -0.10620537f, 0.04612219f, -0.13398151f, 
    -0.01543772f, -0.04442117f, -0.16283959f, 0.11276467f, 0.17073789f, -0.03674070f, -0.16869693f, 0.06923231f, 
    -0.04403466f, -0.03507470f, -0.10230190f, 0.08958334f, 0.12502651f, 0.21090069f, 0.15108605f, -0.09633360f, 
    0.03393881f, 0.13504748f, 0.17047994f, -0.14828241f, 0.12335800f, 0.03863347f, 0.07111903f, 0.22641599f, 
    0.28327480f, -0.08660756f, -0.25425133f, -0.17670739f, 0.33697793f, -0.01443157f, -0.16277109f, -0.32272536f, 
    -0.13154902f, 0.02997994f, -0.12955593f, 0.01740871f, 0.00543745f, -0.19979961f, -0.15987876f, 0.06894004f, 
    -0.11863682f, -0.04793538f, 0.06993871f, -0.14403458f, -0.12795511f, -0.19571596f, -0.17219289f, 0.11361288f, 
    -0.36194625f, -0.05230643f, 0.45983440f, -0.16474523f, -0.22104315f, -0.01421162f, 0.12461397f, -0.13337284f, 
    0.35278824f, 0.18066551f, -0.10315964f, 0.05210316f, -0.04779887f, 0.57237959f, -0.00098544f, 0.22196960f, 
    0.16170606f, 0.08357272f, 0.03046484f, -0.01459036f, 0.04324094f, 0.12174530f, 0.06494784f, 0.05841880f, 
    -0.01949948f, 0.14188060f, -0.07843427f, -0.05642202f, 0.15244615f, 0.02715028f, 0.11815974f, 0.02800380f, 
    0.02883232f, 0.14816809f, -0.17203900f, -0.10310620f, 0.13294166f, -0.01678550f, -0.14196923f, 0.01370877f, 
    -0.03328010f, -0.11108845f, -0.14697474f, 0.02980322f, -0.17310578f, -0.06845386f, -0.16364826f, 0.05687334f, 
    0.05929972f, -0.03678599f, -0.00418646f, -0.06898350f, 0.16422278f, -0.06296025f, 0.01687574f, 0.11692947f, 
    0.15779127f, 0.11379822f, -0.07558736f, 0.16114476f, -0.16047369f, 0.10201151f, 0.09438481f, -0.00131529f, 
    0.19009067f, 0.31158817f, 0.04083572f, 0.14974524f, 0.12297258f, 0.07171924f, -0.02957672f, 0.42153317f, 
    0.34058717f, 0.09050135f, 0.24778463f, -0.17791773f, 0.18823984f, -0.37233365f, 0.10000596f, -0.20286484f, 
    -0.12779655f, 0.01056821f, 0.00559506f, -0.11323448f, 0.04504164f, -0.29126948f, -0.07722819f, 0.09689802f, 
    0.10923406f, 0.06407879f, 0.12010849f, -0.07078531f, -0.29014894f, -0.07675440f, 0.17125244f, 0.13136357f, 
    0.00626285f, -0.12069278f, 0.46838951f, 0.09085376f, 0.01871906f, 0.10421027f, -0.13917838f, -0.16427141f, 
    0.43016773f, 0.09983351f, -0.27223715f, 0.03252978f, 0.22846729f, 0.44246209f, 0.06818252f, -0.01669051f, 
    0.06538211f, 0.10093465f, 0.08197033f, 0.09623754f, 0.07717633f, -0.00071237f, 0.06072346f, 0.14293121f, 
    -0.12393962f, 0.24035312f, -0.10067098f, 0.07523151f, 0.07930311f, -0.29074273f, -0.00498320f, -0.07185644f, 
    -0.15650712f, 0.08905648f, -0.12924108f, -0.16261545f, -0.08059151f, 0.01436663f, 0.05830056f, -0.04115734f, 
    -0.00118846f, -0.01352838f, 0.23881024f, -0.03222069f, -0.14508191f, 0.33934569f, 0.03719014f, 0.44691634f, 
    0.00193738f, 0.10351270f, 0.12307214f, -0.01866305f, 0.13392310f, 0.21641406f, 0.02295640f, -0.03688381f, 
    -0.10460444f, -0.30386278f, 0.16197787f, 0.08147539f, 0.26095909f, -0.03771766f, -0.10243221f, 0.03075534f, 
    -0.18414673f, -0.09155031f, 0.12161692f, 0.00568462f, 0.13670996f, -0.14060293f, 0.08923771f, -0.18381162f, 
    -0.19237919f, 0.03117440f, -0.08678835f, -0.12957656f, -0.00609529f, 0.03352727f, 0.04071084f, -0.08940500f, 
    0.12016997f, -0.12274494f, 0.15254517f, 0.10974034f, 0.10141895f, -0.00092179f, -0.02634155f, -0.13306695f, 
    0.00202031f, -0.11136011f, -0.00071717f, 0.05341396f, 0.03683138f, -0.17026195f, -0.03717738f, 0.14193766f, 
    0.65671432f, 0.09627231f, -0.27547398f, 0.03591719f, -0.11756706f, 0.14036497f, -0.08767853f, 0.37366551f, 
    0.22440404f, 0.04724322f, 0.27759579f, 0.16878448f, 0.03708760f, -0.29498586f, 0.10787429f, 0.09307165f, 
    0.08993279f, -0.01643964f, 0.16060260f, 0.09056731f, -0.15356113f, -0.05811384f, 0.03176347f, 0.03975626f, 
    -0.00492136f, -0.32896462f, -0.12350996f, 0.10393246f, 0.16532381f, -0.01442902f, 0.01591543f, 0.06216023f, 
    -0.00129683f, -0.07734788f, -0.15453719f, 0.08656044f, 0.28867772f, -0.08597277f, -0.03452183f, -0.23322140f, 
    -0.42633286f, -0.02713566f, -0.03301037f, -0.05469123f, 0.13461187f, 0.27077016f, 0.06854601f, 0.06143881f, 
    0.07986645f, 0.12394281f, -0.15184937f, 0.01794971f, -0.10317315f, 0.04876301f, -0.16889863f, -0.16202880f, 
    0.11938285f, -0.17796101f, 0.05674730f, -0.01531512f, 0.14454569f, 0.52520156f, 0.10812888f, 0.01224861f, 
    0.06818381f, 0.37890074f, 0.16525134f, -0.06354607f, -0.12078893f, 0.03838646f, 0.16437750f, -0.10534947f, 
    0.04070380f, -0.07559569f, 0.42202514f, -0.02115167f, -0.15716709f, 0.22783318f, 0.08054063f, 0.57635152f, 
    0.10312710f, 0.01621968f, 0.11433055f, 0.03994140f, 0.00318883f, -0.09489957f, 0.10269279f, -0.05221999f, 
    0.01915577f, -0.36317807f, 0.01476249f, -0.12675311f, -0.15893205f, 0.04686284f, 0.04036999f, 0.00641723f, 
    -0.22743988f, 0.37853765f, -0.10970091f, -0.10980254f, 0.35265023f, -0.15963979f, 0.01621187f, -0.30411965f, 
    -0.00412255f, 0.12025943f, -0.30377731f, -0.10177448f, -0.00967086f, -0.36567029f, -0.15849717f, -0.35421294f, 
    0.03872179f, -0.00337291f, 0.07289886f, -0.04754676f, -0.10262834f, 0.34959626f, -0.07303970f, 0.13666618f, 
    -0.04209345f, 0.14559442f, 0.12588592f, -0.07022074f, 0.27265885f, 0.18014535f, -0.15432003f, -0.10197691f, 
    -0.35207835f, 0.34265590f, 0.10859264f, -0.14829780f, 0.31676999f, 0.14104897f, 0.00710595f, 0.15467720f, 
    -0.21554199f, 0.16722131f, 0.35090083f, 0.13285545f, -0.12740138f, -0.03134811f, 0.09830195f, -0.11347724f, 
    -0.14974545f, 0.11437973f, 0.00003917f, -0.03315179f, 0.11035659f, 0.31935650f, -0.14586124f, -0.00459530f, 
    -0.04759584f, 0.36517122f, 0.16534419f, 0.16754201f, 0.10014398f, -0.06054594f, 0.00926096f, -0.09442712f, 
    0.11733673f, -0.14393447f, 0.04844807f, -0.18167417f, 0.02954629f, 0.08026555f, -0.09994217f, -0.15218587f, 
    -0.12454467f, -0.02838459f, -0.05174257f, 0.00995538f, -0.05230828f, -0.05254672f, -0.01493863f, -0.07539290f, 
    -0.15387218f, -0.09812158f, 0.07720533f, -0.01386574f, 0.12657578f, -0.01924291f, 0.04839061f, -0.14391874f, 
    -0.18212183f, -0.05948161f, 0.13848570f, 0.00195728f, -0.05299341f, -0.10849270f, 0.15938905f, -0.01443577f, 
    0.06920984f, 0.02817822f, -0.16547300f, 0.10892355f, -0.10094352f, -0.11101475f, -0.04708344f, -0.17344065f, 
    0.06174220f, 0.12290290f, -0.03735842f, 0.10385922f, 0.09747253f, -0.02142463f, 0.06260121f, -0.08738065f, 
    0.05610239f, 0.12157905f, -0.15252805f, -0.11235312f, 0.15438089f, -0.03292925f, -0.00437293f, 0.04658194f, 
    0.07862576f, -0.05367962f, 0.01818222f, 0.02450944f, -0.13928498f, 0.02117747f, 0.03896265f, 0.05775775f, 
    -0.11441850f, 0.13367011f, 0.04288149f, 0.01057955f, -0.04224831f, 0.01806245f, -0.09817059f, 0.06019674f, 
    0.12327157f, 0.11444448f, -0.06932503f, 0.13916908f, -0.16777584f, -0.07962094f, 0.03373273f, -0.12326674f, 
    0.05555033f, -0.16334051f, 0.03801110f, 0.12053218f, 0.07415805f, -0.09771504f, -0.05000433f, -0.04386796f, 
    -0.01229603f, -0.04046240f, 0.02083135f, -0.09468304f, 0.01135733f, -0.03766407f, -0.07634468f, -0.14296681f, 
    0.25052556f, 0.23104288f, 0.18967101f, 0.15606646f, 0.14746989f, -0.08239128f, 0.05784922f, -0.19449326f, 
    -0.38397408f, -0.02514566f, 0.43288770f, -0.15487398f, -0.31020179f, 0.02921084f, 0.06485233f, 0.19670181f, 
    -0.13590737f, -0.12598979f, 0.00162189f, -0.06796000f, 0.08773755f, 0.42810434f, -0.12716441f, 0.00154394f, 
    -0.15291806f, 0.06712905f, -0.10655483f, -0.01126884f, 0.02823745f, 0.24090622f, -0.14495118f, 0.14453758f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.06023378f, -0.04289785f, -0.07522280f, 0.28337976f, 0.15301766f, 0.01265429f, -0.02481864f, 0.03387157f, 
    0.13182551f, 0.01459753f, 0.04431810f, -0.07722274f, -0.02938034f, -0.08849183f, 0.08066845f, 0.01353014f, 
    -0.02782097f, 0.12902059f, -0.12706006f, 0.05398580f, 0.09094713f, 0.07583448f, -0.11924489f, -0.07035973f, 
    0.16974437f, -0.04700888f, -0.04412883f, 0.17973629f, 0.10827975f, -0.17115778f, -0.15430138f, 0.07545443f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.26550129f, 0.26191336f, -0.13017076f, -0.07655957f, -0.60118997f, -0.21604073f, -0.22163032f, -0.66495883f, 
    -0.10087440f, 0.05199470f, 0.33287105f, 0.43946925f, -0.51464003f, -0.02509198f, 0.19317450f, -0.35768172f, 
    -0.40980905f, -0.02558737f, -0.00051070f, -0.46760792f, 0.05589012f, -0.01313038f, 0.03838321f, 0.14550893f, 
    0.12575924f, -0.30266961f, 0.09537352f, -0.20517570f, 0.07495774f, -0.09627087f, -0.00054133f, 0.14590397f, 
    0.03333469f, 0.21362607f, 0.19806229f, -0.18189944f, -0.48662728f, -0.21357578f, -0.41029301f, 0.05517009f, 
    -0.02688555f, 0.23611934f, -0.12356050f, 0.06521448f, 0.14230505f, 0.02052048f, -0.41052085f, 0.05303589f, 
    0.09473717f, -0.29342708f, -0.06128030f, 0.10346437f, -0.36238310f, -0.30039689f, 0.13491783f, 0.18782490f, 
    0.04431790f, -0.09142857f, 0.24436972f, 0.18827423f, 0.05552560f, -0.13840540f, -0.03384603f, 0.25939757f, 
    0.02936491f, -0.24889949f, -0.00604729f, -0.85359871f, -0.28807387f, -0.73544413f, 0.10349692f, -0.20125787f, 
    0.17517394f, 0.00376169f, -0.14373484f, 0.24123068f, 0.16606334f, 0.04528965f, 0.11333641f, 0.28424075f, 
    -0.63930517f, 0.25568482f, -0.11907493f, -0.05254643f, -0.35064113f, 0.38469359f, 0.05500026f, 0.20348667f, 
    -0.25762764f, 0.51982170f, -0.34507903f, 0.12971778f, -0.02506830f, -0.03942630f, 0.15562150f, 0.19627334f, 
    -0.48410735f, 0.13378905f, -0.27028286f, 0.40243527f, -0.18236507f, -0.04745013f, -0.26055065f, -0.06781717f, 
    0.14619614f, -0.37203139f, 0.31232852f, -0.13648267f, 0.08975255f, 0.10628307f, -0.06406933f, -0.57435596f, 
    0.17653988f, 0.33717138f, -0.10790284f, 0.10026140f, 0.32757729f, -0.68304622f, 0.10746969f, -0.91730297f, 
    -0.25950179f, -0.05249859f, -0.08751764f, 0.18395022f, 0.13013940f, -0.15573654f, 0.14794989f, -0.08052000f, 
    -0.02781913f, -0.05784220f, -0.01610864f, -0.06800611f, 0.08036373f, 0.17326657f, 0.34230801f, 0.14042123f, 
    0.22335929f, -0.30334741f, 0.21682347f, 0.33284980f, -0.59010297f, -0.03279376f, 0.12637775f, -0.27893928f, 
    0.01008520f, 0.20826808f, -0.15942457f, -0.31086671f, 0.17953719f, 0.04563412f, -0.06450404f, 0.09928305f, 
    -0.01728301f, -0.15840711f, -0.27993560f, -0.35746062f, -0.04698066f, 0.14818598f, -0.00860466f, -0.31920335f, 
    -0.18618080f, -0.19181719f, -0.14816140f, 0.21617019f, 0.03187878f, 0.26230642f, 0.07805474f, 0.33617920f, 
    0.01943468f, 0.14833157f, 0.12183250f, -0.37536576f, -0.26261923f, -0.48857909f, 0.00430365f, 0.10386749f, 
    -0.35813248f, -0.08595280f, 0.03826338f, -0.54728675f, -0.32298985f, 0.25413185f, 0.10666186f, -0.09501249f, 
    0.35538957f, 0.03068563f, 0.05994568f, 0.07356543f, -0.00676862f, 0.02109838f, 0.14046144f, 0.08673518f, 
    -0.18053932f, 0.16639723f, -0.90371531f, -0.19900991f, -0.10345426f, -0.19550990f, 0.23870035f, 0.23965418f, 
    0.06346755f, 0.26915589f, 0.09306610f, -0.49103719f, -0.01920017f, 0.57834601f, 0.12893562f, 0.26611537f, 
    0.25875893f, -0.37187964f, -0.15138328f, 0.46295202f, -0.22687073f, -0.26835173f, -0.08995252f, 0.10528505f, 
    0.17801660f, -0.14027619f, -0.25490519f, -0.19243072f, 0.02459378f, 0.08383725f, 0.08103755f, -0.28900930f, 
    -0.46898070f, -0.58454335f, 0.17649151f, -0.19287190f, 0.48022431f, 0.20996335f, 0.45559210f, 0.04947696f, 
    -0.23081651f, -0.44903404f, -0.08127353f, -0.36700934f, 0.30131400f, 0.10561433f, 0.27196264f, -0.30142206f, 
    0.28686389f, 0.03986424f, -0.11701251f, 0.00453919f, 0.22054005f, -0.15681960f, -0.03479187f, 0.02607532f, 
    -0.21434854f, 0.02948602f, -0.40821499f, -0.24986519f, 0.01879391f, -0.05296757f, 0.02971647f, -0.07806443f, 
    -0.11607418f, -0.49378189f, 0.47979710f, -0.49654844f, 0.17502835f, -0.10173070f, -0.11886238f, 0.46330386f, 
    0.40900585f, 0.12472292f, -0.44838730f, -0.30495852f, 0.06233542f, -0.35723537f, -0.70752269f, 0.22653976f, 
    -0.18209364f, -0.10343833f, -0.01839816f, 0.10753115f, -0.08464625f, 0.03273902f, 0.10280828f, -0.14305425f, 
    -0.38743895f, -0.45400879f, 0.00220086f, 0.47136474f, 0.02931624f, -0.09722386f, -0.12884948f, 0.15578389f, 
    0.09877103f, -0.11669048f, -0.16524698f, 0.06502592f, 0.47011793f, -0.06318656f, 0.01656918f, 0.05832244f, 
    -0.77554613f, 0.17107520f, -0.16420648f, 0.26593295f, -0.24595718f, -0.57017946f, 0.22666164f, -0.18555290f, 
    0.12563100f, -0.32053119f, -0.13166362f, 0.37646723f, -0.12398323f, -0.00723398f, 0.08518452f, 0.32181692f, 
    -0.39929461f, 0.45074877f, -0.26487067f, -0.17317286f, 0.10370513f, -0.01070639f, 0.01135738f, -0.15273222f, 
    -0.51712286f, -0.30842200f, -0.40507787f, -0.10787061f, 0.00841910f, 0.20259464f, -0.40038458f, -0.11513489f, 
    -0.23365007f, 0.12322584f, -0.10583993f, -0.49648535f, 0.34099048f, -0.11401752f, 0.22025931f, 0.07583269f, 
    -0.31675181f, 0.21577418f, 0.04039816f, -0.29927069f, -0.02592388f, 0.26377469f, -0.14521205f, -0.51599234f, 
    0.30124587f, 0.50495666f, 0.05812511f, 0.23791751f, -0.01083250f, -0.17109251f, -0.06501488f, 0.31396464f, 
    -0.04287698f, 0.03768060f, 0.02750519f, -0.13207844f, 0.05914282f, 0.23436651f, -0.28890640f, -0.04256901f, 
    0.17506617f, -0.15745351f, -0.55615240f, 0.06127456f, 0.09578823f, -0.14534958f, 0.29747468f, 0.42960924f, 
    0.36223975f, 0.13256666f, 0.06929611f, 0.14909227f, 0.03444690f, -0.08566029f, -0.01514605f, -0.27104250f, 
    -0.34532225f, -0.47348908f, 0.46779662f, 0.06450470f, -0.00642109f, 0.04436923f, 0.14189561f, -0.60773939f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.08953261f, -0.15974768f, -0.16092837f, 0.23767674f, 0.16869773f, -0.14452484f, -0.00422116f, -0.06161134f, 
    -0.21439306f, 0.18020956f, 0.07096900f, -0.13466533f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
