#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.02152090f, 1.26626730f, -0.71951121f, -0.11079175f, -0.34023234f, 0.51824474f, -0.47925243f, -0.04093450f, 
    0.28480977f, 0.62369430f, 0.83344883f, 0.14745128f, -1.01932347f, 0.02661683f, -0.03413734f, 0.20880738f, 
    0.49975342f, -0.05636934f, -0.46308520f, -0.69066560f, -0.56602001f, 0.66379422f, 0.77223575f, 0.47564593f, 
    -0.41918653f, -0.44297805f, -0.50904220f, -0.99550182f, -0.85260874f, -0.82104975f, 0.63359153f, 0.92884403f, 
    -0.11188523f, 0.13106428f, 0.48596337f, -0.13764003f, -0.66049570f, -0.07677615f, 0.11220341f, -0.88430762f, 
    -0.65036696f, -0.41762072f, 0.67107034f, -0.18409118f, 0.71807164f, 0.75710225f, 0.35101593f, -0.62285042f, 
    -0.20434885f, -0.34884405f, -0.19189480f, 0.50632578f, 0.43979922f, 0.43235090f, 0.36827102f, 0.69363815f, 
    -0.03936579f, -0.09069037f, 0.42864791f, -0.89393336f, -0.25658616f, 0.41339177f, 0.03765630f, 0.26618811f, 
    0.31239516f, 0.34248367f, -0.13688086f, 0.46844035f, -0.88775033f, 0.47744551f, -0.04847286f, 0.59530729f, 
    -0.12126644f, -0.48352894f, -0.35877472f, -0.75407779f, 0.05243317f, 0.58995324f, -0.13715281f, 0.25814039f, 
    0.02349658f, 0.77104515f, 0.61461198f, 0.36793181f, -0.02967169f, 0.55364740f, 0.32326612f, 0.34412107f, 
    0.47854421f, -0.41050446f, 0.47403702f, 0.66397989f, -0.76016414f, 0.19586881f, 0.54081112f, -0.42615858f, 
    0.21234801f, -0.26154464f, 0.17456800f, -0.20364437f, -0.63233876f, 1.45633543f, 0.32215130f, -0.36516127f, 
    0.12290229f, -0.48514000f, -0.41245380f, 0.02921278f, 0.42852604f, 0.18525596f, -0.30995780f, 0.04333831f, 
    0.42599389f, 0.45249832f, 0.03386138f, -0.11744185f, 0.61383897f, 0.70795745f, 0.34392467f, 0.04202593f, 
    -0.72488326f, 0.57749820f, 0.58533591f, -0.74846596f, -0.52748072f, -0.02610482f, -0.59564555f, 0.45834538f, 
    0.48751369f, 0.71759129f, 0.49125326f, 1.06126654f, 0.30948043f, -0.19397144f, 0.06915756f, -0.29424736f, 
    0.33832639f, 0.89574152f, 0.51056099f, -0.87399465f, -0.48856667f, 0.09449843f, -0.04542136f, 0.04162886f, 
    0.17291074f, 0.20251624f, 0.34800598f, 0.37725878f, 0.46463585f, 0.66161251f, -0.29200920f, -0.26264119f, 
    0.45804888f, -0.54891002f, 0.83339983f, -0.27112767f, 0.25423676f, 0.55361480f, 0.13735662f, 0.36323851f, 
    -0.50465703f, -0.28506774f, 0.87380540f, 0.35984087f, 0.40369037f, 0.08595290f, -0.84069496f, 0.04442925f, 
    -0.12577967f, 0.22416508f, 0.02500215f, -0.33061302f, 0.04341495f, -0.36508307f, 0.41292328f, -1.09163356f, 
    -0.96631503f, -0.28311250f, 0.21232821f, 0.30309287f, -0.12976126f, 0.18173948f, 0.67439324f, -0.24165453f, 
    -0.33685011f, -0.54655921f, 0.20573208f, -1.01746035f, -0.58921111f, 1.10700226f, -1.09574986f, 0.19790599f, 
    0.02868885f, -0.32844868f, 0.54418921f, 0.60812068f, -0.41922647f, -0.40353441f, 0.39631996f, 0.01129973f, 
    -0.22291648f, 0.93552172f, -0.40875322f, -0.21982723f, 0.21789007f, 0.48699796f, -0.63937557f, -0.74758428f, 
    -0.76740956f, 0.27644017f, -0.19822714f, -0.69421202f, -0.42851105f, -0.20613374f, 0.37201211f, 0.04967215f, 
    -1.53271198f, 0.27690566f, 0.85294616f, -0.63900030f, 0.34328237f, -0.49622583f, -0.28765449f, 0.20817900f, 
    -0.12802421f, -0.96418172f, -0.33812270f, 0.26087826f, 0.95391732f, -0.33734083f, -0.93718106f, -0.08090337f, 
    -0.42858911f, -0.31499675f, 0.24201612f, -0.54836726f, -0.66304773f, -0.66470641f, -0.09587555f, -0.63989943f, 
    -0.38429534f, -0.23305722f, -0.31662399f, -0.24277511f, -0.44056424f, -0.79730839f, 0.68890792f, 0.60130471f, 
    0.33195716f, -0.12161714f, 1.01862669f, -0.74699003f, -0.40583539f, -0.36035395f, -0.24171843f, 0.08038108f, 
    -0.04380489f, 0.52989346f, 0.43536714f, 0.50738436f, 0.52935171f, -0.14665541f, -0.27385765f, -0.44213176f, 
    -0.14626753f, 0.07129347f, -0.18154135f, 0.03453307f, 0.47498086f, 0.72317696f, 0.76501542f, -0.67319959f, 
    0.53782666f, -0.58606660f, 0.25367776f, -0.01889779f, -0.17585427f, -0.23699623f, 0.43660045f, 0.42620429f, 
    0.68868864f, 0.56691635f, 0.55133998f, 0.01193092f, 0.10608628f, 0.17192078f, -0.59358227f, -0.29673749f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.18002191f, 0.30669305f, -0.02333068f, -0.14408472f, 0.26887065f, 0.30606019f, 0.18325540f, -0.06953982f, 
    0.61540914f, 0.18303148f, 0.40658605f, -0.21980050f, 0.32852849f, -0.22088967f, -0.27217427f, -0.00761020f, 
    0.14913704f, 0.30422121f, 0.30921498f, -0.14728187f, -0.12945725f, 0.00236533f, 0.38998291f, -0.08950502f, 
    -0.03050215f, 0.25760391f, -0.38983971f, 0.06041811f, 0.32561108f, 0.58270329f, 0.33089262f, -0.36678776f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.19955599f, -0.16914061f, -0.31239823f, -0.32908657f, 0.26100174f, 0.17586470f, 0.08108123f, 0.02219748f, 
    -0.36041802f, 0.05323863f, -0.34586871f, -0.26998350f, -0.01699848f, -0.05475484f, -0.06881138f, -0.09504217f, 
    0.10304336f, 0.07464791f, 0.32871169f, -0.08027995f, -0.03719621f, 0.11652949f, -0.09334084f, -0.01894911f, 
    0.10416561f, 0.05555990f, 0.02741881f, 0.33647907f, -0.08019691f, -0.36939582f, 0.18414022f, 0.18152364f, 
    0.24851027f, 0.05124874f, 0.03348752f, -0.13301283f, 0.07548714f, 0.26333484f, 0.25939485f, -0.02112878f, 
    -0.11389314f, 0.02625105f, -0.08451983f, 0.21416037f, 0.20362806f, 0.32653752f, 0.17332557f, -0.14853488f, 
    -0.09876698f, 0.04255168f, 0.06378681f, 0.11195946f, 0.04894066f, 0.04037477f, -0.00303723f, -0.01976557f, 
    -0.15838295f, -0.07150912f, -0.02445583f, 0.03163638f, -0.07946737f, 0.13603905f, 0.04591320f, 0.15190777f, 
    0.20829307f, 0.28890783f, -0.14417052f, -0.16734117f, -0.04266521f, 0.00878872f, -0.04448891f, 0.07438184f, 
    0.16918404f, -0.00699064f, 0.08275189f, 0.11266593f, 0.06160367f, 0.05888617f, 0.02420777f, 0.07249198f, 
    -0.06032286f, -0.06373814f, -0.23248515f, -0.25375649f, 0.26299956f, -0.00720417f, 0.11627470f, 0.07761018f, 
    0.01912285f, 0.01242674f, 0.10431673f, -0.05578310f, -0.49081156f, -0.17130075f, -0.11035205f, 0.01323113f, 
    0.01252902f, 0.15394098f, -0.07900390f, -0.01069093f, -0.03659083f, -0.19257149f, -0.01116279f, 0.22629699f, 
    -0.16734278f, 0.12541772f, 0.00307794f, -0.12171838f, -0.02329626f, -0.21617769f, -0.22640707f, -0.24310264f, 
    -0.03165527f, 0.15168767f, 0.07453902f, -0.01309671f, -0.04774880f, 0.17022070f, -0.40174705f, 0.05551768f, 
    0.12112956f, -0.18773454f, 0.17934535f, 0.03405016f, 0.01591135f, 0.00807160f, -0.46911198f, -0.40064880f, 
    -0.44311121f, -0.09208240f, -0.19576974f, -0.05972918f, -0.06700643f, 0.02384233f, 0.12715364f, -0.46113157f, 
    -0.12174175f, -0.35521176f, -0.17051227f, -0.13630018f, -0.08818346f, -0.08409417f, 0.17283162f, -0.03385051f, 
    -0.14352517f, -0.56200004f, -0.28895152f, -0.05806511f, 0.03827921f, 0.04456161f, 0.00127996f, -0.14572126f, 
    0.15318678f, -0.21747248f, 0.18811096f, -0.01779653f, 0.02264860f, -0.21379201f, -0.15112607f, 0.05542503f, 
    0.03559223f, 0.00010554f, 0.05368606f, -0.23329216f, -0.20895053f, -0.08609641f, 0.09257478f, 0.01249449f, 
    -0.03798538f, 0.02682234f, 0.07626525f, 0.21583351f, 0.38744175f, 0.22572364f, -0.28468636f, -0.13474497f, 
    -0.00349281f, -0.01342452f, -0.01763696f, 0.04238939f, -0.08765034f, 0.02735094f, -0.16964743f, 0.09305500f, 
    -0.07768404f, -0.06068335f, -0.01902648f, 0.00960743f, -0.18453762f, 0.49477735f, -0.24123399f, -0.47364593f, 
    -0.18013878f, 0.06385868f, 0.09882235f, -0.12305654f, 0.08450259f, 0.11244273f, -0.05066428f, 0.05016650f, 
    -0.06987386f, -0.03011060f, 0.06174590f, -0.06246353f, 0.02019248f, 0.09978226f, -0.00732523f, 0.15687898f, 
    0.16038378f, 0.28483808f, -0.03998005f, 0.11450029f, 0.07857592f, 0.03172921f, 0.14000481f, -0.03203918f, 
    -0.33728272f, 0.01014609f, 0.32133201f, -0.00991392f, -0.11664017f, 0.30854565f, 0.09182191f, 0.21651736f, 
    -0.10622733f, 0.30443373f, 0.15365519f, 0.00097646f, -0.16399828f, 0.16392581f, 0.10816246f, 0.14875039f, 
    -0.03437310f, -0.13403976f, 0.05155830f, 0.26468825f, 0.28200680f, 0.06261611f, -0.01754577f, 0.03118742f, 
    0.12805434f, -0.19787325f, -0.03393559f, -0.30932471f, -0.32709610f, -0.41937673f, 0.10895956f, 0.13897218f, 
    0.03537821f, -0.04977478f, 0.02083166f, -0.11152799f, -0.06049959f, -0.09842888f, -0.12707052f, 0.17200585f, 
    0.06110285f, 0.04298720f, -0.01763602f, 0.17323545f, 0.24690247f, 0.05970812f, 0.04556108f, -0.06121888f, 
    -0.01854632f, 0.07865938f, 0.09122851f, 0.02009116f, 0.14590216f, 0.15566280f, 0.23162879f, -0.01912800f, 
    -0.11354328f, -0.24770433f, 0.09889438f, 0.01518533f, -0.02637573f, -0.09933785f, 0.12513877f, 0.16743279f, 
    -0.22255343f, 0.04348956f, 0.10619835f, 0.03942221f, -0.15310644f, 0.05275124f, -0.16978836f, 0.04435829f, 
    -0.39535716f, -0.12565166f, -0.16597550f, -0.00913678f, 0.13982102f, 0.35313153f, 0.13542475f, 0.14335096f, 
    -0.14949077f, -0.36562088f, 0.21080364f, 0.17630294f, -0.05868652f, -0.05701937f, 0.01999882f, -0.01618805f, 
    0.05709590f, 0.27885517f, 0.04760460f, 0.16242962f, 0.22692896f, -0.02347478f, 0.02411943f, -0.37368184f, 
    0.11266681f, 0.07305197f, -0.03772313f, 0.27537486f, -0.26883212f, 0.22343168f, 0.07566414f, 0.01948360f, 
    -0.21935248f, -0.02645382f, 0.08510271f, 0.05709642f, 0.09933583f, 0.09243727f, 0.24873857f, 0.09041658f, 
    -0.07816886f, 0.03952048f, -0.00827099f, 0.07806419f, 0.06847318f, -0.26042613f, -0.08453149f, 0.04568703f, 
    -0.01031077f, -0.03163781f, 0.25292414f, 0.04131033f, 0.03805627f, 0.00148831f, -0.22961444f, -0.21974348f, 
    0.26436937f, -0.12097989f, 0.05790399f, 0.00259670f, 0.05474880f, 0.08661470f, -0.00011301f, 0.01068350f, 
    0.07191495f, 0.48207578f, -0.12388435f, 0.10096487f, -0.00009497f, 0.08755743f, 0.08534033f, 0.16439597f, 
    -0.26140198f, -0.08873740f, -0.22424245f, 0.12459403f, -0.01981832f, -0.25302064f, -0.02102194f, -0.00597626f, 
    0.01135831f, -0.04094954f, 0.00901922f, 0.24897555f, 0.05943038f, 0.01043858f, -0.13574904f, 0.15043455f, 
    0.06370472f, 0.20269850f, -0.17419796f, -0.30601582f, 0.48358798f, -0.00777426f, -0.05715228f, 0.01863054f, 
    0.07029768f, 0.00172669f, 0.04148862f, -0.25840110f, -0.41670686f, 0.09171937f, -0.03657456f, -0.13952596f, 
    0.17833100f, 0.07831883f, 0.04041974f, -0.12588003f, 0.05015018f, -0.13806169f, 0.20245411f, -0.08921900f, 
    -0.10764228f, -0.18450850f, 0.08182254f, -0.11517708f, 0.16268796f, -0.19157302f, -0.06344531f, -0.00653966f, 
    -0.04363932f, 0.08209886f, -0.12509525f, 0.26710448f, 0.26387134f, -0.02950945f, 0.44451636f, -0.05750613f, 
    0.17903994f, -0.04361261f, 0.00838083f, -0.13585387f, -0.17740895f, -0.00590125f, 0.03811358f, 0.08365611f, 
    -0.03495117f, 0.03886709f, -0.11924841f, -0.14947551f, 0.00364897f, -0.27964872f, 0.23513667f, 0.01192066f, 
    0.05247160f, -0.15792440f, 0.07524154f, 0.04504759f, -0.06560017f, -0.19265266f, 0.18868734f, 0.12341917f, 
    0.19239274f, 0.03774180f, -0.21551031f, 0.14317717f, -0.15268628f, 0.00561434f, 0.04249050f, -0.19310741f, 
    0.04490357f, -0.20723495f, -0.46849558f, -0.19224420f, -0.03870417f, 0.01297024f, 0.02438511f, 0.06066817f, 
    -0.14307719f, 0.09695414f, 0.17509551f, 0.21571444f, -0.16116671f, -0.11850827f, -0.14389622f, 0.05046631f, 
    0.08252002f, 0.11880004f, 0.08705357f, 0.07594596f, 0.20016868f, -0.02034017f, -0.31974286f, 0.00080789f, 
    -0.16172127f, -0.02543736f, 0.04003757f, -0.00118394f, -0.12227724f, -0.51468068f, -0.27145523f, -0.19570747f, 
    0.12835807f, -0.09494427f, -0.09117478f, -0.05462413f, -0.05187471f, -0.35832605f, -0.07033371f, -0.33116680f, 
    0.32189342f, -0.03002096f, -0.07777663f, -0.03240326f, -0.08396940f, -0.05893422f, 0.07116567f, 0.27741078f, 
    0.14197797f, -0.24211027f, 0.07021262f, 0.12471592f, -0.09936084f, -0.05179420f, -0.01862761f, 0.01126739f, 
    0.69429630f, 0.11798909f, -0.22433296f, -0.00601267f, -0.06057252f, 0.05130236f, -0.14324842f, -0.06080053f, 
    -0.20211090f, 0.41569215f, -0.05033777f, -0.23631839f, -0.02005474f, -0.08053817f, -0.18110548f, 0.09872990f, 
    0.04118327f, 0.03555125f, 0.22464773f, 0.29176065f, -0.15309983f, 0.06482064f, 0.06577691f, -0.04849018f, 
    -0.14683105f, 0.05015950f, -0.27368435f, -0.08948044f, -0.33129564f, 0.59376448f, -0.13215794f, 0.00051486f, 
    -0.07917152f, 0.13015209f, -0.13351515f, 0.10934605f, 0.07090326f, -0.11569549f, 0.15174554f, 0.02633161f, 
    -0.00550056f, -0.20297936f, 0.21415991f, -0.01129968f, 0.11656670f, 0.11313367f, -0.02217203f, 0.09099262f, 
    0.06116459f, 0.05472597f, 0.03665667f, 0.15753447f, -0.00642715f, 0.12720254f, -0.22225221f, -0.04104660f, 
    0.02773304f, -0.21396880f, 0.12649697f, 0.11275033f, 0.02494762f, -0.08289182f, 0.14057295f, -0.19669838f, 
    -0.37458739f, -0.06237193f, 0.04903698f, 0.14106090f, -0.06887224f, 0.08822671f, -0.07500816f, -0.13562424f, 
    0.39452329f, -0.14037447f, -0.51781118f, 0.10387339f, 0.00298980f, -0.08723906f, 0.08752554f, 0.06666184f, 
    0.03874611f, -0.04829527f, 0.04713672f, -0.23846474f, 0.01845330f, -0.07057240f, 0.20244040f, 0.11668100f, 
    -0.00286951f, -0.01387359f, -0.04354281f, -0.02790189f, -0.00908626f, -0.04776312f, 0.19235118f, 0.06283944f, 
    -0.13101800f, 0.17438184f, 0.24775201f, -0.06219674f, -0.18262038f, 0.20753731f, 0.12467089f, 0.03957417f, 
    -0.19117831f, 0.12549458f, 0.28221276f, 0.06566419f, 0.19379838f, -0.03994654f, -0.11883947f, 0.02960115f, 
    -0.01321414f, 0.06104525f, -0.07572920f, -0.21490948f, -0.32348174f, 0.08805349f, 0.15848015f, -0.04715648f, 
    0.11301355f, 0.15203348f, 0.06851212f, -0.08130841f, -0.19340938f, -0.26151934f, 0.08802319f, -0.07107677f, 
    -0.03658942f, 0.06038290f, -0.06356090f, 0.11992176f, -0.07234736f, -0.09551848f, 0.04982325f, 0.20407650f, 
    -0.08126226f, 0.16707963f, 0.11353463f, 0.27688482f, 0.25224069f, 0.04286152f, -0.08790419f, -0.14621861f, 
    -0.09858753f, -0.17079990f, -0.07945823f, -0.15414333f, 0.06699953f, -0.06347065f, -0.04640934f, -0.13229024f, 
    0.01850953f, 0.15285423f, -0.07875195f, -0.23301975f, 0.14443204f, 0.01298052f, 0.06351458f, 0.03247350f, 
    0.06164165f, 0.03066269f, -0.06896335f, -0.17603970f, -0.22458391f, 0.13675401f, -0.01292966f, -0.17188556f, 
    -0.24692816f, -0.10747483f, 0.00833614f, 0.38852769f, 0.14481904f, -0.21579045f, 0.02495400f, 0.07570875f, 
    0.07508213f, 0.04390233f, 0.29889378f, 0.13261646f, -0.03412443f, -0.14062619f, -0.02305762f, -0.00964458f, 
    0.07480536f, -0.01588734f, -0.21651553f, -0.05354451f, -0.13670358f, -0.10571921f, -0.01663866f, -0.40680513f, 
    0.35796535f, 0.02222958f, 0.06051939f, 0.12415275f, 0.09348510f, 0.21630356f, 0.14824137f, 0.05698710f, 
    0.06338230f, 0.03148580f, 0.05536928f, 0.21198641f, -0.18592428f, -0.08738834f, 0.23477420f, 0.39164343f, 
    -0.07110815f, -0.13750550f, -0.19452843f, -0.03639857f, 0.01548512f, -0.14720866f, 0.03434861f, -0.02989644f, 
    0.13503131f, -0.08030066f, -0.03704925f, 0.08127706f, 0.08883183f, 0.05558933f, -0.11234467f, -0.04230040f, 
    -0.02398205f, 0.14618766f, -0.03433746f, -0.16158931f, 0.04534294f, 0.05419623f, 0.06705169f, -0.21009119f, 
    -0.34146842f, 0.17113101f, 0.03210976f, 0.04308586f, -0.31228760f, 0.04498355f, -0.01886572f, 0.11438701f, 
    0.10461304f, 0.16115029f, 0.05400547f, 0.16535503f, 0.04623804f, 0.01087823f, 0.26743987f, 0.04661101f, 
    -0.18067560f, -0.03560304f, -0.00292780f, -0.13100776f, 0.17729977f, 0.26624691f, 0.06989260f, 0.02868710f, 
    -0.03294133f, -0.00504531f, -0.05305272f, 0.20865907f, -0.01707932f, -0.45512533f, 0.04767937f, -0.43397304f, 
    0.07156075f, -0.18584214f, 0.19768512f, 0.15963079f, 0.00464320f, 0.12659450f, -0.09523731f, -0.08712487f, 
    -0.17147270f, 0.03690871f, -0.31143650f, 0.05833398f, 0.14325848f, -0.04892408f, -0.05451834f, 0.16084167f, 
    -0.05668574f, 0.10067538f, 0.26956660f, 0.21955165f, -0.09408604f, -0.02383577f, 0.09625158f, -0.17381491f, 
    0.05985418f, -0.14946947f, 0.19033231f, -0.05991523f, -0.10556161f, -0.05896993f, -0.03411133f, 0.06745714f, 
    -0.07141222f, -0.12795551f, -0.14631821f, -0.03833607f, 0.06038695f, -0.05670906f, -0.31121811f, -0.09784093f, 
    0.07097527f, 0.10774140f, 0.02151997f, 0.09988984f, 0.07239411f, 0.33109236f, 0.19844714f, 0.00739545f, 
    -0.08555280f, -0.02700069f, -0.05361863f, 0.02569969f, -0.30364868f, 0.08945108f, 0.07600087f, 0.02618964f, 
    0.09878257f, 0.06854971f, 0.03223066f, 0.34157771f, 0.01709295f, -0.04426295f, 0.08118568f, 0.15375361f, 
    0.05489615f, 0.09297053f, 0.12238962f, -0.11254189f, -0.30214688f, -0.18465398f, -0.07602499f, 0.04649039f, 
    0.11569088f, -0.01283074f, -0.15988572f, 0.01790397f, -0.17635404f, -0.25040400f, -0.35931870f, -0.12194749f, 
    -0.16607025f, 0.15016647f, -0.12363951f, 0.04925257f, 0.13121419f, -0.06329719f, 0.07649533f, 0.11730673f, 
    -0.14854524f, -0.00685583f, 0.27385294f, 0.11047585f, -0.01492611f, 0.02616185f, 0.18206125f, 0.08279327f, 
    0.10908139f, -0.19875439f, 0.04729196f, -0.10677488f, -0.14773379f, -0.12536919f, -0.05213300f, -0.08477961f, 
    0.24421844f, 0.06830785f, -0.17688042f, -0.16752440f, 0.01441466f, -0.06607953f, -0.00244278f, 0.03282531f, 
    0.13741615f, 0.01320593f, 0.25637525f, 0.11792307f, 0.01692806f, 0.04872992f, -0.19156712f, 0.11951920f, 
    -0.06602401f, -0.18290821f, -0.31389514f, 0.03719206f, 0.37371162f, 0.23894009f, -0.09535810f, 0.06372292f, 
    0.03978074f, -0.06400171f, 0.00500499f, 0.04008045f, 0.05571345f, -0.06681561f, 0.15447831f, 0.06356243f, 
    0.11321862f, 0.07840015f, 0.23188432f, 0.12540150f, -0.06832468f, 0.10760172f, -0.08888106f, 0.00668053f, 
    0.13774168f, 0.00387284f, -0.14931527f, 0.34479588f, 0.00563761f, 0.08515883f, 0.04354346f, -0.01076632f, 
    -0.10286942f, 0.16753866f, -0.15056570f, 0.09535807f, 0.07976224f, 0.12066931f, 0.01021309f, -0.19171739f, 
    -0.44573364f, -0.25170302f, 0.00125688f, -0.17075734f, 0.03662761f, 0.01373295f, 0.09365464f, 0.04186540f, 
    0.31697392f, 0.14310534f, 0.38007671f, -0.02764744f, 0.09591144f, 0.20558915f, 0.15115345f, 0.14258234f, 
    0.25312808f, -0.17106657f, -0.12345273f, -0.10279191f, -0.12661278f, -0.08911058f, 0.04784351f, 0.10877082f, 
    0.07270335f, -0.16353758f, 0.13322270f, 0.07417914f, -0.01012786f, 0.08818638f, 0.10739493f, 0.09688441f, 
    0.20248604f, 0.00613532f, 0.16449885f, 0.00283961f, -0.17027240f, 0.07079680f, -0.03658747f, -0.08592524f, 
    0.00067566f, -0.31501919f, 0.03444449f, -0.08839805f, 0.22493018f, -0.05551761f, -0.03585770f, 0.08646854f, 
    0.05670298f, 0.08001661f, -0.02406288f, 0.07077619f, 0.26003692f, -0.09685815f, -0.18925609f, -0.34383941f, 
    -0.18986353f, -0.15435122f, 0.00756380f, -0.47128421f, -0.32877883f, -0.23765849f, -0.26525268f, -0.10605223f, 
    0.02467838f, 0.10376549f, -0.04124124f, -0.06824542f, 0.16514179f, 0.02115583f, -0.06191354f, -0.12648164f, 
    -0.02220840f, 0.27549076f, 0.26531130f, -0.03489751f, 0.14360167f, 0.04032725f, 0.09640959f, -0.18542947f, 
    -0.09290010f, -0.14794409f, -0.08744976f, 0.11528417f, -0.04789118f, 0.09147253f, 0.11033199f, 0.13896251f, 
    0.04398807f, -0.11023705f, -0.10507622f, -0.09927457f, 0.10990173f, 0.08010923f, 0.11263953f, 0.18229380f, 
    0.04060654f, -0.10484347f, -0.03478524f, -0.09381855f, -0.03072561f, 0.16984643f, 0.01990195f, -0.01792623f, 
    0.14475915f, 0.06238766f, 0.00886901f, -0.11562245f, 0.03800365f, 0.16785719f, 0.07574412f, -0.08242332f, 
    0.09470091f, 0.00467259f, 0.06127004f, 0.02786554f, -0.14932048f, -0.06763105f, 0.03022557f, 0.06859698f, 
    -0.03366714f, 0.18196005f, -0.12876903f, 0.21074902f, 0.09809390f, 0.02890163f, 0.04144188f, -0.00661730f, 
    0.07507522f, -0.03061808f, -0.00431173f, 0.06840140f, 0.25326034f, 0.13886264f, 0.12005042f, 0.28278777f, 
    -0.03657422f, 0.12844718f, 0.14054653f, 0.14753126f, 0.07801754f, 0.16213176f, 0.33049083f, -0.08232746f, 
    -0.16125157f, 0.26987946f, 0.10238216f, 0.05514764f, -0.05448411f, 0.05911043f, -0.04372434f, -0.01829654f, 
    0.07570294f, -0.12921208f, 0.33564103f, -0.00949391f, -0.01040151f, 0.10335195f, -0.08873715f, -0.13401270f, 
    0.18212302f, 0.13240194f, 0.31935167f, 0.41698852f, 0.08362268f, 0.13067985f, -0.04413395f, 0.12480213f, 
    -0.11645753f, 0.22931892f, -0.11747015f, -0.04246578f, -0.03775361f, -0.10894649f, -0.00731547f, -0.09379815f, 
    0.17158222f, 0.03325807f, 0.14336389f, -0.02129961f, 0.18371682f, -0.16729751f, 0.10223679f, 0.11060076f, 
    0.14894137f, -0.08520576f, 0.10660261f, -0.02722338f, 0.03681726f, -0.04285474f, 0.18824676f, 0.14239480f, 
    -0.05808911f, -0.10232019f, 0.01833704f, 0.12164259f, 0.24559550f, 0.08358347f, -0.04169893f, 0.33569890f, 
    -0.13406195f, -0.01334404f, 0.01133454f, 0.15229541f, 0.09897234f, 0.19952531f, 0.25249454f, -0.02068341f, 
    -0.01558198f, 0.01835446f, 0.29042077f, 0.07983640f, 0.14714803f, 0.12331101f, 0.17740114f, -0.22166978f, 
    -0.20112963f, -0.09779624f, -0.13546303f, -0.21229598f, 0.07220948f, 0.13873163f, -0.04106879f, -0.21115911f, 
    -0.05388772f, 0.06847259f, -0.11904650f, 0.03635960f, 0.00202268f, 0.32658222f, 0.11389870f, 0.19174129f, 
    -0.08122586f, -0.37011147f, 0.16455306f, -0.11070366f, -0.01418181f, 0.15961953f, -0.15274891f, -0.00009254f, 
    0.34533593f, 0.03270989f, 0.33358294f, -0.25586110f, -0.56311095f, 0.00417926f, 0.03001932f, 0.02614654f, 
    -0.10198922f, -0.03955277f, -0.13923167f, 0.43933254f, -0.02774132f, -0.75500458f, -0.16461104f, -0.00959573f, 
    0.03827991f, 0.11158628f, 0.12708056f, 0.05289484f, 0.23361273f, -0.15757687f, -0.23277269f, -0.16157146f, 
    0.09634876f, 0.03926757f, 0.11545043f, 0.09431312f, 0.17482492f, -0.30512705f, -0.13747092f, -0.02503485f, 
    -0.07691132f, 0.03767995f, -0.07046048f, 0.23805301f, 0.13941196f, 0.06076328f, -0.55212742f, 0.24002668f, 
    0.09322354f, 0.08394340f, 0.14816079f, -0.09132548f, -0.04358124f, 0.11755261f, -0.05527517f, -0.38698170f, 
    0.11866084f, 0.14773934f, -0.11069509f, -0.10217003f, -0.07948824f, 0.02041540f, 0.06988566f, 0.15360722f, 
    0.20813432f, -0.26404637f, -0.22715460f, -0.00918065f, -0.12152284f, 0.00274445f, -0.06466448f, -0.04394846f, 
    -0.00281731f, -0.14073451f, 0.13251512f, 0.16341105f, -0.13182989f, -0.08360697f, -0.26938415f, -0.01037669f, 
    0.17663519f, -0.06643508f, -0.54613519f, 0.21943115f, 0.14512257f, 0.03406617f, -0.02475529f, -0.00451024f, 
    0.18039712f, 0.08926293f, -0.13205744f, 0.02527605f, -0.20561184f, -0.02019163f, -0.03814100f, 0.11037487f, 
    -0.04759935f, 0.14218622f, 0.05206573f, 0.04055554f, -0.19873418f, 0.03309677f, -0.08101689f, 0.05133473f, 
    -0.13856678f, -0.05327136f, 0.11105215f, 0.15067410f, 0.11742944f, -0.24287562f, 0.03241161f, -0.07773862f, 
    -0.01957189f, 0.01838402f, 0.03111495f, -0.16808790f, -0.01887867f, -0.23643629f, 0.04552226f, 0.10692116f, 
    -0.01380949f, -0.11070298f, -0.02753930f, -0.10439564f, 0.05774064f, -0.01933719f, -0.03123767f, -0.24633327f, 
    -0.28596830f, 0.33415040f, -0.13266222f, -0.01167240f, -0.10597704f, 0.28077808f, 0.19007391f, 0.02271030f, 
    -0.13345802f, 0.07540799f, -0.03278051f, -0.23082168f, 0.02135809f, -0.09312723f, -0.02278968f, 0.04639697f, 
    -0.00388057f, -0.00910813f, 0.02190274f, -0.06839493f, -0.03394083f, 0.08601162f, -0.00277242f, -0.05315212f, 
    -0.02526722f, 0.04781258f, -0.19888775f, -0.09919040f, -0.00121886f, -0.03552819f, 0.06747597f, -0.09608214f, 
    0.10755417f, 0.09053338f, 0.04272191f, -0.10963235f, -0.20989618f, 0.38035807f, -0.21697822f, 0.14560319f, 
    -0.16059026f, 0.12637904f, 0.09362122f, 0.05159484f, -0.50524771f, -0.13630071f, 0.43958023f, -0.12481306f, 
    -0.05816767f, -0.04259130f, 0.02132049f, 0.07499197f, -0.00735610f, 0.18807133f, -0.25671259f, 0.23388132f, 
    -0.11231937f, 0.20335418f, 0.17895381f, -0.08567877f, 0.11054314f, 0.17975809f, -0.24694695f, 0.06316510f, 
    0.29291421f, 0.19742645f, 0.07688361f, -0.08812474f, 0.06056625f, -0.05652788f, -0.02798048f, 0.32182303f, 
    -0.10341821f, -0.04662362f, -0.17925918f, 0.04375611f, -0.22113982f, 0.00861037f, -0.03331069f, -0.03301939f, 
    0.28905505f, 0.01305695f, 0.21592972f, 0.09626637f, -0.02733061f, 0.09680101f, -0.01131501f, 0.13214803f, 
    0.01606196f, 0.05464651f, -0.02991782f, 0.20966336f, 0.06522613f, -0.04812883f, -0.14036122f, 0.06739458f, 
    -0.02363191f, -0.03865019f, 0.04893653f, -0.03850735f, -0.33377862f, 0.03452861f, -0.11158126f, -0.03435201f, 
    0.04091926f, 0.06137310f, 0.06684516f, -0.00350176f, -0.05666886f, 0.09411252f, -0.00366806f, 0.20368871f, 
    0.00720314f, 0.01815852f, 0.07534430f, 0.11618010f, -0.01639047f, -0.12839757f, -0.22187293f, 0.11094805f, 
    0.07130378f, 0.06651478f, 0.18190618f, -0.02554472f, -0.00209916f, 0.01937783f, -0.16932556f, -0.11861838f, 
    -0.00270903f, 0.00602207f, -0.04213667f, 0.07529262f, -0.00366673f, -0.05547430f, 0.27844775f, 0.01441001f, 
    0.06450573f, -0.05507426f, 0.09723077f, 0.19428255f, 0.02251584f, 0.03809932f, 0.05804793f, -0.18544139f, 
    0.09315305f, 0.13793266f, -0.07619517f, -0.09042460f, -0.10005153f, 0.00722214f, -0.20802666f, -0.06772025f, 
    0.13185315f, -0.01961113f, -0.04803132f, -0.20859887f, -0.19856322f, 0.00654732f, 0.17106596f, 0.06974972f, 
    -0.15426768f, 0.43733963f, -0.04966781f, -0.04043529f, 0.02994286f, 0.07805190f, -0.07656341f, -0.07356802f, 
    0.20595296f, 0.01634973f, -0.24147424f, -0.02302787f, -0.45419893f, -0.19021742f, -0.00179642f, -0.03458527f, 
    -0.10462262f, 0.04708946f, 0.31796157f, -0.42170534f, -0.06181011f, 0.07451519f, 0.05201676f, -0.04548207f, 
    0.04116157f, -0.18444978f, 0.24176538f, 0.15823638f, -0.36860928f, 0.09593633f, 0.10668515f, 0.03345593f, 
    -0.17436981f, -0.14449359f, -0.07547676f, -0.15121756f, -0.13799186f, 0.33993807f, -0.00654392f, -0.10672947f, 
    -0.02566158f, 0.08742414f, 0.03930609f, -0.19827302f, 0.11755144f, -0.13480245f, 0.10786050f, -0.07393429f, 
    0.02762778f, 0.18041869f, 0.14208402f, -0.00991542f, 0.15224572f, 0.03203240f, -0.10487319f, 0.19854774f, 
    -0.10573817f, -0.05591970f, 0.01584024f, -0.05245724f, -0.23097970f, -0.04143737f, -0.11938732f, -0.28630954f, 
    0.18468633f, 0.20146903f, 0.04875597f, 0.11878683f, -0.00068602f, 0.09082308f, 0.15797831f, 0.00305604f, 
    -0.08423746f, 0.27352732f, 0.00595824f, 0.31607941f, 0.13191305f, -0.08762357f, -0.01210258f, -0.05054864f, 
    0.03956489f, -0.02176372f, 0.20137322f, -0.00495020f, 0.23717387f, 0.05711475f, 0.02047040f, 0.34126744f, 
    0.00749725f, 0.08437782f, -0.18568622f, -0.45102546f, 0.10959583f, 0.29069808f, -0.19608794f, 0.08037665f, 
    -0.02532218f, 0.11522429f, -0.04120636f, -0.10753763f, 0.07153174f, 0.12277768f, 0.09164645f, 0.00402947f, 
    -0.06071628f, -0.03845191f, 0.04449247f, 0.24106260f, -0.01092347f, -0.00331893f, -0.20087479f, 0.01984912f, 
    -0.23441365f, -0.15221712f, -0.06726157f, -0.05787968f, 0.08477176f, 0.00167990f, -0.14295508f, 0.03101472f, 
    -0.02385273f, 0.05419954f, -0.18193044f, -0.23050831f, -0.00994673f, 0.04582144f, -0.01208339f, -0.20203093f, 
    -0.26182860f, 0.04428061f, -0.07883814f, 0.19297944f, -0.01280434f, 0.25177905f, 0.03540913f, 0.00245032f, 
    -0.08461633f, 0.23900561f, -0.08732948f, 0.06932760f, -0.03860186f, -0.18801066f, 0.01559386f, -0.01214067f, 
    -0.03628697f, -0.16470638f, 0.13581733f, 0.03223635f, 0.09158644f, -0.05012718f, 0.07231108f, 0.03945018f, 
    0.15210144f, -0.02390864f, 0.29297256f, 0.00271729f, 0.15178028f, -0.11212795f, 0.07311229f, 0.05213903f, 
    0.03049424f, 0.16088125f, -0.05536417f, -0.04924181f, -0.10231034f, -0.05830548f, -0.22135228f, -0.21812786f, 
    -0.19070430f, 0.14769708f, -0.05244785f, 0.12249374f, -0.20188776f, -0.06416377f, -0.00718433f, 0.06381582f, 
    0.01632506f, 0.13731706f, -0.04996387f, 0.06363690f, 0.13356501f, 0.19545655f, 0.10888218f, 0.68717635f, 
    -0.04504533f, 0.01630096f, 0.25927067f, 0.19167738f, -0.13245389f, 0.08990790f, 0.08409334f, -0.06050805f, 
    0.35194939f, 0.12800236f, 0.06118384f, 0.08658832f, 0.21729410f, 0.14147851f, 0.22352675f, -0.31045860f, 
    -0.10989508f, 0.10112507f, -0.16264093f, -0.09591035f, -0.13451433f, 0.01728860f, -0.04572166f, 0.16993898f, 
    -0.59424442f, -0.14614789f, 0.15078011f, 0.07736449f, 0.12380030f, -0.11304506f, 0.11519808f, -0.00535123f, 
    0.18303271f, -0.26609012f, -0.07769408f, 0.29122430f, -0.08833379f, -0.07084870f, 0.02721844f, 0.27482939f, 
    0.07485425f, 0.28589207f, -0.03054661f, -0.19322982f, -0.26230964f, 0.05337154f, -0.04559252f, 0.01665609f, 
    0.00476419f, 0.07479069f, 0.15629385f, -0.18655933f, -0.07688057f, 0.06063217f, 0.14578064f, -0.20594725f, 
    0.12655228f, -0.21565241f, 0.19314049f, 0.17908721f, -0.13874771f, 0.08181355f, -0.08228243f, -0.18070203f, 
    -0.03077224f, 0.02433739f, 0.00788577f, 0.08572014f, -0.17852467f, -0.02403848f, 0.01101024f, -0.13497755f, 
    -0.04788854f, 0.03451492f, -0.01426805f, -0.00110167f, -0.05175750f, -0.16587655f, 0.33204705f, 0.08625184f, 
    0.19288598f, 0.01904958f, -0.06663322f, 0.11285139f, 0.06012212f, 0.08585727f, -0.20829804f, -0.03706518f, 
    0.05918527f, 0.01423040f, -0.04524832f, -0.17202766f, -0.02439573f, 0.02722258f, -0.06385835f, -0.12373365f, 
    -0.12542437f, 0.17884615f, -0.18490051f, -0.17988944f, -0.10029870f, 0.29164895f, 0.23538882f, -0.01901814f, 
    0.26890743f, 0.20632197f, -0.03445898f, 0.00854564f, 0.03082767f, -0.00472448f, 0.02058537f, 0.03923222f, 
    0.03119236f, 0.15418859f, -0.33820191f, -0.15143919f, -0.38033825f, -0.04030299f, -0.04790245f, -0.21183206f, 
    0.00694730f, -0.05032048f, 0.07839453f, -0.36527216f, -0.06735314f, 0.09394377f, -0.16205141f, -0.10042603f, 
    0.03691688f, 0.04785150f, -0.00364968f, 0.02295331f, -0.39998937f, 0.13248172f, 0.10690434f, 0.02028576f, 
    0.08158461f, -0.02180545f, -0.00269602f, 0.03124661f, -0.17327300f, 0.06027916f, -0.02043647f, -0.11599109f, 
    0.10121543f, 0.06347024f, 0.22560883f, 0.00163777f, -0.01394993f, 0.15438884f, 0.09547427f, 0.04799662f, 
    -0.01069482f, -0.00852178f, 0.03902778f, 0.01855230f, 0.12760317f, -0.13744454f, 0.03617030f, -0.00264836f, 
    0.09893230f, -0.12878124f, -0.15552357f, -0.08514190f, 0.00355554f, -0.05206641f, 0.07418649f, -0.02449110f, 
    0.04154920f, 0.28766048f, -0.02605669f, 0.09326927f, 0.06962967f, -0.03326834f, 0.32202345f, 0.18833239f, 
    -0.01979363f, 0.12203183f, 0.14420284f, 0.16672620f, 0.01317965f, -0.24297358f, -0.11691423f, -0.10717855f, 
    0.08091513f, 0.08247835f, 0.08805659f, 0.19983055f, 0.11614984f, 0.07257347f, 0.18223220f, 0.18559322f, 
    -0.00694603f, 0.09161276f, -0.10446017f, -0.25301799f, 0.19138341f, 0.03414446f, 0.09099957f, 0.32509696f, 
    -0.10506639f, -0.02687804f, 0.15361866f, 0.09122356f, 0.10467373f, 0.21646833f, 0.17192507f, 0.04623822f, 
    -0.04084460f, 0.04339242f, -0.08318938f, -0.18110424f, -0.14538944f, -0.08352199f, 0.06296068f, 0.13230354f, 
    -0.16678414f, -0.18925889f, 0.04842300f, -0.00508248f, -0.06104353f, 0.18050663f, -0.01121041f, 0.09867990f, 
    -0.15784676f, 0.02568767f, -0.16425672f, 0.07798561f, -0.04386658f, -0.10444372f, -0.07671623f, -0.19084586f, 
    -0.01351153f, 0.02256878f, 0.04292775f, 0.09334663f, 0.03201480f, 0.14144894f, 0.27204067f, 0.25374493f, 
    -0.07407158f, 0.16604047f, 0.05289720f, 0.02455739f, -0.00704378f, -0.02812621f, 0.04812232f, -0.08154659f, 
    -0.05347248f, -0.01632438f, 0.23490554f, -0.13578206f, -0.03925706f, -0.12879845f, 0.22609563f, 0.09961665f, 
    -0.04301722f, -0.16047205f, 0.23057781f, 0.01437004f, 0.14671259f, -0.10197315f, 0.16508955f, 0.06662761f, 
    0.16925928f, -0.04393474f, 0.17881301f, -0.07553577f, -0.10526798f, 0.02689914f, -0.07011564f, -0.15604773f, 
    -0.11731730f, 0.08821360f, -0.12258211f, -0.04289740f, -0.12039238f, 0.11963948f, -0.02107949f, -0.06868328f, 
    0.07212818f, 0.00283021f, 0.06866775f, -0.24193768f, 0.02944127f, 0.13572179f, 0.12353345f, 0.38760138f, 
    -0.05402419f, -0.00862364f, 0.03184183f, -0.18773192f, 0.18794751f, 0.04415724f, -0.02203060f, 0.01683613f, 
    0.17621799f, -0.08008556f, -0.01196745f, -0.06937900f, 0.15506141f, 0.20427009f, 0.04188272f, -0.30925781f, 
    -0.08589721f, 0.15353240f, -0.00688896f, 0.02253617f, -0.01070574f, 0.04793634f, -0.09913644f, -0.42875415f, 
    -0.26537934f, -0.05886786f, 0.11296542f, 0.21271008f, 0.18688561f, 0.12124506f, 0.00323347f, 0.16507249f, 
    -0.14601901f, -0.24843277f, 0.04499193f, 0.14228062f, 0.09871536f, 0.18082216f, -0.11888080f, 0.01361793f, 
    0.13288809f, -0.14102621f, -0.00847558f, -0.23104960f, -0.50753176f, -0.00675610f, 0.02155427f, -0.08660857f, 
    0.02519397f, -0.08348768f, -0.15850396f, -0.19116938f, -0.03711334f, 0.20010448f, -0.02393728f, -0.22308972f, 
    -0.11429611f, 0.05203915f, -0.11596768f, 0.00657838f, -0.04136889f, 0.13727650f, -0.02768845f, -0.11468861f, 
    0.06600587f, 0.14999071f, 0.00517331f, -0.02016575f, 0.03721530f, -0.06028962f, 0.15307672f, -0.13423496f, 
    0.01062075f, 0.13723060f, 0.21430020f, 0.09016933f, 0.05201900f, 0.03358229f, 0.34331459f, 0.01395524f, 
    0.20715985f, -0.23362605f, 0.00937445f, 0.16353840f, 0.06954390f, 0.22657010f, 0.09456230f, -0.04449736f, 
    0.22173600f, -0.00993746f, -0.04333199f, -0.20994671f, -0.21182323f, 0.13611577f, -0.02720184f, 0.13260312f, 
    0.01075085f, -0.28970823f, 0.36800089f, 0.02752136f, 0.09845018f, -0.17759433f, 0.12182334f, -0.15252185f, 
    -0.16280691f, 0.52961171f, 0.11703642f, 0.17948328f, -0.06042014f, 0.17950353f, 0.05847945f, -0.16802539f, 
    0.08651557f, 0.13261928f, -0.20795949f, -0.24319805f, -0.36744344f, -0.01173259f, 0.08265810f, -0.09105437f, 
    -0.05423920f, -0.23480128f, -0.06215609f, -0.30331323f, -0.06883742f, -0.21815337f, -0.07407409f, 0.20482723f, 
    -0.11022750f, -0.02781294f, 0.01985564f, -0.07370878f, -0.00825068f, -0.00209745f, 0.15706293f, 0.03115163f, 
    0.00453180f, -0.04086605f, -0.01428546f, 0.01293849f, 0.16978669f, 0.22476113f, 0.05670909f, 0.13502614f, 
    -0.03721540f, 0.03591514f, 0.26439834f, -0.06354694f, 0.29150277f, -0.00059441f, 0.15966134f, -0.02355466f, 
    0.24627863f, 0.06916229f, 0.15149295f, -0.04985201f, 0.12640397f, 0.19132569f, -0.03099925f, 0.12468889f, 
    0.08111125f, 0.29530418f, -0.07232078f, 0.01940526f, -0.07881168f, -0.01550162f, 0.07931846f, -0.09862704f, 
    0.16463679f, -0.17792469f, 0.51745248f, 0.09527964f, 0.09665713f, -0.20064978f, 0.10195088f, 0.12904137f, 
    0.00961191f, 0.30662504f, 0.15176995f, 0.20704229f, -0.12068903f, 0.05464217f, -0.06818010f, -0.12926283f, 
    0.03197262f, 0.12837724f, 0.02299383f, -0.09679377f, 0.16917235f, -0.10181727f, 0.00457980f, 0.06956773f, 
    -0.07116830f, -0.05045687f, -0.13671112f, -0.43097678f, 0.06394706f, 0.53866923f, 0.11178213f, -0.12886171f, 
    0.31302628f, -0.18843439f, -0.15289968f, -0.04859622f, -0.02544714f, 0.00376453f, 0.22205426f, 0.02362415f, 
    0.14582521f, -0.00182968f, -0.05030920f, 0.08023474f, 0.19684535f, 0.18446809f, -0.29963183f, 0.10215567f, 
    -0.00843932f, -0.07931056f, 0.01301760f, -0.06374344f, -0.03341059f, 0.09436182f, -0.31791449f, -0.14683110f, 
    0.12355196f, 0.07183121f, -0.00670871f, -0.00870977f, -0.12539174f, 0.07525553f, 0.03958336f, 0.08785909f, 
    -0.17221323f, 0.29804480f, 0.13244289f, -0.00583403f, 0.08561034f, 0.03845995f, -0.07859953f, -0.01403649f, 
    -0.19320640f, -0.02932570f, 0.14866590f, -0.04946100f, -0.02018400f, -0.02225523f, -0.10857908f, 0.05347363f, 
    -0.01408815f, -0.45916921f, -0.01987012f, -0.16020595f, -0.03370564f, 0.04128376f, 0.01907219f, -0.07011963f, 
    0.13181105f, 0.10432991f, 0.42011347f, 0.04571095f, 0.40409422f, -0.09579957f, 0.09390417f, 0.09209783f, 
    -0.01196899f, -0.02126178f, 0.04473070f, -0.01505597f, -0.35239869f, -0.40170562f, -0.10964774f, 0.07402278f, 
    -0.28871533f, 0.22517435f, -0.11633960f, 0.14081852f, -0.00486386f, -0.23152021f, -0.01292723f, 0.04687577f, 
    -0.18281367f, 0.06280394f, -0.15599193f, 0.00050658f, 0.12254617f, 0.03830494f, -0.27322930f, 0.38316661f, 
    -0.16246486f, -0.18206419f, 0.16650693f, -0.17488690f, -0.52924806f, 0.30802262f, -0.14484705f, -0.06875190f, 
    -0.04966767f, 0.01262046f, -0.06240493f, -0.07810740f, -0.05338636f, -0.10084155f, 0.14986825f, 0.13583155f, 
    0.09965896f, -0.17105663f, -0.03856636f, -0.05859593f, -0.09693100f, 0.05015173f, -0.03005473f, 0.19102269f, 
    -0.46323994f, -0.23578288f, -0.24477680f, 0.01145543f, -0.21780133f, 0.41139874f, 0.10752484f, 0.06566964f, 
    -0.09438311f, -0.12152324f, -0.33613586f, -0.37477747f, -0.04893198f, -0.25215405f, -0.00909999f, 0.01244892f, 
    0.02202370f, 0.10053923f, 0.23216912f, 0.39021334f, -0.11899558f, -0.18033783f, -0.20976049f, -0.45822021f, 
    0.02528602f, 0.10639706f, 0.00588466f, -0.28693235f, -0.29779929f, -0.23313281f, 0.09656138f, 0.10179738f, 
    -0.02601646f, -0.10416838f, -0.03174568f, 0.04886103f, -0.15017071f, -0.06870518f, 0.03532780f, 0.07544889f, 
    0.01870592f, 0.05475585f, 0.13763361f, 0.00690112f, 0.13687202f, -0.08218440f, 0.03642674f, -0.00333341f, 
    0.01688310f, 0.02341852f, -0.00858148f, 0.19963478f, -0.09643983f, 0.06380287f, 0.13330239f, 0.27634415f, 
    0.42871523f, -0.00187811f, 0.01018236f, 0.35918200f, -0.04339482f, -0.12870748f, 0.05399515f, 0.17756701f, 
    -0.24420184f, 0.18802333f, -0.02417857f, 0.00896903f, -0.04448496f, -0.04726383f, -0.10046699f, 0.07089581f, 
    -0.47741628f, -0.00464839f, -0.12587523f, -0.10846791f, -0.04843539f, -0.03753661f, 0.00304039f, -0.00177507f, 
    0.04972060f, 0.28215915f, 0.05556230f, -0.46224505f, 0.02572136f, 0.01927442f, 0.07943841f, -0.02385488f, 
    0.04879786f, -0.02200117f, 0.23281302f, -0.00738350f, -0.14333518f, -0.28607157f, -0.25571296f, -0.11120494f, 
    0.12009234f, 0.05533430f, 0.20663941f, -0.27688029f, 0.01824374f, 0.33743608f, -0.03298318f, 0.10386390f, 
    -0.30099902f, -0.04631245f, 0.00232021f, 0.00365593f, -0.08103351f, -0.09389516f, 0.03556575f, -0.10571449f, 
    -0.10184183f, -0.00616898f, 0.10026301f, -0.00928576f, -0.01235701f, 0.46477002f, 0.21174647f, -0.10705211f, 
    0.07451969f, 0.03132927f, 0.27798325f, -0.09560332f, -0.05231123f, -0.15929686f, 0.05062322f, -0.18579890f, 
    0.19821620f, 0.11855999f, 0.24353288f, 0.12343796f, 0.00936811f, 0.00916279f, 0.00815497f, 0.20595463f, 
    -0.35211080f, -0.06668441f, -0.09704943f, 0.05428892f, 0.01913493f, -0.06841889f, 0.02725972f, -0.24799651f, 
    -0.24899779f, -0.11356482f, -0.03042132f, 0.06535652f, -0.03563235f, 0.10946131f, 0.16389777f, 0.05668743f, 
    0.02117023f, 0.11098420f, 0.08378289f, -0.06204190f, -0.03435979f, -0.05046467f, -0.02600248f, 0.05120050f, 
    0.11800054f, 0.01258848f, 0.21779031f, 0.08601679f, 0.18727796f, -0.04118533f, 0.10502607f, 0.20527886f, 
    0.16205354f, -0.02019761f, -0.01684837f, -0.79336125f, 0.05243406f, -0.15164301f, -0.00840097f, -0.03101122f, 
    -0.07506016f, 0.06639967f, -0.13016492f, 0.10472511f, 0.11937737f, 0.20418862f, 0.13211738f, -0.06084886f, 
    -0.04518649f, -0.01251335f, -0.00335385f, 0.04709657f, -0.04281345f, -0.36781400f, -0.49392271f, -0.20956127f, 
    -0.06656112f, 0.00147269f, -0.05534709f, 0.10124714f, 0.02686140f, 0.08704249f, -0.15463606f, 0.21435227f, 
    0.21837381f, -0.19694722f, 0.01727503f, -0.19526511f, 0.11265830f, 0.13603370f, 0.04198183f, 0.12244453f, 
    -0.65571916f, -0.07699768f, -0.18466969f, 0.01239383f, 0.08551598f, 0.06473334f, 0.00319417f, -0.20565972f, 
    -0.16047814f, 0.14108901f, 0.24738272f, -0.11447472f, -0.00088967f, -0.08229142f, 0.12218926f, 0.05788590f, 
    0.13105854f, -0.15775280f, 0.25542435f, 0.26697198f, -0.23759027f, 0.06797273f, 0.05641518f, 0.16637813f, 
    0.11336750f, 0.16881733f, 0.30969033f, -0.20676394f, -0.15599285f, 0.09940554f, 0.13112238f, 0.10308480f, 
    -0.03928118f, 0.07162693f, -0.05569899f, -0.34423333f, -0.44477144f, -0.66758049f, -0.18094149f, -0.31288460f, 
    -0.16204269f, 0.15412197f, 0.10343113f, 0.12898552f, -0.00594612f, -0.49025458f, -0.39799538f, 0.16699328f, 
    0.09731346f, -0.07232238f, -0.06367675f, 0.10358330f, 0.18360296f, -0.18488266f, -0.17987528f, -0.25792554f, 
    0.00143731f, -0.05489396f, 0.13952532f, 0.07880935f, 0.08584746f, 0.08677886f, 0.02360594f, -0.32808653f, 
    0.11647433f, -0.08042191f, 0.09341338f, -0.03688340f, 0.24869736f, 0.15715972f, 0.30773380f, -0.36076766f, 
    -0.04170915f, -0.22620009f, -0.02282930f, -0.02204119f, -0.03572895f, -0.09711453f, 0.09569616f, -0.00391092f, 
    -0.69576621f, 0.00075470f, -0.59353882f, -0.09433039f, 0.03507932f, -0.18974096f, -0.10432046f, -0.04563602f, 
    0.00472275f, -0.17319198f, -0.33279580f, -0.33729997f, -0.15662333f, 0.03964226f, 0.04196410f, 0.06835207f, 
    0.04680199f, 0.05819557f, 0.03529387f, -0.23856328f, 0.30348253f, -0.17689583f, -0.07139193f, 0.00814556f, 
    0.06192974f, 0.07254259f, 0.07800295f, 0.24951194f, 0.22651623f, 0.34510523f, -0.04654872f, -0.10494538f, 
    -0.19999918f, -0.07196190f, 0.10350134f, 0.19583675f, -0.02498969f, 0.28031912f, 0.25297737f, 0.01780807f, 
    -0.06447078f, -0.22358416f, 0.05364699f, -0.07338567f, -0.05924659f, 0.02455107f, 0.31472403f, 0.17242832f, 
    0.09080552f, -0.00616331f, -0.10947894f, 0.09895362f, -0.02564799f, 0.01588506f, 0.03112072f, 0.01664179f, 
    -0.32400551f, 0.02777769f, 0.10992224f, 0.14808103f, 0.24274015f, 0.04285923f, 0.06937657f, -0.17220797f, 
    -0.05175494f, -0.14679289f, -0.05862511f, -0.04791823f, -0.20041947f, -0.06142635f, -0.10605727f, 0.18322243f, 
    0.11203932f, -0.03929937f, 0.14351803f, -0.06063563f, 0.19795880f, 0.17101263f, 0.00015983f, -0.27141869f, 
    -0.08090951f, -0.22157849f, -0.10165046f, 0.14738733f, 0.02599862f, -0.09393950f, 0.10525103f, -0.05090566f, 
    0.16964211f, 0.11108364f, -0.10538263f, -0.11565313f, -0.04501758f, -0.07861714f, -0.11833296f, -0.15360779f, 
    -0.17298301f, -0.31010512f, -0.34314233f, 0.19547568f, 0.22129093f, -0.04265849f, -0.11168414f, -0.13483834f, 
    0.06449769f, -0.12517646f, -0.02314741f, 0.03060084f, 0.02822259f, -0.04806445f, -0.14304447f, 0.13615069f, 
    0.07426412f, 0.13822827f, 0.20804136f, 0.14152467f, 0.13323355f, -0.22332194f, -0.12730536f, -0.05631033f, 
    -0.23254463f, -0.15571690f, 0.11943717f, 0.21144998f, 0.14372948f, 0.13642403f, -0.14493813f, -0.14510676f, 
    0.02929324f, 0.03633145f, -0.09088185f, 0.06505155f, 0.10759747f, 0.04535618f, 0.14320265f, -0.29993129f, 
    -0.05201276f, -0.16838719f, 0.05070286f, -0.29530102f, -0.19501284f, 0.01810846f, 0.07728243f, 0.25918284f, 
    0.24792784f, -0.17260922f, -0.06305954f, -0.00323124f, 0.09238261f, 0.17589036f, 0.07540284f, 0.02199127f, 
    0.07717004f, -0.25615829f, -0.04122704f, 0.07408766f, 0.00922087f, 0.05856441f, 0.07448929f, -0.09289826f, 
    -0.17748535f, -0.00324599f, -0.08678267f, 0.15392892f, 0.01544228f, -0.10583337f, -0.01473061f, 0.19158375f, 
    -0.11122625f, -0.04244494f, 0.09726782f, 0.08598669f, -0.03863110f, 0.04090372f, -0.13634117f, 0.02192564f, 
    0.13539934f, -0.00801206f, -0.02507099f, -0.44948739f, 0.01431239f, 0.00015302f, 0.03913525f, 0.08159424f, 
    0.15043263f, 0.00480402f, -0.10317834f, -0.01861393f, 0.05832842f, 0.02700655f, -0.07662951f, 0.02948861f, 
    0.10387691f, 0.10019043f, 0.11912326f, -0.19493257f, -0.33694199f, 0.31751877f, -0.10263962f, -0.14685716f, 
    -0.01260528f, 0.23623322f, 0.12010579f, -0.10398075f, -0.15299502f, -0.15961164f, -0.04097733f, -0.06125389f, 
    -0.12278651f, 0.06251700f, 0.03657727f, 0.09849713f, 0.07954097f, -0.04884347f, 0.04834662f, -0.04484897f, 
    -0.10522644f, -0.04484747f, 0.03074795f, -0.05680960f, 0.16815853f, 0.10630947f, -0.02856569f, -0.08924448f, 
    -0.07608549f, -0.02279357f, 0.17556532f, 0.05125519f, 0.24508622f, 0.20250650f, 0.02427260f, -0.12849714f, 
    -0.17284738f, -0.24268246f, -0.15267065f, -0.09067696f, 0.06915677f, -0.00295704f, 0.00927719f, -0.08521314f, 
    -0.11817119f, -0.17096122f, 0.05747364f, -0.04163704f, -0.06651011f, -0.16129036f, 0.10370316f, 0.26565695f, 
    0.14966917f, 0.17317474f, -0.03747585f, -0.08259752f, -0.12752655f, -0.18771270f, 0.01895755f, 0.14300026f, 
    0.05791126f, 0.12164442f, -0.09724903f, -0.00769845f, -0.45639893f, 0.29859561f, 0.02844141f, 0.19830018f, 
    0.12315781f, 0.02387507f, -0.09552216f, -0.26057580f, -0.06968291f, -0.27112049f, 0.01948170f, 0.23256190f, 
    0.01529379f, -0.03846498f, 0.11018165f, 0.13858096f, -0.11011272f, 0.12993853f, -0.08173656f, 0.00884207f, 
    -0.13205627f, -0.03964481f, 0.01877730f, 0.05828260f, 0.06508993f, 0.17317498f, -0.12656930f, 0.11838751f, 
    -0.05027904f, 0.14181073f, 0.25419059f, 0.30595672f, -0.01374941f, 0.07750164f, -0.09441083f, 0.03745969f, 
    -0.02548502f, -0.02414853f, 0.19576204f, 0.21533315f, 0.09399045f, -0.17241922f, -0.02206727f, -0.15973504f, 
    -0.20490895f, -0.20309106f, -0.09764474f, -0.14583734f, -0.25532559f, 0.05774471f, 0.03042739f, 0.04308618f, 
    0.09848447f, 0.12220197f, -0.23725109f, 0.17994829f, 0.11151969f, -0.12153747f, 0.11997592f, 0.25894728f, 
    0.15019856f, -0.06622920f, -0.20908155f, -0.05745413f, 0.05375979f, -0.05647738f, -0.11201634f, 0.08808429f, 
    -0.19860329f, -0.01743790f, 0.13960853f, 0.16817392f, 0.25878802f, 0.03847423f, -0.07728230f, 0.11379862f, 
    -0.20258184f, -0.00808556f, -0.03837462f, 0.21564147f, 0.10291368f, 0.22422926f, 0.27908170f, 0.15966636f, 
    -0.08814570f, 0.21895409f, 0.03615498f, -0.00329595f, -0.01026735f, 0.03298365f, 0.09607858f, -0.24134406f, 
    -0.05594958f, -0.01383946f, -0.06638033f, 0.06035575f, 0.13573742f, -0.17044970f, -0.34102374f, -0.45650005f, 
    0.61697656f, 0.28658137f, -0.23802088f, -0.25493255f, 0.24311101f, 0.10640260f, 0.03782627f, 0.11284154f, 
    -0.19979538f, -0.32022640f, -0.19057994f, 0.00711577f, 0.07023111f, 0.00313464f, 0.07898648f, 0.02176006f, 
    0.02897086f, 0.12571710f, 0.03506578f, -0.09281124f, -0.30602634f, 0.31421894f, -0.05731567f, -0.24129011f, 
    0.03603137f, 0.03990554f, -0.08877044f, -0.52063584f, -0.22561753f, -0.14875883f, 0.16178304f, 0.19730863f, 
    0.01707973f, -0.01787996f, 0.03912722f, 0.08913853f, 0.36494896f, 0.34491041f, 0.20173678f, 0.03409674f, 
    -0.03096421f, 0.08792733f, -0.05480133f, -0.00041360f, -0.17863743f, 0.15750749f, 0.04449425f, -0.07138098f, 
    -0.00017587f, 0.07337523f, 0.19211711f, -0.02964986f, -0.15599640f, 0.04735572f, -0.30540952f, -0.15250441f, 
    0.02045161f, -0.09204990f, 0.19638638f, 0.11000407f, 0.01531600f, 0.14957274f, 0.06727701f, -0.13256870f, 
    -0.08694753f, -0.08763619f, 0.11079854f, 0.20170146f, 0.15027469f, -0.00657863f, -0.00738302f, -0.04982601f, 
    0.04946335f, -0.02927359f, 0.04618302f, 0.08199860f, -0.01515630f, 0.19829133f, -0.00039261f, 0.11072391f, 
    -0.04892328f, -0.34581450f, -0.31528714f, -0.23307899f, 0.36613366f, -0.04240483f, 0.02340487f, 0.13459566f, 
    0.00591741f, 0.08672847f, 0.17987718f, 0.01269336f, -0.16629075f, -0.12327156f, 0.05980688f, 0.02185823f, 
    0.05193321f, 0.20264207f, 0.07581234f, 0.13220029f, -0.14065085f, -0.05581132f, -0.08583741f, 0.09509035f, 
    -0.36315203f, 0.01757799f, 0.15161587f, -0.19877078f, 0.04229083f, -0.26743484f, -0.43717751f, 0.05702252f, 
    0.05721583f, 0.13908942f, 0.06870177f, 0.04931270f, 0.10841697f, 0.03259266f, -0.26368675f, -0.10270207f, 
    -0.02316397f, -0.12887272f, 0.08555432f, 0.09346329f, 0.09386929f, -0.15099688f, -0.34873286f, -0.24230053f, 
    -0.20287207f, 0.06603996f, -0.13296819f, -0.09342999f, -0.07041609f, 0.04319678f, 0.04746732f, -0.29555342f, 
    -0.11240574f, -0.19005120f, -0.17182514f, 0.05049115f, 0.26829129f, -0.10562075f, 0.25510943f, -0.17628793f, 
    -0.14002118f, -0.38556755f, -0.40141919f, 0.05407497f, -0.02460765f, -0.00983192f, 0.08061723f, -0.02197558f, 
    0.06542477f, -0.08588830f, 0.05356273f, 0.21229844f, 0.06206369f, -0.11334684f, -0.02815628f, -0.05692203f, 
    0.00086210f, -0.04497985f, -0.44925806f, -0.30279785f, -0.10946118f, 0.13447613f, 0.05189202f, -0.06481183f, 
    -0.11755782f, 0.02926806f, 0.17571232f, 0.15836038f, 0.22030675f, -0.01348088f, -0.23859082f, 0.06600370f, 
    0.14480330f, 0.02101395f, -0.05841487f, -0.12463356f, 0.05247289f, 0.02873789f, 0.20951425f, 0.00035368f, 
    0.08441148f, -0.05643418f, -0.24261542f, -0.18531089f, -0.24769785f, 0.13567315f, 0.24318106f, 0.02755642f, 
    0.18184251f, 0.06642724f, 0.05161336f, -0.07631181f, 0.21148098f, 0.14224088f, -0.10795771f, 0.06539168f, 
    0.14128816f, 0.26435071f, 0.13073516f, 0.03909357f, -0.00500153f, 0.07222509f, 0.19481257f, -0.04119484f, 
    -0.05979932f, 0.11011034f, -0.08923282f, 0.19314948f, 0.07184896f, 0.11088844f, 0.10118937f, -0.14586034f, 
    -0.02063703f, 0.29111955f, 0.49326867f, 0.03632598f, 0.10492881f, -0.03803944f, 0.07874160f, 0.08423253f, 
    -0.17544642f, 0.13793646f, 0.15695085f, -0.03472262f, 0.05593113f, 0.06041208f, 0.20780203f, -0.01628776f, 
    -0.23164085f, -0.13391227f, -0.06140940f, 0.18071164f, 0.08956049f, 0.02202388f, -0.04307741f, 0.05993257f, 
    -0.00536656f, -0.05425008f, -0.30660352f, -0.67560041f, -0.23704809f, -0.16483763f, 0.24407883f, 0.20350356f, 
    -0.15066773f, -0.03516144f, -0.05498568f, 0.10934828f, 0.02999166f, 0.03693610f, 0.02220785f, -0.02212351f, 
    -0.06178235f, 0.05619224f, 0.07059128f, 0.10304829f, 0.00561157f, 0.10875992f, 0.10661921f, 0.01960604f, 
    -0.12665817f, 0.09635565f, 0.13600442f, 0.10058895f, 0.13229211f, -0.08250756f, -0.11296988f, 0.15994130f, 
    -0.19407077f, 0.02747486f, 0.07597275f, 0.16592908f, 0.17940316f, 0.19666602f, 0.11998249f, -0.23984782f, 
    -0.36704805f, 0.09532999f, 0.03739524f, -0.09500550f, -0.17232980f, -0.01602793f, -0.05643708f, -0.07700045f, 
    0.01016908f, -0.03346108f, -0.04309098f, 0.03373523f, -0.03789862f, -0.00534381f, -0.01146309f, -0.01054887f, 
    0.04896891f, -0.04447708f, -0.01503325f, -0.02918795f, 0.03354603f, -0.04567781f, 0.02126060f, -0.03984431f, 
    0.00304525f, 0.00814845f, 0.02850182f, -0.05572491f, -0.03840446f, -0.00958803f, 0.04206054f, 0.04051469f, 
    -0.02492174f, 0.02108077f, 0.04088939f, -0.01627817f, -0.05759609f, 0.00034027f, 0.04559277f, 0.04508442f, 
    0.04163214f, 0.03815126f, 0.02724701f, -0.00143439f, -0.00933927f, -0.01855301f, 0.00603708f, 0.01313978f, 
    -0.00119969f, -0.03306219f, -0.04141807f, -0.00758094f, -0.03805797f, -0.02535713f, -0.01795925f, 0.05227018f, 
    -0.04098191f, -0.03384585f, -0.00047769f, 0.00058182f, 0.03581739f, 0.02764983f, -0.03006067f, -0.00015404f, 
    0.05015973f, -0.00119184f, 0.00199173f, -0.02048853f, -0.02245622f, -0.05552646f, -0.00222702f, -0.02492903f, 
    0.01227739f, -0.03771826f, -0.04721448f, -0.00058416f, -0.03698502f, -0.06029959f, 0.02010974f, -0.01019477f, 
    0.00244490f, -0.04691916f, -0.06243673f, -0.04696074f, 0.02355745f, -0.03676592f, -0.03242217f, -0.00921698f, 
    -0.03478494f, -0.04448711f, 0.02383163f, 0.04920222f, 0.00449729f, -0.00390149f, -0.01467457f, -0.01951329f, 
    -0.05582632f, 0.00649169f, 0.00440873f, -0.00538657f, -0.01970264f, -0.05948946f, -0.02207853f, 0.00334311f, 
    0.01348634f, 0.03007842f, 0.03464735f, -0.05066136f, 0.02175319f, 0.03482618f, 0.02104926f, -0.05152547f, 
    -0.05635227f, -0.05687563f, 0.02959681f, -0.06258123f, -0.01320634f, 0.01188843f, 0.04278266f, -0.06413550f, 
    -0.04338756f, 0.03478964f, 0.01761248f, -0.04538944f, 0.02506020f, -0.02166129f, -0.01729014f, -0.00558408f, 
    -0.06307715f, -0.05782698f, 0.05289824f, 0.01344319f, -0.05640014f, 0.01970302f, 0.05254671f, 0.03950604f, 
    -0.06147669f, 0.01597999f, -0.05022314f, 0.05060367f, 0.02957017f, -0.01969571f, -0.05833601f, -0.00340133f, 
    -0.00179646f, 0.04860020f, -0.03655456f, 0.00842593f, -0.05244822f, -0.02354242f, 0.01602673f, 0.05231046f, 
    -0.00290808f, 0.05289752f, -0.05979732f, -0.04619092f, -0.05695616f, 0.01936777f, -0.03189780f, 0.03743064f, 
    -0.04288614f, -0.04167994f, -0.06069199f, 0.00301816f, 0.03870228f, 0.04201769f, -0.05312347f, -0.00284859f, 
    -0.00468730f, 0.02214338f, -0.02907613f, 0.00385219f, -0.03029866f, 0.05331952f, -0.04617873f, -0.05680509f, 
    0.03723337f, 0.04695634f, -0.04478427f, -0.04962090f, 0.00435356f, 0.04362435f, -0.03655068f, 0.03259932f, 
    -0.04632647f, -0.00705038f, 0.00237472f, -0.02751791f, 0.02317527f, -0.04471713f, 0.05139374f, 0.03450797f, 
    0.01366838f, -0.06057499f, 0.01133166f, -0.06120985f, -0.03896776f, 0.03222046f, 0.02063564f, -0.06001981f, 
    -0.02675927f, 0.02023955f, 0.02899427f, 0.02219398f, -0.04568429f, -0.03170633f, 0.03601529f, -0.04876043f, 
    -0.02545611f, -0.00205966f, 0.04391821f, -0.00593124f, -0.05347330f, 0.03566784f, 0.00092052f, -0.01651878f, 
    -0.02353274f, 0.03399320f, -0.01723564f, -0.02911275f, 0.02591636f, 0.00092273f, 0.02681191f, -0.06429355f, 
    -0.01000881f, -0.04392387f, -0.01880976f, -0.02545092f, 0.01261490f, -0.03288976f, -0.05661897f, 0.04194640f, 
    -0.06238086f, 0.04440654f, 0.04266686f, 0.01350632f, 0.05101873f, 0.00658260f, 0.03153144f, 0.02205815f, 
    -0.00387497f, -0.01549336f, -0.00643391f, -0.02499168f, 0.02139565f, 0.03888701f, -0.04676652f, -0.01302409f, 
    0.00229850f, 0.02794568f, -0.03446487f, 0.02302411f, 0.00188121f, 0.03023296f, -0.04703337f, 0.04713706f, 
    -0.06055392f, -0.02593713f, 0.00428964f, -0.01493491f, 0.00569460f, 0.03742649f, 0.01654814f, -0.01479154f, 
    -0.02355158f, -0.03802406f, 0.01800911f, 0.05008656f, -0.04654406f, -0.02915974f, -0.06077339f, -0.01023725f, 
    -0.05827843f, 0.01556149f, 0.02131795f, -0.03180327f, -0.05722279f, -0.03558380f, -0.02465047f, -0.02480777f, 
    -0.03802552f, -0.03932336f, -0.05861974f, -0.03226415f, -0.05132877f, -0.00945171f, -0.06231131f, -0.03728963f, 
    0.04401648f, -0.00113315f, 0.00531282f, -0.02162891f, 0.02273675f, -0.00398067f, 0.05767534f, 0.03528392f, 
    0.28423834f, -0.19345026f, -0.34582287f, 0.14432277f, -0.02046520f, -0.00949294f, -0.00006676f, -0.18442321f, 
    0.04325001f, -0.12953402f, -0.27598453f, -0.13790022f, 0.06242203f, 0.01461369f, -0.11789848f, -0.09733597f, 
    0.06643832f, -0.05785819f, -0.63919151f, 0.10928413f, 0.06211096f, -0.08620794f, -0.22098444f, 0.10286325f, 
    -0.01462446f, 0.09503848f, 0.12652951f, -0.55003440f, 0.57751155f, 0.59495825f, -0.04253507f, -0.02560281f, 
    -0.16974297f, -0.01089299f, -0.08930611f, -0.03283483f, -0.10626152f, -0.03019116f, 0.36220941f, 0.17355059f, 
    -0.03211148f, -0.12147316f, -0.00407908f, 0.00014848f, 0.05769185f, 0.03558763f, -0.06643571f, -0.14667833f, 
    0.02930477f, 0.01853190f, -0.03020225f, -0.01483315f, 0.07210796f, 0.02762809f, -0.03700695f, 0.15640455f, 
    0.24229118f, 0.23890404f, 0.02406371f, -0.26475471f, -0.13151875f, 0.05983382f, -0.15503284f, -0.42924854f, 
    -0.51993942f, 0.13917400f, 0.00133118f, -0.37576276f, -0.21518379f, -0.02684656f, 0.02551411f, -0.06808586f, 
    0.21945818f, 0.40054044f, 0.06663265f, 0.15852000f, -0.03847868f, 0.25759101f, 0.04585397f, 0.02830782f, 
    0.18166052f, 0.19241059f, 0.03810215f, 0.25887674f, -0.02737934f, -0.22855633f, -0.05455069f, 0.08940393f, 
    0.17488953f, -0.12513892f, 0.02368852f, -0.12224398f, 0.10021536f, 0.09855376f, -0.05366207f, -0.01334538f, 
    0.01393958f, 0.13081929f, 0.02239091f, 0.22218901f, -0.04406356f, -0.34904346f, -0.07201310f, -0.05896269f, 
    -0.01348889f, -0.03636949f, -0.13599338f, 0.02148765f, 0.04723689f, -0.03092164f, -0.04935233f, -0.31593537f, 
    0.05716607f, 0.19590537f, 0.05988839f, 0.06802008f, 0.15953559f, -0.05055565f, -0.28510183f, -0.30936629f, 
    -0.05580894f, -0.18027580f, -0.21182719f, -0.05398043f, -0.13336217f, 0.14198488f, 0.08662108f, -0.13475074f, 
    0.00639171f, -0.47095150f, -0.44753599f, -0.08478395f, -0.00438947f, -0.00282238f, 0.07314567f, -0.18318278f, 
    -0.20918892f, -0.05081902f, 0.02168422f, -0.10192713f, -0.24060610f, -0.07402620f, 0.15439321f, -0.07003488f, 
    0.18710990f, 0.00347447f, -0.05618463f, -0.24089156f, -0.09640317f, 0.06964266f, -0.01047703f, -0.07965205f, 
    0.09976225f, -0.01433944f, -0.13948600f, -0.06191303f, -0.14565469f, -0.08133016f, 0.21388651f, -0.02893115f, 
    0.24736649f, 0.05756643f, -0.17665353f, 0.25609180f, 0.01496893f, 0.01762953f, 0.06599977f, 0.02472644f, 
    -0.08035811f, -0.07281876f, -0.05844041f, -0.22811829f, -0.02695385f, 0.11495396f, -0.27228644f, -0.32039121f, 
    -0.27046782f, 0.10459424f, -0.09914048f, 0.15748198f, 0.16070099f, -0.09721044f, 0.65559369f, -0.10526583f, 
    -0.11210076f, 0.02693670f, 0.05291202f, -0.08941380f, 0.20944698f, 0.03562205f, 0.24137364f, -0.05574702f, 
    -0.09093612f, -0.23698421f, 0.32838657f, 0.10934046f, 0.10849276f, -0.02083969f, -0.02814046f, -0.08095465f, 
    0.19314933f, 0.13046940f, 0.20618050f, 0.04314433f, 0.03424752f, 0.26704827f, 0.09205052f, -0.32590622f, 
    0.08406958f, 0.19518219f, 0.00707238f, 0.01061223f, -0.17272596f, 0.02229035f, -0.07791740f, 0.04544054f, 
    -0.10288253f, 0.08427364f, 0.11281644f, -0.09133665f, 0.10780951f, -0.18957053f, -0.27960986f, -0.01074273f, 
    0.02356481f, -0.45871466f, -0.03153381f, 0.18995047f, -0.03693882f, 0.04835308f, -0.16803655f, 0.10595241f, 
    0.03553406f, 0.10312846f, 0.05782228f, -0.09450667f, 0.06009494f, -0.01607052f, -0.24172100f, -0.17831740f, 
    0.05079332f, -0.05701333f, 0.16554795f, 0.00848952f, 0.47483599f, 0.57238513f, -0.04941109f, -0.23305675f, 
    -0.25789955f, 0.01088890f, 0.11673203f, 0.09221529f, 0.34295157f, 0.55324376f, 0.09221507f, -0.18250427f, 
    -0.20111296f, 0.07055031f, 0.09554050f, -0.05787547f, 0.01359459f, 0.27987409f, 0.19297248f, 0.08508435f, 
    0.02950124f, 0.02694383f, -0.06477898f, 0.06430488f, -0.00528779f, 0.06942488f, -0.20839648f, -0.06167601f, 
    0.13021323f, 0.08585805f, 0.04619223f, 0.18436408f, -0.10950629f, -0.07423289f, -0.01087906f, 0.07456178f, 
    0.12479628f, -0.04913371f, 0.05822347f, -0.42060542f, -0.06819137f, -0.19965863f, -0.01642144f, 0.07946980f, 
    -0.02781826f, -0.02465617f, -0.05304452f, -0.04893337f, 0.01351549f, 0.00155352f, -0.00036019f, -0.01201744f, 
    0.00811453f, 0.04515704f, 0.02085971f, -0.00900673f, -0.06548161f, 0.04204805f, 0.01024195f, 0.00361992f, 
    -0.00694404f, 0.02743974f, 0.04363105f, 0.01103019f, -0.04295930f, 0.02122514f, -0.06462996f, -0.02325856f, 
    -0.03041711f, -0.00839035f, -0.05812499f, -0.01265139f, -0.06146818f, -0.05469556f, -0.03474141f, 0.04350697f, 
    0.04159956f, -0.04735476f, -0.02512598f, 0.02977593f, -0.02388229f, 0.01558667f, -0.01838125f, 0.00803380f, 
    -0.03668631f, 0.02963156f, 0.02226345f, -0.06757876f, -0.02138906f, 0.00917073f, -0.06436741f, -0.02919188f, 
    -0.00316954f, -0.00694589f, 0.03748298f, -0.02640068f, 0.00973894f, -0.02914109f, -0.00855337f, -0.01773690f, 
    0.01382997f, 0.02016589f, -0.02784122f, -0.05502070f, -0.01362432f, -0.04299246f, -0.06061792f, -0.01897802f, 
    -0.03498853f, 0.02240740f, 0.03775425f, 0.03233420f, -0.03676840f, -0.01050547f, -0.05506373f, -0.03922941f, 
    0.01761078f, 0.02503393f, 0.00501024f, -0.00360944f, 0.02718199f, -0.05549379f, 0.02895593f, 0.00341168f, 
    0.04625459f, 0.04272452f, -0.00738487f, 0.02458021f, -0.03643195f, 0.00026798f, -0.01868009f, -0.03642970f, 
    -0.00444889f, 0.04194912f, -0.01074145f, -0.01878844f, -0.01206351f, 0.01734969f, 0.04428168f, -0.05387973f, 
    -0.00377024f, -0.02192968f, -0.01021880f, -0.04209078f, -0.03193512f, 0.00772812f, -0.04456316f, -0.05173752f, 
    -0.03600099f, -0.06532325f, -0.00576387f, 0.03661063f, 0.00513857f, -0.05277233f, -0.02596810f, -0.05986052f, 
    -0.05109296f, 0.04327522f, 0.04337891f, 0.04293545f, 0.04479568f, 0.02826516f, -0.02702637f, 0.00528376f, 
    -0.02157178f, -0.01831661f, -0.03686965f, -0.03738583f, -0.01362188f, 0.01521234f, -0.03683776f, -0.02053725f, 
    -0.01532770f, -0.00620525f, 0.02430833f, 0.00854225f, -0.01980068f, -0.06011299f, 0.00032770f, -0.06191413f, 
    -0.03936464f, 0.01251704f, -0.06754677f, -0.05751640f, -0.03612370f, -0.04919029f, 0.01083901f, -0.01419037f, 
    -0.05462113f, 0.00992234f, -0.00369768f, -0.02605262f, -0.01677031f, -0.01029136f, -0.00396632f, 0.04003730f, 
    -0.03279939f, 0.00945997f, -0.04275236f, -0.00241127f, -0.00957599f, -0.03123833f, 0.03295460f, 0.01942076f, 
    -0.05671839f, -0.05304159f, -0.04234502f, 0.02454399f, 0.02389243f, 0.04723814f, -0.00388239f, 0.02682568f, 
    -0.05524725f, -0.03041062f, -0.05703297f, -0.02548293f, 0.04458982f, -0.06192719f, -0.06068765f, -0.07038276f, 
    -0.05830622f, 0.01499906f, -0.04784227f, -0.03261902f, -0.03670691f, -0.01555449f, 0.01576787f, 0.00150818f, 
    0.00635950f, -0.00674073f, -0.02747476f, -0.00876694f, 0.03528470f, -0.00867099f, -0.01242054f, 0.03861878f, 
    -0.05353808f, -0.03598570f, 0.03071639f, 0.04312711f, -0.04511159f, 0.00891546f, 0.01107345f, 0.03412328f, 
    -0.04907247f, -0.05069965f, -0.02175426f, -0.04246483f, -0.02238330f, -0.02916637f, 0.03857172f, -0.01926284f, 
    -0.03165561f, -0.05993111f, 0.03807669f, -0.04454092f, 0.01876485f, -0.05950767f, 0.03681539f, -0.01335007f, 
    -0.01802124f, 0.03612911f, 0.02590830f, 0.02484067f, -0.05080186f, 0.00321498f, -0.02085749f, -0.05740282f, 
    -0.02989552f, -0.00224352f, 0.00792147f, 0.04512226f, -0.06150578f, -0.05222887f, -0.04244157f, -0.04706189f, 
    -0.06042828f, 0.00904589f, -0.05574459f, -0.00789124f, 0.00620832f, 0.03283795f, 0.04094845f, 0.04088502f, 
    0.04823254f, 0.00742057f, 0.03813795f, 0.01649315f, 0.01905882f, -0.00777523f, -0.04531606f, 0.03259929f, 
    0.00377591f, -0.02487081f, -0.02282972f, -0.00507065f, -0.00394213f, 0.04007000f, -0.06452943f, 0.01776168f, 
    -0.02779419f, 0.04838511f, -0.02069082f, -0.02196703f, -0.05204641f, 0.03946645f, -0.04630079f, 0.00183120f, 
    -0.03276749f, -0.05640113f, 0.04277934f, -0.00954293f, 0.00926137f, 0.03035679f, 0.03776049f, 0.01916699f, 
    0.00352116f, -0.02079475f, -0.00457586f, -0.01491774f, -0.02684920f, -0.03838391f, -0.02636441f, 0.01730963f, 
    0.00658460f, 0.04396125f, 0.03277199f, -0.04442047f, 0.02161341f, -0.04262266f, -0.03217601f, 0.01110948f, 
    0.01946427f, -0.08409709f, -0.29468873f, 0.12924539f, 0.01971593f, -0.00702620f, -0.14267017f, 0.03489694f, 
    0.09060360f, 0.17376651f, -0.05684807f, 0.03037680f, -0.01477224f, -0.08017963f, -0.03095813f, 0.13440114f, 
    -0.02284463f, 0.09929108f, -0.61312598f, -0.16258501f, -0.13248192f, -0.22145931f, 0.04914518f, -0.16523975f, 
    -0.20755240f, -0.19223271f, -0.16500431f, -0.58804655f, -0.11365976f, -0.23710768f, -0.02245506f, 0.13068451f, 
    0.11344440f, -0.32041320f, -0.30247331f, -0.21511194f, -0.24665384f, -0.44886994f, -0.10328996f, 0.02157458f, 
    0.17041500f, -0.12539783f, 0.11461041f, 0.03472747f, 0.07542978f, -0.09256773f, -0.12394236f, -0.07975207f, 
    0.13022736f, 0.01874305f, 0.18760362f, 0.34407076f, -0.13515842f, 0.19018330f, -0.01731254f, 0.02975380f, 
    -0.05093601f, 0.03183578f, -0.03397088f, -0.08787710f, 0.10035876f, -0.15575974f, 0.08671037f, -0.05904302f, 
    -0.13358516f, 0.01295533f, -0.12791371f, -0.09675107f, -0.02444654f, 0.17580315f, -0.12090620f, -0.05285584f, 
    0.00688245f, 0.08318534f, 0.17572309f, 0.11855155f, 0.24094380f, 0.02986028f, 0.09987533f, 0.00482231f, 
    0.00048609f, 0.17877881f, 0.13006189f, 0.05266823f, -0.11176965f, -0.19514285f, 0.02710807f, -0.04176059f, 
    0.08676463f, 0.10892263f, -0.08731997f, -0.09895052f, 0.03273458f, 0.06977369f, 0.14549550f, -0.04502854f, 
    0.18293065f, 0.08149085f, 0.12355229f, 0.09032678f, -0.11113885f, -0.04724985f, -0.17431249f, -0.01146216f, 
    -0.11266159f, -0.01040842f, 0.19780916f, 0.21319239f, 0.04530915f, 0.05195276f, -0.06069191f, -0.00206661f, 
    0.06174912f, 0.05826231f, -0.05940866f, 0.00329931f, -0.04844497f, -0.22603768f, 0.14665890f, 0.17306960f, 
    -0.12744169f, -0.01546402f, -0.14404230f, -0.00821183f, 0.03507315f, 0.17977168f, 0.13226141f, -0.02454370f, 
    -0.09270480f, -0.00712832f, -0.05203878f, -0.07583688f, -0.07151484f, -0.06564765f, 0.07447129f, -0.16049838f, 
    -0.27039081f, 0.14332674f, -0.26627210f, -0.04926430f, -0.07076034f, 0.14565356f, 0.04625022f, 0.10824792f, 
    0.11889341f, 0.14557472f, 0.03188010f, -0.01138409f, -0.06859788f, 0.00150781f, -0.07777728f, -0.04734494f, 
    -0.00064874f, 0.10022780f, -0.04105871f, 0.04246701f, 0.07797157f, 0.06548430f, -0.07727326f, 0.08623123f, 
    0.03247758f, 0.20447594f, 0.05121989f, 0.04214254f, 0.04683059f, -0.04296009f, -0.12944159f, 0.00535368f, 
    0.20368704f, 0.05431449f, 0.04052806f, -0.27437717f, -0.26835731f, 0.11099059f, -0.11458197f, -0.10336445f, 
    -0.23405127f, -0.01108548f, -0.03415481f, 0.26774970f, 0.11807127f, 0.02181689f, 0.05343521f, -0.03298082f, 
    -0.11135951f, -0.15792297f, -0.00848407f, 0.07697516f, 0.18528943f, 0.42408708f, 0.10575256f, -0.27150404f, 
    0.12263228f, -0.28946465f, 0.09949270f, 0.11710884f, 0.00644888f, 0.14120989f, 0.19571783f, 0.02580192f, 
    0.07505396f, 0.21478404f, 0.09637916f, 0.17650980f, 0.21375354f, 0.20042086f, 0.13048583f, 0.08663618f, 
    -0.16349898f, -0.11945961f, -0.18053600f, 0.01341839f, -0.20509975f, -0.08218654f, 0.00214521f, 0.03319249f, 
    -0.16225857f, -0.16656473f, -0.20391501f, 0.03045270f, 0.01095906f, 0.11260996f, 0.01856661f, -0.07572431f, 
    -0.07469814f, 0.16351433f, -0.17409314f, 0.05542087f, -0.14690109f, -0.02713601f, 0.06022980f, 0.13237073f, 
    0.03190755f, 0.20816815f, -0.15903740f, -0.04788536f, -0.49276614f, -0.03293247f, -0.16248846f, -0.10558455f, 
    0.04750855f, -0.00012486f, 0.06660020f, -0.22211434f, -0.04859523f, -0.00327670f, -0.11760828f, 0.01819618f, 
    0.02200186f, -0.17305326f, -0.14110497f, 0.05759077f, -0.14752939f, -0.07356939f, -0.13500807f, 0.01763505f, 
    0.06621932f, 0.10047235f, -0.03274486f, 0.07355437f, -0.04182142f, -0.23096801f, -0.16575021f, -0.08469160f, 
    0.12002692f, 0.12263539f, 0.19052456f, 0.22033566f, 0.15852536f, 0.02345378f, 0.19238114f, -0.01359444f, 
    0.00459996f, 0.00313121f, -0.00639523f, 0.01235993f, 0.15817662f, 0.09603735f, -0.09249431f, 0.15911569f, 
    -0.00604166f, 0.14463437f, -0.13807029f, -0.17593098f, -0.11084475f, 0.00553904f, 0.14533396f, 0.16464031f, 
    0.02646860f, 0.01277596f, -0.01492924f, -0.02976148f, -0.01398237f, 0.03995620f, 0.00722391f, -0.04304554f, 
    0.04199163f, 0.04121954f, 0.01263589f, -0.04894149f, 0.04668025f, -0.06247383f, 0.02333444f, 0.04383620f, 
    -0.04312327f, -0.04827256f, -0.03626249f, -0.02062787f, 0.01873206f, -0.00036059f, 0.01570703f, 0.04735009f, 
    0.05468618f, -0.01754638f, 0.00394095f, -0.00000549f, -0.03698038f, 0.05233162f, 0.03504954f, 0.01062067f, 
    0.02436878f, -0.02196095f, 0.02558923f, -0.05036670f, -0.06516808f, -0.05028600f, -0.05077717f, 0.02649012f, 
    0.02232843f, -0.03744898f, -0.04872739f, -0.04596020f, -0.00579907f, 0.01158918f, -0.03065142f, -0.05109480f, 
    0.01262928f, -0.02944195f, 0.04904123f, 0.01018953f, 0.05004232f, -0.02428037f, -0.06113769f, -0.02310586f, 
    -0.01171312f, 0.04698662f, -0.05771192f, -0.04094624f, 0.03952869f, -0.03960884f, 0.03014483f, -0.00523204f, 
    0.04948700f, 0.02866076f, 0.01118080f, 0.00995231f, -0.01046821f, -0.03382776f, -0.05965728f, -0.03737356f, 
    0.04244606f, -0.02278687f, -0.03639562f, -0.04047294f, 0.02970352f, 0.04590168f, -0.00002383f, -0.03640022f, 
    -0.05743378f, 0.04461676f, -0.00995072f, -0.00906973f, 0.04373160f, -0.04405259f, 0.04662019f, -0.00462764f, 
    -0.00659718f, 0.03286549f, -0.03208732f, -0.00123278f, -0.05136991f, 0.04258292f, 0.01069057f, 0.05303249f, 
    -0.04924101f, -0.02065886f, 0.03164817f, -0.03051008f, 0.01038669f, -0.01576416f, 0.02988592f, -0.02362888f, 
    -0.06040249f, 0.00570939f, 0.00839668f, 0.02623141f, 0.01056656f, -0.00469805f, 0.04530196f, -0.06282585f, 
    -0.05542561f, -0.02096248f, 0.02234877f, -0.04251730f, -0.06043515f, 0.02430735f, -0.06286183f, -0.00864724f, 
    0.05202044f, 0.00053227f, 0.04912632f, 0.03583169f, -0.06877986f, -0.05284819f, -0.06429104f, -0.02224796f, 
    -0.01571419f, 0.02927050f, -0.00916375f, -0.02875293f, -0.06235882f, -0.00545715f, -0.00522404f, -0.00706233f, 
    -0.01818748f, -0.05277333f, -0.06219126f, 0.04892317f, 0.03623290f, 0.02338561f, -0.02620512f, 0.02945273f, 
    0.04231745f, 0.00935842f, -0.03063801f, -0.00279503f, -0.01519915f, -0.02420366f, -0.01943885f, 0.03482933f, 
    -0.04649657f, 0.02451835f, 0.00693113f, 0.04669831f, -0.00126230f, 0.02320728f, 0.02050856f, 0.00987770f, 
    -0.05151968f, -0.02954530f, 0.02134453f, -0.00655649f, -0.01406503f, 0.00152440f, 0.00468799f, 0.03958885f, 
    0.04385572f, 0.02061931f, 0.03172514f, -0.04497764f, 0.03230794f, -0.04066716f, 0.03780160f, 0.04442120f, 
    0.00633967f, 0.04827521f, -0.04404958f, -0.06236754f, -0.03988956f, -0.01833672f, -0.05403988f, 0.03413426f, 
    0.00713139f, -0.04524097f, 0.01377986f, -0.01960353f, -0.00858572f, 0.03033930f, 0.01526645f, -0.04429287f, 
    -0.02253126f, -0.03394771f, -0.04864418f, -0.04889643f, 0.00270750f, 0.04809691f, 0.01676439f, -0.03897154f, 
    -0.01497627f, -0.00017192f, 0.04598933f, -0.01174818f, -0.00920171f, 0.00023206f, -0.02175079f, -0.02082475f, 
    0.02161732f, -0.02975145f, -0.02924655f, -0.04556743f, -0.04865683f, -0.02343731f, 0.00270884f, 0.00972243f, 
    0.04025590f, 0.03246679f, -0.06652060f, 0.01984130f, -0.00603320f, 0.00988316f, 0.04838734f, -0.04433320f, 
    0.01685080f, -0.01700260f, 0.00181629f, 0.03715392f, 0.04783686f, -0.00908080f, -0.01101286f, -0.05589069f, 
    0.04519944f, -0.03755831f, -0.04194699f, 0.02575440f, -0.03592654f, 0.02610566f, -0.02150582f, -0.00789175f, 
    -0.04402163f, 0.03037230f, -0.05561790f, 0.01246046f, -0.06342631f, -0.00061829f, -0.06081937f, 0.00864443f, 
    -0.05709565f, -0.03901507f, 0.02023902f, -0.06172080f, -0.05072101f, -0.02124373f, -0.00415705f, 0.02109535f, 
    -0.05841522f, -0.02611480f, -0.02733007f, -0.05372849f, -0.05921255f, 0.02205526f, -0.00529597f, 0.00471747f, 
    0.02837608f, -0.00161635f, -0.00604947f, -0.04761383f, 0.01317539f, 0.05055112f, 0.03747169f, -0.05351352f, 
    0.01115604f, -0.02811709f, -0.04742931f, 0.03816556f, -0.02625194f, -0.05239657f, 0.02210456f, 0.03137528f, 
    -0.01943161f, -0.05651455f, 0.02639767f, -0.05780157f, -0.06005790f, -0.04292953f, -0.04713152f, 0.01734476f, 
    -0.12295903f, -0.38090172f, -0.14216743f, -0.00570822f, 0.01316245f, -0.06355570f, -0.09499461f, 0.23397203f, 
    -0.09152459f, -0.05699375f, 0.02994315f, 0.09226298f, -0.03662892f, 0.03043260f, -0.06666657f, 0.07245960f, 
    -0.30786899f, -0.05034890f, 0.35842168f, 0.15806405f, -0.05202311f, -0.31060192f, -0.12847339f, -0.08636158f, 
    0.07205234f, -0.15735392f, 0.12056270f, -0.03029479f, 0.07756942f, -0.36938792f, -0.08029330f, -0.03864251f, 
    0.17497054f, -0.07085909f, -0.23785707f, 0.09150887f, 0.30060488f, 0.00022690f, 0.06141397f, -0.13350423f, 
    -0.02479858f, -0.00450272f, -0.04039026f, -0.04600468f, -0.08579493f, 0.15737641f, 0.14571534f, 0.04474601f, 
    0.02898610f, -0.04762868f, -0.12533392f, 0.24773121f, 0.06648028f, -0.06192708f, 0.06723791f, -0.03959460f, 
    0.14847235f, -0.02341915f, -0.07046921f, -0.03323459f, 0.05890138f, -0.13946323f, 0.04987696f, -0.04591119f, 
    0.06181490f, 0.11923016f, 0.03997937f, 0.05075793f, -0.05081806f, 0.13428402f, -0.00654736f, -0.02328459f, 
    -0.00283686f, -0.02343697f, 0.07969384f, -0.20870057f, 0.04658547f, 0.01593317f, 0.05221413f, 0.08227205f, 
    0.06317125f, -0.22709771f, -0.02213284f, -0.16320418f, 0.13445362f, 0.03127426f, 0.13220970f, -0.04877079f, 
    -0.11328339f, 0.01349874f, 0.04137866f, -0.12188295f, -0.16281906f, 0.11009678f, -0.01973447f, -0.04273675f, 
    0.00635444f, -0.13085274f, 0.24641944f, -0.40224811f, -0.02949763f, 0.23641816f, 0.00551895f, 0.05365207f, 
    -0.03493929f, -0.13288572f, 0.00937607f, -0.26733214f, -0.00242159f, -0.12942064f, 0.00353648f, 0.03524133f, 
    0.08833279f, -0.19329765f, 0.13002028f, 0.13080114f, 0.08453201f, -0.27903011f, -0.19449715f, -0.03819064f, 
    -0.04429175f, -0.10262074f, 0.02631155f, 0.12948869f, 0.00592028f, 0.03644061f, 0.02601548f, 0.04250211f, 
    0.21858694f, -0.09786987f, -0.00373218f, -0.08111899f, -0.04231865f, 0.15907523f, -0.21092534f, -0.00159558f, 
    0.23293263f, 0.27845931f, 0.14792593f, -0.06590264f, -0.18975022f, 0.09420601f, -0.01583201f, -0.05655969f, 
    -0.00360334f, -0.06227085f, 0.20997441f, -0.02783039f, 0.07670619f, -0.06634945f, 0.05100131f, 0.19907638f, 
    -0.04332298f, -0.00451126f, 0.15881594f, -0.05145524f, -0.00350207f, -0.11879009f, 0.03046788f, -0.01718711f, 
    -0.15882760f, 0.09500935f, -0.20466146f, -0.13000606f, 0.22558212f, 0.14601655f, 0.19602488f, 0.00150760f, 
    0.04988645f, -0.03422866f, -0.04666638f, -0.15093595f, -0.07423629f, -0.09176202f, 0.16939682f, 0.01965679f, 
    -0.18181565f, -0.06899431f, 0.12266386f, 0.15372597f, -0.29078248f, 0.01171363f, 0.32734454f, 0.10564987f, 
    -0.01558212f, 0.16038796f, -0.05071213f, 0.21143824f, 0.16540141f, -0.54914731f, -0.16847779f, -0.31482741f, 
    0.15767780f, 0.02494716f, 0.08913424f, 0.00378410f, -0.01955937f, 0.20019299f, -0.16495472f, -0.00033829f, 
    0.05997539f, 0.05047891f, 0.09435237f, 0.16337894f, 0.08769635f, -0.09536427f, 0.31743091f, 0.12547217f, 
    0.04531479f, -0.23695546f, -0.03923079f, -0.10841435f, 0.02744705f, -0.02041814f, -0.10147844f, -0.16781515f, 
    0.16492525f, -0.04954918f, -0.12687744f, -0.27706480f, -0.03465227f, -0.06500415f, -0.19874060f, -0.02018643f, 
    0.13836198f, -0.02619429f, 0.34541529f, -0.08941469f, 0.14763300f, -0.23398587f, 0.17260052f, -0.11132248f, 
    0.13662526f, 0.37044480f, 0.16703263f, -0.15522738f, -0.18192403f, -0.47809157f, -0.06174173f, 0.03288007f, 
    0.05531410f, 0.17474973f, 0.06322327f, 0.18456222f, -0.00666727f, -0.23472437f, -0.02685704f, 0.03084064f, 
    0.07710599f, 0.08691097f, -0.02463575f, 0.12380143f, 0.15307006f, 0.05931216f, 0.28390139f, 0.05286101f, 
    -0.02698970f, -0.02530253f, 0.14087182f, -0.03543743f, -0.29342875f, 0.24627219f, 0.27184021f, 0.14634414f, 
    -0.07113878f, 0.05141129f, -0.13526267f, 0.13986710f, -0.00210105f, -0.16270755f, -0.21992853f, -0.18067026f, 
    0.00190092f, 0.01547772f, 0.15862894f, 0.17292140f, 0.04719326f, 0.10554087f, 0.01625019f, -0.32370725f, 
    -0.07356608f, 0.30702475f, 0.05098385f, -0.07808771f, -0.04938550f, -0.01247692f, 0.05031805f, -0.05041227f, 
    0.64981562f, -0.37401077f, -0.33228937f, 0.18029743f, 0.15509272f, 0.11532559f, 0.04613769f, 0.05990972f, 
    0.00933197f, 0.29562306f, 0.08623931f, -0.15344736f, 0.06924282f, -0.14586313f, 0.09286250f, -0.03019802f, 
    0.04169104f, -0.00515210f, -0.34444609f, -0.21176244f, -0.05723593f, -0.10213805f, -0.02599980f, 0.29126009f, 
    -0.15422656f, 0.15323457f, 0.12196723f, -0.67987794f, -0.33025873f, -0.20523289f, 0.10999180f, -0.10111043f, 
    0.31238919f, -0.04381662f, 0.24177705f, -0.04385870f, 0.14719726f, -0.24493900f, 0.01380477f, 0.23340601f, 
    -0.12117517f, -0.11482191f, -0.05005582f, 0.17066835f, -0.10025392f, 0.14393945f, 0.15229446f, -0.06376144f, 
    -0.03142052f, 0.03132386f, -0.07869818f, 0.06890399f, -0.06877013f, 0.00630387f, 0.23329960f, 0.00079796f, 
    0.01183059f, 0.02584703f, -0.26826391f, 0.19327560f, 0.00450118f, -0.14622389f, -0.13359840f, -0.04590459f, 
    -0.04687004f, 0.05182731f, 0.10156179f, 0.05259257f, 0.18824899f, 0.15902707f, 0.02699848f, -0.15914474f, 
    0.01615398f, -0.33002728f, -0.11611742f, 0.07937379f, 0.04367341f, 0.11749811f, 0.02429324f, -0.02711518f, 
    -0.04436741f, 0.02845621f, 0.03489063f, -0.17512652f, 0.07346585f, 0.02888557f, -0.01412211f, -0.09442716f, 
    -0.00783711f, 0.10601037f, 0.28300568f, -0.02588508f, -0.06441206f, 0.06707155f, -0.08642458f, -0.09184756f, 
    0.06932003f, -0.21662253f, -0.11939882f, 0.49558052f, -0.41169524f, -0.20933618f, 0.15912965f, -0.02454947f, 
    0.04217987f, -0.07870836f, 0.17111787f, -0.29033956f, 0.03165640f, -0.15011778f, -0.08645602f, 0.07999481f, 
    0.12221584f, -0.02270608f, 0.04877820f, -0.10310989f, 0.04413880f, 0.07559040f, -0.07558717f, 0.20813993f, 
    0.29134175f, 0.11089507f, -0.13456489f, -0.07698084f, -0.10242189f, 0.15583143f, 0.06114062f, 0.07278109f, 
    -0.02793451f, 0.03236072f, 0.08803034f, 0.03541955f, 0.02278320f, 0.00572783f, -0.07544119f, -0.02019558f, 
    -0.10273531f, -0.03243236f, -0.05508897f, -0.04547128f, -0.13761561f, 0.17375442f, -0.04619684f, -0.08102695f, 
    0.09793852f, -0.16288659f, 0.11288365f, 0.01006222f, 0.11675482f, 0.06445896f, 0.00800639f, -0.04495229f, 
    0.01023151f, -0.14953169f, 0.15135023f, -0.26962352f, 0.04958435f, 0.07816724f, 0.07528477f, 0.09272964f, 
    -0.10102360f, 0.07761636f, 0.10721344f, -0.04397772f, -0.22751853f, -0.02641541f, -0.02320945f, 0.02451828f, 
    0.11162293f, 0.03998167f, 0.01555004f, 0.08507465f, -0.07126804f, 0.43694982f, 0.14069009f, -0.20350330f, 
    -0.05160573f, 0.18738376f, -0.05143828f, -0.12458027f, 0.13472989f, 0.22589402f, 0.37934721f, -0.10234460f, 
    -0.09040944f, -0.21822262f, 0.00656801f, 0.07216978f, 0.14663696f, -0.02007724f, 0.10844381f, -0.41480514f, 
    0.20255837f, -0.06826778f, -0.06712300f, 0.08140399f, -0.20764215f, -0.08091044f, -0.21194397f, -0.00154552f, 
    -0.16946907f, 0.06527825f, 0.01760563f, 0.03488450f, 0.36733910f, 0.05150622f, 0.01223619f, 0.00817315f, 
    -0.18567441f, 0.18176746f, 0.38602453f, 0.01808775f, -0.06147545f, 0.17228760f, 0.07025757f, -0.07287185f, 
    -0.05206615f, -0.21204530f, 0.07564521f, 0.07127260f, -0.13603279f, -0.18953376f, 0.06650022f, 0.17037778f, 
    -0.02436368f, -0.09338171f, -0.04167419f, 0.05392282f, -0.11820418f, 0.02180886f, -0.00322144f, 0.06722005f, 
    -0.07952756f, 0.02037234f, 0.10642805f, -0.01835615f, 0.33606192f, 0.07294630f, -0.01426092f, 0.12876570f, 
    -0.04983265f, 0.02631752f, 0.04617901f, -0.34645489f, -0.16486314f, -0.28424171f, 0.10080336f, -0.03700482f, 
    0.16083927f, 0.01322483f, 0.06342313f, 0.09176660f, 0.07646225f, -0.17887460f, 0.02470473f, 0.07280761f, 
    0.02761441f, 0.13651833f, 0.14413863f, -0.26126167f, -0.17889301f, -0.18308893f, -0.14873305f, 0.06483534f, 
    -0.16560604f, 0.04066983f, -0.09484699f, -0.15447649f, -0.12189829f, -0.05589297f, 0.36832702f, -0.24143280f, 
    -0.33639094f, 0.16536224f, 0.04679945f, 0.03445920f, 0.08010840f, 0.06163938f, -0.11641409f, -0.02446111f, 
    0.23008439f, 0.33312729f, 0.13926649f, 0.07997124f, -0.00258717f, 0.04916290f, -0.03134038f, 0.07680950f, 
    0.15934706f, -0.05003739f, 0.03777514f, -0.17434089f, 0.06443673f, 0.00621908f, 0.04129800f, 0.23679903f, 
    0.07038736f, 0.02681337f, 0.02110525f, -0.20087659f, 0.09471329f, 0.04814486f, 0.05483275f, 0.08703406f, 
    0.11538033f, 0.03721105f, -0.27593496f, -0.07076819f, 0.04412261f, -0.04761560f, 0.21164708f, 0.03282388f, 
    -0.04161822f, 0.01374057f, 0.15320067f, -0.65121013f, 0.08927503f, 0.38234550f, -0.03450708f, 0.02667481f, 
    0.05653859f, -0.13729542f, 0.04226232f, -0.02931541f, -0.52199137f, -0.68566430f, -0.00010790f, 0.03069130f, 
    0.09927846f, 0.12579708f, 0.07090243f, -0.01945236f, -0.00091837f, 0.01584411f, -0.05795733f, -0.19866668f, 
    -0.02995224f, -0.14481871f, -0.01891187f, 0.18805629f, -0.04969185f, -0.04311089f, 0.06159197f, 0.18931673f, 
    0.00008726f, 0.11224380f, -0.06499705f, -0.02930749f, -0.19063732f, 0.01288770f, 0.06272684f, 0.07523370f, 
    0.09871750f, -0.05884780f, -0.08272273f, -0.20216957f, -0.20597032f, -0.10659360f, 0.08836634f, 0.16928738f, 
    0.10623229f, -0.01905645f, 0.12137805f, 0.00022588f, 0.21496157f, 0.02048686f, 0.04447228f, 0.05727080f, 
    -0.04996799f, 0.11497035f, 0.15897472f, 0.01876424f, -0.18062571f, -0.13027374f, 0.00907878f, -0.13860707f, 
    0.07468756f, 0.05547579f, 0.13411991f, 0.10353920f, 0.07933059f, -0.04927849f, 0.05771965f, -0.04502718f, 
    -0.01382478f, 0.12288295f, 0.04651831f, 0.28004116f, -0.09299102f, -0.12226903f, 0.02684715f, -0.20317239f, 
    -0.19092993f, 0.14832439f, 0.24934469f, -0.12241109f, 0.01195981f, 0.04541693f, -0.04310399f, -0.35529655f, 
    -0.15059875f, -0.02768306f, 0.12917286f, 0.14543450f, 0.04074958f, 0.08237820f, 0.10188300f, 0.22265431f, 
    -0.14755341f, 0.14774096f, 0.01809224f, 0.05454091f, 0.17726278f, -0.10073555f, 0.15900421f, 0.11028705f, 
    -0.16824086f, -0.08848870f, 0.04430779f, -0.16734481f, 0.03119185f, 0.08619337f, -0.00625553f, -0.02833928f, 
    -0.11676521f, -0.32344538f, -0.03437166f, 0.05424103f, -0.17324930f, 0.23391061f, -0.04650685f, 0.10571596f, 
    0.12271354f, -0.02437228f, -0.03611664f, -0.19431642f, 0.03340444f, 0.00053876f, 0.05620577f, 0.02649724f, 
    0.01253643f, 0.13350947f, -0.02697308f, -0.04134681f, -0.17387106f, 0.06959210f, 0.04732052f, 0.13820228f, 
    -0.01728959f, 0.11796077f, 0.07601129f, 0.06805725f, -0.19921689f, 0.10675897f, 0.02609240f, -0.06832805f, 
    0.00930077f, -0.20890661f, -0.06056341f, -0.82366389f, 0.17222153f, -0.22181807f, -0.00038433f, -0.14406461f, 
    -0.19510932f, -0.02276428f, -0.17665491f, 0.04877558f, -0.10346637f, 0.27194202f, -0.17615342f, 0.05281360f, 
    0.13356806f, -0.15707326f, 0.14735933f, 0.15478462f, 0.19501603f, -0.25779456f, 0.28114927f, -0.26144236f, 
    0.13130385f, 0.23542307f, -0.25667229f, 0.41577268f, 0.01929937f, 0.30643091f, -0.22993909f, 0.27312762f, 
    -0.06049928f, 0.18217963f, 0.06132459f, -0.06660766f, -0.00518744f, 0.14349516f, 0.09228052f, -0.40681562f, 
    -0.09421554f, -0.20074312f, -0.02078266f, -0.00928330f, -0.01694081f, -0.08104856f, -0.12871622f, 0.01513026f, 
    -0.07381739f, -0.09361047f, -0.19350579f, -0.00499809f, -0.11737408f, 0.04467081f, 0.11096162f, -0.07426440f, 
    0.12573744f, -0.05710344f, 0.20111546f, -0.18620464f, -0.09683642f, -0.11393423f, 0.06314918f, 0.08373199f, 
    0.14290088f, 0.01304988f, -0.77298045f, -0.79789031f, -0.61428225f, -0.14162309f, 0.03768775f, -0.06814034f, 
    -0.05934378f, -0.26520610f, -0.07855793f, -0.24388632f, 0.39724308f, 0.45150715f, -0.03459407f, 0.08087421f, 
    -0.17534456f, -0.04225446f, -0.00483226f, 0.18506233f, -0.03409240f, 0.09155098f, 0.07941403f, -0.25421217f, 
    0.00145556f, 0.08057020f, 0.08291079f, 0.00492618f, -0.02613639f, -0.13738896f, -0.00242224f, 0.18789257f, 
    -0.01890921f, 0.15982653f, 0.03436936f, 0.06984274f, 0.04459981f, -0.03549547f, 0.15104802f, -0.08871774f, 
    0.05123170f, 0.04974288f, 0.03140654f, -0.20249479f, -0.06643429f, 0.00903980f, 0.12320893f, 0.04047268f, 
    0.20531522f, 0.03894104f, -0.02942241f, 0.03947516f, -0.08888011f, -0.06701607f, -0.11836440f, 0.10602317f, 
    -0.88793337f, -0.29671645f, -0.28259629f, 0.01349056f, -0.13950235f, 0.33709833f, 0.20352206f, -0.08916291f, 
    0.02360061f, -0.25056720f, -0.20243779f, -0.04071553f, 0.02578449f, 0.10172258f, -0.05928459f, 0.05383493f, 
    0.12507454f, -0.13284029f, 0.13296767f, 0.11094044f, 0.46506643f, 0.23826139f, 0.07896175f, -0.00922818f, 
    0.11043532f, 0.08219393f, -0.01852660f, 0.25812927f, -0.06668154f, 0.48421761f, 0.01037485f, 0.13978259f, 
    0.02530956f, -0.07710213f, 0.02933349f, -0.04515455f, -0.08043999f, 0.30388260f, 0.12861276f, 0.13730174f, 
    0.09110834f, -0.04330266f, -0.02260512f, -0.09413179f, 0.11990274f, -0.12064840f, 0.03621838f, -0.05089905f, 
    -0.02831379f, -0.04468871f, 0.06058841f, 0.05534234f, -0.01657300f, -0.08732675f, -0.25799772f, -0.41745993f, 
    -0.16263007f, 0.04914765f, -0.11220727f, -0.13571382f, 0.05383798f, 0.07380762f, 0.03400145f, 0.14239214f, 
    0.14505169f, 0.08099583f, 0.01124415f, -0.12198417f, -0.04144996f, -0.03404550f, -0.06093034f, 0.12020008f, 
    -0.17277360f, 0.11613744f, 0.18214799f, 0.02514558f, 0.13918577f, -0.08547729f, 0.15264057f, -0.06622243f, 
    0.08075537f, 0.07837762f, -0.14275953f, 0.01943327f, 0.04770163f, 0.00217970f, -0.04018256f, 0.10523510f, 
    0.19353986f, 0.15462470f, -0.33367187f, -0.18839040f, 0.20207575f, 0.14009877f, -0.14814354f, 0.01644774f, 
    0.12806803f, 0.30090392f, 0.11926743f, -0.66025662f, -0.66060293f, -0.32050619f, -0.07935151f, 0.06550167f, 
    0.21764371f, 0.24685416f, -0.05997138f, -0.20158690f, 0.02488681f, -0.18355697f, -0.05656337f, 0.02284887f, 
    -0.07797758f, 0.04085564f, 0.03637365f, 0.14062810f, 0.16976900f, -0.20745848f, -0.32004297f, -0.07218830f, 
    0.33506769f, -0.26117864f, -0.10700542f, 0.00609112f, 0.05654243f, -0.12264907f, 0.37434319f, -0.13891660f, 
    -0.29316154f, -0.17876501f, -0.23854379f, -0.06930163f, 0.08927339f, 0.17954563f, 0.27764207f, -0.17041931f, 
    -0.36558756f, -0.31627524f, -0.11530156f, 0.06411137f, 0.03220835f, -0.12504527f, -0.05540157f, 0.00518653f, 
    0.21140480f, -0.18509999f, -0.13406102f, 0.05882764f, -0.04770447f, -0.02573467f, 0.05481399f, 0.13017945f, 
    0.08777948f, -0.04237212f, -0.16002323f, 0.10629473f, 0.06708958f, -0.31402397f, 0.19165908f, 0.00737758f, 
    0.13154235f, 0.09920881f, -0.20821087f, -0.25413558f, -0.16195372f, -0.23551388f, 0.09450317f, 0.10142398f, 
    0.07599489f, 0.10451565f, -0.01662200f, -0.02545597f, 0.13072719f, 0.34248707f, -0.13731234f, -0.15868181f, 
    -0.06968887f, -0.04373613f, -0.03058787f, 0.09686046f, 0.15046321f, -0.02855005f, -0.53391159f, 0.04096417f, 
    -0.12543550f, 0.01990662f, -0.01773249f, 0.02780765f, -0.04959007f, -0.29015315f, -0.28550249f, 0.17552361f, 
    -0.17863005f, -0.04065882f, 0.28579086f, -0.11260629f, 0.12606579f, 0.09592828f, 0.08982673f, -0.07751284f, 
    0.19383946f, 0.01701703f, 0.04700444f, -0.04731144f, -0.07814805f, -0.13027786f, 0.04827875f, 0.10791038f, 
    0.20643613f, 0.32909122f, -0.13034053f, 0.00672873f, 0.15311599f, -0.03327173f, 0.00985867f, 0.11928231f, 
    -0.25960055f, -0.11561722f, 0.08074613f, 0.00166552f, 0.08602866f, 0.15213548f, 0.02772289f, 0.12245008f, 
    -0.04903417f, 0.12997919f, 0.00367787f, 0.11974852f, 0.00163606f, -0.00548988f, -0.00317013f, 0.15923946f, 
    0.18833424f, 0.08373047f, 0.07081072f, 0.16772552f, 0.21493015f, -0.07921752f, -0.17144841f, -0.07379942f, 
    -0.02040122f, -0.12554041f, 0.26010993f, 0.20635073f, 0.00775839f, 0.15565073f, -0.06766418f, 0.02471712f, 
    0.02916097f, -0.01470214f, -0.06840575f, 0.07905564f, -0.04907362f, -0.16283125f, 0.01110470f, 0.05775195f, 
    0.13620865f, 0.02843056f, 0.12944187f, 0.08460192f, 0.02983629f, 0.00569730f, 0.01850012f, 0.18240558f, 
    0.08289442f, 0.01817551f, 0.04814823f, -0.02101237f, -0.12051526f, 0.18205093f, -0.31252629f, 0.01228205f, 
    -0.03591654f, 0.13848270f, 0.01970103f, -0.10243127f, -0.05891224f, -0.01171017f, 0.10636886f, -0.09571227f, 
    -0.15133452f, -0.19866084f, 0.17959470f, -0.09030410f, -0.15063651f, -0.07414197f, -0.18876894f, -0.12380312f, 
    -0.05452038f, 0.43535870f, -0.32199246f, -0.06652868f, -0.04800816f, 0.15684606f, 0.16371150f, 0.10511999f, 
    -0.24484019f, -0.00981773f, 0.03260059f, -0.23286809f, -0.07790135f, 0.01763803f, -0.10733349f, -0.02910134f, 
    -0.09604202f, -0.19440097f, 0.03563722f, -0.34702912f, -0.01568884f, 0.07952266f, -0.09072588f, 0.08485774f, 
    -0.08870185f, -0.01552139f, 0.29152659f, -0.03484769f, 0.00759534f, 0.48545712f, 0.02532445f, 0.07453223f, 
    -0.06024329f, -0.02082208f, -0.14781773f, 0.26794970f, 0.10843325f, 0.25033504f, 0.11588207f, 0.23839910f, 
    -0.02781009f, -0.02099421f, -0.00376558f, 0.08056821f, -0.09892941f, 0.01977863f, -0.01147656f, 0.10173199f, 
    0.04453561f, 0.07970613f, -0.11959668f, -0.15379548f, -0.15774712f, -0.26251373f, 0.04025770f, 0.06459307f, 
    0.14142039f, -0.00013326f, -0.03982745f, -0.11395300f, -0.14834772f, -0.01525994f, 0.00314994f, -0.05969947f, 
    -0.10716830f, 0.01393359f, 0.10592838f, -0.21916489f, -0.14136302f, -0.27945665f, -0.04777532f, -0.28747341f, 
    -0.11622743f, 0.22691141f, 0.13095216f, -0.08949045f, 0.03174473f, 0.10906956f, -0.02962894f, 0.09145754f, 
    0.00031996f, 0.07287588f, 0.16199084f, -0.10553943f, -0.08496672f, -0.09899437f, -0.10925452f, 0.01960487f, 
    0.01114081f, 0.00055274f, 0.20245062f, 0.25759205f, 0.22793160f, -0.02228780f, 0.19026864f, -0.06753208f, 
    -0.14265436f, 0.11301007f, -0.12844603f, 0.22809410f, 0.20071669f, 0.36392209f, -0.13466562f, -0.02039771f, 
    0.13750333f, 0.14469030f, 0.18025671f, 0.03927093f, -0.05310993f, -0.14772190f, -0.32261384f, -0.16903260f, 
    -0.03823855f, 0.01180340f, -0.14626256f, 0.10641895f, -0.12198662f, -0.22060871f, -0.14780878f, -0.40116808f, 
    -0.04876620f, -0.12643963f, -0.02887740f, 0.08055453f, 0.13124625f, 0.15084323f, 0.01367074f, 0.08186055f, 
    -0.21101555f, -0.04662322f, -0.10251229f, 0.08260471f, -0.06641186f, 0.05411540f, 0.15175200f, 0.01564692f, 
    0.31014159f, 0.29165193f, 0.11228961f, -0.04995952f, -0.07204856f, -0.00863090f, -0.18749432f, -0.07436388f, 
    0.05178740f, -0.23290710f, -0.32195938f, 0.05243329f, -0.18098339f, 0.15781561f, -0.04202902f, 0.14273383f, 
    0.02842724f, 0.02658553f, -0.27746373f, -0.12432598f, -0.19091573f, -0.00727363f, 0.05703852f, -0.17191274f, 
    0.09725599f, 0.24769326f, 0.03850778f, -0.09262767f, -0.13700403f, 0.04355579f, -0.03265560f, -0.05972327f, 
    -0.02274348f, 0.03122349f, 0.01392058f, 0.27719256f, 0.03052867f, 0.45078719f, 0.09798484f, -0.10610741f, 
    -0.17118980f, 0.01107579f, -0.07002793f, -0.04080178f, 0.24936767f, 0.37689421f, 0.43313196f, 0.07374743f, 
    -0.03126996f, 0.10486542f, -0.02789672f, 0.05077952f, -0.00304176f, -0.76641732f, 0.44787109f, 0.33699405f, 
    0.04677724f, -0.03693610f, 0.20186424f, 0.06117876f, 0.11913191f, 0.04144089f, -0.07373156f, 0.17242844f, 
    0.40568227f, 0.06281486f, 0.14504485f, -0.13638465f, 0.02578091f, -0.19136561f, 0.27358347f, 0.17638844f, 
    0.21051529f, 0.26707998f, 0.11924598f, -0.02440309f, -0.01419105f, 0.06751710f, 0.03339298f, 0.09976086f, 
    0.33530313f, 0.35448733f, 0.30028030f, -0.12578490f, 0.03388974f, 0.01982543f, 0.03001609f, 0.08443616f, 
    -0.21055362f, 0.28617254f, 0.09613296f, 0.13963930f, 0.01584877f, -0.12124553f, -0.16705346f, 0.14330167f, 
    -0.27751711f, 0.32899344f, 0.08026048f, 0.06565787f, 0.62188661f, 0.06424727f, 0.11247507f, 0.09463381f, 
    0.02649761f, -0.01696753f, 0.28287002f, -0.31247291f, 0.02716351f, 0.08064629f, -0.03533976f, -0.06025831f, 
    -0.07611883f, -0.07506957f, -0.08279071f, 0.40361437f, 0.00382840f, 0.18965597f, 0.15851383f, 0.02876385f, 
    -0.04851484f, 0.02724720f, -0.12731345f, -0.14007194f, -0.07033093f, 0.05550573f, 0.16380242f, 0.16698600f, 
    0.04167385f, 0.08806659f, -0.04570647f, -0.06039308f, 0.07924598f, -0.24854788f, -0.17833512f, 0.12290196f, 
    0.29579353f, 0.14987499f, -0.11880864f, 0.29470456f, 0.02960514f, -0.04159518f, 0.05341061f, -0.01642126f, 
    0.03208074f, -0.09198863f, -0.11389923f, -0.09728214f, -0.06124324f, 0.04168157f, 0.00989334f, 0.05151860f, 
    -0.07540963f, -0.10307772f, -0.23247324f, 0.12754394f, 0.00892321f, -0.00448368f, 0.21091178f, 0.10993519f, 
    0.06834222f, 0.09881350f, 0.19989230f, 0.00039087f, 0.04302463f, -0.04883050f, 0.06709033f, 0.16842122f, 
    -0.25720158f, -0.22966619f, 0.24117425f, 0.05775307f, 0.11059781f, -0.00283937f, 0.23691732f, 0.06421427f, 
    0.10424734f, 0.22064792f, 0.24115454f, 0.19445071f, -0.08954574f, -0.10069253f, -0.03789194f, 0.02477749f, 
    0.04957009f, 0.07204022f, -0.14334524f, 0.22741051f, -0.20671193f, -0.11083005f, -0.24527472f, 0.14347120f, 
    0.13338949f, -0.04949461f, -0.01940626f, -0.19599694f, -0.27778965f, 0.02936266f, 0.00066918f, 0.06381486f, 
    0.20540714f, 0.05351670f, -0.08187117f, -0.13938130f, -0.12502633f, -0.52686918f, 0.12769610f, 0.04711622f, 
    -0.06601182f, 0.04286899f, -0.02657506f, 0.15241353f, -0.05369882f, -0.04706188f, -0.15070069f, 0.11556282f, 
    0.05111082f, -0.12668909f, 0.20826444f, 0.03346904f, 0.15564698f, -0.07685363f, 0.06907463f, -0.49374399f, 
    0.02400118f, 0.02260206f, 0.07792634f, -0.05224587f, 0.19809480f, 0.13620473f, 0.10731932f, 0.00966573f, 
    0.07686798f, 0.09281789f, -0.03879727f, 0.00364303f, -0.04791582f, 0.03469200f, 0.05067993f, 0.12830958f, 
    -0.03122815f, -0.25823769f, 0.09760645f, 0.03723187f, 0.00323008f, 0.10645518f, 0.08402229f, 0.15320827f, 
    0.13601719f, 0.08976022f, 0.05179693f, 0.39113492f, -0.03223928f, -0.22218902f, -0.17338353f, 0.26221016f, 
    0.03889344f, 0.17904469f, 0.11353905f, 0.01419130f, -0.04302412f, -0.05162729f, -0.17643653f, -0.01745984f, 
    -0.08472779f, -0.05105821f, 0.04859931f, -0.11997604f, -0.30137575f, -0.11732316f, -0.02225189f, -0.20563452f, 
    0.07179464f, 0.04189851f, 0.07342450f, 0.41326275f, 0.02154393f, -0.03980589f, -0.09300718f, -0.04492317f, 
    0.06540743f, -0.01115806f, 0.07775716f, 0.07586319f, 0.04077925f, -0.15986106f, -0.15934601f, 0.58196718f, 
    0.19093575f, -0.06909104f, -0.03880461f, 0.04681772f, -0.08981982f, -0.06869391f, 0.12731797f, -0.07928280f, 
    -0.00644578f, 0.08313802f, -0.01015425f, 0.04045804f, 0.11146931f, 0.03983535f, 0.15845424f, -0.14241853f, 
    -0.19142945f, 0.01050346f, 0.01035561f, -0.01864824f, -0.02393303f, 0.19322483f, -0.01953714f, 0.17745492f, 
    0.06507271f, 0.05955047f, 0.28590381f, 0.25320297f, -0.08665652f, -0.11930620f, -0.09353720f, 0.11586817f, 
    0.08452621f, 0.13217892f, -0.02166241f, 0.02905725f, -0.15086417f, 0.14175537f, 0.15315577f, -0.06902181f, 
    0.02783375f, 0.04795877f, -0.07521314f, 0.11434115f, 0.19261397f, 0.39031109f, 0.26007488f, 0.01271345f, 
    0.21172571f, 0.06235278f, 0.16978522f, 0.18544540f, 0.04619063f, -0.32226822f, -0.18767272f, 0.18935066f, 
    0.02634716f, -0.02485382f, 0.35422701f, 0.19067845f, 0.07887750f, 0.06326932f, 0.03996682f, -0.00637143f, 
    0.11709433f, 0.14201365f, 0.07322188f, 0.11837058f, 0.09659029f, 0.12559214f, 0.00068069f, -0.12685162f, 
    -0.00934178f, -0.03213869f, 0.11404821f, 0.07171442f, 0.00272991f, 0.08864368f, 0.02581161f, 0.12106696f, 
    -0.05936347f, -0.08329691f, -0.41120592f, 0.03214474f, 0.12742116f, 0.06691743f, -0.01416087f, -0.05302931f, 
    0.12449308f, 0.15057263f, -0.10079212f, 0.12189728f, -0.10190788f, 0.13682450f, 0.09010418f, 0.14156769f, 
    0.09923162f, 0.19686694f, -0.07282417f, -0.13543087f, 0.06555723f, 0.09713622f, 0.10715641f, 0.08818334f, 
    0.00989968f, 0.04377446f, 0.11237030f, 0.07018164f, 0.04415168f, 0.00206714f, 0.05785842f, 0.05282600f, 
    0.02817802f, 0.27431837f, -0.21343191f, -0.09735536f, -0.06661132f, 0.13115220f, 0.05423213f, 0.14997937f, 
    0.12943682f, -0.04699999f, -0.10878392f, -0.34389734f, -0.34110203f, -0.15663497f, 0.05005619f, 0.03422853f, 
    0.16679274f, 0.02552735f, -0.08848876f, -0.17732793f, -0.19709049f, -0.31695411f, -0.13972120f, 0.14790086f, 
    -0.16340682f, 0.05236229f, 0.06029861f, 0.00531794f, 0.24653028f, -0.06145030f, -0.00861402f, 0.15289408f, 
    0.29111928f, -0.11371010f, 0.03814888f, 0.11301997f, -0.00158841f, 0.15467863f, 0.25318158f, -0.15887684f, 
    -0.31938425f, -0.29765069f, -0.02780778f, -0.08879446f, -0.31607541f, 0.15857843f, 0.03333880f, -0.21703164f, 
    0.10162246f, -0.02763093f, -0.02465209f, -0.10669471f, -0.01264314f, 0.02662822f, 0.01472249f, 0.06520893f, 
    0.05293533f, 0.06821639f, 0.09929474f, -0.14114448f, -0.17227459f, -0.10378653f, -0.31691483f, -0.18808180f, 
    -0.31283838f, -0.17849633f, 0.07969346f, -0.05958452f, -0.02349575f, -0.03121684f, 0.06192904f, -0.11252650f, 
    -0.09703048f, -0.20745525f, -0.06745786f, 0.06484359f, 0.06983010f, 0.03503266f, -0.14197370f, 0.06597888f, 
    -0.04783128f, 0.04393858f, 0.03513823f, -0.00212826f, 0.09839126f, -0.02555285f, 0.09330326f, -0.00263361f, 
    0.03889086f, 0.05995026f, 0.00555662f, 0.19441715f, 0.17527904f, 0.09983616f, -0.06806526f, -0.09708954f, 
    0.06319483f, -0.03770434f, 0.09801168f, 0.10802151f, 0.17870317f, 0.06055785f, 0.03318584f, -0.17935355f, 
    -0.12159611f, -0.10720032f, 0.05588287f, 0.04026936f, -0.04272706f, 0.08143736f, 0.16030341f, 0.05894973f, 
    0.19588813f, 0.02386045f, 0.43032664f, 0.18131657f, 0.17424975f, 0.03418042f, -0.00536178f, 0.11485409f, 
    0.33748114f, -0.16252390f, -0.13910341f, -0.02939119f, -0.12041700f, 0.13409752f, -0.07462066f, 0.05572280f, 
    -0.08425034f, 0.02954819f, -0.01285525f, 0.13094498f, 0.07416169f, 0.04064011f, 0.01471414f, 0.23947340f, 
    0.05073262f, 0.18741281f, -0.14722025f, -0.12813927f, -0.33200747f, 0.06562486f, 0.12073539f, -0.18422160f, 
    -0.00127507f, -0.02340941f, -0.02463225f, -0.09281874f, 0.10590404f, 0.00036856f, -0.01685654f, 0.18559448f, 
    0.08187396f, 0.08705162f, 0.17549491f, 0.00524681f, 0.01234954f, 0.11215970f, -0.03403157f, -0.18163507f, 
    -0.14699377f, -0.29387259f, 0.02464066f, -0.12814090f, -0.20740727f, -0.05985472f, -0.38798773f, -0.00624196f, 
    -0.13991646f, -0.00938863f, 0.12618449f, -0.14994505f, 0.15308227f, 0.06150839f, 0.04463246f, -0.01543491f, 
    -0.08564605f, 0.29687533f, 0.06283265f, 0.06286135f, 0.05904819f, 0.10689301f, 0.09809357f, 0.02282169f, 
    -0.07373890f, -0.07163202f, 0.09830797f, -0.01044633f, 0.00121949f, 0.02232615f, 0.16175133f, 0.14187431f, 
    0.10508203f, -0.09313144f, 0.08814535f, -0.05476289f, 0.04746880f, 0.03251380f, 0.13739845f, 0.05339143f, 
    -0.09487382f, 0.12030809f, 0.05941011f, -0.25853738f, -0.10861741f, 0.15136673f, 0.16392745f, 0.01313118f, 
    0.12660323f, 0.01257701f, 0.00670655f, 0.09353949f, -0.06463307f, -0.16422392f, -0.13690367f, 0.01523665f, 
    0.01627606f, 0.13522919f, 0.09527491f, -0.02061452f, -0.27331287f, -0.62018502f, -0.20031825f, 0.04122221f, 
    0.12004513f, 0.13738030f, -0.12903528f, 0.12932599f, -0.08162482f, 0.10798621f, -0.44011950f, 0.12388009f, 
    -0.02479714f, -0.03404321f, -0.01383455f, -0.02787630f, 0.33564073f, 0.16373621f, 0.11849990f, 0.09234786f, 
    0.32933104f, -0.09182551f, 0.20853958f, 0.24014162f, 0.00268327f, 0.14862192f, -0.01572369f, 0.00874096f, 
    -0.22358951f, -0.15159270f, 0.06899456f, -0.35312492f, 0.05297141f, 0.08119255f, -0.09402154f, -0.03265149f, 
    -0.46771088f, -0.36418712f, -0.27551863f, -0.08306114f, -0.02507050f, 0.10624871f, 0.19757330f, -0.15487468f, 
    0.07264268f, -0.10331443f, 0.05480751f, 0.16630743f, 0.02919894f, 0.09987871f, -0.00661563f, 0.00848132f, 
    -0.04910829f, -0.02418527f, -0.24422027f, -0.34032506f, -0.11678896f, 0.13047276f, -0.12726320f, 0.04615044f, 
    0.03242777f, 0.02235604f, -0.01223898f, 0.29689935f, -0.00344001f, -0.16953537f, 0.02612269f, 0.19730642f, 
    0.10109732f, -0.09206298f, -0.07284245f, 0.02139633f, -0.06397880f, 0.02493080f, -0.04659451f, 0.17481394f, 
    -0.02537074f, 0.01149213f, -0.03421778f, 0.11203534f, 0.13003857f, 0.03932887f, 0.15663266f, 0.18341120f, 
    -0.03614824f, -0.07177535f, 0.17716500f, -0.04269177f, 0.19686799f, 0.17299908f, 0.22766563f, 0.03090484f, 
    -0.12944850f, 0.17370610f, -0.06433694f, 0.24280907f, 0.21933095f, 0.04885374f, 0.10140093f, -0.05482208f, 
    -0.33932263f, 0.00175800f, -0.32170954f, 0.05516758f, 0.08185745f, -0.06709821f, -0.04296707f, -0.15218948f, 
    -0.07238768f, 0.33023778f, -0.01229283f, 0.10111061f, -0.08175192f, -0.06012011f, -0.08630300f, 0.04575548f, 
    0.04104754f, 0.06496468f, -0.00773738f, 0.14268313f, 0.09361137f, 0.03709844f, 0.04790436f, -0.01710100f, 
    0.06160526f, 0.17298371f, -0.31370822f, -0.11128552f, -0.11328969f, 0.06096992f, -0.04924074f, -0.13733368f, 
    -0.31889144f, -0.21177284f, -0.27271444f, -0.44882086f, 0.09038121f, 0.15348469f, 0.16810147f, 0.10652937f, 
    -0.14400314f, -0.08197813f, -0.15792258f, -0.15191007f, -0.12643729f, -0.03301086f, 0.03604056f, -0.09586389f, 
    0.05751490f, 0.05830986f, 0.27172485f, 0.17269683f, 0.12548248f, 0.15822265f, -0.19056696f, -0.02107290f, 
    -0.13144635f, 0.04287419f, -0.01309820f, 0.27066469f, 0.13142805f, 0.15503475f, -0.12292301f, 0.14407280f, 
    -0.12892134f, 0.06888156f, 0.00217616f, 0.12361611f, -0.02766623f, 0.14464536f, 0.07134924f, -0.04850788f, 
    0.01645506f, -0.20412816f, -0.07648994f, -0.10975678f, -0.04249091f, 0.04406856f, 0.18912338f, 0.18294936f, 
    0.10994242f, 0.02253331f, 0.12138849f, 0.19526379f, -0.13815461f, 0.10251332f, 0.03245826f, -0.02361064f, 
    -0.03686817f, 0.05057082f, 0.00723619f, 0.00168195f, 0.04294018f, 0.15011069f, 0.03149125f, -0.06319413f, 
    -0.01353242f, 0.02558661f, 0.03961014f, 0.23410664f, -0.12944788f, -0.06123127f, 0.05357984f, 0.03357346f, 
    -0.07414877f, -0.00590940f, 0.02527655f, -0.28565916f, 0.23546807f, 0.08078844f, -0.00705466f, -0.13481188f, 
    -0.05172275f, -0.19004586f, 0.01946736f, 0.07700399f, 0.07206728f, 0.09969363f, 0.00738205f, 0.11801624f, 
    0.14020257f, 0.13074914f, 0.14710577f, 0.06473463f, 0.15775338f, -0.25287163f, 0.09166303f, 0.12951638f, 
    0.00154328f, -0.22040610f, -0.03368931f, -0.04677632f, -0.01282389f, 0.08770531f, -0.15343460f, -0.03933008f, 
    -0.18417917f, 0.17336020f, 0.07520978f, -0.03508439f, 0.10113289f, 0.12754241f, 0.05066194f, -0.41758338f, 
    0.13474439f, -0.46914613f, 0.20595425f, 0.18590234f, -0.03599438f, 0.07332050f, -0.02617626f, -0.03898193f, 
    -0.05935032f, 0.00141468f, 0.02782777f, 0.13393609f, 0.03834103f, -0.01084343f, 0.16767903f, 0.12447650f, 
    0.01281988f, -0.09788668f, 0.14834350f, -0.24968779f, 0.11338577f, 0.00562571f, -0.06158528f, 0.02054034f, 
    0.13171121f, 0.01835208f, -0.21078250f, 0.09539799f, 0.13303849f, 0.01432620f, 0.13293009f, 0.06929466f, 
    -0.01282098f, 0.02089210f, -0.00718139f, -0.14742756f, 0.02086091f, -0.32813054f, 0.04711476f, 0.01670691f, 
    -0.05798341f, 0.29387066f, 0.17602673f, 0.24178225f, -0.47333905f, -0.17613338f, -0.26917404f, 0.18860587f, 
    -0.09518854f, 0.07485513f, -0.05042079f, -0.04665021f, -0.02304069f, 0.14332861f, -0.05033796f, 0.34166703f, 
    -0.17768423f, -0.06780843f, 0.08740530f, -0.16997041f, -0.02403338f, 0.00582411f, 0.02783689f, 0.04117555f, 
    -0.01457154f, -0.06197962f, 0.06681301f, -0.18287861f, 0.09981968f, -0.03984878f, 0.04273255f, -0.19287133f, 
    -0.02712030f, -0.05154444f, -0.10128360f, 0.05780455f, -0.06143422f, 0.15022273f, 0.15298229f, 0.14523764f, 
    -0.27480957f, -0.09293841f, 0.17600100f, 0.00582326f, 0.19632277f, -0.00382447f, 0.12861180f, -0.05534592f, 
    0.27298206f, -0.14425507f, -0.25282031f, -0.01487168f, -0.03809343f, 0.00778898f, -0.07655609f, -0.07706748f, 
    -0.15759356f, -0.01435361f, -0.07909203f, -0.02036402f, -0.23963833f, 0.16409044f, 0.01727088f, 0.07602247f, 
    0.05654486f, 0.10362836f, -0.09686971f, -0.31571099f, 0.15166758f, -0.13629463f, 0.17257036f, 0.30484104f, 
    -0.12134166f, -0.04193866f, -0.09879651f, -0.16601385f, -0.01619828f, 0.00105469f, 0.10418922f, 0.03039184f, 
    -0.03835393f, 0.02895110f, 0.13853982f, -0.00190853f, 0.09684615f, 0.02738748f, 0.06917124f, 0.01757224f, 
    -0.10189895f, -0.13771154f, -0.07045596f, 0.23873909f, -0.01251874f, 0.15005702f, 0.02450268f, -0.06950881f, 
    0.48208034f, 0.00963071f, 0.16518508f, 0.05838405f, -0.09284284f, -0.06109155f, 0.13316087f, -0.18531395f, 
    0.03132349f, -0.12530319f, 0.04937300f, -0.12675947f, -0.07164055f, 0.09356787f, 0.01264238f, 0.10047782f, 
    0.03767847f, 0.01651608f, 0.03847179f, -0.06520339f, 0.05267850f, 0.03103618f, -0.06821275f, 0.01988250f, 
    0.02351395f, 0.00114206f, 0.02675962f, -0.06477493f, 0.00041928f, 0.01444469f, -0.02049869f, 0.00975403f, 
    0.04268355f, -0.01282902f, -0.00105687f, 0.04945657f, -0.02267152f, -0.01168371f, 0.04846182f, -0.01182854f, 
    0.00639568f, -0.06543232f, 0.03438502f, 0.03479755f, 0.00008195f, -0.00813871f, 0.03188129f, -0.03498731f, 
    0.03605111f, 0.04158337f, -0.04827369f, 0.02375911f, -0.01710854f, 0.04235429f, -0.05716858f, -0.03321404f, 
    0.04825719f, 0.02268822f, -0.00606780f, -0.01576867f, -0.02559757f, -0.04316354f, 0.04957823f, 0.00465302f, 
    0.01335257f, 0.02712111f, -0.06240333f, 0.01037142f, -0.05633318f, -0.02813607f, -0.05828394f, -0.01188330f, 
    -0.04513630f, -0.05430051f, 0.04503717f, 0.03957297f, -0.06637084f, -0.05132621f, 0.01153602f, -0.04402896f, 
    0.04363209f, 0.01872895f, 0.04605893f, -0.00853527f, 0.01215761f, -0.06481464f, 0.02441581f, 0.00891484f, 
    -0.01044939f, 0.01743260f, -0.01588218f, -0.04042510f, -0.00040278f, -0.04094772f, -0.04160199f, -0.06237239f, 
    -0.04627072f, -0.01273670f, -0.01400603f, -0.02710711f, -0.06580572f, -0.05889476f, 0.01968786f, -0.04648099f, 
    -0.01640530f, 0.03415608f, -0.02817721f, -0.03570057f, 0.00030175f, -0.02763090f, -0.04307476f, -0.03216676f, 
    -0.00303853f, 0.04502527f, -0.00725175f, -0.04337888f, 0.04742979f, 0.04875620f, 0.01521328f, -0.00381698f, 
    -0.05413778f, -0.04428890f, -0.05233481f, -0.06384906f, -0.04750971f, 0.02227160f, -0.05328778f, 0.00555505f, 
    0.01914709f, -0.06009607f, -0.02011224f, -0.00818362f, -0.04524984f, 0.04637419f, -0.00854399f, -0.00020695f, 
    -0.00455826f, -0.02362543f, 0.01688514f, -0.03928146f, 0.03051992f, -0.03268504f, -0.00455934f, -0.00726814f, 
    0.05216102f, -0.02959894f, 0.01075253f, -0.01292953f, 0.00760854f, -0.06642634f, 0.01784028f, 0.00492003f, 
    -0.01662524f, 0.02790159f, -0.04973043f, 0.04049447f, -0.02448602f, -0.05844320f, -0.01958200f, -0.03483811f, 
    -0.05716407f, -0.04022302f, -0.00218548f, 0.00001668f, 0.03144101f, 0.00604012f, 0.00316919f, -0.05061821f, 
    -0.05297562f, 0.04112004f, -0.02985180f, -0.01278637f, 0.00500902f, -0.03873418f, -0.00020573f, -0.04819946f, 
    -0.01859685f, -0.01631835f, -0.00188713f, -0.00196342f, 0.01757133f, -0.00377003f, -0.01341901f, 0.00862693f, 
    0.03800346f, 0.01462594f, 0.02999392f, -0.00033281f, 0.01395868f, -0.04527223f, -0.01857245f, -0.06558311f, 
    -0.01562889f, -0.01556336f, 0.00052340f, 0.03603564f, -0.01634478f, -0.06220757f, -0.05948198f, -0.05946635f, 
    -0.03954235f, -0.05318630f, -0.04592917f, 0.01467997f, 0.04141496f, 0.04352380f, -0.02078602f, -0.04448499f, 
    0.01198600f, 0.00646246f, -0.06039630f, 0.02565810f, 0.01702477f, 0.04524790f, 0.04240593f, 0.03225093f, 
    -0.04991046f, 0.02342511f, 0.00169481f, -0.02616331f, -0.03335631f, -0.02463591f, -0.02649218f, -0.03027881f, 
    0.01246311f, -0.02913910f, -0.00932990f, 0.02612499f, 0.01718939f, -0.01466211f, -0.03434129f, 0.00049705f, 
    -0.00286944f, -0.05354709f, 0.00102384f, -0.02222129f, -0.05975351f, -0.00424387f, 0.00313906f, -0.03755970f, 
    0.01876416f, -0.02583756f, 0.00086737f, 0.02782483f, 0.00716084f, -0.03987335f, 0.03934192f, 0.01242590f, 
    -0.05469294f, 0.00073657f, 0.03189797f, -0.01845143f, -0.04330207f, 0.01961370f, -0.02643595f, -0.05355263f, 
    -0.05881278f, -0.01303858f, -0.02948916f, -0.05732239f, -0.01963736f, -0.04437650f, -0.04315314f, -0.05314336f, 
    0.01477283f, 0.01180259f, 0.00886737f, -0.06752530f, -0.00174112f, 0.05442285f, -0.01744531f, 0.01450835f, 
    0.01233552f, 0.01793586f, 0.02891675f, -0.04935698f, -0.05829029f, 0.00341670f, -0.02386359f, 0.02739369f, 
    0.02315017f, -0.06472650f, -0.04171441f, -0.01666814f, 0.00147065f, -0.01387485f, -0.02207646f, -0.03349888f, 
    0.03953083f, -0.02073001f, 0.03198499f, -0.03870989f, 0.02722441f, -0.06667518f, -0.02913987f, -0.01564713f, 
    0.02019737f, -0.04916458f, 0.05310394f, 0.01014579f, -0.05901654f, -0.03850623f, 0.04538146f, 0.03710440f, 
    -0.09591756f, -0.23158340f, 0.05280225f, -0.08218583f, 0.30084097f, -0.01406833f, -0.09268126f, 0.02176640f, 
    -0.12352485f, 0.19652075f, 0.16147324f, 0.07354285f, -0.01016700f, 0.01547923f, -0.23207448f, 0.03063831f, 
    0.11488207f, -0.13575953f, -0.41353145f, -1.00258255f, -0.59912282f, -0.12339385f, 0.01372869f, 0.20963337f, 
    0.07683786f, 0.00228350f, -0.02289331f, -0.07969052f, -0.72865474f, -0.60358876f, -0.20745070f, 0.01887516f, 
    -0.03509023f, -0.05073779f, -0.08964673f, -0.03938629f, -0.20920569f, -0.29995716f, 0.24737242f, 0.08082847f, 
    -0.01801437f, -0.05899230f, 0.01824072f, 0.25068712f, 0.03410583f, -0.07791212f, 0.05219331f, 0.08276168f, 
    0.05592655f, 0.09879550f, 0.00042077f, -0.03976652f, 0.16407964f, -0.11679447f, 0.15469207f, 0.12902763f, 
    -0.02163470f, 0.12248173f, 0.03892352f, -0.12005752f, 0.06609795f, 0.09251782f, -0.10148375f, 0.11899216f, 
    0.09317984f, -0.12100715f, 0.01857679f, -0.06269450f, 0.07788156f, 0.06703876f, 0.04360938f, -0.12700304f, 
    -0.01363557f, -0.61526716f, 0.14685480f, -0.03526107f, 0.26299700f, 0.02860315f, 0.16133703f, -0.07260250f, 
    0.01865962f, 0.06279776f, 0.32531857f, 0.10120007f, -0.10513304f, 0.05130140f, -0.17204556f, 0.08502366f, 
    0.03940964f, 0.06870383f, -0.03888992f, 0.27819020f, 0.19920579f, 0.01700315f, 0.17624155f, -0.10235094f, 
    0.06672647f, 0.27268299f, 0.01631152f, 0.14653254f, -0.40661442f, -0.17599674f, 0.18712378f, -0.18144281f, 
    -0.11138330f, 0.15520529f, 0.00815393f, 0.02880276f, -0.02302312f, -0.04885934f, 0.02606904f, 0.00625188f, 
    0.07061008f, -0.06902518f, -0.08753748f, -0.04391638f, -0.09047429f, 0.08822742f, -0.04821888f, 0.31489840f, 
    -0.10711317f, 0.05864967f, -0.17999695f, -0.00441288f, 0.10099482f, 0.03785625f, 0.10172155f, 0.03536531f, 
    -0.14697005f, 0.00665440f, 0.04135134f, -0.04968332f, 0.04512284f, -0.25971970f, -0.10061135f, 0.04179431f, 
    0.36071038f, -0.04454894f, 0.07150450f, -0.18846919f, -0.02696636f, 0.01134843f, -0.01496596f, -0.10528206f, 
    0.03621396f, -0.09345553f, 0.07003462f, 0.01514753f, -0.02704547f, -0.03288721f, -0.05558715f, -0.07514966f, 
    0.07592610f, -0.10282627f, 0.12396951f, -0.15777680f, 0.08339607f, 0.19210289f, -0.09609868f, 0.18129975f, 
    -0.03756954f, 0.03888942f, 0.27168328f, 0.19893508f, 0.03362544f, -0.09544159f, -0.14477366f, -0.06885765f, 
    0.08855703f, 0.08880602f, -0.01360952f, -0.34259865f, 0.70185375f, 0.08182910f, -0.09337417f, -0.11336632f, 
    -0.19852412f, 0.10766651f, -0.02478454f, 0.10583880f, 0.00154824f, 0.49153313f, 0.33219302f, -0.01235735f, 
    -0.32035089f, -0.12862086f, -0.08977073f, -0.15977074f, 0.26458439f, 0.05454142f, 0.09022693f, -0.25044185f, 
    -0.16993143f, 0.29363331f, -0.21220306f, 0.13833977f, -0.15906800f, 0.10966540f, -0.36447540f, 0.36367041f, 
    -0.12947555f, 0.11553247f, 0.11097010f, 0.16315855f, 0.15895167f, 0.15682201f, -0.09514444f, 0.16959374f, 
    -0.13290313f, -0.15917742f, -0.21237358f, 0.05183008f, -0.02385637f, 0.06808034f, -0.02877229f, 0.01370964f, 
    -0.17203510f, -0.35722029f, -0.39417920f, 0.11613547f, 0.32199219f, 0.01537148f, 0.24252997f, -0.13327457f, 
    -0.03175402f, -0.53436434f, -0.10208198f, -0.15932642f, 0.33412048f, 0.10854471f, 0.19452253f, 0.15914090f, 
    -0.08331719f, -0.06224908f, 0.03960074f, -0.85488158f, -0.55596626f, -0.00792179f, -0.23107085f, 0.16410077f, 
    -0.01319000f, -0.10766992f, 0.06135498f, 0.06051803f, -0.01826479f, -0.45456108f, -0.10198542f, 0.04530202f, 
    -0.23143469f, -0.15535088f, 0.12835461f, 0.03192316f, -0.05721382f, -0.31550345f, -0.24775273f, 0.05205218f, 
    0.13399459f, 0.08043046f, -0.02397194f, 0.03687100f, -0.06076307f, -0.07036396f, -0.12498775f, 0.01670090f, 
    0.07222629f, 0.25773033f, 0.11452242f, 0.10303838f, 0.08687638f, 0.08540908f, 0.44799414f, 0.23371434f, 
    -0.07125296f, 0.03173807f, 0.06117294f, -0.04640469f, 0.05866598f, -0.04054876f, -0.07870684f, -0.05985637f, 
    0.28835016f, 0.22243299f, -0.09147532f, -0.10012897f, -0.14700684f, -0.00449363f, 0.07194015f, 0.18040435f, 
    -0.26703870f, 0.12161215f, -0.19983581f, -0.03731000f, -0.19676122f, 0.03779192f, -0.23846284f, 0.21050422f, 
    0.08218050f, -0.36346665f, 0.00426805f, -0.00468445f, 0.01580392f, 0.16466478f, 0.03558646f, 0.00421231f, 
    0.02629182f, 0.09963453f, -0.10742264f, -0.04788161f, 0.18081629f, 0.14793783f, 0.03916498f, 0.06279390f, 
    0.02960011f, -0.02535522f, -0.12055460f, -0.43367469f, -0.24918815f, 0.39524359f, -0.04702536f, -0.12895557f, 
    -0.13783956f, 0.15462023f, 0.11767434f, -0.00977327f, 0.18378501f, -0.15028313f, 0.10709547f, 0.34616244f, 
    0.24389327f, 0.20742977f, -0.06440159f, -0.04057968f, 0.05969454f, -0.10743134f, -0.11967344f, 0.26597407f, 
    0.18870096f, 0.20128894f, -0.07625967f, 0.05919149f, 0.02991927f, 0.15634976f, -0.24522871f, 0.20477717f, 
    -0.08708183f, 0.01291960f, 0.00301278f, -0.15403524f, 0.06715129f, 0.10148843f, 0.27280718f, -0.48806524f, 
    -0.10655965f, -0.26363724f, 0.10614581f, 0.06989279f, -0.13515377f, 0.03127046f, 0.07331090f, 0.18573466f, 
    0.20890354f, 0.10144044f, 0.20381396f, 0.17825285f, 0.13164714f, 0.17326224f, 0.21719800f, 0.05992364f, 
    0.21200286f, -0.32221296f, 0.03433177f, -0.22137907f, -0.17899762f, -0.24085008f, -0.20745197f, 0.16029602f, 
    0.15977134f, -0.06068246f, -0.04649874f, 0.33780879f, 0.14897802f, 0.03027789f, 0.27723041f, -0.12721229f, 
    0.03557821f, 0.22689688f, -0.08678705f, -0.19772919f, 0.28386956f, -0.43369246f, -0.23097183f, -0.02094696f, 
    -0.17753132f, 0.06083901f, -0.15866987f, 0.23248374f, -0.09264476f, -0.00667976f, -0.13019322f, -0.04605330f, 
    0.04083578f, 0.02075228f, 0.11770906f, 0.18317901f, 0.00762759f, -0.26035213f, -0.32889736f, -0.34446314f, 
    -0.16754285f, -0.39918455f, 0.16432048f, -0.25033784f, -0.02953817f, -0.14444152f, -0.30420062f, -0.01623969f, 
    -0.33145145f, 0.11838128f, -0.05597392f, -0.04818523f, -0.08188850f, -0.05046251f, -0.18198146f, -0.21057232f, 
    0.31880417f, -0.17457162f, 0.40392452f, 0.16075104f, -0.21447931f, 0.00770090f, 0.05350721f, 0.14491308f, 
    -0.10284214f, -0.03818884f, -0.19724540f, -0.04930872f, -0.05391075f, 0.02483537f, 0.02570678f, -0.02778531f, 
    0.11061002f, -0.16227596f, -0.01671394f, -0.12090658f, 0.12581511f, 0.23656009f, 0.02639776f, -0.01000139f, 
    -0.02661215f, -0.11909206f, -0.37862039f, -0.01983840f, 0.00396003f, 0.19841230f, 0.17655738f, -0.21121690f, 
    0.00010960f, 0.05468247f, 0.08951694f, -0.25519374f, -0.19462021f, 0.35794494f, 0.10679610f, 0.19444822f, 
    -0.17262055f, 0.07157759f, -0.25030234f, 0.12944999f, -0.26209071f, 0.09703624f, -0.01251084f, 0.05525303f, 
    0.08199938f, -0.13857490f, -0.07201313f, 0.00737272f, 0.30826733f, 0.11505035f, 0.34569445f, 0.17072493f, 
    0.20652132f, -0.15325244f, -0.00574479f, 0.15338887f, 0.13869138f, -0.02032538f, 0.14590985f, 0.21690571f, 
    0.27236396f, 0.03951978f, 0.15772860f, -0.16284880f, 0.16524167f, 0.20886394f, 0.38961950f, -0.06646174f, 
    -0.28148860f, 0.15380913f, 0.03184820f, 0.09312361f, -0.02769921f, -0.06380139f, 0.00974321f, -0.05443499f, 
    0.40293914f, 0.22086728f, -0.22684598f, 0.04447800f, -0.04223811f, -0.05252101f, -0.02492466f, -0.01084835f, 
    0.05833338f, -0.02983185f, 0.19389461f, 0.35660246f, 0.07937824f, 0.19365491f, -0.03925304f, 0.14865109f, 
    0.03026100f, 0.16094798f, -0.14815575f, -0.23387583f, 0.21623398f, -0.09911064f, 0.11616328f, 0.05658358f, 
    0.14307407f, 0.13071093f, -0.05639332f, -0.29632649f, -0.14039910f, 0.16030912f, 0.04320300f, -0.08335515f, 
    0.05446631f, 0.08214203f, 0.03297934f, 0.07494343f, -0.28073171f, -0.14749956f, 0.02795307f, 0.02196867f, 
    0.06458987f, 0.04152485f, 0.01130768f, 0.01550605f, 0.14187443f, 0.04476365f, -0.15166222f, 0.26057863f, 
    0.22740874f, 0.15231626f, 0.09721529f, 0.20917381f, 0.15860289f, -0.01219490f, 0.04710458f, -0.16380374f, 
    0.31373122f, 0.05541909f, 0.10918027f, 0.34316659f, 0.05697197f, 0.27735716f, 0.27482238f, -0.38128826f, 
    -0.04970323f, -0.21250333f, -0.16124786f, -0.13072349f, 0.05823144f, -0.00485005f, -0.10283252f, -0.08431572f, 
    0.07061525f, -0.28201312f, -0.27901950f, -0.25300962f, 0.08100580f, -0.18610151f, -0.14589457f, 0.23078059f, 
    -0.02206246f, 0.17955738f, -0.54820204f, -0.28813097f, 0.07529271f, 0.04104386f, -0.10225905f, 0.11844105f, 
    0.03301817f, -0.10126422f, -0.26687577f, 0.09451561f, 0.42516333f, -0.03142331f, 0.01093979f, -0.12508811f, 
    0.14169502f, 0.12484268f, 0.01498775f, -0.28802890f, 0.05022471f, 0.54838049f, 0.05208844f, 0.00627212f, 
    -0.02743489f, 0.12482946f, 0.08501600f, 0.01485913f, -0.16576399f, -0.08412981f, 0.00567497f, -0.05826471f, 
    0.10305508f, 0.01084366f, -0.04471686f, -0.04753205f, -0.05256987f, 0.13988033f, -0.11461080f, -0.14790021f, 
    0.10075079f, -0.05175263f, 0.02972481f, -0.17700043f, 0.06107496f, -0.00266785f, 0.09238130f, -0.24481981f, 
    -0.11743265f, -0.00473658f, -0.06282139f, -0.04920454f, -0.07347605f, 0.06166358f, -0.03002338f, -0.22797002f, 
    -0.44087982f, 0.03430127f, -0.09343600f, -0.06516738f, -0.00516010f, -0.00430478f, -0.20708543f, 0.13171463f, 
    -0.07870612f, 0.22024587f, 0.26311222f, 0.12681635f, 0.17432672f, 0.04601351f, 0.17828731f, 0.26006475f, 
    0.05786856f, -0.09215196f, 0.05685379f, 0.16391906f, -0.00611650f, 0.00940147f, -0.31422517f, 0.28085107f, 
    -0.01710080f, 0.12778392f, 0.14421345f, -0.23047316f, -0.40220422f, 0.08253663f, 0.06758717f, 0.08220858f, 
    0.17870633f, -0.00536508f, 0.03096360f, -0.42719576f, -0.20646888f, -0.23650321f, -0.35928243f, 0.02619045f, 
    -0.05537775f, -0.06374820f, 0.13407186f, -0.20607048f, -0.01023415f, -0.12609978f, 0.17622791f, -0.24939016f, 
    -0.03103263f, 0.31707108f, 0.10265027f, 0.09868802f, 0.13511933f, -0.11805836f, -0.23675568f, -0.15337051f, 
    -0.06327650f, 0.02642892f, -0.07519130f, 0.03497220f, -0.03726061f, -0.00949057f, -0.22991413f, -0.10750400f, 
    0.02039167f, -0.32958648f, -0.60395670f, -0.24882835f, 0.12166501f, -0.09100810f, 0.09850573f, -0.21816918f, 
    -0.78548342f, -0.29742977f, 0.02485356f, -0.18334894f, -0.10146243f, 0.08941999f, 0.15155216f, 0.09548841f, 
    -0.14953934f, 0.04712048f, 0.13272768f, -0.30180073f, -0.25825560f, 0.16599938f, 0.09056526f, -0.06324138f, 
    -0.00969552f, 0.00372695f, -0.02772626f, -0.01303574f, 0.19943732f, -0.11072636f, -0.14927454f, 0.26199099f, 
    -0.10138065f, 0.16606939f, 0.02990974f, -0.26571226f, 0.13724048f, 0.01566565f, -0.07510462f, 0.01511209f, 
    0.01374938f, 0.20573795f, 0.08939818f, -0.42343107f, -0.05015619f, -0.04879828f, -0.00861844f, -0.06562123f, 
    -0.05961967f, 0.04820061f, 0.03678546f, -0.30254304f, -0.06361410f, -0.23085383f, -0.12121562f, 0.02456085f, 
    0.03329184f, -0.04516910f, 0.09853940f, 0.22158082f, -0.17262881f, 0.35752320f, 0.05535874f, -0.31775132f, 
    -0.02408438f, 0.21438603f, -0.41403043f, 0.05942807f, -0.18224755f, -0.02279882f, 0.23236756f, -0.02468443f, 
    -0.16053723f, 0.11726084f, 0.12734166f, 0.11953767f, 0.26833972f, 0.01231692f, -0.00941816f, -0.30382940f, 
    -0.08215674f, 0.14129031f, -0.08535474f, -0.00441063f, 0.02755967f, -0.06315774f, 0.06454726f, -0.32563394f, 
    -0.40430248f, -0.39015573f, 0.06466608f, 0.09834439f, 0.03264241f, 0.15268935f, 0.06242331f, 0.08497237f, 
    0.12737821f, -0.20872042f, -0.04184856f, 0.24790715f, 0.05143875f, 0.01184673f, 0.09308820f, 0.20955817f, 
    0.12474861f, -0.01862322f, -0.26550946f, 0.06498569f, -0.05544916f, 0.04040001f, -0.05670401f, -0.17597863f, 
    0.23039411f, 0.00259632f, -0.15865548f, -0.01398990f, 0.14033866f, 0.31091499f, -0.03192222f, -0.10998041f, 
    -0.10519267f, 0.09565938f, 0.08585461f, 0.11654451f, -0.02142961f, 0.04845800f, 0.19316879f, -0.06852270f, 
    0.18422581f, 0.23702668f, -0.15724865f, 0.11534962f, 0.01668703f, 0.00040630f, 0.13290153f, 0.06649144f, 
    0.10662381f, 0.18657449f, 0.01294791f, -0.01832805f, 0.09633695f, 0.02593140f, 0.27979493f, -0.25652564f, 
    -0.31722119f, 0.01933782f, 0.07515369f, -0.07174621f, 0.08297265f, -0.02261433f, 0.13917784f, -0.22475199f, 
    -0.01661276f, 0.03960944f, -0.18695134f, -0.09545735f, -0.00305494f, 0.07804672f, -0.24241032f, 0.08218482f, 
    -0.10831240f, -0.00904868f, 0.07091334f, 0.23314704f, 0.15852804f, 0.20926520f, -0.17090078f, -0.14990261f, 
    -0.11672086f, 0.14404583f, -0.21284983f, 0.16867551f, 0.01039358f, 0.06362528f, 0.15286066f, 0.11582310f, 
    -0.22033440f, 0.09456158f, 0.06920206f, -0.10268194f, -0.19586089f, -0.17256440f, -0.06613947f, 0.00005358f, 
    0.00711280f, -0.15132852f, 0.07709152f, 0.70549703f, 0.11454444f, -0.41568229f, -0.26635072f, -0.15199810f, 
    -0.03373322f, 0.13558613f, -0.09183860f, 0.01863463f, -0.19838235f, -0.07973786f, -0.14211646f, 0.10208920f, 
    0.00500649f, 0.16158569f, 0.00497023f, -0.00851442f, 0.11142454f, -0.12364506f, 0.01848576f, -0.07054307f, 
    -0.13571638f, -0.08938960f, 0.20406270f, 0.03940239f, -0.21069627f, 0.24062826f, 0.27255675f, -0.13882332f, 
    0.14786215f, -0.10621162f, -0.03496775f, 0.11890857f, -0.03162629f, -0.09292354f, 0.15317751f, 0.00289120f, 
    -0.03166083f, 0.24300109f, -0.07428250f, 0.04518456f, 0.22681770f, -0.07346141f, -0.00057743f, 0.07310885f, 
    -0.42385796f, -0.30893549f, -0.61058390f, 0.01811387f, -0.07115263f, -0.03216625f, 0.06106491f, -0.00888364f, 
    0.11662389f, 0.21479693f, 0.03348139f, 0.15721577f, -0.00388237f, -0.05115795f, -0.00966600f, 0.09831206f, 
    -0.00457480f, 0.06001770f, 0.23582526f, 0.21546593f, 0.00630307f, -0.08918244f, -0.01349053f, 0.02125808f, 
    0.03986984f, -0.00482782f, -0.09970634f, -0.02729820f, 0.10514040f, 0.12897749f, 0.09499691f, 0.16951655f, 
    -0.26138112f, -0.20840508f, 0.08483835f, -0.10564314f, 0.09352808f, 0.12894620f, 0.12330588f, -0.15865418f, 
    -0.12409499f, -0.24846338f, -0.08428245f, -0.03650188f, 0.03882976f, 0.02319664f, 0.09805210f, 0.05057429f, 
    0.05923117f, 0.00233154f, -0.02543196f, 0.05520345f, -0.08388092f, 0.30225015f, 0.15155956f, 0.15242694f, 
    0.22236647f, -0.27102178f, -0.10546876f, -0.25825694f, -0.16636133f, -0.05999953f, -0.05126425f, -0.37758270f, 
    -0.08554620f, 0.37390456f, -0.13857260f, 0.08298255f, 0.21120286f, -0.24021125f, -0.02047898f, 0.02407244f, 
    0.15821838f, 0.14324091f, 0.16866033f, -0.13795248f, -0.02763781f, -0.20263958f, -0.21771464f, -0.06418125f, 
    0.06159917f, 0.26779646f, 0.20445479f, 0.12204533f, -0.04477962f, 0.08069428f, 0.04257604f, 0.04939048f, 
    -0.21239181f, -0.09235219f, 0.10906341f, -0.10794935f, 0.16437614f, -0.04894670f, 0.08008145f, 0.13388857f, 
    0.00067533f, -0.11484845f, 0.07616401f, -0.06662052f, 0.07077383f, 0.07634580f, -0.10027054f, 0.05848291f, 
    0.13735865f, -0.17075048f, -0.12282629f, 0.09830234f, -0.16128685f, -0.20480189f, 0.08487592f, -0.03901983f, 
    -0.07299195f, 0.03091132f, -0.18403499f, 0.05301206f, -0.06752297f, 0.37441120f, 0.00373271f, -0.16837665f, 
    0.08703462f, 0.32353091f, 0.08108620f, -0.00335457f, -0.05223405f, -0.17523322f, 0.09670474f, -0.25459361f, 
    0.14218557f, -0.19021453f, 0.05397867f, 0.12587751f, -0.06524026f, 0.13407482f, -0.01372574f, 0.13891403f, 
    0.38438970f, 0.13211067f, -0.07367732f, -0.08005029f, -0.06838729f, 0.06498896f, 0.01675600f, -0.01640385f, 
    0.02771792f, 0.25898254f, 0.18238781f, 0.05826643f, -0.06670604f, -0.12368191f, 0.25123322f, 0.00841184f, 
    -0.08361336f, -0.27700311f, -0.45956731f, -0.16508800f, -0.09174957f, -0.01321074f, -0.04385681f, -0.01000681f, 
    -0.19806814f, -0.15866949f, -0.04212147f, 0.04824623f, -0.42643309f, -0.07369661f, -0.14120279f, -0.12810330f, 
    -0.10045794f, 0.25145847f, 0.01897093f, 0.15877217f, 0.08977884f, 0.18569359f, 0.10775802f, -0.22920567f, 
    -0.04313529f, -0.03780169f, -0.15692881f, 0.05606972f, 0.09044149f, 0.09152774f, 0.02306555f, 0.02553796f, 
    -0.05479314f, -0.08369992f, 0.07627120f, -0.01892865f, 0.01015526f, -0.02486173f, 0.09323584f, -0.28135988f, 
    0.00487804f, 0.01545912f, 0.15254305f, 0.12796907f, 0.01279451f, 0.20397030f, 0.12691250f, 0.05031059f, 
    -0.04596512f, 0.08361446f, 0.09641532f, 0.11329447f, 0.02462911f, 0.15763529f, -0.10535698f, 0.12334727f, 
    0.08788182f, 0.12603833f, 0.01724074f, 0.05400416f, 0.01051237f, -0.04429471f, -0.17043491f, -0.17886309f, 
    -0.04098000f, -0.04711448f, -0.04116549f, 0.02752724f, -0.05461210f, 0.00822842f, 0.04074743f, -0.04173119f, 
    0.05304904f, -0.05808082f, -0.00843278f, -0.02134874f, 0.04146413f, -0.04929277f, 0.03502109f, -0.02048534f, 
    -0.06507047f, -0.05971524f, -0.05490100f, -0.03123436f, -0.00619722f, 0.04383583f, 0.03603893f, -0.00102346f, 
    -0.00831302f, 0.02381893f, -0.05520141f, -0.00233754f, 0.02308305f, 0.04476245f, -0.05553397f, 0.00748880f, 
    0.01843908f, 0.03317415f, -0.01240731f, 0.00718930f, -0.05343084f, 0.04470914f, -0.02472562f, -0.02733580f, 
    -0.00924155f, -0.00587207f, 0.00889557f, 0.03939768f, -0.02900106f, 0.04685796f, 0.02564933f, -0.04966069f, 
    0.03305672f, 0.01561228f, -0.03940364f, -0.02303911f, -0.01717805f, 0.03714786f, -0.02982068f, 0.00807809f, 
    -0.05595099f, -0.00756876f, -0.05994550f, -0.02073447f, 0.00198940f, 0.00644715f, 0.04573509f, -0.02376854f, 
    -0.03675697f, 0.04550601f, 0.03060450f, -0.03633829f, 0.05595812f, 0.01671930f, -0.04823478f, -0.00693606f, 
    -0.04146960f, 0.03296464f, 0.03061707f, 0.01592472f, -0.05572615f, -0.03918730f, 0.02915516f, -0.04389218f, 
    0.00476725f, 0.03142404f, 0.02273886f, -0.03250816f, -0.04088338f, -0.06117721f, -0.02950643f, -0.00279477f, 
    0.04417293f, 0.03507981f, -0.04456580f, -0.04796821f, 0.01705455f, 0.04794023f, 0.02559436f, 0.03281295f, 
    0.03691793f, -0.04091936f, 0.03373215f, 0.00358223f, 0.01186315f, 0.00186319f, -0.03322839f, -0.03133688f, 
    -0.01019134f, -0.00701510f, 0.05774647f, -0.00219566f, -0.04502372f, -0.05385234f, 0.00008198f, -0.02583943f, 
    -0.00488624f, -0.04840085f, 0.03261395f, -0.06038145f, -0.06257962f, 0.02599007f, 0.05854190f, 0.03004227f, 
    -0.00517225f, -0.04754760f, -0.05470727f, 0.00155344f, -0.03090918f, -0.03615167f, 0.03085639f, -0.00764963f, 
    -0.00640321f, -0.00104885f, -0.01450606f, -0.06089139f, -0.04851227f, -0.05801376f, 0.04714827f, -0.00666531f, 
    -0.06652925f, -0.02885472f, 0.00647764f, -0.05702851f, 0.04647919f, -0.04612119f, 0.04254488f, -0.02624214f, 
    0.01690842f, -0.02119714f, -0.00160943f, 0.04968016f, -0.04708367f, -0.00979879f, -0.05476855f, 0.03386781f, 
    0.04504534f, 0.03413400f, 0.03905079f, -0.05482284f, 0.04948971f, 0.03543149f, 0.01786775f, -0.03987173f, 
    -0.04723110f, -0.05076241f, 0.02135148f, 0.03646464f, -0.04918553f, 0.03567515f, -0.06319880f, -0.04327772f, 
    -0.01347171f, -0.01865406f, -0.04274893f, -0.01962464f, -0.00525572f, 0.00879654f, -0.03310405f, 0.03581226f, 
    0.00205922f, -0.02298643f, -0.01713252f, -0.02087156f, -0.01751779f, -0.05543953f, -0.01036105f, -0.02273361f, 
    -0.04198107f, 0.03935929f, 0.06213005f, 0.02023047f, -0.01849719f, -0.06688724f, -0.02831841f, -0.00563842f, 
    -0.02535891f, -0.00276097f, -0.05149294f, -0.05593684f, -0.04075513f, 0.00673663f, -0.02998949f, -0.05838256f, 
    0.01716368f, -0.05083050f, 0.03417758f, -0.04731116f, -0.00818330f, -0.03466813f, 0.02275924f, -0.05340322f, 
    0.03074973f, 0.02077881f, -0.00974741f, -0.04918694f, -0.03443190f, 0.02681935f, 0.04671964f, 0.01831545f, 
    -0.02449915f, 0.03459443f, -0.01317065f, -0.06208795f, 0.03745168f, -0.03709194f, -0.05042985f, -0.06096504f, 
    -0.04591171f, -0.04791979f, 0.01334157f, -0.01382647f, 0.00666298f, 0.04194091f, 0.00974375f, 0.03665981f, 
    -0.04499748f, -0.00349154f, 0.03815677f, -0.05526278f, 0.04197883f, -0.03330605f, -0.04976513f, -0.01042051f, 
    -0.02199870f, -0.03881658f, 0.01237841f, 0.03182456f, 0.02019636f, -0.04054075f, 0.00987367f, -0.01190507f, 
    0.05238496f, -0.01980469f, 0.01823551f, 0.00448351f, 0.00388424f, 0.00619372f, 0.04666683f, -0.03734440f, 
    -0.05240945f, -0.03982619f, -0.06567147f, -0.00414829f, 0.04622838f, -0.01122735f, 0.04337989f, -0.04493463f, 
    -0.02836190f, 0.04180422f, 0.01081671f, -0.01964980f, 0.01964969f, 0.03096356f, -0.03235858f, -0.01396870f, 
    -0.00608272f, -0.05020130f, -0.05058635f, 0.03951176f, 0.01877115f, 0.04478193f, 0.03222965f, -0.05181985f, 
    -0.00019938f, 0.01966894f, -0.04393435f, -0.04096400f, -0.03581429f, -0.01765819f, 0.03945888f, -0.06886710f, 
    0.02931837f, 0.06171209f, -0.03227728f, -0.03333319f, -0.02516592f, 0.00141198f, -0.00949343f, 0.01347489f, 
    -0.05359030f, 0.04607957f, 0.02494224f, 0.01688434f, -0.03215558f, 0.04234259f, -0.03735476f, 0.01144959f, 
    -0.03084032f, 0.04807894f, 0.01192503f, 0.00760065f, 0.05993563f, 0.01784892f, -0.02488083f, -0.03528248f, 
    -0.05188962f, 0.03806534f, -0.04710794f, -0.06154171f, 0.03400435f, 0.00746459f, -0.05936733f, -0.02134176f, 
    -0.00374898f, 0.04906300f, 0.00705017f, -0.04433841f, 0.03819884f, 0.04953383f, -0.00143403f, -0.04624061f, 
    -0.06416430f, 0.04808778f, 0.00175774f, -0.06231205f, -0.04038925f, 0.03813662f, -0.01735310f, -0.05470940f, 
    0.00469535f, 0.01176557f, -0.02786577f, -0.01158356f, -0.06424338f, -0.02908349f, -0.05980034f, -0.00278005f, 
    -0.01031228f, 0.00902451f, -0.02218414f, -0.06696743f, 0.00748616f, -0.01246014f, -0.05920105f, 0.05095915f, 
    -0.04114444f, -0.01389541f, 0.01562116f, -0.00720235f, 0.00234282f, 0.00511353f, 0.01979343f, 0.03812581f, 
    -0.05201418f, 0.00839012f, 0.00559167f, -0.02144260f, -0.00572389f, -0.02490193f, 0.01165095f, -0.00273471f, 
    -0.05702963f, 0.02342671f, -0.01135829f, 0.04725650f, -0.00203944f, 0.02171939f, -0.00654362f, -0.06157332f, 
    -0.06402262f, -0.00979923f, -0.00466729f, -0.03000259f, -0.03093722f, -0.01025704f, 0.04119810f, 0.04897325f, 
    -0.06414560f, 0.02166234f, 0.00830959f, 0.02249956f, -0.02623407f, -0.03417322f, -0.01128515f, -0.02707059f, 
    -0.03512331f, 0.00798750f, 0.01649418f, -0.02685306f, 0.02210159f, 0.00053372f, 0.03181981f, 0.00431069f, 
    0.02625681f, -0.03806226f, -0.03826220f, -0.02998241f, 0.01353900f, -0.01682847f, -0.02078523f, -0.00852979f, 
    -0.01262886f, -0.01014333f, -0.02047797f, -0.01119531f, -0.04905003f, 0.03530587f, 0.01217793f, 0.02503080f, 
    -0.00502868f, 0.02056982f, -0.01753746f, 0.03732881f, 0.00968576f, -0.03859794f, 0.04501142f, -0.01414316f, 
    -0.01568775f, 0.02720005f, -0.02243359f, -0.00364152f, -0.00827259f, 0.02383060f, 0.00449528f, -0.02184200f, 
    -0.01824557f, -0.05617711f, -0.00782009f, 0.03933536f, 0.01203686f, 0.01947786f, -0.06535985f, 0.03590370f, 
    -0.06303445f, -0.04279864f, -0.06650843f, -0.06336018f, -0.02383014f, 0.03978958f, -0.00696513f, -0.00093112f, 
    -0.03343897f, -0.05037830f, -0.02852695f, 0.00369934f, 0.01822230f, -0.06168418f, -0.02537532f, 0.02341108f, 
    -0.01086563f, 0.03276388f, 0.02782986f, 0.04155245f, 0.00912125f, 0.02950874f, 0.04470935f, -0.02196581f, 
    -0.05316848f, -0.02479948f, -0.00335130f, -0.01989230f, 0.03664332f, 0.05305202f, 0.00488470f, -0.05713048f, 
    0.03081894f, 0.01771076f, -0.00139871f, -0.05631153f, 0.01741567f, 0.01614324f, -0.00597483f, -0.06595176f, 
    0.00628298f, -0.02858927f, -0.06792805f, 0.00267906f, 0.02975852f, -0.01439041f, -0.05246422f, 0.00589625f, 
    -0.02142883f, -0.04270135f, -0.01145960f, -0.01884376f, -0.05155716f, 0.02279415f, 0.02772146f, -0.00644696f, 
    -0.04161624f, -0.01007884f, -0.01087190f, -0.04649784f, -0.03737343f, 0.04933926f, -0.03432538f, 0.02393410f, 
    -0.06030831f, -0.00716481f, -0.04566120f, 0.04911002f, -0.04976507f, -0.03132819f, -0.00296638f, -0.01421121f, 
    0.04505447f, 0.03192521f, 0.03422307f, 0.01083837f, 0.04244615f, 0.02728674f, 0.02357872f, -0.04100151f, 
    -0.03035150f, -0.05659050f, -0.02790178f, -0.02476633f, -0.00774424f, -0.03736037f, -0.05002399f, 0.00293161f, 
    -0.04285818f, 0.05829260f, -0.03287736f, -0.03540464f, 0.03763228f, -0.03893319f, -0.04990206f, 0.03072837f, 
    0.03491780f, -0.02905453f, 0.03963421f, 0.00350820f, -0.04524925f, -0.01685526f, -0.04888719f, -0.00501999f, 
    0.01658720f, -0.01373762f, 0.01432208f, -0.03526484f, -0.03418168f, 0.01876224f, -0.03387338f, 0.04341320f, 
    -0.02502000f, -0.02872889f, -0.03926336f, 0.02274588f, -0.04135442f, -0.00869307f, -0.00821957f, -0.04138354f, 
    -0.03676806f, -0.05593797f, 0.01267653f, -0.00363148f, -0.06467483f, -0.03005396f, -0.04893987f, -0.06393792f, 
    -0.03665921f, -0.01856505f, 0.04122817f, 0.02667377f, -0.03947254f, 0.03818166f, -0.03298926f, -0.00658959f, 
    -0.32279885f, -0.58994776f, -0.60880297f, -0.07996697f, -0.08075684f, 0.08886662f, -0.07827218f, -0.11818462f, 
    -0.12993093f, -0.47182903f, -0.73190391f, -0.35747945f, -0.03063833f, 0.06904700f, -0.12980051f, 0.10675473f, 
    0.05335787f, 0.01891997f, 0.11434688f, -0.32686648f, 0.03096835f, -0.14677294f, -0.01627131f, -0.02480723f, 
    0.13732798f, 0.00007060f, 0.08222195f, 0.49224117f, 0.12301689f, 0.00692760f, -0.01534724f, -0.02143539f, 
    -0.02347339f, 0.00229169f, -0.11905076f, 0.08122060f, -0.11248948f, 0.35797846f, 0.28621307f, -0.10128616f, 
    0.02459267f, -0.09725406f, -0.04570230f, -0.00802785f, 0.07169067f, -0.08972550f, -0.25038293f, -0.50273556f, 
    -0.11054671f, 0.02486128f, 0.03433534f, 0.17882228f, 0.22149456f, 0.05464566f, 0.12012193f, -0.82329696f, 
    -0.26817828f, 0.25413409f, -0.11657399f, -0.13405436f, 0.03059099f, 0.14782727f, 0.08238056f, -0.04065312f, 
    0.30321717f, 0.37705597f, 0.07301845f, -0.21583761f, -0.00084476f, 0.19499086f, -0.00516011f, 0.23289825f, 
    0.15173340f, 0.06152056f, 0.10658951f, -0.00439840f, 0.06388634f, 0.07956120f, -0.00124282f, 0.14418574f, 
    0.02571595f, -0.10798139f, -0.38576356f, -0.43488866f, 0.15749717f, 0.17227423f, 0.17495114f, 0.08074034f, 
    0.17365493f, 0.05754783f, -0.14040752f, -0.35218000f, -0.40911666f, 0.06930911f, -0.23330726f, -0.03787861f, 
    -0.03207481f, 0.12056163f, 0.15273456f, -0.12234436f, -0.82640409f, -0.27492473f, 0.08708362f, -0.09160548f, 
    0.34611723f, 0.40041170f, -0.04593727f, -0.25226644f, 0.07555994f, 0.16196862f, 0.05657230f, -0.07575722f, 
    -0.12378316f, -0.16758531f, 0.06564283f, -0.08996054f, 0.02227612f, -0.19963476f, -0.10226534f, 0.42987522f, 
    0.16338795f, -0.19083455f, -0.00217441f, 0.11865287f, 0.04390343f, 0.03218949f, 0.53147203f, 0.18856077f, 
    -0.51901126f, -0.36474094f, -0.19359918f, 0.04134225f, 0.03184872f, 0.01715125f, 0.05538944f, -0.60194153f, 
    -0.25556207f, -0.40114686f, -0.00328431f, -0.04922851f, -0.32831711f, 0.00740789f, 0.02038448f, -0.16493838f, 
    0.11393350f, -0.05695532f, -0.64533311f, -0.10489517f, 0.11918935f, 0.06233650f, 0.08784584f, 0.10193571f, 
    -0.09883747f, -0.18358362f, -0.10247312f, 0.21520329f, -0.18519261f, -0.25003436f, 0.04037461f, 0.05065740f, 
    -0.01880672f, 0.03944884f, 0.01381507f, -0.55333722f, 0.13091952f, -0.35983086f, 0.15649791f, -0.20131850f, 
    -0.00686072f, -0.05308913f, 0.09392265f, 0.21618633f, 0.30760902f, 0.18733940f, -0.02546803f, -0.06645524f, 
    -0.08482572f, 0.04617381f, 0.02563067f, 0.29970244f, 0.03997651f, 0.10643051f, -0.07549746f, -0.05040112f, 
    0.07653981f, -0.06482661f, 0.00429695f, -0.14320870f, -0.08333045f, 0.62849051f, -0.97250640f, -0.34707469f, 
    -0.29586795f, -0.01819549f, 0.10090389f, 0.14170671f, -0.02552346f, -0.03007329f, 0.15441716f, -0.09761544f, 
    -0.17786936f, -0.00774472f, -0.10845417f, 0.13106835f, 0.06819080f, 0.13048315f, 0.01381098f, 0.38254082f, 
    0.30595523f, 0.27939251f, -0.12312017f, 0.02491816f, 0.18147145f, 0.03005802f, -0.07299937f, 0.01625310f, 
    -0.06767403f, -0.03490900f, 0.28081578f, -0.03460004f, 0.03047370f, 0.05829780f, 0.10488171f, -0.05822456f, 
    -0.10192191f, 0.17881563f, 0.09908205f, -0.08085914f, -0.06585212f, -0.00184696f, 0.04927306f, 0.16100709f, 
    0.02490738f, -0.04427294f, 0.20985399f, 0.20196368f, 0.30031598f, 0.02990319f, 0.09320244f, 0.13564382f, 
    0.00303954f, 0.01031106f, 0.06746685f, 0.16047867f, -0.37275836f, -0.44158325f, -0.02518421f, -0.09548311f, 
    0.01218766f, 0.11692043f, -0.05403119f, -0.04046825f, 0.32863727f, -0.05298827f, -0.06316335f, -0.05339476f, 
    0.01305699f, 0.03476829f, 0.24776551f, 0.01944228f, -0.09970794f, 0.22569561f, 0.17778561f, -0.17437150f, 
    -0.03470662f, -0.01582621f, 0.00288601f, 0.09014737f, -0.03458343f, 0.08207493f, -0.19029152f, -0.33822089f, 
    0.22387348f, -0.25338212f, -0.06022487f, -0.06728125f, -0.10772096f, -0.03579721f, 0.02075586f, 0.17643277f, 
    -0.17440426f, -0.24820982f, 0.09185062f, -0.05792458f, -0.19418618f, -0.03723526f, -0.12313752f, -0.03450182f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.05768904f, 0.00244444f, -0.17340575f, 0.21882661f, -0.09419207f, 0.27341750f, 0.12304530f, 0.06689069f, 
    0.31349951f, 0.07119206f, 0.09072968f, -0.00215629f, 0.21679795f, -0.02956766f, 0.27106774f, -0.02887033f, 
    -0.00985020f, -0.04974921f, 0.02871262f, 0.16786690f, 0.05668082f, 0.00225259f, 0.20329379f, -0.01723991f, 
    -0.04000228f, 0.13272826f, 0.25542292f, 0.35072955f, 0.09975635f, -0.04144063f, 0.04197505f, -0.05488906f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.62968993f, -0.11346844f, 0.06425215f, 0.15990883f, -0.14029467f, 0.15534867f, -0.15866101f, 0.09722763f, 
    -0.24654503f, 0.56382453f, 0.46517661f, -0.06722895f, 0.02898630f, -0.02514120f, 0.18091932f, -0.09573974f, 
    0.09232952f, 0.30923232f, 0.00725778f, -0.09058803f, -0.18033001f, -0.31057641f, 0.16788894f, 0.08733355f, 
    0.04061028f, 0.03816110f, -0.30093229f, 0.52050978f, 0.24634320f, -0.05739230f, 0.07662985f, 0.47538725f, 
    -0.19080073f, 0.42366758f, 0.18548229f, 0.10283691f, -0.36851105f, 0.00049038f, 0.09601423f, -0.28130743f, 
    0.04086153f, -0.45367408f, 0.01509020f, -0.06061136f, 0.72016132f, -0.15419194f, -0.12049452f, 0.03593197f, 
    0.11545177f, -0.01730609f, 0.12887795f, 0.39251801f, 0.30072463f, 0.25819385f, -0.27072373f, -0.25283539f, 
    -0.00699946f, -0.13878679f, 0.24145463f, 0.17526355f, -0.17266050f, -0.09645077f, 0.11201210f, -0.01634752f, 
    0.28651509f, -0.14589950f, -0.24325705f, 0.28337309f, 0.47355589f, 0.06268577f, -0.05414150f, -0.17596853f, 
    -0.53558475f, 0.27201158f, 0.00439512f, 0.03399478f, -0.19829427f, 0.07880622f, 0.41683295f, -0.15405232f, 
    -0.23914421f, -0.13719831f, 0.13365428f, -0.06209361f, -0.36892739f, -0.03869176f, 0.21871583f, -0.05598821f, 
    0.04727873f, 0.57253999f, -0.01172423f, -0.20775889f, 0.13534158f, -0.04941959f, -0.00946349f, 0.23670177f, 
    -0.02204002f, -0.58396465f, -0.34128633f, 0.22805050f, -0.38202831f, 0.29129279f, 0.08579419f, 0.18864849f, 
    0.64756167f, -0.05041451f, -0.13487227f, -0.03419238f, 0.06088490f, -0.03074176f, 0.01365341f, -0.01537453f, 
    -0.00712200f, -0.00576949f, -0.21744339f, 0.01130913f, -0.06709568f, 0.26633340f, 0.40846488f, 0.21314912f, 
    -0.14635046f, -0.13253112f, 0.21057154f, 0.35727608f, -0.44092196f, 0.12454503f, -0.08878327f, -0.21206607f, 
    0.14672410f, 0.02270307f, -0.20674892f, 0.34103885f, 0.05756304f, -0.26315129f, -0.18645839f, -0.08340384f, 
    -0.37747833f, 0.32461479f, 0.41564295f, -0.14071915f, -0.25020900f, 0.07428159f, 0.17746040f, -0.01852285f, 
    0.22492869f, -0.03493297f, -0.30049458f, -0.16497040f, 0.04362225f, -0.22033542f, 0.33327928f, 0.29754937f, 
    -0.02409869f, -0.19143739f, 0.26210788f, -0.07077023f, -0.06642026f, 0.08572511f, 0.01054878f, -0.23197086f, 
    -0.06079322f, 0.56634223f, -0.01346666f, -0.02003565f, 0.26736921f, -0.13533194f, -0.13502020f, -0.32246336f, 
    -0.15733065f, -0.27315214f, 0.25781792f, 0.16111971f, -0.42176542f, -0.08515996f, -0.10430333f, 0.09387759f, 
    0.47090486f, -0.13431266f, -0.08030522f, 0.09649690f, 0.31603968f, 0.07486923f, -0.04153396f, -0.29868707f, 
    -0.15276328f, 0.36373261f, 0.03857907f, -0.76510316f, 0.02797828f, 0.09528161f, 0.17610288f, 0.16525939f, 
    -0.17372003f, -0.15350889f, 0.00997154f, 0.08295000f, -0.02744399f, -0.01676195f, -0.21422882f, 0.09085563f, 
    0.09683155f, -0.00314800f, 0.12622759f, 0.03614606f, -0.08677293f, 0.07643940f, -0.10063119f, 0.04173573f, 
    0.11721478f, -0.08441672f, -0.08141436f, -0.15173657f, -0.01587548f, -0.14943035f, -0.04163440f, -0.18002029f, 
    0.07947201f, -0.19515410f, -0.16646513f, -0.14104615f, 0.12666827f, -0.09691000f, -0.06031892f, -0.00281135f, 
    -0.04134192f, -0.19171263f, -0.09594771f, -0.04964598f, -0.19241902f, -0.12975638f, -0.18093693f, 0.10003598f, 
    -0.06651244f, 0.00852235f, -0.20080660f, 0.12958263f, 0.03886510f, 0.01246530f, -0.03835409f, 0.14171332f, 
    -0.07795493f, -0.15182291f, 0.14177129f, -0.13133633f, 0.01644428f, -0.06034774f, -0.02697763f, 0.13894229f, 
    0.13864662f, -0.03751829f, 0.10694177f, 0.10215817f, -0.13105308f, -0.07656584f, 0.13246530f, 0.09705769f, 
    0.11698749f, -0.18421924f, 0.13551305f, 0.03702185f, -0.09587145f, -0.15571299f, 0.12806492f, 0.03404642f, 
    -0.17614052f, -0.20870723f, -0.17728457f, -0.10520568f, 0.06700087f, 0.08919106f, -0.04347855f, 0.14670388f, 
    -0.17574956f, -0.03109401f, -0.04967115f, 0.08990216f, -0.13777214f, -0.08312945f, 0.02206565f, 0.03135863f, 
    -0.07535774f, -0.06871902f, -0.16213350f, -0.14345826f, -0.18030025f, 0.03081401f, -0.13527724f, 0.04367660f, 
    0.05606871f, 0.16647591f, -0.34710860f, 0.30266571f, 0.14793284f, -0.41364390f, 0.03414287f, -0.46646020f, 
    -0.14265862f, 0.38197693f, 0.33456269f, -0.09249044f, -0.24628723f, -0.12097448f, 0.16403544f, -0.14660875f, 
    -0.27774239f, -0.61346996f, 0.13286728f, 0.08692205f, -0.16993652f, -0.17443001f, 0.04647031f, 0.30471918f, 
    0.01869537f, 0.10815168f, 0.51128989f, 0.06769837f, 0.27171227f, 0.10952384f, -0.02336801f, -0.56661600f, 
    -0.23347349f, -0.17159916f, 0.11950378f, -0.06967024f, 0.43931600f, -0.01903396f, 0.14984986f, -0.11068369f, 
    0.17941162f, -0.21041925f, -0.13978451f, 0.13833769f, 0.49911818f, 0.00165562f, -0.10882875f, -0.04001379f, 
    -0.09238401f, 0.10659815f, 0.20158859f, -0.26959676f, 0.33396885f, 0.29997879f, 0.23397002f, -0.15443060f, 
    0.17112505f, 0.18645634f, 0.27890313f, -0.03381722f, -0.06925121f, -0.00251031f, 0.10167006f, -0.64188713f, 
    -0.07266467f, -0.23120461f, -0.24740003f, -0.07237512f, 0.40915883f, 0.10749254f, 0.20761521f, 0.05423414f, 
    -0.11218048f, -0.30581731f, 0.21903045f, -0.13992251f, -0.31893736f, -0.01839638f, 0.47631902f, -0.12381683f, 
    -0.03990738f, 0.02730868f, 0.22500417f, -0.30443355f, 0.27474287f, -0.05318492f, 0.20433958f, -0.18469636f, 
    -0.18115154f, 0.74975789f, -0.10424627f, -0.29680690f, 0.15383200f, 0.08033141f, -0.11606944f, -0.44852245f, 
    0.32357842f, -0.37370029f, 0.28525859f, -0.02611624f, -0.52243942f, 0.10570702f, 0.31093311f, -0.11522014f, 
    -0.34988904f, -0.38488454f, -0.00449229f, 0.17077860f, 0.37890190f, -0.08663286f, 0.25001624f, 0.01788522f, 
    -0.13825060f, 0.07268211f, -0.01072248f, 0.37278679f, 0.22641823f, 0.24728726f, 0.01512144f, -0.31078786f, 
    0.12142051f, 0.17186649f, -0.08260409f, 0.34722802f, 0.03261586f, 0.01000678f, 0.05657344f, 0.25646234f, 
    -0.09921045f, 0.39925763f, -0.27238590f, -0.04435441f, 0.01297453f, -0.06553373f, 0.30120525f, -0.06101878f, 
    0.32977101f, 0.09565751f, -0.13554724f, -0.16049318f, -0.32965538f, -0.06728018f, -0.25126660f, -0.12486475f, 
    -0.14857011f, -0.46451473f, -0.10100697f, 0.41838434f, -0.08269211f, 0.05176006f, 0.04370391f, 0.07985639f, 
    0.05002870f, 0.04981532f, 0.07498407f, 0.22138014f, 0.22502759f, -0.02991982f, 0.01923560f, -0.07011451f, 
    -0.34021023f, -0.09064188f, 0.01117493f, 0.23537958f, 0.16572833f, 0.10611097f, 0.09767774f, 0.09525526f, 
    -0.20789829f, -0.22020827f, -0.20248950f, -0.04037514f, 0.79573989f, -0.11328986f, 0.17333977f, -0.09846574f, 
    -0.11433145f, -0.02043007f, 0.25212243f, -0.08872756f, 0.28225371f, -0.05089466f, 0.04859334f, -0.01030259f, 
    0.01446482f, -0.03125845f, 0.26659477f, 0.05297121f, -0.77112103f, -0.10592461f, -0.10049657f, -0.33435330f, 
    -0.19423810f, -0.21045804f, -0.24835704f, 0.27049851f, 0.44183365f, -0.09406713f, -0.02011018f, -0.22162358f, 
    -0.04898396f, 0.12616317f, 0.00884808f, 0.17959002f, -0.20267086f, -0.15474656f, 0.01184311f, 0.14401050f, 
    0.35659364f, 0.45455289f, 0.20356359f, -0.17539728f, 0.25227958f, -0.22717746f, 0.41619995f, 0.14221016f, 
    -0.01033565f, 0.47811955f, 0.23174211f, 0.34119141f, -0.18925239f, -0.06256324f, 0.04976114f, -0.49241388f, 
    0.03737566f, -0.12993677f, -0.05654674f, 0.02789590f, -0.07949216f, -0.14181787f, -0.17055318f, 0.14941165f, 
    -0.03481041f, 0.00954702f, -0.12746020f, 0.00465919f, -0.14366707f, -0.17096902f, 0.10428991f, 0.02195617f, 
    -0.05224909f, 0.03708472f, 0.00988940f, -0.12045413f, -0.10351521f, -0.14532647f, -0.08543240f, -0.03338157f, 
    0.08017492f, -0.11242417f, -0.00982112f, 0.09293694f, 0.10465231f, -0.13064094f, -0.06781289f, -0.17148393f, 
    0.04915690f, -0.01563329f, -0.15403265f, -0.05336310f, -0.11468226f, -0.07979718f, 0.11668817f, 0.08462737f, 
    -0.00001531f, -0.07651858f, 0.01557675f, 0.02909698f, 0.05839656f, 0.11571420f, -0.07315099f, 0.06359705f, 
    -0.17739880f, -0.14794554f, -0.07099638f, -0.00161268f, -0.02082674f, -0.09019699f, 0.02673758f, 0.09827846f, 
    -0.08244443f, -0.08279681f, -0.13217418f, 0.07804486f, -0.06212044f, -0.03836838f, 0.09780010f, -0.07582766f, 
    -0.05051028f, -0.10146286f, -0.51517618f, -0.05674795f, -0.34693533f, 0.26682544f, 0.28095582f, -0.00756963f, 
    0.69723523f, -0.04781037f, -0.22009240f, -0.08268367f, -0.09367623f, 0.10874882f, -0.28953406f, -0.08133388f, 
    -0.19001931f, -0.56667274f, -0.14639299f, 0.31779778f, 0.16776137f, -0.05134031f, 0.12819092f, -0.05613571f, 
    -0.07874618f, 0.04834952f, 0.15215661f, 0.33866981f, 0.20106213f, 0.14522140f, 0.07591365f, 0.03147634f, 
    -0.08629852f, -0.00104225f, -0.01716501f, 0.05426225f, -0.06645606f, -0.08380735f, -0.10249137f, -0.01907940f, 
    0.03510132f, -0.10512392f, -0.12020647f, 0.00620909f, -0.11052699f, -0.04349637f, -0.04173534f, 0.01179315f, 
    -0.14186412f, -0.09164596f, -0.07257318f, -0.03376593f, -0.01500948f, 0.10625848f, -0.13643868f, -0.16804397f, 
    0.07216145f, 0.04256993f, -0.06293858f, -0.16748676f, -0.02439844f, -0.14774118f, -0.17353576f, -0.03339255f, 
    0.19357306f, -0.02811141f, 0.26627624f, 0.18765488f, -0.44114178f, -0.06872175f, -0.44087502f, -0.31948262f, 
    -0.23353614f, -0.13172245f, 0.30362666f, 0.13397041f, 0.33288500f, -0.00879335f, -0.28477007f, -0.08108284f, 
    0.36062339f, 0.32187146f, -0.23926467f, 0.09121558f, 0.22808236f, 0.15161879f, 0.05960353f, -0.20830034f, 
    0.01267639f, -0.41638762f, 0.21427457f, 0.30598709f, -0.29952949f, 0.00408657f, 0.05042606f, -0.18959512f, 
    -0.11498056f, -0.15403168f, -0.27550125f, 0.31257558f, 0.65854305f, 0.16939028f, 0.22113582f, 0.47987059f, 
    -0.53035015f, 0.35310325f, -0.07935919f, -0.13987873f, -0.11815423f, -0.06026616f, -0.04640651f, 0.03630656f, 
    0.21154723f, 0.14640862f, 0.00465018f, -0.22144942f, 0.02465433f, -0.23213989f, 0.25070634f, 0.35480240f, 
    0.15957436f, -0.02558767f, -0.02881133f, -0.04908363f, -0.40780404f, -0.08878370f, 0.12495036f, 0.01776362f, 
    -0.15641609f, -0.29969093f, 0.09572672f, -0.04377300f, -0.31716800f, 0.37794074f, -0.27574944f, -0.23551506f, 
    0.63361424f, -0.02567506f, 0.11228430f, -0.08109845f, 0.92272866f, -0.00272185f, -0.12210309f, 0.09108002f, 
    -0.29283884f, 0.08172647f, 0.09533373f, 0.06167785f, 0.18794435f, 0.20239024f, -0.08550726f, 0.19503452f, 
    0.14707780f, -0.56977957f, 0.17793418f, 0.51765043f, -0.43067640f, 0.09083422f, -0.10553311f, -0.37487227f, 
    -0.18628681f, -0.03007187f, 0.01299911f, -0.00500489f, 0.07779223f, 0.03134345f, -0.02271943f, 0.08464638f, 
    0.10581385f, -0.06576271f, 0.38375068f, 0.02269535f, -0.41605791f, -0.14818774f, 0.27183190f, -0.04606531f, 
    0.14991558f, 0.18145242f, -0.16262369f, -0.46551806f, -0.27010056f, -0.08026331f, 0.07639591f, -0.04947473f, 
    -0.14505093f, 0.15782699f, 0.08224592f, -0.00588855f, 0.14714368f, 0.00385828f, 0.08588091f, -0.24658076f, 
    0.00407453f, -0.14480519f, 0.02014804f, 0.08174726f, -0.04543396f, -0.19194752f, -0.01058432f, 0.14157547f, 
    -0.03257091f, -0.19680266f, 0.06848539f, -0.10144601f, 0.09725323f, -0.05627643f, 0.08213101f, 0.05485966f, 
    -0.17455080f, -0.13932721f, -0.09084231f, -0.14951895f, -0.01208425f, -0.00545601f, -0.04609017f, -0.05769920f, 
    0.02456883f, -0.08265995f, -0.02386490f, 0.04765634f, -0.08312121f, 0.12073138f, 0.13480252f, -0.09869698f, 
    0.47178689f, 0.35775551f, -0.14258651f, 0.06372230f, 0.06643852f, -0.04211138f, -0.22880825f, 0.31945559f, 
    0.02590546f, -0.04711026f, 0.36334655f, -0.08698227f, -0.14664376f, 0.13377020f, -0.07869217f, -0.12906201f, 
    0.15733531f, -0.31834108f, -0.51671588f, 0.41005492f, 0.45302829f, 0.00861647f, 0.06278946f, -0.04354468f, 
    -0.09313206f, 0.12130029f, 0.04357884f, -0.62615931f, 0.06551976f, -0.00190101f, -0.03090682f, 0.69922966f, 
    -0.18120322f, -0.54222751f, -0.02145838f, -0.02489265f, -0.37909791f, 0.47723812f, 0.30528125f, 0.37134740f, 
    0.27428427f, -0.22475152f, 0.04911717f, 0.04407567f, -0.05022092f, 0.13926002f, 0.04669173f, 0.07227344f, 
    0.10182303f, -0.13956270f, -0.19673644f, 0.04152889f, -0.10581538f, 0.22933654f, 0.18308571f, 0.02703491f, 
    0.00926158f, -0.30129448f, 0.03683028f, -0.30396965f, -0.18754786f, -0.15104778f, -0.05031335f, -0.07809611f, 
    0.18646789f, -0.25515428f, -0.27807873f, -0.07692137f, 0.14944044f, 0.46774724f, 0.32294351f, 0.42747968f, 
    -0.40608996f, 0.10423584f, 0.17921022f, 0.01332820f, 0.11509238f, 0.06131518f, 0.37612724f, 0.03320859f, 
    -0.35912022f, -0.22603777f, 0.05558954f, 0.30234402f, -0.18434939f, -0.30008712f, -0.07472157f, 0.25688156f, 
    0.05593492f, -0.08476243f, 0.14971100f, 0.23046803f, -0.05596491f, -0.12526315f, 0.12115875f, 0.35826814f, 
    0.67272401f, -0.16357425f, -0.11267699f, 0.09913886f, -0.26917699f, -0.22900376f, -0.01930739f, -0.08025055f, 
    0.34225529f, -0.02419051f, 0.15231973f, 0.17382941f, -0.39042991f, -0.13497899f, -0.38164386f, -0.15557648f, 
    0.24275923f, 0.27060890f, -0.70426118f, 0.34503806f, 0.16024780f, 0.09091511f, 0.35265782f, -0.21493970f, 
    0.11398391f, 0.38999474f, -0.18684998f, 0.24406062f, -0.10142560f, 0.16560701f, -0.11923069f, 0.43429708f, 
    0.34709603f, -0.28529489f, -0.34080863f, -0.03020245f, -0.08652148f, 0.36163291f, 0.25430837f, -0.15897164f, 
    0.04712145f, 0.24836016f, 0.47923565f, -0.07059148f, 0.18142204f, -0.13193668f, 0.20514135f, 0.04865159f, 
    -0.43193874f, -0.34450069f, 0.04669695f, -0.00144836f, -0.10009421f, -0.31494635f, 0.00288014f, 0.20970039f, 
    0.07930709f, -0.00888141f, 0.04276289f, 0.68899941f, 0.17713711f, -0.16120405f, 0.17108937f, -0.01230259f, 
    -0.12238840f, 0.00104046f, 0.15049857f, -0.00232416f, 0.11045244f, -0.15372129f, -0.05395193f, -0.10794786f, 
    -0.01724681f, 0.15123832f, 0.04026715f, 0.08906002f, -0.12375180f, -0.08368303f, 0.00544501f, -0.06178713f, 
    -0.03805004f, -0.04987182f, 0.04945457f, -0.19286110f, 0.03057439f, -0.08542577f, 0.07951357f, -0.07082273f, 
    0.04183553f, -0.18867289f, -0.02085111f, 0.08678820f, -0.09941578f, 0.15741959f, 0.06615428f, 0.05902013f, 
    0.35137850f, 0.39055029f, -0.16644090f, 0.16393247f, -0.39366001f, -0.00711187f, 0.07269599f, 0.24018541f, 
    -0.37083226f, 0.20963629f, 0.22624932f, 0.03957760f, -0.21868739f, 0.05342135f, -0.00741402f, -0.00015101f, 
    0.01772393f, -0.28706551f, -0.41414011f, 0.53125638f, 0.14096826f, -0.17009076f, 0.15319525f, 0.07940833f, 
    0.03698576f, 0.19828206f, 0.35291961f, -0.28031209f, -0.02444997f, 0.15816554f, 0.06055398f, 0.40598190f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06838699f, 0.14185719f, 0.05031894f, 0.39203054f, 0.31379274f, -0.21729530f, -0.01162009f, 0.09075817f, 
    -0.05509139f, 0.14105698f, 0.26179314f, 0.10700506f, 0.20832856f, 0.20403479f, 0.06031337f, 0.15998329f, 
    -0.10064353f, 0.09162580f, 0.09659490f, -0.07011905f, 0.19438253f, 0.04678195f, 0.17566551f, -0.04956599f, 
    -0.15890358f, -0.03139177f, 0.17952089f, 0.09344203f, 0.05981157f, 0.03241695f, -0.11517670f, 0.30875969f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.09061909f, 0.22357757f, -0.04948374f, -0.58291233f, -0.06823388f, 0.46783757f, -0.06522365f, -0.17760392f, 
    0.01284932f, -0.75630111f, 0.07958639f, -0.53445959f, 0.10801082f, 0.05018042f, -0.79914504f, -0.58932769f, 
    -0.10602737f, 0.03118728f, -0.11432372f, -0.19135697f, -0.09604733f, -0.09747764f, -0.87441605f, 0.21262041f, 
    0.13564476f, 0.35586882f, -0.37439820f, -0.11228441f, 0.25858966f, -0.43801135f, 0.09464911f, 0.16182333f, 
    0.15414962f, -0.16389811f, 0.22469099f, -0.07692061f, 0.05930909f, -0.67334396f, -0.07364720f, 0.11506193f, 
    -0.16616502f, 0.29939803f, -0.31783602f, 0.29886755f, 0.04015734f, 0.23180963f, -0.68578243f, -0.13791269f, 
    0.01760124f, -0.15966806f, 0.45584780f, 0.11072212f, -0.19710365f, -0.33490291f, -0.47117677f, 0.17660689f, 
    -0.18364209f, -0.10027076f, -0.07408842f, 0.27906466f, 0.29755238f, 0.45878962f, -0.06664159f, 0.19977489f, 
    0.04588138f, 0.34451678f, -0.16399108f, -0.05090931f, 0.06249020f, -1.05154061f, 0.02635332f, 0.06135052f, 
    -0.07816773f, 0.10815783f, 0.05649319f, -0.79298002f, 0.02570014f, 0.08726935f, 0.38888624f, 0.10490356f, 
    -0.15719715f, -0.00507255f, -0.36479241f, -0.05083339f, 0.34314311f, -0.14705954f, 0.26168439f, -0.01375501f, 
    0.15301262f, -0.86659968f, 0.12034315f, -0.09008423f, -0.94132507f, -0.01865466f, 0.08561304f, -0.07735883f, 
    -0.23487753f, 0.21041998f, -0.11231211f, -0.31760550f, 0.28329867f, 0.40865010f, -0.15058365f, -0.17121659f, 
    -0.18268660f, 0.23502097f, 0.32153133f, -0.31543761f, -0.20044413f, -0.30640444f, -0.08365976f, 0.14564608f, 
    0.07353067f, 0.15704679f, -0.64248049f, 0.01660078f, 0.27087346f, -0.32290986f, -0.22146653f, 0.16156220f, 
    -0.14396578f, 0.11968385f, -0.45155957f, -0.93327814f, 0.01124743f, -0.83220661f, -0.08575922f, 0.07751645f, 
    0.10458089f, 0.24650884f, -0.34602505f, -0.18799293f, -0.27532515f, -0.39814720f, 0.05409586f, 0.08958121f, 
    -0.00266771f, -0.50050181f, -0.10641679f, 0.14532743f, 0.29847863f, -0.11233834f, -0.07711033f, -0.67292303f, 
    0.09756465f, 0.05719332f, 0.06861275f, 0.00883642f, -0.00797693f, -0.64654338f, 0.31790054f, -0.04244237f, 
    -0.13225372f, 0.24778941f, 0.13414638f, 0.04989457f, 0.09982844f, -0.11823453f, 0.00072126f, 0.08315077f, 
    0.46987936f, -0.27721211f, 0.01933711f, -0.18323524f, 0.20332125f, -0.43731332f, 0.01300381f, -0.06257846f, 
    -0.13995235f, -0.31657812f, -0.16841270f, -0.00898935f, -0.06109821f, -0.76055712f, -0.17922612f, 0.16069397f, 
    -0.13947578f, 0.16308205f, -0.61064994f, 0.05360149f, 0.13736129f, 0.32555419f, 0.03485192f, -0.08049938f, 
    -0.12420800f, 0.09473798f, -0.09070321f, 0.14900626f, 0.12848572f, 0.19639018f, 0.11778944f, 0.00269710f, 
    -0.30482283f, 0.01216650f, -0.42465809f, 0.30268738f, -0.76127106f, -0.69731706f, 0.07577141f, -0.07818169f, 
    0.06652146f, -0.33386716f, 0.24764802f, -0.16377121f, 0.01751515f, -0.17855237f, 0.31551063f, -0.09809981f, 
    0.11462634f, 0.08956084f, 0.21124838f, -0.02007415f, -0.45347103f, -0.16419485f, 0.56355214f, 0.02124671f, 
    0.01790435f, -0.82172155f, 0.45062774f, -0.19364278f, -1.45314038f, 0.22173959f, 0.13953517f, -1.65798986f, 
    -0.07599217f, 0.05220005f, 0.41079834f, -0.71369445f, -0.76201844f, 0.54994911f, -0.10075709f, -0.09714873f, 
    -0.04779000f, 0.04824012f, 0.21891873f, 0.37879673f, 0.18255633f, 0.06853034f, 0.00319091f, 0.17628908f, 
    0.08467139f, 0.10106609f, -0.21132670f, -0.00741763f, -0.44342265f, 0.11228140f, -0.48062223f, -0.18175912f, 
    -0.02318364f, -0.12222473f, -0.63203007f, 0.08941353f, -0.31296945f, -0.05628004f, 0.13165213f, -0.28309879f, 
    0.19941343f, -0.46112600f, 0.63796425f, 0.22290371f, 0.35705218f, -0.59128118f, -0.09969408f, -0.15333997f, 
    -0.10999303f, 0.39291146f, -0.01744483f, 0.03861795f, -0.67232406f, 0.01560244f, 0.06318729f, 0.25709793f, 
    -0.16984066f, 0.10836940f, -0.40316206f, -0.11703144f, -0.40765208f, 0.32327655f, -0.40901649f, -0.05447979f, 
    -0.10235024f, -0.52107704f, -0.18914452f, -0.12941675f, -0.27820665f, -0.15418884f, 0.04246275f, -0.12558062f, 
    -0.31279203f, 0.11482928f, -0.31507668f, 0.22959860f, -0.14141054f, -0.50574243f, 0.01121367f, 0.13881882f, 
    0.06817341f, -0.44046658f, 0.24071269f, 0.04265802f, 0.04263808f, 0.29728833f, -0.20381105f, 0.25454992f, 
    0.15722656f, 0.11569561f, 0.58256179f, -0.04522438f, 0.08323883f, -0.34240600f, 0.10797136f, -0.34188232f, 
    0.09766770f, -0.19955024f, 0.00004418f, -0.84526855f, 0.59854203f, -0.38605791f, 0.10923564f, -0.35577768f, 
    -0.21109852f, -0.05792252f, -0.48159671f, -0.14828351f, 0.09777045f, 0.01331819f, -0.16018701f, 0.05879857f, 
    -0.11016444f, 0.34831887f, -0.23565094f, -0.58457744f, -1.11954021f, 0.63878828f, 0.14217676f, -0.13658677f, 
    0.12487704f, 0.04516509f, 0.42336762f, -0.11865951f, -0.39374942f, 0.12299449f, 0.15691356f, -0.52841741f, 
    0.11341209f, 0.26209366f, -0.33431765f, 0.27843478f, -0.71682948f, 0.30920604f, 0.13399608f, 0.11763632f, 
    -0.49980623f, -0.19096075f, -0.01069840f, 0.20164064f, -0.05766220f, -0.68067127f, 0.01522837f, -0.15782578f, 
    0.05444224f, -0.73286116f, -0.03682673f, -0.06249981f, 0.17041147f, -0.17405547f, 0.33318460f, -0.01312521f, 
    -0.04635043f, -0.08950209f, -0.06193491f, -0.07875671f, -0.36146149f, 0.48070425f, -0.27418637f, -0.19618320f, 
    0.04954021f, -0.02949638f, 0.46085566f, 0.23375808f, -0.17664602f, -0.50380915f, -0.16999705f, 0.05621169f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.02373230f, 0.01359507f, 0.22673775f, -0.04649205f, 0.01159247f, -0.18216971f, -0.15368035f, -0.14906423f, 
    -0.08291177f, 0.25928009f, -0.09071219f, -0.00507106f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
