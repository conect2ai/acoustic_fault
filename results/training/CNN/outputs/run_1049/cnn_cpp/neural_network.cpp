#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.06596263f, 0.56471014f, 0.01659981f, -0.26896742f, -0.11836658f, 0.30466580f, -0.32434198f, 0.08225182f, 
    0.38647965f, -0.61226904f, 0.01518471f, 0.38592622f, 0.59288216f, -0.82293820f, 0.32630554f, 0.05695741f, 
    -0.29480073f, -0.36601889f, -0.53689623f, -0.48179564f, -0.31164959f, 0.15768404f, -0.13480219f, -0.14949171f, 
    0.42547292f, 0.06965217f, 0.38618973f, 0.07056189f, 0.07381417f, -0.19542615f, 0.67286187f, -0.20690358f, 
    -0.56751525f, 0.29785702f, -0.26264709f, 0.15316038f, 0.46954608f, -0.63754618f, -0.36453006f, -0.47930250f, 
    -0.73280835f, -0.79130113f, 0.16977608f, 0.34156004f, 0.13829729f, 0.70343447f, 0.10418162f, 0.22696786f, 
    -0.09362638f, -0.57455099f, -0.21564583f, 0.05807887f, -0.18573920f, 0.29917499f, 0.14561242f, 0.18812108f, 
    0.23217623f, -0.36393988f, -0.04495839f, -0.25501040f, -0.30275950f, -0.27783626f, -0.15000492f, -0.26514596f, 
    -0.22015473f, -0.33668488f, -0.48437139f, -0.65470260f, -0.70355940f, -0.30592713f, -0.47749093f, -0.48502472f, 
    0.35407415f, -0.79040891f, -0.34018311f, 0.15332548f, 0.08337680f, -0.28732768f, 0.12657386f, 0.13678659f, 
    -0.21994691f, -0.80121034f, -0.50677574f, -0.54718792f, 0.52658039f, 0.33737987f, 0.41361496f, 0.21731082f, 
    -0.17949684f, 0.09503029f, -0.10502030f, 0.07711947f, 0.42970705f, 0.19987027f, -0.29181725f, -0.48995697f, 
    0.27896240f, 0.02649649f, 0.29161072f, 0.10874945f, 0.18830605f, -0.46263245f, -0.18136784f, 0.13547470f, 
    0.11997303f, 0.03522396f, 0.35759777f, 0.06759204f, 0.16436930f, 0.32452855f, 0.16429532f, -0.17588788f, 
    0.46998659f, -0.48258767f, 0.15646073f, 0.05705439f, -0.21711943f, -0.24959886f, 0.06962974f, 0.17921537f, 
    -0.10988641f, -0.25736406f, 0.40902272f, -0.40785325f, 0.23065540f, 0.25180203f, -0.23367950f, 0.52087957f, 
    0.20120437f, -0.28562742f, -0.00824780f, 0.09611128f, -0.41882157f, 0.33982348f, 0.12057368f, 0.84898716f, 
    0.30410454f, -0.61976922f, -0.12069561f, 0.15460338f, -0.06365798f, -0.27428883f, 0.11476231f, 0.06355131f, 
    -0.64320743f, -0.05315766f, -0.70733333f, -0.05235005f, 0.32271239f, 0.58075041f, -0.05265607f, 0.38851112f, 
    -0.17690453f, -0.59204727f, -0.24516653f, -0.42373407f, 0.13755210f, 0.11576405f, -0.42325976f, 0.36919162f, 
    0.42506254f, 0.27842385f, -0.36490765f, -0.15281872f, -0.36827463f, 0.34192896f, -0.15440984f, -0.23808326f, 
    0.46945271f, -0.07775989f, 0.45638245f, -0.65018970f, -0.41666391f, -0.32764244f, -0.68937254f, -0.62248075f, 
    -0.60710478f, 0.41578579f, -0.27387369f, 0.27640414f, -0.02667594f, 0.74307019f, -0.30403659f, 0.13495725f, 
    -0.03398858f, -0.45464396f, 0.15761763f, -0.25223741f, 0.44859961f, -0.09433243f, -0.33662221f, -0.58463830f, 
    -0.61325669f, -0.16328831f, -0.49828339f, 0.01306580f, -0.14892457f, -0.40637434f, -1.06549847f, -0.77032340f, 
    0.80528426f, -0.13790928f, 0.69189346f, -0.66685992f, 0.03332079f, 0.50173974f, -0.44383252f, 0.16485149f, 
    0.31773585f, 0.16693296f, 0.33467317f, 0.17046396f, 0.16038597f, 0.25616324f, 0.08684593f, -0.26126888f, 
    0.88681316f, -0.54754680f, -0.51611245f, 0.21197712f, 0.33419409f, -0.45703897f, -0.23367782f, 0.50759691f, 
    -0.07327019f, 0.65240371f, -0.63236046f, -0.21563196f, 0.73952365f, 0.45001069f, -0.29776368f, -0.04276391f, 
    -0.34331483f, -0.12362070f, 0.70473343f, 0.59822863f, -0.45723799f, 0.12282377f, -0.43714765f, 0.14267208f, 
    -0.17024359f, -0.10736027f, -0.35279056f, 0.24650538f, -0.24038132f, 0.13627560f, 0.25993326f, -0.40967742f, 
    0.46570522f, -0.03485049f, 0.43011385f, -0.50961769f, -0.61363846f, 0.55313081f, 0.21644731f, -0.84474027f, 
    0.59646559f, -0.21097347f, 0.43285340f, 0.22852111f, -0.32923502f, 0.84460670f, -0.85816479f, 0.03282207f, 
    0.62242162f, -0.26898474f, -0.10227741f, -0.10688497f, -0.05647537f, -0.03732690f, -0.78909111f, -0.65171033f, 
    -0.36398250f, 0.19727133f, 0.05789507f, -0.35880533f, -0.03457284f, -0.38277313f, 0.29136947f, -0.18017825f, 
    0.63969177f, 0.75082600f, -0.90149248f, -0.55665594f, -0.58937430f, 0.03969663f, -0.34119257f, -0.24681394f, 
    -0.21551883f, -0.98734915f, -0.17128693f, 0.40532655f, 0.49867359f, 0.14716583f, 0.03024746f, -0.24024627f, 
    0.24131705f, -0.41876081f, -0.25933474f, -0.36856905f, -0.30788907f, -0.25176686f, -0.68910742f, -0.14532155f, 
    -0.45213521f, -0.53060251f, 0.29483306f, 0.32219177f, 0.31885868f, -0.33561909f, -0.39497006f, -0.37172404f, 
    0.16517928f, 0.37928021f, 0.37837967f, -1.24210620f, 1.07471108f, -0.09347195f, -0.33866459f, 0.09027430f, 
    0.53362960f, -0.22154276f, -0.09991833f, 0.12024784f, 0.89839226f, -0.61841506f, -0.76386261f, 0.65971529f, 
    0.25242880f, 0.06205678f, -0.60485810f, -0.24421866f, 0.37450871f, 0.36868447f, 0.15385677f, 0.24369110f, 
    -0.12382136f, -0.19717319f, -0.02228379f, 0.20736223f, 0.11649517f, -0.26334110f, -0.53405827f, -0.30288392f, 
    -0.21001506f, -0.21397832f, 0.42262506f, 0.54942620f, -0.47157982f, -0.47923696f, -0.44371575f, -0.22305265f, 
    -0.97913408f, -0.32832181f, 0.08504545f, 0.30526513f, 0.58159429f, 0.15065409f, 0.06360552f, -0.41313815f, 
    0.34787619f, -0.16711400f, 0.39108503f, 0.55906337f, -0.53228283f, -0.50250828f, -0.26024604f, 0.04366298f, 
    0.28624144f, -0.63212651f, 0.11675191f, 0.55607730f, 0.43876955f, 0.05954944f, -0.23513502f, 0.19460575f, 
    -0.53548956f, -0.03016234f, -0.54978985f, -0.80632788f, 0.39716831f, 0.14354220f, 0.68757254f, -0.85163820f, 
    -0.09536278f, -0.23859085f, 0.33015367f, 0.13218461f, -0.83795357f, 0.27063942f, -0.83351088f, -0.21091102f, 
    0.58581978f, -0.58264387f, -0.00279822f, 0.06519853f, -0.50324547f, -0.67307866f, 0.21162161f, -0.43567100f, 
    -0.92291099f, 1.04893804f, -0.02979773f, -0.03003077f, 0.03691165f, -0.14829376f, 0.35042489f, 0.38060871f, 
    -0.61315310f, 0.02160830f, 0.44356933f, 0.03576410f, 0.06563653f, -0.09339786f, 0.50979269f, -0.09372360f, 
    -0.46910802f, 0.19282946f, 0.05837228f, -0.24478133f, 0.06666163f, -0.09346529f, 0.40444508f, -0.00240079f, 
    -0.15279879f, 0.33519870f, 0.05564258f, -0.48927519f, 0.25562754f, 0.63061231f, -0.34508651f, -0.34399548f, 
    -1.01485980f, 0.09985346f, 0.78063917f, -0.57621044f, 0.49470070f, 0.20424697f, -0.04695401f, -0.25566909f, 
    0.33689445f, -0.71129608f, -0.16866566f, 0.24720541f, 0.19567674f, 0.46573493f, 0.32938194f, -0.05285727f, 
    -0.23551254f, -0.32346684f, 0.51186687f, -0.26487616f, -0.14625132f, 0.31953290f, 0.01150955f, -0.38524556f, 
    0.40614679f, -0.42979211f, 0.16793877f, 0.39702174f, 0.35638043f, -0.43443218f, -0.01441339f, 0.56294769f, 
    0.25511724f, -0.15632315f, -0.30736876f, -0.42047471f, -0.08877089f, 0.54976249f, -0.23610480f, -0.29294172f, 
    0.21574940f, 0.14597003f, -0.10898695f, 0.45936778f, -0.07563954f, 0.37372130f, 0.03962157f, -0.56972170f, 
    -0.25651515f, 0.28226084f, -0.31592321f, 0.46067742f, -0.13989370f, 0.18402821f, 0.40206632f, 0.09258442f, 
    -0.50827312f, -0.03645936f, 0.06266775f, -0.29416129f, 0.00555312f, 0.27257636f, 0.21784002f, 0.34942007f, 
    -0.34467477f, -0.39813998f, -0.67198205f, -0.46156994f, -0.58694738f, -0.13746139f, -0.31213427f, 0.11479146f, 
    0.52190405f, -0.26090714f, 0.62587130f, -0.50425571f, -0.39636463f, 0.12547615f, 0.11905400f, -0.11833188f, 
    0.04140487f, -0.67620528f, 0.63645858f, 0.58173096f, -0.41373646f, -0.40959507f, -0.28539142f, -0.38088942f, 
    -0.37397167f, -0.49254331f, 0.13785869f, 0.30914903f, -0.23714054f, -0.67153591f, -0.43259954f, 0.41114688f, 
    0.10023061f, -0.05618586f, 0.40280318f, -0.87113333f, -0.54282546f, -0.51571584f, -0.00892721f, 0.14351587f, 
    0.05454513f, 0.10622804f, -0.51473367f, -0.48214060f, 0.35928282f, 0.62914747f, -0.41470510f, -0.44914204f, 
    -0.66364694f, 0.27463743f, 0.30043492f, -0.33079088f, -0.54390579f, -0.80621487f, -0.67129248f, 0.84550434f, 
    0.85924608f, -0.03361380f, -0.42469323f, -0.05683125f, -0.23709023f, -0.20322521f, -1.04270053f, 0.89638734f, 
    -0.13242468f, 0.56527817f, -0.23101498f, -0.11173259f, -0.26890895f, 0.32691443f, -0.09060110f, 0.31568488f, 
    -0.38610905f, 0.25761819f, 0.46595317f, -0.31705743f, 0.40415651f, 0.07036904f, -0.20518729f, 0.08559416f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.12544388f, -0.19437140f, 0.25127193f, 0.11714757f, 0.23691554f, 0.02097907f, -0.01801235f, -0.26784399f, 
    0.28352061f, 0.03601033f, -0.04516573f, -0.10435379f, 0.14319609f, 0.13410641f, 0.30735299f, 0.16194463f, 
    0.10108532f, 0.13056418f, -0.05231977f, -0.18780239f, -0.08413309f, -0.25263634f, -0.18359022f, -0.20239554f, 
    0.14237504f, 0.13048169f, 0.14877902f, 0.06504239f, 0.03844192f, 0.13358118f, -0.27930832f, -0.05264093f, 
    0.06043346f, -0.15285364f, -0.11608875f, 0.17784901f, 0.05603743f, 0.13656941f, -0.18637761f, 0.06868567f, 
    -0.00973814f, 0.09953264f, -0.05813702f, 0.18123718f, 0.18597013f, 0.33848009f, -0.06892349f, -0.04746303f, 
    0.03699432f, 0.07846438f, 0.06030651f, 0.16819425f, 0.07579994f, 0.05004192f, 0.11436401f, 0.26613238f, 
    0.17977956f, -0.15027857f, 0.17468360f, -0.06969569f, -0.16478077f, -0.04172567f, 0.00327936f, -0.19252856f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.06533886f, -0.07935145f, 0.05518980f, 0.06498114f, -0.00620412f, 0.05419577f, -0.06029747f, -0.00610333f, 
    0.02918774f, 0.02870076f, 0.03182050f, 0.06231750f, -0.01523632f, 0.05105759f, -0.00203922f, -0.11800514f, 
    -0.17465244f, -0.02757814f, -0.01440665f, -0.06026701f, 0.10225418f, 0.33137536f, 0.52645051f, -0.38919494f, 
    0.06250853f, -0.10583418f, -0.02572142f, 0.05385072f, 0.09451719f, 0.01118707f, 0.09233622f, 0.07784825f, 
    -0.03688510f, -0.07534365f, 0.00413054f, 0.00102045f, -0.10518672f, -0.00479759f, -0.02693661f, 0.26062956f, 
    0.26836783f, 0.22627607f, 0.02215493f, -0.11596719f, -0.01593486f, 0.08398980f, 0.09205107f, 0.07538085f, 
    -0.09297588f, -0.11904623f, -0.00948445f, -0.13560387f, -0.05315375f, -0.03056626f, 0.01003753f, -0.02342141f, 
    -0.05459279f, -0.00303463f, 0.02649124f, 0.00200127f, 0.06229918f, 0.02472842f, -0.37881920f, 0.00565006f, 
    -0.01836496f, -0.14593436f, 0.02020246f, 0.01834141f, -0.05035901f, -0.12035596f, -0.10074744f, -0.13812205f, 
    -0.01946625f, 0.03688379f, -0.03523092f, -0.00376984f, -0.09879868f, -0.04263063f, -0.05537276f, -0.09353598f, 
    0.29245290f, 0.22343896f, -0.15336284f, -0.24853069f, -0.11319467f, 0.01765880f, -0.06953760f, -0.07508985f, 
    -0.05291864f, -0.02155310f, 0.03126737f, -0.00717683f, 0.04324329f, 0.03760396f, 0.01583028f, -0.02168750f, 
    -0.04262982f, 0.00110843f, 0.06090729f, 0.07350006f, 0.02876853f, -0.00118190f, -0.00913941f, -0.12227715f, 
    -0.09575258f, -0.02592951f, 0.01641909f, -0.16421796f, -0.14462121f, -0.14337416f, 0.02813856f, 0.02011516f, 
    0.00815414f, 0.02543902f, -0.00240677f, -0.02917804f, 0.06694146f, -0.07555751f, -0.04256723f, -0.06931903f, 
    -0.13509741f, 0.16007915f, 0.15211673f, -0.03465700f, -0.05426234f, 0.01701304f, -0.06125785f, -0.07487953f, 
    0.02874820f, 0.01944087f, 0.03757929f, -0.03693113f, -0.02077742f, 0.03565196f, 0.03205113f, 0.08226365f, 
    -0.03976407f, -0.00243776f, 0.02973041f, 0.02703234f, 0.21010669f, 0.23218706f, 0.14697783f, -0.27242565f, 
    -0.01680693f, 0.08499159f, 0.11623958f, 0.09255198f, 0.01284378f, 0.08111363f, 0.00595424f, -0.02510191f, 
    0.01402526f, -0.05401604f, -0.10934968f, -0.05030375f, -0.14697632f, 0.02658705f, 0.05362670f, 0.04981978f, 
    0.16396096f, 0.05918066f, -0.18979789f, -0.06481852f, -0.08604248f, 0.10797500f, -0.04520869f, 0.12197757f, 
    -0.15077178f, 0.02395157f, -0.01009223f, -0.00560678f, -0.02948635f, 0.02942219f, -0.01370034f, 0.01517350f, 
    -0.05770313f, -0.05422895f, -0.07912312f, 0.06065457f, 0.18790360f, -0.18942909f, -0.17962290f, -0.00937973f, 
    0.09038383f, 0.12370511f, 0.13543765f, 0.13881804f, -0.00057089f, -0.00629746f, -0.04794995f, -0.00992516f, 
    -0.01919058f, 0.00063114f, 0.07209428f, 0.03979669f, 0.08850648f, 0.07235339f, -0.01129655f, 0.00673136f, 
    0.04234839f, -0.00400934f, -0.03713004f, -0.04855989f, -0.00565300f, -0.07984700f, 0.00371615f, 0.02932452f, 
    0.01402973f, 0.04200668f, 0.02870223f, -0.02610693f, 0.01310300f, -0.04568154f, -0.07030924f, -0.01508887f, 
    -0.02523348f, -0.13749082f, -0.01588255f, -0.05566736f, 0.05803015f, 0.03262315f, 0.00548416f, 0.01881420f, 
    0.00275781f, -0.00974656f, -0.01466843f, 0.02567542f, 0.04438151f, 0.01792916f, -0.02773406f, 0.00111691f, 
    0.01274504f, 0.00143318f, 0.02376821f, -0.03869613f, 0.01180311f, -0.00219520f, 0.01131112f, -0.01399116f, 
    -0.25321952f, -0.26913121f, -0.06910017f, 0.08261526f, -0.04255560f, 0.01445285f, 0.01516606f, -0.02398887f, 
    -0.02023618f, 0.06822810f, -0.06566835f, 0.00245015f, 0.03471777f, 0.04406681f, -0.03567393f, -0.00081853f, 
    -0.06047380f, -0.05518125f, -0.11520942f, 0.04972964f, -0.14745305f, -0.16258843f, 0.11851195f, -0.00487396f, 
    -0.01215820f, -0.08846884f, -0.03438835f, 0.01653110f, 0.01394076f, 0.03620461f, -0.00334042f, -0.10522223f, 
    0.07998687f, -0.04285553f, -0.08788990f, -0.09165261f, -0.10806189f, -0.09777918f, 0.01858855f, -0.01980411f, 
    -0.35317612f, -0.28186774f, 0.08379331f, 0.06806010f, -0.20038420f, 0.03053592f, -0.06277294f, -0.06978047f, 
    0.02125602f, -0.05227021f, -0.03591587f, 0.05810027f, -0.01402502f, -0.02748513f, -0.00817497f, -0.14060050f, 
    -0.00410787f, -0.03470426f, -0.04100666f, -0.00206936f, -0.64562571f, -0.21269646f, -0.14673875f, 0.08415475f, 
    -0.27534565f, 0.05379261f, 0.01902837f, -0.01462866f, 0.00788391f, 0.01945981f, 0.03516812f, -0.00423377f, 
    -0.06207330f, -0.00848131f, 0.03793013f, -0.07924487f, 0.08186941f, -0.07061289f, 0.00525847f, -0.03295090f, 
    0.20525235f, -0.01737767f, -0.07332329f, -0.00584256f, 0.00310732f, 0.17670517f, 0.14183086f, 0.07177566f, 
    -0.07558781f, -0.06871210f, -0.02572547f, 0.02607323f, 0.00609027f, 0.07686465f, 0.06311385f, 0.05497088f, 
    0.03364586f, -0.03714164f, 0.00027683f, -0.01524252f, 0.21420734f, 0.20605148f, -0.02109265f, -0.05000643f, 
    0.01089740f, 0.04716781f, 0.04446397f, 0.06805596f, -0.07222399f, -0.10754082f, 0.01234700f, -0.13412145f, 
    -0.02774459f, 0.03086046f, 0.03583403f, -0.04192672f, -0.02032745f, -0.01541075f, 0.00492296f, 0.01014353f, 
    0.16114840f, 0.15708280f, -0.04631048f, -0.02293012f, 0.03993588f, 0.06050479f, 0.06582117f, 0.03205524f, 
    0.00860707f, -0.10581872f, 0.03222700f, -0.14628854f, -0.07668544f, -0.01573049f, 0.01511094f, -0.06016543f, 
    -0.05141356f, 0.01742579f, 0.05545743f, -0.03300278f, 0.27339870f, 0.24231951f, 0.11183693f, -0.33336926f, 
    -0.03787018f, 0.12211221f, 0.14839515f, 0.08286141f, 0.01955258f, 0.06709875f, 0.01684126f, -0.02406373f, 
    -0.00761545f, -0.00841598f, 0.02533968f, -0.00296694f, -0.05682945f, -0.01088368f, 0.03977032f, -0.04173362f, 
    -0.05039648f, -0.03090210f, -0.14100303f, 0.06156231f, -0.02409081f, 0.02896169f, -0.09670538f, -0.08363484f, 
    0.04931363f, 0.05154632f, -0.00626838f, 0.03125720f, -0.04772152f, 0.09725107f, -0.03684533f, -0.04384244f, 
    -0.01665283f, -0.09679568f, -0.01021852f, -0.11817518f, 0.27078900f, 0.17546427f, 0.05520775f, -0.21123357f, 
    -0.10524325f, 0.16721280f, 0.07542794f, 0.15384276f, -0.03073271f, 0.10166521f, -0.00253700f, -0.01008727f, 
    -0.03145380f, -0.00724627f, -0.00280855f, -0.05609827f, -0.04387803f, -0.09351487f, 0.05689405f, 0.06932659f, 
    0.39268100f, 0.16866973f, 0.12341537f, -0.36543974f, -0.03528564f, -0.04994007f, -0.09146191f, 0.17544295f, 
    0.05379964f, 0.12325064f, 0.02161970f, -0.02669503f, -0.15906549f, 0.06977924f, -0.11657912f, 0.06956889f, 
    0.04668055f, -0.03976470f, 0.02847834f, 0.08215102f, -0.08720315f, -0.05384729f, -0.04382798f, 0.04191538f, 
    -0.00371934f, 0.03632013f, 0.06625167f, 0.04865950f, 0.01342189f, 0.02579805f, -0.05637597f, 0.02767856f, 
    0.03461638f, 0.04722942f, -0.00650187f, -0.01583023f, -0.03971006f, 0.02686789f, 0.01707208f, 0.00370229f, 
    -0.00638122f, 0.07861953f, -0.31410637f, 0.06417339f, -0.02371971f, -0.00730143f, -0.00623316f, -0.01300148f, 
    -0.11112184f, -0.02133567f, -0.06592230f, -0.11809769f, 0.00812505f, -0.05406347f, -0.00452683f, -0.07418575f, 
    -0.02265130f, -0.04503667f, -0.06756839f, 0.10162415f, 0.25374562f, -0.40901384f, -0.34224397f, 0.00345630f, 
    -0.12734020f, -0.01125769f, -0.01905174f, 0.03401740f, 0.03004000f, 0.03432458f, 0.02820269f, 0.05851096f, 
    -0.10167380f, -0.02440229f, 0.02160828f, -0.07035190f, 0.08361579f, 0.04018569f, -0.13468736f, 0.01303472f, 
    -0.31696510f, 0.13194321f, -0.30996236f, 0.39620242f, -0.18469560f, 0.02853158f, -0.03582104f, -0.00104150f, 
    0.00018032f, 0.05153652f, -0.03693586f, -0.00084293f, -0.03668967f, 0.01212747f, 0.00049292f, 0.00220102f, 
    -0.00439046f, 0.02304866f, 0.00227992f, -0.09076743f, -0.16112560f, -0.17219399f, 0.02161544f, -0.08693299f, 
    0.06659239f, -0.01305858f, 0.00265264f, 0.02798045f, -0.02030930f, 0.01166875f, -0.13794373f, 0.09107070f, 
    -0.10907333f, -0.08475512f, -0.06028897f, -0.05927257f, -0.16080159f, 0.03479093f, -0.06091086f, 0.03275429f, 
    -0.03348416f, 0.12667476f, 0.32021043f, 0.02040696f, -0.12273698f, -0.26233450f, 0.08957247f, 0.01154630f, 
    0.04389761f, -0.03564432f, -0.01827568f, 0.08906621f, -0.02127627f, -0.01598742f, -0.04409828f, -0.00469757f, 
    0.02112351f, -0.10067482f, -0.13529667f, -0.01229546f, -0.09989293f, -0.46598777f, -0.56274575f, -0.08966522f, 
    -0.01455633f, -0.03418645f, -0.04632741f, 0.09982174f, -0.04358155f, 0.03557384f, -0.00880314f, 0.05586458f, 
    0.07392237f, -0.01162387f, -0.03189272f, -0.22810331f, 0.19682640f, -0.01685337f, -0.16339354f, -0.00807942f, 
    0.33293515f, 0.23043026f, -0.04122688f, -0.26443842f, -0.05244069f, 0.11528840f, 0.14585492f, 0.16648373f, 
    -0.00114602f, 0.03673093f, 0.03025501f, 0.02657639f, 0.01057547f, 0.04379939f, 0.05312937f, 0.03826029f, 
    -0.02066937f, -0.04501227f, 0.01143087f, -0.09048191f, -0.09699202f, 0.20344830f, 0.18851687f, -0.27375230f, 
    0.06959151f, 0.00230266f, 0.16597761f, -0.16467677f, -0.09910974f, -0.01504213f, 0.01589623f, -0.03769407f, 
    0.01430947f, 0.05639877f, -0.00231806f, -0.05630238f, 0.08215541f, 0.00923583f, -0.04374823f, 0.05577685f, 
    0.13817003f, -0.01685886f, -0.30620050f, -0.01606359f, 0.03444178f, 0.10849549f, 0.07924875f, 0.11968987f, 
    -0.04661402f, 0.02955279f, 0.00677187f, 0.04236627f, -0.06158983f, 0.05078751f, -0.00951924f, 0.02281013f, 
    0.07345194f, 0.06155286f, 0.00197713f, -0.00797772f, 0.24737173f, 0.18549758f, 0.05929352f, -0.21385795f, 
    -0.03871223f, 0.07574601f, 0.14837909f, 0.09224752f, 0.02351236f, 0.06561790f, -0.00618907f, -0.03095105f, 
    -0.01763546f, -0.07472487f, -0.09650559f, -0.01342937f, -0.17620921f, -0.03161445f, -0.02612226f, 0.06303372f, 
    0.07131135f, 0.01640885f, -0.05833569f, -0.03411685f, -0.01511696f, -0.18672600f, -0.06805249f, -0.12929030f, 
    0.02534492f, 0.00438314f, 0.07321670f, 0.03661622f, 0.00343003f, 0.00152757f, -0.03153665f, 0.02221809f, 
    0.02150563f, 0.00531124f, -0.05166508f, -0.09559194f, -0.74528688f, -0.00926501f, 0.32998374f, 0.01871853f, 
    0.05686609f, -0.13107240f, -0.13387668f, -0.04785769f, 0.05406937f, -0.14483598f, -0.06603352f, 0.02022012f, 
    0.04130601f, -0.04824264f, 0.00257867f, -0.10157153f, -0.03983989f, -0.00420661f, -0.21565546f, -0.12830020f, 
    0.00886146f, -0.03538641f, -0.04203008f, 0.10084760f, -0.03088753f, 0.02986678f, 0.01600820f, -0.02982341f, 
    -0.09038438f, -0.04632108f, -0.00039684f, 0.00024326f, -0.01123281f, 0.02947896f, -0.02069867f, 0.00431764f, 
    0.11028466f, -0.12586328f, -0.01407515f, -0.06848405f, -0.14615189f, -0.10061958f, -0.07186711f, 0.00052401f, 
    0.02762291f, 0.02669975f, 0.00089967f, -0.03640294f, -0.04933883f, 0.00381170f, -0.01543512f, 0.05041218f, 
    0.02085984f, 0.02501819f, 0.02660603f, 0.04660341f, -0.05573480f, -0.05530682f, -0.06256782f, 0.01756193f, 
    0.17009126f, 0.00754820f, 0.13099863f, -0.04178593f, -0.00857888f, -0.03876167f, 0.06924392f, 0.14029863f, 
    0.02886077f, -0.04120869f, 0.03835595f, 0.02974464f, 0.04858178f, 0.08509423f, -0.07939100f, -0.07800318f, 
    0.03750119f, -0.07299119f, 0.00386919f, -0.06363052f, 0.25496581f, -0.05987561f, -0.13928095f, -0.05458593f, 
    0.03559938f, 0.16934276f, 0.02529612f, 0.13597704f, -0.04417720f, 0.11160713f, -0.02067616f, -0.01548760f, 
    -0.11618909f, 0.04148843f, -0.00698861f, 0.08240839f, 0.06639891f, 0.03353367f, 0.00191368f, -0.01225146f, 
    0.04945947f, 0.01083306f, -0.36306193f, 0.01367735f, 0.00872315f, 0.01025496f, -0.08505865f, -0.15891305f, 
    -0.05669570f, -0.02394465f, 0.04923944f, -0.02576355f, 0.02173425f, 0.03487056f, 0.00883425f, -0.06386932f, 
    0.08909499f, -0.21605571f, -0.01731955f, -0.05029127f, 0.01714313f, -0.06932311f, -0.40144476f, -0.40590549f, 
    -0.06851416f, -0.02440169f, -0.01032248f, 0.00246792f, 0.08300504f, 0.03024514f, 0.00778489f, 0.01427199f, 
    -0.08126898f, -0.01987252f, -0.02004947f, -0.02827565f, -0.11815786f, 0.07623107f, 0.09146421f, 0.11637256f, 
    0.45183203f, 0.22034645f, -0.11553375f, -0.33946371f, -0.10936376f, -0.05450669f, -0.08270465f, 0.15476817f, 
    -0.11036211f, 0.07531607f, 0.01957073f, -0.06148328f, -0.01328408f, 0.02433907f, -0.00067528f, 0.03992217f, 
    0.02308194f, 0.00361424f, 0.00889101f, -0.07982613f, 0.07729032f, 0.09672014f, 0.10042410f, -0.11533871f, 
    -0.07929297f, -0.04068120f, 0.03772397f, 0.10437313f, -0.11722758f, -0.12710796f, -0.04962587f, 0.00471067f, 
    -0.00360684f, -0.04299261f, -0.21599619f, 0.02300077f, -0.05186233f, -0.06608303f, 0.11946089f, -0.29339245f, 
    0.22876114f, 0.17079291f, 0.23856910f, -0.36031240f, -0.04962076f, -0.06483798f, 0.12210478f, 0.11928114f, 
    -0.15036523f, -0.17827512f, -0.03148557f, -0.02655753f, 0.01976591f, -0.00943147f, 0.02150586f, 0.04227918f, 
    -0.08695353f, -0.03238246f, -0.03986697f, -0.18162097f, -0.42439753f, -0.23297030f, 0.16879112f, 0.06453786f, 
    -0.14942698f, -0.03130746f, 0.00295125f, -0.03856043f, -0.02014842f, -0.04927287f, -0.03445486f, -0.00305428f, 
    -0.05730277f, 0.04872312f, 0.00868589f, -0.00575533f, 0.02340408f, -0.01220117f, -0.08793778f, -0.03829073f, 
    0.02786720f, 0.01203339f, -0.04555514f, 0.06182605f, 0.04106538f, 0.03924784f, -0.01306013f, 0.02837433f, 
    0.05775550f, -0.00849583f, 0.02642985f, -0.05855566f, -0.19123058f, 0.02033046f, 0.03424478f, -0.01704377f, 
    -0.02325838f, -0.07882245f, 0.02646223f, -0.06239353f, -0.12189903f, 0.06749518f, 0.13800876f, -0.17218676f, 
    0.07412984f, 0.03207968f, -0.06183377f, -0.07889448f, 0.02114349f, -0.04734381f, 0.02013834f, -0.01637503f, 
    -0.02207257f, -0.01024800f, 0.07695635f, -0.01696038f, -0.09665830f, -0.04948734f, -0.15464532f, 0.01841037f, 
    -0.26405844f, -0.21479036f, 0.29559937f, -0.01286052f, 0.11625069f, -0.04988932f, -0.12294375f, 0.10591806f, 
    0.07314316f, -0.09893594f, -0.11069345f, -0.02756770f, -0.07114571f, -0.03629782f, -0.16908470f, -0.07037390f, 
    -0.11107795f, 0.01657666f, -0.01696191f, -0.01114295f, 0.09386414f, -0.26461676f, -0.06527427f, -0.05850928f, 
    -0.04101874f, 0.00134963f, 0.02660882f, 0.05636042f, 0.10957317f, -0.01679396f, 0.01194024f, 0.05005460f, 
    -0.00002092f, -0.03655111f, -0.01750244f, 0.03442859f, 0.01059836f, 0.06089254f, 0.02839888f, 0.01049580f, 
    -0.07092741f, -0.09943458f, -0.21048516f, 0.01308721f, 0.01284237f, -0.14134029f, -0.07368067f, -0.03425410f, 
    0.03325910f, 0.01461593f, -0.09808905f, 0.04498168f, -0.01242857f, -0.03438642f, -0.06414828f, -0.10745455f, 
    -0.07641950f, -0.09834970f, -0.10731919f, -0.02269532f, -0.17044297f, -0.29328576f, -0.24564999f, 0.12314422f, 
    -0.28836325f, 0.03718422f, 0.00983914f, 0.00702664f, 0.03034900f, 0.06349425f, 0.08414610f, 0.00456409f, 
    -0.05035494f, -0.03737738f, -0.03359656f, -0.11320934f, -0.07127987f, 0.06068845f, -0.05771200f, 0.07871842f, 
    -0.07200300f, -0.05522712f, 0.02945580f, 0.07615034f, -0.02841555f, -0.02122390f, -0.00363553f, -0.01171625f, 
    0.03766516f, 0.06812309f, -0.03726078f, -0.02638536f, -0.15891224f, -0.08982252f, -0.01801436f, -0.03929684f, 
    -0.03799087f, -0.01449955f, -0.05909151f, 0.00617743f, 0.12720455f, 0.19681662f, -0.09843664f, -0.04453471f, 
    -0.06291784f, -0.04509681f, -0.00935946f, -0.05102414f, -0.10090286f, 0.02691199f, -0.03934652f, 0.11048219f, 
    -0.15833294f, -0.04020662f, 0.02362734f, -0.07998652f, -0.07553172f, -0.07375141f, -0.02175900f, -0.03489891f, 
    0.05661327f, 0.01465086f, -0.10518364f, 0.03076564f, -0.04180408f, 0.00207433f, 0.00641513f, 0.00172704f, 
    -0.03204109f, -0.01229746f, -0.03711329f, 0.00106357f, -0.05443548f, -0.02825176f, 0.03339288f, -0.02811569f, 
    -0.04257693f, -0.05143576f, -0.03530765f, -0.07347320f, 0.09794414f, 0.14727476f, 0.04236051f, -0.22649446f, 
    -0.11006059f, 0.03935740f, 0.02230867f, -0.03129542f, -0.07234541f, -0.01471834f, -0.03572698f, -0.03613293f, 
    -0.00830815f, 0.00172181f, -0.03754407f, -0.02479100f, -0.03346741f, -0.01620298f, 0.05782698f, 0.00711780f, 
    -0.47245884f, 0.15572329f, 0.31829774f, -0.56276286f, 0.11709697f, -0.06499594f, -0.01662052f, -0.07630243f, 
    -0.09221068f, -0.03477136f, 0.05564709f, -0.00029448f, 0.00880614f, -0.00700706f, 0.03615424f, 0.00881028f, 
    0.07878345f, 0.02272165f, -0.01460769f, -0.05197576f, -0.02360699f, 0.23318708f, 0.16939376f, -0.12079261f, 
    0.05585396f, -0.20264901f, -0.20650741f, -0.11013648f, -0.04707359f, -0.02322150f, 0.03190516f, -0.03812554f, 
    -0.01682471f, -0.00024641f, 0.03034006f, 0.00509715f, -0.00047441f, -0.04951854f, 0.06821340f, 0.10769767f, 
    0.08191492f, 0.09482450f, 0.13247786f, -0.19463032f, -0.14145213f, -0.15171756f, -0.07235350f, -0.10973850f, 
    -0.10813466f, -0.04438356f, -0.03068875f, -0.06022220f, -0.08149571f, -0.03244855f, -0.03534919f, -0.04751970f, 
    -0.01418912f, -0.01326420f, -0.14230181f, -0.20920275f, 0.24537957f, 0.14208083f, 0.03701303f, -0.15308234f, 
    -0.06141896f, 0.13826545f, 0.13476069f, 0.10474418f, 0.04401721f, 0.04693296f, 0.02775911f, 0.01787797f, 
    0.00302894f, -0.03683579f, 0.01548797f, 0.03328060f, -0.01982101f, -0.08528002f, -0.04897630f, -0.06846406f, 
    0.01016310f, 0.22325909f, 0.22030190f, -0.02861293f, -0.22779080f, -0.16103487f, -0.12641470f, -0.13183181f, 
    -0.01499681f, -0.04812498f, -0.00237956f, 0.01877439f, -0.02427854f, 0.01425414f, 0.06121616f, 0.00245704f, 
    0.01035236f, 0.03906037f, 0.09015761f, 0.03974609f, 0.47242376f, 0.23900320f, -0.22519441f, -0.48228836f, 
    0.07311399f, -0.17191681f, -0.17687036f, 0.04769494f, -0.02333822f, 0.04422621f, 0.02483558f, -0.00671629f, 
    -0.06531397f, -0.16149932f, -0.05020408f, -0.09791069f, 0.04882344f, 0.10500947f, -0.11979862f, -0.00090348f, 
    -0.42064044f, 0.17434888f, -0.24542640f, -0.15633464f, 0.06500837f, -0.20240392f, 0.13191926f, -0.01648225f, 
    -0.01838725f, -0.05150692f, -0.13846681f, -0.02964716f, 0.08866370f, -0.16936246f, 0.00772626f, -0.15392664f, 
    0.07711730f, 0.03068156f, -0.14254180f, -0.02260196f, -0.07211424f, -0.02561808f, 0.01199184f, -0.01412361f, 
    0.01544423f, 0.01742243f, 0.05288302f, 0.02592949f, 0.00318621f, 0.04258713f, 0.12762965f, -0.05697217f, 
    -0.05472795f, -0.07974492f, -0.22360843f, -0.06688742f, 0.00622690f, 0.04717786f, -0.00702512f, -0.00083050f, 
    0.07499842f, 0.02632670f, 0.09309842f, 0.01051890f, 0.10661817f, -0.04127932f, -0.03476351f, 0.00028552f, 
    -0.02147831f, -0.01270471f, 0.02276609f, -0.01313009f, -0.00612273f, 0.07169591f, -0.07028822f, -0.04815894f, 
    0.06159190f, -0.13990006f, 0.00110109f, -0.00502072f, -0.50479603f, -0.01367661f, -0.33857808f, -0.28064647f, 
    0.08051421f, 0.01299446f, -0.01115538f, -0.09146240f, 0.02560241f, 0.01922051f, 0.00448278f, 0.02065299f, 
    0.04457371f, -0.09686963f, 0.11076376f, -0.05857880f, -0.01139790f, 0.01482133f, -0.03131125f, -0.27708718f, 
    -0.19927098f, -0.04496789f, -0.13243338f, 0.06985579f, -0.03418349f, 0.09084471f, 0.12497950f, 0.20653009f, 
    -0.00228770f, -0.08530851f, -0.06034888f, -0.00398427f, 0.08842264f, 0.03932635f, 0.00904241f, -0.03639965f, 
    0.02912697f, 0.05012632f, -0.04616703f, 0.01590407f, -0.02974597f, 0.13827214f, -0.11110828f, 0.01583852f, 
    0.03985259f, 0.12763359f, -0.06539601f, -0.06596421f, 0.02033370f, -0.18643878f, 0.05377258f, 0.10094216f, 
    0.03458720f, -0.04725525f, 0.01552255f, -0.02780573f, 0.02455598f, 0.04789849f, -0.03148093f, 0.06121333f, 
    -0.20523998f, -0.01929543f, -0.17824255f, 0.14388461f, 0.00414201f, -0.05791955f, -0.02212756f, -0.04969227f, 
    -0.04128612f, 0.07903474f, 0.02368264f, -0.01984457f, 0.03229969f, 0.05129460f, 0.04629192f, 0.00811639f, 
    0.01757610f, 0.02533374f, 0.02641397f, 0.00122400f, 0.00522333f, 0.12470967f, -0.02181811f, -0.18230322f, 
    -0.05666677f, -0.09042990f, -0.13878496f, -0.16356835f, -0.17607468f, 0.02485146f, -0.04273393f, -0.00283002f, 
    0.02639841f, 0.04763347f, -0.00672873f, -0.02786068f, 0.06837650f, -0.14746745f, 0.11798377f, 0.11607659f, 
    0.22644125f, -0.08927310f, -0.14719801f, -0.16498241f, -0.06384515f, -0.02533840f, -0.04789683f, 0.00269688f, 
    -0.08270712f, -0.03764537f, 0.00107019f, 0.01525893f, -0.00797881f, 0.00248677f, 0.02573332f, -0.05856762f, 
    -0.18956430f, -0.17261855f, -0.05880745f, -0.06311741f, 0.08327152f, 0.12997124f, -0.01164149f, 0.10385964f, 
    -0.06784936f, 0.12873967f, -0.13954958f, -0.09400299f, -0.06686388f, -0.00370375f, -0.02394388f, 0.00954215f, 
    0.03231580f, 0.01583768f, 0.07477637f, -0.06350761f, -0.00610482f, 0.03682711f, -0.18097556f, -0.05124407f, 
    -0.02558010f, 0.06781310f, -0.18628748f, 0.02134774f, -0.09817944f, -0.04583875f, 0.06040706f, -0.01224784f, 
    0.01515350f, 0.13198066f, 0.06812550f, -0.03202175f, -0.01548803f, 0.04276621f, 0.05795576f, -0.04059583f, 
    0.03625579f, -0.00355198f, -0.06666423f, 0.06246091f, 0.11776598f, -0.14158100f, -0.06905418f, -0.03350393f, 
    -0.16946608f, 0.00724153f, -0.00771786f, 0.02974838f, -0.02995179f, -0.15259594f, 0.04008042f, -0.05454296f, 
    -0.00048461f, -0.06959818f, 0.00172871f, 0.01123778f, -0.01854980f, -0.07419066f, 0.02013550f, 0.00039181f, 
    -0.04893807f, 0.01900104f, 0.00209621f, -0.02985975f, 0.04098023f, -0.00121864f, -0.06288390f, -0.02883166f, 
    0.04763579f, -0.00036640f, -0.01077104f, -0.01276003f, 0.05254865f, 0.08491802f, 0.04075923f, -0.11958229f, 
    0.00489906f, 0.07979248f, 0.03274567f, -0.03368778f, -0.02117754f, -0.05632302f, -0.01449521f, -0.04888339f, 
    -0.01754966f, -0.02447068f, -0.01171162f, -0.01060023f, -0.00389854f, -0.01889218f, 0.20727539f, 0.10009886f, 
    -0.10903082f, 0.04040685f, 0.01223732f, -0.09772006f, -0.03277700f, -0.04029211f, 0.02687295f, 0.06435828f, 
    0.29828560f, -0.00748878f, 0.07992759f, -0.00726124f, -0.00269392f, -0.06345945f, -0.01472213f, -0.01938758f, 
    0.00338388f, 0.02145374f, -0.00222557f, 0.04286334f, -0.01440669f, -0.00231463f, 0.01140748f, -0.04927751f, 
    0.02058348f, 0.00350559f, 0.11462863f, -0.09173311f, -0.01918782f, 0.01245543f, 0.07058674f, 0.00672992f, 
    0.06953581f, 0.01034442f, -0.05166177f, 0.06440663f, -0.00031111f, -0.00873173f, 0.01569782f, 0.04613300f, 
    0.03689799f, 0.05913481f, 0.07035346f, -0.13663134f, 0.13865368f, 0.03468058f, -0.05033260f, 0.03099438f, 
    0.15044630f, -0.01537146f, 0.04479538f, -0.01430767f, 0.11542830f, 0.04799989f, -0.03664991f, -0.05655916f, 
    -0.00011224f, 0.05147270f, 0.00629824f, 0.01022183f, 0.02466395f, 0.03754548f, -0.00974756f, -0.06141353f, 
    0.28682622f, -0.05959332f, 0.02122956f, 0.00648313f, 0.38155895f, 0.03081202f, 0.03004193f, 0.03977689f, 
    -0.04013823f, 0.02330525f, -0.07767644f, 0.01405996f, 0.00344621f, -0.04610384f, -0.07564460f, 0.00229529f, 
    0.03846760f, 0.07685141f, -0.03836076f, 0.04162920f, 0.04662435f, -0.01314954f, 0.10740048f, 0.02188153f, 
    -0.34849000f, -0.18785638f, -0.09399836f, 0.03069471f, -0.15614378f, -0.02169097f, 0.03632006f, 0.05917568f, 
    -0.12696773f, -0.12034224f, -0.04000737f, 0.03847179f, -0.10579951f, -0.05911155f, -0.05273350f, -0.01529919f, 
    -0.01719419f, -0.04992962f, 0.03477167f, 0.02374993f, -0.13250722f, -0.06865931f, -0.10104354f, 0.02269142f, 
    -0.05381401f, 0.02408173f, 0.06891519f, 0.05088563f, 0.08908459f, -0.08121281f, -0.06892598f, -0.00329161f, 
    -0.00854951f, 0.03678807f, 0.03441261f, 0.01264523f, -0.00273777f, -0.00179053f, 0.03440928f, 0.03469504f, 
    -0.17901446f, -0.06338519f, -0.13326730f, -0.00493395f, -0.01102062f, -0.01246378f, 0.02738913f, 0.07384101f, 
    0.09955040f, -0.14681347f, -0.13242884f, 0.06610423f, 0.02312698f, 0.04974876f, -0.06068429f, -0.01083478f, 
    0.03861748f, -0.01738902f, -0.01780601f, 0.02675136f, -0.12959386f, 0.16434017f, 0.01509846f, 0.17552064f, 
    0.15057369f, -0.04837311f, -0.02854079f, 0.06048712f, -0.21087721f, -0.00655859f, -0.00254435f, 0.03326809f, 
    0.01978321f, 0.00789541f, 0.01164950f, 0.02068522f, 0.04659190f, 0.03482389f, -0.30134353f, -0.00192059f, 
    -0.02436507f, 0.06524950f, -0.03139922f, 0.01160785f, -0.02207908f, 0.08844543f, -0.04511493f, -0.07893928f, 
    -0.03340584f, -0.02694295f, -0.03701507f, -0.02131830f, 0.05126505f, 0.07671933f, -0.07161395f, -0.02734418f, 
    0.03880354f, 0.04365761f, -0.03806664f, 0.04871371f, 0.02033579f, 0.21116585f, 0.13993196f, 0.10776295f, 
    0.08321662f, 0.00346163f, -0.08692157f, -0.03987492f, -0.10674880f, -0.07933801f, -0.01536625f, -0.00716973f, 
    0.01800094f, 0.02111168f, 0.06444748f, 0.02147824f, 0.00474221f, 0.03993623f, -0.26553509f, -0.07737803f, 
    0.01865501f, -0.08554489f, -0.22055276f, -0.30215701f, 0.29195404f, -0.25554860f, 0.17022599f, -0.17397746f, 
    0.13880056f, 0.04011052f, 0.11827931f, 0.01469272f, 0.00034055f, 0.02265187f, -0.04768475f, -0.06846303f, 
    -0.06136997f, -0.00535395f, -0.01177331f, -0.10784835f, 0.13903072f, 0.09755047f, 0.10622665f, 0.12372099f, 
    0.08730356f, -0.00056754f, -0.00477093f, 0.00338525f, -0.01343923f, -0.03624046f, 0.07049713f, -0.02610868f, 
    -0.01640686f, -0.00805222f, 0.04121558f, -0.12742426f, -0.09824325f, -0.11377263f, -0.02243972f, -0.05539360f, 
    0.53558224f, -0.02383844f, -0.32312274f, -0.03904095f, -0.26552469f, 0.04220271f, 0.01556731f, -0.03412246f, 
    -0.09424051f, 0.03193542f, 0.09985823f, 0.18623267f, -0.00964619f, 0.04889151f, 0.08250352f, -0.04390422f, 
    0.04388536f, -0.00044287f, 0.10407738f, 0.16836213f, 0.65246856f, -0.11035341f, 0.06651255f, 0.15732244f, 
    -0.01022235f, -0.01916314f, -0.04332853f, -0.02267758f, -0.03583134f, -0.02504081f, 0.11252516f, -0.06073368f, 
    0.10983374f, -0.08296468f, -0.09473465f, 0.09760729f, -0.09489515f, -0.11585636f, -0.00556377f, -0.01817184f, 
    0.34764647f, 0.19199567f, 0.14817837f, 0.25877127f, 0.02875029f, -0.00821536f, -0.01698461f, -0.01338733f, 
    -0.03431150f, -0.00796078f, -0.04440646f, -0.01046728f, 0.00099794f, 0.02984860f, 0.00066785f, -0.02156716f, 
    -0.04654612f, 0.06039336f, 0.10061891f, 0.01536111f, 0.25129205f, 0.03420059f, 0.03673402f, -0.02037777f, 
    0.07811502f, 0.01106349f, -0.01260181f, -0.06385998f, 0.09006705f, -0.01492855f, -0.03884283f, -0.02740536f, 
    0.04043292f, 0.02269847f, -0.03337312f, -0.11936502f, -0.00210960f, -0.02414019f, -0.04866713f, -0.04966573f, 
    -0.07486697f, -0.44017103f, 0.07138833f, -0.25228012f, 0.06558584f, -0.17885312f, 0.18309911f, -0.37497681f, 
    0.14169681f, 0.18233268f, 0.00402032f, -0.06720680f, -0.01001888f, 0.08013054f, 0.02739906f, -0.00116744f, 
    -0.04225347f, -0.06559336f, 0.18250173f, 0.07945591f, 0.77014893f, 0.11293297f, -0.31523705f, -0.03213955f, 
    -0.07386355f, -0.04974822f, 0.01482446f, -0.08526400f, -0.03866527f, -0.01864542f, -0.02842438f, 0.16687843f, 
    -0.00472423f, 0.07730224f, -0.05498587f, 0.07013799f, 0.05579035f, -0.04619540f, 0.00909126f, 0.13233933f, 
    0.08327541f, 0.18692181f, 0.22499344f, 0.17744289f, 0.01755066f, 0.05104883f, -0.03437079f, 0.11002993f, 
    -0.06248284f, -0.22295468f, 0.03367979f, 0.01436932f, 0.03128972f, -0.08106883f, -0.02750068f, 0.00940389f, 
    0.04372445f, -0.01869106f, -0.01374411f, 0.02421145f, 0.09038202f, -0.25165182f, -0.27720144f, -0.49135467f, 
    -0.08585592f, -0.11536250f, -0.19162498f, -0.28185192f, 0.14853485f, -0.00707705f, -0.01998447f, 0.00901173f, 
    -0.00606184f, -0.02257341f, 0.03076576f, 0.01112540f, -0.05140380f, -0.12091445f, -0.01153817f, -0.06181529f, 
    0.16931032f, -0.24012657f, 0.09972422f, 0.00975060f, -0.11946504f, -0.04980437f, -0.01884639f, 0.07988618f, 
    -0.05886651f, -0.08601852f, 0.07253969f, -0.17612135f, 0.11237950f, -0.10194293f, -0.04202696f, -0.01583607f, 
    -0.01026918f, -0.02973306f, -0.04028444f, -0.02492576f, 0.17906217f, 0.12383774f, 0.07837472f, 0.04186698f, 
    -0.00181827f, 0.13559739f, -0.07483944f, -0.04757665f, -0.01277573f, 0.06109593f, 0.00489567f, 0.03573814f, 
    0.05974886f, -0.01707679f, 0.02572720f, -0.06621279f, -0.02380098f, 0.00712335f, -0.14662357f, 0.01908066f, 
    -0.00167570f, -0.02324469f, 0.00766587f, -0.06294993f, -0.00493926f, 0.10662831f, -0.02361372f, -0.20855418f, 
    0.00786180f, 0.04245212f, -0.02217222f, -0.06068024f, 0.06976663f, 0.10404772f, 0.04788762f, -0.05228926f, 
    0.00211263f, -0.08669938f, 0.06843153f, -0.03047053f, -0.89000463f, -0.69773608f, 0.14439030f, -0.09195969f, 
    0.10061026f, 0.06661386f, -0.01894366f, 0.03753522f, -0.10937789f, -0.02206703f, 0.04837901f, 0.01072312f, 
    -0.10196078f, 0.09887354f, 0.10780601f, 0.11734080f, 0.06678135f, -0.03988741f, 0.08414406f, 0.05848418f, 
    1.10996521f, -0.07300099f, 0.22399579f, 0.10759626f, -0.22739922f, 0.06030977f, 0.04573091f, 0.03642503f, 
    0.02189616f, -0.15552145f, 0.08858097f, -0.23546819f, 0.08044846f, -0.13405943f, -0.17809136f, 0.16450228f, 
    0.15308677f, -0.13360967f, 0.01400547f, 0.07722318f, 0.16032240f, 0.05404194f, 0.10799450f, 0.00858624f, 
    0.05148577f, 0.01858559f, 0.01184786f, -0.07686930f, 0.01241089f, -0.00233446f, 0.00680906f, -0.00487994f, 
    0.00826386f, 0.01575929f, 0.01838119f, 0.04877323f, -0.00370279f, -0.01298952f, 0.06857084f, -0.02802351f, 
    -0.13090409f, 0.15319851f, 0.23622996f, 0.01654812f, -0.14463273f, 0.05234228f, -0.04134272f, 0.08765775f, 
    -0.05303814f, -0.02323041f, -0.00381954f, 0.04808650f, -0.01524060f, -0.08586245f, -0.07160127f, 0.24191460f, 
    -0.06684040f, -0.07414377f, 0.05600609f, -0.02969968f, -0.06975979f, 0.16946670f, -0.18807736f, 0.02580862f, 
    -0.18332645f, -0.06566007f, -0.00003590f, 0.10979973f, -0.09814695f, 0.04592348f, -0.00480095f, -0.08163618f, 
    -0.00985919f, -0.05315630f, -0.12374214f, 0.01751148f, -0.03481042f, -0.08166015f, 0.01078787f, 0.00941268f, 
    -0.10788471f, 0.17742284f, -0.14033948f, 0.10308173f, -0.04466263f, 0.10799972f, 0.00488530f, -0.02959022f, 
    -0.02708877f, -0.02860424f, -0.05040756f, 0.02788229f, 0.03687621f, 0.00493233f, -0.04634056f, 0.01624567f, 
    0.16977908f, 0.04012553f, 0.00409059f, 0.02366407f, 0.12271887f, -0.03789722f, 0.02717617f, 0.17927319f, 
    0.22202738f, -0.02677983f, -0.07319272f, -0.05466720f, -0.02810701f, -0.00908870f, 0.05364132f, 0.10536350f, 
    0.09929115f, -0.04693519f, 0.20547780f, 0.07476087f, -0.00441540f, 0.07068931f, -0.01819314f, -0.18107559f, 
    0.26257914f, -0.06859838f, 0.07101510f, -0.08167957f, 0.21643335f, -0.01806652f, 0.08314309f, 0.11019009f, 
    0.12597291f, 0.03222788f, 0.11207997f, -0.11636426f, 0.09674166f, -0.07443278f, -0.13253213f, -0.02180921f, 
    0.00951716f, 0.03617434f, -0.12716815f, -0.22298415f, -0.36582083f, 0.38390529f, -0.04484995f, 0.00345298f, 
    0.05133026f, -0.12980093f, 0.15119617f, -0.06749576f, -0.20102288f, 0.13420169f, -0.03090944f, 0.02637541f, 
    0.04791996f, -0.04386523f, 0.04748204f, 0.05885199f, -0.06048615f, 0.02375210f, -0.12835284f, 0.05910848f, 
    -1.05940127f, 0.26051831f, -0.20270295f, -0.04919626f, 0.02237552f, -0.20468274f, -0.02537453f, 0.00850411f, 
    -0.04401192f, -0.12165246f, -0.02284902f, 0.08825117f, -0.05615457f, -0.03694881f, -0.03692982f, 0.02340711f, 
    0.09464409f, -0.00071178f, -0.10813519f, 0.09701623f, 0.20969695f, -0.08018465f, 0.16813377f, 0.00287583f, 
    0.09255493f, -0.00445681f, 0.02708977f, -0.00732220f, -0.01824308f, 0.02553854f, 0.01140409f, -0.03443589f, 
    0.02707687f, -0.00186823f, 0.00957025f, 0.13800107f, 0.13746758f, 0.04863407f, 0.03008667f, 0.03547199f, 
    0.09055943f, -0.02080796f, -0.03542471f, -0.01790661f, -0.05343721f, -0.00497836f, -0.05508738f, 0.03056095f, 
    0.00731377f, -0.05180327f, 0.14177284f, 0.02834299f, 0.07132654f, -0.07456743f, 0.01687345f, -0.05318683f, 
    -0.00399804f, 0.00992880f, 0.05218884f, -0.04984453f, -0.34646091f, 0.19356872f, -0.02077914f, -0.12703268f, 
    0.26759851f, 0.06503252f, -0.02753979f, -0.04204274f, 0.08110175f, 0.03656025f, -0.03401119f, -0.01268052f, 
    -0.04776615f, -0.00996389f, 0.10924884f, 0.05101302f, -0.01052491f, 0.11393887f, 0.09181693f, -0.23287672f, 
    -0.13157454f, -0.19391845f, -0.03327725f, -0.02918420f, 0.18421873f, 0.00895585f, -0.01154593f, 0.03032517f, 
    -0.02309286f, 0.07424992f, -0.08283223f, -0.00975670f, 0.00306359f, -0.06326225f, -0.06784540f, 0.08007569f, 
    -0.04153302f, 0.06349336f, -0.00232919f, -0.07096519f, 0.05452846f, -0.17358662f, 0.13471018f, 0.09361213f, 
    0.03925549f, -0.01583825f, 0.01553580f, 0.01578465f, -0.06740641f, 0.01861689f, 0.07841393f, 0.02957561f, 
    -0.01706868f, -0.01397764f, 0.02900922f, 0.06180010f, -0.07025199f, -0.09419289f, 0.07620142f, -0.07665541f, 
    0.12214097f, 0.15470658f, -0.08553518f, -0.04909403f, 0.01973607f, -0.11833033f, -0.01041850f, -0.07939163f, 
    0.01109472f, -0.13611871f, -0.00904141f, 0.07328264f, 0.10159747f, -0.06651356f, -0.06452000f, 0.04582438f, 
    -0.09543721f, 0.00668186f, 0.08705632f, -0.03963117f, 0.35651329f, 0.06866382f, 0.27919951f, 0.12424459f, 
    0.07861327f, -0.04096149f, 0.01608197f, 0.04056593f, -0.01688346f, 0.00173481f, -0.08875437f, 0.03037579f, 
    0.03706472f, 0.08350656f, -0.01429291f, 0.13375825f, -0.07086942f, -0.07634777f, 0.14303252f, 0.02907251f, 
    -0.01353442f, -0.06748201f, 0.15399663f, -0.00571306f, 0.05918169f, -0.03715274f, 0.02769874f, -0.02763201f, 
    -0.00257763f, 0.00438467f, 0.11364567f, -0.04492205f, -0.06552760f, 0.05389455f, 0.01415026f, -0.19277757f, 
    0.03870115f, -0.10050184f, 0.01881268f, 0.04467040f, -0.14484255f, -0.10673415f, -0.18745303f, -0.14741725f, 
    -0.16415736f, 0.02996746f, 0.06975844f, 0.16369182f, 0.05969117f, -0.03662032f, 0.20993136f, -0.05786924f, 
    0.05571035f, 0.04518463f, 0.04801772f, 0.03709596f, -0.05358871f, -0.00030987f, 0.04751722f, -0.01804136f, 
    0.00519905f, -0.05866732f, -0.07070699f, -0.00158519f, -0.06626260f, 0.00136190f, -0.04129589f, 0.00300227f, 
    0.01264505f, -0.00843530f, 0.10468174f, 0.09916301f, 0.01112069f, 0.03849212f, 0.05357499f, -0.01790726f, 
    0.02400532f, -0.01920415f, 0.11750404f, 0.01608683f, -0.12123348f, -0.00496868f, -0.13836695f, 0.04268602f, 
    -0.10471373f, -0.03822570f, -0.09033187f, -0.02506436f, -0.15340041f, 0.14484039f, 0.01659160f, -0.01430906f, 
    0.05190319f, 0.00719374f, 0.08909305f, 0.00971574f, 0.00526952f, 0.03484041f, -0.25073940f, -0.17327277f, 
    0.08421832f, 0.24634519f, 0.04388441f, -0.13475285f, 0.07395486f, -0.14674981f, 0.04165731f, -0.10180651f, 
    -0.00628657f, 0.05902282f, 0.01018966f, -0.01191553f, -0.00126076f, 0.01676845f, -0.04267877f, 0.07201602f, 
    0.01132728f, -0.01855768f, -0.02262325f, -0.00951822f, -0.33342898f, -0.35482389f, -0.28598779f, -0.45014548f, 
    -0.17875218f, 0.09680066f, -0.14120758f, -0.10481598f, -0.04121759f, -0.11924657f, -0.01621217f, 0.00135205f, 
    -0.00812036f, 0.02511520f, 0.02561963f, -0.13236757f, -0.11886806f, -0.06423584f, -0.17468244f, -0.19455542f, 
    -0.18882366f, -0.16308177f, 0.17457815f, -0.05155823f, -0.08746583f, 0.08565563f, 0.09208700f, 0.01115125f, 
    -0.05724351f, 0.05519664f, 0.00905220f, -0.00133951f, -0.00194170f, 0.10897398f, 0.03593257f, 0.03449306f, 
    -0.04129069f, -0.01102880f, 0.06383526f, 0.11010852f, 0.18021832f, 0.17328344f, 0.20728756f, -0.01606949f, 
    -0.03237804f, 0.10289425f, -0.13460012f, 0.05429360f, -0.01270527f, 0.00535788f, -0.01643588f, 0.02505406f, 
    -0.01952992f, -0.09010802f, -0.03239823f, 0.10831679f, 0.01798092f, -0.02442367f, -0.03926472f, 0.01824293f, 
    -0.39555597f, 0.12301869f, 0.14715816f, -0.02949559f, -0.10326643f, 0.16842569f, -0.06374865f, -0.05480690f, 
    -0.15183751f, -0.03703942f, -0.04631131f, -0.05318102f, -0.00536727f, 0.04536512f, -0.01477460f, -0.05481650f, 
    -0.12806624f, -0.05643018f, -0.09390479f, -0.21634778f, 0.29494795f, -0.08312462f, 0.01389725f, -0.18291339f, 
    0.22055779f, -0.02293292f, -0.08225596f, -0.00495322f, 0.11673210f, -0.03897119f, 0.13984649f, -0.04954026f, 
    0.07989002f, -0.04717166f, -0.09144833f, 0.12498379f, -0.13399304f, -0.05509476f, -0.13735397f, -0.14562665f, 
    -0.56607080f, 0.14006208f, -0.05286923f, 0.14706527f, 0.13948146f, 0.06118189f, -0.00946797f, 0.02869684f, 
    0.04951853f, -0.06184025f, -0.22666439f, -0.02673038f, -0.12740061f, 0.13505574f, 0.05223767f, -0.07514198f, 
    0.03843099f, -0.07276042f, -0.13650954f, -0.09766686f, 0.23202243f, 0.08174195f, 0.09651057f, 0.08270507f, 
    0.08090442f, -0.05381382f, 0.00055728f, -0.05679584f, -0.03858426f, 0.01108469f, -0.08890754f, 0.16113503f, 
    -0.05221729f, 0.01472763f, -0.08847956f, -0.06002186f, -0.06884773f, -0.08446653f, -0.13794185f, -0.04637445f, 
    -0.06690515f, -0.04992483f, -0.04634219f, -0.07576433f, 0.09211698f, -0.09711988f, -0.02575881f, 0.02785851f, 
    0.00929314f, 0.02737007f, 0.00344590f, -0.10405347f, -0.03642680f, -0.01540826f, 0.00821782f, -0.05052878f, 
    -0.05570890f, -0.02277103f, 0.01730205f, -0.03354836f, -0.10651568f, 0.00216133f, -0.40605232f, -0.03092750f, 
    0.04709230f, 0.05971067f, 0.02120882f, -0.03986868f, 0.02343451f, -0.05669792f, -0.04336743f, 0.03642951f, 
    -0.04661241f, -0.03101273f, -0.02230814f, -0.00599492f, 0.12655683f, 0.12583354f, -0.04821816f, 0.04332935f, 
    0.02695589f, -0.02843589f, 0.14710271f, 0.22449236f, 0.11252163f, -0.03442642f, -0.09265649f, -0.07581118f, 
    0.08819766f, -0.08753820f, 0.00163222f, 0.05179036f, 0.03043317f, 0.01074824f, 0.03595297f, 0.01457185f, 
    0.01692036f, 0.01947655f, 0.00728755f, -0.02142425f, -0.03098275f, 0.04094008f, -0.01015904f, -0.05968741f, 
    -0.09867908f, 0.05666571f, -0.12787159f, -0.12841997f, -0.00160277f, 0.05661714f, -0.01393378f, 0.05183341f, 
    0.01861775f, -0.03222208f, -0.04233431f, 0.02667199f, -0.03913550f, -0.13826722f, 0.04770885f, 0.07387006f, 
    -0.40614530f, -0.01996300f, -0.13542774f, 0.02985726f, -0.28587902f, 0.08138140f, 0.14344744f, -0.01380150f, 
    -0.04428359f, -0.18110454f, -0.01104013f, 0.03616557f, -0.00018434f, -0.00948924f, -0.03199660f, 0.03684773f, 
    0.01817014f, 0.00800709f, -0.05720787f, 0.00906955f, -0.54412138f, 0.12613441f, 0.12913255f, -0.10350495f, 
    -0.06292590f, -0.03511000f, 0.04802619f, 0.01884892f, -0.20785543f, 0.05715336f, -0.01036060f, 0.01971323f, 
    0.05310500f, 0.02455407f, -0.04727269f, -0.06377814f, -0.09797972f, -0.00653035f, -0.10681123f, -0.07382742f, 
    -0.17738791f, 0.00264880f, 0.13293540f, -0.09994486f, -0.03051226f, 0.02438842f, 0.01281439f, 0.02027801f, 
    0.01133390f, 0.00375421f, -0.01141684f, 0.01618446f, 0.00042120f, -0.02496272f, 0.02945736f, 0.06876452f, 
    0.06728141f, 0.13241687f, 0.11306565f, 0.05217714f, -0.63793224f, -0.68427050f, -0.33155528f, 0.00639014f, 
    -0.47185805f, -0.04118091f, -0.01499974f, 0.04987014f, -0.02323105f, -0.14562291f, -0.05134439f, 0.00764237f, 
    -0.02076972f, -0.05758635f, -0.04972738f, -0.09866140f, -0.00381990f, 0.01796967f, -0.04956416f, 0.09455948f, 
    0.02377305f, 0.03787493f, 0.28516471f, 0.13637379f, 0.01855601f, 0.03768780f, -0.03198242f, -0.01944429f, 
    0.14468575f, -0.06385097f, 0.00985630f, 0.02775401f, -0.00239322f, 0.01891680f, -0.00354946f, 0.01402807f, 
    0.01080599f, -0.01812559f, 0.04725156f, -0.04513018f, -0.24944974f, 0.00649817f, 0.37897387f, 0.20132631f, 
    0.19582273f, -0.05014148f, -0.02803022f, 0.09310437f, 0.06842238f, -0.14730467f, 0.05400382f, 0.01308533f, 
    0.06606438f, -0.03501005f, 0.05909034f, 0.00325978f, -0.00747074f, 0.03201710f, -0.01824979f, -0.00791645f, 
    -0.06133474f, -0.00458183f, 0.02028312f, -0.08036015f, 0.02600086f, 0.07794583f, -0.25470161f, -0.09602549f, 
    0.01491943f, 0.10087047f, 0.01499260f, -0.04347505f, 0.06130955f, -0.01898906f, -0.07315931f, 0.01034317f, 
    -0.01219565f, -0.09851176f, 0.00762188f, 0.02085433f, -0.01162115f, 0.04090142f, -0.01035964f, 0.03698403f, 
    0.09237386f, 0.00064184f, -0.00148322f, 0.00633822f, 0.01740060f, -0.04120687f, -0.12376843f, -0.12579399f, 
    -0.07120564f, 0.02578920f, 0.05755124f, -0.02732215f, -0.08003660f, -0.01376253f, -0.05744666f, -0.07716229f, 
    -0.09726451f, -0.10481132f, 0.10177340f, -0.24439493f, -0.10018041f, 0.08255568f, 0.01537765f, -0.03940322f, 
    0.04073179f, 0.04356432f, -0.00445094f, 0.00637881f, 0.03229282f, 0.00385395f, -0.02072467f, 0.05184256f, 
    -0.06381625f, -0.18913676f, 0.09792284f, 0.02470102f, 0.06866390f, 0.10498171f, -0.10551471f, 0.02536066f, 
    0.10054061f, -0.05215192f, 0.03129109f, 0.04815307f, 0.05518178f, -0.02349065f, 0.04923856f, 0.02793535f, 
    -0.00396002f, 0.07194045f, 0.01794380f, 0.05275312f, -0.04268782f, 0.01711688f, 0.02591397f, -0.03897960f, 
    0.02734043f, 0.08942618f, 0.09648205f, -0.11987112f, 0.12508881f, -0.05683645f, 0.06326168f, 0.01250163f, 
    0.04419255f, 0.06004225f, 0.01245498f, -0.03871155f, -0.01292186f, 0.04453264f, 0.03121298f, 0.03266317f, 
    -0.02858527f, -0.01615638f, -0.00357079f, -0.02918221f, -0.42433125f, 0.08735542f, 0.15890664f, -0.24664512f, 
    -0.09557519f, -0.04200885f, -0.02156403f, -0.02026127f, -0.03187301f, 0.12551576f, -0.03492253f, -0.05352244f, 
    -0.02575697f, -0.01062861f, 0.03377253f, 0.02468814f, -0.18205827f, -0.10455299f, 0.08401243f, -0.01743685f, 
    -0.10509174f, 0.30542526f, 0.40876007f, 0.11923711f, 0.21340455f, -0.11967113f, -0.03739570f, 0.10108026f, 
    0.03310979f, 0.07482973f, 0.02724690f, 0.00912595f, -0.09596238f, 0.08415118f, 0.11538830f, 0.04557390f, 
    0.01716928f, -0.00009130f, 0.00132920f, -0.02318301f, 0.13092008f, -0.05055116f, 0.09097541f, 0.08149254f, 
    0.08749703f, 0.00707809f, -0.11864812f, -0.04801677f, 0.02250496f, -0.18445083f, 0.01436622f, 0.06760555f, 
    0.05393725f, 0.00110542f, 0.00692094f, 0.00378569f, -0.00963951f, -0.04623579f, 0.02500212f, -0.05290023f, 
    0.05436379f, -0.09840408f, 0.04527358f, 0.07908059f, 0.07128964f, 0.03833218f, -0.10690926f, -0.04186929f, 
    0.08602352f, -0.22021168f, -0.07476144f, 0.06514576f, 0.06308816f, 0.02305109f, 0.01912943f, -0.01148481f, 
    -0.02726216f, -0.05739988f, 0.02748295f, -0.05141459f, -0.43458790f, -0.59249181f, -0.46918887f, 0.00167839f, 
    -0.48490453f, -0.05460074f, -0.07667486f, -0.04473885f, 0.03626596f, -0.07999551f, -0.02607349f, -0.01474787f, 
    -0.01307843f, -0.03216438f, -0.04551085f, -0.03690988f, 0.00727352f, -0.00984093f, -0.19368440f, -0.04314777f, 
    0.08676965f, -0.15725917f, 0.14341426f, -0.18072349f, 0.11773320f, 0.03576610f, -0.22129294f, -0.21249026f, 
    -0.03850962f, 0.09439334f, 0.04294436f, 0.00710836f, 0.01340739f, -0.00549003f, 0.01019538f, 0.08696243f, 
    -0.06411596f, -0.49228579f, -0.02176528f, -0.02210436f, -0.45734808f, -0.53666967f, -0.11881720f, -0.02738860f, 
    -0.45559466f, 0.07426889f, 0.00237588f, 0.06052766f, 0.01940134f, -0.03945398f, -0.02686951f, -0.00153590f, 
    -0.02177958f, 0.01376629f, -0.02641472f, -0.04322005f, -0.00138227f, -0.03555932f, -0.03891979f, 0.09248529f, 
    0.43537083f, -0.26440346f, 0.10558822f, -0.03709216f, 0.17632589f, -0.08307461f, 0.01920105f, -0.17053434f, 
    0.19804633f, 0.08525268f, -0.01560755f, 0.02029447f, 0.01499337f, 0.02817095f, -0.04648196f, -0.00063495f, 
    0.00481553f, -0.09103643f, 0.05328722f, 0.03964271f, -0.11360081f, -0.18579172f, -0.06474346f, -0.06348111f, 
    0.03682796f, -0.02523630f, -0.06231304f, -0.00759863f, 0.02788760f, 0.03630221f, -0.03792000f, -0.00228136f, 
    -0.03134178f, 0.07509556f, -0.04049903f, 0.06158566f, 0.03949379f, -0.03018720f, 0.00230999f, -0.00003566f, 
    -0.14278427f, 0.11927500f, -0.06932857f, -0.08447149f, -0.06157954f, -0.01716550f, -0.02795727f, -0.06930186f, 
    -0.08607907f, -0.05506018f, 0.05057846f, 0.00523771f, 0.03055251f, 0.05026605f, 0.02088620f, 0.09288374f, 
    -0.01331777f, -0.15884548f, 0.13940570f, -0.07667724f, -0.38208356f, 0.12233901f, 0.27601591f, -0.18081482f, 
    -0.00890519f, 0.04802106f, -0.02087757f, -0.04658897f, -0.01269094f, 0.00413446f, -0.00406003f, 0.02154238f, 
    0.03339297f, -0.07295904f, 0.07038625f, 0.07989766f, 0.09329880f, 0.08100245f, 0.16248041f, -0.14151658f, 
    -0.25829491f, -0.18841657f, 0.30131000f, -0.14389838f, -0.23107736f, 0.00795650f, 0.02923948f, -0.04074590f, 
    0.02406639f, 0.05866031f, 0.01298111f, -0.00374143f, 0.00183854f, 0.03761675f, 0.00958950f, 0.08691532f, 
    -0.05010013f, 0.07222591f, 0.03143798f, -0.04921350f, 0.00538898f, -0.01114361f, -0.13304299f, 0.00751789f, 
    -0.00648413f, -0.01151980f, -0.07064217f, 0.01077972f, 0.01148938f, 0.06984047f, 0.05184745f, 0.05475955f, 
    -0.13399042f, 0.09980629f, -0.00287055f, 0.09472135f, 0.03202320f, 0.06636731f, 0.01471995f, 0.00700371f, 
    0.11891342f, -0.17894164f, -0.09392624f, -0.11507534f, 0.06383192f, -0.01126697f, 0.07183510f, -0.24826844f, 
    -0.16872670f, 0.13403662f, 0.01157984f, 0.06408764f, 0.08382400f, 0.09778498f, -0.10589276f, 0.11198881f, 
    -0.07172817f, -0.10643703f, 0.03680440f, 0.05429427f, -0.43901980f, 0.65066373f, -0.26169834f, -0.13176693f, 
    -0.34373978f, 0.04328260f, -0.05138947f, -0.11344329f, -0.06645773f, 0.01740135f, 0.00017494f, 0.04608215f, 
    0.09080040f, -0.18640564f, 0.02009794f, 0.10032848f, -0.03905114f, 0.19114193f, 0.13024546f, 0.00882354f, 
    -0.15220857f, -0.53631908f, 0.32655415f, 0.42731869f, 0.14406131f, -0.06865791f, -0.11906917f, -0.05362019f, 
    0.13927658f, 0.01008530f, 0.00341964f, 0.00400819f, 0.01722316f, -0.03816069f, -0.02577309f, -0.03674565f, 
    0.02746627f, -0.01405422f, -0.02483444f, -0.05005394f, -0.40943468f, -0.21138856f, 0.23348735f, -0.21810728f, 
    0.00211204f, 0.01531191f, -0.18220533f, -0.17930111f, -0.10385878f, -0.03094116f, 0.03335919f, -0.00053668f, 
    0.02705539f, 0.01737395f, -0.00935880f, 0.01710371f, -0.07134112f, -0.01038831f, 0.05953927f, 0.07022322f, 
    0.05265725f, -0.06816989f, 0.46752426f, 0.17395774f, 0.18526697f, -0.07001874f, 0.02777126f, 0.04569443f, 
    0.06132155f, -0.06413368f, 0.04478792f, 0.00341008f, 0.06806730f, -0.08503181f, 0.09986708f, 0.00842991f, 
    -0.03589016f, -0.00594165f, 0.01343767f, -0.03851876f, -0.37497222f, -0.44774321f, -0.07753385f, 0.15153539f, 
    -0.21903570f, 0.00998379f, 0.03165827f, 0.03066563f, 0.05637842f, -0.07025146f, -0.00786092f, 0.01161294f, 
    0.02512030f, -0.02712131f, -0.01690705f, -0.05401728f, 0.00303577f, 0.00205060f, -0.06639665f, 0.11504500f, 
    -0.21496190f, -0.08226207f, 0.08493227f, -0.05876815f, 0.04223711f, -0.10892209f, -0.20745389f, -0.39807746f, 
    -0.10765412f, 0.07680799f, 0.04448418f, -0.03953754f, 0.01895502f, -0.02928617f, -0.06355724f, 0.01486689f, 
    -0.04402608f, -0.04841041f, -0.14637886f, -0.07137178f, 0.28916830f, -0.01581629f, -0.30913934f, -0.01125580f, 
    0.02652600f, -0.08720315f, -0.00159484f, -0.03755825f, -0.08773610f, 0.00546868f, -0.10528121f, -0.04880202f, 
    -0.00167912f, -0.05905528f, 0.03418885f, 0.03393404f, 0.14321686f, -0.00827071f, 0.12708168f, 0.07292307f, 
    -0.34790865f, 0.24745043f, 0.16243531f, 0.09252957f, -0.13020478f, -0.00213926f, -0.14569424f, 0.01684306f, 
    -0.06539956f, 0.02256786f, 0.04687238f, 0.08561769f, 0.01881532f, -0.12408683f, -0.05405914f, -0.07548289f, 
    0.07639559f, 0.13718478f, 0.14236724f, -0.16448954f, -0.15963842f, -0.06278849f, 0.14219950f, -0.07690974f, 
    -0.03093666f, -0.04216989f, 0.02299931f, -0.00449534f, 0.02153060f, 0.06321175f, 0.04467414f, -0.02927145f, 
    -0.00338965f, 0.05843269f, -0.03073190f, -0.05745198f, -0.05432391f, 0.02282222f, 0.00215450f, -0.01655822f, 
    -0.19569002f, -0.13301416f, 0.17549813f, 0.11853354f, 0.18898359f, -0.06989066f, -0.04630435f, -0.05732116f, 
    -0.06612093f, 0.05315180f, 0.00171985f, -0.00810165f, 0.03921202f, -0.02506916f, 0.00643649f, -0.02211364f, 
    0.10730438f, -0.00835164f, -0.04803620f, -0.00508114f, -0.06062991f, 0.14142613f, 0.37499654f, 0.04224196f, 
    0.28328952f, -0.09313929f, 0.03023764f, 0.03008370f, 0.06594817f, 0.01992884f, 0.01021877f, 0.09012217f, 
    0.00004616f, -0.05080588f, 0.09382883f, 0.01424756f, -0.00697082f, 0.04529382f, 0.00673116f, 0.02910172f, 
    -0.36451611f, 0.18694443f, -0.08396278f, -0.21858446f, 0.01652740f, 0.08288617f, -0.01150609f, -0.07798959f, 
    -0.04662408f, 0.14128691f, -0.01719764f, 0.00708943f, 0.05809990f, -0.08565196f, 0.02794465f, -0.07928433f, 
    -0.01518629f, -0.01015403f, 0.03556770f, -0.01243770f, 0.08814860f, 0.11583822f, -0.19079870f, 0.10005397f, 
    0.20913041f, 0.04707882f, -0.01115605f, -0.07673945f, 0.07845161f, -0.05716599f, -0.10533968f, 0.03607596f, 
    -0.05737607f, -0.00187965f, 0.03322548f, 0.00949632f, 0.08403236f, 0.05760515f, -0.00496482f, 0.06073778f, 
    0.32870728f, -0.15904520f, 0.26343453f, 0.29115787f, 0.05072281f, -0.00318742f, -0.00725034f, -0.15118061f, 
    0.15223435f, 0.04048312f, -0.01510596f, 0.02467378f, 0.06444940f, -0.05628550f, 0.00262975f, 0.02253817f, 
    0.05935123f, -0.01583679f, 0.09114145f, -0.11861398f, 0.18840793f, 0.08714824f, -0.24832352f, 0.23475638f, 
    0.07752971f, -0.13236625f, 0.08897917f, 0.03704399f, -0.07519595f, 0.12839177f, -0.02048265f, 0.01819138f, 
    0.01750349f, -0.05535644f, -0.05532402f, -0.00929471f, -0.03168470f, -0.03150780f, -0.02980146f, 0.06664871f, 
    0.09081421f, 0.45145014f, -0.61329067f, 0.12541589f, 0.14585884f, 0.00449527f, -0.06147882f, 0.13429964f, 
    -0.06585147f, 0.14151126f, -0.05012475f, 0.04812585f, 0.06366724f, -0.01372774f, -0.00397495f, -0.04989659f, 
    -0.04244623f, 0.06041113f, -0.17964388f, 0.05583833f, 0.03741192f, -0.02617166f, -0.03804912f, -0.02859385f, 
    -0.00129828f, 0.06447355f, 0.01252976f, 0.01225979f, 0.00728837f, 0.05678788f, 0.03594914f, 0.02823898f, 
    -0.02263565f, 0.05408078f, -0.02327077f, -0.06938658f, -0.02623248f, 0.09898712f, 0.03123714f, -0.03364786f, 
    -0.11827159f, 0.02714624f, 0.03221586f, -0.03638199f, 0.03586629f, 0.01668083f, -0.06441489f, -0.02952361f, 
    -0.03792578f, -0.03545582f, -0.15591322f, -0.14219241f, 0.05914593f, -0.05850529f, -0.05271287f, 0.02156115f, 
    -0.02904722f, -0.15636389f, 0.02321697f, -0.05858603f, -0.19940355f, 0.07864355f, -0.31290597f, -0.20496190f, 
    -0.04885202f, -0.05486877f, 0.02251080f, 0.08155523f, -0.04912855f, 0.04893868f, 0.00910587f, 0.07949185f, 
    -0.07632688f, 0.04948409f, -0.12075912f, -0.09710186f, 0.07721925f, 0.10139506f, -0.08907744f, -0.07560430f, 
    0.45235538f, 0.09203852f, -0.29440463f, -0.06554301f, 0.13797055f, -0.08914920f, 0.02523177f, -0.01418091f, 
    -0.01943352f, 0.13474184f, -0.12254167f, 0.03401206f, 0.04712056f, -0.07153162f, -0.05947109f, 0.08601231f, 
    -0.01617579f, 0.03580558f, 0.01507139f, 0.01074216f, -0.04498462f, -0.08242635f, 0.12902343f, 0.05362110f, 
    0.21170239f, 0.00789494f, 0.00672382f, -0.04182360f, 0.00307723f, -0.01355246f, 0.04255472f, -0.06263471f, 
    -0.03597757f, -0.01043284f, 0.04589915f, 0.03744342f, 0.05828408f, 0.01959925f, -0.04072953f, 0.04687537f, 
    -0.18991914f, 0.12692295f, 0.06113189f, -0.18110509f, -0.11180723f, -0.01096455f, -0.03491035f, -0.07353009f, 
    -0.00486381f, 0.00973809f, 0.00668036f, -0.03941985f, -0.02179172f, 0.02356820f, 0.03371444f, 0.07031915f, 
    0.04174924f, -0.11253996f, 0.09950870f, 0.04001885f, 0.01206406f, -0.26277229f, -0.01575282f, -0.34708396f, 
    -0.01300407f, 0.01634800f, -0.00622353f, -0.01988939f, 0.02042905f, 0.05388150f, -0.02932691f, 0.01334951f, 
    -0.07462982f, 0.02890400f, -0.02768215f, 0.12114683f, -0.03072223f, -0.01719452f, 0.19468167f, -0.08890341f, 
    0.11983100f, -0.05127689f, 0.00507107f, -0.02350998f, 0.09185876f, 0.00308910f, 0.01016022f, -0.02607538f, 
    0.00792811f, 0.04650692f, 0.04549978f, -0.09778944f, -0.09858331f, 0.09849226f, 0.08861873f, 0.05316357f, 
    -0.03931953f, -0.04598942f, 0.03870420f, -0.06033009f, -0.04752299f, 0.01191292f, -0.00047447f, -0.01212226f, 
    0.03852214f, 0.01080464f, -0.04167093f, -0.16524240f, -0.03474192f, -0.28217998f, -0.01975423f, -0.06544761f, 
    0.11751055f, 0.01386747f, 0.00475990f, 0.06790975f, 0.00192716f, -0.10457148f, 0.05740541f, 0.01755979f, 
    -0.05127062f, 0.02552142f, 0.04227133f, 0.00382378f, 0.05828999f, 0.01233981f, -0.05178330f, -0.09730894f, 
    -0.03392148f, -0.00798768f, 0.01190979f, -0.09544274f, -0.00505751f, 0.03551393f, -0.03445482f, 0.00028415f, 
    -0.05068476f, -0.02414553f, 0.00314057f, -0.03285129f, -0.28673327f, -0.20438904f, -0.01882966f, 0.07461503f, 
    -0.29534718f, 0.07291251f, 0.08773874f, 0.08886129f, -0.01356981f, -0.01038360f, 0.02129634f, -0.01547052f, 
    -0.03404610f, -0.06314564f, -0.03971894f, -0.00030123f, 0.03308685f, 0.00036287f, 0.03332639f, 0.07843743f, 
    -0.52969491f, 0.07831242f, -0.01057839f, 0.03165351f, -0.15523888f, -0.07135142f, 0.05860755f, 0.05238749f, 
    -0.04845986f, -0.00934338f, 0.01721034f, 0.01253414f, -0.00997717f, 0.02352153f, -0.04506166f, -0.06130516f, 
    -0.01807201f, 0.07156342f, -0.10107430f, -0.06577865f, -0.11802018f, 0.14103965f, 0.08159602f, -0.17494227f, 
    0.09030035f, -0.00495549f, 0.00398137f, -0.00851455f, 0.01841631f, 0.01898706f, 0.00582829f, -0.01796352f, 
    0.02545998f, -0.03660588f, -0.02362527f, -0.02888418f, 0.13582088f, 0.11998756f, 0.08172837f, 0.08763769f, 
    -0.30226043f, -0.00579407f, -0.11612202f, 0.09070132f, 0.00345969f, 0.03499129f, 0.14916241f, 0.04598564f, 
    -0.27443144f, -0.00204216f, 0.02671999f, -0.02055849f, 0.02540928f, -0.00404433f, -0.01707461f, 0.04937738f, 
    0.00124424f, 0.00264988f, -0.09350827f, 0.00635344f, -0.21699820f, -0.01828185f, 0.27354956f, 0.24820194f, 
    0.29413241f, -0.02722114f, 0.00281126f, -0.01594832f, 0.13931935f, 0.04643836f, 0.00741542f, 0.01100465f, 
    0.00231433f, 0.00289636f, 0.02154910f, -0.02164841f, 0.00941071f, -0.01348919f, -0.03406831f, 0.01110911f, 
    -0.05485998f, -0.26702303f, 0.17331421f, -0.00043659f, -0.37096116f, -0.03783388f, 0.08619966f, 0.00754476f, 
    -0.08529353f, 0.09135228f, -0.01945746f, 0.03986771f, -0.02777779f, 0.05378835f, -0.00872297f, 0.07247860f, 
    0.04666696f, -0.01004421f, 0.06173683f, 0.09065722f, 0.38374698f, 0.28885233f, 0.25348726f, 0.35609129f, 
    0.25179318f, 0.13592832f, -0.01807660f, -0.17574236f, 0.07718223f, -0.27096906f, -0.01083074f, 0.00412800f, 
    -0.07430248f, -0.19993271f, 0.07666998f, -0.00898516f, 0.00250820f, -0.02358747f, -0.09617618f, -0.06175288f, 
    0.44706881f, -0.25683063f, -0.24256083f, 0.25655290f, -0.00367443f, 0.18362360f, -0.14296511f, -0.04969557f, 
    0.03809171f, -0.06917863f, -0.07183086f, 0.19440022f, -0.02148914f, 0.12374655f, 0.01859795f, 0.05377841f, 
    -0.01857224f, -0.04125910f, 0.18992755f, 0.04590906f, -0.17730300f, -0.12465224f, -0.27564058f, -0.02558501f, 
    0.01539121f, -0.01949395f, -0.03427155f, 0.01242288f, -0.01830029f, -0.01158341f, -0.11115008f, -0.05605821f, 
    0.02573731f, -0.04394658f, -0.09137855f, -0.04377897f, -0.02339694f, 0.09219280f, 0.07230031f, -0.00925183f, 
    -0.26844618f, -0.13726756f, 0.20672068f, -0.20327102f, -0.16882145f, -0.06753789f, -0.03246142f, -0.15235582f, 
    -0.15857945f, -0.05721900f, 0.09368151f, 0.07014995f, 0.15198420f, 0.00078509f, 0.05207952f, 0.03592668f, 
    0.05711469f, 0.05484153f, -0.18301113f, -0.15989722f, 0.33585456f, 0.31151849f, 0.16254029f, -0.36873004f, 
    -0.00104295f, 0.06073043f, 0.14131029f, 0.00295696f, 0.07065653f, -0.04527582f, 0.09717365f, 0.02220016f, 
    -0.04370957f, 0.00754148f, -0.10507670f, -0.03943979f, -0.04144064f, 0.17913483f, -0.04242705f, -0.08877081f, 
    -0.04934658f, -0.09499951f, -0.16751519f, -0.02606022f, 0.23196332f, 0.09556504f, 0.03876260f, -0.01744856f, 
    -0.00484213f, -0.03603626f, -0.05544578f, 0.03660487f, -0.02022264f, 0.05043344f, -0.02875125f, -0.00420537f, 
    0.01405733f, 0.10447066f, 0.04632073f, 0.02720186f, -0.04894949f, -0.16762334f, 0.07438610f, -0.08142191f, 
    0.08990848f, -0.04276835f, 0.06897753f, 0.05116464f, -0.06702383f, -0.06981170f, -0.02879358f, -0.04051962f, 
    -0.00878261f, -0.00069320f, 0.01752604f, -0.11479439f, -0.05345895f, 0.09121800f, 0.01908894f, -0.00668129f, 
    -0.00059973f, -0.03475646f, -0.16968670f, 0.10842551f, 0.15311970f, 0.04459422f, 0.03431296f, 0.10343750f, 
    0.05375941f, 0.08993949f, 0.01992801f, -0.08680144f, -0.03303135f, -0.00885600f, -0.05150058f, -0.03904980f, 
    -0.09094939f, 0.02503650f, -0.00564974f, 0.01335205f, -0.42269754f, -0.18574291f, 0.18470117f, 0.08164496f, 
    0.20977475f, -0.05257846f, 0.00999894f, 0.09813739f, -0.00113263f, 0.02814143f, 0.08402714f, 0.07852067f, 
    -0.01874314f, 0.00868429f, 0.16974652f, 0.00315690f, 0.10993216f, 0.06069460f, -0.04078778f, -0.10815799f, 
    0.07087725f, -0.15491699f, 0.11512524f, -0.03667768f, 0.01506397f, -0.16551797f, -0.05840387f, 0.07651254f, 
    0.06757458f, 0.06949492f, 0.03137328f, -0.00888333f, 0.09705848f, 0.01936835f, 0.03358012f, -0.02272044f, 
    -0.00063811f, -0.00163641f, 0.06238500f, -0.00418375f, 0.00733734f, -0.08853597f, -0.14136554f, 0.08265010f, 
    0.19497393f, -0.07177686f, 0.10515526f, 0.01002040f, 0.04034213f, 0.07777064f, -0.07870712f, -0.00246264f, 
    -0.02229023f, -0.11024766f, -0.01653805f, -0.02543948f, 0.03276367f, 0.06144992f, -0.05660086f, -0.01044194f, 
    -0.12544233f, 0.00329547f, -0.07458043f, 0.04411870f, 0.25070280f, 0.00952117f, -0.10201024f, -0.06401510f, 
    -0.11788139f, -0.02023445f, -0.04895688f, 0.08031917f, 0.03654144f, 0.08340625f, 0.04700421f, 0.10249121f, 
    -0.04761891f, 0.06442455f, -0.03281437f, -0.04365050f, -0.09781170f, 0.05542346f, -0.08590496f, -0.09314036f, 
    0.24115384f, 0.27675620f, 0.07391125f, -0.02236776f, -0.06724663f, -0.15529254f, -0.11257706f, 0.04058022f, 
    0.03900227f, 0.00581933f, 0.06684285f, -0.07979910f, 0.03363505f, -0.03477832f, 0.02400418f, -0.03499847f, 
    -0.00382028f, -0.05737410f, 0.35241619f, -0.00322798f, 0.11560341f, 0.02535076f, 0.07129538f, 0.00594178f, 
    0.08989580f, -0.09028532f, 0.08406523f, -0.07745350f, -0.04087378f, 0.03431265f, 0.04982703f, 0.04581101f, 
    -0.00887334f, 0.09433051f, -0.01138874f, -0.09452780f, -0.08490935f, -0.12834787f, -0.20416820f, 0.25236404f, 
    0.03893177f, 0.04051165f, -0.01975310f, 0.02721759f, -0.04498074f, 0.00460279f, -0.02333087f, 0.03456128f, 
    0.06662901f, -0.05546309f, 0.02012035f, 0.11512345f, -0.08259422f, 0.04227640f, -0.01292989f, -0.02081690f, 
    -0.36596838f, -0.02486761f, -0.07704230f, 0.03838523f, -0.20977825f, -0.16485046f, -0.12925024f, -0.03127658f, 
    0.04049942f, -0.00729799f, -0.02962387f, -0.09081803f, 0.03348320f, -0.06720057f, 0.02395245f, -0.02909200f, 
    0.05567746f, -0.04236654f, 0.09019897f, -0.05037374f, -0.04470407f, 0.15215525f, -0.14300272f, -0.22817618f, 
    -0.22221382f, -0.11242437f, -0.00492611f, -0.01457097f, -0.02639032f, -0.15374574f, 0.03293691f, -0.01743606f, 
    -0.09327378f, -0.02046114f, 0.00342110f, 0.04480633f, -0.07824994f, 0.08787264f, -0.11565166f, -0.12378161f, 
    0.09378495f, 0.27913824f, 0.21916726f, -0.45965821f, 0.00417901f, -0.16569461f, -0.13993517f, -0.05646462f, 
    -0.17308891f, -0.06812945f, -0.07864524f, -0.08141027f, 0.00910800f, 0.12991990f, 0.06437119f, -0.06692916f, 
    -0.06834080f, 0.01103396f, -0.05446465f, 0.02267247f, -0.43291917f, -0.02798438f, 0.38202640f, 0.38993463f, 
    0.18037395f, -0.00266375f, -0.15492892f, -0.16944215f, 0.03246653f, -0.24100734f, -0.02426286f, -0.01100182f, 
    0.06517053f, 0.06336857f, 0.01470346f, -0.09530547f, 0.06812275f, 0.03662978f, -0.06405428f, -0.06436000f, 
    0.26007292f, -0.17739588f, -0.11831377f, 0.06448904f, 0.16471364f, 0.09613502f, -0.10109582f, 0.07263321f, 
    -0.08804255f, -0.16606177f, -0.11343785f, 0.07306893f, 0.02193327f, 0.07291456f, -0.02173650f, 0.06084218f, 
    0.09781484f, 0.08879115f, -0.00010649f, 0.08006299f, -0.12770651f, -0.09432155f, -0.22482264f, -0.02306562f, 
    0.19841443f, 0.08836541f, 0.07015367f, 0.07958995f, -0.00732646f, 0.02313722f, -0.04414575f, 0.03182422f, 
    0.04380763f, 0.03936060f, -0.04936341f, 0.06637150f, -0.01081724f, -0.02299413f, 0.01212457f, 0.04293921f, 
    -0.12725149f, -0.17668587f, -0.22893395f, -0.05740018f, 0.25539055f, 0.12039803f, 0.17786738f, 0.04214362f, 
    0.04082027f, 0.03454339f, -0.00560848f, 0.00156222f, 0.03320673f, 0.03024139f, -0.06980820f, 0.08269218f, 
    0.05978988f, 0.14363939f, 0.11766285f, -0.06961883f, 0.06136528f, -0.08347638f, -0.19721594f, -0.00628517f, 
    0.13099997f, 0.06762282f, 0.05480978f, -0.00318796f, 0.10929794f, 0.08276767f, -0.03112986f, 0.00952225f, 
    -0.00510061f, -0.02922755f, -0.00976841f, -0.01946663f, -0.05555308f, 0.02031693f, -0.03012447f, 0.03527723f, 
    -0.41497710f, -0.02148602f, 0.34248751f, -0.22860667f, 0.29693565f, 0.01863478f, 0.03128165f, -0.06032450f, 
    -0.10131161f, 0.13136157f, 0.11723860f, -0.08525617f, 0.02463267f, -0.14684446f, -0.08599118f, 0.01218008f, 
    0.03214004f, 0.06636108f, 0.06192141f, -0.10681704f, 0.00943065f, -0.08606061f, -0.13897918f, 0.06510969f, 
    0.21450789f, -0.02608653f, 0.01026654f, 0.00404899f, 0.07736342f, -0.01268595f, -0.02139911f, -0.02384191f, 
    0.05596833f, -0.08812988f, 0.00011089f, -0.00111994f, 0.05369390f, 0.03043086f, 0.02124603f, 0.00792330f, 
    -0.25482425f, 0.54907846f, -0.13106261f, -0.17258048f, 0.19780856f, 0.13576528f, -0.02386962f, -0.06943165f, 
    -0.13201720f, -0.08283976f, -0.12953512f, 0.05480839f, -0.08059430f, 0.03677095f, 0.06742465f, 0.00697862f, 
    -0.01423832f, 0.16579242f, -0.06478527f, 0.06349615f, -0.22175109f, -0.32261336f, -0.38926452f, 0.06595223f, 
    -0.21084966f, -0.00112439f, -0.03275270f, 0.03981096f, 0.02851095f, -0.02042750f, -0.11486155f, 0.05324937f, 
    0.02684506f, -0.09241801f, -0.09849405f, -0.03940881f, -0.00523118f, -0.10521623f, -0.08919916f, -0.02051185f, 
    -0.32408282f, 0.01911142f, -0.17777985f, 0.19026944f, 0.16155776f, -0.02065048f, -0.10607565f, 0.12252522f, 
    -0.06136577f, -0.00008772f, 0.04926866f, 0.03204894f, 0.05102142f, 0.02205955f, -0.13044694f, 0.08122670f, 
    -0.05988180f, -0.00520089f, -0.08801813f, -0.13348962f, -0.66855305f, 0.58589596f, -0.12769897f, -0.03664237f, 
    0.01281457f, 0.17013840f, 0.00983504f, 0.09222478f, -0.02680335f, 0.13843735f, -0.05569052f, -0.11782180f, 
    -0.01159498f, -0.05235312f, -0.02951178f, 0.00321436f, -0.01925016f, -0.04251561f, -0.02604410f, 0.05594827f, 
    -0.19350578f, -0.45450994f, 0.26495799f, 0.10068183f, 0.22660556f, -0.08704262f, 0.01723323f, -0.10649122f, 
    0.05704684f, -0.09951237f, 0.07206561f, 0.02017894f, 0.00745254f, 0.02637334f, 0.01712349f, 0.03191340f, 
    0.00442629f, 0.02315375f, -0.06374409f, 0.00706306f, -0.31797764f, -0.03080813f, -0.00211334f, -0.18173900f, 
    -0.31280285f, 0.12428799f, -0.00396357f, 0.08414074f, -0.00080844f, -0.11180258f, -0.05992619f, 0.02795022f, 
    -0.05612668f, -0.02653307f, -0.15893349f, -0.00503757f, 0.00768781f, 0.08975460f, -0.12764336f, -0.08912034f, 
    0.65443927f, 0.16993468f, -0.06854129f, -0.48271307f, -0.06484215f, 0.01875694f, -0.08368388f, 0.09811199f, 
    0.02884918f, 0.04961479f, -0.07359346f, -0.14143431f, 0.00462602f, -0.14020327f, -0.11471818f, -0.13087952f, 
    0.04106832f, -0.19650233f, 0.07286505f, 0.13649060f, -1.53319383f, 0.46837163f, 0.16797301f, -0.08806010f, 
    0.22390337f, 0.09062955f, -0.06549168f, 0.05631909f, -0.19608225f, -0.00806070f, -0.19109334f, -0.02481492f, 
    -0.10949131f, 0.02358554f, 0.17034817f, 0.05158503f, 0.02075899f, 0.10190353f, -0.07773691f, -0.09373491f, 
    -0.12165326f, -0.01218969f, -0.16439348f, -0.02587159f, 0.26178586f, 0.12693653f, 0.00312391f, -0.10698573f, 
    -0.03236756f, -0.03095144f, -0.01859517f, 0.13265729f, -0.01378545f, 0.14553247f, 0.06055361f, -0.01718506f, 
    0.03928140f, 0.06703874f, 0.06184931f, 0.00686170f, 0.14078614f, -0.08414747f, 0.27046925f, -0.01002800f, 
    0.22743055f, -0.14768481f, 0.13818507f, 0.06895716f, 0.05551171f, 0.08930302f, 0.05665465f, -0.01807128f, 
    0.00377998f, 0.03350713f, 0.03505502f, -0.04969874f, -0.06255428f, 0.04213640f, 0.01196106f, 0.04964919f, 
    -0.58834368f, 0.49277467f, -0.02205657f, -0.11285385f, 0.19463551f, 0.21857050f, 0.05112137f, -0.04742738f, 
    -0.10485774f, 0.03723601f, -0.13394363f, 0.01087611f, 0.03622180f, 0.02808855f, 0.03157946f, -0.05107236f, 
    0.06667472f, -0.06815926f, -0.01474684f, -0.04098036f, 0.04445114f, -0.05954530f, -0.15034863f, 0.03117422f, 
    0.17804277f, -0.00855592f, 0.04534301f, -0.00133482f, 0.00081250f, 0.06783613f, -0.02678701f, -0.03177593f, 
    0.00633243f, -0.08774197f, -0.01521962f, -0.00028911f, 0.00805428f, 0.05499523f, 0.01135710f, -0.00724833f, 
    0.06577575f, 0.01959788f, 0.32563326f, -0.10673647f, 0.23355995f, -0.04835937f, 0.06908605f, 0.15018058f, 
    0.05428031f, 0.07971032f, 0.12753426f, -0.00249592f, -0.11257476f, 0.07725932f, 0.13430828f, 0.03938802f, 
    -0.07244240f, -0.00149736f, -0.04413187f, -0.04722005f, 0.73310411f, 0.25547281f, -0.12444177f, -0.01801913f, 
    -0.10765339f, 0.02263829f, 0.02782450f, 0.04862564f, -0.16129319f, -0.15004088f, -0.20284046f, -0.07078104f, 
    0.04776902f, 0.11108659f, -0.05353649f, 0.11484609f, -0.08401973f, -0.03513616f, 0.02127253f, -0.03660750f, 
    -0.04405439f, 0.23627357f, -0.26623461f, 0.15864468f, 0.11666650f, 0.11906824f, 0.11862700f, -0.08315529f, 
    0.09965733f, 0.06683115f, 0.06143753f, -0.09874233f, -0.00854967f, -0.11773538f, 0.03343810f, -0.06205041f, 
    -0.08473561f, -0.05185825f, 0.01469010f, -0.02411043f, -0.40034083f, -0.19426008f, 0.08331492f, -0.00300238f, 
    -0.15614286f, -0.09296757f, -0.04367251f, -0.06902896f, -0.07129585f, -0.10082842f, 0.07543960f, 0.06989891f, 
    -0.04010168f, 0.06209210f, -0.00329384f, -0.02640861f, 0.01584747f, 0.00454054f, -0.05909643f, -0.06728932f, 
    0.23584285f, 0.11242900f, -0.07891359f, -0.07557966f, 0.09935352f, 0.08682906f, 0.02860524f, 0.04261476f, 
    0.06461432f, 0.03671483f, -0.10046503f, 0.02753211f, 0.03986079f, 0.00341219f, 0.05418078f, -0.04958394f, 
    0.06950170f, -0.07042155f, 0.01855984f, 0.05350756f, -0.16509785f, 0.22581422f, -0.08174498f, -0.09910575f, 
    0.16573152f, 0.10993045f, 0.04988685f, -0.01738472f, -0.06925847f, -0.06876328f, -0.16237554f, 0.05111665f, 
    0.05900625f, 0.08806022f, 0.08822259f, 0.04479694f, -0.06177871f, 0.06673497f, -0.06565835f, 0.02774117f, 
    -0.49034199f, -0.10238393f, 0.26065114f, 0.10728528f, 0.09122393f, -0.05211884f, 0.00396082f, 0.07329967f, 
    -0.04623216f, 0.01512655f, 0.00753388f, -0.03961269f, -0.16662034f, 0.01453068f, 0.16892488f, -0.02292085f, 
    -0.11152127f, 0.14988935f, -0.12326726f, -0.16279770f, 0.35431603f, 0.40532762f, 0.49610105f, -0.44062820f, 
    0.07898377f, -0.05381510f, 0.18505128f, -0.02105072f, -0.07264593f, -0.04491302f, 0.01774019f, -0.06616532f, 
    0.15874480f, -0.18300462f, -0.03071226f, -0.00955548f, 0.00242847f, -0.15243801f, 0.04221947f, -0.04494521f, 
    -0.47719309f, 0.27437559f, -0.04572048f, -0.08052488f, 0.10649705f, 0.15172553f, -0.02233922f, -0.06033315f, 
    -0.07976454f, -0.06205031f, -0.04373799f, 0.00935496f, -0.05503323f, 0.00051713f, -0.03380109f, 0.00160509f, 
    -0.05980420f, 0.10785352f, -0.01732757f, -0.05119378f, -0.09049081f, 0.11098026f, -0.10188682f, -0.13684984f, 
    0.10901374f, -0.13215558f, -0.08601077f, -0.04038586f, 0.03032552f, -0.02277045f, -0.09646932f, -0.01901498f, 
    -0.12818411f, -0.11050431f, 0.04074806f, 0.04491322f, 0.02801498f, 0.07847805f, -0.06199309f, -0.03122122f, 
    0.09764776f, 0.04170972f, -0.18412162f, -0.24360327f, 0.17271781f, 0.10311645f, 0.01470259f, -0.12758899f, 
    0.02592967f, -0.23042130f, 0.08253784f, -0.00947581f, -0.19668791f, -0.00145046f, 0.09879953f, 0.05135148f, 
    0.02367184f, 0.09631235f, -0.19958009f, -0.16517194f, 0.11897837f, 0.03104511f, 0.01686413f, -0.29303759f, 
    -0.31360111f, -0.09644939f, -0.07158491f, -0.03087874f, -0.08779281f, -0.07208677f, -0.04489455f, -0.02084443f, 
    -0.01178953f, -0.03468850f, -0.02481510f, -0.08501942f, -0.10093663f, -0.09420627f, -0.01954423f, -0.04490011f, 
    -0.17092612f, -0.01151078f, -0.23881859f, 0.17596218f, 0.02351771f, 0.10257170f, -0.02514132f, 0.04546266f, 
    -0.08957926f, 0.07701816f, 0.07926600f, -0.01957312f, -0.00740419f, -0.14564887f, -0.20689791f, 0.05780702f, 
    0.07898861f, 0.21593156f, 0.01215270f, -0.17716506f, -0.02319269f, -0.23945592f, 0.07640218f, -0.21058716f, 
    -0.08277141f, -0.04886032f, 0.16496290f, 0.03240735f, 0.13247502f, -0.06862034f, 0.07304662f, 0.10290912f, 
    -0.15519761f, 0.06995862f, -0.06504585f, -0.07260434f, -0.00616704f, 0.05045208f, -0.29265755f, -0.11106521f, 
    0.49808627f, 0.48090681f, 0.12160284f, -0.37266341f, -0.30775347f, 0.08979715f, -0.08125135f, -0.16711549f, 
    -0.20732775f, -0.14010566f, 0.09913251f, 0.02853089f, 0.11673407f, -0.13293809f, -0.00490762f, 0.05114656f, 
    0.03020782f, -0.27116841f, -0.00190935f, 0.01185845f, 0.28474784f, 0.27422550f, -0.04531989f, -0.15145083f, 
    -0.04163261f, 0.15717354f, 0.08961876f, -0.00953926f, 0.05789127f, -0.00580501f, -0.13322404f, -0.07140237f, 
    0.01295260f, -0.02104009f, 0.00424653f, -0.08941638f, 0.00921700f, -0.18685174f, 0.08545812f, -0.01950390f, 
    -0.45376968f, -0.08918023f, -0.03195346f, 0.07323754f, -0.07902919f, 0.00159602f, -0.07035580f, -0.01935145f, 
    -0.05020211f, -0.04608434f, -0.02602696f, -0.10281301f, 0.08567327f, -0.01391296f, -0.07413969f, 0.00693277f, 
    0.17238855f, 0.07582663f, 0.04309870f, -0.13389452f, 0.17433859f, 0.05711851f, -0.14689831f, 0.10588266f, 
    -0.34378466f, 0.11816767f, 0.00629656f, 0.06114149f, 0.18230647f, 0.01582539f, -0.03590387f, -0.08086446f, 
    0.06058493f, -0.05297525f, -0.02321611f, -0.04020930f, -0.01467510f, -0.20733540f, 0.11657698f, 0.05803936f, 
    -0.28550363f, 0.04098599f, 0.01001618f, -0.08000544f, -0.25567743f, 0.01723748f, -0.17261036f, -0.13862957f, 
    -0.13996115f, -0.12779298f, -0.11870445f, -0.10746402f, -0.00959078f, 0.05329111f, 0.04520790f, 0.09269304f, 
    -0.02793976f, -0.00521459f, -0.11696445f, -0.03564562f, -0.00152536f, 0.05829664f, -0.18017572f, 0.16507234f, 
    0.04614165f, -0.04250511f, 0.04240574f, 0.03976844f, 0.02516556f, 0.11108219f, 0.00233164f, 0.05146883f, 
    0.04072183f, -0.10393412f, -0.15190014f, 0.07618458f, 0.07774210f, 0.02923521f, 0.13732998f, -0.01283693f, 
    -0.20053278f, 0.00205594f, -0.02657996f, 0.17113626f, 0.06679122f, 0.03099272f, 0.00212702f, 0.03353419f, 
    -0.02624427f, 0.01369186f, -0.00229747f, -0.01570759f, 0.00473178f, -0.08984190f, -0.08563560f, 0.01144766f, 
    -0.04060017f, 0.03801591f, -0.01772744f, -0.06472182f, -0.03042303f, -0.00990898f, -0.19251537f, 0.11237991f, 
    0.19854888f, -0.04506493f, -0.03314501f, 0.02530464f, 0.03917575f, 0.03541010f, -0.03976629f, -0.00824491f, 
    -0.01194395f, -0.10394726f, -0.03115167f, -0.13268952f, -0.02088500f, -0.00711565f, 0.02756712f, -0.01479757f, 
    -0.36160913f, -0.29173991f, 0.13970891f, 0.09647217f, 0.03519855f, -0.00398296f, 0.01212215f, -0.16829060f, 
    -0.01777197f, -0.08298015f, 0.08361600f, 0.10967807f, -0.01102439f, 0.02752783f, 0.04931870f, 0.02081245f, 
    -0.01553659f, 0.08277430f, -0.06989209f, -0.13850622f, 0.31533000f, 0.10392221f, 0.17169496f, -0.17004529f, 
    0.25409713f, -0.13842373f, 0.12894742f, 0.04284796f, -0.02173232f, 0.12109076f, -0.03527046f, 0.01373816f, 
    0.05386049f, 0.03629075f, 0.00575652f, 0.05099222f, -0.08057135f, 0.02364868f, 0.07593627f, 0.03003936f, 
    0.02932764f, 0.02267608f, -0.07150273f, -0.04134857f, 0.14967541f, -0.06773286f, -0.00468510f, -0.02257487f, 
    0.01010225f, -0.06867757f, 0.08010466f, 0.00995957f, -0.04019384f, -0.09934950f, 0.04897385f, -0.04590377f, 
    -0.09610376f, -0.02703077f, -0.05058458f, -0.12269489f, 0.02261361f, -0.02918384f, -0.06992739f, -0.05476143f, 
    0.22417198f, 0.06405538f, 0.00825864f, -0.02887415f, -0.03267441f, -0.02812123f, -0.02271034f, 0.06393341f, 
    0.09313194f, 0.04890906f, 0.05635230f, -0.07433012f, 0.01133244f, 0.02054657f, 0.03147768f, 0.02169586f, 
    -0.05081965f, -0.27951965f, 0.08343010f, -0.01362678f, 0.29672143f, -0.09471565f, 0.09492902f, 0.00623480f, 
    0.05603091f, -0.08681976f, 0.08322244f, 0.01919576f, -0.07316237f, -0.04884433f, 0.06343047f, -0.10038631f, 
    -0.02830927f, 0.09607025f, -0.08800172f, -0.02296806f, -0.54123241f, 0.60226196f, 0.19881277f, -0.12350354f, 
    0.15920703f, 0.08284862f, -0.00286557f, -0.08096460f, -0.00924082f, -0.10863201f, -0.21460076f, 0.04148478f, 
    -0.03761124f, -0.08283936f, 0.07653974f, -0.09882619f, 0.00613932f, 0.05649567f, 0.05003608f, -0.08980856f, 
    0.40946090f, 0.34901226f, -0.12222982f, -0.01708077f, -0.12859838f, 0.12370105f, 0.10304469f, -0.03924327f, 
    -0.11453804f, -0.09346522f, -0.12231076f, -0.06969932f, -0.08583196f, 0.05480029f, -0.15291291f, -0.13641495f, 
    -0.07488780f, 0.07194352f, 0.02854123f, 0.04320066f, -0.54527795f, -0.26515481f, -0.01602327f, -0.58597106f, 
    -0.13632125f, 0.20306839f, 0.37778240f, 0.09659857f, 0.07397246f, 0.02296224f, -0.20168337f, -0.01083936f, 
    -0.09830229f, 0.07266249f, 0.04627419f, -0.00019744f, 0.22190765f, 0.09496982f, -0.15397732f, -0.16058351f, 
    0.02198814f, 0.05619843f, -0.08690973f, -0.02497147f, 0.00830269f, 0.04822258f, 0.02232779f, -0.04739945f, 
    -0.02832134f, -0.00935181f, 0.08773932f, -0.02186205f, -0.10946454f, -0.07059029f, 0.14548674f, 0.02733327f, 
    -0.12187366f, 0.00149591f, -0.01454050f, -0.00336638f, 0.11815951f, -0.57342094f, -0.25672439f, 0.15823960f, 
    -0.34145901f, -0.05561399f, -0.04436374f, 0.09598885f, -0.04986875f, -0.04467361f, -0.05114333f, -0.01767603f, 
    -0.14352371f, 0.01269254f, -0.04766719f, 0.01033102f, 0.12777188f, -0.04682856f, 0.06975553f, 0.06093302f, 
    0.09741849f, 0.12093493f, 0.05577086f, 0.12369258f, 0.02652003f, -0.04615002f, -0.06802353f, -0.13658203f, 
    -0.06383339f, 0.06204376f, 0.04234543f, -0.00207983f, -0.01505068f, 0.06094274f, 0.05213736f, 0.04693173f, 
    -0.02331198f, -0.01864024f, -0.04597213f, -0.06847138f, 0.11478841f, 0.06337986f, 0.08155395f, -0.04686186f, 
    -0.14794049f, 0.14354457f, -0.13856941f, -0.12754858f, 0.07207170f, 0.04286981f, -0.00253357f, -0.06991873f, 
    0.01080280f, -0.05050569f, -0.01922294f, -0.02118470f, 0.02705320f, -0.20054151f, -0.10920439f, -0.10248579f, 
    0.12807788f, 0.11292494f, 0.39285573f, 0.07241850f, 0.17418687f, -0.05282432f, -0.00069216f, 0.05263200f, 
    0.02603478f, 0.11183122f, 0.02624067f, -0.00975923f, -0.00882037f, -0.02487607f, -0.03366075f, 0.01155672f, 
    -0.03215889f, -0.10160120f, -0.07090257f, -0.16645652f, 0.07847115f, -0.08413658f, 0.09093682f, 0.14277634f, 
    0.28506601f, -0.02403162f, 0.04847271f, 0.11064725f, 0.07102625f, 0.09827595f, 0.02437454f, -0.01490363f, 
    -0.03535675f, -0.02270499f, 0.01507101f, -0.07187650f, -0.09368476f, -0.04937491f, -0.13854809f, -0.09984355f, 
    0.07224812f, 0.15875131f, -0.14618064f, 0.12855177f, 0.10340679f, -0.00528983f, 0.05521626f, 0.00860958f, 
    0.07992291f, 0.08790809f, 0.05844774f, 0.00180855f, -0.00407946f, -0.00474202f, 0.02829192f, 0.09892671f, 
    0.19161099f, 0.18628629f, 0.11036939f, 0.19129035f, -0.01947798f, 0.02472709f, 0.15284754f, 0.10139248f, 
    0.10319211f, -0.02875795f, 0.07925660f, -0.02508160f, 0.06550797f, 0.11179184f, -0.02429926f, -0.00567018f, 
    0.01672132f, 0.02531966f, -0.00100020f, 0.05676945f, 0.06003230f, -0.14353900f, 0.09372921f, 0.21293689f, 
    0.05064065f, -0.01202005f, 0.19894718f, 0.03523979f, 0.06210289f, -0.11553165f, 0.03927693f, -0.11020848f, 
    -0.06579176f, -0.21328998f, -0.02841392f, -0.04519519f, -0.02193292f, 0.03167466f, -0.01993577f, -0.01964693f, 
    0.02018321f, -0.11089703f, -0.02678802f, -0.11792547f, 0.09916820f, -0.05272801f, 0.19599824f, 0.06381445f, 
    0.05267976f, -0.13784002f, -0.03401864f, -0.04538208f, 0.03337756f, 0.07948114f, 0.05778111f, -0.05358985f, 
    -0.12606953f, -0.01595811f, -0.03208259f, 0.06035955f, 0.07070046f, 0.04556122f, -0.01704650f, -0.02658806f, 
    -0.00912413f, 0.07740425f, -0.10789355f, 0.04524185f, 0.01466580f, 0.10799547f, 0.07239057f, -0.02593599f, 
    0.03184109f, 0.05838882f, -0.06606127f, 0.06287071f, -0.03186485f, 0.01128202f, 0.03089705f, 0.02304121f, 
    -0.10711718f, -0.11793423f, -0.04371016f, -0.07273057f, 0.03678498f, 0.04499434f, 0.01647549f, -0.00623250f, 
    -0.00053339f, 0.01731427f, 0.04713977f, 0.01876199f, -0.00475572f, 0.01942889f, -0.03411053f, -0.11755037f, 
    0.05085013f, -0.04072459f, -0.00119125f, 0.08873198f, -0.00778534f, -0.05289481f, -0.02036548f, -0.05580651f, 
    0.10398554f, 0.05014810f, -0.18554051f, 0.01608323f, 0.02658368f, 0.08440886f, -0.02113141f, 0.04985254f, 
    0.03496628f, 0.02021802f, 0.03351848f, -0.00956769f, 0.02590990f, -0.00463629f, 0.07082595f, 0.02294493f, 
    0.05300980f, -0.03696786f, -0.12376557f, 0.04692184f, 0.02941396f, -0.02408222f, -0.04756954f, -0.09546982f, 
    -0.05418057f, 0.03931419f, -0.01825207f, -0.02723335f, 0.08577028f, -0.00505825f, -0.12293845f, -0.07948790f, 
    0.00645935f, -0.14956157f, 0.04309099f, -0.08930128f, -0.17916183f, -0.05326021f, -0.01666465f, -0.05279283f, 
    0.09706794f, -0.12687598f, -0.19949764f, 0.06096495f, 0.01126387f, 0.08277371f, -0.05052958f, 0.00281333f, 
    -0.01956220f, -0.03630851f, 0.08124322f, -0.03169471f, -0.03979828f, -0.08082052f, 0.03571297f, 0.01523061f, 
    -0.17639449f, 0.00234701f, -0.03316847f, -0.06291795f, -0.07992215f, -0.06458857f, -0.24314851f, -0.12051282f, 
    0.09779122f, 0.02637099f, 0.02332520f, 0.03618442f, -0.05901189f, 0.01038050f, 0.05287452f, 0.04465567f, 
    0.10385226f, -0.01601878f, -0.00091959f, 0.07595117f, -0.15077403f, -0.01922381f, -0.09073261f, 0.05325533f, 
    0.01466262f, 0.09411022f, 0.17775887f, -0.02801229f, 0.06086972f, -0.20383205f, -0.01224000f, -0.01380949f, 
    0.05444308f, 0.15543821f, 0.04557897f, -0.02852544f, 0.02141805f, -0.09354279f, 0.02960000f, 0.03307340f, 
    -0.03137711f, 0.01628118f, -0.02541190f, -0.00374920f, 0.13890882f, 0.14055958f, 0.07642319f, 0.10967316f, 
    -0.01608116f, 0.03168824f, -0.05111310f, -0.06274432f, -0.05601082f, 0.10663606f, 0.05791079f, -0.01822601f, 
    0.03962636f, 0.05007241f, 0.01550645f, 0.01136753f, -0.04962720f, 0.01231567f, -0.05585802f, -0.05388718f, 
    0.16500731f, 0.17981082f, 0.03228854f, 0.06325081f, -0.02455736f, 0.03053211f, -0.01788473f, -0.09264221f, 
    -0.03749321f, 0.06592815f, 0.11630421f, -0.02916943f, -0.00602115f, 0.04896580f, 0.06763355f, 0.08780722f, 
    0.00474156f, -0.08403823f, -0.07695618f, -0.02376798f, 0.02951719f, 0.15136954f, 0.20533518f, 0.24062884f, 
    0.11764135f, -0.17782946f, -0.03681159f, -0.06171481f, 0.03062900f, 0.07345095f, 0.06166770f, 0.04069134f, 
    -0.00030180f, 0.03298132f, 0.03827481f, -0.00381280f, -0.02136109f, -0.07273027f, 0.02906256f, -0.08398234f, 
    0.07848120f, 0.05207201f, -0.11932842f, 0.02487704f, -0.01389766f, 0.05735816f, 0.16474336f, -0.06044773f, 
    0.01361251f, 0.01754817f, 0.02024286f, 0.02433117f, 0.01035495f, -0.06575496f, 0.02514143f, -0.04936045f, 
    -0.05558043f, 0.00763451f, -0.09469161f, -0.08747951f, -0.01794486f, 0.06905919f, 0.17747566f, 0.12441757f, 
    0.10503183f, -0.09412006f, 0.04547735f, -0.05996489f, -0.05359804f, 0.11245404f, 0.05447998f, 0.03990378f, 
    0.00027511f, 0.02124984f, -0.03496898f, -0.00781195f, 0.03932157f, -0.02872569f, -0.05698093f, 0.10969332f, 
    0.05197896f, -0.15857723f, -0.00098662f, 0.42764923f, 0.22676466f, -0.03414685f, -0.09677515f, 0.05554300f, 
    -0.43218586f, -0.14501840f, -0.14426841f, 0.04053118f, 0.08161793f, -0.05468304f, -0.01944179f, -0.03983826f, 
    -0.08685496f, 0.03890444f, -0.16826606f, -0.00012805f, 0.04061896f, -0.00448610f, 0.01524544f, -0.02274282f, 
    -0.00712197f, 0.09460252f, 0.04442243f, 0.02451774f, -0.00081035f, 0.03370538f, 0.06408705f, 0.05731937f, 
    0.03235844f, -0.05449926f, 0.05422475f, 0.10198381f, 0.03336947f, -0.02144223f, 0.00727159f, 0.07438322f, 
    0.13800730f, -0.08578681f, 0.23351318f, -0.20141649f, -0.04206128f, 0.05812082f, -0.03151550f, 0.03231060f, 
    -0.07237500f, -0.06924329f, -0.02241339f, -0.02258847f, 0.00185084f, -0.03250712f, -0.01144279f, 0.07285549f, 
    -0.04520699f, -0.07474666f, -0.16605920f, -0.23434353f, -0.04128816f, -0.09372323f, 0.08110633f, -0.25507063f, 
    -0.10407038f, 0.08109191f, 0.04697850f, -0.05276525f, 0.08245555f, 0.03271241f, 0.01613456f, 0.05311689f, 
    -0.08724096f, -0.00209834f, -0.03985206f, -0.10594031f, -0.08154969f, 0.00623240f, -0.05144218f, -0.07523006f, 
    -0.25678971f, 0.20426823f, -0.33449826f, -0.22105925f, 0.04881697f, 0.04342077f, -0.00109357f, 0.06810643f, 
    0.05380217f, 0.04546736f, 0.02177187f, 0.02215890f, 0.04179264f, 0.01480195f, 0.00312177f, 0.02620156f, 
    0.09639253f, 0.10538450f, 0.01240342f, 0.12663397f, 0.01687453f, -0.04453549f, -0.08980955f, 0.00221053f, 
    -0.11155008f, 0.01405396f, -0.01704464f, 0.04008003f, 0.02627007f, -0.00287923f, 0.02666250f, 0.02020030f, 
    -0.04411668f, -0.09343095f, 0.01887808f, 0.10408307f, 0.01623981f, -0.07242370f, -0.01515067f, 0.05852642f, 
    -0.19194463f, 0.05794369f, -0.07770578f, 0.17517439f, -0.08417547f, 0.18584219f, -0.07646576f, -0.00841255f, 
    -0.13522381f, -0.00479884f, 0.19106075f, -0.12125894f, 0.08759248f, -0.00086982f, 0.04954841f, -0.04133544f, 
    0.02961716f, -0.01975774f, -0.41226077f, -0.02089168f, 0.22414243f, -0.39798224f, 0.21820034f, -0.24380049f, 
    -0.14455158f, 0.09590565f, 0.10141850f, 0.00775127f, 0.06339452f, -0.07477886f, 0.07339428f, -0.01378320f, 
    -0.05559004f, 0.01127594f, -0.03688550f, -0.06208758f, -0.21806173f, -0.12846151f, -0.17710878f, 0.02025269f, 
    0.07962561f, 0.02186091f, 0.08881619f, 0.20520990f, 0.09720995f, -0.22511813f, -0.00522310f, -0.04913911f, 
    -0.05741446f, -0.06669785f, -0.01067865f, -0.03903009f, -0.00447352f, 0.01011537f, 0.07757542f, -0.03320421f, 
    -0.01026481f, -0.01674690f, -0.04022331f, -0.05684758f, 0.13776967f, 0.12908478f, -0.09272340f, 0.37456414f, 
    0.08492654f, 0.15183781f, 0.13894014f, 0.04601820f, 0.06244668f, 0.12060617f, 0.04974925f, -0.04121942f, 
    0.00316485f, 0.03945171f, 0.00961019f, 0.02932800f, 0.08495086f, -0.09224621f, 0.11577601f, 0.02193540f, 
    0.03975572f, -0.17478609f, 0.16639727f, 0.04358887f, 0.03046693f, -0.14967649f, -0.04479194f, -0.01594504f, 
    0.02490875f, -0.04807822f, -0.01092283f, -0.01632555f, -0.06407247f, 0.00679683f, 0.02599875f, 0.04975237f, 
    0.02349430f, 0.02383564f, -0.03314833f, -0.03870691f, -0.08085389f, 0.01768019f, 0.12188586f, 0.07931149f, 
    0.05832781f, -0.06746527f, 0.02128435f, 0.01320421f, -0.07913937f, 0.02863919f, -0.01593793f, -0.00811547f, 
    0.00038011f, 0.06161799f, 0.00098663f, 0.05218479f, 0.06526884f, -0.04032330f, 0.00395849f, 0.16822563f, 
    -0.00616896f, 0.06579883f, 0.06312004f, 0.08010887f, 0.15884458f, 0.15963160f, 0.17769940f, 0.04254668f, 
    -0.02310274f, 0.11191048f, 0.02805117f, 0.05263243f, -0.03611594f, -0.02603811f, 0.03217302f, 0.00048688f, 
    -0.08307613f, -0.09691201f, -0.04248770f, -0.07136593f, 0.32802135f, -0.53389668f, -0.14700700f, -0.14287685f, 
    -0.12829027f, 0.12320433f, -0.13675155f, -0.04119759f, 0.05251012f, -0.07884441f, 0.03276357f, -0.10588874f, 
    0.02319359f, -0.09204511f, 0.09069550f, -0.02935484f, -0.12219463f, -0.00121153f, -0.17776789f, 0.08461343f, 
    -0.30314770f, -0.23788187f, 0.17170799f, -0.32200873f, -0.12732853f, -0.00052971f, 0.08046293f, -0.04398268f, 
    -0.02624317f, 0.02721650f, -0.08628459f, -0.05542466f, 0.10044613f, 0.15230507f, 0.03561256f, -0.11127453f, 
    -0.01664248f, -0.03521599f, -0.13046791f, -0.07327028f, 0.00004752f, -0.08263467f, -0.03500799f, 0.01546680f, 
    0.12675217f, 0.01682355f, 0.01773747f, 0.05305560f, -0.03736340f, 0.01513898f, 0.02930159f, 0.03011565f, 
    0.03455659f, -0.05236076f, 0.06586497f, -0.01030724f, 0.03587600f, -0.05207290f, -0.03794248f, 0.00062201f, 
    -0.30259615f, -0.11229801f, 0.04541083f, -0.00994439f, 0.02186108f, 0.02539639f, 0.00463504f, -0.11236727f, 
    -0.02755242f, 0.00987322f, 0.00324531f, 0.02585626f, -0.04526398f, -0.07843114f, 0.00727383f, -0.04657054f, 
    0.04030129f, 0.10726094f, 0.02965632f, 0.09907467f, -0.02172962f, 0.01050210f, 0.19577909f, 0.03578487f, 
    0.08220045f, -0.18489856f, -0.07604676f, -0.09749177f, -0.00972945f, -0.03136773f, 0.03011299f, 0.00254976f, 
    -0.13490473f, -0.01504463f, 0.00578176f, 0.02873637f, 0.07060156f, 0.02482046f, 0.04430791f, -0.00205057f, 
    0.14636448f, -0.11459187f, 0.06002989f, -0.19139603f, 0.16113192f, 0.02392135f, 0.00355999f, 0.21044697f, 
    0.06038086f, -0.06394020f, -0.00067762f, -0.02685596f, -0.03352426f, 0.08037162f, -0.05821432f, 0.00834062f, 
    -0.20595196f, -0.05277540f, -0.07416721f, -0.16903925f, 0.04605455f, -0.48974729f, -0.23470141f, 0.07444138f, 
    -0.44444665f, 0.07434627f, -0.02898967f, 0.06859142f, -0.05682863f, 0.02010802f, 0.07803575f, 0.01150579f, 
    -0.16821422f, 0.02201517f, -0.13200106f, -0.04855116f, -0.04509700f, 0.04507504f, -0.03136284f, 0.13585356f, 
    0.03170177f, -0.11410005f, 0.02459336f, 0.29925659f, 0.15760924f, -0.14309596f, 0.03525484f, 0.13201495f, 
    -0.22662064f, -0.08971334f, -0.16860844f, 0.04484964f, 0.04298975f, 0.04409428f, 0.04691963f, -0.06325804f, 
    -0.08086837f, 0.04979400f, -0.11860242f, -0.08789740f, -0.16906877f, -0.08584683f, 0.10231260f, -0.04422620f, 
    -0.02334512f, -0.06590746f, 0.01689010f, -0.05467635f, 0.05587088f, -0.14608337f, -0.02090700f, -0.01964331f, 
    0.02919922f, 0.02902176f, -0.05324418f, -0.12155212f, 0.01620695f, -0.01462909f, -0.02879740f, 0.03502426f, 
    -0.01998669f, -0.10028311f, 0.10980143f, 0.24619032f, 0.05601695f, -0.19868830f, -0.07124731f, 0.00001199f, 
    0.15655009f, -0.09046994f, 0.01994731f, -0.00182484f, -0.01686072f, 0.05803839f, -0.00724215f, -0.10100908f, 
    -0.17212325f, -0.06421564f, 0.09484830f, -0.01960634f, -0.00465174f, -0.06055951f, -0.15992670f, -0.08216859f, 
    -0.01613277f, 0.03333538f, -0.00530245f, -0.01930826f, 0.02225468f, -0.03211426f, 0.09291140f, -0.08083423f, 
    -0.01959813f, 0.00668645f, -0.01051548f, -0.03799625f, -0.12072467f, -0.05563112f, -0.06270347f, 0.03654863f, 
    0.08554728f, -0.00285904f, 0.07024700f, -0.10037185f, 0.00556383f, 0.08745407f, 0.01982387f, 0.04311976f, 
    -0.03381683f, 0.01861761f, -0.05166344f, -0.09878922f, 0.10762374f, 0.03534707f, 0.02779416f, 0.04562600f, 
    -0.05746198f, -0.14191262f, -0.07724767f, -0.03039043f, -0.04396072f, -0.14686041f, 0.01042193f, -0.08908359f, 
    -0.31562239f, -0.03862503f, -0.09197248f, 0.00118088f, 0.11102705f, -0.05786070f, -0.05510502f, 0.03743202f, 
    0.02091781f, -0.09764403f, -0.01319557f, 0.07956192f, 0.10390950f, -0.21412136f, -0.04940413f, 0.19480419f, 
    -0.10844623f, -0.18513723f, -0.12949589f, 0.04200589f, -0.21072525f, 0.08229288f, -0.04862342f, 0.01703039f, 
    -0.04318444f, -0.00429885f, -0.10117503f, -0.15395281f, -0.06034517f, 0.09062401f, 0.06904796f, -0.02034752f, 
    -0.12925321f, 0.00047147f, -0.13907562f, -0.11398605f, -0.16144733f, -0.28506714f, 0.04142284f, -0.11126176f, 
    -0.07316828f, 0.04156431f, -0.01501287f, 0.05169164f, -0.02822701f, 0.10868930f, -0.01188074f, -0.01993421f, 
    0.02350363f, -0.06897926f, -0.08153716f, -0.02850745f, 0.00823780f, 0.04547583f, -0.00825061f, 0.04677995f, 
    0.13685033f, -0.10257288f, 0.01347082f, -0.03929360f, -0.07986489f, 0.20274009f, -0.00863364f, -0.03459154f, 
    -0.01067831f, -0.00231986f, 0.03785648f, -0.00422248f, -0.09596922f, -0.06373511f, -0.03176224f, -0.11392082f, 
    -0.05225826f, -0.20152189f, -0.11674226f, -0.08474045f, -0.41357306f, 0.29743409f, -0.09764153f, -0.36232752f, 
    -0.37112525f, 0.07658333f, 0.02189762f, -0.02677996f, 0.06427397f, 0.08956454f, 0.02447776f, 0.03989873f, 
    0.01079599f, 0.01514348f, -0.00958770f, -0.04705562f, 0.06738752f, 0.08912213f, -0.20923442f, 0.07742035f, 
    0.02976989f, -0.01292113f, -0.10508100f, -0.05853468f, -0.02306183f, 0.03314342f, 0.03444079f, 0.10231353f, 
    -0.02633980f, -0.01492546f, -0.02709761f, -0.01012245f, 0.04435105f, -0.18079267f, 0.06862994f, 0.04471563f, 
    -0.06230965f, 0.00069992f, -0.11744882f, -0.03073682f, 0.10298152f, -0.06058588f, 0.10692227f, -0.01139759f, 
    -0.02333917f, 0.06253632f, -0.03312086f, 0.04296979f, -0.06271058f, 0.06783954f, -0.06576351f, -0.10122075f, 
    0.05043565f, -0.04332951f, -0.00735002f, -0.04987043f, 0.03018252f, -0.06083024f, -0.09565002f, -0.09986762f, 
    0.04764840f, -0.01670449f, 0.05347759f, -0.07963041f, -0.00008892f, 0.01661070f, 0.00764423f, 0.02475504f, 
    -0.05035543f, 0.01972359f, -0.01773899f, 0.00745794f, 0.09762207f, -0.03988597f, -0.03033717f, 0.01583872f, 
    -0.04561726f, -0.06692145f, -0.11848434f, -0.09715493f, 0.07742522f, 0.09612101f, 0.27429113f, 0.07357460f, 
    0.07916468f, -0.04985437f, 0.12628123f, 0.00331374f, 0.06894877f, 0.07002093f, 0.00544702f, -0.01217257f, 
    -0.04088138f, 0.00199256f, -0.06067121f, -0.03136029f, -0.03498008f, -0.04194047f, -0.02187361f, 0.06016062f, 
    0.10135891f, -0.10907798f, -0.03137060f, 0.14079376f, 0.33668980f, -0.20489836f, 0.02169469f, 0.06357870f, 
    0.10544997f, -0.00025318f, 0.00238025f, 0.01723775f, -0.00647725f, -0.00169585f, 0.05834715f, -0.03889490f, 
    -0.04842445f, -0.09531463f, -0.07214899f, -0.01057609f, 0.23863198f, -0.03641669f, -0.20217043f, 0.32757658f, 
    0.00482704f, 0.07457503f, 0.03710450f, 0.11577105f, 0.02107812f, -0.00188431f, 0.07101603f, -0.04181754f, 
    0.01373720f, 0.01621634f, 0.03105612f, 0.07902709f, 0.18145265f, 0.14081001f, 0.07085859f, 0.14036956f, 
    -0.09603528f, -0.02776628f, 0.07505754f, 0.03781630f, 0.09424537f, -0.14268845f, 0.00316435f, 0.03463189f, 
    0.11644971f, -0.02167858f, 0.02694577f, -0.05440038f, -0.05281662f, -0.08261709f, -0.05029842f, -0.02659159f, 
    -0.04821644f, -0.03514005f, 0.03609600f, -0.23795855f, -0.10158610f, -0.03760452f, 0.04019372f, 0.12276742f, 
    0.06971960f, -0.13394490f, -0.04213682f, -0.08768231f, -0.16153251f, -0.11392045f, -0.00037526f, 0.03886183f, 
    -0.03613012f, 0.05298672f, -0.07395817f, 0.03228944f, 0.00527919f, 0.01694095f, 0.04710020f, 0.05894147f, 
    -0.02879858f, 0.13588659f, -0.05611257f, -0.04298365f, 0.04923084f, -0.01190384f, -0.05741687f, 0.02402062f, 
    0.14512406f, 0.08692797f, -0.00693658f, -0.01798143f, 0.04282543f, -0.02788492f, -0.03022015f, 0.06860196f, 
    0.12682196f, -0.07221785f, -0.01121626f, 0.10150686f, -0.03119705f, -0.59068209f, -0.21173741f, 0.10626423f, 
    -0.13233335f, -0.08654782f, -0.01885423f, 0.06855775f, -0.39282399f, 0.04636946f, -0.13033524f, 0.01778517f, 
    0.00567186f, -0.02195450f, -0.19302693f, -0.11066547f, -0.11479056f, 0.04418365f, 0.07243127f, 0.16927658f, 
    0.53797549f, -0.70435220f, -0.16979662f, -0.01614545f, -0.30948815f, 0.01506145f, -0.34782162f, -0.03450092f, 
    -0.03004858f, -0.12868321f, 0.11111888f, -0.10985086f, -0.03029000f, -0.05604601f, 0.10575394f, 0.03568014f, 
    -0.02365716f, 0.02809926f, -0.14856584f, -0.01239871f, 0.10565559f, 0.06499721f, 0.01399316f, -0.01622363f, 
    -0.05412730f, 0.05079415f, 0.02304742f, 0.01984655f, 0.03809750f, 0.04842808f, 0.10117277f, 0.02297273f, 
    -0.12073009f, -0.10044950f, -0.00277510f, 0.01634767f, -0.04816030f, 0.02686203f, 0.00374663f, 0.07824548f, 
    -0.08934792f, -0.16580965f, -0.13106161f, 0.16471876f, -0.00967295f, 0.06714775f, 0.10536443f, 0.01793871f, 
    -0.03735563f, 0.03406861f, -0.09252340f, -0.00157491f, 0.09541123f, -0.04495953f, 0.01902284f, 0.15771389f, 
    -0.05487212f, 0.12468718f, -0.06479742f, 0.06127563f, -0.29987475f, -0.03514043f, 0.20030485f, 0.14562765f, 
    -0.04000482f, -0.02682742f, 0.01358505f, -0.04321244f, -0.03865885f, 0.00244804f, 0.03400714f, -0.16156293f, 
    0.06932546f, 0.12051098f, -0.06916963f, 0.15625516f, -0.12024406f, -0.02917604f, -0.07644545f, 0.01895744f, 
    -0.02196800f, -0.00723478f, 0.03976207f, -0.12794065f, -0.19407986f, -0.01501429f, 0.03113154f, -0.01723009f, 
    0.00476549f, 0.09183329f, 0.08245772f, 0.04197939f, -0.05427887f, -0.03546879f, -0.00985662f, -0.02726441f, 
    0.04802460f, -0.01465942f, -0.00905736f, 0.05617560f, 0.00279501f, 0.03870661f, 0.06860512f, -0.09326890f, 
    -0.01815868f, -0.03219648f, 0.17927174f, 0.03339628f, -0.08747251f, 0.00771213f, 0.13938303f, 0.01467254f, 
    -0.04293585f, 0.08307854f, 0.03617050f, 0.09868257f, 0.03109444f, -0.00094661f, 0.12084103f, 0.02469573f, 
    0.17085217f, 0.01351921f, 0.22956315f, -0.13767187f, -0.07405061f, 0.09963011f, 0.12915127f, -0.08097779f, 
    -0.07668500f, -0.08998894f, -0.04329236f, 0.02080770f, -0.01812293f, -0.04260290f, -0.00078798f, -0.01163076f, 
    0.02190118f, -0.03846699f, 0.06398066f, 0.15752704f, -0.02290507f, -0.04041062f, -0.19716062f, 0.00625432f, 
    0.08306002f, -0.00372599f, 0.10938222f, -0.04649807f, 0.09464995f, 0.05899543f, 0.01453491f, -0.01145864f, 
    -0.05899998f, -0.07922668f, -0.03157224f, 0.02382115f, 0.07292325f, 0.12099855f, -0.03801678f, 0.01603786f, 
    -0.12400252f, 0.02518037f, -0.00193599f, 0.10010879f, -0.04888267f, 0.08602239f, 0.03054966f, -0.02844807f, 
    0.00151951f, 0.03267210f, -0.01163190f, 0.03535357f, -0.00713522f, -0.01511876f, 0.02963667f, -0.21523914f, 
    -0.05069407f, -0.07651473f, -0.11916559f, -0.13405874f, 0.00219815f, 0.03713410f, 0.26594853f, 0.12474348f, 
    -0.05634494f, -0.02002520f, -0.03874248f, 0.07886838f, 0.03353634f, -0.05879727f, 0.04830140f, 0.00539227f, 
    0.00793936f, 0.02068389f, 0.02181857f, 0.07672948f, 0.04403585f, -0.22980519f, -0.26322174f, -0.33007416f, 
    0.14216939f, 0.04170572f, 0.13360339f, -0.18668224f, -0.04386951f, 0.04549184f, 0.04320052f, 0.04103261f, 
    -0.03617208f, -0.02466181f, 0.02192415f, -0.00579763f, -0.00019458f, -0.05038743f, -0.06810163f, -0.04272084f, 
    -0.02788220f, 0.01655714f, 0.05876928f, -0.01020348f, -0.54040658f, 0.01422228f, -0.52206683f, -0.25212863f, 
    -0.10489294f, 0.02437582f, 0.00311962f, -0.04586463f, -0.00741048f, 0.09305125f, 0.04757755f, 0.01764729f, 
    0.01022980f, 0.01727713f, -0.12589158f, -0.06774243f, -0.00486756f, 0.02955237f, -0.02584555f, 0.04208087f, 
    0.03425965f, -0.03033434f, 0.01293730f, -0.03586539f, 0.01154924f, -0.09222719f, 0.06534602f, 0.04879762f, 
    -0.03423873f, -0.02047811f, 0.06905575f, 0.00414535f, 0.02502232f, -0.11469218f, 0.04991544f, 0.09173652f, 
    0.07048443f, -0.01617943f, -0.08281137f, 0.09830015f, 0.12217528f, -0.00158274f, -0.10977274f, -0.00911160f, 
    0.01167881f, 0.02458059f, -0.05020770f, 0.04362261f, -0.07570137f, 0.02263647f, -0.19397759f, -0.03662504f, 
    -0.05552243f, 0.01214248f, -0.11153077f, 0.08488216f, 0.10907961f, 0.01805153f, -0.06156794f, 0.00610804f, 
    -0.19172911f, 0.08720790f, -0.26802820f, -0.07442014f, 0.20859180f, 0.08284688f, -0.02451509f, 0.00858573f, 
    0.04812133f, -0.07667831f, 0.05720828f, -0.02870009f, -0.06261650f, 0.03821657f, -0.02219344f, -0.01654006f, 
    -0.08235009f, 0.09327696f, -0.04658589f, -0.07011069f, -0.03566577f, -0.25804082f, -0.03510280f, 0.11311753f, 
    -0.06933242f, 0.07323926f, 0.02100308f, -0.07892928f, -0.01713758f, 0.11797003f, 0.01206907f, 0.02149689f, 
    -0.06202739f, -0.01768188f, -0.04946584f, 0.22584775f, 0.03639737f, -0.01820152f, 0.04503726f, 0.11253673f, 
    -0.25024587f, -0.09489661f, -0.11262317f, 0.25615999f, 0.05948592f, -0.02226969f, 0.01129585f, 0.06743008f, 
    0.04831214f, -0.00440036f, -0.02352956f, 0.05023665f, 0.05463669f, 0.05005443f, -0.02336846f, 0.12490385f, 
    -0.17128770f, 0.06660642f, 0.03778927f, 0.03062814f, 0.33955503f, -0.12343896f, -0.43163514f, -0.05856261f, 
    0.12197006f, 0.00809404f, 0.14214312f, 0.03722825f, -0.08276204f, 0.03471298f, 0.12392738f, -0.03148865f, 
    -0.00702440f, -0.14817426f, -0.02300199f, -0.04103018f, 0.03021005f, 0.02420113f, -0.08652820f, -0.10983234f, 
    -0.19192931f, 0.20891657f, -0.25249845f, -0.06371251f, -0.07068273f, 0.08525787f, -0.04792441f, 0.05614089f, 
    -0.12151594f, 0.17458715f, 0.03389151f, -0.07497830f, 0.09000093f, 0.08650135f, -0.08875845f, -0.05774244f, 
    0.00123331f, 0.04841185f, -0.08359525f, -0.03627640f, -0.02067815f, 0.01527103f, 0.09859046f, -0.23364641f, 
    -0.10162207f, 0.00964609f, 0.02363755f, 0.02734422f, 0.03979957f, 0.03486802f, 0.05977953f, 0.01263494f, 
    -0.04207081f, -0.07128064f, 0.00311656f, 0.01716425f, 0.05009338f, 0.06021669f, -0.03647176f, 0.09325498f, 
    0.03961159f, 0.04368661f, 0.00756269f, -0.20626071f, -0.15242846f, -0.05017029f, 0.04090424f, 0.00528314f, 
    -0.02232112f, 0.12435766f, 0.05030168f, -0.02128762f, -0.09238784f, -0.00211460f, -0.01858537f, 0.02264465f, 
    0.02877659f, 0.02584067f, 0.03261169f, 0.06231994f, 0.07290514f, -0.05325668f, 0.23487917f, 0.04983669f, 
    -0.15443049f, 0.21423250f, 0.15512398f, 0.05987636f, 0.05135168f, -0.20966296f, 0.03103641f, -0.02869690f, 
    -0.00389900f, 0.06423692f, 0.01744261f, -0.00464640f, 0.02400578f, -0.07522023f, 0.12523013f, 0.11884341f, 
    -0.02776966f, 0.04393024f, -0.15730461f, -0.00908456f, 0.08713441f, -0.12666564f, 0.16487524f, 0.19728015f, 
    -0.05673821f, -0.01395590f, 0.03229366f, -0.03663050f, 0.01652018f, -0.07474166f, 0.22236012f, 0.12410868f, 
    0.03409113f, -0.00406685f, 0.14937101f, 0.06150160f, 0.00426062f, 0.02015798f, 0.13780583f, 0.12432817f, 
    -0.09477588f, -0.00259681f, 0.02553360f, -0.01360228f, -0.02076119f, -0.08894099f, 0.06355347f, -0.00384273f, 
    0.02965701f, 0.06070570f, 0.01132714f, 0.01126287f, 0.03473589f, -0.05488421f, 0.00943208f, -0.16309968f, 
    -0.27484050f, -0.29351950f, 0.19932790f, -0.00700411f, -0.51209080f, 0.11537815f, -0.12347426f, 0.14349903f, 
    0.12159043f, -0.06975894f, 0.08572951f, -0.04401670f, 0.04280780f, -0.08894369f, 0.08667295f, 0.01169470f, 
    0.01875264f, 0.08104170f, 0.16467360f, -0.00967421f, -0.12990546f, -0.07058534f, -0.11710148f, -0.04547995f, 
    0.04576160f, 0.08929417f, -0.00388251f, -0.06952170f, -0.05102500f, 0.03038264f, 0.06344348f, -0.00731169f, 
    -0.00053434f, 0.17286550f, 0.09146093f, -0.02284030f, 0.18501166f, 0.16108990f, 0.01547257f, -0.01906893f, 
    -0.13682176f, 0.04096163f, 0.18221204f, -0.14317527f, 0.12338036f, -0.04478111f, 0.02999539f, 0.02838982f, 
    -0.01561232f, -0.07255176f, 0.11500080f, -0.03966958f, 0.03466295f, -0.07101111f, -0.07811722f, 0.06995727f, 
    -0.07473139f, 0.06210822f, 0.01433487f, -0.00320850f, -0.07118826f, 0.26824498f, -0.38734585f, -0.49988642f, 
    -0.02454959f, -0.08890727f, -0.02749725f, 0.01313957f, -0.04075098f, -0.06702733f, -0.05822572f, 0.07561243f, 
    -0.17962477f, 0.04913274f, 0.10705078f, -0.10626098f, -0.03916158f, 0.07336007f, 0.13077621f, -0.01180236f, 
    0.35487780f, 0.00645346f, -0.17003982f, -0.40845373f, 0.15296184f, 0.04830595f, 0.04216365f, -0.07172251f, 
    -0.00313342f, 0.03202585f, 0.08579834f, 0.06097580f, 0.00142193f, -0.07161364f, -0.01195332f, -0.09018523f, 
    -0.08739983f, -0.20828328f, 0.00537267f, -0.05196477f, -0.20290019f, -0.19264095f, -0.07045956f, 0.01828398f, 
    0.09041886f, -0.04278664f, 0.01989416f, -0.10105854f, -0.08499931f, 0.01084826f, 0.09737869f, -0.08521471f, 
    0.07329854f, 0.09125719f, 0.06206122f, -0.09347680f, -0.02548194f, -0.00912600f, 0.12825881f, -0.04276763f, 
    -0.19107506f, 0.32980308f, -0.01134849f, 0.43603644f, -0.09366564f, 0.23987679f, -0.27097747f, 0.07657649f, 
    0.01336718f, -0.21256667f, -0.16376396f, 0.06844699f, -0.19242015f, 0.02704944f, 0.02573406f, 0.06119435f, 
    -0.01399868f, 0.18606944f, -0.08291549f, -0.15980145f, -0.01139451f, 0.07561001f, 0.20162585f, -0.14131881f, 
    0.01482847f, -0.08961015f, 0.03693325f, -0.07688108f, -0.06113134f, 0.05297077f, 0.07540969f, -0.08072880f, 
    -0.07528661f, -0.13156335f, 0.05561189f, 0.05093721f, -0.20637746f, -0.06184677f, 0.24879798f, -0.02897142f, 
    -0.21093301f, -0.03827152f, 0.04666048f, -0.18924858f, -0.15534332f, 0.10181607f, 0.00003975f, -0.06163916f, 
    -0.06684455f, 0.19021760f, 0.02601807f, -0.05019070f, -0.03744666f, 0.04049020f, -0.03043627f, -0.00114782f, 
    -0.01833878f, 0.04643377f, 0.00928138f, 0.09726145f, -0.27582672f, 0.09435182f, 0.14171916f, 0.20711376f, 
    -0.37987006f, 0.06666149f, -0.13372232f, 0.07501953f, 0.11509041f, 0.09649301f, -0.02121344f, 0.05316770f, 
    -0.05519857f, -0.04747517f, -0.00857382f, -0.01298756f, -0.00335447f, 0.17785059f, -0.14426491f, -0.06281883f, 
    -0.07801315f, -0.15743694f, -0.35654137f, -0.18217006f, -0.10978523f, 0.09028579f, -0.00392261f, -0.06689806f, 
    -0.05120924f, 0.15332590f, -0.06415459f, 0.18151814f, -0.13129370f, 0.00086193f, -0.07483184f, -0.03257790f, 
    -0.02721394f, 0.00616505f, -0.01074951f, 0.11631247f, -0.12716644f, 0.05746172f, 0.16571569f, 0.08935653f, 
    -0.01819292f, -0.01081500f, -0.02682422f, 0.05675110f, 0.04408363f, -0.08999896f, 0.03450520f, 0.02639589f, 
    0.02207366f, 0.08923317f, 0.06135583f, 0.02183668f, 0.00045805f, -0.17942774f, -0.07112291f, -0.32790092f, 
    -0.00400235f, 0.04595222f, -0.04583589f, 0.00908607f, 0.03993044f, -0.09588437f, 0.01956040f, 0.20560288f, 
    0.01603479f, -0.08445189f, -0.05118091f, -0.02892790f, -0.05933246f, -0.06337094f, -0.01389050f, 0.03391514f, 
    0.09136959f, 0.11327900f, -0.14076540f, 0.06797656f, -0.67243588f, 0.77241260f, -0.08064694f, 0.18773736f, 
    -0.12247600f, -0.06359151f, -0.01256464f, -0.10155727f, 0.18086787f, 0.09985670f, 0.06256137f, -0.01165503f, 
    -0.05081644f, -0.11348987f, -0.19340529f, -0.03810296f, -0.01480401f, 0.10862072f, 0.03705496f, 0.03611397f, 
    -0.44786954f, 0.20314670f, -0.22086467f, -0.19739076f, -0.00116096f, -0.14574274f, -0.09030639f, -0.12916644f, 
    -0.07452168f, 0.16485175f, -0.09491227f, 0.15242028f, -0.15502588f, -0.15095136f, 0.08695211f, -0.05926700f, 
    -0.23564625f, 0.01987606f, 0.04285930f, 0.10583217f, -0.12988432f, -0.02037032f, -0.18210784f, 0.04990759f, 
    0.09440588f, 0.08395548f, -0.05448067f, -0.04715296f, -0.00803233f, 0.02206387f, -0.01551186f, 0.01611679f, 
    0.02461425f, 0.00241336f, -0.03230349f, -0.02822027f, -0.01001563f, 0.10364197f, -0.01464825f, 0.01554552f, 
    0.06638311f, 0.03847452f, -0.18076195f, -0.01990169f, -0.09402937f, -0.10525262f, -0.07707344f, -0.00521796f, 
    -0.10377625f, -0.04058168f, -0.04747870f, -0.03249533f, -0.07394018f, -0.06187070f, 0.08728510f, -0.22412077f, 
    -0.20687419f, -0.06127755f, -0.15568522f, -0.21293113f, 0.13657098f, -0.23966189f, -0.09053873f, -0.13971502f, 
    -0.14254035f, 0.04962541f, 0.03422002f, -0.06198587f, -0.08721353f, -0.06984717f, 0.02904492f, -0.02701893f, 
    0.08098064f, -0.03764585f, 0.00395251f, -0.13732894f, -0.03941662f, 0.05368372f, -0.03155904f, -0.03874605f, 
    -0.07852717f, -0.25571612f, 0.00255345f, -0.10315275f, 0.10921282f, -0.28860801f, 0.00437650f, -0.18304437f, 
    -0.04825922f, 0.09239841f, 0.03636476f, -0.03006348f, -0.00625725f, -0.01063420f, 0.02391759f, 0.11136755f, 
    -0.00596437f, -0.05880162f, 0.04008726f, 0.12694278f, -0.37212035f, 0.14660329f, 0.17924060f, -0.08883587f, 
    -0.19922230f, 0.02774661f, -0.02640340f, 0.04827058f, 0.10478085f, -0.01356139f, -0.03223332f, -0.18031546f, 
    -0.10224921f, 0.03803664f, -0.02701015f, 0.07483901f, 0.05612590f, -0.11978749f, -0.02894533f, 0.02116725f, 
    -0.34314537f, -0.08340680f, 0.11221468f, -0.10918617f, -0.20127483f, 0.09713089f, -0.08033345f, -0.05503488f, 
    -0.05516623f, 0.07494363f, 0.02997649f, 0.12212788f, -0.11399069f, 0.00355842f, 0.11747033f, -0.04142610f, 
    -0.03507815f, -0.14760718f, 0.13601932f, 0.36679873f, 0.49339533f, -0.30174676f, 0.16216321f, 0.08836441f, 
    -0.19741932f, 0.26951998f, -0.04730139f, -0.04644158f, 0.13592322f, 0.11137012f, 0.08225682f, 0.01253673f, 
    -0.03368328f, 0.05394166f, 0.06928574f, -0.11799664f, 0.04186180f, -0.11906908f, -0.05356752f, 0.09985367f, 
    0.28672665f, -0.39859736f, 0.15593901f, 0.10978480f, -0.14891443f, 0.25420567f, 0.16393718f, -0.00766772f, 
    -0.18832460f, 0.30545375f, 0.04919539f, -0.06285263f, 0.02384187f, 0.01716527f, 0.04558837f, -0.03820413f, 
    0.04972242f, -0.00988213f, 0.08438709f, 0.14161453f, -0.35910901f, -0.10433076f, -0.21448328f, 0.19213581f, 
    0.03831682f, 0.05485433f, -0.17101750f, -0.03503115f, 0.00409079f, 0.10879453f, -0.07324003f, 0.12444906f, 
    -0.00698132f, 0.00366610f, 0.00498437f, -0.02853446f, -0.03108207f, 0.02592015f, -0.02073435f, -0.03331730f, 
    0.01786062f, -0.03269923f, -0.09150173f, -0.07315729f, 0.04690972f, -0.01975664f, 0.06282207f, 0.02277881f, 
    -0.07626918f, 0.06956680f, 0.01786205f, 0.04592342f, -0.10085416f, -0.06560870f, -0.05448451f, 0.04659495f, 
    0.01662308f, 0.03135136f, -0.04581727f, 0.17390187f, 0.30922607f, -0.06041575f, -0.00862532f, 0.17214763f, 
    -0.15428697f, -0.01224510f, -0.01479659f, -0.06633346f, -0.20931296f, 0.11433986f, -0.00530727f, -0.05740889f, 
    0.18241456f, 0.02044679f, -0.04300245f, 0.07256903f, -0.14812702f, 0.04759130f, 0.13742694f, 0.02121069f, 
    -0.27756566f, -0.21431689f, 0.15388760f, 0.17874454f, -0.17835805f, 0.01614681f, -0.13151596f, -0.16595763f, 
    0.16089351f, -0.01118656f, 0.21861120f, -0.03174318f, -0.06683996f, 0.11173143f, 0.14691487f, -0.01939839f, 
    0.07943626f, 0.02367691f, 0.05239106f, 0.20031540f, -0.16349374f, 0.28474090f, -0.26067287f, -0.06714169f, 
    -0.05266000f, -0.02701111f, -0.05040912f, 0.03739293f, 0.01819025f, -0.05655949f, -0.01541810f, 0.01209342f, 
    -0.15161704f, 0.05309588f, 0.07430448f, -0.10340305f, -0.02967682f, 0.14773543f, -0.09454848f, -0.08226115f, 
    -0.05060938f, -0.05544347f, 0.00380308f, -0.16614994f, 0.10588061f, 0.07695404f, 0.13317814f, 0.14231113f, 
    -0.17286360f, 0.09214936f, 0.05748288f, -0.03592976f, -0.11907434f, 0.09175345f, 0.11306395f, 0.05021719f, 
    0.06760417f, -0.04969401f, 0.03886133f, 0.08797816f, 0.25455764f, 0.00513950f, -0.32236665f, -0.16111690f, 
    0.29224378f, 0.03956386f, -0.01381112f, -0.05182779f, -0.03687448f, -0.03154247f, 0.11566519f, -0.05745750f, 
    -0.02028999f, -0.03104855f, 0.08314972f, -0.17432676f, 0.03902481f, 0.19552913f, -0.00195582f, -0.26392022f, 
    0.00764563f, -0.01570922f, -0.31778821f, 0.04233162f, 0.07775171f, 0.05418951f, -0.08248727f, -0.03360992f, 
    0.01724820f, 0.04607692f, -0.07623440f, 0.07490047f, 0.15196520f, 0.00996587f, -0.17697947f, 0.20061634f, 
    0.00899400f, 0.16921675f, 0.05232462f, 0.02689491f, 0.10576499f, 0.03259578f, 0.15505461f, -0.07593179f, 
    0.09883759f, -0.03833237f, 0.05057616f, -0.03451839f, -0.03980703f, 0.03279373f, -0.10779519f, 0.03653373f, 
    -0.12008904f, 0.03816896f, -0.04218600f, 0.00846756f, 0.07616962f, 0.07299738f, -0.02927087f, 0.13268678f, 
    0.09294922f, 0.02161304f, -0.02190299f, -0.09668396f, 0.11933912f, -0.02411222f, 0.06672411f, 0.05747716f, 
    -0.07592708f, -0.02946840f, -0.03885927f, -0.09703214f, -0.07784031f, -0.00184886f, -0.08163820f, 0.04829072f, 
    0.07032435f, 0.03114259f, -0.06621494f, 0.08554166f, 0.20274483f, 0.10825576f, 0.22601019f, 0.07348074f, 
    -0.09062182f, 0.09300894f, 0.11804447f, -0.03979213f, 0.04196256f, -0.04778286f, 0.07071295f, 0.02452610f, 
    -0.00006879f, 0.09783094f, 0.03450105f, -0.02115144f, 0.02379721f, -0.04082473f, -0.06631082f, 0.05245875f, 
    0.04194214f, -0.33449519f, -0.05409357f, 0.24863119f, -0.29897454f, 0.24370086f, -0.12141839f, -0.00875657f, 
    -0.06745668f, 0.11788685f, -0.02558783f, 0.01500461f, -0.06101393f, -0.01249580f, 0.01797250f, -0.05256592f, 
    0.01102354f, 0.05378258f, 0.03824966f, 0.07737462f, -0.28707856f, 0.08928751f, 0.28799576f, 0.19130220f, 
    -0.24202424f, 0.04859661f, -0.05310010f, -0.06970932f, 0.05699996f, 0.06550799f, -0.02644099f, 0.08075368f, 
    0.00828399f, -0.02187544f, -0.02182525f, -0.05012576f, -0.10489092f, 0.01990055f, -0.19530492f, -0.25108829f, 
    0.24641226f, 0.06848943f, -0.01696691f, 0.14291644f, -0.13697655f, 0.01672994f, -0.07388370f, -0.07872273f, 
    -0.03824758f, 0.18270989f, -0.07875103f, 0.08992174f, 0.04013221f, 0.01450485f, 0.03192003f, 0.05043839f, 
    0.08882689f, 0.02919734f, -0.02503431f, 0.17486659f, -0.18924351f, 0.05908000f, -0.07804178f, 0.03567344f, 
    -0.07978186f, -0.06415614f, 0.04241299f, 0.06900918f, -0.04621859f, -0.02267301f, 0.01454104f, -0.05478188f, 
    -0.02684933f, -0.01518059f, 0.01845319f, -0.16212407f, -0.02186820f, 0.07542952f, 0.00198422f, -0.11444899f, 
    0.51919675f, 0.04807594f, -0.21255817f, -0.10506457f, 0.06345706f, -0.00894478f, -0.00271053f, -0.13891679f, 
    -0.06842896f, 0.22738014f, 0.01415671f, 0.09571643f, 0.01410785f, -0.02481734f, -0.01669544f, -0.05374936f, 
    -0.17379405f, 0.05654543f, 0.09654834f, 0.09422903f, -0.38153279f, -0.17549607f, 0.11932401f, -0.09703680f, 
    -0.42442867f, -0.05205046f, -0.03248497f, 0.00099507f, 0.07052550f, 0.02080335f, 0.01674833f, 0.01756102f, 
    -0.09819809f, 0.13590834f, 0.10274373f, -0.01723837f, 0.03611219f, 0.00536606f, 0.04891902f, 0.02621133f, 
    -0.68676192f, 0.39820150f, 0.19999382f, -0.15867133f, -0.08783825f, -0.12689067f, 0.04389698f, -0.11069698f, 
    0.03115640f, -0.06261913f, 0.22959855f, -0.03562091f, 0.05616224f, -0.14432639f, -0.12228944f, 0.06866568f, 
    -0.17872006f, -0.00047381f, 0.20064756f, 0.14041351f, -0.05899652f, 0.00672632f, -0.00782745f, -0.10280147f, 
    0.03982462f, -0.00988928f, 0.00230359f, -0.01783599f, -0.03285174f, -0.00975868f, -0.03901891f, -0.11678928f, 
    0.09352322f, 0.05789269f, 0.24657042f, 0.02946420f, -0.04673962f, 0.01393648f, 0.13612245f, 0.01316353f, 
    0.06220230f, -0.03588518f, -0.09877587f, -0.08828370f, 0.06803554f, -0.00213191f, -0.00006570f, 0.06721110f, 
    0.04189159f, 0.03408609f, -0.03768070f, -0.04087330f, -0.09729774f, -0.09309460f, -0.03333595f, -0.14730574f, 
    -0.17034648f, -0.08384253f, 0.02266231f, -0.00941726f, 0.11555648f, 0.33656535f, 0.05841101f, 0.19374037f, 
    -0.09900265f, 0.01845254f, 0.05035232f, -0.09077561f, -0.02809954f, 0.11996747f, -0.07302553f, -0.01597278f, 
    0.06607146f, -0.07268932f, -0.01939488f, -0.01168153f, 0.02406303f, -0.04133030f, -0.03051441f, -0.04640228f, 
    -0.44423649f, 0.16950358f, 0.30470026f, -0.07995643f, -0.09260494f, -0.13057201f, -0.09659035f, -0.14011711f, 
    -0.06409995f, -0.02190638f, -0.03499940f, 0.01262399f, -0.00370396f, 0.03253543f, 0.05648512f, 0.00828541f, 
    0.01140007f, 0.00119292f, -0.00702636f, -0.00790635f, -0.06280704f, -0.07250976f, 0.12844642f, 0.00555520f, 
    -0.01401521f, 0.05652727f, -0.12097287f, 0.14842393f, 0.02635588f, -0.10368408f, 0.06248532f, 0.03639570f, 
    0.05070074f, 0.07656623f, 0.01098326f, -0.03715229f, 0.03352950f, 0.05315448f, -0.09466760f, -0.04717642f, 
    -0.32116330f, -0.21939559f, -0.56130487f, -0.18790807f, -0.07817171f, -0.05368688f, 0.12251388f, -0.16575229f, 
    -0.11013114f, -0.32090634f, 0.07108651f, -0.08490103f, -0.07502418f, -0.03168890f, 0.05555340f, -0.01881012f, 
    -0.01532935f, 0.13085712f, -0.02884180f, -0.03007802f, 0.30557469f, -0.19389956f, -0.25017464f, -0.06804276f, 
    0.16641675f, -0.13359143f, 0.09161500f, 0.14805590f, 0.13742995f, -0.04417888f, 0.03694354f, 0.02425969f, 
    -0.06115763f, -0.05414617f, 0.06175081f, -0.02800955f, 0.03406600f, 0.03655864f, -0.01094089f, 0.09578941f, 
    -0.34872437f, -0.25196975f, -0.22835551f, -0.13220878f, 0.01392510f, -0.04589174f, 0.05532280f, 0.06744593f, 
    -0.02790206f, -0.02006543f, -0.03427369f, -0.03094763f, 0.00120945f, 0.01307271f, 0.01732782f, 0.04154992f, 
    0.08549529f, 0.09354769f, 0.02579295f, 0.02996081f, -0.32269824f, -0.33483362f, -0.67097896f, -0.24259333f, 
    0.05002377f, -0.16041709f, -0.08407570f, -0.15832061f, -0.12103993f, -0.37419707f, -0.02273635f, -0.05080328f, 
    -0.02024171f, 0.03974890f, 0.07116741f, -0.02810139f, -0.01338840f, 0.08810847f, 0.19526683f, 0.11398276f, 
    -0.45216307f, 0.30178463f, 0.12325388f, 0.18016878f, 0.10603500f, -0.06283522f, 0.09977926f, 0.06652480f, 
    -0.04233412f, -0.07158730f, -0.00092952f, -0.01761085f, 0.04748573f, 0.00934115f, 0.01672611f, 0.00150751f, 
    0.00160643f, 0.11942401f, -0.00733017f, -0.05482301f, -0.46314582f, 0.33699441f, 0.33536178f, 0.04622454f, 
    0.20682330f, -0.10496590f, -0.08476717f, -0.03475944f, -0.13594806f, 0.20748143f, -0.08615042f, 0.12150699f, 
    0.06125762f, 0.07307041f, 0.05057179f, -0.00465544f, 0.01728455f, -0.01073251f, -0.01653419f, -0.01344331f, 
    0.02779912f, -0.17468831f, -0.04306497f, 0.03276470f, 0.10498682f, 0.02074745f, 0.02743187f, -0.00963817f, 
    0.05076346f, -0.04668313f, 0.07521286f, -0.03144737f, -0.08369062f, -0.03100914f, -0.01183733f, 0.01222139f, 
    0.02399595f, -0.02485028f, -0.00247513f, -0.04690033f, 0.01691521f, 0.08790171f, 0.07367752f, -0.07820297f, 
    -0.05071642f, -0.04628562f, 0.00286160f, -0.06431247f, -0.00809374f, -0.04708068f, 0.03005918f, -0.15778407f, 
    -0.09065353f, 0.01390319f, 0.01322142f, 0.02595209f, -0.07981370f, -0.03545716f, -0.05978096f, -0.04074380f, 
    0.05188669f, -0.10394390f, 0.05987990f, 0.05742998f, -0.05465959f, 0.01738847f, 0.02896159f, 0.07280791f, 
    0.00910184f, -0.03452418f, 0.00241621f, -0.00961255f, -0.02659859f, -0.02130058f, -0.01262428f, -0.07816598f, 
    -0.02715957f, 0.04053955f, -0.01248409f, 0.07962372f, 0.02139275f, 0.08634656f, -0.01096896f, -0.02092284f, 
    0.05809193f, 0.02683651f, 0.03381033f, 0.00447554f, 0.01439942f, 0.05551415f, -0.02012326f, -0.03556181f, 
    0.00123215f, 0.08950307f, -0.00183788f, 0.00254009f, 0.08724411f, -0.08197123f, 0.01681417f, -0.04779475f, 
    -0.02472788f, -0.07418821f, -0.04382287f, -0.04388871f, 0.10361990f, 0.01266040f, 0.07657195f, 0.08306995f, 
    0.01173645f, 0.02892679f, -0.00435414f, -0.00492305f, -0.01899756f, -0.04883584f, 0.01318543f, -0.03981188f, 
    -0.09001324f, -0.06649288f, 0.05390340f, 0.03796670f, 0.30975994f, 0.17645653f, -0.02424663f, -0.07846603f, 
    -0.07407512f, -0.00494409f, -0.02899413f, 0.02140622f, 0.01643943f, -0.15228628f, 0.00408497f, 0.01525512f, 
    -0.01439195f, -0.02555761f, 0.01984026f, 0.01599876f, -0.07092566f, -0.08661902f, -0.15891813f, 0.08027922f, 
    -0.54894364f, 0.22974202f, 0.32678729f, 0.14020987f, 0.27723625f, -0.16513675f, -0.03808748f, -0.12294268f, 
    0.09222185f, 0.14663669f, 0.06724332f, 0.10026623f, 0.05703299f, -0.03688552f, 0.04518776f, 0.02531442f, 
    0.02933035f, -0.04466764f, 0.05050406f, -0.03948482f, -0.35588026f, 0.11149925f, 0.26045489f, -0.01895973f, 
    -0.08554281f, -0.09093279f, -0.09840523f, -0.09870227f, -0.17223985f, -0.03254196f, -0.10232006f, 0.03557643f, 
    -0.03521490f, 0.01606577f, 0.02529673f, -0.00642487f, -0.05405477f, 0.01516560f, -0.05211746f, -0.04858089f, 
    -0.27465090f, 0.13401727f, 0.27760682f, -0.05322572f, -0.02859119f, -0.06929680f, -0.10280706f, -0.07100042f, 
    -0.08405095f, -0.01423317f, 0.04303039f, -0.06400765f, -0.01752361f, 0.00632493f, 0.03285986f, 0.00032068f, 
    -0.04169461f, -0.00717610f, -0.07822182f, -0.03402860f, -0.58648419f, -0.55218047f, -0.40361971f, -0.33631587f, 
    -0.04668624f, -0.25833535f, -0.12022284f, -0.10220171f, -0.20989178f, -0.31357834f, -0.05159845f, 0.01690592f, 
    -0.01541765f, -0.01372051f, -0.01806658f, -0.01350180f, -0.02280721f, 0.02016783f, 0.05451781f, 0.03532036f, 
    0.06458008f, -0.10947939f, -0.06169834f, 0.01678075f, 0.05528462f, 0.02423854f, -0.10403666f, 0.21589890f, 
    0.08521752f, -0.18010822f, 0.04795736f, 0.02157631f, -0.08256111f, -0.03311950f, -0.01928505f, -0.00081674f, 
    -0.04044520f, 0.02298254f, -0.02893419f, -0.10370056f, -0.40135032f, -0.38030416f, -0.59711987f, -0.17200319f, 
    -0.06000999f, -0.17630583f, 0.09293866f, -0.08984020f, -0.08174406f, -0.38113323f, 0.04714071f, -0.01376015f, 
    0.01255516f, -0.02537240f, -0.02201485f, -0.01245338f, -0.04846216f, 0.02799959f, 0.14401899f, 0.03605983f, 
    -0.44934154f, -0.40403670f, 0.45949629f, 0.43275729f, 0.04106763f, -0.28539878f, -0.12243809f, -0.06174608f, 
    -0.22178479f, 0.03014240f, -0.09898237f, 0.00123298f, 0.04744534f, -0.03496828f, -0.04102208f, 0.01340091f, 
    0.07391976f, -0.03795933f, 0.00613370f, -0.07366722f, 0.05997580f, -0.05709626f, -0.03521786f, -0.05521868f, 
    -0.06084378f, 0.00809219f, -0.05069056f, -0.05720139f, -0.03452097f, 0.02951533f, -0.08831368f, -0.14941470f, 
    -0.10327196f, -0.27619743f, -0.17103919f, 0.00536689f, -0.06512405f, -0.08464429f, -0.05003996f, 0.02926828f, 
    -0.11129291f, 0.24699794f, -0.05766952f, 0.14547251f, -0.07163054f, 0.13755614f, 0.06775498f, -0.04066318f, 
    -0.03607502f, -0.17713457f, -0.01610669f, -0.04676683f, -0.02780850f, 0.08404089f, 0.05042936f, 0.02473995f, 
    -0.05154908f, 0.12605131f, -0.19130446f, -0.16433944f, -0.16896325f, 0.02061348f, 0.02779273f, 0.02797632f, 
    0.13269646f, 0.05502889f, 0.02398146f, -0.03733559f, 0.01818362f, -0.01389700f, 0.06502454f, 0.03038899f, 
    0.11678249f, 0.08976399f, 0.01804729f, 0.09743126f, 0.07822459f, -0.00185569f, -0.09156070f, 0.08280901f, 
    0.06349912f, -0.04306154f, 0.04260826f, -0.27414402f, -0.05974180f, 0.00747781f, 0.02961514f, 0.05342366f, 
    0.05643860f, -0.05299016f, 0.04515536f, -0.03451521f, 0.00110997f, -0.01726527f, 0.00754606f, 0.06795281f, 
    0.02634066f, -0.01705838f, -0.02277651f, 0.09024194f, 0.03223613f, 0.09357686f, -0.00940677f, 0.04842198f, 
    -0.09647313f, 0.05472331f, 0.04789450f, -0.01258172f, -0.02143459f, 0.11033120f, -0.00468398f, -0.03948590f, 
    0.09972969f, 0.03404049f, -0.06805341f, 0.05696711f, 0.13417684f, -0.09070692f, 0.00492953f, -0.01746591f, 
    -0.13750108f, -0.28355828f, 0.09260777f, -0.04709150f, 0.17196035f, -0.20665172f, -0.00347230f, 0.07178389f, 
    0.02498812f, 0.10265727f, 0.06056458f, 0.04621976f, 0.06829285f, -0.17568505f, 0.10255032f, -0.04031255f, 
    -0.01773082f, -0.00127102f, 0.04593743f, -0.09169512f, -0.27145118f, 0.12954015f, 0.30459884f, -0.00046787f, 
    0.06071422f, 0.03076694f, 0.09624261f, 0.10583284f, 0.11737274f, 0.04687992f, 0.04391744f, -0.04624488f, 
    0.14412001f, -0.00707163f, 0.14495230f, 0.03379604f, 0.00620444f, 0.12433519f, -0.06133080f, 0.00075575f, 
    -0.59406263f, -0.30346066f, 0.16430835f, -0.17113368f, -0.46734095f, 0.06056721f, -0.07612142f, 0.05259563f, 
    -0.22426948f, -0.06338948f, -0.04282151f, 0.02755517f, -0.03659947f, 0.05671711f, -0.01387461f, -0.01928228f, 
    -0.05232025f, 0.00625314f, -0.01245586f, 0.03353940f, -0.41913110f, -0.82179564f, -0.88578737f, -0.24144191f, 
    0.29547301f, -0.09518092f, 0.16696525f, 0.12908424f, -0.14736769f, -0.27324700f, -0.02037094f, -0.03258061f, 
    -0.00151391f, -0.01272335f, 0.01606929f, 0.01936767f, 0.05885395f, 0.09491314f, 0.09504750f, -0.06401718f, 
    -0.34061924f, 0.35166460f, 0.26582822f, -0.00996481f, 0.20520391f, -0.03802907f, -0.03909916f, -0.09425801f, 
    -0.06439982f, 0.17265910f, -0.00187134f, 0.11841343f, 0.01396201f, 0.07898089f, 0.03085770f, -0.00317844f, 
    -0.02722357f, 0.00179533f, 0.03523003f, 0.02750131f, -0.27803862f, -0.26252624f, -0.63301933f, -0.04514668f, 
    0.00141986f, -0.13904518f, -0.08742246f, -0.09048873f, -0.11038570f, -0.24473457f, -0.00755497f, -0.03431159f, 
    0.00553320f, -0.01538014f, 0.06517345f, -0.04184486f, 0.01244141f, 0.10768896f, 0.14240444f, 0.05594438f, 
    0.15980132f, -0.23695759f, -0.26222393f, -0.08440740f, 0.12372950f, -0.03316392f, 0.06388243f, 0.07867178f, 
    0.04790638f, -0.11434880f, -0.01413180f, -0.00763662f, -0.09939688f, -0.04791835f, 0.03318448f, -0.05013167f, 
    -0.01355237f, 0.08196519f, 0.08441589f, -0.04398677f, -0.07702356f, 0.09883044f, -0.10281710f, -0.14453393f, 
    0.28855306f, -0.09658391f, 0.12433070f, 0.00475258f, 0.02436916f, 0.17767879f, 0.06337981f, 0.12337398f, 
    0.12067423f, 0.03368122f, 0.07278448f, -0.03953201f, 0.05877898f, -0.02087483f, 0.14007671f, -0.05240132f, 
    -0.34758279f, 0.32077789f, -0.03860097f, -0.16778831f, 0.31323490f, -0.03969682f, -0.05538001f, 0.00365629f, 
    0.06225005f, -0.10394009f, 0.07599935f, 0.11204566f, 0.02669386f, 0.16180754f, 0.08219780f, 0.02904106f, 
    -0.04697804f, 0.01663149f, -0.04975200f, 0.04637622f, 0.15478730f, -0.05499734f, -0.11466513f, -0.06447392f, 
    0.06753281f, -0.01033264f, 0.00120713f, 0.07979064f, -0.01827429f, 0.02745220f, -0.02357782f, -0.00957818f, 
    -0.03429877f, -0.07773605f, -0.02505814f, -0.10497961f, -0.11037351f, -0.16685203f, 0.05354660f, 0.04078444f, 
    -0.03414311f, -0.23353815f, -0.18672720f, -0.26069546f, 0.38357472f, -0.10819328f, -0.00361164f, -0.00160756f, 
    0.05658315f, 0.09273689f, 0.02343825f, 0.01003481f, 0.07956661f, 0.12483243f, -0.14913559f, -0.09592850f, 
    0.11183133f, 0.00239187f, 0.16920899f, 0.01720370f, -0.33194581f, 0.25932357f, 0.21221912f, 0.07961529f, 
    0.25418180f, -0.14476834f, -0.08771463f, -0.12559792f, -0.06063869f, 0.08283070f, 0.03672755f, 0.07599524f, 
    0.14623193f, -0.02999896f, -0.02696477f, 0.03079883f, 0.03746085f, 0.00297475f, 0.05845728f, 0.01447597f, 
    -0.01992388f, -0.41937700f, -0.11264756f, 0.04153374f, 0.07127368f, -0.11351267f, 0.19340181f, -0.00549041f, 
    0.12101320f, -0.13406427f, 0.05189325f, -0.04084519f, -0.07796858f, 0.03540036f, -0.00623890f, 0.00035119f, 
    0.02600838f, 0.03239165f, 0.00127193f, -0.00202801f, 0.02622612f, 0.07530455f, 0.12929341f, -0.00798488f, 
    -0.09022977f, 0.02485328f, 0.01692867f, -0.09161413f, -0.05182007f, 0.09974137f, -0.02806890f, -0.01356263f, 
    -0.01708363f, 0.03176093f, -0.11240757f, -0.06562345f, 0.02192298f, -0.00310841f, 0.07653045f, -0.00318043f, 
    -0.20939755f, -0.34612653f, 0.00075663f, 0.11451697f, -0.10774316f, 0.04093586f, -0.03809686f, -0.14172761f, 
    -0.07805578f, -0.08663649f, -0.00953341f, 0.04873057f, -0.05018446f, 0.08370715f, -0.04283489f, -0.00369787f, 
    0.02845988f, -0.04711616f, 0.01795069f, 0.05334605f, 0.08281707f, -0.23714247f, -0.24275330f, -0.37665358f, 
    0.19994614f, -0.06371073f, -0.08273788f, 0.13994983f, 0.09253545f, 0.05689939f, 0.04554397f, 0.00952035f, 
    0.01984883f, 0.05630907f, -0.04549494f, -0.07183255f, 0.01729146f, 0.01865959f, 0.12407646f, -0.03411946f, 
    0.10725422f, -0.13343503f, -0.44748297f, 0.01218610f, -0.07522558f, -0.25271949f, -0.09495068f, 0.03926684f, 
    0.18396056f, 0.31054446f, -0.04676501f, 0.06005957f, 0.06831148f, 0.00229788f, 0.01391333f, 0.03337784f, 
    0.02334433f, -0.08499575f, 0.18716063f, -0.10187874f, 0.09300776f, 0.06397524f, -0.20326531f, -0.04522622f, 
    0.07017976f, -0.02972610f, -0.01739405f, 0.07575081f, 0.00668491f, 0.09832069f, -0.03990284f, 0.01907036f, 
    -0.00173335f, -0.04283402f, 0.02612461f, -0.08270569f, -0.05392167f, -0.13411348f, 0.08454892f, 0.05643800f, 
    0.03988681f, 0.16139255f, -0.09563814f, -0.05585108f, 0.05047829f, 0.00776872f, -0.04068141f, -0.05723241f, 
    -0.06121116f, -0.06418072f, -0.16765082f, -0.04528079f, -0.08363380f, 0.07170415f, 0.04538405f, 0.03896312f, 
    -0.06238085f, -0.02473009f, -0.17777571f, -0.06117737f, 0.08453687f, 0.27234575f, 0.01450186f, 0.09315939f, 
    -0.07493520f, 0.05034444f, 0.09085774f, -0.05939769f, -0.04824360f, 0.10356763f, -0.05195917f, 0.03619822f, 
    0.05352049f, -0.05937177f, -0.01629842f, -0.02269017f, 0.04940836f, -0.10279668f, 0.00569960f, 0.04723669f, 
    -0.20415471f, -0.09270641f, 0.04720270f, -0.06741790f, 0.06373016f, -0.07713912f, 0.14882562f, 0.00814768f, 
    -0.08430376f, 0.11046815f, 0.04891290f, -0.01102814f, 0.00524466f, 0.10461472f, 0.08453581f, -0.07620107f, 
    0.11400547f, -0.07430268f, 0.07717890f, 0.00737383f, -0.06776575f, 0.03775183f, 0.08771633f, 0.07778735f, 
    0.08699307f, -0.01786104f, -0.03088072f, -0.05846149f, -0.03364361f, 0.08474398f, -0.12217384f, 0.10421414f, 
    0.09852527f, 0.09157293f, 0.00689505f, -0.00546100f, 0.04452689f, -0.02881817f, 0.03514942f, 0.02596760f, 
    0.06545983f, 0.09042750f, 0.04379494f, -0.02842121f, 0.00093159f, 0.08315839f, -0.00936199f, 0.04941461f, 
    0.04302670f, -0.01437682f, 0.04031577f, 0.02295836f, 0.00096351f, 0.01526232f, 0.05524682f, -0.02222464f, 
    0.12221488f, -0.03767539f, -0.16822168f, -0.06305832f, -0.17457633f, 0.03484439f, 0.08612746f, -0.06730906f, 
    0.05648429f, 0.01598734f, -0.01450603f, -0.03014506f, 0.02222488f, -0.04904244f, 0.02174042f, -0.06355897f, 
    -0.00445913f, -0.03826724f, -0.05005730f, 0.00807144f, 0.06152090f, -0.04922456f, -0.04737324f, 0.08307157f, 
    0.05602939f, 0.00683221f, 0.03576768f, -0.02760214f, 0.03315544f, -0.03346216f, -0.02506554f, 0.04954159f, 
    0.04817701f, 0.04674238f, 0.05020336f, -0.02114564f, -0.00059174f, -0.14092237f, -0.04063377f, -0.05237861f, 
    -0.05928646f, -0.08098848f, -0.04332090f, 0.01921205f, 0.09221588f, 0.17809978f, -0.04654213f, -0.07659780f, 
    0.00297029f, -0.01693799f, 0.05135924f, -0.13159598f, 0.00527648f, -0.12272640f, 0.16207159f, 0.00199157f, 
    -0.09469090f, -0.04454701f, 0.04793676f, 0.04354438f, -0.02593105f, 0.02503717f, -0.08843128f, -0.14022063f, 
    0.09250536f, 0.11480905f, -0.03873111f, -0.01975910f, -0.02498690f, 0.00584538f, 0.01924014f, -0.03315935f, 
    -0.00543950f, -0.05365586f, -0.00725549f, -0.07047523f, -0.11569747f, 0.00243035f, 0.02907380f, -0.01745474f, 
    -0.04420676f, 0.04481634f, -0.21033508f, -0.11843968f, -0.42979366f, -0.60050815f, -0.74226856f, -0.20758170f, 
    0.03425515f, -0.12812096f, 0.15054797f, -0.03319752f, -0.03123298f, -0.31695405f, 0.03201078f, -0.02404174f, 
    -0.05626848f, 0.00477243f, 0.04131441f, 0.00146399f, 0.01909336f, 0.13308737f, 0.11218928f, 0.11033157f, 
    0.27017301f, -0.18026286f, -0.40901557f, -0.22691891f, 0.08261988f, -0.08098014f, 0.08721237f, 0.20117411f, 
    0.01911393f, 0.04090161f, -0.05382537f, -0.04423757f, -0.01096246f, 0.01593784f, 0.07052309f, -0.02981183f, 
    0.07099433f, -0.02186503f, 0.06097944f, 0.12465729f, -0.30814391f, -0.30267894f, -0.52482843f, -0.09986122f, 
    0.13628884f, -0.15749308f, 0.16773798f, 0.05922322f, 0.00952686f, -0.03180688f, -0.03750794f, -0.00571220f, 
    0.02296246f, 0.01753698f, 0.03013321f, 0.00567083f, -0.00010382f, 0.03090206f, 0.13722858f, 0.04729770f, 
    0.21076068f, -0.01230184f, -0.49314055f, -0.11375297f, 0.06888376f, -0.14932224f, 0.04498353f, 0.11422167f, 
    0.21425356f, 0.02868774f, 0.01062463f, 0.04268502f, -0.00975532f, -0.03404338f, 0.02554723f, 0.03452696f, 
    0.00824022f, -0.02112123f, 0.18709463f, 0.04106538f, -0.37710071f, -0.55556256f, -0.22226152f, -0.09728679f, 
    0.21098366f, -0.09065209f, -0.15382430f, 0.03797659f, -0.11770377f, -0.04720208f, 0.02540711f, 0.00037008f, 
    0.01237363f, -0.08523282f, -0.04975517f, -0.02206708f, -0.00202673f, -0.02461742f, 0.07651658f, -0.03414120f, 
    0.02550901f, 0.07169330f, -0.52711385f, -0.20280814f, -0.10703487f, -0.00688030f, 0.06862532f, 0.06527829f, 
    0.10240831f, -0.14203477f, 0.01886393f, 0.01522110f, 0.04939198f, -0.08050337f, -0.00304554f, 0.07391021f, 
    0.07906644f, -0.06899890f, 0.18251480f, -0.01316223f, -0.08376275f, -0.11566526f, 0.02673324f, 0.04873049f, 
    -0.44597155f, 0.03047976f, 0.16135742f, -0.17620462f, 0.02927866f, 0.12939964f, -0.03918700f, 0.06571300f, 
    0.06235385f, 0.06195486f, -0.22675303f, 0.07179571f, 0.15684234f, 0.00361916f, 0.06951860f, 0.14689757f, 
    -0.38220838f, -0.08626959f, 0.18188144f, 0.09292353f, -0.01927151f, 0.06793885f, -0.15639091f, 0.01644099f, 
    -0.02286952f, 0.20447208f, 0.24405940f, 0.03185020f, -0.07833583f, -0.00290439f, -0.17918816f, 0.01868627f, 
    0.03629237f, 0.06072983f, -0.02720824f, 0.05430169f, -0.13513082f, 0.15506239f, 0.13838418f, 0.01422601f, 
    -0.01774651f, -0.02044726f, 0.03298194f, -0.04513589f, 0.05537217f, 0.05558269f, -0.02539943f, -0.02794436f, 
    0.07666309f, 0.01973730f, 0.23523524f, -0.02559635f, -0.01103774f, -0.10847545f, -0.00556584f, 0.05904742f, 
    0.03727246f, 0.12094254f, -0.11000001f, 0.04718430f, -0.12327813f, -0.04346534f, 0.01161529f, 0.01876601f, 
    -0.01643156f, -0.06947823f, 0.05253230f, 0.03422368f, 0.06521644f, 0.01528964f, -0.02169926f, -0.08432960f, 
    -0.04688168f, 0.09597281f, -0.01534738f, 0.03640836f, 0.23164946f, -0.04333388f, 0.14938357f, -0.19151962f, 
    0.05726310f, 0.06225732f, 0.04638207f, -0.07855389f, 0.06490590f, -0.05371013f, -0.00785208f, -0.01249490f, 
    0.08167084f, -0.05389890f, -0.05319196f, -0.05869536f, 0.07322841f, -0.02696270f, 0.00540951f, -0.00524745f, 
    0.28324947f, -0.44792441f, -0.12790640f, -0.22444507f, -0.13690688f, -0.03999246f, -0.03144553f, -0.00681579f, 
    0.05837593f, -0.09614513f, -0.02895162f, 0.01768317f, 0.03277865f, 0.03406604f, 0.04913925f, 0.01030735f, 
    -0.00602324f, 0.00426615f, 0.04706926f, -0.01997326f, -0.07218315f, -0.09580173f, 0.22968580f, -0.30677670f, 
    0.14716440f, -0.19085282f, 0.02453453f, 0.02198637f, 0.08365936f, 0.02330627f, 0.00203519f, -0.03562125f, 
    -0.02059473f, -0.01532439f, -0.04752968f, 0.00084700f, -0.06034673f, -0.02261077f, 0.03202192f, -0.04845031f, 
    -0.63016766f, -0.46824890f, 0.22330406f, 0.13508940f, 0.20312677f, -0.07274279f, 0.04292934f, 0.05450576f, 
    -0.04397693f, 0.02862477f, 0.03646529f, -0.00213187f, -0.01969908f, 0.03013356f, -0.00525270f, 0.01205234f, 
    -0.00715068f, -0.04067814f, -0.02084962f, -0.10071512f, -0.05992476f, -0.01371448f, 0.03102051f, 0.03977980f, 
    -0.06856677f, 0.10832954f, -0.02324175f, -0.17312761f, 0.03820288f, 0.01696526f, 0.06766026f, -0.01513301f, 
    0.00865041f, 0.03251198f, -0.02817178f, 0.05809801f, -0.02969680f, -0.23013914f, 0.08951708f, -0.03178768f, 
    0.05184019f, 0.16441038f, -0.01977669f, 0.04003609f, -0.07044810f, 0.03944439f, 0.02859925f, -0.07121306f, 
    -0.04346106f, -0.01476655f, 0.02027463f, 0.00235477f, 0.01278909f, 0.03488747f, 0.01489722f, 0.03652816f, 
    0.07668261f, 0.00827028f, -0.08320892f, -0.02546176f, -0.26391441f, -0.29842195f, 0.09917897f, 0.22824451f, 
    0.03387362f, 0.07288580f, 0.05004465f, -0.01528748f, 0.11803076f, 0.16454645f, 0.00102524f, -0.03634885f, 
    -0.05105379f, -0.07069433f, -0.09459301f, 0.01965293f, 0.05168014f, -0.02470540f, 0.11614206f, -0.03088323f, 
    -0.45348030f, -0.48511264f, 0.08705807f, -0.21741107f, 0.12295118f, -0.09368572f, -0.04281952f, 0.07533610f, 
    0.02342750f, -0.05220341f, -0.05884452f, -0.01715638f, 0.01298061f, 0.02003431f, 0.00229966f, -0.04430127f, 
    -0.01502959f, -0.00603360f, -0.00531091f, -0.08484294f, 0.37383944f, 0.10139148f, -0.31407300f, -0.16987623f, 
    -0.18308021f, -0.08951345f, -0.09628059f, -0.00922273f, 0.06171043f, -0.10632570f, 0.00733589f, -0.01223525f, 
    -0.01299249f, 0.03507582f, 0.01594734f, 0.02786268f, 0.01767508f, -0.01416702f, 0.05785529f, 0.00957242f, 
    -0.08767457f, -0.01726707f, 0.07153517f, 0.00885785f, -0.00909779f, -0.00145773f, 0.05025008f, 0.04981984f, 
    0.00793580f, -0.03271407f, 0.03542201f, -0.01821716f, 0.00142319f, 0.01072374f, -0.06582404f, -0.02803616f, 
    -0.00030892f, -0.00183970f, 0.00800507f, 0.03966225f, 0.01899701f, -0.02537216f, -0.05943267f, -0.02687157f, 
    -0.03564953f, 0.00897809f, -0.01580467f, -0.00670683f, -0.03277811f, 0.01535050f, -0.15247022f, -0.02866034f, 
    0.15673937f, 0.01579134f, -0.01323412f, 0.04197396f, 0.00873543f, -0.00529702f, -0.03705529f, -0.00513529f, 
    -0.01288418f, 0.01978948f, -0.01789038f, 0.01922204f, -0.05329931f, -0.02929389f, -0.00052996f, -0.05724994f, 
    -0.02598339f, -0.01589945f, 0.04339718f, -0.01170482f, 0.01915716f, 0.00852491f, -0.01350078f, -0.08806304f, 
    -0.13700749f, 0.00594484f, -0.01599559f, 0.00615801f, 0.08323275f, 0.09007733f, -0.12439074f, 0.04599471f, 
    -0.05790735f, -0.05705596f, 0.00824661f, -0.02306565f, -0.05213359f, -0.04856735f, -0.07196903f, 0.00507578f, 
    0.07687878f, 0.00979689f, -0.09821580f, -0.05997711f, -0.09343026f, 0.04617222f, -0.03432629f, -0.00130232f, 
    0.02420287f, 0.12033874f, -0.12987560f, -0.00030361f, -0.13300410f, -0.07276518f, -0.00040917f, -0.01719637f, 
    -0.03127141f, -0.06433318f, -0.01466333f, 0.03686428f, 0.00132831f, -0.03626256f, -0.03965299f, -0.07699713f, 
    -0.18193017f, 0.12462366f, -0.06906898f, -0.00783359f, -0.09000447f, 0.07113250f, 0.10877293f, 0.02564450f, 
    0.01144832f, -0.04007475f, -0.03144064f, 0.01579030f, -0.03258456f, -0.04677952f, 0.04870940f, 0.01414057f, 
    0.04951793f, 0.03547297f, 0.01042091f, 0.01829550f, -0.22612205f, -0.04066579f, -0.08635698f, 0.04724907f, 
    0.59853363f, -0.15114938f, -0.32610705f, -0.17243679f, -0.36804175f, 0.00999302f, -0.18634044f, -0.06199883f, 
    0.00090810f, -0.03009916f, -0.01854104f, -0.03505318f, 0.03941029f, -0.00336837f, -0.08066946f, 0.02269943f, 
    -0.03341846f, 0.07973365f, 0.02807611f, -0.00213303f, 0.21567494f, -0.15376779f, -0.09972665f, -0.08548618f, 
    -0.09000964f, 0.02162058f, 0.03182818f, 0.03717167f, -0.00609392f, 0.05000109f, -0.01042356f, 0.02243681f, 
    0.08315822f, 0.03073011f, 0.01253827f, 0.02536581f, -0.01583955f, -0.00986408f, 0.02043918f, 0.00844087f, 
    0.15149188f, -0.14481576f, 0.02035923f, -0.07599467f, 0.01492431f, 0.02276025f, 0.05681421f, 0.03147732f, 
    -0.01919396f, 0.00666242f, 0.03108970f, 0.00094747f, 0.05865766f, 0.06522541f, 0.04988375f, -0.00359601f, 
    -0.00037406f, -0.02894573f, 0.04732740f, 0.01876551f, 0.19468333f, -0.26789770f, -0.10584576f, 0.16012347f, 
    -0.05078917f, 0.01850587f, 0.11582141f, -0.04819459f, 0.13911416f, 0.08920677f, -0.00159054f, 0.00553216f, 
    -0.04239900f, -0.01329121f, -0.04648798f, -0.02552498f, -0.01106757f, -0.05429197f, 0.05932827f, -0.05803371f, 
    -0.01526018f, 0.05895055f, 0.09018557f, -0.05916314f, -0.03966334f, -0.05975618f, 0.00940648f, 0.00310554f, 
    0.04365849f, 0.00108347f, 0.00365690f, -0.03802976f, 0.06000385f, -0.01913580f, -0.07371499f, -0.00126903f, 
    -0.03355284f, 0.08469822f, -0.02714545f, 0.01297131f, -0.35329354f, -0.26821229f, -0.34065440f, -0.03621495f, 
    0.00699808f, 0.03601202f, -0.02133222f, 0.00573414f, 0.10151234f, 0.12434789f, 0.00657572f, 0.00754539f, 
    -0.04931649f, -0.05206924f, -0.01439068f, -0.05383933f, 0.00509817f, -0.06968923f, 0.06071001f, -0.04430303f, 
    0.37754169f, -0.69098395f, -0.21585961f, -0.14279196f, 0.22152787f, 0.17762931f, -0.01763192f, 0.01753319f, 
    0.15184420f, 0.03462019f, 0.08761558f, 0.08197735f, 0.05552680f, -0.10595395f, 0.02537466f, -0.04290535f, 
    0.03948734f, -0.05650518f, -0.00779206f, -0.00430486f, 0.03076622f, 0.08651944f, 0.03732522f, -0.05536463f, 
    -0.06048370f, -0.02937680f, -0.00016466f, -0.01785629f, 0.01744301f, -0.02186859f, 0.01274753f, 0.00288441f, 
    0.03942601f, -0.08982223f, -0.02820385f, 0.03466045f, -0.01150101f, 0.05016862f, 0.05764503f, 0.02604863f, 
    -0.43373546f, -0.19763638f, 0.29263985f, -0.14522387f, 0.21993586f, -0.11563601f, 0.03399492f, 0.05045886f, 
    0.00001945f, 0.04431554f, -0.15894260f, -0.02346116f, 0.05536378f, 0.03107758f, -0.03100422f, -0.01845061f, 
    -0.00290220f, 0.04448962f, -0.08473224f, -0.02606841f, -0.08818482f, -0.08908547f, 0.10938438f, 0.05082662f, 
    0.10204141f, 0.01474484f, 0.00499886f, 0.10244860f, 0.05290597f, 0.00178947f, -0.00129444f, 0.02089851f, 
    -0.02897429f, -0.03040672f, -0.10774807f, -0.12222699f, -0.01037510f, -0.12666145f, 0.09666679f, 0.05522679f, 
    -0.13382849f, 0.07016128f, -0.02824638f, -0.03701624f, -0.08047001f, 0.03689531f, 0.02339948f, 0.03675820f, 
    -0.05733014f, -0.03970179f, 0.01170924f, -0.01116992f, 0.04056690f, 0.03806791f, -0.01080480f, 0.12716328f, 
    0.00120590f, 0.01457946f, -0.04139480f, -0.03036433f, 0.04872912f, 0.03453190f, 0.08181098f, -0.10473269f, 
    -0.03826987f, 0.01593851f, 0.05691940f, -0.00773876f, -0.04514757f, -0.06284282f, -0.03300170f, -0.14012928f, 
    -0.09691165f, -0.11973896f, 0.03265705f, 0.00882111f, -0.05090758f, 0.01789852f, -0.00516137f, 0.01773252f, 
    0.17759635f, 0.05905383f, -0.19441567f, 0.11810103f, -0.22978547f, 0.14268680f, 0.00202257f, 0.28277478f, 
    -0.01108715f, -0.01261863f, -0.09207858f, -0.07357835f, 0.00250749f, -0.02515785f, -0.05266291f, -0.05416765f, 
    0.02812548f, -0.03093491f, -0.11013665f, -0.10785756f, -0.09350636f, -0.22445056f, 0.23504175f, -0.16302940f, 
    0.27504084f, 0.03562110f, -0.00151803f, 0.04268164f, -0.03106976f, -0.00210664f, 0.02801967f, -0.06089655f, 
    0.02249275f, 0.05340294f, -0.09793645f, -0.14010502f, -0.03323041f, 0.07725252f, -0.06863343f, -0.22069955f, 
    0.44331273f, -0.42100397f, -0.23608305f, -0.31493291f, -0.16316481f, 0.04914687f, 0.10100983f, -0.05536131f, 
    0.25199333f, -0.03294443f, 0.02919204f, -0.01470751f, 0.02206297f, -0.00123097f, -0.00769167f, -0.01926225f, 
    -0.01166301f, -0.03447071f, 0.00780672f, -0.01416882f, -0.33468854f, -0.02334627f, -0.06051996f, 0.20542897f, 
    -0.15085140f, -0.05394291f, 0.06813686f, -0.01623254f, -0.03918924f, 0.04382038f, 0.04559995f, 0.00935498f, 
    0.04596205f, -0.01499172f, -0.01325797f, -0.02822743f, 0.01436838f, -0.16103931f, -0.04993371f, -0.04323833f, 
    0.20353904f, -0.02185393f, -0.29935017f, -0.14760388f, -0.13298024f, -0.02943037f, -0.07535394f, -0.07189087f, 
    0.08848608f, -0.06918102f, 0.02849630f, -0.02689335f, 0.00318372f, 0.00178208f, 0.07440829f, 0.02857955f, 
    0.03235120f, 0.03107197f, 0.06373876f, 0.00793697f, -0.12651129f, -0.26700705f, -0.06693303f, -0.00797909f, 
    -0.05886415f, 0.02176957f, 0.00597360f, -0.04761922f, 0.13331771f, 0.11882012f, 0.00929037f, -0.01910815f, 
    -0.06179763f, -0.04004519f, -0.04139422f, -0.00059624f, 0.05063459f, -0.00436524f, 0.06393766f, -0.04842246f, 
    -0.15997174f, -0.07118005f, 0.03196130f, 0.10910998f, -0.11078467f, 0.03628090f, -0.00597660f, 0.11768801f, 
    0.02408838f, 0.01925183f, 0.06354722f, 0.03370306f, 0.05519310f, -0.00480782f, -0.02425084f, 0.02236282f, 
    -0.01315117f, -0.00303362f, 0.04874759f, 0.10431320f, 0.54469842f, 0.36923602f, -0.38724887f, 0.06124360f, 
    -0.54360473f, -0.11509755f, 0.07092751f, 0.02826161f, -0.16333713f, -0.09901439f, -0.09281275f, -0.03559213f, 
    0.06422711f, 0.05372922f, -0.00969169f, -0.01378770f, -0.08493692f, 0.08408273f, -0.10488363f, -0.17181367f, 
    -0.23520613f, -0.19820383f, 0.20202981f, -0.00779685f, 0.18040031f, 0.06203324f, 0.05793006f, 0.16612031f, 
    0.02192603f, 0.00408741f, 0.00507073f, 0.02079871f, 0.00077451f, -0.02644776f, 0.05817573f, -0.13755059f, 
    -0.01057148f, 0.02214892f, -0.01223748f, 0.08608163f, 0.00317519f, 0.03729805f, 0.02060378f, 0.01591734f, 
    -0.05084206f, -0.01265578f, 0.02015768f, -0.04444437f, -0.02193131f, -0.02537951f, 0.04048266f, 0.00940537f, 
    0.01586549f, -0.01861857f, -0.00851355f, -0.11459577f, -0.08607035f, -0.03767519f, 0.06592477f, 0.03173696f, 
    0.05124581f, -0.29852572f, -0.30507487f, 0.08370608f, -0.24323918f, 0.03064683f, 0.03781186f, 0.04980932f, 
    0.06149899f, 0.04754141f, 0.00183303f, -0.01615756f, -0.05143442f, 0.19295946f, 0.03402129f, -0.10354755f, 
    -0.13131058f, 0.11634758f, 0.04108968f, 0.10390610f, 0.14345792f, -0.27464408f, -0.45581436f, -0.20358665f, 
    -0.24962173f, 0.00356505f, -0.13271976f, 0.04120266f, 0.16141516f, -0.01799139f, 0.00967835f, -0.01644652f, 
    -0.03586028f, 0.05541154f, 0.08349780f, -0.00564850f, -0.00094449f, 0.03639296f, 0.03083762f, 0.00770319f, 
    0.06777798f, 0.14275870f, 0.17652544f, -0.14623176f, 0.02393825f, 0.03250977f, -0.09502359f, -0.17774576f, 
    -0.01771392f, -0.00992290f, 0.01354382f, 0.04670987f, 0.01147287f, 0.02717723f, -0.03150454f, 0.04076324f, 
    -0.11396325f, 0.01231168f, 0.03528376f, 0.00177335f, 0.05621875f, 0.01781156f, -0.02515933f, -0.01118840f, 
    -0.06116135f, -0.04294309f, 0.06591585f, -0.06430059f, 0.03049822f, 0.02146258f, -0.03679850f, 0.05125603f, 
    -0.00780431f, -0.01971656f, -0.15438296f, -0.06401405f, 0.01767665f, 0.00398505f, 0.01324343f, -0.08061608f, 
    0.28177503f, -0.39725450f, 0.19855693f, -0.53605986f, 0.09651818f, 0.11304393f, 0.03134673f, 0.00364472f, 
    0.17412929f, -0.14549613f, 0.01866721f, 0.02289294f, 0.00621565f, -0.07479898f, 0.02443809f, -0.01042831f, 
    -0.02292080f, 0.00416040f, 0.02614477f, 0.12193526f, -0.41395497f, -0.32106468f, -0.47403428f, 0.05724028f, 
    0.01605496f, 0.04512956f, -0.01750648f, 0.12569328f, -0.07923842f, 0.03550095f, -0.00173809f, -0.01352888f, 
    -0.01754947f, -0.03860961f, -0.06368157f, 0.06636703f, -0.03667765f, 0.08236546f, 0.06433844f, 0.04344006f, 
    0.47164348f, -0.55570441f, -0.41562897f, 0.08226463f, -0.04849219f, 0.10377515f, 0.08902194f, -0.02940348f, 
    0.07768448f, -0.07424217f, 0.09549174f, -0.00982389f, -0.00218278f, -0.05384981f, -0.03950507f, 0.00531379f, 
    -0.05086965f, 0.09328800f, -0.00761205f, -0.10132662f, 0.00256514f, 0.05052869f, 0.01573663f, 0.03402720f, 
    -0.11899675f, -0.04984692f, 0.04809765f, -0.03550662f, -0.07288796f, -0.09553742f, -0.02451632f, 0.03055382f, 
    0.01766482f, -0.03834840f, 0.01181163f, -0.23330747f, -0.08872111f, 0.03711380f, -0.02944872f, 0.00349257f, 
    -0.07571027f, 0.01458464f, 0.14152676f, -0.06964745f, 0.08902439f, 0.00027488f, 0.01761115f, -0.02718219f, 
    0.06940344f, 0.00714891f, -0.15996216f, -0.05118546f, 0.01985140f, 0.04666240f, 0.01748179f, 0.01006642f, 
    -0.01798925f, -0.04138934f, -0.01068972f, 0.00349406f, 0.18906243f, -0.16197284f, 0.12974417f, -0.07615229f, 
    0.10932256f, -0.03430991f, 0.05771125f, -0.06299949f, -0.00166201f, -0.00899182f, 0.10278505f, -0.02015006f, 
    -0.00155347f, -0.00230257f, 0.01624443f, -0.16216078f, 0.08317576f, -0.05909551f, 0.00227103f, 0.00092982f, 
    0.19314010f, 0.29627573f, -0.28968996f, 0.02478216f, -0.25750914f, 0.08172090f, 0.06736574f, 0.04504461f, 
    -0.06532037f, -0.05932414f, -0.10791757f, 0.06160660f, 0.11835890f, 0.01072097f, -0.16513926f, -0.01225028f, 
    -0.03356810f, 0.01498607f, -0.05355927f, -0.11304108f, 0.14069758f, 0.08709686f, -0.10606252f, -0.00505998f, 
    -0.20853350f, 0.02133852f, 0.00448076f, -0.00163293f, 0.04212689f, -0.01582530f, -0.01378977f, -0.02232216f, 
    -0.06438659f, -0.10402580f, -0.08911449f, 0.00665741f, 0.02886069f, -0.02736037f, 0.03027148f, 0.05557121f, 
    -0.02181607f, -0.04833236f, 0.17806737f, -0.13891532f, 0.10629351f, -0.04118339f, -0.01378603f, -0.00603144f, 
    0.00297619f, -0.03773411f, 0.09257290f, -0.03594286f, -0.00074561f, -0.01271676f, -0.04136778f, -0.04089414f, 
    -0.04747508f, -0.01789238f, 0.08826484f, -0.08200214f, -0.06444631f, 0.03620391f, 0.01016168f, 0.13898323f, 
    -0.08050314f, 0.02624251f, 0.06101228f, 0.06581615f, -0.03551314f, -0.02781039f, 0.06179342f, 0.00968217f, 
    0.02844915f, 0.01956127f, 0.02185511f, -0.03897076f, 0.00011920f, -0.06317302f, -0.11509765f, 0.10825791f, 
    0.02902254f, 0.05857405f, -0.04051388f, -0.01099704f, -0.10292860f, -0.00851351f, -0.01474525f, 0.02117445f, 
    -0.04727590f, -0.01531791f, -0.00295895f, -0.05562743f, 0.01704070f, -0.05010903f, -0.01078331f, 0.00772503f, 
    -0.03637414f, 0.10474097f, -0.04385917f, 0.02826669f, -0.18233030f, -0.15893099f, 0.15567310f, -0.01348133f, 
    0.08655445f, 0.02708086f, -0.10157546f, 0.01653740f, 0.11055820f, 0.02383777f, 0.00603120f, 0.14077739f, 
    0.07193112f, 0.05449861f, -0.00355267f, 0.01474777f, -0.01536658f, 0.00364227f, -0.07542821f, -0.04452902f, 
    -0.14447030f, -0.05491466f, 0.05322875f, -0.02546428f, 0.05161459f, -0.03578836f, -0.00477273f, -0.01668327f, 
    -0.01315418f, -0.00163982f, -0.09552690f, -0.05640148f, 0.05227561f, 0.04141768f, -0.02085129f, -0.00647012f, 
    -0.02921752f, -0.01848768f, -0.04799334f, 0.01476256f, -0.43948862f, -0.31480250f, 0.07938807f, 0.16949458f, 
    0.24876826f, 0.04547584f, -0.00735844f, 0.04992479f, 0.01676350f, 0.05942953f, 0.01098429f, -0.00100749f, 
    -0.05047072f, -0.06486333f, -0.10716733f, 0.00932400f, 0.00372184f, -0.05492019f, 0.04442351f, -0.07133105f, 
    0.00876674f, -0.03484627f, -0.07910968f, 0.04892879f, -0.02706183f, 0.04148411f, -0.01346870f, -0.14317380f, 
    -0.20430651f, -0.05767184f, 0.03158924f, 0.00550633f, -0.01792436f, 0.00740667f, -0.01192301f, -0.06709769f, 
    0.01046788f, -0.09198307f, 0.00175966f, 0.00771479f, -0.01018207f, 0.11420917f, -0.00872853f, 0.34532464f, 
    -0.09951404f, -0.02640368f, 0.04410115f, -0.08364434f, -0.03375198f, -0.01640888f, 0.01243978f, -0.01514696f, 
    0.01489854f, 0.00258652f, -0.02036950f, 0.01345955f, 0.06483751f, -0.07360077f, -0.02331574f, 0.06188110f, 
    -0.31377089f, -0.07475263f, -0.31811041f, 0.03386803f, -0.11205282f, 0.09633342f, 0.00328387f, -0.08435374f, 
    -0.05460946f, -0.01074119f, 0.02432080f, -0.02109104f, -0.01761732f, 0.00580950f, -0.01036664f, 0.04564160f, 
    0.02813039f, 0.03401230f, -0.11727394f, -0.02893139f, 0.27479276f, -0.39580724f, -0.33754626f, -0.26628497f, 
    -0.16354251f, 0.01733624f, -0.03736983f, -0.04549998f, 0.19509056f, 0.03377482f, -0.00476280f, -0.01423722f, 
    -0.06219593f, -0.02019060f, 0.05450754f, -0.07703684f, -0.03258234f, -0.01634938f, 0.02333471f, -0.04190128f, 
    -0.24174507f, 0.16376916f, 0.26083520f, 0.06746199f, 0.03471456f, 0.02117153f, 0.09778906f, -0.01240898f, 
    -0.01128793f, -0.10456195f, 0.05587804f, -0.02125966f, 0.03396911f, -0.00456922f, 0.04735782f, 0.05264927f, 
    0.19325221f, 0.00075900f, 0.03319308f, -0.05791073f, 0.28727388f, -0.47614866f, 0.20172222f, -0.37615225f, 
    0.20329981f, 0.03553610f, 0.03396535f, -0.12103139f, 0.20630087f, 0.07889781f, -0.01218224f, 0.06869591f, 
    -0.09094594f, -0.08009049f, 0.07729895f, -0.08662640f, 0.01574514f, 0.04527261f, 0.01453275f, -0.00900129f, 
    0.50242633f, 0.05785545f, 0.09455290f, -0.26324657f, -0.08471555f, -0.09861342f, 0.10077068f, 0.11884495f, 
    -0.00401831f, -0.12863821f, -0.04133771f, -0.11244702f, 0.11868774f, -0.02246537f, 0.07290389f, -0.06109494f, 
    -0.06265348f, 0.07721479f, -0.03154946f, -0.05200079f, 0.04193861f, -0.01345734f, -0.00844185f, -0.02506956f, 
    -0.00257824f, 0.03397688f, 0.01790742f, 0.01809511f, -0.03999738f, -0.00855357f, -0.04076042f, -0.04295232f, 
    -0.15065762f, -0.12108504f, -0.10714241f, 0.01163369f, -0.00441482f, 0.04699889f, 0.02830700f, 0.01048189f, 
    -0.02345182f, -0.00077904f, 0.01979041f, -0.03689369f, -0.15074101f, -0.06681594f, -0.00217579f, 0.03077890f, 
    0.05155125f, -0.06542213f, -0.07260276f, -0.02678993f, -0.01566469f, 0.00866335f, 0.05099674f, 0.06533866f, 
    0.11731549f, -0.00109740f, 0.04771890f, 0.05454980f, 0.24030149f, 0.17181276f, -0.14537258f, -0.00842663f, 
    0.08975663f, 0.02492618f, -0.12988415f, -0.00514307f, 0.00747443f, -0.03475561f, -0.01389287f, 0.10411274f, 
    0.01797477f, 0.09844816f, 0.04981472f, -0.11147867f, -0.06964233f, -0.15099351f, -0.15502311f, -0.13138504f, 
    0.02509404f, -0.23136033f, -0.31752041f, -0.14078672f, 0.07904617f, 0.01697304f, -0.04792935f, 0.04102138f, 
    0.09598470f, 0.16043751f, -0.00581754f, -0.06399859f, -0.06058784f, -0.01891094f, -0.00331180f, -0.00066329f, 
    0.02521629f, 0.05458573f, -0.01198159f, 0.03671882f, -0.04651780f, -0.05624984f, -0.05499794f, 0.04127395f, 
    -0.03055662f, 0.02772987f, -0.07170917f, 0.08811589f, 0.10649142f, 0.06676385f, 0.05153282f, 0.01529119f, 
    0.06117242f, -0.04479957f, 0.16873467f, -0.01569470f, -0.00769989f, 0.06060690f, -0.04836260f, 0.12418220f, 
    0.38268617f, -0.34767610f, -0.21270239f, -0.07008202f, -0.04014063f, 0.04396933f, -0.05820149f, -0.01153422f, 
    0.09320664f, 0.01541647f, -0.01687695f, 0.06372470f, 0.06523549f, -0.02644296f, 0.05867512f, 0.02653130f, 
    0.04163562f, 0.08501787f, -0.00301493f, 0.07109171f, -0.00877332f, -0.02089025f, 0.09015681f, 0.11978302f, 
    -0.18441868f, 0.09399764f, -0.04958285f, -0.00789269f, -0.06910868f, -0.10274690f, 0.02043970f, 0.02387978f, 
    -0.01516858f, -0.03395263f, 0.00697180f, -0.01027124f, -0.02249137f, 0.14239010f, -0.01036951f, 0.07803373f, 
    -0.28390598f, 0.02830238f, 0.19654609f, 0.12655891f, -0.08567636f, -0.01149493f, -0.06774242f, -0.10565453f, 
    -0.03314292f, -0.05567555f, -0.03963033f, -0.01741135f, -0.03118490f, -0.06679226f, -0.05300609f, -0.03081840f, 
    -0.07574197f, -0.13168144f, -0.07195637f, -0.18280937f, -0.02393043f, -0.21099381f, -0.23462686f, -0.24739353f, 
    -0.19833918f, -0.13394339f, -0.25873747f, -0.09884204f, -0.16052999f, -0.36213514f, 0.01935090f, 0.02562185f, 
    -0.00296443f, 0.03363561f, 0.02996606f, 0.10035601f, 0.08781346f, 0.13639195f, -0.07410497f, -0.25591332f, 
    0.23767397f, -0.44072455f, -0.34212792f, -0.04656604f, 0.19502193f, 0.06094848f, -0.01494977f, 0.12451417f, 
    0.01041563f, 0.10569836f, 0.00580656f, -0.04249609f, -0.00355673f, 0.01127781f, 0.05427277f, 0.00232783f, 
    0.01553351f, 0.05298685f, -0.00683264f, 0.02239211f, -0.06813519f, -0.56997299f, -0.36309519f, -0.16676679f, 
    0.00376730f, -0.08348469f, 0.08919793f, 0.10816905f, 0.08104829f, 0.12882920f, 0.03520958f, -0.01193803f, 
    -0.04043719f, 0.00510980f, -0.05122573f, -0.00816469f, -0.04420510f, -0.02906781f, 0.01478124f, -0.03896795f, 
    0.01662102f, -0.01023192f, 0.01967276f, -0.04143179f, -0.09354238f, -0.03551983f, -0.11144999f, -0.07228357f, 
    -0.04506778f, -0.07708580f, -0.03302671f, 0.06947558f, 0.03702058f, -0.05772360f, 0.09370890f, 0.03407061f, 
    0.06780866f, 0.07465266f, 0.09149867f, 0.14437945f, -0.12086520f, -0.05223009f, 0.00409925f, -0.02362208f, 
    -0.02180919f, -0.09548539f, 0.02051910f, -0.01468333f, -0.01385815f, -0.01123871f, 0.09875075f, 0.04046938f, 
    -0.02029272f, -0.01822845f, -0.02542395f, -0.04146392f, 0.08982754f, 0.06932262f, 0.15378675f, 0.05562978f, 
    -0.28755823f, 0.11377562f, 0.12168494f, 0.08541194f, -0.11507261f, -0.01365958f, -0.01077459f, -0.01126945f, 
    0.00375379f, -0.03494197f, -0.07810993f, 0.00214102f, 0.03667953f, -0.00290055f, 0.05004434f, -0.02401818f, 
    0.00944502f, 0.01775176f, -0.02605585f, -0.00319927f, 0.08069057f, 0.01073013f, -0.02561627f, -0.02151699f, 
    -0.08504453f, -0.00930786f, -0.01973985f, 0.02937900f, 0.03997575f, -0.03514254f, -0.02067414f, 0.01856055f, 
    0.00531769f, 0.04190044f, 0.05658667f, -0.00493365f, 0.14012749f, 0.00954905f, 0.12490363f, 0.04670001f, 
    0.09307276f, 0.09262365f, 0.08347495f, -0.02237639f, -0.16087109f, -0.01636388f, 0.03787847f, -0.02305466f, 
    0.03035988f, -0.02631939f, -0.01798780f, 0.02233535f, -0.03262226f, 0.00361512f, 0.03808498f, 0.01749243f, 
    0.15299983f, -0.02490683f, 0.03357577f, 0.01170263f, -0.57504916f, -0.09093094f, 0.16872548f, 0.07956994f, 
    0.05723982f, -0.05970748f, 0.04381951f, -0.01928730f, -0.01844532f, 0.02922505f, -0.05270394f, -0.02024926f, 
    -0.00985851f, 0.05092271f, -0.00108039f, 0.03708331f, 0.01359904f, 0.06507786f, 0.05993228f, 0.03523174f, 
    -0.09746811f, -0.64298087f, -0.37908000f, -0.04104342f, 0.11424413f, -0.07993242f, 0.17238571f, 0.15686297f, 
    0.12681201f, 0.03759070f, 0.03457147f, -0.09196494f, -0.00367210f, -0.02912581f, -0.06842604f, 0.00352821f, 
    0.00485233f, -0.06352251f, -0.01557834f, -0.04391729f, -0.04922625f, -0.14183915f, -0.19376288f, -0.05236053f, 
    -0.03669123f, -0.08873166f, -0.05864666f, 0.03729481f, 0.05385831f, 0.07355047f, -0.00700786f, -0.02556750f, 
    -0.01670041f, -0.03097552f, -0.02171612f, -0.05551022f, 0.08639406f, 0.09354728f, 0.08009658f, 0.05435802f, 
    -0.04209379f, -0.14574015f, -0.14952146f, -0.07326702f, 0.01074474f, -0.04320145f, -0.05423830f, -0.01446537f, 
    0.03102749f, 0.13235100f, 0.01262444f, 0.12226677f, -0.07964030f, -0.10999759f, -0.03265597f, 0.00254116f, 
    0.05034444f, 0.10535252f, 0.05324535f, 0.08635150f, -0.15466656f, -0.43265203f, -0.41282466f, -0.34621471f, 
    -0.12925704f, -0.06491555f, -0.20723353f, -0.04199385f, 0.06398905f, -0.05412653f, -0.02406750f, 0.00902296f, 
    -0.02200006f, 0.02186493f, 0.01475854f, 0.01949081f, 0.02768260f, 0.04076147f, 0.06368639f, 0.10554823f, 
    -0.16451150f, -0.02400211f, 0.00334409f, 0.00639504f, -0.06793698f, -0.02594027f, -0.07909090f, 0.03110234f, 
    0.04691370f, -0.08075261f, -0.01367020f, 0.04494502f, -0.03114552f, -0.01071628f, 0.05707011f, -0.01065917f, 
    0.01489645f, 0.07554529f, 0.05475369f, 0.09999845f, -0.01422963f, -0.38198861f, -0.43851542f, -0.31333876f, 
    -0.07681470f, -0.13030596f, -0.03122714f, 0.06734080f, -0.06225939f, -0.23333555f, -0.01623813f, -0.02142846f, 
    0.01510142f, 0.06865510f, 0.03728557f, 0.03137701f, 0.01127260f, 0.08919819f, -0.07911545f, -0.13929470f, 
    -0.04363267f, 0.12712857f, -0.30579293f, -0.08303354f, -0.30147979f, 0.12464453f, 0.11135102f, 0.07981279f, 
    0.08854744f, -0.04623976f, 0.04434510f, -0.00408044f, -0.10777082f, 0.08472032f, 0.08360378f, -0.00079626f, 
    0.02906346f, -0.00369798f, 0.03222401f, -0.02665869f, -0.15544109f, -0.01520248f, 0.01818441f, -0.07653965f, 
    -0.13768336f, -0.04068616f, -0.03472751f, 0.00329005f, -0.01988336f, -0.02809146f, -0.09050115f, -0.04360726f, 
    0.01980064f, 0.01928024f, 0.05808698f, -0.02368562f, 0.00617299f, -0.01708404f, 0.03409557f, 0.02604561f, 
    -0.01632916f, -0.34787863f, -0.02343878f, 0.16922158f, 0.08197612f, 0.03201381f, 0.06921758f, 0.03172840f, 
    -0.00318634f, 0.15993971f, 0.05184689f, -0.01534961f, 0.00141576f, 0.01646730f, 0.02951091f, -0.03248062f, 
    0.09224530f, -0.03226717f, 0.13026997f, 0.08357501f, -0.19266954f, -0.19529206f, 0.13478664f, 0.17874406f, 
    0.02047071f, -0.03856155f, -0.06246720f, -0.01711799f, -0.00147849f, -0.01686961f, 0.02677515f, -0.09343312f, 
    0.00466023f, -0.00744961f, 0.09971257f, -0.07639963f, -0.05433234f, 0.04809037f, -0.14136790f, -0.02964076f, 
    -0.76148432f, -0.06610557f, 0.24014430f, 0.14326245f, -0.00200011f, -0.00458078f, -0.10242987f, -0.03666236f, 
    -0.06902382f, -0.08815659f, -0.04761871f, -0.06845856f, -0.01828215f, -0.05132310f, -0.03734635f, -0.09940834f, 
    -0.09731195f, -0.09910020f, -0.15921253f, -0.15041104f, -0.08216725f, 0.03715798f, 0.00859190f, 0.03018361f, 
    -0.03811760f, 0.01545195f, -0.00789931f, 0.01062882f, -0.01420352f, 0.03979245f, 0.08395175f, 0.08101470f, 
    0.03342006f, 0.07699906f, 0.01460775f, -0.03059689f, 0.04255590f, -0.07852796f, 0.03887002f, 0.01274742f, 
    0.29949316f, 0.19797817f, -0.11457396f, -0.15602188f, -0.09043364f, -0.13691130f, 0.12820983f, 0.02548401f, 
    -0.02122190f, -0.28349099f, 0.04116596f, 0.04144030f, 0.11693080f, -0.00744245f, 0.02732931f, -0.09755684f, 
    0.04562634f, 0.06868305f, 0.16450268f, 0.06439365f, 0.32965338f, -0.46928683f, 0.02155202f, 0.16319336f, 
    0.20360155f, 0.05729191f, -0.09608393f, -0.06265156f, -0.01790900f, 0.06950467f, 0.07025348f, -0.01098033f, 
    0.07611016f, 0.06641552f, 0.00597262f, -0.05260666f, 0.02074378f, -0.00350524f, -0.29278743f, 0.03869314f, 
    -0.16661800f, -0.33532983f, -0.51602995f, -0.47233444f, -0.01545672f, 0.03782939f, -0.04945998f, 0.17395194f, 
    0.01233159f, -0.07228864f, -0.04990107f, -0.00418220f, -0.06312770f, 0.03156114f, -0.00008019f, 0.02368275f, 
    -0.02375753f, 0.05016803f, -0.00202969f, 0.01182861f, 0.21555564f, 0.15078682f, 0.22204863f, -0.04840293f, 
    -0.14466879f, 0.13796058f, -0.18059205f, -0.09697992f, -0.08876497f, -0.41332641f, -0.04438141f, -0.01421205f, 
    -0.01673696f, -0.03318459f, -0.00742869f, 0.04021726f, 0.07970446f, -0.04353250f, -0.03515410f, -0.24414775f, 
    0.01326076f, -0.28998259f, -0.20124766f, -0.04468729f, 0.04440105f, -0.08468932f, 0.08289306f, 0.09168061f, 
    0.10126559f, 0.09289387f, 0.07857763f, -0.04173499f, -0.07815541f, -0.03806174f, -0.03577428f, -0.01850325f, 
    -0.00305107f, 0.01725749f, -0.00272829f, -0.04437347f, 0.06623216f, -0.11801640f, -0.32384512f, -0.26808575f, 
    -0.09556305f, -0.05912185f, -0.12636854f, -0.04841683f, -0.16461769f, -0.24378037f, 0.01626722f, -0.00498000f, 
    -0.00770543f, 0.09805431f, 0.07064378f, 0.08081917f, 0.01919014f, 0.09280707f, -0.08393583f, -0.27547431f, 
    0.00521772f, 0.03729503f, 0.01903382f, -0.00693899f, -0.19975539f, -0.03401932f, -0.08651930f, -0.21655895f, 
    -0.08394869f, -0.18566161f, -0.05334371f, 0.04917243f, 0.04835159f, -0.01128572f, 0.03440175f, -0.02075240f, 
    0.11228531f, 0.16883580f, 0.11295085f, 0.11714277f, 0.55594730f, 0.05294956f, -0.07677888f, -0.08698916f, 
    -0.05725526f, 0.00687727f, 0.21180120f, -0.03381279f, 0.11816169f, -0.07234207f, 0.09293816f, 0.04724878f, 
    0.07901079f, -0.01044882f, 0.01098667f, 0.05198443f, 0.07632220f, -0.12463729f, 0.00164485f, 0.01467500f, 
    -0.30306530f, -0.62586230f, 0.04375940f, 0.14234583f, 0.33169553f, -0.00021474f, 0.00441475f, 0.00577468f, 
    -0.08376130f, -0.03082484f, 0.10400342f, 0.02704352f, -0.00685786f, 0.10925270f, 0.05931304f, 0.04092037f, 
    -0.08331613f, 0.00194111f, -0.06639038f, -0.06783810f, -0.14408559f, 0.11018817f, 0.09081991f, 0.01791111f, 
    -0.11865478f, -0.01943752f, -0.06555961f, 0.01407956f, 0.00225003f, -0.02405016f, -0.05587363f, -0.02568165f, 
    0.02837870f, 0.01840382f, 0.04221338f, -0.04494339f, 0.05972064f, 0.09106836f, 0.01856047f, 0.05557178f, 
    0.14112607f, -0.01941646f, -0.23988727f, -0.06174189f, 0.17145191f, 0.03661993f, 0.09910523f, -0.09630931f, 
    0.12269159f, 0.03269909f, 0.00994078f, 0.00015551f, -0.02544428f, -0.11286782f, -0.02985858f, 0.12841615f, 
    -0.03202746f, -0.06264953f, -0.08254914f, -0.18621862f, 0.00666430f, -0.43379134f, -0.37920120f, -0.10408414f, 
    0.14777030f, -0.03276389f, 0.09393404f, 0.15915549f, 0.06695379f, 0.11175950f, 0.01922575f, -0.12159136f, 
    -0.03645984f, 0.03733321f, -0.03598394f, -0.02442226f, -0.02805111f, -0.04906653f, -0.06015998f, -0.10253838f, 
    0.18314473f, -0.21500224f, 0.07801270f, 0.03412880f, -0.18102747f, 0.10000231f, -0.05231646f, -0.09670763f, 
    -0.00165782f, -0.09797432f, 0.01088733f, 0.02690493f, -0.00268902f, -0.00892204f, 0.02751204f, 0.09524564f, 
    0.10280378f, -0.03810706f, -0.05447358f, 0.07564088f, -0.01535520f, 0.12467238f, -0.12863623f, -0.01842675f, 
    -0.16545494f, -0.02262327f, -0.06050674f, -0.05546896f, -0.00150180f, -0.07538383f, -0.06063599f, 0.07297590f, 
    0.06681130f, 0.09650062f, -0.01525038f, -0.12102585f, -0.08387478f, -0.06137769f, -0.07915523f, 0.08344714f, 
    0.16770959f, -0.01632031f, -0.41211119f, 0.04755900f, -0.10546879f, -0.07002763f, 0.03244830f, 0.08078887f, 
    0.01596651f, 0.10464419f, 0.03331652f, 0.00290252f, -0.01871041f, 0.04593683f, 0.10387313f, 0.07107868f, 
    0.03401861f, 0.06292451f, 0.01283725f, 0.03114527f, 0.49081549f, 0.00458685f, -0.16650268f, 0.12461935f, 
    0.11881383f, 0.08140066f, 0.10752935f, 0.09175616f, 0.06075043f, 0.09242889f, 0.06936132f, -0.03348207f, 
    0.05411550f, 0.00187871f, 0.03989552f, 0.00806414f, -0.01739497f, -0.02210530f, 0.03713340f, -0.16404755f, 
    0.11372197f, -0.47013927f, -0.40389505f, -0.10531726f, 0.01967175f, 0.14791495f, 0.06197879f, 0.19149339f, 
    0.17172131f, 0.08374505f, 0.00081048f, -0.01292954f, 0.04326505f, 0.03698795f, -0.02343468f, 0.01814134f, 
    -0.04748465f, -0.10058332f, 0.05728213f, -0.00905281f, 0.11820860f, 0.24662445f, 0.05779269f, -0.03953520f, 
    -0.09135643f, -0.04196438f, 0.01522993f, -0.02572266f, 0.05010987f, -0.04074238f, -0.02968368f, -0.04688102f, 
    0.01294487f, 0.00843445f, 0.03389863f, 0.01138221f, 0.04021510f, -0.03025139f, 0.03969294f, -0.04202935f, 
    -0.17892049f, -0.10801347f, -0.06025171f, 0.03241122f, -0.01037022f, 0.00665615f, -0.01355468f, -0.03485516f, 
    -0.02035055f, 0.00822674f, 0.01037646f, 0.13603382f, 0.01987449f, 0.07152861f, -0.02168038f, -0.00226516f, 
    0.04326366f, 0.10463442f, 0.04993539f, 0.12094029f, 0.14409004f, 0.18316621f, -0.04803312f, 0.01564455f, 
    -0.03709847f, 0.07672110f, -0.06698818f, 0.08476064f, 0.09739009f, -0.09991993f, -0.04655623f, 0.03234962f, 
    0.00552608f, -0.05511921f, -0.02272324f, -0.16914968f, 0.01604482f, -0.05646387f, 0.11829074f, 0.04756102f, 
    0.22081690f, 0.15243722f, -0.22075400f, -0.22882865f, -0.16662917f, -0.11440309f, 0.06633329f, 0.00712487f, 
    0.10220943f, -0.05320274f, 0.09772466f, 0.02836930f, 0.05566699f, 0.00288042f, 0.00713530f, 0.08722524f, 
    0.01266169f, -0.03408680f, 0.06512632f, 0.04585209f, -0.03558042f, -0.00015482f, -0.05330549f, -0.09588448f, 
    -0.14834408f, -0.09771288f, -0.02568147f, -0.05725880f, 0.03451378f, -0.02813100f, 0.03683768f, 0.07594512f, 
    0.09689944f, 0.03758266f, -0.01090358f, -0.03274642f, -0.03059049f, -0.02853551f, -0.01699019f, -0.03889576f, 
    -0.05441080f, -0.05176754f, -0.03029996f, 0.07863251f, 0.06775447f, 0.09750661f, -0.01560651f, 0.01063853f, 
    0.03447075f, 0.05709988f, -0.00393600f, -0.03389185f, 0.07594904f, 0.01229371f, 0.07730161f, -0.02289077f, 
    -0.02301342f, 0.09455342f, -0.04135469f, 0.11156665f, -0.49433774f, 0.04828034f, 0.27857748f, 0.03413230f, 
    0.02376675f, -0.09841073f, -0.02290438f, -0.08869400f, -0.02932626f, -0.07611964f, -0.12082845f, -0.02476983f, 
    0.03875322f, -0.09061230f, 0.01844276f, -0.15752995f, -0.05528862f, -0.15469305f, -0.04291938f, -0.18065307f, 
    -0.01214804f, 0.06646550f, 0.05291757f, -0.02647974f, -0.07990267f, -0.04084526f, 0.07429619f, -0.02165469f, 
    0.00365022f, -0.03415739f, 0.01727851f, 0.02300445f, 0.02281621f, 0.05880508f, 0.01355067f, 0.01794521f, 
    0.05881476f, 0.01444904f, 0.13322143f, 0.05797758f, -0.08238943f, -0.18902050f, -0.12639637f, 0.01244341f, 
    0.18028329f, 0.02796761f, -0.04854904f, -0.00254051f, 0.01319981f, 0.01080808f, -0.06283384f, 0.09223146f, 
    0.10445812f, -0.01262458f, -0.00867016f, -0.03531252f, 0.03289812f, 0.06667626f, 0.03084303f, 0.10690886f, 
    -0.16532145f, -0.09075308f, -0.00811644f, 0.04718892f, 0.00013619f, -0.01345637f, -0.00847535f, -0.04191552f, 
    -0.00646476f, -0.00743441f, 0.00286807f, 0.07822177f, 0.05291364f, 0.01529729f, 0.02615353f, -0.00340476f, 
    0.09994630f, 0.07764879f, 0.08247513f, 0.11256751f, 0.19839174f, -0.34173122f, -0.17023551f, -0.03970726f, 
    0.02394108f, 0.07810249f, 0.04121821f, 0.03371784f, -0.02744566f, -0.23320252f, -0.01033932f, 0.05219596f, 
    0.06269735f, 0.02138050f, 0.00147055f, 0.09210969f, 0.02643687f, 0.06318068f, -0.06614745f, -0.08985653f, 
    0.31042361f, 0.25549716f, 0.10678568f, 0.12325543f, -0.17696057f, 0.12221882f, -0.10878745f, -0.03838663f, 
    -0.02466782f, -0.08778691f, 0.00078712f, 0.00242366f, 0.05626491f, -0.03744155f, -0.02186759f, -0.10610166f, 
    0.00887824f, 0.00406792f, 0.03682087f, -0.06291848f, 0.29428074f, 0.16135901f, 0.09306747f, -0.10325030f, 
    -0.14577076f, 0.04760644f, -0.03297182f, -0.05705328f, 0.01429361f, -0.11367203f, 0.00388113f, 0.00544285f, 
    -0.02910589f, -0.01817001f, -0.00915954f, -0.00368486f, -0.10344976f, -0.34515142f, -0.09231655f, -0.26132327f, 
    0.19270548f, 0.07276466f, -0.09245373f, 0.07512009f, 0.02101872f, 0.03764758f, 0.05060565f, -0.00941024f, 
    0.00500186f, -0.09497400f, 0.04859889f, -0.00336875f, 0.12190103f, 0.04687391f, -0.05479858f, 0.00153883f, 
    -0.02790234f, 0.01483905f, 0.09951423f, 0.09977427f, -0.04686773f, -0.22210537f, -0.45893359f, -0.35617882f, 
    0.03124296f, -0.00579822f, 0.09462316f, 0.05335475f, 0.06652385f, -0.03048582f, -0.00017456f, -0.01346193f, 
    -0.05294470f, 0.06859429f, 0.03396023f, 0.05636054f, -0.01666768f, 0.05737647f, -0.03087007f, 0.05356444f, 
    -0.20415743f, 0.07775546f, 0.08279321f, 0.08027072f, -0.03926614f, 0.12684651f, -0.03057163f, 0.07462002f, 
    -0.04978546f, -0.12969127f, -0.04031336f, -0.03215244f, -0.00549692f, -0.03357694f, 0.01273132f, -0.05874545f, 
    -0.03023551f, -0.07698579f, -0.16553104f, -0.23055822f, 0.07365709f, 0.16704744f, -0.34261858f, -0.24266757f, 
    0.05047306f, 0.07100939f, -0.23630564f, 0.03565966f, 0.18577039f, -0.08468542f, 0.05431213f, 0.06421810f, 
    0.05141913f, 0.11930062f, 0.06756257f, -0.01718682f, -0.01322388f, -0.03106732f, -0.08925764f, -0.01490628f, 
    0.35909972f, -0.13845573f, -0.05259636f, -0.00205455f, -0.01383246f, 0.05810262f, -0.02487701f, 0.12836060f, 
    0.07231239f, 0.14305046f, 0.05856847f, 0.11646675f, -0.08677557f, -0.02838496f, 0.12173714f, -0.01775865f, 
    0.11288315f, -0.00154516f, -0.10402045f, 0.13379742f, -0.08371463f, -0.13980167f, -0.07665551f, -0.07217124f, 
    -0.08827818f, 0.00170469f, -0.07837703f, -0.02908034f, -0.02345395f, -0.06405947f, 0.12999679f, 0.03499625f, 
    0.05227733f, 0.08929496f, 0.06600361f, -0.03491915f, 0.01060848f, -0.02438755f, -0.05078305f, -0.00517718f, 
    -0.39074028f, 0.13625555f, -0.17681579f, 0.00174534f, -0.05597047f, 0.06958876f, -0.12587184f, 0.07380793f, 
    -0.03766664f, -0.01689549f, 0.08004940f, -0.04617589f, 0.04668680f, 0.02603734f, -0.02149729f, 0.00987585f, 
    0.03973021f, -0.03671110f, 0.03849980f, 0.02933802f, -0.12563124f, -0.24043253f, -0.24758783f, 0.01947738f, 
    -0.10137951f, -0.03213424f, 0.05014795f, 0.02965851f, -0.07390571f, 0.03043896f, 0.16654825f, -0.09654581f, 
    0.01689333f, 0.08122404f, -0.07328057f, -0.05864713f, 0.10654090f, -0.07865700f, 0.11791046f, 0.17757662f, 
    0.09966119f, -0.05311971f, 0.10723636f, 0.11585961f, -0.19849686f, 0.00889699f, -0.02766505f, -0.13530840f, 
    0.01812299f, 0.00742652f, 0.05703146f, -0.03229962f, 0.06617542f, 0.00948936f, 0.01210576f, 0.03383341f, 
    -0.03916535f, 0.00745568f, 0.02652603f, -0.05503007f, 0.22530557f, -0.25968540f, -0.01886958f, 0.06561690f, 
    -0.02362102f, -0.06410769f, 0.11482044f, -0.05261872f, -0.00114570f, 0.02848246f, -0.04202064f, -0.02170844f, 
    0.01096472f, -0.12107814f, 0.08096343f, 0.07224564f, -0.02865507f, 0.05914575f, -0.10545884f, -0.03089438f, 
    0.20755395f, 0.05086482f, 0.27752146f, -0.07811483f, -0.27123898f, -0.03418161f, -0.17899770f, 0.07776609f, 
    0.12669381f, 0.14245768f, -0.10094821f, 0.03573617f, 0.03416976f, -0.00592350f, -0.02358893f, 0.01739618f, 
    -0.01870913f, -0.04730410f, -0.07973015f, -0.16344070f, 0.05978110f, 0.09022858f, -0.47982150f, -0.02483996f, 
    -0.14348462f, 0.15871017f, 0.03995599f, 0.18156679f, 0.01309134f, 0.10263097f, -0.02913653f, -0.03196118f, 
    -0.04951658f, -0.00900561f, -0.00465375f, -0.01437652f, 0.02202071f, 0.02656561f, -0.00312959f, -0.07756578f, 
    -0.15240900f, -0.13749935f, -0.30636516f, -0.06017242f, 0.08135046f, 0.10902730f, 0.03648835f, 0.09927385f, 
    0.07993536f, 0.09442997f, -0.02205397f, -0.03339488f, -0.00976735f, 0.05924228f, -0.04814109f, -0.05598266f, 
    0.04204581f, 0.03429246f, 0.04418653f, 0.09220561f, -0.10023040f, -0.31730241f, -0.08871254f, 0.09788654f, 
    -0.11556413f, -0.02298290f, -0.12657028f, -0.00931370f, 0.04568181f, 0.18417782f, 0.00191950f, 0.05621481f, 
    0.03297166f, 0.01675754f, -0.01706794f, -0.04648534f, 0.06272370f, 0.12679827f, 0.15598239f, 0.11332453f, 
    -0.00499190f, -0.25010782f, 0.15515447f, -0.03300719f, -0.49885991f, -0.03832041f, -0.08976965f, -0.03258957f, 
    0.16376108f, 0.08277470f, 0.04686471f, 0.03288702f, -0.01528450f, 0.01374344f, 0.00949479f, -0.03616834f, 
    0.02975832f, -0.06451688f, -0.00104014f, 0.03713791f, 0.26432088f, 0.18620110f, 0.27664745f, 0.37165219f, 
    -0.30488968f, 0.00535313f, -0.19765685f, -0.34491351f, -0.10359996f, -0.21029794f, 0.07535910f, -0.02170476f, 
    0.07469629f, 0.09268035f, 0.04005075f, 0.03817815f, 0.02632155f, -0.00692985f, -0.02003874f, 0.00686696f, 
    0.11739415f, 0.01874791f, -0.13526434f, 0.06389710f, -0.04043332f, 0.01614849f, 0.13778998f, 0.11691834f, 
    0.02640302f, -0.02779137f, -0.04101225f, -0.00921611f, -0.09205768f, -0.08098664f, -0.02889094f, 0.05348999f, 
    -0.05666316f, -0.00491728f, -0.09802128f, -0.05011362f, -0.07925911f, 0.15814462f, 0.24319163f, -0.03041879f, 
    0.02892738f, 0.09408098f, -0.09676322f, -0.06326276f, 0.00567123f, 0.00305551f, 0.02674693f, 0.08875914f, 
    0.09025891f, 0.05196620f, 0.03161017f, -0.02980287f, -0.02846546f, -0.06572434f, 0.02987408f, -0.03795455f, 
    -0.00307454f, -0.13864617f, -0.15326548f, -0.11800859f, 0.19012748f, -0.01729791f, 0.11729058f, 0.11110120f, 
    0.06020397f, 0.09438682f, 0.02363941f, 0.05681722f, -0.00438532f, 0.03741599f, 0.00588756f, 0.01157397f, 
    0.07769216f, -0.00348027f, -0.03930239f, 0.03381414f, -0.09479498f, 0.10918444f, -0.12572101f, 0.06285278f, 
    0.02594073f, 0.01958000f, -0.05319123f, 0.05687717f, -0.08358210f, -0.05407847f, 0.01715762f, -0.00383861f, 
    -0.04907377f, -0.08297011f, -0.07041498f, -0.04779458f, -0.09086826f, -0.01570707f, -0.02302665f, 0.02641066f, 
    -0.14400059f, 0.09671337f, -0.20125537f, -0.00203594f, -0.03007500f, 0.08593290f, -0.06431285f, 0.06812939f, 
    -0.04013615f, 0.07000706f, 0.04019893f, -0.07077353f, -0.04260539f, 0.01461537f, -0.06921295f, 0.10312944f, 
    -0.02171176f, 0.03128271f, 0.05189984f, 0.01764168f, -0.21871288f, 0.12633617f, -0.13913855f, -0.49527943f, 
    -0.07306080f, 0.10934719f, -0.05339591f, 0.10836324f, 0.00883633f, 0.05550316f, 0.09795876f, 0.00236334f, 
    -0.05584047f, -0.01706185f, 0.04623767f, -0.06006676f, 0.06469397f, 0.05346743f, -0.02228115f, 0.02615681f, 
    0.19292027f, 0.08395115f, 0.15730180f, 0.16148303f, -0.41817385f, 0.10692481f, -0.29505226f, -0.20219915f, 
    -0.02185578f, -0.08787111f, -0.00622472f, 0.05306755f, 0.07011285f, 0.04706520f, 0.06329935f, 0.01833624f, 
    0.00972744f, 0.02612815f, 0.00505786f, 0.06370538f, 0.09582305f, -0.00598874f, 0.14899795f, 0.00449943f, 
    -0.04357964f, -0.01072796f, 0.03689818f, -0.15554829f, -0.03740289f, 0.01209744f, 0.01845358f, 0.00212473f, 
    0.09767656f, 0.05154555f, 0.02566277f, 0.04082461f, -0.04452286f, -0.03788389f, -0.05620474f, -0.02367223f, 
    0.19833016f, 0.04951018f, 0.06218681f, -0.00942779f, -0.02806188f, -0.00654489f, 0.03112761f, -0.21081242f, 
    -0.05779168f, -0.04984410f, -0.05342280f, -0.04830184f, 0.08514958f, -0.00104906f, 0.03388897f, 0.03670223f, 
    -0.15402775f, -0.02581523f, -0.06592700f, -0.08549095f, -0.17822640f, -0.24265794f, 0.15025309f, 0.02319541f, 
    -0.30231428f, 0.05362690f, -0.15942720f, 0.04888145f, 0.13334848f, 0.23983943f, 0.04090041f, -0.02203142f, 
    0.01315845f, 0.00007911f, -0.04726494f, 0.01187931f, -0.00853137f, 0.02494707f, 0.01815768f, -0.09718761f, 
    -0.08222160f, 0.19148225f, -0.13074574f, -0.09241429f, -0.11149047f, 0.02135905f, 0.10577995f, 0.04677756f, 
    -0.09619987f, 0.08975157f, -0.00925909f, 0.05065046f, -0.18963742f, -0.06993186f, 0.03684244f, 0.00953596f, 
    -0.07510206f, -0.02325881f, -0.07610690f, -0.04223076f, -0.22225638f, -0.30103925f, 0.17554547f, -0.00085362f, 
    -0.26853850f, 0.08872660f, -0.26572925f, -0.05674578f, 0.13621102f, 0.27765810f, 0.00552970f, 0.03924752f, 
    0.06336848f, -0.03021451f, -0.09630068f, 0.03326206f, 0.08464576f, 0.03369476f, 0.05845192f, 0.07567339f, 
    -0.83511215f, -0.14227763f, -0.12024359f, 0.10167806f, -0.31603709f, 0.05100721f, 0.19361518f, -0.42428133f, 
    -0.03279801f, -0.06343253f, 0.00394858f, -0.07523461f, -0.15065308f, -0.00696428f, 0.02799223f, 0.13738458f, 
    0.04386491f, -0.07234990f, -0.03037559f, -0.03830231f, -0.09596843f, -0.09907623f, -0.06260531f, -0.02007178f, 
    0.21847290f, -0.07046946f, 0.08981744f, 0.09528114f, 0.05160202f, -0.00480040f, 0.10766118f, 0.13665883f, 
    0.10299630f, -0.02129930f, 0.02356000f, 0.10662635f, -0.00776228f, 0.02591066f, -0.00659162f, 0.00786963f, 
    0.04000154f, -0.12418876f, 0.30690539f, -0.40795884f, -0.09838814f, -0.08169986f, -0.08295804f, -0.07670598f, 
    0.06440401f, 0.10569582f, -0.04322483f, -0.01117246f, -0.04525416f, 0.01771223f, -0.03687329f, -0.08222061f, 
    0.03720303f, -0.08874656f, -0.09695241f, 0.09138808f, 0.11433036f, -0.34398666f, 0.05747469f, -0.01868952f, 
    0.04542924f, -0.12288298f, 0.00883153f, -0.12723905f, 0.07727332f, -0.02686131f, 0.03680221f, 0.00192802f, 
    0.12730062f, -0.00323567f, -0.02442031f, 0.02867866f, 0.13627109f, 0.03349644f, 0.01120312f, 0.06231858f, 
    -0.06925396f, -0.19905248f, -0.42265588f, 0.04937573f, 0.06472747f, 0.03671975f, 0.01733371f, 0.18847296f, 
    0.00754180f, 0.05984234f, -0.01361041f, 0.01529947f, -0.02666965f, -0.05020173f, 0.01406606f, 0.00081443f, 
    0.14832875f, 0.06966896f, -0.01914681f, 0.05295166f, 0.00010908f, 0.11465015f, -0.00654563f, -0.00913889f, 
    0.18753995f, -0.01015558f, 0.07841147f, -0.05297704f, -0.02027483f, -0.19504280f, 0.00296746f, 0.10623020f, 
    -0.01389743f, -0.14447133f, 0.06212896f, 0.01948811f, -0.04892368f, -0.12766306f, -0.00318180f, 0.11642545f, 
    -0.54448509f, -0.10497295f, -0.29919177f, -0.13993721f, 0.02821577f, 0.11322103f, 0.06719681f, 0.04900155f, 
    -0.14845164f, -0.03588781f, 0.02874915f, 0.01191911f, -0.07738115f, -0.03021884f, -0.04641245f, 0.09137843f, 
    0.00118120f, -0.16064158f, 0.00938360f, -0.03336345f, -0.10410675f, -0.62961668f, -0.05952111f, -0.14719412f, 
    -0.07374711f, -0.02976888f, -0.04940764f, -0.10873841f, -0.04614457f, -0.06579491f, 0.10343675f, -0.09167659f, 
    0.02881718f, 0.05654507f, -0.06036148f, 0.11316341f, 0.10986028f, -0.03581439f, -0.13970523f, -0.00925806f, 
    -0.04831845f, -0.14328699f, -0.18463063f, 0.11899819f, -0.42694154f, -0.14730515f, 0.11197861f, -0.06885658f, 
    0.08894929f, 0.05717779f, 0.06571189f, -0.00154844f, 0.03686393f, 0.00295869f, 0.00460586f, 0.01516216f, 
    0.02599195f, 0.05769289f, -0.00348124f, -0.08043172f, 0.09466840f, 0.26455781f, -0.71168494f, 0.18972011f, 
    -0.07086346f, 0.01154578f, 0.11371928f, 0.16241506f, -0.02975512f, 0.14236116f, 0.02373327f, 0.01890329f, 
    -0.01953148f, 0.00811736f, -0.02132355f, -0.03095098f, 0.01597814f, -0.00668808f, 0.04288757f, 0.04252880f, 
    0.14930640f, 0.07797398f, 0.13617562f, 0.29751164f, -0.25127473f, -0.00816467f, -0.02057103f, -0.20451552f, 
    -0.07671813f, -0.18223728f, 0.04483671f, -0.02386509f, 0.07047237f, 0.14865285f, 0.05773146f, 0.03094512f, 
    0.04236150f, -0.03369362f, 0.01757725f, -0.00712123f, -0.08516753f, -0.17336600f, 0.02522997f, 0.09497710f, 
    -0.20093420f, -0.03438865f, -0.06389875f, -0.02216117f, 0.09406720f, 0.13782004f, 0.01304972f, 0.02595955f, 
    0.05558363f, 0.01922690f, -0.03535166f, -0.02076640f, 0.07914687f, 0.08610263f, 0.10706647f, 0.11365557f, 
    0.02393752f, 0.21689451f, -0.27098095f, -0.03705202f, -0.13505708f, 0.10963769f, 0.09990226f, 0.22875246f, 
    0.05493795f, 0.03887859f, 0.06869679f, -0.03587607f, -0.09238166f, -0.08365437f, -0.08938483f, 0.06967758f, 
    -0.08669703f, -0.09237243f, 0.00400254f, -0.09639103f, -0.69684178f, 0.07032064f, -0.25093809f, 0.36207330f, 
    -0.10725939f, 0.08574853f, -0.26257515f, -0.01311609f, -0.24912955f, -0.00639032f, 0.14380142f, -0.07067622f, 
    -0.00562360f, 0.01570938f, -0.03113817f, -0.04626087f, -0.12108216f, -0.02046986f, 0.04744229f, 0.01452456f, 
    0.07659560f, -0.20285285f, -0.10715349f, -0.15961654f, -0.22062302f, -0.02879842f, -0.06643227f, -0.02845639f, 
    -0.00789335f, 0.03393951f, -0.13082501f, 0.10876857f, 0.00860091f, 0.07325789f, -0.10643274f, -0.04784020f, 
    0.03836065f, 0.06887677f, -0.06879920f, 0.02066500f, 0.01159537f, -0.04947191f, -0.28039262f, 0.03881224f, 
    0.02560188f, -0.06022037f, 0.13439472f, 0.16562065f, 0.05141074f, 0.04272960f, 0.02517454f, -0.01952468f, 
    -0.02853986f, 0.01822186f, -0.01373899f, 0.05237813f, 0.01621627f, -0.02796680f, 0.00588253f, -0.02027373f, 
    0.02114652f, 0.14707176f, -0.01028937f, 0.33838120f, -0.20728168f, 0.05637933f, -0.13056810f, -0.02620819f, 
    0.01481369f, -0.09728330f, 0.01204206f, -0.03164630f, 0.06504218f, -0.02072407f, 0.07844231f, 0.01701755f, 
    0.05846441f, 0.07342544f, 0.04512341f, 0.14485040f, 0.11232691f, 0.05632238f, 0.29852355f, 0.43520558f, 
    -0.41281667f, 0.08853518f, -0.16829820f, -0.18774834f, 0.05224279f, -0.17507300f, 0.03282828f, 0.02085429f, 
    -0.00645177f, 0.05025786f, 0.06138704f, 0.08462195f, 0.01885486f, -0.03669506f, 0.01266600f, 0.09215347f, 
    0.18271616f, -0.40434435f, -0.10908725f, 0.04501743f, 0.00309922f, 0.07551119f, 0.08191223f, 0.17268617f, 
    -0.03256196f, 0.06817647f, -0.03658976f, -0.03997654f, -0.12448651f, -0.00486673f, -0.08762012f, -0.01377348f, 
    -0.01136978f, 0.00069748f, -0.20295066f, 0.02526077f, -0.26781142f, -0.18682718f, 0.00056549f, 0.22778246f, 
    0.08396702f, -0.12517411f, 0.16667375f, 0.03712282f, 0.01355510f, 0.07384491f, 0.02599758f, -0.07444059f, 
    0.03247049f, 0.03098813f, -0.17041558f, 0.06822767f, 0.02528355f, 0.01085882f, -0.03117103f, 0.02077612f, 
    -0.48694280f, -0.22952980f, -0.28256688f, -0.04997147f, -0.38166764f, -0.21063432f, 0.27614009f, -0.35686687f, 
    0.18960172f, -0.05405241f, 0.01751512f, -0.04280746f, 0.04705679f, 0.01474615f, 0.06519751f, -0.01415134f, 
    0.03735170f, -0.02599704f, -0.04714174f, -0.04381279f, -0.16681029f, 0.06164399f, -0.34643006f, 0.09672135f, 
    -0.18273540f, 0.09845895f, -0.31174934f, 0.01412243f, -0.09348200f, -0.17620014f, -0.02019546f, 0.02486953f, 
    0.03560073f, -0.03125235f, 0.13340893f, -0.04893319f, 0.03508845f, 0.02333632f, 0.02899633f, 0.13510843f, 
    -0.24043193f, 0.11195695f, -0.06261019f, 0.20440233f, -0.45188370f, -0.01147011f, -0.40226477f, -0.01121270f, 
    -0.20962933f, -0.18099374f, 0.00164490f, 0.05635506f, 0.02275968f, 0.00566632f, 0.08868825f, -0.09177063f, 
    0.02934554f, -0.02054883f, 0.04910453f, 0.11689539f, -0.25411984f, -0.00857872f, -0.25434253f, 0.10579348f, 
    0.09110735f, -0.04662034f, 0.09401917f, 0.12804411f, 0.01732857f, -0.06462208f, 0.00942896f, 0.02916132f, 
    0.03636669f, 0.00939600f, -0.03796401f, 0.01970007f, 0.08507071f, -0.01114122f, 0.06731255f, 0.08025199f, 
    0.00022563f, 0.11933934f, 0.22519642f, -0.08381465f, -0.11789917f, -0.02090624f, -0.04935962f, -0.10565442f, 
    0.11023360f, -0.00482808f, 0.05515762f, -0.01420550f, 0.00687115f, 0.03800715f, 0.03761879f, -0.06001760f, 
    -0.03128357f, -0.01555071f, -0.05325341f, 0.01278913f, -0.04745171f, -0.41594902f, -0.22680190f, 0.01089418f, 
    -0.03572341f, -0.15787843f, 0.06109753f, 0.05637231f, -0.01105540f, -0.06744952f, -0.04746931f, -0.02653138f, 
    -0.11051805f, -0.01097808f, 0.04284033f, 0.05797927f, 0.14235130f, -0.10182904f, -0.00303754f, 0.06216836f, 
    -0.57840753f, 0.12398292f, -0.16824782f, 0.35941401f, -0.05469830f, 0.00557215f, -0.05569935f, -0.09323884f, 
    0.07887457f, -0.18614373f, -0.07840403f, 0.09215359f, -0.01921428f, -0.09461580f, -0.01397838f, -0.01831051f, 
    -0.13839214f, -0.07687066f, 0.01432726f, 0.04564559f, -0.08140955f, 0.14728570f, 0.06743085f, 0.27885574f, 
    0.09776731f, -0.01142873f, -0.01115278f, -0.15407793f, -0.00978954f, -0.10014146f, 0.13926099f, -0.02357982f, 
    0.10259306f, -0.05801688f, 0.01731701f, 0.06547616f, -0.01506527f, -0.05047522f, 0.06118970f, 0.04186326f, 
    0.16562253f, -0.27750176f, 0.00362890f, -0.01821244f, -0.01547032f, -0.04334169f, 0.02411349f, 0.04129975f, 
    0.06015504f, 0.09378912f, 0.04100859f, 0.02049795f, -0.04022211f, -0.11044320f, -0.01045256f, 0.03469664f, 
    0.00725367f, 0.14679222f, -0.08274362f, -0.03057875f, -0.02036438f, -0.11913583f, -0.19296044f, -0.18332660f, 
    0.13840522f, -0.02573027f, -0.00984896f, 0.11604909f, -0.00075777f, -0.00721277f, -0.07985939f, 0.06841511f, 
    -0.00594959f, -0.08764027f, 0.03361797f, 0.07830364f, 0.14122087f, -0.01509925f, 0.04807837f, 0.21679002f, 
    -0.24695286f, 0.14760107f, 0.00047400f, -0.05842167f, 0.06299926f, 0.04569402f, 0.04713781f, 0.00618760f, 
    -0.02846108f, 0.02362942f, 0.03524220f, -0.00404218f, -0.00983094f, -0.02722191f, 0.01659278f, 0.03728382f, 
    0.05479744f, -0.13020837f, 0.01247463f, -0.00281257f, 0.04128307f, 0.18063049f, 0.20809695f, -0.28413591f, 
    -0.19572176f, 0.06861237f, -0.13909511f, 0.08317859f, 0.01472080f, 0.09685180f, -0.03662236f, 0.02498213f, 
    -0.03624928f, -0.04405272f, -0.04941138f, 0.03123608f, -0.02525734f, -0.06709456f, -0.02143572f, -0.04830212f, 
    0.01697065f, 0.13234451f, 0.26473212f, -0.16296755f, -0.05628716f, 0.01675717f, -0.08189800f, -0.00945720f, 
    0.05393436f, 0.05570897f, -0.00242031f, 0.02339496f, 0.08537541f, 0.04909208f, 0.04306445f, -0.02069815f, 
    -0.00595561f, -0.10827995f, -0.05562448f, 0.01552250f, 0.05444208f, 0.03068643f, 0.02150222f, -0.09510667f, 
    -0.10701314f, 0.01238680f, -0.17522871f, 0.01219489f, 0.08261220f, 0.14152975f, -0.03537218f, 0.03878115f, 
    0.01734913f, -0.04282989f, 0.00943839f, -0.00931118f, 0.01423473f, 0.03441101f, 0.01290536f, 0.03588163f, 
    -0.02927548f, 0.00449669f, -0.72692275f, 0.08145487f, -0.01900345f, 0.13214473f, 0.06749073f, 0.08695547f, 
    0.07271853f, -0.01280359f, 0.03223044f, -0.01042982f, 0.01708950f, -0.01100500f, -0.05488116f, -0.03072563f, 
    0.07194175f, -0.10180268f, 0.02366202f, -0.00451565f, -0.30150273f, -0.16942343f, -0.51740140f, 0.06827249f, 
    -0.09116559f, 0.08895481f, 0.08552460f, 0.16307172f, -0.03743632f, 0.09022713f, -0.00781224f, -0.00830575f, 
    -0.00983145f, 0.03155682f, -0.03477637f, 0.01928975f, -0.02240143f, 0.04736991f, 0.13397215f, 0.13677652f, 
    -0.29444772f, 0.26270869f, -0.19537911f, -0.04774765f, -0.09573546f, 0.09589079f, -0.15539365f, 0.07916920f, 
    -0.03434571f, -0.08183558f, -0.00641961f, 0.00980174f, -0.02102255f, -0.01493733f, -0.03027904f, -0.03573889f, 
    0.05919882f, 0.03319601f, -0.00548571f, -0.05812179f, -0.01350648f, 0.12683231f, 0.22384761f, 0.32386500f, 
    -0.50776303f, 0.11332287f, -0.11329622f, -0.09834966f, 0.08086451f, 0.09956355f, 0.04781293f, 0.00736700f, 
    0.04985924f, 0.05277030f, 0.01457884f, 0.02513804f, 0.07109912f, 0.03256884f, 0.01729162f, -0.01356768f, 
    -0.21414261f, -0.31077436f, -0.66707981f, 0.09834937f, 0.00388982f, -0.08485810f, 0.02462161f, 0.20494799f, 
    -0.05063601f, 0.01985130f, -0.00772147f, 0.03266507f, -0.02934583f, 0.00529270f, -0.00401115f, -0.01457344f, 
    0.12868881f, 0.01386970f, -0.02482262f, 0.16123554f, -0.55532789f, -0.41606006f, -0.04648370f, 0.16378115f, 
    -0.02711378f, -0.29263571f, 0.25582856f, -0.25571933f, -0.03667378f, 0.06081452f, 0.09315065f, -0.08628950f, 
    0.10442369f, 0.00414920f, 0.06897662f, 0.09134533f, 0.12767735f, -0.07682130f, -0.03121309f, 0.04886552f, 
    -0.29067069f, -0.07341088f, -0.10916997f, -0.17115666f, 0.21018156f, -0.19385329f, 0.10846478f, -0.00288606f, 
    -0.20744725f, 0.13417956f, 0.09114495f, -0.07880148f, 0.12335816f, -0.05482456f, 0.03973913f, 0.18157886f, 
    0.04350851f, -0.05379105f, -0.01925122f, -0.09773134f, -0.09376680f, -0.07670677f, -0.06575873f, -0.17908688f, 
    0.01382328f, -0.01711762f, -0.08843774f, -0.02064379f, -0.03857295f, -0.19136778f, 0.15369859f, 0.01485360f, 
    0.08465643f, 0.02560934f, -0.25896290f, 0.14610194f, 0.03854263f, -0.03539303f, -0.12954807f, -0.03626073f, 
    -0.15075912f, -0.40882933f, 0.02086375f, -0.09711574f, -0.19980851f, -0.01066876f, -0.07341685f, 0.04399040f, 
    -0.02073429f, 0.01860389f, -0.11753125f, -0.00911371f, -0.02194960f, 0.01660846f, -0.04823356f, 0.02452767f, 
    0.02469276f, 0.07464543f, 0.15761037f, -0.03013547f, 0.07475800f, -0.02285778f, 0.22354613f, 0.28994548f, 
    0.13842379f, -0.06516611f, 0.06156604f, -0.00411898f, -0.16382016f, -0.06232774f, -0.14523998f, -0.04077753f, 
    -0.13858250f, 0.01657505f, 0.04096305f, 0.04055243f, -0.24418078f, -0.09657592f, 0.10597400f, 0.14249611f, 
    -0.08155894f, 0.05391381f, -0.04232060f, 0.02571323f, 0.14774023f, -0.01966083f, 0.01336301f, -0.00582121f, 
    -0.03681537f, 0.02421385f, -0.06477571f, 0.00277231f, 0.02778460f, 0.01450862f, 0.01825957f, 0.05175463f, 
    -0.01904794f, -0.10312901f, 0.10843662f, 0.10987634f, 0.15171768f, 0.06626313f, -0.16807121f, 0.19655767f, 
    0.09009495f, 0.05092839f, -0.00155336f, 0.04483400f, -0.15625972f, 0.11649138f, 0.00766994f, 0.01575741f, 
    -0.11619342f, 0.03645876f, 0.04934219f, -0.03823993f, 0.07986080f, -0.04460954f, 0.03284270f, 0.10694461f, 
    -0.27181101f, 0.07082963f, -0.20340078f, 0.01061619f, -0.00850871f, 0.04157491f, -0.06097622f, 0.00337346f, 
    0.08164030f, -0.06473761f, -0.03596030f, 0.03933517f, 0.00126170f, 0.04259663f, -0.03627508f, 0.04481968f, 
    -0.01462552f, -0.12239845f, 0.04403491f, 0.14531980f, -0.19372483f, -0.23533916f, -0.11262360f, 0.14822301f, 
    -0.05194170f, 0.00498368f, -0.15860209f, -0.01366741f, 0.16858365f, -0.01491993f, -0.12492502f, 0.05635953f, 
    -0.01141634f, -0.03691561f, -0.05969520f, 0.11203849f, -0.09616309f, -0.02687933f, 0.14207263f, 0.08073268f, 
    -0.01163081f, -0.11807486f, 0.09764380f, 0.03923731f, 0.07677800f, -0.13252535f, 0.03458455f, -0.08884917f, 
    -0.08013177f, -0.17443421f, -0.04282689f, -0.03282438f, -0.06174996f, 0.03042397f, 0.01937308f, 0.08103813f, 
    -0.18584886f, -0.10369024f, -0.11458334f, -0.11924943f, -0.25567582f, -0.07720657f, -0.57178670f, -0.02970738f, 
    0.00093143f, -0.02112865f, 0.02522243f, -0.04959372f, -0.10143261f, -0.03810503f, 0.03145018f, 0.07437602f, 
    -0.03995156f, 0.07835565f, -0.02119463f, 0.08503869f, -0.05913873f, -0.09702094f, -0.10110501f, -0.17071018f, 
    -0.22000365f, 0.21966390f, -0.18319649f, 0.10190296f, 0.06159267f, 0.00689378f, -0.00999570f, -0.05785355f, 
    0.02017012f, 0.00266708f, -0.05521835f, -0.02061583f, -0.00938895f, -0.04458187f, -0.03653929f, -0.00604410f, 
    0.00872948f, -0.09934247f, 0.00340531f, 0.05208860f, 0.14954402f, 0.01018699f, 0.08145459f, -0.00420372f, 
    0.03982760f, 0.07309952f, -0.02668160f, -0.09422381f, 0.02921682f, 0.07788624f, -0.11754128f, 0.18453263f, 
    -0.09243853f, -0.06161116f, -0.08457684f, -0.00478773f, -0.07908900f, 0.01485980f, -0.00807488f, 0.02459861f, 
    -0.16571850f, -0.15455972f, -0.07411011f, 0.01260544f, -0.04856894f, -0.02239110f, -0.04484129f, 0.08248914f, 
    -0.11513786f, 0.02406874f, -0.01219475f, 0.07848898f, 0.00013725f, 0.04932509f, 0.05154416f, -0.01827068f, 
    0.04882875f, 0.13941242f, 0.00610221f, 0.14569488f, -0.07662146f, -0.22349814f, 0.08479866f, -0.01912345f, 
    -0.08069416f, -0.10798534f, 0.03858971f, -0.03604384f, 0.07837732f, -0.00282388f, 0.01641237f, -0.10061138f, 
    -0.05592988f, -0.09417794f, -0.06956828f, -0.04443248f, 0.04802626f, 0.07803620f, 0.08958441f, 0.12140127f, 
    0.03593256f, -0.20057188f, 0.25132018f, 0.01120325f, -0.16482221f, -0.00040830f, -0.14569284f, -0.09335585f, 
    -0.04605087f, -0.08180328f, -0.06435511f, -0.02313147f, 0.00202415f, 0.02418686f, 0.05373507f, -0.01127458f, 
    -0.05316808f, 0.04123697f, -0.07698688f, -0.04869534f, -0.03160094f, -0.19570680f, 0.09446382f, -0.00119139f, 
    -0.04143078f, 0.05954848f, 0.03265881f, -0.10077307f, -0.00776416f, 0.04267476f, -0.01965451f, -0.01156380f, 
    -0.02879781f, 0.04447896f, -0.01914363f, 0.09308477f, 0.03632851f, 0.00045783f, 0.15355541f, 0.01201751f, 
    0.00106620f, -0.19144659f, 0.12687705f, -0.05422908f, 0.09175791f, -0.07373450f, -0.00079309f, 0.05099861f, 
    0.02345581f, 0.00605635f, -0.02814442f, 0.01795150f, 0.00120445f, 0.03633150f, 0.05720715f, -0.03278299f, 
    0.08176788f, 0.02844245f, 0.08214047f, -0.03144242f, -0.12457258f, -0.07799344f, -0.06090913f, 0.05087392f, 
    -0.25456151f, -0.00476668f, 0.02918596f, -0.05228580f, -0.03958897f, -0.04332446f, -0.03212177f, 0.05227985f, 
    -0.04775994f, 0.00634314f, -0.03270662f, -0.04496175f, 0.03119739f, 0.04545366f, 0.02804821f, -0.08253355f, 
    0.16754328f, -0.04913153f, 0.08859609f, -0.13539344f, -0.05760576f, 0.04092360f, 0.05727196f, -0.15922266f, 
    0.17126355f, -0.05694776f, 0.02833863f, 0.00749365f, -0.05925630f, -0.17778756f, -0.17021105f, -0.01097239f, 
    -0.02988490f, 0.06016893f, 0.09210598f, -0.10074020f, -0.04888989f, -0.00615779f, 0.02602058f, -0.06882507f, 
    0.09843262f, -0.03605269f, 0.04488647f, 0.00848918f, 0.01126403f, 0.05186308f, -0.04458754f, 0.05980492f, 
    0.00667895f, -0.02351462f, -0.05705937f, 0.04693827f, 0.02591163f, 0.02310525f, 0.09962507f, 0.12953641f, 
    -0.03195328f, -0.02365382f, -0.03499371f, 0.13253495f, 0.20786138f, -0.05975089f, 0.02270116f, 0.01549267f, 
    -0.08961676f, 0.05574035f, -0.08461655f, -0.01730895f, 0.04461994f, 0.05379225f, 0.05221794f, 0.09265099f, 
    0.01589191f, -0.01121543f, 0.10158502f, 0.19355933f, -0.28316838f, -0.04331883f, -0.25611669f, -0.07577361f, 
    0.12988023f, -0.12331479f, -0.04938051f, -0.04390410f, -0.11057835f, 0.00821633f, -0.05585360f, 0.04492097f, 
    0.05213765f, 0.06834338f, 0.04064143f, 0.06090919f, -0.04789755f, -0.07557637f, 0.03871477f, -0.00840806f, 
    -0.00513392f, -0.19167225f, 0.05368624f, 0.18389173f, -0.06847379f, -0.00928435f, -0.03301789f, 0.16580737f, 
    -0.19612947f, -0.09937949f, 0.04859073f, -0.01826710f, -0.04090911f, 0.04145655f, 0.07192855f, 0.01667007f, 
    0.00393936f, 0.18387388f, -0.03105998f, 0.17184325f, -0.24778429f, -0.03909612f, -0.28666151f, 0.02968801f, 
    -0.02226201f, 0.02071669f, -0.03863982f, -0.05789391f, -0.00185638f, -0.06201422f, 0.02017111f, 0.08011025f, 
    -0.00251193f, -0.00740147f, 0.00588568f, 0.04695333f, -0.01480053f, -0.02119116f, -0.00152605f, -0.17863411f, 
    0.06084030f, 0.28137302f, 0.20580657f, -0.01164259f, -0.00762000f, 0.06310190f, -0.21044959f, 0.21055314f, 
    0.05485548f, 0.06502962f, -0.13728394f, 0.02282972f, 0.15250258f, -0.02605771f, -0.02406850f, 0.03575850f, 
    0.05751178f, -0.06191335f, -0.01988453f, 0.06640223f, -0.02903620f, -0.31488755f, -0.26733083f, -0.17986673f, 
    -0.30045778f, -0.11987548f, -0.06083405f, -0.08519887f, -0.11585783f, -0.03823098f, -0.06157904f, 0.07750684f, 
    -0.05975775f, -0.05397310f, 0.12482899f, -0.02819321f, 0.05741665f, -0.02433700f, -0.03833849f, -0.00780033f, 
    -0.23798952f, 0.18941799f, 0.07932445f, 0.10983648f, 0.01155345f, 0.03686908f, -0.04429782f, -0.04940408f, 
    0.14778422f, 0.11434622f, -0.11273570f, -0.11061072f, 0.02243066f, 0.02010629f, -0.05345092f, -0.09239663f, 
    0.04035191f, 0.04595990f, 0.10539795f, 0.06936450f, -0.08084504f, 0.30077353f, -0.03703640f, 0.08885275f, 
    0.05495187f, 0.09420247f, -0.07811575f, -0.08828602f, 0.06170032f, -0.00644818f, -0.19513758f, -0.00743436f, 
    -0.16657685f, -0.01304905f, 0.02213893f, -0.03345469f, 0.07742871f, -0.21854731f, 0.04207028f, -0.08544637f, 
    0.00913020f, -0.02209504f, -0.13084905f, 0.11492120f, 0.03108456f, -0.06755330f, -0.08906290f, -0.01636617f, 
    -0.21647835f, -0.10256804f, -0.02181124f, 0.06208355f, -0.09093247f, 0.05663303f, 0.01679167f, -0.11945049f, 
    -0.20472106f, -0.09316725f, -0.18107967f, -0.01616874f, -0.06197945f, 0.00153791f, 0.14160062f, 0.17730473f, 
    0.02848356f, -0.02336852f, -0.04282871f, -0.00591553f, -0.03495868f, -0.03837723f, -0.02755882f, -0.03410368f, 
    0.19316901f, -0.11115455f, 0.01681481f, -0.00741175f, -0.01456850f, 0.03588599f, 0.04442427f, 0.13685530f, 
    -0.03110384f, -0.28712085f, 0.24584149f, 0.07685808f, 0.10257972f, -0.05921349f, -0.04781329f, 0.16928165f, 
    0.16312945f, -0.06376396f, -0.01081261f, 0.03364575f, -0.00605122f, 0.00608084f, 0.07127248f, 0.00422480f, 
    0.09008452f, 0.09428306f, 0.14974922f, -0.02403984f, -0.56289089f, 0.41435015f, -0.69340849f, 0.30516556f, 
    0.21057244f, -0.11880524f, -0.06058742f, -0.04605845f, 0.27099159f, 0.11402493f, -0.12367070f, 0.03819954f, 
    -0.02266414f, -0.14091815f, 0.11827672f, -0.15864308f, 0.12544461f, -0.19696362f, 0.13664792f, 0.16470273f, 
    -0.25171286f, 0.00421258f, -0.08863738f, -0.05010406f, 0.15245590f, 0.01342724f, -0.06578086f, -0.07394037f, 
    -0.07670706f, 0.01450608f, -0.10980634f, 0.09154633f, 0.06706256f, -0.03412879f, 0.01717794f, 0.07344153f, 
    0.01102294f, -0.06676504f, 0.06370509f, -0.05314820f, -0.11939367f, -0.17449635f, -0.09583802f, -0.09570572f, 
    0.06500116f, -0.09669465f, -0.12906420f, 0.07253438f, -0.22059043f, -0.06656986f, -0.05347985f, 0.08547188f, 
    -0.05458928f, 0.04640954f, -0.03791925f, 0.10638789f, -0.15253228f, -0.13113369f, -0.05271946f, -0.06943154f, 
    -0.05398411f, 0.19820695f, -0.04077154f, -0.01014260f, 0.01453778f, 0.09464054f, -0.09016762f, -0.02956507f, 
    0.09936476f, -0.02586785f, -0.11875211f, 0.14243759f, -0.05352576f, -0.01324980f, -0.06692559f, 0.01656393f, 
    -0.01034600f, -0.04533644f, 0.02044990f, -0.02230489f, -0.24183010f, 0.01901141f, -0.28725809f, -0.00942764f, 
    -0.01574343f, 0.04624935f, -0.01480857f, 0.01704351f, -0.02107454f, -0.01958248f, 0.01402615f, 0.04320242f, 
    0.01540644f, 0.02476489f, -0.00112481f, 0.04572334f, -0.07535885f, -0.02752682f, -0.04892523f, -0.11504670f, 
    -0.40401819f, -0.51145029f, -0.13607745f, -0.17406385f, -0.02982761f, 0.03908719f, -0.08053295f, 0.04879097f, 
    -0.00889413f, -0.05387177f, -0.09058455f, 0.04318858f, 0.00884426f, 0.00804145f, -0.04157316f, 0.09257702f, 
    0.06794807f, 0.16125922f, 0.08068024f, 0.12521814f, 0.32690132f, -0.24610953f, 0.20668855f, -0.09611774f, 
    0.02833113f, -0.15098196f, 0.14538778f, 0.23047219f, 0.12975585f, 0.08788504f, -0.06337724f, 0.08524481f, 
    -0.16154930f, -0.00146114f, 0.01529418f, 0.03488058f, 0.06371624f, 0.05283527f, 0.01642886f, -0.08521276f, 
    -0.23329169f, 0.14257254f, -0.32234326f, 0.08953669f, 0.04020892f, 0.01072839f, 0.00945736f, 0.04152622f, 
    0.12431033f, 0.07742070f, -0.00450778f, 0.00110840f, -0.06876691f, 0.04679861f, 0.00264437f, 0.05998612f, 
    0.06970552f, -0.16083258f, 0.13507260f, -0.12368326f, -0.02089755f, -0.20313857f, -0.03181826f, -0.08813255f, 
    -0.01111410f, 0.04838417f, -0.07623143f, 0.05014849f, -0.04737902f, -0.00786639f, -0.10831290f, 0.07245300f, 
    0.03939345f, -0.05432443f, 0.00236748f, 0.05916239f, -0.04191635f, 0.05901461f, -0.01013831f, 0.01847583f, 
    -0.03220984f, -0.04195780f, 0.00501685f, -0.04614903f, -0.04349915f, -0.01778316f, 0.11392422f, 0.02011216f, 
    0.03509614f, -0.01997406f, -0.03038728f, 0.03683194f, -0.06488010f, -0.01800265f, -0.04338158f, 0.05516436f, 
    -0.08494160f, 0.01587043f, -0.14251983f, -0.14593716f, -0.22458684f, 0.03095887f, 0.05403958f, -0.02638019f, 
    -0.05648125f, 0.03782193f, 0.00680838f, -0.09713101f, 0.09317012f, 0.00006443f, -0.01326541f, -0.01997818f, 
    0.03415538f, -0.15009485f, -0.12712756f, -0.00590160f, -0.07042854f, 0.00030792f, -0.07201033f, -0.04852282f, 
    -0.24508427f, -0.27079937f, -0.24779585f, 0.16740251f, -0.06881950f, 0.01939621f, -0.14308272f, 0.13475235f, 
    0.07875407f, 0.14331290f, -0.04222285f, -0.02858898f, -0.01524163f, 0.03137909f, 0.03777466f, -0.06095409f, 
    0.04672203f, -0.04647548f, 0.07068654f, 0.14738694f, 0.19109835f, -0.22441684f, 0.03834468f, 0.08115438f, 
    -0.02488243f, 0.05676056f, -0.05577350f, 0.02797409f, -0.10515017f, -0.08404398f, -0.05871505f, 0.03768213f, 
    -0.15169533f, 0.07998137f, 0.11597908f, -0.11537518f, -0.14677650f, -0.01488453f, -0.05286796f, -0.03144024f, 
    -0.19919126f, 0.16287063f, 0.25133386f, 0.00557788f, 0.15087415f, 0.12750235f, 0.02389314f, 0.06915312f, 
    0.08202355f, 0.01991501f, -0.21590953f, 0.12628321f, 0.00932449f, -0.00457339f, 0.02406805f, -0.05888340f, 
    0.07779649f, -0.04531572f, -0.01326133f, -0.05566231f, -0.38299569f, -0.01402637f, 0.10292424f, 0.10044168f, 
    0.04464240f, -0.03073284f, 0.05223767f, -0.17791210f, 0.13360105f, -0.04123967f, -0.02530604f, -0.03105803f, 
    -0.08199593f, 0.05179495f, 0.03053758f, 0.08945729f, 0.00336176f, -0.04246854f, -0.00277683f, -0.18019924f, 
    -0.25538561f, 0.00191288f, 0.24400394f, 0.19315316f, 0.13327107f, -0.17194779f, -0.09325457f, -0.16117343f, 
    0.14143825f, -0.05351701f, -0.04834997f, -0.04186461f, -0.11669227f, -0.02658160f, 0.00884200f, 0.15215907f, 
    -0.00710013f, 0.02054293f, 0.04610533f, 0.03751071f, -0.02470143f, -0.23287493f, 0.05837687f, -0.17042270f, 
    0.00493082f, -0.01282844f, -0.06872678f, 0.03243463f, 0.03009959f, -0.08457531f, -0.07539938f, 0.02335849f, 
    0.02304452f, 0.02387122f, 0.06786706f, 0.08781285f, 0.02819704f, 0.06598375f, 0.03012498f, -0.05227546f, 
    0.06566638f, -0.11240992f, -0.27199256f, 0.16858636f, 0.04722269f, -0.04650154f, -0.00313661f, -0.05945309f, 
    0.10111872f, 0.06116522f, -0.08577882f, -0.14458665f, 0.03248590f, 0.02826164f, 0.05155538f, 0.06538975f, 
    0.01507810f, -0.02307085f, 0.15390715f, 0.15185587f, -0.06606093f, -0.03117973f, 0.06524289f, 0.11516042f, 
    0.18244024f, -0.02700540f, 0.02614644f, -0.04079768f, -0.03597473f, 0.17535226f, -0.05005148f, -0.09129211f, 
    -0.15729886f, -0.00134626f, 0.04957961f, 0.07239334f, -0.21963808f, 0.05260744f, 0.03023327f, 0.23388058f, 
    0.29213017f, -0.33753446f, 0.26807180f, -0.15361115f, -0.02429475f, -0.13753818f, -0.06388809f, 0.01614057f, 
    -0.03649455f, -0.00787860f, -0.06582937f, 0.03398869f, -0.07943008f, 0.07356288f, 0.01720259f, -0.13958468f, 
    0.11708754f, 0.00978641f, 0.02886275f, -0.00968490f, 0.24889724f, -0.00886550f, 0.10239515f, -0.17003681f, 
    -0.07472368f, 0.05293881f, -0.04423072f, -0.00754280f, 0.03431450f, -0.04978565f, -0.03899840f, 0.06737781f, 
    -0.08083320f, -0.07020235f, -0.13897629f, -0.03088447f, -0.06019934f, 0.03010414f, -0.06664880f, -0.12519103f, 
    0.11508217f, 0.11211363f, -0.21554729f, 0.30101693f, 0.04366782f, -0.05178875f, -0.09078737f, -0.10390199f, 
    0.12800086f, 0.06080705f, -0.07709513f, -0.00622622f, -0.04242083f, 0.03995747f, 0.06592388f, 0.00871018f, 
    0.04395976f, -0.03590209f, 0.06979161f, 0.08749543f, 0.04424598f, -0.11383548f, 0.06114598f, -0.00363721f, 
    -0.19783702f, -0.03182662f, -0.05528272f, 0.05516698f, -0.12676494f, -0.13305093f, 0.07408985f, 0.07564754f, 
    -0.12641959f, 0.09652261f, -0.04039452f, -0.04799742f, -0.08685225f, 0.05897912f, -0.36719629f, -0.21301220f, 
    -0.04099916f, -0.21453145f, 0.22800969f, -0.12852919f, -0.08626681f, -0.06453845f, 0.04461965f, 0.08092976f, 
    0.11070878f, -0.00531600f, -0.03202871f, -0.00306097f, 0.01602909f, -0.07919116f, 0.00153614f, -0.03872069f, 
    0.02959777f, 0.12682435f, 0.10905461f, 0.01073043f, 0.05126012f, -0.03864558f, -0.02395999f, 0.25576696f, 
    0.01190200f, -0.10087924f, 0.11779633f, 0.04090636f, -0.04845189f, -0.04876340f, -0.06665102f, -0.06065119f, 
    0.10466118f, 0.10071864f, 0.05297507f, 0.04132393f, 0.04841956f, 0.15453956f, 0.05791977f, 0.20772476f, 
    0.01040565f, -0.07650453f, 0.00067970f, 0.01039972f, -0.07468718f, 0.00385144f, 0.06834311f, -0.01085179f, 
    0.02513555f, 0.01392783f, 0.00844713f, -0.13050941f, 0.00711937f, 0.01883954f, -0.00043662f, 0.03486794f, 
    0.03375850f, 0.07223880f, 0.08992612f, 0.14738677f, -0.20526400f, -0.00435539f, -0.19588450f, 0.06931285f, 
    0.01490814f, -0.02350742f, 0.01488084f, -0.05550543f, 0.05563752f, -0.08806461f, 0.01240869f, 0.09191048f, 
    0.00522899f, 0.05249882f, 0.00719605f, 0.00431239f, -0.04861489f, -0.11653642f, -0.11947466f, -0.13803504f, 
    -0.37561625f, -0.21694583f, -0.09534983f, -0.10500933f, -0.01210515f, -0.05345203f, -0.12002543f, 0.10230872f, 
    0.17250896f, 0.07425907f, -0.19936644f, 0.05400896f, -0.07261528f, -0.00346191f, -0.00696382f, 0.12708664f, 
    -0.13694613f, 0.01706779f, 0.12316824f, 0.04619543f, 0.00696530f, -0.19381510f, -0.09931666f, -0.04249191f, 
    0.17354481f, -0.05521530f, 0.06701061f, -0.03015670f, -0.04528428f, -0.17029156f, 0.01147732f, -0.00644904f, 
    -0.04221412f, 0.03507695f, 0.02274450f, 0.16098960f, -0.20674762f, -0.16499266f, -0.18386336f, -0.22672524f, 
    -0.25858361f, -0.21817355f, 0.04769593f, 0.09284233f, 0.04716407f, -0.04881550f, -0.03848177f, 0.10295508f, 
    -0.01370394f, -0.09676210f, -0.05474500f, 0.06693149f, 0.00818983f, 0.09833279f, 0.05713748f, 0.08146464f, 
    0.05005801f, 0.00438535f, 0.02906459f, 0.00016278f, -0.22700115f, -0.02145387f, -0.24608687f, -0.02231593f, 
    -0.01333354f, -0.04297903f, -0.04143283f, -0.03722256f, 0.03615126f, 0.04125877f, -0.00365684f, 0.00912737f, 
    -0.03862122f, -0.09223612f, -0.10863765f, 0.02642359f, -0.01491514f, 0.03404912f, -0.04235734f, -0.05259405f, 
    -0.09931356f, -0.05949390f, -0.13828631f, 0.08118021f, 0.10823963f, 0.07714240f, -0.06845437f, 0.16270183f, 
    -0.08043899f, -0.13766198f, -0.02834797f, -0.00227548f, -0.07229184f, 0.11976308f, 0.03333511f, 0.15947968f, 
    -0.23940516f, 0.05517193f, -0.33466318f, -0.05544177f, 0.15349649f, 0.23771894f, -0.33056265f, 0.08950174f, 
    0.12161326f, 0.13020317f, -0.05555572f, 0.07360584f, -0.16822250f, -0.03396770f, -0.06958681f, 0.03594124f, 
    -0.08346866f, -0.01067400f, 0.17782123f, -0.02538232f, -0.12867002f, -0.13816509f, 0.00971939f, -0.03623980f, 
    0.44053710f, -0.10157620f, 0.24437897f, 0.16424100f, 0.05026622f, -0.00379790f, 0.17988768f, 0.18146932f, 
    0.11295903f, 0.07098618f, -0.08517776f, 0.16183221f, 0.15146680f, -0.01349573f, 0.06458379f, -0.05519805f, 
    -0.01277545f, -0.05042979f, 0.17244716f, -0.11956535f, -0.41941226f, -0.12992281f, 0.18656887f, 0.26989594f, 
    0.03477456f, -0.00465233f, -0.14246292f, -0.07698011f, 0.11887852f, -0.04304368f, -0.16081633f, 0.02874013f, 
    -0.01413511f, -0.06570266f, 0.13312830f, 0.03788210f, -0.07097600f, -0.04968685f, 0.18484411f, 0.28099352f, 
    0.21909046f, -0.12532143f, 0.22935313f, -0.16583866f, 0.01093168f, 0.05497732f, 0.14688995f, -0.09081583f, 
    0.16718885f, 0.04106310f, -0.04212880f, 0.10609920f, 0.01617392f, -0.04136562f, -0.05569016f, -0.07590207f, 
    0.14237760f, -0.03739007f, -0.11784992f, -0.08047844f, 0.01988199f, -0.38822168f, 0.16002147f, 0.11676204f, 
    -0.03384366f, 0.08113091f, -0.02122766f, 0.17180108f, -0.01266287f, 0.02352456f, 0.07001463f, 0.00123706f, 
    -0.03221964f, 0.04708974f, 0.02055364f, 0.04874821f, 0.05380902f, 0.07824447f, 0.03828088f, -0.03228006f, 
    -0.08740179f, -0.17297620f, -0.10361370f, 0.14855312f, -0.03991305f, -0.08765702f, -0.21021812f, -0.03720389f, 
    -0.08829089f, 0.01211726f, 0.03351632f, -0.02546139f, -0.02165293f, -0.11180020f, -0.13106188f, 0.03014979f, 
    -0.07455088f, 0.00179742f, -0.06361499f, -0.11320942f, -0.17035815f, 0.03260244f, 0.06560748f, 0.16259989f, 
    -0.00944814f, -0.07810830f, 0.04282787f, 0.08300317f, -0.03682179f, 0.07806980f, -0.13851608f, -0.06962939f, 
    0.02378496f, 0.08221922f, -0.04635251f, -0.05560543f, 0.01426172f, 0.13896272f, 0.02818218f, -0.16591753f, 
    -0.18104598f, -0.25420001f, -0.13770826f, 0.14860086f, 0.04804872f, -0.12368835f, -0.23327674f, 0.04726996f, 
    -0.04111826f, -0.13763742f, -0.02510090f, 0.08508605f, -0.00815349f, 0.04678670f, 0.02819428f, -0.00765926f, 
    -0.05104519f, 0.05675848f, 0.03129154f, -0.05427681f, 0.33696431f, 0.13535123f, 0.36154613f, 0.01488553f, 
    -0.28178573f, -0.00236358f, -0.08343617f, -0.01692913f, 0.02405155f, -0.00277516f, -0.08323111f, 0.00966792f, 
    0.02421245f, 0.03623680f, -0.02995416f, -0.03172323f, 0.03598427f, 0.04279439f, 0.07485484f, 0.00354558f, 
    0.22143941f, -0.17160326f, 0.03264820f, 0.00475558f, 0.01839857f, 0.02575342f, -0.08370356f, -0.00640252f, 
    -0.02937472f, -0.07858120f, -0.03978964f, 0.05289562f, -0.02621310f, -0.07586053f, -0.03037871f, 0.02069227f, 
    0.02018037f, -0.00386507f, 0.10203925f, -0.02198068f, 0.06398928f, -0.25836489f, -0.27607363f, -0.23520492f, 
    0.05314329f, -0.13438526f, -0.17785625f, 0.03972653f, -0.06592415f, -0.10111059f, -0.01194884f, 0.00363525f, 
    0.03771599f, -0.08669845f, -0.05527754f, 0.09030865f, -0.03403337f, -0.00422147f, 0.00643544f, -0.00938067f, 
    -0.17153522f, -0.06089905f, -0.21420458f, 0.08923657f, -0.27852347f, -0.00482138f, -0.03439217f, -0.07227810f, 
    0.01984142f, 0.01745199f, 0.01086041f, 0.06075851f, -0.05857809f, -0.00811115f, 0.00300000f, 0.04144745f, 
    -0.00340503f, 0.11454674f, 0.02726235f, 0.06204436f, -0.39019710f, -0.21758197f, -0.23725685f, -0.00456109f, 
    -0.32193565f, 0.01001228f, 0.04328996f, 0.01124073f, 0.02192988f, 0.10470024f, -0.16479920f, -0.09825232f, 
    0.11129121f, -0.02967538f, -0.07824097f, -0.02122839f, -0.06285696f, -0.02834276f, 0.01606146f, 0.02354996f, 
    0.09378898f, 0.12862194f, 0.07373041f, 0.06448186f, -0.07113004f, -0.04411821f, -0.00461351f, 0.00475477f, 
    -0.08285435f, 0.01026239f, -0.07744134f, 0.00595507f, -0.02099611f, 0.05978706f, -0.05840719f, -0.05701103f, 
    -0.03965701f, -0.04208546f, -0.06295324f, -0.02506147f, -0.02309140f, -0.10122658f, -0.10977313f, 0.09899477f, 
    0.09047564f, -0.01794135f, 0.04358436f, -0.06137598f, 0.05855116f, -0.02423718f, -0.09327541f, 0.10077493f, 
    0.08883951f, -0.04289862f, 0.11450719f, -0.01276738f, -0.09702893f, -0.02791864f, -0.10014164f, -0.17338084f, 
    0.07900006f, 0.05967909f, 0.02274491f, 0.10714953f, 0.02860829f, -0.04250467f, -0.00701186f, -0.04184085f, 
    -0.04739153f, 0.07130139f, -0.00631875f, -0.00394534f, -0.06084327f, -0.09532331f, -0.02664932f, 0.10753789f, 
    0.02630706f, 0.12169714f, 0.03401449f, 0.04028392f, 0.12158483f, -0.04637080f, 0.11289538f, -0.05577207f, 
    0.01551299f, 0.07675776f, 0.13672183f, -0.01428065f, 0.08128466f, -0.04738777f, -0.03511237f, 0.07396881f, 
    0.07902552f, -0.01561255f, 0.01593132f, -0.04495726f, -0.06305264f, -0.07529023f, -0.20136291f, -0.07348987f, 
    0.15565124f, -0.00945937f, 0.09837065f, -0.08036974f, 0.05121535f, 0.06718477f, 0.13759413f, -0.08117419f, 
    0.03824608f, 0.01254981f, -0.04889810f, 0.09856916f, -0.00841768f, 0.03647524f, -0.04833429f, -0.00279939f, 
    0.02030787f, 0.05335356f, -0.12882978f, 0.01372884f, 0.31809738f, -0.11113242f, 0.10539079f, 0.28330821f, 
    0.11161535f, 0.00436722f, 0.13202098f, -0.08744911f, 0.13420270f, 0.03516985f, -0.18583900f, 0.04374898f, 
    -0.00590758f, 0.02468212f, 0.00311843f, 0.09511431f, 0.08899513f, 0.07311715f, 0.02967601f, -0.00059607f, 
    -0.15947434f, -0.07403965f, -0.15068184f, -0.04225817f, -0.20694484f, 0.02937273f, 0.11805254f, -0.22454849f, 
    0.02506381f, -0.08235666f, 0.02478447f, -0.06115668f, 0.09457067f, -0.05023869f, 0.02309387f, 0.00133044f, 
    -0.02799249f, 0.07294133f, 0.01964041f, 0.09148119f, -0.16755582f, -0.04739763f, -0.17343575f, 0.17269340f, 
    0.04709090f, -0.06503918f, -0.04472788f, 0.01338788f, -0.10514118f, -0.01521444f, 0.04333053f, -0.00330235f, 
    -0.10787411f, -0.08267085f, -0.03746119f, -0.00120593f, -0.08253775f, -0.08245069f, -0.09710560f, -0.10660780f, 
    -0.14396028f, -0.14493850f, -0.06447117f, 0.22636168f, 0.03435737f, -0.07652433f, -0.07023187f, 0.01725815f, 
    -0.07796829f, 0.03394542f, -0.01567746f, -0.10858341f, -0.11124847f, -0.10045212f, -0.10434832f, -0.01935166f, 
    -0.13340609f, -0.04078738f, -0.13076673f, -0.19091505f, 0.04625653f, -0.26933128f, -0.19999148f, -0.14552890f, 
    -0.01648252f, -0.12029694f, -0.27629477f, -0.06043934f, -0.14772423f, -0.09090608f, 0.03949765f, 0.04989266f, 
    0.00612785f, -0.06308293f, -0.06550290f, 0.00898694f, -0.04487172f, 0.01369686f, 0.00185239f, -0.05272682f, 
    0.22014171f, -0.06798968f, 0.22072543f, -0.01145877f, -0.11321474f, -0.02958776f, 0.10969685f, -0.22922868f, 
    0.13307604f, 0.10664348f, -0.04203539f, -0.00189708f, -0.03082157f, 0.06806749f, -0.04430890f, -0.10466664f, 
    0.10436756f, 0.00233815f, 0.07308066f, -0.11612468f, 0.05710476f, -0.12524575f, -0.29086465f, -0.27889070f, 
    -0.06059105f, -0.13394512f, -0.05165042f, 0.02690751f, -0.04289988f, -0.04740637f, 0.02164251f, 0.03544013f, 
    0.02965480f, -0.05699692f, -0.02207856f, 0.04203302f, -0.01159324f, 0.02859023f, 0.14865781f, 0.06778707f, 
    -0.32362565f, -0.03982781f, -0.59774166f, 0.02161885f, -0.26088226f, 0.12204775f, 0.12757538f, 0.06790228f, 
    -0.14443952f, 0.08350407f, -0.02578952f, 0.06191831f, 0.03203056f, 0.07479386f, -0.04847200f, 0.06240506f, 
    -0.04598462f, 0.00928924f, -0.00488234f, 0.01964867f, -0.01270282f, 0.01148237f, 0.02806925f, -0.00898927f, 
    -0.03433750f, -0.05280693f, 0.02138063f, -0.00808769f, 0.02792794f, 0.07839036f, -0.19810873f, -0.04842329f, 
    0.02010270f, 0.03470902f, -0.14276831f, 0.01477342f, 0.04529618f, 0.04121726f, -0.08139354f, -0.08085636f, 
    -0.27029949f, -0.04211292f, -0.31365740f, 0.35761958f, 0.19076991f, -0.10743100f, 0.07541046f, 0.02806150f, 
    0.20218495f, 0.03361706f, -0.08904574f, -0.01227546f, -0.15541199f, -0.06391187f, 0.12242441f, 0.02106630f, 
    0.00792453f, 0.09825283f, -0.02045490f, -0.03303713f, -0.62255961f, 0.13128614f, -0.23404330f, 0.18614157f, 
    -0.13426988f, 0.07983781f, 0.06794617f, 0.05402577f, -0.07417813f, 0.06046532f, -0.15709352f, -0.10293822f, 
    0.05065322f, 0.15976158f, -0.06406246f, 0.08100191f, 0.03215836f, 0.10998464f, -0.01152654f, -0.02903843f, 
    0.33457372f, -0.15338206f, 0.11404747f, 0.13058406f, -0.05571915f, 0.01479150f, 0.01175828f, -0.12805992f, 
    0.01143840f, -0.02634532f, -0.08008545f, 0.00728298f, -0.03695945f, -0.00581467f, -0.03809420f, 0.07594935f, 
    0.07062327f, 0.03467803f, 0.07480612f, 0.04113663f, -0.05456112f, -0.05989589f, 0.01166985f, 0.12079047f, 
    -0.09695781f, 0.09334943f, -0.04367984f, 0.02053593f, 0.04793659f, 0.02602164f, -0.09276357f, -0.14575052f, 
    -0.08695000f, 0.09257596f, 0.03875628f, -0.00784985f, -0.03495938f, 0.15489110f, -0.14957780f, -0.04446915f, 
    -0.00193907f, 0.15165651f, -0.20888558f, 0.03478767f, 0.31756547f, -0.13232526f, -0.05635059f, 0.04666229f, 
    -0.06556415f, 0.03334821f, -0.00403518f, 0.02841456f, 0.01515236f, -0.13666537f, -0.05966447f, 0.12405496f, 
    -0.01036401f, 0.00231406f, 0.03945393f, 0.08865600f, -0.58222657f, 0.08229013f, -0.18564619f, 0.31212744f, 
    -0.44750696f, 0.01994610f, -0.01122921f, 0.14808302f, 0.02348423f, -0.03992765f, -0.08267647f, -0.01039267f, 
    -0.11151387f, 0.08508521f, -0.01597901f, 0.17970507f, 0.05836078f, 0.13114235f, 0.04831702f, -0.15891865f, 
    -0.10546310f, -0.09148076f, -0.26633802f, -0.00752703f, -0.25242972f, -0.11965830f, -0.17941909f, -0.08452097f, 
    -0.07916987f, 0.00692062f, 0.00171673f, 0.04951082f, 0.01118004f, -0.02119438f, -0.08063841f, 0.00357213f, 
    0.00650757f, 0.04742683f, 0.02076562f, 0.03163420f, 0.42743155f, -0.07036975f, 0.36649194f, -0.01469921f, 
    0.07538942f, -0.08098596f, -0.21061684f, -0.02307724f, -0.03012275f, -0.10226353f, -0.00668050f, 0.03130516f, 
    -0.00103516f, -0.04040262f, -0.00801802f, 0.00141026f, -0.00403697f, -0.06492396f, -0.01585937f, 0.12804472f, 
    -0.37229204f, -0.02557210f, -0.27378958f, 0.11102752f, -0.30188769f, 0.03426715f, 0.03740546f, 0.02140732f, 
    -0.00024054f, 0.06779673f, -0.11015590f, -0.09015574f, -0.00452476f, 0.00538364f, -0.04365795f, 0.06341719f, 
    -0.05914001f, -0.01198552f, -0.06412464f, 0.03553804f, 0.02345238f, -0.16173917f, -0.20185883f, -0.15931723f, 
    0.05528389f, -0.11070712f, -0.09646159f, 0.05708737f, -0.12000021f, -0.03258301f, 0.04006231f, 0.06181864f, 
    0.06515782f, -0.04366584f, -0.01749417f, 0.04869769f, -0.05668443f, -0.00432983f, 0.02285207f, 0.09468346f, 
    0.28005627f, 0.15155774f, 0.22398901f, 0.05359156f, -0.13137515f, -0.06049369f, 0.00064822f, -0.09539805f, 
    -0.08952972f, -0.07201868f, -0.10138948f, 0.06074252f, -0.02097485f, 0.08961415f, -0.00020829f, -0.13298483f, 
    -0.11330140f, -0.01491223f, -0.10949443f, 0.07013528f, -0.08776182f, -0.35395607f, 0.23353858f, -0.40322956f, 
    0.31966555f, 0.15341619f, 0.09917939f, -0.13263619f, 0.16794327f, 0.07256487f, -0.01168427f, 0.10603165f, 
    0.01057430f, 0.03947503f, 0.00940569f, -0.04467584f, 0.04669225f, -0.00251313f, -0.01996926f, 0.05061506f, 
    -0.49688843f, 0.03677604f, -0.13909185f, 0.11756594f, -0.08443698f, -0.08076905f, 0.09701079f, -0.03609733f, 
    0.09217688f, 0.06757830f, -0.11755313f, -0.11778367f, -0.06657337f, -0.03671328f, 0.05413511f, 0.11403445f, 
    -0.05093715f, 0.13359673f, 0.03161576f, -0.00005244f, 0.15068950f, 0.11880883f, 0.17027266f, 0.05710944f, 
    -0.13077724f, -0.13462564f, -0.02136211f, -0.03667261f, -0.01504106f, -0.03281189f, -0.08882025f, 0.00409580f, 
    0.02277342f, 0.00619635f, -0.02333664f, 0.04654415f, 0.08061559f, 0.04536948f, -0.07869444f, 0.05842953f, 
    0.12417004f, -0.08111028f, 0.07876701f, -0.10698135f, -0.02291544f, 0.05648015f, 0.13776900f, 0.03930182f, 
    -0.05150870f, -0.04596461f, -0.04232023f, -0.02356719f, 0.06537712f, 0.13657779f, -0.00320919f, -0.01171331f, 
    0.10752215f, 0.07165852f, 0.07514113f, 0.10004466f, -0.18289578f, -0.05421411f, -0.17138179f, -0.02033614f, 
    -0.49017540f, 0.13040194f, 0.11107841f, -0.06274418f, 0.08367100f, 0.08406478f, -0.07802114f, 0.02471547f, 
    0.01361263f, 0.12626863f, -0.07429009f, -0.05312864f, 0.01745507f, 0.09015154f, 0.00302148f, 0.06442323f, 
    0.16913396f, 0.31544852f, 0.15239576f, 0.17628156f, -0.34046420f, 0.02809160f, -0.01677595f, 0.12243468f, 
    -0.02519911f, 0.02055184f, -0.13143362f, 0.06885558f, -0.04312195f, -0.00546450f, 0.07675530f, -0.08175953f, 
    -0.04148720f, 0.08770678f, 0.16915873f, -0.05328549f, -0.30340195f, -0.11537383f, -0.09439128f, -0.06095450f, 
    0.11286718f, 0.09123176f, 0.03613350f, 0.11185176f, -0.03275619f, 0.04085294f, 0.05446171f, 0.03931044f, 
    0.16736460f, 0.06417411f, 0.09523736f, -0.02975419f, 0.00684481f, 0.02278003f, 0.10333440f, -0.13363142f, 
    -0.52572799f, -0.13811500f, -0.35033095f, 0.40201920f, -0.14786330f, 0.14077131f, -0.13378035f, 0.09550878f, 
    -0.27644193f, -0.03234768f, 0.01255450f, -0.05381130f, -0.10285295f, 0.03328940f, -0.09900129f, 0.09393942f, 
    -0.02369586f, 0.07601386f, 0.02418703f, 0.05969979f, 0.12935443f, -0.22318542f, 0.30684182f, -0.01191574f, 
    -0.00338243f, -0.04409332f, -0.11965005f, -0.09731930f, 0.03908287f, -0.23921359f, -0.09375686f, -0.03543741f, 
    0.05551687f, 0.07458584f, 0.01247993f, 0.15668456f, 0.08571313f, 0.04177769f, 0.10526624f, -0.02954493f, 
    0.36595348f, -0.57561857f, 0.50277227f, -0.13265759f, 0.00190285f, 0.18297690f, 0.03762870f, -0.16373052f, 
    0.11355446f, -0.08190645f, 0.09923909f, -0.05184140f, 0.07164745f, 0.04597098f, 0.06725382f, 0.10665661f, 
    0.10600335f, 0.07596073f, -0.02143646f, -0.14452331f, 0.16161099f, -0.02562985f, 0.16611496f, -0.03006833f, 
    0.08322599f, 0.00988028f, 0.03662046f, -0.04555489f, 0.08797951f, -0.02488430f, -0.09401330f, -0.04416299f, 
    -0.04669254f, -0.04082169f, -0.04157574f, 0.03980498f, 0.04668795f, 0.01259757f, -0.06843076f, 0.02311851f, 
    -0.09958120f, -0.15322335f, 0.08821347f, 0.03003628f, -0.05503646f, -0.10956825f, 0.02853325f, 0.02786199f, 
    0.06870717f, 0.05412769f, -0.02990656f, 0.05255581f, -0.04576798f, 0.02494186f, 0.06550686f, -0.12303150f, 
    -0.01003055f, 0.10766592f, -0.14045325f, -0.20451646f, 0.17196533f, 0.03720628f, 0.14244977f, 0.26105982f, 
    -0.12288127f, -0.14692387f, -0.05697350f, 0.00538277f, -0.05875381f, 0.01793583f, 0.13409682f, -0.15450129f, 
    0.07635339f, 0.00379237f, 0.04488173f, 0.01086397f, -0.00530119f, 0.15516728f, -0.07294863f, -0.11377408f, 
    -0.10740656f, -0.18296140f, -0.04206040f, 0.09924254f, 0.31917378f, 0.15974207f, 0.22442544f, 0.08772410f, 
    -0.05106739f, 0.09622633f, -0.00826509f, 0.00741410f, 0.08529212f, 0.00751311f, -0.01937103f, -0.12481275f, 
    0.09971099f, -0.02393958f, 0.03421140f, -0.02864761f, -0.18697163f, -0.14146216f, -0.17324750f, -0.01164135f, 
    0.07741851f, 0.09920555f, 0.08887988f, 0.08512323f, -0.07272633f, 0.06548259f, -0.00880457f, -0.04696427f, 
    0.04966577f, 0.11675791f, 0.03010071f, -0.07799385f, 0.02058763f, 0.00693619f, 0.03416612f, 0.05581512f, 
    -0.17395234f, 0.03456978f, 0.03510755f, 0.15563640f, -0.11365097f, -0.00351079f, 0.01423984f, 0.03147459f, 
    -0.03069415f, -0.00372789f, -0.06508851f, -0.02677276f, 0.02418406f, 0.06013383f, -0.00301280f, -0.04471237f, 
    -0.05294577f, 0.14530881f, -0.00749406f, -0.11367448f, -0.03320162f, -0.11908773f, -0.23818377f, 0.12342174f, 
    0.10720100f, 0.01691606f, 0.08124903f, -0.08543786f, 0.01338514f, -0.07325802f, -0.14840026f, -0.02048918f, 
    0.05442768f, 0.02212221f, 0.01174920f, 0.12034057f, -0.02734798f, -0.05658262f, -0.00858286f, -0.03816395f, 
    0.09483892f, -0.05277375f, -0.05737811f, 0.13550134f, 0.14774907f, -0.01589916f, 0.17396893f, -0.10284538f, 
    0.05396239f, 0.03385739f, -0.07608634f, 0.15020885f, 0.07977037f, 0.02402666f, 0.05949846f, -0.00369669f, 
    -0.09535812f, -0.04173708f, -0.14379121f, -0.07053491f, -0.09398369f, -0.17908999f, -0.06082150f, 0.21764684f, 
    0.18270519f, -0.13232888f, -0.00652818f, -0.06927972f, -0.01454944f, -0.03708597f, 0.01087797f, -0.02861581f, 
    -0.09087567f, -0.09428093f, 0.05160080f, -0.05825743f, -0.06830842f, -0.02065755f, 0.01091615f, -0.02311966f, 
    0.01175014f, -0.06624005f, -0.01357181f, 0.16104198f, 0.09999949f, -0.09905361f, 0.03810258f, -0.00120130f, 
    0.04572722f, -0.00657500f, -0.02085917f, 0.05823992f, -0.02222412f, -0.00209703f, 0.04799591f, -0.08294752f, 
    -0.06858141f, 0.05817439f, -0.03589386f, -0.14164929f, -0.15132029f, -0.20983291f, -0.10197928f, -0.05455296f, 
    0.09000974f, -0.05782310f, -0.38103434f, -0.08638304f, 0.00824135f, -0.16778745f, -0.05535381f, 0.02137380f, 
    0.03476511f, 0.00241121f, 0.01428077f, 0.04424316f, -0.05426186f, 0.03641875f, 0.15715069f, 0.04170510f, 
    0.26210585f, 0.09010809f, 0.33868980f, 0.04727778f, -0.10470407f, -0.01918461f, -0.07543432f, 0.00559006f, 
    0.01018489f, -0.13289939f, -0.05186235f, -0.03908791f, 0.02466030f, -0.03363704f, -0.02718027f, 0.10482848f, 
    -0.06725579f, -0.01140706f, -0.03887333f, -0.05836198f, 0.00339991f, -0.31087971f, 0.13863942f, -0.19133914f, 
    0.09084900f, -0.04258261f, -0.08794875f, 0.06950118f, 0.06729220f, -0.02573259f, 0.01223031f, 0.10934795f, 
    -0.01819296f, -0.02840069f, -0.01588413f, -0.00498670f, 0.07638162f, 0.04223700f, -0.10819252f, 0.06184255f, 
    0.41109058f, -0.29054734f, 0.32327065f, -0.14452140f, 0.16571784f, 0.07722558f, 0.02618633f, -0.13809717f, 
    0.14293680f, -0.15756153f, -0.03014147f, -0.05818641f, -0.07373246f, 0.03462365f, 0.04452281f, -0.04258591f, 
    0.06312474f, 0.01362207f, -0.00237355f, -0.05293586f, 0.00731067f, -0.11477459f, -0.10061656f, -0.13665928f, 
    -0.23461491f, -0.09660755f, 0.04290394f, -0.07755309f, -0.06343002f, -0.01465454f, 0.00163189f, 0.06023102f, 
    0.16506258f, 0.09490155f, -0.04503203f, -0.03736288f, 0.09683195f, 0.03009122f, 0.09799011f, 0.03799178f, 
    0.45329103f, -0.35305962f, 0.32292649f, 0.09963237f, 0.10162282f, -0.16900712f, -0.11519583f, -0.24693207f, 
    0.17602450f, -0.08067380f, -0.02600700f, -0.08288351f, 0.02511932f, -0.01244992f, -0.01976084f, 0.05376081f, 
    -0.04098045f, -0.00150126f, 0.13094915f, 0.05095342f, -0.84579062f, -0.22162320f, -0.01793184f, 0.21977335f, 
    0.05369183f, 0.22228692f, -0.02516980f, 0.23144162f, -0.22715048f, 0.08732708f, -0.06057829f, -0.03012215f, 
    0.06888378f, 0.17264277f, 0.12838055f, 0.06123548f, -0.03419658f, 0.04722012f, 0.16951810f, -0.00838868f, 
    -0.52128375f, -0.16876318f, 0.11973062f, -0.12411621f, 0.37553716f, 0.07873990f, 0.14984788f, -0.05427430f, 
    -0.01024162f, 0.17781599f, -0.07609364f, 0.06446934f, -0.17098419f, 0.11129382f, 0.00447956f, 0.12364432f, 
    -0.13324180f, -0.03271114f, 0.07622220f, 0.00164121f, -0.25824806f, -0.21723802f, -0.05052885f, 0.15035634f, 
    -0.17102598f, 0.06864946f, -0.00835384f, 0.07783620f, -0.00869584f, 0.00941544f, 0.05665590f, -0.08656592f, 
    0.11618178f, -0.04746704f, -0.02504720f, 0.08273355f, -0.02722480f, -0.01196068f, -0.01629420f, -0.15568286f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14936332f, 0.08554764f, 0.05391300f, -0.07497638f, -0.02943535f, 0.01232324f, 0.02505896f, -0.07132232f, 
    0.01718447f, 0.05633616f, -0.00334333f, -0.01680310f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
