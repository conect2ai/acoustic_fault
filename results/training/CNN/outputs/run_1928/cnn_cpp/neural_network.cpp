#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.12945399f, -0.44437626f, -0.27598643f, -0.37729824f, -0.57150757f, -0.23314920f, -0.37741295f, -0.11363424f, 
    0.24746948f, 0.02981360f, -0.03264593f, -0.09060327f, -0.08421419f, 0.25139111f, -0.05115040f, 0.14342988f, 
    -0.46204466f, -0.15050033f, 0.13279946f, -0.45657262f, -0.35704991f, -0.00006818f, 0.07187396f, 0.22378962f, 
    0.29808930f, -0.81633133f, -0.26954240f, -0.04721295f, 0.04710685f, -0.05478575f, -0.41669846f, 0.15215151f, 
    -0.13802251f, -0.55893779f, -0.61881286f, 0.32088199f, -0.06647300f, -0.11398970f, 0.30163589f, 0.50206685f, 
    -0.12759534f, 0.02614709f, -0.21253975f, 0.09422483f, -0.31231213f, 0.00710623f, -0.24539635f, 0.06773332f, 
    -0.07074984f, 0.06895331f, 0.40708542f, 0.68530494f, 0.58395940f, -0.54093283f, -0.80883431f, -0.31937197f, 
    0.00984389f, 0.37961218f, -0.24027635f, -0.36559552f, -0.30452231f, 0.14014471f, 0.36756551f, 0.29223385f, 
    -0.16462253f, 0.26206908f, 0.20451580f, 0.21104243f, -0.23428230f, -0.26778126f, -0.05374767f, -0.21146160f, 
    -0.36359805f, -0.03450084f, -0.09401800f, -0.42853254f, -0.42286322f, -0.15639699f, -0.48813131f, -0.57052135f, 
    -0.66462606f, -0.36952007f, -0.33084273f, -0.59367478f, -0.58016753f, 0.00602674f, -0.28181714f, -0.41972110f, 
    -0.19702269f, -0.26646808f, 0.05995206f, 0.00757573f, -0.21019925f, -0.01108048f, -0.05288013f, -0.04438554f, 
    -0.10332624f, -0.20211330f, 0.13446715f, -0.10236991f, -0.19143036f, -0.15993485f, -0.29647407f, 0.03278466f, 
    0.18512446f, -0.35333601f, -0.36289951f, 0.31468096f, -0.42837059f, -0.05501601f, 0.09704752f, -0.18356909f, 
    0.13872047f, -0.01942057f, -0.18324672f, 0.22558706f, 0.19829573f, 0.12207942f, 0.16459738f, 0.20046124f, 
    -0.11965503f, -0.11670869f, 0.16992377f, -0.03625817f, -0.23199621f, -0.27014378f, 0.46091318f, -0.18468508f, 
    -0.36468557f, -0.52967960f, 0.07804240f, -0.19851850f, 0.28206614f, 0.52327257f, 0.33937609f, -0.14858648f, 
    -0.54214448f, -0.18960123f, -0.09546895f, -0.01859189f, 0.32203904f, 0.15104707f, 0.09082296f, 0.15328468f, 
    0.19800889f, 0.02255616f, 0.05238481f, -0.17631435f, -0.25663391f, 0.25535664f, -0.50823349f, -0.58363074f, 
    -0.16487841f, -0.11278673f, 0.36848319f, -0.37141421f, -0.43514970f, 0.34847882f, 0.44538477f, 0.48714253f, 
    -0.02880797f, 0.02320017f, 0.02743134f, -0.18621454f, 0.09460861f, -0.26668477f, 0.11600377f, -0.17160413f, 
    0.16420485f, -0.19676444f, 0.11960404f, 0.23024817f, 0.16784328f, -0.01042518f, 0.19985625f, -0.03410601f, 
    0.12398135f, -0.07215035f, -0.07867522f, -0.07530680f, -0.24299870f, 0.06751543f, 0.50219589f, -0.52810472f, 
    -0.35965568f, -0.04627172f, 0.07689440f, -0.15846404f, -0.11264842f, -0.10464565f, -0.06626107f, 0.18526395f, 
    -0.04852321f, -0.03075074f, 0.11128532f, 0.18485847f, -0.09709577f, -0.08036161f, 0.43090078f, 0.08537189f, 
    0.21372528f, 0.39367637f, 0.28421664f, 0.09667905f, -0.31039646f, 0.41586322f, -0.41816729f, -0.22411671f, 
    -0.19211623f, -0.05651921f, 0.20889156f, -0.20500593f, 0.01790992f, 0.20733784f, 0.20193838f, 0.06122686f, 
    -0.07247490f, -0.09483108f, 0.18842873f, 0.06146682f, -0.18064606f, 0.26581049f, 0.14948207f, -0.07644103f, 
    -0.26505005f, -0.66405320f, -0.33898675f, -0.18392459f, 0.08513539f, 0.06325953f, 0.13238662f, 0.22628859f, 
    0.09196454f, 0.29739428f, 0.05833162f, -0.25647113f, 0.01742641f, -0.04816015f, 0.31906393f, 0.03575154f, 
    0.19706319f, -0.19748364f, -0.31074697f, 0.11940540f, -0.06852417f, 0.13097809f, 0.35159484f, 0.32897836f, 
    0.09013340f, -0.22550815f, -0.86603963f, -0.30009505f, 0.07691485f, 0.37160757f, 0.47655228f, -0.28103542f, 
    -0.10923854f, 0.25767335f, 0.38426119f, 0.37528232f, -0.22739646f, -0.23585434f, -0.37254041f, 0.64504421f, 
    -0.22002985f, -0.18110327f, -0.07738303f, 0.13003704f, -0.00938639f, -0.25093621f, 0.06947746f, 0.13435631f, 
    0.19255404f, -0.06851280f, 0.15137574f, 0.43198463f, -0.42561457f, 0.04942855f, 0.13487345f, 0.28391615f, 
    0.26144257f, 0.22718303f, 0.18184666f, 0.14769787f, -0.20806830f, -0.19909313f, 0.36315247f, -0.24555774f, 
    -0.25464943f, 0.04146047f, -0.10630927f, -0.01174849f, -0.02125592f, -0.24410741f, -0.31925038f, 0.02472740f, 
    0.10025375f, -0.34512362f, 0.13399625f, 0.18011388f, -0.75282413f, -0.17557584f, 0.33199847f, -0.39219761f, 
    -0.29428676f, -0.19475149f, -0.69849145f, -0.77478826f, -0.49585178f, -0.51123297f, 0.01140069f, -0.01491864f, 
    -0.34510183f, -0.57411665f, -0.28302276f, -0.30709246f, -0.28123465f, -0.13294344f, -0.45746228f, -0.52686942f, 
    0.10145038f, 0.18404657f, 0.04344163f, -0.08319387f, 0.00352060f, 0.89838099f, 0.69960928f, -0.16675363f, 
    -0.01426517f, -0.56362993f, 0.15765473f, -0.29321748f, -0.20935906f, 0.11185335f, 0.04088559f, 0.20917821f, 
    -0.06477269f, -0.03809143f, 0.01001822f, -0.39386559f, -0.05430707f, 0.03239642f, 0.20009890f, -0.10761931f, 
    -0.04254304f, 0.21046840f, -0.11493760f, -0.18747890f, -0.21214397f, 0.27609816f, -0.08000939f, -0.56822872f, 
    -0.57000118f, -0.21822217f, 0.19960275f, -0.19706386f, -0.20319125f, -0.71059954f, -0.87432182f, -0.87618554f, 
    0.48009571f, 0.19015513f, 0.12559725f, 0.10544498f, 0.38485220f, 0.23614427f, -0.38915297f, -0.23111634f, 
    0.12464587f, -0.20478080f, -0.13522924f, 0.16298360f, 0.11108164f, -0.04773019f, 0.11410009f, -0.97782707f, 
    0.31933117f, -0.13422772f, -0.35287371f, 0.14728713f, 0.15355836f, 0.13480920f, 0.34735131f, 0.02379062f, 
    -0.02454393f, 0.19672157f, 0.13235278f, -0.08280770f, -0.13965026f, -0.16255480f, 0.08773208f, -0.30138853f, 
    -0.15143374f, -0.06036486f, 0.19126944f, 0.05583881f, -0.00041384f, -0.26222640f, -0.29134282f, -0.24089901f, 
    0.48831576f, -0.36009425f, -0.35915259f, 0.23048453f, 0.25069249f, 0.00118112f, 0.46652669f, 0.57873607f, 
    -0.15962224f, -0.47902378f, -0.29713491f, -0.04662922f, -0.10324626f, -0.07507450f, -0.02579449f, 0.31450364f, 
    -0.19564921f, -0.19163546f, 0.10283157f, -0.12480111f, 0.07699914f, -0.07401075f, -0.12358587f, 0.01579681f, 
    0.07206212f, 0.44466680f, 0.36426422f, 0.14583351f, -0.68638414f, -0.92584056f, -0.02866162f, 0.21716553f, 
    0.35897186f, -0.01029301f, 0.03066329f, 0.07118821f, -0.16776371f, 0.35775974f, 0.23554423f, -0.33396628f, 
    0.17384352f, 0.07577935f, -0.47798491f, -0.43341717f, 0.30313173f, 0.17406078f, -0.04556394f, 0.01243119f, 
    0.07983640f, 0.09804316f, 0.15888709f, 0.02159135f, -0.06949911f, 0.33773321f, -0.15667610f, 0.11323001f, 
    0.40634063f, -0.26112509f, -0.46569824f, 0.13801089f, -0.13261104f, 0.25384334f, -0.20622712f, -0.22151838f, 
    0.31686804f, 0.21881454f, -0.20066060f, -0.11425502f, 0.17619427f, -0.17157717f, -0.05174085f, 0.13622606f, 
    -0.21999137f, 0.11130251f, 0.23518972f, -0.95398706f, -0.58152461f, -0.31525823f, -0.63177037f, -0.69693893f, 
    0.70060062f, -0.01682557f, -0.37395293f, 0.06885339f, 0.50464243f, -0.42308423f, -0.31447342f, -0.08554529f, 
    0.32021651f, 0.17517146f, 0.06300617f, 0.05344263f, -0.09017984f, -0.05147709f, -0.19729587f, -0.01153126f, 
    0.09097546f, -0.01230549f, -0.20065220f, -0.19906446f, 0.39094767f, -0.65348262f, 0.25638682f, 0.23268418f, 
    0.04225940f, -0.67958176f, -0.62031025f, -0.41248882f, 0.18594736f, 0.49258718f, 0.14296098f, -0.23362935f, 
    0.16525552f, 0.22971793f, -0.21844585f, 0.13384418f, -0.02677443f, 0.28926021f, -0.15756625f, -0.26580071f, 
    0.14619064f, -0.26299933f, 0.00242779f, 0.13214269f, 0.09677289f, -0.72168326f, -0.44776225f, 0.11213221f, 
    0.52828765f, 0.14078163f, 0.58328360f, 0.52818906f, -0.40067968f, -0.22243051f, 0.21795319f, 0.08093363f, 
    -0.01138182f, -0.33500883f, -0.03984232f, -0.44809636f, 0.21486153f, 0.13141857f, -0.07562412f, -0.10756474f, 
    0.00714831f, -0.11945894f, -0.17053783f, 0.24679743f, -0.01098051f, -0.11201429f, 0.87209809f, -0.67086411f, 
    -0.76007342f, -0.52299547f, -0.24776612f, 0.31594923f, 0.36176839f, 0.40409142f, 0.26916623f, 0.17091788f, 
    -0.13761318f, 0.02173545f, -0.06811450f, 0.04552978f, -0.21539187f, 0.10464993f, 0.01196425f, 0.08157247f, 
    -0.18271539f, -0.24191852f, -0.02452709f, -0.33445495f, -0.31852660f, -0.29179323f, -0.17453566f, -1.06102419f, 
    -0.84167677f, -0.41601193f, 0.15467240f, -0.67636889f, 0.28767213f, 0.16509305f, 0.02991438f, 0.20477229f, 
    0.49112988f, -0.05258793f, 0.12714128f, -0.02412109f, 0.34251365f, 0.16591449f, 0.00173449f, 0.07760581f, 
    -0.30700183f, -0.17090820f, 0.30340919f, 0.28328767f, -0.06032252f, 0.25832886f, -0.02807587f, 0.07593477f, 
    -0.60885656f, -0.41017985f, -0.07675531f, 0.12169810f, 0.24288705f, -0.73507053f, -0.71579099f, -0.43851039f, 
    0.28379771f, 0.10865340f, 0.33917576f, 0.60109383f, 0.50561780f, 0.06765650f, -0.25811803f, -0.26242346f, 
    0.05610602f, 0.04897408f, -0.62325424f, -0.59089261f, 0.03031058f, -0.07171679f, -0.05047875f, 0.07852868f, 
    0.31013682f, -0.83729684f, -0.44270366f, -0.47002646f, -0.30730844f, -0.35135642f, 0.67174304f, 0.23220500f, 
    0.29149887f, -0.16545138f, -0.62698752f, -0.02583204f, -0.08443426f, 0.35874134f, 0.53149790f, -0.28600582f, 
    -0.25802526f, -0.30636117f, 0.10384562f, -0.22088397f, -0.18266769f, -0.00044339f, -0.14081635f, -0.02485186f, 
    -0.00205511f, 0.34638759f, 0.42234036f, 0.75923908f, 0.45071712f, 0.12335953f, -0.07966624f, -0.63930446f, 
    -0.48146167f, 0.06379779f, -0.17796789f, -0.35359162f, -0.26270518f, -0.30817148f, -0.16875693f, -0.15754628f, 
    0.29458737f, 0.17382546f, 0.42616606f, -0.19748423f, 0.16985293f, -0.04264030f, -0.08880700f, 0.13436688f, 
    -0.13696459f, -0.06486586f, -0.25780892f, -0.99582195f, -0.33753774f, 0.31192288f, 0.06689911f, 0.42345768f, 
    -0.22940695f, -0.44806400f, 0.13969582f, -0.11559729f, 0.25734559f, -0.03137625f, 0.15674050f, -0.11172088f, 
    0.61701375f, -0.54565090f, -0.26917201f, 0.01816507f, -0.14218679f, -0.15547270f, -0.29513803f, -0.23756580f, 
    0.09506745f, 0.20106734f, -0.08405981f, -0.30705789f, 0.65213764f, 0.01041000f, -0.62456298f, -0.13938369f, 
    -0.45451120f, 0.15392925f, 0.58117366f, -0.26876390f, -0.85153496f, -0.58771282f, 0.09250591f, -0.44787490f, 
    0.18467571f, -0.38119915f, 0.11906768f, -0.37072140f, -0.19257358f, 0.24498636f, -0.25252330f, -0.43257195f, 
    -0.05894674f, -0.20920132f, 0.18132325f, 0.20648845f, -0.11834724f, -0.27460033f, -0.61312699f, -0.31477365f, 
    0.23483866f, 0.02730453f, 0.01235691f, -0.48831531f, -0.39379108f, -0.15325341f, 0.16771978f, -0.04464972f, 
    0.05088977f, 0.22278602f, -0.24262674f, -0.32588297f, 0.18735671f, 0.26270893f, 0.22839248f, -0.05490471f, 
    0.23859170f, 0.10074241f, -0.00752581f, -0.24455827f, -0.26842457f, -0.35274187f, -0.14326981f, -0.35758686f, 
    -0.76414567f, 0.34275654f, 0.65024281f, 0.03878528f, -0.29076436f, -0.41898724f, 0.19695613f, 0.25799951f, 
    -0.49526832f, -0.25463465f, -0.35723457f, 0.28981912f, -0.28316781f, 0.06035400f, 0.10781288f, -0.21884541f, 
    0.10997040f, 0.11811063f, 0.06814416f, -0.37910545f, -0.21988966f, -0.25076261f, -0.00662876f, 0.21305130f, 
    0.24909577f, 0.30409417f, -0.03719127f, 0.16037907f, 0.11602771f, -0.00885509f, -0.14328896f, 0.09535064f, 
    0.02510028f, -0.03787429f, -0.20002426f, -0.01778739f, -0.10058131f, -0.06219159f, -0.03679542f, 0.16752927f, 
    0.10056300f, 0.12944445f, -0.12280158f, 0.04032858f, -0.27143893f, -0.25536898f, -0.28744188f, -0.53636396f, 
    0.46494865f, 0.69342846f, 0.05744694f, -0.50446427f, -0.42054665f, -0.48097497f, -0.24952003f, -0.29153228f, 
    -0.01726036f, 0.02026570f, 0.20501024f, 0.18843935f, 0.23162608f, 0.35251525f, 0.34961778f, -0.23024784f, 
    -0.21211821f, 0.32405564f, -0.36834949f, -0.00176326f, 0.09882727f, -0.00457620f, -0.04279698f, -0.11500901f, 
    -0.00578218f, 0.27162537f, 0.01379749f, 0.23804642f, 0.19492656f, 0.24642108f, 0.04860684f, 0.10080680f, 
    0.29454839f, -0.18525079f, -0.08069298f, 0.04102964f, 0.18430352f, 0.19669832f, 0.05929832f, -0.03623188f, 
    -0.04436192f, 0.06824161f, 0.21035461f, 0.04359205f, 0.00239271f, 0.01184659f, -0.06975947f, -0.04729456f, 
    0.11910720f, 0.18135463f, 0.47971278f, -0.15124655f, -0.09385788f, 0.06217771f, -0.01472911f, 0.31955656f, 
    0.30359918f, 0.19084938f, -0.06176703f, 0.07065540f, 0.05495638f, 0.18044546f, 0.05003438f, -0.05822680f, 
    -0.03823620f, 0.05277323f, 0.11123929f, 0.09538379f, 0.07987180f, -0.23196217f, -0.06661796f, -0.23586001f, 
    0.29896253f, -0.03447418f, 0.12997004f, -0.54381615f, -0.42561141f, 0.26204750f, -0.09872798f, 0.18216731f, 
    -0.15811779f, 0.27724123f, 0.03790011f, 0.20692807f, 0.28833684f, -0.06617987f, 0.35274318f, -0.05025261f, 
    -0.00594098f, -0.02519602f, -0.21011224f, -0.12023853f, -0.19858789f, -0.34089705f, 0.02470552f, -0.03387409f, 
    0.17193460f, 0.23437330f, 0.22683786f, 0.28622907f, 1.01302516f, -0.37268636f, -0.27623990f, -0.40850762f, 
    -0.71469873f, 0.44777751f, 0.02900621f, 0.16407514f, 0.15751426f, 0.19471191f, -0.11587143f, 0.05563198f, 
    -0.16505402f, 0.38881767f, -0.09026234f, 0.01780367f, -0.24929498f, -0.12085389f, 0.23345621f, -0.01199081f, 
    0.20223533f, 0.02605250f, 0.12879071f, -0.20104979f, -0.15267517f, 0.20220345f, 0.52408779f, 0.36273587f, 
    -0.04903130f, -0.37899655f, -0.35352877f, 0.00882531f, -0.03086407f, 0.00707152f, -0.64963627f, -0.34812209f, 
    -0.28176662f, -0.13610764f, -0.25096953f, -0.15214859f, 0.18380156f, -0.34766662f, -0.11413194f, 0.03976364f, 
    -0.17366561f, -0.07973218f, -0.14873607f, 0.16006468f, -0.20874110f, -0.01143371f, 0.36945519f, 0.56231213f, 
    -0.46067804f, -0.16122442f, 0.03266662f, -0.16243030f, 0.08115301f, 0.30661500f, 0.10965677f, -0.42576385f, 
    -0.04690484f, -0.17909700f, 0.08728378f, -0.12686399f, -0.03020607f, -0.11328355f, -0.09241882f, 0.28428665f, 
    0.14613108f, -0.11551487f, 0.05479452f, 0.07662092f, -0.31766492f, -0.23139952f, -0.23797865f, -0.27376100f, 
    -0.32685071f, -0.65745008f, -0.58950657f, -0.77545851f, 0.21053459f, 0.20820239f, -0.11172815f, -0.32274082f, 
    0.24067020f, -0.13732000f, -0.24482480f, -0.06285509f, -0.06158859f, 0.15374312f, -0.05332870f, 0.17577855f, 
    0.07103345f, -0.16523492f, -0.08039136f, -0.41369745f, -0.12922566f, -0.22243707f, -0.19172873f, -0.01165545f, 
    -0.18531726f, 0.07344110f, 0.09162984f, 0.10076603f, 0.29279611f, 0.32658201f, 0.02020462f, -0.26241153f, 
    0.07332247f, -0.19604996f, 0.18650365f, 0.10652130f, 0.34021097f, -0.36268702f, -0.11508455f, -0.06961647f, 
    -0.31620106f, 0.31865755f, -0.13549806f, 0.04223066f, -0.26518342f, -0.17196104f, 0.13014024f, 0.11757331f, 
    0.19431002f, 0.60639697f, 0.67823786f, -0.51504081f, -0.56007147f, 0.09863064f, -0.17186123f, -0.03469632f, 
    0.13972169f, 0.12019403f, -0.62050617f, -0.31499895f, 0.20845230f, -0.16732368f, -0.27119526f, 0.27216569f, 
    0.17767379f, 0.09104334f, 0.00686978f, -0.03750417f, 0.06909477f, -0.13902153f, 0.02858794f, 0.05013132f, 
    0.00733638f, 0.23804568f, 0.33036464f, -0.88445765f, -0.61263239f, 0.38285476f, 0.02437177f, 0.72108728f, 
    0.58593374f, 0.46124887f, -0.25164184f, 0.16276461f, -0.06570470f, -0.20777294f, -0.05357448f, -0.01744197f, 
    0.12680078f, -0.07906333f, -0.06142847f, -0.05335482f, -0.07840700f, 0.12958720f, 0.03920141f, -0.21189627f, 
    -0.15686895f, 0.02329509f, 0.13238093f, -1.11753201f, 0.53074050f, 0.84813571f, -0.56290632f, 0.11502802f, 
    -0.42161444f, 0.04732671f, -0.05768322f, 0.30086258f, -0.07476544f, -0.40843040f, 0.22791582f, -0.41159818f, 
    0.02137323f, 0.17520350f, 0.05786825f, 0.11108298f, -0.12711403f, 0.04210995f, -0.01035404f, 0.05498500f, 
    -0.24773867f, -0.07648761f, -0.14539526f, -0.04278347f, -0.01516089f, -0.02921657f, 0.11975983f, 0.25791171f, 
    0.10508803f, -0.25137326f, -0.14426754f, 0.30339107f, -0.11669873f, 0.33902028f, -0.10092554f, -0.08053010f, 
    0.25305632f, -0.07967456f, -0.10387871f, -0.02406838f, -0.16108754f, 0.06035988f, 0.11986056f, -0.14588885f, 
    0.17041440f, -0.26330987f, -0.14416294f, 0.01465970f, 0.11424986f, -1.36745405f, 0.54040152f, 0.25344461f, 
    -0.17777660f, 0.19372390f, -0.42083162f, 0.00578051f, 0.55253834f, 0.63815129f, -0.19117144f, -0.58989042f, 
    -0.34295499f, 0.04432175f, 0.14968759f, -0.11700797f, 0.54390103f, 0.00815860f, -0.38624012f, -0.25494084f, 
    -0.38581115f, -0.35546920f, 0.24384555f, -0.09568443f, -0.06922785f, -0.18122271f, -0.55005252f, -0.28917754f, 
    -0.49828750f, -0.63076997f, -0.55330282f, -0.09193663f, -0.12414622f, 0.14185889f, 0.12492520f, -0.10930628f, 
    -0.46314687f, 0.01081474f, -0.01735200f, -0.17740090f, -0.16672590f, 0.23813751f, 0.18207623f, 0.06114543f, 
    -0.05986150f, -0.00482227f, 0.12315778f, 0.27201140f, 0.19260120f, -0.07128182f, 0.36415508f, -0.50718164f, 
    0.13526157f, 0.13699272f, -0.09024698f, 0.38247955f, -0.30945027f, 0.09332190f, 0.37382630f, 0.21198544f, 
    0.14058279f, 0.01861287f, -0.17431171f, -0.14582004f, -0.00271117f, 0.29249907f, -0.07306081f, 0.31029254f, 
    -0.03656598f, -0.27535143f, -0.12781604f, 0.22842880f, -0.03494690f, -0.11338348f, -0.14795572f, -0.02630203f, 
    -0.64153540f, 0.34407628f, 0.62284654f, 0.12151267f, -0.42194641f, 0.05422711f, -0.02694380f, 0.17180292f, 
    0.09524326f, -0.14894184f, 0.02917279f, -0.26076555f, -0.12399513f, 0.28034931f, -0.23069121f, 0.14823519f, 
    -0.06548763f, -0.31738406f, 0.04953175f, -0.17428429f, -0.42046151f, -0.41475967f, -0.04769280f, -0.26800135f, 
    -0.53575796f, -0.78797525f, -0.60426784f, -0.38052455f, -0.08316855f, -0.12272879f, 0.20282234f, 0.24759717f, 
    0.37189117f, -0.09518230f, -0.04031073f, 0.24930438f, -0.04401777f, -0.00413094f, -0.34026539f, -0.20988730f, 
    0.21777113f, 0.14965253f, -0.18353036f, 0.02768789f, 0.12969822f, -0.26071915f, -0.26115528f, -0.15853584f, 
    -0.22706002f, -0.32137579f, 0.08923501f, 0.35566211f, 0.27166182f, 0.39199179f, 0.43547764f, -0.43496993f, 
    -0.42250291f, -0.33171067f, -0.21821472f, -0.08658043f, 0.34132895f, -0.14398687f, 0.10250098f, 0.16477522f, 
    -0.21763931f, 0.09203613f, 0.08189810f, -0.20394550f, 0.13122736f, -0.26796752f, 0.08791868f, -0.13440956f, 
    0.17337868f, 0.24064136f, 0.05267222f, -0.20644788f, 0.27421948f, -0.25469008f, -0.34648749f, -0.28389931f, 
    0.42063910f, 0.01942101f, -0.40596232f, 0.18531540f, 0.18072934f, 0.09935750f, 0.04413584f, 0.32969597f, 
    -0.33696723f, 0.02226838f, 0.24586755f, -0.35944712f, 0.19703101f, 0.10217438f, -0.31114259f, -0.34782937f, 
    0.29694697f, 0.16465910f, -0.20539315f, 0.09051455f, 0.52719641f, -0.04619061f, 0.04695740f, 0.14804690f, 
    0.06066694f, -0.46285570f, 0.02042549f, 0.46510535f, -0.10683914f, 0.18603256f, -0.17642860f, 0.28719535f, 
    0.07970566f, -0.05932405f, -0.25340140f, -0.29206309f, 0.20581171f, -0.09075989f, -0.27889356f, 0.01989152f, 
    0.17716748f, 0.22407766f, 0.22226404f, -0.40335950f, -0.24416213f, -0.34910765f, -0.53881025f, 0.38814449f, 
    0.59840566f, 0.07222544f, -0.33339107f, 0.23296528f, 0.03881147f, -0.09333926f, -0.32990628f, -0.40141141f, 
    -0.33306438f, 0.19099776f, 0.10301937f, 0.09645918f, -0.20537728f, -0.10248274f, 0.10691772f, 0.10702317f, 
    0.32641798f, 0.02435154f, 0.06091651f, -0.09746113f, -0.27314466f, -0.05454248f, 0.40984187f, -0.05182898f, 
    -0.09088311f, -0.02842176f, 0.40546206f, -0.30234778f, -0.14538510f, -0.04971042f, -0.12788911f, -0.24848594f, 
    -0.24085784f, -0.13795437f, 0.39099085f, -0.25000608f, -0.11678068f, 0.06040397f, 0.03664368f, -0.19905879f, 
    0.10490476f, -0.22260943f, 0.04744553f, 0.11961463f, 0.04404207f, 0.02707679f, 0.34786144f, -0.21009748f, 
    0.50985521f, 0.31567761f, -0.27272573f, 0.16149843f, -0.36002591f, -0.28877416f, 0.07101025f, 0.00259946f, 
    -0.22589517f, 0.14519040f, -0.35294002f, 0.28822142f, 0.08597559f, 0.02446646f, 0.29643008f, 0.14339510f, 
    -0.13770550f, 0.11119130f, -0.45968848f, 0.06769809f, -0.17099343f, -0.24435432f, 0.45425504f, 0.20214169f, 
    -0.10873509f, 0.25140265f, -0.36645928f, -0.64560688f, -0.08657841f, 0.49765119f, -0.37564999f, 0.10311899f, 
    0.45058334f, -0.14993355f, 0.10805829f, 0.11340753f, 0.02595443f, 0.11200777f, -0.24773239f, -0.20837417f, 
    -0.16582392f, 0.00384697f, -0.34966162f, 0.08449581f, 0.14465930f, 0.25496647f, 0.45561934f, -0.20303701f, 
    -0.02799999f, -0.09861720f, 0.71351838f, 0.36730629f, -0.33979475f, -0.14806974f, -0.46640256f, -0.11098025f, 
    0.09888238f, 0.23184566f, 0.08250073f, 0.09742893f, -0.09306388f, 0.11884772f, -0.18560612f, -0.14511715f, 
    0.39238879f, -0.06380238f, -0.02465604f, -0.09378451f, -0.18479137f, -0.02470467f, 0.16077095f, -0.31489566f, 
    -0.31603327f, -0.13966739f, -0.49272135f, 0.48030046f, -0.19707020f, 0.30520332f, 0.19836892f, 0.26106480f, 
    -0.02999285f, -0.13957454f, -0.16998683f, -0.14009906f, -0.38049257f, -0.09866305f, 0.04131329f, 0.31550542f, 
    -0.20261663f, 0.14120384f, -0.14408512f, -0.27041170f, -0.07052226f, -0.36059046f, -0.49208492f, -0.00332996f, 
    -0.57915443f, -0.56600964f, -0.64611155f, -0.00262697f, -0.30493549f, -0.33557177f, 0.10344373f, -0.60596961f, 
    0.37273109f, 0.51260310f, 0.27520591f, 0.07368071f, -0.30044341f, 0.25638375f, -0.18569998f, -0.24352066f, 
    0.51120615f, -0.56165367f, -0.39205611f, 0.16891907f, 0.08259917f, 0.21206477f, -0.14562081f, -0.09210645f, 
    -0.15930693f, 0.33583656f, 0.29175997f, -0.23533727f, -0.41387466f, -0.34021586f, 0.61721075f, 0.39089262f, 
    0.05236351f, 0.56022435f, -0.96057665f, -0.72898972f, 0.32834646f, -0.04307733f, -0.08012069f, 0.18100850f, 
    -0.03679553f, 0.07594615f, 0.21520640f, -0.03074879f, -0.10529683f, 0.08470201f, 0.02303463f, -0.02417799f, 
    0.30006188f, -0.02815744f, 0.04292963f, -0.15816617f, -0.24339136f, 0.44639906f, -0.11508732f, 0.04990286f, 
    0.09789819f, -0.33909830f, 0.16927037f, -0.04131819f, -0.40131196f, -0.38406962f, -0.34880042f, 0.54655218f, 
    -0.36688390f, -0.11095370f, 0.32025445f, 0.10937073f, 0.02040654f, -0.08707584f, 0.11110443f, 0.07581101f, 
    -0.28248620f, -0.25275874f, 0.22164129f, 0.19791736f, 0.09606559f, 0.24430285f, -0.86385441f, -0.73607945f, 
    -0.35214195f, 0.06172268f, -0.37664616f, 0.71758020f, 0.03515062f, -0.34139845f, 0.00820893f, 0.41835418f, 
    -0.21860194f, -0.41869181f, -0.49431437f, -0.37952301f, -0.41769224f, -0.06958020f, 0.01812412f, -0.15221509f, 
    -0.13018781f, -0.24666424f, -0.04447304f, -0.07215654f, -0.02906461f, 0.09956405f, -0.06889833f, 0.26075119f, 
    -0.14953911f, -0.28930002f, 0.01394683f, -0.60182595f, -0.11676256f, 0.09834918f, -0.09142123f, -0.06457687f, 
    -0.21819164f, 0.41276968f, 0.18061376f, 0.15002973f, 0.09634906f, 0.04849659f, 0.11358477f, -0.04261939f, 
    -0.08020294f, -0.16116042f, -0.29425767f, -0.18008165f, 0.07869315f, -0.12652373f, 0.12104178f, -0.40117738f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.23101428f, 0.23097979f, 0.16291963f, -0.49238864f, 0.11911000f, -0.06148667f, 0.19420911f, 0.14831629f, 
    0.10101017f, -0.16738522f, 0.05620412f, 0.53108466f, -0.08014227f, 0.52676892f, 0.06590051f, 0.10202934f, 
    0.30395222f, 0.20225614f, 0.17663594f, -0.09236398f, 0.33772343f, 0.24790637f, -0.06162702f, 0.11842547f, 
    0.16934745f, 0.09399623f, 0.11222253f, 0.05547783f, 0.02318401f, 0.22276287f, 0.23935910f, 0.11251211f, 
    0.08845246f, 0.13649233f, 0.31152299f, 0.13251656f, 0.17686678f, -0.04489453f, 0.14221650f, -0.07699894f, 
    0.28663084f, 0.26078725f, 0.29723537f, 0.36520585f, 0.23124447f, -0.15887031f, -0.12484117f, 0.37782216f, 
    -0.11648921f, 0.12638247f, 0.08020407f, 0.18675670f, 0.24763499f, 0.04849616f, -0.00345029f, 0.11550477f, 
    0.04212855f, 0.12178204f, -0.01321860f, 0.21846555f, 0.22352518f, 0.00071835f, -0.20584083f, 0.02887600f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18827514f, 0.05763346f, 0.09553086f, -0.08295301f, 0.10476599f, -0.09563346f, 0.13486990f, -0.12302474f, 
    -0.00970745f, -0.04494071f, 0.00994718f, 0.03882859f, 0.17878020f, -0.00947053f, -0.10532202f, -0.27104902f, 
    -0.05681566f, 0.02418611f, -0.05525031f, 0.06958139f, 0.01584571f, 0.01364216f, -0.05717004f, -0.00002983f, 
    -0.02229013f, -0.16988866f, 0.12308185f, 0.04675128f, -0.11577965f, -0.09734316f, -0.04762246f, 0.01470302f, 
    0.05741709f, 0.03793980f, 0.01710745f, -0.00837065f, 0.21675807f, 0.23619923f, -0.02528566f, -0.13874283f, 
    0.17222498f, 0.13815480f, 0.06965726f, 0.17408916f, -0.07049779f, -0.01117396f, 0.02332977f, -0.06778868f, 
    0.28040150f, 0.13161759f, 0.08752077f, -0.20347270f, 0.03911812f, 0.01194261f, -0.00190522f, 0.13889976f, 
    0.02300798f, 0.07681832f, 0.00323188f, 0.01499566f, -0.15462218f, 0.01728241f, 0.17096363f, -0.00740387f, 
    0.06981008f, 0.21664137f, -0.18540476f, -0.06462251f, 0.11378288f, 0.11027101f, 0.09798693f, -0.15805586f, 
    0.07363415f, 0.14704607f, 0.19493377f, -0.11317218f, 0.08409858f, 0.03745476f, 0.01043674f, -0.21240342f, 
    -0.04701123f, -0.09453215f, -0.05158168f, -0.07593770f, 0.10551956f, 0.02679895f, -0.02393229f, 0.04410674f, 
    -0.00863424f, 0.06504530f, 0.00074106f, -0.18878153f, -0.01300294f, 0.03238709f, -0.02170350f, -0.04518250f, 
    0.01149378f, -0.10357325f, -0.04145785f, 0.00131903f, -0.02787753f, -0.10890166f, 0.09725120f, -0.00418843f, 
    -0.07191726f, -0.03031346f, -0.00304274f, 0.05089563f, 0.04066714f, 0.08478930f, -0.01010843f, -0.03686852f, 
    0.12988263f, 0.06698157f, 0.05327788f, -0.13654281f, -0.06799606f, -0.01374445f, -0.01305649f, 0.04165991f, 
    0.17194119f, 0.14535902f, 0.29216862f, -0.12629728f, -0.01438962f, 0.03849389f, 0.05969333f, 0.04865044f, 
    0.07173041f, -0.03572946f, -0.22566439f, -0.16855146f, -0.39782804f, -0.38408503f, -0.44673324f, 0.01391697f, 
    -0.03331245f, -0.03013467f, 0.01647280f, 0.00990225f, -0.02521284f, -0.02919589f, -0.01385743f, -0.19952191f, 
    0.24214469f, 0.28531501f, -0.15092087f, -0.26473424f, 0.01399386f, 0.17693591f, 0.03898216f, 0.02121370f, 
    -0.06034835f, -0.10322498f, -0.14785609f, -0.08573368f, -0.47956100f, -0.64307815f, -0.67569417f, 0.08732656f, 
    0.02888866f, 0.03134124f, 0.02252270f, -0.01223041f, -0.09901366f, -0.02505703f, -0.03943448f, 0.01039276f, 
    0.33678144f, 0.20054527f, -0.36557868f, -0.15177020f, -0.06397053f, -0.05133972f, 0.05523409f, -0.06679439f, 
    -0.05333356f, 0.04113045f, -0.00548725f, -0.04763254f, -0.11602093f, 0.04362230f, -0.00280414f, -0.05167797f, 
    0.01073311f, 0.06131244f, -0.01079735f, 0.04586782f, 0.02893043f, 0.00394114f, 0.10867251f, 0.05585201f, 
    -0.12023169f, -0.56860852f, -0.09127918f, 0.05410490f, 0.00181377f, -0.01769639f, 0.06607745f, -0.00156325f, 
    -0.00715930f, 0.03533533f, -0.00159629f, -0.07217816f, -0.11441245f, -0.42011485f, -0.02731186f, 0.01421022f, 
    -0.02273250f, 0.02354416f, -0.05591189f, -0.05876093f, -0.06726307f, -0.28133708f, 0.01039501f, -0.10189640f, 
    -0.07453320f, 0.10112007f, 0.02216987f, 0.04864386f, -0.09839032f, -0.01181472f, -0.01354268f, 0.01930977f, 
    -0.14979200f, -0.01094477f, 0.05595590f, -0.06865963f, 0.26809633f, 0.11492217f, 0.03501231f, -0.20750350f, 
    0.03008806f, 0.12308228f, 0.01000482f, 0.02497893f, -0.04648165f, 0.05240745f, 0.07969677f, 0.05259629f, 
    -0.02715070f, 0.24172427f, 0.14005460f, -0.49879208f, -0.05796276f, 0.02389553f, -0.06858685f, -0.04629144f, 
    -0.03050110f, -0.10848356f, -0.00916677f, 0.05319585f, 0.40316492f, -0.18579222f, -0.07524203f, -0.05315815f, 
    0.01092540f, -0.07642972f, 0.01403161f, 0.02187256f, 0.03717383f, -0.01694049f, 0.12627167f, -0.01986657f, 
    -0.02610268f, -0.20618786f, -0.09492221f, 0.11331875f, 0.04021655f, 0.01860263f, 0.02245950f, 0.01314912f, 
    0.00278965f, 0.05435056f, -0.04484877f, -0.00632490f, 0.17418125f, 0.14095257f, 0.06585771f, -0.08351172f, 
    0.14794804f, 0.10711098f, 0.03074251f, 0.04169855f, -0.06123664f, -0.00894426f, -0.00937719f, -0.00900036f, 
    0.23267019f, 0.26813453f, 0.25039047f, -0.30076835f, 0.01933025f, 0.11086728f, 0.03082374f, -0.02661817f, 
    -0.06398266f, -0.13911296f, -0.10141061f, -0.01646054f, 0.25073642f, 0.01750205f, -0.11423160f, -0.11984598f, 
    0.05015418f, 0.13252887f, -0.06803120f, 0.10120714f, -0.11151269f, -0.19150330f, -0.01936946f, -0.05287654f, 
    -0.25505903f, 0.03542560f, 0.19086666f, -0.08307248f, 0.06021095f, -0.00370671f, -0.13144073f, -0.06908575f, 
    0.05947556f, 0.00613170f, -0.01040282f, 0.04230814f, 0.24565661f, 0.22727770f, 0.24946035f, -0.17320617f, 
    -0.04329926f, 0.08108354f, -0.02057521f, 0.03810142f, -0.08120885f, -0.05235456f, -0.04143250f, 0.00266194f, 
    0.15171804f, -0.01207645f, -0.24811544f, -0.05453373f, 0.13284200f, -0.01723406f, -0.04115339f, 0.02513886f, 
    -0.08697619f, -0.08587495f, -0.11804192f, 0.14299460f, 0.28329244f, 0.19203636f, -0.00334716f, -0.20969941f, 
    0.04417508f, 0.02613698f, 0.05849498f, -0.13093774f, 0.02421224f, 0.07798545f, 0.05440287f, 0.01854430f, 
    0.16815563f, 0.10509130f, 0.09952226f, -0.00165763f, -0.07940227f, 0.00549483f, 0.17290083f, -0.06099313f, 
    0.01349561f, 0.03064634f, -0.06118330f, -0.16212203f, -0.12877299f, -0.07590776f, -0.02939361f, 0.07490969f, 
    0.06598167f, 0.01927826f, 0.00535784f, 0.02015806f, -0.00398764f, -0.04733150f, -0.01262630f, 0.09629890f, 
    0.23313430f, -0.06538386f, -0.16625617f, -0.03951377f, -0.05510759f, -0.00678035f, -0.08247383f, -0.05110854f, 
    0.02196390f, 0.04825192f, 0.02377392f, -0.05631115f, -0.00459238f, -0.01865756f, 0.01869478f, 0.07489079f, 
    -0.03850362f, 0.01182852f, 0.01244075f, 0.01206582f, -0.02052365f, -0.00186630f, -0.02120670f, -0.01725089f, 
    -0.00935231f, 0.04829898f, -0.03970625f, 0.07344884f, 0.04557239f, -0.02283396f, -0.02098681f, 0.00093883f, 
    -0.12719217f, -0.27733868f, -0.27232912f, -0.11293664f, -0.18204586f, 0.03601949f, 0.14064363f, -0.09804689f, 
    0.04036213f, 0.03889258f, 0.08784206f, 0.02271367f, -0.06675240f, -0.07706585f, -0.09747766f, -0.14614159f, 
    -0.15480904f, -0.48481417f, -0.15335689f, 0.09046665f, 0.04125437f, -0.01522073f, 0.00254703f, -0.04151632f, 
    -0.00910934f, -0.08812789f, -0.23593490f, 0.01162207f, -0.21066584f, 0.03543130f, 0.15421706f, 0.15419438f, 
    -0.03204340f, -0.01032508f, -0.08140684f, -0.00036489f, -0.01225428f, -0.00686163f, 0.01044345f, -0.00337929f, 
    -0.18740846f, -0.34155419f, -0.08972847f, 0.13422801f, 0.02407313f, 0.02298716f, -0.04239886f, 0.00560306f, 
    0.10831489f, -0.02697049f, -0.16100533f, -0.04282021f, 0.19242641f, 0.13770816f, 0.02423945f, -0.06827093f, 
    0.09977148f, 0.11176058f, 0.10735504f, -0.00059430f, -0.02380768f, -0.01385560f, 0.02092162f, 0.03697920f, 
    -0.04413861f, -0.04658983f, -0.07124355f, 0.00941013f, 0.05689640f, -0.05495372f, 0.04738915f, -0.00283811f, 
    -0.09004720f, -0.08296920f, -0.03290723f, 0.02275988f, -0.00009730f, -0.05444491f, -0.18430994f, 0.10112381f, 
    -0.15369998f, -0.09146624f, -0.07861088f, -0.08619128f, -0.06819528f, 0.04625027f, -0.08763139f, -0.06001613f, 
    0.22259273f, -0.14635845f, -0.20686151f, 0.06276853f, 0.00298986f, -0.01150717f, 0.09025215f, -0.01550986f, 
    0.13336426f, -0.03114611f, -0.05656765f, 0.02984076f, -0.30547300f, 0.06720326f, 0.14453699f, -0.05306086f, 
    -0.22606151f, 0.08706331f, -0.03750058f, 0.03228874f, -0.04576147f, 0.00298934f, -0.06945890f, -0.24752109f, 
    -0.19473939f, -0.06307159f, 0.03560576f, 0.04560368f, 0.02539221f, 0.02012467f, 0.02432440f, 0.05578276f, 
    -0.03111262f, -0.00173261f, -0.03709153f, 0.03351865f, -0.25554869f, -0.02942141f, 0.38449505f, -0.04803253f, 
    -0.06396914f, 0.00177998f, 0.03870491f, 0.04520937f, 0.01126264f, 0.10159093f, 0.01141438f, 0.03423372f, 
    0.17435241f, 0.10985539f, 0.06559461f, -0.13426092f, 0.04895065f, 0.11925756f, -0.05955140f, 0.06446138f, 
    0.01280979f, 0.02613512f, -0.00077986f, 0.02107190f, -0.44828418f, -0.14118591f, 0.13419798f, 0.00385989f, 
    -0.07255458f, 0.05227400f, 0.06037992f, 0.02266818f, -0.27488971f, -0.10119953f, -0.08317757f, -0.07843529f, 
    -0.21066892f, -0.19488053f, -0.02812907f, -0.08805526f, -0.02184691f, 0.01962437f, -0.04874642f, 0.10963007f, 
    -0.04777072f, -0.13787110f, 0.00698571f, 0.11594781f, 0.24334158f, 0.05005053f, -0.07153946f, -0.06805664f, 
    0.10152604f, 0.05157879f, 0.04826593f, -0.01462496f, -0.12057384f, 0.02890643f, 0.11110850f, 0.03107349f, 
    -0.07914062f, 0.18074904f, 0.09672102f, -0.07753669f, 0.04840533f, 0.02594959f, -0.06208847f, 0.01825766f, 
    -0.01387057f, -0.01753026f, -0.03546342f, 0.00193114f, 0.11266825f, -0.04292077f, -0.22547443f, 0.03234783f, 
    0.00826261f, 0.02526198f, -0.07174831f, -0.15675700f, -0.02550526f, -0.03957132f, -0.08519264f, 0.01501451f, 
    -0.47454044f, -0.22892587f, -0.11016721f, 0.03612251f, 0.01347065f, 0.00181758f, -0.04467972f, 0.06888264f, 
    0.03587358f, -0.02149414f, -0.00014842f, 0.02097615f, 0.47754529f, -0.25286362f, 0.20261048f, -0.36576864f, 
    -0.07749907f, -0.14923798f, 0.09311143f, -0.04659451f, -0.02900456f, -0.07337534f, 0.00443816f, -0.02562440f, 
    -0.04495318f, 0.10335375f, -0.03170424f, -0.00041538f, 0.16342905f, -0.14097922f, -0.05388261f, 0.05006433f, 
    -0.02762957f, 0.02346480f, -0.04530460f, 0.01446038f, 0.02202580f, -0.03383086f, 0.09930812f, 0.00679560f, 
    -0.08274963f, -0.04185887f, -0.16245656f, 0.08461200f, 0.01319448f, 0.01126050f, -0.07807034f, 0.04290447f, 
    0.05556846f, -0.20354383f, -0.31353417f, -0.08384905f, -0.04908091f, 0.22907013f, -0.13002229f, -0.00915068f, 
    -0.06506219f, -0.18641318f, 0.06513199f, -0.08307407f, -0.46439007f, -0.10805136f, 0.12502827f, 0.08883744f, 
    -0.00607078f, 0.08124514f, -0.08112516f, -0.00340151f, -0.14797981f, -0.10903808f, -0.16435225f, -0.01123197f, 
    0.10180029f, -0.08143184f, -0.18334857f, 0.06348708f, -0.07057193f, -0.04436066f, -0.02766022f, -0.04668208f, 
    -0.03384814f, 0.05217498f, 0.07163170f, 0.14758283f, 0.17411174f, -0.39003882f, -0.41319332f, 0.01533499f, 
    0.02627883f, -0.04560754f, -0.11995844f, -0.05070472f, 0.03641693f, -0.11793998f, -0.17102177f, -0.07226454f, 
    0.10780583f, 0.25590631f, 0.04084880f, -0.37850067f, -0.24916133f, -0.12017193f, -0.04587604f, 0.08101451f, 
    0.04033568f, -0.01587780f, 0.02639438f, -0.03216051f, 0.12125090f, -0.10501894f, -0.13600238f, -0.02425562f, 
    -0.14577197f, -0.02208416f, 0.08085636f, -0.27720037f, -0.01567387f, 0.04309908f, 0.04143242f, 0.03969869f, 
    0.31983668f, 0.25419834f, 0.04938718f, -0.13997570f, 0.03940294f, -0.03527357f, -0.00031276f, -0.11687738f, 
    -0.04434772f, 0.02101297f, -0.04017158f, -0.07402235f, 0.11378156f, -0.02919130f, -0.05246598f, -0.03150410f, 
    -0.02771469f, 0.01567552f, -0.07865120f, -0.05877756f, -0.11241596f, 0.13429528f, -0.03257425f, 0.08311540f, 
    0.08322538f, 0.17385498f, 0.03349248f, 0.08391454f, 0.16285951f, 0.19112445f, 0.16562876f, -0.06638270f, 
    0.11060435f, -0.01224883f, 0.01845195f, -0.07633371f, -0.21792050f, -0.09182840f, 0.17252751f, -0.22851326f, 
    0.11205351f, -0.00665955f, 0.11861580f, -0.07284239f, 0.03941206f, -0.00874181f, 0.03844467f, -0.03690301f, 
    0.05562146f, -0.12923628f, 0.02929838f, -0.09237627f, 0.05552861f, 0.03954979f, 0.03686561f, -0.03404043f, 
    0.25894770f, 0.04981197f, -0.08901854f, 0.21853387f, 0.17892815f, 0.16523278f, 0.26164442f, 0.02761856f, 
    -0.12797418f, 0.02795688f, -0.11857609f, -0.21634570f, -0.00113726f, 0.05418564f, 0.00021870f, 0.03808819f, 
    -0.20320369f, 0.02154174f, -0.05168120f, 0.09225851f, -0.12145203f, -0.01727774f, 0.11029938f, -0.04866189f, 
    -0.02327989f, -0.00742179f, -0.00691378f, 0.01123315f, -0.22294024f, 0.05902652f, 0.14094964f, -0.14977752f, 
    -0.04982579f, 0.01238910f, -0.13960022f, -0.06606607f, -0.06851094f, -0.05460599f, -0.08718167f, -0.09774429f, 
    -0.26403746f, 0.15673624f, -0.13101715f, -0.02324704f, -0.01576367f, 0.07493436f, 0.03105072f, 0.12762983f, 
    -0.09384626f, 0.07772243f, -0.00871716f, 0.03248642f, 0.00469326f, -0.08511652f, 0.08437818f, -0.06463870f, 
    0.20123935f, 0.02721031f, 0.27084079f, -0.05030899f, 0.02431232f, 0.02708667f, 0.00322963f, 0.07494976f, 
    0.03594048f, 0.04620820f, -0.01060494f, 0.00118645f, 0.01097866f, 0.08541063f, -0.03160658f, 0.05039773f, 
    -0.14531808f, 0.11401286f, 0.02209138f, -0.00792613f, -0.12222818f, -0.06414710f, 0.06172323f, 0.02236296f, 
    -0.10119824f, 0.02623268f, -0.00437378f, 0.13884720f, -0.12880521f, -0.02291913f, 0.07348957f, -0.00419873f, 
    -0.56018132f, 0.04496726f, 0.00688937f, -0.11558688f, -0.05570794f, -0.00095185f, 0.04286850f, 0.02677753f, 
    0.06815264f, -0.01581945f, -0.11874351f, 0.06883857f, 0.36737162f, 0.18866085f, 0.15288109f, 0.30201954f, 
    -0.01428085f, 0.02111527f, 0.01086353f, 0.02241953f, -0.02695206f, 0.07865726f, -0.16084646f, 0.17528869f, 
    -0.08443352f, -0.01307270f, -0.03292962f, 0.06897990f, 0.05026931f, 0.07749012f, -0.11612906f, 0.26481417f, 
    -0.05195362f, 0.03603033f, 0.07340092f, 0.03566698f, 0.27423260f, 0.13476110f, 0.27942201f, -0.12807626f, 
    0.01602993f, -0.02061630f, -0.09030328f, -0.01673419f, -0.02485470f, -0.07451130f, 0.00929553f, 0.08423544f, 
    -0.04769507f, 0.00585465f, 0.09357382f, 0.05123023f, -0.20945820f, 0.12892316f, -0.00340490f, 0.09429912f, 
    0.02746020f, 0.05444783f, 0.02489960f, 0.03393073f, 0.06137967f, -0.19440573f, -0.09958816f, -0.03884719f, 
    0.01464052f, -0.05126823f, -0.01905341f, 0.04942105f, -0.21625030f, -0.02325163f, -0.07043316f, -0.00762763f, 
    0.55764419f, 0.04006178f, 0.20974675f, 0.41842073f, -0.07391279f, -0.03808560f, 0.02112024f, -0.08484981f, 
    -0.00901168f, 0.00602846f, -0.02970945f, 0.04311828f, 0.38347879f, -0.18873838f, 0.02180705f, -0.19392008f, 
    -0.02178804f, -0.04511445f, 0.11886841f, -0.02684948f, 0.07464071f, -0.13135779f, -0.06128061f, -0.05756989f, 
    0.11533201f, -0.03954801f, 0.01578297f, 0.13552032f, -0.00226672f, 0.01412335f, 0.00611804f, 0.00873025f, 
    0.02323977f, -0.03087582f, 0.07724386f, -0.08046746f, 0.16299360f, 0.13735385f, 0.18855025f, 0.05333047f, 
    0.01151944f, 0.13151745f, -0.17913377f, 0.02624219f, -0.06390920f, 0.03443607f, 0.10330288f, -0.18472107f, 
    -0.50908506f, 0.24679844f, 0.02008959f, -0.25635809f, 0.11407891f, -0.03410095f, -0.12082689f, -0.09345877f, 
    -0.03862444f, -0.00376224f, 0.06632971f, -0.00294328f, 0.40928489f, -0.06700143f, 0.01985409f, 0.06636532f, 
    -0.04734609f, 0.05059959f, 0.01751643f, -0.01934232f, 0.06366852f, -0.01564060f, -0.08964435f, 0.09933303f, 
    0.47407669f, -0.12760152f, -0.06994255f, -0.05764916f, -0.02768762f, 0.03138899f, -0.00572345f, -0.17006916f, 
    -0.00104643f, -0.19440688f, -0.22385602f, -0.07476170f, -0.15836373f, 0.15249614f, 0.02932078f, -0.12196083f, 
    0.01184392f, -0.02737092f, 0.03222676f, -0.10238667f, -0.10204923f, -0.01695366f, 0.02550306f, -0.06126122f, 
    -0.57133776f, -0.14689387f, -0.31955287f, 0.05148365f, -0.02418398f, 0.07467209f, -0.00107066f, 0.06146470f, 
    0.02986247f, -0.07063162f, -0.03430530f, 0.06985784f, -0.23965508f, -0.28372777f, 0.24365109f, -0.08213411f, 
    0.00796853f, 0.07004615f, 0.28631732f, -0.10445585f, 0.17021221f, -0.00603069f, 0.06220048f, 0.01298180f, 
    0.14157094f, -0.01299517f, -0.01216726f, -0.21202426f, 0.04667960f, -0.11269768f, -0.07514992f, -0.19215426f, 
    -0.05950782f, 0.00001561f, -0.08000819f, -0.02038288f, -0.45323649f, -0.21561366f, -0.44753218f, 0.06524475f, 
    -0.03908918f, -0.03211197f, 0.08995713f, 0.02373713f, -0.06147832f, -0.16285913f, -0.22321671f, -0.17736357f, 
    0.30955869f, -0.30938974f, 0.28644919f, -0.20905904f, -0.03743409f, -0.14686717f, -0.11785247f, -0.04798036f, 
    0.00926299f, -0.09395806f, -0.05248148f, 0.09026435f, -0.08303084f, 0.11189215f, -0.16854846f, 0.06610091f, 
    -0.11548055f, -0.14015974f, 0.03058299f, 0.02136946f, -0.01196710f, -0.11294524f, -0.03637005f, -0.00645261f, 
    -0.11609612f, 0.16009846f, -0.21086252f, -0.00943320f, 0.08415988f, 0.02591697f, -0.15733959f, -0.16066767f, 
    0.06340335f, -0.12303764f, 0.07822880f, 0.04427200f, 0.05634160f, 0.07890155f, 0.09312227f, 0.06547059f, 
    -0.02068177f, -0.02074568f, -0.04213842f, 0.00651925f, -0.09692554f, -0.03147806f, 0.06178199f, 0.10471024f, 
    -0.03399736f, -0.21094291f, -0.01195480f, -0.10837991f, 0.09327621f, 0.07997010f, -0.09507741f, 0.11715431f, 
    0.10022132f, -0.03123249f, 0.00038253f, 0.13548952f, 0.10195626f, 0.03591674f, 0.06123231f, 0.04949398f, 
    0.03470558f, 0.03444093f, -0.01146119f, -0.04607581f, 0.06946783f, 0.01685350f, 0.04110024f, 0.07346893f, 
    0.17847058f, 0.05250721f, 0.05790391f, 0.10063370f, -0.00477246f, -0.02026950f, -0.01238340f, -0.07777846f, 
    0.08946469f, 0.14939785f, 0.12599276f, -0.03136793f, -0.06454775f, 0.07204391f, -0.02121034f, -0.02096734f, 
    -0.07327908f, 0.05099614f, 0.02515182f, 0.04669122f, -0.03539480f, 0.03127331f, -0.05309629f, 0.14040621f, 
    0.57157081f, -0.08902264f, -0.21552038f, -0.10543590f, -0.01240777f, 0.02223062f, -0.12726212f, 0.01837329f, 
    0.01564054f, -0.05769742f, -0.05105230f, -0.06883051f, 0.09174233f, -0.30536836f, -0.17205377f, -0.57627732f, 
    -0.08169978f, -0.00640773f, 0.04378069f, -0.09083071f, -0.04788158f, 0.01268523f, -0.00601815f, -0.02723903f, 
    0.01239739f, 0.00211094f, 0.08187076f, -0.02594833f, 0.02412295f, -0.07696696f, -0.03869316f, -0.00022944f, 
    -0.25948301f, -0.14598000f, -0.00522102f, 0.07432305f, 0.28315270f, 0.02857192f, 0.16129872f, 0.09000126f, 
    0.15630630f, 0.08803830f, -0.17946409f, -0.41722488f, 0.06287084f, 0.08999734f, -0.10656606f, -0.15664977f, 
    -0.03105889f, 0.06657406f, -0.00169007f, 0.17593919f, -0.02362845f, 0.00965841f, -0.00525441f, -0.03364484f, 
    -0.00132612f, 0.08134476f, -0.04126681f, 0.04658620f, 0.25564793f, -0.07259434f, -0.11185771f, 0.10693768f, 
    -0.08205203f, 0.07552163f, 0.14685151f, -0.34066287f, -0.08828539f, 0.10978599f, -0.05234855f, 0.00781828f, 
    0.54344732f, -0.21681026f, -0.04453495f, 0.09340861f, 0.00344606f, 0.01053743f, 0.01509750f, -0.12913103f, 
    0.21209462f, -0.17344233f, 0.08596923f, 0.02758779f, -0.27040178f, -0.17379148f, 0.03524236f, -0.17598994f, 
    0.17307091f, 0.01771113f, -0.18200152f, 0.20316878f, 0.23918025f, 0.10902885f, 0.01108740f, 0.03359738f, 
    -0.04634984f, 0.20026697f, 0.05416848f, 0.08826559f, -0.01018123f, 0.01639966f, -0.02689640f, -0.01915892f, 
    0.02353132f, -0.00683145f, 0.04906914f, -0.00137149f, -0.78641546f, -0.12016752f, 0.01415747f, -0.02366339f, 
    0.06307629f, -0.02463203f, -0.08258822f, -0.00769641f, -0.13808088f, 0.07527874f, -0.18472794f, -0.15106137f, 
    0.07414103f, 0.28327933f, 0.09007389f, 0.05747147f, -0.13139670f, 0.08312841f, -0.01426542f, -0.02072730f, 
    -0.04158662f, -0.03314807f, -0.06615820f, -0.04089129f, -0.03698016f, 0.03752644f, 0.14238557f, 0.06834457f, 
    0.01405388f, -0.02225672f, -0.04188780f, 0.01696765f, 0.17221385f, 0.03445344f, -0.14182378f, 0.04339813f, 
    0.00702410f, -0.04985769f, 0.01020799f, -0.00695527f, 0.01842057f, -0.04439027f, -0.04787053f, -0.00523805f, 
    -0.11193547f, 0.00587420f, -0.33457857f, -0.36567023f, 0.07200330f, -0.01727372f, -0.00674982f, 0.01541926f, 
    0.03076612f, -0.03656334f, 0.02424645f, -0.11510178f, 0.12214015f, 0.01720224f, -0.20869640f, -0.11473826f, 
    -0.03398835f, 0.17056361f, -0.08491756f, -0.01134936f, -0.01942843f, -0.07797202f, -0.03105224f, -0.06201963f, 
    -0.03038379f, -0.00861456f, 0.04092973f, 0.00091688f, -0.12254235f, 0.00366571f, 0.07254574f, -0.13007535f, 
    0.03650219f, 0.10285228f, -0.05499450f, -0.08447430f, -0.15471677f, 0.08599988f, 0.03343677f, -0.09054568f, 
    0.35207599f, 0.37445745f, 0.17266215f, 0.02738798f, 0.00194126f, -0.00989546f, -0.08776858f, 0.03681061f, 
    -0.00358096f, -0.00135780f, -0.04159867f, 0.04270238f, -0.22053885f, 0.09989230f, 0.09954918f, -0.32554832f, 
    -0.05981221f, -0.01591707f, -0.05213637f, -0.03404015f, 0.14265081f, 0.01434010f, 0.06800409f, -0.07452692f, 
    0.06141135f, 0.03490264f, -0.05129048f, 0.06871182f, -0.33869851f, -0.04011065f, 0.07207938f, -0.06879834f, 
    -0.08045604f, 0.02079552f, 0.02507417f, -0.04116512f, -0.01338181f, -0.01536766f, 0.00908934f, -0.03486284f, 
    0.06203236f, 0.02207924f, 0.09972900f, -0.12128434f, -0.02045524f, 0.01160194f, 0.00237394f, 0.04246750f, 
    -0.12821262f, 0.04638581f, -0.18506500f, -0.16320565f, 0.05338121f, -0.07473306f, 0.00831870f, 0.19630453f, 
    -0.08016668f, 0.16564421f, -0.10932244f, -0.09942418f, -0.01028525f, -0.11192565f, 0.15273048f, -0.00364817f, 
    0.05626182f, 0.02856393f, -0.01417182f, -0.00493992f, 0.00243809f, 0.04783934f, -0.08118945f, -0.00405506f, 
    -0.11108299f, -0.01547354f, -0.03359727f, 0.18610333f, 0.04429141f, -0.02470709f, -0.02735289f, -0.02057859f, 
    -0.44552174f, -0.27900711f, -0.28910339f, -0.08728580f, 0.08215282f, -0.22865976f, 0.03218108f, -0.17762849f, 
    -0.02818038f, -0.13570423f, 0.23213333f, -0.02910832f, -0.02209233f, -0.00749989f, 0.19393913f, 0.05844042f, 
    -0.38422045f, 0.17281556f, -0.10688745f, -0.12928936f, 0.07977147f, -0.03364751f, 0.08387147f, 0.17960046f, 
    -0.02242586f, -0.05093924f, 0.21350913f, -0.07266628f, 0.04308355f, -0.08561202f, 0.05412308f, -0.08720988f, 
    -0.22105141f, 0.04972069f, 0.06561098f, 0.10742599f, -0.03304747f, 0.06077339f, 0.05623600f, 0.01491898f, 
    0.41963249f, 0.23105507f, -0.01188020f, -0.24713457f, 0.01064046f, -0.08206297f, 0.05244185f, 0.11158998f, 
    0.05991713f, 0.01245730f, -0.15805762f, -0.09270664f, -0.07699683f, -0.14472356f, -0.09410211f, -0.10618202f, 
    -0.00457584f, -0.04541585f, 0.03375370f, 0.10871793f, 0.14037450f, -0.31661260f, 0.05467204f, 0.05049410f, 
    -0.17590974f, 0.25695643f, -0.06029432f, -0.07072479f, -0.12806027f, -0.03907335f, 0.09234359f, -0.19776085f, 
    -0.08656780f, -0.00992247f, 0.05461279f, 0.05502935f, -0.11369544f, -0.13466598f, 0.08535102f, -0.04825011f, 
    0.03291414f, 0.04907758f, -0.08202576f, 0.03281932f, -0.14720446f, 0.09329445f, 0.04650221f, 0.01970239f, 
    -0.01549761f, -0.01424930f, -0.00227829f, -0.17737722f, -0.04194456f, -0.07413565f, -0.20762789f, -0.14026028f, 
    0.07591027f, -0.05916315f, -0.06687726f, -0.00329452f, -0.87191784f, -0.35679740f, -0.40975589f, -0.49753520f, 
    -0.11543962f, -0.00818345f, 0.07084968f, -0.05457466f, -0.05944337f, -0.05616499f, -0.00497690f, -0.02666255f, 
    -0.12979349f, -0.13426217f, -0.20042667f, 0.09582834f, 0.08969351f, -0.07874289f, 0.21179138f, -0.02231468f, 
    0.01161491f, 0.00988963f, 0.10205604f, 0.01176827f, 0.09274330f, 0.14756913f, -0.03843585f, 0.07556984f, 
    -0.13181597f, -0.01661832f, -0.20537272f, 0.08382437f, 0.01856569f, 0.05766396f, 0.03130629f, -0.01824287f, 
    -0.12813933f, 0.12569207f, -0.23958935f, 0.14859767f, 0.01094890f, 0.18483923f, -0.08052211f, -0.04564452f, 
    0.00185426f, -0.08876132f, -0.01424754f, 0.00974701f, -0.01871107f, 0.00904706f, 0.03538058f, -0.08227182f, 
    0.00418690f, -0.15855600f, 0.11324336f, -0.03554431f, -0.01469649f, -0.04001125f, -0.00434574f, -0.00359667f, 
    -0.18139929f, 0.07428779f, 0.01172207f, -0.08457588f, 0.07428499f, -0.23116258f, -0.06807050f, -0.04542295f, 
    0.00991350f, -0.00310973f, 0.01246847f, 0.05075447f, 0.02641606f, -0.07434694f, 0.05899037f, 0.19579785f, 
    0.04061900f, 0.01411630f, 0.09265939f, -0.10597126f, 0.05850001f, -0.05608559f, -0.03314351f, -0.00858070f, 
    -0.27708554f, -0.16686840f, -0.20805348f, 0.06748439f, 0.02426663f, 0.08816513f, 0.00723787f, -0.01918343f, 
    -0.05292588f, -0.10442951f, 0.10934161f, -0.11608175f, 0.03871506f, 0.01569037f, -0.05230514f, -0.00597786f, 
    -0.00974729f, -0.01218745f, 0.01378148f, -0.00209756f, 0.01061465f, 0.03557228f, -0.08663829f, 0.01294485f, 
    -0.35062823f, -0.21035184f, -0.15453218f, -0.46671984f, 0.16738425f, -0.03533684f, -0.10264231f, 0.04898281f, 
    -0.00187391f, -0.05752185f, 0.02786693f, -0.04746717f, -0.29817691f, 0.25952482f, 0.27463293f, -0.49480885f, 
    0.00884955f, 0.01415029f, -0.05022613f, 0.11684129f, 0.03543680f, -0.04202517f, 0.03890686f, -0.01941801f, 
    -0.64937955f, -0.31168175f, -0.06899484f, -0.31364721f, 0.06136972f, -0.02584633f, 0.02037390f, 0.15529124f, 
    0.00720088f, -0.02526248f, -0.05638577f, -0.01549224f, 0.20710945f, 0.10791308f, -0.09992873f, 0.15252203f, 
    0.05029115f, -0.05363777f, -0.02844581f, 0.01665599f, -0.00865123f, -0.00594331f, 0.03285021f, 0.12835269f, 
    0.04267104f, -0.05267553f, -0.00486724f, 0.12616241f, -0.03992278f, 0.00330813f, 0.01498869f, 0.01209216f, 
    0.07502562f, -0.03478715f, -0.01673888f, 0.07509001f, -0.02449806f, 0.15170595f, -0.11839379f, -0.06077711f, 
    -0.02682232f, 0.02644782f, -0.13065070f, 0.09606916f, -0.01751109f, -0.13215627f, -0.08814546f, 0.02520482f, 
    -0.08191962f, -0.03792025f, 0.04931397f, 0.04678097f, 0.00618453f, 0.02799245f, -0.07835471f, 0.11399187f, 
    -0.02254433f, -0.06993739f, 0.10854882f, -0.04236494f, 0.14239815f, 0.07701018f, 0.60997981f, 0.52972084f, 
    -0.01415264f, 0.10114519f, -0.10427096f, 0.09345212f, 0.04916870f, -0.05318331f, -0.03593529f, 0.07777461f, 
    -0.35745022f, 0.17238781f, -0.11213282f, 0.09079245f, -0.03788497f, -0.04329729f, -0.04540559f, 0.06599581f, 
    0.07271509f, -0.02113436f, 0.10443068f, -0.01923006f, -0.08189238f, -0.12490437f, 0.15847893f, -0.03516085f, 
    0.01693328f, 0.01970840f, 0.02339740f, 0.04070650f, 0.08199120f, 0.05469734f, 0.05184053f, 0.08151142f, 
    -0.10792041f, 0.37832975f, 0.14539008f, 0.03723805f, -0.01187634f, 0.08954946f, 0.05066770f, -0.06844309f, 
    -0.00711047f, 0.06289789f, 0.03145066f, 0.09977809f, 0.12578040f, -0.07667752f, 0.44342408f, 0.38022634f, 
    -0.08937164f, -0.04141811f, 0.13008840f, 0.08041833f, 0.04479038f, 0.05609558f, -0.04255415f, 0.04252070f, 
    0.12256963f, -0.18833418f, -0.50191325f, 0.04981980f, 0.08894105f, 0.03702359f, -0.15876448f, -0.02755750f, 
    0.01125244f, -0.00685195f, -0.10292375f, 0.07171638f, -0.02385293f, 0.03731656f, 0.41427463f, 0.01478509f, 
    0.03660862f, -0.08348241f, 0.05089284f, 0.06716221f, 0.01921609f, -0.13743527f, 0.06525399f, -0.15920690f, 
    -0.35211617f, -0.21149379f, 0.07700303f, -0.08674763f, 0.00172871f, -0.06192894f, -0.03890619f, -0.14637271f, 
    0.06065701f, -0.04189773f, -0.03805223f, 0.08373625f, 0.15288614f, -0.09125987f, -0.15476948f, 0.19317991f, 
    0.00558214f, 0.01657513f, 0.02157646f, -0.00970440f, -0.07232241f, -0.19326678f, 0.11450902f, 0.14010736f, 
    -0.42563596f, -0.23117998f, 0.09067722f, -0.54318613f, -0.07299685f, 0.02604126f, -0.03906203f, -0.40210834f, 
    -0.04486909f, 0.00420720f, 0.04772868f, -0.14598984f, -0.07639878f, -0.08147564f, -0.12070537f, 0.23216936f, 
    0.11105449f, -0.00024806f, 0.13437299f, 0.14860353f, 0.06815279f, 0.03275922f, 0.03981307f, 0.07519073f, 
    -0.10088812f, 0.02405581f, 0.01499269f, 0.13196543f, 0.02110024f, 0.06993043f, 0.03537787f, 0.17370352f, 
    0.03063565f, 0.05447027f, 0.02862149f, 0.01797653f, -0.01852215f, -0.02262387f, -0.03289452f, -0.03277041f, 
    0.01619386f, -0.00173784f, -0.05416672f, -0.00794412f, 0.01448798f, 0.02319828f, 0.05645194f, 0.00262694f, 
    -0.22320534f, -0.11901698f, 0.11268227f, 0.01921190f, 0.04559681f, -0.05100095f, -0.29076236f, -0.24339844f, 
    0.11302226f, 0.06030507f, -0.11151145f, 0.04803818f, -0.11026219f, -0.04366255f, -0.07179955f, 0.00970335f, 
    -0.11060680f, -0.01001292f, 0.03054799f, 0.06147445f, -0.05488551f, -0.01419232f, 0.06469478f, -0.05181633f, 
    -0.02566753f, 0.00951464f, 0.06203390f, -0.01790876f, 0.01164297f, 0.01372135f, 0.03618178f, -0.05125796f, 
    -0.13426968f, -0.22470599f, 0.04068372f, 0.06176313f, 0.13265435f, -0.12818693f, -0.21201743f, -0.05271658f, 
    0.01856469f, 0.04346130f, -0.02546327f, 0.01625301f, -0.05719251f, -0.04464837f, -0.14452253f, -0.13110128f, 
    -0.47229871f, 0.50783926f, -0.02414368f, 0.02982688f, 0.03344257f, 0.05024526f, -0.03783179f, 0.03966932f, 
    0.02654222f, -0.11627932f, 0.09801275f, 0.07391874f, -0.03432633f, -0.08089421f, 0.15175857f, -0.37932056f, 
    0.02880024f, -0.04096642f, -0.00403990f, 0.03112709f, -0.02580892f, -0.04835227f, 0.00925808f, -0.04708332f, 
    -0.03796154f, -0.02291561f, 0.00878100f, 0.01160665f, 0.06372964f, -0.08338315f, -0.14095357f, 0.02255632f, 
    0.02499342f, 0.04010456f, 0.04150635f, -0.12313338f, -0.07839025f, 0.04465169f, 0.39523914f, 0.26654840f, 
    -0.04488409f, 0.06537348f, -0.02735407f, -0.00882624f, -0.00532950f, 0.05913790f, 0.03365225f, 0.01606707f, 
    -0.02695278f, -0.00272091f, -0.12152548f, -0.14718248f, 0.03281811f, -0.01291189f, 0.00467062f, 0.08463681f, 
    -0.05388587f, -0.02739736f, 0.10201566f, -0.13009536f, -0.05332705f, 0.03337571f, 0.20310633f, -0.11164381f, 
    -0.11487488f, -0.14392298f, 0.05585187f, -0.18242984f, -0.02247647f, 0.07822106f, -0.06401426f, 0.05003598f, 
    -0.02653535f, -0.11452087f, 0.36088401f, 0.00209883f, -0.04740763f, 0.03646563f, 0.07172151f, 0.05423649f, 
    0.08448885f, 0.12514630f, 0.03857798f, 0.00953209f, 0.62610412f, -0.04642558f, -0.01051653f, 0.05540781f, 
    -0.04584976f, 0.06910157f, -0.12634955f, -0.02674544f, -0.07303400f, 0.07052593f, -0.12712380f, 0.00793510f, 
    -0.10778012f, 0.02488215f, -0.01824906f, 0.05498874f, -0.02908311f, 0.02209792f, 0.01384305f, 0.02375721f, 
    -0.05417366f, -0.03892716f, 0.06999272f, -0.08405484f, 0.19653443f, -0.08814438f, -0.26789886f, 0.12858756f, 
    -0.02331772f, -0.01596915f, 0.02319461f, -0.08115377f, 0.02025437f, -0.04963703f, -0.12079933f, 0.17163882f, 
    -0.19126619f, 0.20611304f, 0.08435341f, 0.10360764f, -0.13089558f, 0.14469890f, 0.14042971f, -0.13217188f, 
    0.03943711f, -0.05597307f, 0.00734197f, -0.00183467f, 0.10036708f, -0.20210838f, -0.05993868f, 0.08683511f, 
    0.01270043f, 0.05716095f, 0.01435404f, 0.07345173f, 0.07176555f, 0.17013243f, -0.12999733f, 0.09911523f, 
    0.08901408f, -0.09341370f, -0.14735404f, -0.07117894f, 0.01677414f, 0.00234061f, 0.00790229f, -0.04322142f, 
    -0.10949259f, 0.07129066f, 0.28220552f, 0.11652237f, 0.06278929f, 0.09182148f, 0.11794482f, 0.15812182f, 
    -0.06991152f, -0.01409624f, 0.14305605f, -0.00533377f, 0.05037816f, -0.02457769f, -0.01113008f, 0.09462613f, 
    -0.32794613f, -0.11367766f, 0.05156181f, -0.04690417f, 0.01031385f, 0.01361892f, 0.06924981f, 0.02844543f, 
    0.00347218f, -0.07216069f, 0.00606806f, -0.03949538f, 0.09858654f, 0.02533917f, -0.06764376f, 0.14832084f, 
    0.11110254f, -0.02079977f, -0.01835458f, 0.00277662f, -0.06509009f, 0.08919472f, 0.09652217f, 0.10692769f, 
    -0.04402862f, -0.06762738f, -0.20832039f, 0.11921795f, 0.00475416f, -0.03877904f, 0.04094257f, -0.02264214f, 
    -0.00195124f, -0.09196530f, -0.04545473f, 0.15014732f, -0.02005849f, 0.34175715f, -0.28580803f, -0.01862323f, 
    0.02985115f, -0.01768658f, -0.09091371f, -0.03334836f, -0.06646293f, 0.14729764f, 0.05033680f, -0.17220707f, 
    -0.06219404f, -0.05765946f, -0.00964889f, -0.00083631f, -0.30634442f, 0.10354067f, 0.07532474f, 0.03305301f, 
    -0.00589877f, -0.01776092f, 0.04709572f, -0.03591330f, -0.10430359f, -0.07064235f, 0.01071792f, 0.06726592f, 
    -0.03433142f, -0.02000090f, 0.09381089f, 0.02573656f, -0.02668893f, -0.02357541f, 0.05356687f, -0.07571278f, 
    -0.09182370f, 0.12723075f, 0.00168361f, 0.07606977f, 0.21859601f, -0.03621484f, -0.02711729f, -0.06713490f, 
    -0.02931569f, -0.08500630f, -0.24430732f, -0.05049986f, 0.07188463f, -0.06288374f, -0.05987909f, -0.06518673f, 
    0.01557644f, 0.01102259f, -0.07994784f, -0.03506145f, 0.01240786f, -0.06003892f, -0.06193793f, 0.16192935f, 
    0.08407488f, -0.11634281f, 0.01879647f, 0.08069315f, -0.00193891f, -0.05552375f, -0.03254729f, -0.07697295f, 
    0.05061179f, 0.12921096f, 0.18393688f, -0.03546677f, -0.22001660f, 0.16796321f, 0.23118448f, -0.16205838f, 
    -0.13984022f, -0.10419130f, 0.10628922f, -0.06328702f, -0.02207962f, -0.10164865f, 0.21143536f, -0.02106079f, 
    0.18009406f, 0.35356298f, -0.32758328f, -0.05264910f, 0.10702952f, -0.27424791f, -0.11288822f, 0.12632163f, 
    0.01731692f, 0.04778373f, 0.06834831f, -0.07860302f, -0.56082517f, 0.06345738f, 0.00845176f, 0.02086746f, 
    0.07730945f, 0.03287204f, -0.18316816f, -0.14432825f, 0.08522148f, -0.12924677f, 0.01719216f, 0.00360189f, 
    -0.41273141f, 0.12006370f, 0.59537101f, 0.35298070f, -0.03215931f, -0.01595493f, -0.02390954f, 0.05195463f, 
    0.03551542f, -0.00537520f, -0.12609039f, -0.07112089f, -0.05911428f, 0.04291201f, 0.08278620f, -0.02013372f, 
    -0.07734992f, -0.05332730f, -0.01605818f, -0.06055875f, 0.16352355f, 0.06551577f, -0.02076546f, 0.18014881f, 
    -0.02067846f, -0.12002093f, -0.00324780f, 0.21293180f, -0.02939833f, 0.06790052f, -0.00641886f, -0.03259612f, 
    -0.04998691f, -0.04279689f, 0.16634464f, -0.01372906f, 0.05035055f, -0.01479488f, -0.06790604f, 0.04815220f, 
    0.01973044f, 0.08728936f, 0.02769500f, 0.07582030f, -0.04648600f, -0.13989557f, 0.06055837f, -0.07324754f, 
    -0.04030076f, -0.03028276f, 0.24308015f, 0.03710011f, -0.13617475f, -0.07696823f, 0.04516104f, -0.00827343f, 
    0.04383954f, 0.09488265f, 0.14862169f, 0.01291898f, -0.06767873f, -0.16031691f, 0.01032894f, 0.08471699f, 
    -0.01644422f, 0.03769817f, -0.05716997f, 0.05702206f, -0.00566705f, -0.00704459f, -0.12194070f, -0.05655501f, 
    0.06485488f, 0.02605317f, -0.19618481f, 0.12672679f, -0.07313709f, 0.01759063f, -0.01355896f, -0.07672363f, 
    0.08809831f, -0.07672017f, -0.04946436f, 0.00945801f, 0.68535060f, -0.14016202f, -0.02061772f, 0.15469238f, 
    0.05148456f, 0.05775721f, -0.01595899f, 0.05937343f, -0.14169984f, -0.12066414f, 0.10129754f, -0.02659269f, 
    0.21730259f, 0.02172897f, -0.06570111f, -0.01892748f, 0.08047213f, -0.01922746f, 0.00565969f, -0.09243348f, 
    -0.00561257f, 0.08387438f, -0.00600993f, 0.04576588f, -0.00123382f, 0.02855881f, -0.07298866f, 0.11257931f, 
    -0.11306322f, -0.08315796f, -0.04958964f, 0.02451083f, 0.03880802f, -0.06468955f, -0.21158217f, 0.00865620f, 
    -0.20487063f, -0.09657501f, 0.45694035f, -0.01611815f, -0.19858289f, 0.00517159f, -0.24116823f, 0.05254167f, 
    0.07225481f, -0.14622883f, 0.02475679f, -0.05019328f, 0.13088961f, 0.17752945f, -0.05997711f, 0.11554779f, 
    -0.04818348f, 0.10250499f, -0.13143177f, -0.02416798f, -0.12836286f, -0.16089876f, 0.10584432f, 0.02091138f, 
    0.07144845f, 0.22195594f, -0.11690817f, -0.39456853f, 0.10767987f, 0.08831145f, -0.03438007f, -0.10730547f, 
    -0.09026091f, -0.03693926f, 0.08102617f, -0.11766675f, -0.31749821f, 0.54505020f, -0.18149911f, -0.23353207f, 
    0.12607227f, -0.08395650f, 0.03351402f, -0.08919433f, -0.22417945f, 0.06550501f, -0.08547205f, 0.09591623f, 
    0.08515663f, -0.14070077f, 0.03996086f, 0.16659454f, 0.02906951f, 0.00722188f, 0.02497452f, 0.04665120f, 
    -0.10371926f, 0.04043837f, -0.20527492f, -0.00233656f, -0.44902933f, -0.03847275f, -0.07979400f, 0.01561670f, 
    -0.13724522f, 0.08674687f, -0.20888036f, -0.07803335f, -0.02487549f, 0.09914196f, -0.03131807f, -0.06940835f, 
    -0.00885712f, -0.11887161f, -0.17893581f, 0.12518129f, 0.08130230f, 0.06037238f, 0.01189225f, 0.08417490f, 
    0.04168005f, -0.10340820f, 0.17530473f, -0.10257347f, 0.24295332f, -0.11671190f, -0.04665036f, -0.06583305f, 
    0.07656753f, 0.05825202f, 0.01751045f, -0.04633757f, -0.06912582f, 0.07036354f, -0.09816267f, -0.01642424f, 
    0.15376928f, 0.57394922f, -0.25064895f, 0.19091603f, 0.24031597f, -0.05013005f, -0.06521019f, -0.03442440f, 
    -0.12479949f, -0.05968399f, 0.01762800f, -0.08599508f, 0.01322123f, 0.10826032f, 0.06590974f, 0.46168974f, 
    -0.08357192f, -0.16746792f, -0.08773578f, 0.09001698f, -0.03093308f, 0.16736299f, 0.10148278f, 0.09732073f, 
    -0.20549816f, -0.10192212f, -0.21888196f, 0.10552957f, 0.09986421f, -0.20159034f, -0.08324969f, -0.18214037f, 
    -0.03887473f, 0.00402083f, -0.13909587f, -0.02604304f, 0.08113690f, -0.13137309f, 0.03447551f, 0.15437490f, 
    0.04061843f, 0.02425241f, -0.00871347f, -0.10880709f, -0.08464751f, 0.02758272f, -0.05747814f, 0.14486581f, 
    -0.06512270f, -0.03135593f, -0.15365387f, 0.04011983f, -0.07249485f, -0.08442768f, -0.09541797f, -0.07781881f, 
    -0.15436767f, 0.01744857f, -0.06770039f, -0.13343059f, -0.51371455f, 0.67191947f, -0.33613256f, -0.44238499f, 
    0.10836528f, 0.18512265f, 0.08685400f, -0.05840198f, -0.28001535f, -0.07892279f, -0.00398344f, 0.02304745f, 
    -0.13211447f, 0.09162971f, -0.03203270f, 0.23445021f, 0.11782159f, 0.26725739f, 0.20101410f, 0.02589878f, 
    -0.07278645f, 0.03164688f, 0.01310516f, -0.01031044f, -0.08155257f, -0.09114578f, 0.07804208f, 0.05249444f, 
    0.13786432f, 0.01453012f, -0.06913385f, -0.16559705f, -0.21916361f, 0.11523811f, -0.12968116f, 0.02539253f, 
    0.11601231f, 0.03749196f, -0.08825235f, -0.01019889f, 0.05306832f, -0.11321985f, 0.00572706f, 0.11861788f, 
    0.03815002f, 0.01535785f, -0.14450781f, -0.00874817f, -0.10082456f, -0.11566249f, -0.06651643f, 0.15993412f, 
    0.10163971f, 0.04857124f, -0.06482103f, 0.04175056f, -0.01014399f, 0.07612436f, 0.03458960f, -0.06672865f, 
    -0.01491183f, -0.30985978f, 0.22640109f, 0.14575234f, -0.25726897f, 0.05238882f, 0.00991559f, 0.19834293f, 
    0.07592402f, 0.05605633f, -0.06313161f, -0.01343088f, -0.00831293f, 0.05982383f, -0.17260388f, -0.18392275f, 
    -0.08038923f, 0.04454191f, -0.11885264f, 0.14059439f, -0.11988169f, -0.03927669f, -0.02649444f, -0.06243782f, 
    -0.22158396f, 0.10148033f, -0.21619934f, 0.37653944f, -0.02164494f, -0.02837708f, 0.15971425f, -0.06371688f, 
    0.05044449f, 0.00659400f, -0.01924524f, -0.11792029f, -0.16380902f, 0.00457608f, -0.10311487f, 0.10050496f, 
    -0.04470094f, -0.02597599f, 0.00865373f, -0.02074195f, -0.13219926f, 0.00372711f, -0.07796124f, 0.10670979f, 
    0.14016573f, 0.02146721f, -0.29419801f, 0.02164496f, -0.00834303f, 0.01862112f, 0.01596090f, 0.01464849f, 
    -0.05684320f, -0.00697051f, 0.04829580f, -0.01267754f, -0.13634484f, -0.04500537f, 0.11132706f, -0.06949253f, 
    -0.18616238f, 0.07891718f, 0.06502395f, -0.03487668f, 0.16774788f, 0.12354040f, 0.05854722f, -0.03102854f, 
    -0.22656699f, 0.08948787f, 0.18078913f, 0.03896930f, 0.02886258f, 0.03209870f, -0.06517027f, 0.06005947f, 
    -0.02647351f, -0.16104686f, -0.15699896f, -0.09346407f, -0.19063742f, -0.29385430f, -0.12800165f, -0.21113183f, 
    -0.05772719f, -0.23101175f, -0.02099316f, -0.14047754f, -0.04766358f, -0.03746760f, -0.11040775f, -0.00747729f, 
    -0.15263185f, -0.02975514f, -0.22288841f, -0.20426498f, 0.18159297f, 0.07874450f, 0.15545489f, -0.09112637f, 
    -0.04697247f, 0.00767618f, 0.04062605f, -0.07634970f, 0.07465006f, 0.14664875f, 0.02667289f, -0.08155680f, 
    0.07364850f, 0.02704346f, -0.10543153f, 0.06384396f, 0.03635942f, 0.18153988f, -0.18113701f, -0.00619172f, 
    -0.77557641f, -0.02950927f, 0.08718260f, 0.33778235f, 0.02109074f, 0.21071722f, -0.03213827f, -0.08550461f, 
    -0.07178985f, -0.17565124f, 0.13161644f, 0.08438012f, 0.11513467f, -0.26008275f, 0.25118849f, 0.04758834f, 
    -0.17769727f, 0.02757749f, -0.15574525f, 0.08115704f, -0.09137356f, 0.02324070f, 0.14955300f, -0.00749833f, 
    0.28188065f, 0.02585384f, 0.24839425f, 0.17410073f, -0.16319713f, 0.01563514f, -0.19612713f, 0.08949136f, 
    0.05977750f, 0.17297678f, 0.05177100f, -0.01650414f, -0.08413609f, -0.16751082f, -0.05535000f, 0.20823517f, 
    0.03429992f, -0.09383664f, -0.04944561f, -0.06682488f, 0.05604536f, 0.05735300f, 0.01306067f, 0.05364450f, 
    -0.20969895f, 0.02635900f, -0.10845841f, -0.20386285f, -0.09086950f, -0.00088648f, -0.10548987f, -0.06498900f, 
    0.00835168f, 0.07845339f, -0.00629024f, -0.13648726f, 0.04003483f, -0.20182738f, 0.45210743f, 0.18069254f, 
    -0.10969189f, -0.01570323f, -0.20689604f, -0.04513455f, -0.07504135f, -0.11746111f, -0.02090356f, 0.00438888f, 
    -0.15105881f, 0.78758311f, -0.06396143f, -0.22978224f, 0.31129229f, 0.08419273f, 0.00124495f, -0.00882338f, 
    -0.25913283f, -0.03656603f, -0.00980422f, -0.18167865f, 0.59587634f, 0.12878016f, -0.09857235f, -0.45120844f, 
    -0.07263009f, -0.00806396f, -0.15363009f, -0.24129884f, -0.06988078f, -0.13729580f, -0.10145169f, 0.07610729f, 
    -0.19475710f, -0.02685208f, -0.42135376f, -0.23496298f, -0.07345499f, 0.04244617f, -0.10488209f, -0.16066603f, 
    0.12595564f, 0.09904467f, -0.00305297f, -0.08907293f, 0.72650015f, 0.12573275f, -0.01867128f, -0.16183767f, 
    -0.04877340f, 0.08452677f, 0.05371497f, 0.00673469f, -0.17273580f, -0.12600298f, 0.15436794f, 0.05083266f, 
    0.20740965f, -0.15938747f, -0.06955548f, 0.17384410f, -0.05947148f, -0.06445778f, -0.09975182f, -0.08445458f, 
    -0.00547919f, 0.04334205f, -0.07427282f, 0.10061961f, 0.42168677f, -0.06218740f, -0.21481338f, -0.41103223f, 
    0.01280682f, 0.03225207f, -0.01799067f, 0.02632609f, -0.06609544f, -0.01780729f, -0.11573870f, -0.07115883f, 
    0.15853865f, 0.34692806f, 0.31924701f, 0.05463822f, -0.11382604f, 0.04631094f, -0.01711901f, -0.07291941f, 
    0.08057473f, -0.00024711f, 0.27536318f, -0.12362271f, -0.03843422f, 0.03910534f, 0.00601770f, 0.02135991f, 
    0.09928640f, 0.01619008f, 0.05138563f, -0.03651335f, 0.01611131f, 0.01092081f, -0.01741651f, 0.08299643f, 
    0.14270383f, -0.01125525f, 0.16004704f, 0.18649569f, -0.14656204f, 0.01332714f, -0.04066852f, 0.00245364f, 
    0.02889138f, 0.04713700f, 0.11581559f, 0.05844176f, -0.09572633f, -0.02667269f, -0.22324169f, 0.11221831f, 
    -0.06280679f, 0.04605152f, -0.18319754f, -0.01689659f, 0.05488686f, 0.03029127f, -0.00269041f, -0.16362396f, 
    -0.18745559f, -0.08532889f, -0.10727788f, -0.14494987f, -0.21386567f, 0.04931275f, -0.03965132f, 0.00657381f, 
    0.03672794f, -0.03106589f, -0.17368361f, -0.05581928f, -0.19497210f, 0.43398416f, -0.06813906f, 0.12851867f, 
    0.08587194f, -0.04022996f, 0.02192654f, 0.00393276f, 0.06511054f, 0.01813680f, 0.15000795f, 0.01733221f, 
    -0.06046444f, 0.31434879f, 0.00867846f, 0.37255642f, 0.18746583f, 0.07122213f, -0.19906385f, -0.27904594f, 
    -0.01465493f, 0.02703972f, 0.01507871f, -0.15078260f, 0.27162603f, -0.05761701f, 0.23861660f, -0.31573632f, 
    -0.33251730f, 0.05915622f, -0.08424618f, 0.01222829f, 0.07555935f, 0.12510625f, 0.06244043f, -0.12939054f, 
    0.22845206f, -0.16574797f, 0.09101880f, 0.23747663f, -0.02651659f, -0.00057586f, -0.13250783f, 0.09003074f, 
    0.07541491f, 0.14827798f, -0.10646286f, 0.00266787f, 0.27886808f, 0.04889616f, 0.17144179f, -0.27344197f, 
    -0.12359745f, -0.05683719f, -0.08633361f, 0.05888700f, -0.10650428f, 0.05664962f, 0.20958631f, -0.04184154f, 
    0.01125282f, 0.16336054f, 0.02958563f, 0.07890703f, -0.07047249f, -0.00077603f, -0.06865168f, 0.08178686f, 
    -0.04192234f, -0.02482487f, 0.09178673f, 0.02180066f, -0.22116627f, -0.30021539f, 0.01668769f, 0.05973819f, 
    0.11614749f, 0.01900032f, -0.00061306f, -0.15760385f, -0.12134609f, -0.05496728f, 0.03024906f, 0.11433650f, 
    -0.35332689f, 0.12196892f, -0.03491567f, 0.02464097f, 0.00629366f, 0.11020985f, 0.05357221f, -0.18250090f, 
    -0.13473490f, -0.04577722f, -0.27874333f, 0.03972571f, -0.12149850f, -0.25326201f, 0.07517772f, 0.30743650f, 
    0.00037992f, 0.12856565f, -0.04353626f, 0.02225720f, -0.00172045f, -0.03024655f, 0.05922156f, 0.08038497f, 
    -0.10336701f, 0.04842689f, 0.03428504f, 0.04891793f, 0.13599092f, 0.03436258f, 0.09839962f, -0.04185044f, 
    0.00726545f, 0.10580927f, 0.04299696f, 0.05045620f, -0.20544355f, -0.20764755f, 0.06018198f, 0.20024599f, 
    0.08281273f, -0.02333712f, 0.08022611f, 0.07307709f, 0.04845934f, 0.04157939f, 0.03049609f, -0.02827049f, 
    0.02474119f, 0.19309993f, 0.10954281f, 0.19553611f, -0.07540501f, -0.09720409f, -0.10965165f, -0.00242458f, 
    -0.05297244f, 0.04347288f, -0.06223305f, 0.04752961f, 0.12913711f, 0.13263851f, 0.09548479f, 0.23813057f, 
    -0.12622036f, -0.11319469f, -0.03601547f, 0.08214512f, -0.02598891f, 0.01883847f, -0.04131822f, -0.01399647f, 
    0.04623839f, 0.18167694f, -0.11132426f, 0.05028278f, 0.10833643f, 0.01975807f, -0.34561837f, -0.21887302f, 
    -0.15121013f, -0.06246435f, 0.00977951f, -0.08109378f, -0.02154625f, 0.13061422f, 0.07314787f, 0.16139285f, 
    -0.01976091f, -0.05898264f, 0.07844371f, 0.11166947f, -0.01905428f, 0.00919801f, 0.00227101f, 0.11623701f, 
    -0.11236695f, 0.01279992f, 0.10860366f, 0.13633317f, -0.18102016f, -0.07825755f, -0.09370098f, -0.08456026f, 
    0.02028659f, -0.00879666f, 0.03992288f, -0.07288691f, -0.11726186f, -0.01743778f, -0.09575520f, -0.00542961f, 
    -0.02113030f, -0.16218473f, -0.05361854f, 0.21085422f, 0.04477996f, 0.07321453f, 0.05522085f, 0.06354383f, 
    -0.09727988f, 0.04644751f, -0.02305958f, -0.01364536f, -0.06792720f, 0.00204434f, 0.01297735f, 0.06081535f, 
    0.07773012f, -0.00413131f, -0.09354675f, -0.10701367f, -0.02932047f, 0.09020711f, 0.01858395f, 0.00335488f, 
    -0.08389280f, -0.12492803f, -0.11930621f, -0.06568761f, 0.01182583f, 0.01807458f, -0.00102675f, -0.08953699f, 
    0.05225086f, 0.04452977f, -0.05433139f, 0.12796767f, 0.23156534f, 0.09681644f, -0.08738512f, -0.00391323f, 
    0.01944013f, -0.01973529f, -0.15701817f, -0.05666348f, 0.10008141f, -0.02329641f, 0.05168057f, 0.01216130f, 
    -0.15445243f, -0.00509115f, -0.11957128f, 0.07348284f, 0.15879326f, 0.00694405f, -0.16760474f, -0.02884089f, 
    -0.06899573f, -0.25200230f, -0.01101983f, -0.06860825f, 0.05950871f, 0.03847187f, 0.06831730f, -0.00184671f, 
    -0.07552274f, -0.04576391f, -0.23661612f, 0.01762691f, 0.01507740f, -0.34472287f, 0.09636562f, -0.21709926f, 
    0.05874771f, 0.07479083f, 0.02046899f, 0.05730683f, -0.04017458f, -0.05918121f, -0.10329123f, -0.24471466f, 
    -0.00686180f, 0.03583635f, 0.12382737f, 0.21724983f, 0.16244495f, -0.07309838f, 0.09861287f, -0.07146670f, 
    -0.04969941f, -0.01569005f, 0.07222799f, 0.06827658f, -0.01226293f, -0.12211008f, -0.29450986f, 0.06039114f, 
    0.09988489f, -0.01522739f, -0.01764298f, 0.09927217f, 0.11520705f, -0.05311336f, -0.03374611f, -0.01147313f, 
    0.22768770f, 0.07664157f, 0.31235144f, 0.18278120f, 0.00984896f, -0.14120238f, -0.01266956f, 0.15047950f, 
    0.04718012f, 0.02044231f, -0.04932205f, 0.04603277f, 0.08041244f, -0.20891672f, 0.01365853f, -0.00743099f, 
    -0.03548910f, -0.02396085f, -0.03169419f, 0.06411869f, 0.09775265f, -0.00068026f, -0.08528803f, 0.04538712f, 
    -0.33833584f, -0.14840512f, -0.03739430f, -0.49713048f, -0.03678294f, 0.14748535f, -0.10413067f, 0.07286261f, 
    0.00173869f, -0.04394037f, -0.13139495f, -0.04561515f, -0.06541306f, -0.06923922f, -0.11404479f, -0.06910463f, 
    0.01544890f, 0.06053998f, -0.35881916f, -0.10202228f, -0.14739154f, -0.29534546f, -0.09601332f, -0.18828286f, 
    0.06567921f, 0.00177817f, -0.04163773f, 0.03163389f, 0.10047268f, 0.08481748f, 0.01363575f, -0.00994700f, 
    -0.11710594f, -0.03478815f, -0.07900310f, -0.02282405f, -0.07991221f, 0.07975700f, -0.03067209f, 0.16187081f, 
    -0.18930595f, -0.06186682f, 0.01850447f, -0.13891606f, 0.09053259f, -0.01239663f, 0.04436108f, 0.06867069f, 
    0.04585675f, -0.17136239f, -0.02709248f, 0.11973107f, -0.21373463f, 0.07863460f, -0.10977077f, -0.03762763f, 
    0.01436822f, 0.01061765f, -0.14985575f, -0.07218151f, 0.16640058f, -0.56404036f, 0.14765614f, -0.08702314f, 
    -0.01870908f, 0.01279820f, 0.11244252f, -0.05133664f, -0.10083524f, 0.09423386f, -0.00812793f, -0.01765972f, 
    -0.11749715f, -0.08484539f, 0.05873830f, -0.02065060f, -0.06829870f, 0.01549221f, 0.00032930f, 0.11350095f, 
    0.17093067f, 0.03843474f, 0.07270608f, 0.27914014f, 0.23140356f, 0.23280966f, 0.00155359f, 0.10664038f, 
    -0.19766070f, -0.07911441f, 0.06287935f, -0.11584353f, 0.08810700f, 0.06384265f, -0.01356741f, 0.06094800f, 
    0.09016480f, 0.13162149f, 0.12508270f, 0.22592872f, -0.05540350f, -0.00542083f, -0.12180094f, -0.19165714f, 
    -0.20917690f, -0.05260666f, 0.14039990f, -0.14453413f, 0.14524131f, -0.03164263f, 0.06647057f, 0.11467557f, 
    -0.15520529f, -0.14939308f, -0.01767350f, -0.10743265f, -0.08243631f, 0.04318183f, -0.00136051f, -0.07854862f, 
    0.27333811f, 0.46978140f, -0.07724736f, 0.22325936f, -0.09577370f, 0.00859202f, 0.07761677f, -0.03737014f, 
    0.10642568f, -0.06212540f, 0.03869911f, -0.02951410f, -0.02448608f, 0.02476133f, 0.09760804f, 0.07001035f, 
    -0.03042858f, -0.00823195f, -0.05913026f, -0.16905694f, 0.01192922f, 0.04210345f, 0.08071990f, 0.13857827f, 
    0.01544035f, 0.11582202f, 0.13562608f, 0.01889971f, -0.00816028f, -0.19409166f, -0.01461080f, 0.06200455f, 
    -0.05990143f, -0.01773387f, 0.01335991f, -0.04031499f, 0.01612954f, -0.12289531f, 0.09937339f, 0.05831935f, 
    -0.12821481f, -0.06521295f, 0.00179848f, -0.09541027f, 0.06694582f, -0.04878253f, -0.03406604f, -0.00573551f, 
    -0.24485342f, -0.08217123f, 0.26905513f, -0.15674911f, -0.13408306f, 0.10583516f, -0.22176190f, -0.06327944f, 
    -0.15169686f, 0.08694301f, -0.05349191f, 0.07099867f, 0.05736626f, -0.03016107f, -0.04990150f, 0.03351612f, 
    0.07759926f, 0.00142049f, 0.04251035f, 0.01184998f, -0.05175504f, -0.10996457f, 0.10376705f, 0.13572054f, 
    -0.14509396f, 0.09144049f, 0.08535387f, 0.19041923f, 0.11442208f, 0.00596569f, 0.04167162f, -0.07503594f, 
    0.13400686f, 0.05281551f, 0.10016932f, -0.09771404f, 0.04956461f, 0.05597942f, 0.04316987f, 0.07223275f, 
    0.11340110f, 0.04343946f, 0.06539076f, 0.03139921f, 0.03940141f, 0.02316461f, -0.04231407f, -0.01821755f, 
    0.06797491f, 0.00808252f, 0.02334443f, -0.03518553f, 0.05771309f, 0.00900919f, 0.01473779f, 0.00316685f, 
    -0.07739630f, -0.03691709f, -0.06309576f, -0.00312977f, 0.18719271f, 0.07634173f, -0.03638336f, 0.06102426f, 
    0.10976758f, -0.02430868f, 0.03471024f, -0.03131241f, -0.13512738f, -0.27983093f, -0.09460732f, -0.15271339f, 
    -0.12846023f, 0.15975174f, 0.01965692f, -0.01991865f, 0.02836926f, -0.05006932f, 0.04865399f, -0.01866045f, 
    -0.00732854f, -0.08801453f, -0.27998003f, 0.17443711f, 0.15030420f, 0.29526243f, -0.07754149f, 0.16565083f, 
    0.12245198f, -0.04286041f, 0.07313947f, 0.06067865f, 0.05997464f, -0.05010270f, 0.00027202f, -0.00175700f, 
    -0.08425726f, 0.13125853f, -0.04967048f, -0.08166040f, 0.05531237f, 0.13387762f, 0.15030847f, -0.13127637f, 
    0.14149150f, -0.23387159f, 0.07756393f, -0.05834853f, -0.07613029f, 0.08197912f, 0.09686887f, 0.05536801f, 
    0.01621241f, -0.01564830f, 0.02002477f, -0.05555427f, -0.00643574f, -0.01579895f, 0.05219261f, 0.15905359f, 
    -0.11948624f, 0.03926713f, -0.12914306f, -0.02971109f, 0.02554877f, -0.00283218f, 0.07927228f, -0.01002923f, 
    -0.14449310f, -0.01547689f, 0.01585759f, -0.06645020f, -0.13321921f, 0.24862072f, -0.16342132f, -0.05517996f, 
    0.13339025f, -0.02900707f, -0.09124562f, -0.00385339f, 0.04231548f, -0.02477051f, 0.08536235f, -0.12621735f, 
    -0.15321569f, -0.27736920f, 0.00241663f, -0.01007455f, -0.05845300f, 0.02643044f, 0.00204688f, 0.05327955f, 
    -0.01128710f, 0.00018851f, -0.07615416f, 0.07825473f, -0.14742149f, -0.35582802f, -0.41599226f, 0.26898271f, 
    -0.02368530f, -0.16965936f, 0.05374267f, -0.31738591f, -0.12636200f, -0.21682137f, 0.06787742f, 0.02040377f, 
    -0.06475734f, -0.11815672f, 0.01450769f, 0.01832763f, 0.01981178f, 0.03666542f, 0.04205200f, 0.00157884f, 
    0.04441911f, -0.03426793f, -0.06020741f, -0.02557750f, -0.05010225f, -0.13478078f, -0.02613135f, -0.11178707f, 
    0.07532395f, 0.00384606f, 0.03610872f, -0.02904740f, -0.00346140f, 0.09185831f, 0.10611586f, 0.00128961f, 
    -0.02166160f, -0.00576473f, 0.09865245f, 0.04519885f, -0.12271008f, -0.08931413f, -0.03131082f, -0.09627820f, 
    0.05097055f, 0.02406075f, 0.05470253f, -0.06521819f, -0.22095749f, -0.05645438f, -0.09623354f, -0.10864401f, 
    0.02587892f, 0.01031438f, 0.00871238f, 0.03110605f, -0.07502195f, -0.06990869f, 0.01970253f, 0.03318361f, 
    0.04232283f, -0.13717730f, -0.13058391f, 0.10887730f, 0.01965511f, -0.10236901f, 0.06144280f, -0.10719119f, 
    -0.01280806f, 0.24928781f, -0.03618081f, 0.32431784f, -0.06254337f, -0.06458246f, 0.07689548f, 0.02569323f, 
    -0.10128912f, -0.07140978f, -0.00402067f, 0.05824434f, -0.06615777f, 0.00583783f, 0.04124780f, 0.07351867f, 
    -0.03232758f, 0.04030254f, 0.18390606f, 0.38429493f, -0.05994200f, 0.05678622f, 0.10216065f, 0.10675996f, 
    0.00550002f, -0.01446989f, -0.02856575f, -0.08124294f, 0.09164346f, 0.00494095f, -0.02524683f, 0.05609767f, 
    -0.01682488f, -0.11273168f, -0.10513242f, -0.01352296f, -0.08030973f, -0.37177572f, 0.01653152f, -0.06707571f, 
    -0.26681805f, -0.29849669f, -0.00298946f, -0.26104689f, 0.05502075f, -0.01963374f, 0.06559993f, -0.02419771f, 
    -0.04423469f, -0.06455948f, 0.04784388f, -0.12210830f, -0.31205222f, -0.30237171f, 0.11875954f, 0.06716586f, 
    -0.09732847f, -0.01304613f, -0.06301072f, -0.03719962f, -0.16407852f, -0.14439413f, -0.09108520f, 0.05649909f, 
    0.11952973f, -0.08577720f, 0.22108893f, -0.14992914f, 0.02476730f, -0.06799535f, 0.02870123f, 0.17347758f, 
    0.02088868f, -0.03215662f, -0.04081215f, -0.04560358f, -0.01997546f, 0.02382826f, 0.05732191f, 0.14631724f, 
    0.17045608f, 0.08672439f, -0.20440133f, -0.02226315f, 0.02708965f, -0.07054551f, -0.12757526f, -0.08281136f, 
    0.17432478f, 0.06747720f, 0.08507529f, 0.14197581f, 0.05797756f, -0.01982456f, -0.16970134f, 0.02426662f, 
    0.16631350f, -0.16953567f, -0.16690582f, 0.05246178f, 0.19809802f, -0.03732583f, -0.11445329f, -0.03871132f, 
    0.00752482f, -0.05226896f, 0.01068559f, -0.05982069f, 0.32286027f, -0.07815201f, 0.05002268f, 0.09115868f, 
    0.11812716f, -0.07044802f, 0.18772013f, 0.02200560f, 0.01325243f, -0.03870419f, 0.01143573f, -0.04031161f, 
    0.10389021f, 0.20305584f, 0.13244388f, 0.30254644f, 0.03498903f, 0.06835603f, 0.15860792f, -0.08225729f, 
    -0.18040521f, -0.02380490f, -0.01342523f, -0.00514591f, -0.09250500f, -0.02760249f, -0.17648409f, -0.02941896f, 
    0.11247037f, -0.24250939f, -0.01280648f, -0.03674306f, -0.00780099f, -0.15530258f, -0.01024796f, -0.20966865f, 
    -0.07956158f, -0.07460061f, -0.09797173f, 0.17473572f, 0.22401303f, 0.17538624f, 0.08378899f, 0.05015104f, 
    0.18144663f, -0.04892072f, -0.01442469f, 0.23327580f, 0.01140909f, -0.01862647f, -0.05584655f, -0.16338859f, 
    -0.18392287f, -0.16451488f, -0.10908603f, 0.14402637f, -0.04569319f, 0.04702300f, 0.07152128f, -0.08555350f, 
    -0.00694878f, -0.03568269f, 0.05008867f, 0.04718016f, 0.11863655f, 0.12373447f, 0.05096232f, 0.12863687f, 
    -0.00325963f, 0.01990339f, -0.04781774f, -0.02500067f, 0.11658792f, 0.05717793f, 0.05267863f, -0.01232558f, 
    0.01868520f, -0.18703727f, 0.00594672f, -0.16490206f, -0.00759422f, 0.11042779f, -0.05458511f, 0.02887259f, 
    0.02505272f, -0.02907059f, -0.07147799f, 0.05824956f, 0.13131878f, 0.29134449f, 0.02662833f, 0.10561752f, 
    0.03113436f, -0.00425984f, -0.01771866f, -0.07223964f, 0.06877766f, -0.03164820f, -0.02123409f, 0.08025935f, 
    -0.07505388f, 0.02975201f, -0.28330395f, 0.18772885f, 0.09413658f, 0.06506301f, -0.05960584f, 0.12043114f, 
    -0.14951676f, -0.12635761f, -0.02433365f, -0.15018779f, 0.06666344f, 0.10533928f, 0.04408664f, 0.08475804f, 
    0.17321905f, 0.04839829f, 0.00584328f, -0.08850187f, 0.04459616f, 0.01132036f, 0.03855231f, 0.04620649f, 
    0.04985203f, 0.07622302f, 0.12995438f, -0.13036433f, 0.18345709f, 0.06922249f, -0.00083107f, 0.06394298f, 
    0.01968176f, 0.01989930f, 0.06017735f, 0.05971261f, 0.07887954f, -0.06291997f, -0.19746698f, -0.00377184f, 
    0.09064102f, -0.10553011f, 0.03399002f, -0.06405401f, -0.10470929f, -0.03850405f, 0.00036350f, 0.23326963f, 
    -0.03393115f, -0.26874483f, 0.16246654f, 0.11031069f, -0.03239651f, 0.02307148f, -0.03710774f, -0.01840516f, 
    0.07879422f, -0.02597602f, 0.02440450f, 0.04950494f, 0.04000729f, 0.11036535f, -0.10300885f, 0.08373789f, 
    -0.02976818f, 0.23270427f, -0.06479681f, 0.15256330f, -0.03076192f, 0.07651689f, 0.00872472f, 0.01804225f, 
    -0.08569767f, -0.09427442f, -0.09431039f, -0.07072105f, 0.00761647f, 0.01724888f, 0.10766357f, 0.00737420f, 
    0.17339933f, -0.02947254f, -0.03718574f, -0.01530297f, -0.09017686f, -0.14216879f, -0.09352194f, -0.05766605f, 
    0.14033391f, -0.07452088f, 0.05629997f, -0.22062479f, 0.13279460f, 0.06175140f, 0.00143709f, -0.02364911f, 
    -0.05169307f, -0.35180414f, 0.26238447f, 0.20519166f, -0.09912611f, -0.12345435f, -0.06809992f, 0.00601350f, 
    0.09165294f, 0.12910160f, 0.16984275f, 0.02251906f, -0.22610664f, -0.37403190f, 0.06066502f, -0.15795833f, 
    -0.00631612f, 0.00360823f, -0.01113490f, 0.01164979f, 0.16453549f, -0.11240581f, 0.26694497f, 0.06742705f, 
    0.14189850f, 0.24073137f, 0.27818292f, -0.04949866f, -0.04338187f, -0.00841000f, 0.16663443f, 0.01335744f, 
    0.06886050f, 0.01995840f, -0.01975623f, 0.03408553f, 0.42166308f, 0.02444852f, -0.38055956f, 0.21533868f, 
    -0.01651360f, 0.00995875f, 0.05309160f, -0.03641641f, 0.05106877f, 0.00350461f, -0.03216565f, -0.02471870f, 
    -0.02983864f, 0.17590892f, 0.00369825f, -0.18028021f, 0.29139790f, 0.08337776f, 0.11438898f, -0.16291688f, 
    0.04376598f, 0.00732383f, -0.05162973f, 0.04197218f, -0.35820758f, 0.31565934f, -0.07355173f, 0.02325509f, 
    0.07355363f, 0.01110533f, 0.02713012f, -0.05196087f, 0.11779246f, -0.09136113f, 0.02874487f, 0.07607047f, 
    -0.06442351f, -0.03488981f, -0.00531463f, -0.29101071f, -0.04297949f, -0.03699387f, 0.06303445f, -0.00546280f, 
    -0.03474109f, 0.07341146f, 0.11088964f, 0.03624557f, -0.15630299f, 0.07510208f, -0.34271443f, 0.07244714f, 
    0.13261026f, -0.07604774f, -0.02200379f, -0.06706131f, 0.20101956f, 0.22064406f, -0.06683904f, 0.22800918f, 
    -0.06650264f, 0.00212458f, -0.01116117f, -0.15234961f, 0.08398974f, -0.06812250f, 0.03972807f, -0.02320404f, 
    0.22864912f, 0.00556005f, -0.12791988f, 0.19857165f, -0.34416857f, -0.10362192f, -0.11924448f, -0.24721950f, 
    0.19780596f, -0.19294293f, 0.02862684f, 0.03768887f, 0.03506465f, -0.09594329f, -0.11691791f, -0.04464955f, 
    0.36019400f, -0.10771374f, 0.12063425f, 0.05411412f, 0.00142277f, 0.07328215f, 0.07502435f, 0.18223445f, 
    0.03595797f, 0.02254687f, 0.00843252f, 0.05076779f, -0.40899938f, -0.01194490f, -0.04133068f, 0.07201884f, 
    0.00127223f, -0.05822342f, -0.02404814f, 0.03878862f, 0.08631556f, -0.21471441f, -0.14745712f, -0.01739055f, 
    -0.03651080f, -0.12783143f, -0.11707208f, -0.14626549f, 0.00894760f, -0.02626147f, 0.02379693f, 0.04456891f, 
    0.02795400f, -0.18783823f, -0.01842165f, -0.27163494f, -0.33952188f, -0.52936107f, -0.26540065f, -0.02669160f, 
    0.07392910f, 0.07016163f, -0.10603952f, 0.06582493f, 0.08304493f, 0.00615634f, -0.04264319f, -0.07436848f, 
    0.17292497f, 0.00587660f, 0.24842361f, -0.00219199f, -0.10866936f, 0.11020106f, 0.07827881f, -0.03436836f, 
    0.07565276f, -0.02815247f, -0.02092727f, 0.03165570f, -0.01972695f, 0.33934861f, -0.26467952f, -0.13196942f, 
    0.03653323f, 0.13352582f, -0.12813431f, -0.10574209f, 0.01839791f, -0.01515100f, -0.13829309f, 0.06274699f, 
    0.00407431f, -0.19237743f, -0.08931911f, 0.13023788f, 0.09575927f, 0.05812077f, -0.00792602f, 0.23950695f, 
    -0.00839337f, 0.06056457f, 0.09290939f, -0.03375425f, 0.05393380f, -0.06856672f, 0.39715955f, -0.02107187f, 
    0.14288211f, -0.10081194f, 0.03550085f, -0.06622119f, 0.22758001f, 0.15626916f, 0.07276724f, -0.07890052f, 
    0.06020093f, 0.14333341f, -0.24479721f, -0.26481491f, 0.10435466f, 0.24210003f, -0.05379505f, 0.00014529f, 
    0.02298640f, -0.05702206f, 0.02119640f, -0.09895369f, 0.03955081f, -0.09736668f, 0.30913866f, -0.14625084f, 
    0.20866121f, 0.07042164f, -0.02916490f, 0.10177311f, -0.03991108f, 0.06571212f, 0.18014261f, 0.00602575f, 
    -0.01060820f, 0.02651188f, 0.25635529f, -0.01247001f, 0.02535187f, -0.08118665f, 0.04632301f, 0.10485711f, 
    -0.07614287f, -0.08832654f, -0.11946432f, -0.12443283f, -0.10513174f, -0.03676239f, -0.00475220f, -0.05395949f, 
    -0.02943532f, -0.00474353f, -0.02185627f, 0.03789301f, 0.03513039f, -0.19769415f, -0.12224521f, -0.35046917f, 
    0.00295485f, 0.01870027f, -0.23022084f, -0.03595454f, -0.16787843f, -0.02722962f, 0.14959802f, 0.00159207f, 
    -0.28306708f, 0.03065814f, 0.00573853f, -0.17646898f, -0.06960552f, -0.14530851f, -0.06831582f, -0.00866948f, 
    0.00760843f, -0.04451709f, -0.08927105f, -0.02769868f, -0.04080487f, 0.04506929f, -0.01108997f, 0.01967405f, 
    -0.10040663f, -0.07551920f, -0.13356671f, -0.05785733f, 0.05371808f, -0.02919106f, -0.02614076f, 0.06121032f, 
    0.12837777f, -0.02717441f, -0.10411065f, 0.09050915f, -0.11608187f, -0.33872664f, 0.16445521f, 0.19440740f, 
    -0.08879189f, -0.10837888f, -0.04273161f, -0.02510859f, 0.13812339f, -0.03720700f, 0.10589606f, -0.06610288f, 
    0.00478951f, -0.32267892f, -0.10550233f, -0.19553366f, 0.01112689f, 0.02825959f, 0.08520436f, 0.06138166f, 
    0.04490884f, 0.25070721f, 0.23962598f, -0.19710286f, 0.23605779f, 0.09526176f, -0.34892127f, 0.31653869f, 
    0.09447851f, 0.04175388f, 0.05335207f, 0.07248931f, 0.01646625f, 0.00143858f, 0.02494382f, -0.00010291f, 
    0.14020894f, -0.00331032f, -0.34921864f, -0.02434850f, -0.04321626f, 0.01935114f, 0.08814924f, 0.00823685f, 
    0.01044914f, -0.01171118f, -0.01075543f, -0.08166607f, -0.04180446f, 0.06987686f, -0.19409673f, -0.23644736f, 
    -0.00619829f, -0.06193271f, -0.03699843f, 0.17255163f, -0.04332054f, -0.12711564f, -0.06919660f, -0.11754670f, 
    0.13512741f, -0.06679790f, -0.00899029f, -0.01389130f, -0.02354044f, 0.02398434f, -0.02811720f, -0.03074749f, 
    0.16397634f, -0.09783955f, 0.11211138f, 0.24468158f, 0.13078590f, 0.10559414f, -0.16105115f, -0.20597655f, 
    0.09017280f, 0.10321192f, -0.07119156f, 0.18363595f, 0.17449072f, -0.11184645f, 0.01277154f, 0.12639846f, 
    -0.33714384f, 0.20174479f, -0.13520651f, -0.11136561f, -0.02008394f, -0.06659123f, -0.03880404f, 0.11745980f, 
    -0.17223349f, 0.14574501f, -0.24651670f, -0.02595288f, -0.49704707f, 0.24951184f, 0.22341119f, 0.24487753f, 
    -0.11857728f, -0.06263932f, 0.01648485f, 0.15252009f, -0.13336976f, 0.01720690f, -0.08484717f, 0.06369317f, 
    0.07162064f, -0.13559723f, 0.08888521f, 0.03946327f, 0.03062944f, -0.03654062f, -0.00693493f, 0.00111874f, 
    -0.07363290f, 0.03045656f, -0.01184653f, 0.07856268f, -0.20203267f, -0.04109899f, -0.02060315f, 0.04336406f, 
    0.01069504f, 0.05381118f, 0.00918286f, -0.13251905f, 0.16696849f, -0.19077297f, -0.25112230f, -0.05948054f, 
    -0.09430990f, -0.04926986f, -0.05723526f, -0.03567936f, 0.33667749f, 0.05869523f, 0.06247400f, 0.05122998f, 
    0.04277151f, 0.00037796f, 0.04635265f, 0.05199916f, -0.15705287f, -0.00655306f, -0.04480049f, 0.13550492f, 
    -0.05283118f, -0.11215515f, -0.02486987f, 0.05984486f, -0.05180672f, 0.01791151f, 0.15500796f, 0.00872386f, 
    -0.14267318f, -0.00958956f, -0.12404466f, 0.10399988f, -0.04452441f, 0.05997514f, -0.00834657f, -0.01031371f, 
    0.04458702f, -0.38005063f, -0.30183807f, -0.27512774f, -0.10587928f, 0.12536375f, -0.09956899f, -0.10919534f, 
    0.04177769f, 0.01087495f, -0.08809900f, -0.02094577f, -0.01941531f, -0.12645259f, -0.03267255f, 0.03078472f, 
    -0.01311343f, -0.07881279f, 0.04103154f, -0.20030622f, 0.10444249f, -0.07941999f, -0.04687677f, -0.01979855f, 
    0.03352055f, 0.01465701f, -0.03887282f, 0.02830594f, -0.12033907f, 0.00905938f, -0.27130219f, -0.31165308f, 
    -0.00281215f, -0.05127247f, 0.26856315f, 0.25621742f, 0.10077911f, 0.08429535f, -0.02612497f, 0.10343065f, 
    0.22197995f, -0.49416155f, -0.03644914f, 0.21294582f, 0.05636613f, -0.04841330f, 0.07376090f, 0.03759731f, 
    -0.03423244f, 0.13307202f, 0.21149339f, -0.01972704f, 0.34573016f, -0.16586743f, -0.03223425f, 0.31961274f, 
    -0.00722688f, -0.02565588f, -0.08608399f, 0.00429011f, -0.07460664f, 0.08474836f, -0.13567518f, -0.04945411f, 
    -0.02522434f, -0.03506107f, -0.05876888f, 0.06554070f, 0.27835274f, 0.08886112f, -0.06707651f, -0.03894532f, 
    0.07435136f, 0.04083736f, -0.01125049f, 0.07276743f, -0.06840214f, -0.00265457f, -0.07229100f, 0.00933716f, 
    0.06376345f, 0.19099519f, -0.02258999f, 0.01470515f, -0.08073574f, -0.03773620f, 0.12417778f, 0.13050526f, 
    -0.01355409f, 0.07629867f, -0.10101131f, -0.19522157f, -0.13218412f, 0.04396957f, 0.12266477f, -0.25313747f, 
    0.03512246f, -0.02541120f, 0.24410160f, -0.00987235f, -0.16384004f, 0.01218048f, -0.17199638f, 0.17841506f, 
    0.03085380f, 0.01548743f, -0.01710899f, 0.03948244f, 0.03196961f, -0.01179331f, -0.20039730f, -0.10106465f, 
    -0.17372277f, 0.06268772f, 0.08994765f, -0.21765533f, 0.00427982f, 0.00769123f, 0.08131852f, 0.00896438f, 
    0.14416099f, -0.30831999f, -0.26643687f, -0.66206604f, -0.00210604f, 0.07395482f, -0.43526763f, -0.02693960f, 
    -0.05152047f, 0.20328648f, -0.27426785f, 0.02910423f, 0.02602211f, 0.17842093f, 0.02997050f, -0.14036784f, 
    0.28100428f, -0.26679230f, 0.21573861f, 0.04054419f, -0.12072408f, 0.00673039f, -0.12110917f, -0.02239252f, 
    0.13100941f, 0.09133254f, -0.11412624f, -0.08387170f, 0.11211828f, 0.07340444f, -0.16077022f, -0.11658810f, 
    0.21628806f, 0.12368625f, 0.15076666f, -0.07512962f, 0.00737340f, -0.06753603f, -0.05085790f, -0.01496620f, 
    -0.21306799f, -0.08461103f, 0.11404449f, -0.25298136f, -0.09611613f, -0.02072047f, -0.05776904f, -0.02714749f, 
    -0.00281301f, -0.08167887f, -0.10456108f, 0.02431527f, 0.04870268f, 0.02427311f, -0.00752243f, -0.00182124f, 
    0.07797488f, 0.09333860f, 0.00360293f, -0.13894527f, -0.29105330f, -0.05776315f, 0.00837117f, -0.14343728f, 
    -0.09050791f, -0.52402395f, -0.23718283f, -0.01262824f, -0.06308609f, -0.24358191f, -0.09637646f, 0.09000356f, 
    -0.07228356f, -0.02212578f, 0.02826102f, -0.02391043f, -0.72567314f, -0.60656404f, -0.22510140f, -0.27764577f, 
    -0.20180975f, -0.12009204f, -0.05169151f, -0.21192898f, -0.06275908f, 0.00668489f, 0.02596962f, 0.01932712f, 
    0.25781831f, 0.02539902f, -0.08821834f, -0.25336927f, -0.02869157f, -0.00340521f, 0.15574777f, 0.02097938f, 
    0.01496710f, 0.15807967f, 0.07650800f, 0.09094372f, -0.23846360f, -0.48575580f, -0.49053034f, -0.12084171f, 
    -0.20806807f, -0.05509212f, -0.19892359f, -0.23115139f, -0.01010677f, -0.00729800f, 0.02564410f, 0.00957711f, 
    -0.24097377f, -0.17577137f, -0.16252029f, 0.00546457f, -0.01552742f, -0.05377995f, -0.08549529f, 0.10491928f, 
    0.07205406f, 0.03219013f, -0.03725771f, -0.01739383f, 0.10145181f, 0.10171387f, -0.03849863f, 0.26419577f, 
    0.00156604f, -0.08801156f, 0.17688137f, 0.18801701f, 0.04451381f, -0.03312992f, 0.08499442f, -0.13504972f, 
    -0.16260119f, -0.13789147f, -0.19102389f, 0.19950196f, -0.14047447f, -0.22886144f, -0.10618539f, 0.22410357f, 
    -0.02293343f, -0.02021593f, -0.03470369f, -0.03300957f, -0.11071086f, -0.09865835f, -0.08502211f, -0.24277532f, 
    -0.13210922f, -0.06829086f, -0.09820161f, -0.15301219f, -0.00646861f, -0.05554864f, -0.01115175f, -0.00739180f, 
    0.09978634f, -0.17514794f, -0.01821474f, 0.16393301f, 0.04806297f, -0.01837601f, 0.09524887f, -0.00202477f, 
    -0.05141103f, -0.09578942f, 0.06497533f, -0.09424740f, -0.18276124f, -0.01592740f, 0.06600238f, -0.06407811f, 
    -0.08843640f, -0.04395312f, -0.15317127f, 0.08908742f, 0.01345587f, -0.02049699f, 0.06935754f, -0.05133193f, 
    -0.02671308f, -0.01539028f, -0.05212379f, -0.16662687f, -0.12671332f, -0.05695794f, -0.00617087f, 0.08959301f, 
    -0.12122198f, 0.04017029f, 0.04626966f, 0.15889454f, -0.10002600f, 0.04467444f, -0.00241516f, -0.07956411f, 
    0.00187101f, 0.03014379f, -0.04023580f, -0.02719032f, 0.02221184f, 0.02668031f, 0.03069447f, 0.06648780f, 
    -0.59015065f, -0.72255689f, -0.59814143f, -0.33672407f, 0.07784336f, -0.08532128f, -0.13477726f, -0.36216861f, 
    -0.00864694f, 0.00679259f, 0.02960401f, -0.06677382f, 0.17730050f, -0.06752059f, -0.09740600f, -0.31631818f, 
    0.05349715f, -0.01216286f, 0.13300379f, -0.06058590f, 0.08007638f, 0.12647642f, -0.03942308f, -0.03585561f, 
    -0.88759530f, -0.17463073f, 0.09359057f, 0.26506388f, -0.14630090f, -0.29334348f, -0.20175780f, -0.25764251f, 
    -0.02529852f, -0.02196595f, 0.06403042f, -0.07068369f, -0.09968820f, 0.06084646f, 0.18970351f, -0.01431791f, 
    -0.03703808f, 0.05059805f, 0.08879406f, -0.08176237f, 0.12827981f, 0.03268465f, 0.10875212f, -0.07714923f, 
    -0.20681714f, -0.07910464f, 0.00738471f, -0.06259236f, 0.11296242f, -0.03567713f, 0.03638200f, -0.03920655f, 
    0.00576935f, 0.06522651f, 0.05534775f, -0.07491784f, 0.50422478f, 0.17405066f, 0.14253463f, 0.14616935f, 
    0.03213485f, -0.03047770f, 0.05310447f, 0.05917119f, 0.01725900f, -0.00236311f, 0.06874415f, 0.02658634f, 
    0.07753896f, -0.11611374f, -0.00285733f, 0.09336209f, 0.09000263f, -0.05467921f, 0.10148671f, 0.00639086f, 
    -0.07803314f, 0.00142234f, 0.05653391f, -0.18313092f, -0.50006324f, -0.15315251f, -0.19359614f, -0.21028733f, 
    0.06194468f, -0.03434146f, 0.16588643f, 0.02655476f, 0.00622896f, 0.00620456f, -0.00716500f, 0.12591760f, 
    0.29412228f, -0.33548450f, -0.54362005f, -0.01926984f, -0.13123600f, -0.00523855f, 0.26493916f, 0.12522240f, 
    0.04132611f, 0.08061540f, -0.19498992f, -0.03998524f, 0.10637484f, -0.11557817f, 0.15040156f, 0.01337324f, 
    0.01729938f, 0.04516071f, -0.03369006f, 0.08741874f, -0.02138790f, 0.18106584f, 0.01692025f, 0.02282757f, 
    0.03893273f, 0.29989251f, 0.08081286f, -0.00873017f, -0.00170414f, 0.02322184f, 0.02863425f, 0.04212941f, 
    0.11305065f, 0.12053824f, 0.09671449f, 0.07297727f, -0.57942688f, -0.00433820f, 0.41077089f, 0.26575130f, 
    -0.01704704f, -0.05660193f, -0.10628416f, 0.03245678f, -0.02366129f, -0.04606371f, 0.05912148f, 0.01175224f, 
    -0.43419862f, -0.19101986f, -0.22878544f, -0.39784098f, -0.09068478f, -0.08435955f, -0.11311741f, 0.11677311f, 
    0.01002819f, 0.11693250f, -0.13375659f, -0.10291474f, -0.51062006f, 0.07461141f, 0.55849141f, -0.41222674f, 
    -0.08701141f, -0.29747310f, 0.01745772f, -0.24542062f, -0.14793794f, 0.16930805f, -0.09864273f, 0.10322338f, 
    -0.11561321f, -0.38121885f, -0.15997325f, -0.19007379f, -0.09294655f, 0.14555892f, 0.24238963f, -0.15942097f, 
    -0.01324226f, 0.00076918f, 0.07256342f, 0.00236310f, 0.17914417f, -0.14827380f, 0.34560356f, -0.11543579f, 
    -0.05067905f, 0.08797896f, -0.04009292f, 0.11068896f, 0.04464106f, 0.09538759f, 0.06837019f, 0.05490850f, 
    -0.21772249f, -0.16116731f, -0.05157064f, -0.14254728f, -0.15775394f, 0.00428231f, 0.05926403f, -0.01918104f, 
    0.01648721f, 0.07039451f, 0.02504524f, -0.05145079f, -0.09219430f, -0.09990973f, 0.03868140f, 0.12721397f, 
    -0.14269599f, 0.09495236f, -0.00273416f, -0.07688867f, 0.04106786f, 0.06560137f, -0.04899379f, -0.03651659f, 
    0.08771529f, -0.26956445f, -0.14841139f, 0.18378185f, 0.04262232f, 0.03403674f, 0.13275337f, 0.16121104f, 
    0.07811287f, 0.09210973f, 0.10495171f, 0.16845444f, 0.03611115f, -0.05162242f, -0.06811990f, -0.00920815f, 
    -0.00214300f, 0.06753895f, 0.08570256f, 0.10604964f, -0.02147440f, 0.15847793f, 0.01258274f, -0.01130322f, 
    0.39389879f, -0.01555188f, -0.28550699f, -0.07454513f, -0.07512137f, -0.12440477f, 0.03068846f, 0.15652891f, 
    0.03643965f, -0.15809305f, -0.02106809f, -0.03566782f, -0.05544301f, -0.07267404f, -0.04613351f, -0.00135275f, 
    -0.01777508f, 0.00062901f, -0.02796101f, 0.00909059f, -0.10159390f, -0.09103617f, -0.18311958f, 0.02555055f, 
    -0.06951395f, 0.04920132f, 0.06414278f, -0.03389007f, 0.01871880f, 0.00529137f, -0.01451996f, 0.06721830f, 
    -0.06633382f, -0.00272155f, -0.05639720f, -0.05504378f, -0.04969968f, -0.10833292f, 0.15143231f, 0.11449374f, 
    -0.05851671f, -0.08307566f, -0.08043909f, 0.07454580f, -0.01033956f, -0.01481393f, 0.13065958f, -0.05531611f, 
    0.35877082f, 0.47560582f, 0.05685885f, 0.12778269f, 0.04960268f, 0.03344257f, 0.00524365f, -0.05458788f, 
    0.08898111f, -0.12852979f, 0.08583535f, 0.17649724f, -0.77011138f, -0.30754569f, 0.22878020f, -0.52198225f, 
    -0.02148476f, 0.06080358f, 0.05900877f, -0.07514732f, -0.05463865f, 0.04430997f, -0.00863880f, 0.04213572f, 
    0.10215683f, 0.10141379f, 0.01779665f, -0.06039360f, 0.03816464f, -0.02365041f, 0.10768056f, -0.01283491f, 
    0.08869376f, 0.12520649f, 0.06297778f, 0.11468106f, -0.44713685f, 0.07519750f, 0.01486483f, -0.18830481f, 
    -0.09867530f, -0.04962534f, 0.14867494f, 0.10717466f, -0.01140634f, 0.01191347f, 0.10065423f, 0.10815002f, 
    -0.10815465f, -0.15425949f, 0.09139752f, 0.10973329f, 0.00420718f, -0.02095544f, -0.06907864f, 0.04500248f, 
    0.05915577f, -0.05907658f, -0.09098177f, 0.00591500f, 0.34066036f, -0.03924881f, 0.11709277f, -0.28534386f, 
    0.05797394f, -0.02613888f, 0.13557793f, 0.12787554f, 0.04134146f, -0.04171896f, 0.06747329f, 0.01962437f, 
    -0.20177281f, 0.21966697f, 0.21073422f, 0.07959241f, 0.02483878f, -0.05499138f, 0.02602271f, 0.03699722f, 
    0.15947555f, -0.02164175f, 0.12724949f, 0.07746903f, -0.06474313f, -0.03159279f, 0.05751721f, 0.14731278f, 
    -0.06642596f, 0.02444914f, 0.09657097f, 0.05281319f, 0.20795165f, -0.03115098f, 0.11608799f, -0.01993485f, 
    0.07026785f, 0.09324252f, -0.14290813f, -0.05419797f, 0.02286261f, 0.01199792f, 0.02252919f, 0.03136688f, 
    -0.03780413f, -0.02999358f, -0.15419748f, 0.02450947f, 0.11695711f, -0.03860224f, 0.11882856f, -0.49370912f, 
    -0.12837678f, 0.00284703f, 0.00519700f, 0.08523343f, -0.00878853f, 0.18979765f, 0.22613956f, 0.10638718f, 
    -0.47618812f, -0.38468990f, -0.23650599f, -0.22545899f, 0.03923704f, -0.21805879f, -0.18631132f, -0.08531402f, 
    -0.01248535f, -0.03265184f, -0.03671221f, -0.00639432f, 0.06456369f, -0.01100107f, -0.16554062f, 0.00269498f, 
    0.01713779f, 0.03555423f, 0.03890338f, -0.00185838f, 0.05288195f, 0.04603485f, 0.11968269f, 0.06527032f, 
    -0.02993639f, -0.02374956f, 0.04397414f, -0.19473766f, -0.00253239f, 0.08911667f, -0.01655313f, 0.06439490f, 
    0.08044127f, 0.20734861f, 0.10290126f, 0.08643990f, -0.28008416f, 0.14476560f, 0.23737940f, 0.00499483f, 
    -0.15678443f, -0.01419951f, 0.13590518f, -0.01899864f, -0.04991593f, 0.07155401f, 0.08361752f, -0.15702316f, 
    -0.18022151f, -0.36110798f, -0.27418190f, -0.10627833f, 0.04679356f, 0.10449193f, 0.05331154f, -0.00233541f, 
    -0.03555116f, -0.00879394f, -0.05483301f, -0.04131697f, 0.08194312f, 0.08616666f, 0.32355803f, 0.08332318f, 
    0.07686495f, -0.10519640f, -0.07002149f, 0.12531312f, 0.05681829f, 0.00548348f, -0.08854053f, 0.02424013f, 
    -0.02103805f, 0.05561258f, -0.09666185f, -0.26305386f, -0.03421555f, -0.00594551f, -0.00916102f, 0.06594446f, 
    -0.05875433f, 0.00099395f, -0.07287851f, -0.07811039f, -0.37882704f, -0.11301998f, -0.15171748f, 0.16482557f, 
    0.04832915f, 0.12616518f, 0.06327160f, -0.11978543f, 0.02107607f, -0.02970171f, -0.01433963f, 0.18911272f, 
    -0.24978451f, -0.17442630f, -0.19032630f, -0.04395786f, -0.09061631f, -0.06653062f, 0.00843868f, 0.01355227f, 
    0.00484157f, 0.00186320f, -0.06493165f, 0.00881819f, 0.05438885f, -0.10730724f, -0.15807918f, -0.12120686f, 
    -0.07294043f, 0.07806431f, 0.01738779f, -0.06384881f, -0.01705148f, -0.00685589f, -0.12793550f, -0.03854002f, 
    -0.10065547f, 0.33575639f, 0.14228189f, -0.11856209f, -0.13004050f, -0.00885095f, -0.28169143f, 0.14547248f, 
    0.07745152f, -0.09742914f, 0.02135716f, 0.04073434f, 0.18769696f, -0.04941191f, -0.12138411f, -0.09021521f, 
    -0.02659259f, -0.03293311f, 0.17559360f, 0.09483045f, -0.03660708f, 0.20325480f, 0.12416739f, -0.15794776f, 
    -0.08205094f, -0.09687935f, -0.00389129f, -0.13180155f, -0.01135529f, 0.00671403f, 0.05693978f, 0.01934204f, 
    0.12504506f, 0.16429731f, 0.00081601f, 0.21366860f, -0.24114943f, 0.15702413f, 0.48825768f, -0.01680738f, 
    -0.00110351f, -0.07670324f, -0.02454376f, -0.00427789f, 0.01952316f, 0.12602955f, -0.09101725f, -0.03284697f, 
    -0.26013190f, -0.33708018f, -0.21027212f, 0.28308040f, 0.02206366f, 0.28848660f, 0.01986293f, 0.09437834f, 
    0.20556283f, -0.03955737f, 0.00458344f, 0.02557724f, 0.08497112f, -0.06336799f, 0.00907264f, -0.17513604f, 
    0.04446145f, -0.17016853f, 0.19940495f, -0.10923650f, -0.05862523f, -0.09446716f, -0.05035544f, -0.03055782f, 
    -0.17784563f, -0.42206040f, -0.06972717f, 0.24838966f, 0.00938519f, -0.03501227f, -0.02882359f, -0.00996881f, 
    -0.08344234f, 0.05102161f, 0.04991481f, 0.02207817f, 0.14560568f, 0.26277354f, 0.06326074f, -0.09742180f, 
    -0.05631674f, -0.00987450f, 0.01226234f, -0.05401077f, 0.10414372f, -0.05031910f, 0.01521593f, -0.02064437f, 
    -0.61111665f, -0.30918252f, -0.32548961f, -0.00476665f, -0.16658562f, 0.06255003f, -0.03984443f, 0.00204893f, 
    -0.05543318f, 0.07118368f, 0.01016845f, -0.00321045f, -0.14246380f, -0.09461492f, -0.19503286f, 0.12785129f, 
    0.05599746f, -0.04935703f, 0.06548605f, -0.03593224f, -0.03133659f, 0.02681847f, -0.02379507f, -0.03572908f, 
    -0.11715834f, 0.12635931f, -0.15762015f, 0.14341177f, -0.00729557f, 0.05505589f, 0.11389831f, 0.06008881f, 
    0.03730958f, -0.00498644f, 0.00387263f, -0.03048609f, -0.23291825f, -0.13759685f, -0.27378678f, 0.33890676f, 
    0.07827599f, -0.02571491f, 0.04621111f, 0.10931955f, 0.01295053f, -0.08956546f, -0.10680670f, 0.01407230f, 
    -0.03300788f, -0.10778041f, -0.20227873f, 0.03109108f, 0.06703047f, 0.01760918f, -0.05497048f, -0.04809695f, 
    -0.01763404f, -0.04583709f, -0.04688992f, 0.04864392f, -0.01958392f, -0.02403571f, 0.07078702f, 0.03073809f, 
    -0.07171703f, 0.19218373f, 0.13328360f, 0.02467193f, 0.05435107f, 0.02684410f, -0.02226459f, 0.07025205f, 
    0.46065918f, -0.35095873f, -0.12778428f, -0.07394882f, -0.14858665f, -0.05680905f, -0.04514961f, 0.00662805f, 
    0.02843646f, -0.01852258f, 0.01430835f, -0.05679783f, -0.12498420f, 0.22657438f, -0.24238104f, 0.14148951f, 
    0.03023980f, -0.09493365f, 0.02522717f, -0.03293514f, -0.02427138f, 0.03878084f, 0.00677269f, -0.02031875f, 
    -0.03119170f, 0.09045070f, 0.04102518f, -0.07941383f, -0.10293426f, -0.01574965f, 0.01503066f, 0.04602354f, 
    0.04916991f, 0.00201862f, 0.04828163f, 0.03232573f, 0.23873918f, 0.01152426f, -0.01708821f, -0.09295087f, 
    -0.08055742f, -0.16702478f, 0.03968098f, 0.07016562f, 0.00942506f, 0.08066466f, 0.01155848f, -0.01481515f, 
    0.48336282f, 0.11749573f, -0.16913107f, -0.32026839f, 0.04833440f, -0.02702460f, -0.02452738f, 0.01537632f, 
    -0.03718163f, 0.11404205f, -0.09114230f, -0.11584523f, 0.00070426f, -0.05301771f, -0.00391195f, -0.07469608f, 
    0.00802445f, 0.00717665f, -0.03394446f, -0.02012366f, 0.00697236f, -0.07842628f, -0.14994168f, -0.18455878f, 
    -0.43802622f, -0.28975824f, 0.28583896f, 0.55938268f, -0.05858389f, 0.06482061f, -0.08134410f, 0.02890366f, 
    -0.02424550f, -0.09263025f, -0.10230005f, -0.03770510f, -0.02647429f, -0.03789433f, 0.07172123f, -0.03706831f, 
    0.00224908f, 0.03121040f, -0.04051150f, -0.01431612f, 0.02047276f, -0.04631750f, 0.07580840f, 0.01552391f, 
    -0.54780567f, 0.00161291f, 0.26104310f, -0.01949364f, 0.00304707f, -0.06216271f, 0.10638487f, 0.02658184f, 
    -0.05406659f, 0.04299868f, 0.00251799f, -0.01299561f, 0.28026953f, 0.09893485f, -0.15364686f, -0.07064769f, 
    0.04687586f, -0.02670777f, -0.01978270f, 0.00686191f, 0.07290138f, -0.05092717f, -0.03011395f, -0.05603525f, 
    -0.12573397f, 0.07142743f, -0.15352704f, 0.13395180f, 0.02246613f, -0.06920283f, 0.11068977f, -0.08479918f, 
    -0.01194246f, 0.04042856f, -0.16430376f, 0.00713304f, -0.22918449f, -0.05442243f, -0.12605780f, 0.25311330f, 
    0.01157786f, 0.07906555f, 0.10555850f, 0.06266528f, -0.08307113f, -0.09368693f, 0.05034701f, 0.03613751f, 
    0.04087295f, 0.05631957f, 0.08559490f, -0.05879306f, -0.06823228f, 0.01227841f, 0.02445153f, -0.09271465f, 
    -0.05756688f, 0.02575023f, -0.02018932f, 0.02129187f, 0.27425104f, -0.39667881f, -0.30141732f, -0.52682453f, 
    -0.03583731f, 0.09110864f, 0.01383720f, 0.10233733f, 0.09719604f, 0.04397398f, -0.02596106f, -0.03058814f, 
    -0.20284183f, -0.33172169f, 0.19114529f, 0.10965636f, -0.11445319f, 0.02644779f, -0.08303327f, -0.11070918f, 
    0.01764634f, -0.12856275f, -0.08413671f, -0.06394073f, 0.12517481f, 0.09800029f, 0.02361354f, -0.11933108f, 
    0.06267199f, -0.03860562f, 0.00214659f, -0.00022897f, -0.05895374f, -0.06242830f, 0.06157107f, -0.22310458f, 
    -0.16447149f, -0.16757740f, -0.07621847f, 0.07608388f, 0.03659866f, -0.07052251f, 0.03228040f, -0.00647613f, 
    -0.05711299f, 0.12116534f, 0.08625202f, -0.00297399f, 0.62164581f, -0.41430479f, -0.50610864f, -0.53461432f, 
    -0.11984405f, -0.20532621f, -0.23749813f, 0.05910347f, 0.07904733f, 0.07990541f, 0.02186835f, -0.01894500f, 
    -0.15872437f, -0.53449565f, 0.11841113f, 0.44125095f, -0.04440102f, 0.07305313f, -0.02789219f, -0.04383564f, 
    -0.03221646f, -0.13252553f, 0.05978713f, -0.01776403f, -0.01153476f, -0.08349073f, -0.25603947f, -0.30166280f, 
    0.13855802f, -0.05170564f, -0.05957529f, 0.22785494f, 0.05458107f, 0.10660975f, 0.04491263f, 0.12727377f, 
    -0.08960690f, 0.24590264f, -0.20361039f, -0.00004849f, 0.05628333f, -0.01487488f, 0.06241848f, -0.06266189f, 
    0.00372718f, 0.03663873f, 0.02507775f, 0.03543422f, 0.40483654f, 0.05310795f, -0.23667957f, 0.04051872f, 
    -0.07192651f, 0.00767418f, -0.10420858f, -0.00808545f, 0.03557977f, -0.06184723f, 0.05733532f, -0.03967487f, 
    -0.17759995f, 0.46448007f, 0.51606089f, 0.08554641f, -0.00295897f, -0.09967709f, 0.08851109f, -0.01539139f, 
    -0.01785389f, 0.02652305f, 0.06376072f, -0.02230574f, -0.13224232f, -0.30144107f, 0.07873213f, -0.07553189f, 
    -0.08282249f, 0.04349604f, 0.00059594f, -0.01847555f, 0.01411720f, -0.07753085f, -0.02483009f, 0.00175830f, 
    -0.13036235f, -0.52863061f, 0.12865973f, -0.31848410f, -0.04388745f, -0.04568445f, 0.03325224f, -0.01393615f, 
    -0.06401481f, 0.01467064f, -0.12334143f, -0.03681462f, 0.07548163f, 0.09427176f, 0.07001674f, 0.03147246f, 
    0.03388626f, -0.06417364f, -0.02992682f, -0.08246005f, 0.03049278f, -0.00186335f, 0.06353164f, 0.05634045f, 
    -0.23327570f, -0.09523118f, 0.00444902f, 0.16201568f, -0.01239693f, -0.00559762f, 0.00162527f, 0.02170698f, 
    0.02485106f, 0.01689453f, 0.05780233f, -0.00707979f, 0.05866203f, 0.08871072f, -0.04051481f, -0.00012572f, 
    -0.02957720f, -0.02192266f, -0.02195871f, -0.04448743f, -0.02417120f, -0.00967687f, -0.00250801f, -0.04652398f, 
    0.03040163f, 0.07626759f, 0.06744539f, -0.05013389f, -0.04491342f, -0.00633932f, 0.03191300f, -0.02602966f, 
    -0.10738030f, -0.17045207f, -0.08981163f, -0.09229798f, 0.18414240f, -0.01813986f, -0.07754866f, -0.08198685f, 
    0.01085023f, 0.04657513f, -0.00779424f, -0.04072043f, -0.01609460f, -0.02833455f, 0.16865051f, -0.04561697f, 
    -0.05419337f, -0.15271536f, 0.02012090f, 0.02359953f, -0.02237132f, -0.03920590f, 0.06834283f, 0.00452026f, 
    -0.21996623f, 0.07305337f, -0.03755532f, -0.03109237f, -0.07156441f, 0.40594441f, -0.14024565f, 0.15648097f, 
    0.08117966f, 0.04029319f, -0.02757148f, 0.00217515f, 0.04393959f, -0.02529046f, 0.01476612f, 0.03224231f, 
    -0.03962478f, 0.11520702f, -0.03221153f, 0.05888737f, -0.04072008f, -0.00971604f, -0.05229746f, -0.08444819f, 
    0.01891357f, 0.05146587f, 0.22409284f, 0.02900431f, -0.42340636f, -0.40956727f, -0.30809620f, -0.37934536f, 
    -0.01902603f, -0.02957019f, 0.13612324f, 0.13832459f, -0.00831084f, -0.00504227f, -0.03407953f, -0.03440085f, 
    0.06892788f, 0.12456892f, -0.00368713f, -0.14874081f, -0.00500856f, -0.02984517f, -0.01078838f, 0.02527738f, 
    -0.01519151f, -0.06669920f, -0.00155592f, -0.15652646f, -0.48238203f, 0.19475125f, -0.23902915f, 0.04906364f, 
    0.10690539f, -0.10322914f, 0.13273039f, 0.04184746f, 0.04167705f, 0.04287652f, 0.02172737f, -0.06025279f, 
    0.03919436f, -0.10605999f, -0.08631340f, -0.13390546f, 0.00213752f, 0.04862328f, 0.04142247f, -0.02651298f, 
    -0.01069740f, 0.09797052f, -0.06022083f, -0.07071753f, 0.05566762f, 0.15238214f, -0.26008901f, 0.12320839f, 
    0.01751880f, 0.09787821f, 0.05277282f, -0.06817292f, -0.15476747f, 0.07309868f, -0.00261156f, -0.09354056f, 
    0.07137146f, 0.00274742f, -0.08372487f, -0.04923486f, 0.03152895f, -0.01653193f, -0.05918068f, -0.05752789f, 
    -0.02009106f, 0.05601166f, -0.03458317f, -0.01641646f, 0.08936629f, 0.16772127f, -0.08230208f, 0.18045063f, 
    -0.04427706f, 0.05718841f, 0.03068691f, -0.01168077f, 0.07670429f, -0.07874665f, -0.10579083f, 0.01243974f, 
    -0.35429952f, -0.33877146f, -0.27833918f, -0.24439138f, 0.02303135f, 0.01671856f, 0.02743000f, 0.03237275f, 
    0.01867522f, 0.01140271f, 0.00582234f, 0.02577307f, 0.13929997f, 0.06905293f, -0.00977798f, -0.09277335f, 
    0.01459300f, -0.02168373f, 0.00477081f, -0.08646101f, -0.15804951f, -0.03960372f, -0.18576521f, -0.11287287f, 
    0.11145460f, 0.08914854f, 0.00540503f, 0.06645378f, -0.04547424f, -0.00044381f, -0.02903266f, 0.03843593f, 
    -0.03170894f, 0.13413911f, 0.05552569f, 0.07172210f, 0.11358181f, -0.44662252f, -0.29815310f, -0.12014031f, 
    -0.04249390f, -0.11775008f, 0.05662548f, 0.13142309f, 0.05634269f, -0.02744022f, -0.00972833f, -0.05673060f, 
    -0.07114745f, -0.09701911f, -0.01454244f, 0.03615392f, -0.04843464f, -0.07460891f, -0.09390574f, -0.01528245f, 
    0.04091885f, 0.02342441f, -0.04936159f, -0.00252187f, 0.11296575f, -0.06529266f, 0.08659970f, -0.21793945f, 
    -0.16061528f, 0.01240460f, 0.06118223f, -0.08854233f, 0.03275038f, -0.06498569f, 0.11705242f, -0.08426946f, 
    -0.03185947f, -0.07072156f, -0.02738376f, -0.06460119f, -0.03685940f, -0.02516686f, 0.05517351f, -0.09824037f, 
    0.05932137f, -0.00313500f, 0.00505029f, -0.04594083f, 0.15611115f, -0.14316989f, -0.19539335f, 0.05969777f, 
    0.01784807f, -0.09876844f, 0.14930335f, -0.12614194f, -0.08641402f, 0.12149477f, -0.00935090f, -0.01805805f, 
    -0.01996524f, 0.07798678f, 0.05781621f, -0.02345615f, 0.12436297f, -0.20738654f, 0.00409403f, -0.03289810f, 
    0.04031410f, -0.00817595f, 0.00609728f, -0.03155026f, -0.04017350f, 0.09193894f, -0.01093310f, 0.07728537f, 
    -0.08433957f, -0.04473457f, -0.12963767f, 0.02480968f, -0.07981262f, 0.00331053f, -0.04343435f, 0.00278349f, 
    0.01017862f, -0.00498290f, -0.01945454f, -0.04979800f, -0.07408757f, -0.04847689f, 0.24544989f, 0.02056022f, 
    0.03823891f, -0.00309254f, 0.06286597f, 0.01438217f, 0.03065431f, 0.07666429f, 0.00187825f, 0.01137617f, 
    -0.00669397f, 0.06113159f, 0.02162714f, -0.00933503f, -0.00741332f, -0.03051984f, -0.04218959f, 0.09088735f, 
    0.21792942f, 0.00402549f, -0.09699600f, 0.01464073f, -0.02279356f, -0.09382948f, -0.01697416f, -0.05445230f, 
    -0.01520759f, 0.08919021f, 0.01495169f, -0.00930476f, -0.01291269f, 0.04334556f, -0.19950134f, -0.21833724f, 
    -0.03956937f, 0.02344505f, 0.09327155f, -0.04042325f, -0.03679887f, 0.07869476f, -0.10369807f, -0.03757811f, 
    0.09840260f, -0.08160437f, 0.20165023f, -0.20261091f, -0.11995609f, 0.06408936f, -0.01114353f, 0.03140463f, 
    0.09091564f, 0.07381189f, 0.04101079f, -0.05381515f, -0.12944545f, 0.18405710f, 0.12322596f, 0.00423969f, 
    -0.17526898f, -0.00255920f, -0.12765263f, -0.01840175f, 0.06444691f, 0.01608142f, -0.01169907f, 0.00904565f, 
    0.24259889f, -0.58611053f, -0.03435836f, -0.47846943f, -0.11358982f, -0.05788252f, -0.12164193f, 0.13678104f, 
    0.02818629f, -0.00179201f, 0.10863689f, 0.01895063f, -0.02589688f, -0.00690840f, -0.01679102f, 0.00558864f, 
    0.05848887f, -0.04669287f, -0.01419055f, 0.06350618f, 0.06540211f, 0.07589444f, 0.03341001f, 0.02759379f, 
    -0.30729106f, -0.44299996f, -0.07066646f, -0.06287581f, 0.10397198f, 0.03318043f, 0.04862721f, 0.05651830f, 
    0.03944413f, -0.05909948f, 0.06846673f, 0.00202350f, -0.00690331f, -0.00003000f, -0.19841044f, -0.25566405f, 
    -0.01588359f, 0.00912689f, 0.08505430f, 0.09905528f, 0.12501752f, -0.03940074f, -0.02739879f, 0.03989944f, 
    -0.28928080f, -0.05958607f, 0.04797683f, 0.14235461f, 0.00819149f, 0.01131817f, -0.12336002f, 0.13935202f, 
    -0.14846551f, -0.10773190f, -0.01232592f, -0.08543057f, -0.07070807f, -0.12712704f, -0.28826836f, -0.27544728f, 
    -0.24459232f, -0.18792133f, -0.15616776f, -0.16264871f, 0.00862932f, -0.00976653f, 0.02551466f, 0.01725689f, 
    0.06289352f, 0.01378466f, -0.11604290f, 0.06589454f, 0.00817631f, 0.18079659f, -0.00862551f, 0.00370690f, 
    0.01264401f, -0.03829117f, 0.00030457f, -0.05441162f, -0.24982931f, -0.11271995f, -0.01845278f, 0.03477992f, 
    0.05632082f, -0.08359582f, 0.01793218f, -0.01825578f, -0.03368625f, 0.02932416f, -0.01274879f, -0.06385204f, 
    0.08211336f, -0.08625688f, -0.31769159f, 0.04723190f, 0.18942375f, -0.10759575f, -0.00265661f, -0.00220652f, 
    0.01430187f, 0.05983957f, 0.09972666f, 0.09906172f, -0.01661232f, -0.01368256f, 0.01908111f, 0.16186753f, 
    -0.09107464f, 0.09647369f, 0.02662772f, -0.02116021f, 0.03572772f, -0.00503515f, 0.15246823f, 0.07332058f, 
    -0.14894238f, 0.02262823f, 0.04028859f, -0.02221841f, 0.02737843f, -0.05725774f, -0.06494616f, 0.04859021f, 
    -0.03328738f, 0.08172189f, 0.02680868f, 0.00600438f, -0.02980963f, -0.18933551f, -0.13266563f, -0.13883984f, 
    -0.08198145f, 0.10250173f, 0.09567618f, 0.13741072f, 0.00777175f, 0.01444791f, 0.07346423f, 0.02550131f, 
    0.17474985f, 0.08859769f, -0.51450765f, -0.34589529f, 0.07592846f, -0.05493919f, -0.13252169f, -0.00126787f, 
    0.14570461f, 0.02200653f, 0.12731008f, 0.16244097f, -0.02576923f, -0.02545334f, -0.00432758f, -0.08219763f, 
    -0.10984490f, 0.01670033f, -0.00065465f, -0.01193653f, 0.12068220f, 0.07010128f, 0.06600432f, 0.15264867f, 
    -0.07714073f, -0.23644525f, -0.38893005f, -0.50839448f, -0.14876002f, -0.06873962f, -0.08411857f, -0.02473228f, 
    0.03042050f, 0.08941144f, 0.01032715f, 0.04941104f, -0.58152789f, 0.08789672f, 0.06274457f, 0.24567342f, 
    -0.03668632f, -0.04473322f, -0.14746217f, 0.03272851f, -0.07180902f, 0.03503860f, 0.08077554f, -0.00052088f, 
    0.20308042f, -0.38288531f, -0.21988346f, -0.10415176f, -0.06263761f, 0.09077988f, -0.01691042f, -0.01764027f, 
    -0.00973183f, 0.04472145f, 0.01072324f, 0.04158151f, -0.01927627f, -0.11224882f, 0.02202780f, -0.01809141f, 
    -0.07225086f, -0.01034185f, 0.01578593f, -0.03358004f, -0.22781177f, 0.02483070f, -0.16473128f, -0.22293144f, 
    0.08391961f, -0.16257407f, 0.06733660f, -0.12606919f, -0.04764809f, 0.08242840f, 0.00346055f, -0.06762013f, 
    0.00010217f, 0.00666945f, 0.17936593f, 0.09455530f, -0.48339006f, 0.09789453f, 0.07093413f, 0.18680660f, 
    -0.00080773f, 0.15708172f, -0.00244179f, 0.02497518f, -0.05506285f, 0.15260196f, 0.06058305f, 0.08289209f, 
    -0.10926632f, -0.05494695f, 0.07466953f, -0.05687856f, -0.05490861f, 0.05070513f, -0.05049911f, 0.02156434f, 
    0.08767559f, 0.12678722f, 0.09432080f, 0.01352458f, -0.35701686f, -0.31457785f, -0.45706794f, -0.02119217f, 
    0.13485569f, 0.13767375f, 0.20848431f, 0.00896688f, -0.13324128f, -0.00902394f, -0.05710908f, -0.06451933f, 
    0.60983837f, 0.10752177f, -0.01351526f, 0.01095040f, 0.17303269f, -0.08780930f, 0.02343429f, 0.00514132f, 
    0.06645574f, 0.02454324f, 0.15060110f, 0.03417728f, 0.01015727f, 0.11713497f, 0.04397224f, -0.10142383f, 
    -0.08148132f, -0.05936386f, -0.04809429f, 0.00346604f, 0.10753851f, 0.03076024f, -0.01044458f, 0.07855469f, 
    -0.16686514f, -0.28016490f, 0.01038871f, -0.00695366f, -0.04308768f, 0.02969420f, -0.03552286f, -0.05526941f, 
    -0.07123683f, 0.04047899f, -0.10996022f, -0.18178248f, -0.21277599f, -0.53099638f, -0.41349450f, -0.20251814f, 
    -0.02426658f, 0.17846233f, 0.25353572f, 0.12515521f, 0.06816288f, -0.11104658f, 0.05315063f, 0.01515881f, 
    0.42985031f, -0.31970829f, -0.40900207f, -0.28342584f, 0.15769637f, -0.04424484f, 0.11006020f, 0.03077739f, 
    0.07656077f, 0.13258718f, 0.13797724f, 0.16344810f, -0.21134533f, -0.44264153f, -0.30004650f, 0.05103112f, 
    -0.01204295f, 0.20646191f, 0.11483994f, 0.04635352f, -0.05273747f, 0.05010646f, 0.05620453f, 0.05486046f, 
    -0.50655210f, 0.11298259f, 0.23265243f, 0.17464259f, 0.03858234f, 0.03219138f, -0.12938167f, -0.05094765f, 
    -0.08259108f, -0.11419787f, -0.06329827f, -0.04860309f, 0.16558649f, -0.01437180f, -0.48469317f, -0.19505131f, 
    0.06687862f, 0.06713215f, 0.10772883f, 0.04778106f, 0.00296733f, 0.21072735f, 0.01692415f, 0.01168698f, 
    -0.61178780f, -0.23790322f, 0.11844899f, 0.09031047f, -0.05415031f, -0.00892844f, -0.03061149f, 0.08643297f, 
    0.09226938f, -0.02050291f, 0.13419913f, 0.12174395f, 0.13600326f, 0.01172039f, -0.13855369f, 0.09247831f, 
    0.12305176f, 0.18855861f, 0.02647679f, 0.01099434f, -0.01814027f, -0.06804438f, -0.06542500f, 0.00041842f, 
    0.22537149f, 0.11384407f, 0.08540497f, -0.14761086f, 0.05068113f, 0.00947906f, 0.14301609f, -0.11282377f, 
    0.07692715f, -0.10464842f, 0.07800714f, -0.05147115f, -0.19398543f, -0.05684516f, -0.01472620f, -0.08006061f, 
    -0.02227357f, -0.03223358f, -0.03058011f, -0.07469359f, -0.21034324f, -0.11296652f, -0.26541823f, -0.21970774f, 
    -0.21448192f, -0.03475293f, 0.10557980f, 0.07262160f, 0.09215246f, -0.05005663f, -0.11334554f, 0.07033595f, 
    -0.12235647f, -0.02558767f, 0.09501974f, 0.00780645f, -0.06401295f, -0.00749497f, -0.02440089f, -0.05233637f, 
    -0.04527649f, -0.03715915f, -0.02852909f, -0.03264926f, 0.01645112f, -0.00893234f, 0.00012865f, 0.06507126f, 
    -0.14830008f, -0.03817274f, -0.05339494f, -0.03863106f, -0.02153161f, 0.04707929f, -0.05039019f, 0.00159876f, 
    0.04890811f, 0.07438551f, 0.02113485f, 0.10966534f, -0.00057122f, -0.09510831f, -0.21802993f, -0.11310652f, 
    -0.01273200f, 0.02457152f, -0.02601516f, 0.02182060f, 0.15589836f, 0.13419829f, 0.14325222f, 0.19484752f, 
    -0.39447632f, -0.18314826f, 0.17526691f, 0.09907367f, 0.02231010f, 0.01120355f, -0.01504107f, -0.04229916f, 
    -0.05785330f, 0.01724111f, 0.00377080f, 0.00847860f, -0.59406394f, -0.05678845f, 0.13231912f, 0.17045090f, 
    -0.05690071f, -0.05718924f, -0.11317736f, -0.00776462f, -0.01343082f, -0.02679270f, -0.03647326f, -0.03186763f, 
    -0.26756436f, -0.16031297f, 0.03543145f, 0.01879392f, -0.02879687f, 0.08652537f, -0.00540126f, 0.06444561f, 
    -0.09827823f, -0.11474218f, -0.21551365f, -0.05194692f, -0.14643517f, -0.40769818f, -0.28648463f, 0.04551274f, 
    -0.01712243f, 0.13134985f, 0.01597516f, -0.04761934f, -0.11362283f, -0.12722141f, -0.07834248f, -0.11644994f, 
    0.11620820f, -0.01186031f, -0.00383566f, -0.01273948f, -0.02038986f, -0.08769372f, 0.04070264f, 0.01465239f, 
    0.11767685f, 0.07340335f, -0.00335186f, 0.09722852f, -0.49590966f, -0.15535648f, 0.19687392f, 0.16231683f, 
    -0.04306933f, 0.11122750f, 0.03307589f, 0.09218051f, 0.03322063f, -0.14617088f, 0.09481794f, 0.09612022f, 
    -0.15703817f, -0.29012978f, -0.08569793f, -0.03819408f, -0.08987956f, -0.04253633f, 0.05948675f, 0.00027570f, 
    0.06733949f, -0.05838474f, 0.08773287f, -0.00773841f, 0.36280975f, 0.14019345f, 0.22318161f, -0.00309427f, 
    0.17567341f, 0.06885403f, 0.01472685f, 0.10693601f, 0.19204323f, -0.05307316f, 0.14067544f, 0.01825040f, 
    0.09923592f, -0.02111967f, 0.02014923f, 0.02926068f, -0.07914814f, -0.06252208f, 0.00097647f, -0.02354667f, 
    0.03223105f, 0.02471737f, 0.00550072f, -0.01184507f, 0.09329801f, -0.10439576f, -0.20391044f, -0.24525148f, 
    0.06336198f, 0.03583940f, -0.03726498f, 0.09690068f, 0.09484262f, 0.02691607f, -0.00732997f, -0.01744329f, 
    -0.20311984f, -0.54589337f, -0.33094591f, 0.11280244f, 0.04551597f, 0.03228649f, -0.00237464f, -0.00140897f, 
    -0.07946918f, -0.03141748f, 0.00779931f, 0.04241978f, 0.07133118f, -0.02009470f, 0.02543386f, -0.13924257f, 
    0.00362231f, -0.00370645f, 0.03134630f, -0.05701598f, 0.00449458f, 0.04150332f, 0.08961316f, 0.02566634f, 
    0.01054573f, -0.05289736f, -0.00101691f, -0.12230716f, 0.05369756f, -0.03706010f, -0.02323510f, 0.05357005f, 
    -0.14823774f, -0.08261757f, -0.10654376f, -0.21735635f, 0.03998003f, -0.11063290f, -0.12456562f, 0.02119048f, 
    -0.03786905f, 0.13922441f, 0.11515538f, 0.14506400f, -0.18538038f, -0.08086555f, -0.25732285f, -0.31058398f, 
    0.17367505f, 0.14101404f, 0.07534645f, -0.09006914f, -0.01522352f, -0.14251761f, 0.04946405f, -0.11448263f, 
    0.00014139f, 0.09032426f, 0.05646714f, -0.03504125f, -0.07534369f, -0.15280212f, -0.05304642f, 0.42970368f, 
    0.14794020f, 0.03599406f, 0.09016965f, 0.04301568f, 0.00583938f, 0.21287757f, -0.16523255f, 0.01663972f, 
    -0.20376749f, 0.32084975f, 0.03652701f, 0.11799861f, -0.05948644f, 0.07422045f, -0.07787715f, -0.10181293f, 
    -0.03846576f, 0.02911990f, -0.12846607f, 0.10178880f, 0.34804511f, 0.14696458f, 0.01495987f, -0.05573969f, 
    0.00116477f, 0.09446368f, 0.12834279f, 0.01128898f, -0.01867963f, -0.10628188f, -0.01892243f, 0.01874327f, 
    0.01703935f, -0.05864334f, 0.02229804f, 0.00204953f, 0.05541801f, -0.04285673f, -0.04320922f, -0.15391204f, 
    0.05220222f, 0.07401931f, 0.05997980f, 0.06608764f, 0.01461170f, 0.01584750f, 0.03854065f, 0.05128429f, 
    0.05200930f, -0.22947018f, 0.09350622f, 0.04493090f, 0.09849718f, 0.00270875f, 0.12058862f, 0.00219318f, 
    -0.16845648f, -0.22131732f, 0.00502056f, 0.06616678f, 0.01953779f, 0.08023776f, 0.07025524f, 0.00719751f, 
    -0.10126129f, 0.17738563f, 0.07731622f, 0.15311477f, -0.08151564f, 0.08605574f, -0.00905345f, -0.00566813f, 
    0.05032023f, 0.02715786f, -0.02393729f, 0.00079713f, -0.27348164f, -0.04117128f, -0.10409825f, -0.12420542f, 
    0.03234500f, 0.05002221f, -0.11469842f, -0.06574441f, 0.03180305f, 0.05384022f, -0.01322020f, -0.01088243f, 
    0.02235853f, -0.10781225f, -0.17468674f, -0.33828706f, -0.02671518f, 0.08435115f, 0.09736487f, 0.05861814f, 
    -0.01826363f, 0.00439392f, 0.04460790f, 0.05619337f, 0.11464252f, -0.00099050f, -0.03697708f, 0.12090386f, 
    0.38371459f, 0.01094452f, 0.09034459f, -0.28623259f, 0.05979141f, -0.10033366f, -0.02053107f, -0.03875244f, 
    -0.10021815f, 0.13852470f, 0.07398848f, -0.02814281f, -0.07169697f, 0.04590462f, -0.01559467f, -0.03694163f, 
    0.08188170f, -0.06495546f, -0.11614960f, -0.00699605f, 0.09798212f, 0.12857632f, 0.06363963f, 0.05974866f, 
    -0.02588995f, -0.11436588f, -0.16630107f, -0.00462408f, 0.01274828f, -0.00391082f, 0.12331664f, 0.02147111f, 
    0.02121976f, 0.02155949f, -0.03193511f, -0.11466615f, -0.11745902f, -0.04514488f, -0.10807332f, 0.02336542f, 
    -0.09676719f, -0.02815925f, -0.06583723f, 0.06770550f, 0.04526737f, -0.16308227f, -0.28532317f, -0.24555287f, 
    -0.15171848f, 0.11645015f, 0.03184284f, -0.13585684f, -0.21333158f, -0.24426465f, -0.01808640f, 0.17721495f, 
    -0.10552655f, -0.00291964f, -0.00248917f, 0.00822374f, -0.13292453f, -0.01758568f, 0.05668698f, 0.11982096f, 
    0.09845793f, -0.07648158f, 0.02873821f, 0.05894277f, -0.10203152f, -0.01006889f, 0.02325855f, -0.09721326f, 
    -0.32855424f, 0.43763384f, -0.24411942f, -0.02714962f, -0.00268588f, -0.15953532f, 0.13762981f, 0.06296157f, 
    0.04406828f, 0.03218783f, -0.04672907f, 0.08051029f, -0.36761844f, 0.14079487f, 0.12727259f, -0.00924643f, 
    0.01321579f, -0.09936592f, 0.15506043f, 0.14708251f, 0.03883922f, 0.09100030f, 0.08597320f, -0.09945389f, 
    0.02979309f, 0.03195807f, -0.05306477f, -0.16937445f, -0.03295546f, -0.04334492f, -0.08109818f, -0.02991839f, 
    -0.01158982f, 0.06193924f, -0.03146269f, -0.06337357f, 0.03376064f, -0.01468716f, -0.22415920f, -0.25518271f, 
    0.01533148f, -0.11317634f, 0.08954792f, -0.37063122f, 0.11008855f, 0.04439526f, -0.03691721f, 0.17919439f, 
    0.09710741f, -0.05305328f, 0.28185549f, 0.16051099f, 0.03336258f, -0.30257520f, 0.02324245f, -0.13339448f, 
    0.04398612f, 0.00166767f, -0.10398169f, 0.01832082f, -0.19927436f, -0.21331307f, -0.10389347f, -0.08513761f, 
    0.19208130f, -0.09717061f, 0.02788852f, 0.07949505f, -0.06704084f, -0.07017615f, -0.06762061f, -0.07928766f, 
    0.24847859f, -0.03518551f, -0.25093383f, -0.13830689f, 0.02567649f, 0.16538544f, 0.12509905f, 0.11494258f, 
    0.00383190f, -0.07640247f, -0.05802750f, -0.08313771f, -0.00392409f, 0.28097212f, -0.05752977f, 0.30132842f, 
    0.04362762f, 0.03675616f, -0.14449051f, 0.11090796f, 0.01293841f, -0.14062491f, -0.06886296f, 0.00910507f, 
    0.07357898f, 0.11753830f, 0.05842437f, 0.58764249f, 0.09780382f, 0.02774936f, -0.10022197f, -0.07147389f, 
    0.01669860f, -0.13534385f, 0.02197438f, -0.10746155f, -0.02743478f, 0.05830317f, 0.06278843f, 0.00188460f, 
    0.04286732f, 0.05336830f, -0.08084829f, 0.01468721f, -0.07819889f, 0.04558182f, 0.05387352f, -0.05320144f, 
    -0.27055469f, -0.15142410f, -0.06099804f, 0.01078818f, -0.21401775f, -0.02351677f, 0.02106766f, 0.08680642f, 
    0.09272397f, 0.09182950f, -0.01427198f, 0.07283877f, 0.00549838f, 0.07208484f, -0.21708733f, 0.03072015f, 
    -0.01141309f, 0.02410498f, 0.11928643f, -0.02024065f, -0.07678908f, 0.05512558f, -0.08092417f, -0.00369307f, 
    0.07948118f, -0.24928349f, 0.19779623f, -0.35782513f, 0.01758512f, -0.07053003f, 0.06889948f, 0.03482737f, 
    0.02869350f, -0.08133873f, -0.06001013f, -0.02663443f, -0.30208525f, 0.08783302f, 0.23086728f, 0.28541830f, 
    -0.02130083f, 0.05201259f, -0.12955368f, -0.06400742f, 0.06854027f, 0.11166456f, 0.05955673f, 0.04877466f, 
    -0.29075587f, 0.02900486f, 0.07261331f, -0.09391762f, 0.10971328f, -0.10130359f, -0.03531270f, 0.14999828f, 
    -0.03676838f, 0.07184009f, -0.01489148f, -0.02819351f, -0.33742073f, 0.39921784f, -0.22444467f, -0.73832846f, 
    -0.04764499f, -0.05724292f, 0.16265005f, -0.13494106f, 0.04761293f, 0.08806099f, 0.03574501f, -0.12309796f, 
    0.04283099f, -0.28574398f, 0.12043263f, -0.27190915f, -0.13040759f, 0.10210815f, -0.15485847f, -0.01931950f, 
    -0.00193578f, 0.03310623f, -0.20842876f, 0.10593496f, 0.06974302f, -0.08720578f, -0.28473049f, 0.02835791f, 
    -0.32063520f, 0.09209959f, -0.03970400f, -0.08658511f, 0.11564934f, -0.01503156f, 0.10250134f, 0.01432152f, 
    -0.12039658f, 0.04334779f, 0.03314248f, 0.15490118f, 0.06480344f, -0.00416305f, -0.09280171f, -0.11688121f, 
    0.00263225f, 0.01334986f, -0.01171881f, -0.00701325f, -0.17907396f, -0.18554755f, -0.01592949f, 0.19431971f, 
    0.00963247f, 0.15509194f, -0.13753761f, 0.06304569f, 0.06786091f, 0.01702750f, 0.07101442f, -0.18459676f, 
    0.18073675f, 0.05166401f, 0.43574265f, 0.03023387f, 0.00111842f, -0.16945466f, -0.10313651f, -0.17216071f, 
    -0.04899639f, 0.14612281f, 0.07953501f, 0.06666928f, 0.00094134f, 0.30556315f, -0.14905697f, 0.13648437f, 
    -0.09607653f, 0.01846320f, -0.31338680f, -0.04790747f, 0.05121361f, -0.13277648f, 0.12585254f, 0.08934961f, 
    -0.10470045f, -0.02079607f, 0.13050550f, 0.18186344f, -0.06051496f, -0.22816989f, 0.00523581f, 0.06831289f, 
    0.01161650f, 0.07429066f, 0.01565955f, 0.03176990f, -0.03635932f, 0.12523121f, -0.28640354f, 0.07376084f, 
    -0.12061912f, 0.05127161f, -0.13262032f, 0.02679362f, -0.04161484f, -0.07792300f, 0.05100837f, 0.01677795f, 
    -0.07160368f, -0.01436861f, -0.86475480f, -0.02275467f, 0.11225534f, 0.00362348f, 0.13323247f, 0.17466232f, 
    -0.03409043f, -0.06287377f, 0.01879773f, 0.03612793f, -0.32387519f, -0.19592702f, -0.20040753f, 0.38925517f, 
    0.00694913f, 0.02784590f, -0.11311503f, -0.03618250f, -0.04743806f, -0.02832524f, -0.04847316f, -0.08873028f, 
    0.24915208f, -0.31257921f, 0.03151548f, -0.58061492f, 0.00463370f, -0.04372649f, -0.02323842f, 0.03852772f, 
    0.01906809f, 0.03546647f, -0.12531316f, 0.03311496f, -0.00101060f, 0.05767328f, 0.10805963f, -0.16759399f, 
    -0.02978863f, -0.01119484f, -0.16176198f, -0.01276541f, 0.14617771f, 0.00233295f, -0.05161815f, 0.00219316f, 
    0.15981005f, -0.16254301f, -0.03197807f, 0.09823493f, 0.04560123f, -0.04085844f, -0.10422266f, -0.00223338f, 
    0.07524996f, 0.07550508f, -0.08499718f, 0.04556709f, -0.00485004f, -0.15113999f, -0.07844900f, 0.03397926f, 
    0.03288471f, 0.04336898f, 0.18569392f, -0.00989696f, 0.10781774f, 0.10514119f, 0.09259341f, 0.12358162f, 
    0.08742433f, 0.67345983f, -0.08345534f, -0.25462574f, -0.10481050f, -0.04555131f, 0.09676363f, -0.14339961f, 
    0.10475445f, -0.00230522f, -0.06882530f, 0.00016295f, -0.05385863f, -0.16605538f, 0.07445366f, -0.07223964f, 
    0.12544103f, 0.21179004f, 0.13871102f, 0.06654081f, 0.10949111f, -0.03941411f, 0.06302941f, -0.05818671f, 
    0.14242755f, -0.12316413f, 0.11279710f, -0.04378934f, 0.05484830f, 0.08511156f, -0.04070612f, 0.05316456f, 
    0.03049022f, 0.10858791f, 0.05612986f, -0.02416304f, -0.13615243f, 0.19166048f, 0.12771036f, 0.12686293f, 
    0.17169864f, -0.01545584f, -0.15784796f, -0.05926281f, -0.16785297f, -0.01624900f, -0.08179047f, 0.01348446f, 
    0.03340572f, 0.03499066f, 0.10586639f, -0.61731130f, 0.05764964f, -0.13335137f, -0.00275123f, -0.12133189f, 
    -0.06174687f, 0.08418175f, -0.00117588f, -0.00770647f, -0.43875569f, -0.02298024f, -0.28352770f, 0.16566235f, 
    0.05949588f, -0.04071383f, 0.10184075f, 0.08708662f, -0.04905914f, -0.00163134f, 0.02417303f, 0.00817657f, 
    -0.24692436f, 0.00970212f, -0.11325958f, -0.12858650f, 0.05609365f, 0.00418499f, 0.12690532f, -0.07671118f, 
    -0.03965590f, 0.01231878f, -0.06952041f, 0.20233713f, 0.12485867f, -0.02292657f, 0.02017882f, -0.24943985f, 
    -0.18279989f, -0.08445238f, 0.07653850f, 0.07163723f, 0.14071482f, 0.04736836f, 0.13527220f, 0.10305487f, 
    -0.12324058f, -0.28431037f, 0.04016229f, 0.07739516f, 0.10276452f, 0.09469184f, 0.05394229f, 0.08340117f, 
    -0.07954206f, 0.02356858f, -0.07048734f, -0.04293399f, -0.45117107f, -0.03210789f, -0.15200341f, -0.24235062f, 
    -0.01262987f, -0.16990134f, 0.13671459f, 0.02800254f, -0.09070417f, -0.13065071f, -0.05876220f, -0.00942797f, 
    0.17152762f, 0.03194893f, 0.16694009f, 0.21925199f, 0.06005709f, -0.01476766f, -0.18909036f, 0.02325539f, 
    -0.11600471f, -0.02193999f, 0.03996424f, 0.03999442f, -0.65775263f, 0.12179223f, -0.40465355f, 0.01493528f, 
    -0.05202773f, -0.17526770f, -0.21319750f, -0.17257522f, -0.04778196f, -0.07718164f, 0.00674776f, -0.05581267f, 
    -0.10226170f, -0.21343893f, -0.10030996f, 0.15628652f, 0.08800443f, 0.14874056f, 0.07787963f, -0.02555632f, 
    -0.01239103f, 0.02524549f, 0.04416594f, -0.00116310f, -0.46342802f, 0.27407244f, -0.45043314f, 0.61100990f, 
    0.09632089f, -0.14887056f, -0.05971963f, -0.15257990f, 0.14412566f, -0.04108934f, 0.05446668f, -0.02989344f, 
    -0.01185020f, 0.02820242f, 0.04130924f, -0.20214675f, -0.14341550f, -0.07890320f, 0.03382649f, 0.08213897f, 
    0.04133227f, -0.00845685f, 0.02572141f, 0.01553356f, -0.03883303f, 0.20631659f, 0.09733809f, 0.36827123f, 
    0.06974666f, -0.00102906f, -0.05549904f, -0.21205071f, 0.10170314f, -0.06125388f, 0.01094868f, -0.07396422f, 
    -0.03753377f, 0.05651624f, -0.25818360f, 0.22913489f, 0.00913342f, 0.07153404f, 0.13702194f, 0.07271610f, 
    -0.08366948f, -0.00351738f, 0.23538418f, 0.18236801f, -0.11530306f, 0.06050204f, 0.15702838f, 0.17557086f, 
    0.02133811f, -0.02220653f, -0.18671505f, -0.00344510f, 0.13664374f, 0.05805498f, 0.03571639f, 0.06798062f, 
    0.06716929f, -0.27340677f, -0.31046000f, 0.07858714f, 0.11318201f, 0.14105849f, 0.14507727f, -0.01304959f, 
    -0.02845080f, -0.05769692f, -0.03397668f, -0.11998601f, 0.08487292f, 0.00107085f, 0.02336605f, -0.33897430f, 
    -0.14150971f, -0.07524344f, -0.06559548f, -0.16459937f, 0.16951287f, 0.10195152f, -0.18375367f, -0.11017359f, 
    -0.19979052f, -0.04531785f, -0.16365401f, 0.04317492f, 0.07547916f, 0.13742337f, 0.07141706f, -0.04202590f, 
    0.23858489f, -0.05576442f, -0.08293228f, -0.03310224f, -0.34143806f, -0.23949289f, -0.10870681f, -0.04024332f, 
    0.06931585f, 0.03572180f, -0.02622348f, 0.24640685f, 0.01858116f, -0.06675851f, -0.01783730f, 0.10362307f, 
    -0.04001074f, -0.22825801f, -0.18461561f, -0.11073440f, 0.07648045f, -0.01336424f, 0.15326442f, -0.01851618f, 
    0.05506184f, -0.11685558f, -0.05001697f, -0.11613927f, -0.30294117f, 0.14004590f, -0.28070307f, 0.05367326f, 
    0.06141495f, -0.16828080f, 0.23274544f, -0.10081787f, -0.01468179f, -0.06618225f, -0.07504782f, -0.12952656f, 
    -0.03799930f, 0.13542274f, -0.04072399f, -0.41289237f, 0.07568107f, -0.28117761f, 0.08883674f, -0.24785870f, 
    0.00564157f, -0.05680746f, -0.08804028f, -0.01247365f, -0.26836693f, 0.25450149f, -0.26258689f, 0.12648968f, 
    0.04774226f, -0.05062655f, 0.02902337f, -0.05331536f, 0.12620115f, 0.08736103f, 0.02043130f, -0.03404164f, 
    -0.07929328f, -0.03277592f, -0.00292879f, 0.06509856f, 0.09465629f, 0.11099940f, -0.03653489f, 0.05748205f, 
    0.11150054f, 0.08067027f, 0.18682662f, 0.19673291f, 0.25582287f, -0.02420169f, -0.21372807f, 0.07413824f, 
    0.24591886f, 0.10185147f, -0.14066023f, 0.08511890f, 0.06363554f, -0.16336839f, -0.03104886f, -0.03692672f, 
    0.30190888f, -0.56738967f, -0.10909123f, 0.07833146f, -0.03854167f, 0.23659736f, 0.02594285f, -0.10840222f, 
    -0.06567580f, -0.00427418f, -0.02063490f, 0.00177663f, 0.27775538f, -0.28567848f, 0.03242369f, -0.15276052f, 
    -0.02962261f, 0.01610666f, -0.25276238f, 0.10196795f, 0.03472435f, 0.01435306f, -0.12141068f, -0.18855669f, 
    0.08008386f, 0.00913126f, -0.00794287f, 0.09672043f, 0.01879889f, 0.12289666f, -0.10153317f, 0.00619821f, 
    0.07501750f, 0.03379812f, 0.09164650f, 0.03080407f, 0.03403030f, 0.12062091f, 0.21920574f, 0.02848329f, 
    0.03813296f, -0.08957542f, -0.05343476f, -0.00929242f, 0.04221805f, 0.17115013f, 0.03233594f, -0.02373161f, 
    -0.21294916f, 0.06714632f, -0.01114019f, -0.26463282f, -0.08954089f, -0.08694162f, -0.01854915f, -0.15761615f, 
    0.11996870f, 0.09591456f, 0.01777554f, -0.01027459f, -0.08174256f, 0.00633364f, 0.03059321f, 0.12012995f, 
    -0.01358832f, 0.06026419f, 0.03904615f, 0.11999650f, 0.10145003f, 0.08194320f, 0.10830112f, -0.07005483f, 
    0.01207437f, -0.20390156f, 0.07991103f, -0.03947335f, -0.02330607f, -0.07064553f, 0.08202683f, 0.05511814f, 
    -0.26690760f, -0.11298683f, -0.15192086f, 0.03278792f, -0.10142706f, -0.55116725f, -0.30267590f, 0.00856194f, 
    0.01380541f, 0.01031042f, -0.08459467f, -0.14712253f, 0.04829866f, 0.10367846f, -0.05561560f, -0.00205136f, 
    -0.15190218f, -0.12600014f, 0.19730613f, -0.02483898f, 0.00166437f, 0.06628728f, -0.19499715f, -0.02145429f, 
    -0.15853813f, -0.04011142f, -0.00346564f, 0.04495255f, 0.01422632f, 0.01418313f, 0.01723848f, 0.10026642f, 
    -0.12966073f, 0.13085592f, 0.13321848f, -0.04940115f, 0.01924904f, 0.02330708f, -0.11010329f, -0.11508676f, 
    -0.18800676f, 0.06588177f, 0.08393739f, -0.02351249f, -0.19706054f, -0.04302575f, 0.10556525f, 0.04025727f, 
    0.03206556f, -0.04671025f, 0.03986424f, 0.08265762f, -0.01031856f, -0.38799581f, 0.29727754f, 0.07316624f, 
    -0.00929370f, 0.08783119f, -0.09743065f, 0.12603037f, 0.01362876f, 0.02738734f, 0.17538589f, 0.06025415f, 
    -0.02931031f, -0.21604377f, -0.22871080f, 0.19911943f, -0.10213263f, -0.10212390f, 0.08819262f, -0.24037769f, 
    -0.05708250f, 0.14714053f, -0.14003891f, 0.04798434f, -0.02319733f, 0.20794263f, 0.11542535f, -0.10983551f, 
    -0.02156039f, -0.07290196f, 0.07655115f, 0.13463068f, -0.02043452f, 0.18875705f, -0.01338111f, 0.10241931f, 
    -0.17110938f, 0.48267049f, 0.08788572f, -0.00609459f, -0.10293506f, -0.06060401f, 0.03923255f, 0.01130127f, 
    0.08795671f, 0.00219273f, -0.02443136f, 0.06790722f, -0.13200459f, 0.17623526f, 0.10100494f, 0.17707150f, 
    -0.00761372f, -0.00848956f, 0.02365664f, 0.02455138f, 0.02893344f, -0.10433766f, 0.08777926f, 0.03779417f, 
    -0.13483542f, -0.42361704f, -0.20761883f, 0.02023151f, -0.03765303f, 0.02121026f, 0.06617679f, -0.04806085f, 
    0.06192402f, 0.07929327f, 0.06429394f, 0.04592615f, 0.00695293f, 0.01996445f, -0.31622252f, 0.18720385f, 
    -0.08478805f, -0.09787883f, 0.20764287f, -0.09120088f, 0.01239462f, 0.02037277f, 0.03662930f, 0.04442521f, 
    -0.22612214f, 0.11706289f, -0.09072564f, 0.26266313f, 0.02564213f, 0.07792457f, -0.13056892f, -0.04689349f, 
    0.06802865f, 0.06641517f, 0.07055098f, 0.05286245f, 0.27160618f, -0.06862068f, 0.12199738f, -0.17307559f, 
    0.01951111f, -0.04619315f, 0.04475281f, 0.03570455f, -0.20463148f, -0.16439538f, -0.33055022f, -0.24769418f, 
    -0.12603760f, 0.01719677f, 0.02377028f, -0.15215692f, -0.01731475f, 0.03565297f, -0.23329732f, 0.04837332f, 
    0.12422390f, -0.04135799f, -0.10596439f, 0.15739040f, 0.11095331f, -0.12816700f, 0.26193482f, -0.05883620f, 
    -0.06009363f, 0.04279063f, 0.01100726f, 0.11053113f, -0.03103146f, 0.01767123f, 0.00260604f, -0.01330927f, 
    -0.05535493f, 0.11676565f, 0.13836220f, -0.16669156f, -0.01505513f, 0.12381430f, 0.02385518f, -0.05749781f, 
    -0.07391392f, 0.04823831f, 0.08890883f, 0.13606560f, 0.01701216f, 0.12914200f, -0.20993115f, -0.01079119f, 
    0.05838699f, -0.20453981f, -0.02601652f, 0.00074772f, -0.14779603f, 0.03418779f, -0.05123218f, -0.15086184f, 
    -0.33980194f, 0.01442512f, -0.27041820f, 0.12629928f, -0.02631753f, 0.12282835f, 0.04853021f, 0.14042898f, 
    0.04785087f, 0.14835924f, -0.05016843f, 0.10463439f, -0.18877591f, 0.18327099f, 0.16236159f, 0.02175252f, 
    0.01265095f, 0.03349675f, 0.01778052f, -0.05212780f, -0.07657291f, -0.02809727f, 0.00610760f, 0.04663707f, 
    -0.29329702f, 0.08030709f, -0.19306239f, -0.11231258f, 0.00880254f, -0.13910171f, -0.19937348f, 0.03963572f, 
    0.00046627f, -0.14678794f, -0.11526088f, -0.27324960f, -0.26577550f, 0.15465695f, -0.05175267f, -0.27605128f, 
    0.07048403f, 0.11516806f, -0.05283956f, 0.27171212f, -0.13486733f, 0.08719353f, -0.05308702f, -0.11806119f, 
    -0.45826060f, 0.18513557f, 0.15085280f, -0.02587693f, -0.08200087f, -0.00931477f, 0.09237910f, -0.11777696f, 
    -0.05428443f, 0.00416409f, -0.00042041f, 0.03994616f, 0.31948566f, 0.26043436f, 0.04932492f, 0.22344185f, 
    -0.05124425f, 0.06727005f, 0.06398935f, 0.14777298f, 0.00019979f, 0.04275485f, 0.05960500f, 0.03673720f, 
    0.09676229f, -0.28014529f, -0.02209134f, -0.06208848f, -0.16471611f, -0.11329090f, 0.00577669f, -0.16625144f, 
    -0.15354101f, 0.00388045f, -0.08581313f, -0.08745513f, -0.16395181f, 0.56391245f, 0.20862584f, 0.06543225f, 
    0.07371703f, 0.01918072f, 0.06487174f, 0.03461621f, -0.12484981f, 0.07984247f, -0.09665278f, 0.03714828f, 
    0.09010598f, 0.17864083f, 0.03940314f, 0.52445441f, 0.07749187f, 0.11416072f, -0.01997430f, 0.06557550f, 
    0.09483693f, 0.00741286f, 0.03818451f, 0.18703496f, -0.22423093f, -0.03890570f, -0.21399578f, 0.05403403f, 
    0.05008479f, -0.01287236f, -0.14429651f, 0.00068713f, -0.16192046f, -0.08601722f, -0.03112881f, -0.03499518f, 
    -0.29580799f, 0.11734615f, -0.18161029f, 0.00496720f, -0.04619132f, 0.01404109f, -0.00929257f, -0.15160872f, 
    -0.02068634f, 0.05735938f, -0.08119898f, -0.23348810f, -0.08830866f, -0.02971754f, -0.15788957f, -0.15858908f, 
    -0.12803955f, -0.10186222f, -0.09641298f, -0.11275136f, -0.10769533f, -0.09181137f, -0.16455935f, -0.14345628f, 
    -0.11290859f, -0.30446136f, 0.07136492f, -0.00844033f, -0.10463493f, -0.03734428f, 0.14794211f, -0.09360752f, 
    -0.05609016f, -0.04925965f, 0.13486667f, 0.04648730f, -0.09764421f, -0.31625265f, -0.01604270f, -0.14185329f, 
    -0.11012432f, -0.03255371f, -0.07710804f, 0.05976472f, 0.10756904f, 0.06672660f, 0.10385182f, -0.09412713f, 
    -0.14188166f, -0.04245771f, -0.06171878f, 0.00195815f, -0.04633731f, -0.05795437f, -0.02135945f, -0.01285055f, 
    -0.05072256f, 0.06127511f, 0.08682775f, 0.15913017f, -0.04192980f, 0.08882084f, 0.13503140f, -0.13411279f, 
    -0.06528553f, -0.00717477f, 0.06777698f, -0.02510597f, 0.03781301f, 0.06072567f, 0.19686460f, 0.22035266f, 
    -0.05609375f, 0.14477050f, 0.06794676f, 0.20485348f, -0.05810120f, -0.19860657f, 0.08956186f, 0.04490963f, 
    0.00985903f, 0.13176766f, -0.19385813f, -0.30259117f, 0.00530727f, -0.36032221f, 0.24648499f, -0.06504188f, 
    -0.16134572f, 0.05798921f, -0.06212042f, -0.05707414f, -0.02190006f, -0.03835527f, -0.12016708f, 0.07175575f, 
    0.01568307f, 0.03523643f, -0.00513151f, 0.03863057f, -0.05074493f, -0.05400254f, 0.09856994f, -0.02113232f, 
    0.00050394f, 0.05297330f, -0.00102512f, 0.04632952f, -0.15348162f, 0.01219054f, -0.06257656f, 0.01755705f, 
    0.01344651f, 0.05739601f, -0.01277917f, 0.04746203f, -0.03271036f, 0.04048254f, -0.08542626f, -0.28041986f, 
    -0.05145082f, 0.02237096f, 0.05749688f, 0.10404541f, -0.06854719f, -0.07273182f, 0.03991908f, -0.01295517f, 
    0.13511440f, -0.03413197f, -0.00297913f, 0.07519639f, 0.01290265f, 0.12452090f, 0.18380852f, 0.00003407f, 
    0.10511685f, 0.02107781f, 0.05264601f, 0.08279801f, 0.06308722f, 0.03109361f, 0.15500447f, 0.02543678f, 
    -0.15648203f, 0.12762780f, 0.08708469f, 0.03449361f, 0.05684475f, 0.04129671f, -0.13856180f, -0.08297574f, 
    0.03499814f, 0.05758877f, -0.05034306f, -0.03432244f, 0.38077581f, -0.19749194f, 0.28200492f, 0.13383503f, 
    -0.14004229f, -0.05671264f, 0.28425527f, 0.02089588f, -0.01166988f, 0.12390804f, 0.05449402f, -0.05065597f, 
    -0.24807903f, 0.02588161f, 0.15476952f, -0.14732729f, -0.16011284f, -0.01419019f, -0.17126904f, 0.02429774f, 
    0.08091094f, -0.03912912f, 0.03461073f, 0.09427150f, 0.32465035f, 0.14327873f, 0.17530771f, -0.09203749f, 
    -0.14434305f, -0.01559615f, 0.09398562f, 0.04314608f, -0.11180105f, -0.09984633f, -0.37354407f, -0.24515173f, 
    -0.04734478f, 0.03857229f, 0.07362808f, 0.07144134f, -0.19260977f, 0.09065112f, 0.12734632f, 0.22054829f, 
    0.06260940f, 0.09133389f, 0.01767378f, 0.06806373f, 0.11470716f, -0.10751715f, 0.11641161f, -0.32220003f, 
    -0.14094745f, -0.11160361f, 0.04614795f, 0.02442763f, 0.01128397f, -0.14669977f, 0.11251260f, 0.04452654f, 
    0.10790645f, 0.17748249f, 0.05833081f, -0.20976961f, -0.09294723f, -0.01070958f, 0.05207204f, 0.01069208f, 
    -0.04467208f, -0.06188342f, -0.53729403f, -0.19568726f, -0.01745244f, -0.16650476f, 0.06700241f, -0.03962931f, 
    0.03221145f, 0.03724591f, -0.26168889f, -0.01138297f, -0.18593109f, -0.00455761f, -0.20926780f, -0.25196064f, 
    -0.15910521f, -0.25227204f, -0.33858612f, -0.02167085f, -0.13685675f, 0.10390388f, -0.00021115f, -0.10407890f, 
    0.00031623f, 0.15750140f, 0.06959400f, 0.06073211f, 0.18240553f, -0.04169121f, 0.25802356f, 0.15673056f, 
    0.01263534f, -0.00252893f, 0.08804548f, -0.04938623f, -0.00795603f, -0.13964415f, 0.04056761f, 0.13851166f, 
    -0.32909074f, 0.06865666f, 0.08928037f, 0.04205157f, -0.16667680f, -0.23973431f, 0.03529134f, 0.07605102f, 
    -0.18832600f, 0.00245345f, 0.05537336f, 0.04577409f, -0.32505482f, -0.05343300f, 0.15891963f, 0.00131864f, 
    -0.23174036f, 0.07029283f, -0.07251476f, 0.02111909f, -0.06914236f, -0.06745679f, -0.02302995f, -0.08139005f, 
    -0.15348077f, 0.01935530f, 0.07283799f, 0.02472726f, -0.06032331f, 0.15660413f, 0.03601765f, 0.17491667f, 
    0.03169779f, 0.03576021f, 0.15419926f, 0.09279957f, 0.00105212f, -0.28432342f, 0.06454264f, 0.02432955f, 
    -0.13542238f, 0.01649079f, 0.15322214f, -0.12000206f, 0.01979939f, 0.12481058f, -0.06179391f, 0.12702307f, 
    0.17688636f, 0.17552799f, -0.02967069f, 0.31488317f, -0.06426778f, -0.07812024f, 0.15997408f, -0.02244775f, 
    -0.14543353f, 0.15724003f, 0.17197341f, 0.16205406f, 0.07133387f, -0.00530322f, 0.01951242f, -0.11818317f, 
    -0.12948219f, -0.12172681f, 0.07049635f, 0.00067886f, -0.10688078f, -0.03938260f, -0.11079972f, 0.07678751f, 
    0.01746838f, 0.22922169f, -0.06955586f, -0.06009458f, -0.05139907f, 0.11560895f, 0.12381999f, 0.01222762f, 
    -0.01295459f, -0.18997285f, -0.37889847f, -0.26086569f, 0.02357674f, 0.24447115f, 0.20600422f, 0.04478450f, 
    0.03988170f, 0.01948638f, 0.03113996f, 0.01500170f, -0.05168844f, 0.11671567f, -0.04486047f, 0.03243745f, 
    -0.29036856f, 0.07982890f, -0.29649433f, 0.06284028f, 0.00840780f, 0.00392896f, 0.11724925f, -0.13705809f, 
    -0.11400941f, 0.03426045f, -0.17812507f, 0.04332387f, 0.04552012f, 0.08754558f, -0.21191774f, 0.26590073f, 
    0.00256055f, -0.08788878f, -0.01136517f, 0.09696856f, 0.00576421f, 0.11051668f, 0.00915910f, 0.15422122f, 
    -0.24212885f, -0.14172056f, -0.42526403f, 0.07376958f, 0.05816227f, 0.13192722f, 0.06565153f, -0.10164171f, 
    -0.04042485f, -0.00602593f, -0.14896533f, -0.26309395f, -0.09941516f, -0.04469352f, -0.07753570f, 0.10624521f, 
    -0.01226311f, 0.16074502f, 0.01351166f, -0.01734605f, -0.19858402f, -0.09772891f, -0.17942238f, -0.06096188f, 
    0.15779082f, -0.23093002f, 0.03258220f, -0.36666861f, 0.04213055f, -0.22638083f, 0.01405939f, 0.08455524f, 
    -0.03042502f, 0.03926894f, -0.02588204f, 0.07411985f, -0.16910581f, -0.01048547f, 0.05889557f, 0.04992061f, 
    -0.15608220f, -0.01511092f, -0.16093355f, -0.07513596f, 0.02720314f, -0.02480522f, 0.02818878f, 0.03783992f, 
    0.13575284f, -0.14045772f, 0.35685098f, -0.33344352f, 0.06707823f, 0.12823451f, 0.06106827f, 0.05699091f, 
    0.10167906f, -0.03385580f, 0.15102166f, -0.00580369f, 0.04680069f, -0.25666675f, 0.04487398f, -0.22471364f, 
    -0.20693949f, -0.13500679f, 0.07714222f, 0.01335210f, 0.04136465f, 0.02376883f, -0.03002723f, -0.05751008f, 
    0.20655227f, -0.08266579f, 0.34533104f, -0.17282131f, -0.24171448f, 0.04418845f, -0.01809163f, 0.05658016f, 
    0.03308522f, -0.02475039f, -0.07171280f, -0.15645833f, 0.28590482f, -0.09512693f, 0.18706484f, -0.22962886f, 
    0.02282888f, -0.04894134f, -0.00436735f, 0.03418207f, 0.00769377f, -0.13437176f, 0.03427937f, -0.07989636f, 
    -0.04970929f, -0.12071268f, 0.12634628f, -0.13798298f, 0.15354724f, 0.07117044f, 0.08720545f, -0.01805969f, 
    -0.04769206f, 0.05644632f, 0.04567921f, -0.18575756f, 0.13088666f, 0.12508151f, 0.26503393f, -0.32925883f, 
    -0.04491587f, 0.09326600f, -0.23426098f, 0.15356094f, -0.13666122f, -0.06594765f, -0.23235382f, -0.12634462f, 
    0.14527363f, 0.18942727f, 0.21014781f, -0.01928198f, 0.01442793f, 0.02159986f, 0.04195929f, -0.00710925f, 
    0.02972780f, -0.07409771f, 0.09903861f, 0.12001522f, -0.17202599f, -0.08411871f, 0.05185002f, 0.11081420f, 
    0.14702792f, -0.03338302f, -0.06268814f, -0.15029694f, -0.13068320f, -0.15601058f, -0.13192600f, -0.12525879f, 
    -0.19934827f, -0.54797667f, -0.21826935f, 0.21631855f, 0.07286300f, -0.01699349f, -0.00195724f, -0.16716191f, 
    -0.01045699f, 0.05149710f, 0.02841878f, 0.02043618f, -0.10484958f, -0.09665886f, -0.14504324f, 0.10244631f, 
    0.00297696f, 0.01559705f, 0.04698230f, -0.00956411f, -0.08311983f, -0.03924002f, -0.04020316f, -0.03161815f, 
    -0.44619581f, -0.25867295f, -0.09392768f, 0.12119464f, -0.21062480f, -0.15136470f, -0.01543675f, -0.37831140f, 
    -0.00847547f, 0.02720531f, -0.09049968f, -0.11316967f, 0.10459400f, -0.17184424f, 0.36679876f, 0.14984289f, 
    -0.06669567f, -0.00935511f, 0.02047298f, -0.02041974f, -0.20502457f, -0.03577805f, 0.02455799f, -0.15312713f, 
    -0.31506479f, -0.13246371f, -0.19049217f, 0.02739603f, -0.15671730f, -0.05697849f, -0.20759986f, -0.04422878f, 
    -0.13081913f, -0.09447302f, 0.08630578f, -0.06749658f, -0.05490493f, -0.15734920f, -0.01693353f, -0.25450715f, 
    -0.01059491f, -0.02790528f, -0.05198043f, -0.06824803f, 0.00836297f, -0.00542531f, 0.16525368f, -0.08655137f, 
    -0.03260748f, 0.06854228f, -0.05855789f, 0.07662152f, -0.02259868f, 0.01505163f, -0.01962755f, 0.13952567f, 
    -0.05560078f, -0.14365229f, -0.00473226f, 0.03439210f, -0.06122888f, -0.35663262f, 0.43762052f, -0.24799767f, 
    -0.04792143f, 0.02815377f, 0.12041439f, 0.03092149f, -0.01496146f, 0.11127209f, 0.00343400f, -0.03926310f, 
    -0.18113667f, 0.39236903f, -0.39235345f, 0.16151306f, 0.01084508f, -0.09467373f, 0.15460730f, 0.05194226f, 
    -0.02847754f, 0.00786739f, -0.01617148f, -0.06954677f, -0.10377132f, 0.22800696f, -0.04778991f, -0.09646519f, 
    -0.10496648f, -0.19934416f, 0.12118910f, -0.01771153f, 0.05366888f, 0.02554629f, -0.01038830f, 0.02307594f, 
    0.09096795f, -0.01559579f, 0.27689406f, 0.20733140f, 0.14633107f, -0.24570718f, 0.24383020f, 0.02700499f, 
    -0.05117527f, -0.02580537f, 0.08845504f, -0.12672266f, -0.56990361f, 0.09519520f, -0.31066591f, 0.19460112f, 
    0.08757217f, 0.01822996f, 0.12077489f, -0.14839245f, -0.11265749f, -0.04130065f, 0.14191592f, 0.04284029f, 
    -0.44253400f, 0.02081746f, -0.14283569f, -0.12587476f, -0.02280981f, 0.08636645f, -0.04652488f, 0.11933641f, 
    -0.30005205f, 0.02329541f, 0.15497550f, 0.04087550f, -0.35479295f, 0.04170078f, -0.15685424f, -0.06618401f, 
    0.14662689f, -0.21262522f, 0.04726992f, -0.08679842f, 0.01113790f, -0.05934940f, -0.17844485f, -0.04387413f, 
    -0.23711137f, -0.50770473f, -0.22080383f, 0.13573076f, 0.08511337f, -0.05930228f, -0.00297194f, 0.00281800f, 
    0.08506776f, 0.11429227f, 0.09419450f, -0.07529321f, -0.10429917f, -0.19728817f, 0.04035318f, 0.12280203f, 
    -0.03908735f, -0.20095989f, -0.13809139f, 0.01984496f, -0.06114220f, -0.07889664f, -0.03926729f, -0.05134853f, 
    0.59862506f, 0.22552867f, 0.25481406f, -0.26380709f, -0.18032803f, -0.11314951f, -0.27160004f, 0.08247671f, 
    0.02735531f, 0.01218985f, 0.00773124f, -0.03490170f, -0.43454185f, -0.43880841f, -0.05536433f, 0.01203258f, 
    0.08931075f, -0.01206438f, -0.04619069f, -0.00499982f, 0.02025132f, -0.00656544f, -0.01750599f, 0.12313285f, 
    -0.29171231f, 0.00912638f, -0.03560162f, 0.15221335f, -0.16942157f, 0.03297091f, -0.00733090f, 0.06314088f, 
    -0.09497574f, 0.14520116f, 0.09392598f, -0.08731424f, 0.08984468f, -0.08901677f, -0.08633936f, 0.09295204f, 
    -0.04652938f, -0.11141115f, 0.18847622f, -0.04892175f, -0.02295543f, 0.05341173f, 0.07867297f, -0.02317130f, 
    -0.13461950f, 0.04972903f, -0.01777326f, 0.16180447f, 0.16175029f, 0.01260285f, 0.20472583f, 0.05371670f, 
    0.02637693f, 0.02132170f, 0.15122305f, 0.06022802f, 0.04452816f, 0.03433565f, -0.04674540f, 0.00207722f, 
    -0.07591800f, 0.01235858f, 0.02168724f, 0.03058531f, 0.04319141f, 0.08814066f, -0.04306412f, 0.03629381f, 
    0.26651019f, -0.08318537f, 0.36877775f, -0.00620072f, 0.05397817f, 0.08626245f, -0.11865778f, -0.10325054f, 
    -0.04912706f, 0.09540410f, -0.08137801f, 0.11444870f, 0.24928772f, 0.17026415f, 0.00062500f, -0.13981707f, 
    0.02085623f, -0.00811338f, -0.01744219f, 0.03471536f, -0.08636908f, 0.06403746f, -0.02248419f, -0.10530748f, 
    -0.10696351f, 0.02002105f, -0.17203075f, 0.06684782f, -0.05571637f, 0.02252879f, 0.02197012f, 0.09849038f, 
    -0.15170272f, 0.08440810f, 0.04751246f, -0.02056579f, -0.20662388f, -0.03580315f, -0.31230956f, -0.11680052f, 
    0.09668505f, -0.01174334f, 0.02388018f, -0.04899935f, -0.17276192f, 0.01799171f, -0.26612392f, -0.17127313f, 
    -0.24048562f, -0.41566104f, 0.30363843f, 0.12579417f, -0.02578325f, 0.02185439f, 0.13730790f, 0.04201351f, 
    -0.06687775f, 0.04744745f, 0.08835163f, 0.02555166f, 0.40573737f, -0.00175302f, 0.06877794f, -0.09588590f, 
    0.04027000f, -0.02742239f, -0.08609059f, -0.11077337f, 0.06530111f, 0.09016325f, 0.06050900f, -0.05762524f, 
    0.24823441f, 0.06286839f, 0.16431037f, -0.00864444f, -0.06154810f, 0.18243758f, -0.17801857f, 0.14829138f, 
    -0.06771947f, 0.17437187f, 0.07331748f, -0.04942983f, -0.21211122f, 0.10359100f, -0.22131702f, -0.17220360f, 
    -0.23543042f, -0.14242205f, 0.01245491f, 0.09867503f, 0.02962482f, 0.04173005f, 0.05908968f, -0.01003444f, 
    0.05969596f, 0.12799309f, 0.13766484f, -0.04169318f, 0.05564700f, 0.05391615f, -0.07539546f, -0.04782928f, 
    -0.04473075f, 0.13314025f, -0.08932661f, -0.12912528f, 0.26335213f, -0.21681225f, 0.05054632f, 0.26770124f, 
    -0.00765750f, 0.18931177f, -0.36564732f, 0.14636734f, -0.02150859f, 0.04220290f, -0.09359629f, 0.01782171f, 
    -0.61062980f, 0.08753491f, -0.26288143f, 0.07791556f, 0.07512439f, -0.04119067f, 0.06664465f, 0.08785529f, 
    -0.19321451f, -0.07459163f, 0.03346143f, 0.07112239f, 0.06137531f, -0.26432946f, -0.04488151f, -0.29839778f, 
    0.00910302f, 0.14295770f, 0.22397831f, -0.01429015f, -0.00824288f, 0.09861476f, -0.01233414f, 0.22936548f, 
    0.10718758f, -0.05668576f, 0.11862083f, -0.16938518f, 0.07882930f, -0.15018469f, 0.09579295f, -0.02904491f, 
    -0.00204257f, 0.02260866f, -0.09228302f, -0.06621216f, 0.15722309f, -0.33334893f, 0.08486142f, -0.17419478f, 
    0.04726331f, 0.08339313f, -0.02311263f, 0.13722411f, -0.08146972f, 0.02503609f, 0.22881900f, 0.10500393f, 
    0.10401649f, 0.04131832f, 0.12474250f, -0.31026986f, -0.09856351f, -0.00519810f, 0.08233897f, -0.10142736f, 
    -0.00643235f, -0.01389796f, 0.03534834f, -0.15917486f, -0.03545805f, 0.05748438f, -0.06677737f, -0.15894538f, 
    0.02628203f, 0.15522060f, -0.01306456f, 0.07799456f, -0.02177394f, 0.02825509f, 0.01261225f, -0.00282392f, 
    0.10588034f, -0.07434974f, 0.23525338f, 0.05099316f, 0.08392661f, -0.01431475f, 0.02693795f, -0.01065255f, 
    0.11614211f, 0.10358465f, 0.08147730f, 0.13265540f, -0.05087345f, -0.01856196f, 0.01712519f, -0.15712778f, 
    -0.01033886f, 0.09144551f, 0.00622654f, -0.08917718f, 0.08407541f, 0.11309353f, 0.18131803f, 0.04589164f, 
    0.43207517f, 0.24609798f, 0.18866818f, -0.16976635f, 0.04982368f, -0.00382561f, -0.13245577f, 0.10818947f, 
    -0.08594966f, -0.10542803f, -0.00370401f, -0.03199277f, -0.14233686f, 0.11430322f, 0.20891438f, 0.07748105f, 
    0.04545952f, 0.14435092f, -0.03037723f, -0.00404983f, -0.05585552f, -0.00127860f, 0.12838854f, -0.13398603f, 
    0.39494285f, 0.04663046f, 0.26856518f, 0.01203283f, -0.02357254f, 0.23178044f, -0.01083730f, 0.18137038f, 
    -0.13479716f, -0.02545778f, 0.18100855f, -0.09195159f, -0.03282117f, 0.09928214f, -0.01685614f, 0.09294321f, 
    0.10573511f, 0.11872748f, 0.07615933f, 0.10878562f, -0.01202145f, 0.02372815f, 0.08082587f, 0.09639925f, 
    0.30026484f, 0.05559576f, 0.18619518f, -0.22031949f, -0.13753791f, 0.07557567f, -0.30505869f, 0.05229638f, 
    -0.12676816f, -0.06611219f, -0.07553039f, -0.09853908f, 0.38406199f, 0.01949600f, 0.18753712f, -0.12329025f, 
    0.14722995f, 0.03252474f, -0.10880379f, 0.26297802f, -0.03242869f, 0.00017206f, 0.03366181f, -0.04641251f, 
    -0.20748527f, -0.47029662f, 0.44733387f, 0.13449986f, -0.01883626f, 0.07099640f, -0.16488750f, 0.02797307f, 
    0.04208418f, -0.08837210f, -0.05773549f, -0.25742677f, 0.19970936f, -0.07041196f, 0.20365085f, -0.22615553f, 
    -0.01934224f, 0.06009709f, -0.08159736f, 0.02554154f, -0.19269459f, -0.00340265f, 0.14666580f, -0.05036416f, 
    -0.01296102f, 0.02792434f, -0.09754626f, -0.10821546f, 0.10316686f, 0.01014805f, -0.09661203f, 0.04072019f, 
    0.15401228f, 0.05711460f, 0.07600807f, 0.13671872f, -0.17879842f, 0.12103198f, -0.04560506f, 0.34142011f, 
    0.00888161f, 0.03951692f, -0.06070648f, 0.07266840f, -0.15345994f, 0.01976727f, 0.05827224f, 0.08198731f, 
    -0.24044332f, 0.05164240f, 0.30974317f, 0.51212561f, 0.22243522f, -0.21724688f, 0.09503103f, -0.21323486f, 
    -0.09663398f, 0.00736701f, 0.03861983f, 0.03191814f, -0.27712804f, 0.09866673f, 0.14218789f, 0.32696822f, 
    -0.04632084f, 0.08543044f, -0.06647645f, -0.16037710f, 0.03275323f, -0.13351791f, 0.05083746f, -0.02242789f, 
    -0.35046789f, 0.00381026f, -0.47117710f, 0.12178171f, 0.11165172f, 0.08607829f, 0.01904799f, -0.04853881f, 
    -0.03713240f, 0.00772724f, 0.19409499f, 0.14774485f, -0.24320942f, -0.15842690f, -0.14045763f, 0.12706760f, 
    -0.12755765f, -0.07388839f, 0.09864948f, 0.01523352f, -0.07885357f, 0.06870107f, -0.05455524f, 0.09783319f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11299092f, 0.07213929f, 0.06137402f, -0.07586702f, -0.07732075f, 0.09299330f, 0.05675619f, -0.12604548f, 
    0.09023588f, 0.02696951f, 0.02538145f, -0.00839414f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
